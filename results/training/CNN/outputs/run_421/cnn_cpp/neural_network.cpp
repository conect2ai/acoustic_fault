#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.51788193f, 0.31689242f, 0.56589347f, 0.70422292f, -0.52599657f, -0.02984961f, 0.14601694f, 0.12569700f, 
    -0.30179775f, -0.46129236f, -0.20790522f, 0.06642564f, -0.23181669f, 0.59133047f, 0.45742977f, -0.21431726f, 
    -0.12498764f, -0.13432509f, 0.23593268f, 0.15399589f, 0.05858584f, -0.21663718f, -0.16157664f, 0.10077264f, 
    -0.14805479f, 0.07422508f, -0.03773417f, 0.51855099f, 0.72609901f, 0.62252152f, 0.34745675f, 0.04988601f, 
    0.10540178f, -0.38434219f, 0.21645650f, 0.36180457f, 0.18578166f, 0.03687100f, 0.07059297f, -0.03984861f, 
    -0.22962397f, -0.03051871f, 0.37976182f, 0.17932174f, -0.27759317f, 0.11566953f, 0.06183551f, -0.21110475f, 
    -0.09269169f, -0.31886315f, 0.11862576f, -0.61934006f, 0.12723471f, 0.29580703f, 0.16141215f, -0.58284402f, 
    -0.55282652f, 0.18474962f, -0.19571258f, -0.68558598f, -0.01384409f, 0.10339358f, -0.29397613f, -0.13142854f, 
    0.12800254f, -0.18538296f, 0.00547400f, -0.30532864f, -0.16094284f, 0.21738781f, 0.16487598f, 0.34627846f, 
    0.20289961f, 0.11305778f, 0.06845196f, -0.18794380f, -0.44636685f, -0.47120541f, -0.43224764f, -0.55777806f, 
    0.04315181f, 0.62149149f, 0.30803865f, -0.12115904f, 0.45094299f, -0.08520580f, -0.04885038f, -0.29523677f, 
    -0.28627500f, -0.15484361f, -0.07019044f, 0.04271256f, 0.25115830f, 0.15936938f, -0.04893880f, -0.28625739f, 
    0.13095714f, -0.02193237f, -0.20307495f, -0.05242963f, 0.72592491f, 0.37516150f, -0.41160914f, -0.39970174f, 
    -0.42676359f, 0.14370464f, 0.63546985f, -0.10942479f, 0.26427492f, 0.24681129f, 0.20843661f, -0.15818475f, 
    -0.29938552f, -0.41566762f, -0.33728641f, -0.06046844f, 0.16647539f, -0.07762004f, -0.07470788f, -0.00450237f, 
    -0.07022750f, -0.02392788f, -0.21529755f, -0.09353497f, -0.14056845f, -0.61556238f, -0.55965334f, -0.76682788f, 
    -0.13155934f, 0.09701210f, -0.19157006f, 0.56029779f, 0.21706958f, 0.30308017f, 0.38301811f, 0.08033524f, 
    -0.01711367f, 0.12572236f, -0.05896902f, -0.21915874f, -0.15700585f, 0.30017880f, 0.36262143f, 0.07180119f, 
    -0.18140602f, 0.26854646f, 0.30592674f, -0.39759052f, -0.13294294f, -0.05698866f, -0.50636774f, 0.47887340f, 
    -0.53244692f, 0.51647460f, -0.16952229f, -0.13548972f, -0.07752919f, -0.52744353f, 0.33436567f, -0.43540248f, 
    0.42291227f, -0.16886459f, -0.15245102f, 0.22692716f, -0.25664362f, -0.39629489f, 0.17076923f, 0.02615610f, 
    0.23231374f, -0.03827044f, 0.25986949f, -0.20584144f, -0.03429054f, -0.08460010f, -0.03353972f, 0.09668046f, 
    -0.35461566f, -0.07864373f, 0.86427230f, 0.60037297f, 0.82523644f, 0.68503731f, 0.07277054f, 0.41407576f, 
    -0.26506481f, -0.10091038f, 0.37647054f, -0.17667420f, -0.03843170f, 0.18509428f, -0.09775046f, 0.09868776f, 
    -0.08163594f, -0.07314759f, 0.01193322f, 0.20958799f, 0.11358783f, -0.23456873f, -0.02339449f, 0.01434308f, 
    0.34976739f, -0.48761246f, -0.43144944f, 0.24018997f, -0.16412912f, 0.11830155f, -0.14488986f, 0.24776186f, 
    0.51690149f, -0.04687800f, -0.52089208f, -0.07855877f, -0.17016256f, 0.18936972f, -0.42898908f, -0.33052269f, 
    -0.36781064f, -0.21753605f, -0.06484654f, -0.36583808f, 0.05448460f, 0.17928885f, -0.26589730f, -0.36254165f, 
    0.32175398f, -0.89160842f, 0.63317883f, -0.68921930f, 0.29156199f, 0.61109555f, -0.50203782f, 0.49723819f, 
    0.68554032f, 0.17187400f, -0.17427520f, -0.36505586f, -0.28307271f, -0.14767109f, -0.08223221f, 0.40695271f, 
    -0.16690707f, -0.11406006f, 0.19231240f, 0.16311978f, -0.02504678f, 0.29945612f, 0.02514872f, -0.07656042f, 
    0.04968938f, 0.12236282f, -0.76662034f, -0.32202423f, -0.34694424f, -0.01356181f, -0.36677477f, 0.58078039f, 
    0.62329775f, -0.12674378f, 0.48629373f, 0.11651276f, -0.01427217f, 0.09223492f, 0.08380685f, 0.07933846f, 
    0.13840860f, -0.13185765f, 0.06420490f, -0.06049247f, -0.10153971f, -0.18531303f, 0.11606425f, 0.00260671f, 
    0.06046036f, 0.17986284f, 0.10799411f, -0.32632548f, 0.57554352f, 0.61026442f, 0.17508104f, 0.26159123f, 
    -1.00992286f, 0.37915739f, -0.10575455f, -0.59609759f, -0.44998199f, -0.01197366f, 0.07123761f, 0.25210187f, 
    0.33210325f, 0.06305087f, -0.04772028f, 0.24786343f, 0.17658147f, -0.15341015f, -0.03326371f, 0.13518852f, 
    0.03047592f, 0.02655126f, 0.21089625f, -0.15544283f, 0.56975228f, 0.11989459f, 0.46969160f, 0.10837784f, 
    -0.65869194f, 0.23223589f, -0.27834219f, 0.45704132f, -0.12524101f, -0.06941067f, 0.03753733f, 0.24984093f, 
    0.12102213f, -0.20029767f, -0.36327782f, -0.17865928f, 0.27541217f, -0.18599133f, -0.20664099f, 0.07314032f, 
    -0.04202946f, -0.02520181f, 0.09242430f, 0.05386337f, 0.04546397f, 0.10441247f, -0.84583575f, -0.71238202f, 
    -0.41951221f, 0.21031345f, 0.10708565f, 0.35430220f, 0.11104717f, 0.40886578f, 0.45316443f, -0.27848002f, 
    0.12773493f, -0.19230601f, 0.02072393f, 0.19568090f, -0.03808694f, 0.11700485f, 0.21493104f, -0.01820760f, 
    -0.06378379f, -0.04436257f, -0.24213430f, 0.16236523f, -0.07893576f, -0.08259537f, 0.99706662f, 0.17569309f, 
    -0.79758787f, -0.32489309f, 0.07258598f, -0.32943362f, -0.06722157f, 0.28181559f, 0.38580009f, -0.40340766f, 
    -0.43771741f, -0.16576132f, 0.20115657f, 0.09683862f, 0.18410987f, -0.17042977f, -0.21688613f, -0.27583858f, 
    -0.10322935f, 0.21051235f, 0.06490857f, 0.25812608f, -0.23197812f, 0.09181048f, -0.35041502f, 0.94613892f, 
    0.55065542f, 0.18446274f, -0.50130528f, -0.53503782f, 0.08627354f, 0.36587459f, -0.72732228f, -0.03926255f, 
    0.19450182f, 0.34649310f, 0.06455170f, -0.14548647f, -0.21306588f, 0.00205993f, -0.10855459f, 0.07781436f, 
    0.07254465f, 0.26906633f, -0.21593173f, -0.07809942f, 0.11503515f, 0.34538934f, -0.09226101f, -0.02316567f, 
    0.30871135f, -1.03145885f, -0.32304391f, 0.44169921f, 0.25451526f, -0.83422834f, 0.08870417f, 0.64979249f, 
    -0.40870932f, 0.01263702f, -0.13777263f, 0.32697591f, 0.02147710f, 0.10358360f, -0.21194342f, -0.28677762f, 
    0.09679262f, 0.25119096f, 0.18133555f, -0.20747814f, 0.07993483f, -0.23553525f, -0.05092566f, -0.08011672f, 
    0.10068665f, -0.58756113f, 0.94984132f, 0.29542616f, -0.65600824f, 0.57412779f, -0.85655868f, 0.17536679f, 
    0.64257056f, -0.17972048f, -0.28017527f, -0.05600929f, -0.27861524f, -0.20790595f, -0.14453369f, 0.08473495f, 
    0.27611905f, -0.07244982f, 0.01707714f, -0.00504494f, 0.06386904f, -0.24979891f, -0.12605843f, -0.08289775f, 
    -0.19787794f, 0.10389306f, 0.61122197f, 0.56339514f, 0.68039399f, 0.30873230f, 0.29181424f, -0.29976413f, 
    -0.50718820f, -0.35186112f, 0.13259129f, -0.19638774f, 0.35898918f, 0.23016503f, 0.01318803f, -0.16111529f, 
    0.18188775f, 0.09466173f, -0.10904229f, 0.20442560f, -0.26197323f, 0.38746309f, 0.16395047f, -0.07396705f, 
    0.11072583f, -0.07312844f, -0.10763042f, 0.11443088f, 0.26082361f, 0.53446770f, 0.25561529f, 0.54113406f, 
    -0.29889444f, 0.41799429f, -0.19800088f, -0.26078659f, 0.16776516f, 0.33476329f, -0.01176953f, -0.22473121f, 
    0.04459013f, 0.18986577f, 0.29463607f, 0.22319260f, 0.17166199f, 0.32550082f, 0.49983701f, -0.35268307f, 
    0.12895848f, 0.45304778f, -0.12671904f, 0.28194612f, 0.07040310f, 0.51683670f, 0.21916884f, 0.23009311f, 
    -0.36994651f, -0.63935065f, -0.52937937f, -0.38161287f, 0.06490934f, 0.32819596f, 0.38735339f, 0.14946303f, 
    -0.21974695f, 0.06277031f, 0.26277709f, 0.02958264f, -0.34932280f, -0.05707229f, -0.08402511f, 0.00904323f, 
    -0.14675856f, 0.39094207f, -0.13777237f, 0.13545881f, -0.07841624f, 0.11955287f, -0.37589785f, -0.64035976f, 
    -0.41189522f, 0.00472648f, -0.06234117f, -0.69629550f, -0.34175944f, -0.12703826f, 0.20248611f, -0.07479035f, 
    -0.17340945f, 0.29483256f, 0.43068969f, -0.09599020f, 0.03712374f, 0.25353646f, -0.13424222f, 0.35263488f, 
    0.53919059f, 0.17452337f, 0.05876063f, 0.27429673f, 0.06493686f, -0.00009450f, -0.25666714f, 0.02773638f, 
    0.60574079f, 0.67089570f, 0.50442404f, 0.31427467f, 0.21868563f, 0.18134841f, -0.25421870f, 0.49898583f, 
    -0.51320344f, -0.26204294f, 0.37273690f, -0.15270337f, -0.01088658f, -0.38211739f, -0.09602494f, 0.22590624f, 
    0.09780772f, -0.02272439f, -0.10457695f, -0.20149031f, -0.29547009f, -0.01914313f, -0.10143272f, 0.28666654f, 
    0.49165341f, 0.46077392f, 0.63365728f, 0.58759779f, 0.43811274f, -0.03184633f, -0.05623467f, -0.01584104f, 
    0.12748869f, -0.48921046f, 0.03332472f, 0.02720446f, 0.28625226f, -0.06763553f, 0.02889864f, 0.22864285f, 
    0.27374732f, 0.05255901f, -0.03529958f, 0.06103214f, 0.00593267f, 0.12268856f, -0.44861013f, -0.04544794f, 
    0.82403409f, 0.39056781f, -0.92633224f, -0.30266500f, -0.04618087f, 0.32699916f, -0.29898342f, -0.22538675f, 
    -0.05303222f, 0.29374382f, -0.04056636f, 0.12671776f, 0.23559745f, 0.36352977f, 0.04979995f, 0.16997907f, 
    -0.11722764f, -0.39330655f, -0.01578879f, 0.18095814f, -0.00756503f, -0.07634765f, 0.07345446f, -0.23613635f, 
    0.26281711f, 0.01056586f, -0.47860420f, 0.40422451f, 0.57942128f, 0.32032207f, 0.22171277f, 0.51695943f, 
    0.31640312f, 0.38782474f, 0.48675811f, 0.10696939f, -0.11706666f, -0.07316624f, -0.12045280f, -0.43399745f, 
    -0.17624228f, 0.01361446f, -0.34392294f, 0.28190929f, -0.00351173f, 0.00371118f, -0.02016373f, 0.15488534f, 
    -0.07198292f, 0.07520863f, -0.70252043f, 0.68225199f, -0.48611325f, -0.26780817f, -0.37437654f, 0.38860172f, 
    -0.28144079f, -0.31722599f, -0.02513218f, 0.09550560f, -0.11847641f, 0.00223372f, -0.12003563f, 0.27549163f, 
    0.16206014f, 0.29842380f, 0.35512179f, 0.20026805f, 0.29139715f, 0.05894520f, -0.01768236f, -0.29283333f, 
    -0.20085578f, -0.01457068f, 0.30000371f, 0.00910264f, -0.55764550f, -0.32643428f, -0.60321182f, -0.47416028f, 
    0.05570490f, -0.32050112f, 0.12168060f, -0.13917664f, 0.07200307f, 0.34454182f, 0.22434771f, -0.32395336f, 
    0.03277016f, 0.24179457f, 0.25549057f, 0.31961131f, 0.01486110f, -0.18957071f, -0.05792633f, -0.18611431f, 
    -0.10820246f, 0.38222066f, 0.45373753f, 0.54406852f, -0.45412704f, -0.35254166f, -0.21503668f, -0.05958307f, 
    0.03137211f, 0.39159098f, -0.49391389f, 0.28380027f, 0.04467258f, -0.30165035f, 0.25249827f, 0.01801184f, 
    0.27173370f, 0.45205969f, -0.13475510f, -0.39260375f, 0.04772089f, -0.00111361f, -0.56067640f, 0.16801833f, 
    0.25905013f, 0.06366657f, 0.27721322f, 0.20634750f, -0.21073252f, -0.46050820f, -1.00603700f, -0.51253420f, 
    0.39225760f, -0.07992346f, 0.41785896f, 0.16620527f, 0.32813984f, 0.05759587f, -0.34598014f, -0.23829260f, 
    0.05440639f, -0.11457883f, 0.32781124f, 0.15034528f, -0.09009474f, 0.00589565f, -0.12776758f, 0.01401811f, 
    0.09016691f, -0.00114290f, 0.28679541f, -0.00514624f, 0.26362282f, -0.16655014f, 0.62499636f, 0.57903743f, 
    0.63488215f, 0.31452528f, -0.24176784f, -0.58213735f, -0.09187885f, -0.57790858f, 0.15883796f, -0.27094957f, 
    0.16235200f, -0.00757637f, -0.02478474f, -0.01926757f, -0.36791882f, -0.24066940f, -0.33547792f, -0.31686530f, 
    0.02500749f, -0.29411528f, 0.14597356f, 0.25790837f, -0.19311301f, -0.15095149f, -0.03275284f, -0.34714743f, 
    -0.82174987f, -0.10582346f, 0.37394583f, -0.16798918f, -0.83138585f, 0.11869012f, 0.08878455f, -0.46647504f, 
    0.03808231f, 0.32002473f, 0.29477960f, -0.21464042f, -0.08821651f, -0.00473452f, -0.19201168f, 0.03956480f, 
    -0.03260198f, -0.04019956f, -0.14902073f, -0.08356037f, -0.24498118f, -0.21413794f, 0.22387901f, -0.10379927f, 
    0.25091517f, 0.17240390f, -0.51121092f, -0.76665187f, -0.41399819f, 0.22670737f, 0.47657946f, 0.15116133f, 
    0.38106921f, 0.36304244f, -0.33757949f, 0.06418993f, -0.04075733f, -0.13560599f, -0.18087973f, 0.30346167f, 
    -0.18254931f, 0.07546084f, 0.40032718f, 0.11732854f, 0.05988088f, -0.28754273f, -0.33284110f, -0.22714601f, 
    0.34843183f, 0.82554239f, 0.46985927f, 0.47628590f, 0.58910114f, 0.70017368f, 0.26701427f, 0.02159522f, 
    -0.17468385f, -0.17181209f, -0.45874619f, 0.20939606f, 0.27684641f, 0.17502388f, 0.07099630f, -0.27010831f, 
    0.08642435f, -0.09119315f, -0.17507191f, -0.11563205f, -0.02064363f, -0.19708651f, 0.08451701f, 0.27671409f, 
    -0.07813014f, 0.19415697f, -0.57136428f, 0.07076456f, -0.02394599f, -0.33504128f, 0.20078537f, -0.66648978f, 
    -0.13965508f, -0.45183003f, -0.53335333f, -0.02677625f, 0.26678076f, -0.17770919f, 0.33732757f, 0.37854898f, 
    -0.12863074f, 0.19767742f, -0.19530331f, -0.14429837f, 0.21429624f, 0.16619167f, -0.15066619f, 0.28043297f, 
    0.05951779f, 0.12185846f, 0.42514628f, 0.66304940f, 0.07742082f, 0.32605994f, 0.29334030f, 0.44125104f, 
    -0.26817253f, -0.68623787f, -0.59658700f, 0.07324945f, 0.06863708f, 0.11847105f, -0.15734710f, 0.05181306f, 
    0.36386025f, -0.19286218f, 0.22206213f, 0.35427606f, 0.35133144f, -0.11999396f, 0.11231890f, -0.12331571f, 
    -0.01692294f, 0.12963362f, 0.21917343f, -0.06232554f, -0.59081018f, 0.87680322f, 0.45182851f, 0.38035798f, 
    -0.22950189f, -0.11547081f, 0.19729117f, -0.57262355f, 0.13025188f, -0.31725585f, -0.31384161f, -0.27771914f, 
    0.00342303f, -0.27234903f, -0.25160760f, -0.01480256f, 0.18963487f, 0.13182527f, -0.14160171f, -0.17582779f, 
    0.00491096f, -0.23934446f, -0.52945203f, -0.16252057f, 0.02987939f, -0.96317500f, -0.31381938f, -0.28370690f, 
    -0.25331056f, -0.48354039f, 0.20984358f, 0.72941792f, 0.30267376f, 0.34580725f, 0.24633858f, -0.08196359f, 
    -0.27132565f, 0.18003140f, 0.05841110f, 0.23168866f, 0.07510786f, -0.19120120f, -0.11105821f, -0.27517340f, 
    -0.14938341f, 0.03111156f, 0.06006731f, 0.15972489f, -0.05766371f, 0.05386394f, -0.33600715f, -0.41743922f, 
    -0.66182238f, -0.48816371f, -0.01243982f, -0.32572371f, -0.39015016f, 0.08316052f, 0.35881469f, -0.31782600f, 
    -0.13636146f, 0.20192465f, -0.04836457f, 0.18434362f, -0.18644370f, -0.06100488f, 0.27646866f, -0.25949818f, 
    -0.02088372f, -0.09623511f, -0.14476371f, -0.08422311f, 0.47059426f, -0.22521314f, -0.02006610f, 0.47890568f, 
    0.36589670f, 0.27485755f, 0.28347871f, 0.23191775f, -0.17229906f, 0.36881393f, -0.14626679f, 0.24727602f, 
    0.42421141f, -0.37748963f, -0.26051784f, -0.05790886f, -0.13453799f, -0.51718253f, 0.41134724f, 0.07014682f, 
    -0.28066304f, -0.49420315f, -0.02403923f, -0.30628240f, -0.34754074f, 0.06537055f, 0.25589457f, -0.23124826f, 
    -0.33005676f, 0.09474299f, 0.47174630f, 0.44637114f, 0.50426930f, 0.44142702f, 0.09931687f, 0.27038711f, 
    0.09093552f, 0.37056667f, 0.11479063f, -0.43101987f, 0.50052589f, -0.31796315f, -0.00128346f, -0.15161017f, 
    -0.41772348f, -0.31059578f, -0.05041014f, -0.04186765f, 0.29814282f, 0.16174923f, 0.10713068f, 0.10136641f, 
    0.15643109f, 0.73241401f, -0.15232597f, -0.38142237f, 0.09318125f, 0.54021442f, 0.56301570f, 0.37439835f, 
    0.04005009f, 0.39466387f, 0.42492402f, -0.45798156f, -0.03331512f, -0.20606558f, -0.13948619f, 0.09246380f, 
    0.04658514f, -0.03508704f, 0.04451945f, -0.10721287f, 0.03545738f, 0.21782081f, -0.14257458f, 0.16954008f, 
    0.11999576f, -0.08601362f, -0.74740416f, 0.16939633f, 0.71439803f, -0.79052120f, -0.60787368f, 0.96577322f, 
    -0.17779744f, -0.19744189f, 0.19040248f, -0.02198664f, 0.21614742f, -0.13999863f, 0.15360402f, -0.07416713f, 
    -0.11364390f, -0.32971245f, 0.25935367f, -0.19630457f, -0.07675125f, -0.28612831f, 0.16185839f, 0.24686836f, 
    0.07840500f, 0.13722426f, 0.07167454f, 0.33497670f, 0.43421265f, 0.17629448f, 0.34284446f, 0.39749148f, 
    -0.50293934f, 0.39835244f, -0.26901123f, 0.11301722f, 0.16975681f, 0.16392523f, 0.20077431f, 0.09658089f, 
    -0.18913524f, 0.08797663f, 0.17631176f, -0.11239754f, 0.14448391f, 0.00527566f, -0.44623318f, -0.15216115f, 
    -0.17643099f, 0.17400186f, 0.28046066f, 0.40823698f, 0.55653274f, 0.46683940f, 0.45644385f, 0.86762857f, 
    0.53096259f, 0.55217785f, 0.12803140f, -0.45077500f, -0.38768479f, -0.22066592f, 0.26018205f, 0.19964607f, 
    -0.40135407f, 0.03424366f, -0.29799002f, -0.27067029f, -0.29792434f, -0.07498588f, -0.04905238f, -0.18915331f, 
    0.21630235f, 0.16150624f, 0.15847932f, 0.02738330f, 0.45181081f, -0.46497726f, -0.48467228f, -0.08363385f, 
    0.09756593f, 0.17908253f, 0.08851460f, 0.37719372f, -0.17023517f, -0.18623322f, -0.31732574f, 0.40575358f, 
    -0.08139147f, -0.22137193f, -0.01205021f, -0.08528510f, 0.38540885f, 0.07943767f, -0.62107080f, 0.11570534f, 
    0.31598216f, 0.00376788f, -0.08115302f, 0.16597657f, -0.36624944f, 0.41085061f, 0.25179633f, 0.52384645f, 
    -0.02601188f, -0.06811749f, -0.00457976f, -0.37045887f, -0.10002069f, 0.32398972f, -0.40112495f, -0.29158074f, 
    0.35087678f, 0.44969380f, -0.33072677f, -0.10625146f, 0.32729134f, 0.27728853f, 0.30068481f, 0.32996100f, 
    0.27634525f, 0.08702520f, 0.08110084f, -0.18182978f, -0.27326679f, 0.20883340f, 0.25677547f, 0.34598017f, 
    0.38834637f, -0.03515634f, -0.07464246f, 0.80448532f, 0.59438068f, -0.02312323f, -0.09627894f, 0.29982674f, 
    0.24666516f, -0.39947021f, 0.17624606f, -0.30372202f, 0.25423539f, -0.25162840f, -0.24338955f, -0.28582361f, 
    -0.28689420f, 0.31194383f, -0.26039940f, -0.06447566f, -0.14742884f, -0.10410259f, -0.17155311f, -0.11412170f, 
    0.89308411f, 0.01046174f, 0.28506929f, -0.23050110f, -0.48517856f, -0.11107005f, -0.05061246f, 0.17522910f, 
    0.41871274f, 0.31870592f, 0.14002535f, 0.26410237f, -0.22664380f, 0.17858502f, 0.11274883f, 0.09666741f, 
    0.24229400f, 0.08372848f, -0.03216457f, 0.45700508f, -0.25848368f, 0.01394978f, 0.09327681f, -0.08912893f, 
    -0.14019911f, 0.03922197f, -0.28881091f, -0.04862208f, -0.70849806f, -0.05051327f, 0.25437474f, 0.07086246f, 
    0.02464481f, -0.19377163f, -0.49775758f, -0.00871223f, -0.15679368f, -0.52212882f, -0.00948904f, 0.09646203f, 
    0.23993881f, 0.18152174f, 0.19701497f, 0.07001431f, 0.00669048f, 0.25015199f, -0.34436077f, -0.43423969f, 
    -0.38921204f, -0.27752471f, 0.84927678f, 0.52989715f, -0.20985466f, 0.23248830f, -0.21496624f, -0.12754290f, 
    -0.36719063f, 0.38369885f, 0.39329249f, 0.38804957f, -0.25154346f, 0.18801497f, -0.19684762f, -0.08714312f, 
    0.12184823f, 0.17520988f, -0.33954623f, 0.09788851f, -0.22752109f, 0.24499261f, 0.45722365f, 0.00592874f, 
    0.42597723f, -0.10100998f, -0.09781696f, -0.50597340f, 0.23450214f, -0.01027339f, -0.57064980f, -0.18087928f, 
    0.44931370f, 0.59777492f, -0.28592440f, 0.47636920f, 0.01786656f, 0.31775755f, -0.11153845f, -0.42661244f, 
    -0.28064772f, -0.18713234f, 0.26681411f, -0.25944269f, 0.17949682f, 0.09659064f, 0.09428596f, -0.14132935f, 
    -0.17233068f, 0.10854533f, -0.12658343f, 0.06305450f, -0.68022370f, -0.33732322f, -0.01380959f, 0.36028573f, 
    0.42438889f, -0.46860695f, -0.25748390f, -0.43187204f, -0.55832148f, -0.11468758f, 0.36644194f, 0.18168774f, 
    0.16731334f, -0.08750498f, 0.06388045f, 0.31505218f, -0.41557753f, -0.28396595f, 0.32200712f, 0.21785471f, 
    -0.11440171f, -0.08244653f, 0.07568884f, 0.07698600f, -0.05683147f, 0.21115868f, 0.35687074f, 0.54506612f, 
    0.74978888f, 0.47991619f, 0.31407237f, -0.27601799f, -0.40032768f, 0.32234913f, 0.13891327f, 0.17767529f, 
    -0.18539755f, 0.16522220f, -0.03223411f, -0.23695017f, 0.15201564f, 0.34582236f, -0.11237666f, -0.14830551f, 
    0.16778490f, -0.20289537f, 0.06715957f, -0.19851026f, 0.10631595f, -0.11364585f, 0.37096047f, 0.49353424f, 
    0.51881915f, 0.60114640f, 0.32011557f, 0.32390019f, -0.30937424f, 0.25889382f, -0.07725739f, -0.18551092f, 
    0.18143646f, -0.37392288f, -0.33753556f, 0.03989695f, 0.24264382f, 0.31182006f, -0.25738510f, -0.15302326f, 
    0.22056396f, 0.36161953f, -0.04382944f, -0.19949569f, 0.38318238f, -0.17108624f, 0.09772568f, 0.60098970f, 
    0.22666901f, -0.14065388f, -0.72791529f, 0.22377884f, 0.55864596f, -0.47513306f, -0.17264919f, -0.23843208f, 
    0.16468535f, -0.46715292f, -0.44027233f, -0.28816521f, -0.25621140f, -0.43876505f, -0.41949457f, 0.12267948f, 
    -0.15691374f, -0.22355367f, -0.26106292f, -0.13727468f, -0.04123560f, 0.03077779f, -0.27611759f, 0.17002124f, 
    -0.26512638f, 0.43274719f, 0.66098571f, -0.02618181f, -0.21931712f, -0.56420004f, -0.25641963f, -0.43619445f, 
    -0.16460501f, -0.50247324f, -0.13667601f, 0.48246625f, 0.22305813f, -0.03810690f, 0.16359901f, -0.34014264f, 
    -0.08590471f, -0.06213406f, 0.03665436f, 0.23177722f, -0.25507873f, 0.07587137f, 0.07991658f, 0.00432165f, 
    0.03190175f, -0.62565577f, 0.30013230f, 0.07711373f, -0.38864669f, -0.06080456f, -0.11474315f, 0.67645943f, 
    -0.11370732f, -0.27151945f, -0.16221917f, -0.01561179f, -0.09711868f, -0.07644072f, -0.22543326f, -0.20776702f, 
    0.05506491f, -0.03247163f, 0.33777609f, 0.18609406f, -0.58525926f, -0.00679550f, -0.30107912f, 0.08771223f, 
    0.12162658f, 0.24974346f, -0.11034326f, 0.56033802f, -0.58082241f, 0.13516936f, -0.00341281f, -0.08924729f, 
    -0.20625836f, -0.10869664f, -0.39420855f, -0.54065412f, -0.30131149f, -0.28483993f, -0.16513610f, -0.23439036f, 
    -0.31891352f, -0.34742570f, -0.12905848f, -0.05854050f, -0.04730415f, -0.17810161f, -0.12391207f, 0.04771158f, 
    -0.00631791f, -0.21429314f, 0.26782590f, 0.33014324f, 0.56900257f, 0.17163134f, 0.11703119f, 0.40109497f, 
    -0.43522701f, -0.36150473f, -0.43259090f, -0.41136935f, -0.43619478f, -0.37718943f, -0.40879741f, -0.17692475f, 
    0.53070718f, -0.31025323f, 0.11874762f, -0.19263795f, -0.05032709f, 0.10589293f, -0.17096692f, -0.21787466f, 
    -0.06303532f, -0.23617062f, -0.06147213f, -0.29558083f, -0.08868088f, -0.73234820f, -0.76411349f, -0.25490752f, 
    -0.57451141f, -0.42917576f, 0.50509477f, 0.59186578f, 0.31035301f, 0.32069424f, 0.24753520f, 0.30126157f, 
    0.27691385f, 0.22172357f, -0.10010226f, -0.06803522f, 0.10629681f, 0.06005750f, 0.15789825f, -0.05051063f, 
    -0.12669963f, -0.28417009f, 0.29818940f, -0.05206735f, 0.16112666f, 0.09891365f, 0.50717360f, -0.14411600f, 
    -0.25895163f, 0.50391984f, 0.03379868f, -0.77892369f, -0.75719231f, -0.43199742f, -0.08189714f, 0.16676201f, 
    0.49522471f, -0.00617322f, -0.27218413f, 0.09895817f, 0.04418153f, -0.03372868f, 0.13723727f, -0.22216038f, 
    -0.02236313f, 0.25357848f, 0.02292525f, 0.09296272f, 0.00360299f, -0.08753718f, 0.65929359f, 0.30704486f, 
    -0.27731025f, -0.10229015f, 0.76493472f, -0.32933652f, -0.56142759f, 0.48883083f, -0.17502414f, 0.34351790f, 
    -0.16514365f, 0.16592894f, -0.24422695f, -0.14810497f, -0.03077693f, 0.35191780f, -0.27154508f, -0.12207790f, 
    -0.14608033f, -0.18357499f, -0.04463638f, -0.17223348f, -0.35821438f, -0.23355369f, 0.01587948f, -0.35078689f, 
    -0.50816661f, 0.19611345f, 0.24711260f, -0.29772800f, 0.10563286f, -0.53757840f, 0.03850740f, 0.00649994f, 
    -0.36626762f, -0.25456116f, -0.12716457f, -0.15744805f, -0.52434540f, -0.05149940f, -0.21110898f, 0.41110253f, 
    0.16227828f, 0.27491653f, 0.18441270f, -0.14839152f, -0.01822778f, 0.25108558f, 0.20951433f, -0.15177689f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.11052649f, 0.01457980f, -0.03483525f, -0.01283366f, 0.03882184f, 0.18956183f, 0.10948828f, 0.07930182f, 
    -0.09971806f, 0.29327920f, 0.13901091f, 0.06744704f, 0.05780800f, 0.07914014f, 0.08489515f, 0.17371102f, 
    -0.10122728f, 0.33377632f, -0.05319164f, 0.08579206f, 0.02584785f, 0.33316225f, 0.11449821f, 0.00739549f, 
    0.17620160f, -0.00829265f, 0.09167176f, 0.25975731f, 0.17307881f, 0.32403210f, 0.27831867f, 0.05277374f, 
    -0.02020961f, 0.22463571f, 0.16759568f, 0.17244932f, -0.07437832f, 0.04218674f, 0.09289251f, -0.10271277f, 
    0.11901689f, -0.05043277f, 0.08174440f, 0.24640794f, 0.09098639f, 0.11611121f, -0.04437462f, -0.04087702f, 
    0.04894385f, 0.17264278f, 0.17118149f, 0.04862366f, 0.01121769f, -0.07152276f, 0.13383129f, -0.17703429f, 
    0.22107878f, 0.08173121f, -0.02837444f, 0.10465342f, 0.06616786f, 0.26053441f, 0.16500993f, -0.08168749f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.01252110f, 0.12115002f, -0.02822631f, 0.08452341f, 0.05133679f, -0.04000046f, 0.07412155f, -0.03555397f, 
    0.05748866f, -0.12281334f, 0.09267438f, -0.02633900f, -0.18339606f, 0.04735638f, -0.09992035f, 0.12949374f, 
    0.03193907f, 0.11041605f, 0.12147086f, -0.07371791f, 0.04135169f, -0.00626576f, -0.08171598f, -0.05478597f, 
    0.17997733f, -0.00316851f, 0.06188089f, 0.19574723f, -0.12927283f, 0.01007073f, -0.09363793f, -0.08840723f, 
    0.02161012f, -0.11630677f, 0.03672396f, -0.05370875f, 0.07242601f, 0.06913770f, 0.20769951f, -0.13377076f, 
    0.09120563f, 0.05047838f, 0.03306303f, 0.04832772f, -0.01344704f, -0.00507011f, 0.04977959f, 0.16328074f, 
    -0.01091256f, 0.21103747f, -0.00752163f, -0.05853081f, -0.00385856f, 0.02889159f, 0.00571502f, 0.05920543f, 
    0.01022525f, 0.19000983f, 0.03209148f, 0.07666638f, -0.11567586f, 0.12893924f, 0.08180810f, -0.03115643f, 
    -0.05210143f, -0.01042241f, 0.01942412f, 0.09074629f, -0.09695640f, -0.06670789f, -0.13395721f, 0.06600773f, 
    0.03521095f, 0.11993469f, -0.16357572f, -0.03233871f, 0.00825265f, -0.04099108f, -0.01734399f, -0.02916691f, 
    0.00194440f, -0.03981253f, 0.00109448f, -0.02058475f, -0.22349925f, 0.22180717f, -0.05478283f, 0.12927467f, 
    0.06991457f, -0.09412808f, 0.07478534f, -0.07544615f, 0.09299196f, -0.00822597f, 0.04388523f, -0.06267804f, 
    0.24639249f, -0.02069809f, 0.01446184f, 0.17272493f, 0.09888390f, 0.14285314f, 0.08935901f, -0.05341658f, 
    -0.05723868f, 0.11782805f, 0.02184171f, -0.01740820f, 0.03394908f, 0.15967987f, 0.02225780f, -0.14741643f, 
    -0.13761550f, -0.11252546f, 0.01931587f, -0.02111416f, -0.04886240f, 0.02924989f, -0.00471558f, 0.04882322f, 
    0.06722771f, 0.15324134f, 0.20146082f, 0.06723220f, 0.08290834f, -0.05177237f, -0.04021979f, 0.02988016f, 
    0.05706837f, -0.05075360f, 0.09899066f, 0.03544075f, -0.08201993f, -0.02096510f, 0.07639125f, 0.12564009f, 
    0.06193257f, -0.02044241f, 0.05370893f, -0.12230632f, -0.03342467f, -0.05282643f, -0.09269845f, -0.07258250f, 
    0.21043469f, 0.01759426f, -0.05111761f, -0.00504434f, -0.10020608f, -0.05712863f, 0.06888922f, 0.10771827f, 
    -0.04864259f, 0.05348214f, -0.08136497f, -0.00454813f, -0.05454074f, 0.17909335f, 0.02659744f, 0.06605830f, 
    -0.04791317f, 0.10535390f, -0.02182094f, -0.02749853f, -0.04301776f, 0.00698167f, -0.05273006f, 0.02048168f, 
    0.16484378f, 0.15414117f, -0.06164530f, -0.09072085f, 0.04792477f, 0.05201933f, -0.00615529f, 0.12126435f, 
    0.03646553f, -0.02721376f, 0.00971744f, 0.04473490f, -0.11783278f, 0.12579635f, -0.00845422f, -0.05104512f, 
    -0.05252966f, 0.06411927f, 0.01229003f, 0.01925061f, 0.00847006f, -0.05044761f, 0.05578805f, -0.00012016f, 
    0.27058059f, 0.02989936f, 0.24050581f, 0.08148395f, -0.18971944f, 0.04984504f, 0.08853740f, -0.02167108f, 
    -0.00379379f, 0.06945684f, -0.06782918f, 0.10853978f, 0.00980117f, -0.11230391f, 0.09198490f, 0.05779939f, 
    0.07798883f, -0.04769179f, -0.01448051f, 0.07639547f, 0.04559523f, 0.08117393f, -0.02988756f, -0.00878053f, 
    0.04774903f, -0.09786287f, -0.10969035f, 0.02402485f, 0.08680638f, 0.11107425f, 0.08095654f, -0.00706806f, 
    -0.00761436f, 0.03310227f, -0.02273074f, -0.19835031f, -0.04768587f, -0.18901893f, 0.02653875f, 0.10713476f, 
    0.06361023f, 0.01136929f, -0.01481583f, -0.00098705f, -0.04456957f, -0.08880097f, -0.01660408f, -0.05191875f, 
    -0.11890256f, -0.10545225f, -0.11626463f, -0.03737351f, 0.00060298f, 0.00169906f, -0.01155240f, 0.00927537f, 
    0.00970662f, 0.11741982f, 0.04210067f, 0.01677659f, -0.07526328f, 0.11451781f, 0.09028079f, -0.15353404f, 
    0.01750168f, 0.00256272f, -0.01667705f, -0.02113055f, -0.03135526f, -0.14234629f, -0.01652079f, -0.05068072f, 
    -0.13636568f, -0.05057458f, -0.03030577f, 0.17872253f, -0.04206694f, 0.01837844f, 0.14157295f, -0.03581872f, 
    0.05008425f, -0.00638421f, -0.09278970f, 0.06461671f, 0.08402568f, -0.14742601f, -0.05783674f, 0.30725187f, 
    -0.04824316f, 0.04296342f, 0.01377543f, -0.03729334f, 0.07721416f, 0.03963904f, -0.10506971f, 0.09490960f, 
    -0.03283821f, 0.17243785f, 0.06769892f, -0.17588176f, -0.13241397f, -0.00653859f, -0.04933868f, 0.14721705f, 
    0.02305605f, -0.04492001f, 0.03691021f, -0.06726272f, -0.15085629f, 0.06479803f, -0.00706302f, 0.09803651f, 
    0.05012137f, 0.08064602f, -0.02213624f, -0.10648659f, -0.01375411f, 0.12634838f, 0.02199831f, -0.07055324f, 
    0.21757282f, 0.16979602f, 0.02433528f, -0.12440617f, -0.00200448f, -0.10103840f, 0.00659237f, 0.08775117f, 
    0.07905486f, -0.02042509f, -0.05670158f, 0.09817898f, 0.11185332f, -0.07082634f, 0.00409924f, 0.02928478f, 
    -0.00402625f, -0.00651085f, -0.00796744f, -0.03071804f, -0.02776949f, -0.01829161f, -0.05982720f, 0.00095282f, 
    -0.00091898f, 0.04216337f, 0.03580284f, 0.05635504f, -0.00851156f, -0.01388502f, -0.03299687f, -0.01245090f, 
    -0.06408659f, 0.04672486f, 0.04732523f, 0.01566242f, -0.04011118f, -0.08733513f, 0.00000415f, 0.03292511f, 
    -0.05672683f, -0.08101495f, -0.02293674f, 0.05245348f, -0.02698164f, -0.12866560f, 0.05408597f, -0.09629346f, 
    -0.06633015f, -0.06078107f, -0.33033255f, 0.11282687f, -0.03433051f, 0.01140921f, -0.01036937f, -0.06605718f, 
    -0.09525736f, 0.02957621f, 0.00186322f, -0.07553444f, 0.12082943f, -0.09084715f, 0.16608639f, 0.02232782f, 
    -0.04671948f, -0.07193879f, -0.09865837f, -0.02648828f, 0.08070946f, 0.09812070f, -0.03764896f, 0.00531853f, 
    0.03587211f, 0.18292353f, 0.02372074f, -0.06924658f, 0.05366582f, -0.01478293f, 0.01020083f, 0.05960425f, 
    -0.00663901f, 0.09397701f, 0.02827252f, 0.17064101f, -0.00618944f, -0.03213359f, -0.03045512f, 0.08826520f, 
    0.04176941f, 0.01667256f, -0.04495919f, 0.07598242f, -0.04741367f, -0.04196820f, -0.06029632f, -0.01285353f, 
    -0.11481794f, -0.10115992f, 0.10750687f, 0.03053448f, -0.08086600f, -0.10500684f, -0.06261811f, -0.02038780f, 
    -0.02581886f, -0.02571769f, -0.03220358f, -0.02304194f, 0.00448785f, -0.09686714f, -0.08453621f, 0.11677121f, 
    -0.02748923f, 0.10435192f, 0.01993996f, -0.04813494f, -0.04636150f, 0.02055092f, -0.06673301f, -0.04276624f, 
    0.09275612f, 0.13141462f, -0.11455721f, 0.21064638f, 0.09905190f, 0.02957344f, 0.10117368f, 0.05255445f, 
    0.00072975f, 0.15142407f, -0.00538048f, 0.16844030f, 0.30848011f, 0.14483631f, 0.19578747f, 0.08865454f, 
    0.02272469f, 0.00380867f, -0.01782518f, 0.05792768f, 0.03881775f, 0.03880313f, 0.03676310f, 0.01565127f, 
    -0.07936747f, 0.08140095f, 0.01729797f, 0.20150788f, -0.05809330f, 0.04164748f, 0.00258530f, 0.04838818f, 
    -0.04834659f, 0.01912879f, 0.03203524f, -0.06105822f, 0.06709561f, -0.17842004f, -0.08560731f, 0.03994850f, 
    -0.11204211f, -0.04767438f, -0.08640536f, 0.08833334f, 0.00192047f, 0.11869707f, 0.11584429f, 0.03015368f, 
    -0.10267236f, -0.01539447f, 0.03671475f, 0.07408915f, -0.01848854f, -0.01293468f, -0.09905559f, -0.18573524f, 
    0.02054893f, 0.09405088f, 0.03390640f, -0.07037155f, 0.03768146f, 0.27271670f, -0.04290649f, 0.12123459f, 
    0.03954268f, -0.03200382f, 0.02728122f, -0.03043007f, -0.10373825f, 0.08461928f, 0.04483512f, -0.08673129f, 
    0.33924925f, 0.19707476f, 0.29253313f, -0.04770936f, 0.13873148f, 0.02387311f, 0.07498597f, 0.05407155f, 
    0.03886772f, 0.01118780f, -0.00994111f, -0.00123745f, -0.05728450f, -0.10191777f, -0.05736456f, 0.00385489f, 
    -0.00102241f, -0.14358869f, -0.08572730f, -0.06407589f, -0.08608516f, -0.05470148f, -0.00291667f, -0.15039136f, 
    -0.14078110f, -0.04291398f, -0.05575402f, 0.21172979f, 0.06876112f, -0.05962102f, -0.07695844f, 0.02062838f, 
    -0.13478817f, 0.00339956f, -0.05298178f, 0.01629189f, -0.16165109f, -0.05330870f, 0.20602322f, -0.02185346f, 
    0.01042371f, -0.04978988f, -0.00179734f, -0.05819335f, -0.01728982f, 0.03337219f, 0.05201159f, -0.12791872f, 
    0.08920020f, 0.09974004f, 0.09330741f, -0.03312267f, -0.12961447f, -0.07448667f, 0.08684756f, -0.00798824f, 
    0.00238132f, -0.05786744f, 0.05503384f, -0.08241221f, 0.22330698f, 0.01154690f, -0.06303963f, -0.02090063f, 
    -0.03749532f, 0.13754809f, 0.00011841f, -0.09632628f, -0.02344291f, 0.03821096f, 0.03719243f, -0.02136102f, 
    0.13103385f, 0.02803988f, -0.10403453f, -0.09683588f, -0.09546766f, 0.03702410f, -0.06871200f, 0.27265662f, 
    -0.02553563f, 0.00762638f, 0.02936001f, -0.01359150f, -0.12969360f, 0.09734553f, 0.13520819f, -0.04982081f, 
    -0.04326964f, -0.03373550f, 0.08914528f, -0.02369879f, 0.00714250f, -0.06543350f, 0.12399324f, 0.02746859f, 
    0.19909900f, -0.09426681f, -0.12010756f, -0.00710981f, -0.01958160f, 0.04784791f, -0.02756076f, -0.03314842f, 
    -0.00723589f, -0.08832454f, 0.03271258f, -0.15441647f, 0.14673959f, 0.22396120f, 0.13148354f, -0.04207671f, 
    0.01408598f, 0.09293434f, 0.05716138f, 0.10641588f, 0.07724077f, 0.01602239f, 0.13270555f, -0.03479527f, 
    -0.06476273f, -0.11600866f, 0.14767604f, 0.07632466f, 0.07615246f, 0.02656302f, -0.04213076f, 0.02130470f, 
    0.06890129f, -0.00296500f, -0.04307707f, -0.12612455f, -0.00291537f, 0.09997877f, -0.14192379f, 0.26668590f, 
    -0.00836624f, 0.00679346f, 0.03439741f, 0.02589731f, 0.03507532f, 0.01379118f, -0.02706557f, -0.01946994f, 
    0.01342335f, -0.01189611f, -0.12977119f, 0.15342034f, -0.02257325f, 0.10875162f, -0.01842190f, 0.04049548f, 
    -0.08817848f, -0.05244835f, 0.10201581f, -0.13767385f, 0.09856518f, 0.17022842f, 0.06927733f, -0.18013351f, 
    0.04789934f, -0.00233480f, -0.06743937f, -0.02274147f, -0.02460328f, 0.10607419f, 0.03566176f, 0.05920408f, 
    -0.10909771f, 0.04399743f, -0.07539932f, -0.01968556f, 0.03428720f, 0.06515601f, 0.00963707f, 0.07927101f, 
    -0.05189029f, 0.02682718f, 0.00387183f, -0.05337758f, 0.09591412f, 0.06377581f, 0.25233701f, -0.00677795f, 
    0.12647516f, -0.05464470f, 0.04403837f, 0.04991852f, -0.01949443f, 0.07930660f, 0.09564690f, 0.02996283f, 
    0.20353675f, 0.00047905f, -0.00676834f, -0.16212735f, 0.00525817f, 0.05474969f, -0.04850094f, 0.03716196f, 
    -0.02835193f, 0.10349295f, -0.00669148f, 0.08161020f, 0.04906152f, -0.10211602f, 0.04906694f, 0.10287661f, 
    0.01024502f, 0.03733926f, -0.05797492f, -0.02277630f, 0.02392194f, 0.00978726f, 0.09520174f, -0.02344003f, 
    0.06284771f, 0.02416218f, 0.00201588f, -0.01458572f, -0.12936960f, 0.00743480f, -0.01682644f, -0.02253701f, 
    0.00170377f, 0.06365806f, -0.03480105f, -0.01012240f, -0.03442234f, 0.01268303f, 0.10378684f, 0.04228466f, 
    -0.01290745f, -0.08547143f, -0.04115427f, -0.07713399f, 0.01836213f, -0.02657167f, 0.00366719f, -0.08865047f, 
    0.14053328f, -0.15360008f, -0.06092577f, 0.00793955f, -0.06816842f, 0.00419788f, 0.02720489f, 0.01118055f, 
    0.01185716f, 0.05826974f, 0.01542451f, -0.12075874f, 0.08882458f, -0.08255961f, -0.03301350f, 0.15693069f, 
    0.13544595f, -0.02593627f, -0.06937495f, 0.11992112f, -0.02768140f, 0.01757060f, 0.04225325f, -0.00638296f, 
    -0.07184323f, -0.12221013f, 0.09429125f, -0.11771587f, 0.05040338f, -0.06253093f, 0.03037348f, -0.09298042f, 
    -0.03271002f, -0.07657806f, -0.13494088f, 0.15493321f, -0.26755235f, -0.07625191f, -0.22705087f, -0.00154714f, 
    -0.02529049f, -0.03323923f, -0.04972554f, -0.00749734f, -0.04062083f, 0.01199454f, -0.03572470f, -0.11012501f, 
    -0.18802062f, -0.01594373f, 0.07006664f, 0.09525864f, -0.03653357f, -0.05387079f, -0.04356809f, 0.01749787f, 
    -0.05270553f, 0.06473796f, 0.06112589f, 0.08246335f, 0.05027450f, 0.18893467f, 0.24362640f, 0.32076737f, 
    -0.10058426f, -0.01572339f, 0.07274702f, 0.01096108f, -0.05977440f, 0.09239926f, -0.05250465f, -0.02630420f, 
    0.00126731f, -0.10900928f, -0.08342122f, 0.05017360f, -0.02104312f, -0.00581341f, 0.02721804f, 0.02166507f, 
    0.04968970f, -0.02030599f, -0.02973361f, 0.09999888f, 0.10216765f, 0.21546388f, 0.05750406f, 0.20742007f, 
    -0.11302064f, 0.01280945f, 0.09131030f, -0.00164296f, -0.01219651f, 0.09469058f, 0.05864934f, -0.05216180f, 
    0.06354342f, 0.03901329f, 0.07778035f, -0.11101571f, -0.07314845f, 0.07696059f, 0.02292693f, -0.00975758f, 
    -0.03339437f, -0.00324752f, -0.02394336f, -0.03338947f, -0.03255235f, -0.16856144f, -0.15840991f, -0.10015142f, 
    -0.08100227f, 0.01232803f, 0.12130332f, 0.00648963f, -0.09833475f, 0.05179754f, -0.04222381f, -0.05610642f, 
    0.12154038f, 0.01670855f, 0.05700602f, 0.06163896f, -0.10705169f, -0.03389317f, -0.05046244f, 0.05376941f, 
    0.05030477f, 0.04920981f, 0.02943902f, 0.07961138f, -0.04640853f, -0.19449688f, -0.02845928f, -0.07867958f, 
    0.01394292f, 0.08457141f, -0.02394072f, -0.00905121f, 0.00607020f, -0.06023334f, -0.05265904f, 0.07360833f, 
    -0.04216318f, 0.18087891f, 0.06737372f, 0.12771878f, 0.05663506f, -0.01543349f, 0.01307503f, 0.03392083f, 
    -0.04285397f, -0.06360233f, 0.03381150f, -0.07561710f, -0.29513520f, -0.19234347f, 0.26887760f, -0.01389136f, 
    -0.12219540f, -0.02305911f, -0.01971637f, -0.01755147f, 0.03593807f, -0.02338420f, -0.10825750f, 0.01402308f, 
    0.04245400f, -0.13735965f, -0.04613790f, -0.08688814f, 0.07364350f, -0.00916886f, -0.07956585f, 0.02917753f, 
    0.06171886f, 0.08384421f, 0.07844736f, 0.05901635f, 0.06482594f, 0.08062382f, 0.12569852f, 0.28235438f, 
    -0.01048070f, -0.05131461f, 0.03277161f, 0.08750804f, -0.07805195f, 0.05153599f, 0.04793540f, 0.00030572f, 
    0.37182754f, -0.03863068f, 0.00951992f, 0.14373964f, -0.16212621f, 0.05842504f, -0.15955615f, -0.00369229f, 
    -0.11813926f, 0.12448267f, -0.03540770f, 0.05023900f, 0.07883292f, -0.07141948f, -0.11298642f, -0.04988156f, 
    -0.04344871f, -0.02644098f, -0.06491977f, -0.10848320f, 0.02702489f, -0.01747626f, -0.05623514f, 0.06698035f, 
    -0.05623695f, 0.10832777f, 0.04326864f, 0.13620575f, 0.14222956f, 0.02718097f, -0.03375843f, -0.01275620f, 
    -0.23721175f, -0.03811051f, 0.01021891f, -0.06174764f, 0.00859922f, 0.01951766f, 0.11770795f, 0.05465307f, 
    0.01247851f, 0.00929189f, -0.03895425f, -0.02548573f, 0.00604796f, -0.04215234f, -0.11209773f, 0.02421966f, 
    -0.19681229f, -0.27520317f, -0.03282232f, 0.02993782f, 0.06272001f, -0.03825144f, -0.11344299f, -0.06533027f, 
    -0.08071749f, -0.05087855f, -0.02875053f, -0.08362790f, -0.15398203f, 0.02071820f, -0.10393281f, -0.01593338f, 
    0.07575665f, -0.00989813f, -0.00358700f, -0.05994933f, -0.13833024f, -0.10537790f, 0.06201350f, -0.10042506f, 
    0.10282835f, -0.10677505f, -0.07206529f, -0.07966515f, 0.00521743f, -0.04584105f, -0.04164758f, 0.04894669f, 
    0.04618898f, -0.14573574f, -0.13259412f, 0.02194826f, 0.39059174f, 0.14271361f, -0.03618871f, 0.23970164f, 
    -0.01028618f, 0.04184777f, 0.02488683f, -0.01596565f, 0.03702502f, 0.07918743f, -0.05118938f, -0.00638228f, 
    -0.08272880f, -0.02462447f, -0.17282711f, -0.16641498f, -0.08285446f, -0.06219143f, 0.04529168f, 0.13802052f, 
    0.03449173f, 0.08286431f, 0.06804192f, 0.00430600f, 0.03899601f, -0.02217214f, -0.21687788f, -0.11930878f, 
    -0.07373484f, 0.00123486f, -0.00733851f, 0.03074806f, 0.01501517f, -0.05730547f, 0.06138305f, 0.00393250f, 
    0.11861976f, -0.00487330f, -0.13915552f, 0.21351025f, 0.04610833f, -0.00494854f, 0.13140406f, 0.04828521f, 
    -0.03073964f, 0.05045836f, -0.01759869f, 0.03063064f, -0.21659526f, 0.08670508f, -0.06021303f, -0.12353200f, 
    0.00737179f, 0.03896558f, -0.08780952f, 0.03986548f, 0.05419950f, -0.04422515f, 0.01936551f, -0.09102325f, 
    0.15855676f, 0.05537891f, -0.00548899f, 0.13919893f, 0.05514150f, 0.14789508f, 0.10409355f, 0.12437163f, 
    -0.13207076f, 0.01316124f, -0.05412800f, -0.01400783f, 0.32085592f, 0.14556333f, 0.03026554f, 0.27282998f, 
    0.08162720f, -0.05502449f, 0.03949415f, 0.09967580f, -0.09478131f, -0.05289145f, 0.08507666f, -0.03699598f, 
    0.22909163f, 0.10398409f, -0.03008578f, -0.00409718f, -0.03136684f, -0.05755762f, 0.00294851f, -0.03824586f, 
    0.00470576f, -0.07835979f, 0.01530315f, 0.00800099f, 0.19410571f, 0.10550953f, 0.04720428f, 0.17389856f, 
    -0.07255223f, -0.01666781f, 0.02722730f, 0.08065645f, -0.06767078f, -0.06865801f, 0.05464762f, 0.18753850f, 
    0.04722960f, -0.07537941f, -0.01737843f, 0.00818950f, -0.06177864f, -0.07352290f, 0.03908468f, 0.00700498f, 
    0.18207559f, 0.06701309f, 0.04162611f, 0.07454611f, 0.00193226f, 0.17992215f, 0.24061507f, 0.03812773f, 
    0.06560501f, 0.02291511f, -0.00643032f, 0.04330447f, -0.10530841f, 0.03405559f, 0.10161158f, 0.03566825f, 
    -0.08531579f, -0.07151291f, 0.17823334f, 0.20209683f, -0.01015434f, 0.01093015f, 0.02661763f, 0.04228752f, 
    0.01032398f, -0.00231617f, -0.06385393f, -0.07537367f, -0.01046501f, -0.06017175f, -0.00266937f, -0.00262556f, 
    0.11597314f, -0.04283171f, -0.05043563f, -0.01420198f, -0.03684324f, -0.01729245f, -0.01552788f, -0.00789697f, 
    0.05267277f, 0.12285218f, 0.13716559f, 0.09252732f, 0.05413690f, -0.11292990f, 0.04249106f, 0.01412317f, 
    0.04879902f, -0.11920911f, -0.04151475f, -0.00531547f, 0.00541149f, -0.11064018f, -0.01573032f, 0.03596852f, 
    -0.01732309f, 0.04895329f, -0.06625663f, -0.02173489f, 0.04518009f, -0.00972903f, -0.00620459f, -0.05488080f, 
    -0.09914701f, 0.02899703f, -0.26486671f, -0.13319322f, 0.04714880f, 0.02308297f, -0.00906218f, 0.05184798f, 
    0.00906179f, 0.10598287f, 0.07334815f, 0.06544200f, -0.17925116f, 0.19561332f, 0.12860060f, 0.17349558f, 
    0.15297970f, 0.01126235f, 0.02941713f, 0.02883959f, -0.04837551f, -0.06206747f, -0.02480678f, -0.02008445f, 
    0.42395943f, 0.19564195f, 0.14445895f, 0.19582765f, -0.09008925f, 0.03317720f, 0.05404330f, 0.01624669f, 
    0.01737818f, 0.05998146f, 0.02963273f, 0.03622952f, -0.02484431f, 0.10648146f, -0.10342129f, 0.00253817f, 
    -0.09632763f, 0.04930887f, -0.07308051f, 0.02089484f, -0.03323734f, -0.06305525f, 0.03847349f, 0.15759328f, 
    -0.14140777f, 0.07042740f, -0.10991919f, -0.07187343f, 0.09154592f, -0.04289212f, 0.03502687f, 0.03165180f, 
    -0.00730955f, 0.01732532f, -0.07072982f, -0.03786855f, -0.04663224f, -0.06796280f, -0.25336918f, 0.05040924f, 
    0.10895615f, -0.01258096f, 0.05768454f, -0.13551250f, 0.03699889f, -0.04529426f, 0.02830771f, -0.08627244f, 
    0.01221220f, 0.10530122f, -0.02368606f, 0.07143775f, 0.14941874f, 0.03238171f, -0.02745129f, 0.14475824f, 
    0.00545402f, -0.01224704f, -0.07942688f, -0.05173017f, -0.09036606f, 0.01165316f, 0.01981588f, 0.00173219f, 
    -0.10423554f, 0.05751063f, -0.01912922f, 0.04929820f, -0.03858499f, 0.10117457f, 0.01856162f, 0.01910430f, 
    0.04414679f, -0.04284962f, -0.12961227f, -0.11504340f, -0.01591313f, -0.01149328f, -0.02238544f, -0.05770790f, 
    0.02764263f, -0.05398155f, 0.03546606f, -0.05147668f, 0.07667550f, 0.07350725f, 0.16356069f, -0.04303689f, 
    0.06041547f, -0.10680240f, 0.01109613f, 0.10199333f, -0.12162063f, -0.06360103f, 0.02715632f, -0.07409016f, 
    0.06002183f, -0.12495749f, 0.04367688f, -0.03563493f, 0.05701096f, -0.02446429f, -0.02176504f, -0.01034864f, 
    -0.09912620f, -0.02730846f, -0.14012024f, -0.14975496f, 0.05361447f, 0.08283539f, -0.29413700f, 0.11851422f, 
    0.03342893f, -0.02746507f, 0.03638331f, 0.11908387f, 0.14926235f, -0.02410062f, 0.12539138f, -0.00581380f, 
    0.09261379f, -0.11623691f, 0.00180418f, -0.15171832f, -0.00039156f, 0.00603684f, -0.10698871f, -0.08691641f, 
    0.04269398f, 0.06847597f, -0.01191117f, -0.04311753f, 0.09426142f, 0.16327147f, 0.14238049f, 0.21795920f, 
    0.07581776f, 0.00219454f, 0.05413718f, -0.00870905f, -0.16588120f, 0.00421012f, 0.03412393f, -0.03340968f, 
    0.05657203f, -0.07090545f, -0.04273987f, -0.05028229f, 0.06907238f, 0.07566780f, -0.04383103f, -0.02506852f, 
    0.08272583f, -0.04573653f, -0.12679817f, 0.10099957f, -0.17090632f, 0.21526900f, 0.03998983f, 0.08505640f, 
    0.06011728f, 0.06148992f, 0.18491814f, 0.05730608f, -0.07500573f, 0.08998045f, 0.09045652f, 0.02254873f, 
    -0.11405057f, 0.08155862f, -0.02368394f, 0.01290076f, 0.04552941f, -0.01727974f, -0.00983567f, 0.02559926f, 
    -0.04729968f, -0.05622594f, -0.05185064f, 0.04414566f, -0.08095834f, -0.06280030f, -0.07843262f, -0.11007179f, 
    0.13475575f, 0.05706784f, -0.01859495f, 0.10106926f, -0.08995202f, -0.10426011f, 0.10069875f, -0.02454323f, 
    0.12813294f, -0.10563491f, 0.02517162f, -0.11585675f, 0.12105745f, -0.11249451f, 0.00865330f, -0.04216386f, 
    -0.07034788f, -0.12763126f, 0.05941458f, -0.03409265f, 0.04005395f, -0.01190911f, -0.32297418f, 0.12784757f, 
    -0.01521530f, 0.02202332f, -0.05136013f, -0.02010140f, 0.00759912f, 0.07531075f, 0.05324408f, 0.11148041f, 
    -0.04086430f, -0.19633639f, 0.02430383f, -0.01740022f, -0.05608369f, -0.03113892f, 0.04411947f, 0.01088330f, 
    0.14488916f, 0.01043179f, -0.10091715f, -0.02832859f, -0.10589818f, 0.15690988f, 0.19781211f, 0.12787078f, 
    -0.00588764f, 0.04417704f, -0.00167472f, 0.11523509f, -0.05802863f, 0.08834699f, 0.09717506f, 0.04252192f, 
    0.18555129f, 0.04900569f, 0.07683881f, 0.06566886f, -0.01096867f, 0.04964640f, 0.04204950f, -0.01547061f, 
    0.12205067f, -0.09969971f, 0.10889144f, 0.07415501f, -0.03721403f, -0.01847680f, 0.05694049f, 0.21546923f, 
    -0.05866572f, 0.04448522f, 0.04900076f, -0.00273667f, 0.13991593f, -0.05517365f, -0.02817539f, 0.01593115f, 
    0.27055165f, 0.13604631f, 0.24221276f, 0.17541918f, -0.03194606f, 0.11851559f, -0.05359602f, 0.05587177f, 
    -0.07040899f, 0.03420718f, -0.07625160f, 0.02930005f, -0.08640917f, 0.03361592f, -0.13237597f, 0.23974808f, 
    0.03069401f, 0.01320502f, -0.05193568f, 0.03160613f, 0.07680244f, -0.06575615f, -0.02492000f, -0.07116528f, 
    -0.02852442f, -0.06504929f, -0.24390285f, 0.16990526f, 0.01865204f, -0.11959024f, 0.05174647f, -0.01754583f, 
    0.17918485f, 0.11173741f, -0.00171856f, 0.00741764f, 0.14543967f, 0.01485156f, 0.14276397f, 0.04820073f, 
    0.06800999f, -0.04580640f, -0.07766071f, 0.06793426f, 0.05959476f, 0.01088022f, 0.03667264f, -0.02602187f, 
    -0.16660765f, 0.01326784f, 0.01031945f, -0.02037504f, 0.15029116f, -0.03169879f, 0.11206834f, 0.05537253f, 
    0.06640695f, -0.04496131f, -0.01775015f, 0.03655050f, -0.36087933f, 0.06935018f, -0.17188001f, -0.06168801f, 
    0.12030789f, 0.01498721f, -0.01587455f, -0.01491856f, -0.04387284f, -0.01792333f, -0.01407120f, 0.00567569f, 
    0.26596442f, 0.13869244f, -0.01831692f, 0.10797803f, -0.09869734f, -0.01800128f, 0.01467407f, -0.04703381f, 
    -0.02628900f, 0.01335792f, 0.01805740f, 0.07343721f, -0.01839468f, 0.05751407f, 0.09772120f, -0.05383458f, 
    0.09454244f, 0.08545502f, 0.05063125f, 0.06357037f, 0.01237347f, 0.04971553f, 0.02668133f, 0.10387360f, 
    -0.25660062f, 0.10830373f, 0.03889760f, 0.00581250f, -0.05015471f, 0.07590200f, 0.05085604f, 0.03639703f, 
    0.11601949f, 0.05774883f, 0.07599688f, 0.07790072f, -0.03700230f, -0.06076568f, 0.06703698f, 0.03438156f, 
    -0.03572815f, 0.07271270f, -0.07417580f, 0.07965555f, -0.07312058f, 0.01526000f, 0.00221066f, 0.06734572f, 
    0.01825136f, 0.04675161f, 0.16442102f, -0.04161241f, 0.01851062f, -0.00141556f, 0.04093912f, 0.07479423f, 
    0.07922119f, 0.04081081f, -0.01437350f, -0.05532081f, -0.25161302f, 0.39889243f, -0.22391976f, 0.04554339f, 
    0.12366991f, -0.15176497f, 0.10352795f, 0.02429163f, 0.05733830f, -0.07067929f, 0.01937221f, -0.08325035f, 
    0.05384317f, 0.14034842f, -0.02548216f, 0.03005522f, 0.04650405f, 0.07177503f, 0.09432267f, -0.06394655f, 
    0.02823850f, 0.00746798f, -0.02966251f, 0.11187014f, 0.30393219f, -0.20584956f, -0.03385951f, 0.00892883f, 
    -0.14635475f, -0.10404119f, 0.07640305f, 0.03976806f, -0.05632252f, 0.14932643f, -0.03886014f, 0.05817609f, 
    -0.11896464f, 0.14308679f, -0.01020764f, 0.10068119f, 0.03165998f, -0.09030011f, 0.02622894f, 0.01965188f, 
    0.04134365f, 0.03219573f, 0.08033772f, -0.01140945f, -0.06488875f, -0.17409706f, 0.15760200f, -0.07014317f, 
    0.00402645f, 0.01334841f, 0.01859398f, 0.03585494f, 0.05057191f, 0.02413320f, 0.03467150f, -0.01788178f, 
    0.10854326f, 0.05400506f, -0.02900888f, -0.03384589f, 0.12335116f, 0.06236625f, 0.05844723f, 0.06122740f, 
    0.02237129f, -0.00017824f, 0.02230465f, 0.15198426f, -0.14508203f, 0.14407457f, -0.11969213f, 0.14652210f, 
    0.04134192f, 0.09118818f, 0.05116239f, 0.02346870f, 0.08933041f, -0.07904292f, -0.03652195f, -0.00815458f, 
    0.02560885f, -0.03175627f, 0.17283180f, 0.15078299f, -0.05082769f, 0.15301813f, -0.10377443f, 0.11759374f, 
    -0.02071519f, -0.01649532f, 0.09645810f, -0.02530265f, -0.40396145f, 0.00957855f, 0.06081824f, 0.02976908f, 
    -0.00146882f, 0.04623893f, -0.04582544f, 0.09346328f, 0.06135149f, -0.03076257f, -0.02299834f, 0.06273652f, 
    -0.07667327f, 0.04760097f, -0.03728364f, 0.03874895f, -0.00974607f, 0.07898553f, 0.01743720f, -0.06316770f, 
    -0.03322274f, 0.06777044f, -0.02952118f, -0.05536257f, 0.23157761f, -0.20654333f, 0.08917276f, 0.17455105f, 
    0.01690575f, -0.05961813f, -0.03121786f, 0.02472376f, 0.03029985f, 0.08347677f, 0.09890747f, -0.00931891f, 
    -0.20676351f, -0.10336343f, -0.00914672f, -0.20337281f, 0.11074850f, 0.03915813f, -0.01779113f, -0.06562702f, 
    -0.12237698f, 0.00119711f, -0.00799747f, -0.09969567f, -0.36187935f, -0.02334794f, -0.02589981f, -0.02547132f, 
    0.14425018f, -0.00499561f, -0.04367306f, -0.05291186f, 0.02739507f, 0.07047215f, 0.03906548f, -0.01788990f, 
    -0.07178287f, 0.03617213f, 0.09215352f, 0.04995849f, -0.00683703f, 0.10368649f, -0.01853322f, -0.11873659f, 
    0.03385025f, -0.02762345f, 0.04747915f, -0.03523958f, 0.03489934f, 0.04283387f, -0.01108748f, 0.15514155f, 
    0.02556800f, 0.12105053f, -0.03784636f, -0.04942180f, 0.15220231f, -0.03559469f, -0.04621999f, 0.04733578f, 
    -0.17666060f, 0.10440179f, -0.09502012f, -0.05495038f, 0.06879342f, -0.03548742f, 0.04846431f, 0.02059726f, 
    0.02027420f, -0.07208289f, -0.02395566f, 0.05745604f, -0.22688977f, 0.03714224f, -0.16751440f, 0.05539064f, 
    0.06334635f, -0.00860782f, -0.05212279f, -0.01273192f, -0.07405104f, -0.03277180f, -0.00073724f, 0.06924815f, 
    -0.27538937f, 0.19533496f, 0.09038039f, 0.07131468f, -0.04281852f, 0.13211566f, -0.01885702f, 0.05733869f, 
    0.09427944f, -0.03405651f, 0.01313967f, 0.02410732f, -0.09359889f, 0.08786597f, -0.07648112f, -0.05757938f, 
    0.07499208f, -0.01583750f, -0.01607025f, -0.08139086f, -0.05003170f, 0.04559570f, 0.03220447f, -0.06365360f, 
    0.10164028f, -0.07438827f, 0.03544590f, -0.19950983f, 0.03976276f, 0.00664553f, 0.02810519f, 0.07042603f, 
    -0.09785011f, 0.00880523f, 0.01451335f, 0.11709822f, 0.19096614f, -0.07590760f, -0.01123612f, 0.07978112f, 
    -0.00180524f, 0.06340848f, 0.09431476f, 0.07436936f, 0.04545825f, 0.04610894f, 0.03253682f, 0.08075731f, 
    0.18566452f, 0.02894021f, -0.00589714f, 0.01609957f, -0.01146892f, -0.05737836f, -0.07808907f, 0.04064769f, 
    0.06116981f, 0.03643307f, 0.14779006f, 0.06109935f, 0.02039371f, 0.07293862f, 0.00056602f, 0.06298296f, 
    0.05492900f, 0.01999518f, 0.01783518f, 0.07853360f, -0.06218639f, 0.01538375f, 0.05744907f, 0.04314534f, 
    -0.26429141f, -0.01281766f, 0.11859830f, 0.01095029f, 0.02397486f, 0.03423987f, 0.01531220f, -0.09547834f, 
    -0.04196825f, 0.04917915f, -0.03571524f, -0.00266216f, -0.10160328f, -0.05316408f, 0.13996333f, 0.02983796f, 
    0.00204992f, 0.00156687f, -0.07546260f, 0.00388540f, 0.05885332f, 0.05494061f, -0.02130625f, 0.01051070f, 
    -0.05170675f, 0.01803637f, 0.18458503f, -0.06217724f, 0.02563311f, 0.04111922f, -0.00442237f, 0.08254164f, 
    0.11967168f, 0.03694913f, 0.02407365f, 0.10583340f, -0.27499780f, 0.03539860f, -0.16051476f, -0.23486985f, 
    0.06717017f, 0.02855789f, -0.02325852f, 0.01439490f, -0.05051178f, -0.13561264f, -0.02993435f, 0.08384553f, 
    0.07651118f, -0.01979811f, 0.02914533f, 0.01634356f, -0.05167400f, -0.06384515f, -0.01027485f, 0.01382458f, 
    0.06007053f, -0.00607813f, 0.00430188f, 0.12035322f, -0.15335165f, -0.07754526f, 0.06887972f, -0.02438076f, 
    -0.01689470f, 0.12723742f, 0.00635737f, 0.00275321f, 0.00834531f, 0.00600149f, 0.03813492f, 0.04488129f, 
    -0.15083775f, 0.07098425f, 0.11897844f, 0.19056572f, 0.06731152f, -0.08064768f, -0.01295129f, 0.16253857f, 
    0.01842074f, 0.11249718f, -0.06329653f, 0.06563430f, 0.10242008f, 0.04613799f, 0.01081257f, 0.02222683f, 
    0.06648167f, -0.04567986f, 0.02313676f, 0.05166864f, 0.05831546f, 0.00819497f, 0.00120695f, -0.00010986f, 
    0.09361287f, 0.00318090f, -0.06478341f, 0.27213708f, -0.04555955f, 0.12397725f, -0.03523551f, 0.04210058f, 
    -0.01240113f, -0.03097328f, 0.00648675f, 0.03279049f, -0.17847067f, -0.16559635f, -0.11996318f, -0.01858022f, 
    -0.02523417f, 0.02408662f, -0.11697744f, 0.03701362f, 0.07896271f, 0.07459096f, 0.05372018f, 0.17562979f, 
    -0.09309239f, 0.09093442f, -0.05347193f, -0.13269295f, 0.07949314f, -0.07418936f, -0.09513819f, 0.03211991f, 
    -0.01851282f, -0.00029064f, 0.02148335f, 0.06087242f, -0.19959512f, 0.25655374f, -0.24383770f, 0.11814974f, 
    0.06218393f, -0.03646336f, -0.04704734f, -0.04285232f, -0.06271779f, -0.03927740f, 0.12487103f, -0.06303816f, 
    0.22366244f, 0.26837617f, 0.05671302f, -0.15962820f, 0.17568529f, -0.06038953f, 0.07439008f, 0.00327781f, 
    0.03634021f, -0.01700627f, 0.07379489f, 0.04055207f, -0.23897621f, -0.06130736f, 0.01746451f, -0.00956887f, 
    -0.05693367f, -0.01387585f, -0.07782228f, -0.04719623f, -0.05120525f, -0.00548105f, 0.05994775f, -0.03254560f, 
    -0.41938904f, 0.24821141f, -0.18165225f, -0.13023853f, 0.06187338f, 0.01032829f, -0.05928949f, -0.01599407f, 
    -0.06140712f, -0.03982281f, 0.04422801f, -0.01042593f, 0.00506529f, 0.04096944f, 0.13149616f, 0.06159236f, 
    0.11279951f, 0.02864017f, 0.03358671f, 0.02290692f, 0.10440407f, 0.05235704f, 0.09214805f, -0.07184436f, 
    -0.09048746f, -0.07724859f, 0.10948616f, 0.00360923f, -0.11405480f, 0.00097924f, -0.05318761f, 0.05679192f, 
    0.00759467f, -0.07902469f, 0.09425578f, -0.04262912f, -0.07289165f, 0.23144054f, -0.11031733f, -0.09378440f, 
    0.00195869f, 0.08620710f, -0.04212761f, -0.12625109f, -0.01047967f, -0.01383986f, 0.03724572f, -0.03357412f, 
    -0.08763330f, -0.01313491f, 0.04466731f, 0.01832396f, -0.00453379f, 0.04748337f, -0.00727735f, 0.06799708f, 
    0.11982609f, -0.03578177f, 0.04462489f, 0.08547186f, 0.06310159f, 0.02463071f, 0.01045552f, -0.07315652f, 
    -0.02473553f, -0.01699048f, 0.13294147f, 0.03538965f, 0.06366450f, -0.03146134f, 0.08059977f, -0.06549389f, 
    -0.06022008f, -0.13904759f, -0.05090397f, 0.04468321f, 0.02228669f, 0.09856655f, 0.00915747f, -0.11028956f, 
    -0.06328507f, 0.00502330f, 0.01444845f, 0.01433483f, -0.07154257f, 0.22921355f, 0.18782212f, -0.01612576f, 
    0.09417810f, 0.03816159f, 0.15861546f, -0.02343824f, 0.00430465f, 0.00223133f, 0.09104738f, 0.01605490f, 
    0.01381705f, 0.06966633f, 0.13291474f, 0.03120650f, 0.01398175f, -0.00182261f, 0.02728191f, 0.11371564f, 
    0.19323310f, 0.07021756f, 0.00109975f, 0.10321243f, -0.31813133f, 0.04743290f, -0.07514461f, -0.06133281f, 
    0.07632466f, -0.05651998f, -0.11919629f, -0.00083260f, 0.00243942f, -0.07956534f, -0.01209633f, 0.05760948f, 
    -0.13511389f, -0.00175647f, -0.13528486f, -0.04844614f, 0.07942241f, 0.01851073f, -0.07548682f, -0.07239427f, 
    0.02986465f, -0.04352756f, 0.09080070f, -0.00134187f, -0.13193288f, 0.07102700f, 0.09423713f, 0.00693769f, 
    -0.04239752f, -0.00626616f, -0.06174393f, 0.00494902f, 0.07168297f, -0.01424929f, -0.07629012f, 0.01268606f, 
    -0.04368041f, 0.05578699f, 0.08637790f, -0.03830487f, 0.05334996f, 0.01784473f, 0.02895059f, 0.06369963f, 
    -0.08376808f, 0.01194515f, 0.04351880f, 0.00032811f, 0.09324082f, -0.07260945f, 0.24720010f, 0.13746791f, 
    0.09026326f, 0.03298172f, -0.01747887f, 0.01496085f, 0.03956002f, 0.14577928f, 0.04537306f, 0.08045141f, 
    0.26282147f, -0.02948635f, 0.21272267f, 0.01570857f, -0.04654624f, 0.00494795f, 0.02261207f, 0.05756837f, 
    -0.11087899f, 0.05326012f, -0.02662474f, 0.15215117f, -0.08515788f, -0.11679047f, 0.14050516f, 0.03262775f, 
    0.01977641f, 0.00565070f, -0.04315446f, -0.03657525f, 0.00566141f, 0.01834454f, 0.13226908f, 0.02012630f, 
    0.01786600f, 0.10798964f, 0.03769859f, -0.08668348f, 0.00910111f, 0.08475673f, -0.01752083f, -0.03120990f, 
    0.04047409f, 0.03922155f, -0.11116771f, -0.03718410f, 0.04203825f, 0.07148347f, 0.13089707f, 0.03250863f, 
    -0.04952135f, 0.02412675f, -0.10387298f, -0.02474057f, -0.01826898f, -0.03758713f, 0.02434471f, -0.06952878f, 
    0.00579183f, -0.13647537f, -0.13289832f, 0.13876192f, -0.11399595f, -0.00672344f, 0.03099418f, -0.03899469f, 
    -0.05662378f, 0.09416843f, 0.07798451f, -0.05548706f, 0.26393500f, 0.12878677f, -0.05815911f, 0.19905537f, 
    0.17924149f, 0.07285595f, 0.00546888f, 0.09221658f, -0.07090654f, 0.11113155f, 0.11851145f, 0.01361329f, 
    0.04631601f, 0.13958271f, 0.04863798f, 0.13084616f, -0.10843357f, 0.03515492f, -0.01684372f, -0.02039785f, 
    0.06269460f, 0.01029435f, 0.11881729f, 0.05471956f, 0.19550030f, -0.17233877f, 0.01170375f, 0.02678470f, 
    -0.02814663f, -0.01180164f, 0.09165376f, 0.02031988f, 0.01777141f, 0.02719319f, 0.02203979f, 0.01365142f, 
    0.20723203f, 0.13744001f, 0.02057946f, -0.00887463f, 0.18897749f, 0.09738959f, 0.03012611f, -0.04986043f, 
    0.11546939f, -0.05600461f, 0.07168137f, 0.00983926f, 0.14649780f, -0.03727853f, 0.10495734f, -0.02629829f, 
    -0.15773380f, 0.01421122f, 0.00674411f, -0.06407472f, 0.05260764f, 0.00207281f, 0.04022264f, -0.00074463f, 
    -0.17412783f, -0.11425415f, 0.06217327f, -0.02055967f, 0.01262416f, -0.03622453f, 0.16777307f, 0.03599596f, 
    -0.02674229f, -0.04185414f, 0.08656302f, -0.05597942f, 0.11830332f, 0.12513752f, 0.02161040f, 0.03920243f, 
    -0.04330889f, -0.05359853f, 0.14181428f, 0.01385352f, -0.09228960f, -0.04441237f, 0.00964194f, 0.07556809f, 
    0.27399331f, 0.16514717f, 0.01885569f, 0.14831644f, 0.04600537f, 0.02586860f, 0.02689314f, 0.02494354f, 
    0.12791273f, 0.08739389f, 0.14331254f, 0.12380800f, 0.24185847f, -0.32360989f, 0.03192875f, -0.03544968f, 
    -0.10368168f, 0.01833420f, -0.00798830f, 0.03137790f, 0.08008669f, -0.06474145f, -0.00071468f, 0.04776440f, 
    -0.06113584f, -0.13353506f, -0.07789560f, -0.03213681f, 0.00315748f, -0.06997494f, 0.09398543f, 0.15382551f, 
    0.00349628f, -0.01750766f, 0.02016494f, 0.02352190f, -0.22051474f, 0.23732433f, 0.07626982f, 0.13762872f, 
    0.06062767f, -0.00997048f, -0.00492868f, 0.09666376f, -0.03485445f, 0.04942052f, -0.00209163f, 0.09641711f, 
    0.53977925f, 0.05506235f, 0.10720927f, -0.04736892f, -0.11411812f, 0.03876607f, -0.02376640f, 0.08630176f, 
    -0.05677480f, 0.01354838f, -0.07462870f, -0.00512960f, 0.09741792f, 0.30848581f, -0.19976516f, -0.03105567f, 
    0.07891460f, 0.02355465f, -0.02804010f, 0.00237670f, -0.05871414f, -0.01114237f, -0.00422222f, -0.00625492f, 
    -0.43387368f, -0.11224824f, 0.12286761f, 0.02253203f, -0.00574366f, -0.03679081f, -0.08269950f, -0.02791241f, 
    -0.01377495f, 0.02831159f, -0.05040457f, -0.00979708f, 0.18720683f, 0.00897865f, 0.07191244f, -0.02590663f, 
    -0.04934466f, -0.11196930f, 0.06950802f, 0.07610819f, -0.07161845f, 0.00866997f, 0.00069803f, 0.00423618f, 
    -0.42168316f, -0.02156594f, 0.01373462f, -0.02093915f, 0.05744475f, 0.02075246f, 0.15670814f, -0.01412227f, 
    0.06456235f, -0.12930977f, -0.02129754f, 0.13020030f, -0.12269747f, 0.08110096f, 0.09127099f, 0.04132570f, 
    0.06890492f, 0.03940742f, 0.05754976f, -0.07327747f, 0.09946331f, 0.09634797f, 0.06987583f, -0.03045597f, 
    0.37295195f, 0.06171371f, 0.04188857f, -0.04972072f, -0.01353355f, 0.03333319f, 0.06639675f, 0.10872542f, 
    0.09088554f, 0.05855878f, -0.00788683f, 0.03742541f, -0.33300686f, 0.32788041f, 0.03325812f, -0.12871391f, 
    0.03577361f, -0.01613281f, 0.06286931f, 0.01513742f, 0.10491542f, -0.08066846f, -0.06788204f, 0.03444269f, 
    0.11564773f, 0.20963843f, -0.02699531f, -0.05925449f, 0.03138029f, -0.01476459f, 0.03678264f, 0.06669785f, 
    0.14915340f, 0.02582509f, 0.02309842f, 0.05858525f, 0.15737379f, -0.02153594f, -0.00051010f, 0.12766531f, 
    -0.01655043f, 0.01728576f, 0.03391018f, 0.05431431f, -0.01723941f, -0.00409671f, -0.04421541f, -0.08389964f, 
    0.01344126f, 0.18708561f, 0.07287183f, 0.07610983f, 0.08777319f, 0.08088633f, 0.01496041f, 0.00255915f, 
    0.04995970f, 0.18063796f, -0.04227187f, 0.07788350f, 0.02332470f, 0.03572462f, 0.03010183f, -0.15017149f, 
    0.02252553f, 0.04649415f, 0.09762553f, 0.00855066f, -0.00703614f, 0.01526277f, -0.01352165f, -0.02185760f, 
    -0.08083544f, -0.17546169f, -0.03233247f, 0.07545612f, -0.00090649f, -0.03135785f, -0.04170407f, 0.00712022f, 
    0.14482903f, 0.02792600f, 0.02925538f, 0.10507213f, -0.12908837f, -0.17190009f, -0.04898443f, -0.11232868f, 
    -0.02666843f, -0.02211876f, -0.00721824f, 0.02714290f, 0.01079700f, 0.00507352f, 0.00662546f, -0.04835773f, 
    0.13107236f, -0.29847071f, -0.10547464f, -0.01366593f, 0.16038275f, 0.01403990f, 0.05648580f, 0.07680875f, 
    0.02136553f, -0.00666432f, -0.00184326f, -0.01162918f, 0.08634205f, -0.20598698f, -0.05910762f, -0.01662198f, 
    -0.06039940f, 0.05910205f, 0.01588065f, 0.09134238f, -0.02857051f, 0.01414140f, -0.00886348f, 0.11453085f, 
    0.18003923f, 0.09849195f, -0.05912476f, 0.18961734f, -0.09381273f, -0.00823991f, 0.01574379f, 0.01911803f, 
    -0.01909918f, 0.05690194f, -0.11915714f, -0.08046551f, -0.01787515f, -0.03911296f, 0.09826075f, -0.21095581f, 
    -0.03305915f, 0.00744269f, -0.03779491f, -0.19680849f, -0.04897946f, 0.00275720f, 0.04545335f, -0.09180165f, 
    0.14165051f, 0.07061753f, 0.10203161f, -0.04281564f, 0.05455803f, 0.19884878f, -0.02886369f, 0.03336511f, 
    0.00521306f, 0.05637073f, -0.00973548f, -0.04925924f, 0.23564474f, -0.11367530f, 0.19499786f, 0.04535428f, 
    -0.06542855f, -0.06315845f, -0.00316156f, -0.03976891f, 0.17298990f, -0.10365860f, -0.01997177f, -0.05300368f, 
    0.10209209f, 0.18780260f, 0.00357264f, -0.14457019f, 0.10477133f, 0.08700515f, -0.10578167f, 0.02082179f, 
    0.02314677f, 0.02723794f, 0.04726044f, 0.02744115f, 0.30273756f, 0.10073609f, -0.05841348f, 0.01451530f, 
    0.03515445f, 0.05827108f, 0.01190851f, -0.06903588f, 0.07916243f, 0.02375930f, -0.04549402f, -0.01714467f, 
    0.01553411f, 0.10696591f, -0.15725292f, 0.07536058f, -0.01036565f, 0.03249201f, 0.18104890f, -0.01495515f, 
    0.00149790f, -0.06052741f, 0.01726298f, -0.03616275f, 0.15412626f, -0.10674323f, -0.05948287f, -0.10097372f, 
    0.02320515f, -0.07561738f, -0.11085537f, 0.00818506f, 0.09809603f, 0.14249058f, 0.10893580f, -0.10142844f, 
    0.24771419f, 0.11148076f, -0.03697267f, -0.11102040f, 0.04702768f, 0.09797300f, 0.03366328f, 0.06553961f, 
    0.09528290f, -0.06092430f, -0.05538490f, -0.07784275f, 0.05720539f, 0.09289403f, 0.05971362f, 0.09826217f, 
    0.07321467f, -0.00918482f, 0.11301197f, 0.02570905f, -0.03994266f, 0.12634574f, -0.01633800f, -0.09888444f, 
    0.17474584f, 0.14893866f, -0.08831316f, -0.08967778f, -0.12396017f, 0.06596982f, 0.05974972f, -0.12718391f, 
    -0.03029720f, -0.03290696f, -0.09889064f, 0.06849564f, 0.49726582f, 0.09878100f, 0.03325455f, -0.05803223f, 
    -0.19776769f, -0.02000446f, -0.05860110f, 0.04991272f, -0.02965981f, -0.03773411f, 0.03941153f, -0.03827469f, 
    0.00962954f, 0.09904892f, -0.01145831f, -0.32382894f, 0.02653634f, -0.05013006f, 0.09253393f, 0.00784840f, 
    0.00805161f, 0.08185129f, 0.06416941f, -0.14326961f, -0.16592579f, -0.06342936f, -0.06262287f, -0.03460772f, 
    0.06156840f, -0.02686715f, 0.15384066f, 0.10924668f, 0.00110322f, 0.02002418f, 0.17791955f, -0.12066320f, 
    0.14027868f, -0.16824146f, -0.04076796f, 0.12559147f, -0.04965745f, -0.10069466f, 0.01494123f, -0.10926863f, 
    0.01841769f, 0.00612861f, 0.11130836f, 0.13321835f, -0.05641572f, -0.16498551f, 0.07194810f, 0.07054268f, 
    0.00109134f, 0.08839820f, 0.14574328f, 0.06670908f, -0.06971584f, -0.02227994f, 0.07449141f, 0.06978253f, 
    0.12443376f, 0.02219995f, -0.04666368f, 0.03213949f, -0.23760481f, 0.16129918f, -0.03932392f, -0.00989228f, 
    -0.11860221f, 0.18963249f, 0.05614048f, 0.03098992f, 0.03433182f, 0.01407408f, -0.14093298f, -0.00235602f, 
    0.07338555f, 0.01365918f, 0.02838940f, 0.09618055f, 0.01925156f, 0.15831514f, 0.04141618f, -0.00370956f, 
    0.28677920f, -0.18874538f, -0.03348705f, -0.08079824f, 0.04665726f, -0.09024940f, -0.05815215f, 0.03775599f, 
    0.15359408f, 0.13786384f, 0.11895585f, 0.11710022f, 0.17259580f, 0.08805527f, 0.17987634f, 0.00655504f, 
    -0.09046091f, -0.05866865f, -0.05251647f, 0.04040837f, 0.07748920f, -0.12260700f, 0.09182115f, -0.07636613f, 
    0.03613783f, 0.15915796f, 0.09547373f, 0.03633112f, 0.05317915f, -0.02420894f, 0.01478531f, -0.04282776f, 
    -0.02938711f, 0.03693637f, 0.04705963f, 0.03452716f, -0.11279925f, -0.27500379f, 0.08171216f, -0.03531701f, 
    -0.07428524f, -0.05744543f, 0.05342196f, 0.06899965f, 0.12662879f, 0.02207072f, -0.05794859f, 0.07515683f, 
    -0.28227034f, 0.00670861f, 0.07612662f, 0.16425566f, 0.06095399f, -0.06850833f, 0.04665123f, 0.05686719f, 
    0.01605719f, -0.05018541f, -0.00614251f, 0.04325807f, -0.06676947f, -0.04328433f, 0.11086097f, -0.03506370f, 
    -0.11995770f, 0.04361465f, 0.00130796f, -0.02266185f, -0.09260095f, -0.10354790f, -0.05640024f, 0.12592883f, 
    -0.30231267f, -0.05323340f, -0.00325798f, 0.16251586f, 0.01811647f, 0.05161937f, -0.00846181f, 0.11734432f, 
    0.11448312f, 0.00309946f, 0.13777661f, 0.02319589f, 0.32137990f, -0.04931486f, -0.00003458f, -0.04317172f, 
    -0.09001072f, 0.05362370f, 0.01780875f, 0.08766419f, 0.05823405f, -0.00218311f, -0.01566110f, -0.03677569f, 
    0.24713790f, 0.15846585f, -0.02524303f, 0.01685581f, 0.02948679f, 0.07798409f, -0.04417399f, 0.02992093f, 
    -0.02381393f, -0.12157045f, 0.02386053f, -0.14267591f, 0.13944390f, -0.14153297f, -0.11448914f, -0.04559925f, 
    -0.00687977f, -0.08678295f, 0.06240437f, -0.02989989f, 0.01101784f, 0.06512662f, 0.03402797f, 0.04053427f, 
    -0.10562591f, -0.08092546f, 0.07337553f, -0.12360234f, 0.00379572f, 0.04099990f, -0.06843363f, 0.04427420f, 
    0.02470445f, -0.03123763f, 0.05307216f, -0.01175297f, -0.29498717f, 0.02037217f, 0.06354277f, -0.06174054f, 
    0.12221792f, 0.07459074f, 0.09730285f, -0.02291166f, -0.08678863f, 0.13667446f, 0.08545239f, 0.14320408f, 
    0.05354838f, 0.29162601f, -0.03883678f, 0.03552489f, 0.13325560f, 0.05047202f, -0.02891113f, 0.04117352f, 
    0.17631921f, 0.00793110f, -0.07270029f, -0.02480327f, -0.01912982f, 0.06588709f, -0.20886956f, -0.04888612f, 
    0.01479468f, -0.00698303f, 0.05329829f, -0.01543960f, -0.01469570f, 0.05631467f, -0.02982090f, 0.05651082f, 
    -0.15367448f, 0.01305864f, -0.13455278f, 0.06921522f, 0.05601184f, -0.01670026f, -0.00354142f, -0.12138169f, 
    0.13900843f, -0.00902678f, 0.01353569f, 0.05885569f, 0.06693013f, 0.27413148f, 0.05135272f, -0.15396850f, 
    0.14499652f, 0.05854078f, -0.01183815f, 0.04150236f, 0.14527951f, -0.00573965f, -0.02166063f, -0.09822574f, 
    0.03614757f, 0.16376163f, 0.06587709f, -0.11371537f, -0.01302515f, -0.06791029f, 0.12174549f, 0.00530968f, 
    0.01743964f, -0.04321783f, 0.09995750f, -0.04340755f, 0.26463532f, 0.01264464f, 0.00528747f, -0.03846463f, 
    0.07148044f, 0.08960047f, 0.11881736f, -0.00271307f, 0.05715109f, -0.02683214f, 0.07569502f, 0.07049376f, 
    -0.04272651f, 0.00114723f, 0.18829620f, -0.11853971f, 0.05920506f, 0.04967067f, 0.07581117f, 0.14903152f, 
    0.10944002f, 0.00403878f, 0.06562042f, -0.00385286f, -0.04519127f, -0.03233317f, 0.10527287f, -0.04317220f, 
    -0.11957955f, -0.11705489f, -0.03967962f, -0.00579109f, -0.00255510f, -0.03722035f, -0.18654650f, 0.06716280f, 
    -0.17464034f, 0.15913735f, -0.06149522f, 0.12111745f, -0.04930943f, 0.03658213f, 0.03557818f, -0.00603326f, 
    -0.02691700f, -0.05089219f, 0.07391436f, -0.00419951f, -0.12772273f, 0.01232929f, -0.00833454f, 0.05126841f, 
    -0.05007383f, -0.00736638f, 0.00052088f, 0.04820172f, -0.04613358f, -0.00395422f, 0.03197596f, -0.09019387f, 
    0.02377598f, -0.08820964f, 0.20214100f, 0.20516908f, 0.01273481f, 0.01561156f, -0.08778290f, -0.05107699f, 
    -0.03166481f, 0.02605870f, 0.05239812f, -0.04828233f, 0.07953304f, 0.16889341f, 0.05805500f, -0.21832491f, 
    0.04973092f, 0.00751392f, 0.07218882f, 0.02173272f, 0.07366738f, -0.04686603f, -0.07114777f, -0.02183314f, 
    0.05587076f, -0.09361644f, -0.04384099f, -0.14861229f, -0.00276393f, -0.04146683f, -0.06878686f, -0.03681184f, 
    -0.01540507f, 0.01236170f, -0.07038903f, -0.03817689f, -0.02418462f, 0.33333266f, -0.19233780f, -0.08345810f, 
    0.15104757f, 0.02372702f, 0.03065344f, 0.11219314f, 0.14631361f, -0.00318113f, 0.03534607f, -0.00430895f, 
    0.11033295f, 0.09594872f, -0.09571224f, -0.02295605f, 0.08798517f, 0.05627638f, 0.02112158f, 0.16623275f, 
    0.10488669f, -0.06859589f, 0.04904731f, -0.01647672f, 0.10488929f, 0.00235508f, -0.10845594f, 0.07252089f, 
    -0.05549491f, 0.08268984f, -0.01075508f, 0.10404243f, 0.00211358f, 0.08559956f, 0.05424006f, 0.00951800f, 
    0.08610305f, -0.15620968f, -0.04357520f, 0.06195124f, 0.04710213f, 0.07716779f, -0.03084351f, -0.04698186f, 
    -0.06402549f, -0.07590728f, 0.01495075f, -0.13075964f, -0.02321580f, 0.18936746f, 0.01930791f, -0.19992512f, 
    0.02344432f, 0.05952226f, -0.06321659f, 0.02185947f, 0.07172368f, -0.01719596f, 0.05234106f, -0.01013220f, 
    -0.04557060f, 0.18262264f, -0.15456867f, -0.12756376f, 0.09824336f, 0.01458624f, 0.02874161f, 0.11143572f, 
    0.10861014f, -0.00971121f, -0.05763417f, -0.02395563f, -0.39447832f, 0.15073085f, 0.12945390f, 0.05463987f, 
    -0.05224013f, -0.08723438f, 0.00522393f, -0.07558239f, -0.00240551f, -0.01144389f, 0.09016084f, 0.03161534f, 
    -0.06118758f, -0.04721183f, -0.00113724f, 0.10672157f, -0.02769232f, -0.00302442f, -0.02609497f, -0.07502978f, 
    -0.00858578f, 0.04872062f, -0.05714066f, -0.09517978f, 0.18125217f, -0.01368924f, 0.12929945f, -0.15340607f, 
    0.11685403f, 0.08080142f, -0.00495686f, -0.07678811f, -0.02305182f, 0.02606879f, 0.06842877f, 0.07204222f, 
    0.44499102f, -0.30798453f, 0.12391296f, -0.24031252f, -0.12989433f, 0.01304646f, 0.03293722f, -0.04274744f, 
    -0.11738157f, 0.12479550f, 0.02819940f, 0.03012908f, -0.11850566f, -0.06657576f, 0.04421657f, -0.15180144f, 
    -0.00297858f, -0.08200249f, 0.01005471f, -0.05735454f, 0.02430059f, -0.00572995f, 0.02427104f, 0.06758884f, 
    -0.25377575f, -0.20553777f, 0.07593244f, 0.07429565f, -0.04030945f, -0.00005486f, -0.07943998f, 0.05089697f, 
    0.07794774f, -0.07291102f, 0.07175621f, 0.08071519f, -0.16234715f, 0.33018497f, 0.13182230f, -0.18104008f, 
    -0.05383115f, -0.07780840f, 0.00946190f, 0.00571561f, -0.02887068f, 0.04926679f, -0.03311811f, 0.07992312f, 
    -0.01183237f, -0.08276126f, -0.00262021f, 0.16336669f, -0.07603078f, -0.04127660f, -0.00215157f, 0.04671395f, 
    0.08714193f, 0.05089070f, -0.00180342f, 0.11472584f, -0.13860318f, -0.06036180f, 0.07898307f, -0.09309107f, 
    -0.14941838f, -0.00107405f, 0.10093617f, 0.07688622f, 0.14540663f, 0.09706113f, 0.06501781f, 0.03145443f, 
    -0.04674730f, -0.01541168f, -0.19327489f, 0.17373180f, 0.00275544f, -0.05382254f, -0.05743614f, 0.02966612f, 
    -0.04239742f, 0.04382323f, -0.07345311f, 0.07375964f, 0.20084286f, -0.11241116f, 0.03120365f, 0.01210054f, 
    0.01426626f, -0.01489560f, 0.21380930f, 0.01325085f, 0.04262204f, 0.11856179f, 0.03397869f, 0.01959883f, 
    -0.07908117f, 0.12482904f, -0.06866176f, 0.17818329f, -0.03786275f, 0.00964313f, -0.00459637f, 0.01261206f, 
    -0.00063820f, 0.01321521f, 0.05204895f, -0.05947853f, 0.20327647f, 0.01680230f, -0.04927043f, 0.14878061f, 
    -0.05222536f, -0.05973352f, 0.06686549f, 0.05280478f, 0.03205612f, 0.05062668f, 0.07706948f, 0.08880596f, 
    0.16306463f, -0.39602125f, -0.02167105f, -0.18351282f, -0.07008003f, -0.06310360f, 0.12936901f, 0.03189031f, 
    -0.02792923f, -0.01346581f, -0.08258267f, -0.00217512f, -0.01449073f, 0.18532343f, -0.02550974f, 0.20631739f, 
    0.03336038f, 0.02943114f, -0.02523443f, 0.03886303f, 0.04731742f, 0.11146697f, -0.07698776f, -0.01433011f, 
    0.20350868f, 0.11647097f, 0.03881200f, -0.02816749f, 0.09283489f, 0.06641772f, 0.03233791f, 0.01582963f, 
    0.19472031f, 0.20060419f, 0.08524606f, 0.02564508f, 0.09232606f, -0.07814455f, -0.05519110f, -0.05459671f, 
    0.15535131f, 0.13529596f, 0.06808844f, 0.11093543f, 0.06898902f, -0.01886234f, 0.02653292f, -0.01934964f, 
    -0.04734537f, -0.08443732f, -0.13450728f, -0.03656837f, 0.12363060f, 0.05781773f, 0.11111975f, 0.02718049f, 
    0.03952337f, -0.02222367f, 0.00375081f, 0.00691286f, -0.17537519f, 0.09816044f, -0.23529857f, 0.04226551f, 
    0.08965973f, 0.03044471f, 0.02828084f, 0.04013983f, 0.06959705f, 0.06400668f, 0.07985918f, 0.01773797f, 
    -0.05532164f, -0.08230010f, -0.00210583f, 0.21162002f, -0.02788254f, -0.02636027f, 0.00184688f, 0.00528792f, 
    -0.02660006f, -0.05116465f, -0.04792177f, -0.08957194f, -0.33604488f, -0.13818333f, 0.01540567f, 0.21430624f, 
    0.02192491f, -0.12140676f, -0.02068530f, -0.00730580f, -0.03994487f, 0.01131983f, 0.00394565f, 0.17327288f, 
    0.18553737f, -0.09455229f, 0.03608860f, -0.32093191f, 0.17605665f, -0.01392144f, -0.01022478f, -0.10539358f, 
    0.00093055f, 0.00228327f, 0.00137734f, 0.07980318f, 0.19405679f, -0.03471063f, 0.13119934f, 0.14356880f, 
    -0.14782412f, -0.02003677f, -0.02151202f, 0.06006708f, 0.01210390f, 0.07558655f, 0.03215279f, 0.04748542f, 
    -0.12350459f, -0.00263135f, 0.14780194f, 0.04603267f, 0.03331339f, -0.01621387f, 0.09174281f, 0.11863022f, 
    -0.00533050f, 0.17432061f, 0.04808580f, -0.00727276f, 0.18570702f, -0.10630642f, 0.09546879f, 0.12551351f, 
    -0.13045013f, -0.07641427f, 0.07109170f, 0.07901195f, 0.15804249f, 0.05535260f, 0.04051508f, 0.05336212f, 
    -0.16765404f, 0.13953309f, -0.07472105f, 0.01050462f, 0.01688326f, 0.12327503f, -0.03038351f, -0.02889612f, 
    -0.03207355f, 0.02648807f, -0.04571565f, -0.01396202f, -0.03763836f, 0.06815289f, -0.06012149f, -0.17245078f, 
    0.11618352f, 0.11906643f, 0.07603958f, 0.00496016f, -0.04067168f, -0.06281275f, -0.07393600f, 0.05428863f, 
    0.11380261f, 0.00037158f, 0.18983689f, -0.20741236f, 0.00971079f, -0.02675914f, 0.11340117f, 0.03413539f, 
    -0.02431435f, 0.00547974f, -0.06983141f, -0.12390018f, 0.14873450f, 0.14920475f, -0.00031766f, 0.14498635f, 
    -0.13220266f, 0.04733529f, -0.01009879f, 0.02273967f, 0.06738792f, -0.00249686f, 0.06457692f, -0.02467962f, 
    -0.10973796f, 0.17972250f, 0.00027405f, 0.20872277f, 0.00795607f, 0.09577376f, 0.00453566f, 0.08476699f, 
    -0.01550121f, 0.00988893f, -0.01792988f, -0.02122369f, 0.33122051f, -0.19744056f, 0.04244102f, 0.05932429f, 
    0.05145226f, 0.02942429f, -0.07055695f, -0.05890162f, 0.05047942f, 0.08013899f, -0.01859126f, 0.01012041f, 
    -0.14863783f, 0.05287179f, 0.03452566f, 0.16570152f, 0.10097198f, -0.04849236f, -0.01998638f, -0.00475958f, 
    0.03176187f, 0.06768242f, -0.11912809f, -0.02216153f, -0.04513214f, -0.01748634f, 0.06606145f, 0.17470826f, 
    -0.11895078f, 0.02390458f, 0.00942231f, 0.05110297f, 0.07367599f, -0.04215795f, -0.02428072f, -0.00170559f, 
    0.17470068f, -0.08165989f, 0.21564497f, 0.28690431f, -0.29956540f, 0.03228150f, 0.00760976f, 0.08813573f, 
    0.00679536f, 0.05622491f, -0.04198534f, 0.02990460f, -0.33652186f, 0.04300914f, -0.01274048f, -0.04868108f, 
    -0.13304780f, 0.03961573f, 0.01429867f, 0.07637823f, -0.06242048f, 0.11743368f, -0.07825508f, 0.02495418f, 
    -0.17927586f, 0.04703562f, 0.04725055f, 0.07929935f, -0.06589457f, 0.08006485f, -0.04132047f, -0.01060640f, 
    0.03038234f, 0.17337506f, 0.03981552f, 0.21333267f, 0.22615722f, -0.21130951f, 0.01357889f, 0.01796937f, 
    0.06259776f, -0.05653885f, -0.02235558f, 0.09561787f, -0.00925084f, -0.03459646f, -0.08188426f, -0.01755479f, 
    0.14760670f, -0.08757692f, -0.06329036f, -0.11967617f, -0.02444405f, -0.08841100f, -0.08062717f, -0.07772277f, 
    0.02577455f, 0.18191263f, 0.04990930f, 0.12663986f, -0.05174513f, 0.12110366f, 0.31340203f, -0.06603260f, 
    0.05165454f, 0.07774804f, -0.04945837f, 0.09927618f, 0.05823796f, 0.04423758f, 0.06133028f, 0.14337537f, 
    0.19119745f, -0.23772345f, -0.08636571f, 0.08215646f, -0.01072524f, -0.02851900f, -0.07705524f, -0.01499848f, 
    0.10717073f, 0.02985615f, -0.10092575f, 0.06707040f, 0.08918419f, 0.12264851f, 0.09607556f, -0.27139193f, 
    -0.01418351f, 0.04210098f, 0.06338281f, -0.03905504f, 0.11623276f, -0.01631933f, -0.04932295f, 0.07951837f, 
    -0.08013282f, -0.08515634f, 0.07026786f, 0.05103707f, 0.05832763f, 0.00865483f, -0.02730818f, 0.02714658f, 
    -0.01472163f, 0.11677418f, -0.07657134f, 0.10052621f, 0.09603523f, 0.00301007f, 0.02759485f, 0.08854454f, 
    -0.07038572f, -0.05958276f, 0.06040374f, 0.07559567f, -0.04044645f, 0.03101785f, 0.04478261f, 0.00452224f, 
    0.04207453f, 0.03322594f, 0.14390914f, 0.15327619f, -0.05693296f, -0.01848321f, 0.00311092f, 0.09051342f, 
    0.00878394f, -0.00442570f, 0.04232751f, 0.03822232f, 0.05258078f, -0.16607079f, 0.24767980f, -0.10508060f, 
    0.00951953f, -0.04223248f, 0.07524963f, 0.13339236f, -0.07786275f, -0.16652164f, 0.05326474f, -0.05210771f, 
    -0.22526868f, 0.06238407f, 0.03837188f, 0.05841477f, 0.01906257f, -0.05054094f, 0.00260142f, -0.02813059f, 
    0.01087191f, 0.01015439f, 0.00521498f, 0.04565126f, -0.19573985f, 0.30330393f, 0.11672810f, -0.23775034f, 
    -0.12302305f, 0.09505803f, -0.02527791f, 0.08558653f, 0.15787175f, -0.11667937f, -0.02865346f, -0.08949265f, 
    0.22146374f, 0.11898166f, 0.02633750f, 0.04698574f, -0.03657779f, 0.03738599f, 0.03544898f, 0.11082352f, 
    0.08840341f, -0.16007201f, -0.01489479f, -0.21280259f, 0.18682936f, 0.16812904f, 0.18836820f, 0.09231072f, 
    -0.07766493f, -0.05933490f, -0.00148330f, 0.06907525f, 0.04521492f, -0.02971167f, 0.02375927f, -0.04202261f, 
    0.01150966f, -0.09286791f, -0.12639989f, -0.19073379f, 0.07571186f, 0.05366966f, -0.00983262f, 0.02537936f, 
    0.02906371f, 0.06081941f, 0.01960106f, 0.14494179f, 0.02608484f, -0.02258234f, 0.20168371f, 0.12225129f, 
    -0.13150671f, -0.01631003f, 0.00868459f, 0.00172255f, -0.02358682f, 0.01411835f, 0.01215967f, 0.14293775f, 
    0.18423650f, -0.17523929f, 0.18003368f, -0.05656389f, -0.06016567f, 0.07281721f, -0.09249231f, 0.05226999f, 
    0.02823186f, -0.10157356f, -0.16146383f, 0.09242975f, -0.15500855f, -0.00416065f, -0.05337531f, 0.21543758f, 
    0.03358686f, 0.03094846f, 0.11279411f, -0.02106246f, 0.14645855f, 0.03708567f, -0.04005421f, 0.09778300f, 
    -0.00009137f, -0.02769968f, 0.00015595f, 0.02907379f, 0.01850241f, -0.00974593f, 0.02102184f, 0.02289417f, 
    -0.02786600f, -0.01642860f, 0.01528697f, -0.00173778f, -0.00187536f, -0.02565384f, 0.01662788f, -0.00846484f, 
    -0.02460155f, -0.00655066f, 0.02209614f, 0.02817947f, -0.01968510f, 0.03067228f, -0.00401751f, -0.03580405f, 
    0.02465687f, -0.00670819f, -0.03772334f, 0.00639771f, -0.00541341f, -0.01626178f, -0.02087232f, -0.01848922f, 
    -0.02152685f, -0.03955323f, -0.04116094f, 0.01695471f, 0.00391388f, -0.02171694f, 0.01308329f, 0.01536602f, 
    -0.01460968f, 0.02272953f, 0.01867670f, 0.02275126f, -0.04007316f, -0.03575772f, 0.02510526f, 0.01372966f, 
    0.01506074f, -0.04101330f, -0.00875957f, -0.00289401f, -0.01276475f, -0.01855074f, -0.02674484f, -0.02285301f, 
    0.01308620f, 0.03002220f, -0.03873396f, 0.00682084f, -0.01556788f, 0.01733538f, 0.00897939f, -0.00038609f, 
    -0.00834997f, -0.03423921f, -0.01991169f, -0.02560477f, -0.01774783f, -0.01971270f, -0.01362403f, -0.03713805f, 
    0.00864667f, -0.02566958f, 0.00867481f, -0.02192927f, 0.02800243f, -0.02586751f, -0.00339163f, 0.00151550f, 
    -0.03381979f, 0.00865350f, 0.00782112f, -0.03959447f, -0.03210420f, -0.03198306f, -0.03278530f, 0.02066325f, 
    -0.03699980f, 0.00215185f, -0.02796814f, -0.01985731f, -0.03154408f, 0.00424377f, -0.04052265f, -0.02615532f, 
    -0.00974490f, -0.02579494f, 0.00377383f, -0.00105954f, 0.00204980f, -0.00122414f, -0.00100349f, 0.02297919f, 
    0.00280714f, -0.03605574f, -0.00259332f, -0.03429217f, 0.00685097f, 0.01780975f, -0.03263346f, -0.01327114f, 
    0.02971524f, 0.00592093f, -0.01087013f, -0.02656097f, -0.01968800f, -0.01588315f, -0.00257797f, -0.03684127f, 
    -0.00212675f, -0.02296113f, 0.02761843f, 0.02334204f, -0.03318233f, 0.01742667f, -0.01772571f, -0.02759286f, 
    0.02617374f, -0.00502861f, -0.02009094f, -0.00636259f, -0.02663366f, -0.02453904f, 0.02676122f, 0.00596931f, 
    0.02511516f, 0.02141134f, 0.02695585f, -0.03934859f, 0.00806156f, 0.00939033f, 0.00482826f, 0.02868160f, 
    0.00364699f, -0.01468504f, 0.02205777f, 0.00956715f, -0.02502470f, -0.02897725f, -0.02740746f, -0.00542642f, 
    -0.01366016f, 0.01109875f, 0.02125911f, 0.00376641f, 0.00524673f, -0.02524914f, -0.00177942f, -0.01139976f, 
    -0.03554351f, -0.00150003f, -0.02985250f, -0.01742706f, 0.02518931f, 0.02273307f, -0.03084302f, 0.03403082f, 
    -0.03384571f, 0.03023061f, -0.03590886f, 0.02258780f, -0.00281439f, 0.02483100f, 0.02656826f, 0.01677848f, 
    0.01423422f, -0.00816032f, -0.02086565f, -0.00569110f, 0.02218135f, 0.00554876f, 0.01439321f, -0.02579483f, 
    0.01810658f, -0.01042799f, 0.02297394f, -0.02002435f, -0.01188101f, -0.02858176f, -0.01788589f, -0.02119658f, 
    -0.01826480f, 0.02921681f, -0.00138716f, 0.02264371f, 0.02107120f, -0.00318845f, -0.02533308f, -0.00955719f, 
    -0.02947400f, -0.01770359f, 0.02193204f, 0.02914654f, -0.01724853f, -0.02638098f, -0.04103552f, 0.02682017f, 
    -0.00494763f, -0.00775364f, 0.01136290f, -0.01413904f, -0.03982570f, -0.01650138f, -0.01923379f, 0.01251779f, 
    -0.01588243f, -0.02504535f, -0.02453172f, 0.02845737f, -0.03095222f, -0.00401314f, -0.00313294f, 0.01969931f, 
    -0.00194699f, -0.03097814f, -0.00349011f, -0.00130069f, -0.02473850f, 0.02773665f, -0.01037607f, 0.02184128f, 
    -0.03026751f, 0.02975431f, 0.03005318f, 0.00595169f, 0.02950927f, 0.01468816f, 0.02101811f, -0.02263951f, 
    -0.01994281f, -0.04040612f, -0.00115916f, -0.01563823f, 0.01240685f, -0.01796793f, -0.00195190f, 0.02456668f, 
    -0.02425678f, -0.03323510f, 0.00998157f, -0.01973958f, 0.02999129f, 0.00913887f, -0.03020070f, -0.02425772f, 
    -0.01371115f, -0.00765983f, 0.02818092f, -0.03604129f, 0.02296133f, -0.01193928f, 0.00663740f, 0.01239899f, 
    -0.03776421f, 0.00216562f, -0.03535489f, 0.01879847f, -0.01656990f, -0.02757584f, 0.00319447f, -0.00435441f, 
    -0.01865390f, 0.00876323f, -0.01716890f, -0.01626416f, 0.02522004f, -0.01017528f, -0.01628562f, -0.02007331f, 
    -0.04012363f, -0.02847931f, -0.00323813f, -0.02070231f, -0.01224204f, -0.01662517f, 0.03060546f, 0.02765003f, 
    0.01289078f, 0.02084812f, 0.02324323f, 0.00431014f, -0.02587266f, -0.01991053f, 0.01319769f, 0.00419017f, 
    -0.03551372f, -0.04035304f, -0.01495072f, 0.02549271f, 0.00054453f, 0.00529391f, -0.00562010f, -0.00839445f, 
    -0.03964287f, 0.01864829f, -0.02028539f, -0.03460723f, 0.02653857f, -0.01135666f, 0.02799007f, -0.02123524f, 
    0.00089815f, 0.02243443f, -0.02466160f, 0.00958657f, -0.03056948f, -0.04052366f, -0.03513887f, -0.01094289f, 
    -0.00220623f, -0.03175465f, 0.02112454f, 0.00694205f, 0.02418081f, -0.02084190f, 0.01789285f, 0.02403071f, 
    -0.03934762f, -0.03168861f, 0.02589046f, -0.04068768f, -0.02975869f, 0.01673535f, 0.02036534f, -0.00266908f, 
    -0.03416857f, -0.04076471f, -0.02480391f, 0.02216712f, 0.02185641f, -0.01096738f, 0.01146765f, -0.04127068f, 
    -0.03223221f, -0.01240053f, 0.00898768f, 0.01178407f, -0.03166599f, -0.00365929f, -0.00776426f, -0.01406467f, 
    -0.00423479f, -0.03008950f, 0.01852841f, 0.01410734f, -0.02355622f, -0.02266473f, -0.01840142f, 0.00739655f, 
    0.01914693f, -0.02790584f, 0.01804378f, 0.01989123f, -0.03164873f, -0.03620322f, 0.00570927f, 0.01171847f, 
    -0.03776678f, -0.00522130f, -0.01679547f, -0.02527179f, 0.00654153f, -0.00086238f, 0.02528712f, 0.02625650f, 
    -0.03621481f, 0.02284612f, -0.00181183f, 0.02943223f, -0.02218850f, -0.00129040f, -0.02350515f, -0.03051296f, 
    0.00097105f, -0.02943322f, 0.02637376f, -0.03539798f, 0.00267998f, -0.03132731f, -0.01429352f, 0.03045438f, 
    -0.01667704f, -0.00620747f, -0.03167376f, -0.01105456f, 0.02248983f, 0.01207020f, -0.02684935f, -0.03024643f, 
    -0.03195979f, -0.03973106f, -0.03764284f, 0.01380782f, -0.00403473f, -0.03580109f, -0.02279586f, 0.00629745f, 
    0.01142835f, -0.03905600f, -0.00771300f, 0.01741166f, 0.02658351f, -0.00761064f, -0.03282760f, -0.01072241f, 
    0.00772333f, -0.03263520f, -0.02194830f, -0.02756907f, -0.01592616f, -0.00059228f, -0.01068071f, -0.03533738f, 
    -0.00842344f, -0.03833160f, -0.02563296f, -0.03529219f, -0.03511825f, 0.00502607f, -0.00786937f, -0.02743081f, 
    -0.00316195f, -0.02928043f, -0.01044097f, 0.01512713f, -0.03830010f, 0.02376018f, -0.01540739f, 0.01615984f, 
    -0.02360944f, -0.00817417f, -0.01399788f, -0.02759472f, -0.03218253f, -0.02867974f, 0.00041051f, 0.00097712f, 
    0.01489118f, 0.00166934f, -0.02937622f, -0.02921104f, 0.00246053f, 0.02645857f, -0.01486393f, 0.02796697f, 
    0.00584471f, -0.02467706f, -0.01179759f, -0.02464532f, -0.00055629f, -0.00890998f, -0.02653340f, 0.00775467f, 
    -0.00220706f, 0.00962123f, 0.00258483f, -0.03007210f, -0.03392904f, 0.02515977f, 0.01091942f, -0.00249992f, 
    -0.01826891f, -0.03553625f, 0.00748243f, -0.03520136f, 0.02405676f, -0.01491708f, 0.01930012f, -0.02705163f, 
    -0.02203127f, -0.01564193f, -0.02217248f, 0.00124650f, 0.02611242f, -0.00485908f, -0.04084481f, -0.02470940f, 
    0.00067407f, -0.03325141f, 0.00728200f, 0.02710947f, 0.00144589f, -0.04019022f, 0.02330871f, 0.01935066f, 
    0.02575529f, 0.02876861f, -0.01070954f, -0.00844912f, -0.00370238f, 0.00631632f, 0.00177261f, 0.02390522f, 
    -0.03035516f, 0.01990060f, -0.00779995f, 0.01439535f, 0.01568021f, -0.00957896f, -0.00096476f, 0.00280992f, 
    0.01866101f, -0.02703122f, -0.01837721f, -0.01123447f, -0.01587595f, -0.01206852f, -0.02045864f, 0.00143236f, 
    -0.03488880f, -0.00309659f, 0.01048603f, 0.00356592f, -0.01156249f, -0.04003451f, -0.02568568f, -0.01051571f, 
    0.01430968f, -0.02895980f, 0.01547798f, 0.00912740f, -0.01509432f, 0.00375137f, -0.02711500f, -0.01768260f, 
    0.00657489f, -0.02702901f, -0.02189017f, 0.00432450f, -0.02956039f, 0.00099367f, 0.02416445f, -0.00204075f, 
    0.00456351f, 0.01994159f, -0.01028361f, 0.01795805f, -0.01847722f, -0.02891577f, -0.00573580f, 0.01347208f, 
    0.01711436f, -0.03820175f, -0.01839985f, -0.00350397f, -0.01278577f, -0.03567859f, 0.01852413f, -0.02551686f, 
    -0.03786281f, 0.00776251f, -0.03426258f, -0.03411161f, 0.02817964f, -0.00874570f, -0.00194235f, -0.02579080f, 
    0.02108193f, -0.01865612f, -0.00523936f, -0.01315945f, 0.00701969f, -0.01165687f, 0.00616397f, -0.01411052f, 
    0.02529108f, -0.01142777f, 0.01707503f, -0.01685679f, -0.03000100f, 0.00692208f, -0.01103693f, 0.00928669f, 
    0.01371644f, 0.01400641f, 0.00783278f, -0.00626198f, 0.00069949f, -0.03076911f, 0.01869722f, -0.02530401f, 
    -0.02918401f, 0.00403341f, 0.00654757f, -0.00054551f, 0.01994479f, -0.01240700f, -0.03971614f, 0.01118758f, 
    -0.01495152f, -0.01677768f, -0.01297369f, 0.02707681f, 0.00149158f, -0.01435408f, 0.02850919f, -0.01422087f, 
    -0.01036710f, 0.02046283f, -0.01389413f, 0.00108960f, -0.02423469f, 0.00502506f, -0.03433653f, -0.01004341f, 
    -0.02384853f, -0.00135398f, -0.00164037f, -0.00606587f, -0.00209985f, -0.03612823f, 0.00124596f, -0.01325158f, 
    -0.01693539f, 0.01965428f, 0.02724432f, -0.02498826f, 0.02640353f, 0.01759757f, 0.01109719f, -0.02418660f, 
    -0.02940686f, -0.02921318f, -0.00687555f, -0.02491732f, -0.00304938f, 0.01791179f, -0.01268467f, 0.03438509f, 
    -0.01059454f, 0.01600274f, 0.01832913f, 0.02815430f, 0.01950674f, -0.03251398f, 0.02902980f, 0.01368440f, 
    0.02431612f, -0.04095502f, -0.03169730f, -0.01971441f, -0.02320154f, -0.03789225f, -0.01018681f, 0.01367027f, 
    -0.02941147f, -0.01899348f, -0.00895794f, 0.00368983f, -0.01588062f, 0.02746490f, 0.00442068f, 0.01015004f, 
    -0.03672040f, 0.00085844f, -0.03486967f, -0.00814728f, -0.01816829f, -0.02003698f, -0.03862939f, -0.02170295f, 
    0.00530856f, 0.00986676f, -0.01475893f, 0.00478872f, 0.00200937f, -0.02841350f, 0.00440108f, -0.01381289f, 
    -0.00949946f, -0.02183098f, -0.03409938f, -0.03764276f, -0.02765107f, 0.00304166f, -0.01448304f, 0.00697917f, 
    -0.03215865f, -0.04096445f, -0.01389838f, 0.00590162f, 0.00487413f, 0.02237689f, -0.03765726f, -0.02088878f, 
    0.01912613f, 0.00643747f, -0.02500217f, -0.00439483f, 0.00952601f, -0.03054221f, 0.02369043f, -0.00321205f, 
    -0.01176131f, -0.00388814f, -0.02476794f, -0.00195305f, 0.01272651f, -0.03058789f, 0.01067114f, 0.03077525f, 
    0.01732470f, -0.01045771f, 0.00794390f, 0.02787970f, -0.01669043f, -0.01071351f, 0.02309657f, 0.01589506f, 
    0.01300450f, -0.03180559f, 0.01649292f, -0.02373691f, 0.02408783f, 0.02637106f, -0.03959091f, -0.01052976f, 
    -0.00776532f, -0.01389038f, 0.00094024f, 0.01177720f, 0.00074705f, 0.02775468f, -0.01880343f, -0.02839347f, 
    -0.01540904f, -0.03658653f, -0.02739163f, 0.02413093f, 0.02220049f, -0.02270280f, -0.03619869f, 0.01930795f, 
    -0.01307243f, -0.00031369f, 0.01934438f, 0.01226742f, -0.01507534f, 0.01098812f, 0.02899533f, -0.00716547f, 
    0.01400135f, -0.01696614f, 0.02724656f, 0.00674451f, -0.02123894f, -0.00884028f, -0.03503316f, -0.02962896f, 
    -0.02643742f, -0.02983150f, -0.03136497f, -0.01739641f, 0.01862753f, 0.00051921f, -0.00226775f, 0.01259379f, 
    -0.00642483f, -0.01158461f, 0.15488927f, -0.12795600f, 0.00941158f, 0.03999260f, 0.03531433f, 0.09951652f, 
    -0.02316316f, -0.02719907f, 0.03247815f, 0.05709435f, -0.07854048f, -0.07480088f, -0.05686774f, -0.14914331f, 
    0.03007601f, 0.03081244f, 0.01758591f, -0.02708744f, 0.00508778f, 0.04588154f, -0.03176342f, 0.09710056f, 
    0.17712089f, 0.06604254f, -0.02422045f, 0.02503737f, 0.05319891f, -0.06983727f, 0.05248070f, 0.02827855f, 
    -0.03949804f, -0.13785563f, 0.00629960f, -0.00566423f, -0.13825582f, -0.08028410f, 0.00414577f, 0.22002578f, 
    -0.06234031f, 0.01604502f, -0.01467362f, 0.02230748f, -0.03336376f, 0.06286234f, 0.04575416f, 0.01631925f, 
    -0.25947240f, -0.12964988f, 0.14978938f, 0.02773934f, -0.00103700f, 0.08847862f, 0.08932170f, 0.10874928f, 
    0.06837063f, 0.01860440f, 0.17883398f, 0.00525388f, 0.01407315f, 0.01290069f, 0.03819987f, 0.03931841f, 
    -0.13891715f, 0.04973967f, 0.07275511f, -0.01979501f, -0.03959146f, 0.01859947f, 0.00134921f, -0.01742953f, 
    0.24659556f, 0.10565449f, 0.19726767f, -0.05214243f, 0.01103210f, 0.06725956f, 0.14386016f, -0.02829508f, 
    0.03980369f, 0.07568067f, 0.03767947f, 0.02790044f, -0.26651466f, 0.05009703f, 0.06742943f, -0.22610500f, 
    0.04677179f, -0.01296103f, 0.01921438f, -0.01177970f, 0.00477750f, -0.05471326f, -0.04021392f, 0.06827580f, 
    -0.23303877f, 0.08073327f, -0.05455628f, -0.06702366f, -0.03559958f, -0.13979021f, 0.02270580f, -0.02475369f, 
    0.06485519f, -0.02232940f, 0.02408955f, 0.19671224f, -0.04667637f, -0.02252936f, 0.09794715f, 0.09946107f, 
    -0.06315346f, 0.00166456f, 0.12707613f, 0.06925786f, -0.03884556f, -0.00058054f, -0.06451926f, 0.01585118f, 
    -0.00549991f, 0.04055713f, -0.04094373f, 0.00026006f, -0.01271461f, 0.02412288f, 0.01756595f, 0.03669313f, 
    -0.01781396f, -0.00168607f, 0.03254165f, 0.00009721f, 0.06084391f, 0.00307418f, 0.04197199f, 0.12368543f, 
    -0.04760421f, 0.04048074f, 0.03477046f, 0.03248214f, -0.04684041f, 0.03663069f, -0.08714090f, 0.06024772f, 
    -0.12760125f, -0.08324135f, 0.06516906f, -0.02082543f, 0.10017537f, 0.07868884f, -0.01996049f, 0.03565524f, 
    -0.01045200f, 0.00569994f, 0.06965410f, 0.11535950f, -0.13892183f, 0.03348980f, -0.12538300f, 0.08305356f, 
    0.05912186f, -0.11161395f, 0.08197030f, 0.11081569f, 0.00828290f, -0.01758602f, -0.03219956f, -0.08758305f, 
    -0.13776067f, 0.17106792f, 0.05169826f, 0.22885531f, 0.02243799f, 0.11161402f, 0.00844355f, -0.05046453f, 
    0.02355603f, -0.02937014f, 0.09520869f, 0.09770969f, -0.16824622f, -0.06274717f, 0.13689949f, 0.03070201f, 
    0.03168156f, 0.05840632f, -0.01032936f, 0.08509313f, 0.00977406f, 0.03424552f, -0.04005798f, 0.02886765f, 
    -0.06321500f, 0.25481942f, -0.13794877f, -0.05135652f, 0.18802942f, -0.02977600f, 0.02549701f, -0.06425738f, 
    -0.07687540f, 0.08183187f, -0.04276261f, -0.14009747f, -0.01454612f, -0.00269690f, -0.05530826f, 0.25073132f, 
    -0.03407469f, 0.00952574f, 0.08015226f, -0.01088008f, 0.09101739f, -0.03426624f, 0.05127265f, -0.05275311f, 
    0.03427801f, 0.10833473f, -0.05046928f, -0.11425039f, 0.00351681f, -0.01984068f, -0.01031209f, -0.02216166f, 
    0.00858039f, 0.01426838f, -0.00881773f, -0.04939604f, -0.09551948f, 0.04856746f, 0.00509435f, -0.03539741f, 
    0.13365676f, 0.01994982f, -0.02024339f, 0.06208986f, -0.05753921f, 0.03676101f, 0.08675164f, -0.10366872f, 
    0.19473922f, 0.05372780f, 0.13799264f, 0.04795782f, -0.06061399f, 0.13631260f, -0.02800439f, -0.06963049f, 
    0.04036686f, -0.02217823f, 0.00190146f, -0.04300924f, 0.21379776f, -0.01994338f, -0.14235321f, 0.21055117f, 
    0.01393467f, 0.00500450f, -0.04095129f, -0.00981630f, 0.11172092f, 0.01420787f, -0.03066343f, 0.06680591f, 
    -0.17769799f, -0.06683055f, -0.00071441f, -0.27352956f, 0.05182989f, 0.00505361f, 0.04135355f, 0.08473445f, 
    0.04267072f, -0.03377789f, 0.00899264f, 0.14120735f, -0.19495301f, -0.03346643f, -0.02671197f, -0.17178805f, 
    0.09947067f, 0.03854932f, 0.04710968f, 0.06782679f, -0.09472006f, 0.03301863f, -0.00712636f, -0.01679411f, 
    -0.02449741f, 0.05199150f, -0.04674643f, 0.21801333f, 0.15413266f, 0.02917427f, 0.09736080f, 0.00331217f, 
    0.12449203f, -0.01238540f, 0.04162901f, 0.03274588f, -0.17988744f, 0.07415207f, -0.00379738f, -0.24227451f, 
    0.03049648f, -0.03165037f, 0.01845536f, 0.07275308f, -0.05546272f, -0.04560579f, 0.02268624f, -0.00522182f, 
    0.14631996f, -0.10730802f, 0.07914914f, 0.08535619f, 0.01949139f, -0.00024129f, 0.04186840f, 0.05604200f, 
    -0.09291742f, -0.05435503f, 0.00160977f, 0.08075047f, 0.07698870f, -0.09658821f, 0.00431866f, 0.11718968f, 
    -0.04568241f, -0.05346090f, 0.03976922f, 0.01322711f, 0.02773470f, 0.04905596f, -0.03127612f, -0.06353822f, 
    0.11224835f, -0.06265651f, -0.03122166f, -0.03022796f, -0.01660990f, -0.01200090f, -0.06772380f, 0.01245541f, 
    -0.05904210f, 0.04829482f, 0.02375468f, 0.12383361f, 0.01308931f, 0.11098652f, 0.04451993f, -0.04020175f, 
    0.03578267f, 0.03418580f, 0.02507275f, -0.02969415f, -0.00127354f, -0.05068825f, -0.00473427f, 0.02973853f, 
    0.04357556f, 0.23911318f, 0.16399889f, -0.13762505f, 0.03991657f, 0.03987101f, 0.01831152f, -0.00159341f, 
    0.09787215f, 0.05714530f, 0.08234875f, 0.11793428f, -0.04429914f, 0.17298704f, -0.02534124f, -0.08153984f, 
    0.07538455f, 0.05668366f, 0.01693412f, 0.03546594f, -0.00796769f, 0.03277247f, -0.01879887f, -0.06739756f, 
    -0.09488969f, -0.06378651f, 0.03359101f, 0.19585907f, -0.14386116f, 0.02145093f, 0.12684464f, -0.07286961f, 
    0.06322234f, -0.01944822f, -0.07663337f, -0.09228955f, 0.00883254f, -0.01605509f, -0.12618972f, -0.17433448f, 
    -0.00923972f, -0.00610641f, -0.01075901f, 0.02032847f, 0.05272515f, -0.04105355f, 0.01679276f, 0.05547794f, 
    0.11853749f, 0.04045293f, -0.10915618f, 0.15818922f, 0.02713638f, 0.00291167f, -0.03381146f, 0.09805685f, 
    0.07620813f, -0.10893171f, -0.04421999f, 0.09390074f, 0.04779790f, 0.08713818f, -0.00036168f, -0.06696142f, 
    0.00221368f, 0.03035625f, -0.00903813f, 0.01693186f, -0.03474455f, 0.03904547f, -0.05015228f, 0.00059203f, 
    -0.15938435f, 0.07846447f, 0.21002258f, -0.12163262f, -0.05035858f, -0.03785014f, 0.02253447f, 0.03019043f, 
    0.06250518f, 0.09203222f, -0.09748904f, 0.08991185f, -0.08827438f, 0.03936243f, -0.06691133f, 0.07489254f, 
    -0.01845252f, -0.02865169f, -0.00532123f, 0.05548431f, 0.06794392f, -0.00374443f, 0.06082593f, -0.06567848f, 
    0.18769434f, 0.00840318f, -0.18112962f, 0.11871260f, -0.03951206f, 0.01763149f, -0.04992579f, -0.07950265f, 
    0.07695035f, 0.08928056f, 0.02534792f, -0.02177157f, -0.22580798f, 0.06507127f, -0.12342859f, -0.09338621f, 
    0.08843810f, 0.05689624f, 0.00083465f, 0.12866771f, -0.02827436f, 0.08266284f, 0.05699431f, -0.03775885f, 
    -0.07059846f, -0.12005173f, -0.03674679f, -0.17001769f, 0.00825010f, -0.04217401f, 0.01571051f, 0.11083038f, 
    -0.01568758f, 0.00467657f, 0.01203455f, 0.09448974f, -0.31364742f, -0.06472038f, -0.11229335f, -0.04700712f, 
    0.14362040f, 0.03723244f, 0.10645311f, 0.04975947f, -0.04150798f, -0.11168201f, 0.04428410f, -0.01973145f, 
    0.13851415f, -0.10613770f, -0.14707702f, -0.05735816f, 0.00368438f, 0.12867807f, -0.05285547f, -0.09676249f, 
    -0.08117272f, -0.02690462f, 0.03074686f, -0.00886204f, -0.07645051f, -0.02330883f, 0.06088547f, -0.09467318f, 
    -0.00977038f, -0.01054544f, -0.01556063f, 0.02628613f, -0.01841510f, 0.03361932f, -0.05052711f, -0.00653111f, 
    0.06501160f, -0.00738968f, -0.07954125f, -0.16355199f, 0.10170119f, -0.01885800f, 0.00111700f, -0.03534801f, 
    0.09902380f, 0.04145935f, 0.09669148f, 0.03948539f, 0.05856166f, 0.15233566f, 0.13106488f, 0.08876579f, 
    0.08460388f, -0.04496855f, -0.00083632f, 0.07975426f, 0.10054031f, -0.09005236f, 0.14466301f, -0.10537553f, 
    0.05480878f, -0.01462724f, 0.05004507f, 0.09183715f, 0.07822857f, -0.01254052f, 0.02998645f, 0.09525769f, 
    0.00238366f, -0.09936688f, -0.01307469f, -0.14948478f, -0.23099375f, -0.07601761f, -0.04353736f, -0.01753099f, 
    0.08197449f, 0.01150990f, 0.05290456f, -0.01747400f, 0.09762508f, 0.04312370f, 0.02229747f, 0.02023524f, 
    -0.27214035f, 0.01003407f, 0.21455126f, 0.08260358f, 0.06123418f, 0.01444084f, -0.00312238f, 0.12699652f, 
    0.07431660f, -0.04546592f, 0.01135139f, -0.00581155f, 0.09211284f, -0.08876278f, -0.03485288f, 0.10310271f, 
    -0.05719206f, -0.01389790f, 0.10526528f, -0.02507625f, 0.00324503f, -0.09399730f, -0.01450623f, 0.02608569f, 
    -0.09996875f, 0.06607359f, -0.04920083f, -0.01361371f, 0.09138335f, 0.06848103f, 0.09603303f, -0.05355846f, 
    -0.06188731f, 0.02313122f, 0.12507741f, 0.00086442f, 0.09872926f, 0.02077936f, 0.07698686f, 0.05614196f, 
    -0.01640536f, 0.01828883f, 0.03466718f, -0.02754446f, -0.11247250f, -0.00383569f, 0.03341914f, -0.03649175f, 
    0.13850588f, 0.14608490f, -0.00098606f, 0.09720853f, 0.06540827f, 0.03461787f, 0.06289741f, 0.08244177f, 
    0.10619073f, -0.04539123f, 0.05785863f, 0.02980049f, -0.07306010f, -0.04323046f, -0.12370248f, -0.18401983f, 
    0.03409616f, -0.01502544f, 0.01131974f, 0.03016092f, 0.05535945f, -0.01616388f, -0.06959195f, 0.07091678f, 
    0.04306488f, -0.08846451f, -0.05566318f, -0.17630686f, 0.09249844f, -0.01642711f, 0.01490227f, 0.00746491f, 
    0.07515252f, -0.01681212f, 0.04637985f, -0.07414970f, -0.16882218f, -0.12199405f, -0.07837809f, 0.24181364f, 
    0.01670492f, 0.00732518f, 0.03403409f, -0.06542670f, 0.05186859f, 0.09996174f, -0.00201655f, 0.13046181f, 
    0.03907688f, 0.15810961f, 0.05609029f, 0.17929700f, 0.02682559f, 0.01676716f, 0.07055101f, 0.03984723f, 
    -0.02149172f, -0.03061030f, -0.01257891f, 0.02589799f, -0.02759092f, -0.02658773f, 0.11151356f, 0.15967348f, 
    0.06561155f, -0.08069181f, 0.00462849f, 0.00177137f, 0.05621327f, 0.13812968f, -0.00077166f, 0.08045206f, 
    0.00615491f, 0.09850388f, 0.11573706f, 0.20422608f, 0.03638779f, 0.04385226f, 0.13062690f, -0.10510300f, 
    -0.02580411f, -0.01301338f, 0.02477090f, 0.22733049f, 0.05688202f, 0.14433603f, 0.12067806f, -0.02061708f, 
    0.04875966f, -0.02516918f, 0.02238220f, -0.00909212f, 0.05215793f, 0.00686751f, 0.03398152f, 0.06253071f, 
    -0.13725765f, 0.20713384f, 0.00184476f, 0.01738393f, 0.12546915f, 0.01431543f, -0.00347826f, -0.04668862f, 
    0.07552335f, 0.07717648f, -0.03964318f, -0.14084332f, 0.20376414f, 0.01800512f, 0.00356454f, 0.29577872f, 
    0.01922056f, 0.06326704f, 0.00155132f, 0.06570610f, -0.07290643f, -0.02073137f, -0.01472618f, 0.04154025f, 
    -0.04736708f, 0.05581126f, -0.04287499f, 0.07412661f, -0.06910145f, -0.00645950f, 0.20727722f, -0.01213554f, 
    -0.02180060f, 0.08649199f, 0.11308704f, -0.01412228f, 0.16613966f, 0.03591459f, 0.02229975f, -0.09434354f, 
    -0.03080931f, 0.03872288f, -0.03084364f, 0.03231582f, -0.08193583f, -0.05402042f, 0.01976867f, -0.07791395f, 
    -0.02138863f, 0.02224072f, -0.03128759f, 0.00919638f, -0.04088158f, 0.03037123f, -0.01385458f, -0.00284546f, 
    -0.02020631f, -0.01800626f, 0.01122276f, 0.01215634f, 0.03141740f, 0.02743683f, -0.00117076f, -0.02392577f, 
    0.01957789f, -0.02233658f, -0.01297367f, -0.00945934f, -0.00340952f, 0.02305782f, 0.01620571f, 0.00744788f, 
    0.00739674f, -0.02971135f, -0.02646939f, 0.02087206f, 0.01380496f, -0.01385812f, 0.02616481f, 0.02525454f, 
    0.02768412f, 0.00414595f, 0.02778243f, 0.03074262f, -0.01010962f, -0.01712942f, 0.00715167f, -0.02831413f, 
    -0.03569416f, -0.00189537f, -0.04281003f, -0.00316155f, 0.02527975f, 0.02117801f, 0.00390857f, -0.03249669f, 
    -0.00156176f, 0.00988427f, -0.00494257f, 0.00509775f, -0.02321729f, -0.00190605f, -0.01698535f, 0.00964787f, 
    -0.03735644f, -0.03283514f, -0.03508510f, -0.02581110f, -0.03691994f, 0.00839183f, -0.04420405f, 0.01016470f, 
    -0.00368065f, 0.02088309f, -0.01743058f, -0.02519959f, -0.01294704f, -0.02153866f, -0.00210357f, -0.01389396f, 
    -0.03844915f, 0.00102168f, 0.00857002f, 0.01060223f, -0.00684947f, -0.02812723f, -0.01940363f, -0.02111013f, 
    0.00997757f, -0.02788703f, 0.01921635f, -0.04043731f, -0.02162515f, 0.00372580f, -0.00425405f, -0.00867161f, 
    0.01704990f, -0.01966451f, 0.01350034f, -0.00077136f, -0.03702181f, 0.02913378f, 0.01081372f, -0.02488538f, 
    -0.01768919f, 0.02391954f, -0.01212623f, 0.01951422f, 0.03014130f, -0.01945003f, -0.00967361f, -0.01551299f, 
    -0.02422392f, -0.03406701f, 0.01476067f, 0.02398336f, -0.01957311f, 0.01529449f, 0.01643859f, 0.01212039f, 
    0.02749575f, 0.00584077f, -0.03904602f, -0.01007415f, 0.01467781f, 0.01911337f, 0.00551660f, 0.02542098f, 
    0.00137555f, 0.00719034f, -0.02979402f, -0.02489922f, -0.02420426f, 0.00253844f, -0.03501251f, -0.00074965f, 
    0.00510468f, -0.01292249f, 0.02704015f, -0.01525681f, 0.01688896f, -0.01681648f, 0.02219994f, -0.00198311f, 
    -0.01045743f, 0.01409602f, -0.00745532f, 0.02382696f, 0.00168938f, -0.01645412f, 0.01718350f, 0.00419776f, 
    -0.02680439f, 0.00332899f, -0.00090246f, 0.00791806f, -0.02634131f, 0.00695309f, -0.02166413f, -0.03226625f, 
    -0.00783756f, -0.02415957f, 0.01929598f, -0.00402466f, 0.00514483f, -0.02761879f, 0.01314041f, 0.01841564f, 
    -0.03836994f, -0.03198551f, -0.01984140f, 0.00166144f, 0.01643311f, 0.02214789f, -0.00957018f, -0.03349065f, 
    -0.02078910f, 0.01616225f, 0.02722320f, -0.03780129f, -0.02949193f, 0.01348914f, -0.02056142f, 0.00633047f, 
    0.00807603f, -0.03567388f, 0.00894308f, -0.01850333f, 0.00226109f, -0.03239335f, -0.01945893f, -0.00026693f, 
    -0.01532952f, -0.00918837f, -0.01779009f, -0.00127650f, -0.02149053f, -0.03722079f, 0.00860614f, -0.01115524f, 
    -0.01838605f, -0.01374307f, -0.03622614f, 0.03221340f, 0.00249669f, 0.03272326f, 0.00049372f, 0.00466855f, 
    -0.01756745f, -0.02612719f, -0.04093377f, 0.03305040f, -0.01822111f, 0.00796790f, -0.04258830f, -0.03352101f, 
    -0.03562373f, -0.02082066f, -0.01115244f, -0.01281649f, 0.02481644f, -0.04106363f, 0.02664598f, 0.00563550f, 
    -0.00480909f, -0.00185489f, 0.03111880f, -0.00285410f, -0.01441107f, 0.01449203f, -0.01508754f, 0.03062164f, 
    0.02192452f, -0.00707637f, -0.01705889f, -0.02752461f, -0.02681573f, -0.02997295f, 0.01280393f, 0.03371814f, 
    0.00073720f, -0.00882501f, 0.03298832f, 0.02227259f, -0.00716499f, 0.02630135f, 0.02641647f, 0.03328713f, 
    0.02687875f, 0.02696755f, -0.00522551f, 0.02234728f, -0.03977144f, -0.02884202f, -0.00941192f, -0.02971735f, 
    0.02866559f, 0.01004309f, 0.02349932f, 0.03466251f, -0.03837008f, 0.01680512f, -0.00577984f, -0.03774981f, 
    0.01626385f, -0.03532772f, 0.02663519f, -0.03697433f, -0.00457203f, -0.00350767f, 0.02561709f, -0.00313281f, 
    0.01459952f, 0.01344736f, -0.00651393f, 0.01092901f, -0.02557633f, -0.00369863f, -0.02045756f, -0.00615683f, 
    -0.00392778f, -0.02830395f, 0.01589781f, -0.02707906f, 0.03481837f, -0.02253158f, 0.02995391f, -0.01734397f, 
    -0.02251547f, 0.01141665f, -0.00108902f, -0.03912542f, -0.00158882f, 0.00468956f, 0.00838643f, 0.00522812f, 
    -0.00848416f, -0.01005238f, 0.00970215f, -0.04095013f, 0.02249308f, 0.02079585f, 0.01510451f, -0.00784419f, 
    -0.03116933f, 0.02817548f, -0.03249884f, 0.02724919f, -0.02337202f, -0.02482934f, -0.00522219f, 0.00187397f, 
    -0.00048769f, 0.02675693f, 0.00400858f, 0.00800478f, -0.00737010f, 0.02702641f, -0.01472473f, -0.00831099f, 
    -0.00722708f, 0.00176968f, -0.02937825f, 0.00507347f, 0.02332397f, -0.00202630f, 0.00021056f, 0.00540910f, 
    -0.02347089f, 0.03262980f, 0.00887754f, -0.02561020f, -0.00229525f, -0.03825376f, -0.00039288f, 0.01533956f, 
    0.02927399f, -0.00755073f, -0.00717954f, -0.01666380f, 0.01742079f, 0.02540557f, -0.03099927f, 0.00149113f, 
    0.00805702f, -0.00165448f, -0.00146572f, -0.00275178f, -0.02077103f, -0.02268883f, 0.03122126f, -0.03063451f, 
    0.01581474f, -0.03243824f, 0.02519295f, -0.00549977f, -0.03148899f, 0.01769110f, 0.02202659f, -0.00479785f, 
    -0.00037322f, -0.03764912f, -0.00910028f, 0.00254376f, -0.03477645f, -0.01696449f, -0.02448334f, 0.01860365f, 
    -0.01919673f, 0.01132416f, -0.03864162f, -0.00452766f, 0.01089676f, -0.03132050f, -0.00922420f, 0.01037763f, 
    -0.04344326f, -0.03079352f, 0.00893207f, -0.03452286f, -0.01732472f, -0.02235408f, 0.01718287f, -0.00526520f, 
    -0.03495262f, 0.01309849f, 0.01379488f, -0.03788612f, -0.02510221f, 0.00544227f, -0.01421871f, -0.00530218f, 
    -0.03169625f, 0.01721032f, -0.02293104f, -0.00023601f, -0.00784309f, -0.04365901f, 0.01552805f, 0.02531408f, 
    -0.03871045f, -0.02832015f, 0.00243952f, 0.00601917f, -0.00717219f, 0.01367224f, -0.00666403f, -0.03478171f, 
    -0.03163503f, 0.03006102f, 0.01846543f, 0.01926662f, -0.00669405f, -0.01517450f, -0.03816601f, -0.03055475f, 
    -0.00891543f, -0.02023670f, 0.01560525f, -0.00545025f, -0.01273911f, -0.03339062f, 0.01282740f, -0.00978752f, 
    0.02395973f, 0.03803567f, -0.03020591f, 0.02061711f, 0.01759759f, 0.00959977f, -0.02080897f, -0.03482554f, 
    0.00468998f, 0.03215719f, -0.03175616f, 0.02292039f, 0.02407562f, -0.01000300f, -0.00062357f, 0.02235065f, 
    -0.03669809f, -0.01743087f, -0.01999936f, -0.02346456f, -0.03294023f, 0.01923459f, -0.03689231f, -0.00466814f, 
    -0.00036669f, -0.02596322f, -0.01162330f, 0.02330417f, 0.01541424f, 0.02561802f, -0.01037378f, -0.02201241f, 
    0.02220630f, -0.04461855f, -0.03386827f, 0.00924444f, 0.00083946f, 0.00797854f, -0.00931606f, 0.02190708f, 
    -0.04219283f, 0.00891803f, -0.04043165f, -0.00808950f, 0.01135495f, 0.02197651f, -0.03530960f, -0.01042889f, 
    0.02196863f, 0.02358160f, 0.02044320f, 0.02899028f, -0.00574876f, 0.02167826f, -0.01040448f, 0.03272518f, 
    -0.03301225f, 0.03525044f, -0.03850323f, -0.02282567f, 0.02384407f, 0.00430565f, 0.02997801f, -0.02281312f, 
    0.00141935f, -0.00243452f, -0.02207735f, 0.02394006f, 0.02016613f, -0.01129663f, -0.00729098f, -0.02783095f, 
    0.02150649f, 0.01667853f, 0.00721226f, 0.03540003f, 0.03005477f, -0.01159217f, -0.01947432f, 0.00023999f, 
    0.02543347f, 0.02591165f, -0.01425202f, 0.01646239f, 0.00033421f, 0.00066054f, -0.01369418f, -0.00611294f, 
    0.01549442f, -0.00885162f, 0.00035031f, -0.00569571f, 0.01815795f, 0.02007816f, 0.00439910f, 0.00594264f, 
    -0.01375809f, -0.02308401f, -0.01503315f, -0.02104399f, -0.01970507f, 0.01751881f, -0.03085062f, -0.00671746f, 
    -0.04386902f, -0.01764209f, -0.01657116f, -0.00415164f, 0.01391641f, -0.04145769f, 0.02696371f, 0.03294093f, 
    0.02418709f, 0.02114621f, 0.01644247f, -0.01115280f, -0.02593396f, -0.01624247f, 0.02159441f, 0.03219745f, 
    -0.02785667f, -0.00901984f, -0.00585543f, -0.00409482f, 0.03310544f, 0.02107229f, -0.02170104f, -0.02313399f, 
    -0.01800185f, 0.01880410f, -0.00700177f, -0.02327436f, 0.01319472f, 0.00643987f, -0.00348635f, 0.01333830f, 
    0.02292089f, -0.03620921f, -0.02560615f, -0.01666982f, 0.01265445f, -0.03354132f, -0.00549170f, -0.02735600f, 
    -0.02143378f, -0.00587597f, -0.00891823f, -0.03051475f, -0.00291431f, -0.03603635f, -0.01282559f, 0.03619833f, 
    0.01026176f, -0.01269968f, 0.01052243f, 0.02930144f, -0.01417403f, 0.03118594f, -0.03826850f, 0.00753823f, 
    0.01433563f, 0.01972762f, -0.01256406f, -0.00976465f, 0.00010910f, -0.01876430f, -0.01357882f, -0.00231870f, 
    -0.02093445f, 0.01550395f, 0.01922897f, 0.00653870f, 0.02688530f, 0.00027351f, 0.01447200f, 0.02246037f, 
    -0.01528891f, 0.02679971f, -0.01283364f, 0.02302556f, -0.00204904f, 0.01534950f, 0.01114301f, -0.03433168f, 
    0.03576447f, 0.02869176f, -0.01921867f, 0.00519311f, -0.02911921f, -0.03346545f, 0.01423468f, -0.00101162f, 
    0.01404053f, -0.03291167f, -0.03617768f, 0.02383564f, -0.03728139f, 0.01070386f, -0.02431152f, -0.02618870f, 
    -0.01311490f, -0.00217551f, 0.02458104f, -0.02464486f, -0.01290133f, 0.02882850f, -0.02815223f, 0.01054255f, 
    -0.03718623f, 0.02585011f, 0.02555948f, -0.03461718f, -0.00703138f, -0.02614390f, 0.01784502f, -0.03160283f, 
    -0.03746120f, 0.01496217f, -0.03182052f, -0.00558425f, -0.00533007f, 0.03312546f, -0.02205011f, -0.03979963f, 
    0.00413442f, -0.01283489f, -0.00156345f, -0.00095725f, -0.02435089f, 0.00249773f, 0.00288486f, 0.01637893f, 
    0.00506530f, 0.03123593f, 0.01443211f, 0.01007553f, -0.00796225f, 0.00523023f, -0.01726712f, -0.01651697f, 
    -0.00403289f, -0.00420287f, -0.00321355f, -0.01359824f, -0.02986638f, 0.00697018f, -0.02245805f, -0.00707546f, 
    -0.00207548f, -0.03655960f, 0.01829113f, -0.01390995f, -0.03783827f, 0.00250857f, -0.00998939f, 0.02057801f, 
    -0.00897696f, -0.03487076f, -0.02756498f, -0.00103307f, -0.00341905f, -0.00544481f, 0.00543462f, -0.03862025f, 
    -0.02006065f, -0.03354206f, 0.00222350f, 0.00489894f, 0.03503771f, 0.02399635f, -0.03035853f, -0.00405546f, 
    0.01207341f, 0.02108623f, -0.02672271f, 0.01933805f, 0.02583448f, -0.02551632f, -0.01974452f, -0.04076967f, 
    0.02327956f, -0.01801516f, -0.02811333f, 0.00589481f, 0.02937889f, 0.02233546f, -0.04263701f, -0.02727794f, 
    0.01155414f, -0.03592517f, 0.00854421f, -0.03838887f, -0.02977440f, -0.02591835f, -0.01806729f, -0.01995336f, 
    -0.02588006f, 0.02000071f, -0.02844494f, 0.00210513f, -0.00118174f, -0.02227879f, -0.01989823f, 0.00103167f, 
    -0.02540334f, 0.01248943f, -0.01095675f, 0.00531094f, 0.02417599f, -0.01996028f, -0.02601667f, 0.00719841f, 
    -0.01977399f, -0.00579833f, -0.01519511f, -0.01795305f, -0.01135628f, 0.02181532f, -0.00246508f, 0.02305467f, 
    -0.00209296f, -0.03815567f, -0.00904403f, 0.02058861f, -0.00512695f, 0.00272419f, -0.03732535f, -0.01953175f, 
    0.00144911f, 0.01754556f, -0.03008050f, 0.00872374f, 0.02345684f, -0.03012846f, 0.00097431f, 0.01255982f, 
    -0.02332448f, 0.02165975f, -0.01302958f, 0.02514182f, -0.04142724f, -0.03455207f, 0.01086942f, -0.02613635f, 
    -0.02618964f, -0.02467863f, -0.01496719f, -0.00850022f, -0.01613458f, -0.01123976f, 0.02965231f, -0.01479374f, 
    -0.06135037f, -0.12301625f, -0.17219946f, -0.03553266f, 0.07011094f, -0.01109446f, -0.07132655f, 0.05601895f, 
    -0.08123266f, 0.14054562f, -0.09370664f, 0.06630984f, -0.01969282f, 0.16341458f, 0.02598536f, 0.08028323f, 
    0.04067621f, -0.11466186f, -0.06363375f, 0.17741533f, -0.01225158f, 0.00909638f, 0.19599193f, 0.02611264f, 
    -0.27886316f, -0.00422695f, 0.03566995f, -0.19396953f, 0.01129159f, 0.01668975f, 0.00948505f, 0.12239509f, 
    -0.03545627f, 0.20006458f, -0.04330438f, 0.11536354f, -0.12832296f, 0.00424422f, -0.14178038f, 0.01273891f, 
    0.03611732f, -0.02040613f, -0.02486523f, 0.06668799f, 0.05869284f, -0.04235049f, -0.07831905f, -0.08950802f, 
    0.14034645f, 0.00919436f, -0.03709497f, 0.00985670f, 0.11266818f, 0.02032352f, -0.02207643f, -0.11086938f, 
    0.06503074f, -0.12404941f, -0.03628523f, -0.03745802f, 0.05163397f, -0.10884323f, 0.06148924f, 0.12987241f, 
    0.12566423f, 0.05789511f, -0.13443515f, 0.08504745f, 0.19585775f, 0.06436469f, 0.10036980f, -0.05050152f, 
    -0.17261280f, -0.19094352f, 0.14311334f, -0.05773744f, -0.02323292f, 0.06963289f, -0.00856945f, 0.14565665f, 
    0.09740611f, -0.02456342f, 0.04555469f, 0.02305464f, 0.23810117f, 0.20790823f, -0.06642789f, 0.11465878f, 
    0.10760894f, 0.04313606f, -0.00713385f, 0.16985589f, 0.00193666f, 0.10053504f, 0.00666798f, 0.03802446f, 
    -0.21243241f, 0.01345365f, 0.11610670f, 0.02170001f, -0.03532847f, 0.03435254f, -0.08531029f, 0.09606587f, 
    -0.00269167f, -0.11664899f, -0.10377546f, -0.06936712f, 0.34821194f, -0.20038550f, -0.06859148f, 0.09846541f, 
    0.03280079f, 0.07976095f, 0.01246299f, 0.04542655f, 0.14206618f, 0.07888497f, 0.13629919f, -0.03348552f, 
    -0.17899248f, -0.11051913f, -0.12171334f, 0.06660960f, 0.01353825f, 0.00971337f, 0.05892422f, -0.03318826f, 
    0.06839414f, 0.08943827f, 0.01358702f, -0.00804921f, -0.09444421f, -0.07998903f, 0.02305595f, -0.10525247f, 
    0.00417996f, -0.01613308f, -0.07273541f, 0.09210444f, 0.11132556f, 0.05570054f, 0.15719871f, 0.12306520f, 
    0.06981698f, 0.14014338f, 0.00742589f, 0.01384549f, 0.18341960f, 0.04813765f, 0.07979523f, -0.07205155f, 
    0.08515327f, 0.04455445f, 0.03470532f, 0.18810840f, -0.05796413f, -0.01059240f, 0.05168301f, 0.04153636f, 
    0.11327565f, 0.03316244f, 0.05833925f, 0.01858117f, 0.09258316f, -0.02776023f, 0.03997239f, 0.01516538f, 
    0.01688548f, -0.34858117f, 0.08164056f, 0.04060847f, -0.04783577f, 0.00881732f, -0.09709284f, -0.00326865f, 
    0.02005698f, 0.05190208f, -0.05666632f, -0.00593065f, -0.00931849f, 0.02480804f, -0.01242397f, 0.01257764f, 
    0.09865244f, 0.04433040f, 0.06714645f, 0.01767907f, 0.06295555f, -0.04932936f, -0.02303942f, -0.00341385f, 
    -0.38472340f, -0.21650985f, -0.21364096f, 0.03698393f, 0.08671739f, -0.09927338f, -0.15009190f, 0.08428580f, 
    0.03377839f, -0.12204127f, 0.11278003f, 0.02615405f, 0.18770157f, 0.04858481f, -0.01825690f, -0.10728904f, 
    -0.00805791f, 0.06943241f, -0.02533864f, -0.02504463f, -0.03000515f, 0.08723935f, 0.07436039f, 0.11706915f, 
    -0.19636486f, 0.00086104f, 0.21123511f, 0.00533088f, 0.08171012f, -0.00288396f, -0.04952775f, 0.01462724f, 
    0.03432418f, 0.07388660f, 0.01483869f, 0.15195574f, -0.13551915f, 0.14311734f, 0.01665035f, -0.04409224f, 
    -0.00265421f, -0.02919664f, 0.08380364f, 0.02777464f, 0.10473457f, 0.18666506f, 0.04413810f, 0.12554893f, 
    -0.10474297f, 0.01549178f, 0.12618732f, 0.06941491f, 0.04579080f, -0.10355560f, 0.07809040f, -0.00803076f, 
    0.05132280f, -0.07966128f, -0.07476112f, 0.06595549f, -0.02565629f, -0.10716719f, 0.12222941f, 0.11003819f, 
    0.00555099f, 0.06442785f, 0.13901924f, 0.06435033f, 0.08714994f, 0.14952517f, 0.07759257f, 0.08684622f, 
    0.27524987f, 0.25031868f, 0.00867479f, 0.08451184f, 0.11843534f, 0.04039639f, -0.08258295f, 0.08080895f, 
    -0.02578537f, 0.03773553f, 0.10942415f, -0.07355662f, 0.05976362f, 0.22805806f, 0.04152938f, 0.01892128f, 
    0.07137521f, -0.05203413f, -0.04917808f, 0.02812073f, 0.07779901f, -0.02542596f, 0.17645322f, -0.04704075f, 
    -0.11340270f, -0.02757876f, 0.05067244f, 0.03035381f, -0.02550926f, 0.07553885f, 0.08600765f, -0.04336089f, 
    -0.01348107f, 0.01176319f, 0.06523931f, 0.05799709f, 0.29787648f, 0.04899761f, 0.10126000f, 0.22147928f, 
    0.04485044f, -0.05856735f, 0.00462959f, 0.04772118f, 0.07106496f, -0.02992855f, -0.03081067f, 0.05408985f, 
    -0.25320745f, -0.14095198f, 0.06214214f, -0.09957369f, 0.05254973f, 0.09867878f, -0.03383487f, -0.02530038f, 
    0.07496136f, 0.12564412f, 0.05242441f, -0.00047493f, -0.02475222f, 0.10709523f, 0.01404565f, -0.00357158f, 
    0.15246361f, 0.10815387f, 0.09688493f, 0.11336818f, 0.11728074f, 0.03316385f, 0.07928182f, 0.23082578f, 
    -0.06699003f, -0.08423140f, 0.01244973f, -0.03619916f, 0.11925367f, -0.00140626f, 0.06777185f, 0.04963339f, 
    0.13497208f, 0.00288774f, 0.09140220f, 0.01304398f, -0.11467311f, 0.02450811f, -0.12353669f, 0.05799498f, 
    0.10808964f, 0.04685519f, 0.10582484f, 0.02783093f, 0.03114894f, 0.21423215f, -0.00612936f, 0.11220205f, 
    -0.20123449f, -0.14638211f, 0.32377893f, 0.05400828f, 0.08486187f, -0.02103241f, 0.04261148f, 0.08874903f, 
    0.07851706f, -0.01697184f, -0.05223862f, -0.02102977f, -0.29541910f, -0.15713890f, -0.03921103f, 0.07684452f, 
    0.01478883f, -0.00868420f, 0.04080689f, 0.08024942f, -0.05706353f, -0.04738428f, 0.03712885f, 0.17166601f, 
    -0.00050545f, -0.12056452f, 0.17536712f, -0.03321962f, 0.08721291f, 0.03062197f, -0.07166283f, 0.04926486f, 
    0.01211058f, -0.06281280f, 0.06015052f, 0.06134354f, -0.00832035f, 0.22523211f, 0.07042361f, -0.00049821f, 
    0.03002579f, 0.10224128f, 0.06460507f, 0.04500284f, 0.05567657f, 0.02543960f, 0.09845847f, 0.03084630f, 
    0.01863584f, 0.01647399f, 0.01291326f, -0.08828931f, 0.05055019f, 0.04394257f, 0.15447897f, 0.09832262f, 
    0.06150718f, 0.18859589f, 0.13476129f, 0.08507347f, -0.12242449f, -0.01421790f, 0.24248116f, -0.05523880f, 
    -0.01366895f, -0.05728046f, 0.03100258f, 0.03226585f, 0.12108606f, 0.06198046f, 0.09409662f, 0.08754718f, 
    -0.17441429f, -0.19979943f, 0.11275025f, -0.09449348f, 0.02254298f, -0.01067122f, -0.12008037f, 0.06336559f, 
    0.09464861f, -0.07460181f, 0.08365137f, -0.13971108f, -0.18285638f, -0.19078882f, -0.07675546f, -0.01553534f, 
    0.05526717f, 0.01288585f, 0.05836554f, -0.00342979f, 0.02061127f, -0.00577155f, -0.02799833f, 0.04664173f, 
    -0.02903193f, -0.12692222f, 0.08725026f, -0.03443029f, 0.05398794f, 0.09795526f, 0.02848408f, 0.04891467f, 
    -0.03075036f, -0.07087792f, -0.06683194f, 0.17636050f, 0.17578177f, 0.09873635f, 0.12877613f, 0.16601488f, 
    0.02255388f, 0.11747311f, 0.02658360f, -0.11830832f, 0.06828367f, -0.07577436f, -0.04431777f, 0.06321862f, 
    0.22163865f, 0.15368429f, 0.02730617f, 0.09407341f, 0.16177435f, 0.08049326f, 0.06090540f, 0.16375548f, 
    0.03115676f, -0.06350968f, -0.03329679f, -0.00133210f, 0.19778603f, 0.01626357f, 0.08397153f, 0.01592351f, 
    0.00812814f, -0.01344954f, -0.02395270f, -0.02841672f, 0.12882507f, -0.01079282f, 0.00812943f, 0.08013342f, 
    -0.07016357f, 0.07913700f, -0.04329951f, -0.12423559f, 0.08007898f, -0.13065778f, 0.05020631f, -0.05315031f, 
    0.13342689f, -0.00370459f, 0.05296164f, 0.10993963f, 0.04073741f, 0.10653059f, 0.06983070f, 0.19232029f, 
    0.00783885f, 0.13723670f, 0.03650483f, 0.04677368f, 0.12474101f, 0.02140808f, 0.10091113f, 0.12723437f, 
    -0.18562078f, 0.31031817f, 0.18094768f, 0.01495564f, -0.02543155f, 0.13380456f, 0.07351455f, 0.04149191f, 
    0.10459508f, -0.06460347f, 0.01054723f, -0.05908008f, 0.00659901f, 0.01269246f, -0.24043939f, -0.00039559f, 
    -0.03490724f, 0.12829833f, 0.08094961f, 0.03199759f, -0.04526470f, 0.03224893f, -0.15287445f, 0.20046237f, 
    -0.09214652f, -0.05762658f, -0.07355916f, -0.04179292f, -0.00260098f, 0.17427103f, -0.07272102f, -0.03938487f, 
    0.03178187f, 0.10262405f, 0.07626880f, 0.17999026f, 0.00060124f, 0.14869668f, 0.06669807f, 0.07679922f, 
    0.06804301f, 0.00876652f, -0.09118935f, 0.07099509f, -0.08922672f, -0.05626149f, 0.00102083f, -0.00875584f, 
    0.18239945f, 0.00385338f, -0.02038787f, 0.07724991f, 0.11045621f, 0.01526396f, 0.13126729f, -0.29673725f, 
    0.10471006f, 0.10476069f, 0.10074288f, 0.13683774f, 0.10791100f, 0.02829735f, -0.09838045f, -0.04188542f, 
    0.11228328f, 0.00851769f, -0.05065095f, 0.11210033f, 0.04123052f, 0.09095337f, 0.00636217f, 0.00117853f, 
    0.02040376f, -0.05973021f, 0.13784014f, 0.16702503f, -0.00857115f, 0.00602304f, 0.08230313f, -0.02855813f, 
    0.05336084f, 0.09258303f, -0.02646184f, 0.21437019f, -0.15282013f, -0.08601858f, -0.06312575f, 0.00673497f, 
    0.11808435f, -0.05750440f, 0.06284544f, -0.07668302f, 0.00756306f, -0.02801529f, -0.02318199f, 0.13223487f, 
    -0.04374548f, 0.03011275f, -0.01078004f, -0.09653080f, -0.05523123f, -0.00880462f, 0.10014267f, 0.01270739f, 
    -0.04012894f, 0.14990062f, -0.00842188f, 0.23211087f, -0.11132521f, 0.04801272f, 0.22186039f, -0.12397984f, 
    0.05993702f, -0.03718996f, -0.06133236f, -0.00798238f, 0.02047273f, 0.01740524f, 0.09040017f, 0.06936881f, 
    -0.01532704f, 0.18532179f, 0.14427806f, 0.09714284f, 0.05781733f, -0.01055373f, 0.01209358f, 0.02665424f, 
    0.12224526f, 0.06735186f, -0.00719652f, 0.15511046f, -0.06774353f, 0.03700083f, 0.15105073f, 0.01570775f, 
    -0.06670408f, 0.05021432f, 0.03075440f, 0.05079653f, 0.08130100f, -0.20778826f, -0.11282533f, -0.15821347f, 
    -0.01039073f, -0.09419046f, 0.04948703f, -0.19260168f, 0.03908084f, -0.01774866f, 0.04719043f, -0.04740335f, 
    0.07361923f, 0.04167264f, 0.09123874f, 0.12100647f, 0.00198492f, -0.15108912f, -0.08205531f, -0.06280415f, 
    -0.08471248f, 0.16476847f, -0.07615426f, -0.00306661f, 0.12159605f, -0.11615960f, 0.05494903f, -0.01457014f, 
    0.00601235f, -0.12103488f, 0.08349454f, 0.00397341f, -0.07404913f, -0.08754880f, 0.00270429f, 0.06893095f, 
    0.01850809f, -0.05849794f, 0.00970208f, -0.13504829f, -0.14101063f, -0.13717407f, 0.01894926f, -0.01035087f, 
    0.00257547f, -0.01195895f, -0.07376692f, 0.08866045f, -0.10127491f, 0.05602969f, -0.03156204f, 0.01031130f, 
    -0.06824863f, -0.05510966f, 0.05709788f, 0.00932103f, 0.10429744f, 0.09785497f, 0.03715563f, 0.09645558f, 
    -0.00452225f, -0.05184512f, 0.08765918f, 0.13398290f, -0.18691307f, 0.03646279f, 0.09189592f, -0.22000372f, 
    -0.06429338f, 0.08535541f, -0.00299389f, 0.07224552f, 0.10217455f, 0.00083179f, 0.00401155f, 0.13369001f, 
    0.04410046f, -0.03936407f, 0.07141317f, 0.00530902f, -0.00817362f, 0.03012471f, -0.07911563f, -0.03310840f, 
    -0.02015570f, -0.06924557f, -0.04206436f, 0.09814715f, -0.13269876f, 0.08462155f, 0.02616710f, -0.05005866f, 
    -0.03111865f, 0.10313028f, 0.20696548f, -0.04960303f, 0.17917000f, 0.07701392f, 0.05903132f, 0.10960495f, 
    -0.03771396f, -0.02328519f, 0.02512895f, -0.02417353f, 0.01921602f, 0.01725052f, -0.03144680f, -0.01890206f, 
    0.01689448f, -0.01731090f, -0.02720159f, -0.02976894f, 0.02594589f, -0.00505370f, 0.02553834f, -0.00906680f, 
    0.01911943f, -0.01502258f, -0.02851856f, 0.01256152f, 0.01254645f, 0.03316102f, 0.00847375f, 0.00308358f, 
    -0.03692912f, 0.01419118f, 0.00952162f, 0.02357007f, 0.01009260f, -0.01360415f, -0.01915066f, -0.01169236f, 
    -0.00555367f, -0.02108899f, 0.01088514f, 0.02260891f, 0.02193246f, -0.00747204f, -0.00220304f, -0.01855955f, 
    -0.01648947f, 0.00020183f, 0.00735501f, 0.01504687f, 0.00652849f, -0.00460572f, -0.03918016f, 0.03253752f, 
    -0.02391941f, -0.01196686f, -0.02399154f, -0.00027787f, -0.01791328f, -0.02753793f, 0.01676718f, -0.00575785f, 
    0.00510309f, 0.02162247f, -0.02646088f, -0.01256985f, 0.03284723f, 0.00218535f, -0.02521783f, 0.00814634f, 
    0.03307870f, -0.03425803f, 0.02242841f, -0.00357396f, 0.02336279f, -0.02943541f, -0.03866509f, 0.03262886f, 
    -0.00655668f, 0.02552289f, -0.00731276f, -0.02219437f, 0.00824412f, -0.04110800f, 0.02883338f, -0.03724824f, 
    -0.03107402f, 0.01000740f, -0.02532419f, -0.03616590f, -0.02843951f, -0.00731117f, 0.01860891f, 0.01156570f, 
    -0.00328789f, 0.02868828f, -0.01667973f, -0.01247253f, 0.02276802f, 0.00140383f, -0.03288196f, -0.01968849f, 
    0.02279827f, -0.03703546f, -0.00174796f, -0.00371396f, -0.00402512f, 0.00059875f, -0.02065888f, -0.02847160f, 
    0.00151495f, 0.00264303f, 0.01682231f, 0.00193606f, -0.02287933f, 0.01965260f, 0.01633863f, -0.00367431f, 
    -0.01946713f, -0.03580011f, 0.02515162f, -0.01850125f, 0.00958520f, -0.00973388f, 0.02703517f, 0.00276631f, 
    0.02254866f, 0.01433378f, 0.01628675f, 0.02420929f, -0.01557576f, -0.03666794f, -0.03317776f, -0.03586286f, 
    -0.00078695f, 0.00842778f, 0.02876412f, 0.03319322f, -0.00791313f, 0.02207763f, 0.03212130f, 0.02716884f, 
    0.01472084f, -0.03111176f, 0.00664197f, 0.00809243f, -0.01668728f, 0.01115233f, -0.01595462f, 0.00067765f, 
    0.02334327f, -0.01143391f, -0.01152395f, 0.01327909f, -0.02647679f, 0.02269144f, -0.00062806f, 0.01198836f, 
    0.02761170f, -0.02327896f, 0.01639227f, 0.00292605f, -0.00647406f, -0.00464720f, 0.02233614f, 0.02633771f, 
    -0.00339845f, 0.00305117f, -0.03363115f, -0.03141161f, 0.01502070f, 0.01465502f, 0.01727483f, -0.01409667f, 
    -0.02752635f, 0.02195942f, 0.00069251f, 0.01272126f, -0.03466783f, -0.02545762f, -0.01042134f, -0.02711653f, 
    0.00776910f, 0.03393400f, -0.00645464f, 0.00163016f, 0.02470190f, 0.00332111f, 0.00224661f, 0.01794836f, 
    0.01193762f, 0.02767505f, 0.00983892f, 0.02342742f, -0.04021689f, -0.00678709f, 0.00455875f, -0.00295943f, 
    0.00947306f, -0.00852266f, 0.00869770f, 0.00076624f, 0.00187100f, 0.02816927f, 0.00185112f, -0.03751627f, 
    0.02642834f, -0.01356201f, 0.00369163f, 0.01743496f, -0.02070303f, -0.01910391f, -0.02478698f, -0.01286857f, 
    0.02625486f, -0.03177422f, -0.00279234f, 0.01840326f, -0.03890026f, -0.00265976f, 0.03058202f, -0.01095274f, 
    -0.03260205f, 0.03252288f, -0.01773719f, -0.01705676f, -0.03936562f, -0.01826980f, -0.01527024f, -0.02754288f, 
    0.02773854f, -0.01275992f, -0.02232300f, -0.00981940f, -0.00511823f, 0.00554863f, 0.02645455f, 0.00159114f, 
    0.02115390f, 0.02442863f, 0.02200255f, -0.00869047f, -0.03900640f, -0.02679575f, 0.02662797f, 0.02507185f, 
    -0.01124799f, -0.02744295f, -0.03740493f, -0.03059820f, -0.00969399f, -0.03203312f, 0.01122508f, -0.02061915f, 
    -0.01181831f, 0.02357663f, -0.00824978f, 0.02488530f, 0.01722672f, 0.00397459f, -0.02413646f, 0.00951834f, 
    -0.00775357f, -0.02292345f, 0.00885412f, -0.00494544f, -0.01328024f, 0.02509434f, 0.01839237f, 0.00637425f, 
    -0.00085857f, -0.01930874f, -0.04408081f, 0.02393479f, 0.02656468f, 0.01470310f, -0.00911174f, -0.01082010f, 
    -0.01911843f, -0.01042347f, 0.02586465f, 0.00772074f, 0.01679778f, -0.00985039f, 0.04186205f, 0.02501443f, 
    -0.02908040f, 0.02423865f, -0.03618931f, -0.02486750f, 0.01834065f, 0.02980479f, 0.02048668f, 0.00409743f, 
    0.00197260f, 0.01001518f, -0.01325223f, 0.02842225f, 0.02617159f, -0.03537544f, 0.01300357f, -0.03518707f, 
    -0.02669075f, -0.02549497f, 0.02655215f, -0.02810909f, 0.01147429f, 0.02163069f, 0.00937402f, 0.00253302f, 
    0.00764888f, -0.02118891f, -0.02916978f, -0.02662059f, -0.02310408f, 0.02891272f, 0.00237031f, -0.04100833f, 
    0.02152968f, 0.01530288f, -0.02668309f, 0.00569363f, -0.00025563f, -0.02420199f, 0.00014035f, 0.03542309f, 
    0.00032340f, -0.02867458f, -0.00240818f, -0.01414832f, -0.02799945f, 0.00102711f, -0.00276347f, 0.03200762f, 
    -0.00048840f, -0.01370012f, -0.01453440f, 0.00657512f, 0.00562500f, -0.00580333f, 0.00225622f, -0.00138472f, 
    -0.03943431f, 0.02469218f, 0.01852176f, -0.03202546f, -0.02480408f, -0.00459366f, -0.01528320f, 0.02740342f, 
    -0.02325101f, -0.02973165f, 0.03242781f, 0.02623620f, 0.00313090f, -0.03257396f, -0.03337339f, 0.01845950f, 
    -0.01550972f, 0.00481020f, -0.01257090f, 0.01450342f, -0.02734533f, -0.04126827f, -0.03817006f, -0.02916204f, 
    -0.01144373f, 0.01554793f, 0.03717079f, -0.00842161f, 0.00217937f, 0.00508339f, -0.03284271f, 0.00893579f, 
    -0.01408117f, -0.01822002f, -0.00763537f, 0.02952516f, -0.04312437f, 0.00221282f, 0.00232439f, -0.03453925f, 
    0.01618564f, -0.00440305f, 0.01619991f, -0.02827492f, 0.00088213f, 0.01439179f, 0.03089424f, -0.00171831f, 
    0.02606628f, 0.02482178f, 0.01223661f, 0.02988294f, 0.00395292f, -0.01396676f, 0.02355080f, -0.02470459f, 
    -0.00933134f, -0.01501943f, -0.04277749f, -0.01199702f, -0.02548530f, -0.00972156f, -0.01266574f, -0.00071272f, 
    0.00441959f, -0.00924991f, -0.02769095f, 0.01166385f, 0.03698258f, -0.03022348f, 0.02148794f, 0.01928194f, 
    -0.01177315f, -0.00840357f, -0.01236347f, 0.00420676f, -0.01879202f, -0.03342143f, 0.00620727f, -0.01030620f, 
    -0.00341788f, 0.00962206f, -0.02750969f, -0.03227258f, 0.02206902f, -0.00915569f, -0.00075083f, -0.01184330f, 
    -0.02552558f, 0.01640826f, -0.01020376f, -0.03705445f, -0.01022412f, 0.00463161f, -0.02792528f, 0.02162195f, 
    0.00299640f, 0.02538623f, 0.01104309f, -0.02679751f, 0.00387195f, 0.03932155f, 0.02941451f, 0.02861846f, 
    -0.00454568f, 0.02027628f, 0.01476008f, -0.02511319f, 0.01882674f, -0.02001984f, 0.01147006f, 0.00213676f, 
    -0.00287023f, -0.02283976f, 0.01051522f, -0.02540988f, 0.01372374f, 0.02810852f, -0.02410384f, -0.00228907f, 
    -0.01957524f, -0.00856878f, -0.02552178f, -0.02947095f, -0.03122608f, 0.02692678f, 0.02762900f, -0.03900883f, 
    0.00884308f, -0.01162833f, -0.01065483f, -0.02878177f, 0.02124257f, 0.02712955f, 0.02460046f, 0.01722093f, 
    -0.03289242f, 0.02371783f, -0.03029765f, -0.00652446f, -0.02605743f, -0.03644637f, -0.02537680f, -0.01275865f, 
    -0.03133905f, 0.00050993f, -0.01124215f, -0.02185109f, -0.02218631f, -0.03229941f, 0.00295051f, 0.02214261f, 
    0.01726534f, -0.03072615f, 0.01093885f, -0.02985208f, -0.01472271f, -0.03175899f, -0.03823669f, 0.01973024f, 
    -0.00273409f, -0.03881149f, 0.02874597f, -0.02107362f, -0.00201741f, -0.00808225f, 0.00536115f, 0.01573789f, 
    -0.02902282f, -0.03286824f, -0.01888581f, 0.00761570f, -0.00178695f, -0.02461805f, -0.03531434f, 0.00385210f, 
    -0.00137855f, -0.01010697f, 0.00227877f, -0.02940400f, -0.01867250f, 0.02385532f, -0.02428671f, -0.03033448f, 
    0.01982098f, 0.00118705f, -0.00143868f, -0.00758941f, 0.03463914f, 0.00094032f, -0.02333895f, -0.04220136f, 
    -0.02473439f, 0.00203554f, 0.00716998f, -0.00383483f, -0.01429369f, -0.00173424f, -0.03571646f, 0.02165540f, 
    0.00934011f, -0.02348709f, -0.02049072f, -0.01333584f, -0.01881037f, 0.02940143f, 0.01929221f, -0.00154400f, 
    -0.00287529f, -0.02504981f, 0.02281893f, -0.03151946f, 0.03429142f, -0.00334961f, 0.00489782f, -0.00413143f, 
    -0.01825226f, -0.03408733f, 0.01699148f, 0.03245349f, 0.01162724f, 0.01220449f, -0.00270505f, -0.00006248f, 
    0.00784896f, -0.00809215f, 0.01199508f, 0.00259759f, -0.01452795f, -0.01701222f, 0.02793178f, 0.02268222f, 
    0.00757196f, -0.00285445f, 0.03087766f, -0.00467601f, 0.02711282f, 0.02579458f, -0.02761736f, 0.03341034f, 
    -0.02380366f, 0.02344076f, 0.00100596f, -0.04036312f, -0.01124395f, -0.02180894f, 0.01567072f, 0.01134511f, 
    0.00968199f, 0.01852990f, -0.03929219f, 0.01878279f, -0.01039382f, 0.00048360f, 0.03213695f, 0.01379348f, 
    -0.00567762f, -0.00843106f, -0.02450535f, 0.02842268f, -0.01843541f, 0.00911669f, -0.00086534f, -0.03774050f, 
    0.02845906f, -0.01507978f, 0.01790432f, 0.01832275f, 0.02203244f, 0.02109413f, 0.00766262f, 0.02167647f, 
    -0.04237953f, 0.01197505f, 0.00533380f, 0.02835454f, 0.01429382f, 0.01569951f, 0.01820916f, -0.01250642f, 
    -0.00239207f, -0.00129611f, -0.02667217f, 0.01487816f, 0.00280731f, 0.02257382f, -0.03283438f, -0.00269298f, 
    0.00622003f, 0.01372821f, -0.03302151f, 0.01729561f, -0.03734794f, -0.04282381f, 0.02434378f, -0.03042244f, 
    -0.03922173f, -0.03436434f, 0.00620074f, 0.00789878f, -0.00317957f, 0.03108002f, 0.01859333f, 0.01503529f, 
    -0.00196462f, 0.02522186f, -0.01044098f, -0.03012541f, 0.02567771f, 0.01852636f, 0.02420084f, -0.01362491f, 
    0.01100878f, 0.03263984f, 0.01840486f, -0.00468884f, -0.02937566f, -0.01731030f, 0.01058937f, 0.01679577f, 
    0.00253569f, -0.03324490f, -0.03293587f, -0.01993106f, 0.01946730f, -0.02882229f, 0.01683754f, 0.03369837f, 
    0.00436292f, -0.01241666f, -0.02109984f, 0.02713874f, -0.02312209f, 0.01534840f, 0.00902033f, -0.01882220f, 
    0.03373747f, 0.01694591f, 0.02460632f, -0.01702587f, 0.01983349f, -0.03062828f, -0.00993691f, 0.00976615f, 
    -0.01572960f, -0.04080511f, -0.00723291f, -0.00736135f, -0.00843496f, -0.01432157f, -0.02695889f, -0.03084757f, 
    0.01625911f, 0.02427131f, 0.00888007f, 0.03251443f, -0.00357982f, 0.01444798f, -0.03202181f, 0.00113911f, 
    0.04022563f, 0.01047918f, 0.00716488f, 0.03094330f, -0.03797526f, -0.02752338f, -0.02251462f, -0.00260162f, 
    0.02606766f, 0.01631481f, 0.01765107f, -0.02016211f, 0.01107973f, -0.03392357f, 0.00512831f, -0.03978910f, 
    0.01059163f, 0.02035552f, -0.00566975f, -0.01109347f, -0.03619529f, 0.00398582f, -0.02729963f, -0.03117551f, 
    -0.01245853f, -0.03791585f, -0.01421673f, -0.03808688f, -0.00467201f, 0.00287863f, 0.01160912f, -0.01617445f, 
    0.02749809f, -0.03182289f, 0.00314637f, -0.02269240f, -0.03029306f, -0.03731034f, 0.02699072f, -0.01848024f, 
    -0.00994758f, 0.01939864f, 0.02133856f, -0.02120447f, 0.00060111f, 0.00980026f, -0.00804819f, 0.01239040f, 
    -0.01721253f, -0.03274429f, -0.01010879f, 0.03983494f, -0.00864371f, 0.00582554f, 0.02218960f, 0.02099211f, 
    -0.02139599f, 0.01883217f, 0.00614812f, -0.01721600f, -0.01571121f, -0.02853804f, 0.00271131f, -0.01967836f, 
    -0.00537527f, -0.01228993f, 0.02419012f, -0.03607123f, -0.03559928f, -0.01732415f, 0.00040231f, -0.00274413f, 
    -0.02878144f, 0.01749669f, -0.03591439f, -0.01648978f, -0.04176913f, -0.01147621f, -0.03074981f, 0.02297468f, 
    -0.01171435f, -0.01917180f, -0.02863257f, -0.03945957f, 0.02210783f, -0.01380938f, 0.00821680f, 0.01332136f, 
    -0.01634391f, 0.02178520f, -0.03315283f, 0.02144684f, 0.01434564f, -0.01364685f, 0.00830771f, -0.01933047f, 
    -0.00268032f, -0.01112032f, -0.00345934f, -0.03784311f, -0.01739660f, 0.02755428f, -0.00772000f, 0.02071700f, 
    0.00966850f, 0.00762771f, 0.01778889f, -0.03107443f, -0.03401880f, -0.00353779f, 0.00992977f, 0.00074910f, 
    -0.02376020f, -0.02488769f, 0.02426946f, -0.00415316f, 0.02084502f, 0.02832159f, 0.00423428f, 0.00153220f, 
    -0.01313793f, -0.00923858f, -0.01950348f, -0.00775909f, 0.00458828f, -0.02854297f, -0.03742907f, 0.00235078f, 
    -0.02928809f, -0.01798617f, 0.02667109f, 0.02684165f, -0.01629484f, -0.03379667f, -0.03532158f, -0.01529325f, 
    -0.03415979f, -0.02789523f, 0.01372030f, -0.01572747f, -0.02198109f, -0.04207689f, 0.02254191f, -0.01702891f, 
    0.01991772f, -0.01930769f, 0.01267347f, 0.01519246f, -0.02251870f, 0.03390487f, -0.02424009f, 0.00283618f, 
    0.02457236f, 0.02069373f, 0.00827687f, 0.00296418f, 0.01070178f, 0.02962217f, -0.02436788f, -0.00704624f, 
    0.00419056f, 0.01466222f, 0.01098699f, -0.03975224f, -0.04169651f, 0.01207334f, -0.01671525f, 0.02648365f, 
    -0.01448668f, -0.00328792f, -0.01728205f, -0.03154459f, -0.01354270f, -0.00078280f, 0.00367836f, -0.00279809f, 
    -0.02135280f, -0.03624136f, -0.03319718f, -0.01312178f, 0.01185417f, 0.01160534f, 0.02191947f, -0.03574940f, 
    -0.03207880f, -0.04044173f, -0.03597810f, 0.01591186f, 0.02497143f, -0.03804695f, -0.00940046f, -0.00690448f, 
    -0.01402692f, -0.01858442f, 0.00690195f, 0.00447077f, 0.02586646f, 0.01333658f, 0.01932355f, -0.00965484f, 
    -0.03474801f, -0.02226059f, -0.02423952f, 0.00476291f, 0.02233573f, -0.01059139f, -0.00934425f, -0.00987426f, 
    0.01016740f, -0.03898736f, -0.01847241f, -0.02218216f, -0.03198883f, -0.01375913f, -0.02652818f, -0.01292434f, 
    0.02766375f, 0.02330625f, -0.03370478f, 0.01541139f, 0.00502446f, -0.00729432f, -0.02887291f, -0.02757222f, 
    0.00907790f, -0.01355331f, 0.00292929f, -0.02450916f, -0.04110327f, -0.00498959f, -0.01471697f, 0.03388289f, 
    0.02250456f, -0.00799570f, -0.02063928f, 0.01178461f, 0.03425962f, 0.00620402f, -0.01224127f, 0.01062989f, 
    -0.02705264f, -0.03145690f, 0.01887306f, -0.02841834f, -0.02709884f, -0.00153789f, -0.03841724f, -0.01152681f, 
    -0.02442425f, -0.02599427f, 0.00585946f, -0.00040709f, -0.03699598f, -0.03060068f, 0.00972818f, 0.02745506f, 
    0.02715225f, -0.01355966f, -0.00975853f, -0.00610911f, 0.00822773f, 0.00067845f, 0.01899242f, -0.00960859f, 
    -0.03184178f, -0.02590190f, -0.03515065f, -0.00701461f, 0.00938987f, -0.03226019f, -0.00359363f, 0.02350510f, 
    0.02160647f, -0.03303819f, 0.02097215f, -0.03937918f, 0.01474726f, 0.00654424f, 0.01734472f, -0.00742787f, 
    -0.02817144f, 0.01716460f, 0.00605021f, -0.03163400f, 0.00306777f, 0.01069636f, 0.00148759f, -0.03858653f, 
    -0.04109281f, 0.02738290f, -0.01211220f, -0.03531155f, -0.01743645f, 0.00303508f, -0.03335162f, -0.01207917f, 
    -0.01801132f, -0.03139297f, 0.02783214f, -0.03450786f, 0.01386887f, -0.03250626f, 0.02582699f, -0.02626346f, 
    -0.00907021f, -0.04036210f, 0.01606888f, -0.02856862f, -0.01268214f, -0.00041389f, 0.00833042f, 0.01698779f, 
    0.01923025f, -0.01805513f, -0.01485683f, -0.01127321f, -0.02262210f, 0.01258711f, -0.04054325f, -0.02266501f, 
    -0.03505314f, -0.01476716f, -0.02164242f, 0.03374030f, 0.00202482f, -0.01058899f, 0.01463285f, -0.01766003f, 
    -0.01479328f, -0.01678801f, 0.02831428f, 0.02035347f, 0.02831766f, -0.03310793f, -0.02394404f, -0.02006813f, 
    -0.00675325f, -0.03653689f, -0.01237816f, -0.02709691f, -0.00851875f, 0.01265780f, 0.02330590f, 0.01873362f, 
    -0.00607384f, 0.01502727f, -0.02638266f, 0.02501293f, -0.00490172f, 0.01340265f, 0.02611125f, -0.00022095f, 
    -0.00807839f, -0.02678619f, -0.01887828f, -0.01872777f, 0.03252462f, 0.01814995f, 0.02549402f, -0.03859925f, 
    0.02509902f, -0.00268319f, -0.01114390f, 0.02101119f, 0.01743863f, -0.02509672f, -0.03966130f, -0.00405435f, 
    -0.02591971f, 0.00871989f, 0.00113025f, 0.02463796f, 0.03002301f, -0.02144468f, -0.01563872f, -0.02450157f, 
    -0.03712963f, -0.03283770f, 0.01529060f, -0.03778021f, -0.02667435f, 0.01390917f, 0.01840348f, -0.02929728f, 
    -0.03744696f, -0.00965077f, -0.01366517f, -0.03755008f, 0.02976290f, -0.02548092f, -0.03946949f, 0.00390176f, 
    -0.02073012f, -0.00939468f, -0.01808287f, -0.03153215f, 0.01245905f, 0.01640450f, -0.02045900f, 0.01559190f, 
    -0.03404271f, 0.01218086f, 0.02280213f, 0.01366347f, 0.02153885f, -0.02594147f, -0.02938788f, -0.03204058f, 
    -0.01922932f, -0.00481917f, -0.02587159f, -0.02801399f, -0.01370263f, -0.00843757f, -0.03027341f, 0.01662568f, 
    0.01391626f, 0.02501553f, -0.02518422f, -0.03604756f, 0.01925289f, 0.02487055f, 0.02508304f, -0.01519890f, 
    0.02832317f, 0.02122660f, -0.00153095f, -0.00439913f, -0.03901625f, -0.03785215f, 0.00373998f, -0.03921339f, 
    -0.02655384f, 0.02428014f, -0.00540609f, -0.03129035f, -0.00897811f, 0.02842920f, -0.03482412f, 0.02844037f, 
    0.00935535f, -0.03206388f, 0.00738684f, -0.03503773f, -0.03278226f, 0.02050097f, -0.01938860f, 0.00320274f, 
    -0.03596395f, 0.01298062f, 0.01031480f, 0.02753296f, 0.01455643f, -0.01555912f, -0.03663034f, -0.00558258f, 
    -0.03100422f, -0.02771091f, -0.03235405f, -0.00455711f, -0.02134801f, -0.03680816f, 0.01280971f, -0.02318180f, 
    -0.03645311f, -0.02689894f, -0.01210607f, -0.04125180f, -0.02492236f, -0.02181623f, 0.00062125f, 0.01548437f, 
    0.01792638f, -0.03894548f, 0.01657967f, 0.00324732f, -0.01794752f, -0.02826961f, 0.01005899f, 0.00922065f, 
    -0.01601829f, 0.00842604f, -0.00468916f, 0.02994719f, 0.00401673f, 0.00458533f, 0.01773233f, 0.00093631f, 
    -0.03486329f, 0.00776278f, -0.01982767f, 0.01786792f, 0.02036104f, -0.01512870f, 0.01385446f, -0.00866475f, 
    0.02579662f, 0.02702453f, -0.00506294f, -0.00886925f, -0.03079933f, 0.01783746f, -0.01885269f, 0.01897077f, 
    -0.00485337f, 0.00871580f, 0.00315545f, -0.02183678f, -0.03622961f, -0.00016161f, -0.03211676f, 0.00949550f, 
    -0.01028825f, 0.00399778f, -0.02144868f, -0.03635351f, 0.01731432f, -0.01784488f, -0.03353084f, 0.02014626f, 
    -0.03476408f, -0.00066267f, -0.00811275f, -0.01457161f, -0.02654140f, 0.02798441f, -0.00984191f, -0.02115177f, 
    -0.03370445f, -0.01716257f, 0.00119294f, -0.04023344f, 0.01268771f, 0.02506588f, 0.01702597f, 0.00253085f, 
    -0.00523309f, -0.02683897f, -0.02057914f, -0.02299878f, -0.01508817f, -0.04138739f, -0.01935476f, -0.01846568f, 
    0.02239592f, -0.01119356f, -0.00859356f, 0.01600783f, 0.00766091f, -0.03342627f, -0.01246466f, -0.03209752f, 
    -0.03011238f, -0.03656906f, -0.00240535f, 0.03540439f, 0.01224737f, -0.03484564f, -0.02485644f, -0.03389985f, 
    -0.03518070f, 0.01317088f, -0.01526740f, 0.02063319f, 0.01708537f, 0.01479365f, 0.00921873f, 0.00053579f, 
    0.02193879f, -0.00282760f, -0.00787369f, -0.00011336f, -0.03208340f, -0.02681654f, 0.02444483f, -0.03598157f, 
    0.02958698f, -0.03178319f, 0.00594113f, 0.00541187f, 0.01916090f, 0.01548066f, -0.02163950f, 0.00765708f, 
    -0.02960196f, -0.01757985f, 0.01369627f, 0.02726661f, 0.00316626f, 0.02851310f, 0.02975342f, -0.03300143f, 
    -0.03640391f, 0.01238857f, 0.01898364f, -0.03821879f, -0.00671535f, 0.00486496f, 0.02811078f, -0.02659331f, 
    0.02366450f, 0.01353479f, 0.00520225f, -0.01814594f, -0.00595502f, 0.01852890f, -0.01833430f, -0.02549898f, 
    -0.03634502f, -0.02872096f, -0.01467303f, 0.02613033f, -0.02080465f, 0.01123009f, 0.00576849f, 0.00011356f, 
    0.01942646f, -0.01094288f, -0.04205853f, -0.00037354f, -0.02951471f, -0.03537766f, -0.03218901f, -0.02533419f, 
    0.02839115f, 0.01291968f, -0.03182076f, 0.01712614f, -0.03327191f, -0.02477296f, 0.02168177f, 0.00152324f, 
    0.01917768f, -0.02257427f, -0.01683682f, -0.03203489f, -0.03113025f, 0.02613383f, 0.01892038f, 0.00981277f, 
    0.00923435f, -0.04153329f, 0.01944503f, 0.01468709f, -0.00020532f, -0.03696106f, -0.00949789f, -0.01002992f, 
    -0.03068396f, -0.00135384f, 0.01187179f, 0.02099386f, 0.00053293f, -0.00910475f, 0.02218397f, 0.01503351f, 
    -0.02488761f, 0.01714862f, 0.02676280f, -0.00974092f, -0.03811526f, -0.02648173f, 0.02248049f, 0.01065997f, 
    0.02292716f, 0.02348075f, -0.03139524f, -0.03594380f, -0.00192503f, 0.01461403f, -0.00657309f, -0.00368013f, 
    -0.03083335f, -0.00758171f, 0.01952569f, -0.00714947f, -0.03782680f, -0.01842937f, 0.00047472f, -0.01891227f, 
    0.01976401f, -0.03394098f, 0.01210199f, 0.02293007f, 0.01540769f, -0.02631821f, 0.02678630f, 0.00980224f, 
    0.01583161f, -0.02012752f, 0.00950283f, 0.00461344f, 0.01356041f, 0.00869611f, -0.00555550f, -0.02920982f, 
    0.01327293f, -0.00882270f, 0.00795401f, -0.02221878f, 0.02506970f, -0.00132753f, -0.02334702f, -0.00163740f, 
    -0.03300289f, 0.02745176f, 0.02765253f, -0.03629261f, -0.02104051f, 0.00389510f, 0.01065756f, -0.02782981f, 
    0.02167095f, 0.01219822f, 0.00493954f, -0.02050134f, 0.01570192f, -0.01547766f, 0.02003037f, -0.00560699f, 
    0.00529821f, 0.02853593f, -0.02620237f, 0.02789753f, -0.03658080f, -0.03535420f, 0.01964429f, -0.03455333f, 
    -0.03302746f, -0.00107951f, -0.03607792f, -0.02617262f, -0.02867927f, -0.01225641f, 0.01630598f, -0.03758118f, 
    0.00117812f, -0.03723221f, -0.01868918f, 0.00758570f, -0.03211014f, 0.00987323f, -0.00698578f, 0.00312175f, 
    0.02815299f, -0.01238908f, -0.01795446f, -0.03098840f, -0.03992953f, 0.00928790f, 0.00417701f, -0.03472905f, 
    0.01179051f, -0.01498191f, -0.03001985f, 0.01897999f, -0.03009171f, -0.03306045f, -0.04042369f, 0.01461819f, 
    -0.00580189f, -0.03789004f, -0.01303638f, -0.02147231f, -0.02466915f, -0.00042331f, 0.01931933f, -0.03864800f, 
    0.00471536f, 0.01505367f, -0.02484607f, -0.00112691f, -0.02674564f, -0.01976842f, 0.01414883f, -0.00242350f, 
    0.01405075f, 0.00550243f, -0.01546200f, 0.02846005f, -0.01077966f, 0.00111881f, 0.02478402f, 0.00618142f, 
    0.00698607f, 0.02293293f, -0.01177602f, -0.03706757f, -0.01325810f, -0.00613323f, 0.02899857f, -0.03794453f, 
    -0.03198537f, 0.00335486f, 0.01699113f, -0.04136045f, 0.00465345f, -0.02221500f, 0.01851750f, 0.02467519f, 
    -0.02245353f, -0.01326817f, -0.00090162f, 0.02144490f, -0.00522614f, -0.04095965f, -0.02658116f, -0.02048939f, 
    -0.03142149f, -0.03815089f, -0.01496044f, -0.03173780f, -0.03410955f, -0.01433630f, 0.02577005f, 0.00712352f, 
    -0.02497463f, 0.02769868f, 0.02091892f, -0.01499988f, -0.02834050f, -0.00592452f, -0.01824139f, 0.01121012f, 
    0.02815654f, 0.02132158f, 0.00872984f, -0.02678196f, -0.03116425f, -0.01021970f, -0.03662761f, -0.02734474f, 
    0.03257970f, 0.00027811f, -0.01252439f, -0.03467671f, 0.02032916f, -0.02636685f, 0.00195873f, -0.01210804f, 
    -0.00097772f, 0.01090088f, -0.03801452f, 0.00964719f, -0.01448145f, -0.01372761f, 0.01902223f, 0.00739718f, 
    0.00687308f, -0.02249046f, 0.00823906f, 0.00560316f, 0.00052345f, -0.00245683f, -0.01909989f, 0.00778768f, 
    -0.01708182f, -0.00040134f, -0.03600527f, -0.02372893f, -0.00163256f, 0.00770178f, -0.03525189f, -0.00965894f, 
    -0.04153929f, 0.00189001f, 0.02597188f, -0.00751507f, 0.00007428f, -0.04059206f, 0.01847365f, -0.02692194f, 
    -0.03903554f, 0.00326724f, -0.03551955f, 0.03676312f, -0.02647544f, 0.02852316f, -0.00617218f, -0.01486763f, 
    -0.03144494f, 0.01259875f, -0.01488670f, 0.00430294f, 0.01894883f, 0.00161512f, 0.00341069f, -0.02490748f, 
    -0.00933656f, -0.04108435f, 0.01283134f, -0.00388444f, 0.01922337f, 0.00301404f, -0.01394059f, 0.00362245f, 
    0.01879406f, -0.00244013f, -0.00786972f, 0.00031720f, -0.00591467f, -0.03717252f, 0.00337105f, -0.02323360f, 
    -0.02584479f, -0.01619836f, -0.03500282f, -0.03673272f, 0.00026583f, -0.03876972f, -0.03041371f, 0.01410954f, 
    0.02506624f, 0.02653648f, -0.03776196f, 0.00009183f, -0.03435617f, -0.00773138f, -0.01156844f, -0.02804207f, 
    -0.00355707f, -0.03144873f, -0.02936505f, -0.01100454f, -0.02084944f, 0.00371992f, -0.03719688f, -0.01825963f, 
    -0.04114147f, -0.02856995f, -0.01022471f, 0.00179458f, -0.03386986f, -0.01089849f, -0.00031743f, 0.02467556f, 
    0.01124509f, -0.03803065f, 0.00214616f, -0.03660751f, 0.01579506f, -0.02051873f, -0.01650999f, 0.02303476f, 
    -0.02756394f, -0.02212618f, -0.03880848f, 0.02964187f, -0.02972862f, 0.02156585f, -0.02544586f, -0.01034355f, 
    -0.02612116f, 0.02547820f, -0.00690633f, 0.02116038f, -0.00343603f, -0.00355228f, -0.00029033f, 0.02794246f, 
    -0.01862652f, -0.01650539f, -0.01295854f, -0.02668976f, -0.02692087f, 0.00184933f, -0.00743363f, 0.00957820f, 
    0.02117201f, -0.02348109f, 0.02311021f, 0.00574338f, -0.00146703f, -0.02072297f, 0.00640551f, -0.03509639f, 
    0.02607398f, 0.00241192f, -0.04017598f, 0.02578460f, -0.00140831f, 0.00842339f, 0.00097253f, -0.02036307f, 
    0.00909066f, 0.01570793f, 0.01468917f, -0.01449080f, -0.01012425f, -0.01880118f, -0.01282922f, 0.02219856f, 
    -0.03377942f, -0.02885969f, -0.03422580f, 0.00849235f, 0.02152331f, 0.02844803f, 0.02168928f, 0.01492471f, 
    -0.02910251f, 0.00834028f, -0.02331370f, -0.02053415f, 0.02229348f, 0.02298534f, 0.00278221f, 0.01971339f, 
    0.00101518f, 0.00254238f, 0.02076014f, -0.04139987f, 0.00774836f, 0.00032956f, -0.00799284f, 0.02898414f, 
    -0.03923646f, -0.04058297f, 0.02114694f, -0.03518895f, 0.01067034f, 0.03504058f, 0.00021589f, 0.02672517f, 
    0.02924674f, 0.01396951f, -0.04046265f, 0.02082260f, 0.01191301f, -0.01768228f, -0.01387748f, -0.03970848f, 
    0.00355744f, -0.03588379f, 0.02291918f, 0.02693481f, 0.00635192f, 0.01498760f, -0.00144923f, -0.02274337f, 
    -0.03736524f, -0.01251587f, -0.01736105f, -0.00375598f, 0.02074594f, -0.03142457f, 0.02518931f, 0.00122755f, 
    -0.01901788f, -0.01148104f, -0.01601525f, 0.01104710f, -0.01223984f, 0.01582354f, 0.00406509f, -0.03422838f, 
    0.01655844f, -0.00600171f, 0.01794557f, 0.02876594f, 0.01326972f, 0.02281453f, -0.03586427f, 0.02442192f, 
    0.01301872f, -0.02402972f, -0.03092839f, -0.01860422f, -0.02357820f, -0.01898052f, -0.03950745f, -0.02190398f, 
    -0.01790308f, -0.03017067f, 0.02181794f, 0.01198569f, 0.02310139f, -0.02046701f, -0.01367823f, -0.02540245f, 
    -0.00724644f, 0.00898243f, 0.01045575f, -0.00095565f, 0.02663328f, 0.02672182f, 0.01456250f, 0.01405484f, 
    -0.01500941f, 0.01615318f, -0.03413768f, -0.03438028f, -0.03567054f, 0.00074512f, -0.00514596f, 0.01493642f, 
    0.00110941f, -0.03660049f, 0.02735021f, -0.02876020f, 0.02638835f, 0.01752747f, -0.00380125f, -0.03075857f, 
    -0.03349902f, -0.00834177f, -0.03777537f, 0.00788300f, 0.00079550f, 0.01043011f, -0.01875682f, 0.02391718f, 
    -0.03731817f, 0.00149646f, -0.02027537f, 0.02485743f, -0.00066688f, 0.01866490f, -0.03569326f, 0.01160723f, 
    0.01100088f, 0.02622881f, -0.03272118f, -0.03296547f, -0.01142517f, -0.03259383f, 0.02884583f, -0.03390919f, 
    0.02750969f, -0.02250379f, 0.02878893f, -0.03575433f, -0.03861919f, -0.03305283f, -0.02424152f, 0.01668583f, 
    0.03731214f, 0.02555776f, -0.02600777f, -0.00414173f, -0.00366774f, -0.04122289f, -0.01628244f, -0.04083392f, 
    -0.00910316f, -0.01587552f, -0.01697338f, 0.02390387f, -0.01805754f, 0.00360659f, -0.03149850f, -0.00174225f, 
    -0.00752999f, -0.01159023f, -0.01336826f, 0.00710315f, -0.01951110f, 0.00836731f, -0.04071660f, 0.00389952f, 
    -0.02859970f, -0.01868532f, -0.02092331f, -0.01111304f, -0.03839112f, -0.00328527f, -0.03282956f, 0.02928985f, 
    0.02461025f, -0.02300785f, 0.01640345f, -0.03430169f, 0.00905015f, -0.01144627f, 0.01844305f, 0.00334928f, 
    -0.03794112f, 0.02923458f, -0.03705975f, 0.02201102f, -0.02399036f, -0.01837439f, -0.02057343f, 0.00675623f, 
    -0.02435341f, 0.01715659f, -0.00732234f, 0.02151806f, 0.01390151f, 0.01128593f, -0.01810507f, -0.00349803f, 
    -0.03612266f, -0.01898182f, 0.00340736f, -0.02594635f, 0.01102960f, -0.03973595f, -0.03847789f, 0.00269300f, 
    -0.02064298f, -0.03692996f, 0.02605854f, -0.00465101f, 0.00676566f, -0.03940034f, -0.03626240f, 0.01816992f, 
    -0.00465424f, 0.01612612f, -0.00507211f, 0.02529804f, -0.03010884f, -0.03941755f, -0.01235768f, 0.00406637f, 
    0.01405155f, -0.03209825f, -0.02666386f, -0.02938897f, -0.00628600f, 0.00602072f, 0.01792636f, -0.00154618f, 
    -0.00730935f, -0.03148538f, -0.00043195f, -0.00039298f, 0.03454381f, 0.02659242f, -0.02798511f, -0.01989903f, 
    0.02850714f, -0.02343802f, 0.00813030f, -0.02250184f, -0.02439762f, 0.00777296f, 0.01414901f, -0.03213118f, 
    -0.03005508f, 0.02721578f, -0.03021124f, -0.00165467f, -0.00144299f, 0.01776408f, 0.01238392f, 0.01176873f, 
    -0.00844745f, -0.03100952f, -0.00553111f, -0.01606391f, -0.02059646f, -0.04001646f, -0.01592778f, -0.02105058f, 
    0.00402611f, 0.01972509f, 0.02909625f, -0.04091796f, -0.03596049f, 0.00095687f, -0.03451089f, -0.00301348f, 
    0.01338425f, -0.01120615f, -0.03334185f, 0.02820202f, -0.04069925f, -0.01308770f, -0.00641534f, 0.02416136f, 
    -0.02677948f, -0.00382054f, -0.00922037f, -0.02030117f, -0.03313731f, -0.02995442f, -0.03120089f, -0.02100315f, 
    -0.01798755f, -0.01256308f, 0.01797898f, -0.01349872f, -0.03484490f, -0.00694393f, 0.02599067f, -0.01749535f, 
    -0.01451837f, -0.01430981f, 0.03585067f, 0.00505740f, -0.03475022f, -0.01693245f, 0.01858496f, -0.02133872f, 
    0.02691054f, 0.02537390f, -0.02159471f, 0.00603423f, 0.00235839f, -0.00365711f, -0.02028579f, 0.02656515f, 
    -0.02155215f, 0.01348985f, -0.02818925f, 0.01820662f, 0.02541657f, -0.00889313f, -0.03413749f, 0.01059213f, 
    0.00478247f, -0.04181153f, -0.03206259f, -0.00889781f, 0.00717098f, -0.01926920f, -0.02825541f, -0.02497292f, 
    0.02993131f, -0.00553716f, 0.02480586f, 0.01491462f, -0.00156249f, 0.02913430f, -0.03080635f, 0.01096629f, 
    -0.03137330f, 0.02591146f, -0.01644823f, -0.03469545f, -0.03179172f, -0.01613207f, -0.02471427f, 0.01480168f, 
    0.00988904f, -0.02933189f, -0.00605584f, -0.02108929f, -0.03092087f, -0.01361841f, 0.00675960f, -0.03477247f, 
    -0.01369916f, -0.02014585f, -0.03315385f, 0.02719208f, 0.00396224f, -0.00956154f, 0.00532401f, 0.00795156f, 
    0.01386646f, -0.02031608f, 0.01382346f, -0.02192243f, 0.02693736f, -0.01649251f, 0.00228952f, 0.00142460f, 
    0.00940026f, -0.02076264f, 0.00746496f, -0.01053657f, -0.02462392f, -0.00962186f, 0.02109784f, -0.02346931f, 
    -0.02849068f, 0.00430924f, 0.00744612f, -0.02267338f, -0.01962342f, 0.00625029f, -0.02534836f, -0.00862106f, 
    -0.02486007f, 0.00613120f, -0.04099778f, 0.00403977f, 0.00483965f, -0.00266250f, 0.02383563f, -0.02782718f, 
    0.01472502f, -0.01046113f, -0.00122803f, -0.01680999f, -0.00097936f, -0.03044857f, -0.02566947f, 0.01900292f, 
    0.01846287f, 0.03428841f, -0.00172353f, -0.02818862f, 0.02959536f, -0.01441759f, 0.02402330f, 0.02054421f, 
    -0.02616202f, 0.02127329f, -0.00319046f, 0.01788474f, 0.01684293f, 0.00100362f, -0.04038349f, -0.01937129f, 
    -0.03764316f, 0.01094474f, 0.00032787f, -0.00754638f, -0.03404374f, 0.01490240f, -0.02652759f, 0.02282050f, 
    -0.02440175f, -0.04123185f, -0.03887855f, -0.02112022f, 0.01977326f, 0.02700781f, -0.00865016f, 0.02624071f, 
    -0.01711072f, -0.04156648f, 0.01262262f, -0.00310522f, -0.01803024f, 0.02594623f, 0.00177806f, 0.00611028f, 
    0.00403809f, 0.02402450f, -0.03738837f, -0.03284175f, 0.01559380f, -0.03173117f, 0.00269365f, -0.02747071f, 
    0.01458021f, -0.01340194f, 0.00533404f, -0.02626038f, -0.01966940f, 0.00023153f, -0.02714139f, 0.00418561f, 
    0.00113786f, 0.01625099f, -0.03243643f, 0.01078942f, 0.00195537f, 0.02013778f, -0.00265487f, 0.01474308f, 
    -0.01953529f, -0.02704245f, -0.00677769f, -0.02828978f, -0.03131794f, -0.01089579f, 0.01755498f, -0.01811209f, 
    0.00220613f, -0.02005789f, 0.00681036f, 0.01026832f, -0.01739741f, -0.00196563f, -0.00666935f, 0.02949124f, 
    0.00444769f, 0.00731095f, 0.01673849f, 0.01583631f, 0.01697389f, 0.00099535f, -0.00765782f, 0.01602574f, 
    -0.02512154f, 0.02041127f, -0.01805061f, 0.03315543f, -0.01305166f, 0.01591259f, 0.02885983f, 0.01027446f, 
    -0.00901425f, -0.03491588f, -0.02331185f, -0.03849812f, -0.00665257f, 0.00409823f, -0.02588169f, -0.00767125f, 
    -0.01805557f, -0.01553196f, 0.00695120f, -0.00368706f, -0.00155566f, -0.00555701f, -0.03549423f, 0.02465498f, 
    0.02733349f, -0.00325540f, 0.01815865f, -0.03084969f, -0.01494875f, -0.00844463f, 0.00854544f, -0.04053567f, 
    0.02514235f, 0.01618198f, 0.01665165f, 0.00629749f, -0.01587050f, 0.02585305f, -0.03865201f, 0.00892689f, 
    -0.02932017f, 0.01004915f, 0.02997381f, -0.00673517f, -0.01215632f, -0.01258679f, -0.00520358f, 0.02551097f, 
    -0.02479102f, -0.00548184f, -0.01779075f, -0.01306208f, 0.01711161f, 0.01205541f, -0.01882547f, 0.01118742f, 
    0.01540213f, 0.02852625f, 0.00388400f, -0.00321010f, 0.01725702f, 0.02329452f, -0.03503532f, -0.03006766f, 
    0.02860101f, -0.02934536f, -0.02566025f, -0.02267147f, -0.02984212f, -0.01130202f, 0.02978115f, 0.00556474f, 
    0.00137858f, -0.02904020f, 0.00974947f, -0.03020448f, 0.00634073f, -0.03518240f, -0.02032156f, -0.04168020f, 
    0.02489849f, -0.00009162f, -0.02122966f, -0.00933182f, 0.00498897f, 0.02581384f, -0.00396926f, -0.03903420f, 
    0.02297528f, 0.02895470f, -0.04205954f, -0.01083019f, -0.03637839f, 0.01343575f, -0.01817305f, 0.01811426f, 
    -0.02792027f, -0.01240016f, -0.01106044f, 0.00095577f, -0.00500126f, -0.00047839f, 0.03692232f, 0.00311353f, 
    -0.01445142f, -0.02614124f, 0.01812227f, -0.02848864f, -0.02470567f, 0.01293334f, -0.03629614f, 0.01057982f, 
    -0.01448999f, -0.02439626f, 0.02930187f, 0.00896176f, -0.04070089f, 0.00652640f, 0.01812405f, 0.01814255f, 
    -0.02796241f, 0.00449801f, -0.00952544f, 0.00771654f, 0.02239278f, 0.01162658f, -0.00532684f, 0.00282905f, 
    -0.00193940f, 0.01476878f, 0.02008935f, 0.00455303f, -0.02979262f, -0.04341219f, -0.02129333f, 0.02035149f, 
    -0.04498760f, -0.02302677f, -0.02016496f, 0.01843774f, 0.00326011f, 0.01935703f, -0.02716598f, 0.00432482f, 
    0.02386796f, -0.00979222f, 0.01962406f, -0.01375671f, -0.01646588f, 0.00264494f, -0.02251492f, -0.02581395f, 
    0.01274526f, 0.01971596f, -0.01607047f, -0.00230675f, 0.01186000f, 0.02748558f, -0.00576747f, -0.02597297f, 
    -0.02755581f, -0.03165225f, -0.00569442f, 0.00048463f, -0.03635686f, -0.00305759f, -0.03228970f, -0.00155277f, 
    0.02119856f, 0.01965969f, -0.00518949f, 0.01428077f, -0.00910069f, -0.02706469f, -0.02707325f, 0.01364845f, 
    -0.00894125f, -0.04013324f, -0.03674835f, -0.01266930f, -0.03823246f, -0.01453173f, -0.02835689f, 0.03032582f, 
    0.02240881f, -0.03957871f, 0.02287087f, -0.02225830f, 0.03478010f, -0.03983919f, -0.00263197f, 0.01769739f, 
    0.00309194f, -0.01086681f, -0.00525615f, -0.00469021f, 0.01817331f, -0.03205332f, -0.04150074f, 0.02136016f, 
    0.00410693f, 0.01252725f, -0.01830424f, -0.03318528f, 0.01472393f, -0.00670643f, 0.01018054f, -0.01705797f, 
    0.02862195f, -0.00672144f, 0.01009229f, 0.00645789f, 0.02569143f, 0.00171592f, 0.01703363f, -0.00475077f, 
    -0.02070617f, -0.03993637f, -0.03091471f, -0.00616846f, -0.02710753f, -0.01490813f, -0.03959326f, -0.03925782f, 
    -0.03181129f, 0.00838964f, 0.00084332f, 0.02923876f, 0.00062579f, -0.01770999f, -0.02074533f, -0.00036098f, 
    -0.02763401f, -0.03423984f, -0.01235906f, -0.01643767f, 0.00137920f, 0.01961605f, -0.01546228f, -0.03831365f, 
    -0.01209746f, -0.02452866f, 0.01472933f, -0.04447361f, 0.00509408f, -0.00898192f, 0.01941523f, -0.02673999f, 
    -0.04215676f, -0.02102438f, -0.03631088f, -0.03073476f, 0.01499430f, -0.02981432f, -0.01574954f, -0.04050659f, 
    -0.03939151f, 0.03058610f, -0.02763626f, -0.02224777f, 0.01579507f, 0.00966667f, 0.00699670f, -0.02110696f, 
    -0.01979123f, 0.02065718f, 0.01136778f, -0.03507316f, -0.01130868f, 0.02385763f, 0.02963623f, -0.04434592f, 
    0.01997649f, -0.00700255f, -0.00107739f, -0.00899074f, 0.00266592f, 0.00502837f, -0.02453757f, -0.01096691f, 
    0.00944819f, 0.00809539f, -0.01098845f, -0.00959099f, -0.01018518f, 0.02087116f, 0.00099615f, 0.00551144f, 
    -0.01649737f, -0.03760476f, 0.00828785f, -0.00749649f, 0.02458614f, 0.01157908f, -0.01538895f, -0.02435715f, 
    0.02724203f, 0.01339041f, 0.02152195f, -0.02733103f, -0.01831193f, -0.02015114f, -0.02414327f, -0.02268924f, 
    -0.02310802f, -0.01641515f, -0.00786434f, 0.03589103f, 0.02767323f, -0.02031991f, -0.03408568f, 0.00689401f, 
    -0.02669741f, -0.03623726f, -0.03798471f, -0.02675869f, -0.00307740f, 0.01668621f, 0.00265384f, 0.02051130f, 
    -0.03281552f, -0.01619089f, -0.02562744f, 0.00737848f, -0.02358809f, 0.00931314f, 0.01109572f, -0.03940397f, 
    -0.01940704f, 0.00334844f, -0.03868975f, -0.01534425f, 0.00688320f, -0.00653409f, -0.02505515f, -0.01472191f, 
    -0.02011259f, -0.02406258f, -0.03575438f, -0.02597111f, 0.01330718f, 0.00375459f, 0.00460396f, 0.03106604f, 
    -0.02933964f, -0.02069676f, 0.01735141f, 0.00899216f, 0.01658837f, -0.00494496f, 0.00137620f, -0.01578138f, 
    0.01225412f, 0.00407098f, -0.03985433f, -0.02206256f, 0.02201348f, 0.02622007f, -0.03481044f, -0.01106198f, 
    -0.00026715f, 0.01233810f, -0.02642948f, -0.01874968f, 0.01651987f, -0.01070094f, -0.03176027f, -0.04122660f, 
    0.02337850f, 0.01477447f, -0.04380195f, 0.01031573f, -0.04555314f, -0.03000451f, 0.01137647f, -0.00802309f, 
    -0.00037243f, -0.01380526f, -0.03304848f, -0.02688528f, -0.01098213f, -0.03394292f, -0.03152443f, 0.01224134f, 
    -0.00122464f, -0.02973016f, 0.00304453f, -0.00868469f, 0.02270881f, -0.01730821f, 0.01518712f, 0.01287260f, 
    -0.01814177f, 0.00177059f, 0.03643499f, -0.02767879f, -0.02559046f, 0.00265088f, -0.04291922f, 0.01869007f, 
    0.00459936f, 0.02261786f, 0.01222332f, -0.04542833f, -0.03202496f, -0.02489761f, -0.02835968f, -0.01646564f, 
    0.00955186f, 0.02521045f, -0.03026897f, 0.01856867f, -0.02844364f, 0.01701465f, -0.01206145f, 0.02550601f, 
    0.01155739f, -0.00418285f, 0.01932868f, 0.00301829f, -0.01489257f, -0.01401358f, -0.03060561f, 0.01781184f, 
    -0.00304091f, 0.02103687f, -0.01217891f, -0.02272311f, 0.01437894f, -0.00460919f, -0.03202119f, -0.02727264f, 
    0.02545807f, 0.02455022f, 0.02199051f, -0.03038334f, 0.00944155f, 0.00471206f, -0.02481837f, -0.03030474f, 
    -0.00823575f, 0.01174051f, 0.01021350f, 0.02224877f, -0.02048908f, 0.00843528f, 0.02677434f, 0.00061068f, 
    -0.04231241f, 0.00827208f, -0.03914370f, -0.02960172f, -0.03813647f, -0.00816023f, -0.03347912f, 0.00522912f, 
    0.00174328f, -0.00021359f, 0.02052058f, -0.01761722f, -0.01727655f, 0.01295625f, 0.02511625f, -0.04416944f, 
    0.02389113f, -0.03929284f, 0.00363651f, -0.03479397f, -0.01001577f, -0.04651542f, 0.01343203f, 0.00006759f, 
    -0.02603176f, 0.01572348f, 0.01564838f, -0.04162608f, -0.00611700f, -0.02876093f, 0.00660009f, -0.00388876f, 
    -0.00039007f, -0.01258240f, -0.00982775f, 0.00756323f, -0.00699965f, -0.01250964f, -0.01946937f, -0.04195051f, 
    -0.03647795f, -0.00882881f, 0.02472106f, -0.03162609f, 0.02894941f, 0.00508357f, -0.00582728f, -0.00102590f, 
    -0.00205673f, 0.00954253f, -0.03985122f, 0.02892050f, 0.02374203f, 0.02298203f, 0.00275527f, 0.02602977f, 
    -0.00485033f, -0.02014524f, 0.02409096f, 0.02009911f, -0.03757222f, 0.02055015f, -0.04595557f, 0.02029536f, 
    -0.02447901f, -0.02025544f, 0.02492210f, -0.01580168f, -0.02544145f, -0.02773951f, 0.00260675f, 0.00229262f, 
    0.02341300f, 0.02451495f, 0.01298021f, -0.01034850f, 0.02346517f, 0.03089451f, 0.02802985f, 0.01065745f, 
    -0.01541781f, -0.01570034f, 0.01214592f, -0.00704610f, 0.01725695f, -0.03109150f, 0.01943775f, -0.02440097f, 
    -0.03097828f, 0.00651942f, 0.00381467f, -0.01073175f, 0.00704293f, -0.03887941f, -0.00516488f, -0.00265480f, 
    0.01207730f, -0.00045342f, 0.02283258f, 0.01442358f, -0.00446191f, 0.02316532f, -0.00865509f, -0.02735499f, 
    -0.04080982f, -0.00206070f, -0.00160085f, -0.04424266f, -0.01149690f, 0.01004297f, -0.00876188f, -0.03450600f, 
    -0.03009506f, -0.03711119f, -0.01509928f, -0.03185113f, -0.00858633f, -0.00386930f, -0.02616096f, 0.02228734f, 
    0.01439036f, -0.03709332f, -0.01451105f, 0.01816648f, -0.00852353f, -0.00445801f, 0.02616090f, -0.03552885f, 
    -0.03276378f, 0.00209559f, 0.00772059f, 0.01965461f, -0.01308113f, -0.00729227f, -0.03064566f, 0.01911965f, 
    -0.00719771f, 0.00199560f, -0.00321837f, -0.02347945f, -0.02927378f, 0.00965394f, 0.02081848f, -0.01122206f, 
    0.00774132f, 0.03227487f, 0.01099645f, 0.00817738f, -0.00484553f, 0.00963384f, -0.03189018f, 0.01696106f, 
    0.00040814f, -0.01540028f, -0.02989587f, 0.00584892f, 0.02119788f, 0.00638981f, 0.01093293f, 0.02174286f, 
    -0.03110709f, -0.01180462f, -0.04333981f, -0.03511197f, -0.01661066f, -0.02752046f, 0.02344112f, -0.03095507f, 
    0.01285085f, 0.02243352f, 0.01928513f, -0.03412388f, -0.03704044f, -0.04165551f, 0.00224371f, -0.04028488f, 
    -0.02268123f, 0.00355393f, -0.00901405f, 0.00350780f, 0.02068858f, 0.00746572f, 0.02258921f, -0.00344197f, 
    -0.02363146f, 0.02075512f, -0.00067123f, -0.03477008f, 0.01217882f, -0.00999660f, 0.03049367f, -0.03002331f, 
    -0.04302201f, 0.00392046f, -0.03514112f, 0.00948838f, -0.00293344f, -0.02543476f, 0.02428260f, -0.02547244f, 
    -0.00106900f, -0.03396347f, -0.01113125f, 0.01420735f, -0.00041190f, 0.01766184f, -0.03521074f, 0.02432833f, 
    -0.00418602f, -0.00185227f, -0.00056417f, -0.02446976f, -0.03441069f, -0.03442750f, 0.01975507f, 0.01624833f, 
    -0.03646237f, -0.03712146f, -0.04140025f, 0.02395475f, 0.02946212f, 0.01338886f, 0.00753594f, -0.03953469f, 
    -0.01814567f, -0.00875243f, 0.01276999f, 0.00932767f, 0.01246846f, 0.01741581f, 0.01729139f, 0.00678334f, 
    0.02249604f, -0.03282445f, -0.04580068f, -0.01484061f, 0.00651851f, -0.04208817f, 0.02179595f, -0.02909164f, 
    0.00634519f, -0.04343750f, 0.01573028f, -0.03260664f, -0.00099057f, -0.01677551f, -0.03316600f, 0.02160691f, 
    0.00542685f, -0.04085005f, 0.00979598f, 0.02058571f, -0.00765242f, 0.00565302f, -0.01213438f, -0.01390965f, 
    -0.00751595f, -0.02368388f, 0.01901936f, 0.00893702f, 0.01510050f, -0.03452578f, 0.01884056f, 0.01289051f, 
    -0.03107062f, -0.00918743f, -0.00925954f, -0.03255317f, 0.01446364f, -0.01282765f, -0.01368694f, -0.00615104f, 
    -0.02022004f, 0.01686608f, -0.02130014f, 0.02646132f, -0.01897227f, -0.01329854f, -0.00695427f, -0.00556716f, 
    0.01619875f, -0.02248401f, -0.01375617f, -0.04558693f, 0.01097988f, 0.02760165f, -0.01290391f, -0.04608992f, 
    -0.02632207f, -0.03802251f, -0.02253366f, 0.00216038f, -0.03450761f, 0.01681833f, 0.03075168f, 0.01450045f, 
    -0.00282759f, -0.00341624f, -0.03873790f, -0.01751931f, -0.01509493f, -0.01574208f, -0.04475564f, -0.03501349f, 
    0.02977207f, -0.02906345f, -0.03188041f, -0.00446105f, -0.01793004f, -0.03395989f, 0.01352204f, -0.03772077f, 
    -0.00320723f, 0.01168186f, -0.02939455f, 0.00722371f, -0.01822157f, -0.00917846f, -0.04214364f, 0.00991821f, 
    -0.01273591f, -0.02342089f, -0.03635836f, 0.00187417f, 0.00446077f, 0.03224954f, -0.02595170f, -0.04221567f, 
    -0.00978526f, -0.02707165f, -0.02193783f, 0.00467238f, -0.00995243f, -0.00278183f, -0.01904654f, -0.02513122f, 
    -0.03624995f, 0.01684697f, 0.02443207f, -0.00397274f, 0.03267225f, 0.00893121f, 0.03149441f, -0.00234882f, 
    0.00326447f, -0.00923370f, 0.02051637f, -0.00409618f, -0.01284693f, -0.03935968f, 0.03595960f, 0.00918731f, 
    -0.03960069f, 0.01674366f, -0.00741398f, 0.02481932f, 0.02724280f, -0.03645609f, 0.03279108f, -0.04493804f, 
    -0.04135512f, 0.00218840f, -0.01230287f, -0.02740679f, 0.01092578f, -0.02504738f, -0.01819461f, -0.04029251f, 
    0.03068881f, -0.01407463f, -0.00605178f, -0.00928300f, 0.02424242f, 0.01456610f, 0.01577008f, -0.03332704f, 
    0.00016419f, 0.00403661f, -0.02907116f, 0.01929074f, 0.01378282f, -0.02316707f, -0.00159751f, -0.00350915f, 
    -0.04201415f, -0.02107218f, -0.02475511f, -0.03886893f, -0.01790523f, -0.04420035f, -0.02517657f, 0.02026847f, 
    0.01409216f, 0.02613596f, 0.01631013f, 0.00240441f, -0.03314295f, -0.00734204f, -0.00680324f, 0.01166068f, 
    0.00111659f, 0.01973963f, -0.00999705f, -0.03073793f, -0.02999162f, -0.01954145f, -0.01530019f, -0.02711819f, 
    0.02390776f, 0.00017537f, -0.00074018f, -0.00117013f, -0.01596111f, 0.01813147f, -0.00791481f, -0.00496920f, 
    0.01466264f, -0.00378062f, -0.00014564f, -0.03807622f, -0.03870125f, 0.00419638f, 0.02182219f, -0.03381525f, 
    -0.00360573f, 0.00815128f, 0.02052108f, 0.01679706f, -0.00390696f, -0.01494512f, -0.01229157f, -0.02959407f, 
    -0.03028803f, -0.04407985f, 0.00380010f, 0.01819107f, 0.01410798f, 0.01441159f, -0.00891149f, 0.00865650f, 
    -0.02345975f, 0.01870632f, -0.00013641f, 0.00000183f, 0.00427034f, 0.01662365f, 0.00204785f, -0.02130020f, 
    0.09081917f, -0.11154922f, -0.03449603f, 0.05094035f, -0.00805418f, 0.03483999f, -0.06411564f, 0.00673003f, 
    -0.01791903f, 0.06176675f, -0.07748953f, -0.02272110f, 0.04561596f, 0.12159975f, 0.10136071f, -0.04288962f, 
    0.14195155f, 0.06355849f, -0.14489718f, 0.00379892f, -0.04668518f, -0.00973228f, 0.09675527f, 0.01913258f, 
    -0.20124285f, 0.03151371f, -0.01244594f, -0.09286350f, -0.04033810f, -0.01347389f, -0.00454760f, 0.14162113f, 
    0.05804679f, 0.03452238f, -0.12916251f, 0.06079469f, 0.24695317f, 0.12609479f, -0.22635017f, 0.01689699f, 
    0.14087377f, -0.02495648f, -0.03331513f, 0.10852534f, -0.02422567f, -0.07401385f, -0.13354212f, -0.09040348f, 
    0.40268472f, 0.09309827f, -0.13293849f, -0.09913380f, -0.05904105f, -0.04472139f, -0.18898532f, -0.10022145f, 
    -0.00084101f, 0.00918781f, -0.14080758f, -0.00677830f, 0.14188331f, -0.10449930f, -0.02992379f, 0.10221580f, 
    0.06954748f, -0.00057132f, -0.14923204f, -0.02435924f, 0.08823543f, 0.02270396f, 0.05289869f, -0.04573359f, 
    -0.23918675f, -0.14733946f, 0.00082958f, -0.07422835f, -0.08431754f, -0.04627714f, -0.08900625f, -0.01102987f, 
    -0.11460944f, 0.01536244f, -0.01124580f, 0.06511397f, -0.07422938f, 0.18664896f, 0.26588294f, -0.06821903f, 
    0.10174473f, 0.02665197f, -0.05679574f, 0.01050498f, -0.03679642f, 0.11024863f, -0.00263880f, 0.06640850f, 
    0.07208332f, 0.11624921f, -0.04594131f, -0.00603068f, 0.03267310f, 0.07593308f, -0.06160378f, 0.05322086f, 
    0.06424341f, 0.02132597f, -0.13227943f, -0.14652513f, 0.07281552f, -0.04029645f, 0.01958521f, 0.00885272f, 
    0.07369536f, 0.05244933f, -0.08904495f, -0.00041458f, 0.12730145f, 0.04410906f, 0.08907532f, -0.07911010f, 
    -0.36821261f, -0.02740325f, -0.04038425f, 0.09412494f, 0.05881694f, 0.03201792f, 0.06187506f, -0.01404105f, 
    0.04511040f, 0.04036466f, 0.02421367f, 0.01367603f, 0.31400135f, -0.11988577f, -0.12728989f, 0.03993744f, 
    -0.07639075f, 0.03489382f, -0.04633589f, 0.11704318f, 0.06491818f, 0.05712951f, 0.14243162f, 0.08125859f, 
    0.21305844f, 0.08544113f, -0.10763350f, 0.01530077f, -0.00186853f, 0.00222091f, 0.07595913f, 0.04726750f, 
    0.05323403f, -0.05008526f, 0.01513792f, -0.00473644f, 0.18920039f, -0.01660602f, -0.09407074f, -0.09437386f, 
    0.05107836f, 0.11040658f, 0.01031076f, -0.04263104f, 0.04519862f, -0.00041863f, -0.05158071f, -0.04681514f, 
    -0.03568881f, 0.05685682f, 0.08071117f, 0.02920784f, 0.04545855f, -0.07681381f, -0.08168719f, -0.00422969f, 
    -0.00296246f, 0.02605977f, -0.02759415f, -0.08413927f, 0.33058453f, -0.14627808f, -0.12689155f, 0.07499082f, 
    0.05028912f, -0.05349917f, -0.04273263f, -0.03541203f, -0.11260752f, -0.01654666f, 0.01646941f, -0.03377785f, 
    -0.18521270f, -0.01954415f, -0.09555969f, 0.01139823f, 0.03725369f, -0.01916490f, 0.01343025f, 0.06268748f, 
    0.03292548f, -0.16571014f, 0.09214168f, -0.01059021f, 0.13419582f, -0.26224074f, -0.03695771f, 0.09048107f, 
    0.04033404f, 0.10864878f, -0.14605469f, 0.10070065f, -0.02114247f, 0.08287571f, 0.06868144f, 0.04913066f, 
    0.07763890f, -0.03344310f, 0.03395800f, 0.06066862f, -0.02664928f, 0.03333477f, -0.05199066f, 0.05876783f, 
    -0.06671836f, -0.00881701f, 0.07285326f, 0.09771314f, 0.13012224f, 0.01518524f, -0.03828479f, 0.04474322f, 
    0.09765957f, 0.02778418f, 0.04299838f, -0.07936625f, 0.05959779f, 0.06504354f, 0.04404299f, 0.27046987f, 
    0.23026901f, 0.04287407f, 0.05879270f, -0.02903355f, 0.01826626f, -0.06321884f, 0.01617383f, 0.04599873f, 
    0.06074269f, -0.10648041f, 0.03097891f, -0.02774136f, -0.12449200f, -0.00643729f, 0.00969889f, 0.14446932f, 
    0.01793486f, -0.08410613f, -0.06787901f, -0.02178896f, 0.02700970f, 0.06629640f, 0.05138194f, 0.10601969f, 
    0.07029545f, 0.02723337f, 0.12767233f, -0.13989228f, 0.12660193f, 0.05411940f, -0.09594373f, -0.11768498f, 
    -0.16406298f, 0.02909296f, 0.00071702f, -0.20722276f, 0.03632542f, 0.08897121f, 0.12386825f, -0.09755430f, 
    0.15671283f, -0.08339547f, -0.03172786f, -0.08818365f, -0.00554325f, 0.05997024f, 0.09996704f, 0.01155292f, 
    -0.20989215f, 0.22603434f, 0.14868973f, -0.03361401f, -0.00762693f, 0.00688041f, -0.02296884f, -0.13207833f, 
    -0.02049860f, 0.05539103f, 0.02327177f, 0.13510531f, 0.04798638f, 0.08587511f, 0.02256214f, -0.08441473f, 
    0.11830670f, -0.07256787f, -0.03448554f, 0.00426244f, 0.05636560f, -0.03957181f, -0.08020864f, -0.03799513f, 
    -0.37665015f, -0.11203536f, 0.01662423f, -0.13404219f, 0.16081361f, 0.04685470f, -0.07162544f, -0.12934060f, 
    0.00729544f, -0.02394781f, 0.09362332f, 0.03142086f, -0.04941146f, 0.02840256f, 0.10575806f, 0.13119213f, 
    0.03562968f, -0.01360118f, -0.00599877f, 0.12033322f, 0.09353502f, 0.01552393f, 0.04037900f, 0.15192293f, 
    -0.18279013f, -0.00271692f, 0.09200411f, 0.17919791f, 0.00037375f, -0.08866603f, 0.05798839f, 0.08170941f, 
    0.09720936f, 0.05766136f, 0.13634947f, -0.00658239f, 0.02416485f, 0.04650499f, 0.06411743f, 0.06349136f, 
    0.02981655f, 0.02254956f, -0.00377266f, -0.03177460f, -0.11566249f, 0.12085191f, 0.06307181f, 0.04679640f, 
    0.13589118f, -0.08880004f, 0.02748429f, 0.00237721f, -0.01783304f, -0.01845570f, 0.06764316f, 0.05362217f, 
    -0.05881470f, 0.00103848f, -0.03685413f, -0.01323452f, -0.03296518f, 0.12507133f, -0.01712926f, 0.02188540f, 
    0.05283630f, -0.05855550f, 0.01509347f, 0.01810925f, -0.03988144f, -0.04509621f, 0.07316494f, 0.07780453f, 
    0.20965745f, 0.04300250f, 0.00229620f, -0.12152845f, -0.03842919f, 0.07954594f, -0.18434013f, 0.01884997f, 
    -0.03806303f, 0.02116546f, -0.05346503f, -0.00448268f, -0.12627015f, -0.02477307f, 0.00415886f, 0.17011347f, 
    0.07577720f, 0.10697129f, 0.09691764f, -0.14262167f, -0.03981652f, 0.00835847f, -0.08989605f, 0.14868426f, 
    0.02544685f, 0.02544519f, 0.01425731f, 0.16051640f, 0.05430823f, -0.01590287f, -0.01641287f, -0.09036079f, 
    -0.06222951f, 0.16285986f, 0.19595465f, 0.19769286f, 0.01034665f, -0.05286171f, -0.20151657f, -0.09548461f, 
    0.03242295f, -0.10795551f, -0.00049695f, -0.06953556f, 0.01057431f, -0.09563912f, 0.12764449f, 0.17121544f, 
    -0.17876366f, -0.16828501f, 0.14697416f, 0.18215077f, -0.04715867f, -0.12596208f, -0.21259327f, -0.01387691f, 
    -0.00779640f, -0.04037362f, 0.19597971f, -0.03869883f, -0.31730914f, -0.07635310f, -0.03779804f, 0.10367022f, 
    0.09831563f, 0.03870900f, 0.09419499f, -0.05295988f, 0.05047492f, 0.06060110f, -0.01242769f, -0.03944293f, 
    -0.04181495f, -0.13887902f, 0.09441904f, 0.15728281f, 0.10583164f, 0.09584671f, -0.00284715f, -0.08320411f, 
    -0.03856404f, -0.02935318f, -0.08101407f, 0.17864144f, 0.16101679f, -0.04048553f, 0.04165583f, -0.15344553f, 
    0.07333701f, -0.00866586f, -0.03745070f, -0.32382274f, 0.04532044f, -0.03403141f, -0.31088972f, 0.01158456f, 
    -0.13002867f, 0.06458020f, 0.06761142f, -0.15305999f, -0.01376632f, 0.04873201f, 0.08646949f, 0.03765443f, 
    0.13030574f, 0.07439378f, -0.07147107f, -0.07825585f, 0.17214276f, 0.13092335f, 0.02193983f, -0.17040946f, 
    -0.01325035f, -0.01091940f, -0.07163329f, 0.00809981f, 0.21166819f, 0.14150561f, -0.07931649f, 0.01923999f, 
    -0.47685313f, -0.16597590f, 0.02806878f, 0.04544301f, 0.10441115f, -0.05732663f, 0.09250740f, 0.00666514f, 
    0.17573257f, -0.11645080f, -0.02428774f, 0.01187347f, 0.14218168f, 0.05129026f, 0.06312626f, 0.00201339f, 
    0.13600402f, 0.04429553f, 0.07069742f, -0.02965909f, 0.03718470f, -0.15803158f, 0.02750440f, 0.10471823f, 
    -0.08564644f, -0.05277700f, -0.00795330f, 0.01670044f, 0.02990431f, 0.14769004f, 0.04379027f, -0.04952007f, 
    -0.01510090f, 0.06398733f, -0.06921864f, -0.04639572f, 0.05662813f, -0.09671091f, -0.05340930f, 0.02450767f, 
    0.09392762f, 0.14970574f, 0.06457202f, -0.12525043f, 0.05915820f, 0.10789890f, -0.20846556f, 0.20402442f, 
    -0.00356160f, -0.02652869f, -0.09742223f, -0.04299182f, 0.05764976f, 0.11498032f, -0.02446378f, 0.00773924f, 
    -0.09043970f, 0.07181529f, 0.03602441f, 0.12138095f, 0.07566074f, 0.18791968f, 0.14443326f, 0.03684269f, 
    0.10210852f, 0.02386314f, -0.10401660f, -0.00743117f, -0.09377456f, -0.01644149f, 0.05362696f, -0.05617803f, 
    0.20328182f, 0.09546494f, -0.01178354f, -0.03054498f, -0.00375447f, 0.03748560f, 0.07404123f, -0.15259004f, 
    -0.11347027f, 0.05737263f, 0.03716068f, 0.04854507f, 0.06569934f, -0.03389377f, -0.12517926f, 0.14840370f, 
    0.04522778f, 0.02120549f, -0.12287987f, -0.00167238f, 0.05454507f, 0.12094440f, 0.02827496f, -0.04066245f, 
    0.20091774f, 0.16924731f, 0.08539523f, -0.08631897f, 0.09954562f, -0.08378201f, -0.02692779f, 0.01917787f, 
    -0.02576603f, 0.01256922f, -0.05529658f, 0.07167605f, -0.04669539f, -0.15191209f, -0.01043264f, 0.10035101f, 
    0.08126740f, -0.03027958f, -0.01757625f, -0.00942649f, -0.04063738f, -0.06960300f, -0.14265980f, -0.05236467f, 
    0.13504183f, -0.02584461f, -0.11775059f, -0.08035849f, -0.05051405f, -0.06444967f, 0.04749266f, -0.07643960f, 
    -0.09741876f, 0.03851652f, 0.07782334f, 0.17384903f, -0.05554045f, -0.06503535f, 0.16341971f, -0.02722950f, 
    0.06855246f, 0.01303566f, -0.04782027f, -0.02825333f, 0.02502693f, 0.05590977f, 0.02593763f, 0.03330961f, 
    -0.01591879f, 0.01316422f, -0.08916808f, 0.06592862f, 0.09026419f, 0.01192605f, 0.04678601f, -0.08952833f, 
    0.03789236f, 0.13127372f, -0.05452638f, 0.13434479f, 0.23875715f, 0.04249415f, 0.09574371f, 0.03337744f, 
    -0.07777665f, -0.02988416f, -0.02318233f, -0.00819910f, 0.16841845f, -0.07949805f, -0.06363349f, -0.18457282f, 
    0.17116554f, -0.03169763f, -0.04057469f, 0.06711335f, -0.03883059f, -0.02333015f, -0.04851659f, 0.04803224f, 
    -0.06877463f, 0.03235625f, 0.04421102f, 0.06801999f, 0.09278720f, 0.04082653f, -0.02588615f, 0.18162616f, 
    -0.06323827f, 0.07145987f, -0.04140135f, -0.06719236f, -0.01849579f, -0.14121716f, 0.10903555f, -0.14203697f, 
    -0.02179595f, 0.12027376f, 0.14902169f, -0.04715656f, -0.11628616f, 0.07209249f, -0.10812471f, 0.02222159f, 
    -0.05194189f, 0.08109121f, 0.02085495f, -0.04233687f, -0.00583531f, -0.13607796f, -0.11641607f, 0.05780974f, 
    -0.09860322f, -0.01091092f, 0.04865212f, -0.06756312f, -0.09530818f, 0.00502929f, 0.01514888f, 0.07018918f, 
    0.14106941f, -0.01372510f, -0.03693954f, 0.07605693f, 0.05064667f, -0.00936807f, 0.01876061f, 0.04530758f, 
    0.04231008f, -0.02821933f, -0.06765732f, 0.05935679f, -0.01887426f, -0.00132142f, -0.06596168f, 0.00759254f, 
    0.04728610f, -0.06958781f, 0.00536040f, 0.11141723f, 0.02823663f, 0.09122592f, 0.04186047f, -0.02701080f, 
    -0.11389065f, 0.20000370f, -0.05861465f, -0.05109089f, 0.07736537f, 0.02187549f, -0.12336275f, -0.03914333f, 
    -0.07525879f, -0.05147394f, -0.03112173f, 0.05949381f, -0.03330672f, 0.15843774f, -0.01074347f, 0.09642434f, 
    -0.02829994f, 0.10471593f, 0.10407568f, -0.07291470f, 0.02603311f, 0.05528900f, 0.10777548f, -0.13673316f, 
    -0.05668911f, 0.20178993f, 0.06589765f, 0.01403541f, 0.02756636f, 0.02616087f, 0.02798609f, -0.00606935f, 
    0.06276014f, -0.11166229f, 0.08761525f, 0.05464058f, -0.01191764f, 0.10966384f, 0.00093865f, -0.10607710f, 
    -0.06968395f, 0.08126073f, 0.14010195f, -0.06947695f, 0.06078983f, 0.07285815f, 0.01396237f, -0.03415731f, 
    0.13343804f, -0.01212095f, -0.01859171f, 0.16987047f, -0.06572991f, 0.01687195f, 0.00610882f, -0.18099461f, 
    0.03465639f, -0.16986959f, 0.05005040f, -0.09669507f, -0.10603142f, -0.30875844f, -0.13262677f, -0.36307213f, 
    0.04899066f, 0.08914738f, 0.01901848f, 0.04602983f, 0.04658245f, 0.01728752f, 0.12669864f, 0.12017886f, 
    0.00770987f, 0.06254124f, 0.06488704f, 0.05032321f, 0.11745620f, 0.11596964f, -0.03908078f, 0.07283718f, 
    -0.05838294f, 0.15813415f, 0.02700723f, 0.17146328f, -0.01998194f, -0.06770585f, -0.16815007f, -0.14000686f, 
    -0.00896178f, -0.01256480f, 0.16164429f, 0.06579436f, -0.07624163f, -0.00275691f, -0.16364785f, 0.12341497f, 
    0.07570231f, 0.20415229f, -0.11401011f, 0.16993339f, 0.01223916f, 0.07191784f, 0.02594749f, 0.04809394f, 
    0.03493759f, 0.00084045f, -0.09867082f, -0.04699035f, -0.16477765f, 0.11032599f, -0.20861274f, 0.17413752f, 
    0.12039990f, 0.05116447f, 0.00540726f, -0.12755273f, -0.06984279f, 0.04346102f, 0.14093418f, -0.01267776f, 
    0.12935165f, -0.03373728f, -0.02252919f, -0.02196747f, 0.15380764f, -0.04358770f, 0.03212778f, -0.11813372f, 
    -0.05369168f, 0.18111809f, 0.03345003f, 0.10401468f, -0.07437247f, 0.25353655f, 0.09207132f, 0.03590775f, 
    0.00745075f, -0.08725013f, 0.16654098f, 0.05353040f, -0.04051723f, -0.09435080f, -0.00387831f, -0.01627061f, 
    -0.06088242f, -0.08040828f, -0.12227277f, -0.11103246f, 0.13597882f, 0.07040799f, 0.00246602f, -0.05322095f, 
    0.00993553f, -0.06777689f, 0.04206445f, 0.04846995f, -0.04749653f, 0.16506915f, -0.02713970f, -0.18233618f, 
    0.00775695f, -0.03693505f, 0.02234017f, -0.00955902f, -0.15883084f, -0.10936642f, -0.04073025f, -0.06265203f, 
    0.26926720f, 0.08205272f, 0.02676219f, 0.17426419f, -0.07495304f, -0.01317347f, 0.02606364f, 0.10921321f, 
    -0.09744894f, 0.02484779f, -0.02159692f, -0.06538550f, 0.13313922f, -0.06811645f, -0.10397720f, -0.24327083f, 
    0.09229263f, -0.00075797f, -0.03749242f, 0.00486448f, 0.02802525f, 0.09925506f, 0.10219066f, 0.07761317f, 
    -0.05350046f, 0.07002551f, 0.16532953f, -0.00594454f, 0.12223926f, -0.05786024f, -0.02061747f, 0.10296031f, 
    0.01192186f, -0.06100235f, 0.02830706f, 0.11650663f, 0.13781218f, 0.20901909f, 0.11210937f, 0.16494928f, 
    -0.04923324f, 0.03883373f, -0.09670238f, 0.08137082f, -0.03076189f, 0.07021042f, -0.00122857f, 0.08782880f, 
    -0.08918327f, -0.04914175f, -0.00665558f, 0.13846962f, -0.06770901f, 0.00871497f, 0.12936468f, -0.01348985f, 
    0.09712229f, 0.03878005f, 0.00083565f, 0.09991239f, -0.17308643f, -0.13782214f, 0.06426825f, -0.09000716f, 
    0.00501310f, 0.00063032f, 0.08942961f, 0.14757910f, 0.06500255f, 0.04725049f, 0.09051346f, -0.01275877f, 
    0.29994893f, 0.20194572f, 0.04065623f, -0.07869889f, -0.11959587f, -0.03531809f, 0.06573176f, -0.01098445f, 
    0.03587964f, -0.03678407f, -0.03412715f, -0.08939122f, -0.00540334f, 0.01790319f, 0.16771565f, -0.01018950f, 
    0.08990634f, 0.02679726f, -0.00884582f, -0.00521357f, 0.14400244f, -0.10876673f, -0.12109815f, -0.20711973f, 
    -0.13605113f, 0.00691651f, -0.05034415f, -0.01508868f, -0.04616192f, 0.09913193f, 0.05950807f, 0.02849613f, 
    -0.10063363f, 0.05124785f, 0.07472440f, -0.00375710f, 0.03146077f, -0.09069515f, 0.02142992f, -0.19207107f, 
    0.02681694f, -0.02530793f, 0.02265081f, 0.02665712f, -0.10489419f, -0.12014303f, -0.02422410f, -0.00527590f, 
    -0.07909708f, -0.05972903f, 0.01675820f, 0.12595735f, -0.08456308f, 0.07758144f, 0.11656550f, 0.02430819f, 
    0.09874265f, 0.02439291f, -0.10182115f, 0.14930068f, 0.12408133f, 0.05237963f, -0.02900078f, 0.03739201f, 
    -0.14828059f, 0.01839960f, 0.06750336f, 0.04662951f, 0.05322311f, -0.01199119f, -0.18727551f, 0.04429636f, 
    0.22626618f, -0.02147059f, 0.23550077f, -0.08855013f, -0.01572560f, -0.05049860f, -0.02363995f, 0.03064003f, 
    0.06093742f, -0.02580857f, 0.00068557f, -0.01344761f, -0.03006421f, -0.00759164f, -0.03123536f, 0.07242537f, 
    0.15478635f, 0.07552414f, 0.08930241f, 0.00682939f, 0.07427464f, 0.09227258f, 0.02965481f, 0.04510704f, 
    0.18358542f, -0.05705676f, 0.10669366f, -0.07410210f, -0.18815058f, 0.03923935f, 0.04462214f, -0.00286570f, 
    0.09154723f, -0.10143501f, -0.17402732f, -0.02926750f, 0.11439561f, -0.21096483f, -0.12986910f, -0.07844274f, 
    -0.06103194f, -0.01254341f, 0.01495784f, 0.00553061f, -0.02164881f, 0.01170213f, -0.02106304f, -0.09754934f, 
    0.09492645f, -0.09978689f, -0.08389578f, 0.11128751f, 0.01098235f, 0.06808539f, -0.02787414f, 0.02956580f, 
    0.10599192f, -0.02505712f, -0.03740242f, -0.04927875f, 0.16218424f, -0.00959494f, -0.21652539f, 0.15681148f, 
    0.07792450f, -0.00383746f, -0.00493182f, -0.03231430f, 0.11496492f, -0.13465899f, 0.05249668f, -0.01415249f, 
    0.20579851f, 0.15622595f, -0.10720512f, -0.08604285f, -0.08647531f, 0.05640315f, -0.00355455f, 0.00074413f, 
    -0.01344454f, 0.01724535f, 0.03845530f, 0.10987377f, -0.31565231f, 0.01474864f, -0.18072458f, 0.13546918f, 
    -0.04505443f, 0.00944300f, -0.08224531f, -0.00617053f, 0.02926839f, 0.03972531f, 0.10516950f, 0.02221374f, 
    0.01054097f, -0.13325255f, 0.05550569f, -0.31261489f, 0.13993539f, -0.08916714f, 0.11389001f, 0.09714241f, 
    0.05109943f, 0.02806142f, -0.01858906f, 0.12041236f, 0.16502964f, 0.05779029f, -0.02828210f, -0.07781897f, 
    -0.07428243f, -0.03526485f, 0.01126575f, 0.09128290f, 0.02564375f, 0.00866508f, 0.03360359f, -0.04879284f, 
    -0.27365962f, -0.18160661f, -0.04673099f, -0.02430320f, -0.05947359f, -0.03995140f, -0.01468187f, 0.07004873f, 
    -0.01086073f, -0.00590208f, -0.10062651f, -0.13284937f, 0.28907239f, 0.17397854f, 0.06464281f, -0.03847121f, 
    0.01428539f, -0.03628550f, 0.06068845f, 0.01812215f, -0.03104747f, -0.09543519f, -0.04895698f, -0.06241373f, 
    0.31430614f, 0.06258272f, -0.02350647f, 0.12560143f, -0.08651341f, 0.06014936f, 0.14201644f, 0.12784415f, 
    -0.06436608f, 0.00158454f, 0.00236311f, 0.10055465f, 0.10242910f, 0.00833489f, -0.10354888f, -0.17164144f, 
    0.00216048f, 0.02731412f, -0.04541732f, 0.05544385f, 0.01789629f, 0.05976276f, 0.01940843f, 0.07717688f, 
    -0.13746668f, -0.07955867f, -0.05206301f, 0.09436805f, -0.13154276f, -0.06532333f, -0.05528383f, 0.08046561f, 
    0.03372350f, 0.10611223f, 0.15664403f, -0.06064126f, -0.05466080f, -0.00089610f, 0.11577823f, 0.04880244f, 
    0.00137293f, -0.00948825f, 0.00854891f, 0.12037222f, 0.07040139f, 0.05105614f, 0.19609047f, -0.01692337f, 
    0.00150721f, -0.07551042f, 0.10965831f, 0.07854198f, -0.06969492f, 0.05342626f, 0.03675849f, -0.07799251f, 
    -0.06221339f, 0.05171328f, 0.10578381f, 0.12684622f, -0.08376357f, 0.22980282f, -0.00191754f, 0.01217626f, 
    0.08797222f, 0.00914614f, -0.04812182f, 0.05805150f, -0.02278338f, 0.06166140f, 0.16792308f, 0.00354862f, 
    -0.07124715f, -0.20563588f, 0.22156677f, -0.10614776f, -0.04296867f, 0.03095789f, -0.02719058f, -0.00575113f, 
    -0.02804390f, 0.05771529f, 0.06556470f, 0.10463402f, -0.07658676f, 0.06395748f, 0.02880733f, 0.00268535f, 
    0.02019230f, -0.08013491f, -0.04791498f, -0.00310878f, 0.02577057f, 0.03441829f, 0.03018271f, -0.12479927f, 
    0.10436667f, 0.03946125f, -0.01970471f, 0.01708523f, -0.03692325f, -0.13306649f, -0.06552742f, 0.04317940f, 
    -0.11183506f, 0.02121921f, 0.09597484f, 0.01085010f, -0.09616925f, -0.02490576f, -0.06350604f, 0.17981558f, 
    -0.00321500f, 0.00821940f, 0.08674523f, 0.08087730f, -0.03987053f, 0.10064486f, 0.15869258f, -0.12459122f, 
    0.15643458f, 0.09403247f, 0.22214276f, 0.12222666f, -0.08466805f, 0.05488068f, 0.01759634f, 0.04971496f, 
    -0.00162612f, 0.02245974f, 0.00853006f, -0.21083264f, -0.17258048f, 0.10392380f, 0.12965071f, -0.10555992f, 
    -0.08989263f, 0.08691812f, 0.01852041f, 0.05789916f, 0.13822879f, 0.05520980f, 0.05088441f, 0.09931092f, 
    0.35817865f, -0.06225024f, -0.03038018f, -0.00675920f, 0.05409473f, 0.08202834f, 0.04533936f, 0.21421440f, 
    -0.05019309f, -0.08631523f, -0.02618158f, 0.01347478f, -0.01005158f, -0.06295581f, 0.04658417f, -0.01162498f, 
    -0.06343967f, 0.02920369f, 0.08286455f, -0.02598264f, 0.05795990f, 0.02348070f, 0.12656194f, 0.05764017f, 
    0.15747967f, 0.08651404f, 0.14374378f, -0.05504950f, 0.01071275f, -0.00101712f, -0.06603396f, 0.01321761f, 
    -0.09848461f, -0.09693531f, 0.08556017f, -0.01170767f, -0.04807686f, -0.16187382f, 0.05039041f, -0.12517482f, 
    -0.00792629f, 0.09626825f, 0.03354871f, 0.06045124f, 0.10730185f, 0.00535103f, 0.08947755f, -0.05258343f, 
    -0.26555333f, -0.04963309f, -0.01831796f, 0.13460375f, 0.04955578f, 0.04226129f, -0.03554846f, 0.09636661f, 
    0.03941150f, -0.01264261f, -0.02715832f, -0.20517470f, 0.22101310f, 0.08756793f, -0.09155454f, 0.00256567f, 
    -0.16719554f, 0.01261738f, 0.15798976f, 0.02756504f, 0.01529272f, 0.02818559f, 0.09099752f, -0.06543869f, 
    0.12880656f, -0.03623717f, 0.04865951f, 0.04875569f, -0.05616497f, 0.05924802f, 0.04808820f, 0.12127712f, 
    -0.05909748f, -0.08717986f, 0.00592936f, -0.05382850f, 0.13819930f, 0.21892105f, 0.20942861f, -0.09226475f, 
    -0.07835671f, 0.05288393f, 0.03466224f, 0.08748111f, -0.04335287f, 0.07270002f, 0.07053690f, 0.03254918f, 
    -0.09856158f, 0.18234891f, 0.10205881f, 0.00700567f, -0.05412317f, 0.10996453f, 0.02511972f, 0.11910123f, 
    0.01630062f, -0.05540480f, -0.04013057f, 0.05053781f, -0.08464938f, -0.07393444f, -0.00121319f, -0.12699650f, 
    -0.05220120f, -0.04927848f, -0.00558801f, 0.13520782f, 0.01744528f, 0.10948955f, 0.01975757f, 0.12280923f, 
    0.01009188f, -0.16521458f, -0.16420534f, -0.08038542f, -0.01824466f, 0.05202762f, 0.08270703f, 0.19129065f, 
    -0.07155981f, 0.05737652f, -0.07615888f, 0.10977000f, 0.22711653f, 0.11440259f, 0.03323931f, -0.14879052f, 
    -0.02838878f, 0.03656797f, 0.02749163f, 0.04193206f, 0.08060445f, -0.06482938f, -0.06274963f, 0.10740995f, 
    -0.14762306f, -0.33301619f, -0.26873952f, -0.16051304f, 0.01504416f, -0.01396092f, -0.03336690f, 0.02660419f, 
    0.00861862f, -0.03502003f, -0.07141867f, -0.07857279f, 0.22258252f, 0.11673938f, 0.14296544f, -0.08022737f, 
    -0.05973879f, 0.00746271f, 0.11086784f, 0.04253344f, -0.04782199f, -0.04415304f, 0.04208826f, -0.03799441f, 
    0.21159489f, 0.08838475f, 0.16625419f, -0.02759553f, -0.06388415f, 0.06119683f, 0.00592200f, 0.11197859f, 
    0.07768421f, 0.01711844f, 0.15998323f, -0.05364569f, -0.01437628f, 0.04720341f, -0.02252224f, 0.11581793f, 
    0.03942824f, -0.08695583f, -0.14172471f, 0.12844339f, -0.06945803f, -0.02782588f, -0.06664243f, 0.12233505f, 
    0.05182353f, 0.12381928f, -0.21148272f, 0.14242250f, -0.00178502f, 0.08612967f, -0.02097913f, 0.07195738f, 
    -0.00575924f, 0.06910621f, -0.18547544f, -0.10983005f, 0.12469596f, 0.09267738f, 0.04187243f, -0.10248847f, 
    0.09330552f, 0.07560113f, -0.05085051f, -0.04499053f, -0.04935707f, 0.06299607f, 0.10175434f, 0.03883412f, 
    0.12775959f, 0.02907853f, -0.18524830f, 0.00200652f, -0.01841071f, 0.10785449f, 0.01987192f, -0.00871645f, 
    0.05654635f, 0.01917343f, -0.02561077f, 0.04503420f, 0.42893124f, 0.08961055f, -0.07184660f, -0.01890383f, 
    0.10564823f, -0.01748735f, -0.00755096f, 0.10223051f, -0.00553008f, -0.06663031f, -0.07702670f, -0.05099425f, 
    0.17556170f, 0.04045245f, 0.01374470f, -0.16533159f, 0.06317773f, -0.13507612f, 0.00291955f, -0.00977710f, 
    0.00533981f, -0.06571044f, -0.08004431f, 0.01027540f, 0.34202656f, -0.10913686f, -0.05955290f, 0.08868157f, 
    0.06956223f, -0.08254232f, -0.04873199f, 0.06559761f, -0.05275856f, 0.05857330f, 0.00243310f, 0.11840513f, 
    -0.29741734f, -0.09083787f, 0.08166188f, 0.19920066f, -0.11317041f, -0.00191570f, -0.04444185f, 0.10908264f, 
    -0.04979694f, -0.01971034f, 0.04800499f, 0.05183538f, -0.09937158f, 0.25709540f, 0.03410982f, -0.09924061f, 
    0.18341200f, 0.00603187f, -0.02250965f, 0.04389738f, -0.03327031f, 0.02665769f, 0.06607911f, 0.01553774f, 
    0.10036571f, 0.05047141f, -0.07005861f, 0.09350365f, -0.00621174f, 0.07992958f, 0.06717347f, -0.01424425f, 
    -0.02994875f, 0.04095304f, -0.08146960f, -0.10145378f, 0.20067893f, -0.12750782f, -0.12719230f, 0.00843828f, 
    0.03214817f, 0.06398189f, -0.01116641f, -0.01078669f, 0.04425705f, 0.13429387f, 0.08397453f, 0.03843667f, 
    0.15338783f, 0.16288941f, -0.00732058f, 0.06369375f, -0.12471366f, -0.04108483f, -0.03304848f, 0.03524412f, 
    0.03505997f, 0.01969363f, 0.02222968f, -0.01619118f, 0.37583405f, 0.02518027f, -0.16078778f, -0.12962383f, 
    0.06081278f, 0.06686991f, -0.02456727f, 0.09873064f, -0.11206248f, 0.03283523f, 0.05777622f, 0.01171368f, 
    -0.16974498f, 0.12248963f, -0.06085089f, 0.12211698f, 0.00528238f, -0.04020856f, 0.17682217f, 0.01338139f, 
    -0.03284616f, -0.04778148f, -0.07992213f, -0.00094449f, 0.30440816f, -0.12627643f, -0.14202991f, -0.02121484f, 
    0.00237247f, 0.14552093f, 0.00712545f, 0.02910560f, 0.05132739f, -0.08919560f, -0.08527153f, 0.02774750f, 
    -0.18600917f, -0.10969304f, 0.07875802f, 0.11330894f, 0.10373381f, -0.06107706f, 0.10693414f, 0.04715218f, 
    -0.04326053f, -0.05219140f, -0.07501163f, -0.00918974f, -0.06610511f, -0.12854052f, 0.10101023f, 0.03176089f, 
    0.04002204f, -0.03218783f, -0.05962536f, 0.08409298f, -0.00479252f, -0.00479160f, 0.04542666f, -0.04356150f, 
    0.43535444f, -0.13879481f, -0.05795087f, 0.04871013f, -0.14054783f, 0.07915764f, 0.04515177f, 0.07760571f, 
    0.06958457f, -0.01961451f, 0.06577904f, -0.00804825f, 0.14176600f, -0.31053004f, -0.16619425f, -0.13920173f, 
    0.09668270f, 0.03447446f, -0.02390626f, 0.04100986f, 0.00230293f, 0.01151882f, 0.06398220f, 0.12508205f, 
    -0.07667818f, 0.15437786f, 0.02483296f, -0.11172634f, -0.01701591f, -0.02593693f, 0.03476428f, 0.01366764f, 
    -0.08615293f, -0.03669615f, -0.00210907f, 0.10841793f, 0.14970170f, 0.00720478f, -0.01085046f, -0.13433944f, 
    -0.03051154f, -0.03118922f, -0.03307680f, -0.03980561f, 0.07521170f, -0.02042632f, -0.03970838f, 0.08539228f, 
    -0.00714667f, 0.21750747f, 0.15803696f, 0.00395986f, 0.05817412f, -0.02664686f, 0.04628516f, -0.03703836f, 
    0.00542070f, 0.03711876f, 0.04440395f, -0.02517169f, -0.27079397f, -0.09149206f, 0.09283200f, -0.05322472f, 
    0.02999897f, -0.01821274f, -0.02271480f, -0.04440288f, -0.06478348f, 0.02316330f, -0.02225469f, 0.06962329f, 
    0.18512361f, 0.01652146f, 0.05169205f, -0.07307734f, 0.07685058f, 0.17167597f, -0.04711320f, -0.09986109f, 
    -0.08187474f, 0.01295135f, -0.04428453f, -0.01360168f, -0.07737622f, 0.00758770f, 0.02557071f, -0.18875185f, 
    0.08581734f, -0.01862661f, -0.05581541f, -0.03973098f, -0.02239070f, 0.03072483f, -0.03718820f, 0.06136930f, 
    -0.23055901f, 0.01320985f, 0.17944746f, -0.12781781f, 0.03368289f, -0.03907074f, 0.11576591f, -0.02468787f, 
    -0.02902452f, -0.02202342f, 0.04904990f, 0.08231106f, 0.23627102f, -0.06593550f, -0.04082135f, 0.05250953f, 
    0.06095392f, -0.02319694f, -0.03098520f, 0.04093302f, 0.04444402f, -0.03772851f, -0.05795290f, -0.00820448f, 
    -0.27903083f, -0.03457779f, 0.07489625f, -0.02124530f, 0.11525369f, -0.03995803f, 0.01027096f, -0.14434007f, 
    -0.06055629f, 0.03562232f, -0.02176028f, -0.01604475f, -0.09666433f, -0.10025904f, 0.21657228f, 0.06845504f, 
    -0.01122077f, 0.04021362f, -0.10001978f, 0.00588136f, 0.09688280f, 0.03072357f, 0.03122086f, 0.00823943f, 
    -0.09748842f, 0.03509850f, 0.03005506f, 0.19336534f, -0.03960668f, -0.00698689f, -0.06581680f, 0.05322574f, 
    0.15175150f, 0.03730529f, 0.00032670f, -0.06724065f, 0.20481160f, -0.00459999f, -0.05886745f, 0.13797644f, 
    0.01826659f, 0.07464485f, -0.07699671f, -0.03674840f, -0.02980885f, 0.09391639f, 0.02970862f, 0.00266811f, 
    -0.19195169f, 0.03765598f, 0.07497773f, -0.09743501f, -0.04892486f, 0.06884637f, -0.02071622f, 0.07558353f, 
    -0.12376314f, -0.01810432f, -0.14250936f, 0.00424273f, 0.44610968f, -0.08491070f, 0.00404012f, 0.16770117f, 
    -0.08863926f, 0.05183744f, -0.08054499f, 0.07074333f, 0.04796300f, -0.05142566f, 0.08706623f, 0.04380739f, 
    0.24177267f, -0.00286427f, 0.04878525f, -0.16812094f, 0.01014189f, -0.05850079f, 0.00398162f, 0.12656450f, 
    -0.01244994f, -0.05255203f, -0.06498868f, 0.14750709f, -0.21336953f, 0.13849978f, -0.03128191f, -0.15852676f, 
    0.03930153f, 0.03754377f, 0.07552581f, -0.01823805f, -0.04806076f, 0.05288101f, -0.01567282f, 0.08447205f, 
    0.26785576f, -0.04504505f, -0.08044405f, 0.11709751f, -0.02646347f, 0.07442886f, 0.00236769f, -0.16390996f, 
    -0.06256756f, 0.14206488f, 0.04455025f, 0.04671688f, -0.14079320f, 0.08238693f, -0.06773269f, -0.15550552f, 
    0.05384004f, -0.09398424f, 0.06839722f, -0.06114575f, -0.12657201f, -0.03907835f, 0.12375455f, -0.00584118f, 
    -0.13198531f, -0.17421235f, 0.23286986f, 0.16262563f, -0.07277309f, -0.09485342f, -0.11667708f, 0.01184535f, 
    -0.03752458f, -0.04411015f, 0.05046169f, -0.06102829f, 0.32794973f, 0.10829895f, -0.12225970f, 0.06846506f, 
    -0.07163233f, -0.09168478f, 0.02689742f, -0.01169466f, 0.03753076f, 0.05651170f, -0.03845354f, -0.00446059f, 
    -0.09045993f, -0.14085227f, 0.04521082f, 0.14390363f, 0.05133278f, 0.11823710f, -0.00628992f, 0.10052320f, 
    -0.05558003f, -0.02704357f, -0.06540372f, 0.07533025f, 0.14307874f, -0.18838906f, 0.06057604f, -0.16795376f, 
    0.12280922f, 0.00394453f, 0.09248976f, -0.21984033f, 0.11879027f, -0.05506064f, -0.02537851f, -0.13334130f, 
    0.05451019f, 0.08755776f, -0.07095167f, -0.09527863f, 0.03378024f, -0.01984530f, 0.05340595f, -0.03333821f, 
    0.06595016f, 0.09602281f, -0.00373764f, 0.02905032f, 0.03061908f, 0.16662969f, 0.08819190f, -0.06937540f, 
    0.01286549f, -0.02124117f, -0.04503578f, 0.02965643f, 0.13968934f, 0.04382209f, 0.00372738f, 0.08462443f, 
    -0.34948283f, -0.02391041f, 0.13853623f, 0.11640664f, 0.03794797f, -0.16819304f, -0.00777356f, -0.00831353f, 
    0.06047607f, -0.01943435f, 0.08397943f, 0.00583909f, 0.06921474f, -0.06171111f, -0.00405958f, -0.04940072f, 
    0.09134261f, 0.01676830f, -0.04571912f, -0.00391332f, 0.06931084f, -0.05105120f, 0.09073836f, 0.03087595f, 
    -0.28817511f, 0.04567965f, -0.00974102f, -0.27408966f, 0.05189713f, 0.09732330f, 0.04875949f, 0.03665853f, 
    -0.03127291f, 0.09444980f, 0.01734258f, 0.01828679f, 0.34083432f, -0.06288458f, -0.10152911f, 0.15608488f, 
    0.07828428f, 0.18795320f, 0.00376594f, 0.02049464f, 0.12800027f, 0.00255425f, -0.07586914f, 0.14932680f, 
    -0.01203662f, -0.00889254f, 0.02663390f, -0.08649147f, 0.02914528f, 0.07231939f, -0.02227047f, 0.02531020f, 
    -0.06417771f, 0.06010814f, 0.03661209f, 0.04690229f, 0.00798426f, 0.16655806f, 0.23035704f, -0.09145232f, 
    0.07850296f, -0.00183984f, 0.09003917f, -0.02954923f, -0.08240226f, 0.00486761f, 0.07004480f, 0.06126701f, 
    -0.03216450f, 0.04720123f, 0.09624838f, 0.08914664f, 0.02211950f, -0.06546108f, 0.24065354f, -0.07725424f, 
    -0.13252193f, -0.03598506f, 0.06653080f, -0.00969551f, 0.05550338f, -0.02169587f, -0.15853034f, 0.10071151f, 
    0.04807621f, 0.00138608f, -0.11880928f, 0.07673229f, 0.05267214f, -0.04964478f, -0.06159212f, -0.03072567f, 
    -0.05223915f, 0.08331235f, 0.16432260f, -0.00624190f, -0.03541526f, -0.07835363f, 0.02318635f, -0.01783539f, 
    -0.03969800f, 0.05546815f, 0.08229929f, -0.00584958f, 0.07291573f, -0.11227970f, 0.02681978f, 0.08010843f, 
    0.10713088f, -0.05678791f, -0.03060483f, 0.04685229f, 0.03976233f, -0.02539114f, -0.03502612f, -0.14223631f, 
    0.43873823f, 0.04702324f, -0.14022283f, -0.01558201f, -0.00785240f, -0.02357265f, 0.01641830f, -0.07118776f, 
    -0.01250732f, 0.02794727f, 0.00556954f, -0.02048497f, -0.09757698f, -0.00138886f, 0.01607653f, -0.07102748f, 
    -0.02557600f, 0.01599717f, -0.03020668f, -0.11487906f, -0.00698922f, -0.02373794f, 0.04468997f, 0.03015252f, 
    -0.16450600f, 0.15996601f, -0.09518560f, -0.08941711f, -0.07819375f, 0.02528669f, 0.05489426f, -0.05583537f, 
    0.06924771f, 0.05502691f, -0.07764477f, 0.10181351f, 0.00646353f, 0.06583565f, 0.21493737f, -0.06183839f, 
    0.06083634f, 0.03960360f, -0.02058541f, 0.00586008f, 0.06122662f, -0.00213191f, -0.07204871f, -0.07950518f, 
    0.09194831f, 0.14561793f, -0.01066010f, 0.03851825f, 0.05233828f, 0.03820452f, -0.01734600f, 0.03793637f, 
    -0.15408337f, 0.00286405f, -0.04177331f, 0.04804927f, 0.31097835f, -0.08300007f, 0.01673318f, 0.14482154f, 
    0.09517324f, 0.06253468f, -0.07324076f, -0.02414415f, 0.06085548f, -0.01572332f, 0.07799012f, -0.02653978f, 
    -0.08935263f, -0.03089124f, 0.18910477f, -0.06199653f, -0.07671743f, -0.01817665f, -0.12745161f, 0.08178593f, 
    0.00952992f, 0.17224205f, 0.03853811f, 0.02269101f, -0.10516164f, -0.01903983f, 0.01311425f, -0.07977802f, 
    0.03840246f, -0.01441716f, 0.00312639f, -0.01470294f, -0.16902314f, 0.06106702f, -0.05778725f, 0.06578280f, 
    0.26601365f, -0.04830136f, -0.00424856f, -0.02757959f, -0.05110878f, -0.05601934f, 0.10939842f, 0.07050707f, 
    0.00436116f, -0.09181051f, -0.07569632f, 0.03011503f, -0.02057540f, 0.00014329f, 0.13024886f, -0.23760375f, 
    0.04237511f, -0.07326741f, -0.03513341f, -0.01260386f, -0.04488122f, 0.00197912f, 0.09592012f, -0.12755841f, 
    -0.06066966f, 0.05129634f, 0.16245069f, -0.17576908f, 0.07727993f, 0.06238746f, -0.05801355f, 0.01707591f, 
    -0.02553109f, -0.12313619f, -0.00464082f, 0.04984926f, 0.04724295f, 0.15860756f, -0.00012900f, 0.20865077f, 
    -0.05942695f, 0.09880912f, -0.01304460f, -0.07638483f, -0.02072766f, 0.09163832f, 0.07401188f, -0.08752759f, 
    -0.00295826f, 0.01725814f, -0.01680818f, -0.03771058f, 0.00486966f, -0.03399844f, 0.01208170f, 0.00548535f, 
    -0.01542036f, -0.01427748f, -0.00691313f, -0.02992081f, 0.01340594f, -0.00424670f, 0.02082640f, -0.02670802f, 
    -0.00537008f, -0.01926967f, -0.03588112f, 0.01138930f, 0.02664865f, -0.03395492f, 0.02311984f, 0.02859704f, 
    0.02129361f, -0.02372519f, -0.03872690f, 0.00213061f, -0.00821531f, 0.00927292f, -0.01658560f, -0.01976937f, 
    -0.00525121f, 0.01310080f, 0.01037817f, -0.00688481f, -0.00334478f, 0.02981477f, -0.04063708f, -0.04190992f, 
    0.00892815f, -0.01245978f, 0.01948175f, -0.03912796f, -0.01267518f, 0.01276421f, 0.02354970f, -0.02215609f, 
    -0.02759065f, 0.02078140f, 0.01439936f, -0.02852293f, -0.00513565f, 0.01574474f, -0.01714525f, 0.00983061f, 
    -0.01969009f, -0.02784384f, -0.03937456f, -0.01107908f, -0.01174843f, 0.01579652f, -0.00544795f, -0.02119732f, 
    -0.00963227f, -0.02172560f, 0.00535344f, -0.03374686f, -0.00155140f, 0.01179680f, -0.03836169f, -0.00974499f, 
    -0.03263738f, 0.02223632f, -0.02992146f, -0.00553729f, -0.03579438f, -0.03102334f, -0.01481038f, -0.01267746f, 
    0.01257277f, -0.03392741f, 0.01361294f, 0.03003853f, -0.01208503f, -0.00091039f, -0.02194168f, 0.01333199f, 
    -0.01713341f, -0.01265633f, 0.01170940f, 0.02845609f, 0.00812726f, 0.02780421f, 0.01823514f, 0.02180209f, 
    -0.03743831f, 0.02104334f, 0.02440318f, -0.02680803f, -0.01491275f, 0.02104897f, 0.02722416f, -0.03119905f, 
    -0.04098440f, 0.01549524f, -0.03311931f, 0.02199409f, -0.02785344f, -0.04020961f, -0.00956194f, 0.00575623f, 
    0.02490083f, -0.00919633f, -0.02289576f, 0.02582625f, -0.01598309f, -0.02356531f, -0.03682205f, -0.00388249f, 
    -0.03989203f, -0.01281878f, -0.02792601f, 0.01808315f, -0.02573911f, -0.00656119f, -0.01009413f, -0.00000447f, 
    -0.00983062f, -0.01045485f, 0.01695088f, -0.03466013f, -0.03850091f, 0.01622742f, -0.00074352f, -0.01146306f, 
    0.01282236f, -0.04041575f, 0.02004115f, 0.02538625f, 0.02284206f, -0.01476745f, 0.00614288f, 0.00869394f, 
    0.01166405f, 0.01861647f, -0.02996934f, -0.01497256f, -0.02193000f, -0.02364163f, 0.00673613f, -0.01236448f, 
    0.02116426f, 0.01626515f, -0.01443341f, -0.02264868f, -0.01481719f, -0.02940612f, 0.00562177f, -0.01922714f, 
    -0.00022742f, 0.00182151f, 0.01910987f, -0.03507151f, 0.03555926f, 0.00614407f, -0.03819077f, 0.02894988f, 
    -0.04002852f, -0.01409002f, -0.03131920f, -0.01558982f, -0.01104412f, -0.04204611f, -0.01014231f, -0.03337139f, 
    -0.03820455f, 0.01039507f, -0.02948245f, 0.01776090f, -0.00772775f, -0.02300369f, -0.03118612f, -0.01947238f, 
    -0.02070233f, 0.01314448f, -0.03880590f, 0.02931087f, -0.01972651f, -0.02693987f, -0.04086753f, -0.02849472f, 
    -0.00900926f, 0.02821784f, -0.01828497f, -0.01213803f, -0.02589584f, 0.01924631f, -0.00439188f, 0.00844406f, 
    0.00040131f, 0.00760644f, 0.01115148f, -0.02417696f, -0.01710787f, -0.01628495f, -0.03308125f, -0.01686861f, 
    0.01143776f, -0.00854367f, 0.01381833f, -0.01523345f, -0.01940106f, -0.00883599f, -0.00756386f, 0.01831380f, 
    0.01523470f, 0.01444978f, -0.01212984f, 0.01401586f, -0.03522620f, -0.00303514f, 0.01957667f, 0.02084149f, 
    -0.02776984f, 0.01578823f, 0.01483900f, 0.01833056f, 0.01668729f, -0.00873809f, 0.02883351f, 0.00742962f, 
    -0.00258496f, 0.00212821f, 0.00298739f, -0.00927739f, -0.03884288f, 0.02555868f, 0.00295740f, -0.01368145f, 
    -0.03594466f, -0.04199593f, -0.01165106f, 0.02638469f, 0.01279225f, 0.02897954f, 0.02471985f, 0.00517275f, 
    0.02316313f, -0.03695626f, 0.02168058f, -0.02210303f, -0.02777440f, 0.01822926f, -0.00501284f, -0.00424493f, 
    -0.00404057f, 0.01178668f, -0.01709909f, -0.00796934f, -0.02015628f, 0.02660154f, -0.03037282f, -0.03301730f, 
    0.01829958f, 0.01825646f, -0.02978983f, 0.00810342f, 0.01991256f, -0.02449792f, -0.02672477f, -0.02358372f, 
    -0.02081482f, -0.03964710f, -0.00412545f, 0.02523547f, 0.02357440f, 0.02105840f, -0.00743640f, 0.00251103f, 
    0.03518584f, 0.02787909f, 0.01539169f, 0.01116705f, 0.00808503f, -0.01413185f, -0.03554076f, 0.02896001f, 
    0.01038719f, -0.01785948f, -0.03631241f, -0.01894994f, -0.01899371f, 0.03953591f, 0.02052820f, -0.04137044f, 
    0.02081328f, 0.02322699f, 0.00938852f, -0.02922967f, 0.01613872f, 0.01748892f, -0.00491437f, -0.00175954f, 
    -0.02086967f, -0.00951561f, 0.02670878f, 0.00724617f, -0.03737085f, 0.02253595f, -0.03948034f, -0.03298674f, 
    -0.02907673f, 0.00570933f, -0.04077459f, 0.01656527f, -0.02414253f, -0.03724032f, -0.02124784f, -0.02226419f, 
    0.01306623f, -0.03234947f, 0.00531480f, -0.02609834f, -0.02967984f, -0.00540506f, 0.00440992f, 0.02147646f, 
    -0.00835291f, -0.00595809f, -0.01269452f, -0.03224184f, -0.02373349f, -0.02540559f, -0.01386792f, -0.03881233f, 
    0.02509437f, 0.02971922f, 0.01098512f, -0.02315804f, -0.01926198f, -0.02193058f, 0.01393398f, 0.00914288f, 
    -0.01655215f, -0.03910542f, -0.02975793f, -0.00024765f, 0.01614713f, -0.01755080f, 0.00016288f, -0.00532225f, 
    0.02969527f, 0.01242848f, -0.03947650f, 0.01067933f, 0.00320002f, -0.01632045f, -0.00248300f, -0.00091600f, 
    -0.04107258f, 0.02979784f, -0.00127844f, -0.00443977f, -0.02439566f, -0.03498830f, -0.02723395f, -0.01290938f, 
    -0.03979388f, -0.03755642f, 0.01419497f, -0.03931060f, 0.00138705f, -0.00856548f, -0.02969352f, -0.00611073f, 
    -0.02160782f, 0.00440836f, -0.03388628f, -0.03573269f, 0.01006430f, -0.02976448f, 0.01200789f, 0.01110004f, 
    -0.03624462f, 0.02298955f, 0.02147046f, -0.01486486f, 0.01695535f, -0.01201150f, 0.00070437f, -0.04029799f, 
    0.01469569f, -0.02035044f, 0.02917179f, -0.02710971f, -0.04203587f, 0.00156797f, -0.00523581f, -0.04161552f, 
    -0.02083785f, -0.01238686f, 0.01890690f, 0.00185535f, 0.00564136f, 0.01266606f, 0.02294872f, 0.01809159f, 
    -0.03874757f, 0.01351597f, 0.02130033f, -0.03199562f, -0.03755123f, -0.01747533f, -0.04034156f, 0.00499968f, 
    -0.02588394f, -0.00629626f, 0.01776088f, -0.00979266f, 0.02552052f, -0.01820833f, 0.00919700f, -0.01095770f, 
    -0.02993678f, -0.03074404f, 0.00087014f, -0.02072107f, 0.00400698f, -0.02332613f, 0.01266058f, 0.02909788f, 
    -0.01524004f, -0.02606174f, -0.02570752f, 0.00587707f, 0.01205943f, -0.02462246f, -0.00810218f, 0.00319135f, 
    0.02944942f, 0.01746542f, 0.00727957f, 0.02220551f, 0.00391926f, -0.01638710f, 0.01363007f, 0.00880853f, 
    -0.04103654f, -0.03899343f, -0.02288293f, -0.00323885f, 0.01611583f, 0.02460343f, -0.03483002f, -0.03643728f, 
    0.02040478f, 0.00490482f, 0.01315593f, 0.02130140f, -0.01246859f, 0.02680095f, -0.02752177f, 0.01220038f, 
    0.00355057f, 0.01397002f, 0.02772603f, 0.00226840f, -0.00468860f, -0.00331772f, -0.00385517f, 0.01245710f, 
    -0.02555776f, -0.03438053f, 0.00418097f, 0.00257939f, -0.00378141f, -0.00961261f, 0.01704197f, 0.00525454f, 
    0.02056651f, -0.01449697f, -0.00398355f, -0.01130185f, -0.02341733f, -0.04188301f, 0.01354493f, -0.02702096f, 
    0.00524533f, -0.00595191f, 0.01431544f, 0.02656900f, 0.00378840f, 0.01823761f, 0.00055555f, -0.00439710f, 
    -0.01036670f, -0.03824818f, -0.00654484f, 0.00242955f, -0.01156752f, -0.00535406f, -0.03720967f, 0.01033406f, 
    -0.01984639f, -0.02581805f, 0.02580243f, -0.01802392f, 0.00632158f, -0.01268128f, 0.01076307f, 0.01891831f, 
    -0.00181366f, -0.00884588f, 0.01666151f, -0.00170202f, -0.04085303f, -0.02077910f, 0.01666943f, -0.01126345f, 
    0.01710444f, -0.02884676f, -0.00856629f, 0.00334030f, -0.01245069f, 0.02364182f, -0.01660796f, -0.03767700f, 
    0.02142568f, 0.02145447f, 0.02738076f, 0.01946659f, 0.01236684f, -0.03488198f, -0.00185549f, -0.03951329f, 
    -0.01760093f, -0.02001992f, 0.01279515f, -0.00425184f, 0.02016227f, -0.03523372f, 0.02640073f, -0.00204320f, 
    -0.04033314f, -0.02767817f, -0.00416777f, -0.02631825f, 0.00292539f, 0.03240122f, -0.01774956f, -0.00798367f, 
    -0.02234489f, -0.00839338f, 0.01759999f, -0.01942185f, 0.02109187f, 0.02163692f, 0.01433838f, 0.02916701f, 
    0.02258882f, -0.01955842f, -0.03428983f, -0.01258560f, 0.03319876f, -0.03476190f, -0.04079896f, -0.03457674f, 
    0.01863665f, -0.01974831f, -0.01386561f, 0.02884540f, -0.00291035f, -0.01859600f, -0.03976850f, -0.01742412f, 
    0.00691152f, 0.01609339f, -0.02867234f, -0.02841533f, -0.03000467f, -0.01695043f, -0.03315109f, 0.00557128f, 
    -0.02445979f, 0.00951083f, 0.01431003f, 0.01926761f, 0.02445722f, 0.02428640f, 0.02087943f, 0.01676663f, 
    0.00979946f, -0.03420240f, -0.03549564f, -0.02822741f, 0.01691691f, 0.02604816f, -0.04183674f, -0.01870059f, 
    -0.04089537f, 0.01045400f, 0.00609109f, -0.00948281f, -0.03258827f, 0.00889547f, -0.00028951f, 0.01840081f, 
    -0.04126557f, 0.00230759f, -0.02165805f, -0.00386829f, -0.02047182f, -0.02969928f, 0.02131600f, -0.04187888f, 
    -0.00782388f, 0.02544937f, 0.02382390f, -0.03373909f, -0.00209355f, 0.00848103f, -0.02659852f, -0.00716438f, 
    0.01242121f, -0.02177502f, 0.00579324f, -0.03097599f, 0.02791636f, -0.03466775f, -0.02714752f, 0.01459583f, 
    -0.02275031f, -0.01694196f, 0.02128757f, 0.00657301f, -0.02355911f, 0.01016747f, 0.02437148f, -0.02955619f, 
    0.00769893f, -0.01790124f, -0.03391628f, -0.02555743f, 0.01163654f, 0.02407627f, 0.01095756f, 0.01569336f, 
    -0.02328464f, -0.03225297f, 0.01366369f, -0.03166227f, 0.02799996f, -0.01727561f, 0.02542737f, 0.01463409f, 
    -0.00678234f, 0.01225484f, -0.02280298f, -0.02926684f, -0.01135858f, 0.02552560f, -0.01736163f, 0.01672061f, 
    -0.00048812f, -0.01859317f, -0.00330900f, -0.02983618f, 0.02784456f, 0.02622898f, 0.01140597f, -0.01555473f, 
    -0.00218226f, -0.03957734f, -0.03017929f, 0.01668750f, -0.02000038f, 0.00628545f, -0.03374065f, -0.03288094f, 
    -0.03274750f, -0.02335768f, 0.00797367f, -0.00755370f, -0.01588672f, -0.00083447f, -0.03349838f, 0.00087933f, 
    0.00642196f, 0.00199831f, -0.03565855f, -0.03449522f, -0.03128631f, -0.03137239f, -0.00837250f, 0.02392542f, 
    0.01830729f, 0.01621147f, -0.00378423f, -0.02618919f, 0.01116125f, -0.02135409f, -0.04035071f, -0.03565222f, 
    -0.03094003f, 0.02190581f, 0.02825816f, -0.02409221f, 0.00683475f, -0.02008807f, -0.02251415f, -0.00364825f, 
    -0.02640752f, -0.02664760f, 0.02283898f, -0.00557332f, 0.02002547f, 0.01932649f, 0.00159604f, -0.03184023f, 
    0.00886902f, 0.00908769f, 0.00355167f, 0.01765476f, 0.01220047f, -0.03893758f, -0.01900529f, 0.00086595f, 
    0.00129190f, 0.02444031f, 0.00205066f, -0.03487373f, -0.02983665f, 0.02432483f, -0.01544723f, 0.00384871f, 
    -0.00431689f, 0.00427477f, -0.02285624f, -0.00595911f, 0.00493318f, 0.00469354f, 0.02820604f, -0.03812007f, 
    -0.00635809f, 0.00096819f, -0.04019427f, -0.00815890f, -0.04039250f, -0.01843984f, 0.01909081f, -0.02874577f, 
    0.02144731f, 0.02264512f, 0.00784310f, -0.03221295f, 0.02499104f, 0.02943883f, -0.00601046f, -0.01746679f, 
    -0.03801278f, -0.01483819f, -0.01953464f, 0.01164553f, -0.02216990f, 0.00922314f, 0.02238834f, -0.01087468f, 
    0.02364865f, -0.02175762f, 0.19750483f, 0.12116647f, -0.02621932f, -0.05690847f, 0.01040877f, -0.14736915f, 
    0.10831687f, -0.07483390f, 0.04646419f, 0.08472504f, 0.00241280f, 0.00145756f, -0.06611323f, -0.03826814f, 
    0.07810088f, 0.02480227f, 0.02282379f, -0.04726230f, -0.01058861f, -0.02746929f, 0.07913439f, 0.04139338f, 
    -0.09471691f, 0.09364172f, 0.05523597f, 0.13386007f, 0.04714869f, -0.07303023f, -0.06411953f, 0.13473564f, 
    0.03979422f, -0.10867403f, -0.06767749f, 0.04221303f, 0.19266494f, 0.00525764f, -0.05278302f, -0.08543389f, 
    -0.01644136f, 0.02831502f, -0.00178944f, -0.07389917f, 0.00323937f, -0.00814090f, -0.06126737f, -0.08587223f, 
    -0.03615871f, 0.15210763f, 0.05634107f, -0.06953391f, -0.02097513f, 0.03955862f, -0.01505686f, 0.02692027f, 
    0.05466811f, 0.12108910f, -0.03342051f, 0.15334594f, 0.09921415f, 0.11848129f, 0.00253926f, 0.01452334f, 
    -0.09436066f, -0.03090397f, -0.00729753f, -0.09255687f, -0.06985043f, -0.01321799f, -0.07061181f, -0.01995232f, 
    0.14176317f, 0.04339633f, -0.06847060f, -0.11169800f, -0.11037385f, -0.00952381f, 0.02406648f, -0.12941705f, 
    -0.05414079f, 0.00449269f, -0.02962910f, -0.01537860f, -0.10909130f, -0.06245692f, 0.12614900f, 0.07475337f, 
    0.10284580f, -0.05884106f, 0.01114097f, -0.10541640f, -0.01613512f, 0.07054567f, -0.00582137f, 0.03125461f, 
    0.15192343f, 0.09010208f, -0.00340091f, -0.08538890f, 0.08380108f, -0.07693743f, 0.00677679f, 0.02761025f, 
    0.09109135f, 0.02837207f, 0.03613174f, 0.01524560f, -0.21862529f, 0.12024064f, 0.12743764f, 0.04502377f, 
    0.03976586f, -0.09129774f, -0.04738170f, 0.05663425f, -0.06994789f, 0.01595687f, -0.02883133f, -0.07806025f, 
    -0.05098645f, -0.04955298f, 0.05948512f, 0.07654400f, 0.07220066f, 0.07864386f, 0.00503567f, -0.00472824f, 
    -0.04097856f, -0.07934118f, 0.06236080f, 0.04961856f, 0.01135295f, -0.08169641f, -0.14239600f, 0.03816642f, 
    -0.12445708f, -0.04342258f, -0.03910778f, 0.03315028f, 0.01397714f, -0.02396278f, -0.00140179f, -0.00432520f, 
    0.26278466f, -0.01923582f, -0.09992111f, -0.09669401f, 0.02459404f, -0.05260413f, 0.00460022f, 0.06137838f, 
    0.03272320f, -0.01523407f, 0.06822304f, 0.06338926f, 0.23163816f, 0.13289817f, -0.06428149f, 0.02738913f, 
    0.00038567f, -0.09899782f, -0.00529903f, 0.03478466f, -0.01782036f, 0.12736666f, 0.01206882f, -0.08832682f, 
    -0.17027718f, 0.32016742f, 0.17074294f, 0.06184654f, 0.16345482f, 0.04670159f, -0.12283882f, 0.01165267f, 
    0.08731364f, -0.03038277f, 0.04593884f, 0.03070553f, 0.37128228f, -0.05100133f, -0.05001962f, 0.04196915f, 
    -0.01932933f, 0.05142472f, -0.08448918f, -0.11419678f, -0.09221064f, 0.04936814f, 0.06557148f, 0.07877152f, 
    -0.42973113f, 0.23458198f, -0.06380657f, 0.11995612f, 0.06540109f, 0.00168112f, 0.11800734f, -0.10973611f, 
    0.07833915f, -0.03122592f, -0.03010796f, 0.04293487f, -0.20500013f, -0.14252040f, 0.10092369f, 0.10790044f, 
    0.02344906f, 0.03652450f, -0.18037176f, 0.17678829f, 0.15395315f, 0.05719125f, 0.11618605f, -0.05451928f, 
    0.32488981f, -0.05870093f, -0.08406604f, -0.00255549f, 0.00269052f, -0.02696453f, -0.01853258f, 0.05225076f, 
    0.03181381f, -0.05676536f, -0.00222797f, -0.10480449f, 0.17645790f, -0.09851058f, -0.12198162f, 0.14868356f, 
    0.20144887f, 0.04491003f, -0.00184865f, 0.02115710f, 0.02558881f, -0.05518701f, 0.03132370f, 0.04531343f, 
    0.37957743f, -0.05409181f, -0.07866303f, -0.08141216f, -0.00080190f, 0.02590415f, -0.05929470f, 0.09160837f, 
    -0.02170345f, 0.00473355f, 0.12248188f, 0.04435421f, 0.22108066f, 0.08371963f, -0.06001136f, 0.09691830f, 
    -0.02884122f, -0.09463029f, -0.08980776f, 0.03226031f, 0.02780574f, 0.05131570f, -0.09523975f, 0.01637240f, 
    -0.23622476f, -0.14345595f, -0.09043542f, -0.16174309f, 0.00390058f, -0.06654939f, -0.00232643f, -0.02694790f, 
    0.01380443f, 0.02529239f, -0.10211924f, -0.03884413f, -0.02532676f, -0.07732543f, -0.13996962f, -0.06368600f, 
    -0.07429630f, -0.06622265f, 0.03058931f, -0.03015189f, -0.01661352f, -0.02287185f, 0.00453586f, -0.04142188f, 
    0.12346207f, 0.17054471f, 0.14225110f, 0.02567123f, 0.08203004f, -0.02751060f, -0.10558856f, 0.02496607f, 
    0.06602484f, 0.03422465f, -0.06082748f, 0.13464776f, -0.32510346f, 0.00640600f, -0.12286381f, -0.26135015f, 
    0.17188981f, -0.00791718f, -0.06268092f, 0.07146738f, -0.02333817f, -0.03540650f, -0.02860549f, 0.00558589f, 
    0.05781411f, -0.04937364f, -0.06831070f, -0.05873764f, -0.05276930f, 0.13456625f, -0.00597125f, -0.06895871f, 
    0.04539108f, -0.08355550f, -0.10033924f, -0.03114328f, 0.17750768f, 0.05850142f, 0.02106027f, 0.02820596f, 
    -0.10643476f, -0.13167222f, 0.05772564f, 0.03691087f, -0.08236157f, 0.04384499f, 0.00423394f, -0.02808763f, 
    0.17874740f, 0.00151986f, 0.12823486f, 0.13505237f, -0.06047098f, -0.01455760f, 0.08254478f, 0.02851272f, 
    0.04093802f, 0.05476217f, 0.15341219f, 0.10365542f, 0.30258727f, 0.05570047f, 0.20034169f, 0.10833209f, 
    0.01174409f, -0.02211816f, -0.00903129f, -0.05637728f, -0.01061705f, -0.09450100f, 0.06723224f, 0.08684386f, 
    0.44221756f, 0.05676913f, -0.20300317f, -0.20034868f, -0.01699110f, -0.03434192f, -0.03255538f, 0.01430787f, 
    0.03454044f, 0.09529724f, 0.06694964f, 0.09953391f, -0.24982728f, 0.27450094f, -0.15660186f, -0.08765439f, 
    0.10163300f, 0.00204119f, -0.00572660f, -0.10235589f, -0.04352235f, 0.02397041f, 0.05984623f, -0.02492220f, 
    0.01076389f, 0.19922175f, -0.00620254f, -0.02252099f, -0.06202071f, -0.00741665f, -0.02831500f, 0.04123158f, 
    0.00990347f, -0.00438694f, -0.09506613f, -0.03517996f, 0.08466540f, -0.19171986f, -0.13290264f, 0.06010576f, 
    0.06181491f, -0.00274440f, -0.05112762f, -0.05320431f, 0.02528759f, 0.04469611f, -0.05000224f, 0.06804583f, 
    -0.05898181f, 0.00333621f, 0.00640581f, 0.08777057f, -0.01309163f, -0.10432057f, -0.07099867f, 0.07865120f, 
    0.08870789f, 0.00680994f, 0.08001217f, 0.08097550f, 0.19248816f, -0.04025266f, -0.19249113f, 0.02666909f, 
    0.10358306f, -0.06932404f, -0.04825293f, 0.02263417f, -0.04408029f, -0.08917493f, 0.04856932f, -0.03574420f, 
    -0.01420968f, 0.02947734f, -0.05276343f, 0.05352915f, -0.09068487f, -0.05543168f, -0.06039581f, -0.03099722f, 
    -0.08367719f, 0.01157828f, 0.10163973f, 0.10108916f, -0.16793208f, 0.17010599f, 0.09750887f, 0.08637178f, 
    0.02616352f, 0.04125932f, -0.04246719f, 0.01492805f, -0.00542676f, 0.03901069f, 0.07695904f, -0.04039541f, 
    0.08846904f, 0.16060451f, -0.04348367f, 0.07042860f, -0.07353079f, -0.03903421f, -0.03598798f, -0.07840126f, 
    0.05993697f, 0.07553948f, 0.11812474f, 0.00170529f, -0.06135291f, -0.03835420f, -0.19782370f, -0.15507658f, 
    0.09166204f, -0.06702888f, -0.15231542f, -0.08175009f, 0.00567310f, -0.03854821f, -0.03852829f, 0.10141256f, 
    -0.23776695f, -0.14692228f, 0.00982194f, -0.13799286f, -0.04983028f, 0.06366535f, -0.00215810f, 0.01134272f, 
    0.07028709f, 0.09271096f, 0.01592570f, 0.01048923f, -0.04898842f, 0.08811243f, -0.17082830f, 0.02647650f, 
    0.10010225f, -0.00757157f, 0.06228453f, 0.00250944f, -0.08926038f, 0.11367770f, 0.03513884f, -0.08804835f, 
    -0.11172071f, -0.24091922f, 0.11524358f, -0.03515091f, 0.03368226f, 0.16240886f, 0.09791280f, 0.03414501f, 
    0.07956562f, -0.08048855f, 0.03099097f, 0.02268789f, 0.10060788f, -0.02867642f, -0.10775200f, 0.04452073f, 
    0.04871362f, -0.05660935f, -0.04316572f, -0.00014554f, -0.05869183f, 0.04569462f, -0.07951593f, 0.08873896f, 
    0.25048697f, -0.15432107f, -0.20755899f, 0.03259326f, 0.03863786f, -0.05613196f, -0.03260607f, -0.13508861f, 
    -0.01057202f, 0.07989311f, -0.05406420f, 0.01351947f, -0.03980699f, 0.00623051f, 0.15524237f, 0.01831942f, 
    0.15533468f, 0.03519242f, -0.04179067f, -0.01894119f, 0.06110850f, 0.12276410f, -0.01258575f, 0.03563271f, 
    0.07672772f, 0.14479429f, 0.04916807f, 0.04130231f, 0.08563326f, 0.01816171f, -0.02952395f, -0.01396780f, 
    -0.08270791f, -0.00619416f, -0.05887059f, -0.11424392f, -0.10454959f, 0.12794475f, -0.08276021f, 0.05853344f, 
    -0.00862244f, 0.04633463f, -0.01716446f, -0.05010156f, 0.13640359f, -0.02696249f, 0.08434127f, -0.07476609f, 
    0.23340362f, -0.01645437f, 0.03841225f, -0.10915229f, 0.03502573f, 0.02038493f, -0.09195083f, 0.01736933f, 
    0.01358646f, -0.04700291f, 0.00946916f, 0.10146783f, 0.00613540f, -0.10915432f, 0.07803393f, 0.09236353f, 
    -0.03894389f, 0.02786533f, 0.00546043f, -0.10272471f, -0.09632771f, 0.06486502f, 0.04440418f, -0.02184710f, 
    0.12715274f, 0.23790848f, -0.04912014f, -0.16237615f, 0.29985452f, 0.13535567f, -0.06363960f, 0.10605408f, 
    -0.07392965f, 0.01203168f, -0.04346202f, 0.07747871f, -0.02744619f, -0.04661161f, 0.12322953f, 0.06230370f, 
    0.02909898f, 0.07198723f, -0.00159520f, 0.05202682f, -0.06019730f, -0.04288642f, -0.00146775f, -0.11334760f, 
    -0.17405893f, -0.00556553f, -0.15737055f, 0.04864013f, -0.01425267f, -0.03971137f, 0.06494373f, 0.06783610f, 
    0.00883744f, -0.01163244f, 0.03960955f, -0.01080029f, -0.00054244f, -0.17272875f, -0.06653850f, -0.00462017f, 
    -0.00659282f, -0.02877738f, -0.00289634f, 0.11121733f, 0.02864356f, 0.02932654f, -0.00025563f, 0.04594639f, 
    0.13483898f, -0.32152608f, -0.18941866f, -0.08804429f, 0.05674725f, 0.00440857f, 0.02176559f, 0.02828780f, 
    -0.09604632f, -0.00314634f, -0.00676359f, -0.01265307f, 0.21936312f, 0.00837800f, -0.07114556f, -0.02907992f, 
    -0.03591103f, -0.05344786f, -0.03424837f, -0.00518675f, 0.06210124f, 0.12649652f, 0.09494141f, 0.04813087f, 
    0.11671957f, -0.01520277f, -0.02979187f, 0.11795919f, -0.00532547f, 0.03354288f, -0.06003422f, 0.10686713f, 
    0.11486661f, 0.04687912f, -0.01999196f, -0.04439462f, -0.11228578f, 0.07495021f, 0.04697528f, 0.14523949f, 
    -0.12512404f, -0.07290060f, 0.03734441f, -0.03026219f, -0.04247573f, 0.05092480f, 0.16338167f, -0.02850372f, 
    0.02460988f, 0.03732305f, -0.01744881f, -0.01392775f, 0.02485757f, 0.17070749f, -0.06334247f, -0.05806349f, 
    -0.01368851f, 0.00956498f, 0.02713063f, 0.04330647f, 0.15733345f, -0.11760016f, -0.09417213f, -0.03527522f, 
    -0.10840973f, -0.01036602f, -0.02964195f, -0.08167118f, 0.21732472f, -0.07892530f, 0.07176572f, 0.03342477f, 
    -0.01770727f, 0.19189142f, 0.03443582f, -0.03059723f, -0.04825646f, -0.08421668f, -0.06550518f, 0.04918595f, 
    0.07079241f, 0.05907009f, -0.09564806f, -0.17204548f, 0.29877868f, 0.03141681f, -0.06585512f, 0.24316768f, 
    0.14280617f, -0.04824222f, 0.01697741f, 0.09969303f, 0.07903082f, 0.08042021f, -0.00082472f, -0.14535132f, 
    -0.05306416f, 0.23106667f, -0.17398740f, 0.18047304f, 0.03240943f, -0.03741543f, -0.05291033f, 0.06795297f, 
    -0.02042082f, 0.09850051f, 0.00883091f, -0.06859051f, 0.04936054f, 0.04830129f, 0.11008585f, 0.09733751f, 
    0.01077409f, -0.06707184f, -0.08219166f, 0.02473130f, -0.13472459f, -0.00672248f, -0.04038908f, -0.18052946f, 
    -0.01519435f, -0.07513363f, 0.08801908f, 0.12281578f, -0.06454758f, -0.02949733f, -0.06172802f, -0.04267434f, 
    -0.00657869f, 0.13674697f, 0.07278568f, 0.02508333f, 0.20175347f, -0.12360977f, 0.20306233f, 0.22283061f, 
    -0.01764169f, 0.01874873f, -0.05517529f, 0.06779229f, 0.05880036f, -0.05711010f, 0.10997352f, 0.02762985f, 
    -0.18645734f, 0.18364383f, 0.14040118f, -0.02323172f, 0.16303499f, 0.12865537f, 0.03937271f, 0.12751561f, 
    0.10679308f, 0.16733754f, 0.01653087f, 0.09816656f, 0.26203790f, 0.00638463f, -0.09007586f, -0.03959376f, 
    -0.19778673f, -0.06527498f, 0.00296114f, -0.06620754f, 0.09839920f, 0.00751615f, -0.00779742f, -0.06841860f, 
    0.31406704f, -0.13481382f, -0.13687848f, 0.04092820f, 0.03224272f, -0.04446147f, -0.06512136f, -0.05803660f, 
    -0.02849085f, -0.11322724f, -0.15661985f, -0.07896000f, 0.18289971f, 0.05947339f, -0.07852867f, -0.02169240f, 
    -0.07828614f, -0.11470344f, -0.02178918f, -0.02911323f, 0.11570771f, 0.08856773f, 0.07015938f, -0.04167474f, 
    0.19220777f, 0.06450333f, -0.08997393f, 0.06739458f, 0.10922966f, 0.01792113f, -0.01242919f, 0.07962414f, 
    0.04894204f, 0.04307184f, 0.13283844f, 0.07264049f, 0.43593872f, -0.35075539f, 0.17995921f, 0.11169109f, 
    -0.05573349f, 0.09160619f, 0.01010377f, 0.03427334f, -0.01483747f, 0.07278790f, 0.02909252f, 0.07408114f, 
    0.08386346f, -0.16054769f, 0.01206370f, 0.02617288f, -0.03321003f, 0.01717722f, -0.04035632f, 0.21176882f, 
    0.09270848f, 0.01107678f, -0.06887916f, -0.15707697f, -0.24685146f, 0.19869480f, -0.03439630f, 0.13081951f, 
    0.18059543f, 0.09983376f, -0.03863765f, 0.00323055f, 0.10406905f, 0.10275459f, 0.06384683f, 0.00021736f, 
    0.24187107f, 0.04989675f, 0.05151251f, -0.00845041f, -0.11101490f, -0.00326255f, 0.02597699f, 0.01327509f, 
    0.06404714f, 0.06750933f, 0.03087461f, 0.02736419f, -0.04838373f, 0.24861406f, -0.10145626f, 0.00312876f, 
    0.08964156f, 0.12994319f, 0.01017388f, 0.03339298f, 0.08410642f, 0.02154675f, 0.12240043f, 0.14547873f, 
    -0.05104866f, -0.06479738f, -0.03542844f, 0.01539040f, -0.02968127f, -0.01699950f, 0.05273243f, 0.03335802f, 
    0.10983552f, 0.01994135f, -0.06166351f, -0.01739604f, 0.36814603f, -0.08649623f, 0.10971642f, -0.02010610f, 
    -0.13178392f, -0.03084589f, 0.00097450f, 0.03652654f, -0.03287360f, 0.10306915f, 0.08273112f, 0.03571279f, 
    -0.06311835f, -0.16101195f, 0.10699507f, -0.11907293f, 0.04651784f, -0.06698418f, 0.11128756f, 0.08827548f, 
    0.03518924f, 0.08324970f, -0.12565826f, -0.02382758f, 0.19413219f, -0.05949917f, -0.08895431f, 0.08720981f, 
    0.02909384f, 0.03286413f, 0.06170044f, -0.09511496f, 0.03459354f, 0.01963525f, 0.06750402f, -0.00994199f, 
    0.20352608f, -0.06924234f, 0.24422024f, -0.07629737f, 0.00666269f, 0.02195335f, 0.02970752f, 0.09737498f, 
    0.06752019f, -0.06797206f, 0.08844367f, 0.15221755f, -0.16461399f, 0.31523043f, 0.02146439f, -0.20398654f, 
    0.21544470f, 0.13505754f, -0.00965403f, 0.05385407f, 0.06032965f, 0.08571699f, -0.09769459f, 0.11311463f, 
    0.02721042f, -0.00118018f, -0.03526276f, 0.27818516f, 0.12076238f, 0.08198094f, 0.04076397f, 0.06300350f, 
    0.04898196f, 0.06390192f, 0.06916794f, 0.17193499f, 0.09358094f, -0.01879376f, 0.00303814f, 0.20723537f, 
    -0.04659550f, 0.03240311f, 0.09793812f, -0.03388831f, -0.06359845f, 0.01727117f, 0.05180163f, 0.16925423f, 
    0.02151993f, 0.10471974f, -0.11315209f, -0.00089513f, 0.17652875f, -0.03308621f, 0.10979759f, 0.17751585f, 
    0.05342738f, 0.04844588f, -0.00811201f, 0.08966105f, 0.03070317f, 0.18115295f, 0.03954929f, -0.19109851f, 
    0.01868941f, 0.04016742f, 0.07182305f, 0.01852282f, -0.02741781f, 0.09209142f, 0.08068641f, -0.01714550f, 
    0.11555735f, -0.09882035f, 0.15026088f, 0.19341631f, 0.05491325f, -0.00067796f, -0.05722499f, -0.05309388f, 
    0.00842673f, 0.06192586f, 0.07803269f, -0.10276518f, 0.02523548f, -0.14676921f, 0.11589898f, 0.03258128f, 
    0.03096111f, -0.01421895f, -0.00303583f, -0.04833052f, 0.07965726f, -0.09480010f, 0.11961603f, -0.00330865f, 
    0.15966095f, -0.11040552f, -0.07870760f, -0.02218397f, 0.06502152f, 0.05059435f, 0.00509669f, -0.01376590f, 
    -0.02466500f, 0.12032574f, 0.03082044f, 0.03956965f, 0.14135022f, -0.10454021f, 0.07470140f, 0.04663341f, 
    -0.10086631f, -0.02694677f, -0.01622926f, 0.07664767f, 0.12098314f, -0.01270671f, 0.04585706f, 0.06011557f, 
    -0.12764785f, 0.13814346f, -0.15410458f, 0.08195455f, 0.01701726f, 0.07154235f, -0.04594715f, -0.03586333f, 
    0.06096626f, 0.04373819f, 0.10021771f, -0.02128961f, 0.00673380f, 0.09436483f, 0.03318810f, -0.09192352f, 
    0.00197063f, 0.00673794f, -0.02532376f, -0.07296722f, 0.10419632f, 0.03743931f, 0.09486467f, 0.05862011f, 
    0.01989722f, 0.19881053f, 0.13902578f, 0.00196050f, 0.08908867f, 0.06785489f, 0.14415058f, 0.06267105f, 
    0.11884084f, 0.05477915f, 0.11129160f, 0.00385230f, 0.26251578f, -0.04098877f, 0.15478286f, 0.05039358f, 
    -0.06337568f, -0.09432550f, 0.11561444f, -0.06582154f, 0.04993288f, 0.11233377f, 0.08932037f, 0.03167515f, 
    0.14522612f, -0.06141897f, -0.10683890f, 0.10957917f, 0.19047247f, 0.10565483f, 0.09516491f, 0.14647532f, 
    0.00752319f, 0.07317488f, 0.07772034f, 0.02066732f, 0.35884011f, 0.27859929f, 0.09398638f, -0.05881695f, 
    0.01404939f, 0.00502026f, 0.07424276f, 0.00807471f, -0.00030230f, -0.05173363f, 0.04198918f, 0.13371266f, 
    0.01433286f, 0.03194454f, -0.16483334f, 0.05510880f, -0.03612027f, 0.04833232f, -0.07192571f, 0.07726409f, 
    -0.04053588f, -0.02604406f, 0.05718747f, -0.01013374f, 0.07066712f, -0.16454142f, 0.20976639f, 0.31378418f, 
    0.13888521f, 0.11315300f, 0.05792348f, -0.05163401f, 0.04165870f, 0.15736233f, 0.00476541f, 0.01040836f, 
    0.18649247f, 0.22165848f, 0.07067542f, -0.10777775f, 0.12843029f, 0.08911936f, 0.01272828f, -0.02150241f, 
    -0.00591773f, 0.16591817f, 0.15411204f, 0.04193713f, -0.08876216f, -0.09616803f, -0.04157032f, 0.14493643f, 
    0.20969313f, 0.05288354f, 0.05396157f, 0.02498461f, -0.00895303f, 0.03994457f, 0.11935329f, 0.09117317f, 
    0.13936685f, -0.04045744f, -0.27503455f, 0.00851034f, 0.07285292f, 0.12319233f, -0.08813050f, -0.06951743f, 
    -0.07662918f, -0.14378750f, 0.23213138f, -0.02821876f, 0.14013556f, -0.00697478f, 0.10329206f, -0.03516825f, 
    -0.16606203f, -0.07154270f, 0.05039512f, -0.07195537f, -0.07616824f, 0.09929784f, -0.00647590f, -0.04050997f, 
    0.02541801f, 0.08817714f, 0.19560644f, -0.28911480f, 0.03072167f, -0.06931823f, 0.09543883f, -0.04897689f, 
    0.03048575f, 0.06964429f, 0.02134782f, 0.13338841f, 0.10309587f, -0.02595268f, 0.03697092f, 0.06467234f, 
    0.05474693f, 0.08875450f, 0.15431675f, -0.18361281f, 0.00871330f, -0.06517045f, -0.08833870f, 0.04636730f, 
    0.04885267f, 0.06141566f, 0.05551566f, 0.18525460f, 0.00151023f, 0.01038718f, 0.07340468f, -0.04661515f, 
    0.11018274f, 0.09468085f, 0.00251003f, -0.02947660f, 0.14018324f, -0.18341760f, 0.15260810f, -0.05998987f, 
    -0.07884146f, 0.05518875f, 0.02896245f, -0.01664313f, 0.14715806f, 0.06995584f, -0.02537262f, 0.03762402f, 
    -0.27455431f, 0.01476509f, -0.01144859f, 0.11350321f, -0.05917531f, 0.05037876f, 0.03742561f, 0.17136949f, 
    0.14335793f, 0.06888583f, -0.03934182f, -0.06802933f, 0.16719173f, 0.05453315f, -0.02504716f, 0.10884734f, 
    0.10686884f, 0.13700177f, 0.10872055f, 0.05228951f, 0.07629840f, 0.03663892f, 0.01850127f, 0.20769605f, 
    0.19581252f, -0.36319560f, 0.03130629f, 0.19863701f, 0.05161570f, 0.16292629f, 0.07041365f, 0.00915459f, 
    0.11844601f, 0.00639760f, 0.03782658f, 0.10364158f, 0.17856559f, -0.02076910f, -0.03124226f, -0.01785716f, 
    -0.06564205f, -0.05915900f, 0.00231079f, -0.03426376f, 0.00981441f, 0.03444636f, -0.16293715f, 0.19978611f, 
    0.00630478f, -0.00433876f, -0.11617456f, 0.00308452f, 0.09353514f, 0.02367491f, 0.07564422f, -0.00538663f, 
    -0.04575055f, 0.10031261f, -0.00228375f, 0.21702424f, 0.17196681f, -0.11731751f, 0.04695026f, 0.06363357f, 
    -0.01412781f, -0.04340888f, -0.01275567f, 0.13107108f, 0.00551582f, -0.04396781f, -0.01564472f, 0.05858596f, 
    0.04080975f, 0.05115354f, -0.16277799f, 0.07486334f, 0.02070186f, 0.03770539f, 0.08419666f, -0.09573673f, 
    0.01076528f, 0.10835818f, 0.03432297f, 0.06375413f, -0.01548006f, -0.00835613f, -0.00516801f, -0.01463397f, 
    0.11211690f, 0.00689571f, -0.15400228f, 0.04916954f, -0.03728242f, 0.14245035f, -0.04838851f, 0.04637589f, 
    -0.03307496f, 0.00697839f, -0.00597139f, 0.09281395f, 0.02692711f, 0.01288397f, 0.05529099f, 0.18024242f, 
    0.15715644f, 0.05954075f, -0.06185181f, 0.12345667f, -0.02617553f, -0.11235827f, -0.14446121f, 0.09793226f, 
    -0.00189862f, 0.01043602f, -0.10336833f, 0.13090551f, 0.10565909f, -0.02854066f, -0.09203201f, 0.10099931f, 
    0.21812789f, 0.07790145f, 0.00886482f, -0.06526095f, 0.02346044f, 0.04293526f, 0.02551374f, -0.12684712f, 
    -0.18958665f, 0.02418853f, -0.00842737f, 0.01905051f, 0.19660059f, -0.09684211f, 0.15104999f, 0.16926132f, 
    0.10676683f, 0.05584692f, -0.00090642f, -0.04031090f, -0.00196945f, 0.01081022f, 0.04468372f, 0.04600865f, 
    -0.17966829f, 0.01021607f, 0.06801840f, 0.20393075f, 0.07518096f, 0.00514907f, 0.03724361f, -0.05636843f, 
    -0.05165989f, 0.09103003f, -0.07388279f, 0.19477019f, -0.08287813f, 0.03522723f, -0.03552094f, 0.00052119f, 
    0.11582176f, 0.05641862f, 0.08932921f, -0.00312016f, 0.10287837f, -0.03674325f, -0.01427092f, -0.09471472f, 
    0.09346917f, 0.09414310f, -0.15475094f, 0.02521343f, 0.10291397f, 0.02066019f, 0.06921468f, 0.04001357f, 
    0.13137409f, 0.10890038f, 0.02835707f, -0.02595508f, -0.15682471f, 0.29402137f, -0.25214335f, -0.00715972f, 
    -0.09675856f, 0.09744593f, 0.04423009f, 0.04337683f, 0.02238935f, -0.10078075f, 0.06903266f, -0.03158286f, 
    -0.07124034f, 0.11486109f, -0.11558174f, -0.01560961f, 0.06765223f, 0.14766063f, 0.00269733f, 0.04895961f, 
    0.18693307f, 0.03847872f, 0.06106694f, -0.10833723f, -0.01701094f, -0.07693441f, -0.06489857f, -0.03005306f, 
    0.17498197f, 0.11671869f, 0.10007342f, 0.01751469f, 0.01759162f, 0.04509895f, -0.00638519f, -0.06547257f, 
    0.28366321f, -0.12555385f, 0.08818436f, -0.00057332f, -0.12234750f, -0.07739359f, 0.03733011f, 0.03807048f, 
    -0.00770744f, -0.04395955f, 0.14135936f, 0.10521498f, 0.20650873f, -0.02437516f, -0.20172949f, -0.00743571f, 
    0.16877081f, 0.09766530f, 0.07809813f, 0.07904261f, 0.15187287f, 0.10311294f, 0.01582160f, 0.04418888f, 
    -0.13995858f, 0.14417811f, -0.02017965f, -0.03916408f, 0.15778223f, 0.09278124f, -0.09534057f, 0.00027146f, 
    0.10102893f, -0.04441431f, -0.12317421f, 0.09894086f, -0.14935564f, -0.05897875f, 0.14992309f, -0.17011099f, 
    -0.16221888f, -0.07120381f, 0.04155084f, -0.08114541f, 0.09565517f, 0.03130535f, -0.06554160f, 0.04047466f, 
    0.28307998f, -0.07664438f, 0.04574114f, -0.07056961f, 0.03858491f, -0.04460798f, -0.07067271f, -0.05002661f, 
    0.08825933f, 0.05348285f, -0.10544466f, 0.06114562f, 0.25148559f, 0.05568328f, -0.03117129f, -0.14533539f, 
    -0.07166193f, -0.01415375f, 0.01623684f, -0.00484906f, -0.00343286f, 0.02193617f, -0.00903808f, 0.07020072f, 
    0.01706451f, 0.00777851f, -0.18346471f, -0.10205807f, 0.05580739f, 0.04619320f, 0.15482743f, -0.10489527f, 
    0.01832529f, 0.08819932f, 0.10170687f, 0.01616293f, -0.02027323f, -0.14015388f, -0.00642257f, 0.04317214f, 
    0.01157871f, 0.03926251f, 0.02503786f, -0.04686588f, -0.00340607f, 0.10308321f, 0.18441391f, 0.03046522f, 
    -0.18925549f, 0.08450083f, 0.12168391f, 0.26829749f, 0.10193108f, -0.01444364f, 0.09572500f, 0.07642688f, 
    0.12437416f, -0.03738777f, 0.11985227f, 0.02510211f, 0.04963779f, -0.38849002f, 0.12670971f, -0.02002020f, 
    0.00187158f, -0.04281573f, 0.11685324f, -0.02512181f, -0.09275965f, 0.09330460f, -0.02716208f, 0.10522260f, 
    -0.24667357f, -0.12856634f, 0.05478189f, 0.27043259f, -0.05056161f, 0.05569716f, 0.04605433f, 0.01507729f, 
    0.02716052f, -0.03171325f, -0.05936660f, -0.04429824f, 0.29986104f, -0.06067941f, -0.18166505f, 0.17654777f, 
    0.04697117f, 0.01968847f, 0.02115091f, -0.04110437f, -0.06300750f, 0.06097210f, -0.08292675f, -0.00182387f, 
    -0.02155198f, 0.15711315f, 0.19943571f, -0.15125948f, -0.07501406f, -0.12312242f, 0.04915964f, -0.01160136f, 
    0.02349786f, 0.18310839f, 0.10164331f, 0.12985405f, 0.17409116f, -0.32245693f, -0.02965817f, 0.21979532f, 
    0.12320706f, 0.00959966f, 0.05250121f, 0.01838156f, -0.10386949f, -0.05117590f, 0.00212218f, 0.03599944f, 
    0.03264595f, -0.15478839f, 0.03165326f, 0.11521016f, 0.04286029f, 0.01285906f, -0.01484964f, -0.09433357f, 
    -0.01805220f, 0.10049934f, -0.02906263f, 0.04129340f, 0.15517120f, -0.15543810f, 0.09481560f, -0.27932450f, 
    -0.01849749f, 0.04487225f, 0.01455868f, 0.07887226f, 0.01229681f, -0.05569556f, 0.01705904f, -0.07222977f, 
    0.06520825f, 0.17979686f, 0.08577125f, 0.04216666f, 0.09022410f, 0.10455398f, 0.00485280f, 0.05934823f, 
    0.03270260f, 0.08432675f, 0.07707711f, 0.04348566f, 0.04289203f, -0.29555258f, 0.10511265f, -0.08502142f, 
    0.06597512f, -0.06226937f, -0.02694401f, 0.12830180f, 0.01672054f, 0.05496285f, 0.05245297f, 0.02815029f, 
    -0.15422840f, 0.14355412f, -0.05317419f, 0.18052359f, 0.08542749f, 0.02341313f, -0.00545259f, 0.06576467f, 
    0.05961705f, -0.06904221f, 0.00346293f, 0.09331926f, 0.19180819f, 0.12419389f, 0.05385204f, 0.25374565f, 
    0.03465797f, 0.07652771f, 0.01133053f, 0.11991984f, 0.01395494f, 0.07928330f, -0.03945375f, -0.03522656f, 
    0.36610442f, 0.03393192f, 0.02623707f, 0.01021930f, 0.07410008f, -0.03310703f, 0.13500188f, -0.05046699f, 
    -0.05943998f, 0.06311282f, -0.04095651f, -0.01444227f, 0.16570270f, -0.23483534f, -0.07033022f, 0.02349572f, 
    0.06877030f, 0.10371412f, 0.09422669f, -0.02732130f, 0.02384462f, -0.13925748f, -0.00546978f, -0.08870216f, 
    -0.06688724f, 0.15762484f, 0.20007421f, -0.17744459f, -0.05883913f, -0.00629405f, 0.06575866f, -0.09391085f, 
    0.04126838f, -0.03924446f, 0.01166630f, -0.06446759f, 0.11009228f, 0.11879046f, 0.07418112f, 0.05915622f, 
    -0.00444431f, 0.03158788f, -0.09658021f, 0.00407301f, -0.01118335f, -0.05260643f, -0.12889233f, -0.17592682f, 
    -0.20140009f, 0.04948325f, 0.03613333f, -0.10961457f, 0.05907211f, 0.04744474f, 0.07756471f, -0.09208813f, 
    0.01176522f, -0.00193513f, 0.04305047f, -0.00106963f, -0.09876256f, 0.07006008f, 0.03194042f, -0.08347440f, 
    0.00637247f, 0.07942584f, -0.11948995f, 0.07071839f, -0.11809321f, -0.04018661f, -0.07006492f, -0.01062344f, 
    0.30735683f, -0.00628216f, 0.01823818f, -0.11030636f, -0.01510385f, 0.09358530f, -0.00884209f, 0.03593196f, 
    -0.01123923f, 0.06564317f, 0.02941192f, 0.16957745f, -0.07347462f, 0.24795064f, 0.02634277f, -0.27467331f, 
    -0.07719471f, 0.10795131f, -0.03928032f, 0.06190788f, 0.01938354f, -0.09697778f, -0.09725731f, -0.15478131f, 
    0.08621394f, 0.12856923f, 0.12963963f, 0.16371858f, 0.09048046f, 0.07419807f, -0.11965760f, 0.03218047f, 
    0.03483883f, -0.00641696f, 0.00388183f, -0.04382309f, 0.26608813f, -0.22745535f, 0.04651738f, 0.02389743f, 
    -0.00292724f, 0.08756557f, 0.05059420f, 0.00878245f, 0.01916465f, -0.02625635f, 0.08695377f, 0.10249120f, 
    -0.07637647f, -0.05579614f, 0.01952739f, 0.20238718f, -0.18604539f, -0.04274978f, 0.03438914f, 0.09204344f, 
    -0.06541023f, -0.04942121f, -0.13475943f, -0.19102854f, 0.02593837f, 0.20583278f, -0.03655524f, 0.09858704f, 
    -0.05238197f, -0.00625364f, -0.11790760f, -0.10382935f, -0.12258904f, -0.02217424f, 0.03212507f, -0.08727493f, 
    0.15502352f, 0.08692704f, -0.07018633f, 0.03289127f, 0.01698096f, 0.01315065f, -0.07759316f, 0.03936499f, 
    0.09317088f, -0.11448307f, -0.09738785f, -0.05102287f, 0.38001725f, -0.08082644f, 0.13361244f, 0.13662593f, 
    -0.01841369f, -0.00149975f, -0.03231667f, 0.00656106f, 0.04753112f, 0.03969218f, -0.05738876f, 0.07415858f, 
    0.00260812f, -0.02600806f, 0.09181836f, -0.18183316f, 0.03628555f, 0.07669822f, 0.03684527f, -0.01330482f, 
    0.02871226f, 0.01478568f, 0.07680328f, 0.15949917f, 0.20169261f, 0.01040015f, -0.00478210f, 0.06691625f, 
    -0.08075355f, 0.14058021f, 0.04612596f, 0.02888535f, 0.12149321f, 0.02429550f, 0.08967131f, -0.09260104f, 
    -0.24417511f, -0.13022545f, 0.04062814f, 0.11720623f, 0.08457904f, -0.13056076f, 0.21827273f, 0.15940556f, 
    0.09004059f, -0.01374550f, 0.04684938f, -0.04765376f, -0.12198267f, 0.20519269f, -0.00696343f, -0.18837686f, 
    0.11947704f, -0.04801183f, -0.00722038f, 0.02360947f, 0.01534335f, 0.04045175f, 0.07551448f, -0.12861441f, 
    -0.05911672f, -0.11126533f, -0.07596786f, -0.23614465f, -0.05816681f, 0.15535267f, -0.03596370f, -0.08650102f, 
    0.00166762f, -0.13575192f, -0.17938505f, -0.18981481f, -0.09644819f, 0.21455517f, 0.12444057f, -0.22673640f, 
    0.02075427f, 0.05434893f, 0.05578599f, 0.04947029f, -0.12381130f, -0.00452108f, -0.04986718f, -0.11559311f, 
    0.26162428f, -0.11130808f, 0.04114724f, -0.07239723f, -0.01694099f, -0.01466934f, 0.19093557f, 0.03992629f, 
    -0.00470932f, -0.07107560f, 0.06262225f, -0.09188534f, 0.08461870f, -0.15667826f, 0.01713391f, 0.05685501f, 
    0.03114340f, 0.01399983f, -0.05327873f, -0.11101968f, -0.00435362f, 0.00034792f, 0.00019956f, 0.12988241f, 
    -0.05039178f, 0.09355795f, 0.06919567f, 0.11976393f, -0.00237683f, -0.02266967f, -0.07642727f, 0.12149905f, 
    0.07652931f, 0.04624084f, 0.18493313f, 0.05497874f, -0.01549208f, 0.04704810f, 0.24203144f, 0.03581149f, 
    0.15213157f, 0.05484242f, 0.09163667f, 0.08918052f, 0.00515095f, -0.05103623f, 0.12401317f, 0.06657129f, 
    0.25191054f, -0.08686765f, -0.00438806f, -0.02742846f, 0.04724938f, 0.04286081f, 0.07074210f, -0.03910893f, 
    -0.14728744f, -0.11657204f, 0.08166929f, 0.15102078f, -0.22926940f, 0.11499753f, 0.03257049f, -0.02112647f, 
    -0.07562558f, 0.01409893f, -0.01195965f, 0.12152929f, -0.04676660f, -0.05277053f, 0.03742160f, 0.04915324f, 
    0.12449100f, 0.07366107f, -0.08216391f, 0.06942074f, -0.10534023f, -0.03973367f, -0.06417537f, 0.05468551f, 
    -0.05344068f, 0.06028578f, 0.14844783f, 0.07001961f, -0.04263817f, 0.04499951f, 0.04549193f, -0.13589436f, 
    0.05454133f, -0.03553412f, -0.04613005f, 0.05406369f, -0.01835342f, 0.20177472f, 0.05500853f, -0.01942659f, 
    -0.21694113f, 0.25536147f, 0.01504661f, -0.25995633f, 0.15436275f, -0.04806181f, 0.07491226f, 0.06688114f, 
    -0.03914926f, -0.03355812f, 0.14400139f, -0.00266027f, 0.36374792f, 0.14545038f, -0.19614182f, 0.23410539f, 
    -0.01372751f, 0.10611883f, -0.01393064f, 0.10888768f, -0.05649236f, -0.00071128f, 0.11647408f, -0.04399160f, 
    0.13688286f, -0.05045885f, -0.04387814f, 0.07531926f, 0.07000334f, -0.04751634f, 0.06994749f, -0.02523850f, 
    0.10367929f, -0.03342767f, -0.06360441f, -0.25308374f, -0.29913846f, 0.30081400f, -0.02242530f, 0.07661212f, 
    -0.08419100f, 0.02146481f, 0.08179712f, 0.05623494f, 0.04232489f, 0.11817477f, 0.01021671f, 0.11482307f, 
    -0.01186237f, 0.11146642f, -0.01012339f, 0.16687669f, 0.15515652f, 0.09317806f, 0.05036709f, -0.00377842f, 
    -0.01741775f, -0.07202552f, -0.06468314f, -0.18352014f, 0.16707638f, 0.08856887f, -0.31337836f, 0.10536768f, 
    0.03079441f, 0.12857547f, 0.05896075f, 0.02518319f, -0.01757226f, -0.01762092f, 0.00365473f, -0.02500495f, 
    -0.28741705f, 0.22888371f, 0.23283525f, -0.02594250f, -0.07082166f, 0.02884892f, 0.09120226f, 0.03863714f, 
    -0.08861892f, -0.01235726f, 0.20577635f, 0.02617934f, -0.45138699f, -0.17341134f, -0.17941692f, 0.21518008f, 
    0.05525254f, 0.04350350f, 0.02239903f, 0.11192485f, 0.02596487f, 0.07240605f, 0.12145849f, -0.00969570f, 
    -0.10521441f, -0.01168688f, -0.04322054f, -0.03285635f, -0.04720837f, 0.09157555f, 0.04002449f, -0.10007644f, 
    0.06920982f, -0.05641569f, 0.07195882f, -0.25787994f, 0.00431541f, 0.20697911f, 0.07616426f, -0.24467748f, 
    -0.05793291f, 0.11850201f, 0.00211710f, -0.03342112f, -0.05630661f, 0.01760984f, 0.10109273f, -0.16513219f, 
    0.08836823f, 0.11664774f, 0.07903221f, -0.15535425f, -0.06825848f, 0.04032223f, 0.03127506f, 0.04738199f, 
    -0.00059084f, -0.04052347f, -0.03205989f, 0.03502541f, 0.04020249f, 0.25018203f, -0.30598590f, 0.08598841f, 
    -0.17606547f, 0.12269753f, 0.00289578f, 0.00353182f, -0.01082949f, 0.15963778f, -0.04761735f, 0.09251989f, 
    0.09625253f, -0.19796786f, 0.14459844f, -0.17128648f, -0.02694149f, 0.03403805f, 0.01492426f, -0.07022317f, 
    0.11227290f, -0.02382367f, -0.01309649f, -0.03888583f, 0.19683056f, -0.29043058f, -0.12212145f, 0.04478274f, 
    0.17982021f, -0.01499575f, 0.00168031f, 0.04899132f, -0.02886250f, 0.17696057f, -0.10485489f, 0.12945856f, 
    -0.13415571f, -0.26086175f, -0.10848490f, 0.09032873f, 0.11732491f, -0.16901068f, 0.07620900f, 0.00356985f, 
    -0.00419308f, 0.08861369f, -0.03448024f, 0.09516711f, -0.18410511f, -0.01119911f, -0.04670509f, -0.16209753f, 
    0.10604113f, 0.01494252f, 0.06343071f, 0.01763170f, 0.00730152f, 0.05596295f, -0.17440259f, 0.12634857f, 
    0.11958443f, -0.17677316f, 0.08088470f, 0.03456009f, 0.07965593f, 0.02402346f, 0.01270607f, -0.02846402f, 
    -0.04528765f, -0.01679148f, 0.01154716f, -0.14270154f, -0.12272865f, 0.00529134f, -0.12502310f, -0.20131952f, 
    0.06249001f, 0.03402514f, -0.04073420f, -0.01261328f, 0.00369150f, -0.02858222f, 0.02600526f, -0.04262146f, 
    0.03343974f, 0.17382975f, -0.03980106f, 0.05800389f, 0.05171042f, -0.06101749f, 0.05445790f, 0.09433158f, 
    0.07522841f, 0.05004733f, 0.15840162f, 0.05590275f, 0.13175282f, 0.14067122f, 0.13246015f, -0.05627281f, 
    0.02209252f, -0.05127086f, 0.05572450f, 0.01539545f, -0.06962360f, -0.12956518f, -0.02964219f, 0.05853956f, 
    -0.08680800f, 0.09304874f, -0.11479983f, 0.16565596f, 0.05248900f, -0.03420002f, 0.09359848f, -0.06384958f, 
    0.12070014f, -0.08614064f, -0.06824867f, 0.02490861f, -0.26452330f, -0.03013160f, -0.15150009f, 0.00113438f, 
    0.07619923f, -0.06597849f, 0.02769232f, -0.08447108f, -0.00049639f, -0.03056833f, -0.03941251f, -0.03073809f, 
    0.31523761f, 0.07164925f, -0.04981302f, 0.12639055f, -0.02225816f, 0.01996561f, -0.05522541f, -0.08632430f, 
    -0.04425409f, 0.00042099f, 0.03386215f, 0.01985955f, 0.21650085f, 0.17268124f, 0.29974499f, 0.05726700f, 
    0.03534703f, -0.00445309f, 0.12001387f, -0.02791789f, -0.01952264f, 0.02675841f, 0.05438715f, 0.02677217f, 
    -0.26424420f, 0.11831742f, 0.06370953f, -0.11836911f, 0.01842339f, -0.01598071f, 0.13938123f, -0.02002149f, 
    0.08352263f, 0.02231198f, 0.03113578f, 0.04023431f, 0.11290318f, 0.11651286f, 0.12058696f, 0.11545370f, 
    -0.05834416f, 0.04370090f, -0.00546551f, 0.09986483f, -0.08678058f, 0.06864478f, 0.00641617f, 0.13429371f, 
    -0.01967508f, -0.01962792f, -0.01990589f, -0.05685740f, -0.03209937f, -0.01787627f, -0.00085349f, 0.09436864f, 
    0.03215156f, -0.02193275f, 0.01050354f, 0.03394558f, -0.10369710f, 0.23019724f, -0.16800950f, 0.07290774f, 
    0.02407085f, -0.08612642f, 0.09477549f, 0.05672146f, 0.09319750f, -0.05470375f, 0.05391593f, -0.02875906f, 
    0.14031523f, 0.05483895f, -0.00281530f, 0.14287953f, 0.00502003f, 0.09600829f, 0.13461049f, 0.01278266f, 
    -0.00838882f, -0.01764049f, 0.03792405f, 0.01394209f, 0.30885249f, -0.11085109f, -0.10282981f, -0.02395624f, 
    -0.09911699f, -0.01426691f, -0.00169644f, 0.07510524f, -0.06171143f, 0.14950235f, 0.03448190f, 0.09090997f, 
    0.28990307f, 0.17152832f, 0.12675065f, 0.08727313f, 0.03968619f, -0.08651081f, -0.05546989f, 0.09230898f, 
    0.00210169f, -0.04258217f, 0.07529026f, 0.02237657f, -0.08200909f, -0.05441464f, 0.02296026f, -0.07541627f, 
    0.02814051f, 0.01327588f, -0.02176786f, -0.05478775f, 0.02660367f, -0.03682132f, -0.01377903f, -0.05183994f, 
    -0.15453725f, 0.05336023f, -0.07112505f, -0.04461487f, 0.03413643f, -0.04983091f, 0.03806563f, -0.03023737f, 
    0.01077644f, -0.02310877f, -0.01077280f, 0.07238530f, 0.02059120f, 0.08718753f, 0.06908245f, 0.20369287f, 
    -0.05030120f, 0.07511172f, 0.05961060f, 0.01045814f, -0.01624467f, 0.01314350f, 0.00309295f, 0.03692397f, 
    -0.02670505f, 0.04574588f, -0.00397963f, 0.05181634f, -0.05737610f, 0.08498406f, 0.01023967f, 0.09433747f, 
    0.00158946f, 0.02386850f, 0.01154347f, -0.02232716f, -0.35562652f, 0.01840505f, 0.08940909f, -0.17442933f, 
    -0.06807968f, 0.00919557f, 0.01720531f, 0.02403888f, 0.02599773f, 0.02370819f, -0.01723597f, -0.00192442f, 
    0.33216220f, 0.02595000f, 0.02991073f, 0.08241619f, -0.03553183f, 0.09200943f, 0.03200335f, -0.06418312f, 
    -0.01467781f, 0.07775758f, -0.03196444f, 0.02005812f, 0.09563418f, -0.07054153f, -0.00320463f, 0.01561734f, 
    -0.03419899f, -0.04277716f, -0.05133098f, 0.02377422f, -0.03035171f, -0.04690377f, -0.05561593f, -0.01073354f, 
    -0.22796994f, -0.08092032f, -0.02866551f, -0.14959356f, -0.00069993f, -0.00425807f, -0.07340679f, 0.01592178f, 
    0.00908896f, 0.02142277f, 0.00772266f, -0.08511254f, -0.09829748f, -0.14889401f, -0.09316216f, 0.03062304f, 
    0.03193629f, 0.03348483f, -0.03173526f, 0.02702630f, -0.06761505f, -0.00527042f, 0.02864806f, 0.03763421f, 
    -0.02398100f, 0.01601664f, 0.05763887f, -0.03978383f, 0.00425434f, 0.04695859f, -0.02251502f, -0.10565541f, 
    0.04875509f, 0.13645028f, -0.04037647f, 0.04310274f, 0.03624820f, 0.05550120f, 0.08600380f, 0.00350783f, 
    0.04269240f, 0.05710004f, -0.00447444f, -0.02382785f, 0.03423774f, 0.02570128f, -0.10994940f, 0.07317372f, 
    -0.15863289f, 0.03283406f, -0.15690306f, 0.03244593f, -0.01801766f, -0.04966893f, 0.03781528f, 0.01466760f, 
    0.08770628f, -0.04013923f, -0.08216915f, 0.12268998f, -0.16695657f, -0.08081261f, -0.19637556f, 0.06055602f, 
    -0.01899430f, -0.01380038f, -0.10306423f, -0.01469356f, -0.04809038f, 0.01092659f, -0.09436556f, -0.01244285f, 
    -0.21970485f, -0.04525672f, 0.00377074f, -0.11244546f, -0.00046743f, 0.07262629f, 0.08086894f, 0.16842897f, 
    -0.02888687f, -0.00902442f, 0.03072531f, 0.02741012f, -0.06761917f, -0.00598154f, -0.11687627f, 0.07453790f, 
    0.06113518f, 0.02930471f, -0.03549199f, 0.00765109f, -0.06048662f, 0.09195603f, -0.01043217f, -0.00251369f, 
    0.19911729f, 0.10002813f, -0.07606927f, -0.05032255f, 0.01029858f, -0.01958386f, 0.07496527f, 0.06009114f, 
    -0.02582592f, 0.10754547f, -0.08767539f, 0.10621943f, 0.11488333f, -0.00105807f, 0.13419229f, 0.02051854f, 
    0.01304077f, 0.07536609f, -0.03403637f, -0.04285644f, -0.07662851f, 0.02930937f, 0.10318885f, -0.02490596f, 
    0.13026340f, 0.15782769f, 0.00642445f, -0.00770458f, 0.03028098f, -0.00419229f, -0.07026994f, 0.00861086f, 
    0.01984400f, 0.00739615f, 0.02028550f, -0.00728248f, 0.14151308f, -0.03254095f, 0.09464704f, 0.08675610f, 
    -0.03091999f, -0.00039385f, -0.05362225f, 0.12252234f, 0.02317685f, -0.06728403f, -0.00229330f, 0.02314882f, 
    -0.15146491f, -0.00401328f, 0.00950037f, -0.07765003f, -0.06606523f, 0.01491373f, -0.09059160f, -0.08434195f, 
    -0.03647016f, 0.05441900f, -0.04647853f, -0.06837723f, 0.30606177f, -0.07897216f, 0.15115888f, 0.09487748f, 
    0.03059506f, 0.05829931f, -0.05988900f, -0.08662163f, 0.05326485f, 0.01956642f, 0.03568584f, -0.00441808f, 
    -0.01777749f, 0.11660267f, 0.15267476f, 0.00611189f, -0.00470824f, -0.02019873f, 0.12814109f, 0.08343389f, 
    0.07358936f, 0.00804207f, 0.02517812f, 0.02579274f, -0.13828894f, 0.00236387f, -0.14825813f, -0.20452771f, 
    0.08574671f, 0.02599454f, -0.04782801f, -0.00051209f, -0.08045018f, -0.01926904f, 0.02092592f, -0.02441086f, 
    0.22842534f, 0.00902815f, -0.02990147f, 0.01418274f, -0.02282420f, 0.00543471f, -0.02340727f, 0.03943980f, 
    0.05210619f, -0.05228392f, -0.02818134f, 0.00979262f, -0.13280022f, -0.11398591f, 0.01778746f, -0.02360282f, 
    0.02234313f, 0.05579170f, 0.03093578f, -0.01557185f, -0.05576872f, 0.05651890f, 0.02070428f, -0.12181311f, 
    -0.14222290f, 0.07023521f, -0.04937825f, 0.09546307f, -0.04016280f, 0.02640733f, 0.02022847f, 0.00264192f, 
    0.00665862f, 0.05785235f, -0.10260190f, 0.04142972f, 0.41627222f, 0.15736499f, 0.13638015f, 0.14590453f, 
    0.02140235f, -0.03166884f, -0.04083896f, 0.08483483f, 0.04389616f, 0.04494829f, 0.05292474f, -0.02740887f, 
    0.06610828f, 0.14711259f, 0.06150043f, 0.09266403f, 0.02183546f, 0.14278638f, 0.04192060f, 0.12843195f, 
    -0.01046885f, -0.03641973f, 0.00101063f, -0.08919891f, -0.01085650f, -0.16370469f, -0.16225524f, 0.01373186f, 
    -0.07607058f, -0.00071311f, -0.03585630f, 0.03400683f, -0.00042917f, -0.02547909f, 0.14776267f, -0.04212471f, 
    -0.10253109f, 0.05894298f, -0.15517950f, 0.01353058f, 0.03237081f, -0.05184774f, -0.10202399f, -0.07658150f, 
    0.01126885f, 0.02486116f, 0.05405111f, 0.04107911f, -0.04434272f, 0.15690386f, -0.09801946f, 0.20170380f, 
    0.04098235f, -0.00016074f, 0.05213672f, 0.00063874f, -0.14231130f, 0.00053664f, 0.06523550f, -0.02699123f, 
    0.24448891f, 0.34195817f, 0.10514343f, -0.07393754f, 0.11103152f, 0.06837140f, 0.04616190f, -0.03909814f, 
    0.03153893f, 0.06342442f, 0.04672613f, 0.02415519f, -0.07605020f, -0.11935747f, -0.11340844f, 0.00424339f, 
    -0.02045172f, -0.07898807f, -0.08682299f, 0.01648866f, -0.08743864f, 0.15466304f, 0.06936361f, -0.12179602f, 
    -0.21451457f, 0.13877031f, -0.09454886f, -0.07102031f, 0.06447125f, -0.06555028f, -0.09204030f, 0.00645340f, 
    -0.07234274f, 0.05890245f, -0.03096255f, 0.03260857f, 0.13633853f, 0.04077747f, 0.20726600f, -0.02777695f, 
    0.01947697f, 0.07151042f, -0.02841650f, 0.07247309f, 0.05064578f, 0.01083076f, 0.09224710f, 0.00832145f, 
    -0.04713071f, 0.09469935f, 0.00628551f, -0.03825087f, -0.08371188f, -0.06084918f, -0.01472208f, -0.00401019f, 
    0.02087167f, 0.01881618f, 0.09269200f, -0.01049477f, 0.07776331f, 0.04711256f, -0.04529746f, -0.05152060f, 
    0.01158380f, 0.05357599f, 0.02945061f, -0.04914242f, 0.02033889f, -0.05614317f, -0.03345552f, -0.02449143f, 
    -0.12852460f, -0.05492784f, 0.15158062f, -0.08666415f, 0.01945099f, -0.04167059f, -0.02000760f, 0.07183172f, 
    0.05888278f, 0.00759298f, 0.03215479f, 0.12767240f, -0.01705773f, 0.17368513f, 0.13934770f, -0.03678256f, 
    -0.02970927f, 0.05626680f, 0.12424944f, 0.01329064f, -0.07345304f, -0.17194675f, 0.02325893f, -0.02529791f, 
    -0.09732696f, -0.12561326f, -0.02722500f, 0.06171131f, 0.02320923f, 0.03765105f, 0.01339331f, -0.07914740f, 
    0.00095672f, 0.01884320f, 0.03797172f, -0.02453796f, 0.15857692f, 0.27156636f, 0.15056203f, -0.00584067f, 
    0.03951294f, 0.06292363f, 0.10338963f, 0.07299308f, 0.00807464f, 0.04976819f, 0.07143033f, -0.01944380f, 
    0.20442760f, 0.04511742f, -0.00868723f, 0.02791499f, 0.06267275f, 0.02842746f, -0.01503477f, 0.06566186f, 
    0.14485259f, 0.02451000f, -0.05697981f, 0.00777235f, -0.26553541f, 0.03836311f, -0.11353402f, -0.04195792f, 
    0.05098290f, -0.03441729f, -0.06353336f, -0.03555946f, -0.05142074f, -0.07909293f, 0.02635364f, 0.02428323f, 
    -0.11507124f, -0.00687684f, -0.12185702f, -0.10560293f, 0.05257298f, 0.01008175f, -0.03502760f, 0.03794884f, 
    0.02708071f, -0.07078896f, 0.05898714f, -0.07473988f, -0.10505720f, 0.04348168f, 0.08294186f, -0.13445882f, 
    0.05487720f, 0.03660598f, 0.01890603f, -0.03317303f, -0.10586303f, 0.05094119f, -0.01986933f, 0.14155297f, 
    -0.05039292f, 0.07757048f, -0.00226066f, -0.04296721f, 0.06347004f, 0.00088915f, -0.04012727f, -0.01791025f, 
    0.04495831f, 0.08383948f, -0.00654780f, -0.10390127f, 0.24112037f, 0.07314373f, 0.22508676f, 0.05210037f, 
    0.14442651f, -0.03491110f, -0.01570063f, -0.02470047f, -0.06770352f, 0.16805504f, 0.08308467f, 0.02904597f, 
    0.20887105f, -0.05603874f, 0.19953953f, -0.15482783f, 0.01268236f, -0.01448239f, -0.05957815f, -0.07214568f, 
    -0.03740949f, 0.00511764f, -0.03016982f, 0.02110151f, -0.07607611f, 0.00773233f, 0.06121777f, 0.03634591f, 
    0.02616804f, 0.00804473f, -0.05699991f, -0.03240816f, 0.12049966f, -0.03204311f, 0.07297240f, -0.06937209f, 
    0.11106654f, 0.20632944f, 0.15107387f, -0.05713103f, -0.07385028f, 0.05438986f, 0.04956144f, 0.03069119f, 
    -0.02202178f, 0.05523741f, 0.01326025f, -0.05323311f, -0.03713503f, -0.02841386f, 0.08077365f, -0.09179098f, 
    0.00073839f, -0.07621650f, -0.01568689f, -0.03063496f, -0.00074121f, -0.00554887f, 0.06063501f, -0.08521326f, 
    -0.02326554f, -0.17970376f, -0.06821906f, 0.08537920f, 0.02392091f, -0.06264742f, 0.05204032f, 0.05918461f, 
    0.01777202f, 0.07537667f, -0.03140081f, -0.10612129f, 0.12738177f, 0.07818137f, 0.00642545f, 0.21812168f, 
    0.20396620f, -0.06251834f, 0.00109231f, 0.04745706f, -0.02203327f, 0.11350936f, 0.07046700f, -0.04090117f, 
    -0.03635434f, 0.01523109f, -0.01250602f, -0.01643788f, -0.00039640f, -0.03129983f, 0.02471969f, 0.00278870f, 
    0.02291161f, 0.01047651f, 0.01730977f, -0.02739023f, -0.02373089f, -0.02096912f, 0.00136592f, 0.02021967f, 
    -0.02640617f, -0.01695338f, 0.02516257f, -0.02883645f, -0.02379834f, 0.02688232f, 0.01343398f, -0.03203210f, 
    -0.00090090f, -0.03916197f, -0.01872064f, -0.02506442f, -0.03288233f, -0.00623304f, -0.01917833f, 0.02216712f, 
    -0.03153984f, -0.01235595f, -0.00872586f, 0.01515896f, -0.01703652f, 0.02103756f, -0.02709071f, 0.02735587f, 
    0.00760269f, -0.03997809f, 0.00130816f, -0.01227606f, 0.00085370f, -0.03024349f, 0.01756198f, -0.02260419f, 
    -0.01104798f, -0.01930087f, 0.02748293f, 0.02645526f, 0.00726631f, 0.00187157f, -0.03978578f, 0.02535610f, 
    -0.03924696f, -0.01586324f, 0.01337047f, -0.03147585f, -0.01311687f, -0.03774800f, 0.01559316f, -0.03027542f, 
    -0.03323704f, 0.02677815f, 0.02547885f, -0.02096767f, -0.02639309f, -0.02726924f, -0.00662288f, -0.01867351f, 
    -0.00898259f, -0.02202793f, -0.01175382f, -0.01335985f, -0.00654166f, 0.01594119f, 0.00023887f, -0.03551035f, 
    -0.01789930f, -0.00919592f, -0.02734236f, -0.02788369f, -0.01863071f, -0.04180280f, -0.03254282f, -0.00814443f, 
    -0.00109156f, -0.01709205f, -0.03033641f, 0.00164260f, -0.03236274f, -0.01766817f, -0.00144760f, 0.01912896f, 
    -0.02415200f, 0.02045948f, -0.00615315f, -0.04170418f, -0.02908062f, -0.03908986f, -0.03716709f, 0.01069877f, 
    -0.02895318f, 0.00806258f, -0.00510206f, -0.03493444f, 0.02202287f, -0.03849788f, 0.02111953f, 0.02420289f, 
    0.00258065f, -0.00939658f, 0.02599743f, 0.00922002f, -0.01630580f, -0.02148018f, -0.02565352f, 0.02473641f, 
    0.01887868f, 0.00124053f, -0.00068324f, 0.02090603f, -0.00693853f, 0.00104348f, -0.01482391f, 0.02834553f, 
    0.01296607f, 0.01063781f, -0.01478224f, 0.01703183f, -0.01494347f, -0.04107649f, -0.04021988f, -0.04177931f, 
    -0.04169736f, 0.02219702f, -0.01764126f, -0.03073888f, -0.02303411f, 0.01709434f, -0.00553845f, -0.01860716f, 
    -0.00180848f, -0.01422738f, -0.01499597f, -0.02609310f, 0.03183241f, 0.00453856f, 0.01279144f, -0.02252524f, 
    -0.01706638f, 0.01999600f, -0.00913709f, 0.00942829f, -0.02268786f, 0.00490370f, 0.00255740f, -0.03215323f, 
    -0.00437347f, -0.03571295f, -0.02582564f, -0.04046737f, -0.01276617f, -0.00204611f, -0.03215695f, -0.01531905f, 
    -0.01775998f, -0.02817265f, -0.02547564f, 0.01002649f, 0.02104081f, 0.01117432f, 0.00662154f, -0.00988353f, 
    -0.01396639f, 0.01904993f, 0.00928271f, -0.01433341f, -0.00411279f, 0.00524358f, 0.02614122f, -0.03629547f, 
    -0.01072496f, -0.01074679f, -0.02627863f, 0.01065926f, 0.01174903f, -0.02958499f, -0.00491923f, -0.00524716f, 
    0.02101774f, -0.00625087f, -0.01813089f, 0.02142711f, 0.01255353f, -0.02132189f, 0.00692037f, 0.01854491f, 
    -0.03328733f, 0.00012467f, -0.02572159f, 0.01515903f, 0.00304556f, 0.02824745f, 0.01506992f, 0.02050723f, 
    -0.01528139f, -0.01840803f, 0.01320476f, 0.02207091f, 0.01072157f, -0.01494720f, -0.00828508f, -0.03436599f, 
    0.01186268f, -0.00548787f, -0.01044078f, 0.00980074f, -0.03164332f, -0.03192343f, 0.02271291f, -0.02531316f, 
    0.00638382f, -0.00935169f, 0.01981029f, -0.01657371f, 0.00529597f, -0.01296236f, -0.02363880f, -0.03192961f, 
    -0.02451158f, -0.02470813f, -0.03585427f, -0.03994311f, 0.01821171f, -0.01307164f, 0.02873001f, -0.00259305f, 
    -0.00024514f, -0.00789572f, 0.01868968f, -0.03023804f, 0.02366713f, 0.00973987f, 0.01941477f, -0.02428479f, 
    -0.01489574f, 0.01305459f, -0.02993355f, -0.03673555f, -0.01360085f, -0.00199414f, 0.00047267f, 0.00366620f, 
    0.00778973f, -0.03126329f, -0.02967296f, 0.00410905f, 0.02122396f, -0.00673586f, 0.00119694f, 0.02455667f, 
    0.01514535f, -0.03474834f, -0.03634980f, 0.00483958f, -0.02870716f, -0.03530035f, -0.03679942f, -0.02008970f, 
    -0.00075451f, -0.04086994f, -0.00612318f, 0.01075091f, -0.02559882f, -0.01287831f, 0.00751115f, -0.03374014f, 
    0.01812515f, -0.00854269f, -0.04141851f, 0.00826638f, -0.03315029f, 0.01125114f, -0.01058711f, -0.02020356f, 
    0.00793638f, -0.03694072f, 0.01068072f, 0.02521625f, -0.01376543f, 0.02971329f, 0.01229177f, -0.00645148f, 
    -0.02512543f, 0.00003936f, 0.01150616f, 0.01172011f, -0.03512695f, -0.04049105f, -0.00911073f, 0.02592294f, 
    -0.03505713f, -0.01062804f, -0.00245573f, 0.01386050f, 0.00966580f, -0.00883023f, 0.02388932f, -0.02090511f, 
    0.01629897f, -0.00859532f, -0.02272413f, 0.01403365f, -0.03118019f, 0.02846641f, -0.03680540f, 0.01836857f, 
    0.02686655f, -0.01516428f, -0.01382935f, -0.02877402f, -0.03960331f, 0.01737413f, -0.00069666f, -0.03770519f, 
    -0.02021920f, -0.01621029f, 0.01355035f, -0.03456416f, -0.03045907f, -0.03356791f, 0.02355424f, -0.01651931f, 
    0.01993294f, 0.01618420f, -0.00582419f, -0.03866174f, -0.03045258f, 0.00370315f, -0.03082741f, 0.02202282f, 
    -0.02480643f, -0.03407816f, -0.02588545f, 0.02031146f, -0.00338697f, 0.02712104f, 0.01616419f, -0.02831967f, 
    -0.01227371f, 0.01416297f, 0.00271322f, -0.02058452f, -0.02477019f, -0.00581220f, 0.01802127f, 0.00077138f, 
    -0.02930708f, 0.00901490f, -0.03018460f, -0.02060696f, -0.00558976f, -0.03413635f, -0.03520580f, -0.00350998f, 
    -0.00735645f, -0.03749302f, 0.01350821f, -0.02959960f, 0.00728037f, -0.03164148f, -0.00582844f, -0.04139170f, 
    0.00231657f, 0.02309969f, -0.04176213f, -0.01726050f, -0.02253329f, -0.03860534f, 0.01414852f, -0.00557930f, 
    -0.02830248f, -0.00380922f, 0.00018380f, 0.01892008f, -0.00780760f, -0.01157151f, 0.02407482f, -0.02428450f, 
    0.02531593f, 0.02347085f, 0.02304503f, 0.01607472f, 0.00316173f, 0.02509355f, 0.02693910f, -0.00482878f, 
    0.00336039f, -0.03979103f, 0.01858783f, 0.01891454f, -0.03763473f, -0.01904124f, -0.01918452f, 0.03340903f, 
    0.00552482f, -0.03438659f, 0.01696202f, 0.03607636f, -0.00039598f, -0.02424471f, 0.02539155f, 0.01115286f, 
    -0.01571004f, 0.02043593f, 0.02212848f, -0.02820594f, 0.01714007f, -0.03712868f, -0.03922599f, 0.02307144f, 
    0.01300289f, -0.00274877f, 0.00656149f, -0.01304393f, 0.00473839f, -0.02574730f, 0.00146012f, 0.02965518f, 
    -0.01791915f, -0.03073567f, -0.02367352f, -0.00582050f, 0.01310165f, -0.02887272f, -0.03170134f, 0.02940516f, 
    -0.03882058f, 0.02020684f, -0.00693744f, 0.02223803f, -0.03015574f, 0.02423064f, -0.01623681f, -0.03243250f, 
    0.01210798f, -0.01631626f, 0.00617248f, 0.01308517f, -0.02240552f, 0.02771578f, -0.01317878f, 0.00787247f, 
    0.00454842f, -0.03552922f, -0.01323959f, -0.02766971f, -0.03721937f, 0.01141061f, 0.00348576f, 0.01788582f, 
    -0.01457255f, -0.02457375f, -0.00909098f, -0.02273003f, -0.01922624f, 0.02842929f, 0.01447603f, -0.04176917f, 
    -0.03482664f, -0.01988857f, -0.02789711f, 0.01604461f, -0.01668826f, 0.01735971f, -0.00978600f, -0.02022529f, 
    0.01969483f, -0.00117605f, -0.00244937f, -0.01606617f, 0.00725643f, -0.01281672f, -0.00809690f, 0.01338939f, 
    -0.01732741f, 0.00578037f, -0.01941121f, -0.03243295f, 0.00080696f, -0.01900855f, 0.02520372f, 0.00832524f, 
    -0.03504886f, 0.02613691f, -0.01301304f, -0.02336669f, -0.00909276f, 0.00391876f, -0.04072407f, -0.02971660f, 
    -0.02643691f, 0.02525813f, -0.01826156f, 0.01392154f, -0.01290785f, -0.00818498f, -0.02205773f, -0.01815782f, 
    0.02144655f, 0.00085020f, 0.01698076f, -0.02777300f, -0.03142694f, -0.03816752f, 0.00025800f, -0.03610001f, 
    -0.03309869f, -0.00876968f, -0.00131003f, 0.02076983f, 0.01303539f, 0.01487846f, -0.03242657f, -0.02400097f, 
    -0.01330235f, -0.02617402f, 0.00953666f, 0.02133065f, 0.00722237f, -0.03837566f, 0.00954216f, -0.00837435f, 
    -0.00627828f, -0.01492347f, -0.02265223f, 0.01649175f, -0.04168047f, -0.03150825f, -0.01849554f, -0.01673529f, 
    -0.03553318f, -0.00618567f, -0.03578783f, -0.03969884f, 0.01523745f, -0.03205314f, -0.03061488f, 0.02414565f, 
    -0.03082041f, 0.00986779f, 0.00546396f, 0.00221394f, -0.02007687f, 0.00730776f, -0.00879932f, 0.00048014f, 
    -0.02268112f, -0.00583481f, 0.02255245f, -0.01075551f, -0.02659213f, -0.02840929f, -0.01351657f, 0.02243580f, 
    -0.00155417f, 0.00422420f, -0.01375900f, -0.00045837f, 0.02571574f, -0.01631912f, 0.00100074f, -0.02899447f, 
    -0.01233249f, 0.00810907f, -0.00541384f, -0.01938147f, -0.03064757f, 0.01975172f, 0.00827721f, -0.01085682f, 
    -0.00728679f, -0.03195775f, 0.01199369f, -0.03269681f, -0.00111599f, -0.01513462f, 0.01054710f, -0.02792270f, 
    0.01828433f, -0.00430267f, -0.02311844f, -0.03960165f, -0.00080940f, 0.01681532f, -0.01332854f, -0.00394555f, 
    -0.02844298f, 0.00484244f, -0.03271583f, -0.04004858f, -0.02481349f, -0.01260644f, -0.01983559f, -0.00360354f, 
    0.01151815f, -0.03464917f, -0.00459596f, -0.00056690f, -0.01364082f, -0.04053245f, 0.01472658f, 0.00306237f, 
    -0.01458981f, -0.03568168f, -0.03748524f, -0.00672275f, -0.01430754f, -0.03949974f, -0.00573990f, 0.00754591f, 
    -0.01891481f, 0.00872951f, -0.02144662f, -0.03588234f, 0.03023247f, 0.01704803f, 0.02074068f, -0.04052896f, 
    -0.01530560f, -0.00698442f, 0.02025112f, -0.03547314f, -0.02939618f, 0.01171813f, -0.01675991f, 0.00821899f, 
    0.00734964f, 0.00743643f, -0.03236594f, -0.00663818f, 0.01119408f, 0.02560614f, -0.02032040f, -0.01382325f, 
    -0.03021422f, 0.01339775f, 0.02365871f, -0.01341361f, 0.00536698f, -0.01786747f, 0.00432206f, 0.00300145f, 
    -0.01599200f, -0.00453722f, -0.03118912f, 0.01350271f, 0.02012934f, -0.01094413f, -0.00516080f, -0.01755454f, 
    -0.04033777f, 0.02286922f, -0.00990425f, 0.01125263f, 0.01737989f, 0.01604184f, 0.02999220f, -0.00055983f, 
    -0.03559988f, 0.00757914f, -0.01782923f, 0.01780648f, 0.02683853f, -0.04050693f, -0.01671251f, -0.00817097f, 
    0.01793025f, 0.00214481f, 0.00881484f, -0.02491664f, -0.01946024f, -0.02345361f, 0.02100166f, -0.03486717f, 
    -0.02963173f, 0.01127982f, 0.01950300f, 0.02062003f, 0.02390240f, 0.02253224f, -0.01446688f, 0.01812956f, 
    0.02022757f, 0.00053857f, -0.00437124f, -0.02745577f, -0.03465540f, 0.00857993f, -0.03481324f, -0.04202531f, 
    0.02548135f, -0.02976482f, 0.01587814f, -0.00932257f, -0.02172547f, 0.01714423f, 0.00933148f, -0.00880247f, 
    0.01427526f, -0.00711311f, 0.02290152f, -0.02280650f, -0.00866716f, 0.01155486f, -0.01226568f, -0.03362718f, 
    0.03049163f, -0.01411185f, 0.00541790f, 0.02318338f, -0.02937020f, 0.02101611f, -0.01637470f, -0.03221387f, 
    -0.04101354f, -0.00929988f, -0.03792403f, 0.02378827f, 0.00397959f, -0.03203014f, 0.00483825f, -0.02726935f, 
    0.00612204f, -0.01385399f, 0.02980268f, 0.01696559f, -0.00424857f, -0.01064882f, -0.03645048f, 0.01665167f, 
    0.02196715f, 0.00712216f, -0.01165706f, -0.02999427f, -0.00417494f, -0.00894637f, -0.00947156f, -0.01535857f, 
    -0.03238403f, -0.03393624f, 0.01908395f, -0.00452091f, -0.03092037f, 0.02703866f, 0.00887708f, -0.01706296f, 
    0.00261407f, 0.00375441f, 0.01255977f, 0.00427300f, 0.02504486f, -0.00980878f, -0.01219963f, 0.02690207f, 
    0.01778048f, -0.03666149f, 0.03285438f, -0.03297108f, -0.00156171f, -0.00372291f, -0.00106793f, 0.00675825f, 
    0.00926812f, -0.02214552f, -0.03788150f, -0.03951839f, -0.01234679f, -0.04188811f, 0.00910795f, -0.02421736f, 
    0.00213900f, -0.02900167f, 0.01402058f, 0.01339156f, 0.01588443f, 0.01785908f, -0.03208981f, 0.02736596f, 
    -0.03367211f, -0.01089592f, -0.02334147f, 0.01879135f, -0.01956532f, 0.02241065f, -0.03226810f, -0.00089810f, 
    -0.03665959f, -0.03735374f, -0.00360937f, -0.03142327f, -0.00433150f, -0.00103548f, 0.00577824f, -0.02888278f, 
    0.03129343f, 0.00393313f, -0.02320768f, -0.02657698f, -0.03759117f, -0.01472640f, -0.04069322f, -0.03014112f, 
    -0.00032792f, -0.01935510f, -0.03629807f, -0.01887698f, -0.00022905f, -0.04086554f, 0.00268061f, -0.03786866f, 
    0.02717327f, -0.01680821f, 0.02686988f, 0.03524259f, -0.03285904f, 0.00765314f, 0.00977612f, 0.02222499f, 
    0.02966759f, -0.02792964f, -0.00103739f, -0.00829969f, 0.01638133f, -0.01107749f, -0.01265228f, 0.01117975f, 
    -0.01151558f, 0.01125887f, 0.00885997f, -0.03224827f, 0.01649207f, 0.00453590f, 0.00779617f, -0.01311581f, 
    0.00610425f, 0.00564215f, -0.01829348f, -0.01909364f, -0.02685696f, 0.02088352f, -0.01182256f, -0.03360242f, 
    -0.03813297f, -0.03356873f, -0.02090263f, -0.03337153f, 0.01672601f, -0.02962437f, -0.01272795f, -0.01397513f, 
    0.03000906f, -0.01096861f, 0.00342381f, -0.01665814f, -0.01080335f, 0.02491369f, 0.01603951f, -0.02642639f, 
    -0.00689986f, -0.00986110f, 0.02659512f, -0.02874886f, 0.01501188f, -0.00971564f, -0.01545116f, 0.01405229f, 
    -0.02641954f, 0.02029393f, -0.02810296f, -0.00609642f, 0.01296437f, 0.02157678f, 0.02045495f, -0.01648400f, 
    -0.02463230f, -0.03321277f, -0.03773160f, 0.02869133f, -0.03229531f, 0.02535124f, 0.00402950f, 0.01825171f, 
    0.01858275f, -0.00655171f, -0.00922699f, 0.00142312f, -0.03324855f, 0.01641112f, -0.00785103f, 0.00941232f, 
    0.00169212f, -0.00962230f, 0.01318317f, -0.01937719f, 0.02769170f, -0.01871291f, -0.01344841f, 0.01257190f, 
    0.03009849f, -0.03704323f, -0.01569160f, 0.01082900f, -0.00509911f, -0.00984033f, -0.03718296f, 0.02421255f, 
    0.02546844f, -0.02263029f, -0.01630652f, -0.02526853f, 0.00863602f, -0.01899534f, -0.01886381f, 0.02699049f, 
    0.00327604f, -0.01504414f, 0.01296669f, -0.00965303f, -0.01098799f, 0.00953895f, -0.03237173f, 0.02512267f, 
    0.00089414f, 0.00810106f, 0.01993552f, -0.01465354f, 0.00937582f, 0.02137696f, 0.02817770f, -0.01919479f, 
    -0.02811006f, -0.03548902f, 0.02130864f, -0.01312258f, -0.02184156f, -0.00024797f, -0.01570452f, -0.03773915f, 
    -0.01527612f, -0.00222563f, -0.00553124f, -0.00455603f, 0.00253327f, -0.03716537f, 0.01048954f, 0.02961775f, 
    0.02599606f, 0.00055721f, 0.03040832f, -0.00566747f, -0.02642328f, -0.02544864f, -0.00375082f, 0.01964485f, 
    -0.01125725f, -0.02110512f, 0.01629296f, 0.02174702f, 0.03454405f, 0.00642128f, -0.02910427f, -0.01903341f, 
    0.02027156f, 0.01563381f, 0.00737513f, 0.00652213f, 0.00607077f, -0.00495364f, 0.01035928f, 0.02891097f, 
    -0.00980029f, 0.00995731f, 0.00375457f, -0.00943435f, -0.02994885f, 0.00092867f, -0.00821853f, -0.03645384f, 
    0.02745691f, -0.03450017f, 0.01514182f, -0.02174995f, 0.00992837f, -0.00929287f, 0.00279469f, 0.00553012f, 
    -0.01205404f, 0.02594683f, 0.00004692f, -0.02032596f, -0.03995353f, -0.01628212f, -0.02969737f, 0.01829335f, 
    -0.00740500f, -0.00638802f, -0.00962298f, -0.03298539f, -0.02149160f, -0.03837541f, 0.02801613f, -0.02612894f, 
    -0.02725662f, -0.00688109f, -0.01702639f, 0.01789970f, -0.00679611f, -0.03460316f, -0.01367214f, -0.01371904f, 
    0.00653558f, 0.02449838f, 0.01525879f, -0.02638605f, -0.01892950f, 0.02980206f, 0.02963386f, 0.02309361f, 
    -0.00857708f, 0.00934189f, -0.03456241f, 0.02094150f, -0.02674497f, -0.03255943f, 0.00641160f, 0.01550906f, 
    0.00414956f, -0.02025462f, 0.02831038f, 0.02454734f, -0.01034092f, -0.00283940f, -0.03750654f, -0.02813174f, 
    -0.02789050f, -0.00685779f, 0.02235884f, 0.01886660f, -0.03055550f, 0.02101380f, -0.02784083f, -0.04241255f, 
    0.00283736f, 0.00637944f, 0.02491340f, 0.00939041f, 0.01326597f, -0.01872071f, 0.01403214f, -0.02618168f, 
    -0.01274349f, -0.01100453f, -0.03324762f, 0.02458639f, -0.00211491f, -0.01682426f, 0.03167558f, 0.00816533f, 
    0.01978179f, -0.01714337f, 0.01082957f, -0.03136157f, -0.03370217f, 0.02547183f, 0.02366045f, 0.01069047f, 
    0.00502702f, -0.00679470f, -0.01341948f, 0.00677585f, 0.01108073f, -0.02011949f, 0.00276075f, 0.00266489f, 
    0.02341407f, 0.02976817f, 0.01176961f, -0.01181837f, -0.00252652f, -0.03424825f, -0.01035044f, -0.03437470f, 
    -0.00662421f, -0.03388007f, -0.00671288f, -0.01766434f, -0.03772850f, 0.02003477f, -0.02385433f, -0.02161815f, 
    0.00561704f, -0.02030787f, -0.03138099f, -0.03811620f, 0.01927659f, 0.02536752f, 0.02445103f, -0.01598821f, 
    -0.01600781f, -0.01250028f, -0.03315995f, -0.00725892f, -0.02553609f, -0.03205656f, 0.01340343f, 0.02358439f, 
    0.00712488f, -0.01445224f, -0.02700722f, -0.02127730f, -0.03015004f, -0.02593467f, -0.03876465f, -0.00852370f, 
    -0.02231530f, 0.00670442f, -0.00898757f, 0.00549588f, -0.01433126f, -0.03704562f, 0.00531551f, -0.01644147f, 
    -0.03741603f, -0.02237209f, 0.01039053f, 0.01900244f, -0.00001159f, -0.02681329f, -0.03069622f, 0.00962117f, 
    0.03908875f, -0.03796697f, 0.00254955f, -0.03105928f, 0.00855851f, 0.01390063f, -0.03571465f, -0.03094151f, 
    0.00789009f, 0.00807038f, -0.00973306f, -0.01776676f, -0.00652792f, 0.02082158f, -0.01463052f, 0.00489233f, 
    0.02064419f, 0.03076971f, 0.00329502f, -0.02305918f, -0.01139952f, -0.03713283f, -0.01650688f, 0.02406760f, 
    -0.03998909f, 0.01416831f, -0.02673635f, -0.01272603f, 0.00178129f, 0.01846472f, -0.00588716f, 0.00535071f, 
    -0.02752604f, -0.01336657f, 0.02470802f, -0.00040572f, 0.01186909f, -0.03093622f, -0.01022647f, -0.03760217f, 
    -0.02871578f, -0.00745386f, -0.01650142f, -0.01157201f, 0.02570424f, -0.02168933f, 0.02419960f, 0.01942427f, 
    0.00795578f, 0.02091564f, -0.04147658f, 0.02087667f, -0.01630761f, 0.01560933f, -0.00862645f, -0.03084670f, 
    0.00688598f, -0.02580176f, -0.00792762f, -0.01644243f, 0.02166221f, -0.01670748f, -0.03027141f, 0.01861807f, 
    0.00701938f, 0.00373904f, 0.00840151f, 0.00985730f, -0.03860017f, -0.04493246f, -0.01674633f, 0.00052984f, 
    -0.00864773f, 0.02961547f, 0.03970299f, 0.02049539f, 0.00011328f, 0.02247250f, 0.02026700f, 0.00148978f, 
    0.00790842f, -0.01547623f, -0.01855813f, 0.00448863f, -0.02568842f, 0.00431642f, -0.00350006f, 0.01444797f, 
    -0.03266579f, -0.01098542f, 0.02590242f, 0.01060720f, -0.01429383f, -0.03174054f, -0.02447678f, 0.00660296f, 
    0.00825098f, 0.01820804f, -0.01441503f, -0.00924246f, -0.02160558f, -0.03123957f, -0.02499722f, -0.04381963f, 
    0.02347882f, -0.02367158f, 0.03461209f, -0.03000938f, -0.01868774f, -0.01781200f, -0.00281053f, -0.02344226f, 
    0.00785138f, 0.00501897f, 0.02061942f, -0.01854413f, -0.02506161f, -0.03067064f, -0.02136515f, 0.02210208f, 
    -0.00387213f, 0.00238758f, -0.03044771f, -0.04400603f, -0.03252190f, -0.00119150f, 0.01786179f, 0.00266320f, 
    0.01475546f, -0.02195366f, -0.00197514f, 0.01791593f, -0.04101564f, -0.01219305f, 0.00319359f, 0.02512036f, 
    0.01092612f, -0.02142216f, -0.00501875f, 0.01413383f, 0.02890738f, 0.00713667f, 0.02671264f, 0.02572373f, 
    -0.03630011f, -0.00309175f, 0.02767907f, -0.02338197f, 0.00646787f, -0.01598780f, -0.01557960f, 0.01392467f, 
    -0.02720062f, 0.01337731f, -0.02106875f, -0.00927250f, -0.02884739f, -0.02988017f, 0.02846839f, 0.00557876f, 
    0.01244985f, -0.04003144f, -0.00527921f, -0.03335153f, -0.00745629f, -0.01532947f, -0.02388782f, -0.00235274f, 
    -0.03085518f, -0.03607442f, -0.02679821f, 0.00860242f, 0.01841104f, -0.02936880f, -0.00385192f, 0.00258683f, 
    -0.03476104f, -0.03115339f, 0.02382636f, -0.01918029f, -0.03127049f, 0.02329944f, -0.02807317f, -0.03230863f, 
    0.00655833f, -0.04043406f, 0.02165436f, -0.03368765f, -0.03042188f, 0.00420531f, 0.00810435f, -0.01588909f, 
    0.00801640f, -0.03383302f, -0.02408711f, -0.03414783f, -0.00531833f, -0.03509850f, 0.00106474f, 0.00881633f, 
    -0.03716866f, -0.03077616f, 0.00074657f, -0.01783106f, -0.00933431f, -0.03003412f, -0.02885259f, 0.00908558f, 
    -0.01830268f, -0.03399262f, 0.02697959f, 0.02780538f, 0.00315484f, -0.02433640f, -0.00734719f, 0.01909170f, 
    -0.00229531f, -0.01733354f, -0.01662887f, 0.00003237f, -0.01893590f, 0.02071617f, 0.03012395f, -0.00700260f, 
    0.01343517f, 0.01975029f, -0.00433539f, -0.01736327f, -0.02927025f, -0.03189046f, -0.02144199f, 0.01237267f, 
    -0.00693076f, 0.00173228f, -0.03618821f, -0.00623814f, -0.02629085f, -0.03902438f, 0.03096214f, -0.01549065f, 
    -0.04569874f, 0.00167387f, 0.01268095f, 0.01125629f, 0.00622156f, -0.02676140f, -0.04319245f, -0.00536988f, 
    -0.03557285f, -0.00053448f, 0.02123410f, -0.00893327f, 0.00752623f, -0.01787703f, 0.01690957f, 0.02224671f, 
    -0.04403931f, -0.02687604f, -0.02056370f, -0.02212642f, -0.02938722f, -0.03633986f, -0.01214238f, -0.01029827f, 
    0.02491605f, 0.00161514f, -0.03406486f, -0.03545848f, 0.00691162f, 0.01468159f, 0.03678061f, 0.01954511f, 
    -0.03200821f, -0.02873473f, 0.01698596f, -0.04159212f, -0.02724707f, 0.00750988f, 0.00731544f, 0.01564911f, 
    0.02061577f, -0.02211716f, -0.01233682f, -0.04249065f, 0.00962288f, -0.02486695f, -0.00066929f, 0.02834687f, 
    -0.03539609f, -0.02288074f, -0.01155428f, -0.03918352f, -0.00617494f, -0.02849209f, -0.03940980f, -0.00891268f, 
    -0.01208498f, -0.00928598f, -0.00902463f, -0.03258498f, 0.01992783f, -0.01468044f, -0.00818300f, -0.01821291f, 
    -0.02888818f, -0.03054745f, 0.00152703f, 0.01535111f, 0.01845119f, -0.02908194f, -0.03883846f, -0.01589144f, 
    -0.02404177f, -0.03454073f, 0.00348819f, -0.00342028f, 0.01214573f, -0.01464421f, -0.02291228f, 0.01717738f, 
    0.03726330f, 0.01649519f, -0.01212780f, 0.00114931f, -0.01006008f, -0.01720856f, -0.01253134f, 0.01347492f, 
    -0.01796823f, 0.03475872f, -0.00924075f, -0.04347058f, -0.01998065f, -0.02589560f, -0.02109211f, -0.02118725f, 
    0.01686413f, 0.00962978f, -0.02012863f, 0.01757318f, -0.04003948f, -0.03733662f, 0.01069018f, -0.01683315f, 
    -0.01790511f, -0.00929980f, -0.01011064f, 0.02257251f, 0.02838491f, -0.01310271f, 0.00762256f, 0.00791091f, 
    -0.03330056f, -0.03804316f, 0.02350632f, 0.00944038f, -0.03367566f, -0.01066833f, 0.00341976f, 0.01068322f, 
    0.01513923f, -0.01997099f, 0.02942836f, -0.04289646f, -0.01996673f, -0.00240071f, 0.00435191f, -0.01359430f, 
    -0.03871859f, 0.02051033f, -0.02936022f, -0.03797490f, -0.02834770f, -0.04302391f, -0.00837641f, -0.02308893f, 
    -0.00507314f, -0.02718902f, 0.02310519f, 0.01061639f, -0.02321046f, 0.00807289f, -0.03096204f, 0.01945289f, 
    0.03003202f, -0.00696916f, 0.03040767f, 0.00652998f, -0.03822350f, -0.01754372f, 0.02844564f, -0.01628166f, 
    0.07518959f, 0.00949351f, 0.28822586f, -0.09084815f, 0.07565435f, -0.00249147f, 0.10783290f, 0.18730462f, 
    0.01884474f, 0.06484220f, 0.11435274f, -0.13113031f, 0.08047511f, -0.06496986f, 0.07288462f, -0.17852600f, 
    -0.06381462f, 0.07487507f, 0.05691527f, 0.00762744f, 0.00866086f, 0.04527581f, -0.03620763f, 0.04273289f, 
    0.30625919f, -0.08934102f, 0.15471436f, 0.06424394f, -0.07173535f, -0.04741038f, 0.03588070f, 0.03439077f, 
    -0.05534621f, -0.07383487f, -0.06670151f, -0.01169342f, -0.07496494f, 0.18607661f, -0.08020858f, 0.00807677f, 
    0.12013959f, 0.12045422f, -0.11930869f, -0.02057758f, -0.01085060f, -0.03824516f, -0.01169512f, 0.00583621f, 
    -0.11511176f, 0.05802644f, -0.14267388f, 0.19182846f, -0.03767183f, 0.00077477f, -0.09327164f, 0.01106784f, 
    0.03369367f, 0.01831677f, -0.02746760f, -0.05500205f, -0.32861248f, 0.07814650f, -0.02694376f, -0.17634466f, 
    0.07799544f, 0.07839949f, 0.00740729f, -0.01391953f, -0.00228743f, -0.03824999f, 0.00949483f, -0.00626884f, 
    0.11730791f, 0.21506818f, 0.13024189f, 0.13977526f, 0.04265653f, 0.00942453f, 0.05575141f, 0.01199593f, 
    0.05878530f, 0.03652534f, 0.07058135f, 0.00460547f, -0.14832008f, -0.01702071f, 0.26108900f, -0.22282574f, 
    -0.08673462f, -0.02023775f, -0.03507847f, 0.04681900f, 0.10703600f, -0.05410934f, -0.01920167f, -0.11761234f, 
    0.11567857f, -0.03919144f, -0.02031802f, -0.10644082f, 0.02704300f, 0.06097547f, 0.02174457f, -0.09694897f, 
    -0.02779988f, -0.04711560f, 0.03734411f, 0.00732771f, -0.25228134f, 0.17965148f, 0.29182494f, -0.14148851f, 
    -0.00209561f, 0.02551585f, -0.02576026f, -0.09121016f, -0.01184854f, 0.00251021f, -0.04465909f, -0.01101130f, 
    -0.19397071f, 0.09503762f, -0.01314162f, -0.08864108f, -0.00970956f, 0.11695631f, 0.17767160f, -0.07445210f, 
    -0.00295069f, 0.07033983f, -0.04561007f, -0.01754709f, 0.07721454f, -0.11505760f, 0.30885765f, 0.20632187f, 
    -0.01231202f, -0.07322429f, 0.11412057f, 0.07954666f, -0.07839452f, 0.06771380f, 0.04307495f, 0.07306105f, 
    0.09489602f, -0.10829604f, 0.04735515f, 0.17036593f, -0.00020768f, 0.03719480f, -0.00442937f, 0.06332402f, 
    0.00547144f, -0.02674780f, -0.01744455f, -0.07776749f, -0.15733589f, 0.05336726f, -0.05142923f, -0.21647279f, 
    -0.01014296f, 0.05034560f, -0.06346086f, -0.09178703f, 0.01282702f, -0.02285579f, -0.02095735f, 0.01299870f, 
    0.27148092f, 0.02156347f, 0.10014586f, 0.02442915f, -0.00025460f, 0.16456431f, 0.04579768f, -0.12997510f, 
    0.01221088f, -0.01620089f, 0.10698994f, 0.02300409f, -0.25655335f, 0.09371731f, -0.14612734f, 0.23352759f, 
    0.03059890f, 0.02292696f, 0.01657041f, 0.04327665f, 0.05036856f, -0.02700458f, -0.03630522f, 0.06333225f, 
    0.10590333f, 0.03963457f, 0.28152108f, -0.28494191f, 0.05728203f, 0.09187799f, -0.02135461f, 0.05857856f, 
    0.00241447f, 0.04517006f, 0.03840842f, -0.07256464f, -0.05010476f, 0.03785617f, 0.23915476f, 0.21711670f, 
    0.01502311f, -0.06815965f, 0.05842834f, -0.05634097f, 0.06606619f, 0.01250388f, 0.01510071f, 0.02692633f, 
    0.03093061f, 0.10843923f, -0.09342903f, 0.00138526f, 0.01209101f, 0.00403084f, 0.08144888f, 0.00205623f, 
    -0.09960313f, 0.01093903f, 0.01828831f, 0.07059336f, -0.10099631f, 0.05169529f, 0.05650652f, -0.14058542f, 
    -0.12781826f, 0.04188295f, 0.10334892f, 0.08066375f, -0.00371116f, 0.06467135f, 0.02969391f, 0.03445591f, 
    -0.12053089f, 0.05467698f, -0.14742234f, 0.17092511f, 0.01965705f, 0.03833435f, -0.08634731f, 0.01337084f, 
    -0.03109800f, 0.02443148f, 0.04234013f, -0.06106211f, 0.01586219f, 0.07231531f, -0.09209760f, 0.05974278f, 
    0.02658525f, -0.08227799f, -0.03111360f, -0.02668785f, 0.09571277f, -0.03275230f, 0.03752242f, -0.06587633f, 
    -0.04438184f, -0.00635276f, 0.13725354f, -0.21520987f, 0.02558805f, 0.00704284f, 0.01705761f, -0.07594785f, 
    0.01889887f, 0.03724738f, -0.01189089f, -0.06053413f, -0.03595068f, 0.05196873f, 0.19227125f, -0.10604018f, 
    0.02957680f, -0.01526527f, 0.15002589f, 0.05674505f, -0.04237036f, 0.00952516f, 0.10989586f, 0.02579258f, 
    -0.01295650f, 0.16914402f, -0.08622436f, 0.09659234f, -0.02848170f, 0.06125246f, -0.05181900f, -0.02200692f, 
    0.06600662f, 0.04220114f, 0.04560697f, -0.00044843f, -0.07403591f, 0.04189140f, 0.06015962f, -0.24203199f, 
    -0.09812763f, -0.08190157f, 0.05107455f, -0.11064512f, 0.00569630f, -0.01507874f, 0.08947498f, 0.03169908f, 
    0.05682858f, 0.11994487f, 0.17713895f, 0.19777504f, 0.16203716f, -0.11025071f, -0.03721401f, -0.10281339f, 
    0.04391310f, 0.01454219f, 0.22505270f, 0.05355794f, -0.04427294f, 0.04699061f, -0.14683498f, 0.05041439f, 
    0.07897765f, 0.01930509f, 0.08778408f, -0.03126678f, 0.12570198f, 0.03298481f, -0.14244968f, 0.00295870f, 
    -0.11234471f, -0.20154981f, -0.01635539f, 0.02239399f, 0.03090785f, -0.03679157f, 0.07646432f, 0.01591745f, 
    -0.07754115f, 0.09227096f, -0.09440200f, 0.08371587f, -0.17068821f, 0.06146725f, 0.03786750f, -0.19389674f, 
    0.09576947f, 0.08809291f, 0.08423693f, -0.02343620f, -0.04311565f, 0.10235990f, -0.05108499f, -0.11102048f, 
    -0.07581441f, 0.00069522f, -0.00838675f, 0.17403135f, 0.08879217f, -0.02606697f, -0.04662534f, 0.04143752f, 
    -0.02337845f, -0.02690700f, 0.05218802f, 0.04620126f, -0.01234435f, 0.17117417f, 0.18219006f, -0.07496250f, 
    0.07518132f, 0.01394188f, 0.09203617f, 0.05898676f, 0.01118440f, 0.09071032f, -0.06229451f, 0.02282475f, 
    0.14932944f, -0.03980995f, -0.20939395f, 0.02243844f, 0.00572586f, 0.13281901f, -0.04974197f, -0.16667038f, 
    0.04969556f, 0.00325352f, 0.02698058f, 0.01892020f, -0.03526182f, -0.03393840f, 0.02227207f, 0.07261840f, 
    -0.15354477f, 0.02579089f, -0.02102535f, -0.02414393f, 0.02051557f, -0.05846467f, -0.00798247f, 0.08471297f, 
    -0.08580058f, 0.07282706f, 0.18541819f, 0.22442138f, -0.01291713f, -0.00572613f, -0.03564104f, 0.00986185f, 
    -0.06584015f, -0.03047970f, -0.02464791f, 0.02578036f, 0.06505671f, 0.07558533f, -0.07642763f, 0.02803734f, 
    -0.09653040f, -0.08157770f, 0.01197635f, 0.00792904f, 0.00804007f, 0.05675504f, 0.01750298f, 0.11661953f, 
    0.03351671f, 0.12968910f, 0.28409591f, 0.18830854f, 0.10995832f, -0.11115007f, 0.06578317f, 0.04545989f, 
    0.05676508f, 0.09529094f, -0.07237052f, 0.09082075f, -0.14604297f, -0.03589371f, -0.01249086f, -0.10901924f, 
    0.03454679f, 0.11378241f, 0.07894336f, -0.10519550f, 0.00990589f, -0.01815590f, 0.03018372f, 0.02556338f, 
    0.04428059f, 0.00419690f, 0.00022034f, 0.01580447f, 0.13004775f, 0.04400127f, 0.06194859f, -0.16205208f, 
    0.03195831f, 0.01285636f, -0.05130085f, -0.01556311f, -0.14253829f, 0.10484932f, 0.05999934f, -0.07919548f, 
    -0.06470583f, -0.05072641f, 0.05075549f, -0.00334908f, 0.05360778f, 0.13926558f, -0.08343644f, 0.03570635f, 
    -0.03533186f, -0.13166037f, 0.11515844f, -0.19172195f, -0.11155482f, -0.03323655f, 0.03776012f, 0.11848709f, 
    0.00077015f, 0.01375742f, 0.00939534f, 0.02211364f, -0.02862092f, -0.01063272f, 0.14001618f, -0.21126001f, 
    -0.10210661f, -0.03096448f, -0.09428736f, -0.01362767f, 0.04678697f, -0.00250307f, -0.06367188f, -0.00433179f, 
    0.06610014f, -0.12709327f, -0.07823008f, 0.37613794f, 0.03320367f, 0.03663734f, 0.00375518f, 0.05880407f, 
    -0.02673889f, -0.00091808f, -0.07733143f, -0.07944092f, -0.21103215f, 0.04274832f, 0.00030125f, -0.16079824f, 
    0.01009822f, -0.02162281f, 0.04193850f, -0.01424873f, 0.00929481f, -0.16110381f, -0.00918287f, 0.07753062f, 
    -0.03992501f, -0.15981077f, 0.02273610f, 0.05913790f, -0.14990431f, 0.00180974f, 0.03148081f, 0.04635019f, 
    0.07233248f, -0.10156155f, -0.00644273f, 0.04198432f, -0.16071698f, 0.17468409f, 0.13842988f, 0.05669222f, 
    0.01429520f, 0.02244501f, 0.03647591f, -0.05426406f, 0.00653975f, 0.05815811f, 0.00571373f, -0.07059118f, 
    -0.06533922f, 0.00105917f, 0.09042335f, 0.07057416f, 0.04214069f, 0.01416812f, -0.00765367f, 0.02951765f, 
    0.13509777f, -0.05064261f, 0.00962687f, 0.12925653f, -0.06380418f, -0.06000943f, 0.02015927f, -0.09056824f, 
    -0.04073696f, -0.04266417f, -0.00124299f, -0.06748493f, 0.02912592f, 0.02066139f, -0.00502979f, 0.03974861f, 
    -0.18974163f, 0.10224885f, -0.07826988f, 0.18605559f, -0.06410047f, 0.03026971f, -0.06411364f, 0.06228789f, 
    0.03949528f, 0.05696500f, -0.06334016f, -0.06254275f, -0.04867978f, -0.08198091f, -0.01253912f, 0.13087602f, 
    -0.01237655f, 0.04222554f, -0.05419077f, 0.00310414f, 0.10400462f, 0.10722961f, 0.03809644f, 0.04626962f, 
    -0.17016427f, 0.09586314f, -0.11029415f, -0.03120982f, -0.05452950f, -0.03033212f, -0.09478071f, 0.04095747f, 
    0.05150611f, 0.05254539f, 0.03586491f, -0.08271960f, 0.06932255f, 0.21997282f, -0.06696619f, -0.00352811f, 
    0.01200799f, 0.02794744f, 0.05089820f, -0.19698994f, 0.08456124f, -0.02775177f, -0.08544873f, 0.09753455f, 
    0.07937618f, -0.02857853f, 0.20670794f, -0.05228497f, -0.00681028f, -0.03505326f, 0.02375603f, 0.00048273f, 
    0.03199808f, 0.05200546f, 0.03981817f, 0.10611705f, 0.00255049f, 0.09475738f, -0.05048771f, -0.07402419f, 
    -0.06251632f, -0.02083050f, 0.09825233f, 0.01982816f, 0.05411930f, 0.12887786f, -0.10429995f, 0.08611895f, 
    -0.08386294f, 0.01703798f, 0.02913103f, -0.07173744f, -0.09463115f, 0.03801954f, 0.01467865f, -0.02387224f, 
    0.14031959f, 0.08102623f, 0.05063691f, -0.00922234f, 0.07027524f, 0.04305430f, -0.01362302f, 0.21829754f, 
    -0.03588165f, 0.03081184f, 0.05611854f, 0.04445649f, 0.12270891f, -0.04221537f, 0.02890283f, -0.10310796f, 
    0.10241757f, 0.00783347f, 0.08226018f, 0.20509471f, 0.02866089f, -0.04777433f, 0.04309638f, 0.04008506f, 
    -0.07196490f, -0.04309487f, -0.01724317f, 0.00628599f, -0.04459418f, 0.09280933f, 0.19878379f, 0.13399243f, 
    -0.02397001f, -0.02666598f, -0.03485787f, 0.00254807f, 0.19741501f, -0.04342432f, -0.11836444f, -0.02557968f, 
    0.11607192f, 0.27811360f, 0.14010769f, 0.46896917f, -0.05609384f, 0.00412526f, 0.06882220f, 0.06800920f, 
    0.02882571f, 0.05122915f, -0.03507558f, 0.04691238f, 0.19086204f, 0.16382904f, 0.15922096f, 0.13481890f, 
    -0.10696867f, -0.03974065f, 0.05569844f, 0.01015754f, -0.03985329f, -0.01768632f, 0.13616571f, 0.05673890f, 
    -0.14262401f, 0.04766230f, -0.10718341f, -0.09010467f, 0.09626369f, 0.01706174f, -0.06533860f, -0.10888489f, 
    0.10961590f, -0.00310888f, -0.02895279f, 0.08171932f, 0.03686511f, 0.07531197f, -0.07200933f, 0.26901522f, 
    -0.01401891f, -0.03588200f, -0.01951051f, -0.00486025f, -0.06118154f, -0.04576598f, -0.08699469f, 0.17676702f, 
    -0.02211781f, 0.08485509f, 0.13744850f, -0.04200479f, -0.08911149f, 0.14388907f, -0.08200087f, 0.00553229f, 
    -0.09127606f, -0.06308907f, 0.08912118f, 0.01477148f, 0.18590242f, -0.02170176f, -0.02394694f, -0.03527320f, 
    0.03821370f, 0.06859690f, 0.03092929f, 0.07000994f, -0.03352800f, -0.02712623f, -0.00870846f, -0.04010874f, 
    -0.05051873f, 0.21460876f, -0.21979246f, 0.02746512f, -0.03249672f, 0.18155827f, 0.09698223f, -0.07901721f, 
    -0.08056670f, -0.11684097f, -0.09972161f, -0.04216979f, -0.14779003f, 0.13182254f, 0.01627402f, 0.00103252f, 
    0.01836141f, 0.06825155f, 0.05695549f, -0.02342807f, -0.06179042f, 0.03455118f, -0.04754797f, -0.07369390f, 
    -0.14219148f, -0.15137522f, 0.00994030f, 0.20993280f, -0.04512452f, -0.01988186f, -0.09526312f, -0.14014198f, 
    -0.07197544f, 0.01253053f, 0.15771262f, -0.08614864f, 0.03710135f, 0.10049506f, 0.22896580f, 0.10470966f, 
    0.15502277f, 0.00049345f, 0.12534633f, 0.07926947f, -0.02976104f, 0.02659370f, 0.02836075f, 0.00977925f, 
    0.08592019f, -0.07664735f, 0.16451302f, -0.12987116f, 0.05472010f, -0.12430011f, 0.06776427f, 0.03159535f, 
    0.01307090f, 0.02576702f, 0.01989710f, 0.01070109f, 0.16401771f, 0.16918878f, -0.12654619f, 0.07871113f, 
    0.16704342f, 0.05153091f, 0.14541806f, 0.14305849f, 0.11828066f, 0.02071777f, 0.05675980f, -0.03151439f, 
    -0.20247383f, -0.08074784f, -0.08407257f, -0.10000732f, 0.05366291f, 0.04648225f, -0.05322357f, 0.02556406f, 
    -0.02293679f, -0.12316270f, -0.00141910f, -0.06947571f, -0.11875596f, 0.26427135f, -0.10560198f, -0.00859660f, 
    0.05756937f, 0.07350134f, 0.01980337f, 0.05852851f, -0.03898044f, 0.08610378f, 0.07386405f, -0.01000069f, 
    0.08020345f, -0.02017255f, -0.12822545f, 0.10549601f, 0.01425091f, 0.13513802f, -0.01313533f, -0.11764985f, 
    -0.05504875f, -0.00841234f, 0.04480826f, -0.03357103f, 0.18471909f, 0.06825960f, -0.13890347f, -0.20503214f, 
    0.04198682f, 0.06605471f, 0.07412469f, 0.04657681f, 0.05837343f, -0.05215375f, 0.12837170f, 0.04467085f, 
    -0.11290737f, 0.14414984f, -0.11204321f, -0.03417473f, 0.17729509f, 0.04535873f, -0.03581126f, 0.07971985f, 
    0.04981893f, -0.00849509f, 0.00106694f, 0.01839594f, -0.19910586f, 0.05192768f, 0.07935423f, 0.05782020f, 
    -0.01517184f, -0.01636682f, -0.05261863f, -0.17227706f, -0.05892689f, -0.07410263f, -0.03024870f, -0.00545170f, 
    -0.16518185f, 0.02663669f, 0.00785655f, 0.02276385f, -0.10198481f, 0.00438164f, 0.03477611f, 0.01313398f, 
    -0.09738631f, 0.04847248f, -0.02991256f, -0.13279173f, 0.13222553f, -0.11446192f, 0.02248539f, 0.06983455f, 
    0.12725644f, 0.11518223f, 0.05461287f, 0.02978531f, -0.03876107f, -0.05047932f, 0.01494736f, 0.05365104f, 
    0.38595194f, -0.10410252f, -0.04570987f, -0.09291746f, -0.04326288f, -0.08598536f, 0.04694333f, -0.06051751f, 
    -0.15729338f, 0.13259201f, 0.04601031f, -0.05608403f, -0.06285728f, -0.11455588f, 0.14276013f, -0.32000384f, 
    -0.01056578f, -0.12396546f, -0.01923526f, 0.08163872f, 0.01182070f, -0.03267094f, 0.03596988f, 0.00801226f, 
    0.08932142f, -0.12283809f, -0.06709071f, 0.21246767f, -0.01518617f, 0.01267962f, -0.05949112f, -0.04520595f, 
    -0.02895255f, -0.01725626f, 0.02663463f, -0.01753122f, 0.13986890f, 0.07789352f, -0.08117185f, -0.12343039f, 
    -0.10711370f, -0.02453370f, 0.05843702f, -0.03963460f, -0.03823251f, -0.03764791f, 0.04492315f, 0.05560978f, 
    -0.03273497f, -0.06092622f, 0.03521135f, 0.15002473f, -0.10837204f, -0.05164894f, -0.00711764f, -0.03419767f, 
    0.05354796f, -0.05370188f, -0.03655568f, 0.04004505f, 0.05848660f, -0.00381423f, 0.11023474f, -0.07428846f, 
    -0.13259666f, 0.00026644f, -0.00260732f, 0.01657983f, 0.00838953f, -0.07791510f, 0.04128414f, -0.11688028f, 
    -0.00674715f, -0.10355841f, -0.03374647f, 0.01803465f, -0.15947841f, -0.02613354f, 0.00339880f, -0.06550307f, 
    -0.07104724f, -0.00212397f, -0.07482032f, 0.02945081f, 0.06624567f, -0.17453665f, 0.09382717f, 0.15163200f, 
    0.04825345f, 0.04713084f, 0.14066817f, 0.00351965f, -0.06478712f, 0.01101136f, 0.02141043f, 0.07710500f, 
    -0.02060140f, 0.21030444f, -0.10104898f, 0.12476621f, -0.04575308f, 0.11543691f, 0.06501251f, 0.03180607f, 
    -0.08040313f, 0.04661804f, 0.02722852f, 0.03528463f, 0.27585992f, 0.09656414f, -0.05013435f, 0.11098450f, 
    -0.08999665f, 0.07160565f, 0.08287305f, -0.00971919f, -0.03549522f, 0.07921310f, -0.01639724f, 0.20463109f, 
    0.08710729f, -0.20503198f, 0.04552854f, -0.13028461f, -0.16128255f, -0.11843175f, 0.18645868f, 0.08137500f, 
    -0.08252676f, -0.05417423f, -0.03791499f, -0.04247086f, -0.10045431f, 0.27777758f, -0.05283816f, 0.14633508f, 
    0.04042970f, 0.13718177f, 0.04341003f, 0.07168593f, -0.01597654f, 0.07752264f, -0.02119633f, -0.04594164f, 
    0.10919663f, -0.00147802f, 0.06147142f, 0.00145644f, 0.09926803f, 0.03809322f, 0.12576817f, 0.10334649f, 
    0.11853715f, 0.12389451f, -0.01827905f, -0.00634457f, 0.04796234f, -0.16587673f, 0.10281198f, 0.07795813f, 
    0.10093649f, 0.06105736f, -0.04074765f, 0.20816265f, 0.02197216f, -0.07672433f, 0.03106843f, -0.02914219f, 
    -0.13271326f, -0.01913896f, -0.16145428f, 0.01124341f, 0.04092592f, -0.00416032f, -0.10418448f, -0.02215426f, 
    -0.03396077f, -0.06836154f, -0.11512569f, -0.08640279f, -0.21470578f, 0.08168423f, -0.30987751f, 0.11365497f, 
    0.01900223f, 0.15114078f, -0.07466823f, 0.04382024f, 0.03580437f, -0.01728957f, -0.01943035f, 0.01462384f, 
    -0.03962271f, -0.03045646f, -0.00923927f, 0.14755514f, -0.14722204f, 0.00333022f, 0.05571542f, 0.01523947f, 
    0.00403961f, -0.03826472f, -0.03804248f, -0.01540423f, -0.01974796f, -0.30835921f, -0.02246584f, 0.20069255f, 
    -0.10874364f, -0.04123152f, -0.05364024f, 0.02498689f, -0.04582748f, 0.06990445f, 0.08070358f, -0.00722813f, 
    0.12419334f, -0.12840600f, 0.19144025f, -0.14755782f, 0.18982984f, -0.13695005f, 0.02250724f, 0.00002731f, 
    -0.00114391f, 0.11696701f, -0.04231443f, -0.00807603f, 0.13614620f, 0.10246102f, 0.13435693f, 0.09521022f, 
    -0.09376752f, -0.09010471f, -0.01024991f, 0.04775247f, -0.04877482f, 0.00498924f, -0.04570090f, 0.02692700f, 
    -0.10870537f, -0.13007040f, 0.04305192f, 0.20645548f, 0.05157836f, -0.00092232f, 0.02599097f, 0.04602415f, 
    -0.05335749f, 0.04922156f, 0.01168837f, -0.04887347f, 0.12256144f, 0.00933868f, 0.00652240f, 0.07865886f, 
    -0.17799491f, -0.01369223f, -0.01384603f, -0.00584396f, 0.05923737f, -0.03195701f, -0.07404521f, -0.04314399f, 
    -0.14264582f, 0.06627779f, -0.01320813f, -0.04974814f, 0.02558020f, 0.22575702f, 0.08251607f, -0.01391745f, 
    0.06684863f, 0.06876674f, -0.04601334f, -0.01670399f, -0.05435975f, 0.16260569f, -0.12274484f, -0.02147400f, 
    0.16107942f, 0.09454288f, 0.06595157f, 0.11723954f, 0.06007575f, -0.03869172f, -0.08341065f, 0.07799082f, 
    0.12713337f, -0.06159872f, -0.01476377f, 0.11616665f, -0.01303642f, 0.10465392f, 0.01922494f, 0.14521235f, 
    -0.00307108f, -0.03537277f, -0.02461717f, -0.08467767f, 0.29390696f, 0.09646973f, 0.03554252f, 0.05042813f, 
    -0.07865886f, 0.09620656f, -0.00107311f, 0.08060296f, 0.01630073f, 0.11017915f, 0.08221656f, -0.14732969f, 
    -0.10631306f, 0.28076500f, -0.05669713f, 0.08331634f, 0.05525469f, 0.06814021f, -0.01049892f, 0.04124846f, 
    -0.02892504f, -0.00798628f, 0.02491656f, -0.03423250f, 0.27127233f, -0.00364692f, 0.00424335f, 0.07515205f, 
    0.12522243f, -0.02369222f, -0.08546154f, -0.03941823f, 0.06790093f, 0.09805549f, -0.02664449f, 0.07555784f, 
    -0.09002345f, 0.02965983f, 0.09199505f, 0.00957267f, 0.17101014f, 0.01512873f, 0.01254595f, -0.07320198f, 
    -0.03022681f, 0.00817125f, -0.06970268f, -0.05456020f, 0.10572984f, -0.03870793f, 0.13973624f, 0.08284055f, 
    -0.12440705f, -0.01203594f, 0.01645975f, -0.00445853f, 0.03132005f, -0.01818168f, -0.02049761f, -0.18246116f, 
    0.09231409f, 0.11778647f, 0.28889486f, 0.07959197f, -0.16516522f, 0.00178002f, 0.02470599f, 0.05549749f, 
    -0.04699672f, 0.05645138f, -0.03125101f, -0.01760056f, -0.07063319f, -0.06560255f, -0.06651464f, 0.02254024f, 
    -0.04504719f, 0.12486445f, 0.00896448f, 0.15731668f, -0.12721452f, 0.05937276f, 0.00604512f, -0.02191398f, 
    -0.03989021f, -0.00201731f, 0.09401342f, 0.00129400f, -0.07299680f, 0.00207176f, 0.01140980f, 0.05163600f, 
    0.00421886f, 0.09956480f, 0.00017986f, -0.04360180f, 0.32109925f, 0.02888745f, 0.03848790f, -0.02753900f, 
    0.07721058f, -0.02318491f, 0.13059197f, 0.06968806f, -0.04565902f, 0.03739681f, -0.00957824f, 0.02482986f, 
    0.14188263f, -0.09164729f, 0.04027742f, -0.24161193f, -0.02476724f, -0.06709111f, 0.10887210f, 0.09268904f, 
    -0.11418785f, 0.06492797f, 0.00861205f, -0.07172490f, -0.00489425f, 0.16372129f, 0.17367446f, 0.04622800f, 
    0.14045544f, 0.02073511f, -0.00529806f, 0.05276008f, 0.02081317f, 0.01555947f, -0.02643728f, 0.01986921f, 
    0.39681455f, -0.11030950f, 0.03136331f, 0.00221313f, -0.10050725f, -0.05785032f, 0.06266999f, -0.11062526f, 
    -0.02304574f, -0.02269277f, -0.05600414f, -0.02741280f, 0.03500270f, 0.09089083f, 0.17787284f, -0.17087752f, 
    0.04562490f, 0.02425278f, 0.02544041f, -0.00255669f, 0.00097786f, 0.08442631f, 0.04723860f, 0.00004103f, 
    0.00432129f, -0.17074598f, -0.03098380f, 0.03842840f, -0.00495124f, 0.05937354f, -0.09503616f, 0.05363869f, 
    0.01293706f, 0.07072750f, -0.01011433f, -0.01617113f, 0.09248238f, 0.19216965f, 0.10034432f, 0.06444623f, 
    -0.00777599f, 0.13575995f, 0.04608081f, -0.00162453f, -0.04972562f, -0.05806476f, 0.00661866f, -0.02826373f, 
    0.21895610f, 0.14343525f, 0.08799179f, 0.11526047f, -0.04566730f, -0.00563402f, 0.00407145f, 0.01781390f, 
    -0.00703035f, -0.09887146f, 0.02408548f, -0.05039661f, 0.20469855f, -0.18169454f, 0.13788117f, -0.15362753f, 
    0.07546239f, -0.11808626f, 0.00508800f, 0.10512550f, -0.17161971f, -0.10698540f, 0.03925261f, 0.11719774f, 
    -0.22613189f, 0.00601378f, -0.02215796f, -0.01103832f, -0.09721347f, 0.04030528f, 0.01402432f, -0.10007139f, 
    -0.09633447f, 0.00148445f, 0.02489566f, -0.01230955f, 0.05457366f, 0.14792301f, 0.13293284f, -0.16502027f, 
    0.08058530f, -0.02524306f, 0.00563429f, 0.13280576f, 0.07309867f, -0.04005026f, -0.01635736f, -0.09212096f, 
    0.07312118f, -0.01286914f, 0.09192588f, -0.20317565f, 0.03043517f, 0.00140520f, 0.08733034f, -0.01803137f, 
    -0.04152279f, 0.00477988f, 0.05182572f, -0.04324008f, 0.11398513f, 0.13531348f, 0.04993320f, 0.13633618f, 
    -0.05930774f, -0.00743307f, 0.05767468f, 0.02400370f, -0.05268685f, -0.00256078f, -0.04373094f, 0.07823534f, 
    0.07269407f, -0.00727145f, -0.06945270f, 0.07170671f, 0.03792521f, 0.07159720f, 0.07184754f, 0.12633656f, 
    -0.00151189f, 0.04367289f, -0.05416913f, 0.02156415f, -0.21148720f, -0.08052127f, 0.23103243f, 0.03257782f, 
    -0.09479332f, -0.09340194f, -0.04943561f, -0.09251176f, -0.01455893f, 0.02493860f, -0.01653151f, 0.00968151f, 
    0.27744913f, -0.16371956f, 0.04218969f, -0.03921156f, -0.08227521f, -0.05621232f, 0.13892344f, 0.01509446f, 
    -0.02761539f, -0.03164513f, -0.09379300f, 0.03426797f, -0.07850903f, -0.01148850f, -0.14506382f, 0.27095866f, 
    0.04964281f, 0.12100866f, 0.00335320f, -0.00118297f, 0.04592813f, 0.04672299f, 0.10795804f, 0.00728651f, 
    -0.00599295f, -0.03826811f, -0.01526244f, -0.03114454f, -0.02163767f, 0.00073588f, -0.00751814f, -0.04212580f, 
    -0.00362953f, -0.02329226f, -0.02207056f, -0.00525608f, -0.00942174f, 0.01134657f, 0.03285171f, -0.00967579f, 
    0.03133395f, -0.04093947f, -0.04411030f, -0.04398016f, 0.02039644f, -0.01541785f, 0.00373297f, -0.01898791f, 
    0.02086517f, 0.01701283f, -0.04467657f, 0.00416710f, -0.02347093f, 0.01186916f, 0.02612816f, -0.01241637f, 
    -0.03535357f, 0.01426193f, 0.01942832f, -0.04511468f, -0.01268841f, -0.00248186f, -0.03481412f, -0.02319933f, 
    0.00862208f, 0.01522647f, 0.00968366f, -0.00017553f, 0.02778809f, -0.01039580f, -0.03962950f, -0.02625687f, 
    0.00742469f, -0.02678111f, -0.01900618f, 0.01853727f, -0.01736383f, 0.03770126f, 0.02097730f, 0.01345866f, 
    -0.03342630f, -0.01159693f, 0.01062657f, -0.01360169f, 0.02171371f, -0.01848692f, -0.01113159f, -0.02826345f, 
    -0.01960959f, -0.01661887f, -0.00040079f, 0.00748906f, -0.00284018f, 0.02468465f, -0.00205566f, -0.03089256f, 
    -0.00309004f, 0.02627239f, 0.01269842f, 0.00677761f, -0.03817337f, -0.00469167f, 0.00269776f, 0.00508881f, 
    -0.00370783f, 0.00411131f, 0.02750904f, 0.00403658f, -0.02568352f, 0.01352041f, -0.03352346f, 0.00921186f, 
    -0.03238097f, -0.01979029f, 0.01607451f, 0.00232903f, 0.03091822f, 0.02480743f, -0.00615362f, -0.00907134f, 
    0.00300843f, -0.04277699f, -0.01031234f, -0.01035652f, -0.04039966f, -0.01488305f, -0.01963000f, 0.02250089f, 
    -0.01394366f, 0.02384088f, -0.00519906f, -0.03573878f, -0.01496008f, 0.01116418f, 0.00614111f, 0.00234332f, 
    0.00118798f, -0.00204494f, 0.01755868f, -0.01410208f, -0.03388399f, -0.00073755f, -0.02551313f, 0.00535676f, 
    0.02737005f, 0.01043897f, -0.04435639f, -0.00388364f, -0.04292537f, -0.02164121f, 0.01070618f, -0.03264976f, 
    -0.00923243f, 0.02810167f, -0.01974425f, -0.01392846f, 0.02526943f, -0.02715835f, -0.02242302f, -0.03266876f, 
    -0.03191278f, -0.04131687f, 0.00335185f, 0.02281311f, 0.02823465f, -0.03768447f, -0.02072198f, 0.03111448f, 
    -0.00545902f, -0.00005707f, 0.03619738f, 0.00460214f, 0.02962750f, -0.03029428f, 0.00091107f, -0.01178313f, 
    -0.03045700f, -0.02803794f, 0.02783980f, 0.00253018f, 0.01510338f, 0.00277144f, -0.03831699f, 0.01496384f, 
    0.01606336f, -0.04066566f, 0.00492486f, 0.00666765f, -0.02982853f, -0.00164017f, -0.00290866f, 0.01365479f, 
    -0.00240676f, -0.03123713f, -0.03323827f, 0.02035563f, -0.00064717f, -0.01341773f, -0.04278670f, 0.01918024f, 
    0.01838420f, 0.03482307f, -0.00056685f, 0.01214459f, 0.01449873f, -0.00832749f, -0.00174663f, 0.00623227f, 
    0.02204996f, 0.00774121f, 0.01538306f, 0.01682963f, 0.00957100f, 0.02469198f, 0.01742864f, -0.02419386f, 
    -0.00406076f, -0.02607405f, 0.02167678f, -0.01873826f, -0.04428307f, 0.00070716f, 0.02453389f, -0.01925307f, 
    0.00216595f, -0.00181361f, 0.01446945f, -0.03096725f, 0.00567190f, 0.00415068f, 0.00765721f, 0.02012312f, 
    -0.02852910f, -0.01506673f, -0.04051192f, 0.00388863f, -0.00936438f, 0.00741905f, -0.04795510f, -0.02016948f, 
    0.01524111f, -0.03413638f, -0.01352891f, -0.00745387f, 0.02368755f, -0.02465933f, 0.01712439f, 0.02232032f, 
    -0.01182655f, -0.01610526f, -0.01290736f, 0.02511210f, -0.03641278f, -0.03624059f, 0.02758389f, -0.04260853f, 
    0.01800039f, 0.00015814f, -0.02888688f, 0.02460739f, -0.03638956f, -0.00024767f, -0.00181807f, -0.00809552f, 
    -0.02410493f, 0.01188750f, 0.02002047f, 0.02383721f, -0.02138055f, 0.01953795f, 0.00875568f, -0.03081131f, 
    0.00790260f, 0.00515229f, -0.00591024f, -0.03233218f, 0.01925855f, 0.00272317f, -0.03350607f, 0.00687769f, 
    0.02148413f, 0.01783963f, 0.02307787f, -0.03338101f, 0.00538930f, -0.03789667f, -0.01588588f, 0.00511348f, 
    0.01568555f, 0.01664025f, -0.01702980f, 0.01499993f, -0.00997326f, 0.00323759f, 0.01893539f, -0.02424142f, 
    0.00072171f, -0.00207325f, 0.01006036f, 0.01378186f, 0.00247378f, 0.00681630f, -0.04092440f, -0.02935672f, 
    -0.01948075f, 0.02656033f, -0.00181624f, 0.00796960f, 0.01564227f, -0.03515640f, 0.01753728f, -0.00188314f, 
    -0.02214245f, -0.02430809f, -0.04066644f, 0.02509588f, -0.00205671f, -0.03674459f, -0.00778315f, 0.01348167f, 
    0.01844635f, 0.02645853f, 0.01442669f, -0.03143216f, -0.00263519f, -0.02519417f, -0.00469105f, 0.00601678f, 
    -0.03259141f, -0.04229166f, -0.01833548f, -0.03974872f, -0.02905376f, 0.00047163f, 0.00551273f, -0.02091231f, 
    -0.00357080f, -0.02320519f, 0.02300021f, -0.00098129f, -0.03496588f, 0.01571056f, -0.02524817f, 0.00465036f, 
    0.02401241f, -0.01547260f, -0.00898501f, 0.02117787f, 0.00411614f, -0.02573913f, -0.01872163f, 0.02721606f, 
    -0.02964365f, -0.00347890f, 0.01750403f, 0.00838940f, 0.02323362f, -0.01100936f, -0.02367601f, 0.02551395f, 
    -0.00722505f, -0.00587812f, -0.03406405f, 0.00924692f, 0.01082381f, 0.01255926f, -0.02392311f, -0.02725337f, 
    0.00055973f, -0.03460555f, -0.02611284f, 0.02081299f, 0.00525305f, 0.01719474f, -0.01877814f, -0.04366471f, 
    -0.04608924f, -0.03577153f, -0.00442945f, -0.00986331f, 0.01255879f, -0.03698279f, 0.00486350f, -0.01845513f, 
    -0.01886725f, 0.00195873f, 0.00033197f, 0.01271267f, -0.00545625f, 0.00185701f, -0.03339629f, -0.03962033f, 
    -0.00587816f, 0.01965945f, 0.00611366f, -0.00393875f, -0.00918474f, -0.00006806f, 0.02596970f, 0.02991679f, 
    0.01873844f, 0.00737517f, -0.01725806f, 0.02781055f, 0.00098981f, 0.00868181f, 0.02709032f, -0.02312087f, 
    -0.04076464f, -0.00072212f, -0.01467589f, -0.03396874f, 0.00766475f, -0.01501332f, 0.01023514f, 0.01207137f, 
    -0.04326611f, -0.02808125f, 0.01090925f, -0.02012749f, -0.02463573f, 0.00750400f, 0.00000768f, -0.02743935f, 
    0.04066442f, -0.01705009f, -0.02208279f, -0.03514055f, 0.02123912f, -0.02466770f, -0.00207778f, -0.01478950f, 
    -0.02651075f, 0.01021996f, -0.01731566f, 0.01962547f, 0.01676499f, -0.02329403f, -0.03850459f, -0.04138982f, 
    -0.02317392f, -0.03190020f, 0.02130619f, -0.00268433f, -0.02641555f, 0.00566408f, 0.00040877f, 0.00511338f, 
    -0.02783954f, -0.03298855f, 0.00497862f, 0.00933410f, 0.03340575f, -0.01729752f, 0.02638476f, -0.02803428f, 
    0.01038403f, -0.03366467f, -0.01858291f, -0.00651223f, 0.00149502f, 0.01757922f, -0.00761749f, -0.00430750f, 
    0.02470974f, 0.01601424f, 0.01230768f, -0.02645217f, -0.03388184f, 0.01139021f, -0.00881632f, -0.04220878f, 
    -0.01007544f, -0.03522358f, -0.03096671f, -0.02846852f, 0.01005141f, 0.01445121f, -0.03743174f, -0.03803428f, 
    -0.01361876f, -0.00155387f, -0.01431058f, -0.01368612f, 0.00773495f, -0.01548660f, 0.00166984f, -0.01855537f, 
    -0.01995973f, -0.03369099f, 0.00443972f, -0.02305252f, 0.01083567f, -0.01004201f, 0.00005033f, -0.02073894f, 
    -0.03575818f, -0.03039822f, -0.01574606f, 0.02790530f, 0.00428893f, -0.03356031f, 0.01180742f, -0.03468047f, 
    -0.03163363f, 0.00701492f, -0.00192910f, -0.00641286f, 0.01496365f, -0.03627625f, -0.01354576f, -0.02593853f, 
    -0.02896765f, -0.01099518f, 0.00361123f, -0.02696854f, 0.00607796f, -0.00296466f, -0.03925722f, -0.00950401f, 
    0.00514526f, -0.04196643f, -0.01934697f, 0.00907511f, -0.01712527f, 0.02332039f, -0.03273159f, -0.02194193f, 
    0.01656457f, -0.04093556f, 0.01087761f, 0.01269847f, 0.02342490f, -0.02650647f, -0.02779101f, 0.00282350f, 
    0.01283087f, 0.01952795f, -0.00345629f, -0.03453412f, -0.01842804f, -0.01051620f, 0.02198347f, 0.01345255f, 
    0.01693273f, -0.01856134f, 0.00893973f, -0.00476691f, 0.00322874f, -0.00559315f, 0.00305130f, 0.01615444f, 
    -0.04824432f, -0.04436802f, -0.01869372f, -0.01253427f, 0.02215510f, -0.00238650f, 0.00359759f, -0.01351196f, 
    0.02387945f, -0.00514699f, -0.02335001f, -0.02557474f, 0.02707608f, -0.03291568f, -0.02264476f, 0.01211371f, 
    -0.01389242f, -0.02672757f, -0.04044972f, 0.02684082f, -0.00155958f, 0.02587507f, -0.05029523f, -0.01287911f, 
    -0.04707287f, -0.02352645f, 0.02426387f, -0.03546282f, -0.01739137f, -0.02603586f, 0.02828688f, -0.00693826f, 
    -0.01730402f, 0.00804053f, -0.03183751f, 0.00899788f, -0.02909824f, -0.01542878f, -0.01449585f, -0.01650446f, 
    0.00892221f, 0.03545721f, 0.00620525f, -0.03683586f, -0.02840029f, -0.04603114f, -0.01719736f, 0.01788435f, 
    0.02057536f, -0.02459823f, -0.01031861f, 0.01625429f, 0.02596075f, -0.02643581f, 0.00979094f, -0.03868333f, 
    0.00014388f, 0.00782183f, -0.03465661f, -0.01765884f, 0.00175805f, -0.00590617f, -0.01867353f, -0.00603479f, 
    -0.00342803f, -0.00061896f, 0.01653213f, 0.00111126f, -0.02118588f, 0.02906410f, -0.02308798f, -0.01734268f, 
    0.01014601f, 0.01126944f, 0.01926149f, -0.02814353f, -0.00905514f, 0.02125843f, -0.02133092f, -0.03126424f, 
    -0.02313687f, 0.00480152f, 0.00913703f, 0.01942434f, 0.01242015f, -0.03005546f, -0.04348399f, 0.00257993f, 
    -0.04584283f, 0.01650329f, 0.02017448f, -0.02623279f, -0.01826824f, -0.02189623f, -0.03863524f, 0.01837466f, 
    -0.01286516f, 0.00644548f, -0.01342237f, -0.03193470f, -0.04410275f, -0.02252709f, 0.00081653f, -0.01601066f, 
    -0.02944657f, 0.01289076f, -0.00997968f, 0.00642743f, -0.01455226f, -0.03743295f, -0.04271396f, -0.03294088f, 
    -0.02576489f, -0.03200449f, -0.02307754f, 0.01806435f, -0.00982329f, 0.01408564f, -0.03744809f, -0.03735705f, 
    0.00546820f, -0.02336776f, -0.01127063f, -0.01835563f, 0.00164543f, 0.03136501f, -0.02431701f, -0.03124654f, 
    -0.03746559f, -0.01343714f, -0.02124599f, -0.04856092f, -0.00669261f, -0.01266962f, 0.00921658f, 0.01458258f, 
    -0.03774553f, 0.01485274f, -0.03374119f, -0.03076902f, 0.00632600f, 0.00600854f, -0.04651554f, -0.04021933f, 
    -0.01464978f, -0.01113857f, -0.01494074f, -0.03780634f, 0.01205871f, -0.04813661f, -0.03196244f, 0.02102761f, 
    -0.02443689f, -0.02447722f, -0.03335099f, -0.03967424f, -0.00695146f, -0.03213629f, -0.00018239f, -0.02974796f, 
    -0.04558003f, -0.02829565f, 0.02572617f, 0.01107026f, -0.02658165f, -0.03716745f, 0.00160279f, -0.02132382f, 
    -0.00310804f, -0.01846789f, 0.00264640f, -0.01662561f, 0.01711522f, -0.01079552f, 0.01857884f, 0.01607247f, 
    0.00775684f, -0.00110461f, -0.02976925f, 0.01056068f, -0.00149544f, -0.00706805f, 0.02220520f, -0.00148429f, 
    0.02463101f, -0.01566988f, 0.01007230f, 0.01758886f, -0.01588858f, -0.01464412f, -0.01841806f, 0.00918976f, 
    -0.01355576f, -0.00036677f, -0.03054186f, 0.00090123f, 0.02416447f, -0.04018235f, 0.02930524f, -0.03640734f, 
    0.00695276f, -0.02949860f, 0.02898673f, -0.00435014f, -0.03603445f, -0.02019639f, -0.04089054f, -0.00118935f, 
    0.01929888f, -0.03570865f, -0.04499471f, -0.00695166f, -0.02389742f, -0.01382502f, 0.01965857f, -0.01821107f, 
    0.00808154f, -0.03964209f, 0.01192790f, 0.01760428f, 0.02658699f, -0.02497716f, -0.03452774f, -0.03669566f, 
    -0.03425163f, 0.01342864f, 0.01513725f, -0.01898649f, -0.03932111f, -0.02010035f, -0.00760895f, -0.01622931f, 
    -0.00681904f, -0.01171671f, -0.03503328f, -0.00622313f, 0.00269172f, 0.01883663f, 0.00157512f, -0.04915520f, 
    0.09251387f, -0.02445707f, 0.02752121f, -0.24129462f, 0.02259371f, 0.16325380f, 0.01064294f, 0.05043481f, 
    -0.08549475f, 0.02909806f, 0.06727887f, -0.04425006f, 0.02108516f, -0.03491603f, 0.13479652f, 0.19330736f, 
    0.14402594f, 0.00660033f, 0.00355302f, 0.07581594f, 0.10687561f, 0.04552062f, -0.08775453f, 0.03720282f, 
    -0.32673275f, -0.12418743f, 0.00629921f, -0.06473280f, -0.01731290f, -0.06758920f, 0.04685003f, 0.07778142f, 
    0.00881221f, -0.03161072f, -0.00473804f, -0.01498655f, -0.37526292f, -0.11311086f, 0.06913994f, 0.24402505f, 
    -0.03589848f, 0.00194182f, 0.01215082f, 0.14736027f, -0.04024904f, 0.02932673f, 0.06113603f, 0.09517897f, 
    0.22638647f, -0.06732634f, 0.13862884f, 0.03609441f, -0.03961119f, 0.10829069f, 0.02864785f, 0.09634781f, 
    0.00050585f, 0.04648400f, 0.15013379f, 0.08485361f, -0.12123689f, -0.00085199f, 0.03127731f, 0.13757272f, 
    -0.01450376f, 0.09243550f, -0.01559137f, -0.03522910f, 0.11474881f, -0.02922694f, -0.01958229f, -0.11635837f, 
    0.13373105f, -0.07107447f, 0.00048104f, -0.20127361f, 0.06860722f, -0.04646549f, 0.06643665f, -0.11562477f, 
    -0.02454089f, 0.01954753f, -0.02280787f, 0.04286335f, -0.08922661f, 0.00122324f, 0.19416076f, -0.14779791f, 
    -0.02675141f, 0.05854885f, -0.01633713f, 0.02216337f, -0.00181189f, -0.03470973f, 0.00034828f, 0.09112684f, 
    -0.15344164f, 0.04196789f, -0.07345549f, 0.11369784f, 0.03008483f, 0.02024167f, -0.01256187f, 0.07255632f, 
    0.07995839f, -0.01339704f, 0.04884606f, 0.13302682f, 0.00203831f, 0.12463091f, -0.08216830f, -0.01772673f, 
    -0.04405797f, 0.02108789f, 0.08237077f, -0.05208090f, -0.00074640f, -0.11888634f, -0.04286730f, -0.01323059f, 
    -0.15239775f, -0.09446392f, 0.01988245f, -0.01600799f, 0.09099864f, 0.03178664f, 0.01649576f, 0.06464109f, 
    0.00864425f, -0.07250220f, 0.04109213f, 0.01654954f, 0.02587381f, 0.14092550f, -0.08670989f, 0.31687692f, 
    0.07404606f, 0.07063907f, 0.04743023f, -0.03682174f, 0.02623366f, 0.01017747f, -0.12538835f, 0.05002196f, 
    0.14660069f, 0.02900656f, 0.09049870f, -0.12508017f, -0.07396077f, 0.02551156f, -0.04040063f, 0.02580249f, 
    -0.04237524f, 0.02789228f, 0.13467535f, 0.01432379f, -0.30651879f, 0.17010133f, -0.06650514f, 0.24275969f, 
    0.04224355f, -0.03830016f, -0.00094140f, 0.13127255f, 0.05845939f, -0.07805515f, -0.04628242f, -0.01991859f, 
    0.08030457f, 0.17715566f, -0.17795165f, -0.04852769f, -0.00982335f, -0.04231411f, 0.06672418f, -0.07515584f, 
    0.04735335f, 0.06267773f, 0.04112319f, 0.03601737f, 0.24269269f, -0.01864791f, 0.12646703f, -0.20022805f, 
    0.02984229f, 0.06336167f, 0.11278780f, 0.02589708f, -0.03051185f, -0.05239531f, 0.03794546f, 0.01892663f, 
    -0.25345355f, 0.10175639f, -0.11091576f, 0.04720931f, 0.12077399f, -0.09748806f, -0.01205390f, -0.00922408f, 
    -0.02011365f, 0.03890330f, -0.03025094f, -0.00397395f, 0.16806342f, 0.10991956f, -0.18646920f, 0.16922255f, 
    -0.02577946f, 0.04417171f, 0.06046172f, -0.05361417f, 0.00773048f, 0.12995657f, 0.07465565f, 0.02704158f, 
    0.14632156f, -0.04116170f, -0.00106183f, 0.25664344f, 0.05865548f, 0.10615563f, 0.04507774f, -0.03176059f, 
    0.01680758f, 0.02869192f, 0.00351455f, -0.06016199f, 0.07598257f, 0.08043695f, 0.06008070f, 0.06797270f, 
    0.08797208f, 0.04967642f, 0.00024846f, -0.04061561f, -0.05014139f, -0.05804598f, 0.06279386f, -0.00928755f, 
    0.17814541f, -0.13633427f, 0.05681566f, 0.01876320f, -0.06785471f, 0.04481053f, 0.03436213f, 0.05671790f, 
    0.11445297f, -0.04852075f, -0.03398805f, -0.02461154f, -0.05231239f, -0.08205399f, 0.01635670f, 0.11911620f, 
    -0.00469708f, -0.02455830f, 0.06926083f, 0.03989587f, 0.09615041f, -0.06594639f, 0.05431525f, 0.02014844f, 
    0.08419593f, 0.04447854f, 0.07885770f, 0.01106037f, 0.05024902f, 0.01089134f, 0.08074469f, 0.03247724f, 
    0.00514725f, 0.06050156f, 0.07373606f, 0.03392659f, 0.26937386f, -0.02016328f, 0.15647705f, 0.28177670f, 
    0.13738354f, 0.12588428f, 0.05890316f, 0.04975133f, 0.00557951f, 0.06781252f, 0.02682265f, 0.12589753f, 
    0.09964579f, 0.10766418f, -0.10685385f, 0.09029635f, -0.02873480f, -0.06511728f, 0.01310344f, 0.00095860f, 
    0.00676415f, 0.04814900f, 0.02020459f, -0.02760871f, -0.17751016f, 0.18356894f, 0.05058610f, -0.04454881f, 
    -0.05391990f, 0.04978755f, 0.12506776f, 0.03786239f, -0.03597888f, 0.01789746f, 0.06830234f, 0.03222245f, 
    -0.02225682f, -0.00770933f, 0.07021108f, -0.09894855f, 0.01021638f, -0.03104005f, -0.01248495f, 0.17707768f, 
    0.01450184f, -0.14425571f, 0.08121026f, 0.07332340f, -0.09122577f, -0.01153097f, -0.00474458f, 0.02042927f, 
    -0.00689455f, -0.13386387f, 0.11823451f, 0.14944910f, 0.00857368f, -0.05446583f, 0.01602022f, 0.07526669f, 
    -0.13511313f, -0.06717116f, 0.06506210f, -0.08450501f, -0.07200021f, -0.05441558f, -0.03069307f, -0.07297217f, 
    -0.10969160f, 0.01075032f, 0.01444475f, 0.06623621f, -0.38913095f, 0.08213611f, -0.09269922f, -0.19416955f, 
    0.03108045f, 0.06415170f, 0.00417113f, 0.05917641f, -0.03694930f, -0.06875253f, -0.01439409f, 0.00087841f, 
    0.11158634f, 0.14785236f, -0.05812953f, 0.12173843f, 0.03012894f, 0.01255198f, 0.08433044f, -0.02637227f, 
    0.15443553f, 0.06409096f, 0.06117508f, 0.01550145f, -0.13135257f, -0.09245546f, -0.03436334f, -0.09863264f, 
    0.07349606f, -0.03302061f, 0.06072448f, 0.13493736f, 0.00369577f, 0.13232113f, 0.03240824f, -0.06548029f, 
    -0.09172279f, 0.07520360f, 0.02504459f, 0.21988815f, -0.10205989f, 0.00351076f, -0.05617586f, -0.02621187f, 
    -0.06218450f, 0.06921057f, 0.03827993f, -0.08515904f, 0.27120626f, 0.04624471f, 0.13892892f, 0.26234794f, 
    0.11477973f, 0.05470253f, 0.08579627f, -0.03127311f, -0.00488903f, -0.03034964f, -0.01233006f, 0.02547579f, 
    -0.09591406f, -0.01948405f, -0.02013413f, 0.10283363f, 0.06540214f, -0.09547050f, 0.05178724f, 0.03090009f, 
    0.00948749f, -0.04437241f, 0.05561582f, 0.10882361f, 0.08591398f, 0.01950909f, 0.03001763f, 0.23751083f, 
    0.02184903f, 0.16874553f, -0.09058563f, -0.02003155f, 0.08368994f, -0.05511934f, -0.01758451f, 0.06229471f, 
    0.06647442f, 0.06145243f, -0.04415984f, -0.16120493f, 0.07420217f, 0.10312495f, -0.00024889f, -0.03484466f, 
    0.11901975f, 0.18834725f, 0.02558803f, 0.12560450f, -0.38944396f, -0.05147270f, 0.00287742f, 0.09766142f, 
    0.05517700f, 0.01386167f, 0.02898320f, 0.14589326f, 0.04005007f, 0.00067125f, 0.07133918f, -0.07534041f, 
    -0.10443491f, -0.09841321f, -0.16625451f, 0.11099011f, 0.00848231f, -0.01526460f, -0.02254175f, -0.04402345f, 
    0.05273560f, 0.03570632f, -0.00580953f, 0.11039572f, 0.15607148f, 0.20379850f, -0.03806731f, 0.01676471f, 
    0.06947472f, 0.05178142f, -0.00877222f, 0.08923645f, -0.04979229f, 0.14064647f, -0.03577374f, 0.02499012f, 
    0.05850348f, 0.04606929f, 0.06796613f, 0.00532656f, 0.03047425f, 0.01139638f, 0.05624301f, 0.03279187f, 
    0.10373084f, 0.08045617f, -0.02153124f, -0.06599748f, 0.07250766f, -0.03350130f, -0.01639063f, -0.03787898f, 
    0.08852771f, -0.02554674f, 0.07772356f, 0.00328783f, 0.00668954f, -0.01818428f, 0.03680477f, 0.03401819f, 
    0.14425242f, -0.04981735f, 0.05639076f, -0.23047686f, -0.01085897f, 0.14370109f, 0.08015580f, -0.07116333f, 
    -0.01326765f, -0.05229499f, -0.08950391f, 0.01244866f, 0.19453883f, 0.06806442f, 0.12449576f, 0.04660325f, 
    -0.00142809f, 0.05752091f, 0.08298882f, -0.02458812f, -0.06242438f, -0.06129964f, -0.01051024f, -0.02467897f, 
    0.32523036f, -0.04303192f, 0.11305002f, 0.22613291f, 0.14683892f, 0.10359935f, 0.02311323f, -0.02090405f, 
    0.08620549f, 0.00422342f, -0.02648587f, 0.03155679f, -0.14978743f, -0.10171887f, 0.03924102f, -0.06569949f, 
    0.04361075f, -0.11335707f, 0.02621765f, -0.01934622f, -0.04650507f, -0.14113180f, 0.02401082f, -0.01558367f, 
    0.16444941f, -0.04031732f, -0.03188231f, 0.00566372f, 0.07933640f, 0.04861978f, 0.10837755f, 0.05718776f, 
    0.00081367f, -0.08871195f, -0.00574126f, 0.00609288f, 0.19905500f, -0.18819286f, 0.01029348f, 0.07778171f, 
    0.04293604f, 0.04754980f, 0.01324253f, 0.08002174f, 0.00425594f, 0.06915380f, 0.04535261f, 0.01166542f, 
    0.01972652f, 0.08294308f, 0.02853866f, -0.12538132f, -0.08891555f, 0.10951605f, 0.01570021f, 0.11306935f, 
    -0.00901345f, 0.00362917f, -0.02505439f, -0.12780306f, -0.09112258f, -0.03501653f, 0.06058742f, -0.00672319f, 
    0.03344887f, -0.09495476f, 0.09650370f, 0.06449737f, 0.07810595f, 0.06471208f, -0.03718168f, -0.01825182f, 
    0.37171522f, 0.00380560f, -0.08516575f, 0.00629721f, -0.03753879f, -0.02158441f, 0.12082491f, -0.05484445f, 
    0.04902558f, -0.00953549f, -0.02530395f, -0.05737265f, 0.14704254f, -0.03962812f, 0.09588409f, 0.09981357f, 
    0.02286554f, -0.09644788f, -0.00313173f, 0.01088501f, -0.11486799f, 0.02809654f, 0.05228322f, 0.03726090f, 
    -0.15610702f, -0.07577445f, 0.13850935f, 0.03375672f, 0.05210945f, 0.03356982f, -0.02719312f, 0.04317281f, 
    0.04756099f, 0.00421610f, 0.05703036f, 0.03040605f, 0.31592989f, 0.06759531f, 0.05747382f, 0.30919796f, 
    0.08987716f, 0.13287808f, -0.00004222f, 0.01165152f, 0.06808598f, 0.02196261f, -0.05854901f, 0.07819650f, 
    0.16925479f, 0.10652977f, -0.00600628f, 0.10958830f, 0.13055585f, 0.09526296f, 0.03084591f, 0.00536637f, 
    0.02088671f, -0.01235013f, 0.10070168f, -0.08319578f, -0.00410961f, -0.20384403f, -0.01889250f, 0.12142853f, 
    0.07813777f, -0.06590956f, -0.01385737f, -0.00179909f, 0.07153838f, 0.02965022f, 0.13664146f, 0.06544009f, 
    0.01716449f, 0.05396161f, -0.07325478f, 0.03582061f, -0.07623793f, 0.08031835f, 0.08955009f, 0.05401399f, 
    -0.03427974f, -0.00308611f, -0.00227778f, 0.02190515f, -0.10808182f, 0.03582565f, -0.00722746f, -0.03781822f, 
    0.03237734f, -0.08124986f, 0.16136733f, 0.05216576f, -0.09703448f, 0.00803416f, 0.05250613f, 0.02601189f, 
    -0.04259975f, 0.07272138f, -0.15307249f, -0.17057258f, 0.13598914f, 0.03206472f, 0.05665956f, -0.05777823f, 
    -0.00967727f, -0.01322212f, 0.15202816f, 0.03533870f, 0.02200565f, 0.00263347f, -0.01724823f, 0.22476532f, 
    0.02408515f, 0.03736447f, 0.00063835f, -0.08185858f, -0.01723774f, 0.05072730f, 0.13930254f, 0.07194034f, 
    -0.20582984f, 0.08107952f, 0.00745982f, 0.35070404f, 0.03014581f, 0.00567547f, 0.00323549f, 0.02983071f, 
    -0.02751341f, 0.10673580f, -0.02138602f, 0.03595492f, -0.03932268f, -0.07231637f, 0.04283389f, 0.21100430f, 
    0.01823757f, 0.09578584f, 0.00120679f, 0.02774648f, -0.00226552f, 0.00549259f, -0.01691837f, 0.04865264f, 
    0.11130391f, -0.00592482f, -0.13165055f, 0.00385223f, -0.02585195f, -0.01082082f, 0.14667530f, -0.08104634f, 
    0.02934947f, 0.12836373f, 0.08720667f, 0.03274142f, -0.18379942f, -0.15631005f, -0.13163520f, -0.23979574f, 
    -0.13511896f, 0.09613039f, -0.11510456f, 0.07964889f, 0.02093524f, -0.02172868f, 0.08640976f, 0.01955910f, 
    -0.03601129f, -0.01060132f, -0.02980658f, 0.01910636f, 0.00321302f, -0.03778519f, -0.03267990f, -0.04205371f, 
    0.01943746f, -0.00349494f, 0.01210355f, -0.00897439f, -0.02366671f, 0.02429421f, -0.03588884f, 0.00551381f, 
    -0.01317741f, 0.02070439f, 0.01085936f, 0.02227634f, -0.00187480f, 0.00176827f, 0.02801521f, 0.02250901f, 
    0.02567024f, 0.02787690f, -0.00578665f, -0.01789109f, 0.01623015f, -0.03402346f, -0.03218485f, -0.03091662f, 
    -0.02286510f, 0.02566262f, 0.01928518f, 0.00099755f, -0.03757333f, -0.02680654f, -0.01482161f, -0.01381859f, 
    -0.01120664f, -0.02832716f, -0.02253132f, -0.02046205f, 0.00781633f, -0.00098844f, -0.03788729f, -0.03103814f, 
    0.01116401f, -0.02374343f, 0.00447137f, 0.02268844f, -0.00832754f, -0.00227200f, -0.00290206f, -0.01783839f, 
    0.00424141f, 0.00934552f, 0.01819899f, -0.01777649f, 0.02523292f, 0.00128867f, 0.02298095f, 0.02865257f, 
    0.01048235f, -0.01724336f, -0.02835852f, -0.00802210f, 0.01909602f, 0.01909909f, 0.01466701f, -0.03740241f, 
    0.01936443f, 0.01822366f, -0.00145566f, -0.01146160f, 0.01555821f, 0.00850945f, -0.01230038f, -0.01241819f, 
    0.01160917f, -0.02990866f, -0.00655876f, 0.00873818f, 0.00588103f, 0.01629499f, -0.01050333f, 0.01100449f, 
    -0.00402766f, -0.02099646f, -0.00310006f, -0.00408406f, -0.03235164f, -0.00050611f, -0.00667820f, -0.01430734f, 
    -0.01729777f, 0.01084650f, -0.04005450f, -0.00090406f, -0.03843213f, 0.01988291f, -0.03127810f, -0.01309529f, 
    0.01140533f, -0.01211803f, 0.00832956f, -0.02974004f, 0.02965098f, 0.00791297f, 0.00264610f, -0.00531464f, 
    -0.02332667f, -0.02916215f, -0.03917631f, -0.00086704f, -0.01430870f, 0.00320459f, -0.02241584f, -0.01868646f, 
    -0.00941452f, 0.01532051f, -0.03983877f, -0.02489652f, -0.02235485f, -0.01020915f, -0.03194119f, -0.00314867f, 
    0.01728887f, 0.00545006f, 0.00620038f, 0.00140586f, -0.00366592f, -0.04173128f, -0.00084287f, -0.02392432f, 
    -0.00114338f, 0.01708337f, 0.00889036f, -0.03554592f, -0.02818507f, 0.00356245f, 0.01560264f, -0.03773817f, 
    0.02429834f, 0.02293253f, 0.02280759f, -0.00525462f, -0.00033893f, -0.04092944f, 0.02050960f, 0.00130868f, 
    -0.00457370f, -0.02049403f, -0.02256992f, 0.00896626f, -0.01582173f, -0.02641922f, -0.03666599f, 0.00484638f, 
    -0.03585977f, -0.02778775f, -0.03992761f, -0.01337320f, 0.02976561f, 0.00066990f, 0.01222449f, -0.01299239f, 
    0.02346306f, -0.01012978f, 0.00295814f, -0.00926525f, -0.04082275f, 0.00354879f, -0.03230918f, 0.02076920f, 
    0.00655144f, 0.02015887f, -0.02749576f, 0.01120849f, -0.02125266f, 0.00636277f, 0.01324216f, 0.00868363f, 
    0.02331222f, 0.02174573f, 0.01954767f, -0.00807528f, 0.00426835f, 0.00968379f, 0.02635220f, 0.03000103f, 
    0.00770697f, 0.02190462f, 0.02500926f, -0.00459707f, 0.00005264f, -0.01738859f, -0.00345815f, -0.03742588f, 
    -0.01035088f, -0.00687010f, -0.00224150f, -0.00609536f, 0.00933261f, 0.00873369f, -0.00958042f, -0.02390625f, 
    0.01046067f, 0.00543254f, 0.02729901f, 0.00884769f, 0.00101932f, -0.00747362f, -0.03923296f, -0.02682296f, 
    -0.02220840f, -0.01384621f, 0.00629178f, 0.00347655f, -0.01266881f, -0.03029805f, 0.01370922f, -0.02897127f, 
    -0.03902931f, 0.02140262f, -0.01246808f, -0.02583200f, 0.02682547f, -0.03837788f, -0.03284276f, -0.03802944f, 
    -0.02876779f, -0.00323894f, -0.03437590f, 0.00035721f, -0.03252970f, -0.00504926f, -0.02722096f, -0.01111230f, 
    0.00116148f, -0.01274868f, 0.01788856f, -0.02665546f, -0.00433475f, 0.01569345f, -0.01457984f, 0.02623926f, 
    -0.01961158f, -0.02661020f, 0.01969215f, -0.03551252f, -0.02120222f, -0.02232878f, 0.01335639f, 0.00442664f, 
    0.01595088f, 0.01206703f, -0.00623359f, -0.04163386f, 0.00048610f, -0.02885368f, 0.01103474f, 0.01553049f, 
    -0.03819473f, -0.02734761f, -0.04140673f, -0.04188371f, 0.02353069f, 0.02082138f, 0.01674791f, -0.01087781f, 
    -0.03129388f, 0.01972200f, -0.03736557f, -0.01791430f, -0.00160118f, -0.01097862f, -0.03218832f, 0.01811380f, 
    0.01176667f, 0.01615556f, 0.00040583f, -0.01044257f, -0.02451227f, -0.00915074f, -0.04065620f, 0.02135960f, 
    -0.00880740f, -0.02545208f, -0.00776626f, -0.01764651f, -0.00865104f, 0.01724732f, 0.02512907f, 0.01555373f, 
    -0.01351719f, 0.00330449f, 0.00954635f, -0.00894345f, 0.01970103f, 0.01669961f, -0.04121874f, 0.01962747f, 
    -0.00315353f, -0.01574879f, -0.01487277f, 0.02982499f, -0.02451712f, 0.01446007f, 0.02011360f, -0.03357336f, 
    0.00206108f, -0.02883404f, -0.01437181f, 0.02717802f, 0.01475513f, -0.01757255f, -0.01611000f, -0.00495788f, 
    0.00868226f, -0.01381823f, 0.01577375f, -0.03173415f, -0.03366500f, 0.00646597f, -0.01382350f, -0.04189333f, 
    -0.02402232f, 0.01190830f, -0.03017300f, -0.02576430f, -0.03192604f, 0.00446015f, 0.00392339f, -0.02175011f, 
    0.00998323f, -0.03862413f, -0.01470665f, 0.00533609f, -0.03288935f, -0.00770913f, -0.02356922f, 0.02186947f, 
    -0.03889685f, -0.00712439f, -0.00835879f, -0.00664540f, -0.01780762f, 0.00043858f, -0.00571465f, -0.03838091f, 
    -0.01234176f, -0.01618716f, -0.00243547f, 0.00450206f, -0.03942244f, 0.01915187f, -0.02126433f, -0.03158872f, 
    0.01190316f, 0.02043855f, 0.00168930f, -0.02771867f, -0.02959460f, -0.03140905f, -0.01626593f, 0.00811553f, 
    -0.00337502f, -0.02337869f, -0.03465003f, 0.01655655f, 0.01676714f, -0.01921532f, 0.01703086f, -0.02382938f, 
    -0.03024070f, 0.01402805f, 0.01438536f, -0.02869457f, -0.02623942f, 0.00293610f, -0.02364241f, -0.03198320f, 
    -0.00453284f, -0.03632518f, -0.00978185f, -0.03401456f, 0.02372065f, 0.00180651f, -0.01126548f, -0.02290356f, 
    -0.01581224f, 0.00534125f, -0.02076099f, -0.03593770f, -0.02994135f, 0.01487685f, -0.03191077f, -0.02615758f, 
    -0.03874538f, -0.02546224f, 0.00264745f, -0.02589434f, 0.00217135f, -0.03339531f, 0.00009477f, 0.02361782f, 
    -0.02247918f, -0.03095668f, 0.01741642f, 0.02314550f, -0.01740898f, 0.01138792f, -0.03741133f, 0.00160989f, 
    0.00079167f, 0.00918137f, 0.02817635f, 0.01463792f, -0.02145649f, 0.01703848f, 0.01223725f, -0.03443715f, 
    -0.03123264f, -0.03283769f, -0.01696463f, 0.01816068f, 0.02898693f, -0.02427661f, 0.00636053f, -0.00259795f, 
    -0.03158319f, -0.03391754f, 0.00406825f, -0.03716662f, 0.02897890f, -0.01448152f, -0.01242261f, -0.02960895f, 
    -0.01358350f, -0.02496670f, -0.01864372f, 0.01975848f, -0.00839186f, 0.02590908f, 0.02127709f, -0.01141996f, 
    0.01939844f, 0.00180746f, -0.01975714f, -0.00621706f, -0.02782288f, -0.00958035f, 0.01339025f, -0.02190981f, 
    0.01153718f, -0.02437422f, -0.02515975f, 0.01452413f, -0.03817948f, 0.01512601f, -0.02768187f, -0.02186123f, 
    -0.01862796f, -0.01032834f, 0.02596382f, -0.00538519f, -0.02553256f, 0.01120403f, 0.00408369f, -0.01103543f, 
    0.00296050f, -0.00617063f, -0.01107407f, 0.00595018f, 0.00368307f, -0.01875613f, -0.00550438f, -0.03086703f, 
    0.00863231f, -0.01150186f, -0.01976686f, 0.00942632f, -0.00367650f, 0.01629745f, -0.01477323f, 0.01738885f, 
    -0.02023795f, 0.00917721f, -0.00553337f, -0.00947962f, 0.02962686f, 0.01190260f, 0.02223165f, -0.02996531f, 
    -0.02754506f, -0.00860184f, -0.03431069f, -0.01374468f, 0.02308798f, -0.02406777f, 0.00765796f, -0.03121752f, 
    -0.02455397f, 0.01525586f, -0.03115760f, 0.01432922f, -0.03151643f, 0.01893837f, 0.01712214f, 0.02952461f, 
    -0.03595785f, 0.01834261f, 0.02932588f, -0.01962540f, -0.01104523f, 0.02916394f, -0.02826055f, 0.00794866f, 
    -0.01297389f, 0.00686010f, -0.03038920f, -0.00687507f, 0.01729115f, 0.02871880f, 0.00237336f, -0.04034556f, 
    -0.02128511f, -0.04160444f, -0.00035299f, -0.01632507f, -0.02414897f, -0.02829706f, -0.01017930f, -0.02977246f, 
    0.02133733f, 0.02712162f, 0.00796150f, -0.01904408f, 0.02233076f, -0.03766576f, -0.01202661f, 0.02893259f, 
    -0.00085544f, 0.02385826f, -0.00836236f, -0.02091568f, -0.03038693f, -0.02637266f, -0.01836223f, -0.01119607f, 
    -0.01037831f, -0.03308474f, -0.01480520f, -0.01614258f, 0.01266513f, -0.01725473f, 0.01583869f, 0.01620733f, 
    0.01112143f, -0.01348372f, -0.00045894f, 0.01037742f, 0.00983293f, -0.00304150f, -0.01411329f, 0.01977593f, 
    -0.03587515f, -0.01221595f, -0.01917793f, 0.00419759f, 0.00249612f, 0.02912257f, -0.00618181f, -0.02955095f, 
    0.00893266f, -0.02205546f, 0.02885954f, 0.00803448f, -0.03576839f, 0.02469923f, -0.00512632f, -0.01144922f, 
    -0.01133993f, 0.01204836f, -0.03867231f, -0.02771535f, -0.03370948f, 0.01430896f, -0.04020981f, 0.02441145f, 
    0.02318048f, -0.02580842f, 0.00256881f, -0.01455413f, 0.00876957f, -0.02452731f, -0.03158383f, -0.03184932f, 
    -0.01735085f, -0.04018032f, -0.00552302f, -0.00501952f, 0.02354134f, -0.02073824f, -0.02089359f, -0.00123741f, 
    -0.02031220f, -0.00434344f, -0.02290907f, -0.02563407f, -0.04162801f, -0.02376171f, 0.02624936f, -0.03632999f, 
    0.00942074f, -0.02766536f, -0.02444966f, -0.02665728f, -0.03097436f, 0.01057224f, 0.00052126f, 0.02935371f, 
    -0.02090571f, -0.02296324f, 0.02523504f, -0.00359640f, -0.01772695f, 0.02953832f, 0.01800215f, -0.03496706f, 
    0.00840345f, -0.00487487f, -0.00727322f, 0.02180365f, 0.01802076f, -0.00795969f, 0.00701973f, -0.01060913f, 
    -0.01682744f, 0.02246230f, -0.01420223f, 0.02992567f, 0.02238887f, -0.00065240f, -0.01639627f, -0.00036930f, 
    0.00337060f, 0.01767387f, -0.01395172f, 0.01095236f, 0.00599922f, 0.01405555f, -0.03540931f, 0.02393513f, 
    0.02305551f, -0.01890900f, 0.01011973f, -0.02829629f, -0.00695722f, -0.01667988f, 0.02183052f, -0.02341969f, 
    0.02467878f, -0.01198413f, 0.01181823f, 0.01859912f, 0.02520715f, 0.00208340f, -0.01717541f, 0.02228446f, 
    -0.00321236f, 0.01305276f, -0.01352023f, -0.02160945f, -0.03019399f, -0.01061038f, -0.03158905f, 0.01388123f, 
    -0.00206724f, -0.01046042f, -0.00230549f, -0.03836736f, -0.03852591f, -0.02595515f, -0.02691391f, -0.04033865f, 
    0.02490261f, -0.00035199f, -0.00193697f, 0.01499819f, -0.00963445f, 0.02183087f, 0.01882711f, -0.02535632f, 
    0.02263782f, -0.03900732f, -0.02095364f, -0.00455345f, 0.00300379f, -0.03077782f, -0.03037922f, -0.02655974f, 
    -0.02746288f, 0.02878233f, -0.00246128f, 0.01003261f, -0.04088499f, -0.00316931f, 0.02731380f, -0.03321422f, 
    0.00483724f, 0.02323911f, -0.02947857f, -0.03691597f, 0.01381773f, -0.01654623f, 0.01218179f, 0.01789617f, 
    -0.00493391f, -0.03691498f, 0.02676980f, 0.00262139f, 0.02948051f, 0.00919433f, -0.01624938f, 0.02264939f, 
    -0.01400147f, -0.02084232f, 0.00760419f, -0.02832796f, 0.00636206f, 0.00068132f, 0.02359383f, 0.02992728f, 
    -0.03783980f, -0.02358416f, -0.01271566f, 0.01349719f, 0.01262119f, 0.02195821f, -0.02065761f, -0.00327369f, 
    0.02409000f, -0.00587327f, -0.04100922f, -0.02199673f, 0.01022309f, -0.01391524f, -0.02067685f, -0.01700901f, 
    -0.03649123f, 0.00574918f, -0.01002695f, -0.00954319f, 0.01765942f, 0.01902422f, -0.04132565f, -0.01632812f, 
    0.00373214f, -0.04177309f, 0.02040969f, -0.03078688f, -0.02113931f, -0.01037447f, 0.03400142f, -0.00636405f, 
    -0.00324069f, -0.00916953f, 0.22436015f, -0.16865140f, 0.04634335f, 0.04196971f, 0.09288364f, 0.12222995f, 
    -0.00858161f, 0.00734302f, 0.02037948f, 0.02319346f, -0.06325714f, -0.00437998f, -0.01117776f, -0.16341347f, 
    -0.01897936f, 0.00507793f, 0.03656679f, 0.01353391f, 0.06261403f, -0.00185526f, -0.06914707f, 0.08700637f, 
    0.14085399f, -0.10473815f, 0.05842260f, 0.04555878f, -0.02689554f, -0.06145351f, 0.05361267f, 0.03944661f, 
    -0.08445454f, -0.09050415f, -0.00684014f, -0.01137135f, -0.22545560f, 0.02061736f, -0.01883659f, 0.20524397f, 
    0.01150970f, 0.03815766f, -0.06218919f, 0.00709945f, -0.05331521f, 0.07339781f, 0.03849956f, 0.03625360f, 
    -0.30930597f, -0.07350932f, 0.02839620f, 0.10531477f, -0.01034416f, 0.12754136f, 0.04109910f, 0.08977471f, 
    0.07012334f, -0.00523608f, 0.11840473f, -0.00197644f, -0.23285085f, -0.00103999f, 0.02951875f, -0.05029236f, 
    -0.04420722f, 0.12072501f, -0.02583940f, -0.03406733f, -0.01943929f, 0.03598006f, 0.06918018f, -0.08538914f, 
    0.14544517f, 0.14624389f, 0.22048582f, -0.06585892f, 0.05595873f, 0.03361573f, 0.10742332f, -0.04430614f, 
    0.03215822f, 0.03428213f, -0.03189855f, -0.00195228f, -0.20909607f, 0.09066087f, 0.13674428f, -0.22590998f, 
    0.01402360f, -0.02818133f, 0.05603311f, 0.07014114f, 0.01011956f, -0.04760796f, -0.00949726f, -0.00399216f, 
    -0.14009005f, 0.12415838f, -0.05376607f, -0.14799154f, -0.01416552f, -0.05417250f, -0.02247800f, -0.11738791f, 
    -0.04495427f, -0.05562312f, 0.04185202f, 0.16634452f, -0.07473973f, -0.05244975f, 0.14863554f, -0.04264247f, 
    -0.09356769f, -0.04108061f, 0.09457464f, -0.03328043f, -0.06308626f, -0.05198763f, -0.08208872f, 0.00698635f, 
    -0.22583060f, 0.00229953f, -0.03830222f, -0.03332622f, -0.00913912f, 0.02811898f, 0.04636927f, -0.03024073f, 
    -0.01165163f, 0.01429638f, 0.02117690f, -0.01944738f, -0.06912827f, -0.17083484f, 0.24645975f, 0.15853193f, 
    -0.03537624f, 0.01318069f, 0.04189977f, 0.07927641f, -0.03270531f, 0.04396769f, -0.06739970f, 0.04039182f, 
    0.01200262f, -0.09241832f, 0.07938011f, 0.07130191f, 0.11244544f, 0.09949990f, -0.06725600f, 0.06344987f, 
    0.00735062f, 0.03257405f, 0.04203774f, 0.04379988f, -0.27435845f, 0.07013258f, -0.11051197f, 0.02101545f, 
    0.02391118f, -0.05640730f, 0.03493236f, 0.03662916f, 0.00915773f, -0.06612185f, -0.01475543f, -0.04208010f, 
    0.15226519f, 0.12268559f, 0.03428153f, 0.16403794f, 0.00624879f, 0.17255439f, 0.00802680f, -0.06736562f, 
    0.02321475f, 0.00997642f, 0.09799297f, 0.00761866f, -0.23036233f, -0.03335646f, 0.03723872f, 0.08025147f, 
    0.03577638f, 0.02482566f, 0.00140675f, 0.09932759f, 0.08042537f, 0.03259593f, -0.02890788f, 0.05911938f, 
    -0.15119679f, 0.18184876f, -0.01242131f, -0.15648626f, 0.14658053f, -0.01894306f, -0.02305233f, -0.06114457f, 
    -0.13302220f, 0.09616030f, -0.03058521f, -0.15093510f, 0.04241670f, 0.00489631f, 0.03441249f, 0.37508479f, 
    -0.04747856f, -0.06569622f, 0.06635199f, -0.08091808f, 0.03906837f, -0.01019990f, 0.07678587f, -0.06382254f, 
    -0.03967949f, 0.00525436f, -0.04652074f, -0.05942847f, 0.06059596f, 0.00728517f, 0.04696621f, -0.01638878f, 
    -0.03969213f, 0.00613118f, -0.00119909f, -0.05178286f, -0.15310527f, 0.07252361f, 0.04361349f, -0.13079460f, 
    0.03412435f, 0.01108204f, 0.02248011f, 0.03053182f, -0.03533540f, 0.05881249f, 0.02799665f, -0.08849569f, 
    0.04660291f, -0.04313752f, 0.01004263f, 0.11380883f, 0.00411123f, 0.11601663f, -0.02394054f, -0.05316368f, 
    0.03166547f, -0.07244648f, 0.04975955f, -0.06087584f, 0.23456143f, -0.00333102f, -0.12190000f, 0.26032582f, 
    0.00739596f, 0.00250503f, -0.05658772f, 0.01592597f, 0.10536026f, 0.02888576f, -0.02248740f, 0.01332137f, 
    -0.11785787f, 0.04442312f, 0.00477855f, -0.30199364f, 0.02262775f, -0.00859100f, 0.05397438f, 0.01990206f, 
    -0.00467048f, 0.02041824f, 0.05317986f, 0.08330046f, -0.12878895f, 0.12020198f, 0.01616007f, -0.08064120f, 
    0.07794520f, 0.08732983f, 0.08186010f, 0.09669159f, -0.06371839f, 0.03895646f, 0.05286369f, 0.05229319f, 
    -0.03343956f, 0.14768407f, -0.07753362f, 0.24405509f, 0.06915285f, 0.06481940f, -0.02478273f, 0.05020837f, 
    0.11249538f, 0.03211132f, -0.02615520f, 0.02483300f, -0.14532210f, 0.05861344f, 0.00403252f, -0.28500411f, 
    -0.03986154f, -0.02093294f, 0.01541046f, -0.00300351f, -0.08745359f, -0.01043347f, 0.08173932f, 0.00515627f, 
    0.12531453f, -0.01551090f, 0.13082048f, 0.11890688f, 0.07000171f, -0.00130479f, 0.01911717f, 0.01798230f, 
    -0.07343358f, -0.02572168f, 0.09709369f, 0.10695565f, 0.07719306f, -0.00731813f, -0.10902807f, 0.14724793f, 
    -0.05072453f, -0.05068299f, 0.10448740f, 0.05291671f, 0.07926628f, 0.02439748f, -0.04288093f, -0.02309433f, 
    0.02753625f, -0.11909219f, -0.10252336f, -0.04835662f, -0.05253391f, -0.05736772f, -0.00380975f, -0.02378145f, 
    -0.05315720f, 0.01185100f, -0.00059671f, 0.10957577f, -0.17524615f, 0.08763418f, -0.02389843f, -0.16520141f, 
    0.09397956f, 0.05904233f, 0.05496308f, -0.02130104f, -0.03677624f, 0.01922758f, 0.00591658f, -0.01000453f, 
    -0.05955511f, 0.08835558f, 0.13801952f, 0.00472475f, 0.00625115f, -0.02177417f, 0.06314283f, 0.00535818f, 
    0.05222568f, 0.00084488f, 0.02338824f, 0.10457028f, -0.16205022f, 0.14542669f, 0.10266245f, -0.09521662f, 
    0.08327446f, 0.07921518f, 0.01124246f, 0.05426462f, -0.00524409f, 0.08582696f, -0.00745788f, -0.09118237f, 
    -0.08564653f, -0.10555819f, 0.04156144f, 0.18777904f, -0.11171293f, 0.04771492f, -0.04113423f, -0.09820866f, 
    0.06384345f, 0.02185432f, -0.03233939f, -0.11050360f, -0.04013170f, -0.01039185f, -0.05743606f, -0.11571448f, 
    -0.05183623f, -0.00362981f, 0.04470850f, -0.01520074f, 0.00568347f, -0.10490768f, 0.03642592f, 0.05035247f, 
    0.00557962f, 0.05568076f, 0.02849175f, 0.18760063f, -0.01976048f, -0.05948782f, -0.03218444f, 0.03917645f, 
    0.01373386f, -0.11702155f, -0.01472911f, 0.09665605f, 0.04855821f, 0.02100901f, -0.02748309f, -0.02668035f, 
    -0.04038338f, 0.09307767f, -0.04727451f, 0.03225727f, 0.01464053f, 0.02757220f, 0.00506145f, 0.09657281f, 
    -0.10043837f, 0.07866393f, 0.25112671f, -0.06627558f, 0.07946073f, -0.03386059f, 0.10006744f, 0.04877422f, 
    0.09190591f, 0.13146757f, -0.09622918f, 0.13419624f, -0.30655384f, -0.04597503f, -0.02874997f, 0.05780777f, 
    0.03839720f, -0.00609315f, -0.00980343f, -0.03367464f, 0.04691267f, -0.06737833f, 0.04313720f, 0.01251191f, 
    0.15801479f, 0.00553066f, -0.12441942f, 0.17515299f, 0.04110803f, 0.03285456f, -0.04080241f, -0.14770533f, 
    0.03235232f, 0.06117782f, -0.01802347f, -0.01002557f, -0.23213853f, 0.15066077f, -0.08397425f, -0.09255190f, 
    0.03284825f, 0.04058559f, -0.00406374f, 0.10840704f, 0.00435287f, 0.08537722f, -0.08348449f, 0.06655417f, 
    -0.00313491f, -0.05955999f, 0.01800825f, -0.20463221f, 0.06025926f, -0.01114222f, -0.00996658f, 0.20250116f, 
    -0.02029677f, -0.01216710f, 0.02906722f, 0.06643160f, -0.20565213f, -0.05026606f, -0.10841263f, -0.09107376f, 
    0.03483953f, -0.01169991f, -0.01395026f, -0.01756528f, -0.03676219f, -0.07404109f, -0.01376634f, 0.00560011f, 
    0.16930124f, -0.03524757f, -0.14961068f, 0.10889250f, 0.02794316f, 0.09224252f, -0.00923507f, -0.01611531f, 
    -0.05669592f, -0.02541472f, -0.01039315f, -0.03019829f, -0.18036470f, -0.01455313f, 0.09946756f, -0.12220802f, 
    -0.08868705f, 0.01747058f, 0.03264530f, -0.00836069f, -0.03049409f, -0.08598217f, -0.04147710f, 0.05539145f, 
    -0.04717181f, 0.02316052f, -0.00528155f, -0.13782726f, -0.04315994f, -0.00450018f, 0.00533363f, -0.00677722f, 
    0.06317456f, -0.07559795f, -0.00971887f, -0.00880644f, -0.07387088f, 0.19976968f, 0.11013503f, 0.06797734f, 
    0.07302517f, -0.08285300f, -0.02655573f, -0.02921597f, 0.00112547f, -0.04486701f, 0.13324003f, -0.11739517f, 
    0.00531106f, -0.05636666f, 0.00283184f, 0.07660975f, 0.02731673f, 0.02575443f, 0.02803893f, 0.11121622f, 
    0.14286280f, -0.11405618f, -0.09208571f, -0.09910683f, -0.19432105f, -0.02209047f, -0.09222952f, -0.01770400f, 
    0.04435527f, 0.02061008f, 0.02177946f, -0.01838383f, 0.05159212f, 0.01583037f, 0.00286972f, 0.04991909f, 
    -0.27100965f, 0.06006689f, 0.07211142f, 0.06021671f, 0.02228006f, 0.00169405f, -0.08452097f, 0.09182670f, 
    0.10246679f, -0.01206528f, -0.01058830f, -0.05063411f, 0.08879641f, -0.08698305f, -0.06025330f, 0.10814893f, 
    -0.06933639f, 0.01073569f, 0.09649522f, -0.02926994f, 0.04161617f, -0.00829734f, -0.00833973f, 0.00281804f, 
    -0.05449113f, 0.06517274f, -0.07112807f, -0.03538407f, 0.04059212f, 0.02656816f, 0.03174812f, -0.02463132f, 
    -0.03802398f, 0.04106383f, 0.07176749f, -0.03420435f, -0.01255370f, 0.15951730f, 0.00745691f, 0.08912164f, 
    0.02122901f, 0.00086010f, 0.07697379f, -0.12590985f, -0.04969750f, 0.02624128f, 0.04256869f, 0.03543049f, 
    -0.08054109f, 0.08779674f, 0.12191036f, 0.09667359f, 0.02190112f, -0.03314549f, 0.05204944f, 0.09693268f, 
    0.09341989f, 0.01044284f, 0.07550599f, 0.06910910f, -0.01568164f, 0.05643858f, -0.05801644f, -0.18681602f, 
    -0.01140486f, 0.00048256f, 0.04672780f, 0.06597203f, 0.07627256f, 0.03582881f, -0.05618351f, 0.11007313f, 
    0.04470541f, -0.03772272f, 0.03781781f, -0.13731399f, 0.02965259f, 0.04016267f, 0.02148681f, -0.02687835f, 
    0.05528619f, 0.00831289f, 0.05702066f, -0.05103232f, -0.09807831f, -0.10125287f, -0.12974331f, 0.32787627f, 
    -0.04924463f, 0.00566345f, 0.04142473f, 0.04377078f, 0.11626060f, 0.01750362f, 0.00585553f, 0.04330757f, 
    0.08136512f, -0.01203587f, 0.14102608f, 0.14486331f, -0.01684735f, 0.03053954f, 0.06908236f, 0.00002050f, 
    -0.04003049f, -0.04714599f, 0.03264210f, 0.04860068f, -0.12394199f, -0.03493454f, 0.19366789f, 0.19866242f, 
    0.02170143f, -0.08338191f, -0.00320557f, -0.00825877f, 0.09510119f, 0.01152902f, -0.09380776f, 0.08366264f, 
    0.09579877f, 0.12210660f, 0.10261399f, 0.31582436f, -0.00723777f, -0.02747007f, 0.15191142f, -0.01248367f, 
    -0.03688994f, 0.01751545f, -0.03363881f, 0.18230693f, 0.06004414f, 0.08947061f, 0.07921377f, 0.12132606f, 
    -0.01607016f, -0.03238478f, 0.02935006f, -0.02497620f, -0.01696853f, 0.03179551f, 0.08416326f, 0.09698571f, 
    -0.16026214f, 0.16329788f, -0.02188035f, 0.05197974f, 0.07748231f, 0.09631814f, -0.03968339f, -0.11088565f, 
    0.11743723f, 0.07187183f, -0.03172077f, -0.08931427f, 0.02623776f, -0.00576803f, -0.01434952f, 0.29899970f, 
    0.00559663f, 0.04817908f, -0.04698567f, 0.02002730f, -0.08146296f, 0.01203591f, -0.06934901f, 0.07253207f, 
    -0.04908859f, 0.02783921f, -0.05590828f, 0.15448366f, -0.11450528f, -0.00907850f, 0.15952832f, -0.03793836f, 
    -0.02552999f, 0.09958836f, 0.09378288f, 0.00386687f, 0.22118916f, -0.03467514f, -0.08582986f, -0.08478663f, 
    -0.00608930f, 0.06061552f, -0.02091124f, 0.08585445f, -0.02919874f, -0.06613451f, 0.02809500f, -0.08045015f, 
    0.37121671f, -0.15094234f, -0.09898791f, -0.11566834f, 0.03838088f, -0.00086599f, -0.07052667f, -0.01706685f, 
    0.05363635f, 0.02910003f, -0.06209831f, -0.05029712f, 0.15578078f, 0.11586373f, -0.11309746f, -0.06162394f, 
    0.11175896f, -0.10021985f, 0.08609424f, 0.02776506f, 0.02164141f, 0.00859757f, -0.11610427f, -0.00524445f, 
    -0.05065969f, -0.15893084f, -0.16527665f, -0.15115817f, 0.04067887f, -0.09264650f, -0.00587081f, -0.01995588f, 
    -0.01634302f, -0.00837296f, -0.09485915f, 0.01759720f, -0.12907192f, 0.15678772f, 0.18018742f, 0.23307891f, 
    0.15647522f, 0.04101780f, -0.00111841f, 0.07429595f, -0.04979748f, 0.09436502f, 0.12979245f, 0.07400040f, 
    0.01088330f, 0.25846899f, 0.09347118f, 0.06640675f, 0.06325731f, -0.01500914f, 0.16997725f, 0.05554351f, 
    0.12903887f, 0.07542197f, 0.20835820f, 0.08415443f, -0.15878397f, -0.01322569f, 0.26612934f, 0.10178415f, 
    0.08513383f, 0.12921374f, 0.02017294f, 0.01761285f, -0.05642650f, -0.08059929f, 0.02884952f, 0.02944502f, 
    -0.23140566f, -0.29887539f, 0.07874846f, -0.09382035f, -0.05070870f, -0.07121703f, -0.04062853f, -0.11286912f, 
    -0.00396847f, -0.04346431f, -0.01085185f, 0.01564613f, -0.04041751f, 0.14181183f, 0.08637181f, -0.02247826f, 
    0.01896027f, -0.05341727f, 0.03590470f, -0.04462249f, 0.10643417f, -0.03583940f, -0.03700409f, 0.04305037f, 
    -0.17692176f, 0.20644028f, 0.08415007f, 0.01154162f, 0.06456859f, 0.03523287f, 0.05682645f, 0.05255824f, 
    0.01103393f, 0.02972124f, 0.13093263f, 0.17434715f, 0.28347328f, -0.19965106f, 0.00250811f, 0.02925438f, 
    -0.04647952f, -0.04695968f, -0.01935668f, -0.00125231f, -0.06790087f, -0.05668519f, 0.00733037f, 0.05360874f, 
    -0.02090820f, -0.10977189f, 0.25493672f, 0.08055575f, 0.11725423f, 0.05391395f, -0.02988102f, 0.04694790f, 
    -0.05748494f, 0.01041582f, -0.00105215f, 0.07647277f, 0.41469982f, -0.27883732f, -0.07051641f, 0.07727992f, 
    0.01677421f, -0.07325813f, -0.08819446f, -0.01130356f, 0.09627993f, 0.00808046f, -0.00745750f, -0.07304149f, 
    0.09468294f, 0.24489416f, 0.13465719f, -0.09622627f, 0.01309047f, 0.06409608f, -0.01453107f, -0.04190810f, 
    0.04732702f, -0.01809459f, 0.13575549f, 0.06852856f, -0.36591077f, 0.16981126f, 0.03109044f, 0.14985891f, 
    0.06754854f, -0.01300644f, 0.03662603f, 0.06619827f, 0.05714615f, -0.03143282f, -0.00323843f, -0.00737887f, 
    -0.10318600f, 0.49934655f, -0.30892834f, 0.05400304f, 0.05354952f, 0.01409619f, -0.10880696f, -0.05743204f, 
    0.15602876f, -0.02305185f, 0.05357710f, 0.05689400f, 0.30419847f, 0.22830792f, 0.03374284f, -0.00628652f, 
    0.03096660f, 0.04831172f, 0.03416601f, 0.02162735f, 0.00332887f, 0.00934555f, -0.04891938f, -0.03541019f, 
    0.01017450f, 0.14162417f, -0.20922905f, -0.01838673f, 0.05059836f, -0.11015888f, 0.08069183f, -0.03247380f, 
    -0.03863327f, 0.08935337f, -0.01880683f, -0.01402689f, 0.30171713f, -0.29203686f, -0.03259975f, 0.20684706f, 
    -0.11488804f, -0.05931238f, 0.02581767f, -0.05091871f, -0.04174794f, -0.01984993f, 0.08221816f, -0.07563242f, 
    0.18192348f, 0.06373022f, 0.09046721f, -0.15123072f, -0.01408594f, 0.06959226f, -0.06100982f, -0.04781485f, 
    -0.01254271f, -0.08494820f, -0.06012417f, -0.13436806f, 0.29071850f, 0.06345047f, -0.03181067f, 0.04362380f, 
    0.12982623f, 0.07056519f, -0.04967543f, -0.03120110f, 0.00156408f, 0.06456324f, -0.07135377f, -0.03627532f, 
    0.11697527f, -0.11646336f, 0.11650223f, -0.16333306f, -0.03243013f, -0.01552815f, -0.01954842f, -0.12317945f, 
    0.06395480f, 0.06752115f, 0.01847165f, -0.01514740f, -0.12461191f, 0.02243754f, 0.09261107f, 0.14279251f, 
    -0.04655106f, -0.06409704f, -0.03365396f, 0.04073703f, -0.02416077f, -0.09372795f, -0.02599272f, 0.00233945f, 
    0.22989865f, 0.14733072f, -0.03460779f, -0.12804435f, 0.04042811f, -0.00532673f, 0.06557079f, 0.03994573f, 
    -0.03237486f, -0.02310070f, -0.01303170f, 0.10042027f, 0.00868329f, 0.25772604f, 0.05437885f, 0.10357382f, 
    0.04239995f, 0.09475120f, 0.00309734f, 0.07944381f, -0.03646318f, 0.09209313f, -0.05547249f, -0.10177315f, 
    -0.11564089f, 0.22618943f, 0.02209626f, 0.13062909f, 0.04079858f, 0.02444718f, -0.05304107f, 0.01504078f, 
    0.05071601f, 0.02690916f, 0.06636328f, 0.00394435f, 0.09875563f, -0.11187276f, 0.09193990f, 0.07285896f, 
    0.06540937f, 0.05903677f, 0.04874118f, -0.02067894f, -0.01760179f, -0.08664989f, -0.01426316f, 0.08681902f, 
    -0.04034211f, -0.05417769f, 0.03593026f, 0.03388377f, -0.02044799f, -0.11449684f, -0.04860246f, 0.06657623f, 
    -0.00425061f, -0.09534778f, -0.02113612f, 0.00428839f, -0.10694773f, 0.16010110f, 0.03789725f, 0.08230734f, 
    -0.00032607f, -0.04831589f, 0.03097184f, 0.04923880f, -0.11114104f, -0.01918176f, -0.02173034f, 0.02293259f, 
    -0.15615009f, -0.10585772f, 0.10363674f, -0.04295056f, -0.01883345f, 0.01172091f, -0.06532013f, -0.00770783f, 
    -0.09719020f, 0.02791049f, -0.03230064f, 0.02060022f, -0.28925350f, -0.08675612f, 0.19327581f, -0.12799089f, 
    0.07472377f, 0.07565097f, -0.03844701f, 0.05720840f, -0.02417884f, -0.07924435f, -0.09796078f, 0.00018152f, 
    0.14176321f, -0.00728961f, 0.04745106f, -0.12997036f, -0.04846795f, -0.11924613f, -0.06701692f, -0.07355303f, 
    0.05095408f, -0.00541043f, 0.04644329f, 0.10368069f, -0.09785245f, -0.20167668f, -0.04202320f, -0.10871171f, 
    0.00091176f, 0.04576307f, 0.05335042f, 0.04859639f, 0.14063899f, 0.06372001f, 0.02138302f, -0.14383955f, 
    0.04950848f, 0.19859655f, -0.02220258f, 0.22160637f, -0.00433385f, -0.06715202f, 0.07956950f, 0.05659837f, 
    0.08383988f, 0.07006396f, -0.04233076f, -0.02747853f, 0.09185316f, 0.27919409f, -0.13422596f, -0.03440645f, 
    0.07363889f, -0.04470151f, -0.00460717f, -0.03656787f, -0.02272729f, -0.05147710f, 0.03576181f, 0.01763927f, 
    -0.08381226f, -0.13826180f, -0.10307512f, 0.02312214f, -0.09557617f, 0.00746141f, 0.02240720f, 0.04839659f, 
    0.08066960f, -0.12121540f, -0.08073828f, 0.06210690f, -0.01280322f, 0.12163936f, -0.01298081f, -0.05495311f, 
    -0.03962406f, 0.04222869f, -0.09272490f, 0.03407607f, 0.01400315f, 0.07790259f, -0.01147784f, -0.06789077f, 
    0.08932288f, 0.00580507f, 0.24064445f, -0.05780369f, -0.04485486f, -0.15937904f, 0.10882729f, -0.04082153f, 
    0.15320274f, 0.08017943f, -0.05319222f, 0.06473719f, -0.06601636f, -0.08884956f, 0.20785949f, 0.16482636f, 
    0.18002450f, 0.13077481f, -0.04287761f, 0.09116150f, 0.06347834f, -0.03337534f, 0.06857546f, 0.03546537f, 
    -0.11396639f, 0.10137328f, -0.03301184f, 0.14725825f, 0.14838414f, 0.08401538f, -0.04435476f, -0.01245478f, 
    0.01792245f, -0.02301710f, 0.03195875f, 0.05019141f, 0.10731472f, 0.12260411f, 0.03328792f, 0.00555551f, 
    0.10991924f, -0.04666447f, -0.01186545f, 0.12546347f, -0.03342203f, 0.06051225f, 0.08125380f, -0.04119559f, 
    0.24407591f, -0.18852009f, 0.04959298f, -0.08168921f, 0.04817062f, 0.01827665f, -0.08181775f, 0.02151101f, 
    -0.09424586f, -0.03300042f, 0.02036436f, -0.04604491f, 0.02750605f, 0.20528756f, 0.07299419f, 0.11432745f, 
    0.07318625f, -0.03736246f, 0.12458081f, 0.09395816f, -0.14381000f, -0.01238599f, -0.02449497f, 0.02154725f, 
    0.41822866f, 0.08330669f, 0.01414422f, -0.08804817f, -0.05719968f, 0.07741955f, 0.05259389f, -0.11197276f, 
    -0.04031385f, -0.00428988f, 0.11166161f, 0.16658317f, 0.14952250f, 0.08528626f, 0.01905937f, -0.10417365f, 
    0.03948401f, -0.12528533f, -0.04054164f, -0.05476535f, -0.05704963f, 0.00965282f, 0.06239815f, -0.10550942f, 
    0.07904312f, 0.41437757f, -0.04629267f, -0.03335007f, 0.13735850f, -0.05778649f, -0.01923089f, -0.05248446f, 
    -0.02846284f, 0.00620664f, -0.04103508f, -0.01720961f, -0.04073790f, -0.00485198f, 0.13001567f, -0.06599218f, 
    0.12638085f, 0.12477502f, -0.01573770f, -0.05779179f, 0.07570663f, -0.11850065f, 0.12195461f, -0.00054825f, 
    0.15757383f, 0.16292457f, -0.03717200f, -0.08554569f, 0.06951950f, 0.00965404f, 0.06054340f, -0.00560912f, 
    0.10253903f, -0.11860762f, 0.03581304f, -0.08187882f, -0.03418304f, 0.16198178f, 0.01040137f, 0.05681983f, 
    0.01695129f, 0.07496485f, -0.01019191f, 0.00102661f, 0.00790079f, 0.11510405f, 0.07465218f, -0.00022485f, 
    0.09121038f, 0.08952587f, 0.11271059f, 0.00033883f, 0.06971648f, 0.02785433f, -0.06314356f, 0.02331718f, 
    -0.01346391f, -0.08876062f, -0.05617387f, -0.07455429f, -0.03844574f, 0.15561961f, -0.09633317f, 0.02442460f, 
    -0.04949429f, 0.03810153f, 0.19642138f, -0.06405970f, 0.01380791f, -0.09854850f, -0.02086761f, -0.06442479f, 
    0.04283500f, 0.24362336f, 0.00160205f, -0.04368936f, -0.03674021f, 0.01257627f, 0.03294677f, -0.07287587f, 
    -0.05513739f, 0.00930057f, 0.13665591f, -0.11231064f, 0.08652026f, 0.11467638f, 0.09615894f, 0.14552952f, 
    0.01602465f, 0.08761983f, 0.09704171f, 0.03378187f, -0.07165793f, 0.10445920f, 0.07051685f, -0.00519077f, 
    -0.24428287f, -0.13082720f, -0.04433106f, -0.00732908f, 0.00691837f, 0.01295875f, 0.09904540f, 0.02042420f, 
    0.17010294f, -0.03191536f, 0.07585693f, -0.01993503f, -0.04719331f, 0.09234293f, 0.04475017f, -0.05925423f, 
    0.01519553f, 0.05102842f, -0.04333701f, 0.03857946f, 0.04589412f, 0.04650835f, -0.00761174f, -0.05753484f, 
    0.28062120f, 0.12657383f, -0.02173170f, -0.07444026f, 0.01069108f, 0.03083693f, -0.02714412f, 0.00486041f, 
    0.03650012f, -0.02970868f, 0.02057983f, -0.15591744f, 0.18495098f, 0.02300155f, -0.20456356f, 0.03318937f, 
    -0.02056139f, 0.00157206f, -0.04451966f, -0.06074804f, -0.01690593f, 0.18911815f, 0.14759621f, 0.07899958f, 
    0.18286090f, -0.23396555f, 0.02885649f, -0.03895586f, 0.02878188f, -0.02143205f, -0.05675814f, -0.02920132f, 
    0.01436537f, -0.03758756f, 0.04171906f, -0.04800483f, 0.33400607f, -0.22939649f, 0.10029364f, 0.04503192f, 
    0.14824401f, -0.07973675f, 0.06949879f, -0.02837560f, -0.08195723f, 0.09610879f, -0.00447772f, 0.05793543f, 
    -0.11367195f, -0.10733234f, -0.00504496f, 0.00368272f, 0.00521910f, -0.11949167f, -0.01187948f, -0.16071163f, 
    -0.09631130f, -0.03534707f, 0.08590850f, 0.07520698f, -0.16349585f, 0.07314162f, -0.14165054f, 0.04990732f, 
    -0.03193133f, -0.12913749f, -0.07313063f, -0.01624708f, -0.01335188f, 0.11457198f, 0.01853420f, 0.06609765f, 
    -0.16606434f, 0.35644773f, 0.11963853f, 0.27313745f, 0.15554038f, 0.05390235f, 0.01414567f, 0.08848099f, 
    -0.01326413f, 0.07649346f, -0.02204853f, -0.08375118f, -0.28032959f, 0.04083845f, -0.04714866f, -0.13284683f, 
    -0.05261386f, -0.06847767f, 0.01766546f, -0.01149978f, 0.06411444f, -0.02661421f, -0.01429532f, -0.03372977f, 
    0.08481614f, 0.12488215f, -0.09362896f, -0.02723403f, 0.04209202f, -0.12594222f, 0.15747640f, 0.01792434f, 
    -0.03380267f, 0.18357804f, 0.21021870f, -0.04756089f, -0.04304339f, 0.00358166f, 0.04650840f, -0.03492991f, 
    0.07564116f, 0.03942709f, 0.05258850f, 0.03658038f, -0.06150198f, 0.05162451f, 0.01590676f, -0.06952570f, 
    0.00304815f, -0.00981936f, -0.00362312f, -0.00246047f, -0.01047657f, 0.00625661f, 0.02297452f, -0.03755941f, 
    -0.00550512f, -0.00544287f, -0.01754974f, 0.00018286f, -0.00459406f, -0.01324601f, -0.01707283f, -0.00258793f, 
    0.00315742f, 0.00652280f, -0.00943122f, 0.01809354f, -0.01876603f, 0.02270673f, -0.03118318f, -0.02975292f, 
    0.00343901f, 0.02555465f, -0.03567157f, -0.00567107f, -0.03466061f, -0.02806136f, -0.01305970f, -0.02460889f, 
    -0.00811567f, -0.00532609f, -0.00082393f, 0.02375923f, -0.03445324f, -0.00138686f, -0.00036134f, -0.00802150f, 
    -0.03073303f, -0.02306242f, 0.02040708f, -0.01703866f, 0.02687965f, -0.00871748f, -0.00553213f, -0.02808340f, 
    -0.04000610f, 0.01756690f, -0.02278875f, -0.04017157f, 0.00136562f, 0.02406965f, 0.02689102f, -0.01123391f, 
    0.00010255f, 0.01951501f, 0.02452113f, 0.00513284f, -0.00006297f, -0.00608879f, -0.00724384f, -0.03376557f, 
    0.00278292f, 0.00328050f, -0.02182608f, 0.00494137f, -0.03041554f, -0.02633437f, 0.01240337f, 0.00633558f, 
    -0.04038335f, -0.01531912f, -0.03133732f, -0.03210620f, 0.02132509f, 0.02149961f, -0.02841720f, -0.00261302f, 
    0.00565593f, -0.03231520f, -0.03518701f, -0.00282459f, -0.02453497f, -0.02507846f, -0.00361805f, -0.02248678f, 
    0.02301741f, -0.02027762f, -0.03947885f, -0.00582848f, -0.00029359f, 0.01287795f, 0.01635091f, -0.02583806f, 
    0.02722925f, 0.00573978f, -0.02836154f, -0.03848395f, 0.00659252f, 0.02911338f, 0.01903670f, -0.02817286f, 
    -0.01473793f, 0.02108156f, 0.00424586f, 0.02586682f, -0.00798694f, 0.02616044f, 0.00805762f, -0.03032391f, 
    -0.03292496f, 0.01037486f, 0.00816371f, 0.01437172f, 0.01767965f, 0.00424740f, -0.04161390f, -0.01996896f, 
    -0.01995137f, -0.02166428f, -0.03519855f, 0.02839734f, -0.02179530f, 0.01348061f, -0.00330928f, -0.00845207f, 
    0.00768034f, -0.03484546f, -0.03953688f, 0.01827293f, -0.02453968f, -0.01484921f, 0.02410713f, -0.00364585f, 
    0.01802919f, 0.01627539f, 0.00674667f, -0.00574325f, 0.02482509f, -0.04205725f, -0.01313357f, 0.02969030f, 
    0.01870078f, 0.00300395f, -0.00366271f, 0.00722536f, -0.00251176f, 0.01264797f, -0.04142218f, 0.00126374f, 
    -0.02189192f, 0.02395268f, 0.00229066f, -0.00442664f, 0.01548823f, 0.01000699f, -0.00371422f, 0.02590345f, 
    -0.03008991f, -0.01671269f, -0.01648485f, 0.02868450f, -0.00006825f, -0.01924759f, -0.03527074f, -0.03448594f, 
    0.00001326f, -0.00197013f, 0.02276816f, -0.01146016f, -0.01968171f, -0.02784220f, -0.01557942f, 0.00323661f, 
    0.01071218f, -0.04089836f, 0.02730162f, 0.01793618f, 0.02905841f, -0.00122055f, -0.00639948f, -0.01037939f, 
    -0.03455721f, -0.03195486f, -0.03552515f, 0.02150148f, -0.03939315f, -0.00654857f, 0.02154788f, 0.00546377f, 
    0.01603068f, -0.00524806f, -0.03499099f, -0.00882565f, 0.00290987f, -0.01639637f, 0.01253205f, -0.03922189f, 
    -0.03526367f, -0.00658776f, -0.01095788f, -0.02029744f, -0.00908433f, -0.00274284f, -0.02871471f, 0.00459626f, 
    0.00349906f, -0.02708869f, -0.00038122f, 0.01610208f, 0.01004056f, -0.01985760f, 0.00493672f, -0.04162002f, 
    0.02797254f, -0.03384727f, 0.00544858f, -0.00629117f, 0.02342732f, -0.00893007f, -0.02816953f, -0.03963039f, 
    -0.01056899f, -0.02942536f, -0.02107984f, 0.02818738f, 0.02148250f, -0.02681188f, -0.00552145f, 0.00802953f, 
    -0.01906627f, -0.00838247f, 0.02612285f, -0.01604105f, 0.02226112f, 0.00483519f, 0.00441578f, -0.00565579f, 
    0.00026786f, -0.00022014f, -0.01038895f, -0.02722757f, 0.02713361f, -0.03700342f, -0.00136773f, -0.01659700f, 
    0.01113490f, -0.01619308f, 0.00546685f, -0.02343488f, -0.03882216f, -0.02679111f, -0.03544863f, -0.00395188f, 
    -0.02949617f, -0.02816721f, 0.00795029f, -0.02064825f, -0.02588289f, 0.00458284f, 0.01054537f, 0.00087295f, 
    -0.00335926f, 0.01559450f, 0.01853779f, -0.01708087f, -0.03874661f, 0.02300991f, -0.00916483f, -0.02637418f, 
    -0.01408290f, 0.01391861f, 0.00608534f, -0.01847891f, -0.01405595f, -0.01005150f, 0.02539537f, -0.00723949f, 
    0.01184268f, -0.01187293f, 0.00659675f, -0.03354643f, -0.01901617f, 0.01469009f, -0.01938261f, -0.01148791f, 
    0.01152172f, -0.00742623f, -0.01729155f, -0.03428522f, -0.01710752f, -0.01572034f, -0.02959155f, -0.02393527f, 
    -0.03740203f, 0.02926933f, -0.03568360f, -0.02465718f, -0.02329304f, -0.00441896f, 0.00442638f, 0.01199274f, 
    -0.02909024f, 0.00066546f, 0.01656446f, 0.00107150f, -0.04201455f, 0.02594938f, 0.01432954f, -0.00131582f, 
    -0.03408485f, -0.03250571f, -0.01402416f, -0.03672265f, -0.03217112f, -0.02451092f, -0.03424896f, -0.02196058f, 
    -0.01184430f, -0.00123467f, -0.00103337f, 0.02438095f, 0.01112930f, 0.01086552f, -0.03507945f, -0.04176616f, 
    -0.00763869f, -0.00965799f, 0.02403964f, 0.00722322f, 0.02180254f, 0.00246747f, -0.02271408f, -0.02036447f, 
    -0.02081281f, -0.03096327f, -0.01793209f, -0.01795261f, -0.03821204f, -0.03770988f, 0.01087996f, -0.01508808f, 
    -0.04171717f, -0.01044500f, 0.00049511f, -0.03452129f, 0.00352481f, 0.02658945f, 0.00290775f, 0.01698073f, 
    -0.02524615f, -0.02342572f, 0.02487941f, -0.00555052f, -0.02800583f, -0.02678058f, 0.02323591f, 0.01057904f, 
    -0.01616562f, 0.01373742f, -0.02931720f, -0.01108544f, -0.02307588f, -0.03661331f, -0.02492805f, 0.01998149f, 
    -0.00537505f, 0.02463578f, -0.02794579f, -0.04136768f, -0.04149100f, 0.00921738f, 0.02609539f, -0.04120456f, 
    -0.01938192f, 0.00254570f, -0.02840308f, -0.01907682f, -0.02654018f, -0.00569391f, -0.02099704f, -0.02979184f, 
    -0.01575304f, -0.02319263f, -0.00852108f, 0.02917415f, -0.03545159f, 0.03006386f, -0.00574487f, -0.03084331f, 
    -0.00249661f, -0.00932226f, 0.01874685f, 0.00865473f, 0.02623209f, -0.03695283f, -0.01706745f, -0.03126284f, 
    0.02812222f, -0.03252423f, -0.01388619f, 0.02927789f, 0.00462866f, -0.01587874f, 0.00755977f, 0.01785860f, 
    0.00234820f, 0.00747443f, -0.00587693f, -0.01108616f, 0.00076522f, 0.01691031f, 0.02466525f, -0.03452586f, 
    0.02866489f, -0.01495027f, 0.00473589f, 0.00387596f, 0.01958201f, -0.02188157f, -0.03519570f, -0.01078933f, 
    -0.02637584f, 0.02130278f, -0.01826758f, -0.02059102f, -0.00928388f, -0.01527028f, -0.01950589f, -0.01334067f, 
    0.00865872f, 0.01654424f, -0.04003405f, 0.00390966f, 0.00879078f, -0.01246761f, -0.00201626f, -0.00004892f, 
    0.00229900f, 0.01398724f, 0.02226438f, -0.01174426f, -0.03513585f, -0.00184186f, 0.01022921f, -0.01550292f, 
    -0.00204105f, -0.01893901f, -0.00279566f, 0.02426502f, 0.02252128f, -0.00868878f, -0.00688771f, 0.00023722f, 
    -0.01926661f, 0.01360974f, 0.02168211f, -0.00918231f, -0.03345364f, 0.01821387f, -0.04064392f, -0.03438162f, 
    -0.03282243f, 0.02401465f, -0.01021250f, -0.01045528f, 0.00096041f, -0.01019367f, 0.02669444f, 0.01849481f, 
    -0.02650219f, 0.00729005f, -0.01470938f, -0.04153723f, -0.03361196f, -0.01866955f, 0.02192345f, -0.04169318f, 
    -0.04080942f, -0.02653177f, -0.00311442f, -0.00819107f, -0.03018538f, -0.02289006f, -0.02375636f, 0.00132779f, 
    0.00385755f, 0.00242783f, 0.00205739f, 0.00223443f, -0.00355697f, -0.03432365f, -0.00011933f, -0.02046250f, 
    0.01938866f, -0.02396025f, -0.00350460f, -0.02654190f, -0.03447645f, 0.01715714f, 0.00918863f, -0.03431741f, 
    -0.02164157f, 0.02646653f, 0.02179402f, 0.02154424f, 0.02424868f, -0.03718596f, -0.02111207f, -0.04073647f, 
    -0.02589964f, 0.00163572f, -0.00215193f, 0.00042496f, -0.02667104f, -0.00954728f, -0.02479317f, -0.01694844f, 
    0.00249750f, 0.02658166f, -0.01681177f, 0.01519588f, 0.01419031f, -0.03333344f, 0.00196275f, 0.01366499f, 
    -0.00336527f, -0.02476085f, 0.01855240f, -0.02996386f, 0.01274348f, -0.01751433f, -0.00224038f, -0.02291087f, 
    0.00091650f, -0.01144317f, -0.02254631f, 0.02478448f, -0.01532638f, 0.00601486f, 0.02890620f, -0.04087647f, 
    -0.00112528f, -0.02553892f, -0.01379012f, 0.00040142f, -0.03828952f, -0.02537708f, -0.00382398f, -0.00577787f, 
    0.02340183f, 0.00242796f, -0.00408069f, 0.00976204f, 0.00397119f, 0.02089108f, -0.03746131f, -0.02730948f, 
    -0.03542640f, -0.01063872f, -0.00661667f, -0.03016894f, -0.00266361f, 0.02276646f, -0.02530809f, -0.02473794f, 
    -0.04106779f, -0.03580927f, -0.01955743f, -0.02989339f, -0.02212752f, 0.02894714f, 0.01873481f, -0.04111771f, 
    0.01851715f, -0.00922356f, -0.01342744f, 0.02876689f, -0.02804840f, -0.02315199f, 0.00517407f, 0.01321164f, 
    -0.01913202f, 0.01203847f, -0.04121718f, 0.02717549f, -0.03308525f, -0.03846987f, -0.02362471f, 0.00703931f, 
    0.02244656f, -0.01780926f, 0.02526991f, 0.01626703f, 0.02318469f, 0.01693599f, -0.01288898f, -0.03264432f, 
    -0.00981618f, 0.02866919f, 0.02440215f, 0.02074715f, -0.03139690f, -0.00006879f, -0.01241539f, 0.01524132f, 
    -0.03165811f, 0.02477630f, 0.00390320f, -0.02781137f, -0.02422959f, -0.01507198f, -0.01281590f, -0.00429122f, 
    0.02047018f, -0.02374242f, -0.01230603f, -0.00671098f, -0.03836291f, -0.01054355f, -0.00436315f, 0.01197986f, 
    0.01774368f, 0.00259783f, 0.00750068f, 0.00572100f, 0.02045740f, 0.00332776f, -0.01142709f, 0.02025593f, 
    0.02896943f, 0.02757760f, 0.02815771f, -0.00464918f, 0.02179294f, -0.01515716f, -0.04203922f, 0.01824927f, 
    0.00747242f, -0.01595765f, -0.01712746f, -0.01408644f, 0.02861064f, -0.00068169f, 0.00712395f, -0.00676506f, 
    0.02887047f, 0.02031990f, 0.02626867f, -0.03841372f, -0.03660089f, -0.02933782f, -0.00348398f, -0.01365928f, 
    -0.00003227f, -0.02672081f, -0.01989563f, -0.01932478f, -0.00031688f, -0.01283783f, -0.01172514f, 0.01845299f, 
    0.00966437f, -0.04167866f, 0.02971210f, -0.00262903f, 0.02415419f, -0.02854289f, 0.02253151f, 0.00499397f, 
    -0.01056443f, -0.00614232f, -0.03435500f, -0.02156924f, -0.00921275f, 0.02863297f, -0.02752725f, -0.02488131f, 
    0.02074322f, 0.02734531f, 0.00984885f, -0.00265511f, -0.00642139f, 0.01426791f, 0.01356021f, 0.00430554f, 
    0.01439944f, 0.02993358f, -0.00215677f, 0.00443125f, 0.02588992f, -0.03093189f, -0.03903404f, -0.00418521f, 
    -0.01994532f, -0.03313529f, -0.00010721f, 0.00203396f, -0.04149531f, -0.03127789f, -0.01546798f, -0.03785149f, 
    0.02528884f, -0.02078267f, 0.00212049f, 0.00848384f, -0.03216453f, -0.00459047f, -0.00343437f, -0.02488529f, 
    0.02119411f, -0.00624444f, 0.00337055f, 0.00522546f, -0.02428794f, 0.01759967f, 0.01764419f, -0.02129714f, 
    0.02788459f, 0.02355397f, -0.04138708f, 0.03116314f, 0.02933633f, -0.01541686f, -0.02340226f, -0.01158075f, 
    0.02581883f, -0.03523437f, -0.02888247f, -0.01263798f, -0.01905727f, -0.00418467f, -0.01333730f, -0.00617136f, 
    -0.00589316f, -0.02131562f, 0.01433522f, -0.03684270f, -0.01686491f, 0.02016933f, -0.02339313f, 0.00265995f, 
    0.01820072f, 0.00172229f, 0.02901892f, -0.01004096f, -0.00894992f, -0.01724988f, 0.02735436f, -0.00330208f, 
    -0.03333507f, -0.01777025f, 0.00830549f, -0.02508166f, 0.01498725f, 0.02357705f, -0.03465322f, 0.02320059f, 
    0.02040767f, -0.02165171f, -0.00243656f, 0.03573712f, -0.02348915f, -0.01959096f, 0.00507594f, -0.01829855f, 
    0.02492063f, 0.00309469f, 0.01796463f, 0.01712242f, 0.03062163f, -0.03395335f, -0.00059362f, 0.02079418f, 
    -0.00459782f, -0.02980699f, -0.00242330f, 0.01413527f, 0.00368132f, 0.00403720f, -0.03841075f, -0.01021506f, 
    0.03133188f, 0.02962485f, 0.01500830f, -0.03743055f, 0.00146241f, -0.02192649f, -0.00223579f, 0.01875728f, 
    -0.01085558f, -0.00153005f, 0.02214282f, 0.03221605f, -0.03067056f, 0.01326668f, 0.00683963f, -0.03007500f, 
    0.01478665f, -0.01039155f, -0.01670437f, -0.01755272f, -0.02752956f, 0.01980280f, -0.01057029f, -0.01187674f, 
    0.02570365f, -0.01030276f, -0.03497125f, 0.02114649f, 0.02434893f, -0.03209228f, 0.00508280f, 0.03126454f, 
    -0.02762773f, -0.00724318f, 0.00873380f, 0.00500610f, -0.00028371f, 0.00237955f, -0.00009889f, 0.02139809f, 
    0.02553235f, -0.02997662f, -0.03615517f, -0.02325501f, -0.01335728f, -0.00137987f, 0.00227757f, 0.02019179f, 
    0.00228103f, -0.00251951f, -0.02857743f, 0.02578031f, -0.01269201f, -0.01262974f, -0.03927663f, -0.03922954f, 
    0.01392749f, 0.00712779f, -0.01998720f, -0.01964250f, 0.02100400f, 0.01782796f, -0.02591434f, 0.01146847f, 
    0.00508547f, 0.01844562f, -0.00555052f, -0.01524626f, -0.04156414f, 0.01958474f, -0.03075925f, 0.01378092f, 
    0.02122052f, 0.02078803f, 0.00398656f, -0.03554556f, 0.01561448f, -0.02122138f, 0.02964622f, 0.02447618f, 
    -0.03184973f, 0.02357539f, -0.00613486f, -0.01583031f, -0.00150204f, -0.02356790f, -0.02839893f, 0.01064763f, 
    -0.00518512f, 0.02978112f, -0.00805090f, -0.00493137f, -0.00974666f, 0.02262023f, 0.01419516f, 0.02119436f, 
    -0.00542770f, 0.02568810f, 0.00788175f, 0.02465539f, 0.02075676f, -0.02548235f, -0.01998433f, 0.02840681f, 
    0.00347362f, -0.03304201f, -0.03488756f, -0.02198532f, 0.02037006f, -0.01601861f, 0.02439099f, -0.02451252f, 
    0.02095289f, 0.00279081f, 0.02054811f, -0.01999626f, 0.03447354f, -0.02736287f, 0.02586147f, -0.00783948f, 
    -0.00848133f, 0.02059026f, 0.02923237f, 0.00759527f, 0.01525870f, -0.02629552f, 0.01584888f, 0.01184936f, 
    0.03328640f, 0.00873899f, 0.02934260f, -0.01288601f, -0.00535512f, 0.00561436f, -0.03612134f, -0.03243039f, 
    -0.00293367f, -0.03976029f, 0.01612758f, -0.01846501f, 0.01010872f, -0.02652116f, -0.02428440f, -0.00522005f, 
    0.01889284f, -0.01230318f, -0.03088764f, -0.02197237f, 0.01584199f, -0.03534814f, -0.01350181f, -0.02448142f, 
    -0.01272379f, 0.03305902f, -0.03267231f, 0.02956791f, -0.01635945f, -0.02975730f, 0.01987794f, 0.00388195f, 
    -0.02882482f, -0.01915588f, -0.02301868f, -0.00555873f, 0.02485470f, -0.02205476f, 0.00184042f, 0.00573096f, 
    -0.02750370f, -0.03436397f, 0.00824476f, 0.02176496f, 0.01630226f, -0.02490653f, -0.02304969f, 0.01035628f, 
    0.01464677f, 0.02454256f, 0.01316189f, 0.03483912f, 0.02514008f, 0.01697725f, 0.01405710f, 0.00854540f, 
    0.00733843f, 0.01407851f, 0.02171358f, -0.03488631f, -0.02616322f, -0.03311956f, -0.02744954f, 0.01787613f, 
    0.01206847f, 0.02483129f, -0.02134021f, 0.01675756f, -0.02680423f, -0.01007025f, -0.03110209f, 0.00630267f, 
    0.00326222f, -0.00802039f, 0.00901016f, 0.00647372f, 0.01498160f, 0.00508976f, 0.01520810f, 0.00105108f, 
    -0.03752104f, -0.00627502f, -0.02221777f, -0.02640902f, 0.00197374f, 0.01837225f, -0.00200504f, -0.02211302f, 
    -0.04350714f, 0.01292805f, -0.02698165f, -0.04185481f, 0.01946482f, -0.00696122f, 0.00221171f, 0.02262181f, 
    -0.01216592f, 0.01500044f, 0.00863724f, 0.02982534f, -0.01330599f, -0.01517416f, -0.02767268f, -0.00211381f, 
    -0.03138852f, -0.01255068f, 0.03494483f, 0.00757729f, -0.02159672f, -0.02235259f, -0.00121725f, 0.01076651f, 
    0.00495595f, -0.00132619f, -0.00389944f, -0.03728535f, -0.02631374f, -0.01407234f, -0.02060033f, -0.03424930f, 
    -0.02754918f, -0.01709539f, 0.01140811f, -0.02624965f, 0.01939957f, 0.00622974f, -0.02705175f, -0.00769674f, 
    0.01126601f, 0.02296265f, -0.00196652f, 0.00029024f, 0.01106113f, 0.00166776f, 0.01215968f, -0.03664721f, 
    0.00682908f, -0.00917430f, -0.03604455f, -0.00536549f, 0.02379433f, -0.00700896f, 0.00766974f, 0.02426914f, 
    -0.03049446f, -0.03546506f, -0.02470604f, -0.03294702f, 0.02557744f, 0.00270711f, 0.00821436f, -0.03713238f, 
    -0.03199214f, -0.02800240f, -0.02804997f, 0.00000379f, -0.00135119f, 0.00870121f, -0.03156854f, -0.02797004f, 
    -0.04043075f, -0.01124312f, -0.02150947f, 0.00750014f, 0.00974369f, -0.00726054f, -0.01661720f, -0.02654842f, 
    0.02281770f, -0.00281055f, -0.01834850f, -0.04165917f, -0.04095137f, -0.02092548f, -0.00241221f, -0.03950824f, 
    0.01205724f, -0.04110624f, -0.00466727f, 0.02977821f, 0.02482057f, 0.01430499f, 0.02092643f, 0.02219035f, 
    0.03033660f, -0.02510858f, 0.00819412f, -0.00133694f, 0.02299634f, -0.00338761f, -0.01297505f, 0.02443888f, 
    -0.00727357f, -0.03333469f, -0.00654063f, -0.01323246f, 0.00076324f, -0.00022832f, -0.02321791f, -0.01029013f, 
    -0.00950216f, -0.04239620f, -0.01949435f, 0.01325105f, -0.01584901f, 0.00992002f, -0.02450475f, 0.00740485f, 
    0.01829409f, -0.03767093f, -0.01144972f, -0.02029775f, 0.00368753f, -0.01002351f, 0.02376547f, -0.03382653f, 
    -0.00860874f, -0.02109154f, -0.00238024f, 0.01099080f, 0.02360002f, -0.03773765f, 0.02395710f, 0.01813007f, 
    -0.02174984f, 0.00857982f, -0.04269418f, 0.00174188f, 0.04582321f, -0.01275842f, -0.02049221f, 0.00818148f, 
    0.01956188f, 0.02269134f, -0.03801227f, -0.01074883f, -0.01226745f, 0.00205934f, 0.03442688f, 0.01536348f, 
    -0.04358220f, 0.01727710f, 0.02898685f, 0.00014684f, 0.02805711f, -0.04092774f, -0.03337645f, -0.02404856f, 
    -0.03002259f, 0.02626298f, 0.01579104f, 0.00245581f, 0.02606076f, -0.01652341f, -0.03877547f, -0.00158077f, 
    -0.03946381f, -0.03256392f, -0.03331717f, -0.02018560f, 0.00975156f, 0.00330682f, -0.03970714f, 0.00468933f, 
    0.01277428f, 0.02423981f, 0.00631066f, 0.01680535f, -0.02950336f, 0.00870698f, -0.01713809f, -0.01699158f, 
    -0.00653250f, -0.00637187f, -0.02962339f, -0.03211241f, -0.01624407f, -0.00704248f, 0.00430399f, -0.02568403f, 
    -0.00048264f, 0.02069717f, 0.01079539f, 0.00475386f, -0.01443621f, 0.01810439f, -0.04421885f, -0.00088006f, 
    -0.03459843f, -0.04031227f, 0.01102198f, -0.03691785f, -0.03353842f, 0.00788406f, -0.02566991f, -0.00039662f, 
    -0.01901984f, -0.01309681f, 0.01495089f, 0.00404491f, -0.02954610f, -0.03611983f, 0.00805435f, 0.00577207f, 
    0.01663984f, -0.02469518f, 0.01681001f, 0.01450685f, 0.01753692f, -0.01174292f, 0.02117100f, -0.02168832f, 
    -0.01899686f, -0.01511135f, 0.01650644f, 0.03022258f, -0.00706983f, -0.00352027f, 0.00353650f, 0.03834728f, 
    -0.02142837f, -0.00637963f, -0.01791809f, -0.02771462f, -0.00407384f, -0.03427464f, 0.00922579f, -0.01885535f, 
    -0.01911558f, -0.01902665f, -0.00241957f, -0.01088985f, -0.00454828f, -0.01996992f, -0.00587666f, -0.03540662f, 
    0.01182147f, -0.03100746f, -0.01516314f, 0.01729108f, -0.01016167f, 0.01030216f, -0.01172605f, 0.02155416f, 
    -0.03059999f, -0.03483080f, -0.01075010f, -0.00431612f, -0.03197538f, 0.01688209f, 0.02455320f, -0.04385224f, 
    -0.02526016f, 0.01928602f, 0.00830765f, -0.01680144f, 0.01273541f, -0.02793027f, 0.00631552f, -0.03218460f, 
    0.01758972f, -0.00521726f, 0.03593168f, -0.00009999f, 0.01878224f, 0.02825961f, -0.02318319f, -0.03352201f, 
    0.01295776f, -0.02180315f, 0.02272300f, 0.01978962f, -0.01775606f, 0.00420694f, -0.02042919f, -0.03110522f, 
    0.02115498f, -0.02568400f, -0.03405608f, 0.01965937f, -0.00353837f, -0.02101733f, 0.01458687f, -0.03654261f, 
    -0.03274978f, 0.03181869f, 0.00219255f, -0.01902976f, -0.02656269f, -0.03938467f, 0.02406261f, -0.03748473f, 
    -0.02902717f, 0.01082239f, 0.02610799f, 0.01632720f, -0.02725423f, -0.00379178f, 0.00192511f, 0.03052328f, 
    0.02777141f, 0.02671734f, -0.01960141f, 0.01976002f, -0.00594752f, -0.03962395f, -0.03132185f, -0.01233253f, 
    0.02799080f, -0.01196205f, 0.02805838f, 0.01296146f, -0.03363014f, -0.03759532f, -0.00137198f, -0.00157729f, 
    0.02217352f, -0.03689000f, 0.01644921f, -0.01022392f, -0.04194213f, 0.01002888f, 0.00817267f, 0.02007638f, 
    -0.00467681f, 0.00424589f, -0.03233780f, -0.02083566f, -0.00489182f, -0.01114837f, -0.02447787f, -0.03375280f, 
    -0.04102826f, -0.01868477f, -0.04596142f, 0.02114435f, -0.00094371f, 0.02359366f, -0.00283996f, 0.02562499f, 
    -0.01695468f, -0.01515103f, 0.00379986f, 0.00449875f, 0.03330138f, -0.02106947f, -0.03804471f, -0.02738769f, 
    -0.02634767f, 0.02407333f, -0.02210815f, 0.03756901f, 0.03500126f, 0.00033564f, -0.02009353f, -0.04089482f, 
    -0.02730943f, -0.00095205f, 0.00759991f, 0.00056984f, -0.02345442f, 0.01901900f, -0.02580974f, 0.00567496f, 
    0.02310715f, 0.02795973f, -0.03692812f, -0.01059826f, -0.03032373f, 0.02055755f, 0.01161080f, -0.02265731f, 
    -0.03000737f, -0.01909199f, 0.00463920f, 0.00211866f, 0.00500572f, -0.02722611f, 0.01124425f, 0.00901186f, 
    -0.01118998f, -0.00301751f, 0.03103584f, -0.00473382f, 0.02677388f, -0.03203495f, -0.03439655f, 0.00254154f, 
    -0.00463296f, 0.02426208f, 0.02467284f, -0.01482897f, 0.01803292f, 0.03050005f, 0.02118370f, -0.03833058f, 
    -0.01177214f, 0.01377053f, -0.04413010f, 0.01189195f, -0.00173717f, -0.04372145f, 0.02725467f, 0.00224515f, 
    0.00495799f, -0.00596221f, -0.00612670f, -0.01216217f, -0.00206870f, -0.02047366f, -0.01244869f, -0.03974081f, 
    -0.01984824f, 0.02407535f, 0.01010601f, 0.01130133f, -0.02315262f, 0.01040943f, -0.01145749f, 0.03122484f, 
    -0.03324771f, -0.00079011f, 0.02497164f, 0.00577070f, 0.00637797f, 0.03443987f, -0.01997959f, -0.01189865f, 
    -0.02293762f, 0.00273370f, 0.03492934f, -0.03910126f, -0.02949602f, 0.02232343f, 0.00896300f, 0.02197990f, 
    -0.03428828f, -0.02242514f, 0.02507552f, -0.03544703f, -0.00927470f, 0.02743185f, -0.00380191f, -0.03097179f, 
    -0.01975919f, -0.03811570f, 0.02570924f, -0.02323828f, 0.02331440f, 0.02712488f, -0.02159248f, -0.00336948f, 
    0.01456746f, 0.00019879f, -0.02496729f, 0.03478941f, -0.03647386f, 0.02894979f, 0.02831740f, -0.02107351f, 
    0.03054125f, 0.02628499f, 0.02868851f, -0.01711420f, 0.01151708f, 0.00314031f, 0.01976686f, -0.03147051f, 
    -0.03064093f, 0.01822717f, 0.01402741f, 0.01311322f, -0.02490376f, -0.00922967f, 0.01609059f, -0.02641347f, 
    -0.00382427f, -0.00653874f, -0.00419012f, -0.00859027f, -0.02644195f, 0.02185030f, 0.01755214f, 0.02221094f, 
    -0.03105973f, -0.03876639f, -0.02716159f, 0.01105468f, -0.02085552f, 0.03786280f, -0.00257396f, -0.00029094f, 
    0.01077812f, 0.01510016f, -0.00327179f, 0.03159040f, -0.01519885f, -0.01188491f, 0.01361212f, -0.01744390f, 
    0.00499379f, 0.02883648f, 0.01843651f, 0.00215146f, 0.00003283f, 0.02183322f, 0.01242076f, 0.01239954f, 
    -0.01032791f, -0.00129122f, 0.01905847f, -0.03715859f, -0.03501137f, 0.01326981f, 0.02310749f, 0.01239151f, 
    -0.02593356f, 0.02063867f, -0.01899568f, -0.00943439f, -0.01201703f, -0.00595909f, 0.02691009f, -0.01360504f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.10634302f, 0.03845814f, 0.04279166f, 0.04369825f, 0.00702143f, 0.01338737f, 0.05848161f, -0.03105598f, 
    0.06419494f, -0.00380130f, 0.00987022f, -0.02592347f, -0.03628412f, 0.00919935f, 0.01915978f, 0.02159971f, 
    -0.00181623f, 0.00979672f, 0.08295092f, 0.03971167f, 0.00289862f, 0.02147134f, 0.02626574f, -0.03128975f, 
    -0.00787242f, -0.00600460f, 0.01487878f, 0.00428607f, 0.07276266f, -0.05883947f, -0.01587640f, -0.02832710f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.37213472f, -0.57102662f, -0.13122340f, 0.16508549f, 0.35835132f, 0.01800109f, -0.19587125f, 0.00199552f, 
    -0.10556246f, -0.04624634f, -0.17728235f, -0.04626460f, 0.06255348f, -0.40990102f, 0.30754337f, -0.02565801f, 
    0.15397608f, -0.03381689f, -0.13809180f, -0.36017311f, 0.08499646f, 0.09758473f, 0.04321117f, -0.07075358f, 
    0.32062072f, -0.12921171f, -0.07123283f, -0.04911289f, -0.34875885f, 0.01374632f, 0.01818819f, -0.09025482f, 
    -0.25319058f, 0.35622030f, -0.57523143f, -0.15852755f, 0.27842468f, -0.04726275f, -0.44848916f, 0.11891370f, 
    0.14370820f, 0.05219690f, 0.06560156f, -0.14159961f, -0.03687549f, 0.21255796f, 0.04369647f, 0.12062039f, 
    0.06414618f, -0.15754403f, 0.18326883f, 0.04104983f, -0.29328033f, 0.14258824f, -0.13271573f, -0.31139061f, 
    0.33320689f, 0.13279212f, -0.01603864f, -0.15083727f, -0.53373688f, -0.27763695f, 0.02474865f, 0.02507016f, 
    0.22215292f, -0.35668111f, -0.29404941f, 0.27520606f, -0.46048006f, -0.00794268f, 0.01334979f, 0.14805509f, 
    -0.22550607f, -0.14645462f, 0.15096670f, 0.14783232f, 0.00137883f, -0.07259967f, -0.21673770f, 0.40925694f, 
    -0.03068713f, -0.44720381f, 0.09004341f, -0.04385599f, 0.12067410f, 0.01758382f, -0.05322930f, -0.53258258f, 
    0.17064330f, -0.04241237f, 0.21484293f, 0.06967670f, -0.39675727f, 0.13409109f, -0.04998781f, 0.16216147f, 
    0.39768189f, 0.17316552f, 0.22838067f, -0.03026911f, 0.08025256f, 0.17035967f, 0.07620914f, -0.07837649f, 
    -0.28018513f, 0.12204579f, -0.08410320f, -0.14543357f, -0.03059600f, -0.39916971f, 0.14159594f, -0.36508068f, 
    -0.18136896f, 0.12132241f, 0.08785000f, -0.39433181f, -0.01208770f, 0.00948073f, -0.05192200f, 0.17003107f, 
    -0.10086780f, 0.13085686f, 0.00556819f, 0.01780500f, 0.10450319f, -0.62563884f, -0.01011719f, 0.15287441f, 
    -0.13110676f, 0.20275298f, 0.11668495f, -0.19288798f, 0.10860599f, 0.15784959f, 0.22141692f, 0.15812878f, 
    0.05837788f, 0.08285533f, 0.05548630f, -0.07934405f, -0.09892821f, -0.47750410f, -0.21117631f, -0.47439495f, 
    0.02380529f, -0.34778729f, -0.22583205f, -0.12781644f, -0.06256550f, -0.07863702f, 0.14279026f, -0.03284563f, 
    0.29883632f, -0.05587296f, 0.23781838f, -0.03501735f, 0.29010329f, 0.17994748f, 0.14902233f, 0.09151898f, 
    -0.26936510f, -0.51526600f, -0.12457399f, -0.29058164f, 0.01136081f, -0.16981350f, 0.09307415f, 0.08003356f, 
    0.04310767f, -0.16727832f, 0.07572073f, -0.07048225f, 0.01796019f, 0.49631166f, -0.08660959f, 0.17794318f, 
    0.15423924f, -0.02556295f, -0.05316076f, -0.33306658f, -0.44673762f, -0.02856756f, 0.16722347f, 0.38549432f, 
    0.04294133f, 0.08578509f, 0.13993426f, -0.00999606f, 0.19928135f, -0.01708380f, -0.04432582f, 0.08828419f, 
    -0.37355208f, -0.50938082f, -0.33266655f, 0.27377036f, -0.24842994f, -0.04456284f, 0.12406390f, -0.01730350f, 
    -0.05360625f, 0.10275140f, 0.11352722f, -0.07884079f, 0.09167663f, -0.47483686f, 0.11924177f, -0.07473063f, 
    0.13158646f, -0.41427621f, 0.02259577f, 0.47617039f, -0.31976497f, -0.10925642f, 0.13186224f, 0.28049394f, 
    -0.27487582f, 0.13547970f, -0.04541599f, 0.15957274f, 0.12869941f, 0.10590498f, -0.13995436f, 0.11519103f, 
    0.23983079f, 0.28432661f, 0.20254828f, -0.31640244f, -0.13006747f, 0.14990462f, -0.07195568f, -0.02387716f, 
    -0.24142675f, -0.18143059f, -0.14877737f, 0.02895000f, 0.06381225f, 0.09612706f, -0.47081545f, 0.12283950f, 
    -0.02742298f, 0.03797928f, -0.14523874f, 0.08963161f, 0.17652264f, 0.12831020f, -0.06436522f, 0.20379585f, 
    0.11957766f, -0.05938911f, -0.28836256f, 0.04501215f, 0.06476911f, 0.15354463f, 0.03131038f, 0.15073664f, 
    0.11771275f, -0.04960500f, -0.16338101f, -0.10740466f, -0.15262084f, -0.03567715f, -0.52356273f, 0.01658907f, 
    0.15534502f, -0.09539346f, 0.00667245f, 0.03187237f, -0.12262895f, 0.23077863f, -0.42903087f, -0.25847420f, 
    0.16496123f, 0.03368632f, 0.21156803f, -0.14104129f, -0.12844095f, 0.06975664f, 0.09883441f, -0.20388156f, 
    -0.47455248f, 0.07004420f, 0.17004403f, 0.15867373f, -0.43336359f, 0.33279172f, -0.11154355f, 0.05294517f, 
    -0.03633476f, -0.20364237f, 0.40412295f, -0.33895820f, -0.51531315f, 0.00647492f, 0.12119731f, 0.04477625f, 
    0.05776345f, 0.14536142f, 0.15567872f, 0.00521947f, -0.04788318f, 0.14502500f, 0.22654635f, 0.23131603f, 
    -0.06278320f, 0.11395597f, -0.31317732f, 0.38674098f, 0.01315889f, -0.16769180f, 0.14636236f, -0.37171236f, 
    -0.05252637f, 0.09712660f, -0.04836751f, -0.16046023f, -0.00632363f, 0.27118230f, 0.11368613f, 0.16772209f, 
    -0.43962243f, 0.08142273f, 0.22402047f, 0.30270383f, 0.03935900f, -0.04587743f, 0.21754363f, 0.03679955f, 
    0.09647261f, -0.09932428f, 0.02870824f, -0.16735013f, 0.11152800f, -0.06003654f, -0.47724363f, 0.31413820f, 
    0.07665794f, -0.12408632f, 0.10843778f, -0.23594230f, 0.15564670f, 0.05700018f, -0.07319386f, -0.09181025f, 
    -0.26626205f, 0.13020533f, -0.33023143f, 0.06422302f, -0.03003558f, -0.49208924f, 0.08966131f, -0.01289927f, 
    -0.30816424f, 0.12850454f, -0.38279155f, 0.14352696f, -0.19540374f, -0.05257075f, 0.32821697f, -0.00372866f, 
    -0.25892162f, 0.00838388f, 0.15823388f, 0.11940280f, -0.12855235f, 0.06349985f, 0.02096131f, -0.39131716f, 
    -0.03834745f, 0.62582701f, 0.04286706f, -0.14335832f, -0.24651109f, -0.09819698f, -0.09509505f, -0.10593770f, 
    -0.17631555f, 0.06058149f, 0.15703693f, -0.05036956f, 0.12172595f, 0.07293645f, -0.15522236f, 0.05019533f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.11066714f, -0.03638581f, 0.04971237f, -0.01047304f, -0.01524819f, 0.13790613f, 0.19482240f, -0.17985585f, 
    -0.02470367f, -0.02364184f, -0.12153596f, 0.07381100f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
