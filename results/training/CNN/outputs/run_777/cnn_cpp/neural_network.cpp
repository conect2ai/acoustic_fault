#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.68923306f, 0.60365570f, 0.71875566f, -1.00285625f, -1.13999557f, -0.76501912f, 0.32580259f, -0.72655296f, 
    0.03109756f, 0.40229541f, 0.00217353f, 0.25347757f, -0.27091780f, -0.20911498f, -0.01581496f, 0.01750714f, 
    0.07029538f, 0.02751950f, 0.14995977f, -0.01164141f, -0.48536044f, 0.13230035f, -0.14361531f, -0.21679175f, 
    -0.31642142f, -0.82359505f, -0.79673332f, -0.46598738f, -1.07749748f, -0.68564218f, -0.46108964f, -0.71866053f, 
    0.51116359f, -0.55595660f, -0.57084495f, 0.18853514f, -0.40126303f, 0.00821623f, -0.06062106f, -0.36003426f, 
    0.32997069f, 0.27490404f, -0.20414236f, -0.50394839f, -0.43809325f, -0.03716926f, 0.24291338f, 0.10969455f, 
    0.13907619f, -0.42322326f, 1.57366419f, 0.04869074f, -0.55676550f, -1.08264506f, 0.07677812f, 0.97778869f, 
    -0.78587002f, 0.38798311f, 0.19886729f, 0.41696247f, -0.34149238f, 0.45880267f, 0.15341793f, 0.56668043f, 
    0.38002604f, 0.15563236f, 0.09084777f, 0.15343530f, 0.40790635f, 0.45204934f, 0.33228898f, 0.45326874f, 
    0.08767056f, 0.17637479f, 0.16102317f, 0.92128617f, 0.91903323f, 0.88580847f, 0.35351384f, 0.92478186f, 
    -1.00123501f, -1.35779965f, -0.83367676f, -0.67177516f, -0.50910032f, 0.13828781f, 0.50702035f, 0.31091160f, 
    0.07939110f, 0.02184610f, 0.00330479f, 0.26316071f, -0.05667706f, -0.05906431f, 0.41211507f, 0.41656131f, 
    0.35536653f, 0.24337909f, 0.01358838f, 0.34513476f, -0.35783523f, -1.66088498f, -1.24689710f, -0.16925530f, 
    0.18435372f, 0.42749673f, -0.27663341f, -0.50990212f, 0.47901964f, 0.33146581f, -0.69920182f, 0.30672973f, 
    0.59747541f, 0.63740927f, -0.02803126f, -0.21080969f, -0.01542767f, 0.25308278f, -0.12248814f, 0.05664568f, 
    -0.12030864f, -0.28693855f, -0.18000257f, -0.18473302f, -0.13453209f, -0.42466772f, -0.82112807f, -0.84888810f, 
    -0.61633271f, -0.70589453f, 0.36349210f, 1.06580985f, -0.53790480f, 0.78266549f, 0.84162873f, 0.38745409f, 
    0.02010939f, -0.14580289f, -0.23317908f, -0.13631926f, 0.28694037f, 0.33938414f, 0.07735540f, 0.16729392f, 
    0.19146767f, 0.05046264f, 0.11211152f, 0.03942540f, -0.00591786f, 0.59152371f, -0.11950158f, 0.90737826f, 
    0.00329194f, -0.96211994f, 0.31223464f, 1.27140605f, -0.48936340f, -1.48172331f, -0.71623641f, -1.25446510f, 
    0.23307119f, 0.56082445f, 0.11329302f, 0.25305817f, -0.78700805f, -0.26516074f, -0.21470419f, 0.05814231f, 
    -0.18407820f, -0.07240931f, -0.17461832f, -0.13769506f, 0.05910818f, -0.12196397f, 0.17783147f, 0.52838141f, 
    -0.22040421f, -1.16206658f, -1.18002617f, -0.67737639f, 0.17384784f, 1.05917847f, 0.54107267f, -0.12043087f, 
    0.21336094f, 0.20476747f, 0.26838031f, -0.28415197f, 0.07137562f, 0.23666851f, 0.02154525f, -0.45291424f, 
    -0.21957068f, 0.05784512f, -0.00234863f, -0.13738546f, 0.20493577f, -0.44681618f, 0.22541182f, 0.25633636f, 
    1.28541195f, 1.36010349f, 0.46243632f, 1.23487902f, 0.27853352f, 0.51292247f, 0.49894169f, 0.07154501f, 
    0.43542558f, 0.51197058f, 0.20700216f, 0.28345910f, 0.47186649f, 0.48642212f, 0.01754733f, 0.36545643f, 
    -0.06498419f, 0.59014994f, -0.24027798f, 0.22049382f, -0.42717600f, -0.34101656f, -0.28917173f, 0.02237035f, 
    -0.25303763f, 1.32700670f, 0.54643428f, 0.51882219f, 1.92465317f, 1.12665844f, 0.69396353f, 0.13549532f, 
    -0.33461475f, 0.18454176f, 0.23954989f, -0.58793527f, -0.19132669f, -0.64410764f, 0.11862899f, -0.58703536f, 
    -0.31910375f, -0.18228458f, -0.49516207f, -0.32627103f, -0.42048347f, 0.13049845f, 0.06590685f, -0.07833526f, 
    -0.22690015f, 0.14648806f, 0.70057166f, -0.29422352f, -0.88526201f, 0.94383073f, -0.71912152f, 0.02904708f, 
    1.16411030f, -0.35844606f, 0.93572587f, -0.22738118f, 0.57890707f, 0.36827838f, -0.39884451f, 0.15771422f, 
    -0.01013034f, 0.02958187f, -0.61412549f, 0.40122527f, -0.01632193f, 0.32462370f, 0.08021092f, -0.05443659f, 
    0.74154770f, 0.17411686f, -0.20765512f, -1.35468376f, -0.90872699f, -0.08511823f, 1.45716870f, 0.68350929f, 
    1.18422878f, 1.03579581f, 0.61449289f, 0.03893206f, -0.66110963f, 0.16822250f, -0.04956586f, 0.09999266f, 
    0.06970016f, 0.18442944f, -0.03282890f, 0.13672614f, -0.08154953f, -0.31092885f, 0.02169199f, -0.11365876f, 
    0.04727142f, -0.27353311f, -0.07469577f, -0.44359198f, -2.21238375f, 1.16759002f, 1.02115631f, -0.97234797f, 
    -0.07773215f, 0.24795754f, 1.15609753f, 0.37210050f, -0.10708885f, -0.18695098f, -0.38894248f, 0.14323120f, 
    0.41424581f, -0.35916844f, -0.15035176f, -0.31993046f, -0.40275729f, -0.17165571f, -0.28205654f, -0.57848865f, 
    0.27598432f, 0.40813890f, 0.29708180f, 0.22612621f, 0.01089897f, 0.11459237f, 0.37115374f, -1.21256781f, 
    -0.87184221f, -0.62654191f, 0.04979249f, 0.21580297f, 0.65767938f, 0.81599611f, -0.52268159f, -0.86298805f, 
    -0.20042618f, -0.57329834f, -0.45663074f, -1.16206944f, -0.24044524f, -0.21204033f, 0.07246734f, 0.03429173f, 
    0.04439465f, 0.22405627f, -0.13017513f, -0.20000920f, -0.45811120f, 0.24380361f, -0.02637384f, -0.96360677f, 
    1.02597749f, 1.03261757f, -0.50777906f, 0.27585945f, -0.82794535f, 0.53130686f, 0.33723304f, -0.31960058f, 
    -0.09632909f, -0.79897374f, -0.02602096f, 0.25133735f, -0.37130302f, 0.09010851f, 0.32376435f, -0.44919169f, 
    0.59796405f, 0.53876936f, -0.12934373f, 0.27805200f, 0.62427837f, 0.37679875f, -0.40021548f, 1.49911022f, 
    0.57616311f, 1.74000180f, -0.47687235f, -0.68837404f, 0.83542442f, -0.86421734f, 0.36302677f, 0.07730285f, 
    0.51476020f, 0.64703959f, 0.44563589f, -0.15409730f, -0.19330087f, -0.09158960f, 0.04272044f, 0.31218791f, 
    0.07253110f, -0.19913454f, -0.31037113f, 0.18217307f, 0.39587110f, 0.26115566f, 0.05577563f, 0.06234436f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.09416693f, 0.17818862f, 0.41475129f, 0.26219240f, 0.65835512f, 0.20305298f, 0.53120518f, 0.27355844f, 
    0.68821901f, 0.48675308f, 0.07126088f, 0.38862190f, 0.13282683f, -0.31148285f, -0.05135212f, 0.50842780f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.07522684f, 0.23643351f, 0.11195748f, -0.09831859f, -0.04458217f, -0.29491377f, -0.35770902f, 0.25565177f, 
    -0.05956824f, 0.03598876f, 0.11169303f, -0.23393163f, -0.62448633f, -0.22274499f, -0.28715488f, -0.04957913f, 
    0.02584935f, 0.14054696f, -0.08229839f, 0.00928569f, -0.17212567f, 0.06047424f, -0.14874505f, -0.18221508f, 
    0.67722553f, -0.51525950f, 0.15811996f, -0.65643620f, 0.05945893f, -0.04446157f, 0.15207314f, -0.00745410f, 
    -0.20754921f, -0.05850660f, -0.06271233f, 0.28965846f, 0.36447018f, -0.00562717f, 0.18457896f, -0.13265590f, 
    -0.06888743f, -0.12489411f, -0.05275595f, 0.12109920f, 0.07279997f, -0.21004675f, -0.09183186f, -0.10329951f, 
    0.09284516f, -0.32257545f, 0.02954528f, 0.05464112f, 0.14305198f, -0.01729795f, 0.09746740f, -0.15365638f, 
    -0.01338515f, -0.03780114f, -0.10809927f, 0.12117819f, 0.34431320f, 0.11313763f, -0.03018294f, -0.50016063f, 
    0.02806073f, 0.03480224f, 0.09043834f, 0.02288310f, 0.04089839f, 0.15770763f, -0.06670032f, 0.16489005f, 
    -0.87425160f, -0.02765180f, 0.41141644f, -0.26796508f, -0.11975571f, 0.03126102f, 0.06768183f, -0.08638161f, 
    -0.03757805f, 0.00200303f, -0.15247147f, -0.06374245f, -0.40805143f, -0.17642722f, -0.03320999f, -0.68983531f, 
    0.08916556f, -0.24355972f, 0.05649065f, -0.11912133f, -0.00971693f, -0.02365120f, 0.00795000f, 0.17074957f, 
    0.22036305f, 0.08900165f, -0.36434573f, 0.06223548f, -0.36178890f, -0.03005465f, -0.00197009f, 0.25811625f, 
    0.15831859f, 0.14500988f, -0.06947673f, -0.07222439f, 0.47161165f, -0.10979116f, -0.06078643f, 0.65397388f, 
    -0.16755761f, -0.11495793f, -0.07021168f, 0.06659482f, -0.32800534f, 0.13412385f, -0.12933426f, 0.11152813f, 
    0.09275201f, 0.56821293f, -0.15031005f, 0.10509451f, -0.09371907f, 0.17641844f, -0.03614166f, -0.02753796f, 
    0.11447914f, -0.02163854f, -0.04835524f, -0.15287963f, -0.74412769f, 0.18844764f, -0.02520319f, 0.15105705f, 
    -0.09459065f, 0.05488448f, 0.10362614f, 0.01682058f, 0.07791594f, -0.03958034f, 0.02809078f, -0.11729506f, 
    0.04516214f, 0.21356308f, 0.42500570f, 0.00978269f, -0.05513882f, -0.00359623f, -0.05282421f, -0.09600989f, 
    0.06352751f, -0.10348408f, 0.06752466f, -0.01322472f, 0.06032131f, 0.16278784f, -0.10232203f, -0.48717204f, 
    0.24979568f, -0.11314896f, 0.16716573f, -0.02699392f, -0.05981006f, 0.25910044f, 0.19531594f, 0.02501021f, 
    -0.07442740f, -0.13169371f, -0.19363476f, 0.70543182f, 0.02669940f, -0.10620639f, 0.09113413f, -0.04351502f, 
    0.01912946f, -0.05276234f, -0.05018189f, -0.21269321f, 0.08906747f, -0.15291134f, 0.04257650f, -0.00903043f, 
    -0.24327658f, -0.22236192f, 0.07939324f, -0.21916419f, -0.19796820f, -0.09311112f, -0.12702277f, 0.01282869f, 
    0.48301902f, 0.03600906f, -0.40417802f, -0.23563854f, 0.20656109f, -0.23748484f, 0.11095293f, -0.14018621f, 
    -0.04288910f, -0.02537111f, -0.04907770f, -0.18266073f, 0.02832237f, -0.11763436f, 0.16140777f, 0.05364500f, 
    -0.00127759f, -0.21470225f, 0.17572707f, 0.02293814f, 0.11719609f, -0.00899535f, -0.08254453f, 0.05267950f, 
    0.18059883f, -0.42331079f, 0.30631298f, -0.41049573f, 0.00125142f, -0.05441716f, 0.05638940f, -0.08390141f, 
    -0.06033956f, 0.00765722f, 0.17766424f, -0.06257603f, -0.15301408f, -0.16080527f, 0.18763644f, 0.05389805f, 
    0.00074096f, 0.06484878f, 0.16937900f, 0.00328966f, 0.05577038f, 0.13863610f, 0.01893242f, 0.07616290f, 
    0.26649034f, -0.13959995f, -0.00325840f, -0.10873922f, -0.05691339f, -0.21533047f, 0.04225569f, 0.11375113f, 
    -0.30962136f, -0.18301442f, 0.22947624f, -0.17407039f, -0.09689245f, -0.37444627f, -0.45273501f, -0.17909791f, 
    0.06990566f, -0.17481685f, -0.02120237f, 0.04428034f, 0.07623857f, 0.10012300f, 0.03107540f, 0.15090686f, 
    -0.11797807f, -0.39024499f, -0.06792340f, -0.27208480f, 0.07007608f, -0.15453580f, -0.01643431f, -0.13644443f, 
    -0.13713308f, 0.14612298f, -0.00181008f, -0.20661175f, 0.45088530f, -0.42653444f, 0.06202690f, -0.34346771f, 
    -0.00926484f, 0.14095116f, -0.24441366f, 0.02047699f, -0.20311898f, -0.08283985f, -0.02838194f, 0.01013930f, 
    0.45038798f, 0.17223293f, 0.15941843f, 0.27264017f, -0.03905582f, -0.14354597f, -0.02694960f, -0.04091764f, 
    0.19893800f, 0.00262263f, -0.00179638f, 0.15872605f, 0.39332184f, 0.21368763f, 0.19303091f, 0.26629356f, 
    -0.24170046f, 0.13625871f, 0.06475135f, 0.12987828f, 0.05434240f, -0.02428957f, -0.02675588f, -0.11786252f, 
    0.52234590f, -0.83144146f, -0.09454758f, 0.19176346f, -0.20108314f, -0.07941007f, -0.09380521f, 0.11391930f, 
    0.03612368f, 0.02265843f, -0.10040440f, 0.50461429f, 0.19294143f, 0.30532971f, -0.34136894f, 0.29531357f, 
    0.22446343f, 0.19737639f, -0.15904181f, -0.07325789f, -0.17333205f, 0.19680510f, 0.08893872f, -0.01735338f, 
    -0.60998720f, 0.20965122f, -0.29152551f, -0.19834346f, -0.04058768f, 0.11122411f, 0.14793223f, -0.07218549f, 
    0.06577869f, -0.10918380f, -0.01531576f, -0.25279236f, -0.14052677f, -0.44952750f, -0.01237189f, -0.12473902f, 
    0.01798560f, -0.27766448f, -0.22782347f, 0.19236276f, 0.32124630f, -0.44419613f, -0.16670372f, -0.27555338f, 
    -0.29132852f, 0.33675686f, -0.17985670f, 0.11694451f, -0.08520726f, -0.24533519f, -0.01044242f, -0.16293459f, 
    0.17884421f, 0.03985799f, 0.00373494f, 0.02083807f, -0.30591607f, 0.37517706f, 0.13668405f, -0.05349395f, 
    -0.30113846f, -0.04254160f, 0.01213964f, 0.03123090f, 0.17528240f, -0.25666782f, 0.27198747f, -0.09188493f, 
    -0.39891508f, 0.31511742f, -0.07459708f, -0.59581345f, -0.23508571f, 0.00365380f, 0.18122986f, 0.10780453f, 
    -0.27917275f, 0.00999670f, -0.01674326f, -0.23080955f, -0.31811884f, -0.19753422f, -0.53437644f, -0.26233003f, 
    -0.20247859f, 0.08366656f, -0.07816024f, -0.12975501f, 0.08060334f, 0.17377247f, 0.01162875f, -0.13459995f, 
    -0.78328955f, 0.07906886f, 0.13908443f, -0.22170404f, 0.26511994f, -0.08181723f, 0.21128502f, -0.11253864f, 
    -0.15316109f, -0.04338246f, -0.06233281f, -0.06736607f, -0.13627414f, 0.36021200f, -0.14258252f, -0.03981273f, 
    0.09691774f, 0.05887158f, 0.22473675f, -0.25159869f, -0.18596435f, -0.02264419f, -0.05397652f, -0.21198961f, 
    0.10055898f, -0.03390273f, 0.09072626f, -0.02381786f, -0.26683563f, -0.05022913f, -0.01528767f, -0.02026814f, 
    -0.03709578f, 0.00381912f, -0.31723151f, -0.09256181f, 0.60238642f, -0.23317742f, 0.55235249f, 0.31950992f, 
    -0.13356206f, -0.18119384f, -0.10765244f, 0.15159316f, -0.23988007f, 0.02052232f, 0.14210489f, -0.17332213f, 
    -0.15791161f, -0.42118028f, -0.07262103f, -0.48128748f, 0.26903838f, -0.09707914f, -0.02583997f, -0.05922032f, 
    -0.18381898f, 0.21793510f, -0.05837344f, -0.11808306f, 0.18570772f, 0.25380141f, 0.25607407f, 0.35942250f, 
    -0.23265693f, -0.16282400f, -0.03538893f, 0.20076157f, -0.02240601f, -0.07381684f, 0.09408670f, -0.10824292f, 
    0.37365869f, -0.11493531f, 0.01206593f, 0.03209977f, 0.07648425f, 0.08200364f, 0.06008971f, 0.01695118f, 
    -0.24251819f, 0.07396846f, -0.08077073f, -0.18384863f, -0.05105520f, -0.11213832f, -0.12120560f, -0.10895412f, 
    0.22163437f, 0.09784797f, -0.18603782f, 0.03645771f, 0.15495344f, 0.20042501f, 0.08712875f, -0.16056590f, 
    0.32336044f, -0.12411689f, 0.13513218f, -0.25759372f, 0.09264749f, -0.08177277f, -0.12495437f, 0.21974197f, 
    -0.00406111f, -0.03485232f, -0.05400851f, 0.16380888f, 0.52144003f, -0.34603336f, 0.29302979f, 0.01492114f, 
    -0.12345991f, 0.08645514f, -0.22616594f, -0.02362148f, 0.12830549f, -0.13387541f, -0.06140722f, -0.14484845f, 
    1.00529563f, 0.14801259f, -0.35796902f, -0.27859119f, 0.02297994f, -0.02615939f, -0.07820430f, -0.06787651f, 
    -0.10840924f, 0.24334812f, 0.09011772f, -0.02165307f, -0.14068036f, 0.00354327f, -0.41097113f, 0.37394056f, 
    -0.11901168f, -0.05680022f, 0.20166527f, 0.32187796f, -0.13505210f, 0.04289365f, 0.07718759f, -0.01309906f, 
    -0.61625975f, -0.08134636f, -0.45115480f, -0.02656528f, -0.06034955f, 0.22857191f, -0.18781790f, -0.03225619f, 
    -0.19288535f, -0.02947330f, 0.20662974f, -0.22289051f, -0.53422707f, 0.16619967f, 0.11625648f, -0.27196124f, 
    0.07700891f, 0.05773837f, 0.16485955f, 0.08154175f, -0.02336284f, 0.05660229f, 0.05455963f, 0.00447362f, 
    -0.56974888f, 0.48181310f, -0.21322896f, 0.02995230f, -0.20144166f, 0.18122649f, 0.06513122f, 0.11723711f, 
    0.02599927f, -0.01241357f, 0.10381568f, 0.26942533f, 0.36489335f, -0.19207981f, 0.04546955f, 0.16419557f, 
    -0.16310626f, -0.06627184f, -0.11260296f, -0.15810812f, -0.06013038f, 0.16544542f, -0.16287541f, 0.22325291f, 
    -0.20852427f, -0.09865361f, -0.06513832f, 0.01791036f, -0.31009680f, 0.06404933f, -0.03939286f, 0.05641319f, 
    -0.04924358f, 0.01472830f, -0.18626724f, -0.00562021f, 0.09521182f, -0.64468491f, -0.06355864f, 0.38704893f, 
    -0.00860951f, 0.05106353f, 0.07543954f, -0.09627426f, -0.01152764f, 0.02268922f, -0.13017270f, -0.27363098f, 
    0.22215477f, 0.16204406f, -0.20540206f, 0.10204166f, -0.29185757f, 0.08600940f, 0.00375272f, -0.03210007f, 
    -0.06959774f, 0.16144887f, 0.02490924f, -0.02213890f, -0.01637177f, 0.07205758f, -0.10982763f, -0.29240695f, 
    -0.27072546f, -0.01700400f, 0.00938150f, -0.12596157f, 0.03446110f, -0.23225605f, -0.01247630f, -0.02456162f, 
    1.01739907f, 0.39831665f, 0.22499385f, 0.32905495f, 0.06543790f, -0.02018961f, -0.11443163f, 0.04637932f, 
    0.00152888f, -0.03835285f, -0.12373103f, -0.06529963f, -0.01711297f, -0.26580441f, 0.02442703f, 0.21718268f, 
    -0.14182356f, -0.17234702f, 0.10092646f, -0.01562641f, -0.20590092f, 0.19010317f, 0.11774183f, 0.14794390f, 
    -0.79540795f, -0.68139017f, -0.29924315f, 0.03905366f, -0.37812957f, -0.12355064f, 0.13030483f, 0.03930470f, 
    0.02319376f, -0.06514625f, 0.06324465f, -0.00398838f, -0.27661750f, -0.82429808f, -0.46079966f, 0.13634026f, 
    -0.18340038f, 0.05719804f, 0.09970842f, -0.14508632f, 0.22411163f, 0.02717731f, 0.01206016f, 0.21780474f, 
    0.47995627f, -0.23461394f, -0.23217803f, -0.33483127f, 0.16589724f, 0.12488750f, -0.02918936f, -0.10337178f, 
    -0.03249198f, 0.20827232f, 0.00751541f, -0.09725843f, -0.09313121f, -0.11021081f, -0.00356867f, 0.07227049f, 
    0.09535456f, -0.34002480f, 0.19667563f, -0.04203773f, -0.12334565f, -0.07213636f, -0.02776565f, -0.15704228f, 
    -0.31282276f, 0.51440662f, 0.28315064f, 0.00082880f, 0.08223478f, 0.03590216f, -0.00881239f, 0.17856006f, 
    0.21265672f, -0.01568512f, -0.15587996f, -0.04468329f, 0.19376202f, 0.05365648f, 0.08296429f, -0.05214047f, 
    -0.19212179f, 0.04582319f, 0.23542514f, -0.06857726f, -0.20897140f, 0.33465487f, 0.12007299f, -0.05197844f, 
    0.10136555f, -0.19812095f, -0.02464068f, 0.09241479f, 0.05933601f, 0.23027584f, 0.11342786f, 0.19047095f, 
    0.05033611f, -0.20561843f, 0.16170104f, 0.05733926f, -0.28002590f, -1.01261878f, -0.31525993f, 0.23966618f, 
    -0.05912193f, -0.05217168f, 0.12843071f, 0.06772449f, -0.20844701f, 0.20018685f, -0.15185885f, -0.15258090f, 
    -0.13337335f, -0.49208191f, 0.45296258f, -0.29608300f, -0.08523779f, 0.19080506f, 0.07713024f, 0.03141400f, 
    0.13535355f, 0.05610206f, 0.08996741f, 0.01796841f, 0.35202950f, 0.00741074f, -0.05457184f, 0.01584101f, 
    -0.11075585f, -0.04185104f, -0.01963557f, 0.15563937f, -0.15437090f, -0.05350248f, 0.00773966f, 0.16793206f, 
    -0.01509406f, -0.24004467f, -0.35724032f, 0.07163744f, 0.12286588f, -0.03687657f, -0.05472840f, -0.02497566f, 
    0.11348046f, 0.00612610f, 0.00481035f, -0.01181831f, -0.45147493f, -0.41960832f, 0.36386099f, 0.31882885f, 
    -0.20094121f, -0.03279855f, -0.16041037f, -0.18411760f, 0.18133138f, -0.00076462f, -0.09765576f, -0.12407858f, 
    -0.35142353f, 0.51397318f, -0.04801506f, 0.28001684f, 0.13747641f, -0.13532639f, -0.10625941f, 0.06313504f, 
    0.22675127f, -0.06450237f, -0.09387551f, 0.02450422f, -0.77594411f, 0.08178799f, 0.31195828f, 0.28237745f, 
    0.09171894f, 0.10738959f, 0.02718769f, 0.16256899f, -0.21242665f, 0.03437000f, 0.18580101f, -0.07793293f, 
    -0.08250407f, 0.27329192f, 0.04036503f, -0.27523839f, -0.21403879f, 0.07509185f, 0.06811664f, 0.14765894f, 
    -0.06650466f, -0.01600360f, 0.13926496f, 0.01997847f, -0.54061323f, -0.00755068f, 0.03071335f, 0.11608108f, 
    0.15893617f, -0.03846535f, -0.00071936f, -0.00914354f, 0.05750738f, -0.06233555f, -0.07329985f, 0.03009625f, 
    -0.08330527f, -0.25737190f, -0.24958521f, 0.08865723f, -0.16373040f, 0.05582800f, 0.11814850f, 0.26464313f, 
    -0.04492874f, -0.21351689f, 0.03481505f, 0.07462192f, 0.31625924f, 0.25739211f, 0.03382384f, 0.09994181f, 
    0.00599028f, -0.06271041f, 0.12662710f, 0.15130030f, -0.01280129f, -0.00373538f, 0.00730390f, 0.16059835f, 
    -0.42777762f, 0.24541302f, -0.03894981f, -0.22062543f, 0.04397285f, 0.13626346f, -0.04437622f, -0.15094160f, 
    -0.24903700f, -0.14229341f, 0.00316733f, -0.26525339f, -0.55405933f, 0.29509962f, -0.19908713f, -0.32157159f, 
    0.09803793f, -0.01363750f, 0.20564835f, -0.00325575f, 0.00696795f, -0.01823421f, -0.04825879f, 0.02962177f, 
    0.12264279f, 0.45557666f, -0.19562717f, -0.29612118f, -0.10577305f, -0.15394659f, 0.03102875f, 0.07355423f, 
    -0.04634362f, -0.07964039f, -0.15305166f, 0.03121240f, -0.18744306f, -0.17818917f, -0.03115420f, 0.09271529f, 
    -0.08584815f, -0.08786720f, -0.00894163f, 0.15256412f, -0.06570200f, 0.13135314f, 0.19700508f, 0.07163567f, 
    -0.09166722f, 0.10207129f, 0.08564147f, -0.37403479f, 0.10837681f, 0.32833707f, -0.28681371f, 0.05872292f, 
    -0.01781812f, -0.24376282f, 0.01482536f, -0.01793682f, -0.14794302f, -0.19210845f, 0.13196449f, -0.26614690f, 
    0.05045504f, 0.11788116f, -0.28415895f, -0.04481660f, 0.12591346f, 0.15239988f, -0.14119934f, 0.07585277f, 
    0.06967559f, -0.13944182f, -0.24056372f, -0.02328741f, -0.03355549f, -0.21909086f, 0.03529847f, -0.06448195f, 
    -0.19894911f, -0.09684212f, 0.02944419f, -0.02931570f, -0.27748451f, -0.38396704f, 0.12357917f, 0.14058509f, 
    0.29131258f, 0.09144994f, 0.28344807f, 0.15831587f, 0.24333557f, -0.00107102f, 0.01588054f, 0.14679497f, 
    0.02658344f, 0.12065193f, 0.32360598f, -0.16180797f, -0.21327476f, -0.16804996f, 0.01131260f, -0.05612375f, 
    0.13526089f, 0.28423142f, 0.08623326f, 0.20284002f, 0.17434992f, 0.02252677f, 0.04421190f, 0.13838327f, 
    -0.18601321f, -0.07811634f, 0.06781159f, 0.04984349f, -0.24118696f, 0.02458328f, 0.15783119f, 0.44489413f, 
    -0.97415322f, -0.42719588f, -0.16624027f, -0.10786100f, 0.17138846f, 0.14552042f, -0.06202721f, -0.22683564f, 
    0.05494793f, -0.02846197f, 0.35306966f, -0.12461852f, -0.33634484f, -0.41444835f, -0.36566460f, -0.01931339f, 
    0.07526986f, 0.19414762f, -0.14610788f, -0.23460181f, 0.14559591f, -0.22317898f, -0.14536907f, 0.09338672f, 
    -0.30596814f, -0.20274971f, 0.19156425f, 0.39570358f, 0.00493013f, 0.03716355f, 0.15251003f, -0.14659677f, 
    -0.21181843f, -0.25355309f, -0.03288179f, 0.13790913f, -0.16914703f, -0.14057343f, -0.32672867f, -0.09310418f, 
    0.02816278f, 0.08828016f, 0.14994527f, -0.03490579f, 0.02757302f, 0.28127041f, -0.28647768f, -0.01217675f, 
    0.23187956f, 0.22431430f, 0.27432024f, -0.02521153f, 0.09082819f, 0.17694962f, -0.01205324f, -0.09611996f, 
    -0.18023604f, -0.12494730f, 0.12159816f, 0.11768164f, 0.06452585f, -0.06375478f, 0.19767553f, -0.19990772f, 
    -0.03329516f, -0.06912982f, -0.09555876f, -0.03843202f, 0.10649738f, -0.16489536f, -0.33469483f, 0.02008684f, 
    -0.37726301f, 0.29842734f, -0.04133716f, 0.11532031f, 0.17508610f, -0.32961810f, 0.08737852f, -0.07212044f, 
    0.16506353f, -0.18626086f, -0.10321656f, -0.10936201f, -0.82614589f, 0.05172989f, 0.32052445f, -0.41806725f, 
    0.18987548f, 0.03828263f, -0.00947324f, -0.11435232f, 0.06301810f, 0.08264598f, -0.09735499f, -0.01787064f, 
    -0.86501628f, -0.44920561f, 0.08430970f, 0.37197641f, 0.14136182f, -0.02966471f, 0.00483051f, 0.14251916f, 
    0.10634012f, -0.01022314f, -0.02000266f, -0.20985894f, 0.59482884f, 0.10243446f, -0.19000898f, -0.00071155f, 
    0.07793827f, 0.45511609f, -0.21082661f, -0.14089645f, -0.15471317f, -0.11365983f, -0.21408366f, -0.06080796f, 
    -0.14727201f, -0.06566177f, -0.08123983f, 0.08626998f, 0.06097583f, -0.10270977f, 0.02192480f, -0.19772503f, 
    -0.00488616f, 0.31832725f, -0.13159585f, 0.16200274f, 0.04730625f, -0.09814809f, 0.12989165f, 0.42085940f, 
    0.16340037f, -0.06656232f, 0.01592367f, 0.13175054f, 0.19402210f, -0.06696817f, -0.03389088f, 0.07691283f, 
    -0.57108331f, 0.24741256f, 0.18669343f, 0.50087404f, 0.05262822f, 0.23397461f, -0.05548031f, 0.08007151f, 
    0.18664287f, 0.06678881f, -0.05313531f, -0.05449216f, -0.16358460f, 0.32510257f, -0.31427175f, -0.26162997f, 
    -0.12692904f, 0.02718394f, -0.15681715f, -0.28561831f, 0.07352691f, 0.01235200f, 0.11414498f, 0.15612036f, 
    -0.09828749f, 0.07158762f, -0.15151300f, 0.41145101f, -0.02640181f, 0.13993198f, 0.03981676f, 0.03764436f, 
    -0.03452856f, -0.37265164f, -0.07696526f, -0.34621060f, -0.03018945f, 0.34471872f, 0.02701936f, -0.65128404f, 
    0.08486728f, -0.01819133f, -0.06989672f, 0.05983701f, -0.16079788f, -0.16261366f, 0.06065224f, -0.02888163f, 
    -0.10824459f, 0.01869525f, 0.02092846f, -0.39086965f, -0.14165163f, 0.10940571f, 0.26878178f, -0.00360977f, 
    -0.05813466f, -0.11759330f, -0.15729353f, 0.18254317f, -0.08029780f, -0.13070893f, -0.45710996f, -0.21369518f, 
    -0.06932623f, 0.00651250f, 0.05116248f, -0.10318587f, -0.01114917f, 0.19054221f, 0.06700765f, -0.04799482f, 
    0.33033359f, -0.70802361f, -0.13559015f, 0.09200796f, -0.08657867f, 0.18690953f, 0.06567912f, 0.03564182f, 
    -0.00061951f, -0.08089829f, -0.18224253f, 0.11504053f, -0.09010834f, 0.06267592f, -0.49779084f, 0.23406716f, 
    0.14507234f, 0.01958436f, 0.01817718f, -0.16026090f, 0.18912400f, -0.09778226f, 0.04581181f, -0.00021130f, 
    -0.22933340f, 0.32437602f, 0.04034206f, -0.19926271f, -0.23744202f, 0.23119251f, 0.09252554f, 0.21235223f, 
    0.09133774f, 0.12158839f, -0.26253834f, -0.06861821f, -0.13853317f, 0.19836278f, 0.25410518f, -0.46344572f, 
    0.02061868f, 0.15168457f, 0.01484817f, 0.09322137f, -0.01910189f, 0.17511830f, 0.14320354f, 0.05025665f, 
    0.00677863f, -0.19693939f, 0.28328663f, -0.13215938f, 0.24598965f, 0.25957221f, 0.02415835f, -0.16663219f, 
    -0.17743158f, -0.08393904f, 0.06425773f, 0.06326418f, 0.60402429f, -0.98342097f, -0.06361754f, 0.08645318f, 
    -0.08612062f, 0.04420726f, 0.01282452f, -0.04804469f, 0.15926352f, -0.06578129f, 0.01499223f, 0.04242058f, 
    0.41677046f, -0.43701899f, -0.19108750f, 0.18475370f, -0.14512838f, -0.11343400f, -0.05199016f, -0.03747363f, 
    -0.20987383f, 0.06512109f, -0.11431310f, 0.20893273f, -0.50143039f, -0.09070222f, 0.04673289f, 0.18097359f, 
    -0.00935565f, -0.35269707f, 0.42823237f, -0.26508874f, -0.00599246f, -0.02121464f, 0.09487415f, 0.14611232f, 
    -0.02407436f, -0.17529194f, 0.25380912f, -0.52098417f, 0.08035054f, 0.08452048f, 0.22104320f, 0.19490638f, 
    -0.19231088f, -0.30492076f, -0.15231638f, 0.02007508f, -0.67960793f, 0.45485044f, -0.23949762f, 0.61795753f, 
    -0.06968474f, -0.07816550f, -0.04345560f, -0.02581880f, -0.23453288f, 0.13754071f, -0.00327467f, -0.22061655f, 
    -0.13166237f, -0.33435932f, -0.45218164f, 0.24474169f, 0.05683477f, -0.24733897f, -0.29963878f, 0.03698353f, 
    -0.17470811f, 0.03912316f, -0.19236517f, -0.04534438f, 0.28184268f, 0.27018929f, 0.42015827f, 0.57284874f, 
    0.15567037f, 0.28856066f, -0.07861909f, -0.06442965f, -0.16582303f, -0.21151091f, -0.20076773f, -0.09654909f, 
    0.04236061f, 0.29896870f, -0.48774394f, -0.00632261f, -0.00911631f, -0.03159631f, -0.32142696f, -0.04984006f, 
    -0.17056258f, -0.05857092f, 0.07726204f, -0.12270235f, -0.22708687f, -0.27761722f, -0.59849715f, 0.07341122f, 
    -0.01579578f, -0.23117481f, -0.21793880f, -0.07614443f, -0.18265358f, -0.02648971f, 0.17397065f, -0.06315468f, 
    0.25110051f, 0.20619127f, 0.12570789f, 0.05713964f, 0.07375981f, 0.15353945f, 0.03327205f, -0.10317891f, 
    -0.13896419f, -0.08957174f, -0.19188327f, -0.09566893f, -0.18777928f, 0.70306057f, 0.23473376f, 0.25893754f, 
    0.23455493f, 0.19936532f, 0.09072600f, -0.05934593f, 0.01121425f, 0.07846937f, 0.19418344f, -0.27494720f, 
    -0.17047864f, 0.37730089f, -0.11516114f, 0.51847571f, -0.09401741f, -0.34350038f, -0.14191176f, -0.00648558f, 
    -0.04065179f, 0.09101275f, 0.00729215f, -0.08151997f, -0.06406137f, 0.29333913f, 0.18364508f, 0.18423037f, 
    -0.07718018f, 0.14663085f, -0.07191386f, -0.13085216f, 0.04840688f, 0.01505845f, 0.02149845f, -0.06884734f, 
    -0.35480106f, 0.28681615f, 0.12825003f, -0.28190878f, 0.01990381f, 0.15424204f, 0.07060841f, -0.11585094f, 
    -0.15143090f, 0.01709130f, -0.04170754f, -0.21277818f, -0.32309335f, 0.23225182f, -0.25187477f, -0.39451599f, 
    -0.10218836f, 0.11789701f, -0.10676178f, -0.26596016f, -0.17726916f, -0.11373611f, -0.13777269f, -0.04460570f, 
    -0.26791155f, 0.42869166f, -0.06592143f, -0.03200644f, -0.22360808f, -0.19989714f, 0.04558205f, 0.03392522f, 
    -0.14732991f, -0.05094391f, 0.11515321f, -0.22511275f, -0.14682621f, -0.22735898f, 0.39229462f, -0.27436513f, 
    -0.11933747f, -0.01973895f, -0.05831459f, 0.03837027f, 0.03590561f, 0.06525176f, 0.09906664f, -0.12827909f, 
    0.51569682f, -0.41168222f, 0.06782601f, 0.25011036f, 0.30840158f, 0.02805024f, 0.00043750f, -0.16778705f, 
    -0.04977332f, 0.00502166f, -0.16273837f, -0.11478730f, 0.55429661f, 0.24995543f, 0.00588572f, 0.06210274f, 
    0.07621418f, -0.01588076f, 0.23322085f, -0.19034353f, -0.02380968f, 0.17105834f, 0.12764491f, -0.15335545f, 
    0.49353871f, -0.06967100f, -0.02672403f, 0.18638095f, -0.08792128f, 0.11383261f, -0.14576212f, -0.15324855f, 
    -0.08856294f, -0.06698637f, 0.03224869f, -0.14674191f, -0.49701190f, -0.19067293f, -0.51467842f, -0.64784563f, 
    0.22529480f, -0.11518140f, 0.07344045f, -0.05573582f, -0.16718467f, 0.03738808f, -0.15830904f, 0.02754450f, 
    0.34208491f, 0.03333760f, -0.98338622f, -0.43939805f, -0.05421247f, 0.17366068f, 0.01543408f, -0.22800349f, 
    0.10186207f, -0.12976094f, -0.15753868f, 0.09137735f, -0.63981450f, -0.09770724f, -0.00962577f, -0.42006248f, 
    0.25117373f, -0.29442495f, -0.02121801f, -0.12055236f, 0.03157343f, -0.37984079f, 0.04214445f, 0.08978134f, 
    -0.12273301f, 0.36497757f, -0.12382175f, -0.03999062f, -0.25055003f, 0.04148655f, -0.04379557f, -0.03104160f, 
    0.24877168f, 0.09383649f, 0.14139900f, 0.02523884f, -0.35469833f, -0.32943577f, -0.33172441f, -0.31071565f, 
    0.09398776f, 0.11006633f, -0.01144296f, 0.01932466f, 0.27891394f, 0.19824435f, 0.07457537f, 0.02472688f, 
    -0.46391493f, -0.04988085f, 0.34291780f, -0.05317939f, -0.00286085f, -0.01858392f, -0.19709097f, 0.01517923f, 
    0.03622215f, 0.02853041f, 0.21196736f, -0.15984222f, 0.03969941f, 0.11639798f, 0.22880670f, 0.36308008f, 
    -0.25547510f, 0.12058171f, 0.02572712f, -0.00293174f, 0.11086821f, -0.18929523f, 0.03994025f, 0.10980704f, 
    -0.07398067f, 0.07553018f, -0.62250781f, -0.20216171f, -0.11515213f, -0.06598758f, -0.25963163f, 0.11391431f, 
    0.16101858f, -0.00042779f, 0.11466765f, 0.03123046f, -0.13825940f, 0.51696628f, -0.21432710f, 0.09930013f, 
    -0.07993709f, 0.07289188f, -0.01553693f, 0.02124600f, 0.04880845f, 0.00136231f, -0.09266756f, -0.09705168f, 
    0.27145138f, -0.04308220f, 0.02863099f, 0.36681661f, 0.18973735f, -0.06634407f, -0.23017116f, -0.20463172f, 
    -0.15657161f, -0.14692836f, 0.21396592f, -0.16793703f, 0.01485479f, -0.18325032f, 0.33614650f, 0.44956201f, 
    0.22168873f, -0.01462949f, -0.11285331f, -0.17463909f, -0.03325611f, -0.09328281f, 0.18261077f, -0.33073997f, 
    0.28961715f, -0.25563484f, -0.16457660f, -0.01460359f, -0.08635954f, -0.29018411f, -0.06217047f, -0.15108062f, 
    0.02989518f, -0.04896672f, 0.04606600f, -0.04694204f, -0.03545884f, -0.23245470f, 0.19802795f, 0.17212941f, 
    -0.31485739f, -0.34688324f, -0.07128470f, -0.18714616f, -0.07264656f, 0.15347277f, -0.35487711f, 0.04486714f, 
    0.14526461f, -0.00282110f, -0.01562976f, 0.02562691f, 0.04208470f, 0.12939884f, 0.07401780f, 0.01373930f, 
    -0.08269970f, -0.23137178f, -0.07551834f, -0.29586476f, -0.20821021f, 0.00305026f, -0.22728378f, 0.05165615f, 
    -0.16386215f, 0.05225655f, -0.32063225f, 0.10752038f, -0.17221577f, 0.00725178f, 0.03264338f, -0.33309230f, 
    -0.23606704f, 0.00989354f, 0.08591157f, -0.31306568f, -0.06143273f, -0.36432070f, 0.21941006f, 0.03686453f, 
    -0.08621392f, 0.04769835f, 0.03499590f, 0.24926050f, 0.46512806f, 0.39432219f, -0.18873398f, 0.06126885f, 
    0.08826203f, 0.06880923f, 0.05697446f, -0.05453473f, 0.20689705f, 0.08214883f, 0.00499419f, 0.13473421f, 
    0.07779223f, -0.16770661f, 0.21280499f, 0.11776542f, -0.09983743f, 0.12864077f, -0.27402139f, 0.24624701f, 
    0.02164642f, 0.02014911f, 0.11745302f, 0.04521168f, 0.00009468f, -0.49403739f, -0.44740552f, 0.21436104f, 
    -0.05817688f, -0.00907677f, -0.03391497f, 0.15402618f, -0.01439986f, 0.17236331f, -0.10031354f, -0.17255406f, 
    -0.07068112f, 0.54763842f, 0.06529611f, 0.35537791f, -0.05247521f, 0.21326214f, -0.00899919f, 0.08013804f, 
    -0.13052557f, -0.11280961f, -0.29211679f, -0.13230199f, -0.31829497f, -0.04201681f, 0.03955276f, -0.78964692f, 
    0.01132553f, -0.08206085f, 0.03261153f, -0.04646152f, -0.05554034f, -0.10572547f, -0.04666044f, -0.20696700f, 
    -0.27704909f, -0.07901879f, 0.04143297f, -0.10681832f, -0.06524993f, -0.02903576f, -0.10920884f, 0.09698629f, 
    0.07242436f, 0.07089722f, -0.34155366f, 0.14190498f, -0.19269779f, -0.49233907f, -0.05204755f, -0.29502413f, 
    0.20444511f, -0.12022319f, -0.07232673f, 0.06501961f, -0.02705298f, -0.03160899f, -0.05776210f, -0.02595240f, 
    -0.39036047f, 0.27246317f, -0.13567869f, -0.25425473f, 0.06752577f, -0.26327658f, -0.05574352f, 0.02707184f, 
    0.00430460f, -0.00302515f, 0.23403017f, -0.00380186f, -0.29406643f, 0.01214075f, 0.40453130f, 0.09196761f, 
    0.07349049f, 0.00870292f, -0.18407281f, 0.25226751f, 0.12720096f, 0.10828952f, -0.03095887f, -0.06589489f, 
    -0.41970873f, 0.04849320f, 0.17171828f, -0.28296962f, 0.19444625f, 0.00299697f, -0.11497284f, -0.11306763f, 
    0.04600453f, 0.02902497f, -0.24439405f, -0.00054790f, -0.86914086f, 0.47667876f, -0.26410821f, -0.52907550f, 
    0.20520182f, -0.02137168f, -0.14890072f, -0.18084817f, -0.01357912f, -0.08023950f, 0.15402915f, 0.01881941f, 
    -0.70855284f, 0.25071710f, 0.13261160f, -0.06445774f, -0.09996899f, 0.13946603f, 0.15636413f, 0.20572673f, 
    0.05509076f, 0.08689281f, -0.08629528f, -0.02307778f, 0.41738826f, 0.28869149f, -0.61395156f, 0.29885870f, 
    -0.04445586f, -0.00302818f, 0.01847278f, 0.09039666f, 0.02794286f, -0.00844150f, -0.01055833f, 0.17411579f, 
    0.56132954f, -0.77212232f, 0.19611888f, -0.04172258f, 0.05787807f, 0.09135167f, -0.21098018f, -0.08109574f, 
    -0.08414488f, 0.08239797f, 0.12632647f, 0.22779931f, -0.20163290f, -0.01352256f, 0.38240644f, 0.09898110f, 
    0.05003833f, 0.03693048f, -0.08215993f, 0.07548871f, -0.04137407f, 0.21364965f, 0.02860602f, 0.16982310f, 
    0.69858289f, 0.16502254f, 0.02976303f, -0.22033864f, 0.05770690f, -0.02701831f, -0.04302436f, 0.13902658f, 
    -0.11098578f, 0.16689259f, 0.03494555f, -0.04693970f, 0.85901529f, 0.00971175f, 0.20603038f, -0.46342918f, 
    -0.16656388f, -0.00793735f, 0.04714721f, -0.08201186f, -0.17768779f, 0.00778551f, 0.07318531f, -0.22491866f, 
    -1.02939558f, -0.39133799f, 0.50582087f, 0.23540419f, 0.27257448f, -0.07364423f, 0.12136402f, -0.18631515f, 
    0.04599009f, -0.01771984f, -0.23343550f, 0.08264677f, 0.03314799f, 0.34527603f, 0.30752861f, -0.38697612f, 
    0.13692051f, 0.22110417f, 0.18729420f, -0.02719047f, -0.11603994f, -0.31581038f, 0.21683393f, 0.01795314f, 
    -0.43938413f, -0.29139522f, 0.12601376f, 0.28201765f, 0.09536173f, 0.05373206f, 0.14854975f, 0.09924518f, 
    0.13700189f, 0.24003877f, 0.10682668f, 0.06575976f, 0.04495933f, 0.04131093f, 0.00519088f, -0.59158832f, 
    0.20774797f, -0.04893196f, 0.05733985f, 0.22328649f, -0.03766865f, 0.28938991f, 0.08449500f, 0.21573322f, 
    0.45299771f, 0.28664684f, -0.06338266f, 0.10328766f, 0.31548107f, -0.24257669f, 0.02090941f, 0.17577161f, 
    0.07883216f, 0.00880173f, 0.05851206f, -0.04749607f, 0.32400829f, 0.11035111f, -0.05230095f, 0.04091945f, 
    -0.32730141f, -0.14498569f, -0.07526723f, -0.04522478f, 0.31155890f, 0.02489068f, 0.03845186f, 0.19048478f, 
    -0.08912374f, 0.11147937f, -0.19725493f, -0.18404233f, 0.19389218f, 0.13883640f, 0.08212709f, 0.03845854f, 
    0.11743521f, 0.03530927f, -0.03067402f, -0.02918632f, 0.37650126f, 0.19446595f, 0.04410551f, -0.04957108f, 
    -0.40578532f, 0.10684235f, 0.05484954f, 0.01321679f, 0.23537566f, -0.00110236f, -0.00384518f, -0.33725011f, 
    -1.15846014f, -0.80011564f, -0.37187335f, -0.27428278f, 0.14999601f, -0.05653375f, -0.22410031f, -0.13574448f, 
    -0.08054723f, 0.00491540f, 0.25681332f, 0.10856903f, -0.76980513f, -0.75469381f, -0.40472487f, -0.61782062f, 
    0.04577186f, -0.05085941f, -0.03896933f, -0.05739661f, 0.08554515f, -0.21682836f, -0.22174340f, -0.11855779f, 
    -0.37796074f, -0.19955048f, -0.08090905f, 0.13005775f, -0.12139989f, -0.00815949f, 0.14631981f, 0.19398910f, 
    0.41163754f, 0.07654305f, 0.11808401f, 0.00022165f, 0.65908885f, 0.23456569f, -0.09580355f, 0.03030036f, 
    -0.09589365f, -0.38786420f, -0.09234567f, 0.17103986f, -0.00065536f, -0.22146530f, -0.01127243f, 0.02442581f, 
    -0.50289249f, 0.35683474f, -0.41926947f, -0.08813245f, 0.00062284f, 0.01396864f, -0.06842367f, 0.00232310f, 
    0.09838226f, 0.07056677f, 0.04060865f, -0.08338041f, -0.10181453f, -0.33187237f, 0.30090573f, -0.16911553f, 
    -0.15892762f, 0.03501115f, -0.19129445f, 0.01886477f, 0.20978418f, -0.32768875f, -0.32050657f, -0.08844592f, 
    -0.52268529f, -0.10403715f, 0.04613716f, -0.05878649f, -0.30808932f, -0.06225905f, 0.01868078f, -0.12799764f, 
    0.23498347f, 0.36486647f, 0.09572533f, 0.13657916f, -0.98878771f, -0.30283880f, 0.06078134f, 0.15195082f, 
    0.30905020f, -0.02890643f, 0.00131054f, 0.04914330f, 0.02081563f, 0.07058254f, 0.12783158f, 0.21833088f, 
    0.63866699f, 0.24404147f, 0.06919137f, 0.02712519f, 0.05235043f, -0.12756246f, 0.11925525f, -0.15754960f, 
    0.17413281f, 0.01286065f, -0.07280917f, 0.08801188f, -0.16481659f, 0.31888917f, -0.13114677f, -0.32613921f, 
    -0.15861762f, -0.19249059f, -0.23864204f, -0.25948521f, -0.12273739f, -0.18962876f, 0.05633517f, -0.18900275f, 
    0.14732225f, 0.11950129f, -0.25803974f, 0.08880211f, 0.12584925f, -0.29420853f, -0.16310085f, 0.09154123f, 
    -0.12205961f, 0.18289879f, -0.13589080f, -0.14183640f, 0.51945275f, 0.54133052f, -0.55926311f, 0.48396713f, 
    0.12708372f, -0.07270736f, -0.03159112f, -0.00208526f, 0.03833698f, 0.03803965f, 0.03857017f, -0.12338056f, 
    0.65433002f, -0.08837356f, -0.23587130f, -0.01900094f, 0.03809186f, -0.09503856f, 0.05123725f, 0.01957621f, 
    0.12551256f, 0.15851879f, -0.14974436f, 0.11367653f, 0.24716753f, 0.09906637f, -0.02033485f, -0.00766771f, 
    -0.05038188f, -0.11761994f, 0.23702620f, 0.03280625f, -0.41730657f, -0.00041985f, -0.11515450f, -0.28086597f, 
    0.22190584f, -0.55241793f, -0.25176623f, 0.46600848f, 0.09725656f, 0.11441167f, -0.04479017f, -0.07869696f, 
    0.20191848f, 0.05274888f, 0.08454027f, 0.12675281f, -0.18713062f, -0.26400101f, -0.23415783f, 0.06002988f, 
    -0.00293419f, 0.03826640f, -0.00950887f, -0.07087454f, -0.07614749f, 0.00634300f, 0.13648067f, -0.03849898f, 
    0.00410293f, -0.46726161f, -0.09555095f, -0.18463564f, 0.07850718f, -0.01718237f, 0.11408185f, -0.00262475f, 
    0.05017104f, 0.00487107f, -0.21439175f, -0.06658281f, 0.29513541f, -0.44703856f, -0.33118874f, -0.63742685f, 
    0.00487638f, -0.09832168f, 0.17873748f, -0.02349830f, -0.09692269f, 0.09588109f, 0.06807904f, 0.04985022f, 
    -0.17584187f, -0.36516201f, 0.14297593f, 0.00283301f, 0.19916083f, -0.02129877f, -0.16082771f, -0.10574180f, 
    -0.04229071f, 0.07978851f, 0.08201825f, -0.18190998f, -0.17379035f, -0.34141183f, 0.25306609f, -0.13876262f, 
    -0.08773255f, 0.07734039f, 0.00427606f, -0.04140504f, -0.19405881f, 0.17834049f, 0.22671507f, 0.15273142f, 
    -0.77489769f, 0.01736441f, -0.09259889f, 0.03715915f, -0.12088535f, 0.10124608f, -0.06509282f, 0.17212610f, 
    -0.02801985f, 0.13606314f, 0.19212461f, 0.02980744f, -0.45709914f, 0.29561079f, -0.02208550f, 0.01600182f, 
    -0.04744329f, 0.30020633f, -0.10129852f, -0.28379989f, 0.00969827f, -0.13377732f, 0.04319880f, -0.04236641f, 
    0.05098250f, 0.41394484f, 0.08628695f, -0.23371406f, 0.08645152f, 0.02573309f, -0.11906710f, 0.18724591f, 
    0.06229297f, -0.20774898f, -0.01150932f, -0.20095395f, 0.64391565f, -0.51426136f, -0.06252345f, -0.51737994f, 
    -0.07719471f, -0.09004847f, -0.07323551f, 0.03519452f, 0.06690630f, 0.00048697f, -0.08061423f, 0.12584502f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.13697223f, -0.01738982f, -0.00968713f, 0.03382460f, 0.07361387f, 0.00090371f, -0.00253186f, -0.20250675f, 
    -0.02480895f, -0.06147572f, 0.18855043f, 0.05559890f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
