#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.40176371f, -0.49792194f, 0.61237919f, 0.55936426f, 0.38475019f, -0.58246124f, 0.28806686f, 0.25275165f, 
    0.50566244f, -0.14008038f, -0.48904112f, 0.16318689f, -0.10000306f, -0.08602120f, 0.35441571f, -0.19092239f, 
    0.15486464f, 0.23550066f, -0.86579204f, -0.08655687f, -0.44469437f, -0.00963154f, 0.02843582f, 0.24478844f, 
    0.10019966f, -0.80824369f, -0.07742386f, 0.27289137f, 0.50129527f, 0.68599170f, 0.43814123f, 0.50971603f, 
    0.38523197f, 0.27930525f, 0.21075717f, -0.47060972f, -0.43295887f, -0.23295115f, -0.15080152f, -0.08469389f, 
    0.39597657f, -0.15687084f, -0.27138346f, 0.07958606f, -0.04034125f, -0.53844470f, -0.53187943f, -0.00782136f, 
    -0.39153278f, -0.60869199f, 1.08791554f, 0.79676580f, 0.64816439f, 0.12719919f, -0.40628251f, -0.10783982f, 
    -0.29592246f, 0.06858092f, -0.35432139f, -0.55912942f, -0.10274250f, -0.35822719f, -0.16233826f, -0.16866206f, 
    -0.12734301f, -0.16191207f, 0.52501065f, 0.15391174f, -0.29021376f, -0.00553293f, -0.20363739f, 0.23993134f, 
    -0.19375636f, -0.06912187f, -0.68811357f, -0.30074376f, -1.71426868f, 0.10261724f, 1.57248259f, 0.30880588f, 
    0.64150792f, -1.36870861f, -1.96686125f, -1.05646372f, -0.39940846f, -0.58557349f, -0.13583381f, -0.49804395f, 
    -0.45835069f, -0.38903621f, -0.31664938f, -0.38348228f, 0.24805781f, -0.14934744f, -0.32179618f, 0.04287007f, 
    0.09418733f, -0.22764526f, 0.05036274f, -0.16798568f, 0.57007033f, -0.17089432f, 0.26116571f, 0.12477329f, 
    0.19173138f, -0.36581281f, -0.38339585f, -0.02803780f, -0.16942671f, 0.05788501f, 0.00739567f, 0.69312179f, 
    0.11396750f, -0.35601142f, 0.42032909f, 0.39093396f, 0.15985398f, 0.02963385f, 0.17898425f, 0.12254282f, 
    0.13329931f, 0.47740868f, 0.02830222f, -0.34311640f, 0.49691713f, -0.78331852f, 0.75999218f, -0.50897819f, 
    -1.54031324f, -1.20792389f, -0.27458772f, 0.19688062f, 0.93654937f, 0.81127971f, 0.56103122f, -0.37749353f, 
    -0.13564377f, 0.18283439f, 0.22393733f, 0.17519739f, 0.32404646f, 0.12584868f, 0.01870346f, 0.09590602f, 
    0.38543633f, -0.16513696f, 0.34213793f, -0.03532217f, -0.31112340f, -0.36485338f, 0.74064165f, 0.27097553f, 
    -0.13041234f, 0.12515645f, -0.04597809f, -0.72235662f, -0.64930093f, -0.12859634f, 0.50717175f, 0.48217744f, 
    0.27348432f, -0.45187423f, -0.28665361f, 0.21888682f, -0.13872828f, -0.35455900f, -0.05624282f, 0.62326854f, 
    0.08544324f, -0.30867568f, 0.08323687f, 0.18202743f, 0.06438051f, 0.25176293f, 0.05465127f, 0.12440205f, 
    0.35420623f, 0.54238868f, 0.72823340f, 0.42279217f, 0.72842962f, 0.40720493f, -0.11160346f, -0.14611997f, 
    0.29953194f, 0.14470984f, 0.10463990f, 0.43524960f, -0.10531397f, -0.29181138f, -0.22364970f, -0.24843517f, 
    0.19181029f, 0.05191106f, -0.36000657f, -0.11818957f, 0.01368232f, 0.08824093f, 0.00196693f, 0.07126178f, 
    1.09358168f, 0.59832031f, -0.58439267f, -1.30031002f, -1.19053745f, 0.15598904f, 0.18780580f, -0.53400463f, 
    -0.35652074f, 0.66575283f, 0.43691948f, 0.66248542f, 0.09649632f, 0.09091236f, 0.77732503f, -0.22985886f, 
    -0.06684392f, 0.02742538f, -0.15466839f, -0.21398793f, 0.22088823f, 0.03440524f, -0.14563082f, 0.06522787f, 
    0.02432374f, 1.19746125f, 0.46843255f, 0.28005481f, -0.28150636f, -0.07633765f, 0.28319567f, 0.37637261f, 
    0.26306477f, -0.25265306f, 0.38955811f, -0.15256923f, -0.24010572f, -0.14799128f, 0.30884635f, -0.62330246f, 
    0.16560289f, -0.51136112f, -0.45996618f, -0.03539251f, -0.08924799f, 0.33986029f, 0.14076686f, -0.17078510f, 
    -0.52165985f, -0.15060663f, 0.36835119f, 0.09234975f, 0.87701070f, 1.07017791f, -0.25802782f, -0.24270980f, 
    -0.52384043f, -0.44156098f, 0.09340916f, -0.25664103f, -0.48425153f, -0.24979796f, 0.26093262f, 0.26125300f, 
    -0.10913219f, 0.29500723f, 0.02837810f, -0.00067650f, 0.02168390f, 0.29017958f, 0.30694091f, -0.19398566f, 
    0.04842549f, -0.37798816f, -0.51309741f, -1.01014078f, -0.26979107f, 0.07135463f, 0.41916755f, 0.29998943f, 
    0.23713705f, -0.38316610f, 0.49182314f, -0.17893469f, 0.04796439f, -0.26856491f, -0.01002421f, -0.54803705f, 
    1.03176558f, -0.31090850f, -0.34278634f, 0.03802315f, -0.61208886f, -0.10652211f, 0.06737532f, 0.35522845f, 
    0.22217198f, 0.43648800f, 0.29969767f, 0.25919724f, -0.77044094f, -0.73865145f, -0.66807860f, -0.47799101f, 
    -0.42533615f, -1.22219098f, -1.04474926f, -0.89900315f, -1.13226604f, -1.02021515f, 0.40767083f, 0.23782657f, 
    -0.05703946f, 0.22128312f, 0.63160378f, 0.12094138f, -0.35076067f, 0.06023173f, 0.23600861f, -0.07177489f, 
    -0.26751482f, 0.15176673f, 0.40131742f, 0.37881729f, 0.46805730f, -1.49810386f, -0.55135334f, 0.14569513f, 
    0.41236562f, -0.56145060f, 0.45232266f, 0.13034025f, -0.26955512f, -0.03156969f, 0.37907678f, -0.25147560f, 
    -0.06202406f, -0.24257128f, 0.16262637f, 0.11442438f, -0.23330125f, -0.08147363f, -0.28044909f, -0.20797543f, 
    -0.43377456f, -0.24353336f, -0.51287514f, -0.51306748f, -0.70438087f, -0.96189320f, 1.71329725f, -1.08739030f, 
    -0.97368127f, -0.40518743f, -0.80468857f, 0.46906650f, 0.50956202f, 0.74866247f, 0.34835267f, -0.39306551f, 
    -0.21895671f, 0.03179475f, -0.13088012f, -0.07267346f, 0.18336202f, 0.05658201f, -0.01649666f, 0.04567898f, 
    0.00772485f, -0.10930004f, 0.09758860f, -0.10808291f, -0.04599977f, 0.10254666f, 0.21388042f, -1.70251501f, 
    -0.48258129f, -0.67623907f, -1.21334445f, -0.30891183f, -0.27585998f, -0.81672770f, -0.74840248f, 0.42809755f, 
    0.27936807f, -0.39276204f, -0.82008958f, -0.64985037f, -0.61269957f, -0.20375535f, 0.20684993f, -0.31453583f, 
    -0.28703085f, -0.12583077f, -0.04507500f, -0.06787036f, -0.10041612f, -0.53937054f, 0.24670069f, -0.30777246f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.81827885f, 0.02254485f, 0.69090503f, 0.47116879f, 0.38892305f, 0.36065099f, 0.51647007f, 0.17816134f, 
    1.01086390f, 0.43241462f, 0.31798190f, 0.28743887f, -0.02656000f, 0.16084592f, 0.33250871f, 0.60390538f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.58184373f, -0.59914869f, 0.34241435f, -0.62308693f, -0.04380720f, -0.08679822f, 0.01906119f, -0.04464103f, 
    0.00280314f, -0.23080671f, -0.02521551f, -0.18888508f, -0.22410323f, -0.10857574f, 0.07561741f, -0.02137270f, 
    0.02521516f, 0.12260554f, 0.15907279f, 0.10140068f, -0.18445390f, 0.02079977f, 0.03427202f, 0.27051973f, 
    -0.74017483f, -0.64960247f, -0.13743453f, 0.25803268f, 0.02373737f, 0.05673315f, -0.04197772f, 0.05592036f, 
    -0.06992608f, 0.00825521f, -0.03515139f, 0.12247939f, 0.55695766f, 0.23457605f, -0.14130710f, -0.44935089f, 
    0.02765062f, -0.02203894f, 0.10084882f, -0.20088252f, -0.04667654f, -0.19593562f, -0.10471512f, -0.00214032f, 
    -0.02398634f, -0.00874560f, 0.06975205f, 0.06918348f, -0.49248454f, -0.22963901f, -0.13610609f, -0.21660164f, 
    -0.09982528f, -0.13001867f, 0.01447215f, -0.17711927f, -0.18540373f, -0.29711607f, 0.13518779f, 0.06868016f, 
    0.17966673f, 0.34769428f, -0.26944199f, 0.02693856f, 0.02790085f, 0.03447590f, 0.13607024f, 0.05573271f, 
    -0.16026407f, -0.07941081f, -0.10547497f, -0.08432774f, -0.20823540f, 0.14366917f, -0.07443635f, -0.03266504f, 
    0.07223858f, -0.11419529f, -0.02282770f, -0.05681606f, -0.31870294f, -0.29697606f, -0.23304835f, 0.14444713f, 
    0.17964843f, 0.02215880f, 0.06094646f, 0.02966617f, -0.05948544f, -0.12329902f, -0.00132417f, 0.10606614f, 
    0.52715236f, -0.07010691f, -0.45156154f, 0.12867266f, -0.08259199f, -0.05535278f, -0.26214185f, -0.19347622f, 
    -0.10087161f, -0.08418577f, -0.01003473f, -0.05302520f, -0.53199530f, -0.53725243f, -0.35620081f, 0.43927479f, 
    0.12325577f, 0.13928717f, 0.01301514f, -0.00365891f, -0.01651380f, -0.03381582f, -0.11877463f, -0.05719930f, 
    -0.20920552f, -0.17788754f, 0.23428851f, -0.35934874f, 0.08425048f, -0.20459364f, -0.46424621f, -0.00801225f, 
    0.05605179f, -0.00482075f, -0.09181224f, 0.08952252f, 0.07950331f, 0.12896721f, 0.32777560f, -0.12137758f, 
    0.45180163f, -0.08413030f, 0.06122421f, 0.07934443f, -0.03412206f, -0.22717670f, -0.23985599f, -0.08455015f, 
    0.52070796f, 0.38376033f, -0.27610648f, -0.49209946f, 0.08884218f, 0.05653463f, -0.06615829f, -0.15853564f, 
    0.01385142f, -0.00907984f, 0.02057208f, -0.02611511f, 0.36799955f, 0.05904873f, -0.08858178f, -0.43839157f, 
    0.07752204f, 0.03421266f, -0.00865143f, 0.07567429f, 0.03482880f, 0.04427291f, 0.12914957f, 0.20969833f, 
    0.07730635f, -0.38215396f, -0.62369817f, 0.10863107f, 0.14231463f, -0.09643798f, -0.08563477f, -0.22372402f, 
    -0.15416217f, 0.10374534f, -0.17190142f, -0.02809917f, 0.29966140f, 0.44821110f, 0.11334161f, -0.21155861f, 
    0.09233541f, 0.47396380f, 0.11281387f, -0.03855826f, -0.12096678f, -0.11615454f, -0.08313020f, -0.20169529f, 
    0.12276575f, 0.04191065f, 0.32886031f, -0.14575063f, -0.01717900f, 0.08946574f, 0.03046098f, -0.07130440f, 
    0.10585178f, 0.09275667f, -0.20344158f, 0.14592791f, -0.02552122f, -0.13247620f, -0.03971375f, 0.25159997f, 
    -0.02945792f, -0.04596237f, -0.02790176f, -0.08757443f, -0.00197622f, -0.23154975f, -0.03979163f, -0.33316842f, 
    0.18918854f, 0.00461228f, 0.14921196f, -0.22889969f, -0.00305340f, -0.08739481f, -0.22911860f, 0.05652733f, 
    -0.13641503f, 0.14432606f, -0.13487287f, 0.07614036f, -0.18955250f, -0.23301987f, -0.48550361f, -0.10416403f, 
    0.02327001f, -0.30777496f, -0.10046442f, 0.14359985f, 0.12361115f, -0.07557200f, 0.03453915f, 0.07727356f, 
    0.09446296f, 0.06381562f, 0.00032512f, -0.08328312f, 0.12800844f, 0.08524523f, -0.13200088f, -0.10568088f, 
    -0.14878254f, 0.13464625f, -0.02046470f, 0.03408151f, -0.73946738f, -0.16094944f, 0.15934604f, -0.15939038f, 
    0.16259906f, 0.03932258f, -0.28027642f, -0.30092537f, -0.22536376f, 0.00051555f, -0.11886255f, -0.12529175f, 
    -0.13185337f, 0.29101089f, 0.22091228f, -0.12525389f, -0.03451073f, -0.09699219f, -0.18953760f, 0.15637074f, 
    0.02707989f, -0.06417209f, 0.05617371f, -0.06592323f, 0.25964218f, 0.14274418f, 0.15692286f, 0.31540406f, 
    -0.11113638f, -0.00125681f, -0.05741738f, -0.09935734f, 0.00085513f, 0.08335592f, 0.08070350f, 0.10344291f, 
    0.02556815f, -0.64383042f, -0.13461100f, -0.39092594f, 0.16043499f, 0.09729727f, -0.22483219f, 0.16870852f, 
    0.22612150f, 0.22824924f, -0.00387331f, 0.08963062f, 0.64672881f, 0.27674279f, -0.08264542f, 0.30750188f, 
    -0.09055611f, -0.10955241f, -0.04895556f, 0.15691455f, -0.18441702f, 0.06364150f, 0.06304770f, 0.00881725f, 
    -0.02115250f, 0.15861982f, -0.05298265f, -0.36608565f, -0.07614212f, -0.21759771f, -0.03534782f, 0.18816809f, 
    -0.12525018f, 0.04962735f, 0.17228338f, -0.11516080f, -0.34202880f, -0.20451123f, -0.08991367f, 0.06387603f, 
    0.03210042f, 0.06441569f, 0.24837874f, -0.04225153f, 0.04961685f, -0.06591951f, 0.24593642f, 0.06859628f, 
    -0.17171177f, 0.20537917f, 0.20495534f, 0.12293693f, -0.26674032f, 0.07639126f, 0.03522660f, -0.02674549f, 
    -0.09709791f, -0.03295491f, 0.00727579f, 0.03451510f, 0.06554612f, 0.09949628f, 0.05663199f, 0.06915455f, 
    0.04522128f, -0.00388327f, 0.02267872f, -0.02427757f, -0.31028646f, -0.22120450f, -0.16338198f, -0.68459326f, 
    1.50375235f, 0.17214398f, -0.15004289f, 0.06248166f, -0.08453249f, 0.15388019f, 0.23332801f, -0.28691354f, 
    0.06397612f, -0.16507620f, -0.08917774f, -0.14295842f, 0.37166476f, 0.48633966f, -0.16916655f, 0.22204497f, 
    0.09708526f, 0.06397045f, -0.13832256f, 0.01885704f, 0.07573681f, -0.03183225f, -0.04440564f, -0.18343470f, 
    0.35028794f, 0.19197297f, -0.47328144f, 0.36404401f, -0.09374186f, -0.07081620f, 0.16181774f, -0.05429471f, 
    -0.06163070f, 0.08004685f, 0.18151365f, 0.05882949f, 0.02374611f, -0.25884902f, -0.21648809f, 0.01074930f, 
    -0.03901632f, -0.05769652f, 0.01181580f, -0.01412440f, 0.25116333f, -0.03729748f, 0.12967891f, -0.09741375f, 
    -0.86457539f, 0.19353372f, 0.21914335f, -0.50180012f, 0.02408129f, -0.14951648f, 0.05711335f, 0.03209856f, 
    0.10746016f, -0.06072393f, -0.04605146f, 0.02449499f, -0.50103778f, 0.36935976f, -0.45144880f, -0.25401244f, 
    -0.10103165f, -0.49035010f, -0.10055260f, -0.01477495f, -0.02860056f, 0.00128692f, 0.05068148f, -0.09745979f, 
    -0.21282811f, -0.14281094f, 0.01505243f, 0.02716626f, -0.34779081f, 0.14643711f, -0.29170889f, 0.04776336f, 
    0.13298577f, 0.05793027f, -0.07482186f, 0.03987459f, 0.23249879f, 0.56738049f, 0.07095728f, 0.32431576f, 
    -0.02801611f, 0.09651497f, 0.34040126f, -0.01701397f, 0.02454373f, 0.13338336f, -0.03291902f, 0.06415275f, 
    -0.41002616f, -0.06009746f, 0.21968293f, 0.08768900f, 0.14049822f, 0.06167259f, -0.03071576f, 0.08592355f, 
    0.07118245f, -0.01563659f, 0.09788547f, -0.07704184f, -0.31525210f, 0.28397498f, 0.02998476f, -0.16172557f, 
    -0.00151694f, -0.14599051f, -0.01561580f, 0.13664949f, -0.15616040f, -0.25225595f, 0.16073690f, -0.20667444f, 
    -0.00359094f, 0.13902818f, 0.13121220f, -0.20152251f, 0.10372367f, 0.00238558f, -0.19275808f, -0.32568514f, 
    0.07501512f, 0.20469560f, -0.28033864f, 0.12710005f, -0.01092405f, -0.21743616f, -0.08011673f, -0.40153739f, 
    0.03623420f, -0.05157747f, -0.05971219f, 0.05421612f, 0.04160488f, -0.17467837f, 0.05933009f, 0.14961712f, 
    -0.37323600f, 0.30801332f, -0.11680369f, 0.11998762f, -0.01076093f, 0.11151636f, 0.02889624f, -0.09775510f, 
    -0.02713232f, 0.09017801f, -0.02261527f, 0.03022380f, -0.03213478f, -0.07858802f, -0.25310302f, 0.03471632f, 
    -0.26077032f, 0.08255460f, 0.03969801f, -0.07795538f, -0.11887781f, -0.01872469f, -0.03152972f, -0.11964691f, 
    -0.97947419f, -0.81399679f, -0.34614176f, -0.26074812f, -0.08540436f, 0.03080875f, 0.01162185f, -0.09164725f, 
    -0.12134603f, 0.02545368f, -0.07682506f, -0.08966120f, 0.35308206f, -0.09502706f, 0.38978180f, 0.18227382f, 
    -0.02453595f, -0.03073714f, -0.01737879f, 0.00555655f, 0.11827146f, 0.17312700f, 0.01826135f, 0.08815449f, 
    -0.68052661f, 1.05866098f, 0.66131896f, -0.14715782f, -0.26856089f, 0.13443515f, -0.10274823f, -0.23663531f, 
    0.14171468f, 0.08108899f, -0.00988230f, 0.00142198f, -0.04905685f, 0.56338102f, -0.05359936f, 0.66593140f, 
    0.21080486f, -0.06155968f, -0.07888752f, 0.09969436f, 0.00481497f, -0.01906175f, -0.03773414f, -0.03411812f, 
    -0.28746283f, 0.52822465f, -0.39139146f, -0.99467605f, 0.02176099f, -0.52634656f, -0.24077700f, 0.04034932f, 
    -0.38120645f, 0.20605291f, -0.36484322f, 0.05276516f, 0.36414906f, 0.93798548f, -0.43065420f, -0.60240400f, 
    -0.01024212f, 0.35415578f, 0.21671569f, -0.02373425f, -0.21263413f, -0.14464159f, 0.23767155f, -0.10436086f, 
    -0.42341900f, -0.37309918f, 0.48669222f, 0.21478325f, -0.37957963f, -0.15455051f, 0.14233732f, 0.06960138f, 
    0.11044046f, 0.12335677f, -0.16832303f, 0.22210766f, -0.35799453f, 0.39324662f, -0.26671427f, 0.65512311f, 
    0.05203257f, -0.00684763f, 0.02091049f, -0.10464120f, -0.13179778f, 0.00766645f, -0.13154383f, 0.06146459f, 
    -0.00002935f, -0.25800559f, -0.26676804f, -0.33574450f, 0.15172587f, 0.08669709f, -0.14463969f, -0.18685548f, 
    0.00330666f, -0.05187218f, -0.34524757f, -0.06283903f, 1.28858042f, -0.15131603f, -0.02490450f, 0.50247049f, 
    0.01434948f, 0.13769613f, -0.14101610f, 0.13543387f, -0.06655449f, -0.08688792f, 0.03424822f, 0.16331501f, 
    -0.38533759f, -0.02154453f, 0.02558658f, -0.25518835f, -0.27493522f, -0.17990975f, -0.22029807f, -0.38633803f, 
    -0.04756723f, -0.07528303f, -0.09353582f, 0.09072150f, -0.26375526f, -0.10959705f, -0.09779900f, -0.30729654f, 
    0.13898063f, -0.04962822f, -0.05962775f, 0.00624294f, -0.13363369f, 0.17894948f, 0.02658291f, 0.08586422f, 
    -0.63148117f, -0.05543488f, -0.24823171f, 0.64314979f, -0.03873155f, -0.08865737f, -0.26135826f, 0.16464941f, 
    0.01954632f, -0.14216582f, -0.08228482f, -0.03721096f, -0.37187949f, 0.28914526f, -0.51203018f, -0.08506519f, 
    0.10350353f, 0.33325133f, -0.20782852f, -0.03772655f, -0.12020338f, -0.05509584f, 0.35306808f, -0.23765755f, 
    -0.09178869f, 0.13143918f, 0.46741912f, 0.35435951f, -0.10762665f, 0.14136058f, 0.22736639f, -0.08202975f, 
    0.20203570f, -0.05227397f, 0.03012155f, 0.19964895f, 0.10227934f, 0.28623483f, -0.27530181f, -0.44648892f, 
    0.01564614f, 0.13752197f, -0.18794049f, -0.16481894f, 0.05664485f, -0.08892584f, 0.20665184f, 0.16791253f, 
    0.16589920f, -0.24764909f, -0.19230781f, 0.19661188f, 0.11244340f, 0.31169060f, -0.02889576f, 0.16930825f, 
    0.03447624f, -0.21744822f, 0.16361888f, -0.19131869f, -0.08826181f, 0.21434897f, 0.06072568f, 0.31690046f, 
    0.11624276f, 0.10413218f, -0.15278384f, -0.19072990f, -0.20507802f, 0.00288785f, -0.02407599f, -0.10079008f, 
    -0.88871658f, 0.13528252f, 0.09610254f, 0.58638132f, 0.27802929f, -0.03420786f, 0.10344650f, -0.38149512f, 
    -0.12897231f, 0.00298858f, 0.18979824f, -0.14681651f, 0.31018451f, -0.37882936f, -0.14436430f, 0.13028507f, 
    -0.02011998f, -0.07544211f, -0.00181792f, 0.10417221f, -0.04886403f, -0.02021443f, 0.02547216f, 0.15975387f, 
    -0.42814332f, -0.37850755f, -0.05149026f, -0.27051970f, 0.12960242f, -0.00935631f, 0.08563903f, -0.06732139f, 
    -0.12381149f, -0.07922883f, -0.25920749f, -0.16555570f, -0.03439524f, -0.25051126f, 0.19997296f, -0.14889154f, 
    0.05274086f, 0.00019972f, 0.10590779f, 0.20654604f, -0.12154415f, 0.26035637f, -0.02125028f, 0.17075600f, 
    0.39474943f, 0.48086569f, -0.32927153f, 0.11794616f, 0.13642643f, -0.10495440f, 0.06444404f, -0.00866468f, 
    0.12163320f, -0.08340700f, 0.03270010f, -0.14084223f, 0.20130531f, -0.18667777f, 0.42780450f, -0.04977273f, 
    0.20012623f, 0.33640790f, 0.08702313f, 0.05713741f, -0.08509748f, -0.07159096f, -0.05229368f, -0.03317027f, 
    0.16114908f, 0.02037244f, 0.19706933f, 0.06165538f, -0.14130561f, -0.16324677f, 0.38237476f, 0.05587934f, 
    0.17032441f, -0.04673764f, -0.13015541f, -0.23236392f, -0.19344908f, 0.10767885f, 0.10954808f, -0.18315974f, 
    -0.21424250f, -0.25256535f, -0.16589636f, 0.06673472f, 0.14799732f, -0.22793229f, -0.02980451f, -0.04183974f, 
    -0.20471206f, -0.17051241f, 0.04751034f, 0.02686911f, -0.08164015f, -0.04257459f, 0.23993766f, 0.10057335f, 
    -0.03038143f, -0.10692490f, -0.10277722f, 0.04081777f, -0.08809754f, -0.10542390f, -0.19271745f, -0.01169222f, 
    0.06455643f, 0.08725820f, 0.15056922f, -0.08255617f, -0.04611414f, 0.05253946f, -0.08311490f, -0.08581837f, 
    -0.12663984f, 0.13305384f, -0.12610167f, 0.21221672f, 0.08305834f, 0.09187268f, 0.14070292f, -0.24478619f, 
    -0.11791413f, -0.03682405f, 0.03285968f, -0.08668512f, -0.16867064f, -0.72011113f, -0.87563109f, -0.84489739f, 
    0.06035855f, -0.02337252f, 0.09411837f, 0.08739307f, 0.11437442f, -0.09258246f, -0.13703826f, 0.06550518f, 
    0.07548103f, -0.19238164f, 0.13160440f, 0.38840747f, -0.11360867f, 0.17889217f, -0.04372210f, -0.17624527f, 
    0.13202332f, -0.01455831f, -0.10434690f, 0.02615481f, 0.30313438f, -0.11072394f, -0.02763600f, 0.01521392f, 
    -0.21765693f, 0.05964042f, -0.18704516f, -0.10744692f, -0.14233014f, -0.15080780f, -0.32234806f, -0.23123941f, 
    0.21867791f, 0.30762124f, 0.35701436f, 0.35372087f, -0.28813967f, -0.02112435f, 0.10751272f, 0.39854896f, 
    0.12140458f, -0.04586589f, -0.01893651f, 0.01415448f, 0.03383351f, -0.12012803f, -0.04526111f, -0.07391977f, 
    -0.09495597f, -0.13602281f, 0.06268547f, -0.15355439f, 0.32646349f, 0.13221875f, -0.04835807f, 0.49630517f, 
    -0.55550337f, -0.22249249f, 0.28656521f, -0.17698550f, -0.20176038f, -0.23467289f, -0.37633228f, 0.09954614f, 
    -0.09760977f, -0.01548869f, -0.13588609f, 0.26009965f, -0.21654418f, -0.08399472f, -0.07082244f, 0.11818824f, 
    -0.20256953f, -0.03976944f, -0.15492447f, -0.18201217f, -0.13637793f, 0.01170581f, -0.01915551f, 0.28222692f, 
    0.50759840f, -0.69019723f, 0.18749262f, 0.88946033f, -0.06571272f, 0.00393821f, -0.08955996f, 0.02816311f, 
    0.06629906f, -0.07038314f, 0.33622640f, -0.01992549f, -0.04234946f, -0.20521204f, 0.05200001f, -0.02960816f, 
    -0.09375143f, -0.02230049f, 0.00575607f, -0.02283475f, -0.24756540f, -0.32088038f, -0.47044867f, -0.17275354f, 
    0.13502367f, -0.40017375f, -0.40977985f, 0.18768546f, 0.09268499f, 0.26263344f, 0.14177851f, 0.04493874f, 
    0.01241199f, -0.17388250f, 0.09757490f, -0.31405756f, 0.33482999f, 0.25978681f, 0.52490580f, -0.41873732f, 
    -0.06388582f, 0.17093101f, 0.08262904f, -0.00730578f, 0.10658775f, 0.07194418f, 0.00627592f, -0.02488756f, 
    -0.05800612f, -0.08564586f, -0.15367851f, 0.07170486f, 0.26709720f, 0.08211402f, 0.19083545f, 0.37868813f, 
    0.01146290f, -0.07937406f, 0.07059404f, 0.24831259f, -0.16747235f, -0.19340384f, -0.57019591f, -0.04344065f, 
    0.14772320f, -0.12730357f, -0.00830671f, 0.04220235f, -0.08949383f, 0.04345527f, 0.05884651f, -0.07008985f, 
    0.52416301f, -0.24695459f, -0.22901161f, 0.13225082f, 0.14648241f, -0.06006017f, -0.20345984f, 0.01403628f, 
    0.00160105f, 0.23674195f, 0.04312010f, 0.07500032f, -0.15635157f, -0.33480701f, -0.11689211f, -0.00635838f, 
    -0.01949917f, -0.15843444f, -0.15600120f, 0.12298831f, 0.12944712f, 0.00770134f, 0.03959420f, 0.09678636f, 
    -0.06430444f, 0.06608565f, -0.11725154f, -0.28309304f, -0.02689982f, -0.12765391f, 0.19168146f, 0.12179282f, 
    0.06929856f, -0.00008307f, 0.06677826f, -0.16180548f, -0.17747554f, -0.09743039f, 0.09592643f, 0.23461699f, 
    0.08368675f, -0.02248140f, 0.13803120f, 0.01533820f, 0.18300620f, 0.07861190f, -0.00468060f, -0.03925860f, 
    -0.04667880f, -0.35128316f, -0.11956567f, 0.39617631f, 0.02878802f, -0.02142613f, -0.15439518f, 0.05721653f, 
    -0.07104654f, -0.04467755f, -0.13786736f, -0.17794362f, -0.07211798f, -0.09339039f, 0.06710766f, 0.08362102f, 
    -0.07349302f, -0.21681653f, -0.01783484f, -0.09729283f, 0.16671939f, 0.33833817f, -0.08444741f, -0.09839161f, 
    -0.09923793f, 0.10212943f, 0.21982411f, -0.04952740f, 0.33483756f, 0.14733557f, 0.19916175f, -0.36871946f, 
    0.20934971f, 0.00348648f, -0.05643299f, 0.13166481f, -0.60478479f, -0.05063996f, 0.08010822f, -0.15496236f, 
    -0.05987923f, -0.00318633f, -0.06244204f, 0.06472223f, 0.09327588f, -0.17386200f, -0.14086257f, -0.53980303f, 
    -0.27447104f, -0.58020937f, -0.45285594f, -0.54981679f, 0.11097133f, 0.02056823f, -0.29421511f, -0.04923483f, 
    0.27627879f, -0.06496471f, -0.07238363f, -0.16133311f, -0.24007204f, 0.06875163f, 0.37277269f, -0.09494795f, 
    0.07018238f, -0.15776199f, -0.00239258f, 0.14721942f, 0.10136709f, -0.13341577f, -0.05858499f, 0.11156843f, 
    -0.00019564f, 0.16477637f, 0.08468211f, -0.00414799f, -0.06271673f, 0.14495796f, -0.16822349f, 0.30634513f, 
    -0.09660736f, 0.01678646f, 0.14657818f, 0.07510888f, 0.07836868f, 0.08921009f, 0.03744669f, -0.04943970f, 
    -0.06863769f, -0.00506919f, -0.05713097f, 0.11938716f, 0.32563210f, 0.34256908f, 0.37904614f, 0.22758418f, 
    0.07632793f, -0.23871319f, 0.06849331f, -0.41004556f, -0.02050186f, 0.18782286f, -0.05516274f, -0.33023652f, 
    -0.07804848f, -0.09589879f, 0.02745465f, 0.03729045f, -0.64208311f, -2.02528453f, -0.88916653f, 0.58744895f, 
    0.14070240f, -0.04701519f, -0.10362311f, -0.25727808f, -0.00144648f, 0.07744905f, 0.04825729f, 0.09994257f, 
    0.06833650f, -0.20052160f, -0.09325881f, -0.01137294f, -0.23617974f, 0.01069057f, 0.30035886f, 0.05979823f, 
    0.05539427f, -0.28335190f, -0.18701620f, -0.07536608f, 0.48089236f, 0.43665314f, -0.10356102f, 0.21461229f, 
    -0.17715453f, 0.06853165f, -0.00117275f, 0.17900386f, 0.20348047f, 0.00645518f, 0.09136885f, 0.04356495f, 
    0.10169166f, -0.11676718f, -0.53562307f, -0.15982319f, -0.31630889f, 0.01933561f, 0.21024412f, 0.09185999f, 
    -0.05584723f, -0.02852084f, -0.06560052f, 0.00761125f, -0.06161615f, 0.03856716f, -0.08229430f, 0.01658421f, 
    -0.02006584f, 0.07300148f, -0.07725259f, 0.00875522f, -0.08708066f, 0.10827059f, -0.41714031f, -0.01267870f, 
    0.89227653f, 0.14293994f, -0.29657245f, 0.10779304f, 0.09664472f, -0.14936312f, 0.00106486f, 0.00183916f, 
    0.04435414f, -0.24814318f, 0.02107232f, -0.01853933f, -0.08810771f, -0.07869030f, 0.04542842f, -0.34680206f, 
    0.03715100f, 0.04492696f, -0.02968922f, -0.18729432f, -0.10103333f, 0.14733146f, 0.14536594f, -0.31714314f, 
    -0.07484175f, -0.19628841f, -0.41778386f, 0.27540743f, -0.23716366f, 0.35341328f, 0.11796027f, -0.11364453f, 
    0.11224540f, -0.06759968f, -0.06504872f, -0.05428651f, -0.28439167f, -0.21316199f, 0.12680735f, 0.16020234f, 
    0.04349390f, -0.41652134f, -0.20481551f, 0.12669609f, -0.16485135f, -0.01411586f, -0.02955032f, -0.02570304f, 
    -1.35513902f, -1.17728019f, -0.85824174f, -0.36491528f, -0.31917387f, -0.23687007f, -0.18459360f, -0.46794266f, 
    -0.06327801f, -0.13957781f, -0.05144292f, -0.04823440f, -0.48601168f, -0.19795790f, 0.07957216f, 0.21082661f, 
    -0.20781033f, 0.03171515f, 0.20437646f, -0.07753330f, 0.28160617f, 0.11130779f, 0.34275764f, 0.21951726f, 
    0.09344086f, 0.83145863f, -0.16940771f, -0.03433381f, -0.03221835f, 0.01662060f, 0.20117801f, -0.22991987f, 
    0.24353905f, -0.09476791f, 0.27499083f, 0.00936110f, -0.62778091f, -1.43866467f, -0.22601926f, 0.25712609f, 
    -0.26544589f, 0.16016623f, 0.15003446f, -0.11524493f, -0.00730008f, 0.03669306f, 0.08267726f, -0.10660623f, 
    0.11187678f, -0.24168070f, -0.29008561f, -0.36605561f, -0.10004980f, -0.10095755f, 0.09027015f, -0.14086437f, 
    -0.01327151f, 0.07508976f, -0.18965112f, -0.54603517f, 0.41299057f, 0.17966467f, 0.10017166f, 0.01463021f, 
    0.04800962f, -0.08975811f, -0.02989982f, -0.06624009f, 0.00101993f, 0.12633060f, 0.07226906f, -0.09313539f, 
    0.11644283f, 0.22775048f, -0.11339431f, 0.04091611f, -0.09660237f, 0.01206623f, -0.04612431f, 0.03214047f, 
    0.09744138f, -0.03624097f, 0.15624915f, 0.09043086f, 0.19224052f, -1.57656312f, 1.09561539f, -0.34378332f, 
    -0.03598143f, 0.01370580f, -0.10054200f, 0.22060715f, 0.01326883f, 0.00722986f, -0.03227033f, -0.08857414f, 
    -0.03970015f, -0.07410411f, 0.02268479f, -0.14460605f, -0.03980440f, -0.53984565f, -0.14376399f, -0.18662164f, 
    0.04619305f, 0.05515476f, 0.00162272f, 0.03965589f, -0.02572649f, -0.04563781f, -0.19448146f, 0.02218559f, 
    -0.12873578f, -0.04964883f, 0.31446624f, -0.23660146f, -0.05592476f, -0.07964298f, 0.00126154f, 0.06907959f, 
    0.00848726f, -0.11014821f, 0.13613611f, -0.11520440f, -0.03910132f, 0.15022460f, -0.07805359f, -0.13685210f, 
    -0.04459750f, -0.05728943f, 0.03067460f, -0.02978583f, 0.12865075f, 0.20797862f, 0.05181972f, -0.18414243f, 
    -0.00041824f, -0.10229752f, -0.08383500f, 0.03937665f, 0.03142003f, -0.08018298f, 0.01656922f, -0.02544783f, 
    -0.77404892f, -0.41153193f, 0.23598273f, 0.11379944f, -0.05477863f, -0.02908256f, -0.06400552f, 0.20289114f, 
    -0.11606228f, 0.08438385f, 0.15103941f, -0.05365667f, 0.02910106f, 0.09698985f, -0.02708540f, 0.08335599f, 
    0.04509053f, 0.05908313f, 0.06388476f, -0.14607631f, 0.09680970f, -0.00005643f, 0.05327112f, -0.03190421f, 
    0.13295890f, 0.12809022f, -0.14456651f, -0.12274443f, -0.00948041f, -0.04707260f, -0.01529936f, -0.04010994f, 
    0.13517626f, 0.07748035f, 0.03299419f, 0.18487813f, 0.51023811f, 0.12437034f, -0.01438079f, -0.24141040f, 
    -0.26962283f, 0.04384808f, 0.12276388f, 0.06043785f, -0.06685024f, 0.19706959f, -0.00464471f, -0.05207685f, 
    -1.05239177f, -0.97068095f, -0.30403551f, 0.73830819f, 0.13437794f, 0.07713950f, -0.05611072f, -0.08989175f, 
    0.04168551f, -0.04350527f, -0.05700550f, -0.00852669f, 0.87648278f, -0.74450725f, -0.33886772f, -0.39375484f, 
    0.02054945f, -0.10433660f, -0.17530596f, 0.06396976f, 0.11901910f, 0.08528211f, 0.08673736f, 0.11349209f, 
    -0.24803390f, -0.22452147f, -0.32346129f, 0.20036042f, -0.02636662f, -0.16638419f, 0.55117559f, -0.23875548f, 
    -0.19252902f, 0.20513940f, 0.04113704f, 0.01992067f, 0.15743434f, -0.67952192f, -0.50554806f, 0.08251493f, 
    -0.11599001f, 0.11310473f, -0.02140891f, 0.10615572f, -0.09300724f, -0.07403138f, -0.14441325f, 0.03422342f, 
    0.43380070f, 0.34898779f, -0.08742376f, -0.35426471f, 0.18773979f, -0.08786929f, -0.15951116f, 0.19593516f, 
    0.32862726f, -0.08954403f, 0.09391128f, 0.34123197f, 0.04826514f, -0.05966372f, -0.09170660f, -0.43996868f, 
    -0.23783116f, -0.23236232f, -0.02670684f, -0.08301222f, -0.10970487f, -0.04285459f, 0.04006036f, -0.29960486f, 
    -0.95534241f, 0.40187669f, 0.22339913f, 0.34907380f, 0.08881017f, -0.00571930f, -0.14252891f, -0.10213193f, 
    -0.22597413f, -0.03486616f, -0.12146057f, -0.17732315f, 1.08211541f, 0.22009626f, 0.01874453f, -0.84884328f, 
    -0.07867422f, -0.29846752f, -0.21599415f, -0.32698050f, 0.05657393f, 0.12385186f, 0.00402928f, 0.12940408f, 
    0.14098391f, 0.04799082f, 0.01388436f, -0.07079161f, -0.10534421f, 0.01805850f, -0.20034383f, -0.11937460f, 
    0.00893302f, 0.29737544f, 0.25320289f, 0.03345681f, -0.39590985f, -0.72272563f, 0.02002797f, 0.10650648f, 
    0.14618663f, 0.43984833f, 0.10041443f, 0.43337688f, -0.50702000f, 0.04208844f, -0.06292959f, -0.31487918f, 
    -0.18432945f, 0.38061768f, -0.06785792f, 0.20311217f, 0.34100759f, -0.13004358f, 0.01875065f, -0.22089292f, 
    0.02654209f, 0.05466358f, 0.29622912f, 0.26249519f, -0.02435582f, -0.00018389f, -0.06469668f, -0.09280117f, 
    -0.15044351f, -0.16171743f, -0.06647235f, -0.04149920f, -0.03049207f, -0.03237954f, -0.03022708f, 0.08339869f, 
    -0.61729938f, -0.33573940f, 0.29415599f, 0.25241143f, -0.08388765f, 0.09258533f, 0.01239988f, 0.36698359f, 
    -0.06416585f, -0.07235873f, 0.00669119f, 0.04156772f, -0.48072749f, 0.35102829f, 0.26993406f, 0.04117325f, 
    -0.26560512f, -0.09855421f, -0.09546740f, -0.10160892f, -0.11000315f, -0.22819848f, -0.22813897f, 0.11493880f, 
    -0.03881290f, -0.04334557f, 0.27669430f, 0.14857346f, 0.07685721f, 0.12564749f, 0.07364347f, -0.09577587f, 
    -0.21048734f, 0.05825535f, -0.10084591f, -0.27229473f, 0.09782834f, -0.18148322f, -0.19460592f, -0.23453858f, 
    0.04298335f, -0.05497121f, 0.08374423f, -0.28328916f, 0.00672957f, 0.23152424f, 0.22787297f, 0.21374701f, 
    -0.28610334f, -1.10387659f, -0.17676561f, -0.12481534f, 0.09713891f, 0.02888399f, 0.07312699f, 0.32614139f, 
    0.06155810f, 0.04632022f, 0.07134647f, 0.08421160f, -0.07227432f, 0.23511188f, -0.08110642f, 0.13710932f, 
    0.15992740f, 0.12228522f, 0.04583166f, 0.08545737f, -0.13386717f, -0.09241460f, -0.25224298f, -0.59598684f, 
    -0.52789110f, -0.64866394f, 0.33909217f, 0.02372419f, 0.17569527f, 0.35182029f, 0.01092194f, -0.03544071f, 
    0.24532309f, 0.24860570f, -0.06918037f, 0.28396979f, -0.26285326f, -0.74534488f, -0.51479995f, -0.14456710f, 
    0.14151537f, -0.25433728f, 0.19154258f, 0.01274092f, 0.10936362f, -0.09307857f, 0.11044066f, -0.00279772f, 
    -0.34154961f, 0.35568067f, -0.30407310f, 0.41677511f, 0.16250634f, -0.18006505f, -0.05311724f, -0.03891236f, 
    0.13810593f, -0.21315248f, 0.08435955f, -0.07979019f, -0.18082349f, 0.08728870f, 0.22973740f, 0.44689327f, 
    0.02937219f, -0.07105949f, -0.16190758f, -0.04581908f, 0.05630306f, 0.23320106f, 0.22653069f, 0.13267925f, 
    -0.21014674f, -0.37336630f, -0.43953457f, -0.05689088f, 0.17037712f, 0.15963937f, 0.28463894f, 0.08202962f, 
    -0.00059451f, -0.13027652f, 0.03774310f, 0.14540759f, -0.13285322f, -1.51241446f, 0.34649974f, -0.17376314f, 
    -0.13283578f, 0.06297877f, -0.13070193f, 0.17421202f, -0.13013974f, 0.09539589f, 0.10445537f, -0.10107311f, 
    -0.00407832f, -0.10632616f, -0.12979025f, -0.11306252f, 0.45346418f, 0.11304045f, -0.02106010f, -0.00823320f, 
    0.12863719f, -0.19787423f, -0.23088852f, -0.12833919f, -0.51947528f, 0.64851969f, -0.05215332f, -0.50874060f, 
    -0.49275431f, -0.48047417f, 0.03123032f, -0.56289208f, -0.03110318f, 0.02505432f, 0.11202869f, 0.13554846f, 
    0.08520461f, -0.03743682f, -0.47309038f, 0.04279662f, 0.12494414f, 0.15291394f, 0.30446845f, -0.21464491f, 
    0.02800593f, -0.09740220f, -0.25951257f, -0.03310524f, -0.04983494f, -0.74257863f, 0.29619864f, 0.16253376f, 
    0.17774768f, 0.29920718f, -0.00994331f, -0.02249497f, -0.09416930f, 0.15442769f, -0.00753863f, -0.11155999f, 
    0.08296422f, 0.73991692f, 0.76123011f, -1.19197178f, -0.26892707f, -0.13200618f, 0.19113249f, -0.09620497f, 
    -0.05603161f, -0.08136582f, -0.08061625f, 0.25150403f, -0.18792447f, -0.32305065f, 0.02659268f, -0.21414810f, 
    0.21282312f, -0.02524275f, 0.18298395f, -0.01540374f, 0.18042496f, 0.22442494f, 0.01728308f, 0.27275842f, 
    0.37769434f, -0.03573467f, -0.55451185f, -0.20344219f, 0.46990818f, 0.00524540f, 0.18179895f, 0.22858812f, 
    0.09195115f, -0.14312236f, -0.24389337f, 0.03790915f, 0.07651147f, -0.09002236f, -0.29349720f, 0.19980282f, 
    0.08035757f, 0.20341171f, -0.08891419f, 0.07332678f, 0.06221622f, -0.36343551f, 0.03212381f, -0.23118559f, 
    -0.03813444f, -0.12359565f, 0.16745296f, -0.39050901f, 0.04134727f, -0.37149218f, -0.05710953f, 0.20386446f, 
    -0.05629625f, -0.13831860f, -0.02261898f, -0.03041197f, 0.02220723f, -0.02113525f, 0.14652908f, 0.41213581f, 
    -0.07942376f, 0.12811221f, -0.17814930f, -0.04104346f, 0.05674105f, 0.06279143f, 0.08843709f, 0.13865945f, 
    0.00116487f, -0.53733861f, 0.38272437f, -0.86102927f, 0.19252998f, -0.62251401f, -0.22084002f, -0.08665472f, 
    -0.30781201f, -0.01422099f, 0.07314812f, -0.13953322f, -0.23254690f, 0.27358255f, 0.28922701f, -0.18584538f, 
    -0.01093710f, -0.09771295f, 0.06901629f, -0.06043934f, 0.08888452f, 0.11308804f, 0.24505877f, -0.21875559f, 
    -0.63484752f, 0.23425938f, 0.00361766f, 0.18745057f, 0.02337701f, -0.07691172f, 0.08742154f, 0.28982869f, 
    -0.11121450f, 0.06125175f, 0.18253718f, 0.07045533f, -0.25244755f, -0.19340467f, 0.12189931f, -0.68019283f, 
    -0.22038206f, 0.12224393f, -0.08580171f, -0.39918578f, 0.14538024f, 0.02474833f, -0.62422109f, -0.38253000f, 
    0.19893371f, -0.31709787f, -0.32796222f, 0.59474468f, -0.50136840f, -0.06365415f, -0.13775748f, -0.07602230f, 
    -0.23589690f, 0.01014024f, -0.09032717f, -0.15254951f, -0.72510409f, 0.20832485f, -1.00096846f, 0.67612451f, 
    -0.04739637f, 0.34637737f, -0.13147859f, 0.10056849f, 0.14751691f, 0.04077072f, 0.01224821f, 0.12763306f, 
    -0.60508168f, 0.05989899f, 0.21361315f, -0.35825494f, -0.06596790f, 0.05789034f, 0.13415846f, -0.02198371f, 
    -0.24415521f, 0.09319717f, 0.48769227f, -0.03726240f, 0.40834215f, -0.47876072f, 0.21378835f, -0.11150806f, 
    -0.01767011f, -0.31563216f, 0.19298483f, -0.05173071f, 0.09946571f, 0.31447476f, -0.26164672f, -0.40406516f, 
    -0.09363157f, 0.35845670f, -0.72476143f, -0.11753589f, -0.01861752f, -0.11358320f, 0.28641984f, -0.20744579f, 
    -0.08916940f, 0.12363984f, 0.01472856f, 0.14224544f, -0.42725259f, -0.34351534f, -0.40591359f, 0.11219276f, 
    -0.34685066f, -0.02496331f, -0.08373161f, -0.20930241f, 0.43668613f, -0.16420569f, -0.18601784f, 0.13991326f, 
    0.02755068f, 0.11896317f, 0.22383824f, 0.36802930f, -0.15196708f, 0.20277111f, 0.23358646f, -0.04895259f, 
    -0.31867155f, 0.04129242f, 0.14381720f, 0.18924753f, 0.00709391f, 0.20175144f, -0.13969412f, 0.04637163f, 
    -0.21567856f, -0.32802659f, -0.10206994f, 0.06220891f, 0.04334609f, 0.01816774f, -0.57505232f, -0.11436575f, 
    -0.28117201f, -0.32051224f, -0.06542995f, -0.23530251f, -0.31360328f, 0.13750534f, -0.30835900f, 0.07349919f, 
    -0.10309205f, -0.05890877f, -0.25117958f, -0.08809640f, -0.00027565f, 1.10571218f, 0.57537699f, 0.10216955f, 
    -0.05869384f, -0.08165778f, -0.03131617f, 0.04799133f, 0.14090884f, 0.51105458f, 0.23053993f, 0.17238735f, 
    -0.32195261f, -0.00753011f, -0.28020653f, 0.19012709f, -0.21596116f, 0.01712953f, 0.23005983f, 0.22870636f, 
    -0.07748151f, 0.17186387f, 0.12081686f, 0.02667766f, 0.32342857f, 0.02593691f, -0.10397281f, -0.19849426f, 
    0.11172625f, 0.25533289f, -0.10183595f, 0.14389893f, -0.31992903f, -0.16215889f, -0.48717609f, -0.51007456f, 
    -0.49113086f, 0.30550361f, 0.05592196f, 0.37482995f, 0.13101719f, 0.02081307f, -0.06146762f, 0.57908982f, 
    0.05175582f, 0.14667714f, 0.20467313f, -0.24172193f, 0.05566333f, -0.27195993f, -0.19323060f, -0.12186931f, 
    -0.12424766f, -0.03012514f, 0.07334940f, 0.18055178f, -0.07683824f, 0.16390808f, -0.07810701f, -0.23961295f, 
    -0.21578139f, -0.01369095f, -0.20920952f, -0.12878834f, 0.27043077f, 0.00309522f, 0.04935586f, -0.03283140f, 
    0.10594132f, 0.15756178f, 0.12091751f, 0.13633414f, -0.37517998f, -0.15509839f, -0.33164817f, -0.24945451f, 
    -0.05989438f, 0.00605402f, -0.01702900f, -0.06675655f, 0.10304813f, -0.08718499f, -0.01495755f, 0.30983990f, 
    0.53167003f, 0.16055512f, 0.23464933f, -0.18935488f, -0.19043563f, -0.25373265f, -0.05720232f, -0.15146829f, 
    -0.09616832f, 0.10404170f, -0.04953912f, -0.12596901f, -0.68195468f, 0.03455676f, -0.43376079f, 0.67323554f, 
    -0.10449363f, -0.27327526f, 0.08660638f, -0.07824738f, -0.00619482f, 0.06185526f, 0.16503525f, -0.03013842f, 
    0.18106401f, 0.53332800f, -0.11084197f, 0.31167284f, -0.14974137f, 0.19117786f, -0.06125412f, 0.11835918f, 
    -0.18610057f, -0.06947494f, 0.02731342f, -0.14379597f, 0.40727857f, -0.33613306f, 0.37159809f, -0.87974030f, 
    -0.08330148f, 0.03833966f, -0.07832809f, -0.12722433f, -0.00645862f, 0.15050222f, 0.01342994f, 0.10416392f, 
    0.75995976f, -0.23692358f, 0.49018371f, 0.43371141f, 0.13182487f, 0.10466220f, 0.06409086f, -0.05713921f, 
    -0.39080250f, -0.07264206f, -0.12057654f, -0.24903592f, 0.08882221f, 0.26892656f, -0.16147721f, -0.23296754f, 
    -0.07112381f, -0.11046664f, 0.01022282f, -0.09057236f, -0.15784629f, 0.15058334f, 0.01205362f, -0.29338506f, 
    -0.17916569f, 0.11159428f, 0.00021080f, 0.53247154f, -0.07909121f, 0.00144126f, 0.12653422f, -0.25397807f, 
    0.04585347f, 0.14523031f, -0.13243827f, 0.22233303f, 0.19816346f, -0.14010830f, 0.59023845f, -0.09417720f, 
    -0.25764072f, 0.01234729f, -0.21178752f, 0.06564011f, -0.25951996f, -0.22489166f, 0.25938275f, 0.04604593f, 
    0.39017549f, 0.08429389f, 0.46957704f, -0.32438290f, 0.21594328f, -0.25825578f, 0.20004104f, 0.00040272f, 
    0.17075734f, 0.08023190f, 0.12598042f, 0.16870634f, -0.57438862f, -0.39473403f, 0.17992258f, -0.07576390f, 
    0.28411096f, 0.01547421f, 0.01866020f, 0.07790682f, -0.13717827f, -0.57535106f, -0.15949050f, 0.06394282f, 
    0.13377999f, -0.20541476f, -0.24345350f, -0.23500228f, 0.15948257f, -0.22756247f, -0.46460015f, -0.18485692f, 
    -0.03075850f, 0.01527166f, -0.04822764f, -0.18725979f, -0.57028669f, 0.07778849f, -0.44887215f, -0.05042559f, 
    0.14452225f, -0.13768926f, 0.11753527f, -0.05515641f, -0.09141713f, -0.04192165f, 0.04530878f, 0.14211181f, 
    -0.62047875f, -0.64549911f, 0.12727724f, 0.49815327f, -0.15069793f, 0.46340168f, 0.10330445f, 0.59508997f, 
    -0.46741462f, -0.19834895f, -0.16766536f, 0.04852069f, 0.23926333f, -0.39118317f, 0.41102231f, -0.78394783f, 
    0.16819587f, -0.21166356f, 0.18804513f, -0.01642382f, 0.17749576f, 0.28085744f, 0.15029424f, 0.01997336f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.21989283f, 0.08030629f, 0.27342185f, -0.10238688f, -0.15551235f, 0.19600408f, 0.08174086f, -0.22817671f, 
    0.13860540f, 0.02681978f, 0.01381953f, -0.04484228f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
