#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.48372796f, 0.41233107f, -0.42397678f, -0.02442252f, 0.48823792f, 0.14515427f, 0.16289510f, 0.41615111f, 
    0.05499286f, 0.97438467f, -1.06146252f, -0.86050415f, -0.35292876f, -0.37537634f, -1.08715248f, 0.09746792f, 
    0.19237779f, 0.39070889f, -0.01224750f, 0.28402284f, -0.42574322f, 0.54234219f, 0.39761192f, 0.58472323f, 
    -0.58921647f, 0.00766032f, 0.02080243f, -0.41208431f, -0.25510189f, 0.25646970f, 0.07324884f, -0.82786334f, 
    0.62261665f, -0.04889035f, 0.17050473f, 0.40930423f, -0.46106943f, 0.65617740f, 0.28320661f, -0.58171690f, 
    -0.09692253f, 0.49246624f, -0.49627593f, 0.01218017f, 0.55416596f, -0.62032074f, -0.67156154f, -0.18541026f, 
    -0.92761654f, -0.34687129f, -0.74355704f, -0.30070534f, -0.83000487f, -0.96483016f, 0.64825511f, 0.16367601f, 
    0.02440948f, 0.52281064f, 0.05321530f, -0.22413205f, 0.24935885f, 0.24852180f, -0.35708219f, -0.89012641f, 
    -1.02083623f, -0.45386150f, -0.10194947f, -0.95575619f, -0.16842076f, 0.11147164f, -0.06783512f, -0.36995748f, 
    0.97381324f, 0.74650073f, -1.07520032f, -0.29616454f, -0.56132722f, -1.14540541f, -0.54427320f, -0.00423183f, 
    -0.34016070f, 0.28197458f, -0.54637766f, -0.43032491f, -0.66728097f, -0.28939739f, 0.11652853f, 0.16494595f, 
    -0.68407387f, 0.82029569f, -0.81351137f, 0.68001151f, 0.11592611f, 0.68220121f, -0.00346535f, -0.72638774f, 
    0.29324275f, 0.64581686f, -0.78564131f, -0.76089734f, 0.54786038f, 0.30038047f, -0.82106513f, -0.78547400f, 
    0.63402176f, 0.23582841f, 0.14906283f, 0.27692401f, 0.02567435f, -1.21827507f, -0.67854863f, -0.03166336f, 
    0.27858642f, 0.57210058f, 0.26975304f, -0.16903450f, 0.37108606f, 0.60121167f, -0.96609002f, 0.35978112f, 
    0.18643868f, 0.05118901f, -0.18666726f, -0.35530022f, 0.14777103f, 0.39264017f, 0.29032916f, 0.17811444f, 
    -1.05908775f, 0.14659099f, -0.03234660f, -0.47454986f, -0.72847784f, -0.37587830f, -0.76532805f, 0.34107217f, 
    0.80001402f, -0.30912036f, -0.75361675f, -1.02037179f, -0.59476471f, 0.30214024f, 0.27609652f, 0.41545495f, 
    -0.47439381f, -0.62213606f, -1.18831360f, -0.34063438f, 0.48533827f, 0.57471198f, -0.32138184f, -0.40176511f, 
    -0.43286741f, 1.04070163f, 0.25558844f, -0.64185375f, -0.26278481f, 1.14505994f, 0.10421073f, -0.71466041f, 
    -0.07675280f, -0.47853431f, -0.52435720f, -0.50137156f, -0.95975953f, 0.49589297f, 0.52053565f, 0.64344597f, 
    0.27057785f, -0.14504249f, 0.24022216f, 0.79539526f, 0.43716469f, -0.71976322f, 0.26848620f, -0.11227800f, 
    -0.35483277f, -0.27078843f, 0.74357653f, -0.31908858f, -0.51050413f, -0.27225676f, 0.34544426f, -0.39020777f, 
    -0.17129360f, -0.54815990f, 0.54932666f, 0.63945818f, 0.18514271f, -0.12160324f, -0.47114888f, -0.85090876f, 
    -0.37637380f, -0.13347740f, -0.84438694f, 0.26138741f, 0.42759404f, 0.17184663f, -1.28964138f, 0.33364329f, 
    0.18290174f, -0.38940620f, -0.27035701f, 0.96715212f, 0.09583373f, 0.14037535f, -0.13665824f, -0.83498257f, 
    0.50319111f, 0.58393192f, 0.08253959f, 0.50239366f, -0.44952762f, -0.65168881f, 0.53393185f, -0.30144900f, 
    1.06300950f, 0.09479259f, 0.12085585f, -0.64782166f, -0.36382261f, -0.52315050f, 0.23673917f, -0.07505612f, 
    0.40530473f, -1.20316255f, -1.02461159f, 0.54576820f, -0.02813149f, 0.66726780f, 0.37785375f, 0.15179358f, 
    -0.18321633f, -0.03351618f, -0.75866812f, -1.07389092f, -0.37453139f, 0.36769044f, 0.48845956f, -0.30919665f, 
    0.36924317f, -0.07138169f, 0.43054166f, 0.18611763f, 0.19258891f, 0.32935709f, -0.84745300f, -0.12193966f, 
    0.44640797f, 0.21798640f, 0.07559190f, 0.09817027f, 0.61752027f, -0.26602513f, 0.10134337f, 0.81867844f, 
    -0.37546727f, -0.61437190f, -0.14549428f, -0.40382874f, 0.56033701f, -1.24216139f, -0.10307263f, 1.16963482f, 
    -0.53190565f, -1.01625729f, -0.69340152f, -0.29297739f, 0.28588650f, -0.39989132f, -0.29532748f, 0.08057401f, 
    -0.55446208f, 0.06376620f, 0.08334265f, -0.15851563f, 0.29341671f, 0.49654284f, 0.41586125f, -0.66402322f, 
    -0.51380777f, -0.60968745f, -0.36520553f, -0.73115522f, 0.21133064f, 0.51977372f, -0.36637381f, -0.40665475f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.26089403f, 0.20446812f, 0.55789804f, 0.19334251f, 0.39808562f, -0.43665588f, -0.02444614f, -0.35240427f, 
    -0.13582347f, 0.20001124f, 0.11727229f, 0.39190513f, 0.27931526f, 0.20051560f, 0.03062001f, -0.06966802f, 
    0.08594757f, 0.21729091f, 0.08865897f, 0.14599259f, 0.14224401f, -0.10986189f, 0.02538729f, 0.20390695f, 
    -0.03040531f, -0.03502643f, 0.09779279f, 0.30199388f, 0.17754538f, 0.37866387f, -0.14040409f, -0.31609279f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.01318959f, -0.00646718f, -0.00638370f, 0.06497128f, -0.00216573f, 0.06174036f, -0.03224980f, 0.00420942f, 
    0.07492195f, 0.07419778f, -0.20860276f, -0.17508967f, -0.39663398f, -0.18057489f, -0.21982707f, -0.01017086f, 
    0.00809445f, -0.04104004f, 0.02463053f, -0.02943363f, 0.31213892f, 0.27005422f, -0.30198821f, -0.19969350f, 
    -0.14656839f, 0.00875403f, 0.02034000f, 0.07423857f, -0.26518312f, -0.00784860f, -0.03318859f, 0.02093183f, 
    0.00057862f, 0.05423415f, 0.05255468f, -0.00752803f, -0.01110828f, 0.01287970f, 0.07598623f, 0.21030477f, 
    -0.37818083f, -0.27420527f, -0.28338605f, 0.09381808f, -0.02701795f, -0.02947582f, 0.02810219f, -0.03937234f, 
    0.04488572f, 0.03377986f, -0.08769286f, -0.03651981f, -0.04196319f, -0.05139077f, -0.07176194f, -0.03032372f, 
    -0.00750683f, -0.01754458f, -0.00315885f, -0.07486739f, 0.02816010f, 0.02425779f, 0.20019463f, -0.12335087f, 
    0.08014004f, -0.02696503f, 0.03702359f, 0.05119671f, 0.01249448f, -0.04515589f, 0.02722863f, -0.22183985f, 
    0.00454443f, -0.02634932f, 0.00937285f, -0.03016595f, -0.17033306f, -0.07563883f, 0.00846760f, -0.06520379f, 
    -0.58800870f, -0.51206738f, 0.23524900f, 0.09398887f, -0.10665406f, -0.03614678f, -0.15402296f, -0.11562770f, 
    0.02562382f, -0.11942746f, 0.00760319f, 0.03275721f, -0.09960467f, 0.06892992f, -0.05701598f, -0.17386062f, 
    -0.15627213f, -0.11135641f, -0.15572099f, -0.09266268f, 0.43718207f, 0.26707754f, 0.23357841f, -0.37021300f, 
    0.03027718f, 0.10527988f, 0.19931188f, 0.21186997f, 0.05671494f, 0.01050726f, -0.01831546f, -0.01942681f, 
    -0.00603183f, -0.14615925f, -0.17882960f, -0.01488367f, -0.24384850f, -0.17221233f, 0.15969585f, 0.11735462f, 
    -0.04881271f, -0.02555936f, -0.12247127f, 0.06838138f, 0.03202906f, 0.04637354f, 0.06844436f, 0.06313938f, 
    0.05498043f, 0.08278419f, -0.03415836f, 0.05075337f, 0.01894900f, 0.07726064f, 0.04492370f, -0.09889457f, 
    -0.13820685f, -0.08756635f, 0.02016077f, 0.02152222f, 0.44750234f, 0.23472971f, 0.18345846f, -0.45037666f, 
    -0.05045339f, 0.25846562f, 0.26894179f, 0.22447936f, -0.09636319f, 0.14492850f, 0.00264435f, 0.00992901f, 
    -0.02196269f, -0.00594189f, 0.02945128f, 0.02119819f, -0.07143011f, -0.03768894f, -0.12543379f, 0.01659055f, 
    -0.28302488f, 0.22532918f, -0.50422192f, -0.02457213f, -0.53452915f, 0.00784728f, -0.09780657f, -0.12423228f, 
    -0.08228919f, 0.17187884f, -0.02195792f, -0.04410475f, -0.03917998f, 0.06247672f, 0.05120239f, -0.07865680f, 
    0.09452342f, -0.01312578f, -0.03822795f, 0.07557653f, 0.11002765f, 0.29540840f, 0.22172716f, -0.62398577f, 
    -0.15228763f, 0.00965086f, -0.01429632f, 0.07634141f, -0.09106985f, -0.09769195f, -0.09888127f, 0.00148280f, 
    0.01337010f, -0.01218760f, 0.01576917f, -0.01706897f, -0.10056641f, 0.03389129f, -0.18296057f, -0.14258957f, 
    -0.03762616f, 0.19284604f, -0.27857533f, 0.05735575f, 0.03588964f, -0.21266067f, 0.10691479f, -0.12050550f, 
    -0.01324598f, 0.02355566f, -0.25537091f, -0.10789562f, -0.28075996f, -0.13295427f, -0.38735205f, -0.11444008f, 
    0.02010129f, -0.00088653f, -0.29705656f, 0.02307736f, -0.00821170f, 0.12571682f, 0.27835184f, -0.14074969f, 
    -0.01399941f, -0.33724827f, -0.08825568f, -0.03736847f, -0.02158026f, -0.10714024f, 0.02787567f, -0.08146751f, 
    -0.07868647f, -0.09819512f, -0.02220563f, -0.03135486f, -0.01716997f, -0.00509580f, -0.23140410f, -0.09662660f, 
    0.32808822f, 0.15216264f, -0.14808325f, -0.01846445f, 0.09708212f, 0.13274387f, 0.03696790f, 0.17744374f, 
    -0.22529322f, -0.11359614f, -0.15637913f, -0.11691295f, -0.11330863f, 0.04833238f, 0.00393704f, 0.05558214f, 
    0.09336695f, 0.00281873f, -0.02147530f, 0.00142422f, -0.00149730f, -0.01100277f, 0.02189155f, 0.00978105f, 
    0.08155164f, 0.04293303f, 0.03665249f, 0.02850719f, -0.04166838f, 0.01690657f, 0.04188536f, -0.09674381f, 
    -0.07531148f, -0.03317539f, -0.07567234f, -0.02413904f, 0.08897260f, -0.07734019f, -0.12569444f, -0.08998262f, 
    0.04032364f, 0.07133378f, 0.18191546f, -0.12805089f, -0.23990785f, -0.18168989f, -0.01037660f, -0.14017828f, 
    -0.11569903f, 0.04407775f, -0.04823601f, -0.06977485f, -0.05525399f, -0.07138956f, -0.03416256f, 0.10247389f, 
    -0.02586901f, 0.02006393f, 0.07775529f, 0.08111312f, 0.29182342f, 0.27857599f, -0.07926565f, -0.06086095f, 
    -0.19597456f, 0.05799368f, -0.05620094f, -0.17018360f, 0.07790983f, 0.16719691f, 0.02641331f, -0.03844614f, 
    0.04421580f, 0.03516375f, -0.01451319f, -0.02310271f, 0.00703104f, 0.06240224f, -0.06895879f, -0.05851810f, 
    0.35578504f, 0.02135873f, -0.10273819f, -0.04276603f, -0.08787134f, 0.13320850f, 0.07846543f, 0.25690866f, 
    -0.07659585f, -0.02404978f, -0.00266522f, 0.03146108f, -0.02766449f, -0.07025008f, -0.08542687f, -0.00529364f, 
    0.03803242f, -0.05065053f, -0.04982815f, -0.07887197f, -0.59522748f, -0.72332102f, -0.09108414f, 0.40236744f, 
    -0.49774310f, 0.07693107f, 0.06707992f, -0.07200294f, 0.04002459f, 0.11493657f, 0.11871246f, 0.06988113f, 
    -0.00724267f, -0.01973689f, 0.01307401f, -0.04512258f, 0.06969588f, 0.08706251f, -0.09985483f, 0.14379062f, 
    0.18226947f, -0.17857243f, -0.20670834f, -0.00691486f, 0.09759381f, 0.15187496f, 0.10373649f, 0.10523067f, 
    0.00809278f, 0.02568996f, -0.03795679f, -0.02561256f, -0.15481298f, 0.03195506f, 0.07863223f, 0.00281555f, 
    0.08859492f, 0.03195680f, 0.01862944f, -0.01336819f, -0.32206753f, -0.14689513f, -0.47287124f, 0.16840197f, 
    -0.04055406f, 0.02539650f, -0.02477219f, -0.10303079f, 0.03062697f, 0.06726345f, -0.09488899f, 0.11093888f, 
    -0.06662268f, -0.09129609f, 0.01063095f, -0.21394569f, 0.00341896f, -0.19008279f, -0.07577892f, -0.02656475f, 
    0.20565382f, 0.22618230f, 0.05385137f, -0.15896013f, -0.01313128f, -0.11285667f, 0.03517165f, 0.02545935f, 
    -0.00921360f, 0.04254884f, 0.00960982f, -0.10357291f, -0.02817576f, 0.03374956f, -0.00253785f, -0.01621733f, 
    -0.01572074f, -0.07618821f, -0.05220544f, 0.02222225f, 0.38835877f, 0.42054170f, -0.14971329f, -0.18963225f, 
    -0.11881388f, 0.13750260f, -0.03374813f, 0.21263567f, -0.10194352f, 0.02028948f, 0.02368895f, -0.06045051f, 
    0.05874768f, 0.02375445f, 0.04414415f, -0.02415771f, -0.05388874f, -0.07783521f, 0.04088609f, 0.01939242f, 
    -0.24611378f, -0.08971598f, 0.35356405f, -0.06842988f, 0.12330623f, -0.06435718f, 0.06322780f, 0.16624478f, 
    0.05436893f, 0.02597615f, -0.05148648f, -0.15371166f, 0.00920529f, 0.02837755f, 0.06794790f, -0.03188589f, 
    -0.09569305f, 0.00437224f, -0.01244269f, -0.03980057f, -0.48752648f, 0.03819755f, -0.15027863f, -0.03580399f, 
    -0.17335230f, -0.04194466f, -0.06718707f, -0.02630186f, 0.15577942f, 0.07453576f, -0.02295482f, 0.01976463f, 
    0.00609569f, -0.15845215f, -0.08718752f, -0.04622758f, 0.03199175f, -0.03534346f, 0.00924074f, 0.06574586f, 
    0.08804546f, 0.12273911f, -0.04301764f, -0.15820162f, -0.20377675f, -0.06311130f, -0.04403206f, -0.09462121f, 
    -0.15660857f, -0.14267170f, -0.00556553f, 0.07082212f, 0.01682387f, 0.05528623f, -0.02705286f, -0.02659301f, 
    0.00954022f, -0.00029681f, -0.26822230f, -0.07583741f, 0.25300181f, -0.01032981f, 0.01469263f, -0.12481003f, 
    0.07297792f, 0.06924501f, 0.07441755f, 0.17040302f, 0.11141968f, -0.04947806f, -0.02355632f, -0.13143124f, 
    -0.12531316f, 0.11697898f, 0.00730112f, 0.01397113f, 0.05794724f, 0.02725374f, -0.00266034f, 0.00055255f, 
    0.40029988f, 0.32361591f, -0.12099836f, -0.18179835f, 0.03458323f, 0.09624337f, 0.10921042f, 0.19920540f, 
    -0.13026503f, -0.13061406f, -0.04486164f, -0.09163509f, -0.17087808f, -0.00427357f, 0.08232471f, -0.02665412f, 
    0.02269492f, -0.00136047f, 0.06985288f, -0.03400806f, -0.12665759f, -0.01726254f, 0.08443275f, 0.02115436f, 
    -0.06264430f, -0.09714706f, -0.02676565f, -0.00146925f, 0.01133934f, 0.03476698f, -0.07957188f, 0.03390408f, 
    -0.05722927f, 0.02129479f, 0.09263455f, -0.02029965f, -0.06439273f, -0.07320195f, -0.01258073f, -0.06616856f, 
    -0.04594121f, -0.31426382f, -0.31890005f, -0.04439433f, -0.05853696f, -0.06460398f, -0.11369579f, -0.12906477f, 
    -0.02585625f, -0.13790658f, -0.06552722f, 0.00861764f, -0.03613522f, 0.15106852f, -0.03007363f, -0.31681553f, 
    -0.06937127f, -0.27743524f, -0.12378958f, -0.12344224f, 0.26734045f, 0.39460713f, -0.08170817f, -0.39101154f, 
    -0.04261495f, -0.15062274f, -0.03313747f, -0.08572076f, 0.01501129f, 0.04324301f, 0.00371262f, -0.10282870f, 
    -0.10205019f, -0.00988152f, -0.08686005f, -0.08268031f, -0.02744721f, -0.03627120f, 0.12129533f, -0.02209566f, 
    0.09599563f, 0.08082156f, -0.05199357f, 0.08477617f, 0.05081993f, 0.07151654f, 0.01698546f, 0.11581555f, 
    0.06752791f, 0.07381804f, -0.07431874f, -0.14784229f, 0.00806088f, 0.00001134f, 0.03043736f, -0.02452920f, 
    0.02006758f, 0.00075098f, 0.02122497f, -0.02662467f, 0.51394528f, 0.31282637f, 0.20888314f, -0.49478924f, 
    -0.04995893f, 0.23375885f, 0.32754728f, 0.09174795f, 0.01931812f, 0.00638022f, 0.01717264f, -0.01489598f, 
    -0.08357808f, -0.04270138f, 0.07320040f, -0.02972881f, -0.04191551f, 0.01497047f, -0.06890340f, 0.00274008f, 
    0.06483982f, -0.00409184f, 0.06725436f, 0.00827780f, 0.02639232f, -0.03745858f, -0.01499544f, -0.06958610f, 
    0.00737074f, -0.07013692f, 0.23926100f, 0.09192771f, -0.06592852f, -0.04465528f, -0.01179619f, -0.16465221f, 
    -0.06527602f, -0.14106981f, 0.04644944f, 0.01537752f, -0.02137963f, -0.01892020f, -0.31007597f, 0.20898506f, 
    -0.27396160f, -0.07144057f, -0.00628463f, -0.15007320f, -0.08767056f, 0.16873442f, 0.13135055f, -0.04698715f, 
    0.03112066f, -0.00153374f, 0.05345086f, -0.03142053f, -0.02445856f, 0.08295863f, -0.13417470f, 0.16379558f, 
    0.32040092f, -0.02951958f, 0.15854439f, 0.11791732f, 0.07052597f, -0.04366577f, 0.01585215f, 0.06137962f, 
    0.01337461f, -0.03415110f, 0.16411597f, 0.03615668f, -0.13244054f, -0.16596009f, 0.02245790f, 0.05336451f, 
    -0.01947043f, -0.15409951f, -0.00908136f, -0.10688264f, -0.30524763f, -0.05276822f, -0.10715722f, -0.10483199f, 
    0.00217840f, 0.00433303f, 0.08123665f, 0.10475793f, 0.00625338f, 0.11494921f, -0.16219021f, 0.14183927f, 
    0.01489766f, 0.08974394f, -0.01244710f, -0.11898544f, 0.09268803f, 0.04560000f, -0.03348791f, 0.14438380f, 
    0.12322908f, -0.01226511f, 0.11447140f, -0.01054306f, 0.08874368f, -0.00643875f, -0.01636479f, 0.07058223f, 
    -0.07135872f, 0.08489397f, 0.03197936f, 0.08344461f, 0.07172235f, 0.01595121f, -0.05453947f, -0.09152368f, 
    0.30959347f, -0.05082330f, 0.06870054f, 0.09401130f, 0.20606002f, 0.19277689f, 0.11914045f, -0.04795756f, 
    0.20614727f, 0.14341646f, -0.08979861f, -0.12763824f, 0.06965882f, 0.09830192f, 0.02913034f, 0.00567504f, 
    0.06208600f, -0.07747538f, -0.01099071f, -0.14660762f, -0.15400183f, 0.24148005f, -0.19319549f, -0.12572326f, 
    0.28328702f, 0.10886780f, 0.04511551f, 0.19642349f, 0.04910036f, 0.01577455f, -0.08111729f, 0.03720261f, 
    0.00331517f, -0.09752949f, -0.03276340f, -0.03629109f, -0.06184238f, -0.00847482f, 0.06263591f, -0.05635468f, 
    -0.08775334f, -0.05715631f, 0.07497473f, -0.03620134f, 0.08040559f, 0.39428604f, -0.02064491f, 0.29350552f, 
    0.23017615f, -0.27076283f, -0.05268510f, -0.03632924f, -0.11071567f, -0.04701464f, -0.04359645f, -0.00809606f, 
    0.01412474f, -0.02476113f, 0.05440970f, 0.04698560f, 0.08003058f, 0.00585243f, -0.22106168f, 0.06707238f, 
    0.08178479f, -0.16584522f, -0.70233274f, -0.24310192f, -1.01707661f, -0.12540303f, -0.36545351f, -0.30846003f, 
    -0.19555299f, 0.10756665f, -0.04541237f, -0.03689104f, -0.05088880f, 0.03451151f, -0.01139187f, 0.01695973f, 
    -0.02240191f, -0.24951062f, -0.12898669f, -0.03361774f, -0.44176763f, 0.09847441f, -0.29157093f, 0.05815915f, 
    -0.13244736f, -0.11997295f, -0.11139019f, 0.24160941f, -0.18124193f, -0.01308724f, 0.10556933f, -0.01519501f, 
    0.09803960f, -0.11019341f, -0.06372017f, 0.02365466f, 0.03731290f, 0.02982390f, -0.11622138f, -0.21031225f, 
    0.22501703f, 0.01849184f, 0.00814037f, 0.11058398f, -0.16287690f, 0.00989459f, 0.01284669f, -0.03981829f, 
    0.22039689f, -0.25574809f, 0.06369016f, -0.09243347f, 0.18207507f, 0.04384004f, 0.18440671f, -0.01418484f, 
    -0.10054155f, 0.03021358f, 0.11338605f, -0.17176940f, -0.42765921f, -0.20099090f, 0.19082710f, -0.19683793f, 
    0.06405655f, 0.13205776f, 0.13241717f, 0.02662270f, 0.23950535f, 0.15425427f, 0.01433523f, -0.00846984f, 
    -0.00204823f, 0.17286277f, 0.05561809f, -0.00921728f, 0.03139089f, -0.06804877f, 0.13408987f, 0.17568758f, 
    -0.00720360f, -0.08088179f, -0.19780564f, 0.04958571f, -0.17757937f, -0.07805490f, 0.10770085f, 0.24715321f, 
    -0.26856819f, 0.02769673f, 0.13994028f, -0.17101641f, 0.03985513f, -0.08875893f, -0.05822449f, -0.02580927f, 
    0.00485587f, -0.03754001f, -0.07375999f, 0.03516751f, 0.18010794f, -0.01555536f, 0.01488093f, 0.01645924f, 
    -0.05580357f, 0.00653836f, 0.01856047f, 0.05868100f, -0.09538659f, 0.06993602f, -0.09921499f, 0.10785371f, 
    0.12423712f, 0.09242534f, -0.12315577f, -0.10528962f, 0.08888933f, 0.07044481f, 0.05283198f, -0.00721737f, 
    0.20227706f, 0.03739079f, -0.04666302f, -0.03554469f, -0.30682883f, 0.23330118f, 0.06369906f, -0.05120290f, 
    -0.03550794f, -0.08253902f, 0.08674005f, -0.05986447f, -0.02646888f, -0.04728835f, 0.05578048f, -0.35080084f, 
    -0.45663521f, -0.21655601f, -0.17051677f, -0.10604102f, -0.17681077f, -0.08530165f, 0.04348500f, 0.07478964f, 
    -0.16436511f, 0.17606701f, -0.20218846f, -0.29899693f, 0.02795233f, 0.07653438f, -0.08500936f, -0.13328542f, 
    0.03111070f, 0.16681437f, 0.10249953f, 0.01875543f, -0.00263500f, -0.11354823f, 0.06828336f, 0.01194995f, 
    0.01304559f, 0.26741004f, 0.34816134f, 0.07013851f, -0.30441472f, 0.04548648f, -0.07848888f, 0.14065577f, 
    0.02490057f, 0.14097230f, -0.00338100f, -0.02633085f, -0.11637290f, -0.02798321f, -0.02954103f, 0.18850629f, 
    0.08126416f, 0.02802645f, -0.07981747f, 0.04941318f, 1.12063348f, -0.01795735f, 0.20552261f, 0.13722351f, 
    0.12982866f, -0.06119081f, -0.01000658f, -0.00822419f, -0.11387035f, -0.00284064f, -0.11625183f, -0.00290860f, 
    -0.02309316f, -0.05051781f, 0.02853301f, 0.07740871f, -0.02912842f, -0.26904136f, 0.13185255f, 0.05379613f, 
    0.18505514f, -0.31808814f, -0.10798589f, -0.02178917f, -0.15422642f, -0.05886899f, -0.01027437f, 0.09474473f, 
    -0.03976339f, -0.15477256f, 0.07683738f, 0.04161715f, -0.01954548f, -0.08471872f, 0.00673742f, -0.00086393f, 
    0.02205954f, -0.07212066f, 0.01736198f, 0.03015237f, 0.27485868f, 0.05760096f, -0.06664287f, -0.08941671f, 
    -0.05040000f, 0.05888675f, -0.05035791f, -0.06198365f, -0.01008797f, -0.24915327f, 0.01885612f, 0.04318063f, 
    -0.05627067f, -0.04370258f, 0.06931734f, -0.12261537f, 0.06543506f, 0.18128057f, 0.20338342f, -0.00765217f, 
    -0.28236705f, 0.00819172f, -0.11969846f, -0.05068364f, 0.06728814f, 0.01392895f, 0.10009953f, 0.10229004f, 
    0.32275516f, -0.00069248f, -0.05592212f, 0.11443646f, 0.00049781f, 0.10226832f, 0.04718338f, -0.04423996f, 
    -0.01440282f, 0.02130669f, 0.09226189f, 0.00770057f, -0.15639943f, 0.02155944f, -0.11602096f, 0.24058901f, 
    0.02047618f, -0.11849636f, 0.12079619f, -0.11656298f, 0.04080078f, 0.08948550f, 0.06293262f, -0.04334836f, 
    -0.02968396f, 0.04217694f, -0.00586230f, -0.01463982f, 0.01703445f, 0.04815805f, -0.06119006f, 0.12655239f, 
    -0.72577667f, -0.44337228f, -0.08605785f, -0.04953304f, 0.02819808f, 0.05917458f, -0.00230040f, 0.04425428f, 
    0.09691770f, -0.07541291f, -0.20712766f, 0.10207906f, -0.17404747f, 0.04297182f, -0.07827491f, 0.00691462f, 
    -0.00299522f, 0.00143517f, -0.01193859f, 0.01208119f, -0.02354977f, -0.19458775f, 0.17620981f, 0.03236037f, 
    0.30376366f, -0.01889522f, 0.03634246f, -0.07576967f, -0.01405832f, -0.03925861f, 0.11823151f, 0.05023068f, 
    -0.00624970f, -0.02829638f, 0.09510004f, -0.17194609f, 0.15978625f, 0.04899955f, -0.06009234f, -0.08452058f, 
    0.05313539f, 0.09155612f, -0.13970195f, -0.17555837f, -0.09107818f, -0.15337442f, -0.19835825f, -0.16633597f, 
    -0.06989665f, 0.02715438f, -0.03619242f, -0.05981730f, 0.01758947f, 0.13961565f, 0.04362661f, 0.06789258f, 
    -0.06033731f, -0.20982409f, 0.11624018f, 0.00894192f, 0.22821714f, -0.21290287f, -0.16938120f, -0.04904241f, 
    -0.00088798f, -0.06989961f, -0.01028716f, 0.15446721f, -0.00536625f, 0.02681147f, 0.02521705f, 0.01937138f, 
    0.03640360f, -0.11844371f, -0.23050407f, 0.05000602f, 0.00514363f, -0.01193842f, -0.04729076f, -0.06399664f, 
    0.15199420f, -0.14524375f, -0.13406844f, -0.10643753f, -0.02792311f, -0.02701114f, 0.15298682f, 0.30565596f, 
    0.04803787f, -0.21314287f, 0.03939120f, -0.09111072f, 0.13806988f, -0.02219377f, -0.06983110f, -0.04083929f, 
    -0.04982794f, 0.01139298f, -0.07737926f, 0.03069319f, 0.17999502f, 0.04291852f, 0.19689573f, -0.05185737f, 
    0.04116662f, -0.00994536f, 0.04073262f, -0.04015390f, -0.02558752f, 0.00906818f, 0.08195318f, -0.04206173f, 
    -0.02077657f, 0.06207930f, -0.03625112f, 0.00800842f, -0.04132691f, 0.01618016f, 0.03287350f, 0.02280709f, 
    0.20456994f, 0.26386416f, -0.19308832f, 0.06549980f, 0.11777388f, 0.13190925f, -0.05096081f, -0.16339080f, 
    0.03370044f, -0.21605031f, -0.00665911f, 0.07702223f, 0.07751529f, 0.05541673f, -0.12092128f, 0.17422889f, 
    0.34887969f, 0.01366344f, 0.00287537f, 0.08210948f, -0.54805881f, 0.03860094f, -0.42864981f, 0.02841825f, 
    0.08928680f, 0.18624942f, -0.11342565f, -0.13401660f, 0.36323798f, -0.05772654f, -0.01851980f, 0.08921031f, 
    0.14601935f, -0.01338152f, 0.01897433f, -0.09104589f, 0.05296416f, 0.04821796f, -0.27889565f, -0.15152565f, 
    -0.13422534f, -0.11949455f, -0.18053067f, -0.08413444f, -0.08922853f, -0.00673844f, -0.01610604f, 0.02493361f, 
    0.05109251f, 0.01552329f, -0.12540311f, 0.08561516f, -0.07403830f, 0.08197878f, -0.02078378f, -0.04840083f, 
    -0.00550097f, -0.05300846f, 0.03437087f, 0.00721169f, -0.19397591f, 0.43395770f, 0.03339896f, 0.27912709f, 
    0.11057334f, 0.00620417f, -0.17460670f, 0.11691768f, -0.32246408f, -0.18174192f, -0.03351941f, 0.01291175f, 
    0.00923786f, 0.00307959f, 0.05698447f, 0.12615693f, 0.03623508f, 0.01325099f, -0.20777495f, -0.01527415f, 
    -0.00847895f, 0.00814843f, -0.01945269f, -0.12149033f, 0.04719126f, -0.05223927f, -0.05208826f, -0.03050334f, 
    0.06364635f, 0.00912701f, -0.04835403f, -0.14784205f, -0.09096717f, 0.08004253f, 0.03389128f, 0.03463510f, 
    -0.01111235f, -0.08568987f, 0.04302976f, -0.04070272f, -0.71032315f, 0.05604082f, -0.36216220f, -0.03201469f, 
    -0.67593372f, 0.11761361f, 0.12365322f, -0.02355277f, -0.10991152f, -0.26933438f, 0.00884438f, 0.04094845f, 
    0.01517510f, -0.03619114f, -0.05157026f, 0.01326204f, 0.06282134f, -0.01679251f, 0.16757292f, -0.10733304f, 
    0.02679400f, -0.04314834f, -0.03378807f, -0.01151031f, 0.07994832f, -0.00564790f, -0.06925394f, 0.01729473f, 
    0.01188440f, 0.05004315f, 0.09355641f, 0.00265295f, -0.04029182f, 0.00054095f, 0.20966771f, 0.03264851f, 
    0.12863266f, 0.07554299f, 0.08082490f, -0.06600272f, 0.12184640f, 0.11195123f, -0.21318677f, 0.13055295f, 
    0.12481922f, -0.00433306f, -0.04080698f, 0.01542480f, 0.02699813f, -0.17018481f, -0.02353495f, 0.12485576f, 
    0.03315594f, 0.01914478f, -0.03428338f, -0.02564643f, -0.08897342f, 0.07696089f, -0.11615114f, -0.03802855f, 
    0.08424383f, 0.09195355f, -0.21292190f, -0.04966744f, 0.21789669f, -0.12830159f, 0.07710017f, 0.06900700f, 
    -0.05290240f, 0.02898479f, 0.00524224f, 0.01055963f, 0.01031517f, -0.02843034f, 0.00543330f, 0.08995803f, 
    0.00346101f, 0.02866890f, 0.08600101f, 0.01045094f, -0.71698642f, -0.89568859f, -0.32885152f, 0.11624280f, 
    -0.34476206f, -0.09886545f, 0.02567028f, -0.10281734f, 0.04720143f, -0.06155990f, -0.05109820f, -0.03324155f, 
    -0.00825312f, 0.04695009f, -0.03465068f, -0.13574916f, -0.05068373f, -0.09090601f, -0.06346228f, 0.15645389f, 
    -0.23049234f, -0.12296517f, -0.02103902f, -0.25317734f, -0.00597391f, -0.05025525f, -0.09186578f, -0.05398801f, 
    0.03833026f, 0.11145747f, -0.01710016f, -0.07972313f, -0.09219839f, 0.07262339f, -0.10495160f, 0.05019307f, 
    -0.07912656f, -0.00309458f, 0.08675831f, 0.02896259f, -0.63277853f, -0.09535437f, -0.07935020f, 0.39652094f, 
    -0.38439029f, -0.00499422f, -0.10969868f, -0.04268077f, 0.16213650f, 0.01073918f, -0.00758526f, 0.00271123f, 
    -0.00829090f, 0.03801695f, -0.07057463f, -0.08399391f, -0.00793748f, 0.02628257f, -0.16324706f, -0.02333175f, 
    -0.60662335f, -0.16208184f, 0.56282353f, -0.23290636f, -0.34541786f, -0.03863811f, -0.05988172f, -0.37175500f, 
    -0.08965637f, -0.20401162f, 0.03000601f, -0.01440540f, -0.06128268f, -0.03714532f, 0.03563994f, 0.05835215f, 
    -0.01503077f, 0.08312111f, 0.04711739f, 0.15651342f, -0.34384841f, -0.27169502f, -0.56161124f, 0.17609340f, 
    -0.12582995f, -0.06866070f, 0.04070812f, 0.23507741f, -0.29807732f, 0.00562250f, 0.07297827f, -0.00537503f, 
    0.11498733f, -0.00695233f, -0.01797099f, -0.02748299f, 0.03840985f, -0.01851875f, 0.04594647f, -0.19895642f, 
    0.27191573f, -0.30957344f, -0.10160877f, -0.28794527f, 0.16549043f, 0.18382655f, -0.27394643f, -0.07007565f, 
    0.11332842f, 0.15159796f, -0.01280626f, 0.26073992f, 0.16017224f, 0.02870950f, -0.18099713f, 0.02019629f, 
    -0.02834557f, -0.14496791f, 0.22322452f, 0.12587890f, -0.00269497f, 0.12882812f, -0.30801475f, 0.04735931f, 
    0.04918854f, 0.14173244f, -0.00423153f, -0.00807781f, -0.17946912f, 0.01671602f, 0.07999942f, -0.06898462f, 
    -0.06857843f, 0.02895528f, -0.07540290f, 0.04199532f, -0.04253260f, 0.07253371f, -0.06767087f, -0.00181881f, 
    0.01194964f, 0.22073458f, 0.40782920f, 0.26754338f, 0.28815651f, -0.11529312f, 0.03043521f, 0.10818496f, 
    0.03865201f, 0.13275196f, 0.03360993f, 0.08061779f, 0.08304349f, -0.00449498f, 0.05866966f, -0.03715152f, 
    0.01714608f, 0.00984529f, 0.01680596f, -0.03702625f, 0.05885028f, 0.13491817f, -0.01439039f, 0.01266740f, 
    0.07530513f, -0.04631550f, -0.08993175f, 0.03737310f, 0.00941352f, -0.06404097f, -0.13127948f, -0.12740074f, 
    0.06160531f, -0.00467319f, 0.02484267f, 0.00680612f, -0.09861869f, -0.01730282f, 0.05344202f, -0.04238427f, 
    -0.01225568f, -0.26203150f, 0.23770861f, 0.16333714f, -0.12259874f, -0.01592591f, -0.05866414f, 0.01834934f, 
    -0.04115165f, 0.09502151f, -0.00540785f, -0.00791176f, 0.01753757f, -0.04943302f, 0.00628008f, 0.21525498f, 
    0.23064934f, 0.20600221f, 0.24211065f, 0.18028972f, -0.39813092f, -0.31101471f, 0.07672877f, -0.12786493f, 
    -0.07193730f, 0.16354251f, 0.11233508f, -0.28007597f, -0.07530945f, -0.17119947f, -0.00009837f, -0.02782590f, 
    0.00335043f, 0.00650119f, -0.06008221f, 0.01089832f, -0.04687491f, -0.05697123f, -0.23806474f, -0.00656551f, 
    -0.11551943f, 0.39289942f, 0.78823376f, 0.25983921f, 0.48220623f, 0.04991098f, -0.03004302f, 0.10147434f, 
    -0.05435627f, 0.17322606f, -0.00205560f, 0.01632298f, 0.06441417f, -0.14272214f, 0.12564223f, -0.03454641f, 
    0.10565986f, 0.00408259f, 0.06579643f, -0.00907302f, -0.31127420f, -0.35773325f, -0.03842729f, -0.42607614f, 
    -0.47120166f, -0.01471211f, -0.02426600f, -0.06575187f, -0.00114187f, 0.10474392f, -0.04652849f, -0.03383886f, 
    -0.04888983f, 0.01483621f, -0.01080805f, 0.15624700f, -0.05687632f, -0.25246724f, 0.38020435f, -0.10513049f, 
    -0.14114252f, 0.08810348f, 0.39485666f, 0.21178316f, 0.21595193f, -0.01427453f, -0.04168453f, 0.15321125f, 
    0.03090493f, -0.31287619f, 0.02596663f, -0.11115234f, 0.06954993f, -0.09774175f, 0.17951836f, 0.02444781f, 
    0.00959518f, 0.10680950f, 0.00817980f, -0.04822239f, -0.12391497f, -0.07555822f, 0.15816297f, -0.45030734f, 
    -0.15323260f, -0.07477851f, -0.04228475f, -0.07493944f, 0.01502286f, 0.14222990f, -0.00806688f, -0.03270708f, 
    -0.08290700f, 0.10321705f, 0.04899387f, 0.04208235f, -0.19239572f, -0.17674969f, 0.10347884f, 0.08675429f, 
    0.07913661f, -0.01735051f, -0.10053333f, 0.02671099f, 0.05783723f, -0.00198774f, -0.15850817f, -0.30736685f, 
    -0.03306593f, -0.06652816f, 0.01040162f, 0.04285497f, 0.00811917f, 0.05884486f, -0.09811901f, 0.05406193f, 
    -0.00289675f, -0.02230612f, -0.07315578f, -0.01834271f, -0.07240580f, -0.35959986f, -0.11245318f, -0.02744655f, 
    -0.13622639f, -0.00941646f, -0.12452666f, -0.01116901f, 0.11309921f, -0.23944406f, 0.06008577f, 0.07051308f, 
    0.03084376f, -0.00632960f, 0.00702965f, 0.04385078f, 0.02421159f, 0.01308902f, -0.00732947f, -0.08820029f, 
    0.29453722f, 0.32135126f, -0.16429846f, 0.05695130f, 0.22864537f, -0.05473906f, 0.01786195f, -0.00259551f, 
    -0.08058326f, 0.00864447f, -0.20712230f, -0.05773793f, -0.12045767f, 0.08367080f, -0.04293967f, 0.03847715f, 
    -0.01127781f, 0.03442873f, -0.14737378f, 0.07758093f, 0.25140387f, 0.15792790f, -0.20265199f, -0.34495044f, 
    0.20303732f, 0.06041431f, 0.06171296f, -0.02269505f, 0.12861724f, 0.01367993f, -0.06639733f, 0.02241046f, 
    0.06242957f, -0.04987647f, 0.00779418f, 0.03566974f, 0.12112220f, -0.00014435f, 0.10726469f, 0.13147670f, 
    -0.62787879f, 0.00158734f, 0.21903650f, -0.03441713f, -0.08676523f, -0.09532241f, 0.06844652f, -0.30070096f, 
    -0.28977868f, 0.06167017f, 0.09372743f, 0.00582295f, 0.00782632f, 0.00763040f, -0.08618497f, 0.02615964f, 
    0.01739584f, -0.02011301f, -0.10457849f, 0.01468951f, 0.35689723f, 0.00153723f, 0.32926780f, 0.12945524f, 
    0.35121801f, -0.05077229f, 0.05196236f, -0.07062625f, 0.06469889f, 0.09945267f, -0.01295083f, -0.06072886f, 
    0.10655578f, -0.03796620f, 0.06448627f, 0.05010385f, 0.02635332f, 0.00105973f, -0.03510907f, 0.03032029f, 
    -0.05038483f, -0.05153559f, 0.45158437f, 0.22407596f, 0.15795222f, -0.09585109f, -0.17040016f, -0.09074157f, 
    0.25586876f, -0.05510160f, 0.03192074f, 0.03714480f, 0.08223137f, -0.05271419f, 0.01460425f, 0.02382574f, 
    -0.04592801f, -0.00678907f, -0.00859585f, -0.04954585f, -0.09367201f, -0.00595711f, -0.06940301f, 0.04427360f, 
    0.01822235f, 0.02663702f, -0.01015134f, -0.06500833f, -0.01928668f, 0.09063806f, 0.05241555f, 0.01886762f, 
    -0.01689704f, 0.06421777f, -0.10050321f, 0.00516535f, -0.11786968f, 0.07144995f, -0.02226557f, -0.07026983f, 
    -0.42246962f, 0.32435772f, -0.07138074f, -0.16069548f, 0.01757956f, 0.09538835f, -0.04015138f, -0.01287182f, 
    -0.00926481f, 0.11856060f, 0.01320919f, 0.12449498f, 0.10551635f, -0.11686804f, 0.06382870f, -0.05033601f, 
    -0.20808429f, -0.04361544f, 0.05777617f, 0.03737629f, 0.67221075f, -0.05918555f, -0.18576525f, -0.09430762f, 
    -0.09340025f, 0.07141488f, 0.07991000f, -0.18252170f, 0.19482920f, 0.08188900f, -0.02630516f, 0.02311465f, 
    -0.04915315f, -0.07835492f, -0.04100543f, -0.03199472f, -0.00332907f, 0.16392136f, 0.03827488f, 0.10438267f, 
    0.07693785f, -0.05763979f, -0.01895673f, 0.03699122f, 0.06239794f, 0.01228130f, -0.12633321f, -0.02308650f, 
    0.05035963f, -0.17324811f, -0.16526809f, -0.00360812f, -0.01752024f, 0.02859895f, 0.00741656f, -0.02570514f, 
    -0.08823992f, -0.05939464f, -0.00068607f, -0.06114479f, -0.94408602f, 0.09348068f, -0.36276335f, 0.12102150f, 
    -0.04392354f, -0.09457836f, -0.09136615f, -0.00098201f, 0.04897185f, -0.01648282f, -0.06449185f, 0.06336392f, 
    0.02548426f, 0.05874769f, -0.06309517f, -0.02131525f, -0.00915984f, 0.00265700f, -0.10016754f, 0.04698199f, 
    -0.62930095f, -0.23622915f, -0.48311791f, 0.26512700f, -0.01589312f, 0.10539524f, -0.17248842f, -0.24903634f, 
    -0.09506263f, -0.15171963f, -0.10666943f, -0.01500827f, -0.05906529f, -0.04470371f, -0.01150408f, 0.13267781f, 
    0.06739066f, 0.04856701f, -0.06300849f, -0.09356862f, -0.17701955f, 0.08013561f, -0.38043231f, 0.28993270f, 
    0.19631119f, 0.08782639f, -0.07350097f, 0.20265625f, -0.01858600f, 0.07979166f, -0.01098505f, 0.01224945f, 
    -0.00935734f, -0.05251313f, -0.18633586f, -0.00880884f, -0.13687451f, 0.05117204f, -0.00483230f, -0.12547863f, 
    0.57764095f, -0.00365737f, -0.10458785f, -0.10141965f, -0.46497396f, 0.27189475f, 0.23917401f, 0.03502254f, 
    0.08860324f, -0.07695971f, -0.14805411f, -0.21989939f, 0.05701597f, 0.02472767f, -0.14004681f, -0.14287151f, 
    -0.05735851f, -0.07388850f, -0.07564260f, -0.09817187f, -0.03380137f, 0.12636691f, -0.32770607f, -0.37230492f, 
    0.05271547f, 0.12341327f, -0.03708018f, -0.02881187f, 0.07048936f, -0.16772948f, 0.12672873f, 0.04007850f, 
    -0.25941089f, -0.03007108f, -0.10814474f, 0.16455105f, 0.04381704f, 0.20112534f, -0.15220638f, -0.28208736f, 
    0.35931033f, 0.43749669f, 0.13683683f, -0.47493768f, -0.22550747f, -0.19935885f, -0.03515083f, -0.08733992f, 
    -0.23696080f, -0.15884306f, 0.04513277f, -0.01202002f, 0.06333148f, 0.12732448f, 0.03527161f, 0.06178918f, 
    0.01285396f, -0.07415400f, -0.11176161f, -0.02709234f, -0.12118482f, 0.01357049f, -0.22368032f, -0.14956923f, 
    0.13279167f, -0.06228358f, 0.13359132f, -0.02550104f, 0.03148460f, 0.13436286f, -0.10157729f, -0.00508022f, 
    -0.03345468f, -0.10255885f, 0.00285101f, 0.08906836f, 0.01241121f, 0.06639267f, -0.06584486f, -0.04158262f, 
    -0.61688805f, -0.61626744f, -0.65622473f, -0.01165661f, -0.26011103f, -0.06933112f, 0.05686497f, -0.09074000f, 
    -0.09949614f, 0.00829487f, -0.05275942f, 0.07084667f, 0.02603701f, 0.06043003f, 0.01156797f, 0.03176794f, 
    0.03023778f, 0.04335286f, -0.15595880f, -0.08301780f, -0.12757076f, -0.13091472f, -0.13781479f, -0.13827781f, 
    0.29757580f, 0.02691092f, -0.01398755f, -0.00780045f, 0.17072573f, -0.16337912f, -0.08634527f, 0.05889396f, 
    -0.03892599f, 0.10985148f, 0.08452477f, -0.08179931f, 0.00039449f, 0.25310704f, -0.14997107f, 0.20369548f, 
    -0.13681330f, -0.07253092f, 0.43505394f, 0.38437706f, 0.65420210f, -0.02782002f, 0.07541078f, -0.06293711f, 
    0.14376596f, -0.07765747f, -0.05327928f, 0.04313358f, -0.20022637f, -0.08454523f, -0.05337887f, -0.04899494f, 
    -0.03237383f, 0.13543473f, 0.03698029f, 0.04200046f, -0.14008862f, 0.02328308f, -0.44002295f, 0.08611303f, 
    0.02297987f, -0.02818369f, -0.02027531f, -0.21438012f, -0.01051591f, 0.06201634f, -0.04390883f, 0.11794446f, 
    0.02953540f, -0.11339579f, -0.16516405f, 0.02740538f, -0.13991755f, -0.06813548f, -0.05994088f, -0.30491349f, 
    -0.10306400f, 0.56437969f, -0.39148363f, -0.10183405f, 0.06417260f, 0.00483275f, 0.06172603f, -0.02076992f, 
    -0.04741130f, -0.15121602f, -0.12788980f, -0.22925627f, 0.01879133f, -0.09184019f, -0.13195443f, 0.07233031f, 
    -0.11995468f, -0.16199771f, 0.21842499f, 0.07719303f, 0.29670292f, 0.13703218f, -0.14878258f, -0.35654658f, 
    0.04627793f, 0.00732744f, -0.01138133f, 0.04114164f, -0.09587546f, -0.09887447f, 0.10599283f, -0.04865166f, 
    -0.05380344f, -0.05775414f, 0.05536879f, -0.07569739f, -0.12173600f, -0.02435160f, -0.09304050f, -0.10108643f, 
    -0.37240237f, 0.38473222f, -0.06231298f, -0.00512447f, 0.26995349f, 0.05351604f, 0.06883691f, -0.05973455f, 
    -0.23179023f, -0.07633745f, -0.09509058f, -0.02299712f, -0.01049405f, 0.00563412f, 0.12426554f, 0.05061745f, 
    -0.05917037f, 0.14144753f, -0.01592359f, -0.00719503f, -0.95643288f, 0.18268214f, -0.39003822f, 0.03787785f, 
    0.00949756f, 0.20023587f, -0.18514936f, 0.18617906f, -0.00521430f, -0.10971911f, -0.22298534f, -0.09714061f, 
    -0.24506915f, -0.15512750f, -0.12201027f, 0.12614810f, 0.00851319f, 0.17827590f, -0.21935993f, -0.22935893f, 
    0.16222614f, -0.16700083f, -0.29202932f, 0.19408548f, 0.06199099f, -0.16017212f, 0.08036705f, -0.10191010f, 
    0.16665412f, 0.03077791f, -0.04946781f, 0.01507142f, 0.07531805f, -0.04630883f, -0.03653556f, 0.06812552f, 
    0.00234049f, -0.03803246f, 0.12179523f, -0.05951476f, -0.00971488f, -0.08429736f, 0.25707039f, -0.00805410f, 
    0.53119856f, 0.00231667f, 0.14831161f, -0.04464842f, 0.07244158f, 0.10290110f, 0.07128226f, -0.02244744f, 
    -0.06383204f, 0.06850135f, 0.14137182f, -0.05520650f, -0.09885953f, -0.02114025f, -0.05114455f, -0.02305317f, 
    0.12922037f, 0.18044057f, -0.14647415f, 0.01654192f, 0.18684927f, 0.01342785f, -0.03694785f, -0.02045725f, 
    -0.08992177f, -0.07296794f, -0.11203050f, 0.14043859f, 0.11188130f, 0.09596806f, 0.12400467f, -0.12235016f, 
    0.05607795f, 0.07072102f, -0.07648842f, 0.06856629f, 0.10784885f, 0.45582572f, -0.12545830f, 0.44521812f, 
    -0.24069478f, 0.14742850f, -0.08089590f, 0.14452191f, 0.34644577f, -0.12359960f, -0.08573768f, 0.01942339f, 
    0.07829478f, 0.16510493f, -0.05271972f, -0.20319033f, -0.00568253f, -0.19451824f, 0.09815443f, 0.01086131f, 
    0.03010860f, 0.17927065f, -0.10218759f, -0.04103426f, 0.22542708f, 0.33827093f, 0.12971976f, 0.20363410f, 
    -0.16436945f, -0.10896059f, -0.11572592f, -0.01955452f, 0.02280530f, 0.00324242f, 0.01817090f, -0.15128791f, 
    -0.03622993f, 0.03061536f, 0.06127621f, -0.08037433f, -0.65699708f, 0.28987962f, 0.47726879f, 0.20782132f, 
    0.07724269f, 0.13777117f, -0.15469007f, -0.34954885f, 0.04763250f, -0.19135252f, 0.01288227f, -0.06790983f, 
    -0.00163568f, 0.14267099f, -0.11537062f, 0.09692276f, -0.12314165f, 0.10341880f, -0.09563464f, -0.01062667f, 
    0.04569835f, -0.09514415f, -0.30544579f, -0.11158498f, 0.18211535f, 0.12483030f, 0.04770371f, 0.06661203f, 
    0.09687932f, 0.06901984f, 0.10686991f, 0.01900667f, -0.12990606f, -0.11244936f, -0.05407809f, 0.19078666f, 
    -0.06384703f, 0.16359112f, 0.01157030f, 0.19006662f, 0.02695646f, 0.01924687f, -0.31710181f, 0.01269585f, 
    0.23904921f, 0.10142186f, 0.03020565f, 0.15427209f, 0.11548593f, 0.14274883f, 0.06886569f, 0.09786306f, 
    0.10619877f, 0.08712212f, 0.00989136f, 0.09564229f, -0.08221328f, 0.14319383f, -0.05031305f, 0.05732932f, 
    1.09960186f, 0.53774840f, -0.41151354f, -0.13957106f, -0.15608381f, 0.16076723f, -0.06380098f, 0.19779289f, 
    0.09996600f, -0.47321689f, -0.14792113f, -0.02943311f, -0.16467120f, -0.04307342f, -0.01585660f, 0.21788970f, 
    0.00035501f, -0.00663597f, 0.12170745f, 0.07708417f, 0.53519499f, 1.07612181f, -0.10648805f, -0.44569993f, 
    -0.13019702f, -0.14730912f, 0.09172866f, -0.06642032f, -0.26985735f, 0.14123957f, -0.22921000f, -0.16060890f, 
    0.03329620f, 0.20233367f, 0.16515140f, -0.16404460f, -0.00819972f, -0.14116327f, 0.12828621f, 0.00884744f, 
    -0.31903967f, -0.02829494f, 0.10299329f, 0.28680506f, 0.25275090f, 0.05613190f, 0.01381793f, 0.23876205f, 
    0.15279175f, 0.00496455f, -0.04084820f, 0.15932494f, -0.02318217f, -0.03889325f, 0.12991837f, -0.11842457f, 
    0.19720107f, 0.00494463f, 0.12835759f, -0.22657840f, -0.31249169f, 0.61171913f, 0.18642232f, -0.29062259f, 
    0.16929995f, 0.20688042f, 0.12044651f, -0.10958911f, -0.00891592f, -0.26938960f, -0.21167576f, -0.04566048f, 
    0.07710967f, -0.11974160f, 0.08234175f, 0.02980265f, 0.12657309f, -0.19236426f, 0.21155471f, 0.12456775f, 
    -0.44535738f, 0.06418455f, -0.09072436f, -0.16184033f, 0.39347187f, 0.15888602f, 0.04575994f, -0.00899399f, 
    0.03286079f, -0.05974300f, -0.19683746f, -0.01715637f, -0.05737109f, 0.06197133f, 0.00080336f, 0.07362847f, 
    0.03438552f, 0.02919223f, 0.13323782f, 0.03914770f, -0.22263665f, -0.12928401f, -0.05370832f, 0.01591792f, 
    -0.48987791f, -0.14029936f, -0.05661453f, -0.11790810f, -0.02958872f, -0.02474853f, -0.01746701f, -0.01651332f, 
    -0.10138346f, -0.14758602f, -0.01876922f, -0.09271948f, -0.00974912f, 0.00051015f, -0.04350956f, -0.19143075f, 
    -0.80870092f, -0.02155724f, 0.12907134f, -0.15568778f, -0.17322500f, 0.06502413f, 0.02587789f, -0.06040293f, 
    -0.16308741f, 0.01102040f, -0.10903541f, -0.00006195f, -0.01734785f, -0.23857655f, 0.10209400f, 0.00630115f, 
    0.03768513f, 0.25296241f, -0.12585658f, -0.23368742f, 0.06947654f, 0.30771005f, 0.05743845f, -0.20420036f, 
    0.31781152f, -0.19729592f, 0.09574316f, -0.09852313f, -0.02631902f, -0.08405723f, -0.03201329f, 0.06497790f, 
    -0.19931938f, 0.01500251f, -0.05324559f, -0.01930991f, -0.15382330f, 0.08250344f, -0.17115906f, -0.00210008f, 
    -0.29078418f, -0.17036079f, 0.01992460f, 0.10318477f, 0.38224673f, 0.20584692f, 0.13561033f, 0.13852476f, 
    -0.05054890f, 0.18018423f, 0.04354657f, 0.12335883f, -0.00013882f, -0.05574225f, -0.11205283f, 0.32027170f, 
    -0.02146482f, 0.07850543f, 0.06386026f, 0.07053396f, 0.07257274f, -0.24922559f, -0.13667154f, -0.12990868f, 
    0.26460758f, -0.00362867f, 0.06764726f, -0.12959000f, 0.13668792f, -0.21708956f, 0.01365817f, -0.09656931f, 
    0.07768553f, 0.02387703f, 0.13206497f, -0.17606707f, -0.06473191f, 0.16087767f, -0.19657044f, 0.07621464f, 
    0.03407441f, 0.00487333f, -0.01502630f, 0.00120487f, -0.04179018f, 0.07918637f, 0.09464087f, 0.11337420f, 
    -0.02641136f, 0.01243701f, -0.07128949f, 0.01639601f, 0.17343225f, -0.12357204f, 0.13956769f, 0.20421314f, 
    0.06417770f, -0.01790061f, -0.08054068f, -0.01362643f, 0.37317604f, -0.01893989f, 0.62368619f, -0.02678520f, 
    0.34518129f, -0.10364839f, 0.08476000f, 0.06418096f, 0.01327477f, -0.01306112f, -0.06513177f, -0.00428723f, 
    -0.00506759f, 0.05812852f, 0.02622723f, -0.03544536f, -0.02706333f, -0.11910332f, -0.11155436f, -0.39682296f, 
    -0.08978135f, -0.09946638f, 0.10779257f, -0.20205005f, -0.17683978f, 0.10957054f, 0.02081812f, 0.00911722f, 
    0.10252856f, 0.12092300f, -0.12728754f, -0.03131603f, 0.05686921f, -0.13552438f, 0.03746070f, -0.03873331f, 
    0.01242969f, 0.01416622f, -0.22576739f, 0.10135404f, -0.04161149f, 0.06779358f, 0.05617688f, 0.03604639f, 
    -0.09302379f, 0.02402858f, -0.07011934f, 0.08597443f, 0.01798247f, 0.08166707f, -0.01312806f, 0.02048228f, 
    -0.03363487f, 0.00201167f, 0.03971996f, -0.00407250f, -0.11944086f, -0.09330374f, 0.01123296f, -0.10241719f, 
    0.00118981f, -0.01818129f, -0.25232121f, -0.16006650f, 0.00178326f, 0.04488232f, -0.11508609f, -0.17743418f, 
    0.04593660f, -0.05677851f, 0.07122407f, -0.15643610f, -0.09484369f, -0.18145321f, 0.16663441f, -0.12229032f, 
    -0.26515919f, 0.01880528f, -0.12296791f, -0.04671221f, -0.22582264f, -0.03064353f, 0.06431270f, 0.13587429f, 
    0.08316544f, -0.05673182f, 0.03316776f, 0.02992737f, -0.10319321f, -0.00825441f, -0.00753734f, 0.01232793f, 
    -0.03115261f, 0.13533142f, 0.07257243f, 0.12366992f, 0.16577753f, -0.15288073f, -0.07278833f, 0.30519989f, 
    0.08875677f, 0.05329914f, 0.05227106f, -0.01321305f, -0.02709934f, 0.17317164f, 0.02328795f, 0.04587450f, 
    0.02085822f, 0.05168470f, 0.09806211f, 0.10321732f, 0.00674527f, 0.02876459f, 0.05569137f, 0.11636520f, 
    0.09583265f, -0.08667205f, -0.04538225f, 0.07302898f, 0.03585718f, 0.06619181f, 0.16102441f, 0.27692944f, 
    0.05114259f, -0.19760671f, -0.01421625f, -0.14943959f, -0.03751214f, -0.07444976f, 0.04297681f, 0.04813570f, 
    -0.00243134f, 0.05453334f, -0.00020375f, 0.03485137f, -0.01813907f, -0.08963618f, 0.18318208f, 0.07932941f, 
    -0.02716137f, 0.21821424f, 0.15186462f, -0.06554434f, 0.15662654f, 0.29846993f, 0.22071572f, 0.06026392f, 
    -0.03998154f, 0.21101560f, -0.00490447f, -0.02777266f, 0.05106447f, -0.03848469f, -0.08384710f, 0.04290253f, 
    0.15968136f, -0.00147487f, 0.21848537f, 0.31736076f, 0.26603225f, -0.12558025f, 0.34316266f, 0.15923302f, 
    0.20036618f, -0.15122646f, 0.18667427f, 0.12092315f, 0.05846852f, -0.09607141f, -0.01568108f, -0.19113839f, 
    -0.02368524f, 0.03251338f, 0.00270948f, -0.13432717f, -0.00084280f, -0.05133503f, 0.08835047f, -0.18596320f, 
    0.10511120f, -0.29378933f, -0.14738782f, 0.23221700f, -0.22074908f, 0.09696949f, -0.24551915f, 0.06507204f, 
    -0.17219776f, -0.06119834f, -0.18977703f, -0.20881897f, -0.23126912f, 0.04892921f, 0.05262074f, 0.08003103f, 
    -0.06732301f, -0.02401640f, -0.25440890f, -0.12870871f, -0.14717731f, -0.02725800f, 0.04840214f, 0.18041633f, 
    -0.02503407f, -0.02403341f, -0.04846624f, -0.13791034f, -0.04219563f, -0.00916958f, 0.04456793f, -0.20429993f, 
    0.14328638f, 0.00708312f, 0.00248154f, -0.08174977f, -0.04800887f, -0.10826504f, -0.15654469f, -0.35711205f, 
    0.05595544f, -0.18708864f, 0.11721171f, -0.05617705f, 0.01928392f, -0.23341526f, -0.11538479f, -0.11537720f, 
    -0.01237292f, -0.22058970f, 0.06947935f, -0.08748433f, -0.05396407f, 0.08798022f, 0.01739885f, 0.01140707f, 
    0.04835508f, -0.00212505f, 0.01341512f, -0.09418758f, 0.10262159f, -0.04428793f, 0.02296843f, -0.10588433f, 
    -0.06376945f, 0.13367869f, -0.00561739f, 0.03366493f, 0.00715363f, -0.00845128f, 0.02497106f, -0.03680216f, 
    -0.15885535f, 0.13010877f, 0.05472615f, 0.06877775f, -0.14483115f, -0.01295526f, -0.14927042f, -0.13868380f, 
    -0.34514308f, 0.10639649f, 0.16726096f, -0.09801438f, -0.06556117f, -0.11596736f, -0.03704594f, -0.03093137f, 
    -0.06257731f, -0.02169444f, -0.00298816f, 0.05923358f, 0.01880202f, 0.07973046f, -0.06609803f, -0.04999268f, 
    0.18029448f, 0.00167417f, -0.00643853f, 0.40944648f, -0.16815335f, 0.03517947f, 0.07615508f, 0.09318376f, 
    0.13181727f, -0.01319184f, 0.12252412f, 0.21625160f, 0.09613504f, 0.25131297f, 0.08343580f, 0.04859829f, 
    0.02031922f, -0.10863457f, 0.02189462f, -0.07281412f, -0.01364940f, -0.05751429f, 0.05067077f, -0.29401124f, 
    -0.36307591f, -0.18778248f, 0.15873726f, 0.04694658f, 0.09322616f, -0.10994956f, 0.07287594f, -0.17544205f, 
    -0.06529497f, -0.06083352f, -0.03270449f, 0.04769734f, -0.08677880f, -0.05461615f, 0.03696919f, -0.10763988f, 
    -0.01854312f, -0.00233786f, -0.04735528f, 0.06348291f, -0.75513107f, 0.59825188f, -0.26261431f, -0.65851897f, 
    -0.43656746f, 0.20435457f, 0.00494332f, 0.03516013f, 0.08050303f, 0.08748783f, 0.12117419f, 0.08673407f, 
    0.09170461f, 0.00513966f, 0.02999926f, 0.00569663f, 0.14888266f, 0.14238203f, -0.29719284f, 0.07921147f, 
    0.02216909f, -0.09271111f, 0.09795730f, -0.06117041f, 0.01423227f, -0.15336730f, -0.04173197f, -0.09059215f, 
    0.05603411f, 0.15444872f, 0.12697022f, -0.05671786f, -0.11975777f, 0.00228126f, -0.05914149f, 0.08569192f, 
    0.09376018f, 0.08675627f, -0.04732544f, -0.00297736f, 0.00209461f, -0.07290158f, -0.09076596f, -0.05504746f, 
    0.12858453f, -0.00044637f, 0.00204726f, 0.18368611f, -0.16477187f, -0.01349408f, -0.00107777f, 0.04180443f, 
    0.10455880f, -0.08332974f, 0.01950645f, 0.17222789f, -0.03687390f, -0.07760774f, -0.12638009f, -0.02016801f, 
    -0.02228221f, 0.12185072f, 0.11570808f, 0.10794590f, -0.07236105f, 0.17046145f, 0.01789132f, -0.22252004f, 
    -0.17315325f, 0.12645108f, -0.04693909f, -0.00147911f, 0.06331608f, 0.00913069f, 0.07353373f, -0.00841145f, 
    -0.04658141f, -0.16590510f, -0.13630718f, -0.18231621f, 0.23639153f, 0.10629925f, 0.36175606f, 0.22643641f, 
    0.10755344f, -0.07499976f, -0.10141298f, -0.09568170f, -0.12098742f, 0.19338337f, 0.04607848f, 0.03399157f, 
    0.05502712f, 0.02917061f, 0.01797642f, 0.03770944f, -0.04996021f, -0.03339820f, 0.00351016f, -0.12258087f, 
    -0.04756995f, -0.31169826f, 0.05397095f, -0.04810042f, -0.01940631f, -0.14101163f, -0.05082828f, -0.15159886f, 
    0.07497858f, 0.05217920f, 0.12598428f, -0.00710468f, 0.13379234f, 0.00129377f, -0.03151533f, 0.01631713f, 
    -0.08895846f, -0.10538990f, -0.03114154f, 0.00105275f, 0.33305880f, -0.98233742f, -0.35650417f, 0.26846170f, 
    -0.38235173f, 0.16654833f, -0.09350928f, 0.08860209f, -0.11090406f, 0.05112989f, 0.04053955f, 0.02732449f, 
    -0.07976528f, -0.06473564f, -0.01113196f, -0.10753951f, -0.19567817f, 0.01312782f, -0.31227294f, 0.00719081f, 
    0.09760290f, -0.16271102f, 0.14835706f, 0.14426710f, 0.27609092f, -0.15269238f, 0.08890304f, 0.02130157f, 
    -0.03446965f, 0.05654681f, 0.11861283f, 0.06315371f, 0.00167046f, -0.09360132f, 0.04242766f, -0.00635379f, 
    -0.02644979f, -0.08732063f, -0.23399422f, -0.05152408f, -0.10515215f, -0.40022981f, 0.04064519f, 0.00893873f, 
    -0.01298003f, -0.25626147f, -0.21383314f, -0.02365874f, -0.04847151f, 0.01801796f, -0.16017498f, 0.01161367f, 
    -0.00757047f, -0.04212443f, 0.06695373f, -0.06011744f, -0.04061889f, 0.03225296f, -0.07008237f, -0.01069983f, 
    0.20889036f, 0.00112156f, 0.03374920f, 0.11863105f, -0.00157006f, -0.16716234f, -0.07689781f, -0.16861494f, 
    -0.14181098f, -0.01793016f, 0.01055479f, 0.00116020f, 0.00613197f, 0.04070951f, 0.09238716f, 0.04953468f, 
    0.04949921f, 0.09253985f, -0.00639593f, -0.11774626f, -0.07222358f, -0.04981985f, 0.00014012f, -0.03501166f, 
    0.06652007f, -0.01140669f, 0.10127002f, 0.01712218f, -0.01424705f, -0.01628795f, 0.09561891f, -0.03571091f, 
    0.06629973f, -0.02531723f, 0.00437398f, -0.05755229f, -0.12925804f, -0.13579407f, -0.08500414f, 0.12183209f, 
    0.26115829f, -0.23125108f, 0.03997413f, -0.21532947f, 0.11511657f, -0.05534251f, 0.11304464f, 0.21491554f, 
    -0.02571017f, -0.07873307f, 0.05223022f, -0.09589017f, -0.05570661f, 0.01751923f, -0.04026220f, -0.19483504f, 
    -0.41173348f, -0.24714793f, -0.16572307f, -0.16729534f, -0.03019561f, -0.20388910f, 0.16964899f, 0.41782191f, 
    0.00952485f, 0.04594116f, 0.02965762f, 0.20611387f, -0.26096648f, -0.03383033f, -0.09316135f, -0.12739709f, 
    0.03247403f, -0.02946633f, -0.04924032f, -0.00351035f, 0.01159998f, -0.11556400f, 0.10119465f, 0.04936786f, 
    0.14696112f, 0.09885826f, -0.01143819f, 0.05867280f, -0.01142304f, 0.09153840f, 0.03570001f, 0.04902826f, 
    0.02446217f, 0.09536608f, 0.07754946f, -0.08692048f, 0.03443195f, 0.02622373f, 0.07060898f, 0.17157254f, 
    -0.01174888f, -0.03762915f, -0.08405731f, -0.04190421f, -0.11488806f, 0.04099272f, 0.17510836f, 0.19954623f, 
    0.11003562f, -0.16023561f, -0.07553938f, -0.08485713f, -0.00314460f, 0.03712350f, 0.08699635f, 0.06924985f, 
    0.00385519f, 0.02586567f, 0.00162403f, 0.00920584f, 0.01085920f, -0.13512614f, 0.10548788f, 0.05296980f, 
    0.11134531f, -0.08926915f, -0.32294986f, 0.04189501f, 0.11695053f, 0.11472192f, 0.07373571f, -0.04962504f, 
    -0.06608796f, 0.09541235f, -0.08564382f, -0.01800012f, 0.14004454f, 0.16024502f, 0.02557247f, 0.05390918f, 
    0.13171931f, 0.20110330f, -0.02542769f, -0.04672762f, 0.14921427f, -0.16133504f, 0.48074701f, -0.34717840f, 
    -0.02670485f, 0.11650674f, 0.13822283f, -0.10457081f, -0.12582880f, -0.12369722f, -0.03060737f, 0.00884623f, 
    0.00976201f, -0.01546794f, 0.02096574f, 0.01173023f, 0.05121813f, -0.09169118f, 0.11438488f, 0.18321595f, 
    -0.19240573f, 0.23868418f, -0.39598536f, -0.04570977f, 0.11390212f, 0.01407980f, -0.02700387f, -0.04731032f, 
    -0.13800007f, 0.05907575f, 0.00589965f, -0.00345166f, 0.02485600f, 0.13107705f, -0.01368052f, -0.09934025f, 
    -0.10876365f, 0.16838340f, 0.17072147f, 0.04072471f, 0.21235555f, -0.13708912f, 0.18687464f, 0.17949733f, 
    -0.05513769f, 0.03385478f, -0.02843615f, -0.14157030f, 0.00210540f, 0.00088613f, 0.13725798f, -0.12774982f, 
    0.06988797f, -0.09588969f, 0.01866834f, 0.15926655f, 0.12402222f, -0.10567480f, 0.08739717f, 0.05291977f, 
    -0.38971999f, -0.31291360f, -0.13550116f, 0.35749364f, -0.02150881f, 0.14183001f, 0.10618919f, -0.13607019f, 
    0.10595902f, 0.13379925f, -0.11343608f, 0.00930407f, 0.01574188f, -0.02088203f, 0.00366093f, 0.16531572f, 
    -0.27312219f, 0.12582850f, -0.01350669f, 0.04918341f, -0.03357053f, -0.00863831f, 0.31834921f, 0.29147318f, 
    -0.20901629f, 0.02395642f, -0.13505626f, 0.14143513f, 0.04741572f, -0.07645679f, 0.09155711f, -0.03122572f, 
    -0.03630752f, 0.03370641f, 0.03425287f, 0.07105417f, 0.08073511f, -0.32818303f, -0.15118290f, -0.47406283f, 
    -0.12229137f, -0.04884712f, -0.18539549f, -0.04626490f, 0.21502805f, 0.08128879f, 0.05929253f, -0.14808442f, 
    -0.08477785f, 0.03071969f, 0.19443002f, 0.03944015f, 0.05586622f, 0.03066483f, 0.13064618f, -0.08356138f, 
    0.02680911f, 0.13023543f, -0.01674991f, -0.07622760f, -0.06097915f, -0.17264704f, 0.17616127f, 0.05085872f, 
    -0.24437748f, 0.25431719f, 0.11313938f, 0.15220937f, -0.17258133f, -0.11051108f, 0.10459555f, -0.07864928f, 
    -0.00970546f, -0.03451249f, -0.02538761f, -0.02691131f, 0.08128895f, 0.01420060f, 0.17391528f, -0.08263513f, 
    0.62462252f, 0.15359975f, -0.00992533f, -0.36699477f, 0.29154137f, -0.03650160f, 0.18264836f, 0.33062133f, 
    0.07202895f, 0.04074325f, 0.09118247f, 0.06415416f, 0.03364993f, -0.02022588f, -0.03378361f, -0.08669247f, 
    -0.18733175f, -0.25978875f, 0.02894554f, -0.18711071f, 0.37012661f, 0.00437241f, 0.22544245f, 0.01457076f, 
    -0.15744901f, 0.14065182f, 0.04150152f, -0.38627142f, 0.02739476f, 0.32071215f, -0.00203092f, 0.05525554f, 
    0.02990327f, 0.18792427f, 0.04421046f, 0.07937010f, 0.06896351f, -0.07816426f, 0.05181503f, 0.55935800f, 
    -0.47273809f, 0.32892066f, 0.20372586f, -0.53454089f, 0.12678842f, -0.05998533f, 0.02031767f, -0.15855536f, 
    -0.07179709f, 0.03617124f, 0.35808545f, 0.11691130f, -0.02621179f, -0.03285087f, -0.00947098f, -0.04615450f, 
    0.02444947f, 0.13211611f, 0.04883562f, 0.11953668f, -0.04509906f, 0.04664493f, 0.09186348f, 0.35332006f, 
    -0.24392577f, -0.00733520f, -0.14622204f, -0.03818451f, -0.13992971f, 0.06876281f, -0.11169044f, 0.10357362f, 
    0.00403839f, -0.08700161f, 0.04313101f, 0.00369916f, 0.02751722f, 0.03592268f, 0.00393999f, 0.15776493f, 
    -0.00853018f, -0.33758044f, -0.14364842f, -0.23586398f, -0.11408227f, 0.13558803f, -0.01961261f, -0.15105012f, 
    0.17359953f, 0.18379594f, -0.06846217f, 0.20847465f, -0.05221109f, 0.05722037f, -0.04304789f, -0.03986615f, 
    -0.01459180f, 0.01064201f, -0.02761829f, 0.09188245f, 0.06447691f, -0.19440891f, -0.04078699f, 0.05100154f, 
    0.14074776f, -0.07659096f, 0.00515372f, -0.05518713f, 0.06906430f, 0.02700225f, 0.13871218f, 0.03296023f, 
    0.07385096f, -0.23630932f, -0.01729250f, 0.05652927f, -0.15156978f, -0.01592924f, 0.10170865f, 0.24373843f, 
    0.11789420f, 0.21581896f, 0.04927390f, -0.16416037f, 0.21521895f, 0.06023679f, -0.03936895f, -0.00211482f, 
    -0.01003193f, -0.04538307f, -0.01715386f, 0.04295538f, 0.04231161f, -0.07164715f, -0.03907166f, 0.03865681f, 
    -0.11565459f, -0.30689549f, -0.19379447f, -0.60791290f, 0.21608827f, 0.18672429f, -0.04133141f, -0.16999608f, 
    -0.16378699f, -0.18194020f, -0.06441417f, -0.00452007f, -0.18898255f, -0.16305244f, -0.04744406f, -0.02163688f, 
    -0.00855824f, -0.09063499f, -0.05161342f, 0.05153854f, 0.07202522f, 0.07267969f, -0.15113176f, 0.03834743f, 
    -0.14764786f, 0.02501783f, -0.24414609f, -0.06334689f, -0.12724330f, -0.02950840f, -0.06869371f, -0.01953567f, 
    -0.02989537f, 0.02610901f, 0.02505928f, -0.08542107f, -0.00633170f, 0.11512662f, 0.01142762f, -0.20571633f, 
    -0.15290277f, 0.01403102f, -0.01219685f, -0.01814002f, 0.01218033f, -0.03297599f, -0.49931487f, -0.23409344f, 
    0.22730087f, 0.05444328f, -0.04925350f, 0.00356617f, -0.07132294f, -0.09062470f, 0.24114676f, -0.16467682f, 
    0.07249885f, -0.02696198f, -0.01711084f, -0.16294281f, -0.21962528f, 0.35751000f, 0.11505596f, -0.28770849f, 
    -0.49747708f, 0.11744571f, -0.49150836f, -0.20735359f, -0.03036161f, 0.05568748f, -0.02238393f, -0.09393185f, 
    0.03132559f, 0.14350303f, -0.06711538f, -0.00282740f, 0.07285067f, 0.05516919f, -0.12638262f, -0.08578660f, 
    -0.06688648f, 0.04394700f, -0.01731146f, 0.07367282f, 0.26885554f, 0.03530240f, -0.47693911f, -0.09215434f, 
    0.20436399f, 0.03994116f, 0.17171273f, 0.04946788f, -0.17941862f, 0.03043346f, 0.09359751f, -0.10599709f, 
    0.14687914f, -0.01020479f, -0.05958872f, 0.16737178f, -0.03788572f, -0.27610755f, -0.12199470f, -0.11810663f, 
    0.20125253f, -0.06416685f, 0.27387568f, -0.09676249f, -0.18973178f, -0.02780222f, -0.04676584f, 0.00113657f, 
    0.02022000f, -0.21545999f, 0.01719198f, -0.11058988f, 0.01547103f, -0.05393820f, 0.05695388f, -0.03466100f, 
    0.07558636f, 0.03379606f, -0.00783184f, 0.15348628f, -0.00152706f, -0.09599019f, 0.37705785f, -0.26100296f, 
    -0.12270481f, 0.11209980f, 0.09112619f, 0.09554308f, -0.04049700f, -0.14185254f, 0.00139482f, 0.02396646f, 
    -0.02120729f, -0.04241971f, 0.01624569f, -0.02978079f, 0.04172789f, -0.02387643f, 0.07431951f, 0.07279437f, 
    -0.02692925f, 0.28085193f, -0.15432850f, 0.20851515f, -0.06510788f, -0.00888388f, -0.06861089f, -0.12064743f, 
    -0.06359898f, 0.10545249f, 0.19317614f, -0.16801083f, 0.06174923f, -0.03035838f, -0.02287460f, -0.04559208f, 
    0.13421908f, 0.10700648f, -0.08012885f, 0.01389834f, -0.38950148f, 0.03016841f, -0.01235500f, 0.32993290f, 
    -0.22694248f, -0.00904127f, -0.28344238f, -0.01026684f, 0.07499046f, -0.10472661f, -0.01362788f, -0.07363208f, 
    0.01807013f, 0.12940587f, -0.18131810f, 0.18348062f, -0.03188131f, 0.00617484f, 0.15140177f, -0.07132022f, 
    -0.03606229f, -0.15047820f, -0.16347525f, -0.03772488f, 0.07187007f, 0.16320501f, 0.07529611f, 0.00555267f, 
    -0.11811282f, -0.01156532f, -0.05083903f, -0.06874929f, -0.09131428f, -0.02871672f, -0.01937766f, -0.02684287f, 
    0.08599669f, 0.21149513f, -0.09264965f, -0.07191285f, -0.48673239f, -0.24592429f, -0.30955479f, -0.01811819f, 
    -0.30147347f, 0.22653882f, -0.03127684f, -0.06053694f, 0.12035926f, -0.00843668f, 0.17813428f, 0.01860647f, 
    -0.15305218f, 0.09658035f, 0.09240299f, -0.07191395f, -0.03716533f, 0.11066335f, -0.01769768f, 0.07100666f, 
    -0.36161774f, -0.05519303f, -0.07965527f, -0.22916509f, -0.29588899f, 0.06769767f, -0.04033732f, -0.15255812f, 
    0.04830003f, 0.23782401f, 0.10381223f, 0.11659834f, -0.16473004f, -0.03844796f, -0.01471160f, -0.04714875f, 
    0.05285918f, -0.01098089f, 0.06285288f, 0.15004577f, -0.20004156f, -0.12844175f, -0.21802384f, 0.23383540f, 
    0.12811783f, 0.27231884f, -0.30467969f, -0.09370999f, 0.03349895f, 0.08133166f, -0.16357832f, 0.03227223f, 
    0.04017964f, 0.00474424f, -0.00104628f, -0.02403927f, -0.01939886f, 0.05335444f, -0.09270399f, 0.03579892f, 
    -0.17961508f, -0.19490723f, -0.05636207f, -0.04233573f, 0.05299112f, -0.20939220f, 0.03892227f, -0.12141113f, 
    -0.20817697f, 0.17355193f, 0.08418560f, -0.11198997f, -0.01299903f, -0.03628796f, 0.14719039f, -0.00642237f, 
    -0.07510544f, 0.01419947f, 0.09328234f, 0.14440022f, 0.08501910f, -0.23605879f, 0.50183195f, -0.02807326f, 
    -0.49017620f, -0.07570795f, 0.07812940f, 0.05452966f, 0.09418875f, 0.13923033f, 0.01443966f, -0.03985194f, 
    -0.06164519f, -0.06030508f, 0.09571930f, -0.04149237f, 0.00971989f, 0.00470484f, -0.04263476f, -0.03060962f, 
    0.14825478f, 0.05800731f, 0.04197974f, -0.10127286f, 0.07156175f, -0.05619838f, -0.03349729f, 0.01402184f, 
    -0.01345278f, 0.02083369f, 0.00397681f, -0.05233718f, 0.03881901f, -0.02629860f, -0.08192202f, -0.03219577f, 
    0.08013329f, 0.00339969f, -0.10159006f, 0.05234016f, -0.02222511f, -0.15457147f, -0.00520422f, 0.03079447f, 
    -0.21062116f, -0.07729246f, 0.10670491f, 0.13812020f, 0.00792542f, 0.06920005f, 0.06507648f, -0.04436859f, 
    -0.04438096f, 0.01266327f, -0.01132339f, -0.00561082f, 0.05874968f, 0.02737579f, 0.16275601f, -0.01854321f, 
    0.16799769f, 0.03054213f, -0.02293278f, -0.04456331f, -0.05937234f, -0.02768471f, -0.04207794f, 0.02918692f, 
    -0.00984546f, 0.01787547f, -0.11765566f, -0.05086355f, -0.03000428f, -0.22531556f, -0.05916255f, -0.00231594f, 
    -0.13446394f, -0.06599078f, -0.09265526f, -0.00597217f, -0.46630472f, -0.00713844f, -0.60714436f, -0.04130720f, 
    -0.46294636f, -0.12278602f, 0.11711516f, -0.27965996f, -0.11164651f, -0.41054273f, 0.04019022f, -0.01851842f, 
    -0.11081214f, 0.00964674f, 0.03552621f, -0.00103285f, -0.01226399f, 0.18391521f, -0.21070713f, -0.03780070f, 
    0.03258154f, 0.08402816f, 0.19703586f, -0.11653291f, 0.17114273f, -0.02327625f, -0.04603366f, 0.00632931f, 
    -0.01391571f, 0.06708742f, 0.00836076f, 0.17232722f, 0.09586864f, 0.10787294f, 0.08362414f, 0.04265649f, 
    -0.01040418f, 0.03798121f, -0.03412672f, 0.08517057f, -0.07944450f, 0.13188601f, 0.10274853f, 0.08332900f, 
    0.05674719f, -0.11656563f, 0.02261421f, -0.16508259f, 0.03824576f, 0.05741125f, 0.08555110f, -0.05644410f, 
    0.01925351f, 0.04797135f, 0.02181530f, 0.02668589f, -0.05011561f, -0.05948761f, 0.01474624f, -0.07561000f, 
    0.09626361f, 0.06540660f, -0.08695482f, -0.05247346f, 0.20560305f, 0.01108951f, 0.15598895f, 0.14509167f, 
    0.09575888f, 0.06696116f, 0.00697132f, -0.01776388f, -0.04543041f, -0.05723761f, 0.03122950f, 0.05052209f, 
    0.05750252f, -0.08817729f, 0.09286962f, -0.04300462f, -0.32270318f, -0.15895218f, -0.80285323f, -0.12246495f, 
    0.23248671f, -0.18482791f, -0.08313624f, -0.03534378f, -0.22342515f, -0.21766865f, -0.02108231f, -0.02970869f, 
    -0.02632324f, 0.03611662f, 0.09356249f, -0.10806628f, -0.06531545f, 0.10488417f, 0.08152078f, 0.07117147f, 
    0.11174838f, -0.08971798f, -0.08228301f, -0.21859448f, -0.09381238f, 0.06153093f, -0.03565488f, 0.03984636f, 
    -0.09261319f, 0.00955575f, -0.05704718f, -0.06526417f, -0.12589830f, -0.24549849f, -0.05738715f, -0.06961860f, 
    -0.06499746f, 0.11530089f, -0.10901395f, 0.01293196f, -0.79735184f, -0.78566867f, -0.42151961f, -0.01033178f, 
    -0.33118701f, -0.24570359f, -0.15554546f, -0.05182450f, -0.25983423f, -0.13275819f, -0.04863328f, -0.00705397f, 
    0.02822621f, -0.01924238f, 0.00393853f, -0.00726712f, -0.04797844f, 0.03657863f, 0.13071105f, -0.13126598f, 
    0.34948158f, -0.53061199f, -1.05483592f, -0.21510956f, -0.43288478f, -0.12835664f, 0.31735906f, -0.10684544f, 
    0.06139863f, -0.70057726f, 0.02057930f, 0.05283752f, -0.04661637f, 0.07607029f, 0.13192436f, -0.01251258f, 
    -0.06476849f, 0.24297969f, -0.07500570f, -0.03257702f, -0.00393041f, 0.30674109f, -0.66685289f, 0.26282567f, 
    -0.02389371f, -0.07633717f, 0.00608649f, -0.05422181f, 0.14864914f, 0.00262485f, 0.04776612f, 0.00381476f, 
    -0.09186291f, 0.04512881f, 0.04244798f, 0.00732459f, 0.00980585f, 0.04518944f, 0.07103988f, 0.00700870f, 
    -0.21347483f, -0.29428890f, 0.21818167f, 0.27965090f, -0.29452568f, 0.13365395f, -0.07098236f, 0.12339118f, 
    0.06079224f, 0.09886515f, 0.15891184f, 0.01081838f, 0.00450302f, -0.10726026f, -0.00703389f, 0.13742495f, 
    0.11139305f, 0.04718778f, -0.00580608f, -0.12642083f, -0.01702122f, -0.08503670f, -0.28277552f, -0.06511531f, 
    0.24543074f, -0.10378017f, 0.19510220f, 0.10809929f, 0.12456694f, 0.03296414f, -0.01832841f, 0.09204710f, 
    0.04157662f, 0.00486688f, 0.02877821f, 0.00583262f, -0.02915220f, -0.03278664f, 0.18374728f, -0.10126384f, 
    -0.57852513f, 0.87177765f, 0.26491484f, 0.09212966f, 0.28481224f, -0.15276557f, -0.03676154f, -0.07853018f, 
    0.15882617f, 0.36781415f, 0.08201145f, 0.08732945f, 0.10496964f, 0.00507319f, 0.03563288f, 0.04407628f, 
    -0.04556257f, -0.04237107f, 0.08468945f, -0.01014910f, -0.06786564f, 0.22259122f, 0.05387405f, -0.04905620f, 
    0.00916505f, 0.05071560f, -0.03597711f, -0.04815644f, 0.09744395f, 0.11435417f, 0.05107845f, -0.13242701f, 
    -0.01087579f, 0.05372816f, 0.04181987f, 0.06280780f, -0.11869304f, -0.10063861f, -0.10203333f, -0.10346251f, 
    -0.28079206f, -0.22669286f, 0.17292257f, 0.04439802f, 0.11561245f, 0.00262148f, 0.03043382f, 0.03819155f, 
    0.11097049f, -0.02307120f, 0.01008796f, 0.02306114f, 0.05691881f, 0.13282850f, 0.09466143f, 0.06195990f, 
    0.26143509f, 0.25017574f, 0.10669357f, 0.11092700f, 0.05244689f, -0.34722465f, -0.51573038f, -0.31438133f, 
    0.16165833f, -0.19785768f, 0.01082637f, 0.15867448f, 0.07976712f, -0.51086009f, 0.01313278f, 0.01262539f, 
    -0.09529734f, -0.08801017f, -0.01464078f, 0.00157853f, 0.02073568f, 0.13401751f, 0.16515186f, -0.05318633f, 
    -0.32408208f, -0.28348392f, -0.19478388f, -0.10083931f, 0.74745870f, -0.17006372f, 0.00076524f, -0.02457226f, 
    0.03253810f, 0.05773874f, 0.07768917f, 0.00639954f, 0.03496350f, 0.03031245f, -0.13078167f, -0.04513310f, 
    0.06486356f, -0.01872510f, 0.15146576f, 0.05329738f, -0.33951533f, 0.01045250f, 0.22415815f, -0.03079749f, 
    0.07807527f, 0.00559267f, 0.02947205f, -0.00702261f, 0.01404782f, -0.12603739f, 0.08172128f, -0.02914956f, 
    0.01994720f, -0.01843418f, -0.08956244f, 0.07000969f, 0.13161892f, -0.06790125f, -0.10316111f, 0.24017303f, 
    -0.40186012f, 0.50790524f, 0.29773498f, 0.07669117f, 0.26072520f, -0.11003959f, -0.01847628f, -0.06634328f, 
    -0.06648272f, 0.17546971f, -0.09246769f, 0.10400891f, 0.10425863f, 0.09628033f, 0.05817743f, -0.04043151f, 
    -0.01644087f, -0.04837636f, 0.00217832f, -0.02355678f, 0.22649001f, 0.00097905f, -0.01894020f, -0.13429295f, 
    -0.16776638f, 0.09031649f, 0.05984415f, 0.04260511f, -0.05053056f, -0.03598818f, -0.01393816f, -0.00373179f, 
    -0.11145750f, 0.04314129f, 0.05354084f, -0.03813009f, -0.02254818f, -0.05911460f, -0.18538217f, 0.01913840f, 
    -0.21782143f, -0.17495804f, 0.20931198f, 0.11331165f, 0.14420313f, -0.11323706f, -0.03495795f, -0.22942875f, 
    -0.15340215f, -0.18134820f, 0.00143207f, -0.09109855f, -0.03313773f, 0.00040397f, 0.06146663f, -0.03016164f, 
    -0.02817325f, 0.06077168f, 0.09249508f, -0.28736660f, -0.90632409f, -0.15829189f, 0.05419747f, -0.12852620f, 
    -0.34785634f, -0.27140486f, 0.06746636f, -0.29698914f, -0.13275555f, -0.29515752f, -0.03656572f, -0.00756086f, 
    -0.06939796f, -0.00699144f, 0.04535067f, -0.01369517f, -0.02106774f, 0.13136958f, -0.02418830f, -0.18035126f, 
    -0.34129784f, 0.01263719f, 0.02731789f, 0.11720791f, 0.07975481f, -0.14740051f, -0.01736608f, -0.03276740f, 
    -0.00460659f, 0.26743549f, 0.01767486f, 0.09016032f, 0.22045657f, -0.06002947f, 0.06624907f, 0.02185381f, 
    0.02800110f, -0.14065444f, 0.06960277f, -0.10348890f, -0.00647896f, -0.14054592f, 0.11859191f, 0.09361036f, 
    0.00700135f, 0.01619894f, 0.11596488f, 0.01138458f, -0.06138201f, 0.03008320f, 0.04607119f, 0.00567934f, 
    -0.00818616f, 0.03601330f, -0.09822451f, -0.06155225f, 0.04785963f, -0.00868075f, 0.11239912f, 0.06174357f, 
    0.40935117f, -0.02523344f, -0.52425122f, -0.13765407f, 0.17637296f, -0.06398012f, 0.05555827f, 0.22347443f, 
    0.02024661f, 0.05606929f, 0.03788193f, 0.02586949f, -0.11095994f, -0.03427439f, 0.06618246f, -0.02100565f, 
    -0.01888459f, 0.13079052f, -0.08710727f, 0.06536613f, -0.31622010f, 0.26210678f, 0.35224205f, 0.02930956f, 
    0.13750009f, -0.13727602f, 0.00268344f, -0.11229972f, -0.20206371f, 0.26115537f, -0.12104814f, 0.13758183f, 
    0.18862279f, 0.01161950f, 0.03161855f, -0.02952230f, -0.00553251f, -0.07064187f, 0.06194039f, 0.00788380f, 
    -0.62446803f, 0.51125699f, 0.64044541f, -0.24592896f, -0.11126615f, -0.08220740f, -0.10229491f, -0.11545714f, 
    -0.15962675f, 0.17901716f, -0.06174867f, 0.11768976f, -0.00600402f, 0.00474460f, 0.03386949f, 0.03109309f, 
    -0.02850145f, -0.03623368f, 0.00173051f, -0.02894807f, 0.18923904f, -0.01069252f, -0.23272420f, -0.06829733f, 
    0.14185730f, -0.03853318f, 0.02754260f, 0.12753455f, 0.05460271f, 0.10284793f, -0.06872053f, 0.04229910f, 
    -0.03081483f, -0.10466725f, -0.00782837f, -0.04380131f, 0.01628821f, -0.16973199f, 0.07519541f, -0.02013372f, 
    0.09599696f, 0.02318392f, 0.00062617f, 0.01465568f, 0.15552957f, -0.05068028f, 0.12074394f, 0.06084887f, 
    0.13731518f, -0.05307626f, 0.15443633f, 0.07026178f, -0.03262805f, 0.05245810f, -0.00927763f, -0.04983974f, 
    -0.07963808f, -0.06958653f, -0.06760490f, -0.05691372f, -0.87568152f, -1.27163970f, -1.26400208f, 0.07423068f, 
    0.44382033f, 0.03401640f, 0.17565724f, -0.03571212f, -0.13383652f, -0.22132173f, -0.01151070f, -0.02983936f, 
    -0.01705543f, 0.06654738f, 0.06301526f, 0.01715915f, 0.01774329f, -0.02590902f, 0.26764438f, 0.13699594f, 
    -0.22201608f, 0.18871240f, 0.22997014f, -0.08139614f, -0.03872202f, -0.11177859f, -0.08010241f, -0.15476173f, 
    -0.16849282f, -0.11077069f, -0.09102687f, -0.15942399f, -0.05019281f, 0.01858414f, 0.00851731f, -0.07194716f, 
    -0.11872565f, 0.00757836f, -0.12270581f, -0.05627573f, -1.06772673f, -1.20020306f, -0.64853108f, -0.01290853f, 
    -0.58395994f, -0.25021714f, -0.20364733f, -0.04774528f, -0.10222298f, -0.14016075f, 0.00869772f, -0.04829350f, 
    0.07811095f, -0.16440532f, -0.04375268f, -0.00707173f, -0.03706384f, -0.10147170f, 0.17770420f, -0.13130909f, 
    -0.06233323f, 0.10430736f, -0.01485922f, -0.02237276f, -0.03646746f, 0.00127937f, 0.00199234f, -0.01735107f, 
    0.00063465f, 0.00699298f, -0.03197654f, -0.20076203f, -0.04713018f, -0.12386765f, -0.15229319f, 0.01976429f, 
    0.00947911f, 0.06767295f, 0.05342542f, -0.01576754f, -1.24938834f, -0.98261935f, 0.95518351f, -0.01837853f, 
    0.69742513f, -0.19533995f, -0.01947912f, 0.18032849f, 0.04905581f, -0.07221035f, 0.05371372f, 0.06710576f, 
    -0.08040464f, -0.00667547f, -0.01836831f, 0.02798606f, 0.01297101f, -0.14859776f, 0.02925566f, -0.02757884f, 
    -0.04943312f, 0.04018768f, -0.11835790f, -0.00864230f, -0.15281205f, 0.01690758f, 0.06523771f, 0.14001240f, 
    0.03063036f, -0.09205597f, -0.11953072f, -0.25032160f, -0.25993961f, -0.12407333f, -0.20676035f, -0.11292693f, 
    -0.07448868f, -0.05830354f, -0.00496902f, 0.03927976f, 0.12827626f, 0.01875278f, -0.19134796f, 0.05649624f, 
    -0.06118429f, 0.11673041f, 0.05766661f, -0.04285689f, -0.03381839f, 0.03457395f, -0.14100289f, -0.17024119f, 
    0.08727944f, -0.06160035f, -0.01373019f, 0.04033133f, -0.04141394f, 0.00490222f, -0.06682312f, -0.07385841f, 
    0.12310241f, 0.15949896f, -0.31288996f, 0.04798174f, -0.28577220f, -0.05832459f, 0.10677527f, 0.02429243f, 
    -0.19938917f, -0.13468273f, -0.04804789f, 0.09352436f, 0.10647897f, -0.05521660f, -0.02830397f, -0.08390354f, 
    -0.30245084f, 0.13782129f, -0.08152058f, -0.05412418f, -0.01763329f, -0.44117984f, -0.40305993f, 0.30095208f, 
    -0.09087822f, 0.16874014f, -0.02463691f, -0.18057454f, 0.14408782f, 0.15030108f, 0.03693216f, -0.05657255f, 
    -0.10410561f, -0.00513691f, -0.00580854f, 0.06534517f, 0.20087557f, 0.06548766f, 0.27569357f, 0.05547151f, 
    -0.02865854f, 0.07971223f, 0.17967731f, -0.05355754f, 0.01654658f, -0.04245502f, -0.05834308f, 0.02215252f, 
    0.00726367f, -0.03753513f, 0.07678182f, 0.03551222f, 0.06664532f, -0.02143643f, -0.04635413f, -0.01396156f, 
    -0.07360236f, 0.00646783f, 0.09160221f, -0.00875015f, 0.63540399f, -0.50735050f, -0.23200859f, -0.09099790f, 
    0.02089800f, 0.05178852f, 0.13835023f, -0.15673380f, 0.33847356f, 0.17150179f, 0.03493455f, 0.01862618f, 
    -0.05814737f, -0.07696903f, 0.01631817f, -0.09137897f, 0.01296126f, 0.00235846f, 0.06121860f, -0.16566245f, 
    -1.53787112f, -0.42140231f, 0.52832133f, -0.21864083f, 0.30908984f, 0.07956448f, -0.23525317f, 0.05183350f, 
    0.08327589f, 0.07970048f, 0.07815576f, -0.08023364f, 0.06091818f, 0.05070537f, -0.03023215f, 0.18676285f, 
    0.05724587f, 0.17036161f, -0.29665932f, -0.20850743f, -1.00325811f, -0.56695771f, -0.31161773f, 0.31230840f, 
    0.18807840f, 0.21794711f, 0.05245955f, 0.03320498f, 0.07722816f, -0.18079758f, -0.05556228f, 0.13646962f, 
    0.03555290f, -0.02710060f, -0.01757671f, 0.06940181f, 0.04227157f, 0.06436061f, -0.21934426f, 0.00523221f, 
    0.37424079f, -0.04304185f, 0.12186814f, -0.12850399f, 0.02071680f, 0.03496157f, 0.15061107f, 0.10454720f, 
    0.06841446f, -0.05581742f, -0.17486782f, -0.11214522f, 0.14156689f, -0.11463203f, 0.10008651f, -0.19807670f, 
    0.06556351f, -0.02819416f, -0.03860511f, -0.15380913f, 0.25123438f, -0.20369796f, -0.39338073f, 0.25325814f, 
    -0.35900325f, 0.09009513f, 0.01445841f, 0.07058684f, -0.14421105f, 0.01326612f, -0.08928710f, 0.03701349f, 
    -0.04344860f, -0.02053672f, -0.04296146f, -0.04582269f, -0.01317695f, 0.08016270f, -0.24043164f, -0.10789718f, 
    0.30135950f, -0.61212403f, -0.30783018f, -0.37564352f, -0.22395325f, 0.01661722f, -0.08747374f, 0.08157169f, 
    0.19005412f, -0.22484367f, -0.01517292f, 0.09350905f, 0.01038395f, -0.01575685f, 0.01782873f, -0.01812621f, 
    0.02026036f, 0.04970974f, 0.01879027f, -0.00010283f, -0.09080552f, 0.06719653f, 0.08241664f, -0.08421164f, 
    0.08015193f, -0.04053207f, 0.06684013f, 0.00646426f, -0.01641129f, -0.08800818f, -0.15491365f, -0.11464770f, 
    0.02204746f, -0.03506273f, 0.01999568f, 0.00306602f, 0.02950072f, 0.00706387f, -0.00447570f, -0.00440382f, 
    -0.21471132f, -0.05082120f, 0.24445048f, 0.06072942f, 0.19561318f, -0.01727251f, -0.16075139f, 0.00576224f, 
    0.02930829f, -0.05473841f, -0.06951565f, -0.02945996f, -0.00572677f, -0.04424589f, -0.07604714f, -0.07115876f, 
    0.01522853f, 0.11707959f, 0.04984218f, -0.06633487f, -0.45451659f, -0.20231225f, -0.01597345f, 0.42261299f, 
    -0.14919558f, -0.05245673f, -0.08744832f, -0.16784540f, 0.01098918f, 0.09467497f, 0.11595079f, -0.02502543f, 
    0.08469705f, -0.00348073f, 0.00669933f, 0.08979233f, -0.00393215f, -0.11048745f, -0.01019624f, 0.04178451f, 
    0.15687777f, -0.55030864f, -0.64660513f, -0.51647192f, -0.18893899f, 0.12639914f, -0.04051610f, 0.06562922f, 
    0.03406097f, -0.04589291f, 0.01202811f, 0.10979725f, 0.03422419f, 0.01062396f, 0.01168544f, -0.10306800f, 
    -0.02971317f, -0.02035326f, -0.03584328f, 0.06010582f, -0.28394932f, 0.13877279f, -0.02169552f, 0.21342793f, 
    -0.17507629f, 0.04654090f, 0.07162579f, 0.19039032f, -0.09109920f, 0.02053135f, 0.10477497f, 0.10156637f, 
    0.03298684f, 0.08140539f, 0.06418294f, -0.04007846f, -0.09109864f, -0.01656946f, -0.37315285f, 0.05553775f, 
    0.37127930f, 0.09045326f, -0.25540316f, -0.23571979f, -0.13537535f, 0.05700707f, -0.05919554f, 0.01558608f, 
    -0.08221986f, -0.06347170f, 0.00443675f, -0.00077916f, 0.00196259f, 0.04643310f, -0.05782706f, 0.03097536f, 
    -0.03174016f, -0.03652737f, 0.09505321f, 0.05529413f, -0.18560061f, 0.10286739f, 0.17530462f, -0.05457011f, 
    0.05867947f, -0.00943969f, -0.07017501f, -0.02881464f, 0.08561724f, 0.05519932f, 0.05566170f, -0.00482689f, 
    0.06714193f, 0.03116591f, -0.04079258f, -0.01926603f, -0.23321916f, -0.01862018f, 0.02984939f, 0.04103938f, 
    0.09400924f, -0.29740056f, -0.07056852f, 0.35906708f, -0.03526737f, 0.24550861f, 0.03426388f, 0.15234235f, 
    -0.08880944f, 0.14843714f, 0.16360262f, 0.07594533f, 0.06620049f, 0.01736028f, 0.00045410f, -0.02853512f, 
    0.03356958f, -0.08077998f, -0.10163383f, -0.14879899f, -0.04227831f, -0.68641317f, -0.20040892f, -0.04465327f, 
    0.13591665f, 0.00508517f, -0.02836458f, -0.05074069f, 0.04534471f, 0.00255400f, -0.02207186f, 0.06090261f, 
    0.00051622f, -0.00681384f, 0.00103567f, -0.01420745f, 0.02415060f, -0.03079846f, -0.10307419f, -0.02878997f, 
    0.58713782f, 0.27036881f, -0.13131547f, 0.03349174f, -0.33647177f, 0.17099586f, -0.00552148f, 0.03271069f, 
    -0.12756020f, 0.07443278f, -0.11617576f, 0.00008038f, 0.11228499f, -0.01592231f, -0.07001968f, -0.00818199f, 
    -0.06452567f, 0.03436816f, 0.02425865f, -0.10860139f, 0.08351957f, 0.05761125f, -0.15641141f, -0.06275738f, 
    -0.18591599f, 0.05814900f, 0.00168077f, -0.04975422f, 0.00797013f, -0.00622914f, -0.14937197f, 0.07016460f, 
    0.04539101f, -0.17337532f, -0.08631557f, -0.06655812f, -0.25983414f, 0.04564947f, -0.15961255f, -0.09181697f, 
    -0.25996935f, -0.17718622f, 0.10407040f, 0.07768218f, -0.14975265f, 0.05608680f, -0.13784550f, -0.09772089f, 
    0.24259891f, 0.20311858f, 0.04937741f, 0.04012009f, 0.04147249f, -0.00692604f, -0.00738701f, 0.10370907f, 
    0.03706840f, -0.22146773f, 0.11418666f, 0.08901933f, 0.55750310f, 0.29108688f, -0.26729494f, -0.01460547f, 
    -0.23780751f, 0.09050257f, -0.09684023f, -0.18236388f, -0.07050692f, -0.06755719f, 0.08066346f, 0.08509012f, 
    -0.01769310f, -0.07941505f, -0.02240343f, -0.00594280f, -0.00921678f, -0.01282248f, 0.02238574f, -0.03082234f, 
    0.55790824f, -0.77993053f, -0.13566685f, -0.21935354f, -0.04756652f, 0.04674547f, -0.05491722f, -0.01066659f, 
    0.08788431f, -0.21443847f, 0.04283980f, 0.04452591f, 0.02896642f, 0.06737535f, 0.08866091f, -0.00337503f, 
    0.02598816f, -0.00767648f, 0.06170272f, 0.02385063f, 0.03704213f, -0.00044663f, -0.04380041f, 0.03552687f, 
    -0.16548464f, 0.03478603f, -0.02969944f, 0.05541390f, -0.02317725f, -0.00659851f, -0.03039978f, 0.05308726f, 
    -0.01154004f, 0.02579452f, -0.01893106f, -0.09454399f, -0.01428184f, 0.01626961f, -0.00855002f, 0.04676951f, 
    0.07737985f, 0.12401611f, 0.23943625f, -0.24632294f, 0.11461912f, -0.02836033f, -0.08523408f, -0.08685457f, 
    -0.00053230f, 0.05692784f, -0.02305496f, 0.03777486f, 0.09761838f, 0.00973822f, -0.08627176f, 0.00351764f, 
    -0.14811388f, -0.01161689f, 0.10554432f, -0.10082357f, -0.04903604f, -0.50208801f, 0.51956320f, 0.69216979f, 
    -0.11931065f, 0.10559805f, 0.06127930f, -0.14370279f, -0.01406651f, 0.10400420f, 0.03286096f, 0.06024600f, 
    -0.05535280f, -0.00491330f, -0.02139855f, 0.03323447f, -0.02734725f, -0.17537372f, 0.14034253f, 0.04859414f, 
    0.17595769f, -0.01009900f, -0.06243105f, 0.06153348f, -0.02241038f, 0.10661636f, 0.10150350f, 0.03813341f, 
    -0.03264468f, 0.03340600f, -0.04418408f, -0.18892585f, 0.15691185f, 0.08550734f, -0.01047101f, 0.02258118f, 
    0.02673602f, -0.00573040f, -0.01785561f, -0.02196829f, 0.68834496f, -0.89135587f, -0.62382299f, -0.06317858f, 
    -0.05337139f, 0.00262499f, 0.06318392f, -0.25155231f, 0.24138875f, 0.14746219f, -0.01166986f, -0.00598638f, 
    -0.11957383f, -0.04147197f, 0.00977849f, -0.13041814f, 0.03782941f, -0.01031486f, -0.10831140f, -0.25210127f, 
    -0.25883982f, 0.00510706f, 0.10876250f, -0.04030848f, -0.09417128f, -0.06908347f, 0.03536562f, -0.03476786f, 
    -0.00271975f, -0.04128134f, 0.08411360f, 0.10098457f, 0.06116489f, 0.14216979f, 0.12884803f, -0.01783437f, 
    0.02098894f, 0.05928844f, 0.07508580f, 0.09397149f, 0.52297533f, -0.61753386f, -0.49457842f, 0.01346448f, 
    0.13172816f, -0.02281182f, -0.11029266f, -0.05326902f, 0.01486854f, 0.09744450f, 0.03287169f, 0.03164404f, 
    0.09862690f, 0.01215485f, 0.00992628f, 0.02548516f, 0.02590860f, 0.10351496f, -0.06522634f, 0.14949410f, 
    -0.15879966f, -0.01398409f, 0.14508016f, 0.07615697f, -0.10523900f, -0.06333462f, -0.04760853f, -0.04685987f, 
    -0.06714101f, -0.09974430f, 0.14060725f, 0.13225149f, 0.14828674f, 0.04630894f, 0.04610673f, 0.03108373f, 
    0.08893739f, -0.01885188f, -0.01894685f, 0.07336609f, 0.15982261f, -0.18656769f, -0.16960751f, 0.02230496f, 
    -0.11641211f, -0.03246421f, 0.06166960f, -0.00444913f, 0.03679610f, 0.08997109f, -0.06223234f, 0.02862271f, 
    -0.01260979f, 0.03649703f, -0.01004062f, -0.05745124f, 0.09508627f, 0.05120906f, 0.08799316f, 0.05557915f, 
    0.35162547f, 0.11711469f, -0.02352445f, 0.04202401f, -0.29512462f, 0.09331047f, 0.09018940f, 0.15250599f, 
    0.14214428f, -0.07887319f, 0.00590451f, -0.03100908f, 0.00581556f, 0.09765589f, 0.09413185f, 0.09614049f, 
    0.15279062f, -0.01790223f, 0.12054015f, 0.00699777f, 0.15252332f, 0.05016919f, -0.47788185f, -0.55825257f, 
    -0.10513175f, -0.18221982f, -0.19310087f, -0.10178679f, -0.16676989f, -0.27689624f, 0.04782373f, -0.01603979f, 
    -0.06153015f, 0.19120401f, 0.08842863f, 0.10774823f, 0.09663296f, 0.22509174f, -0.28167599f, -0.35587803f, 
    -0.34985831f, -0.02443279f, 0.09554832f, -0.01546343f, -0.13814855f, -0.06726932f, -0.04273325f, 0.01546400f, 
    -0.02331321f, 0.00762397f, -0.00677322f, -0.12435581f, -0.02903360f, -0.03892729f, -0.03738555f, 0.01579136f, 
    0.03835293f, 0.06272155f, -0.01527064f, 0.10020037f, -0.41809973f, -0.42442146f, -0.74593699f, -0.62390530f, 
    -0.05826617f, 0.11671532f, -0.30701250f, 0.04903697f, 0.02199851f, -0.19285481f, -0.06278343f, -0.04845047f, 
    -0.08763763f, 0.04906016f, 0.04141592f, 0.02778729f, 0.02554494f, 0.06801342f, -0.06352407f, 0.06688792f, 
    -0.78999627f, -0.28581607f, 0.24366647f, 0.24199858f, 0.01978550f, -0.00139639f, 0.07235975f, -0.10616394f, 
    -0.16660781f, -0.24059209f, -0.02763598f, 0.00214381f, 0.05065490f, -0.00823348f, 0.07373592f, 0.06474422f, 
    0.01379388f, -0.04071597f, -0.07425277f, -0.46385241f, 0.35345668f, -0.29000664f, -0.34714314f, -0.04318761f, 
    0.38231573f, 0.23304738f, 0.13886368f, 0.11262950f, 0.00924923f, 0.02524188f, -0.12009636f, 0.03807540f, 
    -0.04572589f, 0.00009393f, -0.04467155f, 0.01384720f, 0.02552766f, 0.10368204f, 0.04495770f, 0.20076905f, 
    0.03216013f, -0.00815846f, -0.09645627f, -0.15766689f, 0.10660113f, 0.13590175f, -0.00715921f, 0.27104211f, 
    0.10692873f, -0.03206732f, -0.02174767f, 0.17279847f, -0.02316407f, 0.03716665f, 0.30668196f, -0.07516240f, 
    -0.03417222f, 0.05064438f, -0.00013160f, 0.16303688f, 0.67587548f, -0.03734454f, -0.14016402f, 0.02037520f, 
    -0.09589740f, 0.05394171f, 0.06481027f, -0.06529992f, 0.03915544f, -0.10740343f, 0.05454538f, 0.09073784f, 
    0.10471344f, -0.00739360f, 0.02320930f, -0.05166072f, -0.01023312f, 0.01873598f, 0.14404349f, 0.03682654f, 
    0.15836713f, -0.76756912f, -0.63377285f, -0.18892448f, 0.30439967f, 0.11316468f, 0.14236763f, 0.16994327f, 
    0.16300721f, -0.01695466f, 0.07770110f, -0.11027543f, -0.09486225f, -0.03459398f, -0.06905804f, 0.01399418f, 
    -0.06660981f, -0.02819126f, 0.01068335f, -0.04777859f, 0.07936005f, -0.16580664f, -0.06450410f, 0.05515477f, 
    -0.02269185f, -0.06032107f, 0.02032586f, 0.00460472f, -0.09171475f, 0.06239762f, 0.11327893f, 0.06280873f, 
    0.05712380f, 0.06932156f, 0.10302214f, 0.00709851f, 0.12324442f, -0.00771249f, 0.10777338f, 0.08179844f, 
    0.13112439f, -0.16568558f, 0.13795765f, 0.15082376f, 0.23817414f, 0.06489184f, 0.00508142f, 0.15023327f, 
    0.01318472f, 0.03788841f, 0.00312720f, -0.00193019f, 0.06435765f, -0.04422080f, 0.03514064f, -0.21233726f, 
    -0.13228782f, -0.12667792f, -0.11424793f, -0.50478232f, 0.07774265f, -0.08772674f, 0.03896048f, 0.06640250f, 
    -0.32433468f, -0.01850781f, -0.19188222f, -0.07485721f, 0.11792958f, -0.23232146f, -0.07859527f, 0.04182971f, 
    0.06360334f, -0.07815556f, 0.02897680f, -0.08365598f, 0.06982430f, 0.20111234f, -0.03194676f, 0.16108482f, 
    0.12919852f, -0.62613332f, -0.66662812f, -0.30473968f, 0.39787385f, -0.05961796f, 0.22925584f, 0.10378543f, 
    0.24949083f, -0.06916626f, 0.01032179f, -0.06110798f, -0.04755898f, 0.05269626f, 0.03942602f, 0.13381226f, 
    -0.03762757f, -0.10004048f, -0.02822405f, -0.02921457f, -0.99243712f, -0.17433372f, 0.40320325f, 0.12412882f, 
    0.04450138f, -0.18837035f, 0.00636208f, -0.19376323f, -0.13465224f, -0.07833910f, -0.21607848f, -0.03431997f, 
    0.02172939f, -0.10964201f, -0.06510198f, -0.13707255f, -0.23290595f, -0.30243894f, -0.08351382f, -0.19705819f, 
    -0.19093838f, -0.46265766f, -0.28177404f, -0.12183173f, 0.12117792f, -0.01438784f, 0.09642642f, 0.12350459f, 
    0.14106287f, 0.02795443f, 0.09901832f, 0.03427415f, -0.04056573f, -0.09467795f, -0.02262222f, 0.01999761f, 
    0.02797003f, -0.02340989f, 0.04245963f, -0.07649387f, -0.54416496f, -0.09885354f, 0.22028495f, 0.10477010f, 
    -0.00119928f, -0.11388700f, 0.05259969f, 0.01588794f, 0.05302965f, 0.05219665f, -0.02858611f, -0.02851641f, 
    -0.09395666f, 0.05385659f, -0.00428084f, -0.02178886f, 0.13270673f, 0.05049239f, 0.02742971f, 0.10235566f, 
    0.28354937f, -0.04988421f, -0.16890788f, 0.03224663f, -0.14307112f, -0.12050147f, -0.16058601f, -0.07187394f, 
    0.02406599f, -0.06017409f, -0.07709270f, 0.07607250f, 0.01939096f, -0.02116702f, 0.06099888f, -0.07903694f, 
    0.04356356f, 0.11151135f, 0.16438523f, 0.15635744f, -0.04977108f, -0.42711651f, -0.58074021f, -0.02753033f, 
    0.05573805f, -0.26173937f, -0.11327321f, -0.04781869f, 0.01941081f, 0.08962898f, -0.10937872f, -0.05973205f, 
    -0.05423290f, -0.08731317f, -0.01254429f, -0.01606048f, 0.04829708f, 0.01347982f, 0.04888770f, 0.02628215f, 
    0.24527065f, -0.28390530f, -0.28956109f, -0.15767187f, -0.10973068f, -0.05811515f, 0.12186287f, 0.03273940f, 
    0.04417833f, -0.05251554f, -0.01226332f, -0.03962888f, 0.03927585f, -0.08013098f, -0.02920281f, -0.03264812f, 
    -0.05191096f, -0.10214143f, 0.02250720f, -0.05185024f, 0.04341083f, 0.22130127f, 0.13257883f, -0.00331329f, 
    -0.38575032f, -0.02610391f, 0.05032910f, -0.07458903f, 0.02343951f, -0.10005625f, -0.05464640f, -0.00861291f, 
    0.00063517f, 0.00402586f, 0.00034745f, -0.03587837f, 0.01210808f, -0.05170783f, -0.01397039f, -0.07547249f, 
    0.17499210f, 0.04739502f, 0.01981896f, 0.18628809f, -0.10535181f, 0.13039078f, -0.19258995f, -0.26499835f, 
    -0.12452644f, -0.09860221f, 0.01516651f, 0.00964211f, 0.01862463f, -0.01868506f, -0.04244972f, -0.05185603f, 
    -0.01694704f, 0.23945643f, 0.05132977f, 0.13156506f, -0.04779606f, -0.32115623f, -0.63290995f, -0.28465471f, 
    -0.12858672f, -0.12301932f, 0.11047417f, 0.02023944f, 0.19443291f, 0.03550453f, 0.13001502f, 0.02346328f, 
    0.06634720f, -0.04453423f, -0.04963391f, -0.01891333f, -0.05496298f, -0.02999554f, 0.02435131f, -0.09311352f, 
    -0.01849812f, -0.45422187f, -0.79168737f, -0.10705835f, 0.07295641f, 0.04043157f, 0.05307167f, 0.07885987f, 
    0.04578543f, 0.16260530f, 0.06840281f, -0.20231815f, -0.07897831f, -0.07623965f, -0.05771083f, -0.07388346f, 
    -0.00311334f, 0.04285024f, 0.00108267f, -0.01916316f, 0.01427958f, 0.16700120f, -0.03247878f, 0.00058413f, 
    -0.06732729f, -0.00260935f, 0.03857014f, -0.03900798f, -0.05849623f, -0.08766849f, 0.02553014f, -0.09136550f, 
    0.06183437f, 0.04608702f, 0.04856441f, -0.02905762f, 0.15788497f, 0.14985694f, 0.10168631f, 0.03419857f, 
    -0.07767142f, -0.09985179f, 0.14052635f, 0.18859702f, -0.09700230f, 0.10952440f, -0.05603927f, 0.02496273f, 
    -0.00116383f, 0.04253201f, 0.02283971f, 0.07477616f, -0.01357344f, 0.02562939f, 0.07972986f, 0.13958567f, 
    0.16487315f, 0.05830216f, -0.12289359f, 0.16537179f, 0.79317665f, 0.42671084f, 0.25809899f, -0.32134289f, 
    -0.31563544f, 0.13195924f, -0.16864461f, -0.20048937f, 0.00436542f, -0.29666775f, 0.05721809f, 0.04963556f, 
    0.12480522f, 0.10744698f, 0.05407118f, 0.19923638f, 0.06725281f, -0.05304643f, 0.00191322f, -0.32905605f, 
    -0.07650587f, -0.12201595f, -0.14736031f, -0.01330524f, -0.10238797f, -0.11325176f, -0.11313625f, -0.04119881f, 
    -0.01613795f, 0.03095063f, 0.11313304f, 0.07190382f, -0.08615605f, -0.09180892f, -0.01742225f, -0.09615370f, 
    0.13053806f, 0.04657048f, 0.07033311f, 0.06813469f, -0.33576402f, -0.56386662f, -1.08423793f, -0.83916563f, 
    0.10650060f, 0.24843012f, 0.01819554f, 0.10931966f, 0.20508353f, 0.00580828f, -0.02493492f, -0.09362664f, 
    -0.09257799f, 0.05909142f, 0.06862214f, 0.03651246f, -0.01389736f, 0.00608977f, -0.04889880f, 0.17122339f, 
    -0.05754383f, 0.21873482f, 0.18867812f, -0.16961455f, 0.05126202f, 0.03044641f, -0.05816940f, -0.00762077f, 
    -0.04730670f, -0.10228971f, 0.19608189f, 0.08159936f, -0.00406203f, -0.09410791f, -0.02701893f, 0.10063322f, 
    0.08316129f, -0.08884875f, 0.04354570f, -0.01113304f, 0.06323341f, -0.07591870f, 0.57445163f, -0.17917301f, 
    -0.34531540f, -0.28354004f, -0.21914174f, 0.07951094f, 0.10608350f, 0.10026071f, -0.14648363f, 0.02789095f, 
    0.01115614f, -0.03311072f, -0.04567530f, 0.06118169f, 0.03302682f, -0.01700491f, -0.16516513f, -0.25442272f, 
    0.05961579f, 0.19387677f, 0.10301062f, 0.12985815f, 0.21586530f, 0.00873463f, -0.20311393f, -0.03006731f, 
    -0.09607707f, -0.02877752f, 0.06806473f, 0.01402853f, 0.05999156f, 0.10698346f, -0.21884231f, 0.15820710f, 
    0.08796553f, -0.03604205f, -0.04947601f, 0.15695518f, 0.00037574f, 0.14913170f, 0.05003525f, 0.01115313f, 
    -0.04902689f, -0.13722377f, -0.05822343f, -0.03904000f, -0.09394196f, -0.12548834f, -0.02885054f, 0.03251489f, 
    -0.02625654f, 0.01542494f, 0.07824609f, 0.01839800f, -0.12260445f, -0.07678784f, 0.00384832f, 0.00180874f, 
    -0.57534862f, 0.25958335f, -0.43367890f, 0.07221572f, -0.00590739f, 0.04782865f, -0.31198981f, 0.00015554f, 
    -0.17804141f, -0.02111946f, -0.04379263f, -0.07036249f, 0.01791245f, 0.08629213f, -0.14750868f, -0.00090272f, 
    0.02574571f, -0.02300934f, 0.04418559f, 0.04789007f, -0.24283019f, -0.04351163f, 0.11257882f, 0.25165337f, 
    -0.34606636f, -0.08085281f, -0.19975185f, -0.13065501f, 0.06169967f, 0.12364382f, 0.03615333f, 0.06400993f, 
    0.15207162f, 0.13699342f, 0.01817775f, -0.08349685f, 0.04825738f, 0.08447354f, 0.28815669f, 0.23591523f, 
    0.09523476f, -0.25684455f, -0.10925826f, 0.02318638f, 0.12363631f, -0.12288962f, 0.06138330f, 0.08057474f, 
    0.11877250f, 0.01497333f, 0.07898376f, -0.02426428f, 0.09155978f, -0.12618183f, -0.08800139f, 0.06751808f, 
    -0.11835160f, -0.01984130f, -0.00775662f, 0.02290465f, -0.39066023f, -0.49458456f, 0.38478103f, 0.25521335f, 
    -0.57232493f, 0.08627417f, -0.13538665f, 0.07205418f, 0.23211524f, 0.38583115f, 0.06294572f, 0.01096298f, 
    0.03280992f, -0.03466619f, 0.03978856f, -0.01554712f, 0.04872375f, 0.01175665f, -0.00306714f, -0.03219550f, 
    0.17812315f, -0.11185934f, -0.31011060f, -0.26019043f, -0.01202471f, -0.15368475f, -0.12648714f, 0.13794115f, 
    0.00990274f, 0.18209416f, 0.02633255f, 0.00277541f, -0.04037122f, -0.06671168f, -0.06810607f, -0.06621470f, 
    0.17676695f, 0.10024936f, -0.12930413f, -0.01326185f, -0.32773921f, 0.14484143f, -0.12994076f, -0.42225197f, 
    -0.44907632f, 0.11384947f, -0.31495857f, 0.00239425f, -0.00751705f, -0.01234925f, -0.11572862f, 0.07777279f, 
    -0.09451230f, -0.08620877f, 0.11747783f, -0.12106915f, 0.00193569f, 0.02260258f, -0.07037092f, -0.21916161f, 
    -0.28265491f, -0.43476543f, -0.12388323f, -0.05594178f, 0.13582146f, -0.24669285f, 0.19241056f, -0.30476522f, 
    -0.35724905f, 0.05965105f, 0.00398451f, 0.02388954f, 0.01365290f, 0.06286276f, -0.00333270f, 0.18352556f, 
    0.17440537f, -0.11617095f, -0.13338222f, -0.05515565f, -0.17262384f, 0.29834372f, -0.40707722f, 0.09746271f, 
    -0.16917472f, 0.02009159f, -0.18796593f, 0.12958954f, -0.14458366f, -0.14754695f, 0.06702131f, 0.07196928f, 
    0.01816722f, -0.11030062f, -0.07840447f, 0.01927077f, 0.03698820f, -0.05042674f, 0.01186252f, -0.05234224f, 
    0.11422633f, -0.03780199f, 0.30802697f, 0.28598371f, -0.65972030f, 0.17630634f, -0.21012880f, -0.26225299f, 
    -0.00841643f, -0.22590694f, -0.01294901f, 0.04105220f, -0.00136435f, 0.04626643f, 0.05658081f, 0.02991862f, 
    -0.00336424f, 0.00402889f, -0.03884100f, 0.11149023f, -0.03628141f, -0.07191232f, 0.22089636f, -0.00154177f, 
    0.08839231f, 0.01714997f, 0.11369122f, -0.12761447f, -0.18264277f, -0.14696941f, 0.05582371f, 0.01634034f, 
    -0.05940285f, 0.09825616f, 0.02909234f, -0.04182161f, 0.05840115f, -0.05650550f, -0.17877571f, 0.08778226f, 
    0.11304318f, -0.36598614f, -0.33400893f, -0.08397090f, -0.13173123f, -0.08045551f, -0.00646490f, 0.10828292f, 
    0.12658185f, 0.08662652f, 0.01088797f, 0.04817769f, 0.06427921f, 0.05745097f, 0.02264331f, 0.01636298f, 
    0.16006719f, 0.22252719f, -0.01096584f, 0.30956122f, 0.09060442f, 0.53618383f, -0.55262309f, 0.16563323f, 
    -0.16414474f, -0.03150532f, 0.05423981f, 0.24710563f, -0.04966897f, 0.17761631f, 0.05907131f, 0.07114439f, 
    -0.04941170f, -0.04687116f, -0.04591063f, 0.00138272f, -0.05256438f, -0.10163926f, 0.16507955f, -0.16491900f, 
    -0.01566881f, -0.09827605f, 0.02022508f, 0.34876630f, -0.84714574f, 0.08566334f, -0.23212621f, -0.21811044f, 
    0.09121339f, -0.01855710f, -0.04267036f, -0.01501819f, 0.01996710f, 0.07338252f, 0.00472263f, 0.08293203f, 
    0.05400190f, 0.09054749f, 0.07716641f, 0.07794502f, -0.25376156f, -0.36788750f, -0.38278776f, -0.90100098f, 
    0.30618754f, 0.06222390f, -0.14252341f, 0.20404164f, 0.08738614f, -0.01360362f, -0.07423069f, 0.02098760f, 
    -0.03937818f, -0.06467377f, 0.03226316f, 0.14291976f, 0.27039504f, 0.02223332f, -0.09098148f, 0.11300602f, 
    0.37578586f, 0.18205816f, 0.36350900f, 0.37832567f, -0.38197196f, 0.09211851f, -0.18193811f, -0.35229313f, 
    -0.08633350f, -0.13194327f, -0.02678013f, 0.07977244f, 0.09939934f, 0.07605487f, 0.03992033f, 0.07918384f, 
    -0.04211533f, 0.01698874f, -0.02743800f, 0.05048594f, 0.08809422f, -0.09397342f, -0.09912954f, -0.35454655f, 
    -0.00984975f, -0.09021481f, 0.03506175f, 0.12128209f, 0.14653139f, 0.09405549f, 0.09462148f, -0.07230937f, 
    0.03560805f, -0.10846438f, -0.04676330f, 0.00922902f, 0.15780631f, 0.01102030f, -0.03849042f, -0.05488515f, 
    0.05964841f, 0.01086127f, 0.03726986f, 0.08094499f, -0.07800888f, 0.03233949f, -0.01445006f, 0.07455580f, 
    0.03584110f, 0.06101408f, -0.10823737f, -0.09044586f, -0.03681461f, -0.04867955f, -0.02986363f, 0.08178122f, 
    -0.04864940f, -0.06058913f, 0.06680206f, -0.15572852f, -0.22215359f, 0.06347258f, 0.31138158f, -0.19220920f, 
    -0.27878281f, -0.07484629f, -0.11188168f, 0.01953439f, 0.18770844f, 0.09079891f, -0.06980988f, 0.01045494f, 
    0.02079018f, -0.03220616f, -0.11739817f, 0.02649916f, 0.03120865f, -0.11243085f, -0.04299054f, -0.10457536f, 
    -0.48230618f, 0.25829485f, 0.10546459f, 0.43164688f, -0.29888883f, 0.11448829f, -0.22011001f, -0.03136536f, 
    -0.33152917f, -0.22954428f, 0.19261457f, 0.09705331f, -0.02014514f, -0.05596398f, 0.08245558f, -0.04631444f, 
    -0.08726941f, -0.13468225f, 0.03902627f, 0.03021703f, -0.34460908f, -0.01073958f, -0.04767499f, -0.25672761f, 
    0.22552422f, -0.00356223f, 0.04679532f, -0.10195998f, -0.00354526f, 0.13866851f, 0.03511339f, -0.16254036f, 
    -0.03776537f, -0.03554395f, -0.01596228f, 0.32341024f, 0.03350128f, -0.02540528f, 0.03586130f, 0.04257665f, 
    0.02482519f, 0.18032637f, -0.36336049f, -0.05652851f, 0.02138647f, 0.19906126f, 0.11518760f, 0.28405368f, 
    0.06970178f, 0.00140166f, 0.01863387f, -0.10365763f, 0.00098438f, -0.07453824f, -0.02434178f, 0.04702984f, 
    -0.01686032f, -0.11586882f, 0.07151233f, -0.12239724f, -0.24512388f, 0.27365285f, 0.26176861f, 0.64477992f, 
    -0.32379919f, 0.08135404f, -0.10823824f, -0.32622084f, -0.08235347f, -0.27586606f, 0.12223218f, -0.11831906f, 
    0.11615530f, 0.03258511f, 0.12804694f, 0.12558569f, 0.04532564f, -0.06286008f, 0.02054666f, 0.02996005f, 
    0.15086748f, -0.07610202f, 0.01540692f, 0.26625344f, -0.40624636f, 0.00989755f, 0.08480345f, -0.34343642f, 
    -0.01700091f, -0.09194814f, 0.10780744f, -0.08194955f, 0.09951434f, 0.03536531f, 0.03939485f, 0.05522498f, 
    0.00377270f, -0.07317629f, 0.02441107f, 0.03233066f, -0.17726943f, 0.17838722f, -0.25121111f, 0.07891256f, 
    0.13647978f, 0.04255169f, 0.15866207f, 0.21977225f, -0.04179411f, -0.16379289f, 0.06355140f, -0.12046023f, 
    0.01252578f, -0.07361139f, -0.08318785f, 0.02970664f, 0.08170513f, -0.17388077f, 0.00995143f, -0.02478420f, 
    0.06139902f, -0.52232534f, -0.10060611f, -0.06166081f, -0.11463067f, 0.13062093f, 0.19687708f, 0.04621914f, 
    -0.08229160f, 0.05843027f, -0.05759781f, -0.03205237f, -0.16331114f, -0.00698895f, 0.03655693f, -0.03098938f, 
    -0.00401126f, 0.06891652f, -0.14866854f, 0.01945333f, -0.19085370f, -0.18505871f, -0.78368074f, 0.00298292f, 
    -0.26041216f, -0.14873272f, 0.00610532f, 0.07941829f, -0.16291060f, 0.16155806f, -0.01408921f, 0.02454546f, 
    0.01818558f, -0.00702235f, -0.03194101f, 0.02283069f, -0.00165893f, 0.05082401f, 0.19497781f, 0.09086889f, 
    -0.02439337f, 0.18488592f, 0.37889513f, 0.01802194f, 0.08203165f, 0.03673311f, 0.01731341f, -0.06531964f, 
    -0.01274661f, -0.02682435f, 0.05316317f, 0.06084376f, 0.18502721f, 0.05370453f, 0.03632095f, -0.03308256f, 
    -0.07514869f, -0.07373781f, -0.02500441f, -0.03023743f, -0.38616347f, -0.41004032f, 0.53985548f, 0.36937323f, 
    -0.72611630f, 0.37190270f, -0.30081469f, 0.00659282f, 0.04734742f, 0.41273308f, 0.04175955f, 0.06572194f, 
    0.02192964f, -0.04473881f, 0.05064294f, -0.01972836f, 0.04017375f, 0.00041201f, -0.01992795f, 0.04131860f, 
    -0.08674949f, -0.38620165f, -0.01777103f, -0.05313062f, -0.34673429f, -0.15142402f, 0.03648058f, 0.03332555f, 
    0.03450275f, -0.08994699f, -0.05566012f, -0.20306210f, 0.05444046f, 0.02834455f, 0.03675329f, -0.04879921f, 
    -0.01577694f, 0.11726964f, 0.14829169f, 0.11065792f, -0.42405781f, 0.31013989f, -0.55829149f, 0.29169241f, 
    0.11339766f, 0.05184992f, -0.15617238f, 0.00502089f, 0.31749579f, 0.09771320f, -0.18721990f, -0.04713375f, 
    -0.01957097f, 0.09419550f, 0.02170365f, 0.04429414f, -0.06472760f, -0.36342117f, 0.09099000f, 0.14919779f, 
    0.02786165f, -0.16691263f, 0.13925216f, 0.11462715f, -0.17564102f, 0.06355105f, 0.09346574f, 0.11764348f, 
    -0.07048246f, -0.00767335f, -0.11041585f, 0.06243315f, -0.07750480f, 0.11128771f, -0.21249463f, 0.00005331f, 
    -0.16434397f, 0.06567469f, 0.07431041f, -0.29501513f, -0.01590094f, -0.11588786f, 0.25603205f, 0.22002330f, 
    -0.02128326f, -0.00279407f, 0.01330180f, -0.00006368f, 0.04883920f, -0.02771291f, -0.09628835f, -0.03561347f, 
    -0.02266290f, 0.00478550f, -0.06813043f, 0.09774280f, 0.09377266f, 0.00908314f, 0.17794564f, 0.17867020f, 
    0.13903433f, -0.48694038f, 0.31473899f, -0.03471027f, -0.08931662f, -0.15801612f, 0.08409415f, 0.08273058f, 
    0.05701332f, -0.00434140f, -0.20787689f, -0.02011464f, -0.01548195f, 0.09021527f, -0.02272912f, 0.00435326f, 
    0.04950238f, 0.11345712f, 0.15600950f, -0.06296459f, -0.37315872f, 0.08866547f, -0.49781641f, 0.11880119f, 
    0.04109393f, -0.02469025f, -0.03611131f, -0.08912794f, -0.10901909f, -0.03983061f, -0.06152164f, 0.15870869f, 
    0.07911584f, 0.00782730f, 0.03460680f, 0.07534304f, -0.12256143f, -0.15273736f, -0.13462296f, -0.19764653f, 
    0.07483019f, -0.45094451f, -0.35094476f, 0.02337843f, -0.47885013f, -0.17034882f, -0.11597624f, -0.26603049f, 
    -0.11545192f, -0.00044135f, -0.25963211f, 0.08548056f, -0.08515558f, -0.03125598f, 0.09435169f, -0.11343431f, 
    0.09332578f, -0.06666456f, 0.06661817f, 0.16141209f, -0.49932754f, 0.08194184f, -0.62943739f, -0.13900228f, 
    0.12432635f, -0.13775806f, -0.16366015f, -0.21397842f, -0.13508090f, 0.06034550f, -0.12869492f, 0.18004584f, 
    0.03435075f, -0.02685395f, 0.03153223f, -0.01316989f, -0.02627270f, -0.08580901f, 0.12359162f, 0.02992988f, 
    -0.19102155f, 0.01060005f, 0.34266350f, -0.05087379f, -0.19774494f, 0.12672615f, -0.07678177f, 0.25743315f, 
    -0.06718565f, -0.13630450f, 0.06137722f, -0.03453061f, 0.02706309f, 0.02577493f, -0.08663875f, -0.01164771f, 
    -0.14342563f, -0.17096870f, -0.35539630f, -0.12315173f, -0.27329874f, -0.10957734f, 0.26245558f, 0.51115805f, 
    0.27239084f, -0.08193380f, -0.04629098f, -0.25260624f, 0.42866048f, -0.25532714f, 0.02457074f, -0.16154587f, 
    0.05327531f, 0.16261299f, 0.19053704f, 0.14816429f, 0.06660970f, -0.37778369f, 0.16131945f, 0.21587478f, 
    0.30600163f, 0.01998553f, 0.41444123f, 0.15814778f, 0.07413879f, 0.01613054f, -0.10210955f, 0.23628408f, 
    0.05206911f, 0.00900005f, -0.01913443f, -0.00173582f, 0.06247341f, 0.14050530f, 0.09386414f, -0.01590990f, 
    0.01410264f, -0.05090988f, 0.02505796f, 0.05833061f, -0.23659562f, -0.21826011f, 0.19496508f, -0.09093566f, 
    0.00087795f, -0.13045840f, 0.05375192f, 0.06883872f, 0.15368347f, 0.00525364f, -0.11783872f, 0.06215484f, 
    -0.03439365f, 0.04227472f, 0.07165003f, 0.11378667f, 0.03177039f, 0.07043749f, 0.08916863f, 0.07455327f, 
    -0.45143521f, 0.19371414f, 0.09092186f, 0.15500897f, 0.08414538f, 0.03487466f, -0.06545985f, -0.27973297f, 
    0.18533561f, -0.08508880f, 0.09480955f, 0.00925177f, 0.03874465f, -0.02597606f, -0.03065834f, 0.00958192f, 
    -0.03846120f, 0.01422870f, -0.01486168f, -0.00156761f, -0.54329121f, 0.10341541f, -0.09772550f, 0.04829312f, 
    -0.12420297f, 0.07106296f, -0.03364068f, -0.02930628f, 0.29066947f, 0.10806330f, -0.08917566f, -0.09557954f, 
    0.04664440f, -0.02892949f, 0.05008854f, -0.12175559f, 0.05509967f, -0.09675967f, 0.28872749f, 0.26608911f, 
    -0.07682298f, 0.11025665f, -0.22723785f, 0.09587676f, -0.13872737f, -0.04499271f, 0.03493880f, 0.17460173f, 
    -0.27114293f, -0.06466407f, 0.11059584f, 0.04404441f, -0.05384220f, 0.03972792f, -0.13555928f, -0.07009516f, 
    -0.20039789f, -0.15789345f, -0.30411187f, -0.19229344f, -0.46564054f, -0.33922267f, -0.18452658f, 0.00454139f, 
    -0.06442405f, 0.04578556f, -0.09147232f, 0.35038993f, -0.28375155f, -0.12120587f, -0.02760225f, 0.10279611f, 
    0.02006797f, 0.05862468f, -0.03131974f, 0.06774691f, -0.04475297f, 0.13124156f, 0.00475231f, 0.25652581f, 
    -0.22831754f, -0.05667771f, -0.11737516f, 0.04406700f, -0.04636304f, -0.09605310f, 0.02142318f, -0.16645619f, 
    0.08452695f, -0.00600957f, 0.01642005f, -0.03337360f, -0.13920812f, -0.20742369f, -0.19360620f, -0.07732685f, 
    -0.05050734f, 0.05977900f, -0.08620083f, -0.12818711f, -0.26998967f, -0.02077552f, 0.38854519f, 0.08358160f, 
    -0.22797561f, -0.10753079f, 0.05622796f, 0.01086265f, -0.10082658f, -0.30667022f, -0.05866745f, 0.06397523f, 
    -0.16961081f, 0.10823875f, 0.01424020f, -0.13974519f, -0.08150392f, 0.01053091f, -0.37497425f, -0.38086295f, 
    0.15568717f, -0.09685367f, 0.15619370f, -0.01325052f, -0.05106676f, 0.10729550f, -0.05631373f, -0.08230025f, 
    0.01433995f, 0.01457560f, -0.06181967f, 0.04325418f, -0.00600276f, -0.00576416f, -0.12031735f, -0.13039413f, 
    -0.11713315f, 0.08933523f, -0.01361596f, 0.05552560f, -0.07884746f, -0.04797451f, 0.53590512f, 0.12399813f, 
    -0.21413261f, 0.01946547f, -0.01792798f, 0.00260351f, -0.04045589f, 0.13643198f, -0.09142661f, -0.05334412f, 
    0.13152629f, -0.01859194f, 0.02190359f, -0.18727671f, 0.07224249f, 0.23741236f, 0.11313995f, 0.12916040f, 
    -0.32934380f, 0.07128275f, 0.05637314f, -0.17453927f, 0.00969567f, -0.06518374f, 0.01470206f, 0.08046754f, 
    -0.05410480f, 0.08899961f, 0.01313820f, 0.06935187f, 0.06169174f, 0.11615644f, 0.02232109f, 0.05723767f, 
    0.18282589f, 0.13358213f, 0.14565966f, 0.24045753f, -0.38490212f, 0.14508763f, -0.02425010f, 0.17274414f, 
    0.15542518f, 0.04320781f, 0.00322404f, -0.07415433f, -0.08425865f, -0.12629007f, -0.05662991f, -0.09795339f, 
    0.01611784f, 0.00355488f, 0.02549610f, 0.02893369f, -0.03150334f, 0.05250889f, 0.02812444f, 0.11846855f, 
    0.57376641f, -0.05816624f, 0.44163093f, -0.17656325f, -0.07601660f, -0.20869870f, 0.02785212f, -0.08424098f, 
    0.14864239f, 0.01897327f, -0.00714034f, 0.01243775f, -0.08503135f, -0.03608845f, 0.10586917f, 0.03521974f, 
    -0.01440113f, 0.14983979f, 0.16926347f, -0.01502857f, 0.38623124f, -0.38407239f, 0.47677228f, 0.11949837f, 
    0.00453055f, -0.09137604f, -0.10238196f, 0.02049400f, 0.06445476f, -0.21852005f, 0.09375934f, -0.01239638f, 
    0.10709147f, 0.14283161f, 0.09056902f, -0.06166710f, 0.04950944f, -0.00973488f, -0.00470538f, -0.06547530f, 
    -0.34737763f, -0.39783812f, -0.20164140f, 0.13101003f, -0.23373675f, -0.01389199f, 0.00035948f, -0.19878733f, 
    0.22828873f, 0.03392884f, -0.23380744f, -0.00581750f, 0.02943790f, -0.03077318f, -0.06066941f, 0.19496056f, 
    -0.04964632f, -0.03073477f, 0.22252755f, 0.14152266f, 0.34150994f, 0.08082364f, 0.25956270f, -0.21581599f, 
    -0.04965822f, -0.05187985f, -0.08789731f, -0.03066247f, 0.04310137f, 0.06036216f, -0.16109666f, 0.12441027f, 
    -0.19543788f, 0.08746639f, -0.18066311f, -0.08547125f, -0.08235919f, 0.04334639f, -0.06383696f, -0.06031951f, 
    -0.17796069f, 0.18214683f, 0.04317617f, 0.16592380f, 0.29983351f, 0.04746694f, 0.05496158f, -0.08918922f, 
    -0.18120316f, -0.00313436f, -0.23025893f, 0.13071246f, -0.06403792f, -0.05288039f, -0.12221444f, 0.09746819f, 
    0.04688684f, -0.12040177f, -0.03158079f, 0.10893231f, -0.34494579f, -0.48914164f, 0.05370970f, -0.12717256f, 
    -0.17702623f, -0.12767313f, -0.10036817f, 0.11152498f, 0.07783354f, -0.13376500f, -0.19847898f, 0.02482026f, 
    0.06430970f, -0.05995204f, 0.11038874f, 0.12266546f, -0.03583929f, 0.13379385f, 0.11669410f, 0.01621347f, 
    0.01373400f, -0.11012512f, -0.09314433f, 0.35639411f, -0.08385331f, 0.07606200f, -0.16162755f, 0.05700029f, 
    0.23863479f, 0.22012097f, -0.14760794f, -0.01354155f, 0.04067497f, -0.08494928f, 0.05949472f, -0.01858512f, 
    0.21759930f, -0.28668997f, 0.12428492f, 0.16285893f, -0.19767439f, 0.04015269f, -0.19281708f, 0.05634364f, 
    0.32566860f, -0.08428419f, -0.04933268f, 0.21044423f, -0.26175413f, 0.03555466f, -0.09605917f, 0.08255481f, 
    0.05586792f, 0.07071861f, -0.01105894f, 0.17495868f, -0.18640625f, -0.19734493f, -0.26248166f, -0.12399797f, 
    -0.10760584f, -0.20819250f, 0.12598963f, -0.07403478f, -0.13730752f, -0.09851084f, 0.09065605f, -0.04258783f, 
    0.08457963f, -0.00895895f, 0.03634917f, -0.18071081f, -0.02704816f, -0.09051494f, -0.03398038f, -0.02483097f, 
    0.17299753f, 0.14676546f, 0.16094425f, 0.27963293f, -0.43003389f, -0.11175223f, -0.26905066f, -0.11842260f, 
    0.16001734f, -0.17102455f, -0.11465918f, -0.01247956f, -0.02007889f, 0.09242300f, -0.01734202f, 0.09879767f, 
    -0.10399295f, -0.05601782f, 0.10498612f, 0.07755399f, -0.07764459f, -0.01102946f, -0.02208213f, -0.02764241f, 
    0.04841573f, 0.00307647f, -0.02008711f, 0.17865197f, 0.01539663f, -0.09577454f, 0.21177293f, 0.01675346f, 
    0.13031876f, 0.04888281f, -0.15261430f, 0.07972123f, 0.03364133f, 0.08589049f, 0.04186401f, -0.04480132f, 
    -0.00481266f, -0.01564820f, -0.20471536f, -0.07244495f, -0.62390631f, -0.41295159f, -0.26637641f, 0.29400229f, 
    -0.10176755f, -0.07748305f, -0.26918992f, 0.04222009f, 0.09347554f, -0.21263598f, -0.12213620f, -0.00196466f, 
    -0.02733970f, 0.04424447f, 0.11308636f, 0.10914750f, -0.03816857f, 0.25095904f, 0.02740227f, -0.09346714f, 
    -0.22829419f, -0.11097249f, -0.19744784f, -0.24440682f, 0.07439091f, -0.05091779f, 0.08825683f, -0.09075192f, 
    0.09924830f, 0.04942427f, -0.06790803f, 0.01891027f, 0.06985907f, 0.15483743f, 0.08134217f, 0.03182566f, 
    -0.12656422f, -0.01550329f, 0.02817085f, -0.00441960f, 0.02614996f, -0.16572021f, 0.14346319f, -0.07094371f, 
    0.04627351f, 0.15287958f, 0.00653816f, -0.03239952f, -0.07239550f, -0.03303692f, 0.05439746f, -0.03249105f, 
    -0.03040829f, -0.00741257f, 0.06520857f, -0.11014447f, -0.01186096f, 0.00033168f, -0.12379889f, -0.25039864f, 
    0.39367130f, -0.11711686f, 0.43058512f, -0.51513267f, 0.14150643f, 0.12310172f, 0.18871771f, -0.12040504f, 
    0.17491336f, 0.12547614f, 0.05800878f, 0.13879761f, -0.00804472f, 0.07985816f, -0.11046726f, -0.07946391f, 
    0.13861825f, -0.08482122f, -0.12331623f, 0.05092565f, 0.21582864f, -0.28574198f, -0.37258774f, -0.30349535f, 
    0.08394439f, -0.08462563f, -0.15404324f, 0.17019305f, -0.18074040f, -0.18494622f, -0.03451318f, 0.02719402f, 
    0.06706262f, -0.06512168f, -0.04837438f, 0.13958059f, -0.04568012f, 0.06753968f, 0.02274341f, 0.03816086f, 
    -0.01104864f, 0.20242816f, 0.01457632f, 0.14988887f, -0.28572723f, -0.15066633f, 0.11682782f, 0.01821976f, 
    0.06775466f, 0.10252786f, -0.31873280f, -0.11197081f, -0.00417217f, 0.06374705f, -0.23711587f, 0.02840031f, 
    0.15000258f, 0.11628564f, -0.16397613f, -0.11844923f, 0.15068585f, -0.32936737f, -0.15161878f, -0.25283411f, 
    -0.20679712f, -0.00259750f, -0.08039472f, -0.09692400f, -0.13109626f, -0.01249927f, 0.01047295f, 0.03687489f, 
    0.11499748f, -0.05783682f, -0.15083520f, 0.06228115f, -0.09798684f, 0.05660309f, 0.02323884f, -0.03808285f, 
    0.36723116f, -0.47505590f, 0.21916312f, 0.70404780f, 0.14146699f, -0.00738711f, -0.08112015f, -0.16917667f, 
    0.06003761f, -0.14224096f, 0.03025130f, 0.11762919f, 0.08516204f, 0.04349320f, 0.09958589f, -0.00296383f, 
    -0.05164186f, 0.11054221f, 0.28426492f, -0.05543642f, 0.28567180f, -0.36532429f, 0.54601097f, -0.10690062f, 
    0.08273308f, -0.21017964f, -0.13434120f, -0.18610077f, -0.12884413f, -0.17562959f, 0.00058675f, 0.00178356f, 
    -0.00645401f, -0.04912984f, 0.04246175f, 0.01817502f, -0.03540054f, 0.09197767f, 0.08523040f, -0.20834889f, 
    -0.47561628f, 0.21758226f, -0.16781108f, 0.14873962f, 0.27631253f, -0.10350000f, 0.07658082f, 0.08443481f, 
    -0.22508726f, 0.26935500f, -0.16602059f, 0.21253251f, -0.03399847f, -0.04065461f, -0.01681753f, 0.20035130f, 
    -0.04531700f, 0.17487460f, -0.03775778f, -0.03063924f, 0.42146567f, -0.13739082f, 0.36149478f, -0.38909084f, 
    0.28201422f, 0.14312537f, 0.03554320f, -0.21305147f, 0.23001850f, -0.09425196f, -0.02480451f, -0.06130895f, 
    -0.03865743f, 0.09027807f, 0.03105237f, 0.10636048f, 0.02599747f, 0.00952416f, -0.08876191f, 0.13170955f, 
    -0.29666910f, -0.27835944f, -0.00200023f, 0.14821199f, -0.42873490f, -0.01703232f, 0.07981525f, -0.17315055f, 
    0.08331993f, 0.04313773f, -0.04816525f, 0.01715603f, 0.03199597f, -0.10242570f, -0.02197919f, 0.02498069f, 
    -0.02922687f, -0.03804042f, -0.04966589f, -0.01409196f, -0.28401050f, 0.12939364f, -0.12492666f, 0.10947923f, 
    -0.25625473f, -0.02670568f, -0.02284361f, 0.12515339f, 0.10452302f, -0.08170851f, -0.06357617f, -0.02044629f, 
    -0.07853597f, -0.01509048f, 0.02916652f, 0.07103447f, -0.11347055f, -0.01809490f, -0.13152653f, -0.25016266f, 
    -0.50425953f, -0.04748690f, -0.18313460f, 0.00960946f, 0.21724835f, 0.03739223f, 0.02362015f, -0.00056894f, 
    -0.02349204f, -0.04509303f, -0.00488011f, 0.09201822f, 0.06955639f, -0.01621034f, 0.08903226f, 0.26327357f, 
    -0.07438608f, 0.01882249f, 0.16490223f, 0.06704919f, 0.64438587f, -0.18408196f, 0.47887072f, -0.06821102f, 
    -0.07384981f, -0.09411927f, -0.04747484f, -0.05615076f, 0.07208782f, -0.19787949f, -0.09362429f, 0.11754485f, 
    0.02345835f, 0.13976863f, 0.06049372f, -0.13324197f, -0.06629075f, -0.09572753f, 0.08297789f, 0.13359001f, 
    0.03725978f, -0.22156459f, 0.07971100f, -0.16761105f, -0.39710188f, -0.12446646f, 0.06569077f, -0.13619292f, 
    -0.05281155f, -0.17974754f, -0.05931192f, 0.01505637f, 0.17995496f, 0.11593609f, -0.05564816f, -0.01061277f, 
    0.02963608f, 0.09614180f, 0.16032483f, 0.16716275f, 0.28951389f, -0.04320560f, -0.63088775f, 0.40817004f, 
    0.24838771f, -0.07877261f, 0.14679757f, -0.18078324f, 0.07550391f, -0.18815383f, -0.28810731f, 0.05471047f, 
    -0.02753828f, -0.01370617f, -0.03113850f, 0.24967228f, -0.01789252f, 0.04956784f, 0.08132095f, 0.05977808f, 
    -0.50438976f, -0.14035064f, -0.14074257f, 0.05058150f, -0.23638830f, 0.01359927f, 0.08357481f, -0.07141761f, 
    0.12041529f, 0.01467836f, -0.17852278f, -0.05194569f, 0.11018285f, -0.06225685f, -0.00973584f, -0.05293440f, 
    -0.04515816f, -0.03576178f, -0.00842772f, 0.03407906f, 0.16067494f, -0.04807608f, -0.07375018f, 0.65365505f, 
    0.24585988f, -0.08715899f, 0.24322419f, -0.07618235f, 0.19212452f, 0.11769649f, -0.14285751f, -0.02120311f, 
    -0.05806486f, 0.12119484f, 0.08691142f, -0.08891055f, 0.06359167f, 0.11350931f, -0.01844299f, -0.08129212f, 
    -0.12659469f, -0.01307083f, -0.30123383f, 0.14679334f, 0.05311803f, -0.10434469f, -0.12727495f, 0.10992727f, 
    -0.26802045f, -0.13266638f, 0.05574697f, 0.12086628f, -0.06243055f, -0.11221901f, -0.08190787f, 0.08779600f, 
    -0.12941879f, -0.05137759f, -0.17713287f, -0.08892441f, -0.02775958f, -0.23488724f, -0.40900952f, 0.36021912f, 
    -0.00851220f, 0.02617666f, -0.19127160f, -0.01298262f, -0.26439559f, -0.13557722f, 0.00323664f, 0.03776549f, 
    -0.13965759f, -0.06476610f, 0.04373924f, 0.03089933f, -0.08359542f, 0.07514269f, -0.05729354f, -0.12161776f, 
    -0.02767836f, -0.30662844f, 0.30997244f, -0.23576766f, 0.28464639f, 0.17540848f, 0.21891443f, -0.05272286f, 
    -0.00007202f, 0.07405757f, 0.04231026f, 0.07843804f, -0.02744724f, -0.05757941f, 0.10288306f, 0.07749567f, 
    0.08376472f, -0.01655340f, -0.09397526f, -0.01286754f, -0.17381430f, -0.01791324f, -0.26717097f, -0.21133316f, 
    0.21619146f, 0.01757998f, 0.23633911f, 0.06285832f, -0.21277738f, 0.04427196f, -0.00902825f, 0.19217466f, 
    -0.08649703f, 0.09187390f, 0.21164902f, 0.01552779f, -0.00476496f, 0.17637077f, 0.05293605f, 0.07858623f, 
    0.47714448f, 0.22906128f, 0.62004691f, 0.07868394f, -0.28332245f, -0.04302668f, 0.00726321f, 0.03125216f, 
    0.07945271f, -0.15535095f, -0.12481607f, -0.05551264f, 0.02493236f, 0.11140484f, -0.01562661f, -0.00867516f, 
    -0.04965472f, 0.04414869f, 0.07480131f, 0.10068287f, -0.45984450f, -0.20330346f, -0.17716117f, 0.14058986f, 
    -0.07492784f, 0.16181794f, 0.26710257f, 0.08035202f, -0.24899954f, 0.15555225f, -0.07071997f, -0.03722454f, 
    0.06260639f, 0.03932130f, -0.07039173f, -0.13157310f, -0.02415220f, 0.00590678f, -0.02192373f, 0.08165222f, 
    -0.36473888f, -0.10517846f, -0.37150604f, 0.54308426f, -0.31446165f, -0.08105882f, -0.13140185f, 0.04517831f, 
    -0.12609766f, 0.07406481f, -0.14889887f, -0.07270678f, -0.03657779f, -0.10387734f, -0.17187896f, 0.09644744f, 
    -0.05344609f, -0.00655824f, -0.03210950f, -0.10164344f, 0.34960315f, 0.12976784f, 0.24410152f, -0.10623114f, 
    -0.00724580f, -0.02566778f, 0.15641922f, -0.01067441f, 0.09605908f, -0.14874637f, -0.14514710f, -0.06473965f, 
    0.07382097f, 0.00472421f, 0.02305887f, 0.09523860f, 0.03019852f, -0.08594236f, -0.12990120f, 0.08822098f, 
    0.04989965f, 0.20854466f, 0.32820895f, 0.19993788f, -0.56330442f, -0.10416117f, 0.05891021f, 0.28387293f, 
    0.06685477f, 0.12514545f, -0.27182415f, 0.01440481f, 0.04794651f, 0.02957768f, 0.03746666f, 0.01469528f, 
    0.01125763f, 0.16717337f, 0.26459849f, -0.39947793f, -0.11370262f, -0.36991566f, 0.18693104f, -0.10000691f, 
    0.00950806f, -0.05137814f, -0.42612115f, 0.21179113f, -0.23162694f, -0.10999773f, 0.00576336f, 0.09578494f, 
    -0.08113386f, 0.08812906f, 0.05350678f, -0.01617071f, 0.00465546f, -0.00537841f, -0.11908667f, 0.03325200f, 
    -0.21427169f, -0.13893992f, -0.19337592f, 0.16458841f, 0.10946853f, -0.11647023f, -0.01695129f, 0.05170866f, 
    -0.04936427f, -0.09423950f, 0.03968702f, 0.14881015f, -0.09903365f, -0.07825602f, 0.04401158f, -0.01896691f, 
    -0.26203310f, -0.05982039f, -0.22263893f, -0.30853757f, 0.40317193f, -0.42445827f, 0.04683345f, -0.20270018f, 
    0.02905516f, -0.13942958f, -0.28467199f, -0.08595030f, 0.06143897f, -0.12397768f, -0.03574117f, 0.08381433f, 
    0.15739872f, -0.02500387f, -0.16484572f, 0.02535341f, -0.07257342f, 0.06274900f, 0.14269581f, -0.08861526f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.22778076f, 0.16218370f, 0.07268885f, -0.11699001f, -0.05965829f, 0.05002142f, 0.05626917f, -0.12406640f, 
    0.08221950f, -0.00896142f, -0.00683208f, -0.04613272f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
