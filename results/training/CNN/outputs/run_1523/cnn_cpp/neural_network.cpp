#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.50365949f, -0.20686534f, 0.27329019f, 0.37664056f, 0.56380206f, 0.33285132f, 0.16927736f, 0.42573264f, 
    -0.48051354f, -0.23954274f, -0.22819977f, -0.48170567f, -0.34854016f, -0.39052010f, -0.56275624f, 0.03419039f, 
    0.56463438f, 0.47047415f, -0.92621464f, 0.31120768f, -0.16455899f, 0.26162508f, 0.92933875f, 0.50147492f, 
    0.36236915f, 0.00602858f, 0.17844245f, -0.30676937f, -0.38370055f, -0.23821387f, -0.23350155f, -0.60175276f, 
    -0.15448876f, -0.26296866f, -0.58447015f, 0.80128920f, -0.80765444f, -0.34005609f, 0.30224118f, -0.27225563f, 
    -0.18258740f, -0.50715894f, 0.05245947f, 0.30233765f, -0.53051531f, -0.72820663f, -0.47309572f, -0.80226058f, 
    -0.40985459f, -0.30346131f, -0.15337485f, 0.03933320f, -0.24892592f, -0.22279082f, -0.26726672f, -0.36561695f, 
    -0.25888252f, 0.75642794f, 0.28637594f, 0.12546431f, -0.53099233f, -0.57539427f, -0.46555763f, 0.71481282f, 
    0.56064427f, 0.23446606f, -0.01116071f, 0.22128619f, -0.14015286f, 0.23896356f, -0.04029511f, 0.78320497f, 
    -0.94983631f, -0.87193847f, -0.16352914f, 0.81684226f, 0.55746329f, -0.17989619f, -0.01179486f, -0.22043645f, 
    -0.22420484f, 0.73081654f, 1.09476674f, -0.99017048f, -0.52943230f, -0.34778583f, -0.07502003f, 0.01728943f, 
    0.33768234f, 0.18307889f, -0.11807103f, -0.09647429f, 0.43955719f, -0.67001182f, -0.58635253f, -0.64463717f, 
    0.16081667f, 0.16951472f, 0.21258877f, -0.54006422f, -0.31997541f, 0.93625796f, -0.38997486f, 0.18393360f, 
    -0.40489140f, 0.12255876f, 0.01568448f, 0.48213530f, 0.21908438f, -0.03924415f, -0.16204850f, -0.00903770f, 
    -0.22579569f, -0.41063827f, -0.11446594f, 0.61896557f, -0.79158503f, 0.01980400f, -0.12950860f, 0.05986968f, 
    -0.52123016f, 1.28914154f, -0.62801647f, -0.06779590f, 0.14123116f, 0.06517942f, -0.15656985f, 0.25491914f, 
    -0.25165585f, 0.34091198f, 0.01291062f, -0.55995852f, 0.45456985f, 0.35365373f, 0.47877347f, 0.84105802f, 
    0.43083754f, 0.73153323f, -0.21246579f, -0.47187674f, -0.07318217f, 0.19133070f, 0.15933129f, -0.08980156f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.14546491f, 0.10499693f, 0.11765090f, -0.19280675f, -0.43906629f, 0.07916714f, 0.10747964f, 0.07593701f, 
    0.00494461f, -0.04010542f, 0.56918353f, 0.05787959f, 0.45858496f, -0.13044491f, 0.14553712f, 0.04189899f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.18029837f, 0.05560822f, -0.09585067f, 0.09395081f, 0.08238250f, 0.20930284f, 0.23230973f, 0.04700855f, 
    0.22352478f, -0.45906401f, -0.07484866f, -0.01510779f, -0.05443134f, 0.11814608f, -0.18895406f, 0.04565378f, 
    0.00514907f, -0.17879538f, -0.49821785f, -0.03565038f, 0.35192400f, 0.04083996f, 0.11099175f, 0.09361930f, 
    0.07949427f, 0.07849281f, 0.25055546f, 0.03170548f, 0.06124524f, 0.04358161f, 0.13184385f, -0.13412113f, 
    -0.35650456f, -0.09014668f, -0.12926662f, 0.02218376f, -0.25115690f, -0.21217211f, -0.49317488f, -0.10743615f, 
    -0.09121197f, 0.02861305f, -0.00078004f, -0.11744615f, 0.02164822f, -0.16210134f, 0.23379508f, -0.05198887f, 
    0.01281718f, 0.09633918f, -0.20792754f, -0.07368460f, 0.03895428f, 0.04693874f, -0.05180414f, 0.11288083f, 
    0.14775421f, -0.05341262f, 0.16757551f, -0.05588788f, -0.02436846f, 0.19815183f, 0.34236348f, 0.31011522f, 
    0.06777859f, 0.04175495f, -0.04119763f, 0.06348218f, 0.20593606f, -0.23551416f, 0.04210199f, -0.22905979f, 
    -0.27573222f, 0.00041856f, 0.44722402f, -0.04986398f, -0.02605138f, -0.04051611f, -0.06164855f, 0.17134981f, 
    0.14910051f, 0.54869711f, 0.01254074f, -0.30337626f, 0.12167251f, -0.03640407f, -0.01516464f, 0.07046026f, 
    -0.10520457f, -0.17104909f, 0.00066410f, -0.65589082f, -0.23207451f, 0.09238748f, 0.17254452f, 0.03447479f, 
    0.11249547f, -0.10364396f, 0.04043727f, 0.06524928f, -0.79612452f, -0.09029831f, 0.01519723f, -0.02512212f, 
    -0.08048595f, 0.09332589f, 0.09271868f, -0.13509715f, 0.02648304f, -0.33039820f, -0.32251695f, 0.07443231f, 
    -0.00370955f, 0.07607709f, 0.14046225f, 0.10437308f, 0.30107772f, -0.29605064f, -0.72145689f, -0.13264239f, 
    0.12304371f, 0.23182714f, 0.06126088f, 0.13163750f, -0.11505760f, -0.03383850f, 0.01230235f, -0.12915151f, 
    0.09796765f, -0.12114947f, -0.09229314f, 0.08185315f, -0.05400223f, -0.08315236f, -0.17329958f, 0.38489574f, 
    -0.07467280f, -0.04533384f, -0.09519058f, 0.14377499f, 0.00228993f, 0.09562653f, -0.12394757f, -0.06098625f, 
    0.10112543f, -0.08642352f, -0.05424602f, 0.10934503f, -0.12743625f, -0.39183572f, -0.15918578f, -0.14833303f, 
    -0.15567090f, -0.02473046f, 0.12953451f, -0.19209258f, 0.00127528f, -0.08220000f, -0.04885512f, -0.04690421f, 
    -0.12778510f, 0.20113169f, 0.20703411f, -0.08518980f, -0.02664720f, -0.02526929f, -0.19367799f, 0.08368187f, 
    0.00160643f, 0.19795194f, 0.00400581f, 0.31544018f, 0.07965948f, -0.16131788f, -0.04248823f, -0.06140529f, 
    -0.07153641f, -0.01816972f, -0.13573039f, 0.07348928f, 0.19497477f, 0.27178901f, 0.09453962f, 0.00661812f, 
    0.01010542f, 0.20321229f, 0.00809240f, 0.15344323f, -0.15202758f, 0.22123580f, 0.11142246f, -0.05356942f, 
    -0.26120895f, -0.08725303f, -0.02747742f, 0.06210105f, -0.03268244f, 0.12260255f, 0.03054817f, -0.23211029f, 
    -0.23929942f, -0.00187305f, -0.02193581f, 0.18725373f, -0.10684916f, -0.27149680f, -0.36230186f, 0.06692009f, 
    0.23695764f, -0.05274803f, -0.06589936f, -0.22436602f, -0.03328602f, 0.09916589f, -0.08516818f, 0.07430574f, 
    0.42433211f, -0.06948058f, -0.35957828f, -0.09826460f, -0.21369909f, 0.12800132f, 0.05825383f, -0.00063259f, 
    0.13690718f, -0.21815196f, 0.11454974f, 0.06427319f, -0.08773444f, 0.28504035f, -0.13850346f, 0.05705814f, 
    0.11861999f, -0.04835870f, -0.00574379f, 0.29679343f, -0.16070300f, -0.00437448f, 0.00340240f, 0.03333782f, 
    0.05854521f, 0.10510048f, -0.04279656f, 0.20527060f, 0.26794335f, 0.19207391f, 0.11247185f, -0.05427295f, 
    -0.00281089f, 0.22833796f, 0.05253499f, -0.14523377f, -0.11085760f, 0.22681113f, -0.36379743f, -0.08883186f, 
    0.08880185f, 0.04561394f, -0.03569762f, -0.20431380f, -0.02310322f, -0.15064129f, 0.14221385f, -0.02312338f, 
    0.08298494f, 0.12532687f, -0.24001674f, 0.03770694f, 0.10809370f, 0.12421584f, -0.00987147f, 0.06832656f, 
    0.03083044f, -0.07113440f, -0.06765570f, -0.23470946f, 0.20528401f, 0.26104096f, 0.07762392f, -0.03029209f, 
    0.25450900f, 0.00376243f, 0.19620444f, 0.14027746f, 0.00129546f, -0.01113918f, 0.09682801f, -0.10677459f, 
    0.11729874f, 0.19384012f, 0.00027484f, -0.11714593f, 0.07814739f, 0.10082969f, -0.04351299f, -0.01987248f, 
    0.09330559f, -0.32389262f, -0.03911592f, -0.16892275f, 0.04705032f, -0.10111356f, -0.05561506f, 0.13629313f, 
    0.04140199f, 0.13960108f, -0.09951486f, 0.01556659f, 0.06286700f, 0.11222332f, -0.08742822f, -0.06900851f, 
    0.09684397f, -0.03035579f, 0.11382674f, -0.21453302f, -0.00619445f, -0.08001872f, 0.09537674f, 0.08797419f, 
    -0.15751378f, 0.06056360f, 0.04441397f, -0.08642547f, -0.56313652f, -0.00026415f, -0.01366450f, -0.23514143f, 
    0.07119065f, 0.01601333f, -0.06093352f, -0.06600568f, -0.22259444f, -0.42417309f, 0.13274260f, -0.20226924f, 
    -0.09963033f, 0.01043872f, -0.15334401f, -0.00112062f, -0.00297209f, 0.04672552f, -0.04264085f, -0.04065750f, 
    0.07049540f, -0.06363320f, 0.06232837f, -0.07424771f, 0.10844307f, -0.07687072f, -0.08920236f, 0.09214427f, 
    -0.09991167f, 0.03689508f, 0.00860156f, 0.04730607f, -0.06605215f, -0.17381445f, -0.06736913f, 0.01411349f, 
    -0.41863722f, -0.01823813f, 0.00840340f, 0.15009396f, -0.12001221f, -0.03660790f, -0.01072579f, -0.12349604f, 
    -0.10944191f, 0.20621389f, -0.34452200f, -0.41288382f, 0.22465181f, -0.04602211f, 0.17986907f, 0.04292219f, 
    -0.01019085f, 0.09157310f, -0.08260433f, -0.01239491f, -0.15745294f, 0.06208067f, 0.21375543f, 0.07719937f, 
    0.15857062f, 0.12626271f, 0.16026212f, 0.11079579f, 0.33223522f, 0.12777829f, 0.08368969f, 0.05457568f, 
    -0.10713079f, 0.18908109f, 0.07351477f, 0.10162915f, 0.06526401f, 0.06145971f, -0.01807195f, 0.23936912f, 
    0.30510762f, 0.15334965f, 0.08163132f, 0.05302820f, 0.12805890f, -0.14407003f, -0.24759904f, 0.53956491f, 
    0.09972052f, -0.05879917f, -0.21624149f, -0.01477045f, -0.04578370f, -0.15191010f, -0.26726994f, 0.16609947f, 
    -0.00840348f, -0.06290303f, -0.05890949f, 0.00784233f, -0.00551505f, 0.08546546f, 0.12125016f, 0.08714207f, 
    -0.09626926f, 0.14674941f, 0.02081572f, 0.04966388f, -0.03497416f, -0.03564363f, 0.01877764f, 0.13072939f, 
    -0.10287732f, -0.00629571f, 0.35469693f, 0.00832188f, 0.12115206f, 0.13033612f, 0.10038043f, 0.18595898f, 
    0.00723636f, 0.01540642f, 0.26976836f, -0.06995489f, 0.14611052f, 0.25500533f, -0.19579087f, 0.04543199f, 
    -0.08933040f, -0.20266105f, -0.40108606f, -0.01416561f, 0.12318669f, 0.12051859f, -0.21525343f, -0.01864170f, 
    -0.16933073f, 0.15377034f, 0.02065866f, -0.01637418f, 0.18362141f, -0.05701813f, -0.29314527f, -0.10984846f, 
    0.03761920f, 0.07162332f, 0.06463000f, -0.05473488f, -0.17323327f, -0.06587879f, -0.02056853f, -0.32239118f, 
    0.21464561f, -0.22534376f, -0.07624267f, -0.17727612f, 0.08683220f, -0.10077029f, -0.19195910f, -0.15747121f, 
    0.05967923f, -0.06267719f, 0.15761095f, 0.05649661f, -0.02004211f, 0.03453810f, 0.16151375f, 0.01503335f, 
    -0.03677129f, 0.01506466f, 0.06787035f, -0.07732036f, -0.06724422f, -0.07412548f, 0.32060155f, 0.09657279f, 
    0.36775234f, -0.11001865f, -0.14160565f, -0.13091776f, -0.12908714f, -0.02142464f, -0.28578252f, -0.19855261f, 
    0.07515647f, 0.11380221f, -0.25986812f, -0.05472321f, -0.00539850f, -0.21724313f, -0.06387903f, -0.02279247f, 
    0.22068481f, -0.16249539f, 0.22218080f, 0.05308671f, 0.25054419f, 0.26467931f, 0.05961734f, -0.04514358f, 
    0.05043398f, -0.13949397f, -0.06382811f, 0.18724298f, -0.08659353f, 0.06996618f, 0.00518757f, -0.24683253f, 
    0.08002069f, -0.06439843f, -0.00236770f, -0.33276603f, 0.26913172f, 0.10020635f, 0.03023490f, 0.34605759f, 
    -0.10427451f, 0.09498551f, -0.11721186f, -0.00551529f, -0.02098363f, 0.04324936f, 0.34488449f, 0.04254395f, 
    -0.14395621f, -0.03849150f, 0.00331872f, 0.18426704f, 0.19050041f, -0.08939457f, -0.00596933f, 0.72738141f, 
    -0.05122352f, -0.03372787f, -0.09670758f, 0.00454035f, -0.06152540f, -0.05031913f, -0.00849918f, 0.14013451f, 
    0.03916408f, 0.07777608f, 0.16313352f, 0.00276015f, 0.08589755f, 0.00708319f, -0.24552044f, -0.02428737f, 
    0.18020174f, 0.24139117f, -0.20715255f, 0.04172329f, -0.23081639f, 0.06060047f, 0.02408984f, -0.18114688f, 
    -0.18430480f, -0.31278726f, -0.03285055f, 0.17516686f, -0.00598576f, 0.07659406f, -0.21000987f, 0.06400409f, 
    -0.03640166f, 0.06137550f, -0.10707201f, -0.01452735f, -0.13710237f, -0.15779850f, 0.13365790f, 0.02081501f, 
    0.08698659f, 0.20870982f, -0.45278785f, -0.28046688f, -0.03832553f, 0.05003418f, 0.03146660f, 0.02584151f, 
    -0.11587439f, 0.12606147f, 0.14939661f, 0.07078250f, 0.19579092f, -0.09754825f, 0.13500904f, -0.06942494f, 
    -0.04782144f, 0.17882270f, 0.06658327f, -0.07738627f, 0.20601536f, 0.20452654f, -0.22705054f, -0.04904122f, 
    -0.14321023f, 0.29040489f, -0.20482358f, -0.02298039f, 0.13948652f, 0.21671742f, 0.20769483f, 0.01182129f, 
    0.12402983f, 0.09738828f, 0.12799683f, -0.04767148f, 0.03271182f, -0.09567644f, 0.30575788f, 0.43436706f, 
    0.07977879f, -0.01383375f, 0.08734933f, 0.14084661f, -0.01492978f, -0.06759444f, -0.31396633f, -0.03959936f, 
    -0.09259588f, -0.29181921f, -0.10410392f, 0.10686103f, 0.03961239f, -0.00041695f, 0.05971668f, 0.17877176f, 
    0.32794097f, 0.34465724f, -0.13645452f, 0.03690384f, 0.07369071f, -0.00845236f, 0.02752910f, 0.05494227f, 
    -0.19095699f, -0.34134632f, 0.01970916f, 0.01172860f, 0.02458593f, -0.13368413f, 0.02891127f, 0.07431913f, 
    0.11765600f, -0.07051440f, -0.05886927f, 0.06932646f, -0.03311033f, -0.17637669f, -0.22886027f, -0.08895001f, 
    0.00917059f, 0.15618841f, 0.25048375f, 0.40174991f, 0.17505918f, -0.18673374f, -0.01532268f, 0.36530626f, 
    -0.07299230f, 0.02089038f, -0.00444617f, -0.00023503f, -0.07749248f, 0.00669558f, -0.13959190f, -0.01590317f, 
    0.00135690f, -0.17437480f, -0.06610065f, -0.12361144f, 0.18037562f, 0.05927866f, -0.18044475f, 0.18278708f, 
    -0.10836943f, -0.20304720f, 0.17881516f, 0.21670856f, -0.11876138f, -0.09107394f, -0.12940995f, -0.15892754f, 
    0.24546370f, -0.05000481f, 0.01312993f, -0.01430285f, 0.00922923f, 0.00597361f, 0.19363917f, -0.68486416f, 
    -0.23407622f, -0.10354756f, -0.05325604f, -0.16807634f, 0.03866012f, 0.10410005f, 0.17137943f, 0.04459672f, 
    0.39905286f, 0.21961530f, 0.08988735f, 0.00002163f, -0.08712444f, -0.09026190f, 0.12596342f, 0.04734128f, 
    -0.09137127f, -0.07870191f, 0.24757499f, -0.12839754f, -0.02855557f, -0.05295379f, -0.02219791f, 0.02764711f, 
    -0.28072348f, 0.15471390f, 0.41901049f, -0.06807141f, -0.26884928f, -0.21067308f, -0.16236560f, -0.00080030f, 
    -0.00221565f, -0.13128480f, -0.05730286f, -0.08375371f, -0.38493752f, 0.41948858f, 0.07748558f, 0.05391655f, 
    -0.06159523f, 0.13166128f, -0.08568930f, 0.04387601f, -0.98548770f, -0.19858678f, 0.09595021f, -0.21895507f, 
    0.03000421f, 0.01984602f, -0.02715584f, 0.10495547f, -0.18048987f, -0.20975828f, -0.61536688f, -0.63736480f, 
    0.05488933f, 0.04507733f, 0.11174957f, -0.02510248f, 0.07190683f, -0.11659963f, -0.46379560f, -0.38745224f, 
    -0.43427309f, -0.02668689f, -0.02562926f, 0.11761751f, 0.07110528f, 0.22046641f, 0.03121205f, 0.18158266f, 
    -0.01113020f, -0.00352232f, 0.03821426f, -0.10765704f, 0.06809233f, 0.06152155f, -0.00447416f, -0.11186302f, 
    -0.12646487f, -0.26760697f, -0.78795463f, -0.10311543f, -0.08792993f, 0.19716161f, 0.08646020f, -0.03555065f, 
    -0.11183619f, -0.18268736f, -0.02369407f, -0.17929725f, 0.04458777f, 0.09698632f, 0.34705350f, 0.04120598f, 
    -0.19783075f, 0.02658018f, -0.80759251f, 0.12541378f, 0.22461386f, 0.00299584f, 0.09570380f, 0.03365869f, 
    -0.08422020f, 0.08755029f, -0.10582129f, -0.25433525f, 0.17631324f, 0.15676849f, 0.22955924f, 0.12558243f, 
    -0.06669133f, 0.09317818f, -0.02017765f, 0.01604360f, -0.07635868f, 0.00731605f, 0.27736768f, 0.02588745f, 
    0.04027819f, 0.04299622f, 0.16739549f, 0.09473581f, 0.05130767f, -0.21548022f, 0.32290190f, -0.07235827f, 
    -0.04361674f, 0.08733246f, -0.16017675f, 0.16088824f, 0.04818247f, 0.06621571f, 0.15465303f, 0.06573644f, 
    -0.21045749f, 0.20033038f, 0.12386008f, 0.27702427f, 0.12166574f, 0.09799836f, 0.21732353f, 0.08521821f, 
    -0.03404165f, -0.08816977f, 0.02585758f, -0.13235977f, -0.25574222f, -0.01726231f, 0.00271785f, 0.13888252f, 
    0.06037876f, -0.07090980f, -0.00508397f, 0.05808295f, -0.16296412f, 0.02327198f, 0.04066828f, 0.12134308f, 
    0.21805832f, 0.05293565f, -0.01218435f, 0.13196008f, -0.06153092f, -0.09444156f, 0.07877065f, 0.03598259f, 
    0.08862713f, -0.04892911f, 0.26352006f, -0.02455032f, 0.03190472f, -0.11497342f, 0.02892495f, -0.02505308f, 
    -0.06270081f, 0.15380396f, 0.20834287f, -0.06344485f, -0.41082323f, -0.08218835f, 0.10249142f, -0.09849305f, 
    -0.21040902f, 0.10673291f, 0.03844810f, 0.08829465f, -0.07893474f, -0.27825347f, -0.13385554f, 0.12477830f, 
    -0.18717223f, -0.02395935f, -0.17650713f, 0.07005869f, -0.08307458f, -0.16341127f, -0.03226845f, 0.15474249f, 
    -0.06505911f, -0.00118401f, 0.08292006f, -0.01676028f, 0.10789061f, 0.07110304f, -0.19398476f, -0.03337151f, 
    0.07766744f, -0.11189076f, -0.01714265f, 0.03707815f, 0.05340292f, -0.14520907f, -0.10438360f, -0.19922659f, 
    -0.28677833f, -0.17694692f, -0.07731920f, -0.02372671f, 0.10921069f, -0.11935041f, 0.27880007f, -0.03745835f, 
    -0.45263794f, 0.00302560f, 0.37109667f, 0.07263868f, -0.07352253f, -0.02956824f, -0.13297284f, -0.12453393f, 
    -0.00779344f, 0.21488345f, 0.05080283f, -0.04328189f, 0.17395656f, 0.09280577f, -0.02437665f, 0.26118866f, 
    0.05731215f, 0.14346658f, 0.17027207f, -0.06401873f, 0.07385355f, 0.12102089f, 0.09392448f, 0.23383743f, 
    0.04575098f, 0.21611339f, 0.15384729f, 0.61887121f, -0.36545292f, -0.15837044f, 0.09127828f, -0.09697951f, 
    -0.10783054f, 0.00665317f, 0.00690269f, 0.37075260f, 0.12601876f, 0.11669591f, 0.28318366f, 0.26471394f, 
    0.21367778f, 0.15465105f, 0.25282934f, 0.22944434f, 0.11370310f, -0.10072856f, -0.73657793f, -0.23874889f, 
    -0.03684830f, -0.06249652f, -0.05595851f, 0.04181585f, 0.28715205f, 0.10584971f, -0.06859702f, -0.18881983f, 
    -0.03022810f, 0.03480039f, -0.06545138f, 0.01261211f, 0.12729393f, 0.24891071f, 0.20795928f, -0.32630008f, 
    -0.21788748f, -0.01245703f, -0.14409705f, -0.07170349f, -0.13969456f, -0.00002768f, 0.05776311f, 0.14503746f, 
    0.23642953f, 0.01673449f, -0.02364788f, -0.12608881f, 0.03289274f, -0.10488375f, -0.18558365f, 0.06203175f, 
    -0.09449167f, 0.04643597f, 0.04782084f, -0.01838059f, -0.01904216f, -0.00756641f, -0.08180183f, 0.08640776f, 
    -0.06719816f, 0.12620133f, -0.37870553f, -0.27678293f, 0.00119000f, 0.07342947f, -0.10314553f, -0.12987196f, 
    -0.14050719f, -0.00462140f, 0.08550559f, 0.19388741f, 0.12390979f, 0.31893352f, 0.06788854f, -0.01303483f, 
    -0.04875948f, 0.01004750f, -0.14435312f, 0.16495180f, 0.22319287f, 0.00267853f, 0.23990768f, -0.02933918f, 
    -0.16077596f, 0.01677754f, -0.00977387f, 0.06097377f, -0.13289946f, 0.16699311f, 0.18205483f, 0.01835003f, 
    -0.12828599f, -0.07935685f, 0.02731538f, 0.00731772f, -0.03543988f, -0.02791317f, -0.03858882f, 0.02408541f, 
    -0.13237646f, 0.00277404f, 0.08571179f, -0.06181934f, 0.07693318f, 0.02303790f, -0.03329516f, 0.44038638f, 
    0.24923000f, 0.34800172f, -0.15938702f, 0.07666417f, -0.12557408f, 0.08944305f, -0.00099305f, 0.19873157f, 
    0.36622831f, -0.08834983f, -0.21849595f, 0.02157287f, -0.03413770f, 0.02653338f, -0.03439943f, 0.03040420f, 
    -0.04704702f, 0.21557291f, -0.27192023f, -0.46897069f, -0.14939924f, 0.10421745f, 0.06888694f, -0.08081339f, 
    0.00179540f, -0.08281548f, -0.11546640f, 0.22398433f, -0.03147602f, -0.07937177f, 0.02202997f, -0.00064494f, 
    -0.03269238f, 0.06450404f, 0.12899391f, -0.22853701f, 0.04469819f, -0.23776540f, 0.06424120f, -0.03997516f, 
    0.27487674f, 0.00634649f, -0.00866152f, -0.00196110f, 0.03840696f, -0.08187234f, -0.16660148f, 0.15752375f, 
    -0.00132746f, -0.29533365f, -0.07875533f, 0.03255222f, -0.13598306f, -0.35364303f, -0.70886636f, -0.03945443f, 
    -0.06990672f, -0.07313064f, -0.21073332f, -0.09201827f, 0.12482924f, 0.06208116f, -0.02527419f, 0.15320958f, 
    -0.10120884f, 0.00388394f, -0.02152043f, -0.01127403f, 0.09584442f, 0.08296238f, -0.08378390f, 0.44769451f, 
    0.08977178f, 0.15999471f, -0.13359308f, 0.05408667f, -0.07053926f, 0.00081814f, 0.07033497f, 0.09268273f, 
    -0.02037850f, -0.02919926f, 0.00427296f, -0.04206637f, 0.06444691f, -0.02116005f, 0.03593210f, -0.05545248f, 
    0.01601149f, 0.02864909f, -0.07733961f, -0.08950450f, -0.02092525f, -0.03388791f, -0.06509552f, -0.04438965f, 
    -0.03110092f, 0.00835061f, -0.08230390f, 0.01892752f, -0.08241332f, 0.05599582f, -0.01480793f, -0.08652745f, 
    0.00438766f, 0.00521475f, 0.02310119f, 0.04749775f, -0.02259088f, 0.04286129f, 0.05817712f, -0.02978322f, 
    -0.06105405f, 0.05461209f, -0.04812350f, -0.08827352f, 0.05540071f, 0.01332213f, -0.04023678f, 0.02562552f, 
    -0.05997145f, -0.00748891f, 0.07505005f, -0.02265627f, -0.00938858f, 0.01217319f, -0.06280617f, -0.02058041f, 
    0.00975996f, -0.00310643f, 0.05647777f, 0.02931334f, -0.04772002f, 0.04474705f, 0.00256955f, 0.00568967f, 
    -0.07412209f, -0.04894133f, 0.01782851f, -0.09007435f, -0.01777927f, -0.05739886f, -0.02296015f, 0.06059228f, 
    -0.02854963f, 0.06934392f, 0.04722913f, 0.01582515f, 0.00743982f, 0.01520857f, 0.02467907f, -0.04475167f, 
    0.00022260f, -0.03176997f, 0.01674462f, 0.03829506f, 0.03625116f, 0.05295090f, 0.07566036f, -0.00306500f, 
    -0.00554918f, -0.04075772f, -0.00883128f, 0.06607214f, -0.01370573f, -0.04052228f, -0.03539298f, -0.02313182f, 
    -0.05695327f, 0.06686172f, -0.00436357f, -0.03846327f, -0.07142901f, -0.08655802f, -0.06169631f, -0.06986454f, 
    0.03071989f, -0.07631493f, -0.07337804f, -0.00333845f, -0.01559014f, -0.08043765f, 0.01330225f, 0.00409257f, 
    0.01849547f, -0.07843780f, -0.07779147f, 0.02570428f, -0.07272981f, 0.07100213f, 0.07202251f, -0.03399923f, 
    -0.06772827f, 0.05292045f, -0.01308832f, -0.02002079f, -0.06015124f, -0.05321252f, -0.01099413f, -0.06635793f, 
    -0.05350593f, -0.07007279f, -0.00248047f, 0.01073959f, 0.06848959f, 0.02111500f, -0.05712924f, 0.04835373f, 
    -0.04051303f, -0.01945982f, 0.07188423f, -0.05442484f, 0.05455836f, 0.05066492f, 0.02987227f, -0.07949995f, 
    -0.04803402f, -0.08070656f, -0.01513941f, -0.07677719f, -0.03205139f, -0.00456763f, -0.07261533f, -0.01595405f, 
    0.03691344f, -0.00648155f, 0.16119070f, -0.58063352f, -0.07804056f, -0.10373452f, 0.15669863f, 0.09293900f, 
    0.05705216f, 0.23323864f, -0.36459905f, 0.03090681f, 0.01713514f, 0.05103255f, -0.09393576f, 0.03086850f, 
    -0.12093012f, 0.01605429f, 0.23144795f, 0.21327138f, -0.03030401f, -0.31432098f, -0.11612353f, -0.28582504f, 
    0.09324574f, -0.07102497f, -0.06225156f, -0.00584259f, -0.09545296f, 0.20776016f, -0.18288217f, 0.04532160f, 
    -0.17975715f, -0.07511437f, -0.07655603f, -0.01809168f, 0.74359262f, -0.02364477f, -0.29533553f, 0.00928496f, 
    -0.19431961f, -0.14061739f, 0.14570102f, 0.00363206f, 0.02079005f, 0.04153108f, -0.01127054f, -0.18190759f, 
    0.02377230f, -0.15598641f, -0.08423664f, -0.03929631f, 0.23128687f, -0.28101572f, 0.12581606f, -0.14789280f, 
    0.07066623f, -0.12006222f, 0.16913192f, -0.24924710f, 0.10544169f, 0.15040895f, 0.17609087f, -0.14102392f, 
    -0.06988348f, 0.00605984f, 0.10762531f, 0.01203370f, -0.13962862f, 0.08842784f, 0.07053119f, 0.11062520f, 
    0.44804257f, -0.29499546f, 0.07385664f, -0.02392171f, 0.17951588f, -0.25415885f, 0.10006176f, 0.04632669f, 
    0.00665570f, -0.28130716f, 0.23660718f, 0.21917921f, -0.06932331f, -0.01682626f, 0.13082653f, -0.04576925f, 
    0.03835604f, 0.05771312f, -0.08598537f, 0.04450253f, 0.17705774f, 0.09595864f, -0.00441554f, 0.03554137f, 
    -0.02432769f, -0.12962517f, 0.06920257f, 0.48416436f, 0.16852550f, -0.29168028f, 0.08312250f, 0.13996026f, 
    0.13661486f, -0.01767324f, 0.02717199f, -0.12483716f, 0.18587904f, -0.18373467f, 0.48470828f, 0.01433478f, 
    -0.08972480f, 0.00435581f, -0.11037745f, -0.01509980f, 0.25707611f, -0.40370950f, -0.16061938f, -0.07505634f, 
    -0.24630396f, -0.17868584f, -0.26092675f, -0.06690831f, 0.03168352f, -0.18558307f, 0.31165597f, -0.09692148f, 
    0.13669533f, -0.01321234f, -0.07318568f, 0.02168433f, 0.04943674f, -0.04075820f, 0.06483070f, -0.17022556f, 
    0.04300830f, -0.07547853f, 0.06987710f, 0.05046658f, 0.13565351f, 0.09724567f, -0.08371071f, 0.02254505f, 
    0.20743169f, 0.03450756f, 0.16958849f, -0.06047648f, 0.03931251f, -0.00167922f, 0.14393973f, 0.07163259f, 
    -0.12744242f, 0.04509967f, 0.27255270f, 0.07132231f, -0.31702575f, -0.11146332f, -0.00486287f, 0.11299250f, 
    0.16429728f, 0.25367349f, -0.06800123f, 0.21119627f, 0.42687255f, -0.05665907f, 0.02325194f, -0.02102400f, 
    0.12955290f, -0.04302282f, -0.21935864f, -0.64504021f, -0.38779142f, -0.22643144f, -0.32116139f, -0.21909285f, 
    -0.10096616f, 0.12088473f, 0.03499136f, 0.03528570f, -0.37473816f, -0.57680243f, -0.92650992f, -0.00267910f, 
    -0.25998452f, -0.09630225f, 0.06734447f, 0.08012977f, 0.16341637f, -0.22324662f, -0.58822697f, -0.53722680f, 
    0.19903362f, -0.18426678f, -0.04282686f, -0.03946657f, -0.00483625f, 0.04066418f, 0.23964360f, 0.09658125f, 
    0.05378486f, -0.02269331f, -0.14574297f, -0.07721469f, 0.22461139f, -0.13436101f, 0.03272996f, 0.10342839f, 
    0.05922655f, 0.07616907f, 0.16904365f, -0.00236460f, 0.20502490f, 0.13963526f, -0.13567825f, 0.11247011f, 
    -0.23008037f, 0.60898143f, 0.43976957f, -0.13951872f, -0.15257809f, -0.49931860f, 0.22268395f, 0.03427556f, 
    -0.15015143f, -0.38140503f, 0.31675154f, -0.12588193f, 0.22690304f, -0.07772070f, -0.13765390f, 0.05027876f, 
    -0.01788526f, -0.11792898f, 0.06197694f, 0.25711784f, -0.14249739f, 0.13365576f, -0.12779295f, 0.12797621f, 
    0.00902912f, -0.18881953f, -0.02886305f, -0.14934380f, -0.00863495f, -0.00990545f, -0.17147686f, 0.01813586f, 
    -0.01602708f, 0.00423230f, -0.06770767f, 0.10889497f, -0.49324334f, -0.46643558f, -0.58279616f, -0.20554504f, 
    -0.08163517f, -0.26883054f, 0.05613866f, 0.02797206f, 0.02715560f, -0.26454350f, -0.37770778f, -0.17883496f, 
    -0.29625320f, 0.08534797f, -0.32731348f, -0.15249620f, -0.11628997f, -0.26545912f, 0.18635324f, -0.04437644f, 
    -0.01629859f, 0.05043122f, 0.11092645f, -0.13716921f, 0.23690467f, -0.06062088f, 0.22023416f, 0.01705286f, 
    0.12730829f, 0.11556466f, 0.09078126f, 0.17903116f, 0.26202610f, 0.14564186f, 0.02474214f, 0.08855796f, 
    0.14916694f, -0.36034384f, -0.34718511f, 0.06541133f, -0.08392753f, -0.13290161f, 0.14878573f, 0.08576954f, 
    -0.01832572f, 0.30604300f, 0.34883341f, 0.36916363f, -0.01068803f, 0.22137201f, -0.16889821f, -0.04341272f, 
    -0.02312575f, 0.13472605f, -0.31405461f, -0.14915137f, -0.29829493f, -0.15155123f, -0.08669437f, 0.05272704f, 
    0.12656145f, 0.06209611f, -0.02615745f, 0.18092018f, 0.38411060f, 0.06535898f, 0.06137193f, 0.06181987f, 
    -0.21943888f, 0.15812883f, 0.07091123f, -0.01489508f, 0.12199493f, 0.16434984f, 0.33441105f, -0.11492811f, 
    0.02832945f, 0.00922644f, 0.08141154f, -0.04375406f, -0.08165587f, 0.08454674f, 0.19239265f, -0.07745291f, 
    -0.13752805f, -0.01084406f, 0.13585788f, 0.21591763f, -0.06763317f, 0.04098038f, -0.06531692f, 0.05633108f, 
    0.12467346f, -0.13513102f, 0.00931034f, -0.13747787f, 0.17464007f, -0.09089778f, 0.09446666f, 0.10746684f, 
    -0.18983741f, -0.17572787f, 0.01382435f, 0.27246627f, 0.01000772f, 0.11218191f, -0.11309667f, 0.03698631f, 
    0.00239311f, -0.24396728f, -0.21417746f, -0.13915488f, -0.14324798f, 0.13361007f, 0.13283139f, -0.05473898f, 
    0.16699302f, 0.28719571f, -0.16963969f, -0.93742162f, -0.22024697f, -0.13301297f, -0.01196615f, 0.13866584f, 
    0.13913320f, -0.01481341f, 0.12351983f, 0.15724654f, 0.29632396f, -0.05604587f, 0.10836248f, -0.10720169f, 
    -0.08809914f, -0.03553087f, -0.13566500f, 0.11537910f, 0.01949906f, 0.15270136f, -0.02447491f, -0.08192237f, 
    -0.13059196f, 0.10048724f, 0.09943500f, 0.09527748f, -0.12715274f, -0.12416034f, 0.16996641f, 0.15076835f, 
    0.13329796f, -0.04820762f, 0.10131886f, -0.14170931f, -0.21206209f, -0.33838356f, -0.30842870f, -0.29206043f, 
    -0.05184128f, -0.06555156f, 0.03796701f, 0.05577993f, 0.13444801f, -0.20875831f, 0.09064362f, -0.06166276f, 
    -0.12622598f, -0.00874353f, -0.09346348f, 0.06582050f, 0.09723546f, 0.03504214f, 0.12474973f, 0.00541191f, 
    -0.48294407f, 0.10215334f, 0.16687845f, 0.00964456f, -0.18624513f, 0.01084074f, 0.09827134f, 0.16489227f, 
    -0.10287900f, -0.01491218f, -0.15159002f, -0.04366768f, 0.27651194f, -0.04542506f, -0.05913781f, -0.00469339f, 
    -0.05928662f, 0.17004330f, -0.01743376f, 0.01266697f, -0.14731993f, 0.05564941f, -0.03713963f, 0.26221204f, 
    -0.04170547f, 0.17681156f, -0.10819148f, -0.14483990f, -0.15372212f, 0.13546589f, 0.09350560f, -0.07725544f, 
    0.03521915f, 0.03445082f, 0.04595030f, 0.19835839f, -0.13430512f, 0.08970727f, -0.15415163f, 0.09426484f, 
    -0.04043906f, 0.18269569f, -0.09769401f, -0.04068122f, -0.32204607f, -0.31026733f, 0.21565796f, -0.06033911f, 
    0.14758202f, 0.08167417f, -0.09469596f, 0.14398099f, -0.08605862f, -0.16703950f, 0.04024266f, 0.07065564f, 
    -0.10353909f, -0.00476833f, -0.09457684f, 0.00394814f, 0.02060575f, -0.09250187f, -0.12950993f, -0.02892459f, 
    -0.11112219f, 0.14996164f, -0.13747889f, -0.05462819f, -0.34249267f, -0.44235942f, -0.41951963f, -0.01893025f, 
    0.05496272f, 0.03655796f, 0.01227092f, 0.24129087f, 0.11099218f, 0.02644748f, -0.04216035f, 0.37076113f, 
    -0.18782975f, -0.17240632f, 0.07297954f, 0.10256625f, -0.03488879f, -0.22725692f, -0.06472638f, -0.16603719f, 
    -0.22186074f, 0.12649174f, 0.25725368f, 0.24298081f, -0.02742493f, 0.18381378f, 0.32308102f, 0.04425815f, 
    0.32001045f, -0.09639616f, 0.02480256f, 0.09466639f, -0.15186445f, 0.04842464f, 0.06192601f, 0.16799980f, 
    0.11051825f, 0.13005963f, 0.13709396f, -0.00235144f, 0.44837019f, 0.03327192f, 0.12409402f, 0.10106792f, 
    0.11665677f, -0.05240251f, 0.15557463f, 0.11424518f, 0.06544732f, 0.09960943f, 0.02461872f, 0.05591359f, 
    0.16913939f, -0.10864589f, -0.21428351f, -0.01169675f, -0.19763088f, 0.28534406f, 0.00441702f, 0.20451140f, 
    -0.02191658f, -0.02464809f, 0.15612388f, 0.08382967f, 0.06009519f, -0.07015460f, -0.15077917f, 0.21138018f, 
    0.09935611f, -0.04586265f, -0.09339940f, 0.02805186f, 0.18266675f, 0.42759871f, 0.08857479f, -0.10505337f, 
    0.13715431f, 0.06078927f, -0.06101124f, 0.14078571f, 0.06758792f, -0.07846842f, 0.06903859f, 0.04436896f, 
    0.33461368f, -0.16906834f, -0.36731741f, -0.00776380f, 0.09218819f, 0.18942352f, 0.07677310f, -0.10578681f, 
    -0.12236218f, 0.03989524f, -0.01238965f, 0.10901587f, 0.16630737f, 0.20046650f, 0.03225453f, -0.00242873f, 
    0.11244212f, -0.09087011f, 0.14637497f, -0.05406207f, -0.06500634f, -0.03002141f, 0.28747562f, 0.18104067f, 
    -0.28575662f, -0.20331500f, 0.01282802f, 0.08459699f, 0.13321996f, 0.06891634f, 0.16890576f, 0.02952497f, 
    0.00191464f, -0.09919881f, -0.17363855f, -0.13744211f, 0.07219270f, 0.20566228f, 0.04045255f, 0.39328310f, 
    0.22763157f, -0.01514398f, 0.06234104f, -0.06862789f, 0.27396491f, 0.10255130f, -0.09512929f, 0.18092087f, 
    0.18200630f, 0.06963052f, -0.09476886f, -0.11865201f, 0.02791675f, 0.15289012f, -0.05222691f, -0.04184973f, 
    -0.04424493f, -0.00316091f, 0.02122490f, 0.10805207f, -0.00707197f, 0.23353826f, 0.13623817f, -0.10081303f, 
    0.14085358f, -0.13992336f, 0.01174049f, 0.04339911f, -0.02046818f, -0.04452059f, 0.05725754f, -0.13076591f, 
    -0.07004098f, -0.20009737f, 0.14202420f, -0.08782399f, 0.09098725f, 0.25568670f, 0.11622122f, -0.04412849f, 
    0.23934202f, -0.09630086f, 0.36318943f, 0.00594216f, 0.13766612f, -0.10968271f, -0.14119652f, 0.07976903f, 
    -0.00971361f, -0.15041147f, 0.14272000f, 0.09821981f, 0.06451680f, 0.06598943f, -0.16152236f, -0.07977668f, 
    -0.15687530f, -0.19921371f, -0.06559055f, 0.45848998f, -0.08521284f, -0.04557868f, 0.03186668f, -0.20996758f, 
    -0.16317946f, 0.13682792f, 0.10318119f, -0.19888772f, 0.00165948f, 0.18404992f, 0.14866613f, 0.03728401f, 
    -0.02378340f, 0.07620631f, 0.06204105f, -0.08802717f, 0.13703021f, 0.35628581f, -0.08483274f, 0.12590267f, 
    0.26648721f, 0.02760896f, 0.09956329f, -0.22337765f, 0.09048040f, 0.24058224f, 0.05185333f, -0.08699629f, 
    -0.09663194f, 0.04791653f, 0.02388057f, 0.19114316f, -0.04838883f, -0.21779034f, -0.43262175f, 0.26018807f, 
    0.42334729f, -0.20608811f, -0.06288116f, -0.17044722f, 0.06885929f, 0.03443498f, -0.01530634f, 0.09355173f, 
    -0.21993248f, 0.11753979f, -0.07198186f, -0.12038808f, 0.16433011f, -0.03500375f, -0.07578991f, -0.09058470f, 
    0.13679817f, -0.14326403f, -0.50362217f, -0.09877550f, -0.17821366f, -0.06717066f, 0.07514305f, 0.06022367f, 
    -0.01195051f, 0.05745744f, -0.00334047f, -0.22977859f, -0.57925504f, 0.10159655f, 0.04744059f, 0.08618674f, 
    0.08023867f, -0.00997355f, -0.02997234f, -0.05522234f, -0.06162223f, -0.41236648f, -0.03593124f, -0.10709640f, 
    0.09511796f, -0.05515055f, 0.09380852f, 0.03796164f, 0.48960531f, -0.65229267f, -0.00309129f, -0.24321292f, 
    -0.12149604f, -0.02399535f, -0.01174761f, -0.03226929f, 0.01564192f, 0.51610172f, -0.15830648f, -0.54112506f, 
    -0.08478486f, -0.13459711f, 0.25850260f, 0.02625320f, 0.02993879f, -0.00360128f, -0.11033847f, -0.30337346f, 
    -0.18895395f, -0.09949356f, -0.06947865f, 0.03415460f, 0.09018601f, 0.01139508f, 0.06682866f, 0.17853509f, 
    0.39227226f, 0.20719302f, -0.09239276f, 0.05000590f, 0.06492833f, -0.03632424f, -0.06071624f, 0.03278743f, 
    0.03489908f, -0.08408799f, -0.70443326f, 0.08302670f, -0.07862017f, 0.30889553f, -0.05052678f, -0.11819459f, 
    0.04061573f, -0.33542076f, -0.35738203f, 0.03997058f, 0.00476561f, 0.21268919f, -0.11763941f, -0.14416067f, 
    0.10780827f, -0.11885377f, 0.18727961f, -0.05394707f, 0.35681140f, 0.07025559f, -0.01409343f, 0.02030947f, 
    0.03150054f, 0.17392007f, -0.02860336f, 0.00832804f, -0.46434206f, -0.15763180f, -0.01023528f, -0.07410775f, 
    -0.16804710f, 0.10018961f, -0.04419067f, -0.12596317f, 0.01172379f, 0.18591788f, -0.01543277f, 0.23158860f, 
    0.00836739f, 0.05596150f, 0.08502517f, -0.01930911f, 0.29042447f, -0.24001859f, -0.34672138f, -0.31972998f, 
    0.16549501f, 0.05761921f, -0.38219538f, 0.19313204f, 0.08671466f, -0.20960172f, -0.17897375f, -0.05232113f, 
    -0.13426676f, -0.09097026f, 0.06003324f, 0.10654525f, 0.18820405f, 0.20788968f, -0.32582486f, 0.41458148f, 
    0.47982135f, 0.26443362f, -0.07818818f, -0.17355454f, 0.04339852f, 0.04266570f, 0.09317292f, -0.11628815f, 
    -0.00690239f, 0.09894247f, 0.19459213f, 0.04871224f, -0.06301194f, -0.08377953f, 0.01342551f, 0.12875257f, 
    0.05816067f, -0.05192031f, 0.22262260f, 0.24387501f, 0.03937043f, -0.00673431f, -0.14613083f, -0.01761834f, 
    -0.04147264f, 0.15110308f, 0.08976179f, 0.03132794f, 0.47810644f, -0.33278337f, -0.16656943f, -0.26306301f, 
    0.13000526f, 0.02417688f, 0.13866612f, 0.05441807f, 0.07872040f, 0.42137161f, -0.03657862f, 0.00475020f, 
    -0.27888492f, 0.09747197f, -0.26385099f, 0.23074348f, -0.15193290f, 0.06269168f, 0.31945509f, -0.12380137f, 
    -0.09869381f, -0.15669014f, 0.03265437f, 0.17713735f, 0.27104115f, 0.01663543f, 0.13294633f, 0.23215793f, 
    0.01140080f, -0.05658923f, -0.42775637f, -0.02569708f, 0.10599695f, 0.02782524f, -0.20541349f, -0.06394161f, 
    -0.02565385f, -0.08114465f, 0.08839916f, -0.01194964f, 0.17861804f, -0.03954918f, 0.21873471f, -0.02159144f, 
    -0.25914815f, -0.10162985f, 0.20777425f, -0.15094601f, -0.03944409f, -0.10768282f, -0.10817201f, 0.15998696f, 
    0.10134970f, -0.22675009f, 0.43468332f, -0.04625591f, 0.01853823f, -0.17341255f, 0.03911084f, -0.01585225f, 
    0.04411680f, -0.20422709f, 0.06837951f, -0.63827038f, -0.09566870f, -0.08264331f, 0.12372909f, 0.05646524f, 
    0.07663248f, -0.18656233f, 0.06821319f, 0.20731996f, 0.06272639f, -0.01452594f, 0.04012075f, -0.01264344f, 
    -0.01153879f, 0.09622373f, -0.02755982f, -0.11776441f, -0.11489773f, -0.22935705f, -0.05813415f, 0.06625423f, 
    -0.05469145f, -0.07098263f, -0.05456369f, -0.05817269f, -0.00161796f, -0.08763001f, 0.49097738f, 0.16436097f, 
    -0.12371762f, 0.02896475f, 0.18140554f, -0.19913313f, 0.29086524f, -1.28473210f, -0.63095957f, 0.51119322f, 
    -0.03356028f, 0.12121519f, -0.27833113f, 0.01786272f, 0.04101995f, 0.08913686f, 0.22989614f, -0.00425739f, 
    -0.29745260f, -0.04945095f, 0.16371560f, -0.05330848f, -0.04333299f, -0.02961983f, 0.14343648f, 0.16384922f, 
    -0.44386551f, -0.54651654f, 0.05108164f, -0.01347368f, 0.03638475f, 0.00737885f, 0.08186959f, -0.08271372f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.29196501f, -0.11332165f, 0.42711264f, 0.11394000f, -0.04757811f, 0.27742001f, 0.50379163f, -0.02900580f, 
    0.06128954f, -0.09744388f, -0.09425449f, -0.07767174f, 0.02030370f, -0.06311636f, 0.27396780f, 0.03631295f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.07936292f, 0.25218734f, -0.32726100f, 0.19506092f, -0.23602295f, -0.03272548f, 0.10934756f, 0.25211096f, 
    0.22403590f, 0.20659913f, 0.07879712f, 0.04857691f, -0.22982119f, 0.35432467f, -0.24364261f, 0.23608060f, 
    -0.14064187f, 0.14692976f, 0.12241609f, 0.00799557f, 0.33046317f, -0.03916912f, 0.18942605f, -0.74985260f, 
    -0.10374223f, 0.13770308f, 0.01037629f, 0.34196594f, -0.04545135f, -0.11658620f, -0.01166597f, 0.45282957f, 
    -0.13457689f, 0.15675709f, -0.02671902f, -0.43325809f, -0.08377271f, -0.40597796f, 0.35943183f, -0.27937990f, 
    -0.14467017f, 0.09299731f, 0.08391962f, 0.41257197f, -0.00091841f, 0.30483446f, 0.02246642f, 0.06184169f, 
    0.68076187f, -0.54269195f, 0.15695806f, -0.01208504f, -0.41007552f, -0.41713130f, 0.21464649f, -0.71472216f, 
    -0.24839167f, -0.00051629f, -0.07055406f, 0.28831565f, -0.35491121f, 0.37539408f, -0.59135491f, 0.25445318f, 
    -0.07488770f, 0.19032019f, -0.17670825f, 0.16071789f, 0.23805976f, 0.01909298f, -0.13499933f, 0.14662252f, 
    -0.12657450f, -0.22698987f, -0.15463893f, -0.25387377f, -0.23212101f, -0.15906382f, 0.12300219f, -0.23240332f, 
    -0.18387577f, 0.19338261f, -0.57184815f, 0.22999039f, -0.08638025f, -0.35513040f, -0.16263688f, 0.04874107f, 
    0.24911135f, 0.20361336f, 0.07462475f, 0.23244630f, -0.44463980f, 0.36178732f, 0.47608852f, 0.45626116f, 
    -0.62202394f, 0.19346255f, 0.23668075f, 0.03864962f, 0.21404360f, -0.32099283f, 0.22975276f, -0.10841206f, 
    0.04640245f, -0.36036053f, -0.49728191f, 0.10581897f, 0.47958425f, -0.53915453f, 0.31718224f, 0.08723179f, 
    -0.37251624f, 0.10322823f, 0.06236203f, 0.32067907f, 0.10650741f, -0.13594736f, 0.18709366f, -0.05206100f, 
    0.24607353f, -0.25407189f, 0.04862238f, 0.15185834f, 0.02321354f, -0.09825273f, 0.30371028f, -0.39148989f, 
    -0.00402317f, -0.04203140f, -0.02194852f, 0.10480423f, -0.24808846f, -0.23244096f, -0.13171397f, -0.05102658f, 
    -0.14579007f, 0.12405621f, 0.03687032f, 0.03940053f, -0.14476828f, 0.10099051f, -0.32200244f, -0.26918575f, 
    -0.06075008f, 0.45653263f, -0.23167464f, 0.24395891f, 0.12164801f, -0.20104001f, -0.07299019f, -0.00040401f, 
    0.04930243f, -0.35485929f, -0.01090522f, 0.61423397f, 0.07188588f, 0.28984305f, -0.38275132f, 0.35200733f, 
    -0.62964302f, -0.41145363f, 0.10052765f, -0.71099114f, 0.36155340f, 0.32334945f, -0.01498685f, 0.33749908f, 
    0.23926519f, -0.10380327f, -0.23946644f, 0.53699499f, 0.24705437f, -0.22648641f, -0.70728064f, 0.49661842f, 
    -0.49932948f, 0.09656782f, -0.11530235f, 0.10039800f, 0.51379973f, -0.31830314f, 0.28413451f, -0.07640838f, 
    -0.20308052f, 0.07973020f, 0.04675656f, -0.30845729f, 0.25237179f, -0.11032824f, 0.08196209f, -0.10387196f, 
    0.29633924f, -0.11600507f, 0.17804186f, 0.15249832f, 0.19457343f, 0.10927076f, 0.13280320f, -0.10966144f, 
    0.23944388f, -0.51011044f, -0.00941493f, -0.21281445f, -0.00913752f, 0.04734426f, 0.43815821f, 0.08311410f, 
    0.16776511f, -0.19942635f, 0.28910193f, 0.24777959f, 0.17404220f, 0.19989584f, 0.08946067f, -0.70656961f, 
    0.19334923f, 0.01796531f, -0.21350579f, 0.31605342f, -0.16725133f, 0.34980333f, -0.70311618f, 0.06025731f, 
    -0.19297962f, 0.20211405f, 0.40228629f, 0.23386903f, 0.00729637f, 0.23476301f, 0.16312173f, -0.88243645f, 
    0.02784003f, 0.44463152f, -0.42191109f, -0.37075904f, 0.01567241f, -0.24275039f, 0.11249468f, 0.23147428f, 
    0.14902677f, 0.04585441f, -0.10142549f, -0.17865595f, -0.33651042f, 0.35113928f, 0.14769468f, -0.26787207f, 
    0.02079705f, 0.14856850f, 0.06795086f, -0.05599350f, -0.20391779f, 0.34750384f, -0.00773592f, 0.07706138f, 
    -0.17266148f, -0.29240939f, 0.04846710f, 0.09713109f, -0.45990998f, 0.25901756f, 0.02582291f, 0.28596452f, 
    0.21228768f, -0.23502623f, 0.04671599f, 0.30682829f, 0.15250619f, 0.02818225f, 0.29682374f, 0.32553518f, 
    -0.05289322f, -0.05681261f, 0.13008448f, 0.09891132f, 0.25636557f, 0.22292897f, -0.17902060f, 0.24011287f, 
    0.14564331f, -0.11912205f, -0.09391492f, -0.25937113f, -0.05685483f, 0.24035907f, -0.27568868f, -0.09163883f, 
    0.58529884f, -0.62677521f, -0.29060397f, 0.36019027f, -0.45700049f, -0.12253148f, 0.33360609f, -0.40801859f, 
    0.17806073f, -0.12311999f, -0.19818799f, 0.04356175f, -0.26973647f, 0.37715420f, 0.13312708f, 0.48155320f, 
    0.04614984f, 0.13911615f, -0.07271475f, 0.24176949f, -0.41965282f, -0.21197379f, -0.31210011f, 0.21151231f, 
    -0.22326404f, -0.16605914f, 0.27291581f, 0.64380699f, -0.15043578f, -0.02081717f, -0.16389413f, -0.24871720f, 
    -0.07869565f, -0.34321800f, 0.20201585f, 0.47519815f, 0.21567859f, 0.20130751f, 0.00289842f, -0.07851186f, 
    -0.20037122f, -0.27497572f, -0.04470165f, -0.28328887f, 0.36889642f, -0.18302384f, -0.13024136f, 0.22412637f, 
    0.31900853f, -0.18077277f, -0.22794259f, 0.23098052f, -0.21399340f, -0.44911763f, 0.33106872f, 0.01431253f, 
    0.22733673f, -0.22709133f, 0.19408675f, -0.17622522f, 0.16922764f, 0.06179560f, 0.02934407f, -0.31092742f, 
    -0.01135271f, 0.12240463f, -0.25771931f, -0.16841106f, -0.13913572f, 0.07442563f, 0.24426135f, -0.24554743f, 
    0.19783957f, 0.03394183f, 0.07379705f, -0.19567886f, 0.20520745f, -0.14592950f, 0.34828889f, 0.54269361f, 
    0.34897056f, 0.26257765f, 0.22479598f, 0.36989161f, -0.09045582f, 0.32909504f, -0.12922770f, 0.23530644f, 
    0.06889011f, -0.13838115f, 0.10620163f, 0.27122056f, -0.25358093f, -0.02845244f, -0.16776395f, 0.11373987f, 
    -0.33342910f, -0.31141356f, -0.42424554f, -0.11558826f, -0.08309734f, -0.40430510f, 0.13526948f, -0.57119817f, 
    0.07050540f, -0.13308971f, 0.17890570f, 0.13072878f, 0.10726976f, 0.51574349f, 0.13236687f, 0.04419202f, 
    0.25356576f, -0.04053047f, 0.23309353f, -0.25732380f, 0.35425836f, 0.06806455f, -0.01925043f, 0.01915168f, 
    -0.13276869f, 0.24533193f, -0.00298677f, 0.21642722f, -0.26781189f, 0.14405844f, -0.24366155f, -0.24420018f, 
    0.02028446f, 0.06209893f, 0.12425946f, -0.17000079f, 0.40156254f, -0.12863331f, -0.15729953f, 0.15438573f, 
    -0.04093874f, 0.12270802f, 0.07041021f, -0.35716772f, 0.00498145f, 0.07009455f, -0.22665013f, 0.10213283f, 
    -0.21568531f, 0.31699580f, -0.32848182f, 0.19678675f, 0.44576448f, -0.38727260f, -0.17023329f, 0.10460766f, 
    0.12085811f, -0.05343005f, 0.19791628f, 0.25535303f, 0.04669649f, -0.04288547f, -0.56319797f, 0.31022748f, 
    -0.48216656f, 0.17646633f, -0.15135370f, 0.32573074f, 0.38679492f, -0.18457255f, 0.15418857f, 0.22368434f, 
    0.13432628f, -0.01726815f, -0.03678340f, 0.27233630f, 0.39518884f, -0.06655226f, -0.44876099f, 0.29175112f, 
    0.04032880f, 0.31792021f, 0.01578912f, -0.34834510f, 0.08765946f, -0.34900919f, 0.00467192f, 0.13948742f, 
    -0.01066710f, 0.52307242f, 0.07788403f, 0.13819154f, -0.26272205f, 0.03904730f, -0.02925623f, -0.04785886f, 
    0.02616675f, 0.27228892f, 0.09098056f, 0.17116338f, -0.16315943f, 0.15482336f, -0.16145526f, 0.49856800f, 
    0.19583341f, -0.17920125f, -0.15277971f, 0.57902771f, 0.25004074f, -0.10816769f, -0.09749418f, -0.07745072f, 
    0.37264004f, 0.03631201f, 0.36485639f, -0.08412623f, 0.48008704f, 0.29268342f, 0.13460930f, 0.33293292f, 
    0.09365133f, -0.38650423f, -0.43871072f, -0.14776562f, -0.28484049f, -0.17992681f, 0.22437739f, -0.04142484f, 
    0.09359589f, 0.09583402f, -0.18297252f, 0.06315327f, 0.13167240f, -0.07248047f, -0.21243446f, 0.24717984f, 
    -0.23601130f, -0.03091842f, 0.03402644f, -0.00888043f, -0.20358258f, -0.20782532f, -0.14003471f, -0.20362911f, 
    -0.58016801f, -0.21749708f, 0.11086164f, -0.24689737f, -0.13618062f, -0.24143122f, 0.53813690f, -0.73439407f, 
    0.14808623f, 0.06602426f, 0.01066619f, -0.24102387f, -0.08042145f, 0.18829533f, -0.17565560f, 0.28886786f, 
    0.07436957f, -0.13039444f, 0.00036400f, 0.66355377f, -0.27731290f, 0.17477131f, -0.23362581f, 0.04429043f, 
    0.08119228f, -0.15148792f, -0.15642615f, -0.27368596f, -0.01798398f, 0.28167650f, 0.52551675f, 0.14771485f, 
    -0.21238427f, -0.11351167f, 0.09270147f, -0.08486839f, 0.06044395f, 0.32707110f, 0.32227531f, -0.08524704f, 
    -0.20094156f, 0.20815073f, 0.01545373f, -0.01452327f, -0.10324857f, -0.21084382f, -0.30209348f, 0.30915192f, 
    -0.10301447f, -0.12286226f, 0.39119777f, 0.00351654f, 0.14367817f, -0.40140632f, 0.37538970f, -0.65364301f, 
    -0.16602544f, -0.12279360f, -0.66867620f, -0.34297416f, 0.20711589f, 0.08509119f, -0.13963926f, -0.14181581f, 
    -0.14817831f, -0.17128733f, -0.34427640f, 0.08667755f, -0.12594076f, -0.61046743f, 0.50684005f, -0.44766912f, 
    0.05570566f, 0.06995058f, -0.02648959f, -0.00575974f, -0.15531793f, 0.22971332f, 0.21552056f, -0.11306226f, 
    -0.10700529f, -0.00419178f, 0.06467787f, -0.27291894f, 0.00650165f, 0.14639148f, -0.30196869f, -0.16787846f, 
    -0.20684433f, -0.05280467f, 0.14528646f, -0.12461939f, -0.26249272f, -0.16749482f, -0.25670859f, 0.10077628f, 
    -0.37940609f, -0.30329964f, -0.44798449f, -0.08915838f, -0.16729401f, 0.15130186f, 0.18858050f, 0.12175097f, 
    -0.15382214f, 0.39932832f, 0.15160276f, 0.05607041f, -0.21229203f, 0.37610251f, 0.28475869f, -0.05696585f, 
    -0.41981038f, -0.41475865f, 0.01155197f, 0.03988447f, 0.07420135f, -0.21418695f, 0.27298513f, -0.35941193f, 
    -0.19600393f, 0.07276075f, 0.14356987f, 0.01266128f, 0.25041872f, -0.15627447f, 0.00526038f, 0.22941315f, 
    0.24209608f, 0.20046191f, 0.13179192f, 0.43711665f, -0.31861430f, -0.14099330f, -0.22304048f, 0.12499276f, 
    0.03458729f, -0.20458823f, -0.29711115f, 0.04882015f, 0.07075597f, 0.26786110f, 0.89566392f, -0.21322113f, 
    0.27799919f, 0.09054999f, -0.13621002f, 0.18238002f, -0.72487491f, -0.11369914f, -0.31775969f, -0.07588191f, 
    0.17570044f, -0.15083221f, 0.06751268f, -0.77835602f, 0.25610042f, -0.15695794f, 0.14697038f, 0.60574424f, 
    0.06674793f, 0.07496145f, -0.18176623f, 0.11894437f, 0.19677009f, -0.07445269f, -0.10255269f, 0.08020098f, 
    0.03587750f, -0.04656677f, 0.12059382f, 0.83841377f, 0.00439371f, 0.24897118f, -0.04152792f, -0.30502576f, 
    -0.14082702f, -0.24549232f, -0.08985364f, -0.26929745f, 0.28064793f, -0.00378016f, 0.46128574f, -0.30086493f, 
    -0.19246547f, -0.05489108f, -0.06336930f, 0.46221402f, -0.30950925f, -0.21319243f, 0.02791763f, 0.03735407f, 
    0.04996600f, 0.18038560f, -0.14295521f, -0.00468348f, -0.20240799f, 0.16752541f, 0.08556093f, -0.15998064f, 
    0.18893635f, -0.13434438f, -0.26368853f, 0.07124342f, -0.05204758f, -0.13391832f, -0.11140633f, -0.02152985f, 
    0.35582641f, -0.63370210f, 0.10629903f, 0.52712804f, 0.03394048f, 0.22621101f, 0.31523615f, 0.12105646f, 
    -0.22880182f, -0.55739552f, -0.02928021f, -0.10494597f, 0.02238868f, -0.11214361f, -0.25137690f, 0.21207617f, 
    -0.03935345f, 0.00640209f, -0.35663936f, -0.13480791f, -0.40633875f, 0.04611005f, -0.08573643f, 0.27334550f, 
    -0.11308578f, 0.17543395f, 0.02028384f, 0.34791204f, -0.20223650f, 0.35387859f, 0.39581305f, 0.32257944f, 
    -0.12908003f, -0.00408700f, -0.05701622f, -0.09796798f, -0.01815721f, -0.17133132f, 0.05780333f, 0.07807490f, 
    0.14048338f, -0.21917379f, -0.22662580f, -0.13581905f, -0.21163177f, -0.10710159f, 0.02940193f, -0.00266561f, 
    -0.18469183f, -0.06100485f, -0.15007539f, -0.31157166f, 0.19703586f, -0.46771526f, 0.10903203f, -0.08844163f, 
    -0.12689613f, 0.06280816f, 0.20839410f, 0.23359509f, 0.10527509f, 0.38120648f, -0.56897867f, -0.12596783f, 
    0.14769569f, -0.54493177f, 0.37547401f, 0.27130297f, 0.21364558f, 0.13559675f, 0.36222929f, 0.63467675f, 
    -0.02957815f, -0.10134591f, -0.53549433f, -0.25400698f, -0.14989845f, -0.22534728f, 0.16808201f, -0.07570249f, 
    -0.43807000f, -0.27838311f, 0.05424071f, 0.01274418f, 0.11344104f, -0.13802901f, 0.46821302f, -0.45284009f, 
    0.17242824f, 0.24729094f, -0.23350438f, 0.01568790f, 0.08462868f, -0.23177569f, -0.27168709f, 0.02226354f, 
    0.49889192f, -0.61948538f, 0.22031118f, 0.52153540f, -0.41231826f, -0.29993480f, 0.13096820f, 0.08231517f, 
    0.20250954f, -0.06703493f, -0.18545648f, -0.32225004f, -0.31231138f, 0.15740226f, 0.01007498f, 0.02358636f, 
    -0.24360436f, -0.00287446f, 0.14037000f, -0.14615756f, -0.09306306f, -0.01091505f, -0.19602200f, 0.17050318f, 
    0.18678969f, -0.53501773f, 0.20612305f, 0.29362425f, -0.14740755f, 0.35158435f, 0.11869430f, -0.26480034f, 
    0.35945806f, -0.28235343f, 0.01812418f, 0.41599816f, -0.47896481f, -0.34702468f, 0.19442560f, -0.07128424f, 
    0.25366148f, -0.23785961f, 0.23509967f, -0.17668045f, -0.01118719f, 0.16031747f, -0.29522315f, 0.49863082f, 
    0.49082023f, 0.30577770f, -0.05127360f, 0.01518968f, -0.12972863f, 0.26474196f, -0.05508340f, -0.36023438f, 
    0.13032982f, 0.32740581f, -0.08317294f, 0.23552874f, -0.30231386f, 0.25050712f, -0.31999564f, 0.19347848f, 
    0.05757756f, -0.06514855f, 0.23129711f, -0.30874386f, 0.45788866f, -0.27097985f, -0.21558672f, -0.43732849f, 
    -0.13359645f, -0.02663025f, 0.10142193f, 0.17779858f, 0.13613901f, -0.11244023f, 0.51035523f, 0.03147202f, 
    -0.06506833f, -0.33863339f, -0.25146723f, 0.68054390f, -0.39565030f, -0.10186970f, -0.09010340f, 0.32828781f, 
    0.00969068f, -0.39875120f, 0.09792292f, 0.10025426f, 0.13053650f, 0.17450988f, 0.44323575f, 0.26666990f, 
    -0.35586283f, -0.02286081f, -0.15409052f, 0.48828408f, -0.02785020f, 0.10823581f, 0.06789335f, 0.61156368f, 
    0.01318024f, -0.37086776f, -0.20832857f, 0.37673336f, 0.19686303f, 0.03142219f, 0.53299266f, -0.11382496f, 
    -0.11499223f, 0.27805516f, -0.17001772f, -0.30815917f, -0.13172649f, 0.12183050f, 0.38014260f, -0.34722915f, 
    -0.01862538f, -0.52522129f, -0.29130015f, 0.25847021f, 0.05472580f, 0.15732567f, 0.35219717f, 0.03106541f, 
    0.29075915f, -0.11016546f, 0.10915644f, 0.18512614f, 0.20193861f, 0.34673673f, -0.11062309f, 0.36880863f, 
    -0.13780296f, -0.47685936f, -0.31750560f, 0.20978586f, 0.09539694f, -0.14367816f, 0.36804205f, 0.11034222f, 
    0.00184191f, 0.16937377f, 0.20780089f, -0.07882091f, 0.05565388f, 0.46234673f, -0.05042852f, 0.11911003f, 
    -0.14558098f, -0.39769614f, -0.41068625f, 0.06198509f, 0.19301733f, -0.16802806f, 0.15529621f, 0.29311344f, 
    0.26181629f, -0.38687944f, 0.00936739f, 0.39353591f, 0.25604650f, -0.15936241f, -0.16477007f, 0.37114319f, 
    0.17331421f, -0.42711109f, -0.16657723f, 0.51184636f, 0.12640364f, 0.23306715f, 0.05054858f, -0.31734183f, 
    -0.08203084f, -0.36706266f, 0.45918876f, -0.25675803f, 0.10225992f, 0.10329937f, 0.16207965f, 0.57809454f, 
    0.13222882f, -0.35164240f, -0.45151445f, 0.31448963f, 0.00698200f, -0.03053024f, 0.26916599f, -0.14109449f, 
    0.15234578f, -0.12173109f, -0.25609818f, 0.09268819f, 0.09976868f, -0.22464052f, -0.11817025f, 0.07491650f, 
    -0.21534246f, 0.12829065f, -0.11386806f, 0.14798370f, -0.05017323f, -0.27094322f, 0.07140753f, -0.25273314f, 
    0.07945118f, -0.07647213f, 0.11709733f, 0.51705527f, -0.62523580f, 0.18488143f, -0.20182313f, 0.15260972f, 
    0.03705997f, -0.20595537f, -0.03040976f, -0.02983489f, 0.19587973f, 0.01196022f, -0.35142311f, -0.45098078f, 
    0.13629565f, -0.21546556f, 0.16518739f, 0.17830074f, 0.49711201f, 0.01669163f, -0.29621464f, 0.29279843f, 
    -0.15162078f, 0.10580534f, -0.91451603f, -0.20017028f, -0.08542766f, 0.38557389f, 0.15228528f, 0.24690683f, 
    0.03454152f, -0.37679753f, -0.57235277f, 0.08874405f, 0.01112404f, 0.22607715f, -0.19089058f, -0.23017962f, 
    0.16640058f, 0.05467099f, -0.38890761f, 0.43404147f, -0.35176823f, 0.39770368f, 0.30863476f, 0.20447454f, 
    0.08246858f, 0.01552702f, 0.14717732f, -0.18386206f, 0.24740863f, 0.46105403f, -0.32173437f, 0.33824691f, 
    -0.21851029f, 0.37787336f, -0.01754113f, -0.02460091f, -0.32003137f, -0.08380274f, 0.12991652f, 0.06933305f, 
    -0.29838037f, 0.16176909f, -0.30107427f, 0.22834107f, 0.39363280f, -0.25693136f, -0.01614553f, 0.12094754f, 
    -0.06823260f, -0.10375289f, 0.06145124f, 0.46148390f, 0.39468053f, 0.33072531f, -0.58474910f, 0.06384754f, 
    -0.12896565f, 0.11548950f, -0.23136495f, 0.08806771f, -0.00373688f, 0.07593291f, -0.12902497f, -0.07254177f, 
    0.10735729f, 0.09888593f, -0.24862370f, -0.08165689f, -0.10378567f, 0.02844437f, -0.20638672f, -0.08494455f, 
    -0.15375300f, -0.13669895f, -0.02825041f, 0.17580469f, 0.22774538f, 0.13164456f, -0.24261419f, -0.06560960f, 
    -0.18781249f, 0.18040599f, -0.17004566f, -0.07234348f, 0.02111688f, -0.17661981f, -0.17394710f, -0.02852570f, 
    -0.05120154f, -0.73144567f, 0.11114001f, 0.31143874f, -0.01837430f, 0.19617046f, -0.15222131f, -0.23913491f, 
    0.11148794f, 0.08072225f, -0.61760759f, -0.26276872f, 0.10302225f, 0.17155463f, -0.13904223f, 0.61310548f, 
    0.33156046f, 0.20357454f, 0.14857289f, 0.05306969f, 0.47168776f, -0.36219868f, -0.10319351f, 0.33160770f, 
    -0.09087982f, -0.47849163f, 0.03384910f, -0.04290311f, -0.05541896f, -0.05911703f, 0.23917459f, -0.20015039f, 
    -0.21724249f, 0.36275885f, -0.23723811f, -0.13151114f, 0.52967197f, -0.51346409f, 0.21481161f, -0.17975946f, 
    -0.10050934f, -0.19605018f, -0.22218917f, -0.22177649f, 0.18660735f, -0.11742344f, 0.67151946f, -0.25006500f, 
    0.53772098f, -0.47360292f, 0.28448796f, 0.36327541f, 0.00371074f, -0.08309850f, 0.22463615f, -0.11336937f, 
    0.03159376f, -0.32187217f, -0.31583881f, -0.00497936f, 0.02198182f, -0.14467996f, 0.14872847f, -0.41480687f, 
    0.35586035f, -0.19158868f, 0.00290241f, 0.17799394f, 0.04094653f, -0.11920605f, -0.11603521f, -0.23106758f, 
    0.09429425f, 0.10093749f, 0.00858170f, -0.19110253f, 0.11610939f, 0.19189346f, -0.41172409f, 0.13512471f, 
    -0.19229257f, 0.02490550f, 0.29708987f, -0.53594971f, -0.19506107f, 0.49244416f, 0.11811292f, -0.50751418f, 
    0.05712667f, 0.19846901f, -0.31892219f, -0.04369338f, 0.16449431f, 0.02587841f, 0.07120104f, 0.15414006f, 
    -0.00432281f, 0.37748399f, 0.04116669f, -0.45713228f, 0.08825246f, 0.36490908f, -0.08200631f, 0.09059771f, 
    0.22272255f, 0.07837920f, -0.27268484f, 0.57167572f, 0.22121805f, -0.15512942f, 0.04681227f, 0.22456326f, 
    -0.50316536f, 0.03431034f, -0.27322036f, -0.36351284f, 0.28049937f, 0.08541784f, 0.22310090f, -0.06686021f, 
    -0.02064827f, 0.05226426f, -0.30535927f, 0.34539828f, 0.20107335f, 0.23889799f, 0.67103875f, -0.22173719f, 
    -0.22328955f, 0.27696186f, -0.12115525f, 0.20731889f, -0.31200609f, 0.46593592f, -0.22052279f, -0.31747454f, 
    -0.15650383f, -0.13722290f, -0.27039498f, -0.04252731f, 0.00515472f, 0.51966465f, 0.16602382f, 0.21069552f, 
    -0.27461559f, -0.02343231f, -1.00080323f, 0.16707908f, 0.10896373f, 0.00567888f, -0.26995593f, 0.10179803f, 
    0.20597079f, 0.41366079f, 0.07676379f, 0.43496063f, -0.28913137f, 0.16720387f, 0.22599366f, 0.11392079f, 
    -0.23354501f, 0.20657952f, 0.11263988f, -0.23030765f, -0.01200055f, 0.36033681f, 0.29425773f, -0.41673160f, 
    0.15596732f, -0.19999222f, -0.55787152f, 0.12698892f, 0.19375825f, -0.25932056f, 0.30830115f, 0.11159836f, 
    -0.42819524f, 0.22202376f, -0.14962062f, 0.39457178f, 0.03418092f, 0.29245108f, -0.05441812f, -0.00925036f, 
    0.22389200f, 0.04438511f, 0.02818942f, 0.03824865f, 0.30229044f, -0.22999585f, -0.08444169f, 0.26832220f, 
    -0.30299944f, 0.52100247f, 0.06302378f, 0.24251193f, -0.23066013f, -1.14735377f, 0.12688211f, 0.21538785f, 
    0.22211605f, -0.12679636f, -0.18054163f, 0.10008075f, 0.13518761f, -0.18507940f, -0.39889196f, -0.03582299f, 
    0.06218579f, -0.13416864f, 0.11034692f, 0.50515079f, 0.00086212f, -0.23208308f, -0.04111727f, -0.35923460f, 
    0.13572718f, 0.23304345f, -0.38477206f, -0.55139196f, 0.13937888f, 0.31310242f, 0.36988139f, -0.00911079f, 
    -0.32621768f, -0.07846195f, 0.02318162f, -0.09198551f, 0.11077971f, 0.46013963f, -0.31573215f, 0.07412488f, 
    0.24443473f, 0.23880273f, -0.77253920f, 0.26858518f, -0.14306745f, 0.31945103f, 0.36117274f, 0.46725971f, 
    -0.05403692f, -0.07494631f, -0.17318657f, -0.11893135f, -0.02532354f, -0.07574916f, -0.17878264f, 0.06420347f, 
    -0.09844378f, -0.16952625f, -0.18792251f, -0.01398984f, -0.22044945f, -0.20822209f, -0.04015294f, -0.08345512f, 
    -0.37016225f, 0.36019868f, -0.22296630f, -0.03388672f, 0.08231379f, 0.11219413f, 0.09000406f, 0.08833818f, 
    -0.08154276f, -0.10782286f, 0.14718013f, 0.16295816f, 0.01790525f, 0.08265218f, 0.25386906f, 0.24803871f, 
    -0.13894242f, 0.22123858f, -0.05418207f, -0.04190379f, -0.08477482f, 0.01076594f, -0.01230388f, 0.01836456f, 
    -0.18043393f, 0.12420727f, -0.06015928f, -0.23444352f, -0.25091988f, -0.09186847f, -0.15812843f, -0.19890460f, 
    0.12788254f, 0.22331829f, -0.16651395f, 0.58164376f, -0.43884337f, 0.20246638f, -0.23021066f, 0.06397345f, 
    -0.10831200f, 0.11231292f, 0.13369720f, 0.65108496f, 0.18245836f, -0.18041404f, 0.31805101f, -0.13650161f, 
    -0.03913451f, -0.16498403f, 0.14216100f, -0.21350549f, 0.03469016f, 0.13840060f, 0.03501660f, -0.14415510f, 
    -0.00595667f, -0.07518693f, -0.09434825f, -0.22731292f, 0.13598147f, -0.00635614f, 0.47174561f, 0.40658602f, 
    0.32686281f, -0.35025415f, 0.21010619f, 0.18102661f, -0.47026727f, -0.28653869f, 0.09722707f, -0.14901687f, 
    0.02928440f, -0.48173770f, 0.19867428f, 0.23068219f, 0.11951157f, 0.24357547f, -0.27028233f, 0.01469058f, 
    -0.33035731f, 0.34840658f, -0.23345345f, -0.11768894f, -0.01171852f, 0.04668055f, -0.26905638f, 0.26599163f, 
    -0.16262776f, 0.36826748f, 0.11144286f, 0.46157867f, 0.11467689f, 0.44230884f, -0.20978014f, -0.12939686f, 
    -0.35696700f, 0.36653754f, 0.23491608f, -0.02243214f, 0.35912231f, 0.46365237f, -0.14315283f, 0.17332292f, 
    0.06131204f, 0.33131549f, -0.30984309f, -0.22908814f, 0.22246836f, -0.32352892f, -0.04441777f, 0.25052777f, 
    -0.15120524f, 0.23031026f, 0.21468912f, -0.13715997f, 0.05121503f, 0.43678072f, -0.14264454f, 0.30812916f, 
    -0.16835932f, 0.05858701f, -0.46412611f, -0.09324466f, 0.27295282f, -0.24218997f, -0.00347859f, 0.27479631f, 
    0.41163003f, -0.28859591f, 0.26780945f, 0.07070979f, 0.16193238f, 0.01710892f, -0.13489445f, 0.09659021f, 
    -0.13889366f, -0.09521405f, 0.00722408f, 0.39213416f, -0.19949153f, 0.26357633f, 0.17254262f, -0.00294372f, 
    -0.39307076f, 0.26991060f, 0.06334743f, 0.42195258f, 0.53484839f, -0.03482861f, -0.00341946f, 0.33987066f, 
    -0.13362381f, 0.03054318f, -0.54635829f, 0.25189999f, 0.38653988f, -0.27060357f, 0.50714850f, -0.28433645f, 
    -0.02176790f, -0.02597979f, 0.08367063f, 0.21888673f, -0.16653828f, -0.04947107f, 0.21389498f, -0.31699711f, 
    0.22403893f, 0.17633511f, 0.00116178f, -0.44886675f, 0.09732970f, 0.25522169f, -0.26621941f, -0.05830696f, 
    -0.10002287f, -0.39380965f, -0.11186204f, 0.21764779f, 0.40312904f, -0.19482733f, 0.00373839f, -0.00790902f, 
    0.14383963f, 0.14416513f, 0.24456182f, -0.14899099f, -0.11296003f, -0.04485034f, -0.09275620f, 0.31224334f, 
    -0.00992884f, 0.02266242f, -0.16469969f, 0.04757226f, 0.07816140f, 0.27762991f, -0.20342606f, 0.15003152f, 
    0.13557512f, 0.28079474f, -0.19994925f, -0.05896352f, 0.26174596f, -0.07958157f, 0.44318044f, 0.47956666f, 
    0.61480409f, -0.49197814f, -0.31878781f, 0.43092009f, -0.40097952f, -0.62063396f, 0.14191224f, -0.27284330f, 
    -0.17436685f, 0.52162188f, -0.18244089f, 0.14005370f, -0.41178876f, 0.34113982f, 0.04887911f, 0.22749805f, 
    0.14640675f, -0.02847229f, 0.21768868f, -0.53254724f, 0.44770667f, -0.25790957f, 0.23117851f, -0.18427992f, 
    0.21494229f, 0.07087402f, -0.20158453f, 0.10334920f, -0.14428964f, -0.03761717f, 0.55374986f, -0.50850755f, 
    -0.00924650f, -0.20786841f, 0.05896138f, -0.16752611f, 0.48672578f, -0.14150223f, 0.15356056f, -0.09781296f, 
    0.19274680f, -0.05639201f, -0.02675641f, -0.44738463f, 0.25470018f, -0.25519764f, 0.48807666f, -0.09080254f, 
    -0.27874663f, 0.17758146f, 0.14593968f, -0.09499955f, 0.19384409f, -0.05908463f, 0.08415958f, -0.30064541f, 
    -0.01149590f, -0.12441226f, -0.16125262f, -0.23397985f, 0.29853141f, 0.09870013f, -0.00789899f, -0.13803187f, 
    -0.06162712f, -0.29526046f, -0.09856796f, -0.15663055f, -0.10736673f, 0.35097915f, 0.23268232f, -0.08310885f, 
    0.08075409f, 0.31517994f, 0.15773538f, -0.12362048f, -0.12265874f, 0.07391894f, -0.26835033f, 0.19276918f, 
    0.23151411f, -0.25400907f, 0.10200759f, -0.18107429f, 0.01032672f, -0.93769705f, 0.54158592f, -0.66148931f, 
    -0.11049738f, 0.18467224f, -0.44987732f, 0.12008096f, -0.27427515f, -0.18506353f, -0.70105851f, 0.26464060f, 
    0.39504704f, -0.19396886f, 0.32229877f, 0.34833866f, 0.41210940f, 0.46239600f, -0.15003715f, 0.34688863f, 
    0.20930037f, -0.36296359f, -0.36402506f, 0.42567989f, 0.00034220f, -0.30403394f, -0.09378810f, 0.10212038f, 
    0.60576975f, -0.47095516f, -0.01023602f, 0.20923698f, -0.66052699f, 0.13546555f, 0.25971586f, -0.03564487f, 
    0.18440859f, -0.42722219f, -0.11300749f, 0.32297161f, -0.07941888f, 0.23400064f, -0.50440282f, 0.26403770f, 
    -0.34019053f, -0.11456683f, -0.26849893f, 0.32936454f, -0.16379084f, -0.14679894f, 0.07048925f, 0.09975936f, 
    -0.11817328f, -0.26321453f, 0.21766157f, -0.08784192f, 0.18263812f, 0.23027222f, -0.00521738f, 0.29269692f, 
    0.22136442f, -0.50212151f, -0.34855452f, 0.45226863f, -0.17045598f, -0.54400110f, -0.08564514f, -0.18895794f, 
    -0.14491749f, 0.70755118f, -0.00496859f, 0.29289973f, -0.55582732f, 0.35181722f, 0.37983018f, 0.25072375f, 
    -0.03672966f, -0.28082919f, -0.25994635f, 0.74780476f, 0.00592252f, -0.33633083f, -0.26837286f, 0.12587690f, 
    -0.06097576f, 0.48625073f, -0.47879502f, -0.17265956f, -0.00020244f, 0.18992965f, 0.54544872f, 0.26440227f, 
    -0.42566940f, -0.20065217f, 0.08536868f, 0.22995457f, 0.42307976f, 0.10825095f, -0.01404611f, 0.37449494f, 
    0.02871239f, 0.12855195f, -0.39936265f, -0.02957348f, 0.25877228f, -0.25025624f, 0.54869467f, 0.02169852f, 
    0.06342298f, -0.35741934f, -0.19885370f, 0.33096492f, -0.26531228f, -0.06619033f, 0.20960470f, -0.20763250f, 
    -0.17324033f, -0.10383875f, -0.39483321f, -0.12252875f, 0.11789349f, 0.05122564f, 0.42882037f, 0.41269946f, 
    0.24476983f, 0.10743973f, 0.07832608f, -0.11145970f, 0.09474602f, 0.01724422f, 0.18180807f, -0.27569252f, 
    0.22261973f, -0.40552193f, -0.08170253f, 0.03354810f, -0.02208554f, 0.24781853f, 0.24431963f, -0.23641482f, 
    -0.13936301f, 0.51991308f, -0.14678076f, 0.15800576f, 0.14316398f, -0.29078147f, -0.16569790f, 0.21371232f, 
    -0.24705172f, 0.06585224f, -0.14478104f, 0.57052404f, -0.13347365f, 0.34544271f, 0.70964921f, -0.09348537f, 
    0.01194640f, 0.13221292f, -0.14289017f, -0.09884088f, 0.31285623f, -0.20720692f, -0.02507754f, -0.30658981f, 
    0.09868303f, 0.43806982f, -0.17635657f, -0.06451163f, -0.22127855f, 0.30289856f, 0.68848956f, -0.19696105f, 
    -0.63634509f, -0.08302104f, -0.27820906f, -0.29582402f, 0.29274851f, -0.15526897f, -0.13813354f, 0.02184157f, 
    0.23610763f, -0.02534343f, 0.12553051f, 0.50824124f, 0.27282935f, -0.08480202f, -0.48876679f, 0.63695645f, 
    -0.17819273f, -0.14122006f, -0.29921761f, 0.27893540f, -0.42390898f, -0.63972056f, 0.40204620f, 0.02087427f, 
    0.01180001f, 0.00208378f, -0.13337649f, -0.14453736f, 0.17094110f, -0.06149159f, 0.12095533f, 0.37824160f, 
    -0.44537577f, 0.41788539f, -0.66866821f, -0.22667201f, 0.35254946f, -0.06428277f, -0.32734114f, 0.50864071f, 
    -0.16631675f, -0.18081863f, -0.82375258f, 0.47284406f, -0.43329498f, -0.18255532f, 0.30394793f, 0.11953957f, 
    0.03083480f, -0.21680181f, 0.12217955f, -0.05594951f, -0.44067985f, 0.18721548f, 0.14234352f, 0.12533501f, 
    -0.00345022f, -0.28411847f, 0.08769107f, 0.42411101f, -0.05178947f, 0.01971278f, 0.42460743f, 0.18459176f, 
    -0.40768260f, -0.05055718f, -0.07751231f, -0.35079977f, -0.10824312f, 0.08386270f, -0.06989367f, 0.03425922f, 
    0.02855618f, 0.23508351f, 0.26098943f, -0.54203844f, 0.11058117f, -0.19454391f, -0.00403894f, -0.31487456f, 
    -0.03917152f, -0.11475848f, -0.08565406f, -0.19275163f, -0.03452018f, -0.44889224f, 0.41618910f, -0.17518160f, 
    0.15178920f, -0.23480108f, -0.38934821f, -0.15458888f, 0.29150763f, -0.05943547f, 0.26400509f, 0.08472775f, 
    -0.65419644f, -0.05980325f, 0.13493530f, -0.15729815f, 0.06247443f, 0.47151232f, 0.38918933f, 0.10750966f, 
    0.13229090f, -0.42476115f, -0.52957845f, -0.24554321f, 0.36418414f, -0.30799019f, -0.50713098f, 0.44007605f, 
    0.24283661f, -0.28816363f, -0.11276693f, 0.01357905f, -1.08624518f, 0.38352117f, -0.44193304f, 0.20745118f, 
    0.22926608f, -0.06668402f, 0.10367879f, 0.24623702f, 0.09762892f, -0.09685737f, 0.14103752f, -0.05384219f, 
    -0.06702771f, 0.13793594f, 0.03456980f, -0.09131154f, 0.14113666f, 0.26088837f, -0.15010051f, -0.05751961f, 
    0.10014337f, 0.54960966f, -0.23418866f, -0.06456442f, -0.42108744f, 0.37281930f, 0.04859989f, -0.19268768f, 
    0.05357879f, -0.35395223f, 0.16476655f, 0.23987260f, -0.07978627f, -0.22842327f, 0.01472643f, 0.35962650f, 
    0.20469086f, -0.13549380f, -0.00687404f, 0.23723012f, 0.11107017f, -0.29189181f, 0.25165755f, 0.12554245f, 
    0.52902496f, -0.14391391f, 0.04253132f, 0.36277434f, -0.47023493f, -0.32727176f, 0.05343126f, -0.09140349f, 
    -0.07912923f, -0.28778639f, -0.28544092f, -0.16462816f, 0.27210340f, 0.12783436f, -0.26837996f, 0.55162227f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.06010316f, -0.45240611f, 0.21217868f, 0.44619265f, 0.20117064f, -0.29154468f, 0.22823271f, -0.00686059f, 
    -0.04679535f, -0.26233551f, 0.00755670f, -0.17177315f, 0.15853934f, 0.63794607f, 0.12003721f, 0.11617405f, 
    0.04212843f, 0.39692423f, 0.28258288f, 0.08640260f, 0.32857573f, 0.45655024f, 0.20328866f, -0.12759885f, 
    0.24370018f, 0.25824878f, 0.35691690f, -0.25780362f, 0.21850385f, 0.26144472f, -0.02807793f, 0.35497651f, 
    0.13736403f, 0.54261917f, 0.49431190f, 0.11302711f, 0.52172542f, 0.56641281f, -0.22423296f, 0.41631067f, 
    0.40945175f, -0.04645688f, 0.24405017f, -0.16714095f, 0.45317569f, -0.21470635f, 0.65489614f, 0.05248778f, 
    -0.21069232f, 0.17809035f, 0.17428574f, 0.37666994f, 0.66608733f, -0.08072048f, 0.24419069f, -0.33280870f, 
    -0.22722958f, 0.25208277f, 0.08102862f, -0.10502552f, 0.38886780f, -0.23875688f, 0.24209206f, 0.44383290f, 
    -0.10619716f, -0.51668376f, -0.23026848f, 0.10604050f, 0.15494324f, 0.29843846f, 0.01792158f, -0.26640046f, 
    0.43333638f, 0.18617962f, 0.37520975f, 0.36599141f, 0.37236264f, 0.32713488f, -0.19699223f, 0.07789055f, 
    -0.06934639f, -0.04821444f, 0.16330732f, -0.17504366f, -0.06829575f, 0.33507994f, -0.32479432f, -0.12152132f, 
    -0.23665540f, -0.17057624f, -0.00031551f, 0.01852028f, -0.09775653f, -0.12427253f, -0.06674214f, 0.06028008f, 
    -0.16066791f, 0.39396152f, 0.33078250f, -0.36084637f, -0.26962000f, 0.43255639f, 0.50260639f, 0.02763741f, 
    0.29917154f, 0.59261292f, 0.60474855f, -0.26090634f, 0.26039761f, 0.02049168f, 0.13930850f, 0.03995595f, 
    -0.12865874f, -0.03102831f, -0.11975407f, 0.04348446f, -0.06790322f, 0.19026832f, 0.59450245f, -0.05559205f, 
    0.13469560f, -0.30139524f, 0.68400007f, 0.19038323f, 0.16475968f, -0.24055120f, 0.45122650f, 0.38091418f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.11386205f, 0.11894081f, -0.01199599f, -0.14514433f, -0.01793906f, 0.10698523f, -0.16861369f, -0.35382342f, 
    -0.15044768f, 0.07604904f, 0.10211133f, -0.07244253f, -0.22293065f, 0.00073967f, 0.45833606f, -0.14777410f, 
    -0.12063667f, -0.02062898f, -0.65842533f, -0.05412753f, -0.32483381f, -0.26388732f, -0.29700613f, 0.10864443f, 
    -0.18845509f, 0.18897009f, 0.04476796f, 0.14327796f, 0.11798295f, 0.15754291f, 0.14242089f, 0.13734238f, 
    -0.07290052f, -0.85856169f, -0.61522174f, -0.03872397f, -0.12622614f, -0.61368287f, 0.07813423f, -0.04112627f, 
    -0.26687509f, -0.78799647f, -0.45021072f, 0.16093636f, -0.02784070f, -0.07575115f, -0.46978456f, 0.04521589f, 
    0.08676696f, 0.07604136f, -0.31553432f, -0.25992835f, 0.15701111f, -0.08050805f, -0.21183942f, 0.22648735f, 
    0.09317027f, -0.71331728f, -0.05367471f, -0.36900300f, -0.05150566f, 0.10238246f, 0.14362724f, -0.14471379f, 
    -0.00027088f, -0.04659183f, 0.26386434f, -0.05541587f, 0.28808218f, 0.04558429f, 0.03022156f, 0.03550598f, 
    -0.51153737f, 0.09716535f, -0.20790462f, -0.52831787f, -0.15989485f, 0.18777588f, 0.10694604f, 0.01947775f, 
    -0.56761825f, 0.12794819f, -0.42294091f, -0.01290155f, 0.11467554f, -0.29511368f, 0.10151222f, -0.08550375f, 
    0.06010392f, 0.03374072f, -0.00295883f, -0.28802431f, -0.09051737f, 0.16490039f, 0.18155940f, 0.05587486f, 
    0.11226062f, 0.05096795f, -0.03565987f, 0.03805955f, -0.05470205f, -0.00729083f, 0.06198907f, -0.40856695f, 
    -0.18786858f, -0.23771504f, -0.14776419f, 0.35810643f, -0.04160729f, -0.08131673f, 0.07394712f, 0.14337204f, 
    0.02813285f, -0.43182898f, -0.21118803f, 0.24458307f, 0.09969559f, 0.10430892f, -0.47613034f, 0.18477909f, 
    -0.15885402f, 0.10870335f, -0.65267384f, -0.55108517f, -0.31570676f, 0.17027068f, -0.25424340f, 0.10993481f, 
    -0.15073262f, -0.06637393f, 0.07484301f, -0.57876509f, 0.08415925f, -0.63926697f, 0.07532531f, -0.01121880f, 
    -0.02764333f, -0.08400135f, 0.42583922f, 0.01823931f, -0.01452052f, 0.01244774f, -0.32759210f, -0.13423197f, 
    0.03036960f, 0.13233337f, -0.75394875f, 0.03145745f, 0.11597746f, -0.09228531f, -0.08364604f, 0.01181808f, 
    -0.02336066f, 0.03993745f, 0.09115208f, 0.11354912f, 0.16734388f, -0.06113963f, 0.05276277f, 0.41817296f, 
    0.04637184f, -0.33349967f, 0.23070127f, 0.13283177f, -0.02006243f, -0.42526144f, 0.03779157f, 0.08916897f, 
    0.00978967f, 0.13622344f, 0.20283325f, -0.05831302f, 0.14410798f, -0.04906455f, 0.02934615f, -0.13375905f, 
    0.06099599f, 0.11077930f, 0.22957675f, 0.08722936f, -0.05140892f, -0.05543138f, -0.18762214f, -0.45090693f, 
    0.05942760f, 0.20809366f, 0.17313108f, -0.16655172f, 0.30565292f, 0.22889999f, 0.11932576f, 0.36562186f, 
    0.04665926f, -0.16274521f, 0.10874022f, -0.86694050f, 0.01248058f, 0.13038868f, -0.05350966f, -0.03493919f, 
    -0.17788969f, 0.00187431f, -0.01734294f, -0.19823669f, -0.04259041f, 0.11336239f, 0.09209250f, 0.17401043f, 
    -0.00549389f, -1.14774203f, 0.00674149f, 0.07364802f, -0.73181713f, -0.34990281f, 0.11789493f, -0.00215376f, 
    0.03787383f, -0.00513882f, 0.06076743f, -0.01672714f, -0.11837711f, 0.04671765f, 0.14672832f, 0.17684563f, 
    -0.04760160f, 0.21315505f, -0.13265730f, 0.02962938f, -0.02005041f, -0.81657362f, 0.19047685f, -0.02869741f, 
    0.11520963f, -0.01676090f, -0.02372486f, 0.34735361f, -0.40882131f, -0.06103750f, -0.83427966f, -0.82065636f, 
    0.09972367f, -0.21716343f, -0.09814108f, -0.16285913f, -0.32253239f, 0.26284263f, -0.34309912f, -1.17584896f, 
    -0.01282392f, -0.02328571f, -0.09004039f, 0.15025090f, -0.08383629f, -0.09967561f, 0.07194642f, -0.55507290f, 
    0.06684534f, 0.06727286f, 0.08521253f, 0.50658339f, 0.02394071f, -1.04431331f, -0.25562385f, 0.03576180f, 
    0.00371616f, -0.26887548f, -0.84249133f, -0.04250789f, -0.07457483f, 0.32241419f, 0.18697307f, 0.05791650f, 
    -0.16609357f, -0.00189327f, 0.25084874f, 0.12175095f, -0.15137509f, 0.16895789f, -0.04678749f, -0.13805728f, 
    0.05075558f, 0.11289012f, 0.01805254f, -1.05343938f, -0.14693722f, 0.09107788f, 0.01750108f, 0.14073575f, 
    -0.00758835f, 0.47417355f, -0.54819703f, 0.03891724f, 0.22210838f, 0.34691247f, 0.02654863f, 0.05935409f, 
    0.02835414f, -0.89902741f, 0.35022739f, -0.19855775f, 0.34557495f, 0.02799914f, -0.00453513f, -0.31212202f, 
    0.04717878f, 0.01759379f, 0.17518854f, 0.46103489f, 0.33156425f, 0.10667350f, 0.07762598f, 0.09355298f, 
    -0.02737430f, -0.69515270f, -0.87411320f, -0.06523876f, -0.57685620f, -0.45518315f, -0.26067978f, -0.08411846f, 
    -0.03674326f, 0.40995625f, -0.51500839f, -0.05241248f, 0.09927443f, -0.22059169f, -0.04698111f, -0.02201389f, 
    0.10266811f, -0.02623547f, -0.27967596f, 0.15682584f, 0.09436718f, -0.04120883f, -0.17273824f, -0.18199812f, 
    -1.09656823f, -0.56901151f, -0.03618716f, -0.07632410f, 0.07990452f, 0.07341289f, -0.80037695f, 0.04280270f, 
    -0.17072828f, 0.01459872f, 0.10477775f, -0.08246895f, -0.00776654f, -0.17777966f, -0.14444721f, -0.06092392f, 
    -0.17460963f, -0.48135400f, 0.15745857f, -0.04336353f, -0.39546192f, 0.45366275f, 0.44025213f, -0.16275661f, 
    -0.05531746f, 0.21204640f, 0.73148400f, -0.38215998f, 0.18462874f, -0.12942658f, 0.18180300f, -0.32071805f, 
    -0.39853710f, 0.04711168f, -0.11177710f, -0.61796218f, 0.01307237f, -0.98528475f, 0.39007878f, -0.11086575f, 
    -0.10258923f, 0.10046604f, 0.27219579f, -0.03321759f, 0.51435453f, 0.36165732f, -0.01871630f, 0.14104220f, 
    0.08216108f, 0.05109709f, 0.12308083f, 0.03639670f, -0.05169026f, 0.21416447f, -0.13962579f, 0.48481533f, 
    0.03960001f, -0.00296532f, -0.13189846f, 0.16290632f, -0.13100483f, 0.12520149f, -0.29600635f, 0.10086821f, 
    -0.62067658f, -0.07963777f, -0.01788095f, -0.47628784f, -0.25751442f, 0.17966194f, -0.06464835f, -0.53939265f, 
    0.38599232f, 0.01886854f, 0.05563868f, -0.01395266f, 0.03710229f, 0.04788319f, -0.53197068f, -0.59253389f, 
    0.02356032f, 0.27326447f, 0.09933201f, -0.09088901f, 0.11381429f, 0.36739895f, 0.00391424f, 0.31055704f, 
    0.07745761f, 0.01279940f, -0.55385995f, 0.01198554f, 0.06381137f, -0.02622982f, -0.42903998f, 0.07690019f, 
    0.00505564f, 0.12284286f, -0.17135446f, 0.15617441f, -0.86535150f, -0.05239823f, -0.45433801f, -0.07397915f, 
    0.20194237f, -0.59054285f, -0.19226781f, -0.00068338f, -0.65770066f, -0.62526840f, -0.01004910f, -0.42546701f, 
    -0.04560221f, -0.09105350f, 0.07285479f, 0.28008631f, 0.15580620f, 0.13844772f, -0.05676873f, -0.06849230f, 
    -0.35139489f, -0.28670421f, 0.24988119f, -0.39157099f, -0.10178365f, -0.40754077f, -0.11909000f, 0.25377899f, 
    0.08848425f, 0.25780976f, -0.19341186f, -0.13260931f, -0.49926296f, 0.23044768f, -0.01144563f, -0.08278427f, 
    0.01831769f, -0.05192668f, -0.43853515f, -0.17347151f, -0.60904449f, 0.08570104f, -0.24791951f, -0.78575164f, 
    -0.21565154f, 0.02275261f, 0.28768066f, 0.01316116f, -0.16545683f, 0.17977142f, 0.27817136f, 0.38453817f, 
    0.15467419f, 0.09272549f, 0.01112743f, -0.52222139f, -0.45842505f, 0.07144912f, 0.26839569f, 0.16019818f, 
    -0.01781924f, -0.19078244f, 0.13350494f, 0.12618236f, 0.48190162f, 0.04495833f, -0.02996365f, 0.08923972f, 
    -0.44419929f, 0.25346118f, -0.07084273f, -0.34992096f, -0.79638034f, 0.18779811f, -0.67954427f, -0.83083045f, 
    0.11965640f, 0.14102933f, -0.04385319f, 0.17946064f, -0.06195902f, 0.16283472f, -0.24212599f, 0.02517362f, 
    0.02323625f, 0.08410131f, 0.03255286f, -0.11891255f, -0.02637016f, 0.08680441f, -0.95997298f, 0.01030019f, 
    0.25698048f, -0.17175491f, 0.28632125f, -0.20024611f, -0.27355808f, -0.17761625f, 0.05754007f, 0.09133998f, 
    0.13538150f, -0.07293481f, -0.13078982f, -0.00552586f, 0.16512357f, -0.02373838f, 0.03155370f, -0.75460601f, 
    0.06679696f, -0.00500924f, -0.99613428f, -0.00102851f, -1.24884462f, -0.11795638f, -0.09540290f, 0.14433061f, 
    0.12883070f, 0.05062245f, -0.39985269f, 0.03793021f, -0.04551671f, -0.07874742f, 0.13004884f, 0.16925192f, 
    -0.07983919f, -0.00974363f, -0.29357371f, -0.06805046f, -0.88173383f, 0.08996274f, 0.06947161f, 0.14286432f, 
    0.10354137f, 0.17989463f, -0.07972424f, -0.11286975f, -0.22729573f, -0.14082998f, -0.01265494f, -0.27383268f, 
    -0.02587175f, -0.39326978f, -0.13420874f, 0.16500100f, -0.03225772f, -0.01851501f, -0.02958008f, -0.01357482f, 
    0.08493673f, -0.10797397f, -0.79459506f, -0.21081758f, -0.08296891f, -0.68657380f, 0.03184021f, -0.03888455f, 
    -0.03747238f, 0.19730900f, -0.38876170f, 0.09983578f, 0.00580201f, -0.57974076f, 0.04735104f, -0.01330356f, 
    0.08959225f, -0.02887431f, 0.01420887f, 0.01489148f, -0.09604654f, 0.09014434f, -0.17566596f, -0.18812872f, 
    0.02820395f, -0.30483353f, -0.29897481f, 0.13092457f, 0.11905897f, 0.36048332f, -0.59321767f, -0.09760040f, 
    -0.42789736f, 0.06033531f, -0.03689804f, -0.02682005f, 0.34477675f, 0.08901686f, 0.29755285f, 0.16735621f, 
    -0.08396983f, 0.18384875f, -0.16002226f, 0.05541982f, -0.62878799f, 0.10496107f, 0.29783139f, -0.13845347f, 
    0.03416963f, -0.04548309f, -0.23955773f, -0.19196172f, -0.19758409f, -0.61638427f, 0.06526373f, -0.01553213f, 
    0.03485546f, -0.05953443f, 0.07042280f, -0.02968793f, -0.03606405f, -0.15147820f, 0.20531222f, 0.09103382f, 
    0.01441824f, 0.04077091f, 0.03115966f, -0.00958484f, -0.00946291f, 0.00234475f, -0.09239452f, -0.02735664f, 
    0.28948927f, -0.09752943f, -0.19458951f, 0.22140527f, -0.17753498f, 0.13360487f, -0.08824971f, -0.00522880f, 
    -0.00998631f, -0.11142871f, -0.15945908f, -0.09146015f, 0.08931585f, -0.06778105f, 0.21467030f, -0.04129919f, 
    0.08802991f, -0.03181940f, -0.30597350f, -0.06868804f, 0.00225939f, -0.03539946f, -0.05314738f, -0.12873261f, 
    -0.07081122f, 0.14592257f, -0.08317915f, 0.09884073f, 0.15286373f, 0.01929178f, -0.03398411f, -0.00730450f, 
    0.02108791f, 0.06251828f, -0.23823269f, 0.12422021f, -0.85608786f, 0.25911048f, 0.02091082f, -0.14455444f, 
    -0.15815391f, 0.11845739f, 0.24847957f, 0.48355114f, 0.06839290f, 0.11983804f, 0.03019896f, 0.13723774f, 
    -0.09536643f, -0.03467267f, -0.36033851f, -0.10723427f, -0.40700555f, 0.08981124f, -0.04465380f, -0.03012385f, 
    -0.52655393f, 0.18366146f, 0.09777405f, 0.05627133f, -0.30443349f, 0.01825010f, 0.07624321f, 0.09529319f, 
    -0.16086863f, 0.01326877f, 0.18920615f, 0.00905512f, 0.57694781f, -0.04463048f, -0.22484633f, -0.03589351f, 
    0.09824051f, -0.09887222f, 0.11833886f, -0.09486666f, 0.15668096f, -0.02960237f, -0.18933854f, -0.09087680f, 
    -0.06982487f, 0.15200645f, 0.00772474f, -0.30012673f, -0.29142147f, -0.48629647f, -0.06897703f, -0.29747221f, 
    0.05345930f, -0.25485480f, 0.17288046f, 0.05079951f, 0.29226717f, 0.01889209f, -0.51318228f, -0.53933555f, 
    -0.09353897f, -0.02996595f, 0.15682460f, 0.09685318f, -0.52726877f, 0.04252012f, 0.11516010f, 0.60261297f, 
    0.25567892f, -0.31861511f, 0.07470188f, 0.21841411f, -0.32192433f, -0.60072613f, 0.03479345f, -0.04701576f, 
    0.00245454f, -0.41314235f, -0.28552774f, 0.69614381f, 0.06431447f, -0.46567315f, -0.56875640f, -0.09511466f, 
    -0.01619419f, -0.50768393f, -0.31532392f, -0.27818528f, 0.17069462f, 0.39076611f, 0.00465120f, 0.11105295f, 
    -0.09051687f, 0.21848615f, 0.41227540f, -0.28640258f, 0.09522566f, 0.05335302f, -0.08447354f, 0.08425419f, 
    -0.94089252f, 0.12908010f, 0.13354585f, -0.44846198f, -1.17156768f, -0.04020379f, -0.20498964f, 0.16126326f, 
    -0.04872834f, -0.34109008f, 0.10415591f, -0.08983223f, 0.27799660f, 0.09685899f, 0.02797946f, -0.72508085f, 
    -0.61430806f, -0.02847306f, -0.04062118f, -0.14990774f, -1.26286387f, -0.05405767f, 0.21592943f, -0.18665953f, 
    0.01838930f, -0.94242561f, -0.04552735f, -1.02722919f, 0.40077928f, 0.15917076f, 0.21414313f, 0.23784381f, 
    0.01548630f, -0.02180890f, -0.52105820f, -0.18102232f, 0.20935780f, 0.00464855f, 0.23627120f, -0.21767889f, 
    -0.06533937f, -0.10224048f, 0.26245445f, -0.24502754f, -0.21105289f, -0.88934505f, 0.03772772f, -0.11436313f, 
    0.44601157f, 0.23303519f, -0.24657838f, 0.38363481f, 0.25817436f, -0.26693004f, -0.15421268f, -1.01336467f, 
    -0.06074037f, -0.02302041f, -0.02016010f, -0.23852153f, -0.52722090f, 0.08126093f, -0.05241407f, -0.03981397f, 
    -0.16304551f, -0.06927382f, -0.14292707f, 0.02103412f, 0.09741161f, -0.18579954f, -0.31663904f, -0.22014579f, 
    0.14086869f, -1.15433455f, 0.09764355f, -0.02516934f, -0.28541562f, 0.25791758f, -0.01781152f, -0.03933462f, 
    -0.01439169f, -0.05719644f, -1.05072391f, 0.33298257f, 0.39173093f, -0.19106720f, 0.00346201f, -0.30569375f, 
    -0.88312024f, -0.00117297f, 0.20149568f, -0.39986402f, -0.41166991f, -0.28892559f, -0.22892205f, -0.09254704f, 
    0.03410725f, 0.16818061f, 0.05519565f, -0.18938391f, -0.25530532f, -0.29419097f, -0.05499635f, 0.39962602f, 
    -0.07537635f, -0.05822349f, -0.68233258f, -0.06367963f, -0.03426306f, 0.08794387f, -0.55952191f, -0.17282741f, 
    -0.01662902f, -0.30954859f, -0.48985407f, 0.21892913f, -0.01086597f, -0.23937336f, 0.43556076f, 0.14042747f, 
    0.09033789f, 0.07000344f, 0.28225580f, -0.09419771f, 0.03948640f, -0.28919524f, 0.09828387f, -0.01434049f, 
    -0.18125163f, -0.02137653f, 0.07010629f, -0.20815407f, -0.20117299f, 0.06651060f, -0.05693865f, -0.13296989f, 
    -0.06681263f, -0.17777511f, 0.01426059f, 0.09122008f, -0.14616477f, -0.06138973f, 0.02585619f, 0.00107008f, 
    0.20128289f, -0.02880029f, 0.00744069f, -0.23805812f, -0.42797837f, -0.04546337f, -0.32532072f, 0.11436119f, 
    0.08386986f, -0.42383453f, -0.20547235f, -0.65312564f, -0.79433274f, -0.13125385f, -0.30783010f, 0.09821557f, 
    0.00643394f, -0.26301855f, -0.06219081f, 0.38772014f, 0.05396769f, 0.27079502f, -0.62058026f, -0.45602825f, 
    -0.04699249f, -0.13387987f, 0.49596399f, 0.56752932f, 0.21658060f, -0.87273765f, 0.01228076f, -0.04154966f, 
    0.57236528f, -0.18575589f, -0.33321926f, -0.66400117f, -0.17880540f, 0.31739396f, 0.16942602f, 0.11784017f, 
    0.38089350f, 0.20967032f, 0.38934839f, 0.10976979f, -0.37671250f, 0.01708543f, 0.64633578f, -0.07579210f, 
    0.04270311f, -0.01858367f, -0.08548140f, 0.18631542f, -0.26166639f, -0.05702424f, 0.33144078f, 0.32331467f, 
    -0.04313796f, 0.01869723f, -0.03731289f, -0.14052668f, 0.32169265f, -0.10633789f, -0.49505886f, 0.06481423f, 
    -0.02805726f, 0.11514048f, -0.32012457f, -0.21026121f, -0.09845883f, -0.21242729f, 0.04528023f, 0.01117565f, 
    0.19602863f, 0.15656024f, -0.07878376f, 0.01096718f, 0.44521239f, -0.31766814f, -0.95355731f, -0.05495484f, 
    0.02301680f, 0.11973433f, -0.85197556f, -0.29032332f, -0.01808254f, 0.73583508f, -0.08703924f, -0.31470725f, 
    -0.50005186f, 0.29013139f, 0.07738987f, -0.55607444f, 0.05054383f, -0.61535662f, 0.46831965f, 0.01541997f, 
    0.00671186f, -0.57901770f, -1.39389491f, 0.19724496f, 0.14671507f, -0.93212980f, 0.28099510f, -0.07826333f, 
    -0.14329179f, -0.18365154f, -0.47859004f, -0.31213108f, -0.07657727f, 0.15678476f, 0.09412476f, -0.20222498f, 
    -0.28936431f, 0.03713927f, -0.01768493f, -0.40949464f, -0.21742588f, 0.05291209f, -0.20447871f, 0.04880025f, 
    0.07539050f, 0.34119973f, 0.08862209f, -0.24448219f, 0.03563600f, 0.01848800f, -0.02664554f, -0.38832659f, 
    0.13664213f, 0.18208449f, 0.11132989f, -0.27642137f, -0.10564840f, -0.01358866f, -0.08060642f, -0.15550703f, 
    -0.04461790f, -0.44167757f, 0.01014635f, 0.19086711f, -0.18155724f, -0.00460645f, -0.12118029f, -0.33513078f, 
    0.27768114f, -0.09177471f, 0.01681020f, 0.17717710f, 0.17369603f, 0.01480001f, -0.10631113f, 0.00464905f, 
    0.07410779f, -0.03938288f, -0.36963734f, -0.45951149f, 0.01643762f, -0.49908075f, 0.04762660f, -0.09322081f, 
    -0.15081453f, 0.26034462f, 0.61647052f, 0.20805354f, -0.22025532f, 0.16497642f, -0.10494529f, 0.23437120f, 
    -0.11078541f, -0.11309158f, 0.21562208f, -0.09621134f, -0.20557930f, 0.23807345f, -0.33948001f, 0.02126061f, 
    0.01026401f, -0.04984688f, -0.08387693f, 0.22182833f, -0.04987158f, -0.57054794f, -0.03150910f, 0.00696270f, 
    -0.08644774f, 0.37692279f, -0.07352441f, 0.18682151f, 0.02397688f, -0.74878138f, 0.56311303f, 0.35423851f, 
    0.06065041f, -0.29229379f, -0.45357144f, -0.15945120f, -0.61921644f, -0.24584770f, -0.07374654f, 0.05229821f, 
    0.13340653f, 0.05324208f, 0.07953485f, 0.20079716f, 0.33886674f, -0.59453499f, 0.12801360f, -0.14519912f, 
    0.03670486f, -0.12495301f, 0.32362056f, -0.02048728f, 0.35555893f, -0.59813279f, 0.15384847f, -0.11493237f, 
    0.18878870f, -0.00072074f, 0.16603032f, 0.18301876f, -0.07774999f, 0.54252589f, -0.41522238f, -0.41476873f, 
    -0.03276190f, 0.09580757f, -0.18908502f, -0.54627448f, 0.05327145f, 0.21025304f, -0.13260366f, 0.23307829f, 
    0.24656004f, -0.00253571f, 0.17593499f, -0.17385030f, 0.02588769f, 0.12512834f, 0.12505645f, 0.06539254f, 
    0.28033799f, -0.08018860f, 0.01077645f, -0.40458459f, -0.19170830f, -0.16551612f, -0.19368604f, -0.43922797f, 
    -0.05549537f, 0.19086868f, 0.17277342f, -0.02100231f, -0.07905520f, 0.08494084f, -0.02130903f, 0.23238248f, 
    -0.13176334f, -0.08571003f, -0.42341694f, -0.14698686f, -0.06679737f, -0.06965705f, 0.13646379f, 0.40156603f, 
    -0.06759352f, -0.23214002f, -0.41605666f, -0.35675487f, 0.10632469f, -0.79171658f, 0.19499922f, 0.04533708f, 
    -0.38509500f, 0.28993940f, -0.03852105f, 0.13667496f, -0.06137548f, -0.24179293f, 0.06361247f, -0.45188445f, 
    -0.07947878f, -0.32062176f, -0.37472904f, 0.18649535f, 0.00425906f, -0.20047227f, -0.05428705f, 0.03439672f, 
    -0.01526866f, -0.32264334f, -0.37270695f, -0.29892913f, 0.06829876f, 0.19514455f, -0.13080406f, -0.19889475f, 
    0.29135510f, -1.01402879f, -0.12265223f, -0.17607172f, -0.37579536f, 0.10256564f, -0.12369812f, 0.07208313f, 
    0.08362570f, -0.09516232f, -0.11184982f, 0.07742590f, 0.12151487f, -0.34388107f, -0.61143291f, -0.48198321f, 
    0.02769332f, -0.79294556f, 0.16539201f, -0.03955646f, -0.14140669f, 0.25467989f, -0.51042289f, -0.17709391f, 
    -0.12367310f, 0.23318529f, -0.07740706f, -0.79455614f, 0.26138568f, 0.12429165f, 0.27969903f, 0.12245578f, 
    -0.64669985f, 0.00730218f, 0.00659612f, 0.15607564f, 0.09918690f, 0.01980116f, 0.11931591f, -0.36225760f, 
    0.24975865f, -0.17221467f, -0.04880540f, 0.00690695f, 0.07907143f, -0.60097623f, -0.04524146f, 0.15365526f, 
    0.00509260f, 0.07836147f, -0.10925290f, -0.54597694f, 0.04351329f, -0.20132612f, 0.31273127f, -0.17492770f, 
    0.01465139f, 0.03641745f, -0.08131893f, 0.22727500f, -0.03000536f, -0.03790062f, 0.32702753f, -0.22640777f, 
    -0.06409734f, 0.18321911f, -0.40492013f, -0.18697663f, 0.38042104f, -0.17837745f, 0.16760437f, -0.27782163f, 
    -0.41979045f, -0.55750066f, 0.19173966f, 0.22110574f, 0.28741837f, -0.21491377f, -0.32775298f, -0.03926275f, 
    -0.08613455f, 0.17793430f, -0.27466100f, 0.23925474f, 0.11502602f, -0.52689439f, -0.06575333f, -0.51104146f, 
    0.13690677f, -1.05097294f, -0.16030729f, -0.64851612f, -0.36484265f, 0.06950369f, 0.13764410f, -0.27879253f, 
    0.03563251f, -0.12797762f, 0.00561455f, 0.19941725f, -0.41044506f, -0.49365395f, 0.18627106f, -0.32757270f, 
    -0.23324874f, -0.28860679f, -0.29933149f, -0.15347730f, -0.30189312f, 0.19454540f, -0.26763940f, -0.36321038f, 
    -0.04677217f, -0.34558207f, 0.11846987f, -0.59106779f, -0.52309763f, 0.05078421f, -0.01902873f, 0.06516743f, 
    0.55547816f, -0.16417611f, -0.13044128f, -0.00153505f, 0.02129744f, 0.04242057f, 0.04721560f, -0.27009600f, 
    0.10353917f, -0.19083729f, 0.10984397f, 0.37988344f, 0.31531748f, 0.16719712f, -0.08826299f, 0.04062000f, 
    0.10966057f, -0.08604361f, -0.50185359f, 0.16601223f, -0.08729059f, -0.16114011f, 0.46109113f, 0.38774487f, 
    -0.73129880f, 0.09480594f, 0.18752092f, 0.15925512f, 0.14640850f, -0.82758385f, -0.70160830f, 0.10620533f, 
    0.26471069f, -0.07977819f, -0.38740572f, -0.12801155f, -0.33511814f, 0.30596766f, -0.62902945f, 0.04748122f, 
    0.13042374f, 0.08729771f, -0.12058493f, -0.56828892f, -0.76249737f, 0.14486705f, 0.15695713f, -0.33933583f, 
    -0.34742367f, -0.30227634f, -0.00530881f, 0.41741356f, -0.44665462f, -0.15453176f, -0.22436133f, 0.22751416f, 
    -0.26467237f, -0.82337373f, -0.47528279f, -0.31037861f, -0.06360447f, -0.24766651f, -0.29992601f, 0.06755023f, 
    0.01238108f, -0.28316405f, -0.94200772f, 0.04356707f, 0.01620504f, -0.77422863f, -0.35437709f, -0.24134101f, 
    0.07989489f, 0.07373051f, 0.25518912f, 0.04106354f, 0.26754311f, 0.14619461f, -0.12868920f, -0.20441765f, 
    0.26774746f, -0.21615416f, -0.00609907f, -0.38220248f, 0.04995568f, -0.62531483f, -0.05624579f, 0.08072207f, 
    -0.05090742f, -0.17789352f, 0.20579664f, -0.60969067f, -0.00678007f, 0.17068352f, -0.06606069f, 0.06501748f, 
    0.01140341f, 0.04313523f, -0.23204432f, -0.26607582f, -0.29473102f, 0.02576475f, 0.25440851f, -0.05378777f, 
    -0.01289041f, 0.04991631f, 0.33932257f, -0.33065099f, 0.47917008f, -0.11138978f, 0.13112038f, -1.06151199f, 
    -0.06195974f, 0.33697191f, 0.29138246f, -0.06250054f, 0.17492025f, -0.07953290f, 0.26009437f, 0.18143223f, 
    -0.05900918f, 0.28746876f, 0.49649879f, -0.47530133f, -0.18238635f, 0.10588372f, 0.03445774f, -0.02770348f, 
    -0.05779052f, 0.19930236f, 0.13703640f, 0.25553331f, -0.02124183f, -0.40693587f, -0.77496105f, -0.23125778f, 
    -0.12166265f, -0.20176356f, -0.31552100f, -0.05541451f, 0.20778993f, 0.10675222f, -0.01416062f, -0.00236394f, 
    -0.20018296f, 0.04006302f, -0.12238490f, 0.04054274f, 0.14126265f, -0.93310761f, -0.42144743f, -0.18185776f, 
    -0.00189664f, 0.20960779f, -0.05458707f, 0.05257072f, -0.11796787f, 0.07095111f, -0.02437378f, 0.06886109f, 
    0.02668511f, -0.19837038f, -0.71369165f, 0.08314041f, 0.05453355f, 0.15032436f, -0.17259066f, 0.46729404f, 
    0.09661466f, 0.25440103f, -0.08722082f, -0.00088373f, -0.05882674f, -0.39233300f, 0.42612073f, -0.00579384f, 
    -0.07410518f, -0.17136043f, 0.20502344f, -0.28147537f, -0.29001018f, -0.50549161f, 0.26634398f, 0.31368923f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.20049308f, 0.26785913f, 0.22484191f, 0.08185674f, -0.11377899f, -0.10070372f, -0.00480930f, -0.23451239f, 
    -0.02084025f, 0.13090444f, -0.04624382f, -0.10626808f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
