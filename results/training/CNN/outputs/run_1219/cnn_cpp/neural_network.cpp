#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.78274149f, 0.23806575f, -0.00310631f, -0.41000167f, -0.40049991f, -0.02921293f, -0.48810089f, -0.62965220f, 
    -0.07414657f, -0.25593579f, -0.08240109f, -0.19107047f, 0.21038459f, -0.27647904f, 0.15209046f, -0.32679203f, 
    -0.42696807f, 0.25901183f, -0.69458461f, -0.27130592f, 0.29383352f, 0.37533358f, -0.29492322f, 0.14156730f, 
    0.32430607f, 0.44273958f, 0.88034129f, -0.34585586f, 0.28563145f, -0.77250564f, -0.93463987f, -0.60679680f, 
    -0.05776953f, 0.59841013f, 0.05382186f, -0.08691218f, -0.20889929f, 0.36889666f, 0.38929889f, -0.15258177f, 
    0.08121243f, 0.10131086f, -0.22645672f, -0.14213951f, -0.31574756f, -0.21406941f, -0.02039060f, -0.00680572f, 
    0.04699672f, 0.05617505f, 0.66535413f, 0.53950953f, -0.31495640f, 0.22239213f, -0.25514895f, -0.09592150f, 
    -0.06980847f, -0.01244871f, 0.01161564f, 0.11329104f, 0.24965940f, 0.08360916f, -0.07635377f, -0.46058008f, 
    0.03121045f, 0.06621972f, -0.17129566f, 0.24252984f, -0.18814428f, -0.27315238f, -0.28728539f, -0.11121533f, 
    -0.11540519f, -0.17606415f, -0.60533100f, 0.50779372f, 0.85458779f, 0.70883721f, -0.08963254f, 0.59591186f, 
    -0.41043967f, -0.24528705f, -0.23991752f, -0.00181820f, 0.04500790f, 0.25162593f, -0.18696781f, -0.03109333f, 
    -0.07046869f, -0.35981292f, -0.14697927f, -0.12347988f, 0.07614766f, 0.40055019f, -0.26379019f, -0.16521709f, 
    0.10180606f, -0.09711608f, 0.08515552f, 0.34208503f, 0.37548688f, 0.73196572f, 0.24465808f, -0.13510108f, 
    0.07397444f, -0.15966168f, 0.71154153f, 0.23270029f, 0.16064125f, 0.15334825f, -0.06605197f, -0.01857059f, 
    0.07206868f, -0.13675034f, -0.40286472f, 0.23336157f, 0.00788361f, -0.28654873f, -0.25784487f, -0.20068322f, 
    0.23495699f, 0.00275608f, -0.18739042f, -0.26829022f, -0.19454175f, -0.34573665f, -0.67509657f, -0.74855137f, 
    -0.19452980f, -0.18910277f, 0.59471059f, 0.30523044f, 0.25631252f, -0.04574686f, 0.06808455f, 0.24778587f, 
    -0.10767750f, 0.17905368f, -0.23704448f, 0.30791399f, 0.10283065f, -0.09153002f, -0.04671455f, -0.43325239f, 
    -0.09757163f, 0.06385572f, 0.30793270f, 0.12151506f, 0.05913546f, 0.28763756f, 0.27408683f, -0.34882012f, 
    -0.40154815f, 0.15089180f, -0.08233219f, 0.07692419f, -0.30016893f, 0.13814408f, -0.22302999f, 0.12509434f, 
    0.07830892f, -0.34113806f, 0.18798083f, -0.39235386f, 0.37324581f, -0.14436406f, -0.12951361f, -0.03354992f, 
    0.37540430f, 0.10982867f, -0.22933227f, 0.14150876f, 0.39299083f, 0.03757965f, 0.71039307f, -0.25329041f, 
    -0.43676338f, -0.46043885f, -0.10911869f, -0.14553821f, -0.55581075f, -0.35537222f, -0.39397016f, -0.66312701f, 
    -0.29807800f, 0.32429272f, 0.74311745f, 0.44510785f, 0.21568054f, -0.08536687f, -0.15232439f, 0.07952405f, 
    -0.13405895f, -0.18750256f, -0.12423757f, 0.16082184f, -0.13671167f, 0.10340848f, -0.10849572f, -0.13537891f, 
    1.12532806f, -0.49628612f, -0.52829057f, -0.20237605f, -0.73186404f, 0.73013341f, -0.28508782f, -0.07551821f, 
    0.21878225f, 0.54636371f, 0.05491750f, -0.05656794f, -0.14383885f, 0.13496205f, -0.07888030f, 0.09855505f, 
    -0.20083372f, -0.04778868f, 0.26102978f, -0.21757811f, -0.18236150f, -0.09107222f, 0.09781647f, 0.22451508f, 
    -0.10585599f, -1.03357041f, -0.08850890f, -0.44580591f, -0.72788936f, -0.62630087f, 0.43767682f, 0.21635884f, 
    -0.04450858f, -0.38164568f, 0.07181330f, -0.38626477f, -0.26724064f, -0.38554174f, -0.45629016f, -0.09406701f, 
    0.31293982f, -0.16355710f, -0.10797987f, 0.08517238f, -0.10852065f, 0.20550363f, -0.16215320f, -0.25280347f, 
    -0.08365783f, -0.30921280f, 0.63852674f, -0.49377948f, -0.76793969f, -0.60802966f, -0.91863710f, 0.56608081f, 
    0.49085760f, 0.47198415f, 0.00853042f, -0.10916944f, 0.06063456f, 0.50920600f, 0.10367096f, 0.03563157f, 
    -0.00198934f, 0.16179845f, -0.01335065f, -0.06391383f, 0.01827949f, -0.02692289f, 0.37155661f, -0.21648349f, 
    -0.15446854f, -0.05715853f, -0.10379904f, -0.82989526f, -0.55417711f, -0.68544114f, -0.22817761f, 0.17916666f, 
    -0.02473091f, -0.32469100f, 0.10467794f, 0.45068353f, 0.63844883f, 0.11328556f, -0.06095345f, -0.02743749f, 
    0.37819919f, 0.39178854f, -0.20440038f, 0.06015585f, -0.09816668f, 0.03700943f, -0.38042825f, -0.29569086f, 
    -0.18238415f, 0.23185080f, -0.14929786f, -0.29018828f, 0.11909780f, -0.46519783f, -0.05949446f, 0.50852102f, 
    0.35482693f, -0.34101501f, 0.23173526f, -0.00097767f, 0.46950662f, 0.18424788f, 0.23726247f, -0.00292921f, 
    0.00880874f, 0.19336008f, -0.07861751f, -0.08925844f, 0.01365499f, -0.32457522f, -0.48275307f, -0.11880634f, 
    -0.13200003f, 0.19705652f, 0.17849566f, 0.21152095f, 0.44726238f, 0.62280989f, 0.47931403f, 0.23881912f, 
    0.06061211f, -0.30574313f, 0.05472805f, -0.15250207f, -0.28087652f, 0.33935219f, -0.02786836f, 0.02569381f, 
    0.07456430f, 0.05764273f, 0.43437138f, 0.33109409f, 0.16369168f, 0.03038014f, -0.05173320f, -0.32674599f, 
    0.41155666f, -0.05148837f, 0.17816542f, 0.20359051f, 0.11530496f, -0.23002248f, 0.11895040f, 0.03960965f, 
    -0.37397483f, -0.52293622f, -0.14110662f, 0.48013672f, 0.24342147f, 0.08051314f, -0.65308958f, -0.08324272f, 
    -0.10628230f, -0.06650241f, 0.06753496f, 0.45219913f, -0.07405806f, -0.65405512f, 0.26937935f, 0.21707322f, 
    -0.41483063f, -0.19349091f, -0.03377059f, -0.38058695f, 0.30041468f, 0.41739359f, 0.06718756f, -0.65859818f, 
    -1.19836330f, -0.29094416f, 0.55305219f, 0.68754131f, 0.87137300f, 0.87637055f, -0.45167309f, -0.20045222f, 
    -0.03732214f, 0.16111615f, -0.30945641f, -0.10092591f, -0.43944898f, -0.23466590f, 0.25835261f, 0.00111599f, 
    -0.08569620f, 0.20949318f, 0.08074044f, -0.05866915f, -0.03488030f, -0.22499508f, 0.00177405f, -0.14184220f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.02412874f, 0.32802409f, 0.13845116f, 0.33854106f, 0.04618641f, 0.12276264f, 0.27764246f, -0.13890962f, 
    0.31107157f, -0.17946203f, 0.36534229f, 0.04961767f, 0.21445589f, -0.12643535f, 0.00306039f, 0.22348896f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.09594769f, -0.00637804f, 0.00753040f, -0.09659727f, -0.01699959f, -0.05913964f, 0.00754494f, -0.05792547f, 
    -0.01009394f, -0.03745115f, -0.06421607f, -0.07479265f, -0.02788492f, -0.02385269f, 0.00933178f, -0.03500938f, 
    -0.11692012f, -0.04626103f, -0.06393050f, -0.10726091f, 0.03346067f, -0.05491652f, -0.08472253f, -0.01924419f, 
    0.02471650f, 0.04514386f, 0.04983095f, 0.01848218f, -0.01674800f, -0.04077000f, -0.06691507f, 0.01592193f, 
    0.00310765f, -0.06513407f, -0.05802820f, -0.05310687f, -0.02630824f, -0.07272383f, 0.02292064f, 0.02523264f, 
    0.07488813f, 0.05864251f, 0.03351027f, 0.04292391f, 0.05701083f, -0.08492933f, -0.06300105f, 0.01945871f, 
    -0.05951746f, -0.03830441f, -0.04741411f, 0.02673889f, -0.02336843f, 0.02862991f, -0.01895351f, -0.01561425f, 
    -0.00934272f, 0.00847559f, -0.02180395f, -0.00550690f, 0.04958355f, -0.10890097f, -0.03652947f, -0.07593095f, 
    -0.11626168f, 0.01469783f, -0.05368995f, -0.01229377f, -0.08719525f, -0.09043723f, 0.00889835f, -0.06942207f, 
    -0.07528697f, 0.03371271f, -0.03543150f, -0.05829458f, -0.01529507f, -0.00948595f, -0.06860743f, -0.05061673f, 
    -0.08575959f, -0.05498124f, -0.00950919f, -0.03696623f, -0.02256256f, -0.02035953f, -0.04317318f, -0.12357482f, 
    -0.02419781f, 0.01747189f, 0.02111243f, 0.01509647f, -0.08459270f, -0.03391825f, -0.04420260f, -0.04278413f, 
    -0.06382705f, -0.10937525f, -0.03411917f, -0.05899651f, -0.07172334f, 0.00893847f, -0.01589741f, -0.11074241f, 
    -0.09146542f, -0.10421676f, -0.03310331f, -0.09092118f, -0.06173360f, -0.09816336f, -0.06703943f, -0.14006582f, 
    -0.06954295f, -0.11267956f, -0.08085444f, -0.02275007f, 0.07584251f, -0.01604143f, 0.00779039f, 0.00333171f, 
    -0.08572678f, 0.00889022f, 0.01883477f, 0.05948333f, 0.05131812f, -0.08360860f, -0.10167310f, -0.02266336f, 
    -0.01951457f, 0.00848849f, -0.00760432f, -0.02449484f, 0.10003091f, 0.00488537f, -0.04975437f, 0.02727707f, 
    0.03873090f, 0.04247150f, 0.04581395f, 0.02977037f, 0.02874174f, -0.10653328f, -0.07626473f, -0.04003793f, 
    -0.01748529f, 0.01889858f, 0.02216728f, -0.03516454f, -0.11188329f, -0.01950687f, 0.06343387f, 0.02034545f, 
    -0.01592756f, -0.01371127f, -0.12224152f, -0.05440103f, -0.00514429f, -0.01889984f, 0.05729553f, 0.02347702f, 
    -0.09156665f, -0.02134085f, -0.09201608f, -0.02788349f, 0.01334262f, -0.09661938f, 0.00991498f, 0.00342665f, 
    0.03589146f, -0.04442494f, -0.07138874f, -0.00310741f, -0.06677677f, -0.05665445f, -0.00340177f, -0.02252429f, 
    -0.04781903f, -0.09760345f, -0.01183349f, -0.03418951f, 0.03438299f, -0.04282717f, -0.09181577f, -0.03167962f, 
    -0.07053026f, -0.06082398f, -0.11074002f, 0.00126143f, -0.04258528f, 0.03038523f, 0.04622493f, 0.02937101f, 
    0.08258693f, 0.25599524f, -0.11935801f, -0.12604095f, -0.14578079f, 0.32027337f, 0.16015165f, 0.05941764f, 
    -0.06111236f, -0.03681018f, 0.02800848f, 0.07267768f, -0.00473940f, 0.39624962f, -0.33753562f, 0.22210941f, 
    -0.02070018f, -0.00465967f, -0.02631581f, 0.03451797f, 0.16904974f, -0.11771058f, 0.10968592f, -0.04334004f, 
    0.29867411f, 0.04826714f, 0.15639597f, 0.01258891f, -0.01596649f, -0.03356073f, -0.04486631f, 0.00446370f, 
    0.09623761f, -0.06186667f, 0.04176289f, 0.01261163f, -0.16645372f, -0.01060001f, -0.31652093f, 0.34763014f, 
    -0.00651664f, 0.00301479f, 0.16079678f, -0.03734356f, 0.03223921f, -0.00095584f, -0.08309417f, 0.11272133f, 
    0.05022484f, 0.33880004f, -0.04859902f, 0.29958227f, 0.00382997f, -0.11657199f, 0.13325387f, -0.16086113f, 
    0.12942475f, -0.04319730f, -0.03045366f, 0.27833262f, 0.22709896f, -0.26726124f, -0.25902152f, -0.14670278f, 
    -0.02414857f, 0.01627680f, -0.13362204f, 0.03545924f, 0.02052487f, -0.09108629f, -0.04446807f, 0.04490788f, 
    0.02915136f, -0.27182785f, -0.00024690f, -0.37336582f, -0.03006019f, 0.10366671f, 0.15766641f, 0.15083891f, 
    -0.10569991f, 0.05781255f, -0.05225946f, 0.15297966f, 0.08250095f, 0.33629850f, 0.34758392f, -0.07071373f, 
    0.22892499f, 0.09057045f, 0.12841411f, 0.10819940f, 0.11615299f, -0.13067392f, 0.12719619f, 0.11241413f, 
    0.34930778f, -0.26935157f, 0.25832132f, -0.36191243f, -0.12581126f, -0.06743129f, -0.15070653f, -0.04028454f, 
    0.14908928f, 0.06006983f, -0.14028893f, -0.09237184f, -0.22750667f, 0.26853725f, -0.25018609f, -0.18812330f, 
    0.23280872f, -0.14076909f, -0.03428296f, 0.26728103f, 0.07598913f, -0.03559977f, -0.04597546f, -0.03220724f, 
    0.04107210f, -0.04661852f, 0.05350320f, -0.47453731f, 0.13379869f, -0.23866209f, -0.15581149f, 0.05765145f, 
    -0.00320849f, 0.15348774f, 0.10245419f, 0.08747701f, 0.28556260f, -0.07504994f, 0.33079371f, 0.06714404f, 
    -0.01948008f, -0.01384658f, -0.07647251f, -0.18427525f, 0.16023737f, -0.13727590f, 0.06306612f, -0.00677156f, 
    0.04053315f, -0.07569497f, 0.37851596f, 0.09350588f, 0.01264240f, 0.01316177f, -0.06905568f, -0.14441673f, 
    0.03453881f, 0.01067208f, 0.01577750f, 0.03042307f, -0.09083765f, 0.12430252f, -0.14296965f, 0.03227626f, 
    -0.03614035f, 0.05299475f, 0.05895695f, 0.09433666f, 0.03050404f, -0.20909646f, 0.13427779f, 0.06756333f, 
    0.17407686f, 0.11010638f, -0.19350699f, -0.11303823f, 0.02117030f, 0.19426753f, -0.14622098f, 0.02429280f, 
    0.05300054f, -0.16025209f, 0.14574984f, -0.06358610f, 0.22444938f, -0.29641658f, 0.13197547f, 0.05124893f, 
    -0.20384021f, -0.15986560f, -0.32880372f, 0.00669286f, 0.14792863f, -0.02616693f, -0.12960330f, 0.06457499f, 
    -0.04330324f, 0.26209670f, -0.03018519f, 0.09755102f, -0.09003057f, 0.18382800f, -0.13815130f, 0.19191405f, 
    0.15677510f, 0.26142979f, 0.16162963f, 0.04164193f, 0.00623631f, -0.02691760f, 0.23589021f, -0.14691801f, 
    0.31123170f, -0.01547239f, -0.08271218f, 0.00936986f, 0.10112287f, -0.00912030f, 0.06567257f, 0.11930716f, 
    -0.05764406f, -0.23831612f, 0.14056726f, -0.13035189f, -0.02708802f, -0.03937498f, -0.15312238f, -0.03582199f, 
    -0.19174820f, -0.15359497f, -0.25645378f, -0.22269326f, -0.15067181f, 0.12979124f, 0.02239919f, 0.11072568f, 
    -0.16956423f, -0.14789455f, -0.12557068f, -0.02861794f, 0.05096333f, -0.06090190f, 0.05017271f, 0.21252355f, 
    -0.15606548f, -0.04146085f, -0.17694794f, 0.01593763f, -0.02822522f, -0.10707662f, -0.16054343f, -0.08518511f, 
    -0.01615742f, 0.09146666f, -0.00151574f, -0.07245268f, -0.04943058f, -0.04236484f, 0.00612463f, 0.15467516f, 
    0.02788795f, 0.08979499f, -0.02395223f, 0.01309920f, 0.10083803f, 0.10050506f, 0.02375788f, -0.04144239f, 
    0.16676787f, -0.04848157f, 0.04515107f, -0.06418444f, 0.06118367f, 0.38208973f, 0.33406228f, 0.02265267f, 
    0.20644578f, 0.18628408f, 0.09459282f, 0.20935182f, 0.15282509f, 0.25075799f, -0.02843157f, 0.00964704f, 
    -0.06629044f, 0.09737900f, 0.15601130f, 0.14466314f, -0.20148422f, -0.32843968f, -0.04119335f, 0.16349764f, 
    0.72008139f, -0.21722440f, 0.44557235f, -0.49348933f, -0.07232149f, -0.08326174f, 0.12307241f, -0.14266743f, 
    0.22194797f, 0.24760199f, 0.20834345f, -0.11912474f, 0.15457211f, 0.49946940f, 0.48647848f, 0.00999337f, 
    0.07653017f, -0.00002631f, -0.02158735f, -0.11586448f, 0.08388072f, -0.08567341f, -0.00540747f, -0.11179130f, 
    0.37177631f, -0.35132810f, -0.29462045f, -0.13253170f, -0.08647288f, 0.20726879f, -0.01094359f, -0.02029347f, 
    -0.02262590f, 0.13404302f, 0.21581258f, 0.03704135f, -0.14584573f, -0.35431805f, 0.18837141f, 0.24532244f, 
    0.24696271f, 0.09083821f, -0.03623585f, -0.09149355f, -0.09795274f, -0.05916559f, 0.07385471f, -0.30540603f, 
    -0.23113644f, -0.15693788f, -0.04398868f, -0.02712707f, -0.18750621f, -0.00547779f, 0.02954223f, -0.00471842f, 
    0.21626881f, 0.20405534f, 0.10618754f, 0.40821841f, -0.17768276f, -0.08891499f, -0.22314191f, -0.10622106f, 
    -0.04118354f, -0.15681186f, -0.13589001f, -0.06405705f, 0.15132524f, 0.07016443f, 0.22566454f, 0.08828834f, 
    0.10740343f, -0.23460832f, 0.20701878f, 0.04482730f, 0.17143793f, 0.14301518f, 0.20970856f, 0.13957494f, 
    0.17482054f, 0.06658603f, 0.12928431f, 0.03024668f, 0.19791643f, -0.19519028f, -0.23510826f, 0.06372917f, 
    -0.10738680f, -0.07464850f, 0.09933961f, 0.11923733f, 0.24088456f, -0.00198467f, -0.13644485f, 0.04265409f, 
    -0.43453810f, -0.11721306f, 0.17733988f, 0.12355027f, -0.00281100f, -0.11083699f, 0.01378777f, 0.05678777f, 
    0.00272979f, 0.09795424f, 0.07148425f, -0.04195334f, -0.26740715f, -0.08404754f, 0.16738181f, 0.00198573f, 
    0.23191421f, 0.11952268f, 0.03738106f, -0.03970650f, 0.11196087f, 0.18731727f, 0.03482670f, 0.04154363f, 
    0.26989740f, 0.04464997f, 0.30442464f, -0.15323424f, 0.02184443f, -0.13369896f, 0.04015903f, -0.05887155f, 
    0.23550920f, -0.23560551f, 0.07909352f, -0.08396432f, 0.26399541f, -0.05090579f, 0.04366207f, -0.56008744f, 
    -0.01952435f, -0.11789025f, -0.11197974f, 0.02419585f, -0.07230526f, -0.02805237f, 0.00954823f, -0.01933944f, 
    0.26037613f, -0.23528644f, 0.21367875f, -0.13841875f, -0.13945107f, -0.06494566f, -0.22839108f, -0.01357886f, 
    -0.06877571f, 0.03707701f, -0.06991943f, -0.07240762f, -0.20531179f, 0.19877508f, 0.42663819f, -0.02227458f, 
    -0.04403049f, 0.01810156f, 0.05799975f, 0.15347438f, 0.02312501f, 0.07494246f, 0.14346628f, 0.00520917f, 
    0.07001465f, 0.09075703f, 0.11488929f, -0.03673164f, -0.06066673f, 0.36753035f, 0.46305814f, 0.04260473f, 
    0.01694602f, 0.11247192f, 0.15975583f, -0.09457870f, -0.20727803f, -0.43187818f, 0.01012036f, 0.06397428f, 
    -0.21381178f, 0.05286706f, -0.19721605f, -0.26036131f, -0.03675565f, 0.05187513f, 0.00938676f, -0.06403764f, 
    0.56875861f, 0.62295693f, 0.39633495f, -0.13015968f, 0.05967288f, 0.02661219f, 0.10750899f, 0.09538519f, 
    0.01785349f, 0.06343226f, 0.08130990f, -0.01499328f, -0.14980721f, 0.03244640f, 0.51522416f, -0.01313534f, 
    0.03243500f, 0.00740775f, -0.00983736f, -0.10180431f, 0.14337902f, -0.07037734f, -0.00770007f, -0.07465891f, 
    0.22522803f, 0.24782695f, 0.26911268f, -0.22439206f, -0.01583821f, -0.00845369f, 0.08326984f, 0.09046786f, 
    -0.06438271f, -0.07045319f, -0.05476528f, 0.00363717f, -0.27474725f, 0.09940041f, 0.05282890f, 0.11738642f, 
    0.01375316f, -0.17428757f, 0.06776701f, -0.00294772f, -0.04539143f, 0.15879330f, 0.02663873f, -0.09484220f, 
    0.03529744f, -0.17252029f, -0.44848603f, -0.06932013f, -0.14523686f, -0.10916797f, -0.01082880f, -0.04635615f, 
    0.11645000f, -0.04327465f, 0.01167589f, 0.03297944f, -0.07337676f, -0.22237304f, -0.04427639f, -0.19832619f, 
    -0.22010817f, -0.21074544f, 0.03187901f, -0.20186637f, 0.17948928f, 0.26123595f, 0.03816977f, 0.10018226f, 
    -0.11558038f, -0.19701362f, 0.51207536f, -0.13160509f, 0.06971174f, 0.08682954f, 0.10710539f, -0.00498982f, 
    0.13156328f, -0.00495884f, 0.14685807f, -0.07724980f, -0.06899420f, -0.31568503f, 0.40335602f, 0.31136706f, 
    -0.15202022f, 0.03509466f, 0.01830634f, 0.17128667f, 0.34520715f, -0.10802329f, 0.01082200f, 0.03625292f, 
    -0.30637464f, -0.13040335f, -0.10579996f, 0.24694359f, -0.04211213f, -0.05726013f, -0.08642565f, 0.08958224f, 
    -0.16023226f, 0.03639162f, 0.16435383f, -0.08008029f, -0.06839713f, -0.22098459f, 0.69252801f, -0.01071935f, 
    0.02103257f, -0.04453249f, -0.16992737f, 0.13483995f, 0.12932524f, -0.01409391f, 0.02644637f, -0.03848502f, 
    0.07835689f, 0.04514960f, 0.23324178f, 0.06342084f, -0.06805152f, -0.06526660f, -0.00133391f, 0.03403676f, 
    -0.07877732f, 0.00445988f, 0.00169618f, 0.11930812f, 0.45595017f, 0.34847859f, 0.34113881f, 0.09904222f, 
    -0.18718506f, -0.01713299f, -0.06248544f, 0.09904326f, 0.07128900f, 0.06816383f, -0.04531156f, -0.03379400f, 
    0.20847321f, 0.06656054f, 0.07321682f, 0.05582123f, -0.00290383f, 0.07988842f, -0.04598531f, 0.07940328f, 
    0.11167153f, 0.02888720f, 0.12988290f, 0.00302239f, -0.07945443f, -0.46137896f, -0.33693302f, -0.19890837f, 
    0.07768097f, -0.02446324f, -0.06619102f, -0.05093720f, -0.05395165f, 0.01813494f, -0.03995050f, -0.03609978f, 
    0.02300829f, -0.05118598f, 0.04331359f, -0.34769124f, -0.00838105f, -0.04705056f, -0.05600896f, -0.11943453f, 
    -0.06096783f, -0.07596862f, -0.15013768f, -0.08515507f, -0.08262591f, 0.24393612f, 0.24307597f, 0.22929506f, 
    0.01766119f, -0.12719280f, 0.13761568f, 0.08594874f, 0.01624573f, 0.01983003f, -0.02766204f, -0.03528975f, 
    -0.07710006f, -0.03012913f, 0.08266090f, 0.01112498f, -0.10939709f, -0.04205322f, -0.10365467f, 0.21778566f, 
    0.01266925f, -0.05921111f, 0.01702374f, -0.00519732f, -0.06466355f, -0.09586547f, -0.16997387f, 0.07922367f, 
    0.06851163f, 0.03033837f, 0.06282356f, 0.13855888f, -0.12035836f, -0.01615825f, 0.01988646f, -0.00470491f, 
    -0.13013169f, -0.56259602f, -0.10778350f, -0.10426860f, -0.23903906f, 0.05503629f, 0.02095352f, 0.15489893f, 
    0.07444493f, 0.01661605f, 0.03528160f, -0.12314512f, 0.38547558f, -0.26761299f, -0.25283787f, -0.27595690f, 
    0.03511925f, -0.05314966f, -0.04776754f, -0.09292968f, 0.00374513f, 0.12340715f, 0.00086851f, 0.00019377f, 
    0.12248697f, 0.15290095f, 0.07447051f, 0.06487994f, 0.03263859f, 0.06645220f, -0.04826700f, 0.01950045f, 
    -0.04074382f, -0.12617195f, -0.21409295f, -0.03542188f, 0.17760865f, 0.08806415f, 0.12742096f, -0.00707425f, 
    0.00420060f, 0.06037404f, 0.00528918f, 0.11462464f, 0.26735699f, 0.16700022f, 0.10628608f, -0.00225078f, 
    -0.14211501f, 0.08818773f, -0.02175213f, 0.06321424f, -0.04112638f, -0.14041184f, 0.33309996f, -0.14337991f, 
    -0.01220757f, 0.06011539f, -0.06600960f, 0.01660341f, -0.00846484f, -0.00667873f, -0.60342604f, 0.33399388f, 
    0.11725633f, 0.38746223f, -0.08716828f, 0.01197909f, 0.00642068f, -0.01857770f, 0.25574917f, -0.02680448f, 
    0.15877448f, 0.02580990f, 0.04704541f, -0.03830350f, -0.02074095f, 0.18919015f, 0.03325192f, 0.12967572f, 
    -0.10669927f, -0.10699885f, 0.12809807f, 0.03173483f, -0.29089233f, -0.26648539f, 0.07076570f, -0.15473397f, 
    0.05374294f, 0.08873720f, -0.00322946f, -0.09312425f, -0.17337078f, 0.03491426f, -0.27821577f, 0.06546199f, 
    -0.29687306f, 0.01247327f, 0.07585357f, 0.07734652f, 0.04470301f, -0.06568109f, -0.01144207f, 0.02777816f, 
    -0.23169611f, -0.15022430f, -0.15930201f, 0.05490323f, 0.03893956f, 0.07558012f, 0.06765161f, 0.00395441f, 
    -0.06245751f, 0.03318064f, -0.01820857f, -0.08835842f, 0.09354697f, 0.06466513f, 0.08351313f, 0.11712754f, 
    0.19717856f, -0.22982226f, -0.01633019f, -0.03427918f, -0.09833392f, -0.04592163f, -0.07258716f, 0.12207910f, 
    -0.02136793f, 0.01724183f, -0.07074551f, 0.02458633f, -0.08426569f, 0.10105713f, -0.07970419f, 0.14420164f, 
    -0.03365145f, 0.17102358f, -0.02232264f, -0.15165530f, -0.12334465f, -0.05783261f, 0.17210464f, 0.04354532f, 
    -0.05847071f, 0.18652800f, -0.12295031f, 0.20103787f, 0.00258068f, 0.18938896f, 0.13045754f, -0.15879305f, 
    0.11895553f, 0.19947787f, 0.11705822f, 0.05909744f, -0.07270478f, 0.05209513f, -0.22320801f, -0.11175547f, 
    0.07671603f, 0.14997871f, -0.02522042f, 0.17046981f, -0.08446765f, -0.19699873f, -0.01287090f, 0.06314780f, 
    0.02579004f, 0.42552513f, -0.49144101f, 0.38312933f, -0.17288482f, -0.12718607f, 0.05015105f, -0.15492420f, 
    0.09070731f, 0.07209378f, 0.00528469f, -0.08727533f, 0.16229992f, 0.06573662f, 0.17120576f, 0.05536458f, 
    0.08014592f, 0.24586897f, -0.11872568f, -0.05624115f, -0.11469895f, 0.02210756f, -0.05714359f, -0.11822233f, 
    0.23950824f, -0.23685284f, -0.17719753f, 0.15265553f, 0.06454064f, 0.24685591f, -0.03825606f, 0.01522833f, 
    0.05394883f, 0.20220907f, 0.08456271f, -0.04708129f, -0.40396026f, 0.29146487f, -0.26559669f, 0.07363044f, 
    0.11661785f, 0.08773667f, 0.01298986f, 0.08612852f, -0.08375789f, 0.21909854f, -0.07040770f, -0.24434125f, 
    -0.21752669f, 0.19454573f, -0.17835604f, -0.12427893f, -0.23097767f, 0.08297153f, 0.04171231f, -0.08510657f, 
    -0.01001032f, -0.01209580f, 0.12093477f, 0.14653733f, -0.15286207f, -0.12338200f, -0.06745804f, -0.01523985f, 
    -0.04011887f, -0.02313493f, -0.03957103f, 0.01110637f, -0.15384910f, 0.29857796f, -0.17703974f, -0.09336900f, 
    0.13094322f, -0.03101202f, 0.07223570f, 0.14207250f, 0.17531615f, -0.16435692f, 0.19638807f, 0.08765636f, 
    0.19649646f, 0.00364488f, 0.06899139f, -0.15725869f, 0.14913318f, -0.14488126f, 0.06616654f, -0.00266448f, 
    -0.17464095f, 0.01357962f, 0.07610624f, -0.03154240f, 0.01077941f, 0.14756438f, 0.00178060f, 0.08682872f, 
    -0.18543778f, -0.12139188f, -0.02339129f, 0.13110369f, 0.18341810f, -0.13182123f, -0.11430621f, 0.11168417f, 
    0.02865589f, 0.13204534f, -0.22623773f, -0.04112867f, 0.32157913f, 0.12283728f, 0.09019164f, -0.17835549f, 
    0.11453807f, 0.04243242f, 0.22746289f, 0.09776131f, 0.16676125f, 0.06022199f, 0.27932432f, -0.15116109f, 
    0.11396011f, -0.12611425f, 0.03185541f, 0.04979379f, 0.00515331f, -0.05599795f, 0.02001033f, 0.01677519f, 
    0.21741250f, 0.21450548f, 0.17145810f, -0.01328625f, 0.26624039f, 0.12879290f, 0.20954183f, -0.27737945f, 
    -0.01110433f, 0.03457927f, -0.07859281f, -0.10621676f, -0.06086578f, -0.07163851f, 0.02312738f, -0.10009000f, 
    -0.07108702f, -0.01129221f, 0.23157468f, -0.08065597f, -0.05484958f, -0.01379653f, -0.07463925f, -0.04475253f, 
    -0.06156261f, 0.12307717f, 0.04569590f, 0.02781025f, -0.03980454f, -0.03535825f, 0.28279039f, -0.02928841f, 
    -0.08680112f, -0.11641279f, 0.08156148f, 0.28352687f, -0.08928888f, -0.04371904f, 0.00417043f, -0.04924078f, 
    0.06611095f, -0.10803498f, 0.06188657f, -0.13172323f, 0.04933314f, -0.09117547f, 0.07808442f, 0.24986202f, 
    -0.10595421f, 0.07347305f, -0.04970871f, -0.25939426f, -0.21862720f, -0.31686524f, -0.02886791f, -0.01311992f, 
    -0.13081990f, -0.09795893f, -0.07123278f, -0.09828474f, -0.13202250f, 0.02546504f, -0.03064543f, -0.03212103f, 
    0.08416669f, -0.04879100f, 0.25397468f, -0.05582656f, 0.16094051f, 0.06058396f, 0.08502937f, 0.30476975f, 
    -0.00488523f, 0.06049481f, 0.13082984f, 0.18563785f, 0.01474569f, -0.09960985f, -0.00312038f, -0.04447047f, 
    -0.08002086f, -0.09531102f, 0.19934499f, -0.02539422f, -0.01650905f, 0.00390318f, 0.10184700f, 0.10604774f, 
    -0.25096914f, 0.06291007f, 0.09033566f, -0.02986020f, -0.07766446f, 0.00875168f, 0.14491168f, 0.13413055f, 
    -0.02608633f, -0.15743048f, -0.08519105f, 0.02039022f, 0.26676866f, -0.11451808f, -0.12412202f, -0.16005699f, 
    0.04653825f, 0.00737396f, -0.00864027f, -0.05264849f, -0.02876541f, 0.11190350f, 0.15166847f, 0.17317878f, 
    0.14468585f, 0.03083005f, -0.08071087f, -0.04550087f, 0.00053920f, 0.02554210f, 0.02365557f, 0.11224350f, 
    0.07587724f, 0.02359588f, -0.16002147f, 0.00941415f, 0.09139501f, 0.07373439f, 0.11539311f, -0.01759019f, 
    -0.05331428f, 0.00919030f, 0.00694440f, 0.02441223f, 0.15952636f, -0.11187163f, 0.20432983f, 0.07251769f, 
    -0.24030943f, 0.00073954f, 0.24472821f, -0.08232921f, -0.08458766f, 0.03363815f, 0.16790549f, -0.10404972f, 
    0.00027064f, 0.02751349f, -0.04395275f, 0.04231011f, -0.12123066f, 0.47359544f, -0.08532160f, 0.07208247f, 
    0.17079197f, 0.17212255f, 0.01413737f, 0.03453452f, 0.04000640f, 0.00725248f, 0.22865409f, -0.04707118f, 
    0.15075791f, 0.18495943f, -0.13398007f, 0.09930846f, 0.20501032f, 0.20427361f, -0.01934935f, 0.09590574f, 
    -0.10296367f, -0.21623464f, -0.06122373f, -0.00505885f, -0.29628623f, -0.32747871f, 0.36859250f, 0.13237417f, 
    0.03108257f, 0.25214577f, -0.23598498f, -0.21785237f, -0.05442626f, -0.00592395f, -0.03299489f, 0.00873500f, 
    -0.57066405f, 0.06097861f, 0.04374939f, 0.05821203f, -0.01583410f, 0.03748240f, -0.18473496f, -0.21875565f, 
    0.00754138f, 0.12655167f, 0.05812635f, 0.39501506f, -0.34342524f, -0.30217195f, 0.47407782f, 0.11328059f, 
    0.04971096f, -0.14779738f, -0.13729399f, 0.03003768f, -0.08445872f, -0.09646278f, 0.11632249f, -0.26652288f, 
    0.32762769f, -0.63215399f, -0.07502535f, -0.00482575f, -0.01585046f, -0.00460088f, -0.24527727f, 0.15276410f, 
    0.01649066f, -0.06266134f, -0.04843798f, 0.01748202f, 0.41557303f, 0.21451104f, 0.00622216f, 0.23225221f, 
    -0.06410412f, 0.13463333f, 0.14007439f, -0.10557876f, 0.05397523f, -0.07596926f, -0.11872507f, 0.07887911f, 
    -0.18731736f, 0.27344912f, -0.14203320f, 0.07329459f, 0.11332605f, 0.07831257f, 0.09959654f, -0.06546888f, 
    -0.01219014f, -0.07698412f, -0.00251655f, -0.29178041f, 0.31594050f, 0.13446829f, -0.18693779f, -0.13437583f, 
    0.09400419f, 0.06289972f, -0.01921147f, 0.06831890f, 0.19973937f, 0.25578654f, -0.00742946f, 0.06924412f, 
    -0.39856800f, 0.25394604f, -0.03783542f, -0.05826578f, -0.03740039f, 0.05966006f, 0.12208098f, -0.18350403f, 
    -0.14200422f, -0.01295740f, -0.00660698f, 0.27097476f, 0.08320634f, -0.00490354f, 0.09697768f, 0.03601892f, 
    0.08162841f, 0.20621645f, -0.06442716f, -0.12557730f, 0.02846201f, 0.12107704f, 0.04578828f, 0.06594642f, 
    0.18855679f, 0.24505451f, -0.00539895f, 0.22899966f, -0.06530529f, -0.08855403f, 0.06555559f, -0.07643986f, 
    0.05163816f, 0.08954149f, -0.12480310f, 0.10124817f, 0.32575446f, 0.19562215f, -0.00573945f, 0.19088089f, 
    0.02674031f, 0.24279183f, 0.17768317f, -0.14430965f, 0.14822343f, 0.08140191f, 0.07804954f, 0.19714868f, 
    0.02313573f, -0.04016388f, -0.22947024f, 0.33487657f, -0.12892488f, 0.03939674f, 0.06626879f, -0.10821792f, 
    -0.23207425f, -0.05620314f, -0.15460366f, -0.03572397f, -0.37513772f, -0.08760596f, -0.54974091f, -0.17098360f, 
    0.07396251f, -0.05197358f, 0.07661898f, 0.10475925f, -0.11903107f, -0.05717613f, -0.28848359f, 0.05178146f, 
    0.22867656f, -0.13623488f, -0.08223817f, 0.06267697f, 0.07690603f, -0.22278561f, 0.07915162f, 0.01374915f, 
    0.06706119f, 0.02446706f, 0.05672357f, -0.31716800f, 0.40993145f, -0.07528011f, 0.03941640f, -0.06737933f, 
    0.04038434f, -0.22426535f, 0.13617435f, 0.02219142f, 0.09429643f, 0.20887433f, 0.16944252f, 0.05899965f, 
    0.03504760f, -0.18116476f, -0.52389061f, 0.05013618f, -0.05968488f, 0.28998870f, 0.10301248f, -0.05034201f, 
    -0.16039942f, 0.01420508f, 0.12858519f, 0.07704290f, -0.35733277f, 0.16156520f, 0.15255724f, 0.07409795f, 
    0.17887640f, 0.06973836f, -0.12070267f, -0.01837634f, 0.03203528f, 0.00508140f, 0.09826342f, 0.00617608f, 
    0.14324574f, 0.08933247f, 0.29683989f, -0.01630573f, 0.00293652f, 0.03453616f, 0.07287411f, 0.06933570f, 
    0.05601433f, -0.16348150f, -0.06457304f, 0.01842511f, 0.14834882f, 0.44447678f, 0.24478237f, 0.41973639f, 
    -0.14960729f, -0.11111742f, -0.03749627f, -0.06077798f, 0.07100269f, 0.08609041f, 0.06571280f, 0.14063004f, 
    0.32284227f, 0.32043320f, 0.14537278f, 0.30859724f, -0.03612293f, -0.00579988f, 0.01127746f, -0.02360352f, 
    0.21161762f, 0.14385760f, 0.07470958f, 0.08782218f, 0.14468531f, -0.45108232f, -0.42691174f, -0.20357232f, 
    -0.07545940f, 0.00609524f, -0.20606458f, 0.02584908f, 0.00921473f, 0.00656513f, 0.00283393f, -0.01518879f, 
    -0.09658729f, -0.12644474f, -0.09677378f, -0.29150778f, 0.08429100f, 0.00235951f, -0.09698965f, -0.13357604f, 
    -0.00411329f, 0.03760017f, 0.13093017f, 0.12998484f, -0.41886613f, 0.08544733f, -0.23318262f, -0.16088650f, 
    0.13645925f, 0.18116456f, 0.19564389f, 0.22405869f, 0.09524391f, -0.05203129f, 0.14785329f, 0.01398270f, 
    0.32018083f, 0.02245487f, 0.11551905f, -0.25473440f, -0.18346837f, -0.00196378f, -0.07414656f, 0.00508956f, 
    0.07197010f, 0.08294386f, -0.12118971f, -0.00509747f, -0.48729616f, -0.46045077f, -0.50608885f, -0.27513772f, 
    0.11366890f, -0.17648582f, -0.14280434f, 0.00101753f, -0.01059362f, -0.05623771f, -0.09707143f, -0.02971253f, 
    0.32567337f, -0.31259677f, -0.24245937f, -0.22111939f, -0.03762512f, -0.03543718f, -0.16132712f, -0.12858026f, 
    0.04265955f, 0.04331572f, -0.00793411f, 0.00923386f, 0.12006066f, -0.10121292f, 0.00962759f, -0.13715556f, 
    -0.08975261f, 0.00143748f, 0.07704280f, -0.18313205f, -0.05362125f, -0.17663200f, -0.01391836f, -0.22739813f, 
    0.21772504f, 0.24673839f, 0.31382433f, 0.22537607f, 0.02497414f, 0.00221786f, 0.00507973f, -0.04587336f, 
    -0.00124174f, -0.07384428f, -0.02683039f, 0.07407841f, -0.05097908f, 0.09217858f, -0.07413208f, 0.08109619f, 
    0.05547722f, 0.09662008f, -0.07604381f, 0.16563810f, 0.09891187f, -0.07324799f, 0.06601527f, 0.05498053f, 
    0.03905311f, -0.35997012f, -0.33234799f, -0.08907756f, 0.07293406f, 0.06609989f, 0.15233411f, -0.03584214f, 
    -0.00684102f, 0.07021642f, 0.01609879f, -0.09822299f, 0.32614174f, -0.10364142f, -0.17861454f, -0.01019685f, 
    -0.12414216f, 0.08008354f, -0.12482901f, -0.05817560f, 0.03125134f, -0.10772128f, -0.13562933f, 0.03708868f, 
    0.17932762f, -0.21138132f, 0.27594373f, 0.16353746f, 0.12566523f, 0.11137928f, 0.12098715f, 0.10324461f, 
    0.05628307f, 0.07057389f, -0.00951645f, -0.00433150f, -0.27005985f, 0.09111942f, -0.02817438f, 0.53260773f, 
    0.03495386f, 0.19068396f, 0.17718640f, -0.14678895f, 0.02391653f, -0.03309756f, 0.10150768f, -0.10646626f, 
    -0.16388476f, 0.09982387f, 0.10933193f, -0.02677814f, 0.05185557f, 0.01761757f, 0.09670169f, -0.17567801f, 
    0.05058091f, -0.03193491f, 0.06553585f, -0.18870984f, -0.23620200f, 0.04074563f, 0.16491280f, 0.00187514f, 
    -0.07623234f, 0.08082217f, -0.05952013f, 0.01871356f, 0.02823983f, -0.04698891f, 0.05550734f, -0.01969888f, 
    -0.09736386f, 0.37139231f, 0.12934849f, -0.12896273f, -0.02157810f, -0.17498563f, -0.09576871f, -0.13138142f, 
    0.09576928f, -0.21185526f, -0.08018865f, 0.08497582f, 0.14957304f, -0.04079361f, 0.08472248f, 0.12326247f, 
    -0.07033090f, 0.02311275f, 0.16339327f, 0.09805433f, 0.11899826f, 0.00412256f, -0.13124880f, 0.05475410f, 
    -0.06002536f, -0.10348216f, 0.15093429f, 0.18639319f, 0.11676795f, 0.18490663f, -0.15653674f, 0.07677310f, 
    0.01887338f, 0.37117839f, 0.24080388f, 0.17907178f, 0.01628081f, -0.24890444f, -0.01901036f, 0.11066042f, 
    0.17991076f, 0.02384041f, 0.05584463f, 0.02029568f, 0.10218061f, -0.08392271f, 0.18569036f, -0.17915386f, 
    -0.38148296f, 0.21020304f, 0.47960228f, -0.01074922f, -0.11986301f, 0.33823249f, -0.17278603f, -0.10453867f, 
    0.00211116f, 0.06078078f, -0.08257975f, 0.13920572f, -0.04399116f, -0.11620588f, -0.07508752f, -0.03237727f, 
    0.07988814f, -0.30034950f, 0.10003558f, 0.11971354f, 0.03285997f, -0.08664786f, -0.16544379f, 0.03617954f, 
    -0.32228664f, 0.24108973f, 0.36413571f, 0.23364127f, 0.09286563f, -0.17612568f, 0.03786725f, 0.21061043f, 
    0.01409674f, -0.07084545f, -0.05007631f, -0.03877594f, 0.46843314f, 0.00787944f, -0.02780048f, -0.07762189f, 
    -0.05024010f, -0.08192155f, 0.13525704f, 0.15199068f, 0.07974028f, -0.10891711f, -0.12726775f, -0.04258207f, 
    0.31091255f, -0.08703129f, -0.14335465f, -0.04133252f, -0.06931484f, 0.09052896f, 0.02864972f, -0.03073059f, 
    0.05599608f, 0.09020343f, 0.06830226f, 0.34507039f, -0.42319393f, -0.15556933f, -0.05352501f, -0.18287744f, 
    -0.02719984f, 0.05730434f, -0.13597438f, -0.14486837f, -0.12023217f, -0.00847952f, -0.00661532f, -0.03487698f, 
    -0.05656122f, 0.37243888f, 0.18208882f, 0.16531360f, -0.04958343f, 0.22030225f, 0.08092717f, 0.10202603f, 
    -0.01723524f, 0.02282554f, 0.13072252f, 0.01474574f, -0.16448008f, 0.51246113f, 0.32911617f, -0.05524520f, 
    -0.12447938f, 0.04255963f, -0.06423479f, 0.02759533f, 0.09305089f, -0.03858245f, -0.12482638f, -0.06879438f, 
    0.03199266f, -0.04092878f, -0.01738037f, -0.01712843f, -0.00106995f, -0.05443892f, 0.05770342f, 0.01565093f, 
    -0.01928123f, -0.00946104f, -0.01614175f, -0.04483981f, 0.01276492f, -0.01595843f, 0.01519548f, -0.07632522f, 
    0.04841386f, 0.01480357f, -0.05146888f, -0.00276962f, 0.00229757f, -0.04638700f, -0.01564891f, -0.04752451f, 
    0.06009751f, 0.06527637f, 0.05114603f, -0.02221275f, -0.07417071f, -0.04517664f, -0.04691191f, 0.04927174f, 
    -0.03922958f, 0.03543366f, -0.00013629f, 0.02233326f, 0.04171739f, -0.04237552f, -0.01554904f, 0.03625242f, 
    -0.07931011f, -0.05981731f, 0.01415187f, -0.00208774f, 0.01141209f, -0.06707618f, -0.07283238f, -0.07976987f, 
    -0.05695296f, -0.06190820f, 0.01135644f, -0.05313663f, 0.02823520f, 0.07044300f, -0.04446479f, -0.03767074f, 
    -0.07142951f, 0.03503961f, -0.04947932f, -0.04963795f, 0.05482561f, -0.04936263f, 0.03416765f, 0.02849968f, 
    0.00318820f, -0.03958382f, -0.00411677f, -0.01420910f, 0.01916603f, 0.03481319f, -0.07971074f, -0.03957832f, 
    0.06703086f, 0.05219126f, 0.04520808f, -0.01969040f, -0.05170896f, -0.01050294f, -0.05675568f, -0.02135174f, 
    0.05243529f, 0.06301448f, 0.00122861f, -0.03541001f, -0.00661321f, -0.05587316f, -0.00570936f, -0.06284909f, 
    0.04063612f, -0.03379066f, 0.01870160f, -0.00224867f, -0.05848495f, -0.04325868f, -0.04721083f, 0.00351739f, 
    -0.00620614f, -0.00719766f, -0.03528440f, 0.03774941f, 0.04301812f, 0.00555843f, -0.04875268f, 0.01490471f, 
    -0.04891629f, 0.04888216f, -0.04512144f, 0.02087486f, 0.06163654f, 0.04238954f, 0.04538493f, -0.04698593f, 
    -0.06924608f, 0.02409177f, -0.01750410f, -0.05098714f, -0.07405984f, -0.05366610f, 0.06631581f, 0.02993812f, 
    -0.01090133f, 0.00996777f, 0.06238760f, -0.02872198f, -0.01339803f, 0.02932741f, 0.05888483f, 0.06069179f, 
    -0.01234680f, 0.04901544f, -0.00834580f, -0.04779007f, 0.03339313f, -0.04449276f, -0.03998150f, -0.04297578f, 
    0.00316121f, 0.01058614f, -0.03065585f, -0.04488303f, -0.03715757f, -0.00068382f, 0.02656847f, -0.06526746f, 
    0.00896304f, 0.05668298f, -0.04500051f, -0.01433892f, -0.08046808f, -0.01546055f, -0.01120042f, -0.05777025f, 
    0.02856806f, -0.01614086f, -0.00973434f, 0.00438452f, -0.07157002f, -0.02630607f, -0.06565169f, -0.05937104f, 
    -0.04132592f, 0.00926076f, 0.01017918f, 0.04889020f, 0.03006264f, -0.07917278f, -0.03064237f, -0.02117581f, 
    0.03200938f, 0.06414998f, 0.03600563f, -0.00637833f, 0.00018407f, 0.02193413f, -0.02231084f, -0.02684735f, 
    0.02285899f, 0.05391379f, -0.01244125f, -0.05344965f, 0.02954166f, 0.00392722f, 0.00798626f, -0.04887320f, 
    -0.04886308f, -0.01146221f, -0.00005882f, -0.00706034f, 0.00680189f, 0.03833861f, -0.01335921f, -0.06849487f, 
    0.01876768f, -0.04568651f, -0.00647437f, -0.05331427f, 0.01951575f, 0.04462115f, -0.03179577f, 0.00027142f, 
    -0.04888232f, -0.00534158f, -0.04591252f, -0.04473237f, 0.02658848f, 0.05562575f, -0.00407724f, 0.02224844f, 
    -0.03799457f, -0.03963839f, 0.05617480f, -0.02706159f, -0.03425363f, -0.02271733f, -0.04837344f, -0.07485493f, 
    0.04694459f, -0.04089703f, 0.05655208f, -0.05350194f, 0.01950682f, -0.04441239f, -0.03494532f, 0.01158138f, 
    -0.00166643f, -0.03205680f, -0.01590323f, -0.06224162f, 0.01710407f, -0.04808248f, 0.05810370f, -0.01334322f, 
    -0.07652269f, 0.03828674f, 0.03448166f, 0.02491597f, 0.04031361f, -0.02482857f, 0.03105101f, 0.00702776f, 
    0.06065455f, -0.02996330f, 0.05605203f, 0.03404574f, -0.05172770f, -0.00161824f, 0.04239655f, -0.06936600f, 
    0.00290974f, -0.08670294f, 0.01898959f, -0.00377618f, -0.04711672f, -0.03161952f, 0.03711129f, 0.06009999f, 
    -0.00170186f, -0.06024375f, -0.06513849f, 0.05045083f, -0.00581326f, 0.03212118f, -0.04933307f, 0.01882405f, 
    0.01125281f, 0.04528466f, -0.06979357f, -0.01212972f, -0.03709339f, -0.06977140f, 0.01186509f, -0.05811089f, 
    -0.02753352f, -0.00263205f, -0.05958286f, -0.07448351f, 0.03549105f, 0.07370967f, -0.05961179f, 0.03393883f, 
    -0.03388936f, 0.02363300f, 0.06025049f, -0.02451910f, 0.02875041f, 0.03066283f, -0.07305094f, -0.00518329f, 
    -0.05780964f, -0.01036313f, -0.00597398f, -0.01105138f, -0.08716790f, 0.02944187f, -0.04558118f, 0.04663218f, 
    0.02499447f, -0.07358020f, 0.01391485f, 0.05694631f, -0.01012847f, 0.03357618f, -0.05601411f, -0.03555882f, 
    0.01471960f, -0.06033272f, -0.06806374f, -0.00843850f, -0.07726078f, -0.00735827f, -0.00461641f, 0.00325449f, 
    -0.03816596f, -0.07864679f, -0.02102149f, -0.02648537f, -0.06746794f, -0.07866019f, 0.04470190f, 0.00422476f, 
    -0.02962980f, 0.04641747f, -0.08078768f, 0.04835606f, 0.04292996f, -0.07986178f, -0.01688561f, -0.08028470f, 
    0.00930050f, 0.02437415f, -0.05321820f, 0.04621409f, -0.00261935f, 0.01372813f, -0.08064298f, -0.00921893f, 
    0.01580286f, -0.06182912f, -0.03990815f, 0.03833497f, 0.04676928f, -0.02779184f, 0.03246232f, 0.02939178f, 
    -0.05596614f, -0.04364901f, -0.03383351f, 0.03695643f, -0.07117044f, -0.05079452f, 0.00433164f, -0.01329980f, 
    -0.05468119f, -0.05284693f, 0.03605311f, -0.04059790f, 0.04315162f, -0.08550818f, -0.03111389f, -0.02708863f, 
    0.04129072f, -0.06843994f, 0.04206670f, -0.07943404f, -0.00137983f, -0.03171492f, 0.01623261f, -0.00618800f, 
    -0.07474938f, -0.07779474f, -0.01987610f, -0.06276818f, -0.00029471f, 0.03135912f, 0.01092414f, -0.05529793f, 
    -0.07488059f, -0.02198642f, -0.00670290f, -0.03764714f, -0.00955547f, -0.06976316f, 0.01998527f, -0.04319943f, 
    0.03519865f, 0.00315785f, 0.01902388f, 0.01544976f, -0.06633050f, -0.00031277f, 0.06158951f, 0.03109637f, 
    0.00630980f, -0.02334332f, -0.07019247f, -0.06933929f, -0.02780759f, -0.04281195f, 0.05423679f, 0.07243817f, 
    0.01743103f, 0.04503750f, 0.01812838f, -0.00492124f, 0.06219263f, -0.03323507f, 0.02719983f, 0.03813743f, 
    0.00384094f, -0.01826805f, -0.00249465f, -0.00600500f, -0.02694269f, -0.02237646f, -0.03043470f, 0.05073777f, 
    -0.02103930f, 0.00623112f, -0.01427214f, -0.06639118f, 0.01668332f, 0.00232324f, 0.01822994f, -0.08025087f, 
    0.01388281f, -0.00977864f, 0.02739782f, 0.01677489f, -0.07740363f, 0.03462904f, 0.00687176f, -0.00359749f, 
    0.03095141f, 0.06094213f, -0.07173130f, 0.04000123f, 0.04129868f, -0.05362621f, -0.05895554f, -0.07873388f, 
    -0.03717790f, 0.02657492f, 0.00850998f, -0.03083234f, 0.05266346f, 0.05245244f, 0.04937057f, -0.00489572f, 
    -0.06743475f, -0.05769908f, 0.04248865f, 0.04003761f, -0.06000835f, 0.01101592f, 0.01912328f, -0.07538737f, 
    -0.04394466f, -0.04787537f, -0.00225467f, 0.03218617f, -0.02013568f, -0.07150012f, -0.01040683f, -0.01791807f, 
    0.03383420f, -0.02829190f, 0.06076371f, -0.01641188f, 0.05792751f, 0.06055307f, -0.00205603f, -0.04514259f, 
    -0.00411385f, 0.04904003f, -0.01257121f, 0.00398476f, -0.01926349f, -0.01638400f, -0.07698841f, -0.07482216f, 
    -0.03072526f, 0.00358537f, 0.00422374f, -0.07051376f, 0.01761016f, 0.03489900f, -0.06710983f, -0.01159011f, 
    -0.02744381f, -0.06874671f, -0.01753945f, 0.00321568f, 0.01890914f, -0.05675372f, 0.04382568f, 0.05914217f, 
    -0.04989030f, 0.02578382f, 0.00329250f, -0.00705334f, 0.00613459f, -0.01905764f, -0.05750715f, 0.06905320f, 
    0.05420242f, -0.06151850f, 0.02121462f, -0.07498723f, -0.04484795f, -0.00146603f, 0.02159589f, 0.04876445f, 
    0.00371163f, 0.04145923f, -0.07237083f, 0.02387366f, -0.03968211f, -0.01557116f, -0.02192075f, -0.07124338f, 
    -0.06902108f, 0.01697960f, 0.05982422f, -0.02053590f, -0.07622434f, 0.00275376f, 0.06213820f, -0.05765267f, 
    -0.07263342f, 0.01489848f, -0.07047964f, -0.00527545f, -0.02520600f, -0.05787414f, -0.01710253f, -0.06018628f, 
    0.05944880f, 0.02561874f, -0.01249727f, 0.00209790f, 0.00306026f, -0.04509135f, -0.00311381f, 0.02091257f, 
    -0.05684817f, -0.05709298f, 0.04497129f, 0.04004847f, 0.01493994f, -0.05941597f, -0.05402663f, -0.05065419f, 
    0.01460038f, -0.01060935f, -0.06664298f, -0.01281221f, -0.04591336f, -0.05253389f, -0.05907856f, 0.02515407f, 
    -0.05652189f, 0.02553154f, 0.01382063f, -0.04713567f, -0.06388027f, 0.02139506f, -0.05682943f, -0.06705759f, 
    -0.04017030f, 0.04514046f, 0.00317059f, 0.04771573f, 0.00128300f, -0.03632426f, -0.03208426f, 0.02249573f, 
    -0.44214058f, -0.38603342f, 0.36131960f, 0.34626284f, -0.08708912f, 0.20681633f, 0.01825092f, 0.13489659f, 
    -0.17124759f, -0.04921618f, -0.05437216f, 0.04665799f, -0.35205376f, 0.10707414f, 0.12900662f, 0.27987057f, 
    -0.19221142f, 0.10789499f, 0.01016904f, 0.04900960f, -0.09156334f, -0.03971940f, 0.07659856f, -0.06049838f, 
    0.09715267f, -0.06548570f, 0.31134406f, 0.07403126f, -0.00623153f, 0.12247646f, -0.12233602f, -0.13424158f, 
    0.08214596f, 0.12663047f, 0.26258248f, 0.20363609f, -0.00866088f, 0.02694473f, -0.01784773f, -0.16324511f, 
    0.05973892f, -0.05616900f, -0.33969679f, -0.23188093f, -0.07132188f, 0.05976971f, 0.00234644f, 0.00276672f, 
    0.06376278f, 0.12843060f, -0.00941016f, 0.06479533f, 0.14236352f, -0.07979541f, 0.23584010f, -0.31684572f, 
    0.09520048f, 0.03353070f, 0.14076860f, -0.01728744f, 0.36889920f, -0.65455329f, -0.23135819f, -0.26007482f, 
    -0.14689492f, -0.14446193f, 0.21503872f, -0.01277959f, -0.11233433f, 0.26318160f, 0.12032705f, -0.00449402f, 
    -0.07261771f, -0.20901491f, 0.10192847f, -0.32224631f, -0.01013300f, -0.06016605f, -0.11759736f, -0.06256007f, 
    -0.26024663f, -0.11125918f, 0.04770537f, -0.00846775f, -0.21058828f, -0.21558230f, -0.19184466f, 0.13871697f, 
    0.12857080f, 0.11207948f, 0.16370034f, 0.35529450f, 0.00747581f, 0.05765395f, 0.01694688f, -0.02399636f, 
    0.00998494f, -0.59950733f, 0.43925440f, -0.39239940f, -0.14180568f, 0.07312104f, -0.08151359f, -0.23924610f, 
    0.11412445f, 0.05182962f, 0.08532275f, 0.07632148f, 0.00594724f, -0.34714699f, -0.14265995f, -0.26057270f, 
    0.00856093f, -0.02847731f, 0.04108378f, 0.18420134f, -0.16598555f, 0.07327297f, 0.12226024f, 0.00809415f, 
    -0.34963360f, 0.07810845f, -0.30293840f, -0.21395782f, -0.09140531f, -0.28995854f, 0.21419682f, -0.07411642f, 
    -0.02151788f, 0.02321531f, -0.07701960f, 0.01167896f, 0.62622380f, -0.43464458f, -0.20592682f, -0.09297476f, 
    -0.01175412f, 0.18236420f, -0.28760558f, -0.05734465f, 0.16373727f, -0.00205906f, 0.00850960f, -0.00006133f, 
    0.14812975f, -0.14452927f, -0.12951726f, -0.20111708f, -0.10932657f, 0.01066094f, -0.07724009f, -0.19750446f, 
    -0.11920582f, -0.00106891f, 0.05831354f, -0.28923544f, 0.02089414f, -0.10636692f, -0.19843072f, -0.14520888f, 
    -0.22371432f, 0.11942794f, 0.05939072f, 0.28289354f, 0.08944505f, -0.38416252f, -0.00686783f, -0.11171304f, 
    0.08547252f, 0.39063495f, 0.28237975f, 0.08946595f, 0.01824970f, -0.04881544f, -0.04556369f, 0.27311659f, 
    0.13673162f, 0.01619310f, 0.01453243f, -0.07600387f, 0.24983670f, 0.13711844f, 0.29189503f, -0.48319864f, 
    -0.24019705f, -0.08676356f, 0.06262966f, 0.30684549f, -0.10140035f, 0.11020325f, 0.25150749f, -0.10265086f, 
    0.03114860f, -0.25364283f, -0.03954347f, -0.09678888f, 0.22767463f, 0.11945850f, 0.00353067f, 0.05299415f, 
    0.01955738f, 0.04350148f, -0.01295218f, 0.00568514f, 0.27795064f, 0.11445127f, -0.11704613f, -0.38529763f, 
    0.15388083f, 0.14145027f, 0.28842515f, 0.01133425f, -0.04269235f, -0.04204920f, 0.05851850f, 0.04562993f, 
    -0.05499946f, -0.00772107f, -0.14710787f, -0.02297512f, -0.00070232f, -0.06778510f, -0.10283753f, 0.03086323f, 
    0.13556014f, 0.11469261f, -0.25167608f, -0.25054127f, -0.04440144f, 0.22413896f, 0.04028045f, -0.24753346f, 
    -0.02932263f, -0.05855972f, -0.07887711f, -0.07865520f, -0.10293150f, -0.00464808f, 0.10173094f, 0.08018672f, 
    0.00204349f, -0.00882122f, 0.23285569f, 0.02433985f, -0.01459705f, -0.02691439f, -0.10321132f, 0.05825281f, 
    -0.15592471f, 0.04307872f, 0.09727130f, -0.10919243f, -0.41291133f, 0.13655505f, 0.18350358f, 0.10882666f, 
    0.07638346f, 0.07513355f, 0.03540308f, 0.00634977f, 0.20718963f, 0.02481461f, 0.00304690f, -0.02728088f, 
    -0.03473245f, -0.06279402f, 0.03673271f, 0.22106205f, 0.09330063f, 0.16147906f, -0.07283006f, 0.07525910f, 
    0.03378521f, 0.11809658f, 0.13563964f, 0.04232229f, -0.29078349f, -0.56341344f, -0.39692461f, -0.33129218f, 
    -0.12430102f, 0.14804853f, 0.02663664f, -0.18319134f, -0.32104567f, -0.11833110f, -0.08076154f, -0.02483118f, 
    0.01612123f, 0.40489638f, -0.01848797f, 0.13841763f, 0.07859275f, -0.03268456f, 0.05304112f, -0.07945191f, 
    0.18005738f, 0.17057668f, 0.17712618f, -0.04114655f, 0.20020686f, 0.00053670f, 0.19709277f, -0.03705609f, 
    0.01656368f, 0.12374327f, -0.00053767f, -0.30987602f, -0.05279614f, 0.03834823f, -0.00910756f, -0.07962067f, 
    -0.06340777f, 0.16242264f, 0.03513772f, 0.23260280f, 0.07546350f, 0.15742853f, 0.11965097f, -0.02602972f, 
    0.21329693f, 0.07017855f, 0.03034928f, 0.01965204f, -0.45174959f, 0.01008329f, -0.14037794f, -0.12664691f, 
    -0.09198350f, 0.16716555f, 0.06179172f, 0.07818019f, -0.03069955f, 0.11764492f, -0.00231585f, -0.11510330f, 
    -0.00066395f, 0.07924356f, -0.17509790f, -0.11459590f, -0.08305910f, -0.17198548f, 0.07135592f, 0.07077126f, 
    0.08307379f, 0.23033036f, 0.20305468f, 0.23800912f, -0.09426076f, -0.02857451f, 0.09741338f, 0.07920820f, 
    -0.12110037f, -0.19755068f, -0.00898706f, -0.03502393f, -0.05953814f, -0.00802501f, -0.01075445f, -0.02381776f, 
    -0.15752125f, -0.20747308f, 0.22282088f, 0.01662840f, 0.03419431f, -0.03799467f, 0.06960034f, 0.14038478f, 
    0.32071275f, 0.10766603f, 0.01318660f, 0.02087420f, 0.09349941f, 0.19221006f, 0.08869553f, -0.34276834f, 
    0.02834310f, -0.07519824f, 0.12121720f, 0.10127924f, 0.07945631f, 0.20024981f, 0.10981131f, 0.03978898f, 
    -0.05814476f, -0.15386575f, -0.05923624f, -0.28991893f, 0.10053208f, 0.09503996f, 0.07930725f, 0.08874045f, 
    0.09772073f, 0.06435835f, -0.00292051f, 0.11516791f, 0.22649880f, 0.32269129f, -0.20815180f, -0.20505448f, 
    0.21125340f, 0.09095445f, 0.37024534f, 0.22854488f, 0.07657500f, -0.09063236f, 0.11213308f, 0.15890005f, 
    0.24282984f, 0.16537134f, 0.14160815f, 0.05757888f, -0.06423447f, 0.05404011f, 0.08081371f, 0.10548787f, 
    0.23000564f, -0.02003803f, -0.01496654f, -0.28911126f, -0.04283687f, 0.10417919f, -0.07100647f, -0.19508156f, 
    0.05890400f, 0.14998408f, 0.12999566f, -0.11876613f, -0.05201966f, 0.06152425f, -0.06722856f, -0.03253539f, 
    -0.05054547f, 0.62950224f, 0.45674282f, 0.38865173f, -0.09347163f, -0.12239841f, -0.01655986f, -0.15281197f, 
    -0.13853122f, -0.17879862f, -0.06721174f, 0.02713535f, -0.37368044f, -0.22963022f, 0.13734753f, -0.15936230f, 
    0.00569354f, -0.07519928f, -0.03906975f, 0.11337814f, 0.10061356f, 0.19258937f, -0.00876361f, 0.04362531f, 
    0.01060300f, -0.25847745f, 0.08264481f, -0.15554817f, -0.02333490f, 0.02971587f, -0.00185241f, 0.15193447f, 
    0.05732849f, 0.11117826f, 0.11599884f, 0.18200727f, -0.41523531f, -0.38564998f, -0.05769285f, -0.14124326f, 
    -0.08031941f, -0.02338561f, -0.10718694f, -0.13737085f, -0.18681674f, -0.00912047f, -0.00379375f, -0.06540585f, 
    0.25235000f, 0.13865401f, 0.64824140f, -0.24271597f, -0.03665451f, 0.02082507f, 0.17789438f, 0.09851237f, 
    0.16844143f, 0.19379911f, 0.04840698f, -0.07734217f, -0.04353454f, 0.06894539f, 0.04449292f, -0.09070227f, 
    0.09834086f, -0.06397934f, 0.04913426f, 0.02389726f, -0.02958272f, 0.03824831f, 0.03440034f, -0.07351767f, 
    -0.27801356f, 0.25831324f, 0.15031470f, -0.11878338f, -0.11629189f, -0.02198881f, -0.01034018f, 0.11485620f, 
    0.22745261f, 0.13456303f, 0.13049224f, 0.06587879f, 0.04034748f, -0.03404293f, 0.08173602f, -0.18377435f, 
    -0.04136537f, -0.04456950f, -0.11998188f, -0.03401544f, -0.11643157f, -0.06362600f, 0.06000181f, -0.06464203f, 
    0.17112947f, 0.02092586f, -0.07199274f, -0.10803210f, 0.11119342f, -0.04728856f, -0.02235076f, -0.05017473f, 
    0.09105089f, 0.12035592f, 0.08174102f, 0.11023211f, 0.01028799f, 0.03374032f, 0.14184649f, -0.08908563f, 
    -0.06548367f, -0.11113333f, -0.00653050f, -0.13747914f, -0.06459381f, -0.02223866f, 0.16046779f, 0.09365828f, 
    -0.19012779f, 0.00058123f, 0.20788065f, -0.08472025f, 0.00546623f, 0.05178146f, 0.03764199f, 0.10078792f, 
    0.07112976f, 0.12183012f, -0.03412482f, 0.19954094f, 0.07742800f, 0.28561747f, 0.29452363f, 0.08140023f, 
    0.16743305f, 0.07581537f, 0.09423786f, 0.17694984f, 0.09419625f, 0.22979255f, 0.06542297f, -0.07656416f, 
    -0.06966960f, 0.18119803f, -0.14509106f, -0.03009232f, -0.05703815f, 0.12842034f, -0.03006469f, 0.08886389f, 
    0.03966555f, -0.31832999f, 0.01902397f, 0.00906324f, -0.17983124f, -0.10068382f, 0.24117841f, -0.33056363f, 
    0.12654561f, -0.02031001f, 0.01169539f, 0.07105085f, -0.00084831f, -0.01498014f, -0.09868146f, 0.25214025f, 
    -0.18506581f, -0.21831921f, 0.18945128f, 0.13955854f, -0.08544934f, 0.00112479f, 0.07466716f, -0.03246536f, 
    -0.11954021f, -0.06974492f, 0.03003932f, 0.13342534f, -0.17797513f, -0.29536340f, -0.33376923f, -0.13924797f, 
    0.20687741f, -0.08377045f, -0.00804117f, 0.02067830f, -0.02595427f, 0.02903993f, 0.07556307f, -0.06334238f, 
    -0.31036076f, -1.27995288f, -0.62092614f, 0.36564422f, 0.01967874f, 0.17907852f, -0.05417767f, 0.10256721f, 
    -0.17133389f, 0.08668646f, 0.06829585f, -0.01619565f, 0.12625812f, 0.03684667f, -0.12254358f, -0.00572152f, 
    -0.05537693f, -0.10203092f, -0.02021549f, -0.08802357f, -0.12060969f, -0.04583708f, 0.12581415f, -0.09938327f, 
    0.11472856f, 0.07023646f, -0.16263929f, -0.20093147f, 0.00189688f, 0.07917297f, 0.15328664f, 0.00410041f, 
    -0.10826579f, -0.08902547f, -0.30832604f, 0.12875757f, 0.20388445f, 0.32862324f, 0.02162106f, -0.18251601f, 
    0.03383646f, -0.00563945f, -0.14091288f, 0.01322454f, -0.05223127f, -0.04463183f, -0.04214944f, 0.05623176f, 
    0.63027984f, -0.12053710f, -0.20336248f, -0.13294251f, -0.13110231f, -0.20843801f, 0.21216398f, 0.10909863f, 
    0.12140999f, 0.01279598f, 0.11313152f, 0.06306908f, 0.23266000f, 0.29748604f, 0.13736825f, -0.08139376f, 
    -0.00313068f, 0.21381578f, -0.08709908f, -0.08592224f, -0.13369179f, -0.02883985f, 0.00070600f, -0.16878344f, 
    0.27709678f, -0.19628514f, -0.43982285f, -0.17316805f, -0.15274459f, 0.10489790f, 0.11411952f, -0.03849287f, 
    -0.11124996f, 0.03817061f, 0.02244644f, 0.13178700f, 0.13958310f, 0.07415822f, 0.07831433f, -0.06603997f, 
    0.08030792f, 0.22322945f, -0.15055840f, -0.00373915f, 0.09534056f, 0.02412212f, 0.12340783f, -0.05445802f, 
    -0.59369290f, -0.07678167f, -0.11272063f, -0.07968552f, 0.06155609f, 0.20615555f, 0.07472875f, -0.14158332f, 
    0.01399119f, 0.03679140f, -0.09129695f, 0.05828527f, 0.21854216f, 0.03226644f, -0.29546401f, -0.04928617f, 
    -0.01294395f, 0.00799965f, 0.13458818f, 0.08328234f, 0.02915322f, 0.18604410f, 0.01172183f, -0.05591027f, 
    0.22563182f, -0.06310554f, -0.03037136f, -0.08602883f, 0.00954813f, -0.04779319f, 0.03846350f, 0.05255580f, 
    0.09629010f, 0.00706978f, -0.00414879f, -0.11339945f, 0.51558727f, -0.24491332f, 0.13037528f, 0.31044430f, 
    -0.07363211f, -0.17078467f, 0.27048719f, 0.12787330f, 0.23684199f, 0.09203400f, 0.13479643f, -0.06696101f, 
    -0.27587992f, -0.34048191f, -0.42530814f, -0.31710511f, -0.10599197f, -0.04886538f, 0.09028717f, -0.15358107f, 
    -0.19469938f, -0.05601190f, 0.03102449f, -0.11909197f, -0.08003898f, -0.09013000f, -0.14354233f, 0.09797257f, 
    -0.08154880f, -0.23697019f, -0.12150034f, -0.21963219f, 0.16727923f, 0.06580597f, -0.14811614f, -0.16219221f, 
    0.06879600f, 0.14150265f, 0.15875903f, -0.00386735f, 0.01320960f, 0.01094919f, -0.03808751f, 0.00446120f, 
    0.10062172f, 0.14309561f, -0.13318537f, 0.01879220f, 0.08134723f, 0.05518389f, 0.04905980f, 0.16729559f, 
    -0.08371080f, 0.01807453f, -0.04397452f, 0.05734107f, 0.15711778f, 0.05283037f, 0.01389816f, 0.10722671f, 
    0.39068344f, 0.09655916f, -0.03429719f, 0.05399100f, 0.11190768f, 0.13707423f, 0.10852196f, 0.02659295f, 
    0.14594916f, 0.17754710f, -0.01089496f, -0.18557300f, 0.09688564f, 0.01325862f, 0.06751519f, -0.29901206f, 
    0.08929091f, 0.13227306f, -0.04498828f, 0.04722466f, 0.10310545f, 0.25488132f, 0.17532133f, 0.11368982f, 
    0.03920837f, 0.11068933f, -0.08987935f, 0.07850431f, -0.01896277f, -0.11935613f, -0.06394140f, 0.06704272f, 
    0.08092514f, 0.09058991f, 0.13082054f, 0.16122067f, 0.05374639f, 0.14895904f, -0.17382392f, 0.02532388f, 
    0.14342278f, 0.07035362f, -0.07776483f, 0.15166204f, 0.15700535f, -0.03395661f, 0.00004746f, 0.04688132f, 
    0.09542650f, 0.21120481f, -0.25766763f, -0.06251616f, 0.06763379f, 0.06529119f, 0.03182804f, 0.15813832f, 
    0.09621909f, 0.06602076f, -0.05251729f, -0.12017456f, -0.20320816f, -0.32952631f, -0.07604034f, -0.02338073f, 
    -0.03150109f, -0.28367743f, -0.19633986f, 0.02712645f, 0.06582812f, 0.04693355f, -0.09673376f, -0.27369669f, 
    0.35661566f, -0.13046154f, -0.03615899f, -0.07573465f, 0.13377661f, 0.20443845f, -0.11799861f, -0.16756389f, 
    0.05845857f, 0.05151845f, 0.08371017f, 0.00086792f, -0.51492238f, 0.04997388f, 0.01327869f, 0.09081670f, 
    0.11325470f, 0.02770734f, 0.10702203f, -0.02033135f, -0.22459543f, -0.05181238f, 0.00755967f, -0.32339910f, 
    -0.01157696f, 0.22747755f, 0.15345871f, 0.16043593f, -0.03850748f, -0.00647884f, -0.02460231f, 0.06595081f, 
    0.04063161f, -0.00202296f, -0.12572268f, -0.09464063f, 0.06254356f, 0.10901640f, -0.00768779f, 0.17488822f, 
    0.07301468f, 0.09428237f, -0.07142473f, 0.10422676f, 0.03486260f, 0.10880984f, 0.10655428f, 0.01825366f, 
    0.09026906f, -0.65226144f, -0.40870440f, -0.50480092f, 0.04593845f, -0.10326612f, 0.13075989f, -0.34267461f, 
    -0.16006519f, -0.10535875f, 0.12553693f, -0.01227342f, -0.25546297f, -0.25955534f, -0.01828028f, 0.08501457f, 
    0.15800428f, 0.05411436f, -0.10659013f, 0.07184170f, 0.06207136f, -0.18306480f, -0.31455272f, -0.14536229f, 
    0.00830020f, 0.09488095f, 0.06947409f, 0.03952717f, 0.02895877f, 0.02537133f, 0.14210823f, 0.01726194f, 
    -0.09912533f, 0.07808868f, -0.22504288f, 0.00649793f, 0.50111198f, 0.32703689f, -0.16308936f, 0.34639236f, 
    -0.03045110f, -0.06355460f, 0.07486819f, 0.21501936f, 0.11577131f, 0.08409517f, 0.24334700f, 0.04768727f, 
    0.31564984f, -0.16657747f, -0.40638009f, -0.06765957f, -0.10006447f, -0.02091321f, -0.13051800f, -0.03558651f, 
    0.29889500f, 0.47599646f, 0.34764090f, 0.12615128f, 0.04791476f, -0.28457099f, -0.12754147f, 0.35785267f, 
    -0.00136739f, 0.01638306f, -0.15447345f, -0.12015465f, -0.09267893f, -0.23325516f, -0.28340369f, -0.03042176f, 
    -0.16693607f, 0.18265037f, 0.05254468f, -0.10503931f, -0.01935221f, -0.06932122f, 0.07696866f, -0.23246679f, 
    0.25077623f, 0.16396286f, 0.18646777f, 0.08581290f, -0.01374823f, 0.10895047f, 0.35065848f, 0.02378977f, 
    0.20404594f, 0.12537932f, 0.09323255f, 0.16910428f, -0.02898536f, -0.11577215f, 0.02117142f, -0.08950965f, 
    0.16310629f, -0.22084087f, 0.11536869f, 0.08204000f, 0.17434059f, 0.01122770f, -0.07161754f, 0.17615189f, 
    0.01849163f, -0.22276536f, -0.18044548f, -0.15096802f, 0.12734021f, 0.01217528f, 0.42856410f, 0.18569304f, 
    0.15534674f, -0.07718453f, 0.07820815f, -0.05070111f, 0.05628943f, -0.04773327f, 0.05036689f, -0.18053436f, 
    -0.01504392f, -0.05774180f, 0.25038582f, -0.19525462f, 0.06544185f, 0.14573742f, -0.21632291f, 0.04432372f, 
    0.12169513f, 0.12428697f, 0.16491091f, 0.09036566f, -0.37274235f, 0.13415352f, 0.11456387f, 0.05966842f, 
    0.04865350f, -0.08063219f, 0.36437806f, 0.22000185f, -0.02193362f, -0.05565805f, 0.11539777f, 0.32507411f, 
    -0.39316878f, 0.60620201f, 0.50009084f, -0.22573845f, 0.11602290f, -0.00430104f, 0.08510574f, 0.18940108f, 
    0.07260616f, 0.16981424f, 0.11051968f, -0.11170824f, -0.02053401f, -0.09910886f, 0.30094954f, 0.27644277f, 
    -0.06135401f, -0.39293200f, 0.01322756f, 0.08832745f, 0.18902953f, -0.10472406f, 0.14414135f, 0.17265543f, 
    0.17526972f, -0.30475172f, 0.26804307f, 0.23479334f, 0.09048695f, -0.18484543f, -0.33708486f, 0.07387614f, 
    0.19132353f, -0.02004120f, 0.11597282f, -0.08556581f, -0.01794008f, -0.07720350f, -0.08950351f, 0.01754039f, 
    0.12856989f, 0.09625918f, -0.08832134f, -0.03905081f, 0.26553535f, 0.03283156f, 0.19428815f, 0.12594855f, 
    0.06105924f, 0.28909159f, -0.23317403f, -0.14120141f, 0.01701645f, 0.12435314f, -0.09685502f, 0.06253587f, 
    -0.09496310f, -0.03657608f, -0.09769259f, 0.05302385f, -0.59658974f, 0.35191041f, 0.20284608f, -0.07816452f, 
    0.01596069f, 0.28351697f, -0.02878308f, 0.06048973f, 0.00425451f, -0.00280052f, 0.07166351f, 0.25690949f, 
    -0.16822350f, -0.02508215f, -0.05811181f, -0.08752289f, 0.20896347f, -0.08047646f, -0.18089145f, -0.08664061f, 
    -0.05401254f, -0.03575823f, 0.03341123f, -0.08410818f, 0.18852484f, -0.42239863f, 0.65562457f, -0.24589674f, 
    -0.07438745f, 0.08609685f, 0.05256179f, 0.07391287f, 0.05868212f, -0.04932455f, 0.08790777f, 0.11664709f, 
    -0.04381747f, 0.01617167f, 0.17117175f, 0.20795423f, -0.16714133f, 0.04245101f, 0.03078281f, -0.02842802f, 
    -0.05119080f, 0.20770095f, 0.11261117f, 0.26450497f, 0.63561422f, 0.30653387f, 0.50263894f, 0.03482546f, 
    -0.14736459f, -0.07125474f, -0.09916631f, 0.03496241f, 0.00526917f, -0.06375340f, -0.00464323f, -0.14018719f, 
    0.25392109f, -0.26022750f, 0.13755056f, 0.11599350f, -0.16006410f, 0.07732495f, 0.05116510f, 0.18210582f, 
    0.05603036f, 0.13129404f, 0.13236761f, 0.01184824f, -0.34481961f, -0.26991883f, -0.00191838f, 0.08893156f, 
    -0.13830376f, -0.00443306f, -0.06542053f, -0.07671721f, -0.19263829f, -0.19520579f, -0.09794476f, -0.15548907f, 
    -0.06480075f, 0.05952932f, 0.13280694f, -0.11238074f, 0.02995169f, 0.07088137f, 0.09541059f, 0.10052812f, 
    -0.23221700f, -0.27195990f, -0.09225723f, -0.36975747f, -0.01031914f, -0.27819923f, 0.00896471f, -0.25745016f, 
    0.11699331f, -0.03169009f, -0.01710160f, -0.23298779f, 0.07827336f, 0.31746188f, -0.21997148f, -0.14622094f, 
    -0.16195287f, 0.28919211f, -0.22920284f, 0.21961692f, -0.02024653f, 0.00179904f, 0.03714538f, 0.30304715f, 
    -0.08190002f, -0.13254824f, 0.23823382f, 0.07294329f, 0.07578950f, 0.06955715f, 0.33657339f, 0.00723267f, 
    -0.10879843f, 0.06595462f, 0.20250195f, 0.05548167f, -0.04968090f, 0.07981238f, 0.18153031f, 0.16495872f, 
    -0.11699241f, -0.27285174f, -0.24110354f, -0.08182608f, -0.27285957f, 0.09234076f, 0.09332710f, 0.09121498f, 
    0.07137268f, -0.06678007f, -0.03396646f, -0.02801647f, 0.05885319f, 0.10198703f, 0.01165343f, 0.11310215f, 
    0.05254827f, 0.05851134f, -0.08376054f, -0.04489100f, -0.08162271f, 0.04180631f, 0.14332932f, 0.10156146f, 
    -0.00261869f, 0.05803157f, 0.01286654f, 0.09212971f, -0.00331200f, 0.02372343f, 0.11183151f, 0.04518341f, 
    -0.04630662f, -0.15890057f, -0.13706689f, -0.16331470f, 0.05046037f, 0.02947810f, 0.21966864f, 0.08720446f, 
    -0.07320549f, -0.09978676f, 0.08923750f, -0.00533059f, 0.14252143f, -0.00050543f, 0.03917904f, 0.05960324f, 
    -0.24600367f, -0.06309842f, 0.11465650f, -0.21242328f, 0.00477280f, -0.14285478f, 0.22277488f, -0.09462780f, 
    -0.05915078f, -0.06542440f, -0.15980095f, -0.16144297f, -0.10864259f, -0.05929633f, -0.16917823f, 0.21863797f, 
    0.26942486f, 0.21820816f, 0.26516873f, 0.20972241f, 0.05727888f, -0.12175338f, 0.33035347f, 0.05580952f, 
    -0.32632452f, -0.05975612f, 0.04812580f, -0.04349504f, 0.06152995f, -0.05706115f, 0.16046095f, -0.26103196f, 
    -0.05337745f, -0.26648337f, -0.01613798f, -0.03804059f, -0.21245161f, 0.10385193f, -0.08186802f, -0.16554336f, 
    -0.05930017f, 0.20683546f, 0.16083479f, -0.07083592f, -0.00147383f, 0.11482469f, -0.10179884f, 0.05044304f, 
    0.25797704f, 0.25257334f, -0.06043922f, -0.01055450f, 0.03248005f, -0.04364335f, 0.12797207f, -0.08283593f, 
    0.22514392f, 0.15954670f, 0.24022093f, 0.20292099f, 0.36669251f, 0.03966333f, -0.06941660f, -0.19591291f, 
    -0.03754903f, 0.05496379f, 0.20593129f, 0.04529860f, -0.06013548f, 0.02521541f, 0.08907454f, -0.09831824f, 
    0.58489096f, -0.11256751f, 0.20641804f, -0.07460140f, -0.06052244f, -0.10912617f, 0.06836485f, 0.11572203f, 
    0.11648115f, 0.02109745f, -0.16610484f, 0.14991109f, -0.00548039f, 0.19429353f, 0.29890150f, 0.07220444f, 
    -0.20005421f, -0.06390644f, 0.10270336f, -0.06676280f, -0.23495427f, -0.03134479f, 0.09158820f, 0.08991463f, 
    -0.10400959f, 0.32254064f, 0.20822468f, 0.19469705f, -0.22788632f, 0.04638823f, 0.21085988f, 0.05956799f, 
    -0.26252919f, -0.08740684f, -0.02067393f, -0.14783852f, -0.15894835f, -0.17532395f, 0.10156055f, 0.02790005f, 
    -0.16990450f, 0.03340965f, -0.24982794f, -0.28882942f, 0.08936028f, 0.27793828f, -0.07163733f, -0.03770543f, 
    0.36941209f, 0.63830948f, -0.28139141f, 0.24895862f, 0.19772044f, -0.00990532f, 0.04574207f, 0.15444525f, 
    -0.00584345f, 0.04450095f, 0.12340043f, 0.03386423f, -0.20313476f, -0.25934383f, 0.13107434f, -0.04441605f, 
    -0.08187567f, 0.08443174f, -0.19034559f, -0.02416640f, 0.05380064f, -0.02199539f, -0.11426947f, -0.08102235f, 
    0.35847980f, 0.29471433f, 0.13273378f, -0.09721142f, -0.07608625f, -0.22981721f, -0.03203498f, -0.03361859f, 
    0.10053229f, 0.03354438f, -0.14213178f, 0.05308947f, -0.19004108f, 0.29891121f, -0.00338857f, 0.09344281f, 
    -0.14295883f, 0.01838991f, 0.06401053f, 0.17542005f, 0.05912069f, 0.03119627f, 0.05317859f, 0.03637237f, 
    0.00887634f, 0.05237773f, -0.00444104f, 0.20015918f, -0.20617926f, 0.01397962f, 0.12256600f, 0.20044512f, 
    -0.11328598f, -0.04759904f, -0.04575326f, -0.22254294f, 0.27367988f, -0.01773415f, 0.14580317f, 0.11044155f, 
    -0.08499894f, 0.01132958f, 0.05530324f, -0.03605969f, -0.04639897f, 0.01243476f, -0.15170617f, -0.00339392f, 
    -0.17790879f, 0.00282869f, 0.31798437f, -0.15140432f, 0.08537242f, 0.01113173f, -0.15463366f, -0.04446444f, 
    -0.08615547f, 0.08581331f, -0.05080198f, -0.13064735f, 0.08603951f, -0.54838240f, 0.50956959f, 0.31544358f, 
    -0.03533687f, 0.08982747f, 0.02909048f, 0.05680976f, 0.17158537f, 0.10108288f, 0.19445485f, -0.11776552f, 
    0.03796835f, 0.08178912f, 0.17392185f, 0.12253279f, -0.24045612f, -0.19957779f, 0.15072063f, -0.17884192f, 
    0.12779610f, -0.13571988f, 0.11243110f, 0.15650532f, -0.21099466f, 0.28833640f, -0.11896099f, 0.23848839f, 
    -0.04594436f, 0.03064510f, 0.20684037f, 0.20271617f, -0.14343244f, 0.14641310f, 0.10936980f, 0.04871515f, 
    0.02494086f, 0.09283365f, -0.21320239f, -0.16076162f, -0.14552206f, -0.10097311f, 0.08909322f, -0.08951075f, 
    -0.00553002f, 0.09179651f, 0.30267677f, 0.23064846f, 0.01077704f, -0.24796039f, -0.53591210f, 0.24264775f, 
    -0.13944985f, 0.07401384f, 0.21134673f, -0.13887413f, 0.03755348f, 0.14172456f, -0.07465229f, -0.09478279f, 
    -0.09716541f, -0.07461522f, -0.04720150f, -0.29135156f, -0.03964275f, -0.05712277f, 0.10247483f, -0.07008289f, 
    0.12992878f, -0.05639076f, -0.03399051f, 0.26682496f, 0.55873704f, 0.17325895f, -0.07139155f, 0.06230158f, 
    -0.07562886f, 0.00470359f, -0.03153458f, 0.00521588f, -0.18654639f, 0.02690447f, 0.21253894f, 0.06557880f, 
    0.13467668f, 0.19583280f, -0.01249435f, -0.00865947f, -0.04989175f, -0.04521641f, -0.02445289f, -0.01626646f, 
    -0.02675805f, -0.01692492f, -0.01935690f, 0.05460855f, 0.03588960f, 0.35339689f, 0.50875270f, 0.20254442f, 
    0.06498938f, 0.06146547f, -0.06970181f, 0.18064636f, 0.22145046f, 0.23820092f, -0.06413766f, -0.08497887f, 
    0.12315983f, 0.03396225f, -0.28542474f, 0.21830453f, -0.07189756f, -0.02941968f, -0.08154756f, 0.19418660f, 
    -0.07169711f, 0.05968070f, -0.19676107f, -0.00115495f, -0.02708327f, -0.29472998f, -0.43936250f, 0.06672622f, 
    -0.00751883f, 0.17947359f, -0.14565545f, 0.12506108f, 0.07739527f, 0.04478830f, 0.09368276f, 0.01032788f, 
    0.29254431f, 0.08128514f, 0.28367308f, -0.00978971f, 0.02560450f, -0.26357937f, -0.14446521f, 0.25063810f, 
    0.13302599f, 0.03347082f, -0.11880207f, -0.04146445f, 0.25442374f, 0.38239658f, -0.01692202f, 0.05361663f, 
    -0.05084836f, -0.13581064f, 0.03678709f, 0.03622371f, -0.01049753f, -0.02800574f, -0.07168514f, 0.22200124f, 
    -0.05348469f, 0.12924401f, 0.23341879f, -0.11237808f, 0.07698026f, -0.04812403f, -0.27540848f, -0.07947806f, 
    -0.34060672f, -0.14991078f, 0.17137481f, -0.16403483f, 0.29555488f, 0.14507034f, -0.13125639f, -0.06841125f, 
    0.04018090f, 0.23266347f, 0.08793792f, 0.01804358f, 0.01998266f, -0.02766771f, 0.03760840f, 0.05492214f, 
    0.22169800f, 0.26673335f, -0.11215985f, 0.08930389f, 0.04839679f, -0.07207422f, -0.11724637f, 0.22455014f, 
    0.06671975f, 0.00701743f, -0.06665014f, 0.02678533f, 0.16193566f, -0.35154510f, 0.27387393f, 0.38573077f, 
    0.00221310f, 0.14479986f, -0.25771338f, -0.00678765f, -0.02469444f, 0.02822139f, 0.04783082f, 0.05377641f, 
    0.41413870f, 0.03242868f, 0.03332656f, -0.11184482f, 0.17341357f, -0.01410271f, -0.03764886f, 0.06099425f, 
    0.05876751f, 0.17740244f, 0.12558314f, 0.09703144f, 0.59224749f, -0.01769205f, 0.31719869f, 0.11522912f, 
    0.14685175f, -0.09258165f, 0.15386203f, 0.21600869f, 0.05211516f, 0.02112295f, 0.04246780f, 0.18350115f, 
    -0.16939716f, 0.00780325f, -0.14987513f, 0.14911745f, 0.10721463f, -0.00037030f, -0.01079935f, 0.06403384f, 
    -0.26489481f, 0.01727001f, -0.22366066f, -0.26822919f, 0.12706573f, 0.26607338f, 0.27464458f, 0.16492742f, 
    -0.01062871f, -0.06290477f, -0.02444464f, 0.00348131f, -0.01564524f, 0.03823293f, -0.05210146f, 0.07091428f, 
    -0.30728942f, 0.32435030f, 0.12241263f, 0.03374325f, -0.03276474f, 0.00260113f, 0.01267096f, -0.00940155f, 
    -0.19162516f, 0.03932718f, 0.09914693f, -0.04451897f, -0.31793585f, -0.26041272f, -0.44628680f, 0.03027037f, 
    0.10184941f, 0.08638466f, 0.04781634f, -0.01326420f, 0.21180864f, 0.01153651f, -0.03043429f, 0.01779045f, 
    0.06734780f, -0.19326968f, -0.04418844f, 0.16283330f, 0.15264513f, -0.02248150f, -0.22750145f, 0.03724304f, 
    0.16717075f, 0.00151423f, 0.05114696f, 0.15391687f, 0.24732019f, 0.10730016f, 0.11605731f, -0.07597017f, 
    0.08207074f, -0.00953176f, 0.01634106f, -0.01634824f, 0.06290522f, 0.05423187f, -0.04460123f, -0.14870046f, 
    -0.39333192f, -0.50042444f, -0.14653388f, 0.48799101f, 0.05136562f, 0.05700474f, -0.01105530f, -0.07721312f, 
    0.25377154f, -0.04172341f, 0.09669977f, 0.09593541f, 0.25780615f, 0.22441477f, -0.36529717f, -0.11258291f, 
    0.02130998f, -0.03737917f, 0.11985795f, -0.05042613f, -0.16094798f, -0.05681444f, 0.04901411f, 0.02011432f, 
    -0.47995943f, -0.28584301f, -0.38013181f, 0.24095400f, 0.11577801f, 0.24281341f, 0.04412351f, 0.25589705f, 
    -0.08205150f, 0.13627218f, 0.03640031f, -0.07664503f, -0.18119851f, -0.05267847f, -0.19292112f, -0.31771794f, 
    0.11685694f, 0.13001721f, 0.02718494f, 0.07763568f, 0.03916013f, -0.05371134f, -0.13987795f, 0.02673757f, 
    -0.06740450f, 0.20973589f, -0.00505869f, -0.26162598f, 0.03393441f, 0.05490639f, 0.03853402f, -0.11219515f, 
    0.15866281f, 0.12371839f, 0.30333996f, 0.29337037f, -0.20970345f, -0.15548477f, 0.02755213f, 0.02492758f, 
    -0.05128146f, 0.03390111f, -0.08791095f, -0.01223580f, 0.00965395f, -0.00739948f, 0.02700866f, -0.05634347f, 
    -0.01123048f, 0.35179505f, -0.17509368f, 0.27358782f, 0.01639749f, 0.16727388f, -0.12213227f, 0.22523016f, 
    0.10725192f, 0.16453914f, -0.07290252f, 0.11575744f, -0.08869035f, 0.54989356f, -0.40900379f, -0.26237813f, 
    -0.16856088f, -0.00786160f, 0.12912904f, -0.00022812f, -0.08102041f, 0.02537749f, 0.01617933f, 0.16172527f, 
    0.03573909f, -0.03435387f, -0.13978066f, 0.20584361f, 0.17621969f, -0.07320487f, -0.07958034f, -0.00693114f, 
    -0.08288721f, 0.04243534f, -0.37020686f, -0.05103416f, -0.07931079f, -0.00593916f, -0.02034746f, 0.11766246f, 
    0.07698978f, 0.01962701f, -0.19593829f, -0.05762098f, 0.13450640f, -0.01269522f, 0.02089992f, -0.00022376f, 
    -0.39768153f, -0.09865060f, 0.39779887f, -0.14150997f, -0.13498601f, 0.04952065f, -0.06517807f, 0.00166335f, 
    0.25381336f, 0.28842768f, -0.00477290f, 0.14186317f, -0.07141163f, -0.02424566f, 0.78785127f, -0.04335502f, 
    0.01804282f, -0.13268192f, -0.01334301f, -0.01678314f, -0.06206229f, -0.06802950f, 0.04605242f, -0.05932973f, 
    -0.10840851f, 0.22944799f, 0.05111362f, -0.03468867f, 0.11840585f, 0.10473302f, -0.19397227f, 0.15307394f, 
    0.12206838f, 0.06351984f, -0.11057952f, -0.12612528f, 0.12243374f, -0.02844104f, 0.23779167f, 0.13567221f, 
    0.06946872f, 0.03258473f, 0.08403461f, 0.20948882f, -0.02972792f, -0.05047568f, -0.09483454f, -0.03235160f, 
    -0.24472135f, -0.19639781f, -0.11859184f, -0.09890338f, 0.09141874f, -0.10107251f, -0.30470040f, -0.13321771f, 
    -0.01069346f, -0.06886013f, 0.14735077f, -0.28771651f, -0.02131793f, -0.24259013f, -0.29186296f, 0.19836979f, 
    0.02617931f, -0.08091775f, 0.14516352f, 0.04966582f, 0.03699613f, -0.02704905f, -0.07748124f, 0.03350645f, 
    -0.53168142f, 0.00690266f, 0.54731876f, -0.28478861f, 0.06061582f, 0.09008900f, 0.08747522f, -0.04937773f, 
    -0.19035125f, 0.13106425f, 0.13514748f, 0.16333266f, 0.07756187f, -0.10306941f, 0.14009115f, 0.28030342f, 
    0.08635519f, 0.00913006f, 0.04869295f, -0.05435431f, 0.03116693f, 0.13716874f, 0.20298345f, 0.18660596f, 
    -0.31584367f, 0.36818242f, 0.40490022f, 0.30482289f, 0.00676435f, 0.03252671f, 0.08313394f, 0.05913243f, 
    -0.09916740f, -0.07734998f, -0.03292569f, 0.02826120f, 0.27724123f, -0.19304739f, 0.03430035f, 0.24189617f, 
    0.09046245f, 0.01488222f, -0.02094570f, -0.24619041f, 0.05871701f, -0.00993881f, 0.13358688f, 0.17052290f, 
    0.40376261f, -0.03270517f, -0.25631714f, -0.10053043f, 0.10026062f, -0.21343012f, 0.02525959f, -0.14510433f, 
    -0.09915152f, -0.02750363f, -0.08093195f, -0.07400639f, -0.38834062f, 0.23793048f, 0.03597557f, -0.00861775f, 
    -0.03093883f, -0.11724155f, -0.02461922f, 0.18831104f, 0.11805465f, -0.20808467f, -0.11778584f, 0.00974225f, 
    -0.06369957f, -0.23716784f, 0.06319833f, 0.11993694f, 0.04762918f, -0.05311120f, 0.15645267f, -0.03062903f, 
    -0.02617543f, -0.05130988f, -0.04936126f, -0.08609182f, -0.15380917f, 0.53998840f, -0.10056235f, -0.12302024f, 
    0.12807269f, 0.18559097f, -0.04382208f, 0.01203019f, -0.07971004f, 0.03254253f, 0.12757723f, -0.03286204f, 
    0.08861788f, -0.23036763f, -0.02243447f, 0.04776371f, 0.19171980f, -0.06954189f, 0.08204785f, 0.02576201f, 
    -0.00047643f, 0.06895818f, -0.00393953f, -0.03188646f, 0.29179826f, 0.16588470f, -0.16749398f, -0.22379115f, 
    -0.18215081f, 0.11291398f, 0.30941868f, 0.09871322f, 0.03117756f, 0.08090332f, 0.04607112f, 0.01529410f, 
    -0.13122731f, 0.09574721f, -0.19852103f, 0.00421758f, -0.02523523f, -0.01792899f, 0.09553957f, -0.01577415f, 
    0.22213425f, 0.26758572f, -0.14798284f, -0.01477144f, -0.00812449f, 0.11419272f, 0.26159301f, -0.01360121f, 
    0.00633540f, 0.09066998f, -0.08219053f, -0.28125611f, -0.04574630f, -0.03933694f, -0.02231351f, -0.06161470f, 
    0.13983256f, 0.10348717f, 0.34267262f, -0.10544198f, -0.03369993f, -0.03954859f, -0.23881799f, -0.08498993f, 
    0.00490642f, 0.10116111f, 0.12349486f, 0.00487833f, -0.26111841f, 0.27011845f, 0.02428528f, 0.10676898f, 
    0.06330010f, -0.11197818f, 0.03256896f, 0.07256339f, 0.01636628f, 0.17296384f, 0.10759723f, 0.20797263f, 
    -0.23499380f, 0.02023416f, 0.03780025f, 0.40232095f, -0.01823079f, -0.06078556f, -0.14829780f, -0.06441871f, 
    -0.03660352f, -0.04027416f, 0.24515653f, 0.04551710f, -0.32408094f, -0.33638269f, -0.16347827f, 0.03825969f, 
    0.05472335f, 0.08363042f, -0.07744151f, 0.03990546f, -0.05566117f, 0.04165396f, -0.12736595f, -0.14036906f, 
    -0.29208007f, 0.34941265f, -0.47607625f, 0.46603745f, -0.00937597f, 0.02751258f, 0.18413939f, 0.04297794f, 
    0.17432070f, 0.15045145f, 0.08938044f, 0.01228711f, 0.16458358f, -0.35235623f, -0.26130253f, 0.18566716f, 
    -0.03069000f, 0.15489388f, 0.09435850f, -0.03654317f, -0.06459691f, 0.01399657f, 0.06669700f, 0.02592435f, 
    0.05212595f, 0.07004900f, 0.14439824f, 0.34697548f, 0.03522257f, 0.06168653f, -0.02363652f, 0.11494710f, 
    0.11922014f, 0.07018472f, 0.13412695f, 0.06558198f, -0.26852423f, 0.21797188f, -0.20360292f, -0.35088390f, 
    -0.09052511f, -0.06826429f, -0.05627130f, 0.08795774f, -0.11628050f, 0.13266462f, 0.06079916f, 0.08274686f, 
    0.11888762f, 0.33227172f, -0.02562472f, -0.04593918f, -0.16154848f, -0.16153726f, -0.10138980f, 0.00816355f, 
    0.02739903f, 0.03412576f, 0.14662381f, -0.05933524f, 0.16013944f, -0.28994206f, 0.06530704f, -0.12495841f, 
    -0.09146976f, -0.11382870f, -0.03417182f, -0.33418632f, -0.04969662f, 0.05512068f, -0.08925772f, -0.26818839f, 
    -0.06910262f, -0.06123354f, 0.06375146f, 0.21317478f, 0.11557531f, -0.06839937f, 0.08760073f, 0.06602956f, 
    -0.03594827f, 0.15878816f, -0.03788355f, 0.14611797f, -0.24660961f, 0.42681119f, 0.01981637f, -0.26928577f, 
    0.08815710f, 0.04950350f, -0.02962808f, -0.03877741f, -0.15570274f, 0.14955577f, 0.02690637f, 0.10175554f, 
    0.16160429f, 0.14264399f, -0.17523474f, 0.20852454f, 0.16055652f, 0.11764824f, 0.01149957f, 0.06998605f, 
    -0.09591234f, -0.00764985f, -0.18954112f, 0.14602609f, -0.00906902f, -0.08458994f, 0.13168800f, 0.06773195f, 
    -0.14033532f, 0.03200829f, -0.23752868f, -0.08056962f, -0.08702011f, -0.02811055f, -0.05834791f, 0.08987129f, 
    -0.25436091f, -0.10706928f, 0.02420826f, -0.06663772f, -0.04359495f, -0.09612971f, -0.27023822f, -0.06798010f, 
    0.01419877f, 0.27474651f, 0.07119433f, 0.27613533f, -0.48624119f, -0.42764863f, 0.12575240f, 0.06502848f, 
    -0.09223964f, -0.08071727f, -0.01448435f, -0.12885675f, -0.11373325f, -0.12131260f, -0.07122523f, -0.09166074f, 
    0.05549591f, -0.40518034f, -0.22306353f, 0.06001296f, 0.04713193f, -0.10518843f, -0.00683217f, 0.06551741f, 
    0.19165967f, 0.06878909f, 0.05905101f, -0.03502703f, 0.34072495f, 0.16790138f, -0.06759635f, 0.12599798f, 
    0.12966214f, 0.00929927f, 0.05816609f, 0.13233688f, 0.13514730f, -0.06358632f, -0.02838809f, 0.06313314f, 
    -0.20003636f, 0.01836825f, -0.15870659f, -0.02720943f, 0.08777178f, 0.03280293f, -0.15701918f, -0.20683569f, 
    0.02653779f, -0.11546484f, -0.12818122f, -0.28612712f, 0.21375123f, 0.30864167f, -0.15317972f, 0.13924454f, 
    0.15970574f, 0.11775703f, 0.18701877f, 0.30634302f, 0.17926884f, 0.11376780f, 0.08367334f, 0.21401928f, 
    -0.36519381f, -0.28181458f, 0.02501147f, -0.22542293f, -0.00870083f, 0.09331056f, 0.05779500f, -0.21585931f, 
    -0.06047491f, 0.03591002f, 0.14571613f, 0.22853291f, 0.20482627f, 0.10728026f, 0.03362681f, 0.28024012f, 
    0.20320112f, 0.31581190f, 0.01020380f, 0.11276183f, -0.02519168f, 0.20475726f, 0.18874772f, 0.23922504f, 
    -0.02385483f, -0.03172705f, -0.08461742f, 0.32234049f, 0.09251747f, -0.02455266f, 0.04911408f, -0.10576818f, 
    0.03672369f, -0.00454320f, 0.01811020f, 0.12122051f, 0.28011551f, -0.16532685f, 0.10569441f, 0.28719124f, 
    0.18190628f, 0.18750723f, -0.03877781f, -0.05838973f, 0.15130760f, 0.10878079f, 0.22417797f, 0.17919055f, 
    -0.04386199f, -0.14163834f, -0.08828479f, 0.04036020f, -0.10451208f, -0.09897672f, -0.07575058f, -0.14429606f, 
    -0.23187052f, -0.05975583f, -0.04311164f, -0.08731021f, -0.01472368f, 0.14204252f, -0.50375968f, -0.10109456f, 
    -0.12032229f, -0.06441168f, 0.01403535f, 0.05186449f, -0.10889535f, -0.15968104f, -0.05725706f, -0.11972157f, 
    0.25390106f, -0.01598845f, -0.18958442f, 0.20296778f, 0.15250646f, -0.28311506f, 0.13919219f, 0.13856259f, 
    0.01961016f, -0.10395668f, -0.01737744f, -0.01822398f, 0.15039264f, 0.18463677f, -0.17161654f, -0.13522446f, 
    0.15947539f, -0.04641751f, 0.09049359f, 0.17263208f, -0.04342757f, 0.09195149f, 0.12508303f, 0.06396860f, 
    -0.13328531f, 0.14124194f, 0.14420216f, 0.19324756f, -0.18717434f, -0.22086047f, 0.10964134f, -0.11120237f, 
    0.06865133f, 0.09780371f, 0.01580837f, 0.04832015f, 0.13267499f, 0.18101519f, -0.26929533f, 0.33162144f, 
    -0.02241816f, -0.00626765f, 0.18400271f, 0.20703366f, -0.13424674f, 0.23991276f, 0.12201636f, -0.00530471f, 
    0.39230838f, -0.04655127f, -0.18844323f, -0.02168053f, 0.05010670f, -0.08037332f, 0.17489752f, -0.03793885f, 
    0.22370806f, 0.25688559f, 0.35519326f, 0.25177911f, 0.22380607f, -0.16234806f, -0.21471222f, 0.23080811f, 
    0.08735669f, 0.15111777f, 0.10654286f, -0.00367110f, -0.04065663f, -0.11009831f, -0.11041680f, -0.06872947f, 
    0.13012689f, -0.10644364f, -0.01151605f, -0.10465455f, -0.02003960f, -0.06990770f, 0.06813487f, -0.14076361f, 
    0.14164093f, -0.06185899f, -0.00305608f, 0.09951122f, -0.08652054f, 0.05741755f, 0.21419606f, 0.05988111f, 
    -0.10718893f, -0.11063612f, -0.03216758f, 0.10405058f, -0.09491146f, -0.05705407f, 0.06300435f, -0.05317500f, 
    0.00757335f, -0.04190895f, 0.13313691f, 0.07565664f, -0.06568785f, -0.00447781f, 0.06954426f, 0.16086297f, 
    -0.09262739f, -0.15864724f, -0.15583408f, -0.16719969f, -0.06629999f, -0.00913474f, 0.45712721f, 0.26896310f, 
    -0.10401004f, 0.01234302f, -0.06341498f, -0.08037040f, 0.07013077f, 0.27928066f, 0.13425997f, 0.03150520f, 
    0.14435507f, 0.07993297f, -0.12498366f, 0.14861225f, 0.15559289f, -0.00287130f, -0.05824719f, 0.16561514f, 
    0.03512404f, -0.09942733f, -0.05441223f, 0.04320900f, -0.45965967f, -0.21296464f, 0.11057778f, 0.08354424f, 
    -0.04782972f, -0.04719850f, 0.07771433f, 0.10717648f, 0.11842669f, 0.05878997f, 0.18837439f, 0.15984267f, 
    0.06397689f, 0.24717529f, 0.31527212f, -0.28822771f, -0.00935277f, -0.09857921f, -0.08982366f, -0.00645515f, 
    0.10849839f, 0.13320017f, -0.14327770f, -0.03492424f, -0.25409311f, 0.08410873f, 0.07694828f, 0.27877790f, 
    -0.12433819f, -0.20800260f, 0.02970671f, -0.02013069f, 0.05602121f, -0.08921527f, 0.10726531f, 0.17229331f, 
    0.06611803f, -0.23824137f, 0.16287486f, 0.26863053f, 0.01338226f, -0.09959576f, -0.18110757f, 0.12071469f, 
    -0.02616519f, -0.10212308f, -0.08052050f, -0.29627958f, 0.20517381f, 0.02482619f, -0.02874649f, 0.10681117f, 
    0.05417782f, 0.14316224f, -0.01663247f, -0.17496589f, -0.00856460f, -0.00975705f, 0.02322651f, 0.06088044f, 
    -0.05693364f, 0.23589671f, -0.09861764f, -0.15380502f, -0.05754318f, 0.00050872f, -0.03370307f, 0.17937468f, 
    -0.11197150f, 0.08595368f, -0.01320506f, 0.00717926f, -0.50684232f, -0.41989833f, 0.17026070f, 0.16565374f, 
    0.00313361f, 0.27163506f, -0.12346090f, 0.05890604f, -0.03118761f, 0.04217902f, 0.08187649f, 0.15541576f, 
    0.37627202f, 0.19146824f, 0.55374330f, 0.32642576f, -0.02561398f, 0.37854427f, 0.03903326f, 0.22604562f, 
    0.03162062f, -0.10695825f, 0.14344756f, 0.19422436f, -0.02561301f, -0.29920337f, 0.33215329f, 0.49486873f, 
    0.00667298f, 0.33692929f, 0.09941373f, 0.03738980f, -0.13265185f, 0.04623333f, -0.14685772f, 0.16308011f, 
    -0.09976809f, 0.07981895f, -0.13461073f, 0.06479469f, 0.00832167f, -0.03417882f, -0.00400296f, -0.14121695f, 
    0.03482878f, -0.25883913f, -0.06263168f, -0.07704215f, -0.11504693f, 0.04024722f, 0.09626593f, 0.15463729f, 
    -0.15004386f, -0.03488878f, -0.15148681f, -0.01762389f, 0.10265313f, 0.00256204f, -0.10045777f, -0.04643949f, 
    0.49444896f, -0.04262831f, -0.01375016f, -0.03326317f, -0.22116542f, -0.19545005f, -0.14546424f, -0.04556717f, 
    0.17362067f, -0.47398332f, -0.04675887f, 0.01612531f, 0.05340815f, 0.17203349f, -0.05862155f, 0.13797611f, 
    0.11215878f, 0.21429855f, 0.14926592f, 0.02670521f, 0.06812622f, -0.05335524f, -0.09001851f, 0.15772673f, 
    -0.10070784f, 0.28864607f, -0.07307085f, 0.19653021f, 0.09902725f, 0.40394151f, 0.25975183f, 0.01395307f, 
    0.17667940f, 0.18299469f, 0.17446996f, 0.20097716f, 0.32830000f, 0.34662515f, 0.49991041f, 0.42440680f, 
    0.42571616f, 0.09574985f, 0.03326585f, 0.01919404f, 0.07662232f, -0.03550701f, 0.12002011f, 0.00869261f, 
    -0.21056493f, 0.35513902f, -0.29157287f, 0.20796227f, -0.16718633f, 0.23620334f, -0.16994637f, 0.07838149f, 
    0.20065066f, 0.02953917f, -0.18962494f, -0.12249125f, -0.18316241f, 0.37040579f, 0.28786051f, 0.13088700f, 
    0.09633010f, -0.19834186f, -0.07992108f, 0.15522620f, 0.02873510f, -0.12338098f, -0.16177359f, -0.04931670f, 
    0.07671226f, -0.23573303f, -0.18251741f, -0.13412273f, 0.05941445f, 0.04508362f, -0.00843037f, 0.15542795f, 
    0.15536560f, 0.19698672f, 0.06390243f, -0.10639340f, -0.19574164f, 0.19161691f, 0.01439076f, 0.01245437f, 
    0.14130872f, -0.25479624f, 0.14732172f, 0.15204084f, 0.02689787f, 0.09295181f, -0.06276766f, -0.11484019f, 
    -0.20833823f, -0.16343707f, -0.07861595f, -0.02943452f, -0.15260327f, 0.09672076f, -0.02689265f, 0.01242932f, 
    0.10940940f, -0.05007116f, 0.12245924f, 0.33829707f, -0.35684732f, -0.31195498f, -0.26979589f, -0.11863619f, 
    -0.16805574f, -0.08888838f, 0.04790395f, -0.06572054f, 0.03408670f, 0.38769639f, 0.04324124f, 0.01634218f, 
    0.14193359f, 0.53871828f, 0.08259317f, 0.24871027f, 0.16571854f, 0.12223709f, 0.10506165f, 0.08628373f, 
    -0.07742050f, -0.08100168f, 0.17221572f, -0.14598571f, -0.32874757f, 0.13174653f, 0.09014784f, 0.05794069f, 
    -0.08956691f, 0.15558498f, 0.13601872f, -0.02113941f, 0.02437056f, 0.09760389f, -0.27210984f, 0.17611633f, 
    -0.00831643f, -0.01869221f, 0.05552268f, -0.07807162f, -0.04813376f, -0.06728328f, 0.03647537f, -0.05012274f, 
    -0.07630923f, -0.01504623f, 0.03280922f, -0.02619327f, 0.04867030f, -0.07903819f, 0.05615738f, -0.01698747f, 
    -0.00403796f, -0.04161479f, 0.02774899f, 0.00109187f, -0.01776551f, -0.01944505f, -0.00278250f, -0.00419279f, 
    -0.07298842f, 0.03897848f, 0.01907161f, -0.02204438f, -0.00765435f, 0.02591598f, 0.00893343f, -0.05762234f, 
    -0.03887167f, 0.05815350f, -0.03808451f, -0.02046259f, 0.01827295f, -0.01620393f, -0.06823666f, -0.05898424f, 
    -0.06279922f, -0.02619296f, 0.04318263f, 0.03261578f, -0.06435252f, 0.02143000f, -0.06413811f, 0.05085457f, 
    0.06389803f, 0.03660203f, 0.01752005f, 0.01032303f, -0.04222598f, -0.07582421f, 0.02424458f, -0.03072073f, 
    -0.06288282f, -0.05538123f, -0.03508896f, -0.07443871f, -0.05073177f, 0.05942620f, -0.04480345f, -0.00140146f, 
    -0.04739255f, -0.08113033f, 0.01981447f, 0.03991582f, -0.01838837f, -0.05163280f, 0.01089451f, 0.03046296f, 
    -0.01725128f, -0.01625274f, 0.01378983f, -0.02326273f, -0.01464396f, -0.03341511f, 0.03172924f, 0.04505521f, 
    -0.05976366f, -0.05326374f, 0.03759159f, 0.05105415f, -0.01074346f, 0.00366334f, -0.03623971f, -0.01187905f, 
    -0.06079408f, -0.01833006f, -0.01651013f, -0.00329563f, -0.02797724f, -0.04643095f, -0.08224192f, 0.05340390f, 
    0.02524270f, -0.07184114f, -0.07744619f, -0.00369839f, -0.00940064f, -0.07487237f, 0.02113174f, -0.01732809f, 
    -0.05294646f, 0.05374601f, 0.00686687f, 0.01096627f, 0.00227362f, -0.03989551f, -0.01471210f, 0.04554274f, 
    -0.07889470f, 0.00843449f, -0.03077937f, 0.01986464f, -0.01900943f, -0.01391373f, -0.05227105f, -0.03381809f, 
    0.01355326f, 0.04885315f, -0.00417087f, -0.02512110f, -0.00747189f, 0.02034732f, -0.03917317f, 0.04989488f, 
    0.05575664f, -0.05616569f, -0.03312771f, 0.02551298f, -0.04007353f, 0.01270494f, 0.00836739f, 0.02314455f, 
    -0.04158168f, 0.03081415f, -0.04475522f, -0.06499483f, -0.01360106f, 0.03239692f, -0.02970206f, -0.01467059f, 
    -0.01571595f, 0.03947670f, -0.05170552f, -0.00885207f, -0.06114110f, 0.00815357f, -0.02088770f, -0.04146441f, 
    0.00968458f, 0.02876426f, -0.06570408f, -0.01513407f, -0.02748781f, 0.00601719f, 0.05285306f, -0.01636921f, 
    -0.01350361f, 0.05693205f, 0.04999757f, -0.07805331f, 0.00857057f, -0.06361635f, -0.02787056f, -0.00560778f, 
    -0.06375109f, 0.03383781f, -0.04657187f, -0.01540449f, 0.04064173f, -0.03904979f, -0.03042098f, 0.05899925f, 
    0.03109534f, -0.03610961f, -0.07614211f, -0.06685414f, 0.03087697f, -0.00760893f, 0.00119754f, -0.00280101f, 
    -0.00500508f, 0.04780845f, 0.01652274f, -0.07531855f, 0.05119793f, -0.08273305f, -0.00542041f, 0.06053907f, 
    -0.00026567f, -0.00521654f, 0.05365141f, 0.02413823f, 0.03043642f, 0.01373581f, 0.05439628f, 0.06787647f, 
    -0.02425862f, -0.05331261f, -0.02824600f, 0.01285683f, -0.00658059f, 0.03377561f, 0.02313983f, -0.02542413f, 
    0.06380478f, -0.00687341f, -0.07302405f, 0.04000277f, -0.00374780f, -0.00219706f, 0.03509533f, -0.02392962f, 
    0.02601022f, -0.02247552f, 0.03236027f, 0.06828182f, -0.05407222f, 0.03861174f, 0.03555232f, 0.00583960f, 
    -0.00947492f, -0.00313509f, -0.03211986f, -0.07006497f, -0.06792220f, -0.03475839f, -0.01384550f, 0.06275749f, 
    -0.07528844f, -0.01834474f, -0.01208765f, 0.04829701f, -0.04321970f, -0.00867177f, -0.07946780f, -0.06813443f, 
    0.03344269f, 0.01638001f, -0.00853600f, 0.03559873f, 0.00498867f, -0.02931662f, -0.01855702f, 0.00599717f, 
    -0.07696202f, 0.00879955f, -0.03518024f, 0.01991479f, -0.03054877f, -0.01127295f, 0.05130066f, -0.06431860f, 
    0.04259088f, 0.00342456f, -0.02542994f, -0.05458368f, -0.01017522f, -0.05939738f, 0.06291492f, -0.06187898f, 
    0.04292136f, 0.04294308f, -0.05687518f, -0.06058924f, 0.05746212f, -0.05984510f, -0.05526811f, -0.04687941f, 
    -0.03438637f, -0.05255932f, -0.01713421f, -0.05726526f, -0.01398902f, 0.02427979f, 0.05067803f, 0.06310406f, 
    -0.04295943f, -0.01651368f, 0.00384376f, 0.00694234f, 0.04435397f, -0.07815707f, 0.02951757f, 0.02934782f, 
    -0.02686226f, -0.05250685f, -0.05430935f, -0.03845983f, -0.02145691f, -0.05646243f, 0.02042421f, -0.07790407f, 
    -0.06518254f, -0.05833646f, -0.04459685f, 0.02564052f, -0.06069846f, 0.04887025f, 0.03158479f, -0.05902617f, 
    -0.02803322f, 0.00819535f, 0.04709714f, -0.00237632f, -0.02475812f, -0.02893540f, 0.01257354f, -0.04520990f, 
    -0.01804738f, -0.06070493f, 0.05479059f, -0.01693636f, -0.01168740f, 0.05189249f, -0.03097185f, 0.00162434f, 
    -0.00484987f, -0.03103373f, -0.03566873f, -0.02737817f, 0.03356079f, -0.05659449f, 0.00469364f, -0.07210733f, 
    -0.00691622f, -0.03575461f, 0.06238459f, -0.07434164f, -0.07538857f, 0.01580124f, -0.03643512f, -0.05120271f, 
    0.02628090f, -0.03634281f, 0.03609006f, 0.01083386f, 0.02104660f, -0.03297371f, -0.01236558f, 0.02225327f, 
    0.05507872f, 0.05386526f, -0.00354957f, -0.00129179f, -0.05308871f, 0.01939693f, 0.04401781f, 0.05809660f, 
    -0.01682840f, 0.04113967f, -0.00597650f, 0.04412395f, -0.02371861f, -0.06017565f, -0.02013517f, -0.06698053f, 
    -0.01958901f, 0.02862390f, -0.02840960f, 0.06306789f, 0.03147310f, -0.07754834f, 0.02400345f, 0.04471461f, 
    -0.07115619f, 0.01474825f, -0.00618677f, -0.05211989f, 0.05219330f, -0.02157187f, 0.04059074f, 0.04482416f, 
    0.00223320f, -0.00901823f, 0.04558894f, -0.01541957f, 0.01114168f, 0.00316041f, 0.04100911f, -0.07546563f, 
    -0.01820271f, -0.01770673f, -0.06990152f, 0.04641639f, 0.04478244f, -0.07059331f, -0.06537665f, 0.02689416f, 
    0.02555928f, -0.00526179f, -0.06735796f, -0.04679054f, -0.03515480f, -0.02871084f, 0.01355746f, -0.06722985f, 
    0.02832153f, -0.03056507f, 0.00921580f, -0.02900226f, 0.05382459f, 0.05069815f, -0.00485976f, -0.08001141f, 
    -0.07968980f, 0.05470119f, 0.00259698f, 0.05110731f, 0.02921164f, -0.05720397f, 0.04918201f, -0.07830535f, 
    -0.03301199f, 0.02604857f, 0.01907626f, -0.01158338f, 0.02983599f, 0.04413498f, -0.00357906f, 0.04413860f, 
    -0.02544943f, -0.01439925f, -0.02850198f, 0.04287075f, -0.00915013f, -0.02289342f, -0.01803960f, -0.06820774f, 
    0.00939417f, -0.07396831f, 0.04222818f, -0.07208630f, 0.06270204f, 0.01978226f, -0.00078548f, -0.04260431f, 
    0.04908743f, -0.06295653f, 0.02396867f, -0.07750200f, 0.05086344f, 0.06050532f, -0.03958441f, -0.04151276f, 
    -0.01467029f, 0.00998232f, -0.03639484f, 0.01259085f, 0.00751868f, -0.01811269f, -0.05213762f, 0.04441028f, 
    -0.04656876f, -0.02468178f, -0.01536166f, -0.04245984f, -0.00174431f, -0.02686678f, -0.03751307f, 0.04536927f, 
    0.00349577f, -0.06911530f, 0.01817511f, 0.05263271f, -0.04878926f, -0.00670939f, -0.06309957f, -0.04424079f, 
    0.05396755f, -0.04169246f, 0.00199989f, -0.00997943f, -0.02130247f, 0.04564657f, 0.05344697f, -0.06556289f, 
    0.05432141f, 0.00033228f, -0.07765029f, -0.05904210f, -0.00089329f, -0.07323150f, -0.06040777f, -0.02622366f, 
    -0.00849382f, -0.05135784f, -0.04860955f, -0.01756022f, -0.04047429f, -0.05925396f, 0.00025876f, -0.06592116f, 
    0.04569234f, 0.00621632f, -0.01571020f, 0.01824703f, -0.05513695f, 0.00601746f, 0.06028333f, -0.07520961f, 
    -0.00354833f, -0.02673444f, 0.00895422f, 0.03030340f, -0.07517036f, 0.05812673f, -0.02643274f, -0.03418550f, 
    -0.02727708f, 0.00235991f, -0.02801648f, 0.05099469f, -0.06161926f, -0.06505115f, 0.04110406f, -0.03878589f, 
    0.00235150f, -0.07948552f, -0.04450313f, 0.03433944f, -0.07893551f, 0.05017851f, 0.05392477f, -0.04475811f, 
    -0.03560049f, -0.02659295f, 0.01644900f, 0.03477462f, 0.00983183f, -0.01135203f, -0.00828016f, -0.04046747f, 
    -0.04168830f, -0.05780091f, -0.06212782f, 0.02322456f, -0.06573725f, -0.03182528f, -0.06410723f, -0.04103535f, 
    0.03691686f, -0.05256242f, -0.07461926f, 0.05083974f, -0.05698775f, 0.01815504f, -0.03323891f, 0.06145772f, 
    -0.05458875f, 0.05949182f, -0.07745576f, -0.01624216f, 0.01067388f, 0.00881732f, 0.04112784f, -0.02162441f, 
    0.01750102f, 0.06230517f, 0.05304394f, -0.00259349f, -0.02379505f, -0.04909592f, 0.04271100f, 0.03436267f, 
    -0.02970279f, -0.00233086f, -0.04890191f, 0.00847043f, -0.05929669f, 0.03937071f, 0.02328427f, -0.00832468f, 
    0.10761184f, -0.10680543f, 0.05787229f, 0.39579538f, 0.02692708f, 0.00239409f, 0.05954128f, 0.14324032f, 
    0.00799020f, -0.01966766f, 0.11816051f, 0.03254858f, -0.50084651f, -0.19761847f, 0.04609249f, -0.09755323f, 
    0.07140010f, -0.06523377f, 0.00294681f, -0.01154630f, 0.05712904f, -0.15046459f, -0.02430807f, 0.06955119f, 
    -0.55232334f, 0.09421712f, 0.35802248f, -0.09080120f, -0.12791640f, -0.08535765f, -0.01145542f, -0.12388922f, 
    -0.10825409f, -0.19035904f, -0.12911321f, 0.00323301f, -0.18179150f, 0.10354289f, 0.23548797f, -0.29116592f, 
    -0.22712101f, -0.04454556f, -0.05182956f, -0.05658744f, 0.10746875f, 0.13179834f, 0.11537602f, -0.10230920f, 
    -0.07887527f, 0.02645748f, 0.38157189f, -0.37737793f, -0.07150496f, 0.05566135f, -0.07266767f, 0.07197324f, 
    -0.27302149f, 0.01237385f, -0.17409053f, -0.03806644f, 0.07412998f, 0.15634827f, -0.01416275f, 0.26711071f, 
    -0.06407745f, 0.09010310f, 0.10291904f, 0.22055233f, -0.16081156f, 0.10035829f, 0.22551258f, 0.26457915f, 
    0.02756232f, 0.12369139f, -0.15586904f, 0.12709619f, 0.05604649f, 0.12693511f, 0.15338688f, -0.09276337f, 
    0.06852717f, 0.21342286f, 0.19327043f, -0.06445172f, -0.33778983f, -0.30931827f, -0.36144978f, 0.16353343f, 
    -0.07027531f, 0.12483674f, 0.08757525f, 0.30138010f, -0.10747380f, 0.00757012f, -0.04582103f, 0.13471305f, 
    -0.27496031f, 0.42314789f, -0.12774566f, 0.31307280f, 0.00305247f, -0.10869373f, 0.17631315f, -0.07989495f, 
    -0.00730063f, 0.04327325f, 0.08833650f, -0.05437436f, 0.26456669f, -0.28502873f, 0.04181952f, 0.25957498f, 
    -0.10689835f, 0.17147595f, -0.15880108f, 0.04123704f, 0.07922579f, 0.04661742f, -0.08628018f, -0.08645053f, 
    0.03763692f, -0.30394217f, 0.32941213f, 0.31417409f, -0.11458300f, -0.02779813f, -0.02182098f, 0.24337715f, 
    -0.04707313f, 0.03899607f, 0.06353539f, -0.04453799f, 0.08477104f, 0.27046159f, -0.35492137f, -0.03173584f, 
    0.08976440f, -0.11701271f, 0.01404885f, -0.14217186f, -0.31092715f, 0.06224548f, -0.10742534f, -0.00881114f, 
    0.04791166f, 0.39376280f, -0.34683159f, -0.20456250f, -0.05320936f, 0.08851161f, 0.09104256f, 0.01576803f, 
    0.04533699f, -0.00933436f, 0.18965097f, 0.13749591f, -0.11992484f, 0.03004068f, 0.04644842f, -0.21343558f, 
    -0.03679875f, -0.04965138f, 0.00963307f, -0.08655354f, 0.08166182f, 0.35976833f, 0.01115154f, 0.18407567f, 
    0.02849490f, -0.26913598f, 0.36128739f, 0.32549959f, 0.13848993f, -0.03306004f, 0.47058639f, 0.14280960f, 
    0.14313936f, 0.20764007f, 0.15577562f, 0.03980997f, 0.05434062f, 0.05937617f, -0.12586454f, 0.17731293f, 
    -0.07311047f, 0.04376287f, -0.06912701f, -0.08845811f, -0.10168549f, -0.20639631f, -0.08804891f, -0.03575328f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.05228421f, 0.10476281f, 0.26270443f, 0.24732378f, -0.02667429f, 0.03102261f, 0.11916050f, -0.03951805f, 
    0.15559731f, 0.19971606f, -0.07026298f, -0.03309596f, 0.04744475f, -0.08589623f, 0.16002561f, 0.17671406f, 
    -0.07886201f, -0.06272302f, 0.19990239f, 0.15712662f, 0.06441969f, -0.07578426f, 0.05565289f, -0.07841677f, 
    0.16505449f, -0.15459974f, 0.08228943f, 0.18590271f, -0.00751577f, -0.00728350f, -0.00992696f, -0.02563524f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.16410689f, 0.05934527f, 0.15588883f, 0.57833588f, 0.31326658f, -0.09113397f, 0.18057692f, 0.13531514f, 
    0.23616870f, 0.19915617f, 0.16744168f, -0.13647343f, 0.10616154f, 0.33315086f, -0.29141876f, 0.02282572f, 
    0.05142596f, 0.03405816f, 0.03937497f, 0.19914879f, 0.42766783f, 0.15119386f, -0.52534628f, -0.19076711f, 
    -0.33082253f, -0.10003659f, 0.35931033f, 0.22136357f, -0.07469696f, 0.15639719f, 0.07132594f, 0.04052214f, 
    -0.06712884f, 0.64878380f, 0.22834110f, 0.28571716f, -0.16943078f, 0.02290299f, -0.04237115f, -0.08538435f, 
    0.44598201f, 0.09359127f, 0.06631486f, 0.06964724f, 0.13849939f, 0.45832610f, 0.09541708f, 0.27825826f, 
    0.01919085f, 0.18814643f, 0.17283686f, -0.32684886f, -0.00815084f, -0.17425632f, -0.16187912f, 0.13596536f, 
    -0.25234410f, 0.23271637f, -0.06718098f, -0.16168198f, 0.06039295f, 0.14078850f, -0.15055229f, -0.24718909f, 
    0.03688973f, -0.18778127f, -0.03541987f, -0.01709726f, 0.03543786f, 0.15070896f, -0.05473092f, -0.37522084f, 
    0.18905145f, -0.14088543f, -0.14690605f, -0.09489550f, 0.07595377f, -0.28207436f, 0.01202461f, 0.28087524f, 
    -0.07300153f, -0.06505373f, -0.23812220f, -0.55068725f, 0.12631917f, 0.18909420f, 0.13668410f, 0.25788206f, 
    -0.20028180f, -0.26010153f, -0.30301160f, 0.13754274f, -0.09510700f, 0.14234076f, -0.16118304f, 0.18526329f, 
    0.00750314f, 0.10822501f, -0.03485022f, 0.31402633f, -0.22666478f, -0.10930412f, 0.02908275f, -0.35487154f, 
    -0.27293131f, 0.12102330f, -0.07086535f, -0.15374652f, 0.00699055f, -0.30903593f, 0.12713452f, 0.33499536f, 
    -0.28194275f, -0.05887977f, 0.32883525f, -0.07263996f, -0.01004137f, 0.16416560f, 0.30150005f, -0.33808956f, 
    -0.00080491f, -0.28194681f, 0.40545341f, -0.04950929f, 0.16384095f, 0.16010937f, -0.15617959f, -0.28114283f, 
    -0.07160226f, 0.64156270f, 0.30236235f, -0.18282859f, 0.03739471f, -0.06803035f, 0.00593435f, -0.26030585f, 
    0.15459202f, 0.03027906f, 0.04373868f, 0.13997668f, 0.00363146f, 0.82008547f, -0.15384646f, 0.20507441f, 
    0.46170911f, -0.57175505f, 0.16325916f, -0.03971890f, -0.22907288f, 0.08638336f, 0.10869450f, -0.09679290f, 
    -0.20245972f, -0.14830898f, -0.19747391f, 0.03086929f, 0.09301776f, 0.06956116f, 0.06923582f, -0.38179198f, 
    0.07253420f, 0.00197339f, -0.15838461f, 0.12327183f, 0.00813973f, 0.28828549f, -0.26474282f, 0.32815674f, 
    0.04114581f, 0.03207963f, 0.01520997f, 0.01226699f, -0.15975784f, 0.34039041f, 0.08576118f, -0.07903581f, 
    0.37138912f, 0.19092165f, -0.19874446f, 0.19366415f, 0.40998405f, 0.37002522f, -0.10676382f, -0.25801450f, 
    0.18691319f, 0.08555266f, -0.06765985f, 0.06983894f, 0.06562553f, 0.08200604f, 0.17418048f, 0.19508916f, 
    0.03365370f, -0.27849355f, -0.36346486f, -0.22968487f, -0.40671915f, -0.31528598f, 0.37614217f, 0.30270299f, 
    -0.26206061f, 0.28973839f, -0.02254631f, 0.09222557f, -0.13195893f, 0.47368783f, 0.13780975f, -0.04516678f, 
    -0.47496173f, -0.21673225f, 0.32978263f, -0.06257942f, 0.01248238f, 0.11793160f, 0.29436836f, 0.63207155f, 
    0.48539767f, 0.19483760f, 0.02939597f, -0.04487218f, 0.01431562f, -0.11934247f, -0.00864078f, -0.10362528f, 
    0.10903912f, 0.33990127f, -0.07082240f, -0.06028432f, -0.49064082f, -0.20400338f, 0.04794213f, -0.23285770f, 
    -0.25935897f, 0.38115251f, -0.13854401f, -0.17676185f, 0.02165865f, 0.83537430f, -0.05498042f, 0.26582816f, 
    -0.50193256f, -0.53976232f, 0.25928602f, -0.58445221f, -0.36768991f, -0.03140552f, 0.23835276f, -0.18440749f, 
    0.11270442f, -0.20607658f, 0.06296587f, 0.15309134f, -0.01898133f, -0.10890792f, 0.15745942f, -0.13400905f, 
    -0.07422875f, -0.27810061f, 0.15996982f, 0.40437680f, 0.40227100f, 0.16785048f, 0.01920494f, -0.20417981f, 
    0.13764133f, 0.36330813f, -0.14448501f, 0.12739362f, -0.01182167f, 0.25612700f, 0.24564674f, 0.05371057f, 
    0.19972867f, -0.36153066f, -0.21161573f, 0.35489604f, -0.18764359f, -0.23206866f, 0.19900595f, -0.00759517f, 
    0.20237352f, -0.21375823f, -0.25009257f, 0.33249640f, -0.05617324f, -0.06119689f, -0.07923102f, 0.56935948f, 
    -0.13020530f, 0.02060477f, 0.09628618f, -0.07146592f, 0.17794682f, -0.17158458f, -0.12493046f, 0.03068204f, 
    -0.09077732f, 0.01042878f, -0.14708240f, 0.05532777f, -0.11638021f, -0.05955546f, -0.00988344f, -0.08858605f, 
    0.14770035f, -0.12313080f, -0.01683567f, -0.12835117f, 0.00351737f, 0.00480505f, -0.16490732f, 0.16226560f, 
    0.05375022f, -0.08240622f, -0.16158427f, -0.07350066f, -0.06263715f, 0.08288462f, -0.10951129f, 0.11619087f, 
    0.15155280f, 0.34381500f, -0.06826032f, -0.13313526f, -0.01343553f, 0.02075517f, -0.07352188f, 0.23682415f, 
    0.04730533f, 0.17821439f, -0.13233243f, -0.02130466f, -0.10596205f, 0.40134412f, -0.27183527f, -0.08069778f, 
    -0.01764806f, -0.01487410f, 0.18362173f, -0.03536648f, 0.02721676f, 0.10821546f, 0.01759421f, 0.07081982f, 
    -0.33445314f, 0.20398366f, 0.11253499f, 0.34059158f, 0.02583470f, -0.10743950f, -0.11782540f, -0.28401652f, 
    -0.03323078f, 0.28140956f, 0.47481897f, 0.20010072f, 0.22199929f, -0.07089223f, 0.18705146f, 0.08241253f, 
    0.15213895f, 0.22540301f, 0.06003135f, 0.06007772f, -0.05098248f, 0.63449138f, 0.06427901f, 0.31270823f, 
    0.28374213f, -0.27523309f, -0.06874117f, 0.02168705f, -0.28468591f, -0.42761412f, 0.09674495f, 0.32149881f, 
    -0.20706329f, -0.18044260f, -0.48673868f, 0.09796853f, -0.15452290f, -0.14241113f, -0.02152671f, 0.06772640f, 
    -0.07509721f, -0.30472067f, 0.01670391f, 0.15849008f, 0.46550998f, 0.11355076f, 0.19028287f, -0.02278584f, 
    0.27159178f, -0.17359410f, -0.17208397f, 0.22506514f, -0.10270302f, -0.28831747f, -0.04078639f, -0.11262839f, 
    0.73458469f, -0.13426217f, -0.05665338f, 0.44469494f, 0.14413317f, -0.05932231f, 0.43083391f, -0.48923156f, 
    0.05570718f, -0.18862453f, 0.14949518f, 0.25702420f, 0.17017891f, -0.04436573f, -0.05116990f, -0.06798221f, 
    -0.07496510f, -0.49127534f, 0.04210538f, -0.07513104f, -0.21394005f, 0.01478890f, 0.00943968f, -0.23346485f, 
    -0.30907226f, 0.10615849f, -0.12006631f, -0.11354534f, -0.02825192f, -0.23313425f, 0.13614692f, -0.34520742f, 
    0.48757234f, 0.14250374f, 0.19431461f, 0.14341120f, 0.33219728f, -0.29883054f, -0.09536230f, 0.17658581f, 
    -0.24355218f, -0.44078854f, 0.01007276f, -0.11558334f, 0.17447819f, -0.01046293f, 0.11623597f, -0.14156300f, 
    0.04371962f, 0.42703363f, 0.35304141f, 0.13311142f, 0.05797972f, -0.11446353f, -0.06426051f, 0.35148779f, 
    0.31366852f, -0.11529539f, -0.09326737f, 0.02045827f, 0.11198822f, 0.26372030f, -0.11329545f, -0.01214261f, 
    0.67237157f, -0.05938394f, 0.13936555f, 0.16839795f, -0.14245388f, 0.23406273f, -0.27772960f, 0.21322137f, 
    -0.44070154f, 0.25908670f, -0.10834360f, -0.06503111f, -0.10852052f, 0.14029406f, -0.09700663f, 0.02810776f, 
    -0.16486998f, 0.11699285f, 0.25249118f, 0.17409745f, 0.13877568f, -0.13313317f, 0.11601382f, -0.36468068f, 
    0.47150832f, -0.16108875f, -0.12345315f, -0.05856447f, 0.07254356f, -0.48282987f, 0.13326165f, 0.18190323f, 
    -0.05591025f, 0.09145069f, 0.21583244f, -0.18950999f, -0.13815404f, -0.04630541f, 0.21559730f, 0.05384445f, 
    -0.07611763f, -0.02071436f, 0.09772076f, -0.03498866f, -0.11740944f, 0.09687615f, 0.01888196f, -0.16757531f, 
    -0.15781756f, -0.09976384f, -0.11347696f, -0.11279293f, -0.11122851f, -0.11209670f, 0.07292794f, 0.17182878f, 
    0.09501155f, -0.02533362f, 0.10981378f, 0.06666044f, -0.15636505f, -0.14639033f, -0.03547425f, -0.01510942f, 
    0.05682745f, -0.05181634f, -0.01013280f, 0.02386255f, -0.07682405f, -0.05445451f, -0.03526893f, -0.14479767f, 
    -0.04093204f, -0.11248287f, -0.14703526f, 0.06684595f, 0.04394585f, 0.07161525f, -0.11047511f, -0.08374882f, 
    -0.04252703f, 0.20720463f, 0.24425888f, 0.23208429f, 0.07830105f, 0.26418886f, -0.24031956f, 0.24676196f, 
    -0.05552303f, -0.06510949f, -0.12717345f, 0.16674443f, -0.01905971f, -0.52300340f, -0.23094434f, -0.30279577f, 
    0.13620991f, 0.04311093f, 0.29089740f, -0.02649752f, -0.05395909f, 0.44744200f, -0.16781683f, -0.35138071f, 
    -0.00708481f, 0.17261147f, 0.38851044f, 0.40692106f, -0.06820339f, -0.09200747f, 0.06045534f, 0.11643139f, 
    -0.03794627f, 0.56422144f, 0.11154983f, -0.32877502f, 0.11329541f, -0.04718331f, -0.05956820f, -0.21616660f, 
    0.39193299f, 0.08639432f, 0.12951568f, -0.17476068f, 0.15623082f, 0.00904686f, -0.16561191f, -0.13771731f, 
    0.15252812f, -0.08144534f, 0.14826775f, -0.49788314f, -0.15302257f, 0.33546063f, 0.56455892f, -0.52491629f, 
    -0.03860937f, 0.02522890f, 0.09010904f, 0.32318118f, 0.00326487f, 0.01837606f, -0.05762549f, -0.31492403f, 
    0.13368471f, 0.14900763f, 0.38497826f, 0.08742383f, -0.21395260f, 0.14615469f, -0.22119579f, 0.03530359f, 
    0.41527373f, 0.17539899f, 0.15503900f, 0.00742943f, -0.07190920f, -0.13756897f, 0.29237196f, 0.02166399f, 
    0.09910223f, -0.26271531f, 0.02113560f, -0.28980288f, -0.38886693f, -0.26584858f, -0.01016554f, -0.13927642f, 
    0.13973030f, 0.19987617f, -0.23367858f, 0.39913464f, 0.15308654f, 0.04835976f, 0.10264920f, -0.08468009f, 
    -0.01932175f, -0.56669515f, 0.02259464f, 0.03729775f, 0.39764705f, -0.20357549f, 0.39015633f, 0.07380321f, 
    -0.05485344f, 0.00878004f, 0.01263423f, 0.12902744f, -0.15685773f, 0.54598755f, -0.27601191f, 0.07545403f, 
    -0.28844082f, 0.04411655f, 0.28564319f, 0.27372769f, -0.25175565f, -0.10209650f, 0.23317790f, 0.89634168f, 
    -0.24869388f, 0.03823111f, 0.17134634f, -0.10050130f, 0.09036887f, 0.02633064f, 0.15600801f, 0.15692134f, 
    0.08962251f, 0.28067446f, -0.00042280f, -0.12704000f, 0.25012857f, -0.25383735f, 0.36757687f, -0.49276960f, 
    0.03202836f, -0.47872868f, 0.07747938f, -0.10787527f, -0.05461009f, -0.19652772f, -0.08168773f, 0.20577472f, 
    0.47572351f, -0.16159301f, 0.23786718f, 0.46937361f, 0.20269273f, 0.27798483f, -0.12198117f, -0.58030051f, 
    0.22262886f, -0.10309942f, 0.27008373f, -0.29900664f, -0.12857533f, -0.05692849f, 0.02720034f, -0.48578522f, 
    0.02699162f, -0.41308525f, -0.24221183f, 0.47663078f, 0.07112156f, -0.13432266f, 0.31334013f, 0.02198615f, 
    -0.29406741f, 0.32831603f, -0.00067880f, 0.07903800f, 0.11245393f, 0.54265535f, 0.26900524f, 0.23011179f, 
    -0.22659953f, -0.29797426f, 0.14083338f, 0.38418603f, 0.30153432f, -0.02958677f, -0.27019864f, 0.21261492f, 
    0.01912480f, -0.09702805f, -0.12827742f, 0.19445345f, 0.14411026f, -0.03289544f, 0.01689313f, 0.20531365f, 
    -0.07324680f, 0.03363032f, 0.04886696f, 0.23468883f, -0.36483064f, 0.00053497f, 0.16896598f, -0.16509792f, 
    -0.18878604f, 0.16573359f, -0.17917290f, 0.01375360f, 0.03413536f, -0.55089641f, 0.09694368f, 0.39403188f, 
    -0.58794516f, -0.22553240f, 0.12939021f, -0.47560355f, 0.18311231f, 0.44165662f, -0.32027391f, 0.10067402f, 
    0.51909810f, -0.06283906f, 0.28671277f, -0.06313277f, -0.07979940f, -0.04000260f, 0.08515280f, 0.36213019f, 
    0.10006057f, -0.35993025f, 0.30578661f, -0.24095014f, 0.21808338f, 0.33317572f, -0.05692990f, 0.36325201f, 
    -0.04561516f, 0.26763037f, 0.01364935f, -0.10568226f, 0.07505179f, -0.31309772f, 0.09825282f, -0.20067412f, 
    0.24727368f, -0.07775967f, -0.04638629f, 0.33065233f, -0.17189659f, 0.11450015f, 0.51315653f, 0.08792665f, 
    0.35468429f, 0.16541201f, -0.30988827f, 0.15882568f, 0.06753976f, -0.02125983f, -0.08944783f, 0.38383558f, 
    -0.06258533f, 0.23592433f, 0.27494666f, 0.15337342f, -0.36145595f, -0.15807895f, -0.00987376f, 0.35971811f, 
    0.09063386f, -0.00196422f, -0.15375628f, 0.04854789f, 0.07712601f, -0.57228142f, -0.04209058f, -0.19005240f, 
    -0.47710076f, 0.00624145f, 0.40173724f, 0.04071045f, -0.15053655f, -0.20152032f, -0.42671025f, 0.61192697f, 
    -0.06421426f, 0.29437503f, 0.50044608f, 0.16699122f, -0.11168381f, 0.09601191f, 0.15061370f, -0.45953333f, 
    -0.01518221f, -0.30112123f, -0.11694883f, 0.03905667f, -0.39529744f, 0.23225047f, -0.17115615f, 0.16979860f, 
    -0.10102298f, 0.06704272f, 0.03704307f, 0.11403442f, 0.08724010f, -0.76783532f, 0.02451077f, 0.14561431f, 
    -0.32153156f, 0.01201177f, 0.27444896f, 0.17310116f, 0.12504883f, 0.06145994f, 0.06453124f, -0.28438592f, 
    0.35167560f, -0.27493414f, 0.36837751f, 0.18770716f, 0.05359636f, -0.01461519f, 0.05897490f, -0.02832353f, 
    0.03677765f, 0.32671246f, 0.26475313f, -0.27005151f, 0.06156142f, 0.14080921f, 0.02716002f, -0.45788315f, 
    -0.00128144f, 0.11948712f, 0.14623752f, -0.08050571f, -0.01784988f, 0.42818323f, 0.33369052f, 0.05968935f, 
    -0.08076973f, -0.00324239f, -0.10504491f, -0.41637132f, 0.04991725f, 0.18207790f, 0.22924860f, -0.03398985f, 
    -0.12786514f, -0.49077407f, -0.23240103f, -0.14404832f, 0.02505763f, -0.17198446f, -0.05187228f, 0.14378004f, 
    -0.08230133f, -0.52527785f, 0.01037275f, -0.27040556f, -0.00629592f, 0.22312748f, -0.03283714f, 0.09191711f, 
    0.07298405f, 0.11751518f, -0.01899072f, -0.11825893f, 0.08596425f, 0.80828506f, 0.17463380f, 0.06352653f, 
    0.12886964f, 0.05765274f, 0.03086372f, -0.27863270f, -0.54376566f, -0.03911182f, 0.03964680f, 0.51562947f, 
    0.19787323f, 0.45722979f, -0.18732040f, 0.13496459f, 0.05094289f, -0.00781221f, -0.14683698f, 0.34214324f, 
    0.14088616f, -0.15994821f, 0.29391068f, 0.20295112f, -0.26301268f, 0.23497608f, 0.14350152f, 0.15581740f, 
    -0.25975820f, -0.29291725f, 0.07388372f, -0.05089002f, -0.06150766f, -0.62550199f, 0.51431596f, 0.30552110f, 
    0.52728313f, -0.08735278f, 0.03995460f, 0.47899872f, 0.21371098f, -0.43363222f, 0.20824909f, -0.34775519f, 
    0.40746328f, -0.08342212f, -0.24717842f, 0.00168810f, -0.13257776f, 0.14527622f, 0.04142265f, -0.04549153f, 
    0.01371236f, 0.47811231f, -0.15703753f, -0.47284696f, 0.02875795f, -0.03424741f, -0.04420543f, 0.33868107f, 
    -0.07441087f, 0.19867121f, -0.14643089f, 0.08912393f, -0.13959302f, 0.50002587f, -0.46781275f, -0.09970555f, 
    0.19852266f, -0.01386443f, -0.08346897f, 0.13911429f, -0.17727430f, 0.19843267f, 0.29563916f, -0.11620124f, 
    -0.20501770f, 0.24393435f, -0.04574580f, 0.22372885f, -0.03056327f, -0.13253793f, -0.07038064f, -0.22031826f, 
    -0.04718524f, -0.36922207f, 0.03387990f, -0.19219279f, -0.04136430f, 0.21928416f, -0.09560442f, 0.10281193f, 
    0.26889259f, -0.11756189f, -0.16723570f, -0.08469744f, -0.04787450f, 0.16945387f, 0.20510513f, 0.06817410f, 
    -0.35597834f, -0.09640451f, 0.00227048f, 0.06867763f, -0.49728248f, 0.00590380f, 0.33501056f, 0.31742707f, 
    0.55922115f, 0.26276684f, -0.21878247f, 0.17237441f, -0.13422298f, 0.17006475f, 0.12449574f, 0.49107045f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.21172261f, 0.11498512f, -0.27827129f, 0.27118099f, 0.13386518f, 0.06819283f, 0.14818518f, 0.23038055f, 
    0.11870743f, -0.01280425f, 0.22938024f, 0.06175732f, -0.11749709f, 0.06846803f, -0.05976550f, 0.18056038f, 
    0.02299528f, -0.03209788f, 0.14043574f, 0.11535313f, -0.16914415f, -0.04036193f, 0.07609124f, 0.26245311f, 
    0.16637003f, 0.29871315f, 0.06509041f, -0.04671690f, -0.30715936f, 0.06118393f, -0.11493573f, -0.00670015f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.39921838f, -0.04855878f, -0.06874261f, -0.56235009f, 0.22617358f, 0.24133156f, -0.24257921f, -0.67360914f, 
    -0.36060318f, 0.00528374f, 0.18379451f, -0.30869728f, 0.00707604f, 0.23332193f, 0.33223009f, -0.42554665f, 
    0.00804943f, 0.09681923f, 0.20902622f, 0.06284002f, -0.14547044f, -0.31926709f, -0.59108233f, -0.61976862f, 
    0.17711326f, -0.01090953f, -0.07709202f, 0.13563025f, 0.08206780f, 0.09853511f, 0.55327398f, -0.03817710f, 
    0.20695513f, 0.13304804f, -0.22895029f, -0.34729424f, -0.01062704f, 0.03567675f, -1.16592193f, -0.67741054f, 
    0.16001754f, 0.10191286f, -0.18130229f, 0.09646098f, 0.20989563f, -0.02181556f, 0.19950205f, 0.12806985f, 
    -0.15264356f, 0.11971580f, -0.13303931f, 0.24910972f, -0.26663536f, 0.40094641f, -0.11598827f, -0.11481749f, 
    0.14357677f, -0.07029771f, -0.10445153f, -0.15385105f, 0.01894462f, 0.20050924f, -0.58220845f, 0.04165688f, 
    0.14348294f, 0.13655660f, -0.16319865f, -0.00052228f, -0.61069989f, 0.00048283f, 0.25363469f, -0.03447835f, 
    -0.16115378f, 0.10525567f, 0.12831642f, 0.03835788f, -0.49349275f, -0.11954539f, -0.09518702f, -0.18906191f, 
    0.06247266f, -0.05395584f, -0.97437894f, -0.26410466f, 0.08615861f, -0.78640068f, 0.29779300f, -0.04339372f, 
    0.00132748f, 0.42576322f, 0.19754623f, -0.01430834f, -0.82684499f, 0.26397386f, -0.50512254f, -0.30899084f, 
    -0.41365924f, -0.08682011f, 0.05958497f, -0.36845934f, -0.34010845f, -0.31685865f, 0.37427795f, -0.01924312f, 
    -0.09147359f, -0.04956710f, -0.07135979f, -0.22865954f, -0.30330342f, -0.53170991f, -0.16353847f, 0.00840555f, 
    0.01117786f, -0.01182299f, -0.08911501f, 0.12938277f, 0.28922057f, -0.15923120f, -0.17619106f, 0.01406490f, 
    0.25627819f, 0.11963109f, -0.08146458f, 0.21056156f, 0.39928862f, -0.25853178f, -0.10776347f, 0.36896440f, 
    0.14300755f, -0.08221509f, 0.14278226f, -0.09239132f, -0.32404459f, 0.16320032f, 0.00150962f, -0.25439849f, 
    -0.36741927f, -0.09891793f, 0.15236440f, -0.71904796f, 0.12750658f, -0.46942869f, 0.02885205f, 0.03008827f, 
    -0.02740466f, 0.22949861f, 0.13576812f, -0.01996152f, -0.01302017f, -0.43720233f, -0.22402057f, -0.02562892f, 
    0.03594317f, 0.28949130f, 0.11431178f, 0.20529480f, -0.18165804f, -0.57142317f, 0.07634039f, -0.12448213f, 
    -0.21375832f, 0.27364519f, 0.19633360f, 0.20016956f, 0.28436694f, -0.32339883f, -0.42396635f, 0.44831461f, 
    -0.04593219f, 0.08582038f, 0.17920196f, -0.02018247f, 0.01912447f, 0.26426524f, -0.20605139f, 0.24599914f, 
    -0.11523190f, 0.04106436f, 0.31009731f, 0.26670033f, -0.22241241f, -0.27671596f, -0.22105715f, -0.21322551f, 
    -0.03480483f, 0.18572994f, 0.02545667f, -0.09537940f, -0.23679498f, 0.06941383f, -0.02183337f, -0.15496621f, 
    -0.06432756f, -0.00138550f, 0.08881372f, 0.34397537f, -0.41193673f, -0.15345991f, 0.38094056f, 0.06909481f, 
    -0.49605906f, 0.11737774f, -0.67234433f, -0.58951217f, -0.19506219f, -0.36073938f, -1.08150554f, 0.16306941f, 
    -0.06935806f, -0.24124269f, -0.20113274f, -0.55401546f, -0.25346825f, 0.38283241f, 0.12004664f, 0.35885778f, 
    -0.96313918f, -0.08254156f, 0.10932006f, -0.11360092f, -0.18623866f, 0.28331834f, -0.22866413f, -0.50302452f, 
    0.25800562f, 0.19435856f, 0.30221036f, -0.13330527f, 0.43518177f, 0.03301551f, -0.02780754f, 0.30192199f, 
    0.15839027f, -0.03230111f, 0.01983953f, 0.32243526f, -0.07408410f, -0.54494095f, 0.13726678f, -0.04493487f, 
    -0.05881213f, -0.46215168f, -0.14531922f, -0.34087253f, 0.18570332f, -0.11575515f, 0.30047551f, -0.24493112f, 
    -0.28147230f, -0.47461087f, -0.77067298f, 0.14749807f, -0.01368586f, -0.43068835f, -0.03659795f, -0.23904772f, 
    -0.37455207f, -0.06348091f, -0.08812694f, 0.20393185f, 0.22901009f, -0.25341555f, 0.15116790f, 0.18569255f, 
    0.34684390f, -0.01670693f, -0.80843139f, 0.35480630f, 0.02472294f, -0.57595468f, -0.02472489f, 0.13446130f, 
    0.08304662f, -0.81986725f, -0.10352282f, 0.07266963f, 0.14780058f, -0.33984149f, -0.09268065f, 0.05277323f, 
    0.22970004f, -0.82092285f, -0.37003115f, 0.26404476f, -0.27502862f, 0.07158799f, -0.65036768f, 0.07786246f, 
    0.18138544f, 0.35085991f, -0.05238935f, 0.15233986f, 0.12759174f, -0.38692984f, -0.01577234f, 0.04898276f, 
    -0.66901767f, 0.11045589f, 0.03500777f, -0.24549252f, -0.67808670f, -0.25426590f, 0.39134923f, 0.13004677f, 
    0.10203835f, 0.10946052f, -0.05620274f, -0.46069065f, 0.15889110f, 0.22302142f, -0.14010319f, 0.34578866f, 
    -0.21199954f, 0.23982170f, -0.25006318f, 0.11499975f, -0.74107641f, -0.44929907f, -0.61115313f, -0.34175023f, 
    -0.00647313f, -0.73983300f, 0.12085196f, 0.08799691f, -0.59670556f, 0.32544863f, -0.11507665f, 0.27990341f, 
    0.27056995f, 0.07482689f, -0.16261010f, -0.30643597f, -0.02281125f, -1.02207100f, -0.79585671f, -0.44469249f, 
    0.03927500f, 0.14268492f, 0.14025190f, -0.03460878f, -0.67587137f, -0.31580707f, 0.09582087f, 0.39674374f, 
    0.10236119f, -0.59024626f, 0.25069529f, -0.17331848f, -0.31471497f, -0.07524333f, 0.15273803f, 0.05185407f, 
    0.06015620f, -0.80644929f, -0.32488525f, 0.22878894f, -0.11505264f, -0.50383925f, 0.00006040f, -0.23712744f, 
    0.22770946f, -0.10370447f, -0.19257498f, -0.01246131f, 0.29885629f, 0.08726110f, -0.40356857f, 0.01391094f, 
    -0.04168374f, 0.00181060f, -0.49131256f, -0.70711124f, 0.50083905f, 0.19904687f, 0.19163558f, -0.11239251f, 
    0.00818712f, -0.20705077f, 0.05637083f, -0.71228325f, -0.68272662f, 0.21870403f, -0.63532341f, -0.11494923f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.21937819f, 0.15842190f, 0.17012212f, -0.19417675f, -0.13719399f, -0.00638427f, -0.04107319f, -0.18016443f, 
    -0.00408015f, -0.00329697f, -0.07327840f, 0.12164298f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
