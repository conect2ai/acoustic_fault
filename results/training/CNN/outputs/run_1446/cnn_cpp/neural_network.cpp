#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.13813080f, -0.25433078f, -0.46308273f, -0.19264235f, 0.20916925f, 0.21390265f, 0.39462662f, 0.71834427f, 
    -0.24268650f, -0.51298219f, -1.07590771f, 1.01736259f, 0.25244567f, -0.19466418f, 0.50655782f, 0.12926464f, 
    -0.20923655f, 0.01890926f, -0.19773372f, -0.41757727f, -0.42635423f, 0.06942044f, -0.71455997f, -0.20990732f, 
    -0.02250528f, 0.14315353f, -0.56376189f, -0.82462996f, -0.18026692f, -0.03600406f, -0.70132327f, -0.73017901f, 
    0.13849367f, 0.68439627f, -0.03789902f, 0.59406662f, 0.61463356f, 0.17184697f, 0.06742105f, 0.27462593f, 
    -0.65192246f, -0.24266323f, 0.30697986f, 0.32644835f, -0.05386106f, -0.42220041f, 1.13267195f, -0.77651089f, 
    0.49664655f, -0.24071816f, -0.30628300f, 0.62970328f, -0.73586833f, -0.09247507f, -0.74125993f, -0.36520290f, 
    0.21798132f, 0.88926691f, 0.21851236f, -0.81886929f, -0.59127313f, -0.37467760f, -0.42271197f, 0.82329220f, 
    0.47538346f, -0.19267687f, -0.35835686f, -0.00798753f, 0.53512460f, 0.53242701f, 0.18871178f, -0.54928851f, 
    -0.61418235f, 0.72315258f, 0.23372602f, 0.08329253f, -0.53191990f, -0.00797749f, 0.26781151f, -0.04082909f, 
    0.74427170f, -0.54506028f, -0.06974992f, 0.49500173f, 0.35445562f, -0.05989202f, 0.13904534f, -0.39498320f, 
    -0.80130100f, 0.81857157f, 0.47815159f, 0.66099793f, 0.58957529f, -0.30033359f, -0.72510475f, -0.72070533f, 
    -0.04377704f, -0.19295473f, 0.12089469f, 0.44242606f, -0.82809949f, -0.09398113f, 0.19591920f, 0.34632596f, 
    0.19753696f, 0.20248346f, 0.24205324f, 0.26943853f, 0.34131142f, -0.65281332f, -0.40685531f, -0.31892052f, 
    -0.72025639f, -0.89515048f, 0.32508627f, -0.26752201f, 0.39416167f, -0.08702878f, -0.79185116f, -0.96640044f, 
    1.15612423f, 0.30023569f, -0.26579699f, 0.01700128f, -0.04947086f, 0.13202646f, -0.17859447f, -0.66251338f, 
    -0.82042122f, 0.64588034f, 0.84326446f, 0.47513515f, -0.22008272f, -0.29993433f, -0.00910355f, 0.79323643f, 
    -0.40860164f, -0.54285973f, 0.34246230f, 0.25489968f, 0.88066435f, -0.24091458f, 0.04884281f, -0.66750932f, 
    0.59324646f, 0.65615851f, 0.57435262f, 0.10706407f, 0.09611809f, 0.17162436f, 0.14490534f, -0.29518852f, 
    -0.16743910f, -0.13299777f, -0.02662750f, 0.30429146f, 0.52718288f, -0.55304074f, -0.64087617f, 0.41565692f, 
    0.43824133f, 0.66689420f, 0.60785085f, 0.48868132f, -0.27790847f, -0.44946459f, 0.00246721f, 0.91992801f, 
    -0.19886920f, -0.29906625f, 0.16886804f, 0.29146284f, 0.47451749f, 0.14798364f, 0.29312396f, 0.48872191f, 
    -0.03659928f, -0.28638676f, 0.23596989f, 0.55140370f, -0.44033435f, 0.02847685f, 0.16322300f, -0.45898098f, 
    -0.09362011f, 0.61428851f, -0.42218244f, -0.06797738f, 0.61460131f, -0.77352995f, 0.50709087f, -0.87174803f, 
    -0.62562692f, 0.84015560f, 0.04340240f, -0.17475177f, 0.33769670f, -0.27616888f, 0.87196255f, -1.01298785f, 
    -0.45158181f, -0.12408683f, 0.15596871f, -0.37634933f, -0.31140316f, -0.33540842f, -0.21479800f, -1.06726480f, 
    -0.68870199f, -0.34410000f, 0.70085865f, 0.20834811f, -0.08678225f, 0.17786628f, -0.19166274f, -0.23149529f, 
    0.73927146f, 0.80328041f, -1.11229491f, -0.22146647f, 0.47081092f, -0.47860602f, -0.24602987f, 0.20340480f, 
    0.09395275f, 0.76559788f, 0.70541018f, 0.54031056f, 0.05618097f, -0.49327973f, -0.19025788f, 0.34176159f, 
    0.24858572f, -0.20656325f, 0.42911223f, 0.11089638f, -0.30873209f, -0.81573194f, -0.85675055f, -0.24915652f, 
    -0.37969828f, -0.49545991f, -0.28084880f, -0.71818882f, 0.12630357f, 0.52706659f, 0.12054572f, 0.62847650f, 
    0.85805112f, 0.04737024f, 0.26743385f, -0.11634773f, -0.39109808f, 0.63874388f, -0.47147170f, -0.20234270f, 
    -0.46834755f, -0.64137834f, -0.06162940f, 0.69585752f, -0.38400340f, -0.90997761f, 0.60636848f, 0.79127711f, 
    -0.20691063f, -0.25114000f, 0.42161170f, -0.21620731f, -0.10784410f, -0.34919485f, 0.06646399f, 0.63609207f, 
    -0.47380844f, -0.59396946f, 0.20291959f, 0.10342208f, 0.01674354f, -0.32345149f, 0.59895968f, 0.07927581f, 
    -0.33466330f, 0.72882056f, -0.46441659f, -0.33073348f, 0.48324001f, -0.35362461f, 0.62133723f, -0.07360778f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.03023662f, -0.20580392f, -0.05803300f, 0.16480760f, 0.30153638f, -0.03587132f, -0.19122021f, 0.11168881f, 
    0.26715532f, 0.17744051f, 0.26429036f, 0.18259682f, -0.14903814f, 0.11222070f, -0.14629754f, 0.04787602f, 
    -0.29616955f, -0.05357013f, 0.36574259f, -0.33261028f, 0.44229934f, 0.46385610f, 0.08006942f, -0.17821437f, 
    -0.01379886f, -0.30333319f, -0.05671339f, -0.22427031f, 0.31107470f, 0.45225531f, 0.27997321f, 0.18436067f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.01942824f, 0.05318349f, 0.01977377f, -0.10456898f, -0.07510845f, -0.00978655f, 0.10225526f, -0.19642608f, 
    0.06036208f, -0.25968638f, -0.04677636f, -0.00140440f, -0.15766174f, 0.18196161f, 0.05781481f, -0.20147468f, 
    -0.00933527f, -0.07177637f, 0.20381984f, 0.14060663f, -0.10177454f, -0.23395796f, -0.09379022f, -0.11067591f, 
    0.04741351f, -0.14760426f, -0.11999930f, 0.01039821f, -0.04621870f, 0.23032913f, -0.27244598f, -0.01050665f, 
    0.15388344f, 0.08784398f, -0.05196890f, 0.13023356f, 0.01457859f, 0.01464952f, -0.05304581f, -0.13537690f, 
    -0.10309860f, 0.14568354f, 0.01038044f, -0.02878522f, 0.06194830f, -0.26106471f, -0.26462972f, -0.08358593f, 
    -0.12718496f, 0.20332058f, -0.01518479f, 0.01235068f, 0.11483583f, 0.12951240f, -0.06962056f, 0.33368927f, 
    0.27797040f, -0.14239025f, 0.01440064f, 0.02704748f, 0.03996773f, 0.02031897f, -0.22026725f, -0.05621613f, 
    0.15376490f, 0.05589061f, 0.01625893f, 0.01428638f, 0.02875370f, 0.06127130f, -0.01085617f, 0.07025380f, 
    0.06361920f, -0.10221829f, 0.06873038f, -0.07764494f, 0.05560590f, 0.00658865f, -0.02195619f, 0.06451257f, 
    0.11178342f, -0.24482286f, 0.16148634f, -0.05695624f, -0.05928896f, 0.09747725f, -0.00758955f, 0.07759771f, 
    0.06147854f, -0.08875291f, -0.39577794f, 0.02137659f, -0.07551768f, -0.10652299f, -0.04512009f, -0.00584932f, 
    -0.15375458f, 0.01311674f, 0.11085831f, 0.00877027f, 0.06689947f, -0.00704372f, -0.11383811f, 0.02488876f, 
    0.09502104f, -0.13229489f, 0.04664585f, 0.01557292f, -0.05210212f, 0.02968666f, 0.10907830f, -0.29008782f, 
    0.07890512f, -0.05232371f, -0.12357992f, 0.06126982f, -0.11807781f, 0.18220247f, 0.34295002f, 0.24261947f, 
    -0.12229254f, 0.15705290f, -0.08907450f, -0.06806222f, 0.10790324f, -0.24080367f, 0.06029510f, 0.25174344f, 
    0.25943375f, -0.00383678f, 0.09345002f, -0.22778495f, -0.00393537f, 0.09028219f, -0.17130443f, 0.41915730f, 
    0.18335743f, 0.19097964f, 0.02879398f, -0.07613317f, -0.12806757f, 0.06143421f, 0.05417781f, -0.08117556f, 
    -0.03111712f, -0.02983087f, 0.00962403f, 0.09744065f, 0.05290323f, 0.03405298f, -0.02461166f, -0.14214200f, 
    0.13970551f, 0.10129860f, 0.00571567f, -0.00098287f, -0.15800162f, -0.06405220f, 0.21915868f, -0.10870396f, 
    0.01799021f, 0.12469196f, 0.08991071f, 0.17436889f, 0.07325403f, -0.03766027f, 0.03816670f, -0.02193759f, 
    0.09126199f, -0.14279012f, 0.14446691f, 0.06789403f, 0.00580872f, -0.00899089f, -0.02339171f, 0.00218878f, 
    0.03374667f, -0.12830454f, -0.18147202f, 0.01165246f, -0.26895648f, 0.02810919f, 0.00260499f, -0.10033014f, 
    0.24939787f, -0.00961891f, 0.08123779f, 0.05796857f, 0.00875910f, -0.14905222f, 0.14553396f, -0.05769989f, 
    0.01863386f, 0.11334658f, 0.02536042f, 0.06794321f, -0.01581571f, -0.14311005f, 0.37958795f, 0.09335681f, 
    -0.14505497f, -0.06905805f, 0.02017951f, 0.01886905f, -0.04420835f, 0.09089197f, -0.22274697f, -0.00977322f, 
    0.33987164f, 0.17390837f, -0.18105556f, 0.19603357f, -0.11981078f, -0.00323812f, -0.01703447f, -0.16707915f, 
    -0.35620207f, -0.20538229f, -0.29965532f, -0.10151660f, 0.09134133f, 0.11919154f, -0.13320373f, 0.01204357f, 
    -0.13579281f, -0.03203142f, 0.07413271f, -0.15300874f, 0.07043889f, 0.04761039f, -0.00249393f, -0.03824848f, 
    -0.02092737f, 0.08736201f, -0.13170244f, 0.30389982f, 0.00751460f, -0.06369841f, -0.08014039f, -0.05543052f, 
    -0.08521271f, 0.00861898f, 0.09019050f, -0.04669849f, 0.04555637f, 0.07183799f, -0.08579694f, 0.10880800f, 
    0.03082489f, -0.19015925f, -0.09193128f, -0.02806187f, -0.02452894f, -0.06620412f, -0.06216342f, -0.06630704f, 
    -0.21379749f, 0.17536891f, -0.07706345f, -0.14516822f, 0.16934083f, -0.18795668f, -0.10424297f, 0.04994268f, 
    0.01209045f, -0.08795118f, 0.08948404f, -0.06292047f, 0.07301029f, 0.14725463f, -0.36152795f, -0.03599637f, 
    0.07583607f, -0.04445758f, 0.23885468f, -0.06288987f, 0.10102655f, 0.00492985f, -0.03998129f, -0.19909079f, 
    0.01133805f, 0.16615738f, 0.11098272f, 0.10096482f, 0.06554180f, -0.00083461f, 0.02456891f, 0.07398115f, 
    -0.02897762f, -0.00392707f, -0.05336703f, -0.00284111f, -0.02914165f, -0.01831598f, -0.02814654f, 0.05222061f, 
    -0.02250184f, 0.02373786f, 0.00007473f, 0.03260308f, 0.03989984f, -0.02333339f, -0.03801717f, 0.05272492f, 
    0.00444822f, -0.01882268f, 0.03386765f, -0.03162539f, 0.00416665f, -0.00868711f, -0.03827307f, 0.00318258f, 
    0.02824997f, 0.02445867f, 0.00159395f, -0.01433258f, 0.02144882f, 0.01190659f, -0.00496061f, 0.04362554f, 
    0.01175588f, -0.01145510f, -0.05641174f, 0.00196541f, 0.02842912f, -0.04139205f, 0.00303028f, 0.00519314f, 
    -0.01686792f, -0.00514835f, -0.04889740f, 0.02770349f, -0.00556772f, 0.05274352f, -0.04889848f, 0.03370246f, 
    0.01359060f, 0.04560116f, 0.04341637f, -0.03764538f, -0.05816603f, 0.03839980f, -0.03417950f, 0.05386498f, 
    -0.02167689f, 0.02257828f, -0.00677184f, -0.00281434f, -0.01236350f, -0.00719967f, 0.01112160f, 0.00093244f, 
    0.03116275f, -0.04646364f, 0.05095936f, -0.03255948f, 0.01653482f, 0.03771218f, 0.03803516f, 0.02653753f, 
    0.01457581f, -0.03498593f, -0.03444685f, 0.05153438f, -0.06051696f, -0.01126998f, -0.04013634f, 0.02363326f, 
    -0.00132122f, 0.01732845f, -0.02466919f, -0.03871519f, -0.04093685f, -0.02555262f, -0.04814608f, -0.01741458f, 
    0.02626715f, 0.01964885f, 0.02623773f, -0.03100894f, -0.05146277f, -0.01357671f, -0.04147345f, -0.04408535f, 
    -0.00769096f, -0.03583064f, 0.04053656f, -0.02449472f, 0.03218219f, -0.02755457f, -0.05110487f, 0.01426694f, 
    -0.03358273f, 0.03871399f, -0.05165986f, -0.04798960f, -0.04280497f, -0.00921348f, 0.05006941f, -0.04309393f, 
    0.00134433f, 0.05168812f, -0.05883611f, -0.01712941f, -0.02873496f, -0.03425692f, 0.02362591f, -0.04324831f, 
    0.02347984f, -0.03605204f, 0.02769298f, -0.00734300f, 0.01265318f, 0.03516779f, -0.05805613f, -0.02202691f, 
    -0.04984045f, -0.03200644f, 0.03242620f, -0.00601588f, -0.05830653f, 0.01282242f, 0.00256078f, 0.03872417f, 
    -0.01351268f, -0.01960632f, 0.02229196f, -0.02150447f, 0.00561980f, -0.02547940f, -0.03958257f, 0.01507207f, 
    0.04790320f, -0.01718626f, 0.03189502f, 0.05286769f, -0.06445460f, -0.02804036f, -0.02871727f, 0.05783178f, 
    -0.02870343f, 0.01231281f, -0.04259769f, 0.04112114f, -0.05400291f, -0.02996074f, -0.04570843f, 0.02393734f, 
    -0.01308889f, 0.00476712f, 0.02370027f, -0.02766317f, 0.04834048f, -0.01031330f, 0.00983096f, -0.02403910f, 
    -0.04405618f, -0.06224214f, 0.00201892f, -0.01381799f, 0.01114793f, 0.00647879f, -0.03592483f, -0.05773037f, 
    0.01132934f, 0.04905235f, 0.03833768f, -0.04896590f, 0.03724796f, 0.05050927f, -0.02275204f, -0.06367434f, 
    0.03555549f, -0.03244293f, -0.03590759f, -0.01911402f, -0.04586516f, -0.05526542f, 0.03835763f, -0.05156443f, 
    -0.00553102f, -0.03150764f, 0.01155512f, -0.04328658f, -0.05854808f, -0.00860905f, -0.04560861f, 0.01670550f, 
    0.00642422f, -0.05210957f, 0.00232492f, 0.00865728f, 0.00742241f, -0.03308889f, -0.03769180f, -0.02938088f, 
    0.02354694f, 0.03619768f, -0.00423076f, 0.01239817f, 0.00640072f, -0.01141504f, -0.02740257f, 0.03892308f, 
    -0.04257746f, -0.00503447f, 0.04904157f, -0.00515232f, 0.04360029f, -0.02954009f, 0.00257257f, -0.02616345f, 
    -0.04438277f, 0.01643447f, -0.02365303f, 0.02011732f, -0.03075141f, -0.02282854f, -0.03540025f, 0.03654506f, 
    -0.03252614f, 0.03411750f, -0.03575409f, -0.02210081f, -0.05486079f, 0.02102002f, -0.00339655f, 0.04480619f, 
    -0.02987260f, 0.04990024f, 0.01879192f, -0.03916229f, -0.04931409f, 0.04357076f, -0.05064590f, -0.06131574f, 
    0.04584719f, 0.03133310f, -0.03418459f, -0.04707837f, -0.01120017f, -0.01584829f, -0.01629289f, 0.02481147f, 
    -0.05427902f, -0.01398305f, -0.00124734f, 0.03093327f, 0.02510503f, -0.01746572f, -0.03235454f, -0.01009875f, 
    -0.04486487f, -0.05765965f, 0.04120455f, 0.01608127f, 0.04049806f, -0.01438883f, -0.01794147f, 0.03655504f, 
    0.04419568f, -0.03294921f, 0.00679976f, 0.01910191f, -0.06132269f, -0.03214472f, -0.03354638f, -0.00675039f, 
    -0.06386965f, -0.03329768f, 0.01238752f, -0.01774651f, -0.01374099f, -0.02615328f, -0.03976828f, 0.03603257f, 
    -0.00757219f, -0.17022827f, -0.08022126f, 0.00764923f, -0.02810142f, -0.00194992f, 0.29168952f, -0.04298570f, 
    -0.17681980f, -0.20801836f, -0.14606091f, 0.03229928f, -0.27645299f, 0.23060712f, -0.06176827f, -0.15547809f, 
    0.13435163f, -0.23601265f, 0.11094768f, 0.21319813f, 0.04836180f, -0.02841292f, 0.09908535f, -0.00446329f, 
    0.13567770f, 0.08333851f, 0.01991352f, 0.20892948f, 0.11939523f, 0.36841387f, 0.16033046f, 0.08140156f, 
    -0.08571016f, 0.19717102f, 0.02771647f, -0.03713772f, -0.12440922f, -0.27724987f, 0.12719557f, -0.16049692f, 
    -0.06375768f, -0.00599905f, 0.11211025f, 0.06666971f, 0.14625630f, 0.04452362f, -0.06565165f, -0.07049957f, 
    0.12612551f, -0.14074022f, 0.16004939f, -0.08245748f, -0.09299472f, -0.14691457f, -0.05761479f, 0.08173816f, 
    0.26935980f, -0.04568404f, -0.08446889f, 0.10896198f, 0.04055945f, 0.09605367f, -0.03744728f, -0.04800987f, 
    -0.16212368f, -0.04436129f, -0.06625362f, -0.06309625f, 0.06218911f, -0.10461225f, -0.09658328f, 0.19325835f, 
    -0.03474489f, -0.03715727f, -0.08354878f, -0.00429734f, -0.17994182f, -0.01223721f, 0.09246411f, 0.07120137f, 
    0.25570166f, -0.06018297f, -0.10562412f, -0.20800801f, -0.17619292f, 0.26134548f, -0.16262193f, -0.01249052f, 
    0.10647909f, -0.11152828f, -0.19998400f, 0.04742592f, 0.09046324f, -0.03814536f, -0.20573235f, 0.14606056f, 
    0.07910956f, -0.01808526f, -0.02101649f, -0.00147672f, -0.12470324f, -0.08789878f, 0.06115007f, 0.00380979f, 
    0.08254662f, 0.05001015f, 0.06884801f, 0.01074925f, 0.08163171f, 0.45689189f, 0.25204304f, -0.05443406f, 
    0.16863440f, -0.04716314f, 0.12905607f, 0.17201219f, -0.03642718f, 0.12082832f, 0.26978728f, 0.39367524f, 
    0.02856457f, 0.00320320f, -0.05296817f, -0.10806304f, -0.05337034f, 0.19161744f, -0.14609842f, 0.08706948f, 
    0.38096491f, -0.07198543f, -0.11725146f, -0.00409655f, -0.00118058f, -0.10535410f, 0.04758916f, -0.09220392f, 
    0.09276850f, 0.03941429f, 0.02737267f, -0.16302732f, 0.03533070f, -0.03696768f, -0.07929473f, -0.02943745f, 
    -0.54928041f, -0.35151345f, -0.10957109f, 0.11235315f, -0.03167659f, 0.04652790f, 0.15982042f, -0.19666195f, 
    -0.02826911f, 0.13844182f, -0.05654188f, 0.03897122f, 0.09286080f, -0.15890251f, -0.01519489f, 0.08388743f, 
    -0.00955090f, 0.03648943f, 0.05371935f, -0.06320743f, -0.24996036f, 0.01789790f, -0.13496025f, 0.06591816f, 
    -0.09817452f, 0.06225417f, 0.00290281f, 0.04166083f, -0.22804508f, -0.16919775f, 0.04481736f, 0.15705061f, 
    -0.01818158f, 0.15553533f, -0.24483880f, -0.03956372f, -0.05007402f, 0.22004351f, -0.18316039f, 0.12094117f, 
    0.14751709f, -0.02658927f, 0.11518662f, 0.13349810f, -0.05663840f, -0.06642587f, -0.07559628f, -0.04761236f, 
    -0.17747828f, 0.00883949f, 0.12794851f, 0.11623465f, 0.01823051f, 0.00815363f, -0.01830351f, 0.13503936f, 
    0.07526374f, -0.08222618f, 0.06671583f, 0.03542413f, 0.00673026f, 0.05590008f, 0.05384335f, 0.03094305f, 
    0.05831131f, 0.32289991f, -0.06239162f, 0.07398643f, 0.09035300f, 0.13292742f, -0.02745274f, 0.06612371f, 
    -0.69955021f, -0.66323346f, -0.54525661f, 0.07746682f, -0.00663749f, -0.28226280f, 0.09405725f, 0.10876623f, 
    -0.00739859f, -0.34450245f, -0.23100847f, 0.02631176f, 0.01178858f, -0.09208877f, 0.12926175f, 0.06412621f, 
    0.07641579f, 0.16506755f, 0.09278757f, 0.29029799f, 0.04967004f, -0.07118292f, 0.15016773f, 0.05001226f, 
    0.01078518f, -0.10080276f, -0.03548565f, 0.03325600f, -0.38518319f, -0.21454349f, 0.04128730f, 0.02726684f, 
    -0.05686983f, -0.13338092f, -0.08417509f, 0.34675196f, 0.06081923f, 0.07412624f, 0.20569663f, -0.02069132f, 
    -0.12185444f, -0.04618488f, -0.02066247f, 0.13725746f, -0.03609498f, -0.15485738f, -0.12279554f, 0.03953531f, 
    0.00665846f, -0.15127569f, -0.01796871f, 0.16679980f, -0.00359176f, 0.00777029f, -0.23793018f, 0.02057109f, 
    -0.08694518f, 0.07909402f, -0.09925105f, -0.07076533f, -0.01761779f, -0.00313844f, -0.01322741f, -0.21981883f, 
    0.06537024f, 0.00099122f, 0.34224549f, -0.04560307f, -0.13606995f, 0.00160615f, 0.20782125f, -0.00709469f, 
    0.06636114f, -0.13917419f, -0.00490610f, 0.02799485f, 0.19301878f, -0.07580765f, -0.00418389f, -0.02736516f, 
    0.21124719f, 0.40350702f, 0.13504598f, -0.29419380f, 0.24052235f, -0.09764251f, -0.05441443f, 0.19574533f, 
    0.11655525f, -0.17648096f, 0.41015837f, 0.10687248f, -0.32940745f, -0.01851384f, 0.04156005f, -0.00437643f, 
    0.03094652f, 0.14216894f, 0.11855301f, 0.29470456f, -0.21278083f, -0.31543374f, -0.08183578f, 0.06707215f, 
    -0.02857876f, 0.03258019f, 0.13488421f, 0.22155853f, -0.20603499f, 0.11094390f, 0.05693318f, 0.07874639f, 
    -0.15022607f, -0.09178262f, 0.09855230f, 0.09332619f, 0.17039421f, -0.00885350f, 0.42745236f, 0.30752984f, 
    -0.00225635f, 0.04496276f, 0.13257882f, 0.06562932f, 0.03069626f, 0.03674595f, -0.15063730f, -0.03102299f, 
    0.15566052f, 0.02869572f, -0.03161128f, -0.02718247f, -0.39131388f, -0.30477452f, -0.41905674f, 0.05027198f, 
    0.15251160f, 0.02154596f, 0.11816921f, -0.00190880f, -0.00160354f, -0.21397196f, 0.01963473f, 0.16656922f, 
    -0.08379789f, 0.12642917f, 0.08047429f, -0.02547081f, -0.21626744f, -0.11440266f, 0.10241608f, 0.16201186f, 
    0.19553065f, 0.19387008f, -0.16207719f, -0.13322078f, -0.07786935f, 0.08345251f, -0.09791165f, 0.05322553f, 
    0.05749408f, -0.15610838f, -0.25525311f, 0.04667412f, -0.08502733f, -0.00107206f, 0.04027198f, -0.02864453f, 
    0.14225361f, -0.11713953f, -0.25013211f, 0.12847862f, -0.00830363f, 0.00645025f, 0.12379999f, 0.25580692f, 
    0.09327663f, -0.05966651f, 0.00428372f, 0.24558696f, 0.03802696f, 0.12581912f, -0.52842337f, 0.16460288f, 
    -0.02132170f, 0.09691375f, 0.09774937f, 0.20945269f, 0.15551274f, 0.17668796f, 0.39130157f, 0.24311557f, 
    -0.13013512f, 0.16316764f, 0.04684151f, -0.15992528f, -0.10288460f, 0.08620302f, 0.18903817f, 0.26240706f, 
    0.18198127f, 0.14137658f, 0.20612235f, 0.04856851f, -0.06633664f, -0.22702938f, -0.17660005f, -0.06888328f, 
    0.11127688f, -0.11185272f, 0.29472646f, 0.33409089f, -0.06138832f, -0.13278128f, -0.35335436f, -0.12790337f, 
    0.01278658f, -0.09813603f, -0.00459679f, -0.08561686f, -0.07507189f, 0.08201633f, -0.00929443f, -0.01183748f, 
    -0.18586810f, -0.18849517f, 0.05144409f, -0.03318566f, 0.15465784f, -0.18669492f, -0.07988290f, 0.13549484f, 
    0.28610712f, 0.35780102f, 0.11037952f, 0.09214050f, 0.05314482f, -0.14821674f, 0.05062309f, 0.07758658f, 
    -0.30215147f, -0.18633024f, -0.09544612f, -0.02757783f, -0.06965221f, -0.09521721f, 0.15995677f, -0.12441110f, 
    0.12449088f, -0.08926100f, 0.03864928f, 0.03183345f, 0.21909048f, -0.10978255f, -0.06001646f, 0.22452235f, 
    -0.09197125f, -0.13914917f, 0.25364980f, 0.06871878f, 0.23541039f, 0.10662646f, 0.23670810f, 0.21822976f, 
    0.15386359f, -0.14440599f, -0.22055508f, -0.09434087f, -0.08038740f, -0.02098299f, -0.06295548f, 0.18008362f, 
    -0.31834331f, -0.05520202f, -0.07763871f, -0.08970937f, -0.06604580f, -0.08255903f, -0.09985460f, 0.14614676f, 
    0.41191444f, 0.11699878f, -0.02950773f, 0.11719935f, -0.02483675f, -0.08185153f, -0.05377097f, -0.01313756f, 
    -0.22960161f, 0.15298851f, -0.03119591f, 0.07622912f, -0.06654020f, 0.23320955f, 0.20925394f, 0.05915478f, 
    0.00814924f, -0.12431949f, 0.08682890f, 0.05815892f, -0.05588101f, -0.11076319f, 0.04386701f, 0.16648759f, 
    0.04283830f, 0.03725620f, -0.01356562f, 0.20042321f, -0.03059326f, 0.07421121f, 0.20158276f, 0.11256881f, 
    -0.10953454f, 0.02463673f, -0.33667165f, 0.01486955f, -0.13796996f, -0.10970066f, 0.41778028f, 0.07964932f, 
    0.19557805f, -0.01572573f, -0.17060101f, -0.00298648f, 0.01552046f, -0.07342940f, 0.08182277f, 0.06420557f, 
    -0.10611575f, 0.12762977f, 0.09889073f, 0.10358172f, 0.06613490f, 0.11506333f, -0.19373250f, 0.11449017f, 
    0.04233238f, -0.07616299f, -0.06928424f, -0.24678126f, -0.29131767f, -0.33037418f, -0.09024438f, 0.08598504f, 
    0.12483137f, -0.14524104f, 0.18706459f, 0.09290311f, 0.00175868f, 0.32010233f, -0.00104560f, 0.14392740f, 
    -0.14267142f, -0.01771404f, 0.13575058f, 0.10032444f, -0.14299843f, 0.09244591f, 0.11063778f, 0.31241754f, 
    0.12509103f, -0.02489084f, 0.04201630f, -0.05456133f, -0.05108523f, -0.01351926f, 0.02090791f, -0.06771978f, 
    0.10095140f, -0.06200385f, -0.14479643f, -0.04268652f, -0.20425455f, 0.21084985f, 0.15615401f, 0.06858197f, 
    0.06642357f, -0.00664917f, -0.06765354f, 0.11813734f, 0.24823143f, -0.22040753f, -0.25293627f, 0.11637939f, 
    0.08397181f, -0.00434512f, 0.16755815f, 0.20304625f, 0.11499008f, 0.37816355f, 0.01628383f, -0.00672202f, 
    -0.13054073f, 0.11693044f, -0.10771637f, 0.06491064f, -0.06796893f, -0.08420250f, -0.08251344f, 0.06892066f, 
    -0.06464710f, 0.01443981f, -0.08840157f, 0.22898927f, 0.02479864f, 0.46954164f, -0.74326479f, 0.10368034f, 
    0.36474845f, -0.15656172f, 0.19253889f, -0.14469700f, -0.24982564f, -0.11263926f, -0.83115911f, -0.15593506f, 
    0.22178116f, 0.32534102f, 0.07624104f, -0.10454550f, -0.04154360f, 0.07125472f, 0.10640711f, -0.08564270f, 
    -0.18488199f, 0.08115967f, 0.01366978f, -0.06831415f, -0.00013570f, 0.13767973f, 0.08701011f, -0.08354650f, 
    0.13426775f, 0.02600349f, -0.06251930f, 0.02605238f, -0.02730235f, 0.00752031f, 0.10918174f, -0.11299720f, 
    -0.08477738f, -0.50371087f, -0.11579646f, 0.15831915f, 0.12100103f, 0.00357831f, -0.02451334f, -0.08873889f, 
    -0.38316682f, 0.05725656f, 0.54147792f, 0.14777212f, 0.11841243f, 0.05265577f, 0.13733177f, -0.05586782f, 
    -0.00668543f, 0.01015725f, -0.13199863f, -0.08866144f, -0.01694175f, 0.06919207f, -0.09532768f, -0.15478449f, 
    -0.03988253f, 0.20148090f, 0.17672381f, 0.25473249f, -0.05160134f, 0.35850137f, 0.54281169f, -0.16615120f, 
    -0.13267767f, -0.00883280f, -0.12318289f, -0.08832856f, -0.01429441f, -0.21745852f, 0.13985875f, 0.31866130f, 
    -0.11935130f, -0.08766419f, -0.13884363f, 0.07071239f, -0.05417658f, 0.01710995f, -0.62390405f, 0.34769243f, 
    -0.03211381f, -0.02212173f, -0.06058164f, -0.16867454f, 0.06938230f, 0.00416250f, -0.02351446f, -0.48822978f, 
    -0.04766983f, -0.52036107f, 0.17489131f, -0.15630500f, -0.13377546f, -0.22966319f, 0.00526640f, 0.04134619f, 
    -0.21839765f, 0.04849479f, 0.03693887f, 0.05590780f, -0.01159453f, -0.01702995f, -0.06282911f, -0.05203831f, 
    -0.03257153f, -0.09072874f, 0.08043025f, -0.04430700f, 0.03247505f, 0.13589507f, -0.16567257f, 0.16477397f, 
    0.23726797f, 0.02119654f, 0.09961947f, -0.07900605f, -0.42364025f, 0.02438672f, -0.22958644f, -0.02765338f, 
    -0.09513789f, 0.01204952f, 0.06085451f, -0.01269349f, 0.17771977f, 0.03242368f, 0.08465216f, 0.05234165f, 
    0.11405173f, 0.13773333f, 0.12118995f, 0.20940463f, 0.04363780f, 0.13415939f, -0.20118704f, 0.10066337f, 
    -0.04467537f, -0.05659541f, 0.03860813f, -0.10481776f, 0.09532183f, 0.00860032f, 0.13652155f, -0.18128289f, 
    -0.02294545f, -0.07929046f, 0.11169063f, -0.05486887f, -0.11077750f, -0.03205165f, 0.20438372f, -0.07957192f, 
    -0.22631904f, 0.17456430f, 0.00867854f, 0.24346140f, -0.07921497f, -0.18552651f, 0.19045828f, -0.29436564f, 
    -0.01175239f, 0.05450723f, -0.14829099f, -0.09682550f, -0.08513322f, 0.11095986f, -0.05032083f, -0.06905331f, 
    0.17899941f, -0.32576740f, -0.43041670f, 0.16269529f, 0.06640635f, -0.01621015f, 0.12442125f, 0.11958656f, 
    -0.10030552f, -0.07007978f, 0.20706177f, 0.20392492f, 0.06996001f, 0.03293807f, 0.14311846f, -0.00596671f, 
    0.20792666f, -0.08853847f, 0.37966853f, -0.02040105f, 0.17989290f, -0.02329500f, -0.07287887f, 0.01375602f, 
    0.22451544f, 0.19265048f, 0.22380652f, -0.05937325f, 0.05242201f, -0.05874896f, -0.01574487f, 0.06638794f, 
    -0.07508746f, 0.02672758f, 0.15871458f, 0.07217209f, 0.14347214f, 0.34471256f, 0.25923395f, -0.04607515f, 
    0.15142697f, -0.05625332f, 0.01551588f, 0.06388462f, -0.05099756f, -0.15563464f, -0.17910452f, 0.09841175f, 
    -0.06683822f, 0.08233886f, -0.16042207f, -0.14750536f, -0.02475766f, -0.11488447f, 0.18595386f, 0.01224873f, 
    0.07252252f, 0.18881460f, 0.02842094f, -0.05882914f, -0.02450195f, -0.09018976f, -0.11516400f, -0.28600088f, 
    -0.08436301f, 0.23911372f, -0.14010887f, -0.00309739f, 0.11076716f, -0.13508235f, 0.01791707f, 0.09050380f, 
    0.05134757f, -0.19312282f, -0.05781265f, 0.04298413f, -0.01493238f, -0.08566675f, 0.22096395f, 0.00442268f, 
    0.04414972f, 0.42302275f, -0.11302046f, -0.58679456f, 0.15925933f, 0.15203266f, 0.07408372f, 0.14507067f, 
    0.03981435f, -0.14984076f, 0.01802076f, 0.05761684f, 0.08157636f, 0.01930248f, -0.00741158f, 0.07160759f, 
    -0.06640551f, 0.10371308f, -0.04214039f, 0.28648084f, 0.18705601f, 0.08277539f, 0.01252384f, -0.02817807f, 
    -0.00906765f, 0.10085422f, -0.03891717f, -0.02652903f, -0.24178383f, 0.14616564f, 0.05044276f, -0.11933514f, 
    -0.05420512f, -0.01965271f, -0.04211948f, -0.13498059f, 0.01986102f, -0.48915523f, -0.16471806f, -0.04681898f, 
    0.08853412f, 0.17179351f, -0.00661923f, -0.13629615f, 0.34633750f, -0.01709386f, 0.65191144f, -0.09840324f, 
    -0.03469821f, 0.09733729f, 0.06351914f, -0.05262838f, 0.06771274f, 0.11964331f, 0.02615556f, -0.61742681f, 
    -0.05169030f, -0.08503572f, -0.21948823f, -0.20461443f, -0.08499564f, 0.11944950f, -0.05947348f, 0.20079781f, 
    0.06764177f, 0.29132059f, -0.20805094f, 0.01511976f, -0.26165146f, -0.06849837f, 0.10268033f, 0.08620183f, 
    -0.10052930f, 0.18949474f, 0.00397394f, -0.50857610f, 0.03091179f, -0.08223225f, -0.06630453f, 0.04242162f, 
    0.16665916f, -0.19618389f, -0.15341517f, 0.54815537f, 0.47292525f, -0.23639867f, -0.06165873f, -0.07652805f, 
    0.08975656f, -0.10897516f, -0.02679243f, -0.00118776f, -0.07715849f, -0.24834278f, -0.05548272f, 0.01353561f, 
    -0.10566578f, 0.05172805f, -0.03531738f, -0.13594724f, 0.27228341f, 0.09359668f, 0.34637371f, -0.12660912f, 
    0.02207130f, 0.02729080f, -0.02059683f, 0.16641980f, 0.04924570f, 0.14183323f, -0.06479535f, 0.17938535f, 
    -0.07122122f, -0.17656228f, -0.13288318f, -0.00550709f, 0.01046166f, 0.11450732f, 0.37370783f, 0.05892480f, 
    0.17722669f, 0.10285144f, -0.14636675f, -0.20510469f, -0.05602645f, 0.00307416f, 0.07963049f, -0.22802992f, 
    0.04345248f, 0.08945408f, -0.15940008f, 0.09510928f, 0.09583329f, 0.00575165f, -0.07550009f, 0.31577754f, 
    -0.61785060f, -0.75223756f, -0.02025742f, 0.24852119f, 0.07761214f, 0.04459369f, 0.02859450f, 0.07242783f, 
    -0.07511057f, -0.01723924f, -0.04187180f, -0.01701380f, 0.08282703f, -0.15384342f, 0.03255878f, 0.13038097f, 
    -0.12784034f, 0.04378144f, -0.49162281f, -0.15267529f, -0.21800017f, 0.00896078f, -0.25703362f, -0.18996853f, 
    -0.02629836f, 0.09643888f, 0.02577684f, 0.44261962f, -0.29587033f, -0.12799624f, 0.08757816f, -0.15380532f, 
    -0.02427263f, 0.02293853f, -0.04111598f, -0.02029156f, -0.04841765f, -0.01889089f, -0.11936187f, -0.04641600f, 
    -0.01212124f, -0.07841805f, 0.08801122f, -0.11686119f, -0.15580824f, 0.03656222f, -0.03192924f, -0.15577875f, 
    0.00676640f, 0.04248106f, -0.06636367f, -0.10002647f, -0.07739525f, -0.05636250f, 0.20673873f, -0.04931397f, 
    0.10085375f, 0.03620415f, 0.05646899f, 0.03809211f, -0.07154527f, -0.01708918f, 0.06178130f, 0.06205926f, 
    -0.18962869f, 0.02689266f, 0.10304672f, 0.05429538f, -0.15229250f, 0.05405239f, 0.06977656f, 0.13954830f, 
    0.19193770f, 0.06744636f, 0.41796076f, -0.04900330f, -0.03940254f, -0.14343721f, 0.10371324f, 0.09376756f, 
    0.09713016f, -0.53892815f, 0.13240013f, -0.49809507f, 0.00543069f, -0.05827338f, 0.02813541f, 0.09146577f, 
    -0.02832010f, 0.03127423f, 0.14348473f, 0.39677289f, 0.40102303f, -0.08035382f, -0.23515998f, 0.15917380f, 
    -0.09228761f, 0.07719940f, -0.03123940f, 0.52962697f, -0.12671484f, -0.01060508f, -0.01317508f, -0.05963502f, 
    0.16750075f, -0.05960043f, -0.04919630f, -0.02649956f, 0.33714840f, 0.08460324f, 0.02891180f, -0.01539232f, 
    -0.08430877f, 0.12228986f, -0.06025007f, 0.04649002f, 0.04394995f, 0.41019928f, -0.02269204f, -0.45331830f, 
    -0.10202960f, -0.05229630f, -0.01045857f, -0.04706511f, -0.09630815f, 0.17425622f, 0.01732662f, 0.04538272f, 
    0.09268849f, 0.03274221f, 0.05756899f, -0.05202882f, -0.18194576f, 0.16654518f, -0.01900877f, -0.31625029f, 
    0.09404335f, -0.59178597f, -0.19312276f, -0.07769198f, -0.25815192f, 0.12840657f, -0.02643163f, -0.17788595f, 
    0.17692068f, -0.25546691f, -0.28055143f, 0.00839392f, -0.15926945f, -0.08145487f, 0.11910138f, 0.09821966f, 
    -0.24131088f, 0.55053449f, -0.22254558f, 0.35621825f, -0.08273324f, 0.03505344f, 0.43814167f, 0.06925435f, 
    -0.07228227f, -0.20281291f, 0.29939774f, 0.14214373f, 0.17722560f, -0.06286147f, -0.00298020f, -0.09383123f, 
    0.04563489f, -0.06236986f, 0.08696023f, 0.24871367f, 0.42565089f, 0.33962983f, -0.02442882f, -0.14068381f, 
    -0.22136015f, -0.11003304f, -0.01933544f, 0.03908342f, -0.25022495f, -0.29796118f, -0.14962795f, -0.02596874f, 
    0.13257216f, -0.08801915f, 0.01193622f, 0.18438825f, 0.16496584f, -0.06604124f, 0.11717659f, -0.22755174f, 
    -0.01910478f, -0.13347365f, 0.01975578f, -0.11766496f, 0.14055774f, -0.01135951f, 0.16580746f, 0.06987865f, 
    -0.23066913f, -0.11735322f, -0.05872977f, 0.09483983f, 0.12167745f, -0.03994829f, 0.11774122f, -0.25890431f, 
    -0.39617378f, -0.06851806f, -0.01035352f, -0.02798272f, 0.05421895f, -0.00461513f, 0.05625709f, 0.14695953f, 
    -0.40682662f, -0.08540121f, 0.11537331f, 0.03099652f, 0.09264094f, -0.08274914f, 0.00919981f, 0.11281070f, 
    0.00648501f, -0.06528150f, -0.04905455f, 0.03722158f, -0.08429910f, -0.02143270f, -0.05539292f, 0.01837400f, 
    0.33888820f, -0.20702498f, -0.12251729f, 0.10781042f, 0.01325151f, -0.11758213f, 0.07118026f, -0.04934526f, 
    -0.10411154f, -0.07929688f, -0.07226197f, -0.04642476f, -0.17671613f, -0.59165066f, -0.02039310f, -0.10738784f, 
    -0.03926844f, 0.10054073f, -0.04022786f, -0.10976023f, 0.34128335f, 0.38260606f, 0.22406648f, -0.02471004f, 
    -0.01366669f, -0.03713764f, -0.01177806f, 0.01872107f, 0.05889130f, 0.20955352f, -0.11453146f, -0.49832571f, 
    0.01064352f, -0.03319883f, 0.00719350f, 0.03483790f, -0.02300450f, 0.07032364f, 0.26311427f, -0.43589163f, 
    -0.26984593f, 0.04707837f, 0.00127877f, -0.01686700f, -0.02316573f, 0.01489707f, 0.03810094f, -0.06205306f, 
    -0.42217058f, -0.08384998f, -0.05366176f, -0.13999332f, -0.02299513f, 0.35795411f, -0.06584480f, -0.17596965f, 
    -0.06613355f, -0.42261744f, 0.05422945f, 0.15123565f, -0.05080735f, -0.21261941f, -0.08972540f, -0.13069461f, 
    -0.12181617f, -0.10278598f, 0.25662890f, 0.14305383f, -0.07337431f, -0.04913053f, -0.07857811f, 0.26315185f, 
    0.08770972f, 0.07324520f, -0.32537115f, -0.08561682f, -0.29985461f, 0.05590312f, -0.31500483f, -0.08738805f, 
    0.17315103f, -0.07291397f, -0.21916768f, -0.01222777f, -0.00101706f, -0.05385187f, 0.17882065f, 0.23243661f, 
    0.01703562f, 0.03891132f, -0.07416467f, -0.01920421f, -0.15626080f, 0.17296110f, 0.12257124f, 0.05324525f, 
    -0.04191477f, -0.08811046f, -0.03384413f, 0.00494676f, -0.05305736f, -0.16797073f, 0.02302531f, 0.09963893f, 
    -0.15418714f, 0.12362747f, 0.16170464f, 0.13794413f, 0.07666226f, 0.01908757f, 0.23424287f, -0.02875073f, 
    0.22438386f, 0.02574198f, 0.01458825f, 0.10114345f, 0.05552495f, -0.02643772f, -0.12863153f, 0.36857587f, 
    -0.10385060f, -0.15093289f, -0.00427387f, 0.08317947f, -0.11607151f, -0.06763853f, -0.04838154f, 0.02384184f, 
    -0.64816338f, -0.28131625f, -1.03790665f, 0.21589553f, 0.06273261f, 0.17030418f, -0.08244017f, 0.04222474f, 
    -0.13868271f, -0.20678379f, -0.27665150f, 0.64428359f, 0.08805085f, 0.21978712f, -0.03829908f, -0.16224991f, 
    0.14845940f, 0.09721965f, 0.05297832f, 0.35718042f, 0.28914416f, -0.14557680f, -0.03591131f, -0.00022787f, 
    -0.04599271f, -0.18007569f, -0.07322419f, 0.04346753f, -0.38414404f, 0.17939828f, -0.21817528f, -0.10037167f, 
    0.15653448f, -0.01106423f, -0.09777505f, 0.19213244f, 0.08550435f, 0.21407467f, 0.03109904f, -0.05997248f, 
    0.01513101f, 0.08404852f, 0.06875879f, 0.14771701f, 0.09902900f, -0.65223271f, -0.02825787f, 0.09876088f, 
    -0.02472047f, -0.10649244f, -0.11177443f, 0.10202578f, -0.15742220f, 0.00640320f, -0.09544066f, -0.03360281f, 
    0.11601567f, -0.09486142f, -0.01135033f, 0.00126463f, -0.07802537f, 0.05702508f, -0.06761453f, -0.54455113f, 
    0.06309427f, 0.44235444f, -0.15951359f, 0.07573139f, -0.02008993f, -0.06663286f, 0.05811578f, 0.07658109f, 
    -0.05110497f, -0.13092096f, -0.03552707f, 0.11836615f, 0.16879633f, -0.00585304f, -0.09564802f, -0.48348066f, 
    -0.05767622f, 0.13237338f, -0.17498732f, 0.13307467f, 0.03032950f, 0.10477950f, 0.25631616f, 0.32662866f, 
    -0.02902301f, 0.13395798f, -0.09817754f, -0.04148356f, 0.18453012f, 0.20021279f, 0.20745490f, 0.05556274f, 
    0.00079728f, 0.10050320f, 0.02016320f, -0.05123311f, 0.01307489f, 0.02211905f, 0.21705905f, 0.21033680f, 
    0.04558425f, 0.06551449f, -0.17266856f, -0.10154890f, 0.21385412f, 0.19026931f, -0.16456604f, -0.02851574f, 
    0.00364518f, -0.00350432f, -0.03581650f, 0.03574087f, -0.02613879f, -0.04254078f, 0.39216208f, -0.14477654f, 
    0.24422005f, 0.15334700f, -0.14294212f, 0.09229349f, 0.10748943f, -0.03975607f, 0.20247027f, 0.02156989f, 
    0.10674513f, 0.08635145f, 0.01646967f, 0.23055889f, -0.00947934f, 0.03412157f, 0.29448298f, -0.06112879f, 
    0.11442217f, -0.14631088f, -0.08476266f, 0.09652130f, -0.08510790f, 0.07341368f, -0.07078585f, -0.00107996f, 
    0.13916346f, 0.13520926f, -0.19471551f, 0.03497841f, -0.03485208f, 0.12694255f, -0.02641095f, -0.09043466f, 
    -0.24754979f, 0.02671847f, -0.09493411f, -0.05818262f, 0.20833455f, 0.17503992f, 0.32278746f, 0.32078624f, 
    0.26916850f, 0.09948210f, 0.18040158f, 0.25351694f, 0.26110345f, -0.00016582f, -0.13148871f, -0.07970507f, 
    0.09344355f, 0.07534134f, 0.07010841f, -0.03112608f, -0.13101642f, -0.01001032f, 0.07388529f, 0.06953341f, 
    0.15853378f, -0.08962080f, -0.28697118f, -0.26554972f, -0.13864863f, 0.30354825f, -0.17265995f, 0.24750569f, 
    0.22727162f, 0.00089322f, -0.01342194f, 0.24059121f, -0.23046015f, 0.01630702f, -0.21609996f, 0.20747936f, 
    0.32733476f, 0.20653604f, 0.18200384f, 0.05077362f, 0.19303019f, 0.24080943f, -0.20872143f, -0.41991562f, 
    0.15494728f, 0.16162746f, 0.11199358f, 0.18228833f, 0.23402952f, 0.25047335f, 0.21955422f, -0.28485849f, 
    0.05299400f, -0.09998555f, 0.10933448f, 0.11043756f, 0.24715093f, 0.15711991f, 0.11182612f, 0.06060642f, 
    0.30634409f, 0.20348968f, 0.09326572f, 0.02711869f, 0.10445864f, -0.01499558f, 0.17035678f, 0.22594464f, 
    0.19975884f, 0.16616452f, -0.06279001f, -0.16987984f, 0.07882603f, -0.02545155f, 0.12101652f, -0.49531052f, 
    -0.26287097f, -0.35245529f, -0.06402477f, 0.11032840f, -0.22679828f, 0.14442144f, 0.05403198f, 0.03995273f, 
    0.17087267f, 0.10526391f, 0.08629190f, 0.01401504f, -0.14035322f, -0.08547662f, 0.05940931f, 0.09327226f, 
    0.12160343f, -0.08838665f, -0.08518797f, -0.22595638f, -0.23585242f, 0.09480137f, 0.04045636f, 0.01155715f, 
    0.25438532f, 0.09556533f, -0.09202358f, -0.00468153f, -0.02472482f, 0.18086834f, -0.08574174f, 0.02323999f, 
    -0.06566631f, 0.22312702f, 0.22434881f, 0.23054688f, 0.19609238f, 0.14431821f, 0.07070161f, 0.33531362f, 
    0.31496778f, 0.24008468f, -0.01689463f, 0.15186824f, -0.07273426f, 0.23819943f, 0.01804629f, -0.00679471f, 
    -0.40698424f, 0.11513730f, 0.12515719f, 0.15633759f, 0.11349346f, 0.26637787f, 0.13318244f, 0.20079850f, 
    -0.20227729f, 0.27455050f, 0.06056600f, -0.11365107f, -0.23359664f, 0.22010121f, 0.17821251f, 0.11333809f, 
    -0.06996837f, 0.25688648f, 0.13219734f, -0.10538869f, -0.02825353f, -0.14253275f, -0.02411152f, -0.01998513f, 
    0.09809452f, 0.04556836f, -0.14222834f, 0.16750246f, 0.09689657f, 0.20832586f, 0.10618889f, 0.15211105f, 
    -0.00695406f, 0.00720377f, -0.03277187f, -0.07772321f, -0.36943176f, -0.02733462f, -0.03562973f, 0.24480371f, 
    0.09726971f, 0.01921902f, -0.29107255f, -0.03084155f, 0.14591759f, -0.05072024f, -0.08214537f, 0.14802697f, 
    -0.19965655f, -0.07247020f, 0.05833249f, -0.07560278f, 0.10945988f, 0.29651377f, 0.03562463f, -0.02950751f, 
    -0.03655251f, 0.07995268f, 0.09927582f, 0.10225628f, 0.22518243f, 0.12158334f, -0.17393900f, 0.14471687f, 
    -0.21158716f, 0.14101288f, -0.27908853f, -0.08990674f, 0.20527059f, -0.06618737f, -0.05241764f, 0.13294131f, 
    0.17178679f, -0.22623469f, 0.11349294f, 0.06390231f, -0.11984250f, 0.01633108f, -0.14920840f, -0.07859430f, 
    -0.05863987f, -0.02543486f, 0.05288798f, -0.07722491f, 0.05685206f, 0.08312705f, 0.15254472f, -0.03149141f, 
    -0.16686977f, -0.43395472f, 0.19017209f, -0.20161901f, -0.05211574f, 0.14210211f, -0.05881678f, -0.03411610f, 
    -0.10100576f, -0.24121900f, -0.03127421f, 0.43283629f, 0.14279045f, -0.01298796f, -0.00642275f, -0.03283433f, 
    -0.00348999f, 0.19360986f, 0.28607893f, -0.64918339f, 0.15996097f, 0.00613225f, -0.02773150f, -0.00889808f, 
    0.00300862f, -0.28615403f, 0.07460575f, -0.09424904f, 0.00385999f, -0.11047295f, 0.24284251f, 0.12941307f, 
    -0.05974356f, -0.19906102f, 0.09286988f, 0.17757918f, -0.09904780f, -0.08080943f, -0.46090746f, 0.11339992f, 
    -0.12228527f, 0.26212850f, 0.38017443f, -0.15139592f, 0.07363106f, 0.21221137f, -0.21869202f, 0.06414995f, 
    0.38412550f, 0.20349748f, 0.32015210f, -0.19016305f, 0.02312974f, 0.20002398f, 0.12021489f, 0.14822640f, 
    -0.21348621f, 0.27667218f, 0.05474891f, -0.11697100f, 0.06639437f, 0.01735529f, 0.13457537f, -0.01579754f, 
    -0.19472760f, 0.01704239f, 0.10078635f, 0.16062681f, -0.19462807f, 0.04950875f, -0.00979135f, -0.14238793f, 
    -0.14699021f, -0.34370911f, 0.07806998f, 0.10357701f, 0.01892217f, 0.05951283f, -0.03809589f, 0.01533819f, 
    0.07333444f, 0.14475945f, -0.17944713f, 0.01813693f, 0.12786835f, -0.00136074f, 0.10610672f, -0.05149432f, 
    0.00042810f, 0.00755096f, 0.02863856f, -0.08153909f, 0.06871321f, 0.01011794f, -0.05255179f, 0.03150788f, 
    0.15648244f, 0.10204149f, -0.05241383f, -0.19426587f, -0.62300074f, 0.06076599f, -0.09250839f, -0.07421517f, 
    -0.04552517f, -0.00511555f, 0.00027205f, 0.00491955f, -0.03672723f, -0.10416155f, 0.31182036f, 0.43394214f, 
    0.03467796f, -0.13123624f, 0.10212128f, 0.23384732f, 0.17647566f, 0.14435945f, -0.30615580f, -0.12351695f, 
    0.33229247f, 0.02340480f, 0.06646620f, -0.14829008f, -0.01348964f, -0.10333314f, 0.04094649f, -0.03054122f, 
    -0.21928470f, 0.18321192f, -0.07800725f, -0.15482850f, 0.13615897f, 0.05771561f, 0.07927070f, 0.24368709f, 
    0.02113884f, -0.01723090f, -0.03617152f, -0.13891430f, -0.13287100f, -0.10915205f, 0.00146502f, -0.00694062f, 
    -0.09904508f, -0.11270914f, 0.02807099f, 0.04592353f, 0.07830156f, -0.22548704f, -0.04102516f, -0.25673115f, 
    -0.29676592f, -0.20065923f, -0.00040463f, -0.11002810f, -0.02253172f, -0.04879349f, -0.13798435f, -0.07357332f, 
    0.08245120f, 0.14039205f, -0.07005791f, 0.02867190f, 0.21009976f, -0.04878601f, 0.05319026f, 0.01271457f, 
    -0.08127318f, 0.04792414f, -0.08604965f, 0.04058501f, 0.07363225f, 0.29219264f, -0.32594922f, 0.05910571f, 
    0.09208972f, -0.06913524f, 0.20294920f, -0.05960785f, -0.02491597f, -0.03366489f, 0.06871898f, 0.70961183f, 
    -0.08495888f, 0.18841760f, -0.19194108f, -0.05414229f, 0.11581335f, 0.08284622f, 0.26948237f, 0.07391724f, 
    0.06649279f, -0.01226054f, 0.10295229f, 0.21138671f, 0.18027726f, 0.16969214f, 0.23509124f, -0.46020067f, 
    0.25419411f, 0.45641351f, -0.15160337f, -0.04644417f, -0.19832474f, -0.14495859f, 0.24933144f, 0.07329673f, 
    0.20459636f, -0.05911991f, 0.09377687f, 0.12753721f, -0.23094656f, 0.04090849f, 0.00915296f, -0.08686851f, 
    0.05219045f, 0.15612043f, 0.08140755f, 0.31159842f, -0.01585755f, -0.12241437f, -0.20049149f, 0.07363175f, 
    0.07504123f, -0.00684306f, -0.16887927f, 0.01773622f, -0.00666086f, -0.17609650f, -0.00852899f, -0.05519844f, 
    -0.13203047f, 0.02860936f, 0.02102787f, -0.00970427f, -0.06742239f, -0.16857514f, 0.05998553f, 0.12206352f, 
    -0.07710086f, -0.02343451f, 0.11152410f, -0.13099645f, -0.31287217f, -0.34578940f, 0.19435799f, 0.09817079f, 
    -0.11139426f, 0.02160687f, -0.12115937f, -0.00692587f, -0.09512597f, -0.07627791f, 0.13380270f, -0.02677709f, 
    -0.15781717f, 0.07269519f, 0.05719706f, 0.08528569f, 0.04074537f, -0.05073738f, 0.09226073f, 0.10425118f, 
    0.00942784f, -0.04628653f, 0.03271852f, -0.11214844f, 0.11041203f, -0.11951789f, 0.03513340f, -0.17147765f, 
    0.07845048f, 0.28712496f, -0.20227152f, 0.22421323f, -0.20548181f, 0.10463952f, -0.00339514f, -0.01116694f, 
    0.12415555f, -0.14839415f, -0.00638255f, 0.10985566f, 0.02119732f, -0.02102999f, 0.12509148f, -0.01942267f, 
    -0.04946288f, 0.20989285f, 0.13735783f, 0.09522678f, -0.01323947f, -0.14168265f, 0.14865164f, -0.19819981f, 
    -0.05395218f, -0.16573702f, -0.02554027f, 0.05997039f, -0.27773336f, -0.05405034f, -0.17603424f, -0.02862919f, 
    -0.06660860f, 0.11181030f, -0.00998914f, 0.08338724f, -0.36401010f, -0.30767930f, -0.17419584f, 0.06358548f, 
    -0.02636292f, -0.02750397f, -0.19610488f, -0.01102720f, 0.08819272f, 0.01561634f, 0.11646955f, 0.06517162f, 
    -0.02248328f, 0.03189897f, 0.04379676f, 0.06602616f, -0.00289467f, 0.14752291f, 0.24224629f, 0.23504615f, 
    0.33402506f, 0.28816992f, -0.02116891f, -0.00004722f, 0.14498757f, -0.10072386f, -0.63232952f, -0.05407246f, 
    -0.38051632f, -0.04520927f, -0.07349905f, -0.18990405f, 0.00397096f, -0.06227845f, 0.13167669f, 0.14007153f, 
    0.16154289f, 0.16571915f, 0.20571184f, -0.06487145f, -0.00018825f, 0.00374042f, -0.07401942f, -0.03075027f, 
    0.04351312f, 0.08812463f, 0.09345926f, -0.04147960f, -0.00049143f, 0.03556864f, 0.12245451f, 0.06179554f, 
    -0.04342150f, -0.07503958f, 0.04696706f, 0.17015120f, -0.17781320f, 0.07914811f, -0.00852716f, 0.14443104f, 
    -0.15868069f, 0.13494106f, 0.47845030f, 0.21802995f, 0.36074021f, 0.02167617f, 0.02891686f, -0.01086073f, 
    -0.05890907f, -0.02710469f, 0.00557982f, 0.22759759f, -0.02105577f, -0.00710344f, 0.01500134f, 0.06517486f, 
    0.04557747f, -0.01042395f, 0.12621896f, -0.00183044f, -0.21090667f, 0.17657222f, -0.14577146f, -0.06562088f, 
    -0.05533189f, 0.04469272f, -0.14485371f, -0.01869029f, 0.02890680f, 0.20304263f, -0.49642187f, -0.84220040f, 
    0.03848290f, -0.27567461f, -0.16400620f, -0.02008958f, -0.03476950f, -0.01178160f, 0.12383579f, -0.52553183f, 
    -0.44382745f, -0.29366100f, -0.32691354f, -0.31697229f, -0.06145670f, -0.13634981f, -0.09196647f, 0.29485428f, 
    -0.01067730f, 0.22623494f, -0.01146880f, -0.07454197f, -0.13143668f, -0.03805121f, -0.16355833f, -0.20746566f, 
    0.25081998f, 0.15067780f, 0.19350107f, -0.02210805f, -0.06423310f, -0.02040026f, -0.09563081f, -0.11358684f, 
    -0.09144019f, -0.00681051f, 0.01905949f, 0.07066271f, 0.12664156f, -0.01090810f, -0.03305955f, 0.04247774f, 
    0.02202502f, -0.01615283f, 0.06709462f, 0.07157711f, 0.32073531f, 0.09661181f, -0.03158549f, -0.01112155f, 
    0.02628836f, -0.03444116f, 0.00403547f, 0.12360916f, 0.07529046f, 0.07060768f, 0.09647733f, -0.12372780f, 
    -0.22232394f, 0.00911425f, -0.13238561f, -0.01051985f, -0.25797829f, 0.28553241f, 0.34393093f, -0.15231854f, 
    0.10685641f, -0.08137550f, 0.24507503f, -0.01594590f, 0.20453712f, -0.49076530f, -0.46824703f, -0.55467719f, 
    -0.17780250f, 0.04513166f, -0.25775889f, -0.06493677f, -0.10773177f, 0.00582883f, 0.27587292f, -0.12339028f, 
    -0.60805333f, 0.00993375f, -0.08189613f, 0.05617517f, 0.11387786f, -0.10029498f, -0.02322320f, -0.00567682f, 
    -0.44414371f, -0.13942046f, -0.04224627f, -0.36669445f, -0.26071069f, -0.08813228f, -0.04494054f, 0.00126160f, 
    0.07071250f, -0.03747899f, -0.14313252f, 0.24168630f, -0.06588414f, -0.11051758f, 0.14653194f, -0.02022955f, 
    0.05708354f, 0.24576123f, 0.16968869f, 0.10216976f, 0.11911245f, -0.09176501f, -0.09147047f, -0.01530168f, 
    -0.03460631f, -0.15130660f, 0.07381256f, 0.15293062f, -0.54792130f, -0.13257881f, -0.04891760f, -0.01419759f, 
    -0.03409743f, -0.02165682f, 0.06493725f, 0.09326711f, 0.07065214f, 0.16911115f, -0.11245240f, -0.07456663f, 
    -0.18321499f, -0.05770474f, -0.03071356f, -0.10148733f, -0.27299362f, 0.11435377f, -0.39644346f, 0.05186087f, 
    0.00457422f, 0.04330219f, -0.07716466f, -0.09084582f, 0.01139815f, 0.01421528f, 0.10530119f, 0.34644240f, 
    -0.13425231f, 0.13244951f, 0.12460533f, 0.18345831f, 0.02666949f, 0.13207972f, 0.01148798f, 0.17230891f, 
    0.31002125f, 0.18287744f, 0.17467010f, -0.11832338f, -0.07922006f, 0.29019776f, 0.10397279f, -0.09555825f, 
    0.15037048f, 0.21885444f, -0.02948328f, 0.00854357f, 0.11056120f, 0.27134836f, -0.04323921f, -0.08504280f, 
    0.05362462f, -0.04485550f, 0.01965272f, -0.00248458f, 0.01009926f, -0.03312549f, -0.05592358f, -0.04641782f, 
    0.03142904f, 0.04840945f, -0.02193786f, -0.04508936f, -0.01738678f, 0.01646319f, 0.00486177f, 0.05844107f, 
    -0.06245165f, 0.00478554f, -0.00396305f, 0.02046215f, 0.01354665f, -0.03303294f, 0.00702182f, 0.03637313f, 
    -0.01447409f, -0.01096823f, 0.02574403f, -0.00598677f, 0.04666452f, -0.03037268f, -0.00673924f, 0.03560487f, 
    -0.04295380f, -0.03559051f, -0.01436340f, -0.03071717f, -0.02594272f, 0.02286647f, -0.03560648f, -0.01034936f, 
    -0.02196433f, -0.02823508f, -0.02670915f, -0.01146335f, 0.01136799f, 0.04373351f, -0.01194490f, -0.04605974f, 
    -0.04334575f, -0.02776566f, 0.01364436f, -0.02846842f, -0.00777433f, -0.00653750f, -0.02881027f, 0.01850764f, 
    0.01635469f, 0.01244425f, -0.04486244f, -0.00617119f, 0.03074371f, -0.00258598f, 0.00301078f, -0.02346521f, 
    -0.01945462f, 0.00041047f, 0.03850603f, -0.02275729f, 0.00442039f, 0.04646295f, -0.01028885f, 0.05136332f, 
    0.03962945f, -0.00939411f, -0.06293113f, -0.03088464f, 0.04670377f, -0.02119081f, -0.02084838f, 0.01676028f, 
    0.00865506f, -0.02060977f, -0.04497187f, -0.00619487f, -0.00183991f, 0.01345471f, -0.00060943f, 0.02859382f, 
    0.01278924f, -0.03431470f, -0.06648362f, 0.03328191f, -0.02752348f, -0.05863701f, -0.03625389f, -0.01255473f, 
    -0.00078366f, -0.04298037f, -0.05593576f, 0.04319223f, 0.01785748f, 0.04871693f, 0.03342259f, -0.04176302f, 
    0.00338220f, -0.05713607f, -0.04576663f, -0.02985447f, 0.02772064f, -0.05454697f, 0.04238731f, -0.00797537f, 
    -0.04194174f, 0.00820311f, -0.05426233f, 0.02977877f, -0.05877656f, 0.02220831f, 0.02287525f, 0.00645358f, 
    -0.02006170f, -0.02627710f, -0.01816731f, -0.05760225f, -0.02876631f, -0.02889687f, 0.03570974f, 0.01844919f, 
    0.02048926f, -0.05102989f, -0.06647973f, 0.03991880f, 0.01707518f, 0.01989776f, -0.00229501f, 0.04671510f, 
    0.05479211f, 0.02433435f, -0.01266424f, -0.03447937f, 0.02069883f, 0.00160049f, -0.04355258f, -0.00950607f, 
    0.00262350f, -0.00899243f, 0.00293879f, -0.01040543f, -0.02827721f, -0.03703247f, 0.00399611f, -0.01425532f, 
    -0.02327522f, -0.02968417f, 0.00375442f, 0.05256080f, 0.01354603f, 0.00688319f, -0.02275575f, 0.00251823f, 
    -0.02563406f, -0.01158076f, -0.04779933f, 0.02126379f, -0.02635683f, -0.05158703f, -0.01323581f, 0.01207112f, 
    0.03331846f, -0.04446957f, -0.01467973f, -0.06189623f, -0.01588877f, -0.00450793f, -0.02524372f, -0.05937798f, 
    -0.03840544f, 0.01233580f, -0.01919305f, -0.05034257f, 0.03334263f, -0.05973495f, 0.00446892f, -0.03210319f, 
    -0.00638312f, -0.01844156f, -0.04139604f, 0.03160755f, -0.01940644f, 0.00097501f, 0.00693132f, -0.04223266f, 
    -0.00699839f, 0.04054140f, 0.03970790f, -0.03494490f, -0.03940896f, 0.03525484f, -0.06546860f, 0.01824115f, 
    -0.02522030f, -0.00964496f, -0.03500284f, -0.01278515f, 0.01648836f, 0.00674160f, -0.03552696f, 0.01844555f, 
    -0.03949944f, 0.02176060f, -0.05809161f, 0.00840302f, 0.02331388f, -0.03510014f, 0.04895174f, 0.00193238f, 
    0.04401356f, 0.06349184f, 0.05165809f, 0.04440487f, 0.01740590f, -0.06238161f, -0.00824940f, -0.03604474f, 
    -0.00482802f, -0.04866380f, -0.02234812f, 0.02366683f, -0.02177552f, 0.03619236f, -0.04683251f, -0.03694745f, 
    0.02140969f, -0.00988807f, 0.04686345f, 0.03396302f, -0.00364789f, -0.01965574f, -0.05476166f, 0.05016199f, 
    -0.00242552f, 0.02603807f, -0.01675942f, 0.05819148f, -0.02690087f, 0.01250360f, -0.03976498f, 0.01777067f, 
    0.00845405f, 0.03314443f, 0.02730855f, 0.04612830f, -0.03701404f, -0.05623728f, -0.02094368f, 0.03119111f, 
    -0.01279783f, 0.02637749f, -0.06212015f, 0.00955566f, -0.06120275f, 0.01471387f, 0.04972001f, -0.04022599f, 
    -0.00625661f, 0.03855872f, 0.02472310f, 0.03343970f, -0.01853877f, 0.04232201f, 0.04044027f, -0.02777204f, 
    -0.03487813f, -0.03622037f, -0.02851032f, -0.02346415f, 0.00755327f, -0.02642393f, -0.02278707f, 0.01600290f, 
    -0.00870955f, 0.04482730f, -0.03234384f, -0.02341372f, -0.05201599f, -0.01532031f, -0.05922925f, -0.04741552f, 
    -0.00513242f, -0.02170086f, 0.00051470f, 0.13119479f, -0.07595938f, -0.09341657f, 0.05270461f, -0.25049317f, 
    -0.16391203f, 0.24858296f, 0.06167961f, -0.32742465f, 0.36977229f, -0.30350706f, -0.09153522f, 0.07770518f, 
    0.11766467f, 0.12603752f, -0.06829602f, 0.02620988f, 0.27361950f, -0.01767142f, 0.09263787f, 0.21318896f, 
    -0.11593996f, -0.28606898f, 0.03813581f, 0.30278602f, 0.07129857f, 0.20141518f, 0.10401761f, -0.12832709f, 
    -0.05485813f, -0.02001224f, -0.01891764f, -0.14405352f, 0.13497359f, 0.06555796f, -0.29735318f, 0.14990772f, 
    -0.06814958f, 0.16000266f, 0.14397284f, -0.06257465f, -0.09047849f, 0.34048602f, 0.21650785f, -0.40315485f, 
    -0.05455058f, 0.10006744f, -0.11590483f, 0.27150869f, 0.08308267f, 0.11091177f, -0.13706350f, -0.15841740f, 
    0.17665249f, -0.12612772f, 0.08075140f, 0.05229278f, 0.05737028f, -0.01295405f, 0.02070342f, 0.10179133f, 
    -0.01193919f, -0.47867966f, 0.15072691f, -0.19992039f, -0.08719351f, 0.19085474f, 0.06410327f, -0.18659361f, 
    -0.05483342f, -0.10987683f, -0.17112103f, -0.01360122f, 0.07058695f, -0.03999964f, 0.12498634f, -0.01102085f, 
    -0.32207468f, 0.08639894f, -0.16346091f, -0.07287859f, 0.05750103f, -0.00791553f, -0.10912462f, -0.00683017f, 
    0.13269049f, -0.14647402f, 0.05096591f, 0.08722591f, 0.10599189f, 0.16932327f, -0.09714130f, 0.10446318f, 
    -0.09853344f, 0.06548419f, 0.08952744f, -0.04942783f, -0.01596666f, -0.14652829f, -0.05662152f, -0.01136563f, 
    0.12694596f, 0.11699224f, -0.06625555f, -0.00535701f, 0.19772343f, 0.54185587f, 0.18049692f, 0.13424970f, 
    0.02531412f, -0.09591513f, -0.03696482f, -0.15926576f, -0.17232347f, 0.05606376f, -0.11659094f, 0.03857546f, 
    -0.03796795f, -0.00056007f, -0.04940510f, 0.10979613f, -0.04207164f, 0.08047525f, 0.06203462f, -0.18500589f, 
    -0.14122184f, -0.14819174f, -0.01497868f, 0.11860168f, 0.08337828f, 0.07864476f, 0.17580478f, -0.39839467f, 
    0.03712948f, -0.23903796f, 0.06388766f, -0.01737870f, 0.00698621f, 0.02263968f, 0.14191188f, 0.27998751f, 
    0.01727389f, 0.13088857f, -0.08727711f, 0.21687181f, 0.02814549f, 0.08033186f, -0.08967538f, 0.09152815f, 
    0.30773148f, 0.10262065f, 0.02110380f, -0.08071841f, 0.04126932f, -0.09038949f, 0.16185352f, 0.01138186f, 
    -0.08107901f, -0.28051916f, -0.04555818f, 0.01097515f, -0.62327838f, 0.19522740f, -0.10356979f, 0.07318384f, 
    0.12461271f, 0.22486685f, -0.03636830f, -0.19501381f, -0.15015443f, -0.12527840f, -0.08088581f, 0.10410126f, 
    0.16089579f, -0.09005536f, -0.11789582f, 0.06738828f, -0.17175783f, -0.20857623f, -0.04729915f, 0.14552303f, 
    0.01109929f, -0.03323184f, 0.00023554f, 0.06015457f, -0.17675653f, -0.01610458f, 0.12966843f, 0.00093638f, 
    -0.26871195f, 0.08960316f, 0.38525712f, -0.03679318f, 0.07421139f, 0.04670661f, -0.01900730f, 0.24080917f, 
    0.29408872f, -0.07686552f, 0.12287991f, -0.04474222f, 0.16147757f, -0.05509932f, -0.01362691f, -0.16894676f, 
    -0.36712304f, 0.06400952f, 0.12439306f, 0.06163104f, 0.11767043f, -0.14439043f, -0.20639277f, 0.14325425f, 
    0.01063947f, 0.34482595f, -0.20800669f, 0.19508465f, 0.07308352f, -0.11885402f, 0.06338190f, -0.08056147f, 
    -0.26024219f, 0.04741113f, 0.01827207f, -0.24783053f, 0.12802379f, 0.00377231f, 0.24002086f, -0.06423097f, 
    -0.13580751f, -0.01774986f, 0.13155863f, 0.28079009f, 0.26574937f, 0.21853153f, -0.06136732f, 0.15619351f, 
    0.06820438f, -0.03489824f, 0.03074108f, 0.03751093f, -0.07737775f, -0.18513803f, -0.10096502f, -0.11324834f, 
    0.09661146f, -0.19385991f, -0.03543122f, 0.08405204f, 0.17352192f, 0.30591786f, 0.07787911f, 0.03895125f, 
    0.00307608f, 0.11008270f, 0.05615393f, -0.24730569f, -0.03420154f, -0.08532293f, 0.11044475f, -0.07967183f, 
    -0.09308746f, 0.03977665f, -0.05320491f, 0.07281053f, 0.17033051f, 0.16799904f, -0.06140997f, -0.02433616f, 
    -0.40484071f, 0.04563945f, 0.08615653f, 0.08784468f, -0.01110452f, 0.20438489f, -0.26743418f, 0.01343913f, 
    -0.34206495f, -0.39170122f, 0.08804128f, 0.19024386f, -0.23267420f, -0.12222728f, 0.05771283f, -0.00970948f, 
    -0.22032827f, 0.09201957f, 0.05945783f, -0.02808303f, 0.01879529f, -0.02636898f, 0.09891669f, -0.10621712f, 
    0.16463087f, -0.06784197f, -0.71769631f, -0.92286742f, 0.04645639f, -0.26964831f, 0.10419204f, 0.05753594f, 
    -0.30805147f, -0.17717412f, -0.15720014f, -0.04306513f, 0.03502594f, 0.07283127f, -0.12448994f, 0.18725359f, 
    0.04308589f, -0.04758061f, 0.08579375f, 0.13158965f, -0.26857835f, -0.10581475f, 0.01273617f, 0.09719487f, 
    -0.06104527f, -0.02249504f, 0.07810563f, -0.10449418f, -0.05279612f, 0.18814340f, -0.06839818f, 0.01279402f, 
    0.01075247f, -0.10806756f, 0.14774916f, 0.12221543f, -0.07488627f, 0.01899583f, -0.28908771f, -0.18126541f, 
    -0.06239402f, 0.19768375f, -0.07237712f, 0.23558332f, 0.23786129f, 0.16313227f, -0.14730990f, -0.01537268f, 
    -0.18564123f, -0.16274318f, -0.28351310f, 0.05750731f, 0.02002464f, 0.02858924f, -0.13796209f, -0.18725787f, 
    0.11907265f, -0.00596603f, -0.06154946f, 0.00773108f, -0.11536720f, 0.03822754f, -0.07763874f, -0.09391806f, 
    0.26913059f, -0.04970661f, -0.18589622f, -0.02894740f, 0.03532179f, -0.20194463f, 0.08524888f, 0.06190649f, 
    -0.09201166f, 0.38961047f, -0.08925968f, -0.03824341f, 0.09820428f, -0.10813942f, -0.07082833f, 0.13207178f, 
    0.01111029f, 0.12108372f, 0.17600648f, 0.19582185f, 0.42332640f, -0.01035118f, -0.09434267f, -0.16870013f, 
    -0.02006967f, 0.03473154f, -0.08907516f, 0.00762949f, -0.10324497f, -0.07886221f, 0.02583911f, -0.04100367f, 
    -0.00343954f, 0.09614955f, 0.14201622f, -0.02770378f, -0.07088047f, -0.23057328f, 0.12078390f, 0.08903440f, 
    0.11182456f, -0.21056905f, 0.01576120f, -0.11216915f, -0.06218439f, -0.26564246f, -0.26605853f, -0.01845741f, 
    0.00170514f, 0.07142605f, 0.18930417f, -0.12241600f, 0.06450380f, 0.04050837f, -0.09083345f, -0.44085816f, 
    0.01729913f, 0.11100657f, 0.14320193f, 0.25011238f, -0.03712402f, -0.05106653f, 0.11395367f, -0.51634085f, 
    -0.39436892f, 0.18250182f, 0.16620576f, 0.19769870f, -0.10550707f, 0.08516204f, 0.09218954f, 0.09808983f, 
    -0.35729960f, 0.33559626f, -0.02875611f, -0.12953725f, -0.08756492f, -0.12486749f, -0.02071159f, -0.06937297f, 
    0.14129168f, -0.21802647f, -0.05443585f, -0.34312448f, -0.02708023f, -0.08547056f, -0.31281966f, 0.29209322f, 
    -0.04302012f, -0.22711658f, -0.24770774f, -0.09828883f, 0.03427970f, 0.08295628f, 0.22922300f, 0.08413136f, 
    0.07504150f, 0.05411753f, -0.00538738f, -0.12076749f, 0.12879118f, 0.09336423f, -0.09204914f, 0.00940619f, 
    -0.09113564f, -0.04604299f, 0.15481606f, -0.23711213f, 0.33920753f, -0.05306219f, 0.03113480f, 0.05103372f, 
    0.14208990f, 0.12062939f, 0.03765001f, 0.04773832f, -0.07698926f, 0.22289117f, -0.10021818f, -0.00122481f, 
    -0.05096552f, 0.15602374f, 0.13947982f, -0.15842332f, 0.09784971f, 0.17739925f, 0.07882441f, 0.11942610f, 
    -0.02590608f, 0.10171836f, 0.07184196f, 0.02551842f, 0.11627425f, 0.13320117f, -0.02595257f, -0.26189315f, 
    -0.24749857f, -0.11083491f, 0.07696698f, -0.02536173f, 0.19267845f, -0.25903404f, -0.10411454f, -0.05376972f, 
    -0.39548904f, 0.07053202f, 0.16888045f, -0.06655065f, 0.08124016f, -0.15036121f, 0.08958648f, -0.01645868f, 
    -0.11360580f, -0.31783953f, 0.33500108f, -0.30208266f, -0.22544682f, -0.18930197f, -0.03473471f, -0.14869180f, 
    -0.03417192f, -0.12013512f, 0.13921520f, -0.10843324f, 0.19501041f, -0.00836642f, -0.04971077f, 0.01415619f, 
    0.00179569f, -0.00973384f, 0.06700809f, 0.07177459f, 0.16759656f, -0.33424476f, -0.16658834f, 0.12976812f, 
    0.00051705f, -0.00058323f, -0.07088593f, -0.01778099f, 0.11570910f, 0.02726045f, 0.14109692f, 0.18731216f, 
    0.12319811f, 0.13954021f, 0.03358165f, -0.05244087f, 0.20518422f, 0.48529270f, 0.26199466f, 0.04696113f, 
    0.01231937f, -0.04712734f, 0.09879325f, 0.04220628f, -0.04290322f, 0.12512915f, 0.19229472f, -0.12452145f, 
    -0.02698340f, 0.01075057f, 0.10455539f, -0.10181738f, 0.07749098f, 0.18662640f, -0.01640014f, 0.32424039f, 
    -0.20583829f, -0.23615780f, -0.05367359f, -0.24244753f, -0.03757606f, 0.01108602f, 0.13932349f, -0.02325483f, 
    -0.08270390f, 0.06309059f, -0.00341335f, -0.04400463f, 0.18777518f, 0.05800717f, 0.01589392f, -0.02356240f, 
    0.20268643f, -0.30333197f, -0.19296232f, -0.23145775f, -0.12611382f, -0.01773855f, -0.04501821f, -0.02269319f, 
    -0.14946544f, -0.15247680f, -0.37028083f, -0.54677206f, -0.67983562f, -0.14454287f, -0.05808777f, -0.26785415f, 
    0.01594643f, 0.05539403f, 0.06992129f, -0.53420556f, -0.04384328f, -0.01172324f, 0.18489902f, 0.37371483f, 
    -0.02459949f, -0.05507844f, 0.05084108f, 0.07931607f, 0.07579532f, 0.08841593f, 0.06710766f, -0.01876477f, 
    0.05609683f, -0.03310085f, 0.12495057f, 0.03026793f, 0.08332612f, 0.09024677f, -0.18619463f, 0.08197383f, 
    0.20540157f, -0.05705702f, -0.03777152f, 0.36746347f, -0.00682843f, 0.03439900f, 0.28869897f, -0.40273243f, 
    -0.07146806f, -0.14319886f, -0.11971902f, -0.17400305f, 0.02511150f, -0.04495377f, 0.08296730f, 0.34271413f, 
    0.28097153f, -0.06201907f, -0.02517922f, -0.34560949f, -0.11949655f, 0.04405350f, 0.01951775f, 0.01191318f, 
    -0.18919380f, -0.21818353f, 0.17814377f, -0.01946127f, 0.00559684f, 0.24851307f, 0.14784536f, -0.05950797f, 
    0.10258650f, 0.07762340f, -0.00803792f, 0.05041543f, 0.10490276f, 0.01988843f, -0.01752574f, 0.10434965f, 
    0.12520556f, 0.02162649f, 0.16020246f, -0.18817349f, -0.11675420f, -0.08119268f, 0.08013150f, -0.04819502f, 
    0.11539033f, 0.08129694f, 0.21789970f, -0.12295915f, 0.19723329f, -0.18012255f, -0.07563563f, 0.08201834f, 
    0.07149044f, 0.07007846f, 0.11811228f, 0.07917335f, -0.63766223f, -0.16552269f, -0.64592469f, 0.04152208f, 
    0.07098587f, -0.24835137f, 0.01530475f, -0.15044248f, 0.23621120f, -0.20831233f, 0.28924662f, -0.14120586f, 
    -0.10739681f, 0.05489548f, -0.10419793f, 0.06254012f, 0.01491197f, -0.01122852f, -0.33798599f, 0.02629260f, 
    -0.08417891f, -0.17256129f, -0.01632708f, -0.29164258f, 0.01517321f, -0.04984837f, -0.01943350f, -0.17531946f, 
    0.35147628f, 0.10520469f, 0.07432511f, 0.00298099f, -0.06802845f, 0.06004675f, -0.10572974f, 0.20954303f, 
    0.09871311f, 0.09913141f, -0.07395381f, -0.17216721f, -0.12319374f, -0.27898207f, -0.16229126f, -0.09373054f, 
    0.02321162f, -0.25701553f, -0.07401606f, -0.11357192f, -0.06157000f, -0.11134304f, 0.00490689f, 0.09083106f, 
    0.06317805f, 0.11641935f, 0.11963541f, 0.35308218f, 0.06366946f, 0.01538947f, -0.10674830f, -0.00114163f, 
    -0.07074933f, -0.06429079f, 0.09883063f, -0.07275750f, -0.04638678f, 0.09696630f, -0.44325453f, -0.18824521f, 
    -0.26240265f, -0.17208204f, -0.16247800f, 0.02233843f, -0.06894206f, 0.15664375f, -0.26158676f, 0.13551801f, 
    0.24009965f, 0.17223617f, 0.02911451f, 0.12350745f, 0.22087783f, -0.18437818f, 0.22054328f, 0.32961816f, 
    -0.06914648f, 0.07675695f, 0.09463231f, 0.10809560f, -0.09063989f, -0.01899950f, -0.24839653f, -0.24304436f, 
    -0.35618189f, -0.05332237f, 0.09630925f, -0.08914581f, 0.05270004f, 0.03527901f, 0.18377922f, -0.15152468f, 
    -0.24636924f, -0.13832937f, -0.08001939f, -0.14833201f, 0.10944658f, -0.04835293f, 0.00624556f, -0.10078478f, 
    -0.03625502f, -0.14835472f, 0.04297536f, 0.05041517f, 0.01151096f, -0.06167084f, -0.11850133f, -0.06799041f, 
    0.08313574f, 0.20124438f, -0.06572720f, -0.05541290f, -0.27641615f, -0.15903500f, -0.11849850f, -0.14956822f, 
    -0.01774647f, 0.03813818f, -0.89427304f, -0.50554204f, -0.33001387f, -0.14204894f, 0.06244902f, -0.00587834f, 
    0.10147072f, 0.09919064f, 0.22209391f, -0.06834883f, -0.00006342f, -0.03031193f, -0.08368485f, -0.16384365f, 
    0.05429964f, 0.00885276f, -0.03994936f, 0.16679697f, -0.21492389f, -0.27526230f, -0.00006340f, 0.07989278f, 
    0.14503138f, -0.12441366f, 0.10509292f, 0.13349034f, 0.26765519f, 0.22374988f, 0.19924121f, -0.14114140f, 
    0.04998922f, 0.04374012f, -0.06031921f, -0.01083799f, 0.03333835f, 0.14028557f, 0.21644996f, -0.30071899f, 
    0.00177148f, 0.07401868f, 0.11828510f, 0.18869372f, 0.18041883f, 0.02754916f, -0.06593233f, 0.22207814f, 
    -0.00354511f, -0.16916145f, -0.15324597f, -0.03475251f, -0.01010794f, 0.00763801f, -0.02052446f, 0.15036158f, 
    0.01024022f, 0.01949738f, 0.01551383f, 0.01852900f, -0.04483654f, -0.02649946f, -0.01437393f, 0.02600298f, 
    -0.05478496f, 0.03526314f, 0.04119878f, -0.03910610f, 0.03432764f, 0.03843838f, 0.05830212f, 0.03001475f, 
    -0.04012512f, 0.01788584f, -0.06111396f, -0.05486869f, -0.01785051f, -0.00459955f, -0.02454662f, -0.01748596f, 
    -0.01369768f, 0.04071595f, -0.02512725f, 0.00698277f, 0.04549619f, 0.01540668f, -0.02314596f, -0.02550717f, 
    -0.00580403f, 0.04967512f, 0.00597314f, 0.00381986f, -0.03163738f, 0.02131240f, -0.06160213f, -0.01917340f, 
    -0.04588827f, -0.03950235f, -0.03513804f, -0.04079236f, 0.00062749f, 0.02390748f, -0.01422746f, 0.02510717f, 
    -0.02225865f, -0.02428841f, 0.01364078f, -0.05511638f, 0.01483217f, 0.04950995f, -0.01174901f, -0.02628985f, 
    -0.05351533f, -0.02054564f, 0.00753983f, 0.00482214f, 0.01115761f, -0.02242179f, 0.03658608f, 0.01071636f, 
    -0.04339869f, -0.01965257f, 0.01412746f, 0.01798687f, 0.00439569f, 0.03318153f, -0.00552960f, 0.01436199f, 
    -0.00251027f, -0.04582134f, -0.05243251f, -0.01083144f, 0.03339538f, -0.00347810f, -0.04272708f, -0.06370724f, 
    -0.03252780f, 0.01982085f, 0.02262921f, 0.01940868f, -0.05114454f, -0.01446205f, -0.02212652f, 0.05085615f, 
    0.02913886f, -0.02312542f, -0.00896764f, -0.05124165f, -0.01132686f, 0.03884610f, -0.05436013f, 0.03572148f, 
    0.01640597f, -0.00761761f, 0.01817489f, 0.02581399f, 0.00588075f, -0.04551090f, -0.05005123f, 0.05068277f, 
    -0.05167843f, -0.02298986f, 0.01008173f, -0.06742570f, 0.02367144f, -0.04723541f, -0.02963037f, 0.02601534f, 
    -0.01497942f, 0.04512106f, 0.04512124f, 0.01855264f, -0.00147867f, 0.04512004f, -0.04264706f, 0.01698696f, 
    -0.03241418f, -0.00217353f, -0.05447077f, -0.01141220f, -0.03754418f, 0.00323330f, -0.01854178f, 0.03532231f, 
    -0.05165184f, 0.03601561f, 0.01159337f, -0.00902756f, 0.02368050f, -0.05141263f, -0.04161929f, -0.05579115f, 
    0.04854180f, -0.02343941f, -0.03457299f, -0.05196343f, -0.03648420f, 0.00765384f, 0.03660328f, -0.03789511f, 
    -0.00963170f, -0.01723127f, -0.00602143f, -0.02040753f, 0.04120061f, -0.02595410f, -0.01490442f, -0.04989340f, 
    0.02774690f, -0.02408964f, -0.00738331f, 0.00302904f, -0.05119051f, -0.00038887f, 0.04339653f, -0.03139353f, 
    -0.02753924f, -0.00522735f, -0.01920481f, -0.00609703f, -0.06198997f, -0.01997773f, -0.00406342f, -0.05868282f, 
    0.04217751f, 0.02676735f, 0.01998632f, 0.01755887f, 0.04397744f, 0.00527403f, 0.00501138f, 0.03658973f, 
    -0.05904358f, 0.04296608f, -0.04622572f, -0.03813545f, -0.04013341f, 0.03749606f, -0.02647065f, -0.00579491f, 
    -0.05081297f, 0.01821057f, -0.05067568f, 0.04838926f, -0.04525875f, -0.01627135f, -0.00332240f, 0.02097013f, 
    -0.04468204f, -0.00668358f, 0.05289226f, -0.02786328f, 0.05340124f, -0.03830399f, 0.00037361f, -0.03876366f, 
    -0.03021208f, 0.04891908f, -0.01013514f, -0.01500797f, -0.00626444f, -0.00313183f, -0.03859267f, 0.01219476f, 
    -0.04023078f, 0.00454375f, 0.00696419f, -0.06262032f, -0.02978620f, 0.03138298f, 0.04875099f, -0.06241273f, 
    0.02475345f, -0.01922167f, -0.04810454f, 0.01311347f, 0.04984823f, 0.00570748f, 0.03657800f, -0.02383396f, 
    0.02356089f, 0.00492579f, -0.04544313f, -0.00652715f, 0.01291189f, -0.02728843f, 0.03240434f, -0.04804061f, 
    -0.05790002f, -0.02192373f, 0.04631570f, 0.03308633f, -0.02566922f, 0.02519741f, -0.03992110f, -0.04407967f, 
    0.03528219f, -0.06232489f, -0.01329640f, -0.01292311f, -0.03904164f, 0.03763272f, -0.03612955f, 0.02089864f, 
    -0.03905087f, -0.00814491f, -0.05786177f, -0.00949142f, -0.06371145f, 0.03964905f, -0.02476038f, -0.05969617f, 
    0.00961278f, -0.00680286f, -0.05452647f, -0.00547377f, 0.00334745f, -0.02973592f, -0.00160940f, -0.02454801f, 
    -0.00852903f, -0.03840045f, -0.00651661f, -0.02083210f, -0.04729689f, -0.00082826f, -0.03972737f, 0.02313750f, 
    0.04875477f, -0.03597577f, 0.04317856f, 0.00212526f, -0.01299888f, -0.03161160f, 0.03040894f, -0.01117835f, 
    0.02619427f, -0.03140653f, 0.00024646f, -0.04245497f, -0.03272225f, -0.02641107f, -0.05476584f, -0.03270044f, 
    0.03960329f, -0.04096765f, 0.03751126f, -0.00537899f, 0.00335578f, -0.03913031f, 0.04092327f, -0.01443274f, 
    0.03681689f, 0.03051272f, 0.02209055f, -0.03505597f, 0.02714596f, -0.06109928f, -0.03681889f, 0.04613169f, 
    0.03510148f, 0.01757365f, -0.03007346f, -0.02589711f, -0.02508004f, -0.02780658f, 0.04002455f, -0.06715238f, 
    -0.05050163f, -0.01053086f, -0.03345204f, 0.01100000f, 0.00512368f, 0.03759797f, 0.01983537f, -0.06815970f, 
    -0.04463298f, -0.01861921f, -0.06485204f, -0.02469938f, 0.04772525f, 0.01013070f, 0.00054963f, -0.02726479f, 
    0.03754619f, -0.01936200f, 0.00126835f, -0.05796324f, -0.00339488f, -0.01017122f, 0.03024692f, -0.02674564f, 
    0.04574454f, -0.00788777f, 0.01787029f, 0.00364614f, -0.05281494f, -0.02912273f, -0.05135450f, -0.05103587f, 
    0.04981350f, -0.01311775f, -0.06107031f, 0.02396162f, -0.01497188f, 0.04688307f, -0.06217837f, -0.00083686f, 
    -0.00392419f, 0.03506440f, 0.02696980f, 0.03333561f, -0.03276918f, 0.03620174f, -0.01784514f, 0.01441512f, 
    -0.02684724f, -0.02784913f, 0.00792617f, 0.02574369f, -0.02837802f, 0.03262353f, 0.03528224f, -0.00233689f, 
    0.00576821f, -0.04072493f, -0.00037135f, -0.04721096f, 0.00330727f, 0.02794135f, 0.00949043f, 0.00179034f, 
    0.03004248f, 0.04249229f, 0.00490285f, 0.03590536f, -0.02349774f, -0.03951786f, -0.03980543f, 0.04520489f, 
    -0.04793873f, -0.00779411f, 0.03151776f, -0.00033951f, -0.05859188f, 0.00486325f, -0.03339644f, 0.04393012f, 
    -0.00908635f, -0.04329488f, -0.01662206f, -0.03756002f, -0.03698687f, -0.06199094f, 0.03336721f, -0.04203938f, 
    0.03057736f, -0.05858017f, 0.01925563f, -0.06590847f, -0.01709285f, -0.05873497f, -0.03694222f, 0.02437966f, 
    0.03997226f, 0.00247156f, -0.05588438f, -0.02436518f, -0.04540029f, -0.05628863f, -0.02793451f, 0.05310912f, 
    -0.03133409f, -0.05989001f, 0.02971704f, 0.00760302f, -0.04494707f, -0.04157706f, 0.04401678f, 0.01870514f, 
    -0.01452130f, 0.03761043f, -0.03505881f, -0.01676111f, -0.06024827f, -0.02177703f, 0.04121913f, 0.01265728f, 
    -0.05283747f, -0.05213953f, 0.04062442f, -0.06036210f, -0.05440297f, -0.01060355f, -0.00683652f, 0.03577932f, 
    -0.03585272f, -0.04312200f, 0.03694953f, -0.04401056f, -0.05168369f, -0.04247352f, 0.02703885f, -0.01177304f, 
    -0.02827166f, -0.06002835f, -0.02778966f, 0.03190583f, 0.02939156f, 0.02505380f, 0.04264266f, -0.05735156f, 
    0.02369968f, 0.02882265f, -0.05825215f, 0.00839137f, 0.04802751f, -0.04566088f, 0.01125281f, -0.02832731f, 
    -0.01510667f, -0.00211380f, 0.01199708f, -0.04785524f, 0.00696591f, 0.00675266f, 0.02421575f, 0.01559135f, 
    0.04811954f, -0.01214323f, 0.01642361f, -0.04659174f, 0.02364862f, -0.00666803f, 0.02102578f, 0.04121468f, 
    -0.01856269f, 0.00571130f, -0.02722017f, 0.02989657f, -0.04761837f, -0.00155065f, -0.02182957f, 0.01213397f, 
    -0.03378595f, -0.02300311f, -0.05262933f, 0.01776452f, 0.00844522f, -0.02351452f, 0.01531007f, -0.01661576f, 
    -0.03717890f, 0.05220392f, -0.06612541f, 0.00662039f, 0.00284927f, -0.02987379f, 0.00715450f, 0.00871602f, 
    -0.04594447f, 0.02606986f, 0.03773292f, -0.06640848f, 0.03972436f, 0.04388473f, 0.05114118f, 0.05036823f, 
    0.05808464f, -0.00234400f, 0.04679388f, 0.02178206f, -0.04199405f, -0.05683516f, -0.03797475f, -0.04649528f, 
    -0.03782486f, 0.04716615f, -0.03467863f, 0.02952858f, -0.05642390f, 0.00516221f, -0.04981872f, 0.01671135f, 
    0.03302769f, -0.02843237f, -0.01949030f, -0.04164228f, 0.00262251f, 0.04792827f, 0.02058584f, 0.03664126f, 
    -0.01963108f, 0.03981115f, -0.01341116f, 0.04467658f, -0.03405865f, -0.06196443f, -0.02126046f, 0.03556871f, 
    -0.04105124f, -0.00481336f, 0.02189069f, -0.02792790f, -0.05202829f, -0.01473470f, -0.01635300f, -0.06645580f, 
    -0.05715591f, -0.03822569f, 0.00771914f, -0.00703814f, -0.01531957f, -0.01768423f, 0.03576491f, -0.01839627f, 
    0.01913264f, -0.04899982f, 0.04018405f, -0.03426003f, 0.03995451f, -0.04699517f, 0.04968162f, -0.01290936f, 
    0.01340360f, 0.00584127f, -0.01302626f, -0.02458322f, 0.02330819f, -0.06253188f, 0.02970085f, -0.01732483f, 
    -0.09005821f, -0.08523902f, 0.00369639f, -0.06726296f, -0.08265460f, 0.16490585f, 0.08542567f, -0.16265418f, 
    -0.02424574f, 0.20281897f, -0.20947804f, -0.43615115f, -0.42402458f, -0.24990638f, -0.02658094f, 0.15490310f, 
    -0.07267699f, 0.04721416f, 0.25792387f, -0.06891374f, -0.37884280f, -0.09988014f, 0.03441702f, -0.00784510f, 
    -0.13339697f, 0.02301024f, -0.04179395f, 0.76312423f, -0.68436754f, -0.60859454f, 0.12558667f, 0.00793530f, 
    -0.03238085f, -0.00944421f, -0.11978912f, -0.11614045f, -0.15067933f, -0.00195792f, 0.17729545f, -0.04781353f, 
    0.07036301f, 0.01750630f, 0.10830224f, -0.02966524f, 0.02585549f, 0.63456875f, -0.14915179f, 0.17313090f, 
    -0.08252690f, 0.21286321f, 0.06802753f, 0.07819192f, 0.04324483f, 0.16720986f, 0.07214698f, -0.32429478f, 
    0.08923107f, -0.07613833f, -0.16123532f, -0.15585411f, -0.03445721f, 0.11422817f, 0.23326188f, 0.06658456f, 
    0.06836896f, 0.07234157f, -0.08738867f, -0.12642075f, -0.04306522f, 0.16013949f, 0.03354495f, 0.14533766f, 
    0.39919767f, 0.01877595f, 0.05067350f, 0.11220765f, 0.06788192f, 0.04170588f, -0.03036831f, 0.00552386f, 
    -0.01901103f, 0.16179109f, 0.03347305f, 0.07323603f, 0.02600164f, 0.16628212f, 0.03149816f, -0.06728454f, 
    -0.04575166f, -0.00901908f, -0.38241640f, -0.00499120f, 0.08626008f, 0.04765725f, 0.05895538f, 0.06545171f, 
    0.10745011f, 0.03938476f, 0.15691018f, 0.10420865f, -0.10390094f, -0.09680907f, -0.05479307f, -0.02916648f, 
    0.15019974f, 0.12651300f, 0.06084972f, -0.05084384f, 0.26369935f, -0.57767045f, 0.01560869f, -0.12313229f, 
    0.05792283f, 0.00044050f, -0.11305836f, 0.02462551f, -0.03038123f, 0.06149330f, -0.61009306f, -0.09699664f, 
    -0.19367197f, 0.11828839f, 0.14139538f, 0.00341782f, -0.00191995f, -0.00634504f, 0.40101570f, -0.54035056f, 
    -0.37464327f, -0.13409257f, -0.03465170f, -0.05364754f, 0.00098344f, -0.02847273f, -0.02809464f, 0.09643357f, 
    0.09780845f, 0.03989703f, 0.07382852f, -0.28256702f, 0.06756472f, -0.02178201f, 0.02227223f, 0.18281727f, 
    0.05645440f, 0.11202134f, 0.14289403f, -0.00233439f, 0.01139183f, -0.15595017f, -0.04170971f, -0.13327193f, 
    -0.03332388f, 0.04926871f, -0.00912876f, 0.20365064f, -0.14301690f, -0.02886603f, -0.18182932f, 0.06652113f, 
    0.08522777f, -0.08809032f, -0.09848029f, 0.16400868f, 0.05074348f, -0.00273511f, 0.03583895f, 0.09978346f, 
    -0.08110233f, 0.02128963f, 0.07268096f, 0.04948848f, 0.13168766f, -0.01857293f, -0.17294522f, -0.07537306f, 
    0.10263322f, -0.07256772f, -0.08653594f, -0.11354043f, 0.24808134f, -0.00359400f, -0.30260822f, 0.10905810f, 
    0.13204484f, 0.07675512f, -0.21041255f, -0.04259463f, -0.03091133f, 0.53913224f, -0.23694499f, -0.75818330f, 
    0.05593016f, -0.09729618f, 0.16077757f, 0.17751114f, -0.04116030f, 0.02231831f, 0.13427620f, -0.28803244f, 
    0.30970782f, 0.00785650f, -0.06446006f, 0.15043305f, -0.07563211f, 0.00646451f, -0.07993589f, 1.14483190f, 
    -0.48565263f, -1.04658937f, -0.09420907f, -0.08957837f, 0.03490058f, -0.06344586f, 0.00635961f, -0.01438395f, 
    -0.17164579f, -0.14021201f, 0.15028481f, -0.02676235f, -0.21705902f, 0.30204985f, 0.02249092f, 0.09999821f, 
    0.02625330f, -0.12054747f, 0.02371295f, 0.19043846f, 0.00713549f, -0.00215388f, -0.03918372f, 0.10998413f, 
    -0.01782330f, 0.08325204f, -0.24405426f, -0.04156386f, -0.10186026f, -0.10182586f, -0.06619302f, -0.00550986f, 
    0.07947475f, 0.09943528f, -0.02347615f, 0.16095315f, 0.12394802f, -0.09608335f, -0.49562934f, -0.40411004f, 
    -0.10984829f, 0.08555227f, -0.07415256f, 0.00151532f, 0.51845080f, -0.50251490f, -0.00098316f, 0.00256576f, 
    0.01065459f, -0.02450714f, 0.05219097f, 0.01249895f, -0.03913486f, 0.20962635f, 0.06319230f, 0.13761286f, 
    -0.01728988f, -0.07126496f, -0.14211698f, -0.10218373f, 0.20017289f, 0.04928549f, -0.07384658f, -0.01823017f, 
    -0.13131912f, 0.14424887f, 0.07282218f, 0.13122608f, 0.02555546f, -0.09860674f, 0.06832817f, -0.01311721f, 
    0.10046086f, -0.13464394f, 0.10439403f, 0.05328738f, 0.08794476f, 0.03977475f, -0.01841230f, -0.02868932f, 
    -0.02093255f, 0.08861322f, 0.03576130f, 0.02201525f, -0.21096963f, -0.18554954f, -0.05305453f, 0.10411912f, 
    0.01536380f, -0.16122586f, -0.26754126f, 0.15602979f, 0.14365241f, -0.01463178f, 0.31040004f, -0.32158345f, 
    -0.18696071f, -0.04851323f, 0.01378574f, 0.34589651f, 0.11001918f, -0.04289769f, 0.04586817f, 0.02237969f, 
    0.03946456f, 0.02369753f, -0.06002503f, -0.20371704f, 0.03915706f, 0.26511735f, -0.09175891f, 0.00128508f, 
    -0.00316705f, -0.02160920f, 0.05799463f, 0.03836377f, -0.00758891f, -0.16163124f, 0.01280002f, -0.15777576f, 
    -0.00218857f, -0.07772605f, 0.00665795f, -0.12281973f, 0.14441507f, -0.11397055f, 0.09779288f, -0.27207166f, 
    0.16299489f, 0.02368807f, 0.13045867f, 0.24112546f, -0.10691054f, -0.13407049f, 0.08074264f, 0.05891116f, 
    -0.00634893f, 0.14299355f, -0.02061197f, -0.10990007f, 0.02405172f, -0.32076627f, -0.17548993f, 0.00143256f, 
    -0.01913667f, 0.06104794f, 0.13939187f, -0.03640498f, 0.01691506f, -0.19885713f, -0.05605754f, 0.01094618f, 
    -0.01169293f, -0.11742364f, 0.10550619f, 0.00831404f, 0.12830245f, 0.03337045f, -0.10585655f, -0.02142053f, 
    0.22644965f, -0.00522848f, -0.15066637f, 0.21321416f, -0.13206117f, -0.04769395f, 0.02336157f, 0.06377701f, 
    -0.10829911f, 0.04637421f, -0.01546332f, -0.24128412f, -0.53559142f, 0.05247941f, 0.09678378f, 0.06583852f, 
    -0.07044744f, -0.06006083f, -0.07241102f, 0.07102662f, -0.05971250f, -0.13213830f, -0.09290733f, 0.00766738f, 
    -0.00600257f, -0.01827564f, 0.21391006f, 0.16379808f, -0.04480654f, 0.18458889f, 0.21676691f, 0.05733698f, 
    0.06070225f, 0.07353041f, 0.13110204f, 0.06455394f, 0.00831080f, 0.27198839f, 0.00660463f, -0.11501933f, 
    -0.04653846f, -0.11647459f, 0.01094576f, 0.08485182f, -0.01683784f, 0.02732175f, 0.09919562f, -0.20780745f, 
    -0.30681801f, -0.06165892f, -0.08012062f, 0.06550684f, 0.00209930f, 0.05650007f, -0.06533661f, 0.01543565f, 
    -0.16382945f, -0.09494299f, 0.07217214f, -0.02285654f, -0.04823127f, -0.21063586f, -0.18988915f, -0.38596180f, 
    -0.13431512f, -0.16897832f, 0.06018322f, -0.00909138f, 0.08617111f, 0.06888267f, -0.13710108f, -0.24212027f, 
    -0.20624197f, 0.05691887f, 0.02193214f, 0.05047679f, -0.20799764f, -0.01491852f, -0.03096104f, 0.00825507f, 
    0.19851713f, 0.15918130f, 0.06121597f, -0.17049399f, 0.06793217f, 0.06116894f, 0.00634447f, 0.00822140f, 
    -0.16356848f, -0.18225354f, -0.03377589f, -0.05954547f, -0.05849627f, 0.10041087f, -0.18154617f, 0.00198163f, 
    -0.20802200f, 0.11246142f, -0.18359096f, 0.02228750f, -0.05618083f, -0.05468803f, 0.40049091f, 0.06228103f, 
    0.14370741f, -0.11854252f, -0.02234896f, 0.11189917f, 0.18343163f, -0.22378229f, 0.00487963f, 0.04085394f, 
    0.10625494f, 0.05728503f, 0.06801517f, 0.07316221f, 0.11032114f, -0.02391460f, 0.26196057f, 0.03019162f, 
    0.14231314f, 0.12945513f, 0.04292333f, 0.05016295f, -0.04157052f, -0.13635322f, -0.17224059f, -0.00209614f, 
    -0.03984856f, -0.32162288f, 0.10455026f, -0.05955841f, -0.08901829f, 0.04343092f, -0.07819917f, 0.13740970f, 
    0.03365183f, -0.00091145f, -0.07874097f, -0.08831843f, 0.20875560f, 0.23217666f, -0.00646779f, -0.24812657f, 
    0.21232623f, -0.13362378f, -0.13867238f, -0.00486266f, -0.00981256f, 0.00492426f, -0.02132674f, -0.18416221f, 
    0.13792978f, 0.00500646f, -0.02743659f, -0.02000684f, -0.02810918f, 0.05107090f, 0.08882743f, 0.04548645f, 
    0.21626195f, 0.09467412f, -0.04791852f, -0.02049842f, -0.26054913f, 0.08640119f, 0.09261185f, 0.00868128f, 
    0.11307858f, -0.21329027f, -0.12769760f, -0.02011277f, -0.05519151f, 0.18414520f, 0.19116837f, 0.06103797f, 
    0.20461975f, 0.26565042f, 0.11077397f, 0.12583329f, 0.10801303f, -0.35744905f, -0.07339406f, 0.20190194f, 
    0.06581286f, 0.00897320f, 0.16052160f, -0.18858270f, -0.10251550f, -0.17613493f, -0.15547535f, 0.01501304f, 
    0.33424667f, -0.01293730f, 0.44484451f, 0.03326004f, 0.01382931f, -0.07133289f, 0.28568605f, -0.27567473f, 
    -0.09504881f, 0.18695478f, 0.08667543f, 0.11156476f, 0.11273438f, -0.37528890f, 0.07708635f, 0.04167623f, 
    0.00818884f, 0.04161614f, -0.00801781f, -0.01119705f, -0.05647823f, -0.02098108f, -0.05919322f, 0.00453171f, 
    -0.00582028f, 0.02417416f, -0.01634398f, 0.01490887f, 0.01483190f, -0.02695740f, 0.01629287f, 0.00444899f, 
    -0.04290003f, 0.03278825f, -0.01868272f, -0.03277256f, 0.04582481f, -0.05436263f, 0.03882807f, 0.04747037f, 
    -0.00970411f, 0.02521978f, 0.04140074f, 0.02118991f, -0.03440681f, -0.01523138f, 0.01935711f, -0.03986996f, 
    -0.06066183f, -0.00051588f, -0.04216379f, 0.01391772f, 0.01070780f, 0.00359091f, -0.04531313f, 0.02844025f, 
    0.04037920f, -0.02657220f, -0.01248002f, 0.00452315f, -0.04692539f, 0.00376064f, -0.03171645f, -0.02690910f, 
    0.03883525f, 0.03284858f, -0.01359087f, 0.00838477f, -0.02911500f, -0.00542438f, 0.03318415f, 0.04234939f, 
    0.00867389f, -0.03598921f, 0.01149991f, 0.05046403f, -0.03687865f, 0.05069278f, 0.01040054f, 0.02181478f, 
    0.03798931f, -0.05068496f, -0.00168282f, 0.00814793f, -0.04988926f, 0.01609096f, 0.03581135f, -0.06510099f, 
    -0.02237184f, -0.02950272f, 0.01377585f, -0.04387666f, 0.00995547f, -0.01839494f, -0.00698381f, -0.01219298f, 
    0.03621549f, -0.04361012f, 0.01959325f, 0.00740749f, -0.06734835f, -0.01126704f, 0.05264387f, 0.04028338f, 
    -0.05904157f, 0.01304915f, -0.05779635f, 0.01777795f, -0.01587850f, -0.04645333f, -0.02583113f, -0.03913951f, 
    0.02083590f, -0.04209148f, 0.01281430f, -0.01516279f, -0.04029923f, 0.00270198f, 0.03762455f, -0.06352015f, 
    -0.05581345f, -0.00660540f, 0.01197174f, -0.02943366f, -0.01694963f, 0.00912705f, 0.00311198f, 0.01643104f, 
    -0.00029574f, 0.00717541f, 0.02697724f, -0.03405463f, -0.05044118f, -0.01905327f, 0.05570969f, -0.02631477f, 
    -0.02569383f, -0.04732894f, -0.00195376f, 0.03520515f, -0.03417465f, 0.02035086f, -0.03974006f, -0.04717157f, 
    -0.02800882f, -0.02371922f, -0.02935162f, -0.03881761f, 0.01280109f, 0.03980191f, -0.01771529f, 0.05506745f, 
    0.04139236f, -0.03302068f, -0.03901827f, -0.05303835f, -0.03650729f, 0.00193263f, 0.04552987f, -0.03295455f, 
    0.01884883f, 0.04682422f, 0.01305728f, 0.04716222f, -0.04480616f, -0.02889234f, -0.03293414f, -0.05751099f, 
    -0.06672328f, 0.02365341f, 0.01252390f, 0.02193226f, -0.00279704f, 0.01984117f, 0.01329485f, -0.00853629f, 
    0.03013247f, -0.04935488f, -0.02368205f, -0.04398675f, -0.03860341f, -0.03589405f, -0.01215442f, 0.03696740f, 
    0.00862279f, -0.04473502f, -0.05270796f, -0.03336290f, 0.05592570f, -0.03734945f, 0.01182542f, 0.01113157f, 
    0.01915074f, 0.02026946f, 0.02856717f, 0.03766677f, -0.02407258f, -0.02702037f, 0.03442344f, 0.01651925f, 
    0.00515435f, -0.03689449f, -0.03074386f, -0.04264342f, 0.02702882f, 0.04410480f, 0.00000993f, -0.00409666f, 
    -0.02772149f, 0.03354202f, -0.00106452f, 0.01052479f, -0.06283090f, -0.06548723f, 0.01223085f, 0.00455895f, 
    0.02441604f, -0.05530120f, -0.03574183f, 0.03589176f, -0.02038592f, 0.03168953f, 0.02897931f, -0.04794702f, 
    0.01757268f, 0.04311705f, 0.02343540f, -0.06098203f, -0.03483817f, 0.01879808f, -0.05767705f, 0.02353069f, 
    -0.04027798f, -0.03607706f, 0.03128641f, -0.02012053f, -0.01923775f, -0.05485985f, -0.04792413f, 0.00790159f, 
    -0.01094143f, -0.01823880f, -0.02153690f, 0.05340251f, 0.03818426f, -0.00747693f, 0.00196363f, -0.04922072f, 
    -0.00320164f, -0.00146062f, 0.01950968f, 0.05771283f, -0.00889781f, 0.01431456f, -0.00921256f, 0.00579770f, 
    0.03270574f, -0.05429658f, -0.02743404f, -0.01089975f, -0.04721092f, 0.02409311f, 0.04100130f, -0.00243636f, 
    0.03392817f, 0.04722006f, 0.02502990f, -0.03177299f, 0.03136470f, 0.02183504f, -0.01605876f, 0.03573842f, 
    0.05049939f, -0.02073493f, -0.03341362f, 0.02359601f, 0.00693394f, 0.02495740f, -0.03351451f, -0.06422366f, 
    0.00710458f, 0.01888192f, 0.03673145f, 0.03279515f, -0.04649774f, -0.06094801f, -0.00307213f, -0.00211205f, 
    -0.05785429f, 0.03505648f, 0.00457403f, -0.04743809f, 0.03638672f, 0.05067103f, -0.02981721f, 0.03407958f, 
    -0.00208835f, -0.04130806f, -0.01797279f, -0.06339461f, 0.03793446f, -0.01211510f, -0.02938198f, -0.05289156f, 
    0.01974944f, -0.00930902f, 0.02771928f, 0.03407209f, -0.02415709f, -0.01711263f, -0.02585092f, -0.05977137f, 
    -0.05007496f, -0.06075466f, 0.04496677f, -0.03300076f, 0.01491870f, -0.05567059f, 0.01498331f, 0.05638376f, 
    -0.04670676f, -0.00847583f, -0.06555382f, -0.01913949f, -0.02586361f, 0.05046796f, -0.03324657f, -0.04079877f, 
    -0.04320518f, -0.06133514f, -0.00549128f, -0.05014403f, -0.03713838f, -0.02402330f, -0.05036350f, -0.01475632f, 
    0.00745404f, 0.02786351f, 0.05093495f, -0.04513781f, -0.01678558f, 0.03216311f, -0.03501114f, 0.02351265f, 
    0.05092934f, -0.00254086f, -0.03891376f, 0.00093967f, -0.06433842f, 0.04773725f, -0.06224852f, 0.04036259f, 
    -0.02723380f, 0.04387016f, 0.04971772f, 0.02806505f, -0.00278702f, 0.04875391f, -0.05789183f, 0.04124829f, 
    -0.04728776f, -0.03383240f, 0.04329900f, 0.01410135f, -0.06157496f, -0.00369210f, -0.00826083f, -0.00135472f, 
    -0.02742274f, -0.01133685f, -0.01528490f, 0.03513527f, 0.00359412f, -0.02038601f, -0.00562411f, -0.05833421f, 
    0.00053578f, -0.01043309f, 0.00749039f, 0.01295503f, -0.06313512f, -0.06252099f, 0.02014806f, -0.06304438f, 
    0.01862193f, 0.02240679f, -0.05219922f, 0.02702921f, 0.03159182f, -0.06504732f, -0.02741018f, -0.01178491f, 
    0.00063319f, -0.00911529f, 0.04224509f, 0.03781569f, 0.00499459f, 0.04237945f, -0.02683315f, 0.01725892f, 
    -0.01603663f, -0.00889061f, 0.01257757f, -0.00496404f, -0.00335584f, -0.05242367f, -0.04340633f, -0.02611202f, 
    0.02127038f, 0.00929781f, -0.00307345f, -0.03312073f, 0.00712605f, -0.03072826f, -0.03343085f, -0.03871157f, 
    0.03058910f, -0.03914435f, -0.06216635f, -0.04796873f, -0.02530008f, -0.05284887f, 0.02343898f, 0.00487933f, 
    -0.02682863f, -0.01211063f, -0.06080773f, 0.02942963f, -0.04252748f, 0.00719754f, 0.00154162f, 0.04992678f, 
    0.03746329f, -0.06584159f, -0.01751615f, -0.04312855f, 0.00081210f, 0.01085945f, 0.03396486f, 0.04546880f, 
    0.03906297f, -0.01534283f, 0.00028316f, -0.02501477f, -0.00743350f, 0.03000564f, -0.03838302f, -0.03653929f, 
    0.00494870f, 0.00470865f, 0.04479312f, 0.04669688f, -0.01283895f, 0.05098685f, -0.00915396f, -0.01318951f, 
    0.00944998f, -0.02511570f, -0.04949227f, -0.01769936f, 0.03307302f, -0.00343515f, -0.05901357f, 0.00019347f, 
    -0.02199866f, 0.00168616f, -0.04915956f, -0.00473336f, -0.03426375f, -0.03558558f, 0.02817109f, 0.04262374f, 
    0.03072388f, -0.03402968f, 0.01145766f, -0.01688905f, -0.03596891f, -0.02635315f, -0.00820088f, -0.00361388f, 
    -0.02862081f, 0.01111251f, 0.01356080f, -0.06333356f, -0.04415955f, -0.02398752f, 0.05184548f, 0.03718840f, 
    -0.03775942f, -0.03139523f, -0.01536951f, 0.03636011f, 0.01576621f, -0.00468073f, -0.00096840f, -0.03713365f, 
    -0.05997645f, 0.00934605f, 0.03459354f, 0.03855715f, -0.04739948f, 0.00326562f, -0.06048258f, -0.00025197f, 
    -0.03686327f, -0.01012116f, 0.01565968f, -0.02484193f, -0.05866086f, -0.06411362f, 0.03180598f, 0.04178628f, 
    0.02347493f, -0.04645675f, 0.00580683f, -0.05028099f, -0.00765022f, -0.00314233f, -0.03898080f, 0.02840148f, 
    -0.00372962f, -0.02430391f, -0.04807384f, 0.01045415f, -0.06290149f, 0.01974071f, 0.01787380f, -0.00619779f, 
    -0.06480984f, 0.03501982f, -0.05713731f, -0.02762594f, -0.04458765f, -0.02408592f, -0.04237061f, -0.04595262f, 
    -0.03986904f, -0.03954849f, 0.03729877f, -0.04911665f, 0.03255366f, 0.02466219f, 0.03745830f, -0.04301229f, 
    0.03466212f, -0.03859860f, -0.05251406f, -0.00400146f, 0.04368495f, 0.01119793f, 0.02716509f, -0.05267369f, 
    0.00251106f, 0.00993260f, 0.00115751f, 0.03605044f, 0.02863514f, -0.02348332f, -0.01703778f, -0.04599570f, 
    0.01855204f, 0.03935894f, -0.00829168f, 0.03478698f, 0.04431004f, -0.03472930f, 0.04937078f, 0.05162420f, 
    -0.01830488f, -0.01417222f, -0.03073099f, -0.00672955f, 0.02886157f, -0.05757683f, 0.00381476f, -0.01664940f, 
    -0.00367675f, 0.02021010f, -0.03282826f, -0.04103194f, -0.04850719f, 0.03488084f, 0.02889643f, 0.04871366f, 
    -0.04775555f, 0.02494754f, -0.02918520f, -0.04297656f, 0.04262124f, -0.05202432f, -0.06105020f, -0.05709825f, 
    0.07765199f, 0.04330599f, 0.07195306f, 0.05163840f, -0.02512037f, -0.07210168f, -0.06206799f, -0.00096560f, 
    0.13127527f, -0.70519996f, 0.15768239f, -0.11579262f, 0.11851235f, 0.14556096f, 0.00602124f, -0.32811567f, 
    -0.10188077f, 0.12671621f, -0.17996208f, -0.18309262f, -0.22164829f, -0.21347766f, -0.11676074f, -0.10238993f, 
    -0.01451821f, -0.00537811f, 0.01637218f, 0.01274832f, 0.33842492f, 0.20447303f, -0.08311076f, -0.20172612f, 
    0.02849962f, -0.02186196f, 0.08274636f, -0.01905243f, 0.23331486f, 0.08279809f, -0.00851520f, 0.16616321f, 
    0.08656506f, -0.00409738f, -0.07901131f, 0.01507230f, 0.16026199f, -0.44911090f, 0.28163350f, 0.16136375f, 
    0.23611368f, 0.06793752f, 0.48198161f, 0.09369036f, 0.45462665f, -0.19205253f, -0.06852884f, -0.15823118f, 
    -0.01825318f, 0.05713745f, -0.15082060f, 0.11737532f, -0.08343744f, -0.07967853f, -0.06404092f, 0.10014299f, 
    0.19488534f, 0.10000106f, 0.08543925f, 0.04194222f, 0.09458965f, -0.25965557f, -0.02627495f, 0.15351619f, 
    -0.11227301f, 0.14928134f, -0.19349881f, 0.10787486f, 0.02842445f, 0.12366884f, -0.02360903f, 0.23187806f, 
    0.02059706f, -0.07877351f, 0.15831798f, 0.25153282f, -0.02709314f, 0.07371698f, 0.05345641f, 0.30150774f, 
    -0.05846750f, 0.10037205f, 0.15038978f, -0.18169686f, -0.21343863f, 0.11348642f, 0.07624434f, -0.03862951f, 
    -0.09150814f, -0.01134812f, -0.01612496f, 0.00910101f, 0.08549697f, -0.00286253f, -0.07379653f, 0.08100824f, 
    0.10311618f, -0.00480205f, 0.11765962f, -0.09934969f, 0.01703200f, -0.09823144f, 0.02221842f, -0.23446836f, 
    -0.23373771f, -0.13769117f, 0.04816740f, 0.00041926f, 0.03329438f, 0.01160115f, -0.02472977f, -0.11443505f, 
    -0.01651112f, -0.02735679f, -0.03184934f, -0.16814724f, -0.12716058f, -0.14943933f, -0.06526432f, -0.20489846f, 
    -0.33798349f, 0.03591448f, 0.01125570f, -0.09733064f, -0.14726931f, -0.16455866f, -0.08561866f, -0.09913030f, 
    0.00161012f, -0.17722055f, -0.04305995f, -0.00407580f, -0.11317611f, 0.11212984f, 0.01873376f, 0.00991599f, 
    -0.07455322f, 0.08776858f, -0.07649735f, -0.00786751f, -0.11417688f, -0.11951365f, -0.11082047f, -0.04008823f, 
    -0.07966548f, 0.09150158f, 0.00223477f, -0.17335591f, -0.04399501f, -0.08200403f, -0.05451521f, 0.12937291f, 
    0.14936757f, 0.00679293f, -0.02130044f, 0.05595777f, -0.07178945f, -0.19469956f, -0.02316337f, 0.09937143f, 
    -0.01048763f, 0.01981650f, 0.00819608f, -0.05920061f, -0.03825632f, -0.05044277f, -0.05422919f, 0.03792249f, 
    -0.05298216f, 0.02661136f, -0.07315042f, -0.08780811f, 0.20730665f, 0.28523079f, -0.09229752f, 0.17378600f, 
    0.11795712f, 0.15586081f, 0.37240481f, 0.07204781f, 0.28922454f, -0.01658072f, -0.00556786f, 0.28436041f, 
    0.13938658f, -0.03948270f, -0.08958282f, -0.02752105f, -0.05694068f, 0.07833647f, 0.16188356f, -0.42628580f, 
    0.01047538f, 0.11732711f, -0.15607277f, -0.04863375f, -0.05984131f, 0.08175067f, -0.14865687f, -0.34471610f, 
    -0.17775053f, -0.04225217f, 0.05375565f, 0.00288268f, -0.20440939f, -0.18766981f, -0.02073009f, 0.04185463f, 
    0.12968723f, 0.08357192f, 0.08942524f, 0.07728146f, 0.23671101f, -0.02250731f, 0.00787671f, 0.06069431f, 
    0.13534532f, 0.15670033f, 0.08673920f, -0.08415698f, 0.09402611f, 0.01042847f, -0.11266576f, -0.07323641f, 
    -0.01223020f, 0.00308869f, -0.35216600f, -0.63814843f, -0.74500525f, -0.05845020f, -0.12471380f, -0.10381435f, 
    0.06273587f, 0.03308394f, -0.07469162f, -0.23639067f, 0.01625950f, -0.10402686f, 0.09935546f, 0.07086984f, 
    -0.07975011f, 0.09858812f, -0.01380764f, 0.07065868f, -0.19124667f, 0.31780666f, -0.08082628f, -0.00519279f, 
    -0.00528973f, -0.11869838f, 0.04948314f, 0.16375196f, 0.00703994f, -0.10081115f, 0.15925521f, -0.03334960f, 
    0.07647990f, 0.08155838f, -0.21589915f, -0.07590851f, -0.00023389f, 0.14632079f, 0.14701867f, 0.28425357f, 
    0.11923834f, 0.08789142f, 0.34502116f, 0.30769148f, 0.13767770f, 0.02286487f, 0.05087511f, 0.07888792f, 
    0.10111592f, 0.06563421f, 0.16448264f, 0.41387987f, -0.11259490f, 0.05849074f, 0.05232024f, 0.14958531f, 
    -0.02956175f, 0.01907944f, -0.03167958f, 0.02945193f, -0.05050757f, -0.02152445f, -0.06119099f, 0.00081503f, 
    -0.03471939f, -0.05992176f, -0.00483211f, -0.05451237f, -0.03240643f, -0.02256702f, 0.01581659f, -0.03932733f, 
    -0.04370743f, 0.00318922f, 0.00911290f, -0.01092698f, 0.01490646f, -0.03322813f, -0.04153869f, -0.06064233f, 
    0.00419004f, -0.03332971f, 0.02757717f, 0.05091738f, 0.04016466f, -0.04564872f, 0.02782857f, 0.05946963f, 
    -0.00263755f, -0.01350055f, 0.03027713f, 0.03834799f, 0.03330081f, 0.01454930f, -0.05679682f, -0.02839214f, 
    -0.04623382f, 0.01206868f, 0.01511009f, 0.03385260f, -0.03613767f, -0.00253631f, 0.03090308f, -0.04669248f, 
    -0.04886859f, -0.05033127f, -0.01563727f, -0.05140402f, -0.04599423f, -0.01335697f, -0.05442851f, -0.05829656f, 
    -0.03034097f, -0.01980179f, 0.03317509f, -0.00540504f, -0.05528020f, -0.00811331f, -0.04200415f, 0.01088859f, 
    -0.06468506f, 0.01091647f, 0.02888594f, 0.02184044f, -0.01163912f, -0.00188587f, 0.03758544f, 0.00213388f, 
    0.00080130f, 0.01357991f, -0.06398098f, -0.02166965f, -0.06115911f, 0.02149089f, 0.03435566f, 0.00166165f, 
    0.05437469f, 0.01606080f, 0.01123305f, -0.00623442f, -0.04873408f, -0.03662505f, -0.01486660f, 0.01050453f, 
    -0.03135528f, 0.04885763f, -0.04007863f, 0.03034925f, -0.03846168f, -0.01621897f, 0.01862355f, -0.04559385f, 
    -0.01500823f, 0.04986272f, 0.00723697f, -0.00731931f, 0.01886556f, 0.02619145f, -0.06407773f, 0.03548744f, 
    0.03876070f, -0.00372233f, -0.06416909f, -0.01151575f, 0.03097379f, -0.04566852f, 0.01201204f, 0.06379620f, 
    -0.03071698f, 0.04891756f, 0.01401654f, -0.04380843f, 0.04173402f, 0.06203140f, -0.00672177f, -0.05016042f, 
    -0.03268741f, 0.04351778f, 0.02570799f, -0.01769409f, 0.00199027f, -0.05732203f, -0.00033569f, 0.03593781f, 
    0.02085049f, 0.05121382f, 0.04427752f, -0.05199097f, 0.03646479f, -0.01479846f, -0.05701118f, 0.03743840f, 
    0.05154698f, -0.03820463f, 0.05130517f, -0.02321596f, -0.03765978f, -0.00949504f, -0.05880529f, 0.00566961f, 
    0.04000387f, 0.00357005f, -0.04522469f, -0.00628624f, -0.01607689f, 0.03675607f, 0.03854629f, -0.05321087f, 
    -0.02844541f, -0.00840901f, -0.00480850f, -0.05974351f, -0.01269527f, 0.00927096f, -0.01402723f, 0.01292283f, 
    -0.05920517f, 0.00514668f, 0.03391426f, 0.01022253f, 0.01538565f, -0.04169855f, -0.02461099f, 0.01089676f, 
    -0.03267844f, 0.00242241f, -0.05152428f, -0.05816545f, -0.03190727f, 0.01313872f, 0.03098052f, 0.04980898f, 
    -0.04015963f, 0.04238057f, 0.03551816f, -0.02845986f, 0.05113668f, 0.01857794f, -0.04968655f, -0.01661180f, 
    0.03040014f, -0.01393295f, 0.00117205f, -0.00097133f, 0.04135851f, -0.00314913f, -0.01485166f, 0.03834184f, 
    -0.01534021f, -0.02493397f, 0.04408314f, 0.02200994f, -0.00928939f, -0.00321203f, -0.04821688f, -0.01079307f, 
    0.05317485f, -0.03548430f, -0.01714860f, -0.05494008f, -0.04757717f, -0.05169630f, -0.01970476f, -0.03457003f, 
    0.00705279f, 0.04831145f, 0.04433307f, 0.02079233f, 0.04179781f, 0.00751414f, -0.01336720f, -0.00513177f, 
    0.04477891f, -0.00543071f, -0.03555374f, 0.01292169f, 0.05059546f, -0.01000163f, -0.01789201f, -0.03622011f, 
    -0.00313973f, -0.01504351f, 0.00775085f, 0.00544204f, 0.03878816f, 0.00155658f, -0.05469010f, -0.05656577f, 
    -0.01483335f, -0.05058718f, -0.00633292f, -0.00486658f, 0.00656853f, -0.06086656f, -0.04720966f, 0.01625339f, 
    0.04532111f, -0.04611458f, -0.05234978f, 0.04983931f, 0.04192716f, -0.03965178f, -0.05791644f, 0.04556779f, 
    -0.03771310f, 0.03978356f, 0.04809730f, -0.05048465f, 0.03956114f, -0.05612966f, 0.03998667f, -0.03011508f, 
    0.04728085f, -0.06130796f, -0.05576099f, -0.05977757f, 0.00814323f, -0.04682317f, 0.05087319f, -0.03555172f, 
    0.04962673f, -0.05489971f, -0.04715388f, -0.01448313f, -0.04999682f, 0.01487635f, -0.01713036f, -0.00031013f, 
    0.00037582f, 0.03290332f, 0.02891118f, -0.01693662f, -0.00617621f, -0.02767733f, 0.00525232f, -0.05621428f, 
    -0.05521518f, 0.02465037f, -0.00920630f, 0.05062290f, 0.01548523f, 0.00402833f, 0.03796145f, -0.01794276f, 
    0.00913039f, 0.02263896f, 0.16013490f, -0.06434803f, 0.04962752f, -0.07198250f, -0.23639886f, -0.05468053f, 
    -0.17916355f, 0.03992860f, 0.40201649f, 0.14700234f, -0.08709320f, 0.19851598f, 0.05778368f, -0.10614262f, 
    0.01845202f, -0.15491815f, -0.03547606f, -0.13207002f, 0.08662177f, 0.12523894f, -0.02979823f, -0.03857639f, 
    -0.07306775f, 0.15529156f, 0.03341583f, -0.13603893f, 0.08083665f, 0.02854842f, 0.00804563f, -0.00074278f, 
    -0.10493270f, -0.11425461f, -0.21286125f, -0.20600595f, 0.11934739f, 0.05852019f, 0.01272689f, 0.01709210f, 
    0.06990795f, -0.01389391f, -0.06013920f, 0.16459087f, -0.11295792f, -0.11579054f, -0.27875772f, 0.48606312f, 
    0.19614056f, 0.31350750f, -0.03815630f, 0.08833522f, 0.04826378f, 0.24042358f, -0.15313788f, -0.01685121f, 
    -0.08791976f, 0.02138653f, 0.06809206f, -0.22073735f, 0.07916286f, 0.15860392f, 0.11285572f, -0.07912029f, 
    0.12362149f, -0.03361710f, -0.03634807f, -0.01031623f, -0.05365155f, -0.02603062f, -0.10706117f, -0.20410948f, 
    -0.15881757f, 0.16523004f, -0.08686703f, 0.05237507f, -0.03952032f, -0.03159548f, 0.00141598f, -0.36861444f, 
    -0.19981186f, 0.13570154f, 0.20122711f, -0.08189394f, -0.08188195f, 0.10135051f, 0.10140961f, -0.03941016f, 
    0.09720054f, 0.16295913f, 0.35112441f, 0.30514696f, -0.01109548f, -0.07031879f, 0.08032209f, 0.19721439f, 
    0.05832852f, -0.00279410f, -0.04531243f, 0.02282861f, 0.03420222f, 0.16999012f, -0.01884991f, -0.12445793f, 
    0.06174561f, -0.16428682f, -0.12414303f, -0.40498587f, 0.04825344f, -0.39931524f, 0.12201043f, 0.07695960f, 
    0.08923213f, -0.27257159f, -0.12176162f, -0.03727245f, -0.11145490f, 0.13052486f, -0.10768623f, -0.00056868f, 
    -0.14801750f, -0.02772422f, -0.11193980f, -0.12639900f, 0.30792680f, 0.12953894f, 0.14515428f, -0.17146307f, 
    -0.13063292f, -0.14403267f, -0.12077607f, 0.02313099f, -0.12847833f, 0.19187045f, 0.26023802f, -0.39010903f, 
    -0.21648970f, -0.01322510f, 0.05755777f, -0.20653513f, 0.13400540f, 0.00341948f, 0.06460063f, 0.31839839f, 
    0.00518685f, 0.09860029f, -0.13505866f, -0.04021400f, 0.02108793f, 0.03346460f, -0.02041937f, 0.00821163f, 
    -0.17572987f, -0.00216061f, -0.14213593f, 0.02720892f, -0.00505090f, -0.12537688f, -0.26869908f, -0.13623509f, 
    -0.27896687f, -0.27923089f, -0.36606538f, 0.00915944f, -0.19408363f, 0.07237814f, 0.00703886f, -0.02890708f, 
    0.04645072f, 0.06824039f, -0.02727442f, -0.14071059f, -0.03946824f, 0.01627182f, 0.11113098f, -0.03662072f, 
    0.05189913f, -0.13431875f, 0.08640819f, -0.04451025f, 0.01367525f, 0.24516277f, 0.04942631f, -0.01754357f, 
    -0.03881421f, 0.07339310f, -0.04140901f, -0.13218264f, -0.01880786f, 0.29299945f, 0.09403954f, 0.22989966f, 
    0.06173788f, 0.18876661f, 0.26930875f, 0.08533780f, 0.21702150f, 0.29737681f, 0.00078928f, -0.04530623f, 
    0.20457566f, 0.09197420f, 0.11477757f, 0.18512698f, 0.00359224f, 0.28475115f, 0.10232702f, -0.04779873f, 
    -0.33972052f, -0.16104451f, -0.38004109f, 0.00637881f, 0.00618334f, 0.08951203f, -0.07810356f, 0.09461755f, 
    -0.01868807f, 0.32962343f, 0.02706065f, -0.02552059f, -0.02186385f, 0.04614187f, 0.02806003f, 0.15203913f, 
    -0.11265058f, 0.21826306f, 0.05504313f, -0.13141264f, -0.06261817f, -0.05367635f, 0.06705073f, -0.08876026f, 
    0.07795558f, -0.14052500f, -0.09341151f, -0.06343369f, 0.23318447f, 0.08905300f, -0.03716430f, -0.20734809f, 
    0.01200347f, 0.12425274f, -0.03376104f, -0.22628948f, 0.22400436f, -0.10733710f, 0.04858348f, 0.08809551f, 
    -0.03263524f, -0.02704050f, -0.08338587f, -0.07913638f, 0.00045464f, 0.25481552f, 0.02845972f, 0.08229702f, 
    0.29149604f, -0.12131573f, 0.04958114f, 0.06459056f, -0.03754096f, -0.02076424f, 0.39066643f, -0.32807040f, 
    -0.05673345f, 0.13765429f, 0.17279950f, 0.12089359f, -0.09561525f, -0.03164454f, -0.26417604f, 0.32190305f, 
    0.08874951f, 0.15207905f, 0.06145932f, -0.27588367f, 0.07238902f, 0.13275862f, 0.14595236f, 0.03430736f, 
    0.15436287f, -0.18878637f, -0.13422307f, 0.12143622f, 0.05667870f, 0.02179222f, 0.01424616f, -0.10519274f, 
    -0.04732896f, -0.04138278f, -0.05832950f, -0.02526822f, -0.03537431f, 0.03206211f, 0.00628726f, 0.02785044f, 
    -0.01162749f, -0.05108636f, -0.03996812f, -0.00808149f, 0.02193440f, -0.05730484f, -0.04689647f, -0.01433052f, 
    0.01636940f, -0.03111375f, 0.03868182f, -0.05516664f, 0.05575692f, 0.03770899f, 0.00506715f, -0.04514506f, 
    -0.05654847f, -0.06242515f, -0.01278798f, -0.03992556f, -0.05903433f, -0.02808969f, 0.04838107f, -0.01740316f, 
    0.01939132f, -0.04912326f, 0.01756313f, -0.04299079f, 0.01203811f, 0.04347222f, -0.00366547f, 0.03916056f, 
    -0.05369372f, -0.01641369f, -0.01744189f, 0.04650480f, 0.02416382f, 0.04759971f, 0.01867191f, -0.00590667f, 
    0.00748495f, -0.01128238f, 0.00125165f, 0.05389660f, 0.03121547f, -0.00050659f, 0.03486333f, 0.01042571f, 
    0.05073587f, 0.03214125f, -0.00190434f, 0.03306306f, -0.02752944f, -0.05002352f, -0.02491093f, 0.01462266f, 
    -0.03376416f, -0.00230630f, -0.03361118f, 0.02346877f, -0.01685028f, 0.00001138f, -0.05699895f, 0.01692196f, 
    0.01848760f, -0.02618831f, -0.02323750f, 0.01771058f, -0.04974534f, 0.00493796f, 0.00787084f, 0.00980593f, 
    -0.02300969f, 0.00664381f, -0.05185334f, -0.05299987f, -0.02393140f, 0.01263485f, 0.02728838f, 0.02677079f, 
    -0.00325772f, 0.03525301f, -0.03841492f, 0.01220202f, 0.00133311f, 0.03736550f, 0.04596134f, 0.03059253f, 
    0.00370469f, -0.04332826f, 0.04182252f, -0.01414297f, 0.01210751f, 0.02742730f, -0.04507875f, -0.02362886f, 
    0.00248831f, 0.02707481f, -0.04686996f, -0.00600842f, -0.00919017f, -0.06161110f, -0.01627212f, 0.03799514f, 
    -0.02521864f, 0.03515742f, -0.00965582f, -0.05878425f, 0.03362498f, -0.02018603f, -0.05363791f, -0.01311118f, 
    -0.05763923f, 0.00036973f, -0.05596907f, 0.00369850f, -0.01343973f, -0.06950358f, -0.07020560f, -0.05555099f, 
    -0.04399098f, -0.05917276f, 0.02511166f, -0.03954283f, 0.04996059f, 0.02832432f, -0.01207019f, 0.01244240f, 
    0.03697828f, 0.04353411f, -0.05753516f, 0.02061897f, 0.02531358f, -0.01426181f, -0.03604168f, 0.01404821f, 
    0.00170826f, -0.04579286f, 0.00353543f, 0.01567790f, -0.01825323f, 0.05269644f, 0.01079433f, -0.05515119f, 
    0.02357008f, -0.02808041f, 0.00507595f, 0.04567672f, 0.01258756f, 0.03659854f, 0.02951489f, -0.05345678f, 
    -0.03863860f, -0.01660599f, 0.01078145f, -0.04456536f, -0.05877404f, 0.01501402f, -0.00507409f, -0.05461704f, 
    0.02632695f, 0.04219005f, -0.04023418f, 0.04830384f, -0.01000822f, -0.02793298f, 0.03294646f, -0.03400652f, 
    -0.02758852f, -0.04001596f, -0.02945914f, 0.03541480f, -0.02841662f, -0.06363629f, 0.02611850f, -0.03233814f, 
    0.04624670f, 0.01041060f, -0.05994938f, -0.05611337f, -0.05782430f, 0.00670762f, -0.00065857f, -0.04154135f, 
    -0.00773491f, 0.04925796f, -0.02226557f, -0.05505566f, 0.04734696f, -0.02558810f, 0.04857516f, 0.01382139f, 
    0.04717268f, 0.03540601f, -0.02838601f, 0.00951441f, 0.00670420f, 0.00635421f, 0.01401717f, -0.02675443f, 
    -0.02383277f, 0.04794893f, -0.06249244f, 0.03439298f, 0.02154307f, 0.04284037f, 0.02897687f, 0.01973221f, 
    0.00188438f, 0.02142250f, -0.02300343f, -0.00579635f, -0.00046028f, -0.05574564f, -0.05463021f, 0.02400606f, 
    0.03926625f, -0.03117972f, -0.00190627f, 0.04787812f, -0.03332292f, -0.00424623f, -0.04409669f, 0.01785225f, 
    -0.03341935f, 0.00399569f, -0.06876770f, 0.01761791f, -0.06010834f, -0.00570805f, -0.03580534f, -0.05118804f, 
    -0.01601976f, 0.03964377f, -0.02195111f, 0.03207357f, 0.02301416f, -0.01225866f, 0.00026447f, -0.00675429f, 
    -0.03484312f, 0.01170486f, 0.02593924f, 0.02789609f, 0.01515897f, -0.00127623f, -0.00779641f, -0.04017528f, 
    0.02650235f, 0.02671537f, -0.00514100f, -0.01676472f, -0.00141186f, -0.00631952f, -0.04919537f, -0.02306443f, 
    -0.04124411f, 0.00801986f, -0.05858968f, -0.04231314f, -0.04661717f, 0.04091643f, 0.03584180f, -0.05855455f, 
    0.00218235f, -0.05512242f, 0.02588458f, 0.00525771f, -0.02941407f, 0.01196781f, -0.01283521f, 0.01687436f, 
    -0.05714532f, -0.02388790f, 0.02513362f, 0.04008278f, -0.02569468f, -0.04962348f, 0.00479563f, -0.05416967f, 
    0.11413175f, 0.16189010f, 0.12505390f, -0.11950925f, 0.09493861f, 0.08931071f, 0.05071923f, 0.05171224f, 
    0.14390126f, 0.65204287f, -0.44648281f, -0.72203082f, -0.46761212f, -0.26008725f, -0.16610079f, -0.18721285f, 
    -0.09393129f, -0.11140892f, -0.24300990f, -0.24652214f, -0.05510646f, -0.06447487f, -0.06365603f, 0.01665055f, 
    -0.10575335f, 0.05909073f, -0.04047249f, -0.19470076f, -0.14981484f, -0.05324607f, -0.19403630f, -0.01258692f, 
    -0.10070796f, -0.16034740f, 0.01806922f, -0.05739396f, -0.11128435f, 0.30208570f, -0.22823188f, 0.10891938f, 
    0.04347584f, -0.23030357f, 0.11440761f, 0.18765941f, 0.20309007f, 0.46262309f, -0.09934933f, -0.31653565f, 
    0.01865684f, -0.09266470f, 0.06929324f, 0.02987066f, 0.20782539f, 0.20869973f, -0.43787298f, 0.08396259f, 
    0.23855928f, -0.06957177f, -0.04616508f, -0.04917671f, 0.22491875f, -0.00638242f, -0.26057270f, 0.33044532f, 
    0.35287046f, -0.42451325f, 0.03642367f, -0.20034462f, -0.22273315f, 0.08485973f, 0.00391817f, 0.05986071f, 
    0.21916361f, -0.39091319f, -0.12802126f, 0.04655334f, -0.15385367f, -0.00387650f, 0.12601872f, 0.09748685f, 
    0.11210087f, 0.09703047f, 0.25142789f, 0.03541582f, -0.08338606f, 0.00422704f, 0.07836068f, 0.13011730f, 
    -0.08927651f, 0.27217472f, -0.39507866f, -0.11811145f, 0.13719201f, -0.01587450f, 0.08494966f, -0.15421325f, 
    0.13439997f, 0.04080840f, 0.15545581f, 0.16567655f, 0.16322301f, 0.00896305f, -0.11848999f, -0.02148711f, 
    0.04657346f, 0.06301495f, 0.26983306f, 0.17480452f, -0.38759741f, -0.03942706f, -0.05972052f, -0.01220616f, 
    -0.12763983f, -0.30878711f, -0.17989276f, -0.10571559f, 0.00713664f, -0.30986673f, 0.17875130f, 0.35963845f, 
    0.04832192f, 0.04361866f, 0.07203003f, 0.08153205f, 0.09162590f, 0.04733142f, -0.54205155f, 0.05627992f, 
    0.46451604f, -0.19882581f, -0.05940552f, -0.02606145f, 0.11972271f, -0.01867077f, 0.00942153f, 0.04541898f, 
    -0.03498944f, 0.13974424f, 0.04687902f, 0.01674963f, -0.06778932f, 0.12529923f, -0.07360166f, 0.26812369f, 
    -0.34652612f, -0.06633517f, 0.05889492f, -0.24300411f, -0.42795303f, -0.12029602f, -0.07112088f, -0.17137830f, 
    -0.03393137f, -0.03523516f, -0.49320489f, -0.08269859f, -0.07006148f, -0.02171879f, -0.16762744f, 0.19068894f, 
    0.09529585f, -0.10861293f, 0.30090630f, 0.20282391f, 0.04144140f, 0.06427795f, 0.16166717f, -0.22154959f, 
    0.16758576f, 0.13539562f, 0.12128434f, -0.09320080f, -0.16313779f, -0.10987885f, -0.18595321f, 0.09348845f, 
    -0.15950665f, -0.00927784f, 0.15092473f, -0.11128836f, 0.09052677f, 0.04348805f, -0.15399675f, 0.23958851f, 
    0.19175309f, 0.02553454f, 0.23546514f, 0.09117635f, 0.28922883f, 0.03123704f, 0.32732937f, 0.31091961f, 
    -0.04781404f, 0.10367323f, 0.13948429f, 0.04752293f, -0.08089647f, 0.22340621f, 0.23267402f, 0.18361279f, 
    -0.08952586f, -0.04320000f, 0.06496471f, -0.18654126f, 0.04339482f, -0.03662160f, -0.01527804f, -0.67641139f, 
    0.15014499f, 0.53593957f, -0.11566780f, -0.12994154f, 0.08124189f, -0.03524245f, 0.07445214f, -0.03116225f, 
    0.32516065f, -0.07480127f, -0.10217637f, 0.08859523f, -0.05385344f, -0.05658288f, -0.15145077f, 0.27126253f, 
    -0.30030870f, -0.56436092f, 0.01705994f, -0.22338124f, -0.20846258f, -0.25736812f, -0.19402777f, -0.03035428f, 
    -0.11137016f, 0.12286074f, -0.20724536f, -0.16387059f, 0.15475549f, -0.00634550f, -0.08536379f, -0.02461260f, 
    0.13325955f, 0.06183011f, 0.01299874f, -0.04696887f, -0.04696541f, -0.09218522f, -0.35084575f, -0.52171665f, 
    -0.36465555f, 0.03186134f, 0.05538153f, 0.04419666f, 0.46124059f, -0.36271206f, 0.10964212f, -0.12653527f, 
    0.06248945f, -0.15307604f, 0.08761934f, 0.09867018f, 0.14613502f, 0.15549882f, 0.03465751f, 0.15333724f, 
    0.07154003f, -0.09996905f, -0.05153529f, 0.02673314f, 0.02481151f, 0.08495457f, 0.21385756f, -0.43635172f, 
    -0.22205222f, 0.12525088f, 0.22875255f, 0.05197080f, 0.08832173f, 0.14836502f, 0.09458327f, 0.28207228f, 
    -0.29979497f, -0.29254603f, -0.14983775f, 0.12760748f, 0.19528562f, 0.01794370f, 0.15759495f, 0.02640227f, 
    0.08325839f, 0.08173607f, 0.11593174f, 0.03327028f, 0.05399852f, -0.11329090f, -0.06548603f, 0.07594710f, 
    0.01984490f, -0.35042936f, -0.10489783f, -0.19005112f, 0.09656922f, 0.06825765f, 0.12558416f, -0.13173622f, 
    -0.15714066f, -0.07549135f, -0.00334450f, -0.16707060f, -0.14174436f, -0.09784451f, -0.08509184f, 0.07636421f, 
    0.06456342f, 0.12490533f, 0.03741824f, -0.30181623f, 0.19019577f, -0.04700769f, -0.03247368f, -0.01732055f, 
    0.06800766f, -0.05709992f, 0.03556273f, -0.12853293f, 0.43792325f, 0.06173594f, 0.02845161f, -0.03216528f, 
    0.10707431f, -0.00924602f, 0.03462785f, 0.10554018f, 0.06399012f, -0.56875312f, 0.00768179f, 0.29097649f, 
    0.07232198f, -0.10662006f, 0.20109929f, 0.28506926f, -0.03747519f, -0.06359731f, 0.22384515f, 0.06326276f, 
    0.33133155f, -0.10497479f, -0.01388391f, -0.04069294f, -0.17361011f, 0.03509141f, 0.08224883f, 0.18067521f, 
    0.20410873f, -0.00128714f, 0.05313718f, 0.03599157f, 0.06485016f, 0.09301896f, 0.02837913f, -0.03066532f, 
    -0.02465697f, 0.03686975f, -0.15648547f, -0.01031847f, -0.08535745f, 0.10291699f, 0.08609001f, -0.10172921f, 
    -0.16483656f, 0.10180360f, 0.22122291f, 0.24965306f, 0.19547163f, 0.00274658f, 0.05640017f, 0.09311247f, 
    0.04387985f, -0.06505343f, 0.36234981f, -0.25336415f, -0.25081471f, 0.07924355f, 0.12786038f, 0.06088767f, 
    0.08676919f, -0.00531801f, -0.03583473f, -0.10185085f, 0.06758536f, -0.01612736f, -0.06572694f, 0.06963403f, 
    0.18729433f, -0.05381599f, -0.01009799f, -0.04010473f, -0.09455185f, -0.08197669f, -0.12121501f, -0.08336780f, 
    0.03629869f, 0.00905840f, 0.00394406f, 0.02708943f, -0.16180545f, -0.32645953f, 0.21689944f, 0.21430106f, 
    0.04644610f, -0.06647585f, 0.03393527f, -0.13684693f, -0.00425782f, 0.01387949f, -0.24259473f, 0.00111754f, 
    -0.15659821f, -0.01025672f, -0.00996477f, -0.01086331f, -0.19043817f, -0.05433065f, 0.05694941f, -0.06665926f, 
    0.06907146f, -0.06376296f, -0.09344698f, -0.03713079f, 0.02444771f, 0.09075088f, -0.07491453f, 0.25143403f, 
    0.10697540f, 0.07396591f, -0.00172022f, -0.06576643f, -0.02258166f, -0.23387717f, 0.04979273f, -0.06413519f, 
    -0.12621041f, 0.00212400f, 0.08114892f, -0.21631588f, -0.10096688f, 0.03980321f, -0.17414114f, 0.12174892f, 
    -0.11129607f, -0.01390681f, 0.04515173f, 0.06962373f, 0.04225141f, -0.17516109f, -0.04636274f, 0.06060177f, 
    0.08852867f, 0.00830042f, -0.10542743f, 0.09368211f, 0.00713514f, -0.05623700f, -0.00974621f, -0.04822242f, 
    -0.10264278f, -0.14083590f, -0.07169469f, -0.15677659f, 0.15881892f, 0.25279066f, -0.26677585f, 0.28249985f, 
    0.10081352f, 0.25136811f, 0.09827287f, 0.03979837f, 0.09649188f, 0.06339314f, -0.09783546f, 0.32467774f, 
    0.10493126f, 0.03400852f, -0.11042588f, 0.08252709f, -0.02805405f, 0.06069863f, -0.00192253f, -0.44408298f, 
    0.01638732f, -0.10585352f, 0.12105332f, 0.11469541f, -0.01519388f, -0.11618070f, 0.13700399f, -0.29919645f, 
    -0.11954377f, 0.21544768f, 0.03273311f, -0.06255733f, 0.10565132f, -0.25329798f, 0.17682993f, 0.00552635f, 
    0.43293989f, 0.07647347f, 0.18291368f, -0.10621475f, 0.19230121f, 0.02072682f, 0.14482942f, 0.09224483f, 
    -0.10801668f, 0.34997001f, 0.10900778f, 0.09285309f, -0.09135272f, -0.01327929f, -0.10076167f, -0.00085517f, 
    -0.00197597f, -0.05981095f, -0.44434679f, -0.78547204f, -0.51432002f, -0.04167893f, 0.08762375f, 0.14674337f, 
    0.12642975f, 0.18225481f, -0.07737987f, -0.07414682f, -0.02208645f, -0.16946252f, 0.18155684f, 0.10513618f, 
    -0.07358813f, 0.03995943f, 0.06371976f, -0.03815885f, -0.49332052f, -0.14915423f, -0.22805773f, 0.14270854f, 
    -0.02772133f, -0.03538277f, 0.10745817f, -0.03782407f, 0.15003616f, -0.01497136f, 0.11806569f, -0.07221340f, 
    0.02611736f, 0.09846986f, -0.02499410f, -0.04002670f, 0.01089093f, 0.01267217f, 0.18648410f, 0.06264099f, 
    0.14896131f, 0.13139354f, -0.03271200f, 0.11668094f, 0.16167152f, 0.12748457f, -0.09063976f, 0.25595075f, 
    0.01308316f, 0.07222185f, 0.24406262f, 0.04840264f, -0.01235856f, -0.03283914f, 0.08421791f, -0.13945831f, 
    -0.05729565f, -0.05473577f, 0.04305365f, -0.00429570f, -0.00702766f, -0.06149541f, -0.02549284f, -0.05928637f, 
    0.02938329f, -0.03932794f, 0.02597542f, 0.03696366f, -0.04903372f, 0.04169464f, 0.02629732f, -0.03327459f, 
    0.03479722f, 0.05094315f, -0.03631561f, -0.04003370f, 0.03048866f, -0.02791758f, -0.03389829f, 0.00170807f, 
    0.00161388f, 0.00568771f, 0.04900342f, 0.03788048f, -0.03881386f, -0.06005067f, 0.04843556f, 0.02109546f, 
    -0.04240346f, -0.05669625f, 0.01581555f, -0.05578241f, 0.03805408f, -0.06620421f, -0.05905421f, 0.04722646f, 
    -0.01867909f, -0.05920352f, -0.01608927f, -0.00356670f, 0.00242372f, -0.03404770f, 0.03347797f, 0.01859851f, 
    -0.03609409f, -0.04690127f, -0.05869216f, -0.01395617f, 0.02604181f, -0.04932725f, -0.05333053f, 0.04008522f, 
    0.01104541f, -0.03610977f, -0.02987975f, -0.05796354f, -0.05890375f, -0.05245857f, -0.01535318f, -0.01484507f, 
    -0.00580765f, -0.01406815f, -0.03862952f, 0.01894890f, -0.04357181f, -0.04524960f, -0.01144385f, -0.06073730f, 
    0.00549356f, -0.05271722f, 0.00337319f, -0.00402454f, -0.00726153f, 0.03150923f, -0.00708215f, 0.03755240f, 
    -0.04443641f, 0.03299464f, -0.04318353f, 0.03909926f, 0.02446808f, 0.04356355f, -0.02720438f, -0.02627330f, 
    -0.01850265f, -0.03931006f, -0.01941640f, -0.05208179f, -0.00039143f, -0.03818439f, -0.00405860f, 0.02346288f, 
    0.04882614f, 0.02346921f, -0.02230764f, -0.00791443f, -0.00043465f, 0.02665756f, -0.00752786f, -0.03724390f, 
    0.02075780f, -0.03537553f, -0.05197738f, 0.03217819f, 0.04802966f, -0.03924960f, -0.00557494f, -0.03792781f, 
    0.02067642f, 0.04480428f, 0.03330554f, -0.03831492f, 0.01309353f, -0.06167393f, 0.00753512f, 0.00609488f, 
    0.03563071f, 0.04655516f, 0.00311804f, 0.00390761f, -0.02266630f, -0.05426931f, -0.02211179f, -0.00092316f, 
    0.00389041f, -0.02225587f, 0.01653815f, 0.02285870f, -0.02572067f, -0.03822339f, 0.04503671f, 0.01386408f, 
    -0.03229444f, 0.02140278f, 0.00524800f, 0.02158168f, 0.01394058f, -0.05299364f, -0.02217840f, -0.05251762f, 
    0.02747560f, -0.04109389f, -0.05681781f, 0.02416662f, 0.01406496f, 0.01949938f, -0.03799758f, 0.04878809f, 
    0.01956702f, -0.01429554f, 0.04455478f, -0.06640327f, 0.00022276f, -0.00343325f, 0.01957166f, -0.04435439f, 
    0.01824130f, 0.01066239f, 0.00191118f, -0.04620472f, -0.03994908f, 0.03433194f, 0.01942696f, -0.01802592f, 
    0.01399330f, 0.01744196f, -0.00414474f, -0.02060487f, 0.01035318f, 0.00124052f, 0.00206100f, -0.06030608f, 
    0.01081668f, 0.01291179f, 0.03369825f, -0.01953961f, -0.00588461f, -0.03815790f, 0.02402205f, -0.02104106f, 
    -0.04144567f, 0.02971812f, -0.04784086f, 0.03887737f, -0.04058506f, 0.01291608f, 0.05070073f, -0.04628943f, 
    0.01904825f, 0.01730562f, 0.04624413f, -0.01705244f, 0.02567614f, 0.00970484f, 0.00132271f, 0.00075549f, 
    0.00687817f, 0.00299746f, 0.01066540f, 0.00683817f, 0.02811968f, 0.04160162f, -0.02908135f, -0.04325556f, 
    -0.01573374f, 0.00835047f, -0.05840564f, -0.03396371f, -0.04894622f, -0.00869114f, 0.00999515f, 0.02215161f, 
    -0.05507826f, 0.04539515f, -0.04546104f, -0.02872263f, -0.05327517f, -0.05790667f, 0.01838423f, -0.04312078f, 
    0.04123811f, -0.04828513f, -0.04621193f, -0.04314848f, 0.04201313f, -0.02162815f, -0.03376224f, -0.04472834f, 
    -0.04703034f, 0.03137102f, -0.05824436f, -0.02377198f, -0.01324689f, -0.02733064f, 0.03411108f, 0.05157762f, 
    0.00224437f, 0.01428908f, 0.00533197f, -0.04614809f, 0.05310456f, -0.05153874f, -0.02297219f, 0.00046311f, 
    -0.03681103f, -0.01922368f, -0.07067723f, 0.01335420f, 0.04729458f, -0.04843221f, -0.00637207f, -0.05917096f, 
    0.04474641f, 0.04118839f, 0.02745307f, -0.01908423f, 0.01801288f, -0.05649423f, -0.02776843f, 0.00492669f, 
    0.01484271f, -0.02586190f, -0.02392304f, -0.03306878f, 0.04486921f, 0.03045919f, -0.00173282f, -0.01486700f, 
    -0.02846638f, 0.04055256f, 0.00970929f, -0.04662165f, -0.05742097f, -0.00850229f, 0.04804674f, 0.02909077f, 
    -0.01990608f, -0.01363710f, 0.04901322f, 0.02212230f, 0.00950033f, 0.02013269f, 0.02710238f, 0.00169052f, 
    -0.11636823f, -0.19649953f, -0.27212912f, -0.11744748f, 0.21844114f, -0.00207206f, 0.07521093f, 0.13201492f, 
    -0.04667380f, -0.15402472f, -0.55467749f, -0.19756125f, -0.01512704f, 0.17003301f, 0.19459127f, -0.09019715f, 
    -0.20165308f, 0.11063113f, 0.33120760f, -0.03395459f, -0.27809757f, -0.06388243f, -0.09393857f, 0.00437380f, 
    -0.03915921f, -0.06683915f, -0.01542443f, 0.00472775f, -0.27776381f, -0.02242470f, -0.18267833f, -0.16668095f, 
    -0.22778316f, 0.10579044f, 0.13272807f, 0.11213949f, 0.06605200f, 0.20039019f, 0.02040735f, -0.09424162f, 
    -0.03855118f, 0.00262526f, 0.14140505f, 0.11642729f, 0.06469224f, 0.06048651f, 0.04869437f, -0.67324769f, 
    -0.06713758f, 0.05097339f, 0.08271477f, 0.15970252f, 0.17859362f, 0.05428644f, -0.33032852f, 0.11007237f, 
    -0.38748974f, -0.14613393f, 0.03982358f, 0.08888476f, 0.08100896f, -0.02532560f, 0.11753295f, 0.11160242f, 
    0.02111177f, 0.13853405f, -0.18800481f, -0.01312781f, -0.17568560f, -0.03223062f, -0.03702520f, 0.02771233f, 
    0.12337465f, 0.10401465f, 0.08577589f, 0.06715456f, 0.13470027f, -0.06800645f, 0.12289344f, 0.19332723f, 
    -0.06187259f, -0.01242865f, 0.20650417f, 0.21686031f, 0.07011305f, -0.11952443f, 0.10111485f, 0.09952685f, 
    0.14330240f, 0.03114837f, 0.65543604f, 0.17697035f, 0.35333142f, -0.14906238f, -0.12932442f, -0.17706472f, 
    0.03329625f, 0.11737876f, 0.23713920f, -0.18005235f, -0.17962988f, -0.19261710f, -0.11275189f, 0.15259245f, 
    0.10616560f, 0.06838445f, 0.08129843f, -0.01576095f, -0.02664987f, -0.05783968f, -0.20937672f, 0.01505965f, 
    0.11295629f, -0.01597741f, 0.02872658f, 0.03674284f, 0.13856709f, -0.51664573f, -0.05207853f, 0.07140603f, 
    -0.12483605f, 0.10655453f, 0.15516618f, 0.06344640f, -0.18071441f, -0.00145962f, -0.18184972f, -0.46028215f, 
    -0.23020075f, -0.26123819f, -0.07299928f, 0.00545334f, 0.01614410f, -0.19697849f, 0.06880298f, 0.03072680f, 
    -0.22819334f, 0.14890434f, -0.05227936f, 0.10681119f, -0.08594095f, -0.09784220f, -0.05383892f, 0.14530297f, 
    0.30663472f, 0.03092818f, 0.27893659f, -0.05083703f, -0.22395523f, -0.13745026f, -0.11209884f, 0.04925627f, 
    0.06738971f, 0.01587696f, 0.08511807f, -0.10501227f, -0.10009946f, 0.04191256f, -0.04001795f, 0.21690811f, 
    0.12409778f, -0.04185377f, 0.21205653f, -0.10737390f, 0.18702206f, -0.15019882f, 0.06246617f, -0.20852453f, 
    -0.06817102f, 0.15367644f, 0.21296926f, 0.29665387f, 0.03229297f, 0.19277702f, -0.14002474f, -0.00510869f, 
    -0.12149724f, -0.04576941f, -0.09556028f, -0.21271230f, 0.24509929f, 0.16074285f, 0.15948206f, 0.33257118f, 
    0.09691978f, -0.18634695f, 0.12561734f, 0.16544566f, 0.03214086f, -0.17698821f, -0.55571532f, -0.45478210f, 
    -0.00133600f, 0.22600113f, -0.01435588f, 0.10985917f, -0.05690218f, -0.08901922f, -0.45240328f, -0.02627394f, 
    -0.67710477f, 0.13747509f, 0.20176400f, 0.16945720f, 0.08493917f, -0.13866599f, -0.10466701f, 0.11291568f, 
    -0.21220692f, -0.24405050f, -0.14627416f, -0.07958234f, 0.28369284f, -0.11379056f, -0.09864528f, 0.07097370f, 
    0.39475232f, 0.07840857f, -0.16676405f, 0.04662241f, 0.22240514f, -0.07777543f, 0.00849998f, 0.00458923f, 
    -0.21974131f, 0.29581901f, 0.25245526f, 0.25255823f, -0.14322650f, -0.28250253f, -0.15310830f, -0.06627712f, 
    0.12352452f, -0.01876383f, 0.12830335f, -0.21164145f, 0.06959942f, -0.20703064f, -0.10802004f, 0.00660108f, 
    0.01030284f, -0.04330525f, -0.02567469f, 0.10357603f, -0.03894457f, -0.09723227f, -0.20564277f, -0.03591532f, 
    -0.20036738f, -0.18377092f, -0.19915615f, 0.08189952f, -0.46887964f, -0.23873140f, -0.12049191f, -0.08090961f, 
    0.02880679f, -0.22045107f, 0.07007904f, 0.10419449f, -0.02527667f, 0.02041977f, 0.03703210f, 0.26167136f, 
    -0.02694068f, -0.06379814f, -0.02326316f, 0.00204637f, 0.18292309f, 0.09229264f, 0.30460858f, -0.09710520f, 
    0.39292115f, 0.18502578f, 0.10586115f, -0.25516814f, 0.10727661f, 0.16535303f, -0.12575075f, 0.03016646f, 
    0.01818655f, 0.00686016f, 0.13680613f, 0.27140054f, -0.07776964f, 0.02630349f, -0.01259572f, -0.10808376f, 
    0.02341263f, 0.01807993f, -0.04051856f, -0.02846323f, 0.00822236f, -0.00822268f, 0.03455725f, -0.00736518f, 
    -0.01670362f, 0.04962399f, 0.05614018f, -0.02798550f, 0.01129354f, -0.02950194f, 0.01393825f, 0.01784385f, 
    0.03026788f, -0.06394131f, 0.06290308f, -0.03020799f, 0.04839872f, -0.02326023f, -0.04470231f, -0.02475357f, 
    -0.03975515f, -0.01355303f, 0.01672061f, 0.02285267f, -0.00743883f, -0.02197581f, -0.03657522f, 0.04870799f, 
    0.02220838f, -0.01102486f, 0.01522204f, -0.02249380f, -0.05093616f, -0.02384134f, -0.05469596f, -0.03472557f, 
    -0.03705180f, -0.01474256f, -0.01615969f, 0.00311982f, -0.04821486f, -0.05644621f, -0.03762390f, 0.01839819f, 
    0.01863629f, -0.01895521f, -0.04237736f, -0.03998983f, -0.05980764f, 0.02678049f, 0.00464492f, 0.03235830f, 
    -0.01876116f, 0.00909948f, -0.00852051f, -0.05911259f, 0.01067331f, -0.02855180f, -0.01338076f, 0.00849392f, 
    -0.00794415f, -0.02124227f, -0.04823389f, 0.00391285f, -0.04107528f, -0.04339164f, -0.03765363f, -0.04192885f, 
    0.02170609f, 0.01048850f, -0.01942855f, -0.01598595f, -0.02507850f, 0.03972906f, -0.02691763f, -0.03913605f, 
    0.00505712f, 0.00483277f, 0.01241254f, -0.04467606f, 0.01884148f, 0.02337477f, -0.01857583f, 0.02878302f, 
    -0.02313452f, 0.01628299f, 0.00388202f, -0.01470078f, -0.02482312f, 0.00393345f, -0.00577478f, -0.02626857f, 
    -0.04654433f, 0.01529238f, 0.01089599f, -0.05504673f, -0.02970785f, -0.00669832f, 0.05332490f, -0.04903155f, 
    -0.02258451f, -0.04141413f, 0.00934017f, -0.01345052f, 0.04749348f, -0.01368015f, -0.02858439f, -0.04850778f, 
    -0.05630515f, -0.03358011f, 0.02957165f, -0.03417263f, 0.01426508f, -0.05288088f, 0.04141936f, 0.00504809f, 
    -0.01161796f, -0.03245569f, -0.04486557f, -0.00133656f, 0.02815095f, -0.04809377f, -0.01526659f, -0.06067277f, 
    -0.00838937f, 0.03911197f, -0.01023126f, -0.04449879f, -0.05541553f, 0.02739853f, -0.04333856f, -0.05405550f, 
    -0.01255738f, 0.02110171f, -0.02917131f, -0.00786872f, -0.00437090f, -0.00807689f, -0.04259525f, -0.06413414f, 
    -0.03228436f, 0.01286407f, 0.05844805f, 0.05256516f, -0.03729674f, 0.05059212f, 0.00135433f, -0.02338501f, 
    -0.03937810f, -0.02495276f, -0.01613544f, 0.03987532f, -0.00519143f, 0.00280351f, -0.06154375f, 0.03051838f, 
    0.02588767f, 0.00319339f, 0.02678368f, 0.04900068f, 0.04204966f, -0.01807605f, -0.03664966f, -0.04394528f, 
    -0.01939979f, -0.01851663f, -0.04409315f, 0.02394736f, 0.01367917f, 0.05996140f, 0.00131013f, -0.01221246f, 
    0.05632855f, 0.01443282f, -0.02744726f, -0.00237473f, 0.01179770f, -0.00846349f, -0.06749581f, 0.05181397f, 
    -0.02934483f, 0.04476373f, -0.06192814f, 0.04761147f, -0.02114251f, -0.02505648f, 0.02605746f, 0.01940732f, 
    -0.01765909f, 0.01964362f, -0.00094167f, -0.01284469f, 0.02492052f, 0.04302232f, 0.03056894f, -0.03801763f, 
    0.02950638f, 0.03995419f, 0.04814769f, -0.01767902f, 0.00485284f, -0.05717023f, 0.01111478f, 0.02880521f, 
    -0.02902048f, -0.05015248f, -0.03775959f, -0.05640388f, -0.01339140f, 0.00879878f, -0.00460467f, 0.00659799f, 
    -0.03119138f, -0.05141079f, 0.04317506f, 0.03278414f, -0.03430087f, -0.00423327f, -0.05130547f, 0.00525949f, 
    0.03741343f, 0.05308434f, -0.02786203f, -0.03649104f, -0.03240600f, -0.00499525f, -0.04321524f, 0.02685834f, 
    -0.05119222f, -0.01297301f, -0.04097876f, -0.01871619f, -0.05584849f, 0.01014470f, -0.06254636f, 0.01319247f, 
    0.01175809f, 0.04344018f, -0.03248771f, -0.04323048f, -0.03418399f, -0.05937887f, 0.03157277f, -0.00460766f, 
    0.03939236f, -0.02969391f, 0.03741809f, -0.01838273f, 0.04750254f, -0.05316466f, 0.02829298f, 0.04739898f, 
    0.03848051f, 0.02467481f, 0.02248750f, -0.02080850f, 0.03367678f, -0.00604123f, -0.02293461f, -0.02539047f, 
    0.01140109f, -0.00463172f, 0.01962161f, 0.05470321f, 0.00799955f, -0.02103272f, 0.01113713f, 0.01546496f, 
    0.02568231f, -0.04215702f, 0.04051746f, -0.05587747f, 0.03589397f, -0.03943684f, -0.03444761f, 0.01562105f, 
    0.05502380f, -0.01613293f, 0.01271756f, -0.04491980f, -0.02277840f, 0.04775897f, 0.04234833f, -0.04546964f, 
    -0.07734081f, -0.15776974f, 0.14347962f, 0.03159911f, 0.04022888f, -0.07961340f, 0.17983265f, -0.11813977f, 
    -0.03365493f, 0.03198330f, -0.13157901f, 0.29588223f, 0.19595660f, -0.24620293f, 0.03078269f, -0.09755021f, 
    -0.13157991f, -0.08199887f, -0.17397384f, 0.03440230f, 0.12308116f, -0.08973694f, 0.02441662f, 0.00617089f, 
    0.02904716f, -0.12996301f, 0.18867837f, -0.04935224f, -0.16912191f, 0.12773429f, -0.13533320f, 0.11847251f, 
    -0.13241373f, 0.08537038f, -0.01968953f, 0.09036637f, 0.06650640f, -0.09786563f, 0.16971146f, 0.03104003f, 
    0.03909768f, 0.00874881f, 0.00829409f, 0.10703790f, 0.10681974f, 0.23659948f, -0.12415437f, -0.02955428f, 
    -0.02568851f, -0.02828104f, 0.39681020f, -0.02824789f, 0.09158272f, 0.00196019f, -0.24774183f, 0.11200176f, 
    0.23655434f, 0.05412174f, 0.17339778f, 0.06477337f, 0.17527105f, -0.07850176f, -0.21291998f, 0.15763538f, 
    -0.11690456f, -0.07649006f, -0.24954264f, -0.08081453f, -0.14765404f, 0.07491567f, 0.09711924f, 0.23749961f, 
    0.10218882f, -0.17195074f, 0.27173206f, -0.08756875f, 0.06892046f, 0.13404368f, 0.15677115f, 0.09605407f, 
    0.02417578f, 0.09013749f, -0.26637846f, 0.30449688f, -0.03976399f, -0.12203866f, -0.06462676f, -0.09126342f, 
    -0.12307022f, 0.24669509f, 0.11503892f, -0.20410196f, -0.04882601f, 0.09971426f, 0.01405978f, 0.05563420f, 
    0.08042374f, 0.11583525f, 0.07920177f, -0.22115637f, 0.00428986f, -0.02108794f, 0.13786197f, 0.06778271f, 
    -0.10215031f, 0.08134895f, 0.12666172f, 0.06760859f, -0.22910649f, -0.21479578f, -0.12067312f, -0.09553263f, 
    -0.15839289f, -0.09070630f, -0.04217213f, -0.08286789f, -0.02277940f, 0.05816551f, 0.18158533f, -0.25271362f, 
    0.13006194f, 0.08457083f, -0.01990605f, -0.07527430f, 0.12520665f, 0.01883223f, -0.18609716f, -0.00994970f, 
    -0.26826763f, 0.18428403f, 0.13934101f, 0.14832611f, -0.09453832f, 0.16982500f, -0.04096288f, -0.22314705f, 
    -0.16768542f, -0.04650824f, 0.14558725f, -0.05579257f, 0.06108543f, 0.06409727f, 0.02618848f, 0.20582014f, 
    -0.00181968f, -0.11422878f, -0.23517795f, -0.38500389f, -0.09254352f, -0.24586046f, -0.03322475f, 0.08323514f, 
    -0.06391751f, -0.26015124f, -0.29547405f, -0.10112369f, -0.16057977f, 0.06121140f, 0.00218726f, 0.21698318f, 
    0.07498083f, 0.03102767f, 0.04497941f, -0.27183509f, -0.28049621f, -0.01024297f, -0.31179062f, 0.12275989f, 
    0.00970974f, 0.04629378f, 0.05888461f, -0.08813664f, -0.10358259f, -0.01929687f, -0.49356425f, -0.19227877f, 
    -0.34833014f, 0.11919083f, 0.07140595f, 0.11341026f, 0.19368692f, 0.01658926f, 0.18131848f, 0.20666635f, 
    0.10485823f, -0.01662131f, 0.06757850f, -0.05516384f, 0.20852113f, 0.03967706f, 0.31595764f, 0.39241141f, 
    0.10136198f, -0.09266011f, 0.22731173f, 0.03171016f, 0.05078295f, -0.07401124f, -0.10792273f, 0.13729660f, 
    0.01169274f, 0.09019025f, -0.02087563f, 0.17866082f, -0.09625253f, 0.17898017f, 0.00861403f, -0.10141326f, 
    -0.04658885f, -0.50808722f, -0.13739389f, 0.15899010f, 0.11101814f, -0.03027901f, -0.08864415f, 0.02580081f, 
    0.51789248f, -0.37113056f, 0.34935346f, -0.01678568f, 0.09083855f, 0.05941006f, 0.04271030f, -0.02738061f, 
    -0.02483269f, 0.07858299f, -0.18889512f, -0.17294066f, -0.11339185f, -0.11279476f, -0.04986288f, -0.11559950f, 
    0.22980727f, 0.01127337f, -0.13382615f, -0.26312578f, -0.37763172f, -0.00387753f, 0.01646358f, 0.10974161f, 
    0.03879076f, 0.06794834f, 0.04207386f, 0.11289819f, -0.19174711f, 0.08907203f, 0.03932336f, -0.11619777f, 
    -0.02749770f, 0.05933513f, 0.10386473f, 0.08126801f, -0.14679489f, 0.09419667f, 0.30428970f, -0.06809492f, 
    -0.03875853f, 0.29483849f, 0.07420004f, 0.07432493f, 0.32353723f, 0.02137301f, -0.01433902f, 0.17453925f, 
    -0.26653683f, 0.03025559f, -0.04897572f, -0.12135307f, -0.11288631f, -0.11838373f, 0.03820247f, -0.11118025f, 
    0.21826382f, -0.13685220f, 0.25705394f, 0.27280819f, -0.02582837f, 0.17224553f, 0.08672721f, -0.27992037f, 
    -0.08749815f, 0.06458651f, 0.06671795f, -0.08299171f, 0.07393883f, -0.22636236f, 0.20137726f, 0.11670762f, 
    -0.23537810f, 0.01688453f, -0.09216113f, 0.01459860f, -0.14924467f, 0.11193576f, 0.16952907f, 0.14133336f, 
    -0.00120785f, -0.34687677f, 0.08268413f, -0.29398826f, -0.03063171f, 0.06685062f, -0.26727009f, -0.04725880f, 
    -0.10348276f, -0.17288351f, 0.07112388f, 0.02337712f, 0.19927983f, -0.01826886f, 0.12131613f, 0.07751679f, 
    0.11887499f, 0.02441462f, -0.20166931f, 0.08880816f, 0.14295869f, 0.10044219f, 0.08759247f, 0.01913903f, 
    -0.02790198f, 0.18462768f, 0.01882883f, 0.12107127f, -0.37013042f, -0.05369394f, 0.17981729f, -0.07991736f, 
    0.16760273f, 0.03339752f, -0.00810037f, 0.00070440f, 0.26186100f, -0.13762419f, -0.02144230f, 0.37736538f, 
    0.24424048f, 0.34415475f, -0.09103445f, -0.21559611f, 0.09569606f, -0.05990107f, 0.21016212f, 0.16906646f, 
    0.44439831f, 0.06077669f, 0.11767815f, 0.04851788f, 0.04076567f, 0.02477180f, -0.29451606f, -0.56303316f, 
    -0.00025121f, 0.12448498f, -0.01478030f, 0.00968085f, -0.01452336f, 0.00447621f, 0.06674200f, 0.16314378f, 
    -0.08016098f, 0.20014027f, -0.08249781f, 0.07999094f, 0.18353692f, 0.02044471f, 0.10264139f, 0.20084751f, 
    0.27591798f, -0.47319585f, 0.30845189f, 0.03264537f, 0.18450688f, -0.05040181f, -0.16655517f, -0.13775861f, 
    0.30956459f, -0.12420078f, -0.41538516f, -0.13155913f, 0.00519929f, -0.16603942f, 0.04900736f, 0.06345124f, 
    0.05668498f, -0.00008767f, -0.02129220f, -0.06264927f, -0.21238954f, 0.07411880f, -0.03614818f, 0.00275483f, 
    0.10116038f, 0.10616426f, 0.15787214f, 0.11778642f, -0.18918687f, -0.35124624f, 0.62230361f, -0.31115547f, 
    0.13175441f, 0.15647192f, -0.05123309f, -0.07441702f, -0.01811191f, 0.02612684f, -0.09053127f, 0.18710269f, 
    -0.04161702f, 0.15103903f, -0.16800508f, -0.07064033f, -0.16446668f, -0.07290965f, -0.17178020f, -0.05365658f, 
    0.09427944f, 0.07319990f, 0.00544142f, -0.05856646f, -0.03566487f, -0.14031218f, -0.09010901f, -0.14099701f, 
    -0.20019360f, -0.03322113f, -0.04360516f, -0.04217139f, -0.05124488f, 0.06257802f, 0.08870619f, -0.00678305f, 
    -0.72663355f, -0.47275221f, 0.24216922f, 0.04521766f, -0.07848563f, -0.00854016f, 0.10768648f, -0.05330155f, 
    -0.03493072f, -0.13871168f, 0.06665587f, 0.02941607f, 0.04285557f, 0.12204617f, -0.04455776f, 0.05676856f, 
    0.04433819f, 0.33433115f, -0.03561936f, -0.04063376f, -0.09281837f, -0.10188440f, -0.03476393f, -0.02108660f, 
    0.12484693f, 0.07264154f, 0.29322159f, -0.19648632f, -0.10237942f, -0.19032249f, 0.15559174f, 0.09281127f, 
    0.07648514f, 0.05995660f, 0.00568372f, -0.13504513f, 0.09087346f, 0.28129083f, -0.19185893f, 0.09095336f, 
    -0.10141324f, 0.03004552f, 0.26335156f, 0.25479606f, 0.20101658f, -0.06453935f, 0.23205289f, 0.07409940f, 
    0.05892191f, -0.00083530f, 0.08853390f, 0.11098418f, -0.09641827f, 0.02435261f, 0.21789631f, -0.08840234f, 
    0.13481289f, -0.00308910f, -0.03273992f, 0.01812208f, 0.02484272f, 0.24226901f, -0.17747311f, -0.07330754f, 
    -0.30156469f, 0.09000461f, 0.03118216f, -0.03679548f, -0.11197416f, 0.11584585f, 0.03672731f, -0.07558075f, 
    -0.39654475f, -0.26544899f, -0.04264652f, -0.02151825f, -0.00337899f, 0.09715784f, 0.03334811f, -0.01794679f, 
    0.06529956f, -0.74144471f, -0.27848724f, 0.21390359f, -0.06837647f, 0.01976440f, -0.05985279f, 0.04608279f, 
    0.06741367f, 0.05702692f, -0.04934552f, -0.26338321f, 0.32124966f, -0.10173596f, 0.10125509f, 0.02407221f, 
    0.00274531f, -0.03562550f, -0.08718832f, -0.43812245f, 0.02700903f, -0.28080165f, 0.10339454f, -0.07518382f, 
    -0.08914659f, -0.09930713f, -0.00324785f, 0.00911497f, 0.16105345f, 0.32330745f, 0.12032172f, 0.04119677f, 
    0.17725697f, 0.07294340f, 0.01061574f, 0.10977194f, 0.14009100f, -0.21055889f, 0.16055369f, -0.06941082f, 
    0.09766045f, 0.05579818f, -0.06758794f, 0.12734321f, 0.08387071f, 0.13851424f, 0.14240159f, -0.01306792f, 
    0.18619952f, 0.11171572f, 0.26598823f, 0.10792911f, 0.11710590f, 0.21306700f, 0.18293737f, 0.03325371f, 
    0.17934419f, -0.18612432f, 0.03833777f, 0.05694121f, -0.19590563f, -0.06795502f, 0.09507025f, 0.10239898f, 
    0.09255620f, -0.27597111f, -0.44653577f, 0.10692522f, 0.05810121f, 0.12065265f, -0.00280172f, 0.20334196f, 
    -0.19619136f, 0.05153080f, -0.79991859f, -0.33812749f, -0.14329940f, -0.14753293f, 0.03108525f, 0.15235919f, 
    0.11081490f, -0.18954560f, 0.24473818f, 0.17930683f, 0.06716015f, -0.03476936f, 0.08782110f, -0.11940380f, 
    -0.05904648f, -0.08865076f, 0.17789856f, 0.07797153f, 0.21448560f, 0.07340556f, -0.00718708f, -0.01613068f, 
    -0.01548241f, -0.12388258f, 0.07137518f, -0.06682368f, 0.08442471f, -0.25203639f, 0.13589887f, -0.10685488f, 
    0.09674897f, -0.20772362f, 0.04082617f, 0.01149245f, 0.12458804f, -0.37273213f, 0.34581122f, -0.15966201f, 
    0.25002772f, -0.15701053f, 0.27362156f, -0.08278895f, 0.22237535f, -0.09653280f, 0.17885339f, 0.00302625f, 
    0.25671813f, -0.06765491f, -0.05551130f, -0.05426819f, 0.17100276f, 0.07571877f, 0.08502087f, 0.28696439f, 
    -0.13867846f, 0.25120288f, 0.02935816f, 0.07394537f, -0.02591606f, 0.04175491f, -0.02102935f, 0.21749404f, 
    -0.27537143f, -0.20415036f, 0.00187086f, 0.00447437f, 0.03369600f, -0.01980006f, -0.03682799f, 0.13691933f, 
    0.12904574f, -0.54883999f, -0.17824629f, 0.14875878f, -0.00425721f, 0.01475817f, 0.02613169f, 0.19821800f, 
    0.08772364f, 0.00920695f, 0.16792916f, 0.10910577f, -0.08325477f, -0.06289110f, -0.19965573f, -0.20521525f, 
    0.14519793f, -0.00438193f, 0.18106668f, -0.04974980f, -0.44315764f, -0.53554493f, 0.16953726f, 0.10911988f, 
    -0.12559387f, -0.03406184f, 0.24388777f, 0.08035367f, 0.15044920f, 0.30255693f, 0.06470880f, -0.08379079f, 
    -0.02741903f, -0.25102252f, 0.10140155f, 0.03517445f, 0.17000769f, -0.01482142f, -0.10794107f, -0.00300394f, 
    0.01435309f, 0.02640239f, 0.11113086f, 0.09326848f, -0.13488884f, 0.11134387f, -0.05854730f, -0.40750542f, 
    -0.19555840f, 0.06493983f, -0.15151523f, -0.10125797f, 0.22895069f, -0.05632350f, 0.08859197f, 0.94626778f, 
    -0.12446403f, 0.00177813f, -0.09810725f, -0.18234284f, -0.06015908f, 0.22454464f, 0.02068255f, -0.20679913f, 
    0.36328900f, -0.23106621f, -0.18140566f, 0.30588412f, 0.00939377f, -0.16123787f, -0.14275828f, -0.13839813f, 
    -0.06155844f, -0.03048366f, 0.04261044f, 0.14382930f, -0.02504726f, -0.10346840f, -0.06372108f, -0.00998225f, 
    -0.06108578f, 0.17194028f, 0.62233257f, -0.07681706f, -0.05147085f, -0.02473122f, -0.08711979f, -0.01624514f, 
    -0.02199814f, 0.05270974f, -0.00592162f, 0.16002139f, -0.54135364f, -0.17724273f, -0.16000764f, 0.15576947f, 
    -0.08602832f, 0.05525229f, 0.00354349f, 0.17401326f, -0.17866059f, -0.00753700f, -0.02886049f, 0.16391982f, 
    0.02898567f, -0.02652953f, 0.27361840f, -0.00371115f, 0.06165953f, -0.43474683f, -0.02771915f, 0.18532073f, 
    0.04974046f, 0.14196409f, 0.29709423f, 0.11443454f, 0.19386120f, -0.13636765f, 0.33867243f, 0.06348094f, 
    0.17020698f, 0.05701649f, -0.05020088f, -0.01195102f, 0.10879419f, 0.09133963f, -0.04135384f, 0.14416496f, 
    0.01920428f, 0.07543081f, -0.01399626f, 0.05726545f, 0.22995475f, 0.04841867f, -0.03920035f, -0.11021142f, 
    0.07365923f, -0.49792063f, -0.73375690f, -0.07640848f, 0.10149059f, -0.02972972f, -0.07438070f, 0.09921784f, 
    0.04670694f, -0.06567994f, -0.33354032f, 0.18296687f, 0.08120670f, -0.01259836f, -0.21318263f, -0.09680358f, 
    0.01901863f, 0.08337235f, 0.02832193f, 0.46134621f, 0.13858861f, -0.05122164f, -0.04510316f, -0.24386452f, 
    -0.09488276f, -0.02315537f, 0.11708929f, -0.62090141f, -1.15089846f, -0.18537694f, -0.28258330f, -0.15762947f, 
    -0.37902331f, -0.01716765f, 0.10953670f, 0.22671574f, 0.02546756f, 0.04894875f, 0.06075720f, -0.22075370f, 
    -0.14781697f, -0.18527268f, -0.02166316f, 0.09469408f, -0.03514476f, -0.90541786f, -0.07661703f, 0.20647718f, 
    0.20260689f, -0.24722865f, -0.01374754f, 0.18002397f, 0.07871162f, -0.20774065f, 0.11144982f, -0.16282958f, 
    -0.10114944f, -0.02936308f, -0.17138574f, 0.00697559f, -0.03582892f, 0.18062766f, 0.25884247f, 0.04540514f, 
    0.19502251f, 0.04610213f, 0.05515361f, 0.05627221f, -0.20728581f, 0.13728708f, 0.04970836f, 0.08598188f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.00470409f, -0.03538195f, 0.04250769f, -0.10986756f, 0.01485417f, -0.20164612f, -0.03439748f, 0.09929259f, 
    0.10941422f, 0.33550259f, -0.04812557f, 0.14313562f, 0.30227092f, 0.13162708f, 0.02039659f, -0.04548260f, 
    -0.02637497f, 0.08398263f, -0.01171904f, -0.01317030f, 0.15759838f, -0.05852284f, 0.14172038f, 0.01765019f, 
    0.43473715f, 0.26717263f, -0.01627718f, 0.11397461f, -0.06330556f, 0.16901603f, 0.16552141f, 0.14523496f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.05974048f, -0.16266234f, -0.00001243f, 0.00324223f, -0.22692248f, -0.18720770f, 0.07968270f, 0.00656668f, 
    0.05752120f, 0.06053217f, -0.15347093f, 0.13337433f, -0.15630819f, 0.17645922f, -0.17298527f, 0.06983315f, 
    0.00059278f, -0.16439939f, 0.00582740f, -0.11555487f, 0.04599440f, -0.10376538f, -0.22177206f, 0.15609115f, 
    0.10539123f, -0.17772004f, 0.05547630f, -0.06663395f, 0.13438964f, 0.01733704f, -0.06218531f, -0.18998303f, 
    0.22326206f, 0.07787182f, 0.17716125f, 0.16741447f, -0.44355309f, 0.72768360f, 0.45335433f, 0.15065087f, 
    -0.17796271f, -0.12993576f, -0.12543955f, 0.03214221f, -0.27395076f, -0.19538985f, -0.06337135f, 0.05287417f, 
    0.03205997f, 0.10746934f, 0.18500645f, -0.11930000f, 0.12221285f, -0.13640220f, -0.08501595f, -0.06213648f, 
    -0.51496476f, -0.30697471f, -0.09023631f, -0.41990632f, -0.13717347f, 0.13352650f, 0.63325822f, 0.54224920f, 
    -0.07011474f, -0.09782869f, -0.10498291f, 0.06302010f, 0.61513329f, -0.03082321f, -0.31914788f, -0.25832394f, 
    -0.20848452f, -0.61052960f, 0.15310107f, 0.24442530f, 0.52275133f, -0.15554747f, 0.12884961f, 0.15218893f, 
    -0.28213170f, 0.22943410f, 0.01341359f, 0.16206001f, -0.01856452f, 0.00969586f, 0.02071497f, -0.00944713f, 
    0.66120505f, 0.01756598f, -0.06070432f, -0.12594485f, -0.01579158f, 0.45297357f, 0.25968757f, -0.09086826f, 
    0.12219655f, 0.06800708f, 0.64606708f, -0.03433749f, 0.41650346f, -0.30739936f, -0.29966190f, -0.30210784f, 
    0.20507641f, 0.29385233f, -0.15560499f, -0.35686192f, 0.14580694f, 0.05292038f, -0.16766113f, 0.07609707f, 
    0.21624675f, 0.10674311f, 0.01783411f, -0.15411127f, 0.24984655f, -0.16265634f, -0.15913126f, 0.12106977f, 
    0.02804307f, 0.10967639f, -0.04504570f, 0.30512539f, -0.13470522f, -0.04687326f, 0.47236672f, 0.17417417f, 
    -0.16485082f, 0.16104816f, -0.08195864f, 0.11713445f, -0.17544496f, 0.20925282f, -0.18281665f, -0.07900614f, 
    0.26733446f, -0.28672200f, -0.10198347f, 0.29623747f, -0.17423156f, -0.09670475f, 0.03040482f, 0.09595156f, 
    0.35743627f, -0.03797588f, 0.01824267f, 0.03713477f, -0.10861142f, -0.00569859f, 0.01981382f, -0.04903952f, 
    0.00009107f, -0.12812136f, -0.07478298f, 0.28386888f, 0.16723795f, 0.30301550f, 0.11269112f, -0.03507394f, 
    -0.20473307f, 0.12862758f, 0.04411796f, -0.12042630f, 0.08327550f, -0.16809885f, -0.14736311f, 0.00380560f, 
    0.03784590f, 0.09407631f, 0.10165712f, -0.14513256f, -0.15913936f, 0.04191220f, 0.01686458f, -0.05010261f, 
    -0.11765212f, -0.05030789f, 0.10077542f, 0.01561057f, -0.09292712f, 0.04280058f, 0.10562424f, -0.07870820f, 
    -0.16269134f, -0.18039581f, -0.06258994f, -0.18133545f, 0.06420925f, 0.02148429f, -0.16572453f, -0.12713252f, 
    -0.18274149f, 0.12789910f, 0.07770624f, -0.09933677f, 0.08588707f, -0.15595798f, -0.10003103f, -0.18553907f, 
    0.12731121f, -0.10856605f, 0.05909100f, 0.09777435f, -0.11073943f, -0.10044751f, -0.11257503f, -0.05216204f, 
    0.08797270f, -0.09687506f, -0.10578618f, 0.07170521f, -0.05786471f, -0.13166085f, -0.19847883f, 0.09800413f, 
    -0.04012950f, -0.13776653f, -0.16578920f, 0.14377089f, -0.10003826f, 0.03903699f, -0.03237545f, 0.02347848f, 
    0.02445490f, -0.08122746f, 0.00571877f, -0.12448215f, -0.05125261f, -0.07239152f, -0.09008224f, 0.03438212f, 
    -0.06308813f, 0.07175988f, -0.12781477f, -0.04344736f, -0.01536164f, -0.01296202f, 0.04611862f, 0.05969357f, 
    -0.09071585f, -0.07317283f, 0.07761545f, 0.02997497f, -0.17069121f, -0.05766479f, -0.20482410f, 0.02521754f, 
    0.04996191f, -0.21900085f, 0.07541057f, -0.18697639f, -0.14430594f, 0.14801857f, -0.17359637f, 0.03053310f, 
    0.12040077f, 0.07243785f, 0.17192717f, 0.29113060f, -0.18973729f, 0.29197997f, -0.38653153f, 0.12194385f, 
    0.15403567f, -0.09808202f, 0.07095824f, -0.00442511f, 0.16693157f, 0.36032745f, 0.12832576f, -0.16529003f, 
    0.28934866f, -0.45617148f, 0.05605316f, 0.12066989f, -0.24598612f, -0.09367798f, -0.27050841f, -0.15949564f, 
    0.58800358f, -0.02959377f, 0.10999490f, -0.00599957f, -0.04657597f, -0.35423708f, 0.07669493f, 0.25276658f, 
    -0.40666771f, -0.12148991f, -0.34330052f, -0.40790024f, -0.41258281f, 0.62893116f, -0.19956809f, 0.32292151f, 
    0.04895646f, -0.66677791f, -0.08856593f, 0.14387101f, 0.63408589f, 0.00149738f, 0.18015732f, 0.14549913f, 
    -0.06567764f, -0.29811406f, 0.13786615f, -0.02945440f, 0.01160026f, -0.07859517f, 0.31195632f, -0.01688796f, 
    0.13866511f, 0.14957140f, 0.07620121f, -0.33812451f, 0.13324486f, 0.03702497f, -0.08329492f, -0.30096665f, 
    -0.12391241f, 0.18016535f, 0.20398085f, 0.07129428f, 0.21352503f, -0.44376454f, 0.28099647f, -0.00474357f, 
    0.21074729f, 0.05798728f, -0.09111528f, 0.37638882f, 0.05834806f, 0.13964109f, -0.16596240f, -0.14394489f, 
    0.38833663f, -0.04440091f, 0.13725609f, -0.04057671f, 0.04836950f, 0.11303462f, -0.14991479f, 0.05900318f, 
    0.53720498f, 0.30098665f, -0.17051630f, 0.67008877f, 0.00081927f, -0.37129930f, -0.34051529f, 0.70962214f, 
    -0.07286881f, -0.10067669f, 0.23608746f, -0.42651564f, 0.32956576f, 0.07710914f, -0.50125796f, 0.17804079f, 
    0.40012830f, -0.09773067f, 0.09864490f, 0.30474341f, 0.04395124f, -0.79236364f, 0.11468026f, -0.15750210f, 
    -0.19272105f, -0.36576176f, -0.09045491f, 0.14180852f, -0.15608962f, -0.05000392f, 0.23506354f, -0.11586184f, 
    0.46499908f, 0.03092917f, 0.06683088f, 0.29159102f, -0.06911632f, -0.03097991f, -0.07412432f, -0.14308371f, 
    -0.02275636f, 0.14019473f, -0.48370627f, 0.09679762f, 0.21205965f, -0.26943412f, -0.38880947f, 0.20630023f, 
    0.19433568f, -0.21965297f, -0.10398746f, 0.19735380f, 0.62805897f, -0.04101139f, 0.06058083f, -0.09225894f, 
    -0.19969922f, -0.19321227f, 0.00057307f, -0.12909362f, 0.21612355f, -0.15870197f, 0.34325212f, -0.01128449f, 
    0.39900360f, 0.28556585f, -0.17010531f, -0.50606674f, -0.06009262f, 0.40113568f, -0.32448548f, -0.34586751f, 
    -0.18210128f, 0.06403352f, -0.12777406f, -0.15355431f, 0.81747848f, 0.03625344f, 0.28459615f, -0.35618517f, 
    -0.09404241f, -0.79176056f, -0.12153422f, 0.30439106f, 0.35700142f, 0.12299760f, -0.08261190f, -0.15347145f, 
    -0.29360455f, 0.26878753f, 0.07425511f, 0.12509014f, -0.07783298f, -0.15725373f, 0.20216684f, 0.04594905f, 
    0.02066658f, -0.02861907f, -0.04946667f, 0.33790520f, 0.03396871f, 0.36647752f, 0.17933868f, -0.21528481f, 
    -0.13685013f, 0.05381025f, -0.02980409f, -0.24180441f, 0.54060256f, 0.04354214f, -0.53668618f, 0.19024228f, 
    0.00061143f, -0.12349936f, 0.05389889f, 0.11841300f, 0.47200447f, -0.44749799f, 0.14222461f, 0.02266994f, 
    -0.36859229f, 0.03204960f, -0.09059832f, -0.08196422f, 0.24585789f, -0.00430000f, 0.30889770f, 0.08377153f, 
    -0.45029315f, 0.21315372f, -0.06444774f, 0.32415611f, -0.05705864f, 0.22671562f, 0.25789747f, -0.52164072f, 
    -0.09127512f, -0.09807831f, 0.28646669f, -0.05165966f, -0.21405926f, 0.44491953f, 0.47395259f, 0.22902319f, 
    -0.37834033f, 0.23860835f, 0.14119843f, 0.52965438f, -0.16458386f, -0.51421738f, 0.02012519f, 0.02189215f, 
    0.09672850f, 0.15327390f, 0.09791161f, -0.04181678f, 0.11601946f, 0.00527542f, -0.12380368f, -0.14125577f, 
    -0.45935604f, -0.19167101f, 0.17029679f, 0.55777240f, -0.14711034f, -0.40002707f, 0.48290610f, 0.58821821f, 
    -0.04036146f, 0.11985084f, 0.00030943f, 0.13865037f, -0.42484441f, -0.23729952f, 0.46829265f, -0.34723330f, 
    -0.27337950f, 0.13173686f, -0.09527743f, 0.02531942f, -0.44446254f, -0.08854301f, 0.09341779f, 0.04181872f, 
    -0.29255295f, 0.44871351f, 0.04091501f, 0.09590766f, 0.23774083f, 0.01658419f, -0.13589488f, -0.13939975f, 
    0.07263210f, 0.09236101f, -0.16168037f, -0.03193735f, 0.16251440f, 0.44233817f, 0.38296530f, 0.45472309f, 
    0.34554777f, 0.04591139f, 0.36480334f, -0.12923759f, -0.38602749f, 0.55562764f, -0.05071905f, 0.33579156f, 
    0.00361567f, 0.08471122f, -0.16288652f, 0.22924308f, 0.07882959f, -0.23541932f, -0.15169601f, 0.06861191f, 
    0.40410426f, -0.17815384f, 0.10672915f, 0.16004001f, -0.36087927f, 0.04352088f, 0.27141070f, 0.05783742f, 
    0.31143174f, -0.38229504f, 0.16845489f, -0.37757689f, -0.16457519f, -0.33290604f, 0.14208369f, -0.36475945f, 
    -0.10385500f, 0.06289462f, 0.32417148f, 0.15244038f, 0.49443856f, -0.06135769f, 0.51767778f, 0.15498377f, 
    -0.16868593f, -0.02506101f, -0.11763693f, 0.40368551f, -0.07755572f, -0.58635247f, -0.08808097f, 0.01384393f, 
    0.35074168f, 0.28610119f, 0.12895790f, -0.03772950f, -0.13266164f, -0.02624653f, -0.03860819f, 0.06417816f, 
    -0.27897888f, -0.00926449f, 0.15182254f, 0.74266261f, 0.09461108f, -0.33583635f, -0.23474443f, 0.21266724f, 
    0.06982716f, 0.13111484f, -0.07920886f, 0.22746179f, -0.17338522f, -0.44758531f, -0.06422597f, 0.07902763f, 
    -0.00540109f, 0.11109570f, 0.18233047f, 0.42623025f, -0.07410886f, 0.20799503f, 0.13772622f, -0.09092864f, 
    -0.59879822f, 0.28355664f, -0.08235557f, -0.07931118f, -0.05602385f, 0.14108242f, -0.02261503f, -0.08169629f, 
    0.52863294f, -0.13984093f, -0.14256261f, -0.43278345f, -0.03008116f, 0.11843342f, 0.28759891f, 0.20313239f, 
    0.07577617f, -0.09083773f, -0.16773124f, -0.17615856f, -0.15936133f, 0.06453709f, 0.05079598f, -0.19340019f, 
    0.09367070f, 0.04725225f, -0.02361989f, 0.11826783f, 0.08717430f, -0.11068714f, -0.00610322f, 0.16295664f, 
    -0.02363596f, -0.09484443f, 0.07824710f, -0.15349935f, -0.14404283f, -0.03283037f, 0.00940307f, 0.03771584f, 
    -0.06276006f, 0.09445573f, 0.00324172f, -0.16371325f, -0.11164106f, -0.18171303f, -0.16099583f, -0.08181778f, 
    -0.39122561f, -0.06267344f, 0.09353615f, -0.34173518f, 0.16775861f, -0.24579898f, 0.38320363f, 0.09461203f, 
    -0.09002074f, -0.22492629f, 0.09377047f, 0.14216961f, 0.15603352f, -0.37209076f, -0.17596743f, -0.01670257f, 
    -0.53535908f, -0.04613444f, 0.00308800f, -0.02746336f, 0.30054370f, 0.16594636f, 0.22262347f, -0.17200157f, 
    -0.14663652f, 0.03017993f, 0.17234136f, 0.26525488f, 0.04688550f, 0.17545591f, -0.24133232f, 0.14824890f, 
    -0.05246314f, 0.08598504f, 0.00773289f, 0.01877805f, -0.07894479f, 0.01894426f, 0.14236809f, -0.07595706f, 
    0.14888358f, 0.03252982f, 0.09097563f, -0.05098518f, -0.17196950f, 0.01069594f, -0.15577284f, 0.08273951f, 
    0.00846639f, -0.10446670f, 0.15699175f, -0.07411019f, -0.05524760f, 0.10245177f, -0.08468873f, 0.03555579f, 
    0.13851635f, -0.13172035f, 0.01006300f, -0.07965151f, -0.08513349f, -0.05729427f, 0.04436623f, -0.15480094f, 
    -0.09353415f, 0.03203671f, 0.08790671f, 0.24662282f, 0.21319111f, 0.77987379f, 0.03885993f, 0.08907786f, 
    -0.16534080f, -0.33626956f, 0.12566671f, -0.03523808f, 0.45755887f, 0.10580872f, 0.05092377f, 0.06967437f, 
    0.62156993f, -0.10612416f, 0.15240474f, -0.15559638f, -0.18254794f, 0.02664223f, -0.09267993f, 0.05237235f, 
    0.06049054f, -0.03690697f, 0.09800501f, 0.05333837f, -0.01371423f, -0.14573483f, -0.11978108f, -0.33130568f, 
    0.32031468f, -0.00616244f, 0.23779562f, -0.19282082f, 0.22417971f, -0.44931516f, 0.23399411f, 0.35656530f, 
    -0.02740636f, 0.31175491f, -0.05864331f, 0.41152167f, -0.16877043f, -0.45980904f, 0.10442153f, -0.15823941f, 
    -0.23329386f, 0.16762292f, 0.05476952f, 0.08907782f, -0.13701133f, 0.00292128f, 0.10936807f, -0.14904188f, 
    0.58287740f, -0.15727383f, -0.03269123f, -0.65913957f, 0.09740175f, -0.20193388f, 0.13075636f, -0.27749565f, 
    -0.23617430f, -0.12233326f, 0.06640900f, 0.06204998f, 0.15405804f, 0.62467158f, 0.09217764f, 0.03484672f, 
    0.33278328f, -0.15518007f, 0.11906485f, -0.01593073f, -0.06105138f, -0.04834525f, 0.15818690f, -0.07098339f, 
    -0.61420959f, -0.15270749f, -0.15989494f, -0.04251634f, 0.20292495f, 0.03710192f, 0.33606234f, 0.16451587f, 
    -0.41951621f, 0.09159105f, 0.02554262f, 0.02697909f, -0.07921897f, 0.76797491f, 0.30024481f, -0.31668088f, 
    -0.04703506f, 0.10140448f, -0.14755630f, 0.25212336f, 0.05965455f, -0.54658628f, -0.31207907f, 0.12015943f, 
    -0.21226339f, -0.06756536f, -0.17954464f, -0.11097067f, 0.14079113f, 0.66276532f, -0.02540992f, 0.09781305f, 
    0.01860966f, 0.30583870f, 0.11555196f, 0.14939684f, 0.20362663f, 0.01382064f, 0.09913973f, 0.00811425f, 
    0.32263574f, 0.36539444f, -0.13135679f, -0.08878801f, -0.05209009f, 0.34215856f, -0.15887779f, 0.07365580f, 
    0.25557271f, -0.06300741f, 0.01187068f, 0.06963802f, -0.05060232f, -0.42847836f, -0.31440103f, -0.18307026f, 
    0.52603120f, -0.06456393f, 0.10829136f, -0.18874325f, -0.35095692f, 0.35388497f, 0.03477212f, 0.01272446f, 
    -0.11535196f, 0.17518601f, 0.14186701f, 0.05811641f, 0.25891003f, 0.11580880f, 0.13297628f, 0.12727535f, 
    0.64003682f, 0.20414984f, -0.04282044f, 0.23112120f, 0.11225254f, 0.37725559f, 0.20001546f, 0.43025672f, 
    -0.03941038f, -0.03422027f, 0.12578148f, -0.01604764f, 0.03909715f, -0.13115589f, -0.10022230f, 0.13110638f, 
    -0.06912123f, 0.03085804f, 0.15540232f, 0.01519792f, -0.12493297f, -0.11805706f, 0.06977341f, -0.10491840f, 
    -0.11815321f, -0.06100500f, -0.12381139f, 0.05431191f, -0.18476765f, 0.04342879f, -0.07841902f, 0.03686557f, 
    0.01532181f, -0.01458413f, -0.04855395f, -0.18439524f, 0.07357553f, -0.08535931f, -0.15816668f, -0.13869230f, 
    -0.16552939f, -0.08209473f, -0.01903381f, 0.10591450f, -0.03161699f, -0.03888572f, -0.06357618f, -0.03698094f, 
    -0.07581469f, -0.15974811f, -0.11363861f, 0.03307168f, -0.08471632f, 0.03333553f, -0.07968696f, -0.13561463f, 
    -0.18382613f, -0.06497068f, -0.16282690f, 0.15567958f, -0.14197105f, 0.17406353f, -0.22011882f, -0.10882603f, 
    -0.07898862f, -0.02912262f, 0.07419769f, -0.12030953f, 0.02991330f, -0.03985910f, -0.00450982f, -0.15278843f, 
    -0.25500435f, 0.08187001f, 0.02721372f, 0.35768896f, -0.35827994f, -0.21550158f, -0.27830377f, -0.16536345f, 
    -0.23877135f, -0.28471875f, 0.05189126f, 0.17644289f, 0.57034367f, -0.00804868f, -0.15444154f, -0.15739775f, 
    0.47965825f, 0.36946017f, 0.00177351f, 0.08177862f, -0.06368895f, 0.11349753f, -0.18419509f, 0.16228129f, 
    0.48256639f, -0.12155044f, 0.03587754f, 0.11631907f, 0.12494200f, -0.01424449f, 0.33398101f, 0.14793895f, 
    0.16385968f, -0.01622161f, 0.04402795f, -0.25192231f, -0.18510620f, 0.14048125f, 0.37302116f, 0.18996312f, 
    0.38326499f, 0.05830813f, 0.00314371f, -0.22931555f, -0.26187101f, 0.44968617f, 0.00088077f, 0.00352175f, 
    0.07942740f, -0.15912133f, 0.07352693f, -0.03824548f, 0.06565141f, -0.00731062f, -0.00475854f, 0.13847589f, 
    -0.37092751f, 0.36289802f, -0.00719573f, 0.35257125f, -0.01626588f, -0.16977955f, -0.19048402f, 0.73202026f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.14635187f, -0.18640162f, 0.15750797f, 0.07649332f, -0.13962959f, 0.13629362f, 0.12130072f, -0.08928911f, 
    0.18587855f, 0.21052152f, 0.19371168f, 0.15325531f, 0.31796083f, 0.10206757f, 0.28781399f, 0.28068548f, 
    -0.06262302f, -0.04156182f, -0.19549741f, 0.51697594f, -0.01383198f, 0.21953212f, 0.03162346f, -0.38264227f, 
    0.38760191f, 0.16628201f, 0.38480279f, 0.13809778f, 0.17884694f, -0.09095155f, 0.25735593f, -0.09983240f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.28909609f, 0.31147486f, -0.94851249f, -0.27565664f, -0.12480764f, 0.10290337f, 0.15127623f, -0.15132335f, 
    -0.23750792f, 0.07106650f, -0.10410774f, -0.63455164f, -0.03731150f, -0.22412519f, -0.80300254f, 0.16540498f, 
    0.31213155f, 0.14631513f, 0.26489246f, 0.00520405f, -0.04859165f, 0.38595501f, -0.16858590f, 0.01508526f, 
    0.19762313f, -0.05864157f, -0.30397612f, -0.40800732f, -0.13822190f, 0.00875139f, -0.49563062f, 0.26339638f, 
    0.00383061f, 0.32471928f, -0.20908956f, 0.42532367f, -0.24567565f, 0.08976508f, 0.12084156f, 0.08145339f, 
    0.26094076f, -0.61509407f, 0.14715227f, -0.17124607f, -0.54267234f, -0.94448888f, -0.28814459f, 0.15813476f, 
    0.47703722f, -0.12632695f, -0.09143686f, 0.16270299f, 0.12789898f, -0.69743288f, -0.11614145f, -0.32318264f, 
    -0.19254105f, -0.29976514f, 0.12125780f, 0.19319378f, 0.07802004f, -0.02452320f, 0.08276615f, 0.29136425f, 
    0.12330855f, -0.49053112f, 0.21521805f, 0.03975227f, 0.15627533f, -0.04239309f, -0.13006455f, -0.13366839f, 
    0.33768663f, -0.12564586f, 0.02524059f, 0.21989062f, 0.08726430f, -0.47197628f, -0.39822254f, -0.48861095f, 
    -0.72564483f, 0.34278944f, -0.47329512f, 0.33205220f, 0.02177830f, -0.72268957f, -0.02832845f, -0.11113690f, 
    0.53826147f, -0.12821345f, -0.00759056f, 0.22221574f, -0.00685571f, -0.18347719f, 0.29191846f, -0.38405830f, 
    -0.00159154f, 0.34287599f, 0.00635275f, -0.39457956f, 0.28058898f, -0.10947851f, -0.09143887f, 0.07357419f, 
    0.35188439f, 0.35830018f, -0.62192118f, -0.08561812f, -0.14836277f, -0.13104819f, 0.12969872f, 0.19756660f, 
    -0.47121283f, 0.39266419f, -0.23229927f, -0.01072829f, 0.01765016f, -0.55629176f, 0.02327494f, 0.37951434f, 
    -0.13924362f, 0.15783539f, -0.42792755f, -0.47185105f, -0.19828817f, 0.00524452f, -0.00793060f, -0.38236377f, 
    -0.03221444f, -0.08456905f, 0.15518235f, 0.22652823f, -0.44590652f, -0.13231884f, -0.11828857f, -0.03056357f, 
    -0.02644244f, -0.71024990f, -0.05318022f, 0.06965282f, -0.42919216f, 0.47451678f, 0.20423819f, 0.04590223f, 
    -0.60984874f, 0.08475554f, 0.31794015f, -0.07447460f, -0.16773714f, 0.07931954f, -0.07190678f, 0.11327360f, 
    0.27006546f, 0.02126238f, -0.29579225f, -0.19005130f, -0.05776152f, 0.16664726f, -0.80166215f, -0.02503405f, 
    -0.12923844f, -0.14398466f, 0.41881758f, -0.33092245f, 0.04090193f, 0.08791081f, 0.00372712f, 0.11285743f, 
    0.05129680f, -0.89702928f, 0.23346221f, -0.17968322f, -0.03998321f, 0.49234563f, -0.18108580f, 0.11271866f, 
    0.25229591f, -0.34840259f, 0.23323134f, 0.23574461f, -0.01754768f, 0.05376047f, 0.01154301f, -0.23075111f, 
    -0.04395915f, -0.11772452f, 0.06883907f, -0.01738360f, 0.08517031f, 0.00599447f, 0.17445140f, -0.13716099f, 
    0.03939343f, -0.91471928f, 0.06029648f, -0.67815036f, -0.16535328f, 0.03754549f, 0.08502353f, 0.08838919f, 
    0.29523474f, 0.64302254f, 0.02966078f, -0.06376952f, 0.57080573f, -0.01304120f, 0.03196327f, -0.87094903f, 
    -0.43197259f, -0.20586856f, -0.57600439f, -0.05195436f, 0.11749329f, -0.13569881f, 0.09340826f, 0.11935850f, 
    -0.34927592f, -0.07639728f, 0.30441603f, 0.09671348f, 0.07537362f, -0.03529326f, -0.82179660f, 0.42296314f, 
    0.02844821f, -0.65174240f, -0.34563395f, -0.04290335f, 0.54207009f, 0.00687024f, 0.11781108f, -0.13841218f, 
    0.30045217f, 0.17626110f, 0.17499995f, 0.11038361f, -0.20363323f, -0.22521965f, -0.23128515f, -0.06929803f, 
    -0.22809272f, 0.16053824f, 0.26704940f, -0.92337823f, 0.11245580f, -0.20849983f, -0.12598991f, 0.52701533f, 
    -0.41538793f, -0.63507479f, -0.02669831f, -0.04645434f, 0.08327293f, -0.09411354f, 0.49324077f, -0.09139182f, 
    -0.04754942f, -0.14779925f, 0.36967158f, 0.37647036f, -0.24646181f, 0.09204274f, 0.14873654f, 0.14852537f, 
    0.24123256f, -0.25989929f, 0.08290208f, -0.62991625f, 0.13491958f, 0.21803413f, 0.06425562f, -0.42507723f, 
    -0.28982282f, -0.38042158f, -0.02246339f, -0.19567530f, 0.04132773f, -0.73410982f, 0.01590106f, 0.51872283f, 
    -0.58742464f, -0.13490205f, 0.33337396f, -0.06366591f, -0.12639743f, 0.06155809f, 0.82896495f, -0.30193311f, 
    0.01121612f, -0.52845925f, 0.06187633f, -0.11362810f, -0.46626568f, 0.04970268f, 0.16863264f, -0.18572575f, 
    -0.30904648f, 0.46830183f, -0.16182449f, 0.30489621f, 0.29714316f, -0.46042189f, 0.58245009f, -0.04780155f, 
    -0.25474438f, 0.11058827f, -0.08036012f, 0.00641427f, 0.07582254f, 0.52998894f, -0.05671642f, -0.28245100f, 
    0.30152032f, -0.11543958f, 0.05212714f, -0.29211763f, -0.17391138f, -0.16698059f, -0.24707849f, -0.27317846f, 
    -0.09797884f, 0.19804750f, 0.35844636f, 0.10445495f, 0.06057756f, -0.09231393f, -0.09451970f, 0.14654978f, 
    -0.62628168f, -0.19444089f, -1.04535389f, -0.48512095f, -0.09099348f, 0.34791988f, 0.30008098f, -0.34424341f, 
    0.54766214f, -0.26025823f, -0.57045972f, 0.20274660f, 0.04421658f, -0.24529652f, -0.02581801f, -0.49108696f, 
    -0.15004827f, 0.24739324f, 0.31460902f, 0.28811577f, 0.09388856f, -0.12839638f, 0.05589452f, -0.67870504f, 
    -0.07581964f, -0.32106799f, -0.03065384f, 0.30473313f, 0.34656602f, -0.00492715f, 0.15459642f, -0.01660539f, 
    -0.14934249f, -0.14485970f, 0.04516658f, 0.33890903f, 0.06093888f, 0.39994049f, 0.30029321f, -0.36959904f, 
    -0.59962010f, -0.60980111f, -0.14432284f, -0.33622798f, -0.17802395f, 0.50058049f, -0.04527186f, -0.17987609f, 
    -0.79014242f, 0.40031508f, -0.11539814f, 0.30304104f, -0.04728173f, 0.12089282f, -0.39096200f, 0.24528447f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.03159385f, 0.36206156f, 0.17691930f, 0.06772782f, -0.23982196f, -0.09100860f, -0.02168637f, -0.38310489f, 
    0.05080750f, 0.04149542f, -0.04313344f, -0.06442925f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
