#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.89227945f, -0.26423961f, -0.58354145f, 0.00866824f, -0.30613649f, -0.63598740f, -0.49166220f, -0.08265016f, 
    0.13544494f, -0.29202011f, -0.54452217f, -0.23222823f, 0.26476294f, -0.01825444f, 0.23186480f, 0.13205725f, 
    -0.17129523f, -0.57777500f, 0.11315849f, 0.44310358f, 0.26025984f, 0.09898089f, -0.12436632f, -0.03040944f, 
    0.06931610f, -1.07911909f, 0.60452843f, 0.02182282f, -0.49378037f, 0.20583637f, 0.24771164f, 0.70603281f, 
    -0.59434688f, -0.23695131f, -0.29621109f, 0.11792927f, 0.10997129f, 0.26760444f, -0.08582841f, 0.22213939f, 
    0.18865089f, 0.03466022f, 0.07796189f, -0.06042923f, 0.10223785f, 0.07861329f, 0.11947589f, -0.08239870f, 
    0.06174001f, 0.17604233f, 0.71740156f, 0.33611196f, -0.45206332f, -0.46830735f, -0.76946855f, 0.83818012f, 
    0.47843102f, 0.11359069f, 0.34228233f, 0.03764500f, -0.43055299f, -0.41694900f, -0.41508323f, -0.15092877f, 
    0.05642411f, -0.15710109f, -0.08413054f, -0.21142684f, 0.06199808f, -0.07218768f, -0.09103125f, -0.15672076f, 
    -0.10961211f, -0.27237344f, 0.04211464f, -0.15297161f, -0.85571486f, -0.39049020f, -0.18783438f, 0.56064087f, 
    0.71623850f, 0.80879933f, -0.09093964f, -0.01275955f, 0.28763014f, 0.10357324f, 0.12642159f, -0.26800644f, 
    0.09490900f, -0.04123108f, -0.00329554f, 0.14565170f, 0.15228872f, -0.03058666f, 0.16942108f, 0.05719811f, 
    -0.03379042f, -0.14004263f, -0.08709355f, 0.09263485f, -0.70550334f, -1.09180927f, 0.29192162f, 0.01415194f, 
    -0.56729579f, 0.11807691f, 0.12504990f, 0.59730476f, -0.46876186f, -0.01428503f, -0.11179933f, -0.05011958f, 
    0.21240710f, 0.31926623f, 0.08627367f, -0.28580147f, 0.08143017f, 0.18681064f, -0.23584425f, -0.08315139f, 
    0.05596518f, -0.13265973f, 0.01183698f, -0.22553669f, 0.02885842f, 0.12142866f, -0.94344765f, 0.12579390f, 
    -0.14149565f, -0.06411779f, 0.73962307f, -0.62217528f, 0.59782583f, 0.49594307f, -0.12316691f, 0.16211283f, 
    -0.26249710f, -0.21317784f, 0.30871475f, -0.27719754f, 0.24865615f, 0.27445039f, 0.13148159f, 0.16567035f, 
    0.11078832f, 0.07492094f, 0.15897593f, 0.28348482f, 0.09702165f, 0.26874417f, 0.35244021f, -0.25779068f, 
    -0.99767911f, -0.96945137f, 0.13742232f, -0.11852840f, 0.17670400f, 0.34244412f, 0.00435919f, 0.34655884f, 
    -0.36394301f, -0.03612229f, -0.07086748f, -0.21769701f, -0.22572172f, -0.04641718f, -0.04495022f, 0.11424250f, 
    0.08926098f, -0.18785959f, -0.15734775f, -0.07058758f, -0.19792920f, -0.06381035f, 0.14924285f, 0.61466610f, 
    -0.24148418f, 0.29483849f, 0.92204416f, 0.59653902f, -0.79707849f, 0.68046600f, -0.03930671f, -0.09748022f, 
    0.41447762f, 0.20728992f, 0.12071943f, -0.00525912f, -0.23599905f, 0.12465081f, -0.21968770f, -0.01792882f, 
    -0.06202998f, 0.32129344f, -0.25637093f, 0.15674564f, 0.06813852f, -0.10769954f, -0.00709700f, 0.06647437f, 
    0.19693662f, -0.29298213f, -0.52295983f, 0.63720900f, 0.04395510f, 0.30491471f, 0.50737596f, 0.45379862f, 
    0.69548017f, 0.51538724f, -0.03306248f, -0.43868089f, -0.23556274f, -0.16836824f, -0.36184901f, -0.16579655f, 
    -0.32479915f, 0.08012943f, -0.17293158f, -0.23475808f, -0.19043352f, -0.30957741f, -0.06248809f, -0.29975602f, 
    -0.05456939f, -0.41328308f, 0.64564568f, -0.86807245f, 0.52980930f, -0.16989887f, 0.31359950f, -0.51223660f, 
    -0.73962367f, -0.37632868f, -0.25176305f, -0.24151295f, -0.14992796f, 0.13889079f, 0.07566652f, -0.22635168f, 
    -0.35793275f, -0.11666448f, -0.10964181f, -0.01567618f, -0.26747143f, -0.15424903f, -0.04490977f, 0.24379778f, 
    -0.19227630f, -0.01918324f, -0.47077286f, -0.47270930f, -0.84662604f, -0.38066339f, -0.05989661f, 0.52980542f, 
    0.01116886f, 0.01656366f, 0.27299282f, 0.20572755f, -0.44941938f, -0.04365409f, 0.09027234f, 0.29646787f, 
    0.24426246f, 0.00717123f, -0.30339578f, -0.17936568f, 0.06637084f, -0.41800714f, -0.08078674f, 0.11362440f, 
    0.07367131f, 0.03865118f, 0.17861114f, 1.04016531f, 0.58683312f, -0.39298144f, 0.50442564f, 0.65728605f, 
    0.10158630f, -0.33236149f, -0.45010486f, 0.12871346f, 0.15223925f, -0.07241110f, -0.31173283f, -0.34382233f, 
    -0.25925896f, -0.17030816f, 0.19342403f, 0.14065617f, -0.20759398f, -0.13923906f, 0.07526387f, -0.16127977f, 
    0.21631111f, 0.29353541f, -0.09815740f, 0.27687985f, 0.65283298f, 0.88020021f, 0.98773932f, 0.90210450f, 
    -0.32296512f, -0.09965462f, -0.57234311f, -0.79351503f, -0.43981501f, 0.09760558f, -0.20029016f, 0.27868322f, 
    -0.02980407f, 0.14227143f, 0.07769313f, 0.00060469f, -0.15252580f, 0.08199845f, 0.03106979f, 0.04183735f, 
    0.11683492f, -0.00315108f, 0.06325057f, -0.05782057f, 0.06081649f, 0.91098243f, 0.55784702f, 0.66740257f, 
    0.26222736f, 0.84617490f, 0.47467798f, 0.30835143f, 0.29338655f, 0.59739202f, 0.01546672f, -0.09786215f, 
    0.25981179f, 0.04514640f, 0.21712935f, -0.16036469f, -0.04099217f, 0.02372632f, 0.24180849f, 0.18579538f, 
    -0.04937545f, 0.06077857f, -0.08720051f, 0.05420072f, 0.12902720f, 0.20535798f, -0.50111210f, -0.95625502f, 
    -0.82682008f, -0.30652314f, -0.26629516f, -0.64167911f, 0.20000307f, 0.29343539f, 0.18900836f, 0.47113580f, 
    0.37913385f, 0.05983040f, 0.09405020f, -0.21356720f, -0.24272795f, 0.09056974f, 0.17922910f, 0.07806107f, 
    0.06980206f, 0.05656709f, 0.00543564f, -0.07608087f, -0.04263289f, 0.10559876f, 0.19398493f, -0.67358470f, 
    0.33756331f, 0.36537632f, 0.26422259f, 0.65501446f, -1.08449745f, 0.26267737f, 0.14778623f, -0.33976701f, 
    0.26626891f, -0.43320698f, 0.13245602f, 0.37073398f, 0.09977627f, 0.27252126f, 0.44491753f, -0.02223196f, 
    0.15199991f, -0.16118263f, -0.17027958f, -0.16433638f, -0.18162055f, -0.07065780f, 0.08995686f, -0.17499954f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.23390102f, 0.12198064f, -0.05065220f, 0.36075127f, 0.15434238f, 0.04348073f, 0.00456695f, 0.04105164f, 
    -0.07029791f, 0.25373453f, -0.09969096f, -0.10292379f, 0.02804961f, 0.34087384f, 0.09616881f, -0.03187606f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.26419604f, -0.02185176f, 0.05675218f, 0.18723057f, 0.14729232f, -0.01395809f, -0.11096384f, -0.13646437f, 
    0.08157329f, -0.00097987f, -0.01619036f, 0.11291537f, 0.03202244f, -0.18570144f, 0.09621629f, -0.04093444f, 
    -0.04553950f, 0.04441933f, 0.09984512f, -0.01819830f, 0.09099051f, -0.00631845f, -0.01164285f, 0.07679067f, 
    -0.32426953f, 0.04351356f, 0.37402228f, 0.10177816f, 0.07338525f, -0.01874919f, -0.01361837f, 0.04302826f, 
    0.12939069f, -0.03611304f, -0.01398299f, 0.01637153f, -0.24488720f, 0.19949186f, -0.07931963f, 0.09410761f, 
    0.18860623f, 0.07244197f, 0.08763284f, 0.01091241f, 0.10892110f, 0.08445986f, 0.07996569f, -0.09763571f, 
    -0.09735464f, 0.13934867f, -0.13168131f, -0.00536459f, 0.26149109f, 0.09652604f, -0.02888715f, 0.07949942f, 
    -0.15690728f, 0.05400817f, -0.10265008f, 0.02583301f, 0.41433793f, -0.06958399f, -0.09699903f, -0.03731725f, 
    0.14489813f, -0.07699265f, 0.15096115f, -0.05719468f, -0.02063269f, -0.05744871f, 0.04537940f, 0.05734428f, 
    -0.26696786f, 0.00759831f, -0.12152001f, -0.02951325f, -0.08409971f, -0.13932963f, 0.04654509f, 0.04167011f, 
    0.13242930f, -0.02164969f, -0.00848184f, -0.02170649f, -0.44377521f, -0.00069698f, -0.03870280f, -0.05304717f, 
    -0.09161741f, 0.05931871f, -0.01075915f, -0.03499230f, 0.04130833f, 0.11852405f, 0.14154747f, 0.22740932f, 
    -0.34585837f, 0.16053994f, -0.07501084f, 0.03083087f, 0.14602461f, 0.07504725f, 0.10677728f, 0.05747392f, 
    0.05189218f, 0.01261238f, 0.03298109f, 0.12473641f, 0.12699543f, -0.05567155f, 0.23555280f, -0.05312614f, 
    -0.05537114f, 0.10912595f, 0.04170923f, -0.04147272f, -0.02750142f, -0.17410898f, -0.05797165f, 0.13324930f, 
    -0.22445562f, -0.16743474f, 0.02453451f, 0.15080930f, 0.12087421f, -0.30457070f, -0.00801193f, 0.05224791f, 
    0.16650446f, 0.07813835f, -0.01920853f, 0.00409834f, 0.02685005f, -0.06083437f, 0.16640362f, 0.11970872f, 
    -0.07085443f, 0.13173720f, 0.06991411f, 0.14705461f, 0.00970492f, -0.07704383f, 0.05044360f, 0.01730818f, 
    -0.04211239f, 0.23009174f, 0.37978277f, -0.24610122f, 0.06434279f, 0.16041072f, -0.02230980f, -0.02488287f, 
    0.04524951f, -0.00671315f, -0.01673712f, 0.04229685f, -0.01957304f, 0.12928836f, -0.16252171f, -0.37371829f, 
    -0.04621401f, 0.10144727f, 0.13915052f, -0.00315791f, 0.04892614f, 0.13651764f, -0.02794093f, 0.05782477f, 
    -0.48465422f, -0.05843247f, -0.12213533f, -0.09646546f, 0.00224995f, -0.06305355f, -0.00432119f, 0.15981850f, 
    -0.03099933f, 0.11730968f, -0.04003102f, -0.04682044f, -0.13063553f, -0.15829831f, 0.06008359f, 0.06230093f, 
    -0.10230179f, -0.00804851f, 0.01388595f, 0.04655043f, 0.13907464f, 0.17205603f, 0.15267715f, 0.11660389f, 
    -0.30557978f, 0.04174275f, 0.02889762f, 0.06487051f, 0.04020747f, 0.08821890f, -0.04850644f, -0.12285630f, 
    0.10231424f, 0.09315950f, 0.00629638f, 0.00763696f, 0.00492549f, -0.20294207f, -0.12865382f, 0.12866738f, 
    0.09277499f, -0.05934048f, 0.06337319f, 0.00259010f, -0.07220045f, 0.02330703f, 0.10079627f, -0.10485002f, 
    -0.13749588f, 0.25298384f, -0.00224659f, 0.22584371f, -0.00976422f, 0.10509575f, 0.01315018f, -0.08980318f, 
    0.14990406f, -0.00721231f, 0.03275372f, 0.10028822f, 0.22276670f, 0.17888342f, -0.05361699f, 0.00036496f, 
    0.19111906f, 0.07347662f, 0.01224018f, 0.11742807f, 0.09035559f, -0.03008472f, 0.07050762f, 0.01254711f, 
    0.22017387f, 0.03446101f, -0.11718027f, 0.03563364f, 0.04248806f, -0.10164100f, -0.00517314f, 0.06753436f, 
    0.07281698f, 0.07976259f, -0.01509070f, -0.04609369f, -0.12203175f, -0.01424159f, -0.01537684f, 0.07643788f, 
    0.07549760f, -0.04465565f, 0.19753207f, -0.03285145f, 0.04617798f, 0.04681609f, 0.04527470f, 0.03568425f, 
    0.06502865f, -0.13912126f, -0.18709251f, 0.42581356f, -0.03825109f, 0.08786105f, 0.04096298f, 0.17096604f, 
    0.15441497f, -0.06545798f, -0.02473253f, 0.04287796f, -0.17576025f, 0.00470346f, 0.09458464f, -0.38796797f, 
    0.11862746f, -0.07288112f, 0.03839643f, 0.02270782f, 0.15821940f, -0.04546563f, 0.04298680f, 0.08140889f, 
    -0.16496943f, -0.06379905f, -0.04409583f, -0.11123777f, -0.06273890f, 0.03102905f, -0.03328122f, 0.03133096f, 
    0.06860999f, -0.16066903f, -0.05810995f, 0.09243271f, -0.17678091f, 0.05895915f, 0.25034642f, 0.07138626f, 
    -0.05642112f, 0.13939781f, 0.14555727f, -0.03020663f, -0.13450649f, 0.10417942f, 0.01705845f, 0.10162146f, 
    -0.25663659f, -0.07105181f, 0.13891923f, -0.08756249f, 0.10436967f, 0.11613250f, 0.04085468f, 0.02633222f, 
    0.04496370f, 0.02579757f, 0.03669209f, 0.07628741f, -0.44119725f, 0.18899362f, 0.00726852f, -0.33454490f, 
    -0.08672858f, 0.00858008f, 0.08131344f, -0.14646684f, 0.19998758f, -0.02918139f, 0.04645078f, 0.09326877f, 
    -0.36520633f, 0.26019931f, 0.43038294f, -0.35475266f, 0.13899919f, 0.10397875f, 0.01028772f, 0.01366717f, 
    -0.12361392f, 0.03475318f, 0.07475252f, 0.05047712f, -0.38309002f, 0.24977118f, 0.24632595f, -0.11731900f, 
    -0.01667352f, 0.14680010f, 0.00527902f, -0.10614270f, 0.05732409f, 0.08339781f, 0.06722403f, 0.07638563f, 
    -0.12683612f, -0.21926185f, 0.04772944f, 0.04710107f, 0.16248989f, 0.12069596f, -0.08197960f, -0.02702766f, 
    -0.04525108f, 0.04118394f, 0.01935130f, 0.05885064f, 0.49585080f, -0.12759323f, 0.05399832f, -0.18081313f, 
    0.01149737f, 0.07902820f, 0.07045891f, 0.06101587f, 0.07656032f, -0.03362433f, 0.15499856f, -0.01102797f, 
    0.36492881f, 0.13705331f, -0.16814990f, 0.10020769f, -0.08390158f, 0.18816061f, 0.02883956f, -0.06703846f, 
    -0.00609359f, -0.07508957f, 0.11822303f, -0.11812078f, 0.01478351f, 0.29389110f, -0.07494724f, 0.05978017f, 
    0.07193568f, 0.02419002f, 0.00109347f, -0.06502801f, -0.01447904f, -0.06796263f, -0.03002732f, -0.08345229f, 
    -0.31342405f, 0.03550153f, 0.13373424f, 0.16487201f, -0.05545132f, -0.00643777f, 0.03077475f, 0.07158245f, 
    -0.02944483f, -0.03598967f, 0.01527490f, 0.00136721f, -0.28843585f, -0.10989647f, -0.11445096f, 0.05292633f, 
    -0.14278221f, -0.06891222f, 0.04706444f, -0.07912369f, -0.06349189f, 0.10462864f, 0.03987126f, 0.03628145f, 
    -0.11974080f, -0.00388711f, 0.28220341f, -0.01555633f, -0.02649109f, 0.10450881f, 0.03369989f, -0.01555367f, 
    -0.13552199f, 0.05591963f, -0.08265714f, 0.24620968f, 0.19235696f, 0.16644207f, -0.04556388f, -0.20391609f, 
    0.06664924f, -0.08020241f, -0.17185877f, -0.12642063f, 0.04898139f, -0.09554675f, -0.08553051f, -0.02249484f, 
    -0.21290609f, 0.08971877f, 0.25695068f, -0.05296514f, 0.09208842f, -0.19565992f, 0.02837440f, -0.00587761f, 
    -0.04670489f, 0.08554853f, 0.09900544f, 0.03324261f, 0.21753304f, 0.08808630f, 0.08062306f, 0.00325250f, 
    -0.06724086f, 0.08934605f, 0.04310630f, -0.00094993f, -0.07804119f, 0.02440322f, 0.09918503f, 0.01370680f, 
    -0.16966510f, -0.29418641f, 0.08246741f, 0.02138649f, 0.03518959f, -0.00776162f, 0.16777043f, 0.04067719f, 
    0.04905885f, 0.13799115f, 0.25059929f, 0.05117059f, 0.02106271f, 0.02790163f, 0.00433125f, 0.18874727f, 
    0.02650703f, 0.01539475f, -0.07731932f, 0.01991971f, 0.12417347f, 0.06555460f, 0.07795804f, 0.09525164f, 
    -0.01968302f, -0.03339562f, 0.03933311f, -0.00360965f, -0.00643896f, -0.08593475f, -0.15313569f, -0.04680419f, 
    0.03548210f, 0.01860319f, 0.02886091f, -0.05574906f, 0.15715143f, 0.22948642f, -0.01597620f, 0.15004650f, 
    0.00453178f, 0.22324999f, -0.14576371f, 0.18071598f, -0.16617906f, -0.08773617f, -0.04512120f, 0.02125512f, 
    0.08869302f, -0.05168016f, -0.07196776f, 0.03328531f, 0.03266772f, 0.00022518f, -0.06370188f, 0.02640324f, 
    0.25274560f, -0.18844494f, -0.00779008f, -0.10527923f, 0.12230079f, 0.07093560f, -0.14892383f, 0.09128513f, 
    -0.14861205f, -0.08217093f, 0.01548958f, 0.06426443f, -0.04868719f, 0.02463661f, -0.04785538f, -0.16416238f, 
    0.08647572f, 0.25153634f, 0.03029420f, 0.14928162f, 0.02806465f, 0.08961001f, 0.00171807f, 0.06223371f, 
    -0.00659489f, 0.17510203f, 0.15763551f, -0.21177559f, -0.44654724f, 0.14759395f, 0.20400685f, 0.15479030f, 
    -0.09467360f, -0.02391884f, 0.06006878f, 0.14214934f, -0.01706339f, 0.06340832f, -0.07335362f, 0.00052747f, 
    0.12949093f, 0.02521413f, -0.15627398f, -0.15404396f, -0.08404246f, -0.01043543f, 0.09445982f, 0.02284027f, 
    -0.08333222f, -0.12718141f, 0.00441290f, 0.00466378f, 0.36579704f, 0.12332201f, -0.10241131f, -0.02680429f, 
    -0.03664385f, 0.08902255f, -0.04453940f, 0.08011346f, -0.10528196f, -0.10841689f, -0.17424628f, -0.10561879f, 
    -0.17576383f, -0.17091693f, 0.08670627f, 0.11115075f, 0.06617556f, -0.10848822f, 0.13470042f, 0.20636362f, 
    -0.12777594f, -0.03852969f, 0.11145788f, 0.04721462f, 0.24486150f, -0.47843441f, 0.03613526f, -0.05722975f, 
    -0.11682220f, 0.07496372f, 0.06161006f, 0.09132443f, -0.12535527f, 0.07828128f, -0.04780519f, 0.03240500f, 
    0.32293737f, -0.09842275f, -0.03025006f, -0.01524835f, -0.19791298f, 0.12264902f, 0.04918291f, 0.08100334f, 
    0.07782007f, 0.03710305f, -0.00327284f, -0.01595550f, -0.16269708f, 0.06277812f, -0.10237093f, 0.05083736f, 
    0.03647448f, -0.04468123f, -0.14432676f, -0.07752260f, -0.08795290f, -0.01897273f, 0.09965699f, -0.12542017f, 
    0.13008505f, -0.01479712f, 0.26911661f, -0.05577217f, 0.06476497f, -0.22362144f, 0.23025350f, 0.01858442f, 
    -0.11074229f, 0.18839300f, 0.09399877f, 0.12234867f, 0.32399905f, -0.11661598f, 0.16645786f, 0.08454496f, 
    0.05796536f, 0.19859251f, 0.10535433f, -0.03114716f, -0.11009020f, 0.01744918f, 0.00037004f, 0.00713829f, 
    0.01678655f, -0.26340738f, 0.00812456f, -0.11801011f, 0.00639668f, -0.04829179f, 0.07400436f, 0.18886654f, 
    0.09890147f, 0.31941140f, 0.05756410f, 0.13507088f, 0.12800193f, 0.03519421f, -0.22329916f, -0.02005915f, 
    0.12127925f, 0.01749019f, -0.03439268f, 0.07889239f, 0.03341914f, 0.09437241f, -0.10732036f, 0.06376187f, 
    0.15974244f, 0.11887720f, -0.01497560f, 0.05365271f, -0.14606231f, -0.13632070f, -0.14727217f, -0.04167146f, 
    -0.02023906f, 0.09372918f, -0.19048510f, 0.11965324f, 0.22431540f, 0.05007908f, -0.21452202f, -0.09692032f, 
    0.08747804f, 0.05753217f, 0.01825255f, 0.08260714f, -0.05369177f, -0.00407703f, 0.08966248f, -0.07017291f, 
    0.25167266f, -0.04645040f, -0.23783351f, 0.02628130f, -0.08820357f, 0.19009678f, 0.11409959f, -0.07712340f, 
    0.14399314f, -0.11512149f, -0.02830463f, -0.07477545f, 0.01603258f, -0.02986033f, -0.01477983f, 0.06191533f, 
    -0.03470813f, -0.11192734f, 0.14173582f, 0.15538678f, -0.04253139f, -0.03267271f, -0.15374762f, -0.05318433f, 
    0.56273288f, -0.07295351f, 0.01625918f, 0.05170657f, -0.01189009f, -0.04165788f, 0.15314394f, -0.03883905f, 
    -0.01905723f, 0.02416714f, 0.06241230f, -0.16619720f, 0.02702909f, 0.08973508f, 0.15304719f, -0.05161932f, 
    -0.04337735f, 0.05880339f, 0.02152240f, -0.10948505f, -0.05609910f, 0.02999370f, -0.17278650f, -0.05025518f, 
    -0.11377835f, -0.16172515f, 0.12341604f, -0.08380190f, 0.03439903f, -0.04494246f, 0.14285015f, 0.00663411f, 
    0.09794082f, -0.22127272f, 0.14632343f, 0.06098199f, -0.13275260f, -0.04495499f, 0.12566479f, 0.08432644f, 
    0.12032343f, -0.08609640f, -0.01540789f, 0.15437187f, -0.01428966f, 0.09214153f, -0.08640333f, 0.06007667f, 
    0.51026398f, 0.03944215f, -0.19185659f, -0.10960604f, -0.04637972f, 0.18738793f, -0.12579435f, 0.05293167f, 
    -0.12080552f, 0.18636309f, 0.02954534f, 0.00273456f, 0.01284716f, 0.03097831f, -0.01783236f, -0.04331720f, 
    0.05392784f, 0.00608184f, 0.04797698f, 0.09797449f, 0.11999504f, -0.04352299f, 0.13019516f, 0.06491578f, 
    -0.58069044f, -0.24871707f, 0.06953537f, -0.17470188f, 0.09565695f, -0.06646529f, -0.00283875f, 0.03395913f, 
    0.01419353f, -0.06781401f, -0.02556727f, -0.00726689f, -0.17859533f, -0.05278306f, 0.12014307f, -0.01574218f, 
    -0.08617373f, 0.13377573f, 0.09335915f, 0.00015935f, -0.15126567f, -0.11954800f, -0.06472278f, -0.00542322f, 
    -0.25485906f, 0.25377253f, -0.04209896f, -0.37381193f, 0.00556545f, 0.04142703f, 0.08112038f, -0.09614371f, 
    0.08234716f, -0.08940420f, 0.15039404f, 0.15475428f, 0.28168136f, 0.20007086f, 0.16908723f, 0.17855591f, 
    -0.08050874f, -0.06843729f, 0.00969023f, -0.03786669f, 0.08364179f, -0.04217033f, -0.04128271f, 0.09444279f, 
    0.16956080f, 0.14098883f, -0.04163186f, 0.11811946f, 0.06032270f, -0.04558885f, 0.04540084f, -0.11698384f, 
    -0.09292027f, -0.02324174f, 0.00529440f, 0.05927242f, 0.28496772f, 0.11422165f, 0.22590245f, 0.21321449f, 
    -0.11794805f, 0.06478775f, 0.02412637f, 0.06658157f, 0.03302404f, 0.11920177f, 0.00826696f, 0.21846020f, 
    -0.25477892f, -0.08288622f, -0.09567608f, -0.25126040f, -0.09860973f, 0.27246615f, 0.00518037f, 0.04085828f, 
    -0.14614353f, -0.04090749f, 0.11390460f, -0.02396959f, -0.05344116f, 0.11408921f, 0.05145240f, 0.07033405f, 
    0.05496018f, -0.01156923f, -0.01169324f, 0.03596909f, 0.04681635f, 0.00681159f, 0.02502093f, 0.01975290f, 
    0.48954713f, 0.16200109f, -0.00876921f, 0.26405182f, -0.02937195f, 0.00359885f, -0.05145842f, 0.01367574f, 
    -0.10688514f, 0.05514620f, 0.06017311f, -0.01343685f, 0.20620258f, 0.07033621f, 0.30820668f, 0.09010249f, 
    0.12395570f, -0.02231808f, -0.05884872f, -0.03442308f, 0.18725109f, 0.11437777f, 0.14150035f, 0.12242290f, 
    -0.54080421f, -0.08502041f, -0.08303473f, -0.00663633f, 0.06137767f, 0.01946258f, 0.03089362f, -0.08639058f, 
    0.03859812f, -0.17487437f, -0.07725713f, 0.02273895f, -0.14425474f, 0.21589588f, 0.18754128f, 0.12803636f, 
    0.10730825f, -0.00189870f, 0.07267395f, -0.17943962f, 0.01125430f, 0.04305635f, -0.11073065f, -0.06961329f, 
    0.11101007f, -0.03762654f, 0.04010664f, -0.14785543f, -0.05008786f, 0.02429963f, 0.11645356f, 0.01416822f, 
    -0.11874551f, 0.00884441f, -0.08448675f, 0.06214343f, 0.07518268f, 0.04399935f, 0.09302980f, 0.10266225f, 
    -0.06798538f, 0.08968383f, -0.07189824f, 0.08359715f, -0.02943845f, -0.01433456f, 0.03954057f, -0.01546122f, 
    0.09658798f, -0.15388718f, -0.14452334f, -0.19109529f, 0.01754349f, 0.03231357f, 0.05807418f, -0.14046696f, 
    -0.08585270f, 0.05052245f, -0.11177131f, 0.02775283f, 0.09915950f, 0.13807471f, 0.09201282f, 0.07332061f, 
    -0.06099305f, -0.00419933f, 0.10544405f, 0.10577597f, 0.00179526f, -0.01894546f, -0.07211162f, -0.00788289f, 
    -0.22071464f, 0.10683195f, -0.01798348f, 0.18570466f, -0.05227720f, 0.03260470f, 0.01407292f, -0.06913666f, 
    0.04023749f, -0.00498211f, -0.07439572f, -0.14158227f, 0.30746466f, -0.12493572f, 0.09703440f, 0.05291985f, 
    -0.08423300f, -0.00063345f, -0.08493982f, 0.11796839f, -0.01894211f, 0.09044264f, -0.02504528f, -0.11363526f, 
    0.04323185f, 0.06567075f, 0.08125372f, -0.11456221f, -0.02313844f, 0.06689991f, 0.08407173f, -0.08212999f, 
    -0.10067282f, 0.01218378f, -0.05948416f, -0.20212044f, -0.06863222f, -0.13178293f, -0.37241197f, -0.03674445f, 
    0.01356081f, -0.00213850f, -0.05006088f, -0.02764667f, -0.16009614f, -0.06014441f, -0.03130493f, -0.13343485f, 
    -0.12103789f, 0.09921250f, 0.01315129f, -0.10946869f, -0.05917423f, -0.07922267f, -0.01621739f, -0.01369490f, 
    0.01118751f, -0.03660028f, -0.16054368f, -0.14074516f, 0.09392756f, -0.02365929f, -0.17722325f, 0.07065700f, 
    -0.01527114f, -0.11371768f, -0.09405228f, 0.00739950f, 0.01097107f, -0.03577806f, -0.07180507f, -0.03541021f, 
    0.31163269f, 0.11752944f, -0.13144256f, 0.06306791f, 0.00132233f, 0.09917895f, -0.03443929f, -0.14042428f, 
    0.06965579f, 0.00695685f, 0.16879256f, -0.08053073f, 0.06456251f, -0.12252290f, -0.17670932f, 0.22714636f, 
    -0.00850199f, -0.03031846f, -0.10278749f, 0.12087522f, -0.07877124f, 0.03067392f, 0.08158539f, -0.00212774f, 
    0.42129934f, -0.23528764f, -0.38766280f, 0.23975322f, 0.00221835f, -0.11259974f, 0.07067896f, -0.05225268f, 
    0.07227265f, -0.08761235f, 0.05673729f, 0.12428891f, -0.04715834f, -0.27867547f, -0.30602971f, -0.09234428f, 
    -0.03386686f, -0.00057290f, -0.11823125f, 0.00722729f, 0.04473277f, -0.05882956f, -0.02222168f, 0.00459615f, 
    0.14772949f, 0.29070926f, 0.00081916f, -0.25902620f, -0.09768111f, -0.19742079f, 0.00606043f, -0.06019789f, 
    0.13607959f, -0.04578008f, -0.14784290f, -0.15437078f, -0.44509366f, -0.02211492f, -0.19904414f, -0.15786061f, 
    -0.06207766f, -0.13538569f, -0.05089119f, -0.00671388f, -0.03234340f, 0.03985836f, -0.11262891f, 0.12137523f, 
    -0.25613546f, -0.29739791f, -0.17319086f, -0.07863175f, -0.15144587f, 0.02680426f, -0.01799477f, 0.05359342f, 
    -0.14136405f, -0.04307716f, -0.04458833f, -0.01558826f, 0.01622584f, -0.16999474f, -0.06368630f, -0.23551096f, 
    -0.14691907f, -0.00787328f, 0.00861352f, 0.02219288f, 0.04043918f, -0.09187184f, -0.01539617f, -0.02854376f, 
    0.10895824f, 0.15692556f, 0.13066606f, 0.06870957f, -0.08988424f, -0.02968770f, 0.01393416f, 0.22794349f, 
    0.10411268f, -0.07067017f, 0.02827146f, -0.03418690f, 0.22429378f, -0.24175359f, -0.00923996f, 0.01375807f, 
    0.02037465f, -0.05333205f, -0.09542347f, -0.03407789f, 0.00937876f, 0.04655512f, 0.08696362f, -0.02411950f, 
    0.28056329f, -0.02805769f, 0.09717558f, 0.05406209f, 0.01939204f, -0.09363943f, 0.04668071f, 0.12821226f, 
    0.01275950f, 0.00173358f, -0.11202226f, 0.10471615f, 0.30277315f, 0.04358789f, 0.12470139f, -0.09739428f, 
    -0.01213722f, 0.02614554f, -0.09065393f, -0.17896144f, -0.05367594f, -0.03124690f, 0.19050768f, 0.14635266f, 
    0.07524426f, 0.15519962f, 0.19880196f, -0.26434636f, 0.00506566f, 0.02651813f, 0.00900807f, 0.20661077f, 
    -0.05482147f, -0.05948551f, 0.04501424f, 0.20749705f, 0.37315562f, -0.05243266f, 0.00184402f, 0.40322095f, 
    0.02642452f, 0.10710133f, -0.00501060f, 0.07875752f, 0.09165435f, 0.00129576f, -0.03915960f, 0.06464864f, 
    0.25719899f, -0.01556692f, 0.14227092f, 0.38325521f, 0.11604115f, -0.02041745f, 0.05162039f, 0.07847290f, 
    0.09307793f, 0.17343225f, 0.22793135f, -0.01753391f, -0.40510225f, -0.13149396f, -0.31834492f, -0.26545143f, 
    0.11120351f, 0.03175917f, -0.18561797f, 0.03793129f, 0.14618893f, 0.08018993f, -0.12933405f, -0.11304357f, 
    -0.01307701f, 0.08058667f, 0.26262724f, -0.01097870f, -0.06080020f, -0.22839577f, 0.08115052f, 0.05877732f, 
    0.00432215f, 0.03952605f, -0.12539025f, 0.08236796f, 0.05578000f, -0.01364714f, 0.21892479f, 0.09821717f, 
    -0.10901282f, 0.02412871f, -0.07474226f, 0.07129789f, -0.05533650f, -0.06696481f, 0.09828942f, 0.06892782f, 
    -0.14960620f, 0.06512313f, -0.06108615f, -0.22181004f, -0.08721682f, -0.02448080f, 0.02313299f, -0.02151284f, 
    -0.04116400f, -0.01703984f, -0.00702206f, -0.16245067f, 0.37569240f, 0.34555453f, 0.09688794f, 0.26399401f, 
    -0.00930186f, -0.14822091f, 0.02418967f, -0.07980741f, -0.09745327f, -0.05774981f, 0.00189670f, -0.02806843f, 
    0.13711186f, -0.20272897f, 0.02406174f, 0.06014321f, -0.08415665f, -0.05648052f, -0.01002542f, 0.07487331f, 
    -0.03427282f, -0.01654077f, 0.13520387f, 0.08643476f, 0.32675642f, -0.19751115f, -0.03968655f, 0.09387169f, 
    0.08561192f, 0.08245997f, 0.00194959f, -0.02445097f, 0.11939776f, -0.01517962f, -0.06093847f, -0.02853712f, 
    -0.00247086f, -0.02819804f, -0.01748373f, -0.05991842f, -0.02210454f, -0.06689418f, 0.05344483f, -0.06366140f, 
    0.03148748f, -0.06332386f, -0.03518441f, -0.01539804f, -0.03424122f, -0.05660555f, 0.03112310f, 0.02460464f, 
    -0.01243366f, 0.00903889f, -0.06502822f, 0.01821409f, -0.03003278f, 0.02344028f, 0.05524447f, 0.01869639f, 
    -0.02812028f, -0.04522901f, -0.06772644f, -0.06217048f, 0.04079926f, 0.01463146f, 0.02337440f, -0.04040131f, 
    -0.01277934f, -0.04065336f, -0.01496451f, 0.02921061f, -0.03557625f, -0.00542543f, -0.05250130f, 0.06417903f, 
    0.02456520f, 0.01566187f, 0.03852845f, 0.01609722f, 0.00725397f, -0.01473188f, -0.00523254f, 0.04027647f, 
    0.01084795f, -0.04721424f, 0.03529755f, 0.03196159f, -0.04060403f, -0.00867272f, 0.04125186f, -0.00643583f, 
    -0.03268213f, 0.00588945f, 0.04559252f, -0.04426262f, -0.02726081f, 0.05667355f, -0.06758161f, -0.05117133f, 
    -0.04168606f, 0.01837154f, 0.06644100f, 0.05526998f, -0.06224270f, 0.02294886f, 0.03414256f, -0.01620639f, 
    -0.05790729f, -0.04549617f, 0.02716091f, 0.00327739f, -0.02674746f, 0.05182027f, 0.02384066f, 0.04966285f, 
    0.02375023f, -0.03262336f, 0.03511608f, -0.07197366f, 0.02762308f, -0.04335063f, -0.01290702f, 0.06005286f, 
    -0.00976894f, -0.03497467f, -0.07704678f, -0.01676052f, 0.04900742f, 0.00639622f, -0.07878522f, -0.01698669f, 
    0.05478632f, 0.05248462f, 0.01870470f, -0.00222265f, 0.04112882f, -0.04505275f, -0.05922303f, 0.00969535f, 
    -0.04284214f, 0.01647883f, 0.02186144f, -0.08109327f, 0.00163953f, 0.05437967f, -0.05662028f, 0.04037512f, 
    0.02758478f, 0.03808965f, -0.06406430f, 0.06345118f, -0.02990813f, -0.05554620f, -0.07569087f, -0.07070921f, 
    -0.01045585f, 0.06058006f, 0.03893519f, -0.03492522f, 0.00213966f, 0.02801395f, -0.03974626f, -0.07259950f, 
    -0.04490283f, 0.00409203f, -0.01352999f, -0.03489809f, 0.02379539f, -0.07279808f, -0.00706314f, 0.04647823f, 
    0.05465980f, -0.04272646f, 0.05780270f, 0.02129382f, -0.06917025f, 0.01357719f, 0.00155615f, 0.02519662f, 
    -0.06624853f, 0.05694353f, 0.02374790f, 0.01311073f, 0.04863968f, -0.08080751f, -0.00584292f, -0.05359469f, 
    -0.02689029f, -0.05774929f, 0.05188534f, 0.04674644f, 0.07170949f, 0.01649321f, -0.01913451f, -0.02609839f, 
    0.02639393f, 0.04308058f, -0.05225366f, -0.01136483f, -0.06381100f, -0.02596536f, -0.05289124f, 0.04525554f, 
    -0.03460995f, 0.01780535f, 0.02453829f, -0.04539504f, 0.03643371f, -0.07090355f, -0.07610254f, -0.04704141f, 
    -0.04718401f, 0.01197412f, -0.06234037f, 0.00530756f, -0.06464528f, 0.06008642f, 0.01099546f, -0.06552250f, 
    -0.04060195f, -0.07828370f, 0.03998273f, 0.01369559f, 0.05196152f, -0.03673244f, -0.01242833f, -0.02064049f, 
    0.17032325f, 0.05156050f, 0.07999284f, -0.04677159f, 0.11749279f, 0.06130079f, 0.10408545f, 0.09433059f, 
    0.18690990f, 0.03506684f, 0.11661822f, 0.03261214f, 0.38874456f, 0.25704563f, 0.14458756f, 0.24029152f, 
    0.14544101f, -0.11380483f, -0.04157758f, -0.00998592f, -0.03070840f, -0.12366067f, -0.00346105f, -0.03040434f, 
    0.06687053f, -0.05547408f, -0.29027340f, -0.01613927f, -0.10858233f, 0.32662487f, 0.07604578f, -0.17585312f, 
    -0.10983041f, -0.00122408f, 0.17445946f, 0.04701675f, -0.08955219f, 0.12010878f, 0.20286264f, -0.05074137f, 
    -0.12932098f, 0.01283190f, 0.13552269f, -0.05860344f, 0.07595468f, -0.06907546f, 0.03388461f, 0.03688544f, 
    -0.04211197f, -0.22673246f, 0.13418797f, -0.05613130f, -0.04228818f, 0.05624013f, 0.05816596f, -0.15963882f, 
    -0.00047955f, 0.03523850f, -0.02042728f, -0.06650712f, -0.18052749f, 0.17610483f, 0.01123885f, 0.16789509f, 
    -0.07398073f, 0.13451087f, 0.15157415f, -0.02533535f, -0.20392731f, 0.08678613f, -0.22970164f, -0.10279308f, 
    0.00070085f, 0.07365421f, -0.07036757f, 0.21782427f, -0.05491563f, -0.01729387f, 0.04993878f, -0.12684299f, 
    0.07485592f, 0.09920187f, -0.18444520f, -0.11379300f, 0.39253449f, 0.14066350f, 0.02735551f, -0.19257884f, 
    0.03772136f, 0.00468787f, -0.00683753f, -0.02948832f, -0.00816143f, 0.06189318f, 0.07513347f, 0.08089588f, 
    0.11271913f, 0.11959044f, 0.04480781f, -0.27212512f, -0.21355809f, 0.02399433f, 0.01626547f, 0.02138133f, 
    -0.09753101f, -0.11904124f, -0.05520442f, -0.02922218f, 0.38145983f, 0.41946718f, 0.27075288f, 0.31923920f, 
    -0.20037749f, -0.06814655f, -0.11873057f, 0.01199986f, -0.05633083f, 0.02235409f, -0.00419406f, 0.03727915f, 
    0.22101790f, 0.18627256f, -0.06734091f, -0.11210170f, -0.10904877f, 0.20866176f, -0.10556342f, 0.01482211f, 
    -0.05224817f, 0.01389070f, 0.04401844f, 0.10578477f, -0.21377987f, 0.03366045f, 0.04776419f, 0.05860416f, 
    0.14592521f, -0.02802588f, 0.01892081f, -0.00696227f, 0.03081559f, 0.20791721f, 0.02061592f, 0.00409151f, 
    -0.06120619f, -0.12929374f, -0.06006492f, 0.30859676f, 0.12667784f, -0.10370150f, 0.06273108f, 0.01987986f, 
    0.08374478f, 0.08561693f, -0.08030374f, -0.03434975f, -0.37522480f, -0.18590203f, 0.03739020f, -0.11390471f, 
    0.00253122f, 0.14550163f, -0.00803777f, 0.05949453f, -0.02414764f, 0.05888804f, 0.03387870f, 0.13551642f, 
    0.06985104f, 0.25564396f, 0.04532940f, -0.19774184f, -0.04781090f, 0.03100434f, 0.02193869f, -0.13492225f, 
    0.07577594f, -0.07497513f, -0.03883103f, -0.13996759f, -0.10565019f, 0.01732914f, -0.02413333f, 0.16662341f, 
    0.07123607f, -0.06287054f, 0.03393522f, -0.06630751f, 0.11114804f, 0.10182789f, -0.07484309f, -0.05393009f, 
    0.12069505f, -0.34817687f, 0.09016281f, 0.02881359f, -0.06228317f, 0.05131211f, 0.12804799f, -0.03715622f, 
    -0.22688082f, -0.18080325f, 0.08875851f, 0.06542443f, 0.00337228f, -0.13419341f, -0.01347655f, 0.06445301f, 
    0.02830545f, -0.01939240f, 0.13802606f, 0.07530346f, 0.01793552f, -0.09086035f, -0.06091896f, -0.14529613f, 
    0.23464124f, -0.10732679f, -0.03083981f, 0.03832033f, -0.10396170f, 0.03834170f, -0.05845928f, 0.08558989f, 
    -0.07494172f, 0.01490806f, 0.04722943f, 0.10615728f, 0.22926548f, -0.01859997f, -0.14572415f, -0.19588330f, 
    0.13957956f, 0.13294186f, -0.04143602f, 0.08809043f, 0.08925333f, 0.15408507f, 0.00999240f, 0.03913065f, 
    -0.01925084f, -0.05355891f, -0.07035177f, 0.27282152f, 0.01752544f, 0.06818561f, -0.05179374f, -0.05819592f, 
    -0.01786124f, 0.08335732f, -0.05417926f, -0.05914567f, -0.00410762f, -0.13418354f, -0.14877328f, 0.01103374f, 
    -0.01449248f, 0.06774121f, 0.07941550f, -0.07222945f, 0.04536268f, 0.08001698f, -0.04596752f, -0.06863617f, 
    0.21289444f, -0.26372677f, 0.10102359f, -0.42882764f, 0.05599995f, 0.17912011f, 0.10066672f, 0.00505831f, 
    0.05510026f, -0.01373679f, 0.11763296f, 0.06268977f, 0.33490342f, -0.12411061f, 0.19512686f, 0.13511954f, 
    -0.19592513f, 0.10565863f, 0.02749470f, 0.15510553f, -0.02208283f, 0.02865132f, 0.03889891f, 0.09865663f, 
    -0.06684769f, 0.18384071f, -0.00963446f, -0.06492227f, -0.02527476f, 0.15469863f, -0.02323541f, -0.19627376f, 
    0.05699255f, -0.00443642f, -0.05733031f, 0.12496752f, 0.17987870f, 0.19536069f, 0.15119216f, 0.30383825f, 
    -0.08965800f, -0.00369619f, 0.17589335f, -0.01880758f, -0.09051350f, 0.07827054f, -0.21477190f, 0.14956209f, 
    -0.00202080f, -0.07894633f, -0.03493039f, -0.27250370f, -0.16651838f, 0.05283508f, 0.06684993f, -0.02832027f, 
    0.01991655f, 0.08920261f, 0.09631866f, 0.11896992f, -0.06274646f, -0.06934983f, 0.03971528f, -0.06417134f, 
    -0.17697181f, 0.10709022f, -0.00159711f, 0.08152676f, -0.08066520f, 0.00920623f, -0.08338675f, -0.18006764f, 
    0.08872768f, 0.47143233f, 0.02016237f, 0.08741432f, -0.05940711f, -0.10955343f, 0.02278238f, 0.15933576f, 
    -0.09616429f, -0.01224575f, -0.05391696f, 0.08656355f, -0.26464573f, 0.14836103f, 0.32482088f, -0.02373444f, 
    -0.15757619f, -0.02517778f, 0.06168017f, 0.04459524f, 0.00404002f, 0.05669167f, -0.05644362f, 0.15180708f, 
    -0.07590760f, -0.16679688f, -0.14650750f, -0.11647940f, 0.16329740f, 0.12520370f, 0.01669619f, -0.12160555f, 
    -0.02356207f, 0.01313569f, -0.05839235f, -0.02818229f, -0.08434377f, 0.08794594f, 0.06822491f, -0.13935219f, 
    0.05938122f, 0.01648374f, 0.09109665f, -0.07927733f, 0.08618656f, -0.07490163f, 0.07868588f, -0.05525690f, 
    -0.16884805f, -0.16778044f, -0.02800062f, -0.01012065f, -0.01349849f, 0.00368447f, -0.01887765f, 0.06038378f, 
    0.08933725f, 0.07193393f, -0.06977614f, -0.08049659f, 0.04385536f, 0.21695757f, -0.33454925f, -0.18386704f, 
    0.00341111f, 0.22174284f, 0.05753997f, 0.01432668f, -0.04745575f, 0.04775435f, -0.12465459f, -0.06628793f, 
    -0.46412742f, -0.11917121f, 0.02807415f, 0.16413121f, 0.03204055f, -0.04333870f, 0.09678070f, -0.00871241f, 
    0.01910077f, -0.14545347f, 0.06981901f, 0.06094535f, 0.44984144f, -0.13474812f, -0.05059996f, 0.02730019f, 
    -0.08683434f, -0.09059811f, 0.13161159f, 0.09591373f, -0.02220106f, 0.04408868f, -0.01459059f, 0.06026870f, 
    0.17002106f, 0.02982016f, -0.01780827f, -0.03976847f, -0.25208920f, 0.05563407f, 0.12784311f, 0.08240139f, 
    0.08221896f, 0.04782322f, 0.01298112f, 0.18088046f, -0.33559269f, 0.11479329f, 0.02333572f, -0.02671695f, 
    0.00191427f, -0.14099772f, 0.00818520f, -0.04048983f, -0.06681320f, 0.02348231f, -0.03092031f, 0.03223132f, 
    -0.02258387f, -0.14354445f, -0.10282214f, 0.08848226f, 0.06450572f, -0.23691416f, 0.10870489f, -0.08583310f, 
    -0.01313530f, -0.02805992f, 0.07960816f, 0.17678989f, 0.19773589f, -0.05303615f, 0.07938790f, 0.15073800f, 
    0.14780432f, 0.08440454f, 0.03954614f, 0.10208740f, 0.01258790f, 0.01056377f, 0.09989200f, 0.10778044f, 
    0.06170047f, -0.46933305f, 0.04953456f, 0.00779978f, 0.08069768f, -0.18532813f, 0.19848849f, 0.21983004f, 
    0.09428964f, 0.10014386f, 0.18293783f, 0.17432979f, 0.26396012f, 0.02558539f, 0.15534958f, -0.02913627f, 
    0.14706330f, 0.21842299f, 0.03352048f, 0.03327131f, 0.09073208f, 0.04964408f, 0.07358810f, 0.02773171f, 
    0.41949567f, -0.04053108f, -0.13023855f, -0.02825573f, -0.15106668f, -0.24448389f, 0.07095523f, 0.12575907f, 
    -0.15153651f, -0.02787097f, -0.14284010f, -0.03366224f, 0.15621696f, -0.05354649f, -0.18721133f, -0.14284822f, 
    0.20406778f, -0.11747607f, 0.19166921f, -0.00386374f, 0.04862346f, 0.07023105f, 0.06840265f, -0.13162804f, 
    -0.09446061f, 0.12753592f, 0.37386039f, -0.03220123f, 0.02697610f, 0.22819534f, -0.12853898f, -0.08786967f, 
    0.12662062f, -0.02750719f, -0.01563038f, -0.04042327f, -0.32484159f, -0.34103635f, -0.21781389f, -0.06621660f, 
    0.02505507f, -0.08133984f, -0.07885801f, 0.19253837f, 0.13356942f, 0.16844711f, 0.01220428f, 0.05991754f, 
    0.40749371f, -0.12337698f, 0.07078482f, 0.10307799f, 0.04421641f, 0.03172595f, 0.10373724f, -0.14678943f, 
    0.00549243f, -0.06527045f, 0.13281465f, -0.05271911f, -0.12056766f, 0.31284195f, 0.02187399f, 0.15039785f, 
    -0.07503713f, 0.08785399f, -0.00557774f, 0.08204211f, -0.10504211f, -0.03557525f, -0.09241338f, -0.10561512f, 
    0.30466408f, 0.42825863f, -0.00726730f, 0.18804815f, 0.03377793f, 0.04495483f, 0.00428448f, -0.06081133f, 
    0.19405337f, 0.07461516f, 0.11627501f, -0.10544047f, -0.23794498f, 0.10837260f, 0.21050495f, 0.03583020f, 
    0.07958877f, -0.14381875f, -0.05864552f, -0.08819258f, -0.06357551f, 0.13852780f, 0.10977939f, 0.10164000f, 
    0.39014444f, 0.15327057f, -0.08446380f, 0.02921681f, -0.02456041f, 0.03128224f, -0.06885121f, -0.03544119f, 
    0.02641469f, 0.06939968f, 0.11394852f, -0.06051319f, -0.46094891f, 0.18250993f, 0.04706781f, -0.05205796f, 
    -0.05937532f, 0.01884679f, 0.05553592f, -0.15917875f, -0.00600389f, -0.17062803f, 0.04119792f, 0.02191488f, 
    -0.10559746f, -0.09939007f, 0.16777916f, -0.19425012f, 0.18619233f, -0.06385952f, -0.11001341f, 0.00890526f, 
    -0.15094359f, -0.00760047f, 0.13990213f, 0.05375794f, -0.38573706f, 0.21572720f, -0.04901905f, 0.00675991f, 
    0.02489888f, 0.01916229f, -0.07614203f, -0.05060294f, 0.04518069f, -0.05997416f, 0.00924024f, 0.09472137f, 
    -0.16576676f, 0.11964419f, -0.06890293f, 0.29434925f, -0.03127997f, 0.04306620f, -0.11838195f, -0.02229294f, 
    0.06525003f, 0.03012056f, -0.09061608f, 0.00693759f, -0.09990840f, 0.26098520f, 0.26170459f, -0.04148499f, 
    0.11906800f, -0.23972347f, -0.01477620f, -0.04515088f, -0.03967992f, -0.04743386f, 0.01295149f, 0.00887235f, 
    0.02074830f, 0.06569166f, 0.06693766f, 0.04413917f, -0.07149663f, 0.07465327f, -0.00180519f, -0.12750852f, 
    -0.15534335f, -0.06341221f, -0.01367760f, -0.12418360f, -0.32755646f, 0.03118050f, 0.21625391f, 0.04901128f, 
    -0.13900459f, -0.07661863f, -0.03705278f, -0.04092327f, -0.02495822f, -0.14195976f, 0.21252164f, -0.03056152f, 
    -0.39471555f, 0.01102677f, -0.06380530f, -0.01703317f, 0.11342327f, 0.23770081f, 0.00367985f, 0.07113072f, 
    0.00528947f, -0.00294963f, 0.04958081f, 0.03242750f, -0.04670840f, 0.22862147f, 0.19088438f, 0.12555452f, 
    0.04079359f, -0.04916878f, -0.01630696f, -0.02506598f, 0.03283252f, -0.03254254f, -0.01984193f, 0.18431067f, 
    -0.08273619f, -0.24233139f, 0.06255937f, 0.04961370f, 0.05444463f, 0.07733154f, 0.03721849f, -0.03769798f, 
    -0.12478747f, 0.05946737f, 0.07213308f, -0.02218528f, 0.38384855f, 0.15468262f, 0.17273787f, 0.13466991f, 
    0.16672219f, 0.06395584f, -0.03455408f, -0.07218831f, -0.04496061f, -0.09214915f, 0.07883333f, -0.04127578f, 
    -0.30748442f, 0.15050885f, 0.14369527f, 0.27572453f, -0.02023775f, 0.06552274f, 0.00488414f, 0.15512894f, 
    -0.06382281f, 0.06324844f, -0.07720114f, 0.12292089f, 0.26406559f, -0.08323836f, 0.12252455f, 0.24484965f, 
    0.07025019f, -0.05445909f, 0.07380323f, -0.01553947f, -0.07526723f, -0.01415856f, 0.05342932f, -0.02607525f, 
    0.15638995f, -0.10420482f, 0.20667000f, 0.12034162f, 0.09826291f, 0.00493884f, 0.01279847f, -0.03217054f, 
    0.11741805f, -0.13982578f, -0.00686842f, 0.21738409f, 0.41252142f, -0.08687346f, 0.19623210f, -0.05886573f, 
    -0.03020291f, -0.03803673f, -0.01361047f, 0.04637389f, -0.02197520f, -0.12619069f, 0.01659234f, 0.05500344f, 
    0.13395642f, 0.05472923f, -0.07595095f, -0.42477775f, -0.02106653f, 0.14791191f, 0.07748308f, 0.03961809f, 
    0.05086925f, 0.14910442f, 0.18585531f, 0.21159391f, -0.17034754f, 0.29747710f, 0.11963503f, -0.17205462f, 
    0.12520050f, 0.03748877f, 0.12313795f, -0.03277906f, 0.05326339f, -0.00222981f, -0.01661228f, 0.17925724f, 
    0.20299724f, 0.09881630f, -0.14714810f, 0.02865455f, 0.08513112f, 0.08908112f, 0.11583158f, -0.03407790f, 
    -0.00135093f, 0.01481536f, -0.13929503f, 0.04641189f, 0.52494401f, -0.24018145f, -0.01896862f, 0.02314830f, 
    0.22347501f, 0.07021786f, -0.03507351f, 0.07524706f, 0.08224317f, 0.09422027f, -0.05552302f, -0.06953408f, 
    0.14157277f, 0.08965483f, -0.09961537f, 0.00567132f, 0.03785825f, 0.18243638f, 0.01928740f, 0.11643887f, 
    -0.07595836f, 0.19719508f, -0.00882618f, -0.07052596f, -0.19651078f, -0.26861283f, -0.25164348f, 0.14723979f, 
    -0.10322066f, 0.07635000f, -0.21205275f, -0.19843341f, -0.11634880f, -0.05333466f, -0.11171516f, -0.16742261f, 
    -0.02057059f, 0.52176392f, -0.24885812f, -0.02846767f, 0.15123765f, 0.02078868f, 0.05210355f, -0.10640004f, 
    -0.16507480f, -0.07075863f, -0.10129935f, 0.04462675f, 0.47925356f, 0.33859888f, -0.00607654f, 0.03860831f, 
    -0.11166056f, 0.01867360f, 0.05786437f, -0.06027268f, -0.04639583f, 0.07393121f, -0.07942421f, 0.15207429f, 
    0.18242894f, 0.11493868f, -0.05411327f, 0.00614346f, 0.24629495f, -0.05459872f, -0.00418823f, 0.03624454f, 
    0.11067614f, 0.01737494f, 0.16343492f, 0.13313802f, -0.05371685f, -0.14706963f, 0.28191608f, 0.17395708f, 
    -0.10645985f, -0.07159445f, -0.01041797f, 0.03546804f, 0.06792101f, -0.02615452f, 0.07465656f, -0.03446999f, 
    0.07049065f, 0.13506728f, 0.07067883f, 0.13851500f, -0.11751784f, 0.07587493f, -0.13079530f, -0.02423911f, 
    -0.17353514f, -0.07515632f, -0.15011318f, 0.06632339f, -0.27531600f, -0.13613780f, -0.12214854f, -0.36555880f, 
    -0.03127110f, 0.01766805f, 0.02453404f, -0.30982122f, 0.12418527f, -0.09110690f, -0.06530535f, -0.11867564f, 
    -0.20917104f, 0.05901503f, -0.16784798f, -0.29960740f, 0.15651549f, 0.11595408f, 0.06554164f, 0.08105790f, 
    -0.01083238f, 0.05932019f, -0.03298514f, 0.02803243f, -0.15191340f, -0.16869926f, -0.06080132f, 0.22665979f, 
    0.07141559f, -0.17086430f, -0.11175770f, 0.05326016f, -0.06605794f, -0.04331601f, 0.02865429f, 0.03525019f, 
    -0.01151133f, -0.00647170f, -0.07331233f, -0.05596649f, -0.04504640f, -0.04601666f, 0.02558008f, 0.05816735f, 
    0.00152146f, 0.01706938f, 0.02815843f, -0.04659135f, 0.04981500f, -0.04487457f, -0.00677609f, -0.04920436f, 
    0.05829225f, 0.02548645f, -0.04788357f, -0.05211633f, -0.02236923f, -0.05929444f, -0.04101517f, -0.06420836f, 
    -0.03197247f, 0.02595278f, -0.00443906f, -0.04743201f, 0.01625212f, -0.04626596f, -0.01868345f, 0.04082096f, 
    -0.06707548f, -0.06831686f, -0.04331344f, -0.03904845f, 0.00247936f, -0.01859806f, 0.06244679f, 0.03900737f, 
    0.04944273f, 0.05712601f, 0.04896919f, -0.07052573f, 0.04370702f, -0.04347418f, -0.04002713f, -0.05757554f, 
    -0.00202844f, -0.04035830f, 0.04975399f, -0.07995370f, -0.07453855f, -0.00681627f, 0.01248678f, 0.05000158f, 
    0.02039340f, -0.04122771f, -0.02879209f, -0.02259595f, -0.02294698f, 0.00048192f, -0.01433998f, -0.06212799f, 
    -0.06152910f, 0.03412015f, -0.06469686f, -0.05160148f, -0.07168284f, -0.06846123f, -0.04502809f, 0.03597523f, 
    -0.04805344f, 0.03750876f, -0.00194937f, -0.02477968f, -0.07622372f, -0.00041886f, 0.02260250f, -0.06078799f, 
    -0.06516489f, 0.05550934f, -0.00339975f, -0.04542409f, 0.01302480f, -0.07463270f, 0.03470386f, 0.00601612f, 
    0.02737079f, -0.05436954f, -0.06506532f, 0.00106635f, -0.00864458f, -0.00171626f, 0.02215527f, -0.03573263f, 
    0.00194895f, 0.03466855f, -0.00708557f, -0.01491953f, 0.02141513f, 0.00553791f, -0.00424902f, -0.02941498f, 
    0.05733729f, 0.03635097f, 0.02687194f, -0.04752106f, -0.04831142f, -0.03334246f, -0.04840667f, 0.01732974f, 
    -0.01448451f, 0.00972415f, -0.05299659f, -0.04693045f, -0.07968549f, 0.01358062f, -0.03013681f, -0.04461982f, 
    0.01507741f, 0.00157078f, -0.06203716f, -0.02819885f, -0.02005068f, -0.06149307f, 0.04238309f, -0.04143524f, 
    -0.05176942f, 0.03118633f, -0.06464673f, 0.00213882f, -0.04562159f, 0.02589104f, -0.04256769f, 0.02340506f, 
    -0.03587118f, 0.00491528f, 0.03133675f, 0.02949121f, 0.03604903f, 0.02059523f, 0.02737779f, -0.03618666f, 
    0.02966669f, 0.00139183f, 0.05289115f, -0.04143823f, 0.04112208f, 0.01224078f, 0.01495377f, 0.02527995f, 
    0.01138970f, 0.00153258f, -0.03835965f, -0.00868752f, -0.08125545f, -0.01885333f, -0.06691735f, -0.06706240f, 
    -0.00584950f, 0.05425147f, -0.04035286f, 0.00288663f, -0.00837317f, -0.02651483f, 0.03419683f, 0.01315865f, 
    0.01069510f, -0.06471463f, -0.07040974f, 0.00453253f, -0.03211933f, -0.06929112f, 0.05473057f, -0.05478805f, 
    -0.01116438f, 0.00668153f, 0.00422373f, -0.04517021f, 0.02606188f, -0.02250375f, -0.05459928f, -0.03363603f, 
    -0.07213448f, -0.05114499f, -0.01429782f, -0.05797595f, -0.03083776f, -0.06398018f, -0.04466501f, -0.07192645f, 
    0.03183381f, 0.05196080f, -0.02245487f, -0.05188202f, -0.04040143f, 0.03681446f, -0.05889708f, 0.01246331f, 
    -0.05372476f, -0.02308306f, 0.06271010f, -0.00825890f, -0.00873795f, -0.05777871f, 0.02512163f, 0.04497692f, 
    0.01446331f, 0.04593529f, 0.03953759f, 0.02394582f, -0.07751489f, -0.03616212f, 0.03148808f, -0.00808690f, 
    -0.07771602f, -0.05534308f, -0.03624411f, -0.01416145f, -0.03829312f, -0.06217789f, -0.01770543f, -0.04030804f, 
    -0.01295940f, -0.01133567f, -0.04939048f, 0.02145381f, 0.05539981f, -0.06830320f, -0.02801543f, 0.04302873f, 
    0.01832916f, -0.01876702f, 0.03423819f, -0.07550880f, 0.02423722f, 0.05777733f, 0.02352237f, 0.03270344f, 
    -0.02520889f, -0.02661899f, -0.03088186f, -0.06010152f, 0.01215015f, 0.00712714f, -0.00536333f, 0.05489063f, 
    -0.06280302f, -0.01752216f, 0.05016686f, -0.03977195f, 0.05650626f, -0.01162540f, -0.03473097f, 0.06140051f, 
    -0.04090173f, -0.07957412f, -0.04456089f, 0.03459448f, -0.03161107f, -0.00175596f, 0.00816037f, 0.04190659f, 
    -0.05848073f, -0.03055567f, -0.07356746f, 0.06063568f, 0.05927086f, -0.04494979f, 0.04621198f, -0.00989735f, 
    0.04611474f, -0.02802420f, -0.03115603f, -0.05010093f, 0.03396938f, -0.07339624f, 0.05570771f, 0.01211431f, 
    0.04050926f, -0.02113145f, 0.00025788f, 0.04158692f, -0.05076043f, 0.04737382f, -0.05742867f, -0.04368411f, 
    0.04830913f, -0.07978008f, -0.01626792f, -0.07859497f, -0.02691728f, 0.04133362f, 0.06096657f, -0.01623861f, 
    0.05678321f, -0.05341301f, 0.05017896f, -0.02141108f, -0.03970230f, -0.01141184f, -0.01273113f, -0.02067401f, 
    -0.04068958f, 0.06074390f, -0.05879310f, -0.07063065f, -0.00821816f, -0.06543630f, -0.02903613f, 0.00376743f, 
    0.02765559f, -0.03634698f, -0.04050097f, 0.02439746f, -0.00879928f, 0.00268867f, -0.03038253f, -0.07012786f, 
    -0.03824179f, 0.04162058f, -0.05616941f, -0.00319721f, -0.04335366f, 0.01076351f, -0.04077181f, 0.06135990f, 
    0.04243034f, 0.05308438f, 0.02218976f, -0.07395406f, -0.05113885f, -0.01226842f, -0.06377277f, -0.05485547f, 
    0.01881585f, 0.04623163f, 0.02549605f, -0.07058313f, 0.03242694f, -0.05875073f, -0.04650005f, 0.06350064f, 
    -0.01493487f, -0.02306532f, 0.05045469f, -0.03774052f, -0.05821989f, 0.01428894f, -0.05657987f, 0.01540217f, 
    0.03101789f, -0.02662768f, -0.04173461f, 0.02696912f, 0.03964669f, 0.05830649f, -0.07084420f, -0.03461665f, 
    0.03575850f, -0.01374009f, -0.03824365f, -0.00391334f, 0.06421795f, -0.01216450f, -0.04854869f, -0.04558773f, 
    -0.06290822f, 0.00196118f, 0.03909883f, -0.04024675f, 0.04503466f, -0.02270183f, -0.00732155f, -0.01210130f, 
    0.00739202f, -0.07189569f, -0.07953908f, -0.05859244f, 0.01467026f, -0.06750010f, 0.01283090f, 0.02505017f, 
    0.26373404f, 0.28131571f, -0.00403510f, 0.15214567f, 0.06594680f, -0.00493146f, -0.00129453f, -0.04036898f, 
    0.12444232f, -0.01967175f, 0.04994439f, -0.00126129f, 0.22801897f, 0.35453191f, -0.02854260f, 0.01229361f, 
    0.08589456f, -0.05047849f, 0.00536303f, -0.03074797f, 0.01622946f, 0.01502483f, -0.08091640f, -0.04157953f, 
    -0.25861704f, -0.06064104f, -0.10803735f, 0.02426478f, -0.03310743f, 0.02666581f, 0.26409271f, -0.05244129f, 
    -0.02000391f, 0.04990654f, 0.14044945f, 0.12015942f, -0.43153694f, 0.11367805f, 0.26062989f, 0.01428462f, 
    -0.23094834f, -0.00748055f, 0.04947565f, -0.06252765f, 0.01439204f, 0.02479818f, 0.09982847f, 0.09004986f, 
    0.10998321f, 0.06162408f, 0.11206004f, -0.20140596f, -0.12135890f, 0.15317115f, -0.07449629f, 0.01711257f, 
    0.04873926f, 0.13212620f, -0.05152303f, 0.07401484f, -0.09892292f, 0.25795579f, 0.05128329f, 0.03278243f, 
    0.00867457f, -0.02286499f, -0.04098015f, -0.04531815f, -0.08242155f, -0.01067082f, -0.12574954f, -0.08799797f, 
    -0.02214785f, -0.02914759f, 0.02386942f, 0.23821066f, -0.03073309f, -0.16429961f, 0.04492304f, -0.17832294f, 
    -0.05227301f, 0.18545406f, -0.05334252f, -0.01272363f, 0.10627530f, 0.06850433f, 0.00580408f, -0.02341649f, 
    0.04425977f, 0.07071758f, 0.12561637f, -0.04290634f, -0.04721951f, -0.07432969f, 0.13412777f, 0.06558676f, 
    0.01877058f, -0.05212243f, -0.05357041f, -0.07914262f, -0.05421589f, -0.01178524f, 0.15084042f, 0.11863211f, 
    -0.02915847f, -0.01102578f, 0.15360424f, 0.06613578f, 0.24908103f, 0.14684969f, 0.12372158f, 0.06674198f, 
    0.09898043f, 0.01524607f, -0.12012421f, -0.04108443f, -0.02491399f, -0.06410722f, 0.03883855f, 0.05976053f, 
    0.32146239f, 0.13505964f, -0.21608795f, 0.21718535f, -0.07745862f, -0.13850936f, -0.07962164f, 0.04004679f, 
    0.05985261f, 0.02354276f, 0.01285340f, 0.09553038f, 0.24600826f, 0.04469084f, -0.01932204f, 0.17566983f, 
    0.01704717f, -0.05729388f, 0.05359467f, 0.19985510f, -0.05294494f, 0.03287389f, 0.05621977f, -0.01742727f, 
    -0.20328857f, -0.09714599f, 0.05615890f, 0.05395051f, 0.14823601f, 0.11396620f, -0.03780452f, -0.02294064f, 
    0.16927904f, -0.14758767f, -0.19219762f, -0.03340396f, -0.19278672f, -0.23401394f, -0.23889287f, -0.21801141f, 
    -0.11901779f, 0.05138663f, 0.08800523f, 0.12841412f, -0.02315012f, 0.06689401f, -0.06370850f, -0.06057985f, 
    0.26545832f, 0.29777151f, 0.00269489f, 0.04584162f, 0.06758291f, 0.01584030f, 0.10551577f, -0.02206398f, 
    -0.05988104f, 0.10720187f, 0.15169203f, -0.15856802f, -0.23659129f, 0.03408640f, -0.00540507f, 0.28050041f, 
    -0.06069025f, 0.06313504f, -0.04436588f, 0.06604249f, -0.00768152f, 0.12131589f, -0.07974682f, 0.05668249f, 
    -0.15542446f, 0.08526513f, 0.05966336f, 0.02211827f, -0.03828680f, 0.16319278f, 0.00339760f, 0.01353379f, 
    0.12307113f, -0.03395498f, 0.00973010f, -0.00151326f, 0.32769439f, 0.03976969f, -0.30305323f, -0.15394862f, 
    0.08282886f, 0.14187708f, 0.04747438f, -0.09590502f, -0.00343505f, 0.09528322f, 0.02853439f, -0.06052239f, 
    -0.46201992f, 0.14595462f, 0.08008986f, 0.21108006f, 0.01693821f, -0.01786279f, 0.21974123f, 0.11589158f, 
    0.08941559f, -0.12451541f, 0.03104555f, -0.06697328f, 0.20051304f, -0.04279837f, -0.09179432f, 0.15304257f, 
    -0.12709318f, -0.11186001f, -0.00038186f, 0.08677643f, -0.01762015f, -0.01389965f, 0.00727745f, -0.04973488f, 
    0.64219874f, -0.23419942f, 0.12572458f, -0.14352673f, -0.07905049f, 0.02808820f, 0.18912047f, 0.15592870f, 
    0.00430674f, 0.08255332f, 0.00963351f, 0.20229827f, 0.08649530f, 0.12991069f, 0.11075908f, 0.01728595f, 
    -0.03959711f, -0.06876246f, -0.05209747f, -0.01516017f, -0.03130267f, 0.10797121f, 0.06564709f, -0.05295533f, 
    -0.06398737f, 0.19189051f, 0.00310281f, 0.43087885f, -0.13128048f, -0.07618368f, 0.16262995f, 0.17109637f, 
    0.06982500f, 0.11820819f, 0.08596740f, 0.14173806f, -0.15748911f, 0.00403674f, -0.14560203f, -0.02942112f, 
    0.25449607f, -0.00504644f, -0.03910064f, -0.14445619f, -0.06752045f, -0.04362556f, 0.05210505f, 0.01017772f, 
    0.06097105f, -0.25420472f, 0.10906442f, -0.08726665f, -0.15688904f, -0.08068417f, 0.16489466f, 0.22753951f, 
    0.22153333f, 0.17458341f, 0.23836102f, 0.10035597f, -0.02080231f, 0.02521861f, -0.13950990f, 0.02734485f, 
    0.20197500f, 0.17629537f, -0.14359225f, 0.23516649f, 0.09448320f, 0.08446004f, 0.15615760f, -0.05911895f, 
    0.12255026f, 0.22891009f, 0.34925288f, 0.11366471f, -0.01439871f, -0.16117731f, 0.06961381f, -0.00384464f, 
    -0.02241718f, 0.01536719f, -0.16371390f, 0.01821697f, -0.25490484f, 0.19488092f, -0.01248908f, -0.07674132f, 
    0.13915071f, 0.17487819f, -0.01965826f, -0.08945936f, -0.06327833f, 0.02219305f, 0.05867071f, 0.12502748f, 
    -0.26235661f, -0.25308976f, 0.04779379f, -0.11475466f, 0.24900936f, 0.15905105f, -0.09409222f, -0.16971029f, 
    0.11965382f, 0.01688843f, -0.02456557f, -0.17191485f, -0.31391278f, -0.05995569f, -0.13235401f, -0.04429364f, 
    0.00481043f, -0.03044666f, -0.04478168f, -0.08844944f, -0.07745954f, 0.08927999f, -0.00467193f, -0.08907092f, 
    0.17940541f, -0.03825860f, 0.43411160f, -0.01899570f, -0.05655811f, 0.02028241f, 0.00070434f, -0.01160856f, 
    -0.06798448f, -0.07303812f, 0.13292412f, 0.04331704f, 0.00677424f, -0.11743546f, 0.21981451f, 0.07582255f, 
    0.11755703f, 0.05641376f, -0.09362316f, 0.11883602f, -0.00508493f, -0.00813918f, -0.09652111f, -0.02492836f, 
    0.33038777f, -0.06665120f, 0.13149391f, 0.21553230f, -0.06589325f, -0.01634065f, 0.03972719f, -0.05442646f, 
    -0.23451985f, -0.13037623f, 0.06200380f, 0.05317543f, 0.05150222f, -0.12176726f, 0.26544079f, -0.19557604f, 
    0.00308900f, -0.18760423f, 0.04706283f, 0.01840976f, 0.04128056f, -0.12418982f, -0.11754944f, -0.05112018f, 
    0.10377381f, 0.06787235f, 0.22062559f, 0.00580593f, 0.02024234f, -0.07383326f, -0.08287052f, 0.20719142f, 
    0.03156415f, 0.10071588f, 0.03399272f, 0.10664706f, -0.31985885f, -0.02335488f, -0.07897580f, -0.00548954f, 
    0.10409988f, 0.06698192f, -0.11161032f, -0.12466801f, 0.07213642f, 0.18853541f, 0.04025990f, -0.01604324f, 
    0.43055263f, -0.01926423f, 0.01171553f, 0.01750023f, 0.21942101f, -0.02834922f, -0.14863297f, 0.08880851f, 
    -0.24828389f, 0.06095151f, -0.25328517f, 0.19882624f, 0.24566509f, -0.02954423f, -0.20970438f, -0.08908541f, 
    -0.00878779f, 0.04299256f, -0.00597090f, -0.14934129f, 0.07212715f, -0.14254931f, 0.10976341f, 0.06874567f, 
    -0.02399425f, -0.22451526f, 0.31089470f, -0.19964908f, 0.01942918f, -0.01597929f, -0.05351616f, 0.22786005f, 
    -0.07600074f, 0.14550181f, 0.03453433f, 0.02909877f, -0.16808301f, -0.12675770f, 0.35462537f, 0.30610779f, 
    -0.19547702f, 0.02405690f, 0.03218419f, -0.03412319f, 0.04849184f, 0.08029411f, 0.15476975f, -0.06746394f, 
    0.03779364f, 0.27106935f, -0.00159553f, 0.20477970f, 0.13968471f, 0.12494465f, -0.06868446f, -0.16529942f, 
    0.09771270f, 0.27440068f, 0.08805021f, 0.05326361f, -0.16201273f, 0.02358701f, 0.00142322f, -0.03322403f, 
    -0.01422361f, -0.01365279f, -0.00051535f, -0.02537584f, -0.07464769f, -0.07879332f, 0.01801802f, 0.03499135f, 
    -0.29095596f, 0.03276647f, 0.09517849f, 0.13656692f, 0.01233296f, -0.20615534f, 0.16420378f, -0.01961230f, 
    0.18586110f, -0.05073998f, -0.10606483f, 0.03977754f, 0.31187558f, -0.00419356f, 0.36566547f, 0.10733400f, 
    -0.16956313f, 0.18476351f, -0.04400459f, 0.05204813f, -0.20065786f, -0.01719098f, 0.01889071f, -0.00287900f, 
    -0.32081002f, 0.01678533f, 0.11080034f, -0.14250605f, -0.13532208f, 0.08972422f, 0.07218202f, 0.04321523f, 
    -0.16864100f, -0.00463386f, -0.05655474f, 0.00726765f, 0.38486624f, 0.45937324f, -0.02636836f, -0.02086407f, 
    -0.08877274f, -0.16195925f, 0.07606252f, 0.05790459f, -0.13484249f, -0.08251980f, 0.06325988f, -0.04616064f, 
    -0.11052945f, -0.25567639f, -0.01850670f, 0.16558971f, 0.00143134f, 0.02993237f, 0.06758691f, 0.24944867f, 
    -0.11087476f, 0.15706289f, -0.02229881f, 0.06432030f, 0.22728114f, -0.19299673f, 0.13507213f, 0.04541760f, 
    0.07061680f, 0.07069986f, 0.01037770f, -0.08314750f, -0.00153812f, -0.08441172f, -0.02474195f, 0.10248276f, 
    0.11418660f, 0.23631671f, 0.02985590f, 0.09392688f, 0.07270869f, -0.01026519f, -0.05089086f, -0.04051156f, 
    0.22330508f, 0.11146357f, 0.03665293f, -0.03765731f, -0.04178117f, -0.03602412f, 0.01862996f, 0.07057063f, 
    0.14015241f, -0.13874735f, 0.00314252f, -0.09430151f, 0.00271336f, 0.14602773f, -0.06286220f, -0.04552581f, 
    0.09315273f, 0.36836195f, -0.19177197f, 0.14339414f, -0.00983415f, 0.06372161f, 0.05396301f, -0.04356798f, 
    0.14256412f, -0.07237691f, 0.04873054f, 0.01402176f, -0.19140038f, 0.23370573f, 0.02710617f, 0.03140024f, 
    0.07885622f, 0.02990125f, 0.04308436f, -0.07304455f, 0.10318354f, -0.05224045f, -0.02958171f, -0.02042865f, 
    0.08934920f, -0.06195453f, -0.07420712f, -0.15929501f, 0.21749532f, -0.01297575f, -0.04193721f, 0.07018425f, 
    -0.08323328f, 0.02065253f, 0.04718937f, -0.02433647f, -0.51895505f, 0.13150637f, -0.05088695f, 0.06668263f, 
    -0.03406772f, -0.06875224f, 0.04481242f, -0.06004908f, -0.02036030f, -0.09240822f, 0.03504412f, 0.07143862f, 
    -0.05173553f, -0.09548358f, -0.14888708f, 0.53235769f, -0.03800856f, -0.00045161f, 0.03205131f, 0.12030731f, 
    0.11166658f, 0.00939176f, -0.03475785f, 0.06742768f, -0.07347476f, 0.19680318f, 0.17056480f, -0.31943002f, 
    0.11331073f, -0.11925496f, -0.00141833f, -0.04442585f, 0.07680392f, -0.01218159f, 0.00788992f, -0.07024227f, 
    -0.06712468f, -0.06479444f, -0.03175776f, -0.07586006f, -0.10954256f, 0.02034750f, -0.02330630f, 0.00729027f, 
    -0.03109532f, -0.17485631f, 0.03177083f, 0.08764692f, -0.16724184f, 0.19430161f, 0.34387904f, 0.02086016f, 
    -0.08653168f, 0.14425811f, 0.03181204f, 0.02611901f, -0.11916485f, -0.04328264f, 0.08786277f, 0.12216445f, 
    -0.25575587f, 0.08687088f, -0.10046487f, 0.03948755f, 0.08520125f, 0.12662783f, 0.08879349f, 0.12768443f, 
    -0.07134790f, 0.00010777f, -0.01242334f, 0.14381476f, -0.30790707f, 0.16184339f, 0.03760350f, -0.14631853f, 
    0.02628877f, -0.02594953f, -0.01271507f, -0.07817739f, 0.10191531f, 0.02860816f, 0.02746592f, 0.16190857f, 
    -0.40257746f, 0.11902399f, 0.27820393f, -0.14633721f, -0.00047648f, 0.07120191f, 0.01028850f, -0.05997161f, 
    -0.10425947f, 0.10346220f, -0.00559701f, -0.07497726f, -0.17278884f, 0.14367512f, 0.18641676f, -0.16045123f, 
    0.08239152f, 0.06278279f, -0.01677524f, -0.05645858f, -0.10580929f, 0.01522687f, 0.05520146f, 0.10663836f, 
    -0.18603159f, -0.07010616f, 0.23162268f, 0.23720232f, 0.13339831f, 0.10590765f, -0.04700656f, 0.05802844f, 
    -0.08699368f, 0.10571712f, 0.01768516f, 0.08270309f, 0.45634589f, -0.06278998f, 0.05105794f, 0.13369432f, 
    0.00827634f, -0.00286269f, 0.04855388f, -0.11411105f, -0.01834281f, -0.06362813f, 0.11270420f, -0.11055971f, 
    0.10239459f, 0.13735224f, 0.18788955f, -0.01768579f, 0.10839339f, 0.06780571f, -0.03233680f, 0.05959567f, 
    0.15087391f, 0.15424868f, -0.04741037f, 0.20674528f, 0.05638506f, 0.15871863f, -0.03558263f, -0.04297362f, 
    0.04848872f, -0.07792034f, -0.10740472f, -0.03214704f, 0.09549104f, 0.13614827f, 0.10087403f, 0.14546074f, 
    0.03679983f, 0.13066089f, -0.13546710f, -0.29488939f, 0.07551718f, -0.03026544f, -0.03800156f, -0.03282309f, 
    0.05391216f, -0.03519548f, 0.00347218f, -0.02736240f, -0.12581465f, 0.21442112f, 0.18608573f, -0.00240155f, 
    0.07314610f, 0.01933488f, 0.00063917f, 0.09928749f, 0.04478876f, -0.13523236f, -0.01261464f, 0.11952595f, 
    0.23052365f, 0.11402863f, 0.04155652f, 0.08901057f, 0.09886392f, -0.10140172f, 0.04552398f, -0.00776633f, 
    -0.02645112f, -0.12103911f, 0.03818807f, -0.16997078f, -0.31367806f, 0.03443471f, 0.23486844f, 0.11898366f, 
    0.07831451f, 0.02690808f, 0.14032026f, 0.18517648f, 0.06743014f, 0.14115286f, 0.00820596f, 0.09152721f, 
    0.16837849f, -0.13221477f, -0.05480925f, 0.22974157f, -0.06886429f, 0.21253461f, -0.09694326f, 0.09848553f, 
    -0.03870933f, -0.10507622f, -0.23669314f, -0.09111506f, -0.20359820f, 0.00406883f, -0.06505036f, -0.06981130f, 
    0.16030338f, 0.04624248f, -0.11054996f, -0.05348890f, -0.01337532f, -0.12693200f, 0.00485434f, -0.15884115f, 
    0.29738459f, 0.24249445f, -0.12780777f, -0.10131465f, -0.02054748f, 0.06651371f, -0.16443381f, -0.12308522f, 
    -0.02664313f, -0.08908709f, -0.17136219f, -0.16987175f, 0.15242042f, 0.15822721f, -0.10567485f, -0.12441695f, 
    0.12532091f, -0.06699087f, -0.03417933f, -0.01583390f, 0.06986192f, -0.00789807f, 0.01693748f, -0.11546328f, 
    0.17877920f, 0.21947235f, -0.12939584f, 0.17203993f, 0.04677478f, 0.07031033f, 0.15886690f, 0.15761402f, 
    0.03170833f, -0.08121657f, 0.08959073f, -0.00353089f, -0.05960453f, -0.21573286f, 0.01105909f, 0.13946092f, 
    0.04282687f, -0.12786782f, 0.09000475f, -0.03874442f, 0.02199861f, 0.01260311f, 0.04702137f, 0.01945031f, 
    -0.43684477f, -0.31487632f, -0.02204935f, 0.29195029f, 0.11522614f, -0.12413859f, -0.06824791f, -0.11955285f, 
    0.03767242f, 0.13232791f, 0.09171786f, 0.00733387f, -0.11198450f, -0.28206140f, -0.06305403f, -0.04417671f, 
    0.19359477f, 0.09142652f, -0.00467388f, -0.08083232f, -0.01954529f, -0.05039008f, 0.16867468f, 0.17919058f, 
    0.23635058f, -0.00279854f, 0.14186972f, 0.09652385f, 0.04553555f, 0.06063709f, 0.07695574f, 0.12059443f, 
    0.03190909f, -0.00542251f, -0.08795124f, 0.21031454f, 0.30130693f, -0.11630578f, -0.24345760f, -0.00223648f, 
    -0.05185610f, -0.00169403f, -0.12959576f, 0.06029272f, 0.13136038f, -0.00862401f, 0.11933364f, 0.19405900f, 
    -0.02866338f, -0.02092595f, 0.05553482f, 0.06346501f, -0.06882041f, -0.01803784f, -0.07125911f, 0.04256535f, 
    0.01594808f, -0.00250924f, 0.05084093f, -0.04434343f, 0.00558010f, -0.01173571f, -0.00775816f, 0.03486273f, 
    -0.04827356f, 0.06287721f, -0.00842318f, 0.04038600f, 0.05256825f, 0.02897993f, 0.01777791f, -0.02423685f, 
    0.03819806f, -0.02851549f, -0.06561633f, -0.01845388f, 0.02755361f, -0.08860576f, -0.02682953f, -0.02759999f, 
    0.04721253f, -0.04732031f, -0.02045794f, 0.01039853f, -0.05587901f, -0.05255322f, 0.02679134f, -0.04909277f, 
    -0.00708867f, 0.01285110f, 0.06433512f, -0.04630258f, -0.08058670f, -0.04180662f, -0.01698625f, 0.00397782f, 
    0.04490993f, 0.04565942f, -0.05506141f, 0.00609678f, 0.04428089f, 0.00572083f, -0.00217981f, -0.06000416f, 
    -0.00652092f, -0.04283056f, 0.00099084f, -0.01897883f, -0.02187185f, -0.00678924f, -0.01589632f, -0.03884862f, 
    -0.04027881f, -0.03123160f, -0.02449409f, 0.04395356f, -0.00941247f, -0.01882315f, 0.05950173f, -0.03504889f, 
    0.01238048f, 0.02030046f, 0.00793324f, -0.07863772f, -0.02939341f, -0.05218790f, -0.04863549f, -0.02335537f, 
    0.03379522f, -0.05447828f, -0.04925701f, -0.03692002f, -0.04439696f, -0.04003023f, -0.04157731f, -0.06056293f, 
    0.03631817f, -0.02021105f, 0.04744449f, 0.06334191f, -0.06710144f, -0.01597152f, -0.05529990f, -0.00544857f, 
    0.05821301f, -0.05622629f, 0.03005593f, 0.03872410f, -0.03031879f, 0.00218036f, -0.01228764f, -0.03727262f, 
    -0.01504161f, -0.00487769f, -0.03431025f, -0.02954254f, -0.00584662f, 0.04975425f, -0.05785174f, -0.00362004f, 
    -0.00638587f, -0.02768953f, -0.02353485f, -0.01541418f, 0.06109135f, -0.06286839f, 0.06612433f, 0.03915565f, 
    0.03236554f, 0.03615656f, -0.00088967f, -0.02756233f, -0.00729497f, 0.04197963f, 0.06860831f, 0.01670137f, 
    0.02280819f, 0.04521600f, 0.01922086f, 0.02615715f, 0.07566244f, 0.00439023f, -0.06331084f, 0.03532848f, 
    -0.06316306f, 0.00080317f, -0.01131547f, -0.07347088f, -0.05101245f, 0.03605131f, 0.06496800f, 0.05876627f, 
    -0.05635270f, 0.03743307f, -0.01892305f, 0.05695444f, 0.00114891f, 0.00718650f, -0.00461970f, 0.05312124f, 
    0.05519400f, -0.04953717f, 0.04658261f, -0.04443682f, 0.04297880f, 0.03402913f, 0.00900608f, -0.05216669f, 
    -0.01968235f, 0.01933512f, -0.03727692f, -0.02038685f, -0.05881689f, -0.05446268f, 0.03229261f, 0.02899877f, 
    -0.00120703f, -0.01600628f, -0.01667197f, -0.03584719f, -0.04746974f, 0.04665836f, -0.04247507f, -0.06228563f, 
    -0.07617810f, 0.02683078f, 0.02242780f, -0.02339435f, -0.04824064f, -0.06449404f, -0.06945321f, 0.04545489f, 
    0.06307487f, -0.06073139f, -0.00008701f, -0.06215752f, -0.00611379f, 0.00962665f, -0.08012101f, -0.02704488f, 
    -0.19089395f, -0.02725338f, -0.06774291f, 0.20651670f, -0.03760064f, 0.02947003f, -0.01197003f, -0.06166214f, 
    -0.07887220f, 0.08135923f, 0.00293006f, 0.16928959f, 0.42778164f, 0.05799219f, -0.04877251f, -0.11662235f, 
    0.01264602f, 0.06558543f, 0.04494395f, 0.02540731f, -0.07164457f, -0.11673057f, 0.18308227f, 0.00579357f, 
    -0.15652794f, -0.10901878f, 0.09810345f, -0.38322020f, -0.04037167f, 0.13014168f, 0.23777443f, 0.03479966f, 
    0.10195994f, 0.00293747f, 0.05214754f, 0.13252518f, -0.02722527f, 0.04618390f, 0.16514844f, -0.08181651f, 
    0.12037221f, -0.08741359f, 0.20752113f, 0.19771430f, -0.08940246f, 0.04148391f, 0.04429200f, 0.10942005f, 
    -0.02737864f, 0.11843573f, 0.04720514f, 0.07392684f, 0.02267725f, 0.11363019f, 0.08783267f, -0.01998930f, 
    0.11596280f, -0.16562854f, -0.19724025f, 0.00434479f, 0.52398843f, -0.18917523f, 0.02344529f, -0.01917548f, 
    0.00055505f, 0.06925829f, 0.01106247f, 0.04022248f, -0.01934324f, 0.06486318f, -0.03760735f, -0.15124480f, 
    0.04075230f, 0.10163835f, 0.02123075f, 0.01661860f, 0.12902026f, -0.06442769f, 0.07677747f, 0.01267449f, 
    -0.20451750f, 0.06805370f, -0.11703551f, -0.00894433f, 0.15943246f, -0.12873660f, -0.59410721f, 0.20131236f, 
    0.00779938f, -0.00786712f, -0.06474986f, -0.15026984f, -0.00360653f, 0.00969955f, 0.07039648f, 0.11293264f, 
    0.01118936f, 0.06155594f, -0.27315050f, 0.01199626f, 0.07666538f, -0.03705234f, 0.25282779f, 0.22442698f, 
    0.00921649f, 0.05624041f, 0.11939043f, 0.09951747f, 0.32777891f, 0.01495892f, -0.13391431f, -0.15894714f, 
    0.18411978f, 0.00648195f, -0.15943620f, -0.07465747f, 0.18514915f, 0.16365197f, -0.09814068f, -0.01417988f, 
    0.57297057f, -0.07274215f, 0.01711862f, 0.24443345f, 0.06418783f, -0.08751205f, 0.10315463f, 0.21178252f, 
    -0.04498932f, -0.03490255f, 0.05408869f, -0.04570086f, 0.32286647f, -0.20689780f, 0.17099145f, 0.37220725f, 
    0.05829163f, -0.13221765f, -0.08171429f, 0.10569362f, -0.00273229f, 0.07106105f, 0.17647097f, 0.05336727f, 
    0.28157982f, 0.02599704f, -0.00682905f, 0.04837562f, -0.13282372f, -0.06064853f, -0.12763797f, -0.08195546f, 
    -0.04768919f, 0.07492805f, 0.07269837f, 0.17016646f, 0.11443813f, -0.27223769f, -0.43912423f, -0.30100453f, 
    -0.05365862f, -0.10377568f, -0.10464311f, -0.05190718f, -0.02343339f, 0.05374874f, -0.08754547f, 0.08676129f, 
    0.32775655f, 0.17934892f, -0.08669923f, -0.22033238f, 0.17159329f, 0.05571103f, 0.18378606f, 0.00593050f, 
    -0.10724997f, -0.03950466f, -0.05434197f, -0.20210250f, -0.19850183f, -0.15792298f, -0.18530521f, 0.12261522f, 
    -0.00794601f, -0.04795465f, -0.16115116f, 0.15936579f, -0.08838116f, 0.09700041f, 0.01979197f, 0.02728764f, 
    0.11996471f, -0.40141413f, 0.13816918f, -0.01189077f, -0.05820798f, -0.06300112f, 0.12274899f, 0.14591293f, 
    -0.16340564f, -0.06192263f, -0.04939021f, 0.14209099f, 0.04462310f, 0.11534358f, -0.12130080f, -0.35983014f, 
    0.01741040f, -0.02492753f, 0.04214954f, 0.03435302f, 0.18032086f, 0.11182357f, -0.14134161f, 0.02738820f, 
    0.17994772f, -0.18723242f, 0.02681390f, -0.17977302f, -0.04032977f, -0.10134446f, -0.02942973f, 0.05721683f, 
    -0.00842358f, -0.06984816f, 0.01771392f, -0.02498056f, 0.10748078f, 0.01315675f, 0.09430142f, -0.11807575f, 
    0.01907859f, 0.08230428f, -0.09754267f, -0.03011422f, -0.01117671f, 0.01733892f, -0.03665921f, 0.02282873f, 
    0.09835541f, 0.12572178f, 0.08890904f, 0.03578582f, -0.06848769f, 0.02257992f, -0.06095846f, 0.17040886f, 
    -0.01627203f, -0.03809154f, 0.00376203f, 0.05238248f, -0.24122500f, 0.06981795f, -0.00881105f, 0.10091598f, 
    0.07836869f, -0.05186931f, 0.02253329f, -0.07943532f, 0.11578854f, 0.18833958f, 0.05222580f, 0.11959952f, 
    0.14714350f, -0.26283392f, 0.13792290f, -0.33005136f, 0.05742754f, -0.01619787f, 0.03444657f, -0.08631272f, 
    -0.06450179f, -0.13632686f, -0.00514385f, -0.04088729f, 0.21794057f, 0.04598365f, 0.14089319f, 0.37242347f, 
    -0.08806849f, 0.15055732f, -0.07116400f, 0.08275118f, -0.06969459f, 0.12257898f, 0.07186590f, -0.01330910f, 
    0.27786282f, 0.17500861f, -0.09228797f, 0.22519468f, 0.03009661f, 0.06422330f, 0.04636214f, -0.18334706f, 
    -0.09072094f, -0.00399794f, -0.04388418f, 0.06392621f, 0.43811542f, 0.16429880f, 0.05598763f, -0.09720033f, 
    0.08036090f, 0.09443348f, 0.17462452f, 0.01894495f, 0.06443534f, -0.14568365f, -0.11057421f, -0.06620184f, 
    0.40279222f, -0.04802073f, -0.13902609f, -0.03371238f, -0.19802341f, -0.25122976f, 0.09095524f, 0.12835895f, 
    -0.08735797f, 0.01900194f, 0.00850650f, -0.03707840f, 0.33418795f, -0.36437184f, 0.01522814f, 0.02462619f, 
    -0.10991560f, -0.01058883f, 0.22670460f, 0.06226007f, -0.04258466f, -0.00050204f, 0.00747515f, -0.18267457f, 
    -0.40037349f, 0.14038360f, 0.20072232f, 0.23346433f, -0.03127902f, 0.02768621f, -0.02005375f, 0.00045817f, 
    -0.01462378f, -0.01659514f, -0.02132434f, 0.07622591f, 0.02585440f, -0.25084683f, -0.04369891f, -0.06188036f, 
    0.00378705f, -0.01296553f, 0.01608071f, 0.12436040f, 0.06621924f, 0.08505629f, 0.01067217f, 0.18379450f, 
    0.21021286f, -0.05431166f, -0.01823666f, 0.06322512f, -0.00103795f, 0.00617772f, 0.08739132f, 0.08719503f, 
    -0.07945416f, -0.05973001f, 0.08910879f, 0.21012440f, 0.14384894f, 0.13218898f, -0.11740588f, 0.18563446f, 
    0.04006452f, 0.02402322f, -0.04021281f, -0.14874184f, 0.01958416f, -0.13484044f, -0.02878685f, -0.03448518f, 
    0.04906256f, -0.00443819f, -0.04721089f, 0.03288297f, -0.01987616f, -0.05195256f, 0.03989894f, -0.02750816f, 
    -0.07895066f, -0.04043455f, -0.04816940f, 0.02051971f, -0.02751482f, -0.05381589f, 0.03789072f, -0.03571289f, 
    -0.02983847f, 0.02067288f, -0.01814048f, -0.06129240f, -0.03606835f, 0.01996407f, -0.00429386f, -0.06919780f, 
    -0.02810732f, -0.03677550f, 0.05946264f, 0.03323739f, -0.05785367f, -0.04209074f, -0.04604523f, -0.02013141f, 
    -0.01296257f, -0.02299065f, 0.04981369f, 0.05956361f, -0.04203938f, 0.02267475f, 0.02541908f, 0.00715826f, 
    0.02539652f, 0.03764498f, -0.02430092f, -0.01028159f, -0.07141301f, -0.02796370f, -0.01396238f, -0.02314496f, 
    -0.04160383f, 0.00644198f, 0.05130568f, 0.03956592f, 0.01694698f, -0.01455782f, 0.05068727f, -0.05490530f, 
    -0.07734091f, 0.03814843f, 0.04785834f, -0.08088576f, 0.05643736f, 0.03804329f, -0.06403619f, -0.07397909f, 
    -0.02275058f, -0.05849479f, -0.05333042f, -0.05851147f, 0.03301892f, 0.00254682f, -0.00573571f, 0.02014678f, 
    -0.03263715f, -0.06788515f, -0.07798322f, -0.00447652f, -0.06209139f, 0.02766172f, 0.03219087f, 0.03448323f, 
    -0.02254042f, 0.05862214f, 0.06356335f, -0.01140793f, 0.02595335f, -0.07420922f, -0.02320925f, 0.00772173f, 
    0.00393605f, -0.06690446f, -0.04680784f, -0.08052969f, 0.01488628f, 0.01076337f, -0.02318828f, -0.00469648f, 
    -0.01718703f, 0.07100403f, -0.06103015f, -0.03412095f, 0.04300224f, 0.06441560f, -0.06230913f, 0.01970665f, 
    -0.01343495f, 0.05358905f, 0.02708649f, -0.04675246f, -0.07041271f, 0.05596623f, -0.04660861f, 0.00689087f, 
    -0.00877512f, -0.05151326f, -0.07688353f, 0.05109819f, 0.05522816f, -0.00447619f, -0.04281820f, 0.05072952f, 
    -0.04594034f, 0.00414215f, -0.00922457f, 0.02819677f, 0.00684214f, 0.05599399f, -0.07199040f, -0.00487256f, 
    0.03825856f, -0.01240875f, -0.05613114f, -0.07567327f, -0.02588214f, -0.07741496f, -0.06959710f, -0.06533591f, 
    -0.03252155f, 0.05345925f, 0.05257544f, -0.06571606f, -0.01779280f, -0.03081162f, 0.05368622f, 0.06190054f, 
    0.00717940f, -0.00634405f, 0.03037921f, -0.02172906f, -0.06477311f, -0.04021047f, -0.01460628f, 0.03318351f, 
    -0.02346562f, -0.00176800f, -0.01300752f, 0.00658495f, 0.04936197f, -0.06445675f, -0.05536604f, -0.03193617f, 
    0.06299373f, -0.06666776f, -0.03333527f, 0.01007246f, -0.08203600f, -0.04621470f, -0.02956690f, -0.03913201f, 
    -0.05502313f, -0.06765783f, 0.06037390f, -0.07129250f, 0.04973662f, -0.06973395f, 0.01726428f, 0.00298350f, 
    0.01235987f, -0.04084043f, 0.03079365f, -0.02610597f, 0.02890236f, 0.01141660f, 0.03996943f, -0.05956980f, 
    0.02208626f, -0.01309480f, 0.01991199f, -0.00069593f, -0.06157740f, 0.05632343f, -0.06261431f, -0.00675489f, 
    0.15647446f, 0.27069113f, 0.07738316f, 0.07951955f, 0.18468030f, -0.11166082f, 0.00676277f, -0.11225839f, 
    0.17736942f, -0.04222501f, 0.15271701f, -0.11032241f, 0.26166409f, 0.05444758f, 0.33971661f, 0.29951391f, 
    0.11964082f, 0.08006600f, 0.08085413f, 0.14196201f, -0.03048981f, -0.03924116f, -0.02186204f, 0.05367105f, 
    -0.29123178f, -0.07580965f, 0.15437014f, 0.20025113f, 0.11675235f, 0.07115671f, 0.07154381f, -0.00158583f, 
    -0.13766110f, 0.11906762f, 0.14070132f, 0.16677110f, -0.25122574f, 0.05860957f, -0.04050126f, 0.15645429f, 
    -0.04640552f, 0.04078564f, 0.16573404f, -0.11273873f, -0.00256675f, -0.00154735f, 0.09811530f, -0.06289013f, 
    0.01339971f, -0.13270453f, 0.02628102f, -0.22739367f, 0.08919597f, 0.04792609f, 0.11355796f, 0.00159644f, 
    0.01858808f, 0.11682752f, -0.08980547f, 0.07418432f, 0.37680686f, -0.08772781f, -0.27695677f, 0.02194476f, 
    0.08572790f, 0.09298702f, 0.06909309f, 0.01327160f, -0.12405741f, -0.14216475f, -0.20692222f, -0.14004496f, 
    -0.17294359f, 0.08021601f, -0.10994005f, 0.09956940f, -0.04194284f, -0.20779155f, 0.15898813f, -0.12661184f, 
    0.02960580f, 0.21209134f, 0.07327193f, 0.03175874f, -0.42734548f, -0.00054731f, 0.16443135f, -0.24529415f, 
    0.04147505f, -0.06555099f, 0.14867257f, -0.04168023f, -0.06862392f, 0.02013379f, 0.14100233f, 0.14488415f, 
    -0.26373088f, -0.01386822f, -0.00277655f, -0.24639125f, -0.01153332f, -0.08774113f, 0.18818168f, 0.05385571f, 
    -0.08003609f, 0.08973123f, 0.11566065f, 0.15956546f, 0.32303169f, 0.11639448f, 0.08787111f, 0.18421513f, 
    -0.11549253f, 0.08199795f, 0.08370263f, 0.03610263f, -0.04427442f, -0.02184378f, 0.03642369f, 0.18543068f, 
    -0.19668189f, 0.03338298f, -0.01001875f, 0.03947721f, 0.05053978f, 0.00971263f, -0.01497227f, -0.04387956f, 
    0.03015593f, 0.02229594f, -0.01273458f, 0.05297070f, -0.01774847f, 0.31227946f, -0.10938881f, -0.02662345f, 
    0.02741466f, 0.05869731f, -0.13899894f, 0.10063978f, -0.02423876f, 0.03440589f, 0.02213354f, -0.00110098f, 
    0.43444648f, 0.01419783f, -0.00468425f, 0.11850163f, 0.01825367f, 0.11717349f, 0.02393141f, 0.03631270f, 
    0.07635089f, -0.13339418f, -0.06008655f, 0.10851047f, -0.26491082f, 0.11096061f, -0.01666719f, -0.15345921f, 
    -0.08576570f, -0.02789520f, 0.08905995f, 0.00260097f, 0.01383270f, 0.08505613f, -0.07053051f, 0.07689650f, 
    -0.27675542f, 0.03260497f, -0.20427926f, -0.16389249f, -0.03239748f, -0.00009639f, -0.08796737f, -0.13667864f, 
    0.00550816f, -0.00812455f, -0.01130446f, -0.16244991f, -0.45849824f, 0.03453593f, 0.31957248f, 0.13186529f, 
    -0.07413755f, -0.02777575f, 0.08435048f, 0.03309289f, 0.07322868f, 0.01815622f, 0.04846725f, -0.01028701f, 
    -0.28134850f, 0.04224115f, -0.19392201f, 0.06090444f, 0.08189932f, 0.05347915f, -0.08041855f, 0.13788293f, 
    0.00269206f, -0.03392698f, -0.03131368f, -0.05025626f, -0.06990951f, -0.12498318f, -0.00703643f, 0.07601363f, 
    -0.13807648f, 0.10310738f, 0.13544692f, -0.02718235f, -0.03241783f, -0.07068680f, 0.15814407f, -0.12705766f, 
    0.03824268f, 0.10715268f, 0.05995053f, 0.12447985f, 0.02901069f, -0.04700519f, 0.05795534f, -0.09744105f, 
    0.09060282f, 0.03403152f, 0.06006731f, 0.02864098f, 0.29009700f, -0.03800504f, 0.07451510f, -0.03394428f, 
    0.19312762f, 0.01325832f, 0.17988905f, 0.12053359f, -0.02397173f, 0.03285159f, -0.05064847f, 0.03644606f, 
    -0.39629346f, 0.32067713f, -0.07486638f, 0.11086408f, -0.03532645f, 0.03597340f, 0.11855164f, 0.10743271f, 
    0.20462994f, -0.04909014f, -0.03911797f, -0.04213667f, 0.25735548f, 0.00292328f, -0.12100904f, -0.03432264f, 
    0.02179943f, -0.10791945f, 0.00689142f, -0.06729215f, -0.04146584f, -0.14378618f, -0.01771999f, 0.05531062f, 
    0.01923602f, 0.06801221f, -0.31387222f, 0.03487606f, 0.14478116f, -0.04184205f, 0.08595140f, -0.05627624f, 
    0.07264930f, -0.13907667f, 0.00163373f, -0.00831717f, 0.60522622f, 0.05619386f, -0.22184570f, -0.02491570f, 
    0.18208757f, 0.03911544f, -0.06504510f, 0.04357430f, 0.22188622f, -0.01594848f, 0.05962447f, 0.04393571f, 
    -0.20941372f, -0.10570897f, 0.07823838f, 0.20278022f, 0.02095077f, -0.05381468f, 0.08404826f, 0.33687654f, 
    0.05745460f, -0.10257705f, 0.09777629f, 0.13222174f, -0.36880413f, -0.12572609f, 0.09507775f, -0.23920967f, 
    0.04946624f, 0.05876041f, -0.08788336f, -0.14117554f, 0.09304133f, 0.01489480f, 0.03386321f, 0.09531343f, 
    0.09166329f, -0.23999707f, 0.03730873f, 0.07577673f, 0.12447503f, -0.12574066f, -0.01528847f, 0.06729905f, 
    0.07930771f, 0.08548894f, 0.01240816f, 0.09212881f, 0.11506791f, 0.04790602f, 0.10401928f, 0.08751362f, 
    0.07209856f, -0.11382963f, 0.05572256f, 0.07436278f, -0.08221246f, 0.05551250f, 0.22066152f, -0.11344493f, 
    0.36068401f, 0.45700625f, 0.24540515f, -0.37071246f, -0.02787397f, -0.00728556f, -0.11276996f, -0.02413385f, 
    -0.02146479f, 0.09593569f, -0.01571605f, -0.00776060f, 0.29959595f, 0.24511176f, -0.02116328f, 0.18351462f, 
    0.15511656f, 0.01771444f, 0.00275534f, 0.05468581f, 0.04612567f, 0.03746800f, -0.11633348f, -0.00841321f, 
    0.05260329f, 0.03491337f, -0.06778427f, 0.13049106f, 0.08584791f, -0.08427998f, 0.09657086f, -0.09966171f, 
    0.04823118f, 0.09383938f, 0.11322702f, -0.06765243f, 0.38382357f, -0.05130478f, -0.04187427f, -0.06707007f, 
    -0.07790456f, -0.00874594f, -0.11601010f, 0.25271419f, -0.05869820f, 0.09110314f, -0.03294380f, 0.00085507f, 
    -0.00626550f, -0.00347367f, -0.04079182f, -0.03667641f, 0.06057989f, -0.06890567f, -0.04893060f, -0.06398358f, 
    -0.04001547f, 0.02368164f, -0.04936010f, 0.03758286f, 0.02945158f, 0.02020016f, -0.05035807f, -0.02101180f, 
    -0.05812633f, 0.02583423f, -0.05151319f, 0.04206439f, 0.00350703f, -0.02623642f, -0.07701460f, -0.06674512f, 
    0.01275514f, -0.00954306f, 0.04870664f, 0.01304641f, 0.04673522f, -0.07355091f, -0.07428614f, -0.07340325f, 
    -0.01167463f, -0.01157130f, -0.07136581f, -0.05115373f, 0.01971230f, 0.01065136f, 0.04189711f, -0.00043717f, 
    -0.05163765f, -0.07846826f, -0.04242513f, -0.03241654f, -0.03051894f, 0.05231439f, 0.05578791f, -0.04708019f, 
    0.03856402f, 0.06274805f, -0.06546995f, -0.05575987f, 0.00135246f, 0.05546058f, -0.06616960f, -0.02798539f, 
    0.05797400f, -0.01248198f, 0.05455780f, -0.01984591f, 0.02303391f, -0.03304424f, 0.04140010f, -0.03845605f, 
    0.03223895f, -0.06304114f, 0.04436071f, -0.07105742f, 0.05867196f, 0.04783765f, 0.00307957f, -0.05059707f, 
    -0.04020958f, -0.02847378f, -0.06996166f, -0.01712137f, 0.03367869f, -0.04921952f, 0.06609536f, -0.02757779f, 
    -0.06273233f, 0.06211730f, -0.06786110f, 0.01112653f, 0.05301693f, 0.01030203f, 0.00867221f, 0.00212777f, 
    -0.07439960f, -0.04859175f, -0.06653284f, -0.03703814f, 0.00714609f, -0.02785988f, -0.05618582f, -0.07735092f, 
    0.05973901f, 0.05912378f, -0.02853174f, -0.03939619f, 0.03726391f, 0.04549145f, 0.01243248f, -0.02953051f, 
    -0.00682796f, -0.06335004f, 0.02021847f, -0.02995746f, 0.00903787f, 0.05219326f, 0.01496634f, -0.00772401f, 
    0.00034858f, -0.05257459f, -0.02197319f, -0.02702232f, 0.05022291f, -0.03579168f, -0.01372121f, -0.06883650f, 
    -0.02022842f, -0.06746804f, -0.03881331f, -0.05101627f, 0.01036553f, -0.06541426f, -0.03444557f, -0.01703906f, 
    0.00417593f, -0.03800701f, 0.00831819f, -0.07066246f, -0.00706691f, 0.03884584f, -0.01584156f, 0.00914710f, 
    0.05925908f, -0.01100415f, 0.03347960f, -0.08032207f, -0.01854799f, 0.02859900f, -0.02391313f, 0.00419166f, 
    0.00333623f, -0.06969257f, -0.00701110f, 0.01283940f, -0.05626670f, -0.07493111f, 0.03458008f, 0.06268229f, 
    0.04230269f, -0.01297558f, 0.02527189f, -0.01030398f, 0.00158907f, 0.03331941f, 0.05196660f, 0.02339558f, 
    0.00105389f, -0.05365123f, -0.02892549f, 0.06242701f, 0.01607835f, 0.01157837f, -0.07694144f, -0.05678220f, 
    -0.06765065f, 0.00491891f, 0.04499528f, -0.01249981f, 0.02041104f, 0.04092320f, -0.00564016f, -0.00468159f, 
    0.06263458f, 0.05871392f, -0.03307578f, 0.00636419f, -0.02505618f, -0.03413074f, -0.00011955f, 0.06219845f, 
    0.00824037f, -0.07337400f, 0.00374008f, -0.00934022f, -0.00009308f, -0.03638629f, 0.04835263f, -0.06273957f, 
    0.04261402f, -0.17161654f, 0.26255578f, -0.01674922f, 0.08403902f, -0.00818433f, 0.15449624f, -0.15795277f, 
    -0.15170404f, -0.16570102f, 0.06553856f, 0.05196613f, 0.15996608f, -0.07360379f, 0.02450772f, 0.23866107f, 
    0.13405325f, -0.05929491f, 0.06482805f, 0.03258998f, -0.01083057f, -0.06519604f, -0.05413699f, -0.05813083f, 
    -0.14765956f, 0.19585522f, 0.04401208f, 0.02030243f, -0.05232906f, 0.09789685f, 0.11466314f, 0.18735109f, 
    0.02492066f, -0.01249750f, -0.07662687f, 0.04430989f, -0.03353143f, 0.04439268f, -0.18491694f, 0.00669570f, 
    0.06257080f, 0.02011555f, -0.03033591f, 0.01738902f, 0.05885863f, 0.10439228f, 0.13998832f, -0.08197814f, 
    0.58002853f, -0.13376760f, 0.02921754f, 0.10026039f, 0.18913361f, 0.02547155f, 0.13285288f, -0.08074252f, 
    -0.17639975f, 0.21349956f, -0.15980387f, 0.01544872f, 0.51667303f, 0.02450458f, 0.11069132f, -0.05569950f, 
    0.13266860f, 0.11458106f, 0.19604945f, -0.06444443f, 0.04115628f, 0.18667658f, -0.00940262f, -0.03260690f, 
    0.06307432f, -0.01934410f, 0.24261081f, 0.06178513f, -0.07820652f, 0.13620897f, 0.00719844f, 0.30549586f, 
    0.05057978f, 0.08003186f, 0.10726944f, -0.03721847f, -0.30726749f, -0.26587465f, 0.01343256f, -0.09390209f, 
    -0.17088783f, 0.09462225f, 0.00017685f, 0.01452004f, -0.02524434f, 0.05155074f, 0.09898268f, 0.11901559f, 
    0.00507392f, 0.08535521f, -0.00349723f, -0.26653686f, -0.13112788f, 0.08511171f, 0.05439195f, -0.20995417f, 
    0.07940307f, -0.04225897f, -0.02642642f, 0.14559308f, 0.13853803f, 0.24970388f, 0.06643464f, 0.46223688f, 
    -0.02597015f, 0.03699718f, 0.09015555f, 0.07197060f, 0.01462534f, 0.12128785f, -0.04087599f, 0.07821146f, 
    -0.16749431f, 0.05742832f, 0.29936412f, -0.08264346f, 0.00859884f, 0.09145417f, 0.16863157f, 0.02016104f, 
    0.08597723f, 0.06444288f, -0.03563390f, 0.02264058f, -0.51475203f, 0.18139082f, 0.01655731f, -0.04886752f, 
    -0.24097008f, 0.22712986f, -0.06895101f, -0.05164167f, 0.07702431f, -0.08012393f, -0.15013553f, 0.08333991f, 
    -0.38942891f, 0.00909649f, 0.11524267f, -0.13851613f, 0.10852004f, -0.12964559f, 0.06007699f, 0.07937318f, 
    -0.07205597f, -0.00221572f, -0.06613199f, -0.03535387f, -0.65716588f, 0.29620954f, 0.12245040f, -0.16581401f, 
    -0.14988957f, 0.06085100f, 0.08574975f, -0.08878849f, 0.02712989f, 0.15774691f, 0.06007348f, 0.06576905f, 
    -0.00719110f, -0.24039513f, 0.07672460f, -0.32787344f, 0.10887749f, 0.16565262f, -0.13703898f, -0.11559435f, 
    0.01906532f, -0.04658797f, -0.01750954f, 0.03457811f, -0.02866028f, -0.22110939f, 0.20377383f, -0.07892535f, 
    0.11830858f, 0.08419330f, 0.01703175f, -0.03811158f, 0.24319470f, 0.07315561f, 0.04061127f, 0.10737572f, 
    0.05288783f, -0.01682954f, -0.01112499f, -0.10357779f, -0.05089347f, -0.01266094f, 0.03197865f, -0.00936424f, 
    -0.02594529f, 0.01325267f, -0.00715126f, -0.07594097f, 0.02465867f, -0.04648254f, -0.03355381f, 0.02217922f, 
    0.00411675f, 0.05154907f, -0.06905726f, -0.03400586f, 0.01571905f, -0.11062133f, -0.00511615f, 0.03612133f, 
    -0.05325675f, 0.04890339f, 0.02428917f, 0.03886913f, -0.02616462f, 0.00895046f, -0.05631485f, 0.05651397f, 
    -0.07780980f, -0.05419600f, -0.02952428f, 0.00231745f, -0.04592908f, -0.00130930f, 0.07816556f, 0.04049530f, 
    0.03931981f, -0.02453205f, 0.05309909f, 0.01771827f, -0.04053091f, -0.05879726f, -0.08274356f, 0.05376825f, 
    0.03021557f, -0.08964179f, 0.04126318f, -0.06558283f, -0.10757136f, 0.02825716f, -0.07250009f, -0.02649323f, 
    0.00411432f, -0.03349299f, -0.06590457f, 0.03762357f, -0.02642916f, -0.10321168f, 0.07218651f, -0.04528859f, 
    -0.12373374f, -0.00537703f, 0.03357858f, -0.08547095f, -0.08966167f, -0.05878751f, -0.08099876f, 0.02194869f, 
    0.03902890f, 0.07479316f, 0.07019436f, -0.09434016f, -0.01853800f, 0.00856117f, 0.00305086f, 0.00660400f, 
    -0.08048906f, 0.04277198f, 0.08190056f, 0.02448589f, -0.03767065f, -0.03774368f, -0.05725160f, 0.04583942f, 
    0.02110313f, -0.00094983f, 0.00492913f, -0.05510347f, 0.00645238f, 0.01270160f, -0.01596062f, 0.02573771f, 
    -0.01974710f, -0.04251257f, -0.02057510f, -0.01252814f, 0.00701172f, -0.03506367f, 0.04983841f, 0.01059432f, 
    -0.04060450f, 0.06655892f, 0.05705722f, 0.04975213f, 0.02708082f, 0.03858899f, 0.02348368f, -0.05228793f, 
    0.01264859f, -0.04862196f, -0.03308620f, -0.07351170f, -0.03909219f, -0.01538139f, -0.01057155f, -0.00281893f, 
    -0.07826674f, 0.00060339f, 0.06835462f, -0.03827962f, -0.08739567f, -0.08935406f, -0.03185508f, 0.02227994f, 
    -0.06806004f, 0.00502545f, 0.04311410f, -0.04390427f, 0.02308864f, -0.01137940f, 0.07291044f, 0.02605416f, 
    -0.03558474f, 0.07099659f, 0.04045286f, -0.00511090f, -0.00371622f, -0.03159403f, -0.06830603f, 0.03138060f, 
    -0.01360179f, -0.05623960f, -0.03724447f, -0.09230173f, 0.04261712f, -0.05101965f, -0.04901947f, -0.05742498f, 
    0.05780926f, 0.00387642f, -0.04138250f, -0.04314788f, -0.01441284f, -0.10806385f, -0.10817371f, -0.03986218f, 
    -0.11315987f, -0.07188199f, -0.03940017f, 0.00589784f, 0.01100036f, -0.02594990f, -0.02363328f, -0.00067478f, 
    0.04517927f, -0.01922214f, -0.07724501f, 0.01739046f, -0.02752854f, 0.00916016f, -0.05553090f, -0.10025355f, 
    -0.05098721f, -0.10588340f, 0.02104793f, -0.02500291f, -0.03827914f, -0.10295481f, -0.01464378f, 0.03673771f, 
    -0.06130120f, -0.08821055f, 0.06182047f, -0.08175185f, -0.05413770f, -0.02372216f, 0.01586725f, -0.04643306f, 
    0.00304623f, -0.02619120f, 0.01410000f, 0.05958667f, -0.06857763f, -0.03911011f, -0.04324568f, -0.06736286f, 
    0.00986423f, -0.02380597f, 0.03589705f, -0.05197450f, 0.02680184f, -0.04709172f, -0.05651161f, -0.05543877f, 
    -0.01489014f, -0.05455291f, -0.04102188f, 0.00734704f, 0.06111327f, -0.02982008f, 0.02818228f, -0.01877696f, 
    -0.04119835f, -0.04267475f, -0.03517156f, -0.00059729f, 0.02155135f, -0.04884561f, -0.04756912f, -0.00093146f, 
    -0.04725684f, -0.06766582f, -0.07284727f, 0.02325282f, -0.00026111f, 0.01839335f, -0.06920598f, 0.03977990f, 
    -0.07304981f, -0.00573986f, -0.04279611f, 0.04591576f, -0.06203420f, -0.03545653f, 0.01724279f, 0.02320386f, 
    0.01808154f, 0.06417590f, 0.05913174f, -0.01110050f, -0.06345368f, -0.03172427f, -0.01596955f, -0.05648039f, 
    0.05814451f, -0.05758577f, 0.05916651f, -0.06097342f, -0.03519899f, 0.02486373f, -0.02245517f, -0.04624281f, 
    -0.01281869f, -0.03798307f, -0.07362340f, 0.00133061f, -0.05504413f, -0.01089960f, 0.06162582f, 0.03071500f, 
    0.01142970f, 0.00205332f, -0.06946058f, 0.00893481f, -0.07418869f, -0.01206093f, 0.01614489f, -0.02229325f, 
    -0.01006536f, -0.01590739f, -0.03624585f, 0.03572412f, -0.02306932f, 0.00345343f, -0.02416752f, -0.04056418f, 
    -0.07169890f, -0.05300914f, 0.01346960f, -0.03913375f, -0.07447198f, -0.03562069f, -0.00498092f, 0.03420161f, 
    -0.03437808f, 0.00760773f, 0.05729188f, 0.03223650f, 0.03536137f, -0.05749518f, 0.04200336f, 0.05061207f, 
    -0.06696434f, -0.06676290f, 0.02942170f, 0.06438231f, -0.05776982f, -0.05642137f, 0.00184098f, 0.01414723f, 
    -0.02360935f, -0.06085771f, -0.04261753f, 0.00655809f, 0.00177948f, 0.03385511f, -0.01131031f, -0.01636111f, 
    -0.03387265f, -0.03771293f, -0.01891827f, 0.00484663f, 0.01903378f, -0.01915888f, 0.05443576f, 0.02213803f, 
    -0.01277358f, -0.07280329f, -0.03749783f, 0.04630496f, -0.02254643f, -0.04083001f, -0.05566983f, 0.05375281f, 
    0.06363897f, -0.05507445f, -0.05817735f, 0.02230490f, -0.02789437f, 0.06239016f, -0.00239959f, 0.06142615f, 
    0.01561205f, -0.00349195f, -0.05433240f, -0.02710176f, 0.01661037f, -0.06064853f, 0.04605838f, -0.06064944f, 
    0.04153357f, -0.06574870f, 0.04076057f, 0.03948371f, -0.02398143f, 0.02164830f, -0.01753170f, -0.06703143f, 
    0.01690129f, -0.04228159f, -0.01991511f, -0.04298565f, 0.04526678f, 0.02979383f, -0.01504353f, -0.01408585f, 
    -0.06453704f, -0.02043439f, -0.02660023f, -0.06494994f, -0.00790013f, -0.06809562f, 0.03882895f, 0.03299223f, 
    0.06304350f, -0.01940378f, 0.06203700f, -0.06626906f, 0.00135193f, 0.00732411f, -0.02856338f, 0.03854289f, 
    0.06004138f, -0.01127118f, -0.06746308f, -0.00348027f, -0.06075486f, 0.02255468f, -0.07804328f, -0.05062409f, 
    -0.04700619f, 0.05614029f, 0.05877821f, -0.00881198f, -0.01649688f, 0.04048865f, -0.05460773f, -0.00733976f, 
    -0.04855618f, -0.03600620f, 0.02561088f, 0.05040185f, 0.04528437f, 0.04306167f, -0.01547834f, -0.02110199f, 
    0.01679132f, 0.03245274f, -0.03091499f, -0.04818167f, 0.03364239f, -0.02682554f, -0.07650151f, 0.04454637f, 
    -0.06236701f, -0.06482051f, 0.00951331f, -0.02134804f, -0.01401286f, 0.00271851f, -0.06118888f, -0.03294524f, 
    -0.04856883f, 0.00871701f, 0.04152898f, -0.06809790f, -0.02792630f, -0.05646453f, -0.04806920f, 0.00963858f, 
    -0.04033192f, -0.01838686f, -0.06711575f, -0.04035936f, -0.01140479f, 0.03632722f, -0.04810744f, -0.02144419f, 
    -0.06033954f, 0.02628677f, 0.03334887f, 0.00365560f, -0.00517356f, 0.03284137f, -0.05490688f, -0.05628548f, 
    0.04856127f, -0.00964002f, 0.00335536f, 0.05488615f, 0.01300196f, 0.00211578f, 0.03177021f, 0.03410150f, 
    0.03493335f, 0.02691147f, -0.07551996f, 0.01405954f, 0.00948396f, -0.01401917f, -0.07943733f, -0.07921721f, 
    -0.02062953f, -0.01367942f, -0.04958093f, -0.05838079f, -0.05555503f, -0.01908287f, 0.01120372f, 0.04858505f, 
    -0.04523487f, -0.01549300f, 0.03686592f, 0.02448829f, 0.00436278f, 0.02400400f, -0.03704531f, 0.06211690f, 
    0.05450921f, 0.01643679f, 0.05403479f, -0.07147118f, -0.02459336f, 0.02845147f, -0.04721811f, 0.06646020f, 
    -0.05023041f, -0.02149335f, 0.06584753f, 0.04684522f, -0.03738563f, -0.00315648f, -0.03921602f, -0.01501682f, 
    -0.04481873f, 0.00887530f, -0.03865513f, -0.04813965f, 0.00370392f, 0.03900133f, 0.02220176f, -0.00565383f, 
    -0.05158193f, -0.06152200f, 0.02196516f, 0.06014965f, 0.04375188f, -0.03157461f, -0.01644362f, -0.02380464f, 
    0.01389036f, -0.04268878f, 0.00589641f, 0.05292792f, 0.05615458f, 0.02096688f, 0.01043519f, -0.03134552f, 
    0.03448312f, 0.00116749f, -0.05078046f, 0.01224624f, 0.03674743f, -0.07168563f, -0.06114409f, -0.04039773f, 
    0.02454302f, 0.04772916f, 0.03347217f, 0.00072496f, 0.04565195f, 0.04725556f, 0.00930888f, -0.06896226f, 
    0.00539040f, -0.05877773f, -0.07203706f, -0.02934406f, -0.01661500f, 0.01248131f, 0.01601327f, 0.01299692f, 
    0.05100264f, 0.00206833f, -0.06887192f, -0.05579163f, -0.03957902f, -0.00469448f, -0.03863428f, -0.03322650f, 
    -0.08289173f, 0.00720722f, -0.01076238f, 0.02715038f, -0.04160552f, -0.01616731f, -0.00199505f, -0.00812067f, 
    -0.00367875f, 0.00865833f, -0.03545532f, -0.02917684f, -0.01099187f, -0.03445657f, -0.07019990f, -0.02316331f, 
    -0.06005873f, 0.00435595f, 0.01871185f, -0.03361407f, -0.01109186f, -0.06451851f, 0.04152391f, 0.04342457f, 
    -0.05883587f, 0.05843617f, -0.06839052f, -0.05340789f, -0.05064772f, -0.06688133f, 0.03735054f, -0.03965218f, 
    -0.03887430f, 0.02784797f, 0.02877079f, -0.03615924f, 0.01352914f, -0.02188300f, -0.05256402f, 0.03318823f, 
    0.05423636f, 0.05533450f, -0.02026588f, 0.03338318f, -0.06270392f, 0.02506240f, 0.03657126f, 0.05456488f, 
    -0.03037233f, 0.02980796f, -0.04092654f, -0.02803284f, 0.01216725f, -0.08103868f, 0.05560826f, -0.02899895f, 
    -0.01879464f, -0.00317264f, -0.00990182f, 0.05448051f, -0.07506615f, -0.00417950f, 0.02884571f, 0.02309824f, 
    0.05637061f, -0.02893242f, 0.01585508f, 0.03666550f, -0.05939797f, -0.00368947f, -0.06786834f, -0.02793634f, 
    0.05988264f, 0.00673731f, -0.00746454f, -0.07212652f, -0.03477067f, 0.04799204f, -0.01904076f, 0.01671657f, 
    0.07216316f, -0.01687569f, -0.02270323f, -0.01296498f, 0.02821054f, -0.04546656f, 0.05353279f, 0.01873750f, 
    0.05461514f, -0.02660877f, -0.08454645f, -0.05922665f, -0.01310734f, 0.06420539f, 0.01518501f, -0.06073210f, 
    -0.06904933f, 0.05416800f, -0.07470889f, -0.07678378f, 0.06905261f, 0.01648490f, 0.05724549f, 0.01626536f, 
    -0.00911878f, -0.03084615f, -0.06246966f, -0.05723515f, 0.01293898f, -0.04348843f, 0.04335310f, -0.01259131f, 
    0.02232742f, -0.05084774f, -0.04529086f, 0.06955823f, -0.03649439f, -0.06315778f, -0.06148515f, -0.03430611f, 
    -0.05135990f, -0.02331179f, 0.00030518f, -0.07775777f, 0.00003088f, -0.03758898f, 0.04194954f, 0.03651486f, 
    -0.08050375f, -0.00294894f, -0.01225966f, 0.03143146f, 0.01977408f, -0.04044495f, -0.06299249f, 0.01539917f, 
    -0.06981469f, 0.01904383f, -0.01145037f, -0.07648908f, -0.02164770f, -0.04481644f, -0.05702932f, -0.03838836f, 
    -0.03966042f, 0.03463244f, 0.03610436f, 0.00616994f, 0.04143732f, -0.02654232f, 0.01108773f, -0.01687343f, 
    -0.03238089f, -0.03507312f, 0.00331185f, 0.05100315f, -0.00304183f, -0.02840683f, -0.01234774f, 0.04173861f, 
    -0.05256465f, -0.02690699f, -0.02571270f, -0.02693960f, -0.04087908f, -0.04509298f, 0.00990937f, -0.05201405f, 
    -0.03138168f, 0.01332261f, 0.03803993f, 0.01370188f, -0.04324867f, 0.02855436f, -0.01689291f, -0.00834025f, 
    -0.08094268f, 0.02078337f, 0.02994510f, -0.04958432f, 0.03146929f, -0.04944137f, 0.00425681f, -0.02702156f, 
    0.00921426f, -0.01590509f, -0.00239577f, -0.05446208f, 0.03222759f, 0.01322539f, -0.07823568f, 0.00660228f, 
    0.02485615f, 0.02699699f, 0.01178145f, -0.02060406f, -0.03716513f, -0.02848527f, 0.02242912f, 0.02383586f, 
    -0.06448387f, 0.00412034f, 0.02170874f, 0.05265486f, 0.01404408f, -0.05136082f, 0.00068341f, -0.03093205f, 
    0.06552240f, 0.01182949f, -0.07053241f, -0.05891923f, 0.02950730f, 0.05996292f, -0.02047053f, -0.01721951f, 
    0.01711409f, 0.05474127f, -0.04100323f, -0.01664778f, -0.04266466f, -0.01081635f, -0.07563653f, 0.00884697f, 
    0.04273758f, 0.04091058f, -0.02949601f, 0.02020069f, 0.01966636f, -0.05257801f, -0.03035068f, -0.04935323f, 
    0.05481100f, 0.03886655f, -0.06031307f, -0.04638958f, 0.04031072f, -0.05280624f, -0.04418800f, -0.01994105f, 
    -0.01235704f, 0.01323120f, 0.00907035f, 0.02669943f, 0.05768516f, -0.03982409f, -0.07039203f, -0.02133641f, 
    -0.06098762f, 0.00455171f, 0.03485238f, 0.00768605f, 0.04670166f, -0.06023470f, -0.05539393f, 0.05548665f, 
    0.05752568f, -0.00725582f, -0.02349519f, -0.02877798f, -0.04718560f, 0.02091122f, 0.04902781f, -0.02106951f, 
    -0.04900482f, -0.06903404f, 0.05466198f, 0.06279708f, -0.04919018f, -0.00007271f, -0.04552741f, 0.01762659f, 
    -0.05074427f, -0.00314354f, 0.06396165f, 0.05189211f, -0.03069417f, 0.05303525f, 0.00601269f, -0.04335151f, 
    0.05914353f, -0.03678680f, -0.01124973f, 0.04535472f, -0.03984874f, -0.07287388f, -0.02696846f, 0.02199876f, 
    0.00002204f, -0.01356559f, -0.04671769f, -0.00622959f, 0.02119956f, -0.05216134f, -0.03716012f, 0.05976423f, 
    -0.06919161f, -0.07697652f, -0.00034099f, -0.04901811f, -0.05491342f, -0.01073633f, -0.04699067f, -0.06960244f, 
    0.05974964f, -0.01652044f, -0.02583826f, 0.05056006f, 0.02223223f, 0.00114771f, -0.04923138f, -0.07013970f, 
    -0.05597743f, -0.05812407f, -0.04920450f, -0.04994323f, 0.03630378f, 0.02630519f, 0.05217382f, 0.01815987f, 
    0.05683380f, -0.04042239f, -0.01913295f, -0.05625378f, 0.01995100f, -0.01893014f, -0.06625282f, -0.07384230f, 
    0.02670681f, -0.05284891f, -0.00540414f, 0.03585420f, -0.00540787f, -0.07290366f, -0.00527460f, 0.00875680f, 
    -0.04702440f, -0.06973577f, -0.04660314f, 0.00706023f, 0.04883583f, 0.05269321f, -0.01614244f, -0.01595287f, 
    0.02322125f, -0.04497049f, 0.01484213f, -0.07819089f, 0.05369847f, 0.04877797f, -0.06207814f, -0.07638159f, 
    0.05631001f, 0.00740063f, -0.05426030f, 0.04890906f, -0.01681215f, -0.02224594f, -0.07151210f, -0.07250973f, 
    0.01548453f, -0.02116450f, -0.03051988f, -0.00290985f, -0.03737707f, -0.03185892f, -0.05802971f, -0.01531184f, 
    -0.03451073f, -0.02887835f, -0.01467667f, -0.03999332f, -0.02960700f, -0.01776632f, 0.02890507f, 0.01094561f, 
    -0.02582746f, -0.03634887f, -0.07197709f, 0.00394946f, -0.00030876f, 0.02572263f, -0.01113013f, 0.03907463f, 
    0.03767399f, -0.06049606f, 0.01204342f, 0.00203851f, 0.02687527f, -0.04301980f, 0.04162494f, -0.04824806f, 
    0.06344164f, 0.04641423f, -0.07145414f, -0.03926641f, 0.04422526f, -0.07536492f, 0.01233868f, 0.02012942f, 
    0.04756841f, -0.00438873f, -0.02059819f, -0.06294206f, -0.04989946f, -0.01967393f, 0.01899658f, 0.04334856f, 
    0.06203851f, -0.01409037f, -0.04149529f, -0.06877285f, 0.00854426f, 0.01031054f, -0.03519329f, 0.04448242f, 
    -0.00676124f, -0.25936505f, -0.15299426f, 0.15175149f, -0.21343216f, -0.02112391f, 0.09962698f, -0.09467820f, 
    0.00041196f, 0.30304763f, 0.06497531f, -0.01704093f, -0.85949624f, 0.30713460f, -0.29719403f, -0.75787014f, 
    0.02415567f, 0.16013446f, 0.18157397f, -0.03561516f, 0.31602287f, 0.12472475f, -0.03976291f, -0.09531258f, 
    -0.01248553f, -0.03961644f, 0.11625940f, -0.03312878f, 0.01000224f, 0.01480730f, 0.02721255f, 0.16546708f, 
    0.06880406f, 0.01023389f, 0.06682160f, 0.07267637f, -0.13878991f, -0.08289905f, -0.00550057f, -0.16289206f, 
    -0.06533067f, -0.00857645f, -0.01019352f, 0.03946488f, 0.04258142f, -0.00068468f, -0.07919666f, 0.02592019f, 
    -0.54393011f, 0.08709394f, -0.12272180f, -0.09824084f, -0.03030324f, 0.06006211f, -0.11305753f, 0.12019568f, 
    -0.15186751f, 0.08376484f, -0.07596175f, 0.01327648f, -0.51231915f, 0.24898060f, -0.19025823f, -0.05129543f, 
    -0.04334049f, -0.00948095f, -0.06210704f, 0.07321236f, 0.26210549f, 0.08029244f, 0.12068231f, 0.23827909f, 
    0.01912937f, -0.35174301f, 0.29969448f, -0.36478460f, 0.15611082f, -0.09086595f, 0.16989088f, -0.02684781f, 
    -0.07985856f, -0.06069145f, 0.03371385f, 0.05906593f, 0.03008852f, -0.02586814f, 0.16570252f, 0.37889546f, 
    -0.07302039f, 0.03645394f, -0.13843364f, -0.00825732f, 0.08136628f, 0.06848961f, 0.03323687f, -0.02940738f, 
    0.14988236f, -0.23434839f, -0.15333487f, 0.00005925f, 0.21126029f, -0.01387696f, -0.03267318f, 0.02342274f, 
    0.03944134f, 0.15702447f, 0.15333048f, 0.10311469f, -0.19096585f, -0.08179151f, 0.00552589f, -0.16801372f, 
    -0.02726526f, 0.04340924f, 0.01544661f, 0.15676779f, 0.28552926f, -0.02767005f, 0.04262735f, 0.05818074f, 
    0.02581517f, -0.05772125f, -0.32440716f, -0.12389141f, 0.08686075f, -0.05804731f, 0.18753430f, 0.10234803f, 
    0.00840891f, 0.14358309f, -0.12233419f, -0.06705280f, 0.21972306f, -0.12262255f, 0.18787439f, 0.24616484f, 
    -0.05826838f, -0.11467610f, -0.03510632f, -0.09078236f, 0.16956060f, 0.15960878f, 0.00890295f, 0.19056037f, 
    -0.24235815f, 0.04058619f, 0.25293449f, 0.16185388f, -0.23436397f, -0.03088196f, 0.08361658f, -0.27984998f, 
    0.29146066f, -0.10623848f, 0.01430639f, 0.11006462f, 0.45586070f, -0.08758834f, -0.09899330f, 0.22470383f, 
    -0.20877431f, -0.08271181f, -0.09684298f, -0.06497085f, -0.00551491f, -0.03774139f, 0.04414626f, 0.08120546f, 
    0.02245769f, -0.04761883f, -0.28601325f, 0.13810578f, 0.10678618f, 0.15015882f, 0.12925386f, 0.16734171f, 
    0.12399875f, 0.03282413f, 0.17130788f, 0.07798100f, -0.25954780f, 0.09076574f, 0.14611951f, 0.10750063f, 
    0.07626129f, 0.25149766f, -0.10641465f, -0.02375720f, -0.08419481f, 0.10075600f, 0.03831522f, -0.04433781f, 
    -0.09341486f, 0.08523048f, -0.04829759f, -0.00620486f, 0.09430662f, 0.04012775f, -0.11694293f, 0.11117643f, 
    0.31054655f, 0.19771110f, 0.13471708f, -0.04099422f, 0.06414857f, 0.18524194f, -0.00363210f, 0.05786737f, 
    -0.00050161f, 0.11006133f, -0.02985359f, 0.00980097f, -0.06164871f, 0.02197321f, 0.09208672f, 0.08633698f, 
    -0.25332743f, 0.03903031f, 0.21439962f, 0.03710540f, 0.10249120f, 0.05352078f, 0.00432235f, -0.01281928f, 
    0.00107865f, -0.00332442f, 0.08121362f, -0.02488854f, -0.09844477f, 0.15803711f, -0.01361122f, 0.11129811f, 
    -0.17222914f, -0.05963576f, 0.08703162f, -0.09417598f, -0.01637638f, -0.18225282f, 0.03240675f, 0.12596920f, 
    -0.31950966f, -0.11449184f, 0.19462448f, -0.40541103f, -0.05229449f, 0.01799852f, 0.06795309f, 0.00767536f, 
    0.03445618f, -0.06016449f, 0.10400721f, 0.19461308f, 0.11251752f, 0.13887937f, 0.10249638f, -0.03020282f, 
    -0.12795082f, -0.03935146f, -0.04236889f, 0.07500885f, -0.15484892f, -0.07352860f, -0.03677835f, -0.05221707f, 
    -0.37364292f, 0.37419781f, -0.20553845f, 0.05026080f, 0.00250192f, -0.23255259f, 0.07144170f, -0.12035005f, 
    0.08932046f, 0.12994583f, -0.15284681f, 0.01370389f, -0.33891618f, 0.11706329f, -0.18606798f, 0.10846561f, 
    0.21561587f, -0.06010651f, 0.00533070f, -0.02911906f, 0.07352312f, -0.09165870f, 0.09293399f, 0.10285766f, 
    0.10696255f, -0.10734486f, 0.11286283f, 0.10456440f, 0.08460189f, -0.22452998f, 0.23319620f, 0.20427588f, 
    0.04652467f, 0.01023563f, 0.11365955f, -0.02925341f, 0.31012335f, 0.01403612f, -0.12056419f, 0.03146469f, 
    0.14100341f, 0.08221750f, -0.12082671f, 0.11880092f, 0.14074220f, -0.07280698f, 0.23317303f, -0.13311625f, 
    0.10002662f, -0.02105022f, -0.00920836f, 0.11221065f, 0.12527150f, 0.04643738f, -0.11769505f, -0.04227294f, 
    0.00782356f, -0.09850930f, 0.13194399f, -0.17616768f, 0.04814804f, 0.05173669f, -0.10624404f, 0.19292445f, 
    0.12165844f, 0.01758667f, -0.06151356f, -0.03288921f, 0.08929600f, -0.04073567f, -0.05433212f, 0.12952493f, 
    0.31126389f, -0.29579589f, -0.08291876f, 0.18590091f, 0.15252417f, 0.00684929f, -0.11743788f, 0.00702552f, 
    0.10367975f, -0.08646102f, -0.04627678f, 0.04196531f, 0.22502472f, -0.21703750f, -0.19551846f, 0.07628061f, 
    0.14626566f, 0.07623755f, -0.10317619f, 0.03571772f, 0.03573074f, -0.01464038f, 0.07359932f, -0.10895642f, 
    -0.19220082f, 0.11793981f, 0.13956165f, 0.01225144f, -0.09028492f, -0.09889241f, -0.07793628f, 0.02813476f, 
    0.04939298f, -0.07863346f, -0.08765335f, 0.04161217f, -0.57322526f, 0.17093511f, 0.12660295f, 0.24523973f, 
    -0.16174200f, -0.03476275f, 0.01231161f, 0.09600001f, -0.06547407f, 0.15286273f, -0.05941554f, -0.00400544f, 
    -0.09478724f, -0.22269326f, -0.00721970f, -0.07636841f, -0.18983208f, 0.02625011f, -0.04100875f, 0.09029192f, 
    -0.23918279f, 0.12289211f, -0.19167329f, 0.10311717f, -0.19456902f, -0.03051855f, -0.08986881f, -0.03843562f, 
    -0.11798719f, 0.17926647f, -0.08490446f, -0.03371840f, -0.01604050f, 0.10663179f, 0.01325971f, 0.04679427f, 
    0.18016192f, -0.05672958f, -0.05116886f, -0.11271413f, 0.14592779f, -0.04419978f, -0.12002051f, -0.01668227f, 
    0.09054322f, -0.05193035f, -0.08562439f, -0.03748691f, 0.53641379f, -0.21099542f, -0.05174982f, -0.03547403f, 
    0.16037759f, 0.08481111f, -0.06352095f, 0.15428312f, -0.06701436f, 0.01500808f, -0.04699190f, 0.01119147f, 
    -0.14061627f, 0.20090893f, -0.13322836f, 0.33263013f, -0.15496191f, 0.01374714f, 0.03379046f, -0.03951328f, 
    0.15363607f, -0.06214144f, 0.15646549f, -0.07925514f, -0.33603966f, -0.06397741f, 0.05795900f, -0.01899553f, 
    -0.05520828f, -0.06561118f, 0.02544748f, 0.21508873f, 0.22508705f, 0.14901358f, 0.09497976f, 0.15966640f, 
    0.27506718f, -0.11886033f, 0.10803556f, -0.37198272f, 0.16032410f, 0.22060138f, -0.01991306f, 0.01277150f, 
    0.02862873f, -0.15849149f, 0.09246293f, 0.01992124f, 0.03897312f, -0.11414450f, 0.00204443f, 0.02453802f, 
    0.00069195f, 0.07663326f, -0.12569205f, 0.02484183f, 0.04335196f, -0.08841876f, -0.10008729f, -0.07753577f, 
    0.08085149f, -0.01047370f, -0.00818698f, 0.01294184f, 0.08845131f, -0.03388415f, -0.07914070f, -0.05129841f, 
    0.09360041f, 0.02862610f, -0.17598501f, -0.12675506f, -0.17754586f, -0.18647210f, -0.14956746f, -0.10331911f, 
    0.12459457f, -0.03501498f, 0.23176934f, 0.00398754f, 0.10215311f, 0.06565611f, 0.03443485f, -0.08553024f, 
    0.00331548f, -0.06632449f, -0.01066201f, -0.09472877f, -0.11549232f, 0.06138554f, 0.02115311f, 0.08942142f, 
    -0.03070770f, 0.07790258f, 0.06417283f, -0.04793945f, 0.17307518f, -0.23942225f, -0.07939556f, -0.15464292f, 
    0.04437863f, -0.01566813f, 0.16020331f, -0.04536938f, 0.03663028f, -0.04455924f, -0.05407190f, 0.08251552f, 
    0.25812128f, 0.09513238f, -0.05407405f, 0.06906449f, 0.01754645f, -0.05568716f, 0.08119830f, -0.05106619f, 
    -0.07885846f, 0.01886303f, 0.11131430f, 0.19725253f, 0.14904146f, -0.04633053f, 0.10497618f, 0.10540532f, 
    0.10625950f, 0.07118347f, -0.00666989f, 0.00347442f, 0.04979275f, -0.12350787f, 0.04926486f, 0.08208928f, 
    0.18950047f, -0.15987886f, -0.00505329f, 0.04343810f, 0.07373527f, 0.09108935f, -0.00559360f, -0.01594169f, 
    0.03821721f, -0.07759438f, -0.03387608f, 0.15605569f, 0.21616936f, 0.23265852f, -0.09958722f, -0.31460702f, 
    0.01966321f, 0.00902734f, -0.04505238f, 0.10635075f, -0.07405837f, -0.17925625f, 0.12024003f, 0.12690160f, 
    0.01180033f, -0.33987367f, 0.20871618f, -0.09981469f, -0.02024714f, 0.06717503f, 0.02415220f, 0.07523047f, 
    -0.03007117f, 0.23371226f, -0.00202190f, 0.14947502f, -0.15858291f, 0.13939407f, -0.10281795f, -0.12206725f, 
    -0.06708860f, 0.06992503f, -0.10746380f, 0.02130759f, 0.09878755f, 0.18082680f, 0.06756259f, 0.13491265f, 
    0.11023268f, -0.15505448f, -0.06474335f, -0.22579212f, 0.09992561f, -0.10397711f, -0.11797610f, 0.14745802f, 
    0.10661036f, 0.05165670f, -0.10414498f, -0.13079965f, 0.37065867f, 0.02847500f, -0.07994349f, 0.03111824f, 
    0.11316764f, -0.07559435f, -0.15208058f, 0.13670681f, 0.12315588f, 0.01141308f, 0.02548384f, 0.13250747f, 
    0.17080306f, -0.11413101f, -0.06236508f, 0.21425553f, -0.09786440f, 0.01573006f, -0.06264178f, 0.04661397f, 
    0.02853991f, -0.09889611f, 0.30798638f, -0.14443417f, -0.34706286f, -0.06904783f, 0.18621910f, 0.05180972f, 
    -0.04055081f, 0.05937890f, 0.02446986f, 0.22755156f, 0.21571414f, 0.24963634f, 0.07676549f, 0.10819347f, 
    0.17400600f, 0.00766784f, 0.27104619f, -0.15488096f, -0.03551619f, 0.21348181f, -0.15133978f, 0.07579938f, 
    0.03876757f, -0.23279992f, 0.06555067f, 0.00883850f, -0.32070068f, -0.10148320f, -0.06030884f, 0.12508106f, 
    -0.03088588f, 0.08168881f, -0.16866170f, 0.12558660f, 0.09027102f, 0.03093293f, -0.08703075f, -0.14427342f, 
    0.30080077f, 0.00803682f, -0.13801260f, -0.05453020f, 0.00352352f, -0.04047412f, -0.14909704f, -0.16907392f, 
    0.12206026f, 0.00714829f, -0.12673621f, -0.12437102f, 0.24910933f, 0.00141315f, -0.12082565f, 0.04847453f, 
    0.09195994f, -0.03110549f, 0.17724119f, 0.13788706f, 0.15230346f, 0.09384856f, -0.04397633f, -0.14487052f, 
    0.07052513f, 0.08767372f, 0.00143117f, -0.06803657f, -0.09835479f, 0.04747692f, 0.14108363f, 0.05346844f, 
    -0.06101175f, 0.00815178f, 0.06143300f, -0.21698368f, -0.04358806f, -0.39620730f, -0.14750592f, -0.20839778f, 
    0.09152592f, -0.05505651f, 0.14808926f, -0.20997858f, 0.18093924f, 0.00500640f, -0.10409690f, 0.19448674f, 
    -0.15715386f, -0.31984723f, -0.05780011f, 0.34877956f, 0.16146693f, -0.02868542f, 0.05485986f, 0.03466057f, 
    -0.04717057f, 0.12659349f, 0.25302857f, -0.00025527f, -0.02500148f, -0.21825792f, 0.10492164f, 0.07095651f, 
    0.17956421f, 0.10584444f, -0.11476950f, -0.04612887f, 0.09089995f, -0.05416850f, 0.26214576f, 0.10515276f, 
    0.19879778f, -0.16020177f, 0.10864296f, -0.05723405f, -0.03358142f, -0.00965178f, -0.05484345f, 0.06729444f, 
    -0.05423184f, -0.18882844f, -0.13615166f, 0.28685841f, 0.01605790f, 0.22929856f, -0.08575204f, -0.02207191f, 
    0.03546384f, 0.05749437f, 0.00593927f, -0.05850103f, 0.00955186f, -0.07381786f, 0.09852418f, 0.14879103f, 
    0.15787455f, -0.13307646f, 0.06743348f, -0.07426722f, -0.14189401f, 0.01408522f, 0.16205329f, 0.20307977f, 
    -0.12992364f, 0.13091785f, 0.01917346f, -0.01652046f, -0.27043098f, 0.01771324f, 0.09956901f, -0.12939927f, 
    0.04840298f, 0.02711810f, -0.06595631f, 0.03141806f, 0.01825805f, 0.07225433f, 0.03836708f, 0.10695348f, 
    0.50136882f, -0.11119509f, -0.14231314f, -0.26054499f, 0.10478070f, -0.08636142f, -0.12241896f, 0.08766615f, 
    -0.02022979f, 0.10973310f, -0.01899139f, -0.00454831f, 0.08370285f, -0.04357778f, 0.07850959f, -0.09828573f, 
    -0.01227230f, -0.02371673f, -0.03279652f, 0.12926312f, 0.01543993f, 0.06818969f, 0.01667394f, -0.01689916f, 
    -0.26533151f, -0.03875286f, 0.01450649f, 0.15670370f, 0.04900571f, -0.10036739f, -0.09114631f, 0.05234434f, 
    -0.03952231f, -0.07506394f, 0.14630638f, -0.06934649f, -0.37606409f, -0.02837502f, 0.07377990f, -0.02272805f, 
    -0.01922039f, 0.00735497f, -0.07282656f, 0.14918485f, 0.18551406f, 0.12385311f, 0.05738658f, 0.08702446f, 
    0.17403921f, -0.08005609f, 0.15965147f, -0.37417260f, 0.06114192f, 0.16696729f, -0.05926382f, 0.05370675f, 
    0.00683958f, -0.13594580f, 0.00112616f, 0.00416684f, 0.18144064f, 0.07585190f, 0.11820193f, 0.22270750f, 
    -0.10488548f, 0.05886111f, -0.11699611f, 0.06225247f, -0.01403758f, 0.01225501f, -0.10902674f, -0.17913085f, 
    0.23572654f, 0.20716636f, -0.03817499f, 0.11272143f, 0.13578653f, 0.05807412f, -0.16885237f, -0.10393921f, 
    -0.05751583f, 0.05142214f, -0.17652360f, -0.18646972f, 0.03143943f, 0.03836177f, -0.19185247f, 0.05972409f, 
    -0.03822223f, -0.09565504f, 0.14532349f, 0.07385440f, 0.09569000f, -0.05983853f, 0.05203237f, 0.05263229f, 
    -0.00886344f, 0.06744677f, -0.18018831f, -0.15512396f, -0.12770681f, 0.24295788f, 0.07807657f, 0.03977782f, 
    0.03764559f, -0.01096881f, 0.22597557f, -0.02497354f, 0.13346483f, -0.26100406f, 0.05326326f, 0.12944338f, 
    0.09965543f, -0.03473454f, 0.04318524f, -0.08474271f, -0.01447190f, 0.02027899f, -0.13956989f, 0.04692400f, 
    0.12473353f, -0.15072897f, -0.23915738f, 0.40881801f, -0.05156603f, -0.09161045f, 0.05999284f, 0.04795174f, 
    -0.12144122f, 0.09492484f, 0.11244390f, 0.04708562f, 0.38899893f, -0.07120871f, 0.27371463f, 0.29413673f, 
    0.16623065f, 0.07914635f, -0.01930650f, -0.02304775f, 0.01154116f, -0.15173796f, 0.11846863f, 0.02019497f, 
    0.04559146f, -0.00817010f, -0.01716758f, 0.05968994f, -0.05415898f, 0.03179554f, 0.00754681f, 0.02356494f, 
    -0.03830085f, 0.01064931f, -0.05952724f, 0.18810764f, 0.07256662f, 0.09516347f, -0.18189518f, -0.03473652f, 
    0.02874436f, -0.00935075f, -0.06169705f, -0.04846877f, -0.10405155f, -0.06630632f, 0.00565399f, 0.07212876f, 
    0.54165137f, 0.57040083f, 0.10137984f, 0.27453196f, -0.14523433f, -0.08671187f, -0.15909165f, -0.13251306f, 
    -0.20982382f, 0.02738521f, -0.09029712f, -0.15200587f, -0.11631314f, 0.13338850f, 0.14208707f, 0.02924629f, 
    -0.09174965f, 0.06578378f, -0.01107410f, -0.09332667f, 0.05392944f, 0.03249471f, -0.00205198f, -0.04180652f, 
    0.10314216f, 0.01114917f, -0.20996083f, 0.15019010f, -0.03362716f, -0.09982198f, 0.12187901f, 0.02992652f, 
    0.04018939f, 0.01333704f, -0.03176134f, 0.03920712f, -0.10383603f, 0.23806624f, -0.19108906f, 0.04080426f, 
    -0.00433289f, 0.13724101f, 0.19585684f, -0.04883122f, -0.15531386f, 0.05702242f, -0.05894299f, -0.04106431f, 
    0.24581096f, 0.16227785f, 0.13630864f, 0.19767770f, 0.11466432f, 0.05830506f, -0.01857303f, 0.05253270f, 
    -0.25178054f, -0.04354657f, -0.16488132f, -0.01375091f, 0.06941479f, 0.04858651f, 0.02344698f, 0.05988151f, 
    0.05918787f, -0.20215572f, -0.15863328f, 0.01004257f, -0.06292130f, -0.14529538f, 0.15133792f, -0.13119508f, 
    0.23662269f, -0.04128044f, 0.26574007f, 0.33754516f, 0.03315770f, 0.13523452f, -0.00828214f, 0.08662260f, 
    -0.00909705f, 0.10938819f, 0.01423255f, 0.06546027f, -0.54228193f, -0.09505565f, 0.04770526f, -0.23384696f, 
    0.06773704f, -0.16441900f, 0.02442528f, 0.00387624f, 0.00562335f, -0.03092918f, -0.15346541f, -0.05600784f, 
    -0.24692626f, -0.08255394f, 0.02415406f, -0.02674418f, 0.00450244f, 0.16496772f, -0.00688016f, 0.00661629f, 
    0.17753497f, 0.06442102f, 0.04640245f, -0.03223524f, -0.29028067f, 0.04574746f, -0.03599207f, 0.04526380f, 
    -0.06774839f, -0.14926223f, 0.09057581f, 0.05671227f, -0.04845950f, -0.04703917f, 0.19755521f, 0.01082318f, 
    -0.12452736f, 0.13289836f, -0.15354173f, 0.29822072f, 0.06337410f, 0.09055115f, 0.02960812f, 0.01003425f, 
    0.18889515f, -0.15143293f, -0.08830649f, 0.01272111f, 0.15458548f, 0.21069810f, -0.19539703f, 0.06729524f, 
    -0.11120077f, -0.07380337f, -0.22382736f, -0.08926181f, -0.10518637f, -0.11373681f, -0.05799117f, -0.05000467f, 
    0.21075870f, -0.06365703f, 0.05263257f, 0.06664314f, -0.02044773f, 0.04397210f, -0.13210884f, 0.07823672f, 
    -0.01142156f, -0.21644354f, -0.08277666f, 0.07966927f, 0.20610332f, -0.18477882f, -0.21252847f, -0.03393244f, 
    -0.06951996f, -0.01365756f, 0.01872578f, -0.00649165f, -0.01326495f, -0.10427061f, 0.00463219f, -0.10909985f, 
    0.13412288f, 0.39171296f, 0.10821714f, 0.45212120f, 0.20217003f, 0.26834276f, 0.14674778f, 0.26647973f, 
    0.05515500f, 0.07850115f, 0.02080079f, -0.16057512f, -0.17152877f, -0.16517884f, 0.14362828f, -0.00124700f, 
    -0.16543809f, -0.07973139f, -0.07175039f, 0.22327018f, -0.07617775f, -0.13154618f, -0.01422992f, 0.08067388f, 
    0.05196657f, -0.03603652f, -0.06709230f, 0.02512545f, -0.06295609f, 0.00185827f, -0.08132791f, -0.05743112f, 
    0.02594341f, -0.02444441f, 0.04251610f, -0.06654691f, -0.04394045f, -0.01066953f, 0.01765651f, -0.03610905f, 
    -0.03710650f, 0.00720724f, 0.04869983f, -0.06517132f, -0.03762492f, 0.05965485f, -0.05504281f, -0.00952773f, 
    -0.02519242f, -0.01215704f, -0.05676126f, 0.00380229f, -0.06040374f, -0.01700097f, 0.04342012f, -0.05044078f, 
    -0.06922821f, -0.06374933f, 0.04591702f, 0.00946980f, -0.00060969f, -0.02039786f, -0.01123241f, 0.02852048f, 
    -0.00502683f, 0.01606473f, -0.02993902f, -0.05586550f, -0.05165656f, -0.05024325f, 0.02977607f, -0.03276529f, 
    0.04953775f, 0.02408720f, -0.04439368f, 0.01721206f, -0.04331847f, -0.00884147f, 0.02237303f, -0.05835194f, 
    0.00443005f, 0.02728650f, -0.06551725f, 0.02334052f, -0.00719096f, -0.02347003f, 0.04113597f, -0.03168938f, 
    0.01906550f, 0.03568669f, -0.00840789f, -0.00088930f, 0.01801933f, -0.03723979f, -0.06271919f, 0.00679797f, 
    -0.01058453f, 0.04208259f, 0.02587507f, -0.02963946f, 0.02292428f, -0.06685792f, 0.06573232f, -0.01867068f, 
    0.01340299f, 0.01884106f, -0.03413008f, 0.05105002f, 0.01629100f, 0.00674481f, -0.06967777f, 0.06209153f, 
    0.05984388f, 0.03393823f, -0.01958116f, 0.02865691f, 0.02065049f, 0.02545110f, 0.05202024f, -0.00624435f, 
    -0.00862539f, -0.07086018f, -0.04607347f, -0.07554914f, -0.02827738f, 0.02301284f, -0.05808623f, 0.04061914f, 
    0.05646716f, -0.03674308f, -0.05809730f, -0.05545292f, -0.02427352f, -0.05401492f, 0.01285373f, 0.04187226f, 
    -0.03559099f, -0.04761049f, 0.04448384f, -0.07754994f, -0.03862275f, -0.05803097f, -0.02699826f, -0.06659166f, 
    -0.07843567f, -0.02654067f, -0.00535023f, 0.06419700f, -0.04315223f, 0.01236723f, -0.06648286f, -0.05426628f, 
    -0.07437807f, -0.01679736f, 0.06266608f, -0.02141215f, -0.05819952f, 0.01711799f, -0.00163427f, 0.06673698f, 
    -0.05435864f, -0.04089557f, -0.06554744f, -0.00406587f, -0.07175405f, 0.02041997f, 0.04819620f, -0.02303030f, 
    0.01840341f, 0.00730150f, 0.04170919f, 0.05729488f, 0.00716690f, 0.01846320f, 0.03992237f, -0.07042821f, 
    0.06356514f, 0.04254787f, 0.02832042f, 0.05472530f, -0.04599097f, -0.06523698f, 0.02534808f, 0.02905126f, 
    -0.02498903f, -0.05156719f, -0.06884173f, -0.04834465f, -0.05389523f, -0.03211413f, -0.01719343f, -0.07401052f, 
    0.05158095f, -0.03905557f, -0.02453213f, 0.06156980f, 0.03352673f, -0.04291549f, 0.04668711f, 0.06084399f, 
    -0.01407514f, 0.04723459f, 0.04700384f, -0.03305015f, 0.05902116f, -0.04902916f, -0.07074037f, 0.03021112f, 
    0.03853110f, 0.04818284f, 0.02068123f, 0.01489157f, -0.07690574f, -0.01863546f, 0.00822233f, 0.03478793f, 
    0.28073436f, -0.05227241f, 0.25237659f, 0.03362113f, -0.09677793f, 0.01123498f, -0.00095008f, -0.06268282f, 
    -0.12073179f, 0.15120673f, -0.04303766f, -0.04938285f, -0.24343626f, 0.25063103f, 0.00752272f, -0.06328449f, 
    0.05771739f, 0.08155253f, -0.04189035f, -0.00245996f, 0.10291779f, 0.24308147f, 0.11422497f, 0.13395530f, 
    -0.10434121f, -0.02576048f, 0.09918448f, -0.10631044f, 0.03030320f, -0.09331998f, -0.09733843f, -0.07824892f, 
    0.02068386f, -0.07004142f, -0.06219741f, -0.04557787f, -0.00579014f, 0.21655160f, -0.22920643f, -0.00773453f, 
    0.12181203f, -0.00437350f, -0.10375360f, 0.00336203f, 0.07892212f, -0.03926096f, 0.02097742f, 0.00263622f, 
    0.24850745f, -0.00362820f, -0.03999532f, 0.07551109f, 0.08181891f, -0.02239228f, -0.11308850f, 0.05249063f, 
    -0.19419910f, -0.04001860f, 0.04677591f, 0.11199987f, -0.15638459f, 0.06288113f, -0.05512483f, -0.04811618f, 
    0.05178628f, -0.07719049f, 0.01091897f, 0.08320887f, 0.28651562f, 0.08064979f, 0.08899521f, 0.18055727f, 
    0.09110772f, -0.38545585f, 0.26217854f, -0.11293140f, -0.06761927f, 0.10457628f, -0.16737357f, 0.11537685f, 
    0.07775699f, -0.21204993f, 0.04051128f, -0.07753178f, -0.50147408f, -0.01904020f, 0.12514317f, 0.01299448f, 
    -0.08437165f, -0.06792843f, -0.01234810f, 0.06987042f, 0.07931195f, 0.01609017f, -0.00610497f, 0.00950394f, 
    -0.05245201f, -0.05237293f, -0.18665597f, -0.08545351f, 0.14157809f, -0.02664659f, -0.16268499f, -0.27170438f, 
    0.10052270f, -0.02889355f, 0.01052795f, -0.11036287f, 0.23777647f, -0.05387094f, 0.09891822f, 0.15345699f, 
    -0.00151956f, -0.01901842f, 0.22800961f, 0.20417044f, 0.01153565f, -0.11968413f, 0.13971008f, -0.08689073f, 
    -0.14930601f, -0.05594132f, -0.30127120f, -0.11445999f, 0.06421203f, 0.04955628f, 0.04720069f, 0.09437706f, 
    0.05079389f, -0.09961046f, 0.04824877f, -0.12793191f, -0.00142474f, -0.12156609f, -0.05117080f, 0.05494718f, 
    -0.05737626f, 0.02442214f, 0.03967002f, -0.21250841f, 0.05775461f, -0.06414840f, -0.16463174f, 0.14233355f, 
    -0.17435487f, -0.12358689f, 0.18764469f, 0.32928997f, 0.18259944f, 0.07839581f, -0.01269960f, -0.03962941f, 
    0.01784417f, 0.05459008f, 0.22150120f, 0.14726776f, 0.00586109f, -0.12690084f, 0.00540136f, -0.00779334f, 
    0.07853119f, 0.03359319f, -0.08907101f, -0.12414154f, 0.06906333f, -0.05184443f, 0.15301076f, 0.14566654f, 
    -0.00663852f, -0.21016379f, -0.08574545f, 0.07207499f, 0.08873192f, 0.11749111f, -0.02282288f, 0.23223469f, 
    -0.02108791f, -0.03700779f, -0.15264578f, 0.18544117f, -0.13705212f, 0.28036806f, 0.00719381f, -0.00744351f, 
    -0.05277700f, 0.13456988f, 0.00340363f, 0.17165886f, 0.02717907f, -0.03660779f, 0.12400671f, 0.14885254f, 
    -0.14675860f, -0.29800159f, -0.01176870f, 0.10625986f, 0.17445759f, 0.02892977f, -0.02615367f, -0.06944782f, 
    0.03931541f, -0.06642150f, 0.05171787f, 0.08222061f, -0.18692398f, -0.25716868f, 0.16370818f, 0.14242458f, 
    0.01498851f, -0.11227408f, 0.21345934f, 0.02391604f, 0.01363102f, 0.03484473f, 0.11811181f, -0.09237639f, 
    0.13419095f, 0.12781236f, -0.02171797f, 0.07414867f, -0.04126887f, 0.16423486f, -0.00984786f, -0.06347319f, 
    0.07067703f, -0.00038050f, 0.05967028f, 0.09146070f, -0.12645830f, 0.27017021f, -0.13303939f, -0.04572513f, 
    0.23746431f, -0.02516706f, 0.02335987f, 0.01263174f, 0.15722641f, 0.01020977f, 0.08682325f, 0.07722151f, 
    -0.46987841f, 0.01413343f, 0.00733985f, 0.08496643f, 0.16223224f, -0.03623120f, 0.03680900f, -0.03713343f, 
    -0.00472404f, 0.02819929f, -0.04962125f, -0.01723302f, 0.34089234f, -0.05739459f, -0.07046814f, -0.07608820f, 
    0.12071787f, -0.02520464f, 0.20812893f, -0.01625901f, 0.03364307f, 0.01024840f, -0.04097216f, 0.07037458f, 
    -0.17615905f, -0.07433420f, -0.21539786f, -0.19320515f, -0.01664608f, 0.11502530f, 0.06219815f, -0.02614397f, 
    0.19218320f, -0.11184307f, -0.00950116f, -0.07760245f, -0.00444713f, -0.00244770f, 0.08519959f, -0.03344347f, 
    -0.23061936f, -0.11846472f, -0.00051531f, 0.03650646f, 0.10594280f, 0.08383934f, 0.00157099f, 0.11213338f, 
    -0.26360250f, 0.11662667f, -0.06922282f, 0.01550987f, -0.01777410f, 0.11548563f, 0.01337660f, -0.06082065f, 
    -0.05962053f, -0.19207107f, -0.02125068f, 0.09716760f, 0.10570151f, 0.01748193f, 0.38982397f, 0.14721225f, 
    -0.24404138f, 0.06159992f, 0.14617243f, -0.10980320f, 0.04769461f, -0.06120711f, 0.00146702f, 0.11999968f, 
    -0.23198946f, -0.28396887f, -0.10245415f, -0.11087503f, 0.17291132f, 0.03491867f, 0.09157852f, 0.00366734f, 
    0.09428804f, 0.14382014f, 0.11127905f, 0.10202164f, -0.15207121f, 0.04148146f, 0.29693219f, 0.13115062f, 
    -0.15007079f, 0.09082615f, 0.08044571f, 0.10543235f, 0.02042147f, 0.03540557f, 0.00157304f, -0.02873870f, 
    -0.09094347f, 0.45204851f, 0.32123670f, -0.05457096f, -0.11245877f, -0.15364492f, -0.02397540f, 0.10456192f, 
    -0.07581181f, 0.03647914f, 0.04418951f, 0.05232705f, -0.06525397f, 0.19286342f, 0.12952460f, -0.03878227f, 
    -0.16394690f, 0.06056048f, -0.03986108f, 0.08230432f, 0.10876448f, 0.12451699f, 0.01453944f, -0.01309730f, 
    -0.57884371f, 0.10387931f, -0.28387135f, -0.10619987f, 0.17496072f, 0.00688724f, -0.03895997f, 0.03211081f, 
    -0.00724404f, 0.04633421f, 0.00912067f, 0.01513937f, -0.10905828f, -0.02126365f, 0.11751951f, -0.01079611f, 
    0.00058136f, 0.01980909f, 0.02353126f, -0.02836643f, 0.00981039f, 0.01670772f, 0.18438028f, -0.01274006f, 
    -0.02992423f, -0.10596055f, 0.13301504f, 0.09349669f, 0.02677719f, 0.03264768f, 0.00409656f, 0.10696600f, 
    0.13671617f, 0.02597404f, 0.02661215f, -0.10418944f, -0.55757135f, 0.19841607f, -0.06749677f, 0.09442363f, 
    0.00643065f, 0.13039681f, 0.06901773f, 0.04214681f, 0.01177420f, 0.17509109f, 0.01780670f, -0.10288174f, 
    0.39074281f, -0.08152702f, -0.26333681f, 0.01614828f, 0.01440732f, 0.02034100f, 0.01365929f, 0.03412218f, 
    -0.05574707f, 0.08339745f, -0.00243730f, -0.03293111f, -0.11787482f, -0.01365245f, -0.18755482f, -0.17546858f, 
    0.04916061f, 0.02360605f, 0.00372851f, 0.02234943f, -0.06835210f, -0.03220493f, 0.03581643f, 0.03526758f, 
    -0.76425332f, -0.03186052f, 0.10613398f, 0.05541673f, 0.02300620f, 0.00055142f, -0.05074793f, -0.03573843f, 
    0.03316754f, 0.04502298f, 0.17593040f, 0.02941049f, -0.59582084f, 0.01703058f, 0.02097913f, 0.03499727f, 
    0.01951839f, -0.06776799f, -0.08237645f, -0.00409469f, 0.07554509f, -0.01538834f, -0.13401017f, 0.09645822f, 
    -0.16622345f, -0.24322370f, -0.11587066f, -0.02478653f, 0.10311533f, -0.04106779f, 0.07415880f, -0.14820257f, 
    0.11777999f, -0.13401166f, 0.11063939f, -0.11786766f, 0.38170221f, 0.24351069f, 0.12905186f, -0.22240421f, 
    -0.08816674f, -0.10835692f, -0.01213626f, 0.10686186f, 0.08921389f, -0.09706564f, -0.00308362f, -0.00643873f, 
    -0.11922751f, -0.19942798f, -0.13926347f, -0.27939284f, 0.02546625f, 0.08013079f, -0.01316279f, -0.14621642f, 
    -0.05646306f, -0.20989756f, 0.01693029f, -0.01771219f, 0.12415186f, 0.15458836f, 0.45753321f, 0.33160168f, 
    -0.08210517f, -0.04814032f, 0.01623124f, 0.04964236f, 0.11128686f, -0.03695745f, 0.01738174f, 0.12364151f, 
    -0.01706738f, -0.27347729f, -0.41382921f, -0.24646385f, -0.04520281f, 0.22287890f, -0.00280965f, -0.00095387f, 
    -0.00633503f, 0.14084783f, 0.27384645f, -0.09083407f, 0.04552254f, 0.02456453f, 0.00321626f, 0.00268938f, 
    0.18359815f, -0.07755381f, 0.14114985f, -0.03929751f, 0.06421944f, -0.00172506f, 0.08924449f, -0.05949127f, 
    0.33505648f, 0.40196460f, 0.13396484f, 0.26873997f, 0.08550012f, -0.24071376f, -0.11355089f, 0.02097080f, 
    0.10790715f, -0.03484893f, 0.08015762f, 0.10922311f, 0.08713268f, -0.15976556f, 0.28970808f, 0.05123135f, 
    0.01495202f, 0.19598599f, 0.01867031f, -0.03599793f, 0.04394895f, 0.15446584f, 0.03757082f, 0.06559808f, 
    -0.24996853f, 0.24917087f, -0.11669078f, 0.01800706f, 0.24742121f, 0.17197369f, 0.02838853f, -0.04721382f, 
    0.03138649f, 0.10817760f, 0.03137348f, -0.07046698f, -0.15932633f, 0.27899712f, 0.01503934f, -0.17671081f, 
    -0.09133093f, 0.04602569f, -0.06440630f, 0.04611776f, -0.01721430f, -0.00592694f, 0.01802223f, -0.11937115f, 
    -0.37692028f, 0.16784222f, -0.15590058f, -0.18553124f, -0.01998332f, -0.01494573f, 0.04394570f, 0.00070433f, 
    0.04818129f, 0.07908690f, -0.01082634f, 0.03345721f, 0.08295624f, -0.22155701f, -0.05148277f, 0.15861697f, 
    -0.14785554f, 0.10518879f, -0.07014271f, -0.12821074f, 0.00444261f, -0.06066119f, 0.02250588f, 0.11494622f, 
    0.29908347f, 0.03511393f, -0.20057794f, -0.04651139f, -0.09840328f, 0.11819791f, -0.00421443f, 0.08312148f, 
    -0.02376637f, 0.02877865f, 0.02518470f, -0.04312900f, 0.33868101f, -0.33243456f, -0.09393887f, -0.00507431f, 
    0.00569727f, 0.02005170f, 0.03480209f, 0.21766029f, 0.01232923f, -0.07617617f, 0.01298227f, 0.03711505f, 
    0.01491400f, -0.39485034f, -0.10260715f, -0.04310513f, -0.09683695f, -0.19650970f, 0.14248426f, -0.15067971f, 
    0.15398797f, 0.12284874f, 0.08561147f, -0.11439817f, -0.39943352f, -0.06793284f, 0.01740382f, 0.16158804f, 
    -0.14054434f, -0.05501650f, -0.06446769f, 0.05664835f, -0.19529685f, 0.07457769f, 0.10973129f, 0.13072129f, 
    -0.06138522f, 0.25306064f, -0.10271151f, 0.05571837f, 0.00919856f, -0.00802569f, -0.01959672f, 0.16649945f, 
    0.19961928f, -0.02699579f, 0.12325514f, 0.08495419f, 0.35058212f, 0.18246412f, 0.13785166f, -0.26675037f, 
    0.28662780f, 0.10096192f, -0.03989262f, 0.00531451f, 0.01353997f, 0.01237408f, 0.01031487f, -0.09934893f, 
    -0.06336471f, -0.22354792f, -0.02747845f, -0.07358457f, 0.15033817f, -0.02087262f, -0.12682217f, 0.29160836f, 
    0.06659002f, 0.07687243f, -0.00784499f, -0.05420977f, -0.13102612f, -0.13759032f, -0.06640414f, -0.02622575f, 
    0.07079455f, -0.04404290f, -0.14863126f, 0.00562135f, -0.00078764f, -0.01782629f, -0.01136588f, -0.01614038f, 
    -0.37039474f, 0.01909017f, 0.10177218f, -0.08252603f, -0.02227385f, 0.22436368f, -0.08799033f, 0.00059416f, 
    -0.03090399f, 0.02934292f, -0.16751222f, -0.06051929f, -0.30369326f, 0.31041399f, -0.22666715f, -0.16024278f, 
    0.18632653f, 0.04917101f, -0.06316338f, -0.25433916f, 0.08812367f, 0.04251860f, 0.08828435f, 0.02748434f, 
    0.69042891f, 0.00542161f, -0.21304062f, 0.02651824f, 0.14320743f, 0.19679625f, 0.00488685f, -0.05513864f, 
    -0.12145194f, 0.17652774f, 0.09408231f, 0.06112336f, 0.07193466f, 0.21961795f, 0.25244522f, 0.14635153f, 
    0.15994556f, -0.04436725f, 0.02759559f, -0.08162472f, 0.08469702f, 0.10237664f, 0.07905886f, 0.07209812f, 
    0.05014584f, -0.23994304f, 0.09368171f, 0.02316536f, -0.05761563f, 0.08700915f, -0.09825169f, -0.03958104f, 
    0.00352118f, 0.04329398f, -0.00475131f, 0.05638750f, 0.32192683f, 0.02414639f, 0.18993129f, -0.20872046f, 
    0.05464235f, 0.06968305f, -0.08247794f, -0.14847760f, 0.09234962f, -0.04338050f, 0.07991188f, 0.02268030f, 
    0.05422250f, 0.02201512f, -0.03411799f, 0.04224146f, 0.04340314f, 0.04452111f, -0.07524358f, 0.05091206f, 
    -0.01646440f, -0.05094244f, -0.01909970f, -0.01403981f, -0.04305523f, -0.03546692f, 0.02049973f, -0.08362573f, 
    0.02605118f, -0.06873431f, -0.03816486f, -0.00346475f, -0.03931826f, -0.06582650f, 0.01966997f, 0.01143463f, 
    -0.06001224f, -0.02677249f, -0.04969638f, -0.03929903f, 0.02604251f, -0.05100079f, 0.02007923f, 0.00619814f, 
    -0.03128549f, 0.00349259f, 0.02368384f, -0.03256422f, 0.01632542f, -0.07764571f, -0.01997004f, 0.01891368f, 
    0.01986018f, -0.06514840f, -0.04949266f, 0.02129057f, 0.01248314f, 0.03168774f, 0.03716788f, 0.04871320f, 
    0.05045633f, -0.03562857f, 0.00350743f, -0.05197160f, 0.05482510f, -0.00282849f, 0.04415336f, -0.05835827f, 
    -0.07056639f, -0.07104222f, 0.03786466f, 0.02405485f, 0.03683028f, -0.08078007f, 0.03405172f, -0.02228772f, 
    -0.06314990f, -0.03977090f, 0.00503413f, -0.06611969f, 0.01639301f, -0.04873100f, -0.02545124f, 0.03524652f, 
    -0.01309386f, -0.05079944f, -0.05212831f, -0.02560161f, 0.03831540f, -0.01197068f, 0.05111775f, -0.00372355f, 
    0.06175688f, -0.06961461f, -0.05568703f, -0.02466494f, -0.01484020f, -0.05572678f, -0.01538369f, -0.06418332f, 
    0.03371253f, -0.03533230f, 0.05072684f, -0.02959857f, -0.03141346f, 0.02687969f, -0.02007228f, 0.03762385f, 
    -0.06519081f, -0.00744347f, -0.04006876f, 0.02535200f, 0.03050721f, -0.00536283f, 0.03020761f, 0.02544044f, 
    0.06989665f, -0.07105161f, 0.04439148f, 0.06536616f, -0.00174063f, -0.07503969f, 0.02959205f, -0.03593552f, 
    0.04748593f, -0.05209083f, -0.06528028f, -0.03370408f, -0.01154412f, 0.02985638f, 0.02329335f, 0.00437920f, 
    -0.07121132f, -0.04744673f, 0.01550573f, 0.01278178f, 0.06236045f, 0.01322560f, -0.06768742f, -0.03905658f, 
    0.05210627f, -0.04664360f, 0.05769290f, -0.00160133f, 0.05084578f, 0.02064523f, 0.00590673f, 0.06887832f, 
    -0.04821494f, -0.07540243f, -0.06599604f, 0.06164969f, -0.02084190f, 0.00625752f, 0.04563599f, -0.05020567f, 
    -0.01817588f, 0.02055690f, -0.04176662f, -0.03739366f, -0.00523647f, -0.02007065f, -0.06123531f, 0.00303607f, 
    0.04374167f, -0.03157075f, -0.04815251f, 0.05256532f, 0.05314256f, -0.00368775f, 0.00715156f, -0.07204358f, 
    -0.00496661f, 0.02946926f, -0.00214929f, 0.00958202f, -0.02281759f, -0.04043104f, -0.05459504f, 0.03194083f, 
    -0.06047199f, 0.00849395f, 0.05053544f, 0.02514267f, -0.01489153f, 0.00249394f, -0.00964703f, 0.04294401f, 
    -0.05848441f, 0.04751501f, -0.06323918f, -0.01369688f, -0.03689745f, -0.00968105f, -0.06343488f, -0.03298981f, 
    -0.06616762f, 0.05165080f, -0.02736645f, 0.01679255f, 0.03368802f, -0.01519102f, -0.00196897f, 0.06323265f, 
    -0.01985075f, -0.05064878f, -0.03309440f, -0.03421931f, -0.03234012f, -0.06613228f, -0.02584691f, -0.01775264f, 
    -0.03805910f, 0.05978880f, -0.02789879f, -0.02582177f, -0.01426210f, -0.05835436f, 0.03348536f, -0.00217743f, 
    0.02018658f, -0.06651920f, -0.04064895f, -0.01932720f, -0.04019550f, -0.01345366f, -0.04885607f, -0.06858392f, 
    0.00229053f, -0.00766693f, 0.06082125f, 0.00918213f, -0.02159281f, -0.05249149f, -0.02609683f, -0.02916411f, 
    0.02815292f, 0.02630909f, -0.07485805f, -0.00818958f, 0.02283411f, -0.02749474f, -0.05837223f, -0.00193365f, 
    -0.06211876f, -0.03957533f, 0.00642009f, -0.03382355f, -0.00461854f, 0.01086687f, -0.05608405f, -0.04006879f, 
    0.06347383f, 0.04243906f, 0.05110314f, -0.00026855f, 0.02319291f, -0.04213791f, -0.06037333f, -0.03004481f, 
    0.01995237f, 0.02670959f, -0.03416080f, -0.02957547f, -0.00530363f, -0.03508972f, 0.01334101f, -0.03595954f, 
    0.05012555f, -0.07389934f, 0.02550231f, -0.03351875f, -0.00561859f, 0.01977875f, 0.06354654f, -0.00882302f, 
    0.00015939f, -0.05614218f, -0.04509180f, -0.00286928f, 0.05178861f, -0.06615285f, 0.03377408f, 0.04963570f, 
    -0.00813707f, 0.03247283f, 0.02409829f, 0.01840475f, -0.05375428f, -0.05139717f, 0.05674192f, 0.05039376f, 
    0.03326101f, -0.03429743f, -0.07626466f, -0.03588383f, -0.02544686f, -0.01566660f, -0.00020690f, -0.00741074f, 
    0.06575181f, 0.05909994f, -0.06585810f, -0.04486441f, -0.04050953f, 0.02921090f, -0.06094765f, -0.03398970f, 
    -0.05422148f, -0.03063379f, -0.00636465f, -0.05242659f, 0.06488091f, 0.06405041f, -0.04399330f, 0.06063480f, 
    -0.04643957f, 0.01304485f, 0.05463495f, -0.07663766f, 0.00536514f, 0.04226837f, -0.04784579f, -0.03681061f, 
    0.01236528f, 0.05752552f, 0.06308539f, -0.04114967f, -0.03013031f, -0.05371403f, 0.02089360f, 0.05982054f, 
    0.04458225f, -0.01390253f, -0.02463539f, -0.01442750f, -0.06197862f, -0.00265239f, 0.01241167f, -0.03712948f, 
    0.05589169f, 0.00847455f, -0.04012927f, -0.02253608f, 0.03633188f, -0.06513169f, -0.05928004f, -0.05565228f, 
    0.04789748f, -0.03814016f, -0.06038447f, -0.03942255f, -0.01831090f, 0.03222112f, 0.04316919f, -0.01331386f, 
    -0.00810179f, -0.06003091f, -0.06389859f, 0.04451156f, 0.00750947f, 0.04120719f, -0.02199071f, -0.06150262f, 
    -0.00805875f, -0.05690131f, -0.07814889f, 0.01139322f, -0.03542617f, 0.00749284f, 0.05823816f, -0.07307801f, 
    0.01043716f, 0.05256873f, 0.06221044f, 0.06404197f, -0.00034000f, 0.04372049f, 0.01382389f, -0.06952067f, 
    0.00879374f, -0.02232071f, 0.06339982f, 0.00052369f, 0.01018774f, 0.03324109f, 0.02159834f, -0.05750106f, 
    0.02709598f, 0.02449868f, -0.07168826f, 0.04007513f, -0.04943271f, -0.05067029f, 0.03549307f, -0.05425439f, 
    -0.33638963f, 0.07803387f, -0.18407083f, 0.04589636f, 0.16054232f, 0.05178064f, -0.18875778f, -0.12256709f, 
    0.11307699f, -0.00473265f, 0.03575852f, 0.01784586f, 0.11311337f, -0.14314131f, -0.20271789f, -0.00794424f, 
    0.01702761f, -0.00031151f, 0.05337826f, -0.14540069f, -0.06826553f, -0.00712148f, -0.09034993f, -0.08398452f, 
    -0.31428829f, 0.19499531f, 0.15467049f, 0.31867805f, -0.00901837f, -0.07742526f, 0.13730533f, -0.08653425f, 
    0.05533441f, -0.12913013f, 0.07656173f, 0.08833212f, 0.19063939f, -0.03979528f, -0.00105012f, 0.12103384f, 
    0.07767378f, -0.08499624f, 0.16046287f, 0.06191292f, -0.01121086f, -0.07028350f, 0.00312036f, -0.04909183f, 
    0.04547343f, 0.08842581f, -0.15020107f, -0.16891719f, -0.06419801f, 0.05307332f, 0.10528499f, 0.07404476f, 
    0.07331459f, 0.04242884f, -0.13701876f, 0.16950941f, -0.06955528f, -0.00807451f, -0.08781638f, 0.06684671f, 
    0.04432392f, -0.12367339f, 0.03790222f, -0.15893912f, -0.02137351f, -0.10678454f, -0.00836907f, -0.06144986f, 
    -0.08369227f, -0.04070589f, -0.24655706f, 0.37096512f, -0.08093255f, -0.12522529f, 0.10952714f, 0.07011193f, 
    0.05519605f, -0.08248097f, 0.08291420f, 0.08652387f, 0.13859707f, 0.11140551f, 0.12737495f, -0.22894524f, 
    0.20772691f, 0.06730269f, 0.02617199f, 0.07053344f, 0.06014653f, 0.07156041f, 0.16267845f, -0.04215661f, 
    -0.11944278f, -0.22756371f, 0.10067999f, -0.06609014f, 0.05446448f, -0.03261985f, 0.16754350f, 0.36625323f, 
    0.08954987f, -0.05406211f, 0.21036285f, 0.24311696f, -0.23002928f, -0.10726452f, 0.19206186f, -0.15337256f, 
    0.12713592f, 0.13547216f, 0.00478366f, 0.00188170f, -0.01407234f, 0.04709244f, 0.06613548f, 0.12442659f, 
    -0.05689409f, -0.04216547f, 0.10558932f, 0.13528536f, 0.02243829f, -0.16671009f, -0.02699894f, 0.11589085f, 
    -0.06403211f, 0.02423060f, -0.21400069f, 0.11640516f, -0.10979138f, 0.20175518f, 0.00582907f, -0.27175915f, 
    0.11134467f, -0.05748863f, 0.15382946f, -0.10710110f, 0.02779013f, 0.03718330f, 0.16366075f, -0.04382139f, 
    -0.22994484f, 0.30614802f, 0.32939059f, -0.43852618f, -0.00339289f, 0.22142382f, -0.05378743f, -0.01567208f, 
    0.06102232f, 0.05021014f, -0.08066507f, -0.02364542f, -0.11228011f, 0.15682735f, -0.05186867f, -0.05478254f, 
    -0.01041400f, 0.05386857f, 0.03246238f, 0.12553853f, 0.02411565f, 0.12201637f, -0.11841188f, 0.02670108f, 
    0.07763794f, -0.18740067f, 0.01842232f, 0.24029180f, 0.09146740f, -0.00712236f, -0.05262042f, -0.07489923f, 
    -0.05237491f, 0.14202037f, 0.13159849f, -0.14490159f, 0.39198178f, -0.05230857f, 0.06711676f, 0.08124602f, 
    0.01112742f, 0.03196946f, 0.04814284f, 0.19287473f, -0.07420195f, 0.02237921f, -0.07334229f, -0.10207961f, 
    -0.03956963f, -0.34567747f, 0.04589036f, -0.02315465f, 0.17365524f, 0.02209921f, 0.12553890f, 0.03976138f, 
    0.22784613f, -0.02285106f, 0.21608295f, 0.10802215f, 0.23970287f, 0.22188070f, -0.04719229f, -0.09287304f, 
    0.00554810f, -0.04792975f, -0.00203923f, 0.08188845f, 0.07344981f, 0.06290007f, -0.02394967f, 0.08661024f, 
    -0.09664930f, -0.15750544f, 0.04322587f, 0.00784128f, -0.04559448f, 0.22747903f, 0.05806568f, -0.04833631f, 
    -0.03517861f, -0.01429337f, 0.07232393f, -0.02658328f, -0.29992375f, 0.17717649f, 0.06674528f, 0.17402653f, 
    -0.12113747f, -0.06205263f, 0.04554612f, -0.03383745f, 0.08705160f, 0.00854407f, 0.06807615f, 0.15109974f, 
    -0.07666204f, -0.11226160f, 0.35381225f, -0.25987041f, 0.01848140f, 0.07614037f, 0.06927053f, 0.07815867f, 
    -0.07146068f, 0.07848674f, -0.07694381f, 0.01180354f, 0.25210482f, 0.05117809f, 0.17315009f, -0.03877025f, 
    -0.12756635f, 0.10690304f, 0.00531637f, 0.05967613f, -0.00886431f, 0.04897309f, -0.09962567f, -0.05768606f, 
    -0.31396723f, 0.28243473f, -0.10595172f, -0.16461802f, -0.09649837f, -0.07219752f, 0.01911931f, -0.08403178f, 
    -0.06949410f, 0.14291140f, -0.12533191f, -0.01465335f, -0.11399145f, 0.01043555f, -0.08025122f, 0.25596112f, 
    -0.11114155f, 0.04348278f, 0.10703701f, -0.04204338f, -0.06634462f, -0.06766767f, 0.05947217f, 0.20495459f, 
    0.01656464f, 0.03007291f, -0.01720859f, 0.08903998f, -0.03414670f, -0.03607456f, 0.23635584f, -0.09930052f, 
    -0.04863223f, 0.04576592f, 0.17342676f, 0.19185992f, 0.71949077f, 0.14876899f, -0.01504540f, 0.12997925f, 
    -0.13305327f, 0.08912206f, -0.11736524f, 0.06591891f, 0.19464485f, 0.01023367f, 0.08242653f, 0.01051650f, 
    0.26516426f, 0.09517756f, -0.06661813f, -0.01966504f, -0.11371620f, -0.16141975f, 0.03050828f, -0.01106424f, 
    0.00898129f, 0.03920412f, 0.12066337f, -0.00451216f, 0.14039624f, -0.03464202f, 0.02976151f, 0.25642967f, 
    -0.12651488f, 0.13081366f, -0.00752385f, 0.20963094f, -0.01228730f, 0.03021445f, -0.02548575f, -0.10028175f, 
    -0.09400158f, -0.16781470f, 0.04574249f, 0.13883561f, 0.04656507f, -0.06047656f, 0.02007530f, 0.06537309f, 
    0.07477998f, 0.02803571f, -0.02135050f, -0.02224838f, -0.13676268f, -0.28491870f, -0.18381590f, -0.18728690f, 
    -0.14973007f, -0.04736152f, -0.02076051f, 0.07329314f, 0.04030364f, 0.06301793f, 0.08631945f, -0.00591007f, 
    -0.32115090f, 0.23562144f, -0.06352560f, -0.27932820f, 0.01241189f, -0.08021401f, -0.04980318f, -0.03188836f, 
    0.08034102f, -0.13174738f, 0.07386991f, 0.03478163f, -0.53251350f, 0.02459304f, 0.07138857f, 0.41776347f, 
    -0.08775828f, -0.07021339f, -0.01236497f, -0.09447278f, 0.08831561f, 0.08365338f, -0.01114035f, -0.03665680f, 
    -0.20100674f, 0.31075978f, -0.02422059f, -0.05090502f, 0.13790391f, 0.07235247f, -0.07533631f, 0.07983413f, 
    0.27888918f, 0.12493888f, -0.00891852f, 0.04545393f, 0.13754675f, 0.06421918f, -0.02325595f, 0.26382113f, 
    0.06508858f, 0.03850912f, 0.00581166f, 0.07115534f, -0.01630845f, 0.03748085f, 0.14361033f, 0.01006961f, 
    -0.23832011f, 0.14766461f, -0.05871480f, 0.02912581f, 0.04268183f, 0.20153894f, 0.20388092f, -0.21560046f, 
    0.03700363f, -0.04511035f, -0.00170468f, -0.00459347f, 0.11904729f, 0.21024916f, -0.00368032f, 0.17451286f, 
    -0.02290984f, 0.00479253f, 0.08750061f, 0.12136941f, -0.04881460f, -0.13078953f, -0.01421276f, 0.06001332f, 
    -0.07332151f, 0.06042059f, -0.04990468f, -0.01936107f, -0.10040751f, -0.01553270f, 0.20499949f, -0.05002535f, 
    0.17386267f, -0.02730813f, 0.21545045f, -0.07676210f, -0.01747475f, 0.12594216f, 0.19713987f, 0.05548303f, 
    0.05817873f, 0.03710534f, 0.09068529f, 0.27419561f, 0.01706747f, 0.13972908f, -0.05868451f, -0.07297630f, 
    0.06173495f, 0.19485128f, -0.17776030f, 0.54129189f, -0.04134392f, 0.02642603f, 0.03691473f, -0.06626931f, 
    0.07295961f, -0.03101547f, -0.10995977f, -0.11102954f, -0.20250447f, -0.06307168f, -0.29316160f, -0.36409360f, 
    0.33700022f, -0.01044736f, -0.02888712f, -0.04321755f, 0.03305243f, -0.05036306f, -0.00822105f, 0.02790369f, 
    -0.07997483f, -0.12068982f, 0.09702668f, -0.30524600f, -0.20678844f, -0.09492140f, 0.11233466f, 0.24860482f, 
    0.03303124f, -0.19753276f, -0.14942828f, 0.02493798f, 0.12249855f, 0.11237803f, 0.04254184f, 0.29477403f, 
    0.05135809f, -0.02522027f, -0.03556225f, 0.06228276f, 0.08135508f, 0.14671892f, 0.13935302f, -0.06131477f, 
    0.14917122f, 0.07641067f, 0.10084423f, 0.04403366f, 0.13925534f, 0.16105138f, 0.00270708f, 0.01349266f, 
    0.01125065f, -0.01593279f, 0.07404600f, -0.01425053f, -0.33881104f, 0.12391802f, -0.23434463f, -0.04439145f, 
    0.15155415f, 0.01045051f, -0.06641383f, -0.06067675f, 0.23737085f, 0.10657945f, 0.01759778f, 0.09282633f, 
    0.18838926f, -0.22092466f, -0.14127187f, 0.03716933f, 0.20433207f, -0.03377107f, -0.08686002f, -0.06728847f, 
    0.08543827f, 0.05741753f, 0.00046426f, -0.02313273f, -0.56520230f, -0.22664025f, -0.15632388f, -0.04948783f, 
    0.14109357f, 0.17730020f, -0.03941236f, -0.00351050f, 0.08520070f, 0.14470387f, 0.00035593f, 0.06402327f, 
    0.15202086f, 0.15778971f, 0.16485134f, -0.14146902f, 0.09648994f, 0.05864775f, -0.09480369f, -0.14672080f, 
    0.08627339f, 0.02646399f, -0.01031956f, -0.09374902f, -0.09333588f, 0.08559430f, -0.02888350f, -0.10238594f, 
    -0.02408689f, -0.10194331f, -0.03632135f, 0.22532101f, 0.06085731f, 0.08300997f, 0.10326764f, 0.06218583f, 
    -0.13786493f, -0.40191749f, -0.08174855f, -0.31211790f, -0.03023485f, 0.05876237f, 0.15736367f, 0.17154309f, 
    -0.14563346f, -0.09844360f, 0.03937353f, -0.03654057f, 0.01974145f, -0.14460039f, -0.08466802f, -0.05793415f, 
    0.00914586f, 0.06020597f, 0.01584942f, 0.01612908f, 0.08197040f, 0.05002113f, -0.13066350f, -0.04395832f, 
    0.41082564f, -0.09806928f, -0.06631093f, -0.04825436f, -0.02034870f, 0.07191078f, -0.12951253f, 0.15791726f, 
    -0.04402641f, 0.03843414f, 0.00747867f, -0.03097709f, 0.40434307f, -0.33352870f, 0.01843385f, -0.09468798f, 
    0.05195105f, 0.01511187f, -0.06689506f, 0.12968169f, -0.01197331f, 0.11158423f, 0.02699409f, 0.03593745f, 
    -0.04204008f, -0.07851663f, 0.02643566f, 0.05213249f, -0.10886809f, 0.03711967f, 0.08827356f, 0.04650051f, 
    0.17131661f, -0.01500352f, 0.00716227f, 0.00474495f, -0.17238045f, -0.03198651f, 0.10512395f, -0.07716842f, 
    -0.05591036f, 0.03776053f, -0.00417893f, 0.05634226f, -0.06949252f, 0.02915099f, 0.03971530f, 0.10432906f, 
    0.08879194f, 0.14127994f, 0.05419556f, -0.31268656f, 0.03053801f, 0.08038872f, 0.09889106f, 0.05772605f, 
    0.03448358f, -0.04558665f, 0.20343134f, 0.25814858f, 0.56716812f, 0.04538430f, 0.01631400f, 0.39876601f, 
    0.00868638f, 0.01530245f, -0.03945214f, 0.02258773f, 0.02750758f, -0.00258400f, -0.07842641f, 0.00313147f, 
    0.26888850f, -0.02678680f, 0.07294708f, 0.20391263f, 0.02188216f, 0.03757169f, -0.08147727f, 0.06477825f, 
    0.07600410f, 0.15148704f, 0.15193124f, 0.14293146f, -0.04446485f, 0.05456864f, -0.12753066f, -0.05257782f, 
    0.12182498f, 0.05540266f, -0.02358595f, -0.08871069f, 0.10047451f, 0.07883567f, -0.17260566f, -0.07531790f, 
    0.06535908f, 0.01267336f, 0.13053913f, -0.23033105f, -0.06453463f, 0.05545773f, -0.02897771f, 0.01396507f, 
    -0.15383694f, 0.11174097f, -0.06448312f, -0.02070293f, 0.01485214f, -0.08572407f, 0.14367586f, -0.03057121f, 
    0.00833155f, 0.01797436f, 0.07694804f, 0.04465554f, -0.07825392f, -0.01015643f, 0.01264589f, -0.02367052f, 
    0.09425353f, 0.15971042f, -0.16826031f, -0.07203205f, -0.06940981f, -0.03028402f, 0.03283720f, 0.02465465f, 
    0.00037007f, 0.01894181f, -0.03088995f, -0.14518380f, 0.23534532f, 0.12129601f, 0.19838528f, 0.23545676f, 
    0.06799256f, -0.17929316f, -0.02984897f, 0.07060566f, 0.07543602f, -0.00559107f, -0.07337893f, 0.06568906f, 
    0.09399507f, -0.18611561f, 0.07765988f, -0.02397669f, -0.01808836f, 0.03845542f, 0.00346963f, -0.14076792f, 
    0.11363015f, -0.10635199f, -0.00299305f, 0.05480668f, 0.16780874f, -0.00355372f, 0.02369651f, 0.02993114f, 
    -0.00270037f, 0.14682677f, 0.01448261f, -0.12237648f, 0.08499884f, -0.15176669f, -0.06802051f, -0.12198532f, 
    -0.11630626f, 0.10498365f, -0.07119100f, 0.19421390f, 0.12639055f, -0.03767768f, -0.02451410f, -0.09569626f, 
    -0.07726914f, 0.19606280f, -0.16413696f, 0.09240925f, -0.30774739f, -0.06310142f, 0.12525317f, 0.21719542f, 
    -0.19294448f, 0.13394094f, -0.00719294f, 0.12866886f, -0.05956732f, 0.13678302f, 0.16609173f, 0.00069802f, 
    -0.03283138f, -0.03342704f, 0.32794464f, 0.03499013f, 0.15702420f, -0.07964936f, -0.03844224f, -0.05246993f, 
    0.06370606f, 0.04183472f, -0.03394907f, -0.07016538f, 0.22587532f, 0.16172569f, -0.27857327f, 0.12747815f, 
    0.18158069f, -0.05949462f, 0.09115032f, 0.13446553f, 0.06811309f, 0.00152055f, 0.00293363f, -0.04765189f, 
    -0.26248157f, 0.09688263f, -0.27351421f, 0.22663493f, 0.13801564f, -0.04555587f, -0.00445572f, -0.09558477f, 
    0.03332091f, -0.06273747f, 0.10197546f, 0.02779722f, 0.13027585f, -0.15567468f, -0.18853685f, -0.05579703f, 
    0.04512730f, -0.00878739f, -0.09138402f, 0.21655980f, 0.08392229f, -0.11255184f, 0.11633876f, 0.04159117f, 
    0.00891165f, -0.11718353f, -0.13609616f, -0.12605843f, -0.04255527f, 0.13691446f, -0.07349225f, 0.05490608f, 
    0.09901496f, -0.02003436f, 0.10547036f, 0.00135855f, -0.47206199f, -0.03701205f, -0.03176700f, -0.19071165f, 
    0.10137419f, -0.05806985f, 0.00405403f, -0.05075336f, 0.08437537f, 0.04921335f, -0.04511234f, 0.10649272f, 
    -0.23090355f, 0.00351461f, -0.04356346f, -0.14220512f, 0.16188273f, -0.01055994f, -0.02041797f, 0.00100418f, 
    0.09031648f, 0.03205032f, -0.07268968f, -0.11724710f, -0.16046573f, -0.16647534f, 0.07531308f, 0.04803563f, 
    0.02197104f, 0.08666823f, 0.30394402f, 0.12171412f, 0.10315510f, 0.03243528f, 0.12615716f, 0.12336661f, 
    -0.28036740f, -0.12910278f, -0.14222674f, -0.09149059f, 0.07289665f, 0.02965807f, 0.06868606f, -0.01812204f, 
    0.10785906f, 0.04236848f, 0.10101339f, -0.05944016f, -0.02742985f, -0.00978963f, -0.12705311f, -0.09500368f, 
    0.05965862f, -0.02127608f, -0.04082899f, -0.14042822f, 0.15035699f, -0.06291041f, 0.00057701f, 0.16423926f, 
    0.42547292f, 0.16137168f, 0.13357170f, -0.00066361f, 0.04447322f, 0.07021588f, -0.03623446f, 0.01641512f, 
    0.03861754f, 0.04185205f, 0.05068066f, 0.17334470f, 0.24361300f, 0.03736655f, 0.03266834f, -0.06225163f, 
    0.08754731f, 0.03375796f, 0.00245798f, -0.03548503f, 0.08662248f, -0.13242079f, 0.03551681f, -0.01610626f, 
    -0.20205805f, -0.03360090f, -0.25443771f, 0.07839184f, -0.00711649f, -0.03212684f, -0.04216775f, 0.06964314f, 
    -0.04977150f, 0.15251301f, -0.13371244f, 0.05639293f, -0.18920572f, 0.24350494f, -0.03885562f, -0.28658959f, 
    -0.02009237f, -0.00925588f, 0.10064808f, 0.14544795f, -0.13488747f, 0.02951798f, 0.12850344f, 0.07595476f, 
    -0.12499357f, -0.35339341f, -0.02581631f, -0.05762973f, -0.12788926f, 0.02958961f, -0.06423954f, 0.10363515f, 
    -0.04894907f, 0.23131108f, -0.06317603f, 0.06471747f, -0.33769101f, 0.19656093f, -0.19638510f, -0.28141525f, 
    -0.10141529f, 0.05614038f, -0.09401288f, -0.12728854f, 0.13608851f, 0.22087443f, 0.17675789f, 0.15779893f, 
    0.22204182f, -0.00377547f, -0.02458160f, -0.16979204f, 0.05736391f, -0.09508666f, -0.18368196f, -0.03886915f, 
    0.07131426f, -0.07388147f, -0.06241731f, -0.14285186f, 0.14978665f, 0.11763852f, 0.03162722f, 0.08999418f, 
    -0.05484694f, -0.00162837f, -0.03775408f, 0.12907273f, -0.00443087f, 0.07316542f, 0.02712533f, 0.13117765f, 
    -0.18709621f, 0.23583275f, 0.08192390f, 0.08307382f, 0.01063023f, -0.02763277f, -0.15733899f, 0.08744326f, 
    0.09968243f, -0.10572220f, 0.13594045f, -0.03430863f, -0.22133760f, 0.12598190f, 0.26206097f, -0.04028015f, 
    -0.09977081f, -0.06401746f, -0.02707171f, 0.13616581f, 0.28294519f, 0.15717973f, 0.16976529f, 0.23831773f, 
    0.10370695f, 0.06560232f, 0.01457401f, -0.29363272f, 0.08243747f, 0.05144438f, -0.08147261f, -0.03248659f, 
    0.04097104f, -0.25916129f, -0.04812832f, -0.02868985f, -0.00583692f, 0.11169260f, -0.16619851f, 0.36293933f, 
    0.01553323f, 0.01605881f, -0.17702581f, 0.09747875f, 0.15596396f, -0.04779712f, -0.07712360f, -0.08704191f, 
    0.19562171f, 0.10489937f, -0.10686485f, 0.36623433f, 0.11873062f, -0.03217764f, -0.05889939f, -0.04428804f, 
    0.08524300f, -0.08427804f, -0.10153230f, -0.09885075f, 0.04023692f, -0.18430665f, -0.05567709f, -0.20890345f, 
    0.05464895f, -0.00924639f, 0.11779901f, -0.07188022f, 0.22529854f, -0.10933105f, -0.02699175f, -0.13851379f, 
    0.29574534f, -0.05470928f, -0.07423673f, -0.05659512f, -0.05051683f, 0.00125701f, -0.04016477f, 0.11580727f, 
    -0.02792362f, 0.07014396f, 0.08076546f, -0.14974663f, 0.20703436f, -0.43546739f, 0.10054445f, 0.18071972f, 
    0.16147545f, -0.07237299f, 0.12995030f, -0.00198518f, 0.06958973f, -0.05424496f, -0.11155491f, 0.03926615f, 
    -0.13644348f, -0.11150132f, 0.08959922f, 0.16431443f, 0.05767792f, -0.08322188f, -0.05548858f, -0.03621544f, 
    -0.06394561f, 0.02434189f, 0.13277271f, -0.02159409f, 0.40913144f, -0.16102621f, -0.04401466f, 0.16114695f, 
    0.15827517f, 0.12660460f, -0.10040336f, -0.03762689f, -0.01071698f, -0.00956946f, 0.05300528f, 0.02749681f, 
    0.02602158f, 0.07557335f, 0.05678989f, 0.11520796f, -0.02560002f, -0.03760115f, -0.04009244f, 0.19013673f, 
    0.07926689f, 0.04761371f, -0.03793727f, 0.31014416f, 0.05556142f, 0.14311615f, -0.25441200f, 0.09582598f, 
    0.02685078f, 0.08467088f, 0.00078404f, 0.08184351f, -0.03480279f, -0.02723205f, 0.05459230f, 0.03417338f, 
    -0.00638500f, 0.02198641f, -0.02994932f, 0.04908770f, -0.03013115f, -0.05963456f, 0.02572730f, 0.05851045f, 
    -0.09361794f, -0.08213910f, -0.04986599f, -0.00516138f, -0.07326022f, 0.04754978f, 0.01828562f, -0.02784202f, 
    -0.03706973f, -0.01870213f, -0.03432525f, -0.06228910f, -0.03489768f, -0.09167524f, -0.05816815f, 0.01434484f, 
    0.04259396f, -0.08952309f, -0.05456431f, 0.03580160f, -0.06035509f, 0.03532333f, 0.01345260f, -0.00803490f, 
    0.00286018f, -0.07223251f, 0.06311370f, 0.04402734f, -0.00531276f, 0.00382376f, 0.01095134f, -0.03396267f, 
    0.02402791f, -0.00275679f, 0.05055655f, -0.04826098f, -0.00497728f, 0.02096351f, -0.03356276f, 0.05087250f, 
    -0.08026204f, -0.00916281f, 0.01930428f, 0.04776916f, 0.02257900f, -0.01641180f, -0.00000778f, 0.03783690f, 
    0.04676225f, -0.05436750f, -0.03596165f, 0.03008606f, -0.00315532f, -0.02418228f, -0.03485108f, 0.06890098f, 
    -0.05466158f, -0.04987114f, 0.01259709f, -0.07388827f, -0.06992850f, -0.04866837f, -0.04260417f, -0.05188940f, 
    -0.01200711f, 0.03340443f, -0.04715880f, 0.01284941f, 0.03821955f, 0.00947564f, -0.00872214f, -0.04174144f, 
    0.01741958f, 0.01272127f, -0.06719773f, -0.07281999f, -0.05886915f, -0.02391099f, -0.05493791f, 0.02834602f, 
    -0.05232118f, -0.01060555f, -0.04459956f, -0.04441809f, 0.06068443f, 0.02964924f, 0.03410493f, -0.06680023f, 
    0.04944249f, -0.02994606f, 0.02643907f, 0.03307194f, -0.00714868f, -0.04364179f, -0.09611427f, 0.04753434f, 
    -0.04270474f, 0.04410124f, 0.06596470f, 0.05400159f, -0.01042073f, 0.05471925f, -0.03481197f, -0.08147457f, 
    -0.06808946f, -0.03868905f, 0.01254555f, -0.02921973f, 0.01964619f, -0.10928831f, -0.07255634f, -0.08666124f, 
    -0.08636645f, -0.08528411f, -0.04438344f, 0.05838025f, -0.04456960f, 0.00594346f, -0.05735391f, 0.01369761f, 
    -0.06324808f, -0.04314106f, -0.08435455f, 0.05013074f, -0.06072411f, 0.03829054f, -0.07725804f, -0.06294081f, 
    0.05956494f, -0.08860750f, 0.03173273f, 0.02131724f, -0.05894605f, -0.01942222f, -0.03386811f, -0.04576235f, 
    -0.03624089f, 0.07968308f, -0.03302680f, -0.07302077f, -0.05046627f, 0.03825638f, 0.02312320f, 0.00174033f, 
    -0.02976178f, 0.02677643f, -0.02238335f, -0.00429739f, 0.00239364f, -0.07510608f, -0.07213524f, -0.00239267f, 
    -0.04425655f, 0.00141191f, -0.01097039f, -0.00240436f, 0.02127398f, -0.02911938f, -0.04701274f, 0.02937065f, 
    0.04865735f, 0.04720858f, -0.06129126f, -0.01221947f, 0.07273979f, -0.00871867f, -0.02207208f, -0.08442133f, 
    0.05661413f, -0.00570337f, 0.03840155f, 0.04211960f, 0.04210353f, 0.03797242f, -0.01268543f, -0.08918044f, 
    0.08000194f, 0.02075139f, -0.00239138f, -0.03230497f, -0.02285860f, -0.03207001f, -0.00158602f, -0.08104061f, 
    0.03020049f, -0.04294309f, -0.05709943f, -0.04771979f, 0.03115945f, -0.07580902f, -0.00693602f, 0.03078390f, 
    0.03935726f, -0.04998687f, 0.02159774f, -0.05667455f, 0.04273343f, 0.00951389f, 0.02418337f, -0.00795850f, 
    -0.07588708f, -0.08214583f, 0.03302948f, -0.08134355f, 0.00065167f, 0.01536032f, -0.02193958f, -0.05159639f, 
    0.00143689f, -0.02048797f, -0.06330119f, -0.05775008f, -0.03294802f, 0.03442344f, 0.02835697f, -0.08127268f, 
    -0.04808329f, 0.05007789f, -0.04951592f, 0.05972026f, -0.05352484f, 0.02066163f, 0.03481432f, 0.00042308f, 
    -0.07971688f, -0.05098659f, -0.01871410f, -0.03061361f, 0.01248597f, 0.00014354f, -0.08000120f, -0.00737658f, 
    0.02216847f, -0.00169594f, -0.01603837f, 0.03203751f, 0.00584276f, 0.05090189f, 0.05165032f, -0.06730197f, 
    -0.06162033f, 0.05416551f, -0.06390475f, -0.01606322f, -0.08528375f, 0.01515023f, -0.07444340f, 0.00759912f, 
    0.02462067f, -0.00675101f, -0.03265105f, -0.04384442f, 0.04978669f, 0.05037655f, -0.01997190f, 0.04938026f, 
    0.05507980f, 0.04625339f, -0.02411876f, -0.04472751f, 0.00759588f, -0.06970248f, -0.05448733f, 0.04927063f, 
    -0.05331178f, -0.04322835f, -0.07683723f, 0.01678144f, -0.07805801f, -0.05300524f, 0.02060179f, 0.04145449f, 
    -0.01400396f, 0.04548406f, -0.06939168f, 0.04088495f, 0.02075168f, 0.05087201f, -0.03829603f, -0.01255088f, 
    0.01945868f, -0.00494814f, -0.03620628f, -0.03560007f, -0.01720050f, -0.04762478f, 0.00657604f, 0.00029229f, 
    0.03093070f, 0.00170865f, -0.01737692f, 0.04423345f, 0.04275195f, -0.05878780f, -0.02121391f, 0.02130014f, 
    0.02848455f, -0.00984056f, 0.02043738f, 0.03205749f, 0.01926342f, 0.01015352f, -0.02071824f, 0.00895156f, 
    0.00436348f, -0.03772072f, 0.02790523f, -0.01545291f, -0.05657261f, 0.01964751f, 0.01123230f, -0.08084322f, 
    0.01153640f, 0.05526501f, 0.01026772f, -0.04955473f, 0.04540730f, -0.02326650f, 0.06910077f, 0.02417791f, 
    -0.05237121f, -0.02639712f, 0.05294030f, -0.04701142f, 0.05854902f, -0.06662343f, -0.08314104f, 0.04777642f, 
    -0.05164558f, -0.05720135f, -0.06302145f, -0.00371783f, 0.04947995f, -0.00640644f, -0.02085756f, 0.04008486f, 
    0.02124216f, 0.00156010f, -0.03124548f, 0.04885826f, -0.01575744f, -0.04227957f, 0.01150235f, 0.00900371f, 
    0.04816179f, 0.02398723f, -0.07918244f, -0.03476234f, -0.03215774f, 0.02117156f, -0.00633211f, -0.05714601f, 
    0.01871442f, -0.03756000f, -0.08192965f, -0.02855380f, -0.01156855f, -0.01886317f, -0.05135467f, 0.02182602f, 
    -0.02195692f, 0.04839164f, 0.05786725f, -0.07497980f, -0.00058080f, 0.01862348f, -0.00059872f, 0.01036114f, 
    0.01263230f, -0.07086208f, 0.03069933f, -0.04539272f, 0.00924034f, 0.04526500f, 0.00911304f, -0.07464010f, 
    0.53086901f, 0.22437590f, -0.00216047f, 0.25935474f, 0.06466658f, -0.01921116f, 0.09832288f, -0.14854383f, 
    -0.00516667f, -0.10879393f, 0.17238687f, -0.04436653f, 0.00366936f, 0.18432851f, 0.23447835f, 0.04987139f, 
    0.11653683f, -0.14246355f, 0.06938408f, -0.05471665f, -0.02624467f, -0.02769955f, -0.03872309f, -0.02775912f, 
    -0.12613450f, -0.05118810f, 0.04567459f, 0.20833658f, 0.00915461f, -0.01413998f, 0.04291226f, -0.09422904f, 
    0.01619357f, -0.04872216f, 0.08347514f, 0.05394056f, -0.43262962f, 0.00884916f, -0.07907508f, 0.07102138f, 
    -0.06888003f, 0.01886129f, 0.16587764f, -0.16774422f, 0.01006836f, 0.01251922f, 0.03994935f, 0.05429665f, 
    -0.04987935f, -0.03151090f, 0.02545864f, -0.19715862f, 0.12675351f, 0.04786365f, -0.12046214f, 0.02297413f, 
    -0.18273874f, 0.03905210f, -0.04664572f, 0.12600821f, -0.20655020f, 0.09758309f, -0.25075662f, 0.07427163f, 
    0.02456304f, -0.01637734f, -0.01102857f, -0.09112082f, -0.04145645f, -0.08013818f, -0.14179175f, -0.09824171f, 
    -0.06558686f, -0.23918636f, -0.00604164f, 0.01908661f, 0.01035041f, -0.12443934f, 0.11314005f, -0.16032635f, 
    0.00656199f, 0.20527515f, 0.03591727f, 0.04546147f, -0.13945474f, 0.08378490f, 0.44162148f, -0.09898753f, 
    -0.19406970f, 0.07733668f, 0.10858645f, 0.05385974f, -0.06347651f, 0.03116877f, 0.06190619f, -0.01309405f, 
    -0.20677169f, -0.01240373f, -0.00379070f, -0.15268323f, 0.00008935f, 0.06130725f, 0.13762611f, -0.07525741f, 
    -0.07524151f, -0.00416580f, 0.00674535f, 0.09531612f, 0.20619802f, 0.14287989f, 0.27396017f, 0.09577674f, 
    -0.04141279f, 0.12768270f, 0.06242453f, 0.11339031f, -0.12956385f, -0.10164348f, 0.08924440f, 0.17731135f, 
    -0.03224325f, -0.01468708f, -0.36658257f, 0.04828968f, -0.14592372f, -0.09501204f, -0.03060142f, -0.08114719f, 
    -0.02272917f, -0.05296391f, 0.02031070f, 0.00421861f, 0.23586772f, 0.13377960f, -0.01260163f, 0.01270767f, 
    -0.09398527f, -0.00196547f, 0.00616041f, 0.14743489f, 0.03297850f, -0.05835818f, -0.05691335f, 0.00078323f, 
    -0.05680833f, 0.11081716f, 0.20575215f, 0.22206864f, -0.01104264f, 0.15718615f, -0.03211327f, 0.10659163f, 
    0.00726557f, -0.14902119f, -0.02260092f, 0.08996231f, -0.08646885f, -0.05013173f, 0.13867858f, -0.05294878f, 
    -0.15705873f, 0.02048054f, 0.10073635f, 0.13745698f, 0.04083411f, 0.03458294f, 0.03817522f, -0.00105913f, 
    -0.13518406f, 0.12212811f, -0.10908674f, 0.23044926f, 0.03861933f, 0.00975794f, -0.07313196f, -0.02638769f, 
    -0.09236737f, 0.17295198f, 0.02602448f, -0.09759931f, -0.21367575f, 0.17249325f, 0.24231823f, 0.20024617f, 
    -0.03478107f, 0.08315301f, 0.07318350f, 0.02038006f, 0.00395893f, 0.09470572f, 0.00356071f, -0.02150036f, 
    0.22402169f, 0.30114231f, 0.02640232f, 0.10584543f, -0.14036557f, -0.02177981f, -0.02027968f, -0.08699443f, 
    -0.08072970f, -0.13294654f, -0.09379512f, -0.01979396f, -0.00327901f, -0.07763585f, 0.12460168f, 0.25717983f, 
    -0.09402177f, 0.15954471f, 0.06223003f, 0.00307974f, -0.04593181f, -0.11313853f, 0.05213426f, -0.15668561f, 
    0.23603307f, 0.11071322f, -0.20695820f, -0.06854372f, -0.08060383f, -0.03372573f, 0.08439969f, -0.11386679f, 
    0.01709951f, 0.05209464f, -0.02080132f, 0.13489048f, 0.15207200f, 0.27147034f, -0.00315354f, 0.01089828f, 
    0.12614216f, 0.15000798f, 0.12254407f, -0.08806952f, -0.16629472f, 0.10786583f, 0.01810748f, 0.03712118f, 
    -0.04503800f, 0.26848507f, -0.04552345f, 0.32364586f, 0.10655222f, 0.02417852f, 0.09848349f, -0.11750509f, 
    0.05373957f, -0.09574929f, -0.02470551f, -0.05720012f, 0.35807365f, 0.00128687f, 0.06962597f, 0.10234024f, 
    0.06691931f, 0.21495749f, -0.07875108f, -0.02888119f, 0.02057788f, 0.07959231f, 0.11750609f, 0.02467147f, 
    0.49177122f, 0.12614945f, 0.13912867f, 0.24711414f, 0.16230899f, 0.25606027f, -0.12905394f, 0.03716017f, 
    -0.09329566f, 0.04071641f, 0.12199508f, -0.10893864f, -0.26264530f, -0.26201239f, -0.10336015f, -0.12068965f, 
    -0.00812466f, -0.07335532f, -0.07107430f, -0.05695664f, -0.08876869f, -0.03095622f, -0.19025677f, -0.05593681f, 
    -0.16939314f, 0.22741625f, 0.07874411f, -0.12333035f, -0.10003673f, 0.04054633f, -0.13768664f, -0.05550838f, 
    -0.05501912f, -0.15850559f, -0.04512339f, -0.21169426f, -0.37743425f, 0.06611174f, -0.03407343f, -0.10141663f, 
    -0.10164994f, -0.08322401f, 0.01043448f, 0.01679672f, -0.04052113f, 0.13605341f, -0.03774832f, -0.02337003f, 
    0.08457006f, 0.09665346f, 0.01652825f, 0.25923291f, 0.20737325f, 0.28362316f, 0.06813636f, -0.21849383f, 
    0.05405033f, -0.06834809f, 0.22039796f, -0.02178470f, -0.27186793f, 0.22097431f, -0.05079024f, 0.19474500f, 
    -0.03888506f, -0.17822096f, -0.04591004f, -0.03059047f, -0.05667245f, 0.07330802f, 0.19519547f, -0.13004017f, 
    0.27293080f, -0.04071428f, -0.19339930f, 0.09438485f, -0.12536085f, -0.26813793f, 0.04415639f, -0.07236382f, 
    0.03231704f, -0.03173937f, -0.00053778f, 0.12830210f, -0.21457671f, -0.03978462f, -0.14040335f, 0.09623932f, 
    0.06925902f, -0.03757095f, 0.01972499f, -0.10539827f, 0.11035912f, -0.07841860f, -0.18587546f, 0.00233268f, 
    0.21399383f, 0.30898598f, 0.25771663f, 0.02330256f, 0.19633183f, 0.18771656f, 0.04099630f, -0.12032695f, 
    0.05545181f, -0.01256856f, 0.01356926f, -0.05154477f, -0.14302208f, -0.09406943f, 0.00893732f, -0.11177481f, 
    -0.10624679f, -0.17307253f, -0.15127020f, 0.13472930f, -0.19602215f, -0.13796863f, -0.03067777f, 0.14979719f, 
    0.14319822f, -0.27223197f, 0.13572940f, -0.14741819f, -0.00019006f, 0.03281206f, 0.02565268f, 0.09850793f, 
    -0.04959546f, -0.05291250f, 0.01781524f, -0.08525483f, -0.18091601f, -0.00961125f, 0.08969372f, 0.09276456f, 
    -0.11042984f, 0.15015735f, -0.00186164f, 0.15113898f, -0.03345801f, -0.00088556f, 0.05003681f, 0.07825875f, 
    0.15209079f, -0.35376728f, 0.00661388f, -0.16829285f, 0.04825486f, -0.01271885f, -0.13510452f, 0.08259992f, 
    -0.00894475f, 0.05286376f, -0.10493109f, 0.03735621f, 0.45915809f, -0.09246621f, -0.14618979f, -0.04271225f, 
    0.02314967f, 0.02623457f, -0.02494980f, 0.08659112f, -0.02232147f, 0.02532825f, -0.03686604f, -0.03906200f, 
    -0.02112183f, 0.03407631f, -0.08599848f, 0.08445117f, 0.01360943f, -0.01027530f, 0.05919487f, -0.07152577f, 
    0.02691749f, 0.05027881f, 0.12510656f, -0.01404110f, 0.02533636f, -0.14522640f, -0.09182777f, -0.07761673f, 
    0.05947642f, 0.00572441f, 0.00426017f, 0.17541461f, 0.04783854f, 0.10803278f, -0.09427807f, -0.01989127f, 
    0.10430054f, -0.07998586f, 0.08283458f, -0.41927713f, 0.08870158f, 0.05527944f, 0.12621866f, 0.04852247f, 
    0.02502616f, -0.00251275f, 0.12196483f, 0.03414714f, -0.33510199f, -0.06801796f, 0.08912387f, 0.10798964f, 
    -0.08652711f, 0.14152926f, -0.03692267f, 0.10724647f, 0.08659623f, 0.06985587f, -0.07286889f, 0.12501727f, 
    -0.09623609f, -0.05367179f, -0.11721874f, -0.06239657f, 0.12034994f, -0.02917125f, 0.02062764f, -0.07292482f, 
    0.10938361f, 0.04599113f, -0.03108348f, 0.07488345f, 0.42665213f, 0.01224433f, -0.01995803f, 0.30874470f, 
    0.05712818f, 0.10199139f, 0.17154181f, 0.14875220f, 0.05008118f, 0.12927483f, 0.00279043f, 0.21756732f, 
    0.02953510f, 0.06321859f, -0.04297257f, -0.29080555f, -0.29328126f, -0.04831742f, 0.01096075f, 0.01904433f, 
    -0.02899803f, 0.09994370f, 0.07490496f, -0.15646330f, 0.04581485f, -0.08588119f, -0.25070867f, -0.07745726f, 
    -0.01367002f, 0.05549842f, 0.02791007f, -0.11038967f, -0.00327947f, -0.10300688f, -0.03036307f, -0.04997431f, 
    0.44025800f, -0.03793593f, -0.09912956f, 0.24640487f, 0.00912143f, 0.12536012f, 0.04572104f, 0.09261768f, 
    -0.07437072f, -0.03822719f, 0.10134877f, 0.07164852f, -0.03776535f, -0.04721029f, 0.18095699f, 0.02636697f, 
    -0.04009702f, 0.02181328f, 0.00110955f, 0.01428932f, 0.07632620f, 0.05717258f, 0.06884190f, 0.13810727f, 
    0.14320600f, -0.09047379f, -0.24519940f, -0.23522823f, -0.00583126f, -0.02946522f, 0.01246970f, -0.01670734f, 
    0.05371171f, 0.00162699f, -0.10429631f, 0.02511076f, -0.28893694f, 0.29937294f, 0.01553775f, -0.06607205f, 
    -0.02483104f, -0.02417665f, 0.01498583f, -0.09922879f, -0.05693575f, -0.06767108f, 0.04212729f, 0.07614384f, 
    0.27722636f, 0.19139378f, -0.05107460f, 0.10891061f, -0.03441292f, -0.08483562f, 0.03242705f, -0.03348968f, 
    0.05064890f, 0.06022797f, -0.05729295f, -0.03696009f, -0.07763200f, 0.06797341f, 0.44569829f, -0.19118594f, 
    -0.02464669f, -0.02147104f, -0.01223003f, -0.09320989f, 0.11559940f, -0.06385953f, -0.00970949f, 0.18472970f, 
    0.25653335f, -0.19650190f, 0.18520331f, -0.10779679f, 0.18640296f, -0.06160449f, -0.11471178f, 0.03683618f, 
    -0.08778164f, 0.19701985f, 0.09150013f, 0.08476859f, -0.42394224f, 0.05571880f, 0.05996134f, -0.12919831f, 
    0.03620799f, 0.07086408f, 0.07326481f, -0.12572001f, 0.01715554f, -0.03287788f, 0.03078709f, -0.08805470f, 
    -0.22944155f, 0.12355453f, -0.10546702f, -0.10886277f, 0.07129016f, -0.03415991f, -0.01634106f, -0.03583648f, 
    -0.04684552f, -0.16463938f, -0.03680770f, 0.06637884f, 0.01954715f, -0.03353419f, -0.29646787f, 0.06101867f, 
    -0.08533789f, -0.10073388f, -0.22231713f, 0.09778378f, 0.05782918f, -0.12134881f, 0.05826596f, 0.00818849f, 
    -0.01553961f, 0.03522949f, 0.11269985f, -0.18905067f, 0.02555010f, 0.02327305f, -0.08947950f, -0.18685243f, 
    -0.00330252f, 0.03176535f, -0.10129147f, 0.09699718f, -0.18660893f, 0.10134725f, 0.13763176f, 0.26310813f, 
    -0.04923739f, -0.02486082f, 0.06173028f, -0.00708180f, -0.00300069f, 0.06452842f, -0.02835277f, -0.07370100f, 
    0.00540961f, 0.20971824f, -0.06156224f, 0.15132079f, 0.16047958f, 0.04848362f, 0.05902187f, -0.05224240f, 
    0.04140260f, 0.20900777f, -0.06170622f, -0.12393479f, -0.01754163f, -0.17229907f, -0.12471691f, -0.25481448f, 
    0.08561280f, 0.04503196f, 0.02543706f, -0.02728003f, 0.06939662f, -0.19976959f, 0.03309983f, 0.01995521f, 
    -0.03090821f, -0.01784275f, -0.34015420f, 0.20905793f, -0.02101344f, -0.06208567f, -0.02871735f, -0.01721062f, 
    0.15230751f, 0.00278542f, 0.07506365f, -0.11379424f, 0.66138154f, -0.24003446f, 0.05797515f, 0.18917687f, 
    0.04222737f, -0.12317628f, 0.00401835f, 0.03919259f, -0.12598388f, 0.04529474f, 0.02924642f, 0.05640254f, 
    0.38388792f, -0.17749457f, -0.07943589f, 0.29327101f, -0.02114408f, 0.10888726f, 0.04584090f, 0.01649711f, 
    -0.00262315f, -0.00949826f, 0.06873973f, 0.24004757f, 0.80924255f, -0.13561578f, -0.10570876f, 0.06201998f, 
    0.08988999f, -0.03658954f, 0.01296769f, -0.00993325f, 0.05344965f, -0.11444839f, 0.09459154f, -0.01086140f, 
    -0.05019773f, 0.09573286f, -0.27411211f, 0.36701840f, -0.16859078f, -0.06932855f, 0.11963657f, 0.30713290f, 
    0.09240367f, 0.14859061f, -0.07936706f, 0.14206380f, -0.09618069f, 0.12264935f, -0.02524670f, 0.15329012f, 
    -0.10065379f, 0.01159107f, 0.07511862f, 0.05086996f, -0.19381890f, -0.03561886f, -0.02991240f, 0.05937325f, 
    -0.04656729f, -0.05740691f, -0.03791281f, -0.06920295f, 0.05495501f, -0.05992028f, -0.04740145f, 0.06371540f, 
    -0.01618451f, 0.02814936f, 0.01291262f, -0.05734434f, 0.05557378f, -0.01373461f, -0.05134472f, 0.05388401f, 
    -0.05871203f, 0.01844594f, -0.02820736f, -0.01310289f, 0.01147474f, 0.04860830f, -0.00106164f, 0.03316639f, 
    0.00708105f, -0.00192114f, -0.07574216f, 0.02618947f, -0.07412750f, 0.00426018f, 0.00779546f, -0.05414914f, 
    -0.03843388f, -0.05178574f, 0.04128951f, 0.06350935f, 0.02377842f, -0.00622768f, -0.03324455f, 0.02891982f, 
    0.03305059f, -0.07601324f, 0.03418263f, -0.00131896f, 0.02245194f, -0.07602620f, 0.00479674f, -0.06853875f, 
    0.05257754f, -0.02762303f, -0.06713302f, -0.02550622f, 0.01578405f, -0.04261272f, -0.04294895f, -0.05029901f, 
    -0.03815650f, -0.07081147f, -0.02863451f, -0.02913899f, 0.04280419f, 0.02523342f, -0.06233435f, -0.06336474f, 
    0.02452748f, -0.05476801f, -0.06671414f, 0.03148891f, -0.04877692f, -0.04076346f, 0.01740699f, 0.03873909f, 
    0.00694215f, -0.04116440f, -0.03917287f, -0.01292991f, -0.01711256f, -0.00107842f, 0.04516263f, 0.03781021f, 
    -0.01884455f, -0.00463905f, 0.05848147f, 0.00665673f, -0.02524823f, -0.00945112f, 0.05327400f, 0.02941410f, 
    0.04480864f, -0.01793397f, -0.01729823f, -0.04802645f, -0.03934337f, -0.03634936f, -0.06652270f, -0.02999525f, 
    -0.04976739f, 0.04707948f, 0.05559422f, -0.00794737f, 0.02103055f, -0.03940967f, 0.02407538f, 0.04531907f, 
    0.01392390f, -0.02124050f, -0.03937540f, -0.05063047f, -0.07640754f, -0.07187471f, -0.03957973f, 0.02557961f, 
    -0.04301918f, -0.04698960f, 0.06316540f, 0.00213646f, -0.03419619f, -0.01317377f, 0.01841235f, -0.06191966f, 
    0.05637083f, 0.05531290f, -0.01990432f, -0.03830887f, 0.02748016f, -0.00007610f, -0.07040882f, 0.05715409f, 
    0.02521309f, -0.02326280f, 0.04523059f, 0.05303721f, 0.04186315f, -0.06155319f, 0.06137745f, -0.02616479f, 
    0.06603334f, 0.02041028f, -0.04750613f, -0.04796421f, -0.06999382f, -0.05717770f, -0.04080327f, -0.02985628f, 
    0.02484872f, 0.04187281f, -0.00448940f, 0.03839147f, 0.01220169f, 0.02530284f, 0.00659442f, 0.00430463f, 
    -0.05353983f, -0.00179873f, 0.06608662f, 0.01621057f, -0.03926880f, -0.03881361f, -0.00638871f, 0.01083703f, 
    -0.03767121f, -0.03997839f, -0.05696198f, -0.01272238f, -0.07604608f, 0.03252193f, 0.01484535f, 0.04304257f, 
    0.00788501f, -0.07564268f, -0.06910351f, 0.02725424f, 0.00783214f, -0.02481390f, 0.01953050f, -0.05309726f, 
    0.01967437f, 0.01605457f, 0.05854000f, 0.03720178f, -0.03423135f, -0.06278564f, -0.01841633f, -0.03684565f, 
    0.00326067f, -0.04193064f, 0.03389521f, -0.03916124f, 0.00693419f, -0.00312001f, -0.06431741f, 0.03799881f, 
    0.03342817f, -0.04480698f, -0.04978364f, 0.04228250f, -0.00155823f, 0.01454891f, -0.00333222f, -0.03036513f, 
    -0.05108254f, -0.06518304f, -0.07239190f, -0.05410809f, -0.07007384f, 0.01179635f, -0.06746024f, 0.02828319f, 
    0.02420941f, -0.06276817f, -0.00413690f, 0.00598552f, -0.01953371f, 0.03088643f, -0.00279499f, 0.07131627f, 
    0.00266557f, 0.04757119f, 0.03701715f, -0.02437004f, 0.05310063f, -0.01853126f, 0.02256547f, 0.02501790f, 
    0.00817645f, -0.04841976f, -0.04585011f, -0.04504110f, 0.03104670f, 0.04467833f, -0.03513999f, -0.00699578f, 
    0.03376161f, 0.04270439f, -0.05098957f, -0.06044243f, -0.02896030f, 0.04328440f, -0.06977163f, -0.02556799f, 
    -0.05344057f, 0.04193208f, 0.05126573f, -0.04180051f, -0.00320091f, -0.06619013f, -0.03772113f, 0.03187531f, 
    -0.02498276f, 0.05907230f, 0.04282307f, -0.02481956f, 0.03601945f, 0.01388089f, -0.00844893f, 0.03637784f, 
    -0.04741494f, -0.04505455f, -0.00134371f, 0.00413486f, -0.04081218f, 0.04221059f, -0.06352718f, -0.06501342f, 
    0.03342638f, -0.04920065f, 0.03771989f, 0.00159451f, -0.00354871f, -0.00668401f, 0.00754229f, -0.00336489f, 
    0.02768216f, -0.00889937f, -0.05945661f, 0.04784406f, -0.05258115f, 0.00981545f, -0.04726184f, -0.04468909f, 
    0.03707325f, -0.00656027f, -0.06511430f, 0.05339679f, -0.01089937f, 0.03162193f, -0.01468451f, -0.06420949f, 
    0.03580847f, -0.00459823f, -0.03373322f, -0.00222946f, 0.06600069f, -0.06070355f, 0.00888059f, 0.05346521f, 
    0.02389663f, -0.04562452f, -0.03099007f, 0.02939712f, 0.02734124f, -0.01565741f, -0.03864423f, 0.04245490f, 
    -0.06314252f, 0.01816675f, -0.07280341f, -0.01160690f, -0.00897999f, 0.02076858f, 0.03407380f, 0.01883507f, 
    -0.03625114f, -0.03273803f, 0.04387307f, -0.04363802f, 0.01414361f, -0.01519508f, -0.04259666f, 0.00725289f, 
    0.04339689f, -0.06597270f, -0.04157529f, 0.03468690f, 0.06542157f, -0.06380269f, 0.01380639f, -0.02097209f, 
    -0.04590030f, 0.05366654f, 0.00662639f, 0.01101149f, 0.06018907f, -0.06538275f, -0.01307212f, -0.04600253f, 
    0.00094958f, 0.00482029f, -0.02070583f, -0.03548666f, 0.01114445f, -0.04131481f, 0.04765026f, -0.07073914f, 
    0.02934732f, -0.03467650f, -0.00983706f, -0.07497240f, -0.06555539f, -0.02638106f, 0.00280505f, -0.07121445f, 
    0.02747725f, -0.03843735f, -0.06252556f, 0.06563503f, -0.00763286f, -0.02337410f, -0.01396429f, -0.03979949f, 
    -0.01197922f, -0.03242942f, -0.04679968f, -0.07489333f, 0.05236679f, 0.04116969f, -0.04226698f, 0.00750994f, 
    -0.06769177f, 0.04716012f, -0.07183950f, -0.06860138f, 0.02142239f, -0.04118068f, 0.02131302f, 0.05573450f, 
    -0.04259363f, 0.03514334f, -0.06335481f, -0.06622415f, 0.06321114f, -0.07826877f, 0.02065804f, 0.03095717f, 
    -0.26621997f, 0.17853357f, -0.16617221f, 0.01716204f, -0.10827383f, 0.12477276f, -0.01455930f, 0.10790788f, 
    -0.05613836f, -0.01217497f, -0.16427438f, -0.02910174f, -0.02557509f, -0.12562110f, -0.03615353f, -0.04331470f, 
    -0.13703763f, 0.01666029f, -0.03453767f, -0.00205638f, 0.04127415f, -0.07012215f, 0.11036438f, -0.09007459f, 
    0.25643322f, 0.17287101f, 0.02474698f, -0.08619878f, 0.00630194f, -0.07814652f, 0.10588206f, 0.03328562f, 
    0.03704366f, 0.13639732f, 0.04902833f, 0.01160418f, 0.17485072f, -0.11714762f, 0.28863764f, -0.01707015f, 
    0.10166524f, 0.02692513f, 0.01102477f, 0.01504997f, 0.02318634f, 0.04192837f, -0.05144005f, -0.02774975f, 
    -0.18007469f, 0.39209217f, -0.07423585f, 0.25868505f, 0.02736176f, 0.01599767f, 0.06654350f, 0.03966112f, 
    0.27015749f, -0.06268127f, 0.01734461f, -0.05455470f, 0.17828406f, 0.07091781f, 0.13028541f, 0.08002692f, 
    0.08295760f, 0.02012556f, -0.13701926f, 0.00036272f, 0.04244239f, -0.09406929f, 0.17728393f, 0.01761386f, 
    0.08670163f, 0.09198828f, -0.06916966f, 0.07458604f, 0.17301168f, 0.00754375f, -0.05532926f, -0.03234162f, 
    -0.09729944f, -0.01806501f, 0.03304270f, -0.07935499f, 0.65965569f, 0.10558823f, -0.12550135f, 0.12160755f, 
    0.17114943f, -0.04541280f, -0.01075272f, -0.02374485f, 0.05466814f, -0.02650683f, -0.12165844f, -0.02203636f, 
    -0.02765251f, 0.06200488f, 0.04872714f, 0.29538572f, 0.02095126f, 0.09828202f, -0.07428940f, 0.25852862f, 
    -0.04015853f, 0.03423857f, 0.09049968f, 0.02172332f, -0.43716720f, -0.12055271f, -0.11258659f, -0.37253541f, 
    0.09340251f, -0.14427775f, -0.18226513f, -0.25790653f, -0.01576031f, 0.01538993f, 0.00259928f, -0.07960386f, 
    0.10983940f, -0.06054561f, 0.15640233f, 0.20384194f, 0.13738698f, 0.04151269f, -0.04364679f, -0.02544344f, 
    0.19859919f, 0.04009587f, -0.05649370f, 0.05967989f, 0.16419873f, -0.03111939f, 0.19946201f, 0.19118772f, 
    0.14834514f, -0.13141820f, -0.03801442f, 0.10407702f, -0.04086664f, 0.06686657f, 0.21493764f, -0.02765997f, 
    0.18456782f, 0.17057075f, -0.09978320f, -0.28048569f, -0.10425620f, -0.03434767f, -0.05358465f, -0.05962376f, 
    0.05817083f, 0.05207911f, 0.01477693f, -0.02550919f, 0.45534566f, 0.29102832f, -0.10814494f, 0.22132096f, 
    0.18552680f, 0.00698695f, 0.05175885f, -0.03054807f, -0.12210386f, 0.05593215f, -0.12467587f, -0.05570903f, 
    0.23052174f, 0.20621446f, 0.15125099f, 0.16424495f, 0.07857985f, -0.06274712f, 0.10221007f, 0.11624888f, 
    0.10651836f, 0.16695365f, 0.03722673f, -0.12423033f, 0.50093329f, -0.15329455f, -0.29960856f, -0.05770722f, 
    0.13593465f, -0.00634860f, -0.11462951f, 0.12046961f, 0.01750287f, 0.05793577f, -0.06641487f, -0.02754082f, 
    0.26748753f, -0.01743250f, 0.08042497f, 0.14424697f, 0.13866729f, -0.07769839f, -0.04999455f, -0.10629793f, 
    0.07762802f, 0.01165150f, 0.01014438f, 0.03592194f, 0.52886373f, -0.16557601f, 0.46734300f, 0.08846015f, 
    0.04132232f, -0.11542980f, -0.11184338f, -0.01544141f, -0.05243294f, -0.10733242f, -0.04848411f, 0.07667314f, 
    -0.01614999f, 0.01937546f, 0.08973188f, -0.22052726f, -0.03040191f, 0.09553858f, 0.16105972f, 0.18750754f, 
    0.12950148f, 0.09446182f, 0.07521276f, 0.08123469f, -0.10186251f, 0.23186660f, 0.15400496f, -0.12308185f, 
    0.10246889f, 0.02910653f, 0.13927299f, 0.02445282f, 0.10610752f, -0.03293261f, 0.02972107f, 0.00113729f, 
    0.42425841f, 0.01271442f, -0.30428854f, -0.08087934f, 0.05259070f, -0.12144254f, 0.03467129f, -0.00146848f, 
    -0.04865059f, 0.02242512f, -0.00669710f, -0.03033629f, 0.25988618f, -0.33779618f, -0.30618814f, 0.07413145f, 
    0.04343380f, 0.06185620f, 0.01491695f, 0.12868413f, 0.01370994f, -0.14437045f, -0.15426150f, -0.07461811f, 
    0.08109185f, 0.02763392f, -0.04209008f, 0.09491540f, -0.18037705f, 0.13480712f, 0.07220282f, 0.21350060f, 
    0.11810510f, 0.37709203f, 0.03109176f, 0.02353360f, -0.19321316f, -0.08630329f, -0.10087385f, -0.15429623f, 
    0.21849237f, -0.00836382f, 0.01247294f, -0.30935857f, -0.16701776f, -0.02090525f, 0.06915351f, -0.03149081f, 
    0.02826935f, 0.39249697f, -0.14917222f, -0.24059801f, 0.13435771f, 0.01038159f, 0.12066976f, 0.07139941f, 
    -0.07129959f, 0.09496500f, 0.00701940f, 0.02079277f, 0.07112735f, -0.02851096f, 0.04125914f, 0.06453273f, 
    0.02823678f, 0.07624745f, 0.00218289f, -0.04896180f, -0.12261778f, 0.08384869f, 0.09562801f, 0.12785956f, 
    -0.09020047f, 0.08260363f, -0.07858365f, 0.11098648f, 0.03900169f, -0.16700856f, -0.01102449f, 0.15125686f, 
    0.16395499f, 0.12814038f, 0.02784058f, 0.20633569f, 0.08613389f, -0.17816435f, 0.20813695f, 0.16800965f, 
    0.03202109f, 0.01616140f, -0.11209144f, -0.00557647f, 0.03210012f, -0.03537735f, 0.19011012f, 0.17611790f, 
    0.10492547f, -0.00592178f, -0.03526859f, -0.02541432f, 0.07695860f, 0.25835145f, 0.08996772f, -0.03562755f, 
    -0.13669556f, 0.01917247f, -0.09951378f, 0.05770730f, -0.01795131f, 0.05216600f, -0.04625628f, -0.39554936f, 
    0.17984512f, -0.03202846f, 0.00981952f, -0.21903281f, 0.01726897f, -0.15005101f, -0.00417323f, -0.03813989f, 
    -0.16535819f, -0.31472549f, -0.17263086f, 0.03684668f, -0.14953621f, -0.21436282f, -0.06153229f, 0.13202637f, 
    -0.10727183f, 0.08377969f, -0.14326061f, -0.03537887f, 0.35227758f, -0.20993896f, -0.05948244f, -0.00307937f, 
    0.09100640f, 0.01607919f, -0.04334309f, -0.07238929f, -0.00003707f, -0.12317115f, -0.04653781f, 0.12142061f, 
    0.12672627f, 0.05058114f, -0.11172178f, -0.11074684f, 0.03742994f, 0.11225649f, 0.04416589f, -0.06905483f, 
    -0.07735693f, -0.07849433f, 0.05998675f, -0.05515511f, 0.04675138f, 0.00586570f, 0.05434137f, 0.35066968f, 
    0.03166497f, 0.19191413f, 0.03414929f, 0.16102886f, -0.05921814f, -0.07669657f, -0.02699936f, -0.06251780f, 
    -0.05850917f, -0.14152123f, 0.00754941f, 0.18681934f, 0.00950446f, 0.00996489f, 0.06148364f, -0.01136435f, 
    -0.10403203f, 0.04536539f, -0.09070100f, 0.01036466f, 0.32413781f, -0.24684785f, -0.25540692f, 0.01028494f, 
    0.01501625f, 0.07378528f, -0.00363607f, 0.06971951f, -0.03480546f, -0.04505078f, 0.02173020f, -0.03047774f, 
    -0.04581911f, -0.19765496f, -0.03629754f, 0.07334255f, -0.05874902f, 0.04136117f, 0.07821156f, -0.06287062f, 
    0.14217487f, 0.11812866f, 0.03348421f, -0.06324411f, 0.12918453f, -0.09735277f, -0.03757231f, -0.14242923f, 
    0.04371052f, 0.15148410f, 0.01504977f, 0.00113839f, -0.12091117f, 0.02417755f, -0.00780738f, -0.10884704f, 
    0.09956706f, -0.13768628f, 0.19840458f, -0.06219220f, 0.12584339f, -0.03650972f, 0.14862195f, 0.10662942f, 
    0.01482537f, 0.15302388f, 0.18260595f, 0.10076898f, -0.02291294f, -0.02385953f, 0.09792636f, -0.29997897f, 
    0.03243199f, 0.12408327f, 0.04465072f, 0.05131954f, -0.04857690f, 0.05123821f, 0.00048802f, 0.07688729f, 
    -0.11746514f, -0.26314837f, 0.14214879f, -0.28570026f, -0.13008404f, -0.09818982f, 0.09161607f, -0.07002682f, 
    0.10125681f, 0.01080467f, -0.05612467f, 0.00081034f, 0.09677737f, 0.05021143f, 0.07185956f, 0.38101241f, 
    0.01661060f, -0.01879406f, 0.11832603f, 0.02559000f, -0.03855171f, 0.11289506f, 0.10337986f, 0.21205890f, 
    -0.08271128f, 0.01052380f, -0.01724391f, -0.17442665f, -0.06475829f, 0.14547932f, -0.03543408f, -0.10653943f, 
    -0.01210167f, 0.11119067f, 0.02305990f, 0.03490957f, -0.15709721f, 0.24786124f, -0.12889813f, -0.12213371f, 
    0.04856944f, 0.04685436f, -0.03573937f, -0.01158309f, -0.02584100f, 0.01651568f, -0.02988644f, -0.06436959f, 
    0.48399028f, 0.06924107f, -0.16609026f, 0.06169133f, 0.08656088f, 0.06684935f, 0.09657890f, -0.00934385f, 
    0.00696978f, -0.10827140f, 0.01348156f, -0.07299770f, -0.25195733f, 0.09600804f, 0.12535627f, 0.04538776f, 
    -0.08242060f, 0.01223443f, 0.01131767f, 0.10366975f, -0.05693110f, 0.00323557f, -0.09282678f, -0.02149868f, 
    0.12996951f, 0.06009915f, -0.08965212f, -0.18096456f, 0.00395694f, 0.01464870f, -0.04265689f, -0.15719479f, 
    0.06234398f, 0.06795514f, 0.05032655f, -0.15101397f, -0.37436613f, 0.24114554f, 0.21510632f, -0.24918017f, 
    0.05445802f, 0.06407215f, 0.05019878f, 0.05794938f, -0.06483012f, 0.01083196f, -0.10916089f, 0.05451748f, 
    0.20689896f, 0.45108491f, -0.03936440f, 0.16892625f, 0.05003190f, -0.01219761f, 0.03270708f, -0.04771458f, 
    0.16837744f, -0.02647813f, 0.00212663f, -0.02198019f, 0.23184074f, 0.03070486f, 0.24054316f, 0.05300539f, 
    0.11935388f, -0.08261219f, -0.04065135f, -0.03162030f, -0.05237207f, -0.09228249f, -0.05079166f, -0.02467544f, 
    -0.19676717f, 0.12976119f, 0.16366811f, 0.04208705f, -0.04394528f, 0.08081087f, 0.05486311f, 0.03476090f, 
    -0.13404563f, 0.03062798f, 0.13400921f, 0.09801109f, -0.54873145f, 0.05750997f, 0.20429902f, 0.12698297f, 
    -0.06325193f, -0.06502674f, 0.07419220f, -0.24412653f, -0.00289157f, -0.06776361f, 0.09702431f, -0.00967527f, 
    0.20683612f, 0.02845527f, 0.09644303f, -0.18082511f, 0.14218134f, 0.00656522f, -0.06465805f, -0.00824886f, 
    -0.11120705f, 0.05702593f, -0.14847878f, 0.06939821f, 0.12855344f, 0.15342599f, -0.13602883f, 0.13512529f, 
    0.04071859f, 0.03182751f, -0.10238509f, -0.15019862f, -0.16042149f, -0.19044408f, 0.00501570f, -0.10549770f, 
    -0.13766834f, 0.13201302f, 0.04367622f, 0.33958170f, -0.03982972f, -0.20725384f, -0.00939484f, -0.00105071f, 
    0.02196525f, 0.21092458f, -0.09287413f, 0.05148213f, -0.06009255f, 0.00288882f, 0.10020068f, -0.09565512f, 
    0.11735133f, -0.10168487f, 0.09003630f, -0.13620555f, -0.03534069f, 0.05954611f, 0.04728292f, 0.00767628f, 
    -0.13203721f, 0.12093445f, 0.07350133f, -0.02329524f, -0.06555068f, 0.10638884f, 0.16377237f, 0.00922825f, 
    -0.11062940f, 0.09586681f, 0.21096328f, -0.03302766f, -0.09764506f, -0.03904775f, 0.03895136f, -0.03479799f, 
    -0.01979349f, 0.04263749f, -0.11308451f, -0.08270586f, -0.05880043f, -0.07561594f, 0.11444157f, 0.08773174f, 
    -0.13297899f, 0.11325453f, 0.03340383f, 0.20241578f, 0.21743548f, -0.03893720f, -0.02582351f, 0.00494147f, 
    0.10177138f, -0.01069775f, -0.02478591f, 0.14068621f, 0.10082064f, 0.20435426f, 0.14042322f, 0.28954315f, 
    0.07793825f, -0.01644923f, -0.10674843f, 0.02787200f, -0.12244399f, 0.02134257f, 0.15403272f, 0.09957153f, 
    -0.06360521f, -0.28381091f, -0.09161008f, -0.08479985f, 0.04454987f, 0.12123594f, 0.07825478f, -0.10594638f, 
    0.09390040f, -0.12509695f, -0.05405402f, -0.01821030f, 0.22560605f, 0.04056719f, -0.19175541f, -0.03977171f, 
    -0.01758749f, -0.02955987f, 0.15145506f, -0.00181038f, -0.08329737f, 0.06487025f, -0.02473131f, -0.04108852f, 
    -0.11921628f, 0.07063135f, 0.09885887f, 0.17060536f, 0.01798498f, -0.02900810f, 0.01084933f, 0.14928687f, 
    -0.05872527f, 0.01708937f, 0.02158813f, -0.15354814f, 0.14428273f, -0.18682498f, 0.08700819f, 0.32328331f, 
    0.03478190f, 0.06607965f, 0.07894500f, -0.05373059f, 0.06050929f, 0.07396717f, -0.07951430f, 0.01713291f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.12976928f, 0.07221155f, 0.03597121f, -0.11945949f, 0.01541223f, 0.01584880f, -0.03878959f, 0.00583924f, 
    -0.07885384f, 0.04107393f, 0.11819176f, -0.12006351f, -0.05008943f, -0.03710511f, -0.05586319f, -0.08753254f, 
    0.09484420f, -0.04457946f, 0.10046547f, 0.05193631f, -0.03483135f, 0.12623698f, -0.02016837f, -0.01365038f, 
    0.03862596f, 0.12721704f, 0.02958989f, 0.11014704f, -0.03777029f, 0.01423922f, -0.06562150f, -0.01635429f, 
    -0.03639813f, 0.09419180f, 0.05964356f, 0.03423062f, 0.18883352f, 0.06192354f, 0.01020347f, -0.06265882f, 
    0.23543933f, 0.04262735f, 0.03948372f, -0.02520411f, -0.00112786f, 0.04430557f, 0.06870747f, 0.07442970f, 
    0.17138165f, 0.00485385f, 0.20481409f, 0.08916414f, 0.00040807f, 0.05101957f, 0.02199590f, -0.10802183f, 
    0.09836134f, -0.08906248f, 0.05014775f, -0.01775898f, -0.11265431f, -0.05028686f, 0.07432660f, -0.07623524f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.15809414f, -0.31707153f, -0.07479040f, -0.24875042f, 0.15621245f, 0.15939111f, 0.09743191f, -0.11581937f, 
    0.09046196f, 0.23391366f, -0.35887614f, -0.16147923f, 0.61317968f, -0.09558062f, 0.02706995f, -0.00879089f, 
    -0.65454191f, 0.14800596f, -0.39499837f, -0.02746704f, 0.05226050f, 0.46654117f, 0.26026690f, -0.02109398f, 
    -0.11556115f, 0.06317203f, -0.10375954f, -0.10851666f, 0.05134306f, -0.00580649f, 0.09097826f, 0.02799975f, 
    0.06229844f, -0.10205276f, -0.22988845f, -0.11738862f, -0.21032003f, 0.12778902f, -0.51950365f, 0.10161672f, 
    -0.23134762f, 0.26641572f, 0.03243402f, -0.44367108f, 0.10557641f, 0.07709468f, -0.27500364f, 0.34471637f, 
    -0.39885163f, 0.08712305f, -0.13776343f, 0.10053687f, 0.10175802f, 0.10138804f, 0.01977682f, -0.04375650f, 
    -0.01255490f, 0.26995301f, 0.01928659f, -0.13836427f, 0.15242954f, 0.19975968f, -0.24560021f, 0.00840764f, 
    -0.16447024f, -0.24603923f, 0.07454616f, 0.22332926f, 0.01237639f, 0.05490313f, 0.23852667f, 0.01634007f, 
    -0.37127590f, 0.11936539f, 0.02921670f, -0.17918912f, -0.74685901f, 0.09102426f, -0.10849007f, -0.31404185f, 
    -0.12016818f, 0.11462628f, -0.40944290f, -0.06363839f, 0.01497778f, -0.09866394f, 0.18237247f, -0.02517384f, 
    -0.48246449f, 0.02469853f, 0.02672491f, -0.19357771f, 0.03475878f, -0.01791081f, 0.00677871f, -0.11209275f, 
    0.03376571f, 0.61395103f, -0.19427507f, 0.32449046f, 0.21240467f, 0.30060765f, 0.38332820f, 0.04096554f, 
    0.19218153f, -0.12910536f, 0.11806953f, 0.15157869f, 0.06026540f, 0.01946949f, -0.13387689f, -0.36230880f, 
    -0.35516152f, 0.21307331f, 0.09378989f, 0.20828077f, -0.05744737f, -0.01509207f, -0.08744095f, 0.12341136f, 
    0.22580117f, 0.21318661f, 0.09704233f, -0.05017619f, 0.12594712f, -0.61163282f, 0.04950454f, -0.31634891f, 
    -0.20321803f, 0.06831907f, -0.46768549f, 0.41459271f, -0.12569346f, -0.31819785f, 0.16312741f, -0.01123929f, 
    0.10983481f, -0.14261539f, 0.37623924f, -0.07883482f, -0.28859639f, -0.07898661f, -0.00544729f, 0.11698490f, 
    0.18598817f, -0.05845796f, 0.23713386f, 0.19212243f, 0.00477588f, 0.11143748f, 0.24989781f, 0.05938368f, 
    -0.41390222f, 0.13232222f, 0.02797754f, -0.52586710f, 0.09064236f, -0.00206128f, 0.03032505f, 0.11731144f, 
    0.11284259f, -0.23278187f, -0.27968621f, 0.01708173f, -0.05706782f, -0.04003150f, -0.75708240f, -0.00113771f, 
    -0.53027868f, -0.52469605f, -0.42590833f, 0.33903310f, -0.00924271f, -0.07819784f, 0.32328147f, -0.36364186f, 
    -0.09401265f, 0.16474938f, -0.39189607f, -0.01154908f, 0.07345247f, -0.00543853f, -0.08607033f, -0.56433457f, 
    -0.36629474f, 0.09611712f, 0.06470888f, 0.07900045f, 0.26584816f, 0.15990934f, -0.42588204f, 0.13374439f, 
    -0.07695398f, -0.41562030f, 0.08945505f, 0.26770902f, -0.12194470f, 0.15130994f, -0.27545807f, -0.00774821f, 
    0.19164802f, -0.03592993f, 0.03307673f, -0.20888928f, 0.23729065f, 0.08344475f, -0.11107349f, 0.21562220f, 
    0.19525108f, 0.01322986f, -0.27339619f, 0.09421815f, 0.03904687f, 0.02092856f, 0.07404218f, -0.03696228f, 
    0.36748755f, -0.62689257f, -0.07292259f, 0.21742395f, 0.09111456f, 0.07980193f, 0.10615667f, -0.01029442f, 
    -0.05005612f, -0.32448232f, 0.18672557f, -0.34537581f, 0.20319088f, -0.01545361f, -0.04508196f, -0.10034422f, 
    0.23209909f, -0.43877304f, -0.61817390f, -0.27728719f, -0.04051125f, 0.07160988f, -0.45531049f, 0.42579597f, 
    0.01213007f, -0.23687467f, -0.14375882f, -0.26229581f, -0.03756716f, 0.00425667f, 0.22492260f, -0.20961580f, 
    0.27754271f, 0.19325106f, 0.02843957f, -0.02622493f, -0.59671295f, 0.31826106f, 0.19810380f, 0.18178715f, 
    0.16960818f, 0.00718290f, 0.27352676f, -0.14112890f, -0.21325682f, -0.38595816f, -0.00156924f, -0.04375274f, 
    -0.12953290f, -0.15600507f, 0.14585654f, 0.19417302f, -0.16830717f, 0.09738947f, 0.08866654f, 0.23129050f, 
    0.03918745f, 0.15784287f, 0.21656388f, -0.04983685f, 0.05084368f, -0.11730018f, 0.05991896f, -0.00613436f, 
    0.03411996f, -0.00892188f, 0.05707107f, -0.16790016f, -0.05466941f, 0.08946222f, 0.06373502f, 0.10807724f, 
    -0.09985341f, 0.52348566f, 0.07953522f, -0.41115358f, -0.30593574f, -0.23365892f, 0.31127778f, -0.01440875f, 
    0.18849385f, 0.05458169f, 0.16388509f, -0.55758840f, -0.03888345f, 0.10923457f, 0.17400046f, 0.07730250f, 
    -0.18221538f, -0.28004256f, -0.00146084f, 0.02195252f, -0.07628956f, 0.08803866f, 0.35796654f, -0.39297697f, 
    -0.32148615f, 0.22258323f, -0.03482553f, 0.04271595f, -0.07006730f, -0.08578625f, -0.23267426f, 0.29060438f, 
    -0.01941651f, 0.23686235f, -0.46866190f, -0.58422339f, 0.23907065f, 0.00103532f, -0.22233722f, 0.01702155f, 
    0.06733455f, 0.18324998f, -0.35913998f, 0.27062351f, 0.13898772f, 0.03293541f, 0.04060127f, -0.43934214f, 
    -0.46736103f, -0.05113917f, 0.34436041f, 0.05646402f, 0.05359194f, -0.77698261f, -0.03235251f, 0.11494041f, 
    -0.03528055f, -0.06654324f, -0.09152164f, -0.04251235f, 0.01024172f, -0.06836169f, 0.08904645f, 0.03460499f, 
    0.09013180f, -0.19415386f, -0.31513926f, 0.14053693f, 0.19375849f, 0.27445006f, 0.09415133f, -0.00411863f, 
    0.29010561f, 0.21123520f, 0.33800477f, 0.22177240f, 0.03787711f, -0.09165622f, -0.09492943f, -0.32532531f, 
    -0.06946054f, -0.08094579f, 0.28046900f, 0.01116949f, 0.13757804f, -0.00526385f, 0.16235328f, 0.24350961f, 
    0.18992919f, 0.15030116f, 0.11441581f, -0.01554148f, -0.14095506f, 0.19291350f, 0.02055717f, -0.24749580f, 
    -0.01588248f, 0.21109699f, 0.25934163f, 0.22788617f, 0.22003773f, -0.33478448f, 0.03892701f, -0.02486117f, 
    0.28391474f, 0.31917801f, 0.29416043f, -0.20431700f, -0.47348240f, 0.08889298f, -0.00839108f, -0.05207986f, 
    0.19032514f, -0.15678848f, 0.10310684f, -0.57507110f, -0.09981017f, -0.29011872f, -0.07810026f, -0.05388448f, 
    0.21292691f, 0.04643979f, 0.08744756f, 0.31497627f, 0.01346391f, -0.04009400f, 0.06610947f, -0.01397172f, 
    0.07895220f, -0.26277831f, -0.14436132f, -0.23189174f, -0.35627225f, -0.35451329f, -0.80440921f, 0.10852055f, 
    -0.28973776f, 0.21343939f, 0.30511418f, 0.29230103f, -0.01279567f, -0.05127851f, 0.21631917f, 0.21359119f, 
    0.01328248f, 0.17865404f, -0.12185413f, -0.41715544f, 0.07949969f, 0.02505598f, 0.18133415f, -0.59308755f, 
    0.08886422f, -0.72133410f, -0.00779890f, 0.09506202f, -0.15158857f, -0.35318413f, 0.35901171f, -0.17080773f, 
    -0.47984302f, 0.09626888f, 0.09180608f, 0.02777039f, -0.48989174f, 0.12525879f, -0.02498832f, -0.02679994f, 
    0.28385061f, -0.00859118f, -0.45245939f, 0.17339736f, 0.12560669f, 0.09582627f, -0.02129817f, 0.20764728f, 
    0.12473909f, -0.00342693f, 0.27166742f, 0.18718183f, -0.02498106f, -0.01109698f, -0.33201224f, 0.03281975f, 
    -0.13711898f, -0.10100695f, 0.08466300f, 0.25652599f, -0.05678099f, -0.08394329f, 0.12456350f, 0.08693795f, 
    -0.00657066f, -0.06481751f, -0.49441341f, -0.19384119f, -0.18766370f, -0.03912854f, 0.27994546f, -0.08192766f, 
    -0.10318135f, -0.24754634f, -0.09377769f, 0.02349707f, 0.05986072f, -0.09625115f, -0.09916858f, -0.37833816f, 
    0.19049834f, -0.21625786f, -0.40212432f, -0.31419107f, -0.04461735f, 0.10930299f, 0.05450712f, 0.32600719f, 
    -0.54502666f, -0.32976708f, -0.06289455f, -0.07643833f, 0.14825177f, 0.08977546f, 0.11852569f, 0.25568384f, 
    -0.31788608f, -0.21371405f, 0.05204047f, -0.36877674f, 0.37180328f, -0.00032396f, 0.25197977f, 0.03383187f, 
    0.10773562f, -0.43747273f, -0.25133967f, 0.34806341f, -0.45694751f, -0.12405838f, -0.07223606f, -0.24419400f, 
    0.25535652f, -0.20045210f, 0.08259825f, 0.13281024f, -0.00866933f, -0.26471111f, -0.16376175f, 0.07820489f, 
    -0.40335354f, -0.03595729f, -0.09620735f, -0.31476265f, 0.04339869f, 0.09118285f, -0.11998587f, -0.04326373f, 
    0.02771251f, -0.36300349f, 0.41177937f, -0.11556702f, 0.18979847f, 0.22656469f, -0.26125821f, 0.02938155f, 
    -0.13413060f, -0.19082694f, 0.02251660f, 0.26616818f, -0.12136088f, 0.05537518f, -0.20486765f, 0.26735544f, 
    0.11216535f, 0.21502125f, -0.34043491f, 0.27791446f, 0.03589683f, 0.03799054f, -0.50135839f, -0.20801944f, 
    -0.25681192f, 0.11622471f, 0.10596595f, -0.09217245f, 0.15841050f, -0.62546289f, -0.38238844f, 0.10325760f, 
    0.38959387f, 0.38119361f, -0.21249001f, -0.22780165f, -0.25744316f, -0.27470511f, 0.27720168f, -0.10618753f, 
    -0.62746012f, -0.08252405f, -0.22309403f, -0.14303599f, 0.23869012f, -0.06836269f, -0.01696575f, -0.42598251f, 
    0.30209449f, 0.28218284f, 0.08058537f, -0.12454733f, -0.02862818f, 0.10835329f, -0.51957846f, -0.05575877f, 
    0.13459300f, 0.13664217f, -0.02598036f, 0.38746667f, -0.04590211f, 0.09624668f, 0.03386841f, 0.09417325f, 
    0.02940368f, -0.61379713f, -0.08757339f, -0.16665940f, -0.23515567f, -0.69329005f, -0.01130874f, 0.03992565f, 
    0.00064580f, 0.15857661f, -0.96601862f, 0.12819681f, -0.06661587f, -0.04930279f, 0.27278504f, -0.30301708f, 
    0.00190968f, -0.12037456f, 0.27276456f, -0.28433570f, -0.10597385f, 0.02964864f, -0.18396804f, 0.24211192f, 
    -0.19721813f, -0.15896887f, -0.08241647f, -0.09602300f, 0.13976854f, 0.39253923f, -0.04439091f, 0.20351477f, 
    -0.01716193f, 0.23187864f, -0.30457595f, -0.24543662f, -0.54430467f, 0.09490918f, -0.16982876f, -0.08923070f, 
    0.12610544f, -0.02889527f, 0.37571585f, -0.53202069f, 0.18034916f, -0.00791035f, 0.01850380f, 0.08218530f, 
    0.27319294f, -0.51324600f, 0.04085948f, 0.31215131f, 0.02554950f, 0.23302354f, 0.25989178f, -0.01800765f, 
    -0.31797478f, -0.11759452f, -0.08817928f, 0.21742190f, 0.02697730f, 0.10581136f, 0.06214940f, -0.08400692f, 
    -0.10502237f, -0.41821840f, -0.07124659f, 0.17486727f, 0.41100457f, -0.11206647f, -0.29950309f, -0.00229278f, 
    0.27045465f, -0.02038313f, -0.02243010f, -0.41042694f, -0.09595139f, 0.02154965f, 0.03431995f, 0.19155641f, 
    0.33049634f, -0.18779917f, -0.06809025f, 0.23932979f, -0.07840943f, 0.03211387f, -0.20656663f, -0.05386794f, 
    0.01539184f, -0.65590000f, -0.10964671f, 0.05980016f, -0.17655456f, -0.20891733f, -0.12620680f, -0.44031620f, 
    0.00619094f, -0.24852331f, 0.22334740f, 0.12463230f, -0.03629284f, 0.30709577f, -0.37635925f, -0.06801465f, 
    0.05976008f, -0.24771339f, 0.15558568f, -0.19924885f, -0.23921503f, -0.09277496f, 0.01522716f, 0.13027707f, 
    -0.00429085f, -0.77292919f, -0.38133594f, -0.15253495f, 0.08949450f, 0.36042944f, -0.50529408f, -0.05409791f, 
    0.30111206f, 0.21637155f, -0.06797936f, -0.51894265f, -0.00893500f, -0.09086087f, -0.11637624f, 0.04647207f, 
    0.11319652f, -0.57131428f, 0.36809382f, 0.00124901f, -0.25959724f, -0.15942442f, 0.04956969f, -0.08276328f, 
    -0.21215844f, -0.09252290f, 0.17887533f, 0.09545785f, -0.09488317f, -0.11402782f, 0.07515665f, 0.05523078f, 
    0.35152742f, -0.21573351f, 0.36396676f, -0.06994042f, 0.04904862f, -0.02115096f, 0.06018017f, 0.11920631f, 
    0.16314188f, 0.29906398f, 0.04953470f, 0.03036469f, 0.14500041f, -0.17454547f, 0.31773308f, 0.03425352f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.14134474f, 0.03043481f, -0.15476370f, -0.19361608f, 0.09647401f, 0.15142033f, 0.01177566f, -0.01827849f, 
    -0.02625325f, -0.00159776f, 0.22423741f, -0.06589424f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
