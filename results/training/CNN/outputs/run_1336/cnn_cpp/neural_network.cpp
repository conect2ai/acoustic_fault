#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.14865039f, 0.29539204f, -0.02953946f, 0.16839020f, 0.20320201f, -0.02011596f, -0.35800710f, -0.00691082f, 
    0.44022158f, 0.76936960f, 0.39606127f, 0.53519034f, -0.47172722f, -0.55437124f, -0.36999819f, -0.41463751f, 
    -0.06526115f, -0.32432732f, 0.46089485f, -1.21091616f, -0.72678834f, -0.60642868f, -0.56351209f, -0.72168213f, 
    -0.29030669f, -0.11674727f, 0.18505797f, -0.99826723f, -0.12713961f, 0.97510302f, -0.54953659f, -0.70730287f, 
    -1.08192694f, -0.12566346f, -0.84038138f, -0.61034244f, -1.19254339f, -0.14708786f, -0.10381688f, -0.80976021f, 
    -0.87910968f, -0.45373759f, 0.03323914f, 0.06008988f, 0.06120869f, -1.05430758f, -0.29645798f, 0.86795908f, 
    0.01177190f, -0.04012109f, 0.68314809f, -0.13719268f, -0.08716943f, 0.06182670f, 0.91170883f, -0.45365357f, 
    -0.67114818f, 0.17325248f, 0.36281905f, 0.29019094f, -0.37476674f, 0.71671605f, -0.48292503f, -0.31275919f, 
    -0.09711292f, 0.12638108f, -0.60094076f, -0.25525311f, -0.42536193f, -0.47981077f, -0.58162755f, 1.00053036f, 
    -1.15794098f, 0.49684989f, -0.96332508f, -0.25686976f, 0.40866238f, 0.95086247f, -0.12581760f, 0.05182927f, 
    -0.02210139f, 0.84118497f, -1.27147186f, -1.01865470f, 0.74647003f, 0.81075346f, 0.44978318f, -0.20146671f, 
    -0.25472629f, -0.18840717f, -0.87868524f, -0.55618894f, -0.06438538f, -0.37300286f, 0.34053364f, -0.94508779f, 
    0.01376766f, 0.15201487f, -0.02055187f, 0.09062944f, 0.35587311f, 0.56630969f, 0.58121467f, -0.41251063f, 
    -0.61001474f, 0.21265818f, -0.34487852f, -0.12120732f, -1.46243548f, 0.55055004f, -0.38872916f, 0.10322542f, 
    0.69823229f, 0.35406274f, -0.03248206f, -0.18958251f, -0.04481540f, -0.55009371f, -0.55847853f, 0.63812816f, 
    -0.37179354f, 0.44974762f, -0.23184806f, 0.31478605f, 0.20274056f, 0.33496577f, -0.74061644f, 1.05199432f, 
    -0.24062411f, -0.36471006f, 0.20766978f, 0.10204691f, 0.50291371f, -0.32446837f, -0.04224686f, 0.17012714f, 
    0.62933195f, 0.21167785f, 0.46829963f, 0.44165218f, 0.50456446f, -0.30485365f, -0.05076146f, -0.39349002f, 
    -0.99409348f, -0.40423638f, -0.59809148f, 0.65737647f, 0.69051605f, 0.15811111f, -0.08338757f, 0.40069294f, 
    -0.12226553f, -0.08402267f, 0.46031773f, -0.24273384f, -0.58675963f, -0.34496126f, 0.01939856f, 0.42613912f, 
    0.46113005f, 0.35979530f, 0.69618702f, 0.97826058f, 0.23936799f, -0.23491234f, -0.77460390f, -0.37696105f, 
    -0.28426984f, 0.04999612f, 0.62227058f, 0.46991983f, -1.37127101f, -0.24610238f, -0.47203028f, -0.33025041f, 
    0.41807163f, 0.43330392f, 0.27354667f, 0.13366175f, 0.24073429f, 0.11323001f, 0.01208640f, 0.04059383f, 
    -0.21375275f, 0.42945844f, 0.05420592f, 0.04435461f, 0.43162602f, -0.37574378f, -0.43820876f, -0.34162971f, 
    0.32732797f, -0.34520656f, -0.10542260f, 0.20500824f, 0.54703468f, 0.19301631f, -1.20775759f, -1.09300315f, 
    -0.41298330f, 0.43161225f, 0.41198725f, -0.54212499f, -0.19895098f, -0.55883884f, -0.68341887f, -1.27817452f, 
    1.11655939f, 0.04704638f, -0.25036061f, 0.93084210f, -0.84340775f, 0.04033000f, 0.18078329f, -0.19174428f, 
    0.42251775f, -0.67635149f, 0.76477128f, -0.48235002f, -0.36778241f, -0.62910885f, 0.12575571f, -0.30220866f, 
    0.41987601f, 0.08075099f, 0.90835434f, -0.58726788f, -0.83423173f, 0.07769522f, 0.73587090f, 0.20575008f, 
    -0.04284471f, -0.30625716f, 0.70247132f, -0.33550856f, 0.01420034f, -0.18712237f, 0.17741580f, 0.44627991f, 
    -0.06917714f, -0.35088554f, -0.11324307f, -0.68322808f, -0.87651348f, -0.26900977f, -0.05322346f, 0.16318011f, 
    0.47658619f, 0.31982750f, 0.02738487f, 0.25114983f, 0.29767889f, -0.17437117f, 0.03859410f, 0.63482040f, 
    0.36322883f, 0.50751293f, 0.05875558f, -0.09445371f, 0.11870462f, -0.09568588f, -0.82908976f, 0.95702296f, 
    -0.99658746f, -1.12308466f, -0.85776174f, 0.17126122f, 0.43171448f, 0.03763897f, -0.18887395f, -0.31314191f, 
    -0.77913296f, -0.10837879f, -0.74776340f, -0.36315179f, 0.01787982f, 0.83654344f, -0.21442626f, 0.89440322f, 
    0.14557238f, -0.66774720f, 0.23214513f, -0.12494770f, 0.16382597f, -0.28463519f, 0.38495016f, 0.01232463f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.39284179f, 0.14371747f, 0.32019922f, -0.02807049f, -0.34508210f, -0.08471144f, 0.21340644f, 0.00838186f, 
    0.28588068f, 0.25833350f, -0.32413137f, 0.30859953f, 0.11530875f, 0.05635022f, 0.18583605f, -0.35383809f, 
    0.13498431f, -0.01738224f, 0.20187937f, 0.39278939f, 0.09761123f, 0.32398298f, -0.15515378f, 0.11807936f, 
    0.15350291f, 0.16969746f, 0.52011967f, 0.36244094f, -0.20826134f, 0.06050804f, -0.08376410f, 0.40418825f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.13863505f, -0.22166505f, -0.07930508f, 0.03068251f, 0.04485827f, 0.01136206f, -0.07595564f, -0.01971659f, 
    0.03609968f, -0.03983821f, -0.07225017f, 0.02044505f, -0.06234480f, -0.03854507f, -0.08858284f, -0.07965892f, 
    -0.04019008f, -0.04462139f, -0.02125851f, -0.04349464f, -0.58783722f, 0.46670544f, 0.01553415f, -0.17063425f, 
    0.06599081f, 0.04575888f, -0.06706537f, -0.18457757f, -0.00261157f, 0.06430135f, 0.02407150f, -0.04194743f, 
    0.00515515f, 0.05304437f, 0.07049319f, 0.13861181f, 0.09932831f, 0.03382975f, 0.01950634f, 0.06144352f, 
    0.23340397f, 0.24081026f, -0.00684010f, -0.34764621f, -0.19187763f, 0.14966281f, 0.06638253f, 0.16006868f, 
    -0.25050932f, 0.01920250f, -0.05817544f, -0.00139894f, -0.04148716f, 0.01793983f, 0.01229162f, -0.01164274f, 
    -0.01127543f, -0.00991683f, 0.24182002f, 0.06583193f, 0.39131168f, 0.38309944f, 0.12646353f, -0.62230307f, 
    0.16448024f, -0.00390888f, 0.13719238f, -0.10607412f, -0.01824957f, 0.03324093f, 0.01052278f, -0.04124278f, 
    -0.06340946f, 0.03110888f, -0.02810832f, 0.03959025f, -0.15773313f, -0.00702372f, 0.21169296f, 0.16475484f, 
    0.29662865f, 0.43770599f, 0.17458494f, -0.34622973f, -0.07147114f, 0.08485840f, 0.24824916f, 0.15643103f, 
    0.09155384f, -0.04756034f, 0.01754438f, -0.03485364f, -0.05840858f, -0.01473182f, -0.02011917f, -0.02994807f, 
    -0.05154888f, 0.02866063f, -0.17119353f, -0.04331498f, -0.05695647f, -0.12673736f, 0.32650718f, -0.06059071f, 
    0.11236144f, -0.02758835f, 0.00762777f, 0.12754355f, 0.11294816f, 0.11332329f, 0.03196859f, -0.02149550f, 
    -0.06498383f, 0.03738261f, -0.18011515f, 0.03250067f, -0.02313793f, 0.06799375f, -0.00852115f, -0.04190422f, 
    -0.20381162f, -0.49338731f, -0.32501203f, 0.13170798f, -0.04048963f, -0.00479538f, -0.05518869f, -0.02762349f, 
    -0.07084364f, 0.03334595f, -0.12000371f, 0.08814902f, -0.26047769f, -0.17031212f, -0.19078858f, 0.01339320f, 
    0.07162968f, 0.07782008f, -0.02852093f, 0.08791264f, 0.10300522f, 0.33766949f, 0.04521233f, -0.33194327f, 
    -0.19857801f, 0.16179368f, -0.02860691f, 0.11580016f, -0.02435305f, -0.05182928f, 0.00526760f, -0.03506867f, 
    0.04131733f, 0.04103340f, -0.05197883f, -0.05748970f, -0.11799616f, 0.04357286f, -0.11475910f, -0.57671148f, 
    0.03206331f, -0.24602035f, 0.05327356f, 0.05374236f, 0.06887218f, 0.07360964f, 0.12823455f, 0.10763177f, 
    -0.06725257f, -0.00374663f, -0.04272129f, -0.06837195f, -0.01211117f, 0.06082935f, 0.05984054f, 0.02178322f, 
    0.05120645f, -0.02702528f, -0.05857393f, -0.03376473f, 0.52132994f, -0.54321218f, -1.11884689f, 0.16289704f, 
    0.00687541f, 0.09098979f, -0.07240115f, 0.08255031f, -0.11912598f, 0.03372823f, -0.01620941f, 0.06814134f, 
    -0.09870863f, -0.06316248f, -0.05651904f, -0.00762624f, 0.12794687f, 0.02997387f, 0.01280014f, 0.00287733f, 
    0.51932216f, 0.39033547f, 0.01049609f, -0.35232314f, -0.12421621f, 0.07600541f, 0.14230125f, 0.31914651f, 
    0.03282504f, 0.15266764f, 0.01078188f, -0.05386406f, -0.03758782f, -0.02815104f, 0.00598165f, -0.03148058f, 
    -0.06986501f, -0.17092775f, -0.07098403f, 0.01654919f, -0.45713481f, -0.05847095f, -0.58241534f, -0.07171483f, 
    0.09465034f, -0.05806668f, -0.03475150f, -0.05254820f, 0.01695455f, 0.09076158f, -0.02666462f, 0.00053840f, 
    0.04921878f, 0.06484082f, 0.04962909f, -0.04331679f, -0.00657972f, 0.02644676f, 0.00880058f, 0.03187400f, 
    -0.10979841f, -0.13918236f, 0.01537650f, -0.01823398f, 0.09343266f, -0.02378949f, 0.02101052f, 0.07356850f, 
    0.11490079f, -0.09842077f, -0.04517895f, 0.00621453f, 0.01446849f, -0.02444380f, 0.07645608f, -0.00776932f, 
    0.06541810f, 0.04754151f, -0.05397047f, -0.02160469f, 0.05101251f, 0.13445918f, 0.13279685f, -0.05428201f, 
    0.00822683f, -0.01176319f, 0.02215885f, 0.09462849f, 0.03026107f, -0.00481054f, -0.02240098f, -0.01846293f, 
    -0.08265839f, -0.00415529f, -0.01341639f, 0.03927305f, -0.04682330f, -0.12146606f, -0.04643258f, 0.03133911f, 
    -0.23798598f, -0.10297027f, 0.12459201f, 0.06533108f, 0.02635234f, -0.05152738f, -0.09939048f, 0.00945566f, 
    0.06103241f, 0.00843239f, -0.08227900f, -0.16575553f, -0.17478074f, -0.24075246f, -0.11278769f, -0.12792711f, 
    -0.04266945f, 0.04915203f, -0.16696006f, -0.11070514f, -0.12140399f, -0.13874969f, -0.14420995f, -0.04402052f, 
    -0.10001138f, 0.07725107f, 0.06176494f, 0.07711747f, 0.10953249f, 0.09376290f, 0.06400251f, 0.06398946f, 
    0.08972295f, 0.00692974f, 0.02527790f, -0.05824181f, -0.02520823f, 0.04477718f, 0.04262612f, 0.01441576f, 
    0.17633663f, -0.02845875f, -0.38305530f, 0.00132723f, 0.07631759f, 0.08465987f, 0.12876476f, 0.04488510f, 
    -0.00673227f, -0.00523280f, -0.11788297f, 0.05256528f, -0.01955090f, 0.00848791f, -0.00597687f, 0.02155641f, 
    0.05818045f, -0.00682000f, -0.04500595f, 0.03603019f, 0.10624160f, 0.04732499f, 0.02994760f, 0.05389430f, 
    -0.01898843f, -0.07477149f, 0.04700392f, 0.08288874f, 0.07998839f, 0.04685220f, 0.02946885f, 0.23322946f, 
    -0.05405477f, 0.02378510f, -0.01920403f, -0.03928333f, -0.00028997f, -0.00508363f, -0.06635194f, 0.01081845f, 
    -0.14044762f, -0.24779014f, -0.18982953f, -0.00519280f, -0.18318959f, 0.10028645f, -0.12888686f, -0.21473338f, 
    0.02843655f, -0.04372749f, -0.01214525f, 0.04931184f, 0.04729106f, 0.08738643f, 0.03256811f, -0.01143329f, 
    0.00420539f, -0.22422135f, 0.00582514f, -0.10504576f, 0.31787866f, 0.24225560f, -0.03343869f, -0.25909653f, 
    -0.00373698f, 0.03855423f, -0.10163656f, 0.19101541f, -0.07447745f, -0.11735561f, -0.10891185f, -0.07619214f, 
    -0.05696522f, 0.04085430f, -0.01490099f, -0.01497056f, -0.06374036f, -0.02542941f, -0.04678223f, 0.04102132f, 
    0.01773478f, -0.01416344f, 0.04837687f, 0.01135180f, 0.04022647f, -0.03067088f, -0.01097744f, 0.03869863f, 
    0.04985664f, 0.02498805f, -0.27979362f, -0.18470979f, -0.19239429f, -0.05076721f, -0.16705224f, -0.04907607f, 
    -0.12670188f, -0.08338501f, -0.01471090f, -0.07555960f, 0.26519141f, 0.18831865f, -0.02008202f, -0.03631763f, 
    0.01334122f, 0.00070762f, 0.06849717f, 0.09777539f, -0.23049504f, -0.25037676f, -0.07495988f, -0.18829539f, 
    0.01506892f, -0.02892860f, 0.03912374f, -0.07336635f, -0.11078604f, -0.08316454f, -0.06299493f, -0.00388987f, 
    0.59606844f, 0.23321341f, -0.04601141f, -0.38081366f, -0.14411773f, 0.10044618f, 0.21736485f, 0.22554976f, 
    0.06527810f, 0.11861784f, 0.00254384f, -0.03592121f, -0.09709138f, -0.07069398f, 0.02694316f, -0.03596924f, 
    -0.02241141f, -0.08106712f, -0.16857237f, -0.02195787f, -0.25562751f, 0.22721873f, -0.07136802f, 0.12076166f, 
    -0.09270075f, -0.34506556f, -0.00356713f, 0.07193644f, 0.08978111f, -0.09584813f, -0.11842279f, -0.07608360f, 
    -0.14741729f, -0.12580401f, -0.27992645f, -0.22524951f, -0.06403805f, -0.01396415f, -0.21315081f, -0.12665576f, 
    0.06765186f, 0.14476180f, 0.03497325f, -0.60742021f, 0.00286141f, -0.17565317f, -0.07690097f, -0.03834211f, 
    -0.18339112f, -0.01516072f, 0.02117431f, 0.00761632f, -0.02500003f, 0.02625835f, -0.05756490f, -0.04701411f, 
    -0.01486589f, -0.01522846f, -0.12728046f, -0.22575343f, -0.53099060f, -0.13249327f, 0.05863808f, 0.11937341f, 
    -0.55630082f, -0.11856724f, -0.01339762f, -0.16312043f, 0.05209509f, 0.03349971f, 0.01938378f, -0.07820383f, 
    -0.02375420f, 0.01484732f, 0.07177129f, -0.22860399f, 0.11712338f, -0.12932526f, -0.07033663f, -0.04640672f, 
    -0.34698218f, -0.33886623f, -0.22513230f, -0.06631918f, -0.20037901f, -0.06028419f, -0.06043732f, -0.04469527f, 
    -0.00034245f, 0.02902484f, 0.03220653f, -0.01139114f, -0.05104411f, 0.02521120f, -0.00678228f, -0.14980757f, 
    -0.00666644f, 0.01817348f, -0.03744925f, -0.05672378f, 0.15942189f, 0.13953404f, 0.04175171f, -0.02755530f, 
    0.07275003f, 0.09105548f, 0.06483552f, 0.16037764f, -0.01581258f, -0.25414121f, -0.13313980f, -0.15780908f, 
    -0.08911313f, 0.01778469f, -0.00380374f, 0.04517566f, 0.04347187f, -0.03262828f, 0.01599784f, -0.00748356f, 
    -0.02175884f, -0.05424952f, 0.00871539f, 0.03761495f, 0.04493926f, 0.06826679f, 0.00459364f, 0.05740840f, 
    0.06590276f, 0.07759463f, -0.03083373f, -0.29526594f, -0.05497923f, -0.16339743f, -0.14681873f, -0.02316357f, 
    0.06126130f, 0.02555228f, 0.03243656f, -0.02354819f, 0.22959636f, 0.42347160f, 0.03210918f, -0.65718520f, 
    -0.09174685f, -0.10280074f, 0.11152832f, -0.03923853f, -0.03838503f, 0.14576493f, 0.11449952f, 0.00137571f, 
    0.00091759f, -0.02565256f, -0.10781344f, 0.01105140f, -0.03101497f, -0.07074418f, 0.19990009f, -0.16445352f, 
    0.38222232f, 0.29897285f, -0.21227384f, -0.42441064f, -0.21718925f, 0.20544502f, 0.10483301f, -0.04519678f, 
    0.02466151f, 0.00904567f, 0.03564403f, 0.03262054f, 0.06976865f, 0.02752277f, 0.07674870f, -0.02222019f, 
    -0.09213165f, -0.03478055f, -0.00872074f, 0.11417472f, -0.31358725f, -0.19891384f, -0.19827355f, 0.13762760f, 
    -0.03542950f, -0.01419092f, -0.03019211f, -0.05342957f, -0.01011263f, 0.01979405f, -0.06782896f, 0.02814288f, 
    -0.16654482f, -0.11315060f, -0.01117792f, -0.02697634f, -0.08333808f, -0.21615775f, -0.00237706f, -0.00912676f, 
    0.03742037f, 0.00818905f, 0.06009858f, 0.06002560f, 0.12915449f, 0.04049726f, -0.04548359f, 0.03707626f, 
    -0.02916596f, 0.00365459f, 0.00361749f, 0.07845055f, 0.09242414f, -0.08536122f, 0.06003886f, 0.11042973f, 
    0.13360450f, -0.07074743f, -0.05069080f, 0.03148752f, 0.55988228f, 0.05376470f, -0.26222694f, -0.22812447f, 
    -0.19476402f, -0.04671582f, -0.11440957f, -0.12051206f, -0.08397824f, -0.11194131f, -0.05252175f, 0.02732447f, 
    0.05955176f, -0.00859505f, -0.02600163f, -0.00882463f, -0.13594015f, -0.26495990f, 0.02251730f, -0.05992583f, 
    -0.14037254f, 0.17168915f, -0.13625920f, 0.23846404f, -0.10399999f, -0.05783160f, 0.13513532f, 0.05733101f, 
    -0.23543835f, -0.00983538f, 0.02038166f, -0.02553975f, 0.07015358f, -0.02013076f, 0.05003680f, -0.03186979f, 
    0.07757939f, 0.08734132f, -0.21851215f, 0.06562337f, -0.38784763f, -0.12451126f, -0.34202644f, -0.29463467f, 
    0.05165147f, 0.26807502f, -0.27628478f, -0.06784885f, 0.07432291f, -0.05227028f, 0.04496669f, 0.06562769f, 
    0.09944233f, -0.06280772f, 0.06212078f, -0.16224650f, -0.12468676f, -0.11084186f, -0.35462111f, -0.46072146f, 
    -0.34492069f, 0.25786969f, 0.05929405f, 0.33855826f, 0.19787197f, -0.07337138f, 0.09478907f, -0.22454321f, 
    0.07074752f, -0.04670274f, -0.02163008f, 0.02263949f, 0.01512997f, 0.00172743f, 0.06254429f, -0.00970811f, 
    0.01050202f, 0.07242294f, -0.24245216f, 0.02389535f, -0.12011547f, -0.25080690f, 0.01629531f, -0.01850028f, 
    0.05615083f, -0.07297890f, -0.02955667f, 0.07592721f, -0.03216486f, 0.03937326f, -0.05174140f, -0.03411879f, 
    -0.22397332f, 0.18827380f, 0.03020392f, 0.06055722f, -0.00099135f, -0.03548869f, -0.03225513f, -0.08555605f, 
    1.07010627f, 0.05162678f, -0.10097849f, -0.00392341f, -0.13242410f, -0.01056524f, 0.04567608f, -0.03305595f, 
    -0.00500603f, 0.03120832f, 0.07340994f, 0.14852825f, -0.09165095f, -0.14919147f, 0.07859200f, -0.16898631f, 
    -0.00523146f, -0.04840439f, 0.07601868f, 0.05912170f, -0.05066084f, 0.09318794f, -0.16445555f, 0.20537347f, 
    -0.08172120f, -0.03650698f, 0.03158808f, 0.12482956f, -0.21291417f, -0.03424663f, -0.00913605f, 0.10905684f, 
    0.02513067f, -0.03238665f, 0.05427033f, -0.03205600f, 0.07402534f, -0.00567949f, -0.42818990f, 0.09651814f, 
    -1.07584810f, -0.55779678f, 0.01786423f, -0.04701364f, -0.15314932f, 0.06028585f, 0.02756195f, 0.16864440f, 
    -0.12271568f, -0.19644898f, 0.00759298f, 0.04139993f, -0.06795200f, -0.06159129f, -0.09527405f, 0.02040159f, 
    0.06702837f, 0.02421916f, 0.02903209f, 0.02481944f, 1.06608260f, -0.14398414f, 0.08890130f, 0.09209379f, 
    -0.29311004f, 0.01524100f, -0.04314708f, -0.02652961f, -0.03669623f, -0.05727600f, 0.17966507f, -0.28551450f, 
    0.00550933f, -0.01395154f, -0.01657869f, 0.03313416f, 0.01263800f, -0.13690495f, -0.00009990f, -0.01506183f, 
    0.26722234f, 0.29792580f, 0.09998070f, 0.14456527f, 0.21851738f, -0.16115308f, 0.13533737f, -0.04977709f, 
    0.10939252f, -0.13357492f, 0.03727983f, -0.01673216f, 0.00835079f, 0.04267910f, -0.04293515f, -0.00998874f, 
    0.04598736f, -0.07601442f, -0.11709062f, -0.19523098f, 0.12140680f, 0.12381100f, -0.15417488f, 0.16246669f, 
    0.15550248f, -0.05659627f, -0.10171878f, -0.09217175f, 0.02169107f, -0.02477818f, 0.00315056f, 0.08567940f, 
    -0.00067837f, -0.01644800f, 0.04573823f, 0.05775846f, -0.00075842f, 0.13305216f, 0.10068841f, -0.02699883f, 
    -0.39192039f, -0.35091776f, 0.03554343f, -0.04225507f, -0.01019758f, 0.10655016f, -0.03511875f, 0.03171920f, 
    -0.04565452f, -0.09612808f, 0.00698484f, 0.00910703f, -0.12886392f, -0.03784138f, 0.09601843f, 0.08954794f, 
    0.07045685f, -0.13206841f, 0.03155119f, 0.00649171f, -0.04368892f, -0.00812698f, -0.11297122f, -0.09414580f, 
    0.10412042f, -0.13958302f, 0.05607446f, 0.11812852f, 0.05187893f, 0.09844555f, -0.08886186f, 0.14456333f, 
    0.12885386f, -0.00460263f, -0.06140027f, -0.10259037f, 0.04106152f, 0.06957529f, -0.00487975f, 0.01962392f, 
    -0.16411577f, -0.20558880f, 0.09557326f, -0.06534585f, 0.07979438f, -0.05873972f, 0.04740656f, -0.11110502f, 
    -0.04694039f, 0.09751602f, 0.02584228f, 0.02927119f, 0.04664598f, 0.04969550f, -0.06174115f, 0.21496189f, 
    -0.03213779f, -0.11039591f, 0.04572553f, 0.00785005f, 0.16063944f, 0.05059465f, 0.13723397f, 0.13894793f, 
    0.16025656f, -0.06710630f, -0.03917373f, 0.02756146f, -0.02517499f, -0.06788775f, -0.05586172f, -0.00120620f, 
    -0.03208016f, -0.02970764f, 0.03656043f, -0.04579727f, -0.26354361f, -0.08578344f, 0.07824030f, -0.06292213f, 
    0.07904424f, -0.28826129f, -0.11537760f, 0.01297689f, -0.11397667f, -0.04257447f, -0.01097730f, 0.06202434f, 
    0.09170000f, -0.09783445f, 0.09707679f, -0.05505484f, -0.06941760f, -0.11220453f, 0.00253536f, 0.01037130f, 
    -0.01956980f, -0.10677294f, 0.02555883f, -0.01884062f, -0.14589156f, -0.14934662f, 0.00236922f, -0.06021070f, 
    -0.07503232f, -0.00300892f, 0.07679453f, -0.03162621f, 0.00789595f, 0.04557035f, 0.10206363f, 0.00221184f, 
    0.10907248f, 0.16554041f, 0.01223292f, -0.07606044f, 0.00607239f, -0.07340721f, 0.06028393f, 0.07635794f, 
    0.03582288f, 0.03151665f, -0.06232307f, -0.03713571f, 0.00139515f, 0.14687712f, -0.16287544f, -0.15884215f, 
    -0.05022842f, -0.02466466f, -0.03512876f, -0.03742908f, 0.05972322f, 0.08936074f, -0.03510970f, 0.03288023f, 
    0.18609568f, -0.17242606f, 0.03344164f, 0.15330164f, -0.28753561f, 0.02043571f, -0.18021421f, 0.03965013f, 
    0.14859761f, -0.07952946f, 0.29289800f, 0.15348420f, -0.20933723f, 0.12948379f, 0.05683216f, 0.01743311f, 
    -0.05109228f, 0.03469083f, -0.02141620f, 0.00777147f, -0.00313909f, 0.02475895f, -0.08464172f, 0.14719836f, 
    0.07439608f, -0.02216234f, 0.07571378f, -0.02323092f, 0.06873047f, -0.00978503f, -0.03355169f, -0.01084098f, 
    -0.04813970f, -0.03716205f, 0.17389071f, 0.10023267f, -0.01107158f, 0.02643821f, -0.06463551f, -0.20039566f, 
    -0.02707583f, -0.03547224f, 0.01112791f, 0.01896549f, -0.22605100f, -0.11031859f, -0.14408398f, 0.02920228f, 
    0.00133155f, 0.04312900f, 0.13390467f, 0.11223717f, 0.17842373f, -0.04317790f, -0.15117215f, 0.03608082f, 
    -0.01349300f, 0.06102500f, 0.02772518f, -0.04656883f, 0.07037136f, 0.07921854f, -0.02795177f, 0.03872672f, 
    0.48467234f, 0.33211738f, 0.41182882f, 0.02797459f, -0.07296374f, 0.08739048f, -0.09950186f, -0.00496109f, 
    0.30107239f, -0.10003994f, 0.06833068f, -0.03697558f, -0.01049969f, -0.17678684f, -0.04657483f, 0.11368988f, 
    -0.03229524f, -0.10463605f, -0.05683004f, -0.06444353f, -0.14758883f, -0.45860913f, -0.00422740f, -0.25993693f, 
    0.02951997f, -0.02804285f, 0.29307368f, -0.41475451f, 0.06199264f, 0.14467205f, 0.02233192f, -0.08632997f, 
    0.07041710f, 0.17576426f, -0.06006419f, -0.03569718f, -0.01886397f, -0.01522879f, 0.12962838f, -0.14563639f, 
    -0.18832760f, 0.41025826f, -0.36331064f, -0.27004328f, 0.07801498f, -0.33544821f, -0.08867639f, -0.03494731f, 
    -0.12558697f, 0.10702264f, -0.11557782f, -0.05461342f, 0.07856566f, 0.03830208f, 0.00345982f, 0.00497503f, 
    -0.03232759f, 0.04862272f, 0.01760901f, -0.05660006f, -0.64897329f, -0.30880463f, 0.50268579f, 0.07042066f, 
    -0.05597507f, 0.09175092f, 0.04926829f, 0.02411179f, -0.13183187f, 0.10138205f, 0.05489271f, 0.05125749f, 
    -0.04788705f, 0.14469698f, -0.09626827f, 0.00721248f, 0.02631175f, 0.11784863f, 0.09074344f, -0.03101547f, 
    0.50806624f, 0.23101224f, 0.15254185f, 0.22702187f, 0.13348374f, -0.00833647f, -0.02268842f, 0.00948787f, 
    -0.07777867f, -0.00582364f, -0.08978129f, -0.04370818f, -0.02012136f, 0.04673127f, -0.06629150f, 0.09781542f, 
    0.01498883f, 0.11783145f, 0.12191915f, -0.07020298f, -0.20107065f, -0.06384552f, -0.17190740f, -0.04350746f, 
    -0.05378282f, -0.00948386f, 0.10875782f, 0.15205577f, -0.03912285f, -0.03614639f, -0.03993529f, 0.05389611f, 
    0.08834627f, -0.07626258f, -0.06519716f, -0.05583530f, 0.01459667f, 0.06197739f, -0.01938029f, -0.00413931f, 
    0.29045868f, 0.01075241f, 0.13164079f, 0.11866628f, 0.03802625f, -0.08610593f, -0.10183790f, -0.04527006f, 
    -0.01036715f, -0.06239230f, 0.07690512f, 0.03229197f, 0.15110913f, -0.01410740f, -0.03567604f, -0.05815837f, 
    -0.08530886f, -0.10793111f, -0.06248977f, -0.09474448f, -0.50804400f, 0.29047984f, -0.33412781f, -0.25241253f, 
    -0.03802082f, -0.05663353f, -0.12019964f, -0.25612631f, 0.25461027f, 0.02809294f, -0.09011730f, 0.02793555f, 
    0.04762267f, 0.04699179f, 0.09682161f, 0.05114021f, -0.05982472f, 0.07541596f, -0.02945692f, -0.05986894f, 
    -0.15077865f, 0.12386788f, -0.25344664f, 0.31513694f, 0.08146366f, -0.22207044f, 0.16024727f, -0.18594152f, 
    0.12218827f, -0.13105077f, -0.04477395f, -0.01635349f, -0.09035313f, 0.00527912f, 0.03589180f, -0.02075882f, 
    -0.01197105f, -0.00839963f, -0.03238929f, 0.07637772f, 0.39812869f, 0.06064580f, 0.09751588f, -0.00916173f, 
    -0.01704094f, 0.04940832f, 0.01356150f, 0.04333748f, -0.02154158f, -0.01948501f, 0.00578114f, 0.01874912f, 
    -0.00938377f, 0.09160353f, -0.09338080f, -0.13258827f, 0.06816114f, 0.16404267f, 0.09512461f, -0.01194883f, 
    0.00190736f, 0.07955058f, -0.03938172f, -0.12201744f, 0.04808797f, -0.00819719f, -0.03804870f, 0.02767200f, 
    0.00256030f, 0.07041209f, 0.03806102f, -0.06752662f, 0.10826208f, 0.01163171f, 0.14423719f, 0.04859965f, 
    0.01493982f, -0.01958482f, 0.01484139f, 0.01573827f, -0.90200263f, -0.02541387f, 0.46543682f, -0.21451817f, 
    -0.13727193f, -0.03795125f, 0.08359146f, -0.05201650f, 0.07588034f, -0.00183803f, 0.02800741f, -0.03512297f, 
    -0.01178643f, -0.00926320f, 0.02320852f, 0.03290118f, 0.00378860f, 0.20370474f, -0.00339357f, 0.04601461f, 
    -0.09832945f, 0.05227629f, -0.01459253f, 0.34880605f, -0.54077828f, 0.08202828f, 0.13073397f, 0.10769638f, 
    0.03598976f, -0.10287601f, 0.01225166f, 0.07686212f, 0.04478670f, -0.05394750f, -0.10508314f, 0.01446512f, 
    0.05060790f, -0.05755318f, 0.00441490f, 0.04584368f, 0.15799336f, -0.11742243f, -0.27874979f, 0.06202798f, 
    -0.13561800f, -0.02592286f, -0.23944406f, -0.18661259f, 0.17467140f, 0.05439966f, -0.08502980f, 0.01364654f, 
    -0.00414289f, -0.02711097f, -0.08392711f, -0.08173969f, 0.13587992f, 0.22651385f, -0.07249600f, 0.06025914f, 
    -0.11670505f, -0.64367127f, -0.98349196f, 0.09280735f, -0.50470269f, -0.06755199f, 0.05133847f, -0.12134690f, 
    -0.01989477f, 0.06551473f, -0.05083389f, -0.02994352f, -0.06021534f, -0.01136925f, -0.02664259f, 0.00386363f, 
    -0.02521398f, 0.02934726f, -0.17058142f, 0.24897672f, 0.41431862f, -0.17790775f, -0.27293438f, 0.06406701f, 
    0.16040219f, 0.00997540f, 0.06548759f, 0.02515732f, -0.03570883f, -0.08572599f, -0.21061720f, -0.13944395f, 
    -0.03779137f, 0.03932700f, -0.28423417f, 0.04256257f, 0.00571841f, 0.10585220f, -0.11611518f, 0.03701870f, 
    -0.21309273f, 0.24684472f, 0.18729211f, -0.10221574f, 0.06532387f, -0.09638684f, -0.08004472f, -0.02309886f, 
    -0.06594566f, 0.20083314f, 0.17295672f, -0.05289364f, -0.29934222f, 0.26526788f, 0.16608684f, 0.08357278f, 
    -0.01895718f, -0.03921776f, 0.12229247f, -0.09355399f, -0.26488212f, -0.70296997f, -0.66596371f, -0.07738268f, 
    0.10906784f, -0.11494400f, -0.07567532f, 0.05695242f, -0.17609708f, 0.11822829f, -0.02281644f, -0.02573101f, 
    -0.00516489f, -0.10389400f, 0.00663107f, -0.00431428f, -0.00552683f, 0.02660329f, -0.13495073f, 0.05922069f, 
    -0.02057954f, 0.51695079f, 0.36299399f, 0.18483680f, 0.20787606f, -0.10001672f, 0.04068135f, 0.10117842f, 
    -0.07866434f, 0.02068316f, 0.05873778f, -0.07095817f, -0.03820504f, 0.03142785f, 0.21180426f, 0.00830316f, 
    0.06277217f, 0.04390026f, -0.00227404f, -0.00912141f, -0.22892159f, 0.20188108f, 0.85876095f, -0.05084048f, 
    0.17416044f, -0.10182743f, -0.06035788f, -0.00256108f, -0.02206076f, 0.11945447f, 0.10195646f, 0.05463658f, 
    0.02696946f, -0.09176746f, 0.04409389f, 0.01075802f, 0.02586035f, 0.04772046f, 0.11785345f, -0.10825372f, 
    0.11535014f, -1.15633106f, -0.05460552f, 0.14396869f, -0.68264633f, -0.01945966f, 0.06762803f, -0.31394747f, 
    0.26287004f, -0.10222346f, 0.00144846f, 0.00264190f, 0.00099850f, 0.02095285f, -0.02586524f, -0.00433465f, 
    0.01617579f, -0.05048545f, -0.02177925f, 0.02738988f, -0.30047005f, 0.12172955f, -0.07081215f, -0.56562895f, 
    0.04706643f, 0.08222792f, 0.00938945f, -0.05289107f, 0.07830802f, 0.02519567f, -0.00143178f, 0.03258178f, 
    0.03732738f, -0.01027855f, -0.01822651f, -0.00773186f, -0.01743139f, -0.05047310f, 0.04791695f, 0.08129584f, 
    0.13958684f, -0.14116466f, 0.23996101f, 0.06077227f, 0.21825126f, -0.02333513f, 0.02204038f, -0.00145071f, 
    0.00232427f, -0.14019780f, 0.02302618f, -0.04360311f, -0.01312652f, -0.00590020f, 0.02055421f, 0.08864205f, 
    -0.02885705f, -0.01883631f, -0.01432305f, -0.02042766f, 0.24004008f, -0.05075536f, -0.03190301f, 0.00490390f, 
    0.13203853f, -0.03729517f, -0.00517212f, -0.06489355f, -0.00800940f, 0.05306330f, -0.12008839f, -0.00317691f, 
    0.16646126f, 0.00861317f, -0.04136620f, -0.02180119f, -0.00214087f, -0.05155425f, -0.05901353f, -0.04300708f, 
    0.24696337f, -0.10696187f, -0.05780223f, -0.09982096f, 0.12003084f, 0.10128272f, -0.00801867f, -0.09624286f, 
    -0.08028097f, 0.01654891f, -0.06705914f, -0.14296935f, -0.06877673f, 0.21893974f, -0.06134352f, 0.08092368f, 
    0.02021297f, -0.11418533f, 0.07050200f, 0.09071111f, -0.16757394f, -0.27488497f, -0.31893918f, -0.25001577f, 
    0.00745354f, 0.00771021f, -0.04238909f, -0.01500053f, 0.02484868f, 0.06433048f, -0.01858470f, -0.04302880f, 
    -0.08445276f, 0.08228528f, 0.01473489f, 0.03359874f, 0.02905377f, 0.07541092f, 0.04395767f, 0.01135080f, 
    -0.02901975f, -0.25982448f, 0.49826682f, 0.10047330f, 0.21636161f, -0.01782781f, -0.02510340f, 0.06941715f, 
    0.13534406f, -0.13445221f, 0.07320777f, 0.04028504f, 0.01033351f, 0.08210712f, 0.01344844f, 0.08123507f, 
    -0.05097873f, 0.01615361f, 0.04029284f, -0.01406674f, -0.11213148f, -0.05854029f, -0.07033317f, 0.00592093f, 
    0.09675540f, -0.02246438f, -0.04021629f, -0.23953934f, -0.06591872f, -0.13060457f, -0.04307726f, -0.22908686f, 
    -0.06155802f, 0.03966140f, -0.06992044f, 0.01578498f, -0.07155080f, -0.10138015f, -0.09671897f, -0.13446765f, 
    -0.37374932f, -0.06386171f, 0.20369910f, -0.21429902f, 0.15028763f, -0.06175997f, 0.05923827f, -0.08324490f, 
    -0.13425429f, 0.10011054f, 0.00683143f, 0.00078297f, 0.08626813f, -0.06412402f, 0.01410965f, -0.06073284f, 
    -0.26977187f, -0.22078623f, -0.09519777f, -0.06453173f, -0.04181400f, 0.20595169f, 0.02198737f, 0.17541252f, 
    0.21566437f, -0.02863276f, 0.01239161f, -0.27564570f, 0.04811643f, -0.18634389f, 0.04279495f, 0.23755871f, 
    -0.05674681f, 0.06141479f, 0.04018138f, 0.01677018f, 0.00681072f, -0.03406889f, 0.04148274f, -0.03203741f, 
    -0.11347477f, -0.02101864f, -0.11273332f, -0.02545993f, 0.03579142f, 0.00249065f, -0.02960506f, 0.06825581f, 
    -0.01248045f, 0.02956541f, 0.01896707f, -0.12073849f, 0.05337891f, -0.00946181f, -0.02008373f, 0.01003370f, 
    -0.05619085f, 0.00006210f, -0.06272662f, -0.01694528f, 0.12018071f, 0.01418633f, 0.01682867f, 0.14967118f, 
    0.11236279f, -0.00418485f, -0.15093085f, -0.03290930f, 0.07596789f, -0.19161119f, 0.03932712f, 0.16479325f, 
    -0.01122033f, -0.01222124f, -0.04190908f, -0.00475824f, -0.04748892f, 0.03934861f, 0.02422666f, -0.01942281f, 
    -0.16236654f, -0.36758816f, 0.94974566f, 0.66829360f, 0.44849882f, 0.05874326f, -0.09152704f, -0.07691625f, 
    0.30391380f, 0.02068241f, 0.01596057f, 0.01127966f, -0.00699487f, 0.00565759f, -0.00222848f, 0.01308109f, 
    -0.06408058f, -0.01095610f, -0.10586695f, 0.02504200f, 0.77959687f, -0.34463003f, -0.00828923f, -0.40302530f, 
    0.20044245f, 0.25577798f, -0.18743910f, -0.24337251f, -0.10132369f, 0.23088433f, -0.12044624f, 0.12627345f, 
    0.26625264f, 0.10727414f, -0.11361911f, 0.20455740f, -0.07123294f, -0.15824309f, 0.15175247f, 0.04353643f, 
    -0.41240808f, 0.07886294f, -0.11993892f, -0.16880198f, -0.17886794f, 0.01905712f, -0.11272302f, -0.13692515f, 
    -0.25953898f, 0.01670323f, 0.00288633f, -0.00239553f, 0.04047803f, -0.02642312f, -0.06562655f, -0.03708048f, 
    0.01002748f, 0.02456119f, 0.03150311f, 0.01158192f, 0.18890628f, -0.06727540f, 0.10335027f, -0.00338948f, 
    0.07191579f, 0.07916453f, -0.01234065f, 0.00559613f, -0.15833828f, 0.15338467f, 0.06614397f, -0.01150216f, 
    -0.04693820f, 0.14203413f, -0.04029890f, -0.02324561f, -0.15298748f, 0.10703212f, 0.16508757f, -0.20485769f, 
    -0.14525440f, 0.08229963f, -0.09417571f, 0.07614060f, 0.03048104f, -0.00807437f, 0.00180419f, 0.02460364f, 
    -0.02429312f, 0.07145160f, 0.01287468f, 0.05587247f, -0.01602010f, -0.00721991f, -0.03897287f, 0.04647211f, 
    -0.06700885f, 0.10034643f, 0.07514217f, -0.05368863f, 0.04791524f, 0.15443185f, 0.16487357f, 0.11519516f, 
    0.25545236f, -0.02654558f, -0.01493848f, 0.06834874f, 0.05954430f, -0.01604355f, -0.01305059f, -0.03718585f, 
    0.03982133f, -0.01396214f, 0.03960590f, 0.00731373f, -0.01858309f, 0.04286666f, -0.05344279f, 0.02560876f, 
    -0.26003119f, -0.30313462f, -0.06415469f, -0.05087947f, 0.00362009f, -0.03848619f, -0.01120246f, 0.04307514f, 
    0.01212217f, 0.02155246f, -0.11478815f, -0.12206674f, -0.03154866f, -0.07550935f, -0.05406636f, -0.00979366f, 
    -0.00627009f, 0.04379763f, 0.03209814f, -0.00770240f, -0.50342345f, -0.83520365f, -0.44743472f, -0.13386193f, 
    -0.42855439f, 0.03514121f, 0.04356391f, -0.25182864f, -0.01163674f, 0.12181349f, 0.01117149f, -0.06352005f, 
    -0.02808188f, 0.01446337f, -0.13805655f, 0.02282354f, -0.01812059f, 0.03576757f, -0.09614005f, -0.07770915f, 
    -0.26952016f, -0.39997023f, -0.37473893f, 0.19087189f, -0.53719944f, -0.00618534f, -0.07035275f, 0.05723480f, 
    -0.03467025f, -0.31435850f, 0.00873663f, 0.05566334f, -0.09817664f, 0.05891892f, -0.02942182f, -0.02696082f, 
    -0.02922564f, -0.01793544f, 0.04868589f, -0.02031101f, -0.27742901f, 0.21739188f, 0.02462493f, -0.01563385f, 
    -0.02849040f, -0.09902035f, -0.06832186f, -0.04227032f, -0.01468015f, 0.05873778f, -0.04959261f, -0.06310256f, 
    -0.03766907f, 0.05119237f, 0.11547070f, 0.04758552f, -0.04487064f, -0.06406184f, 0.10673574f, -0.04908430f, 
    -0.35599861f, -0.20139644f, 0.11719429f, -0.28333092f, -0.54329157f, 0.05743333f, -0.02507902f, -0.14219083f, 
    -0.23079185f, 0.05932765f, -0.07604928f, -0.13195433f, -0.03129356f, -0.01709647f, -0.08977459f, -0.08871189f, 
    -0.14395694f, -0.12205287f, -0.16218135f, -0.28740752f, -0.30500528f, -0.43900117f, 0.62897080f, -0.06968185f, 
    0.12754562f, -0.25421277f, 0.10354245f, 0.24679786f, 0.19207369f, 0.06133070f, 0.18240079f, 0.12067559f, 
    -0.03475590f, 0.13808021f, 0.12929815f, 0.00690366f, 0.00458513f, 0.07254615f, 0.02155283f, -0.07604464f, 
    -0.15330283f, -0.02126989f, -0.43000630f, 0.22128470f, 0.20126405f, -0.04551969f, -0.13545756f, 0.07581973f, 
    -0.06897214f, 0.11867145f, -0.10591278f, 0.04388380f, 0.04857780f, -0.11787278f, -0.06083697f, -0.13686873f, 
    -0.07828385f, 0.08551148f, -0.12283225f, -0.07442196f, 0.19801983f, 0.21908239f, 0.20965636f, -0.09119254f, 
    0.45946652f, -0.10320569f, 0.26708558f, -0.02649312f, -0.08384429f, 0.05419767f, -0.06332280f, -0.02248526f, 
    -0.15627666f, -0.12638631f, -0.07976158f, 0.03159104f, -0.16385236f, 0.15393144f, -0.13182247f, -0.03681671f, 
    0.24258013f, -0.10494976f, -0.30405977f, -0.19003648f, 0.31994447f, 0.10719854f, 0.04496687f, -0.01764207f, 
    -0.00261324f, -0.02317738f, -0.23949687f, -0.13111934f, -0.06659864f, 0.00819183f, -0.05349546f, -0.14510621f, 
    -0.04697700f, 0.02991201f, -0.00366644f, -0.01406910f, 0.14489844f, 0.97385079f, 0.00688929f, -0.44361740f, 
    -0.07593647f, 0.39026913f, 0.08851440f, -0.30040297f, -0.03408237f, -0.31132248f, -0.14818130f, 0.05130849f, 
    -0.01360198f, -0.04674057f, 0.13992187f, 0.17219798f, 0.16988826f, -0.18266974f, 0.02678527f, -0.04013547f, 
    -0.21620691f, 0.22695667f, -0.19943690f, 0.34418473f, 0.05164848f, -0.07570729f, -0.26049364f, 0.06026589f, 
    -0.07271310f, -0.29864752f, -0.00923819f, -0.02092530f, 0.19307382f, -0.00992011f, -0.20738353f, -0.01758495f, 
    0.02126104f, 0.12094934f, -0.04826099f, -0.05785832f, 0.14043003f, -0.10416497f, -0.25610018f, -0.07566391f, 
    0.14930470f, 0.11049489f, -0.08410694f, -0.00859997f, 0.02205493f, 0.11945193f, -0.05454984f, 0.04230187f, 
    -0.00896031f, -0.11263025f, -0.05432510f, -0.02847013f, -0.17853796f, -0.07041731f, -0.00312985f, -0.14322302f, 
    0.83528435f, -0.26274306f, -0.28703874f, 0.02105961f, 0.06573220f, 0.15551065f, -0.05487861f, 0.12178943f, 
    -0.13865355f, -0.38893515f, -0.10645888f, 0.03956177f, -0.01451382f, 0.10330109f, -0.01212783f, 0.01301533f, 
    0.10570253f, 0.18559083f, -0.10622232f, -0.01337563f, -0.36582971f, 1.19394600f, -0.04301158f, 0.02715913f, 
    0.25635654f, 0.29462856f, -0.04289030f, -0.06710899f, -0.10583337f, 0.13916187f, -0.14655380f, -0.06349932f, 
    0.07141729f, 0.06955060f, 0.05973702f, 0.01348179f, -0.06501956f, -0.06214498f, 0.01050201f, -0.01648506f, 
    -0.12397003f, 0.01713730f, -0.26147172f, -0.06393793f, 0.27934310f, 0.20018731f, 0.02421729f, 0.00000914f, 
    0.04252138f, 0.11704411f, -0.08199394f, 0.06237265f, -0.04751864f, 0.11612713f, -0.08159280f, 0.08048064f, 
    -0.05906726f, 0.16255890f, 0.06565905f, 0.10911874f, -0.24513625f, 0.06612092f, 0.88827693f, -0.09371781f, 
    0.32697889f, -0.36540878f, 0.15855771f, 0.20853703f, -0.13450125f, -0.16433246f, 0.06695361f, -0.05579823f, 
    -0.02746039f, -0.11439359f, 0.05917757f, -0.06509507f, -0.18102045f, 0.11878005f, -0.11720455f, -0.11425951f, 
    0.96326727f, -0.03874964f, -0.03028168f, -0.13474430f, 0.04275310f, 0.22190051f, 0.07933342f, 0.02733590f, 
    -0.17199296f, -0.10290081f, -0.19999395f, -0.15856095f, 0.14869133f, -0.04046154f, -0.01853984f, -0.10515276f, 
    0.00769163f, -0.11652509f, 0.04902361f, 0.03118764f, -0.05220140f, 0.03306372f, 0.10227903f, -0.42161202f, 
    0.18522583f, 0.16352101f, -0.02314249f, -0.05524782f, 0.12433467f, -0.07462049f, 0.17282741f, -0.05799324f, 
    0.04484156f, -0.04549050f, -0.05680003f, 0.27605101f, 0.06007992f, 0.12287841f, 0.15358616f, 0.20147964f, 
    0.40799019f, -0.23496914f, -0.06744239f, -0.28187877f, -0.34064689f, -0.13065141f, 0.06462352f, -0.04810142f, 
    -0.06612528f, -0.23919135f, -0.08646385f, -0.09911306f, 0.12047438f, -0.30813399f, -0.10440953f, -0.21933442f, 
    -0.17566182f, -0.11024721f, 0.16089955f, 0.01633338f, -0.49172050f, -0.28627285f, -0.15204258f, -0.04032875f, 
    -0.48634514f, 0.21079919f, 0.23090477f, 0.14697713f, 0.22145770f, 0.21283883f, -0.02971115f, -0.02830794f, 
    0.22746293f, -0.09162709f, -0.05926228f, 0.09122229f, -0.01344230f, -0.21724485f, -0.04784766f, 0.04100119f, 
    -0.11369392f, 0.10890010f, -0.26117590f, -0.08165599f, 0.21281168f, 0.26231101f, 0.04138086f, -0.08984694f, 
    -0.08849052f, -0.11626898f, -0.15792516f, -0.04174176f, 0.05735955f, 0.09563319f, 0.03393522f, -0.02436398f, 
    0.01012788f, -0.13122194f, 0.13505436f, 0.04053263f, -0.02389349f, 0.04841761f, 0.00046924f, -0.11653148f, 
    0.33489415f, 0.09862161f, 0.14602695f, 0.03548685f, 0.00855193f, 0.02607794f, 0.13459484f, -0.02856114f, 
    -0.03444699f, -0.11269160f, 0.10970384f, 0.02754747f, -0.20202018f, -0.07369779f, -0.04532216f, 0.00193811f, 
    -0.41484928f, 0.04085284f, 0.65638739f, -0.28154868f, 0.21482515f, -0.16842689f, 0.04297713f, -0.14568554f, 
    -0.05308936f, 0.06988195f, 0.18153489f, 0.06135895f, -0.08639596f, -0.08749766f, 0.09253533f, 0.03319016f, 
    0.04515599f, 0.07099776f, -0.10314953f, -0.01004924f, -0.29726315f, 0.04976933f, -0.07858565f, 0.09076030f, 
    0.24896297f, -0.12467224f, 0.05769464f, -0.00372688f, -0.02730043f, 0.09522519f, -0.19484113f, 0.08784771f, 
    -0.09453177f, -0.06398998f, 0.04655389f, -0.01367435f, -0.05392204f, 0.24538174f, -0.27039936f, -0.02194396f, 
    -0.45578822f, -0.57301641f, -0.20282337f, -0.22417779f, -0.28477946f, -0.03561132f, -0.19834775f, -0.07731093f, 
    -0.19431913f, -0.09042793f, 0.00024840f, 0.09336410f, -0.12731466f, -0.19047530f, 0.03776801f, 0.12949279f, 
    -0.02435120f, 0.23865618f, -0.29096073f, -0.40664592f, -0.18595786f, -0.23224379f, -0.21034776f, -0.05393115f, 
    0.38999709f, 0.09896755f, -0.02844148f, -0.00367606f, 0.09936725f, 0.04951209f, -0.06392977f, 0.07476412f, 
    0.00146663f, 0.12067360f, 0.00982480f, 0.09444033f, -0.03014532f, 0.22399062f, 0.03707025f, 0.09029888f, 
    -0.25480482f, 0.19144572f, -0.26673532f, -0.08985738f, 0.42572519f, 0.16115059f, 0.11526999f, -0.02818487f, 
    -0.12310776f, 0.03787584f, -0.11584753f, 0.17683356f, -0.03910736f, 0.15894900f, 0.26484656f, -0.08877560f, 
    0.02135904f, 0.14748611f, 0.11517538f, 0.12517656f, 0.66347444f, 0.88963443f, -0.23293550f, -0.72217005f, 
    0.03539314f, 0.04479667f, 0.10556253f, -0.06621886f, -0.50652450f, 0.17425174f, -0.17165290f, -0.31284079f, 
    0.08864041f, -0.14907423f, 0.04284944f, -0.02460570f, 0.03673217f, -0.15381081f, 0.07158521f, 0.08272154f, 
    -0.00827121f, -0.17553982f, 0.04152381f, 0.17841448f, 0.07912020f, 0.17875116f, 0.03189769f, 0.05116865f, 
    0.07622581f, -0.03291268f, 0.14627071f, -0.03649035f, -0.03097244f, -0.18174723f, 0.01353852f, 0.03103493f, 
    -0.08059996f, 0.14714935f, -0.05790255f, -0.20881264f, 0.24382919f, -0.09731203f, 0.19464204f, -0.05001100f, 
    -0.11456127f, -0.01847989f, -0.08242922f, -0.04809568f, 0.19617790f, -0.26247704f, -0.18416384f, -0.05968616f, 
    -0.04216823f, -0.17128712f, 0.02801905f, -0.18647915f, -0.06234313f, 0.11882824f, -0.00614244f, -0.01530983f, 
    -0.65945339f, 0.32088515f, -0.01966022f, 0.04871155f, -0.47948387f, 0.00293915f, -0.19318113f, -0.08599988f, 
    -0.01609932f, -0.09329504f, -0.04682837f, 0.02401473f, -0.09024803f, -0.11406804f, -0.15659921f, -0.21472315f, 
    -0.04504236f, -0.11957193f, -0.09228908f, -0.03638545f, -0.24455184f, 0.08211147f, -0.12452719f, -0.19062118f, 
    0.27255309f, 0.16705753f, -0.05461293f, -0.17505944f, -0.10940494f, -0.21551271f, -0.16118741f, -0.01066656f, 
    0.04773993f, -0.00203841f, 0.01851054f, -0.02363203f, -0.02357632f, 0.04683576f, 0.08785395f, 0.06307271f, 
    -0.06984935f, -0.10676457f, -0.38805610f, -0.20797978f, -0.40395662f, 0.62244052f, 0.32975087f, 0.13937338f, 
    0.18917473f, 0.18820500f, -0.11284173f, -0.16882710f, 0.00478988f, -0.22546716f, 0.01340534f, -0.13195612f, 
    0.11888595f, -0.17247279f, -0.30031347f, -0.17428276f, 0.09634458f, -0.07879018f, -0.15022752f, 0.10345534f, 
    0.32049781f, -0.05725343f, 0.13040483f, -0.00346338f, 0.08599453f, 0.05172943f, 0.15515594f, -0.02218332f, 
    -0.04715528f, -0.01767613f, -0.08944745f, 0.05408353f, -0.13043742f, 0.19108716f, -0.49805686f, 0.02458433f, 
    -0.05083946f, -0.29267195f, -0.37225750f, -0.00451149f, 0.35529831f, 0.20679049f, -0.06496695f, 0.15730652f, 
    0.05002238f, 0.01401223f, 0.27768040f, -0.08423138f, 0.15525755f, 0.01949824f, 0.04359749f, -0.01244629f, 
    -0.02823307f, 0.21376278f, -0.15796174f, 0.19886830f, -0.46715602f, -0.05996057f, 0.34531885f, 0.37286475f, 
    -0.09849703f, 0.07966727f, -0.15571092f, -0.19437356f, -0.06112069f, -0.37480378f, -0.03747916f, -0.08696051f, 
    -0.03807382f, 0.03955650f, -0.01887545f, 0.01867300f, 0.07420257f, 0.21837381f, -0.01795355f, -0.15488145f, 
    0.07863212f, 0.00073920f, -0.16327223f, -0.15389803f, -0.15148264f, 0.07248616f, -0.00598104f, -0.07801978f, 
    0.00138908f, -0.01200312f, -0.03387325f, -0.06575816f, -0.00758007f, -0.17043917f, 0.00746895f, 0.01056507f, 
    -0.08814222f, -0.02092253f, -0.04751527f, -0.06926154f, 0.29645300f, 0.16016515f, -0.35685369f, 0.29433426f, 
    0.33630446f, -0.02685151f, 0.03968733f, 0.06721470f, 0.10959514f, 0.13253048f, 0.03856955f, 0.07702889f, 
    -0.00104352f, 0.03175857f, 0.06443786f, 0.08381025f, 0.14133190f, 0.06085389f, 0.14116694f, 0.17395583f, 
    0.10637740f, -0.06593449f, 0.35391062f, -0.03963302f, 0.10562870f, -0.10258877f, 0.13355160f, 0.12329417f, 
    -0.00005382f, -0.02013896f, -0.05250548f, 0.01643250f, 0.00672015f, 0.05494459f, -0.00784529f, 0.00375971f, 
    0.03523407f, -0.15260977f, -0.13307512f, -0.00983483f, -0.06357156f, -0.18367332f, -0.12896785f, 0.32838356f, 
    -0.17524648f, 0.04275655f, 0.02877311f, 0.13891467f, -0.05978268f, 0.00699502f, -0.07097208f, -0.05639965f, 
    -0.01774733f, 0.06457193f, 0.00845078f, 0.14899735f, 0.24672888f, 0.13982767f, 0.17887494f, 0.37607640f, 
    0.03428460f, 0.04947593f, 0.20163749f, 0.32138655f, 0.03523782f, -0.16023348f, -0.01191691f, -0.02476965f, 
    -0.01181573f, 0.14749554f, 0.06151320f, 0.02599190f, 0.01605970f, 0.02367360f, 0.03922462f, 0.00395522f, 
    0.01931265f, -0.03142537f, -0.01867129f, -0.06004333f, 0.22066228f, -0.17123219f, -0.14865862f, -0.03962073f, 
    -0.07798081f, -0.13010581f, -0.08852071f, 0.07645541f, -0.01343584f, 0.04905736f, -0.01141103f, -0.02544466f, 
    0.13001765f, -0.06036598f, -0.16587879f, -0.09516157f, -0.18526630f, -0.03003505f, 0.04955162f, -0.02485908f, 
    -0.16602997f, -0.02646968f, 0.06040653f, -0.26718199f, -0.10986537f, -0.01305260f, 0.07223848f, 0.06888156f, 
    -0.02386609f, -0.07297370f, -0.02454336f, -0.19109021f, -0.11703792f, -0.02679154f, 0.04179586f, 0.06641810f, 
    0.07660044f, -0.15339868f, -0.09681810f, -0.06581298f, -0.13441995f, 0.10448635f, 0.17927709f, 0.10248391f, 
    0.13263084f, -0.09020299f, 0.19220051f, -0.02413472f, 0.17157206f, 0.02767424f, -0.02430348f, -0.13019386f, 
    -0.05974149f, -0.04039769f, 0.04917039f, -0.12231137f, -0.09166778f, -0.08806639f, 0.05004734f, -0.25740445f, 
    -0.16787705f, -0.14215378f, 0.09251751f, -0.12433895f, -0.00598008f, -0.24938150f, -0.09451988f, -0.13519068f, 
    0.17702831f, 0.10170523f, 0.01440913f, 0.03783699f, -0.00087654f, -0.24552880f, 0.05734020f, -0.02645642f, 
    -0.07143738f, 0.00163807f, -0.02552212f, 0.05078163f, -0.39260334f, -0.55139172f, 0.14777806f, -0.21197143f, 
    -0.04849989f, -0.08917781f, 0.10789472f, -0.19214925f, 0.07253694f, -0.00420797f, -0.00257260f, -0.05749963f, 
    -0.19057523f, 0.15453593f, -0.05150007f, -0.05149803f, 0.00567853f, -0.05830600f, 0.01339678f, -0.08477574f, 
    0.03680290f, 0.01423070f, 0.15261278f, 0.35825184f, 0.11799557f, -0.18889815f, -0.11880277f, -0.03086243f, 
    -0.23244295f, 0.01341690f, -0.06156741f, 0.06496374f, 0.04764171f, 0.10166933f, 0.06624417f, -0.01208366f, 
    -0.08351310f, 0.04378437f, -0.07710245f, 0.05287055f, 0.42228144f, -0.17167431f, -0.37788773f, 0.11879378f, 
    -0.03298230f, 0.16494513f, -0.00932947f, -0.01351081f, 0.00833229f, 0.06813220f, 0.00131203f, 0.02381830f, 
    -0.02294230f, -0.00063927f, -0.08528291f, 0.00086715f, 0.09596495f, -0.14456718f, -0.01994433f, -0.04958687f, 
    0.01015382f, -0.55824840f, 0.04144167f, -0.04043491f, -0.13263190f, -0.08949441f, -0.14718187f, -0.04333460f, 
    0.08101560f, 0.07103233f, 0.00275266f, -0.10915603f, -0.07494142f, -0.07654413f, 0.04070308f, 0.04219274f, 
    -0.01126642f, 0.02865185f, -0.11471373f, 0.04780594f, 0.01473949f, 0.08049478f, 0.03120881f, 0.24280798f, 
    -0.03031982f, 0.05246543f, 0.05239820f, -0.04537755f, -0.06330981f, 0.09846617f, -0.16329578f, 0.07860668f, 
    -0.11605093f, 0.09831734f, 0.08208291f, -0.04965115f, -0.17684478f, -0.05168222f, -0.22847652f, -0.13909225f, 
    0.24463242f, -0.07826088f, -0.10630361f, -0.02666112f, -0.27788717f, 0.04412750f, 0.11669982f, 0.00950673f, 
    0.05443134f, -0.06360693f, 0.17770533f, -0.13877763f, 0.12297641f, 0.07833812f, -0.10120916f, -0.02067608f, 
    0.11994879f, -0.04691237f, -0.19721650f, -0.03358188f, 0.23805839f, 0.14884949f, 0.02661140f, -0.14867435f, 
    -0.13854720f, 0.15884881f, 0.03311376f, 0.05738963f, 0.06156099f, 0.12443492f, 0.16093954f, 0.15184970f, 
    0.08050622f, -0.03427175f, 0.03457147f, -0.03968037f, 0.02374766f, -0.05847608f, -0.06869324f, 0.18403451f, 
    0.23576847f, -0.25639373f, 0.27483788f, 0.02260668f, -0.00264675f, -0.18867572f, -0.09094772f, -0.05453406f, 
    -0.01696144f, 0.01015621f, 0.07273522f, -0.10124405f, -0.06930838f, -0.07956301f, 0.04443111f, 0.06286135f, 
    -0.00333726f, 0.09344377f, -0.09361469f, -0.03290749f, 0.10119563f, 0.18773329f, 0.12788694f, 0.07280946f, 
    0.04501037f, 0.13721134f, 0.14115253f, 0.08466296f, -0.04367270f, 0.17678837f, 0.02237648f, -0.06873133f, 
    0.08258020f, -0.01713694f, 0.00205210f, 0.01069780f, -0.11208639f, -0.10660078f, -0.10266113f, -0.25320414f, 
    0.02498669f, 0.00339042f, -0.06874231f, 0.05361723f, 0.21478593f, -0.16376258f, 0.05969709f, 0.13880898f, 
    -0.03278852f, 0.04028174f, 0.01661936f, 0.00824336f, -0.06358735f, -0.03407927f, 0.00539299f, -0.10934124f, 
    -0.22142111f, 0.00493965f, 0.02841847f, -0.09565365f, 0.12126663f, -0.14258294f, 0.20373264f, -0.01945910f, 
    -0.08145969f, -0.00660976f, -0.09196444f, -0.05533586f, -0.13379849f, -0.22529981f, 0.17384325f, -0.07414605f, 
    0.04555919f, 0.01578256f, 0.02732387f, 0.01757244f, -0.02874538f, -0.09714197f, -0.00642323f, -0.08083177f, 
    0.05543593f, 0.01639954f, -0.01761704f, -0.00271067f, -0.02326852f, 0.05986657f, 0.10503467f, 0.04628371f, 
    0.02354936f, 0.05980804f, 0.00137803f, -0.02427467f, -0.07806820f, -0.08391874f, 0.07929642f, 0.12022880f, 
    -0.05060087f, 0.00457281f, 0.00730223f, 0.05934880f, 0.16602845f, 0.10265496f, 0.11648405f, 0.06611548f, 
    -0.04836656f, -0.04000273f, -0.08202597f, -0.08468209f, -0.11365049f, 0.03852990f, 0.12045486f, -0.07888253f, 
    -0.01105591f, 0.08200926f, 0.05695546f, 0.09200861f, -0.11079805f, -0.06529078f, -0.09528408f, -0.09611975f, 
    -0.19644910f, -0.23376283f, 0.12280188f, 0.18145058f, 0.15678467f, -0.20251969f, -0.08564473f, -0.01485576f, 
    -0.33640409f, -0.28383261f, -0.03774482f, 0.08488375f, 0.09205753f, -0.01879127f, -0.13563372f, -0.02215675f, 
    0.10998848f, -0.01860392f, 0.02401535f, 0.11248893f, 0.32776296f, -0.54174232f, -0.20532253f, 0.33548722f, 
    -0.48627666f, 0.38281366f, -0.41733587f, 0.03829219f, -0.04201081f, -0.03592640f, -0.00157664f, -0.14256093f, 
    -0.12458697f, 0.06209666f, 0.14645422f, 0.01641088f, -0.05274558f, 0.03057281f, -0.41403452f, 0.07215898f, 
    -0.03959712f, 0.06652777f, 0.10112315f, 0.20031331f, 0.17694725f, -0.06705025f, 0.25411654f, -0.21053024f, 
    0.11684726f, 0.16329674f, -0.10733037f, 0.00023787f, -0.10284790f, 0.01962781f, 0.02254056f, -0.04906513f, 
    -0.04137938f, -0.22669619f, -0.18736012f, -0.05083062f, -0.13917626f, 0.18095121f, -0.21953085f, -0.28959215f, 
    -0.32700384f, 0.11271609f, -0.11347461f, 0.05157804f, 0.19744746f, -0.12280805f, 0.09660212f, -0.06567905f, 
    0.10909077f, -0.12358223f, -0.01970804f, -0.05944363f, -0.26476747f, -0.13515052f, -0.41991979f, -0.02420670f, 
    -0.25329837f, -0.10342632f, -0.12609124f, -0.45799473f, -0.16424993f, 0.02310019f, 0.08265489f, -0.01092181f, 
    0.14545141f, -0.01020543f, -0.04030650f, -0.00661715f, -0.04943694f, -0.00393432f, 0.02325749f, -0.11808737f, 
    -0.03084967f, -0.11500871f, -0.05739456f, 0.08014862f, 0.12562366f, -0.06641653f, 0.09140787f, 0.03882581f, 
    0.04389384f, -0.16596203f, -0.10948063f, -0.08954011f, -0.03180814f, 0.02789112f, 0.05821393f, -0.05535750f, 
    -0.10419778f, 0.04406951f, 0.02129309f, 0.02191437f, 0.04472365f, 0.01580859f, 0.02111910f, -0.06401062f, 
    0.18316108f, 0.20900828f, 0.05636378f, -0.00572611f, -0.00393194f, 0.05780014f, 0.03629081f, 0.08709101f, 
    0.12077322f, 0.18657860f, -0.06162460f, 0.09979638f, -0.15027706f, 0.06984408f, -0.09368052f, 0.11901776f, 
    -0.00995193f, 0.01133583f, -0.02742655f, 0.04568840f, -0.05475749f, 0.12298199f, 0.37714380f, 0.31246826f, 
    0.27462190f, -0.02705362f, 0.14049885f, 0.04958170f, -0.00337453f, 0.21290427f, -0.06068299f, -0.00950146f, 
    0.01098320f, -0.00740791f, 0.01001987f, 0.00744559f, -0.01069283f, -0.16432939f, -0.04145832f, -0.03940493f, 
    0.17460549f, 0.26025197f, 0.48922890f, 0.15044475f, 0.11290000f, -0.16432902f, -0.17589411f, 0.08941820f, 
    -0.06929300f, 0.22699742f, 0.01566457f, 0.01976006f, 0.01318531f, 0.04868246f, 0.02123463f, 0.04053294f, 
    -0.03828112f, 0.03392568f, -0.05886817f, -0.20814319f, -0.01240512f, -0.13170506f, -0.20993571f, -0.15634377f, 
    -0.10985909f, 0.00456547f, 0.01353055f, 0.00808775f, -0.09336917f, -0.02253860f, 0.00636297f, 0.04557430f, 
    0.11630470f, -0.19234876f, -0.04752434f, 0.03974980f, 0.00642498f, -0.09645569f, -0.08837257f, 0.04825435f, 
    0.00568374f, -0.18402103f, -0.17797333f, 0.16311455f, 0.05627197f, -0.03934160f, 0.05915114f, -0.03909503f, 
    -0.02294340f, 0.04851762f, 0.14518367f, -0.02495770f, -0.01510193f, 0.09079742f, -0.01682585f, -0.00970327f, 
    -0.14407250f, 0.05635294f, 0.10834061f, 0.26121572f, -0.23196658f, -0.00460042f, -0.11489337f, 0.15250112f, 
    0.05878818f, 0.12783942f, 0.10500880f, -0.11948542f, 0.11975077f, 0.01447406f, 0.00336759f, 0.05483582f, 
    0.00871094f, -0.04287114f, 0.00719977f, -0.19873245f, -0.03487528f, 0.09314221f, 0.09180711f, -0.08747424f, 
    0.19947228f, 0.07808875f, 0.36242756f, -0.13100655f, -0.03782312f, 0.22124404f, 0.03947951f, -0.23840202f, 
    0.13103561f, 0.07864127f, 0.08130702f, 0.07042634f, 0.02587581f, 0.03716657f, -0.04664959f, -0.00266660f, 
    0.01212670f, -0.17717004f, 0.03280072f, 0.01183424f, -0.16567092f, -0.03311797f, 0.46929845f, 0.15196706f, 
    -0.55865967f, -0.11442824f, 0.02921187f, 0.04710386f, 0.19501533f, 0.06840698f, 0.01626337f, 0.01918420f, 
    -0.02040914f, 0.00232709f, 0.03707277f, -0.01719751f, 0.00300679f, -0.08324090f, -0.33336192f, -0.43679762f, 
    0.03601899f, -0.18699409f, 0.30992863f, 0.07710633f, -0.37331045f, 0.19778946f, 0.12505475f, 0.16286889f, 
    0.02014324f, -0.15199427f, 0.07622646f, 0.03818496f, 0.03926651f, 0.00168309f, 0.01031672f, -0.01347738f, 
    0.04728883f, -0.07847967f, -0.03913271f, 0.02152257f, -0.27237871f, -0.16695270f, -0.21675205f, 0.10228056f, 
    -0.11013180f, 0.17893627f, -0.08750886f, -0.15716797f, 0.05313948f, 0.04990009f, 0.09575047f, -0.08324030f, 
    -0.02336251f, -0.16035362f, 0.18288286f, -0.00734429f, 0.06062996f, 0.05258399f, 0.04222727f, 0.10710810f, 
    -0.49083939f, -0.29493657f, -0.06289937f, -0.06323329f, 0.14418715f, 0.11220149f, 0.01950031f, 0.02532402f, 
    -0.04296971f, -0.09432050f, 0.10210380f, -0.11528356f, 0.18444969f, -0.04034308f, -0.02875757f, -0.04781182f, 
    -0.13478558f, 0.07458778f, -0.00679415f, -0.12027310f, 0.23146115f, 0.01240757f, 0.38333482f, 0.04192328f, 
    -0.16170615f, 0.00354499f, -0.14740653f, -0.19702238f, 0.08081508f, 0.05480269f, 0.01264560f, -0.01255104f, 
    0.06859007f, 0.10105251f, 0.09553200f, 0.09785268f, 0.01156500f, -0.11949384f, -0.10336491f, 0.43839017f, 
    -0.33449373f, 0.53129393f, -0.51854467f, -0.00967665f, -0.04807967f, 0.09058570f, -0.11338549f, -0.05060930f, 
    -0.00314640f, 0.26513779f, 0.03633911f, -0.10153281f, -0.07728291f, 0.13015273f, -0.06593008f, -0.09225599f, 
    -0.01974013f, 0.10906424f, -0.08420703f, -0.01138565f, -0.36607677f, -0.17196004f, -0.47811794f, -0.42985114f, 
    0.06399149f, -0.03778925f, 0.00345739f, -0.08114573f, 0.01296439f, -0.05846599f, -0.10553402f, 0.16976535f, 
    -0.05410871f, -0.12404568f, 0.08448844f, -0.04552352f, -0.10999946f, 0.09760319f, -0.02363737f, 0.03997871f, 
    -0.31166017f, -0.12675214f, 0.29771167f, -0.00495731f, -0.20887744f, 0.24398451f, 0.02734007f, 0.12802231f, 
    0.02405890f, -0.10504872f, 0.04538601f, -0.03576452f, 0.01587668f, -0.08262894f, 0.10145646f, 0.00788863f, 
    0.03319390f, 0.09540144f, 0.05960380f, 0.03665773f, -0.19878408f, -0.05028399f, -0.18893030f, -0.14142564f, 
    -0.01551574f, 0.05728159f, -0.02073994f, -0.08489285f, -0.01371638f, 0.01004215f, 0.05223664f, -0.03592762f, 
    0.02578767f, 0.07506463f, -0.04115440f, 0.02667093f, -0.04247295f, 0.03166643f, -0.13535707f, -0.10505361f, 
    -0.59388667f, 0.74139565f, -0.38899100f, 0.02955330f, -0.08227564f, -0.02175967f, -0.04747281f, -0.03764950f, 
    0.06060732f, 0.06107769f, 0.11395461f, 0.07113098f, -0.03598199f, 0.05120184f, -0.11681762f, -0.10229158f, 
    -0.03437550f, 0.17340778f, -0.00287750f, 0.01431469f, -0.01779454f, -0.12819132f, 0.00958918f, 0.01724533f, 
    -0.15802251f, 0.20139816f, -0.15109113f, -0.04591061f, 0.07349682f, -0.11455101f, 0.08453596f, -0.23457147f, 
    -0.09737843f, -0.04133844f, 0.09484381f, 0.01953623f, 0.05814670f, 0.04809912f, 0.09773257f, 0.17237577f, 
    -0.38739377f, 0.44181696f, -0.21242644f, 0.11320368f, 0.00347172f, 0.18158717f, -0.22007972f, 0.10352831f, 
    0.01598477f, -0.01276495f, 0.02606459f, -0.01332979f, -0.13422975f, 0.12261901f, 0.08377691f, -0.06372017f, 
    -0.02379666f, 0.30047622f, 0.10055810f, -0.03536895f, -0.03986752f, -0.04118026f, -0.14214575f, 0.08887239f, 
    0.07136548f, 0.00871107f, 0.00191536f, -0.08181271f, -0.01249145f, -0.02181537f, 0.07520731f, -0.11766209f, 
    -0.12155718f, 0.13463978f, 0.06594425f, -0.22625633f, 0.16629872f, 0.18863271f, 0.04140014f, -0.10669120f, 
    -0.65728605f, 0.25266761f, -0.42044407f, -0.34202167f, -0.13308324f, 0.07973873f, 0.00181931f, -0.04153019f, 
    -0.13346523f, 0.04962753f, -0.02399035f, 0.03513459f, -0.06781226f, -0.05559107f, -0.03315894f, -0.03992195f, 
    -0.01551293f, 0.13507649f, -0.09654447f, 0.05403678f, 0.11500609f, 0.12492217f, -0.01294765f, 0.03475873f, 
    -0.05389592f, -0.04942564f, -0.32034704f, 0.06416700f, 0.01968304f, 0.00827381f, -0.23934808f, -0.01490353f, 
    -0.07599418f, -0.07741577f, -0.11282911f, 0.05974532f, 0.14660217f, 0.12331874f, -0.10251771f, 0.07335853f, 
    0.13597222f, -0.09301510f, -0.27083951f, 0.05835864f, 0.11739548f, -0.24389485f, 0.12683934f, 0.00442619f, 
    -0.00454644f, 0.02911275f, 0.02185394f, -0.06193634f, -0.03410808f, -0.01592385f, -0.03219903f, 0.04206868f, 
    -0.01405170f, 0.20718023f, -0.17731136f, -0.04532792f, 0.35481903f, -0.16690920f, 0.10253572f, -0.05609213f, 
    -0.37444240f, 0.11120945f, -0.02110879f, 0.05917097f, 0.03772964f, 0.15378831f, 0.00052660f, 0.03914517f, 
    0.03070234f, -0.03370645f, -0.07690621f, -0.04934338f, 0.04791195f, 0.00692485f, 0.10043512f, 0.05616697f, 
    0.06429642f, -0.08731980f, -0.10741003f, 0.02317709f, -0.00930828f, 0.02953170f, -0.01403860f, -0.09211094f, 
    -0.02099565f, 0.04360723f, -0.08534350f, -0.05726681f, 0.29352725f, -0.03722687f, 0.05481736f, 0.18905093f, 
    0.09422037f, 0.08231499f, -0.00734549f, 0.04981397f, 0.05711996f, 0.01416168f, 0.09089286f, -0.20292619f, 
    -0.14649145f, -0.01362596f, 0.09965917f, 0.04814755f, -0.08856039f, -0.04175021f, 0.19455814f, -0.04645310f, 
    0.03576667f, -0.04823950f, -0.01820959f, 0.07587357f, 0.07763391f, -0.11360379f, 0.04957178f, 0.08868685f, 
    -0.46937430f, 0.02436174f, -0.08168544f, -0.15302430f, -0.13029724f, 0.09737510f, -0.00799994f, 0.07401275f, 
    -0.13751251f, 0.08374634f, 0.04596375f, -0.07654253f, -0.05556732f, 0.01954499f, -0.00288545f, -0.22084931f, 
    -0.06975005f, -0.20389239f, -0.05086884f, -0.19298424f, -0.85909605f, 0.75814587f, 0.14393297f, 0.07566120f, 
    0.16710089f, 0.03120925f, -0.39221987f, 0.05961796f, 0.24110857f, -0.34934267f, 0.14233458f, 0.02494040f, 
    -0.01548784f, -0.15813005f, 0.03682686f, 0.04590068f, 0.00360820f, 0.04855065f, 0.22054701f, 0.09042928f, 
    0.01627171f, -0.17080033f, 0.18496712f, 0.12452673f, -0.22014549f, 0.07949404f, -0.07349682f, 0.06702866f, 
    0.15182167f, -0.10973526f, 0.10123827f, -0.02703304f, -0.01772886f, -0.01443017f, 0.04347501f, -0.03337185f, 
    0.07736077f, 0.04126824f, 0.06255893f, 0.29655796f, 0.76193702f, 0.20228328f, -0.62843496f, 0.20406657f, 
    0.32128176f, -0.03406863f, -0.24051359f, -0.20501293f, -0.12556066f, 0.17418990f, -0.01266269f, 0.08371413f, 
    -0.12660004f, 0.03477105f, -0.06391023f, 0.25528991f, -0.00340159f, -0.00423409f, 0.03713811f, -0.02596932f, 
    0.13172460f, -0.25293764f, -0.11512576f, -0.14786227f, 0.25278410f, 0.05180098f, -0.05721588f, -0.05534781f, 
    -0.01274067f, 0.02810855f, 0.16430216f, 0.01827597f, 0.08797928f, 0.04012037f, 0.16579679f, 0.02850627f, 
    -0.03879770f, 0.04694153f, 0.05393053f, 0.06511081f, -0.18218166f, -0.15707380f, -0.17759673f, -0.03433128f, 
    -0.12133464f, 0.10834052f, 0.00564692f, -0.11833552f, 0.13139799f, 0.15270017f, 0.05178145f, 0.00859308f, 
    -0.05054322f, -0.04267814f, -0.04475668f, -0.00085907f, 0.04823308f, 0.01819135f, 0.00588757f, 0.05995552f, 
    -0.01912389f, -0.03131977f, -0.18578917f, -0.01271372f, 0.03621207f, 0.03956843f, -0.00997677f, -0.10016294f, 
    -0.06301533f, -0.04982224f, 0.08891198f, 0.06196446f, -0.06572124f, 0.06503091f, 0.21587349f, -0.06356101f, 
    0.04460099f, 0.18344419f, 0.10616849f, 0.04714063f, 0.15736087f, -0.22606730f, 0.40625542f, 0.05312696f, 
    -0.56444335f, 0.02579756f, -0.07946484f, -0.01443005f, -0.10494129f, -0.16329807f, 0.05504404f, -0.03035542f, 
    -0.00422895f, -0.06198503f, 0.07316855f, -0.08012024f, 0.06287414f, -0.00938264f, -0.00713243f, 0.11653002f, 
    0.11430761f, -0.01228361f, 0.14267083f, -0.10400324f, 0.03167173f, 0.18553828f, 0.19205356f, 0.15157336f, 
    -0.25365466f, -0.07781233f, 0.03225422f, -0.02791727f, 0.03420166f, -0.00028390f, -0.01275944f, 0.00482483f, 
    -0.01076776f, -0.07173393f, 0.13189773f, 0.18085210f, 0.12755202f, -0.12761478f, -0.35385281f, -0.09370214f, 
    0.15737091f, -0.05808662f, 0.10891735f, -0.00786825f, -0.06898457f, 0.05940471f, 0.15369359f, -0.04109017f, 
    0.03641158f, -0.13841172f, -0.00903444f, 0.16551022f, -0.05226946f, -0.17845033f, 0.00077560f, 0.02966074f, 
    -0.00327132f, -0.00862649f, 0.04945003f, -0.12872410f, 0.02078738f, 0.03259723f, 0.04976349f, 0.07194386f, 
    0.01892792f, 0.07397453f, 0.02918252f, -0.00729175f, -0.12667099f, 0.07913338f, -0.04914295f, 0.02896483f, 
    -0.09431251f, -0.04946047f, -0.08529376f, -0.03168252f, 0.07310858f, -0.63725632f, -0.54416168f, -0.26318306f, 
    0.06498952f, -0.07087731f, 0.13613060f, 0.23181111f, -0.07479960f, -0.07024575f, -0.00945325f, -0.07562292f, 
    -0.01237590f, 0.03426247f, 0.06338604f, -0.04521854f, 0.01941719f, 0.08968177f, -0.08654388f, 0.07609951f, 
    -0.72678339f, -0.49018982f, -0.93482208f, -0.01938283f, -0.32844239f, -0.15792073f, -0.00583582f, -0.15659806f, 
    -0.00708436f, -0.48112419f, 0.06398442f, 0.01319564f, -0.09447210f, -0.01799238f, 0.07059056f, -0.05210058f, 
    -0.07047797f, 0.21193035f, 0.01358433f, 0.07443608f, -0.70529008f, -0.75133717f, -0.79287958f, -0.05829315f, 
    0.32109478f, -0.10149050f, 0.19545265f, -0.14936075f, -0.32080013f, -0.23391762f, -0.05533029f, -0.08309902f, 
    0.05683354f, 0.08673426f, 0.08550625f, -0.06009617f, 0.05370503f, 0.20619611f, 0.33019459f, 0.07284273f, 
    -0.83053488f, -0.74441230f, -0.43711817f, -0.57872570f, 0.35678062f, -0.35326216f, -0.16959852f, -0.12023348f, 
    -0.16900352f, -0.07621463f, -0.02593980f, -0.01019774f, -0.04240615f, -0.01949391f, -0.00494500f, 0.03066595f, 
    0.00022790f, 0.03014335f, 0.33598742f, 0.09534580f, -0.27127177f, -0.09762245f, 0.02134083f, -0.01157524f, 
    -0.02533597f, -0.06584395f, 0.05951660f, -0.09834935f, -0.07337140f, 0.27862582f, -0.09967405f, 0.09549356f, 
    0.12678394f, 0.25447357f, 0.06051857f, -0.01119146f, 0.10116573f, -0.18350384f, 0.11440405f, 0.04831701f, 
    -0.09667563f, 0.24042185f, -0.01366253f, -0.01044613f, 0.15385802f, 0.09633074f, -0.01824264f, 0.07795702f, 
    -0.02338253f, -0.08086948f, 0.08116340f, -0.01996377f, 0.25798416f, 0.01990224f, -0.08975285f, 0.08914305f, 
    -0.00472885f, -0.00444174f, -0.00323275f, 0.00441310f, 0.18873465f, -1.09510183f, -0.83492130f, -0.11127844f, 
    0.25946596f, 0.08747728f, -0.05491928f, 0.00992073f, -0.03561457f, -0.37234208f, -0.02233151f, 0.00944302f, 
    -0.12394098f, 0.15828311f, 0.00721566f, -0.03348597f, -0.02327085f, 0.08708221f, 0.24874005f, 0.00224847f, 
    -0.41668752f, 0.31690574f, 0.14399275f, 0.01696554f, 0.49824858f, -0.15147763f, 0.05364705f, -0.03020122f, 
    0.14363538f, 0.29910350f, 0.01803717f, 0.09971624f, 0.09131557f, 0.01512965f, 0.07204156f, 0.00606978f, 
    0.03034256f, -0.03142593f, 0.05138639f, -0.04773159f, -0.38356656f, 0.39142290f, 0.16500346f, 0.04242771f, 
    0.34747431f, -0.05285982f, -0.02371109f, -0.03178030f, 0.09518278f, -0.02089403f, 0.20781174f, 0.16441962f, 
    0.14954735f, 0.09172080f, -0.03963035f, 0.06585711f, 0.03139491f, 0.07996846f, 0.01482425f, 0.03078503f, 
    -0.79630113f, -0.51486057f, -0.41019058f, 0.27632278f, 0.25381339f, -0.20955995f, -0.10020399f, -0.00347805f, 
    -0.10375863f, -0.14962956f, 0.01448650f, 0.09514844f, -0.04834934f, 0.00847167f, 0.00776332f, -0.00327530f, 
    -0.02973494f, 0.06399105f, 0.09000382f, -0.05061186f, 0.03765928f, -0.12539683f, -0.12461574f, 0.00301125f, 
    -0.13125788f, 0.06234983f, 0.18548056f, 0.04014819f, -0.10953551f, 0.02005455f, 0.03362349f, -0.06905901f, 
    -0.00197037f, -0.02333026f, -0.01712270f, 0.13487689f, 0.07045059f, 0.05203366f, 0.05651501f, 0.05520068f, 
    -0.36342877f, 0.02337650f, 0.37308317f, 0.02887333f, 0.14210489f, -0.08110015f, -0.00325461f, 0.13997167f, 
    -0.08417507f, 0.31201610f, -0.09800459f, 0.08710561f, 0.10464083f, 0.06949400f, 0.12235975f, 0.02507583f, 
    0.02042956f, -0.03861679f, 0.07088529f, -0.04474914f, -0.25892189f, -0.04815886f, 0.32619575f, -0.16507207f, 
    0.01408602f, -0.18919109f, -0.08417476f, -0.17260900f, -0.13824987f, 0.00204006f, 0.09613427f, -0.10653356f, 
    -0.01821665f, -0.00502580f, 0.04963703f, -0.04263264f, 0.00512655f, -0.10841956f, -0.00062717f, -0.09484373f, 
    -0.05138026f, -0.06103098f, 0.10374022f, 0.13828652f, 0.09357531f, -0.09934296f, -0.08207889f, 0.08502946f, 
    0.03336164f, 0.06423545f, 0.06963847f, 0.09886780f, 0.29458568f, -0.16126870f, 0.13994534f, -0.00018265f, 
    0.01956133f, -0.09764896f, -0.02048571f, -0.16520718f, -0.02529394f, 0.05647107f, 0.03623771f, -0.09563811f, 
    -0.03711161f, -0.01641887f, -0.00586328f, -0.07801243f, -0.11568839f, -0.00464302f, -0.11751640f, -0.18641274f, 
    -0.12687811f, -0.12632804f, -0.16398954f, -0.08065680f, -0.01869445f, -0.07301662f, -0.00822007f, 0.07766905f, 
    -0.36608329f, 0.23174138f, 0.61552447f, 0.12264694f, 0.19984864f, -0.00869277f, -0.13431622f, 0.04542743f, 
    -0.11673327f, 0.22051987f, -0.12851915f, 0.22289217f, 0.09040999f, 0.09864429f, 0.04589200f, 0.02678378f, 
    -0.02618856f, 0.01899467f, -0.00876086f, 0.00743087f, 0.04309370f, -0.02516646f, -0.16130781f, -0.19331674f, 
    0.06137620f, -0.14486319f, -0.14479476f, -0.17314532f, 0.03093580f, -0.07844705f, 0.02326584f, -0.22215249f, 
    -0.10909297f, -0.03230511f, 0.06889835f, -0.03059780f, -0.06896680f, -0.02369791f, 0.03547436f, -0.19403812f, 
    0.23387019f, -0.28064752f, -0.32042485f, 0.00139562f, 0.17724074f, -0.18014401f, 0.13851348f, 0.30347702f, 
    0.17713620f, -0.10763633f, 0.04627531f, -0.03482107f, -0.17323948f, 0.00268924f, 0.04944203f, 0.00031224f, 
    0.06117477f, 0.01496050f, 0.06208179f, 0.02606794f, -0.23347858f, 0.58756769f, 0.06898776f, -0.14902686f, 
    -0.00163763f, -0.24197485f, 0.01816317f, -0.17558663f, 0.06809711f, 0.09508564f, -0.03721283f, 0.00232083f, 
    -0.00104671f, -0.04004022f, 0.03112539f, -0.01040855f, -0.01662056f, 0.02151677f, 0.09377927f, -0.08904784f, 
    0.10995182f, 0.07157478f, -0.01735350f, -0.07472518f, 0.08642342f, -0.00540631f, -0.08605630f, -0.06936188f, 
    0.04384496f, 0.06741190f, -0.16125205f, -0.08015473f, -0.17700917f, -0.06468178f, 0.01571202f, -0.01593526f, 
    -0.09053424f, -0.20557216f, -0.08913388f, -0.06958836f, -0.31198159f, 0.34321198f, 0.29886359f, 0.09791438f, 
    -0.08447970f, -0.10756193f, -0.13222885f, -0.23205404f, -0.18465675f, -0.03868740f, -0.19852544f, 0.07390836f, 
    -0.04942130f, 0.05464808f, 0.00278867f, -0.04296302f, -0.04784529f, 0.03931278f, -0.05797880f, -0.02386836f, 
    -0.22957720f, -0.78571993f, -0.47371110f, -0.08999182f, 0.12457775f, -0.20701069f, -0.18910773f, -0.08770244f, 
    -0.14609092f, -0.07703126f, -0.05147121f, 0.03601011f, 0.03838292f, -0.07107799f, -0.21993816f, 0.05104739f, 
    0.02503064f, -0.06878379f, 0.13257469f, 0.02763958f, -0.59444481f, -0.34710056f, 0.44613704f, 0.14228900f, 
    0.15140963f, -0.14731273f, 0.09680004f, 0.13133155f, -0.00908323f, -0.04916362f, 0.07339133f, -0.02948730f, 
    -0.04213800f, -0.13592397f, 0.04379683f, -0.09293465f, 0.08990754f, 0.02499150f, 0.01121393f, -0.08346679f, 
    0.22344729f, -0.69088018f, -0.49037379f, 0.05174240f, 0.14606827f, 0.06410936f, 0.17152302f, 0.02859939f, 
    0.05175337f, -0.13102530f, 0.03238337f, -0.02064290f, -0.05348926f, 0.05660385f, 0.07392674f, 0.02411130f, 
    0.05956008f, 0.14940129f, 0.00479591f, 0.07140264f, 0.40603235f, 0.11747444f, -0.35416460f, -0.06487235f, 
    0.10402314f, -0.03667132f, -0.02432978f, 0.06183688f, 0.18403052f, -0.06590630f, 0.04867807f, 0.04994801f, 
    0.16171026f, -0.23048706f, -0.12177177f, -0.09185498f, 0.04536141f, -0.16627473f, 0.14080587f, 0.10499457f, 
    -0.04651544f, 0.12855135f, -0.06124873f, 0.01364444f, 0.06672497f, 0.00905978f, 0.01500774f, 0.01563128f, 
    -0.01567739f, 0.01793666f, 0.02647396f, -0.05371347f, 0.07642119f, -0.00020988f, -0.04244923f, 0.08061591f, 
    0.23085943f, -0.16681470f, -0.10965624f, 0.20739102f, -0.39569980f, 0.53879082f, 0.33401173f, -0.02668343f, 
    0.08000255f, -0.14114563f, -0.09147303f, -0.16529830f, -0.10847939f, 0.28953552f, -0.19277413f, 0.05378744f, 
    0.05265349f, 0.04557779f, 0.04234207f, 0.04815636f, -0.06139198f, -0.03831285f, 0.06340184f, -0.07243754f, 
    -0.19192110f, 0.11803705f, 0.00700542f, -0.11662113f, 0.11556022f, 0.02312971f, -0.04482188f, -0.07705013f, 
    -0.07695384f, -0.03243049f, -0.03378818f, 0.01009103f, 0.06992962f, 0.09341951f, 0.17857595f, -0.00587657f, 
    -0.02605696f, -0.04422851f, -0.09370663f, -0.00088652f, -0.49739543f, -1.14480305f, -0.78948498f, -0.23880710f, 
    0.30383375f, 0.06801942f, 0.23193717f, -0.03826515f, -0.20818061f, -0.47244632f, 0.01060707f, -0.02048337f, 
    -0.04468565f, -0.07404901f, 0.07299905f, -0.00542386f, 0.02333774f, 0.07265148f, 0.39745548f, -0.00114056f, 
    -1.00902247f, -0.59425455f, -0.22233708f, 0.19094294f, -0.50567949f, -0.16569349f, -0.00472998f, -0.29478282f, 
    -0.06755435f, -0.41830423f, -0.00302996f, -0.07502496f, 0.03689517f, -0.02669239f, -0.01441960f, 0.01624751f, 
    -0.02512230f, 0.11363632f, 0.04715290f, -0.33650059f, 0.24780242f, 0.20303741f, 0.04904754f, -0.18420392f, 
    0.05817814f, 0.04853036f, -0.02265960f, -0.01309181f, -0.01210023f, -0.08828778f, -0.02056336f, 0.01625987f, 
    -0.11730716f, -0.05310948f, 0.00578752f, 0.06236341f, -0.16146620f, -0.12519404f, -0.22961205f, 0.03412762f, 
    0.08434328f, 0.10576877f, -0.03927135f, -0.00657340f, -0.05162486f, -0.02097572f, 0.00886684f, 0.04804040f, 
    -0.07384419f, -0.13354006f, -0.13135940f, -0.02775277f, 0.06239149f, -0.12785262f, -0.06352415f, -0.11651161f, 
    0.00254739f, 0.03234756f, -0.04830558f, 0.01151545f, -0.25290832f, 0.16581793f, -0.07789361f, -0.13192150f, 
    -0.13807894f, 0.06561519f, 0.04323769f, -0.12260060f, -0.16171382f, -0.00549994f, 0.05921448f, 0.02061855f, 
    0.04929620f, -0.00730424f, -0.02263381f, 0.08194411f, -0.00056846f, -0.06857977f, -0.12323675f, -0.03727915f, 
    -0.70334136f, -0.63640493f, 0.13802451f, -0.08179943f, 0.31507194f, -0.11657276f, 0.07289980f, 0.11220635f, 
    0.06659981f, -0.04618535f, -0.02320180f, 0.03929857f, -0.02766347f, -0.06239616f, -0.07767548f, -0.00886893f, 
    0.00531302f, -0.05521409f, 0.14364070f, -0.11038931f, -0.18255824f, -0.43333662f, 0.23206122f, 0.70150310f, 
    -0.03473714f, -0.03753760f, 0.14490816f, -0.25541064f, 0.13595268f, 0.24603498f, -0.01200076f, -0.00770527f, 
    -0.02056538f, 0.05346188f, -0.05635278f, 0.02704415f, 0.11433867f, -0.11179791f, 0.03733353f, 0.03131744f, 
    0.53363419f, -0.53801298f, -0.37301517f, 0.47089681f, -0.20231403f, -0.00727889f, 0.01218767f, -0.01367041f, 
    0.01462848f, 0.14494644f, 0.06145660f, -0.04162584f, -0.04168780f, -0.04322487f, -0.03110265f, 0.00743210f, 
    -0.02196467f, 0.00671365f, 0.08909218f, -0.09211134f, 0.25898230f, 0.42383084f, -0.21550766f, -0.08204572f, 
    -0.21556662f, 0.09464297f, 0.06240818f, 0.00665342f, -0.03983970f, -0.02393429f, -0.01658453f, 0.17193566f, 
    0.19730690f, -0.13301137f, -0.19813301f, 0.00525106f, -0.04499169f, 0.05041019f, 0.02370708f, -0.02585892f, 
    -0.23738639f, 0.00089322f, -0.02479443f, 0.04059282f, -0.12551135f, 0.07799299f, -0.08040357f, 0.12941040f, 
    -0.04824778f, -0.05940193f, -0.22130069f, 0.04344948f, 0.09319980f, 0.04862041f, -0.08340263f, -0.02354831f, 
    -0.04836152f, 0.08206252f, -0.02436468f, 0.04756180f, -0.78996491f, -0.11803953f, -0.03756649f, 0.24864435f, 
    -0.22647789f, 0.14710778f, 0.22597468f, 0.00799342f, -0.01739882f, -0.04641268f, 0.07359686f, -0.05178358f, 
    0.01944378f, -0.10586419f, -0.13127616f, 0.08160846f, -0.04375455f, -0.08852680f, 0.11888579f, -0.05307270f, 
    0.88147807f, 0.21399744f, -0.28226334f, -0.06416427f, -0.43723384f, 0.00327218f, -0.05387459f, -0.04549511f, 
    -0.24403945f, -0.18106216f, -0.05993998f, -0.05118126f, -0.00904530f, 0.04555197f, -0.15088747f, -0.02360550f, 
    -0.08603249f, 0.05516627f, -0.03151698f, 0.01177582f, -0.12886843f, -0.40263829f, -0.06576078f, 0.00543566f, 
    0.08116472f, 0.06462761f, 0.01704029f, 0.22886807f, 0.03117334f, -0.03303611f, -0.12297510f, 0.14800537f, 
    0.05566321f, 0.01669491f, -0.02790432f, 0.00483503f, -0.03842290f, -0.04612098f, 0.08330508f, 0.09398285f, 
    0.63740557f, -0.55836564f, -0.47897592f, -0.26400849f, 0.03257069f, 0.08138477f, -0.13647418f, -0.01297838f, 
    0.05460070f, 0.06812669f, 0.00139085f, 0.01698930f, -0.04481897f, -0.03863176f, -0.03144678f, 0.00679628f, 
    -0.00839253f, -0.03327591f, 0.05236471f, -0.02989179f, 0.03787899f, 0.11823110f, 0.18591042f, -0.16603236f, 
    -0.06748652f, -0.03141806f, -0.01762653f, -0.08501235f, 0.00909694f, -0.01478205f, 0.03022205f, 0.01002724f, 
    0.03667511f, 0.00047945f, -0.07055296f, -0.12186677f, -0.08657135f, -0.24542181f, 0.10545721f, -0.06175860f, 
    0.55134666f, 0.23191023f, -0.35020438f, -0.06748440f, -0.29549885f, 0.01138839f, -0.01672772f, -0.00876729f, 
    -0.08363952f, 0.00166391f, -0.04252223f, -0.02552527f, 0.02546743f, 0.12893511f, -0.06525931f, -0.01941885f, 
    -0.06107726f, -0.00150489f, -0.01914795f, -0.03833996f, 0.06657413f, 0.01269967f, -0.12404075f, 0.05488156f, 
    -0.03232391f, 0.16453122f, -0.00508346f, 0.05142254f, -0.02193378f, -0.11750135f, 0.07828859f, -0.01749255f, 
    0.15263546f, 0.05263662f, -0.00480539f, 0.00825699f, -0.05970499f, -0.02571274f, -0.04883486f, -0.04332044f, 
    0.27771404f, 0.23410153f, 0.00814030f, -0.11546596f, -0.18887624f, 0.07003252f, -0.01782998f, 0.03173373f, 
    -0.01574064f, -0.06498304f, -0.12317690f, -0.16664451f, -0.11225595f, 0.02579292f, -0.07147095f, 0.01401365f, 
    -0.09636946f, 0.01485390f, -0.06541821f, -0.04017067f, 0.07094491f, 0.13877529f, 0.03021346f, 0.10306147f, 
    -0.11333875f, 0.05656721f, 0.06706087f, 0.02565586f, 0.00322249f, -0.02356232f, 0.00243213f, 0.01559074f, 
    0.04725745f, -0.03639646f, 0.00695681f, 0.09435814f, -0.02145473f, 0.07087703f, -0.03353953f, 0.03110430f, 
    0.41944373f, 0.05548441f, -0.12142471f, -0.11708017f, -0.17590685f, -0.04459695f, -0.00755870f, -0.04855103f, 
    -0.00144822f, -0.03247407f, 0.03894610f, -0.08919741f, 0.12889847f, 0.00853819f, 0.01802867f, 0.01198830f, 
    0.00374425f, 0.00551504f, 0.04316225f, 0.04407016f, 0.06121162f, -0.07431404f, -0.15929708f, 0.10740199f, 
    -0.09058586f, 0.10877799f, 0.02512228f, 0.08571098f, 0.02514644f, 0.07521556f, -0.01201874f, -0.15340817f, 
    0.16539706f, 0.08957922f, 0.01901892f, 0.03094884f, 0.01352351f, 0.01014733f, -0.00750065f, 0.04161279f, 
    -0.10720932f, 0.14480124f, 0.03271580f, -0.00216413f, -0.16773899f, 0.05563881f, -0.03332286f, -0.13296421f, 
    -0.00044417f, 0.01931094f, 0.01877645f, -0.00278750f, 0.07145037f, 0.03455174f, -0.00835215f, 0.02178839f, 
    -0.09945534f, -0.05795022f, 0.12437153f, 0.10098896f, -0.09019005f, -0.40218535f, -0.25687319f, 0.01578883f, 
    -0.00537208f, 0.09741729f, -0.14738315f, 0.11010086f, 0.06506763f, -0.05573052f, -0.07780594f, -0.00309967f, 
    0.04542756f, 0.03474329f, 0.00072275f, 0.00223510f, 0.01599212f, 0.03220792f, -0.05039058f, -0.08530312f, 
    -0.01705141f, 0.12727186f, -0.08380481f, -0.00447513f, -0.02546067f, 0.04761828f, -0.01305276f, -0.01527920f, 
    -0.01887637f, -0.04463902f, -0.04182345f, -0.19195828f, -0.07739064f, 0.00738080f, -0.08016393f, -0.01308947f, 
    -0.00977822f, 0.00921575f, 0.00105366f, -0.00073823f, 0.19517539f, -0.33445069f, -0.05186373f, -0.08525068f, 
    -0.11998539f, 0.01448694f, 0.07299921f, 0.09352785f, -0.00628689f, 0.05518626f, 0.01148969f, -0.00896919f, 
    0.08244571f, 0.02786335f, 0.01055065f, 0.03094297f, -0.03062504f, -0.05442590f, -0.04197720f, -0.04206651f, 
    0.67390215f, -0.85007930f, -0.74180597f, -0.81197387f, -0.24529159f, -0.09363488f, -0.04778132f, -0.15510027f, 
    0.39662096f, 0.02926660f, 0.01720521f, 0.03671079f, -0.02828892f, -0.09102599f, 0.08312152f, -0.14087479f, 
    -0.02120593f, -0.08816584f, 0.08702832f, -0.04349034f, 0.58236283f, 0.16758610f, -0.32896701f, 0.14501992f, 
    -0.36356327f, -0.06087027f, -0.03305811f, 0.08523334f, -0.01488515f, 0.04158717f, -0.19115531f, -0.00569259f, 
    -0.00298049f, -0.06892148f, 0.05925714f, 0.00901403f, -0.01669810f, 0.06919999f, -0.18857744f, -0.12527630f, 
    -0.62741792f, -0.56702960f, 0.31671861f, 0.16832697f, 0.12211234f, -0.01207587f, 0.02168485f, -0.09759197f, 
    -0.12091117f, -0.00500940f, 0.06726009f, 0.02194884f, -0.02858872f, -0.00142926f, -0.06071813f, 0.04079857f, 
    -0.00254034f, -0.09617423f, -0.03793697f, -0.13584271f, 0.01934858f, 0.23918533f, 0.00146666f, 0.04640337f, 
    -0.17607626f, -0.16497579f, 0.09216405f, 0.03139496f, -0.19167221f, -0.02652614f, 0.02283258f, 0.08191575f, 
    0.02380496f, -0.07491010f, 0.12496458f, -0.18794358f, -0.13256256f, 0.09305758f, -0.19384952f, 0.08446108f, 
    -0.00555713f, 0.01802177f, -0.02213454f, 0.14051448f, -0.09723369f, -0.01877666f, 0.04505387f, 0.08979594f, 
    -0.08135360f, -0.06098978f, -0.00733458f, 0.04132484f, 0.05957828f, 0.02636978f, -0.02906675f, -0.04047007f, 
    -0.10378663f, -0.16774318f, 0.00164597f, 0.01737728f, 0.46766162f, -0.13859995f, -0.28319150f, -0.14164437f, 
    -0.20873065f, 0.06994134f, -0.06426682f, -0.06029685f, 0.01487974f, -0.16046649f, 0.03194686f, 0.04128598f, 
    -0.00399352f, 0.01249117f, 0.04531053f, -0.00261066f, -0.03443057f, -0.05249143f, 0.03190105f, -0.01957109f, 
    0.04357842f, 0.14146930f, -0.12037178f, -0.04081466f, -0.09387097f, 0.03305697f, 0.07028920f, 0.07379226f, 
    0.00420246f, -0.04715802f, -0.13078782f, -0.21072018f, -0.38706106f, -0.10742705f, -0.18627977f, 0.01328298f, 
    -0.00007572f, 0.01386033f, 0.05278608f, 0.00238292f, -0.78884101f, -0.79565603f, 0.40690282f, 0.62286329f, 
    0.29959285f, 0.08057055f, 0.06034593f, 0.00422996f, -0.15228097f, 0.11888667f, 0.10357111f, 0.04236298f, 
    0.00489432f, -0.03862190f, -0.04610730f, 0.03477962f, 0.00428716f, -0.14965972f, 0.05069270f, -0.01751814f, 
    -0.31935373f, -0.55518079f, -0.09546634f, -0.15337664f, -0.08074339f, -0.00039398f, 0.08163997f, 0.02159351f, 
    -0.12358008f, 0.18532136f, -0.03509143f, -0.03081058f, 0.06002357f, -0.00586457f, -0.01012331f, 0.03869164f, 
    0.05735748f, -0.02148071f, -0.05447339f, -0.09756269f, -0.08684852f, 0.09654482f, 0.05311172f, 0.00756511f, 
    -0.04458030f, -0.00252183f, -0.01392332f, 0.05111910f, -0.00609397f, -0.01531135f, 0.04656311f, -0.02218481f, 
    0.06102519f, -0.00456786f, -0.02306864f, 0.01749421f, -0.06233564f, -0.03539823f, -0.02499241f, 0.07580235f, 
    -0.05173825f, 0.06791272f, 0.08435826f, 0.08023197f, -0.21268207f, -0.10466379f, -0.01762493f, 0.08141103f, 
    0.09756876f, -0.02951857f, 0.01989824f, 0.00211273f, -0.00992536f, 0.10343008f, 0.11546466f, 0.10532005f, 
    0.14534611f, 0.05792288f, 0.07440744f, 0.12258411f, -0.31510204f, 0.30032742f, 0.39787322f, 0.26324508f, 
    -0.15988350f, 0.02108817f, -0.15110758f, -0.14054130f, -0.13339299f, -0.10651383f, -0.06443150f, -0.03973261f, 
    -0.03276269f, -0.10849682f, -0.06435808f, -0.17686397f, -0.18574220f, -0.04772058f, -0.28372192f, -0.25061330f, 
    0.51064581f, -0.98266327f, -0.68858856f, 0.00786048f, 0.20522650f, -0.01189643f, -0.11352550f, 0.06501999f, 
    -0.05067175f, -0.08759248f, 0.02055775f, -0.02106175f, 0.07839900f, -0.00897481f, 0.05712615f, 0.02695259f, 
    0.02128435f, 0.07276728f, -0.13883992f, 0.00132480f, 0.18761835f, 0.15796965f, -0.02435016f, -0.30858231f, 
    -0.06854678f, -0.03401694f, -0.45391271f, -0.16963200f, -0.12524162f, -0.27848345f, 0.00727569f, 0.10931455f, 
    0.02783599f, 0.05634646f, 0.01249999f, 0.07119520f, 0.01726286f, -0.17659153f, -0.07558260f, -0.53453815f, 
    0.16699460f, -0.45860171f, -0.88132554f, -0.50320894f, -0.06404111f, 0.09418450f, -0.21728913f, -0.16112189f, 
    0.14455345f, -0.15084355f, 0.00464454f, 0.01347400f, 0.00222715f, 0.02770997f, -0.01453525f, 0.03516680f, 
    0.00842393f, 0.03002414f, 0.02868494f, -0.00503512f, 0.04574897f, -0.11820082f, -0.18166012f, -0.23695970f, 
    -0.20636778f, -0.12688436f, -0.08230785f, -0.04427617f, 0.09826358f, -0.06569669f, 0.04601328f, 0.03411061f, 
    0.06558196f, 0.05808199f, -0.05914221f, -0.00058214f, -0.00616087f, -0.11536988f, 0.08971076f, 0.00085649f, 
    -0.43764740f, -0.18859261f, 0.14309300f, 0.06843795f, -0.01111697f, -0.12543355f, 0.08967604f, 0.01418547f, 
    -0.07133112f, 0.07488365f, 0.07786731f, 0.02117637f, 0.00668366f, 0.15088631f, 0.01765871f, 0.02318096f, 
    0.15022163f, -0.08162427f, 0.15022358f, 0.03716536f, 0.34984612f, -0.04803522f, -0.37164909f, -0.01830527f, 
    -0.00791143f, 0.03770570f, -0.02722677f, 0.25934321f, 0.12043045f, -0.23037140f, -0.03642269f, 0.07262163f, 
    -0.01986775f, -0.02988024f, 0.00684804f, 0.10728935f, 0.11413651f, 0.09369370f, 0.19039701f, 0.21621783f, 
    0.29597464f, -0.89549112f, -0.52753174f, -0.08460838f, 0.02249311f, -0.06137302f, 0.24648137f, 0.07893225f, 
    0.16572876f, 0.03278969f, -0.00414271f, 0.06202816f, -0.04145418f, -0.10532587f, -0.01973680f, 0.04518016f, 
    -0.00030849f, -0.09464424f, 0.04555030f, -0.14712641f, -0.27337581f, -0.59733522f, 0.07986844f, 0.08666639f, 
    0.27690226f, -0.08946547f, 0.08359970f, 0.09430765f, -0.05598522f, -0.03812668f, 0.01144242f, -0.07429382f, 
    -0.06688719f, -0.02122934f, -0.02219785f, -0.07357886f, -0.03458671f, -0.05546101f, -0.07059467f, -0.06988876f, 
    -0.33593795f, -0.26191229f, -0.69306397f, -0.27269974f, -0.18688706f, 0.01632860f, -0.02601191f, 0.08945344f, 
    0.02494819f, -0.21883006f, 0.01303506f, -0.01295614f, -0.07266254f, 0.03075131f, -0.00327848f, 0.04357152f, 
    0.03352986f, -0.02132071f, 0.01866529f, 0.01370936f, -0.23579521f, 0.15231058f, 0.23018678f, 0.10580414f, 
    -0.04090714f, 0.03470859f, -0.11645148f, -0.04517781f, 0.01843246f, -0.15719634f, -0.06357864f, 0.00367392f, 
    -0.01836729f, -0.06027352f, 0.00086393f, -0.03218954f, 0.01792820f, -0.11577166f, -0.12953080f, 0.11958174f, 
    0.15802263f, -0.28460097f, -0.34093940f, -0.23472533f, -0.15450819f, -0.08333778f, 0.13570160f, 0.09994768f, 
    0.08731479f, -0.03974354f, 0.01114286f, 0.15039931f, -0.03271545f, -0.02913488f, 0.01876756f, 0.00496007f, 
    -0.00342388f, -0.02288965f, 0.05479535f, -0.05927409f, 0.11743665f, -0.04382012f, -0.17073640f, -0.03667910f, 
    -0.14992681f, -0.09592639f, -0.00759260f, -0.05629800f, -0.02509047f, -0.02002820f, 0.07286245f, 0.03561781f, 
    0.08180001f, -0.03939854f, 0.01075305f, 0.02695514f, 0.11758244f, 0.03259044f, 0.15322970f, 0.09454428f, 
    0.31459594f, 0.00134690f, -0.10526164f, -0.16266587f, 0.03221334f, -0.04759180f, 0.21595174f, -0.02506156f, 
    0.10248005f, -0.05728982f, 0.04125357f, 0.22149895f, 0.10842974f, -0.08992260f, 0.11497644f, 0.03369534f, 
    -0.02073771f, -0.01808625f, 0.08483250f, 0.03646060f, -0.37657475f, 0.12524466f, 0.24272837f, 0.02807818f, 
    -0.29986870f, -0.14308712f, -0.08773883f, -0.09783136f, -0.02223060f, -0.03736806f, -0.17177588f, -0.04636531f, 
    0.04874058f, -0.08984821f, -0.04758019f, -0.00648366f, 0.03840685f, -0.03083720f, -0.04802193f, -0.03818244f, 
    -0.06141320f, -0.31295887f, -0.50825191f, 0.00573947f, -0.05403084f, -0.09657385f, 0.12854062f, 0.15178899f, 
    0.06953730f, 0.05676115f, 0.10295263f, 0.02124648f, 0.02915232f, -0.00818146f, 0.02655552f, -0.04178560f, 
    0.05914468f, -0.02195321f, 0.02210741f, -0.01966478f, 0.07669357f, -0.10078792f, -0.13033623f, 0.00109607f, 
    -0.05655221f, -0.09557799f, -0.05712904f, -0.15267433f, -0.07550313f, -0.10252313f, -0.04641550f, 0.07680094f, 
    0.11909143f, 0.02445479f, -0.05338564f, 0.02719790f, 0.14483818f, 0.18715744f, 0.20465165f, 0.22104259f, 
    -0.26130307f, 0.07804819f, 0.14172731f, 0.14941871f, -0.22383116f, -0.00118429f, -0.07976358f, 0.09446041f, 
    0.02582454f, -0.16513509f, -0.01585787f, 0.07299614f, 0.03017833f, -0.02678991f, -0.02035280f, 0.09695280f, 
    0.04292801f, 0.08878843f, 0.08253203f, 0.01040397f, 0.42626235f, -0.30540922f, -0.48729330f, -0.06072111f, 
    0.19645925f, -0.01891727f, -0.07639626f, -0.00887816f, 0.10458753f, 0.21509835f, -0.05695829f, -0.05840082f, 
    -0.07706705f, -0.01705849f, -0.03012496f, -0.05896494f, 0.03513708f, -0.00194735f, 0.09548832f, 0.08201703f, 
    -0.13830903f, 0.00727815f, -0.01215458f, 0.04054700f, -0.13006568f, -0.05332401f, -0.01936173f, -0.07089772f, 
    0.01418043f, 0.00711580f, 0.01446410f, 0.04383691f, -0.01106997f, 0.14971560f, 0.02589342f, 0.03355556f, 
    0.10673944f, 0.09886122f, 0.08966603f, 0.10011847f, -0.00130502f, -0.27024922f, -0.34617230f, 0.02114343f, 
    0.12449280f, -0.06708153f, -0.00320518f, 0.03429065f, 0.04335379f, 0.23804103f, 0.00271155f, -0.04820214f, 
    -0.09440798f, -0.04200218f, 0.00241512f, -0.09201029f, 0.17080648f, 0.10594065f, 0.07969781f, 0.09322263f, 
    -0.16425490f, -0.21753375f, -1.02597249f, -0.45147324f, -0.08183957f, -0.06338932f, 0.00241827f, 0.27578193f, 
    0.07281102f, -0.04765658f, -0.06486420f, -0.08947036f, -0.03163769f, 0.05015451f, 0.08561368f, 0.03165672f, 
    -0.02539949f, 0.09206145f, -0.13442010f, -0.12782183f, 0.48258534f, 0.08731256f, -0.12395512f, 0.06023874f, 
    -0.30460894f, -0.16228861f, 0.16741541f, 0.21512921f, 0.07575620f, -0.26996702f, 0.18137665f, 0.31157017f, 
    -0.02080579f, 0.06237065f, 0.15028119f, -0.11284282f, 0.06422623f, -0.02156892f, 0.04505021f, 0.03906735f, 
    0.75600600f, 0.02153199f, 0.05338463f, 0.11399720f, -0.08590076f, 0.09654309f, -0.10150567f, -0.10881218f, 
    -0.12101317f, 0.01725118f, -0.01732758f, 0.12197356f, 0.04214216f, -0.04291508f, 0.05543880f, 0.04400757f, 
    0.10715482f, 0.03432876f, -0.10374916f, 0.13770039f, 0.19784462f, 0.32538724f, 0.11616591f, -0.01190315f, 
    0.13922836f, -0.08791698f, 0.18487410f, -0.02879787f, 0.13861065f, -0.13812338f, 0.03489336f, -0.05596066f, 
    0.00698357f, -0.02345236f, 0.08216089f, 0.09499204f, -0.00807681f, -0.03689260f, 0.13718167f, -0.11462575f, 
    -0.21497801f, 0.05042132f, 0.19071628f, 0.01929296f, 0.04455863f, 0.00479480f, -0.00660023f, -0.02820547f, 
    -0.04625842f, 0.02798856f, 0.06719737f, -0.05143868f, -0.06861229f, 0.02086044f, -0.01280070f, -0.10776957f, 
    0.02082482f, 0.03205299f, -0.09254454f, -0.11503533f, -0.00386418f, -0.37989688f, -0.53198737f, -0.23198766f, 
    0.03478398f, -0.01001123f, 0.05895571f, 0.10556474f, 0.06638657f, 0.12562945f, 0.05101166f, -0.04768298f, 
    -0.10275380f, -0.01327686f, -0.07440689f, 0.00886212f, -0.01241201f, 0.03227520f, 0.08902148f, -0.02543800f, 
    -0.31308863f, -0.09537863f, 0.01923659f, -0.07083010f, -0.10806567f, -0.04838641f, 0.02430662f, -0.00232934f, 
    -0.05140203f, -0.02562524f, 0.12432978f, 0.00017732f, 0.04948497f, 0.06337765f, 0.08610956f, 0.03708414f, 
    0.02755086f, -0.01281018f, 0.00369345f, -0.01300345f, 0.98536134f, -0.06380685f, -0.17730494f, -0.14887552f, 
    -0.28989926f, 0.07495674f, -0.15476872f, -0.26491719f, 0.06119416f, -0.19522595f, 0.00786355f, 0.02535173f, 
    0.10321203f, 0.00078758f, 0.01450488f, 0.00068235f, 0.08914077f, 0.02168874f, 0.06183885f, 0.00639079f, 
    -0.02955846f, -0.59846175f, -0.78435254f, -0.03738546f, 0.02740671f, -0.14825599f, 0.00618373f, 0.07000002f, 
    0.11947805f, 0.12151988f, -0.06133102f, 0.00494488f, -0.07820824f, -0.06849094f, 0.04376617f, -0.03440510f, 
    0.08816412f, 0.02322159f, 0.13515350f, 0.07284212f, -0.45903647f, -0.08355296f, 0.21748307f, 0.08325252f, 
    0.02237112f, -0.08537665f, 0.02447824f, -0.05081779f, 0.00478480f, 0.09835487f, 0.00559825f, 0.01522593f, 
    0.03081439f, 0.13588856f, 0.10067030f, 0.05063180f, 0.02789943f, -0.02123873f, 0.03637866f, 0.16535927f, 
    -0.20637663f, 0.09771698f, -0.01965053f, 0.17032970f, 0.05589109f, -0.05691636f, -0.01564471f, 0.01793422f, 
    0.01369706f, -0.03750409f, 0.04643592f, 0.08056942f, -0.06424772f, 0.06714411f, -0.11421478f, 0.07006334f, 
    -0.08294374f, 0.00812044f, -0.08748613f, 0.00962181f, -0.04535801f, -0.16604766f, -0.70570529f, 0.10317107f, 
    0.07390899f, 0.20092933f, 0.11494543f, 0.20276645f, -0.03562056f, 0.12668197f, 0.00896204f, -0.05394197f, 
    -0.00957615f, -0.01122189f, -0.06907132f, -0.04344876f, 0.09116375f, 0.02046345f, 0.03721794f, 0.08697026f, 
    -0.03632345f, -0.08239699f, 0.47192603f, -0.06345877f, -0.17319266f, -0.32233438f, -0.24715084f, 0.08140439f, 
    0.02582151f, 0.27431971f, -0.04154517f, 0.08900613f, 0.05598476f, 0.03776836f, -0.03877941f, 0.07137286f, 
    0.06083679f, 0.13194713f, 0.01995755f, -0.00898201f, -0.36058325f, -0.39429268f, -0.61318123f, 0.34036225f, 
    -0.27704927f, -0.10538786f, 0.03690519f, -0.05116532f, -0.01742174f, 0.16281065f, 0.12282579f, 0.00745842f, 
    0.03691678f, 0.09839430f, -0.03201410f, -0.02476211f, 0.02645988f, -0.04013640f, 0.26753244f, 0.25046909f, 
    -0.63843966f, -0.04306689f, 0.09584260f, 0.24421871f, -0.30353695f, 0.13681298f, -0.53448230f, 0.20858523f, 
    -0.15019096f, 0.17823707f, 0.01849794f, 0.04145712f, 0.06054996f, 0.00583336f, -0.03692341f, 0.03595035f, 
    0.03046554f, 0.16703944f, 0.22890635f, -0.15064250f, -0.59844643f, 0.42631626f, -0.13271058f, 0.59963423f, 
    0.03939101f, -0.23610768f, -0.05793469f, -0.10260587f, 0.12817463f, -0.29377234f, 0.12131077f, 0.02902213f, 
    -0.00054517f, -0.20221715f, -0.12022019f, 0.06523450f, -0.08689936f, -0.12299025f, 0.06709810f, 0.01214070f, 
    0.02725131f, -0.11903255f, 0.33834052f, -0.46223965f, -0.04326708f, -0.01379366f, -0.16588253f, -0.04613005f, 
    0.07536809f, -0.14228804f, -0.14064859f, 0.12623566f, -0.08683487f, -0.01610289f, 0.19348043f, 0.11340828f, 
    -0.01247141f, -0.01614244f, -0.13892895f, 0.10895997f, -0.54113597f, 0.15309319f, -0.82854819f, 0.05362935f, 
    -0.26543340f, -0.12196214f, -0.02315666f, -0.04588749f, -0.01080845f, 0.00922085f, -0.01577593f, -0.07071150f, 
    -0.08548278f, -0.12563355f, -0.05345635f, -0.15361239f, -0.07020915f, 0.19069175f, 0.14538419f, -0.15924165f, 
    -0.05345088f, 0.13284041f, 0.14634937f, 0.47613168f, -0.59703946f, 0.24355659f, -0.34741235f, -0.25638306f, 
    -0.19422811f, -0.07800138f, -0.04721864f, -0.00149600f, 0.09409951f, 0.10675450f, 0.09770231f, -0.04368398f, 
    -0.07188208f, -0.00261359f, -0.02977574f, 0.09143057f, 0.09232873f, -0.14036688f, 0.22722729f, 0.21724996f, 
    -0.32440379f, 0.04448168f, -0.09823807f, -0.16611332f, 0.16325489f, -0.14308937f, -0.03530431f, 0.06889448f, 
    0.10968433f, 0.03362153f, 0.05119658f, 0.05910323f, 0.01467668f, -0.00357075f, -0.04429924f, 0.16291116f, 
    -0.88234371f, -0.29873088f, -0.06883090f, -0.11604767f, -0.30785209f, -0.07324700f, -0.08447244f, -0.06476128f, 
    0.01006784f, 0.17772095f, -0.00956467f, -0.11761122f, 0.08456563f, 0.04028480f, -0.04523316f, 0.02798123f, 
    0.05216918f, 0.07815490f, 0.04112136f, -0.02166642f, 0.08385895f, -0.54152262f, -0.01741731f, 0.12104051f, 
    0.09141572f, -0.01424422f, 0.16945121f, 0.16403373f, -0.03736025f, 0.14700256f, -0.03987451f, -0.00385793f, 
    -0.08623845f, 0.03723250f, -0.06273524f, -0.02893202f, 0.13978533f, 0.07407874f, -0.04226331f, 0.03655408f, 
    -0.29831868f, 0.25579795f, 0.15175968f, 0.54428273f, -0.09394384f, 0.07849855f, -0.03846159f, -0.28967759f, 
    -0.18457650f, -0.05030262f, 0.15229164f, -0.09928153f, 0.13479775f, 0.03902252f, 0.04278181f, 0.08540402f, 
    0.00417266f, -0.09124063f, -0.03033238f, -0.02187171f, -0.16231063f, -0.00298626f, 0.07473195f, 0.24222614f, 
    0.04547434f, 0.08033437f, 0.07718466f, -0.17450897f, -0.06494903f, -0.24434970f, -0.06886418f, -0.04949291f, 
    -0.07572271f, -0.02072864f, -0.05626416f, 0.07934092f, -0.12096970f, -0.16522193f, -0.10018801f, -0.09267927f, 
    -0.52460229f, 0.07238984f, -0.18302263f, 0.08095169f, 0.09623580f, 0.12404989f, -0.08180020f, -0.00079845f, 
    -0.32873744f, -0.08627073f, -0.05619639f, 0.03599508f, -0.06415235f, -0.10172469f, -0.06610821f, -0.12432190f, 
    0.05608114f, -0.20575404f, -0.07347650f, -0.01007079f, -0.12371378f, -0.01397664f, -0.19921729f, -0.00219516f, 
    0.30165520f, -0.06988650f, -0.05393902f, 0.14949010f, -0.01803870f, -0.00680326f, -0.04076236f, 0.09755675f, 
    0.04814083f, -0.06761009f, -0.07548348f, 0.09320018f, 0.06498300f, 0.02122686f, -0.08263822f, 0.14141139f, 
    0.07233870f, 0.17439727f, 0.11740300f, 0.27936226f, -0.04782883f, -0.00848545f, -0.03502239f, -0.36976391f, 
    -0.08595642f, -0.15572943f, 0.13383085f, 0.01207366f, 0.07253325f, 0.13654436f, 0.07773636f, 0.10024373f, 
    0.03796811f, 0.00868318f, 0.03798611f, 0.01649341f, -0.10924440f, 0.34377214f, 0.13589789f, 0.04840653f, 
    -0.14487158f, 0.15336128f, 0.07679525f, 0.14630815f, 0.04355095f, 0.00099292f, 0.06140439f, 0.11085142f, 
    0.09637164f, -0.16528806f, -0.04973624f, 0.05052143f, -0.00921501f, -0.14340919f, -0.02756091f, -0.27052635f, 
    -0.06192344f, 0.17071383f, -0.55623090f, 0.04430772f, -0.23603067f, 0.24677500f, 0.04505249f, 0.20825884f, 
    -0.08105782f, 0.08909332f, -0.01083621f, -0.08534075f, -0.17327908f, -0.04228709f, -0.06559755f, -0.01826977f, 
    -0.06764995f, -0.03510856f, -0.01091022f, 0.02423881f, -0.16218475f, -0.16676675f, 0.54660314f, 0.25028238f, 
    -0.50963360f, 0.20376022f, -0.28103054f, -0.08104941f, 0.00915737f, 0.00613943f, 0.00678096f, -0.05789250f, 
    0.09089085f, 0.01881139f, -0.01343184f, 0.02194334f, -0.02475795f, -0.07360908f, -0.01896515f, -0.04347649f, 
    -0.13653949f, 0.15136525f, -0.02559728f, -0.02102397f, -0.10427468f, 0.04039154f, 0.03794599f, -0.02109895f, 
    -0.00308497f, -0.14305136f, 0.07656280f, 0.13255632f, -0.05376725f, -0.00405130f, -0.09871247f, 0.03744672f, 
    0.00464582f, -0.07637267f, 0.02405552f, -0.00596793f, 0.13571829f, -0.05387889f, 0.35190296f, -0.11186524f, 
    -0.11949463f, -0.05403116f, 0.02002369f, -0.16355260f, -0.06012880f, 0.03596231f, 0.04119870f, 0.01852680f, 
    0.11933565f, 0.04660694f, 0.03932018f, 0.06274261f, -0.11254103f, -0.04572422f, -0.03043450f, -0.03769157f, 
    -0.23715554f, -0.12630680f, -0.04334750f, 0.56632501f, -1.05648053f, -0.21433818f, 0.08749560f, -0.32574970f, 
    0.18310875f, 0.17373048f, 0.17516835f, -0.02431170f, 0.13606878f, 0.06811621f, 0.05128011f, 0.10473873f, 
    0.18255419f, 0.19450447f, 0.14899549f, 0.17409459f, -0.85773903f, -0.17574148f, -0.19747220f, -0.34142581f, 
    0.11795431f, -0.10085731f, 0.19338292f, -0.28494152f, -0.33288360f, 0.15158899f, 0.05922750f, -0.11317442f, 
    -0.08210577f, -0.03526117f, 0.17747003f, 0.25909948f, -0.30729470f, -0.12471632f, -0.06989600f, -0.14331222f, 
    0.29393455f, -0.02211172f, -0.44601122f, 0.11465909f, -0.02415163f, 0.26235536f, 0.02855187f, 0.14569524f, 
    0.04243042f, 0.01910991f, -0.02926052f, -0.04306180f, -0.02353994f, -0.07447267f, -0.03703139f, 0.00176309f, 
    0.01025731f, -0.10184994f, -0.06958194f, -0.00928850f, -0.98573828f, -0.04275037f, -0.62262875f, 0.02257775f, 
    0.02689436f, -0.01983855f, -0.04492002f, 0.12875327f, -0.29320681f, -0.07585411f, -0.07802202f, 0.06245098f, 
    -0.05720765f, -0.04217548f, 0.05833630f, 0.10055096f, 0.22299764f, -0.18541451f, 0.05875263f, 0.17578797f, 
    -0.11798345f, -0.18314034f, -0.25597852f, -0.20670153f, 0.11124649f, 0.04222301f, -0.00991600f, 0.07770040f, 
    0.00542972f, -0.10492034f, -0.05123479f, 0.03729938f, -0.03353023f, -0.07610741f, 0.06653407f, 0.16394246f, 
    0.05176871f, -0.03198875f, -0.04912151f, 0.03974863f, -0.05965671f, -0.03286678f, 0.34823045f, 0.43349940f, 
    -0.43416879f, 0.16064094f, -0.06472840f, -0.31665882f, -0.07602393f, -0.26291955f, 0.10654062f, -0.05145631f, 
    0.02502911f, 0.10198490f, 0.07981318f, 0.01412443f, -0.01003061f, -0.06358320f, 0.00734464f, 0.05532398f, 
    0.04067657f, 0.07093534f, 0.19974881f, 0.01085999f, 0.03410251f, -0.04679761f, -0.09495666f, 0.02278274f, 
    0.11408601f, -0.09570852f, 0.10867572f, 0.18044759f, 0.14856601f, 0.02646621f, -0.18403707f, 0.13163348f, 
    0.06797022f, 0.00759167f, -0.11541163f, -0.00941936f, 0.35049060f, 0.11278649f, -0.65956467f, 0.19109295f, 
    -0.23771328f, -0.01086581f, -0.03235595f, 0.10482633f, -0.09727946f, 0.05917617f, -0.02518753f, -0.02654506f, 
    0.00574746f, -0.00393265f, -0.13546790f, 0.07301121f, 0.00744675f, -0.02423075f, 0.02296162f, -0.01492178f, 
    -0.27299875f, -0.26415199f, 0.52408069f, -0.52972019f, -0.11255651f, -0.10578343f, -0.38021901f, 0.10385004f, 
    0.21352793f, 0.25056931f, -0.11928470f, 0.05363807f, -0.01406478f, -0.03836948f, -0.00626553f, 0.02491848f, 
    0.10608273f, -0.02891050f, -0.20252450f, 0.02362216f, -0.11734064f, -0.00242500f, 0.07896884f, -0.31890598f, 
    -0.06856050f, 0.09040988f, -0.07598577f, 0.06947045f, 0.11965461f, 0.05197827f, 0.14163914f, 0.02870354f, 
    0.06865228f, -0.02254364f, 0.02947076f, 0.14911316f, 0.02076299f, 0.03352493f, -0.06759354f, 0.01595100f, 
    0.07984245f, -0.29861155f, 0.08979433f, -0.05138964f, -0.24658698f, -0.02962315f, -0.01633595f, 0.12604181f, 
    -0.03556386f, 0.13525045f, -0.10095836f, 0.05121765f, 0.01216827f, 0.09436864f, -0.04925629f, -0.07735354f, 
    0.13485877f, 0.14046340f, 0.14945376f, 0.03118132f, -0.19946396f, -0.29553705f, 0.05739541f, 0.03966187f, 
    0.17755170f, -0.14547023f, -0.09978975f, 0.03351562f, -0.01035560f, -0.22516330f, -0.09931474f, 0.03350420f, 
    -0.05502637f, -0.02707425f, -0.01973518f, 0.03243681f, -0.24616691f, -0.29907155f, -0.17642239f, 0.05001674f, 
    -0.63464773f, 0.21513839f, -0.51686829f, 0.14791457f, 0.12861268f, 0.01406004f, -0.18265428f, -0.15865488f, 
    0.20741209f, -0.01566119f, -0.02183386f, 0.05760991f, -0.11386713f, 0.06718142f, -0.00304453f, 0.03443043f, 
    -0.02899424f, -0.40090427f, 0.00564150f, -0.05595872f, -0.20143478f, -0.06888609f, -0.48202342f, -0.20163915f, 
    0.06394334f, 0.09510464f, 0.05517190f, 0.16449015f, -0.31196746f, -0.10146199f, -0.06489305f, 0.06242137f, 
    -0.12772740f, 0.02770481f, 0.03301093f, 0.14095864f, -0.26683888f, -0.20384267f, -0.49602771f, -0.35803923f, 
    -0.33072534f, 0.06514088f, -0.21705535f, -0.19864729f, 0.20543559f, -0.20694967f, -0.02158267f, -0.05190166f, 
    0.07587133f, 0.06162021f, -0.18484981f, 0.24288990f, 0.03435208f, 0.06214129f, 0.01789359f, 0.14842609f, 
    -0.01540666f, -0.13502935f, 0.03688012f, -0.18078440f, 0.39730161f, -0.09766224f, 0.45111170f, -0.13407439f, 
    -0.18954253f, -0.05428505f, -0.32983065f, 0.08607275f, -0.06171957f, -0.15184450f, -0.10041882f, 0.06917804f, 
    -0.04486061f, 0.06441680f, -0.00170020f, 0.03836123f, -0.10861731f, 0.12645692f, 0.07965866f, -0.09015422f, 
    -0.35194209f, 0.07960350f, 0.23828968f, 0.13214666f, -0.19443756f, 0.18033676f, -0.01028906f, -0.30698091f, 
    -0.08330208f, 0.16801366f, -0.06972671f, -0.05406923f, 0.07937066f, 0.04236282f, -0.11053991f, -0.15463704f, 
    -0.05166005f, 0.02310111f, -0.07168565f, -0.11147664f, -0.13408035f, -0.37754691f, 0.33916882f, 0.18324143f, 
    0.23361354f, -0.13504541f, -0.00984911f, -0.25216654f, -0.07099687f, -0.06809589f, 0.06676428f, 0.06917171f, 
    0.07559084f, 0.12355006f, -0.01930450f, 0.08241933f, -0.00023194f, -0.20290790f, 0.17393038f, -0.18224804f, 
    0.50291568f, -0.18800601f, 0.33733290f, -0.32518530f, 0.04381612f, 0.01707463f, 0.12804741f, -0.07290310f, 
    0.18362086f, 0.04268365f, 0.04348654f, 0.01721974f, -0.21087225f, -0.17218971f, -0.26721615f, -0.04521825f, 
    -0.07259870f, 0.08240750f, 0.10239360f, -0.14516255f, -0.29590803f, 0.42223498f, -0.15569578f, 0.03796243f, 
    0.06135441f, 0.09198094f, -0.10295278f, -0.07922336f, 0.02720882f, 0.04878299f, -0.11861206f, -0.00486718f, 
    -0.06644561f, -0.11738946f, -0.10386734f, -0.07624738f, -0.13801046f, -0.15710591f, -0.09073674f, -0.14160618f, 
    -0.35695985f, 0.12967525f, 0.13881497f, 0.13055153f, 0.23375030f, -0.13417441f, -0.15921381f, -0.24462610f, 
    0.10132136f, -0.02195849f, -0.09680198f, 0.14416412f, 0.14305164f, -0.00803286f, 0.03593848f, 0.04395346f, 
    -0.00433990f, 0.02549162f, -0.01091398f, -0.04536738f, 0.07302891f, -0.38771483f, -0.21614772f, 0.27166522f, 
    -0.09977263f, -0.01620362f, -0.23061854f, 0.10747613f, -0.29488429f, -0.09319793f, -0.01918681f, 0.02847729f, 
    -0.12262493f, 0.05379957f, 0.12313487f, -0.09028260f, -0.12808099f, -0.15056644f, -0.02911071f, 0.15508583f, 
    0.47041631f, -0.12948880f, 0.30682120f, -0.31711462f, -0.03585893f, 0.03362502f, -0.02207306f, 0.08002766f, 
    0.16735555f, 0.02774496f, -0.13500059f, 0.11977658f, -0.08651528f, -0.17467187f, -0.12207413f, 0.03672044f, 
    0.02292326f, 0.14053276f, -0.00635822f, -0.02525162f, -0.28648266f, -0.06291825f, 0.32757792f, -0.17612664f, 
    -0.06546816f, -0.02950662f, 0.03916256f, 0.16604444f, 0.10743433f, 0.10701817f, 0.04652616f, 0.06731597f, 
    -0.10790996f, 0.07790140f, 0.01696138f, -0.02916837f, 0.19318452f, 0.04648630f, 0.13361901f, 0.24758214f, 
    0.22015861f, -0.43100905f, 0.27947953f, 0.17327285f, 0.11395367f, -0.24312449f, -0.05821343f, 0.36173296f, 
    0.02554409f, -0.01651465f, 0.02353937f, -0.11735365f, -0.48680833f, 0.28523743f, 0.24819712f, -0.18215419f, 
    0.14350431f, 0.29345253f, -0.03498580f, 0.20721968f, -0.00955225f, -0.41086486f, -0.09601601f, -0.04844161f, 
    -0.54805934f, -0.07951476f, -0.13283668f, 0.01505766f, -0.19515091f, -0.11729915f, 0.00061550f, 0.08050038f, 
    -0.04032882f, 0.05783658f, 0.03838126f, 0.19189000f, 0.04504760f, -0.02849209f, -0.09744836f, -0.29665333f, 
    0.31387019f, 0.00059097f, 0.04354092f, -0.04412250f, -0.12035601f, 0.16137525f, 0.00954741f, -0.19004719f, 
    0.03466247f, 0.05243821f, -0.20965436f, 0.14948826f, -0.05022790f, -0.17677222f, -0.15271124f, -0.03372172f, 
    -0.03312122f, -0.04176250f, 0.04070435f, -0.07933779f, -0.48705438f, -0.33765846f, 0.13677217f, -0.03370478f, 
    -0.00853387f, -0.21773715f, 0.07918854f, 0.10215806f, 0.02964333f, -0.09469710f, -0.03588001f, 0.06490538f, 
    -0.06538963f, 0.00586992f, 0.01570240f, 0.05981271f, 0.18726070f, 0.25026068f, 0.23808818f, 0.27628794f, 
    -0.29218373f, -0.40197718f, -0.04840422f, 0.03088269f, -0.13332634f, 0.01525574f, -0.14806211f, 0.09990829f, 
    -0.14990942f, 0.00295247f, -0.12063293f, -0.00135921f, 0.01977782f, -0.03569259f, -0.11125806f, 0.09278871f, 
    -0.07370047f, 0.09605501f, 0.08563482f, 0.06678010f, -0.67732239f, 0.17863522f, 0.01262105f, 0.14096288f, 
    0.04350429f, -0.05123464f, 0.11759806f, -0.20804685f, 0.18632668f, 0.04540652f, 0.08792838f, -0.09875999f, 
    -0.02009566f, 0.00305275f, 0.08042141f, 0.11670262f, 0.03566783f, -0.11872815f, 0.18291989f, 0.17993312f, 
    -0.24439286f, -0.37053916f, -0.03811695f, 0.13775013f, -0.23536749f, -0.00822384f, -0.04831171f, -0.10748889f, 
    0.18142834f, 0.07144573f, -0.12251001f, -0.02604265f, 0.07420807f, 0.06516235f, -0.03877348f, 0.02593010f, 
    0.06592474f, 0.05035922f, 0.33393648f, 0.16959381f, -0.18455829f, 0.06366517f, -0.10049625f, -0.10686455f, 
    0.14257939f, -0.00313550f, 0.11557611f, 0.06258287f, 0.00651194f, 0.14816569f, -0.11362341f, 0.02588330f, 
    -0.04497358f, -0.05628229f, -0.06761795f, 0.07190349f, 0.19768816f, -0.12178846f, 0.15519276f, 0.27910888f, 
    -0.26499751f, 0.18398739f, -0.20639011f, 0.01374176f, 0.12172331f, 0.10048896f, -0.07276243f, -0.07663197f, 
    -0.07836220f, -0.04070936f, -0.11282318f, 0.05165555f, 0.02943800f, -0.18184429f, -0.06811800f, -0.01509060f, 
    -0.08249976f, -0.05923910f, -0.15193522f, -0.18153015f, 0.56818908f, -0.33952838f, 0.67933214f, 0.09653373f, 
    0.00125717f, -0.09304115f, -0.00422652f, 0.33446372f, 0.23133062f, 0.08332027f, 0.16552129f, 0.00494150f, 
    0.11490734f, -0.03404941f, 0.00990557f, 0.03562073f, 0.01086136f, 0.13678575f, 0.00926397f, 0.18461081f, 
    -0.44649568f, 0.04231340f, 0.24595304f, 0.10372216f, -0.01366287f, -0.01625597f, -0.05543008f, 0.08564901f, 
    0.28510192f, 0.17200580f, -0.04547494f, 0.09705096f, 0.04719533f, 0.08613739f, -0.04339144f, 0.02631449f, 
    0.00438033f, -0.09867766f, 0.21859024f, 0.16401146f, 0.10157919f, -0.43274581f, 0.12296911f, -0.10821380f, 
    0.11395155f, 0.00992659f, 0.02037165f, 0.23157057f, 0.05913965f, -0.11015762f, -0.16418304f, -0.01729879f, 
    0.02695047f, 0.21704456f, 0.22734204f, 0.05147772f, 0.01476507f, 0.09828475f, -0.16675781f, -0.11353289f, 
    -0.26502842f, -0.05771726f, 0.05967123f, -0.04897053f, -0.05134500f, -0.08800397f, -0.01898062f, -0.12030742f, 
    0.17566258f, -0.03349844f, -0.02600923f, 0.01696457f, -0.04362474f, -0.05210790f, 0.05054902f, 0.07470745f, 
    -0.02811439f, 0.04636217f, 0.02370440f, -0.14816988f, -0.00175298f, -0.03866390f, 0.16927865f, -0.04899576f, 
    0.06199870f, -0.05152107f, -0.02171924f, -0.11833116f, 0.08935173f, 0.03287918f, 0.02626625f, 0.07611653f, 
    -0.07025407f, 0.08588780f, -0.02771421f, 0.06243262f, -0.01113420f, 0.00352594f, 0.03650318f, 0.05520841f, 
    -0.15207532f, -0.20766193f, -0.06012906f, 0.12089902f, -0.13780145f, -0.02485396f, -0.16230662f, -0.23725301f, 
    -0.06451663f, -0.13773450f, -0.10981852f, 0.07961109f, -0.13943571f, 0.01498180f, -0.01170477f, 0.02454192f, 
    -0.04357848f, -0.00550138f, 0.15419383f, -0.10308544f, -0.78510964f, -0.05903931f, -0.41288224f, 0.04893874f, 
    0.16995084f, 0.02523229f, -0.25781369f, 0.20260982f, 0.15793066f, 0.18821301f, -0.05253374f, 0.23526442f, 
    0.01980020f, 0.11633764f, 0.01949426f, 0.06500981f, -0.00231696f, -0.01320057f, 0.04278273f, 0.01483341f, 
    -0.41669044f, 0.03430726f, 0.27015030f, -0.19952461f, 0.10752517f, -0.09853549f, -0.02195365f, -0.08942684f, 
    0.07582319f, -0.29185051f, -0.15441954f, -0.09161737f, 0.17150237f, -0.03180131f, -0.08672691f, -0.07049447f, 
    -0.00074036f, -0.06692576f, 0.00178577f, 0.09676500f, -0.17249647f, -0.08900762f, 0.06756146f, 0.14646280f, 
    -0.09263951f, 0.07972725f, -0.06446912f, -0.10778513f, 0.08409864f, 0.23359621f, -0.05573190f, 0.05488995f, 
    0.00407862f, 0.02506039f, -0.06483810f, -0.11408946f, 0.02139990f, 0.02234430f, 0.10592571f, 0.15567492f, 
    0.08740320f, -0.00988912f, 0.19491464f, -0.17566451f, 0.06275970f, 0.02656907f, 0.15936667f, -0.02115870f, 
    0.12025434f, 0.06337485f, -0.08123728f, 0.13689700f, -0.05521605f, -0.02518125f, -0.01454363f, -0.15563360f, 
    -0.02162859f, -0.13109422f, -0.04532477f, -0.27035567f, 0.69178492f, 0.01968038f, 0.52030391f, 0.16334969f, 
    -0.21002573f, 0.01311557f, -0.06594169f, -0.06196580f, 0.00921440f, -0.10588259f, -0.09646972f, 0.01080141f, 
    -0.03068707f, -0.07507556f, 0.01401313f, 0.03310275f, 0.03203865f, 0.04014856f, 0.09204580f, 0.10370678f, 
    -0.24250674f, -0.26127589f, -0.26892936f, -0.03535043f, -0.07646901f, -0.01423079f, -0.44983730f, -0.11652081f, 
    0.16261134f, -0.08974328f, -0.09754800f, 0.02014305f, 0.00411026f, -0.03780359f, 0.00542109f, 0.15011908f, 
    -0.04158700f, 0.06734379f, 0.24453078f, 0.04001392f, 0.03957747f, -0.58205074f, -0.17420962f, 0.08643694f, 
    0.24922992f, -0.09953853f, -0.40599164f, 0.26896772f, -0.28712848f, -0.10538758f, 0.04841282f, 0.07604229f, 
    0.02810352f, -0.07128619f, 0.03913227f, 0.00583889f, -0.02731620f, 0.03859062f, 0.07195789f, 0.09918973f, 
    0.13453256f, -0.50082690f, -0.25995541f, -0.39433664f, 0.20841835f, 0.04690888f, -0.13928799f, -0.14409539f, 
    -0.10319985f, -0.06828570f, 0.02291405f, 0.00597802f, 0.04079045f, 0.00178770f, -0.07271949f, 0.01864703f, 
    0.02197045f, -0.06658929f, 0.05462930f, 0.00282380f, -0.27461812f, -0.51487845f, 0.32202727f, -0.26282904f, 
    0.25281766f, 0.22818033f, 0.29767150f, 0.09834452f, -0.14507742f, 0.07274051f, 0.02156943f, 0.02299982f, 
    0.11605470f, 0.13429891f, 0.23892950f, -0.05218365f, 0.12981144f, -0.08214892f, -0.06616879f, 0.00949233f, 
    -0.20941120f, -0.03096564f, -0.40683660f, 0.54706281f, 0.03962689f, -0.07934560f, 0.24562269f, 0.00663933f, 
    0.33682331f, -0.00937826f, -0.28181952f, -0.04979675f, 0.02527034f, 0.11578675f, 0.11216227f, -0.01620567f, 
    -0.04159325f, 0.27060917f, -0.09542981f, 0.08593178f, 0.03508729f, -0.23796289f, 0.37793982f, -0.14334619f, 
    0.13172758f, -0.10677937f, -0.28886452f, -0.03856046f, 0.05931732f, 0.09704142f, 0.06356025f, 0.07658407f, 
    0.04832985f, 0.10067219f, -0.15549116f, -0.00602657f, 0.11787860f, -0.06016268f, 0.22428311f, -0.06607538f, 
    -0.16283631f, -0.11259710f, 0.23070046f, -0.39616624f, -0.14535148f, 0.00053762f, 0.18212697f, -0.28158855f, 
    0.15579286f, 0.01731027f, 0.05424985f, -0.01888249f, 0.07918829f, -0.06802217f, -0.02467816f, -0.00633582f, 
    -0.02238392f, 0.08326893f, 0.02883646f, 0.09056021f, -0.87665242f, 0.13633972f, -0.43252134f, 0.35609215f, 
    -0.45435429f, 0.04822188f, 0.15865830f, -0.00861926f, 0.11178412f, 0.16268443f, -0.24821511f, -0.09588809f, 
    0.08488381f, 0.16647795f, -0.04046103f, 0.06641610f, 0.01050177f, 0.15496774f, -0.12618168f, 0.11539150f, 
    -0.01673109f, -0.24020988f, -0.34382182f, 0.04440376f, -0.22068106f, -0.01679074f, -0.06724745f, -0.08577756f, 
    -0.23673055f, 0.09502912f, 0.03266878f, 0.07404003f, -0.01620544f, -0.08718362f, -0.10649811f, -0.00606044f, 
    -0.07397090f, 0.05737463f, 0.04779942f, 0.08604110f, 0.22501831f, 0.17444718f, 0.38640767f, 0.05084937f, 
    -0.23353912f, -0.00942027f, -0.02281905f, 0.18418860f, -0.10715765f, 0.06044159f, -0.13510276f, 0.00628153f, 
    -0.00992566f, 0.03123425f, -0.01837809f, -0.03887597f, 0.01431478f, 0.14620084f, 0.17952362f, -0.02625910f, 
    -0.37198079f, -0.07453402f, -0.20272592f, 0.05748069f, -0.01902467f, 0.00895241f, 0.09776484f, -0.07472625f, 
    0.01385348f, 0.12669876f, -0.07446264f, 0.02050067f, 0.04765755f, -0.01235290f, -0.05762519f, -0.09619248f, 
    -0.04821885f, 0.03624751f, 0.06999509f, 0.12161452f, -0.22153090f, 0.03033500f, -0.36283183f, 0.20871460f, 
    0.06734200f, 0.07708208f, -0.01620483f, 0.01203900f, -0.17469935f, 0.01216646f, -0.03734263f, 0.15202761f, 
    -0.07982301f, -0.03959013f, -0.22599946f, -0.00096531f, -0.14213639f, -0.00548851f, -0.12557763f, -0.11826328f, 
    -0.13357976f, 0.02559608f, 0.06432114f, -0.11285049f, 0.12787119f, 0.00973772f, 0.16579413f, -0.17998126f, 
    0.23575903f, 0.22354250f, -0.06850927f, 0.12444168f, -0.06533927f, -0.07462155f, 0.07057369f, -0.08681457f, 
    -0.01471031f, -0.08754414f, 0.05876813f, -0.05216977f, -0.03335806f, -0.22347102f, -0.04019298f, -0.13477299f, 
    0.09921803f, -0.00001539f, 0.07112307f, -0.06281523f, 0.03837920f, 0.00138949f, -0.11067352f, -0.02593973f, 
    -0.00146487f, 0.02567860f, -0.01379604f, 0.06985461f, 0.05391646f, 0.03477067f, -0.11279093f, -0.10690143f, 
    -0.57753444f, 0.13461062f, -0.48030528f, 0.07224917f, -0.24915393f, 0.01220149f, 0.01775098f, -0.05156888f, 
    -0.06859456f, 0.18731236f, -0.10067122f, -0.09963352f, 0.01519453f, 0.01170186f, -0.00733620f, -0.01668286f, 
    -0.07915170f, -0.09213612f, -0.07110149f, 0.13875116f, 0.08154987f, -0.11577442f, 0.01664191f, -0.01558742f, 
    0.13125645f, -0.03409665f, -0.01780760f, -0.05709717f, -0.03489367f, -0.18397385f, -0.02872249f, 0.15697180f, 
    -0.02137676f, -0.02640732f, 0.08994903f, -0.05921128f, -0.16539608f, -0.04453526f, -0.27102306f, -0.01140324f, 
    0.52955759f, 0.18899027f, 0.56936246f, -0.04946784f, -0.29568034f, 0.06557707f, 0.16205993f, -0.05044683f, 
    0.08505946f, 0.05958097f, -0.13533211f, 0.06564102f, 0.02070325f, 0.04443790f, -0.00409207f, -0.12442257f, 
    0.08848609f, 0.11830668f, 0.09156724f, 0.05187896f, -0.18536004f, -0.41950527f, -0.05284301f, 0.19545805f, 
    -0.08273801f, 0.02198515f, -0.14755048f, -0.05126856f, 0.21697493f, -0.19279407f, -0.01455314f, 0.02821679f, 
    -0.01349717f, -0.12271128f, -0.00282115f, 0.00647912f, -0.02657363f, 0.07028187f, 0.08869538f, -0.14933100f, 
    0.19906211f, 0.08245032f, 0.28538015f, -0.07284377f, -0.10511248f, -0.00303253f, 0.12029062f, 0.01046412f, 
    0.04179473f, -0.05474973f, 0.00566747f, 0.05067317f, 0.09373393f, -0.04944517f, 0.03285519f, -0.11479234f, 
    0.02682283f, 0.01811179f, -0.20743211f, -0.19806984f, -0.16743062f, -0.20803432f, -0.21953355f, 0.26717010f, 
    0.10582294f, -0.11650234f, -0.17120554f, -0.03150962f, -0.02484509f, -0.02402694f, -0.05715367f, -0.13762955f, 
    -0.11965265f, -0.17874873f, -0.06197307f, 0.01882946f, -0.14872247f, 0.00941470f, -0.14384866f, -0.31227982f, 
    -0.14485940f, -0.24286500f, -0.33383647f, 0.02135760f, -0.47133532f, -0.06538250f, 0.16948971f, 0.15602781f, 
    -0.23786624f, -0.02914485f, -0.05807205f, 0.01450076f, 0.18697727f, 0.16085286f, 0.00560655f, 0.07325307f, 
    0.11540353f, 0.20287050f, 0.00993475f, 0.13088153f, -0.75985080f, -0.09082444f, -0.55970246f, 0.43904591f, 
    0.49812680f, 0.02689897f, 0.17215300f, 0.06563056f, -0.05709311f, 0.32643205f, -0.06754532f, 0.34134078f, 
    0.05106659f, -0.06226433f, -0.05961888f, 0.10920765f, 0.11193015f, 0.13033165f, 0.02724513f, 0.10499591f, 
    0.09316581f, 0.10656883f, 0.36302221f, 0.01175315f, -0.13988219f, 0.00241096f, -0.33051389f, 0.21626714f, 
    -0.06136590f, -0.08785062f, -0.09947900f, -0.00567765f, 0.04467123f, 0.10833711f, 0.09773226f, -0.00707898f, 
    -0.15361598f, -0.04954808f, 0.25441197f, -0.11132303f, 0.51067901f, -0.32431880f, 0.27835432f, 0.04833522f, 
    0.19066682f, -0.03079442f, 0.17625466f, -0.24072248f, 0.33307227f, -0.14305370f, -0.15414235f, -0.03994120f, 
    -0.04121394f, -0.01260630f, -0.03175025f, 0.01384479f, 0.06941563f, -0.04486649f, -0.04988013f, 0.01959427f, 
    0.08664878f, -0.07391833f, 0.06017433f, 0.15953289f, -0.07088002f, -0.10559431f, 0.06888752f, -0.04467391f, 
    0.10063159f, -0.19919346f, -0.08980009f, -0.10886990f, -0.00476105f, -0.03939833f, -0.04610769f, 0.13029395f, 
    0.00383962f, 0.10732409f, -0.09237784f, -0.02494283f, -0.07518881f, -0.28771755f, -0.02394858f, 0.08009095f, 
    -0.27177721f, 0.02514711f, -0.05269571f, -0.09684173f, -0.04977730f, 0.07669809f, 0.03767313f, 0.02154327f, 
    -0.01242230f, -0.15637690f, -0.13293017f, -0.01038209f, -0.08414923f, 0.04598774f, -0.14606544f, -0.02041981f, 
    -0.39584318f, -0.09914508f, -0.09957737f, 0.03355952f, -0.22347733f, -0.00850211f, 0.08096827f, 0.09267960f, 
    0.05242434f, -0.02941004f, -0.09468652f, 0.02434096f, 0.11815144f, -0.03325729f, -0.06680758f, 0.03654571f, 
    -0.04513619f, -0.03538743f, -0.10999500f, 0.05804499f, -0.13255230f, -0.16247994f, 0.07560978f, 0.04778865f, 
    0.01429077f, -0.02118438f, -0.47998050f, 0.24106319f, -0.06283028f, -0.24175146f, -0.03014496f, 0.05462628f, 
    0.00995219f, 0.05001619f, 0.01301181f, 0.04062066f, -0.12393136f, -0.01705010f, -0.08430583f, -0.01016854f, 
    -0.01686494f, -0.33341533f, -0.22311777f, 0.24501583f, -0.03331248f, -0.00226643f, -0.19685844f, -0.18412469f, 
    -0.02271243f, -0.06069377f, 0.02015901f, 0.04978531f, -0.15965836f, -0.06829531f, 0.00659222f, 0.10341661f, 
    -0.07306852f, 0.12672487f, -0.01811076f, -0.21694249f, 0.14533427f, -0.09098856f, 0.02046029f, 0.44784248f, 
    0.08214226f, -0.02966868f, 0.16760026f, 0.04078621f, 0.33372658f, -0.00804658f, -0.28469703f, 0.05046220f, 
    0.00046844f, -0.04678686f, 0.06583086f, -0.09495428f, 0.02900595f, 0.17685145f, -0.03425291f, -0.10348177f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.19457793f, 0.12503573f, 0.05923500f, -0.10681877f, -0.05872050f, 0.02514047f, 0.06081609f, -0.09714109f, 
    0.07162357f, 0.03353837f, 0.03896163f, -0.00894103f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
