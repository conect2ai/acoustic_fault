#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.18882404f, -0.02240920f, 0.53964645f, 0.67963427f, 0.12338040f, 0.54986000f, -0.23253007f, -0.40249336f, 
    -0.14553429f, -0.90072221f, -0.10670234f, -0.62307876f, -0.24614163f, 1.05330074f, 0.48282459f, 0.18603490f, 
    0.38880038f, -0.01650756f, -0.12961018f, -0.16555385f, 0.34229836f, 0.43537650f, 0.20670921f, 0.83065408f, 
    0.42500952f, -0.02162458f, 0.06107379f, -0.88779318f, -0.23761478f, -0.15059347f, 0.30917221f, 0.27170935f, 
    -0.13431548f, -0.40349242f, -0.25287601f, -0.34738001f, -0.45860767f, 0.57489681f, -0.67793888f, -0.16313700f, 
    0.31739390f, -0.07461529f, 0.49694127f, 0.33460280f, 0.16344298f, 0.89825916f, -0.83807474f, 0.26554921f, 
    -0.67734247f, 0.49724478f, -0.30113062f, -0.22416675f, 0.19196337f, 0.07481974f, -0.26304349f, -0.32360509f, 
    0.01029054f, -0.31143805f, -0.98954934f, -0.69922322f, -0.20860553f, 0.65091890f, -0.08450048f, 0.61444479f, 
    -0.48552176f, 0.46497229f, 0.12919752f, -0.06079791f, -0.00790558f, 0.01612826f, -0.53855968f, -0.21812402f, 
    0.34788603f, 0.00495494f, 0.74938273f, -0.19226991f, -0.02974454f, 0.02298036f, 0.17295097f, 0.29155636f, 
    0.01021969f, 0.00022821f, 0.10451309f, 0.00334899f, -0.71905649f, -0.09827185f, -0.34598389f, 0.40542087f, 
    0.36809897f, 0.67698067f, 0.83715308f, -0.84746665f, -0.75531441f, 0.14065157f, 0.30565491f, 0.58629864f, 
    -0.01520420f, -0.10172861f, -0.05020582f, -0.74816126f, -0.76793081f, -0.20159517f, 0.08336412f, 0.00092516f, 
    -0.18669526f, 0.16328473f, 0.10387919f, 0.46438521f, 0.31468952f, 0.02315413f, -0.40684709f, -0.66127801f, 
    0.53366417f, -0.43029773f, -0.05761281f, -0.42444095f, -0.24169502f, -0.64884841f, -0.61979091f, -0.40187839f, 
    -0.06060125f, 0.24075802f, -0.38669267f, 0.05749799f, -0.25125709f, -0.58683866f, 0.24044874f, -0.17493211f, 
    -0.95327824f, -0.21556453f, -0.25541171f, 0.00098674f, -0.23276062f, -0.24886169f, -0.16631958f, 0.99257982f, 
    0.62116271f, 0.01308407f, -0.35442343f, -0.49402472f, -0.32772544f, -0.08497458f, 0.44186729f, -0.11158475f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.07912169f, 0.26696402f, 0.09951676f, -0.01456237f, 0.14861695f, 0.24289958f, -0.15073019f, 0.32914603f, 
    0.47807410f, -0.20515473f, -0.15315409f, -0.30878076f, -0.11232177f, -0.55362880f, 0.36403963f, 0.27731830f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.00738278f, 0.31179258f, -0.06582140f, -0.07161098f, 0.05205106f, 0.02695091f, -0.12594067f, 0.01801994f, 
    -0.00545401f, -0.62719089f, 0.17255530f, 0.56888914f, -0.09483525f, 0.05986923f, 0.06776579f, 0.12591055f, 
    -0.01180188f, 0.17874986f, 0.04089163f, 0.08023211f, 0.01106517f, -0.15081321f, 0.14934994f, -0.04311977f, 
    0.10054027f, -0.05864800f, 0.18745731f, -0.20114481f, -0.11451875f, 0.23671985f, -0.07304418f, 0.05323332f, 
    0.07197089f, -0.21801102f, 0.03603319f, 0.12992208f, -0.11606807f, 0.02500203f, 0.00084751f, -0.05800049f, 
    0.04025513f, 0.01747643f, 0.14689757f, -0.06127945f, 0.12509052f, 0.37688339f, -0.20138662f, -0.74295443f, 
    0.09610185f, 0.07448346f, 0.08922057f, 0.18857647f, 0.03253274f, -0.00302636f, -0.42015895f, -0.26923922f, 
    -0.53281587f, 0.03419034f, -0.01556756f, -0.10335407f, 0.07937890f, -0.06207724f, -0.01251673f, 0.04533456f, 
    0.13433486f, -0.09070782f, -0.00125194f, 0.05488263f, 0.04712889f, 0.24578016f, -0.16887590f, 0.32768911f, 
    0.30954614f, -0.15570512f, -0.21765049f, 0.09992368f, 0.05104293f, 0.11443614f, 0.05078702f, -0.01137195f, 
    0.14744627f, 0.00111163f, -0.38774204f, -0.61799210f, 0.01170160f, -0.04428590f, -0.24397410f, 0.00287601f, 
    0.07411910f, -0.05791954f, 0.12529472f, 0.35055912f, -0.12527530f, -0.21432002f, 0.00230847f, -0.15826733f, 
    0.16190569f, 0.04232174f, -0.17798313f, -0.47244954f, 0.21464151f, 0.27733836f, -0.06521201f, 0.31371328f, 
    -0.07478163f, -0.09584685f, 0.07667127f, -0.14345999f, -0.63719249f, -0.53768814f, -0.48230121f, 0.13718432f, 
    0.08989272f, 0.01023775f, 0.14987239f, 0.13132802f, -0.00097029f, -0.06901342f, -0.14995109f, 0.12485427f, 
    -0.07815758f, 0.06912493f, -0.04513910f, -0.10633103f, -0.05351684f, 0.05580454f, -0.06291421f, 0.02917958f, 
    0.15080634f, -0.04205493f, 0.00271609f, -0.13308921f, -0.01620815f, 0.02414712f, 0.09719891f, 0.36939088f, 
    -0.18072034f, -0.26993811f, 0.09558228f, 0.23759907f, 0.06506322f, -0.01912770f, 0.04099467f, -0.03764392f, 
    0.00025482f, 0.07634276f, -0.44894224f, -0.04556349f, 0.16207857f, 0.00328918f, 0.11894085f, 0.22748999f, 
    -0.23941225f, 0.12661788f, -0.10049302f, 0.25957265f, 0.02760709f, 0.27634180f, 0.19983937f, 0.03915919f, 
    0.11243935f, 0.07239532f, -0.02901859f, -0.04862960f, -0.09611178f, -0.07086398f, 0.03467089f, 0.01056254f, 
    0.15243822f, -0.26324511f, -0.52484125f, 0.00552572f, -0.13271861f, -0.10508263f, 0.04284556f, 0.09532176f, 
    0.23081404f, 0.09429413f, 0.12542845f, 0.37404221f, 0.03513660f, -0.13272288f, -0.16051668f, 0.03365833f, 
    0.11659025f, -0.28091535f, -0.16788229f, -0.04313612f, -0.04683482f, 0.12852034f, 0.22583455f, -0.14361992f, 
    0.37952277f, -0.02664105f, 0.02857232f, 0.33816692f, 0.10273787f, 0.13740611f, -0.17000553f, -0.10097554f, 
    0.10463030f, 0.23684762f, 0.03682102f, 0.08111756f, -0.03663563f, -0.04926459f, -0.07445031f, 0.15231851f, 
    0.09909388f, -0.30552605f, 0.08498023f, 0.01511746f, 0.07860825f, 0.11734376f, 0.15819253f, 0.00629318f, 
    0.23706357f, 0.11588146f, -0.31934145f, 0.04439601f, -0.06717811f, 0.00741530f, 0.11744277f, 0.08892991f, 
    -0.11382088f, -0.27168199f, -0.07708667f, 0.08295038f, 0.06263669f, -0.09315079f, -0.14768781f, -0.16390176f, 
    -0.15070461f, -0.33774269f, -0.62270796f, 0.20015572f, 0.06724582f, 0.14766799f, -0.02679170f, 0.16448839f, 
    0.10239594f, -0.10408356f, 0.05158233f, 0.13997547f, -0.19575194f, 0.02433793f, -0.07012340f, 0.07650174f, 
    0.08960018f, 0.01491871f, 0.01395279f, -0.34695324f, -0.01593411f, -0.00335586f, 0.08491936f, 0.22677442f, 
    -0.00114100f, -0.05442895f, 0.22351618f, 0.07432444f, 0.20481318f, -0.00336357f, -0.05193376f, -0.09461221f, 
    -0.08023942f, 0.13639195f, 0.34310594f, 0.05352608f, -0.06453562f, 0.23812500f, -0.11193305f, -0.31361279f, 
    0.27629876f, 0.04315911f, 0.06114757f, -0.09068426f, 0.02150244f, 0.01556687f, 0.17129581f, 0.15597795f, 
    0.27493167f, -0.12636398f, -0.11369460f, -0.00772195f, 0.09023207f, 0.07452358f, -0.00203241f, 0.00731296f, 
    -0.11269984f, -0.13566688f, 0.04164259f, -0.02541889f, -0.02714038f, 0.15254070f, -0.10926153f, -0.39022750f, 
    -0.54372466f, 0.36166158f, -0.18283176f, -0.08451162f, -0.10951659f, 0.13660662f, 0.16770472f, 0.07405322f, 
    0.01918448f, 0.06191715f, 0.04328918f, -0.09995133f, 0.01332629f, 0.12398125f, 0.03286134f, -0.17246176f, 
    -0.08636010f, 0.12357172f, 0.09309748f, -0.10933919f, -0.03414518f, 0.13577418f, -0.03165979f, -0.24432594f, 
    -0.08129457f, -0.13351949f, -0.14716516f, -0.10437106f, -0.01429516f, 0.23132837f, -0.03367445f, 0.00534929f, 
    -0.05760372f, 0.01395760f, 0.03036767f, 0.27760661f, 0.19309771f, 0.37331787f, -0.12457542f, 0.19092578f, 
    0.27285519f, 0.23127154f, -0.02135326f, -0.00826449f, 0.13055477f, 0.10705197f, 0.04258821f, 0.07902627f, 
    -0.06611918f, 0.22482456f, 0.09984098f, 0.16429511f, 0.07428378f, 0.01336784f, -0.17701547f, 0.08843175f, 
    -0.00907359f, 0.02991978f, 0.09520083f, -0.02630028f, 0.18612424f, -0.12320898f, -0.03025519f, -0.39325717f, 
    -0.08096619f, 0.11576986f, 0.01689603f, -0.11748213f, -0.05587738f, -0.03347966f, 0.15956517f, -0.04097841f, 
    0.16381373f, 0.07732742f, -0.19637264f, 0.16968802f, -0.03517571f, 0.13341391f, 0.00772650f, 0.31254485f, 
    0.21921220f, 0.24250799f, -0.06212797f, -0.32885182f, -0.27875569f, 0.08270124f, 0.15897368f, 0.08473933f, 
    -0.04994378f, -0.05298687f, -0.05071764f, 0.03026899f, -0.20382632f, -0.06187410f, -0.02962566f, -0.26754528f, 
    -0.21057433f, 0.18289389f, 0.21800031f, 0.04648032f, -0.06446131f, -0.17246154f, -0.09748331f, -0.04522926f, 
    0.07259286f, 0.19897406f, -0.02622710f, 0.04999728f, -0.09059105f, -0.36039191f, -0.03275459f, 0.04533383f, 
    -0.01894159f, -0.34503159f, -0.07657003f, -0.16310966f, -0.03856985f, -0.01956961f, 0.05183976f, -0.00806873f, 
    -0.07955017f, -0.01558550f, 0.10194171f, 0.11534150f, 0.11321725f, 0.00492066f, -0.18721735f, -0.13309084f, 
    -0.03847655f, 0.22473323f, 0.05379152f, 0.08913106f, -0.16008802f, 0.16117761f, 0.01471702f, 0.02443310f, 
    0.13585375f, 0.19409275f, 0.17080802f, -0.34580594f, 0.04727979f, -0.18768218f, -0.17650272f, 0.02836525f, 
    0.17591420f, 0.08190772f, -0.05307577f, -0.33320996f, 0.22586285f, -0.22898664f, 0.06452729f, -0.05186500f, 
    0.21313071f, -0.04804638f, 0.13960844f, 0.28024790f, 0.17079329f, -0.04275587f, 0.03053015f, -0.15315223f, 
    0.00032203f, -0.04289581f, -0.27537951f, 0.35990199f, -0.06641518f, -0.43074980f, -0.08891026f, 0.06459293f, 
    -0.09015459f, -0.09656148f, -0.12985091f, 0.01605220f, 0.19552192f, 0.07292447f, 0.00897822f, -0.15717496f, 
    -0.16856946f, 0.09154738f, 0.14474751f, 0.05418229f, -0.03150378f, -0.09798092f, -0.41980013f, 0.15859094f, 
    -0.00996262f, 0.02698646f, 0.32169572f, -0.01907714f, 0.12854502f, -0.22182886f, -0.33581451f, 0.26128501f, 
    0.24675523f, -0.22384466f, -0.07333680f, -0.12868676f, 0.13375574f, 0.09830384f, 0.05137943f, 0.26204544f, 
    0.01511850f, 0.06642047f, -0.00605406f, -0.08793830f, 0.02219922f, -0.09644925f, -0.09247198f, 0.00260989f, 
    0.20753112f, 0.01193141f, -0.02102470f, 0.02531760f, 0.02115504f, -0.04255976f, -0.01645883f, 0.02033811f, 
    -0.00955304f, 0.07541271f, 0.35340434f, -0.16465703f, 0.02507154f, 0.25925329f, 0.11620659f, 0.00746034f, 
    -0.13345279f, 0.13914955f, 0.38659230f, -0.09570719f, -0.13284077f, 0.17772678f, -0.30324581f, 0.21697353f, 
    -0.21071410f, 0.12336951f, -0.07571083f, 0.01035602f, -0.00663157f, -0.27821246f, 0.04115820f, 0.19547294f, 
    -0.01222809f, 0.09279841f, 0.02926382f, 0.00586821f, -0.11041292f, -0.30971032f, -0.11979773f, 0.01130820f, 
    0.01860824f, -0.07647873f, 0.02469478f, 0.16860656f, -0.01174708f, 0.39755672f, -0.09317652f, 0.24186312f, 
    -0.08846518f, -0.11786998f, 0.21540430f, 0.22314724f, 0.18750891f, 0.04672821f, -0.16515368f, -0.22021686f, 
    -0.40746480f, -0.12231402f, -0.02240424f, 0.06771120f, 0.02753902f, -0.10782053f, -0.06431280f, 0.36591238f, 
    -0.27559751f, 0.06150673f, 0.08446258f, 0.01849899f, 0.19953381f, 0.15978494f, -0.02328338f, -0.03196166f, 
    0.03655004f, -0.11796781f, 0.02370479f, 0.06472388f, -0.12788382f, -0.20512080f, -0.04172141f, -0.02210513f, 
    0.16870035f, 0.42744330f, -0.39734006f, 0.06991637f, 0.19497950f, -0.09600342f, 0.16762155f, -0.20801215f, 
    0.06363682f, -0.05451041f, -0.02259590f, 0.14545518f, 0.11116722f, -0.12017544f, 0.01094251f, -0.01019795f, 
    0.18766353f, 0.05681746f, -0.05361666f, 0.15119471f, -0.05821510f, -0.29865742f, -0.04671001f, -0.12222169f, 
    -0.10318775f, -0.11144487f, -0.02766154f, 0.06473898f, 0.32040897f, -0.10947961f, -0.06109237f, 0.12343365f, 
    -0.03491658f, -0.03388516f, 0.08063159f, 0.01642212f, -0.01044841f, -0.42641655f, 0.08747962f, 0.29332301f, 
    0.09492946f, -0.07649296f, 0.30154324f, 0.03303445f, -0.06212778f, 0.02122332f, 0.30903074f, 0.32235816f, 
    0.45643133f, -0.13471629f, -0.03740942f, -0.20201357f, 0.06406131f, -0.06374007f, 0.04087949f, -0.06739326f, 
    -0.16869332f, 0.12668061f, -0.13191409f, -0.02798841f, -0.08980636f, 0.01389355f, 0.06821468f, -0.15197074f, 
    -0.09536739f, 0.21682979f, 0.07271132f, -0.14239292f, 0.03922687f, -0.09273916f, -0.03834741f, -0.24291527f, 
    -0.27035680f, -0.20340167f, 0.00868830f, -0.03288636f, 0.05166439f, 0.10942605f, 0.06541616f, 0.16269733f, 
    -0.13070685f, -0.12785949f, -0.36110637f, -0.20881498f, -0.17881116f, 0.01413056f, 0.16182549f, 0.02212068f, 
    0.16657741f, 0.00653947f, 0.04682454f, 0.32899845f, 0.18682222f, 0.10271624f, 0.38839296f, 0.09989394f, 
    -0.19326709f, -0.02073704f, 0.00026534f, -0.09400219f, 0.16175717f, 0.03685271f, 0.09114662f, 0.01595145f, 
    0.09156273f, 0.03920270f, -0.01660937f, -0.10592313f, 0.14572567f, 0.42567945f, -0.05067731f, -0.04958313f, 
    0.11407936f, -0.08663745f, 0.25324813f, 0.18074970f, 0.11203811f, 0.03586968f, -0.21798497f, -0.03895267f, 
    -0.19665629f, -0.08351314f, -0.01471073f, 0.20036732f, -0.16300406f, -0.06068000f, 0.01269815f, -0.04802540f, 
    0.19168918f, 0.41423124f, -0.06564545f, 0.02568457f, -0.14279957f, -0.01388859f, -0.10228790f, -0.05770470f, 
    -0.01598829f, 0.09121947f, 0.08455356f, -0.21239516f, 0.10366274f, -0.17923304f, 0.00785837f, -0.18702103f, 
    -0.01455886f, -0.05176686f, 0.00326691f, -0.35880286f, -0.05753935f, -0.10726352f, -0.20855138f, 0.21936817f, 
    -0.17812753f, -0.14896071f, 0.02965437f, 0.28148842f, 0.10654912f, 0.04932510f, 0.02371422f, -0.18284976f, 
    -0.04288543f, 0.07205714f, -0.06584176f, 0.21509150f, -0.39384013f, -0.44463986f, -0.07604378f, -0.07023641f, 
    -0.14422502f, 0.16019036f, 0.00296498f, -0.08452971f, 0.12401438f, -0.03006370f, -0.05824752f, 0.10583568f, 
    0.22897728f, 0.15257651f, 0.10480361f, -0.00278492f, 0.03599098f, 0.41044414f, 0.23946302f, 0.30306366f, 
    -0.06748913f, 0.09530269f, 0.27388710f, 0.03602637f, 0.20101710f, 0.11123184f, -0.19723126f, -0.14421704f, 
    0.07896369f, 0.00612726f, -0.02786745f, 0.02081813f, -0.01233012f, -0.10578550f, -0.05510323f, 0.22521797f, 
    0.15682901f, -0.01171318f, 0.10173510f, -0.13506952f, 0.06219535f, 0.18107872f, -0.06102900f, 0.17410953f, 
    0.00253738f, -0.22101009f, 0.08474069f, 0.06452301f, 0.04088690f, 0.08434023f, 0.00452504f, 0.15923963f, 
    0.18386209f, -0.29116777f, -0.40057546f, 0.06299719f, 0.12239952f, 0.11995565f, 0.21010616f, -0.07955276f, 
    -0.06085708f, 0.22578834f, 0.21209359f, -0.02823846f, -0.00903773f, -0.11448054f, -0.02437313f, 0.18678173f, 
    0.05539768f, 0.05088347f, 0.00940422f, 0.31671521f, 0.41730934f, -0.14071846f, -0.24396056f, 0.03110324f, 
    -0.08142438f, 0.06351591f, -0.07180823f, -0.07866294f, -0.44964284f, 0.00816503f, 0.13162710f, -0.04127264f, 
    0.07259531f, 0.04172510f, -0.17522748f, 0.08820259f, 0.15397297f, 0.02784367f, 0.21507864f, -0.50103194f, 
    -0.27361804f, -0.20340896f, -0.09835880f, 0.26496425f, -0.05751068f, 0.10399988f, -0.27800635f, -0.20380285f, 
    -0.65722680f, 0.02268061f, 0.00526729f, 0.06638554f, -0.06924298f, 0.11772020f, -0.02031577f, -0.07883315f, 
    -0.32936674f, 0.05974815f, -0.12374894f, 0.02130153f, 0.22249055f, 0.06592143f, -0.03913833f, -0.02404671f, 
    -0.05199669f, 0.01050704f, -0.07185389f, -0.03376471f, -0.02864981f, 0.05002245f, -0.02410551f, 0.03116067f, 
    -0.01660832f, 0.02221759f, 0.03656493f, 0.04766793f, 0.05737400f, 0.04434527f, 0.02223340f, 0.00245525f, 
    0.00301715f, -0.01349158f, 0.01287255f, -0.02936233f, 0.02884367f, 0.03466246f, 0.06601457f, -0.07735414f, 
    -0.09019942f, 0.05310200f, 0.00740211f, 0.05508839f, -0.08309656f, -0.09393819f, 0.02224812f, -0.02613440f, 
    0.06719930f, 0.00103833f, -0.05114719f, 0.05911531f, 0.02819583f, 0.03870117f, -0.01681276f, -0.03896048f, 
    -0.03663946f, -0.09167691f, -0.00290917f, -0.05083277f, -0.02222459f, 0.00542946f, -0.03756555f, -0.01811432f, 
    -0.04926290f, -0.05404373f, -0.03285621f, -0.06242482f, -0.07367103f, -0.06136125f, 0.03818258f, 0.05155160f, 
    0.00874213f, 0.07256760f, 0.06421274f, 0.03941090f, 0.00556132f, -0.07690537f, -0.03388836f, 0.05019208f, 
    0.03953931f, -0.06743069f, 0.01462896f, -0.04591213f, 0.05791579f, 0.02890809f, -0.00630117f, -0.00005082f, 
    -0.07695255f, 0.01873678f, 0.01517131f, -0.06003294f, -0.07859114f, -0.04259630f, 0.04818038f, -0.00699577f, 
    -0.00205829f, -0.02137332f, -0.06834570f, -0.03000994f, 0.05275393f, 0.06991110f, -0.04210603f, -0.02664224f, 
    -0.05902901f, 0.01467425f, 0.06300415f, 0.04669684f, -0.04904834f, -0.04350681f, 0.05510452f, 0.01545929f, 
    -0.05996782f, 0.05395058f, -0.02003129f, -0.07609899f, 0.05639793f, 0.03310689f, 0.03458343f, -0.04661670f, 
    -0.00840124f, 0.05940616f, -0.01023005f, 0.01553012f, 0.04789825f, 0.06139925f, 0.05874562f, -0.02529442f, 
    0.04073444f, 0.04883181f, 0.05590701f, -0.00391509f, -0.01416252f, -0.03112446f, -0.08986806f, -0.04877138f, 
    -0.02008570f, 0.00585998f, -0.05628578f, -0.00385542f, 0.06966293f, 0.05046189f, -0.04722939f, -0.04053433f, 
    0.03668098f, -0.06951185f, -0.08420360f, -0.00291271f, -0.04888857f, -0.05269612f, -0.09017988f, 0.05462655f, 
    -0.07671788f, -0.08179412f, -0.02877885f, -0.03881555f, -0.05977225f, -0.06974135f, -0.08018691f, -0.00624465f, 
    0.08171383f, 0.13055611f, 0.09238292f, -0.22406672f, -0.16208555f, -0.16305466f, -0.05038944f, -0.11446767f, 
    0.17182726f, 0.23397779f, 0.20281301f, 0.14423726f, -0.18472898f, -0.18580788f, 0.00308407f, -0.01609981f, 
    0.13211608f, 0.06815731f, 0.13252713f, 0.31039375f, 0.30408737f, -0.27940243f, 0.05362149f, -0.01668016f, 
    0.21035230f, -0.00589192f, -0.04876954f, -0.16719547f, -0.07822327f, 0.10073853f, -0.10889688f, -0.06643633f, 
    0.03083107f, -0.05168204f, -0.10981488f, -0.09280809f, 0.20705479f, 0.01227245f, 0.16723421f, 0.11526862f, 
    0.26516286f, -0.01125752f, 0.19050255f, 0.03098652f, -0.02877787f, -0.60667729f, 0.07896104f, -0.55602193f, 
    -0.17149268f, 0.02594452f, 0.11100912f, -0.02993111f, 0.00203165f, -0.06993392f, 0.32434073f, 0.67601734f, 
    0.28676170f, -0.16407652f, 0.05533331f, -0.01628236f, 0.18395658f, 0.01314586f, -0.06472709f, -0.07167168f, 
    -0.35528904f, -0.18400520f, 0.01152888f, 0.04695002f, 0.04724701f, 0.24191315f, -0.03950475f, -0.08599057f, 
    -0.22766733f, -0.19874421f, -0.01094810f, -0.01905078f, 0.04427446f, 0.05228150f, 0.12599900f, 0.03600484f, 
    -0.14892253f, 0.21817413f, 0.17244393f, 0.06398670f, 0.17169966f, -0.29590675f, 0.18847343f, -0.05844465f, 
    0.04855160f, -0.18016265f, -0.44230363f, -0.15031661f, -0.19422215f, -0.01130238f, -0.22602251f, -0.09906947f, 
    0.04706026f, 0.01432185f, 0.14200394f, 0.23490715f, -0.03918380f, 0.34857723f, -0.05344518f, -0.05425265f, 
    0.06813174f, 0.09786768f, -0.13059184f, 0.10837553f, 0.29777840f, 0.02237429f, -0.30275407f, -0.10608256f, 
    0.05391676f, -0.10856143f, -0.03308102f, -0.14642021f, -0.00030854f, -0.12057428f, 0.08990873f, 0.22525090f, 
    -0.06677338f, -0.12880674f, -0.15787782f, 0.17322356f, -0.03730686f, -0.13703734f, 0.01106710f, -0.04134589f, 
    -0.21493337f, -0.00007316f, -0.01700645f, 0.13044082f, 0.04959087f, -0.07065300f, 0.08363296f, -0.08118519f, 
    -0.25287798f, 0.05235407f, -0.04681042f, 0.08384252f, -0.00769594f, 0.07087168f, 0.10256172f, -0.20256321f, 
    -0.11677743f, 0.04355755f, -0.14513116f, -0.06970439f, -0.09845902f, -0.03263383f, 0.03064337f, -0.14040710f, 
    0.17252822f, -0.17750873f, 0.01606774f, 0.29382131f, -0.04493478f, -0.01088511f, -0.03215032f, 0.12683362f, 
    0.08659749f, 0.12827349f, -0.10410276f, 0.09436011f, 0.09116061f, -0.07801116f, 0.17450656f, -0.07737880f, 
    -0.07979223f, 0.19381344f, 0.11980270f, -0.33709607f, -0.06435208f, -0.02243183f, -0.20504948f, 0.05756463f, 
    0.00013143f, 0.06800204f, 0.01686983f, 0.34135461f, -0.00960156f, 0.13555086f, 0.33616170f, 0.04521719f, 
    0.05095562f, 0.07192894f, 0.14523165f, 0.06827589f, -0.09645049f, -0.07932893f, -0.12831356f, 0.42275566f, 
    0.04938915f, -0.05946858f, 0.39946133f, -0.09720466f, 0.07436147f, 0.02268682f, -0.36447620f, -0.01363107f, 
    -0.28473660f, -0.11713491f, 0.00423002f, -0.19502357f, 0.09841750f, -0.10676796f, 0.13438699f, 0.21303859f, 
    -0.11018678f, 0.39693272f, 0.01449733f, 0.00471633f, 0.14022969f, -0.00175464f, 0.04769937f, 0.26549450f, 
    0.06987918f, -0.11316896f, -0.16507003f, -0.04591230f, 0.17903227f, 0.03412220f, 0.04484625f, 0.06062803f, 
    -0.00795311f, -0.14859064f, -0.13403426f, -0.32191533f, -0.20345183f, -0.03670237f, -0.33981818f, -0.15949680f, 
    -0.21832496f, -0.33565149f, -0.05579606f, -0.48011234f, 0.20941608f, 0.11005282f, -0.29761866f, 0.12996387f, 
    -0.09041928f, 0.04793734f, 0.19823800f, -0.44591200f, 0.12819718f, 0.14321965f, -0.02435463f, 0.14654292f, 
    -0.19518410f, 0.03704802f, -0.29882109f, -0.09739319f, 0.03628070f, -0.22224106f, -0.20814244f, -0.06714676f, 
    0.06567237f, 0.10636947f, 0.30910292f, 0.19962083f, 0.16419677f, -0.29546693f, -0.29141694f, 0.09159165f, 
    -0.03918048f, -0.07439049f, -0.08506241f, 0.20949000f, -0.06648551f, 0.07364139f, 0.13034378f, -0.04886824f, 
    0.03694984f, -0.15733871f, 0.14189048f, 0.19700727f, 0.04381742f, 0.15686610f, 0.06383549f, 0.34747607f, 
    -0.15124449f, -0.10918324f, -0.06755363f, 0.12915677f, 0.10259980f, -0.01835659f, 0.14266917f, -0.04892654f, 
    -0.00339244f, 0.00362555f, -0.38741288f, 0.09408070f, -0.06965394f, 0.06035810f, 0.07792929f, 0.01280999f, 
    -0.23735261f, 0.18955359f, -0.06347121f, -0.03147693f, 0.03726177f, 0.06455291f, -0.15261687f, 0.09127028f, 
    -0.25169566f, 0.18830480f, 0.02254385f, -0.09215409f, -0.08206335f, 0.03299338f, -0.03461445f, 0.09156349f, 
    0.07178398f, 0.19491854f, -0.05275833f, 0.26813394f, 0.25469440f, -0.10978727f, 0.00523815f, -0.02350093f, 
    0.04194693f, 0.00109071f, -0.01563592f, -0.09448037f, 0.05820582f, 0.30434793f, 0.17162943f, 0.05582324f, 
    0.14749724f, -0.02208246f, -0.00574872f, 0.27044514f, 0.15820156f, -0.14349452f, -0.14608774f, 0.54227132f, 
    0.05777400f, 0.27402139f, 0.08827122f, 0.22589543f, 0.25417694f, 0.48233673f, -0.20565580f, -0.36701453f, 
    -0.25440606f, 0.07776354f, 0.10134349f, 0.02336485f, 0.09716472f, 0.02158714f, -0.08107292f, -0.14632182f, 
    0.00067522f, 0.20506690f, 0.08158408f, 0.18086272f, 0.10568389f, -0.07769519f, -0.06434848f, -0.01558120f, 
    0.01569314f, 0.27450785f, -0.01138478f, -0.03939882f, 0.14845954f, 0.08957765f, -0.09664605f, 0.24023066f, 
    0.01202441f, 0.17501317f, 0.17024297f, -0.03074499f, -0.16344026f, -0.10988866f, 0.07225774f, 0.06103895f, 
    0.08251661f, 0.06078438f, 0.10844742f, -0.23519646f, 0.14653511f, 0.10825329f, 0.17441638f, -0.07875845f, 
    -0.22630249f, 0.11199419f, 0.01986207f, -0.03299180f, 0.01287346f, 0.19720469f, -0.03905752f, 0.07633122f, 
    -0.06570822f, -0.05481008f, -0.19830550f, -0.04937867f, 0.04548803f, 0.03999021f, -0.26041842f, 0.11069144f, 
    -0.05217887f, -0.07991459f, -0.18809353f, -0.07998411f, -0.02765428f, -0.00586439f, 0.14214571f, -0.05244229f, 
    -0.09978177f, -0.11785526f, 0.01643090f, 0.13633022f, 0.06362356f, -0.16204305f, 0.00137702f, -0.01888180f, 
    0.05311782f, 0.22701053f, -0.07700955f, -0.02353813f, 0.12829679f, 0.10359866f, 0.03138392f, -0.42238694f, 
    -0.20216629f, 0.06831659f, 0.09471238f, 0.30365014f, 0.07552981f, -0.09731511f, 0.09143129f, -0.01024944f, 
    0.05074240f, -0.13967715f, -0.20229381f, 0.11921209f, 0.04782759f, -0.06960081f, 0.17531589f, 0.25345474f, 
    -0.01303059f, -0.31894216f, -0.38501081f, 0.07053597f, -0.08303330f, 0.10236737f, 0.10149840f, 0.13360573f, 
    0.05805167f, 0.11012284f, 0.00217817f, 0.06226901f, -0.00496741f, -0.08275314f, 0.08951587f, 0.02462909f, 
    -0.14109176f, 0.02486095f, -0.08668944f, 0.33917508f, -0.04490886f, 0.17843693f, 0.17776433f, 0.06599018f, 
    0.06801350f, -0.00866336f, -0.00606492f, -0.07788890f, 0.08031381f, -0.07473437f, -0.13402298f, 0.16198704f, 
    -0.07831215f, -0.04740455f, -0.09020287f, -0.04489725f, -0.12697145f, -0.41617975f, 0.14695069f, -0.38755116f, 
    -0.13116673f, -0.29434779f, 0.03559345f, 0.18746307f, 0.06549449f, 0.10280547f, 0.19507743f, -0.15198410f, 
    -0.16898033f, 0.08210835f, -0.00930441f, -0.05190140f, 0.00063257f, -0.01097758f, -0.01288163f, -0.28638017f, 
    0.21963733f, -0.32650939f, 0.09293780f, 0.00948637f, -0.12387464f, 0.14795358f, 0.15223700f, 0.23306015f, 
    -0.03383971f, -0.29310870f, -0.04269484f, -0.03994708f, 0.21303105f, -0.07650465f, 0.12855481f, 0.03022331f, 
    0.11799701f, 0.24864216f, 0.37139767f, -0.08867769f, -0.25799182f, 0.02817962f, 0.06406523f, -0.28244287f, 
    -0.34466830f, -0.15586741f, 0.47701833f, 0.03902989f, -0.21348730f, -0.21987213f, -0.10279115f, -0.02834656f, 
    0.11617655f, 0.18614627f, -0.08640221f, 0.22504301f, -0.00084694f, 0.05084578f, 0.22326811f, -0.03001215f, 
    0.30929953f, 0.04804730f, -0.18664038f, -0.20543912f, 0.06544521f, -0.10897011f, -0.11169802f, 0.08146594f, 
    0.02901309f, 0.12349994f, -0.17713812f, 0.06276704f, -0.10189068f, 0.22665402f, -0.32386011f, 0.24850178f, 
    -0.01656796f, -0.05083154f, 0.05039255f, 0.03575614f, 0.07928389f, -0.02199212f, 0.22444493f, 0.12022446f, 
    0.29412007f, 0.10697313f, 0.06428109f, 0.00950578f, -0.06597576f, 0.01245375f, 0.02566925f, -0.24054050f, 
    -0.25898433f, 0.24604477f, -0.15628335f, -0.00708017f, 0.02035860f, 0.07957468f, 0.03809619f, 0.05686751f, 
    -0.08583011f, -0.06074785f, 0.04601602f, 0.08400743f, 0.11970355f, -0.10381565f, 0.04303600f, -0.16942552f, 
    -0.21499930f, 0.34412241f, 0.07457361f, 0.22025928f, 0.06039959f, -0.05221909f, -0.08537871f, 0.07859478f, 
    0.06330774f, -0.00350804f, -0.19031383f, 0.08763336f, -0.02210906f, 0.11126152f, 0.14169492f, -0.24542856f, 
    0.00211246f, -0.01646330f, 0.04636131f, 0.38545129f, 0.36507073f, 0.08510768f, 0.02584676f, -0.16404958f, 
    -0.10803283f, -0.11527304f, -0.05740788f, -0.24438621f, -0.12013987f, 0.00335611f, 0.10905021f, 0.08704440f, 
    -0.18808292f, 0.23845656f, 0.01544239f, 0.12526169f, -0.08303876f, -0.07616380f, -0.19391529f, 0.02495808f, 
    0.02020670f, -0.17418678f, 0.16781689f, -0.13378407f, 0.09651207f, -0.11637085f, -0.07923674f, 0.25073805f, 
    0.31623045f, 0.04649106f, 0.02920640f, 0.07136494f, 0.16047558f, 0.11639075f, 0.06215192f, -0.19263703f, 
    -0.14668986f, 0.11447608f, -0.03335018f, 0.04740359f, 0.19103090f, -0.08416630f, -0.03422359f, -0.23521645f, 
    -0.41983396f, -0.22024116f, 0.06866301f, -0.05197680f, 0.09775820f, -0.04849898f, 0.01618678f, 0.03956665f, 
    0.08835734f, -0.20321018f, 0.03817766f, 0.03110854f, -0.02890482f, 0.28564113f, -0.05778465f, 0.11606035f, 
    0.13796595f, 0.30342737f, 0.32986438f, -0.08691406f, 0.02668989f, -0.09001783f, -0.02865526f, 0.04667460f, 
    -0.07427505f, -0.15297274f, 0.09069594f, 0.57458067f, 0.37895578f, 0.05671192f, -0.04126708f, 0.06464832f, 
    0.15414909f, 0.04827883f, 0.23934115f, -0.03877770f, 0.01862568f, 0.26260743f, 0.23262909f, 0.01718483f, 
    -0.02681832f, -0.08566415f, -0.00607541f, 0.16264868f, -0.31601954f, 0.65667641f, 0.33036402f, -0.30498359f, 
    -0.02532315f, -0.16427380f, -0.05959882f, 0.04918654f, 0.04982906f, 0.01130372f, 0.12455146f, 0.24405344f, 
    0.22145587f, 0.06205769f, 0.08077478f, 0.07047124f, 0.03279756f, -0.12452468f, -0.22610113f, -0.50999230f, 
    -0.28163791f, -0.15863158f, -0.08726638f, 0.02348637f, 0.01874981f, -0.07479260f, -0.08512644f, 0.14852770f, 
    -0.09876278f, -0.04478787f, -0.26264447f, -0.28528863f, -0.06669231f, -0.02688920f, -0.03535179f, -0.09434982f, 
    -0.02170506f, -0.40139714f, -0.30778265f, 0.09199630f, -0.08856308f, 0.07523055f, 0.05858013f, 0.14151534f, 
    0.09850872f, 0.03055339f, -0.24830376f, -0.23780634f, -0.34138474f, 0.16824377f, -0.02556123f, -0.12569796f, 
    -0.01118709f, 0.21018447f, 0.08928452f, -0.24543044f, 0.02419175f, 0.30858257f, -0.04181329f, -0.12272696f, 
    0.03399603f, 0.20227966f, -0.03989592f, -0.04502795f, -0.06931842f, -0.06281091f, -0.30054039f, 0.06093033f, 
    -0.15559289f, 0.26713246f, 0.04113668f, 0.17345044f, -0.24633177f, 0.23231256f, -0.16442509f, -0.18903622f, 
    -0.15210269f, 0.03163145f, -0.10335543f, 0.13160451f, 0.11647649f, 0.19000365f, 0.09451950f, -0.01739654f, 
    0.38786566f, -0.23513703f, 0.10421458f, -0.10895579f, -0.06342944f, -0.02498671f, 0.03918523f, 0.54393125f, 
    -0.09842768f, -0.14581586f, -0.01217824f, 0.11360238f, 0.01152518f, 0.16700728f, -0.10054038f, 0.02177552f, 
    0.16584387f, -0.28810951f, -0.26536888f, 0.03279230f, 0.03272918f, -0.01021212f, 0.13318694f, 0.17596425f, 
    -0.04426621f, 0.35978898f, 0.20328578f, 0.10402673f, -0.04047689f, -0.08929957f, 0.08639631f, -0.02445472f, 
    -0.09571154f, -0.08444879f, 0.50228316f, -0.62834042f, -0.59861672f, -0.11833427f, -0.14464168f, -0.14290810f, 
    0.04848678f, 0.08600688f, 0.11980168f, 0.03727716f, -0.00619260f, 0.11613920f, -0.02849574f, -0.15664198f, 
    0.16870074f, 0.04611868f, -0.18624735f, 0.08179562f, -0.23736507f, 0.00559743f, 0.10590196f, 0.24598451f, 
    -0.16959253f, 0.08953348f, 0.04448094f, 0.14979498f, -0.08082241f, 0.15702340f, -0.04650128f, 0.19804442f, 
    0.02452427f, -0.13569389f, 0.06191956f, 0.19832329f, 0.04557076f, -0.06840287f, -0.09680361f, 0.45848194f, 
    -0.07562018f, 0.16372772f, 0.06522935f, 0.14884953f, 0.18688984f, -0.06891649f, -0.06857859f, 0.41208643f, 
    -0.30127269f, -0.54777205f, 0.10707387f, 0.13756362f, -0.10958215f, 0.08664793f, 0.10791748f, 0.02436152f, 
    0.02908305f, 0.03620846f, -0.08106191f, -0.03844075f, -0.16068262f, -0.13704900f, 0.09349041f, -0.05072531f, 
    -0.15235852f, -0.11102247f, -0.16742581f, 0.41631177f, 0.06586686f, 0.12989369f, -0.07442962f, 0.12942487f, 
    -0.05559567f, -0.02383696f, -0.23078649f, -0.09775841f, -0.03443570f, -0.01945088f, -0.06328844f, 0.26255679f, 
    0.03065385f, 0.20275109f, 0.09499067f, -0.26462528f, 0.08372400f, 0.34779915f, 0.07090823f, 0.07750464f, 
    -0.04158782f, -0.01829706f, 0.11197638f, 0.10170703f, 0.02694348f, 0.35616726f, 0.15765877f, 0.09561919f, 
    0.07811785f, -0.01737942f, 0.28768355f, 0.11810782f, -0.03164660f, -0.11024821f, -0.09875963f, 0.18366751f, 
    0.14150043f, 0.01768904f, 0.10775974f, -0.13849083f, -0.11029499f, 0.16849507f, -0.09999084f, -0.11579844f, 
    0.52183908f, 0.12726039f, 0.26580712f, -0.03210938f, 0.05967444f, -0.03891145f, -0.18000554f, -0.12824045f, 
    0.11417521f, 0.26887891f, 0.23930445f, 0.07466870f, -0.15104340f, 0.02564977f, -0.01458479f, 0.18940322f, 
    -0.41982186f, -0.05034221f, -0.22564557f, 0.09280417f, -0.01529458f, -0.01801384f, -0.16853936f, 0.13669282f, 
    0.16776939f, 0.05981022f, -0.07003955f, -0.27861747f, -0.24355164f, -0.06073804f, -0.11831015f, 0.03307949f, 
    -0.11314069f, 0.06540280f, 0.02340225f, -0.06056254f, 0.54738265f, -0.19914588f, -0.32654539f, 0.14827694f, 
    -0.04690354f, -0.04246543f, -0.00411132f, -0.11598313f, -0.49977946f, 0.41714871f, 0.14220813f, 0.09394045f, 
    -0.03190455f, 0.03951591f, 0.05171358f, 0.08646784f, 0.18653812f, -0.03091954f, 0.04228849f, 0.03168412f, 
    -0.10226575f, -0.05144091f, -0.03987532f, 0.09098864f, -0.04177729f, -0.46223760f, -0.02323500f, 0.39719981f, 
    -0.02416408f, -0.10462632f, 0.01620820f, -0.05484077f, 0.16425605f, -0.02897800f, 0.23919407f, -0.00385973f, 
    0.25429171f, -0.07737461f, -0.03019244f, 0.01957099f, -0.07554393f, 0.09074192f, -0.03376165f, -0.32853863f, 
    -0.00711857f, 0.23992881f, -0.09581729f, 0.12171275f, -0.04596157f, 0.12283194f, -0.13533792f, 0.02960620f, 
    -0.03825319f, -0.06582182f, 0.00637525f, -0.08942150f, 0.03196996f, 0.00764070f, -0.11937658f, -0.00878540f, 
    -0.03724130f, -0.10253358f, -0.13595417f, -0.03621873f, -0.06166044f, 0.04879209f, -0.07686827f, -0.02036175f, 
    0.03464583f, -0.09153035f, -0.01031611f, -0.04639021f, -0.06888742f, -0.02657258f, 0.02404266f, -0.05399352f, 
    -0.10583006f, -0.07727738f, -0.09418080f, 0.00798432f, -0.02912249f, -0.07246597f, -0.09945109f, -0.03608497f, 
    -0.09969094f, 0.04040439f, 0.04568795f, 0.01088240f, -0.05739956f, -0.06483220f, -0.07464060f, -0.05768364f, 
    -0.09703011f, -0.04951563f, -0.13116685f, -0.08819310f, -0.09225381f, -0.01613277f, -0.08977615f, -0.07211515f, 
    -0.03766031f, -0.03256569f, -0.15915701f, -0.01528269f, -0.10477813f, 0.02742264f, 0.01670907f, -0.02222927f, 
    -0.09842294f, -0.02921578f, 0.02029428f, -0.06999278f, -0.06427054f, 0.05812432f, 0.02713744f, -0.05430616f, 
    -0.09835733f, -0.00951947f, 0.00675759f, -0.09176491f, -0.01264360f, 0.05336717f, -0.00469485f, -0.03190773f, 
    -0.06423362f, -0.00644649f, -0.11393546f, -0.01806397f, -0.01222437f, -0.02349373f, -0.01949881f, 0.01978510f, 
    0.04857824f, -0.03179087f, 0.00851763f, -0.01748696f, -0.08358628f, -0.01224677f, -0.04457958f, 0.00412473f, 
    -0.04494005f, -0.08809302f, -0.15421106f, 0.01244009f, -0.08529381f, 0.02651470f, 0.04010553f, -0.07976021f, 
    -0.06329912f, -0.05607254f, -0.02506279f, -0.06701692f, -0.09958538f, 0.01645578f, 0.04810138f, 0.01503470f, 
    -0.05396876f, 0.01002403f, 0.02593061f, 0.03617960f, -0.01796052f, -0.12826645f, -0.11816940f, -0.10407751f, 
    0.03460965f, -0.00163738f, -0.05743402f, -0.08621050f, 0.02700321f, -0.09072632f, -0.11173362f, -0.08876584f, 
    -0.03905469f, -0.11786249f, -0.11469043f, -0.05692628f, -0.10166537f, 0.02120330f, -0.07363595f, 0.01716305f, 
    -0.05137650f, -0.02342882f, -0.07212077f, -0.08733853f, -0.02239437f, -0.04119721f, -0.01272868f, -0.04947107f, 
    -0.01999737f, -0.04574526f, -0.07520378f, -0.06886936f, -0.10453845f, -0.00718786f, -0.03338705f, -0.06531684f, 
    -0.15393108f, -0.03326140f, 0.06636254f, -0.04037181f, -0.09770465f, -0.14601912f, -0.24623740f, -0.09472501f, 
    0.11384312f, -0.65819931f, -0.38512436f, -0.19477859f, 0.16812052f, 0.34594983f, 0.05854021f, 0.09090106f, 
    -0.03824522f, -0.01767264f, 0.03988517f, 0.05504896f, 0.06530055f, -0.09027368f, -0.01539171f, 0.01771615f, 
    -0.10420330f, -0.01510478f, 0.17706326f, 0.01770097f, -0.23775581f, -0.16271625f, -0.19285467f, -0.16967906f, 
    0.01898250f, 0.06503375f, -0.07691149f, -0.15145350f, -0.13297711f, -0.23193200f, -0.27728868f, 0.01619232f, 
    0.07523429f, 0.25180840f, 0.29632327f, -0.09858085f, -0.03841667f, 0.74404007f, -0.29704759f, 0.06216130f, 
    -0.00453992f, 0.02367089f, 0.05046429f, 0.08854218f, 0.01953191f, 0.05875118f, -0.12435477f, -0.54204905f, 
    0.17323068f, -0.02763641f, 0.04610634f, -0.31811973f, 0.14515446f, 0.07044547f, 0.06315867f, 0.28997624f, 
    0.29220405f, 0.14543602f, 0.09953859f, -0.00247010f, 0.09345548f, -0.01534559f, 0.04951846f, 0.25914633f, 
    0.38959709f, -0.04212415f, 0.08917507f, 0.10667753f, -0.04564155f, -0.00974222f, 0.09170093f, 0.12077942f, 
    0.17007145f, -0.29841417f, -0.45412347f, -0.18978775f, -0.21041322f, 0.04001466f, -0.13106279f, 0.20650609f, 
    0.23048382f, 0.00274330f, -0.67216402f, -0.31311008f, -0.36052179f, -0.06153486f, -0.06078335f, -0.04519150f, 
    -0.09203968f, -0.19899119f, 0.14132825f, -0.24660607f, -0.01551582f, 0.22443205f, -0.35282356f, -0.03214764f, 
    -0.11511552f, -0.11797856f, -0.02319541f, -0.04025676f, -0.61059433f, -0.26180828f, -0.04720062f, -0.11552084f, 
    -0.03402993f, 0.08706952f, 0.09797890f, -0.22955306f, 0.11367767f, 0.14735156f, -0.05256342f, -0.07447290f, 
    -0.07627115f, 0.24355111f, 0.02136983f, -0.05054526f, -0.15064059f, 0.12030487f, -0.06755587f, -0.15309183f, 
    -0.44349727f, -0.11967178f, 0.01945502f, 0.24652275f, 0.26574954f, 0.02229816f, 0.05012654f, 0.36902806f, 
    0.16062640f, 0.13623665f, 0.02155913f, -0.15531009f, -0.13496786f, 0.11852575f, -0.02335274f, 0.23151590f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.34868786f, 0.21338482f, 0.14243035f, -0.08245537f, -0.02714697f, 0.07800897f, 0.01364399f, 0.05859997f, 
    0.35173029f, 0.08631216f, -0.02144004f, -0.13451874f, 0.06529008f, 0.06448962f, -0.11875308f, 0.40647057f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.07591801f, 0.13707422f, 0.32278582f, 0.01061425f, -0.17818193f, -0.48811010f, -0.20496020f, 0.03422498f, 
    0.13024399f, 0.02238308f, 0.10315435f, -0.12957394f, 0.10886122f, 0.03171769f, -0.13958450f, -0.11413642f, 
    -0.20584992f, -0.35602275f, -0.24329014f, -0.24971236f, 0.26568988f, -0.42312446f, -0.04651350f, -0.00240563f, 
    -0.52784783f, -0.05493624f, 0.30292436f, 0.39155510f, 0.04698703f, -0.27359697f, -0.17861918f, -0.36106324f, 
    -0.43736684f, 0.28197524f, -0.17475119f, -0.18553759f, 0.01260581f, -0.46541142f, 0.22493847f, 0.27413961f, 
    -0.09281251f, 0.28571296f, 0.29664037f, 0.08522352f, -0.21332571f, 0.16456275f, 0.14438279f, -0.53648800f, 
    -0.34544212f, -0.19137807f, 0.32995042f, 0.05124268f, 0.06984221f, 0.08479853f, 0.16985098f, -0.30573171f, 
    -0.09012443f, 0.24124467f, 0.12330195f, 0.25839868f, -0.29653227f, 0.20105727f, 0.02718493f, 0.16252223f, 
    -0.47531202f, -0.03854360f, 0.30713397f, -0.84461391f, 0.12415650f, 0.03550513f, 0.07919211f, -0.39281437f, 
    -0.06386780f, 0.38326314f, -0.18470734f, 0.13736297f, -0.27000135f, 0.50423259f, 0.09380160f, 0.17798929f, 
    0.04493684f, 0.23149501f, -0.19307759f, -0.01529316f, -0.20802528f, -0.40122861f, 0.09260522f, 0.29157993f, 
    0.33402333f, 0.14706115f, 0.26704469f, -0.11373205f, -0.18535087f, 0.12188827f, 0.16822222f, -0.46749002f, 
    -0.46886373f, -0.02659633f, -0.16919953f, 0.12617449f, 0.13518630f, 0.01393147f, 0.21720526f, 0.43799487f, 
    0.23306957f, 0.12958370f, 0.07641723f, -0.25807002f, 0.11420566f, 0.04595966f, 0.06491366f, 0.22049263f, 
    0.07935683f, -0.12903209f, -0.11646982f, 0.12291130f, 0.05668328f, -0.29232424f, 0.08429213f, 0.21340705f, 
    -0.16565271f, 0.25883612f, 0.28278926f, -0.41715050f, 0.21985292f, -0.31681648f, -0.01111886f, -0.20843154f, 
    -0.48204815f, -0.09271664f, -0.18883702f, 0.38169858f, 0.43890610f, -0.12603244f, -0.01748262f, 0.06188229f, 
    -0.03488884f, 0.00817090f, -0.02930287f, 0.05255266f, -0.14038178f, 0.42271951f, -0.15442604f, 0.50532842f, 
    0.11681037f, -0.22255309f, 0.18528444f, -0.32006913f, -0.14585523f, -0.45489281f, 0.08452611f, -0.07582478f, 
    0.49294853f, 0.39458489f, -0.36380029f, 0.13520989f, -0.11192309f, 0.25129676f, 0.16200954f, 0.06278987f, 
    -0.11670971f, 0.24478319f, -0.00875598f, 0.02939293f, -0.09804288f, -0.16681331f, -0.03211343f, 0.06333506f, 
    -0.08519650f, -0.17800310f, -0.04476261f, -0.07249999f, -0.18862477f, -0.10854495f, 0.08146298f, -0.23781177f, 
    -0.22844990f, -0.03641357f, 0.00923836f, 0.22050512f, 0.16322964f, 0.17994006f, 0.16325293f, 0.19755940f, 
    0.32359552f, -0.21609563f, -0.09969383f, -0.15599234f, 0.74459940f, -0.16573352f, -0.08495504f, 0.60839272f, 
    0.04785211f, -0.28248835f, 0.05369700f, 0.02666876f, -0.11775208f, -0.13471793f, -0.04073308f, 0.00733385f, 
    0.29663232f, 0.30343604f, -0.24602325f, -0.07992092f, 0.18742464f, 0.22203925f, 0.16116756f, -0.05315408f, 
    -0.13514988f, -0.21393545f, -0.10095783f, 0.20141627f, 0.28050718f, 0.17334332f, -0.01392154f, -0.02340285f, 
    -0.31662163f, 0.26723775f, 0.38154793f, -0.02601250f, 0.30811089f, -0.23898475f, -0.16913918f, 0.62122768f, 
    -0.43838903f, -0.15543282f, -0.06598525f, -0.08589462f, -0.44341242f, -0.44529611f, -0.04465917f, -0.16889624f, 
    -0.02747923f, 0.20769611f, 0.22568041f, 0.38630852f, 0.69551975f, -0.12280717f, 0.14094757f, -0.33059487f, 
    0.17533764f, 0.11235248f, 0.33743739f, -0.59251386f, 0.16027750f, -0.48272070f, 0.19302401f, 0.06755176f, 
    0.11317375f, -0.00714619f, -0.26384169f, -0.25659516f, 0.41134402f, 0.08635639f, -0.09430366f, 0.57953471f, 
    0.28115821f, -0.27848944f, -0.25694576f, 0.00368049f, 0.00876659f, -0.13575856f, -0.10950480f, -0.35876608f, 
    0.41065398f, 0.26130727f, -0.11408728f, 0.06979105f, 0.02158211f, 0.27669758f, -0.13322146f, -0.20919803f, 
    0.18758199f, 0.33758882f, -0.32767749f, -0.13129130f, -0.25978500f, -0.32551983f, 0.21649130f, -0.11795647f, 
    0.29545444f, 0.29286212f, 0.34170181f, -0.25108820f, -0.46000841f, 0.10351983f, 0.08864179f, -0.16344632f, 
    0.37375760f, 0.02960845f, -0.30185720f, 0.27554438f, 0.36248022f, 0.28292277f, 0.10931321f, -0.45685640f, 
    0.29626203f, -0.03325946f, 0.02563728f, -0.23788567f, -0.29108280f, -0.25775120f, 0.05281688f, 0.47800332f, 
    -0.23524266f, -0.22911501f, 0.04111940f, 0.18578762f, -0.18205976f, -0.12226495f, 0.02390525f, -0.12621981f, 
    -0.04810447f, -0.01159206f, -0.14936426f, 0.18750301f, -0.17707920f, -0.19667345f, -0.08055788f, 0.08920997f, 
    0.15901116f, 0.17125919f, 0.03677834f, -0.38219646f, -0.47128052f, 0.48175842f, -0.09899564f, -0.72300196f, 
    -0.32699120f, -0.17119908f, 0.14525977f, 0.14917016f, 0.20585351f, 0.45180205f, 0.11020419f, 0.57537508f, 
    -0.03512993f, 0.13757893f, -0.16046482f, 0.00068460f, 0.00128489f, 0.47154039f, -0.15777840f, 0.31423363f, 
    -0.42731005f, -0.14448123f, 0.41138020f, -0.04585763f, 0.41111442f, 0.25233054f, -0.13403851f, 0.02163927f, 
    0.29079404f, -0.05301937f, 0.26169741f, -0.14555472f, 0.07379003f, -0.07388744f, 0.00024021f, 0.01525257f, 
    0.24080653f, -0.27511391f, -0.35337001f, -0.43413645f, -0.01894307f, 0.03257358f, -0.20039350f, 0.12533510f, 
    0.02286700f, 0.26991430f, 0.08320501f, -0.48989806f, -0.00175482f, -0.35977778f, 0.19230910f, 0.00027766f, 
    0.55286282f, 0.26834938f, -0.21157476f, -0.18544790f, -0.49308777f, 0.18408854f, 0.10152701f, -0.06103110f, 
    -0.02642544f, -0.24045168f, 0.25646880f, 0.18071760f, -0.17812507f, 0.18684417f, 0.04440532f, 0.08073528f, 
    -0.05059085f, -0.26947632f, -0.21748266f, 0.28033113f, 0.57837224f, 0.30636856f, -0.06195871f, 0.24539040f, 
    -0.20917027f, -0.19663098f, 0.13399234f, 0.25139248f, 0.02992709f, 0.31409264f, -0.12475852f, -0.06718154f, 
    -0.07567105f, 0.01724292f, 0.12457614f, 0.19803903f, 0.20822380f, -0.08041752f, -0.26304859f, -0.06595930f, 
    -0.05679815f, 0.25741228f, 0.27071056f, -0.01505268f, 0.16053866f, 0.26335797f, 0.01915967f, -0.05746699f, 
    -0.32912248f, -0.15478508f, 0.13415994f, 0.23688991f, 0.07507016f, -0.43390352f, 0.19643305f, 0.03589072f, 
    0.23987526f, 0.14780851f, 0.35667887f, -0.42157868f, -0.24749526f, -0.03862378f, -0.17464797f, -0.14514706f, 
    0.18234296f, 0.00468275f, -0.23042177f, 0.02062320f, 0.11476421f, 0.26724708f, -0.17002694f, -0.08308195f, 
    0.06658835f, 0.48449716f, -0.07834172f, 0.12928873f, -0.26029122f, 0.05718656f, -0.09707130f, -0.42148861f, 
    0.03703339f, 0.08756327f, -0.09653386f, -0.27479535f, 0.10662305f, 0.07123776f, 0.14825359f, 0.02575809f, 
    -0.51338857f, -0.04209976f, 0.20230526f, -0.30120254f, 0.27434850f, -0.59713137f, -0.06288358f, -0.02078274f, 
    0.41031319f, 0.35452461f, -0.22531021f, -0.08442372f, -0.01796547f, 0.17232955f, -0.06333193f, 0.41052634f, 
    -0.01736753f, 0.32434022f, -0.09955423f, 0.04496751f, 0.07702158f, 0.17316005f, -0.07809254f, -0.20799266f, 
    -0.22001350f, 0.19436240f, -0.00390567f, 0.04512636f, -0.29980502f, -0.15004618f, -0.18390703f, -0.13648008f, 
    0.20681198f, 0.35763407f, -0.10368416f, -0.07354365f, 0.12173413f, -0.33259991f, -0.06730386f, -0.33385292f, 
    -0.00037333f, 0.35045013f, -0.33697706f, -0.14292219f, -0.20992249f, -0.02914124f, 0.20598732f, 0.32984596f, 
    -0.38697585f, 0.16294749f, 0.14583053f, -0.06990492f, 0.05092616f, 0.15455835f, 0.03197087f, 0.31365624f, 
    0.05114963f, 0.06118528f, -0.33692920f, 0.24927147f, -0.15726687f, 0.00421812f, -0.00786105f, 0.15382966f, 
    -0.38866073f, -0.13877545f, 0.10891073f, 0.06341454f, -0.06919631f, -0.08921426f, 0.21417049f, -0.07078300f, 
    0.14957517f, 0.25244418f, -0.27234137f, 0.02062715f, 0.39038473f, 0.19485509f, 0.20751162f, -0.47129756f, 
    -0.32118276f, 0.17174104f, 0.10205332f, 0.03006808f, 0.47195059f, -0.56222647f, 0.12630330f, 0.30967891f, 
    0.09683659f, -0.26442155f, 0.17781042f, 0.23695678f, 0.04891548f, -0.12032557f, 0.08993738f, 0.34805715f, 
    -0.80576593f, 0.31982288f, -0.02944862f, 0.23201199f, 0.74422401f, 0.00416944f, -0.23141663f, 0.03016788f, 
    -0.14993197f, -0.12026259f, 0.01903185f, 0.39131194f, 0.18663646f, 0.04126491f, 0.02506677f, -0.03177969f, 
    -0.51761800f, 0.15019026f, 0.00394327f, -0.02052279f, 0.00468591f, 0.42288560f, -0.17607073f, -0.22979355f, 
    -0.21169473f, 0.10272998f, 0.34238127f, 0.47422674f, -0.45025176f, 0.04005931f, -0.11909790f, 0.28191301f, 
    0.02337125f, -0.16036795f, -0.19021177f, 0.38888389f, -0.38907090f, 0.08869468f, -0.14728175f, 0.21347788f, 
    -0.51894927f, 0.25158450f, 0.30243456f, 0.29875341f, -0.13075890f, -0.00789484f, 0.15330748f, 0.02556208f, 
    0.19613142f, 0.36482963f, -0.44381341f, -0.08501995f, -0.14781219f, -0.01318493f, 0.00861892f, -0.07689937f, 
    0.28389436f, -0.00357010f, -0.04443936f, -0.29254058f, -0.17436741f, 0.18741772f, 0.06508284f, 0.00506706f, 
    -0.41832563f, -0.12613906f, 0.24090461f, -0.38193405f, 0.41028237f, 0.25073612f, 0.02041027f, -0.61615556f, 
    -0.08971875f, 0.40275145f, 0.28601208f, 0.21062620f, -0.10964392f, -0.06724922f, -0.24279961f, 0.26064020f, 
    -0.04127010f, -0.31427771f, 0.05601494f, 0.07062138f, -0.21951340f, -0.18908171f, -0.20211570f, -0.37899688f, 
    0.18289228f, -0.09183576f, 0.16095588f, 0.11924286f, 0.36345652f, 0.20568903f, -0.20787036f, 0.20480652f, 
    -0.39119101f, -0.24846256f, -0.02041341f, 0.20528117f, 0.33171937f, -0.17922205f, -0.09451882f, 0.08019208f, 
    -0.03259035f, 0.29618049f, -0.20349275f, 0.15198608f, -0.23683923f, 0.40933821f, -0.15720028f, 0.38251936f, 
    -0.01545299f, -0.25425547f, 0.28656244f, 0.11057372f, -0.07911582f, 0.04081291f, -0.22963569f, -0.20026439f, 
    -0.22679478f, 0.02236711f, -0.23707300f, 0.35282078f, 0.52291995f, -0.08374730f, -0.01719297f, 0.51993042f, 
    -0.12374339f, 0.06908560f, 0.18870883f, 0.23775277f, 0.44821644f, -0.10885917f, 0.24399510f, -0.46544203f, 
    -0.22073542f, 0.21344729f, 0.24204071f, -0.48091963f, -0.28617814f, 0.04346652f, -0.00844143f, -0.47514594f, 
    -0.30576411f, -0.26188883f, 0.43217257f, -0.35088027f, 0.10983732f, 0.02358903f, -0.22645886f, 0.03432012f, 
    -0.19356565f, 0.18987587f, -0.02556466f, 0.02094413f, -0.21583673f, 0.27637860f, -0.14906812f, 0.06836038f, 
    0.48843262f, 0.22451076f, -0.27897707f, -0.56650364f, 0.31011465f, 0.21140121f, -0.03495464f, -0.36122683f, 
    0.02989512f, 0.03232519f, 0.36575803f, 0.10076626f, -0.17522795f, -0.27594683f, 0.14838260f, 0.09474451f, 
    -0.14174403f, 0.08195630f, -0.17377816f, -0.32693115f, -0.13620120f, 0.02300770f, -0.11211316f, 0.17840254f, 
    0.19645040f, 0.26896977f, -0.04545154f, -0.08439387f, -0.38888851f, 0.38923866f, 0.00461792f, -0.08479718f, 
    -0.11410582f, 0.20956899f, 0.31065691f, -0.60602355f, 0.11017735f, -0.04256714f, 0.07759205f, 0.35410374f, 
    0.07945698f, -0.20799649f, -0.23624118f, 0.25788647f, 0.27834150f, -0.36920351f, -0.02832523f, 0.43669394f, 
    -0.29226187f, 0.15721427f, -0.04016314f, 0.11853120f, 0.34931558f, 0.12822387f, 0.08653973f, 0.33373770f, 
    -0.10150431f, 0.16026145f, 0.34860703f, -0.20969649f, 0.13294868f, -0.12504905f, 0.12270108f, -0.41340536f, 
    0.12739238f, -0.01324068f, -0.22974522f, 0.01080611f, -0.25018886f, -0.20059980f, -0.12010437f, 0.02164607f, 
    -0.20820689f, -0.08311620f, -0.04106545f, -0.10324046f, 0.22773933f, -0.15863265f, -0.04110101f, 0.12852392f, 
    -0.09436255f, 0.11117733f, 0.08341374f, -0.07311428f, 0.10709210f, -0.09541471f, -0.09675969f, 0.25482458f, 
    0.13733783f, -0.04140414f, 0.12701999f, -0.10570576f, -0.05319167f, 0.07677200f, -0.11989119f, -0.34799555f, 
    0.40824071f, 0.04025053f, 0.07354367f, 0.07298370f, 0.10027965f, 0.13423304f, 0.03287056f, 0.13550246f, 
    0.34327793f, -0.16783978f, -0.07541542f, 0.03499116f, 0.43163174f, -0.31492224f, -0.15910296f, 0.01630211f, 
    -0.01045846f, -0.10868764f, -0.24073970f, -0.01781341f, -0.28585362f, 0.32357803f, 0.03328836f, -0.09037664f, 
    0.18759678f, -0.12912895f, 0.14836134f, 0.44750202f, 0.28143114f, -0.10380950f, 0.10064409f, -0.83918768f, 
    -0.79808998f, 0.38765135f, -0.27228251f, 0.06241875f, 0.33082253f, 0.32039708f, 0.05649215f, -0.32611474f, 
    0.02699134f, -0.02387821f, 0.14392984f, -0.18748288f, -0.21581683f, 0.23157209f, -0.02108234f, -0.17473258f, 
    0.10943265f, 0.39246324f, -0.11150301f, 0.06684720f, 0.36376059f, -0.32239708f, 0.05301570f, 0.07735758f, 
    -0.03426948f, -0.12076317f, 0.11353863f, -0.25064752f, -0.05114570f, -0.03499390f, -0.16448380f, 0.25791541f, 
    0.16686615f, -0.08874556f, -0.07335252f, -0.21360880f, 0.06636313f, -0.20527089f, -0.17493555f, -0.09587222f, 
    -0.23255479f, -0.04599240f, -0.18350920f, -0.08840680f, -0.01510218f, 0.07131556f, 0.07792556f, 0.08643582f, 
    -0.32039294f, -0.00005591f, -0.03928965f, 0.21593130f, 0.27035242f, 0.08226549f, 0.00702070f, -0.25099492f, 
    -0.15770213f, 0.16469379f, 0.02341536f, -0.24588510f, 0.20852441f, -0.08930466f, -0.11737343f, 0.65916806f, 
    0.05144498f, 0.42542905f, -0.53770489f, -0.02842197f, 0.40378490f, -0.01007344f, -0.09668351f, -0.20168112f, 
    -0.31110364f, 0.10668628f, 0.46088278f, 0.17340025f, -0.13478033f, -0.30254188f, -0.21853954f, 0.05733404f, 
    -0.36834362f, 0.33548886f, 0.40240100f, -0.27915061f, 0.15984540f, -0.52358460f, -0.01212447f, -0.38171273f, 
    -0.26514441f, 0.31160939f, -0.25880098f, -0.08567425f, 0.01608822f, -0.14011355f, 0.28017086f, 0.36783186f, 
    0.21364430f, -0.12170672f, 0.10679799f, 0.24639545f, 0.61913449f, 0.05685444f, -0.06305417f, -0.54360193f, 
    0.29125702f, -0.15550570f, -0.10400476f, -0.65281653f, 0.10162862f, -0.05172607f, 0.15761131f, 0.29476500f, 
    -0.17697436f, 0.01946224f, -0.31230399f, 0.12526117f, -0.68698353f, -0.08956006f, 0.04098008f, 0.00031112f, 
    0.09886919f, -0.23236318f, 0.39365971f, 0.35004634f, 0.58528757f, -0.00641194f, 0.00308118f, -0.56119865f, 
    -0.07905436f, -0.31720012f, -0.25177753f, 0.29129630f, -0.11537131f, 0.18788108f, -0.05983666f, 0.14891838f, 
    0.31142390f, -0.14590897f, 0.05899651f, 0.27148351f, 0.32007203f, 0.02664327f, -0.21123029f, 0.29584944f, 
    -0.14405361f, 0.07222153f, -0.54956901f, 0.11265066f, 0.25079754f, 0.17571992f, 0.07733947f, 0.13029209f, 
    0.14022295f, -0.03111759f, -0.22899410f, 0.21060906f, 0.02356388f, -0.37809905f, -0.19263914f, 0.33684003f, 
    -0.00528695f, 0.10231923f, 0.33300015f, -0.58868742f, -0.19679305f, -0.16980775f, -0.17500317f, -0.05884952f, 
    -0.44918159f, 0.22915380f, -0.18268615f, -0.01428631f, 0.02865980f, 0.39878938f, 0.11327755f, 0.22530477f, 
    0.29906094f, -0.10212868f, 0.00241333f, 0.15305869f, 0.12224646f, 0.02100362f, -0.01379271f, -0.38542134f, 
    -0.43934044f, 0.29196826f, 0.06287647f, -0.32430279f, 0.27614358f, 0.00471256f, 0.13334496f, 0.38294774f, 
    0.39810139f, 0.33272344f, 0.05197630f, 0.15671578f, -0.00689136f, -0.34569684f, 0.21031311f, -0.37804317f, 
    0.35077846f, 0.07144658f, -0.02421354f, -0.22465307f, 0.59610903f, -0.19000599f, -0.01494654f, -0.09280623f, 
    -0.12768734f, -0.26889265f, 0.44884309f, -0.23957124f, -0.20909068f, -0.05375635f, 0.17580573f, -0.54515558f, 
    -0.30564710f, 0.36462763f, 0.00796026f, 0.37369433f, 0.38560435f, -0.17664766f, 0.09617302f, 0.14544660f, 
    0.03167614f, 0.33870581f, 0.09853386f, 0.18684426f, 0.16437341f, 0.04370883f, -0.08023552f, 0.15969254f, 
    -0.34107319f, -0.18088317f, 0.35157183f, -0.26754722f, 0.07350624f, 0.10050631f, -0.08737589f, -0.05646122f, 
    -0.14414772f, 0.33937249f, -0.22542940f, -0.04098427f, 0.35314226f, 0.25389928f, 0.08628499f, -0.00480568f, 
    0.01726213f, -0.40290585f, 0.23653950f, 0.20607997f, -0.18164518f, 0.41040564f, 0.05266394f, -0.16935144f, 
    -0.10837761f, 0.06567913f, 0.04417408f, -0.09180943f, -0.42845553f, -0.30112299f, -0.10855045f, 0.29872242f, 
    0.19923674f, -0.00282455f, 0.18097275f, 0.33380032f, 0.42045641f, 0.13411316f, -0.15019904f, 0.09517830f, 
    -0.40846986f, 0.03941224f, -0.04999138f, -0.15653385f, -0.38331956f, 0.11925190f, 0.22800264f, 0.35331362f, 
    0.28455532f, 0.27443972f, 0.09422591f, 0.00998973f, -0.13763016f, 0.08932620f, -0.12448113f, -0.10899945f, 
    -0.11823961f, 0.05226674f, 0.46385810f, -0.04702863f, 0.06963100f, -0.15694079f, 0.17991892f, -0.04609495f, 
    -0.00566703f, 0.09867759f, -0.43040556f, -0.07057370f, 0.29572076f, 0.23862666f, 0.14989673f, 0.19507343f, 
    -0.04803871f, -0.24338992f, 0.37050816f, 0.05464257f, 0.27078077f, -0.12443098f, 0.06702213f, -0.41854551f, 
    -0.11512211f, 0.18759228f, 0.02476049f, 0.26264882f, 0.29007617f, -0.38925049f, -0.14479491f, -0.20397215f, 
    0.05585583f, -0.04586444f, 0.17773159f, -0.25202322f, 0.02741723f, -0.29500178f, 0.18908101f, -0.36847511f, 
    -0.12351183f, 0.25428280f, 0.55222285f, -0.12541614f, 0.64111674f, -0.05992507f, 0.22369455f, -0.63247490f, 
    0.44082755f, 0.20179102f, -0.03900180f, -0.20863782f, -0.02998525f, -0.34938595f, 0.07643421f, -0.61449939f, 
    0.00493943f, 0.26910225f, -0.05480549f, 0.15948357f, -0.34310719f, -0.02466405f, -0.07417665f, 0.21891065f, 
    -0.05033749f, -0.22111292f, 0.21489196f, -0.05672254f, -0.14306138f, -0.02334837f, -0.20304252f, -0.05388650f, 
    0.12047827f, 0.26768091f, -0.26930842f, -0.09338718f, 0.38228184f, 0.01525372f, -0.16740125f, 0.05934744f, 
    -0.18232879f, -0.13701028f, -0.20271273f, -0.09316544f, -0.23013717f, -0.13599032f, -0.00307661f, 0.00944577f, 
    0.50256121f, 0.18747368f, -0.28815627f, 0.20184453f, 0.27842054f, 0.22443976f, 0.13770027f, -0.54810649f, 
    -0.43850395f, 0.05263822f, -0.56620145f, -0.06077854f, 0.45498812f, -0.22741605f, 0.11847707f, 0.32228526f, 
    0.02090389f, -0.32797319f, 0.19430456f, 0.42450464f, 0.07458772f, -0.25259838f, 0.10216731f, -0.17986944f, 
    0.26271120f, 0.10439471f, 0.41083470f, 0.00445762f, -0.37806165f, -0.16195904f, 0.00560437f, 0.02925061f, 
    -0.21488334f, -0.01746726f, -0.16375308f, 0.18021999f, -0.17984208f, 0.14523746f, -0.05144895f, -0.01965770f, 
    -0.30795944f, 0.42024943f, -0.23699199f, -0.42807156f, 0.39203313f, -0.73478001f, -0.19881408f, 0.13239129f, 
    0.40085503f, 0.30405477f, -0.30712277f, -0.26426601f, -0.25196257f, 0.30629915f, 0.09854318f, 0.12872557f, 
    0.06599626f, -0.12859282f, -0.00392327f, -0.16271392f, 0.02304634f, 0.04150760f, -0.11979595f, -0.12424892f, 
    0.08677664f, -0.12470460f, -0.09077886f, -0.23505542f, -0.12416142f, -0.16205198f, -0.01408669f, 0.06736523f, 
    -0.01817405f, -0.19728230f, 0.24638285f, -0.14941446f, -0.17127456f, 0.31325710f, -0.12551221f, -0.41931817f, 
    -0.38715500f, 0.09035483f, 0.01751322f, 0.35467026f, 0.31910515f, -0.18060935f, 0.35191366f, 0.55723500f, 
    0.15652367f, -0.17588785f, -0.09218988f, -0.08942586f, -0.23702055f, -0.22047076f, 0.10735619f, 0.14595026f, 
    -0.02026388f, 0.01990396f, -0.16747969f, -0.12644359f, -0.01158732f, -0.14241475f, -0.23782614f, -0.22550413f, 
    0.35832778f, 0.10737943f, -0.34957185f, -0.29798418f, 0.17071594f, -0.41293418f, -0.20623496f, -0.15218675f, 
    0.20640957f, -0.10118892f, 0.02053430f, -0.13168979f, 0.41996023f, 0.36182469f, 0.03803200f, 0.12505400f, 
    0.38987809f, 0.25613636f, 0.10813747f, -0.02689985f, 0.23394914f, 0.01531649f, -0.18650798f, -0.00010829f, 
    0.12074630f, -0.12626883f, -0.15085119f, -0.42566827f, 0.19564593f, 0.10611858f, 0.14950383f, 0.11310945f, 
    0.32573375f, 0.14411007f, -0.04079792f, 0.03591728f, 0.40472740f, -0.16217361f, -0.20367905f, 0.30672652f, 
    -0.03217815f, -0.37665272f, 0.05469420f, -0.04856447f, 0.75305110f, -0.05549753f, -0.11866374f, 0.16887026f, 
    -0.25509188f, -0.32704812f, -0.06022598f, 0.30104592f, -0.05002313f, 0.23676179f, -0.05253541f, -0.11727945f, 
    0.09083214f, 0.16171706f, -0.01063283f, -0.02868705f, 0.45836720f, 0.29077142f, 0.22401480f, 0.03132274f, 
    -0.38740188f, 0.56595135f, -0.34748423f, -0.01069780f, 0.47184739f, -0.13880017f, -0.16165288f, 0.46971628f, 
    0.05031377f, -0.20989454f, 0.02534517f, -0.36436641f, 0.09682881f, 0.14920273f, -0.15275471f, -0.20009942f, 
    0.17965211f, -0.20203157f, -0.24153963f, -0.15111290f, 0.23904620f, -0.17311499f, 0.17152049f, 0.25893590f, 
    -0.01473252f, 0.21060154f, 0.43384945f, 0.31409076f, 0.14932922f, -0.31141677f, 0.13708645f, -0.66094869f, 
    -0.19458139f, 0.32920182f, 0.12648138f, 0.06660040f, 0.17880416f, 0.35960737f, -0.07784785f, 0.40275246f, 
    -0.19180980f, -0.32428584f, 0.01928541f, 0.32623664f, 0.19724932f, -0.22893113f, 0.22976559f, 0.03119630f, 
    0.21265365f, -0.22958553f, 0.35832700f, -0.47671375f, -0.39930481f, -0.04166013f, 0.01198293f, 0.13347580f, 
    0.25515661f, -0.23698059f, -0.31474012f, 0.40026736f, 0.34103045f, 0.18951584f, -0.08683684f, 0.37410820f, 
    -0.23875348f, -0.08850347f, 0.10969508f, 0.18878062f, 0.04056572f, 0.23333555f, 0.13581380f, -0.04277112f, 
    -0.56620014f, 0.18295839f, 0.34978458f, -0.10831111f, -0.15444061f, 0.28634265f, 0.19039226f, 0.20675252f, 
    -0.29919532f, 0.01777847f, -0.05251114f, 0.16394283f, 0.58437574f, 0.02424286f, 0.23420739f, -0.18000878f, 
    -0.08898719f, 0.21551546f, -0.31626800f, -0.38406914f, 0.03065298f, 0.05719917f, -0.11481468f, 0.55739629f, 
    0.18036774f, 0.42787898f, 0.24931173f, 0.14767578f, 0.22655381f, -0.33547029f, 0.07885001f, -0.30259502f, 
    0.24503201f, 0.04746260f, -0.17572601f, -0.22074959f, -0.06972942f, -0.29977390f, -0.14115018f, -0.14609893f, 
    -0.17452651f, 0.33257291f, 0.07074975f, -0.08812826f, 0.13362700f, 0.13762990f, -0.19748807f, -0.06999687f, 
    0.07484696f, 0.19024873f, -0.06782804f, -0.29626581f, -0.21875228f, 0.14407296f, -0.10137821f, -0.30953145f, 
    -0.38781646f, 0.01614947f, 0.03608834f, -0.03508073f, 0.02046896f, -0.01544975f, -0.10204283f, 0.10297733f, 
    -0.27473193f, -0.03147818f, 0.47564122f, 0.34856689f, 0.23043239f, 0.31350964f, 0.04078149f, -0.85474610f, 
    0.04645748f, 0.16402575f, 0.14314638f, -0.05833320f, -0.44345713f, 0.21895596f, 0.16034184f, -0.28832820f, 
    0.11801907f, -0.00640381f, -0.00006323f, 0.27447298f, -0.00871217f, -0.25015786f, 0.18287344f, 0.14188749f, 
    0.44905654f, -0.13698182f, -0.09681252f, -1.31316376f, -0.16019778f, -0.37297311f, 0.10921608f, -0.30402458f, 
    -0.01326564f, -0.07715013f, 0.29098827f, 0.26366171f, 0.62473530f, 0.15145350f, -0.21834290f, -0.10167664f, 
    -0.00503844f, -0.13087676f, -0.13519911f, -0.38953948f, -0.08515346f, -0.32884753f, -0.14970963f, 0.29220003f, 
    0.36333966f, 0.10773721f, 0.27479446f, 0.01057408f, 0.41120863f, 0.20480348f, -0.12070218f, -0.56576306f, 
    -0.11435472f, -0.02935512f, -0.12115896f, -0.09501834f, -0.16948286f, 0.17893414f, -0.05680227f, -0.12672058f, 
    -0.16148925f, -0.05768369f, -0.17837511f, -0.02223463f, -0.14926974f, -0.27330816f, 0.09427217f, 0.17064548f, 
    0.10183968f, 0.39104089f, -0.30119714f, -0.17152588f, -0.44576699f, 0.30633438f, 0.19700766f, -0.43794674f, 
    0.04853025f, -0.07441155f, 0.49734011f, 0.02386586f, -0.07053211f, 0.35096505f, 0.07436867f, -0.56310916f, 
    0.10307569f, -0.02291127f, -0.27597752f, 0.20257510f, 0.24400826f, -0.07095030f, -0.26047799f, -0.63545996f, 
    0.18847166f, 0.16958107f, -0.22433402f, -0.33915192f, 0.05861775f, 0.14827350f, 0.01685593f, 0.62477398f, 
    -0.18121511f, 0.03886865f, -0.28654063f, -0.33040777f, 0.26331255f, -0.07780737f, 0.14999260f, 0.09008351f, 
    0.51289004f, 0.30741951f, 0.07140891f, 0.11138562f, -0.65500438f, 0.04881500f, -0.16096219f, 0.01677310f, 
    0.17201275f, 0.15956786f, -0.12928969f, 0.30190352f, 0.16726913f, 0.28472853f, 0.06306176f, 0.17140372f, 
    0.15192066f, -0.12361011f, 0.14300787f, -0.14409690f, 0.46061867f, -0.27925572f, 0.03299899f, -0.20280093f, 
    -0.34635049f, -0.32451585f, 0.29983512f, -0.17531879f, -0.10291683f, 0.18747306f, 0.21702257f, -0.03378310f, 
    0.00796841f, 0.32675147f, 0.29881594f, 0.30671802f, -0.12511377f, 0.03201335f, 0.00668067f, 0.03353411f, 
    -0.12657818f, 0.05955401f, -0.06365081f, -0.14558490f, 0.33964378f, 0.42760250f, 0.04210331f, -0.41814274f, 
    -0.03343279f, 0.03310653f, 0.07038236f, 0.34708759f, -0.05484446f, -0.21281166f, 0.09201942f, 0.36061630f, 
    -0.03836527f, 0.15321338f, -0.01858975f, -0.00950740f, -0.00293031f, -0.17100441f, -0.00051949f, 0.05606843f, 
    0.05695756f, 0.04226460f, -0.39749116f, 0.03706414f, -0.05480446f, 0.04655553f, -0.04050205f, 0.01579246f, 
    -0.09667979f, -0.20347008f, 0.13381447f, -0.61306381f, -0.01624166f, 0.15607826f, -0.06266270f, -0.61923712f, 
    -0.02583724f, 0.44329205f, 0.18538870f, 0.21584545f, -0.21103606f, 0.14890063f, 0.14780609f, 0.26477784f, 
    0.10634452f, 0.09159954f, -0.16457783f, 0.00939101f, 0.07619333f, -0.22014096f, -0.13401628f, -0.10878331f, 
    -0.24992703f, -0.22107065f, -0.02562511f, 0.10178783f, -0.08153102f, -0.13741940f, -0.14888567f, 0.16737330f, 
    0.15732960f, -0.01101888f, -0.05899506f, -0.10285646f, 0.12781230f, -0.05169052f, -0.15814535f, -0.15025114f, 
    0.14574407f, -0.28083637f, 0.14411083f, -0.21588124f, -0.10069499f, -0.12583397f, 0.06346929f, -0.00215772f, 
    -0.18864724f, -0.20054007f, 0.00605264f, -0.24669161f, 0.06730700f, -0.19899121f, -0.11983928f, 0.09930286f, 
    -0.19535229f, -0.13053742f, -0.00440258f, -0.21475402f, -0.21188888f, 0.13112408f, -0.14567384f, 0.14687383f, 
    0.33384511f, 0.57531452f, -0.56405824f, -0.48805526f, 0.47882402f, -0.41812330f, 0.23618700f, -0.09857345f, 
    0.21088025f, -0.15532348f, 0.18286337f, -0.27906758f, -0.14629702f, 0.17797628f, -0.21663509f, -0.02053363f, 
    0.26764572f, -0.10231584f, 0.14251456f, 0.24252476f, -0.23869780f, 0.39948425f, 0.09474353f, -0.26970500f, 
    -0.48739848f, -0.18695210f, 0.21089937f, 0.34033889f, 0.10657179f, -0.06265961f, -0.14475746f, 0.31146735f, 
    -0.64796793f, 0.45458943f, -0.07408883f, -0.07712905f, 0.60840613f, -0.14041567f, 0.00462749f, 0.56532359f, 
    -0.04009810f, 0.06077134f, -0.28048044f, 0.13030399f, 0.12263130f, -0.16889575f, -0.21652289f, 0.29490292f, 
    0.04537295f, -0.15032834f, -0.18235119f, 0.21989042f, 0.24833280f, 0.39534527f, -0.19339556f, -0.00650183f, 
    0.27929881f, -0.20255758f, -0.32160756f, -0.87529576f, -0.68478084f, -0.39638391f, -0.00906844f, 0.20847026f, 
    0.23391797f, -0.21130624f, 0.29118571f, -0.45498925f, -0.10036080f, -0.16159040f, 0.08921178f, -0.79747403f, 
    -0.22669049f, 0.20340949f, 0.08493058f, 0.25807661f, 0.20847233f, 0.18896325f, 0.06747980f, 0.73984945f, 
    0.06631480f, 0.30190912f, -0.21243647f, 0.06092408f, 0.25823495f, 0.27612624f, -0.24570285f, 0.19412780f, 
    0.20073646f, -0.29912153f, -0.10216499f, -0.08844595f, 0.08688138f, 0.10448229f, 0.11431463f, -0.21024042f, 
    -0.42783564f, -0.04344542f, -0.03714246f, -0.05393683f, 0.28028569f, -0.48274872f, 0.07688294f, 0.44260511f, 
    0.03809562f, 0.38514468f, 0.32174641f, -0.14022772f, 0.59242195f, 0.16324246f, 0.15702257f, -0.34244820f, 
    -0.01739259f, -0.00640535f, 0.30347589f, 0.06962988f, -0.11103254f, -0.27894861f, 0.18940276f, -0.00334275f, 
    0.12874271f, -0.02486202f, 0.18757755f, -0.09993047f, 0.07901760f, -0.02477673f, -0.12261586f, -0.19324394f, 
    -0.39654756f, -0.14858004f, -0.03533502f, -0.21026725f, -0.18224406f, 0.05603058f, -0.21266437f, -0.04244541f, 
    -0.02911511f, 0.34062573f, 0.31705514f, 0.44181713f, -0.17910311f, 0.32666668f, -0.10989027f, -0.06877332f, 
    -0.13955778f, 0.15774988f, -0.24319187f, -0.68821466f, -0.12474436f, -0.57712579f, 0.08989154f, -0.24799131f, 
    0.36566448f, -0.05871196f, 0.08494487f, -0.11986638f, 0.48617896f, 0.39764836f, 0.16275325f, 0.36423308f, 
    -0.27893221f, 0.15884212f, -0.35278943f, -0.12902616f, 0.16903023f, 0.07392093f, 0.17160888f, 0.32963702f, 
    0.34834781f, 0.22264300f, -0.22840598f, -0.21916440f, -0.19977318f, 0.32972908f, -0.02013377f, 0.00753540f, 
    0.03969754f, -0.04574440f, 0.08642489f, -0.36480349f, -0.36228085f, 0.07455052f, 0.18695384f, 0.04197368f, 
    0.26955143f, -0.20953389f, -0.33504185f, 0.42121184f, 0.18211286f, 0.09417041f, 0.01840100f, 0.50983614f, 
    -0.01546723f, -0.26213297f, 0.20364058f, 0.17448893f, 0.42864832f, -0.08174818f, 0.13353762f, 0.17650928f, 
    0.22826076f, -0.14022569f, -0.12594226f, -0.05640068f, 0.33380729f, 0.00862951f, -0.21421269f, -0.26995164f, 
    0.44037351f, 0.11151281f, -0.02397481f, -0.36651805f, -0.15979843f, 0.15778065f, 0.16251507f, 0.13328966f, 
    0.43591842f, -0.09630203f, 0.28791624f, -0.05066961f, -0.08723705f, -0.00939495f, -0.16835101f, -0.44494998f, 
    -0.12587193f, -0.08914063f, -0.04131487f, 0.14093991f, 0.37344927f, 0.14434935f, -0.06727628f, -0.12074863f, 
    0.14004175f, -0.16780172f, -0.31914857f, 0.16397651f, -0.22059260f, 0.17792790f, 0.02886774f, 0.25816503f, 
    0.40980434f, 0.10935017f, -0.02061300f, -0.12142088f, -0.20466524f, 0.23033445f, -0.18268523f, -0.32161942f, 
    -0.17785209f, -0.06507335f, 0.44387099f, 0.22853826f, -0.09067547f, -0.13136590f, 0.00116720f, -0.13726151f, 
    -0.46374699f, -0.18321140f, 0.36039519f, -0.09592228f, 0.13120063f, -0.05499708f, 0.23400907f, -0.03252988f, 
    -0.26401544f, 0.19419505f, -0.00670730f, 0.32384378f, 0.70140457f, 0.12498301f, 0.00490940f, -0.00692718f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.36597928f, -0.33204159f, 0.35806340f, -0.05398211f, 0.51678705f, 0.46211097f, 0.13473250f, 0.18991391f, 
    -0.18419708f, 0.09278782f, -0.10014996f, 0.24097814f, 0.08313111f, -0.23673271f, 0.04161092f, 0.53348845f, 
    -0.03102969f, 0.13368987f, -0.26201025f, -0.11071116f, 0.32379705f, 0.24201778f, -0.27574512f, 0.21619894f, 
    -0.32178581f, 0.12861882f, 0.44016406f, 0.32695267f, 0.37621284f, 0.06943034f, 0.25420687f, 0.30777454f, 
    -0.19974858f, -0.29319441f, -0.48711288f, -0.25364718f, -0.05900278f, -0.28276697f, 0.15683438f, 0.37514630f, 
    0.29885697f, -0.24995793f, 0.05391819f, -0.07855120f, 0.35441339f, 0.24904566f, 0.45767844f, -0.04860678f, 
    0.20226030f, -0.19334872f, 0.17060524f, 0.02302204f, 0.02712592f, -0.10903102f, 0.18900128f, 0.00339904f, 
    0.04774299f, 0.05418440f, 0.31755289f, 0.34899321f, 0.09924196f, -0.36174121f, -0.06844493f, 0.00322842f, 
    -0.11968229f, 0.05646204f, 0.18201512f, 0.46276167f, 0.13529292f, -0.41190490f, 0.14288120f, -0.03947472f, 
    0.04689533f, 0.51282477f, -0.06485989f, 0.50948220f, -0.26112437f, -0.44471702f, -0.12237126f, 0.44119030f, 
    0.02982324f, 0.31245342f, -0.01842427f, 0.00212527f, 0.30125940f, 0.02859078f, -0.28137326f, 0.04008952f, 
    -0.13743331f, -0.03569229f, 0.29678026f, 0.08140182f, -0.03490363f, 0.21044245f, 0.10218392f, -0.19826946f, 
    0.34057644f, 0.53343076f, 0.52808589f, -0.02734059f, 0.27914235f, -0.21245089f, -0.03522049f, 0.28553772f, 
    0.03891066f, -0.16685493f, 0.15005063f, 0.29445142f, -0.04239767f, -0.24133578f, -0.22050297f, 0.39570212f, 
    0.29178745f, 0.15691708f, 0.48222804f, 0.41475394f, 0.24776499f, 0.33685258f, 0.21095432f, 0.23254652f, 
    0.35249776f, -0.25952685f, 0.30023652f, 0.04005203f, 0.51329452f, -0.06285135f, 0.13155894f, -0.24218339f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.27673668f, 0.72240627f, -0.05262060f, -0.10880734f, -0.48223940f, -0.07161958f, -0.06576566f, -0.18123810f, 
    -0.10753549f, -0.39029762f, 0.06523424f, -0.15246002f, -0.14696975f, 0.20521785f, 0.10505956f, -0.80754262f, 
    -0.10273083f, -0.04533551f, -0.22884814f, 0.06319048f, -0.48237395f, 0.00311305f, -0.36927310f, 0.35530528f, 
    -0.08828480f, 0.07237265f, 0.23340148f, -0.51029998f, -0.75167352f, -0.40060619f, 0.05234189f, -0.28688538f, 
    -0.00237618f, -0.34072840f, 0.14360559f, 0.17432936f, 0.13607697f, 0.05535008f, -0.05460127f, 0.16805807f, 
    -0.19577911f, -0.21871774f, -0.01128000f, 0.04225781f, -0.52033639f, 0.49058270f, -0.50472409f, 0.19187990f, 
    0.11861232f, 0.08568256f, 0.03931219f, 0.06511366f, 0.36073166f, -0.38737863f, -0.12867036f, -0.04455804f, 
    0.23192911f, 0.31042600f, -0.54591358f, -1.17481506f, 0.16333552f, 0.17894655f, 0.70579344f, -0.54780340f, 
    -0.16798139f, -0.06689464f, 0.08528695f, -0.04919469f, 0.03244453f, 0.07472704f, -0.08213899f, -0.59367752f, 
    0.28296012f, 0.09403361f, 0.08866998f, -0.42354989f, -0.08798895f, 0.35649744f, -0.08436816f, -0.44083157f, 
    0.07998403f, 0.19180334f, -0.05160270f, -0.16871245f, -0.26257226f, 0.01471689f, -0.08113010f, -0.22546934f, 
    0.28366873f, 0.20452838f, -0.01073313f, -0.07883696f, 0.02838460f, -0.02713520f, -0.06438833f, 0.05335913f, 
    -0.00322979f, 0.08353392f, 0.02712551f, -0.04878271f, 0.05668846f, -1.10705245f, 0.11968291f, 0.17826825f, 
    0.00666774f, 0.46378687f, -0.13535859f, -0.07762964f, -0.06300467f, 0.03332423f, 0.06956808f, -0.17625639f, 
    0.11307649f, -0.01875302f, -0.39164913f, -0.10034312f, 0.07568397f, -0.02132961f, -0.01193594f, 0.07153152f, 
    -0.11064761f, -0.23759942f, -0.09459686f, 0.00549990f, 0.05315902f, 0.12692374f, 0.21865867f, 0.09253212f, 
    -0.09346423f, -1.45408535f, 0.05598275f, 0.05056249f, -0.07407331f, -0.08877706f, 0.01135705f, 0.07360488f, 
    -0.13770767f, -0.04723430f, -0.00027932f, 0.21383508f, 0.03448195f, 0.05542221f, 0.31730813f, -0.16949269f, 
    0.03053072f, -0.19836913f, 0.07966816f, 0.04194589f, 0.67987049f, 0.04759838f, -0.24812523f, -0.64201283f, 
    0.10960785f, 0.04442989f, 0.02505387f, -0.02243388f, -0.08917308f, -0.26662156f, -0.15975685f, -0.21218777f, 
    -0.03282124f, 0.11023598f, -0.60929888f, -0.43718430f, 0.03164389f, 0.05879607f, -0.06750067f, 0.12913714f, 
    0.27550051f, -0.12465283f, 0.19193800f, 0.24339199f, 0.02052127f, -0.13352455f, -0.13670647f, -0.56514698f, 
    -0.09101698f, -0.00522605f, -0.00904778f, 0.06234683f, 0.52410018f, -0.72971702f, -0.12036557f, -0.06744003f, 
    0.34584764f, -0.17325801f, -0.30706310f, 0.37933019f, 0.46606916f, 0.18111086f, 0.00945865f, 0.03443840f, 
    -0.03852672f, -0.04046287f, 0.39686099f, -0.07930114f, -0.13550423f, 0.04781864f, 0.07646520f, -0.09988735f, 
    0.10778611f, 0.31440431f, -0.08178354f, 0.05162092f, 0.28876361f, -1.55243289f, -0.21585038f, -0.83764738f, 
    -0.04215501f, 0.56227541f, -0.01679297f, -0.07928890f, -0.10003868f, -0.03257380f, 0.12026624f, -1.00709343f, 
    0.22670242f, -0.15366745f, 0.21036009f, 0.02273101f, 0.29804584f, -0.28572395f, -0.22307602f, 0.18770625f, 
    0.06372792f, 0.19024108f, 0.09783675f, -0.06133970f, 0.29292521f, 0.21806137f, -0.70985371f, 0.03328642f, 
    0.10985335f, 0.01814447f, -0.10374120f, 0.19784801f, -0.06592804f, -0.10295247f, -0.01015185f, -0.50738430f, 
    0.18379067f, -0.58526051f, 0.34273612f, 0.33646765f, -0.02977701f, 0.02063463f, 0.02818946f, 0.06593852f, 
    -0.13862480f, -0.19889738f, 0.21559153f, -0.06974430f, 0.00435771f, 0.14573881f, 0.05857705f, 0.11873338f, 
    0.06140205f, -0.12051621f, -0.02220975f, -0.09557965f, 0.38211921f, 0.13896826f, -0.20180361f, 0.23825759f, 
    -0.55179763f, -0.06387083f, 0.06335425f, -0.61566436f, -0.04273322f, -0.18955678f, -0.87883538f, 0.15608631f, 
    0.04372215f, 0.17524801f, -0.30242732f, 0.01878608f, 0.46862778f, 0.05860275f, -0.26576933f, 0.09173710f, 
    -0.08620390f, -0.02001043f, 0.07415544f, 0.15162860f, 0.05931165f, -0.04066234f, 0.14664581f, -0.07056100f, 
    -0.17412543f, -0.74636519f, -0.61732894f, -1.57638848f, 0.03224665f, 0.14425600f, 0.14017873f, 0.18822390f, 
    -0.10626097f, -0.30058542f, -0.34221211f, -0.76147574f, 0.00879348f, 0.29184583f, 0.16395345f, -0.20948172f, 
    0.00570631f, -0.05975587f, 0.05663791f, -0.09999111f, -0.03420117f, -0.32486409f, -0.04761055f, 0.08596548f, 
    -0.55332410f, -0.15523706f, -0.07478216f, -0.84067625f, -0.25568920f, -0.02451251f, -0.15466814f, 0.19189490f, 
    -0.00962582f, 0.05522162f, -0.64398903f, 0.16385785f, 0.22545379f, -0.16011997f, -0.03779889f, -0.16507842f, 
    -0.49314204f, 0.04165129f, -0.01021043f, -0.10287294f, -0.25220454f, -0.91948450f, 0.06173344f, 0.26589948f, 
    0.04980491f, -0.42121482f, -0.06860798f, 0.35317591f, 0.06441740f, -0.20015864f, -0.12192830f, -0.09479044f, 
    -0.20386542f, -0.31692341f, 0.22968484f, 0.13298410f, -0.67754537f, -0.06583753f, 0.06598771f, -0.68710476f, 
    0.06187049f, 0.80993158f, 0.17072940f, -0.06086905f, 0.40828368f, -0.86227155f, 0.02886669f, 0.07008007f, 
    -0.04521807f, 0.01396122f, -0.02423890f, 0.35359913f, 0.02699336f, -0.16155235f, -0.00220209f, 0.35296291f, 
    0.18610653f, -0.46617931f, -0.34286752f, 0.26905438f, -0.01236181f, -0.34937182f, 0.01935194f, 0.05486229f, 
    0.56348437f, -0.07129919f, 0.30823115f, -0.10462387f, 0.28384727f, -0.02581612f, 0.16967297f, -0.68540752f, 
    0.02225827f, 0.02604645f, 0.24215424f, 0.12923265f, 0.19070916f, 0.05765345f, 0.10801831f, -0.55903697f, 
    0.15282412f, -0.38799742f, 0.02019116f, -0.55267930f, -0.47627160f, 0.12675162f, -0.04990783f, -0.44012260f, 
    -0.31315300f, 0.23596090f, -1.39350295f, 0.01272544f, 0.11858696f, 0.21561515f, -0.12133705f, -0.16764188f, 
    -0.16462065f, 0.04915363f, 0.11932579f, -0.25787932f, 0.21611607f, -0.26368946f, 0.19914675f, -0.07759881f, 
    -0.01576102f, -0.22930746f, -0.07312622f, 0.02140157f, 0.23935045f, 0.40040630f, 0.09670230f, 0.15763870f, 
    -0.44814143f, 0.03467103f, -0.21428964f, -0.71160257f, 0.20251529f, 0.07870807f, -0.00202394f, -0.46142426f, 
    0.13988158f, 0.01832627f, 0.00007995f, -0.58689654f, -0.30432639f, 0.85240895f, 0.12283801f, -0.04706647f, 
    -0.15973192f, 0.25613049f, 0.14152436f, -0.53243726f, -0.17392136f, -0.25217158f, -0.81584805f, 0.02237250f, 
    -0.56774336f, -0.22838885f, -0.11720116f, 0.26663572f, 0.12927336f, -0.05670224f, 0.08866156f, -0.11391971f, 
    -0.22905427f, 0.13130808f, -0.08275288f, -0.43900040f, -0.41394997f, -0.19587240f, 0.36061308f, 0.20261163f, 
    -0.00693142f, -0.02604698f, 0.06630753f, -0.08221968f, -0.18100263f, -0.24517800f, 0.01385163f, 0.22996165f, 
    -0.08771943f, -0.04945502f, -1.00363970f, 0.35812080f, -0.17050786f, -0.05131300f, 0.09154875f, 0.13068511f, 
    0.01848968f, -0.15069287f, 0.00504559f, 0.06727134f, 0.31471902f, -0.28763884f, -0.05353796f, -0.14185590f, 
    0.14909786f, -0.03187051f, -0.21903461f, -0.05279730f, 0.07513297f, 0.00232180f, -0.04867041f, 0.35093778f, 
    0.29010743f, 0.05810294f, -0.74757856f, -0.19193573f, -0.08391539f, 0.11835723f, -0.05622231f, 0.16656148f, 
    -0.06903523f, -0.01954468f, -0.94886243f, -0.49028903f, -0.29023072f, -0.47764936f, 0.07060717f, 0.09961602f, 
    0.10936651f, -0.89820307f, 0.10902195f, -0.07676440f, -0.27558482f, 0.03673460f, 0.19275090f, -0.02458062f, 
    0.22071660f, -0.14959992f, -0.05078654f, 0.24356697f, -0.05770899f, -0.06533385f, -0.02178409f, 0.02602606f, 
    -0.14231564f, -0.52827132f, 0.21660820f, 0.02013772f, -0.18076968f, 0.11770411f, -0.27532905f, -0.29965347f, 
    0.08152171f, -0.02612347f, -0.07060711f, -0.15531474f, -0.30415171f, -0.05921555f, -0.19073340f, -0.27083644f, 
    0.10286092f, -0.03699759f, 0.28930026f, 0.05372696f, -0.07126688f, -0.08257604f, -0.40376845f, -0.81370085f, 
    -0.24319987f, 0.03864677f, -0.13436007f, -0.18599178f, -0.18885660f, -0.51887107f, -0.05881581f, 0.21098484f, 
    0.09950471f, 0.06202045f, 0.05141160f, 0.04721503f, 0.07634450f, -0.31857723f, 0.12068114f, -0.08019233f, 
    0.06096698f, -0.12492384f, -0.40692967f, -0.47502169f, 0.12557703f, 0.08950353f, -0.13014406f, -0.01108740f, 
    0.20728351f, -0.09512971f, -0.57695234f, 0.06826692f, 0.19215316f, 0.09147724f, -0.02528046f, 0.10211099f, 
    -0.66239834f, -0.05857816f, -0.39024383f, -0.25868094f, 0.24460557f, 0.07299775f, 0.07832509f, 0.12305395f, 
    0.05416860f, -0.86748308f, -0.05324059f, 0.07586330f, -0.03210307f, 0.10390321f, 0.10422491f, 0.31109813f, 
    -0.05068539f, 0.11090495f, -0.09888413f, 0.03511978f, -0.04131595f, -0.16105857f, -0.18499617f, 0.12087388f, 
    -0.27868313f, 0.02650306f, 0.16433863f, 0.01134069f, 0.04554870f, -0.59423333f, 0.00268225f, 0.08779747f, 
    -0.19548996f, -0.30457407f, -0.00585653f, -0.78509903f, 0.01559209f, 0.04324751f, -0.04190213f, 0.01568947f, 
    -0.16246983f, 0.23977581f, -0.41667780f, -0.58817816f, 0.22078781f, 0.14636727f, -0.02523545f, 0.08700597f, 
    0.00883116f, 0.17389545f, -0.06932335f, 0.08807749f, -0.12325943f, 0.03661755f, -0.13473238f, 0.08645749f, 
    0.10699639f, 0.33866578f, -0.14725125f, -0.04659806f, 0.16657068f, -0.05882500f, -0.01906971f, -0.21021760f, 
    -0.07232362f, 0.04628052f, -0.01144372f, 0.12580445f, -0.01244113f, 0.00600237f, 0.10235690f, 0.23521224f, 
    -0.00514902f, -0.29007199f, 0.08445532f, -0.04316076f, -0.17923245f, 0.03701704f, -0.58221942f, -0.10337754f, 
    0.17806505f, 0.01428408f, 0.06997948f, 0.10688543f, 0.04563326f, 0.32467297f, -0.12591125f, -0.08838688f, 
    -0.09293305f, 0.20730120f, 0.07621954f, -0.25477993f, -0.30426520f, -0.26467857f, -0.08612362f, 0.02314147f, 
    0.10460139f, -0.09968301f, 0.23016801f, 0.66117150f, 0.09774514f, -0.43255043f, -0.34270138f, 0.09520370f, 
    0.01359238f, 0.05039738f, 0.03248963f, 0.00530524f, -0.39158514f, -0.60269940f, -0.06898686f, 0.07775476f, 
    0.06191212f, -0.38046348f, 0.32204220f, -0.15810405f, -0.24099451f, 0.03945045f, -0.30515164f, 0.04701298f, 
    0.03026993f, 0.14995430f, 0.17616175f, 0.02389135f, -0.25702310f, 0.11967607f, -0.13730733f, 0.24421076f, 
    0.30032927f, 0.26823854f, -0.07454136f, 0.12783690f, 0.03473950f, -0.06368002f, -0.15032390f, -0.06153068f, 
    0.07716973f, 0.11166492f, 0.07253680f, 0.01813121f, -0.01030285f, 0.16666247f, 0.11114816f, -0.29699343f, 
    -0.03127777f, -0.14893562f, 0.28792667f, -0.07820246f, -0.05906003f, 0.12983561f, -0.05043989f, -0.11500022f, 
    -0.07064739f, 0.26701894f, 0.12136283f, -0.06610879f, -0.51259029f, -0.10842930f, -0.51201403f, 0.07295406f, 
    -0.00902337f, -0.11308572f, -0.08257642f, 0.03847812f, -0.04903984f, -0.04314622f, -0.03984378f, -0.68399477f, 
    -0.09999213f, -0.09229262f, -1.55955517f, 0.22586092f, -0.15724029f, 0.21152255f, 0.06029747f, -0.10048609f, 
    0.14331360f, -0.20510805f, 0.18897873f, 0.24064261f, -0.11906597f, -0.09534506f, -0.03855622f, 0.19322504f, 
    0.02372214f, -0.06595303f, -1.35800552f, -0.31986415f, -0.57194728f, 0.14677079f, -0.36668417f, -0.30350274f, 
    -0.57040131f, 0.11368524f, 0.02967388f, -0.20898628f, 0.04055997f, -0.59437710f, -0.31440717f, 0.21495703f, 
    0.21861653f, 0.32462394f, 0.30796307f, 0.06167325f, 0.02439852f, -0.27048525f, 0.61808705f, 0.21164839f, 
    -0.18112865f, -0.14326246f, -0.31622174f, 0.28141174f, 0.17699870f, -1.07923436f, 0.10004906f, 0.13475288f, 
    -0.35448685f, 0.03632765f, -0.48734915f, -1.27404749f, -0.18033184f, -0.27538887f, 0.23522034f, -0.51013947f, 
    -0.18970849f, -0.40168133f, -0.36529171f, 0.25051615f, -0.49961355f, 0.43895313f, 0.01349574f, -0.17034033f, 
    -0.36181623f, 0.02934047f, -0.02086219f, 0.17576347f, 0.11957700f, -0.26467171f, 0.16280740f, -0.04208717f, 
    -0.56504554f, 0.22640833f, -0.70688468f, 0.17065273f, -0.09748883f, -0.22223851f, -0.49989322f, -0.02755066f, 
    0.02325947f, 0.27396229f, -0.29732907f, 0.02519333f, 0.04241019f, -0.32466823f, -0.55737174f, -0.04714852f, 
    0.01425318f, -0.91282612f, 0.30012125f, -0.12850808f, 0.10562311f, -0.06119331f, 0.00153493f, -0.13045000f, 
    0.01602888f, -0.60758907f, -0.02017240f, 0.25880498f, 0.19690116f, 0.08549320f, -0.41945124f, -0.19863625f, 
    -0.56661469f, -0.27980855f, -0.13306922f, -0.17813782f, -0.37388778f, 0.27033481f, 0.03422522f, -0.26845121f, 
    0.10309299f, -0.20518915f, -0.81137246f, -0.10486906f, 0.32439467f, 0.06980819f, -0.01554308f, 0.11125672f, 
    -0.27302408f, -0.17471728f, 0.01457988f, -0.05842108f, 0.01136192f, -0.11844848f, 0.00787589f, 0.39360070f, 
    -0.10481393f, -0.77148187f, -0.09080493f, -0.24128163f, 0.19138689f, -1.71169937f, 0.01881207f, -0.43784708f, 
    -0.71248859f, 0.01363145f, -0.11730360f, -0.02582694f, 0.40322506f, -0.04223427f, 0.23288025f, -0.59045196f, 
    -0.38983899f, -0.10454731f, -0.58390546f, 0.11119875f, -0.55941510f, -0.47144070f, 0.09564953f, -0.07521388f, 
    0.21438514f, -0.14341639f, 0.02615995f, 0.14683424f, 0.03859085f, 0.09474090f, -0.19262232f, -1.16020310f, 
    0.06075764f, -0.45963266f, -0.03278787f, -0.07977272f, -0.23411642f, 0.04525542f, 0.23464611f, -0.24016120f, 
    0.03572354f, 0.10066773f, -0.01682034f, -0.17661054f, 0.12226274f, -0.41957235f, 0.10456494f, -0.01268599f, 
    -0.00217670f, -0.06989700f, 0.36442333f, 0.67502069f, 0.41379100f, 0.05047712f, -0.01590620f, 0.07241035f, 
    -0.23478095f, 0.08950791f, 0.10595513f, 0.05834682f, 0.10461579f, -0.31570169f, -0.11742093f, -0.20389059f, 
    0.01036874f, 0.02554129f, -0.02838532f, -0.03672699f, -0.53845882f, 0.99556369f, -0.04076815f, -0.07755687f, 
    0.12566867f, 0.05841599f, -0.44617268f, -0.19497126f, -0.22845371f, 0.07369668f, -0.01356422f, -0.08893639f, 
    0.14697950f, -0.04066234f, 0.24281517f, 0.03531578f, 0.36337745f, -0.56952024f, -0.25159585f, 0.18638992f, 
    0.05077527f, -0.43352225f, -0.34221256f, 0.19862486f, -0.70054328f, -0.63656408f, 0.16521330f, -0.20410872f, 
    -0.06184851f, -0.03515070f, -0.02571880f, -0.19828406f, 0.02471721f, -0.03988391f, 0.10129444f, 0.49521267f, 
    -0.73981637f, -0.07503396f, 0.32945648f, 0.11252165f, 0.03016320f, -0.09142500f, 0.14721175f, -0.65091527f, 
    -0.02076527f, -0.24624997f, -0.71946150f, -0.08481699f, -0.19696398f, -0.19989589f, -0.40986747f, 0.04058030f, 
    0.03862137f, 0.11026060f, 0.01404562f, -0.36547250f, 0.07929903f, -0.02299171f, -0.00366220f, -0.05343297f, 
    0.06054487f, 0.32468015f, -0.71104878f, -1.01093125f, 0.05571069f, -0.46937615f, -0.02222381f, -0.11933015f, 
    -1.09916639f, 0.14263280f, -0.23885922f, 0.08757263f, -0.45049915f, 0.14230782f, -0.08457405f, -0.01465195f, 
    0.12831795f, -0.13183394f, -0.49931008f, 0.11168426f, 0.36691588f, -0.20564105f, -0.32432276f, -0.03808247f, 
    -0.28905639f, 0.13795237f, 0.08729973f, -0.18028003f, -0.01329766f, 0.02331404f, -0.42985934f, 0.34776440f, 
    -0.11710159f, -0.26757389f, -0.24065085f, 0.07175522f, 0.20459555f, -0.35143644f, 0.25706747f, 0.15289409f, 
    -0.09078199f, -0.09595145f, 0.30904841f, 0.18482621f, -0.07907370f, 0.13553780f, 0.07412168f, 0.14917912f, 
    0.02089792f, -0.64428103f, -0.03699160f, -0.28699890f, 0.34416416f, -0.13505299f, -0.17612535f, 0.24067473f, 
    -0.28504622f, -0.10584965f, 0.19285206f, -0.53112650f, 0.22595760f, 0.15358132f, -0.04160037f, 0.93437362f, 
    -0.85120296f, 0.05309414f, -0.02954401f, -0.04180229f, -0.27637345f, -0.05274630f, -0.04239015f, 0.08625943f, 
    0.01234311f, -0.02420382f, 0.68105471f, 0.05738825f, -0.63811016f, -0.32153895f, 0.13607340f, 0.48450223f, 
    0.03290501f, -0.09237160f, 0.31727889f, -0.11788797f, -0.20865272f, 0.00208634f, -0.10588426f, 0.23244883f, 
    0.14230227f, -0.77975744f, 0.20058806f, 0.04332091f, -0.61704034f, -0.67124826f, 0.17172079f, -0.38378394f, 
    0.00738149f, 0.41095996f, -0.07985272f, -0.80457145f, -0.06539842f, -0.12114000f, -0.31489471f, -0.20139346f, 
    -0.96301627f, 0.07258848f, 0.30118173f, -0.02937444f, -0.00252130f, 0.10817500f, -0.03001942f, -0.36161909f, 
    0.12402827f, -0.71363407f, -0.82079250f, 0.04667620f, -0.41443378f, -0.18326084f, -0.22752704f, -0.26917818f, 
    0.15444951f, 0.24381334f, 0.03564307f, 0.02481759f, -0.00611555f, 0.02332090f, 0.00210690f, -0.26002464f, 
    0.06098696f, 0.24359252f, 0.76387757f, 0.27915287f, -0.38473865f, -0.35970372f, 0.13549781f, 0.08370344f, 
    -0.89920425f, -0.25895831f, 0.22607814f, -0.03390904f, -0.10328715f, -0.06720114f, -0.01886446f, 0.29038557f, 
    0.21877918f, -0.15299071f, -0.16264021f, -0.63331908f, -0.94568712f, 0.26966634f, 0.33269939f, -0.05521959f, 
    -0.35492176f, 0.10568057f, -0.04256199f, 0.13515468f, 0.09751078f, -0.51637739f, 0.04980672f, 0.13581088f, 
    -0.03761611f, 0.06047691f, -0.17654265f, 0.06849778f, -0.66055757f, -0.09542679f, -0.50896877f, 0.17554046f, 
    -0.32619956f, -0.13101630f, 0.15151818f, 0.17326336f, 0.08563518f, -0.11956881f, 0.12012364f, 0.13619703f, 
    0.18062770f, -0.38989589f, -0.24617392f, -0.47740716f, -0.71679586f, -0.56287587f, 0.11202569f, -0.80610913f, 
    0.14692721f, -0.34186712f, -0.28054905f, -0.55814701f, -0.48255843f, 0.01075584f, 0.27624160f, 0.15133826f, 
    0.23673944f, 0.03067455f, 0.18393330f, 0.13743441f, -0.71582574f, -0.19211628f, 0.13874292f, -0.01543006f, 
    -0.32261601f, 0.04580105f, -0.02788615f, -0.29515439f, 0.19172184f, -0.20534107f, 0.24626142f, -0.40219525f, 
    -0.38751933f, 0.12790965f, -0.74261534f, 0.07973111f, -0.08105513f, 0.06039131f, 0.23316680f, 0.09173989f, 
    -0.28021100f, 0.06740822f, -0.14588723f, 0.24710254f, -0.11497842f, -0.77866566f, -0.34532401f, 0.29658687f, 
    -0.02498727f, -0.57155883f, 0.06407885f, -0.16374895f, 0.17735688f, 0.10485227f, -0.13778347f, 0.36632651f, 
    -0.25940239f, 0.02640461f, 0.10605904f, -0.20620698f, -0.10686693f, 0.22559735f, 0.16373570f, -0.51063019f, 
    0.08109604f, -0.58288997f, 0.21322460f, -0.01278736f, -0.04485806f, -0.38165483f, 0.16498348f, 0.14099756f, 
    -0.51080251f, -0.24778041f, 0.13071010f, -0.67973161f, -0.03253890f, -0.06142966f, 0.02707403f, 0.13858233f, 
    -0.48357487f, 0.42328587f, 0.58952010f, -0.77571654f, 0.23432615f, 0.12361165f, 0.12853597f, -0.70222700f, 
    -0.00356219f, 0.17473705f, 0.02025353f, 0.02488525f, 0.24923988f, -0.09584516f, -0.28642529f, -0.21869837f, 
    -0.02121250f, -0.38357577f, -0.01380823f, 0.34425238f, 0.31258619f, 0.11310417f, 0.09365586f, -0.22956830f, 
    0.28602824f, 0.27785707f, 0.03417966f, -0.35918558f, 0.18989272f, -0.50801623f, -0.12945484f, -0.28764015f, 
    0.31080908f, -0.09365464f, -0.63942683f, -0.04570379f, -0.23913606f, -0.48432463f, -0.11154712f, 0.21119046f, 
    0.04528167f, 0.11451228f, -0.39323777f, 0.14859112f, -0.14353186f, 0.31140053f, -0.05470432f, -0.17131467f, 
    0.23742871f, 0.50479811f, -0.73720276f, -0.46272570f, 0.16238125f, -0.13992554f, -0.14959818f, 0.10934976f, 
    0.22907197f, 0.41036835f, -0.15812553f, -0.44276705f, 0.20435631f, -0.23977573f, 0.26621658f, -0.45722264f, 
    -0.11558689f, 0.04182140f, 0.07633310f, -0.32648885f, -0.39587200f, 0.07500395f, -0.46492273f, -0.03089072f, 
    -0.37285900f, -0.33089486f, -0.19055836f, -0.96542007f, -0.57352757f, 0.07951810f, 0.23271510f, -0.05929943f, 
    -0.85695845f, -0.24907736f, 0.13561052f, -0.49771777f, -0.18151121f, 0.03001658f, 0.36823589f, 0.16264185f, 
    0.14894959f, -0.12280508f, -0.08189827f, 0.06870309f, 0.61075073f, -0.45994258f, -0.14623843f, 0.23102213f, 
    0.00257744f, -0.31477219f, -0.00017043f, -0.57784283f, -0.23972441f, -1.20933509f, 0.38751754f, -0.66103637f, 
    -0.28804621f, -0.44704750f, -0.11275187f, -0.03782378f, -0.00336069f, -0.17233580f, 0.14125589f, -0.16948742f, 
    -0.05601402f, -0.62538588f, 0.09733656f, -0.08880807f, 0.00847175f, -0.37296987f, 0.38763005f, -0.35008454f, 
    0.24744579f, 0.10341682f, 0.00290972f, 0.10511049f, -0.00583807f, -0.04060451f, -0.02370819f, -0.56612182f, 
    -0.48793641f, -0.11426450f, -0.62786019f, -0.07767941f, -0.19747005f, 0.07454430f, 0.02809828f, 0.28536382f, 
    -0.24114628f, 0.23769048f, -0.06378961f, 0.15069044f, -0.04604872f, 0.11979663f, -0.26146841f, 0.16282481f, 
    -0.02601420f, -0.12035248f, 0.23023684f, 0.00087897f, 0.09847821f, -0.20419574f, 0.12804776f, -0.28130257f, 
    0.19502479f, 0.28845567f, 0.06633974f, -0.16177399f, 0.11557684f, 0.09346969f, -0.48061129f, 0.08290139f, 
    0.26388204f, 0.23215553f, 0.07816170f, -0.06214797f, -0.18375868f, -0.52415347f, -0.29908717f, 0.15531410f, 
    -0.42752844f, -0.21087292f, -0.49280167f, -0.20138022f, -0.04235908f, 0.44284216f, -0.00150725f, 0.23227330f, 
    -0.15460610f, -0.46642569f, 0.47234008f, -0.29364902f, -0.18382779f, 0.25051004f, 0.10524150f, 0.25604331f, 
    -0.06950486f, 0.30596235f, -0.08379290f, -0.13995552f, 0.09348857f, -0.10323582f, 0.18132296f, -0.20788346f, 
    -0.15754573f, -0.02167389f, -0.17290966f, -0.14684358f, -0.35848755f, -0.20589072f, 0.03146309f, -0.08474709f, 
    0.09591740f, 0.09459808f, 0.28396294f, 0.08503387f, -1.03116548f, 0.04241837f, 0.28982446f, -0.07498689f, 
    0.24728790f, 0.06085477f, -0.55396408f, -0.24915245f, -0.48394454f, -0.02129453f, 0.05770157f, 0.06522308f, 
    -0.16749255f, -0.61264819f, 0.18512370f, 0.09790252f, -1.00903261f, -1.76425302f, -0.32567170f, 0.48416841f, 
    -0.03638775f, -0.48202285f, -0.00522975f, 0.33835772f, 0.03064045f, -0.19602877f, 0.06917531f, 0.06755795f, 
    -0.07842609f, -0.83351803f, -1.03519952f, 0.02094395f, 0.24646753f, -0.06869345f, -0.00044492f, -1.11214697f, 
    -0.18235655f, -0.42566568f, -0.51281482f, -0.07607139f, -0.63336915f, 0.33577377f, 0.40203595f, -0.17898695f, 
    0.09121791f, -0.01887225f, 0.00507497f, 0.20207645f, 0.05133043f, -0.06440673f, 0.06783564f, 0.31833547f, 
    -0.32317191f, 0.28901282f, -0.35090527f, -0.01529126f, -0.40202829f, 0.08115051f, -0.27324018f, -0.08459295f, 
    0.12276180f, 0.20637527f, -0.24387315f, -0.08508877f, -0.32059258f, -0.01413858f, -0.32637423f, -0.21488962f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.23549618f, 0.00385622f, 0.14455621f, 0.12275943f, -0.05388062f, -0.02064024f, 0.02338574f, -0.03862042f, 
    -0.00170828f, 0.30919343f, -0.02042785f, -0.13417360f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
