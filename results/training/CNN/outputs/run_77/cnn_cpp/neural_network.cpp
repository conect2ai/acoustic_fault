#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.64076507f, 0.35703665f, 0.31051269f, -0.41459888f, -0.34923548f, 0.00617045f, -0.48762324f, -0.66412789f, 
    0.17512569f, 0.30832326f, -0.07214865f, 0.80260497f, -1.14717710f, 0.50466567f, -0.16266787f, 0.50939995f, 
    0.11378584f, 0.14900105f, 0.53571475f, 0.24701050f, 1.07052934f, -0.03303578f, 0.52092063f, -0.05268147f, 
    0.32878202f, 0.33561745f, 0.19070968f, -0.72859728f, -0.44236207f, 0.64926374f, -0.52128696f, 0.76762772f, 
    -0.59345227f, -0.16930108f, 0.02865719f, -0.56461984f, -0.31228712f, -0.72316200f, -0.52890080f, -0.45362279f, 
    -0.03412944f, -0.76118481f, -0.31558749f, -0.34673238f, -0.61850691f, 0.31447217f, -1.01665044f, -0.52677184f, 
    0.30350760f, -0.55964577f, -0.54534382f, 0.14649032f, -0.49454364f, 0.30889603f, 0.75548267f, 0.43055710f, 
    -1.05911481f, 0.36855555f, -0.39392275f, -0.00003001f, -0.23790124f, -0.24587099f, -0.02242519f, -0.72312653f, 
    -0.57070220f, -0.39020371f, -0.14864896f, -0.34560797f, -0.18464524f, 0.25571242f, -0.37091970f, -0.57585680f, 
    0.53375620f, 1.09166217f, 0.67785573f, -0.82365865f, -0.69425106f, -0.22250733f, -0.25999790f, 0.26853240f, 
    -0.39221561f, -0.31052572f, -0.86068541f, -0.62812662f, -0.32510805f, 0.56135076f, -0.28118965f, -0.33582336f, 
    -0.02912079f, 0.31263149f, 0.47787029f, -1.41210806f, -0.30959713f, -0.45281363f, 0.43308195f, 0.61581814f, 
    0.16687201f, 0.51818562f, -0.14208752f, 0.05451072f, 0.94178730f, -0.70925730f, 0.33786964f, -0.52189201f, 
    0.61898589f, -0.43337730f, -0.39269406f, -0.20166574f, -1.06791747f, 0.07589622f, -0.89055401f, -0.39835271f, 
    0.45497409f, 0.05925639f, 0.08120187f, -0.19165699f, 0.32653612f, 1.01767361f, -0.67898899f, -0.51966798f, 
    0.89066631f, 0.15748392f, 0.09705771f, 0.02840020f, 0.00576249f, -0.17226797f, -0.07858036f, -0.81928724f, 
    0.72042567f, -0.70010889f, 0.10752495f, 0.62791061f, 0.35850471f, -0.14983000f, -0.20672354f, 0.36946303f, 
    -1.27156007f, 0.49055719f, 0.26078460f, 0.84818500f, 0.35370275f, 0.01048523f, -0.14498694f, 0.05556627f, 
    0.78512716f, -0.59627831f, -0.64630973f, 0.17565772f, -0.67175925f, -0.35643628f, -0.29327086f, -0.25303268f, 
    -0.17093754f, -0.89927214f, -1.11936033f, 0.66497582f, 0.73120916f, 0.18974324f, 0.51454288f, -0.17309137f, 
    0.11370157f, 0.15295739f, 0.00085739f, 0.24732098f, -0.23818697f, -0.66795939f, -0.16713268f, -0.22782935f, 
    -0.48139980f, -0.28968808f, -0.37531468f, -0.21512760f, 0.13974594f, 0.68506229f, 0.12561007f, 0.63790047f, 
    0.32751504f, -0.48421839f, 0.64426380f, 0.61340189f, 0.98688775f, 0.68235159f, 0.12858477f, -0.27713713f, 
    -0.40955219f, 0.17978941f, 0.44674575f, 0.50587004f, 0.44693828f, -0.44874513f, -0.61670417f, -0.83033949f, 
    0.80662626f, -0.86092955f, -0.36870617f, 0.24549870f, 0.33467838f, 0.47190768f, -0.36093658f, 0.79203880f, 
    -0.52426171f, 0.74171597f, -0.11737961f, -0.89343953f, -0.15763521f, -0.09298178f, -0.58765882f, 0.79587919f, 
    0.45329598f, -0.76467311f, -0.68032360f, 0.08156286f, -0.70333481f, 0.21190016f, 0.46393660f, 0.56492227f, 
    -0.89425701f, 1.48494208f, -0.54683417f, -0.45355466f, 0.78619438f, -0.42060253f, 0.01354229f, -0.33564204f, 
    -0.01312166f, -0.92644393f, 0.46966037f, 0.26144558f, -0.59240967f, -0.60998118f, -1.05988884f, 0.32442534f, 
    0.05372182f, 0.40848389f, 0.29162264f, -0.96733159f, -0.60906506f, 0.28405723f, 0.24331902f, -0.65968531f, 
    -0.66881639f, 0.65487820f, 0.14767168f, -0.55552512f, -0.35396358f, -0.00175856f, -0.87823927f, 0.04490919f, 
    -0.54185051f, 0.65577203f, -0.34831718f, 0.03866174f, 0.84465003f, 0.87595874f, -0.66933072f, 0.11584940f, 
    0.72766000f, 0.32367438f, 0.01794310f, 0.14303304f, -0.07086625f, 0.37214127f, 0.30211982f, 0.55100977f, 
    0.58000177f, -0.72304255f, -0.11729372f, 0.56656170f, 0.56415296f, -0.10287886f, 1.01833820f, -0.71548843f, 
    0.58375680f, -0.26915765f, -0.71890563f, -0.76258302f, 0.38618633f, 0.50137800f, -0.25448003f, 1.09449065f, 
    -0.54484957f, 0.76576042f, -0.00449836f, -1.02694750f, -0.13130133f, -0.13395703f, -0.00617799f, -0.01120946f, 
    -1.24139285f, -0.12418734f, 0.27218717f, 0.24757998f, -0.35739091f, 0.18501854f, 0.55324960f, -0.42209220f, 
    0.00688436f, 0.03438786f, 1.13031185f, -0.22098579f, -0.48100060f, 0.70031625f, -0.20427445f, -0.01197814f, 
    0.00283419f, 0.46513340f, 0.67088318f, -0.08418898f, -0.22818497f, -0.30168155f, 0.47452509f, 0.58196872f, 
    -0.34380251f, 0.19642384f, 0.57935059f, 0.73115480f, -0.03001093f, -0.67353648f, 0.68706769f, -0.65406996f, 
    -0.29612392f, -0.55961084f, 0.49707207f, 0.28637743f, 0.29045317f, 0.34485763f, -0.29690525f, 0.80425483f, 
    0.80830592f, -0.12690087f, -0.05714009f, -0.49145275f, -0.54296863f, -0.72354078f, -1.13229918f, -0.36366066f, 
    0.44603077f, 0.57315880f, 0.56316394f, -0.11301193f, -0.33503133f, 0.08600677f, -0.22476628f, -0.60970205f, 
    -1.12528706f, -0.66321343f, 0.48492965f, 0.46555024f, 0.65300572f, -0.27110872f, 0.11032397f, -0.50400949f, 
    0.53240156f, 0.77204770f, -0.81893146f, -0.12586811f, -0.61680317f, -0.01998912f, -0.42656210f, -0.21717100f, 
    0.93117446f, 0.04471691f, 1.05288959f, -0.64146882f, 0.46487266f, -0.45615238f, 0.09647050f, 0.09057981f, 
    -0.10019741f, 0.65972298f, 0.68634421f, 0.52135164f, -0.60234195f, -0.06942651f, 0.49017417f, -0.45189661f, 
    -0.48462364f, -0.47343105f, 0.80235773f, -0.72059983f, -0.46056369f, -0.50318354f, -0.63250190f, 0.73175329f, 
    -0.14299883f, -0.36735070f, 0.28533718f, -0.21298555f, -0.75106877f, -0.35655662f, -0.36464176f, 0.60371393f, 
    -0.77988416f, 0.41525528f, 0.70775735f, 0.19387816f, -0.15283944f, -0.58041483f, 1.01435554f, -0.31937638f, 
    -0.64317816f, -0.62827194f, 0.22172360f, 0.56379813f, -0.02185368f, 0.86296123f, -0.69345462f, 0.20605503f, 
    0.85177267f, 0.36530590f, -0.48307231f, -0.33409628f, 0.30347270f, -0.41141009f, -0.57744247f, -0.73818272f, 
    -0.58331835f, -0.31208393f, 0.77432245f, 0.22419855f, -0.21880749f, -0.08677026f, -0.31288341f, 1.04275429f, 
    0.75447816f, 0.47020924f, 0.15454872f, 0.48087591f, -0.26270840f, 0.30278125f, -0.22836863f, -0.32089442f, 
    0.84664553f, 1.11053133f, 0.26103091f, -0.36654738f, -0.60998851f, -0.72631621f, 0.58225381f, -0.30043769f, 
    0.08570883f, 0.79095119f, 0.79755187f, 0.32805997f, 0.41913202f, 0.57353920f, 0.77834135f, -0.35412803f, 
    -0.34543043f, 0.29590008f, 0.69040149f, 0.03483426f, 0.80318987f, 0.72791600f, 0.18116449f, -0.16350096f, 
    -0.15742925f, -0.35857171f, 0.34428480f, 0.51125944f, -0.26865101f, -0.91648114f, -0.78220165f, -0.31871989f, 
    -0.96417046f, 0.40424833f, -0.06532931f, -0.05228329f, -0.45871499f, 0.46703377f, -0.73099464f, 0.49465823f, 
    -0.26725787f, -1.09220755f, -0.11101368f, 0.28627923f, 0.34819672f, -0.50584620f, -0.95139432f, -0.73095983f, 
    0.67462742f, 0.90849614f, 0.75797743f, -0.26771879f, 0.32108352f, -0.28501531f, -0.81692535f, 0.53011894f, 
    -0.30969885f, 0.80660820f, 0.80793917f, 0.44271958f, 0.47377938f, -0.35534418f, -0.09886328f, -0.54249179f, 
    -0.14653815f, 0.83803612f, 0.96979064f, 0.40574300f, -0.09644734f, -0.45971730f, -0.52067369f, -0.36252350f, 
    0.79295701f, 0.45119438f, 0.48282206f, 0.35584280f, -0.21110718f, 0.74285001f, 0.08891913f, 0.23141049f, 
    -0.34329629f, -1.36110651f, 0.89868337f, 1.17097569f, 0.69678664f, 0.61156207f, 0.36414126f, 0.01423736f, 
    0.00293339f, -0.10919607f, 0.52274555f, 0.77922189f, -0.66333562f, 0.79904860f, 0.23950584f, -0.75991386f, 
    0.23517323f, 0.33189383f, -0.20174377f, -0.68940765f, -0.42542922f, -0.74830550f, 0.56534463f, 0.91175020f, 
    -0.23052922f, -0.40477306f, -0.46889296f, -0.21769881f, 0.49620894f, -1.07431209f, 0.92538589f, 0.14056732f, 
    -0.75580889f, 0.37576184f, 0.00306332f, -0.46754530f, -0.52773964f, 0.38980556f, -0.42783973f, -0.51120263f, 
    -0.38434267f, 0.01469696f, -0.12237369f, -0.65565449f, -0.35452619f, -0.50959140f, 1.23231149f, -0.20921645f, 
    -0.97215152f, -0.47571757f, 0.56335378f, 0.40796080f, -0.18925205f, -0.46592206f, 0.30434743f, 0.87173080f, 
    1.05557859f, -0.15667599f, -0.03478636f, 0.50122291f, -0.27233779f, -0.06583055f, 0.30049998f, 0.00789343f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.26268357f, -0.06399605f, 0.26417777f, -0.04274951f, -0.01302352f, 0.38451311f, 0.20104586f, -0.13389975f, 
    -0.08540143f, 0.21043232f, 0.16212758f, 0.21785250f, 0.39606225f, 0.08746216f, 0.11979754f, 0.23463137f, 
    0.20960097f, 0.13008791f, 0.25009879f, 0.17712983f, 0.08831148f, 0.01913647f, 0.09026586f, 0.20184048f, 
    -0.01860512f, -0.12258749f, 0.16816048f, 0.04641379f, 0.29876751f, 0.24664779f, 0.06326179f, 0.04481987f, 
    0.15030590f, 0.17074932f, 0.19095074f, -0.03188463f, -0.11067922f, 0.09501609f, 0.12339766f, 0.12419867f, 
    0.00320595f, 0.02366250f, -0.03919994f, 0.07496224f, 0.05666112f, 0.18189628f, 0.13178535f, 0.10643351f, 
    -0.11679255f, 0.03306583f, 0.37028849f, 0.07039503f, 0.22646764f, 0.03125206f, -0.07355739f, 0.24037509f, 
    0.28993079f, 0.31397015f, 0.04664474f, -0.01136064f, 0.25290823f, 0.05990128f, -0.06599599f, 0.33416700f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.05830527f, 0.00639628f, -0.02116844f, -0.00908242f, 0.06922643f, -0.06503593f, -0.10533529f, -0.08826224f, 
    -0.02567066f, 0.03183278f, -0.04128539f, -0.00668185f, 0.03063463f, -0.06270625f, 0.04856058f, 0.01690714f, 
    0.00552078f, -0.08759409f, 0.03768147f, 0.04601837f, 0.21977097f, -0.08378906f, -0.06836810f, 0.11109522f, 
    -0.07703996f, -0.05215751f, -0.04694137f, -0.10512479f, -0.03408659f, 0.00736350f, 0.06633605f, -0.06795104f, 
    0.02001545f, -0.01888052f, -0.02609157f, -0.09665238f, -0.05412589f, 0.03512948f, -0.09225373f, -0.00206707f, 
    0.13933818f, -0.02527832f, -0.04426712f, -0.00430008f, -0.09918620f, -0.04627705f, -0.12082328f, -0.00035767f, 
    0.00843631f, -0.04700093f, -0.02939609f, 0.03242702f, 0.01709230f, 0.01374678f, -0.00553020f, -0.07634932f, 
    -0.05088915f, -0.01002038f, -0.03440753f, -0.03079729f, -0.10004737f, -0.25118011f, 0.16535124f, 0.02301254f, 
    -0.25128186f, -0.02303841f, 0.03480688f, 0.03865163f, 0.15914483f, 0.05094331f, -0.04127939f, 0.10324309f, 
    0.00288966f, 0.00975770f, -0.04984489f, 0.11655246f, -0.13571551f, -0.00347820f, -0.02154900f, -0.02099445f, 
    -0.14865927f, -0.24033447f, 0.04945631f, 0.02140164f, -0.15690187f, 0.07573359f, 0.01969830f, 0.01168769f, 
    -0.01653174f, -0.09724480f, 0.05349740f, -0.03219283f, -0.03877761f, -0.00217801f, 0.01979771f, 0.02284674f, 
    -0.06623738f, 0.04567605f, -0.03721446f, 0.03037439f, -0.09956720f, -0.32476041f, 0.17362377f, 0.09440900f, 
    -0.12414900f, -0.00720294f, 0.08174958f, -0.00573647f, -0.01673661f, 0.00089671f, -0.11830959f, 0.00484177f, 
    -0.06714129f, -0.00563135f, 0.03576660f, 0.03608168f, 0.01122631f, 0.02881430f, -0.07967338f, -0.07551163f, 
    0.06410474f, -0.08721115f, 0.08695517f, 0.04518606f, 0.14063017f, -0.08998473f, 0.06469575f, 0.02009980f, 
    0.03800726f, -0.05057496f, 0.03203066f, 0.00466390f, -0.04500371f, -0.02719895f, -0.03966681f, 0.06825209f, 
    0.00340738f, 0.03368731f, -0.08471905f, -0.01546573f, -0.12481726f, -0.20920360f, -0.17053533f, 0.05045908f, 
    -0.14613633f, 0.07881270f, -0.05069672f, -0.10640644f, 0.14761712f, 0.03421357f, 0.07807450f, -0.12186489f, 
    -0.03503824f, -0.01544435f, 0.04227665f, 0.03125129f, 0.02337526f, -0.02297196f, 0.09936937f, -0.01786900f, 
    0.15256640f, 0.08530476f, 0.01514705f, -0.01315636f, 0.19475178f, -0.02061451f, -0.10103273f, -0.12731390f, 
    0.03646963f, 0.07126217f, -0.01142164f, -0.05946521f, -0.06989678f, -0.00307595f, 0.02105346f, 0.02845179f, 
    0.01839196f, -0.03195215f, 0.09497903f, 0.02003945f, -0.18292601f, 0.06657404f, -0.03465160f, -0.04891360f, 
    -0.19516635f, 0.03534791f, -0.03489387f, 0.08276015f, -0.06467972f, -0.04469681f, 0.00196201f, 0.03898850f, 
    0.03609468f, -0.03106261f, 0.00068896f, -0.11719552f, -0.11575419f, 0.02031228f, -0.04885425f, 0.04886248f, 
    0.02374152f, 0.00653068f, -0.10671183f, -0.03017946f, -0.28301036f, -0.06941739f, 0.07381323f, -0.05037614f, 
    -0.05230068f, 0.08079002f, 0.04522082f, 0.01141942f, 0.01265850f, -0.04502810f, 0.09226964f, 0.00990097f, 
    0.01062171f, -0.05669257f, -0.09994584f, 0.02980396f, 0.10533094f, -0.01757630f, 0.12010918f, -0.06256773f, 
    0.08338229f, -0.03610285f, 0.01321527f, 0.06869181f, -0.07806746f, -0.05861850f, -0.00952316f, 0.02066244f, 
    -0.03043792f, -0.03091236f, 0.06374695f, -0.05225770f, 0.02232545f, -0.00882116f, -0.15297060f, 0.00415216f, 
    0.25623950f, 0.20464458f, -0.06455030f, -0.08286039f, -0.12920339f, 0.01759133f, -0.06849387f, -0.06872441f, 
    0.07619702f, -0.03094461f, 0.05263117f, -0.00777777f, -0.03438369f, 0.04949403f, 0.01622524f, 0.01386038f, 
    -0.05505397f, 0.00693560f, -0.08099658f, -0.11501630f, 0.19578075f, -0.04429906f, 0.04426407f, 0.01965119f, 
    0.05805708f, 0.03328078f, 0.07989208f, -0.00432445f, 0.00183552f, -0.05481127f, -0.09074915f, 0.00433897f, 
    -0.02455759f, -0.05237017f, 0.02875329f, 0.04290856f, 0.07303448f, 0.02355813f, -0.06023455f, 0.03297693f, 
    -0.00461056f, -0.03621671f, -0.16003981f, 0.08824523f, -0.24292202f, -0.10877928f, 0.00725347f, 0.00611142f, 
    0.01450578f, -0.03098768f, 0.07116480f, -0.03902714f, -0.02878863f, -0.02852540f, -0.02773184f, -0.07258493f, 
    0.01011597f, -0.04609951f, 0.07791089f, 0.07607041f, -0.17243652f, 0.13748607f, 0.04913496f, -0.03677033f, 
    -0.25115418f, -0.05171575f, -0.07933909f, 0.02931155f, -0.06929010f, 0.03792231f, -0.02056591f, -0.03360746f, 
    -0.11061905f, -0.02019452f, 0.02945707f, -0.01514912f, 0.03015624f, -0.03220720f, -0.04931041f, -0.00100586f, 
    0.12133987f, -0.32985967f, 0.19197014f, 0.18330882f, 0.00281748f, 0.07426683f, 0.06699580f, 0.00359903f, 
    0.02990344f, -0.00574500f, -0.09696168f, -0.00897928f, -0.02824980f, 0.07342710f, 0.03294769f, 0.01289362f, 
    0.01412226f, 0.02667055f, 0.01798663f, -0.02685220f, -0.24759856f, 0.10320976f, 0.15834303f, -0.03079597f, 
    -0.25941187f, 0.02266613f, 0.03563368f, 0.02451581f, 0.05783112f, -0.04825396f, -0.06121442f, 0.00700624f, 
    -0.06518864f, -0.07393494f, 0.01337331f, 0.00439007f, 0.05568668f, 0.00049977f, -0.00363136f, 0.03202108f, 
    0.03068179f, -0.04313858f, -0.01042724f, 0.10158443f, 0.05804111f, 0.00221316f, -0.05817600f, -0.04027762f, 
    -0.08912326f, -0.00582935f, -0.03018112f, 0.00357314f, 0.04606055f, -0.09303772f, 0.00771354f, -0.06183762f, 
    0.02604487f, -0.02600534f, 0.01075431f, -0.03943424f, -0.22377717f, -0.02064832f, 0.05148996f, 0.03317772f, 
    0.00528224f, -0.00281509f, 0.04869074f, 0.05798009f, 0.01546624f, -0.11506541f, -0.00972889f, -0.05920842f, 
    0.00602245f, -0.03071745f, 0.05061930f, -0.02377698f, 0.02633501f, -0.06080930f, -0.05587330f, -0.02214698f, 
    0.05485331f, -0.05146379f, -0.05445204f, -0.11212134f, 0.08958714f, -0.00169854f, -0.05200201f, -0.14032273f, 
    0.04180280f, -0.01600455f, -0.03396881f, 0.00792265f, -0.02041229f, 0.04184632f, 0.00472825f, -0.01252829f, 
    -0.02097535f, 0.01982913f, 0.01750742f, 0.05327780f, 0.04427459f, -0.45769873f, -0.11482150f, -0.03771353f, 
    -0.03417476f, -0.00253492f, 0.00275832f, -0.00930815f, -0.03345813f, 0.10938320f, -0.07143790f, 0.05195386f, 
    0.05082793f, 0.00540701f, 0.11547683f, 0.12631936f, 0.02434068f, 0.12405500f, -0.02164852f, -0.04976020f, 
    0.19531703f, -0.05526205f, 0.09836740f, 0.04233385f, 0.08442121f, -0.06822999f, -0.09884097f, 0.10048673f, 
    -0.02447766f, 0.01327136f, 0.10680607f, 0.05974154f, -0.07194703f, 0.08261331f, -0.00684353f, -0.05465503f, 
    0.03587618f, 0.03724264f, -0.04676669f, -0.04648508f, -0.18778227f, -0.07315710f, 0.03041485f, 0.02847391f, 
    0.07278416f, -0.03091103f, -0.02755130f, -0.03371630f, 0.09706599f, 0.06070089f, -0.00818095f, 0.05069225f, 
    0.02832820f, -0.02818290f, -0.01598733f, -0.03173482f, -0.02519478f, -0.04379975f, 0.04714366f, -0.06487614f, 
    0.48843771f, 0.12502825f, 0.19935310f, -0.23593518f, 0.24551751f, 0.00620405f, 0.00223975f, 0.03844273f, 
    -0.04192613f, 0.02674404f, -0.03616493f, -0.00023411f, -0.01665928f, -0.06393999f, 0.14305437f, -0.07648139f, 
    -0.07245274f, 0.07378159f, -0.09433072f, -0.07978577f, -0.34827772f, -0.15807734f, -0.05281293f, 0.01749958f, 
    0.04826692f, 0.04307540f, -0.04315715f, -0.04122757f, 0.01464651f, -0.01036471f, 0.08943204f, 0.08270926f, 
    -0.03842849f, -0.00411607f, 0.00905575f, 0.04068275f, -0.04940562f, 0.04280112f, 0.07572157f, -0.11264222f, 
    -0.09199854f, -0.23044308f, 0.06260806f, -0.07834749f, -0.14839475f, -0.00599077f, -0.07386331f, 0.05477334f, 
    -0.08105081f, 0.01792431f, -0.10023763f, 0.09564779f, 0.14774555f, -0.01219938f, 0.07331564f, -0.08074132f, 
    0.02863919f, -0.07672264f, -0.06718408f, 0.03475157f, -0.07693537f, -0.17729825f, -0.07367803f, 0.11419965f, 
    -0.10525936f, -0.08627042f, -0.03929435f, -0.00136217f, 0.07576910f, 0.00349695f, 0.01021140f, 0.00855159f, 
    -0.12724386f, 0.04659928f, -0.06851268f, 0.00614128f, -0.07559299f, 0.01043654f, -0.01221920f, -0.03759078f, 
    -0.07255463f, 0.00003087f, 0.06061696f, -0.20631073f, 0.30264089f, -0.09564147f, -0.02157505f, -0.02060983f, 
    0.10211886f, -0.03455377f, -0.06066684f, 0.02567922f, -0.03163028f, -0.00494984f, 0.01533882f, -0.04613662f, 
    0.02474299f, 0.00096923f, 0.00538184f, 0.01077509f, -0.09436512f, -0.10807204f, 0.03413091f, 0.00595716f, 
    -0.01695167f, -0.03973984f, -0.00995540f, 0.00187115f, -0.06554252f, -0.03492318f, 0.03819732f, 0.01082452f, 
    -0.02801741f, 0.02633958f, -0.04414541f, -0.04890187f, -0.05187584f, -0.02500807f, 0.01519603f, -0.03127772f, 
    0.24410322f, -0.25219715f, 0.17716166f, 0.04632154f, -0.20301585f, -0.17147589f, -0.01935880f, 0.03840914f, 
    -0.03324720f, -0.06423813f, -0.09810408f, -0.01309401f, -0.02640153f, 0.01786370f, -0.03777741f, -0.02204035f, 
    -0.08446591f, 0.06057737f, 0.04745757f, -0.01152594f, 0.23979746f, -0.23418874f, 0.03133072f, -0.04943291f, 
    -0.19411151f, 0.04740214f, -0.01233694f, -0.01897089f, 0.00764385f, 0.02112852f, -0.17552535f, -0.01703129f, 
    -0.07264888f, 0.08591091f, 0.07484291f, 0.00799736f, -0.02082080f, 0.04461866f, 0.06614618f, 0.02580026f, 
    0.03255006f, -0.15097751f, 0.00459315f, -0.04324431f, -0.07864138f, 0.01272914f, 0.04691983f, -0.09563024f, 
    0.05174549f, 0.05935444f, 0.05450223f, -0.04497117f, 0.02562650f, -0.00018303f, -0.03966307f, -0.04358718f, 
    0.05117263f, -0.06973673f, -0.00093793f, -0.09798341f, -0.00113308f, 0.01112237f, 0.01920259f, -0.27770692f, 
    0.20182933f, -0.07539038f, -0.00465047f, -0.01030161f, 0.00095001f, 0.06146082f, -0.00513329f, -0.03761716f, 
    0.02621931f, -0.06830174f, 0.06367318f, -0.09776791f, -0.05334658f, 0.12946463f, -0.11150387f, -0.08958944f, 
    -0.13869010f, -0.11338896f, -0.05708570f, -0.10684123f, 0.03716433f, 0.02434242f, 0.01605878f, -0.03331200f, 
    0.00807253f, 0.03468053f, 0.00948824f, 0.00246730f, 0.08299313f, 0.03978144f, -0.00656048f, 0.00490945f, 
    -0.00068734f, -0.04135680f, -0.06179081f, -0.03629045f, 0.24822456f, -0.39467520f, 0.13097475f, -0.04803384f, 
    0.06769697f, -0.01115181f, 0.00967630f, 0.09306044f, -0.01290402f, -0.00013610f, -0.11454478f, 0.06350619f, 
    0.00862965f, 0.11718410f, -0.00732564f, 0.02245605f, 0.04560687f, -0.03810617f, -0.07374911f, 0.06906397f, 
    0.10485349f, 0.07410524f, 0.20711501f, -0.01830717f, 0.12626381f, -0.06681751f, 0.02931013f, 0.06805438f, 
    0.08534126f, -0.06866624f, 0.09446002f, 0.04535514f, -0.02881916f, -0.00287797f, 0.04216408f, 0.05972544f, 
    0.10212099f, 0.05234699f, -0.02157406f, 0.05205489f, -0.08727737f, 0.12946180f, 0.03157022f, -0.15715100f, 
    -0.37989697f, 0.08346179f, 0.09540749f, -0.08235175f, 0.09998848f, -0.01503020f, 0.03354155f, -0.02553937f, 
    0.00097392f, 0.03045255f, -0.04134498f, 0.04079811f, 0.01774637f, 0.00182268f, 0.02930228f, -0.00840809f, 
    -0.42575949f, 0.27167630f, -0.07835548f, 0.01375867f, -0.19592078f, -0.05341088f, -0.06337807f, 0.03125879f, 
    -0.02980512f, 0.06014305f, -0.00732541f, -0.15309079f, -0.10783731f, 0.12292353f, 0.04144407f, -0.07619928f, 
    -0.05989553f, -0.04615128f, 0.00449419f, -0.07072489f, -0.04469528f, 0.04671136f, -0.11925922f, 0.01111949f, 
    0.07801355f, -0.03407130f, -0.03206711f, -0.05185054f, 0.04274073f, 0.06615753f, 0.01914392f, 0.02477434f, 
    -0.02543283f, -0.03475618f, -0.05780524f, 0.02140710f, -0.09641445f, 0.05129012f, 0.07796623f, -0.00820794f, 
    0.29690713f, 0.06115253f, -0.01007400f, -0.01949610f, -0.18760116f, -0.14639978f, -0.16712613f, -0.08138869f, 
    0.07192191f, 0.00256881f, -0.08336031f, 0.07015647f, -0.08574350f, -0.00218488f, 0.02757336f, -0.08989255f, 
    -0.08235364f, 0.06322246f, -0.00779999f, -0.00285263f, 0.14968120f, 0.09882317f, -0.04202104f, -0.02351781f, 
    0.16683570f, -0.12163854f, -0.15391691f, -0.10976832f, 0.03352762f, -0.05984325f, -0.00940638f, -0.01340507f, 
    0.08225890f, -0.07399223f, 0.00266613f, 0.10717501f, 0.08039728f, -0.12678723f, 0.04068224f, 0.06556170f, 
    0.09610196f, -0.23797353f, 0.05558522f, 0.14193735f, -0.14557604f, 0.08270642f, 0.07116357f, -0.08247472f, 
    0.02457074f, -0.05116893f, -0.10292397f, 0.00580675f, 0.04193815f, 0.00837484f, 0.09899230f, -0.02924385f, 
    0.00237661f, 0.03774624f, 0.05606731f, -0.10703107f, -0.12486400f, -0.19978091f, -0.07642163f, 0.04204221f, 
    -0.11557703f, 0.01443074f, -0.10000267f, -0.01248372f, 0.05059382f, 0.02146679f, -0.00354713f, 0.15116413f, 
    -0.04934257f, -0.03684215f, 0.02167525f, -0.03271826f, -0.01875803f, -0.01446616f, 0.03739050f, -0.04754401f, 
    -0.07860233f, -0.18371095f, -0.01898682f, 0.09358773f, -0.21933687f, -0.04279662f, 0.02053765f, -0.00497261f, 
    -0.00672523f, -0.04881893f, -0.02381595f, 0.07989560f, 0.02541590f, -0.11192241f, -0.07319609f, -0.02855832f, 
    -0.01324471f, 0.01616710f, 0.02302593f, -0.03155280f, 0.08496321f, -0.00542425f, 0.08762743f, 0.02889149f, 
    0.00629090f, -0.03014152f, -0.09813804f, -0.02453580f, 0.01204087f, -0.00380890f, -0.08430399f, 0.06633574f, 
    0.03774167f, 0.08660802f, -0.00604809f, -0.00838696f, 0.01961626f, 0.00447471f, -0.09105092f, 0.01634516f, 
    -0.06088629f, 0.13292153f, 0.05345979f, -0.20505579f, -0.27663690f, 0.06070352f, 0.05004509f, -0.02857368f, 
    0.02858238f, -0.02260695f, -0.00676592f, 0.03193919f, -0.01419374f, 0.03061916f, -0.02017259f, -0.06858146f, 
    0.02671304f, 0.04888450f, 0.01937006f, 0.00563741f, 0.11717352f, 0.13453199f, -0.01270688f, -0.15688430f, 
    0.20651676f, -0.23841864f, -0.05188726f, 0.00875357f, 0.06846269f, 0.02414868f, 0.07154500f, 0.03920788f, 
    -0.11845969f, 0.00558316f, 0.04358668f, 0.00293138f, 0.00595482f, 0.02698134f, -0.05516370f, 0.08169290f, 
    0.14050962f, 0.20319255f, 0.06519625f, -0.10716567f, 0.13624315f, -0.16019149f, -0.07801896f, -0.02585104f, 
    0.03246525f, -0.00170754f, 0.07359872f, -0.02827966f, 0.05678041f, -0.05107290f, -0.01512836f, 0.12129515f, 
    0.02018775f, 0.07895528f, -0.00914429f, -0.04357647f, -0.01718867f, -0.09292293f, -0.04893554f, -0.08359930f, 
    0.16288699f, -0.04126264f, -0.08878181f, -0.05068904f, 0.03783925f, -0.03290856f, 0.02381280f, 0.01883758f, 
    0.04008077f, 0.00907608f, 0.07351899f, 0.04706350f, 0.12496784f, -0.04068894f, -0.04315080f, 0.12963933f, 
    0.11066998f, -0.09994411f, 0.07654417f, 0.02792616f, 0.00073552f, -0.07086159f, -0.15236504f, -0.04023578f, 
    -0.00575916f, -0.00085786f, -0.05638991f, 0.01819179f, -0.09860300f, 0.02937850f, -0.01106780f, 0.00313058f, 
    0.00237608f, 0.04408905f, -0.06489230f, -0.00177265f, -0.20580426f, -0.26906839f, 0.12897326f, 0.26939788f, 
    0.01513266f, -0.01298173f, 0.00221051f, 0.09514585f, 0.05496421f, -0.00320441f, 0.09239979f, -0.14996330f, 
    0.03249049f, 0.00791679f, -0.00527162f, 0.02871885f, -0.07111968f, -0.01388793f, 0.00336857f, -0.03944968f, 
    0.11493839f, -0.16796258f, -0.02346502f, -0.04186174f, 0.01941452f, -0.05589286f, -0.06256664f, -0.04231120f, 
    -0.15038122f, 0.06915844f, -0.00964508f, -0.01338516f, -0.01101712f, 0.06213965f, -0.06769768f, 0.00243537f, 
    -0.05874602f, 0.05428398f, -0.11574727f, -0.06321885f, 0.00021937f, 0.16438027f, 0.03191022f, -0.21132207f, 
    -0.23323438f, 0.06091497f, 0.10461917f, -0.05358269f, 0.08209120f, -0.05192101f, 0.01369438f, -0.02549319f, 
    0.05735566f, 0.02424878f, -0.03005896f, 0.07520223f, 0.07606505f, 0.01782118f, 0.03165708f, 0.04161255f, 
    0.52036101f, -0.08201865f, 0.18520959f, -0.16702491f, -0.02710885f, 0.02552883f, 0.09407084f, 0.07248974f, 
    -0.01107187f, -0.03142258f, -0.00067440f, 0.05495599f, -0.04374013f, 0.07466421f, 0.08684304f, 0.07235069f, 
    0.07809205f, -0.04793713f, 0.06405881f, -0.03244774f, -0.07923375f, 0.01748002f, 0.20116936f, 0.06565242f, 
    -0.17783940f, 0.00378736f, -0.04775135f, 0.07899356f, 0.02750587f, 0.00257130f, -0.01928184f, -0.00784170f, 
    -0.03319830f, 0.04059414f, -0.06282590f, 0.05432428f, -0.02968586f, -0.01137295f, -0.01362975f, 0.03324964f, 
    0.18719634f, -0.09115414f, -0.01681997f, -0.09074974f, 0.06355812f, -0.14551596f, 0.03887999f, -0.05267445f, 
    0.00422722f, 0.03957425f, -0.04221583f, -0.00192306f, -0.02757966f, 0.01617593f, -0.05316116f, -0.00273852f, 
    -0.02388492f, -0.12092331f, 0.00001159f, 0.03792369f, 0.03273482f, 0.02442710f, 0.24591689f, 0.09833519f, 
    0.18130429f, -0.02886217f, -0.09377037f, 0.10979138f, -0.05608483f, -0.00825239f, 0.04259267f, -0.04147167f, 
    0.01248861f, -0.03589994f, 0.01796796f, 0.08061317f, -0.06675673f, -0.10595529f, 0.02047688f, -0.03044337f, 
    0.04744536f, -0.05074347f, 0.03911470f, -0.05443452f, 0.20610991f, -0.13104084f, -0.03553823f, 0.07808629f, 
    0.06432188f, -0.05516816f, 0.01729663f, 0.08952019f, 0.02539041f, 0.03087130f, 0.04291611f, 0.03168605f, 
    0.00813481f, 0.07923241f, 0.01481038f, -0.01976596f, 0.26704910f, 0.15177025f, 0.14686106f, -0.08404786f, 
    -0.22635320f, 0.02749861f, 0.07349142f, -0.04232917f, 0.00130649f, -0.10031477f, 0.02457598f, -0.03018293f, 
    -0.01449102f, 0.04145863f, -0.00350785f, 0.03985880f, 0.01644844f, 0.02117151f, -0.02810808f, -0.02026974f, 
    0.15385996f, -0.15252617f, -0.01798005f, 0.09998897f, -0.30382645f, -0.06495776f, -0.02078979f, 0.01401366f, 
    0.01337900f, 0.05325253f, -0.11698753f, -0.01657063f, -0.03527844f, 0.00356361f, 0.04310927f, -0.01381573f, 
    -0.06897778f, 0.06148386f, 0.05727440f, 0.06395608f, 0.01137171f, -0.13369170f, 0.00716944f, 0.14099723f, 
    0.00148117f, -0.03387358f, 0.01039853f, -0.05105790f, -0.05659767f, -0.03820954f, -0.00247430f, -0.03483689f, 
    0.09660438f, -0.01866451f, -0.00411919f, 0.02419474f, 0.03333050f, -0.02451611f, -0.01001138f, -0.06734451f, 
    -0.19383928f, 0.09552053f, 0.07297259f, 0.14690253f, 0.20839639f, -0.11427724f, -0.01333954f, -0.00698898f, 
    -0.00785654f, -0.02989926f, -0.05155427f, 0.01713706f, 0.11891150f, 0.04099055f, -0.02200146f, 0.04835316f, 
    0.03384469f, -0.03619732f, -0.06715336f, -0.05960954f, -0.05571401f, 0.05922128f, 0.04181532f, -0.22474121f, 
    0.28799602f, -0.12125546f, 0.02209827f, -0.03139618f, 0.07651751f, 0.04914373f, -0.00319850f, 0.05260883f, 
    0.00385000f, -0.04625108f, -0.07135904f, -0.04776848f, 0.03317223f, 0.03752213f, -0.02177378f, -0.02919802f, 
    0.17309779f, -0.00698510f, 0.00785375f, 0.03557293f, -0.02027862f, -0.05270533f, -0.04430991f, 0.03484855f, 
    0.06638030f, 0.01269177f, -0.05594920f, -0.05365534f, -0.07930075f, -0.02022741f, -0.03138310f, 0.06910424f, 
    -0.02733956f, 0.00513432f, 0.02595865f, -0.04341059f, -0.18967965f, 0.02169918f, -0.10016452f, 0.00668934f, 
    0.07733269f, 0.03462891f, -0.02578321f, -0.01665847f, 0.03307481f, -0.06828800f, 0.09169949f, 0.06988204f, 
    -0.07100828f, 0.02965191f, -0.00635105f, 0.00830192f, -0.15384229f, -0.03905168f, -0.04642824f, -0.04165640f, 
    -0.03913841f, 0.16167817f, 0.13563731f, -0.00120829f, 0.22942276f, -0.09701695f, -0.02954192f, 0.00540197f, 
    0.00718640f, 0.06158149f, 0.10325686f, -0.06183768f, -0.03046164f, -0.06545167f, 0.01396943f, -0.02720634f, 
    0.01885457f, 0.00537708f, -0.07215263f, 0.03023385f, -0.14703602f, -0.03795074f, -0.14498794f, -0.01270342f, 
    -0.00324396f, 0.02170040f, -0.00009406f, -0.03877780f, -0.07918886f, 0.08554745f, 0.07296358f, -0.02241932f, 
    -0.01455618f, -0.09352359f, -0.02739048f, -0.12484676f, -0.01963582f, -0.03313195f, -0.14586908f, 0.03115598f, 
    0.08906646f, -0.03222811f, -0.12586951f, -0.07597398f, -0.11790886f, 0.04215106f, -0.09833477f, 0.05054056f, 
    0.02364264f, 0.10285595f, 0.00505512f, 0.00244341f, -0.00204452f, -0.03393286f, 0.02241832f, -0.04977457f, 
    0.04372046f, -0.08070592f, -0.11465110f, -0.05660303f, -0.03308141f, -0.00409839f, 0.02270859f, -0.05941117f, 
    0.01027752f, 0.09911053f, 0.00141916f, 0.09767321f, 0.01261340f, 0.01606747f, 0.04182859f, 0.05184584f, 
    -0.02584558f, 0.04165378f, -0.04028671f, -0.05289518f, 0.04727225f, -0.12069921f, 0.09489539f, -0.07510697f, 
    0.02888267f, -0.29659945f, 0.07734428f, -0.19489209f, -0.03928758f, -0.01994266f, -0.06450959f, 0.04764442f, 
    0.02908250f, -0.01363161f, -0.03300925f, -0.06647140f, -0.02075881f, 0.00142302f, -0.00288285f, -0.11425978f, 
    0.01332776f, -0.07377028f, 0.07047216f, -0.12965885f, 0.11353980f, 0.07845736f, -0.11119606f, 0.01877633f, 
    -0.17363094f, 0.06870840f, 0.03098936f, -0.03875191f, -0.04366226f, 0.00743128f, -0.07979226f, -0.02575101f, 
    0.03838412f, 0.07621132f, -0.01287581f, -0.00843032f, 0.05598956f, -0.15544450f, -0.17536955f, -0.15557665f, 
    -0.01305113f, 0.04354670f, -0.28240153f, 0.02436541f, 0.05878327f, 0.02762684f, -0.03811737f, 0.05679115f, 
    0.02035263f, 0.00747331f, -0.02555458f, -0.01924103f, -0.01729436f, 0.04204855f, -0.00240603f, 0.04422629f, 
    -0.02301068f, -0.09161442f, -0.09707015f, -0.08826838f, 0.10501902f, -0.19192782f, -0.06779075f, 0.04494987f, 
    -0.08250859f, 0.01697595f, -0.02289131f, 0.04886204f, 0.03365903f, 0.05811187f, -0.00108326f, -0.01668179f, 
    -0.01142823f, 0.01798602f, 0.00813319f, 0.04052394f, 0.03175369f, 0.01706514f, -0.09202398f, -0.04534493f, 
    0.11457165f, -0.38132849f, 0.02727214f, 0.07131395f, 0.08754757f, -0.11567298f, 0.05773991f, 0.04056911f, 
    0.11322935f, 0.01403611f, 0.05857257f, -0.06427573f, 0.01015226f, 0.04470706f, -0.15973040f, 0.14100645f, 
    -0.06172232f, 0.03957948f, -0.00993467f, -0.00507138f, -0.03280635f, -0.11009235f, 0.01825304f, -0.01935981f, 
    0.26811555f, -0.06732716f, -0.09778963f, -0.01734982f, 0.00649306f, -0.07717705f, 0.05622683f, -0.03053014f, 
    -0.05310329f, -0.01105589f, -0.03857047f, -0.03874969f, -0.01190930f, 0.06814045f, 0.16222914f, -0.12682515f, 
    0.10730107f, 0.06692849f, -0.11969656f, -0.04860749f, 0.04707729f, 0.11637792f, 0.08597146f, 0.05343944f, 
    0.02838353f, 0.07435821f, 0.00275545f, -0.06462247f, 0.02297980f, -0.03479559f, 0.06864072f, 0.05309427f, 
    0.03903199f, 0.04125264f, 0.00130567f, -0.03324460f, 0.17920086f, -0.54745954f, 0.12679189f, -0.09943827f, 
    -0.10128253f, 0.01613138f, 0.07267974f, -0.12663448f, -0.01849537f, -0.03367477f, 0.07217411f, -0.05182040f, 
    -0.00609113f, 0.05835060f, -0.08711173f, 0.04811065f, 0.00526307f, -0.13296580f, 0.06389425f, 0.03205187f, 
    -0.35035333f, 0.04673658f, 0.00869196f, 0.07961631f, -0.14403673f, -0.04087221f, -0.05350899f, -0.08092911f, 
    0.05952982f, 0.00166217f, -0.02702411f, -0.04090896f, -0.02702892f, 0.04424407f, -0.08298153f, -0.00284231f, 
    -0.01829653f, 0.04026373f, 0.01566549f, -0.05633333f, 0.20303008f, -0.18417113f, -0.05521857f, 0.00279279f, 
    -0.05821798f, 0.01104916f, 0.04358076f, -0.00411901f, 0.01553995f, 0.08435332f, 0.15420827f, 0.02780141f, 
    -0.07420517f, 0.02875399f, -0.08672929f, 0.05586956f, 0.04080700f, -0.02090644f, 0.01881745f, -0.06329035f, 
    0.00532014f, -0.05176863f, 0.07914011f, -0.24181008f, -0.02110679f, 0.00967525f, 0.00001487f, -0.01265043f, 
    -0.03775200f, -0.02457013f, 0.02976285f, -0.03278274f, 0.03007683f, 0.01894063f, -0.07852432f, -0.05405074f, 
    -0.06064674f, -0.17993143f, 0.00117952f, -0.02607437f, 0.05765531f, 0.08536805f, -0.09945847f, 0.11040305f, 
    -0.33088750f, -0.07078108f, 0.03654626f, 0.01187911f, 0.01142540f, 0.08224396f, 0.02115004f, 0.03041282f, 
    -0.08852632f, 0.10741376f, 0.02347317f, 0.04818053f, 0.08188939f, 0.02041615f, 0.02451656f, 0.03253751f, 
    -0.05002294f, 0.00282499f, -0.05992756f, -0.12937160f, -0.00985866f, -0.03182002f, -0.03188701f, 0.01399694f, 
    0.10804569f, -0.02043663f, -0.01122069f, -0.00679025f, -0.02154572f, 0.07039280f, -0.09214920f, -0.01810822f, 
    -0.01102851f, 0.01286932f, 0.05924170f, 0.02166260f, -0.00814982f, 0.24800140f, -0.00505848f, -0.05658782f, 
    0.05742564f, -0.06861591f, 0.01532920f, -0.05433463f, -0.06754924f, 0.05136348f, 0.01206204f, -0.04522552f, 
    0.04517760f, -0.07744827f, -0.08080354f, -0.02718907f, -0.00995395f, 0.11856326f, -0.03885373f, 0.04660587f, 
    0.09561158f, 0.04223920f, 0.15465936f, 0.04049864f, -0.01233846f, -0.02876304f, -0.13086234f, 0.04341966f, 
    0.04487579f, -0.05310295f, -0.00018097f, 0.02319757f, -0.00380693f, 0.05014139f, -0.00533130f, 0.07108876f, 
    -0.04273102f, -0.05181856f, -0.06122949f, -0.05539159f, -0.08295463f, 0.17944378f, 0.01266153f, -0.01405965f, 
    0.03231109f, 0.12555808f, -0.02317648f, 0.11929808f, -0.03120822f, 0.00618301f, 0.11430333f, -0.11238478f, 
    0.01334797f, -0.03498770f, -0.10369883f, -0.02813207f, 0.07486434f, -0.20823401f, 0.02877649f, -0.00377164f, 
    -0.25486851f, -0.22555490f, -0.14300190f, -0.11512485f, 0.15742214f, 0.09983768f, -0.10930238f, -0.07054137f, 
    -0.02899760f, 0.05119861f, -0.01711506f, 0.04253561f, 0.00545964f, -0.16772905f, 0.03790325f, -0.02859174f, 
    -0.03502489f, -0.09391488f, 0.05444671f, -0.02011133f, 0.27938512f, -0.12861314f, 0.02254325f, -0.08802141f, 
    -0.09062355f, -0.01769904f, -0.07647692f, 0.02010744f, 0.05724971f, -0.01443258f, -0.03769665f, 0.02281026f, 
    0.01232022f, 0.01667048f, 0.10273143f, 0.04228366f, -0.09412555f, -0.01323715f, -0.13769549f, 0.02133825f, 
    -0.26021609f, -0.00537912f, -0.32983068f, -0.37883598f, 0.17171907f, -0.05243194f, 0.11737500f, -0.04497479f, 
    0.00246552f, 0.01891230f, 0.12332961f, -0.05250063f, 0.06416727f, 0.04379452f, 0.04114950f, 0.02133305f, 
    -0.00022089f, 0.00700835f, -0.03367192f, 0.00105611f, -0.22888827f, -0.24238467f, 0.02913797f, -0.08131099f, 
    -0.05569864f, 0.01369858f, -0.02366989f, 0.13781761f, -0.01337968f, 0.09717509f, -0.07710546f, -0.06085325f, 
    0.14201884f, 0.00038400f, 0.00591747f, -0.07284029f, 0.05778243f, 0.00067633f, -0.09585305f, 0.02424418f, 
    0.21119180f, -0.23346680f, 0.06055601f, -0.02517921f, -0.08520143f, -0.03115458f, 0.04203118f, 0.04511790f, 
    0.03797127f, 0.05152621f, -0.04779964f, -0.06632913f, 0.03801304f, -0.02487876f, -0.06173496f, 0.03093529f, 
    -0.00783198f, 0.03240118f, -0.00847725f, 0.09411471f, 0.10998011f, -0.07325871f, -0.09915470f, -0.02152770f, 
    -0.06559123f, 0.08021598f, -0.02947045f, -0.00015012f, -0.01271681f, 0.03183192f, 0.00318798f, -0.08056354f, 
    0.06125877f, 0.01257728f, 0.00375990f, 0.00423743f, -0.00801822f, 0.00904477f, -0.05193199f, -0.07168107f, 
    0.26312149f, 0.04295408f, 0.10604781f, -0.05738579f, 0.04920621f, -0.01999238f, -0.01066332f, -0.02325834f, 
    0.00548622f, -0.01388779f, 0.05703976f, 0.01043417f, -0.06684943f, 0.13278933f, 0.03772733f, -0.08346011f, 
    0.08516115f, 0.03315770f, 0.00293560f, -0.02714792f, -0.12067923f, 0.08371711f, 0.13904421f, 0.03340630f, 
    0.09698164f, -0.01254298f, -0.00458216f, -0.01210143f, -0.02804432f, 0.01870958f, 0.05487938f, 0.02389663f, 
    0.02379703f, 0.00455777f, -0.05822573f, -0.04961210f, 0.01213593f, -0.01345514f, 0.04215925f, 0.13944143f, 
    -0.00395407f, -0.07730344f, 0.10610019f, -0.05611731f, -0.10766946f, 0.07737208f, 0.01877502f, -0.01205159f, 
    -0.00079897f, -0.08868553f, 0.04396768f, -0.00314944f, 0.05797673f, -0.02464319f, -0.00042296f, -0.02557254f, 
    0.03419523f, -0.14813524f, -0.06217038f, 0.03424081f, -0.04278953f, 0.16333826f, 0.07281607f, -0.02863795f, 
    -0.04586567f, -0.06459923f, -0.00852671f, 0.05857076f, -0.02552045f, -0.01225140f, 0.14886896f, -0.01683061f, 
    0.14053394f, 0.00491677f, 0.00346013f, -0.04075921f, -0.06429455f, -0.13914786f, -0.02836427f, -0.00822774f, 
    -0.06018690f, 0.20686159f, 0.00763805f, -0.00153191f, -0.15560973f, 0.12385552f, 0.05218109f, 0.00316357f, 
    0.07563365f, -0.03794032f, -0.07999199f, -0.01513131f, -0.07574362f, 0.03836928f, -0.03875259f, 0.12344998f, 
    0.03690323f, 0.07267565f, 0.07766603f, 0.09229740f, 0.16636500f, 0.10716571f, -0.05577213f, -0.19798635f, 
    0.11872441f, -0.02627742f, 0.04992894f, -0.04484359f, 0.00106314f, 0.03170604f, 0.04880147f, -0.00701178f, 
    0.03013872f, 0.05190334f, 0.10822778f, -0.05863966f, 0.05466030f, 0.02371132f, -0.05157997f, 0.05653225f, 
    0.12445895f, 0.04377428f, 0.09837329f, -0.09582963f, -0.05683229f, -0.02135900f, -0.01556855f, -0.08799165f, 
    0.03315639f, -0.04264925f, -0.01044976f, -0.00034209f, -0.03427839f, -0.14137368f, 0.03676013f, -0.01327683f, 
    -0.05787288f, 0.12824531f, -0.02038619f, 0.02343358f, -0.08555938f, -0.20283866f, 0.07394644f, -0.14815907f, 
    0.10060718f, -0.00761016f, -0.12157306f, 0.01491413f, -0.03276521f, -0.10278932f, -0.04584821f, -0.10347966f, 
    0.05384148f, -0.04783769f, -0.01072769f, 0.00509896f, -0.03325298f, -0.05760892f, 0.01335019f, -0.10362498f, 
    0.01708100f, -0.23155983f, 0.06029207f, 0.01581939f, 0.11334307f, 0.00124575f, -0.07660113f, -0.09089115f, 
    -0.07399177f, -0.07358251f, -0.07896908f, 0.09073462f, -0.12541290f, -0.03128127f, -0.03425959f, -0.01139058f, 
    -0.01268843f, -0.06952246f, 0.05824526f, 0.02752334f, 0.15044799f, 0.11634879f, -0.09859599f, 0.07529886f, 
    -0.21604928f, -0.02405018f, 0.01213740f, 0.01088239f, -0.05909883f, 0.05131310f, 0.02872081f, 0.04617454f, 
    -0.09206104f, 0.06688055f, 0.01310750f, 0.05039578f, 0.09537997f, 0.01649486f, 0.03288719f, -0.02611577f, 
    0.38416016f, -0.12358858f, -0.16881716f, 0.05962035f, -0.03846867f, 0.01058266f, 0.08502812f, 0.02365896f, 
    0.06811531f, 0.05283687f, 0.03935711f, -0.03046074f, 0.00775593f, -0.02082044f, 0.05329894f, 0.07941799f, 
    -0.03524867f, 0.03115527f, -0.10384117f, 0.06089266f, -0.12290709f, -0.01100494f, -0.17941779f, -0.11651668f, 
    -0.10916587f, 0.05161523f, 0.06757257f, 0.03355808f, -0.02461771f, 0.04270172f, -0.04821252f, -0.08836854f, 
    0.06105992f, -0.05433716f, -0.08115590f, 0.02148625f, 0.02060733f, 0.01119094f, -0.09216326f, 0.01544472f, 
    0.19015603f, 0.03414774f, 0.02701767f, 0.13403471f, 0.27197084f, 0.00257360f, -0.08196902f, 0.02817586f, 
    -0.04132207f, -0.00650969f, 0.18494917f, -0.01504444f, -0.03538568f, 0.02016095f, -0.04806453f, -0.05955359f, 
    0.08649497f, -0.02715745f, -0.02653699f, 0.01519891f, 0.07748757f, 0.15310252f, -0.01366881f, 0.12495808f, 
    0.03973407f, -0.01024785f, -0.00446033f, 0.06895970f, 0.01004833f, 0.05805858f, -0.03719615f, 0.00375990f, 
    -0.16349746f, 0.05319166f, -0.10839550f, 0.06052728f, -0.12673897f, 0.06515843f, 0.00042442f, -0.04746131f, 
    -0.15288365f, -0.13649046f, 0.06968073f, -0.17108388f, 0.03017091f, -0.09715474f, -0.01368404f, 0.01157226f, 
    0.02867383f, 0.02754550f, 0.03748812f, 0.03956647f, -0.05689355f, -0.02538612f, -0.03975392f, 0.02676845f, 
    -0.13582747f, 0.02425387f, -0.00822327f, -0.09234972f, 0.12423415f, -0.12915593f, -0.11481052f, 0.04059343f, 
    -0.03215630f, -0.12734371f, 0.00938130f, -0.02997882f, 0.02669341f, 0.07717529f, 0.01446116f, -0.05278131f, 
    0.04554423f, -0.00253434f, 0.00343364f, 0.15868542f, 0.10700201f, 0.02124120f, -0.05762772f, 0.03617163f, 
    -0.54810381f, -0.06141176f, -0.02027464f, -0.04374135f, -0.26213941f, -0.14508334f, 0.00515512f, -0.01554430f, 
    0.05478968f, -0.03281776f, 0.01204446f, -0.01698338f, -0.00275444f, -0.04100416f, 0.08826543f, -0.12867722f, 
    0.01724721f, -0.10163421f, -0.05631517f, 0.10028502f, 0.27423918f, -0.13502325f, 0.05398392f, -0.04525548f, 
    -0.03769701f, 0.00723977f, 0.00545263f, -0.00647304f, -0.09566259f, -0.00700383f, 0.01176236f, -0.08942999f, 
    0.06818625f, -0.03282418f, 0.04627897f, 0.03897879f, -0.01389932f, -0.03174759f, 0.09175126f, 0.11426582f, 
    0.12999776f, -0.17629220f, -0.17341048f, 0.03796634f, -0.10206518f, -0.00272153f, -0.00190045f, 0.00989133f, 
    -0.05389190f, 0.09502725f, 0.05314478f, 0.03019748f, -0.04735199f, -0.02921034f, 0.06250556f, 0.01705818f, 
    0.03584461f, -0.02286815f, -0.13436605f, 0.07686644f, 0.20316975f, 0.01966431f, 0.12077658f, 0.06755774f, 
    0.16537318f, -0.10190402f, -0.06898512f, 0.05896045f, -0.03905238f, -0.04675461f, -0.12495363f, -0.05665656f, 
    -0.01559608f, 0.02526295f, -0.10970858f, -0.04596160f, 0.10897990f, 0.03255351f, -0.03998180f, -0.00914708f, 
    0.08957386f, -0.11058164f, 0.03544097f, -0.00508700f, 0.16002773f, 0.01240214f, -0.10131503f, 0.07969145f, 
    -0.05486408f, -0.01885386f, -0.08077070f, 0.04245048f, 0.04627013f, 0.04098660f, -0.00254197f, -0.00937058f, 
    -0.07202160f, -0.07733417f, -0.04490948f, -0.01847446f, 0.21513365f, 0.23176412f, 0.11568120f, 0.12561138f, 
    0.15700643f, -0.08583444f, 0.01847192f, 0.00563091f, 0.00784944f, 0.00944814f, 0.00806661f, 0.04109789f, 
    -0.02895200f, 0.00451622f, -0.03708882f, -0.03139425f, 0.03494053f, 0.07793508f, 0.01024910f, -0.01694879f, 
    0.07156853f, -0.01848471f, 0.09125872f, 0.00156822f, 0.06360138f, -0.02595624f, 0.00653061f, 0.02064784f, 
    0.00942756f, 0.05030354f, 0.08184801f, 0.00963446f, 0.02770728f, -0.05613345f, 0.03143920f, -0.06315568f, 
    -0.00317184f, -0.00965040f, 0.02721315f, 0.05073205f, 0.24329072f, -0.12484519f, -0.28516537f, -0.07143109f, 
    -0.07110357f, -0.02874869f, -0.07676526f, 0.02608548f, 0.04356326f, -0.00497218f, -0.00399399f, 0.08543862f, 
    0.05020538f, 0.02210434f, 0.08143040f, -0.03440451f, -0.07889500f, -0.14199530f, -0.05715527f, -0.08643256f, 
    -0.21163267f, -0.04430895f, -0.05778937f, -0.08580984f, 0.08351201f, 0.08000322f, -0.07990785f, 0.11163376f, 
    0.01813509f, 0.03685714f, -0.01506777f, 0.03759258f, 0.08392775f, -0.04293261f, 0.11282156f, -0.05579109f, 
    0.01768386f, -0.15866743f, 0.00255935f, -0.10264113f, 0.18894432f, -0.03499721f, -0.10684027f, -0.01523172f, 
    -0.18839769f, 0.04200770f, 0.00549970f, 0.00894928f, 0.00660205f, 0.08060980f, 0.07356784f, 0.02630053f, 
    0.00776205f, 0.04977888f, -0.07404707f, 0.05112627f, 0.04598579f, 0.00303971f, -0.04642219f, 0.04758606f, 
    -0.31126344f, 0.15335864f, -0.06576428f, -0.01324084f, 0.08416254f, -0.08194396f, 0.09471155f, -0.08486578f, 
    -0.05018743f, -0.05833809f, 0.07938248f, -0.03083759f, -0.06872302f, -0.05625246f, 0.05688854f, 0.09217635f, 
    0.04814250f, -0.06623201f, -0.00046403f, 0.09085358f, 0.01714186f, 0.04368432f, -0.04101105f, -0.00245086f, 
    0.03837224f, 0.01422727f, -0.03366137f, -0.02538540f, -0.07168920f, 0.10482673f, -0.00941253f, 0.13464057f, 
    -0.02946798f, -0.03556556f, 0.03510271f, -0.03043399f, -0.08485497f, -0.00265995f, 0.02677341f, 0.03253281f, 
    0.09779455f, 0.09944843f, 0.12235390f, 0.13041559f, 0.12879115f, 0.03038532f, -0.09199876f, 0.02774033f, 
    -0.01581390f, 0.05806786f, -0.00729696f, -0.01902152f, -0.00391188f, 0.04013784f, -0.07427851f, -0.02406120f, 
    0.05801350f, 0.07246152f, 0.08478472f, 0.04118029f, -0.31819692f, 0.12472764f, -0.01692517f, -0.08692242f, 
    0.08884882f, -0.06634519f, 0.13424268f, -0.04338029f, -0.03898967f, 0.05610781f, -0.03249443f, 0.06405659f, 
    0.05430602f, -0.03691515f, -0.02012648f, 0.06351029f, -0.09384871f, 0.08493314f, -0.00904788f, 0.06783990f, 
    0.03314595f, -0.26230475f, 0.01606495f, -0.11990224f, -0.01139160f, -0.00901625f, -0.03085187f, -0.03833120f, 
    -0.06290966f, 0.00855870f, -0.07031862f, 0.01185940f, -0.04810055f, -0.00727299f, -0.00329237f, -0.04348612f, 
    0.01133058f, -0.07288246f, -0.01324444f, -0.02089198f, -0.16303025f, -0.07401273f, -0.23240733f, -0.01382100f, 
    -0.09734062f, 0.06860747f, -0.06162180f, 0.00697308f, 0.08617941f, 0.01873616f, 0.04374367f, 0.12303959f, 
    -0.00895353f, -0.16097149f, 0.03934555f, -0.04131017f, -0.03334049f, -0.03121400f, -0.00502266f, -0.00083393f, 
    -0.14654000f, 0.17133957f, 0.09925774f, 0.02294031f, -0.20985560f, 0.01182613f, 0.00290693f, 0.01667231f, 
    -0.01642516f, 0.11971235f, 0.10471543f, 0.02156385f, 0.05161352f, -0.02154773f, -0.02058447f, -0.00875091f, 
    -0.01966440f, 0.00412168f, 0.04011020f, 0.05246358f, 0.07002164f, -0.11943980f, 0.03103948f, -0.16141751f, 
    0.01064303f, -0.00600826f, -0.05133804f, 0.03423959f, -0.02034274f, 0.00811412f, -0.04640619f, 0.03723317f, 
    -0.03278349f, 0.07479400f, -0.15728949f, -0.10858383f, -0.04257947f, -0.06373225f, 0.05986855f, 0.13431698f, 
    0.24731070f, -0.51195866f, 0.05435786f, -0.27123573f, -0.09164149f, -0.07157017f, -0.12355350f, -0.11507249f, 
    -0.00544852f, -0.04991451f, -0.03142842f, 0.06061867f, -0.13891684f, 0.00454138f, -0.01891135f, -0.14129432f, 
    -0.04470553f, 0.01693125f, 0.01094604f, 0.00654749f, 0.20091872f, 0.12436351f, 0.09060433f, -0.02248840f, 
    0.02594405f, -0.04706111f, -0.05657468f, -0.00608148f, -0.01810657f, -0.00896350f, 0.02186087f, -0.00784582f, 
    0.04757206f, 0.08530659f, 0.05575100f, -0.06378002f, 0.08130319f, -0.03912752f, 0.00566291f, -0.01187051f, 
    -0.12471272f, 0.06660514f, -0.04852317f, -0.06498151f, -0.01919111f, 0.01326868f, -0.00397586f, -0.00629343f, 
    -0.00221514f, -0.03422873f, -0.03395852f, 0.04372034f, 0.01629972f, -0.01390123f, 0.00043627f, -0.10182562f, 
    0.00102527f, 0.04132068f, -0.04549120f, -0.02346645f, 0.19519737f, 0.17866060f, -0.02412810f, 0.00577716f, 
    -0.08883365f, 0.02020232f, 0.08662765f, -0.03099847f, -0.04380443f, -0.05878722f, -0.05426436f, 0.01660326f, 
    -0.02175169f, -0.00350531f, -0.05284861f, 0.01836425f, 0.02162460f, -0.09383348f, 0.04529436f, -0.01405319f, 
    0.03129433f, 0.09531152f, -0.03242343f, 0.01608371f, -0.01500004f, 0.00253223f, 0.09094312f, 0.03022021f, 
    -0.00500199f, -0.08400901f, 0.00557573f, 0.00798416f, -0.01015635f, 0.00242952f, -0.02737758f, -0.00993329f, 
    -0.05716340f, 0.00368265f, 0.03377840f, 0.00941819f, 0.40935206f, -0.10695019f, -0.18723856f, -0.07807495f, 
    -0.09937719f, -0.02850435f, -0.05697326f, 0.02692345f, 0.01733549f, -0.03514943f, -0.00219213f, 0.01865014f, 
    0.01078617f, 0.05058770f, 0.01079189f, 0.08158220f, -0.06906471f, -0.03109849f, 0.07109889f, -0.05166604f, 
    -0.06410692f, -0.16527261f, -0.13106218f, -0.02411792f, -0.14073169f, -0.06789581f, 0.00288109f, -0.09061408f, 
    0.02600535f, -0.05523290f, 0.01734043f, 0.01942374f, 0.03596344f, 0.06407601f, 0.00628573f, 0.01685898f, 
    -0.04470621f, 0.07878663f, 0.06481731f, -0.02057431f, -0.19287843f, -0.19382948f, 0.04346653f, -0.06696697f, 
    -0.13006434f, -0.03825262f, -0.07895352f, -0.02755816f, -0.04852944f, 0.03205163f, -0.01981579f, -0.01331506f, 
    0.00855748f, -0.02595226f, -0.03634440f, -0.01112918f, -0.00611963f, 0.03419119f, -0.09721550f, 0.04792379f, 
    0.07938305f, -0.28323483f, -0.09256629f, -0.03833627f, -0.14092292f, 0.06488415f, -0.10401147f, 0.03866403f, 
    0.05588372f, 0.01772171f, -0.02966901f, 0.01407948f, 0.00959147f, -0.04365302f, -0.03943528f, 0.03475048f, 
    -0.00867334f, 0.00548070f, -0.06075963f, -0.08203982f, -0.09938163f, -0.30600432f, -0.09102994f, -0.02579580f, 
    -0.16174248f, -0.09571153f, 0.00469270f, -0.01501042f, -0.00686787f, -0.07520875f, -0.01478985f, 0.04643629f, 
    0.00976686f, -0.04296641f, 0.06013682f, 0.02262118f, -0.07635956f, 0.01613004f, 0.00802948f, 0.04873404f, 
    -0.06702104f, 0.02328153f, -0.16873486f, -0.05068811f, 0.02426685f, 0.03651046f, 0.15737487f, 0.10493383f, 
    -0.06586644f, -0.04260671f, -0.01995075f, 0.03571714f, -0.00049266f, -0.00513457f, -0.06175218f, 0.00295766f, 
    0.05009283f, 0.07181506f, -0.10817524f, 0.02467448f, 0.28972748f, -0.18278615f, 0.00225303f, 0.01866289f, 
    0.06515993f, -0.06534857f, 0.03033748f, -0.05173611f, 0.05430013f, -0.01507752f, 0.04191611f, -0.00876929f, 
    0.00213411f, 0.04847648f, -0.06090055f, -0.02527676f, -0.00825285f, 0.02945299f, -0.00999882f, -0.02134439f, 
    0.26955622f, -0.01519100f, 0.06864490f, 0.01539645f, -0.01660159f, -0.00574802f, -0.00457988f, 0.06948862f, 
    -0.03712808f, -0.01516920f, -0.02215417f, -0.03718751f, -0.01571427f, -0.00211851f, -0.02148005f, 0.03148035f, 
    0.00711071f, 0.02081388f, 0.01185165f, 0.00566788f, -0.01880286f, 0.00753904f, -0.09363442f, 0.02674566f, 
    -0.05580649f, 0.00973037f, -0.04391941f, 0.03134774f, -0.03126103f, 0.05907760f, -0.04025350f, -0.06125279f, 
    -0.00921788f, 0.00328740f, -0.05148354f, -0.00921561f, -0.02816292f, 0.01556409f, -0.09275377f, -0.02053320f, 
    0.03727986f, -0.01250584f, -0.10683474f, 0.04187820f, 0.07251211f, -0.02372912f, 0.03059576f, -0.06511284f, 
    -0.07325306f, -0.00489287f, 0.02050637f, -0.03565811f, -0.01564339f, -0.00461571f, 0.01451943f, -0.00804049f, 
    -0.02647934f, -0.01160009f, -0.02970466f, -0.01414010f, -0.17447230f, 0.03396562f, 0.09772458f, -0.00627935f, 
    0.02074617f, -0.03639131f, -0.11030903f, 0.01800363f, 0.04829616f, 0.07660676f, 0.03280007f, -0.07756902f, 
    -0.03003370f, -0.00219177f, -0.05658502f, 0.01252563f, -0.04541617f, -0.03648928f, -0.03491640f, -0.01750598f, 
    0.18780816f, 0.05602384f, -0.03298150f, 0.06539848f, -0.03065080f, -0.00867596f, 0.04143031f, 0.03283528f, 
    -0.01743332f, 0.04262009f, 0.02588767f, 0.05128745f, 0.03116116f, -0.02513336f, 0.01088034f, 0.11198533f, 
    -0.08134247f, -0.06573490f, 0.07212788f, -0.05439899f, 0.01596299f, -0.00436686f, 0.14994036f, -0.06580875f, 
    0.08436041f, -0.02463736f, -0.05194069f, -0.02030163f, 0.02223195f, 0.03800765f, 0.00206897f, 0.00897432f, 
    -0.00238046f, -0.04654377f, -0.02217912f, -0.00898289f, -0.02076384f, -0.03231058f, 0.02893396f, 0.06567980f, 
    -0.26534152f, -0.19265746f, -0.09350263f, -0.13070086f, -0.19495647f, 0.01021505f, 0.00122658f, 0.00944879f, 
    -0.00827057f, 0.00179859f, 0.00156719f, 0.03873659f, -0.01248645f, -0.01395266f, -0.03952456f, -0.01479005f, 
    0.01072214f, 0.06960773f, -0.02556324f, -0.05232840f, 0.18087845f, -0.05875337f, 0.05959150f, -0.03084453f, 
    0.16969895f, -0.21288066f, -0.06048651f, -0.02467545f, 0.00590098f, 0.02383491f, 0.00697367f, -0.00767971f, 
    0.00626264f, -0.07048225f, 0.05192105f, -0.00805638f, 0.02939376f, -0.01626148f, 0.07191961f, 0.02401819f, 
    -0.06566715f, -0.06077395f, -0.09020174f, -0.04084664f, -0.08860758f, -0.02247187f, -0.00207293f, -0.00873622f, 
    -0.03202111f, -0.00871586f, -0.02598666f, -0.02310038f, 0.01974013f, 0.04046481f, 0.02031253f, -0.02767199f, 
    -0.00442499f, 0.01090430f, -0.07283703f, -0.05456605f, 0.17350338f, 0.03701304f, -0.01707715f, 0.00827698f, 
    -0.03693785f, -0.04368928f, 0.02798412f, 0.03081361f, -0.00901091f, -0.02569764f, -0.00232832f, 0.01724743f, 
    -0.00651992f, 0.05128509f, 0.04027955f, -0.07966794f, 0.01649018f, -0.10226689f, 0.01033227f, -0.04890852f, 
    0.03089810f, 0.08619359f, 0.06185240f, -0.05014502f, -0.02016414f, 0.02007113f, 0.02424537f, 0.09595481f, 
    -0.04216093f, -0.02947657f, -0.05227263f, 0.08118457f, 0.02230191f, -0.04993797f, 0.02407803f, -0.01073211f, 
    -0.09184501f, 0.01453581f, 0.05428932f, -0.04307695f, -0.18107808f, -0.04994790f, 0.12411726f, -0.11103969f, 
    -0.02522194f, -0.01479151f, -0.14804541f, -0.18979831f, -0.01566366f, 0.09675688f, -0.09737191f, 0.04157594f, 
    -0.04806755f, -0.04467919f, 0.01960570f, 0.00540026f, -0.02834348f, 0.10420106f, -0.01756725f, 0.07326388f, 
    0.11413132f, -0.27475488f, -0.05842248f, -0.09333523f, -0.09153323f, 0.07569617f, 0.04298622f, 0.06749092f, 
    -0.06346850f, 0.01474612f, -0.05147671f, -0.01951946f, -0.01670075f, 0.02552904f, -0.06644706f, 0.00669934f, 
    -0.08851545f, 0.00529010f, 0.01625643f, -0.01642638f, 0.02907892f, 0.13780154f, 0.04830334f, -0.17130092f, 
    -0.08588642f, 0.04179931f, 0.04465292f, 0.08470216f, -0.09526914f, -0.02274478f, -0.05003053f, 0.01271808f, 
    -0.01935493f, -0.11828288f, -0.03319459f, 0.01161525f, 0.00848464f, 0.01820262f, 0.02768413f, -0.03577653f, 
    0.13536286f, 0.03088006f, -0.14706720f, -0.21418124f, -0.07449824f, 0.02516249f, 0.02564828f, 0.01958407f, 
    -0.10828615f, -0.01057685f, -0.07838237f, -0.01126396f, 0.02164888f, 0.00130622f, 0.10258588f, -0.01636279f, 
    -0.04834568f, -0.01080766f, -0.04740835f, -0.01228194f, 0.14410225f, 0.12298977f, -0.17821564f, -0.08727180f, 
    -0.19847965f, 0.13478421f, 0.01735057f, -0.11848853f, 0.02969220f, -0.00498085f, -0.01690539f, 0.00064340f, 
    -0.01181595f, -0.04750183f, -0.08053470f, -0.02188556f, -0.01677568f, 0.02421365f, 0.03543040f, -0.11230972f, 
    -0.20177224f, -0.13678698f, 0.13238031f, -0.19856703f, 0.00400990f, -0.12742801f, -0.01107640f, 0.01725777f, 
    0.07554381f, -0.00957015f, 0.03796816f, 0.00341845f, -0.04876010f, 0.07464716f, 0.02102758f, -0.02032888f, 
    0.05851636f, -0.01381058f, -0.05066188f, -0.06580965f, 0.23611243f, -0.18577020f, -0.00825718f, -0.00035544f, 
    -0.16459380f, -0.03431241f, 0.05216261f, -0.06834313f, 0.04978179f, 0.01259903f, -0.06835625f, -0.01799391f, 
    0.00990352f, 0.01005776f, -0.02969021f, 0.01748595f, -0.01663371f, 0.00496840f, 0.06716028f, -0.03887780f, 
    0.19317803f, -0.03611572f, 0.01646170f, -0.06821618f, -0.01970870f, 0.01145047f, -0.05287001f, 0.08177841f, 
    0.01409475f, 0.04561386f, -0.02317790f, 0.00895585f, 0.10747159f, -0.03490076f, -0.03650754f, -0.00251373f, 
    -0.03000635f, -0.02839902f, -0.00750194f, -0.06578963f, 0.00194017f, 0.03183575f, 0.03603293f, -0.00642685f, 
    0.00223354f, -0.02019975f, 0.04952988f, 0.02091563f, -0.05170741f, -0.01148999f, 0.03495027f, 0.02359972f, 
    -0.01369446f, -0.02341229f, -0.00314726f, 0.06093219f, -0.03584844f, -0.07348364f, -0.03276168f, 0.03149337f, 
    -0.38647407f, 0.10201485f, 0.09046296f, -0.18564411f, 0.05565638f, 0.00257560f, 0.10462455f, -0.01148271f, 
    0.07038841f, -0.04134426f, 0.03391180f, -0.02733297f, 0.04807600f, -0.08700876f, -0.04152742f, 0.10058625f, 
    -0.00791312f, -0.00309235f, 0.11278670f, -0.06839757f, -0.45136714f, 0.15373257f, -0.06660804f, -0.14896457f, 
    0.09135177f, 0.01806111f, 0.08102822f, -0.03293752f, 0.04155977f, -0.02675692f, -0.04970642f, -0.00229353f, 
    -0.03645306f, -0.04352151f, 0.03331535f, -0.01677309f, 0.05449824f, 0.01549773f, 0.00780830f, -0.03043998f, 
    0.12919791f, 0.00997473f, -0.03443553f, 0.05669199f, 0.07809354f, -0.02196130f, 0.03462581f, -0.05967879f, 
    -0.04110239f, -0.03510939f, 0.01050246f, 0.01322018f, -0.00544065f, 0.04293280f, 0.00868462f, 0.06548138f, 
    0.01720385f, -0.04860678f, -0.04955512f, -0.01116555f, 0.03654457f, 0.07917280f, -0.06236521f, -0.15865798f, 
    -0.01141046f, 0.03681550f, 0.02290174f, 0.05876325f, -0.13111706f, -0.01570933f, -0.04469416f, -0.03783392f, 
    0.03717806f, -0.04246105f, -0.00833181f, -0.02945169f, -0.06322449f, 0.03546967f, -0.05789198f, -0.01627644f, 
    0.13393833f, 0.05100600f, 0.01428100f, 0.03510184f, -0.05316999f, -0.03382642f, -0.02476868f, 0.06551725f, 
    0.02052002f, 0.05618609f, -0.01162492f, 0.00497724f, 0.03035967f, 0.05549854f, -0.01952937f, -0.04611957f, 
    -0.01633739f, -0.07218520f, -0.01691235f, -0.02915527f, -0.28669551f, -0.19973707f, 0.12226486f, -0.17415997f, 
    -0.16592988f, 0.01496209f, -0.02448486f, -0.05346451f, -0.00765316f, 0.06690844f, -0.04170344f, 0.12645726f, 
    -0.02208924f, -0.06661026f, 0.01508463f, 0.09205997f, 0.01108498f, -0.03275352f, -0.04774865f, -0.08156292f, 
    0.18837854f, -0.10826644f, 0.14816062f, -0.07447735f, 0.07705806f, 0.08348874f, -0.11812709f, -0.00196861f, 
    0.02751471f, 0.13785206f, 0.01237503f, -0.10254207f, 0.06443713f, 0.02899341f, -0.02427739f, -0.08770154f, 
    -0.12263390f, -0.01878830f, -0.09080706f, -0.05592289f, 0.17496522f, -0.02507109f, 0.12873752f, 0.14416492f, 
    0.22441599f, -0.11661699f, -0.06215893f, -0.14544216f, 0.04309279f, 0.10415426f, 0.10474899f, 0.00373528f, 
    -0.05082554f, -0.05171519f, -0.01313108f, -0.00212176f, -0.09748816f, -0.05631880f, 0.01152270f, 0.03050560f, 
    0.29744828f, -0.13795055f, 0.11855213f, 0.12817152f, -0.14814930f, -0.09228142f, -0.01148525f, -0.00018408f, 
    -0.01557443f, 0.05567917f, -0.01691617f, 0.03480695f, 0.05661893f, 0.10230519f, 0.00929164f, 0.00752923f, 
    -0.10532111f, -0.06021267f, 0.03147716f, 0.03962682f, 0.16431156f, -0.05215050f, -0.28202549f, 0.03233086f, 
    -0.09877063f, -0.00585906f, 0.03340107f, -0.02175410f, -0.06994142f, -0.05830489f, -0.05881682f, -0.01540034f, 
    -0.01100918f, -0.02945568f, 0.02386239f, -0.02396447f, 0.02626604f, 0.00455352f, 0.00703418f, -0.05927415f, 
    -0.16877760f, 0.25696272f, -0.05396060f, -0.19200000f, 0.07718572f, 0.00088979f, 0.04850455f, 0.00464986f, 
    0.04763938f, -0.12276055f, -0.03376871f, 0.04289727f, -0.05901612f, -0.03460873f, 0.00085543f, 0.01022447f, 
    0.02489910f, -0.01038745f, 0.05549474f, -0.01358747f, -0.10597265f, 0.03121332f, -0.11057690f, -0.05627454f, 
    0.00638067f, 0.06111116f, -0.02795923f, 0.03008640f, 0.03573662f, -0.02607674f, 0.00901182f, -0.00195669f, 
    0.02186185f, -0.02174119f, 0.01032596f, -0.08651373f, -0.02132326f, -0.02561374f, -0.06172078f, -0.02331709f, 
    0.24786055f, 0.03248439f, -0.13641076f, 0.08741730f, -0.24623097f, -0.01747056f, -0.04663863f, 0.11828507f, 
    0.06922505f, 0.06588867f, 0.04936033f, 0.03584493f, -0.01480698f, -0.05156729f, -0.07208536f, -0.07124481f, 
    0.02044674f, 0.04736200f, 0.04791332f, 0.02744380f, 0.26147807f, -0.08764274f, 0.09708796f, -0.11241193f, 
    -0.05941321f, -0.04941514f, 0.02988508f, -0.06658785f, 0.02928318f, 0.00411617f, 0.03727258f, -0.07505127f, 
    0.03292982f, -0.04942697f, 0.01332884f, -0.01711975f, 0.04260879f, 0.05961551f, 0.05831490f, -0.03601549f, 
    0.22930759f, -0.09897389f, -0.13816409f, 0.06878119f, -0.13585497f, -0.10992954f, 0.07313789f, -0.03268621f, 
    0.03738420f, -0.03084328f, 0.04629407f, -0.08737043f, -0.01935668f, -0.04798579f, -0.02143742f, 0.02000071f, 
    0.03852974f, 0.07379381f, 0.08295151f, -0.08489797f, -0.19983687f, -0.10831351f, 0.09646813f, -0.11286842f, 
    0.02176453f, 0.01147509f, 0.00003724f, 0.00558602f, 0.03697759f, 0.01245314f, 0.03058796f, -0.01200072f, 
    -0.01956200f, -0.04677854f, -0.00721006f, 0.01787125f, -0.05569932f, -0.05059239f, -0.08212179f, -0.01310309f, 
    0.23950547f, -0.08081889f, -0.02056528f, 0.01023687f, 0.12029731f, -0.05834424f, -0.00604715f, -0.08059605f, 
    0.03210820f, 0.03842038f, 0.02794931f, -0.00201557f, 0.03276212f, 0.06711929f, -0.00090046f, -0.00227637f, 
    0.00739705f, 0.06122452f, -0.02220945f, -0.02179874f, 0.09356239f, -0.00076107f, 0.09715321f, -0.14233725f, 
    0.14886227f, 0.08357716f, -0.03223881f, 0.06383490f, 0.08657717f, -0.06240778f, -0.04622380f, 0.05702784f, 
    0.01969315f, -0.00751951f, -0.03155303f, -0.03878967f, -0.03459682f, 0.01984954f, -0.06197929f, -0.05055999f, 
    0.01848351f, 0.04477475f, -0.05224545f, -0.04168449f, 0.05305574f, 0.03021473f, -0.01427734f, 0.13560213f, 
    -0.03439618f, -0.05277762f, -0.05363006f, 0.06396029f, -0.04609474f, -0.06591019f, 0.00212046f, 0.01435688f, 
    0.01627070f, 0.06737942f, -0.05856854f, -0.02649265f, -0.04621479f, -0.03405355f, 0.09497491f, -0.07443398f, 
    -0.05067855f, 0.04762421f, -0.04073096f, 0.08079844f, 0.04707246f, 0.01136908f, -0.05665711f, 0.00541154f, 
    0.02623639f, 0.05557700f, -0.05878511f, -0.12376606f, -0.05299703f, -0.03324758f, -0.04822582f, -0.03203780f, 
    -0.13102747f, -0.03398751f, 0.07765333f, -0.02649601f, 0.00104197f, 0.03638238f, 0.02992398f, 0.04934905f, 
    0.00709107f, -0.02960609f, -0.03986605f, 0.01201717f, 0.01721266f, 0.01993045f, -0.04780445f, -0.06180690f, 
    -0.04121390f, 0.02019233f, -0.10093947f, -0.03788975f, -0.01657741f, -0.20426446f, -0.00411680f, -0.16076386f, 
    -0.36233652f, -0.00843395f, 0.02574838f, 0.01877892f, -0.06480137f, 0.03038499f, -0.01394682f, 0.04060186f, 
    -0.02239780f, -0.03990098f, -0.01751423f, -0.01319832f, -0.06013854f, 0.10840544f, 0.03433586f, -0.01282555f, 
    -0.06156046f, -0.18579942f, -0.01214425f, -0.19505961f, -0.16199507f, 0.07683791f, 0.00140691f, -0.01187562f, 
    0.06342579f, -0.00209547f, -0.02045329f, 0.03441973f, -0.09238829f, -0.02036157f, -0.02962385f, -0.03043717f, 
    -0.08595864f, 0.04761925f, 0.07158973f, -0.02073849f, 0.18696077f, 0.02770690f, 0.16896778f, 0.14178085f, 
    0.19408093f, -0.11695397f, -0.07501971f, -0.06970985f, 0.05766207f, 0.04003398f, 0.05010684f, -0.03610134f, 
    -0.03928087f, -0.01574303f, -0.02983245f, -0.03612073f, -0.01124841f, -0.06222412f, -0.00747032f, 0.01858388f, 
    0.23021229f, 0.08544371f, 0.16089627f, -0.05830397f, 0.17288394f, 0.07533924f, -0.00450974f, -0.05749439f, 
    0.02519414f, 0.06484583f, -0.01066098f, -0.00869693f, -0.02278733f, 0.04810915f, -0.02805716f, -0.01893602f, 
    -0.09869003f, 0.01826808f, -0.05689184f, -0.02991903f, 0.15078670f, -0.11264747f, 0.02847845f, 0.00693253f, 
    0.08409209f, 0.01664358f, 0.01138347f, 0.01555279f, 0.02106709f, -0.00685358f, -0.00390369f, 0.02062801f, 
    -0.00796294f, -0.03845708f, 0.04769059f, -0.01714737f, -0.01094883f, 0.00255180f, -0.07149310f, 0.00515633f, 
    -0.10922984f, 0.09423829f, 0.04893267f, -0.07693776f, 0.06267448f, 0.05837775f, -0.06969216f, 0.00302692f, 
    0.08805659f, 0.01137965f, 0.00508794f, -0.03925022f, 0.05690209f, 0.01597514f, 0.02151335f, 0.01337534f, 
    -0.03813009f, -0.10278342f, -0.01035055f, -0.04141100f, 0.27146226f, 0.02446795f, -0.17071652f, -0.00204989f, 
    0.03205374f, -0.00952435f, 0.00126052f, 0.00409203f, 0.03620235f, 0.02892176f, -0.02029856f, 0.02472267f, 
    -0.00869155f, -0.01996339f, 0.00545357f, -0.00445004f, -0.06377507f, -0.14627239f, -0.01550575f, -0.02616562f, 
    0.22852814f, -0.24781370f, 0.00891062f, -0.12380727f, -0.03018420f, 0.04018366f, -0.02546745f, 0.07632693f, 
    -0.04127688f, 0.02363954f, -0.00663721f, 0.01187539f, 0.09004252f, -0.00428727f, -0.06945293f, 0.03913210f, 
    -0.06844544f, 0.00134213f, 0.01710901f, 0.01834637f, 0.21065240f, -0.09752317f, 0.10528950f, 0.04691754f, 
    0.22241206f, -0.03454411f, -0.01444855f, -0.12045571f, 0.03561147f, 0.06083137f, 0.03053518f, -0.02643761f, 
    -0.03276477f, 0.06706654f, 0.01045935f, 0.02509084f, -0.04276071f, 0.01650796f, -0.03659921f, -0.02644487f, 
    -0.36389011f, 0.12035960f, -0.10163835f, -0.02480679f, -0.01187132f, -0.02838048f, 0.01501725f, -0.01842794f, 
    -0.01408472f, -0.06250787f, 0.03834196f, -0.05038349f, -0.01056043f, -0.00685071f, 0.06365528f, -0.00624090f, 
    0.00680335f, -0.00042210f, -0.04759363f, 0.02727809f, 0.02470759f, -0.13325007f, -0.17458402f, 0.03929704f, 
    -0.11430874f, -0.00338027f, -0.06461830f, -0.02471601f, 0.05642322f, 0.00614366f, 0.07572377f, 0.02436158f, 
    0.02126602f, 0.00286598f, 0.01135450f, 0.00381613f, -0.04690646f, 0.05893415f, -0.04668593f, -0.06852894f, 
    0.12303562f, -0.04432358f, -0.10158945f, 0.08108532f, -0.12697068f, 0.00915771f, -0.12612227f, 0.08705028f, 
    0.08371979f, 0.08212043f, 0.02506102f, 0.04183637f, -0.08082663f, 0.04833110f, 0.00045011f, -0.05506650f, 
    -0.05665982f, -0.00447311f, 0.05785655f, -0.02689716f, 0.16439328f, 0.01692081f, 0.00814313f, -0.15673573f, 
    0.02944112f, 0.02158316f, 0.00878470f, 0.06724307f, -0.07301375f, -0.02132292f, -0.03667385f, 0.03436404f, 
    0.04373164f, -0.04847927f, 0.01157555f, 0.00276811f, -0.00612611f, 0.05754655f, 0.01120745f, -0.06089670f, 
    0.04307788f, -0.20237266f, -0.08419927f, 0.00626257f, 0.09918058f, 0.03308316f, 0.01713514f, 0.00551796f, 
    -0.06412526f, 0.00433903f, 0.02473105f, 0.00816691f, 0.00837992f, 0.07316542f, -0.05113297f, 0.04883236f, 
    0.01732535f, 0.05294748f, -0.00377765f, -0.00005866f, -0.43400449f, 0.26304471f, -0.06037708f, 0.08488159f, 
    0.09038086f, 0.03066524f, 0.05461479f, -0.01360946f, 0.03598825f, -0.03264469f, -0.03584051f, -0.02803158f, 
    -0.01804673f, -0.07682657f, -0.00535285f, 0.04433395f, 0.05468971f, -0.05650698f, 0.00270049f, 0.00930682f, 
    -0.35008615f, -0.01979135f, -0.06389914f, 0.06150996f, -0.03425215f, -0.05719522f, -0.00445636f, 0.04308853f, 
    0.05525970f, -0.08275554f, -0.02024049f, -0.07130419f, 0.00992817f, -0.06588712f, 0.02607419f, 0.01276855f, 
    -0.02366142f, -0.03689744f, -0.05210354f, -0.03574601f, -0.18862048f, 0.23792113f, 0.12992640f, 0.12986033f, 
    0.05421029f, -0.03408521f, -0.04890104f, -0.00336573f, 0.04862861f, -0.00228560f, -0.00509155f, -0.06723356f, 
    0.07121284f, 0.01927995f, -0.05416012f, -0.04867838f, -0.02862596f, -0.03520871f, 0.11529814f, 0.04739695f, 
    0.01705172f, 0.08224955f, 0.08154085f, 0.07323456f, -0.03044496f, -0.09810016f, -0.09315746f, 0.02614849f, 
    -0.05544863f, 0.00431113f, 0.00648263f, -0.05057614f, 0.00269288f, -0.00710923f, 0.01727696f, 0.06209017f, 
    0.02892568f, 0.12686014f, 0.05238464f, -0.01177136f, 0.13331230f, 0.11826591f, -0.02114431f, -0.01777220f, 
    -0.09211078f, -0.04287213f, 0.03351318f, -0.03394106f, -0.03541833f, -0.00012715f, 0.01210352f, 0.00512204f, 
    -0.01642980f, -0.02118610f, -0.00669335f, -0.07744373f, 0.01886118f, 0.05523117f, -0.05358717f, 0.01278343f, 
    0.06092662f, 0.02505770f, 0.04877761f, 0.06247526f, 0.03444577f, -0.03025569f, 0.04306929f, 0.01729071f, 
    0.00054381f, 0.03207852f, 0.10430444f, -0.00765272f, -0.04024702f, -0.01927606f, 0.04556552f, -0.04813563f, 
    0.00974491f, -0.03314896f, -0.04090023f, 0.04363403f, -0.04180512f, 0.10185185f, 0.02853247f, -0.00778822f, 
    0.01475854f, -0.07490512f, -0.06601870f, 0.04295847f, -0.02583972f, -0.03081127f, 0.04856025f, -0.05794466f, 
    -0.02055796f, -0.01017463f, 0.04055335f, -0.04160931f, -0.00476162f, 0.11700096f, 0.12255475f, 0.01087032f, 
    -0.17804043f, -0.16177040f, -0.21166353f, 0.12768732f, 0.24255006f, 0.05199091f, 0.07123710f, 0.04180829f, 
    -0.05215015f, 0.05874673f, 0.02984075f, 0.03776211f, -0.09597728f, -0.00971719f, -0.04043503f, 0.03031449f, 
    0.01079214f, -0.01477332f, 0.04437037f, 0.02370087f, 0.01385184f, 0.02788081f, 0.02089661f, 0.06341016f, 
    -0.04036545f, -0.05341649f, -0.10888857f, 0.01677317f, -0.03918887f, 0.02351812f, 0.01442496f, 0.05281693f, 
    -0.01865925f, -0.01544431f, 0.01369336f, -0.00892545f, -0.02311139f, 0.05226025f, 0.05080675f, -0.04608094f, 
    0.03523262f, 0.01033329f, 0.01518189f, 0.06898726f, -0.16917595f, -0.03598022f, -0.02902939f, -0.10235439f, 
    -0.03722411f, -0.02803057f, 0.06233889f, 0.05340014f, 0.00959568f, 0.01564742f, 0.04479192f, -0.08474465f, 
    0.02880077f, -0.02019643f, -0.05873607f, 0.02793005f, 0.03463181f, -0.02115788f, -0.14147763f, 0.03045216f, 
    0.00127087f, -0.10186072f, 0.02168357f, 0.04032625f, 0.06378882f, 0.05527837f, 0.00850759f, -0.03541112f, 
    -0.01032638f, 0.02711312f, 0.00485833f, -0.05618041f, -0.00725255f, 0.00705736f, -0.00398863f, 0.02470141f, 
    -0.06726592f, 0.12907806f, -0.05798351f, -0.04099542f, -0.03821594f, -0.07379406f, -0.05167408f, 0.02344595f, 
    -0.04874523f, -0.03845324f, 0.01360615f, 0.02036353f, -0.04260737f, 0.02568401f, 0.00680367f, -0.01846267f, 
    -0.00049367f, 0.03110994f, 0.08934749f, -0.00812027f, -0.01763952f, 0.15578696f, -0.04558112f, 0.04264700f, 
    -0.13751483f, -0.04677975f, 0.07589421f, 0.00651278f, 0.06529675f, 0.00523766f, -0.03625077f, -0.00131468f, 
    -0.00592407f, 0.04316813f, -0.00627204f, 0.01322776f, 0.00339693f, -0.01608506f, -0.06546475f, -0.04846828f, 
    0.17421137f, 0.04178933f, 0.10876047f, 0.10352843f, 0.07371156f, 0.02101196f, 0.01286135f, -0.03532967f, 
    -0.05435603f, -0.13747743f, -0.08019550f, 0.02921620f, -0.03381330f, -0.02565189f, 0.08064311f, -0.00300434f, 
    0.04147673f, -0.06895021f, 0.07462529f, -0.04418782f, -0.00124225f, -0.03666103f, -0.11384127f, 0.06893558f, 
    -0.14082374f, -0.01313437f, 0.01427558f, -0.04417600f, -0.03030441f, 0.00963382f, -0.00895831f, 0.03885470f, 
    0.00441958f, 0.00835079f, 0.04473729f, 0.01686915f, 0.00987540f, -0.04725148f, -0.01345334f, 0.09022933f, 
    0.07370195f, 0.13670196f, 0.13078140f, 0.05118031f, 0.00900451f, -0.04212112f, 0.09265627f, -0.03366013f, 
    0.01251352f, 0.02411090f, 0.01735575f, 0.02567034f, -0.03592872f, -0.03088594f, -0.04676535f, 0.00786404f, 
    0.00975241f, -0.00315956f, 0.05618271f, -0.04330821f, 0.20897155f, -0.11449996f, 0.08037198f, -0.11276839f, 
    -0.05680908f, -0.07028460f, -0.04876446f, -0.10031972f, 0.01311458f, -0.05283450f, 0.02103206f, -0.05238106f, 
    0.05968632f, -0.00634628f, -0.02589306f, -0.05536970f, 0.01067797f, -0.08149995f, 0.01023031f, 0.03030978f, 
    -0.00328800f, 0.04178220f, 0.09144616f, -0.02702013f, 0.06484812f, 0.00373705f, 0.02331850f, -0.00002051f, 
    -0.02732385f, 0.01727945f, -0.05294867f, -0.01604482f, 0.02883404f, 0.04001234f, -0.02117707f, 0.06848267f, 
    -0.00589271f, 0.04490651f, 0.02360049f, 0.00399998f, -0.21814485f, -0.12788700f, 0.04454359f, -0.03389744f, 
    -0.10559199f, -0.00235642f, -0.01056390f, 0.06174617f, 0.00711086f, -0.08698708f, -0.03014962f, -0.03080173f, 
    -0.05706811f, 0.04245227f, -0.01731138f, 0.03356200f, -0.02835745f, -0.03898021f, -0.01542245f, -0.03167075f, 
    0.12344936f, -0.37274134f, -0.18602251f, 0.10794762f, 0.02987746f, -0.04471485f, -0.05947122f, 0.09034169f, 
    0.08266974f, -0.05945577f, 0.06041337f, -0.00354814f, -0.03841588f, -0.11997214f, 0.01949029f, -0.04231862f, 
    -0.02700015f, -0.00337047f, -0.00892799f, -0.02004395f, 0.15986100f, 0.19122308f, -0.22697954f, 0.01788527f, 
    -0.04944404f, -0.04901610f, -0.01312146f, -0.05958882f, 0.06363778f, 0.00410692f, -0.09039953f, 0.00908666f, 
    0.01748723f, -0.05102119f, 0.04551262f, 0.04676385f, -0.04665728f, 0.03696222f, -0.07445800f, -0.01614121f, 
    0.44505891f, 0.07961681f, -0.03340573f, 0.12620226f, 0.10985151f, -0.00029407f, -0.04519717f, -0.03224926f, 
    0.02312905f, 0.03776687f, -0.07110464f, -0.03651530f, 0.00386777f, 0.07896917f, 0.03514967f, 0.00080892f, 
    0.05098114f, 0.00162585f, 0.00158063f, 0.01476578f, 0.08465628f, -0.06634270f, 0.00888000f, -0.03682016f, 
    0.05724950f, 0.00086568f, 0.01634903f, -0.00208789f, -0.02293048f, 0.02753484f, 0.03102675f, -0.00238072f, 
    0.01782867f, -0.08730347f, -0.02101303f, 0.01599057f, -0.00237461f, 0.08284919f, -0.00580310f, 0.01617873f, 
    0.20222799f, 0.35956538f, -0.04190220f, -0.13451667f, -0.00223344f, -0.04705624f, 0.01562984f, -0.00602217f, 
    0.05037851f, 0.02482009f, -0.01182765f, -0.05552883f, -0.05669348f, 0.01911375f, -0.08960793f, -0.00454341f, 
    -0.01513737f, -0.03218827f, 0.16072352f, 0.07865041f, 0.15235522f, 0.23604971f, 0.10561907f, 0.10290103f, 
    -0.05379554f, 0.08042076f, 0.05473579f, 0.02817835f, -0.02187536f, -0.04077173f, -0.02786356f, -0.01548709f, 
    -0.06428489f, -0.01896573f, -0.04212221f, 0.04549379f, 0.01494147f, 0.04259561f, 0.02092529f, 0.09493566f, 
    0.04483845f, 0.11469989f, -0.07209969f, 0.09730195f, -0.10968441f, 0.00526683f, 0.05456133f, -0.05160530f, 
    0.00690086f, -0.06219903f, -0.00075401f, 0.00886354f, 0.06738907f, 0.02939377f, -0.02824644f, 0.05447277f, 
    -0.07913532f, 0.08396426f, -0.07113647f, -0.06377677f, -0.26397622f, 0.18161359f, 0.02586119f, 0.08875416f, 
    0.03407994f, 0.04322150f, -0.00184407f, 0.04056770f, 0.05981828f, 0.00973780f, -0.10653792f, -0.09596274f, 
    -0.02323286f, -0.00168426f, -0.03724737f, -0.00356540f, 0.02653583f, -0.03962573f, 0.02750112f, -0.03873681f, 
    -0.01818127f, -0.13473253f, -0.19156371f, -0.07585889f, -0.06462399f, -0.11839781f, -0.08940291f, 0.01147044f, 
    0.05016398f, -0.00772225f, -0.03511754f, 0.00905807f, 0.00635066f, 0.04500695f, 0.04173862f, -0.06471031f, 
    0.01548731f, -0.10668381f, -0.00336407f, 0.02336369f, 0.05939418f, -0.08502120f, -0.14453769f, 0.17344993f, 
    -0.00614120f, 0.07582358f, -0.01733227f, 0.03154684f, -0.00638285f, 0.01810045f, -0.05072199f, 0.01564471f, 
    -0.06109770f, -0.11031650f, -0.01360468f, -0.02239903f, -0.05442861f, 0.08487209f, -0.04183551f, -0.10449724f, 
    -0.06954883f, 0.05303018f, -0.06902415f, 0.22254147f, 0.06762476f, 0.00454397f, 0.04111605f, 0.04237540f, 
    0.06290670f, 0.04562715f, 0.04316886f, 0.01842718f, -0.07269357f, -0.06664765f, -0.00851168f, -0.05094160f, 
    -0.00759520f, 0.10388286f, 0.03085502f, -0.06132914f, 0.12057303f, -0.06482974f, -0.04157402f, 0.10948262f, 
    0.15128382f, 0.05374925f, 0.10537960f, 0.01492562f, -0.01050296f, -0.02747182f, 0.01233526f, 0.00749435f, 
    -0.11952204f, 0.00233157f, -0.05492997f, -0.03329004f, 0.04009218f, 0.04946418f, 0.02631426f, -0.02522553f, 
    0.02222584f, 0.15940054f, -0.01814109f, -0.03331029f, 0.01135872f, -0.00720994f, -0.06329072f, -0.03784151f, 
    0.03299988f, -0.05369253f, 0.01987541f, -0.05219641f, -0.01444190f, 0.04860098f, -0.04981170f, -0.05202494f, 
    0.00861832f, 0.05080228f, -0.04027174f, -0.05440989f, -0.04291995f, -0.00470339f, -0.02065168f, -0.13415790f, 
    0.02056111f, -0.06012423f, 0.01357570f, -0.03321330f, 0.01806962f, 0.01813079f, -0.01001139f, 0.06394544f, 
    -0.08498339f, 0.07082829f, -0.12990603f, 0.01140212f, 0.00034239f, -0.02762826f, 0.01616272f, 0.08452360f, 
    0.02707171f, -0.03371315f, -0.08467120f, 0.03908829f, -0.11286305f, 0.00853732f, -0.06658271f, 0.00251151f, 
    0.00348561f, -0.01625935f, -0.06138662f, 0.01487029f, 0.01544158f, 0.02518781f, 0.00896106f, 0.02544386f, 
    -0.03026472f, -0.06944721f, 0.01816718f, -0.02607727f, 0.04920553f, 0.10597352f, -0.09734124f, 0.26922652f, 
    -0.02565609f, 0.11430550f, 0.00947760f, -0.05395848f, 0.07558258f, 0.00967321f, -0.08109277f, -0.00238022f, 
    -0.07558863f, 0.03788897f, 0.06564587f, 0.11346879f, 0.00168941f, 0.02868151f, -0.01857540f, 0.04149639f, 
    -0.17589256f, -0.21046059f, -0.15246858f, 0.08312642f, -0.20188940f, -0.04217169f, -0.11253267f, -0.03440794f, 
    -0.02356330f, 0.04448555f, -0.11611564f, -0.09929135f, 0.02704160f, 0.02568047f, 0.02049052f, 0.03725644f, 
    -0.02192363f, -0.06555735f, -0.00136155f, 0.06182325f, 0.13474132f, -0.09571367f, -0.02816955f, -0.06184381f, 
    -0.09952505f, -0.04731771f, -0.09186822f, 0.01868179f, -0.04421315f, -0.00995348f, -0.09108999f, 0.01691323f, 
    0.00379056f, -0.08079235f, 0.02488548f, -0.04142008f, -0.01836739f, 0.07622086f, -0.00561694f, 0.02848428f, 
    0.10440791f, -0.14099227f, -0.06480700f, -0.02557857f, -0.08153570f, -0.03731909f, -0.10037119f, 0.07283632f, 
    -0.07464869f, -0.01116808f, -0.04315576f, 0.04134029f, -0.08178160f, 0.07178079f, 0.05065246f, 0.00730646f, 
    0.04323664f, 0.06861883f, 0.00070957f, -0.01610838f, -0.00414935f, 0.16604109f, -0.03032606f, 0.12384692f, 
    0.06863344f, 0.06501606f, 0.01830249f, 0.01815018f, -0.00156589f, 0.02385150f, -0.06505173f, -0.02368287f, 
    0.04961645f, -0.06444760f, -0.01817141f, 0.00150557f, 0.03122260f, 0.00664192f, 0.04287236f, 0.02976257f, 
    -0.58234328f, 0.19912381f, -0.33228162f, 0.10387643f, 0.04392637f, -0.06237250f, 0.08983875f, 0.02603806f, 
    0.06011795f, -0.02076920f, -0.03657623f, -0.04887987f, 0.02135121f, -0.07219747f, -0.02179918f, -0.01634313f, 
    -0.01855606f, -0.01104182f, 0.02678571f, 0.02791960f, -0.12131640f, -0.26077235f, -0.22156836f, 0.01080708f, 
    0.08935054f, 0.01819482f, 0.08690330f, 0.02995636f, -0.03018277f, -0.03990526f, -0.05552772f, 0.02026868f, 
    0.02283523f, -0.00231227f, -0.00498035f, -0.00773007f, 0.04032939f, 0.01451821f, 0.03223658f, 0.05156962f, 
    0.12487479f, 0.16265461f, 0.14645749f, 0.09735560f, 0.10456772f, -0.00865620f, 0.03100876f, 0.04887431f, 
    -0.00025783f, 0.02065703f, -0.02190625f, 0.03278966f, -0.07589494f, -0.03894986f, 0.00208543f, -0.05729178f, 
    0.03942221f, 0.03244663f, 0.03263471f, 0.06645034f, -0.12433003f, 0.13231666f, 0.08105236f, -0.00073585f, 
    -0.01261341f, -0.01849044f, -0.04391729f, -0.05241412f, 0.01958012f, -0.02824616f, -0.02872173f, -0.02452368f, 
    -0.02667021f, 0.02850653f, -0.01440316f, 0.02518537f, 0.02375552f, 0.00527431f, 0.00903635f, -0.00443489f, 
    -0.19679211f, 0.20103593f, 0.11670671f, 0.17046222f, 0.06005309f, 0.04875547f, 0.00542109f, 0.09350284f, 
    -0.04743972f, 0.02893000f, -0.02045671f, 0.04300220f, -0.02058098f, -0.03745275f, -0.11212756f, 0.01649735f, 
    -0.09350989f, 0.05259553f, 0.01415241f, -0.10697537f, -0.06734552f, -0.15565519f, -0.15623040f, 0.04520563f, 
    -0.13643995f, -0.02211023f, -0.00470708f, 0.00535771f, -0.00890010f, -0.01025037f, -0.00532554f, -0.01988583f, 
    -0.00866576f, 0.06800489f, 0.01683215f, 0.04255796f, -0.04758570f, 0.04696510f, -0.06266386f, 0.00643473f, 
    -0.12648709f, 0.06986771f, -0.00325335f, 0.06408153f, -0.03365372f, -0.07719572f, -0.08698438f, 0.03684118f, 
    0.01806489f, -0.01480490f, -0.03544185f, 0.04741209f, -0.04306619f, 0.04895864f, 0.00862446f, 0.01577432f, 
    0.02614285f, 0.03939889f, 0.08366112f, -0.02579853f, -0.46681666f, -0.32800248f, -0.30452242f, 0.00393371f, 
    0.00534285f, -0.14584227f, -0.03794238f, -0.06767795f, 0.07916623f, -0.01538072f, -0.03310846f, -0.00310710f, 
    0.09979787f, 0.04518213f, 0.01437186f, 0.01481894f, -0.02550389f, -0.02281067f, -0.01868783f, 0.04399864f, 
    0.05245175f, -0.17592596f, -0.26868728f, 0.07642034f, 0.18725768f, -0.03672592f, 0.11485044f, -0.02881172f, 
    0.04283867f, -0.00540836f, 0.04367014f, 0.03613631f, -0.00099947f, -0.08294132f, -0.07310993f, 0.04512095f, 
    -0.00589528f, 0.04833326f, 0.00275661f, -0.08970115f, -0.29079962f, -0.46951029f, -0.06223470f, -0.16274759f, 
    -0.22706160f, -0.06109823f, -0.01108461f, -0.04144366f, 0.02154728f, -0.08515546f, -0.03693850f, -0.04149112f, 
    0.04826262f, 0.00028372f, 0.00753302f, 0.05282537f, -0.00183763f, -0.02700048f, -0.05923483f, 0.08525041f, 
    -0.23496421f, -0.27105004f, -0.10535712f, 0.04596795f, -0.05226220f, 0.00443794f, -0.01192470f, 0.03146714f, 
    0.02683348f, -0.09306534f, 0.00889580f, -0.07284846f, -0.00186477f, 0.06724643f, -0.03060062f, 0.02007145f, 
    0.03062391f, 0.03260743f, -0.06816148f, -0.01634233f, 0.16415471f, 0.11097569f, 0.12922348f, -0.01027431f, 
    0.05501662f, -0.01523878f, 0.04397416f, 0.01524850f, -0.01911269f, 0.05982646f, -0.04239267f, 0.01081523f, 
    0.00076005f, -0.16634475f, -0.03560356f, 0.00726980f, 0.04128851f, 0.08612338f, -0.00082279f, -0.00676471f, 
    0.33859369f, 0.10586547f, 0.04920061f, 0.05673324f, 0.00685668f, 0.02800189f, -0.01347243f, -0.07572512f, 
    -0.01247903f, 0.00166618f, -0.04481384f, -0.02096368f, -0.04535647f, 0.01895666f, 0.01071301f, 0.02874069f, 
    -0.01677130f, 0.05661354f, -0.01986239f, 0.03805510f, -0.05997948f, -0.12147035f, -0.09309531f, -0.06837982f, 
    -0.17009072f, -0.03488801f, -0.15912178f, 0.03885151f, -0.06848340f, -0.00078109f, -0.06476442f, -0.03917291f, 
    0.05182754f, -0.09525715f, 0.08476904f, 0.02223458f, -0.00612569f, 0.03973195f, 0.05662169f, 0.05642348f, 
    -0.31002125f, 0.08229057f, -0.03710826f, -0.14541890f, -0.16747011f, 0.01946677f, -0.12149796f, -0.02312685f, 
    -0.00822553f, -0.06863330f, 0.00689715f, -0.11058818f, -0.10977025f, 0.01792972f, -0.02816114f, 0.00357751f, 
    0.08941744f, 0.03686064f, 0.05191460f, 0.03952891f, -0.13490680f, -0.19384883f, -0.07142860f, 0.02206728f, 
    -0.04305370f, -0.02173274f, -0.08342361f, -0.01716404f, 0.00668104f, -0.08152501f, -0.00197584f, -0.06856494f, 
    0.07253567f, -0.05954259f, 0.00112124f, 0.02556035f, 0.07041623f, 0.05978816f, -0.00750386f, 0.04270638f, 
    -0.09193684f, -0.37688529f, -0.16510962f, -0.02778836f, 0.05452283f, -0.04977646f, 0.01224867f, 0.00177886f, 
    0.01835722f, -0.05897205f, -0.05034196f, -0.00473634f, -0.01578590f, -0.01104328f, 0.03144948f, -0.01799029f, 
    -0.06868174f, -0.01453123f, -0.05619218f, -0.02414715f, -0.20830598f, -0.00740177f, 0.04138190f, -0.14640117f, 
    -0.09620631f, -0.03708748f, -0.06468665f, -0.04200549f, 0.08084144f, -0.05149752f, 0.09523350f, -0.00280655f, 
    -0.01730778f, 0.03191835f, -0.06777421f, -0.04798934f, 0.03247248f, -0.06448453f, 0.05185612f, 0.01903895f, 
    0.21877243f, 0.11286573f, -0.13500260f, 0.11678507f, 0.03437290f, -0.06687999f, -0.05560972f, -0.02442748f, 
    0.04280002f, 0.01039779f, -0.06423119f, -0.03898656f, -0.03946346f, 0.05182904f, 0.04711861f, -0.09016083f, 
    0.02156753f, 0.04889046f, -0.03715254f, -0.02103930f, -0.12330180f, 0.01361217f, -0.14456615f, 0.00407814f, 
    -0.06121937f, -0.05157392f, -0.13957238f, 0.06478515f, 0.02775108f, -0.01464604f, -0.02594072f, -0.03216416f, 
    0.00958539f, -0.06283695f, 0.01492803f, -0.00749055f, 0.00066164f, 0.02664308f, 0.04791530f, 0.00114487f, 
    0.14386187f, -0.06040716f, -0.01660419f, 0.03594534f, 0.05898495f, -0.01860620f, 0.09783344f, 0.00001940f, 
    -0.01384069f, 0.00989321f, -0.04509751f, 0.07690216f, -0.01492557f, -0.04486438f, 0.00699938f, -0.00871092f, 
    0.05668721f, -0.02804747f, 0.08008309f, -0.00637036f, 0.04824816f, -0.01789661f, 0.12039536f, 0.04554823f, 
    -0.02590219f, -0.01065778f, 0.02544854f, 0.04813481f, -0.05529911f, 0.04652577f, -0.03331978f, -0.00684645f, 
    -0.03206020f, 0.00277221f, 0.04481167f, 0.03866441f, -0.01536981f, -0.02412942f, 0.00783262f, 0.01158013f, 
    0.05008766f, -0.10154019f, 0.05929281f, 0.03393992f, -0.04951149f, -0.03660749f, 0.00257260f, 0.02281837f, 
    0.01818388f, 0.11143020f, -0.04053981f, 0.03862567f, -0.06242310f, 0.04618461f, -0.07438877f, 0.02544258f, 
    0.00191614f, -0.03255821f, -0.02003333f, 0.02045460f, -0.03417117f, -0.23778199f, -0.27754319f, -0.12455428f, 
    0.07055499f, -0.12604761f, -0.06417670f, -0.04502571f, 0.04503207f, 0.01174063f, -0.03032153f, 0.04335620f, 
    -0.04870914f, 0.01896602f, 0.02729054f, -0.05922167f, 0.00270090f, -0.04631388f, 0.02192670f, 0.05053106f, 
    0.08395805f, -0.00013365f, 0.07465723f, 0.04743060f, 0.00861944f, 0.01564321f, 0.04158018f, -0.05288974f, 
    -0.02556478f, -0.03859483f, 0.06252562f, 0.12018140f, -0.03363144f, -0.01858981f, 0.00449065f, -0.08882061f, 
    0.07947057f, -0.01452210f, 0.03265314f, 0.08479756f, -0.45662543f, -0.20168911f, -0.01584128f, 0.01413710f, 
    0.10549190f, -0.08954312f, -0.08457747f, 0.08721800f, -0.00449135f, -0.04041416f, 0.01038136f, -0.01173994f, 
    -0.05249739f, -0.05528831f, 0.02771572f, -0.01435421f, 0.00988484f, -0.06964908f, 0.09398534f, -0.10174762f, 
    -0.32252210f, 0.05037553f, -0.11599708f, -0.12171927f, 0.06312869f, 0.06111546f, -0.00979053f, 0.00648403f, 
    0.06101826f, 0.02425867f, 0.00122355f, -0.02694394f, -0.00950389f, -0.03649786f, 0.04226618f, 0.03443901f, 
    0.04699617f, -0.06871555f, 0.06540359f, 0.01805374f, -0.12933847f, 0.06848983f, 0.02640242f, -0.16186017f, 
    -0.13937916f, -0.05732072f, -0.05250513f, -0.09746704f, -0.00804185f, 0.01923091f, -0.03668150f, -0.05144682f, 
    -0.04971292f, 0.06318555f, -0.00824215f, 0.01154683f, 0.06691843f, -0.04351439f, -0.00698047f, -0.03731208f, 
    0.00643639f, 0.04839349f, 0.00521871f, 0.10791081f, 0.06108252f, -0.01944563f, -0.03285351f, -0.01897322f, 
    0.13441065f, -0.01291841f, -0.03617384f, 0.00566542f, -0.01197095f, 0.06763984f, 0.08253041f, -0.01613698f, 
    0.01762912f, 0.01095800f, 0.08887471f, -0.00641632f, 0.02875773f, 0.15120187f, -0.03340547f, 0.06173686f, 
    -0.04914511f, -0.01447319f, -0.04899389f, 0.02910330f, 0.02830686f, -0.05795729f, 0.03112577f, -0.04391379f, 
    -0.04969876f, 0.01773291f, -0.03414192f, 0.05468116f, -0.05616299f, 0.12963405f, 0.03023924f, 0.11542778f, 
    0.09351657f, 0.00636193f, -0.18030387f, 0.15011138f, -0.22423334f, -0.05606277f, -0.01380049f, 0.05212070f, 
    -0.03792197f, 0.03927556f, -0.09607190f, 0.01745625f, 0.04559223f, 0.03899426f, -0.02529074f, 0.02735013f, 
    0.00683801f, 0.00337286f, -0.07131438f, 0.04491716f, 0.18943694f, -0.02999672f, -0.08860075f, -0.06643637f, 
    0.15526336f, -0.02001683f, 0.05468464f, 0.05923112f, 0.07613347f, 0.01342042f, 0.05262753f, -0.02033460f, 
    0.08806408f, -0.03057525f, 0.02838887f, 0.00911514f, 0.05725028f, -0.00205556f, 0.10570282f, 0.05257545f, 
    -0.14301385f, -0.15704487f, 0.17873707f, 0.22473183f, 0.00264460f, -0.10315578f, -0.08881587f, 0.09994538f, 
    -0.06810022f, -0.01410314f, 0.02185390f, -0.00363377f, 0.09447605f, -0.07301700f, 0.04080700f, 0.06038915f, 
    -0.08842327f, 0.07595029f, 0.02567268f, 0.05547700f, -0.16443512f, 0.15632151f, 0.03198227f, 0.04627847f, 
    0.04344459f, 0.05904677f, -0.03769058f, -0.03709730f, 0.10316256f, 0.02021864f, -0.01049700f, 0.01569645f, 
    -0.04146574f, 0.02470300f, 0.02721788f, 0.01261346f, 0.01411085f, 0.01262339f, 0.05048388f, -0.09551613f, 
    -0.48016554f, 0.28391102f, -0.03497720f, -0.07419955f, -0.05734114f, 0.05576146f, 0.01682468f, -0.05373116f, 
    0.00177260f, 0.08251669f, -0.10168144f, 0.05772791f, 0.06285819f, -0.02094146f, -0.10495497f, 0.05013622f, 
    0.05665842f, 0.02232227f, 0.03087051f, -0.08269259f, 0.16030835f, -0.16209826f, -0.15794954f, 0.14435717f, 
    -0.00450790f, 0.04555447f, -0.02343639f, 0.06315400f, -0.01366816f, 0.05332527f, -0.01236527f, 0.01003012f, 
    0.07610194f, 0.00023703f, -0.04735398f, -0.00121272f, -0.04722659f, 0.02264767f, -0.03108348f, 0.03384804f, 
    -0.01098374f, -0.01219828f, 0.01036235f, 0.01349604f, 0.05494180f, 0.02785248f, 0.01102408f, 0.00543968f, 
    -0.03469196f, 0.01049536f, 0.04653687f, -0.01978735f, 0.03873581f, 0.00949920f, -0.02400956f, -0.00262220f, 
    -0.03772115f, -0.01346880f, 0.09041675f, -0.05268969f, -0.11988145f, 0.20917819f, -0.09832744f, 0.00828975f, 
    -0.18540701f, -0.00302769f, -0.06300682f, 0.03455932f, -0.21139905f, 0.04260466f, -0.02302667f, -0.04425040f, 
    0.03800850f, 0.02643143f, 0.06207680f, 0.01174865f, -0.05890040f, 0.02273451f, -0.09635686f, 0.02498545f, 
    -0.19314381f, -0.11627758f, 0.09395565f, -0.16673464f, 0.06236413f, 0.00193212f, -0.01454861f, 0.04058744f, 
    0.00783099f, 0.05347823f, -0.04758232f, 0.03141734f, -0.01337641f, -0.03486853f, -0.02021181f, -0.00645386f, 
    0.05434659f, -0.04905644f, 0.03948727f, -0.06044866f, -0.53900474f, 0.10490459f, 0.03300424f, -0.08385962f, 
    0.00538731f, 0.04112207f, 0.03077610f, -0.07225226f, 0.05537105f, -0.01179674f, 0.03871587f, -0.07911222f, 
    0.09750002f, 0.00972791f, 0.05428233f, 0.03366743f, 0.04098000f, 0.06726713f, 0.01946166f, -0.04845850f, 
    0.01716832f, 0.21461514f, -0.16318451f, 0.14429438f, -0.16068314f, -0.05779076f, -0.04982192f, 0.07698089f, 
    0.00534235f, 0.00083402f, 0.02313734f, -0.01892896f, -0.03406253f, 0.01242193f, -0.02027224f, -0.00148289f, 
    0.01040978f, 0.07125562f, -0.03347580f, 0.13771461f, -0.14730686f, 0.06827977f, -0.17861544f, -0.20804195f, 
    0.16843705f, 0.01063999f, -0.01202907f, -0.05868234f, 0.11755592f, -0.01377922f, 0.03398431f, -0.05760706f, 
    -0.04995036f, 0.04243723f, 0.01792940f, 0.02256418f, -0.03328127f, -0.06347112f, 0.02966642f, -0.03898200f, 
    0.08015653f, 0.05704985f, 0.04533958f, 0.08250813f, 0.04553924f, -0.00964197f, -0.00060824f, 0.02762200f, 
    -0.02273169f, 0.05550867f, 0.06727583f, -0.03191731f, 0.03093529f, 0.02707769f, 0.03520026f, 0.04579328f, 
    0.03936179f, -0.00762379f, -0.03110741f, -0.01563445f, -0.26316768f, 0.10472840f, -0.08714417f, -0.01330829f, 
    0.03326885f, 0.01510319f, -0.09792538f, -0.03940821f, 0.11779916f, 0.01892277f, -0.03319915f, -0.00547169f, 
    0.02294147f, 0.01140564f, 0.07807487f, 0.07019912f, 0.06481807f, 0.01684686f, -0.04602072f, -0.05875803f, 
    -0.06428237f, -0.30732512f, 0.05773080f, 0.13061963f, 0.04104281f, -0.13483492f, -0.00023796f, -0.08759047f, 
    -0.06067323f, 0.01336063f, 0.04534080f, -0.00533055f, -0.01674933f, -0.01703494f, 0.06588405f, -0.12476896f, 
    0.04314051f, 0.00659260f, 0.04536849f, -0.00101903f, -0.18959704f, -0.17338018f, 0.05502025f, 0.04675237f, 
    0.04804561f, 0.01498272f, -0.00042323f, 0.05346428f, 0.07096782f, -0.03705892f, 0.09978405f, -0.06121127f, 
    -0.07468743f, 0.04155716f, 0.06645282f, 0.04530603f, 0.01052555f, -0.00286288f, -0.01671660f, 0.10424682f, 
    0.15240926f, 0.11639695f, 0.03510859f, 0.00024073f, -0.14727259f, -0.00106749f, 0.05104225f, 0.04905184f, 
    0.04233245f, -0.01313862f, -0.03879783f, -0.03236552f, 0.04945646f, 0.05072143f, -0.01256876f, -0.06146252f, 
    0.03292918f, 0.04795301f, -0.01106281f, 0.06504375f, -0.00487640f, -0.22591585f, -0.03371584f, 0.03293711f, 
    -0.07643062f, -0.06522854f, 0.01872794f, 0.00424288f, -0.10003076f, -0.12823196f, 0.01670134f, -0.00343303f, 
    -0.02945524f, -0.00345010f, 0.02970796f, -0.14646290f, 0.05546880f, -0.01248922f, 0.03294723f, -0.01162699f, 
    -0.10213839f, 0.10554155f, 0.05611318f, -0.08884600f, -0.12324306f, 0.08978071f, -0.00643622f, 0.12102161f, 
    -0.13385938f, -0.03587021f, 0.01971480f, 0.05419624f, -0.01038437f, 0.00310114f, -0.04706897f, -0.02673654f, 
    0.01806691f, -0.04715819f, -0.07796384f, 0.02068215f, -0.14118537f, -0.10537104f, 0.20902334f, 0.03144854f, 
    -0.09090182f, -0.01046466f, 0.11517952f, -0.05986218f, -0.07009960f, -0.07327828f, 0.11655169f, -0.03888034f, 
    -0.09461155f, 0.07477593f, 0.06116582f, -0.11792937f, 0.01159637f, 0.02483431f, 0.01705116f, 0.07254662f, 
    -0.18162026f, 0.30669037f, 0.04357497f, 0.24720575f, -0.01762209f, -0.03583399f, -0.07233487f, -0.11133088f, 
    0.00835667f, -0.17136165f, -0.00247094f, 0.06106568f, -0.09523465f, 0.01809693f, 0.02031599f, 0.02982893f, 
    -0.07750043f, -0.05963908f, 0.01968754f, 0.08749578f, -0.05859983f, -0.04475692f, -0.04676205f, -0.01765627f, 
    -0.01381712f, 0.05479407f, 0.03661188f, 0.04855412f, -0.02919240f, 0.08681324f, 0.10912532f, 0.04590772f, 
    0.01295314f, -0.01275522f, 0.10210833f, -0.02690987f, -0.05813398f, -0.04546258f, 0.03176067f, 0.06688932f, 
    0.12045874f, -0.25653744f, -0.01130029f, -0.00234593f, -0.12443485f, 0.02475097f, 0.00920313f, 0.03287484f, 
    0.00208726f, 0.02417966f, -0.03750860f, -0.00636253f, -0.07028717f, -0.05442976f, -0.01842181f, 0.08084212f, 
    0.00473771f, -0.03116800f, -0.05029971f, -0.03307834f, -0.09693614f, -0.17444143f, 0.03145180f, -0.08269312f, 
    0.06605130f, -0.02614526f, -0.02010732f, -0.16350786f, -0.05187228f, 0.02736455f, 0.02539690f, -0.07170442f, 
    0.02283099f, -0.05506355f, 0.05231818f, 0.02550471f, -0.09344678f, -0.01397047f, -0.11574958f, -0.07983688f, 
    -0.12401073f, -0.15169260f, 0.24961546f, 0.14877500f, -0.11329186f, -0.01598716f, 0.05453993f, -0.08465832f, 
    -0.08488206f, 0.03992160f, 0.06342105f, -0.02127692f, -0.03496877f, -0.02721582f, 0.04459926f, -0.00352681f, 
    -0.11456323f, 0.05932650f, -0.02186709f, 0.02735881f, -0.03903385f, -0.05483820f, 0.11035920f, 0.10921913f, 
    -0.07983745f, -0.02825876f, 0.09659641f, -0.03432200f, 0.00889357f, 0.01880652f, 0.09891824f, 0.06623658f, 
    0.00582305f, -0.01170942f, -0.08934393f, -0.08051119f, 0.08891826f, 0.02619005f, -0.00568903f, 0.01575449f, 
    0.23416887f, 0.17275263f, -0.07844776f, -0.13317023f, 0.06447908f, 0.03369561f, -0.02929855f, -0.01961009f, 
    0.01539880f, -0.07107828f, 0.01229611f, 0.01398737f, 0.06325848f, -0.05967930f, -0.07966448f, -0.08233818f, 
    -0.05076660f, -0.13374890f, -0.00990089f, 0.05412913f, -0.16871201f, -0.01298882f, 0.03482775f, 0.05206867f, 
    -0.00956365f, 0.08471657f, -0.04575265f, 0.11515953f, -0.02782812f, -0.07214365f, 0.04673448f, -0.02270951f, 
    -0.04691785f, -0.04807919f, -0.00047006f, 0.00077772f, 0.09440681f, -0.15633297f, -0.03060188f, -0.09812883f, 
    0.13880822f, 0.01139172f, 0.07877293f, -0.04742968f, -0.09119912f, -0.06280274f, 0.06084123f, -0.01428455f, 
    0.01801973f, 0.04531335f, -0.03741536f, -0.06124606f, 0.01824392f, 0.00247182f, -0.02187887f, 0.01215142f, 
    -0.05252711f, -0.02432604f, 0.01011068f, -0.12225056f, -0.13419835f, -0.09875188f, -0.12060504f, 0.14690064f, 
    -0.29281953f, -0.12700273f, 0.02631526f, 0.07663976f, 0.03414493f, 0.01860815f, -0.00063821f, -0.14039241f, 
    -0.02281963f, 0.03443474f, -0.00764233f, -0.03464207f, 0.03563054f, -0.04433940f, -0.06681467f, -0.07191266f, 
    -0.16976006f, -0.05935423f, -0.02733869f, 0.14132427f, 0.05011893f, 0.03653179f, -0.04667040f, 0.07207034f, 
    0.04207468f, 0.00135267f, 0.01559322f, -0.03735570f, 0.01254880f, 0.13072474f, 0.07922336f, -0.06637273f, 
    0.10341130f, 0.03754345f, -0.02266080f, -0.05753282f, -0.55743170f, -0.08920510f, -0.15777826f, 0.09494481f, 
    0.22322141f, 0.01078908f, -0.00059875f, -0.00683809f, 0.08722737f, 0.07516308f, 0.05913875f, -0.01208152f, 
    0.00541558f, 0.07369434f, 0.04641749f, -0.01709681f, 0.01836177f, 0.05129141f, 0.06963746f, -0.02144964f, 
    -0.01329863f, 0.08928942f, -0.13874787f, -0.02761969f, 0.11869089f, 0.03620365f, 0.04415416f, 0.07099557f, 
    0.04205596f, 0.02791459f, 0.02964774f, -0.07060713f, 0.00680664f, -0.01025443f, -0.06906695f, -0.03851703f, 
    -0.03368567f, 0.09858916f, -0.01223120f, -0.05198989f, -0.19269468f, 0.08394589f, 0.01142825f, 0.12004785f, 
    -0.05496312f, -0.04315507f, -0.01167564f, -0.00161589f, -0.09200588f, -0.03910317f, 0.05954335f, 0.04927880f, 
    -0.03116030f, 0.05510531f, 0.05912702f, -0.02587807f, 0.03070606f, -0.02100546f, 0.03237927f, 0.05132711f, 
    -0.25323540f, 0.03592749f, 0.12225682f, 0.00177952f, -0.01938940f, 0.02667175f, 0.00193541f, -0.07695756f, 
    0.00247162f, 0.07454471f, 0.07424931f, -0.06102302f, 0.02495828f, -0.16406015f, -0.01479549f, 0.02752177f, 
    -0.03632512f, -0.03382755f, 0.00482771f, 0.01547016f, 0.11292422f, 0.00087287f, 0.17163493f, -0.01673804f, 
    -0.01541492f, -0.00709668f, 0.04750387f, 0.02912807f, -0.00545290f, 0.03864869f, 0.07861049f, -0.02712688f, 
    0.01718766f, -0.04015150f, 0.02488546f, 0.01851386f, 0.08993029f, 0.05231941f, 0.04356553f, 0.07006603f, 
    0.09658241f, 0.03364456f, -0.16264869f, -0.06513990f, -0.14761642f, -0.02494599f, -0.14642918f, -0.11063547f, 
    -0.13942653f, 0.03134849f, -0.04034266f, 0.05006206f, 0.01561409f, -0.01082511f, 0.04433915f, -0.07624029f, 
    0.00925116f, 0.07458618f, -0.06292308f, -0.07256583f, -0.23184860f, 0.07336245f, 0.01290776f, -0.01883493f, 
    0.03667520f, 0.07174844f, 0.05562740f, 0.01749030f, 0.01718531f, -0.07097214f, -0.03655170f, 0.05197360f, 
    -0.06513648f, 0.04411417f, 0.01681869f, -0.10235288f, -0.08819912f, -0.01010137f, -0.00197807f, -0.04603183f, 
    -0.08070894f, -0.14203544f, 0.10568079f, -0.07731096f, -0.03011107f, 0.03402591f, -0.09720363f, -0.08197886f, 
    -0.04838578f, -0.02104796f, 0.01145010f, 0.01107374f, -0.06731126f, 0.03905705f, -0.02709254f, -0.04657208f, 
    -0.03757047f, 0.01032741f, 0.07050942f, -0.03261734f, -0.14346646f, 0.21196966f, 0.03704097f, -0.04772746f, 
    -0.12151390f, 0.00609174f, -0.02451324f, -0.05691067f, 0.01668483f, -0.13739081f, 0.02788871f, 0.02553822f, 
    -0.03526839f, 0.07862687f, 0.01826868f, -0.02620772f, -0.05782750f, -0.02254401f, -0.11047503f, 0.00734064f, 
    -0.37916374f, 0.03581822f, 0.13711672f, 0.04012456f, 0.12835690f, 0.02318772f, -0.04974544f, -0.03685362f, 
    0.07369698f, 0.07193985f, -0.03193961f, -0.00713152f, 0.01671550f, 0.07361978f, -0.02704299f, -0.03120703f, 
    0.09042851f, 0.09064965f, 0.05968188f, -0.13716117f, 0.01852299f, 0.08502582f, 0.11274642f, -0.06208404f, 
    -0.03983077f, 0.02581361f, 0.02664795f, -0.01135017f, 0.06604156f, 0.07833335f, 0.06286711f, -0.05786846f, 
    0.01017982f, -0.08571563f, -0.03584442f, 0.03581680f, 0.01333532f, -0.09407928f, 0.01935667f, 0.02516732f, 
    -0.28245521f, -0.29340133f, 0.14112194f, 0.16393565f, -0.02024312f, -0.13665701f, 0.02084533f, -0.02926373f, 
    -0.01667932f, 0.06845705f, 0.01342172f, 0.05408473f, -0.03289929f, -0.06856742f, 0.04611641f, -0.01583494f, 
    -0.01993430f, -0.01083027f, 0.05030546f, 0.03875637f, 0.16691190f, -0.03902501f, 0.02931635f, 0.02735443f, 
    0.02419967f, 0.06877789f, 0.00150845f, -0.03523853f, 0.11336347f, 0.06865200f, -0.06836490f, 0.03352187f, 
    0.06242571f, 0.00863177f, -0.02019873f, -0.03936163f, -0.00729761f, -0.04197513f, 0.03618924f, -0.05743899f, 
    -0.07507963f, 0.27397242f, -0.03350645f, -0.10138156f, -0.02305637f, 0.07676366f, 0.03787565f, -0.08176120f, 
    0.05067153f, -0.00469587f, -0.02468423f, 0.00866119f, 0.02210952f, 0.05585966f, -0.00388061f, -0.11682522f, 
    0.04017439f, -0.03333374f, 0.01162686f, -0.04171372f, -0.06074375f, 0.05528363f, -0.08481845f, 0.09979009f, 
    -0.05068640f, -0.01507497f, 0.04993791f, 0.03449855f, 0.04957217f, -0.07720530f, -0.01527655f, -0.01276180f, 
    0.09972044f, -0.04688449f, 0.02659758f, -0.00558635f, -0.05548447f, 0.04181490f, 0.00080339f, 0.03050865f, 
    -0.02203858f, -0.06035057f, 0.14543512f, -0.11338512f, -0.23793849f, -0.11361046f, 0.09120841f, -0.01831094f, 
    0.06734741f, -0.00927066f, 0.02672824f, -0.06046758f, -0.03805127f, 0.02778033f, 0.11643173f, -0.02676518f, 
    -0.00112685f, 0.01508819f, -0.04756781f, 0.15579416f, -0.64649194f, 0.00026896f, -0.00425021f, 0.12767968f, 
    0.20719095f, 0.08704931f, -0.02328767f, 0.10459513f, -0.03109445f, 0.10038651f, 0.00521396f, 0.07194725f, 
    0.00713411f, 0.00810426f, 0.06140664f, 0.06995083f, 0.00456288f, 0.01823892f, 0.05514587f, -0.08166782f, 
    -0.01753681f, -0.01590917f, -0.13022274f, 0.13082115f, 0.11155848f, 0.08541935f, 0.05453718f, 0.12429918f, 
    -0.02278715f, -0.02678613f, 0.01127939f, -0.01396021f, 0.11342835f, 0.01307600f, -0.03035901f, -0.00139354f, 
    0.02026773f, -0.11162236f, 0.05341610f, 0.00912907f, 0.14439447f, 0.13416420f, -0.26845387f, -0.09275197f, 
    -0.00487044f, -0.00336016f, -0.00009221f, 0.01287734f, 0.02114807f, -0.08530729f, -0.00984329f, -0.02530024f, 
    -0.02685378f, 0.09052791f, 0.06863385f, -0.01002497f, 0.09346459f, 0.02112095f, -0.04241145f, 0.05126002f, 
    -0.05104885f, -0.08048233f, 0.09332737f, -0.09829453f, -0.00353509f, -0.03119104f, 0.01385542f, -0.09044373f, 
    -0.04311972f, 0.04169187f, 0.08207631f, 0.00178288f, 0.02263815f, 0.05531026f, -0.03861861f, 0.05461986f, 
    -0.04017112f, -0.06904586f, -0.02360491f, -0.01592081f, 0.39570123f, 0.35544616f, -0.32683352f, -0.17126136f, 
    0.02985082f, -0.00592310f, -0.03064128f, 0.16157830f, 0.06978559f, 0.05765099f, -0.01596504f, 0.00666859f, 
    -0.04170227f, 0.00730527f, -0.05160169f, 0.00091980f, 0.06299597f, -0.09638751f, -0.05508676f, -0.02058550f, 
    -0.17277843f, 0.01033583f, -0.08474834f, -0.06593890f, -0.12822370f, 0.02880257f, -0.02134262f, 0.01280450f, 
    0.01027265f, -0.00412690f, -0.02398802f, -0.06534475f, -0.05493620f, 0.00558728f, 0.06231817f, 0.00362402f, 
    0.04300422f, -0.02048755f, -0.09571070f, 0.03259698f, -0.34078521f, -0.22664557f, -0.00467423f, 0.07351086f, 
    0.12329283f, 0.01318225f, -0.01371808f, -0.01622689f, -0.02820582f, 0.06804344f, -0.04823085f, -0.04792337f, 
    0.04288573f, 0.09587981f, -0.02486341f, -0.02924519f, 0.02392690f, 0.10846267f, 0.11977017f, 0.01183763f, 
    -0.00279968f, -0.02564854f, 0.08528601f, -0.07247738f, 0.03780426f, 0.09144984f, 0.02486950f, -0.02268606f, 
    -0.02090166f, -0.03652179f, 0.00899079f, 0.08319078f, -0.07000392f, -0.02507505f, -0.04484318f, 0.00171522f, 
    0.05111071f, -0.06216730f, 0.01767395f, 0.00798283f, -0.05201615f, 0.08225195f, -0.02245781f, 0.08624853f, 
    0.06531534f, 0.05864957f, -0.13889664f, 0.00979026f, -0.02074982f, -0.01928753f, -0.03102920f, 0.03004372f, 
    -0.01887106f, 0.00057407f, 0.09358329f, 0.09794991f, 0.07060439f, -0.05331242f, 0.01529582f, -0.00883281f, 
    0.33870259f, 0.02715315f, 0.01126125f, -0.12215650f, -0.20609172f, -0.04831030f, -0.05600435f, 0.02078037f, 
    -0.02385216f, 0.00300121f, -0.01368390f, -0.06258401f, 0.09178370f, -0.05274731f, 0.10763889f, 0.00852117f, 
    -0.03823259f, -0.01801600f, 0.02001064f, -0.08268195f, 0.03504182f, -0.09159288f, 0.13967595f, 0.02051900f, 
    -0.05252104f, -0.02386470f, -0.07161659f, -0.00402299f, 0.07375795f, 0.01708409f, 0.03773617f, 0.00950869f, 
    -0.12045030f, -0.09124041f, 0.02164708f, 0.00740598f, 0.08994046f, -0.06140782f, -0.06415240f, -0.02104098f, 
    0.05950508f, 0.04231069f, 0.06549831f, -0.03541044f, 0.07061164f, 0.01567382f, -0.04889020f, 0.01644460f, 
    0.03254221f, 0.04814704f, -0.05312465f, -0.01778820f, 0.05260357f, 0.11753577f, -0.05450958f, 0.00810864f, 
    -0.15050772f, -0.00533262f, -0.00353970f, 0.00718254f, 0.08158116f, 0.07331890f, 0.05574287f, -0.09213345f, 
    -0.23706916f, -0.15395577f, -0.00386736f, 0.04788959f, 0.07505187f, 0.09849160f, -0.01795999f, -0.05442887f, 
    0.08124373f, -0.01975292f, 0.01463812f, -0.02367900f, 0.02824412f, 0.04570521f, -0.06142075f, 0.11914179f, 
    0.03251775f, -0.03541066f, 0.09173078f, 0.20277664f, -0.18077086f, -0.01368253f, 0.06060987f, 0.06120202f, 
    -0.00709173f, 0.04515754f, 0.00147910f, -0.05194859f, 0.00482199f, -0.00085867f, 0.00536625f, -0.03625365f, 
    0.02550479f, 0.01965991f, -0.00830213f, 0.01959082f, -0.00323123f, 0.07645358f, -0.17045395f, -0.02155302f, 
    -0.03147155f, 0.02748398f, 0.03209023f, 0.02115194f, 0.01628069f, -0.11088363f, -0.02361059f, 0.00730218f, 
    -0.05983087f, -0.06887177f, -0.04646644f, -0.04948793f, 0.01027638f, 0.05255376f, 0.00241797f, -0.09734672f, 
    -0.08344046f, 0.03505756f, -0.00126982f, 0.06912756f, 0.12654209f, 0.10286122f, 0.08970235f, 0.03130027f, 
    -0.01896646f, 0.02589872f, -0.01471474f, 0.02738422f, 0.00206960f, -0.01131181f, -0.05439004f, -0.07816727f, 
    0.05881922f, -0.01463917f, -0.09789382f, 0.02224121f, 0.00311136f, -0.14580916f, -0.23223054f, 0.08250862f, 
    0.14079149f, 0.00635344f, -0.00098814f, -0.12477998f, 0.04004374f, -0.00497485f, 0.04451219f, -0.00479975f, 
    0.08327432f, 0.01596742f, -0.00417022f, 0.02272822f, -0.00030157f, -0.06709119f, 0.01952964f, -0.00141068f, 
    -0.01409517f, 0.07589251f, -0.01058488f, -0.16165186f, -0.05462479f, -0.01450916f, -0.00449355f, -0.04534276f, 
    -0.02262360f, 0.05675690f, -0.05299466f, 0.07367092f, -0.03289521f, 0.01308411f, -0.02177747f, 0.01400534f, 
    -0.01740916f, -0.02937525f, 0.02532604f, -0.00938648f, -0.10344002f, -0.03360021f, 0.01757801f, 0.01527185f, 
    0.05903757f, 0.00344781f, 0.06373474f, 0.07717711f, -0.02743883f, 0.14063254f, -0.00469295f, 0.02941316f, 
    0.02433393f, -0.04210443f, -0.07125326f, 0.05230383f, -0.04996830f, 0.05297938f, -0.07644440f, 0.02373927f, 
    0.08463582f, 0.05174766f, 0.01634656f, 0.00599168f, -0.04018821f, -0.09205545f, -0.06130935f, -0.01367547f, 
    0.08252663f, -0.02597120f, -0.09840459f, -0.01500269f, 0.07231032f, 0.13673432f, 0.10445025f, -0.11574309f, 
    -0.02223390f, 0.07585482f, 0.07210942f, -0.08712507f, -0.32650551f, -0.04237729f, -0.31841606f, -0.06721393f, 
    0.04680173f, 0.08128335f, 0.09361641f, -0.08078689f, 0.02018912f, -0.05050300f, 0.06722629f, 0.02589569f, 
    0.04213444f, -0.03561933f, 0.00562559f, -0.07273915f, 0.00627111f, -0.10461412f, 0.05042601f, 0.04136436f, 
    -0.44616196f, -0.07198659f, -0.05291319f, -0.00688126f, -0.09894840f, 0.07487997f, -0.08610174f, 0.05085168f, 
    -0.00351512f, -0.13377172f, 0.04386992f, -0.02478383f, -0.07205958f, -0.05192343f, 0.02846612f, -0.04533455f, 
    0.01661257f, -0.01439303f, 0.01487294f, 0.03736056f, 0.05952897f, 0.15314044f, 0.10683189f, -0.09629762f, 
    -0.19028194f, 0.03513858f, 0.05176257f, -0.05921506f, -0.04745159f, 0.13598430f, 0.00461526f, -0.00509353f, 
    -0.01823187f, 0.04536795f, -0.10149761f, 0.07584943f, 0.03986035f, -0.02677335f, 0.07873423f, 0.05008259f, 
    -0.43493542f, -0.08696393f, -0.11534501f, -0.07773420f, -0.00093339f, 0.02859404f, 0.05845803f, 0.04751388f, 
    0.00415479f, -0.02776561f, 0.08351045f, 0.01494481f, 0.00645278f, 0.00861497f, -0.01386919f, -0.01785662f, 
    -0.01836923f, -0.04498788f, -0.13660063f, 0.09120832f, -0.06805719f, 0.02226809f, -0.08247437f, -0.02017462f, 
    0.06645972f, 0.03381923f, -0.00072516f, -0.03498403f, -0.00084081f, -0.08125015f, 0.08395425f, 0.08086574f, 
    -0.00873114f, 0.01019230f, 0.04284662f, 0.01312847f, 0.01493909f, 0.01752048f, 0.12684231f, -0.07209697f, 
    -0.14212538f, 0.00182831f, -0.06396467f, -0.12196203f, -0.13066635f, 0.00424022f, -0.01398888f, -0.00830125f, 
    0.07461946f, 0.06771324f, 0.04861091f, -0.03472734f, -0.05330255f, -0.02502452f, -0.03938884f, 0.00712281f, 
    -0.07414175f, 0.02429496f, -0.15334985f, 0.02392556f, -0.21888687f, 0.22602940f, -0.02483331f, 0.06739235f, 
    -0.01197529f, -0.03172636f, 0.03622728f, -0.03699459f, 0.02141530f, -0.15952112f, -0.05150146f, 0.00363158f, 
    0.02963808f, 0.00827850f, 0.02793437f, 0.02549387f, -0.08892570f, 0.02542863f, 0.11542471f, 0.01518750f, 
    0.00080560f, -0.16334935f, -0.12234743f, -0.02651562f, 0.09284636f, 0.01883838f, -0.06350987f, -0.06370273f, 
    0.01161797f, 0.07778706f, 0.07124014f, 0.03662441f, 0.04880611f, -0.05124927f, -0.01200094f, -0.02703829f, 
    -0.04117859f, -0.03695754f, -0.00704549f, -0.07311514f, -0.46573785f, -0.02417746f, -0.08266781f, 0.04302395f, 
    -0.17854656f, 0.10688428f, 0.02381143f, 0.00371418f, -0.08402128f, -0.02131491f, -0.00868919f, 0.00957416f, 
    0.02604108f, -0.06085072f, -0.04322365f, 0.04324176f, -0.03899180f, 0.02637929f, -0.00698220f, -0.05395845f, 
    0.13268201f, -0.02026470f, 0.03718455f, 0.01605836f, 0.06860840f, 0.02650352f, 0.04003137f, -0.02992963f, 
    0.01630908f, 0.05153748f, 0.00112103f, 0.04063334f, -0.02455853f, 0.03740563f, 0.05374718f, -0.10210696f, 
    -0.00673781f, -0.00415960f, 0.00190875f, -0.00551166f, 0.02092761f, -0.07992589f, 0.04814180f, 0.01120827f, 
    -0.10678466f, 0.05434192f, 0.03005169f, -0.06037899f, -0.02025297f, -0.04833603f, -0.00474464f, 0.00836850f, 
    0.00420964f, 0.08794063f, -0.01681369f, 0.07578961f, -0.02995225f, -0.00955791f, 0.13710618f, 0.01998177f, 
    0.03915991f, 0.08415177f, -0.01565441f, 0.07516459f, 0.03970755f, -0.04611357f, -0.03593964f, 0.08305063f, 
    0.01896671f, 0.07252415f, -0.02649003f, -0.15113728f, 0.00792658f, 0.03153809f, 0.01093235f, 0.04475148f, 
    0.07853454f, 0.01478276f, -0.00695351f, 0.06912525f, -0.37706584f, -0.20339671f, -0.05621468f, -0.04105494f, 
    -0.09610564f, -0.05991939f, 0.09847517f, -0.02715202f, -0.01504741f, 0.11356545f, -0.09551948f, 0.16646609f, 
    0.11444861f, -0.01815430f, 0.00187536f, 0.04543022f, -0.00344400f, -0.11611728f, 0.01380860f, -0.06833439f, 
    0.02930191f, 0.06874880f, 0.06226814f, 0.00070058f, -0.13861886f, 0.01549997f, 0.05920146f, 0.04630857f, 
    0.05364323f, -0.04921028f, -0.05695004f, 0.01515326f, 0.02272881f, -0.05640854f, 0.02588521f, -0.07675517f, 
    -0.07415550f, -0.12824291f, 0.03600840f, 0.02437246f, -0.01220078f, 0.03779574f, 0.12962553f, 0.13019070f, 
    0.12713721f, -0.06926126f, -0.04214847f, 0.05887795f, -0.06572466f, 0.11046740f, 0.02234101f, -0.17114235f, 
    -0.01194346f, 0.07986289f, -0.01159897f, 0.01266675f, 0.02781186f, -0.21455851f, 0.03706839f, 0.02598060f, 
    -0.15027563f, -0.06377313f, 0.20465259f, 0.23109385f, -0.26539165f, -0.09676227f, -0.08498614f, 0.00722810f, 
    -0.02594163f, 0.03266999f, 0.08269043f, 0.05545287f, -0.05272757f, 0.01200990f, -0.15402997f, -0.05094372f, 
    -0.13396953f, -0.08368769f, -0.01650347f, -0.01388217f, 0.13114607f, 0.11450656f, 0.01488720f, 0.15252005f, 
    -0.08004717f, -0.02565437f, -0.08212659f, -0.06674233f, -0.02424576f, -0.00277152f, -0.04249979f, 0.04293197f, 
    0.05761193f, 0.14732961f, 0.14454204f, 0.04015384f, 0.03666566f, -0.04157167f, -0.13454629f, 0.01220779f, 
    -0.21941108f, 0.00445758f, -0.20524818f, 0.03245579f, 0.14157236f, 0.03728079f, 0.01591221f, -0.00426882f, 
    -0.00643061f, 0.14148793f, 0.04443078f, 0.06279200f, 0.10503287f, -0.08426842f, 0.02079492f, -0.12404943f, 
    0.08624864f, 0.05237382f, 0.07011032f, -0.14659923f, -0.00651735f, 0.02896433f, -0.01536379f, -0.01308014f, 
    0.15699941f, -0.02687225f, -0.05249746f, -0.04610202f, 0.03565842f, -0.07299162f, -0.05469160f, -0.01799076f, 
    0.05256854f, 0.08331206f, -0.00427311f, -0.05068374f, -0.02265391f, 0.07311217f, -0.23747766f, -0.00095378f, 
    0.03524688f, 0.04425072f, 0.02262830f, 0.03707976f, 0.03807316f, -0.00676286f, 0.03648948f, -0.08470725f, 
    -0.12053709f, -0.00762347f, 0.04031919f, 0.00102519f, -0.01857436f, -0.01569062f, 0.02082510f, 0.02090800f, 
    -0.02379518f, 0.04179023f, 0.03981605f, 0.05298253f, 0.03077789f, 0.00473620f, -0.03224547f, 0.15698117f, 
    0.04729492f, -0.02101944f, 0.04977120f, 0.01066517f, 0.05296873f, 0.05944934f, 0.03417652f, 0.01379349f, 
    -0.04541989f, 0.06125179f, 0.03496299f, -0.02262742f, 0.05439537f, -0.00140316f, 0.00913695f, -0.08636186f, 
    -0.01994513f, -0.05146764f, -0.16736537f, 0.22969688f, 0.24755518f, -0.02894476f, -0.13352259f, 0.07352896f, 
    0.09586902f, 0.03425962f, 0.03830660f, -0.03853729f, 0.06780206f, 0.00208428f, 0.11644984f, 0.00570623f, 
    0.09961167f, -0.07978572f, -0.07769185f, -0.12426001f, 0.06666610f, -0.09160311f, 0.02907560f, 0.21836394f, 
    0.15859067f, -0.04746730f, -0.13054745f, -0.06490800f, -0.01272717f, -0.00678941f, 0.04429766f, -0.04630660f, 
    0.02984820f, 0.05281535f, 0.04373731f, 0.07792763f, -0.09934516f, -0.02290884f, -0.10803590f, -0.11491743f, 
    -0.17278963f, -0.35073590f, 0.04499374f, 0.03475504f, 0.07955451f, 0.01651129f, 0.02121910f, 0.07737231f, 
    -0.12651207f, 0.08608304f, 0.07028615f, 0.00220943f, -0.00221913f, -0.01368523f, -0.03418282f, -0.02146905f, 
    0.03581115f, 0.03323947f, -0.06492876f, -0.03111135f, -0.04644719f, 0.01520195f, 0.10058119f, 0.19611254f, 
    -0.09527531f, -0.12434526f, -0.09022144f, 0.02080639f, -0.06239861f, 0.13974047f, 0.09195205f, -0.00212636f, 
    0.02539019f, -0.01718131f, -0.05019607f, 0.02854502f, -0.03807725f, -0.08884628f, 0.13702321f, -0.00830799f, 
    0.02288290f, 0.04526522f, 0.00671055f, 0.04731234f, 0.08050582f, -0.04603589f, -0.00531162f, 0.02815246f, 
    -0.10439266f, -0.01160687f, -0.00949723f, 0.00524711f, -0.07886989f, 0.03319482f, -0.04089231f, 0.06641822f, 
    0.02874935f, -0.00763050f, 0.06678006f, 0.12210339f, -0.00582149f, -0.01404976f, -0.00858069f, -0.07025372f, 
    0.02139020f, 0.04611272f, -0.03830975f, -0.06343964f, 0.03007064f, 0.13308366f, 0.08068728f, 0.14436804f, 
    0.03336127f, -0.03855770f, -0.07518062f, -0.04422715f, -0.09694091f, -0.01295351f, 0.14522548f, 0.04242459f, 
    0.15156220f, 0.20934194f, -0.03295223f, -0.04667267f, -0.04269068f, -0.08348603f, -0.05176995f, 0.02827283f, 
    0.02314247f, -0.08722863f, 0.06985695f, 0.05731438f, -0.00913577f, 0.01666842f, 0.01935777f, -0.02750017f, 
    -0.03648111f, 0.01704764f, 0.05576808f, 0.06093688f, -0.32903206f, -0.03474095f, -0.32063147f, -0.13602428f, 
    -0.11159172f, 0.10234943f, 0.05496357f, 0.02995134f, -0.05957881f, -0.14934713f, -0.02802592f, 0.00801981f, 
    0.00884482f, -0.09047879f, -0.00559142f, 0.05404207f, -0.01890318f, 0.03173925f, -0.03141180f, 0.00541188f, 
    -0.53011292f, -0.16401409f, -0.02413884f, -0.10227811f, 0.06801551f, 0.10093857f, -0.07088471f, -0.11733667f, 
    0.01334091f, -0.12019195f, -0.04226100f, 0.06554943f, -0.09187917f, 0.01864920f, -0.00917930f, 0.03137691f, 
    0.01166083f, 0.05587690f, -0.03857918f, -0.04034175f, 0.09824669f, 0.04558001f, 0.08412011f, 0.10275970f, 
    -0.11323863f, -0.04677155f, 0.05399262f, -0.03014115f, 0.05296975f, -0.07630480f, -0.04338464f, 0.04552430f, 
    0.04723784f, 0.10591020f, 0.21118201f, -0.10426013f, -0.04848740f, -0.01485353f, -0.05605545f, -0.10197970f, 
    -0.09009777f, -0.08044803f, 0.01653388f, 0.07131742f, 0.01298219f, -0.09213940f, 0.03191134f, 0.06895065f, 
    -0.00171679f, 0.01484906f, -0.05798412f, -0.02737247f, 0.05973769f, -0.00740066f, 0.06631064f, -0.13699907f, 
    -0.07545134f, -0.01813510f, -0.04823754f, -0.03994828f, 0.04182983f, -0.00843985f, 0.04110112f, -0.02104570f, 
    0.03436649f, -0.07297046f, -0.01103776f, -0.13419968f, -0.01269323f, 0.05193594f, 0.00704652f, 0.01918055f, 
    0.10330488f, 0.09228528f, 0.04851532f, 0.01011109f, -0.00645760f, 0.08545217f, 0.06402774f, -0.05915476f, 
    -0.07154012f, -0.18074684f, -0.04713495f, -0.07041660f, 0.04491093f, 0.07380526f, 0.03527434f, -0.01033204f, 
    -0.00137310f, 0.07263101f, 0.03532023f, -0.01231911f, -0.00613458f, 0.02251483f, -0.04951883f, 0.05176248f, 
    -0.03769624f, -0.10977985f, -0.07848512f, 0.16246520f, -0.32839447f, -0.12673652f, 0.05248902f, -0.02929181f, 
    0.05929792f, 0.04231630f, -0.01650064f, 0.06815163f, 0.00288562f, 0.01987041f, -0.03379864f, -0.02754723f, 
    0.06831537f, 0.05820137f, 0.02133191f, -0.00118340f, 0.06571547f, -0.12110642f, -0.06563467f, -0.04170916f, 
    0.10658423f, 0.04700371f, -0.08811219f, 0.13152826f, 0.22801891f, -0.05640907f, -0.03306631f, 0.05976269f, 
    0.06448655f, 0.02851870f, 0.01382836f, -0.04116550f, 0.02500557f, 0.11664142f, 0.15720473f, 0.06495557f, 
    0.10092665f, -0.03474678f, -0.15480527f, -0.08860675f, -0.09034683f, 0.08050075f, 0.05559291f, 0.11070490f, 
    0.11828694f, -0.04075757f, 0.00618737f, 0.05004544f, -0.00514478f, -0.00461433f, 0.08249276f, -0.00341999f, 
    -0.01262385f, -0.05456201f, 0.02408320f, 0.00655922f, 0.06084778f, 0.03184307f, 0.05797944f, -0.07126265f, 
    -0.07367323f, 0.10957720f, -0.30402055f, -0.12067683f, -0.02000617f, 0.07563107f, 0.04800145f, 0.06591086f, 
    0.02970410f, -0.06647705f, 0.08362383f, -0.02638751f, -0.07155231f, -0.04846481f, -0.06706434f, 0.03234238f, 
    -0.13498826f, -0.07494988f, -0.03034188f, 0.02409071f, 0.05388601f, -0.07496804f, 0.04572719f, 0.11117905f, 
    0.03771053f, 0.03516706f, 0.02401104f, -0.00825415f, -0.06208200f, -0.06251763f, -0.00711730f, 0.03522516f, 
    0.04109545f, 0.01135528f, 0.09805983f, 0.00035158f, -0.03113787f, 0.05499835f, 0.10412119f, -0.02895588f, 
    0.04213701f, 0.06254708f, -0.03076251f, 0.11202753f, 0.00737317f, 0.01200713f, -0.02443274f, -0.04814530f, 
    0.00312426f, 0.03765289f, -0.07625056f, -0.15166852f, -0.01996373f, 0.11110920f, 0.09325118f, 0.00760197f, 
    0.12307679f, -0.12540537f, 0.05854069f, 0.10790417f, 0.20905571f, 0.07567252f, 0.08827390f, -0.03749019f, 
    0.02614456f, 0.00533557f, 0.00495074f, -0.00109653f, -0.09124683f, -0.01476349f, 0.02283851f, 0.00542360f, 
    0.03545989f, 0.07450442f, -0.05917371f, 0.09161536f, -0.04132692f, 0.06142269f, 0.08426742f, 0.05211600f, 
    0.15557173f, 0.01716753f, 0.07922976f, 0.13064830f, 0.08666708f, 0.03617033f, 0.06202191f, 0.03375592f, 
    -0.00953942f, -0.04147144f, 0.00043238f, -0.00052422f, -0.04388883f, -0.08406091f, -0.03265044f, 0.09193458f, 
    0.01945589f, 0.01455828f, 0.02631475f, 0.05470858f, -0.09595137f, -0.12286057f, 0.20372061f, 0.08783581f, 
    0.18775792f, 0.03143090f, -0.08129786f, -0.00236949f, 0.01828022f, 0.00218794f, -0.05637345f, 0.00069148f, 
    0.00959498f, 0.10034325f, 0.02028741f, 0.03192551f, 0.09044679f, -0.21430369f, -0.12951826f, 0.00269018f, 
    -0.17401342f, -0.06823573f, -0.04891765f, 0.08055304f, -0.02169264f, -0.10658644f, 0.06170661f, 0.04575114f, 
    -0.05612592f, 0.06316292f, -0.05833340f, 0.01897496f, 0.04680837f, -0.07291149f, -0.12711315f, -0.01661204f, 
    0.09991188f, -0.12833261f, 0.14027341f, 0.02907855f, -0.24314296f, 0.13874066f, -0.17090207f, -0.14472234f, 
    -0.10207272f, 0.03259891f, 0.03387794f, 0.09868014f, -0.05177597f, -0.22158962f, -0.02431357f, 0.04517374f, 
    -0.03275624f, -0.06606054f, 0.01154569f, 0.07552822f, -0.02963424f, -0.00859944f, 0.04187472f, 0.01580437f, 
    -0.29517987f, 0.18739715f, 0.08832613f, -0.06246633f, -0.12515740f, 0.06503265f, -0.16980648f, 0.11441888f, 
    -0.06209318f, -0.01099947f, 0.07745825f, -0.00075366f, -0.00941918f, -0.06654546f, -0.04543310f, 0.03838028f, 
    -0.04006138f, 0.12350992f, -0.01851036f, 0.00507397f, -0.12148884f, 0.08597594f, 0.15955912f, 0.11500302f, 
    -0.06385718f, -0.02245141f, 0.07178221f, 0.03995972f, -0.04335970f, -0.03115565f, 0.02252796f, -0.02672392f, 
    -0.04006524f, -0.07847452f, -0.04356417f, -0.06610695f, 0.01514027f, -0.02146622f, 0.03055696f, -0.05250733f, 
    0.00293889f, 0.04171318f, 0.04358660f, 0.03753233f, -0.02960639f, -0.04749227f, 0.04730443f, 0.00714449f, 
    -0.06999931f, -0.00888555f, -0.03159919f, 0.02710880f, -0.02901203f, -0.02795503f, 0.02803280f, 0.08677798f, 
    -0.02199297f, 0.14477283f, -0.03004410f, 0.02223502f, -0.32280713f, -0.10326626f, 0.22856280f, 0.15044573f, 
    -0.41752645f, 0.10572900f, -0.07679957f, -0.02549083f, -0.04262918f, -0.03737868f, 0.02129440f, -0.07049632f, 
    -0.03518609f, 0.02866693f, -0.04326414f, -0.05556246f, 0.07414025f, 0.15066652f, 0.04192897f, -0.05134885f, 
    -0.05595788f, -0.01434261f, 0.00116231f, -0.04958696f, 0.03508076f, 0.04762292f, -0.00764334f, -0.02998979f, 
    -0.06578373f, 0.06020799f, -0.03697020f, -0.11212031f, 0.02964787f, -0.03625873f, 0.00270870f, -0.00909645f, 
    -0.01373579f, -0.13745359f, 0.03857494f, -0.05567008f, -0.11575171f, 0.26856682f, -0.12537503f, -0.26368573f, 
    -0.02315019f, -0.02286873f, 0.07244191f, 0.08793270f, -0.04428140f, -0.03726078f, 0.12004995f, -0.06104518f, 
    -0.02948888f, -0.14302914f, 0.00318241f, 0.03078817f, 0.04837851f, -0.07793958f, -0.06101058f, 0.00889827f, 
    -0.18504725f, -0.00547783f, -0.07518514f, 0.12527995f, 0.00839705f, 0.01906553f, 0.03075078f, -0.05616337f, 
    -0.00179798f, 0.03547666f, 0.02291553f, -0.04470441f, 0.08652007f, 0.03365546f, 0.01148607f, 0.01117866f, 
    -0.04173567f, 0.00708316f, -0.10774519f, -0.08606711f, -0.00737709f, 0.05151645f, 0.00643041f, -0.09401924f, 
    0.06742300f, 0.06716960f, 0.12377183f, -0.03429133f, 0.03913640f, 0.07763126f, -0.01226962f, 0.01895826f, 
    -0.05246498f, 0.01325276f, 0.05849786f, -0.11315163f, 0.01435204f, 0.14915799f, -0.08827795f, -0.01877162f, 
    -0.03776158f, -0.11659268f, -0.02220481f, -0.00070934f, 0.16096795f, 0.02249905f, 0.03452673f, 0.01277811f, 
    -0.05456859f, -0.02578444f, -0.00687281f, -0.01352061f, 0.02008242f, -0.05528303f, -0.01765300f, -0.07801508f, 
    -0.02174955f, 0.05535167f, -0.02501691f, 0.02175449f, -0.03176187f, -0.10744613f, -0.02866462f, 0.11425176f, 
    0.08007024f, 0.02081354f, 0.04221669f, -0.02562937f, -0.07858365f, 0.02634770f, -0.06039048f, -0.09914517f, 
    0.00716437f, 0.01747754f, 0.01425948f, 0.02090981f, -0.09158693f, -0.05679817f, 0.08165875f, 0.04431085f, 
    -0.12951182f, 0.13951911f, 0.05853087f, -0.00758828f, -0.17338991f, 0.06832451f, 0.00640669f, 0.06093376f, 
    0.00926249f, 0.03375613f, 0.02168330f, -0.05146017f, 0.02253077f, -0.02186344f, 0.05981225f, 0.00676232f, 
    0.01951018f, -0.03732802f, -0.01428714f, -0.06552129f, 0.17835347f, 0.04520695f, 0.18459159f, 0.01719246f, 
    -0.00430287f, 0.10696183f, 0.04443282f, 0.07439470f, -0.01556131f, -0.05087012f, -0.03428506f, -0.02572283f, 
    -0.07571228f, 0.02395169f, 0.02005605f, 0.07161165f, -0.00917033f, -0.00542194f, -0.02720302f, -0.05932843f, 
    0.12243265f, 0.07747011f, 0.01897680f, 0.10318275f, -0.00753327f, -0.02149153f, -0.05881999f, -0.04838793f, 
    0.01220508f, 0.04005131f, -0.00079849f, 0.02458084f, 0.03911979f, -0.01453736f, -0.00934610f, 0.05802078f, 
    -0.02396384f, -0.03859852f, -0.05072160f, -0.15865105f, 0.26075670f, -0.22169344f, -0.08860128f, -0.01962848f, 
    -0.06367951f, 0.07762425f, 0.09122965f, 0.02068532f, -0.02051843f, -0.07508963f, -0.09222950f, 0.01098128f, 
    0.10194851f, -0.08744317f, 0.00467000f, 0.01600864f, -0.02025459f, 0.05649829f, 0.03793838f, 0.06117598f, 
    -0.06916890f, -0.00003045f, -0.18762690f, -0.30545107f, -0.01443329f, -0.07953741f, 0.00676210f, -0.03553215f, 
    -0.00111769f, -0.05869259f, -0.03979722f, 0.01193483f, -0.01191809f, -0.05661022f, -0.01267613f, 0.06719363f, 
    -0.00366237f, 0.02317648f, 0.02201734f, 0.03595069f, -0.14564545f, 0.03924352f, -0.13664399f, -0.18833807f, 
    0.12362803f, -0.06532240f, 0.03368349f, 0.03529510f, -0.03639478f, 0.00733100f, -0.02465890f, -0.01233026f, 
    0.03530166f, -0.00935838f, -0.02429689f, -0.00384224f, 0.00721980f, 0.09329831f, 0.00627423f, 0.05077530f, 
    0.09136396f, -0.01651803f, -0.13808624f, 0.12331174f, 0.02819594f, 0.01573506f, 0.05192833f, -0.00091846f, 
    -0.01979351f, 0.02162828f, 0.03363798f, -0.03026886f, -0.01027539f, -0.01011204f, -0.03511902f, -0.03663315f, 
    -0.00090838f, 0.05798691f, -0.06110679f, 0.00906348f, -0.17127006f, 0.03519066f, 0.08244900f, -0.24376824f, 
    0.07406747f, 0.01530807f, -0.15203051f, -0.12660831f, -0.07751479f, -0.14125265f, -0.06889949f, 0.00425134f, 
    -0.04227500f, -0.00886231f, 0.04740116f, -0.00811853f, 0.09445606f, 0.02885423f, -0.05806914f, 0.04247363f, 
    -0.16429454f, 0.27445006f, 0.05899362f, -0.07438289f, -0.33203813f, 0.05030477f, 0.01821424f, 0.11341976f, 
    -0.00609259f, 0.05067300f, 0.00576963f, 0.02153743f, -0.07454492f, -0.04763535f, -0.15165660f, -0.03700046f, 
    -0.03383919f, -0.04426383f, -0.00087142f, 0.12946770f, -0.05663693f, 0.00247762f, 0.00467128f, -0.28142631f, 
    0.07555172f, -0.06636378f, -0.02752431f, 0.02925507f, -0.09135289f, -0.10405613f, 0.05392278f, -0.06871255f, 
    0.08748248f, 0.05227735f, -0.06373715f, 0.06120741f, -0.03688763f, -0.00529090f, 0.06203018f, 0.05540330f, 
    0.35897675f, 0.01931356f, 0.14698300f, -0.07291527f, 0.21765600f, 0.01792851f, -0.03195030f, 0.01994801f, 
    0.02057921f, -0.03296370f, -0.00880572f, 0.00201761f, 0.05471165f, -0.08261039f, -0.00935341f, -0.10406767f, 
    -0.04160020f, 0.02423860f, 0.01304998f, 0.01144276f, -0.13142821f, 0.18603659f, -0.06625256f, 0.07387397f, 
    -0.08937556f, -0.03223027f, -0.05043703f, 0.06364758f, -0.00911930f, 0.05361433f, 0.05714588f, 0.04742074f, 
    0.03515201f, 0.01036048f, -0.01581358f, 0.06992859f, -0.08245914f, -0.03891552f, -0.06064679f, -0.01295515f, 
    -0.17716464f, 0.03093269f, 0.09601017f, 0.05614925f, 0.07221608f, -0.02399924f, 0.00052237f, 0.06019860f, 
    -0.04505372f, -0.02896977f, -0.04027643f, -0.04287639f, -0.04931160f, 0.03839449f, 0.03072938f, 0.04897495f, 
    -0.03819719f, -0.05678487f, 0.07148184f, 0.06591573f, -0.02935792f, -0.24291565f, -0.09207774f, -0.18048991f, 
    0.30557919f, -0.04658913f, 0.04053938f, -0.01084025f, 0.06044133f, 0.01568215f, -0.08447085f, -0.02250515f, 
    -0.00077819f, 0.01202860f, -0.04585735f, -0.05854377f, -0.01177875f, 0.08039787f, -0.11065720f, 0.09672679f, 
    0.36018229f, -0.14253639f, 0.03432025f, 0.05786051f, -0.02461123f, -0.01393867f, 0.00199150f, 0.04768850f, 
    -0.01970262f, -0.05278538f, 0.01839097f, -0.06495802f, 0.04602076f, 0.00417514f, 0.07090764f, -0.04557075f, 
    0.04728118f, 0.00731727f, 0.06265446f, 0.01380356f, 0.35890201f, -0.27032858f, -0.01369977f, -0.01839643f, 
    0.20588355f, 0.02038311f, -0.00719042f, 0.08910708f, -0.00405252f, -0.02513355f, 0.03192730f, -0.05280205f, 
    0.06737052f, 0.04531002f, 0.00576769f, -0.02449628f, -0.03143800f, -0.02327572f, -0.15078755f, 0.00721496f, 
    -0.04350149f, -0.13335368f, -0.18449166f, -0.17540592f, 0.12125079f, -0.03432043f, 0.03646851f, -0.03847492f, 
    -0.00155252f, -0.04300553f, -0.02347781f, -0.06360387f, -0.00099916f, 0.06326686f, -0.02965319f, 0.02220738f, 
    -0.00873850f, 0.08405384f, 0.05237977f, 0.06076058f, 0.01866309f, -0.50037229f, -0.05039571f, 0.01197304f, 
    0.00258674f, -0.06164386f, 0.05752952f, 0.06532013f, -0.00527443f, -0.03788892f, -0.01329804f, 0.07327408f, 
    -0.03923791f, 0.03742138f, 0.07397097f, -0.04627433f, -0.02146623f, -0.01163267f, -0.01141583f, 0.01336221f, 
    -0.10357593f, 0.00570039f, -0.02845933f, 0.08000628f, -0.14584799f, 0.01019450f, -0.01186146f, 0.05562085f, 
    -0.01628678f, -0.00972077f, 0.01281826f, 0.04734532f, -0.03639145f, 0.02253825f, -0.03929216f, 0.04675801f, 
    -0.01859906f, -0.02828615f, 0.03790167f, 0.03312766f, 0.08345219f, -0.20631686f, -0.02693183f, 0.19106597f, 
    0.02778311f, -0.04267937f, -0.03927791f, -0.02403300f, -0.03740215f, 0.04459020f, 0.09180261f, 0.07763399f, 
    -0.05092071f, 0.00124534f, -0.00727271f, -0.07562672f, -0.00603047f, -0.00204691f, -0.12896533f, -0.15398891f, 
    -0.16583455f, 0.13009249f, 0.03756785f, -0.01241342f, -0.05053002f, 0.00916032f, 0.04725340f, -0.05498746f, 
    0.03845587f, 0.04855451f, 0.01600102f, 0.07251284f, 0.02004315f, 0.00359902f, -0.06824510f, -0.01604244f, 
    0.05647299f, -0.01977165f, -0.00742377f, -0.08755768f, 0.08505016f, -0.06044226f, -0.16616499f, -0.20006765f, 
    0.01587571f, -0.03314580f, -0.01536551f, -0.03030718f, -0.06593700f, -0.05567954f, 0.01785597f, -0.04290983f, 
    -0.15696588f, -0.00202777f, 0.09973282f, -0.21524389f, -0.06096502f, 0.10403209f, -0.02258025f, 0.08239867f, 
    -0.00441276f, -0.05275371f, -0.01251641f, 0.11026212f, 0.05818512f, -0.09899968f, 0.13881503f, -0.00404765f, 
    0.06520610f, -0.01325143f, 0.07381850f, 0.05174994f, -0.00785541f, 0.02546745f, 0.02820400f, 0.09662812f, 
    0.00018625f, 0.12601042f, -0.06903046f, 0.06685477f, -0.09211644f, 0.08642460f, -0.06212405f, 0.08926824f, 
    -0.08438201f, 0.08806001f, 0.09752876f, -0.08985858f, 0.04061313f, 0.01539319f, -0.03685666f, 0.00234130f, 
    0.01365853f, 0.03152930f, -0.14271636f, 0.04897441f, 0.00311229f, 0.05407251f, 0.00090169f, -0.02357060f, 
    -0.19583978f, -0.04420731f, -0.01625613f, 0.22204122f, 0.16414565f, 0.13155192f, -0.04815331f, 0.03791288f, 
    0.05003698f, -0.07481034f, -0.13169733f, 0.05447014f, -0.00893358f, 0.03674278f, 0.01843277f, -0.00818123f, 
    0.03029673f, 0.13402507f, 0.12081054f, 0.03483932f, 0.19012047f, -0.12969676f, -0.06903319f, -0.05599958f, 
    0.23321795f, -0.00964555f, 0.00035183f, -0.02755926f, -0.03943611f, -0.02141944f, -0.05895928f, -0.02208354f, 
    -0.09612758f, -0.05596240f, -0.08416059f, -0.01111348f, 0.07029303f, -0.03700351f, 0.09308133f, -0.08671495f, 
    -0.06420711f, -0.19421913f, 0.00409067f, -0.30188307f, 0.09961654f, -0.04103658f, -0.02996302f, -0.00914538f, 
    -0.08791751f, -0.11887304f, -0.00817596f, -0.05535823f, -0.12521946f, 0.03398685f, -0.02970248f, -0.02510413f, 
    0.01413227f, 0.00933166f, 0.00128682f, 0.05607175f, 0.04095340f, 0.05247104f, -0.05653823f, -0.08634749f, 
    -0.03937680f, -0.02220778f, 0.05773553f, 0.03623075f, 0.02625377f, -0.01843988f, -0.00384559f, -0.01781055f, 
    -0.04597697f, -0.02777163f, 0.02715660f, -0.00651950f, 0.12482464f, 0.02103972f, 0.10549263f, 0.01580746f, 
    -0.32962582f, 0.09284583f, -0.13070902f, 0.19890100f, -0.01212832f, -0.03616298f, -0.01488218f, 0.03678432f, 
    0.03890268f, 0.02357141f, -0.03275181f, -0.04499625f, 0.02627750f, -0.06592116f, -0.03638255f, 0.03264452f, 
    -0.03129419f, -0.05890390f, -0.06815962f, -0.03300674f, -0.05331416f, 0.14847086f, -0.07999337f, 0.06644631f, 
    -0.11036658f, -0.01923339f, -0.00219947f, 0.06982134f, 0.01306739f, -0.11502676f, 0.00524740f, 0.03779168f, 
    -0.02753622f, 0.00145360f, -0.03619127f, -0.01161899f, -0.01457773f, 0.09367070f, -0.04599376f, 0.02937675f, 
    -0.01041211f, 0.16949263f, -0.05940123f, -0.12170094f, 0.01608046f, -0.07048950f, -0.01912140f, 0.07757577f, 
    -0.06669196f, -0.00578978f, -0.05419878f, 0.01366976f, -0.09361302f, -0.03048128f, -0.09238263f, 0.06937657f, 
    -0.15209429f, 0.12570083f, 0.05403306f, 0.15033895f, -0.05833897f, 0.14918092f, 0.02957920f, -0.06283280f, 
    0.03106260f, -0.02437624f, 0.03727532f, 0.02875913f, 0.04094921f, 0.01634718f, -0.11135874f, 0.04999002f, 
    0.01525116f, -0.03454856f, 0.05095399f, 0.02972741f, -0.06549918f, 0.06313799f, 0.14622785f, 0.03307759f, 
    0.07470979f, -0.05799396f, -0.03501656f, -0.12417559f, -0.04755760f, -0.06245195f, -0.01505294f, -0.05650436f, 
    -0.00661930f, 0.01896399f, -0.03961937f, 0.07009561f, -0.00663493f, -0.05987619f, 0.03699989f, 0.04140988f, 
    -0.00898706f, 0.00210955f, 0.01640797f, 0.04196517f, -0.24174088f, 0.11953889f, 0.06570628f, 0.05690990f, 
    -0.03871948f, 0.11860888f, 0.00553097f, 0.03649180f, 0.06688885f, -0.11376414f, -0.03984788f, 0.03672248f, 
    -0.05472418f, 0.00672440f, -0.09460663f, 0.04013265f, -0.09092693f, 0.05349040f, 0.02313595f, -0.12439540f, 
    -0.07594842f, -0.23123634f, 0.18261322f, 0.07435662f, 0.10927870f, 0.00466676f, -0.04048577f, -0.01431639f, 
    0.00689454f, -0.04048213f, -0.00316291f, -0.00444758f, 0.09543580f, -0.00430521f, -0.05752023f, 0.04259105f, 
    0.02837053f, -0.02867571f, -0.00990243f, -0.07305361f, 0.07446900f, -0.11640749f, -0.11401270f, -0.00977887f, 
    0.04313516f, -0.05630253f, 0.10153656f, -0.07045530f, -0.07009324f, -0.02181906f, 0.04018874f, -0.12177321f, 
    -0.04758410f, -0.03306592f, 0.12627706f, -0.04797184f, 0.05972829f, 0.10590053f, -0.07182331f, 0.02283764f, 
    0.05162932f, -0.24866763f, -0.08292615f, 0.07407041f, -0.13881250f, 0.04822827f, 0.11230856f, -0.04774142f, 
    0.08154699f, 0.05521841f, -0.11664923f, -0.05949844f, 0.05434610f, -0.03855418f, 0.01470721f, 0.04488837f, 
    -0.07886457f, 0.04741653f, -0.18759787f, -0.01722772f, -0.03677911f, -0.43471909f, -0.00356642f, -0.25922266f, 
    -0.01089402f, -0.07297523f, 0.01283274f, 0.00743896f, -0.01774091f, 0.04421600f, -0.06071598f, 0.03936708f, 
    0.03503918f, 0.12109215f, -0.01001043f, -0.03516968f, -0.02506860f, -0.11629914f, -0.05846369f, 0.02590856f, 
    -0.21320637f, 0.05190835f, -0.02599054f, -0.04937323f, 0.06106421f, 0.01363392f, 0.00675660f, 0.12436617f, 
    -0.08275442f, 0.03670279f, 0.02951623f, -0.01432926f, 0.07659364f, -0.02190147f, -0.00236244f, 0.00168214f, 
    0.06352047f, -0.09811820f, 0.05307197f, 0.17006253f, 0.14753401f, -0.00705549f, 0.16180474f, -0.22239432f, 
    0.02959902f, 0.01786165f, -0.06749120f, 0.07040118f, -0.00432409f, 0.05983022f, -0.07130765f, 0.03025621f, 
    -0.14073220f, -0.05629696f, -0.04494749f, -0.03656294f, 0.00543872f, 0.05549560f, 0.06527245f, 0.08304454f, 
    0.08398470f, 0.20808378f, 0.16680269f, -0.00111948f, -0.11315130f, 0.07130928f, -0.01749771f, 0.02316235f, 
    -0.03642083f, -0.00520751f, -0.08432162f, -0.00182907f, 0.04034013f, 0.05169141f, 0.08773507f, 0.15393025f, 
    -0.03853014f, -0.10640614f, 0.02163343f, -0.04777308f, -0.21591309f, 0.12633601f, 0.11369827f, 0.08280131f, 
    -0.10355666f, 0.05769034f, -0.01449347f, 0.09190188f, 0.05534309f, -0.03275787f, 0.00946840f, 0.00412800f, 
    -0.13467745f, 0.02168094f, 0.02923838f, 0.07198407f, -0.01150274f, -0.17263086f, 0.02703179f, -0.00645514f, 
    -0.00100888f, -0.25911042f, 0.15527183f, -0.06958869f, 0.11648013f, 0.13697070f, 0.08859431f, 0.08044378f, 
    -0.03756690f, -0.00819814f, 0.07488392f, -0.02705614f, 0.06251720f, 0.03526950f, -0.07287597f, 0.02308598f, 
    0.03475886f, -0.03547103f, 0.12187898f, -0.13402250f, 0.02773089f, 0.02031169f, 0.01479118f, -0.09370657f, 
    -0.00869219f, 0.00670895f, 0.04489167f, -0.05220364f, -0.12771662f, -0.11802315f, -0.04246695f, -0.15456556f, 
    0.01353450f, -0.12617332f, -0.00471068f, -0.12910797f, -0.08419879f, 0.09323598f, -0.00460149f, 0.09937801f, 
    0.02750104f, -0.01868293f, -0.02994594f, -0.08196260f, -0.04851100f, 0.10589901f, 0.05074240f, -0.01242954f, 
    -0.12978487f, -0.02234610f, 0.01396092f, 0.08828103f, 0.05994593f, -0.03639391f, -0.13087898f, 0.07532448f, 
    -0.15776469f, 0.04531964f, 0.00577002f, 0.03860111f, -0.00895250f, -0.17439146f, -0.07512278f, -0.06931308f, 
    0.21282871f, -0.03591535f, 0.02905973f, -0.06750618f, 0.04940925f, -0.01819996f, -0.06129929f, -0.01544077f, 
    -0.00030289f, -0.00574655f, 0.07231090f, -0.01936605f, 0.02936659f, -0.03450185f, -0.12430483f, 0.07760946f, 
    -0.00798726f, -0.20183010f, -0.05762317f, -0.18057629f, 0.02574932f, -0.02292361f, 0.05610658f, 0.01445481f, 
    -0.03426129f, -0.10010383f, 0.00122409f, -0.08428407f, 0.07961385f, 0.06672439f, 0.02089608f, 0.03250526f, 
    -0.02675489f, 0.01278542f, -0.01499564f, 0.08842348f, -0.35083500f, 0.25538287f, 0.05209039f, 0.05327625f, 
    -0.26823989f, -0.04205932f, -0.07463165f, -0.01088604f, 0.08773097f, 0.00672368f, 0.04148086f, -0.01989704f, 
    0.01463299f, 0.05885630f, 0.00204448f, -0.11512130f, -0.00388529f, -0.07268178f, -0.06178292f, -0.03887993f, 
    -0.05641388f, 0.21446079f, -0.01224014f, 0.00180203f, -0.37051964f, 0.04542709f, -0.02832871f, 0.02138136f, 
    0.03724098f, 0.00972400f, 0.09628916f, 0.10731639f, -0.05603977f, 0.04834326f, -0.15306942f, 0.04136220f, 
    -0.11895982f, 0.00288319f, 0.00946832f, -0.03115246f, -0.34012499f, 0.10445806f, -0.00926725f, 0.10981251f, 
    -0.08438902f, -0.10742887f, -0.04461213f, -0.00760020f, -0.02418519f, -0.01346470f, -0.06839545f, -0.03777848f, 
    -0.01326904f, -0.04281743f, 0.09129672f, 0.02562223f, 0.01067975f, -0.10253850f, -0.09674588f, -0.09686397f, 
    -0.08615349f, 0.06227336f, -0.05646217f, 0.04309414f, 0.05092253f, -0.08441333f, 0.01836545f, 0.00093520f, 
    0.01009105f, 0.04121933f, -0.03204464f, 0.04511014f, 0.13463150f, 0.01055929f, 0.05887491f, 0.00830878f, 
    0.00691326f, 0.02237965f, -0.00571872f, -0.01621493f, -0.32982674f, 0.06466819f, -0.46712965f, -0.06213608f, 
    -0.04359758f, 0.05742327f, 0.12409136f, -0.12793663f, 0.03863555f, 0.07490657f, -0.08938002f, -0.06357116f, 
    -0.06169339f, 0.03642889f, -0.07497316f, 0.04698159f, 0.04775431f, 0.12933035f, 0.12195656f, 0.03391699f, 
    0.13948198f, -0.08917735f, 0.02348004f, 0.11328801f, 0.14765927f, 0.00663238f, 0.09400833f, -0.04714790f, 
    -0.02154410f, -0.13595317f, -0.00401015f, -0.00694185f, -0.07893514f, 0.02267044f, 0.05179678f, 0.04583356f, 
    0.01942354f, 0.12591960f, 0.03278770f, -0.01664886f, -0.01778327f, -0.39628929f, -0.04491415f, -0.20188066f, 
    0.06850034f, -0.03443212f, 0.03624719f, -0.05986179f, 0.10207747f, 0.00498395f, -0.01759244f, -0.01614858f, 
    0.00793613f, 0.07057451f, 0.07732620f, -0.05806573f, 0.01785881f, -0.06474466f, -0.09261950f, -0.01554117f, 
    0.12476427f, -0.38644302f, -0.08036878f, 0.16298003f, -0.08058169f, -0.16871583f, 0.00914153f, -0.03660296f, 
    0.07445544f, -0.00362741f, -0.09054390f, 0.04301140f, 0.11019411f, 0.00688094f, 0.07435384f, -0.13756603f, 
    -0.03180309f, 0.04356450f, -0.03143552f, -0.05833123f, 0.13400307f, -0.09682234f, -0.16403452f, -0.00801219f, 
    -0.01005729f, 0.04305121f, 0.04081336f, 0.05186847f, 0.05630384f, 0.02004440f, -0.04836667f, -0.07538954f, 
    0.08152747f, 0.00563135f, 0.09443440f, 0.05505535f, 0.02576988f, -0.06132953f, -0.10255010f, 0.03588197f, 
    -0.21762311f, 0.15246148f, 0.01340087f, 0.14881450f, 0.11687052f, -0.00197387f, -0.00234741f, -0.03465612f, 
    0.10905965f, -0.00988191f, -0.00844192f, 0.07325137f, -0.01017952f, 0.04002189f, 0.02751927f, -0.02392094f, 
    0.03718254f, -0.09598716f, -0.04256382f, -0.08186143f, 0.29260740f, -0.25961515f, -0.12356450f, 0.13429654f, 
    -0.02993686f, -0.09795347f, -0.05669989f, 0.02052796f, 0.04357808f, 0.02521949f, 0.04926349f, -0.02679009f, 
    -0.05959425f, -0.05418485f, 0.04075018f, 0.01648687f, 0.00006147f, -0.03797150f, -0.05956053f, -0.02626418f, 
    0.03331595f, -0.10277022f, -0.13498175f, 0.19585802f, -0.08552674f, -0.07095623f, 0.08295755f, -0.00434925f, 
    0.09264472f, 0.02602157f, -0.05238147f, 0.05914446f, -0.05266199f, -0.02667129f, 0.02138582f, -0.01719528f, 
    -0.01472531f, 0.07015501f, -0.11164477f, -0.00529756f, 0.11420929f, -0.26029450f, 0.00163635f, -0.07846103f, 
    0.05324069f, -0.03834143f, 0.09078719f, -0.07609423f, 0.00056663f, -0.04397617f, 0.01026590f, 0.03328643f, 
    0.02342422f, 0.14633998f, 0.07070215f, 0.09160293f, -0.00036358f, 0.08380917f, -0.05679647f, 0.04450273f, 
    0.02059706f, -0.06616122f, -0.00751710f, -0.02374604f, 0.19795135f, 0.00703812f, -0.03354432f, 0.07077840f, 
    -0.02108856f, -0.01606453f, -0.06804635f, -0.01890922f, -0.07881811f, 0.03543928f, 0.04953868f, -0.03280799f, 
    -0.08091390f, 0.04751488f, 0.12403911f, -0.00177449f, 0.05929255f, -0.07855219f, -0.10540145f, -0.04601055f, 
    0.03694599f, -0.00575828f, 0.01973500f, -0.00580495f, 0.03053514f, -0.06546257f, 0.01811436f, -0.02145406f, 
    0.02997068f, 0.00601344f, -0.05233519f, 0.07422473f, -0.03664967f, -0.03078766f, 0.09386336f, 0.02782634f, 
    -0.17319266f, -0.15210105f, -0.04148605f, 0.17145939f, 0.18678676f, 0.10266291f, -0.00684512f, -0.01838072f, 
    0.04345086f, -0.07726100f, -0.01226644f, -0.07390188f, 0.08542719f, 0.00258090f, -0.17666288f, 0.15688957f, 
    0.03034282f, -0.05227793f, 0.03587646f, 0.06509974f, -0.25650382f, 0.17416134f, -0.05463998f, 0.08180106f, 
    -0.32501701f, 0.01558696f, 0.03939001f, 0.01843379f, 0.07270413f, 0.01553059f, -0.01174881f, -0.00454399f, 
    0.03517956f, 0.00257768f, -0.04935560f, -0.00966386f, -0.10995855f, 0.04851792f, -0.02055413f, -0.04193176f, 
    -0.02542991f, -0.04914564f, -0.06379186f, -0.03789886f, 0.02444299f, -0.02600722f, -0.05353795f, -0.05634324f, 
    -0.03555870f, -0.00226813f, -0.07142504f, -0.01940644f, 0.00700976f, -0.02385569f, 0.00722364f, -0.05739912f, 
    -0.02087800f, -0.07138423f, 0.00101789f, -0.02339487f, 0.21476151f, -0.36423829f, 0.03560294f, -0.09959102f, 
    -0.00711278f, -0.04194836f, -0.00860593f, 0.02253702f, -0.04894969f, -0.03155134f, -0.02767436f, -0.08023270f, 
    -0.05915312f, 0.03702981f, -0.04096644f, -0.03426956f, 0.05471634f, 0.00234741f, -0.01957003f, 0.01032702f, 
    0.07562682f, -0.24453256f, -0.03044126f, -0.05309710f, -0.03889371f, -0.02403480f, -0.02158199f, 0.01126376f, 
    -0.06393591f, -0.07433373f, -0.04028586f, -0.07233664f, -0.04084126f, 0.03706314f, -0.05064692f, -0.01136506f, 
    0.01469642f, -0.06185134f, 0.01855770f, 0.00199811f, 0.15221636f, 0.04078583f, 0.16933538f, 0.01852031f, 
    0.11276461f, 0.04859314f, 0.09662850f, 0.03289618f, 0.04278149f, 0.02578113f, -0.02032040f, 0.03342794f, 
    0.01075122f, 0.03554736f, 0.03055027f, -0.05243761f, 0.04099907f, -0.01005052f, 0.01237675f, -0.01124912f, 
    0.07938965f, 0.10309239f, 0.11665325f, 0.05531740f, 0.15226263f, 0.05945935f, 0.04978470f, -0.01371127f, 
    -0.00345676f, -0.01964815f, 0.01348667f, 0.01334300f, -0.01128172f, -0.02579455f, -0.06488521f, -0.01628754f, 
    -0.04707077f, -0.01745018f, 0.03020738f, 0.01326494f, 0.00884520f, 0.11700434f, 0.05954217f, 0.05458903f, 
    0.08456083f, -0.04406877f, 0.02483856f, -0.06389578f, -0.05716915f, -0.06059897f, -0.07368270f, -0.01634187f, 
    -0.04425207f, -0.06941763f, -0.06962888f, 0.06006873f, -0.00819608f, 0.04103311f, 0.04950144f, -0.06373107f, 
    0.07224444f, 0.11502416f, 0.03680658f, -0.00957852f, 0.02209697f, 0.00988682f, 0.04989018f, -0.06311073f, 
    0.01180816f, 0.01658382f, -0.06229629f, 0.02923338f, -0.00559064f, -0.00315718f, 0.01109609f, 0.04100454f, 
    -0.05073777f, 0.00594776f, 0.03256082f, -0.00218991f, 0.03104235f, 0.14172006f, 0.17581949f, 0.13105196f, 
    0.17854865f, 0.14097929f, 0.09666159f, -0.00990121f, -0.06189342f, 0.01313270f, 0.00223362f, 0.01891835f, 
    0.07262549f, -0.07641385f, -0.09377003f, 0.05909894f, -0.03052380f, -0.07752874f, 0.10826456f, 0.04184413f, 
    -0.06419691f, -0.18005182f, -0.07128969f, -0.06547501f, -0.01905976f, 0.00145867f, -0.11847362f, -0.03411779f, 
    -0.00860312f, -0.02356461f, -0.11369225f, 0.04102663f, -0.00811798f, -0.00930540f, -0.08516904f, -0.00697878f, 
    0.03901726f, -0.05772351f, 0.02537450f, 0.01482386f, 0.07671739f, 0.07398291f, 0.18468477f, -0.05713791f, 
    0.11148981f, 0.05393104f, 0.05595154f, 0.00199162f, -0.00898914f, -0.03423270f, -0.07711322f, 0.03219745f, 
    -0.05467876f, -0.00331763f, -0.05302855f, -0.07998749f, 0.00591320f, -0.02337233f, -0.02670169f, -0.01108739f, 
    0.10730824f, 0.06188919f, 0.13121468f, -0.00091360f, 0.05154958f, -0.13710910f, 0.05648930f, -0.04873988f, 
    0.03636524f, 0.00474531f, -0.00663343f, 0.06850004f, -0.09989160f, 0.01249726f, 0.00757799f, -0.00597492f, 
    -0.01303671f, 0.02391677f, -0.01380271f, -0.03954247f, 0.10246203f, 0.11393700f, 0.01943629f, -0.02485086f, 
    -0.04795535f, 0.00692596f, -0.04071497f, -0.04611755f, -0.02269231f, -0.00304729f, -0.01239666f, 0.03698899f, 
    0.00528269f, 0.01916290f, 0.00627780f, -0.01366623f, -0.00491764f, -0.05757876f, -0.04746898f, 0.00882287f, 
    -0.01532014f, -0.03712093f, 0.11911292f, 0.04214459f, -0.01710143f, 0.10171050f, -0.02439602f, -0.03547315f, 
    0.04498275f, -0.01679624f, -0.00531843f, 0.02248034f, 0.01900107f, 0.02344515f, -0.02940252f, -0.00786417f, 
    -0.04587821f, 0.00723554f, 0.03714571f, -0.02047217f, -0.11619126f, 0.00611009f, -0.09834428f, -0.04956963f, 
    -0.00887210f, -0.11803152f, 0.02961190f, -0.08246563f, -0.01955840f, 0.01407394f, -0.05229575f, 0.07281451f, 
    -0.04046124f, -0.06914466f, 0.00599748f, 0.02528827f, 0.00913219f, 0.05388822f, 0.00227441f, -0.02386954f, 
    0.12580855f, -0.04619635f, -0.03324350f, -0.00709474f, 0.18894109f, -0.07302977f, -0.04097303f, -0.03127288f, 
    -0.01446442f, -0.01006931f, -0.00978649f, -0.01693128f, -0.01385272f, 0.00862083f, -0.03456112f, -0.01546620f, 
    -0.03014216f, 0.00720853f, 0.00406099f, -0.03835231f, -0.00818921f, -0.01983049f, 0.01792268f, -0.10260185f, 
    0.07860693f, -0.11355443f, -0.03669249f, -0.02890339f, -0.01244760f, -0.01125917f, -0.01361537f, 0.04211555f, 
    -0.09620630f, -0.01000264f, -0.03785478f, -0.00556019f, -0.01059390f, -0.01940831f, -0.01731368f, -0.06455860f, 
    0.05716971f, 0.13244317f, 0.02699055f, 0.08827591f, 0.10200229f, -0.01660042f, 0.03426359f, -0.07024679f, 
    -0.04418809f, -0.04603709f, -0.11764256f, 0.01441146f, -0.04204182f, -0.04134290f, -0.04185477f, 0.01991570f, 
    0.01572193f, 0.02265877f, -0.04336593f, -0.02654625f, 0.00848645f, -0.10634784f, 0.10733003f, 0.08535510f, 
    0.19593103f, 0.09167499f, 0.05451854f, -0.02170692f, -0.01493900f, -0.04835825f, -0.00833129f, -0.00879914f, 
    0.00424982f, -0.05286463f, -0.03952882f, -0.03034618f, -0.01200506f, -0.00497417f, 0.03815240f, -0.00309612f, 
    0.08429712f, -0.02262939f, 0.00245358f, -0.02359366f, 0.09323010f, -0.00995809f, -0.02735982f, -0.06832393f, 
    -0.02197708f, -0.01446569f, -0.01182705f, -0.03066950f, -0.00461559f, 0.01290357f, 0.01014170f, 0.00338212f, 
    -0.03638083f, -0.04683889f, -0.00072420f, -0.00488749f, 0.10122639f, -0.14102589f, -0.03388692f, -0.11199978f, 
    -0.07890306f, -0.02040556f, -0.02728615f, -0.01176971f, -0.04620635f, -0.05932361f, 0.06813115f, 0.04405016f, 
    -0.03334955f, 0.01859386f, -0.06720804f, -0.07955227f, 0.03540813f, -0.04911125f, 0.00848419f, -0.03475981f, 
    -0.27734068f, -0.01557035f, -0.03975904f, -0.08628257f, -0.14239022f, -0.01574034f, 0.00163235f, -0.05275397f, 
    0.01783182f, 0.00928299f, -0.04364361f, -0.03058698f, 0.02528567f, -0.01224351f, -0.00737273f, -0.04532837f, 
    -0.01279851f, 0.04097006f, 0.03170787f, 0.07611541f, -0.10635430f, 0.16337365f, 0.10107611f, 0.14710507f, 
    0.08255310f, 0.02390465f, -0.02920302f, -0.00683150f, -0.02956933f, -0.01835097f, -0.05706962f, -0.01938635f, 
    -0.00131010f, -0.06162974f, 0.00810378f, 0.04803661f, -0.05549590f, 0.08930945f, -0.02868982f, -0.05656569f, 
    -0.16838770f, 0.13847981f, -0.01911947f, 0.09807336f, 0.07297239f, -0.00472877f, -0.02899221f, -0.00724694f, 
    0.04210669f, 0.00841133f, 0.00080260f, -0.02872313f, 0.01031415f, 0.03813832f, -0.05690343f, 0.08346958f, 
    -0.02909307f, 0.04614099f, -0.00252588f, -0.01931425f, -0.08845546f, 0.03773152f, -0.06784277f, -0.03932670f, 
    0.03034568f, 0.00682357f, -0.02895508f, -0.04950875f, 0.03451757f, -0.01934898f, 0.00406220f, 0.00861001f, 
    0.01154870f, 0.01518072f, -0.02866366f, -0.06423314f, -0.01949943f, 0.02506422f, -0.03655386f, -0.03453061f, 
    -0.17205901f, -0.10510258f, 0.16685529f, 0.09176040f, -0.06979593f, 0.08623552f, -0.04915820f, -0.05792518f, 
    0.04516521f, 0.02786190f, -0.02225647f, 0.02262453f, -0.04197888f, 0.02130633f, -0.13362984f, 0.04329181f, 
    -0.06013756f, 0.01865730f, -0.03870606f, -0.01368769f, 0.02339702f, -0.17735818f, -0.01131754f, 0.08211230f, 
    0.02042083f, 0.06561853f, -0.13836145f, -0.07472041f, 0.04221802f, 0.00132932f, 0.00612967f, 0.00264838f, 
    0.00113014f, -0.00833188f, 0.00031089f, 0.02250885f, 0.00984353f, 0.04808367f, 0.04921521f, 0.03480373f, 
    0.06834375f, 0.00681366f, 0.08952185f, -0.01495972f, 0.13767266f, -0.07451238f, 0.04991505f, -0.00812210f, 
    0.01615093f, 0.05734919f, 0.04021580f, -0.00237872f, -0.09821428f, -0.02695228f, 0.01777807f, -0.06402697f, 
    0.08153308f, 0.03770286f, -0.04419038f, -0.02204480f, 0.10114864f, 0.03854495f, 0.09650721f, 0.01112464f, 
    0.06343406f, -0.05961347f, 0.00099878f, -0.07640111f, -0.04592470f, 0.04592237f, 0.02411388f, -0.01151330f, 
    -0.00297129f, -0.03937898f, 0.00797608f, -0.05174683f, 0.00525475f, 0.01425056f, 0.04692193f, 0.00442972f, 
    -0.25126687f, 0.01641912f, 0.04874223f, -0.06649343f, -0.11091377f, 0.03020409f, -0.03955763f, -0.02108901f, 
    -0.01728467f, -0.03635904f, 0.06371152f, 0.04453191f, 0.00192647f, -0.01535577f, -0.03278950f, 0.03375461f, 
    0.03220480f, 0.02348832f, -0.01983367f, 0.00726572f, -0.18717429f, -0.05579707f, -0.13440655f, -0.05657377f, 
    -0.02609790f, 0.00977949f, -0.05247748f, -0.03064807f, 0.03713936f, -0.02286985f, -0.05646365f, 0.03010263f, 
    -0.03067597f, -0.04101887f, 0.03214497f, -0.01404757f, -0.07042752f, 0.01081591f, -0.00280435f, 0.03863866f, 
    -0.04124554f, 0.12782001f, -0.38975325f, 0.16124329f, 0.16053975f, -0.06753095f, -0.04104729f, -0.09067716f, 
    0.00433357f, -0.01741184f, -0.04635650f, 0.00654143f, -0.02875987f, 0.00214223f, -0.04659837f, -0.01646080f, 
    -0.08157644f, 0.00973353f, -0.10223202f, 0.01895494f, -0.05812591f, 0.11621597f, -0.23031910f, 0.04514266f, 
    0.09513619f, -0.00770169f, -0.10605036f, -0.07634311f, 0.00159564f, -0.00930834f, -0.16055472f, 0.00350089f, 
    0.00965126f, -0.00788999f, -0.06122797f, 0.01377521f, -0.03637662f, -0.04555360f, -0.02867708f, 0.03856871f, 
    0.06144718f, 0.03823281f, 0.02274908f, 0.11415295f, 0.04179791f, 0.11633012f, 0.00002228f, -0.02499200f, 
    -0.01907144f, 0.01180778f, -0.00516718f, 0.01129172f, 0.01075970f, -0.08401742f, 0.05779523f, -0.00066129f, 
    -0.03333633f, -0.04150302f, 0.00218792f, -0.08670149f, -0.10787112f, -0.12216070f, 0.18454632f, -0.01920407f, 
    -0.08241070f, 0.01243901f, -0.00487966f, -0.03981527f, 0.05364337f, -0.02544526f, -0.03263191f, -0.02635644f, 
    -0.01452726f, -0.01762990f, -0.10185345f, -0.03971222f, 0.03058145f, 0.01398770f, -0.06782649f, -0.02994456f, 
    0.03257612f, -0.03349651f, 0.01347303f, -0.10415816f, -0.08694077f, -0.08927989f, 0.10478918f, -0.02280680f, 
    -0.07092346f, -0.02199596f, 0.00158265f, -0.00734328f, -0.05447426f, -0.02131308f, -0.01907957f, 0.00167762f, 
    -0.00111797f, 0.02648194f, -0.03444814f, -0.01931048f, 0.16886646f, 0.10284282f, -0.02383208f, 0.04092302f, 
    0.07290754f, -0.07016778f, 0.06013043f, -0.08984067f, 0.05617210f, 0.03626233f, -0.00966111f, 0.05426673f, 
    -0.01135774f, -0.02249880f, -0.01257195f, -0.03724152f, 0.02010457f, 0.05898890f, -0.02316200f, -0.06332216f, 
    -0.15327516f, 0.15867305f, -0.02435288f, -0.10668822f, -0.10503708f, -0.07658494f, 0.01313649f, -0.05202243f, 
    -0.03533287f, -0.05488041f, 0.05954309f, 0.01982680f, 0.00812403f, 0.08915398f, -0.02301369f, 0.06398981f, 
    -0.01420380f, 0.00250561f, -0.00944734f, 0.01074310f, -0.05876004f, 0.10546132f, 0.15926507f, 0.14312899f, 
    0.15143903f, 0.07761270f, 0.09952028f, -0.02070184f, 0.04398108f, -0.02467247f, -0.01070419f, 0.03086724f, 
    0.04755167f, -0.03596189f, -0.00032534f, -0.01698151f, 0.00710533f, 0.00770890f, 0.01492697f, -0.05048822f, 
    0.10797157f, 0.08156986f, 0.20219187f, -0.03359957f, 0.08400758f, -0.02895658f, 0.05521166f, -0.05183954f, 
    -0.00645229f, -0.01675881f, 0.02797962f, 0.03749669f, 0.04457210f, -0.06071603f, -0.05317315f, 0.01841968f, 
    -0.02761433f, 0.01908926f, 0.06582426f, -0.08098508f, 0.06341652f, -0.19353805f, 0.06252296f, 0.05508856f, 
    0.01431611f, 0.03321969f, -0.08760282f, -0.04218493f, -0.00968635f, 0.01897210f, 0.01378078f, 0.01691296f, 
    -0.05449334f, 0.06561944f, -0.04583418f, 0.00827398f, 0.02194459f, -0.00512094f, -0.00024095f, -0.02665728f, 
    0.10252266f, -0.33271196f, -0.18688437f, -0.03541209f, 0.01065549f, -0.06366936f, -0.02204590f, 0.01083903f, 
    0.01036152f, -0.05348605f, -0.04536062f, -0.07379865f, -0.09366792f, 0.05028823f, 0.05809154f, 0.00668808f, 
    0.02118716f, -0.02320178f, -0.02614673f, -0.02560011f, -0.01301156f, -0.16856973f, -0.08447669f, -0.13304062f, 
    -0.10222715f, -0.06858876f, -0.07366860f, 0.01090010f, -0.05548112f, -0.04942661f, -0.06357400f, 0.02434726f, 
    -0.00048759f, 0.01583414f, 0.01564929f, -0.00606961f, -0.01541252f, -0.01968204f, 0.01628373f, 0.00435607f, 
    0.09760904f, 0.17322043f, 0.07122619f, -0.01609662f, 0.09530106f, -0.06257328f, 0.04068008f, -0.06061006f, 
    0.00959351f, -0.00348769f, -0.02768358f, -0.02197824f, -0.02119614f, -0.05305678f, 0.00251327f, 0.01987857f, 
    -0.03589306f, 0.07521040f, 0.00531932f, 0.04429136f, 0.10163744f, 0.05936844f, 0.17348328f, 0.00846219f, 
    0.07671240f, -0.10944434f, 0.05475094f, 0.01201747f, -0.02121510f, -0.01428816f, 0.02110193f, 0.05147243f, 
    -0.04251498f, 0.04454702f, -0.00041774f, -0.06430464f, -0.06190122f, -0.01400950f, 0.00985389f, -0.04973684f, 
    0.11019725f, -0.17508754f, 0.02570302f, 0.01532451f, 0.15407476f, 0.00830869f, 0.01119710f, -0.00233429f, 
    0.00361367f, -0.02537793f, -0.05427644f, -0.00559921f, -0.03126036f, -0.05246317f, -0.02017431f, -0.02525417f, 
    0.01503272f, 0.04195070f, 0.01272837f, 0.04709100f, -0.10600664f, 0.00274028f, -0.13098098f, -0.00789736f, 
    -0.04359505f, -0.06285458f, -0.00388764f, -0.05185677f, 0.01131103f, -0.04492548f, -0.00490163f, 0.00913671f, 
    -0.13171376f, -0.00955845f, -0.04012058f, -0.00013812f, 0.01121938f, -0.04120101f, -0.08437198f, -0.01359137f, 
    0.13886447f, 0.06771469f, 0.17224945f, 0.01199999f, 0.11674931f, 0.05241124f, 0.09447672f, -0.01118006f, 
    0.02675026f, 0.02000911f, -0.04371417f, 0.01956939f, 0.01844037f, -0.03153903f, -0.04214010f, -0.05106837f, 
    0.00329583f, 0.01266910f, 0.02776151f, -0.02341704f, -0.20876499f, -0.19503471f, -0.12128236f, -0.08834497f, 
    -0.15961902f, -0.07171956f, -0.01165557f, 0.00672592f, -0.04084644f, -0.06336128f, -0.02743226f, -0.00619086f, 
    -0.01435417f, -0.00359723f, -0.00801425f, 0.03699405f, 0.01667467f, 0.00177851f, -0.01692221f, 0.01571926f, 
    -0.41619101f, -0.06944835f, -0.12538685f, -0.07682244f, -0.03672812f, 0.01290354f, -0.02034393f, -0.07045480f, 
    0.01874394f, -0.04112538f, 0.02862559f, 0.02621085f, 0.01956256f, -0.04161820f, -0.05246829f, -0.09199023f, 
    -0.03858377f, 0.05585384f, 0.01206818f, 0.05545643f, -0.13431539f, -0.07712048f, -0.00036259f, -0.09479428f, 
    -0.16655590f, -0.03703904f, -0.01513289f, 0.00080130f, -0.05285351f, -0.02755053f, 0.07219674f, 0.01165708f, 
    -0.00560004f, -0.03807207f, -0.04516625f, 0.00613086f, 0.02399688f, -0.04572991f, -0.01285803f, 0.00700813f, 
    -0.07653987f, 0.00176469f, -0.12190218f, -0.12221257f, -0.05152186f, -0.05493957f, -0.04944830f, -0.01146506f, 
    -0.04733932f, -0.06214745f, -0.04216046f, -0.00280753f, 0.00975495f, -0.04250217f, -0.04949976f, -0.01964347f, 
    0.00587212f, -0.00733430f, -0.02372296f, -0.06330945f, 0.02411456f, 0.13987151f, 0.00244298f, -0.05289418f, 
    0.19084874f, -0.08602392f, 0.00158983f, -0.12774704f, -0.00588925f, -0.02677915f, 0.06177992f, 0.01255680f, 
    -0.00245093f, -0.04086157f, -0.01491324f, -0.02805586f, -0.02167380f, 0.08736299f, 0.00569183f, -0.05361405f, 
    -0.13287176f, 0.11317264f, -0.00736573f, 0.00856944f, 0.10142593f, -0.01990974f, -0.12897012f, -0.02073165f, 
    0.01362091f, 0.01368959f, -0.05086542f, 0.01825469f, -0.01991020f, -0.06936724f, -0.08490027f, 0.04599403f, 
    -0.00948183f, 0.05301111f, 0.00201192f, -0.06371851f, 0.10906026f, -0.01816029f, 0.17329192f, 0.07374617f, 
    0.09416223f, 0.02063790f, 0.07428498f, -0.01984919f, -0.00305119f, 0.00502522f, 0.02817006f, 0.02459756f, 
    0.00282324f, 0.04973742f, -0.05046333f, -0.09857230f, -0.01598027f, 0.02434373f, 0.01995405f, -0.03484847f, 
    -0.07750285f, 0.03954631f, 0.08025089f, 0.03038938f, -0.09573541f, 0.00882989f, -0.09242114f, -0.05453713f, 
    0.02659604f, -0.02471181f, 0.00837931f, 0.02283752f, 0.05542691f, -0.01233797f, 0.01502561f, 0.03947512f, 
    -0.01384192f, 0.03203251f, 0.00934790f, -0.02381244f, 0.04367505f, 0.07427127f, 0.03645640f, 0.01779536f, 
    0.02502436f, 0.00454777f, 0.02512397f, -0.01789365f, -0.01875026f, -0.00989873f, 0.01276288f, 0.00291400f, 
    0.01616520f, 0.03331542f, -0.02025525f, 0.03201924f, -0.05857702f, -0.02464401f, -0.00796686f, 0.00749721f, 
    -0.12954497f, -0.04324078f, -0.18050617f, -0.14163078f, -0.18962868f, -0.03165136f, -0.02984415f, 0.00051118f, 
    -0.01720008f, -0.05552033f, -0.04168376f, -0.00451956f, -0.00828408f, -0.04458649f, -0.03269922f, 0.03230591f, 
    -0.04203808f, -0.03414645f, -0.01259058f, 0.04012671f, 0.09631305f, -0.09148202f, 0.01653842f, 0.03710807f, 
    -0.04312900f, 0.08738764f, -0.00833238f, 0.00527455f, -0.04651026f, -0.03536357f, -0.04120153f, -0.02373138f, 
    -0.01443298f, -0.05727822f, -0.02053393f, 0.02956043f, 0.03068734f, 0.00642092f, -0.01124727f, -0.00906082f, 
    -0.24378374f, 0.10421424f, 0.01295143f, 0.01170318f, 0.02476788f, -0.06652685f, -0.03168017f, -0.04422028f, 
    0.00149419f, -0.04821144f, 0.05396260f, 0.01042633f, -0.01160468f, -0.00341026f, -0.04935886f, 0.02004719f, 
    0.02130857f, 0.01505983f, -0.02381658f, -0.05105561f, -0.09941309f, 0.11253875f, 0.20262761f, 0.02363491f, 
    0.05734194f, 0.07063224f, 0.05213536f, -0.01553502f, 0.05383924f, 0.04466923f, -0.04676805f, 0.00170750f, 
    0.00392412f, -0.01196231f, -0.05707660f, 0.02894514f, -0.02387699f, 0.00795256f, 0.00939603f, 0.01392382f, 
    -0.00329211f, 0.03398858f, -0.11978839f, -0.00611881f, 0.11326552f, -0.07445281f, -0.02891430f, -0.06530189f, 
    0.05365687f, -0.06596698f, -0.08284533f, 0.02046082f, -0.01243039f, 0.01573552f, -0.02176178f, 0.01324708f, 
    -0.06611843f, -0.04205909f, -0.02120026f, -0.07248444f, 0.01938462f, 0.09336013f, 0.10930090f, -0.00123661f, 
    0.10824873f, -0.00469808f, 0.00329323f, 0.01942311f, 0.02921324f, 0.00097433f, 0.00096828f, -0.00942462f, 
    -0.01842976f, -0.03557011f, 0.01083656f, -0.01232484f, -0.02579780f, -0.04196002f, -0.00967917f, 0.02681331f, 
    0.01908300f, 0.14719436f, 0.00890933f, -0.13167799f, 0.07697135f, 0.01273216f, 0.10995691f, 0.04293101f, 
    -0.02945132f, 0.03697845f, -0.03745535f, 0.00672223f, -0.00560038f, -0.07076698f, 0.03858128f, 0.06201230f, 
    0.02764152f, -0.00106057f, -0.01447251f, 0.03659838f, -0.29784778f, 0.02891858f, 0.02077612f, -0.04430035f, 
    -0.12740824f, 0.03639608f, -0.00282477f, -0.03096034f, -0.02987991f, -0.06164505f, -0.00219153f, -0.04255448f, 
    0.02634167f, -0.05420358f, -0.03293069f, 0.01715352f, 0.02206485f, -0.00539356f, 0.00008668f, -0.01896364f, 
    -0.11429447f, -0.08984396f, -0.01378957f, 0.06437610f, 0.07403125f, -0.01386187f, 0.01465303f, -0.03464890f, 
    0.01616943f, -0.01355960f, 0.05541124f, -0.00005099f, -0.00171385f, 0.03992303f, 0.03656047f, -0.03652517f, 
    0.04847965f, 0.04439878f, 0.01148507f, -0.01384097f, 0.07760634f, -0.09402845f, -0.14885813f, -0.07353655f, 
    0.02951613f, 0.08336424f, 0.06156953f, 0.03559077f, -0.08382654f, -0.04409955f, -0.05329487f, 0.13603115f, 
    0.01567446f, 0.02919184f, -0.01412300f, 0.06529716f, 0.03557218f, -0.01319722f, 0.00152258f, 0.04550505f, 
    0.09259440f, -0.03061099f, -0.08635654f, 0.02137847f, 0.07932957f, 0.05014299f, 0.03096209f, -0.01492318f, 
    -0.06826559f, -0.00321169f, 0.00433676f, 0.02163334f, 0.04658575f, -0.00851833f, -0.03049487f, 0.05825622f, 
    -0.00289697f, 0.06850832f, 0.01500823f, 0.01078132f, -0.09351485f, -0.14991507f, -0.14234884f, -0.09013686f, 
    -0.15918973f, 0.02904457f, -0.04498183f, 0.01588704f, -0.16357684f, 0.09055041f, 0.05171542f, 0.04811009f, 
    -0.00126326f, 0.07120748f, 0.06609523f, -0.01451643f, 0.01926049f, -0.02228498f, 0.06991427f, -0.00170165f, 
    -0.02389931f, 0.00768537f, 0.02119399f, -0.21205249f, -0.13185170f, 0.00627675f, 0.03287468f, -0.02237490f, 
    -0.03621631f, -0.03698483f, 0.01421379f, -0.00576163f, -0.00556556f, -0.01574440f, -0.03236810f, -0.04576848f, 
    -0.00794564f, -0.01035833f, -0.11969530f, -0.07859471f, -0.13091040f, 0.05147778f, 0.13861108f, -0.02446279f, 
    -0.19958647f, -0.00947732f, -0.02495868f, 0.00035481f, 0.03045879f, -0.03667241f, 0.03672924f, 0.03998628f, 
    0.00375124f, -0.01263882f, -0.00342508f, -0.09167148f, 0.03047688f, -0.10666571f, 0.02569662f, -0.01952703f, 
    -0.08289364f, 0.08159587f, 0.02975322f, -0.04541789f, -0.15119599f, -0.06256337f, 0.00748886f, -0.05844388f, 
    -0.00178451f, -0.06300279f, 0.07570686f, -0.03997160f, 0.03141039f, -0.05756767f, 0.05711180f, -0.02243178f, 
    -0.00473510f, -0.07910357f, 0.09156410f, -0.02672747f, -0.09204786f, -0.14780402f, 0.21601373f, -0.23454019f, 
    -0.08079397f, 0.03831045f, 0.04776913f, 0.01526686f, -0.01419250f, -0.00826572f, 0.00184769f, 0.08605647f, 
    -0.06283888f, 0.09757317f, -0.00347320f, -0.11906958f, -0.01315580f, 0.12219790f, -0.20166631f, -0.01249753f, 
    -0.15229237f, -0.21044163f, -0.06699396f, -0.11758008f, 0.13885964f, 0.07069754f, 0.03640272f, -0.07975867f, 
    -0.00186298f, -0.00114083f, 0.11083822f, 0.04458128f, 0.07320146f, 0.04304260f, 0.06526276f, -0.10508686f, 
    0.07659196f, 0.06500448f, 0.04530272f, -0.02468337f, -0.13867871f, 0.05732868f, 0.14073591f, -0.02139899f, 
    -0.08909012f, -0.02399697f, -0.00537539f, 0.02451502f, -0.07541251f, -0.01939116f, 0.00455114f, -0.03170928f, 
    0.02643126f, -0.03025284f, -0.03870073f, 0.00929603f, -0.06323387f, -0.05709158f, -0.04737877f, 0.02464627f, 
    -0.10326990f, 0.13094743f, 0.08100355f, -0.05533579f, 0.03613367f, -0.00263786f, 0.05175447f, 0.00867390f, 
    0.00649229f, 0.00829445f, 0.08197488f, 0.03484379f, -0.00349209f, 0.06162110f, 0.05907746f, -0.06170331f, 
    0.06074966f, 0.01968063f, 0.04139722f, 0.02849100f, -0.11959895f, 0.01173046f, -0.07399990f, -0.09703245f, 
    -0.05316089f, 0.00672409f, 0.04313911f, -0.11892416f, 0.00970064f, -0.04729316f, -0.00699403f, 0.03248926f, 
    0.03285845f, -0.13454874f, 0.03129765f, -0.03357710f, 0.03007926f, -0.04714801f, 0.04625879f, -0.03394220f, 
    -0.13534005f, -0.03630694f, 0.13789551f, 0.00242965f, 0.02582038f, -0.08460371f, -0.04065828f, -0.03992460f, 
    -0.04176418f, 0.02391057f, 0.01626262f, 0.00439356f, -0.01389812f, 0.00787239f, -0.05516041f, -0.02714442f, 
    -0.00691694f, 0.01044337f, -0.02147024f, -0.02498279f, -0.01409586f, 0.13093734f, 0.12807262f, 0.05736474f, 
    -0.04583853f, -0.07955869f, -0.00311115f, -0.00388050f, -0.04583407f, -0.03116754f, 0.02774404f, -0.00583663f, 
    0.00493009f, -0.03379956f, -0.04674358f, -0.08868162f, 0.03626418f, -0.02885998f, 0.12599349f, -0.02514581f, 
    -0.02978097f, -0.10205482f, 0.10400482f, -0.01887520f, 0.05015174f, 0.11820086f, -0.06104538f, -0.02126005f, 
    -0.08420086f, -0.03146982f, -0.00461529f, -0.05090407f, -0.04063737f, 0.00534621f, 0.01203762f, -0.01111172f, 
    -0.00265031f, 0.08775724f, -0.17564455f, 0.03355349f, 0.01754126f, -0.00113618f, 0.05513499f, -0.01209555f, 
    0.11659747f, -0.02759364f, -0.02785122f, 0.02097255f, -0.03875223f, -0.04037639f, 0.07818351f, -0.07259653f, 
    -0.05390815f, -0.02183498f, 0.03921573f, 0.02260128f, 0.01484713f, -0.00517294f, 0.05059650f, 0.01343981f, 
    -0.16037406f, 0.07741333f, 0.04990800f, -0.06288041f, -0.16237859f, -0.07028677f, 0.01472989f, 0.00933238f, 
    -0.01682916f, -0.07685591f, 0.05254455f, 0.01587554f, 0.03234114f, 0.00190051f, -0.02558708f, -0.06225571f, 
    0.00473864f, -0.05753627f, 0.00675004f, 0.00381733f, -0.07898220f, -0.11139137f, 0.16810559f, -0.01045441f, 
    0.09137253f, -0.05104838f, -0.08035532f, 0.00793023f, -0.04846134f, -0.04347453f, -0.00231714f, -0.03612406f, 
    0.02650715f, -0.09303076f, 0.00013425f, -0.00253282f, -0.10280349f, 0.04918467f, 0.03410411f, 0.03506894f, 
    -0.09534462f, -0.01825110f, -0.11095678f, -0.04568120f, -0.02692013f, 0.02415223f, 0.00862915f, -0.00304966f, 
    0.00480635f, -0.00674455f, 0.01090207f, -0.01878964f, -0.01379604f, -0.01159990f, -0.00290604f, -0.06608061f, 
    0.00000976f, -0.03576855f, 0.01554361f, -0.04804318f, 0.09424321f, -0.01757381f, 0.01991754f, 0.03506761f, 
    0.08218242f, 0.01128044f, 0.01236996f, -0.03621532f, -0.08486573f, 0.01336304f, -0.05595715f, 0.02379058f, 
    0.00202428f, -0.06852029f, 0.00245109f, 0.05697322f, -0.06207312f, -0.02454519f, 0.02666520f, 0.07400694f, 
    0.07211205f, 0.12083308f, -0.11809404f, -0.03214507f, 0.03791308f, 0.04995906f, 0.04111192f, -0.03184684f, 
    -0.00349604f, -0.02899539f, 0.04134507f, 0.01483083f, 0.01939556f, 0.02329845f, 0.00168144f, 0.01465123f, 
    0.02552438f, 0.05967518f, 0.05431922f, 0.00072893f, -0.15509233f, 0.03220771f, 0.13818499f, -0.05676210f, 
    -0.09157936f, -0.11137636f, -0.02880954f, -0.01211596f, 0.06886824f, -0.03635450f, 0.05782645f, 0.03472140f, 
    0.05254993f, 0.06006026f, 0.01162517f, 0.01581839f, -0.01688058f, -0.11854924f, 0.06421795f, -0.05413612f, 
    -0.02662574f, 0.00838525f, -0.10264597f, 0.08413634f, -0.09057674f, 0.00570603f, -0.02219669f, -0.18235569f, 
    -0.00180846f, -0.00238748f, 0.06754761f, -0.05319241f, 0.02529096f, -0.01974143f, 0.11073591f, -0.01747443f, 
    0.04560282f, -0.12577292f, 0.10482103f, -0.03249307f, 0.01418406f, 0.12950814f, -0.18620290f, -0.03672192f, 
    -0.05653593f, -0.01015031f, 0.00511910f, -0.05046289f, -0.02793909f, -0.00176488f, 0.01602899f, 0.01319337f, 
    0.05257573f, 0.03215978f, 0.01154605f, 0.01740925f, -0.01451420f, -0.04884805f, -0.00277154f, 0.09626837f, 
    0.00924566f, 0.12182675f, -0.27382028f, 0.09959207f, -0.07259892f, 0.02890610f, -0.05917782f, -0.12637390f, 
    -0.09528287f, 0.06877895f, -0.01431505f, 0.01971639f, 0.03246860f, -0.03409953f, 0.02025701f, -0.00662810f, 
    -0.05252107f, -0.08097315f, 0.08547381f, -0.05057664f, -0.14899825f, -0.07009368f, -0.16739118f, -0.22136720f, 
    -0.11780936f, 0.01954324f, -0.10031858f, 0.01609126f, 0.09461295f, -0.08029550f, 0.07474668f, 0.04637320f, 
    0.04511041f, -0.01579767f, 0.00444080f, 0.04741136f, -0.06706800f, -0.09382971f, -0.02536715f, 0.01294420f, 
    -0.00022646f, 0.10717077f, 0.00114591f, -0.09986177f, -0.10956930f, -0.06502855f, 0.00910605f, 0.06179480f, 
    -0.01801173f, -0.02742267f, 0.02722855f, -0.02819635f, 0.02229838f, 0.02610578f, 0.02211411f, -0.03705671f, 
    -0.04307140f, -0.16379106f, 0.02076356f, -0.00724466f, -0.14870596f, -0.15191057f, -0.05045999f, -0.21643402f, 
    -0.09716570f, 0.07490128f, -0.06652823f, 0.04145656f, -0.05822270f, -0.11281499f, -0.02631783f, 0.05832409f, 
    -0.02043964f, 0.07434940f, -0.01611101f, -0.02443447f, 0.03460934f, -0.07183085f, -0.09446098f, 0.04709063f, 
    0.11117670f, 0.08140703f, -0.10967857f, 0.05874254f, 0.05544109f, 0.02897161f, 0.00696428f, -0.08382364f, 
    -0.06554592f, -0.04259467f, -0.02016619f, 0.05182503f, -0.03237883f, -0.00263687f, 0.00442342f, -0.02598598f, 
    0.01194360f, -0.02730373f, 0.09729274f, -0.02943190f, 0.09635580f, 0.05209601f, -0.01894234f, -0.05163375f, 
    0.00962315f, 0.05493623f, -0.05041802f, -0.02210874f, 0.02460321f, 0.01117285f, 0.03329746f, 0.00518035f, 
    -0.00779075f, 0.02980160f, -0.01672681f, 0.02835969f, 0.01001685f, 0.03766726f, 0.06071365f, -0.07642249f, 
    0.01975092f, 0.03898603f, -0.01957389f, -0.21020158f, 0.01271008f, -0.03245329f, 0.02714221f, -0.02219544f, 
    -0.06861099f, -0.04730627f, 0.05427161f, 0.00969015f, 0.01612937f, -0.01155325f, -0.12937346f, 0.00422243f, 
    0.14308569f, -0.01949963f, -0.05315445f, 0.00019219f, -0.16302432f, 0.01324772f, 0.05900163f, -0.09319916f, 
    0.01647497f, -0.00524426f, 0.01476037f, -0.07936327f, -0.07522661f, -0.05346141f, 0.05588799f, 0.07059454f, 
    0.02591506f, 0.04000545f, -0.08105291f, -0.05403358f, 0.10521967f, 0.02253632f, 0.01992953f, -0.02506086f, 
    -0.07043605f, -0.15595759f, 0.08381312f, -0.08751979f, -0.03908501f, 0.01852000f, -0.05312259f, 0.01465752f, 
    -0.01457571f, -0.00424850f, -0.02269004f, 0.03559997f, -0.00783928f, 0.06611439f, -0.05660080f, -0.08710049f, 
    0.00025545f, 0.02389097f, -0.10764430f, 0.01824423f, 0.04603549f, 0.07188066f, -0.22611900f, 0.09827536f, 
    0.05971268f, 0.05625054f, -0.01781615f, -0.07934572f, -0.05675050f, 0.01635403f, 0.00255614f, 0.03035118f, 
    0.03991034f, 0.01513000f, -0.07424061f, 0.00858707f, -0.05458893f, -0.05871844f, 0.10841309f, 0.01472349f, 
    0.05924813f, 0.09243048f, -0.03834679f, 0.05618277f, 0.02013287f, -0.02096639f, 0.01167700f, 0.00823642f, 
    -0.00179486f, 0.03739176f, 0.06441438f, 0.01191106f, -0.00799596f, 0.02926511f, 0.00634745f, -0.04642629f, 
    0.02238915f, 0.00004951f, 0.04083490f, 0.05821532f, -0.05443877f, 0.05851455f, -0.06681702f, -0.07445900f, 
    -0.07151797f, -0.02612407f, 0.03243355f, -0.04248117f, -0.05240707f, 0.03394841f, 0.07158177f, 0.07128274f, 
    0.01917829f, 0.02550337f, 0.07534547f, -0.05998661f, 0.02189535f, -0.11774666f, 0.09470338f, 0.08666536f, 
    0.23614226f, 0.16219474f, -0.06296096f, 0.07255759f, 0.04951771f, -0.07390282f, -0.03933480f, -0.14353643f, 
    -0.06978153f, -0.02629225f, -0.00125301f, -0.08313501f, 0.04432672f, -0.02593216f, 0.14957137f, 0.00862500f, 
    0.00994869f, -0.04288111f, 0.08085082f, -0.04115495f, -0.17689204f, -0.08850215f, 0.21771429f, 0.03461771f, 
    0.13165918f, -0.05799495f, -0.04648679f, 0.05414141f, -0.07422607f, -0.01026101f, 0.03465621f, -0.02168211f, 
    -0.00409403f, -0.15994263f, 0.02512209f, -0.04126502f, -0.01666468f, 0.02731554f, -0.00314755f, 0.05366937f, 
    -0.17098652f, 0.03488623f, 0.13188726f, -0.08052186f, -0.01468779f, 0.06829802f, -0.06714065f, -0.00228751f, 
    0.04722462f, -0.01816277f, -0.01006823f, -0.04030412f, -0.02414835f, 0.00636955f, 0.04457590f, -0.02063600f, 
    -0.01889121f, 0.03095469f, -0.01318770f, 0.05033930f, -0.12612964f, -0.11998290f, -0.12339837f, -0.12527999f, 
    0.04967718f, 0.03761485f, -0.07279753f, -0.01058643f, 0.03200216f, -0.05045604f, 0.06978603f, -0.01803055f, 
    0.01384969f, -0.00616188f, 0.06648687f, -0.01574007f, 0.00318144f, 0.00936323f, -0.02983192f, -0.13349095f, 
    0.05023584f, -0.16083835f, -0.13903524f, 0.05524255f, 0.13857907f, 0.08396839f, 0.05713731f, -0.02479458f, 
    -0.09087885f, -0.04090920f, 0.01797975f, 0.03391824f, 0.08359354f, 0.02139562f, -0.00477535f, 0.02058443f, 
    0.06168001f, 0.05259499f, 0.01426809f, -0.06166913f, -0.05944394f, -0.07513334f, -0.00639890f, 0.04503508f, 
    0.11759062f, 0.07368960f, 0.02278430f, -0.06486054f, 0.00450001f, -0.02422426f, 0.04626954f, 0.05906222f, 
    -0.01093898f, -0.01509572f, 0.03840464f, -0.10189651f, -0.00660328f, 0.08021825f, 0.02014876f, -0.00337082f, 
    -0.21293546f, 0.09746443f, 0.00083587f, -0.18296549f, -0.17344424f, -0.00320117f, 0.01088872f, -0.04989129f, 
    0.07521554f, -0.12827261f, 0.05199214f, -0.03017662f, 0.01147681f, 0.06593603f, 0.02092319f, -0.04256242f, 
    0.02640713f, 0.02057967f, -0.00418547f, 0.00915158f, 0.09010110f, 0.05872865f, -0.04018649f, -0.03934986f, 
    -0.08900331f, -0.08061656f, 0.04398944f, -0.02597921f, -0.06427094f, -0.03453931f, -0.00588193f, 0.00867676f, 
    0.02825694f, 0.09274027f, -0.03828165f, 0.04436394f, -0.05147920f, -0.15026981f, -0.04094028f, 0.02983628f, 
    -0.04238427f, -0.26714766f, 0.01182313f, -0.20563684f, -0.06033755f, -0.06499372f, -0.08061877f, 0.03838534f, 
    -0.10857836f, -0.05529013f, -0.02569586f, 0.01852310f, 0.02153564f, 0.00894537f, -0.04485960f, 0.05685709f, 
    -0.01147540f, 0.06500494f, -0.27322456f, -0.02640712f, 0.12553915f, 0.11658629f, 0.08249979f, 0.01583275f, 
    0.00205342f, -0.05765384f, -0.03381027f, 0.00468746f, -0.05302215f, -0.02969926f, 0.00010208f, 0.00589548f, 
    0.00606932f, -0.07754039f, 0.01735680f, -0.05138335f, -0.03288244f, -0.08325330f, 0.09907530f, -0.04796444f, 
    -0.11770748f, -0.02414495f, 0.11956213f, 0.04627231f, 0.02663301f, 0.01170365f, -0.02835050f, 0.02303124f, 
    -0.07622354f, -0.01186066f, 0.02988311f, -0.01449617f, -0.06623835f, 0.01485662f, 0.07630667f, -0.00390698f, 
    -0.03791365f, -0.05481409f, 0.02105686f, -0.01691910f, 0.06070229f, 0.08200272f, -0.13835326f, 0.17202741f, 
    0.10997017f, 0.12358119f, 0.09949532f, -0.01614010f, -0.09167984f, -0.04343511f, -0.00774931f, -0.04018716f, 
    0.01360772f, -0.01535176f, 0.00514157f, -0.03605526f, 0.04690056f, 0.03400519f, 0.09038719f, -0.06318578f, 
    -0.05090597f, -0.04243213f, -0.16216736f, -0.01038917f, 0.04546546f, 0.06686883f, 0.04747005f, -0.02386582f, 
    0.02493620f, -0.05321047f, 0.01313987f, -0.00265937f, 0.06872711f, 0.00205105f, -0.00973303f, 0.03526727f, 
    0.05673605f, 0.01702115f, 0.07346880f, -0.06099413f, 0.16968597f, 0.11957242f, -0.08861889f, 0.07631448f, 
    0.12300670f, 0.00112593f, 0.02554007f, -0.10171365f, -0.03604112f, -0.05510904f, -0.00547619f, 0.00628679f, 
    -0.04695231f, -0.10825683f, -0.03202190f, -0.08269850f, 0.01950053f, 0.09085602f, 0.05986127f, -0.02654335f, 
    0.05550001f, 0.02281917f, -0.00145628f, 0.07962631f, 0.06550253f, 0.02600725f, 0.00322445f, -0.07525426f, 
    -0.06399132f, -0.06703532f, 0.04666648f, 0.01876434f, 0.00553579f, -0.01333805f, -0.03127171f, -0.04042869f, 
    0.00540801f, 0.01508658f, 0.05329445f, 0.00410597f, -0.10042101f, 0.13212107f, -0.12651773f, -0.15727432f, 
    -0.19320901f, 0.00076507f, -0.02364672f, -0.02086898f, 0.02833082f, -0.05904435f, 0.00569375f, 0.04342712f, 
    -0.02833134f, 0.00772114f, -0.01140748f, -0.00339797f, -0.01551778f, -0.13201691f, -0.12101336f, 0.06060035f, 
    -0.04788503f, 0.00865125f, -0.18455669f, -0.01670729f, -0.16240659f, -0.01781495f, -0.00213378f, -0.07018884f, 
    -0.01026760f, -0.00566036f, 0.10204754f, -0.01745997f, 0.05922812f, -0.03251918f, 0.05262322f, -0.05562659f, 
    -0.00645233f, -0.13111794f, 0.06864020f, 0.01016372f, -0.06282599f, -0.05048065f, 0.08872832f, 0.06271760f, 
    0.15121615f, -0.12805201f, -0.07788233f, -0.00279289f, -0.02581586f, -0.01610215f, -0.00750869f, -0.04803999f, 
    -0.11749597f, -0.04484098f, 0.11123715f, 0.02257808f, 0.00050079f, -0.01072611f, 0.01607738f, -0.00166073f, 
    0.06222644f, 0.07993536f, -0.03799424f, 0.08397514f, 0.12587023f, -0.01147861f, -0.06159148f, -0.10472741f, 
    -0.06008253f, 0.03532763f, -0.05224173f, -0.09223450f, -0.05951168f, 0.04873687f, 0.08589713f, 0.01205570f, 
    0.07042226f, 0.02402962f, 0.06790393f, 0.01189354f, 0.00861328f, -0.00963922f, 0.05220927f, -0.04487285f, 
    0.04565994f, -0.06412812f, -0.02042279f, -0.05086447f, -0.00318581f, -0.03581987f, 0.03861928f, 0.00831881f, 
    0.00592365f, -0.03111362f, 0.05646878f, 0.03742220f, -0.01163641f, -0.00690824f, 0.04619698f, -0.04560226f, 
    0.09597023f, 0.14510740f, -0.06616555f, 0.05881105f, 0.07020623f, 0.05376866f, 0.04487326f, -0.01870326f, 
    -0.01382061f, -0.00092352f, 0.03584895f, 0.02639999f, -0.05455239f, 0.01189459f, 0.01258912f, -0.07819649f, 
    -0.01513394f, 0.06063877f, 0.04619472f, -0.03282194f, 0.09264155f, 0.07156406f, 0.02294896f, 0.04755045f, 
    0.11823089f, -0.02674434f, -0.05846550f, -0.01622262f, -0.00701599f, -0.05669998f, 0.04138848f, -0.02024130f, 
    -0.07720479f, -0.03087810f, 0.01886036f, -0.01997239f, 0.03291016f, 0.05051253f, 0.05994673f, 0.06088512f, 
    0.08681019f, 0.08447539f, -0.11546409f, 0.07579128f, 0.00533869f, -0.02126966f, 0.04480700f, -0.03498250f, 
    -0.07151392f, 0.00116618f, 0.02200575f, -0.07830668f, 0.02636483f, 0.05583905f, 0.07087746f, 0.01149043f, 
    0.00506215f, -0.01576874f, 0.07875887f, 0.01906074f, 0.04410335f, -0.04597295f, 0.06279419f, 0.00645884f, 
    0.04453110f, 0.00424581f, -0.06645061f, -0.00556055f, -0.06703559f, 0.05443291f, -0.01328722f, -0.04550866f, 
    -0.10414895f, -0.04413066f, 0.06873105f, 0.03390726f, -0.04893846f, -0.05877978f, 0.02733875f, -0.03921274f, 
    -0.17593358f, 0.05284689f, 0.07808444f, -0.05934442f, -0.02045117f, -0.00172739f, 0.01489597f, -0.06274261f, 
    -0.01314096f, -0.09453549f, -0.00116047f, 0.01391355f, -0.03809813f, 0.01179835f, -0.05669006f, -0.06435406f, 
    0.05017114f, 0.05294674f, -0.12426535f, -0.03961367f, -0.05571052f, 0.06150201f, -0.04875743f, -0.12503615f, 
    -0.14246844f, 0.02377819f, -0.01360110f, -0.03287810f, 0.02849502f, -0.02213695f, 0.02655374f, 0.01798439f, 
    -0.02930904f, -0.04328576f, 0.02509381f, -0.08321242f, 0.00870766f, -0.03199614f, -0.00580611f, -0.08707766f, 
    -0.09847805f, 0.18592313f, -0.12044506f, -0.07241140f, -0.13966666f, -0.02172549f, -0.02087282f, 0.00387849f, 
    -0.01655494f, -0.02556092f, 0.10474378f, -0.04348167f, -0.09268269f, -0.01459244f, -0.00175031f, -0.05176359f, 
    -0.03816408f, -0.02055260f, 0.04834753f, 0.02904722f, 0.10735108f, 0.04385288f, -0.19476587f, 0.11915666f, 
    0.09363963f, 0.02015634f, -0.00970125f, -0.03584711f, -0.06510048f, 0.00607581f, -0.07047684f, 0.00607241f, 
    0.00051179f, 0.00941129f, 0.03459504f, -0.05734232f, -0.04847724f, -0.01930960f, 0.07411245f, -0.00033687f, 
    -0.06895469f, -0.07310146f, -0.06713651f, 0.06667900f, -0.04668435f, 0.00661647f, 0.02771591f, 0.00976148f, 
    -0.04100148f, -0.01138893f, 0.00456229f, -0.03111296f, 0.02647261f, -0.02460697f, -0.03648405f, 0.06070523f, 
    0.03942308f, 0.00185413f, -0.05827546f, 0.00909459f, -0.12518531f, -0.12950189f, 0.15664066f, -0.04253660f, 
    -0.28601560f, -0.01887934f, -0.03001036f, -0.07537596f, -0.01936826f, 0.08862752f, -0.02099049f, -0.01497273f, 
    -0.00314181f, 0.00086773f, -0.03475974f, -0.08347994f, -0.03747105f, -0.01921719f, 0.06374719f, 0.03954793f, 
    0.04037561f, -0.14748928f, 0.09546451f, -0.16701475f, -0.17017321f, 0.10336635f, 0.04106162f, 0.00839957f, 
    -0.06175068f, -0.06338657f, -0.07454192f, 0.00877462f, -0.01905563f, 0.09236956f, -0.02597670f, -0.04009438f, 
    0.02104395f, 0.00170520f, 0.03677943f, 0.04279929f, -0.08679618f, -0.29975566f, 0.08650680f, 0.06446338f, 
    0.18507949f, -0.04987899f, -0.00884806f, 0.05129401f, -0.04066436f, 0.04768134f, 0.10713707f, -0.03842854f, 
    -0.00015058f, 0.01510252f, 0.02134214f, -0.03305545f, 0.07758705f, 0.00077896f, 0.04534345f, 0.09069216f, 
    -0.08002346f, -0.07323680f, -0.05209881f, 0.04504790f, -0.01780326f, -0.02379491f, 0.03967220f, -0.01099366f, 
    -0.04269447f, 0.00216886f, -0.01955566f, 0.00648341f, 0.04236634f, 0.09804378f, -0.00807771f, 0.07658102f, 
    0.01295580f, -0.02633212f, 0.03668249f, 0.00670591f, 0.02313367f, -0.03764626f, 0.06676795f, -0.01452783f, 
    -0.06187171f, 0.09358670f, 0.02379762f, -0.03358174f, -0.02008478f, -0.03211064f, -0.03999536f, -0.04705617f, 
    0.00430042f, -0.00565004f, 0.06701594f, 0.00058764f, -0.02065045f, -0.05913461f, -0.05485285f, 0.00283284f, 
    -0.31974849f, 0.12592860f, 0.24489738f, -0.10072332f, 0.12887906f, 0.03252489f, 0.01465242f, -0.02960517f, 
    0.01473066f, -0.01587054f, -0.03717406f, -0.02486552f, 0.04259589f, 0.03301398f, 0.08894322f, 0.01845220f, 
    0.03494195f, 0.03120819f, -0.03968950f, 0.09334649f, -0.02647725f, -0.14012136f, -0.11935772f, 0.16585650f, 
    -0.02689684f, -0.13359520f, 0.10182106f, 0.05567644f, 0.01250490f, 0.03205175f, 0.00783017f, 0.02369586f, 
    -0.00472262f, 0.00026620f, -0.00230728f, 0.00254429f, -0.03440181f, 0.06059074f, 0.03843739f, -0.00521397f, 
    0.09775639f, -0.34663633f, 0.22296147f, -0.14580236f, -0.20830669f, -0.04657115f, 0.06191014f, -0.11574820f, 
    -0.03529387f, 0.02275774f, -0.03882189f, 0.08498691f, 0.04514206f, -0.12301365f, -0.04817675f, -0.06685262f, 
    0.07551189f, -0.03130278f, -0.04975455f, -0.08265489f, 0.01177314f, -0.07694884f, 0.05864529f, 0.13063513f, 
    0.03378372f, -0.02305356f, -0.03115804f, -0.06588911f, 0.01561655f, 0.10125077f, -0.09443922f, 0.05596107f, 
    -0.08002910f, 0.05390128f, -0.00359850f, 0.02088428f, -0.07146410f, 0.07106034f, -0.00912851f, -0.00675534f, 
    0.15190759f, -0.18135326f, -0.25762710f, 0.12739085f, -0.04382366f, 0.03728314f, 0.11087810f, -0.01953433f, 
    -0.03041442f, -0.01238001f, -0.02628438f, -0.02711855f, -0.00229672f, 0.07323479f, 0.13155259f, -0.00167924f, 
    -0.03109402f, -0.01242322f, 0.01169195f, -0.01496525f, -0.10007978f, -0.13797654f, 0.12574908f, -0.09940460f, 
    -0.00731145f, -0.02786363f, -0.00024248f, -0.01833277f, 0.07837311f, -0.08290159f, -0.02859119f, 0.01829103f, 
    0.02576941f, 0.03060829f, 0.11790752f, 0.04076129f, 0.03478118f, 0.05580133f, -0.09040134f, 0.08602851f, 
    0.21191604f, -0.42349675f, -0.01944167f, 0.09588747f, -0.03826008f, -0.03222165f, 0.02179830f, 0.00077585f, 
    0.11948755f, -0.02914918f, -0.06046845f, 0.07207612f, 0.01818328f, -0.03702553f, -0.03221094f, -0.03799412f, 
    0.06554169f, 0.10514983f, 0.05832559f, 0.03952887f, 0.05270952f, 0.26884905f, 0.04523782f, 0.25390145f, 
    -0.02451940f, 0.06026893f, -0.00753083f, 0.10482468f, 0.06953501f, -0.00026709f, -0.09435547f, -0.03053909f, 
    0.04671663f, 0.01116665f, 0.08550086f, 0.05996988f, 0.03878405f, 0.01255555f, -0.13595617f, -0.11693387f, 
    0.27147648f, -0.01824251f, -0.04700302f, 0.01226994f, -0.04164311f, -0.02228664f, 0.01444300f, 0.07223717f, 
    -0.06744774f, 0.01402159f, 0.11018552f, 0.07785054f, 0.02404390f, 0.00795256f, 0.04707840f, 0.09062362f, 
    -0.01604049f, 0.00320856f, 0.09651319f, 0.10096106f, 0.24974424f, -0.14074841f, -0.12616813f, 0.08300949f, 
    -0.06362353f, 0.08235918f, 0.06314743f, -0.01167838f, -0.00384625f, 0.11274102f, -0.12950324f, 0.09220888f, 
    -0.01129274f, 0.01677393f, -0.06998285f, -0.02428196f, -0.03649876f, -0.08766846f, -0.05476091f, 0.00309056f, 
    0.01038953f, 0.10799656f, 0.01648626f, 0.01360936f, -0.07731508f, 0.05935144f, 0.01416536f, -0.02883581f, 
    -0.05371524f, -0.00599771f, -0.08081826f, -0.03294603f, 0.03551118f, 0.02468718f, 0.15056610f, 0.06421199f, 
    0.05046953f, 0.00124693f, -0.07298713f, -0.01715945f, 0.34623432f, -0.00141610f, -0.08227917f, -0.05706727f, 
    0.07539282f, 0.15289342f, -0.07893023f, 0.00274926f, -0.11629220f, 0.08327634f, -0.03221526f, 0.04006363f, 
    0.06801451f, 0.09591987f, 0.04625468f, 0.03523028f, 0.02187225f, -0.05805906f, -0.01189250f, -0.00977723f, 
    -0.00267816f, -0.07207244f, 0.05207466f, -0.04292841f, -0.05441369f, -0.07356597f, -0.04908726f, -0.03624058f, 
    -0.04980670f, -0.03733085f, 0.00459560f, 0.00847184f, 0.03271819f, -0.05926021f, 0.01932458f, 0.02492141f, 
    0.06522968f, 0.00660430f, -0.02905949f, 0.07445224f, 0.22279240f, -0.07137988f, 0.08704419f, -0.14150989f, 
    -0.01067547f, 0.03869582f, 0.00203911f, 0.03063192f, 0.01352362f, -0.05459270f, -0.11042573f, 0.01745077f, 
    -0.06516957f, 0.00402576f, 0.02905340f, 0.00733420f, 0.01945852f, -0.12031808f, -0.02447661f, -0.01488663f, 
    -0.01460119f, 0.00048587f, 0.06029759f, -0.12345006f, -0.22862826f, 0.00609206f, 0.04397972f, 0.10742813f, 
    -0.08894759f, 0.00253323f, -0.06392059f, -0.06852667f, 0.00609604f, -0.06141308f, -0.01605703f, -0.01809422f, 
    -0.05345257f, -0.05845007f, 0.03285386f, -0.03787561f, -0.19061396f, -0.08655357f, 0.02262162f, 0.14122640f, 
    -0.03470198f, 0.07046717f, 0.04729708f, -0.04142110f, -0.03464352f, -0.02096574f, 0.00859437f, 0.02945126f, 
    0.03831571f, -0.05590838f, -0.15313745f, -0.04288294f, -0.05487387f, 0.05210838f, 0.02424688f, 0.01399046f, 
    -0.50322956f, 0.04884787f, 0.08922300f, -0.11579829f, 0.14195295f, 0.01658618f, 0.04713374f, -0.06689405f, 
    0.00064249f, 0.08097058f, -0.09316014f, -0.05809213f, -0.05774126f, 0.02079410f, -0.01478209f, 0.06435006f, 
    0.02370720f, 0.04487164f, 0.00841264f, -0.00214348f, -0.32030946f, 0.08425213f, 0.08367299f, -0.06723423f, 
    -0.04395889f, 0.00054690f, 0.00942885f, 0.06293789f, 0.00621747f, -0.05858612f, -0.01395927f, 0.00563944f, 
    -0.05712175f, 0.00235344f, -0.07427565f, 0.00183879f, -0.01174671f, 0.08162992f, 0.04868117f, 0.00283870f, 
    0.32012892f, -0.44583842f, 0.11199018f, -0.11686762f, 0.13194978f, -0.07739173f, -0.00974676f, 0.00699536f, 
    0.07389291f, -0.09193424f, 0.00507075f, -0.10711980f, 0.02054995f, -0.03898757f, -0.05993832f, 0.06213383f, 
    0.10023142f, 0.07685269f, -0.03283890f, 0.08648142f, -0.13059840f, -0.00735886f, -0.06268419f, -0.09792442f, 
    0.14757869f, -0.15211059f, 0.07946777f, 0.15593579f, 0.03555632f, 0.00235282f, -0.01852302f, 0.01053444f, 
    -0.00971250f, -0.10487799f, -0.02864777f, 0.03259126f, -0.13451825f, 0.08037087f, 0.04540268f, 0.04308983f, 
    -0.21389303f, 0.03638880f, -0.05752300f, 0.05952876f, -0.00218667f, 0.10646620f, -0.00730332f, 0.03213161f, 
    -0.03547449f, 0.08775926f, -0.02935485f, 0.00208500f, 0.02910019f, 0.01732932f, 0.06876101f, 0.09412097f, 
    -0.13339826f, 0.05762664f, 0.01290024f, 0.04543177f, -0.07942725f, -0.11753549f, 0.01524840f, 0.05718033f, 
    0.06869965f, -0.08429161f, -0.05912389f, -0.00222567f, 0.00788603f, 0.01706752f, 0.04163129f, 0.04583830f, 
    -0.04619311f, -0.03925297f, -0.09597012f, -0.00824122f, -0.02862687f, -0.03112111f, 0.10661215f, 0.03964387f, 
    -0.21498665f, 0.13360457f, 0.20575729f, -0.01496780f, -0.05340828f, 0.05675143f, -0.01718804f, 0.05893284f, 
    0.03645497f, -0.10711166f, 0.03598431f, 0.00562615f, 0.05394388f, -0.01542072f, -0.03426241f, 0.01918106f, 
    -0.00078666f, 0.05515220f, -0.10237236f, 0.08526184f, 0.14089364f, 0.07911318f, -0.00321408f, -0.31516922f, 
    -0.13982169f, -0.00640872f, -0.04668255f, 0.04787520f, 0.06446458f, 0.01592662f, -0.09815615f, 0.00285444f, 
    0.08160335f, -0.07928465f, 0.01887183f, 0.03648290f, 0.05924476f, -0.15981860f, 0.04665407f, 0.03619559f, 
    0.17502046f, 0.09531968f, -0.18044667f, -0.31696224f, -0.34493259f, 0.02567546f, 0.06084611f, -0.04875911f, 
    -0.02187967f, 0.03767435f, -0.15079039f, 0.02476490f, -0.00810002f, 0.03410455f, 0.01701994f, -0.03947192f, 
    0.04899115f, -0.03940650f, 0.11213337f, 0.00944199f, 0.21067123f, -0.02590244f, -0.07531612f, -0.11298319f, 
    -0.26452902f, -0.04841163f, -0.00705791f, 0.02593036f, 0.01998426f, -0.02878632f, -0.02015526f, -0.01448019f, 
    -0.08334775f, -0.04973217f, 0.02562157f, -0.00788415f, 0.08088002f, -0.06925357f, 0.04219602f, 0.07660271f, 
    -0.05133204f, -0.08180697f, -0.15756267f, 0.09079046f, -0.01851407f, -0.07723736f, 0.03404437f, 0.05391244f, 
    0.04498346f, 0.02800169f, -0.01519988f, -0.03742122f, 0.02742979f, 0.08864225f, 0.10567567f, 0.05857379f, 
    -0.00964548f, 0.01948895f, 0.10245493f, -0.09668756f, 0.28572395f, -0.29735455f, 0.13662006f, -0.02880645f, 
    0.04958962f, -0.03574005f, 0.01313948f, -0.00519064f, 0.04759442f, -0.03419154f, -0.00719061f, 0.01301317f, 
    0.02177623f, 0.01778380f, -0.04462912f, -0.00028164f, -0.03702302f, 0.07928406f, -0.11405368f, 0.11234384f, 
    -0.19749533f, -0.02002969f, -0.25311694f, 0.13657233f, -0.07178190f, 0.07088244f, 0.08631679f, 0.04748637f, 
    0.00668585f, -0.03262184f, -0.05220972f, -0.00829138f, -0.06323306f, -0.05994476f, 0.00468930f, -0.06528974f, 
    -0.01608217f, -0.02743234f, -0.00878757f, 0.02093689f, -0.20349674f, 0.34804395f, 0.04917897f, 0.01233614f, 
    -0.01407956f, 0.02089713f, 0.00550787f, -0.01516189f, -0.00705092f, 0.01312213f, -0.02563209f, 0.05930182f, 
    -0.02568239f, 0.05340386f, 0.02166811f, -0.01392769f, 0.00822132f, -0.02737806f, 0.02532616f, 0.03855424f, 
    -0.52691674f, 0.23144163f, 0.07188302f, -0.03607877f, 0.12904051f, 0.13569608f, 0.07334422f, -0.05337427f, 
    -0.05878112f, 0.09414475f, 0.05853931f, -0.05352819f, 0.00508336f, 0.01721315f, 0.01784981f, 0.13197893f, 
    0.00233568f, -0.02142028f, -0.06731338f, 0.08332833f, 0.24483491f, 0.00358444f, -0.07448429f, 0.06181929f, 
    0.02889332f, 0.09961754f, -0.08155906f, -0.03594347f, 0.02056620f, 0.13786726f, -0.04266138f, 0.01981817f, 
    -0.01202311f, 0.01100905f, 0.01142864f, 0.00001639f, -0.03292870f, 0.00545174f, -0.01601851f, 0.02949922f, 
    -0.10184292f, -0.11759790f, 0.07842550f, 0.08710657f, -0.09907404f, -0.05176121f, 0.00030391f, -0.08171707f, 
    0.08484504f, -0.01229856f, -0.04436494f, 0.08544539f, 0.03582791f, -0.00447066f, 0.02401600f, -0.01891307f, 
    0.02131207f, -0.05591376f, 0.04357530f, -0.10448489f, -0.08765913f, -0.16810191f, 0.08846781f, -0.18194091f, 
    0.07211142f, -0.04890126f, -0.01504923f, -0.03644064f, 0.00208224f, 0.00473952f, 0.01111743f, 0.03360639f, 
    0.06877311f, -0.07935398f, -0.09662393f, 0.09012224f, -0.01656352f, 0.00767880f, -0.00126727f, 0.02903157f, 
    -0.07415131f, -0.20274897f, 0.05815633f, -0.18797642f, -0.38484222f, 0.05726415f, 0.05849976f, -0.05446921f, 
    0.01645205f, -0.03912733f, -0.10379168f, -0.00437512f, -0.07704481f, 0.04846569f, -0.03939436f, -0.05369005f, 
    0.03004136f, 0.08887622f, 0.05792851f, -0.00180052f, 0.05015018f, -0.14346623f, 0.04366009f, 0.07155161f, 
    -0.18676731f, 0.02423128f, 0.05577654f, 0.00351288f, -0.05056663f, -0.04281026f, -0.01149244f, 0.00668253f, 
    0.04254926f, -0.09807819f, -0.01710441f, 0.01157762f, 0.00488352f, 0.01151458f, -0.07783692f, -0.04432667f, 
    0.03884893f, 0.04218041f, -0.18100548f, 0.17375201f, -0.05389300f, -0.07097574f, 0.02859469f, 0.00320650f, 
    0.05890114f, -0.09593695f, -0.00467595f, -0.04264954f, 0.04016979f, -0.03307655f, 0.05840481f, 0.07477977f, 
    0.01815013f, -0.00666388f, -0.04893228f, 0.02895823f, -0.21741553f, -0.08812771f, -0.08713934f, 0.05097903f, 
    0.09886125f, 0.00484195f, -0.01249284f, 0.02196876f, -0.03053718f, 0.03869126f, -0.04231688f, 0.05378710f, 
    -0.15824705f, -0.01128624f, -0.06682356f, -0.05684119f, -0.07582595f, 0.04413360f, 0.07469441f, 0.06198256f, 
    0.07069278f, 0.03996355f, 0.00657501f, -0.29569262f, 0.04243965f, 0.00763402f, -0.00753816f, 0.02983890f, 
    -0.03302934f, 0.01437787f, -0.05516794f, -0.00361965f, -0.03914791f, -0.05476741f, -0.02232317f, 0.00478040f, 
    0.07295510f, 0.04303330f, 0.09111517f, 0.02555719f, -0.03128224f, 0.19792435f, -0.15560454f, 0.06745700f, 
    -0.09256308f, 0.04498818f, 0.02252151f, 0.02710756f, 0.10593966f, 0.05631440f, -0.04545289f, 0.06596857f, 
    0.05647370f, 0.01483789f, 0.02808371f, 0.02834617f, -0.03519115f, 0.10995490f, 0.00822197f, -0.09995639f, 
    0.06420118f, -0.16385043f, 0.04040490f, 0.13917795f, -0.01135640f, -0.02700618f, 0.02821591f, -0.05124003f, 
    0.01884895f, 0.02959511f, -0.02626579f, -0.00572171f, 0.02889608f, 0.00504108f, 0.00721934f, 0.01158114f, 
    -0.03389342f, -0.01543793f, 0.02331963f, 0.03452738f, -0.11976375f, 0.00641172f, 0.07640663f, -0.00808703f, 
    -0.06929189f, 0.07538284f, 0.00947535f, -0.06946929f, -0.05884236f, 0.02148979f, -0.02451158f, 0.01357259f, 
    -0.08636022f, 0.00707404f, -0.02748620f, 0.06483152f, -0.04726371f, 0.07823299f, -0.09397320f, -0.00353834f, 
    -0.15526150f, 0.01282878f, 0.23750348f, -0.15782990f, -0.19273086f, -0.03754204f, 0.02176922f, -0.02724522f, 
    -0.06018190f, 0.08862732f, 0.01446114f, -0.07393614f, -0.04155721f, -0.13941906f, 0.04453393f, -0.04109466f, 
    0.00254959f, 0.09137490f, -0.10471930f, -0.08673954f, -0.07562245f, -0.08873598f, -0.07526467f, 0.05996469f, 
    -0.09847470f, 0.03774613f, 0.02692571f, 0.07760472f, 0.01226401f, -0.17191878f, 0.05311638f, 0.03419973f, 
    -0.06948517f, -0.04261679f, -0.06206033f, 0.02520082f, -0.02211655f, -0.11027972f, -0.14246276f, -0.08266724f, 
    0.01258998f, -0.01911664f, 0.00673295f, -0.04529568f, -0.06231634f, 0.02709463f, 0.05816471f, -0.00081522f, 
    0.03390940f, -0.04463818f, 0.05086041f, -0.03915036f, -0.04127655f, 0.04839871f, -0.04934688f, 0.04065536f, 
    -0.00892867f, -0.00067454f, -0.10390308f, -0.00680878f, -0.09915924f, 0.01292980f, 0.13116927f, -0.10834005f, 
    -0.15962735f, -0.00999731f, -0.03804605f, -0.00154669f, -0.09295802f, 0.02119700f, 0.04272314f, 0.09542757f, 
    -0.10218090f, -0.02492098f, 0.06021393f, 0.01274685f, 0.06554271f, 0.01814879f, 0.02543778f, -0.02282495f, 
    -0.32262978f, 0.07036062f, 0.06425249f, 0.03938965f, 0.01520907f, -0.01462786f, -0.03288342f, 0.02175007f, 
    0.05530245f, -0.01342114f, -0.00137676f, 0.04576167f, -0.05964518f, 0.04405675f, -0.10750999f, 0.02782011f, 
    -0.10771776f, 0.12177925f, -0.02080736f, 0.02482881f, 0.01627813f, -0.04299708f, -0.07221871f, 0.11254845f, 
    -0.03668763f, 0.03179369f, 0.02975622f, -0.07599655f, -0.00681386f, 0.04491080f, -0.02667806f, -0.05294202f, 
    -0.01271648f, -0.00580888f, 0.01116895f, -0.11209864f, -0.12127846f, -0.04319024f, -0.02817553f, 0.02119383f, 
    -0.15432321f, -0.17936441f, -0.01995592f, -0.09276322f, -0.00334969f, 0.03172627f, 0.07152701f, -0.04787272f, 
    0.03994416f, 0.09946017f, -0.04504578f, 0.03002019f, -0.02271615f, 0.02308638f, -0.03782768f, -0.07860301f, 
    0.01760634f, -0.02473016f, -0.05191056f, -0.00388490f, -0.06703390f, 0.01021226f, 0.03707953f, -0.19204308f, 
    0.09694636f, 0.04474507f, -0.02494940f, -0.06538370f, 0.01250516f, 0.05515908f, 0.01618888f, -0.04735383f, 
    0.06141629f, 0.04256210f, -0.04492865f, 0.03506067f, -0.00828906f, 0.00058972f, 0.03687793f, -0.06307390f, 
    0.19208223f, 0.06265997f, 0.00678948f, 0.03819168f, -0.18016505f, 0.02830355f, 0.03327732f, 0.08325262f, 
    -0.00548036f, -0.12420876f, -0.02014280f, -0.04023415f, -0.03559757f, -0.07218238f, 0.07891469f, -0.01181746f, 
    0.02410996f, -0.02949492f, -0.07094258f, -0.02439285f, -0.04284430f, -0.19303319f, 0.00215346f, -0.09078904f, 
    0.01500123f, 0.08559174f, 0.01521021f, -0.06351980f, -0.03399227f, -0.02645845f, -0.00039666f, -0.04072115f, 
    -0.00309779f, 0.08134137f, 0.07452789f, 0.02008783f, 0.00303719f, -0.15194593f, -0.00700179f, -0.02797934f, 
    -0.37889221f, 0.22457376f, 0.20177342f, -0.02074245f, 0.12259306f, 0.04564317f, 0.02565286f, -0.02023278f, 
    -0.06888221f, 0.02036630f, -0.03065844f, 0.04183630f, 0.03301095f, 0.01281862f, -0.07996958f, 0.05506595f, 
    -0.03230212f, 0.08811262f, -0.01246068f, 0.03901802f, -0.12047384f, -0.04618874f, 0.00757664f, 0.16928110f, 
    0.06418594f, 0.08035752f, -0.02827194f, -0.00774588f, -0.01307695f, 0.09968233f, -0.06485487f, -0.01176076f, 
    0.02723433f, 0.04743325f, -0.04437989f, 0.00087362f, -0.02314969f, 0.04305376f, -0.00292168f, -0.03650131f, 
    0.40070605f, -0.01233152f, -0.10357223f, -0.18384229f, -0.05916340f, -0.03257805f, -0.01438488f, 0.02341439f, 
    0.03814207f, -0.13850927f, -0.00622146f, -0.05385318f, 0.00285556f, 0.02225845f, -0.03700013f, 0.07988395f, 
    0.05285507f, 0.04753069f, 0.00725660f, 0.08468954f, -0.08736557f, 0.12763876f, -0.06160849f, -0.04133210f, 
    -0.13654897f, -0.07794471f, 0.02399198f, -0.06700583f, 0.01568374f, 0.07401665f, 0.02497997f, -0.05038672f, 
    0.09684708f, 0.07151281f, 0.10130956f, 0.04479532f, -0.00937088f, 0.03289668f, -0.02153449f, 0.01279124f, 
    -0.45991987f, 0.27968898f, -0.05758748f, 0.09449746f, -0.17244011f, 0.02543482f, 0.03118184f, -0.04671849f, 
    0.06700934f, 0.07936581f, 0.00321873f, -0.00255982f, 0.02422776f, 0.10558320f, 0.06064462f, 0.05246532f, 
    -0.01590089f, 0.05494479f, -0.10763939f, -0.04576200f, -0.11910643f, 0.03115730f, 0.10785916f, -0.06278056f, 
    -0.01173852f, 0.05363061f, 0.01510292f, 0.00672456f, -0.03501390f, -0.04917737f, -0.02270279f, 0.06951552f, 
    0.02192654f, -0.01399913f, -0.01551438f, 0.04618473f, -0.02645709f, 0.06595777f, -0.07328967f, 0.03920151f, 
    -0.25173187f, -0.06337746f, 0.08062266f, -0.03359741f, -0.09474764f, 0.05577837f, 0.04359742f, 0.04295104f, 
    0.01817375f, 0.03298269f, -0.00066393f, -0.00660898f, 0.01589789f, 0.06500317f, 0.06901398f, 0.03442433f, 
    0.00191109f, 0.01057191f, -0.00882543f, 0.01287961f, -0.17540199f, -0.01067558f, -0.05197961f, -0.11499185f, 
    -0.03204640f, 0.00288729f, 0.05481184f, 0.02001156f, 0.08146501f, 0.03392574f, -0.03877461f, -0.01620011f, 
    -0.04679144f, 0.00836185f, 0.00018211f, 0.13392033f, 0.01254850f, 0.11221128f, 0.04350895f, 0.10877728f, 
    -0.36092213f, -0.20419835f, -0.10402953f, -0.13188232f, -0.08351560f, -0.04041804f, 0.03954713f, -0.08288433f, 
    -0.02871066f, 0.05684450f, -0.00335000f, 0.05611979f, 0.01431680f, 0.05123173f, 0.06291533f, 0.04121952f, 
    0.02986181f, 0.08954418f, 0.06600066f, 0.07464603f, 0.03589032f, 0.06391114f, -0.14439245f, 0.02934969f, 
    0.07931958f, -0.06161161f, 0.03849208f, -0.03212764f, 0.00618676f, 0.03469883f, 0.05010635f, 0.01450582f, 
    -0.09938154f, -0.01240960f, 0.01206401f, 0.12388403f, -0.05842308f, -0.10090104f, -0.12112700f, -0.04339692f, 
    0.12356947f, -0.07006228f, -0.00355914f, 0.09114797f, -0.05223276f, -0.00102825f, 0.00718737f, -0.00601505f, 
    -0.00608340f, 0.00813330f, 0.03057414f, 0.00639808f, -0.03958087f, 0.02076295f, -0.06336164f, -0.05507599f, 
    -0.06636142f, -0.15279810f, -0.07655683f, -0.04154445f, 0.02276555f, 0.03110034f, -0.01894806f, -0.01261131f, 
    -0.01596559f, 0.04586663f, 0.00109128f, 0.05619688f, -0.00456342f, 0.06129635f, 0.03976208f, 0.06603883f, 
    -0.01010272f, 0.02414805f, 0.03768323f, 0.03845344f, -0.00118516f, -0.03443825f, 0.04186552f, -0.02721610f, 
    -0.22494580f, -0.21339451f, 0.01713045f, 0.04632286f, 0.14067422f, 0.04489302f, 0.05080579f, 0.02242975f, 
    -0.02703257f, -0.06985645f, 0.11152206f, 0.04736619f, -0.04963421f, -0.02179203f, 0.02285757f, 0.02574079f, 
    -0.04793165f, -0.04157640f, 0.04017837f, 0.05246077f, 0.14286147f, -0.01568804f, 0.00802430f, 0.01552228f, 
    -0.02844757f, -0.00270772f, -0.11653524f, -0.01475809f, -0.03572641f, -0.07302377f, -0.02068765f, -0.00669129f, 
    -0.10678747f, 0.10482235f, -0.08160730f, -0.03964024f, -0.09935385f, -0.09905300f, -0.08670023f, -0.14014071f, 
    -0.22689281f, 0.03914888f, 0.06939398f, -0.11021436f, -0.21889663f, 0.09785890f, -0.07447060f, -0.04248874f, 
    -0.05111705f, 0.04313711f, -0.02516568f, 0.00056076f, -0.07403805f, 0.07345129f, -0.06201820f, 0.00834754f, 
    -0.02709550f, -0.10019396f, -0.13680361f, -0.04632096f, 0.18995310f, 0.00730631f, -0.03251267f, 0.05291149f, 
    -0.11844018f, -0.02818358f, 0.02713173f, 0.02976257f, 0.00290334f, 0.01202652f, -0.05063788f, 0.03861495f, 
    0.02242650f, -0.05396064f, -0.04416725f, 0.01553084f, 0.10125048f, -0.09641608f, -0.05265012f, 0.02226887f, 
    -0.00189687f, -0.10713201f, -0.04217722f, -0.06065353f, 0.08798180f, -0.02190463f, -0.04619882f, 0.03284804f, 
    -0.00740572f, 0.01083242f, 0.01942351f, -0.06999648f, -0.02710350f, -0.01703523f, -0.01382986f, -0.02011550f, 
    0.05225092f, 0.03336900f, 0.06474692f, 0.06515859f, -0.18951221f, -0.14378025f, -0.05358625f, -0.04139350f, 
    0.10458717f, 0.07152849f, 0.04611683f, -0.00278905f, -0.02883867f, -0.09113751f, 0.00837637f, 0.05816361f, 
    -0.06213522f, -0.00725981f, 0.05578780f, -0.00480820f, -0.03415319f, 0.00216562f, 0.03908369f, 0.05862314f, 
    0.09605949f, -0.00872532f, 0.09395403f, 0.07879706f, 0.02746916f, -0.01772603f, 0.04524292f, 0.01515761f, 
    0.03016981f, 0.01793805f, 0.04393077f, 0.09829681f, 0.02094466f, -0.01824582f, 0.05076803f, 0.00517958f, 
    0.03140019f, -0.01790059f, -0.09499975f, -0.04189836f, -0.11694127f, -0.07904921f, -0.01353921f, 0.03861582f, 
    -0.01767312f, -0.03357701f, -0.03071869f, 0.04778004f, 0.02189164f, 0.03611279f, 0.04259338f, -0.00868017f, 
    -0.01743594f, -0.00791656f, 0.00699057f, -0.01471493f, -0.03402317f, 0.01155798f, 0.15396853f, 0.00749365f, 
    -0.12850921f, 0.11666536f, 0.06995989f, -0.07315599f, 0.06462742f, 0.08367881f, 0.02338400f, -0.06678446f, 
    0.00819555f, -0.01288597f, -0.06799656f, 0.01855154f, 0.01545543f, 0.00655739f, -0.01028119f, -0.03898784f, 
    0.06365059f, 0.04577893f, -0.08583272f, 0.12983699f, 0.14502198f, -0.00699814f, 0.00297620f, 0.06736563f, 
    0.05185396f, -0.08983469f, -0.04356417f, 0.01180646f, 0.00454203f, -0.04354675f, -0.00484860f, -0.00175636f, 
    0.01663918f, -0.08069046f, 0.01688797f, -0.04191455f, -0.01059262f, 0.07459044f, 0.02128568f, 0.07092695f, 
    -0.18210629f, -0.09317189f, 0.08929992f, -0.00343041f, 0.01971345f, 0.05040112f, 0.01210843f, 0.02593416f, 
    -0.04898721f, 0.05974955f, 0.02111285f, 0.00782428f, -0.01630238f, -0.04313289f, 0.02032448f, -0.02720524f, 
    -0.07866474f, -0.16079919f, -0.01338320f, 0.00037393f, 0.03773770f, 0.19622736f, -0.03463560f, 0.09157057f, 
    -0.03760039f, -0.02896606f, -0.01562338f, 0.01965987f, 0.02047326f, 0.04535163f, 0.05330634f, -0.00067958f, 
    -0.01235607f, -0.02912342f, 0.02114732f, -0.00011288f, 0.00276616f, 0.13669719f, -0.02663581f, 0.00270923f, 
    -0.01180957f, -0.02313210f, 0.05429819f, 0.08779716f, 0.00667029f, 0.05518870f, 0.04076692f, 0.03876668f, 
    0.03084121f, 0.00873418f, -0.00100501f, 0.03505098f, -0.02698739f, 0.00987231f, -0.01238222f, 0.01170705f, 
    -0.03981370f, -0.03501315f, -0.01304120f, -0.00895426f, -0.15898448f, 0.00875446f, -0.08180489f, -0.00242058f, 
    0.06728206f, 0.01440921f, 0.03466729f, 0.00958878f, -0.01087364f, 0.05317337f, 0.03447954f, -0.00382751f, 
    0.03265404f, -0.03614204f, 0.07377215f, 0.03429417f, 0.12047608f, 0.09442396f, 0.02056832f, 0.10720579f, 
    -0.35673773f, -0.16324365f, -0.09345919f, -0.08324450f, 0.08166077f, 0.05871257f, 0.00346161f, -0.07350269f, 
    -0.01052604f, -0.03958083f, -0.01352092f, 0.00563447f, 0.03522713f, 0.11571797f, 0.00136663f, 0.12439750f, 
    0.05391359f, 0.05879096f, 0.02681400f, 0.03527610f, 0.24383849f, 0.08336958f, 0.02099692f, -0.06301606f, 
    -0.01696048f, 0.01392402f, -0.13360538f, 0.13154435f, -0.06886760f, -0.00769382f, -0.02576739f, -0.08006401f, 
    0.06722832f, 0.00079747f, -0.05603577f, -0.01086066f, 0.13223357f, -0.00085585f, 0.05615621f, 0.05210496f, 
    -0.25943443f, -0.04377313f, -0.02277588f, 0.06902033f, -0.10103716f, 0.07232592f, 0.01795146f, 0.00837290f, 
    -0.02520149f, 0.02114102f, 0.07801857f, 0.03578142f, -0.00066767f, -0.04327484f, 0.09274732f, 0.02950543f, 
    -0.10538439f, -0.06613042f, 0.07222357f, 0.00151412f, -0.05185859f, -0.11518192f, 0.04933737f, 0.07115084f, 
    0.06268952f, 0.05559359f, 0.03838433f, -0.03234708f, 0.07378462f, 0.00504436f, -0.00588270f, 0.05331497f, 
    0.05299605f, 0.02703210f, 0.02979800f, 0.05828495f, 0.05243752f, 0.00144148f, 0.05326640f, -0.01114702f, 
    -0.34825733f, -0.11071099f, -0.12843481f, 0.16024697f, 0.11432709f, -0.02911854f, 0.05549286f, -0.13638546f, 
    -0.00296788f, 0.02940931f, 0.04209573f, 0.07831782f, 0.04336751f, -0.01898251f, 0.20434456f, -0.00396503f, 
    -0.06233424f, -0.03162559f, -0.08391286f, -0.09880652f, 0.24315065f, 0.20263113f, 0.00313513f, 0.00841312f, 
    0.11801081f, 0.09246556f, -0.07852484f, 0.00529395f, 0.01522574f, 0.09977198f, -0.09646976f, 0.04087698f, 
    0.08028050f, -0.05985917f, -0.01389270f, 0.04850741f, 0.04371374f, -0.04407575f, -0.10011707f, -0.00488727f, 
    0.09788012f, 0.05248073f, -0.10262252f, 0.02574470f, -0.08722748f, 0.01692948f, -0.05518686f, 0.07544442f, 
    0.00764677f, 0.05612749f, -0.00652559f, -0.04670096f, 0.01033637f, -0.02317309f, -0.03768916f, 0.01584505f, 
    0.05645861f, -0.08581226f, 0.03742598f, 0.07298506f, 0.16839902f, 0.10053232f, 0.08260515f, -0.02350172f, 
    0.01194132f, 0.05372068f, 0.12026165f, 0.02701167f, -0.02418621f, 0.02055977f, 0.01483680f, -0.03833818f, 
    -0.01975323f, 0.02091764f, 0.06453230f, 0.11885813f, 0.03993830f, -0.01659565f, -0.08362696f, 0.02692908f, 
    -0.16005565f, -0.16538237f, -0.13133617f, -0.02928402f, 0.05761210f, -0.01636977f, 0.03815786f, -0.02335087f, 
    -0.06148964f, -0.01195591f, 0.04611374f, -0.01119528f, -0.04528786f, 0.01831504f, 0.04345684f, 0.00873007f, 
    0.04075545f, 0.06163388f, 0.09366492f, -0.00057484f, -0.07259133f, -0.00215602f, 0.03932443f, -0.02854500f, 
    0.03404514f, 0.03775591f, -0.00602715f, -0.03733710f, 0.03701436f, 0.03102040f, 0.03144441f, 0.03692165f, 
    0.07426300f, 0.06014903f, -0.03432217f, 0.02243295f, 0.10864409f, 0.07287448f, 0.08510589f, 0.09639467f, 
    0.00471586f, -0.02234950f, 0.15035099f, -0.12115324f, -0.20409465f, 0.09379790f, -0.02827458f, -0.00315260f, 
    -0.00418780f, 0.06084704f, -0.01857665f, 0.00400298f, 0.02895898f, -0.00545904f, -0.01740930f, 0.04546974f, 
    0.09585693f, -0.08756286f, -0.09359315f, -0.00238425f, -0.35654783f, -0.15011035f, 0.13975713f, -0.04800921f, 
    -0.25661898f, 0.04339176f, -0.07313268f, 0.00157757f, -0.07408945f, 0.06673239f, -0.02731641f, 0.02115584f, 
    -0.03298502f, 0.03584193f, 0.03422805f, -0.03560379f, -0.05160720f, -0.03243862f, -0.08241956f, -0.04199064f, 
    0.05116574f, 0.04306540f, 0.02016272f, -0.00019231f, 0.07724949f, -0.00836365f, -0.05752068f, 0.03458241f, 
    0.02947062f, 0.06042837f, -0.01041193f, -0.01041906f, -0.00253109f, 0.04719077f, -0.03337282f, 0.00056218f, 
    0.01912337f, 0.05670438f, 0.03929215f, 0.03240565f, -0.29048014f, -0.09323578f, -0.10567781f, 0.04631966f, 
    0.05539848f, 0.03376433f, 0.04295366f, -0.09696810f, -0.00880647f, 0.04507136f, 0.02309912f, 0.01264846f, 
    0.02489147f, 0.01764905f, 0.13604183f, 0.03558866f, 0.05176965f, 0.08219315f, 0.03206412f, -0.03535385f, 
    -0.06059653f, -0.10372802f, 0.03070495f, -0.04442937f, 0.12279665f, -0.03952800f, 0.00968856f, 0.02262584f, 
    0.01290049f, -0.03635589f, 0.02638654f, -0.00925330f, 0.02711258f, 0.00505352f, 0.01262136f, 0.00878632f, 
    0.03451766f, 0.05762041f, 0.07368759f, 0.08381425f, 0.01777190f, -0.18963446f, -0.05697542f, -0.02906052f, 
    0.18156563f, 0.03205523f, -0.00496081f, 0.06448805f, -0.09772851f, -0.02093440f, 0.00653303f, -0.05917338f, 
    0.02237228f, -0.03088596f, -0.07075045f, 0.01372184f, -0.03712177f, 0.00654527f, 0.07101375f, 0.05877469f, 
    -0.01975694f, -0.10521659f, -0.26132762f, -0.01863557f, -0.18234731f, -0.02145444f, 0.06240832f, -0.01146964f, 
    -0.04119492f, -0.04981350f, 0.08849145f, 0.00075904f, -0.07803422f, -0.12217762f, -0.00532918f, -0.00143013f, 
    -0.01548095f, 0.05908429f, 0.10061190f, -0.02742255f, 0.23261458f, 0.13715339f, -0.07347985f, 0.01100078f, 
    -0.06742606f, -0.17061853f, -0.14083785f, -0.02311334f, -0.03837187f, -0.05307707f, -0.01383844f, -0.01802954f, 
    -0.01403059f, -0.03622482f, -0.11532307f, -0.01429103f, -0.02049963f, 0.02709356f, -0.05932692f, -0.07334039f, 
    0.14125885f, -0.01868256f, 0.04728183f, 0.03113110f, 0.03237423f, 0.03488045f, 0.10114034f, -0.03920630f, 
    -0.00034994f, -0.05134191f, 0.02109718f, 0.03271554f, 0.03359751f, -0.01212935f, -0.01702090f, -0.05856312f, 
    0.06011938f, -0.01215622f, -0.04419701f, 0.04827133f, 0.01257316f, 0.13049562f, 0.11621613f, -0.02611620f, 
    0.06137124f, 0.06843098f, -0.00138289f, -0.01632644f, 0.03028119f, 0.03648132f, 0.00297743f, -0.03776388f, 
    0.00950382f, 0.00512048f, -0.03000286f, 0.02913745f, -0.10109019f, -0.08967452f, -0.10941083f, -0.03915570f, 
    -0.49938402f, -0.26817650f, -0.04657046f, -0.18970163f, -0.33034497f, 0.00988612f, 0.00979501f, -0.01654044f, 
    -0.02915164f, 0.03186654f, -0.00747414f, 0.09391931f, 0.02422729f, 0.04150036f, 0.02364982f, 0.06582172f, 
    0.00105311f, 0.08154093f, -0.05325316f, 0.01785671f, -0.29437608f, -0.07552721f, 0.01155309f, -0.08992819f, 
    -0.14713639f, 0.06479940f, -0.00019128f, -0.00900781f, -0.01112898f, -0.05930469f, -0.00839531f, -0.05386365f, 
    -0.04752233f, 0.03761471f, 0.02121865f, -0.05388204f, -0.07077202f, 0.00945812f, -0.03903340f, 0.01550005f, 
    -0.18965010f, -0.15941092f, 0.05754063f, 0.00215217f, 0.12686197f, 0.00552663f, 0.00762616f, 0.02419771f, 
    -0.03070574f, -0.06661718f, -0.02525324f, 0.05525275f, 0.03376742f, 0.03104246f, 0.08980282f, 0.03772847f, 
    -0.03816924f, -0.17602505f, -0.11075357f, 0.03636506f, 0.16625132f, 0.05351642f, -0.12611644f, 0.00268531f, 
    -0.14278378f, 0.01805855f, 0.00619379f, 0.03371403f, 0.07316091f, 0.09471077f, 0.05600915f, -0.03391432f, 
    0.00441107f, 0.01029876f, -0.02643873f, 0.08896459f, 0.08370310f, -0.02972449f, 0.01213198f, 0.03159643f, 
    0.18900855f, 0.24197392f, -0.01629657f, -0.02700230f, -0.08794574f, 0.03015114f, 0.00884737f, -0.05933468f, 
    0.06109442f, 0.05730896f, -0.03520581f, 0.01744774f, 0.10029099f, -0.05814020f, 0.02853859f, 0.01992214f, 
    0.13615713f, -0.08924180f, -0.05970704f, 0.09497083f, -0.13321173f, -0.01319524f, -0.01835203f, 0.03083329f, 
    -0.06897026f, 0.03601632f, 0.07060311f, 0.03671626f, -0.06316426f, 0.00629135f, 0.04384295f, -0.00273391f, 
    0.07119207f, -0.05643213f, -0.04966950f, -0.03346886f, 0.00069120f, 0.06721228f, 0.10140729f, 0.04950255f, 
    0.27667361f, -0.03108950f, -0.04106957f, 0.06898056f, 0.00354656f, -0.06537715f, -0.03960669f, -0.07481667f, 
    0.02673479f, 0.00469106f, 0.04115114f, 0.04261410f, -0.05850233f, -0.03816641f, -0.05309452f, -0.03903927f, 
    0.00177194f, -0.08642983f, -0.10620642f, -0.01527546f, -0.46685675f, -0.39607221f, -0.27797771f, -0.20388253f, 
    -0.35271603f, 0.02222467f, 0.03529606f, -0.04376917f, -0.10416009f, 0.04403107f, 0.06439698f, -0.01807913f, 
    -0.06071044f, -0.00159124f, 0.02132483f, -0.05636184f, -0.02333311f, 0.02954395f, -0.01822848f, 0.01981911f, 
    -0.30868775f, -0.06313580f, 0.00301931f, -0.08857735f, -0.16283353f, 0.12605013f, -0.04711338f, -0.00078260f, 
    -0.07845151f, -0.00006371f, -0.00584314f, 0.03192296f, 0.03007716f, 0.08455221f, 0.01567677f, -0.01625543f, 
    0.00801005f, -0.07007886f, -0.11051639f, -0.03929356f, -0.27087861f, -0.23857287f, -0.12789817f, -0.12742516f, 
    -0.06662916f, -0.02444932f, 0.01401326f, -0.09889986f, -0.06649783f, -0.05894959f, 0.00040244f, -0.12471306f, 
    -0.04979755f, -0.02396877f, 0.05241562f, -0.06254923f, -0.05711808f, 0.09299938f, 0.05625579f, 0.04721223f, 
    -0.26051027f, -0.14628386f, 0.00086211f, -0.07643233f, -0.10170406f, 0.01939199f, -0.01324898f, 0.00336061f, 
    -0.04750915f, 0.05691185f, 0.01849619f, 0.00733114f, 0.02263569f, 0.00906025f, -0.00806248f, 0.01686864f, 
    -0.06162677f, 0.07548007f, 0.03915564f, 0.03513243f, 0.07639945f, -0.08136638f, 0.16890155f, 0.06832647f, 
    -0.04109053f, 0.08475272f, 0.14542165f, 0.00182403f, 0.09642157f, -0.08376613f, 0.05590254f, -0.00099610f, 
    -0.04438288f, 0.00005027f, -0.00582936f, -0.08773942f, -0.02003880f, -0.17075665f, -0.01065622f, -0.03713554f, 
    0.12112691f, 0.11038101f, -0.13591151f, 0.10787888f, 0.03412532f, 0.07420387f, 0.01419964f, 0.10053646f, 
    -0.04308577f, 0.10517368f, -0.02371889f, -0.01892632f, 0.11552644f, -0.01632546f, 0.05601896f, 0.00815406f, 
    0.03307094f, -0.12983708f, 0.07094084f, 0.06775911f, 0.24646400f, 0.10019759f, 0.03757942f, -0.04271974f, 
    -0.03695115f, -0.15186131f, -0.04587216f, -0.06622174f, 0.02670956f, -0.06151744f, -0.09036478f, -0.02028824f, 
    -0.05650930f, -0.07234789f, -0.06575620f, -0.08703732f, 0.03444016f, 0.04437827f, -0.00788325f, 0.02817333f, 
    0.15734302f, 0.01980646f, -0.13127223f, -0.01833526f, -0.05171789f, 0.00157500f, -0.04791093f, -0.03904610f, 
    -0.00989041f, -0.02582848f, 0.00392389f, 0.03769938f, -0.10507387f, -0.04887424f, 0.04789774f, -0.06758256f, 
    -0.03792279f, 0.10136376f, 0.01265800f, -0.04527566f, 0.02847773f, 0.04991349f, -0.05766269f, 0.05525359f, 
    -0.05313994f, 0.01440068f, 0.03114105f, -0.05737596f, 0.01229374f, 0.00796006f, 0.04220334f, 0.03993596f, 
    0.00149117f, -0.02351510f, -0.00954374f, -0.05069732f, -0.03207260f, 0.00708418f, 0.08059616f, 0.00326435f, 
    -0.32865167f, -0.21644171f, -0.05570471f, -0.06246956f, -0.01380531f, 0.03565306f, 0.05222661f, -0.03673555f, 
    -0.04191960f, 0.01188061f, 0.02658506f, 0.03824434f, -0.02360503f, 0.06111413f, 0.03311223f, 0.02488189f, 
    0.01354911f, 0.09110240f, 0.04393869f, 0.07829297f, -0.40380520f, 0.03171914f, -0.21334718f, -0.12026437f, 
    0.03412014f, 0.06237348f, 0.02787998f, -0.14356491f, 0.00999721f, 0.06553318f, 0.05264869f, 0.00666276f, 
    0.01420723f, -0.02035762f, 0.06671763f, -0.08659360f, -0.02476997f, 0.10880584f, 0.03852802f, 0.04301598f, 
    -0.21473810f, -0.09702891f, -0.15365236f, -0.03171254f, -0.05903803f, 0.03407596f, 0.03858576f, -0.00638560f, 
    0.02608128f, 0.03068738f, 0.11183492f, 0.00231002f, -0.00270575f, -0.01677972f, -0.00056259f, 0.07170317f, 
    0.01711330f, -0.04011635f, 0.13373503f, -0.01293660f, 0.24984790f, 0.05202425f, -0.05418042f, 0.09174919f, 
    -0.07840549f, -0.12257423f, -0.08901484f, -0.04820207f, 0.00481376f, -0.06430114f, -0.03653495f, 0.06042756f, 
    -0.06926069f, -0.09907805f, -0.07019836f, -0.02840819f, -0.03364283f, -0.05707167f, -0.07127020f, -0.08611546f, 
    -0.19538540f, 0.04369811f, 0.15994035f, 0.06890294f, -0.04000749f, 0.02089216f, 0.01170547f, 0.00236173f, 
    -0.00136797f, 0.09354410f, -0.07020389f, 0.04098686f, 0.05777478f, -0.01031047f, 0.02303165f, -0.05618073f, 
    0.02796647f, -0.05564733f, -0.04694377f, -0.02497854f, -0.00413174f, -0.12881665f, 0.03353843f, 0.02871891f, 
    0.06513614f, 0.00197678f, 0.04251377f, -0.00750490f, 0.04895079f, -0.03385959f, 0.03149141f, -0.01723757f, 
    -0.00885973f, -0.07053804f, -0.05971992f, -0.03197075f, -0.03509708f, -0.08503388f, 0.00894775f, -0.01384202f, 
    -0.19922738f, -0.29266846f, -0.00454234f, -0.03700206f, 0.17389619f, -0.03793069f, 0.09891149f, 0.03694329f, 
    -0.02662336f, -0.15552765f, 0.01141950f, -0.02534573f, 0.00259047f, -0.09483589f, 0.08945019f, -0.06900569f, 
    0.00582282f, -0.02893164f, -0.01731736f, 0.00990273f, -0.41457197f, -0.24446312f, -0.06213560f, -0.02885142f, 
    -0.04160445f, 0.00889624f, 0.04348339f, -0.06942832f, -0.04594192f, 0.02530110f, 0.07488477f, -0.00188582f, 
    0.01256336f, 0.03885874f, -0.01959830f, 0.01836689f, -0.01574440f, 0.02820074f, 0.04172311f, -0.01425039f, 
    0.01279563f, 0.21909188f, -0.03868938f, -0.07528515f, -0.00122398f, -0.04135078f, -0.04180062f, 0.00877565f, 
    0.03517106f, 0.03044561f, 0.04473162f, 0.03974081f, -0.05230900f, -0.02046501f, -0.01250022f, 0.02132589f, 
    0.00957264f, 0.02556036f, -0.04146521f, 0.03831491f, 0.13426995f, 0.07726961f, -0.07511432f, 0.03606028f, 
    0.27592143f, 0.06214377f, -0.02193756f, -0.02422071f, 0.01814119f, 0.04374097f, -0.00723431f, 0.06511937f, 
    -0.00804362f, -0.00971851f, -0.03550253f, -0.02527915f, 0.04458941f, 0.01428778f, 0.02932253f, -0.01011762f, 
    0.36847124f, 0.03068953f, -0.15636726f, 0.02898162f, 0.13092156f, 0.00868334f, -0.05441412f, 0.01412593f, 
    -0.01010337f, 0.06709056f, 0.01067605f, 0.00070229f, -0.02351294f, 0.03905240f, -0.02275999f, 0.06026565f, 
    -0.00631895f, -0.03459906f, 0.02267739f, -0.04154608f, -0.16629235f, 0.17341119f, 0.00230453f, 0.02017176f, 
    0.14945377f, 0.00709903f, -0.18007955f, 0.00518901f, -0.00302413f, -0.06735253f, -0.05316579f, 0.05042297f, 
    0.06590883f, 0.06275755f, 0.08606412f, 0.09258575f, -0.02006544f, -0.03770523f, -0.01524222f, -0.04478798f, 
    0.03809144f, -0.06101560f, -0.02730449f, -0.08026637f, 0.01239550f, -0.04749338f, -0.13201514f, 0.03007681f, 
    -0.08187903f, -0.13569507f, 0.01496957f, 0.02116757f, 0.02214305f, -0.04921148f, -0.03192919f, 0.01162357f, 
    -0.08846197f, -0.02025319f, 0.09219147f, 0.04526614f, 0.18378474f, -0.14618300f, 0.05042623f, 0.06502275f, 
    0.02294516f, -0.06182797f, -0.17111075f, 0.02768453f, 0.05949678f, -0.01853414f, 0.02526897f, -0.01861356f, 
    -0.04389853f, 0.01430399f, -0.01070223f, -0.01562940f, -0.01039261f, -0.06620008f, 0.02387259f, 0.01903586f, 
    0.05074519f, 0.13033114f, -0.09072763f, 0.11602560f, 0.11579747f, 0.12391132f, 0.01177937f, 0.02834208f, 
    -0.02549471f, -0.05576438f, -0.01898004f, 0.00984409f, 0.05881104f, -0.00682672f, -0.00624085f, -0.01466228f, 
    -0.00036128f, -0.05873761f, -0.03461514f, 0.06272428f, 0.00423500f, 0.00737439f, -0.08424616f, -0.19125681f, 
    -0.00974592f, -0.13764948f, -0.06875467f, 0.04166059f, -0.01400299f, -0.19903235f, -0.03944035f, -0.00625675f, 
    -0.05159613f, 0.06673886f, -0.00747347f, 0.00342466f, -0.08714952f, -0.04139325f, 0.05883082f, 0.06570739f, 
    0.36822009f, 0.20615564f, -0.14203730f, -0.11138935f, -0.10912293f, -0.04032318f, 0.07350606f, -0.02259301f, 
    0.01817279f, -0.09125215f, 0.12780543f, -0.04689457f, -0.01158825f, 0.01781066f, 0.00726066f, 0.06800180f, 
    -0.03209858f, 0.03948173f, 0.00084596f, 0.15263070f, 0.10330354f, 0.08607001f, -0.00499363f, 0.05825077f, 
    0.02469418f, -0.01434623f, -0.00328451f, 0.07332293f, -0.06877286f, -0.07339186f, 0.02720610f, -0.03771341f, 
    0.06178778f, -0.01741747f, 0.01101948f, 0.03861692f, 0.02246020f, 0.03469938f, 0.01503242f, 0.02078546f, 
    -0.30675566f, 0.13632712f, -0.03929222f, -0.03838602f, 0.07072840f, 0.09537479f, -0.01491985f, 0.07646075f, 
    -0.08016910f, 0.06665053f, -0.01390053f, 0.06386306f, 0.03013046f, -0.00155513f, -0.00129336f, 0.01029664f, 
    0.03388830f, -0.11179579f, -0.07997397f, -0.04249313f, -0.03372833f, 0.02288689f, 0.03192087f, 0.04565087f, 
    -0.01589964f, 0.12336155f, 0.06253590f, -0.00159527f, -0.00217402f, -0.03085545f, -0.02756396f, -0.03751304f, 
    0.08666732f, 0.02071501f, -0.02531398f, -0.06321213f, -0.01420619f, -0.00486865f, -0.03674951f, 0.04931746f, 
    0.01552747f, 0.08118867f, 0.08458430f, -0.04878794f, -0.01096674f, -0.08060420f, -0.02677010f, -0.03286634f, 
    -0.07738717f, -0.01090393f, -0.02725509f, -0.00284926f, -0.00215864f, -0.01710793f, -0.06892253f, -0.00922169f, 
    0.08867797f, 0.02414423f, -0.00954053f, -0.01045942f, -0.05898044f, -0.31549531f, 0.04220991f, 0.03490536f, 
    -0.03070629f, 0.07885113f, -0.06369911f, 0.01709547f, -0.01453246f, 0.06823327f, -0.03283925f, 0.01318750f, 
    -0.05288217f, -0.06963973f, -0.02524801f, -0.07681609f, 0.02760691f, -0.03561631f, -0.04570776f, -0.00767310f, 
    -0.42843145f, 0.25189295f, -0.07093608f, -0.10166036f, 0.18021673f, 0.02053171f, 0.00192660f, 0.06022859f, 
    0.02819953f, 0.09758781f, 0.01913335f, -0.02950438f, 0.04652844f, 0.01973125f, 0.04003616f, -0.03312921f, 
    -0.03756168f, -0.02585533f, -0.04666010f, -0.08130018f, -0.37263855f, 0.00990744f, -0.01687793f, 0.01443138f, 
    -0.01244294f, 0.11191093f, -0.01573881f, 0.08273908f, 0.00007458f, 0.07395193f, -0.10209662f, -0.02639062f, 
    0.02752417f, 0.00642123f, -0.00576047f, 0.01428602f, -0.03785826f, -0.00191129f, -0.08094805f, -0.01026734f, 
    0.09724002f, 0.02161677f, -0.05761464f, 0.01361580f, 0.12288278f, -0.01642715f, -0.18846264f, -0.01575532f, 
    0.02628186f, -0.00293345f, -0.03343617f, 0.07748861f, -0.02536537f, -0.02079708f, 0.04558737f, -0.02584737f, 
    0.08839654f, 0.04502797f, 0.02071909f, 0.11057996f, -0.23572090f, 0.11956416f, 0.05265873f, -0.02233128f, 
    0.07426262f, -0.08281406f, 0.03380919f, 0.03229214f, 0.06708778f, -0.07759304f, 0.02445022f, -0.00098121f, 
    0.02942827f, 0.02735066f, -0.04521549f, -0.03623225f, -0.09547243f, 0.05612734f, -0.14051023f, -0.05901942f, 
    -0.04809747f, 0.11228605f, -0.06575452f, -0.05346803f, -0.06125900f, -0.02585622f, 0.01917863f, -0.01000239f, 
    -0.03230440f, -0.06177371f, 0.02311270f, -0.02549207f, -0.01981135f, -0.02359113f, -0.01265840f, 0.04551160f, 
    0.03323336f, -0.03336248f, 0.00802689f, 0.02310463f, -0.18802814f, 0.04765567f, -0.01435154f, -0.04075824f, 
    0.04097824f, -0.01813865f, 0.01077822f, 0.00366604f, 0.05744858f, 0.11337089f, -0.01460821f, 0.00398655f, 
    -0.03024180f, -0.06316058f, 0.01333687f, -0.00756226f, -0.10049501f, -0.05213181f, 0.01151630f, -0.01870097f, 
    0.16496685f, 0.11841920f, -0.10946540f, -0.02465300f, 0.07242137f, 0.14798497f, 0.03549991f, 0.00689508f, 
    0.02089994f, -0.00197491f, 0.07463508f, 0.05920408f, -0.00407318f, 0.00839927f, 0.02343286f, -0.00186603f, 
    -0.07780101f, 0.00813895f, -0.04479460f, 0.06680852f, 0.25442028f, -0.03314127f, 0.05645500f, -0.00786966f, 
    0.04755878f, -0.06220015f, 0.00341688f, -0.04865864f, 0.11137468f, -0.11596823f, -0.00028373f, -0.05647053f, 
    -0.09539038f, 0.04983874f, -0.08660007f, -0.00212977f, -0.09464844f, 0.01713125f, -0.07246466f, -0.14805859f, 
    0.02319751f, -0.07180736f, -0.13707405f, 0.06250045f, -0.10863601f, -0.10445779f, 0.01353639f, -0.01549950f, 
    -0.03687387f, -0.10010869f, 0.06728382f, -0.01407228f, 0.00719067f, 0.03080018f, -0.03967107f, 0.02702566f, 
    0.03885245f, -0.00164081f, -0.11133246f, -0.08153097f, 0.03126661f, 0.08347367f, -0.09167172f, -0.00715697f, 
    0.05092335f, 0.07691780f, 0.03753519f, -0.01587723f, -0.03944014f, -0.01918936f, 0.01512515f, 0.09473871f, 
    -0.02172633f, -0.00404193f, 0.03006833f, -0.04241417f, 0.06976429f, 0.07062507f, -0.07645701f, 0.06719320f, 
    -0.10346252f, -0.05701721f, -0.10223042f, 0.11232704f, -0.28647432f, -0.18268161f, 0.07125868f, -0.06007976f, 
    0.04727576f, 0.00959886f, -0.09667642f, -0.05701256f, 0.03181741f, -0.03039625f, 0.02741350f, 0.06861547f, 
    0.12252294f, 0.00903115f, -0.02745729f, -0.10163084f, -0.10063179f, -0.16894348f, -0.10450286f, 0.09238854f, 
    -0.03712551f, -0.14468266f, 0.09371977f, 0.05066423f, 0.05641807f, -0.01665999f, 0.06082999f, -0.10322071f, 
    -0.08593839f, 0.01239003f, 0.01888865f, 0.03743747f, 0.00065000f, -0.02516633f, 0.11545520f, 0.02440252f, 
    0.14702080f, -0.03134411f, -0.08065458f, 0.01201908f, 0.06195058f, -0.01571803f, -0.01669157f, 0.04137243f, 
    0.01519512f, 0.02736900f, 0.04656563f, 0.01270440f, -0.04858016f, 0.02303799f, -0.05458441f, 0.01980242f, 
    -0.07018629f, 0.03097565f, -0.08683719f, -0.04645302f, -0.08333827f, 0.08549774f, 0.01457804f, -0.08820662f, 
    0.06044570f, -0.03016906f, -0.04738096f, 0.01589906f, -0.05109322f, -0.05207640f, -0.07739662f, -0.00290839f, 
    0.02342768f, -0.03832915f, -0.04213150f, 0.00088113f, -0.02217398f, 0.01707355f, 0.08579194f, 0.02040000f, 
    -0.09922238f, -0.03610547f, -0.04009626f, 0.05383107f, -0.21416353f, 0.09610662f, 0.07618427f, 0.04373931f, 
    0.00744680f, 0.03713967f, -0.02346658f, -0.01650627f, -0.00423137f, 0.03224044f, -0.02946440f, -0.06166027f, 
    -0.02062193f, -0.06283751f, -0.07719946f, -0.00346271f, 0.20859160f, -0.21169059f, 0.01430485f, -0.00609156f, 
    -0.04735490f, 0.01586210f, 0.03912361f, -0.04016733f, 0.02545446f, 0.00554994f, 0.02478771f, -0.02358626f, 
    -0.03054790f, 0.05146645f, 0.07631293f, 0.05717432f, -0.02328781f, -0.00460605f, -0.02815327f, 0.00083033f, 
    0.04516228f, -0.08593678f, -0.10958335f, -0.01399791f, 0.25217101f, 0.12784271f, -0.11480471f, -0.04598869f, 
    0.09051586f, -0.01821728f, 0.04299320f, -0.01764700f, 0.01773533f, 0.02821833f, 0.04185601f, 0.07097470f, 
    0.00207898f, 0.08189135f, -0.03745950f, 0.02624036f, 0.07568848f, 0.06900821f, -0.07406730f, -0.23715445f, 
    0.22203557f, 0.04084219f, -0.15135920f, -0.01724704f, 0.09364621f, 0.05546784f, 0.00038632f, -0.01725985f, 
    0.03067541f, 0.01551964f, 0.02187238f, 0.11371449f, 0.04455684f, 0.06655288f, -0.03020487f, 0.01689579f, 
    -0.12254347f, -0.04510676f, 0.05730007f, 0.04218747f, 0.11508169f, -0.13800451f, 0.00717924f, 0.02191149f, 
    -0.00102396f, -0.13669463f, 0.02305499f, 0.07757306f, -0.03501037f, 0.05786366f, 0.03170284f, 0.02376014f, 
    -0.02091871f, 0.02635219f, 0.02102944f, -0.00022834f, 0.10087691f, -0.09439263f, -0.12139116f, 0.08473114f, 
    -0.23949279f, -0.05610498f, 0.02377082f, 0.02872766f, 0.03843300f, -0.01382155f, -0.14708728f, 0.00131508f, 
    0.00377582f, 0.03287728f, 0.11077169f, -0.00198160f, 0.08338544f, 0.00630056f, -0.07461445f, -0.01516865f, 
    -0.27360106f, 0.09326540f, -0.05821483f, 0.04154480f, -0.01740472f, 0.06400017f, -0.02521332f, 0.01443515f, 
    -0.00565034f, 0.04299993f, 0.02048176f, 0.01379841f, 0.00843698f, 0.03994299f, 0.03970109f, -0.00875997f, 
    0.06892732f, -0.00914608f, -0.06140454f, -0.05818903f, 0.07457457f, 0.06029282f, -0.07886694f, 0.10901432f, 
    -0.00406326f, 0.13963409f, -0.01428860f, -0.00028301f, 0.02405739f, -0.06144447f, -0.00678296f, 0.04107824f, 
    -0.05696080f, 0.06419272f, -0.03509641f, 0.03672861f, -0.00827912f, 0.04673004f, -0.11941335f, 0.00587505f, 
    0.03001124f, -0.34830293f, -0.13249038f, -0.06187736f, -0.21511140f, -0.04228269f, 0.10838342f, 0.11425557f, 
    -0.00199355f, 0.06754597f, -0.04310758f, 0.01017308f, 0.03425867f, -0.03087110f, -0.19818161f, -0.14994919f, 
    -0.03869842f, -0.10615211f, -0.15217121f, -0.08157872f, -0.03352247f, 0.05594628f, 0.08736458f, -0.06469212f, 
    -0.01902485f, -0.06066308f, 0.00651277f, 0.03683109f, -0.07952584f, -0.14713617f, -0.04018671f, -0.05616228f, 
    0.08514245f, 0.00903190f, -0.09587933f, -0.08706726f, -0.08515784f, -0.07173858f, -0.09574354f, 0.00984620f, 
    0.01010678f, 0.14635256f, 0.04820108f, -0.01461349f, -0.01168120f, 0.01480272f, -0.01509743f, -0.00027718f, 
    -0.09477642f, -0.00528360f, 0.01185690f, -0.01618086f, 0.04939434f, -0.19729607f, -0.08704486f, -0.01245932f, 
    -0.02458685f, -0.07057490f, 0.11660889f, 0.03595125f, 0.13599961f, -0.03651685f, -0.08714025f, 0.01321795f, 
    0.00220451f, -0.05825868f, 0.04409521f, 0.02163086f, 0.02799662f, -0.05201002f, 0.04900558f, -0.01674647f, 
    -0.04648488f, 0.06469259f, -0.06558423f, 0.04462567f, -0.00034313f, -0.03925878f, 0.04792983f, 0.06395005f, 
    0.39252940f, 0.11951472f, -0.17652953f, 0.00494089f, 0.28696904f, 0.05919912f, -0.12772429f, 0.02266459f, 
    -0.02226703f, 0.02649538f, 0.04804004f, 0.05543653f, -0.01328350f, 0.04842671f, -0.04706317f, 0.05333944f, 
    0.00688221f, -0.01030598f, -0.02143084f, -0.01224479f, -0.02464456f, 0.14509122f, -0.09009311f, -0.18940678f, 
    -0.11990176f, 0.02346578f, -0.07746407f, 0.04620107f, 0.02526391f, 0.05331300f, 0.07738003f, -0.04860364f, 
    -0.00174072f, -0.03343265f, 0.03022879f, -0.05924715f, -0.01789791f, -0.08902790f, -0.01724397f, 0.05687794f, 
    -0.12849376f, 0.29397640f, -0.03505841f, 0.03645668f, 0.07210276f, 0.04746110f, -0.11692569f, 0.11125828f, 
    0.00994074f, 0.01489136f, 0.00199843f, 0.06747824f, 0.08093745f, 0.02671823f, -0.00327866f, 0.02068429f, 
    0.07382879f, -0.06196093f, -0.05230584f, 0.05690395f, -0.00768477f, 0.14825387f, -0.10082505f, -0.05057659f, 
    0.07323508f, 0.02623921f, -0.01690699f, 0.04823618f, -0.02204909f, -0.05139248f, 0.01768291f, -0.05475946f, 
    0.06643138f, -0.01656491f, -0.06460059f, 0.06152316f, -0.02537616f, 0.05301990f, 0.04905099f, -0.11607934f, 
    0.06468931f, -0.03328725f, -0.07438035f, 0.10768607f, 0.24286237f, 0.05304190f, 0.01710831f, 0.01030985f, 
    0.08866172f, 0.08890950f, 0.04808763f, -0.10307731f, -0.01971105f, 0.04823816f, 0.07733820f, 0.03995867f, 
    -0.00721999f, 0.00460832f, 0.08582433f, -0.03969025f, -0.03531570f, -0.30663192f, -0.04845922f, 0.06192219f, 
    -0.02061884f, -0.00918649f, 0.04693584f, 0.00860035f, -0.03224947f, 0.11509364f, -0.00515716f, 0.03134008f, 
    -0.07010921f, -0.00803238f, -0.05773605f, 0.02173418f, 0.05286903f, 0.00927446f, 0.00828326f, -0.08672163f, 
    0.00432514f, 0.08965597f, -0.00395896f, -0.00843440f, -0.08055465f, -0.05114230f, -0.08602148f, 0.01469761f, 
    -0.07855736f, -0.11942926f, -0.03207269f, -0.01767656f, 0.07805801f, -0.08964827f, 0.00284661f, 0.04122004f, 
    0.00200528f, -0.01006773f, 0.02362814f, -0.06375013f, 0.40558365f, -0.14521174f, -0.24886891f, -0.07827268f, 
    -0.25975233f, -0.02049563f, -0.00049506f, 0.00514497f, -0.06308223f, 0.04431258f, 0.06420612f, 0.04532613f, 
    0.01730620f, 0.01186472f, -0.00742638f, -0.01479606f, -0.05321035f, -0.06016014f, -0.04570846f, -0.03469524f, 
    0.40192363f, 0.05068205f, -0.22968934f, -0.06441642f, -0.03469022f, 0.02175181f, 0.09444278f, -0.14143494f, 
    -0.00739296f, -0.05212045f, 0.06208366f, 0.04643002f, -0.00902605f, 0.03376632f, 0.00767903f, 0.05724199f, 
    0.04532651f, 0.02413059f, 0.00269146f, 0.04727323f, -0.30787265f, -0.27802575f, -0.19321716f, -0.09053434f, 
    -0.35097837f, 0.05949769f, 0.03788222f, 0.00512951f, 0.01290277f, 0.10483906f, -0.03757885f, -0.03469075f, 
    -0.01347449f, -0.04907035f, 0.04310339f, -0.09399682f, -0.03496067f, -0.00603405f, -0.07607360f, -0.05920727f, 
    0.13144971f, -0.04881363f, -0.11944018f, 0.00674397f, -0.07513504f, -0.01657025f, -0.04999103f, 0.01834312f, 
    -0.00046878f, 0.04521745f, 0.03005486f, 0.07481911f, -0.04980132f, -0.01089590f, 0.02498617f, 0.02650516f, 
    0.02926362f, -0.02272028f, 0.03939351f, -0.09694371f, 0.06678665f, 0.02791759f, -0.04263633f, -0.14911619f, 
    0.17679639f, 0.06264156f, -0.07045006f, -0.05857135f, -0.08501017f, 0.05424699f, 0.01628801f, 0.05999615f, 
    -0.06703833f, -0.00988360f, -0.11847614f, -0.08174910f, -0.05690356f, 0.06458890f, 0.05452305f, 0.05057563f, 
    0.06765869f, -0.02447083f, -0.06542052f, 0.07699398f, -0.06500441f, -0.01638069f, 0.03057184f, -0.01229847f, 
    0.03982054f, -0.01566968f, 0.08198573f, -0.07665996f, -0.04118323f, 0.07067541f, -0.03960496f, -0.01936127f, 
    -0.02347904f, 0.00351370f, -0.05271000f, -0.06079474f, -0.12376562f, -0.06576950f, -0.02042072f, -0.03295088f, 
    -0.01669496f, 0.00519408f, -0.00318979f, 0.00892377f, -0.01601670f, -0.01087751f, -0.04199920f, -0.04341300f, 
    0.04654810f, 0.02878533f, -0.05749199f, -0.07997782f, -0.04359981f, -0.04037829f, -0.09450628f, -0.03679089f, 
    -0.11126854f, -0.33425799f, -0.02704581f, -0.05020229f, -0.04365307f, -0.05342048f, 0.09716599f, -0.02653075f, 
    0.08262402f, 0.05912764f, -0.10434581f, 0.06784091f, 0.02715533f, 0.02131151f, -0.15827039f, -0.04415991f, 
    -0.08347236f, -0.02132918f, -0.17740779f, -0.08060013f, -0.20189531f, -0.19618259f, 0.03147669f, -0.01800248f, 
    -0.00209052f, -0.06334648f, 0.08102298f, 0.07528469f, 0.00840489f, -0.03020541f, -0.01531970f, 0.00376420f, 
    -0.02450706f, 0.01219175f, -0.03666141f, -0.03839022f, -0.00721434f, 0.02110772f, 0.00002732f, -0.00350129f, 
    0.01749604f, -0.14097530f, -0.11056185f, -0.11049096f, -0.23919995f, 0.08433526f, 0.02560449f, 0.02633157f, 
    -0.00391539f, 0.02440665f, -0.00664858f, -0.06666563f, 0.05874093f, -0.03945843f, 0.01379531f, -0.04729970f, 
    0.02322698f, 0.00026281f, 0.02430171f, -0.02979658f, -0.28813899f, -0.07703532f, 0.01089857f, -0.01557852f, 
    0.01094277f, -0.01384718f, 0.10960364f, -0.06135061f, 0.05281509f, -0.06925660f, -0.03899395f, 0.03238707f, 
    0.07014864f, 0.04418171f, 0.03860604f, -0.00480491f, 0.04795610f, -0.08645318f, -0.08684022f, 0.01370983f, 
    0.16473386f, -0.12956482f, -0.05577620f, 0.10624869f, -0.05875484f, 0.04444366f, 0.01190389f, -0.04542254f, 
    -0.03145743f, -0.02914088f, 0.02508120f, 0.00329192f, -0.01443765f, -0.01029173f, -0.10145278f, -0.03459819f, 
    0.00251423f, -0.04748793f, -0.12308203f, -0.01279876f, 0.04438430f, -0.08899484f, 0.07875565f, 0.03232229f, 
    -0.13720027f, -0.04277963f, 0.04789209f, 0.02316240f, -0.04013900f, -0.09169738f, -0.15034758f, -0.02698004f, 
    0.09348076f, 0.03207924f, -0.02787286f, -0.07036869f, -0.02852794f, 0.02141708f, -0.04995560f, 0.01821034f, 
    -0.15724251f, -0.08118123f, 0.00671134f, -0.12445021f, 0.16614686f, 0.05039888f, -0.13479713f, 0.01257243f, 
    0.04653357f, 0.03790507f, -0.04048520f, -0.06772496f, 0.05848785f, 0.07090218f, 0.00570421f, 0.06165963f, 
    0.03253585f, 0.01118863f, 0.04682787f, -0.04581978f, -0.03510996f, 0.05069363f, -0.04534050f, -0.01305060f, 
    -0.02698483f, 0.08332112f, -0.05385424f, 0.05259426f, -0.04598614f, -0.05809218f, 0.04705025f, 0.04768761f, 
    0.00251573f, 0.00004507f, 0.01253181f, -0.00539143f, 0.00351725f, -0.02802566f, 0.02016614f, 0.06153407f, 
    -0.24727292f, 0.27432209f, -0.02354376f, 0.11884557f, -0.12977727f, 0.16970284f, 0.08308771f, 0.04735741f, 
    0.04565624f, -0.00108095f, 0.06432069f, 0.04896469f, -0.04036640f, 0.00537106f, 0.07779285f, -0.02331439f, 
    0.12544367f, -0.00395502f, 0.01602992f, 0.05840699f, 0.26103491f, 0.03874916f, -0.10086098f, 0.09175979f, 
    -0.24762553f, -0.01426770f, 0.01564616f, 0.03951366f, -0.01723953f, 0.01320094f, -0.01303254f, 0.03050672f, 
    0.03338927f, -0.00576688f, 0.02884825f, 0.02183619f, 0.02807279f, 0.00234066f, -0.06183918f, 0.02637816f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.04575721f, 0.02936074f, -0.02618027f, 0.01357647f, 0.00403550f, 0.02222224f, -0.02830240f, -0.02568980f, 
    -0.03607588f, 0.01163600f, 0.06880821f, 0.00070613f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 5120);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
