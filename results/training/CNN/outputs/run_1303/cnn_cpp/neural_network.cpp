#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.90267295f, -0.47772208f, -1.17308998f, 0.18422265f, 0.33605042f, 0.25264505f, 0.52943236f, 0.49992847f, 
    0.30921307f, 0.97779763f, -1.07453454f, -1.38526297f, 0.67328340f, 0.53561765f, 0.34778830f, -0.39582840f, 
    0.35022852f, -0.64214045f, 1.55732274f, -1.56573927f, 0.01059335f, 0.16943172f, 0.08194531f, -0.36448002f, 
    -0.23246731f, 0.16305849f, 0.01538869f, 0.92066240f, 0.05175587f, -0.28217819f, 0.61616206f, 0.97253364f, 
    0.48355013f, -0.65285033f, -0.01762071f, -0.41280338f, -1.48059762f, 0.04487928f, -0.22963046f, -0.26406235f, 
    1.04989731f, -0.88039023f, -0.23076914f, -0.37134200f, -0.73529196f, 0.55609417f, -0.06767865f, 0.70707625f, 
    -0.84872931f, -0.01356593f, 0.44729584f, 0.66096300f, -0.54957187f, 0.10801712f, -0.37168199f, -0.13230577f, 
    -0.53942376f, -0.44732895f, -0.91468549f, -0.53676212f, 0.27908170f, -0.51684809f, -0.42276049f, 0.87951767f, 
    -0.20161611f, 1.04622579f, -0.57921708f, -0.90687537f, -0.75397569f, 0.15221889f, -0.87650973f, -0.71907032f, 
    0.69739097f, -0.69301355f, -0.63072580f, -0.46742690f, -0.66854316f, -0.43271264f, 0.58968425f, 0.78619707f, 
    0.84131658f, -0.60539180f, -0.91863012f, 0.00406759f, -0.74465775f, -1.00194895f, -1.09222019f, 0.23960951f, 
    0.10367002f, -0.03442467f, 0.91902792f, 0.54351830f, -1.20826375f, -0.24532486f, -0.69613683f, -0.78415346f, 
    -0.53473032f, -0.28877735f, -0.51093572f, -1.05122924f, -0.49289930f, -0.21750320f, -0.76187885f, -0.64106280f, 
    0.12319273f, -0.61982960f, -1.00986922f, -0.66789228f, -1.31616640f, -0.47631511f, 0.64723986f, -0.43251571f, 
    -0.19704640f, 0.20062529f, 0.31710985f, 0.31481919f, 0.69830179f, 0.74907029f, -0.08463205f, -0.69227505f, 
    -1.16024888f, -0.14065395f, 1.19113696f, -0.12401171f, -0.11582170f, 0.16234715f, -0.43950012f, 0.64590657f, 
    0.63733989f, -0.31921351f, 0.10341337f, 0.68750066f, -0.57638437f, -0.13868146f, 1.01174700f, -1.32750618f, 
    -1.27693474f, -0.61967772f, 0.75064987f, 0.14407642f, 0.37983602f, 0.31342003f, -0.17951649f, -0.01700404f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.45918936f, 0.33125070f, 0.43840069f, 0.48058626f, -0.01488021f, 0.58615464f, 0.17623937f, 0.46247321f, 
    0.29905161f, 0.08077636f, 0.27263585f, -0.06294835f, 0.15873720f, 0.50652951f, 0.09697016f, 0.56628650f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.02745904f, 0.02222126f, 0.03975860f, 0.02165285f, 0.04028232f, 0.04696802f, -0.00811040f, -0.03652074f, 
    0.01932199f, -0.05722672f, -0.00681887f, 0.03968001f, -0.04162467f, -0.03585812f, -0.02745085f, 0.00327312f, 
    -0.01897690f, 0.04071691f, -0.00698002f, -0.04067600f, 0.04316565f, -0.01254214f, 0.02357727f, 0.04954764f, 
    0.02488748f, -0.03642689f, -0.02422461f, -0.04779191f, 0.04831379f, -0.01299280f, -0.01902707f, 0.01381367f, 
    -0.05505531f, -0.05371671f, -0.00027646f, 0.01776719f, -0.01831912f, -0.01429919f, -0.01895462f, 0.03780833f, 
    -0.02449485f, 0.00841673f, 0.04037640f, 0.04937535f, -0.04975503f, -0.03134884f, 0.01310421f, -0.01411879f, 
    0.02581843f, 0.00265423f, -0.04272221f, 0.03583247f, -0.04373581f, 0.04036144f, 0.00955232f, -0.00302631f, 
    0.02703883f, -0.00013705f, -0.02336517f, 0.00507938f, -0.02658355f, 0.01299394f, 0.00918347f, 0.02751970f, 
    -0.01530447f, -0.00987380f, -0.00065379f, -0.00002458f, 0.03077932f, -0.01812634f, 0.00242988f, -0.02888345f, 
    0.04210835f, -0.00518535f, -0.01993191f, 0.02070259f, -0.01611625f, -0.00447423f, -0.02969955f, 0.04867552f, 
    -0.02632032f, 0.02457412f, 0.01044276f, 0.03985630f, -0.04848338f, -0.02358519f, 0.04481909f, 0.03175930f, 
    0.01274433f, -0.03522212f, -0.03083982f, 0.00017817f, -0.01261187f, -0.05209324f, -0.02034067f, 0.03233731f, 
    0.00656152f, -0.02950712f, 0.03075723f, -0.05860839f, 0.02243452f, -0.01515066f, -0.00933265f, -0.00295453f, 
    -0.03943680f, -0.02353739f, -0.00242860f, -0.03362975f, -0.01019952f, -0.03460298f, 0.02007463f, -0.01387548f, 
    -0.04014031f, -0.02503472f, -0.04528379f, -0.05595044f, -0.04557750f, -0.00514240f, -0.00853183f, 0.02202570f, 
    -0.05585008f, 0.01346560f, -0.04262002f, -0.02649545f, 0.03416050f, 0.04873310f, -0.03820512f, 0.01131864f, 
    -0.05376863f, 0.00187491f, 0.02628051f, 0.03960203f, 0.00822511f, -0.02014939f, -0.05041745f, -0.05390847f, 
    0.01100939f, -0.05661032f, -0.05473387f, 0.04608927f, 0.00657312f, 0.03761643f, -0.04926861f, -0.03953695f, 
    0.04863499f, -0.05937992f, -0.03035198f, -0.00108545f, 0.01113896f, 0.01020931f, -0.03479986f, 0.04038758f, 
    -0.04359163f, -0.05891252f, 0.03674847f, -0.04502540f, -0.01978325f, 0.02258947f, -0.06157484f, 0.03729223f, 
    -0.02254888f, 0.04380435f, -0.04776810f, -0.02596844f, 0.00052153f, 0.03942776f, -0.04961790f, -0.04562825f, 
    0.03804315f, -0.02609046f, -0.01003851f, -0.02893268f, -0.01630232f, -0.04769202f, -0.03646054f, -0.01157309f, 
    -0.02018130f, -0.02217216f, 0.01956897f, -0.04976826f, -0.04343987f, -0.03263321f, -0.02797436f, -0.01855522f, 
    0.00600794f, -0.03179736f, 0.01839872f, 0.01537162f, -0.03966177f, -0.05321646f, -0.01002864f, 0.01442392f, 
    -0.02889882f, -0.04899889f, -0.04061671f, -0.04189481f, -0.03992037f, 0.04633830f, -0.00189991f, 0.04099201f, 
    0.01971516f, 0.01809959f, -0.06128235f, -0.03097894f, -0.04029394f, 0.00557077f, 0.00605831f, -0.02407370f, 
    -0.02711779f, -0.04524865f, -0.02873788f, -0.03144328f, 0.00136893f, 0.04398786f, -0.02721227f, 0.02377267f, 
    0.00977050f, -0.04219431f, -0.04642440f, -0.05659609f, -0.02967352f, 0.01812348f, 0.01889166f, 0.01065681f, 
    0.02043345f, 0.04911800f, -0.01984708f, 0.01972556f, 0.01093291f, -0.03823509f, -0.03644339f, -0.01111076f, 
    -0.01582870f, 0.04389408f, -0.02299759f, 0.03977353f, -0.05635543f, 0.01862487f, -0.01768515f, 0.04142629f, 
    0.04589294f, 0.04318525f, 0.00691242f, 0.00469360f, -0.03359345f, 0.04204275f, -0.00785181f, 0.01041992f, 
    -0.03354447f, -0.00137124f, -0.01585430f, -0.05437465f, -0.03548624f, 0.02676179f, -0.04644569f, -0.01712125f, 
    0.02811838f, 0.01312932f, 0.02141659f, 0.01861054f, -0.04456179f, -0.06019065f, -0.05842664f, -0.01427017f, 
    -0.01597366f, -0.03245739f, -0.04515759f, -0.02154062f, 0.00929938f, 0.00850700f, 0.03228741f, -0.02820124f, 
    -0.02420054f, -0.02658474f, 0.03748970f, -0.03183101f, 0.03863315f, -0.01887096f, -0.05756553f, -0.00692641f, 
    0.01236085f, -0.00557482f, 0.03671844f, 0.01194162f, 0.00345995f, -0.05617624f, 0.01919551f, 0.03942965f, 
    -0.05174071f, 0.00883941f, -0.04198184f, 0.02999368f, -0.03515624f, 0.02610597f, 0.02223025f, 0.03165334f, 
    0.03227218f, 0.03051723f, -0.00037830f, 0.00956685f, 0.03504128f, -0.02553974f, -0.02021859f, 0.02812155f, 
    0.02226290f, 0.02740022f, 0.04293935f, -0.06094281f, 0.01826490f, 0.04218486f, 0.04689984f, -0.04138539f, 
    -0.05512314f, -0.05360281f, 0.02643445f, 0.03042266f, 0.03750382f, 0.03458114f, -0.02129801f, -0.05205604f, 
    0.18219471f, -0.19361109f, -0.46679151f, -0.22753628f, -0.14831084f, 0.05810850f, 0.11814927f, 0.18348157f, 
    0.02781313f, 0.12051475f, -0.04405958f, 0.10145596f, 0.05149094f, -0.03657049f, -0.12825477f, -0.05353780f, 
    0.04479142f, -0.07544049f, 0.00733974f, -0.00593307f, 0.57571125f, -0.03359631f, -0.25597394f, -0.22455783f, 
    0.09847517f, 0.11166100f, -0.07663757f, 0.34124255f, -0.11012932f, 0.07028019f, 0.13177064f, 0.08354858f, 
    0.04939387f, -0.13392274f, -0.12492380f, -0.03123232f, -0.11977405f, 0.05244568f, 0.00616671f, 0.09831952f, 
    0.22323202f, -0.02777633f, 0.17502150f, -0.04950464f, 0.18301451f, -0.00712502f, -0.15374950f, 0.10776730f, 
    -0.30215442f, 0.20935363f, 0.04887811f, 0.19539873f, 0.05212552f, -0.00915790f, -0.15846463f, 0.02410585f, 
    0.19415326f, 0.12218584f, -0.06505442f, 0.21896559f, 0.32217276f, 0.16262561f, 0.24737106f, 0.36547276f, 
    -0.06779547f, -0.07185648f, -0.07391384f, 0.08613840f, -0.09360643f, -0.03471801f, 0.13596980f, -0.06205896f, 
    0.00391582f, 0.05276278f, 0.06488283f, -0.15084454f, -0.12227590f, -0.14866719f, 0.11169164f, -0.04819287f, 
    0.57359815f, 0.35564697f, -0.07983407f, -0.52804631f, -0.14951655f, 0.10028109f, 0.10022285f, -0.11492651f, 
    0.24515130f, 0.32081237f, -0.00765153f, -0.08607813f, -0.17289205f, 0.08817270f, 0.04058673f, -0.01780546f, 
    -0.01379844f, -0.11786436f, 0.08512280f, -0.05121947f, -0.04768300f, 0.19905399f, 0.18361810f, -0.09258490f, 
    0.05518106f, -0.04853272f, 0.07321015f, -0.03414525f, -0.08159176f, -0.07272522f, -0.06214740f, 0.03068916f, 
    -0.02451994f, 0.04074129f, -0.01705505f, 0.02336621f, 0.10428143f, 0.02942338f, 0.12667847f, -0.09443292f, 
    0.18268724f, 0.11296165f, -0.02512903f, -0.18591858f, -0.03281221f, 0.08811237f, 0.20298864f, -0.12679932f, 
    0.01946642f, 0.06667840f, -0.03522732f, -0.01677799f, 0.03698715f, 0.00057682f, 0.16236047f, -0.05903958f, 
    -0.01394832f, 0.15020218f, 0.00443975f, 0.06680693f, -0.26074368f, 0.15356976f, 0.20241848f, -0.24326435f, 
    0.13025820f, 0.06466600f, 0.14495754f, -0.03044808f, -0.11616864f, -0.05472575f, -0.08021920f, -0.03777724f, 
    -0.00712828f, -0.02279094f, 0.00160006f, 0.01542245f, 0.08178645f, 0.01990046f, -0.05778878f, -0.17825477f, 
    0.00511242f, -0.03302249f, -0.32179675f, -0.19114757f, -0.09423729f, 0.14683717f, 0.13372163f, -0.02255390f, 
    0.02739837f, 0.11645120f, 0.14083293f, 0.12847869f, -0.05116551f, 0.11983179f, -0.03746009f, -0.12887776f, 
    -0.07246512f, -0.00212216f, 0.06084640f, 0.30568609f, 0.38684449f, 0.23273428f, -0.13413477f, -0.13900800f, 
    0.09589202f, 0.15587319f, 0.14327392f, -0.07263441f, 0.15203945f, 0.17403342f, -0.04953317f, -0.10734487f, 
    0.06490280f, 0.07992552f, -0.02729432f, 0.00295382f, -0.01454018f, 0.11693452f, 0.07374582f, 0.21024098f, 
    -0.11350827f, 0.02207437f, 0.08474282f, -0.14557621f, -0.06651367f, 0.11766747f, 0.03504743f, -0.00911153f, 
    0.02477484f, 0.16623314f, 0.05223563f, -0.02067196f, -0.01020174f, 0.01445878f, -0.03341470f, -0.08265689f, 
    0.07098585f, -0.04237824f, -0.13254149f, -0.11151996f, 0.35559177f, 0.35171670f, 0.16249561f, -0.29453886f, 
    0.05288769f, 0.23217882f, 0.22388917f, -0.02494146f, 0.09789622f, 0.15880387f, -0.04569344f, 0.02622030f, 
    -0.12467253f, 0.00861589f, -0.00286053f, 0.00471797f, -0.27038330f, -0.00716260f, -0.00996429f, -0.09707132f, 
    0.05791110f, 0.12455017f, 0.04894572f, -0.41757318f, -0.05797115f, -0.10255548f, -0.01306950f, 0.06014348f, 
    0.12612981f, -0.00541549f, 0.07718510f, -0.03144994f, 0.00480044f, -0.02598033f, -0.09572071f, -0.10239510f, 
    0.02821952f, 0.05290364f, 0.12894233f, 0.06541401f, 0.08907049f, 0.57909721f, -0.31763309f, 0.22193471f, 
    -0.10232066f, -0.00395905f, -0.11296887f, 0.24407080f, -0.09892664f, 0.23817989f, 0.08734629f, 0.12601620f, 
    -0.05758426f, 0.11120129f, -0.07722890f, 0.05621987f, 0.07335304f, 0.05922516f, -0.12559353f, -0.04111582f, 
    0.05327890f, 0.30059123f, -0.09162664f, 0.25343692f, -0.19980720f, -0.15836263f, -0.10835867f, 0.11515678f, 
    -0.14290620f, -0.11516374f, 0.01285405f, 0.04938526f, -0.06113917f, 0.10778595f, -0.06166746f, 0.04413766f, 
    0.09759539f, 0.03198221f, -0.11796259f, -0.06405962f, 0.26612526f, -0.03923787f, -0.30370000f, -0.46363413f, 
    0.09417012f, 0.11720947f, 0.23436742f, 0.14159481f, 0.27220011f, -0.00996769f, -0.01541318f, -0.03916470f, 
    0.02487139f, 0.00490698f, -0.00210650f, -0.04785876f, 0.04003091f, -0.04231938f, -0.07217187f, -0.09270407f, 
    -0.26412070f, 0.07568557f, -0.05514883f, 0.14305216f, 0.21178645f, -0.11307726f, 0.05065111f, 0.21152954f, 
    -0.01074750f, -0.09619523f, 0.00395322f, -0.04097978f, -0.04060106f, -0.09382256f, -0.05014309f, -0.00696008f, 
    -0.15293863f, -0.11381998f, -0.09416168f, -0.08218981f, 0.01470121f, 0.83663362f, -0.01397957f, 0.41512290f, 
    0.21192814f, 0.07640937f, 0.24435362f, 0.06358498f, 0.00140454f, 0.13327153f, 0.05441304f, -0.02496571f, 
    0.06411432f, 0.07220565f, 0.10681340f, 0.04708641f, -0.16307633f, 0.06607237f, 0.02976887f, 0.01984793f, 
    -0.67633724f, 0.87681055f, -0.63005382f, 0.91578710f, -0.37805992f, -0.09807562f, 0.06458735f, -0.04515113f, 
    0.16207634f, -0.03606876f, -0.16430539f, 0.13366075f, -0.01749589f, -0.04536165f, 0.01956506f, 0.24813804f, 
    -0.03730803f, 0.33626965f, 0.18893817f, 0.03674518f, 0.13196708f, -0.08407976f, -0.38048410f, -0.01542713f, 
    -0.06319819f, 0.04300780f, 0.04638784f, -0.09635206f, 0.08089414f, 0.00502631f, -0.17958188f, -0.18619542f, 
    -0.12995796f, -0.04184438f, 0.06296170f, 0.11336728f, -0.04444953f, -0.10431083f, -0.00369585f, -0.17653106f, 
    0.28266960f, 0.17927560f, 0.05753611f, 0.15119271f, 0.24881123f, -0.01678298f, 0.14011636f, 0.14719728f, 
    -0.10568640f, -0.00079828f, -0.02694522f, 0.13574509f, 0.03993828f, 0.02082713f, 0.12046707f, -0.05380977f, 
    0.10393424f, 0.01420969f, 0.19482093f, 0.10917939f, 0.17902477f, -0.00239020f, 0.19391547f, 0.11169328f, 
    -0.11050772f, 0.02674683f, -0.15379304f, -0.08581101f, -0.04174918f, -0.00771106f, -0.02482991f, -0.11312978f, 
    0.05462386f, -0.04022308f, 0.05438349f, 0.07510579f, -0.09228657f, 0.14595824f, 0.00410677f, -0.13504565f, 
    0.08176513f, -0.05888242f, -0.22219719f, -0.19769230f, 0.13420784f, -0.09929959f, -0.00194780f, -0.04931971f, 
    -0.08847446f, -0.21514806f, 0.04577127f, -0.05589416f, 0.04172758f, -0.08681313f, 0.00758842f, 0.02958072f, 
    -0.10682263f, 0.07729376f, -0.13079540f, 0.15885614f, -0.22318581f, -0.07147948f, 0.67092967f, -0.14839290f, 
    -0.05593995f, -0.04797974f, -0.09288266f, 0.03247371f, -0.03676394f, -0.02070567f, 0.03156697f, 0.00419695f, 
    0.08776242f, -0.00891716f, -0.00609460f, -0.01317475f, -0.08354937f, 0.13047452f, 0.16294804f, 0.02289931f, 
    -0.23919678f, -0.02073727f, -0.36738333f, 0.25127757f, -0.07257251f, 0.01862119f, -0.07313336f, -0.02878259f, 
    0.11045433f, -0.20640619f, 0.08755247f, 0.01104760f, 0.01111674f, -0.00610692f, -0.03945391f, 0.02013463f, 
    -0.09418272f, 0.13651554f, -0.09342144f, -0.03091869f, -0.13464496f, 0.07340227f, -0.24467224f, -0.08044421f, 
    -0.00279364f, 0.08179245f, -0.03801513f, -0.18591973f, -0.05867455f, -0.30646512f, 0.07843010f, -0.08687087f, 
    0.00376179f, -0.03825123f, 0.06222863f, -0.02479521f, -0.03822946f, 0.02286791f, -0.09012595f, 0.08161609f, 
    0.06007161f, -0.04602988f, 0.17294136f, 0.09396215f, -0.08108447f, -0.04080933f, -0.00521265f, -0.05846117f, 
    0.12257413f, -0.17012711f, 0.01828159f, 0.05382374f, -0.00660143f, -0.04354960f, 0.00955822f, 0.01176000f, 
    0.00640857f, 0.05224915f, 0.24661776f, 0.08394973f, 0.29141068f, 0.05561024f, 0.15556726f, -0.40788418f, 
    0.18838963f, -0.13805187f, 0.05452798f, 0.13777854f, -0.00296069f, 0.02888422f, -0.09022745f, 0.03538568f, 
    0.04738626f, -0.08194982f, -0.11145200f, 0.10119896f, 0.07562783f, 0.06451851f, -0.08067646f, -0.12012256f, 
    -0.08442865f, 0.03529857f, 0.17579873f, -0.19225387f, 0.27116370f, 0.15587588f, 0.07577183f, -0.06410252f, 
    -0.04218491f, 0.13850625f, 0.09915198f, 0.07398408f, -0.04118425f, 0.01757951f, 0.00178124f, -0.08709645f, 
    -0.02908212f, 0.02524389f, -0.21747653f, 0.08454138f, 0.75266802f, -0.01969929f, 0.22085780f, 0.09065155f, 
    0.19284454f, -0.10179249f, 0.27643055f, -0.06770405f, 0.32612523f, 0.15919794f, -0.02919726f, 0.16579865f, 
    -0.05980683f, 0.02331509f, 0.18868127f, 0.06035788f, 0.11746567f, 0.12680744f, -0.04782836f, 0.11351549f, 
    0.27548388f, -0.44168413f, 0.52410978f, -0.57549530f, 0.41742358f, 0.15734783f, 0.06077138f, -0.14273854f, 
    0.11660731f, 0.13260132f, -0.03543395f, 0.15663187f, 0.08196105f, -0.05677778f, 0.05937532f, 0.00967131f, 
    0.14515863f, -0.05516722f, -0.07211794f, -0.12580867f, -0.26258215f, 0.31414679f, 0.25684467f, -0.10699482f, 
    0.27046511f, 0.12599917f, 0.03028345f, 0.17730092f, -0.09592028f, 0.00413579f, -0.06129713f, 0.07503338f, 
    0.08976171f, -0.08113542f, -0.03252806f, -0.05892462f, -0.08030258f, 0.09688987f, -0.12806016f, 0.02050398f, 
    0.30736667f, 0.35490668f, 0.40382752f, 0.09172875f, 0.15437083f, -0.04696677f, -0.18861316f, -0.20853642f, 
    0.01402795f, 0.01879920f, 0.07405996f, 0.01138873f, -0.05198755f, -0.11978649f, -0.03137789f, 0.05960833f, 
    -0.10186721f, -0.15218802f, -0.03767899f, -0.09146780f, -0.48369551f, -0.41228342f, 0.08544016f, 0.23540679f, 
    0.03087899f, -0.01737256f, 0.13911225f, -0.07955980f, 0.18400627f, 0.13436806f, -0.05850095f, -0.00743680f, 
    -0.03322357f, 0.20406039f, 0.01973659f, 0.07834632f, 0.20234698f, 0.16015725f, 0.04955726f, 0.14831205f, 
    -0.29776415f, -0.37615457f, 0.46110237f, -0.26193553f, 0.18524699f, 0.11090078f, -0.07515738f, 0.23649283f, 
    0.19681278f, -0.24199843f, -0.00438534f, -0.12173632f, -0.15581296f, 0.07397569f, 0.17658901f, -0.07458447f, 
    -0.03891434f, -0.03841569f, -0.21244405f, -0.13349213f, -0.56812435f, 0.08284161f, 0.10426854f, -0.18609345f, 
    -0.02329607f, 0.07946472f, -0.02790099f, -0.02959615f, 0.07972971f, 0.15254879f, -0.08158978f, 0.18964796f, 
    0.13862771f, 0.13468441f, -0.04911287f, 0.06823267f, 0.28683731f, 0.23363777f, -0.10621564f, 0.20376129f, 
    -0.24445897f, -0.25738636f, -0.27617168f, 0.09737191f, -0.00348291f, -0.09257194f, 0.00567108f, 0.11301270f, 
    -0.21167946f, -0.06452319f, -0.01188152f, 0.06070132f, 0.12907819f, 0.05961385f, -0.12835602f, 0.08753176f, 
    0.14703119f, 0.27957475f, -0.05275272f, 0.29516241f, -0.06539774f, -0.14122099f, -0.01766640f, -0.08501235f, 
    -0.04709047f, -0.06923100f, 0.04709878f, 0.16916710f, 0.07357463f, -0.10330415f, 0.08876634f, 0.05644064f, 
    -0.04879540f, -0.04765607f, 0.11187679f, 0.01176411f, 0.22126587f, -0.26238918f, -0.06269625f, 0.01774312f, 
    -0.02381249f, -0.10992774f, -0.00241384f, -0.03285997f, -0.09944384f, -0.02990599f, -0.03140119f, 0.12347620f, 
    0.13616161f, 0.02758218f, 0.03705381f, 0.12032594f, 0.04176153f, 0.10983142f, -0.08787393f, 0.03181245f, 
    0.10887378f, 0.06711815f, 0.18146051f, 0.07000810f, 0.30583367f, -0.01156821f, -0.21106398f, 0.28842977f, 
    0.18153705f, -0.03551320f, 0.06116322f, 0.19021069f, 0.08384755f, 0.08927261f, 0.00097943f, -0.08437896f, 
    -0.18149799f, -0.13604820f, -0.15263617f, 0.10661412f, 0.21241981f, 0.07075305f, 0.09995534f, 0.32732481f, 
    0.26239297f, 0.26707277f, 0.45837614f, 0.02565535f, 0.07155057f, -0.00284266f, 0.06212940f, 0.17699279f, 
    0.09544013f, 0.15632261f, 0.08123149f, 0.15286662f, -0.18696614f, -0.28746384f, 0.02792009f, -0.08860792f, 
    -0.13860470f, -0.15630344f, -0.13048306f, -0.25614455f, 0.06973435f, -0.09504344f, 0.06967579f, -0.10475188f, 
    -0.02821907f, -0.05461397f, -0.10383517f, 0.23724040f, -0.08559054f, 0.13304462f, 0.05021459f, 0.09340303f, 
    0.01872720f, -0.03489659f, -0.11916469f, -0.00261073f, 0.01367674f, -0.05292013f, 0.19520482f, 0.00570905f, 
    -0.12963261f, -0.13389236f, 0.04406802f, 0.02477103f, 0.06949206f, -0.10345300f, 0.05560604f, 0.08480914f, 
    0.13020816f, 0.14323263f, -0.05248131f, -0.00001902f, 0.00178794f, -0.00907528f, -0.11838572f, 0.15740231f, 
    0.10105570f, 0.34678608f, 0.01942524f, 0.32289729f, -0.10015193f, -0.16450778f, -0.21441212f, -0.02438568f, 
    -0.19190755f, 0.10388084f, -0.00935227f, 0.13668130f, 0.05617568f, 0.06810766f, 0.06560723f, -0.05344209f, 
    0.06779008f, 0.24463418f, 0.04938613f, 0.04879571f, 0.28602415f, 0.21102084f, 0.32886136f, 0.39748353f, 
    0.07371882f, 0.20869222f, 0.11538068f, 0.11471201f, 0.00445618f, -0.06188637f, -0.14606947f, 0.07436047f, 
    -0.11579985f, 0.02795982f, 0.10439149f, 0.03909650f, -0.12711994f, -0.15454550f, -0.05214389f, 0.00505324f, 
    -0.25156301f, -0.15538834f, -0.02161198f, -0.18983372f, -0.47140804f, -0.23977147f, 0.14646721f, -0.38963035f, 
    0.19593260f, 0.17868833f, -0.03491110f, 0.03431585f, 0.01219600f, -0.38178515f, -0.06991243f, 0.11176827f, 
    0.12527692f, -0.07499682f, 0.15750919f, 0.05310219f, -0.01290195f, -0.20120206f, 0.15010749f, 0.05235222f, 
    -0.22867909f, 0.26724136f, -0.18061942f, -0.10801134f, -0.09442721f, 0.04349532f, 0.02508412f, -0.07945839f, 
    0.05530735f, -0.04449397f, 0.05003322f, -0.00056622f, 0.08119845f, 0.07297019f, 0.19088484f, 0.04537939f, 
    -0.11242301f, -0.16923293f, 0.01938513f, -0.10804068f, 0.34353513f, 0.04859998f, 0.33627969f, 0.30779880f, 
    0.02855011f, -0.01951286f, -0.08232699f, -0.15303575f, 0.05912039f, -0.03889727f, -0.07823046f, -0.01079925f, 
    0.06602745f, 0.03900116f, -0.05730622f, 0.04324140f, -0.02346801f, -0.07131912f, 0.06860393f, -0.02036423f, 
    -0.00806310f, -0.02154517f, -0.05654906f, -0.05044030f, -0.03907761f, -0.00915408f, -0.01094355f, 0.04921279f, 
    0.02397582f, -0.01707985f, -0.01381143f, -0.01865570f, 0.00594732f, -0.05897043f, -0.02474591f, 0.01829350f, 
    0.04084721f, 0.04866308f, -0.00279414f, -0.00485160f, 0.02669537f, -0.05436003f, 0.03037278f, -0.03873629f, 
    -0.03663372f, 0.04121046f, 0.01318489f, 0.00231324f, 0.00325837f, -0.04824956f, -0.02858089f, 0.01279279f, 
    0.01737557f, -0.03853641f, -0.00304341f, 0.03877340f, 0.01102988f, 0.03837242f, 0.03377936f, -0.06090954f, 
    -0.02993998f, -0.00909002f, 0.01778501f, -0.03977182f, -0.05118795f, 0.00707129f, -0.03656527f, 0.04236029f, 
    -0.02215156f, 0.01110897f, 0.00656899f, -0.01219813f, 0.04600812f, -0.02395900f, 0.01050692f, -0.02009211f, 
    0.01278458f, 0.04513006f, -0.00794981f, -0.02067216f, -0.02204518f, -0.01517986f, 0.04001968f, 0.03943315f, 
    -0.02372072f, -0.05274860f, 0.00381675f, -0.05732602f, 0.00810495f, -0.02605639f, -0.05632898f, -0.02197237f, 
    0.03409991f, -0.04958073f, 0.04432855f, 0.01901329f, -0.02559235f, -0.05404340f, -0.04895425f, -0.05697891f, 
    0.04270841f, 0.04767275f, 0.01974139f, -0.04338945f, 0.02945084f, -0.01494620f, 0.04745785f, -0.03657265f, 
    0.04596229f, 0.03793501f, 0.03395892f, -0.02888250f, 0.02025691f, 0.02299985f, 0.00921145f, -0.01691674f, 
    0.02163601f, -0.02191970f, 0.04184875f, -0.06010909f, 0.02019667f, -0.02775679f, -0.04385973f, 0.02511091f, 
    0.01323433f, 0.00628093f, -0.03106610f, -0.05629092f, -0.04582058f, 0.00202689f, -0.05348489f, -0.04835461f, 
    0.01167868f, -0.05297381f, 0.03493379f, 0.00210170f, 0.00847850f, -0.01783839f, -0.01580875f, -0.03500250f, 
    -0.02986332f, -0.03769287f, -0.01763252f, -0.02872839f, -0.03652148f, 0.04622735f, 0.03029444f, 0.00930102f, 
    0.04647078f, -0.05781846f, 0.00547297f, -0.00991370f, -0.03744158f, -0.03636776f, -0.00014134f, -0.05101496f, 
    -0.02706710f, -0.04044718f, -0.02594135f, 0.00499165f, 0.01244722f, 0.00759304f, 0.04162931f, -0.02671432f, 
    -0.00536964f, -0.03173590f, -0.00516469f, -0.04544940f, 0.02101962f, -0.05742575f, -0.01406766f, -0.04230407f, 
    0.02829705f, -0.00547495f, 0.04151883f, -0.05894644f, 0.04329003f, 0.01033775f, 0.03681040f, -0.00531757f, 
    0.02298086f, -0.01580996f, 0.02177841f, 0.02831849f, -0.01926815f, -0.02713469f, -0.04032424f, 0.03038826f, 
    0.03312311f, 0.01269973f, 0.04365003f, 0.02461276f, 0.01130901f, -0.00211007f, -0.04812764f, -0.03323706f, 
    0.03584053f, -0.04585704f, -0.03403683f, -0.02205477f, 0.05503640f, -0.02820693f, 0.01167964f, 0.00415728f, 
    0.03454864f, -0.06055622f, -0.03024380f, 0.03258052f, -0.01079600f, 0.01566728f, 0.01621973f, -0.03931366f, 
    0.01791580f, -0.01514068f, -0.05879459f, -0.05346794f, -0.03466193f, 0.03930110f, 0.00301262f, 0.03635478f, 
    -0.02063623f, 0.01289782f, 0.02483881f, -0.05989756f, 0.01612118f, 0.02581813f, -0.05152554f, -0.04698262f, 
    -0.01769051f, 0.02719179f, -0.03977668f, -0.01106543f, -0.01728686f, -0.01913415f, 0.00630056f, 0.03557669f, 
    -0.04607106f, -0.03822574f, -0.03875142f, -0.03353171f, -0.03901616f, 0.02964798f, -0.03396524f, -0.03022863f, 
    -0.05173737f, 0.03800547f, -0.01266897f, 0.04049676f, -0.02435995f, 0.02151105f, -0.02474011f, 0.00194038f, 
    0.01184036f, -0.02307862f, 0.01854586f, -0.01807295f, -0.02954574f, -0.02391321f, -0.05409838f, -0.00654907f, 
    -0.03831742f, -0.02055310f, 0.04135193f, -0.00028668f, -0.00319352f, 0.01281269f, -0.01011566f, -0.04601632f, 
    -0.01861420f, 0.01012972f, -0.03560848f, -0.01442229f, 0.04689712f, 0.00929669f, -0.01538218f, -0.00025974f, 
    -0.05137098f, 0.03305772f, -0.06102427f, 0.00537573f, -0.05573654f, 0.04704604f, 0.00133382f, 0.00388591f, 
    -0.03367988f, 0.02512287f, -0.05328370f, 0.01354434f, 0.00553740f, 0.04598517f, -0.06056201f, 0.03410778f, 
    0.01164599f, -0.02681697f, -0.06012323f, -0.00317087f, 0.02099187f, 0.00825353f, -0.00068189f, 0.01984150f, 
    -0.04594368f, -0.03076216f, 0.03090144f, 0.03583971f, -0.01215847f, -0.03393096f, -0.02124050f, -0.02175452f, 
    0.01860078f, -0.02970313f, 0.02303300f, -0.03355826f, -0.05032516f, -0.00263920f, -0.04289515f, 0.02681277f, 
    -0.05666727f, -0.00205896f, 0.03950904f, -0.00597401f, 0.00478064f, -0.01947083f, 0.02713018f, 0.03817531f, 
    0.01171426f, 0.02190198f, 0.04173853f, -0.01269300f, -0.03463851f, 0.00077541f, 0.01024432f, 0.00538537f, 
    -0.02710550f, -0.02893465f, 0.02904991f, 0.03148590f, -0.03310134f, -0.04509861f, -0.00890632f, -0.05762319f, 
    -0.30449206f, -0.01071778f, -0.32294264f, -0.18350847f, -0.33830228f, -0.03809324f, 0.06637004f, 0.10001085f, 
    0.05240523f, 0.20697598f, 0.03587865f, -0.03460446f, 0.00635845f, -0.13480160f, -0.18952376f, -0.11298379f, 
    0.06897267f, 0.05597024f, -0.06256042f, -0.10656108f, 0.03341731f, -0.25142020f, -0.47055963f, -0.08639902f, 
    0.02306052f, -0.00442911f, 0.02987512f, 0.02194325f, 0.00582193f, -0.00864106f, -0.09101448f, -0.00572627f, 
    0.07708494f, -0.06535595f, -0.00358588f, -0.06301733f, -0.02455343f, 0.17351654f, -0.05549159f, 0.04449283f, 
    0.45063740f, -0.59550649f, 0.09416248f, -0.01664705f, 0.18005146f, 0.12696898f, 0.07107338f, 0.09330241f, 
    -0.07820502f, 0.08121151f, 0.14363004f, 0.16395694f, -0.09404485f, -0.00959666f, 0.14815201f, 0.03857932f, 
    0.02954569f, 0.23615253f, -0.04715171f, 0.03332864f, -0.32908311f, 0.07091905f, -0.06924437f, 0.02614767f, 
    0.24115068f, -0.07668091f, -0.02835025f, -0.02404619f, -0.04649529f, -0.05385594f, -0.00348055f, 0.05898723f, 
    0.16740434f, 0.09239966f, 0.13400242f, -0.06007134f, 0.00846235f, 0.19079395f, -0.06850814f, -0.01546963f, 
    -0.05391644f, 0.61568171f, -0.16112345f, -0.05689420f, -0.19549133f, -0.04698476f, -0.06659133f, 0.25876033f, 
    0.03194328f, 0.10215185f, -0.02001563f, -0.02240828f, -0.11949736f, 0.24092829f, 0.16930065f, -0.10096812f, 
    0.06926449f, 0.01945221f, 0.01114632f, -0.14804724f, 0.15817313f, 0.13472840f, 0.10495595f, -0.08928394f, 
    0.09724053f, 0.21392286f, 0.06255092f, 0.09258107f, -0.00819594f, 0.00205617f, 0.00873309f, -0.00422632f, 
    0.12064680f, -0.02510984f, 0.05928814f, 0.11029804f, 0.18606441f, -0.01733747f, -0.00533580f, -0.04702671f, 
    0.39738631f, 0.19876289f, 0.45576814f, -0.11647240f, 0.13244709f, -0.06072802f, -0.09062101f, -0.08138361f, 
    0.00421255f, -0.10701601f, 0.12525816f, -0.06449031f, -0.03448462f, 0.01159645f, 0.23599871f, 0.05688522f, 
    0.05215647f, 0.11834065f, 0.14562681f, -0.07056087f, 0.37807137f, 0.10412119f, 0.16315363f, -0.00437977f, 
    -0.03432287f, 0.09343059f, 0.14238472f, 0.10592858f, -0.03844735f, -0.04473990f, -0.14876200f, 0.08736806f, 
    0.04980811f, -0.10539254f, 0.01161498f, -0.04885479f, 0.16077921f, 0.19079635f, 0.06976395f, -0.00718939f, 
    0.56873584f, 0.16418032f, 0.24119906f, -0.12160847f, -0.03272393f, -0.10624571f, -0.02132046f, -0.02907857f, 
    0.01277717f, 0.07658372f, 0.00382499f, 0.15039700f, -0.13993990f, -0.07325057f, 0.04603130f, -0.21566568f, 
    0.03642943f, 0.10804764f, 0.01572949f, -0.00757206f, 0.64052653f, 0.32054493f, 0.49848598f, -0.24520707f, 
    -0.00134919f, 0.09981020f, -0.07125869f, 0.16855715f, -0.18877900f, 0.00537744f, 0.00823184f, -0.16768116f, 
    -0.03459889f, 0.14763533f, 0.15168145f, -0.04586138f, -0.03764734f, 0.13196899f, 0.18397598f, 0.13311714f, 
    0.32516322f, 0.01236998f, -0.14337321f, -0.16111097f, 0.19890757f, -0.00303544f, -0.01334989f, 0.07332224f, 
    0.04012908f, 0.07212057f, 0.03290714f, 0.04205636f, 0.01195410f, -0.05954447f, 0.06909459f, -0.02266143f, 
    0.03322589f, 0.03692570f, 0.15506472f, -0.08748686f, 0.46857479f, 0.25177464f, 0.39473444f, -0.32143825f, 
    -0.06745514f, 0.07955442f, -0.11169057f, 0.09640443f, 0.01590895f, 0.02789169f, 0.13019453f, -0.01987023f, 
    -0.01311111f, -0.03513025f, 0.18764213f, 0.02998722f, 0.09033822f, 0.03140990f, 0.07745648f, -0.29618007f, 
    -0.36011735f, 0.05211060f, 0.15559146f, -0.17027365f, -0.29982859f, -0.07017611f, -0.12611808f, 0.01644630f, 
    -0.05990749f, -0.01728956f, 0.32803234f, -0.02630708f, -0.01989150f, -0.21550693f, -0.00048862f, -0.13151549f, 
    0.11893318f, -0.09131082f, 0.03706576f, -0.10778808f, 0.57282537f, -0.28149363f, 0.00632770f, -0.11076803f, 
    -0.02851954f, 0.18081754f, -0.18958446f, -0.02045832f, 0.17912176f, -0.00835795f, 0.13220081f, 0.00264244f, 
    0.10834321f, -0.07930972f, -0.05587384f, 0.04963246f, 0.02849689f, -0.12877195f, 0.13129069f, 0.04532791f, 
    -0.08873238f, 0.02075486f, 0.02761974f, 0.09232964f, -0.05059726f, 0.21658352f, 0.13891982f, 0.00043531f, 
    0.13915072f, 0.03293887f, 0.10341223f, 0.01684438f, 0.01940474f, 0.19258769f, -0.02403162f, 0.16016525f, 
    0.08437307f, -0.10495793f, -0.12840779f, 0.08927374f, -0.02673434f, 0.00618636f, -0.36519137f, -0.32209972f, 
    -0.42381793f, -0.07515565f, 0.02885417f, 0.21021934f, -0.05192720f, 0.13558522f, 0.00845600f, -0.29038718f, 
    -0.04412382f, -0.01130848f, 0.00573410f, -0.04987217f, 0.01178830f, -0.07927980f, -0.05848180f, -0.06852806f, 
    -0.05680266f, 0.11322175f, 0.43323314f, 0.23511133f, 0.44505534f, -0.03575386f, -0.10511493f, -0.03961559f, 
    -0.08486352f, -0.01918257f, 0.00144986f, 0.07350507f, 0.07105350f, 0.09660906f, 0.16221456f, -0.03206300f, 
    -0.18577527f, -0.07706791f, 0.00865715f, -0.10030991f, -0.06563194f, 0.39610067f, 0.66418111f, 0.07182158f, 
    0.31635761f, -0.03104647f, 0.24335735f, -0.06268784f, 0.01835685f, -0.02555851f, 0.03927672f, -0.00404792f, 
    0.27978274f, 0.33599964f, 0.23802885f, 0.07170534f, 0.19742820f, 0.09927835f, 0.03839692f, 0.06857749f, 
    -0.61401147f, 0.48288924f, 0.01075007f, 0.15285531f, -0.12487327f, 0.11351598f, 0.06232637f, 0.22160386f, 
    -0.45586717f, -0.27434769f, -0.04933099f, 0.10185000f, -0.06308348f, 0.18003257f, -0.06237945f, 0.22623844f, 
    0.02149354f, 0.22368261f, -0.12357630f, -0.18849863f, 0.14436030f, 0.05435615f, 0.17708516f, -0.25392321f, 
    -0.20518184f, 0.14964588f, 0.00317736f, 0.05011299f, -0.01473916f, -0.04384465f, 0.05740622f, 0.06145108f, 
    0.22097877f, 0.01369059f, 0.05991984f, 0.14208394f, -0.00443215f, -0.17640328f, 0.10128187f, 0.09584321f, 
    -0.03085340f, -0.14096755f, -0.27716070f, 0.02715510f, 0.23212601f, 0.04390927f, 0.07707027f, -0.03522825f, 
    -0.14810976f, 0.23613907f, -0.11825423f, -0.06118922f, 0.01289482f, -0.11724376f, 0.07242385f, 0.22773722f, 
    0.20979047f, 0.03374584f, 0.15405115f, 0.01399265f, 0.37281492f, 0.15055999f, -0.29764882f, -0.10107683f, 
    -0.30776745f, -0.06987291f, -0.06956948f, -0.21151255f, -0.04778118f, -0.08182086f, 0.17944789f, 0.10933175f, 
    -0.03447363f, -0.23843506f, -0.18594068f, -0.00661920f, -0.11198308f, 0.02765238f, 0.01438784f, -0.06698046f, 
    -0.19956553f, -0.28437725f, -0.21381895f, 0.18912792f, 0.09159499f, -0.09110265f, 0.04359122f, -0.13670033f, 
    0.04029515f, -0.00895159f, 0.04153953f, -0.03659522f, -0.04801149f, -0.03219520f, 0.00650433f, -0.08794747f, 
    0.04997538f, 0.11687063f, 0.01838048f, 0.13386096f, -0.20045602f, -0.39283752f, 0.11405063f, 0.39223614f, 
    0.08670000f, 0.07531583f, 0.13301913f, 0.16165559f, -0.07348299f, 0.14170450f, -0.00941379f, -0.07644358f, 
    -0.05915954f, 0.07742570f, 0.06026540f, 0.00518477f, 0.09391268f, 0.03780611f, 0.06256613f, 0.09087066f, 
    -0.40581626f, -0.05230287f, -0.10188837f, 0.25716045f, 0.18439943f, 0.14832027f, 0.03856867f, 0.15382418f, 
    -0.26101404f, 0.01308744f, 0.06777753f, 0.04196289f, 0.01895443f, -0.17341256f, -0.19086124f, -0.00124724f, 
    -0.15553384f, 0.24515413f, -0.16419441f, -0.41550475f, -0.33824843f, -0.35111403f, -0.31015816f, 0.37634242f, 
    0.13825485f, -0.08741643f, 0.01253126f, 0.00993635f, 0.14591071f, 0.01234466f, -0.00109551f, 0.04296322f, 
    -0.04725767f, -0.14304800f, -0.03874942f, -0.07597715f, 0.08130503f, 0.28650984f, -0.10985937f, 0.04084617f, 
    -0.07114408f, -0.29628900f, 0.18473235f, 0.33823454f, 0.34044722f, -0.00843350f, 0.15000179f, -0.10907630f, 
    0.00103863f, -0.05105911f, -0.04027915f, -0.02946627f, 0.01412121f, -0.05324274f, 0.03051761f, -0.02047558f, 
    0.14532509f, 0.03843699f, 0.11371537f, 0.12988694f, -0.04339029f, -0.13793270f, -0.31902733f, 0.13497534f, 
    0.07011648f, -0.07600787f, -0.09672640f, -0.00508942f, -0.01133333f, 0.18435690f, -0.07168485f, -0.03343013f, 
    0.01834604f, 0.06060871f, 0.10078263f, -0.07793025f, 0.18695904f, 0.11866421f, 0.04938239f, 0.16603641f, 
    0.20588632f, -0.13661030f, -0.31052876f, 0.29933643f, 0.29581660f, 0.15482028f, -0.13318016f, -0.21424170f, 
    -0.19625135f, 0.00365989f, -0.06719808f, 0.02420137f, 0.04244985f, 0.08134616f, -0.11002199f, 0.02887277f, 
    -0.27059191f, 0.02788005f, -0.03435832f, 0.01704175f, 0.05363396f, 0.16925584f, -0.12367889f, 0.02675967f, 
    0.19411196f, -0.09617023f, 0.12740916f, 0.27786908f, -0.18325692f, -0.18191688f, 0.11751915f, 0.13214694f, 
    -0.02802243f, -0.06869706f, 0.03837942f, -0.06696131f, 0.04524224f, 0.07860613f, -0.10199006f, 0.10659648f, 
    0.06636056f, 0.29588142f, -0.54863000f, -0.31932995f, 0.00414756f, -0.03776867f, -0.13444743f, -0.06771668f, 
    -0.31037125f, -0.00362887f, 0.19056544f, 0.08534205f, 0.14407174f, -0.21094540f, 0.16423954f, 0.09136672f, 
    0.02977747f, -0.18596514f, -0.04434080f, -0.01292667f, -0.30379114f, 0.06953564f, 0.38344505f, 0.20586972f, 
    0.40054306f, 0.15170303f, -0.02867775f, -0.05417323f, 0.17861263f, -0.09966737f, -0.13285102f, -0.00093224f, 
    0.13444948f, 0.12538560f, 0.11019722f, -0.05848346f, 0.02244627f, 0.14490104f, -0.01534977f, -0.04323797f, 
    0.01020785f, 0.01784777f, -0.05760794f, -0.04420939f, -0.03435910f, 0.03732181f, 0.03083361f, 0.00601547f, 
    0.02802180f, 0.04159502f, -0.00121801f, -0.06267426f, 0.03938804f, 0.02388582f, -0.00657539f, 0.00001626f, 
    -0.01661542f, -0.02026270f, -0.00242960f, -0.04065190f, -0.01043694f, -0.04383813f, -0.00978717f, 0.04714136f, 
    0.00916265f, -0.03512150f, 0.03857368f, 0.03241767f, -0.02163836f, -0.06101845f, 0.03807996f, 0.04407923f, 
    -0.03119950f, -0.06134211f, 0.00910867f, 0.04778906f, 0.01567107f, -0.00002079f, -0.01024426f, -0.05440233f, 
    0.01257653f, -0.02918494f, -0.06260166f, -0.03875779f, -0.02901860f, -0.01054070f, -0.05101677f, -0.00128360f, 
    -0.03792061f, -0.01455960f, -0.02596608f, -0.04822752f, 0.00897859f, -0.05835703f, -0.05773338f, -0.04645581f, 
    -0.02020877f, 0.02975062f, -0.05669133f, -0.00746368f, -0.04883154f, -0.00370358f, -0.01511876f, 0.02978073f, 
    -0.00884840f, -0.01739900f, 0.02935889f, 0.01300153f, -0.00842011f, -0.04328006f, -0.00045780f, -0.04681807f, 
    0.02040773f, -0.04513165f, -0.02144395f, 0.04382404f, -0.00146718f, 0.01301803f, -0.06375241f, 0.01280483f, 
    -0.03455712f, -0.02864221f, 0.02584805f, -0.02847947f, 0.04211705f, 0.04654084f, -0.01710115f, -0.04900958f, 
    -0.01429841f, -0.01500859f, 0.02125126f, 0.03987600f, -0.03494407f, -0.00239544f, -0.03726570f, -0.04415571f, 
    -0.02473160f, -0.01754886f, -0.00653975f, -0.02979135f, 0.01938841f, 0.03861047f, -0.00509683f, -0.00331586f, 
    -0.03291763f, -0.06020361f, -0.00738314f, -0.05078794f, -0.03499797f, 0.04392496f, -0.02636170f, -0.02165001f, 
    0.01685937f, 0.01579282f, 0.03450820f, 0.00649734f, 0.00976794f, -0.03115156f, 0.02994142f, 0.00917416f, 
    0.02053859f, 0.03078981f, -0.00167165f, -0.04620137f, -0.05022594f, -0.04311349f, -0.05839225f, -0.01145119f, 
    -0.03386156f, 0.02544103f, -0.03152078f, 0.01250255f, 0.00142712f, -0.05517552f, 0.00246691f, -0.04080277f, 
    -0.01298949f, -0.01920408f, -0.05938084f, -0.03789297f, -0.03830273f, -0.04320799f, -0.05587460f, -0.05219913f, 
    -0.04942440f, 0.03235274f, -0.03133642f, -0.05397096f, 0.02562834f, -0.03751736f, -0.03154454f, -0.00605722f, 
    -0.03203967f, 0.04012807f, 0.00739649f, -0.00377197f, 0.00253725f, 0.04181239f, 0.03039306f, -0.00350842f, 
    0.02975705f, 0.01621480f, 0.01923356f, -0.04070443f, 0.04184569f, 0.01976270f, -0.00161612f, 0.00721412f, 
    -0.03863377f, -0.01575813f, 0.00152327f, -0.04422547f, 0.00349489f, -0.00620210f, 0.05530299f, -0.03845198f, 
    0.01673904f, 0.03050636f, -0.00627058f, 0.02623167f, -0.00707736f, -0.02044165f, 0.03694789f, -0.01680881f, 
    -0.04167210f, -0.03798225f, -0.01054450f, -0.00593201f, -0.00360117f, -0.01598750f, -0.06072009f, -0.02783068f, 
    -0.05141428f, -0.02579152f, 0.01535869f, 0.01639855f, -0.02571379f, 0.01723619f, -0.05813835f, 0.00554371f, 
    -0.03238273f, -0.01934680f, -0.02032695f, 0.00511560f, -0.02013158f, 0.00047742f, -0.00202332f, 0.00006789f, 
    0.00118397f, 0.03095596f, 0.03455024f, -0.02732030f, -0.02913529f, 0.00321556f, 0.00222256f, -0.00704629f, 
    -0.05854433f, -0.02092936f, -0.00503694f, -0.02191551f, 0.00890797f, -0.00356016f, -0.05701259f, 0.04124693f, 
    0.00050986f, 0.02144454f, 0.01617426f, -0.02076966f, 0.04484204f, 0.01864732f, -0.01120095f, -0.02935605f, 
    0.01100744f, -0.03583397f, -0.00387207f, -0.05692148f, 0.02866562f, -0.06171812f, 0.03943514f, 0.01686348f, 
    -0.01860945f, 0.03398823f, -0.00002400f, -0.01016896f, 0.02379674f, -0.04219202f, 0.01046565f, 0.04405690f, 
    -0.03863163f, 0.01459647f, -0.06472306f, -0.00899743f, -0.05906905f, -0.04832281f, -0.05989709f, 0.01748358f, 
    -0.04220914f, -0.02651428f, -0.02467623f, -0.06404988f, -0.01360842f, 0.02546934f, 0.04558132f, -0.01413884f, 
    0.00501605f, 0.00647053f, 0.02645971f, 0.01359949f, 0.02976543f, 0.00029047f, -0.03373599f, -0.00490342f, 
    0.02900587f, 0.01620758f, -0.03130570f, 0.00171403f, -0.02160551f, -0.05528092f, 0.03458283f, -0.04269209f, 
    0.01401791f, 0.03058070f, -0.00895567f, 0.04360252f, -0.00719036f, 0.03130907f, 0.00914305f, -0.00363963f, 
    0.02951878f, -0.01885163f, -0.06053984f, 0.00252233f, 0.03976714f, 0.02103753f, 0.01858047f, 0.03539375f, 
    0.02112242f, -0.05080073f, -0.04030120f, 0.00873427f, -0.02337472f, 0.01354684f, -0.02532282f, -0.02530842f, 
    -0.06381571f, -0.03083069f, 0.03020009f, 0.02912351f, -0.02850355f, 0.00447561f, 0.01560761f, -0.03768462f, 
    -0.05115712f, 0.03269667f, -0.00791554f, 0.04332209f, 0.01687725f, 0.01260391f, 0.00444164f, 0.02638903f, 
    0.23284252f, -0.09890069f, 0.11594486f, 0.12516259f, -0.11838532f, -0.01746557f, -0.08523472f, -0.00026078f, 
    0.07974119f, -0.05783311f, 0.08424442f, -0.06234333f, 0.08695392f, 0.14880651f, 0.02764304f, -0.05842122f, 
    -0.02850188f, -0.02533950f, 0.01901801f, -0.01804015f, 0.44152451f, -0.45206171f, 0.06643218f, -0.10784787f, 
    -0.59204727f, -0.07239477f, -0.05928963f, -0.17002258f, 0.17310570f, 0.07186813f, 0.09534305f, -0.07969272f, 
    -0.23078372f, 0.06937372f, -0.03111157f, 0.00476800f, 0.08837532f, -0.08853453f, 0.08120828f, 0.06192522f, 
    0.90828395f, -0.36210847f, 0.28234082f, -0.67352515f, -0.07616256f, 0.01444010f, 0.15294674f, 0.10380109f, 
    -0.10881341f, -0.07469887f, 0.03847162f, -0.01851264f, 0.15726832f, 0.09150990f, -0.05086412f, -0.04365893f, 
    0.19780941f, -0.02134418f, -0.07246716f, -0.06913844f, 0.61807430f, -0.00814066f, -0.07887779f, -0.02438102f, 
    0.07016207f, 0.00947682f, 0.01515481f, 0.04107064f, 0.00025547f, 0.11240456f, -0.09769312f, 0.35383102f, 
    -0.16227835f, -0.09149250f, 0.06502913f, -0.02503655f, 0.05549200f, -0.22822383f, 0.27674627f, 0.15014920f, 
    0.01259773f, -0.29821911f, 0.02914338f, 0.10080725f, -0.06546730f, 0.04054096f, 0.04894647f, -0.12837972f, 
    -0.04068746f, 0.10870364f, 0.04895493f, -0.05397325f, -0.08614995f, 0.02750283f, -0.37720650f, 0.07061120f, 
    0.12590924f, -0.26342925f, -0.11812349f, 0.13364084f, 0.00990314f, -0.06427091f, 0.03423826f, -0.15424559f, 
    0.15558766f, -0.10916623f, 0.17435537f, 0.15408091f, 0.02007023f, 0.03080239f, 0.20314167f, -0.06468567f, 
    -0.03723190f, 0.03815680f, 0.06003478f, -0.00776513f, -0.00619739f, 0.11448373f, 0.06259821f, -0.08633065f, 
    -0.06239744f, 0.30803812f, 0.30405769f, 0.15077069f, -0.18155874f, 0.11436762f, -0.01358410f, -0.02069114f, 
    0.05365226f, 0.24253553f, -0.09867556f, 0.04170379f, -0.00826538f, -0.06832352f, -0.06608022f, -0.01104322f, 
    0.04465061f, 0.06564749f, 0.07167447f, -0.03735644f, 0.16614555f, 0.25889331f, -0.33908749f, -0.21545132f, 
    -0.17616752f, -0.26196760f, -0.29082850f, -0.03202393f, 0.09126088f, 0.02872349f, 0.01779705f, -0.10489417f, 
    -0.00421136f, -0.04960585f, -0.07182451f, -0.00391310f, 0.00080767f, -0.29859096f, 0.00219277f, 0.04425299f, 
    -0.00638606f, -0.01935267f, 0.20089589f, -0.09403180f, -0.08200794f, 0.12418193f, 0.20812094f, 0.05738410f, 
    -0.07555596f, 0.00984803f, 0.27664733f, 0.16282786f, 0.19713587f, 0.07955790f, 0.03435172f, -0.02213323f, 
    -0.07543719f, -0.14001822f, -0.08463317f, 0.03562649f, 0.06417280f, 0.21890904f, 0.36513188f, 0.05580572f, 
    0.01160634f, -0.11331596f, -0.04416241f, 0.12878039f, 0.12238479f, 0.12905881f, -0.00254308f, -0.08784080f, 
    0.07602618f, 0.00084405f, -0.01807343f, 0.00233097f, -0.01390248f, -0.01771601f, 0.11167224f, -0.03676361f, 
    -0.07333469f, 0.28207836f, 0.05557248f, -0.13839160f, -0.45061439f, 0.16356979f, 0.01136671f, 0.06152144f, 
    0.05471303f, 0.26416063f, -0.07743505f, -0.09388854f, 0.11347682f, 0.06041855f, -0.02330562f, 0.02295632f, 
    0.03793157f, 0.16456096f, -0.00453356f, 0.16495797f, -0.27804214f, 0.08202566f, 0.22466451f, 0.36381763f, 
    -0.08845794f, 0.19086856f, -0.02164846f, 0.05327392f, -0.01801942f, 0.00443714f, 0.07101027f, -0.03381655f, 
    0.08191507f, -0.07360188f, 0.07798806f, -0.11050832f, 0.12346786f, 0.22504622f, 0.12236147f, 0.29104024f, 
    -0.17647895f, 0.12214499f, -0.11654807f, 0.30522695f, 0.13664830f, -0.01735092f, 0.10581623f, 0.29290801f, 
    0.04864445f, 0.02889787f, -0.08416387f, -0.09001587f, 0.22394319f, 0.05802879f, -0.09561452f, -0.09280012f, 
    -0.10110937f, 0.08006126f, -0.23081264f, -0.08404829f, -0.48218116f, 0.28299797f, 0.35667828f, -0.04613745f, 
    -0.18201706f, 0.02418380f, 0.23088723f, 0.21534467f, -0.20789623f, 0.22970088f, -0.08027931f, 0.07638519f, 
    0.16762058f, 0.12222633f, -0.13783921f, 0.05575651f, -0.14257368f, 0.12820673f, -0.05276149f, -0.17521533f, 
    -0.07557300f, 0.25490332f, -0.17388867f, 0.11526679f, 0.24360067f, 0.01822404f, -0.04378228f, 0.12412570f, 
    -0.05578201f, 0.04581757f, 0.03688714f, -0.02376468f, -0.07244543f, -0.11512145f, -0.03273274f, -0.23660965f, 
    -0.18538564f, 0.09725249f, 0.02532349f, 0.01936155f, 0.40421370f, -0.12113828f, 0.20289542f, 0.44652849f, 
    -0.16474229f, -0.13108487f, -0.07463282f, 0.09627437f, 0.13408525f, -0.01528389f, 0.17147221f, -0.19090445f, 
    -0.07821377f, 0.01561734f, -0.12435551f, 0.02591142f, -0.03909618f, 0.06605421f, 0.02348272f, -0.07918499f, 
    -0.02699998f, 0.00315426f, 0.00258377f, 0.03726488f, 0.01157286f, 0.00155038f, -0.01054453f, -0.03351284f, 
    0.02370650f, 0.04959910f, -0.02561610f, -0.01517102f, -0.00801147f, -0.02722828f, 0.04004128f, -0.00046948f, 
    0.03309261f, -0.00814447f, -0.06258246f, 0.04380462f, 0.04353068f, 0.01322385f, -0.05450790f, 0.00524442f, 
    -0.05984400f, -0.02840479f, -0.02533114f, -0.02297665f, 0.00185121f, 0.04671067f, -0.00238026f, 0.02142515f, 
    0.04154029f, -0.05020962f, 0.01843006f, -0.04021572f, -0.02113899f, 0.00040196f, -0.06191663f, -0.01789642f, 
    -0.05399191f, -0.03211781f, 0.04396802f, -0.01599951f, -0.05635274f, 0.03869524f, -0.01618664f, -0.05915397f, 
    0.02500200f, -0.01958267f, -0.01673316f, 0.03423293f, 0.02910524f, -0.02510801f, -0.04008785f, 0.04727085f, 
    0.02344801f, 0.02419347f, 0.03170226f, 0.02049026f, 0.03791403f, 0.04386704f, 0.03622095f, 0.04522206f, 
    0.02686894f, -0.05773006f, -0.04335179f, -0.01701537f, -0.06025400f, -0.04253890f, -0.06048325f, -0.06358392f, 
    0.00297082f, -0.04422127f, 0.01912458f, -0.02546723f, -0.04194279f, 0.02748608f, -0.03226853f, 0.00994807f, 
    0.01441252f, 0.02517693f, -0.05978137f, 0.02675830f, -0.02052542f, -0.06012742f, 0.00697704f, 0.01834975f, 
    -0.02940503f, 0.04276365f, -0.00660403f, -0.04014105f, 0.00629290f, -0.06368072f, 0.03177823f, -0.00153893f, 
    0.04361317f, -0.01159018f, -0.02555567f, -0.04392876f, 0.01302234f, -0.03315407f, -0.01511729f, 0.03479981f, 
    -0.04600261f, -0.05046619f, -0.00654535f, 0.00207130f, -0.00720928f, -0.05747106f, 0.01658488f, -0.03892653f, 
    -0.00273470f, -0.01190636f, -0.04311319f, 0.04855197f, 0.00905905f, 0.00961779f, 0.04879500f, -0.01380492f, 
    0.02839139f, 0.03895763f, -0.05501055f, 0.04645313f, -0.00427607f, -0.00067435f, 0.04932488f, 0.05313786f, 
    0.02874234f, 0.05299820f, 0.01167371f, -0.05498526f, -0.02098782f, -0.00710522f, -0.00397384f, 0.03641244f, 
    -0.05922636f, -0.03647947f, 0.01039642f, -0.04919803f, 0.02020827f, 0.04616056f, 0.00287351f, -0.00626092f, 
    -0.00595544f, -0.04858265f, 0.01043400f, -0.01234628f, -0.04506863f, -0.02881398f, -0.03243723f, -0.05206995f, 
    0.04335182f, 0.00116671f, 0.01289715f, -0.04137951f, -0.03180369f, 0.04458126f, -0.03532428f, -0.02616994f, 
    -0.01555139f, -0.06475420f, -0.04338226f, -0.04330994f, -0.04661749f, -0.02384638f, 0.01416110f, -0.05696933f, 
    -0.03226060f, 0.01792902f, 0.00588156f, -0.04076095f, -0.03252555f, -0.06093415f, 0.03059162f, -0.03002273f, 
    0.03833601f, 0.02795792f, -0.02615277f, -0.01934789f, -0.00202706f, 0.01781171f, -0.00778123f, -0.05597494f, 
    -0.02039939f, -0.04975791f, -0.04262716f, 0.03197026f, 0.03120472f, 0.03391996f, 0.04316951f, 0.00980736f, 
    -0.00224255f, -0.01542676f, -0.01291434f, 0.03640926f, 0.02401663f, -0.05279392f, -0.01680475f, 0.03593266f, 
    -0.03046534f, -0.05784326f, -0.03521751f, 0.01536567f, -0.01205002f, -0.03880404f, 0.00587658f, -0.03593615f, 
    0.04913807f, -0.00924135f, 0.03120153f, -0.05862088f, 0.03820262f, -0.05076884f, -0.00129535f, -0.02002516f, 
    -0.03811220f, 0.04489763f, 0.02647034f, 0.03222108f, -0.03694208f, 0.01062168f, 0.03872886f, 0.05046620f, 
    -0.03340932f, -0.02405272f, 0.00830274f, 0.02159334f, 0.01887497f, 0.01089783f, -0.00481309f, 0.03024110f, 
    0.00847124f, -0.00659643f, -0.05790759f, -0.05144557f, -0.03849336f, -0.00773956f, 0.00100828f, -0.00626338f, 
    0.03648404f, -0.00308442f, -0.02272462f, -0.04277720f, -0.02848328f, -0.00019512f, -0.03954892f, -0.03014763f, 
    -0.05736219f, -0.03364735f, -0.01885378f, 0.01772236f, -0.03666382f, -0.02776930f, -0.03438570f, -0.04093218f, 
    0.04508751f, 0.04082701f, -0.00154795f, -0.00840853f, -0.00815426f, 0.02106004f, -0.04392135f, 0.04588249f, 
    -0.03783645f, -0.01834452f, -0.05719753f, 0.00931382f, -0.03830805f, -0.02457996f, -0.04769320f, 0.03221373f, 
    -0.03606872f, -0.02045912f, 0.01638577f, -0.04188520f, 0.00863938f, -0.04678210f, -0.01463909f, -0.01365483f, 
    0.01500264f, 0.04066049f, 0.03735279f, -0.03934734f, -0.05191772f, 0.00820470f, -0.04076932f, -0.01564023f, 
    0.04456916f, -0.04368901f, -0.03745544f, 0.02814138f, 0.03693339f, -0.03788819f, -0.04114822f, -0.01932072f, 
    0.00944196f, 0.01164459f, 0.02481955f, -0.01146986f, -0.01644404f, 0.04734760f, 0.02007682f, -0.01871153f, 
    0.00036397f, 0.04466011f, -0.02919983f, -0.00266334f, -0.02693592f, 0.02725751f, 0.01605832f, -0.01579248f, 
    -0.01324511f, -0.04567887f, -0.03793796f, 0.04280660f, -0.02482289f, -0.01711880f, 0.01676296f, 0.03394487f, 
    0.34603721f, 0.02879636f, 0.01291988f, 0.15865128f, 0.02877978f, 0.10116280f, 0.10144578f, 0.01566956f, 
    -0.01199875f, -0.16373561f, -0.09719476f, 0.12964326f, 0.15942831f, 0.01809783f, 0.00202875f, -0.00606216f, 
    -0.02365197f, -0.09740601f, -0.04298592f, 0.00348747f, 0.72438139f, 0.23337919f, 0.06020396f, 0.25283509f, 
    -0.45480475f, -0.02176431f, -0.06090196f, 0.07411081f, 0.09501161f, -0.02952310f, -0.01784623f, -0.11980838f, 
    -0.07096842f, 0.15454166f, 0.10690812f, 0.06102861f, 0.06265902f, -0.10309148f, -0.00890521f, 0.08377152f, 
    -0.01848056f, 0.06322080f, -0.29940325f, -0.14017224f, -0.19280162f, -0.15668221f, 0.10800748f, -0.02066653f, 
    -0.08716911f, -0.15622601f, -0.17842220f, -0.05907657f, 0.01731784f, -0.05762929f, -0.00949005f, -0.24485190f, 
    0.00440932f, -0.11364387f, -0.01108800f, -0.22752734f, 0.50757933f, -0.44595096f, -0.43239743f, -0.03431926f, 
    -0.24989665f, 0.02720121f, 0.01175022f, 0.13416095f, 0.03635053f, -0.01761435f, -0.20589939f, 0.16347916f, 
    -0.15003212f, -0.10459783f, -0.08131626f, 0.04812137f, -0.01281031f, -0.19759855f, 0.09661239f, 0.03576008f, 
    0.60096514f, -0.05726024f, 0.37067077f, 0.15758492f, 0.16198984f, 0.06325962f, 0.16136853f, -0.15605219f, 
    -0.05721173f, 0.33023316f, 0.15965094f, 0.03285439f, 0.01631275f, -0.03669495f, -0.09350079f, 0.02780190f, 
    0.03028667f, -0.01659518f, -0.15332595f, 0.26345980f, -0.26148614f, -0.25997213f, -0.03037318f, -0.15478571f, 
    -0.10401738f, -0.22523287f, 0.22854488f, -0.04430005f, 0.04557196f, -0.25659773f, -0.00972438f, -0.10601893f, 
    -0.01723973f, 0.07297830f, -0.03040551f, -0.05758844f, 0.00354787f, -0.08549209f, 0.07856093f, -0.09663420f, 
    0.06423809f, 0.36583668f, 0.16674779f, 0.14735505f, 0.16898939f, 0.10642394f, -0.04734826f, 0.01427294f, 
    0.04667931f, 0.29058537f, -0.04784531f, 0.03155692f, 0.03617208f, -0.02325132f, -0.00030322f, 0.04475764f, 
    -0.00938531f, 0.00768616f, -0.13987513f, 0.02970902f, -0.06189940f, 0.08881446f, -0.26474771f, -0.24267645f, 
    0.00248120f, -0.09591446f, -0.23459780f, -0.07783993f, 0.01175508f, 0.06585618f, 0.04824867f, -0.06270433f, 
    0.04066107f, -0.03185024f, 0.02588234f, 0.12635693f, -0.09525193f, -0.23918229f, 0.12190928f, 0.05025998f, 
    -0.00224587f, 0.20710495f, 0.14623545f, 0.15181731f, 0.04669661f, 0.01759382f, 0.21400698f, 0.31318745f, 
    0.09320670f, 0.06569803f, 0.23300365f, 0.09866975f, 0.11063024f, 0.08966712f, 0.08231638f, -0.05628373f, 
    -0.14596786f, -0.14855522f, 0.08085014f, 0.02094415f, 0.01630584f, 0.43761429f, 0.10811947f, 0.25979450f, 
    0.32403797f, -0.32661721f, -0.22329232f, 0.02876073f, 0.25923645f, 0.28905913f, 0.01105532f, 0.03008522f, 
    0.08759704f, -0.06345418f, -0.02851570f, 0.06755586f, -0.07327028f, -0.00377210f, -0.08322012f, 0.10820205f, 
    -0.06908715f, 0.15765101f, 0.03842401f, -0.08660500f, -0.24232815f, -0.04047793f, -0.21282910f, 0.07136004f, 
    -0.16729556f, 0.14726092f, -0.07214937f, -0.01653150f, -0.00949105f, 0.02303648f, -0.00132785f, -0.07760710f, 
    -0.06901178f, 0.09037291f, -0.00492165f, 0.25465900f, 0.05674994f, 0.27498570f, 0.27955362f, 0.10319170f, 
    0.14175318f, 0.16849227f, -0.01295091f, 0.14311746f, 0.05646282f, -0.11763006f, 0.01667006f, -0.01938199f, 
    0.05076038f, -0.11467482f, -0.10712286f, -0.07271250f, 0.00467468f, 0.28046671f, 0.17216928f, 0.22310947f, 
    -0.22618683f, 0.18179189f, 0.01948322f, 0.09530965f, 0.31357774f, 0.04139605f, 0.13035268f, 0.32182059f, 
    0.10450897f, -0.07494160f, -0.08923998f, 0.21606776f, 0.11991700f, 0.01753081f, -0.10238142f, 0.04520172f, 
    -0.08038512f, 0.06528564f, -0.13162714f, -0.12611662f, -0.35367551f, 0.05697283f, 0.42747054f, 0.15165240f, 
    -0.13462532f, 0.04404195f, 0.07626753f, 0.12918493f, -0.24487202f, -0.21208848f, -0.19192825f, -0.00500330f, 
    -0.13713607f, 0.18796612f, -0.06051174f, 0.04154787f, -0.25086993f, -0.06757956f, -0.12455217f, -0.26445255f, 
    -0.23330191f, -0.39817044f, 0.01555201f, -0.16248673f, 0.07306007f, 0.06703437f, -0.12018483f, 0.03213986f, 
    -0.11284237f, -0.19917327f, 0.16097032f, 0.06135338f, -0.00369026f, -0.13318020f, -0.03154359f, 0.10819528f, 
    0.12450333f, 0.04367318f, 0.01152882f, -0.12271936f, 0.51090622f, 0.17257859f, 0.33029151f, 0.39624900f, 
    0.00379383f, 0.04536071f, -0.05061683f, 0.14474137f, 0.09569187f, -0.07580648f, -0.04860868f, 0.03817229f, 
    0.09001015f, -0.03028678f, -0.08256914f, 0.13103193f, -0.00663992f, -0.00160058f, -0.02251526f, -0.02677185f, 
    0.01839706f, -0.01499124f, -0.05530971f, -0.01259946f, -0.01042011f, 0.01884882f, 0.03018619f, -0.01730379f, 
    -0.03497650f, -0.04787011f, -0.03975360f, -0.01343465f, -0.02016333f, 0.03533215f, 0.03200105f, -0.05309051f, 
    0.00074350f, -0.01557092f, -0.01592586f, -0.03506384f, -0.05152025f, -0.00823923f, -0.05480583f, -0.05295645f, 
    0.01993928f, 0.00820745f, -0.02495415f, -0.01319969f, -0.02374892f, 0.00573631f, 0.00946871f, 0.01133128f, 
    0.01670084f, 0.01790004f, -0.05630653f, -0.03939769f, 0.03556962f, 0.02182621f, -0.00232449f, -0.03739845f, 
    0.02201711f, 0.04563317f, 0.01709279f, -0.03688946f, 0.02286737f, 0.04299094f, -0.02748414f, 0.04424547f, 
    -0.01449773f, -0.02398844f, -0.03355178f, -0.04148253f, 0.03697613f, 0.01216632f, -0.02130049f, -0.01733926f, 
    -0.00914484f, 0.03179220f, -0.04475481f, -0.04604806f, 0.01756472f, 0.05671337f, -0.02514226f, -0.05953697f, 
    -0.04386495f, 0.04345159f, 0.04913121f, -0.04412209f, -0.05667896f, -0.04859685f, -0.02452367f, 0.04664088f, 
    -0.00499170f, 0.02827464f, 0.04058823f, 0.04079450f, -0.06255507f, 0.02318604f, -0.05952562f, 0.01076553f, 
    -0.02523715f, 0.01659130f, -0.03110532f, -0.01352668f, 0.03757068f, 0.02600338f, 0.00366508f, 0.04540416f, 
    -0.01741249f, -0.03916598f, -0.06116798f, 0.03050829f, 0.01929647f, 0.04166383f, -0.04840424f, -0.01923499f, 
    0.04133140f, 0.00410641f, -0.04330117f, -0.00165152f, 0.02114583f, -0.02828458f, 0.00783199f, 0.03230708f, 
    0.03419067f, -0.01073709f, -0.02528797f, -0.03945727f, -0.03731072f, -0.04210206f, -0.05732475f, -0.02256188f, 
    -0.00414524f, 0.01343871f, 0.02349100f, 0.01633263f, 0.03543670f, -0.03994018f, -0.04161974f, -0.03742437f, 
    0.04678049f, -0.01550723f, -0.04977046f, -0.01279805f, -0.04569735f, 0.02347297f, -0.03404389f, 0.01660427f, 
    0.00353685f, 0.04815045f, -0.05696401f, 0.02031433f, -0.03782720f, -0.01532519f, 0.02217179f, -0.00236774f, 
    -0.01714782f, -0.04777040f, 0.00284252f, -0.04127834f, 0.01089008f, 0.04340184f, -0.04366583f, -0.05269312f, 
    -0.01423802f, 0.04627337f, -0.05192714f, -0.05832885f, -0.01780003f, 0.02487734f, -0.00024928f, 0.04613545f, 
    -0.05894203f, 0.01349861f, 0.00287462f, -0.05981636f, -0.05697500f, -0.04184304f, 0.02486473f, -0.02825764f, 
    0.00750489f, -0.01997001f, 0.02508747f, -0.01392168f, 0.01632604f, -0.01160799f, -0.00710018f, -0.01855662f, 
    0.04475037f, 0.04858302f, -0.04342974f, -0.05249341f, -0.03428925f, -0.03790323f, -0.03298315f, -0.04523359f, 
    -0.00266304f, -0.05886790f, -0.05137691f, -0.01312725f, 0.04788773f, -0.03372068f, 0.02896605f, 0.02061200f, 
    -0.00700648f, -0.03355633f, -0.03013241f, 0.01737243f, 0.01494468f, -0.04751900f, -0.02040416f, 0.04960623f, 
    0.03667967f, 0.01832038f, -0.04535918f, -0.03259860f, 0.04906299f, -0.04560658f, 0.00815097f, 0.00732181f, 
    0.00662659f, 0.04814679f, 0.04389006f, -0.00037050f, 0.00596278f, -0.02571672f, -0.02664205f, -0.04930556f, 
    0.02266135f, 0.04619764f, 0.01642281f, -0.04207110f, -0.00419563f, -0.05750836f, 0.02560090f, -0.01374025f, 
    0.04039649f, 0.03838574f, -0.03694183f, 0.03353618f, 0.00750364f, -0.01808284f, -0.05177934f, -0.01762514f, 
    -0.00987303f, -0.05310382f, -0.04551634f, 0.02854481f, -0.00632896f, -0.04928327f, -0.04024424f, 0.03104141f, 
    -0.00340019f, 0.02484298f, -0.01505682f, -0.03401272f, -0.05725583f, 0.00154930f, 0.04492908f, 0.02732842f, 
    0.03736956f, -0.05153288f, 0.04565988f, -0.02116525f, 0.03832611f, -0.03246518f, -0.04704313f, -0.05167944f, 
    0.03369156f, 0.02977283f, 0.01603384f, 0.02608540f, 0.04859069f, 0.01319141f, 0.02672521f, -0.04447590f, 
    -0.01208266f, -0.00311386f, -0.02588296f, 0.02806781f, -0.06261989f, -0.00104499f, -0.06316242f, -0.00582469f, 
    0.03290251f, 0.02573810f, 0.04272752f, -0.05744264f, -0.01609522f, -0.01575461f, -0.03537851f, 0.03500128f, 
    0.00578441f, 0.04816088f, -0.01770983f, -0.00981501f, 0.03485435f, 0.00663153f, -0.06170537f, 0.04253307f, 
    -0.03716825f, 0.02801604f, 0.00620416f, -0.03230413f, -0.00072156f, -0.03570860f, 0.00325277f, 0.04052779f, 
    -0.02956780f, -0.00055832f, -0.01459301f, -0.04834010f, -0.00976592f, 0.01767447f, 0.01644281f, -0.04423112f, 
    0.04765737f, -0.03435435f, 0.02934550f, 0.04046931f, -0.04862764f, -0.03132316f, -0.05664489f, 0.00761028f, 
    0.00205247f, -0.00069469f, -0.05780911f, 0.02013406f, -0.04022230f, -0.03802918f, -0.05203491f, 0.00667676f, 
    0.00810071f, -0.06085626f, -0.01643767f, 0.02160424f, -0.05928027f, 0.03367231f, -0.03633268f, 0.03515699f, 
    -0.10217278f, 0.35898462f, 0.41569990f, -0.05690132f, -0.12210190f, -0.01149755f, -0.11674340f, 0.02951588f, 
    0.19052935f, 0.11479122f, 0.05798620f, 0.11457438f, -0.04180840f, 0.13953885f, 0.02459678f, -0.15945452f, 
    0.12759602f, -0.12597242f, -0.10330869f, 0.02613189f, 0.35134599f, -0.03633926f, 0.31634420f, -0.24153379f, 
    -0.02785595f, 0.00874839f, -0.05466655f, -0.12321734f, -0.09255400f, -0.04375697f, 0.20994025f, -0.01850174f, 
    -0.11552376f, -0.08082267f, 0.07050636f, 0.06032985f, 0.06787455f, -0.09949637f, 0.05446327f, -0.12114469f, 
    0.84441304f, 0.03526119f, -0.08284258f, -0.55997419f, -0.02908089f, -0.00481641f, 0.20866945f, -0.24077998f, 
    -0.07596394f, 0.24480911f, 0.29228941f, -0.02118457f, 0.12248807f, -0.01630685f, 0.08252124f, 0.06697360f, 
    -0.11078250f, -0.04539854f, 0.02899314f, 0.24081549f, 0.31333318f, 0.01334558f, 0.31775850f, -0.24907710f, 
    0.06594002f, -0.25762412f, -0.23718202f, -0.20335990f, -0.23520680f, -0.12188058f, 0.21867353f, 0.03490282f, 
    -0.00258566f, 0.03905538f, -0.01139727f, 0.12832595f, 0.09654251f, 0.23988669f, 0.09751580f, 0.02701255f, 
    -0.17066249f, -0.06722966f, 0.24857138f, -0.04250964f, -0.08207951f, 0.08907804f, 0.01174633f, -0.01795078f, 
    0.22596793f, -0.17120525f, 0.08348750f, -0.04118375f, -0.12517160f, 0.03108457f, 0.02204164f, 0.08566258f, 
    0.01876116f, -0.02876391f, -0.07990719f, -0.02038711f, -0.34426239f, -0.05164488f, -0.52063668f, -0.27648470f, 
    0.27456483f, 0.11581134f, -0.02214265f, -0.05088970f, -0.10555247f, 0.30720532f, 0.01618261f, -0.11134510f, 
    0.04082447f, 0.19498226f, 0.05623206f, 0.10209447f, 0.10227593f, 0.05442712f, -0.10991306f, 0.08957606f, 
    -0.08617564f, 0.31605658f, 0.19221365f, 0.04671510f, -0.18754686f, 0.11630026f, 0.08179270f, 0.00670054f, 
    0.04045924f, 0.05960920f, -0.07032790f, 0.06966632f, -0.03694840f, -0.00312158f, 0.09375427f, -0.02585466f, 
    0.12010229f, 0.10723364f, 0.08381359f, 0.18468593f, -0.20488232f, 0.17525776f, -0.44833410f, -0.29160294f, 
    -0.06744314f, 0.20586066f, 0.18145758f, -0.04199231f, 0.15246943f, 0.02082211f, 0.02479884f, -0.00848358f, 
    0.03459013f, 0.03032288f, -0.12830044f, 0.01248258f, 0.11494406f, 0.07148229f, 0.10116811f, 0.15334494f, 
    0.25577441f, 0.41380465f, -0.05059110f, -0.43862420f, -0.12796852f, 0.05535577f, 0.11420518f, -0.06264272f, 
    0.01905724f, -0.00808750f, -0.00855959f, -0.04858188f, 0.08375902f, 0.09187254f, -0.07282468f, -0.12650341f, 
    -0.11204856f, -0.32226107f, -0.01501896f, 0.16396312f, 0.05878453f, 0.17874892f, 0.23943353f, -0.19717862f, 
    -0.07982491f, 0.13786921f, 0.14017072f, -0.05871167f, 0.01984352f, -0.00689905f, 0.01162499f, 0.01252071f, 
    -0.07006073f, 0.01635201f, -0.00087582f, -0.00249374f, 0.08343001f, -0.11304192f, 0.09423529f, 0.20196086f, 
    0.02813094f, 0.24340001f, -0.04375113f, -0.12667060f, -0.42646688f, 0.16621564f, 0.10245667f, -0.01573478f, 
    -0.05098316f, 0.06727512f, 0.12141707f, -0.01132061f, -0.05365547f, 0.03297477f, 0.04552419f, 0.10928051f, 
    0.09289000f, 0.05234062f, -0.05102919f, 0.07206316f, -0.26673809f, 0.10788466f, 0.13025261f, 0.29099125f, 
    0.00644330f, -0.02104601f, 0.05358048f, 0.02998531f, -0.09938564f, -0.04093619f, 0.04060146f, -0.01265005f, 
    -0.10799697f, -0.03643659f, 0.04627897f, 0.05462145f, 0.02965152f, 0.17925325f, 0.01414170f, 0.15829962f, 
    -0.08513362f, 0.23047613f, 0.22539757f, 0.10224897f, -0.14921638f, -0.28723297f, 0.05475694f, 0.08991282f, 
    0.07330099f, 0.12804627f, 0.02769435f, 0.04497586f, 0.07758173f, -0.02020556f, 0.15599537f, -0.02489330f, 
    0.05412233f, -0.06282602f, -0.23791413f, 0.11872017f, -0.25950563f, 0.39464137f, -0.06105402f, -0.07311687f, 
    -0.10342096f, 0.06273051f, 0.01254930f, 0.01589917f, -0.07517642f, 0.55789047f, 0.18198492f, -0.01801420f, 
    0.11596114f, 0.04228693f, -0.10834751f, 0.07752728f, -0.04345717f, -0.23240487f, 0.04354219f, -0.01672204f, 
    -0.22911187f, 0.00021854f, -0.35318127f, 0.10491535f, 0.17399412f, -0.14277235f, -0.24351083f, -0.04831191f, 
    -0.30799556f, 0.06849041f, -0.10435905f, -0.17726466f, -0.11518358f, -0.08791327f, -0.00294209f, 0.06261954f, 
    -0.01350336f, 0.05176923f, -0.05972559f, 0.11733091f, -0.02339066f, 0.17376308f, 0.34408867f, 0.16684559f, 
    0.08590662f, -0.16366038f, 0.06787670f, 0.11160567f, 0.07405173f, 0.12921132f, 0.29453844f, -0.00361858f, 
    -0.06977089f, -0.01621622f, -0.01605053f, 0.08947986f, 0.02748771f, 0.04783767f, 0.04542226f, 0.02565882f, 
    0.11360494f, -0.37935722f, -0.25974354f, -0.02251365f, -0.17505699f, -0.04082379f, 0.11211697f, 0.14773074f, 
    0.10870570f, 0.36824980f, 0.13121039f, 0.03482134f, 0.00438329f, 0.00709857f, -0.06373549f, -0.03966254f, 
    -0.02435135f, 0.02532897f, -0.06837244f, -0.05767248f, -0.20630784f, 0.03413152f, 0.09545100f, 0.16000976f, 
    0.20927271f, -0.00192927f, 0.12516043f, 0.26718214f, 0.16529031f, 0.19463061f, 0.02041056f, -0.18211107f, 
    0.10345830f, 0.17841427f, 0.13317518f, -0.06489807f, -0.13753074f, 0.03730123f, 0.10541486f, 0.08667261f, 
    0.66691375f, -0.10794996f, 0.21746646f, 0.50540972f, 0.21603006f, -0.04103288f, 0.32135278f, -0.14079715f, 
    0.40917796f, 0.35773209f, 0.21288244f, -0.06021222f, 0.14785831f, 0.11817361f, 0.14892174f, 0.28187034f, 
    0.07140242f, 0.22134267f, 0.45680076f, 0.19699048f, -0.02859487f, -0.03147136f, -0.07807686f, 0.12642381f, 
    -0.00734252f, -0.11392258f, -0.02340732f, -0.07032197f, -0.12676902f, -0.14069380f, -0.10641779f, -0.15392715f, 
    0.08654836f, 0.11816613f, 0.23492615f, 0.17636372f, -0.01328199f, 0.05091761f, 0.11554300f, -0.13962296f, 
    -0.40070769f, -0.02442677f, 0.03999953f, 0.40456307f, 0.11822661f, 0.07577232f, -0.14323270f, 0.16611309f, 
    0.16702327f, -0.16400103f, -0.08970330f, -0.04420750f, -0.06970114f, -0.12486997f, 0.25374132f, 0.11204744f, 
    0.13413534f, 0.03757510f, 0.30690503f, 0.12628861f, 0.34975392f, 0.28461796f, 0.20542395f, 0.16221544f, 
    -0.09490269f, 0.19342610f, -0.01871035f, -0.01601771f, 0.00723587f, -0.13770784f, -0.11824508f, -0.04795604f, 
    0.18209058f, 0.02401393f, -0.01242624f, 0.18694609f, -0.01635829f, 0.44373214f, 0.12074653f, 0.01298902f, 
    -0.12761264f, -0.09676728f, 0.09379533f, 0.33957031f, 0.13477394f, 0.06784604f, -0.04489173f, 0.15495303f, 
    0.00637138f, 0.00648873f, 0.05299765f, 0.05965002f, -0.04870160f, -0.04688194f, 0.08468267f, 0.04689455f, 
    0.11275643f, -0.04830002f, 0.04489020f, 0.00683951f, 0.38724831f, 0.08391829f, 0.50652760f, 0.32604793f, 
    -0.15948384f, 0.25728947f, -0.31323165f, -0.17751896f, -0.02828864f, -0.05119687f, -0.04671932f, -0.04081338f, 
    0.05486596f, -0.03260835f, -0.04432270f, 0.05568442f, 0.03159890f, 0.15368982f, -0.01359681f, -0.14955150f, 
    -0.19783039f, -0.46263057f, -0.02176779f, 0.38053417f, -0.00989484f, -0.05706436f, -0.20469618f, 0.13730681f, 
    0.18305713f, 0.13245733f, 0.05754765f, 0.16707672f, 0.07650199f, 0.02711768f, -0.07565065f, 0.00722401f, 
    0.10823884f, -0.02080475f, -0.18290684f, 0.03098121f, -0.16199939f, -0.36497724f, 0.17414878f, 0.40357894f, 
    -0.13045053f, 0.03737452f, -0.01443672f, 0.29157102f, 0.07677115f, -0.02296524f, -0.03749498f, 0.01553704f, 
    -0.05756777f, -0.10981505f, 0.07362895f, 0.05119205f, 0.10551071f, -0.00843061f, 0.02265605f, 0.14715360f, 
    0.24301268f, 0.03179812f, 0.24531892f, 0.08405136f, 0.26373896f, 0.14101715f, -0.16118321f, -0.14939447f, 
    0.12213731f, 0.05201231f, 0.10383641f, -0.01532418f, 0.04281868f, -0.06803089f, -0.01194913f, 0.27508524f, 
    -0.02322578f, -0.05263095f, 0.12350024f, -0.21389443f, -0.19830112f, -0.12198156f, -0.04959738f, 0.27849382f, 
    0.05710293f, 0.09976512f, -0.23103996f, -0.05287542f, 0.19539484f, 0.09338398f, 0.01166722f, 0.05683446f, 
    -0.05397630f, -0.12990387f, 0.09245612f, 0.36277232f, 0.18315345f, -0.04495624f, -0.10306566f, -0.09438517f, 
    0.36817911f, -0.42664525f, -0.37344792f, 0.13469553f, -0.22456974f, 0.20826904f, 0.02043104f, -0.02551494f, 
    -0.11068571f, 0.20298964f, 0.01689662f, 0.27506772f, 0.25226706f, -0.07606824f, -0.03185692f, -0.08947790f, 
    0.09626641f, 0.03507922f, -0.13505514f, -0.05104644f, 0.68721187f, -0.37601608f, 0.43908653f, 0.33733901f, 
    0.26374909f, 0.48701692f, 0.54059809f, 0.17717902f, -0.00684477f, 0.44795784f, 0.01660843f, 0.12869053f, 
    0.24087901f, 0.14287071f, 0.21960169f, 0.07626428f, 0.08106640f, 0.25043264f, 0.04225968f, 0.17382860f, 
    0.33840343f, 0.05555835f, 0.00618658f, 0.01625248f, -0.11725442f, 0.01323383f, 0.15447484f, -0.02633907f, 
    -0.00394007f, -0.23556824f, -0.21096180f, 0.18333673f, 0.27949104f, 0.02481117f, -0.02632014f, 0.07587080f, 
    0.21286321f, 0.11706784f, -0.04252873f, -0.03725415f, 0.11172962f, -0.41344064f, -0.59427679f, 0.15223058f, 
    -0.15650219f, 0.02522919f, 0.10163166f, 0.29635540f, 0.17228346f, 0.34538528f, 0.10673041f, 0.07063793f, 
    -0.04640489f, -0.06734864f, -0.08416775f, -0.15672731f, -0.04265701f, -0.08217571f, -0.07142304f, 0.07102413f, 
    -0.18979925f, -0.08855022f, -0.05871308f, 0.13185374f, -0.20552146f, 0.03838616f, -0.00180236f, -0.03563831f, 
    -0.00471422f, 0.08299344f, -0.07184588f, 0.07888267f, -0.12127492f, 0.03629167f, -0.09600484f, -0.12663420f, 
    -0.10524835f, -0.09176930f, -0.05275600f, -0.04700994f, -0.00800685f, -0.33776602f, -0.60095012f, -0.00324575f, 
    -0.41947460f, 0.05418326f, 0.16427502f, -0.11496960f, 0.17645882f, 0.01411433f, 0.00274956f, -0.01798766f, 
    0.04333016f, 0.08889136f, -0.09147472f, 0.06275443f, 0.07989340f, 0.15368134f, -0.00504020f, 0.11121583f, 
    0.13447823f, 0.17787631f, -0.01256133f, 0.26575232f, -0.28384981f, -0.02165542f, 0.13194284f, 0.25860080f, 
    0.21431386f, -0.14885807f, 0.01348747f, 0.17737667f, -0.01022496f, 0.21138796f, 0.00869302f, 0.09421583f, 
    0.11630604f, 0.26926062f, -0.03362416f, 0.01490814f, 0.35452923f, 0.11265521f, -0.00118893f, 0.16027756f, 
    0.26119441f, -0.02077283f, -0.03737512f, -0.03488022f, 0.03739058f, 0.02605064f, 0.09335662f, 0.05968978f, 
    0.11224980f, -0.01218098f, 0.02493646f, 0.26065633f, 0.05506203f, -0.08584739f, -0.16101852f, -0.00512881f, 
    -0.37255523f, -0.27924496f, -0.79269546f, -0.07439826f, -0.01186236f, -0.25148296f, 0.10421721f, -0.05452034f, 
    -0.20740487f, 0.02317954f, 0.02746153f, 0.14421882f, 0.11534131f, 0.18854658f, -0.02791155f, 0.14008436f, 
    0.01079835f, -0.12257995f, 0.15409032f, 0.11738101f, 0.45599616f, 0.17709529f, 0.24014579f, 0.08025877f, 
    0.10512356f, 0.07610431f, 0.11883225f, 0.11471078f, 0.05460652f, 0.01697793f, 0.01866100f, -0.11726367f, 
    0.02850080f, -0.20089006f, 0.00448447f, 0.13071980f, 0.06015075f, -0.07811179f, -0.19568406f, -0.02197969f, 
    0.13189542f, -0.18875192f, -0.19471784f, -0.31678149f, -0.02323325f, 0.01237173f, -0.11383005f, -0.09444752f, 
    -0.00338469f, 0.08045846f, -0.00480141f, 0.09296578f, 0.20426756f, 0.01878972f, -0.03159311f, 0.06027445f, 
    0.16078067f, 0.07386144f, 0.19557416f, -0.18290724f, 0.86615574f, 0.20384912f, -0.03113952f, 0.06275555f, 
    -0.02926617f, -0.09229020f, -0.08004421f, 0.10905983f, 0.00234814f, 0.18627900f, -0.09204686f, 0.00883604f, 
    -0.01620877f, -0.02334008f, -0.01215520f, -0.06031987f, 0.11201966f, -0.04776683f, 0.11449483f, 0.22883387f, 
    -0.26592293f, 0.02887399f, 0.20284021f, -0.08025090f, 0.04593471f, 0.07364848f, 0.00550975f, 0.01741662f, 
    0.09231425f, 0.01744239f, 0.11611256f, 0.09201201f, -0.13205533f, -0.07797726f, 0.04430968f, 0.02082568f, 
    -0.05601102f, 0.05781390f, -0.17580223f, -0.44957688f, -0.05645382f, 0.04193132f, -0.08278795f, -0.19767658f, 
    0.04563412f, 0.03990267f, -0.08696069f, -0.02514170f, -0.03348762f, 0.16358075f, -0.03588168f, 0.09064226f, 
    0.00006921f, 0.03914188f, -0.05784607f, 0.04134135f, 0.03835752f, 0.26429880f, 0.23270458f, -0.11293019f, 
    0.23878632f, -0.12740240f, -0.39343792f, 0.11369955f, -0.07624930f, -0.00334310f, -0.16861901f, -0.10885590f, 
    0.23744947f, -0.05826108f, -0.04163157f, 0.04012826f, -0.04006156f, 0.05167341f, -0.05248167f, 0.01410421f, 
    0.10755462f, 0.03592513f, 0.15922968f, 0.04208947f, 0.04572256f, -0.29117331f, -0.06391529f, -0.45116118f, 
    -0.02094334f, 0.10020213f, -0.09924543f, -0.08811424f, -0.10234065f, 0.10031318f, -0.07764408f, 0.07220282f, 
    0.15710364f, 0.05600361f, 0.13033462f, -0.04302728f, 0.04571803f, -0.21195297f, 0.22901355f, 0.15687051f, 
    -0.43828267f, -0.12777905f, -0.00304594f, 0.07532946f, 0.07440729f, 0.14279169f, -0.05813327f, 0.02107364f, 
    -0.11963519f, 0.09402830f, -0.08570687f, 0.05159336f, -0.05635370f, -0.09394152f, -0.00866921f, -0.25639334f, 
    -0.13082713f, -0.04026988f, -0.06101388f, -0.08213314f, 0.22372371f, -0.09511729f, 0.22225153f, -0.30087471f, 
    0.01536762f, 0.09478827f, 0.10918931f, 0.36909905f, 0.34248075f, -0.01299998f, -0.02685659f, 0.11933997f, 
    0.06146988f, -0.02547601f, -0.02562401f, 0.05512624f, 0.22459739f, 0.01717238f, 0.24896199f, 0.22460493f, 
    0.19310330f, 0.20895235f, 0.18053102f, -0.03487166f, 0.15469463f, 0.06885864f, 0.08188086f, 0.11727567f, 
    0.02294284f, 0.00573567f, 0.06865068f, 0.02915577f, 0.02458518f, 0.02055096f, 0.10109710f, -0.07967272f, 
    0.05697223f, -0.30723029f, -0.08151013f, -0.02243448f, -0.13308100f, -0.21817759f, -0.16789329f, -0.02595643f, 
    -0.68218696f, 0.01578300f, -0.05923215f, 0.01952682f, -0.20148931f, 0.10439094f, -0.06648458f, -0.04285514f, 
    0.03388123f, 0.00664672f, -0.12196921f, -0.13029549f, 0.02249413f, -0.02373819f, 0.08885629f, -0.05795205f, 
    0.19968520f, 0.12343723f, -0.13881260f, -0.04945815f, 0.52592379f, -0.12876944f, -0.00073309f, 0.09932185f, 
    0.09397461f, -0.01521148f, -0.02282575f, -0.04355422f, -0.05110059f, -0.18274920f, 0.00231582f, 0.05757349f, 
    -0.14568622f, 0.01550751f, 0.04452372f, -0.05471393f, -0.32572457f, 0.05378900f, -0.22011499f, 0.47750139f, 
    0.52242374f, 0.01441087f, 0.32237843f, 0.19408894f, -0.07943531f, 0.19304574f, 0.08860031f, -0.03793683f, 
    0.07479244f, 0.18418388f, -0.01926443f, 0.02413003f, 0.18885390f, -0.07108360f, 0.08936652f, 0.04475349f, 
    -0.70461261f, 0.25119534f, 0.03043334f, 0.42600060f, 0.28466213f, 0.03357962f, -0.07124020f, 0.30825889f, 
    0.34148908f, -0.21080394f, 0.02800939f, 0.06526992f, -0.02461785f, 0.06316622f, 0.10028328f, -0.09187674f, 
    -0.00328324f, -0.14524031f, -0.09449798f, -0.07135091f, -0.50403333f, 0.12273747f, 0.18253909f, 0.13133989f, 
    -0.55492961f, 0.20890228f, -0.03982354f, -0.04951636f, 0.11370019f, 0.36964047f, -0.01565426f, 0.04507985f, 
    0.01615831f, 0.04376451f, -0.05544296f, -0.15663944f, 0.01643938f, -0.04125087f, -0.09696183f, 0.09422143f, 
    0.56023866f, -0.04815876f, -0.12995420f, 0.06452917f, 0.26329288f, 0.01149922f, 0.12772913f, 0.08844486f, 
    -0.23193088f, 0.05821515f, -0.28518066f, 0.03266033f, -0.04081676f, 0.08507513f, 0.01374272f, -0.01599721f, 
    0.11709949f, 0.24246898f, -0.06456412f, 0.18819751f, -0.13785954f, -0.25520244f, 0.50992352f, 0.18287165f, 
    -0.34638372f, -0.25580916f, -0.13758995f, -0.00354808f, 0.04720504f, -0.04967428f, 0.00290188f, 0.04402982f, 
    -0.10725905f, -0.01500857f, 0.10631561f, -0.07633143f, -0.04854981f, -0.07900675f, 0.00353414f, -0.10076082f, 
    0.06134681f, -0.18046100f, -0.31531271f, -0.22146414f, 0.22286932f, -0.02628956f, 0.15316267f, -0.11662821f, 
    0.06360350f, -0.02279697f, 0.00796018f, -0.04717783f, 0.05296999f, 0.01084247f, 0.04245336f, -0.00023676f, 
    0.05817027f, -0.04172960f, 0.09230792f, 0.13314959f, -0.14931557f, 0.08201651f, 0.40604702f, 0.09534676f, 
    0.32339865f, 0.11077626f, -0.00052459f, 0.07920906f, -0.00987450f, 0.01831018f, 0.11867442f, -0.03174515f, 
    -0.18096174f, 0.01611169f, 0.09040663f, 0.13880737f, 0.11075713f, 0.02778180f, 0.10429129f, 0.18878105f, 
    -0.16301145f, 0.03341313f, -0.12579165f, 0.09728470f, 0.25931472f, 0.08305105f, 0.17593007f, -0.00013201f, 
    0.11241211f, 0.11558713f, 0.07651034f, 0.05420944f, -0.05622797f, -0.07749034f, -0.01140359f, -0.02728375f, 
    -0.14781676f, -0.13713789f, 0.10301165f, -0.00279917f, 0.00666655f, 0.10689852f, -0.28095463f, -0.02136561f, 
    0.29656661f, 0.00273282f, 0.21978351f, -0.23436397f, -0.03489515f, 0.02954667f, 0.09928022f, 0.01071302f, 
    -0.04383997f, -0.01277481f, -0.09104519f, 0.05339484f, -0.03676734f, -0.06001123f, 0.05118458f, 0.01789251f, 
    -0.32740614f, 0.00360274f, 0.19235675f, 0.28337571f, 0.22601976f, -0.05760443f, 0.18347837f, -0.06619857f, 
    0.12479421f, -0.06993780f, 0.04422322f, -0.13221508f, -0.03957196f, 0.06747389f, -0.06218472f, 0.11940337f, 
    0.03337706f, 0.11232605f, -0.02915314f, 0.20807172f, 0.17720057f, -0.13797638f, -0.31713533f, -0.38177001f, 
    0.21733837f, -0.09772310f, 0.25847027f, 0.04465804f, 0.02630029f, 0.14167030f, -0.12713248f, -0.13186651f, 
    -0.09962372f, 0.11708453f, -0.01512298f, 0.03739988f, 0.11299665f, 0.09549844f, 0.17598507f, 0.13408506f, 
    0.31931195f, 0.22828688f, 0.27429575f, -0.51180363f, 0.18941236f, -0.00279578f, 0.09205113f, 0.20546468f, 
    -0.09862795f, 0.11182328f, -0.02516956f, 0.08739639f, -0.10850978f, 0.00596098f, -0.18763043f, -0.06873772f, 
    -0.08464881f, -0.09536693f, 0.12949537f, 0.06908855f, -0.00834825f, 0.19882154f, -0.14938149f, -0.37158117f, 
    0.20014921f, -0.28177434f, 0.14750735f, 0.08730509f, 0.25975364f, -0.16952103f, 0.09842879f, -0.02378776f, 
    -0.02243550f, 0.04276567f, 0.11906187f, 0.03260014f, 0.06326681f, 0.02079928f, 0.06658994f, -0.17054838f, 
    0.22303577f, -0.03873770f, 0.30383632f, -0.60327452f, -0.38514620f, -0.29931748f, -0.01140121f, -0.01951874f, 
    0.01346618f, -0.13111228f, 0.04529531f, 0.01178392f, 0.09480613f, -0.00151375f, 0.12243242f, -0.12162253f, 
    -0.02286315f, -0.15003271f, 0.09145121f, -0.41472808f, 0.16680813f, 0.13620216f, -0.07626662f, -0.28817475f, 
    0.61358583f, 0.14019997f, 0.07291396f, 0.14852102f, 0.21518137f, 0.08581636f, -0.22682440f, 0.04414087f, 
    -0.15874264f, -0.11056966f, 0.04815876f, -0.07105207f, -0.04540191f, 0.02945235f, -0.04576369f, 0.02109519f, 
    0.01039694f, -0.01044071f, -0.00373418f, 0.01974237f, 0.01063198f, 0.03685984f, -0.00065106f, 0.00911164f, 
    0.03700441f, -0.06425797f, 0.04307139f, -0.03929829f, -0.05335927f, -0.06196508f, -0.05966174f, -0.00552349f, 
    0.01675932f, 0.02498514f, -0.02304612f, 0.01258188f, -0.03727950f, -0.01111539f, -0.05315357f, -0.03394942f, 
    -0.03798776f, 0.01665936f, -0.06443281f, -0.01945550f, 0.02319214f, -0.04935713f, 0.00337038f, -0.02462974f, 
    -0.01982568f, -0.04135247f, 0.01135107f, -0.00233478f, 0.01846562f, 0.06109036f, -0.05155352f, 0.02420265f, 
    -0.06311824f, -0.05267577f, -0.04418201f, 0.02091279f, 0.03834776f, -0.00892900f, 0.02991422f, -0.00154123f, 
    0.01373356f, -0.03309447f, -0.00799687f, 0.04102435f, -0.04893657f, -0.03347180f, -0.03966941f, 0.02231082f, 
    0.03207834f, -0.01079005f, -0.03325730f, 0.00057011f, 0.04144868f, -0.06197316f, 0.01489612f, 0.04151683f, 
    0.02592203f, -0.04749253f, 0.01104223f, 0.01338068f, 0.00422896f, -0.01938551f, -0.04308994f, -0.00265232f, 
    -0.02108206f, 0.02293610f, -0.02185873f, 0.00912765f, 0.04028583f, 0.02761739f, -0.06257290f, -0.03692821f, 
    -0.03124357f, 0.03939770f, 0.01436948f, 0.02853224f, 0.02966151f, 0.00468546f, 0.04985622f, 0.03259970f, 
    -0.05677832f, -0.02073305f, -0.04661918f, 0.01788890f, -0.00017765f, -0.02360662f, 0.04529814f, 0.01049015f, 
    -0.02144105f, -0.01527952f, -0.04509954f, 0.02384468f, 0.00020039f, -0.05217355f, -0.03733507f, -0.03404209f, 
    -0.00779127f, -0.05452644f, -0.02855212f, 0.00524285f, 0.03944209f, 0.01742626f, -0.01733157f, -0.05762191f, 
    -0.05068360f, -0.06220621f, -0.00890549f, -0.05587864f, 0.00457760f, -0.06128753f, -0.05151191f, -0.02571398f, 
    0.02905537f, -0.05112459f, -0.05308161f, 0.00472035f, -0.00260133f, 0.04334269f, -0.04228285f, 0.02402341f, 
    0.04003814f, -0.02252319f, 0.02881048f, -0.00470277f, 0.01395988f, -0.01805893f, -0.02088670f, 0.04423743f, 
    -0.01427138f, -0.01829994f, -0.05989507f, -0.00237844f, -0.05108537f, 0.03027583f, 0.03465078f, -0.04665808f, 
    -0.04077725f, -0.03547226f, -0.04862882f, -0.05268292f, 0.02601777f, 0.02826962f, 0.03575259f, 0.00191130f, 
    -0.03616947f, 0.01361430f, 0.00735613f, -0.05784095f, -0.02545204f, -0.02325820f, -0.06248937f, -0.00808348f, 
    0.04602331f, 0.01248196f, 0.00498598f, 0.00755221f, -0.04145814f, -0.01775433f, -0.05857431f, 0.00214109f, 
    0.03905632f, -0.05472807f, 0.05285079f, 0.05323755f, -0.01488010f, -0.02553815f, -0.05956348f, 0.04583123f, 
    0.04700680f, -0.00253860f, -0.00614044f, -0.03425348f, 0.03514713f, -0.03672777f, -0.05639337f, 0.00682395f, 
    0.03482167f, -0.02211801f, 0.03534367f, 0.03443015f, -0.06560785f, -0.02483959f, -0.00795112f, -0.00971033f, 
    0.03310857f, -0.01051173f, -0.00499983f, -0.03918814f, 0.01301213f, -0.02082422f, 0.01269050f, -0.01548646f, 
    -0.05770640f, 0.00814716f, -0.03791288f, 0.00713347f, 0.05112302f, 0.04734784f, 0.03793613f, -0.05885644f, 
    0.03418591f, -0.02151014f, -0.01555887f, 0.04922651f, -0.00400152f, -0.03652248f, 0.02537171f, -0.03399014f, 
    -0.04722095f, -0.01869964f, 0.04362994f, -0.05056940f, -0.03971409f, 0.01761167f, 0.02313639f, 0.04732196f, 
    -0.00398407f, 0.02203569f, 0.00198887f, -0.06001651f, -0.06094302f, 0.02837819f, -0.01270680f, -0.00428373f, 
    0.01498267f, -0.04946012f, -0.02811826f, -0.04332820f, 0.04767651f, 0.04690997f, -0.03126266f, 0.01114400f, 
    -0.05996534f, -0.06634693f, 0.03678092f, -0.03792090f, 0.05522468f, -0.03075131f, 0.04706242f, -0.04451357f, 
    -0.06117510f, -0.01310616f, 0.01046937f, -0.01456278f, 0.01078965f, -0.01376577f, -0.01670411f, 0.05285187f, 
    -0.01245352f, -0.00414058f, -0.01336835f, -0.01322634f, 0.00803583f, 0.00986097f, -0.04705587f, 0.00132301f, 
    0.03733756f, 0.01278489f, -0.05611384f, 0.02820148f, -0.02025535f, -0.05210230f, 0.03613674f, -0.02446398f, 
    0.00474870f, -0.01715257f, 0.00890724f, 0.01570576f, -0.03473771f, 0.00065496f, 0.05894497f, 0.01489249f, 
    -0.00592477f, -0.01890293f, -0.04481134f, -0.06640705f, -0.02975531f, 0.01779426f, -0.05038974f, 0.00704401f, 
    -0.00076177f, -0.00776482f, 0.02847313f, -0.00778101f, 0.05242445f, 0.03160118f, 0.01087114f, -0.00921152f, 
    -0.03391960f, -0.06294293f, 0.02445887f, 0.00584137f, 0.03912137f, -0.00730422f, -0.02610339f, -0.04236207f, 
    -0.02083473f, -0.03309667f, -0.02878585f, 0.02646641f, -0.05310744f, 0.01921683f, -0.06429061f, 0.02779128f, 
    -0.02806876f, -0.02789075f, 0.04632534f, -0.03947600f, 0.00202877f, 0.03860748f, -0.02595128f, 0.02660751f, 
    -0.01652388f, -0.02278399f, 0.01996780f, -0.03439401f, 0.03806381f, -0.05833623f, -0.05971008f, 0.00520011f, 
    -0.02578051f, -0.01050563f, 0.05355498f, -0.00595692f, -0.03739209f, 0.03530111f, 0.01533851f, 0.04303657f, 
    -0.03022129f, -0.02960731f, -0.04070120f, 0.03215316f, -0.01635870f, -0.01756427f, 0.02649423f, 0.01513164f, 
    -0.00538152f, 0.04079140f, 0.02295156f, -0.02685758f, 0.02487685f, 0.02024454f, 0.01961491f, 0.03123149f, 
    -0.06275973f, -0.06307625f, -0.01893800f, -0.03396640f, -0.00697797f, 0.03136134f, 0.00964234f, -0.05828901f, 
    -0.02390135f, -0.01848538f, -0.04657444f, 0.00680946f, -0.03452211f, -0.04079029f, 0.03420229f, -0.03436765f, 
    -0.02337905f, -0.00666902f, -0.00294098f, -0.00223130f, -0.02652840f, 0.02865226f, -0.02740334f, 0.02898158f, 
    0.01082692f, 0.02925316f, -0.05021140f, -0.00286732f, -0.03343273f, -0.03150949f, -0.05653346f, -0.02355214f, 
    0.01840927f, 0.00054702f, 0.01549056f, -0.02474520f, -0.01006340f, -0.01421416f, 0.03145434f, -0.00617016f, 
    -0.01875408f, -0.02463206f, -0.04877979f, -0.04546542f, -0.01457756f, 0.00893891f, -0.01259013f, -0.05729456f, 
    0.01901689f, 0.03939210f, 0.03776668f, 0.03184946f, 0.02578850f, -0.00579826f, -0.02733805f, -0.04922172f, 
    -0.01202677f, 0.01246004f, -0.04840671f, -0.05959231f, -0.04087060f, -0.05141462f, -0.03061590f, -0.01785920f, 
    0.04808673f, -0.03752957f, -0.02821030f, -0.00905529f, 0.03993594f, -0.04732732f, -0.02118314f, 0.01703303f, 
    0.04442353f, -0.06189219f, -0.00959246f, -0.04176258f, 0.03867938f, -0.03579592f, 0.01583127f, 0.03013905f, 
    -0.03208240f, 0.03255074f, -0.05066822f, -0.05907799f, -0.01373365f, -0.02281624f, 0.01339012f, -0.00763184f, 
    -0.04861946f, 0.00396690f, -0.04626268f, 0.04393428f, 0.00299711f, 0.00079219f, 0.01179711f, 0.05062577f, 
    0.04909941f, -0.04469694f, -0.03801018f, -0.03958434f, -0.02367481f, 0.01825160f, 0.01820860f, -0.00148464f, 
    -0.01154299f, 0.01283456f, 0.04862212f, -0.00729276f, -0.01992070f, -0.01189585f, 0.03705334f, 0.01885605f, 
    0.04310244f, -0.03382038f, -0.00788779f, 0.00935368f, 0.03749658f, 0.04195644f, -0.02138229f, 0.00749388f, 
    0.04654743f, -0.05271666f, -0.05782810f, 0.00190888f, -0.00119926f, 0.02211890f, 0.00332063f, -0.02760856f, 
    -0.04244374f, -0.02189479f, -0.01398866f, 0.00652101f, 0.01740930f, 0.03015698f, -0.04857521f, -0.02577233f, 
    -0.01175893f, 0.03078528f, 0.02824646f, 0.02592911f, -0.05995697f, 0.01259483f, -0.01404737f, 0.04817133f, 
    -0.00714357f, -0.02516910f, 0.02758362f, 0.01871589f, 0.02977297f, -0.04323830f, -0.03299789f, 0.02219839f, 
    -0.03431055f, 0.04527099f, -0.01852403f, -0.02391526f, 0.04555930f, 0.04617067f, 0.03596528f, -0.05697276f, 
    0.03019763f, -0.02039929f, 0.03264447f, 0.01519394f, -0.04180465f, -0.00528114f, 0.00423026f, -0.03502242f, 
    0.03081307f, 0.04275183f, -0.04647394f, -0.03282708f, -0.03098500f, -0.04756307f, 0.02657567f, 0.03897746f, 
    0.02097292f, -0.05271905f, 0.03254166f, 0.03066522f, -0.01865704f, 0.01669518f, -0.03594509f, -0.03890047f, 
    -0.01174708f, -0.02384536f, 0.00087008f, -0.04321971f, -0.00844539f, 0.04093069f, 0.03655322f, -0.03054723f, 
    -0.04506789f, 0.00465639f, 0.00917592f, -0.00910685f, -0.02492190f, 0.02941607f, -0.04078344f, -0.03476661f, 
    -0.01275938f, 0.01663041f, -0.03139767f, -0.01942131f, -0.01116749f, 0.02684327f, -0.00505954f, 0.03208220f, 
    -0.00009287f, 0.01048908f, -0.04775780f, 0.01642112f, -0.02140377f, 0.00127877f, 0.03646003f, 0.03249404f, 
    -0.05679527f, -0.05240936f, 0.01276328f, 0.05842361f, 0.02065961f, 0.02792231f, -0.06132615f, -0.03320174f, 
    -0.01977879f, 0.02685826f, 0.01890058f, -0.05192989f, -0.04291287f, -0.04101605f, 0.02050486f, 0.02635535f, 
    0.03006778f, -0.04798368f, -0.03323025f, -0.04512818f, 0.03571620f, 0.03211296f, -0.00411650f, -0.03011903f, 
    0.03075281f, -0.01461137f, -0.03742347f, 0.03554104f, -0.01003752f, -0.03227206f, -0.03199363f, -0.05603442f, 
    0.01880272f, -0.02142625f, -0.00723784f, 0.03887392f, 0.01419939f, 0.00268121f, 0.02044852f, 0.00659145f, 
    0.04212736f, -0.02440822f, -0.00963312f, 0.02015239f, -0.04591025f, -0.01081678f, -0.05730321f, -0.05476525f, 
    0.04177241f, 0.03561619f, 0.04386333f, 0.00372242f, 0.04243235f, 0.02367879f, -0.01301157f, -0.05748297f, 
    -0.04103553f, -0.04318406f, 0.01414784f, 0.04983047f, 0.00197715f, 0.03539396f, -0.03208452f, 0.03272745f, 
    0.00517136f, -0.03123717f, -0.06297638f, 0.01799317f, -0.01769454f, 0.03433708f, 0.04599510f, -0.01107042f, 
    -0.57397473f, 0.16625112f, 0.20690279f, -0.17515355f, -0.10578892f, -0.21008901f, -0.04655924f, 0.04928047f, 
    0.07719943f, 0.16151451f, -0.26982781f, 0.17004824f, -0.05694285f, -0.04374283f, -0.14142080f, -0.12674649f, 
    -0.08177762f, -0.03973683f, -0.10544787f, -0.02516795f, -0.15789153f, 0.31087455f, -0.39489055f, 0.06291559f, 
    0.17675836f, 0.14415534f, 0.24661125f, 0.05051304f, 0.07780810f, -0.06626666f, 0.15765800f, -0.08372171f, 
    0.12832814f, -0.12675446f, -0.03469475f, -0.01451079f, 0.06437458f, 0.23764525f, 0.03170767f, 0.08969324f, 
    0.38788861f, 0.60898024f, -0.52799100f, 0.09649979f, -0.38025534f, 0.13434705f, 0.16618399f, 0.30645558f, 
    0.02551312f, 0.09979791f, 0.10228330f, 0.15441298f, 0.05706592f, 0.04152114f, 0.17744575f, 0.12498110f, 
    -0.02507423f, 0.34471545f, 0.05088923f, 0.05592444f, 0.25898376f, 0.05610898f, 0.11581866f, 0.12994857f, 
    0.29017699f, -0.02165709f, 0.01935832f, -0.06748056f, 0.01402998f, -0.04100177f, -0.02044600f, 0.05980097f, 
    -0.02908071f, 0.00802500f, 0.08506805f, -0.04160086f, 0.05220315f, -0.01309914f, -0.02933086f, -0.06743117f, 
    -0.77509654f, -0.54930013f, -0.81028438f, 0.07928039f, 0.28238791f, -0.11493202f, -0.11240508f, 0.02705342f, 
    -0.04935706f, -0.11798704f, -0.01832198f, 0.00226710f, 0.13218391f, 0.12197190f, 0.00071357f, -0.04257669f, 
    -0.02337913f, -0.11620430f, 0.14309198f, -0.01819701f, 0.30246666f, 0.09192634f, -0.02692567f, 0.07487918f, 
    0.18443136f, 0.07800901f, -0.02964982f, 0.01911092f, 0.00315536f, 0.18910588f, 0.00526320f, -0.06068865f, 
    -0.04196011f, -0.02263523f, 0.05534979f, 0.10096034f, -0.01268128f, -0.14991772f, -0.06057224f, -0.01558431f, 
    -0.37896857f, -0.48154336f, -0.32962036f, -0.24138148f, 0.17104889f, 0.00663972f, -0.02677329f, -0.08459735f, 
    -0.02438311f, -0.21581015f, 0.04152449f, -0.02737269f, 0.09502609f, 0.00356080f, 0.00718797f, 0.08239975f, 
    0.04043891f, 0.11142689f, 0.04701184f, 0.17454913f, 0.19446740f, -0.14356731f, -0.13117202f, -0.19195995f, 
    0.20581882f, 0.12451739f, 0.20514618f, 0.08082280f, 0.04547408f, -0.20154525f, -0.04441573f, 0.00556279f, 
    -0.07067625f, -0.03222808f, 0.05514795f, -0.03591209f, -0.09347906f, -0.07824872f, 0.20451540f, 0.13908589f, 
    -0.14508201f, 0.14686953f, -0.19601913f, -0.22242512f, -0.11016178f, -0.06224542f, 0.14141349f, -0.03165375f, 
    -0.14421116f, -0.21774247f, 0.18120354f, -0.17670570f, -0.08223976f, -0.05927393f, -0.05212797f, -0.04160858f, 
    -0.16027905f, 0.00980200f, -0.01320003f, -0.36295268f, -0.56973976f, -0.20875581f, -0.34551638f, -0.53100431f, 
    0.36829492f, 0.18257570f, 0.15371172f, -0.22223668f, 0.00063439f, -0.34516677f, 0.01529486f, -0.01214712f, 
    -0.07978475f, 0.03377497f, 0.00831829f, 0.00762691f, -0.03761280f, 0.15763308f, 0.05341431f, 0.00656591f, 
    0.39450946f, -0.31973600f, -0.45244578f, 0.07674174f, -0.21118571f, 0.06542383f, 0.20787194f, 0.13165067f, 
    0.03262037f, -0.29534650f, -0.07815004f, 0.11708444f, -0.04676249f, 0.02413920f, 0.04813733f, -0.04709641f, 
    0.02725270f, 0.04832882f, 0.08985030f, 0.16213544f, -0.27417555f, -0.74123102f, -0.41717437f, -0.41344473f, 
    0.43143290f, -0.12697829f, -0.04581202f, 0.14575735f, -0.04933467f, -0.05192021f, -0.05922583f, -0.02154907f, 
    0.06594086f, -0.06087284f, 0.03291031f, -0.00235955f, 0.04159814f, -0.02661288f, 0.13497244f, -0.01518952f, 
    -0.56734347f, 0.00203339f, 0.18816049f, -0.04856582f, -0.06694900f, -0.22904317f, 0.03104786f, -0.00781873f, 
    -0.06509648f, 0.08831831f, 0.00328933f, 0.09620952f, -0.07009444f, 0.04908333f, -0.00354057f, -0.17100705f, 
    -0.00538705f, -0.00281431f, -0.05214758f, -0.03442217f, 0.58069652f, 0.27019587f, -0.12485646f, -0.20677285f, 
    0.05765770f, -0.17258550f, 0.13453490f, 0.31020376f, 0.47964233f, 0.34387925f, 0.36393082f, 0.21231321f, 
    0.12382721f, -0.21086451f, -0.24469367f, 0.01440645f, 0.39289615f, 0.03704765f, 0.40001464f, 0.13740508f, 
    0.05542428f, -0.04987903f, 0.19723763f, -0.03602457f, 0.24955694f, 0.07998682f, 0.03721705f, -0.09192243f, 
    0.04284265f, 0.09820360f, -0.01819366f, 0.03188530f, -0.02733815f, -0.04367560f, -0.02078789f, -0.13384366f, 
    -0.06223195f, -0.24152330f, 0.00357320f, -0.13859890f, -0.98082256f, 0.22035581f, 0.28173104f, -0.29940370f, 
    0.04147160f, -0.20377357f, -0.00795678f, 0.30953583f, -0.09406096f, 0.16747236f, -0.04043874f, 0.00242372f, 
    -0.05065533f, -0.11453983f, -0.14128743f, -0.06935237f, -0.01951261f, -0.03420990f, 0.09543660f, 0.05158958f, 
    0.03702987f, 0.00293316f, -0.01801444f, -0.03388283f, -0.04699271f, -0.05680492f, -0.05925604f, -0.00420918f, 
    0.03304270f, -0.03487375f, -0.05788383f, -0.02781726f, 0.00659742f, 0.04625617f, -0.00400982f, 0.04360841f, 
    -0.00816424f, -0.02796167f, 0.03903619f, -0.03890214f, 0.04170630f, -0.02598466f, -0.02400188f, -0.04443216f, 
    -0.00144683f, -0.03377920f, -0.00335288f, -0.00174171f, 0.02147567f, -0.02262734f, 0.00233909f, 0.04021470f, 
    -0.03697048f, -0.03755807f, 0.03323184f, -0.04376519f, -0.03611312f, 0.03579596f, 0.00347596f, -0.05199764f, 
    0.04553713f, -0.06036532f, 0.03668510f, 0.03533589f, 0.04520510f, -0.06022390f, 0.02047160f, 0.00978806f, 
    0.00023284f, -0.06364930f, 0.00513288f, 0.02924820f, -0.04965025f, -0.02772433f, 0.03686272f, -0.03147524f, 
    0.01876581f, 0.02340818f, 0.04399281f, 0.00217610f, -0.05420822f, 0.01495903f, -0.03746342f, -0.02584681f, 
    -0.01808072f, 0.01666463f, -0.00116619f, -0.05633562f, -0.05767750f, 0.04141827f, -0.01163284f, -0.04816745f, 
    -0.01903618f, 0.01568246f, -0.00107672f, 0.03180995f, -0.05683042f, -0.03644022f, -0.00868915f, 0.01301865f, 
    -0.06374677f, -0.03933926f, 0.03264403f, -0.03573591f, -0.03546208f, 0.01350977f, -0.01273477f, 0.04987575f, 
    -0.01826778f, -0.05476443f, -0.05362164f, -0.02981287f, -0.05100965f, -0.02611013f, -0.01768562f, 0.04156597f, 
    -0.01345201f, -0.00628826f, -0.06190426f, -0.05392203f, -0.03611303f, 0.04962743f, -0.01899012f, -0.00114020f, 
    0.02087159f, -0.00567264f, 0.02821491f, 0.00203842f, -0.05883857f, -0.05493281f, 0.02964269f, 0.02530081f, 
    0.02702026f, -0.05090397f, 0.01850042f, 0.01047700f, -0.02953645f, -0.00947753f, 0.05128440f, 0.02361681f, 
    -0.02097937f, -0.00669354f, -0.02732091f, 0.03744385f, 0.04610616f, -0.02528304f, -0.02693212f, -0.06119794f, 
    -0.06721665f, 0.00507953f, -0.02396104f, 0.03638378f, 0.01470329f, -0.03348930f, 0.04766861f, -0.05849603f, 
    -0.02018289f, -0.01807060f, -0.02569619f, -0.01517034f, -0.05546710f, 0.00501906f, 0.01983913f, -0.04014136f, 
    0.00321030f, 0.04310746f, -0.02743123f, -0.04348038f, -0.00587807f, -0.04632151f, -0.01792207f, 0.03834142f, 
    0.02034928f, 0.05160800f, 0.03153033f, 0.03510001f, -0.00218953f, -0.03604512f, 0.05135420f, -0.03003288f, 
    0.00270685f, -0.03492260f, -0.05407332f, 0.01134706f, -0.02737186f, -0.00931921f, 0.02310522f, 0.02341537f, 
    -0.02176376f, -0.05434552f, -0.00905709f, -0.05942233f, -0.02001807f, 0.01787879f, -0.00052726f, -0.04164878f, 
    0.00444382f, -0.04946703f, 0.02741760f, 0.02448636f, 0.02867269f, 0.02116590f, 0.01448210f, 0.00699174f, 
    0.00951648f, -0.02919957f, -0.03851414f, -0.05381549f, 0.00708077f, -0.06586539f, -0.02071651f, -0.04391697f, 
    0.05218046f, -0.02482287f, 0.03294600f, 0.00848648f, -0.02904805f, 0.02461415f, -0.04080218f, -0.05146433f, 
    -0.01661667f, -0.03340817f, 0.03969208f, -0.03469023f, 0.00191024f, -0.00929175f, 0.02486006f, 0.00822110f, 
    -0.02997144f, -0.03228286f, -0.01022330f, -0.04024887f, -0.05683891f, 0.01843499f, -0.02844285f, -0.00702859f, 
    -0.00820814f, 0.01474208f, -0.00892414f, 0.01531445f, 0.03590868f, 0.01577555f, -0.04729270f, -0.01653246f, 
    0.01079780f, 0.03050207f, -0.04509020f, -0.04756598f, -0.01458655f, -0.06183785f, -0.01656225f, 0.00577606f, 
    0.02728714f, -0.04394960f, 0.00747989f, 0.02501132f, -0.00808551f, 0.03362796f, -0.05889332f, -0.02154732f, 
    -0.03066950f, 0.01494728f, 0.01402323f, 0.04534927f, 0.04085870f, 0.03198593f, 0.03361812f, -0.03011061f, 
    -0.01306359f, -0.05651639f, -0.02432072f, -0.03831101f, -0.03934290f, -0.00560293f, 0.03530367f, 0.04228121f, 
    -0.04424874f, 0.02305797f, 0.00935446f, -0.01943707f, -0.03017305f, -0.05604646f, 0.00597944f, 0.03052604f, 
    0.02905974f, 0.00661347f, -0.01624780f, -0.00573154f, -0.05460750f, 0.02969961f, 0.00459529f, 0.02083539f, 
    0.00025009f, -0.00038190f, 0.04039131f, -0.04505508f, -0.02964553f, 0.03199256f, 0.00565156f, -0.05904411f, 
    0.05224849f, -0.04539412f, -0.02122831f, -0.03309155f, -0.02005422f, -0.03662850f, -0.03554840f, 0.04166983f, 
    -0.00100541f, -0.01713675f, -0.04328647f, 0.05272144f, -0.03776490f, 0.00821836f, -0.02073975f, -0.03739356f, 
    0.01023915f, 0.00547224f, -0.03216346f, 0.00888413f, 0.04204275f, -0.00707563f, 0.01166276f, 0.01632603f, 
    -0.04760890f, -0.03393886f, -0.00866013f, 0.04419952f, 0.01427446f, -0.04402998f, -0.00998970f, 0.03310181f, 
    -0.04053550f, 0.02566594f, 0.01687968f, -0.05390394f, -0.00223603f, 0.03700029f, 0.01809859f, -0.03691369f, 
    0.00066926f, 0.03949707f, -0.02488625f, -0.05093655f, 0.02077050f, -0.02506837f, -0.03131171f, -0.03762807f, 
    -0.01317597f, -0.01127464f, -0.04842766f, 0.04251932f, -0.02234586f, 0.01742536f, 0.00119169f, 0.04748132f, 
    0.04344343f, 0.02340622f, -0.05878802f, 0.02570335f, 0.01745861f, 0.02738744f, 0.04372530f, -0.03992474f, 
    0.00079428f, 0.04180114f, -0.02049793f, 0.01482164f, 0.03039623f, -0.01461626f, 0.02592267f, 0.01905815f, 
    -0.05260558f, -0.00018515f, -0.03380691f, -0.02855834f, 0.04633294f, -0.00046096f, 0.04312113f, 0.01558056f, 
    0.02027446f, -0.02823286f, -0.01347807f, 0.03628140f, -0.06311051f, 0.03070699f, -0.02001941f, 0.01384712f, 
    -0.02942240f, 0.03792514f, 0.01633231f, -0.02630915f, -0.04555871f, 0.03249283f, 0.00886081f, -0.04099720f, 
    -0.05918419f, -0.01209750f, -0.05851556f, 0.03012112f, -0.00424094f, 0.00921218f, 0.01416523f, -0.03459372f, 
    -0.02030816f, -0.05838579f, -0.04500791f, -0.01463187f, -0.02631258f, -0.02803656f, 0.02827881f, -0.00589988f, 
    0.00829243f, -0.04857570f, -0.03602323f, -0.03219854f, -0.01650579f, -0.00774008f, -0.06285977f, -0.02142336f, 
    0.02304093f, -0.01522285f, 0.01172076f, -0.05802758f, 0.00160750f, -0.06264564f, 0.00833367f, -0.05537476f, 
    0.03911661f, 0.04340577f, -0.03968553f, -0.05295507f, 0.04406698f, -0.00549560f, 0.01726926f, -0.04876597f, 
    -0.02170613f, -0.06355907f, 0.02973006f, -0.00700399f, 0.04109851f, -0.00476229f, 0.03714190f, 0.03559410f, 
    -0.01261871f, -0.04083289f, -0.00717456f, -0.03578158f, -0.02840521f, -0.05329335f, -0.05010065f, -0.06372985f, 
    -0.05563764f, -0.03674316f, -0.04900946f, 0.00592228f, -0.03587422f, -0.05697069f, 0.00413260f, 0.00040977f, 
    -0.05808645f, -0.02538947f, -0.00300138f, -0.00447771f, -0.04865550f, -0.01149473f, -0.04889264f, 0.00403960f, 
    -0.02415264f, 0.02807674f, 0.04216628f, -0.04122313f, -0.00881887f, 0.03302480f, 0.02686812f, 0.01610163f, 
    -0.03653314f, -0.04246850f, -0.05173096f, 0.01370699f, 0.02145679f, -0.00360196f, -0.00623269f, -0.03099623f, 
    0.00318417f, -0.05921544f, -0.01874156f, 0.00180111f, -0.05019642f, -0.01398643f, -0.04542772f, 0.01872922f, 
    -0.00649729f, 0.02174360f, -0.00125116f, -0.03043764f, -0.03964910f, -0.03719031f, -0.05157967f, 0.02054940f, 
    -0.03605717f, -0.04708682f, -0.02045835f, -0.04207838f, -0.01752246f, 0.00351456f, 0.00198638f, 0.01726410f, 
    -0.04265669f, -0.01098123f, 0.00973358f, -0.05243813f, 0.04220589f, -0.02233237f, 0.00989642f, -0.06075547f, 
    0.00759147f, 0.02625329f, -0.04362728f, 0.00327127f, 0.01840826f, -0.05756831f, 0.01907655f, 0.01368744f, 
    0.02633007f, -0.01731768f, 0.00638661f, -0.05192039f, -0.03357826f, -0.02309813f, 0.01976086f, -0.03147797f, 
    -0.03504826f, 0.04197401f, -0.03226721f, 0.02430567f, -0.01304677f, 0.03355205f, 0.03297994f, -0.01712851f, 
    -0.01173469f, -0.02830878f, 0.01499699f, -0.06363355f, 0.03268355f, 0.00855590f, -0.05285702f, -0.00155633f, 
    0.02007373f, 0.03396998f, 0.03400845f, -0.04514536f, -0.01438574f, -0.05802727f, 0.02007211f, -0.04526446f, 
    -0.02113651f, 0.01492380f, 0.01836177f, -0.02228846f, -0.05894388f, 0.03031489f, 0.01290747f, -0.05770537f, 
    -0.04735261f, 0.04452422f, 0.00120052f, -0.00899246f, 0.02161070f, -0.05107290f, -0.02621483f, 0.04580408f, 
    0.03129725f, 0.02741423f, -0.03014323f, 0.00421310f, -0.00283504f, 0.04663360f, -0.01446732f, -0.04869139f, 
    -0.03583216f, -0.02128786f, -0.04984409f, -0.02870963f, -0.00596343f, -0.01646743f, 0.02093240f, 0.03018415f, 
    -0.03077152f, 0.00439898f, -0.03609041f, -0.04442512f, -0.02009935f, 0.03590629f, 0.03445914f, 0.04460888f, 
    0.04118724f, -0.00937478f, 0.03765939f, -0.04267019f, -0.01183296f, 0.01057966f, 0.03527662f, -0.03419855f, 
    -0.04302071f, 0.04343573f, 0.03951407f, -0.04922581f, 0.02032901f, 0.01479364f, -0.02504055f, -0.03116898f, 
    0.03485793f, 0.02101582f, 0.04560956f, 0.01553056f, 0.01903654f, -0.01298583f, -0.03226702f, -0.03447639f, 
    -0.00684233f, 0.03331887f, 0.00192496f, 0.01380476f, 0.03344577f, -0.01069202f, 0.00440198f, 0.00307134f, 
    -0.04060959f, 0.04345876f, 0.02222627f, -0.03461526f, -0.03369525f, -0.05651716f, 0.02094964f, -0.03545374f, 
    0.02797859f, -0.04568287f, -0.02492980f, -0.04703927f, -0.05285776f, -0.03368248f, 0.02318625f, 0.01312090f, 
    -0.06487566f, 0.00237032f, 0.03102422f, 0.01424718f, -0.06483573f, 0.02014435f, -0.05858096f, -0.05020444f, 
    0.03014733f, 0.04256570f, -0.05810841f, 0.04197707f, 0.00569797f, -0.00620480f, 0.01230523f, -0.04978616f, 
    0.06375132f, -0.20514873f, -0.48189837f, -0.00584134f, 0.05531282f, 0.02504887f, 0.10879862f, 0.13865842f, 
    0.07864308f, 0.09194595f, 0.03840717f, -0.09594635f, -0.10703027f, -0.10854664f, -0.20340981f, -0.00265721f, 
    0.12212702f, 0.08189756f, 0.01974509f, 0.09415634f, -0.01340345f, 0.34184548f, -0.31601930f, 0.09881531f, 
    0.17462912f, 0.16532105f, 0.16514926f, -0.12873076f, -0.07155278f, -0.03386434f, -0.13917144f, -0.02486151f, 
    0.09622641f, -0.05302816f, 0.02884620f, -0.17714201f, -0.11851411f, -0.06518637f, -0.07816123f, 0.00231542f, 
    -0.36274037f, 0.04431535f, 0.02927659f, 0.54070657f, 0.32614392f, 0.17913996f, -0.05504973f, -0.07185420f, 
    0.57262403f, 0.04233533f, -0.11610920f, 0.21897380f, 0.08588292f, -0.06760122f, -0.13630249f, 0.03820415f, 
    0.20840456f, -0.19417256f, 0.22600195f, 0.06450310f, -0.26174793f, -0.03285458f, -0.19496213f, 0.10856315f, 
    -0.17308049f, 0.04972366f, 0.02070403f, -0.13945512f, 0.04321709f, -0.06530114f, 0.13888019f, -0.05729967f, 
    -0.00994909f, 0.09194851f, 0.06938753f, -0.15796554f, -0.00062748f, 0.20149976f, -0.03293417f, -0.14093594f, 
    0.00930237f, 0.58553571f, 0.31487328f, 0.08428986f, 0.09636523f, 0.17009942f, 0.11991423f, 0.37748986f, 
    0.10161609f, 0.05683302f, -0.11507981f, -0.04939994f, 0.07610320f, 0.15876757f, 0.17845869f, 0.01664285f, 
    0.04294059f, 0.16427413f, -0.08556484f, 0.04482402f, -0.11104469f, -0.19932854f, 0.17994010f, 0.20171882f, 
    -0.11653754f, 0.00058754f, -0.15653791f, -0.07628281f, 0.04170840f, -0.19657260f, -0.14203697f, 0.00461807f, 
    0.00988844f, 0.00831344f, 0.00318985f, 0.18732436f, -0.03993690f, 0.17045705f, -0.03998846f, 0.02404166f, 
    0.21101744f, 0.06227197f, 0.12311520f, -0.05782543f, 0.25762653f, 0.08326840f, 0.18485011f, 0.25880930f, 
    0.05244265f, 0.16882288f, -0.00057808f, -0.02892774f, -0.02348376f, 0.10396253f, 0.14717363f, 0.10497459f, 
    -0.04016272f, -0.07810842f, -0.05006140f, -0.01859879f, 0.14371809f, 0.14058092f, 0.63092840f, 0.26309046f, 
    0.15285233f, 0.01164857f, -0.01111634f, -0.00904029f, 0.25830624f, 0.05474696f, -0.05884044f, 0.09518032f, 
    -0.10789690f, -0.07449062f, -0.01953180f, 0.06114879f, 0.04477535f, 0.00724373f, -0.03710330f, -0.02220553f, 
    0.18357979f, -0.01715105f, 0.14270774f, 0.01965853f, -0.02564410f, 0.20891249f, -0.00556646f, 0.22059520f, 
    0.13311034f, 0.28357571f, -0.01001791f, 0.17466158f, -0.04229098f, -0.03157672f, -0.06078666f, 0.02422779f, 
    0.06692494f, -0.07233379f, 0.19642569f, 0.19586663f, 0.27771062f, 0.38646168f, 0.30337813f, 0.11151982f, 
    0.06978822f, 0.21081495f, 0.13343093f, 0.14604025f, -0.02782341f, 0.27600580f, -0.07113415f, 0.03147217f, 
    0.06605272f, 0.12396587f, 0.03976990f, 0.07505022f, 0.00115000f, -0.16635977f, -0.06916544f, -0.00040621f, 
    0.21168418f, 0.20837641f, 0.11641128f, 0.19526543f, 0.59357464f, 0.05375911f, 0.09096599f, 0.17226395f, 
    0.23789884f, 0.26224422f, 0.03956364f, 0.02986399f, 0.03075495f, -0.01568376f, -0.08190476f, -0.04783794f, 
    0.10123952f, -0.24077246f, 0.04550520f, -0.12397376f, 0.22383569f, 0.00944406f, 0.13251533f, -0.24239005f, 
    0.03527784f, -0.09805598f, 0.24287775f, 0.05915513f, 0.16543698f, 0.14127691f, -0.04319325f, 0.06731768f, 
    -0.02712398f, -0.00705059f, 0.06698024f, 0.16363969f, 0.19172525f, 0.00550767f, -0.17824662f, -0.13795158f, 
    0.12307850f, -0.03941778f, 0.14353360f, -0.22181740f, -0.18930948f, 0.27586448f, -0.00023331f, 0.11179348f, 
    0.13350210f, 0.04876302f, 0.21815738f, 0.09064610f, -0.17775162f, -0.11596071f, 0.02788438f, 0.05725013f, 
    0.15394104f, 0.07033981f, 0.03348636f, 0.10794281f, 0.38299829f, -0.60401213f, 0.30037865f, 0.06251951f, 
    0.05668987f, 0.30361745f, -0.03291663f, -0.31389290f, 0.18757826f, -0.12056105f, -0.10391539f, -0.00460961f, 
    -0.02600721f, 0.02640071f, 0.24552047f, 0.04573042f, 0.06711520f, 0.00008968f, -0.03232437f, 0.16951400f, 
    0.07732554f, -0.46759680f, 0.42487732f, -0.13296561f, -0.15202196f, 0.01399184f, -0.06377187f, -0.11353600f, 
    -0.01263248f, -0.07182882f, 0.07187696f, 0.02141570f, 0.30339059f, 0.02990070f, 0.12106784f, 0.23189881f, 
    0.09967011f, 0.10637029f, -0.03417615f, -0.11627410f, 0.10890165f, 0.15292498f, -0.54602027f, -0.18309513f, 
    0.15984705f, 0.24776737f, 0.11266088f, 0.12746441f, -0.05805752f, 0.03519045f, -0.13895629f, 0.01023072f, 
    -0.12107737f, -0.03084728f, -0.08479839f, -0.07200231f, -0.01316441f, 0.03969354f, -0.11383820f, -0.01452081f, 
    -0.06001895f, 0.02492276f, -0.05642455f, -0.00591501f, -0.02542102f, -0.01874677f, -0.03546682f, 0.02692308f, 
    -0.03509716f, -0.05343740f, 0.01755965f, 0.02535357f, -0.03247555f, -0.04799900f, -0.01512796f, -0.05105224f, 
    -0.01033573f, 0.02782734f, 0.04560358f, 0.01127197f, -0.04834004f, 0.04697515f, 0.01089066f, -0.03916189f, 
    -0.03604662f, -0.00942447f, -0.04970467f, -0.01168317f, 0.02145700f, 0.04906752f, 0.04214656f, -0.00969198f, 
    0.01452623f, 0.01379153f, -0.01992861f, 0.00928315f, -0.01308772f, -0.00730891f, -0.05131408f, 0.04215714f, 
    -0.02431755f, 0.04087490f, -0.02241022f, -0.04521161f, -0.03134865f, 0.02359512f, 0.02881183f, 0.01024333f, 
    0.00906739f, 0.02159004f, -0.04052125f, 0.00844059f, -0.01688633f, -0.00486479f, 0.01242783f, 0.00158229f, 
    0.00468134f, 0.01454057f, 0.03115171f, -0.04740692f, -0.05053727f, -0.04737174f, 0.00230188f, -0.02459285f, 
    0.01117529f, -0.03766776f, 0.01165808f, 0.00053014f, -0.01414816f, -0.00931024f, 0.01461046f, -0.01042456f, 
    0.00252589f, -0.02957459f, -0.03144061f, -0.02680257f, -0.03077313f, 0.00332498f, 0.03875585f, 0.02938020f, 
    -0.00334134f, 0.02618234f, -0.05453165f, -0.02831733f, 0.03415745f, -0.05458275f, -0.03787756f, 0.00886502f, 
    0.05259036f, -0.00730984f, 0.01598515f, -0.00736888f, -0.03370223f, 0.03260766f, -0.01938208f, 0.02658100f, 
    0.02244834f, 0.00058899f, -0.00971735f, 0.03975615f, -0.00760522f, -0.01098717f, -0.01310885f, 0.01122439f, 
    0.02957064f, -0.04114294f, -0.02678059f, 0.00719044f, 0.04762143f, -0.03578806f, -0.02013853f, 0.03722109f, 
    0.03287504f, -0.05524630f, 0.00148123f, -0.03107139f, 0.00933067f, -0.04831800f, -0.02155810f, -0.00554480f, 
    -0.01598721f, -0.02233912f, 0.03874606f, 0.04039734f, -0.00760024f, -0.02240506f, -0.03857315f, 0.01884989f, 
    -0.04540728f, -0.05123666f, 0.01287835f, -0.01027806f, -0.04594744f, 0.04178824f, 0.01487574f, -0.02333799f, 
    -0.04422149f, -0.05434493f, 0.01905304f, 0.03327046f, 0.04259262f, -0.03219030f, -0.02738078f, 0.01927728f, 
    -0.04853430f, 0.04011528f, 0.00655624f, -0.02337945f, -0.01474121f, -0.02075724f, 0.04730486f, -0.06010151f, 
    0.03800300f, -0.05083098f, -0.03969841f, 0.00414495f, -0.03202299f, -0.01987917f, -0.01769668f, -0.05001719f, 
    0.00200259f, -0.01846434f, 0.00929176f, 0.00680624f, -0.05781620f, 0.00447485f, -0.00848124f, 0.04105265f, 
    -0.01997165f, 0.04429483f, -0.05975359f, -0.00576300f, -0.05175357f, -0.05138297f, 0.00106063f, 0.04135656f, 
    0.03463133f, -0.01822764f, 0.02111239f, -0.00647674f, 0.02167334f, -0.02548707f, 0.03138445f, 0.03612619f, 
    0.00235472f, 0.03552464f, 0.02908236f, 0.02803321f, -0.04917281f, -0.02181049f, -0.03382115f, 0.01723709f, 
    0.02671459f, -0.04675289f, 0.00384181f, -0.03760355f, -0.00679469f, 0.02809162f, -0.04574877f, -0.00537660f, 
    -0.00865328f, -0.01260906f, -0.01118718f, -0.03858685f, -0.04728894f, 0.00145307f, -0.05571336f, -0.03164923f, 
    -0.05693300f, 0.00833855f, -0.01007843f, -0.04183009f, 0.04393271f, -0.03388479f, -0.05947036f, -0.01010204f, 
    -0.04681138f, -0.04816329f, 0.05016342f, 0.03990425f, -0.00693613f, 0.01072622f, -0.02376975f, 0.05011487f, 
    0.01720292f, -0.02275619f, 0.00855701f, 0.01017503f, 0.04239466f, 0.03840445f, -0.05093133f, -0.01166442f, 
    0.02967417f, -0.00592761f, 0.00342016f, 0.03598225f, 0.04261359f, 0.02964911f, -0.03044976f, -0.04119343f, 
    -0.01948689f, 0.01158518f, 0.00955949f, -0.03255971f, 0.04871845f, -0.02310995f, -0.00763146f, 0.01691325f, 
    0.00792319f, -0.04000326f, 0.04415424f, -0.04420311f, 0.00366130f, 0.03843720f, -0.02400905f, -0.01257724f, 
    0.00674855f, 0.02749027f, -0.00485644f, -0.01596192f, 0.03074049f, -0.03524585f, 0.02583796f, -0.04738443f, 
    0.00606200f, -0.05590151f, 0.02451389f, 0.00887054f, -0.05278888f, 0.04845915f, -0.05163629f, 0.04665468f, 
    -0.00687463f, 0.04131479f, -0.05013163f, 0.02757664f, -0.05209288f, -0.02131398f, 0.02518561f, 0.00008942f, 
    0.03743446f, 0.02525027f, 0.04530669f, -0.00103579f, 0.03335727f, 0.04866438f, -0.03372813f, -0.00837446f, 
    -0.05175118f, -0.00929369f, -0.00253348f, 0.03684903f, 0.04202566f, 0.02269077f, 0.00390163f, -0.04358033f, 
    0.03888219f, -0.03137564f, 0.04543409f, -0.05115885f, -0.02998017f, -0.02255913f, -0.05896786f, -0.02389517f, 
    -0.04935513f, -0.03920085f, -0.00719656f, -0.03060708f, 0.04653930f, -0.05597062f, -0.04599563f, 0.02321110f, 
    -0.02669853f, 0.00454584f, -0.02579174f, 0.01311610f, -0.04916291f, 0.02504517f, -0.03150669f, 0.01182801f, 
    -0.25486550f, 0.31717676f, 0.51531869f, 0.03359067f, -0.06514097f, -0.12831472f, -0.05079816f, -0.12601553f, 
    -0.01435837f, 0.10234839f, 0.25616744f, 0.20308958f, 0.08837301f, -0.08658984f, 0.00401600f, -0.06440970f, 
    0.03562489f, 0.02951262f, -0.00034243f, 0.04173407f, -0.58582640f, 0.08847146f, 0.40449071f, -0.10659562f, 
    0.37731603f, 0.07801817f, 0.05950497f, 0.03507637f, 0.05207753f, 0.04513403f, 0.03465690f, 0.24846807f, 
    0.07944691f, -0.01267953f, 0.05496302f, -0.15462542f, -0.12120967f, 0.06647286f, 0.03647445f, -0.09687608f, 
    0.11499713f, 0.21308479f, 0.36386567f, -0.16083109f, 0.21897689f, 0.24009268f, 0.06677736f, -0.03095316f, 
    0.37970293f, 0.29722115f, 0.23750924f, 0.03267194f, 0.10570672f, 0.02819479f, 0.12398221f, 0.10438392f, 
    -0.04158426f, 0.02730442f, 0.28412223f, 0.28197125f, -0.52256227f, 0.07208806f, 0.18150192f, -0.21086355f, 
    0.24136934f, -0.10249022f, -0.09877422f, -0.10648300f, -0.18236923f, -0.09836461f, 0.14906068f, -0.03702116f, 
    0.17614098f, 0.04629349f, 0.09236736f, 0.02162133f, 0.01624698f, 0.37022126f, 0.01134903f, 0.03265730f, 
    -0.78241432f, 0.01612365f, 0.25315040f, 0.13914186f, -0.02407055f, -0.08616436f, -0.22672613f, 0.16300729f, 
    0.22682491f, -0.42496967f, -0.07895996f, -0.08055656f, 0.18187279f, 0.00167124f, 0.06008746f, 0.03173882f, 
    0.01110683f, 0.23450921f, 0.04428642f, -0.27802747f, 0.09243082f, -0.07995879f, -0.28167105f, 0.08791431f, 
    0.16953696f, 0.18857610f, -0.19267212f, 0.12178521f, 0.12048638f, 0.27354386f, 0.01071909f, 0.13991116f, 
    0.03039827f, 0.12431428f, 0.02714566f, 0.18591234f, 0.00725649f, 0.08693856f, 0.02266658f, 0.27565187f, 
    -0.24517015f, -0.19187437f, -0.01991323f, 0.20150419f, -0.12625447f, -0.02343518f, -0.01630073f, 0.23945431f, 
    0.03939819f, -0.19834584f, -0.01669998f, 0.02570055f, -0.00240402f, 0.07182764f, -0.08634986f, 0.05426669f, 
    0.05811253f, -0.01309058f, 0.11433688f, 0.00490280f, 0.06165068f, -0.11451384f, -0.25531825f, 0.31103766f, 
    0.00490678f, 0.20242481f, 0.44574150f, 0.36648765f, 0.23783562f, 0.03667719f, -0.05893730f, 0.02347810f, 
    -0.05354844f, -0.06511866f, -0.02020535f, -0.04305359f, 0.00456920f, 0.18384174f, 0.02356574f, 0.12229457f, 
    0.02297741f, 0.08206078f, 0.18537743f, 0.02863138f, -0.06944017f, 0.03504013f, -0.03109660f, -0.30019909f, 
    -0.01038203f, 0.02075511f, -0.27799985f, -0.13125692f, -0.13197401f, -0.13409735f, -0.08459987f, -0.00644101f, 
    0.08014817f, -0.05501481f, 0.07616873f, 0.03071137f, -0.22461864f, -0.22716296f, 0.15506937f, 0.08817237f, 
    -0.19876812f, 0.12304728f, 0.13427734f, 0.11371317f, -0.19064887f, -0.26023349f, -0.07190835f, -0.01160879f, 
    -0.10682505f, 0.03927093f, -0.00371114f, -0.08914069f, 0.08321974f, -0.04535842f, 0.14776607f, -0.02050056f, 
    0.22133641f, 0.02137711f, -0.12146153f, 0.05377578f, 0.25939327f, 0.00859176f, 0.14996630f, 0.17628768f, 
    0.05307574f, -0.17228757f, 0.08136199f, 0.09193464f, 0.01418165f, 0.05805528f, -0.02223150f, 0.00308406f, 
    0.16332611f, -0.03104762f, -0.21344815f, -0.13948375f, -0.36432201f, -0.23067047f, -0.20339501f, 0.29871598f, 
    -0.12682599f, -0.21638393f, -0.11730745f, -0.13201916f, -0.00183354f, -0.02955532f, 0.00220603f, -0.02414482f, 
    -0.00525676f, 0.26269561f, 0.11128318f, 0.08174334f, 0.14388664f, -0.10100732f, -0.02624782f, -0.20067737f, 
    0.00017590f, -0.09776238f, 0.19657622f, 0.22934596f, -0.35133052f, -0.04323335f, -0.04507582f, -0.22072129f, 
    -0.04737468f, 0.03801461f, 0.10978746f, -0.02407075f, -0.02018859f, -0.01387593f, 0.08916675f, 0.03294009f, 
    0.06236199f, -0.06550299f, 0.15062353f, -0.05870748f, 0.13034363f, 0.01456245f, -0.05450374f, -0.07786108f, 
    0.29051170f, 0.09101770f, -0.02239209f, -0.13352469f, 0.23136798f, 0.25687343f, 0.28904498f, -0.01974729f, 
    0.19452810f, -0.02251817f, 0.09921315f, -0.00596662f, 0.21229278f, -0.04991668f, 0.16974300f, 0.21243985f, 
    -0.15755074f, -0.16796499f, -0.22654495f, 0.06899405f, -0.16705653f, -0.18462741f, 0.03042084f, -0.10090894f, 
    -0.00849170f, 0.08872505f, -0.03162153f, -0.10715394f, -0.01858325f, 0.11705056f, -0.04868620f, 0.04907252f, 
    -0.02527969f, 0.03799298f, 0.09716944f, 0.10605033f, -0.39865226f, 0.16791901f, 0.11481936f, 0.23430294f, 
    -0.06175071f, -0.09074797f, 0.09995168f, -0.08529558f, 0.07248411f, 0.31665307f, 0.10710918f, 0.17077489f, 
    0.05898410f, -0.05367378f, 0.02644256f, -0.05007084f, -0.00035289f, -0.13663253f, 0.15536465f, 0.12768538f, 
    -0.04245226f, 0.03053385f, 0.01049242f, 0.02369122f, 0.02328151f, 0.02635717f, -0.02679534f, -0.04491571f, 
    -0.05163236f, 0.03979251f, -0.00033118f, -0.03767113f, -0.03102226f, -0.04409410f, 0.01099710f, 0.01263325f, 
    -0.01879527f, -0.02479005f, 0.04437348f, -0.02837230f, -0.04605356f, -0.02095531f, -0.05164555f, -0.02487696f, 
    -0.03738653f, -0.03650871f, -0.01042549f, -0.04016721f, 0.02824995f, -0.00482482f, -0.04682021f, -0.04494157f, 
    -0.01695141f, -0.05353132f, 0.01438325f, 0.01673606f, -0.03166121f, 0.00888631f, -0.05132628f, 0.04244176f, 
    -0.01943732f, -0.00985499f, 0.00006375f, -0.04071378f, 0.01041042f, 0.01954424f, -0.01758524f, -0.04006522f, 
    -0.05979801f, -0.04689885f, -0.01247903f, -0.02186134f, 0.02379050f, 0.01363904f, -0.00591289f, -0.05388949f, 
    0.03266472f, 0.00452767f, -0.01691153f, 0.03218988f, -0.00048765f, 0.04200528f, 0.04275011f, 0.04323364f, 
    0.01017816f, -0.04530545f, -0.03000077f, -0.00464330f, 0.02438451f, 0.00443367f, -0.02742260f, 0.00040689f, 
    -0.05077419f, -0.00146430f, -0.04962732f, -0.05364074f, -0.00552833f, -0.02588498f, -0.03142593f, 0.02398829f, 
    -0.04848957f, -0.02801928f, -0.05247815f, -0.03712404f, -0.03725460f, 0.03971130f, -0.02826065f, 0.00035766f, 
    0.02789700f, -0.05314595f, -0.02663495f, -0.06113067f, 0.03863115f, -0.00299966f, 0.01245373f, 0.04240226f, 
    0.04181011f, 0.02600440f, 0.05026692f, 0.00497589f, -0.00406414f, -0.00488184f, 0.03825225f, -0.05686839f, 
    -0.04425097f, 0.00288966f, -0.01418451f, -0.03429712f, 0.01099283f, 0.04561079f, 0.03303288f, -0.03846376f, 
    0.01902034f, -0.03492983f, 0.01223016f, -0.04397435f, 0.01678750f, 0.02646935f, 0.03178164f, -0.00697726f, 
    0.04732976f, 0.02929474f, 0.00635963f, -0.00272498f, -0.03466624f, 0.02415578f, -0.02833722f, 0.00563707f, 
    -0.03565248f, 0.01932910f, 0.03011182f, 0.02245317f, -0.01804867f, 0.03333941f, -0.01371014f, 0.04211899f, 
    -0.00409120f, -0.05236438f, 0.01828551f, 0.04546002f, 0.04125119f, 0.00181931f, -0.04006578f, 0.01614817f, 
    -0.04462240f, 0.01324029f, -0.00202905f, -0.02809610f, 0.01316883f, 0.01721570f, 0.01687752f, -0.02835772f, 
    0.00565455f, -0.02029654f, -0.05104799f, -0.04923649f, -0.04826286f, -0.00737053f, 0.00646365f, -0.04776071f, 
    -0.04839913f, -0.05695543f, -0.04185464f, 0.04396348f, -0.02046494f, 0.00752693f, -0.00987192f, 0.00042016f, 
    0.02178250f, -0.01854895f, -0.03164308f, -0.05677945f, -0.03611897f, -0.00715534f, -0.05213837f, 0.03011572f, 
    -0.03395647f, 0.00850567f, 0.03734856f, -0.00718913f, -0.00495902f, 0.00844721f, 0.04863157f, -0.04716203f, 
    -0.02473420f, -0.01385191f, -0.00096679f, -0.05016527f, -0.00515943f, 0.04367287f, -0.00324187f, -0.02911128f, 
    0.03236472f, 0.03273071f, -0.02833601f, 0.02760720f, 0.02854811f, -0.00331527f, -0.00667623f, -0.03054628f, 
    -0.01656623f, 0.04994273f, -0.02426065f, -0.01775207f, 0.02605244f, 0.02202644f, -0.04275816f, 0.01382609f, 
    -0.03244510f, -0.01238870f, -0.04639455f, -0.05717129f, -0.04969713f, -0.01857830f, 0.00328307f, 0.00172450f, 
    -0.04379119f, -0.01070859f, 0.03318437f, -0.03996604f, -0.00071081f, 0.03713796f, 0.04438506f, 0.00193050f, 
    0.00830927f, 0.01005846f, 0.04758428f, 0.03124293f, 0.05338495f, 0.04620249f, -0.04283917f, -0.01616298f, 
    0.04185388f, -0.03896662f, -0.03093269f, 0.02759775f, -0.03368978f, 0.01233520f, -0.01097991f, 0.01899194f, 
    0.02348547f, -0.01209778f, 0.00894409f, 0.01833713f, -0.03339134f, 0.01804935f, 0.00007664f, -0.00135251f, 
    -0.05164161f, 0.01632981f, -0.04041827f, -0.01711751f, -0.00545112f, -0.02543458f, -0.02319863f, 0.01248276f, 
    -0.02035492f, -0.01231793f, 0.00552331f, -0.05753310f, -0.01378791f, -0.02543214f, 0.01015025f, -0.01477910f, 
    0.02754956f, -0.04290815f, -0.01697043f, -0.05154653f, -0.03475314f, 0.02016801f, 0.02645070f, -0.03836289f, 
    -0.01031827f, -0.01098387f, -0.03185820f, -0.03010004f, 0.03555055f, -0.04726211f, 0.01625916f, -0.05353791f, 
    -0.03821046f, -0.02935140f, -0.02326230f, 0.03825412f, 0.00759691f, -0.04026316f, 0.04613921f, 0.00680095f, 
    0.02692576f, -0.03761635f, 0.04593853f, 0.04138533f, -0.00974351f, 0.01975161f, -0.02965750f, 0.03053018f, 
    0.04933779f, -0.05904627f, 0.02182487f, 0.00939910f, 0.04952534f, -0.02222331f, -0.04404265f, -0.03174582f, 
    -0.01020927f, 0.01634792f, 0.04191858f, 0.01769202f, -0.00473573f, 0.02768632f, 0.01554893f, 0.02832310f, 
    -0.05569169f, -0.06230865f, 0.03837071f, 0.04262092f, -0.04082444f, -0.04125033f, 0.03091408f, 0.00697618f, 
    -0.05081850f, 0.01106555f, -0.02479364f, 0.03937592f, 0.05884251f, -0.00689282f, -0.04192335f, 0.03369777f, 
    -0.00629148f, -0.01014724f, -0.05631508f, -0.05929930f, -0.02297442f, -0.04085248f, 0.03836774f, -0.01684453f, 
    0.01834354f, 0.03067743f, 0.01333155f, 0.01441471f, 0.05605788f, -0.01430705f, -0.00884156f, 0.00869865f, 
    0.04507812f, 0.04408987f, -0.05293205f, 0.00085289f, 0.00556967f, 0.01699438f, -0.01156709f, -0.06258444f, 
    -0.04687045f, 0.00096080f, 0.02877462f, -0.02463248f, 0.03090469f, 0.03253513f, -0.03740289f, -0.02300301f, 
    -0.03729117f, -0.02716304f, 0.01000029f, -0.05507933f, 0.02073767f, -0.02587961f, -0.00706851f, -0.04237906f, 
    0.00139883f, 0.00443665f, 0.00877643f, -0.01194561f, -0.00106371f, -0.02883076f, -0.00503636f, -0.02167234f, 
    0.00069253f, -0.00929595f, -0.02319806f, -0.02489624f, 0.01837883f, -0.02200888f, 0.01504245f, -0.05323221f, 
    0.02489882f, 0.01633217f, -0.00037600f, -0.06483746f, -0.00323028f, 0.03910344f, -0.05072240f, -0.06309395f, 
    -0.05482419f, -0.00175349f, 0.03489866f, 0.05039731f, -0.05586658f, -0.02442856f, -0.05108762f, 0.01749345f, 
    0.01439995f, -0.02137794f, -0.03692490f, 0.02591870f, 0.02205699f, 0.02583517f, 0.02830822f, -0.03160395f, 
    -0.05445317f, 0.03103911f, -0.00018370f, 0.03603481f, 0.02320393f, 0.01431477f, 0.02852006f, 0.00266387f, 
    0.04196212f, -0.05974122f, -0.02993578f, 0.00967896f, 0.02276180f, -0.00528955f, -0.03933896f, -0.01397878f, 
    0.03764549f, 0.01798204f, 0.03164983f, 0.03086212f, 0.02692820f, -0.04040902f, -0.06465723f, 0.01966809f, 
    0.03209988f, 0.04273850f, 0.02897341f, -0.02700764f, 0.03736041f, -0.02654090f, -0.02066369f, -0.05527214f, 
    0.05365061f, -0.02419797f, -0.04587909f, 0.03477794f, 0.04240903f, -0.00753523f, -0.05237979f, -0.01933197f, 
    0.01411290f, 0.02044763f, 0.03843762f, -0.03289990f, -0.05675090f, -0.02776857f, 0.00961814f, 0.05947992f, 
    -0.03041770f, -0.04983008f, -0.02890674f, -0.04598059f, -0.04359772f, 0.05357341f, -0.03638947f, 0.05165967f, 
    -0.00107425f, 0.05065938f, -0.01436966f, -0.03968285f, -0.06152125f, -0.03539001f, -0.03813100f, -0.01784672f, 
    -0.03061479f, -0.04238132f, 0.01843232f, 0.03270581f, 0.00590932f, 0.02056445f, -0.02619426f, -0.03727296f, 
    -0.00657657f, -0.00500278f, -0.06280320f, 0.03112050f, 0.04500743f, 0.01891204f, 0.00049982f, -0.04474351f, 
    -0.02931227f, -0.05873452f, 0.00618035f, -0.05515051f, -0.02306787f, 0.04069292f, -0.00148928f, -0.06091250f, 
    0.02006559f, -0.03628036f, 0.03535472f, -0.02511487f, -0.02209658f, 0.01214298f, -0.06364547f, -0.03852540f, 
    0.03975231f, -0.04372464f, 0.03419355f, 0.00580658f, 0.01969271f, -0.04114133f, -0.05794195f, -0.04470765f, 
    0.04164542f, 0.03584696f, 0.00027366f, 0.02992512f, -0.05544412f, 0.01961901f, 0.01582664f, 0.00858508f, 
    0.04690449f, -0.02704299f, -0.00543542f, -0.00032469f, -0.05682674f, -0.03912407f, 0.01305186f, 0.01722327f, 
    0.03526500f, 0.02059201f, -0.04944252f, 0.01118042f, -0.04964281f, -0.00807505f, 0.01223315f, -0.03586563f, 
    0.04168693f, 0.03976205f, 0.04967057f, -0.04036847f, 0.03626605f, -0.05374594f, -0.01243834f, -0.00511805f, 
    0.00094108f, 0.03315471f, -0.01892422f, -0.01432277f, -0.03938747f, -0.03699127f, -0.03607121f, -0.04373420f, 
    -0.03759838f, -0.03719610f, 0.02364528f, 0.00344799f, -0.04378437f, -0.03004175f, -0.05728152f, 0.00428566f, 
    0.03499909f, 0.00040978f, -0.02075765f, -0.03874613f, 0.02543108f, -0.03852889f, -0.06468669f, 0.00855548f, 
    0.03656319f, -0.01849701f, 0.00714442f, -0.02319466f, 0.03007349f, 0.01076489f, -0.04425493f, 0.01288670f, 
    0.02210461f, 0.00263525f, 0.00961064f, 0.04015746f, 0.02982186f, -0.05451569f, -0.02830905f, 0.00973536f, 
    -0.02650087f, -0.05159744f, -0.04209612f, -0.03694633f, -0.03024974f, 0.01427358f, 0.02742483f, 0.01228222f, 
    -0.05207763f, -0.04840418f, -0.00887318f, -0.06375923f, -0.01704350f, -0.04504088f, -0.04777038f, 0.00201057f, 
    0.01942704f, 0.03013761f, -0.01153297f, 0.03096862f, 0.01219163f, 0.02662412f, -0.01124750f, 0.00159173f, 
    -0.05354438f, -0.05101209f, -0.01063167f, -0.03849969f, 0.03985718f, -0.00069924f, 0.03659366f, -0.00721298f, 
    0.03610050f, 0.01211029f, -0.00225460f, -0.02434159f, -0.03049243f, -0.04043688f, -0.01303835f, -0.01409589f, 
    -0.00075833f, -0.01220651f, 0.00860705f, 0.04658182f, -0.02264832f, 0.01880296f, -0.05416741f, 0.01118934f, 
    -0.01652865f, 0.00064648f, 0.01458905f, 0.00630373f, 0.01073740f, -0.01344754f, -0.02659300f, -0.02793216f, 
    -0.30643773f, 0.31901163f, 0.41146949f, 0.10252145f, -0.25237918f, -0.05465682f, -0.05708519f, -0.11911067f, 
    -0.00438695f, 0.05042046f, -0.15763532f, 0.20251377f, 0.07832304f, 0.10981109f, -0.14941098f, 0.00468343f, 
    -0.02173630f, -0.00012957f, -0.04587892f, 0.08924534f, 0.55156344f, 0.43162239f, 0.18112290f, 0.14917964f, 
    -0.43050340f, 0.16163753f, -0.06682185f, -0.25990692f, 0.19799283f, -0.05009609f, 0.01375468f, -0.03326488f, 
    0.14342999f, 0.01245964f, 0.07937611f, -0.02693443f, 0.03286134f, 0.02910371f, -0.13659368f, 0.05103969f, 
    0.08466264f, 0.51980567f, -0.43310666f, 0.03392923f, -0.37304854f, 0.07295357f, 0.09905992f, -0.07291658f, 
    0.33891949f, 0.14810203f, -0.07220670f, 0.06717571f, 0.12361202f, 0.07258860f, 0.14763115f, -0.00100014f, 
    0.03724129f, 0.13213384f, 0.24210291f, 0.15850027f, 0.53216702f, -0.06185893f, 0.06260704f, -0.15447353f, 
    0.18770467f, -0.04664603f, -0.10552147f, -0.05534685f, -0.00280929f, -0.02411190f, 0.03460826f, 0.18283381f, 
    0.04070032f, 0.02500576f, 0.03369663f, 0.00906761f, 0.09887796f, 0.07071362f, -0.07401444f, 0.06235448f, 
    -0.35021383f, -0.14582755f, 0.52137917f, 0.41082129f, 0.34500137f, 0.15458031f, 0.00549135f, 0.05528978f, 
    0.01222797f, 0.02221634f, 0.12768511f, -0.06632943f, 0.06117928f, -0.01930180f, 0.01427271f, 0.06864124f, 
    -0.07978282f, 0.12073948f, 0.00612538f, 0.04158934f, 0.03531703f, -0.08423071f, -0.18415944f, 0.05928089f, 
    0.23870760f, -0.11263260f, 0.12016939f, 0.17186993f, 0.09603885f, 0.03765970f, -0.06723960f, -0.01701012f, 
    -0.02707227f, 0.01906160f, 0.03978238f, 0.04896677f, 0.01160094f, -0.01487261f, 0.00082089f, -0.05196683f, 
    -0.15169473f, 0.19003822f, -0.06343135f, 0.21368934f, 0.16722700f, 0.04669445f, -0.16155903f, 0.18810076f, 
    0.04620395f, 0.04407196f, -0.10758235f, 0.00889806f, -0.05681224f, 0.02563225f, 0.11946404f, 0.09434129f, 
    -0.04188436f, -0.05306592f, -0.18981154f, 0.06061659f, 0.23080288f, -0.13331637f, -0.75173241f, -0.15910126f, 
    0.08027410f, 0.10983437f, 0.12283721f, 0.11252385f, 0.15330826f, 0.09445443f, -0.05744639f, -0.06266385f, 
    -0.02798031f, -0.03538907f, -0.00675795f, 0.16292451f, -0.09890406f, -0.17854720f, 0.01670693f, 0.10409149f, 
    -0.23454671f, 0.37552911f, 0.13079457f, -0.14837259f, -0.14972867f, 0.04172241f, 0.14304692f, 0.11302316f, 
    0.25747401f, 0.09545621f, 0.02809247f, -0.21301699f, -0.05996820f, -0.06860606f, -0.06260771f, 0.00218848f, 
    -0.02429957f, -0.19884966f, 0.19910170f, -0.01020215f, -0.52605855f, 0.30039543f, -0.12389392f, 0.29489085f, 
    0.29992926f, -0.09020548f, -0.21932827f, 0.03090315f, 0.27692285f, -0.02832475f, -0.06394076f, 0.01968827f, 
    -0.04159705f, 0.05197628f, -0.02041481f, -0.00414626f, -0.00435719f, -0.11961405f, -0.13020226f, -0.04629899f, 
    0.36208132f, 0.08190108f, -0.57441038f, 0.04647500f, -0.22564290f, 0.05501049f, 0.06144933f, 0.15032209f, 
    0.03225826f, 0.08465525f, -0.11325963f, 0.03129574f, -0.13542643f, 0.09062859f, 0.08505319f, 0.00613169f, 
    0.02023970f, -0.00085848f, -0.23317277f, 0.12610358f, -0.53984731f, 0.08606608f, 0.15625747f, 0.31844532f, 
    0.20364225f, 0.01071314f, 0.03446905f, 0.13863298f, 0.10489281f, 0.06937347f, -0.05905550f, 0.03289213f, 
    0.02121209f, -0.07142010f, 0.00355364f, 0.02972017f, 0.01480598f, 0.05015957f, 0.07888236f, -0.02929753f, 
    -0.68009722f, 0.13824406f, 0.22705625f, 0.00396805f, 0.07902745f, -0.22930986f, 0.12620296f, 0.06384592f, 
    0.02160339f, 0.06058924f, -0.20539357f, 0.08652697f, -0.03654827f, 0.09196702f, -0.06360804f, 0.01547179f, 
    0.04902159f, -0.03909949f, 0.00332279f, 0.08098014f, -0.25133717f, -0.14352965f, 0.23471603f, -0.07274064f, 
    -0.01293098f, 0.14087681f, 0.09856193f, -0.06125153f, 0.12326540f, 0.00185666f, -0.05815016f, 0.15625916f, 
    -0.11943756f, -0.03374368f, 0.10220273f, 0.08278117f, 0.20153899f, -0.03147516f, 0.08778402f, 0.02954456f, 
    -0.13611326f, -0.14948606f, 0.20918940f, -0.14762273f, 0.28777355f, 0.00808370f, -0.00277190f, -0.06934052f, 
    -0.11740854f, 0.03710791f, 0.07835090f, 0.05198059f, 0.00632186f, 0.06897011f, -0.00153059f, 0.00713036f, 
    -0.00533961f, -0.10718009f, -0.01285707f, -0.10781685f, -0.22377516f, 0.36679903f, 0.58253396f, 0.42047456f, 
    -0.33131477f, -0.05202067f, -0.04887282f, 0.07718410f, -0.19798405f, 0.04271767f, -0.14262015f, 0.03432257f, 
    0.06041471f, -0.02591120f, -0.17867497f, 0.10999233f, -0.02856649f, -0.17353980f, 0.09759769f, 0.04927080f, 
    0.17595364f, 0.20327237f, 0.10181019f, 0.05533910f, 0.38163164f, 0.13053124f, 0.03933948f, 0.12428819f, 
    0.16039893f, -0.06680637f, 0.09536316f, -0.12029082f, -0.19275670f, -0.08784512f, 0.04126637f, 0.04843025f, 
    0.03887785f, 0.05541702f, -0.06998198f, 0.00759267f, -0.19987115f, 0.32436636f, 0.35233828f, -0.25892866f, 
    0.32483074f, -0.11539668f, 0.01905861f, -0.10087435f, -0.44408208f, 0.06268548f, -0.02421119f, 0.03477354f, 
    0.08669368f, -0.20311595f, 0.17621712f, 0.03990088f, 0.01870265f, 0.00862663f, 0.09067415f, -0.17213902f, 
    0.07314569f, 0.06681999f, 0.17974395f, -0.09645266f, 0.18924136f, -0.16824417f, -0.30371383f, -0.14745249f, 
    -0.21367866f, -0.03400971f, 0.13760100f, -0.12957773f, 0.01458452f, -0.12150644f, -0.07983150f, 0.25471562f, 
    0.08745091f, 0.03634154f, -0.00833251f, 0.14286292f, -0.29272568f, -0.05043324f, -0.20450726f, -0.20915855f, 
    -0.13720477f, 0.13403673f, -0.05652886f, -0.10269617f, -0.03029332f, 0.21777877f, 0.18177572f, -0.06097294f, 
    0.09818004f, -0.08798119f, 0.00061956f, -0.03499455f, -0.10727084f, 0.10655353f, 0.11391108f, -0.12613271f, 
    -0.11112643f, 0.20001213f, 0.13717076f, -0.05914089f, 0.00793878f, 0.13972250f, 0.06660579f, 0.09188137f, 
    0.18621458f, -0.15987214f, -0.11736730f, -0.09078631f, -0.10679877f, 0.09365237f, 0.07734039f, -0.18915398f, 
    -0.02568902f, -0.07011271f, -0.02139714f, 0.01263364f, -0.50729901f, -0.29613364f, -0.13162518f, -0.04262310f, 
    -0.22251265f, 0.18372014f, -0.22149390f, -0.14798956f, -0.13269003f, 0.06432541f, 0.12239642f, 0.12513493f, 
    0.05507676f, 0.16108777f, -0.05503664f, -0.02101474f, -0.05477025f, -0.00544527f, -0.17441423f, -0.04739793f, 
    0.10526410f, 0.10683808f, 0.22766802f, -0.04637233f, -0.12635031f, 0.18987457f, 0.31847450f, 0.06205514f, 
    0.12364833f, 0.09510884f, 0.00583055f, 0.02809015f, -0.04954646f, 0.04173725f, -0.04570407f, -0.10045085f, 
    0.00923534f, -0.04277011f, 0.13407052f, 0.07108898f, -0.30687854f, 0.21727562f, 0.48671779f, 0.17707916f, 
    -0.08749660f, -0.26520473f, -0.00870449f, -0.11920603f, 0.00351247f, -0.01014355f, 0.03065946f, 0.07464065f, 
    0.02368199f, -0.00017356f, -0.05918689f, -0.09705117f, 0.13270493f, 0.29469076f, 0.02061097f, 0.16825730f, 
    0.37111828f, 0.22479253f, -0.00820905f, -0.10146197f, 0.25607079f, 0.15242279f, 0.10711583f, -0.03452066f, 
    -0.06902206f, -0.09604954f, -0.06485055f, -0.07769066f, -0.02145700f, -0.04915250f, -0.05560321f, 0.09380440f, 
    0.04686753f, 0.00213683f, -0.05754152f, 0.12927502f, 0.21468259f, 0.03860619f, 0.40742031f, -0.21296938f, 
    -0.30098802f, 0.41396418f, 0.32400170f, 0.04047740f, -0.10879754f, -0.00872428f, -0.09586176f, -0.08754376f, 
    0.01264506f, 0.04396640f, -0.04849795f, -0.15790224f, 0.05160778f, -0.05466319f, -0.05736040f, 0.09874205f, 
    -0.05700624f, 0.29682758f, 0.32875529f, 0.13938837f, 0.18318787f, -0.07345758f, 0.01258298f, -0.17202348f, 
    0.01519311f, 0.24203423f, -0.04035597f, -0.02339140f, 0.00184254f, -0.04740626f, -0.01682471f, -0.03854085f, 
    0.11258940f, -0.11689916f, 0.22170807f, 0.06990048f, 0.03127827f, 0.05633530f, 0.16374709f, 0.03876910f, 
    0.02385361f, 0.03921325f, 0.29684573f, 0.09370672f, -0.00286884f, 0.08245961f, -0.03722936f, -0.06696398f, 
    0.04375724f, 0.10001542f, -0.11882257f, -0.09502740f, -0.03551582f, -0.07544553f, -0.12364809f, 0.08256470f, 
    0.39599925f, 0.06352533f, -0.08768295f, 0.12207723f, 0.13490704f, 0.14949185f, -0.04759084f, -0.01047946f, 
    0.06707508f, 0.07722234f, -0.12778983f, -0.25573650f, -0.19707231f, -0.03566645f, 0.04380436f, 0.09244703f, 
    0.01313977f, 0.13868797f, -0.06052542f, 0.11105987f, 0.16651158f, 0.16324839f, 0.00227493f, 0.10361090f, 
    -0.01888604f, -0.13637036f, -0.07497369f, -0.22075370f, -0.15036260f, 0.31191730f, 0.16299951f, -0.07111234f, 
    0.03043918f, 0.01374378f, -0.00316912f, -0.09389164f, 0.00797382f, -0.07347849f, -0.01804038f, 0.18355298f, 
    -0.17897516f, -0.24848476f, -0.30214798f, 0.10554464f, 0.02834814f, 0.02189262f, -0.00805490f, -0.11652485f, 
    0.03965930f, 0.15801366f, -0.10298711f, -0.05960396f, 0.11058651f, 0.03893345f, 0.16729440f, -0.01823383f, 
    -0.05369601f, -0.07561003f, -0.13088492f, 0.19695766f, -0.07925618f, 0.23669972f, 0.02665310f, 0.09459230f, 
    0.56402743f, 0.10266407f, 0.17340107f, 0.06175683f, -0.01588466f, -0.07960661f, 0.08923279f, -0.01011856f, 
    -0.11956693f, -0.02929768f, -0.02055077f, -0.05280157f, 0.02668243f, 0.18064032f, -0.10086337f, -0.03536716f, 
    -0.16859326f, -0.21090360f, 0.05974794f, 0.05440839f, -0.01455515f, 0.12074501f, 0.11353810f, -0.02478049f, 
    0.02583178f, -0.06396680f, 0.00517515f, 0.04703610f, 0.06389918f, -0.02189982f, -0.00997799f, -0.03849988f, 
    -0.05092994f, -0.14178710f, -0.06271419f, -0.07062460f, 0.47911420f, 0.23903163f, 0.37651864f, 0.28328860f, 
    0.27303231f, 0.04301028f, -0.06933390f, 0.13721146f, 0.01089793f, -0.05300939f, -0.14612995f, -0.09174489f, 
    0.22632900f, 0.18498768f, -0.00306093f, 0.11043427f, 0.06512329f, 0.11055855f, 0.05702676f, 0.03499037f, 
    -0.16195230f, 0.57951635f, -0.23948509f, 0.70351815f, -0.26969874f, 0.10446410f, 0.03288666f, -0.10558075f, 
    -0.02526241f, 0.46067023f, 0.12589368f, 0.22124237f, 0.07135266f, 0.13890779f, 0.09489283f, 0.07719380f, 
    0.27033570f, 0.13736199f, 0.08653968f, 0.16459160f, 0.09893935f, -0.13222335f, 0.50534993f, 0.13552207f, 
    -0.03317470f, -0.29770169f, -0.15881202f, -0.08658738f, -0.05926720f, -0.44572505f, -0.11509264f, 0.01409154f, 
    0.05242621f, 0.11432844f, 0.10965718f, 0.23981462f, -0.05382723f, -0.23034561f, -0.07082894f, -0.18660070f, 
    0.42417419f, 0.05616609f, -0.04379283f, -0.35746375f, -0.07167129f, 0.09497002f, 0.18766047f, -0.19980951f, 
    0.12362374f, 0.27687055f, 0.22641233f, -0.00041628f, -0.07297407f, -0.02675518f, 0.13366640f, 0.16586429f, 
    -0.03438901f, 0.01954618f, 0.28453630f, -0.01877360f, 0.05393182f, 0.42243955f, -0.11346804f, -0.16224664f, 
    0.04439414f, -0.12329563f, 0.08269672f, -0.00757073f, -0.04283987f, -0.16444087f, -0.08904734f, -0.07419012f, 
    0.07004756f, -0.06679795f, -0.05625087f, 0.01620389f, 0.18166967f, 0.18473940f, 0.21455237f, -0.07614497f, 
    -0.03885048f, -0.17255628f, -0.48544747f, -0.17102227f, -0.06022739f, 0.11481566f, -0.00937258f, 0.01734137f, 
    0.03135054f, 0.07347225f, -0.07728872f, -0.02034108f, 0.03610882f, -0.10419866f, 0.02317009f, 0.02483249f, 
    -0.11435992f, 0.24577443f, -0.19565910f, 0.13820656f, -0.20161527f, -0.15825242f, -0.06076696f, -0.14643510f, 
    -0.01280633f, 0.11510184f, 0.03162787f, 0.06624153f, -0.20359191f, -0.04617646f, 0.08350237f, -0.10873167f, 
    0.03546008f, 0.05407179f, -0.02129729f, 0.14317669f, -0.03102564f, 0.19442502f, -0.06620996f, -0.11319614f, 
    -0.39745626f, -0.14279826f, -0.66516137f, -0.06440707f, -0.37381920f, -0.07250268f, 0.05676563f, -0.12792850f, 
    0.11531290f, -0.10793205f, 0.06675287f, -0.10020950f, -0.06564240f, 0.11856475f, 0.02764605f, -0.02778568f, 
    -0.08058340f, 0.02482145f, 0.10485663f, 0.11281901f, -0.09873307f, -0.21072285f, -0.65275460f, -0.14641985f, 
    -0.08977501f, 0.01413361f, -0.19369747f, -0.04174286f, 0.23393476f, 0.04776300f, -0.13693734f, -0.01588622f, 
    -0.00971420f, -0.03730356f, -0.07476214f, 0.11609903f, -0.03989486f, 0.37670636f, -0.11230725f, 0.09241204f, 
    -0.05957479f, -0.21974114f, -0.17509924f, 0.10253840f, -0.18406284f, 0.17799224f, -0.13167256f, 0.08454464f, 
    -0.07620557f, -0.00613986f, 0.02273394f, -0.09313561f, -0.16968076f, 0.02952683f, 0.18172251f, 0.11372472f, 
    -0.00706688f, 0.14084317f, -0.08266769f, -0.01075633f, 0.26525053f, 0.19331960f, -0.19540434f, -0.12174032f, 
    0.00578804f, 0.14009403f, -0.01706059f, 0.10991164f, 0.04152616f, 0.13892791f, 0.00690185f, -0.01588639f, 
    -0.05539004f, -0.12942703f, -0.15931922f, 0.15116522f, -0.16340667f, 0.17852280f, 0.06417952f, -0.07364874f, 
    0.12423671f, -0.15428127f, -0.12181111f, -0.33466575f, 0.13178159f, -0.14571312f, 0.08665457f, -0.03201573f, 
    0.10649876f, -0.03513223f, -0.04297280f, 0.03326141f, -0.03267306f, 0.01664441f, -0.01105415f, 0.14610909f, 
    0.14380580f, -0.13906902f, 0.22304095f, -0.00743909f, -0.00489362f, 0.64005923f, -0.07857344f, 0.58455795f, 
    0.16017421f, 0.05993498f, 0.13531490f, 0.13442075f, 0.08905195f, 0.04422750f, 0.04700434f, 0.18926412f, 
    0.08714347f, 0.19066994f, 0.14545766f, 0.13994464f, 0.14803968f, 0.08405865f, -0.01777145f, 0.01478389f, 
    -0.01184944f, 0.19343129f, 0.22660820f, -0.17639637f, -0.17404085f, -0.16675875f, -0.27805740f, 0.13298829f, 
    -0.25604272f, -0.20415919f, 0.02890270f, 0.16119954f, -0.08703738f, 0.07575213f, -0.05598163f, 0.13611262f, 
    0.08920582f, 0.04085761f, 0.01065215f, -0.13591142f, -0.01282369f, 0.07024027f, 0.15937701f, -0.00776185f, 
    0.28663194f, 0.24352203f, 0.17411785f, 0.09927368f, 0.21813104f, -0.07163129f, -0.10235078f, -0.04935717f, 
    0.27673364f, 0.01616665f, 0.06836080f, 0.01118529f, -0.00807193f, -0.01055514f, -0.01713115f, 0.01626921f, 
    0.34644964f, 0.31485292f, 0.24660154f, -0.09840024f, -0.14452237f, 0.11022732f, -0.24686506f, -0.21706127f, 
    -0.17184679f, -0.12598163f, -0.01971384f, -0.00717589f, 0.03260519f, 0.00960492f, 0.06397280f, -0.07321539f, 
    -0.18962364f, -0.08085568f, -0.14166105f, -0.03911862f, -0.38067886f, -0.13456710f, 0.05811136f, -0.36568221f, 
    -0.21430942f, 0.10512580f, -0.13354211f, -0.08875163f, 0.27982986f, -0.02858052f, -0.11643157f, 0.12000301f, 
    0.06821986f, 0.14779533f, 0.11818350f, 0.16671953f, 0.01248097f, 0.27677670f, 0.16720799f, 0.16584563f, 
    -0.28262454f, -0.37142506f, 0.81534463f, -0.60601944f, 0.28145340f, -0.01486408f, -0.06484361f, 0.32655147f, 
    -0.19564429f, -0.44671142f, 0.20348373f, -0.11726417f, -0.13601658f, -0.08628096f, -0.11759726f, 0.08979122f, 
    -0.13215992f, 0.10996191f, -0.12857570f, -0.12736663f, -0.08821409f, 0.21359605f, -0.23141897f, -0.14227061f, 
    0.27428505f, 0.17582433f, -0.24816649f, 0.00985977f, -0.05079132f, 0.13008974f, 0.06366153f, 0.08238964f, 
    0.10091223f, 0.11726315f, -0.06141271f, -0.00761633f, 0.10118809f, 0.30431497f, 0.17128275f, 0.09950260f, 
    -0.47604534f, 0.13279124f, -0.16677469f, 0.07154343f, -0.09649759f, 0.09167561f, -0.07449561f, 0.17292438f, 
    0.00641134f, 0.14894088f, -0.23303111f, -0.12336668f, -0.07124864f, 0.15122236f, -0.03766497f, -0.02173064f, 
    0.16998507f, -0.09118316f, 0.09351858f, 0.33936441f, -0.16029666f, -0.27000010f, -0.03659997f, -0.01195576f, 
    -0.06068545f, 0.37093189f, -0.00482602f, -0.04090983f, -0.21612197f, -0.20927784f, 0.18181255f, 0.25745004f, 
    -0.08471175f, 0.03874557f, -0.03554245f, 0.06981876f, -0.02471865f, -0.30896312f, -0.24599478f, -0.11259672f, 
    0.11986181f, -0.02655886f, 0.53687769f, 0.12352191f, -0.06948303f, 0.03230275f, 0.17924507f, 0.03402620f, 
    0.07954434f, 0.17988859f, 0.15017201f, 0.02535855f, 0.03212871f, -0.01645345f, -0.04566127f, -0.02374936f, 
    0.13282683f, -0.13088354f, 0.23998645f, 0.11036410f, 0.23763536f, 0.03326748f, 0.09527592f, 0.53505802f, 
    0.20215434f, -0.03127886f, 0.29632702f, 0.09131025f, 0.00057302f, 0.12236579f, 0.00497047f, -0.02772771f, 
    -0.21097729f, -0.08007929f, -0.00227359f, -0.06352950f, 0.24319100f, 0.31138355f, 0.03144723f, 0.26851603f, 
    0.26197442f, 0.24166913f, 0.67594868f, -0.18477736f, 0.08539538f, 0.13140760f, -0.00941847f, 0.18272097f, 
    -0.04112083f, 0.15690480f, -0.01313743f, 0.16606541f, -0.09088042f, -0.38110498f, -0.13962764f, -0.06924108f, 
    -0.17643124f, -0.22435878f, -0.40306410f, -0.39926282f, 0.16878727f, -0.09452272f, 0.63228256f, 0.16164842f, 
    0.01395686f, 0.26760551f, 0.24823754f, 0.29780793f, -0.11206522f, 0.20417874f, 0.06815557f, 0.03723828f, 
    -0.00903183f, -0.01650916f, -0.03800393f, -0.17799108f, -0.01081784f, -0.13657050f, 0.18811806f, 0.02412275f, 
    0.14508027f, 0.09412581f, 0.21230897f, 0.09040229f, 0.57663500f, -0.05482715f, 0.19969760f, 0.01735171f, 
    0.25681853f, 0.25029862f, -0.00014687f, 0.10553309f, -0.00036380f, -0.09895111f, -0.09847351f, 0.08729658f, 
    0.24033783f, 0.14598024f, 0.26309124f, 0.09172160f, 0.04247283f, 0.00345593f, 0.08441855f, 0.16389339f, 
    -0.38741836f, 0.15830399f, 0.04596096f, 0.06200727f, 0.08165597f, 0.24989086f, 0.05028787f, 0.00372343f, 
    -0.00141108f, 0.20911656f, 0.17338850f, -0.05778945f, 0.27335277f, 0.03989343f, 0.09686390f, 0.33718568f, 
    0.14539416f, -0.03158810f, -0.06119145f, 0.29653510f, -0.31206763f, 0.26325917f, -0.15706301f, -0.18232405f, 
    -0.06324750f, -0.12796853f, 0.12580375f, -0.04785606f, 0.00347539f, -0.27233884f, -0.06080180f, -0.08072755f, 
    -0.26746193f, -0.10817401f, -0.19482996f, -0.22676143f, -0.01098450f, -0.29715958f, -0.08633640f, -0.27169034f, 
    -0.02729293f, 0.20676316f, -0.30989265f, 0.14743793f, -0.13296604f, -0.16117969f, -0.03697664f, 0.19620438f, 
    0.02417766f, -0.09779362f, 0.10698442f, 0.08554333f, 0.06976496f, -0.04520738f, 0.23246090f, 0.08237817f, 
    -0.36897585f, 0.23059697f, -0.48884940f, 0.47521770f, -0.00695297f, 0.05647647f, 0.01068760f, -0.16267493f, 
    -0.12877460f, -0.16049051f, 0.01996589f, -0.03286750f, 0.13294190f, -0.00821561f, 0.01504586f, -0.08146304f, 
    -0.24326806f, -0.13585375f, -0.25836772f, -0.13757025f, 0.04608251f, 0.05620639f, 0.26605931f, 0.21799845f, 
    -0.23381418f, 0.02176886f, -0.05141379f, -0.37920550f, -0.08122122f, -0.13104625f, 0.05586277f, -0.15477246f, 
    -0.02446029f, 0.03741790f, 0.20674138f, -0.04138041f, 0.09128022f, -0.00338492f, 0.12829241f, 0.05509683f, 
    -0.04695506f, -0.01176769f, -0.02251002f, -0.01299408f, 0.03580097f, 0.00257160f, 0.00496107f, -0.02504533f, 
    -0.02462958f, 0.00559995f, -0.00855728f, -0.02802086f, -0.04357785f, -0.02607626f, 0.04222152f, 0.03662238f, 
    -0.00803571f, -0.02768706f, 0.04008208f, 0.02376681f, -0.03309889f, 0.03370196f, 0.00428566f, -0.04659674f, 
    0.00684290f, -0.04208675f, -0.01421062f, -0.00114473f, 0.04899002f, 0.04261829f, -0.00167947f, -0.05415136f, 
    0.04266394f, 0.02605806f, 0.01907060f, -0.02368080f, -0.03954589f, 0.01249756f, -0.01642750f, -0.03256568f, 
    -0.02781656f, 0.01117003f, 0.00974305f, 0.02542235f, -0.01630736f, 0.03069970f, 0.01809440f, -0.05334272f, 
    -0.05309442f, 0.02013988f, 0.01390120f, 0.01212581f, -0.02596169f, -0.05740162f, -0.00448279f, 0.02408475f, 
    0.01036561f, -0.05715885f, 0.01647575f, 0.03828100f, -0.05569998f, -0.04328720f, 0.05519128f, 0.01895129f, 
    -0.00390243f, -0.01246115f, 0.01732344f, 0.00322539f, -0.04977538f, -0.03442699f, -0.02771650f, -0.00978880f, 
    -0.00108209f, 0.00167487f, 0.02553546f, 0.03165344f, -0.02143672f, -0.00492302f, -0.02433362f, 0.04797039f, 
    0.02607121f, 0.03811904f, -0.01370471f, 0.03776931f, 0.02110670f, 0.00846155f, 0.02189684f, -0.04680742f, 
    -0.00105858f, -0.04182993f, -0.04862159f, 0.01468769f, 0.00085644f, -0.03677776f, 0.03513897f, 0.01442464f, 
    0.00490595f, 0.01110230f, -0.04774294f, 0.05059140f, -0.02982939f, -0.04931042f, 0.00116183f, 0.01354958f, 
    -0.02635975f, 0.00723542f, -0.01159893f, -0.00378163f, -0.04763249f, -0.06051292f, -0.01718123f, 0.03841700f, 
    -0.04732888f, -0.01574950f, -0.06000695f, 0.04338912f, 0.02263257f, -0.05893984f, 0.03350947f, -0.02324584f, 
    0.00312502f, 0.01798601f, -0.03716317f, 0.00854011f, -0.02837408f, -0.05071131f, -0.03472024f, -0.01263835f, 
    -0.02734632f, -0.00995834f, 0.03569401f, -0.06077446f, -0.05677037f, 0.05827828f, -0.06084693f, 0.02004595f, 
    0.02977711f, -0.03832872f, -0.04566972f, -0.04485779f, -0.00152005f, 0.01511906f, 0.00375114f, -0.02414867f, 
    -0.04280975f, -0.01640712f, 0.01413728f, 0.01205709f, -0.02263603f, 0.01571849f, -0.04100532f, 0.00220718f, 
    -0.04016560f, 0.02102825f, 0.03509698f, -0.02160193f, 0.01466989f, -0.02916648f, 0.01169583f, -0.04623808f, 
    0.03379937f, -0.01096518f, -0.00451974f, -0.05125849f, -0.01229400f, -0.00687307f, -0.02394916f, -0.05418742f, 
    -0.02629843f, 0.03872395f, -0.00350931f, -0.00075883f, -0.05564194f, 0.01679224f, 0.02790932f, 0.02533155f, 
    0.01588979f, -0.05153387f, 0.04755732f, -0.03005955f, -0.03795839f, -0.04739271f, -0.00661121f, -0.04720114f, 
    -0.06141733f, 0.04365981f, 0.00084321f, -0.04878690f, 0.04971543f, 0.02053028f, -0.00086772f, -0.03563165f, 
    0.01663741f, -0.05318110f, -0.00954369f, 0.02484744f, -0.00670867f, -0.00882228f, 0.05795795f, -0.06040223f, 
    0.01896548f, 0.01687846f, 0.02879424f, -0.03046929f, 0.03649706f, -0.02564882f, 0.03326454f, -0.01541252f, 
    -0.03401784f, -0.03228876f, -0.03512107f, -0.01407886f, -0.00828851f, 0.00267298f, -0.05345072f, -0.02838696f, 
    -0.04210501f, -0.00702530f, 0.03000344f, -0.01175724f, -0.04461373f, -0.03404572f, -0.06233900f, 0.03734489f, 
    -0.02709726f, -0.01473549f, -0.04840593f, 0.04361814f, 0.03474294f, 0.00023006f, -0.01141596f, 0.00400479f, 
    -0.05128253f, -0.02360169f, -0.03360120f, 0.04658153f, -0.02711394f, -0.02454958f, 0.00287127f, -0.03591819f, 
    -0.03544638f, 0.01465871f, 0.01252987f, 0.04425801f, -0.02760380f, 0.01551086f, 0.04556702f, 0.04048868f, 
    0.00752890f, -0.05094108f, 0.04019397f, 0.01205542f, 0.01384344f, -0.00325610f, -0.00978671f, 0.00880409f, 
    -0.00527958f, -0.01165337f, 0.02328544f, 0.02936305f, -0.01174433f, 0.01406371f, 0.02696977f, -0.04140849f, 
    0.01683014f, 0.03517746f, -0.05160221f, -0.00149028f, 0.02649444f, -0.01834671f, -0.00902401f, 0.00778220f, 
    -0.00819573f, 0.02295375f, 0.04872546f, 0.00260159f, -0.03232006f, -0.02093015f, 0.01349167f, 0.04550165f, 
    -0.01972061f, -0.01815997f, 0.05510310f, -0.01268044f, -0.04668793f, -0.05649710f, 0.03834541f, -0.01677827f, 
    -0.01038631f, -0.01165940f, 0.00567305f, 0.03445974f, 0.02723995f, 0.02047625f, -0.04258498f, 0.03031428f, 
    -0.06134174f, 0.04230895f, 0.04107979f, -0.00244708f, -0.00033934f, -0.00488559f, 0.02288956f, 0.00504517f, 
    0.02466632f, -0.05606724f, 0.04730355f, 0.04262205f, 0.04082585f, -0.05157854f, 0.00593483f, -0.04788739f, 
    -0.02159739f, -0.00044599f, -0.04874051f, -0.03210081f, -0.05056172f, 0.02006906f, 0.01377943f, -0.03650681f, 
    0.02538507f, 0.03040663f, -0.00735105f, -0.02582313f, -0.02414137f, -0.00944703f, -0.01014087f, -0.04802039f, 
    -0.00821874f, -0.04304360f, -0.04203299f, 0.00191658f, -0.04357015f, -0.00174905f, 0.03203273f, -0.01062003f, 
    -0.00120369f, -0.04194026f, -0.06356449f, -0.05656518f, -0.00528009f, -0.05596064f, -0.03158399f, 0.00995988f, 
    -0.04914866f, 0.01487248f, -0.03705101f, -0.04615999f, 0.00355011f, -0.04279523f, 0.03991011f, 0.00609980f, 
    -0.03829084f, -0.04743827f, 0.02458564f, -0.00750917f, 0.00460429f, 0.00420757f, -0.02415501f, -0.03786296f, 
    -0.03774722f, -0.05965688f, 0.02195285f, -0.00470426f, 0.04422038f, 0.03572854f, 0.01051325f, -0.02022119f, 
    -0.03743777f, -0.02555822f, -0.00693601f, 0.03893410f, -0.03651557f, -0.02977955f, -0.06222026f, -0.01962154f, 
    0.04563017f, -0.02431793f, 0.00985160f, -0.06023483f, -0.03911346f, -0.02471364f, 0.04066179f, -0.02180260f, 
    -0.04913818f, -0.06104215f, 0.04053786f, -0.00197337f, 0.02766085f, -0.05637971f, -0.05968935f, 0.01641591f, 
    0.01706466f, -0.05460721f, -0.01070995f, 0.00226257f, 0.00001690f, -0.05802453f, 0.04170145f, -0.05216736f, 
    -0.03554196f, -0.02772542f, -0.02557206f, -0.01118793f, -0.04796960f, 0.01083754f, -0.03252055f, -0.05445588f, 
    -0.02346608f, -0.00725477f, 0.05093103f, 0.05492588f, 0.01857746f, 0.06320024f, -0.02905700f, 0.04178424f, 
    -0.04310121f, 0.00220191f, -0.03202333f, 0.02147928f, 0.02875825f, 0.02414073f, -0.00915717f, 0.01405060f, 
    -0.01091983f, -0.01555718f, -0.00856024f, -0.02700892f, -0.05391767f, 0.01913134f, 0.04388997f, 0.03078924f, 
    -0.06013465f, 0.03916097f, 0.03048112f, 0.01163310f, -0.05821808f, -0.05690706f, 0.04782469f, -0.03375498f, 
    -0.00858814f, 0.04906195f, -0.01623021f, 0.01457609f, 0.00688239f, 0.04245171f, 0.04164577f, -0.01721545f, 
    -0.04105705f, 0.03953330f, 0.03439902f, -0.01119150f, -0.02917239f, -0.05621965f, -0.02190394f, -0.02614026f, 
    0.04582948f, 0.04077323f, 0.02666531f, -0.03296054f, -0.05074982f, -0.03661653f, -0.00008913f, -0.02908112f, 
    -0.00617727f, -0.03404375f, -0.01618214f, -0.04883093f, -0.01272969f, -0.01139181f, -0.01220393f, -0.01180113f, 
    -0.03264870f, -0.05898242f, -0.05407272f, -0.04013990f, -0.01087183f, -0.01549334f, 0.02233903f, 0.03965200f, 
    -0.05369225f, 0.01432025f, -0.02451993f, -0.03264879f, -0.03334792f, -0.01355472f, -0.00586614f, 0.04514461f, 
    0.00396093f, -0.01676003f, 0.03823041f, -0.03905385f, -0.02084574f, -0.05345561f, -0.01451960f, -0.01004685f, 
    0.04234316f, -0.04938680f, 0.02313681f, 0.04296235f, -0.00740206f, 0.01250682f, 0.02783424f, -0.02772216f, 
    -0.01731849f, 0.05550401f, -0.01482025f, -0.05398550f, -0.05965625f, 0.03658894f, 0.05249340f, 0.05303025f, 
    -0.01261014f, 0.01965487f, 0.01897926f, -0.02862624f, 0.00309759f, -0.06020648f, -0.00626771f, -0.06064992f, 
    -0.02912498f, 0.04647291f, -0.02441172f, -0.03598962f, -0.00311230f, -0.00200820f, 0.02610685f, 0.01319768f, 
    -0.05832860f, -0.00973375f, -0.03182554f, 0.01333403f, -0.02211718f, -0.05491072f, 0.03322629f, 0.00184000f, 
    0.03935211f, -0.05277900f, -0.03784610f, 0.03151005f, -0.04959139f, -0.00666124f, 0.00000089f, -0.05029388f, 
    -0.02405025f, 0.02632043f, -0.01662976f, -0.05804577f, -0.02667889f, -0.05237257f, 0.04208730f, -0.00485003f, 
    -0.01063039f, 0.04687241f, -0.02691329f, 0.01900619f, -0.03617529f, -0.00083199f, -0.04955454f, -0.00373896f, 
    0.04694512f, 0.01615930f, 0.01851098f, 0.03327866f, -0.00210598f, -0.01115207f, 0.03961087f, 0.01104150f, 
    0.02926701f, 0.01095161f, -0.05601371f, 0.05220358f, -0.02579761f, -0.01432026f, -0.01762619f, 0.01549225f, 
    -0.03487540f, -0.03889358f, -0.03296508f, 0.00572502f, -0.01642098f, 0.04503100f, -0.05038842f, -0.03477798f, 
    0.01879150f, 0.00741144f, -0.05086733f, 0.03733544f, 0.04164470f, -0.05969776f, 0.02343179f, 0.00765309f, 
    0.04585510f, -0.00679885f, 0.02915710f, -0.00768303f, 0.01542295f, 0.04841600f, -0.00832452f, 0.01964865f, 
    -0.03150695f, -0.05077977f, 0.01857617f, -0.01330815f, 0.03345435f, 0.03072473f, -0.00295150f, 0.02632829f, 
    -0.05625384f, 0.03143633f, 0.02214085f, -0.01576500f, -0.03438588f, -0.04506467f, -0.00225855f, 0.00145859f, 
    0.01513425f, -0.03412149f, 0.00401243f, -0.01114279f, 0.02476537f, -0.01358066f, 0.00928058f, 0.00777597f, 
    0.01550932f, -0.04338825f, -0.01497741f, -0.02700062f, -0.04028850f, 0.04637743f, -0.04422493f, -0.00559067f, 
    -0.05703169f, -0.02678654f, 0.04315985f, -0.04960790f, 0.02335417f, -0.02277877f, -0.05294042f, -0.04817152f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.03823786f, -0.11739974f, -0.03192765f, 0.06919402f, 0.04416830f, 0.04001429f, 0.07974972f, -0.06114839f, 
    0.11986882f, -0.04027237f, -0.04805914f, -0.03126870f, 0.10349876f, 0.15060656f, 0.17328317f, -0.10825647f, 
    -0.05640688f, 0.03668364f, 0.08787165f, 0.03539716f, -0.04082776f, 0.00153344f, 0.03762569f, 0.26797184f, 
    -0.01926825f, -0.05945660f, 0.19845058f, -0.00847204f, 0.07367186f, -0.02111114f, -0.02209590f, 0.02141631f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.10359613f, 0.43273622f, 0.06479770f, 0.03874399f, -0.12700847f, 0.35792419f, -0.97306871f, 0.04085471f, 
    0.09341318f, -0.17317326f, 0.26555091f, -0.12369300f, 0.18921588f, -0.56367832f, -0.60533488f, 0.20229638f, 
    -0.08285877f, 0.08570637f, -0.00589861f, -0.09913974f, -0.09136815f, 0.04827969f, -0.03504847f, -0.63920534f, 
    0.12007372f, 0.09035476f, -0.22478233f, 0.30964151f, -0.08332504f, 0.10710719f, -0.00608163f, 0.03349236f, 
    -0.14309651f, 0.26611173f, 0.06796009f, -0.83366990f, -0.13010721f, 0.08440464f, -0.24843957f, 0.02868979f, 
    0.34150493f, -0.16339241f, 0.47691512f, -0.09632141f, 0.27461225f, -0.02578593f, 0.54166597f, -0.78531343f, 
    0.06582809f, 0.15457830f, 0.41172805f, -0.15350097f, -0.10067451f, -0.09641789f, -0.05458532f, -0.38050815f, 
    -0.03056053f, 0.01319242f, 0.33761492f, -0.07062715f, 0.18243779f, -0.58317995f, -0.12012213f, -0.06429654f, 
    0.08329093f, -0.22284152f, 0.30933571f, -0.02660429f, -0.15696472f, -0.98033082f, 0.43251327f, 0.11190378f, 
    0.07409938f, -0.15999553f, -0.26951000f, -0.01340456f, 0.31534716f, -0.03588249f, -0.66901857f, -0.10849095f, 
    0.10738747f, 0.08997878f, -0.32506433f, 0.00932790f, 0.03932913f, -0.44955847f, -0.01197372f, 0.15602358f, 
    -0.11436755f, 0.03229957f, -0.17989987f, 0.27701807f, 0.37510073f, 0.04972038f, -0.13369000f, -0.17925352f, 
    -0.14542629f, 0.12796824f, 0.43260074f, -0.18291575f, 0.12512922f, -0.07689589f, 0.47758394f, -0.05596499f, 
    -0.74936706f, 0.00710829f, 0.00067609f, 0.09623799f, -0.39646906f, -0.26559469f, -0.41662776f, 0.36754584f, 
    0.15383379f, 0.07284639f, -0.53442252f, 0.04735475f, -0.13828944f, 0.24622864f, -0.17822950f, -0.38949373f, 
    0.02235902f, 0.00219191f, -0.12772976f, 0.12006237f, 0.14908834f, 0.09965440f, 0.14302503f, -0.14049767f, 
    -0.03942426f, -0.42928070f, -0.23567295f, 0.30975109f, 0.14546864f, -0.02726391f, -0.04087945f, 0.03120244f, 
    0.31105217f, 0.14468746f, 0.11088380f, -0.08450338f, 0.11400159f, -0.23378412f, -0.26192844f, 0.18419003f, 
    -0.09521023f, -0.04151497f, -0.12885937f, 0.01831731f, 0.01343760f, 0.05318287f, 0.06108608f, -0.08043186f, 
    -0.01099794f, 0.09075337f, 0.01086174f, 0.01583442f, -0.82331932f, 0.32884112f, -0.13522220f, -0.13887993f, 
    0.15307298f, 0.02251269f, 0.03589444f, -0.45075187f, -0.05178936f, 0.43803310f, -0.41447598f, -0.09352800f, 
    -0.25227326f, -0.00238516f, -0.35274285f, -0.05817048f, 0.17319058f, 0.10047480f, -0.48002768f, -0.68610269f, 
    -0.08965176f, -0.04475106f, 0.11628959f, 0.17797300f, -0.12556945f, 0.16162266f, 0.05794585f, 0.20018296f, 
    0.10634803f, 0.01462973f, 0.01836120f, 0.24441132f, -0.34130028f, 0.20468268f, -0.00193008f, -0.13484202f, 
    0.15957943f, -0.35609704f, 0.26847231f, 0.04586324f, 0.02245831f, -0.06133977f, 0.35440233f, 0.09958071f, 
    -0.29906362f, -0.08044830f, -0.79248190f, -0.03818548f, 0.13691752f, -0.36256689f, 0.02739566f, 0.23131514f, 
    0.00713418f, 0.04963261f, 0.57066119f, -0.04887075f, -0.01456268f, -0.77213085f, -0.15452325f, 0.42003450f, 
    0.03702773f, 0.06060464f, 0.29900727f, -0.43847036f, 0.13340747f, -0.12332651f, -0.08075681f, -0.04290590f, 
    0.08429412f, 0.38704312f, -0.90069038f, -0.03796319f, 0.00670185f, -0.25519985f, 0.09733219f, -0.05057887f, 
    0.17880186f, 0.05802264f, -0.43869057f, -0.06301165f, -0.65231782f, 0.31963685f, -0.00299363f, 0.20868699f, 
    -0.06583657f, 0.01861347f, -0.40196961f, -0.06918054f, 0.16460231f, -0.17339681f, 0.12960751f, -0.15172049f, 
    0.08231952f, -0.11527716f, -0.59700495f, -0.45886248f, -0.03389458f, 0.50057459f, 0.02613058f, -0.14250341f, 
    0.15305734f, 0.20961200f, -0.33932304f, -0.10835531f, 0.00239357f, 0.52888238f, -0.20574369f, 0.00373550f, 
    -0.35966530f, 0.11388869f, -0.77232981f, -0.02616462f, -0.20482986f, 0.26809120f, -0.21447358f, -0.04530691f, 
    0.14172554f, 0.03865819f, -0.32878342f, -0.12878211f, 0.15876929f, 0.09364314f, -0.02044524f, 0.23227787f, 
    -0.06883554f, 0.09614185f, -0.76781368f, -0.25946903f, 0.42398113f, -1.00700283f, 0.06723361f, 0.02520053f, 
    0.13902703f, -0.31586531f, -0.88041812f, 0.46351862f, 0.08524527f, -0.00109620f, 0.07935694f, -0.13577813f, 
    0.20139925f, 0.14226066f, 0.12352223f, -0.11215781f, 0.06549980f, -0.25745746f, 0.16829486f, -0.73758495f, 
    0.04545308f, -0.15242559f, -0.21634394f, -0.14783753f, 0.01097817f, -0.42079619f, -0.17441736f, 0.19745937f, 
    -0.07449883f, -0.16991138f, 0.38405034f, -0.41864732f, 0.12577051f, 0.50938469f, -0.03661667f, -0.05369323f, 
    -0.01008347f, -0.28404835f, 0.19511162f, -0.07403487f, 0.06819970f, -0.55795342f, -0.49315113f, 0.11367568f, 
    -0.44763649f, -0.11100201f, 0.06921575f, 0.03775205f, -0.06498286f, -0.05894499f, -0.69059557f, 0.32398635f, 
    -0.01704356f, -0.15710911f, -0.19957677f, 0.02249335f, 0.15202643f, 0.34956917f, 0.00140139f, 0.15223572f, 
    -0.09874608f, 0.06631552f, 0.57995826f, -0.44942054f, 0.27923453f, -0.75137681f, 0.05261957f, -0.02623043f, 
    -0.05698669f, -0.73257107f, 0.72770566f, 0.07237262f, 0.01075959f, 0.26701298f, -0.05261989f, -0.07439770f, 
    -0.29459932f, -0.05816385f, 0.08802777f, -0.15595451f, -0.95675629f, 0.20044474f, 0.46407321f, -0.12501033f, 
    0.01951192f, -0.03731957f, 0.17093340f, 0.06813464f, -0.00672950f, 0.06315369f, -0.17794868f, -0.22865447f, 
    0.09517565f, 0.13213874f, 0.02864945f, -0.47441971f, -0.07692549f, -0.06861855f, 0.03356814f, 0.08743498f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.51791978f, 0.17553937f, -0.19474046f, -0.17279345f, -0.10401651f, 0.27684870f, 0.36471930f, -0.25777709f, 
    0.09373309f, -0.10406756f, -0.28532401f, -0.29038030f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
