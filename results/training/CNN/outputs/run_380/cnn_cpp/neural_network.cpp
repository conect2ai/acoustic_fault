#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.26485977f, -0.89869148f, -0.27522695f, 0.47885850f, 0.94963080f, -1.30359852f, -0.33189407f, -0.17733556f, 
    -0.66440821f, -0.08309083f, 0.58223814f, 0.79974794f, 0.04784032f, -0.08277957f, -0.14935453f, -0.04400663f, 
    -0.16397984f, -0.20513076f, -0.23245545f, 0.08098040f, -0.16323262f, -0.03164617f, 0.12986459f, 0.18886571f, 
    -0.01891924f, 1.48708940f, 0.95473856f, -0.22566329f, 0.16517697f, -0.28239068f, -0.38653937f, -0.14794464f, 
    0.27044165f, 0.39809206f, 0.20125680f, -0.02688592f, -0.15738945f, -0.01293124f, -0.31511471f, 0.37146220f, 
    0.12254564f, -0.41213730f, -0.20216279f, -0.38336208f, -0.15680523f, 0.30193463f, 0.09258436f, -0.06040744f, 
    -0.14997569f, -0.16196848f, -0.63164169f, 1.61369669f, -0.21998391f, -0.31175339f, 0.94441998f, 0.43699449f, 
    -0.50878394f, 0.55297673f, -0.03929948f, 0.27059090f, -0.27369833f, -0.36529192f, -0.05134356f, 0.24199808f, 
    -0.28447124f, 0.00812644f, 0.06759105f, -0.09847397f, 0.23586433f, -0.05251478f, -0.16988942f, 0.10468346f, 
    -0.13991132f, -0.27871266f, -0.23650196f, 1.41792166f, -0.33369136f, 0.32667369f, 1.44362664f, 0.78043360f, 
    -0.04973320f, 0.53821248f, -0.17549586f, 0.31494403f, 0.42935216f, -0.42644614f, 0.05108224f, -0.05643616f, 
    -0.23360063f, -0.15007588f, -0.40184921f, 0.10782263f, 0.25766826f, 0.34699985f, -0.07065332f, 0.35970920f, 
    0.31391561f, 0.02104645f, -0.18922862f, 0.19043185f, 0.30288240f, 0.32149938f, 0.94758874f, 0.68800610f, 
    0.10200254f, -0.40254417f, 0.05593301f, -0.27992865f, 0.13281502f, 0.79661387f, 0.25847310f, 0.49102890f, 
    -0.44505402f, 0.26079199f, -0.50746912f, 0.12234251f, -0.41870099f, -0.62083340f, -0.34384260f, -0.67795318f, 
    0.01549732f, -0.10000515f, 0.13112292f, -0.09868713f, -0.35143504f, 0.68062949f, -0.25632197f, -0.38682616f, 
    -0.83163911f, -0.52387482f, -0.59335041f, 0.86330879f, 0.40642527f, 0.53968269f, 0.03612526f, -0.00448261f, 
    0.21509698f, 0.09137379f, -0.45047379f, -0.16706850f, 0.19019276f, 0.50798821f, 0.23752685f, 0.25450748f, 
    -0.23472734f, -0.12866886f, 0.03463729f, 0.13551207f, -0.31124541f, 0.08266778f, -0.40003738f, -0.30389896f, 
    -0.73970014f, -0.04301524f, -0.17721480f, 0.37755251f, 0.20681135f, -0.47083873f, 0.53766137f, 0.37517262f, 
    0.64747244f, -0.00794763f, -0.20811534f, 0.48306760f, 0.07288394f, 0.29736689f, 0.33518809f, 0.43974078f, 
    0.04802550f, 0.35798389f, -0.16013250f, 0.18123652f, 0.68766010f, 0.23427476f, 0.24707721f, 1.12342250f, 
    0.38485938f, 0.99330759f, -0.03785160f, 0.32152915f, 0.30234379f, -0.75233632f, 0.07359672f, 0.05573340f, 
    0.35835400f, -0.02442729f, 0.43431506f, -0.13238241f, 0.23946247f, 0.21815340f, 0.44180983f, 0.20159672f, 
    -0.19449607f, 0.12601653f, -0.09608230f, -0.34906277f, 0.14786017f, 0.13234417f, -0.55667222f, 0.45339224f, 
    0.62792063f, 0.79562581f, 1.04908192f, 0.04169500f, -0.15551367f, 0.41453415f, 0.65909445f, -0.83918029f, 
    0.03304647f, -0.65345889f, 0.18676616f, 0.47584045f, -0.02584290f, 0.18790275f, 0.28925404f, 0.16908161f, 
    0.08309707f, -0.30543479f, 0.08521824f, 0.39581251f, -0.04009926f, -0.07271770f, -0.11167157f, -0.11783663f, 
    -0.00498509f, -0.52246779f, -0.91300321f, 0.13941363f, 0.67192829f, -0.33604610f, 0.63255352f, 0.38522482f, 
    0.42697635f, -0.52925557f, -1.16613364f, -0.34612331f, -0.27735549f, -0.17493440f, 0.72535211f, 0.76091063f, 
    0.16884157f, -0.03352287f, -0.48474434f, -0.09158564f, 0.17160416f, 0.41657600f, 0.28108528f, 0.16791634f, 
    0.29697919f, -0.28118676f, -0.98685741f, 0.28533247f, 1.11298740f, 0.43645716f, 0.16081232f, 0.98709863f, 
    0.90613228f, 0.66242552f, 0.50251693f, 0.15486370f, 0.16914822f, -0.15671794f, 0.37725472f, -0.39600745f, 
    -0.45498937f, -0.27675453f, -0.33153358f, -0.11988509f, -0.17593898f, -0.11703862f, -0.13121510f, -0.06598121f, 
    -0.10063044f, 0.14736733f, -0.31606489f, -0.94533247f, 0.77170259f, -0.07191435f, -1.07593608f, -0.72018629f, 
    0.75420743f, 0.24470076f, -0.43083334f, 0.78379434f, 0.75715965f, 0.08300607f, -0.12939201f, -0.32179743f, 
    -0.26828340f, -0.72464997f, 0.08937433f, 0.13919705f, -0.32606205f, 0.03126553f, -0.01431201f, -0.33101395f, 
    -0.19831000f, -0.17865908f, -0.26072130f, -0.10095076f, 1.04836917f, 1.04828155f, 0.90072531f, 0.88451606f, 
    0.26186123f, 0.19862993f, -0.08292094f, -0.33636209f, -0.91373628f, 0.07822182f, 0.16554409f, 0.57882500f, 
    0.20313336f, -0.06900756f, 0.05304187f, -0.06907713f, 0.10884277f, 0.33767155f, -0.18428841f, 0.28904882f, 
    0.30719191f, 0.23907669f, 0.32174653f, 0.33799356f, 0.12950113f, 1.04250205f, 0.32082599f, -0.50895852f, 
    -1.09559369f, -0.76544970f, 0.48879227f, 0.10697965f, -0.22134574f, -0.69463915f, -0.20898280f, -0.09910378f, 
    0.30461910f, -0.07320223f, 0.31627351f, 0.13846940f, 0.02821988f, -0.02094614f, 0.11207512f, -0.26981834f, 
    -0.17963529f, -0.12016401f, 0.02989738f, 0.35795370f, -0.09595937f, 0.26979882f, -0.49568579f, -1.05532956f, 
    -0.10063508f, -0.06255412f, -0.65450835f, 0.06169644f, -0.29381290f, 0.42446643f, -0.12382648f, -0.75654155f, 
    -0.24581437f, 0.03641293f, -0.31032971f, 0.43561837f, -0.63240069f, -0.40581402f, 0.39044687f, -0.15458283f, 
    0.53322929f, 0.34026080f, -0.03879807f, -0.19748367f, 0.16303581f, -0.00321200f, -0.23090273f, 0.44422945f, 
    -0.52872813f, -0.62574506f, 0.14875831f, -0.95249170f, -0.41893598f, 0.56791008f, 1.06421030f, 0.00959377f, 
    0.30563837f, 0.07217199f, 0.01243392f, -0.20970784f, -0.76687789f, -0.27060995f, -0.50296050f, -0.36832628f, 
    -0.43524730f, -0.05926319f, -0.20591269f, -0.02351121f, 0.10693011f, -0.09629844f, 0.02510796f, -0.10776240f, 
    -0.79811919f, -0.58277971f, -0.93959248f, -0.83447468f, -0.13757658f, -0.47965756f, -0.47370958f, 0.24119684f, 
    -0.07867653f, 0.29126263f, -0.48050424f, 0.13280492f, 0.44677454f, -0.09090916f, -0.06260655f, 0.44393411f, 
    -0.05260425f, 0.27565637f, 0.47162294f, -0.11726627f, -0.26268840f, 0.04563516f, 0.09753816f, -0.39944622f, 
    -0.14216021f, 0.15305817f, 0.50217521f, -0.43130907f, -1.00473559f, -0.80262411f, -0.14641385f, -0.01925147f, 
    0.51411611f, -0.53804427f, -0.51646751f, 0.20507766f, 0.34050515f, 0.44912896f, 0.61518806f, 0.17544356f, 
    -0.14273593f, -0.14500807f, 0.16199139f, -0.19097885f, 0.12481872f, 0.12035886f, 0.32616100f, -0.40661302f, 
    0.20129339f, -0.04490589f, -1.38295293f, 0.56363112f, 0.75314534f, -0.64296412f, -0.47411662f, -0.19850489f, 
    0.79269534f, -0.12133399f, -0.34832203f, -0.18243954f, -0.18479663f, 0.64299446f, -0.16630298f, -0.00148717f, 
    0.22603944f, -0.56599450f, -0.32962739f, -0.23244880f, -0.47110835f, -0.38361111f, 0.50954378f, 0.22471675f, 
    0.02045212f, 0.10225127f, 0.38503793f, -1.13215446f, 0.52420825f, -1.07837403f, -0.52759588f, 0.01962510f, 
    -0.11527061f, 1.03053546f, 0.53019547f, -0.03882183f, 0.40665525f, 0.22308140f, -0.49613026f, -0.03244667f, 
    -0.45417309f, 0.39914328f, 0.25633302f, 0.43156931f, 0.07803599f, 0.40800059f, -0.09785939f, -0.01850508f, 
    0.09553085f, 0.04403534f, -0.08917429f, 0.33167633f, -0.50638103f, -1.61316442f, -0.37345380f, 0.67979008f, 
    0.54682833f, -0.44899592f, 0.94561517f, 0.67816645f, -0.80005950f, 0.11271900f, 0.29351041f, 0.08885142f, 
    -0.17333709f, -0.10960338f, 0.20174348f, -0.30399868f, 0.08098873f, 0.03716714f, -0.00125657f, -0.02736800f, 
    -0.09502804f, -0.13543569f, -0.02385791f, -0.14587854f, 0.06104676f, 1.21112788f, 0.54682851f, -0.61255515f, 
    -0.54607219f, -0.37561134f, 1.08707595f, 0.25821942f, 0.48624399f, 0.80971128f, 0.39211002f, -0.24930198f, 
    0.01786769f, -0.35057199f, 0.03100048f, -0.36737564f, -0.10572543f, -0.22152580f, 0.06540213f, 0.12663184f, 
    0.24945967f, -0.04137275f, -0.02704918f, -0.53978711f, -0.31011578f, 0.13270465f, 0.85521263f, 1.03458571f, 
    0.83474964f, 0.49217537f, 0.72641808f, -0.12542966f, -0.35330462f, 0.08589190f, -0.09471899f, 0.44607592f, 
    -0.20795998f, -0.60775536f, -0.15728237f, 0.00623170f, -0.35410520f, 0.13238229f, 0.27776346f, 0.31869179f, 
    0.14577919f, -0.30700356f, 0.46787533f, 0.00140791f, -0.29355660f, 0.10180702f, 0.46664110f, 1.32629395f, 
    0.30421937f, -1.32062244f, -0.33613059f, -0.55380046f, -0.56536478f, 0.47171557f, -0.58575147f, 0.20099647f, 
    0.14119312f, 0.30510420f, 0.05449755f, -0.08544827f, -0.10042119f, 0.09006394f, 0.21763299f, -0.01904088f, 
    -0.22146186f, 0.13010782f, 0.23128752f, -0.03400221f, 0.29552528f, 0.25121060f, 0.09748305f, -0.18387789f, 
    -1.08639586f, -0.53993601f, 0.35229477f, 0.10381264f, -0.56511337f, -1.15399456f, -0.45336089f, -0.28617656f, 
    -0.92550391f, 0.33482319f, -0.34964254f, 0.19487123f, 0.02656603f, 0.08796681f, -0.02037939f, -0.25915071f, 
    -0.40184540f, 0.41255984f, -0.21309766f, -0.60194010f, -0.09397396f, -0.02271203f, -0.26354298f, 0.38568184f, 
    0.30296868f, -0.57002515f, 0.62237769f, 0.26635066f, 0.48574540f, 1.05557632f, -0.37485325f, 0.60546142f, 
    0.91252649f, -0.08175558f, 0.28779107f, -0.71237290f, -0.31389877f, 0.18810980f, 0.04535742f, -0.00230648f, 
    0.20021866f, -0.11638185f, 0.01475490f, 0.12375717f, 0.06281085f, 0.08866911f, -0.21950449f, -0.37831554f, 
    0.02937024f, 0.12504174f, -0.76451826f, -0.18272711f, -0.50848675f, -0.65216374f, -0.34538332f, 0.75836599f, 
    -0.63671780f, -0.49473196f, -0.41671306f, 0.50001782f, 0.39202324f, -0.65475518f, 0.61748272f, -0.37887949f, 
    -0.11712766f, 0.00047873f, -0.35976285f, 0.60295409f, -0.13244927f, -0.08660857f, 0.41279304f, 0.29857668f, 
    -0.24893561f, 0.18049736f, -0.09652758f, -0.46453696f, -1.07547021f, -0.88608253f, -0.27202120f, 0.50354171f, 
    -0.61415845f, 0.49110609f, 0.12340032f, -0.19881080f, 0.16181231f, 0.58682650f, -0.23362294f, 0.33876497f, 
    -0.26715806f, 0.17609958f, -0.21918504f, 0.14995980f, -0.05842460f, -0.56209302f, -0.42014593f, 0.02970554f, 
    -0.17061606f, -0.14369161f, 0.19430044f, -0.19143231f, -0.51980752f, -1.21517551f, 0.18299690f, 0.21299286f, 
    -0.16968097f, -0.14266258f, 0.65682596f, -0.48695812f, 0.62096232f, -0.14949879f, 0.54806149f, -0.03469622f, 
    -0.13311198f, 0.61756217f, -0.33047548f, 0.05659693f, -0.05499010f, -0.21057881f, 0.16605434f, -0.09080838f, 
    0.01933648f, 0.02151792f, -0.03869058f, -0.28593677f, 0.55543351f, -0.53965425f, -0.52122027f, 0.93204296f, 
    0.89069706f, -0.48299402f, -0.84600073f, 0.40474400f, 0.85197425f, 0.07812385f, -0.00203220f, -0.12141730f, 
    -0.08744460f, -0.49664116f, 0.07495751f, -0.28734502f, 0.26119447f, 0.10357910f, -0.28719315f, -0.22689295f, 
    0.04851902f, -0.40615302f, -0.00771353f, 0.39264581f, -0.10856044f, -0.06600032f, -0.60343158f, -0.88405007f, 
    -0.79404694f, -0.81539172f, -0.46779075f, 0.41029024f, 0.61910772f, 0.21660049f, 0.42392135f, 0.74465621f, 
    -0.17684418f, -0.48060611f, 0.18452486f, -0.05027738f, 0.13854899f, -0.13749684f, -0.22567758f, -0.19644415f, 
    -0.15686367f, -0.10012549f, 0.17964160f, 0.10265415f, -0.07832260f, 0.44274962f, 0.30537868f, -1.07672727f, 
    1.13847530f, 0.34537068f, -0.90953195f, 0.67236692f, 0.31301969f, -0.55331123f, -0.73073214f, -0.29694560f, 
    -0.50669986f, 0.18381254f, 0.08940834f, -0.35576868f, -0.12424912f, -0.06162444f, 0.22431751f, 0.32459301f, 
    -0.40438497f, -0.31110069f, -0.30329874f, 0.07101612f, 0.50840044f, 0.41694462f, 0.37300366f, -0.31013900f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.22676496f, 0.42046082f, 0.06608669f, 0.35870174f, 0.40985641f, -0.13061753f, 0.26105058f, 0.18302333f, 
    0.07039797f, 0.31252566f, -0.05978838f, 0.13933027f, 0.33876738f, 0.23089458f, 0.13296576f, -0.03482996f, 
    0.18936259f, 0.34198803f, 0.31556529f, 0.19155686f, 0.21185087f, 0.13056138f, 0.25508556f, 0.44171301f, 
    0.09754168f, 0.17732164f, 0.32855356f, 0.16650459f, 0.15686835f, 0.14146483f, 0.07920387f, 0.30069232f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.25831589f, -0.11283409f, 0.07018210f, 0.28937936f, -0.09370044f, -0.10451529f, -0.15546414f, -0.07567814f, 
    -0.01234523f, -0.00203266f, 0.22257225f, -0.11616854f, -0.01021269f, 0.01059779f, -0.04744287f, -0.16793759f, 
    -0.22209866f, -0.12979439f, 0.03047294f, 0.03728015f, -0.07410272f, 0.01898860f, 0.04893751f, 0.07479189f, 
    0.05758724f, 0.04300505f, 0.45959747f, -0.09815077f, -0.10020255f, -0.00677578f, 0.11358351f, -0.25990483f, 
    0.19405304f, 0.02413067f, -0.06378272f, -0.19966985f, 0.31402376f, -0.14124995f, -0.16332692f, 0.45884955f, 
    -0.15355124f, -0.02490266f, 0.05951699f, 0.04212730f, -0.15617728f, 0.15541220f, -0.08025346f, 0.10994460f, 
    0.04679078f, -0.07280868f, -0.16422324f, 0.26972750f, -0.16471717f, -0.16179043f, -0.06802777f, -0.00038672f, 
    -0.13734148f, 0.11341116f, 0.06907686f, -0.18201181f, -0.19708197f, 0.04673399f, -0.00126696f, -0.52569675f, 
    0.13669422f, -0.07174224f, -0.01619632f, -0.16604847f, 0.06459595f, 0.01492556f, -0.04405450f, -0.02503703f, 
    0.25179976f, 0.12585199f, -0.20753068f, 0.06188284f, 0.05290908f, 0.16163284f, 0.06521746f, -0.04925021f, 
    -0.04143394f, 0.00166358f, -0.04904085f, 0.01266976f, 0.08775247f, -0.24090321f, -0.09568398f, -0.11941659f, 
    -0.06747209f, -0.06333153f, -0.09327115f, 0.08315163f, 0.05798531f, 0.04693577f, 0.07379004f, -0.04191722f, 
    -0.19782037f, 0.18842411f, 0.13691825f, -0.05342341f, -0.31413063f, -0.01917159f, 0.11235792f, 0.12973776f, 
    0.11481716f, -0.06649505f, 0.04930061f, -0.05241685f, -0.14097081f, 0.11518389f, -0.10812148f, 0.14724381f, 
    0.13026257f, 0.03547686f, -0.10258301f, -0.13512242f, 0.07613346f, -0.17117020f, 0.02959470f, -0.09842957f, 
    0.10981960f, 0.07417379f, 0.16359630f, 0.22902207f, -0.14354771f, -0.01196140f, 0.10332917f, -0.10320348f, 
    0.00177709f, -0.07907116f, -0.05120704f, -0.09373077f, 0.58695191f, 0.05869730f, -0.00953403f, -0.12850478f, 
    -0.05576000f, 0.04954974f, 0.08142792f, -0.05138706f, -0.03490831f, 0.05855534f, -0.02341460f, -0.11108736f, 
    0.24482034f, 0.11716677f, -0.08158532f, -0.03665122f, -0.34141883f, -0.26807231f, 0.01842629f, 0.02682269f, 
    -0.11733964f, -0.06821194f, -0.21499327f, -0.02400209f, -0.21730091f, 0.06429170f, 0.13545184f, -0.42506996f, 
    -0.11299050f, -0.02204872f, 0.01747639f, -0.13503875f, -0.32759553f, 0.08028544f, -0.03524014f, 0.07381183f, 
    -0.31312469f, -0.01907272f, 0.01396439f, 0.00071823f, 0.09869938f, 0.06491674f, 0.13526176f, 0.05257704f, 
    0.13179176f, 0.02281774f, 0.16926467f, -0.15880921f, -0.50840956f, 0.01085158f, -0.10692094f, -0.06148680f, 
    -0.04030162f, -0.07319324f, 0.02341178f, -0.25395465f, 0.07250051f, -0.02624241f, 0.10669582f, 0.08004661f, 
    -0.08440378f, -0.21777968f, -0.06785398f, -0.21220164f, -0.01027389f, -0.12766866f, 0.11712677f, 0.00951706f, 
    -0.05628082f, 0.00631901f, -0.04661635f, 0.01293697f, -0.77994686f, 0.12664036f, 0.04312582f, -0.12966488f, 
    -0.12602714f, 0.10858023f, 0.00609298f, -0.13065581f, -0.01168739f, 0.01186637f, -0.12227216f, 0.13641828f, 
    -0.18153235f, 0.09337503f, 0.34486434f, 0.03648087f, 0.02315311f, 0.01758083f, -0.04133023f, 0.06256017f, 
    0.09605648f, -0.05040609f, 0.06791747f, 0.11975094f, 0.38199827f, 0.37312159f, 0.13720486f, -0.30130681f, 
    0.20613541f, -0.05632531f, -0.02725072f, 0.08752906f, -0.03057468f, 0.01026841f, -0.07590398f, 0.06958538f, 
    -0.46203980f, 0.26651570f, -0.11625504f, 0.08571370f, 0.04352906f, -0.01421862f, -0.11733509f, 0.01325061f, 
    0.05467365f, -0.08001429f, -0.03089845f, 0.00444151f, 0.42087746f, -0.12316069f, -0.22311236f, -0.25515881f, 
    0.10622776f, -0.12504055f, -0.03105153f, 0.02620049f, -0.03885638f, -0.05162258f, -0.09812687f, 0.15818056f, 
    0.13881305f, 0.00591843f, 0.15119442f, 0.00635825f, -0.14295751f, -0.11117788f, 0.05966229f, -0.00230729f, 
    0.02689530f, -0.02741700f, 0.03017131f, -0.17958774f, -0.31102014f, -0.07298475f, 0.12904947f, -0.08845711f, 
    -0.04619802f, -0.00953201f, 0.08044548f, 0.05460344f, 0.03418695f, -0.10044507f, 0.13264425f, -0.06686044f, 
    -0.50004166f, -0.20842269f, -0.32973111f, 0.28083050f, -0.02436617f, 0.07400285f, -0.08615965f, 0.03065476f, 
    -0.10314085f, 0.02854828f, -0.13053770f, 0.12994862f, -0.12545109f, 0.06970780f, 0.18310982f, -0.06137132f, 
    -0.15790531f, 0.01856252f, -0.01991177f, 0.03402726f, 0.09916270f, -0.12491254f, -0.02915209f, 0.06228478f, 
    0.20880669f, -0.26783311f, 0.03699434f, -0.16336042f, 0.00828905f, 0.08095362f, 0.09743110f, 0.00422017f, 
    -0.08085391f, -0.00032674f, 0.07876381f, -0.16746365f, -0.48145613f, 0.17000306f, -0.16130754f, 0.07059075f, 
    0.09271852f, -0.07408689f, -0.16181518f, -0.15510373f, -0.15572530f, 0.15338019f, -0.04293608f, -0.00375544f, 
    -0.23609948f, 0.02541940f, 0.02759956f, 0.17138706f, -0.15278001f, -0.08578541f, 0.08694910f, 0.08140406f, 
    -0.00942299f, 0.22099054f, -0.35799333f, -0.00354199f, -0.22347891f, -0.09157823f, 0.03112599f, 0.44088247f, 
    -0.04701778f, 0.08732533f, 0.05283248f, -0.03051284f, 0.16869125f, -0.04715999f, -0.01104990f, 0.06478257f, 
    0.28917935f, 0.19852301f, -0.08494824f, -0.33712402f, 0.14127707f, 0.03811840f, 0.06657607f, 0.05553539f, 
    0.10430205f, 0.02118618f, 0.00311245f, 0.11676001f, -0.60369575f, 0.14594862f, 0.16678061f, -0.18331245f, 
    0.04394863f, 0.05552187f, -0.00974620f, -0.06212707f, 0.02388632f, -0.02846980f, -0.06722709f, 0.07457054f, 
    -0.24228793f, -0.48771426f, 0.10780112f, 0.01722994f, 0.04470506f, 0.04061158f, 0.04572122f, 0.11334813f, 
    -0.04591114f, 0.08657715f, -0.08536078f, -0.07793662f, 0.27205351f, -0.08997366f, 0.12350511f, 0.14771576f, 
    -0.15209831f, -0.09446549f, -0.01020119f, 0.12181726f, -0.03805970f, 0.00697619f, -0.18456791f, 0.05936512f, 
    0.14715312f, 0.04116178f, -0.08476984f, -0.11473774f, 0.13337973f, -0.00176074f, 0.01333155f, -0.06302892f, 
    0.04912486f, -0.06169489f, 0.00373685f, 0.06296521f, 0.42908797f, -0.01960989f, 0.19405441f, 0.38518980f, 
    -0.16668835f, 0.05766094f, -0.07847101f, 0.08653180f, 0.01869426f, -0.12110136f, 0.03256920f, -0.13032992f, 
    0.14004077f, 0.20412639f, 0.20623048f, 0.20637010f, -0.09936503f, 0.14553955f, 0.03600084f, -0.05407951f, 
    0.06173453f, -0.26246083f, -0.17167149f, -0.04838235f, 0.28628159f, -0.43483901f, -0.18777390f, -0.37204698f, 
    0.07352302f, -0.19526049f, -0.03652990f, 0.09357741f, 0.06766091f, -0.17975490f, -0.00996174f, -0.04443208f, 
    -0.08651005f, -0.24434805f, -0.29871300f, 0.03699606f, 0.12507819f, -0.08578854f, -0.02288899f, -0.00005526f, 
    0.07120899f, 0.03451880f, -0.01316050f, 0.15333049f, 0.20762676f, 0.07430450f, 0.10770822f, 0.05124407f, 
    -0.04843534f, -0.04785923f, 0.05283826f, -0.00822134f, 0.04806970f, -0.12115113f, 0.05374308f, 0.05812877f, 
    -0.15236722f, -0.09220555f, 0.12031293f, 0.02222212f, -0.14336039f, -0.00388535f, -0.08809199f, -0.06333929f, 
    0.06751145f, 0.03874426f, -0.12154905f, 0.14307337f, -0.22642960f, 0.11006752f, -0.28641838f, 0.39640695f, 
    -0.25976178f, 0.00641454f, -0.03467661f, -0.06446607f, 0.09078521f, 0.20622979f, -0.22222809f, 0.06743845f, 
    -0.19793287f, 0.22601636f, 0.00803944f, 0.20440717f, 0.04762590f, 0.18202759f, 0.06244082f, -0.04487285f, 
    -0.07616069f, 0.10778622f, 0.10246661f, -0.04915500f, -0.80614680f, 0.01868338f, -0.00213885f, -0.09971643f, 
    -0.00245840f, -0.14666016f, -0.09468664f, -0.16120982f, 0.02760734f, -0.02552590f, -0.08994018f, -0.18270114f, 
    0.11874978f, 0.08882098f, 0.27272901f, 0.29170650f, -0.09404758f, -0.00099045f, 0.10655943f, 0.01461083f, 
    -0.01735770f, 0.08577152f, 0.16351409f, 0.07602037f, 0.22884908f, 0.05205562f, 0.01668126f, -0.36439264f, 
    0.07650746f, -0.04565424f, -0.04664149f, -0.00391052f, -0.21451075f, -0.09219037f, -0.06103831f, 0.02496384f, 
    -0.11040545f, -0.28706327f, -0.10012198f, 0.09922779f, -0.04569425f, -0.16669175f, 0.10080666f, 0.03278069f, 
    0.12934351f, 0.07347381f, -0.00944853f, 0.13248858f, 0.31006148f, -0.32086527f, -0.06166787f, 0.01944926f, 
    -0.08774284f, 0.08083221f, -0.06788633f, 0.07982992f, 0.06760255f, -0.26327664f, -0.31124011f, 0.04705020f, 
    -0.04105837f, 0.01734626f, 0.17724842f, -0.26354766f, 0.01754551f, -0.09100554f, 0.07469161f, -0.03017700f, 
    0.02039145f, -0.03887510f, 0.12949820f, 0.00561011f, 0.20192750f, -0.13334808f, 0.00001413f, -0.18170533f, 
    -0.02804640f, -0.04987661f, -0.11302342f, 0.20756216f, -0.10465516f, 0.01286102f, 0.04776878f, -0.18224497f, 
    -0.50643891f, 0.16657181f, -0.47955108f, -0.32550514f, -0.11789224f, 0.14335060f, 0.02055015f, 0.11536852f, 
    0.03780674f, -0.10513457f, -0.13911581f, -0.14668538f, 0.26785624f, 0.06628241f, -0.29972920f, -0.35367957f, 
    0.10835435f, 0.20152797f, 0.05749974f, 0.06488169f, 0.30277127f, 0.07310515f, 0.00612042f, -0.03134449f, 
    0.23517993f, -0.15394552f, 0.06411195f, 0.14879361f, -0.20368421f, 0.09591170f, -0.02769110f, 0.01003673f, 
    -0.08218149f, 0.00636753f, 0.18472639f, -0.00997052f, 0.26385239f, -0.25630313f, 0.29468012f, -0.13211334f, 
    0.05124689f, -0.05707797f, -0.17308265f, -0.01112608f, -0.07083995f, 0.04914381f, 0.04908155f, -0.03322903f, 
    0.34939036f, -0.05923435f, 0.00536556f, 0.07983166f, -0.12425485f, -0.05653410f, 0.03233340f, 0.07124917f, 
    -0.07865410f, -0.03398934f, -0.12296379f, -0.00266917f, 0.58289534f, -0.36856049f, -0.17007315f, -0.30433545f, 
    -0.09245468f, -0.09183772f, -0.04932837f, 0.02314253f, -0.22379442f, 0.13808891f, -0.11387234f, 0.13646652f, 
    -0.09676672f, 0.00762393f, 0.07723355f, 0.00842382f, -0.06074228f, 0.02086418f, -0.16108383f, 0.05077977f, 
    -0.01454087f, -0.10651430f, 0.00227614f, -0.07265241f, 0.19735004f, 0.16989078f, -0.18828274f, 0.11740438f, 
    0.19722696f, 0.10689887f, -0.12267491f, 0.12020724f, -0.05040279f, 0.22071795f, -0.01283903f, 0.03424259f, 
    -0.03713497f, 0.00525269f, 0.01192173f, -0.09534474f, -0.06679366f, -0.14759146f, 0.01378803f, 0.06916629f, 
    0.06482114f, -0.04853232f, -0.02841056f, 0.17272650f, 0.47567034f, -0.09804620f, -0.09484541f, -0.02703150f, 
    -0.02752678f, 0.01981753f, -0.02398288f, 0.06490584f, 0.13038750f, -0.21237496f, 0.00504582f, -0.00872294f, 
    0.00806863f, -0.07142555f, -0.20319727f, 0.10961180f, -0.00261629f, 0.03421423f, 0.03125209f, 0.31594509f, 
    -0.00749855f, 0.04023810f, 0.10946821f, 0.02129309f, -0.32540196f, 0.16117156f, -0.25339463f, 0.16066588f, 
    -0.14481169f, -0.12668179f, -0.07796643f, -0.25074360f, -0.09225901f, -0.09307285f, -0.16491468f, -0.05675755f, 
    0.04974504f, -0.19771919f, 0.00170683f, -0.16541551f, 0.02207025f, -0.12619019f, -0.06312458f, 0.07288420f, 
    0.03980947f, -0.01371958f, -0.09728558f, 0.11513184f, -0.18077338f, -0.18799879f, -0.22607636f, -0.37071997f, 
    0.02432814f, 0.01367909f, 0.07029989f, -0.17997913f, 0.15740700f, 0.24835259f, -0.00153050f, -0.09958109f, 
    0.54835236f, -0.14081241f, -0.12918627f, -0.13168132f, -0.01781780f, 0.12827328f, -0.02576500f, -0.12135565f, 
    -0.12389983f, -0.00858394f, 0.11742019f, -0.19693045f, 0.02570559f, 0.02888223f, -0.04930149f, -0.21057937f, 
    -0.05171360f, -0.20004652f, 0.18622205f, -0.05144694f, -0.02781058f, -0.00820756f, 0.06780971f, -0.09821977f, 
    0.22218344f, 0.05421820f, 0.04124028f, 0.06521817f, 0.01940981f, 0.08821683f, 0.12698856f, -0.09305303f, 
    -0.07941682f, 0.04024689f, -0.02048692f, 0.03452695f, -0.13838288f, 0.03602299f, 0.05743428f, -0.05585176f, 
    0.06473267f, 0.11327215f, 0.01466947f, -0.01790248f, 0.07065713f, 0.10453081f, -0.08684395f, -0.00765187f, 
    0.07587934f, 0.01551529f, -0.17682078f, -0.05365709f, -0.15259074f, 0.09561264f, 0.05459816f, -0.10732533f, 
    -0.13858874f, 0.09482861f, 0.07514867f, -0.07100071f, 0.06722643f, 0.30904013f, -0.06724335f, 0.11315534f, 
    -0.21527736f, -0.14688459f, 0.13784681f, 0.13288894f, -0.03348751f, -0.00827129f, -0.21857193f, -0.08724037f, 
    0.24056314f, -0.04422623f, 0.09827357f, 0.05710046f, -0.16991390f, -0.11218833f, -0.06674963f, 0.06662379f, 
    -0.16475463f, -0.03572399f, -0.03257697f, -0.05542971f, -0.13644059f, 0.05939614f, -0.00740385f, -0.02787074f, 
    -0.04986666f, 0.09264781f, 0.02370868f, 0.02312481f, -0.01141739f, 0.11132998f, -0.04992256f, -0.04194270f, 
    0.25133353f, -0.03847590f, -0.20610785f, -0.11210778f, 0.12460005f, 0.11323532f, 0.05610763f, 0.03066328f, 
    0.00914639f, -0.05975839f, -0.04316049f, -0.13999604f, -0.06902528f, -0.08876257f, -0.31280440f, -0.22961676f, 
    -0.17555884f, 0.03214260f, -0.20357190f, 0.03903522f, 0.17130698f, -0.25929853f, -0.08866820f, -0.11904498f, 
    0.43596670f, 0.08347060f, 0.00447465f, -0.06259301f, -0.07426218f, -0.02837019f, -0.00602235f, 0.00783696f, 
    0.01602406f, 0.17548233f, 0.05026757f, -0.05532700f, 0.33438870f, -0.00859452f, 0.12822105f, -0.03314836f, 
    0.10894251f, 0.12176358f, 0.13989846f, 0.00101393f, -0.10523965f, 0.11184996f, 0.11262987f, -0.16601971f, 
    0.02137078f, 0.07311223f, -0.06641714f, -0.15079227f, 0.09444074f, 0.09640887f, 0.07630389f, -0.01522919f, 
    -0.01203311f, -0.03128815f, -0.02959100f, -0.07961939f, -0.30343357f, 0.05924943f, -0.01411054f, -0.32866389f, 
    -0.14917876f, -0.12251230f, 0.15921849f, -0.07810879f, 0.01552040f, 0.00635594f, -0.12967429f, -0.01712853f, 
    -0.52183145f, -0.10117614f, -0.44698304f, -0.17686468f, -0.19173789f, -0.00862989f, -0.24324746f, -0.16406240f, 
    -0.00417694f, -0.02532152f, 0.00177399f, -0.01758965f, 0.25433525f, 0.07197426f, 0.10516535f, 0.28146046f, 
    -0.08295057f, -0.17172188f, 0.15732786f, 0.08991709f, -0.03315693f, -0.02329111f, 0.19171764f, -0.07089225f, 
    0.05323884f, -0.17442478f, -0.25878209f, 0.23471445f, -0.10366888f, 0.04025408f, -0.04479571f, -0.04103589f, 
    0.11394612f, 0.01509532f, -0.15387434f, 0.07217866f, -0.44220123f, 0.08622305f, -0.25771305f, -0.20234779f, 
    -0.16732189f, 0.02104547f, 0.06977160f, 0.00232138f, -0.05159151f, -0.04711426f, -0.15175188f, -0.03978198f, 
    0.47080332f, -0.03470085f, -0.26398376f, -0.38320690f, -0.01743341f, 0.03035104f, -0.02376518f, 0.06145013f, 
    0.08752812f, 0.06473695f, 0.01671240f, -0.18883115f, 0.02293653f, 0.14161015f, -0.05832145f, 0.23307112f, 
    -0.01341118f, -0.20157616f, -0.10987598f, 0.03765954f, -0.12430845f, -0.03404805f, 0.08548450f, 0.07662828f, 
    0.69069517f, -0.36430681f, 0.13908808f, 0.18826975f, -0.07852726f, -0.01132824f, -0.03996872f, 0.00095658f, 
    -0.01609555f, -0.00420083f, -0.01661857f, -0.02696885f, 0.09666895f, 0.09684083f, -0.03834520f, 0.12390666f, 
    0.03760904f, -0.06311975f, 0.15973298f, 0.16348238f, -0.07221451f, -0.12453759f, 0.09870634f, -0.08574283f, 
    -0.04639338f, -0.00150867f, -0.07881568f, -0.01612681f, 0.24939978f, 0.01852736f, 0.10526512f, -0.10587681f, 
    0.02287512f, -0.02136996f, -0.13109894f, -0.01738883f, 0.08804755f, -0.18999763f, 0.03931916f, -0.23696063f, 
    -0.12369421f, -0.11006800f, 0.12796968f, 0.01558797f, -0.09639400f, -0.04054692f, -0.02856422f, -0.00189224f, 
    0.23897608f, -0.19009368f, -0.33914754f, -0.22500433f, -0.08200488f, -0.09663644f, -0.14833297f, 0.11262197f, 
    0.10407482f, 0.13752252f, 0.04006429f, -0.10639647f, -0.05930094f, -0.21584539f, -0.21400768f, -0.06519714f, 
    0.07129960f, 0.02525835f, 0.08991501f, -0.17996709f, 0.06980778f, 0.03962322f, 0.00403076f, 0.11351845f, 
    -0.03988554f, -0.06719433f, 0.12695919f, -0.20204903f, -0.06827578f, -0.08603303f, -0.10851008f, 0.02576420f, 
    -0.03250266f, 0.08262048f, -0.08210032f, 0.03773381f, 0.51958859f, -0.30423227f, 0.09384930f, 0.05509676f, 
    -0.24689882f, 0.10258471f, -0.12393433f, -0.01254303f, -0.14196543f, 0.02471153f, -0.02036635f, -0.04626681f, 
    0.44800788f, -0.24618714f, -0.10929140f, -0.03838491f, -0.34945062f, -0.01144553f, -0.00330009f, 0.03039449f, 
    -0.09879918f, 0.00615011f, -0.04071629f, -0.13243677f, 0.18157960f, 0.02850294f, -0.40905571f, 0.09518144f, 
    -0.17617117f, -0.06004164f, -0.09375747f, 0.09160008f, -0.06115226f, 0.11488342f, 0.06368650f, 0.02280483f, 
    0.19696546f, 0.27460536f, 0.28081569f, 0.34000164f, -0.14939012f, -0.24027452f, -0.07803541f, 0.03915891f, 
    -0.00892656f, 0.05909624f, -0.05864286f, 0.03855801f, 0.16322540f, -0.19232200f, -0.26622739f, -0.19135186f, 
    -0.01658373f, 0.12485556f, -0.08128860f, -0.12777704f, -0.05237558f, -0.07264297f, -0.02651992f, -0.12816282f, 
    -0.00235450f, 0.13493812f, 0.33618668f, 0.21865638f, 0.08284918f, 0.11309470f, -0.02146979f, -0.11570366f, 
    0.04829487f, 0.06782824f, -0.04372340f, -0.13343987f, 0.17841530f, -0.38848203f, -0.33768576f, -0.16576618f, 
    -0.06540571f, -0.00306017f, -0.04120595f, 0.05292983f, -0.04414021f, 0.01299682f, 0.15816961f, -0.08767664f, 
    0.53187990f, 0.27939823f, -0.28366897f, -0.00579387f, -0.22515066f, 0.05268416f, -0.15612969f, 0.16042660f, 
    0.16620992f, -0.00114279f, -0.08245220f, 0.07879194f, -0.34974691f, -0.30931878f, -0.23158468f, -0.06040196f, 
    -0.03815609f, 0.04388862f, -0.00551916f, -0.02814313f, 0.01257563f, -0.00200542f, 0.04533417f, 0.10436763f, 
    -0.64361978f, -0.11549332f, -0.31247824f, 0.23771293f, 0.00528157f, 0.22499101f, 0.06370817f, -0.09606969f, 
    -0.03435712f, 0.11564715f, 0.09970967f, 0.07421254f, -0.07222583f, -0.03646173f, -0.05822486f, 0.08978014f, 
    -0.06100183f, 0.03302146f, -0.02749828f, -0.00447648f, -0.00410906f, 0.06576510f, 0.03510780f, 0.18747754f, 
    0.15310244f, 0.03880046f, -0.21450733f, -0.25387469f, -0.07488975f, -0.06022372f, 0.04722648f, -0.11265536f, 
    0.06961448f, -0.09422602f, -0.04167658f, -0.06784634f, -0.25457278f, -0.28363585f, -0.39653501f, 0.24979526f, 
    -0.09571198f, -0.01426123f, 0.06958463f, -0.03490607f, -0.05624858f, -0.03665981f, -0.11880516f, -0.05779418f, 
    0.28508526f, 0.25886032f, -0.08590806f, 0.30123332f, -0.11873733f, 0.00725793f, 0.07558783f, 0.08343399f, 
    -0.20109876f, -0.02137690f, 0.05942135f, -0.11466918f, 0.17552847f, 0.00439175f, 0.15153076f, 0.04344053f, 
    0.09978728f, 0.01906544f, 0.03987445f, -0.15300585f, -0.09799539f, -0.22776341f, 0.06161352f, 0.02851486f, 
    -0.51490504f, -0.00839886f, -0.17588994f, -0.21714793f, 0.03495039f, -0.08591591f, 0.07782935f, -0.00252341f, 
    0.19233152f, 0.09175301f, 0.05681539f, -0.00880063f, -0.03695670f, 0.31041986f, 0.06041345f, -0.29043400f, 
    0.03480559f, 0.18621983f, -0.15553823f, 0.10245833f, -0.01890960f, -0.14802235f, 0.04315615f, -0.05565140f, 
    -0.27053955f, -0.84664983f, -0.25147286f, 0.32110092f, -0.04410214f, -0.10665541f, -0.04768834f, -0.02521990f, 
    -0.07762595f, -0.15470403f, -0.07160588f, -0.08698075f, -0.02413659f, -0.19982794f, 0.01134225f, 0.08743072f, 
    -0.09372931f, -0.06542338f, 0.03175299f, 0.12482985f, -0.07000807f, 0.03117314f, -0.09042792f, -0.03204261f, 
    0.09301824f, -0.01440449f, 0.16317841f, 0.04686127f, -0.08815510f, 0.02609704f, 0.03496437f, 0.22562841f, 
    0.05015627f, -0.02977748f, 0.07217795f, 0.07914587f, 0.06796564f, -0.29561415f, 0.06849226f, 0.04497621f, 
    0.08741000f, 0.09768111f, 0.00578569f, 0.08503266f, -0.06321509f, 0.06189823f, 0.02053190f, -0.00067624f, 
    0.02434764f, -0.03258567f, -0.11751415f, 0.02863978f, -0.17329955f, -0.10238592f, -0.02231017f, -0.00905656f, 
    0.04294580f, 0.07985426f, 0.06250680f, 0.14573589f, 0.06567451f, -0.17431901f, 0.05610405f, -0.07698505f, 
    -0.09559022f, -0.03190394f, 0.12772748f, 0.02760225f, -0.04619306f, 0.02187928f, -0.02029984f, 0.09420406f, 
    -0.07227629f, 0.45038143f, 0.24231537f, -0.04061082f, -0.03088207f, -0.06804802f, -0.04675540f, -0.19641100f, 
    0.02154913f, 0.08104233f, -0.01918641f, 0.09300223f, -0.42449167f, 0.07924351f, 0.05922704f, -0.16363642f, 
    -0.12328127f, -0.11477195f, 0.13246688f, 0.01675937f, 0.02718914f, -0.09919092f, -0.10103194f, -0.04488220f, 
    -0.12886736f, -0.05490877f, 0.27115080f, 0.05449679f, -0.02662449f, 0.10477582f, 0.14795640f, -0.01819628f, 
    -0.00632923f, -0.04194176f, -0.25927737f, 0.10041897f, -0.30469048f, -0.15635417f, -0.05943333f, -0.13773043f, 
    -0.16298456f, 0.05019431f, 0.01067245f, 0.03986404f, 0.03261272f, 0.08862468f, 0.03790463f, -0.03947728f, 
    -0.50486416f, -0.68235475f, -0.50585288f, 0.16442567f, -0.20435786f, 0.00193648f, 0.00915332f, -0.20518884f, 
    -0.12620714f, 0.03822185f, 0.00744288f, 0.12094911f, 0.13004604f, -0.30797052f, 0.04737011f, -0.17603172f, 
    -0.15419637f, 0.12951453f, -0.03721865f, 0.10513674f, -0.06562056f, -0.05571064f, -0.00722052f, 0.03831093f, 
    0.05068381f, 0.29242757f, 0.15378478f, -0.06297213f, -0.01250567f, -0.19783637f, -0.01595588f, -0.01379417f, 
    -0.06620245f, -0.03387480f, 0.01775433f, 0.17790884f, -0.45584011f, 0.12483725f, 0.04316865f, 0.02888721f, 
    -0.04483066f, -0.12141408f, 0.04851114f, -0.03648990f, -0.06992380f, 0.12696046f, 0.06556856f, -0.10701764f, 
    0.13662477f, 0.32464001f, 0.08641338f, -0.14003332f, -0.06815177f, -0.15237913f, 0.08777039f, 0.13600306f, 
    -0.00505714f, -0.08282931f, -0.09812056f, 0.05136220f, 0.08517668f, 0.00436823f, -0.06610484f, 0.22270906f, 
    -0.06635807f, 0.00878188f, -0.05275707f, -0.01966055f, 0.00202368f, 0.25666982f, -0.03505845f, 0.13094261f, 
    -0.02840832f, 0.08821281f, -0.02574544f, 0.11191189f, 0.01977380f, -0.12276090f, 0.11721144f, -0.10966859f, 
    -0.00913032f, -0.06436922f, 0.09740421f, 0.03743368f, -0.12307219f, 0.27084324f, 0.07773109f, -0.02830992f, 
    0.00106324f, -0.00160277f, -0.06877533f, 0.15365861f, -0.20951216f, -0.03846450f, 0.03273833f, 0.00616679f, 
    0.12211519f, 0.08410284f, -0.05228537f, -0.13921882f, -0.11140661f, -0.04421667f, 0.09450455f, -0.20220913f, 
    -0.17269067f, -0.08471648f, 0.02223335f, -0.08084776f, 0.65507472f, 0.20400903f, 0.08385151f, 0.02587116f, 
    0.21524355f, -0.01442050f, -0.13386817f, 0.17574854f, 0.05438616f, -0.01749449f, -0.07145518f, -0.18075547f, 
    -0.35991764f, -0.21164683f, 0.20397580f, 0.05001840f, 0.03231008f, -0.09362990f, 0.01577920f, 0.01715902f, 
    0.06090375f, 0.08439077f, -0.04348145f, -0.03125870f, 0.27262965f, -0.31620398f, -0.00635889f, 0.00045732f, 
    -0.07302634f, -0.14759274f, 0.05353874f, -0.27647167f, -0.07776168f, 0.11840934f, 0.02068405f, -0.06403204f, 
    0.38244981f, -0.15615916f, -0.36608338f, 0.16288246f, -0.04295457f, 0.07869067f, 0.02123849f, 0.00757229f, 
    -0.03773783f, -0.11156981f, -0.04825545f, 0.01150717f, 0.10793493f, 0.28765455f, 0.02510029f, 0.04165813f, 
    -0.03419147f, 0.02434677f, 0.09578636f, -0.01488173f, 0.01790963f, -0.03243619f, -0.06542475f, 0.04585163f, 
    -0.37533632f, 0.16179442f, 0.08544316f, 0.02669754f, 0.01457569f, 0.08068383f, -0.00858247f, 0.12221550f, 
    -0.09155962f, 0.20246163f, -0.02937878f, 0.08348035f, -0.31427577f, -0.00413709f, 0.40836444f, 0.04174979f, 
    -0.19820400f, 0.08994437f, -0.01266976f, -0.01622807f, 0.02087224f, 0.19155788f, 0.16548173f, -0.03938293f, 
    0.05929171f, 0.04345774f, 0.13670717f, 0.07828461f, -0.01246601f, 0.12175273f, -0.03499341f, 0.06373157f, 
    -0.06835095f, -0.14879499f, 0.08933423f, -0.18895723f, -0.21193860f, -0.32121861f, 0.00401038f, -0.06179352f, 
    -0.17702213f, 0.06504950f, -0.20487542f, 0.07130107f, 0.12698233f, -0.09700102f, -0.00693673f, -0.01945408f, 
    -0.31226775f, 0.25504717f, -0.03207989f, -0.16894542f, 0.08727220f, -0.13578531f, -0.04752123f, 0.00524853f, 
    -0.02999181f, 0.02397862f, 0.01458805f, -0.08973675f, -0.35020345f, 0.01382794f, -0.05957049f, -0.54372662f, 
    0.13752303f, -0.08307058f, 0.02099535f, 0.06194752f, -0.05729359f, -0.22696224f, 0.10039423f, 0.11270443f, 
    -0.04823316f, 0.42348951f, -0.19542769f, -0.03511480f, 0.06973688f, -0.06217671f, 0.26265174f, 0.17682116f, 
    0.00282287f, 0.02744239f, 0.03202465f, 0.03800246f, 0.29401228f, 0.19585299f, 0.21059723f, 0.20103225f, 
    0.04392205f, -0.08085702f, 0.08811392f, 0.16183594f, 0.01757481f, 0.23794213f, 0.18901040f, 0.15992720f, 
    -0.31716767f, -0.04051662f, 0.18872069f, 0.12498229f, -0.10392174f, 0.06199597f, -0.18790314f, 0.01135110f, 
    0.04844260f, -0.10078523f, -0.06820279f, -0.03269140f, -0.06203092f, -0.09026109f, 0.11926558f, 0.06096113f, 
    0.09855317f, 0.14844851f, 0.09851189f, -0.01292781f, 0.07804880f, 0.15222898f, -0.03459787f, 0.06914897f, 
    -0.00133371f, 0.22604704f, -0.01675978f, -0.00726466f, -0.05825810f, 0.02135000f, -0.03716885f, 0.06393057f, 
    -0.03179329f, -0.10461894f, 0.07415430f, -0.01823622f, -0.48569083f, -0.01191657f, 0.22383146f, 0.01451199f, 
    -0.00258523f, 0.13948292f, -0.05352354f, -0.08837821f, -0.13725075f, 0.12519471f, 0.24209645f, 0.03616672f, 
    0.22097155f, 0.03424801f, 0.12798733f, 0.34967422f, -0.01798360f, 0.03248893f, -0.02996908f, 0.17326099f, 
    0.19652550f, -0.05376050f, 0.04313950f, -0.01730175f, 0.12983865f, 0.03265378f, -0.01312822f, 0.00677641f, 
    0.01599168f, -0.10600686f, 0.07768492f, -0.07484472f, -0.03907759f, -0.02299802f, 0.05528963f, 0.01187965f, 
    0.05558523f, 0.02135061f, 0.02224527f, -0.38658008f, 0.03990699f, -0.14665611f, -0.04646439f, -0.10713460f, 
    -0.02779619f, -0.08622536f, 0.03179663f, -0.00951596f, -0.42883900f, -0.23224339f, -0.01857737f, 0.13116267f, 
    -0.03343311f, -0.10338241f, 0.02644507f, -0.04225880f, 0.03477901f, -0.12955149f, 0.02053644f, 0.13371502f, 
    -1.19039392f, 0.19216913f, -0.22498278f, -0.13963449f, 0.05575215f, -0.06186754f, -0.04293640f, -0.00189359f, 
    -0.10571498f, 0.05903507f, -0.06000997f, 0.05482930f, -0.42095476f, -0.03081535f, -0.06758985f, 0.25607952f, 
    -0.02937138f, 0.00917613f, 0.11304425f, -0.05493643f, -0.08440533f, -0.12726675f, 0.01169873f, 0.00718242f, 
    0.04332196f, 0.11218081f, 0.04098973f, 0.22422265f, -0.18093042f, -0.06314838f, -0.00162294f, 0.01214596f, 
    0.15568426f, 0.14286812f, -0.03103302f, -0.04382910f, -0.00027988f, 0.07905041f, -0.17314447f, -0.02159854f, 
    -0.02289463f, -0.07757677f, 0.05914983f, 0.03859920f, 0.01761303f, -0.04935754f, -0.02125369f, -0.16728306f, 
    -0.01810716f, -0.41007581f, 0.40013701f, -0.12129041f, 0.08763988f, 0.00092310f, -0.07038498f, 0.00508411f, 
    0.12376749f, -0.00686228f, -0.10595696f, 0.12930502f, 0.08861409f, 0.23479140f, -0.31755349f, 0.08802484f, 
    -0.05894461f, -0.14381357f, 0.11596283f, 0.05424488f, -0.10517069f, -0.06748091f, -0.05770735f, -0.10999283f, 
    0.01630091f, 0.04941019f, 0.03885643f, 0.07240191f, 0.07063904f, -0.01241094f, 0.08346428f, -0.02051933f, 
    -0.11143454f, 0.01067525f, -0.00428841f, 0.10806860f, -0.12439919f, 0.18317826f, -0.17926501f, -0.03331192f, 
    0.03713448f, -0.04262803f, -0.02280265f, 0.19179994f, 0.08322991f, -0.20794140f, 0.06465891f, 0.02315396f, 
    -0.24372381f, 0.22698677f, 0.03947843f, -0.21188505f, -0.05771744f, -0.05622285f, 0.01124522f, -0.06341077f, 
    0.11031245f, -0.05612066f, -0.11378968f, -0.24896480f, -0.29075232f, -0.28275687f, -0.06178276f, -0.07273576f, 
    0.08937693f, 0.20452832f, -0.09321715f, 0.11211427f, -0.08252294f, -0.02773290f, -0.07036465f, 0.01106331f, 
    -0.43255764f, -0.18975322f, -0.09646799f, 0.26911879f, 0.09535329f, 0.02233007f, -0.03927580f, 0.08757687f, 
    -0.06333391f, -0.11938741f, -0.05516968f, -0.06914832f, 0.30357549f, 0.25640348f, 0.08507715f, -0.02755154f, 
    -0.09499540f, -0.08815066f, -0.10989176f, -0.11961406f, -0.08256445f, 0.06636022f, 0.01319641f, -0.05197071f, 
    -0.05100599f, -0.00699710f, 0.01895569f, -0.07642002f, -0.08768054f, -0.00265141f, 0.09234750f, -0.08179433f, 
    0.04302533f, -0.19341429f, -0.04980958f, 0.33605510f, 0.14388818f, 0.02952029f, -0.07551192f, 0.08973795f, 
    0.01944859f, 0.09419226f, -0.17468098f, 0.06604253f, -0.11899301f, -0.07734781f, -0.08999855f, -0.04468792f, 
    -0.22114584f, 0.10828738f, 0.33201823f, 0.10644034f, 0.03896077f, -0.21512289f, 0.01255477f, -0.12523393f, 
    -0.00645226f, 0.08893052f, 0.01414997f, 0.08203109f, -0.16660592f, -0.10950707f, 0.18977647f, -0.33408105f, 
    0.02921062f, -0.15766953f, -0.16157433f, 0.10204686f, 0.19599341f, -0.06760836f, 0.03833215f, -0.08114917f, 
    0.10103873f, -0.11565042f, -0.03925668f, -0.04629787f, -0.01154138f, -0.18609294f, 0.01827764f, 0.08611286f, 
    0.08574917f, -0.19090062f, -0.28432447f, 0.01256481f, 0.18287903f, -0.07488653f, -0.11716733f, 0.08923475f, 
    -0.04045934f, 0.09010362f, 0.01616904f, -0.03591301f, 0.05781784f, -0.07226913f, -0.13145907f, 0.15927456f, 
    -0.26543096f, 0.06561597f, 0.06991511f, 0.01165168f, -0.02138054f, -0.03845589f, 0.11597466f, 0.00964171f, 
    0.14725018f, -0.00860640f, -0.04353848f, 0.16784222f, -0.00045786f, 0.17201835f, 0.17698540f, 0.12010138f, 
    0.07652904f, -0.07678792f, 0.10961875f, -0.12441360f, -0.03811431f, -0.08535534f, -0.07990737f, 0.19102611f, 
    0.11920276f, 0.09590852f, 0.04883048f, 0.32262129f, 0.05573690f, 0.24536015f, 0.07450557f, 0.01931548f, 
    -0.13853927f, 0.10003056f, 0.00016010f, 0.10927631f, -0.30886149f, 0.09847867f, 0.17758879f, 0.02420803f, 
    -0.02811097f, 0.20509182f, 0.11936255f, 0.08808897f, 0.00988656f, 0.32410577f, 0.14234541f, -0.12443308f, 
    -0.43653932f, -0.09584834f, 0.19701771f, -0.06947348f, 0.02583366f, -0.12764893f, -0.11979297f, 0.07543332f, 
    0.13002178f, -0.16048002f, -0.15196770f, -0.12195252f, 0.23914070f, -0.18301444f, -0.09675015f, 0.00305455f, 
    0.07876512f, -0.10721706f, -0.19985244f, -0.39969018f, -0.09469377f, -0.20179772f, -0.16760506f, 0.00615906f, 
    0.03195497f, -0.02509044f, 0.11405378f, 0.04032439f, 0.02524615f, 0.01840363f, 0.08018398f, -0.00628040f, 
    0.00377480f, 0.09821661f, 0.11412038f, 0.07276265f, -0.25983161f, -0.00322162f, 0.00279732f, 0.12419976f, 
    -0.14371535f, -0.05752919f, 0.04941114f, 0.14830442f, 0.31134129f, 0.02343209f, 0.07452548f, -0.07336697f, 
    -0.17765243f, 0.01295144f, -0.49992603f, 0.17615916f, 0.11477601f, -0.00662385f, 0.01476476f, -0.21101080f, 
    -0.10942093f, 0.16132991f, -0.05917462f, -0.03498263f, 0.17090669f, 0.01368866f, -0.21691172f, -0.13426267f, 
    -0.02473521f, -0.09419064f, 0.02626935f, 0.13629201f, 0.04051172f, -0.08401362f, -0.10075429f, -0.19854695f, 
    -0.35039514f, -0.33506411f, -0.04270334f, 0.00279184f, 0.21068770f, 0.13973932f, -0.08233245f, -0.07607284f, 
    -0.12445807f, 0.04964208f, 0.04084742f, 0.10615296f, -0.12002183f, 0.05450558f, -0.04318121f, 0.23412205f, 
    -0.05065621f, -0.00500836f, 0.16858928f, 0.12336955f, 0.11787060f, 0.18904735f, 0.13759996f, 0.06146333f, 
    -0.45389584f, -0.42685670f, -0.04985036f, 0.36792952f, -0.02891892f, -0.07810103f, 0.01060447f, 0.13837941f, 
    -0.03639929f, 0.02325075f, -0.05577774f, -0.07893304f, -0.42423019f, 0.07379489f, 0.06737394f, -0.14088006f, 
    0.07158610f, 0.04167595f, -0.07596091f, -0.10181475f, 0.15017234f, 0.02935967f, 0.05179705f, 0.09526463f, 
    -0.57650363f, 0.25107878f, -0.17809206f, -0.61331886f, 0.18842955f, 0.02185606f, -0.00126283f, -0.09321333f, 
    0.01657964f, -0.03944443f, -0.01770333f, -0.02938402f, 0.33765468f, 0.09586440f, -0.13040157f, -0.07514387f, 
    -0.08768425f, 0.12031250f, -0.35522249f, -0.24878556f, -0.10902564f, -0.02739565f, 0.01289854f, 0.10859785f, 
    0.16659102f, 0.07597364f, 0.09228314f, 0.12109141f, 0.07817622f, 0.07697537f, -0.20369841f, 0.00359181f, 
    0.10055988f, -0.04043831f, 0.11521348f, 0.13305321f, -0.17841315f, -0.18863268f, -0.06703255f, 0.10449488f, 
    0.06076009f, -0.15219229f, 0.03669351f, -0.11187360f, 0.03197635f, 0.03140789f, -0.20115010f, -0.04153825f, 
    0.26200327f, 0.19316727f, -0.14123517f, 0.22822443f, 0.09391699f, -0.03267394f, 0.07385357f, 0.08201288f, 
    -0.04422915f, -0.13469215f, 0.32001781f, -0.04564528f, -0.01811392f, 0.17950986f, 0.40277576f, -0.22018042f, 
    -0.04075718f, 0.11473602f, 0.04895053f, -0.09319071f, -0.06643850f, -0.04795185f, 0.02622969f, -0.12253322f, 
    -0.37177870f, -0.21940546f, -0.12465581f, 0.39085117f, 0.21348636f, 0.03348428f, -0.21388632f, 0.08201335f, 
    0.10076627f, -0.04923066f, 0.02473446f, -0.27104893f, -0.72851938f, -0.21995734f, -0.00336562f, -0.21517864f, 
    0.05950433f, 0.09396585f, -0.00821603f, 0.08954298f, -0.12290845f, -0.00947041f, -0.11152384f, -0.02534514f, 
    -0.47895774f, -0.04907686f, -0.12397220f, 0.04750617f, 0.06752197f, 0.17937289f, -0.07860323f, -0.16549902f, 
    -0.07516959f, -0.11526527f, 0.15584049f, 0.19073057f, 0.07799292f, 0.18420476f, -0.12431514f, -0.09480684f, 
    0.01787513f, -0.08846164f, 0.17970131f, -0.07347920f, 0.10539704f, 0.03656571f, -0.09162509f, -0.01372125f, 
    -0.40945733f, -0.27704671f, -0.47766140f, -0.13008663f, 0.03941146f, 0.16591331f, 0.08896095f, 0.04019499f, 
    0.02594436f, 0.12310237f, 0.04157275f, -0.00282668f, -0.21232885f, 0.04357342f, 0.22786263f, 0.50537306f, 
    -0.15408832f, -0.05526339f, 0.16125658f, 0.12996984f, 0.05041545f, 0.01516362f, -0.13020423f, 0.12793826f, 
    0.53033364f, 0.27781036f, 0.01362322f, -0.17928840f, -0.04909177f, 0.05974545f, -0.06345661f, -0.02180694f, 
    0.00418832f, -0.16380078f, 0.08197397f, -0.04570525f, -0.69903618f, 0.25913817f, 0.02817827f, 0.22751316f, 
    -0.11448005f, 0.03788573f, 0.06896693f, 0.15233496f, 0.00239140f, -0.03283781f, 0.20683604f, 0.01788597f, 
    -0.29265919f, 0.04194729f, 0.05876374f, -0.13677275f, -0.11549795f, 0.10408334f, 0.19713667f, -0.00179038f, 
    -0.15084973f, 0.03270718f, -0.04911132f, 0.03102226f, 0.47029543f, 0.03940688f, 0.17199460f, -0.44456357f, 
    -0.10177748f, 0.07000706f, 0.06567092f, -0.01101317f, -0.07268373f, 0.14857584f, 0.08725049f, 0.04864483f, 
    0.02114409f, 0.12339145f, -0.05421500f, -0.00564128f, -0.02351424f, -0.01949247f, 0.01066855f, 0.00032759f, 
    0.06351279f, 0.09415366f, 0.22301556f, 0.10780261f, -0.19171083f, -0.31187621f, -0.03188581f, 0.19688964f, 
    0.24014030f, -0.05239758f, 0.03276664f, -0.07340825f, -0.01092404f, -0.07221363f, 0.13347626f, -0.13624850f, 
    -0.30956113f, -0.07275015f, -0.08071755f, -0.19847219f, -0.16810879f, 0.08789963f, -0.04630908f, -0.02533891f, 
    -0.07188926f, 0.05655266f, -0.09913556f, -0.09265459f, -0.18814157f, 0.40696591f, 0.07879286f, 0.04241434f, 
    -0.18589501f, -0.03402235f, -0.09529899f, 0.13054624f, 0.08114532f, 0.16425009f, -0.05457340f, -0.26321170f, 
    -0.03118780f, -0.05861862f, 0.11201743f, -0.06604136f, 0.07535199f, -0.04015519f, 0.00289890f, -0.04033936f, 
    0.01537778f, -0.13464765f, 0.08259293f, -0.14205058f, -0.02399222f, -0.14471284f, 0.15510269f, -0.15704598f, 
    0.15226324f, 0.02038715f, -0.01957659f, -0.16051477f, -0.07660155f, -0.11972650f, 0.03541608f, -0.09487187f, 
    0.49071866f, -0.69095415f, -0.11835409f, 0.10740744f, -0.11195934f, -0.05040260f, 0.10804308f, 0.04605436f, 
    0.08391375f, 0.01475396f, 0.04468183f, 0.21800901f, -0.21928413f, -0.12120204f, -0.32416192f, 0.20568834f, 
    -0.12156738f, 0.10446464f, 0.18082803f, 0.05346866f, -0.06742710f, 0.14145836f, 0.11495798f, 0.14451931f, 
    0.02090193f, 0.15256433f, 0.03640604f, -0.28794003f, -0.09555934f, 0.00471696f, -0.14034452f, 0.08491268f, 
    0.03059776f, -0.01068483f, -0.11661975f, -0.17936368f, 0.35721612f, -0.16975428f, -0.34216437f, 0.34957361f, 
    -0.03804767f, 0.04069742f, -0.09039322f, -0.06168631f, -0.04217221f, -0.04389173f, -0.13610539f, -0.04870351f, 
    -0.21140714f, 0.11377736f, 0.08907381f, -0.29047459f, -0.03499634f, -0.01987546f, 0.20101650f, -0.05413503f, 
    0.09586286f, -0.01757457f, -0.15900913f, 0.25479785f, 0.06795552f, -0.11019021f, 0.28608170f, -0.21906936f, 
    0.25118575f, -0.12196500f, -0.08892619f, -0.32137492f, 0.05104260f, 0.07076798f, 0.05754367f, 0.17189930f, 
    -0.28182688f, -0.04643532f, -0.18317881f, -0.26978731f, -0.11308683f, -0.01218962f, -0.09088974f, 0.12474945f, 
    -0.04324367f, -0.02190072f, -0.18822947f, -0.00327442f, -0.20039386f, -0.09543306f, -0.30115551f, 0.38080743f, 
    -0.01109843f, -0.12825511f, -0.11471581f, 0.00646620f, -0.03537591f, -0.20940690f, -0.08592735f, 0.02236179f, 
    0.18131287f, -0.21968171f, -0.13658611f, 0.20024046f, 0.05744613f, 0.08539093f, -0.02767903f, -0.05873931f, 
    -0.14711514f, 0.05302216f, 0.09832428f, -0.06318089f, -0.28657484f, -0.21367325f, -0.04822887f, 0.23640396f, 
    0.10608117f, -0.04088430f, -0.00385264f, -0.06318539f, 0.07113967f, -0.05465417f, -0.02296835f, -0.07466809f, 
    0.71548998f, -0.35832849f, 0.06429278f, 0.08739097f, 0.04694467f, -0.02971519f, 0.08889730f, 0.20715494f, 
    0.17596456f, 0.09097966f, 0.00577279f, 0.08467020f, -0.51616025f, -0.06166773f, -0.23047659f, 0.26298267f, 
    -0.12530398f, -0.02526936f, 0.26632223f, -0.03547043f, 0.12172108f, -0.04141828f, 0.07144549f, -0.11380654f, 
    -0.09298566f, 0.28297985f, 0.23623359f, -0.16154544f, 0.06265432f, -0.03113038f, 0.21262875f, 0.08345064f, 
    0.08532556f, -0.02926009f, 0.04955711f, -0.01057757f, -0.35646036f, -0.22121173f, -0.06043240f, 0.29317686f, 
    0.13691300f, 0.18632987f, -0.03720193f, 0.01395802f, 0.02035788f, -0.14273869f, 0.08833110f, -0.08955771f, 
    -0.30101714f, -0.07742614f, -0.29205406f, -0.19061057f, -0.02912726f, -0.02412877f, 0.09147597f, -0.24745780f, 
    0.08662661f, 0.10417049f, -0.08656128f, 0.04937260f, -0.11102613f, -0.14175384f, 0.10473175f, -0.08048842f, 
    -0.04034493f, 0.01722152f, 0.12462516f, -0.05962804f, -0.07624183f, -0.10861729f, -0.14449665f, 0.05024560f, 
    0.25952482f, 0.01705290f, -0.11336828f, -0.19951807f, -0.17281401f, 0.13150297f, -0.18549773f, -0.17053925f, 
    -0.25748941f, 0.23708656f, 0.10958646f, 0.11739779f, -0.21380398f, 0.06905764f, 0.04141483f, -0.20503180f, 
    -0.01684418f, 0.01184262f, 0.07443865f, -0.05248791f, -0.00928709f, 0.03709548f, 0.08073929f, 0.09156826f, 
    0.20605436f, 0.16832383f, -0.07168479f, -0.09481858f, -0.04691856f, -0.03254620f, -0.06854854f, -0.05543389f, 
    -0.05082033f, 0.01390670f, 0.12553012f, -0.13883260f, 0.21144344f, -0.26862064f, 0.10686249f, -0.18894127f, 
    0.13586846f, 0.08038899f, 0.10647682f, 0.08435910f, -0.07292666f, -0.01703510f, 0.08344391f, -0.06898033f, 
    -0.00801970f, -0.21469803f, 0.00535110f, -0.37743440f, -0.09482591f, 0.10352992f, -0.12685020f, -0.15723701f, 
    -0.00172100f, 0.04926138f, 0.03903672f, 0.07464249f, -0.00769770f, -0.07877665f, -0.16092753f, -0.16954300f, 
    0.04505113f, -0.03158407f, -0.02326581f, 0.05511177f, -0.25469729f, 0.07793453f, 0.04966401f, 0.00086959f, 
    0.31719658f, -0.15792300f, -0.10926902f, -0.10146311f, -0.19442868f, -0.05315556f, -0.04173252f, -0.05441947f, 
    -0.10072758f, -0.00324984f, 0.02353744f, 0.04671587f, -0.48600978f, 0.07431488f, -0.26247492f, -0.17248529f, 
    0.08852889f, 0.05432437f, -0.06885489f, -0.12480745f, -0.05573345f, -0.02835527f, 0.11529095f, -0.02981014f, 
    -0.08176169f, 0.21242434f, 0.03542721f, 0.04557572f, 0.05698201f, -0.09721664f, -0.05477344f, -0.16050553f, 
    -0.11734100f, -0.06736816f, -0.00614607f, -0.08035986f, -0.28532472f, 0.16977951f, -0.13891885f, -0.08406380f, 
    -0.01248400f, -0.02936186f, -0.04569441f, -0.13208079f, -0.15715589f, -0.08626012f, -0.06280573f, -0.26720148f, 
    -0.19961058f, -0.21874559f, -0.13395827f, -0.33389047f, -0.00515283f, 0.04058749f, -0.09769963f, -0.02219940f, 
    -0.17050168f, -0.09413859f, -0.04606383f, -0.09014169f, 0.21057676f, 0.11912251f, 0.12933865f, 0.13408691f, 
    0.03447323f, 0.06208657f, 0.05669267f, -0.09914540f, 0.04406679f, 0.04232443f, 0.01672988f, -0.00870338f, 
    -0.47285736f, 0.27595386f, 0.03845534f, -0.17609011f, 0.00868628f, -0.00958338f, -0.04634417f, -0.05903670f, 
    -0.03364421f, 0.13587679f, 0.06181909f, -0.16896755f, -0.31471410f, -0.03807380f, -0.33565587f, -0.15884466f, 
    -0.04171240f, 0.02636575f, -0.13500497f, -0.00970315f, -0.07146647f, 0.10276907f, 0.00556164f, -0.15875712f, 
    -0.28004506f, -0.42876399f, -0.03759941f, 0.06470073f, -0.04718966f, -0.05055802f, 0.03025585f, -0.00188815f, 
    -0.04608183f, -0.11763526f, -0.07031853f, 0.01987590f, 0.17450020f, -0.07484559f, 0.13137537f, 0.09389935f, 
    -0.07533360f, -0.09856885f, 0.02396720f, -0.03699658f, 0.03183391f, -0.05259047f, -0.14814393f, -0.01637387f, 
    -0.03938192f, -0.11922438f, 0.05665209f, -0.10083237f, 0.10776851f, 0.00674399f, -0.06356648f, -0.14936040f, 
    -0.04748425f, -0.09055940f, 0.05785625f, -0.06252643f, -0.17098922f, 0.22046429f, 0.04826815f, 0.14470774f, 
    0.07834691f, -0.03425033f, 0.04904884f, 0.02200383f, 0.11492402f, -0.01623406f, -0.02554761f, -0.10802375f, 
    -0.32957327f, -0.00260928f, -0.04343250f, -0.30467233f, -0.08872958f, -0.15558080f, 0.00313105f, -0.11500257f, 
    -0.09189152f, -0.00406919f, -0.04194811f, 0.01697504f, -0.08662371f, 0.07173869f, -0.11859716f, 0.10790653f, 
    -0.16248991f, 0.02626839f, -0.10339423f, -0.02423353f, 0.00619156f, -0.02560578f, -0.00005346f, -0.04840493f, 
    0.12171111f, 0.08783361f, 0.11439285f, 0.34094238f, 0.05417941f, 0.05136865f, -0.04210348f, -0.18346985f, 
    -0.07839464f, -0.00831376f, -0.04048752f, -0.17854516f, 0.33472410f, 0.12503129f, 0.19242279f, 0.05523330f, 
    -0.07136096f, 0.00336670f, 0.13340069f, 0.12401149f, -0.04609850f, 0.13703683f, 0.13336349f, -0.07672757f, 
    0.14789699f, 0.13931145f, 0.16726647f, 0.21126099f, 0.11167498f, -0.00776920f, 0.00012913f, -0.07391095f, 
    -0.06821384f, -0.03574293f, -0.09542313f, -0.03047628f, 0.08499044f, 0.04171406f, 0.01105347f, 0.13193649f, 
    -0.05358661f, -0.08889785f, -0.04957465f, -0.02103043f, 0.01207598f, -0.05101796f, -0.00583549f, -0.10514734f, 
    0.43925726f, -0.00450074f, 0.24248902f, 0.11300554f, 0.29742110f, 0.08134931f, 0.04953893f, -0.13098811f, 
    -0.10129490f, -0.18616401f, -0.01528643f, -0.05124509f, 0.05520540f, 0.01289706f, 0.16461851f, 0.09388660f, 
    0.16423498f, -0.06918363f, 0.03280837f, -0.01674234f, -0.06735863f, -0.02019513f, 0.10809566f, -0.01016055f, 
    0.38802189f, -0.27051193f, 0.24909082f, -0.26267654f, -0.04877990f, -0.00341418f, -0.05301784f, 0.00318888f, 
    -0.06035218f, 0.10984023f, -0.10835418f, -0.08493614f, 0.15725468f, 0.05686034f, -0.19231850f, -0.12631129f, 
    -0.10654916f, -0.03993128f, 0.07945099f, 0.06846837f, 0.00031286f, 0.08980878f, 0.09486512f, -0.10143131f, 
    -0.16852026f, 0.04133200f, -0.16167513f, -0.08929509f, 0.00543889f, -0.06826244f, -0.08803847f, -0.10534526f, 
    -0.04946328f, 0.00279737f, -0.05910070f, 0.08826891f, -0.17016713f, 0.20321333f, -0.14303072f, 0.03877013f, 
    -0.00498335f, -0.06112220f, -0.11755571f, -0.04775740f, -0.06719860f, 0.04392350f, 0.01322988f, -0.12290730f, 
    0.27403706f, -0.03542082f, 0.06108456f, 0.06187064f, 0.18914005f, 0.03283387f, 0.00482895f, -0.09972894f, 
    0.04158560f, 0.00209624f, -0.11334623f, -0.23283090f, 0.03282650f, -0.19058275f, -0.00321170f, -0.04995079f, 
    -0.14518562f, 0.02289663f, -0.05150129f, -0.19891442f, 0.08527350f, -0.12346939f, -0.08651493f, 0.10445745f, 
    -0.07964737f, 0.08116207f, 0.03299692f, 0.20867182f, 0.16742888f, -0.06228726f, -0.01465241f, 0.04782517f, 
    -0.11464709f, -0.03973540f, 0.05970323f, -0.04368573f, 0.01585762f, 0.09464406f, 0.20694491f, -0.01800940f, 
    -0.06546469f, 0.03930034f, -0.02120778f, 0.00057603f, -0.07905848f, 0.06699333f, 0.01957377f, -0.03648395f, 
    -0.06509995f, 0.18135700f, 0.32135540f, -0.07408526f, -0.12231223f, 0.08509736f, -0.10184446f, -0.14340420f, 
    -0.03531957f, -0.07045990f, -0.05557011f, 0.08244618f, 0.37951156f, -0.23437439f, -0.03744930f, -0.13035299f, 
    0.02642995f, 0.03446484f, -0.01509820f, 0.03522115f, 0.03944833f, 0.01675495f, -0.00372165f, -0.03916560f, 
    -0.13587846f, 0.26703328f, 0.13539280f, 0.24923263f, 0.08933272f, 0.01767210f, 0.07714436f, -0.00085025f, 
    -0.04741639f, 0.05192488f, 0.00418303f, -0.05543738f, -0.10447244f, -0.00935846f, 0.14992076f, 0.27395347f, 
    -0.05291617f, -0.00198434f, -0.17638321f, -0.03206323f, -0.10027190f, -0.02242531f, -0.01422712f, -0.02240208f, 
    -0.38045549f, 0.11974990f, -0.17171928f, -0.23551372f, -0.05040505f, 0.05272027f, 0.03254208f, 0.03507683f, 
    -0.03671345f, 0.12513480f, -0.04080617f, 0.17653476f, -0.02727236f, 0.14949486f, -0.12314115f, -0.11554743f, 
    0.09901128f, -0.02996764f, -0.09707972f, 0.01530443f, 0.04391963f, -0.06037671f, -0.13119394f, -0.15189299f, 
    0.15724756f, 0.14042498f, 0.08500078f, 0.07384910f, -0.01122607f, -0.07093890f, -0.35028622f, -0.01192891f, 
    0.02384299f, 0.03791831f, 0.14151818f, -0.15623930f, 0.05014487f, 0.03698169f, 0.19972092f, 0.27142856f, 
    0.12582594f, 0.00968262f, 0.00634785f, -0.03623419f, 0.07278750f, 0.08794595f, 0.10727444f, 0.00792436f, 
    -0.06475283f, -0.10679825f, -0.01686503f, 0.06258340f, 0.05843530f, -0.05342026f, -0.04269472f, -0.03576341f, 
    0.06128888f, -0.19679119f, -0.00816453f, 0.01433790f, 0.02765962f, 0.30043784f, -0.12910689f, 0.04843483f, 
    -0.19159925f, 0.09849793f, -0.19385038f, 0.06512831f, 0.10208005f, 0.12440225f, 0.05167443f, 0.10668863f, 
    -0.06177949f, -0.00028526f, 0.19874282f, 0.17512706f, -0.03551606f, 0.09093904f, -0.04100535f, -0.13518682f, 
    -0.01800015f, 0.02304191f, 0.06270920f, 0.10611539f, 0.06004970f, 0.11681428f, -0.02318397f, 0.02453108f, 
    0.10360385f, 0.05528088f, 0.03822486f, -0.06562085f, -0.00658114f, -0.04467892f, 0.06818277f, 0.11464991f, 
    0.27697331f, -0.14879136f, -0.27000067f, 0.07447504f, 0.04198967f, 0.02182174f, -0.04923127f, -0.01441631f, 
    -0.08970857f, 0.02280997f, 0.04084013f, 0.08742407f, 0.00685826f, -0.16174869f, 0.06163455f, -0.26635042f, 
    -0.07532478f, -0.13154753f, -0.02871809f, 0.01126539f, -0.07421535f, 0.13255593f, 0.03199306f, -0.01218358f, 
    0.29150236f, -0.03013704f, 0.01493865f, 0.08751868f, -0.12954102f, -0.04552637f, -0.07393920f, 0.00971897f, 
    0.01814636f, -0.20245928f, -0.07952236f, -0.15356609f, 0.08852968f, 0.15802950f, -0.20461850f, 0.12991819f, 
    -0.03314838f, -0.08326077f, -0.06486397f, -0.03932322f, -0.03916484f, -0.17351861f, -0.16213471f, 0.22462705f, 
    0.06148352f, -0.13059156f, -0.10938057f, 0.14915466f, 0.07600994f, 0.04121958f, 0.11584167f, -0.07898860f, 
    0.09230067f, -0.01892212f, 0.07529386f, -0.07468735f, 0.16050543f, 0.31955150f, -0.27123830f, -0.21160567f, 
    0.01881195f, -0.03720052f, 0.06299438f, -0.10027605f, 0.07493408f, 0.00649221f, -0.00833152f, 0.03189331f, 
    -0.32209489f, -0.20713042f, 0.03787499f, -0.46679407f, -0.13060296f, -0.08420325f, 0.10705213f, 0.00763920f, 
    -0.07460705f, -0.10070490f, 0.12283648f, -0.00146939f, -0.09000950f, -0.05569533f, -0.12932487f, 0.06165431f, 
    0.00521975f, -0.11004439f, -0.00679348f, 0.20761065f, 0.06605993f, 0.07473789f, -0.25146988f, 0.10812308f, 
    -0.35779303f, -0.06883214f, 0.05845382f, -0.02637899f, 0.05685490f, -0.08728270f, -0.05840883f, -0.11206514f, 
    0.01878325f, -0.12776616f, 0.05679656f, -0.10308826f, 0.17060028f, 0.25204220f, -0.17030005f, -0.19597514f, 
    0.10973043f, -0.03482695f, -0.02931418f, -0.04658134f, 0.14367907f, 0.08320926f, 0.08185437f, 0.12575614f, 
    0.12700988f, -0.08044496f, -0.07223231f, -0.23117781f, -0.05036438f, 0.16369875f, 0.04399993f, 0.01482432f, 
    -0.01349475f, 0.12140349f, -0.08108974f, 0.00153242f, -0.09854960f, 0.04060971f, 0.03154293f, 0.23147796f, 
    -0.29286626f, -0.04486142f, -0.12720890f, -0.29688519f, -0.09995665f, 0.03938750f, 0.01669231f, -0.08063394f, 
    -0.32544559f, -0.06314179f, 0.02735598f, -0.02754892f, -0.04588883f, -0.09036517f, 0.11772896f, -0.18650395f, 
    0.03480584f, 0.00197764f, -0.05833309f, 0.07863633f, 0.15602873f, 0.25057399f, -0.03863696f, 0.08241589f, 
    -0.24917710f, 0.10971398f, -0.16805576f, -0.00975791f, -0.07236777f, 0.05453659f, -0.02726365f, -0.02936621f, 
    -0.11166440f, -0.09901142f, -0.02400352f, 0.22896662f, 0.09055718f, -0.01128288f, -0.09889289f, 0.02497134f, 
    0.02399945f, -0.00086305f, 0.23992941f, 0.07140075f, -0.05881761f, 0.34326026f, -0.33950442f, 0.02680545f, 
    -0.09787107f, -0.05134875f, 0.00534127f, -0.10416733f, 0.07871733f, -0.03622269f, 0.02635079f, 0.02413229f, 
    -0.04872520f, -0.28558737f, 0.04774185f, -0.25446156f, -0.10272455f, 0.05354819f, 0.12318064f, -0.04682566f, 
    0.01734607f, 0.00983635f, 0.12005967f, -0.16292839f, 0.12030560f, 0.20166600f, 0.04680906f, 0.24191590f, 
    -0.10455025f, -0.06253973f, -0.15747726f, -0.09817686f, -0.07576925f, 0.13838772f, 0.00698855f, -0.11462133f, 
    -0.24301314f, -0.00903528f, 0.00374205f, -0.28018209f, 0.10201272f, -0.05821389f, 0.03329045f, 0.15931614f, 
    0.14767696f, 0.05574446f, 0.03331855f, -0.05757006f, -0.35318419f, 0.01578671f, 0.12662062f, -0.24679543f, 
    0.00916842f, -0.03795760f, 0.01119337f, -0.15239993f, -0.03181510f, 0.00182768f, -0.11161760f, -0.03128427f, 
    -0.10797933f, -0.52859545f, 0.21078011f, -0.06215997f, -0.03547444f, 0.03504700f, -0.12428416f, -0.21939017f, 
    -0.10917479f, -0.06401125f, 0.14327528f, 0.14107020f, 0.08094020f, -0.25372788f, 0.12150303f, 0.01131575f, 
    0.09297862f, -0.03830139f, 0.10407683f, -0.19544993f, 0.01639795f, 0.02408307f, -0.28752226f, 0.05464894f, 
    -0.16626236f, 0.01409092f, 0.26495695f, 0.21665791f, -0.17634304f, 0.09177483f, 0.03900136f, 0.02744812f, 
    -0.10088724f, -0.04926368f, 0.03562696f, -0.22585382f, -0.32598495f, -0.18226008f, -0.32494181f, -0.31784603f, 
    0.09401120f, -0.18021770f, 0.10396306f, 0.03428898f, 0.13808702f, -0.11438760f, -0.13958676f, 0.06304068f, 
    -0.50358802f, 0.00466570f, -0.14008871f, -0.07804641f, -0.11414030f, 0.02601864f, -0.04924478f, -0.00360820f, 
    0.13429129f, 0.04571462f, -0.04466384f, -0.03649743f, -0.14400893f, 0.11954376f, 0.30606893f, 0.04844386f, 
    0.09987924f, 0.04207319f, 0.13445581f, -0.08911674f, 0.10018700f, -0.04883840f, 0.01463001f, -0.05004689f, 
    -0.02862784f, -0.45794269f, -0.29121390f, 0.03377680f, -0.18519288f, 0.09898768f, 0.04217953f, 0.07634672f, 
    -0.03874232f, -0.08059473f, -0.01620137f, 0.09343521f, -0.46556318f, 0.15432911f, -0.28226078f, -0.07972679f, 
    0.14616875f, -0.13840990f, 0.10229509f, -0.17371979f, -0.17577919f, -0.06171371f, -0.17687979f, -0.01188351f, 
    -0.03650706f, -0.09046523f, 0.34276250f, -0.37278530f, -0.00098166f, 0.05266198f, 0.02722209f, -0.13574007f, 
    0.15879010f, -0.08668192f, 0.03420701f, -0.00051758f, 0.06158515f, -0.18801048f, -0.24239075f, 0.20506659f, 
    0.11991233f, 0.05891175f, -0.12989737f, 0.20463355f, -0.19348355f, -0.04179993f, -0.05946271f, -0.05700299f, 
    -0.22168623f, -0.14048976f, 0.09359274f, -0.06220168f, 0.12514991f, -0.00018938f, -0.14108402f, -0.07339656f, 
    -0.10908932f, -0.04279353f, -0.23074639f, -0.14677218f, 0.25832739f, 0.11515932f, 0.26000449f, -0.37152046f, 
    0.28038216f, 0.12679249f, -0.03278038f, -0.05465876f, -0.14170496f, 0.06626838f, -0.05052140f, -0.15047312f, 
    0.03206138f, -0.00730566f, 0.03913398f, -0.25781471f, 0.09347025f, 0.05359657f, -0.14219560f, -0.01128114f, 
    0.16180559f, 0.02653197f, 0.02421490f, -0.02480306f, 0.50408214f, 0.15666233f, -0.26847094f, 0.10125683f, 
    0.00441030f, -0.10345914f, -0.05650765f, 0.14165336f, -0.13142757f, -0.08267994f, -0.04463697f, 0.05113205f, 
    0.05335062f, -0.15303254f, -0.00652208f, 0.03014106f, 0.15715407f, 0.20886001f, -0.09635030f, -0.14409073f, 
    -0.00321391f, 0.06439473f, 0.06773230f, 0.10108016f, -0.22914225f, -0.48793584f, 0.18383384f, -0.29858372f, 
    0.00443492f, -0.02344276f, 0.01392564f, 0.12728959f, 0.06894414f, 0.02818407f, 0.06954876f, 0.08550842f, 
    -0.18186937f, 0.26637721f, -0.21002081f, -0.37223512f, 0.16567494f, 0.13720647f, -0.05042250f, 0.04377497f, 
    -0.22005276f, 0.02257604f, -0.11112863f, -0.04667773f, -0.15680136f, 0.17820750f, 0.33115914f, 0.36969280f, 
    0.13692261f, 0.01854401f, -0.12480597f, 0.03430451f, -0.03699060f, -0.16222283f, 0.15513484f, 0.08974437f, 
    0.54180884f, -0.05972686f, -0.04296037f, -0.05783248f, 0.15110852f, 0.09955535f, -0.20781074f, 0.17245917f, 
    -0.14572911f, -0.04290760f, 0.06798127f, 0.00758965f, -0.23181933f, 0.35141495f, -0.23484030f, 0.14362626f, 
    0.07205794f, 0.02277519f, -0.03958979f, 0.11388977f, -0.06371046f, 0.09947441f, 0.02868393f, 0.12331503f, 
    0.00975863f, -0.38763872f, -0.18251416f, 0.00169012f, -0.04123496f, 0.12432989f, 0.03608593f, 0.05028546f, 
    -0.07374522f, 0.00406117f, -0.04147188f, -0.00670777f, 0.16983235f, -0.21113476f, 0.39381993f, 0.00462774f, 
    0.24147731f, 0.16166653f, -0.00404904f, -0.11174107f, 0.02859188f, -0.06422091f, -0.17468384f, -0.04299290f, 
    0.14572939f, -0.65998763f, 0.26050708f, 0.06123085f, 0.08415904f, -0.07057188f, 0.11708056f, -0.09813130f, 
    0.00039664f, 0.06733605f, 0.03807735f, 0.21759570f, 0.34897980f, -0.80586338f, -0.21771403f, 0.02996132f, 
    0.03648459f, -0.03284177f, 0.03349849f, 0.17462711f, -0.20120272f, -0.09142147f, 0.02380013f, -0.06798289f, 
    0.08450253f, -0.16855440f, -0.22651200f, -0.00960221f, -0.02567240f, -0.05133228f, -0.04704742f, -0.00858502f, 
    -0.01676788f, 0.00469343f, 0.07022864f, -0.13817054f, -0.11606840f, 0.43945831f, 0.34831932f, 0.08225833f, 
    0.17344090f, 0.09439690f, 0.02118577f, 0.18355046f, 0.08156455f, 0.06447056f, -0.09330959f, -0.04929566f, 
    -0.21295440f, -0.08614238f, -0.00112531f, -0.11326425f, -0.06885978f, 0.04613971f, -0.10933860f, -0.17687538f, 
    -0.16161343f, -0.04090655f, 0.02800053f, -0.09770397f, -0.33847213f, 0.41967610f, 0.26219410f, 0.06924972f, 
    -0.14429505f, 0.02408148f, -0.07831638f, -0.05883162f, -0.07770973f, -0.01624113f, 0.03098799f, 0.05239445f, 
    -0.03783036f, -0.05542979f, -0.06120251f, -0.03034483f, -0.00934056f, 0.07512675f, -0.01268694f, -0.11173485f, 
    -0.19264007f, 0.10189552f, -0.11181396f, -0.04531526f, 0.48822290f, -0.48633525f, -0.10597593f, 0.06984825f, 
    0.07893987f, -0.09262069f, 0.10944467f, 0.00831328f, 0.08767734f, 0.03771607f, 0.13284352f, 0.07780544f, 
    -0.40204111f, -0.15745874f, 0.12696190f, -0.31379950f, -0.05757307f, 0.07480556f, 0.07400113f, -0.07013150f, 
    -0.00061842f, -0.04643220f, -0.02841300f, 0.09554996f, 0.01947766f, -0.32047760f, -0.03175227f, 0.28523499f, 
    -0.04464509f, 0.10995943f, 0.01803345f, 0.00859219f, 0.04483975f, 0.09529381f, 0.00003945f, -0.02676393f, 
    0.14734161f, -0.26104346f, -0.00915154f, 0.10729460f, 0.16527921f, -0.14425772f, 0.08693898f, -0.05543872f, 
    -0.01508656f, 0.16891946f, -0.11777037f, 0.06775574f, 0.33307895f, 0.10129663f, 0.37587628f, 0.10761542f, 
    -0.10712716f, -0.00466643f, -0.09657975f, -0.09074352f, 0.06666023f, -0.07743111f, 0.22319238f, 0.05992850f, 
    -0.22815111f, 0.00775066f, 0.15384746f, -0.03768693f, 0.02401185f, -0.15624759f, -0.12716745f, -0.03829263f, 
    0.06714249f, 0.00257420f, 0.10184491f, 0.02132888f, -0.03468145f, -0.32749674f, -0.06891283f, -0.35425660f, 
    0.02914467f, 0.07880362f, -0.06983318f, 0.08447859f, -0.05614297f, -0.21938244f, 0.22874683f, -0.07590870f, 
    0.38509911f, 0.08638974f, -0.04489125f, -0.05518616f, 0.18610114f, 0.01374826f, 0.01935334f, 0.14188945f, 
    0.01935233f, -0.05053421f, -0.14725271f, 0.11050736f, -0.66066033f, -0.39777827f, 0.18163548f, 0.13790706f, 
    0.06415692f, 0.12033656f, -0.06752446f, -0.04063132f, 0.11682414f, -0.05410479f, -0.11900873f, 0.15789840f, 
    -0.73724717f, -0.01436001f, -0.23759258f, -0.21480572f, 0.20990759f, -0.09082966f, -0.05792943f, -0.02407644f, 
    0.05954353f, -0.01650029f, -0.03925240f, -0.16431881f, -0.34183830f, -0.54805410f, -0.10300676f, -0.17694120f, 
    -0.03897082f, 0.04433392f, 0.02879015f, 0.03353307f, 0.06890314f, 0.04822591f, 0.17458872f, 0.03348735f, 
    -0.15865776f, -0.04901364f, -0.03118714f, -0.10140196f, 0.20359437f, -0.11241373f, -0.09554682f, -0.03139034f, 
    -0.05584326f, -0.26823995f, -0.11944916f, -0.04370536f, -0.12697509f, -0.22785142f, 0.11747220f, -0.13684241f, 
    -0.05460626f, 0.04728225f, 0.13907471f, -0.06652090f, 0.06392912f, -0.14233164f, 0.03015992f, -0.12646443f, 
    0.12713830f, 0.03735806f, 0.05561323f, 0.20556284f, -0.02300908f, 0.07980468f, 0.10110217f, 0.05634096f, 
    0.09559508f, 0.12452909f, 0.15738137f, 0.22028735f, -0.54134178f, -0.33953863f, 0.07375678f, 0.06920721f, 
    0.14887419f, -0.13929066f, 0.05113949f, -0.12547837f, 0.00331275f, -0.02790832f, 0.10474276f, 0.31414187f, 
    -0.83547652f, -0.18389854f, -0.15015070f, -0.29732943f, 0.12842071f, -0.06848366f, -0.06997980f, 0.01919993f, 
    0.17059444f, -0.00919771f, -0.08501413f, 0.07845109f, 0.17230353f, -0.14083657f, -0.07552242f, 0.28041530f, 
    -0.05920556f, -0.05336661f, 0.16146763f, 0.10008641f, 0.03400226f, 0.16973683f, 0.03643936f, 0.02933333f, 
    0.01814396f, 0.10685975f, -0.17631380f, -0.28439814f, 0.01244180f, 0.00615494f, -0.26355332f, -0.11187091f, 
    0.00045597f, -0.23138776f, -0.10657503f, -0.20113470f, -0.19143204f, 0.03122621f, -0.12154167f, 0.04655674f, 
    -0.11650093f, -0.22462586f, -0.04956879f, -0.06376407f, -0.05194334f, -0.17338228f, -0.21861501f, 0.01899089f, 
    -0.48304829f, -0.27737984f, -0.11381610f, -0.25105536f, 0.11370412f, 0.04423330f, 0.10009576f, 0.02465240f, 
    0.16080932f, 0.14070265f, 0.15631893f, 0.08958015f, -0.23214079f, -0.02798290f, 0.00129684f, -0.01197562f, 
    -0.05191303f, -0.04142256f, -0.07533344f, -0.00489353f, 0.10401243f, -0.03051778f, 0.18198065f, -0.03649559f, 
    0.32457393f, 0.04798904f, 0.07440685f, -0.05675096f, 0.00761303f, 0.10121883f, 0.17726611f, 0.16349432f, 
    0.06806772f, -0.01908218f, -0.01631541f, -0.03319352f, 0.05186442f, -0.03150606f, -0.02945368f, -0.19478777f, 
    -0.18771783f, 0.01881703f, 0.16549684f, -0.12938070f, 0.09027643f, -0.35110736f, -0.27147236f, -0.05084011f, 
    0.21576232f, 0.18603799f, 0.04038708f, -0.28580421f, -0.09251533f, 0.13848928f, 0.10532639f, 0.01208861f, 
    -0.15443596f, -0.05002286f, 0.04435781f, -0.15309629f, 0.06609305f, 0.00153763f, -0.03117429f, -0.12213305f, 
    -0.06629530f, 0.13330372f, -0.03827891f, 0.02410154f, 0.08117621f, 0.11663029f, 0.12099487f, 0.01683787f, 
    -0.26306754f, 0.19377375f, -0.34242582f, -0.04132443f, -0.03735847f, 0.11842416f, 0.06136919f, 0.11191861f, 
    0.21935113f, 0.09408154f, -0.00761480f, -0.24828178f, 0.38754192f, 0.04954891f, 0.10043386f, 0.13534369f, 
    -0.26622435f, 0.07249457f, 0.03238903f, 0.01547022f, -0.06394305f, 0.11601073f, -0.05608317f, 0.05913306f, 
    0.24269094f, 0.02564204f, -0.17713833f, 0.14835897f, -0.11474434f, -0.14647129f, -0.18363148f, 0.02012026f, 
    -0.11184406f, 0.00619152f, 0.03635947f, 0.00209501f, -0.21941835f, -0.42721662f, 0.00371141f, -0.16150692f, 
    0.06273947f, 0.13375284f, -0.05703290f, -0.05185065f, 0.11490005f, -0.14754866f, -0.09120096f, 0.01591968f, 
    -0.60282350f, -0.12290438f, -0.15902251f, -0.31178278f, 0.13755278f, 0.09509642f, -0.10528674f, 0.03181503f, 
    0.08927359f, -0.10599271f, 0.01990110f, 0.09701040f, -0.43887389f, -0.30834395f, 0.25961998f, 0.07501522f, 
    0.15556695f, 0.07969525f, 0.21137561f, -0.01696309f, 0.29329833f, 0.08681585f, 0.04015641f, 0.03037142f, 
    0.21820730f, 0.24036506f, -0.15965232f, 0.10556871f, 0.22080539f, 0.22128269f, -0.00543756f, -0.00090565f, 
    0.04115784f, -0.04133504f, 0.12829277f, -0.11828136f, -0.20348431f, 0.02806379f, -0.31551403f, -0.32545024f, 
    0.10038587f, 0.00096184f, -0.22764583f, 0.20870769f, 0.04212359f, 0.07866858f, 0.07414941f, 0.04898181f, 
    0.18335161f, 0.06796330f, -0.21380740f, 0.14417651f, -0.05752694f, 0.05427375f, 0.16132124f, -0.00652377f, 
    0.06008342f, 0.11758027f, 0.11391968f, 0.01486270f, 0.13928019f, 0.11612921f, 0.02656696f, 0.05956880f, 
    -0.09074513f, 0.04356707f, -0.01933531f, 0.03534553f, -0.02240913f, -0.16348854f, -0.06153791f, -0.16910219f, 
    0.23280375f, -0.08220536f, -0.06143029f, 0.03533418f, -0.10919099f, 0.12626189f, -0.02336984f, 0.32215580f, 
    -0.01285779f, 0.09047043f, 0.00847688f, -0.04598521f, -0.35078260f, -0.19757132f, -0.12714373f, -0.10678082f, 
    0.00081976f, -0.02433634f, 0.07485081f, -0.10545763f, 0.11376359f, 0.04693323f, 0.04340443f, 0.10052915f, 
    0.37905967f, 0.08266136f, -0.02219479f, -0.05221012f, -0.29670411f, -0.07896240f, 0.08899689f, -0.07461078f, 
    0.07032782f, 0.13725230f, -0.06493007f, -0.16876255f, -0.09974393f, 0.17235442f, -0.14481305f, -0.12635767f, 
    0.16684726f, -0.04551081f, 0.11266453f, 0.03711304f, -0.00929789f, 0.14798249f, 0.06090655f, 0.16080016f, 
    -0.31938604f, 0.15635875f, -0.34927273f, -0.02806719f, 0.18604657f, -0.05264955f, 0.04188698f, 0.07370833f, 
    0.03918048f, 0.06941170f, 0.05351732f, -0.12871212f, 0.17142648f, 0.41876185f, -0.07901990f, -0.02904726f, 
    0.14460634f, 0.04222470f, 0.03403420f, 0.00354101f, 0.05258501f, -0.00843853f, 0.07485897f, 0.08157681f, 
    -0.52291977f, -0.09188548f, -0.06128588f, 0.07143806f, 0.01541849f, 0.02977505f, -0.06224228f, 0.08485967f, 
    0.06844959f, 0.02305530f, 0.06953906f, 0.06662887f, -0.21388955f, -0.04226141f, -0.12963873f, -0.21911743f, 
    0.21524864f, 0.05491308f, 0.00698335f, 0.05398719f, -0.00873448f, -0.04335738f, -0.10346463f, 0.05591510f, 
    0.51765996f, 0.03510935f, -0.14926524f, -0.20746094f, 0.03449437f, 0.08804598f, 0.03710305f, 0.09379216f, 
    -0.05137581f, 0.17109592f, 0.09619880f, 0.15171458f, -0.29656097f, 0.39689887f, -0.05697003f, -0.00355607f, 
    -0.01752217f, -0.09974608f, 0.11034483f, -0.14841765f, -0.12896632f, 0.06519456f, -0.08729742f, -0.07963906f, 
    0.38832763f, -0.09845194f, -0.08886375f, -0.01071423f, 0.02323277f, -0.06343168f, -0.12827305f, 0.01484185f, 
    -0.16420074f, 0.06000235f, -0.16651264f, -0.14534560f, 0.30217883f, -0.07701657f, -0.33181137f, -0.02201748f, 
    -0.08677351f, -0.08884195f, 0.05153022f, 0.12752812f, 0.06023693f, 0.10129075f, -0.03200675f, 0.04370848f, 
    0.44367385f, -0.20034833f, -0.23730476f, 0.16672800f, -0.10883699f, -0.11820626f, 0.09025992f, -0.06738958f, 
    -0.01050777f, -0.00932529f, -0.05103020f, -0.07992757f, -0.11903352f, -0.18597007f, 0.35653320f, 0.01972801f, 
    -0.07496122f, 0.00862366f, -0.16281736f, -0.02673840f, 0.01685368f, -0.07572180f, 0.09802147f, 0.04799618f, 
    -0.65479499f, -0.22317603f, -0.15008679f, -0.37512580f, -0.03441198f, 0.04458045f, -0.02463761f, 0.03756133f, 
    0.01982372f, 0.13920727f, -0.11279102f, 0.04497977f, -0.17532225f, -0.23649086f, -0.01536555f, 0.00197767f, 
    -0.09604630f, 0.15624866f, 0.05331415f, -0.00831136f, 0.09212334f, 0.02841696f, -0.16156080f, 0.13334218f, 
    0.58565366f, 0.01756636f, -0.23228347f, 0.00901569f, 0.08929527f, -0.12152983f, 0.12730971f, -0.07323656f, 
    0.02973314f, -0.06568413f, 0.01373453f, -0.01227216f, 0.16442981f, -0.21919508f, -0.23093440f, 0.02877491f, 
    0.11744545f, -0.10994215f, 0.00615217f, 0.01086801f, -0.04041588f, 0.07330667f, -0.00816460f, 0.01205626f, 
    -0.17965654f, 0.14500612f, 0.20058022f, -0.21982792f, -0.04743700f, 0.01109710f, -0.22945100f, -0.21443027f, 
    0.06504332f, -0.04389854f, -0.12189910f, -0.27504095f, -0.56899548f, 0.10917808f, -0.05337510f, 0.09331996f, 
    0.15309463f, 0.01091698f, -0.06533034f, 0.05089882f, 0.04593904f, 0.11301852f, 0.09950096f, 0.02551077f, 
    0.08525929f, 0.36877751f, -0.28032100f, -0.07989794f, -0.01789744f, -0.19269057f, -0.10692916f, -0.12311217f, 
    0.09535494f, 0.09161684f, -0.08926141f, -0.06900290f, -0.00688642f, -0.01747107f, -0.06832417f, -0.06774373f, 
    -0.06539474f, 0.00198985f, -0.03411023f, -0.11983666f, -0.02304878f, -0.21351694f, 0.01339733f, -0.09861221f, 
    0.04569807f, 0.05258472f, -0.08533997f, 0.30069390f, -0.19414781f, 0.02089640f, -0.12947579f, -0.01584822f, 
    -0.07192463f, 0.06007412f, 0.23574229f, 0.12299641f, 0.04706262f, -0.00840296f, -0.04720750f, 0.11284037f, 
    -0.07795048f, 0.02298752f, 0.06975836f, -0.05845251f, -0.32086188f, 0.00369478f, -0.11614287f, -0.36534944f, 
    -0.28085694f, 0.23412983f, -0.02307163f, 0.07514944f, 0.14687756f, -0.03196077f, 0.14360604f, -0.05123301f, 
    0.00241774f, -0.01859153f, 0.06793717f, 0.14174046f, -0.30417293f, -0.28512785f, -0.07764074f, 0.00589012f, 
    0.01155271f, 0.00229855f, 0.07697368f, -0.03473898f, -0.01412779f, 0.08963031f, -0.05594218f, 0.03699855f, 
    0.32031944f, 0.09703606f, -0.43826836f, -0.31175211f, -0.03081171f, 0.03173389f, 0.02572218f, 0.14993060f, 
    -0.09687892f, 0.03997045f, -0.14505228f, -0.11118828f, 0.24263591f, 0.21414667f, 0.02736108f, 0.04935382f, 
    0.12988520f, 0.05248522f, -0.17526881f, -0.07052184f, -0.00631748f, 0.09178595f, 0.05528530f, 0.07777714f, 
    -0.23227063f, 0.20454989f, -0.06265357f, -0.04302680f, -0.22082394f, -0.20590018f, 0.00804214f, 0.07797495f, 
    0.07209733f, -0.06394820f, -0.17355861f, 0.11519659f, -0.82163966f, -0.02952716f, 0.02740558f, -0.10933103f, 
    0.04190056f, -0.06809632f, 0.00030259f, 0.12322156f, 0.05623205f, -0.07251684f, -0.05852745f, 0.06267941f, 
    0.29809678f, -0.25760359f, -0.14785749f, 0.13388899f, -0.09439152f, 0.15105273f, -0.01611051f, -0.05235960f, 
    0.14743415f, -0.04292198f, -0.16778843f, -0.06747098f, 0.14760427f, 0.11145638f, 0.11697520f, -0.05733407f, 
    0.00030592f, -0.04136917f, 0.20095116f, -0.12441294f, 0.03597849f, -0.01272118f, 0.15712069f, -0.04413161f, 
    -0.11679275f, 0.20303258f, 0.10538005f, -0.10700529f, 0.15180893f, -0.13774857f, 0.02497100f, 0.05583716f, 
    0.10017939f, -0.03793010f, -0.00232221f, -0.08187377f, -0.26663178f, 0.39181021f, 0.19526884f, -0.24380079f, 
    -0.02504990f, -0.03223843f, -0.17559926f, 0.11184105f, 0.00467405f, 0.05360688f, -0.08346071f, -0.17234911f, 
    -0.06252595f, -0.17678162f, 0.07845847f, 0.12681283f, 0.05376329f, 0.01517791f, 0.04238284f, 0.08395181f, 
    0.00275004f, -0.06097142f, 0.07897995f, -0.02124806f, -0.02788791f, -0.14856918f, 0.05725459f, 0.49323136f, 
    -0.27443695f, 0.04972739f, -0.02383131f, 0.10873354f, -0.07748577f, -0.10509458f, 0.04997015f, -0.02974730f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.08238655f, 0.02883695f, -0.04761111f, -0.04159011f, 0.03663675f, 0.01561880f, -0.02450058f, -0.06878503f, 
    -0.04304129f, -0.00328495f, 0.16908027f, 0.03940003f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
