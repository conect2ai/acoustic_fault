#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.76422411f, -0.54339832f, -0.06676949f, 1.03944874f, -0.14479567f, -0.92322588f, -0.15361713f, -0.13970259f, 
    0.01032076f, -0.78437966f, 0.36815104f, 0.98926014f, 0.34574673f, -0.21388008f, 0.35058832f, -0.38163397f, 
    -0.58819628f, -0.19225803f, -0.93147326f, 0.01180494f, -0.20508741f, 0.56770039f, 0.15642372f, 0.34168461f, 
    -0.27610201f, 0.81604558f, -0.66430384f, -0.14071383f, 0.01459845f, -0.08602656f, -0.46053573f, -0.32306463f, 
    -0.84471214f, -0.26471862f, 0.68171751f, 0.21021163f, 0.16078182f, -0.94076306f, -0.82462251f, 0.42707384f, 
    1.10777426f, 0.22248460f, -0.19463411f, 0.08577164f, -0.20178749f, -0.75932062f, -0.13013402f, 0.73961765f, 
    -0.59626663f, -0.67486662f, -0.76607549f, 0.57109821f, -0.38516733f, -0.19044422f, 0.54267865f, 0.50163400f, 
    -0.58577508f, -0.29876277f, 0.34616527f, -0.60779941f, -0.09961643f, 0.09136453f, 0.40564516f, -0.98262352f, 
    0.43108517f, -0.18819541f, -0.46179903f, -0.34434664f, -0.31363797f, -0.54399109f, 0.25553602f, -0.57768512f, 
    0.21110415f, 0.61830807f, -0.62788391f, -0.56190825f, 0.08721785f, 0.18176612f, 0.05979680f, 0.04900651f, 
    0.65507388f, 0.65098113f, 0.21571550f, 0.15129402f, -0.65777248f, 0.18598366f, 0.31372738f, 0.11602247f, 
    0.14117408f, -0.19870014f, -0.20550548f, -0.55025208f, -0.52080333f, -0.19337337f, 0.46012577f, -0.22584094f, 
    -0.40153697f, -0.30234101f, -0.70409191f, 1.00588965f, -0.93025857f, -0.75092560f, -0.22030757f, 0.66051012f, 
    0.23287766f, 0.13350058f, -0.06781692f, -0.15446091f, 0.30604437f, 0.25810501f, 0.19298853f, 0.18519127f, 
    0.56682545f, -0.18396281f, 0.47418228f, -0.51249605f, 0.02857270f, -0.18142664f, -0.02037177f, 0.49102661f, 
    -0.72235858f, -0.61490738f, -0.13037443f, 0.49342760f, -0.14061433f, 0.56718010f, -0.33546636f, -0.30734977f, 
    0.69430757f, -0.70950019f, 0.39455813f, -0.31060842f, -0.34102008f, 0.89926070f, -0.49214414f, 0.32794547f, 
    -0.87504870f, 0.38886651f, 0.04627119f, -0.32305425f, -0.77608156f, 0.21830970f, -0.35010463f, -0.10440867f, 
    -0.90366018f, -0.59045565f, -0.34697008f, 0.57341391f, 0.36088794f, 0.28101209f, -0.32965186f, -0.51481992f, 
    -0.44311786f, 0.74340957f, -0.74803603f, 0.00306182f, -0.03497513f, -0.00789661f, 0.89709908f, -0.20947435f, 
    0.00738782f, 0.20060088f, 0.01767222f, 0.30589813f, 0.14867139f, 0.42725182f, 0.49683225f, 0.63197529f, 
    -0.46837130f, 0.48798835f, -0.11547527f, -0.59195459f, 1.17908847f, -0.56101710f, 0.04089374f, -0.23435305f, 
    0.00449365f, -0.02332090f, -0.40904897f, 0.48190957f, 0.62233919f, -0.40428057f, -0.74590027f, -0.39999112f, 
    -0.14338472f, -0.17414813f, 0.53826517f, 0.46761551f, 0.44064018f, -0.88542002f, -0.93796742f, -0.36316392f, 
    0.00605920f, -0.19120900f, -0.09170664f, 0.30469704f, -0.02373988f, -0.23221020f, 0.82631862f, 0.27098227f, 
    -0.61329675f, -0.10395140f, 0.13165225f, 0.17258148f, -0.24861085f, 0.74893534f, -0.57244217f, -0.91641802f, 
    0.69029188f, -1.07312644f, -0.13657044f, 0.88214189f, -0.32650432f, 0.28983036f, 0.19642138f, 0.10616745f, 
    0.22061707f, -0.08031295f, 0.06272803f, -0.33470929f, -0.09935597f, 0.64114988f, 0.06083795f, 0.09770697f, 
    0.28266138f, -0.64712083f, -0.08996667f, -0.34954309f, -0.05758163f, -0.27024564f, -0.46612537f, 0.36851227f, 
    0.65027851f, 0.24687934f, -0.58693701f, 0.82198536f, 0.12623149f, -0.24501164f, -0.14033237f, 1.05358100f, 
    0.09933183f, -0.69875097f, -0.42690572f, -0.84618169f, 0.98630387f, -0.07859834f, 0.21677387f, 0.37612459f, 
    0.20193110f, 0.19671617f, 0.38337401f, 0.10925609f, 0.28594011f, -0.24014644f, -0.87333494f, -0.56462646f, 
    -0.33539233f, -0.29293069f, -0.00250400f, -0.37300110f, 0.04984007f, 0.59252954f, 0.15318303f, -0.12982610f, 
    0.01972754f, 0.29525518f, -0.49129257f, -0.37914723f, -0.42987749f, 0.00255035f, 0.42598167f, -0.61120433f, 
    0.41864663f, 0.10951179f, -0.09683778f, 0.15003845f, 0.29537046f, 0.35188231f, 0.50862956f, 0.57684910f, 
    0.87367707f, 0.06008131f, 0.28810281f, -0.92813915f, -0.46459234f, -0.11192907f, 0.25606820f, 0.00547114f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.08938095f, -0.02629610f, -0.00325134f, 0.12899457f, -0.09110215f, -0.04847338f, 0.21057634f, -0.27913508f, 
    0.04355350f, 0.36715296f, -0.05780711f, 0.50006396f, -0.02660162f, -0.11030717f, 0.26775500f, 0.48520634f, 
    0.10336404f, 0.23594546f, 0.26509812f, -0.00784860f, 0.16284552f, -0.12303941f, 0.14123181f, -0.06559928f, 
    0.52050662f, 0.25483388f, -0.12258411f, -0.25775331f, -0.31007054f, 0.19225267f, 0.08302112f, -0.09103019f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.00653606f, 0.02193976f, 0.00734523f, -0.02241103f, 0.01195259f, -0.05591582f, 0.04375784f, 0.04510066f, 
    -0.04019290f, -0.04327289f, 0.01109567f, 0.02681033f, -0.05435927f, 0.02320804f, -0.02262516f, -0.05505096f, 
    0.03902746f, 0.02948887f, -0.02574101f, -0.03561855f, -0.05463283f, -0.03721027f, -0.01238252f, 0.00858792f, 
    0.02393672f, -0.05535829f, -0.03384942f, -0.04400745f, 0.03360426f, -0.02637254f, 0.04080504f, -0.00679082f, 
    0.04690561f, -0.04525692f, 0.02985626f, 0.03225385f, -0.06432418f, -0.00480842f, 0.03430828f, -0.04356416f, 
    -0.02214154f, 0.03142712f, -0.05193739f, -0.05113043f, 0.03569285f, 0.03395815f, -0.04042122f, 0.03666774f, 
    0.00923461f, 0.03846684f, -0.03260906f, 0.00921918f, 0.03716366f, -0.04479209f, 0.01332965f, -0.03778972f, 
    0.01950136f, 0.01287919f, -0.04518276f, 0.03663734f, 0.01891804f, -0.05578003f, -0.01934272f, -0.04412182f, 
    0.02033127f, -0.04209433f, -0.05694639f, 0.02952954f, -0.05043624f, -0.02412131f, -0.04592229f, 0.01057858f, 
    -0.05022381f, 0.01787627f, -0.02792783f, -0.02317222f, 0.01833502f, 0.00745669f, 0.03058409f, 0.01340242f, 
    -0.01471596f, 0.03889892f, 0.00889875f, -0.06324369f, -0.04003800f, 0.03098165f, -0.04505104f, -0.04346791f, 
    -0.00730048f, -0.05275252f, -0.03145009f, -0.02567731f, -0.02447945f, 0.01515121f, -0.05618911f, -0.02900226f, 
    0.02717439f, -0.06352215f, 0.04157050f, 0.03487860f, -0.02348024f, -0.06497528f, 0.02428173f, 0.05097753f, 
    0.03596273f, 0.02612191f, 0.02498584f, 0.01086144f, -0.01913499f, -0.02662821f, -0.06048810f, -0.05945002f, 
    -0.04220304f, 0.02352167f, 0.04224649f, 0.04405639f, 0.04766365f, 0.06102176f, -0.02396991f, -0.06848982f, 
    0.01393044f, -0.03186845f, 0.01551950f, 0.04889436f, -0.00360467f, -0.05045829f, 0.05059904f, -0.01394221f, 
    0.01852378f, -0.05539617f, -0.03928293f, -0.04631685f, 0.04406291f, -0.03831011f, 0.02237452f, 0.03669298f, 
    0.00576688f, 0.01015673f, -0.03867156f, 0.04639592f, -0.04096476f, -0.02610778f, 0.00927313f, -0.03820997f, 
    -0.02040138f, 0.04592086f, -0.06490565f, -0.00064909f, -0.05742254f, -0.03170229f, 0.03032728f, 0.02040950f, 
    0.04201465f, -0.02304854f, -0.00004801f, 0.00504665f, 0.02687025f, -0.03001902f, -0.05713167f, -0.02327454f, 
    0.03948581f, -0.00835042f, -0.01869543f, -0.04856891f, -0.04511616f, -0.00918653f, -0.00823014f, 0.02257671f, 
    -0.01934046f, -0.02860311f, 0.01233727f, -0.01953766f, -0.02477584f, 0.02860611f, 0.02089541f, 0.04756353f, 
    0.01623169f, -0.00115323f, 0.05352588f, -0.02925621f, -0.02759819f, -0.00632573f, -0.05411297f, -0.06692297f, 
    0.02494056f, -0.02008182f, -0.02018165f, 0.02492225f, 0.04913050f, -0.04622873f, -0.02698729f, -0.00957531f, 
    -0.02860835f, 0.04305288f, -0.03443797f, -0.02239506f, 0.03678099f, -0.05695551f, 0.03361638f, -0.04069457f, 
    0.00492074f, 0.03687717f, 0.04405784f, -0.05249128f, 0.00723597f, 0.03655859f, 0.00973889f, 0.00164683f, 
    -0.05817477f, -0.03066180f, -0.05633686f, 0.00644056f, -0.01051553f, -0.06108868f, -0.02890909f, 0.04155038f, 
    0.05058951f, 0.01116913f, -0.00264229f, -0.02989219f, -0.01865746f, -0.04640933f, -0.05223151f, -0.05345698f, 
    -0.04271121f, 0.03494562f, -0.01352202f, 0.01503827f, 0.03240230f, -0.03067906f, 0.00747427f, 0.01637137f, 
    -0.05979644f, 0.01125055f, -0.01456740f, 0.05039176f, 0.02163090f, -0.05461241f, 0.00572159f, -0.03144152f, 
    -0.05052730f, -0.02690171f, 0.04360339f, 0.05380219f, 0.03380050f, 0.02809508f, 0.04484182f, -0.01848874f, 
    -0.00658719f, -0.01972658f, 0.04890890f, -0.00158920f, -0.04509285f, -0.02442770f, 0.02894382f, 0.01991851f, 
    0.00217552f, -0.05245028f, 0.01858244f, -0.05711493f, -0.01405993f, -0.00990671f, -0.00134955f, 0.03417762f, 
    -0.06015886f, -0.00857795f, -0.03907991f, -0.05884157f, -0.02562273f, -0.01023353f, -0.05855732f, 0.03322828f, 
    -0.03852726f, 0.02777037f, -0.01707674f, 0.00400446f, -0.02556617f, -0.03510966f, -0.03818350f, 0.00613531f, 
    -0.03262401f, -0.04106126f, -0.05366397f, 0.03306508f, -0.04720791f, 0.01898563f, -0.02029856f, -0.00598486f, 
    0.24766193f, 0.08043290f, 0.22798106f, -0.09655564f, -0.05547038f, 0.09140528f, 0.17875503f, -0.01426092f, 
    0.23392624f, -0.32473123f, -0.73387671f, -0.28557155f, -0.13283890f, -0.25638765f, -0.02050274f, 0.16079812f, 
    0.07799628f, -0.06857956f, -0.11654449f, -0.36493331f, -0.11943419f, -0.25791910f, -0.04327761f, -0.03507037f, 
    -0.10127609f, -0.06987602f, 0.19088651f, 0.08785380f, 0.16500199f, 0.28544441f, -0.03887554f, 0.17463319f, 
    -0.32576859f, 0.08572251f, 0.01581345f, 0.00204408f, 0.19708170f, -0.76789629f, -0.04160243f, -0.00825315f, 
    -0.00309262f, 0.13953154f, 0.12949240f, 0.21717761f, 0.16293648f, 0.14473779f, 0.18162780f, -0.01965116f, 
    -0.12179303f, 0.11433246f, -0.12014735f, -0.03249120f, -0.06942867f, 0.16247775f, -0.21974324f, -0.23293692f, 
    -0.31169638f, -0.04363546f, -0.04218470f, -0.23601551f, 0.06223644f, -0.01586320f, 0.00276855f, -0.19311923f, 
    0.04835332f, 0.10870479f, 0.03641985f, 0.19613370f, -0.27577925f, 0.18261501f, 0.02092272f, 0.07946602f, 
    -0.12637980f, 0.04022066f, -0.53945094f, 0.04311489f, 0.09622740f, -0.21426801f, -0.00496254f, -0.26333347f, 
    -0.19414851f, 0.11725630f, -0.31306213f, -0.22132914f, -0.09973317f, 0.00655027f, 0.09925079f, -0.11966374f, 
    0.06694862f, -0.07403086f, 0.15880232f, 0.02891040f, 0.46838921f, 0.19917168f, -0.06873233f, 0.04274821f, 
    0.08348447f, 0.13305321f, 0.12474809f, 0.28311101f, -0.06521616f, -0.38605765f, 0.04273361f, -0.05556115f, 
    0.02733034f, 0.05871158f, 0.18017370f, -0.06510737f, -0.21820669f, -0.41740823f, -0.37252998f, 0.01928764f, 
    -0.13216250f, -0.18278798f, -0.19498715f, -0.20601112f, 0.24141446f, -0.17438093f, 0.26046288f, 0.07428229f, 
    -0.05471292f, 0.01616015f, -0.22411913f, 0.03060180f, -0.09762873f, -0.06486731f, -0.00995115f, -0.07066272f, 
    0.16100921f, -0.03418275f, 0.16484889f, -0.20722076f, 0.04595436f, 0.11607210f, -0.07303613f, 0.20959893f, 
    -0.05274763f, -0.03227864f, -0.02111061f, 0.21291989f, 0.11652160f, -0.00352255f, 0.03163768f, 0.09972234f, 
    0.23291020f, 0.02480645f, 0.39800957f, -0.06030294f, 0.09139589f, 0.00004694f, 0.21243389f, 0.10312344f, 
    -0.00192388f, 0.55918008f, -0.07415112f, -0.35814348f, -0.26131967f, 0.18069865f, 0.13817506f, -0.08878152f, 
    0.00554936f, -0.05577651f, 0.45418030f, -0.15679079f, -0.74116921f, 0.17800446f, -0.19207992f, 0.03954136f, 
    0.29308528f, -0.03555807f, 0.04040657f, -0.06826077f, -0.30071077f, -0.29760569f, 0.00333636f, -0.18819778f, 
    0.01572608f, 0.13756925f, -0.04524789f, 0.02809521f, 0.11929315f, 0.30151901f, -0.15795854f, -0.08937845f, 
    0.07173830f, -0.03060190f, 0.11916813f, 0.02645085f, -0.04778406f, 0.33106953f, 0.20907664f, 0.40463826f, 
    0.08988357f, 0.07552033f, 0.27517655f, 0.08341283f, 0.01605580f, 0.05872033f, -0.30595794f, -0.19154698f, 
    -0.08897466f, 0.01338963f, 0.01878229f, 0.19606896f, 0.07597786f, 0.07690006f, -0.23418789f, -0.35352921f, 
    -0.72349644f, -0.27759847f, -0.14512330f, 0.09344079f, 0.18937002f, 0.07143194f, 0.04073900f, -0.01571962f, 
    -0.01319823f, -0.23707694f, -0.05689844f, -0.09863634f, 0.06780600f, 0.03996092f, -0.00736286f, 0.08439271f, 
    -0.07030981f, 0.17589104f, 0.21397755f, 0.29430246f, -0.19716935f, 0.12430024f, -0.16721471f, -0.05123865f, 
    -0.02420726f, 0.05645322f, -0.35953537f, -0.46761563f, 0.16029309f, 0.03211344f, -0.22497958f, 0.24614950f, 
    -0.06468109f, 0.07891860f, 0.09158283f, 0.11382897f, -0.29756138f, -0.68073869f, 0.00497721f, -0.27124578f, 
    0.24624532f, 0.24957077f, 0.05771343f, 0.04248961f, -0.01217257f, 0.43646559f, 0.26984215f, -0.04793466f, 
    0.02726959f, 0.15300055f, 0.08722274f, 0.09240764f, -0.07990900f, -0.02937559f, -0.01601362f, 0.10073002f, 
    0.07369356f, 0.04594826f, -0.11329983f, 0.10833723f, -0.02837675f, -0.00429715f, -0.26736948f, 0.10732072f, 
    -0.49496803f, -0.13249519f, -0.01710596f, 0.05786260f, 0.05134548f, 0.09916658f, -0.26758015f, -0.09763096f, 
    -0.32991284f, -0.56415772f, 0.09188097f, 0.11370743f, -0.03637715f, -0.17831458f, -0.01929631f, 0.04275573f, 
    -0.22742011f, 0.15535860f, -0.02298061f, -0.01665991f, -0.15017836f, -0.01549456f, 0.18198323f, 0.02616283f, 
    0.01302856f, -0.10414117f, -0.17568149f, 0.08472977f, 0.11607675f, -0.00938360f, 0.01386179f, -0.27559206f, 
    -0.35670730f, -0.28023878f, -0.06914754f, 0.02365579f, -0.11801939f, 0.07179224f, 0.01946445f, -0.02506215f, 
    0.05207923f, -0.00415110f, -0.00994283f, 0.14227745f, 0.13428158f, 0.35959253f, -0.14486350f, 0.05386415f, 
    0.11024019f, 0.01963391f, -0.17314407f, 0.05772178f, -0.12310522f, -0.22380705f, -0.62398070f, -0.07477532f, 
    -0.19272517f, 0.06182950f, 0.04772933f, -0.07882705f, -0.06704343f, -0.08870681f, 0.22146425f, 0.36769095f, 
    0.02280440f, -0.11218719f, 0.03945225f, 0.08515880f, -0.05117959f, -0.18963568f, -0.00659191f, 0.14925432f, 
    -0.33114368f, -0.03989619f, -0.00835824f, 0.05425139f, -0.02654211f, 0.01218397f, -0.11003184f, -0.26523775f, 
    0.44210300f, 0.31430680f, 0.07212922f, 0.12903376f, 0.17602621f, 0.35180163f, 0.03353843f, -0.16151476f, 
    0.03762810f, -0.05659718f, -0.10363130f, -0.02227214f, 0.04498319f, 0.10359412f, 0.08033879f, -0.00368270f, 
    0.07761988f, -0.28996739f, -0.30598888f, -0.27717423f, 0.09536809f, -0.11099665f, -0.06781308f, 0.11979944f, 
    0.01186942f, 0.03519104f, -0.21074452f, -0.11998570f, 0.01346478f, 0.06488628f, -0.07369133f, 0.05892989f, 
    0.03642996f, 0.02557801f, -0.21540861f, -0.24106669f, -0.11975855f, -0.31870568f, -0.10497212f, -0.14516164f, 
    0.05676522f, 0.06603716f, 0.10752127f, 0.00954094f, -0.01038884f, -0.04658063f, 0.00292835f, 0.06503260f, 
    -0.08375935f, 0.02005446f, 0.07433783f, 0.04817282f, -0.05887656f, -0.06734460f, 0.11279274f, 0.19536023f, 
    0.05586772f, -0.01285365f, -0.00840575f, 0.05452047f, -0.08191781f, -0.06245360f, -0.20819303f, 0.12728079f, 
    0.32197517f, -0.00616740f, 0.16794011f, 0.07413415f, -0.06212604f, 0.17603107f, -0.14788847f, 0.29270682f, 
    0.26910973f, 0.17026927f, -0.02975263f, 0.09446315f, 0.16833000f, -0.00066523f, -0.06503483f, -0.23951121f, 
    -0.28724250f, -0.17121167f, -0.23786765f, 0.05843253f, -0.10600112f, 0.14574458f, -0.07757355f, -0.14137903f, 
    -0.17213117f, -0.18083258f, -0.08686122f, -0.14487405f, 0.13949831f, -0.22598557f, -0.12573037f, 0.11057184f, 
    -0.06312775f, 0.14770298f, -0.00090315f, 0.01332727f, -0.04175857f, 0.02318856f, -0.19323410f, -0.11093412f, 
    0.08680732f, 0.01517557f, 0.14804155f, -0.07265172f, 0.09954176f, -0.16097811f, -0.21723236f, 0.41402274f, 
    0.17865810f, 0.11261050f, 0.26624000f, -0.08022719f, 0.09506629f, 0.05250156f, 0.06049986f, -0.14218193f, 
    0.11248653f, 0.04656782f, -0.00763599f, 0.00190612f, -0.02015041f, -0.09306664f, -0.16304877f, -0.00758030f, 
    0.02603920f, -0.13050011f, 0.09553977f, 0.15594552f, 0.03828015f, 0.05376544f, -0.24658616f, 0.01235252f, 
    -0.30592233f, 0.21158938f, 0.05843769f, -0.20520788f, 0.06917896f, -0.17303602f, -0.03737665f, -0.11266471f, 
    0.34285367f, 0.06679196f, -0.21335955f, -0.06819291f, -0.05183025f, -0.03466539f, 0.01352786f, 0.08464898f, 
    -0.10637030f, -0.05967287f, -0.10856964f, 0.11161666f, -0.09798740f, -0.03941265f, 0.05987550f, 0.04486139f, 
    0.22803673f, 0.40474835f, 0.26118097f, 0.25257695f, 0.04143206f, 0.00658125f, 0.04122108f, 0.08702818f, 
    -0.10028851f, 0.07277667f, -0.15487631f, 0.00491517f, 0.05346163f, 0.14791739f, -0.01733656f, -0.02650071f, 
    -0.15033345f, 0.05341716f, -0.17934318f, 0.04591199f, 0.04014734f, -0.04878350f, -0.06034651f, -0.17060944f, 
    -0.08073641f, 0.12401033f, 0.13910644f, 0.18566883f, 0.07035716f, 0.26506358f, 0.46808350f, -0.00137850f, 
    0.00513388f, 0.14616798f, 0.27611384f, 0.11670718f, -0.20857847f, 0.01866710f, -0.15174642f, -0.10104828f, 
    0.12803216f, 0.09582147f, 0.02879672f, 0.03534547f, -0.18430078f, -0.01667463f, 0.01748724f, 0.00388951f, 
    0.04522656f, 0.05087793f, 0.03312562f, -0.10177229f, 0.09248759f, 0.01027705f, 0.20945992f, -0.22577475f, 
    -0.42571774f, -0.30694655f, 0.13733824f, 0.22377256f, -0.00839291f, -0.02615665f, 0.34877220f, -0.13516641f, 
    -0.37752321f, 0.24590981f, -0.83654809f, -0.09870684f, -0.06922354f, 0.13408139f, 0.07474269f, 0.04814991f, 
    -0.12491690f, 0.00715420f, 0.10237882f, 0.06460211f, 0.12950705f, -0.03289011f, -0.01303174f, -0.00580563f, 
    -0.27562651f, -0.24383309f, 0.26318696f, 0.19181916f, -0.24792944f, 0.02152251f, 0.17122161f, -0.02214260f, 
    0.01527379f, 0.07014406f, -0.12541708f, -0.14487576f, 0.10759690f, 0.47990417f, 0.01235978f, 0.09416292f, 
    -0.05239409f, 0.05893669f, 0.03468420f, 0.05968504f, -0.09645332f, -0.38524479f, -0.19877663f, 0.10604183f, 
    0.35914224f, -0.05728236f, 0.18836765f, 0.13015690f, 0.09368901f, -0.29594043f, 0.02864511f, 0.47549126f, 
    -0.06675788f, -0.04784459f, 0.04424641f, 0.10216340f, -0.03026401f, 0.09996933f, -0.10409516f, 0.49268579f, 
    0.09136454f, 0.09168922f, -0.03822134f, 0.00943631f, 0.00385898f, 0.12445872f, -0.12092990f, -0.20845798f, 
    -0.18194632f, -0.10855719f, -0.02501013f, -0.07247827f, 0.12423339f, 0.03456908f, -0.32219902f, -0.11774727f, 
    -0.00398749f, 0.00085698f, -0.01257184f, -0.15252392f, 0.02252982f, -0.12932056f, -0.02784235f, 0.04118430f, 
    -0.11703282f, -0.03798267f, -0.00308504f, 0.01295927f, -0.04241421f, 0.13686800f, -0.04427604f, 0.09256615f, 
    0.15599236f, -0.01765607f, -0.04551703f, -0.17301303f, -0.62975615f, 0.00023787f, -0.03931197f, 0.05397863f, 
    0.14660007f, -0.09452303f, 0.09071386f, -0.43399963f, -0.27718538f, 0.05668838f, -0.24862327f, 0.29404792f, 
    -0.22306149f, 0.22801714f, 0.03900622f, 0.17293167f, 0.00502594f, 0.15295745f, -0.00233687f, -0.01274640f, 
    -0.04710954f, -0.12116179f, 0.10425573f, -0.05612241f, -0.14836870f, -0.06947117f, 0.30748373f, 0.82436550f, 
    0.12180209f, 0.04467617f, -0.10811589f, 0.13966098f, 0.09252436f, 0.13790421f, -0.18141547f, 0.13858141f, 
    0.36618781f, 0.06579825f, 0.03747172f, -0.15751149f, 0.18201555f, 0.38925666f, -0.02335641f, -0.21845049f, 
    0.27848303f, -0.00885017f, 0.04529400f, -0.02744524f, 0.01625960f, 0.06039691f, -0.16389740f, -0.03905335f, 
    0.20874038f, -0.43916783f, -0.56671977f, 0.06138986f, -0.14953920f, 0.13792993f, 0.10028941f, -0.03727725f, 
    0.11129756f, 0.00650222f, -0.14216340f, 0.01516048f, -0.07692955f, 0.06101391f, -0.16970880f, 0.14046267f, 
    -0.03171075f, 0.02337212f, 0.11596874f, 0.18831681f, 0.12698621f, -0.18441540f, -0.00903195f, -0.19616713f, 
    -0.05920566f, 0.05130751f, -0.06344440f, -0.30539307f, 0.14647859f, -0.15744448f, 0.08008704f, 0.13072489f, 
    0.02829742f, -0.04705302f, 0.31757638f, -0.16086042f, -0.02364744f, -0.04515214f, 0.28563458f, -0.23045434f, 
    0.15604840f, -0.08770873f, 0.07034773f, 0.00636309f, -0.03487182f, 0.21289581f, -0.57930845f, -0.84601218f, 
    -0.13117644f, -0.01815958f, 0.10692842f, 0.17981942f, -0.06564076f, 0.05661005f, -0.08786449f, 0.16384907f, 
    -0.04495418f, -0.01139026f, 0.22347191f, -0.23012502f, 0.09176437f, 0.22685789f, 0.00979852f, -0.14299506f, 
    -0.11845029f, -0.48903403f, 0.05424818f, 0.24121515f, 0.02564162f, 0.12772021f, 0.17903247f, -0.04666880f, 
    -0.00433524f, -0.14606740f, 0.02286646f, -0.29004076f, -0.07551475f, -0.16712913f, 0.12768066f, 0.02840938f, 
    0.01074007f, -0.10189059f, -0.07556254f, 0.04118172f, -0.12254778f, 0.10096525f, 0.02945501f, 0.05502173f, 
    0.03595778f, -0.03487740f, 0.07379964f, 0.36137760f, 0.04112315f, 0.11679095f, 0.06912024f, 0.10941526f, 
    0.06920074f, -0.13631034f, -0.28112575f, 0.19447458f, 0.10262050f, -0.09601187f, -0.18746035f, 0.12446968f, 
    -0.14344916f, 0.08331143f, 0.22662294f, -0.03635476f, 0.06948182f, -0.58205163f, -0.00808319f, -0.10989580f, 
    0.13008511f, -0.02300689f, -0.01429029f, -0.24086846f, 0.01761474f, -0.07907333f, 0.12843363f, 0.08242494f, 
    0.19124030f, 0.07466362f, 0.04948232f, 0.11686900f, -0.26423067f, -0.03258621f, 0.09677168f, -0.02922783f, 
    -0.03504274f, -0.15335855f, -0.18862700f, -0.18232460f, 0.14020349f, 0.07692283f, 0.08320251f, 0.01594796f, 
    0.03367670f, 0.01008762f, -0.00141541f, 0.02909278f, -0.02313202f, 0.15707690f, 0.22251895f, 0.21432106f, 
    0.03370914f, 0.00148936f, -0.00062131f, 0.02165612f, -0.05382126f, -0.03793311f, -0.04678882f, 0.03908048f, 
    -0.03169967f, 0.00954378f, 0.01691340f, -0.04951781f, -0.04858201f, -0.02494437f, -0.01748594f, 0.01783217f, 
    -0.05873207f, 0.03585429f, -0.01910524f, -0.01936301f, 0.03322760f, -0.04949005f, -0.04316024f, -0.01337827f, 
    -0.06404641f, 0.03175142f, -0.03761905f, -0.00206639f, -0.05637312f, -0.01950237f, 0.02542038f, -0.05002734f, 
    0.02437011f, -0.05605689f, -0.00547364f, -0.01228558f, 0.00596407f, -0.02482306f, -0.03321344f, 0.01338737f, 
    0.02058062f, 0.04431419f, -0.01141785f, -0.06209970f, -0.03791459f, 0.00089261f, -0.02624038f, 0.02995452f, 
    0.00263393f, -0.05222994f, 0.04456819f, -0.00837822f, -0.03333430f, -0.03663627f, -0.03308519f, -0.02423397f, 
    -0.00341786f, -0.05192127f, 0.04291923f, -0.00275173f, -0.01468339f, -0.03684760f, -0.04083272f, 0.04338498f, 
    0.01793732f, 0.02747090f, -0.04489109f, -0.01880761f, -0.04095882f, -0.01356727f, 0.00160358f, -0.01105941f, 
    -0.02259738f, -0.03609742f, -0.01995007f, -0.02223358f, -0.05378922f, 0.03727965f, 0.03011599f, -0.05767406f, 
    0.02191409f, 0.03885151f, -0.00783770f, 0.02754475f, -0.02354181f, -0.01376025f, 0.01511576f, -0.02961900f, 
    -0.02999984f, -0.04058945f, 0.04984330f, 0.05266119f, 0.00732487f, -0.03487782f, -0.00200234f, 0.03680829f, 
    -0.01786020f, -0.00191324f, 0.03680905f, 0.04024778f, 0.04432433f, 0.03022361f, -0.03068183f, -0.04728861f, 
    -0.03898285f, 0.02538995f, -0.03907664f, -0.03006423f, 0.03765169f, 0.04204404f, -0.05389302f, 0.02682755f, 
    0.00144967f, 0.01730525f, 0.02297354f, 0.05004404f, -0.01798357f, -0.00772460f, 0.01821326f, -0.01533841f, 
    -0.00119321f, -0.06036558f, -0.04012622f, 0.01680780f, 0.02421861f, -0.01296615f, -0.02162236f, -0.06285036f, 
    0.00354130f, -0.06638165f, -0.01770131f, -0.01045240f, 0.02379371f, -0.02528016f, 0.03647389f, -0.05603971f, 
    -0.00473234f, 0.00915189f, -0.03204286f, -0.00821551f, -0.01261685f, -0.01855544f, 0.03441496f, 0.03257854f, 
    -0.01645628f, -0.00840415f, 0.01528409f, -0.02715438f, 0.04192459f, -0.00540253f, 0.00831179f, 0.04100998f, 
    0.01548892f, -0.04186468f, -0.03985160f, -0.04724620f, -0.03932504f, -0.03464016f, 0.02138657f, -0.04707137f, 
    -0.03731278f, -0.01628685f, 0.03651416f, -0.05632066f, 0.00412538f, -0.03925797f, 0.00326158f, -0.02315784f, 
    -0.01231445f, 0.04667271f, 0.03909562f, 0.04181646f, -0.02986922f, 0.04644944f, -0.01856246f, -0.02736660f, 
    0.00620179f, -0.06371251f, 0.03097945f, 0.01343697f, 0.00396143f, -0.04506328f, -0.03527717f, -0.04346295f, 
    -0.04084804f, 0.03617894f, -0.00913959f, -0.01314203f, -0.02579261f, -0.04520078f, -0.01210444f, -0.03373370f, 
    -0.03418032f, -0.04136812f, 0.03476448f, 0.03452072f, 0.04265691f, -0.02400392f, -0.00272798f, -0.02288621f, 
    -0.00160363f, -0.03801994f, -0.02706061f, -0.01696725f, -0.06175851f, -0.02722131f, 0.04400353f, -0.05656869f, 
    -0.00695242f, -0.03874155f, 0.00551959f, -0.04132267f, -0.00423600f, 0.02396476f, -0.06118472f, -0.01409496f, 
    -0.02957283f, 0.01725943f, 0.03802290f, -0.01731862f, -0.00738065f, -0.03421462f, 0.03077303f, -0.05462335f, 
    0.02913421f, -0.00783933f, -0.01884638f, -0.01102520f, -0.02549211f, 0.03652006f, -0.02824640f, -0.01612726f, 
    0.03692408f, -0.01295438f, -0.06486193f, 0.00728668f, 0.02332945f, 0.00797460f, -0.04573622f, 0.03211967f, 
    -0.04666800f, 0.02164086f, -0.04793962f, 0.04947718f, -0.01688269f, -0.03028063f, 0.01610256f, -0.02925970f, 
    -0.04406327f, -0.02508713f, -0.02580619f, 0.01572403f, -0.05367422f, 0.01216152f, 0.02668681f, 0.02188616f, 
    0.03749766f, 0.01103151f, -0.03199242f, -0.05057926f, -0.05300178f, 0.03533854f, 0.03740543f, -0.00908839f, 
    -0.05894709f, 0.04019893f, 0.03526775f, -0.02513935f, -0.05530304f, -0.05658452f, 0.05060929f, -0.04581488f, 
    -0.04669295f, 0.01991147f, -0.04137369f, 0.03911863f, 0.03854850f, -0.05934773f, -0.01296506f, -0.03215236f, 
    -0.01071825f, 0.00006186f, 0.01169334f, 0.04296040f, -0.03276760f, -0.00276403f, -0.02593828f, 0.04806454f, 
    0.23581196f, 0.19531250f, -0.07967164f, 0.06588948f, -0.08102012f, 0.19900528f, 0.05531573f, 0.12607896f, 
    0.01519753f, -0.91952848f, -0.46943724f, 0.04827397f, 0.08252286f, -0.00832980f, -0.06064994f, -0.00739898f, 
    -0.13203257f, -0.06008040f, -0.91261280f, -0.27016851f, 0.02783165f, 0.08354953f, 0.07666343f, -0.01640148f, 
    -0.26173413f, 0.09957777f, -0.03178591f, 0.04985693f, 0.23066658f, 0.04270392f, -0.12161126f, -0.09470091f, 
    -0.19047806f, -0.07985003f, -0.04272291f, 0.10826290f, 0.85184860f, -0.88411260f, -0.18675697f, 0.00118544f, 
    -0.03752230f, 0.02410438f, 0.14050031f, 0.12308989f, 0.03321965f, 0.09801005f, 0.09653103f, -0.08277754f, 
    -0.05801843f, -0.13398263f, -0.25347674f, -0.04330443f, 0.02366540f, 0.14520593f, -0.17105947f, 0.01796287f, 
    -0.34447029f, 0.10097604f, -0.32144743f, 0.14921765f, -0.02351219f, 0.11207358f, 0.13116968f, -0.21832980f, 
    0.15025201f, -0.16235293f, 0.11546557f, 0.09583157f, 0.00301119f, 0.00252753f, 0.04679157f, -0.10564930f, 
    -0.05656867f, -0.18687083f, -0.20952825f, 0.17716427f, -0.08009502f, 0.12892975f, 0.15493822f, -0.15353696f, 
    0.19677895f, 0.18065853f, -0.56506366f, 0.19820052f, -0.07408598f, 0.01452421f, 0.01952119f, -0.04057261f, 
    0.10142443f, 0.09379980f, 0.18101345f, 0.07841770f, 0.29269788f, 0.21270922f, -0.09215812f, 0.04077057f, 
    0.18395136f, -0.12466700f, -0.18680201f, 0.56521279f, 0.09975703f, -0.31377488f, -0.03817014f, -0.04656659f, 
    -0.07394993f, 0.02431491f, 0.09294511f, 0.03677905f, -0.24538925f, 0.11655891f, 0.17187524f, -0.23945153f, 
    -0.24995251f, -0.19462441f, 0.00988671f, 0.01085470f, 0.16365048f, -0.18785557f, 0.27363265f, 0.37725693f, 
    -0.08420750f, -0.06729177f, -0.06618237f, -0.07840558f, 0.15775099f, 0.24577071f, 0.13490917f, 0.02530675f, 
    0.02440612f, -0.12005235f, -0.03340216f, -0.00521612f, 0.19214116f, -0.08851308f, -0.04445285f, 0.18247384f, 
    -0.14116710f, -0.23499776f, -0.10221156f, -0.00445009f, 0.01879349f, 0.07801500f, 0.01515806f, -0.01647843f, 
    0.26343164f, 0.06198694f, 0.34970436f, 0.12588522f, -0.01412815f, -0.00725141f, 0.06395861f, -0.07654014f, 
    -0.16047056f, 1.06098604f, 0.15497829f, -0.23643851f, -0.23295690f, 0.10069457f, 0.15745406f, -0.05133771f, 
    0.04877615f, 0.08236734f, 0.19326387f, -0.60027128f, -0.07693063f, 0.01630842f, -0.14776459f, -0.14188732f, 
    0.07123779f, 0.07214961f, 0.09701610f, -0.68721116f, -0.29234684f, -0.27152240f, 0.06736758f, -0.30764124f, 
    0.18350323f, 0.10334209f, -0.01002873f, 0.17188281f, 0.07076006f, 0.04987009f, -0.29977596f, 0.05557502f, 
    -0.05168907f, -0.10143129f, 0.14377931f, 0.03273313f, 0.03792073f, 0.34622273f, 0.07820661f, 0.08913931f, 
    0.19327578f, 0.02779724f, 0.27436715f, -0.07068878f, 0.07436478f, -0.06043899f, 0.20383918f, -0.21985242f, 
    -0.01892107f, -0.01047787f, 0.07194338f, -0.14525121f, -0.15889406f, 0.25157347f, -0.18845418f, -0.75125712f, 
    -0.35665363f, -0.56274259f, 0.21453318f, 0.26476470f, 0.17403148f, 0.03642463f, -0.00966673f, -0.10367355f, 
    0.28521988f, -0.20902283f, 0.04011048f, 0.01101273f, 0.18276136f, 0.07508830f, 0.11535919f, 0.14179876f, 
    0.09736420f, -0.04274133f, 0.11043207f, 0.01500412f, 0.00961510f, 0.02993432f, -0.05480711f, -0.09543147f, 
    0.03099328f, -0.09001072f, -1.26857173f, -0.42117548f, 0.63516647f, -0.13110986f, -0.15050544f, 0.06300690f, 
    0.12450868f, -0.03497911f, -0.21892431f, -0.00231508f, -0.43546447f, -0.21324480f, -0.02980539f, -0.19873005f, 
    0.26528296f, -0.12391603f, 0.07181842f, 0.20912191f, -0.01799162f, 0.26779428f, 0.24415918f, 0.10242970f, 
    0.02455625f, 0.04728024f, 0.03555967f, -0.00726097f, 0.00083718f, 0.24781270f, -0.16699818f, -0.11868466f, 
    -0.19575900f, -0.10037173f, -0.19260654f, -0.08478869f, -0.02789567f, -0.07844350f, 0.11446963f, 0.05863185f, 
    -0.09476562f, 0.06208429f, 0.07005282f, 0.27129796f, 0.03609692f, 0.00323528f, 0.08755564f, -0.48032799f, 
    -0.44756722f, -0.62555033f, -0.04973503f, -0.01091377f, -0.24844493f, -0.11396255f, 0.09788441f, 0.21193039f, 
    0.30582204f, -0.10457449f, -0.12674123f, -0.04180182f, 0.02210142f, 0.10178004f, 0.09449901f, 0.09921461f, 
    0.13798583f, 0.16984579f, -0.01824941f, -0.40932241f, 0.00412353f, 0.14861909f, 0.10569443f, 0.13365711f, 
    0.07815201f, -0.06181155f, -0.04293176f, -0.30057442f, 0.05307696f, 0.03046516f, 0.09191789f, 0.07055533f, 
    0.10691043f, -0.10714243f, 0.07046216f, -0.21397385f, -0.15446138f, 0.06023177f, 0.03440696f, -0.05503687f, 
    0.03878318f, -0.06855592f, -0.20935062f, -0.00999112f, -0.11650831f, -0.36893341f, 0.08913784f, -0.08239716f, 
    0.05300687f, 0.15243003f, -0.07995773f, 0.25681478f, 0.09870137f, 0.20706554f, 0.12767218f, -0.05879048f, 
    -0.03651521f, 0.09395581f, -0.31237155f, 0.06946376f, -0.04294558f, -0.03453466f, -0.20580642f, 0.14451212f, 
    0.09066996f, 0.02951330f, 0.04629852f, 0.04468523f, 0.08371129f, -0.04228213f, -0.11066341f, 0.25366074f, 
    0.08603831f, -0.13056126f, -0.09811060f, 0.12283756f, -0.24474515f, -0.03245232f, -0.02225070f, 0.22668941f, 
    -0.35470510f, 0.06495089f, -0.02072895f, 0.14230098f, 0.11525305f, -0.06652688f, -0.13009408f, -0.33001792f, 
    -0.13494787f, -0.16723716f, 0.13759308f, -0.08562134f, -0.04371250f, -0.04694626f, 0.09161792f, 0.23757404f, 
    -0.04711021f, -0.13114621f, 0.00686351f, -0.03136415f, -0.12891725f, 0.03621225f, 0.04723978f, 0.12627766f, 
    -0.04755399f, 0.16033751f, 0.17029013f, -0.13152972f, 0.04544448f, 0.23779382f, -0.10649705f, -0.14644429f, 
    0.03882691f, -0.19895750f, 0.20625019f, 0.01924481f, 0.12684579f, -0.11354116f, -0.00775257f, 0.06551639f, 
    0.17486426f, 0.01347332f, -0.06886249f, 0.15059184f, -0.02849117f, -0.20202340f, 0.15611146f, -0.30587974f, 
    0.01892759f, 0.10670777f, -0.21190472f, 0.11131459f, -0.18187834f, -0.29223722f, -0.07374182f, 0.07427228f, 
    0.03842862f, 0.00065480f, 0.19783917f, 0.10697463f, 0.09327099f, -0.04871754f, 0.13063070f, 0.06766476f, 
    0.03170222f, 0.06563788f, 0.08628447f, -0.05674258f, -0.14365911f, 0.07315429f, 0.04816128f, -0.08679003f, 
    0.07610197f, -0.03782835f, -0.25473732f, -0.03808013f, 0.19238310f, 0.01743717f, 0.04900820f, 0.17502846f, 
    0.32826689f, -0.15649965f, 0.02557430f, -0.04171877f, 0.13287137f, 0.10973124f, 0.03700257f, 0.07688344f, 
    0.13949151f, -0.14550434f, 0.04933783f, -0.11152420f, -0.04971568f, 0.18365866f, 0.07342611f, 0.17829531f, 
    -0.21183544f, -0.15857437f, 0.04060310f, -0.22288023f, 0.17054678f, 0.07080837f, 0.10719313f, 0.21015652f, 
    0.10578480f, 0.11665698f, -0.06333669f, 0.16959827f, -0.06253033f, 0.02504340f, 0.10774947f, 0.09296083f, 
    0.18836814f, -0.14692689f, -0.25564310f, -0.19896968f, -0.23781575f, 0.34489694f, -0.24595261f, -0.06386172f, 
    0.04351659f, 0.02465820f, -0.05037458f, 0.14398663f, -0.03071104f, 0.02101527f, -0.19913423f, -0.03227348f, 
    0.20959550f, -0.11272328f, -0.04166275f, 0.19091931f, 0.31271723f, 0.08962160f, 0.06808644f, 0.34193018f, 
    -0.08135765f, 0.39581490f, -0.09104539f, -0.02291913f, 0.00412056f, -0.09328914f, -0.08883848f, 0.34409228f, 
    -0.12449666f, -0.07381314f, -0.10828191f, -0.03329330f, 0.06641451f, 0.08401190f, -0.04743373f, -0.08147861f, 
    -0.05225283f, 0.00109768f, -0.17020638f, -0.01576889f, 0.20955208f, 0.09065647f, -0.04559899f, 0.08692914f, 
    -0.01627522f, -0.18643732f, -0.10088430f, -0.02037084f, -0.11730502f, -0.07499610f, 0.11680290f, 0.04624858f, 
    0.15115364f, 0.08991691f, 0.03706357f, -0.03070512f, -0.02104803f, 0.07556384f, 0.10167702f, 0.09489988f, 
    0.14719802f, -0.12732244f, -0.09428607f, -0.14393751f, 0.17760539f, -0.04522030f, 0.01928131f, 0.12226196f, 
    -0.13211676f, -0.02050624f, -0.15564500f, -0.00746564f, 0.13844955f, -0.24915703f, 0.00031033f, 0.12567668f, 
    0.39012888f, 0.00586255f, 0.05010104f, 0.17924652f, 0.14228551f, -0.03493788f, -0.04270514f, -0.04793186f, 
    -0.06374536f, 0.04142266f, 0.14888822f, 0.00835434f, -0.37085944f, -0.24278505f, -0.20673479f, 0.15816204f, 
    0.12230293f, -0.13150853f, -0.15776004f, -0.01230186f, -0.03512042f, 0.07843074f, 0.01219124f, -0.07614090f, 
    0.50939518f, -1.05733228f, -0.22109668f, -0.31178582f, 0.05121887f, 0.04740714f, 0.10545062f, 0.09800547f, 
    -0.07417394f, 0.25365412f, -0.02255120f, -0.09891731f, -0.17641984f, -0.07510553f, -0.08862388f, 0.01321663f, 
    0.10286181f, 0.19698742f, 0.33566177f, -0.09765971f, 0.20600680f, -0.09003021f, -0.01757446f, -0.08333843f, 
    0.06163171f, -0.10341930f, 0.04681912f, -0.08954474f, -0.26361105f, 0.23424970f, 0.09840260f, -0.26377997f, 
    0.08784188f, -0.12057774f, -0.12923458f, 0.16253906f, -0.35867229f, -0.67980295f, -0.25314292f, -0.15687351f, 
    -0.01205774f, 0.16927394f, -0.15475672f, -0.03231123f, -0.11409872f, 0.21627337f, -0.18583265f, -0.12971258f, 
    -0.06231761f, 0.01364062f, 0.02530156f, 0.03859650f, 0.24446075f, -0.05829640f, -0.68143022f, 0.14752410f, 
    0.32634950f, 0.12336791f, -0.03522314f, 0.22012141f, 0.03843192f, -0.06433301f, 0.09869595f, 0.60391736f, 
    0.10438594f, 0.13842271f, -0.02842232f, -0.11007043f, -0.18537118f, 0.07784683f, 0.01334701f, -0.09627373f, 
    -0.26479340f, 0.12538767f, -0.17677711f, 0.08123203f, -0.15933162f, 0.14766614f, -0.07772797f, -0.24161877f, 
    0.12910880f, 0.16838245f, 0.34880561f, 0.12402184f, -0.01644005f, -0.04896270f, 0.01343390f, 0.02602961f, 
    0.01951444f, 0.07962248f, 0.21318762f, -0.44488037f, -0.27550966f, -0.09832107f, -0.01538078f, 0.12581758f, 
    0.01595183f, 0.02081500f, -0.05764761f, -0.31162557f, -0.06107223f, -0.02366231f, 0.03357814f, 0.03194416f, 
    0.46502024f, 0.02130770f, 0.07030014f, -0.04900108f, 0.24660906f, 0.17965628f, 0.11196811f, -0.03134474f, 
    -0.12432444f, -0.10505955f, 0.15435837f, 0.04633413f, -0.10588595f, -0.23857264f, -0.53087342f, -0.38388240f, 
    0.02768353f, -0.13370000f, -0.24284863f, -0.09215711f, -0.06160963f, 0.04637573f, 0.30664721f, 0.10673788f, 
    0.07958689f, 0.20003873f, -0.20306869f, -0.02179314f, 0.00885913f, 0.18117623f, 0.00359025f, 0.36095428f, 
    -0.28470296f, 0.18420471f, -0.03015531f, 0.14912672f, 0.10381918f, 0.13885967f, 0.17190054f, -0.00045535f, 
    0.16313803f, -0.96352136f, -1.01153660f, -0.10487885f, 0.00735180f, -0.01601362f, 0.03423007f, 0.09097748f, 
    -0.10242200f, 0.24134174f, -0.02414982f, -0.17287058f, 0.02180202f, 0.10209572f, 0.04301992f, -0.04642282f, 
    -0.01801870f, -0.08099066f, 0.21216536f, 0.32814124f, 0.08753791f, -0.16894248f, -0.12353551f, 0.14730579f, 
    -0.00428370f, -0.20450965f, 0.01883737f, 0.48867586f, -0.12322731f, -0.39940763f, 0.07031856f, 0.15778971f, 
    0.23086539f, 0.08631073f, 0.01730769f, -0.16257352f, -0.41556218f, -0.36416811f, -0.17820889f, 0.22009061f, 
    -0.13548273f, 0.21997118f, 0.16268007f, -0.04230822f, 0.07962338f, 1.27363467f, -0.45283362f, -1.05087554f, 
    -0.19522193f, -0.04324475f, -0.00190302f, -0.03421721f, -0.06443296f, -0.02909411f, -0.11187779f, 0.32420340f, 
    0.10765989f, 0.03739610f, -0.24578463f, 0.18845858f, 0.23328094f, -0.08601867f, 0.22201420f, 0.42727801f, 
    -0.82259661f, -1.04553568f, -0.12619415f, 0.11289093f, 0.04288090f, 0.12532319f, -0.12279460f, -0.20887244f, 
    0.06987226f, 0.04941119f, -0.08936654f, 0.15406270f, 0.09885608f, 0.10621288f, 0.10875303f, -0.02302903f, 
    0.00428983f, 0.33027855f, -0.78357852f, -0.19325300f, 0.07333685f, 0.14566468f, -0.02346670f, -0.05823151f, 
    -0.20845456f, 0.08808361f, 0.10287426f, 0.11182969f, 0.17359057f, -0.00565909f, -0.01303737f, -0.19148259f, 
    -0.08660777f, 0.14991400f, 0.14871451f, 0.34160760f, 0.08132776f, -0.23727673f, -0.24478568f, -0.15146123f, 
    0.02122436f, 0.23677646f, -0.26358578f, -0.02112669f, -0.56500840f, -1.23071051f, -0.72583580f, -0.16079561f, 
    -0.00454727f, 0.05561144f, -0.08653961f, -0.11127102f, 0.08140544f, 0.02455757f, 0.20817943f, 0.20922445f, 
    -0.02462713f, -0.15286218f, -0.08276225f, -0.00504351f, -0.07679825f, 0.12559877f, 0.12218181f, -0.00758733f, 
    -0.15575132f, -0.04144555f, -0.03709387f, -0.04558886f, 0.19816773f, -0.06201071f, -0.02615466f, -0.11909517f, 
    0.24374194f, 0.11005254f, -0.19301520f, -0.14905049f, 0.01203618f, 0.03325075f, -0.02023188f, 0.12381326f, 
    -0.12896831f, 0.00697457f, 0.21943288f, 0.00301205f, 0.02963406f, -0.03161911f, 0.19088513f, -0.02486184f, 
    -0.01510863f, -0.20127214f, -0.08167796f, -0.19303301f, -0.08462666f, 0.04475915f, -0.01380946f, -0.22532634f, 
    -0.31185305f, -0.04631217f, 0.19693002f, 0.31374413f, 0.04495439f, -0.04224370f, 0.01244993f, -0.11986993f, 
    0.20992409f, 0.16020475f, -0.03467410f, 0.05705611f, 0.25744763f, 0.32074720f, 0.07353418f, -0.06700767f, 
    0.01799449f, 0.19292353f, 0.04675310f, 0.07018168f, -0.08707926f, 0.29629076f, -0.09705202f, 0.04985721f, 
    -0.11040475f, 0.08519960f, -0.03513424f, 0.00775076f, -0.20853904f, -0.17417371f, -0.01769991f, 0.31876248f, 
    0.00641595f, 0.05123844f, 0.03996412f, -0.00717491f, 0.05068447f, 0.10273687f, 0.33453619f, 0.31813258f, 
    0.08186580f, 0.07196611f, -0.04781486f, 0.14094149f, 0.00770929f, 0.26077893f, 0.16039838f, 0.21644431f, 
    0.21999799f, 0.26670417f, 0.11065419f, 0.05742246f, 0.20086965f, 0.26084149f, 0.17300637f, 0.28428382f, 
    -0.00865007f, -0.00232351f, -0.16237785f, 0.03688274f, 0.06893843f, -0.04073164f, 0.12221872f, 0.20632899f, 
    0.11758755f, -0.09973917f, -0.05171928f, -0.09666956f, -0.01812865f, 0.00520841f, -0.04243140f, -0.05416550f, 
    -0.01521420f, -0.21889777f, 0.00677329f, -0.02937514f, 0.06562896f, -0.04016183f, -0.01465663f, 0.10362580f, 
    0.17192812f, 0.14597394f, -0.01019684f, 0.12908965f, 0.11387055f, 0.38225994f, 0.03426671f, 0.08867990f, 
    0.38411266f, -0.04603673f, 0.11745043f, -0.06917255f, -0.17503017f, 0.11468051f, 0.00097723f, -0.12218592f, 
    -0.18746115f, -0.19533716f, 0.10069120f, 0.16566056f, -0.04749998f, -0.31259918f, 0.13437158f, -0.21139948f, 
    0.18126181f, 0.05840529f, -0.11207379f, 0.06152118f, 0.00163742f, 0.12486558f, 0.31410408f, 0.16994669f, 
    0.16193573f, -0.07606152f, 0.21556637f, 0.16101526f, 0.14225340f, -0.02233199f, 0.04465343f, -0.10353851f, 
    0.12796894f, 0.46955451f, 0.03266772f, 0.05290015f, 0.13654600f, -0.06592547f, -0.01691873f, 0.15823768f, 
    -0.07998261f, 0.01085977f, 0.07139455f, -0.10045683f, -0.00131372f, 0.02676419f, 0.06412026f, -0.01993680f, 
    0.01920845f, -0.05016566f, 0.04952925f, -0.20011933f, 0.15372980f, -0.00855873f, 0.27747929f, 0.08150618f, 
    -0.07846322f, 0.09157095f, -0.04404901f, 0.07673871f, -0.09827316f, 0.02269065f, 0.00385618f, -0.02231340f, 
    0.18019085f, 0.19491202f, -0.02995584f, -0.11840312f, 0.23901886f, 0.03196696f, 0.36530799f, 0.22854699f, 
    0.00003358f, -0.12841770f, -0.18438204f, 0.15822694f, -0.23941167f, -0.14027110f, 0.12963581f, -0.08017145f, 
    -0.03617613f, 0.01099605f, 0.04130482f, 0.08803581f, 0.00194781f, -0.18427782f, -0.31575373f, 0.26014563f, 
    -0.09339069f, -0.08021932f, -0.10524789f, 0.09600589f, 0.09083668f, 0.09746750f, 0.05686743f, 0.23765987f, 
    0.02076382f, 0.03799842f, 0.04845543f, 0.08653355f, -0.23614717f, 0.16982470f, -0.12123924f, -0.17472194f, 
    0.35937655f, 0.46077633f, 0.09265601f, 0.14070293f, -0.27207556f, -0.05026191f, 0.07336278f, -0.09124973f, 
    -0.01507271f, -0.04723446f, -0.08503085f, 0.12747650f, 0.09016493f, 0.12152444f, 0.17812343f, 0.00846137f, 
    0.14174543f, -0.01403212f, 0.03302576f, 0.13867658f, 0.04972146f, -0.04977026f, -0.07305849f, 0.12106965f, 
    0.04644489f, -0.00214191f, -0.17150070f, -0.09217253f, -0.42415455f, -0.17298323f, -0.05207860f, 0.03924370f, 
    -0.16878158f, -0.11101069f, -0.12381433f, -0.13362220f, 0.07366857f, -0.18599057f, 0.14999400f, 0.15037866f, 
    -0.10806010f, 0.09908790f, 0.08649687f, -0.04922092f, -0.12783359f, -0.25245270f, 0.44001558f, -0.11483224f, 
    -0.11655661f, -0.11556294f, 0.07180498f, 0.06488051f, 0.02840640f, -0.15018168f, 0.11865676f, -0.12653966f, 
    -0.01833083f, -0.19357753f, 0.06623119f, -0.07211272f, 0.04202280f, 0.01062876f, -0.16925056f, -0.07627355f, 
    -0.10834574f, -0.14358856f, 0.10889772f, -0.02574719f, 0.17045969f, 0.02162131f, 0.02619141f, -0.18236709f, 
    0.09614824f, -0.02827299f, 0.01420258f, 0.12832752f, -0.34371009f, -0.26438925f, 0.14541863f, -0.33606213f, 
    0.06068194f, 0.05793813f, 0.15839417f, 0.24162556f, -0.13801038f, -0.08870695f, -0.02320161f, -0.09568468f, 
    -0.16774635f, -0.11074221f, -0.03109153f, 0.06903550f, 0.05499275f, -0.08736939f, -0.04959626f, -0.01840593f, 
    -0.11840904f, -0.16506121f, -0.17143020f, 0.03515115f, -0.10262574f, 0.19034809f, 0.14659026f, -0.03163827f, 
    -0.06152872f, -0.07307688f, 0.05894125f, 0.31082359f, -0.00882407f, -0.03966345f, 0.00923992f, 0.01772116f, 
    -0.07856094f, 0.14056532f, 0.10696679f, 0.17043719f, -0.16439703f, 0.18033731f, -0.21633181f, 0.26638946f, 
    0.19106272f, 0.15181725f, -0.28153938f, -0.27939391f, -0.14871109f, -0.31875962f, -0.00557724f, -0.12806785f, 
    0.07362527f, 0.06157640f, 0.10297856f, -0.03035506f, 0.09076126f, 0.10162480f, 0.18407314f, 0.02352642f, 
    0.06922279f, 0.03719510f, -0.01642044f, 0.23784000f, 0.11198135f, 0.31664816f, 0.10723345f, 0.01024309f, 
    0.09142558f, 0.04429973f, 0.01504051f, -0.02465167f, 0.03767498f, -0.07323036f, 0.12840775f, 0.13534243f, 
    -0.00485760f, 0.05499385f, -0.05101862f, 0.04683414f, 0.11434360f, 0.09058390f, 0.18332176f, 0.11654908f, 
    0.13027269f, 0.04505095f, -0.06717077f, 0.06314723f, 0.07307383f, -0.00564073f, -0.01425946f, -0.00990368f, 
    -0.00669273f, 0.06386016f, -0.15996592f, 0.01155583f, 0.09820527f, 0.05040652f, -0.05121389f, -0.06774188f, 
    -0.18778020f, -0.08403912f, -0.23426375f, -0.00215602f, 0.12094487f, 0.05276627f, 0.16450079f, 0.11029075f, 
    0.20558172f, -0.09999739f, 0.03692873f, 0.01658209f, -0.15268040f, -0.07338039f, -0.04622786f, 0.12612803f, 
    -0.01417403f, 0.08158508f, -0.07458433f, 0.16994195f, -0.17319055f, -0.04225342f, 0.10304382f, -0.06587657f, 
    0.07132182f, 0.05971752f, 0.04179444f, 0.05275005f, 0.23584083f, 0.29239964f, 0.29719555f, -0.14829563f, 
    0.08044813f, -0.06169304f, 0.21344247f, 0.00898302f, 0.02968187f, -0.05784233f, 0.06354260f, -0.03171726f, 
    0.06899549f, 0.24152620f, 0.08361615f, -0.02381552f, -0.05580731f, -0.08378118f, -0.05520803f, 0.12409225f, 
    -0.13869022f, 0.08268327f, 0.17559703f, 0.00809941f, -0.17772250f, 0.01534631f, -0.22295731f, -0.31929904f, 
    -0.39102474f, -0.03388339f, -0.14379355f, -0.06203662f, 0.23363809f, 0.08255515f, 0.04413850f, 0.09078353f, 
    -0.08441021f, 0.23111045f, -0.14642328f, -0.05344283f, -0.05296757f, 0.18371513f, 0.07506342f, -0.00215535f, 
    0.08391349f, 0.07943246f, 0.13557173f, 0.18277198f, 0.23472682f, 0.22619839f, 0.14107111f, -0.06116994f, 
    0.03571959f, 0.17035261f, 0.14332519f, -0.02023617f, -0.07949700f, -0.07866067f, 0.16665746f, -0.17820439f, 
    -0.01776530f, 0.03723375f, 0.16840160f, 0.19124368f, 0.16851377f, -0.09731954f, -0.13510731f, -0.04591543f, 
    -0.18367827f, -0.09234379f, 0.12308025f, -0.03293473f, -0.01268034f, 0.03817052f, 0.09718475f, 0.08116794f, 
    0.01542056f, 0.07356039f, 0.09297023f, 0.14986636f, 0.00783720f, -0.02622803f, -0.04441589f, -0.02098840f, 
    0.35414734f, 0.10739169f, 0.20999062f, -0.20100446f, -0.02120764f, -0.21712042f, 0.01193050f, 0.00194207f, 
    0.16641219f, -0.01799258f, 0.14147601f, 0.14921854f, 0.08150107f, -0.01092496f, 0.13036199f, 0.12464143f, 
    0.22183284f, 0.04711955f, 0.05108935f, 0.02413031f, -0.13261533f, -0.08557196f, 0.00181179f, 0.17780779f, 
    0.17545561f, 0.12034911f, -0.13510394f, 0.01921912f, -0.27206865f, 0.08538500f, -0.14510182f, 0.02795200f, 
    -0.15213931f, -0.02940854f, -0.13399148f, -0.06853780f, 0.11340757f, -0.07925951f, 0.31345245f, -0.00031850f, 
    -0.03773550f, 0.01565057f, 0.17071521f, 0.11522222f, -0.10174508f, -0.06609970f, -0.04940377f, 0.02115452f, 
    0.00589641f, 0.02084072f, 0.11508807f, 0.10968176f, 0.19440947f, -0.09599540f, -0.11298305f, -0.12208232f, 
    -0.03045586f, 0.02286515f, 0.02233377f, -0.10969369f, 0.05040712f, -0.01949918f, -0.08964372f, -0.02831689f, 
    -0.03401066f, 0.05463064f, 0.07930380f, -0.00580787f, 0.12079356f, 0.19440889f, 0.31307095f, -0.32254735f, 
    0.06117412f, -0.09016208f, 0.08925402f, 0.11227256f, 0.01365465f, 0.11452876f, 0.13858892f, 0.02096610f, 
    -0.22387798f, -0.00704035f, 0.23955670f, -0.18159206f, 0.04317673f, -0.30017602f, 0.08479796f, 0.13036364f, 
    -0.04891464f, -0.33402228f, -0.36477640f, -0.17576528f, -0.03895350f, -0.04768496f, -0.09242146f, -0.20297913f, 
    0.15180148f, 0.02724578f, 0.00114526f, 0.10493165f, 0.30521131f, -0.34929347f, -0.06411117f, -0.18789949f, 
    0.09055877f, -0.22410893f, 0.10316426f, 0.12439207f, 0.15227976f, 0.32954565f, -0.07822202f, -0.03045195f, 
    -0.03698185f, -0.00639925f, -0.09903488f, -0.15469976f, -0.54742932f, 0.50735420f, 0.39668337f, -0.10880884f, 
    -0.44566849f, 0.10208693f, 0.07281689f, -0.06273628f, 0.19738296f, 0.08395346f, -0.03259324f, 0.32718962f, 
    -0.03264961f, -0.04553608f, -0.26566440f, -0.01708441f, -0.03900063f, 0.09581698f, -0.32835180f, 0.04190184f, 
    -0.16728751f, 0.22157308f, -0.01605273f, -0.23164184f, -0.04104362f, 0.08088651f, -0.07189869f, -0.08796020f, 
    0.18714760f, 0.48794398f, -0.00522536f, -0.07527427f, 0.03752398f, 0.09806654f, 0.11578219f, 0.03755687f, 
    -0.19476108f, 0.04637162f, -0.25720507f, 0.14364287f, 0.15870741f, -0.24623658f, -0.09045631f, -0.01110161f, 
    0.09709163f, -0.17526405f, -0.09995814f, -0.17869258f, 0.09662882f, 0.07030421f, 0.00903914f, 0.05195818f, 
    0.07751550f, -0.03472504f, -0.13719036f, 0.25542399f, 0.11962255f, 0.05437476f, -0.21325570f, 0.06558032f, 
    0.08776330f, 0.12812258f, 0.07460295f, -0.44050828f, 0.31566620f, -0.19630036f, 0.05547867f, 0.00813573f, 
    0.30682868f, -0.14869009f, 0.07525589f, 0.05729518f, 0.14261772f, 0.04978129f, 0.18864101f, 0.06816395f, 
    0.02581457f, -0.06637261f, 0.13313340f, -0.20726717f, 0.25379467f, 0.05343978f, 0.08254716f, 0.24118593f, 
    0.09079882f, 0.05262171f, -0.21845850f, -0.09692663f, 0.08678181f, 0.08069917f, -0.21034923f, 0.17403142f, 
    0.23109560f, 0.06433391f, 0.26290420f, -0.08813698f, -0.07176881f, 0.32850569f, -0.31001234f, 0.02545507f, 
    0.10860663f, -0.04240391f, 0.09831124f, 0.01632637f, 0.09802414f, 0.12797241f, -0.12027703f, -0.16320638f, 
    -0.21482171f, 0.09168522f, 0.19290835f, -0.13850635f, 0.03804861f, 0.01831151f, 0.11752238f, -0.06453673f, 
    0.08482121f, -0.01485614f, 0.37324837f, -0.19953056f, -0.18588232f, -0.07588311f, 0.01889649f, -0.07656591f, 
    0.13925561f, 0.11514395f, 0.24861854f, 0.18526317f, 0.08549823f, -0.30184266f, -0.24398230f, 0.00665468f, 
    0.16544536f, 0.04937942f, 0.07359489f, -0.08095271f, -0.03500121f, -0.03367902f, -0.05372420f, 0.04752444f, 
    -0.21538435f, -0.10474439f, 0.22954670f, -0.05052712f, -0.00727804f, 0.14427675f, -0.29940769f, 0.05226001f, 
    0.05999542f, 0.04402266f, 0.12916097f, 0.04010940f, -0.03988725f, -0.02743855f, 0.15414451f, 0.31803787f, 
    -0.12151784f, -0.15987156f, -0.14899431f, 0.08323072f, -0.17202027f, -0.00491239f, -0.35585371f, 0.16536680f, 
    -0.35673162f, 0.13643019f, 0.14653096f, -0.22096500f, 0.03294842f, 0.15795957f, -0.24099162f, -0.18215367f, 
    -0.00306085f, 0.47527283f, -0.30914381f, -0.01144203f, 0.02606162f, 0.17113161f, -0.01502670f, -0.00166257f, 
    -0.21326259f, 0.17114498f, -0.26313412f, -0.09425894f, -0.09812289f, 0.04031449f, 0.06085645f, 0.12650248f, 
    -0.03183537f, 0.47750163f, 0.21875472f, 0.30065417f, -0.14964215f, 0.03235253f, -0.07421915f, 0.07305862f, 
    0.00732165f, -0.01265002f, -0.08111203f, 0.00004231f, -0.22879660f, 0.05456956f, -0.31833690f, 0.09037064f, 
    0.05514390f, -0.09775425f, 0.26573256f, 0.13585737f, 0.15330148f, -0.14354324f, -0.27592754f, -0.21951923f, 
    0.05580218f, 0.03286133f, 0.21874952f, 0.06158732f, 0.10470173f, 0.51608890f, 0.16286874f, -0.10137291f, 
    -0.21893640f, -0.12128552f, -0.09796938f, -0.02465440f, 0.11585112f, -0.02381295f, 0.18247901f, -0.03122051f, 
    0.06061501f, -0.08827494f, -0.01102250f, 0.16586368f, 0.07907823f, 0.06227726f, 0.11680160f, -0.05149880f, 
    -0.07672919f, -0.15287110f, -0.17096005f, 0.00122507f, 0.22287479f, 0.10537182f, 0.19157548f, -0.59560806f, 
    -0.56251264f, 0.22287886f, 0.10715286f, 0.04077984f, -0.04855988f, -0.03482509f, -0.16387440f, -0.07386933f, 
    -0.20662385f, -0.07517663f, -0.19004135f, -0.15078971f, -0.03742903f, 0.10791287f, 0.05627823f, 0.04511707f, 
    0.11912017f, -0.36842212f, 0.34820011f, -0.11963820f, -0.19427373f, -0.12037433f, -0.01196819f, 0.07766101f, 
    -0.08062702f, 0.04209273f, -0.17380321f, 0.23984167f, 0.24561113f, -0.12615098f, 0.10795453f, -0.07108944f, 
    -0.02808423f, 0.07303602f, 0.11245444f, -0.20126584f, -0.19896410f, -0.11330439f, -0.03767206f, -0.00782323f, 
    -0.06462634f, 0.08736977f, -0.20624144f, 0.03748023f, -0.08916789f, -0.02276859f, 0.19100957f, -0.07890163f, 
    -0.06985470f, 0.12482686f, 0.16111077f, -0.07837854f, 0.13521013f, -0.31531653f, -0.01510305f, -0.35514930f, 
    0.08093281f, -0.10769942f, -0.05392911f, 0.19517717f, -0.23841123f, 0.00199079f, 0.41705823f, 0.01327662f, 
    0.18758719f, 0.20753001f, 0.19914715f, -0.01367262f, 0.19501869f, 0.13478686f, 0.00159300f, -0.15093511f, 
    -0.09543081f, -0.01934705f, 0.00838554f, 0.01588765f, 0.07515926f, 0.07566184f, 0.05589200f, 0.16604875f, 
    0.20481303f, 0.23661466f, -0.00931287f, -0.04384410f, -0.02236151f, -0.28575554f, -0.02327886f, -0.08128335f, 
    -0.04654188f, 0.37179834f, 0.16052251f, -0.19666384f, 0.07066337f, -0.02049365f, 0.08330930f, -0.12717541f, 
    0.24400406f, -0.22217739f, 0.21080145f, -0.09635157f, -0.04209665f, -0.12374145f, 0.26337990f, 0.04532095f, 
    -0.01403216f, 0.03860864f, 0.23173346f, 0.13655922f, 0.02860363f, 0.25420856f, -0.12469121f, 0.03576128f, 
    0.17611100f, 0.22271606f, 0.14487131f, 0.18627648f, -0.00948954f, 0.13543025f, 0.01802113f, -0.02313915f, 
    -0.09361051f, 0.06311347f, 0.02941008f, 0.03451279f, -0.25837085f, -0.15568563f, -0.05460001f, -0.18131113f, 
    -0.06517500f, -0.10481679f, -0.19674754f, -0.09072399f, -0.07688205f, -0.04613494f, -0.10513820f, 0.16332397f, 
    0.26246753f, -0.00762342f, 0.12667790f, 0.09572694f, 0.25281307f, -0.25761104f, 0.09642506f, 0.17193364f, 
    -0.15955168f, 0.21879426f, -0.06041026f, 0.02233311f, 0.14120562f, 0.16318770f, -0.10331640f, 0.09022612f, 
    0.05247290f, 0.12069565f, 0.00835167f, -0.04514781f, -0.02864031f, 0.05247802f, -0.09538525f, 0.13402916f, 
    0.20885874f, -0.02872151f, 0.10451353f, -0.03190402f, -0.00244467f, 0.14301863f, 0.21962027f, 0.11747524f, 
    -0.06209324f, 0.08655825f, -0.04345074f, 0.09122235f, -0.09335165f, 0.07111046f, 0.02812321f, -0.15323569f, 
    0.03361609f, 0.11257447f, -0.01225179f, 0.00922243f, -0.13702621f, 0.28402272f, 0.14257073f, -0.10326216f, 
    -0.00308321f, 0.17076679f, -0.07245103f, -0.01639308f, 0.23491585f, 0.09990064f, -0.06845822f, -0.17765699f, 
    0.00913677f, -0.24227513f, -0.36376089f, -0.07343838f, -0.16735224f, -0.24840578f, -0.06447609f, 0.02564344f, 
    0.16158427f, 0.12405745f, 0.03939335f, -0.11379865f, -0.04103730f, 0.15793976f, 0.28883427f, -0.02847851f, 
    0.25647041f, 0.08988413f, 0.06090306f, 0.19804719f, -0.07873384f, 0.13255525f, -0.18082149f, -0.63929516f, 
    -0.20731594f, 0.46699071f, -0.07961972f, 0.13884962f, 0.39038834f, -0.10341640f, 0.23812169f, -0.04956764f, 
    0.11121468f, 0.13760602f, -0.03244403f, -0.05763254f, 0.05094575f, 0.01963989f, 0.07113229f, 0.09426831f, 
    -0.21854286f, -0.44855106f, 0.01358120f, -0.02698390f, -0.14706664f, -0.18267860f, -0.03593972f, -0.13194045f, 
    -0.15349202f, 0.06009449f, -0.16236503f, 0.02336980f, -0.20907639f, -0.15515670f, -0.03300766f, 0.10238653f, 
    -0.02498505f, -0.23058638f, -0.14048034f, -0.21565104f, -0.09120416f, -0.02750423f, 0.00924096f, -0.01862260f, 
    0.03791670f, -0.02955377f, 0.15152447f, -0.04193439f, -0.03877245f, -0.17583536f, 0.07804745f, -0.05257595f, 
    0.08079817f, 0.05752033f, 0.00156750f, 0.01415263f, 0.01607731f, 0.07033402f, -0.18473670f, 0.19178846f, 
    -0.14821884f, -0.00514921f, 0.18557495f, 0.02228188f, 0.13672487f, -0.08259103f, 0.11445250f, 0.12595865f, 
    -0.15091760f, -0.06007630f, -0.02075392f, -0.04148880f, 0.06483694f, -0.16433387f, -0.26794741f, 0.31682262f, 
    -0.19552888f, 0.19868116f, -0.24743086f, -0.00487533f, 0.04483748f, 0.07421587f, 0.05894405f, -0.04259393f, 
    0.05457086f, 0.12188443f, 0.08803636f, -0.09114394f, -0.10283215f, -0.01840936f, -0.03278085f, -0.14951541f, 
    0.06544176f, -0.05575725f, -0.12097802f, -0.00878723f, 0.18913440f, 0.00233913f, 0.22050408f, -0.27355072f, 
    -0.31451342f, -0.53849393f, -0.24837372f, -0.13462497f, -0.04943846f, 0.05573115f, 0.07613041f, 0.04869417f, 
    -0.10738723f, -0.08404597f, -0.07325436f, 0.00555600f, -0.18905909f, -0.10463922f, 0.25504395f, 0.05162225f, 
    0.04187449f, 0.25193387f, 0.17946868f, -0.00157267f, -0.00356362f, -0.12780327f, -0.25677323f, -0.01075995f, 
    0.08667507f, -0.00037806f, -0.14415990f, -0.30274096f, -0.11786488f, -0.21025549f, 0.19164214f, -0.11056892f, 
    0.20709145f, 0.00564647f, 0.17800912f, 0.04806691f, 0.13055564f, -0.13294819f, -0.00284114f, -0.15159534f, 
    -0.02788991f, -0.22788817f, 0.03781269f, 0.03809991f, 0.30488420f, 0.03577762f, -0.04594096f, -0.28292423f, 
    -0.02752517f, 0.18870519f, 0.04302274f, -0.03597473f, -0.04678638f, 0.07405161f, -0.11549113f, -0.12468890f, 
    -0.03200874f, 0.03482986f, -0.04104563f, -0.00341813f, 0.11364701f, -0.06989273f, 0.23070721f, -0.04721992f, 
    0.21541211f, 0.08129092f, 0.06157696f, 0.26213530f, -0.02477948f, 0.08252157f, -0.02121592f, -0.09436771f, 
    -0.11941290f, 0.17734089f, -0.17113373f, -0.05355358f, -0.09768256f, -0.05932849f, -0.02666674f, -0.19027606f, 
    -0.13606833f, 0.02993362f, -0.07424217f, 0.13729914f, -0.03245812f, -0.05029120f, -0.00275824f, 0.13699199f, 
    0.03549255f, -0.14791034f, -0.09314103f, 0.05201299f, 0.07987236f, -0.02248621f, 0.16209897f, -0.24604373f, 
    0.08182289f, -0.02998105f, -0.16188154f, -0.26126757f, -0.11421636f, -0.10244022f, 0.21946833f, 0.06262138f, 
    0.38109547f, 0.27464181f, 0.13052753f, 0.06289083f, 0.17801645f, 0.22440994f, 0.20262274f, 0.03625003f, 
    0.27225989f, 0.16268641f, -0.08125233f, -0.03053533f, 0.04263387f, 0.00870802f, -0.17368290f, 0.11379527f, 
    0.27256569f, -0.03995279f, 0.08435920f, 0.09672154f, 0.15267298f, 0.03302882f, 0.08863802f, -0.16508304f, 
    -0.21241923f, -0.00543784f, -0.08687632f, -0.10072374f, -0.15092614f, -0.26870450f, -0.15058750f, -0.18262123f, 
    -0.19960913f, 0.13481840f, 0.12997042f, 0.01508438f, 0.08933306f, 0.01022888f, 0.17911229f, -0.18726718f, 
    -0.06796105f, -0.04529667f, 0.02345714f, 0.14077966f, 0.08806065f, 0.09615359f, -0.10353523f, -0.01712797f, 
    -0.15366556f, -0.21858799f, 0.00189976f, 0.21768852f, 0.23167549f, 0.19214714f, -0.06278037f, 0.18274978f, 
    0.02221905f, 0.07982623f, -0.14878736f, 0.09749693f, -0.05305364f, -0.04561497f, -0.25562885f, 0.03506314f, 
    0.04014124f, 0.13301396f, 0.16256560f, 0.21327426f, 0.22919200f, -0.13763149f, -0.01942289f, -0.01781775f, 
    -0.01354430f, -0.05902056f, -0.16155173f, -0.00911122f, 0.07940160f, 0.19473448f, 0.11408473f, 0.31994173f, 
    -0.01336902f, -0.02742826f, 0.11753185f, -0.01584415f, -0.14968176f, -0.24102564f, 0.10814233f, 0.08687916f, 
    0.50869739f, 0.05772540f, -0.03015958f, -0.02010232f, -0.22526468f, 0.00847473f, 0.21242747f, 0.14168449f, 
    0.06166075f, 0.04642009f, 0.03579344f, 0.12880725f, 0.08364499f, -0.10057453f, 0.03130764f, 0.05409409f, 
    0.24595635f, -0.17803583f, 0.00783789f, -0.02534781f, 0.01420789f, -0.06070940f, 0.06097233f, 0.06987491f, 
    0.13795613f, 0.10736403f, -0.13146098f, 0.02475204f, 0.11433253f, 0.19984896f, -0.06243297f, 0.06591970f, 
    -0.00139675f, -0.30351350f, -0.28513861f, 0.10465281f, 0.05789141f, 0.03298941f, 0.11118891f, -0.09038266f, 
    -0.11533219f, -0.08501536f, -0.00937254f, 0.06356362f, -0.28593209f, 0.19682758f, -0.22014739f, 0.06254017f, 
    0.07153492f, -0.01664079f, 0.00682536f, 0.07336930f, 0.04057064f, 0.08716416f, -0.09967188f, -0.04468184f, 
    -0.00514404f, 0.13659354f, -0.03615894f, -0.07431120f, -0.31817502f, -0.18103099f, -0.09501997f, 0.01653206f, 
    0.00992186f, 0.18716443f, 0.00088923f, -0.09228784f, 0.01007373f, 0.22742215f, 0.14282344f, -0.16165620f, 
    -0.02947624f, 0.08520561f, -0.04329572f, -0.03925324f, 0.00699652f, 0.15617545f, 0.17124481f, 0.00035117f, 
    -0.12128098f, 0.11351502f, -0.36866182f, 0.15227962f, -0.07884851f, 0.09783687f, 0.10496213f, -0.07181565f, 
    0.14424804f, 0.04075668f, -0.09311442f, 0.09952726f, -0.24116865f, -0.13244373f, -0.04911628f, 0.05713048f, 
    -0.06108236f, 0.12096742f, 0.11159064f, 0.14607890f, -0.16007397f, 0.04402298f, -0.37517807f, -0.13044570f, 
    0.06062644f, 0.06976085f, 0.17353839f, 0.06807502f, -0.09698839f, 0.15465887f, -0.17350534f, -0.01572006f, 
    0.02740398f, -0.09669181f, 0.04859072f, 0.26297566f, 0.00423402f, 0.06350449f, 0.12144340f, -0.28955135f, 
    -0.26576847f, -0.12689392f, -0.03217335f, -0.21178567f, 0.05468667f, 0.21017832f, -0.18624817f, 0.06483947f, 
    0.03676033f, -0.11101428f, 0.25463572f, -0.00912744f, 0.08832096f, 0.08732828f, -0.09994782f, 0.08137930f, 
    -0.30824047f, 0.06625388f, -0.00655986f, -0.08985285f, 0.11908460f, 0.23712540f, 0.09243526f, 0.23238887f, 
    -0.03293145f, -0.22550979f, -0.06228697f, 0.06527807f, 0.06455760f, 0.12031976f, 0.14692949f, 0.18494570f, 
    0.12538436f, -0.01661598f, -0.20679766f, -0.11945211f, 0.12346008f, -0.11961225f, 0.19335720f, 0.16333541f, 
    0.36825299f, -0.23367056f, -0.02374622f, 0.11098281f, 0.07681379f, 0.09238626f, -0.04811869f, 0.31641442f, 
    0.04908372f, 0.20574641f, 0.00645645f, 0.07008682f, 0.00245473f, -0.17309658f, -0.04514344f, 0.22771062f, 
    -0.02361602f, -0.07605009f, -0.25155389f, 0.03401316f, 0.28603518f, -0.08848143f, -0.02886426f, 0.13094060f, 
    0.12057213f, 0.17885065f, 0.16119203f, 0.09053215f, -0.24232666f, 0.07214497f, -0.09750484f, -0.06285876f, 
    -0.00648971f, -0.14147194f, 0.17694697f, 0.04348744f, 0.24847944f, 0.48953667f, -0.60485542f, -0.25861940f, 
    -0.24260575f, 0.19996564f, -0.10523987f, 0.18562482f, 0.08435675f, -0.01066119f, 0.20395020f, -0.04808480f, 
    -0.26431394f, -0.10462606f, 0.17879584f, -0.03730350f, 0.22386128f, 0.11996377f, 0.34775203f, -0.28938201f, 
    0.07347753f, 0.15949886f, 0.00338395f, 0.05656743f, 0.11319161f, 0.14995769f, 0.30816808f, 0.09716188f, 
    0.28503349f, 0.21194512f, 0.24716386f, -0.03520907f, -0.07766841f, 0.07570018f, 0.07628521f, -0.09016306f, 
    -0.11739328f, -0.07505777f, -0.13469830f, 0.05848818f, 0.05115629f, 0.02495878f, -0.16020501f, 0.15084530f, 
    0.10596281f, 0.15200880f, -0.10233915f, 0.13234586f, 0.17260723f, 0.01381882f, -0.07414636f, -0.27732977f, 
    0.13084300f, 0.04199919f, 0.14950262f, -0.01168050f, -0.30000377f, -0.19253404f, -0.07075129f, 0.22562572f, 
    -0.22797194f, 0.04826685f, -0.07355857f, 0.17439745f, 0.01317048f, 0.39858922f, -0.19700664f, 0.04419929f, 
    0.09324615f, 0.04083581f, 0.11255433f, 0.11500819f, -0.05422269f, -0.11828095f, 0.33923614f, 0.27280372f, 
    -0.00436925f, -0.09261877f, -0.02918106f, -0.13738073f, -0.04877198f, -0.00171086f, -0.30676287f, 0.04903422f, 
    -0.12267916f, -0.12491633f, -0.03740790f, -0.04168307f, 0.31260324f, 0.09842803f, 0.08520252f, -0.14187652f, 
    -0.34510443f, -0.61426091f, 0.08418976f, -0.15751351f, 0.11318713f, -0.24144909f, -0.04504143f, 0.03022340f, 
    0.02211170f, -0.01638298f, 0.18685544f, 0.06163984f, 0.15802430f, -0.10165891f, 0.18615334f, 0.10572656f, 
    0.29661953f, -0.05403419f, 0.12324618f, 0.14459041f, -0.03519533f, 0.02638285f, 0.05014344f, -0.06673200f, 
    -0.01195450f, 0.07947404f, 0.06720460f, -0.30094939f, 0.10314742f, -0.32505402f, 0.00181446f, -0.18390870f, 
    -0.06120991f, -0.06821837f, 0.00520521f, -0.11114217f, -0.23058969f, -0.24512066f, -0.24465621f, -0.56253546f, 
    -0.43336800f, -0.05798358f, 0.09032401f, 0.08204076f, -0.09237667f, -0.12815832f, -0.09066016f, -0.21230766f, 
    -0.08706274f, -0.04267209f, 0.09465706f, 0.07163584f, -0.04747599f, -0.55243427f, -0.11192854f, -0.41058728f, 
    -0.05535295f, -0.18297280f, 0.04286411f, 0.23404302f, 0.35770676f, -0.02424373f, -0.17325227f, -0.04140749f, 
    -0.18434653f, 0.03402660f, 0.02224548f, -0.15667470f, 0.09202407f, 0.24867234f, 0.09937174f, -0.63290012f, 
    -0.49598053f, 0.19147506f, 0.03813676f, -0.01209217f, -0.20703124f, 0.21387123f, -0.37605411f, -0.26054367f, 
    0.00245678f, -0.06132586f, -0.03514395f, 0.05030801f, 0.00240755f, -0.01024430f, 0.04630224f, -0.04306374f, 
    -0.04128374f, -0.04742369f, -0.02830022f, -0.03823946f, 0.04199582f, -0.02954653f, -0.01758007f, 0.03416143f, 
    0.01956290f, -0.03820910f, 0.02201163f, -0.02463415f, 0.00218187f, 0.02579697f, -0.00263327f, -0.02256366f, 
    0.01948036f, -0.03065063f, 0.00666797f, -0.04857721f, -0.02178721f, 0.05011496f, 0.04341974f, -0.05447169f, 
    0.01347484f, 0.02585131f, -0.00709165f, -0.01609182f, -0.00484070f, 0.00787206f, 0.03026082f, 0.05356653f, 
    0.02505154f, -0.05878182f, 0.00214246f, 0.05205745f, 0.02882151f, -0.00452022f, -0.05270487f, -0.00916828f, 
    -0.01011502f, 0.04122865f, 0.00844128f, -0.03792176f, 0.00947942f, -0.00867881f, -0.05352508f, -0.05600452f, 
    0.01819830f, -0.03496546f, -0.02140566f, -0.04911100f, -0.05289295f, -0.06669721f, -0.04461028f, -0.02965870f, 
    0.04499219f, 0.04568089f, -0.03286231f, -0.03632702f, -0.04759663f, -0.00220354f, 0.00781815f, -0.02881008f, 
    0.03167987f, 0.00653694f, -0.04854975f, 0.01516253f, -0.02148362f, -0.00140929f, -0.03809817f, -0.03164146f, 
    0.01337239f, -0.00447469f, -0.00900078f, 0.01262231f, -0.03635509f, -0.03633184f, -0.04813414f, -0.05547888f, 
    -0.03798621f, -0.00846999f, 0.03686122f, 0.05133683f, -0.02771697f, 0.03923994f, 0.02644433f, -0.03663241f, 
    0.02149410f, 0.00946450f, -0.03149190f, 0.06492520f, -0.02149406f, 0.02359952f, -0.04288656f, -0.05551753f, 
    0.04831066f, -0.05392699f, 0.01780340f, -0.05177107f, 0.02564110f, 0.00674038f, 0.00107787f, 0.00388200f, 
    -0.04231651f, -0.03855218f, 0.04926965f, -0.02527126f, -0.01561296f, -0.06185880f, -0.03859381f, 0.03393416f, 
    -0.03999951f, 0.02076183f, 0.03936188f, 0.02657160f, -0.06322305f, -0.06621157f, -0.02930910f, -0.04907019f, 
    -0.01900411f, 0.01109158f, -0.03652582f, -0.04350793f, -0.05603771f, 0.04796089f, 0.01966272f, 0.05528331f, 
    -0.01226105f, 0.03533862f, -0.04980334f, -0.02835169f, 0.03490847f, 0.02213142f, 0.00416081f, -0.00911739f, 
    0.03385075f, 0.04342100f, -0.01746681f, -0.06203699f, -0.03904189f, 0.01161423f, -0.01941066f, -0.03959969f, 
    0.03416251f, -0.00295773f, 0.00888276f, 0.05445256f, -0.01465488f, 0.00666372f, 0.02493799f, -0.01166239f, 
    -0.00445373f, -0.00478384f, 0.01438305f, 0.02580362f, -0.05447831f, -0.06345679f, 0.02715813f, -0.02831176f, 
    0.03998111f, -0.01611129f, -0.00548704f, 0.03556002f, 0.04196497f, 0.02813275f, -0.05517882f, -0.05409656f, 
    -0.00705830f, -0.04179087f, -0.05231307f, 0.01711778f, 0.04420565f, -0.05291504f, -0.05173115f, 0.02911918f, 
    0.04904849f, -0.06005280f, -0.04482244f, -0.02855383f, 0.02387283f, -0.02841928f, -0.04260737f, -0.03887222f, 
    0.05181855f, 0.03446248f, -0.04586579f, -0.03265909f, -0.06340503f, 0.02511529f, 0.01677672f, 0.04780948f, 
    -0.05800006f, -0.01149107f, -0.04902742f, -0.02561974f, -0.01267664f, -0.01672618f, 0.04355944f, -0.03379968f, 
    0.03258432f, 0.02446749f, 0.02193775f, 0.04401658f, 0.03932112f, 0.00379756f, -0.02271072f, -0.05343770f, 
    -0.05785149f, 0.00413772f, -0.00574809f, 0.01296804f, -0.00963853f, -0.05464650f, -0.00792551f, 0.04413500f, 
    -0.05992039f, -0.03767197f, -0.00141563f, -0.06253408f, -0.02855511f, 0.00230316f, 0.04458978f, -0.01471056f, 
    -0.02822190f, 0.04827083f, 0.03223043f, -0.00297264f, -0.01187017f, -0.04909450f, -0.00574268f, -0.01211328f, 
    -0.05515060f, -0.03219528f, -0.04029664f, 0.01175600f, -0.00713805f, 0.00307419f, -0.01308694f, -0.00903908f, 
    -0.05501635f, -0.04482659f, -0.03667152f, 0.00562905f, 0.04549247f, 0.03011890f, -0.00680373f, 0.02393317f, 
    0.03560663f, -0.02419979f, -0.01319407f, 0.03124521f, -0.03517091f, 0.02033119f, -0.06671554f, -0.06866919f, 
    -0.06895986f, 0.02797917f, -0.05809266f, 0.04229602f, -0.03636410f, -0.00025408f, 0.01075365f, -0.01164741f, 
    -0.04879256f, 0.01186169f, 0.04726799f, -0.01883435f, 0.02701177f, -0.00139996f, 0.02594619f, -0.00986728f, 
    -0.02889671f, 0.00673344f, 0.03402687f, 0.03020673f, 0.04790166f, -0.04940316f, 0.05150229f, -0.04513466f, 
    -0.03589297f, -0.75412750f, -0.28262833f, 0.06911979f, 0.09515611f, 0.08336334f, -0.04581461f, 0.06176024f, 
    -0.15868196f, -0.01001533f, 0.17384158f, -0.09575766f, -0.16228901f, 0.00452540f, -0.00877540f, -0.05371427f, 
    -0.02020341f, 0.34909508f, -0.08687082f, -0.02176364f, 0.35511696f, 0.03266984f, -0.22159359f, -0.00277955f, 
    0.09107994f, 0.05881819f, 0.19288459f, -0.45256814f, 0.00393182f, -0.39440611f, -0.00428867f, 0.04121057f, 
    -0.06707991f, -0.00924175f, -0.00011229f, 0.11351122f, -0.40648791f, 0.22652736f, 0.18146792f, -0.03869792f, 
    0.09890769f, -0.19866750f, 0.05534775f, -0.02495505f, 0.12214640f, -0.58458197f, -0.17403375f, -1.18840313f, 
    -0.03277601f, 0.14734292f, -0.13763669f, 0.07992321f, 0.02444776f, -0.06981836f, 0.19856472f, -0.19790958f, 
    -0.13219859f, 0.16238518f, -0.08203261f, 0.17223093f, -0.02713500f, 0.04947337f, -0.13178572f, 0.14537555f, 
    -0.19586821f, -0.62070596f, 0.05141236f, -0.03240398f, -0.15796566f, -0.02303005f, -0.00638689f, 0.19692603f, 
    0.10714624f, 0.04057039f, -0.04771470f, -0.05547275f, -0.06034010f, 0.21188904f, 0.07683021f, -0.06639159f, 
    -0.21708125f, 0.36612016f, 0.11553368f, -0.20924625f, -0.00945756f, -0.11263324f, 0.13134876f, 0.07110266f, 
    0.10919368f, 0.17324120f, 0.22901034f, -0.20985854f, -0.61811912f, -0.01240302f, 0.20656174f, -0.13733642f, 
    -0.04656366f, -0.04227938f, 0.04757757f, -0.04219237f, 0.47679839f, 0.01834874f, 0.11281445f, 0.16050103f, 
    -0.06938555f, 0.14682730f, 0.03039518f, 0.04121690f, -0.01783595f, 0.02414982f, -0.04664754f, -0.08349831f, 
    -0.07686679f, -0.07423691f, 0.10315350f, 0.13544749f, 0.11299793f, 0.17538521f, -0.41896385f, -0.38496497f, 
    -0.13971220f, -0.04314708f, -0.14205208f, -0.01216826f, -0.05727410f, -0.32408291f, 0.01706395f, -0.16342078f, 
    0.20922951f, -0.01387664f, -0.05127050f, 0.05059182f, 0.12911798f, 0.01019057f, 0.12728412f, -0.02323325f, 
    -0.70110399f, -0.44092017f, 0.15050462f, 0.12605377f, 0.00395176f, 0.24866985f, -0.06483228f, 0.10346010f, 
    0.18599720f, -0.28052008f, -0.22168544f, 0.03462575f, 0.11177053f, 0.07200619f, 0.04214112f, 0.13972035f, 
    0.19021116f, -0.04590201f, 0.08382726f, -0.00936903f, 0.03225545f, 0.03778915f, 0.14535595f, 0.03535474f, 
    0.00778502f, -0.07059277f, -0.11919115f, 0.11589198f, 0.01213321f, 0.09243680f, 0.07044740f, 0.05098888f, 
    0.05700227f, 0.09547168f, 0.01543186f, -0.07911823f, -0.35154825f, 0.01297107f, -0.03202047f, -0.10735781f, 
    0.07071557f, 0.09234717f, -0.19105232f, -0.14167525f, 0.27255666f, 0.34266323f, -0.24878013f, -0.16746743f, 
    0.14554340f, -0.00516692f, 0.00853822f, 0.00806180f, -0.15538792f, -0.10594600f, -0.33274904f, -0.22861119f, 
    0.08443373f, 0.14401267f, -0.00293053f, -0.12623441f, -0.06090124f, 0.07735971f, 0.11476671f, 0.15305820f, 
    -0.04570585f, 0.11494377f, -0.23926868f, 0.06443814f, 0.20489550f, -0.02466634f, 0.02668650f, -1.15967286f, 
    -0.22408041f, 0.28705373f, 0.01600463f, 0.44896960f, 0.11460445f, 0.04143553f, -0.13954683f, -0.01528902f, 
    0.09524238f, 0.16527851f, 0.02536655f, 0.03924645f, -0.00465024f, 0.20345438f, 0.02999150f, 0.05628531f, 
    -0.09046996f, -1.03644669f, 0.05347633f, 0.50556368f, 0.01302318f, 0.14666522f, -0.01776954f, -0.05446454f, 
    0.04270336f, 0.09909981f, 0.03760581f, 0.12021004f, -0.16205654f, -0.02138451f, -0.07371285f, -0.05340717f, 
    -0.02770024f, -0.02857243f, 0.19862495f, -0.37744433f, -0.21120769f, 0.05081877f, 0.06719882f, -0.05841029f, 
    0.08202065f, 0.25394374f, -0.10832552f, 0.00054638f, -0.53496307f, -0.07011503f, -0.26486862f, 0.01974473f, 
    0.04582728f, -0.19956279f, 0.02846726f, -0.09642743f, 0.04684108f, -0.22920938f, -0.06887406f, 0.07954183f, 
    -0.04455367f, -0.06264348f, 0.00663169f, -0.12159126f, 0.23705471f, 0.09562150f, -0.04340390f, 0.00229316f, 
    -0.05246415f, 0.00045894f, -0.07360978f, 0.08538336f, -0.07874920f, -0.05402146f, -0.10610908f, 0.30887464f, 
    -0.27521670f, -0.27788997f, -0.03030819f, 0.01134289f, 0.11053832f, 0.13626516f, -0.09422546f, 0.00060646f, 
    0.22224966f, -0.07660310f, -0.07622962f, -0.05139153f, 0.08000080f, -0.07438767f, -0.08249370f, -0.03689916f, 
    -0.00172714f, 0.48303294f, 0.24729714f, 0.20129140f, -0.06554626f, 0.00557502f, -0.05148457f, 0.11889352f, 
    0.25716320f, -0.00412816f, 0.01458485f, -0.25772300f, -0.27954969f, 0.13528138f, -0.12753557f, 0.12241954f, 
    0.04474587f, -0.11863557f, 0.15260717f, -0.02466660f, -0.02604467f, 0.21953605f, -0.02068546f, 0.07771153f, 
    0.12786472f, -0.00401933f, -0.05591565f, -0.11746687f, -0.17689525f, -0.14851330f, -0.01916037f, 0.01947482f, 
    0.25227123f, 0.16100891f, -0.08571578f, -0.00139808f, 0.15259673f, 0.35893345f, 0.19486973f, 0.30338606f, 
    0.04902733f, -0.04632163f, 0.04535658f, 0.00240428f, -0.02021491f, 0.02230000f, 0.01418267f, 0.16314419f, 
    -0.03367214f, -0.00143861f, -0.03765972f, -0.12448776f, 0.03587710f, -0.10166249f, -0.09527485f, 0.34123540f, 
    0.02925710f, 0.04085246f, 0.09185927f, -0.04460647f, 0.17983983f, -0.04281616f, -0.13362065f, 0.07456034f, 
    -0.21828374f, -0.00130117f, -0.19059843f, -0.05635156f, 0.11208934f, -0.12304966f, 0.11719406f, -0.18005119f, 
    -0.25709584f, -0.14967589f, 0.17408930f, -0.11819562f, 0.17335427f, -0.05615630f, -0.30545607f, -0.00127780f, 
    0.02991763f, -0.05894225f, -0.00238511f, -0.06926158f, 0.10387406f, -0.15484516f, 0.00951835f, 0.17174046f, 
    -0.00139656f, 0.03016804f, 0.20187093f, -0.37349665f, 0.29183865f, 0.20664823f, -0.03506554f, 0.11553816f, 
    -0.04786849f, -0.04063781f, 0.02198629f, 0.03349824f, 0.19859743f, -0.02451131f, -0.08673085f, 0.32598656f, 
    -0.01939131f, 0.02065868f, 0.01887920f, 0.08743676f, 0.04076448f, 0.31326586f, -0.27660215f, -0.20763281f, 
    0.13688400f, -0.14720868f, 0.01975347f, 0.08439478f, 0.05494104f, -0.30749834f, -0.03767437f, -0.02531811f, 
    -0.07021906f, 0.20363548f, 0.00667238f, 0.20354426f, -0.00681704f, 0.10528355f, 0.06950695f, -0.01779828f, 
    0.23131803f, 0.17568058f, 0.02366251f, -0.04059057f, -0.06064660f, -0.02065647f, 0.09729342f, -0.05219886f, 
    0.10590298f, -0.19863451f, 0.01369617f, 0.05926591f, 0.06963799f, 0.16270198f, -0.09427131f, 0.05123328f, 
    0.18051615f, -0.28787726f, -0.03703354f, -0.45062789f, 0.23826014f, 0.12769370f, -0.05899707f, 0.01968169f, 
    0.22429158f, -0.31715491f, 0.07334837f, 0.09472533f, -0.11578632f, 0.18203737f, -0.11446102f, 0.16448084f, 
    -0.11570707f, 0.03378466f, 0.09076552f, -0.01020636f, 0.02788438f, -0.36788410f, -0.19172694f, -0.03501621f, 
    -0.23636019f, 0.17324966f, 0.10923897f, 0.05542137f, 0.07290121f, 0.23286656f, 0.12485874f, -0.01516749f, 
    0.10706894f, -0.05841926f, -0.11135367f, -0.01693378f, -0.27299681f, 0.12992944f, -0.07977908f, 0.09591173f, 
    0.16389970f, -0.08760448f, 0.13536286f, 0.05131658f, -0.06150257f, 0.00924233f, -0.21397959f, 0.27738121f, 
    0.14365156f, -0.09317926f, -0.10633761f, 0.04172371f, 0.10547795f, -0.07878634f, 0.03977546f, 0.29420617f, 
    -0.09948822f, -0.05977437f, -0.02727927f, 0.07465632f, 0.15288371f, -0.34461033f, -0.07495676f, 0.21867581f, 
    -0.02927591f, -0.12309306f, -0.21636544f, 0.07106891f, -0.00971152f, 0.01500795f, -0.08526079f, 0.06706199f, 
    -0.28834927f, 0.16545452f, 0.08431125f, 0.05132063f, 0.20009756f, 0.05066120f, 0.09413163f, -0.00945476f, 
    0.03447231f, -0.15820543f, 0.09002657f, -0.10880841f, -0.28520244f, -0.10770398f, 0.10340031f, 0.14083414f, 
    -0.01748096f, -0.01412494f, 0.19138204f, 0.12103824f, -0.11044573f, -0.23709375f, 0.00553910f, -0.15106946f, 
    0.01424156f, -0.11724687f, 0.01529645f, -0.12984711f, 0.11364052f, 0.10421384f, 0.28443193f, 0.12484748f, 
    -0.06716613f, 0.08838479f, -0.00836819f, -0.07478033f, -0.03838883f, -0.13097097f, -0.05247562f, 0.10027844f, 
    0.12648159f, 0.08198503f, -0.14312974f, 0.09531882f, 0.06980097f, 0.12605616f, 0.19543366f, -0.12897438f, 
    -0.12084268f, 0.01806669f, -0.02593601f, 0.00516266f, -0.16415751f, -0.14895484f, -0.41059867f, 0.12759165f, 
    0.21196783f, -0.06076936f, -0.05172823f, -0.15299420f, 0.07582378f, -0.01937048f, 0.03552283f, -0.06189995f, 
    0.19674748f, 0.14395873f, 0.48486689f, 0.14011273f, -0.02782610f, -0.04084175f, 0.15900192f, 0.05091567f, 
    0.02072452f, -0.11604980f, -0.73659945f, -0.18976997f, -0.13394457f, -0.18281603f, -0.24031574f, 0.23300686f, 
    -0.09716412f, -0.14156184f, 0.08043336f, 0.00722481f, 0.19613826f, -0.02889069f, 0.15396515f, 0.00256041f, 
    -0.02439103f, -0.12723184f, -0.00733092f, -0.00699996f, 0.12321302f, 0.16943470f, 0.20600599f, -0.10035122f, 
    -0.14697653f, -0.02028702f, -0.15899660f, 0.10334082f, -0.25464779f, 0.08158734f, 0.38307053f, 0.14977758f, 
    0.06339817f, -0.16277252f, 0.14836194f, 0.00872806f, -0.03061459f, -0.25225747f, -0.01011285f, -0.40268585f, 
    -0.12551966f, -0.11675977f, 0.04503343f, -0.05208803f, 0.07390063f, 0.21721368f, -0.46267822f, -0.28849614f, 
    -0.21063370f, 0.15478231f, 0.00502989f, 0.10572658f, -0.01378091f, -0.15001395f, 0.10005747f, -0.18750319f, 
    0.06532746f, 0.33363664f, -0.10320722f, -0.09125808f, 0.01990727f, -0.01232696f, 0.05556307f, 0.02850333f, 
    -0.37235373f, -0.38152882f, -0.00094842f, 0.23356450f, 0.18164369f, 0.05472100f, 0.00788399f, -0.02231219f, 
    0.17823306f, -0.05728592f, -0.08238202f, 0.19693100f, 0.12149472f, -0.20674819f, 0.06194666f, -0.10030578f, 
    0.10387825f, 0.08918846f, -0.24700402f, 0.32734233f, 0.09142016f, 0.10111809f, 0.12659684f, -0.19845627f, 
    0.12193740f, 0.06865716f, -0.09189342f, 0.28250059f, 0.14356577f, 0.16176312f, 0.14986216f, -0.01656279f, 
    -0.01864712f, 0.06095521f, -0.11272616f, -0.11593903f, 0.16539855f, 0.02585061f, 0.45167005f, 0.02169600f, 
    -0.32990858f, -0.28647774f, 0.08365361f, -0.06781168f, 0.05939181f, -0.78810680f, 0.12772913f, 0.21659836f, 
    -0.12255605f, 0.08335596f, -0.06474973f, -0.17809361f, -0.01471286f, 0.27747488f, -0.06463932f, 0.13381936f, 
    0.44991466f, -0.05093182f, -0.00744274f, -0.04806112f, 0.17171039f, 0.11739728f, 0.12193068f, 0.06074705f, 
    0.14111461f, -0.19492757f, 0.03532255f, -0.04676620f, 0.14166404f, 0.05405098f, 0.01450622f, 0.03229745f, 
    -0.01218601f, 0.03586413f, 0.18217969f, 0.14400676f, 0.13413018f, 0.06538778f, 0.12488960f, 0.07331606f, 
    -0.13553710f, 0.12666029f, -0.17204134f, 0.15147915f, -0.07655303f, -0.00759089f, -0.16638660f, -0.10476641f, 
    0.11413950f, -0.01092003f, 0.19281171f, -0.09923284f, 0.06442914f, -0.04592122f, -0.03341371f, -0.06456870f, 
    0.04061093f, 0.00967714f, 0.04996254f, -0.20211579f, -0.37600413f, 0.01615185f, 0.00569522f, 0.01636823f, 
    0.25546294f, 0.00922139f, 0.08810394f, 0.05203926f, 0.05246618f, -0.38004595f, -0.05077988f, -0.03185569f, 
    -0.01735458f, 0.06648498f, 0.16585201f, -0.23153351f, 0.31952766f, 0.16467294f, 0.16073979f, -0.05524416f, 
    -0.07126713f, 0.04895278f, -0.25817093f, -0.03039484f, -0.05426238f, -0.13133121f, 0.09431789f, 0.02870020f, 
    0.23926246f, -0.05085948f, 0.04595286f, -0.11566414f, -0.03770522f, -0.06029174f, 0.17928025f, -0.29305461f, 
    -0.43737885f, 0.27370578f, -0.09541822f, -0.11267177f, 0.06048042f, -0.02200070f, 0.17057414f, -0.27213722f, 
    -0.16670355f, -0.10750514f, 0.15628958f, 0.07736138f, 0.11648976f, -0.11122920f, 0.03170953f, -0.03011696f, 
    -0.10232782f, 0.08400756f, 0.14266343f, 0.03837978f, 0.15388143f, -0.04319857f, -0.05642112f, 0.07896296f, 
    -0.01134545f, 0.11843397f, -0.54476494f, -0.15928377f, -0.00040775f, 0.00670144f, -0.16717407f, -0.26645803f, 
    0.18730402f, -0.04594895f, 0.05491697f, 0.37964615f, -0.22764942f, 0.01998631f, -0.17415445f, 0.11133489f, 
    0.22898939f, -0.06700002f, 0.07770504f, 0.04237219f, -0.04631346f, 0.07897829f, 0.05673316f, -0.04428068f, 
    -0.17312242f, -0.19259299f, 0.08409681f, 0.13168196f, -0.04368273f, 0.09557806f, 0.43109715f, 0.14567375f, 
    -0.01044491f, -0.07708054f, -0.09851252f, 0.06387889f, 0.07447354f, -0.22626345f, -0.05962329f, -0.14184448f, 
    -0.25893846f, 0.04142671f, -0.00222043f, 0.16265348f, 0.02620422f, -0.03129315f, 0.14847527f, -0.44999361f, 
    -0.61311591f, -0.58796793f, -0.00711107f, -0.27553642f, 0.11580018f, -0.12342101f, -0.17590588f, 0.03242062f, 
    -0.18961085f, 0.16713902f, 0.37101185f, 0.08121732f, 0.10560416f, -0.07711155f, 0.07539260f, 0.15348190f, 
    -0.01261489f, -0.14030024f, 0.04240914f, 0.16070829f, -0.04094078f, -0.04808270f, -0.24693878f, 0.20253302f, 
    -0.06034807f, -0.35464317f, -0.31787696f, 0.00144611f, 0.15061200f, -0.10253873f, -0.18370646f, 0.00418202f, 
    -0.01879138f, 0.10476578f, 0.06542781f, -0.10509622f, -0.40976429f, -0.00241040f, 0.08456329f, 0.05610032f, 
    -0.07573510f, 0.11779989f, 0.10826961f, 0.00581874f, -0.13407151f, 0.28955656f, 0.16223627f, -0.37623775f, 
    -0.13012025f, -0.24943934f, -0.11641847f, 0.01469643f, 0.04628251f, -0.19215956f, -0.34311554f, -0.17828028f, 
    0.03121053f, 0.07037691f, -0.01009511f, 0.08204005f, 0.01537424f, -0.14979632f, -0.20018844f, -0.02469844f, 
    0.10644063f, -0.07043862f, 0.15153393f, 0.02457877f, -0.01011394f, 0.31082293f, 0.24237728f, -0.30229756f, 
    -0.01334613f, 0.14384690f, 0.06470321f, 0.01833692f, -0.06443057f, 0.08664965f, -0.03777724f, -0.06202253f, 
    -0.10927210f, -0.13753103f, -0.04840204f, 0.05726302f, 0.30912080f, -0.07379590f, -0.17978433f, 0.11595530f, 
    0.24907365f, -0.05442019f, 0.04577953f, -0.02527980f, -0.11251323f, 0.00666698f, 0.20413084f, -0.08233492f, 
    0.01098470f, 0.26144883f, -0.17595428f, 0.18127857f, 0.18564278f, 0.00152809f, -0.04794874f, -0.14952365f, 
    0.09059460f, 0.12113226f, -0.11246452f, 0.39448655f, 0.38359174f, 0.06826976f, -0.05867835f, 0.15608677f, 
    0.02776366f, -0.07326940f, 0.03685968f, 0.22994404f, -0.06860331f, -0.07478373f, 0.08143084f, -0.23488577f, 
    -0.14315477f, -0.20115212f, 0.17792946f, 0.05321262f, 0.08007118f, -0.09150051f, -0.46242833f, -0.32330093f, 
    -0.24245383f, 0.32452396f, 0.04290552f, -0.11952327f, 0.20787713f, 0.16855627f, 0.27299222f, 0.23093282f, 
    0.10415762f, -0.02224415f, -0.03948529f, 0.06947900f, 0.17124449f, -0.03044433f, 0.17720206f, 0.09322957f, 
    0.19373798f, 0.18015654f, 0.05182948f, 0.21043500f, 0.03451102f, 0.09868579f, 0.16585003f, 0.11696196f, 
    -0.29135796f, 0.13755611f, 0.10851470f, -0.03734073f, 0.00445577f, 0.08198556f, 0.12464138f, -0.00727276f, 
    -0.01711853f, 0.17854807f, 0.12667392f, -0.14266708f, -0.18493606f, -0.25080800f, 0.04790681f, -0.02117225f, 
    0.18914813f, 0.04611031f, -0.15585561f, -0.05695133f, 0.08252218f, -0.21889049f, -0.24010865f, -0.10287683f, 
    0.08769985f, -0.12288827f, 0.08629890f, 0.36313692f, -0.20981918f, -0.00877955f, 0.08721763f, 0.12266079f, 
    -0.15459378f, 0.03091804f, -0.03616242f, 0.14959490f, -0.22484407f, -0.01700855f, -0.02477653f, 0.05281688f, 
    0.05526992f, 0.07922642f, -0.07968881f, 0.10327389f, 0.21259362f, -0.43884295f, 0.07944021f, -0.16132921f, 
    -0.05843999f, 0.02979516f, 0.10093403f, -0.03121382f, -0.02199779f, -0.16976131f, 0.25684917f, 0.16604191f, 
    -0.09207665f, -0.04874951f, -0.09336452f, 0.16727550f, -0.11304010f, -0.04587430f, 0.33187172f, -0.01504307f, 
    -0.03148650f, 0.40217966f, -0.11469177f, -0.27555665f, 0.12202633f, 0.02537104f, -0.06932703f, 0.08106053f, 
    0.02625224f, 0.17447214f, 0.09822673f, 0.07408140f, 0.13581108f, -0.01155115f, -0.01852497f, 0.17835097f, 
    0.22942382f, -0.03472345f, -0.04437622f, 0.07646931f, 0.06635182f, 0.17093623f, 0.06295567f, 0.03698082f, 
    0.03232270f, -0.01277305f, -0.26560354f, -0.00097999f, -0.15724589f, -0.14599776f, -0.26135173f, -0.26009694f, 
    -0.14894573f, -0.18110801f, 0.07742968f, -0.03561427f, -0.17706493f, -0.02664549f, -0.00215022f, -0.13066220f, 
    -0.19236013f, -0.00334855f, -0.08703738f, -0.01324653f, -0.33929136f, -0.32583666f, -0.20340087f, -0.04078265f, 
    0.07832403f, -0.00936330f, 0.08522116f, 0.15323706f, -0.34312549f, 0.12169683f, 0.13084900f, 0.27713379f, 
    -0.13470879f, 0.00456628f, 0.01105621f, 0.05379219f, 0.14960089f, -0.12694012f, -0.18444645f, 0.00252564f, 
    -0.14499404f, -0.16690050f, -0.17811815f, -0.04938718f, -0.14276363f, 0.14474110f, 0.16077465f, -0.32571101f, 
    -0.52938360f, -0.09734318f, -0.28822979f, -0.06825263f, -0.16728674f, 0.05080429f, 0.06471124f, 0.08544490f, 
    -0.45728150f, -0.18820183f, -0.09529406f, -0.47100082f, -0.03877797f, -0.06128910f, 0.11553765f, 0.04189254f, 
    0.00453368f, -0.25871509f, -0.19859183f, -0.01542996f, -0.01664525f, -0.01581116f, 0.07830321f, 0.17980263f, 
    -0.04203407f, 0.11767001f, 0.04674666f, 0.22477996f, 0.10991727f, -0.26308271f, 0.08101276f, -0.15224691f, 
    0.11975708f, -0.03509766f, -0.04608354f, 0.14930364f, 0.24977866f, 0.06530949f, -0.14646384f, -0.00900795f, 
    -0.02181096f, -0.13636030f, 0.00617090f, -0.07999004f, 0.65066987f, 0.03391833f, 0.15304615f, -0.21297857f, 
    -0.34264955f, -0.39759982f, 0.00169990f, -0.09245512f, -0.08856989f, 0.40031171f, 0.22889806f, 0.08774211f, 
    -0.01644379f, -0.39677161f, 0.15839954f, -0.02203472f, -0.02344925f, 0.08253503f, 0.01393215f, -0.03447149f, 
    -0.18815218f, 0.15920961f, 0.15569653f, -0.00411645f, 0.05899104f, 0.07395551f, -0.08500896f, -0.26245177f, 
    -0.07351538f, -0.51496023f, -0.02965571f, -0.15060347f, -0.05407544f, 0.06247297f, 0.09422376f, 0.11566556f, 
    -0.30373940f, 0.13543797f, -0.00578874f, 0.19049489f, -0.00678676f, 0.05142019f, 0.02350439f, -0.07111457f, 
    -0.03056133f, -0.00167947f, -0.01116577f, 0.10008530f, 0.14420721f, 0.02326081f, 0.12160783f, 0.00641563f, 
    0.04369640f, -0.02522996f, 0.14180571f, -0.11149943f, -0.10079702f, 0.00259278f, 0.07327004f, -0.07937085f, 
    -0.01811014f, -0.04525677f, 0.19223577f, 0.46848950f, -0.27704200f, 0.09592073f, 0.09522051f, -0.18294340f, 
    0.23502438f, 0.04541490f, -0.12038788f, 0.01597460f, 0.20725346f, -0.14167577f, 0.13530771f, -0.00059748f, 
    0.09657685f, 0.04073150f, -0.09366829f, 0.18348205f, -0.05755530f, 0.16621952f, 0.31155914f, -0.26537898f, 
    -0.15681672f, -0.20765184f, 0.15706830f, 0.08929683f, -0.11176178f, -0.10499439f, -0.54150790f, -0.05390685f, 
    -0.18390854f, 0.09854005f, 0.12968011f, 0.01339466f, 0.17337532f, -0.06981217f, -0.05321272f, 0.10103396f, 
    -0.26390091f, -0.23098566f, 0.09156017f, -0.11725253f, 0.11613522f, 0.11417047f, 0.12490945f, 0.04672608f, 
    -0.11511774f, 0.14943407f, 0.05300138f, -0.04750005f, 0.07484823f, -0.36102512f, 0.10317528f, -0.14338370f, 
    0.25925660f, 0.22936508f, -0.08260372f, 0.17219350f, -0.07026705f, -0.10523711f, 0.07425001f, 0.14098711f, 
    0.06533906f, -0.04340653f, 0.08790813f, 0.04613884f, 0.19474347f, 0.05524507f, -0.09653591f, 0.03177487f, 
    0.24011235f, -0.01797775f, -0.00535956f, -0.48087716f, 0.07031652f, -0.53070748f, 0.04746348f, -0.09251941f, 
    0.27850375f, 0.10542402f, -0.19725467f, -0.00383365f, 0.12970887f, 0.05969273f, 0.22511618f, 0.17638026f, 
    0.02511347f, 0.11417218f, -0.11698955f, -0.05663576f, -0.13904415f, -0.27855533f, 0.05798360f, 0.67464858f, 
    0.18898173f, -0.04899522f, -0.17418332f, 0.07097828f, -0.08134730f, 0.00717302f, 0.19262578f, -0.28785542f, 
    0.14408718f, 0.05360920f, -0.09049985f, -0.00270453f, 0.02011302f, -0.03335648f, 0.04582887f, -0.56538320f, 
    -0.45814702f, -0.28364837f, 0.06162124f, 0.06116065f, 0.07134140f, -0.01407900f, -0.02132414f, -0.20361713f, 
    0.05001760f, 0.06728857f, 0.08465583f, 0.09775427f, 0.09320515f, -0.03350022f, 0.15343699f, 0.07376300f, 
    -0.00901240f, -0.01047273f, 0.11246009f, 0.17312956f, -0.17243505f, -0.07506700f, -0.06173526f, 0.04984998f, 
    -0.05742414f, -0.06172366f, -0.17214596f, -0.18531504f, 0.02288747f, 0.03048996f, -0.12257449f, 0.05837508f, 
    0.02918958f, 0.03526415f, -0.01204393f, -0.23071066f, 0.04668817f, -0.09436495f, -0.07391803f, -0.05902860f, 
    -0.09538385f, 0.10813250f, -0.09370048f, -0.11218327f, -0.08411074f, 0.00310282f, 0.07452801f, -0.08727062f, 
    -0.19049242f, -0.16537026f, 0.03723720f, 0.01518355f, 0.11692516f, 0.57571346f, -0.16383693f, -0.06038654f, 
    0.07542504f, -0.05908018f, -0.06062576f, 0.13460447f, 0.10728347f, -0.05584307f, 0.16805345f, 0.00897336f, 
    0.05698449f, 0.11557175f, 0.05616944f, 0.02311968f, 0.23465529f, 0.12714083f, -0.03992823f, 0.25132975f, 
    0.00429997f, -0.22803627f, 0.00657781f, -0.04942405f, 0.12927069f, -0.03797223f, 0.05567282f, -0.13036573f, 
    -0.03990600f, 0.01003066f, 0.52722818f, -0.02999628f, 0.05096271f, -0.15583633f, -0.06196082f, 0.11486314f, 
    -0.06839341f, -0.48593220f, 0.08238164f, -0.00147802f, 0.06372815f, 0.05792481f, -0.11218662f, 0.10196543f, 
    0.08946226f, 0.12000304f, -0.08900733f, 0.13669072f, -0.07510857f, 0.02048397f, -0.03326686f, -0.22732486f, 
    -0.03617181f, 0.03632191f, 0.15758324f, -0.09408020f, -0.07317084f, 0.34711179f, -0.15409087f, 0.02585687f, 
    -0.08942634f, 0.24335045f, 0.02083329f, 0.13176166f, -0.30468506f, -0.80889320f, -0.17729691f, -0.13338909f, 
    -0.14535885f, 0.01269524f, -0.24862736f, -0.17683318f, -0.10178238f, -0.32906887f, -0.22908036f, 0.51211458f, 
    -0.34616593f, -0.04717014f, -0.08451822f, 0.00356267f, 0.10808425f, -0.15053324f, 0.05224933f, 0.32723856f, 
    0.07950870f, -0.00870984f, 0.10495988f, 0.07934262f, 0.27310479f, 0.04759890f, 0.03484797f, 0.03160438f, 
    0.10891116f, -0.39167783f, -0.18040049f, -0.19258738f, -0.05453790f, 0.00205556f, 0.13349727f, -0.07099975f, 
    -0.19525224f, 0.34057418f, -0.30845317f, 0.08349832f, 0.00187080f, 0.06128753f, 0.19314405f, 0.10180592f, 
    0.04642649f, 0.23451999f, 0.26463667f, 0.32837993f, -0.05202717f, -0.15539645f, 0.05247159f, -0.17859146f, 
    0.09945691f, 0.04103866f, 0.14292264f, 0.09426666f, -0.37422362f, 0.04729325f, 0.07089508f, -0.07554136f, 
    0.02065562f, 0.00085762f, 0.05084403f, -0.24079980f, -0.49568552f, 0.04453883f, 0.10709137f, -0.04607080f, 
    0.35739261f, -0.07832774f, 0.16965330f, -0.04080944f, 0.09098493f, 0.18356551f, 0.29022405f, -0.15458645f, 
    -0.15807559f, -0.25607204f, -0.18184979f, 0.24143164f, -0.00462502f, -0.41951537f, 0.17717022f, 0.19584771f, 
    0.06841478f, 0.04885818f, -0.12643604f, -0.11668807f, 0.16187601f, 0.12645319f, -0.04452937f, -0.31028998f, 
    0.06923673f, 0.15158173f, 0.18578115f, 0.02572669f, -0.00985038f, 0.04903780f, 0.00865660f, -0.21638046f, 
    0.06622781f, 0.26778117f, -0.15308544f, 0.18512809f, 0.04116415f, 0.06982421f, 0.12254404f, -0.00760793f, 
    -0.10907799f, -0.05088939f, -0.51897019f, 0.11000100f, 0.04230249f, -0.25111011f, -0.12785393f, 0.00587398f, 
    0.14004424f, -0.05694238f, 0.14237641f, -0.15278633f, -0.00220015f, -0.18211217f, 0.07340484f, 0.04482091f, 
    -0.23195347f, -0.10794822f, -0.05280260f, 0.08771142f, 0.17072026f, 0.00692488f, -0.12214104f, -0.14668775f, 
    -0.08758780f, -0.16235076f, 0.00600625f, -0.23165895f, 0.54919010f, -0.65253961f, -0.06091074f, 0.07472596f, 
    0.37800339f, 0.29318503f, 0.08148001f, 0.08829451f, -0.29617706f, -0.34695801f, 0.06263492f, 0.19275525f, 
    0.15675825f, 0.28085133f, 0.07852446f, 0.09932970f, 0.11348783f, 0.17926370f, 0.43288907f, -0.46473736f, 
    -0.03264173f, -0.23226343f, 0.16800553f, 0.11303020f, 0.08638412f, -0.11107118f, 0.10319660f, -0.07689541f, 
    0.76825362f, 0.17552803f, -0.07106932f, 0.11272915f, -0.03573357f, 0.08602959f, 0.28020996f, -0.46961558f, 
    -0.54900849f, 0.31830472f, -0.00842452f, 0.00869924f, 0.01804118f, 0.00755200f, 0.04905177f, -0.16119966f, 
    -0.02522876f, 0.13289273f, -0.19116311f, 0.20228338f, -0.04340231f, 0.03656985f, 0.07192270f, 0.02480191f, 
    -0.00913164f, -0.30718580f, -0.21233009f, 0.18629082f, -0.12551413f, -0.09572904f, -0.02875165f, -0.03460331f, 
    0.06704138f, -0.05996632f, -0.43718109f, 0.34025100f, 0.26057839f, 0.01209857f, -0.18791851f, 0.04164679f, 
    -0.02287848f, 0.00718530f, 0.03343762f, -0.17449790f, -0.07693497f, -0.25973260f, 0.03472238f, -0.21823338f, 
    0.15492639f, 0.04379828f, 0.04974158f, 0.03055151f, 0.20429611f, 0.12708472f, -0.60973054f, -0.34316853f, 
    -0.28024384f, -0.09299274f, 0.04357021f, -0.00302919f, -0.13336220f, 0.20507947f, -0.00098973f, 0.01794257f, 
    -0.15193503f, 0.04596759f, -0.04485877f, 0.06561146f, 0.02144013f, 0.06864023f, 0.02448627f, -0.00969622f, 
    -0.12877938f, -0.03463607f, 0.08426760f, 0.02148176f, 0.09555299f, 0.07309689f, -0.07108479f, 0.07450376f, 
    0.39706486f, 0.34318590f, -0.13165806f, -0.21487483f, -0.20243569f, 0.09118129f, 0.05006608f, 0.13490304f, 
    0.02793159f, 0.22578509f, -0.06809373f, -0.04957488f, 0.03141337f, -0.10882881f, -0.04943449f, -0.11943739f, 
    -0.22610845f, 0.03072955f, 0.10602564f, 0.00642594f, 0.08640371f, -0.20411891f, -0.07448913f, -0.12026653f, 
    0.03593053f, 0.00174452f, -0.25804558f, 0.01569465f, -0.11157359f, 0.17270634f, 0.04957069f, -0.00033972f, 
    -0.06805516f, 0.21154477f, 0.21144496f, 0.22540371f, 0.14870510f, 0.23007971f, -0.14425479f, -0.09338290f, 
    0.07072750f, 0.08913279f, -0.07324187f, 0.14393860f, 0.22648001f, -0.21852341f, -0.34423774f, 0.09097148f, 
    0.12599172f, 0.04492652f, 0.09419342f, 0.03686371f, 0.16557743f, 0.18671824f, 0.51584369f, 0.18195611f, 
    -0.00839158f, -0.05970489f, -0.16538306f, -0.00650450f, -0.15523858f, 0.08885254f, 0.12421039f, 0.08350137f, 
    0.03037543f, -0.09218508f, -0.05608543f, 0.11400537f, 0.12881529f, 0.01340602f, 0.12381621f, 0.09364903f, 
    0.31110811f, 0.26778510f, -0.09046889f, 0.12433192f, -0.02888856f, -0.05067122f, -0.05350184f, -0.18758275f, 
    0.11949695f, 0.02822638f, -0.13492908f, -0.22694828f, 0.04888086f, 0.13779218f, 0.08233921f, 0.06644259f, 
    0.02308261f, -0.20762870f, -0.33217743f, -0.14838819f, -0.04401946f, -0.04912270f, -0.07098949f, 0.06650160f, 
    0.10753511f, 0.03137775f, 0.17925775f, -0.05036663f, 0.09678825f, 0.05152635f, -0.03783852f, 0.08670417f, 
    -0.09687970f, -0.14035648f, 0.16417159f, -0.19733088f, 0.07135313f, 0.23501322f, 0.04751589f, 0.03151658f, 
    0.06259648f, 0.01774179f, 0.06977855f, -0.03070002f, -0.01964865f, -0.06395844f, 0.04734686f, 0.02069961f, 
    -0.10335338f, -0.23978898f, -0.10620775f, 0.09782939f, 0.21779862f, 0.12452590f, 0.35829762f, -0.00504815f, 
    0.16483131f, -0.19987458f, -0.03863277f, 0.07546591f, -0.09919813f, 0.01463382f, -0.10492469f, 0.18049549f, 
    0.46781325f, 0.21810216f, -0.06073521f, 0.16530432f, -0.05246878f, 0.14585687f, 0.15702334f, 0.20944633f, 
    0.33553165f, 0.22340962f, -0.16476424f, -0.00288509f, -0.00735930f, -0.07208884f, -0.18303286f, -0.06530601f, 
    0.03946795f, -0.20810492f, -0.19820242f, 0.12956901f, -0.01660893f, 0.05495510f, -0.03738758f, 0.01486835f, 
    0.12280161f, -0.14084595f, -0.12299471f, -0.19208574f, -0.01001935f, -0.21761896f, 0.09764010f, 0.14033985f, 
    0.02130014f, 0.15678668f, -0.03322959f, -0.13024057f, -0.28048316f, -0.07698987f, -0.17247243f, -0.09667931f, 
    -0.01228122f, 0.07383268f, 0.21621107f, 0.26224199f, 0.22754061f, -0.01779202f, -0.28633016f, 0.21549997f, 
    0.32697487f, 0.20682165f, 0.39428997f, 0.25747907f, 0.01101541f, 0.33491871f, -0.03744007f, 0.10542700f, 
    0.00289561f, 0.13531396f, -0.09666967f, -0.04489543f, -0.14024159f, -0.01147382f, -0.12436376f, 0.11670812f, 
    0.16287178f, -0.03827936f, -0.02801145f, -0.21743993f, -0.01694731f, -0.07511494f, -0.26053366f, 0.14873491f, 
    -0.07393929f, 0.02287538f, 0.18439348f, -0.28819495f, 0.17193855f, -0.00169492f, -0.09505133f, -0.03511772f, 
    0.25831336f, 0.61498243f, -0.22225840f, -0.04784765f, 0.07925444f, -0.10704795f, -0.06782012f, 0.02188510f, 
    -0.10248417f, -0.17570172f, -0.21931505f, 0.05758814f, -0.21384177f, 0.03334783f, -0.05607074f, 0.01145944f, 
    0.10108484f, 0.25066164f, 0.31363791f, 0.22634462f, 0.05790510f, -0.20482266f, 0.02912275f, 0.02402399f, 
    -0.05269563f, -0.06120479f, -0.04760277f, -0.04566025f, 0.07395148f, 0.30977681f, -0.23904201f, -0.10154312f, 
    0.00318252f, 0.00803420f, 0.29091531f, -0.06030330f, 0.01771339f, -0.11032534f, -0.07565575f, -0.08990991f, 
    0.02523705f, -0.15576990f, 0.12350506f, 0.18782529f, 0.28731105f, 0.20540552f, 0.53465754f, -0.06816727f, 
    0.01774913f, -0.14840557f, -0.18809760f, -0.06575593f, -0.13435990f, 0.07764222f, 0.13893807f, 0.10195263f, 
    -0.03209883f, -0.09970560f, -0.08499169f, -0.05164284f, -0.04465337f, 0.16632414f, -0.12840849f, 0.06297428f, 
    -0.15119806f, 0.01189750f, -0.14744106f, 0.00598205f, 0.00872152f, -0.09367501f, 0.05771675f, -0.31461030f, 
    -0.25692475f, 0.24248384f, -0.22731207f, 0.09184715f, 0.03244182f, 0.21942565f, 0.04285590f, -0.02125957f, 
    0.03801461f, 0.12653463f, 0.14801468f, 0.25797957f, -0.06514236f, 0.08660738f, 0.09295839f, 0.12604566f, 
    -0.00839497f, 0.37008372f, 0.27779490f, -0.03319504f, -0.04042904f, -0.00818331f, -0.00496424f, 0.09849362f, 
    0.29249370f, -0.01910018f, -0.21526423f, -0.36600173f, -0.11546093f, 0.08136915f, -0.02612456f, 0.08532019f, 
    0.06918286f, -0.31092784f, 0.00112937f, -0.11363202f, -0.06804616f, -0.01986856f, -0.06729019f, 0.05837088f, 
    0.04472490f, -0.05228788f, -0.29772025f, -0.12633167f, -0.25650281f, -0.10271792f, 0.28916600f, -0.28162074f, 
    0.08891603f, -0.09869426f, 0.11569042f, -0.23623502f, 0.10158354f, 0.16355368f, 0.19832054f, 0.32490852f, 
    0.07326448f, 0.01327763f, -0.05929147f, -0.21585461f, 0.03002568f, -0.14060694f, 0.05771349f, 0.18254584f, 
    -0.07622958f, 0.01204881f, -0.12494677f, -0.03652407f, 0.17871346f, -0.26533002f, 0.04648508f, 0.34587678f, 
    0.08593661f, 0.14984474f, 0.12898949f, -0.05825366f, -0.13166870f, -0.03520245f, 0.03350706f, -0.03202546f, 
    -0.16328016f, 0.09987637f, 0.05219919f, -0.00394649f, 0.06867368f, 0.07411506f, 0.08877672f, 0.05211653f, 
    -0.06741410f, 0.10071815f, 0.11925894f, 0.04072747f, -0.04327018f, -0.10815196f, -0.05858658f, 0.01412038f, 
    0.00816612f, 0.04227382f, 0.02358203f, 0.07727404f, 0.15820925f, 0.15570913f, 0.06442582f, -0.07720876f, 
    0.09643955f, 0.06428415f, 0.05883224f, -0.00218430f, 0.18157871f, 0.22373550f, -0.20347084f, 0.02999269f, 
    -0.02890322f, 0.12841439f, -0.04860094f, 0.06203107f, 0.16268168f, 0.13631821f, 0.19851594f, 0.02634154f, 
    0.10971551f, 0.01659185f, -0.10760832f, 0.17309085f, 0.01905980f, -0.11568405f, -0.12703566f, -0.18907270f, 
    -0.33254787f, -0.12576826f, 0.15530381f, -0.19411923f, 0.09975525f, -0.23651515f, 0.36013275f, 0.08198506f, 
    -0.16925263f, -0.23494305f, 0.13242279f, -0.14766043f, -0.22115883f, -0.00747773f, 0.18707223f, 0.00357497f, 
    0.14499235f, 0.22757812f, 0.08279502f, -0.08636763f, 0.13343664f, -0.05912117f, 0.08767416f, 0.01574729f, 
    -0.04748363f, 0.04533856f, -0.01390240f, 0.21565454f, 0.10908172f, -0.01894964f, 0.20175846f, 0.14193989f, 
    0.03037583f, -0.04653584f, 0.10758133f, 0.01648892f, -0.12143281f, 0.15579943f, 0.02929725f, 0.08781573f, 
    0.14864151f, -0.13192765f, 0.11510032f, -0.00159213f, 0.08438968f, 0.03485063f, -0.00239737f, 0.04318096f, 
    -0.08031051f, 0.05235209f, 0.12304643f, -0.11741505f, 0.14389133f, -0.04068932f, 0.14102988f, -0.00083065f, 
    -0.07539015f, -0.05923754f, -0.00390905f, -0.22261062f, -0.02324645f, 0.10051494f, -0.05458935f, 0.04768166f, 
    0.06203108f, 0.00626118f, 0.16704449f, -0.07612450f, -0.09571395f, -0.02984879f, 0.07295133f, 0.38725305f, 
    0.24424978f, -0.00778194f, 0.13152340f, 0.13094708f, 0.05666299f, 0.06065611f, 0.17162515f, 0.04613267f, 
    0.02065776f, -0.04950387f, -0.26224825f, -0.00861100f, 0.09005121f, -0.07129278f, 0.10904063f, -0.40658024f, 
    -0.31558639f, 0.00095054f, -0.00343928f, 0.26548639f, -0.07519887f, 0.05087518f, -0.09274496f, 0.20081964f, 
    0.05646053f, 0.05283176f, 0.02871288f, 0.01632537f, 0.03491983f, 0.00539430f, 0.07110103f, 0.08132032f, 
    -0.13459739f, -0.23009916f, -0.17669167f, -0.05431667f, 0.00370448f, 0.10459433f, -0.03676562f, 0.01329867f, 
    -0.00798640f, -0.05270696f, -0.02806672f, -0.03121315f, -0.21515079f, -0.11953317f, 0.02132174f, 0.06695881f, 
    -0.08644523f, 0.27774453f, 0.04286975f, 0.07017691f, -0.22376586f, 0.10033019f, 0.03586251f, 0.05954711f, 
    0.08439679f, -0.05254779f, -0.00297158f, -0.22090279f, 0.02392533f, 0.03108481f, 0.18702723f, 0.18642588f, 
    -0.03117356f, -0.12975290f, -0.05845254f, -0.10138522f, -0.02313752f, -0.06916261f, 0.01193180f, 0.04982262f, 
    0.09224059f, -0.06964523f, 0.11002553f, 0.01335460f, -0.08402590f, 0.07210166f, -0.04463987f, 0.04780426f, 
    -0.00175413f, 0.01816437f, 0.03802018f, 0.19317903f, 0.01259288f, -0.09954004f, -0.07371636f, -0.08709748f, 
    0.26396221f, 0.14770257f, -0.16085745f, -0.25690636f, -0.10362963f, 0.04555354f, -0.05193311f, 0.02886249f, 
    -0.38137102f, -0.24541464f, 0.04098110f, -0.06742956f, -0.11084644f, -0.08094233f, 0.09908553f, 0.13812326f, 
    0.15735765f, -0.15464042f, 0.10038700f, -0.12461264f, -0.12074585f, 0.08657257f, -0.04319138f, 0.10488061f, 
    -0.09319724f, 0.21953271f, 0.05597484f, 0.04202123f, 0.26746914f, -0.07054606f, -0.13567445f, -0.09181187f, 
    0.03936115f, 0.06112177f, 0.07726492f, -0.28876641f, -0.33836758f, -0.59941661f, 0.12856111f, 0.03161485f, 
    -0.03843610f, -0.10021050f, -0.06635302f, -0.11292107f, -0.30695567f, 0.14388403f, 0.23838502f, -0.24369439f, 
    -0.18343194f, -0.09969261f, 0.04363206f, 0.04603243f, 0.06144168f, -0.10673206f, -0.38741678f, -0.26671472f, 
    -0.02312133f, 0.04836235f, -0.16880895f, -0.10360782f, -0.00666516f, 0.02326768f, 0.34767562f, -0.06839179f, 
    -0.28326470f, 0.05002759f, 0.12870783f, 0.15145466f, 0.16386937f, -0.00186076f, -0.08381380f, -0.10932402f, 
    -0.22069125f, -0.35299844f, -0.11795934f, -0.13688612f, -0.05655136f, -0.02862783f, 0.07245301f, 0.04966908f, 
    0.09638973f, 0.12901370f, -0.25677699f, -0.03105202f, -0.05197530f, -0.01974697f, 0.09098694f, -0.16000150f, 
    -0.04063942f, 0.25025812f, -0.02275114f, -0.20782699f, 0.07518700f, 0.04323324f, 0.07124265f, 0.11911102f, 
    0.16127089f, 0.06091858f, 0.12202708f, -0.13134162f, 0.05981825f, -0.14447103f, -0.01768875f, 0.14207801f, 
    0.15431705f, 0.04785624f, 0.21524878f, 0.01471914f, 0.36702415f, 0.04712991f, -0.06856702f, 0.08718961f, 
    0.22960463f, 0.24111184f, -0.00086405f, 0.09276319f, 0.07591053f, -0.06647176f, -0.03042321f, 0.02263366f, 
    -0.09037474f, -0.03086215f, 0.01864669f, -0.01308835f, 0.11765172f, 0.05055900f, -0.35933322f, -0.45758954f, 
    -0.00796862f, -0.02844809f, -0.12270212f, -0.11476123f, -0.06934401f, -0.17952630f, -0.36997366f, -0.11372821f, 
    0.07528484f, 0.02453112f, 0.00835853f, 0.13748477f, -0.08621376f, 0.13176695f, 0.05288051f, -0.07032190f, 
    -0.48389244f, -0.15078169f, 0.14349960f, 0.19175394f, 0.10776492f, -0.01240856f, -0.00370173f, 0.06389550f, 
    -0.04051605f, 0.15160322f, 0.25419739f, -0.06006712f, -0.09536675f, -0.22282536f, 0.04337247f, 0.12136567f, 
    0.28813565f, -0.06472848f, 0.19686888f, -0.07809397f, -0.04862519f, 0.02185271f, 0.08277801f, -0.03523207f, 
    0.15668155f, 0.11323970f, 0.05054703f, 0.01269999f, -0.07865613f, -0.06647482f, -0.08601462f, -0.08715284f, 
    0.01808358f, 0.14534153f, 0.05635837f, -0.17070411f, -0.44647676f, -0.08590876f, 0.10749842f, -0.21524972f, 
    -0.04821008f, 0.01898585f, -0.20249668f, 0.07146028f, 0.33625221f, 0.48059878f, -0.14676499f, 0.00314346f, 
    0.01971442f, -0.06441258f, -0.01545235f, -0.11250019f, -0.09192713f, -0.31180400f, 0.41976851f, 0.81623560f, 
    -0.06738109f, 0.00541032f, 0.03136652f, -0.08950176f, -0.04759841f, 0.10416728f, 0.28797114f, -0.01509185f, 
    -0.29852453f, 0.01878058f, -0.17473528f, 0.08332530f, 0.03262630f, 0.13544987f, 0.05131651f, -0.63582522f, 
    -0.24097022f, 0.10804977f, -0.06504396f, 0.13785489f, -0.09906604f, -0.09275673f, -0.10808641f, 0.24256399f, 
    0.06440062f, 0.21943590f, 0.04579129f, -0.08790312f, 0.07043201f, 0.00927932f, 0.04141168f, 0.19226809f, 
    -0.03355628f, -0.37218055f, 0.23949340f, 0.18471599f, -0.03521900f, 0.04211921f, -0.06004911f, -0.01824692f, 
    0.12660728f, 0.04546756f, -0.27735439f, -0.11711181f, -0.16864124f, -0.08162119f, -0.00785036f, -0.04445399f, 
    0.00790998f, 0.17155570f, 0.29176858f, -0.13377023f, -0.15570064f, -0.05767204f, -0.13685529f, -0.12249563f, 
    -0.06012530f, -0.02926379f, 0.00402506f, -0.12688191f, -0.29418325f, 0.03080665f, -0.37672594f, -0.15661670f, 
    -0.22877111f, 0.02882423f, 0.01571824f, 0.04734718f, -0.02008371f, -0.05339241f, -0.33000925f, -0.02604534f, 
    -0.02446954f, 0.14302972f, 0.10379905f, 0.16144133f, 0.07767757f, 0.09508830f, 0.08739751f, 0.07631015f, 
    -0.08847040f, 0.00727111f, -0.05279091f, -0.01318742f, -0.10121448f, -0.01939113f, -0.18191029f, 0.19605003f, 
    -0.56630683f, -0.20640270f, -0.07897060f, 0.03714542f, 0.07506866f, 0.13212681f, -0.05174317f, -0.11593498f, 
    0.34563676f, 0.16318624f, -0.38685766f, -0.04171725f, -0.01983424f, 0.04533185f, 0.02013157f, 0.02976513f, 
    0.10257298f, -0.00728549f, -0.01366823f, 0.14288898f, 0.20800121f, 0.05165241f, 0.18961360f, -0.27733907f, 
    -0.26933983f, -0.59156716f, 0.09737689f, -0.01966486f, 0.01116578f, -0.11698693f, 0.29761750f, 0.13919123f, 
    -0.03353515f, -0.06212591f, 0.00756798f, 0.23801742f, 0.31134415f, 0.04570121f, -0.07898627f, -0.02564196f, 
    0.03345015f, 0.04419259f, -0.05858524f, -0.03790728f, 0.38067961f, -0.04012658f, -0.32703903f, 0.05715352f, 
    0.12695330f, -0.03623188f, 0.00107721f, 0.06780565f, -0.12553111f, -0.08055758f, 0.42836964f, -0.02539423f, 
    -0.09202294f, 0.03521209f, 0.08913840f, -0.11236954f, -0.06341079f, -0.16752921f, -0.09934885f, -0.06538784f, 
    0.22137438f, 0.00895536f, -0.11202785f, -0.08740781f, 0.00675937f, -0.00502414f, 0.01453772f, 0.04488047f, 
    0.27766314f, -0.17308132f, -0.02164600f, 0.06072634f, 0.21919864f, -0.02066634f, 0.04139120f, 0.03922691f, 
    0.02490256f, 0.02346739f, 0.03120285f, 0.03883482f, 0.05880655f, -0.31698692f, -0.08006376f, -0.04823831f, 
    0.08989410f, -0.18627374f, -0.18514895f, 0.08898994f, 0.01062220f, 0.01675275f, 0.02170523f, -0.09875745f, 
    0.19755130f, -0.03044813f, 0.17238976f, 0.01318700f, -0.24884605f, -0.02510627f, 0.04817452f, -0.09539009f, 
    0.09658256f, 0.06825186f, 0.00968522f, 0.10005299f, -0.11466066f, -0.18526445f, -0.09038529f, -0.06883622f, 
    -0.08674949f, -0.08304129f, 0.14191234f, -0.08465447f, -0.08063304f, 0.00533269f, 0.09735912f, 0.03245568f, 
    -0.00849837f, -0.11056422f, 0.07621022f, 0.00163427f, -0.22229317f, 0.16847388f, 0.10448983f, 0.60645658f, 
    0.04284601f, -0.05049003f, -0.04735176f, -0.04645091f, -0.02894548f, 0.03413007f, 0.06986243f, 0.12124176f, 
    0.35135111f, -0.15356559f, 0.01812487f, 0.18247786f, -0.02198905f, 0.03644530f, -0.08841167f, 0.00334878f, 
    0.13196324f, -0.15429732f, 0.02002298f, -0.04034067f, 0.05623362f, -0.11340327f, -0.06091057f, 0.02423274f, 
    0.23271872f, 0.08468083f, -0.03695593f, -0.03687086f, 0.07006099f, -0.02688790f, -0.04846964f, -0.02743772f, 
    -0.17645976f, -0.12435756f, -0.18476635f, 0.02211059f, -0.00185006f, -0.22036967f, 0.01117208f, -0.07344760f, 
    -0.12767039f, -0.06742193f, 0.04414139f, -0.08194774f, 0.06428012f, -0.08776435f, 0.02647260f, 0.00407379f, 
    -0.06764485f, -0.04019052f, -0.09574308f, -0.09002198f, -0.11151864f, 0.33246881f, 0.01857289f, -0.22834826f, 
    0.17804652f, 0.03426931f, 0.08349317f, 0.31744483f, 0.11877653f, 0.08783066f, -0.03532103f, -0.11780218f, 
    -0.06275463f, -0.08571755f, -0.02931246f, 0.08145260f, 0.06929060f, 0.24768887f, 0.11592066f, -0.08645955f, 
    0.03059541f, 0.09768689f, -0.06436200f, 0.12929271f, 0.04043113f, 0.08711857f, -0.10835184f, -0.26284721f, 
    0.18539704f, 0.07796729f, 0.09811351f, 0.02097979f, -0.14643107f, 0.01121918f, -0.02097504f, 0.18310291f, 
    0.18121995f, 0.29647639f, 0.10755439f, 0.09956569f, 0.02653504f, -0.13290659f, 0.17030452f, 0.01125103f, 
    0.00880262f, -0.15985130f, 0.07967391f, -0.12684681f, -0.12358994f, -0.16524914f, -0.05698707f, 0.13202453f, 
    -0.02604751f, 0.16764745f, 0.32325605f, -0.01640684f, 0.02212872f, 0.14474490f, -0.02508990f, 0.04894040f, 
    -0.02492786f, 0.10756999f, -0.02035663f, -0.08559369f, 0.22195555f, 0.22099593f, -0.11187664f, 0.18196882f, 
    -0.26448968f, -0.24233654f, -0.22863266f, 0.08445036f, 0.07356979f, 0.20494179f, -0.04892179f, 0.02935227f, 
    0.17005657f, -0.00503136f, 0.13721342f, 0.09907413f, 0.24505869f, 0.22999392f, 0.02625295f, 0.08806378f, 
    -0.04936654f, -0.04364099f, -0.01135909f, 0.01349940f, 0.10089915f, -0.14909202f, -0.01883752f, -0.04574927f, 
    0.12997845f, 0.00403305f, -0.03648213f, -0.08201205f, -0.12535986f, 0.05182636f, 0.08987811f, 0.11468905f, 
    0.03659016f, 0.06786077f, -0.13332999f, -0.10002845f, 0.13032106f, 0.02906525f, -0.02227431f, -0.22923003f, 
    -0.29440227f, 0.04853325f, 0.05240035f, 0.16822223f, 0.09970499f, 0.04245558f, 0.10148294f, 0.06917506f, 
    -0.22141458f, -0.06015474f, 0.31181774f, -0.09960459f, -0.05740560f, -0.17002624f, 0.15715218f, -0.00968763f, 
    0.10893561f, -0.07072151f, -0.04244871f, -0.10531415f, -0.02859754f, -0.08713783f, -0.01942785f, -0.08220841f, 
    0.14628437f, 0.10082415f, -0.45267838f, -0.09118551f, 0.29259717f, 0.08046502f, 0.01242363f, -0.00227164f, 
    0.08079170f, -0.05110764f, 0.02316136f, -0.06737646f, -0.40843961f, 0.18391135f, 0.05460694f, -0.03684395f, 
    -0.21971735f, 0.06308407f, -0.02932811f, 0.04425524f, -0.44806740f, -0.08644237f, 0.15097757f, -0.07433236f, 
    0.01585176f, -0.10277627f, 0.05078273f, -0.04375942f, 0.18254496f, -0.04629694f, -0.31592533f, 0.03590163f, 
    -0.13879062f, -0.00564500f, -0.25811183f, 0.04743397f, 0.09106919f, -0.08450955f, 0.46799272f, -0.11353004f, 
    0.14112872f, 0.32143837f, 0.01695444f, 0.01904816f, 0.14172320f, -0.00247911f, 0.07810508f, 0.02098927f, 
    0.06768383f, 0.36484668f, -0.23291786f, -0.08713713f, -0.13591395f, 0.11029807f, 0.10984045f, 0.07049137f, 
    0.38724864f, -0.31555164f, -0.44614893f, 0.02308815f, -0.16631128f, 0.07675602f, 0.03561833f, 0.11485013f, 
    -0.23989163f, 0.35096720f, 0.05814145f, -0.26278490f, 0.07312158f, -0.12914647f, -0.17863043f, -0.01093951f, 
    0.11137750f, -0.07015765f, 0.02232834f, 0.00947897f, 0.16638489f, -0.00494201f, 0.02627637f, 0.02713024f, 
    -0.01305717f, -0.05567018f, 0.27655813f, 0.07043760f, 0.25762764f, 0.01128229f, -0.00525915f, 0.16747120f, 
    -0.01028442f, 0.19875380f, -0.02389445f, 0.20263976f, 0.11471462f, 0.10004182f, 0.17424080f, -0.05977952f, 
    -0.54331553f, -0.08724459f, -0.05831785f, 0.17057993f, -0.02596423f, -0.09086540f, -0.66167039f, -0.02487204f, 
    -0.26544517f, -0.30862978f, -0.19026937f, 0.00041139f, 0.17754564f, -0.09262134f, 0.22481458f, -0.40904561f, 
    0.22470249f, 0.11110569f, 0.09470183f, -0.01135411f, 0.13107897f, -0.15314120f, 0.23371592f, 0.20764941f, 
    0.06674697f, 0.16096875f, 0.06768699f, 0.00262707f, 0.01522369f, 0.02978467f, 0.15218221f, 0.18114144f, 
    -0.29569942f, 0.05120160f, 0.01296716f, -0.10096119f, 0.07228167f, 0.01686084f, -0.08984591f, -0.01170865f, 
    0.14259326f, 0.13176323f, 0.08805919f, -0.00627333f, 0.00562412f, 0.03414887f, 0.14847316f, 0.13183278f, 
    0.05870886f, 0.26959357f, -0.17446487f, -0.06161319f, 0.03661882f, -0.13841784f, 0.02015593f, -0.13564375f, 
    0.05395093f, 0.03238860f, -0.09400488f, 0.33370823f, -0.29933679f, -0.22801417f, 0.10692686f, -0.25579092f, 
    0.26641297f, 0.20833302f, -0.04063649f, -0.05543955f, 0.02530809f, -0.02863257f, -0.22282034f, -0.02614939f, 
    0.00497796f, 0.04287892f, -0.02696875f, 0.06115765f, -0.33491343f, -0.26098198f, -0.06777022f, 0.00220764f, 
    0.03167519f, 0.00492368f, -0.04882059f, -0.19929084f, -0.01373172f, -0.05405153f, 0.46310720f, -0.22430569f, 
    -0.02083457f, 0.10216694f, -0.08173925f, -0.07366478f, 0.13472931f, -0.22241910f, 0.17905821f, -0.38177732f, 
    0.10037920f, 0.18353796f, -0.01673613f, -0.01005050f, 0.15340503f, 0.03352619f, -0.03820400f, 0.06229021f, 
    0.14983046f, 0.20954791f, 0.01002203f, -0.00513357f, 0.02632514f, 0.18033664f, 0.16725740f, 0.23177466f, 
    -0.03155848f, -0.09037076f, -0.15633939f, 0.09001531f, -0.01689966f, -0.02110163f, -0.10034062f, 0.11042657f, 
    0.04279306f, -0.05769875f, -0.16502048f, -0.21668683f, -0.15344442f, -0.13720892f, -0.34995523f, -0.00845276f, 
    -0.08626829f, 0.14203341f, 0.31852746f, 0.14547020f, -0.32127985f, -0.55515897f, -0.08240364f, -0.41045505f, 
    0.06020268f, 0.06749391f, 0.14589497f, -0.06641544f, -0.17822796f, -0.12856975f, -0.27638716f, -0.00868791f, 
    -0.21117684f, -0.09371206f, -0.05403190f, -0.01189112f, 0.06095277f, 0.09507758f, 0.02065711f, 0.00905930f, 
    0.10333270f, -0.08084977f, -0.18296891f, 0.11510652f, 0.15193947f, 0.04323380f, 0.22429058f, -0.00921760f, 
    -0.25791681f, -0.39854518f, -0.12451687f, 0.06285279f, 0.16363236f, 0.05852437f, 0.00258310f, 0.15967211f, 
    -0.16567139f, -0.16440348f, -0.11187088f, -0.15534377f, -0.40164179f, 0.07183678f, 0.06689913f, 0.14047757f, 
    -0.01366363f, -0.01893543f, -0.01443355f, -0.00923631f, -0.01259624f, -0.02061524f, 0.04061290f, -0.02263249f, 
    0.01779788f, 0.04487000f, 0.02505299f, -0.01898829f, -0.03499091f, 0.02052781f, 0.03836924f, 0.02631225f, 
    0.03058380f, -0.01463957f, -0.00393678f, 0.00143807f, 0.03000547f, -0.00204719f, -0.00106075f, -0.04300166f, 
    0.05759323f, -0.01665694f, -0.03265110f, -0.05268804f, 0.01149402f, 0.02119642f, -0.05866545f, 0.01007956f, 
    -0.05263530f, 0.01006579f, -0.01988346f, -0.05322770f, -0.04326843f, 0.03881885f, -0.04435781f, 0.01452667f, 
    -0.05537974f, -0.02588618f, 0.05062094f, -0.05552534f, 0.02840993f, -0.04212110f, -0.05857866f, 0.03277775f, 
    0.01235413f, -0.05546132f, 0.00409388f, -0.04716183f, -0.03952802f, 0.03682117f, 0.01853906f, -0.01784712f, 
    -0.01651309f, 0.00586460f, -0.00950633f, -0.04433886f, 0.05078139f, 0.05442585f, 0.02015743f, -0.00662482f, 
    0.05087934f, 0.03417076f, 0.04451889f, -0.03498860f, -0.01759193f, -0.04284704f, -0.04404446f, 0.02680959f, 
    -0.02439257f, 0.02794159f, -0.01036656f, 0.00151226f, 0.05692803f, 0.03661009f, 0.03813658f, -0.05161550f, 
    -0.03081361f, -0.01048288f, 0.04232040f, -0.04256739f, 0.00437678f, -0.02985615f, 0.04449585f, 0.04987452f, 
    -0.05032360f, 0.05360560f, -0.00000334f, 0.02616389f, -0.01023654f, -0.00075950f, -0.00928749f, 0.02287237f, 
    -0.00448629f, 0.02320832f, 0.03285212f, 0.02476684f, -0.01946654f, -0.04392391f, -0.01037969f, -0.00001324f, 
    -0.05704606f, -0.05476154f, 0.05417068f, -0.03835157f, 0.02261158f, 0.02499468f, -0.05850375f, -0.04757191f, 
    -0.02859368f, -0.05665538f, 0.01509114f, 0.05765196f, -0.02284599f, 0.03978321f, -0.02719476f, 0.04244998f, 
    0.03190917f, 0.00326545f, -0.05473575f, -0.03507367f, 0.02003311f, -0.04240704f, 0.00573727f, 0.04814813f, 
    -0.02251551f, -0.03801723f, -0.00590078f, 0.02621136f, 0.00825662f, -0.00700227f, -0.00142303f, 0.01141415f, 
    -0.04186192f, 0.04048876f, -0.04272806f, 0.05774805f, 0.02313796f, 0.02088846f, -0.03904528f, 0.02963389f, 
    0.01565054f, -0.00679069f, 0.02719667f, 0.03019234f, -0.00408608f, -0.05087279f, 0.01639851f, -0.04094081f, 
    0.05066952f, -0.03467299f, 0.00714803f, -0.02358541f, 0.03614600f, 0.01367091f, -0.00169293f, -0.04833106f, 
    0.02465169f, 0.00894499f, -0.04345294f, 0.01221624f, 0.00383975f, 0.00700291f, -0.01917789f, -0.05267491f, 
    -0.00546168f, -0.05734243f, 0.05180544f, 0.01073962f, -0.03122045f, -0.02112410f, -0.04567094f, 0.04837317f, 
    -0.05147306f, -0.03962808f, -0.02437826f, -0.04081371f, -0.04833486f, -0.04588776f, -0.05638259f, 0.03369957f, 
    -0.00232849f, 0.03245449f, 0.01332427f, -0.03713792f, -0.02800704f, 0.00439279f, -0.05203246f, 0.01309727f, 
    0.03236047f, 0.05052031f, -0.00769108f, -0.01919354f, 0.02754720f, 0.00450970f, 0.00285738f, -0.03640310f, 
    -0.04294436f, -0.05539636f, -0.02218350f, -0.05098817f, -0.03307389f, -0.04341982f, -0.03162419f, -0.02378687f, 
    -0.05764228f, 0.02878727f, 0.01837795f, -0.02092980f, 0.03622420f, -0.01824784f, -0.03140537f, 0.03277957f, 
    -0.04713432f, 0.00358205f, -0.03294007f, -0.04113967f, 0.05674044f, -0.04327619f, 0.04022742f, 0.02058697f, 
    -0.04651015f, -0.03534259f, 0.05833123f, -0.04434696f, -0.04300176f, -0.01497265f, -0.04665918f, 0.04189838f, 
    0.05198498f, -0.03045311f, 0.00228845f, 0.01039999f, -0.03619850f, -0.00521030f, 0.04715380f, -0.01143937f, 
    0.04512915f, 0.01149930f, -0.02265730f, -0.00286727f, -0.03866928f, 0.01482522f, 0.02633447f, -0.03815598f, 
    0.03957326f, -0.05395132f, -0.00165209f, -0.01613263f, -0.05279477f, 0.02902709f, -0.03616295f, 0.03436556f, 
    0.04428977f, -0.01301479f, 0.00297645f, -0.00393269f, 0.04682403f, -0.02816418f, -0.05411453f, -0.05092067f, 
    0.02791490f, -0.04380604f, -0.02188505f, 0.04666952f, -0.03319286f, -0.03922300f, -0.03801386f, -0.04766388f, 
    0.04493183f, 0.04996324f, -0.01214025f, -0.01966767f, 0.02227003f, -0.04723069f, 0.01484568f, 0.02720167f, 
    0.05366984f, -0.04892605f, -0.00795569f, 0.02452731f, 0.01484944f, -0.05645429f, -0.02985249f, 0.00619968f, 
    0.02743682f, -0.02761509f, -0.06278261f, 0.01288535f, 0.00579817f, 0.04763963f, 0.03304535f, -0.01344279f, 
    -0.03907225f, -0.03333466f, -0.05349893f, -0.06084265f, 0.02181045f, -0.04936599f, -0.04459210f, 0.04320860f, 
    0.04939685f, -0.01813742f, -0.01512681f, -0.00016878f, 0.02862973f, -0.04495190f, -0.06423536f, -0.01898899f, 
    -0.03643965f, -0.02235681f, -0.00571199f, -0.01705111f, -0.00913320f, -0.05331128f, -0.03844750f, 0.04427957f, 
    -0.01553144f, -0.00718723f, 0.03943412f, 0.02158879f, 0.02428844f, 0.02373939f, -0.00425198f, -0.04340055f, 
    -0.01417902f, 0.00601980f, 0.01181714f, 0.00773140f, -0.04130462f, 0.04419160f, 0.04538794f, 0.02629520f, 
    -0.03633809f, -0.02591911f, -0.05414072f, 0.04662084f, -0.04026753f, -0.01229782f, 0.02327081f, 0.02154483f, 
    -0.04595351f, 0.00735334f, 0.02453821f, -0.05999257f, -0.00979873f, -0.05880871f, -0.02060078f, -0.00246346f, 
    0.04264268f, 0.04767126f, -0.04036582f, -0.02379614f, 0.01556450f, 0.02561204f, -0.04048067f, 0.00181512f, 
    -0.06050000f, 0.06061817f, 0.01824518f, 0.02434750f, -0.05671247f, -0.00155070f, -0.00682595f, -0.05372623f, 
    0.01561287f, -0.03557980f, -0.05117832f, 0.00688584f, 0.04723541f, 0.00295271f, -0.04167357f, 0.04036319f, 
    0.03051338f, -0.05359192f, -0.05428682f, -0.05015811f, 0.01306649f, -0.04566334f, -0.02541521f, -0.00881063f, 
    -0.04104636f, 0.05571367f, 0.00954802f, -0.03038425f, -0.03101826f, -0.05915817f, -0.03478656f, -0.01862460f, 
    -0.05472254f, 0.02955338f, -0.05991619f, -0.05112198f, -0.05497357f, -0.03997578f, -0.05128142f, 0.04113737f, 
    0.02081065f, -0.03835287f, 0.03018188f, -0.03989007f, -0.05884628f, -0.01004993f, -0.01189759f, -0.00035916f, 
    0.03440877f, -0.04080709f, -0.03125132f, 0.02331363f, 0.04469608f, -0.04442991f, -0.06156213f, 0.00115167f, 
    0.03162955f, 0.04995793f, -0.00128477f, -0.01203966f, -0.02451346f, 0.03020711f, -0.06203474f, -0.00641091f, 
    -0.00248110f, 0.01949183f, -0.02984292f, -0.04495239f, 0.05025740f, 0.04298263f, -0.02066212f, 0.01554373f, 
    -0.01926094f, -0.03852846f, 0.02121010f, -0.04747857f, -0.00650055f, -0.03226351f, -0.05009554f, -0.02332221f, 
    0.02355139f, -0.02331229f, 0.01537521f, -0.03460765f, 0.01809263f, -0.00921555f, 0.01532881f, 0.03505673f, 
    0.03842367f, -0.01284231f, 0.03917430f, -0.03763020f, 0.06057282f, -0.04414274f, 0.01984370f, -0.00680958f, 
    -0.02115596f, 0.01973410f, -0.02403805f, -0.04753963f, 0.02125163f, 0.02962327f, 0.00478753f, 0.04184318f, 
    -0.01439497f, -0.05201222f, -0.02739490f, -0.02295533f, 0.01370412f, -0.01796395f, 0.02852851f, -0.01385050f, 
    0.03381297f, -0.05575469f, -0.02353945f, 0.01107958f, -0.03002501f, 0.00494345f, -0.02406857f, -0.03034785f, 
    -0.06797473f, -0.01365387f, -0.04134902f, 0.03183068f, -0.00690173f, -0.03588869f, -0.00418620f, 0.05670083f, 
    -0.02936363f, -0.02706645f, -0.02204070f, -0.04412887f, -0.06500375f, 0.02186929f, -0.00319411f, 0.00622916f, 
    -0.00073756f, -0.01800691f, 0.01349565f, -0.05665657f, -0.05003920f, -0.00096695f, -0.06519479f, 0.02122866f, 
    -0.04881530f, 0.02800899f, 0.01629807f, 0.04069889f, -0.00079014f, -0.06331503f, -0.00032808f, 0.00560599f, 
    0.03209806f, -0.05831918f, 0.00085047f, 0.03644151f, 0.04011221f, 0.02852932f, 0.05146900f, 0.02381017f, 
    0.04248070f, -0.05607095f, 0.02659322f, 0.01030306f, 0.00759905f, 0.05128574f, 0.05509193f, -0.01213115f, 
    -0.01327650f, 0.02285737f, -0.01234494f, 0.00529235f, -0.04261477f, -0.03212275f, 0.00074068f, -0.04615264f, 
    0.05414592f, 0.00245401f, -0.00402620f, -0.05989163f, -0.06542840f, -0.05535516f, -0.03343010f, -0.01790371f, 
    0.00730099f, -0.05856496f, -0.02955271f, 0.02508632f, -0.04342702f, -0.01948237f, -0.04196506f, 0.03736094f, 
    0.00303140f, 0.04270027f, 0.01366670f, -0.03062378f, 0.04919276f, -0.06076126f, 0.02908613f, 0.02770787f, 
    0.00554391f, -0.02359255f, 0.02516519f, 0.04321865f, -0.01205404f, 0.04999208f, -0.01264985f, 0.04161704f, 
    -0.04729022f, 0.01299625f, -0.00305010f, -0.05506598f, 0.00216283f, -0.02345878f, -0.01763176f, 0.03764661f, 
    -0.25915688f, -0.21099649f, 0.10796538f, 0.01683029f, 0.10104331f, 0.12751605f, -0.04172779f, 0.12967369f, 
    -0.08762864f, 0.15216552f, 0.09472016f, 0.06774561f, 0.03492237f, 0.06326292f, -0.13658120f, 0.12060257f, 
    0.21438827f, 0.11051661f, 0.35304108f, 0.22211698f, 0.10836194f, -0.14463237f, -0.19347315f, -0.08153220f, 
    0.18213139f, -0.15417983f, 0.02619063f, -0.27849936f, -0.09602097f, -0.19363509f, -0.02294455f, 0.08643436f, 
    -0.01435048f, -0.14101501f, -0.22505000f, -0.02554256f, 0.32352796f, -0.12250136f, 0.14454624f, -0.19553426f, 
    -0.26748997f, 0.03838841f, 0.11183301f, 0.00656359f, -0.08381279f, -0.11133007f, -0.15722074f, 0.30066636f, 
    0.05380725f, -0.02946165f, -0.03730169f, -0.17794320f, 0.06009565f, -0.04651449f, 0.03020594f, 0.25361934f, 
    0.16306356f, 0.06376307f, 0.02634606f, 0.00370852f, 0.12430609f, 0.01266429f, -0.14471391f, -0.03864641f, 
    -0.29830810f, -0.18213978f, 0.02895772f, -0.07314340f, -0.00398088f, -0.10158556f, -0.06039446f, -0.00134968f, 
    -0.09786540f, 0.03654076f, -0.06827595f, 0.17479032f, 0.11395697f, 0.07486509f, -0.11721583f, -0.01685531f, 
    -0.14945318f, 0.08504543f, 0.00212941f, 0.14923261f, 0.09519104f, -0.07784089f, 0.04456127f, 0.04671906f, 
    0.00258780f, 0.02937506f, -0.06095688f, 0.02734994f, -0.10280588f, -0.02872798f, 0.12537605f, 0.11421801f, 
    -0.08881659f, -0.11801787f, 0.00749452f, 0.10636918f, 0.12635711f, 0.21595863f, -0.08557454f, 0.12671191f, 
    -0.03558112f, 0.09198768f, 0.02732376f, -0.17113774f, 0.17417449f, 0.13183171f, 0.16310064f, 0.18405293f, 
    0.05766425f, -0.01052904f, 0.06529025f, -0.11642981f, 0.17588623f, -0.51020360f, -0.02033025f, 0.12261609f, 
    -0.27018252f, 0.10280620f, 0.01778517f, -0.17069654f, -0.10513870f, -0.28385854f, -0.01882760f, -0.10128745f, 
    -0.07840095f, -0.23625781f, 0.21053626f, -0.04746060f, -0.11528060f, 0.15800866f, -0.12429742f, -0.47110707f, 
    -0.11764584f, 0.05218554f, 0.10341836f, 0.06409369f, -0.09379945f, -0.15030168f, 0.09498830f, 0.03608626f, 
    -0.14415000f, 0.18822470f, 0.08732923f, -0.10171413f, -0.03981198f, 0.00744569f, -0.02745432f, 0.16878413f, 
    -0.01933116f, 0.24573347f, 0.01429516f, 0.16758454f, -0.32010052f, -0.15970367f, -0.09233110f, -0.07224223f, 
    0.02832319f, -0.15544200f, 0.31532374f, 0.16871783f, 0.13906690f, -0.00693737f, -0.12348282f, -0.08196986f, 
    -0.00674837f, -0.11173503f, -0.14528830f, 0.04169074f, 0.20924208f, -0.14561780f, 0.16126575f, 0.14281733f, 
    0.11333224f, 0.12580262f, 0.05606645f, -0.05539189f, 0.08178110f, -0.00698226f, -0.18240501f, 0.25671878f, 
    0.07801777f, 0.16905504f, 0.06280251f, -0.05641813f, -0.10389499f, 0.05247548f, 0.16031596f, 0.27980232f, 
    -0.09005277f, 0.08679014f, 0.03379321f, 0.03348106f, -0.02963722f, -0.22626826f, 0.17313120f, -0.02163797f, 
    0.09690325f, 0.03879446f, -0.11483578f, 0.15366724f, 0.14576648f, 0.11521560f, 0.13190393f, 0.34850669f, 
    -0.34285003f, -0.17602569f, -0.11338692f, 0.19852284f, 0.01061170f, 0.15310970f, 0.05623032f, 0.03539704f, 
    0.15468274f, -0.03023830f, -0.01043061f, -0.00943285f, -0.01471069f, -0.11758938f, 0.01404117f, -0.04603192f, 
    -0.13266927f, 0.14286621f, -0.10309188f, -0.22148590f, 0.01336651f, 0.02257870f, 0.02396799f, -0.05842663f, 
    -0.15094440f, 0.00311637f, -0.13798392f, 0.18064961f, 0.16917405f, -0.11753685f, 0.10549350f, -0.11664761f, 
    0.30056021f, 0.29949579f, 0.19961682f, 0.25309852f, 0.08026849f, 0.00851630f, -0.00171880f, -0.06596750f, 
    -0.15319866f, 0.01631214f, -0.10932541f, -0.20614241f, -0.02900499f, 0.23593684f, -0.03430876f, -0.02348334f, 
    0.08792342f, -0.18067299f, -0.09235217f, -0.02337189f, -0.01840604f, 0.18211496f, 0.10107129f, 0.06204361f, 
    0.19799599f, 0.04447479f, 0.10260740f, 0.28506443f, 0.07085867f, 0.08472216f, 0.18555333f, 0.10946524f, 
    -0.02274777f, 0.16617520f, -0.03246798f, 0.04650016f, -0.14506269f, -0.05036009f, -0.10685077f, 0.13593413f, 
    0.13341084f, 0.11538924f, 0.03734135f, 0.00790225f, 0.04541531f, -0.06077237f, -0.00624250f, -0.05334142f, 
    -0.01731934f, 0.06925718f, 0.21693835f, -0.11130270f, 0.05291435f, -0.06314888f, 0.01569437f, 0.03730416f, 
    -0.15355459f, -0.01059009f, 0.06126415f, -0.16392687f, -0.09670864f, 0.04805614f, -0.03661363f, 0.02296792f, 
    -0.00344871f, -0.27396011f, -0.07276820f, 0.02291200f, 0.00342251f, -0.01546287f, -0.09087504f, 0.01203896f, 
    0.06413466f, -0.07287730f, 0.17553230f, -0.27044734f, -0.32816607f, -0.22738802f, 0.14661087f, 0.05838681f, 
    -0.14585589f, 0.12170772f, 0.05857742f, 0.05675465f, 0.01526393f, 0.07103079f, 0.14772879f, -0.19099672f, 
    -0.05427741f, 0.05404885f, -0.04454337f, -0.27594012f, -0.01287239f, -0.35084519f, -0.07803806f, 0.01405851f, 
    0.12040176f, -0.04026759f, -0.08983269f, -0.02321371f, 0.10852420f, -0.19414477f, 0.16833663f, -0.14354353f, 
    -0.15192731f, 0.04632990f, 0.06650197f, -0.00401386f, 0.13062368f, 0.12095410f, 0.15597476f, -0.30069309f, 
    -0.36409760f, -0.27126753f, 0.04395321f, -0.10587949f, 0.01470196f, -0.25149783f, -0.15591849f, -0.04681939f, 
    0.09790158f, 0.03624486f, -0.13485108f, 0.05706597f, -0.03394665f, -0.06195285f, -0.04086650f, 0.04895681f, 
    -0.06485044f, 0.22113237f, 0.05282189f, 0.10952971f, 0.04233817f, 0.00844574f, 0.02495053f, -0.07299829f, 
    -0.10020260f, 0.13990118f, -0.14022119f, -0.05161747f, 0.20026866f, -0.03509275f, 0.04524775f, -0.11179831f, 
    -0.21184747f, -0.11320738f, 0.07753602f, 0.31603408f, 0.20737572f, -0.12565175f, 0.02854764f, 0.23284645f, 
    0.23781504f, 0.12157503f, -0.01146260f, 0.08467105f, -0.03874358f, 0.04064396f, -0.00667495f, -0.05841909f, 
    -0.04617684f, -0.07090911f, -0.06979325f, -0.00473916f, 0.08434617f, -0.16822532f, -0.16839904f, -0.22256556f, 
    -0.10150378f, -0.05178125f, -0.15284967f, -0.03634852f, 0.14197840f, -0.10728041f, 0.05245688f, -0.11602268f, 
    -0.05109594f, 0.20134763f, -0.07669622f, 0.17868021f, 0.12970978f, -0.03938738f, 0.11873002f, -0.13847536f, 
    0.03228433f, 0.01503124f, 0.06591265f, 0.21233617f, -0.03265231f, 0.01253209f, 0.25177991f, 0.16555318f, 
    -0.14914759f, 0.11755315f, -0.02362218f, -0.08569958f, -0.08381420f, -0.14123441f, -0.24220397f, -0.11772576f, 
    0.03093564f, 0.27953064f, 0.25818944f, 0.02218117f, 0.09644651f, 0.05581298f, 0.13482539f, 0.04837365f, 
    0.00995401f, -0.09899185f, -0.00526637f, -0.06221806f, 0.04407842f, 0.13654652f, -0.01215317f, -0.13763370f, 
    0.09477109f, -0.04793928f, 0.00172138f, -0.09681003f, 0.12195601f, 0.17645323f, 0.08385597f, -0.05203583f, 
    -0.09040379f, 0.17641494f, -0.04354187f, 0.10552728f, 0.29349229f, 0.06369683f, -0.33046162f, 0.00007378f, 
    -0.00904617f, 0.03112594f, -0.01513964f, 0.17062117f, -0.08583521f, -0.13351086f, 0.15804279f, 0.44423655f, 
    0.03953655f, 0.00553576f, -0.10101091f, -0.12695107f, 0.07133721f, 0.02338070f, 0.37065822f, -0.11214071f, 
    0.06764632f, 0.05338427f, -0.00254089f, 0.23204762f, -0.03057205f, -0.01337563f, 0.07939592f, -0.35401613f, 
    0.12737414f, 0.19710796f, -0.00451271f, 0.10433915f, -0.01205330f, 0.06162088f, -0.15348203f, 0.21492366f, 
    0.24601439f, 0.15104422f, 0.02026241f, 0.11380782f, 0.06306829f, 0.10350475f, 0.11736629f, 0.16901897f, 
    -0.07676905f, -0.33761469f, 0.08606943f, -0.00688243f, -0.11696003f, -0.01415147f, -0.02993149f, 0.02550215f, 
    0.08481336f, -0.01706300f, 0.01900719f, 0.08959292f, -0.04743477f, -0.14487502f, -0.30214021f, 0.08897147f, 
    -0.05007069f, -0.12442218f, -0.02064649f, -0.27780086f, -0.13894285f, -0.12254796f, 0.08855931f, 0.04288352f, 
    -0.12708773f, -0.01124278f, -0.26073006f, -0.06915423f, -0.25264984f, -0.06856856f, -0.13954143f, 0.05601321f, 
    0.04102505f, -0.18942328f, -0.09558906f, 0.06232528f, -0.07255138f, 0.06758168f, -0.00926036f, -0.02097527f, 
    -0.06327058f, 0.10722487f, -0.01094078f, 0.03081111f, -0.09117875f, -0.01236519f, 0.08370672f, 0.09683656f, 
    -0.03098381f, -0.06378425f, 0.01958958f, -0.08334012f, -0.06342167f, -0.00729900f, -0.14225635f, -0.05078594f, 
    -0.25463927f, 0.24697191f, -0.14615960f, 0.01154225f, -0.01728445f, 0.18577099f, 0.09272309f, -0.10747412f, 
    0.02947901f, 0.00810367f, -0.05759416f, 0.00050371f, -0.02468557f, -0.05824478f, -0.03553057f, 0.04670923f, 
    0.00774726f, -0.02217482f, -0.03412345f, -0.01691638f, 0.04711378f, -0.03152992f, 0.03018734f, -0.03425609f, 
    -0.05773870f, 0.00908203f, 0.04839702f, -0.05819063f, -0.03451443f, 0.04653224f, -0.03536392f, 0.01489888f, 
    -0.01760995f, 0.02810963f, -0.06367856f, 0.03924030f, 0.01523795f, -0.04316745f, 0.02523495f, 0.04432054f, 
    -0.00739578f, 0.00493171f, -0.00909931f, -0.03594204f, 0.00035312f, -0.03544880f, -0.03296297f, 0.00073092f, 
    -0.04822061f, -0.06249967f, -0.00916824f, -0.02904656f, -0.05522514f, -0.05841620f, 0.03339317f, 0.04870386f, 
    -0.02509693f, -0.04222913f, -0.01992912f, 0.00652588f, 0.03242851f, -0.00146987f, -0.04089981f, -0.03371072f, 
    0.02481413f, -0.01500332f, 0.00534448f, -0.01389900f, 0.00330133f, -0.02647009f, -0.01425116f, -0.01662312f, 
    -0.00744279f, -0.04069357f, -0.06052334f, -0.06368005f, 0.02133373f, 0.00275526f, -0.04596958f, 0.00181643f, 
    0.04375306f, -0.00065384f, 0.01030969f, -0.04044024f, -0.05853973f, 0.04255432f, -0.04665115f, -0.06623881f, 
    -0.05099707f, -0.03262009f, 0.02727404f, 0.00617979f, 0.02308036f, -0.01370514f, -0.04077870f, -0.02584475f, 
    -0.05246949f, 0.02744473f, -0.01291606f, -0.00144509f, -0.00568093f, 0.02921337f, -0.05468624f, -0.01357946f, 
    0.04706138f, -0.05986760f, 0.04319049f, -0.05952061f, -0.03823913f, 0.03008581f, 0.03471278f, -0.02171160f, 
    -0.04539933f, -0.00794797f, 0.00952050f, -0.06274945f, 0.02102875f, -0.01553354f, -0.05466980f, -0.04013143f, 
    0.02890931f, -0.04585913f, -0.05362279f, 0.05134561f, 0.04864506f, 0.01738482f, -0.03643855f, 0.03917247f, 
    -0.05919036f, -0.04126249f, 0.03615627f, -0.01453904f, 0.02178420f, 0.04342079f, -0.00383017f, -0.05971705f, 
    0.02739793f, 0.01098594f, 0.03234930f, 0.00935603f, 0.04209444f, -0.04204157f, 0.01028915f, 0.01063726f, 
    -0.02134330f, -0.02401470f, 0.03529145f, -0.03565208f, 0.00018188f, -0.03069944f, 0.03376175f, 0.01389397f, 
    -0.01968413f, 0.03214119f, -0.02307218f, -0.06667795f, 0.02544152f, 0.02788619f, -0.06120017f, 0.03961446f, 
    0.02239755f, -0.06003031f, 0.01655271f, 0.01419333f, -0.01294051f, -0.05169468f, 0.01320736f, 0.04380035f, 
    -0.01360736f, -0.05057721f, -0.05244485f, -0.00394886f, 0.04052004f, -0.03134942f, 0.03870669f, -0.02974621f, 
    -0.05776278f, 0.02216898f, 0.04770892f, -0.06596161f, 0.01435277f, 0.01929034f, 0.01325773f, 0.03731486f, 
    0.04062856f, 0.02928468f, -0.02102589f, 0.01522384f, 0.00366168f, -0.05175806f, -0.05534492f, -0.04319971f, 
    -0.04579729f, -0.03785509f, -0.01032684f, 0.01163430f, -0.04426286f, 0.00139147f, -0.06215773f, 0.00599442f, 
    -0.00495838f, -0.02815134f, 0.04133681f, 0.00108723f, -0.04150038f, -0.00397388f, 0.04339766f, 0.04074957f, 
    0.03016821f, -0.05130925f, -0.05544552f, -0.04979327f, 0.00025224f, 0.01837342f, -0.00245241f, -0.00163011f, 
    0.03227213f, 0.01504364f, 0.00542125f, -0.02762437f, -0.04238911f, -0.05434803f, 0.01967351f, -0.00302527f, 
    -0.04263317f, -0.00034559f, -0.01233572f, 0.03996355f, -0.06420702f, 0.01973064f, -0.02149571f, -0.03557391f, 
    -0.01869261f, -0.05082344f, 0.04248796f, -0.00674565f, -0.01670857f, -0.01400868f, 0.03795009f, 0.02076516f, 
    -0.04161970f, -0.00253229f, 0.00961912f, -0.05245982f, 0.04476286f, -0.05448622f, -0.05296023f, 0.05052603f, 
    -0.06419204f, 0.04268147f, -0.01082555f, -0.05731885f, 0.02347842f, 0.01166860f, -0.01997246f, 0.03690459f, 
    -0.00151810f, -0.05215155f, -0.04301775f, 0.02715705f, -0.05151654f, 0.02281620f, -0.01320902f, -0.00639689f, 
    0.02354003f, -0.06102950f, -0.04870239f, 0.03604161f, -0.04289124f, -0.04480686f, -0.04330730f, -0.03561423f, 
    0.03291673f, -0.01904875f, -0.06094649f, 0.04041964f, -0.05865365f, -0.05290040f, -0.02283835f, -0.04164549f, 
    -0.02203861f, -0.04409254f, -0.03743040f, 0.03551931f, -0.04856639f, -0.04592050f, -0.01792790f, 0.04652506f, 
    0.00148518f, -0.01633628f, -0.06515121f, -0.01705869f, -0.02763114f, -0.03647785f, -0.04654716f, -0.02167253f, 
    0.02000019f, -0.05606395f, 0.02768810f, -0.02255066f, -0.05606803f, 0.01079810f, 0.00912903f, -0.02872679f, 
    0.00544929f, 0.03772401f, 0.03988351f, 0.01679796f, -0.03111644f, -0.02448678f, -0.02677175f, 0.04002545f, 
    0.03913725f, -0.00202351f, -0.04588597f, -0.03992865f, -0.04322533f, 0.03351594f, 0.02296886f, -0.01808954f, 
    0.01217525f, -0.01406466f, -0.01169650f, 0.01237580f, -0.03214977f, -0.04431159f, -0.00305866f, 0.04606802f, 
    -0.05634351f, -0.05126517f, -0.04348931f, 0.03993609f, -0.00393195f, 0.03136784f, 0.03618811f, 0.02947775f, 
    -0.04117944f, 0.02009633f, 0.02535053f, 0.03709466f, 0.05068962f, -0.06977645f, 0.01421096f, 0.00677019f, 
    -0.03625480f, 0.01118938f, -0.04798420f, 0.00637190f, -0.01146384f, -0.03476300f, -0.05601118f, 0.01486966f, 
    0.04253399f, -0.04076997f, 0.00571465f, 0.02552761f, -0.05195113f, -0.00193071f, 0.03113867f, -0.05270438f, 
    0.04098110f, -0.05878577f, -0.03694827f, 0.00965136f, 0.01002771f, 0.01730687f, 0.00881959f, 0.01473075f, 
    -0.05474585f, -0.00476474f, 0.02557208f, 0.00080593f, -0.04722707f, 0.02422137f, 0.01003623f, -0.01667263f, 
    -0.04638581f, 0.02159808f, -0.04749463f, 0.02198486f, 0.02160273f, -0.02625512f, -0.01460791f, -0.00991485f, 
    -0.02310070f, 0.02766790f, -0.05370481f, -0.01908410f, -0.01050542f, -0.06316730f, -0.01779577f, 0.02150945f, 
    -0.03368333f, -0.05568629f, -0.01448942f, -0.06414597f, -0.00162959f, -0.03885284f, -0.01514552f, 0.04226686f, 
    -0.00480221f, 0.05128315f, -0.04550846f, 0.00664677f, 0.01114279f, -0.05518249f, -0.00568953f, 0.00361862f, 
    0.01827075f, 0.01576728f, -0.02801329f, -0.05385152f, 0.02471989f, 0.00827202f, -0.04755718f, 0.03414931f, 
    -0.03152157f, 0.00121777f, -0.03902693f, -0.04798469f, -0.03345799f, -0.03472425f, 0.03259205f, -0.02570639f, 
    0.00421720f, -0.06541228f, 0.02171982f, 0.00769638f, -0.06987730f, 0.00007464f, -0.01997801f, 0.03403424f, 
    -0.02500442f, -0.04960054f, -0.00846895f, 0.02197241f, 0.04765940f, -0.00016146f, -0.04562653f, 0.03299024f, 
    0.02768046f, 0.01243843f, -0.04156815f, 0.02134644f, 0.01979374f, 0.00888102f, -0.04997253f, -0.04437125f, 
    0.03659894f, -0.01537696f, -0.06199997f, -0.00043476f, -0.03388533f, 0.04499974f, -0.04049953f, 0.02322104f, 
    0.01666488f, -0.01474752f, 0.04391572f, -0.00838337f, -0.01489352f, 0.02619157f, -0.05565465f, 0.01313710f, 
    -0.01857331f, -0.02006797f, -0.03434593f, -0.02323798f, 0.02556994f, 0.01853196f, -0.04022383f, 0.04576208f, 
    -0.04191709f, 0.01875058f, 0.04806136f, -0.03030778f, -0.04300210f, -0.03994597f, -0.04029755f, -0.04223398f, 
    0.02163094f, -0.06511435f, 0.02068770f, 0.03477905f, -0.01031680f, 0.01947262f, 0.03647251f, 0.04348672f, 
    -0.06969123f, -0.06186527f, 0.04180872f, -0.02484486f, 0.03049352f, -0.03336887f, -0.00100374f, 0.02819049f, 
    -0.04687826f, -0.01603700f, -0.01969820f, -0.05473678f, -0.04385722f, -0.02393688f, -0.00679836f, -0.02495817f, 
    0.03908837f, -0.03008941f, 0.04589627f, 0.00436667f, -0.00451297f, 0.00742597f, 0.04218469f, 0.02464405f, 
    -0.01904720f, 0.01520497f, -0.01774176f, -0.00391443f, 0.00218907f, 0.03414737f, -0.00946910f, 0.03969578f, 
    -0.00561015f, 0.00028966f, -0.07279614f, 0.04241116f, -0.02620967f, -0.00880310f, -0.05270319f, 0.04999972f, 
    0.05376115f, -0.03141570f, -0.00623366f, -0.01811822f, -0.00996584f, -0.00351898f, 0.01884285f, -0.02313717f, 
    0.02798080f, 0.01406453f, 0.02444510f, -0.00889184f, 0.03485275f, 0.05023417f, -0.01793854f, -0.05419714f, 
    -0.01987656f, -0.01227799f, 0.05288999f, -0.02436874f, -0.02078017f, -0.06606881f, 0.00663788f, 0.00815271f, 
    -0.04703807f, -0.03576204f, -0.02750944f, 0.01857367f, -0.04588958f, -0.00339585f, 0.01901316f, 0.01302714f, 
    0.03919962f, 0.04682799f, -0.00059232f, -0.00493560f, -0.00313539f, -0.05793399f, -0.05244990f, 0.01690678f, 
    -0.05676898f, -0.02693868f, -0.01902567f, -0.02927629f, -0.06260386f, -0.05319054f, -0.01084367f, 0.04230755f, 
    0.01641707f, 0.05314559f, 0.00897618f, -0.03172280f, -0.05148926f, 0.00088265f, 0.05331288f, 0.03128928f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.02427301f, -0.04294774f, -0.00204872f, -0.02593191f, 0.01389034f, -0.00851240f, -0.09145067f, 0.25247651f, 
    0.08621931f, 0.06342643f, 0.06249649f, 0.10561506f, 0.11756074f, 0.27210379f, -0.03705268f, 0.11779101f, 
    -0.00810999f, 0.22050305f, 0.28530422f, 0.12651810f, 0.03537868f, -0.07802043f, 0.07417037f, 0.22153103f, 
    -0.14464159f, 0.28773943f, -0.01546085f, 0.00148046f, -0.01089460f, 0.27315482f, -0.02136833f, 0.01348610f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.05844496f, 0.08508756f, -0.19651347f, 0.00019388f, -0.01472902f, 0.09161958f, -0.19446632f, -0.13132979f, 
    -0.12415266f, -0.09121715f, -0.17704821f, -0.12416841f, 0.04538544f, 0.08621202f, 0.12020410f, -0.09588582f, 
    -0.05345974f, 0.10502009f, -0.03403671f, 0.10268333f, -0.14549936f, -0.08613041f, -0.04618180f, -0.04614897f, 
    -0.05497267f, -0.07747431f, -0.13798043f, -0.09232485f, 0.06809708f, -0.19398050f, 0.13230866f, -0.05989584f, 
    -0.09166294f, -0.34594262f, -0.02513167f, -0.06212206f, -0.06945757f, -0.54406774f, 0.22421664f, -0.05372621f, 
    0.28332886f, 0.08689737f, 0.09298058f, 0.11702814f, -0.34553954f, 0.35411119f, -0.13560854f, -0.05441827f, 
    0.39450893f, -0.63246393f, -0.03722387f, -0.11083669f, -0.17087068f, 0.03068105f, 0.27944821f, 0.23821062f, 
    0.04119420f, 0.33697614f, 0.02049867f, -0.10767802f, -0.22032669f, -0.16578163f, 0.14546248f, -0.06167528f, 
    0.07809095f, -0.21927474f, -0.43338913f, -0.61149371f, 0.08790410f, -0.29957137f, 0.09385688f, -0.57769787f, 
    0.21265785f, 0.18284580f, 0.07713524f, 0.41302612f, -0.19730070f, -0.27337068f, -0.06219767f, 0.14428814f, 
    -0.32569516f, 0.74228060f, 0.35502094f, -0.44752479f, 0.18205242f, 0.18739109f, 0.16849263f, 0.28750825f, 
    -0.08287549f, 0.40127078f, -0.07058764f, -0.01930101f, -0.01793715f, 0.30122539f, -0.14260484f, -0.13532163f, 
    0.01880321f, 0.37787727f, 0.10505230f, -0.04736611f, -0.09035410f, 0.04495287f, 0.25788194f, 0.08672652f, 
    -0.12291036f, -0.14959981f, 0.19185480f, -0.16870783f, -0.22181706f, 0.37805018f, -0.13242267f, -0.38580745f, 
    0.12734407f, 0.17926709f, 0.08739155f, 0.34202257f, -0.03480244f, -0.11892027f, 0.31900620f, 0.08180185f, 
    -0.27843872f, -0.50889593f, 0.15096559f, -0.01490588f, 0.37839150f, -0.03887511f, 0.15053567f, -0.17466170f, 
    -0.10014512f, -0.29296237f, -0.52504039f, 0.18937615f, -0.00910832f, -0.63792264f, 0.11045596f, 0.21859179f, 
    0.30841631f, -0.05250761f, 0.10730240f, 0.29514325f, -0.22907844f, 0.08130229f, -0.18016790f, 0.42408621f, 
    0.04962429f, -0.14144817f, 0.16157699f, -0.33332920f, -0.08548646f, -0.10648390f, -0.06105075f, 0.35374340f, 
    -0.16668610f, 0.28349137f, -0.00183305f, -0.00943551f, -0.01596001f, 0.16191611f, -0.05915871f, 0.16510686f, 
    0.04362846f, 0.31771344f, -0.20064713f, -0.49249837f, -0.00824253f, 0.34355640f, -0.00803001f, -0.19814694f, 
    -0.14382325f, 0.01347544f, 0.25467858f, 0.31656861f, -0.16973574f, -0.23886029f, 0.08718206f, 0.14842635f, 
    -0.16019401f, 0.22149731f, 0.17005071f, 0.03562203f, 0.10884074f, -0.16085695f, -0.03966724f, 0.12312808f, 
    0.04097577f, 0.06016917f, 0.06598894f, 0.12997901f, 0.14995188f, 0.09763185f, -0.12771797f, 0.10183886f, 
    -0.06309478f, -0.48374623f, -0.02575200f, -0.09294017f, -0.14393020f, -0.26693431f, -0.01650179f, 0.28913379f, 
    0.41473106f, 0.19757248f, -0.07761855f, -0.36169735f, -0.16486211f, 0.34007880f, -0.12730059f, -0.51904827f, 
    0.17451681f, -0.10194307f, 0.32483783f, -0.36370310f, 0.51100278f, 0.17068291f, 0.16267489f, -0.68329358f, 
    0.14971089f, 0.24178116f, -0.12485306f, 0.07824972f, -0.13833529f, -0.20560604f, -0.03938277f, 0.06791213f, 
    0.07752977f, -0.54794711f, 0.02160506f, 0.21194676f, -0.03711631f, -0.12908205f, -0.11323819f, 0.33656517f, 
    -0.18755367f, 0.16613677f, 0.01151899f, 0.07070013f, 0.05601459f, 0.05744578f, 0.04814997f, 0.03022825f, 
    -0.08371019f, 0.42780453f, -0.29589504f, 0.13907549f, -0.40104699f, 0.04160232f, 0.01860436f, -0.20788683f, 
    0.13682263f, -0.39734489f, 0.01510927f, 0.17216417f, 0.03391686f, -0.10055400f, -0.11627073f, 0.13705815f, 
    0.12059463f, 0.03424106f, 0.08751161f, -0.00808749f, -0.03112340f, 0.35112408f, 0.17933951f, 0.11027219f, 
    -0.12753458f, -0.37160444f, -0.24644461f, -0.23494478f, -0.22817615f, -0.04018593f, 0.16634572f, -0.34911412f, 
    -0.03944769f, 0.00297497f, -0.22327074f, -0.07093790f, 0.00519008f, 0.21285258f, -0.09324694f, 0.47793731f, 
    0.52224201f, -0.47557065f, -0.03531731f, 0.09690716f, 0.21251982f, -0.17004710f, 0.00385757f, -0.07368829f, 
    0.15918186f, 0.08294645f, 0.22977675f, 0.05506557f, 0.07916793f, -0.15766415f, 0.20911354f, -0.01471205f, 
    0.04294205f, 0.01740559f, 0.01227552f, -0.15767437f, -0.20310454f, 0.08213793f, -0.14947537f, -0.18046486f, 
    0.45303133f, -0.13552658f, -0.09142812f, -0.04183904f, 0.72880906f, 0.41634807f, -0.08398984f, -0.57096934f, 
    0.25105119f, -0.31158412f, 0.04786171f, -0.04897519f, -0.00983601f, -0.19192997f, 0.09029788f, -0.07609814f, 
    0.07558873f, -0.00342047f, -0.05631440f, -0.02803624f, -0.08069145f, -0.00566187f, -0.16471070f, 0.09541485f, 
    0.01772613f, -0.15590118f, 0.07365721f, -0.14265440f, -0.19580233f, -0.12381650f, 0.13947672f, -0.22589965f, 
    0.08221760f, 0.01530731f, -0.06445174f, -0.14116868f, -0.12822106f, -0.02422894f, 0.03684114f, -0.04257518f, 
    -0.09723125f, -0.05493256f, 0.10016984f, -0.05241199f, 0.07663862f, 0.03673125f, -0.05785637f, -0.12625368f, 
    -0.14954749f, 0.54824740f, 0.14508030f, 0.19501856f, -0.17665689f, 0.29009211f, 0.27657887f, 0.12667434f, 
    -0.19360757f, -0.21101625f, -0.05214324f, -0.05447654f, -0.15701690f, -0.22040060f, 0.00925018f, -0.31020537f, 
    0.16708542f, -0.25979891f, -0.20919099f, 0.18954030f, 0.54825407f, 0.29417378f, 0.13834530f, -0.10226312f, 
    0.19581409f, -0.04179067f, -0.10691737f, 0.11124827f, 0.39082825f, 0.17692077f, 0.16693121f, -0.16381887f, 
    0.05266259f, -0.05699599f, -0.09934881f, 0.12654002f, 0.04041994f, -0.34718466f, 0.07265759f, 0.61981350f, 
    0.20837848f, -0.15859331f, 0.35600871f, 0.06040513f, -0.17665237f, -0.05029054f, -0.16476817f, -0.07116408f, 
    0.28631532f, -0.11279913f, -0.34517270f, 0.09809830f, 0.00266373f, 0.02530999f, -0.07805690f, -0.11486838f, 
    -0.07713999f, 0.10184096f, -0.12630999f, -0.06100408f, -0.08744290f, -0.00065279f, 0.14210044f, 0.07504198f, 
    0.03195142f, 0.09275311f, 0.14510870f, -0.06814753f, 0.08475607f, -0.43416589f, 0.18693078f, -0.01076936f, 
    0.26577476f, -0.07372290f, 0.66899943f, 0.22778916f, -0.39812845f, -0.00279973f, -0.17564960f, 0.12105200f, 
    -0.03425039f, 0.07042811f, -0.29924092f, 0.13152590f, -0.10219500f, 0.14014898f, -0.17469013f, 0.09780270f, 
    -0.18993513f, -0.22232187f, -0.12890251f, 0.11369953f, 0.14737678f, -0.33033165f, 0.10731209f, -0.10507502f, 
    0.00548805f, 0.20845382f, -0.08272783f, -0.32875389f, 0.08210654f, 0.28191456f, -0.23861824f, 0.32992107f, 
    0.15701239f, 0.13944767f, 0.20578508f, 0.31706935f, 0.09399207f, -0.24249154f, -0.04675708f, 0.28339076f, 
    -0.29604495f, 0.32516718f, 0.22776049f, 0.05142711f, 0.43751109f, -0.12243515f, -0.04149194f, -0.10015895f, 
    -0.03319469f, 0.16614752f, -0.01960598f, -0.00145975f, 0.06559283f, 0.28067452f, -0.06737509f, -0.10195936f, 
    0.09235460f, 0.20095372f, 0.31058636f, 0.20165682f, 0.07277649f, 0.61698776f, -0.44544089f, 0.61929041f, 
    -0.08840419f, 0.13401651f, 0.12207087f, -0.08127757f, 0.33445162f, 0.16862538f, 0.03371364f, -0.19153942f, 
    -0.23950355f, 0.24890788f, 0.24915829f, -0.18355727f, -0.10637382f, 0.28006947f, -0.05652849f, -0.11797000f, 
    -0.21572569f, 0.16497013f, 0.09162004f, 0.02401134f, -0.16935460f, 0.04844814f, 0.07802943f, 0.15659119f, 
    0.13883947f, 0.18719009f, -0.16497271f, -0.33790240f, -0.17545851f, 0.49627805f, -0.11067870f, 0.21431202f, 
    0.08767296f, 0.19630843f, -0.41220945f, -0.02926837f, 0.17879349f, 0.38627180f, -0.03630108f, -0.14539984f, 
    0.20040192f, -0.28056645f, 0.17863460f, 0.22223952f, 0.20480582f, -0.07440331f, 0.13501817f, 0.08300476f, 
    -0.24882184f, 0.44905391f, -0.02036913f, -0.05750950f, -0.18374287f, 0.33773243f, 0.06255273f, -0.00842060f, 
    0.00234290f, -0.13714588f, 0.53756642f, -0.44276819f, -0.10840652f, -0.25503182f, -0.11472391f, -0.55682892f, 
    0.19207644f, 0.17905165f, 0.20414369f, 0.02194576f, -0.13150328f, -0.07259288f, 0.07687064f, -0.91566890f, 
    0.04278046f, 0.38955417f, 0.49144039f, -0.32062471f, -0.43887630f, 0.15519670f, -0.05224503f, 0.02360261f, 
    -0.10011862f, 0.79664868f, -0.00650775f, 0.05937913f, -0.18965700f, 0.13024661f, -0.08243474f, -0.02074571f, 
    0.10328998f, -0.07892626f, 0.07573426f, -0.01717342f, 0.06694929f, 0.28729403f, 0.13726446f, -0.31728756f, 
    0.19592063f, -0.02333936f, -0.14655070f, -0.26345602f, 0.24144502f, 0.51895028f, -0.13349736f, -0.32797366f, 
    0.33543545f, 0.52090210f, 0.37457928f, 0.14197133f, -0.47360349f, 0.37172514f, -0.11233111f, -0.06009602f, 
    0.23462419f, -0.39041337f, 0.02480667f, -0.04080398f, 0.07563735f, -0.17741880f, 0.16334629f, 0.04939169f, 
    0.04138024f, -0.05433206f, -0.18975745f, 0.18096545f, 0.07248286f, -0.07992420f, 0.02948033f, -0.09820414f, 
    0.01430678f, 0.10504647f, -0.01768007f, 0.11517609f, -0.08399689f, -0.05131629f, -0.01227363f, -0.07128700f, 
    -0.18308195f, 0.25158954f, -0.06978387f, -0.13856834f, -0.08188288f, -0.10182875f, -0.13341783f, 0.05580226f, 
    0.00407940f, -0.05155982f, -0.15402628f, 0.02252861f, 0.06699485f, -0.13377100f, 0.03898390f, 0.08652663f, 
    0.01110560f, -0.07241870f, -0.00341648f, -0.20568626f, -0.07952175f, 0.19206211f, 0.14269486f, 0.29049852f, 
    -0.12977377f, -0.01411852f, 0.37628293f, -0.21119425f, 0.08660755f, 0.28050002f, -0.08153863f, 0.43052191f, 
    0.30254000f, 0.14651865f, -0.01415316f, 0.36738783f, -0.54894572f, -0.08843663f, 0.20684962f, 0.15536371f, 
    -0.06779401f, -0.38759071f, 0.15949315f, -0.04983358f, 0.14599855f, -0.10333098f, 0.07483760f, -0.13809206f, 
    -0.10795137f, -0.02596194f, 0.45249680f, 0.28920135f, -0.02516486f, -0.40236047f, -0.06679562f, 0.09909141f, 
    0.06891783f, 0.12186313f, 0.36533874f, 0.09397222f, 0.09874011f, -0.12512676f, 0.07510246f, -0.42045009f, 
    0.08984389f, 0.12208699f, -0.01951978f, -0.19436984f, -0.19680463f, 0.18299335f, -0.17172325f, 0.07215300f, 
    0.21518174f, 0.08849140f, -0.12877770f, -0.15076186f, 0.05933630f, -0.24522156f, 0.02961711f, 0.06988546f, 
    -0.11161471f, -0.43221694f, -0.07856925f, 0.35405707f, -0.02252044f, -0.07518594f, 0.02240043f, 0.02100688f, 
    -0.22009490f, -0.18988331f, 0.01058260f, 0.22204970f, 0.11503997f, -0.16105922f, -0.06685919f, 0.27482089f, 
    0.18465491f, -0.14710940f, 0.16630103f, -0.16829607f, -0.13069589f, 0.28130305f, -0.03977657f, 0.40051413f, 
    0.04454323f, 0.42188171f, -0.06480084f, -0.09958027f, 0.07485970f, 0.09591186f, 0.00804099f, 0.05383375f, 
    -0.11832645f, 0.56532979f, 0.29852819f, -0.05642532f, 0.11680549f, 0.39111820f, -0.09008208f, -0.34572691f, 
    -0.02765138f, -0.10820682f, -0.02015344f, 0.05667185f, -0.03065537f, 0.37287822f, 0.04068496f, -0.33472621f, 
    0.18910760f, -0.27041647f, -0.31209236f, 0.48115808f, 0.43879718f, 0.18234508f, -0.05592716f, -0.06329281f, 
    0.13505743f, 0.06657225f, 0.02199227f, -0.11592713f, -0.26984763f, 0.19634987f, 0.02853843f, 0.05230451f, 
    0.11010078f, -0.08029592f, -0.18131065f, 0.00491457f, 0.09639016f, 0.10225484f, -0.18928035f, 0.08464298f, 
    0.10142495f, -0.14738879f, 0.10066421f, -0.14558363f, -0.11297657f, -0.09908909f, -0.03575286f, 0.14105383f, 
    -0.13973467f, 0.02288569f, -0.18864922f, -0.04573439f, -0.12683861f, -0.01184216f, -0.01907714f, 0.09368744f, 
    0.05929250f, 0.05427818f, 0.09474909f, -0.15453194f, -0.05133918f, 0.00535825f, -0.12843908f, -0.09824013f, 
    -0.01862824f, -0.28990674f, 0.31674710f, -0.08920908f, -0.11097311f, -0.46611413f, -0.05328985f, -0.49632818f, 
    0.38818607f, 0.26773292f, -0.15868425f, 0.47015446f, -0.03220426f, -0.00795717f, 0.14157598f, -0.02165937f, 
    -0.01097358f, -0.06542364f, -0.03941034f, 0.27193114f, 0.23387878f, 0.03826397f, 0.03599591f, 0.03810130f, 
    0.16568056f, 0.30241325f, -0.14042714f, -0.09783830f, -0.27546349f, 0.13904513f, -0.15837422f, 0.12182152f, 
    -0.00621545f, 0.49543568f, 0.27884403f, -0.02624319f, 0.01757798f, 0.62040240f, -0.00576776f, -0.87024838f, 
    0.02806598f, 0.14295289f, 0.39411733f, 0.01380899f, 0.23312671f, 0.03438533f, 0.11335181f, -0.36887312f, 
    -0.45287833f, 0.53208500f, -0.11639881f, 0.04789462f, 0.00646091f, 0.24420302f, -0.28029400f, -0.25387049f, 
    0.24573486f, -0.47171602f, 0.03042107f, 0.06517825f, -0.07012777f, -0.20447229f, 0.11529782f, 0.12415080f, 
    -0.14998074f, 0.31281662f, -0.16334613f, -0.06645910f, 0.00600772f, 0.04959564f, 0.14833575f, 0.18785580f, 
    -0.25649276f, -0.10444590f, 0.38185769f, -0.07116220f, -0.14472595f, -0.16479291f, -0.12542546f, -0.35825324f, 
    -0.02484332f, 0.66429281f, 0.18730564f, 0.09787535f, 0.06047765f, 0.08801676f, 0.04031025f, -0.11591610f, 
    -0.04129564f, -0.00343098f, -0.00372816f, -0.07408851f, 0.34160379f, -0.03588034f, -0.03907864f, -0.04905979f, 
    -0.07007494f, -0.15157887f, -0.12849519f, -0.01314857f, 0.15812238f, -0.31758863f, -0.14996068f, -0.14585350f, 
    -0.08490216f, -0.21688791f, -0.38380438f, 0.44478324f, -0.07948253f, 0.02574126f, -0.04158011f, 0.21646799f, 
    -0.00992166f, -0.35364163f, -0.04681367f, 0.26593161f, 0.33327815f, 0.31304953f, 0.18327045f, 0.36044064f, 
    -0.00104118f, -0.00717241f, -0.06906014f, -0.14144324f, 0.18533622f, 0.17678775f, -0.08274917f, -0.09807146f, 
    -0.09573834f, -0.01715288f, 0.05704808f, 0.12873687f, -0.01894533f, -0.08644845f, 0.06134203f, -0.07892357f, 
    -0.18411332f, -0.18204576f, 0.10411444f, -0.14107257f, 0.10814362f, -0.16241445f, 0.09517235f, -0.08414578f, 
    -0.11765406f, 0.06059300f, -0.09761830f, -0.21670750f, -0.06224419f, -0.05705982f, 0.05036930f, -0.14346690f, 
    -0.02566237f, -0.04475813f, 0.15650317f, 0.11875344f, -0.17226183f, -0.03909883f, 0.13165583f, -0.03516309f, 
    0.08981574f, 0.29374242f, 0.25874227f, -0.23538047f, -0.11340690f, -0.30009356f, 0.30543038f, -0.33272293f, 
    0.07839392f, -0.26144868f, 0.44123375f, -0.16297755f, -0.32368365f, 0.33412540f, 0.15671772f, -0.15958726f, 
    0.56013530f, -0.43342313f, -0.19561040f, 0.39026624f, -0.46862057f, 0.19351093f, 0.08596759f, 0.37666035f, 
    -0.32307079f, 0.36285219f, -0.05820945f, 0.00652530f, 0.22535281f, 0.11633479f, -0.10069509f, 0.01865933f, 
    0.16825674f, 0.03437146f, 0.18674132f, 0.29140162f, 0.09613463f, 0.50882661f, -0.28777882f, 0.68107468f, 
    0.18347870f, 0.21306944f, 0.03310278f, -0.18996119f, 0.37558022f, 0.04329430f, -0.13172415f, -0.28238752f, 
    -0.04171408f, 0.29566759f, 0.07758451f, -0.30009744f, 0.38791329f, 0.22175522f, -0.19660039f, -0.46220315f, 
    0.36714715f, 0.08250056f, -0.07347833f, -0.16560352f, -0.18501447f, -0.11664139f, 0.02233799f, -0.13042983f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.10003200f, 0.17935765f, 0.20333228f, 0.26268283f, 0.10357074f, -0.08797958f, 0.02027659f, -0.41177768f, 
    -0.27390334f, 0.00447216f, 0.01960305f, -0.19955528f, -0.05244308f, -0.18457624f, 0.15918431f, 0.13137871f, 
    0.14564793f, 0.22393674f, 0.20257214f, -0.18857318f, 0.33341262f, -0.23977554f, -0.17447557f, 0.23307410f, 
    -0.09547874f, 0.05186141f, -0.16628283f, -0.08521887f, 0.26678738f, -0.13906124f, 0.06476001f, 0.20765023f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.00251591f, -0.42054510f, -0.45595303f, 0.15689078f, -0.10981529f, 0.20620902f, -0.56295347f, 0.03820242f, 
    0.75971353f, 0.12385986f, 0.13968797f, 0.30462784f, -0.38068226f, -0.21368727f, -0.34208614f, -0.12837802f, 
    -0.17419547f, -0.33931810f, 0.20009537f, 0.17502983f, -0.00469364f, -0.01316529f, -0.18366216f, 0.31851366f, 
    -0.04860418f, -0.36306235f, 0.23319377f, 0.19798981f, -0.14602156f, -0.12240639f, -0.14943418f, 0.14063241f, 
    -0.08419809f, -0.52747935f, -0.09361579f, 0.11069347f, -0.14754900f, 0.40111175f, -0.23311263f, -0.24207807f, 
    -0.95731115f, -0.16660742f, -0.10014115f, 0.00911382f, -0.01129214f, -1.06747472f, 0.34170136f, 0.41614801f, 
    0.29721692f, -0.12647250f, 0.13322936f, -0.07761905f, 0.12220678f, -0.30251157f, 0.06394224f, -0.08104274f, 
    0.13602729f, -0.32042748f, 0.45200729f, 0.16319923f, 0.34255955f, 0.02777501f, -0.39891687f, 0.10623129f, 
    -0.15353031f, -0.00404270f, 0.41461268f, 0.34118605f, -0.06546080f, 0.25183249f, 0.12433958f, 0.27576056f, 
    -0.38930625f, -0.88614202f, 0.08852421f, -0.19476441f, -0.28167114f, -0.60341179f, -0.01436802f, -0.16859318f, 
    0.13628072f, 0.60578537f, 0.18779409f, 0.00275296f, 0.18634012f, -0.11321073f, 0.00435094f, -0.46141517f, 
    -0.14170894f, -0.12651740f, -0.88388914f, 0.39365467f, -0.16298397f, 0.08716967f, 0.10381652f, -0.27374518f, 
    0.04490087f, 0.35760954f, -0.31416509f, 0.20176931f, -0.39769849f, -0.53988177f, 0.45868391f, 0.44349536f, 
    0.07328565f, 0.32569161f, 0.11225257f, 0.15071315f, 0.14288066f, -0.12520434f, -0.77361822f, -0.49374932f, 
    -0.04347948f, -0.02400949f, 0.19087213f, 0.07332300f, 0.18650053f, -0.18869749f, -1.20575511f, -0.13711341f, 
    0.00675541f, -0.04149977f, -0.12916534f, -0.12535591f, -1.06853294f, 0.08803646f, 0.27338186f, -0.12605345f, 
    0.07389031f, -0.17946282f, -0.18382780f, 0.08748937f, -0.37512854f, 0.17352749f, -0.36855528f, -0.13981111f, 
    -0.46014190f, 0.04546016f, 0.13457566f, 0.14141014f, 0.10611251f, 0.76486689f, 0.01679415f, -0.22811104f, 
    -0.48064369f, 0.18740909f, -0.12812819f, -0.09884509f, 0.08385962f, 0.16609380f, 0.00434170f, -0.15104721f, 
    -0.07023825f, -0.08278177f, 0.24046201f, 0.28613743f, 0.19975975f, 0.13902999f, 0.25321990f, -0.08680713f, 
    0.12241056f, -0.06124472f, -0.20771995f, -0.23619744f, -0.33713800f, -0.46464095f, 0.02732557f, -0.10556103f, 
    -0.32798055f, 0.01954859f, -0.05169443f, 0.06976939f, -0.65945786f, -0.54890859f, -0.28903702f, 0.23038068f, 
    0.11846495f, 0.39762488f, 0.02930953f, -0.10089592f, -0.29365417f, 0.22393715f, 0.16346236f, 0.25681788f, 
    0.12146401f, 0.20647745f, 0.17427045f, -0.24220259f, 0.12223303f, -0.16860889f, -0.03373513f, 0.11967590f, 
    -0.14068104f, 0.28003216f, 0.51389277f, -0.37109530f, 0.38124195f, 0.35795936f, -0.57079899f, 0.10422142f, 
    -0.25671878f, -0.68379259f, -0.09015297f, -0.20357147f, -0.01117238f, 0.02861003f, -0.00546750f, -0.58091193f, 
    0.02610134f, -0.51166856f, -0.54058522f, 0.09851246f, 0.03009658f, -0.19268736f, 0.34730598f, -0.97395295f, 
    -0.04599734f, -0.01330595f, -0.12806471f, -0.43054900f, 0.10039805f, 0.02334263f, 0.26524016f, -0.56069946f, 
    -0.07678192f, -0.07908759f, -0.69285578f, 0.12006699f, 0.17997432f, -0.12138594f, 0.25706384f, 0.08933706f, 
    -0.01399172f, 0.11466857f, -0.01810039f, 0.22915152f, 0.38314691f, 0.22173974f, -0.14488730f, 0.28617781f, 
    -0.15229358f, -0.71006519f, -0.74036688f, -0.22236349f, -0.22359355f, 0.19387101f, 0.08495168f, -0.81358105f, 
    0.12905096f, -0.70822561f, -0.52772820f, 0.24023376f, -0.34317192f, 0.09846593f, 0.03377808f, 0.28773147f, 
    0.11867056f, 0.17471063f, -0.36947513f, -0.78321618f, 0.12171391f, -0.25601575f, 0.34495232f, -0.14434224f, 
    -0.16913599f, -0.20286189f, 0.15327206f, -0.68111849f, 0.06618939f, -0.21943511f, 0.27946016f, 0.32107893f, 
    0.25701800f, -0.42950165f, -0.10907276f, -0.11847423f, -0.01372341f, 0.06116355f, -0.11937457f, -0.15836281f, 
    0.17620373f, 0.16784255f, -0.55595708f, -0.73765349f, -0.27816200f, -0.09448570f, -0.77822232f, 0.50882345f, 
    -0.09960958f, 0.24554731f, -0.34746918f, 0.48781916f, 0.08539956f, -0.08751225f, -0.32275769f, -0.22758721f, 
    -0.72281516f, -0.50451386f, 0.00546866f, -0.13280536f, 0.20024426f, 0.31724513f, -0.16811852f, -0.58623713f, 
    0.16862504f, -0.38961801f, -0.08313046f, 0.11279718f, 0.20735352f, -0.21143882f, -0.28997019f, 0.60664862f, 
    0.15224215f, 0.12161440f, -0.12902832f, -0.20969957f, 0.08823439f, -0.17617588f, 0.42517108f, -0.50362742f, 
    -0.01702538f, -0.16027898f, 0.49056008f, -0.33168444f, -0.02072721f, -0.25390914f, 0.30193254f, 0.07771432f, 
    -0.54370654f, -0.01565234f, -0.01357265f, -0.77244288f, -0.33361447f, 0.16770506f, -0.01519024f, 0.03751003f, 
    -0.39121899f, 0.24399248f, 0.18451017f, 0.06701721f, -0.33934242f, 0.30326682f, -0.27725697f, -0.95913541f, 
    0.04737664f, 0.28942230f, 0.25636357f, 0.05620335f, -0.22918725f, -0.09058464f, -1.07187366f, 0.20363480f, 
    0.10666901f, -0.06464952f, 0.50988632f, -0.28943452f, 0.01472170f, 0.23089151f, 0.18106697f, 0.06815027f, 
    -0.23812674f, 0.15789382f, 0.09081203f, 0.35391924f, 0.03867650f, -0.29494897f, 0.30546355f, -0.74800622f, 
    0.18178628f, -0.09799161f, -0.63025230f, 0.08547678f, -0.70393497f, -0.46001497f, -0.22589479f, 0.42837274f, 
    0.04026834f, 0.30763289f, -0.27488405f, -0.12365413f, 0.28167984f, -0.21328060f, -0.43096384f, -0.06674404f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.00628753f, 0.02694309f, 0.04600700f, 0.23342577f, -0.41757062f, -0.11722670f, 0.05898362f, 0.01198610f, 
    0.10296976f, 0.04316146f, 0.13725252f, -0.00209178f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
