#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.11892152f, 0.03118840f, -1.22904170f, -1.53945029f, -1.03044820f, 0.13799240f, -0.25487107f, 0.09172867f, 
    -0.69201845f, -0.15395239f, 0.45394194f, -0.35043952f, 0.06580389f, 0.21408074f, 0.20392203f, -0.25229934f, 
    0.09189452f, -0.02834355f, -0.12508096f, 0.19239402f, -0.01699756f, 0.02771694f, 0.27067858f, 0.00815873f, 
    0.13591939f, 0.68800813f, -0.30867913f, -0.77804744f, 1.51781309f, 1.42889345f, 1.16417468f, 0.61471486f, 
    -0.51798779f, 0.49001959f, 0.12396815f, -0.49878350f, -0.08877113f, -0.35962021f, 0.00645862f, -0.23610732f, 
    -0.31235775f, -0.02759396f, -0.12439853f, -0.25087526f, -0.26331285f, 0.14520121f, -0.02668114f, -0.27510357f, 
    -0.07141540f, 0.01475074f, 0.98857909f, 0.97116005f, 0.26411977f, -0.00150173f, 0.77497631f, -0.11979143f, 
    -1.85874546f, -0.91074413f, -0.80657816f, 0.00139993f, 0.85430986f, 0.46757373f, -0.11922452f, -0.04952059f, 
    -0.29199278f, 0.13809337f, -0.07189502f, -0.17505561f, -0.00931939f, 0.09411304f, 0.38663960f, 0.17376022f, 
    0.14283594f, 0.14171010f, -0.23132946f, 1.18838024f, 1.48238039f, 1.30260336f, 1.01802516f, 0.56930399f, 
    0.01319497f, 0.13649066f, 0.45089522f, -0.05045125f, 0.58933592f, 0.28812549f, 0.43848842f, 0.06248787f, 
    0.56055939f, -0.02799543f, 0.03316686f, -0.02768006f, 0.48282880f, 0.00044161f, -0.23349677f, -0.05375146f, 
    0.11560470f, -0.49554607f, 0.05412192f, 0.46058503f, -1.05078137f, -1.62459803f, -0.25669071f, 0.67869616f, 
    0.55446035f, 0.62497318f, 1.00656843f, 0.38781133f, -0.20472372f, -0.46281362f, -0.50799274f, -0.34794384f, 
    0.00909483f, 0.56336576f, 0.62408268f, -0.10687479f, -0.00229155f, -0.67309135f, -0.16270383f, 0.13499983f, 
    0.16154765f, 0.18392488f, 0.06418394f, 0.18714109f, -0.34560680f, 0.73159063f, 1.08566427f, 0.58430916f, 
    0.67083657f, 0.86490959f, 0.87822342f, -0.08749206f, -1.17564213f, 0.09911500f, -0.38948947f, -0.71674842f, 
    -0.21728933f, -0.19634344f, 0.50367320f, -0.71145827f, -0.29826179f, -0.09797240f, 0.03650938f, -0.21778773f, 
    -0.17053127f, -0.20891067f, -0.26517510f, -0.20316048f, -0.48331082f, -0.37023401f, -0.49677259f, -0.13440754f, 
    0.37597290f, -0.69188815f, -1.05325770f, 0.50163192f, 0.63677609f, 0.34284556f, -0.45266312f, -0.17998137f, 
    0.40886346f, 0.18874347f, -0.75855619f, 0.08865847f, 0.41111469f, 0.14083849f, -0.09347743f, -0.54744697f, 
    -0.13728254f, -0.13426778f, -0.15190412f, 0.10961951f, 0.71658415f, 0.32753882f, 0.29131785f, -0.37061769f, 
    -1.18055367f, -0.34515002f, 0.47020990f, -0.78166652f, -0.09625376f, 0.20623058f, -0.87961227f, 0.15857749f, 
    0.67078751f, 0.58906120f, 0.35452503f, -0.47131342f, 0.60492158f, -0.10823303f, -0.35013965f, 0.16527036f, 
    0.29490706f, 0.71333301f, 0.28334665f, -0.00095480f, 0.54508233f, 0.69906318f, -0.34832940f, 0.06244790f, 
    -0.62904769f, -0.02475438f, -0.92540497f, -1.38074839f, -0.91090083f, 0.48833057f, -0.63233221f, -0.55908209f, 
    0.21183723f, 0.30210540f, -0.12816188f, -0.31291592f, 0.01122864f, -0.03141208f, -0.51052541f, 0.24687822f, 
    0.18331061f, 0.26543289f, 0.30146393f, 0.73410040f, -0.12394956f, -0.05174786f, -0.21154641f, -0.44722733f, 
    0.53268909f, -0.15393294f, -1.63674796f, -0.69846183f, 0.32261947f, 0.38138014f, -1.24809659f, 1.00491250f, 
    0.54656917f, -1.24868786f, 0.29110071f, 0.52250111f, -0.01539159f, -0.02893473f, -0.55537516f, 0.44401643f, 
    -0.36032739f, 0.17248748f, 0.00170758f, -0.22766234f, -0.56598371f, -0.01530322f, -0.19555481f, -0.24149573f, 
    0.10923310f, -0.16360320f, -1.93999350f, 1.33438194f, -0.09094068f, -0.67714685f, -0.55267882f, 0.52195674f, 
    -0.16328363f, -0.01050915f, 0.40339231f, -0.77910602f, -0.10292406f, 0.42977083f, 0.11632954f, 0.19540261f, 
    -0.12148874f, -0.44958714f, 0.11432323f, -0.35245672f, -0.26045781f, -0.37639090f, 0.14918366f, 0.08476780f, 
    0.10794380f, 0.20549047f, -0.01858126f, 0.35512471f, -0.43660364f, 1.25702620f, 1.15602601f, -0.20628850f, 
    -0.72137135f, 1.07361114f, 0.24270046f, 0.46791333f, 0.09853210f, 0.00770099f, 0.05904881f, -0.07459907f, 
    0.01273110f, -0.73526281f, -0.33781573f, -0.43894967f, -0.53989875f, -0.10774159f, -0.60132921f, -0.38181293f, 
    0.05029639f, 0.10462791f, 0.29647356f, -0.49514645f, 1.09890747f, 0.29927301f, 0.07208078f, 0.42034695f, 
    -1.48396432f, 0.56850666f, 0.05996217f, -0.01972033f, -0.59888875f, 0.36709759f, 0.67779809f, -0.06058837f, 
    0.21444498f, -0.34149736f, 0.04718583f, 0.09268783f, -0.15503658f, 0.51792997f, -0.19775492f, -0.40006754f, 
    0.07308563f, 0.08689458f, -0.04415533f, 0.30795592f, -0.53501737f, 1.06898415f, -0.88308018f, -1.05710280f, 
    -0.48041096f, 0.60660040f, 1.25952375f, 0.33444875f, -0.02778167f, 0.66110653f, 0.75164896f, -0.01438045f, 
    0.73320711f, -0.42754510f, 0.68146127f, 0.39587316f, 0.25186011f, 0.18146488f, 0.27231440f, 0.32259977f, 
    0.04771584f, 0.02414651f, -0.12577549f, -0.04166085f, 0.06770330f, 0.04905490f, -1.18557250f, -1.05670810f, 
    -0.59033811f, -0.08372650f, -0.96334749f, 0.72106671f, 1.46804130f, 0.18082049f, -0.01751322f, 0.64565289f, 
    -0.36337945f, -0.32831413f, -0.19315624f, -0.54411554f, -0.35728189f, -0.12398763f, 0.14478526f, 0.18910117f, 
    -0.22497581f, -0.24758165f, 0.15112725f, -0.10543188f, 0.06325898f, -0.03152148f, 0.21618378f, 1.54100454f, 
    0.34965467f, 0.63064754f, 1.29338968f, 0.91753328f, 0.88379133f, -0.02005525f, -0.10615513f, 0.25146803f, 
    -0.25035271f, 0.29197747f, -0.00337052f, -0.51242137f, -0.11656034f, 0.10229173f, 0.66594851f, 0.35442087f, 
    -0.04777459f, 0.22498803f, 0.68769306f, 0.37038717f, 0.03031412f, 0.61026573f, 0.28589201f, 0.59855211f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.34636626f, 0.44902292f, 0.47186571f, 0.44336385f, 0.28757966f, 0.09931574f, 0.15934855f, 0.42113310f, 
    0.27157488f, 0.23937894f, 0.15459344f, 0.37611911f, 0.35179108f, 0.30744222f, 0.17482196f, 0.22807291f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.73431766f, -0.28923258f, 0.10313200f, -0.27725217f, 0.02075807f, -0.18088450f, 0.19925895f, -0.12368811f, 
    -0.22976857f, -0.06476966f, -0.07996293f, 0.10361136f, -0.05534409f, -0.02418287f, 0.17752768f, 0.63908130f, 
    -0.17425987f, 0.02939163f, 0.00627723f, -0.10166688f, -0.23759662f, 0.06268007f, 0.03306620f, -0.02653321f, 
    0.31311595f, -0.31699249f, 0.58435857f, -0.24852887f, -0.25497621f, -0.02934494f, -0.06618269f, 0.02673613f, 
    0.20660776f, -0.10818438f, 0.07328036f, -0.12435319f, 0.18881340f, -0.03262776f, -0.17279857f, -0.00581531f, 
    -0.30036551f, -0.10180713f, 0.02677948f, 0.05205762f, -0.06633123f, 0.13947703f, -0.00656429f, 0.00454489f, 
    -0.52545977f, 0.30160221f, 0.06729062f, -0.13901211f, 0.17787796f, -0.00189600f, -0.25290531f, -0.09390993f, 
    0.06269932f, -0.16354059f, 0.10668684f, -0.14684647f, 0.03391166f, -0.06711093f, 0.11814140f, 0.24000023f, 
    -0.03997965f, -0.07550085f, 0.02437322f, 0.06400580f, 0.07450002f, 0.02149050f, -0.03899698f, 0.06453435f, 
    -0.34682918f, 0.02306378f, 0.14445677f, -0.41445357f, 0.04930951f, 0.13590512f, 0.08823950f, 0.09157966f, 
    0.33021852f, -0.00861531f, 0.04157060f, 0.01996364f, 0.02581525f, -0.28849924f, -0.14356257f, 0.43827197f, 
    0.06977140f, -0.08484992f, -0.11638588f, -0.07102547f, -0.14788774f, 0.06458461f, -0.09087897f, -0.04005493f, 
    0.33390021f, -0.38366747f, -0.15199077f, -0.45978591f, 0.21165365f, -0.03867074f, 0.13202384f, 0.06065033f, 
    0.04454878f, -0.05787779f, -0.01056705f, 0.00503292f, -0.85040283f, -0.02230513f, -0.05125502f, 0.17482868f, 
    0.01168011f, -0.20757909f, -0.21545018f, -0.16455376f, -0.04909794f, 0.11249293f, -0.07373270f, 0.03752657f, 
    0.24783824f, 0.07284071f, -0.07152487f, 0.03350481f, -0.02699947f, -0.08438239f, 0.13529208f, -0.17601563f, 
    0.05400500f, -0.09859460f, 0.05897844f, -0.06861223f, 0.32432559f, -0.08272699f, -0.33401996f, 0.42364386f, 
    -0.13393295f, 0.05493657f, 0.20285866f, -0.18143938f, -0.07961374f, 0.01377524f, -0.05514087f, -0.02431013f, 
    -0.24544054f, -0.05399923f, -0.12696536f, -0.19731936f, -0.27098477f, 0.19107784f, -0.22386067f, -0.06397771f, 
    -0.22200367f, 0.12375142f, -0.00850998f, -0.11226521f, 0.39132819f, -0.16181386f, 0.26805598f, -0.40463465f, 
    0.06421456f, 0.16437864f, 0.01579448f, -0.05778942f, -0.08575977f, 0.01463700f, 0.00546428f, -0.06833147f, 
    0.47114769f, 0.54710966f, 0.27275363f, -0.30941102f, -0.00572699f, 0.00051575f, -0.12597050f, 0.20178644f, 
    0.00725461f, -0.05459384f, -0.05079433f, 0.08898729f, 0.33930516f, -0.21682364f, -0.22968119f, 0.35132170f, 
    -0.28494209f, -0.06173278f, -0.12493297f, 0.16577986f, 0.02160581f, -0.07589373f, -0.01316663f, -0.01515259f, 
    0.59970170f, -0.17272851f, -0.07573118f, -0.39592686f, -0.07792394f, 0.15334550f, -0.06580600f, 0.06533600f, 
    -0.15348428f, 0.03945296f, 0.09017975f, -0.12258770f, 0.26826835f, -0.33380672f, -0.35566992f, 0.07553206f, 
    0.07606928f, 0.19730991f, -0.18282419f, 0.07116444f, -0.03798846f, 0.22787733f, 0.07866476f, -0.26152262f, 
    -0.31926316f, -0.18390964f, 0.08455089f, -0.15816668f, 0.01081097f, 0.05209314f, 0.17631888f, 0.02502924f, 
    0.07656813f, 0.13434035f, 0.06230151f, 0.15321346f, 0.48305389f, 0.04715156f, 0.16630489f, 0.37216613f, 
    -0.01855044f, -0.08223244f, 0.02350817f, 0.09607765f, 0.00424140f, 0.00971908f, -0.04720896f, -0.05410421f, 
    0.32367441f, 0.21480212f, -0.17347485f, 0.15790302f, -0.09792713f, 0.16541915f, -0.01018540f, -0.14827760f, 
    -0.12267293f, 0.27852947f, -0.17092359f, 0.09487952f, 0.28866673f, -0.18009825f, -0.06218978f, 0.07824834f, 
    -0.21966675f, -0.07599090f, 0.01716354f, -0.11530600f, -0.03605685f, -0.13320370f, 0.10904649f, -0.13496909f, 
    -0.44661632f, -0.05135591f, -0.62291002f, -0.08163033f, -0.01972917f, 0.15659927f, -0.23048922f, -0.00449988f, 
    -0.18091096f, 0.01582824f, -0.29349479f, 0.06680576f, -0.06738623f, -0.09573437f, -0.79012752f, 0.20137948f, 
    -0.10071292f, -0.03831705f, 0.02063747f, 0.08546171f, 0.02275532f, -0.11888514f, 0.12074064f, 0.10142951f, 
    -0.46537828f, -0.14642537f, 0.22658558f, -0.32650700f, -0.00661771f, 0.18068279f, 0.14859332f, 0.07254753f, 
    0.16296533f, 0.11063207f, 0.13895784f, 0.04312617f, 0.41266665f, -0.17838918f, 0.03881370f, 0.25100300f, 
    -0.29463837f, 0.14517756f, -0.28380337f, 0.04663697f, -0.02671252f, -0.21013293f, 0.11085513f, -0.09030651f, 
    -0.87245345f, -0.12953454f, -0.11219192f, -0.36070603f, -0.27161965f, -0.14136137f, 0.02458134f, -0.03747181f, 
    0.07339691f, -0.06329374f, -0.13841137f, -0.43071881f, -0.05266167f, 0.15278728f, -0.04620762f, 0.42452618f, 
    -0.22966954f, -0.03512393f, -0.09452059f, -0.00416809f, 0.01214759f, -0.21695633f, -0.08035262f, -0.17025325f, 
    0.26961979f, -0.04925654f, 0.00323305f, 0.07965692f, -0.25275680f, 0.00200520f, 0.23823470f, 0.07680687f, 
    0.22861913f, 0.02561419f, -0.01816862f, 0.27661327f, 0.78688979f, -0.63614124f, 0.08535907f, -0.24122450f, 
    0.03054742f, 0.02644415f, -0.25739774f, -0.11294697f, -0.14789490f, 0.04438218f, 0.02498149f, 0.01106318f, 
    -0.21025409f, -0.05274028f, -0.27145568f, 0.03482974f, 0.14601445f, -0.10526536f, 0.05183605f, -0.17627075f, 
    0.23647319f, 0.08057559f, -0.18144107f, -0.10488310f, 0.34508628f, -0.11684506f, 0.41902384f, 0.36659601f, 
    -0.20299830f, -0.06342435f, -0.00346560f, -0.01866474f, -0.00151668f, 0.16771531f, -0.00980916f, 0.17445874f, 
    -0.44857717f, -0.13103350f, -0.06783894f, -0.18129228f, -0.34368643f, -0.42724416f, 0.27503332f, -0.10181823f, 
    -0.09536490f, 0.04534216f, 0.06926136f, 0.05084188f, -0.43679690f, -0.61361891f, 0.27172655f, -0.07677503f, 
    0.10375426f, 0.12327805f, -0.22330835f, 0.01984547f, 0.00110039f, 0.13624151f, -0.05938678f, -0.03271723f, 
    -0.56082219f, 0.11210878f, -0.12983760f, -0.26523152f, 0.21910980f, 0.08859581f, 0.06192011f, -0.19617270f, 
    -0.10159330f, -0.00578785f, 0.08477464f, -0.24019100f, 0.04248716f, 0.29933262f, -0.07344563f, 0.10058415f, 
    0.25304934f, 0.23256968f, 0.06769702f, -0.15154165f, -0.00842304f, 0.01511394f, -0.13830440f, 0.10612173f, 
    0.10793675f, -0.22653157f, -0.05181323f, 0.06429823f, -0.41346857f, 0.06386894f, -0.05294492f, 0.16006239f, 
    0.21342690f, -0.18514763f, -0.10664446f, 0.00593165f, 0.26802984f, -0.38141569f, -0.05217422f, 0.26410127f, 
    0.26969105f, 0.13734813f, 0.02228758f, -0.09479125f, -0.10264002f, 0.23667887f, -0.17968914f, 0.08189973f, 
    0.20157455f, -0.02826275f, 0.14603145f, -0.14805247f, -0.04721376f, -0.30676150f, -0.08725206f, -0.03787777f, 
    0.01582392f, -0.24260539f, 0.08214377f, -0.01909890f, 0.29532966f, -0.61197054f, 0.19108281f, -0.22136527f, 
    -0.07452149f, 0.04346120f, 0.23112708f, -0.23752461f, -0.00706062f, -0.11043020f, -0.08400268f, -0.05154771f, 
    -0.38336286f, -0.26507148f, 0.21713352f, -0.00857871f, 0.05768187f, -0.31216678f, -0.13763815f, -0.05271793f, 
    -0.09604118f, 0.15401353f, 0.00027217f, -0.04933952f, 1.26216686f, -0.25010473f, 0.10139658f, 0.02967422f, 
    -0.08605296f, 0.10445541f, -0.11388040f, -0.04565629f, -0.07320132f, 0.09708872f, 0.00868301f, -0.23743978f, 
    0.28115052f, 0.12958704f, -0.29804388f, -0.51635218f, -0.01841052f, -0.04319331f, -0.14869951f, 0.01075715f, 
    -0.28028962f, -0.04322525f, -0.22945879f, 0.02000761f, 0.07609496f, 0.33073872f, -0.14669783f, -0.01403403f, 
    -0.17380410f, 0.12854734f, 0.13198173f, 0.00068408f, -0.21688746f, 0.17306799f, 0.13376348f, -0.08562465f, 
    -0.15427972f, -0.12020252f, -0.01927100f, -0.38400322f, -0.11196825f, -0.17031510f, -0.12856840f, 0.23562472f, 
    -0.05006888f, -0.33208850f, 0.02478147f, -0.08831038f, -0.02316785f, 0.08202461f, 0.24253070f, 0.13432904f, 
    -0.01860222f, -0.13478757f, 0.02777286f, -0.00372715f, -0.04508432f, -0.12904239f, -0.04294812f, -0.10516132f, 
    0.73530447f, -0.03132617f, 0.38045362f, 0.31148177f, -0.27873889f, -0.39208618f, 0.19435258f, 0.25448647f, 
    0.19621348f, 0.22841027f, -0.03515844f, -0.05997796f, 0.26635832f, -0.00501557f, -0.14751631f, 0.12222013f, 
    0.10462610f, -0.12135188f, -0.02995867f, -0.00297326f, 0.03713787f, -0.14872682f, 0.12478799f, -0.21044734f, 
    -0.04588566f, -0.30536434f, 0.01237134f, 0.05391563f, -0.19817083f, -0.04373138f, -0.01321879f, 0.25119501f, 
    0.00750935f, 0.12059052f, -0.14525926f, 0.01756167f, 0.05126423f, -0.29545882f, -0.22097346f, -0.03365558f, 
    0.03293349f, -0.04487272f, 0.33538532f, -0.03856265f, 0.09535338f, 0.06790705f, 0.08774270f, 0.13137087f, 
    0.17364717f, -0.22422291f, -0.24586940f, 0.61192781f, 0.16913107f, 0.17787331f, -0.07725086f, -0.05652915f, 
    -0.07422912f, 0.02412622f, -0.00335421f, -0.20803878f, -1.38351190f, -0.97168773f, -0.35085160f, 0.04929024f, 
    -0.16371797f, -0.07593542f, 0.17451209f, -0.06001785f, 0.14076979f, -0.22731419f, 0.02429971f, -0.04789666f, 
    0.19887771f, 0.06349377f, -0.06307773f, 0.20763353f, -0.21991844f, -0.10287577f, 0.07551865f, 0.04094049f, 
    -0.02768648f, -0.37528756f, -0.02107191f, 0.01060056f, 0.89044398f, -0.56021094f, -0.14334790f, 0.42286810f, 
    -0.15283482f, 0.16147651f, -0.01650319f, 0.00418175f, 0.07108009f, 0.03124531f, 0.11014479f, 0.18814448f, 
    0.13917381f, 0.23687442f, 0.20306802f, -0.25247926f, 0.06188428f, -0.12535760f, 0.06567646f, -0.10926332f, 
    0.20120488f, -0.16148607f, -0.07878218f, -0.07205565f, 0.06475742f, 0.01242368f, 0.07377002f, -0.23486212f, 
    -0.06748816f, -0.12800725f, -0.08177727f, 0.02224943f, 0.01421510f, -0.19433720f, 0.25748956f, 0.08202888f, 
    0.02639670f, 0.25943264f, -0.06560040f, -0.13867220f, -0.23210870f, -0.12613836f, 0.00460094f, 0.00563339f, 
    0.03272165f, -0.15661374f, -0.13405897f, 0.08597423f, 0.10219768f, -0.11152765f, 0.31635565f, 0.28128749f, 
    0.09072762f, 0.07178728f, 0.08701780f, -0.05258478f, -0.00847109f, 0.28732234f, -0.07059061f, 0.10343275f, 
    0.48326626f, 0.66723084f, 0.10152183f, 0.02798040f, -0.15751155f, 0.19845656f, -0.02101237f, 0.06899621f, 
    0.08881807f, 0.05547692f, -0.16140494f, 0.01418890f, -0.86464196f, -0.12887891f, -0.22718039f, 0.02058028f, 
    0.08735810f, -0.07018679f, -0.05820872f, 0.00634235f, 0.06395552f, 0.27284029f, 0.06692640f, 0.00241008f, 
    0.03853399f, -0.43042433f, -0.52119827f, 0.17493027f, 0.03346330f, 0.15872753f, -0.10806026f, -0.05396644f, 
    0.05375724f, -0.03655947f, -0.09209007f, 0.11216547f, -0.14781226f, 0.19658439f, -0.32331279f, -0.00928734f, 
    -0.19753374f, 0.25178945f, -0.04301086f, -0.03294598f, -0.16087012f, -0.03093135f, 0.18699707f, 0.15836166f, 
    -0.15616028f, -0.04083145f, -0.04602236f, -0.37006745f, -0.11818755f, -0.25953126f, 0.05001157f, 0.11867509f, 
    -0.11021765f, -0.11745476f, 0.09201962f, -0.08289757f, -0.46145144f, -0.54513764f, -0.32215625f, -0.15435742f, 
    -0.09708655f, 0.04206655f, -0.04721173f, -0.08721333f, 0.05134351f, -0.16590057f, 0.10927892f, -0.12096469f, 
    0.03529058f, 0.11057048f, -0.06061105f, 0.21524097f, 0.02610232f, 0.01568763f, 0.29471946f, -0.10723093f, 
    -0.04240289f, 0.12217563f, 0.03320656f, -0.01849715f, 0.52266258f, 0.04434719f, -0.39169568f, -0.04172396f, 
    -0.14237516f, 0.01931018f, 0.01144597f, -0.02785206f, -0.06928082f, -0.02688568f, 0.07963142f, 0.18575977f, 
    -0.59564412f, -0.23189938f, 0.22041038f, 0.24920006f, -0.24040256f, 0.19217350f, -0.32560670f, -0.19165733f, 
    0.02260418f, -0.00156614f, -0.14097844f, -0.25583589f, -0.12225378f, -0.29855764f, -0.08352377f, 0.22789347f, 
    -0.07714742f, -0.16067629f, -0.01714602f, 0.06770238f, 0.05253182f, 0.12573256f, -0.08755716f, -0.02492676f, 
    -0.77786577f, 0.18252712f, -0.35487354f, -0.32482007f, 0.12398192f, -0.14297710f, 0.15484771f, 0.14574994f, 
    -0.03474659f, -0.18974188f, 0.11047073f, 0.12235665f, 0.00476664f, 0.30333850f, 0.11568690f, 0.06080300f, 
    -0.11487717f, 0.12827939f, 0.05794359f, 0.24444029f, -0.04256390f, -0.02093222f, 0.06276625f, 0.11404803f, 
    -0.16095394f, -0.11085068f, 0.04179406f, -0.09796473f, 0.10470344f, -0.03551804f, -0.08785411f, 0.02194334f, 
    -0.14093009f, -0.22021365f, -0.18504281f, 0.16672839f, -0.12131833f, 0.27829349f, 0.13898677f, -0.19472449f, 
    0.03544531f, 0.36744088f, -0.08647536f, 0.05408984f, -0.14688157f, -0.05506119f, 0.03587539f, -0.02067159f, 
    0.22140487f, 0.06341817f, 0.16121951f, 0.44034910f, 0.06815382f, -0.11196610f, 0.10602159f, 0.16337951f, 
    -0.12137990f, 0.03237715f, 0.14850661f, 0.14658155f, -0.56753159f, -0.00378238f, -0.24648567f, -0.10177987f, 
    0.00341310f, -0.27406326f, -0.04481204f, 0.07909767f, 0.09222879f, -0.03749519f, -0.02875605f, 0.01279710f, 
    0.71351922f, 0.35172033f, -0.19777946f, -0.71474099f, 0.13596240f, 0.11912616f, 0.08701621f, -0.06063993f, 
    0.04562648f, -0.01606521f, 0.02682594f, 0.02579254f, -0.63822109f, 0.28115439f, 0.17707579f, -0.03384054f, 
    0.13874963f, 0.12742543f, 0.16843976f, 0.15769453f, -0.13632888f, 0.09802245f, 0.04184708f, 0.05193488f, 
    -0.18100017f, -0.01360395f, -0.00347403f, -0.59106815f, -0.01612283f, -0.02585469f, -0.10340737f, -0.16840489f, 
    -0.03192304f, -0.16740410f, -0.13762210f, 0.15214185f, -0.49252665f, 0.13803658f, -0.01507325f, 0.39132327f, 
    0.21203130f, -0.17924148f, 0.16748065f, -0.15575595f, 0.01172416f, -0.06926272f, -0.04689496f, -0.02662221f, 
    -0.92346996f, -0.28696027f, 0.07122812f, 0.17765783f, 0.06966496f, -0.10247412f, 0.09198043f, 0.11717228f, 
    -0.06729314f, 0.05450056f, 0.19747818f, 0.10883936f, 0.08210685f, 0.18818840f, 0.07595370f, -0.20422587f, 
    -0.00308961f, 0.06004060f, 0.09726087f, 0.01680082f, 0.10744816f, -0.09087393f, -0.11839996f, -0.18525845f, 
    -0.28865886f, -0.36580703f, -0.05373366f, -0.03773769f, 0.19505471f, -0.08755723f, -0.09084304f, 0.25448263f, 
    0.13228752f, 0.05792842f, -0.00270456f, -0.02673974f, -0.12395871f, 0.11800207f, 0.46448937f, -0.58522385f, 
    0.02556136f, 0.02550089f, -0.11685964f, 0.06977206f, 0.15430148f, -0.20588714f, -0.07461259f, -0.06733035f, 
    0.11115064f, 0.03256477f, -0.08855516f, 0.31102583f, -0.21960665f, -0.15215552f, -0.00704908f, 0.09109446f, 
    -0.08826192f, -0.01549102f, -0.07737625f, 0.24926667f, 0.30502021f, 0.22545560f, 0.26005256f, -0.05090445f, 
    -0.02585083f, 0.43163589f, 0.02830381f, -0.09778202f, -0.08787555f, -0.09236782f, 0.27691254f, 0.07242355f, 
    -0.75731468f, 0.21111925f, -0.15175259f, -0.25532472f, 0.06756122f, 0.14026132f, 0.10777772f, 0.10555923f, 
    0.03847044f, 0.23738347f, 0.13720654f, -0.19502459f, 0.01860266f, -0.28769600f, 0.20586321f, 0.16968612f, 
    0.12734354f, 0.01578859f, 0.15733424f, -0.02833096f, -0.05085267f, 0.08136073f, -0.10495627f, -0.02571070f, 
    -0.43889689f, -0.29977760f, -0.06755952f, -0.03960018f, 0.04043501f, -0.03853188f, 0.25049728f, 0.16837220f, 
    0.26319367f, 0.23133159f, -0.43361735f, -0.02099971f, -0.90407932f, -0.16987185f, -0.00640334f, 0.28408509f, 
    0.09142197f, -0.23097582f, 0.10326844f, 0.06938346f, -0.08833112f, 0.04115201f, 0.11175022f, 0.06344731f, 
    0.13383305f, -0.18677668f, -0.19424653f, 0.09735956f, 0.27766854f, 0.06256881f, -0.24517682f, -0.11786220f, 
    -0.02506985f, -0.01553423f, 0.14522810f, 0.12199075f, -0.74328285f, 0.09116842f, 0.08272865f, -0.34530768f, 
    0.24077412f, 0.07237828f, -0.01580857f, 0.07806761f, -0.05842786f, -0.17632416f, -0.14226677f, -0.14043441f, 
    -0.60245836f, -0.72193241f, 0.28378889f, 0.49518630f, 0.07406007f, -0.01718874f, -0.11642888f, 0.16366291f, 
    0.05877240f, -0.08220375f, 0.06850429f, 0.14328505f, -0.08352228f, 0.08591855f, 0.02497190f, 0.08071063f, 
    0.09075100f, -0.16417502f, -0.05309726f, 0.14589651f, 0.15470813f, -0.06708351f, -0.11147438f, -0.19968109f, 
    0.46356156f, 0.19109279f, -0.04546646f, 0.08029073f, 0.26979059f, -0.13291466f, -0.05599119f, 0.11055119f, 
    -0.05068784f, -0.00605077f, 0.05823505f, -0.37577456f, -0.35694733f, 0.01845570f, -0.11806874f, -0.27107832f, 
    -0.02812556f, -0.16899498f, -0.06421915f, -0.16501358f, 0.08459222f, 0.07031577f, 0.13773730f, 0.08358866f, 
    -0.36989498f, 0.27610686f, -0.46786141f, -0.11446934f, 0.16273783f, 0.13791807f, 0.06466030f, -0.17917162f, 
    0.00228169f, -0.26406500f, -0.04851559f, -0.26745358f, -0.14202201f, 0.00888496f, -0.09078503f, -0.04728508f, 
    -0.14548695f, -0.16205685f, 0.05817188f, -0.11225367f, 0.22996889f, 0.24850506f, -0.10293204f, 0.34124935f, 
    0.11119566f, -0.18468305f, -0.68360668f, 0.35527581f, 0.26255396f, 0.06358632f, -0.25037265f, -0.20774597f, 
    0.13779472f, -0.14322306f, -0.01479854f, -0.12697110f, -0.04339232f, -0.43759954f, -0.15370813f, -0.04919099f, 
    -0.11176593f, 0.04151957f, -0.00222231f, 0.06466693f, 0.04264426f, -0.14986621f, -0.21677528f, 0.01455356f, 
    0.10613422f, 0.37607291f, -0.32395878f, -0.36748073f, 0.04863978f, 0.20051046f, 0.13538517f, -0.01408963f, 
    -0.04283734f, 0.02618715f, -0.10934253f, -0.03377803f, -0.24027005f, 0.41264254f, 0.30295864f, -0.21131268f, 
    -0.03995503f, -0.08546937f, 0.00550835f, 0.18797608f, 0.12228157f, -0.05748434f, -0.05498555f, -0.03180842f, 
    0.31342989f, -0.58179247f, 0.08146184f, -0.07881364f, 0.05519651f, -0.07761182f, -0.02175380f, 0.01563217f, 
    -0.03449218f, 0.11622346f, 0.01120840f, -0.10361432f, -0.21802033f, 0.31589526f, 0.03547487f, -0.39503586f, 
    -0.11754730f, 0.08134767f, 0.19423789f, 0.05750092f, 0.00224460f, -0.00683345f, 0.07174104f, 0.02537389f, 
    0.13910142f, 0.05873593f, -0.39659104f, 0.21492536f, -0.28189737f, 0.18127906f, -0.18727191f, -0.33022815f, 
    -0.12804566f, -0.07862539f, 0.20199740f, -0.21884872f, 0.21262915f, 0.36606431f, -0.00071254f, -0.15749329f, 
    -0.19410914f, -0.01792204f, 0.00036131f, -0.21076681f, -0.04422216f, 0.25705624f, -0.04349611f, -0.24746446f, 
    -0.24866736f, -0.17493881f, -0.56130260f, 0.08594975f, -0.37901646f, -0.16285472f, 0.15430066f, -0.19724460f, 
    -0.09725264f, -0.09679141f, -0.15637775f, -0.06154505f, 0.04142301f, 0.18063699f, 0.08786922f, -0.12244280f, 
    -0.15006784f, 0.08494011f, 0.23372282f, 0.15540615f, 0.08301223f, -0.02918677f, 0.06254384f, 0.19533226f, 
    0.31328946f, -0.32804349f, 0.25961977f, 0.17532411f, -0.12809356f, -0.13516690f, 0.03219558f, 0.04159836f, 
    -0.12512520f, 0.18614973f, -0.05814971f, 0.08887794f, 0.50573897f, -0.33196703f, 0.38711244f, -0.29920089f, 
    -0.03126359f, -0.04890546f, 0.17342104f, -0.10661378f, -0.05557379f, 0.06412432f, 0.39745983f, 0.28820676f, 
    -0.11145655f, 0.04161597f, 0.24038181f, 0.48382795f, -0.05505724f, 0.11965938f, -0.03770911f, 0.17012596f, 
    -0.28006265f, 0.16710073f, 0.05314967f, 0.07387357f, -0.64713997f, -0.34541735f, -0.03188648f, -0.09956618f, 
    0.12987186f, -0.06730764f, 0.06586795f, 0.20699498f, 0.07825407f, -0.00751457f, -0.04312110f, 0.04001470f, 
    0.27340445f, -0.62426895f, -0.23081388f, -0.25957388f, -0.02038257f, 0.11547644f, -0.11450246f, -0.07366700f, 
    -0.00438279f, 0.08547855f, 0.16781461f, 0.39657098f, -0.19750939f, 0.35581264f, 0.33663112f, -0.62145764f, 
    -0.05842196f, 0.07853049f, -0.01486403f, 0.16477065f, 0.12050857f, -0.19684608f, 0.05769188f, -0.31357524f, 
    -0.16760485f, 0.33626249f, 0.11085425f, 0.01192089f, -0.23567103f, -0.12997060f, -0.13109592f, -0.04858706f, 
    -0.09042776f, -0.15894490f, 0.04133291f, -0.17256412f, -0.20040229f, 0.49467301f, 0.11230543f, -0.18949218f, 
    -0.24085931f, -0.07932523f, 0.02015868f, -0.15997177f, -0.13819218f, -0.00830299f, -0.30468997f, -0.07114846f, 
    -0.59682590f, 0.04013292f, -0.50000381f, 0.02853018f, -0.18470645f, -0.45333406f, -0.14919332f, -0.10652629f, 
    -0.29886329f, 0.07466286f, -0.03627859f, -0.02760336f, -0.36364368f, 0.03068898f, -0.24248952f, -0.39524525f, 
    0.09842157f, 0.03754025f, -0.00613032f, -0.05219421f, 0.00931486f, -0.05957969f, 0.02806004f, -0.08077228f, 
    -0.08133751f, -0.14738534f, 0.15935442f, -0.19190782f, 0.15409122f, 0.01490905f, 0.07365007f, 0.03823234f, 
    -0.10825510f, -0.03028285f, -0.04594164f, -0.10816176f, -0.23722917f, 0.48146209f, -0.00192381f, 0.04409470f, 
    -0.20474029f, 0.11775724f, 0.06801674f, -0.09253157f, -0.23942606f, 0.07965870f, 0.14925766f, 0.02213266f, 
    0.38324407f, 0.24797381f, 0.30720711f, 0.50543880f, 0.11492166f, 0.12178990f, 0.03879891f, -0.00171803f, 
    0.11653931f, 0.03053745f, -0.00349273f, -0.03427247f, 0.20989284f, 0.24826919f, 0.12132812f, 0.04866431f, 
    0.07062895f, -0.14407556f, 0.03184339f, -0.04692781f, -0.06682852f, 0.04934468f, 0.06228000f, -0.16355430f, 
    0.15806438f, 0.41430518f, -0.01159035f, 0.46869519f, 0.30126074f, 0.01512444f, 0.01374327f, -0.01747354f, 
    -0.04392904f, -0.06766246f, 0.02647222f, -0.04456683f, 0.41464138f, -0.04857124f, 0.31425443f, -0.27091363f, 
    -0.07491556f, -0.10637725f, -0.12460300f, -0.24994940f, -0.03874041f, 0.21516578f, -0.37968588f, 0.00879998f, 
    0.32820565f, 0.12166528f, 0.23809724f, 0.36080584f, 0.25618899f, -0.28171289f, -0.00359708f, -0.19520836f, 
    -0.24978685f, 0.15396564f, -0.03740000f, -0.09747987f, 0.18971889f, -0.37675220f, -0.20284726f, -0.46786121f, 
    -0.16231407f, 0.00156894f, -0.07766212f, -0.15788864f, -0.15597518f, -0.08519393f, -0.07972145f, 0.10344538f, 
    -0.32963419f, -0.15530957f, -0.19890228f, -0.13884635f, -0.17930400f, -0.08482090f, 0.04758271f, -0.04051124f, 
    -0.03876913f, 0.08427338f, -0.14915922f, -0.05538377f, -0.29318812f, 0.07728880f, -0.01356635f, -0.13074738f, 
    -0.15872321f, 0.08386634f, -0.05079775f, -0.47099224f, 0.02669775f, 0.01277427f, -0.17187117f, -0.18826416f, 
    0.14747041f, 0.40761977f, 0.28707969f, 0.33936107f, 0.32909253f, 0.31125799f, 0.15798648f, 0.08685046f, 
    -0.09757789f, -0.04245966f, -0.00091269f, 0.04831962f, -0.53081399f, 0.13148163f, -0.26878947f, -0.15731102f, 
    -0.10968024f, 0.06376046f, 0.03181076f, -0.04233583f, 0.06011092f, 0.00899739f, 0.08976567f, -0.15423591f, 
    -0.07908469f, 0.67525089f, -0.12744458f, -0.29876891f, -0.03467771f, -0.01617680f, -0.17509682f, 0.03992608f, 
    0.16046230f, 0.11524679f, -0.15347379f, -0.02413189f, 0.39437991f, -0.03283887f, 0.17685637f, 0.09756169f, 
    -0.06582080f, -0.13375917f, 0.00323999f, -0.11686511f, 0.11500932f, -0.31926587f, -0.13563624f, -0.13263054f, 
    -0.30333394f, -0.14911836f, -0.35288674f, -0.34943825f, 0.21139370f, -0.01909757f, 0.01212896f, 0.16689117f, 
    0.12003984f, 0.15726680f, -0.09506122f, 0.25418431f, 0.34803808f, -0.29555249f, 0.01839304f, 0.36241615f, 
    0.19059969f, 0.00579967f, -0.21555269f, -0.02794153f, -0.07218210f, -0.12229249f, 0.31774265f, -0.25217137f, 
    -0.23268440f, -0.02943897f, 0.02681627f, 0.08683407f, 0.08395248f, -0.07478987f, -0.01662830f, 0.07254539f, 
    0.00305386f, -0.01008831f, -0.00526247f, -0.25335750f, -0.17570896f, -0.36954230f, 0.09678090f, 0.38690209f, 
    0.14306079f, -0.18302786f, -0.20480941f, 0.00898227f, 0.09146548f, -0.07694846f, 0.36992198f, -0.42691085f, 
    0.27236280f, 0.03349522f, 0.16685790f, -0.16793144f, -0.05789274f, 0.12662664f, 0.18698503f, -0.16181326f, 
    -0.22078431f, -0.05491652f, -0.30910668f, 0.08864319f, 0.19436274f, -0.31874016f, 0.37101012f, -0.07829789f, 
    -0.31465742f, -0.40115252f, 0.04960391f, 0.16630532f, 0.09697349f, 0.07560339f, 0.10062920f, 0.07960001f, 
    -0.42382309f, 0.17098506f, 0.00268331f, -0.21612540f, 0.01706298f, 0.09937899f, -0.26578724f, 0.10506097f, 
    -0.03215315f, -0.12746367f, 0.07835818f, -0.04243148f, -0.58771366f, 0.13499634f, -0.28516352f, -0.49968582f, 
    0.01001825f, 0.05141203f, 0.11864727f, -0.08990202f, 0.05112526f, -0.05480044f, -0.05971038f, 0.07865458f, 
    -0.10047216f, 0.15709323f, 0.09848201f, -0.17219937f, 0.05962227f, -0.05747272f, -0.17228188f, -0.05289255f, 
    0.32402837f, -0.00163040f, -0.00569689f, 0.21152762f, 0.26878968f, -0.39586130f, 0.09245813f, 0.08902103f, 
    0.05888566f, -0.19037265f, -0.09698340f, -0.25917059f, -0.12175639f, -0.19089077f, -0.18311550f, -0.09838586f, 
    0.30798236f, 0.45602232f, -0.46260229f, -0.05315349f, 0.10092089f, -0.15131699f, 0.17698607f, -0.11287338f, 
    0.21021862f, 0.06290209f, -0.04780578f, -0.01317787f, -0.11438071f, 0.50431883f, 0.13285425f, 0.20582448f, 
    -0.42099008f, -0.02331938f, -0.16688775f, -0.21823914f, 0.03642307f, 0.04802072f, 0.10487314f, -0.05701141f, 
    -0.06458265f, -0.38090780f, 0.34553337f, 0.08082848f, -0.26467177f, -0.26250947f, -0.17952195f, -0.11085922f, 
    -0.10246643f, -0.20171185f, -0.28275120f, -0.28286788f, 0.15011233f, -0.00069102f, 0.12192189f, 0.33913869f, 
    0.00731678f, -0.05504378f, 0.02855898f, -0.13423215f, -0.10786971f, 0.24013340f, -0.11085424f, 0.27671313f, 
    -0.08442101f, 0.04728127f, 0.66083503f, 0.31151000f, -0.23297611f, 0.21940079f, -0.06385349f, -0.05507229f, 
    0.02375768f, -0.14440022f, -0.06188823f, 0.13019548f, -1.09993088f, 0.86269653f, -0.28339174f, -0.09048880f, 
    0.18745817f, -0.05995295f, -0.02617746f, -0.14678806f, -0.20382090f, -0.00987872f, 0.05865185f, 0.06438987f, 
    -0.01728327f, -0.00091507f, 0.08590594f, -0.67875558f, 0.05301870f, 0.01066187f, -0.09157734f, -0.05416067f, 
    0.00145301f, -0.10398328f, 0.16181208f, -0.18934399f, -0.22123241f, 0.09391862f, -0.01316224f, -0.21014884f, 
    0.09244481f, 0.00499761f, -0.00960659f, -0.10591641f, 0.03102998f, 0.12877506f, -0.15213110f, -0.12439604f, 
    0.67357576f, -0.10322969f, -0.23901473f, 0.28650975f, -0.08750148f, 0.05634587f, -0.10433911f, -0.05154342f, 
    -0.00351175f, -0.14012080f, -0.05306127f, -0.15774745f, -0.60233462f, 0.43807268f, -0.22747268f, -0.55288541f, 
    0.17732218f, 0.00433972f, -0.26119453f, 0.01283143f, -0.02557601f, 0.18399192f, -0.19212151f, 0.14645699f, 
    0.07236864f, 0.19923007f, -0.05765746f, 0.04746241f, 0.22495651f, -0.24506329f, -0.10173717f, 0.03455131f, 
    -0.11722237f, -0.02712898f, 0.23404412f, 0.15728882f, -0.36050034f, -0.34953085f, 0.07861008f, -0.36055702f, 
    0.24268693f, 0.22834826f, -0.13568902f, -0.05240197f, 0.08459798f, 0.01149192f, -0.17543799f, -0.13962610f, 
    -0.42607373f, -0.32380250f, 0.42018062f, -0.39704508f, 0.08590270f, 0.16433537f, -0.12019854f, 0.16115975f, 
    -0.07057586f, -0.01475207f, -0.19836199f, 0.05808564f, -0.08476879f, -0.21693259f, -0.29259536f, 0.03667448f, 
    -0.13315378f, 0.22253822f, -0.02321390f, -0.02903436f, -0.02105835f, 0.14253797f, 0.24751969f, -0.10931858f, 
    -0.12896498f, -0.51206857f, -0.20589222f, 0.31383759f, 0.13205242f, -0.01959747f, 0.05846096f, 0.00212842f, 
    -0.14416520f, -0.01905018f, 0.34055546f, 0.20388156f, 0.03034710f, -0.12364142f, 0.15653020f, -0.24367985f, 
    -0.05846808f, 0.02602428f, -0.04792166f, 0.06017206f, 0.13028987f, 0.06186579f, -0.22271249f, 0.26021609f, 
    -0.03324176f, 0.30409470f, 0.09414710f, 0.01317281f, 0.08823247f, 0.24676280f, 0.22686373f, -0.02418481f, 
    0.08260437f, 0.09763328f, 0.27328530f, 0.06206492f, 0.06477961f, 0.77434576f, -0.03537741f, 0.20562460f, 
    0.02143792f, 0.00961124f, -0.15276113f, 0.32447702f, 0.18903299f, -0.08252838f, -0.07853562f, -0.01154502f, 
    -0.28455353f, -0.18633720f, -0.09160683f, -0.10583106f, 0.14166319f, 0.03708886f, -0.03694994f, -0.01443084f, 
    0.00901205f, 0.17267506f, -0.01366927f, 0.10833304f, -0.19635378f, 0.25864911f, -0.29212743f, -0.27493045f, 
    0.26726606f, -0.06930076f, -0.02126823f, -0.07426687f, -0.38576064f, -0.17466690f, 0.03417525f, -0.31305078f, 
    -0.13313483f, -0.05192313f, 0.02632915f, -0.06366108f, 0.03428041f, 0.27735645f, -0.07058030f, -0.11895005f, 
    0.16441998f, -0.03727209f, 0.00586347f, 0.01942629f, 0.22820732f, -0.19255000f, -0.06363652f, 0.29147354f, 
    0.02772522f, -0.23613620f, 0.02852156f, 0.02228538f, 0.03078837f, -0.14642607f, 0.08143391f, 0.00856633f, 
    0.30139172f, 0.29902580f, 0.17301306f, -0.26776007f, 0.15009567f, 0.08988388f, 0.08478613f, 0.07125309f, 
    0.10803901f, 0.03941492f, 0.12185879f, 0.16581574f, -1.66216862f, -0.51003778f, -0.40100563f, -0.52361953f, 
    0.10286330f, 0.01404692f, -0.36584502f, -0.05743778f, 0.05768442f, 0.07389677f, 0.08149425f, 0.12351455f, 
    0.65475172f, -0.09864108f, 0.03958329f, 0.25772023f, -0.15603657f, -0.44466186f, 0.13751112f, 0.08651343f, 
    -0.03751180f, 0.21635687f, -0.09301978f, -0.08208358f, -0.85805380f, -0.30164900f, -0.12323533f, -0.71912944f, 
    0.10051343f, -0.20408903f, -0.08981504f, -0.21377115f, 0.07214741f, -0.39033726f, -0.14486435f, -0.33102879f, 
    0.01141027f, -0.04714468f, 0.10301556f, -0.03847963f, -0.01311128f, 0.08058988f, 0.05338525f, 0.05786602f, 
    0.20285437f, 0.36519065f, -0.00360813f, 0.00165752f, 0.53154248f, 0.05534931f, -0.19307904f, 0.18679248f, 
    0.05402672f, -0.28274262f, 0.01992048f, 0.06645656f, 0.20665148f, 0.50071108f, 0.07167565f, 0.16208200f, 
    0.12176123f, 0.14982562f, -0.02347158f, -0.21549827f, -0.13080037f, 0.11652710f, -0.04953953f, -0.13342093f, 
    0.14999740f, 0.10188916f, -0.14554437f, -0.14970239f, 0.17480791f, -0.13997895f, -0.09256237f, 0.04431270f, 
    0.00335930f, 0.19134839f, 0.06948133f, 0.18672679f, -0.01120187f, -0.23830730f, -0.07797711f, 0.01117127f, 
    -0.39242527f, -0.05955870f, -0.52171075f, 0.02164985f, 0.11024564f, 0.16245818f, 0.20513795f, 0.09920541f, 
    0.08431237f, 0.13076694f, 0.09695564f, -0.12222848f, -0.15784618f, -0.27803120f, -0.06220997f, -0.29987669f, 
    0.22178023f, 0.28875938f, -0.07428740f, -0.09687788f, 0.04531233f, -0.02109432f, -0.10848291f, 0.00480369f, 
    -0.97171545f, -0.46342412f, 0.04500078f, 0.52548194f, 0.28018296f, -0.02015988f, 0.09404960f, -0.01181066f, 
    -0.05395184f, -0.13970375f, 0.09392162f, 0.07099885f, -0.08478295f, 0.04088191f, -0.25365782f, 0.20699710f, 
    0.14046799f, 0.01194730f, 0.15199208f, 0.20461488f, 0.16122271f, -0.05270163f, 0.12366972f, 0.08086571f, 
    0.55958271f, 0.31028876f, -0.28571641f, -0.05919072f, -0.39074582f, -0.40053776f, 0.03348480f, -0.10298793f, 
    -0.07577228f, -0.06927177f, 0.02094243f, -0.06083428f, -0.95535111f, -0.45245627f, -0.10266902f, -0.53061128f, 
    -0.07950028f, 0.03514576f, 0.06985714f, -0.02334086f, 0.14952300f, 0.28535888f, 0.06419734f, 0.39617071f, 
    0.18361211f, 0.03405962f, -0.43240830f, -0.15763134f, 0.13398269f, -0.31773865f, -0.08874661f, -0.12627555f, 
    -0.07859378f, 0.26574954f, 0.00291791f, 0.14259860f, -0.04466479f, -0.44114318f, 0.32690772f, -0.21630593f, 
    0.29790840f, 0.08674669f, 0.11881725f, -0.03297772f, -0.12196132f, 0.12834039f, 0.16520803f, 0.13583981f, 
    0.85134625f, 0.12594236f, -0.39409590f, 0.41707531f, 0.10209352f, -0.14728606f, 0.05775895f, 0.19726603f, 
    0.11857858f, -0.08989790f, 0.07491238f, 0.00955518f, 0.63521069f, -0.34030801f, -0.26847133f, -0.41168523f, 
    -0.04674729f, -0.08167332f, -0.09776886f, 0.10220810f, 0.01118050f, -0.08037994f, -0.31335500f, 0.04733863f, 
    -0.14375594f, -0.06698070f, 0.48682767f, -0.05564921f, 0.03275758f, -0.04926783f, 0.09293362f, -0.04033971f, 
    0.01209034f, -0.14486536f, 0.14808275f, 0.29417562f, 0.09047995f, -0.21383199f, -0.26375544f, -0.02441675f, 
    -0.02707619f, 0.01580654f, -0.11785854f, -0.08924609f, 0.22799300f, -0.00658660f, 0.03052197f, -0.01802700f, 
    -0.18094856f, -0.26716167f, 0.14071079f, 0.38079345f, -0.12356772f, -0.06249990f, -0.05136007f, 0.10281610f, 
    -0.17271145f, 0.12409674f, 0.40761912f, -0.10786419f, 0.37701029f, 0.12087513f, 0.16496195f, -0.13195585f, 
    0.01310171f, 0.05744623f, -0.03605250f, -0.04113005f, -0.05408170f, -0.21436961f, -0.28521785f, -0.04373561f, 
    0.51743883f, -0.08583891f, -0.51897961f, 0.33367586f, -0.37168133f, -0.09625483f, -0.27640593f, -0.18876855f, 
    0.15162723f, -0.11422437f, -0.19602181f, -0.07087570f, -0.39020887f, 0.44860387f, -0.10643457f, 0.02936735f, 
    0.36458409f, -0.22196315f, 0.33775494f, -0.24492347f, -0.07636423f, 0.03691040f, 0.02338351f, 0.01153785f, 
    -0.56628972f, -0.20356789f, 0.12473417f, -0.00887851f, -0.23318015f, 0.29968214f, -0.07180604f, -0.09527641f, 
    0.12098899f, -0.14316270f, -0.02467061f, 0.08410936f, 0.10000439f, 0.04478461f, -0.25624800f, -0.47151574f, 
    0.23352857f, -0.08123191f, -0.15046749f, 0.06741101f, 0.07259633f, 0.04863799f, 0.07050790f, -0.02344490f, 
    0.35361403f, -0.37724698f, 0.18053074f, 0.06003712f, 0.17848121f, -0.25441077f, -0.01441987f, -0.20609146f, 
    0.02993380f, 0.05849064f, 0.01335267f, -0.07720336f, 0.04638091f, -0.30674627f, -0.12410191f, 0.14063577f, 
    -0.07928293f, -0.10904753f, 0.08131564f, 0.13732563f, -0.09586997f, 0.13155848f, -0.21026173f, -0.16588929f, 
    -0.22334056f, -0.22060645f, -0.03816241f, 0.17071186f, -0.23303542f, 0.26299530f, -0.08790214f, -0.07626656f, 
    -0.25917739f, 0.05556740f, -0.10019483f, -0.21712317f, 0.32740313f, -0.65472013f, 0.05904511f, -0.05299915f, 
    0.11357902f, 0.05047626f, -0.00796042f, 0.10436227f, -0.23598926f, -0.03367461f, 0.00144141f, -0.10431461f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.09304721f, 0.01218204f, -0.10624876f, 0.05730467f, -0.04657071f, 0.03994452f, -0.06402105f, -0.16713357f, 
    -0.06193629f, 0.08874160f, 0.25938681f, 0.00938429f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
