#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.27824259f, 0.12532194f, -0.09503260f, -0.09679660f, 0.23235345f, 0.30201012f, -0.21525092f, -0.54336077f, 
    -0.43168604f, -0.48339128f, 0.19549304f, -0.38296941f, 0.43022940f, -0.44800502f, -0.17959841f, 0.20393768f, 
    -0.12717794f, 0.11486646f, -0.08853229f, 0.14100628f, 0.05090772f, -0.12653694f, -0.10983018f, 0.17106177f, 
    -0.09271988f, 0.25822085f, 0.50682515f, 0.36664087f, 0.44457966f, 0.31706211f, -0.19029853f, 0.02955612f, 
    0.02243881f, -0.02282858f, -0.00448263f, 0.17925976f, 0.09940622f, 0.13488089f, -0.17689225f, 0.02621758f, 
    -0.17029613f, 0.01450751f, -0.02191553f, 0.19765206f, -0.25887123f, -0.10363615f, -0.04588889f, -0.11788526f, 
    -0.05999751f, -0.29085493f, 0.34434205f, -0.75430673f, -0.09812742f, 0.64208353f, -0.17215568f, -0.02837954f, 
    0.34407696f, -0.70619065f, -0.54189795f, 0.24917597f, 0.19381152f, -0.13566530f, -0.07939189f, -0.10397132f, 
    0.52690363f, -0.28542078f, 0.09490945f, -0.09736669f, 0.11114392f, -0.19724257f, 0.17863943f, -0.10944512f, 
    -0.03499323f, 0.16732872f, -0.15184435f, -1.11707509f, -0.22492215f, -0.41600272f, -0.70471203f, -0.14138378f, 
    -0.03881236f, 0.00656105f, 0.64785272f, 0.59444475f, 0.01996754f, 0.05303673f, 0.37073311f, -0.06645314f, 
    0.24298289f, -0.23561276f, 0.10841778f, 0.12043394f, 0.05867442f, -0.14557613f, 0.08768743f, 0.17409436f, 
    0.05526661f, 0.17199236f, -0.10068218f, -0.05517299f, 0.35715318f, -0.57475114f, -0.40325293f, 0.43503332f, 
    -0.44988465f, 0.28831989f, 0.49750814f, 0.37646922f, -0.25293133f, -0.42719874f, 0.38296026f, 0.16984236f, 
    0.16213202f, 0.09787333f, 0.20182250f, 0.22159106f, -0.33974645f, 0.06418308f, 0.26046792f, -0.11701944f, 
    -0.00246609f, 0.23227473f, -0.05093037f, -0.00589502f, -0.15337041f, -0.11462457f, -0.57100540f, -0.46333608f, 
    0.03396482f, 0.47060972f, -0.29555234f, -0.54211223f, -0.30839512f, -0.18585199f, -0.30586773f, 0.09194636f, 
    0.19321936f, -0.11098102f, 0.09287327f, -0.34885097f, 0.15051696f, -0.06361714f, -0.20124213f, -0.13738097f, 
    -0.30227062f, -0.31682152f, 0.19103195f, 0.06064376f, -0.26779833f, -0.00920027f, -0.00897600f, -1.05261421f, 
    0.33043438f, 0.60249501f, 0.60854548f, -0.18960235f, -0.43691036f, 0.31098339f, -0.48875287f, -0.14058194f, 
    -0.06648479f, -0.31571195f, 0.09561510f, -0.22126755f, -0.01871211f, -0.25434303f, 0.02454966f, 0.23964970f, 
    0.17374049f, 0.25437793f, -0.02646228f, 0.15180668f, -0.18604968f, -0.08255363f, 0.09908270f, -0.53237170f, 
    -0.23089845f, -0.18010463f, 0.51785076f, 0.63355327f, 0.78043306f, -0.40018919f, -0.21491633f, 0.36047357f, 
    0.39474750f, 0.12383541f, 0.15003279f, -0.06473948f, 0.03204941f, 0.19858837f, -0.41479591f, -0.04444873f, 
    -0.11734339f, -0.13393158f, 0.19222420f, 0.15263170f, -0.10416292f, 0.16638038f, -0.00982825f, -0.04483388f, 
    -0.16779329f, -0.46425530f, -0.35734782f, -0.18349807f, -0.39039394f, -0.15397166f, -0.21428509f, -0.27288958f, 
    -0.05290755f, 0.14442657f, 0.26368010f, 0.46568230f, 0.03161357f, -0.11614301f, -0.17591345f, -0.13380648f, 
    -0.05242693f, 0.05101289f, 0.30520669f, 0.06953578f, -0.15091643f, 0.02679871f, -0.21860430f, -0.40681371f, 
    -0.25030884f, -0.09408872f, -0.57535547f, 0.00098736f, 0.23646137f, -0.36678818f, -0.56649727f, -0.24206966f, 
    -0.43676069f, -0.13491021f, -0.24683353f, 0.01006934f, -0.12437668f, 0.03673800f, 0.19750254f, 0.24121180f, 
    0.10118805f, -0.23547471f, 0.16567971f, -0.17177008f, 0.07005136f, -0.03789815f, 0.11688741f, -0.09993564f, 
    0.14083037f, 0.40389693f, -0.67267036f, -0.45934239f, -0.31158939f, -0.30315474f, -0.63924390f, 0.54611337f, 
    0.34122768f, -0.34995613f, -0.25418109f, 0.18847592f, -0.17864142f, -0.32299453f, -0.31420204f, -0.21636103f, 
    -0.17643435f, -0.04275405f, 0.01163510f, -0.13308652f, -0.08464701f, -0.16146220f, -0.00554132f, -0.16704637f, 
    0.06533272f, 0.00063789f, -0.02050946f, 0.26367208f, -0.16435233f, 0.32264602f, 0.30902380f, 0.10349362f, 
    -0.01003755f, -0.32835540f, 0.18375750f, 0.24421756f, 0.10885641f, 0.42589068f, -0.47755241f, -0.04717305f, 
    0.06254531f, 0.06940004f, -0.13114004f, 0.09374615f, -0.08521754f, 0.16159998f, -0.39796492f, -0.00322595f, 
    0.01345521f, -0.13178147f, 0.37448707f, 0.05062071f, 0.52632833f, -0.03624000f, -0.01233687f, 0.18330857f, 
    -0.00675414f, 0.15479606f, 0.13103740f, -0.00002992f, -0.26010418f, -0.36266741f, -0.01316923f, 0.16896068f, 
    -0.16198570f, -0.34861049f, 0.16866134f, -0.07993349f, 0.18062329f, 0.15268651f, -0.16389354f, -0.19477719f, 
    -0.06759490f, -0.29109010f, 0.29607180f, 0.35160232f, 0.35117307f, 0.28323326f, 0.92198914f, -0.43765640f, 
    -0.34879333f, -0.65055931f, -0.27253342f, 0.03891911f, 0.29008120f, 0.04060952f, 0.03890615f, -0.01965287f, 
    0.03536969f, 0.30727541f, 0.30238679f, -0.23545910f, 0.10147502f, -0.14181003f, -0.23396079f, 0.01642802f, 
    -0.27787688f, 0.34826002f, 0.12216038f, -0.18252839f, 0.10942238f, -0.00080429f, 0.32645831f, -0.73712993f, 
    -0.39285249f, -0.09730336f, 0.14195900f, -0.04213862f, 0.28472134f, 0.60153419f, -0.38632920f, -0.05874602f, 
    -0.19851823f, 0.03980858f, 0.24309409f, -0.28455111f, 0.12049554f, 0.07072429f, 0.09375537f, 0.13259666f, 
    -0.12319904f, 0.19418271f, -0.19790874f, -0.26595300f, -0.08235799f, 0.33546570f, -0.05851828f, -0.70595002f, 
    0.76694578f, 0.07893406f, 0.21419132f, -0.14506979f, -0.08502902f, -0.03014181f, -0.01406811f, 0.07600325f, 
    0.02846731f, 0.00303559f, -0.23937283f, -0.17849241f, -0.19983613f, 0.07344693f, -0.01677970f, 0.05032314f, 
    -0.09666419f, -0.10033256f, -0.16642928f, -0.28864428f, 0.06410696f, -0.19907795f, -0.33768350f, -0.46642926f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.12633564f, -0.24201916f, 0.20675294f, 0.19321693f, -0.29063371f, -0.02957310f, 0.04658058f, 0.22284953f, 
    -0.23896702f, 0.12681250f, -0.26849559f, 0.39215589f, 0.23502216f, 0.05785454f, 0.17461711f, -0.04344228f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.00867562f, 0.31623533f, 0.08482166f, -0.25068557f, 0.08925105f, -0.15641329f, -0.06226450f, -0.04038466f, 
    -0.02431728f, 0.03183909f, -0.03728224f, -0.01215243f, 0.06347094f, 0.06023771f, 0.03401214f, 0.14714079f, 
    -0.02079596f, -0.08531371f, -0.09950139f, -0.06067120f, -0.05846299f, -0.17281291f, 0.02555293f, -0.09157028f, 
    0.18334764f, -0.22504370f, 0.30954781f, -0.28794384f, 0.01072513f, -0.04242034f, 0.06856941f, 0.16849194f, 
    0.05369500f, 0.03048299f, 0.02797424f, 0.00806939f, -0.40438467f, -0.30568862f, -0.42987913f, -0.02759406f, 
    0.16477875f, 0.03081184f, 0.04461804f, 0.01221896f, 0.12979430f, -0.06254746f, 0.03722427f, -0.02489596f, 
    0.33577091f, -0.40319589f, -0.14984909f, -0.30601749f, 0.02167561f, -0.06596968f, 0.06959575f, -0.04553155f, 
    0.05805252f, 0.15422435f, -0.02958101f, -0.01475917f, 0.06310552f, 0.18065365f, 0.19501500f, -0.03636976f, 
    0.04394300f, 0.06697895f, 0.16642433f, -0.05247884f, 0.09972426f, -0.08683664f, -0.02762258f, 0.15061945f, 
    0.25314772f, -0.08040692f, -0.12706326f, -0.24696365f, -0.07817546f, -0.00717097f, 0.10760630f, -0.04795050f, 
    -0.05532365f, 0.13584186f, -0.07441562f, -0.13265206f, 0.23281823f, -0.22999853f, -0.01760736f, 0.19101815f, 
    -0.15784846f, 0.02008865f, -0.11946119f, -0.05176951f, 0.17431363f, 0.04652429f, 0.03029567f, 0.02293290f, 
    -0.13146773f, 0.14389512f, 0.00101255f, 0.00152570f, -0.10996085f, 0.12956281f, 0.02344032f, 0.16804531f, 
    -0.02839280f, -0.16319817f, 0.00856470f, -0.10793275f, 0.07781063f, 0.06226892f, 0.19395338f, -0.04433837f, 
    0.14787158f, 0.13439041f, 0.00806995f, 0.02852558f, 0.04708701f, 0.03662832f, 0.02379758f, 0.12127186f, 
    0.19188574f, 0.24973786f, 0.14743824f, -0.28598985f, 0.07260138f, 0.09664610f, 0.11406066f, 0.25499374f, 
    0.16400245f, -0.03370580f, -0.04792407f, -0.00061422f, 0.09930485f, 0.15268527f, 0.15137358f, 0.13796659f, 
    -0.09616375f, 0.09066403f, -0.10982872f, -0.25236884f, 0.08043306f, -0.07805702f, 0.16856621f, 0.04505232f, 
    0.21902272f, -0.10794576f, 0.06433076f, -0.00711145f, 0.02875212f, 0.01423151f, 0.00299375f, -0.12599647f, 
    0.20177223f, -0.00819716f, 0.05496112f, 0.05527986f, -0.08195342f, 0.00719619f, 0.05719956f, -0.23120168f, 
    0.03238932f, 0.00267924f, 0.01669082f, 0.01319795f, 0.07401219f, -0.05665962f, 0.16898353f, 0.06587587f, 
    0.20258610f, -0.54215735f, -0.14584439f, -0.02766860f, 0.04263425f, -0.09928578f, 0.14362092f, 0.06058976f, 
    0.14192431f, 0.03282164f, 0.02614480f, 0.05340353f, -0.21811737f, -0.02133589f, 0.06492952f, 0.09858847f, 
    0.10456633f, -0.02298626f, 0.05370664f, -0.03227621f, -0.00850889f, -0.22873501f, -0.14464140f, -0.07218652f, 
    -0.03919556f, -0.09476405f, -0.03750568f, 0.06955444f, 0.11418159f, 0.06140360f, 0.01602414f, -0.11092778f, 
    -0.02180148f, 0.15570082f, -0.07281714f, -0.08224374f, 0.13393818f, 0.06485481f, 0.01208215f, -0.04261408f, 
    0.01544419f, 0.07604514f, 0.08217924f, 0.11080797f, -0.09658740f, -0.20607834f, -0.09327295f, -0.19539000f, 
    0.27239937f, -0.54472297f, 0.01433434f, -0.28186134f, 0.07680873f, 0.10922690f, 0.09691197f, -0.12358712f, 
    0.02172821f, 0.05567259f, 0.07363648f, -0.10912025f, -0.24886771f, -0.11757772f, -0.03698846f, 0.01818058f, 
    0.00760244f, 0.00704117f, 0.05181994f, 0.05553104f, 0.21149306f, 0.05754313f, -0.03894448f, 0.12167463f, 
    0.06211787f, 0.12501089f, 0.00859193f, -0.23980685f, 0.01882617f, -0.02443888f, -0.05545350f, -0.21698524f, 
    0.02052114f, -0.02207336f, -0.05758148f, 0.00169482f, 0.02471855f, -0.05743360f, 0.02280698f, -0.10937379f, 
    -0.08479285f, 0.01869434f, -0.01072168f, -0.04739973f, 0.04044770f, 0.00100314f, -0.07692302f, -0.01899527f, 
    0.16140601f, -0.08591014f, -0.08060549f, 0.03898427f, 0.14677736f, 0.03539920f, 0.19355631f, -0.12904507f, 
    0.02114438f, 0.01194847f, 0.01083142f, 0.05908517f, 0.10299120f, -0.01897520f, 0.41749650f, -0.00324771f, 
    -0.06933460f, -0.06979406f, -0.02703761f, -0.01014366f, 0.10762274f, 0.00622046f, 0.41050041f, 0.22553618f, 
    -0.03408431f, -0.07362954f, 0.27123806f, -0.05005504f, -0.07761002f, 0.15897393f, 0.06138485f, 0.07648500f, 
    -0.00776764f, 0.08676999f, -0.10776540f, -0.00455051f, 0.11823504f, -0.31769767f, -0.16263802f, -0.09880794f, 
    0.20591238f, 0.08502435f, 0.06563404f, -0.06621476f, 0.06234256f, -0.00737926f, 0.04991064f, 0.05007355f, 
    -0.26937205f, -0.18854438f, -0.41790450f, -0.34872830f, -0.16190526f, 0.01359605f, -0.03050529f, 0.06177663f, 
    -0.06261951f, 0.04526752f, 0.27154261f, 0.06949401f, 0.28572980f, 0.08152551f, 0.05245452f, -0.00170812f, 
    -0.00046569f, 0.09131835f, -0.01483863f, -0.02815272f, -0.02802740f, 0.00914192f, -0.02852168f, 0.07027847f, 
    -0.16657612f, -0.12533839f, 0.13261795f, -0.15628095f, 0.40580434f, 0.04932195f, 0.00769113f, 0.06006272f, 
    -0.00599302f, 0.04545988f, -0.05812458f, 0.09106147f, 0.15399137f, 0.47797236f, -0.23173302f, -0.05920346f, 
    0.04986621f, -0.03658383f, -0.00504734f, -0.02839409f, 0.12944269f, 0.23369774f, 0.21931350f, 0.02841108f, 
    -0.03692657f, 0.06647231f, -0.31328833f, -0.01949287f, -0.02894450f, -0.03097325f, 0.17963186f, 0.15540828f, 
    0.17928272f, -0.13155033f, 0.05447553f, 0.12691244f, -0.01222531f, 0.03674787f, 0.14199591f, 0.09826812f, 
    -0.07798966f, -0.00425148f, 0.06883038f, -0.03238617f, -0.03204866f, 0.05476626f, 0.01861421f, -0.07965633f, 
    0.13751628f, 0.09262102f, 0.18944313f, -0.04774155f, 0.04014175f, 0.06835043f, -0.08686555f, -0.02329335f, 
    0.04343195f, -0.11098991f, 0.05722674f, -0.08403751f, -0.54726213f, -0.33445776f, -0.24699867f, -0.18277416f, 
    0.08005423f, 0.00326201f, -0.10426814f, -0.11798320f, -0.00937042f, -0.00821555f, 0.08489542f, 0.05790504f, 
    0.24683587f, -0.00627712f, 0.35179618f, -0.05810511f, 0.12081383f, 0.03331892f, -0.03458264f, 0.17110294f, 
    0.07051698f, 0.00561290f, 0.02675205f, 0.04022545f, 0.10728256f, 0.10104375f, 0.10939533f, 0.10085536f, 
    -0.09901877f, 0.08245574f, 0.09251341f, 0.08855288f, -0.00575063f, 0.10647303f, -0.12494022f, 0.02921280f, 
    -0.06002153f, -0.17418602f, -0.01794698f, -0.03256189f, 0.12131742f, -0.06947904f, 0.07737640f, -0.04180287f, 
    0.08159932f, -0.06341363f, -0.11142201f, 0.11634301f, 0.14093281f, 0.06559351f, 0.29603156f, -0.10497217f, 
    0.08288971f, -0.00741818f, -0.06689147f, 0.00053731f, 0.06726792f, -0.09371968f, 0.02223850f, 0.02186271f, 
    0.22107577f, -0.29012758f, 0.18302201f, 0.06923839f, -0.02833954f, 0.07735714f, -0.06544571f, 0.11776144f, 
    -0.04813398f, 0.09870066f, -0.11444232f, 0.06890712f, -0.18215491f, -0.08978038f, -0.03161642f, -0.18874481f, 
    -0.19238371f, -0.12236673f, -0.06120602f, 0.02364486f, -0.08356493f, -0.06334231f, -0.07564981f, 0.20452249f, 
    0.04221034f, 0.07752273f, 0.15199187f, 0.15591879f, 0.13734832f, -0.00643510f, 0.05382544f, 0.20142451f, 
    -0.10659248f, -0.07355705f, -0.01488047f, -0.22843707f, 0.10963096f, 0.17168388f, 0.27084625f, 0.23351696f, 
    0.12327450f, 0.29358444f, 0.08845847f, 0.04378977f, 0.09690784f, 0.03142845f, -0.06772978f, 0.03454715f, 
    -0.18452917f, 0.03207249f, 0.09749772f, 0.06326289f, -0.04354933f, -0.03999038f, 0.05973399f, 0.08938702f, 
    0.01599548f, 0.01034565f, -0.09201714f, -0.12697875f, -0.15045252f, -0.29013234f, -0.09150577f, -0.16573805f, 
    -0.04605248f, -0.04917515f, 0.06788163f, 0.07543603f, -0.09302319f, 0.11888348f, 0.15745962f, -0.04596562f, 
    -0.08065013f, -0.04930869f, 0.02325697f, -0.07266095f, 0.05669025f, -0.05734273f, 0.03306011f, 0.10224556f, 
    0.08900386f, 0.02517916f, 0.22117428f, 0.01434069f, 0.09576342f, 0.12578022f, -0.04535392f, 0.09350734f, 
    -0.05007065f, 0.06791335f, 0.09622988f, 0.00794436f, -0.04703260f, -0.07638548f, -0.23538676f, -0.04757743f, 
    0.07451678f, -0.14098729f, 0.05001785f, -0.06625333f, 0.01027980f, 0.14155278f, -0.11301830f, 0.01919288f, 
    -0.20146091f, 0.12988415f, 0.03483982f, 0.16777207f, 0.07156376f, -0.11682337f, -0.20551632f, 0.01898681f, 
    0.07306170f, 0.01352960f, 0.06304371f, 0.04266926f, 0.14284314f, -0.11025771f, -0.03409025f, 0.03841743f, 
    0.09887921f, -0.06219400f, -0.00529411f, 0.11477293f, 0.01645322f, 0.04976942f, -0.08414736f, -0.14217953f, 
    -0.02147408f, 0.12388292f, -0.05417000f, 0.13124979f, 0.14439914f, 0.02300201f, 0.00335863f, 0.08734618f, 
    -0.15633038f, -0.05632221f, -0.03509792f, 0.05576798f, 0.06927313f, 0.06152957f, 0.04467828f, 0.22650082f, 
    -0.26413438f, 0.42517847f, -0.49622989f, 0.18400224f, 0.11793559f, -0.02420610f, 0.18586963f, 0.08110363f, 
    -0.03042950f, 0.05248075f, 0.24168825f, -0.07583579f, -0.53381181f, -0.34048286f, 0.09296539f, -0.29461947f, 
    0.04955382f, 0.21985459f, 0.14074929f, -0.09296676f, -0.17071274f, -0.05756323f, -0.01154412f, -0.16159329f, 
    0.01456387f, -0.03962890f, -0.15428329f, 0.13511951f, -0.03958434f, 0.04157591f, 0.08118425f, -0.10056986f, 
    0.02192068f, 0.03174654f, -0.00484304f, -0.23020431f, -0.30632225f, 0.00209026f, -0.06689505f, 0.13336101f, 
    0.02904119f, 0.06630239f, -0.12413642f, 0.07498278f, 0.06975603f, 0.09374601f, -0.11903925f, 0.13476481f, 
    0.03279933f, 0.39593166f, 0.34219590f, -0.00162422f, 0.08581533f, 0.06501102f, 0.15585746f, 0.14783829f, 
    0.03738725f, -0.01329477f, -0.03641621f, 0.03821101f, -0.24095114f, 0.21205382f, -0.17896339f, 0.20060384f, 
    0.00517043f, 0.03828041f, 0.10679208f, 0.08917338f, -0.01508859f, -0.04752495f, 0.10408755f, 0.04242893f, 
    0.09110739f, -0.14558427f, 0.00493761f, 0.05095079f, -0.11473569f, 0.07599534f, -0.00822642f, -0.20713395f, 
    0.04734008f, 0.17901653f, -0.05062201f, 0.19354148f, -0.07431181f, 0.06127334f, -0.28476846f, -0.05191622f, 
    -0.00716097f, 0.02981998f, -0.14217934f, -0.15312684f, -0.08608699f, -0.08804858f, -0.11182694f, -0.11745536f, 
    -0.12175311f, -0.15814616f, -0.40822524f, -0.01879811f, 0.19486964f, -0.07001873f, 0.01632055f, -0.04745824f, 
    -0.21274187f, 0.06094760f, 0.05276849f, 0.13900423f, 0.25121334f, 0.20415959f, 0.12446848f, 0.10013293f, 
    0.00706873f, -0.04042989f, 0.01826363f, 0.01405073f, 0.10837776f, 0.05646383f, 0.01989025f, 0.16721335f, 
    0.14050031f, 0.09870183f, 0.02449267f, 0.18855941f, -0.07528711f, -0.04350678f, 0.04555456f, -0.10250964f, 
    -0.18600757f, 0.05008056f, -0.25783798f, -0.06698869f, 0.60502821f, -0.29323861f, -0.03651682f, -0.12567475f, 
    -0.06160862f, 0.04263746f, 0.15697250f, 0.22927518f, 0.08476378f, 0.06371212f, -0.01540514f, -0.02773113f, 
    -0.16865884f, 0.21957305f, 0.00428003f, 0.01927112f, 0.14154880f, -0.01580155f, 0.09588658f, 0.09346184f, 
    -0.13433564f, 0.01357949f, -0.17287970f, -0.08568367f, 0.15281002f, 0.00013148f, 0.12282494f, -0.05664881f, 
    -0.19463435f, 0.05511120f, 0.00659863f, 0.15245460f, -0.01176143f, 0.11610376f, 0.22511765f, -0.04509382f, 
    0.31518266f, 0.40886930f, -0.05180992f, -0.06643108f, 0.08369888f, -0.01938654f, 0.00930380f, 0.06574930f, 
    0.02124958f, 0.21922946f, 0.01856365f, 0.04005821f, -0.19996765f, -0.18172620f, -0.09106696f, 0.32490256f, 
    -0.02236964f, 0.00565844f, -0.18879907f, -0.12075984f, 0.15572678f, -0.05106024f, 0.10703717f, -0.00498597f, 
    0.07817779f, 0.01947533f, -0.01800651f, -0.00790524f, 0.02470595f, -0.19099675f, 0.04609083f, 0.11721504f, 
    -0.00320124f, -0.03981102f, -0.04345544f, 0.12955151f, -0.04273883f, -0.18722172f, -0.03636649f, 0.10508984f, 
    0.06817603f, 0.27359527f, 0.02599173f, -0.04327504f, -0.16210721f, 0.01099809f, -0.04001030f, -0.04756105f, 
    -0.05533180f, 0.00032246f, -0.35353145f, -0.10114822f, -0.01317350f, -0.31419641f, 0.14282228f, -0.05784129f, 
    -0.01768430f, -0.03971794f, 0.11112764f, -0.03695632f, 0.18942723f, 0.03914111f, 0.11369058f, 0.03688813f, 
    0.06623472f, 0.02942183f, -0.00948830f, -0.08336601f, -0.05312188f, 0.10785834f, 0.15809299f, 0.14196481f, 
    0.09491164f, 0.05060621f, -0.00868123f, -0.20271635f, -0.10901818f, -0.04564642f, 0.05237879f, -0.03285082f, 
    0.00512285f, 0.10298186f, -0.01634635f, -0.01059920f, -0.27983537f, -0.28372604f, 0.18475553f, -0.01876179f, 
    0.00515325f, -0.06744386f, -0.05847415f, -0.00844692f, 0.07105637f, 0.09901131f, 0.05869339f, 0.08277972f, 
    0.00227990f, 0.12735616f, 0.05293597f, 0.10920721f, 0.17649645f, 0.14790681f, 0.12252405f, 0.00214829f, 
    0.13350561f, 0.02740334f, 0.21042670f, 0.18703915f, 0.14622827f, 0.12953761f, 0.13848452f, -0.05271744f, 
    0.09613056f, -0.03361708f, 0.11330182f, 0.01015211f, 0.09847633f, 0.10791602f, -0.12118867f, -0.08737959f, 
    0.12639080f, 0.09652729f, 0.13166390f, 0.07272822f, 0.16183797f, 0.09779165f, -0.07786933f, -0.19140971f, 
    0.04165675f, 0.02919855f, 0.09809973f, 0.19142210f, -0.37658182f, -0.30537114f, 0.09660158f, -0.16378060f, 
    0.01213794f, -0.06660576f, -0.04853076f, -0.05690302f, -0.04727712f, 0.01230878f, -0.02366419f, -0.04574509f, 
    0.08444469f, -0.07400362f, -0.18583843f, 0.03281817f, 0.15856709f, -0.08979237f, 0.15007663f, 0.01844396f, 
    -0.10514393f, -0.01307052f, -0.11512799f, -0.24491675f, 0.02537394f, -0.17923577f, -0.04440707f, 0.06521499f, 
    0.14126736f, 0.15465318f, -0.07641700f, -0.07074727f, 0.05412484f, -0.08582926f, 0.10365305f, 0.00916682f, 
    0.14798458f, -0.00554382f, -0.19508380f, -0.10022047f, 0.20268701f, 0.05086626f, 0.17586873f, -0.11647625f, 
    0.00768242f, 0.06032472f, -0.03341102f, -0.01665529f, -0.13890082f, -0.05012305f, -0.08551475f, 0.11680190f, 
    -0.01521463f, -0.09106799f, 0.02995855f, 0.02739836f, 0.09865757f, 0.15993808f, 0.03990110f, 0.16382983f, 
    0.07361367f, 0.04100692f, -0.01414417f, 0.04477841f, 0.00382835f, -0.03578483f, 0.01035511f, -0.04668470f, 
    -0.04415593f, 0.04610255f, 0.02239101f, 0.01819307f, 0.01038294f, -0.18506798f, 0.07694847f, 0.19453272f, 
    0.08213729f, 0.09890526f, 0.00593851f, 0.02993262f, -0.00197067f, 0.02612803f, 0.01863630f, -0.09619002f, 
    0.21973479f, -0.04677651f, -0.03723238f, -0.22651857f, -0.01942197f, -0.03659861f, -0.06319041f, 0.06843939f, 
    0.10808212f, -0.03731622f, 0.10694229f, -0.00692454f, -0.36977240f, -0.23442031f, -0.20561704f, -0.13529694f, 
    0.21506731f, 0.00136968f, -0.21216132f, -0.00606685f, 0.02707068f, -0.04811459f, 0.07656217f, 0.02533078f, 
    0.20576449f, -0.11198143f, -0.25493610f, -0.05060453f, 0.20937394f, 0.06366243f, -0.12164954f, -0.06915337f, 
    -0.08709722f, 0.12042932f, -0.16345666f, -0.04624781f, 0.16431707f, 0.21058048f, -0.01103226f, -0.00538111f, 
    0.22146229f, 0.06915793f, 0.23330247f, 0.07998626f, 0.06085166f, 0.04371407f, -0.04804724f, 0.13022910f, 
    0.08864033f, -0.25513160f, 0.02549595f, -0.21414632f, 0.10167173f, 0.02527803f, 0.14266942f, 0.02781685f, 
    0.08136287f, 0.13275217f, 0.01584365f, -0.00452061f, -0.09832807f, -0.17407560f, 0.36317852f, 0.20383607f, 
    -0.08351213f, -0.06349003f, -0.18134013f, -0.21011287f, 0.02702081f, -0.02691561f, 0.14848544f, 0.01327478f, 
    -0.00257043f, 0.01567539f, -0.00116672f, -0.28339729f, -0.01391291f, -0.06874258f, 0.02805817f, 0.13991538f, 
    0.02239494f, -0.08565186f, 0.11815522f, -0.10379369f, 0.27795422f, 0.09501648f, 0.03682001f, -0.08218816f, 
    0.09899408f, 0.11647554f, 0.00164727f, -0.04922528f, 0.08127822f, -0.01170608f, 0.00939280f, -0.02616598f, 
    0.15821125f, 0.07182194f, -0.32943320f, -0.26210591f, 0.04806344f, 0.03170514f, 0.05036252f, 0.03502982f, 
    0.02200538f, -0.02905329f, 0.07761715f, -0.02814963f, 0.04964036f, -0.24369569f, 0.12194292f, 0.19289209f, 
    0.09303924f, 0.03949482f, -0.00752625f, -0.17655466f, 0.11749005f, 0.01991180f, 0.11203733f, 0.14752463f, 
    0.08538246f, -0.09152326f, -0.08496971f, 0.16397628f, 0.13495237f, 0.04873433f, -0.17285571f, -0.09022079f, 
    0.03817616f, 0.01411707f, 0.10837901f, 0.16392078f, 0.07596669f, 0.30316028f, 0.08431910f, -0.28525057f, 
    -0.00162494f, -0.05895460f, 0.11630607f, -0.13625073f, 0.11613428f, 0.27008545f, 0.17178082f, -0.13315307f, 
    0.14482908f, -0.20060110f, -0.39033020f, -0.01525383f, 0.25541940f, -0.07033139f, -0.08679420f, 0.07091504f, 
    -0.10980073f, -0.01331463f, 0.08440396f, 0.13511956f, -0.43443826f, -0.10420159f, 0.13833465f, 0.11211113f, 
    0.05078878f, 0.07406592f, 0.02214802f, 0.04948993f, -0.05537080f, -0.10961963f, 0.02036738f, -0.10785995f, 
    0.00347595f, 0.01076863f, -0.04268426f, 0.04026501f, -0.01605412f, 0.04404346f, -0.05222268f, 0.01827646f, 
    0.05058091f, 0.00431388f, -0.04201140f, -0.06979868f, -0.03728614f, 0.03813025f, -0.06307433f, -0.07359605f, 
    0.05417464f, -0.02322458f, -0.03740257f, 0.04934491f, 0.04900320f, 0.00780592f, -0.02653111f, -0.02129471f, 
    -0.05917906f, -0.04369236f, -0.03821193f, 0.02610140f, 0.06007346f, -0.03330063f, 0.02715745f, -0.00007855f, 
    -0.03293662f, 0.02610200f, 0.01275684f, -0.02285123f, -0.03138957f, -0.05589094f, -0.02297340f, -0.06888267f, 
    -0.01283996f, -0.07378934f, 0.04206268f, 0.03628076f, -0.07739282f, -0.03745950f, 0.03858599f, 0.04026363f, 
    -0.05421046f, -0.06814649f, -0.06370214f, 0.05664299f, -0.00107359f, 0.00735849f, -0.06719653f, -0.01896719f, 
    -0.01801984f, 0.02383543f, 0.00333245f, -0.06432951f, 0.02816458f, 0.04008369f, 0.06601277f, -0.06985178f, 
    0.00300297f, 0.02273106f, -0.06032822f, -0.05180892f, -0.06080864f, -0.00199243f, 0.04145596f, -0.00475855f, 
    -0.00391601f, -0.07661881f, 0.02917931f, 0.05417797f, -0.05304428f, 0.00837022f, 0.01848783f, 0.06284458f, 
    0.04888809f, 0.00640107f, -0.03883433f, -0.02025254f, -0.00133914f, -0.06581245f, -0.05719002f, -0.00426794f, 
    -0.04418619f, -0.05078104f, 0.00567361f, -0.04914274f, -0.06857762f, 0.02095378f, 0.00829326f, -0.04024071f, 
    0.05566079f, -0.00932781f, 0.01656427f, -0.03892778f, -0.07277328f, 0.00174625f, 0.05905400f, -0.04874732f, 
    -0.03744652f, -0.03345629f, -0.04665678f, -0.00917008f, -0.04063137f, 0.00704747f, 0.02878889f, -0.00535330f, 
    0.00501024f, -0.02796905f, -0.04096994f, -0.07587050f, -0.02223393f, 0.00227086f, 0.04767092f, -0.03331353f, 
    -0.03918847f, -0.01711403f, 0.05311534f, -0.06124664f, 0.05463501f, 0.06875587f, 0.02692260f, -0.04098019f, 
    0.00268024f, -0.05839970f, -0.04882317f, 0.00229545f, 0.01035656f, -0.04402300f, -0.01338121f, 0.00863014f, 
    -0.01395116f, 0.02925975f, 0.00488641f, 0.01714034f, 0.02399690f, 0.05475175f, -0.00502806f, -0.06467006f, 
    -0.07401786f, -0.07152592f, -0.03268779f, -0.04275021f, -0.02332206f, 0.06263343f, -0.05450717f, -0.04437874f, 
    0.05345658f, 0.06339685f, -0.02054140f, 0.02930104f, -0.03785839f, -0.00480168f, -0.07187898f, -0.03225579f, 
    0.01400589f, 0.02985254f, 0.06025502f, 0.00287478f, -0.00841955f, -0.05219041f, 0.00075696f, -0.07428732f, 
    -0.00579570f, -0.02019263f, -0.04469101f, -0.03686351f, 0.05748612f, -0.07719605f, -0.06500938f, -0.01439577f, 
    -0.00073085f, -0.06280560f, 0.03934031f, 0.05108313f, -0.00167581f, -0.05170526f, -0.06049312f, -0.05604287f, 
    -0.01122567f, 0.06407882f, -0.04115726f, -0.04739616f, 0.04803696f, 0.01142831f, 0.00859536f, 0.00647141f, 
    0.00523108f, -0.01875656f, -0.07150259f, 0.03626809f, -0.03054186f, -0.00955815f, 0.01952419f, 0.06008565f, 
    0.01504605f, 0.00423114f, -0.05716458f, -0.05127723f, 0.04725287f, -0.00516784f, 0.02238934f, -0.00912575f, 
    -0.06372780f, 0.05650410f, 0.03671005f, 0.02757344f, -0.05163005f, -0.03650530f, -0.00401942f, 0.05982356f, 
    0.02864749f, 0.04104534f, -0.02604128f, -0.01171767f, 0.01421587f, -0.00961618f, -0.06144504f, 0.03190804f, 
    0.01892969f, -0.00037762f, 0.06388138f, -0.05431575f, 0.05710692f, -0.02343324f, 0.02713001f, -0.00365100f, 
    0.00681869f, -0.01788162f, -0.01797171f, -0.03477256f, -0.04657181f, -0.01802014f, 0.06181780f, -0.03936990f, 
    0.05166767f, 0.05501750f, 0.05255249f, 0.02875023f, -0.03910828f, -0.03205619f, 0.02610237f, -0.06168588f, 
    0.03457143f, 0.01096095f, 0.04722172f, -0.00072198f, 0.05118430f, -0.01680983f, -0.06707633f, -0.04826509f, 
    -0.05263412f, 0.02527536f, -0.04233373f, -0.01721451f, 0.06378251f, -0.03274221f, 0.01797937f, -0.07515097f, 
    0.01051623f, -0.03997621f, -0.05181601f, -0.06938790f, -0.00803583f, 0.05931580f, -0.02436419f, -0.01951544f, 
    0.00687292f, 0.00526521f, 0.04554304f, -0.05089453f, -0.04408089f, -0.06855157f, -0.05310732f, 0.00500399f, 
    -0.06493475f, -0.01943500f, 0.06359655f, 0.05668507f, -0.00052733f, 0.02318717f, -0.04249562f, -0.00223561f, 
    -0.01599529f, 0.04720664f, 0.01996533f, 0.02232542f, -0.02433382f, 0.07012860f, -0.02980443f, -0.05469874f, 
    -0.07808813f, -0.06657091f, 0.03737305f, 0.00343829f, -0.04826398f, -0.03100371f, -0.02797140f, 0.03204677f, 
    0.00157062f, 0.04712139f, -0.03978978f, 0.05122635f, -0.07697671f, 0.04032812f, -0.07153342f, 0.03793248f, 
    -0.05699636f, -0.04098151f, -0.03524600f, 0.01107660f, -0.06670845f, -0.04259769f, -0.04314215f, 0.07125425f, 
    0.03351589f, -0.03048321f, 0.03457359f, 0.02546314f, -0.05756085f, 0.05877144f, -0.05545721f, -0.00157223f, 
    0.04160069f, -0.07105026f, -0.07120971f, -0.06557217f, -0.00445382f, -0.03549837f, 0.05651702f, -0.05334359f, 
    -0.00239791f, -0.00324374f, 0.01180540f, -0.04332165f, -0.02791462f, -0.00441996f, 0.05474239f, -0.07199784f, 
    -0.03730681f, -0.06420209f, 0.05013131f, 0.05751984f, -0.07784274f, 0.06427012f, -0.01519209f, 0.05691317f, 
    -0.07099730f, -0.07274472f, 0.01458533f, 0.04548551f, 0.05289317f, 0.00539566f, 0.02893979f, -0.01103847f, 
    -0.06548225f, 0.01852505f, -0.07503573f, 0.02935627f, -0.04142875f, -0.04994932f, 0.05825363f, -0.01643750f, 
    -0.02380890f, 0.00203473f, 0.00059191f, -0.05997618f, 0.05532880f, 0.03537367f, -0.03557850f, -0.05558643f, 
    0.03690275f, -0.05545323f, -0.07153018f, -0.05080313f, -0.07729411f, 0.01322596f, -0.03869478f, -0.04904375f, 
    0.00233746f, 0.03811857f, -0.08229099f, -0.01366768f, 0.02286347f, 0.03818869f, 0.01714337f, 0.04306834f, 
    -0.02346080f, 0.04663983f, 0.05925231f, 0.02883166f, 0.00227201f, -0.07338489f, -0.01444682f, 0.01492469f, 
    -0.03624638f, -0.01544030f, -0.03094804f, 0.05701086f, 0.01315310f, -0.02421761f, -0.00633992f, -0.06663701f, 
    0.02181331f, 0.02336629f, 0.04814713f, 0.03090093f, -0.07183810f, -0.01685680f, -0.05447516f, -0.03382070f, 
    -0.03394641f, -0.04142341f, -0.06318130f, -0.04554068f, -0.03107212f, -0.04287906f, -0.07251739f, 0.01920336f, 
    0.05816920f, -0.01389158f, -0.03817732f, -0.03288897f, -0.03676924f, -0.04474469f, 0.04634058f, -0.06415770f, 
    -0.06657422f, 0.05919200f, 0.06524792f, 0.04620077f, 0.05075329f, -0.03124633f, 0.00443883f, 0.05531336f, 
    -0.00199868f, 0.04002573f, -0.06783095f, -0.05360601f, 0.05419443f, 0.04825315f, 0.05788442f, 0.05471474f, 
    -0.03791356f, -0.05420070f, -0.01569752f, -0.07563120f, 0.05565517f, 0.05281197f, -0.05893362f, 0.03521705f, 
    -0.07149812f, 0.04850723f, -0.06251634f, 0.05993579f, -0.02237543f, -0.00074165f, -0.05852962f, 0.03760534f, 
    -0.03617762f, -0.05849367f, 0.01553549f, 0.05411223f, 0.05253009f, -0.03143749f, -0.06559006f, -0.07000920f, 
    -0.01905083f, 0.05395163f, -0.03794831f, 0.02109031f, -0.03754600f, -0.03410689f, 0.05975417f, -0.02578980f, 
    0.01388267f, 0.03674472f, -0.05736208f, 0.02940066f, 0.04236446f, -0.03000542f, -0.00745555f, -0.07080254f, 
    0.06052111f, 0.04342919f, 0.05659075f, -0.05564182f, 0.02959476f, -0.03632039f, 0.00735765f, -0.07069675f, 
    0.03148356f, 0.00933142f, -0.02347465f, -0.02491166f, 0.05932783f, -0.05915106f, 0.01754477f, -0.02318451f, 
    -0.01777902f, -0.03263455f, 0.00066536f, 0.04197500f, -0.04497357f, 0.01183819f, -0.07269129f, 0.02363328f, 
    -0.02186351f, -0.01363584f, 0.03671338f, -0.05598017f, -0.02661315f, 0.05477505f, -0.07816737f, 0.01931472f, 
    -0.01151352f, -0.02692563f, -0.05561677f, -0.06870635f, 0.03155521f, -0.06575236f, 0.01922313f, -0.05429665f, 
    -0.06651268f, 0.03580907f, -0.03587912f, -0.07769418f, -0.01164378f, -0.07041237f, 0.00807508f, 0.05329772f, 
    -0.00013999f, -0.04995739f, 0.04603900f, 0.00041515f, -0.04688813f, 0.04765359f, 0.02036517f, 0.05926793f, 
    -0.01045109f, 0.00487799f, 0.01790122f, 0.02197321f, -0.00695320f, 0.01892722f, 0.06587876f, -0.03230793f, 
    0.03378458f, -0.03941382f, 0.00585788f, -0.03838959f, -0.00439425f, 0.00295137f, -0.07794448f, -0.02450360f, 
    0.02942532f, -0.01933698f, -0.05855284f, -0.03588080f, -0.05105618f, 0.05370019f, 0.01709502f, -0.03356097f, 
    0.01612545f, 0.00418329f, 0.01002380f, -0.03811396f, -0.05523212f, -0.00915752f, -0.01994938f, 0.01226828f, 
    -0.08189836f, 0.04938047f, 0.04053058f, -0.06705512f, 0.05710719f, 0.10943229f, 0.09810187f, 0.16119382f, 
    0.05493969f, -0.09424475f, 0.12105186f, -0.05584977f, -0.01101045f, 0.09499939f, -0.00597889f, 0.02954364f, 
    -0.17157348f, -0.28570193f, -0.03861278f, -0.06932135f, 0.12877473f, 0.04262574f, -0.03574400f, 0.01849045f, 
    -0.23840891f, -0.00533639f, 0.38864252f, 0.31148568f, 0.12671226f, 0.09087560f, -0.06185572f, 0.01043005f, 
    -0.11860526f, -0.05309683f, -0.09057498f, -0.06611102f, 0.20282795f, 0.30717996f, 0.15077911f, 0.24021654f, 
    -0.10636578f, -0.15861048f, 0.18253763f, -0.04330824f, -0.03764613f, 0.07453735f, -0.00755525f, 0.03149049f, 
    -0.05296423f, 0.25581282f, 0.33483800f, -0.17864579f, 0.00145911f, -0.27720964f, -0.00038619f, -0.06040059f, 
    0.15412796f, -0.02920154f, 0.05898356f, 0.11037625f, -0.31693113f, -0.27888113f, 0.10421167f, 0.09620145f, 
    0.02319271f, 0.12973966f, -0.12249619f, 0.07967947f, 0.11064293f, 0.00052877f, 0.11570160f, -0.02509089f, 
    -0.27550498f, 0.21937577f, -0.14175935f, 0.26799512f, -0.05878175f, 0.05467747f, -0.14829388f, 0.21715765f, 
    0.07428293f, -0.08679119f, -0.01045660f, -0.02234611f, 0.11794376f, 0.14489417f, -0.16523680f, -0.26654828f, 
    0.03072832f, -0.06368671f, 0.07453723f, 0.17712662f, 0.08961569f, 0.07568552f, -0.06550306f, 0.08609739f, 
    -0.18935440f, -0.04688789f, -0.06057575f, 0.21503569f, 0.01838587f, 0.00402217f, -0.06643358f, -0.02214663f, 
    0.05376527f, 0.05040144f, 0.04991285f, 0.13313466f, -0.41505966f, -0.23441593f, -0.08913998f, 0.16968943f, 
    -0.10766184f, 0.08990916f, -0.03159845f, 0.02428748f, -0.06047180f, 0.09449324f, -0.15542409f, -0.09297320f, 
    -0.34445325f, -0.05018094f, 0.33490297f, 0.26744312f, 0.00242143f, -0.08715372f, -0.03675003f, 0.04531860f, 
    -0.01706064f, 0.05757600f, -0.04727601f, -0.01392402f, 0.07998070f, 0.17796098f, -0.02264362f, -0.05841649f, 
    -0.22697848f, -0.12629564f, 0.06792341f, 0.12282582f, -0.12913314f, 0.03975914f, -0.05942938f, -0.04501843f, 
    0.12251775f, 0.08280540f, 0.01323757f, -0.18867785f, -0.04641990f, -0.00154423f, 0.00213780f, 0.06170934f, 
    -0.20200759f, 0.01363757f, -0.21172163f, -0.32407853f, 0.17567717f, -0.05593722f, -0.22556792f, 0.13620244f, 
    0.04384864f, -0.04583961f, -0.02704706f, -0.12658836f, 0.10351615f, -0.10910527f, -0.17086510f, -0.05068878f, 
    0.03104028f, 0.34373522f, 0.15905204f, 0.00805865f, 0.07644919f, -0.02219922f, 0.19819091f, -0.20148398f, 
    -0.05823405f, 0.10706414f, -0.04209085f, -0.04154201f, 0.46362329f, -0.03275064f, 0.08870763f, 0.09687909f, 
    -0.07176403f, -0.18989682f, 0.00692998f, -0.27991277f, 0.22393556f, 0.06306658f, 0.09064934f, 0.18735635f, 
    -0.08059317f, 0.03572939f, -0.00962712f, -0.01620304f, -0.05032951f, -0.01740465f, 0.01331321f, 0.02625212f, 
    0.07740777f, -0.03797031f, 0.03574970f, 0.07279934f, 0.01286279f, 0.12286635f, -0.03501211f, -0.08323351f, 
    -0.08959980f, -0.28380314f, -0.13567001f, -0.09613878f, -0.03146452f, -0.05043123f, -0.09631461f, -0.04195604f, 
    -0.05729848f, 0.05870268f, 0.05028585f, 0.25421599f, 0.10685832f, 0.05857085f, 0.10937725f, 0.04274656f, 
    0.04866643f, 0.06975447f, 0.04750399f, 0.07335927f, -0.07615594f, 0.06951302f, -0.00513370f, 0.20138012f, 
    -0.04884963f, -0.00631720f, 0.17532837f, 0.05366132f, -0.02676256f, 0.14613448f, 0.07395244f, 0.10308249f, 
    -0.19360289f, -0.23978688f, -0.06851918f, -0.11006524f, -0.04460577f, -0.09948773f, -0.13049410f, 0.01442734f, 
    0.07025374f, 0.11961019f, 0.04458605f, -0.19954492f, -0.21619180f, -0.08586258f, -0.06511155f, 0.12499672f, 
    -0.05678644f, 0.02172874f, -0.00315032f, 0.01459099f, 0.13323903f, -0.06110979f, 0.05082433f, 0.05754783f, 
    -0.17219359f, 0.28438628f, -0.08610168f, 0.32141688f, -0.13762137f, 0.03187758f, 0.01251992f, -0.03463610f, 
    0.08750433f, -0.00566777f, 0.00814383f, -0.06963837f, -0.26745835f, 0.05577015f, -0.41797647f, 0.14104697f, 
    0.01692605f, -0.15884849f, -0.06705108f, 0.11226987f, 0.02577652f, 0.08149645f, -0.02422790f, 0.17859641f, 
    -0.17724308f, -0.05037900f, -0.21470849f, 0.18470652f, -0.11978740f, 0.03626240f, -0.08191775f, -0.04658287f, 
    -0.07685396f, -0.13392487f, 0.09557436f, -0.02722469f, -0.26608464f, -0.11501084f, -0.01744678f, 0.26063335f, 
    0.06057898f, 0.00895578f, -0.12329908f, -0.01593649f, -0.03110747f, 0.03031838f, 0.05374154f, 0.05674912f, 
    -0.12387243f, -0.03061581f, 0.30182320f, 0.22892563f, -0.02981744f, 0.10360221f, -0.00470424f, -0.02248359f, 
    0.00370809f, 0.08177165f, -0.03500275f, -0.06782366f, 0.22024871f, 0.54749030f, -0.14847872f, 0.13842168f, 
    -0.15629946f, -0.09293193f, 0.06150776f, -0.00000209f, -0.00248017f, -0.01950626f, 0.31044590f, 0.02275836f, 
    -0.07737076f, 0.03728199f, -0.15517311f, 0.13555892f, -0.02112496f, 0.02834714f, -0.02386176f, -0.08758537f, 
    0.22367911f, -0.02570786f, -0.11202310f, 0.02676355f, 0.30592248f, -0.01954302f, 0.04250036f, -0.05697265f, 
    -0.03334918f, 0.02366923f, -0.02737953f, 0.10545070f, 0.11451676f, 0.04462693f, 0.12042782f, -0.03912600f, 
    -0.17313963f, 0.08123841f, 0.17814192f, 0.01189704f, -0.06443799f, 0.13267575f, -0.01784535f, -0.07183047f, 
    0.10307779f, 0.04622403f, -0.03986550f, -0.00863808f, 0.29228106f, 0.11758642f, -0.01376044f, -0.04752231f, 
    0.05739925f, -0.00034401f, -0.07275598f, -0.14653030f, 0.05311845f, -0.02090541f, -0.13336901f, -0.08109280f, 
    0.15326411f, 0.04021613f, 0.20706630f, -0.18790808f, -0.06617623f, -0.02840195f, 0.04187934f, 0.08504523f, 
    -0.05977018f, -0.15031691f, -0.01801171f, 0.00883287f, -0.28828841f, -0.15591776f, -0.09830461f, -0.12543708f, 
    0.08460723f, 0.06850766f, 0.04500481f, 0.04554380f, -0.10612386f, -0.08231246f, 0.08382768f, 0.02727029f, 
    0.04162252f, -0.02177270f, 0.19649523f, -0.10381233f, 0.11824221f, -0.06613255f, -0.09711935f, 0.00142622f, 
    0.02008732f, -0.08997186f, 0.02406956f, 0.02582924f, -0.00304200f, 0.22317481f, 0.19126327f, 0.02748618f, 
    -0.03234454f, 0.01407324f, 0.07381242f, 0.05944434f, 0.13352373f, -0.16787332f, 0.01796217f, 0.01379820f, 
    0.03737864f, -0.03876841f, 0.03760909f, 0.07824514f, 0.08451457f, 0.11060009f, 0.01214968f, 0.08195796f, 
    0.20805500f, -0.07695152f, -0.13340822f, 0.19199426f, 0.10785648f, 0.15452261f, 0.22290035f, -0.12302057f, 
    0.04536471f, -0.01975828f, -0.00585999f, -0.17016253f, 0.26533017f, -0.02503887f, -0.01276076f, 0.05394389f, 
    0.29830021f, -0.30964494f, 0.26805189f, 0.09411566f, -0.07325029f, -0.06167859f, -0.05171318f, 0.14426568f, 
    -0.04438875f, -0.07690328f, -0.04734008f, -0.07424157f, -0.18176037f, -0.13424981f, -0.16025668f, 0.09617143f, 
    -0.06385446f, 0.00315538f, 0.01904154f, 0.01724280f, -0.01276574f, 0.00612026f, -0.01074605f, 0.26142275f, 
    0.31143373f, 0.14786817f, 0.14536133f, 0.06966276f, -0.07956219f, 0.04756975f, 0.07659224f, 0.12316726f, 
    0.12844919f, -0.13796328f, -0.12339902f, -0.17655249f, 0.03010860f, 0.30290815f, 0.32143486f, 0.08893134f, 
    -0.07966355f, 0.03457462f, 0.05830128f, 0.05270953f, 0.02933793f, -0.01092108f, -0.00684433f, 0.04455609f, 
    -0.06331615f, 0.10708676f, 0.07614625f, -0.03713398f, -0.19510183f, 0.03504243f, 0.10829965f, 0.08296047f, 
    0.09609748f, 0.02904683f, 0.01950116f, -0.05794093f, -0.19326010f, -0.35992047f, -0.30255556f, -0.22239575f, 
    0.07546006f, 0.02382828f, -0.06455538f, 0.14224085f, 0.05400176f, 0.00234863f, 0.02837347f, -0.00366800f, 
    0.19111319f, -0.10289981f, -0.14077127f, -0.03297890f, -0.01025196f, 0.11212582f, -0.00198225f, 0.14637637f, 
    0.06880743f, 0.04823000f, 0.14435290f, 0.01061953f, 0.01249511f, -0.14632414f, 0.15822689f, -0.29722494f, 
    0.10996891f, -0.05147078f, -0.06079431f, -0.01770857f, -0.17161082f, -0.02336885f, 0.08123957f, -0.16647629f, 
    0.14605610f, -0.27033603f, 0.14513795f, 0.08638053f, 0.10488676f, 0.00830707f, 0.05234757f, 0.01267020f, 
    0.12252478f, 0.02041823f, 0.06292789f, 0.31113645f, -0.07904257f, -0.03340016f, -0.19164804f, -0.01572620f, 
    0.16252816f, -0.06920436f, 0.08108734f, 0.00639353f, 0.08061070f, -0.06957718f, -0.00182307f, 0.10746244f, 
    0.12680715f, -0.03900502f, 0.18884090f, 0.06421567f, -0.05100468f, 0.19413856f, -0.02865683f, -0.01495636f, 
    0.04918219f, 0.08918613f, 0.11933981f, -0.04249420f, 0.21524516f, 0.27359524f, 0.12147985f, -0.11931580f, 
    0.02362924f, 0.02962013f, -0.05007338f, -0.04523141f, -0.08703355f, -0.10993355f, -0.09039722f, -0.23333532f, 
    -0.03182578f, 0.31629232f, -0.18694696f, 0.05749755f, 0.13891512f, -0.02358608f, 0.03345444f, 0.13112657f, 
    0.01081576f, 0.05660160f, 0.11787771f, -0.00446835f, -0.12301778f, -0.10036694f, 0.09036329f, -0.39825308f, 
    -0.08791481f, -0.20306097f, -0.10218868f, 0.05397047f, 0.23314351f, 0.18499106f, 0.14391169f, 0.05787782f, 
    -0.18303210f, 0.01074068f, -0.09328928f, 0.10551818f, 0.04787867f, 0.08063571f, -0.03537343f, -0.04395429f, 
    -0.18180744f, -0.05322173f, -0.17720562f, -0.02781281f, 0.08178024f, 0.19241354f, 0.21517457f, -0.02841239f, 
    0.03510567f, 0.06265955f, -0.11645665f, -0.09619940f, -0.02251994f, -0.01981844f, 0.06027521f, -0.10143000f, 
    0.05140939f, -0.25983390f, 0.29552579f, -0.09926047f, 0.15724568f, 0.04889431f, 0.20067056f, 0.03750299f, 
    -0.12940049f, -0.03932937f, 0.12106065f, -0.01856599f, -0.19068548f, 0.16031036f, -0.05149466f, 0.06553371f, 
    0.07519161f, 0.10394313f, 0.02796589f, -0.23366603f, -0.01822051f, -0.12548602f, 0.00425427f, -0.08475162f, 
    0.28989995f, -0.18358791f, -0.09541335f, -0.16634962f, -0.07565616f, -0.03281973f, 0.11143257f, -0.07144698f, 
    -0.04157626f, -0.04434575f, -0.04550974f, -0.09976113f, 0.13985018f, 0.13628669f, -0.09766239f, 0.08959794f, 
    0.04912724f, -0.01892577f, 0.01629035f, -0.07604472f, 0.08544239f, -0.08650690f, 0.00004399f, -0.00788282f, 
    -0.10120185f, -0.08238273f, -0.49191919f, -0.27580497f, 0.05361499f, -0.03601723f, 0.14105646f, 0.01346825f, 
    -0.05451046f, 0.07665039f, 0.01037196f, -0.05475997f, 0.38866827f, -0.04558639f, 0.12091442f, 0.29056728f, 
    0.04973879f, -0.04777993f, -0.08951536f, -0.03147268f, -0.11921404f, 0.15359209f, -0.05265079f, 0.03108595f, 
    -0.07285202f, 0.04167932f, -0.15110533f, 0.07056956f, 0.11389003f, 0.14821701f, -0.11241112f, 0.16683903f, 
    0.13827682f, -0.02752535f, 0.04935812f, 0.06392367f, 0.16890095f, -0.17061178f, 0.19568795f, -0.17373638f, 
    0.06460227f, 0.04238134f, 0.17794813f, 0.08731361f, -0.01634124f, 0.16710980f, -0.09424893f, 0.11140279f, 
    -0.28926489f, 0.17516099f, -0.04079925f, 0.02349834f, 0.11311391f, 0.04998136f, -0.30704543f, 0.20928620f, 
    -0.00316822f, 0.06491826f, 0.03225354f, 0.10580350f, -0.10355927f, -0.00240250f, 0.01382830f, 0.00242654f, 
    -0.04132326f, 0.05412685f, 0.09566820f, 0.01368353f, 0.10654693f, -0.06371024f, 0.15626974f, -0.07118729f, 
    0.03816290f, 0.24559723f, 0.06426585f, -0.24935625f, 0.03245728f, 0.01425859f, 0.16178727f, 0.24436198f, 
    -0.04782841f, 0.17069769f, 0.10107668f, -0.16347077f, 0.11668079f, 0.17317767f, 0.00089752f, -0.10835127f, 
    -0.04645941f, -0.04525503f, -0.19166477f, 0.10722770f, 0.04070598f, 0.02679869f, 0.07851768f, -0.02925328f, 
    0.07556577f, -0.29127014f, -0.01305974f, 0.19373500f, 0.11830323f, -0.00813493f, 0.17723638f, -0.00995547f, 
    0.01485173f, 0.06184011f, -0.21294048f, -0.04271841f, 0.30729038f, 0.04036763f, 0.06258036f, 0.20241457f, 
    0.16138488f, -0.02129612f, 0.14889567f, 0.01637251f, -0.07437114f, 0.00664867f, -0.05997749f, 0.11822464f, 
    -0.38629067f, 0.02952735f, 0.09836183f, 0.03889148f, 0.12165974f, -0.22519749f, -0.14522620f, -0.02359677f, 
    -0.11213046f, -0.06661801f, 0.20443270f, -0.02550668f, 0.04874866f, -0.13844201f, 0.09274796f, 0.07218214f, 
    0.07410255f, -0.01139112f, -0.01346075f, 0.00616923f, 0.02956278f, 0.06299077f, 0.01446297f, -0.16236602f, 
    0.12917784f, 0.40004435f, -0.02535483f, 0.06840116f, 0.07955059f, -0.00919463f, 0.19390619f, 0.12207265f, 
    0.14394803f, -0.07919312f, 0.08649437f, -0.06622516f, 0.21633695f, -0.10459066f, 0.18879165f, -0.06056096f, 
    0.06660738f, -0.06687491f, -0.08408928f, -0.16263837f, -0.03011439f, 0.01331536f, 0.01700578f, -0.02912291f, 
    0.07708748f, -0.09311856f, -0.06484173f, 0.07983527f, 0.02874198f, -0.06713154f, 0.08741553f, 0.02926926f, 
    0.00953432f, 0.07742804f, 0.25365549f, 0.12904567f, 0.03400962f, -0.12580511f, 0.02656428f, 0.04562273f, 
    0.03482548f, -0.17302142f, 0.10346141f, -0.01246213f, 0.12995934f, -0.13792515f, -0.13530947f, -0.10545869f, 
    -0.19739373f, -0.08861382f, 0.07446110f, 0.02446628f, -0.02980030f, -0.07649067f, -0.09194548f, -0.00858540f, 
    0.00371459f, -0.07933728f, 0.09899245f, 0.22649065f, 0.28266117f, -0.05126909f, 0.16825028f, 0.07767016f, 
    0.00584960f, -0.07848860f, 0.02562438f, -0.00805176f, -0.00515367f, 0.05928952f, 0.02143218f, -0.10853885f, 
    -0.25904125f, 0.02930885f, -0.11168389f, -0.13614364f, 0.04044218f, -0.03157444f, -0.00762465f, 0.00662725f, 
    -0.32531315f, -0.12411309f, -0.25046796f, -0.24334829f, -0.04996652f, 0.16460279f, 0.04588974f, 0.07940205f, 
    0.20230655f, -0.22116153f, -0.13580690f, 0.00098660f, -0.04649864f, 0.23255736f, 0.06928337f, -0.06086266f, 
    -0.08911658f, 0.23593825f, -0.03886427f, -0.06025055f, 0.15924317f, -0.01289369f, 0.18541677f, -0.07361720f, 
    -0.12008940f, -0.06879892f, -0.08680344f, -0.17152388f, -0.06272737f, 0.09479465f, -0.02893700f, 0.01582323f, 
    -0.05123761f, -0.07159428f, -0.05274246f, -0.09452781f, 0.18808326f, 0.24175084f, 0.26798564f, 0.33402368f, 
    -0.02817455f, -0.01840556f, -0.03799321f, -0.04495851f, 0.03396141f, 0.02636361f, -0.06628561f, 0.00345172f, 
    -0.00855983f, -0.03166477f, 0.00367467f, 0.03434087f, -0.07532915f, 0.01085776f, -0.05480809f, 0.04978210f, 
    -0.03192481f, -0.05526843f, 0.03388055f, 0.04278665f, -0.02536172f, 0.02267996f, -0.03754031f, -0.00700993f, 
    -0.06916872f, 0.00871105f, 0.00304163f, 0.05396070f, 0.06222221f, 0.06132742f, -0.01454986f, -0.05653867f, 
    -0.00827541f, -0.06916922f, 0.00419475f, -0.06370956f, -0.03887575f, -0.04831462f, 0.04377016f, -0.07684813f, 
    -0.04969826f, 0.03724758f, -0.05988948f, -0.00152887f, 0.05852691f, 0.05753983f, 0.04378965f, 0.01842861f, 
    -0.05799765f, 0.05487271f, 0.02699955f, -0.06025413f, 0.02660681f, 0.04916269f, -0.04853389f, -0.02349306f, 
    0.03343017f, -0.01207041f, -0.05990075f, -0.04534146f, -0.07201445f, -0.04442927f, -0.06393792f, 0.05137240f, 
    -0.00442537f, 0.05970907f, -0.03429579f, 0.05201378f, -0.02898879f, -0.00089648f, -0.02438571f, 0.04876811f, 
    0.05255600f, 0.00481855f, -0.02800605f, 0.00187538f, -0.01646776f, -0.04647235f, -0.02840079f, 0.03111732f, 
    0.01698940f, 0.03403354f, 0.02366184f, 0.02520102f, -0.05686662f, -0.07429124f, -0.06469331f, -0.00594647f, 
    0.05993356f, 0.03796497f, -0.01368358f, 0.03601407f, 0.00446253f, -0.06082493f, -0.04396313f, -0.04278118f, 
    -0.00424375f, -0.07736330f, -0.01200769f, -0.03489319f, -0.05796117f, 0.01838630f, 0.05945913f, -0.07998269f, 
    -0.02694761f, 0.05147374f, -0.03473242f, -0.01086659f, -0.03953056f, -0.03948637f, -0.01669155f, -0.05514186f, 
    -0.05161659f, -0.06619304f, -0.04371653f, -0.02602134f, -0.01359492f, 0.04347521f, -0.02604751f, -0.02263214f, 
    -0.07298762f, 0.03807175f, 0.00876952f, -0.02317491f, -0.05720011f, 0.05814942f, 0.00659861f, 0.03081929f, 
    -0.05654075f, -0.05241366f, -0.00946456f, -0.05044892f, -0.04262283f, 0.05103220f, -0.03671071f, 0.05325525f, 
    0.02549407f, -0.00853501f, 0.05704087f, -0.02216357f, -0.01898703f, -0.01432032f, -0.01122126f, -0.02784767f, 
    0.05191863f, -0.06346904f, -0.00757227f, 0.00789044f, -0.06332549f, -0.03507634f, -0.04509465f, 0.06478257f, 
    -0.01418204f, -0.00420774f, 0.01865707f, 0.05733143f, 0.00510775f, 0.04467419f, 0.03071210f, -0.07642275f, 
    -0.03002036f, -0.01809707f, 0.04434997f, -0.05215898f, -0.01883647f, -0.00886011f, 0.01582032f, 0.00962472f, 
    -0.04208793f, 0.03807989f, -0.06020342f, 0.01378832f, -0.07415222f, -0.03963867f, -0.03549544f, 0.06641103f, 
    0.00339743f, -0.06210757f, -0.07440985f, -0.06794456f, 0.04658662f, -0.04776585f, 0.05181380f, 0.01678983f, 
    -0.06368166f, 0.02722563f, 0.02987795f, -0.07211524f, -0.04050036f, 0.03641452f, 0.00160786f, 0.00231807f, 
    -0.09696746f, -0.18861121f, -0.10616776f, 0.00922347f, -0.11277167f, 0.06693732f, -0.00222458f, -0.07832182f, 
    0.11623472f, -0.22218382f, 0.03934281f, 0.15444912f, -0.26097673f, -0.20194899f, -0.16232455f, -0.03051870f, 
    0.08757101f, 0.00360434f, -0.02650254f, 0.03176137f, -0.17487445f, -0.11870313f, 0.01807919f, -0.03239285f, 
    -0.09250493f, 0.22955655f, 0.23169026f, 0.15160286f, 0.06317773f, 0.01163375f, 0.06618797f, 0.18308981f, 
    0.00976972f, -0.05895229f, -0.04485048f, 0.11313815f, -0.27410543f, 0.31782329f, 0.31176081f, 0.27063981f, 
    -0.09343969f, 0.11096098f, 0.08526010f, 0.04062694f, 0.14665397f, 0.03653422f, -0.00023883f, -0.11009201f, 
    -0.07058487f, -0.03899800f, 0.01016474f, -0.02813066f, -0.15158769f, 0.04645344f, -0.01932714f, -0.00083671f, 
    0.12150826f, 0.13901754f, 0.13733642f, 0.00029891f, -0.07677843f, 0.14213602f, 0.09582338f, -0.05528580f, 
    0.03636168f, -0.07852229f, 0.04559586f, 0.00369992f, 0.17548488f, -0.08779240f, 0.09091437f, 0.24582031f, 
    -0.10986905f, -0.18605311f, 0.29202724f, 0.27940747f, 0.00550338f, 0.00851343f, -0.01855836f, 0.00057579f, 
    -0.06204203f, 0.07989837f, -0.07019025f, -0.13305572f, -0.42466462f, 0.06546804f, -0.22608189f, 0.27101371f, 
    0.03390506f, -0.12507822f, 0.04333945f, 0.09930117f, 0.05870476f, 0.09895264f, -0.02347182f, 0.28494358f, 
    0.01085778f, 0.16268325f, 0.03939433f, 0.09416796f, -0.08303452f, 0.05271349f, -0.04833303f, 0.21136564f, 
    -0.00561353f, -0.05422207f, -0.16938755f, -0.20858161f, -0.18114802f, 0.09771761f, 0.22621149f, 0.09877049f, 
    0.08662266f, 0.24183491f, 0.01800691f, -0.11921816f, -0.04694936f, -0.05837727f, -0.18547145f, -0.02133822f, 
    -0.02748539f, 0.22018906f, 0.25072366f, 0.03335179f, -0.11672578f, 0.10399079f, 0.07795463f, 0.00235693f, 
    0.00816056f, -0.01772578f, -0.07687145f, -0.16219419f, -0.19613445f, 0.03497291f, -0.29728299f, 0.00176184f, 
    0.04867765f, -0.03470175f, -0.07314440f, -0.04924373f, 0.01087030f, 0.10813514f, 0.11478575f, 0.12487402f, 
    0.03678881f, -0.00941738f, -0.15601188f, -0.01943668f, 0.20430376f, 0.03147123f, 0.04594538f, -0.00807889f, 
    0.09245730f, 0.05671385f, 0.05036794f, 0.09059755f, 0.60111862f, -0.05292051f, -0.12326881f, -0.22077501f, 
    0.02776384f, 0.11930820f, 0.11568906f, 0.17235951f, 0.07420694f, -0.14574972f, 0.03459058f, 0.00248947f, 
    0.08547081f, 0.02499922f, 0.10713320f, 0.14051221f, 0.09334286f, 0.15392841f, 0.06956699f, 0.12465647f, 
    0.07327482f, 0.06934415f, 0.07886896f, 0.09124186f, -0.02826898f, -0.12984067f, -0.12434509f, -0.12558299f, 
    -0.02561377f, -0.07980456f, -0.14069308f, 0.04156264f, -0.02180854f, -0.05186510f, 0.01685556f, -0.16180363f, 
    0.06500398f, 0.02420090f, 0.12644587f, -0.03218211f, -0.05621350f, -0.01543526f, 0.08145032f, 0.22288163f, 
    -0.18951151f, -0.07027475f, -0.01584456f, -0.05974786f, 0.05472579f, 0.12285236f, 0.00884298f, 0.00308661f, 
    -0.10539188f, -0.15521578f, -0.10394372f, -0.04074668f, 0.15648508f, 0.09912584f, 0.04217500f, 0.12077840f, 
    -0.24386100f, -0.04813357f, 0.03970043f, 0.14124763f, 0.19963050f, 0.04435219f, 0.06318232f, 0.06658114f, 
    -0.02660111f, -0.10266827f, 0.08911155f, 0.07281110f, 0.18034896f, -0.24796143f, -0.00196396f, -0.22052877f, 
    0.08732222f, -0.03131001f, 0.00551928f, -0.06444126f, -0.00702851f, 0.09879202f, -0.03288263f, -0.00453016f, 
    -0.04757473f, 0.05505049f, -0.07149292f, 0.00467211f, -0.02988507f, 0.00090840f, 0.01288816f, -0.00754459f, 
    -0.02109935f, 0.01032530f, 0.01044753f, -0.09058793f, -0.21166772f, -0.22889134f, 0.02003373f, 0.21150811f, 
    -0.01980826f, 0.09030920f, 0.07186866f, 0.10304444f, -0.06692056f, 0.03940205f, -0.13482429f, 0.05328830f, 
    -0.00370256f, 0.21262273f, -0.08857840f, -0.11777028f, 0.18126866f, 0.03957976f, 0.04717004f, 0.28958365f, 
    -0.10385770f, -0.07422207f, 0.08332165f, 0.02727682f, 0.13495779f, 0.06864540f, -0.01609560f, -0.06166163f, 
    0.06116121f, 0.05264129f, 0.00761778f, 0.01653949f, 0.03364735f, 0.06221047f, 0.03724630f, -0.11961199f, 
    -0.09654193f, -0.21038434f, -0.05558988f, -0.04422244f, -0.08392241f, 0.10579417f, 0.11920476f, 0.08407179f, 
    0.00909399f, 0.00051915f, 0.09729872f, 0.20724550f, -0.01405364f, -0.09802726f, -0.07829214f, -0.05192511f, 
    0.02619733f, 0.00104152f, 0.01218463f, 0.12045594f, -0.17537723f, -0.18323991f, -0.14161350f, -0.13715261f, 
    -0.02820501f, -0.17059417f, -0.12584342f, 0.03866486f, 0.00771996f, -0.09460798f, 0.03971407f, 0.19066305f, 
    -0.02193080f, 0.02236824f, 0.08313384f, 0.25962797f, 0.15354535f, 0.13739887f, 0.16314523f, 0.08605959f, 
    -0.22115211f, 0.02657887f, -0.12275496f, -0.00680622f, 0.03308634f, 0.10759658f, -0.06202566f, -0.02809833f, 
    0.10578656f, 0.17172243f, 0.03623866f, -0.12697089f, -0.07830974f, -0.07011139f, 0.00861367f, -0.11379843f, 
    -0.25939730f, -0.10261833f, -0.19895460f, -0.15340179f, -0.04172553f, -0.08379299f, -0.00193521f, 0.19264400f, 
    -0.06786776f, -0.08477444f, 0.16664603f, 0.10380124f, 0.10470957f, 0.16792405f, 0.10001656f, 0.08376999f, 
    -0.06421722f, 0.17122476f, -0.15657343f, -0.06376775f, 0.10666397f, -0.11843129f, 0.17059611f, 0.05359416f, 
    -0.15530999f, -0.11925299f, -0.20812513f, -0.05675865f, 0.13159649f, -0.01094144f, 0.21718402f, -0.05422590f, 
    -0.17077969f, 0.00538953f, 0.06867514f, 0.06750348f, 0.12297560f, 0.08956678f, 0.31255093f, 0.16735575f, 
    0.26422513f, -0.00557749f, 0.17346789f, -0.17721061f, -0.03821774f, -0.00445094f, 0.09964395f, 0.10066323f, 
    -0.10848754f, -0.00299640f, 0.01668942f, -0.17143618f, -0.11171607f, -0.24734797f, -0.21344970f, 0.02155928f, 
    0.07811379f, 0.07117182f, 0.03446421f, -0.07536170f, 0.05001950f, 0.06237803f, 0.11775891f, 0.14307979f, 
    0.14257367f, -0.09698977f, -0.03144545f, -0.08383743f, 0.14480388f, -0.00670732f, 0.07621668f, 0.08732570f, 
    0.02213893f, -0.07982577f, -0.14631619f, 0.01288693f, 0.00223669f, 0.20531575f, 0.30109814f, 0.05755680f, 
    -0.07158832f, -0.10754707f, 0.08114434f, 0.08215369f, -0.04049478f, 0.03687481f, 0.06819725f, -0.00763323f, 
    -0.02527857f, -0.22057246f, 0.11339480f, -0.00312709f, -0.00755664f, -0.18263572f, -0.04762735f, 0.17911023f, 
    0.14899971f, 0.04894697f, 0.02795975f, 0.07370421f, 0.22445507f, 0.03279601f, 0.21691240f, -0.14607193f, 
    0.10108993f, -0.04891702f, 0.00820942f, 0.05231320f, 0.07649891f, 0.05516796f, 0.04878299f, 0.06092933f, 
    0.30288953f, -0.34206191f, 0.08144293f, -0.06031565f, 0.03230125f, -0.06725418f, 0.15183462f, -0.00335559f, 
    0.01688858f, 0.07520507f, -0.00976306f, -0.09892710f, -0.06550146f, -0.08359493f, 0.12430477f, 0.38718009f, 
    0.00836327f, -0.19757108f, 0.05628127f, -0.08941457f, 0.05500796f, -0.09292300f, -0.14957267f, 0.06530199f, 
    0.12295261f, 0.18394405f, 0.06017290f, -0.02820236f, 0.02920918f, -0.09218284f, 0.01806053f, -0.01672182f, 
    0.11914598f, 0.05546968f, 0.07006036f, 0.04049318f, 0.21521109f, 0.14977275f, 0.09949534f, 0.00664849f, 
    -0.04620137f, -0.10630872f, 0.16172466f, 0.04530682f, -0.02113059f, -0.07233723f, -0.21434794f, -0.12079857f, 
    -0.11150412f, 0.07467290f, -0.00503658f, 0.00731876f, -0.06505613f, -0.00388193f, 0.00046611f, 0.03240045f, 
    0.08633107f, -0.04031307f, 0.07991584f, 0.08881509f, -0.12485741f, -0.25216508f, -0.20641719f, 0.10514452f, 
    0.12832232f, 0.04730495f, 0.12547232f, -0.04838492f, -0.02698428f, 0.04380316f, 0.04364155f, -0.06830630f, 
    -0.01302775f, -0.11957374f, -0.16592263f, 0.00621077f, 0.15123925f, 0.11089928f, 0.04617142f, 0.08466948f, 
    -0.16310278f, -0.14681512f, -0.07564382f, -0.35271752f, -0.00849997f, 0.10516658f, 0.18550600f, -0.12110390f, 
    0.16583750f, 0.10660359f, -0.01261693f, -0.02460659f, 0.11655551f, -0.09013619f, -0.13340628f, -0.03764818f, 
    0.08512179f, -0.28028625f, 0.00946221f, -0.05189889f, 0.05297662f, -0.06971317f, -0.01035419f, -0.04262744f, 
    0.03546488f, 0.02519505f, 0.06578778f, -0.00359689f, -0.21591027f, -0.07131071f, -0.17126593f, 0.23807189f, 
    -0.03401827f, -0.09519158f, -0.10903931f, -0.10056341f, 0.11251096f, 0.09617990f, 0.21401285f, 0.28931704f, 
    -0.19228277f, -0.22443517f, -0.44872409f, 0.01203508f, 0.04809545f, -0.00283452f, 0.12526566f, -0.03769032f, 
    -0.04274779f, -0.04282553f, -0.05242825f, 0.03394156f, -0.08078787f, -0.02573393f, 0.02903212f, 0.04945518f, 
    -0.08913139f, -0.01850260f, -0.06119452f, 0.07319903f, -0.09094555f, -0.15477747f, 0.06044108f, 0.06051734f, 
    -0.14667642f, 0.28720593f, -0.16006100f, 0.06084137f, -0.12312009f, -0.00233166f, -0.00849491f, -0.09747396f, 
    0.04843391f, -0.03975557f, 0.03594162f, -0.04316636f, -0.08074205f, 0.45046675f, 0.22574569f, 0.27010152f, 
    0.02283654f, 0.22426033f, 0.03378934f, 0.08583067f, -0.13354468f, -0.11780240f, 0.00450430f, 0.04577981f, 
    -0.11321796f, -0.06315158f, 0.02269352f, 0.15311444f, -0.20075879f, -0.01705059f, 0.08497638f, 0.08115665f, 
    -0.06787305f, 0.10163525f, 0.19050919f, -0.02911186f, -0.15978289f, -0.02082119f, -0.42213085f, 0.11766628f, 
    0.05782389f, 0.11052267f, 0.14770472f, 0.03578600f, -0.03746211f, 0.12946402f, -0.10174250f, -0.11530412f, 
    -0.30476394f, 0.36499172f, -0.28737500f, -0.16830069f, -0.00712497f, 0.07895462f, 0.06128948f, 0.02366983f, 
    0.14075015f, 0.03431756f, 0.00594969f, 0.04445951f, -0.20027097f, 0.31295466f, -0.11167056f, 0.26392564f, 
    -0.01503566f, -0.00688704f, 0.09260825f, 0.12930366f, 0.09901702f, 0.14106862f, 0.09142015f, -0.06880579f, 
    -0.05497954f, 0.21362799f, -0.22154996f, -0.03695016f, 0.05231411f, -0.07068432f, -0.17497182f, -0.03693124f, 
    0.08232026f, 0.18127634f, -0.25179628f, 0.01536662f, -0.14627691f, 0.04470820f, -0.06808209f, -0.27344978f, 
    -0.11077876f, -0.00831546f, 0.02183741f, 0.03469921f, -0.06807436f, 0.01450412f, 0.09750332f, -0.14565112f, 
    0.42358378f, 0.16756472f, 0.37741366f, 0.03163156f, 0.03382511f, 0.12570350f, -0.17083757f, -0.16923414f, 
    0.05153480f, 0.05310518f, -0.02309679f, -0.13206637f, -0.34696585f, 0.20190692f, -0.17937841f, 0.11486594f, 
    -0.09835359f, -0.04260438f, 0.01788774f, 0.06185945f, 0.02421146f, -0.06231720f, 0.12434945f, 0.05114393f, 
    -0.07703638f, 0.00854328f, -0.02103156f, 0.04641585f, -0.12681033f, -0.04659222f, 0.18277390f, -0.04033656f, 
    0.02116392f, 0.08178102f, -0.11159962f, 0.06291213f, 0.03280326f, -0.01365422f, 0.00295222f, -0.04422031f, 
    -0.01002249f, 0.07343345f, 0.02882964f, -0.01324909f, 0.06286638f, -0.12695749f, -0.05467160f, 0.03268998f, 
    0.13019571f, 0.04461175f, 0.18078510f, 0.01918329f, 0.00042843f, 0.01406412f, 0.29132190f, 0.02484122f, 
    0.17601731f, 0.15120801f, 0.12485531f, -0.12748878f, -0.12677778f, 0.11145326f, 0.16945489f, 0.02590202f, 
    -0.06448067f, 0.01114928f, -0.04351583f, 0.02490195f, -0.13426781f, 0.08774967f, -0.02954724f, 0.13319477f, 
    -0.09887314f, 0.26420051f, 0.08768568f, -0.09132401f, -0.04501109f, 0.10001575f, -0.10292979f, 0.01904173f, 
    -0.00422726f, 0.04435253f, 0.07950388f, -0.04328654f, -0.10301178f, 0.10792968f, 0.09598571f, -0.04397986f, 
    -0.01991657f, -0.04338729f, -0.14651775f, -0.04402160f, -0.04398941f, 0.02991251f, -0.05228765f, -0.12905197f, 
    0.25568682f, -0.00846301f, 0.18995441f, -0.06110543f, -0.04841886f, 0.07067664f, 0.00911294f, 0.07928979f, 
    -0.00117252f, 0.11818717f, -0.03558525f, -0.02046742f, 0.24225833f, -0.33543903f, -0.40126407f, 0.06484575f, 
    0.12131166f, 0.22669476f, 0.14170049f, 0.05447219f, -0.01438749f, 0.04752862f, -0.07082719f, 0.13495325f, 
    -0.15085854f, -0.09981279f, -0.27406031f, -0.11604622f, 0.06728231f, -0.16015786f, -0.07260632f, 0.12350108f, 
    -0.05386279f, 0.13443834f, -0.11151299f, -0.07021570f, 0.11062716f, 0.01237568f, 0.02533058f, -0.03253555f, 
    -0.08673989f, 0.10236265f, 0.08430202f, -0.05835235f, 0.03528921f, -0.03806994f, 0.02244187f, 0.08323580f, 
    0.44359088f, 0.37386146f, -0.00922448f, 0.07797725f, -0.03300099f, -0.02087565f, 0.02655456f, -0.15109381f, 
    0.10446613f, 0.09821805f, -0.00296130f, -0.04259717f, 0.16564573f, -0.06072110f, -0.00552898f, -0.60181558f, 
    -0.24001449f, 0.09046872f, -0.02023310f, -0.05010102f, 0.05271897f, 0.01458836f, 0.16221118f, 0.03487854f, 
    0.05125209f, -0.13988198f, -0.07216395f, 0.17439544f, 0.15536791f, -0.00649858f, -0.04699668f, 0.00797022f, 
    -0.08199667f, -0.12041039f, 0.03875929f, -0.14840734f, 0.17290494f, -0.24155577f, 0.02071267f, 0.18571867f, 
    0.27118084f, 0.19423445f, 0.02647628f, 0.04945694f, 0.17926222f, 0.05467589f, -0.01154980f, 0.14738852f, 
    -0.22433358f, -0.14832199f, -0.13477886f, -0.12322688f, 0.06874676f, -0.07132614f, 0.00550541f, 0.09848986f, 
    0.08057481f, 0.09057764f, 0.04682041f, 0.09935391f, 0.11388686f, -0.08276618f, 0.17974676f, -0.16368456f, 
    -0.00164957f, -0.07460743f, -0.09449196f, -0.07008637f, 0.02263696f, -0.11742196f, 0.14484550f, 0.10336524f, 
    -0.37672600f, -0.04132622f, 0.12687698f, -0.00150471f, 0.05702781f, -0.02004277f, -0.05289864f, -0.09105556f, 
    0.06576756f, -0.06302243f, 0.18832138f, 0.19277713f, -0.19884104f, 0.06639663f, -0.02799460f, 0.53401703f, 
    -0.00436510f, -0.01650877f, -0.16643535f, -0.06435199f, -0.14075783f, -0.01020290f, 0.07123613f, -0.07016975f, 
    0.08347830f, -0.04875496f, -0.25696924f, -0.14413136f, -0.03548440f, 0.09585868f, 0.12085778f, -0.00629423f, 
    0.07190152f, -0.04396033f, -0.10784309f, 0.07293144f, 0.20969635f, 0.11743746f, 0.15434626f, -0.07903144f, 
    0.03229322f, -0.00848762f, -0.02908878f, 0.13695127f, 0.04507357f, 0.02841345f, -0.31310922f, -0.13082965f, 
    -0.02363904f, -0.32539690f, -0.20037290f, 0.07764082f, -0.05631896f, 0.09740148f, 0.05710306f, -0.05714125f, 
    0.04827388f, 0.06380546f, -0.11685213f, 0.10568002f, 0.05539220f, -0.04948881f, -0.06537811f, -0.04622467f, 
    -0.04477704f, 0.03322431f, -0.09746870f, -0.04737005f, -0.02797220f, -0.09997914f, 0.01457956f, -0.02486215f, 
    0.00710972f, -0.00997473f, -0.07827318f, 0.04464742f, -0.04895161f, 0.01974918f, 0.08352587f, -0.00409636f, 
    0.09144927f, -0.02380607f, 0.19224153f, -0.01096579f, -0.43392041f, 0.27620777f, 0.14775662f, 0.09456473f, 
    0.16017903f, -0.00660915f, 0.02547135f, 0.05495915f, -0.09459968f, 0.04278797f, 0.06349160f, 0.04182835f, 
    0.00165177f, -0.15777948f, 0.10632555f, -0.03451002f, 0.00910619f, -0.01224099f, -0.13785827f, -0.09540686f, 
    -0.03123507f, 0.17262343f, 0.10001633f, -0.00113022f, -0.24397662f, 0.06353797f, -0.14156622f, 0.09133585f, 
    0.14514950f, -0.07292280f, 0.08279622f, 0.12236321f, 0.02781524f, 0.08421618f, -0.07137335f, 0.11033357f, 
    -0.51876932f, 0.03093972f, -0.01745634f, 0.01873935f, 0.09866913f, 0.18841274f, 0.22426252f, 0.11940915f, 
    0.10826237f, 0.03516151f, 0.01794410f, -0.09834602f, -0.18105540f, -0.00150357f, 0.08254655f, 0.34119448f, 
    0.00592759f, -0.05125916f, -0.18705194f, -0.11724054f, 0.12849103f, 0.02211459f, 0.06001088f, 0.07735914f, 
    -0.22367650f, -0.10175011f, 0.01920610f, -0.24828787f, -0.17508388f, 0.01716614f, -0.07633132f, -0.06449750f, 
    0.03017255f, -0.03478738f, -0.13191730f, 0.01888769f, -0.06537681f, 0.00396402f, -0.08900656f, 0.02340823f, 
    -0.02126594f, -0.00576463f, -0.02915841f, -0.09104473f, -0.11697485f, -0.16149774f, -0.01860037f, -0.04369797f, 
    0.00787595f, 0.03887077f, 0.04656382f, -0.11264816f, 0.08495962f, 0.00074891f, -0.04507448f, -0.09579697f, 
    -0.04508360f, 0.03470867f, 0.03787509f, -0.06273913f, 0.14080141f, 0.18763067f, -0.09919888f, 0.21604204f, 
    -0.08117101f, 0.03999027f, 0.07361762f, -0.23954147f, 0.09663441f, 0.04079860f, 0.11786067f, -0.03007487f, 
    0.11331522f, -0.14196138f, -0.06478553f, 0.06499597f, 0.11087512f, 0.14695692f, -0.10306847f, -0.11587493f, 
    0.03353136f, 0.02028009f, -0.11818305f, 0.12452252f, 0.34575754f, 0.33309612f, 0.04426635f, -0.45387182f, 
    0.02211832f, -0.14246544f, 0.16288388f, 0.00792257f, 0.27040857f, 0.21344131f, 0.21294026f, 0.01204799f, 
    -0.08143108f, 0.12398644f, 0.03482610f, -0.01242459f, 0.26527783f, 0.05709684f, -0.12103497f, 0.19624336f, 
    0.09861837f, 0.03991732f, 0.03860458f, -0.00384395f, -0.35737032f, 0.01047661f, 0.02259875f, 0.03145397f, 
    0.00967383f, 0.01403329f, -0.10118473f, 0.03055225f, -0.02587873f, -0.03317640f, 0.13337459f, -0.09725124f, 
    -0.02892897f, -0.08324942f, -0.06857375f, 0.00492844f, -0.07232175f, -0.06897226f, 0.04002613f, -0.02251941f, 
    0.01935846f, 0.02498299f, 0.01750644f, 0.05789440f, -0.07175286f, -0.05197712f, 0.03478201f, -0.04653427f, 
    -0.00597727f, -0.04777317f, 0.03260146f, 0.04111269f, 0.01220841f, 0.05614911f, 0.03241570f, -0.05780281f, 
    0.02436112f, 0.02608241f, -0.08366712f, -0.01447560f, 0.00732930f, -0.03494273f, -0.06317334f, 0.01753892f, 
    0.00260832f, -0.04861145f, 0.05545454f, -0.03208618f, -0.00734660f, -0.05471337f, -0.03291450f, 0.00852377f, 
    0.03667768f, -0.03538617f, 0.02752611f, 0.06223772f, -0.05527982f, -0.02033930f, -0.02065701f, 0.02441130f, 
    0.01401651f, -0.06120605f, -0.04765736f, -0.06013805f, 0.02320324f, 0.01047820f, -0.06144584f, -0.04180245f, 
    0.01725237f, -0.02524395f, 0.01083671f, -0.06550702f, 0.00701977f, -0.02740871f, -0.08486036f, 0.00591705f, 
    0.04507665f, -0.04874155f, -0.08704542f, 0.02455355f, 0.03052734f, -0.06407655f, -0.03764892f, -0.03638847f, 
    0.05392791f, -0.02055310f, -0.01847128f, -0.06444620f, -0.00758609f, -0.04333289f, 0.03232812f, 0.05059494f, 
    -0.00040616f, 0.04266877f, 0.02995021f, 0.00577206f, -0.05588779f, -0.08142903f, 0.02255252f, -0.03425114f, 
    0.03705156f, -0.06656611f, -0.04277588f, 0.00356728f, 0.05707799f, -0.03486894f, -0.07946652f, 0.05441612f, 
    -0.02742536f, -0.09193177f, -0.00976844f, 0.02314076f, -0.04415730f, 0.02286942f, 0.00809799f, -0.01959724f, 
    -0.06326006f, -0.03322654f, -0.04172059f, -0.01458100f, -0.07360340f, 0.03607402f, -0.02718452f, -0.07039007f, 
    -0.01043902f, 0.04562767f, -0.01034163f, 0.02873814f, 0.01870097f, -0.06138598f, -0.06242280f, 0.04225230f, 
    0.04578806f, -0.07553559f, 0.04372603f, -0.05465733f, -0.00903888f, 0.02960342f, -0.04911185f, 0.02326111f, 
    -0.06830128f, -0.08686391f, -0.06261373f, 0.04540240f, 0.04735309f, -0.05162470f, -0.03692180f, 0.05369660f, 
    -0.04852560f, -0.04748575f, -0.04513504f, -0.07770634f, -0.02636152f, -0.01469085f, 0.01151017f, -0.04700856f, 
    -0.07644995f, -0.01975426f, -0.03522897f, -0.04053621f, -0.01490073f, -0.05086183f, -0.01105820f, 0.00754288f, 
    0.05912974f, -0.06691539f, 0.04927266f, -0.03095946f, 0.04494606f, 0.02793644f, -0.03729250f, -0.04575692f, 
    -0.03556443f, 0.01904538f, -0.03044591f, 0.02117488f, 0.04096189f, -0.06959284f, -0.04042412f, -0.00360722f, 
    -0.05504066f, 0.00247081f, 0.03890560f, -0.02951851f, 0.00483365f, 0.03495046f, 0.02636989f, -0.05237802f, 
    -0.07189321f, 0.02645625f, -0.02503699f, 0.02282364f, -0.08008685f, -0.04225125f, -0.01547593f, -0.05769291f, 
    -0.06957909f, 0.03972944f, 0.04896394f, -0.01832682f, -0.07076532f, -0.02839360f, -0.06159686f, -0.00316889f, 
    -0.14018059f, 0.03707916f, -0.07336157f, -0.00252892f, 0.19056681f, 0.09045533f, 0.11966386f, 0.21092457f, 
    -0.02188662f, 0.01106341f, 0.08637536f, -0.17815514f, -0.21576747f, -0.10797902f, -0.01392525f, -0.00453671f, 
    0.10985546f, 0.02825258f, 0.09203710f, 0.01167685f, -0.00144131f, -0.02540752f, 0.07384433f, -0.01280085f, 
    0.38062671f, -0.37873346f, 0.24183016f, -0.12647958f, 0.12689018f, 0.11556521f, -0.01858198f, 0.08242311f, 
    -0.07104214f, 0.08876853f, -0.09200065f, -0.01853935f, -0.06344640f, 0.01604929f, 0.02486664f, 0.14563547f, 
    0.02731645f, 0.03142665f, 0.04873690f, 0.02146572f, -0.00453752f, 0.04215873f, -0.02485493f, -0.02277798f, 
    -0.03562176f, 0.24651586f, 0.08786861f, -0.42448404f, 0.02499909f, -0.17965648f, -0.16705054f, -0.13552120f, 
    0.02923704f, 0.06936912f, -0.06906809f, 0.03310790f, 0.33111247f, 0.05387656f, 0.05896034f, -0.24681428f, 
    0.00703007f, 0.05471221f, -0.02693192f, -0.05602441f, 0.02571598f, -0.13764389f, -0.03544699f, -0.01381332f, 
    0.27566224f, -0.14380687f, 0.14357036f, 0.32001132f, 0.13183799f, 0.07960345f, 0.15132394f, -0.07509204f, 
    -0.00721487f, 0.17009495f, -0.07389628f, 0.07946676f, 0.24109405f, -0.09492964f, 0.42178267f, -0.04040984f, 
    -0.21528508f, -0.04977580f, -0.12294117f, -0.11073780f, 0.09650349f, 0.03880920f, 0.17981091f, 0.08877365f, 
    -0.03024070f, 0.07810414f, 0.08021550f, 0.05936909f, 0.11664023f, 0.02560880f, 0.08432658f, 0.07823969f, 
    -0.00810648f, 0.03534936f, 0.10853849f, -0.12306569f, 0.20415340f, -0.19055305f, 0.05173046f, -0.01262658f, 
    0.09558927f, 0.13422734f, 0.12546170f, 0.04901948f, 0.02400612f, -0.07987901f, -0.03199009f, 0.07381093f, 
    -0.26883423f, -0.14328130f, -0.19584805f, -0.27811506f, -0.09894944f, -0.13128906f, -0.01831932f, 0.14542279f, 
    -0.06161603f, 0.03312169f, 0.02817326f, 0.12546535f, 0.10919038f, -0.08562315f, 0.10098533f, -0.17630254f, 
    0.08543698f, 0.12913020f, -0.00804972f, 0.07045319f, -0.02844637f, -0.02123728f, 0.01900384f, 0.06531782f, 
    -0.27441981f, -0.27784455f, 0.03902951f, -0.21494298f, 0.17327179f, -0.03208160f, -0.06445863f, -0.01808838f, 
    0.11068071f, -0.17647164f, 0.11761066f, 0.04212492f, 0.22620264f, 0.47747192f, -0.27336895f, 0.07693370f, 
    -0.02047092f, -0.10571826f, 0.00690746f, -0.00782788f, 0.02982257f, 0.06129190f, -0.02369145f, -0.05369204f, 
    0.12629567f, -0.07819317f, -0.31150752f, -0.20460156f, 0.02285251f, 0.10961801f, 0.10025761f, 0.07229291f, 
    -0.00343015f, -0.05917849f, 0.08078051f, 0.20231406f, 0.07854132f, 0.00378753f, -0.03464440f, 0.00793654f, 
    -0.08352541f, -0.07848880f, 0.06315186f, 0.03582289f, -0.00310072f, 0.13124824f, 0.00516165f, -0.01473011f, 
    0.07320192f, 0.36625710f, -0.10693766f, -0.08569486f, 0.01715099f, -0.13396628f, 0.03040309f, -0.08703603f, 
    -0.10258120f, 0.09809501f, -0.03853875f, 0.11049198f, -0.07781212f, -0.02760091f, -0.04876263f, -0.00937970f, 
    -0.04740024f, -0.01639416f, -0.15192248f, -0.05475064f, -0.08481094f, -0.01874728f, 0.02988872f, 0.02610870f, 
    -0.02837409f, 0.12195805f, 0.24506217f, -0.08308109f, -0.00953350f, -0.12096582f, 0.19487114f, 0.08829173f, 
    0.09459174f, -0.01084973f, 0.03783200f, 0.03250460f, -0.03165698f, 0.02990739f, -0.00101608f, 0.10756558f, 
    -0.02787424f, 0.21832056f, 0.05830067f, 0.05873973f, -0.01405985f, -0.09238832f, 0.03452105f, 0.05621072f, 
    -0.18470059f, 0.10617286f, -0.32280725f, -0.06539106f, -0.08573303f, -0.08886999f, 0.05007282f, -0.12252665f, 
    -0.05138534f, 0.01391644f, 0.25050917f, 0.01895196f, 0.15551965f, 0.21285044f, 0.00323818f, 0.07239603f, 
    0.04752644f, 0.10304616f, 0.13980204f, -0.11358313f, -0.13375691f, -0.04172814f, 0.06894037f, 0.07627874f, 
    0.10303959f, 0.08787372f, -0.01315902f, -0.16716698f, -0.09324750f, -0.07376713f, -0.05974753f, 0.02579539f, 
    0.02614137f, 0.00453374f, -0.13051756f, -0.09366082f, -0.25375664f, -0.24983256f, -0.03550272f, 0.05937849f, 
    0.01969971f, -0.09438714f, 0.06637194f, 0.17621033f, 0.12393757f, -0.05296623f, 0.01034152f, -0.08080463f, 
    0.08281338f, 0.07438689f, 0.03488251f, 0.13334811f, 0.10125209f, 0.16836347f, 0.10142825f, 0.04168779f, 
    -0.14917378f, -0.07506309f, 0.18568258f, 0.10866591f, 0.09573300f, 0.16889638f, 0.21457803f, -0.05172058f, 
    0.07305480f, -0.09563967f, 0.02029333f, 0.00423559f, -0.02118551f, 0.04175165f, -0.03769192f, 0.09155271f, 
    0.33818009f, 0.32620931f, 0.26689106f, 0.07884873f, 0.15148543f, 0.14211249f, -0.02516256f, -0.04724953f, 
    0.07689451f, -0.03836813f, -0.08640449f, -0.07371701f, -0.42892644f, -0.08786836f, -0.03759543f, -0.10491951f, 
    -0.00330057f, -0.09351990f, -0.07312120f, -0.05769688f, 0.00493373f, -0.04641702f, 0.01307022f, -0.02924198f, 
    0.10247090f, -0.09499228f, -0.17913580f, -0.14819738f, 0.05108152f, 0.00188164f, 0.17817868f, -0.17430359f, 
    -0.11497431f, -0.03666968f, -0.05987715f, 0.01996627f, -0.01674125f, -0.17776515f, 0.10893022f, 0.10880005f, 
    0.08336404f, 0.12748653f, -0.03247944f, 0.04024780f, 0.04955766f, -0.04428980f, 0.19672900f, 0.14285594f, 
    0.19366939f, -0.00025001f, -0.21046810f, 0.09226378f, 0.11939404f, -0.07296069f, 0.12987718f, -0.01234298f, 
    0.09229905f, 0.20663719f, -0.02419783f, -0.07923852f, -0.35204020f, -0.14784954f, -0.07783671f, 0.04453785f, 
    -0.01495016f, -0.04958265f, -0.16339910f, 0.02451785f, -0.01590329f, 0.03966344f, -0.07777271f, -0.08144957f, 
    0.16043988f, 0.05706804f, -0.09185477f, -0.05187017f, 0.19624896f, -0.20516881f, 0.11438930f, 0.06031508f, 
    -0.14428543f, -0.01848549f, -0.11983415f, 0.04083520f, -0.03980405f, -0.05973358f, 0.09493740f, 0.09080930f, 
    -0.04551496f, 0.08717762f, 0.05958568f, 0.01611819f, 0.05862905f, 0.02158379f, 0.13041268f, 0.06509029f, 
    -0.04562459f, -0.09929784f, 0.11730374f, -0.17062862f, -0.05993335f, -0.02309044f, -0.03981012f, -0.08808441f, 
    0.06625014f, -0.02298095f, 0.01445802f, 0.08970819f, -0.15651698f, -0.08905447f, -0.00778256f, -0.06151973f, 
    -0.10470671f, -0.01103385f, 0.03804947f, -0.02060962f, 0.01706700f, -0.13008553f, 0.14321542f, 0.01267382f, 
    0.28800005f, -0.06843812f, -0.00951987f, -0.02500588f, -0.08247265f, 0.03319112f, 0.11656540f, 0.03229150f, 
    -0.08057927f, -0.07887276f, 0.05140497f, 0.22436391f, 0.14375575f, 0.06029744f, -0.04530058f, 0.00304458f, 
    0.02417738f, 0.06451686f, 0.16716306f, -0.08087134f, -0.15077752f, -0.13050890f, -0.11529302f, -0.01242657f, 
    0.08022940f, -0.28713712f, -0.08949437f, -0.22346501f, 0.07966369f, 0.00746508f, -0.11639155f, -0.10434978f, 
    -0.09148634f, 0.02376029f, 0.04737785f, 0.02302513f, 0.18777260f, -0.02761587f, -0.05535132f, 0.10513404f, 
    -0.00397336f, 0.02745305f, 0.09865564f, 0.06808992f, -0.06439118f, 0.08511089f, -0.11255975f, -0.27164039f, 
    0.06813557f, 0.23091018f, 0.09704430f, -0.04351493f, 0.09232683f, 0.01798297f, 0.12359137f, -0.03119126f, 
    -0.01667329f, -0.04532986f, -0.09783638f, 0.02806528f, 0.01692550f, 0.10887401f, 0.04844044f, -0.21988598f, 
    0.01479896f, 0.06862054f, 0.07053471f, 0.05613821f, 0.02716842f, 0.13116050f, 0.02267661f, -0.00339619f, 
    0.31621414f, 0.21698113f, 0.11096343f, -0.04078342f, 0.04530080f, -0.02475034f, 0.05017964f, 0.11648850f, 
    0.01948125f, -0.01597710f, -0.19295663f, -0.06049599f, -0.16064988f, 0.03509283f, 0.10975494f, -0.01604660f, 
    0.06783598f, 0.07364528f, -0.00398526f, 0.07267378f, 0.07481088f, -0.12960531f, -0.14332089f, -0.07580350f, 
    0.35601869f, 0.07491606f, 0.11278334f, 0.02978694f, -0.14520355f, 0.01933401f, 0.13806191f, -0.14017573f, 
    -0.02641585f, -0.02473073f, 0.04536408f, 0.00787552f, -0.20776229f, -0.14064382f, 0.03452788f, -0.03568384f, 
    0.07027902f, 0.09899957f, -0.00764780f, 0.10546856f, 0.03234760f, -0.17455609f, 0.02889666f, 0.06039819f, 
    0.25293180f, -0.12841204f, -0.08146992f, 0.06526141f, 0.00855023f, -0.13467821f, 0.17838220f, -0.02186044f, 
    0.15837058f, 0.09314049f, 0.03163440f, 0.01261788f, -0.10480611f, -0.10354302f, -0.09841156f, 0.02602302f, 
    0.00255848f, -0.10212462f, -0.04515269f, -0.04930796f, -0.02624508f, 0.00989232f, -0.02019991f, 0.13462582f, 
    -0.00123327f, 0.38047823f, 0.23586036f, -0.32134712f, -0.05400524f, -0.17315736f, 0.11094101f, 0.00498510f, 
    0.03388235f, 0.04847598f, -0.01379445f, -0.06591912f, 0.14651169f, 0.18052381f, 0.07541800f, 0.05716557f, 
    0.00896441f, -0.09480558f, -0.00276696f, 0.04526274f, -0.16609435f, -0.11637389f, -0.02715792f, -0.08085714f, 
    0.21734892f, -0.19567420f, -0.18055391f, 0.03295484f, -0.00160724f, -0.14753248f, 0.24804635f, -0.01309565f, 
    -0.03139289f, 0.06884912f, 0.05408600f, -0.02221588f, -0.19794767f, -0.35309014f, -0.15837538f, 0.18029445f, 
    0.07395899f, 0.09794693f, 0.18866010f, 0.04032311f, 0.08503395f, -0.04898627f, -0.07993205f, -0.09498468f, 
    -0.11122904f, -0.08345291f, -0.08061665f, -0.06033296f, 0.08362494f, -0.08151279f, 0.08310018f, 0.06154752f, 
    0.11920574f, 0.09565125f, -0.01623737f, -0.09945548f, 0.16961399f, -0.09750259f, 0.14376514f, -0.17695726f, 
    -0.03690180f, 0.10534930f, -0.14965223f, -0.27546683f, 0.09770355f, 0.06975306f, 0.08298207f, 0.13677628f, 
    0.70934254f, 0.40912822f, 0.08602419f, 0.06214376f, 0.01771063f, -0.11748639f, 0.08391555f, -0.18406701f, 
    0.08103240f, 0.07462747f, -0.04859322f, -0.18002295f, 0.05225484f, -0.14607987f, -0.16728282f, 0.03457635f, 
    -0.09374730f, -0.13384210f, 0.00282002f, 0.03660890f, 0.11397539f, 0.06420291f, 0.07955635f, 0.20861857f, 
    0.18080850f, 0.01013905f, -0.01243634f, 0.12588403f, 0.03229893f, 0.07080700f, -0.05159312f, -0.04583430f, 
    -0.07675882f, 0.07860328f, 0.09805553f, -0.04174442f, 0.32574350f, -0.14176109f, 0.02994446f, 0.14320862f, 
    0.08012952f, -0.08391275f, 0.11702587f, -0.08756033f, 0.14797017f, -0.13704973f, -0.03656011f, 0.02828436f, 
    -0.43595934f, 0.00982584f, 0.00990846f, 0.03424057f, -0.17856568f, -0.03758711f, 0.01892403f, -0.14600384f, 
    -0.01538108f, 0.04577087f, 0.20332131f, 0.27637416f, 0.37878752f, 0.23119158f, 0.20727068f, 0.05054334f, 
    0.16313754f, -0.03954696f, -0.05679975f, 0.04713025f, 0.03279047f, 0.00609088f, 0.21694523f, 0.00274837f, 
    -0.21216062f, -0.00487504f, -0.10208492f, 0.10710162f, 0.02077189f, -0.03034966f, -0.06463857f, -0.03414143f, 
    0.10368259f, -0.10715221f, -0.06509241f, -0.05295064f, 0.14918582f, -0.16299583f, 0.13413410f, 0.08144619f, 
    0.09093591f, 0.02262798f, -0.11040986f, 0.07864422f, -0.07383396f, -0.00857524f, 0.04572872f, -0.11688688f, 
    0.01398438f, -0.03107208f, -0.11673088f, -0.11778408f, -0.06579613f, -0.01450038f, 0.31528023f, 0.07183377f, 
    0.00874028f, -0.10727338f, -0.17344542f, 0.06651449f, 0.03809917f, 0.14574200f, -0.13246606f, -0.07817566f, 
    0.07144856f, -0.09523041f, -0.00236725f, 0.05755116f, 0.18703307f, 0.19832903f, 0.05958982f, 0.09716206f, 
    -0.12744759f, -0.22951958f, -0.32786003f, -0.14987741f, 0.16754222f, -0.07070864f, 0.27280024f, 0.05283923f, 
    -0.11948066f, 0.08600712f, -0.11280227f, -0.06866331f, 0.02514739f, -0.05946098f, 0.05777318f, 0.06598653f, 
    -0.06337457f, -0.07988801f, 0.05731377f, -0.10780571f, 0.06005438f, -0.04253997f, 0.13059080f, 0.13600335f, 
    0.12792237f, -0.39842615f, -0.08904724f, 0.07615283f, 0.01515356f, 0.28643557f, -0.00512952f, -0.22145109f, 
    -0.16430059f, 0.05452540f, 0.20741673f, -0.05111684f, -0.22657220f, 0.13655096f, 0.04247310f, 0.15024905f, 
    0.03190155f, 0.06087280f, 0.20993139f, -0.07475325f, -0.18063046f, -0.13472748f, -0.05729518f, -0.02577058f, 
    0.02177454f, -0.00970564f, 0.03693756f, -0.06713232f, -0.12291964f, -0.05804458f, 0.04733510f, 0.00583537f, 
    0.12100838f, -0.12426528f, -0.07974865f, -0.05159488f, -0.17743178f, -0.23434919f, -0.20526946f, 0.04860155f, 
    0.12141749f, 0.01605970f, 0.01804447f, 0.18768840f, 0.10868216f, 0.18867658f, -0.06014179f, 0.03945855f, 
    0.08616562f, 0.51071316f, -0.30246949f, 0.08610028f, -0.01832114f, -0.11472400f, 0.16269332f, -0.05794227f, 
    0.06940179f, -0.02808799f, -0.03057139f, 0.03473125f, 0.23472671f, 0.00438721f, 0.09334517f, 0.18294093f, 
    0.03455286f, 0.02871931f, 0.03489557f, 0.10912494f, 0.09166425f, 0.10870516f, 0.22140133f, -0.01885478f, 
    0.00546385f, 0.03841193f, 0.00403172f, 0.06438562f, -0.02057437f, 0.07597913f, 0.07493854f, -0.00189822f, 
    0.00254433f, -0.10706985f, -0.08959878f, 0.08974764f, -0.05170632f, -0.17624755f, -0.32122728f, -0.14815229f, 
    -0.14585277f, -0.09398494f, 0.02151814f, -0.06403795f, -0.05733324f, -0.11308378f, 0.03570710f, -0.09543506f, 
    0.12243275f, -0.05324916f, 0.26066312f, 0.21147765f, -0.13842322f, -0.04139675f, 0.05788556f, 0.05626421f, 
    0.01803464f, -0.08857325f, 0.07905735f, 0.12021679f, 0.15711087f, 0.45680723f, 0.08533250f, 0.02323033f, 
    -0.11609091f, -0.07507191f, -0.01678285f, 0.00735383f, 0.08426629f, 0.05677057f, 0.10538367f, -0.02642301f, 
    0.06542861f, 0.00402328f, 0.13890100f, 0.04789537f, -0.15829869f, -0.07866108f, -0.11499618f, -0.08215830f, 
    -0.11978508f, -0.12541704f, -0.21388763f, -0.00780542f, -0.13029762f, 0.38728267f, -0.21340325f, -0.11782639f, 
    -0.06412702f, -0.09307638f, 0.14161859f, 0.11648071f, 0.03839744f, -0.00297315f, -0.01118373f, 0.05973613f, 
    0.16621856f, 0.02055988f, -0.06994174f, -0.07604190f, -0.02622283f, 0.01147263f, 0.25256363f, 0.08048781f, 
    0.15866891f, -0.10724217f, -0.09047349f, -0.01633012f, 0.12019205f, 0.16210395f, 0.22470577f, -0.06228602f, 
    -0.07108294f, 0.01959196f, 0.05675733f, 0.02812856f, 0.01604622f, 0.16208370f, 0.21791269f, 0.09891211f, 
    0.14935288f, -0.22515397f, 0.22877188f, -0.00275780f, -0.08829805f, -0.01674782f, -0.06938113f, 0.04025908f, 
    0.08551744f, -0.00519009f, -0.04481356f, 0.08366825f, 0.15432988f, 0.04488275f, -0.06200301f, -0.11597559f, 
    -0.07475445f, -0.01359277f, 0.01866010f, -0.00958877f, 0.12274901f, 0.01289473f, -0.03793496f, 0.05493655f, 
    -0.17656727f, 0.06199840f, -0.08606679f, 0.23021136f, 0.20545703f, -0.07780656f, 0.01521236f, 0.07097247f, 
    0.05289915f, -0.00179090f, 0.03893856f, 0.13749667f, -0.03569921f, 0.22886600f, 0.39488959f, -0.04105401f, 
    -0.06831475f, -0.09607591f, 0.02754709f, 0.02671377f, 0.00075400f, 0.15046272f, 0.05881909f, -0.08568120f, 
    -0.03337494f, -0.01979956f, 0.15048215f, 0.05184884f, -0.03881447f, -0.06288456f, -0.02914800f, -0.08595990f, 
    0.14731435f, -0.10260059f, 0.01279428f, 0.00461743f, -0.24284793f, -0.15142879f, 0.32330579f, 0.07174473f, 
    -0.07937758f, -0.08474495f, -0.15420738f, 0.07987031f, 0.05825581f, 0.09458992f, 0.17041129f, -0.01416854f, 
    -0.21224339f, -0.29856771f, 0.26728144f, 0.18575180f, 0.08575962f, -0.00329466f, 0.10803514f, 0.21288641f, 
    -0.11695549f, -0.03621431f, 0.04707975f, 0.13906144f, -0.17844011f, -0.08676507f, -0.16383308f, 0.29669055f, 
    0.08760747f, -0.03011765f, -0.04042598f, -0.07950481f, 0.06753076f, -0.17639963f, -0.00714105f, 0.15808791f, 
    0.00933948f, -0.12020592f, 0.18552448f, 0.04545058f, -0.18326741f, 0.14344458f, 0.11856101f, -0.05427070f, 
    0.13108583f, 0.16801527f, 0.06112806f, 0.17539223f, -0.14517958f, 0.10118233f, 0.08000471f, 0.20709087f, 
    -0.05234681f, -0.13869743f, -0.01917957f, 0.02951862f, 0.00056119f, -0.08923409f, -0.07857490f, -0.08357460f, 
    -0.33871824f, -0.23750101f, -0.14875677f, 0.09396547f, -0.03097504f, 0.03127468f, 0.02125235f, 0.06014128f, 
    -0.04242376f, 0.10246132f, 0.01839775f, 0.08007602f, 0.10226706f, -0.04560327f, -0.11062036f, 0.15727329f, 
    0.09108172f, 0.01542651f, 0.06339672f, 0.11794396f, -0.06489698f, 0.11394659f, -0.16370441f, -0.19756138f, 
    0.07839730f, 0.14696611f, -0.09521143f, -0.06143297f, 0.07436237f, 0.03552629f, 0.00897384f, 0.20236465f, 
    -0.13360722f, 0.05466624f, -0.21461648f, -0.23300843f, 0.24785438f, -0.11648914f, 0.16174559f, -0.30238912f, 
    0.01550466f, -0.05080800f, 0.08713202f, 0.01305407f, 0.10285722f, 0.16741894f, -0.09307581f, 0.00278742f, 
    -0.29674950f, 0.09949539f, 0.21252555f, -0.06893224f, 0.07439745f, 0.15289533f, -0.09016817f, 0.02763023f, 
    -0.14596823f, 0.03989802f, -0.04316009f, 0.01222025f, 0.17391640f, -0.01305238f, -0.10797533f, 0.20412913f, 
    -0.01207992f, 0.00499594f, 0.13313124f, -0.00421675f, 0.25503677f, 0.00893233f, 0.31442484f, 0.19558394f, 
    -0.04163177f, 0.25903076f, 0.16056474f, -0.28907442f, 0.05188366f, -0.14262937f, 0.10586516f, 0.01605805f, 
    -0.04199172f, 0.00618177f, -0.05567158f, -0.12993798f, 0.24987157f, 0.21635535f, 0.16512816f, 0.15948667f, 
    -0.04808533f, -0.00937201f, 0.06738557f, 0.07107553f, -0.10625304f, -0.23112047f, -0.11641368f, -0.16502908f, 
    0.02978528f, -0.30986178f, 0.17469701f, -0.10097167f, -0.07723530f, 0.03127708f, 0.16376811f, -0.03177392f, 
    0.07258967f, 0.05138883f, -0.02802614f, -0.03584675f, -0.10344197f, -0.01952378f, -0.12427921f, 0.11791220f, 
    -0.11643680f, -0.05607121f, 0.09650290f, 0.05187986f, 0.07683942f, 0.00820780f, 0.00401106f, 0.05491473f, 
    0.05261246f, 0.04140294f, -0.01689377f, -0.14315388f, -0.11511992f, -0.14491537f, 0.08393103f, -0.01415061f, 
    0.13245034f, -0.09396539f, 0.18324189f, 0.07191006f, 0.05104777f, -0.05101964f, 0.17941365f, 0.00513184f, 
    0.02040482f, -0.01436881f, -0.00625488f, -0.11090466f, -0.07929601f, -0.13976707f, 0.08600708f, 0.02490831f, 
    0.33161885f, 0.05532473f, -0.26065308f, -0.34592637f, -0.03657805f, -0.00686733f, 0.13532740f, -0.07743361f, 
    -0.00213855f, 0.03874072f, -0.04263715f, -0.04411297f, 0.37600121f, -0.10970606f, 0.06093591f, 0.28951040f, 
    0.08355396f, -0.05452751f, 0.00937678f, 0.06469373f, 0.06100859f, 0.06936259f, 0.00951013f, 0.05749337f, 
    -0.16550533f, 0.01331553f, 0.04919936f, 0.00229555f, -0.04635626f, 0.11248062f, 0.01006600f, -0.05902088f, 
    -0.03166778f, 0.21536791f, 0.00423985f, -0.00205362f, 0.09850635f, -0.09807925f, -0.08160821f, -0.03334033f, 
    0.07182413f, -0.10175315f, -0.01023834f, -0.12106806f, 0.05770670f, -0.04719597f, 0.02621315f, -0.07091562f, 
    -0.13626602f, 0.17197137f, 0.17787425f, -0.07863908f, -0.10462042f, -0.02766446f, 0.07199486f, 0.06133410f, 
    0.06613949f, 0.01463493f, 0.07502492f, 0.08452189f, 0.22992909f, 0.26250684f, 0.02677881f, 0.08384678f, 
    0.06648277f, 0.06771448f, -0.07630416f, -0.09075843f, -0.01974379f, -0.03092778f, 0.02492448f, -0.00037404f, 
    0.00835138f, -0.08577403f, 0.06698991f, -0.24824424f, 0.14433631f, 0.10642989f, 0.13121797f, 0.04780688f, 
    0.04071941f, 0.02616956f, -0.06591389f, -0.07410169f, 0.04937139f, -0.17829648f, -0.03114239f, 0.01629708f, 
    -0.02310743f, 0.07969903f, -0.06918511f, 0.19369002f, 0.17980357f, -0.09111894f, 0.10878370f, 0.24248114f, 
    0.12633182f, -0.19245626f, -0.01099408f, 0.04533200f, -0.18232188f, -0.00023389f, 0.27576938f, -0.07405904f, 
    0.25247112f, 0.05478641f, -0.01687701f, -0.04286016f, -0.04568307f, 0.18679504f, 0.07525498f, 0.07406732f, 
    0.04800677f, -0.09624716f, -0.02694193f, -0.06128025f, 0.03939005f, 0.09832101f, 0.12108096f, 0.16324739f, 
    0.07918228f, -0.21675552f, -0.19726568f, -0.06544907f, 0.08903437f, -0.12720342f, 0.16111292f, 0.06339540f, 
    -0.02212111f, -0.07868818f, -0.13205972f, -0.00761962f, -0.03692598f, -0.06246692f, 0.06173380f, 0.16126832f, 
    -0.09407818f, 0.05951291f, 0.03949916f, -0.02768806f, 0.08283130f, -0.20735095f, 0.15128176f, 0.14444454f, 
    0.12566572f, -0.34755701f, 0.29986811f, -0.20479167f, -0.10074742f, 0.09836153f, -0.18679748f, -0.08047096f, 
    -0.12864348f, -0.04470908f, 0.05062041f, 0.00545770f, -0.37294614f, 0.31999552f, -0.10188954f, 0.25558642f, 
    -0.17225581f, -0.00399760f, 0.00817992f, -0.04484190f, 0.04422245f, -0.07569024f, 0.04622158f, 0.11753329f, 
    0.22620836f, -0.18531677f, 0.11469673f, -0.08471494f, -0.14133683f, -0.11640882f, -0.00612406f, 0.04443189f, 
    0.07895085f, 0.13131586f, 0.09657814f, -0.02614472f, -0.03824558f, 0.09958930f, -0.00969543f, 0.06244274f, 
    0.16361274f, -0.09127872f, 0.15002367f, 0.20685677f, -0.01181353f, -0.00503791f, -0.09331552f, 0.04075955f, 
    -0.35057431f, -0.17514236f, -0.40284511f, -0.16036318f, -0.13041858f, 0.08386800f, -0.03932139f, 0.06693509f, 
    0.02327883f, 0.01067832f, -0.04680526f, -0.03139351f, 0.18837832f, 0.02704033f, 0.14600943f, 0.27165323f, 
    -0.03040777f, -0.10095666f, 0.01958107f, 0.04756531f, -0.01967816f, 0.00278308f, 0.01613833f, -0.00827508f, 
    -0.21411188f, 0.29505703f, 0.23354018f, -0.12018204f, -0.07560212f, -0.03182255f, -0.04886360f, 0.09972551f, 
    0.07088954f, -0.13491476f, -0.09483939f, -0.05192648f, -0.06343389f, 0.16680713f, -0.05417765f, -0.18319193f, 
    -0.12852333f, 0.02488608f, -0.05664089f, 0.12511101f, -0.09803113f, -0.05902208f, -0.02138678f, -0.00737890f, 
    0.31639615f, 0.24790950f, 0.37647182f, -0.00806691f, -0.09721971f, -0.01860518f, 0.02944760f, 0.03619570f, 
    0.15465273f, 0.01083479f, -0.07715024f, -0.11855808f, -0.12621586f, 0.08698101f, 0.01247576f, 0.08744319f, 
    -0.10102479f, 0.04677029f, 0.09085009f, -0.14546140f, 0.12143511f, 0.01607540f, 0.04889932f, 0.01225587f, 
    0.25573307f, -0.11834502f, 0.13006583f, 0.01714964f, 0.06558414f, 0.12050071f, 0.12563375f, -0.09456735f, 
    0.08886150f, 0.08615310f, 0.07581137f, 0.01338843f, -0.12662919f, 0.22657543f, -0.19617024f, -0.48107859f, 
    -0.10752640f, 0.15322915f, -0.03119416f, 0.11500793f, 0.25425863f, -0.09471512f, -0.00817141f, 0.12917620f, 
    0.29604274f, -0.39588138f, 0.22142886f, 0.09156384f, -0.10985835f, -0.15301789f, 0.20639685f, 0.00678383f, 
    0.18366756f, 0.09109511f, 0.10751937f, -0.00846926f, -0.15692049f, 0.06461322f, 0.01397779f, 0.14221235f, 
    -0.02774511f, -0.06583941f, 0.05012254f, -0.15260819f, 0.04210795f, 0.00340731f, -0.02859955f, 0.09860864f, 
    -0.08095475f, -0.10101372f, -0.06646635f, 0.00993992f, -0.08855495f, -0.02155177f, -0.13204241f, 0.01244373f, 
    -0.04320757f, -0.03901990f, 0.02009868f, -0.07237892f, -0.08901077f, -0.04236897f, -0.03151805f, -0.02449247f, 
    0.01028625f, 0.05379762f, 0.00692995f, -0.03933052f, -0.06282667f, -0.04581637f, 0.05635154f, 0.04260224f, 
    -0.06506553f, -0.06831588f, -0.10162513f, -0.00110702f, -0.05952923f, -0.06763470f, -0.05115470f, -0.01674064f, 
    -0.09058636f, 0.04266080f, -0.07259616f, 0.02211925f, -0.02882840f, 0.04395355f, -0.05094314f, -0.00563022f, 
    0.05108895f, 0.00576293f, -0.03913112f, 0.04349126f, -0.04325329f, 0.02711379f, 0.07597956f, -0.07351024f, 
    0.05205163f, 0.06125809f, -0.03201351f, -0.03144414f, -0.01819789f, -0.04384673f, -0.01268341f, 0.08061934f, 
    0.03070373f, 0.01148284f, -0.00993993f, -0.07473113f, -0.02532990f, -0.08869696f, -0.11143223f, -0.12040371f, 
    -0.06185381f, -0.08910733f, -0.08641037f, -0.03939102f, -0.04325472f, 0.01358696f, -0.03331211f, -0.11973041f, 
    0.01496459f, 0.05247305f, 0.05146772f, 0.01232184f, -0.10026894f, 0.00932158f, -0.00345844f, -0.07753692f, 
    -0.01816375f, 0.07795328f, -0.02130440f, 0.06134416f, 0.00863382f, 0.00491790f, -0.00178599f, -0.00159771f, 
    0.06544539f, 0.09817988f, 0.00928843f, -0.03116017f, 0.00791597f, -0.02191947f, -0.00867097f, -0.07524166f, 
    -0.02059961f, -0.06198151f, -0.03769915f, -0.07066497f, -0.01722417f, -0.03122754f, -0.05566984f, -0.03754432f, 
    -0.00016451f, -0.12733774f, -0.02800396f, 0.01396101f, -0.00835192f, 0.03584014f, -0.08858474f, -0.09748038f, 
    -0.03831986f, -0.02439393f, -0.01977630f, -0.04264415f, 0.01253274f, 0.00055618f, -0.03860407f, 0.05248272f, 
    -0.09995660f, -0.04345835f, -0.02732204f, -0.05070389f, 0.00903181f, -0.01197286f, -0.10015687f, -0.09836017f, 
    -0.03657062f, -0.02902589f, -0.01143282f, -0.10873971f, -0.02777920f, -0.09379489f, -0.03123934f, -0.02488781f, 
    -0.06719851f, 0.03304511f, -0.05629048f, 0.04728077f, -0.05743507f, -0.02553531f, -0.04816307f, -0.04814745f, 
    0.01626885f, -0.06604383f, -0.00162058f, 0.00033027f, -0.02763883f, -0.00160856f, -0.07269751f, -0.06980649f, 
    -0.00724911f, 0.05316611f, 0.01509942f, 0.07431007f, 0.01671495f, -0.02169354f, 0.00972696f, -0.00105692f, 
    0.00721273f, -0.08566938f, -0.03456014f, -0.06807496f, 0.00072998f, -0.06167013f, 0.01855630f, 0.03119289f, 
    -0.04666755f, 0.04379207f, 0.07953138f, 0.02894797f, -0.10174421f, -0.09651030f, -0.05587704f, 0.04794263f, 
    -0.02739771f, -0.08032968f, 0.03618510f, 0.04097877f, -0.04959792f, -0.06847464f, -0.01948184f, -0.00681901f, 
    -0.02620517f, 0.03482732f, 0.01317940f, 0.02182559f, -0.05794479f, 0.01398735f, 0.03907831f, -0.04224646f, 
    -0.13283074f, 0.10692110f, -0.25878355f, 0.00783825f, 0.09866065f, -0.04409957f, -0.04150156f, -0.16032560f, 
    -0.00484674f, 0.02957361f, -0.02893012f, 0.03527506f, -0.01996000f, 0.04721105f, 0.09940302f, 0.02581610f, 
    -0.10745712f, -0.17077331f, -0.12518504f, -0.05532374f, -0.11717708f, -0.04847839f, 0.00803219f, -0.12402241f, 
    0.10288291f, -0.02285557f, -0.07038768f, -0.04413993f, -0.02048131f, 0.10471770f, 0.06558426f, 0.02384879f, 
    0.04740481f, 0.00540326f, 0.16120607f, 0.04986417f, -0.13495402f, -0.26172104f, -0.20623240f, 0.06920228f, 
    0.15073477f, 0.19634058f, 0.08733536f, 0.05493499f, 0.00679075f, 0.00768882f, 0.00815386f, 0.05250650f, 
    0.02277332f, -0.12198084f, -0.08481865f, -0.21824124f, -0.02234681f, 0.04045507f, -0.04461603f, 0.05302251f, 
    -0.04964850f, 0.13496652f, 0.07056324f, -0.06140172f, -0.05574135f, 0.00653451f, -0.30757186f, 0.09274476f, 
    -0.02337223f, 0.06565908f, 0.15318607f, -0.01848180f, 0.04619287f, -0.02498893f, -0.07617268f, 0.09413385f, 
    -0.02712178f, 0.41478288f, -0.22046034f, 0.15409216f, -0.03288003f, 0.04686144f, 0.10206513f, -0.12260721f, 
    0.01778304f, 0.02759793f, -0.01158365f, -0.03304396f, -0.06439446f, -0.07272161f, -0.12598653f, -0.13404691f, 
    -0.11129209f, -0.03099672f, -0.10165428f, -0.01922876f, 0.10016950f, 0.26579708f, 0.11820561f, 0.10200235f, 
    -0.12300606f, 0.02800108f, -0.21050867f, 0.01811511f, 0.01439197f, 0.08648637f, -0.00548338f, 0.01288592f, 
    -0.11655939f, -0.14187910f, -0.10934261f, -0.01053455f, 0.04332520f, -0.21533811f, -0.08800095f, 0.02254381f, 
    0.21155475f, 0.08173805f, -0.04263891f, 0.00131366f, 0.01776734f, 0.01769307f, 0.14086573f, 0.09255791f, 
    0.23923139f, -0.00293755f, 0.19204111f, 0.03024532f, 0.12980926f, 0.09195561f, -0.02400168f, 0.05064728f, 
    0.01721630f, 0.05995252f, 0.05653054f, -0.06917877f, 0.00099250f, 0.26394972f, 0.06428559f, -0.05383070f, 
    -0.21906464f, -0.03959334f, -0.13161550f, -0.20048963f, 0.18621181f, -0.08528872f, 0.12544124f, 0.18781190f, 
    -0.04250263f, -0.06852872f, 0.09308858f, 0.09102736f, -0.09649804f, -0.02128172f, 0.07342488f, -0.13630724f, 
    0.23960401f, -0.07919528f, 0.04950323f, 0.21759014f, 0.06008532f, 0.04461362f, -0.08781029f, 0.22403146f, 
    -0.11371831f, -0.00278565f, 0.09397276f, 0.14951737f, 0.05231718f, -0.01528057f, 0.12989581f, 0.01601234f, 
    0.11150305f, 0.04539835f, -0.07327508f, -0.07527668f, 0.03273529f, 0.03407659f, 0.10981921f, 0.02328227f, 
    0.09767347f, 0.02675000f, -0.04138880f, 0.00605281f, 0.01750632f, 0.15652508f, 0.20151447f, -0.03603041f, 
    -0.00071878f, -0.00092396f, -0.04755405f, 0.02843809f, -0.13360725f, -0.04634043f, -0.27329016f, -0.20276758f, 
    0.13213904f, 0.19101071f, 0.26491049f, 0.08815284f, 0.07220180f, 0.13140629f, 0.11578491f, 0.14322789f, 
    -0.00270630f, 0.00986421f, 0.06419885f, -0.12674485f, 0.00605214f, -0.06615416f, -0.03984311f, 0.07176184f, 
    0.11029880f, 0.08805747f, -0.04788269f, -0.31556025f, 0.22414050f, 0.22741009f, 0.20263577f, 0.22550677f, 
    0.10155717f, -0.06458237f, 0.03194717f, 0.11009106f, 0.02903047f, 0.03956653f, -0.03884074f, 0.07703245f, 
    -0.09158192f, 0.06296675f, -0.17614645f, 0.03274045f, 0.38710800f, -0.02154645f, 0.08730914f, 0.06867596f, 
    0.06547861f, -0.11585961f, -0.05370776f, -0.00706078f, 0.04215141f, 0.03277384f, -0.01981254f, -0.00221452f, 
    0.08643162f, 0.03475303f, 0.00895243f, -0.38990659f, 0.01100288f, -0.15005821f, -0.07925824f, 0.19796778f, 
    0.10470052f, -0.06245538f, -0.01174905f, -0.03144492f, 0.07048096f, -0.05445238f, 0.23286495f, 0.12213905f, 
    0.02150209f, -0.00838133f, 0.05047211f, 0.12604089f, 0.05042072f, -0.02851694f, 0.18256268f, -0.01404092f, 
    -0.02601246f, 0.09649593f, 0.04504675f, -0.00372924f, 0.00690559f, 0.03777784f, -0.08652884f, 0.12009133f, 
    0.10313846f, -0.05535303f, -0.18199617f, 0.00529211f, 0.27138186f, -0.11873540f, 0.23636512f, -0.39955145f, 
    -0.17106675f, -0.03269267f, -0.18921810f, -0.09305082f, 0.04245705f, -0.01354983f, -0.08472887f, -0.03096887f, 
    -0.02663513f, -0.00265212f, 0.21138421f, 0.06139480f, 0.03112731f, -0.12655567f, 0.01939993f, -0.00349797f, 
    0.25296900f, 0.19548225f, 0.26632911f, 0.22616735f, 0.02691948f, -0.04594709f, -0.01306946f, 0.10649008f, 
    -0.07585363f, -0.00664970f, 0.08087927f, 0.13791928f, -0.05350787f, 0.07118447f, -0.04577186f, -0.20257573f, 
    -0.19270836f, -0.11352862f, 0.00626867f, 0.25088948f, 0.08292653f, 0.12109571f, -0.03430078f, 0.13249305f, 
    0.12569118f, 0.07676864f, -0.01480320f, 0.25321659f, -0.11236615f, -0.15483616f, 0.14278251f, -0.05689662f, 
    0.00799616f, -0.08319215f, -0.06526182f, 0.03614021f, -0.12190606f, 0.01383723f, -0.09737191f, -0.10869855f, 
    -0.18358937f, 0.07689694f, -0.01981362f, 0.03754496f, 0.06459055f, 0.02075623f, -0.05773297f, 0.01587050f, 
    -0.38940299f, -0.15841666f, -0.23541509f, -0.43681708f, -0.21726914f, 0.24351314f, 0.03887843f, 0.18412323f, 
    -0.00504450f, 0.15933819f, -0.03747887f, -0.09845868f, -0.03297329f, 0.07606508f, -0.02806486f, -0.11253469f, 
    -0.17116426f, 0.03568187f, -0.07595144f, -0.16035196f, -0.07148664f, 0.00947194f, 0.01114726f, -0.28119859f, 
    -0.07084417f, -0.08967233f, -0.11472579f, -0.11863168f, 0.28929543f, 0.01521803f, 0.01644119f, 0.18934804f, 
    -0.12113499f, -0.15020883f, 0.04361422f, -0.05279730f, 0.10967664f, 0.18988052f, 0.12547018f, 0.36255118f, 
    0.18523093f, 0.06137701f, 0.03582260f, -0.05629334f, 0.02616387f, 0.01516518f, 0.06760613f, 0.15003394f, 
    -0.01137232f, 0.08297656f, -0.00244111f, -0.00285515f, -0.23606512f, -0.30108717f, -0.08157300f, 0.06735094f, 
    0.09955995f, 0.11247057f, -0.03611423f, -0.09002306f, 0.08945975f, 0.09928846f, 0.15215677f, 0.11918800f, 
    0.21958037f, -0.18872458f, 0.07906671f, -0.10499504f, 0.02546738f, -0.01813583f, -0.00534981f, 0.09654450f, 
    -0.07558079f, -0.09142761f, -0.00294487f, 0.02388999f, 0.02486725f, 0.10630614f, 0.16860899f, -0.06483968f, 
    0.00989955f, 0.00397241f, 0.01006125f, 0.07140402f, -0.05811109f, -0.05254084f, -0.05331461f, 0.02152219f, 
    0.12685645f, -0.04983059f, 0.08237433f, -0.15687244f, -0.06874006f, -0.08570055f, -0.07182478f, 0.07239743f, 
    0.12160301f, 0.07112417f, 0.07927668f, 0.06329201f, 0.21100895f, 0.02646746f, 0.08362968f, -0.02584495f, 
    0.13917789f, -0.09175857f, 0.01947552f, -0.05099152f, 0.07007861f, 0.04657894f, 0.01464413f, 0.06533692f, 
    0.14764294f, -0.26157343f, 0.07299300f, -0.07506962f, 0.09252945f, 0.00089342f, 0.07177261f, 0.07705695f, 
    0.04304898f, 0.00499116f, -0.03773388f, -0.04055415f, 0.18403041f, -0.30095923f, 0.20109737f, 0.15018034f, 
    0.04728585f, -0.11187177f, -0.03467118f, -0.06223441f, 0.08699393f, -0.12274000f, -0.03768339f, 0.04384245f, 
    0.13146503f, 0.19259435f, 0.26013112f, 0.07086699f, 0.14668994f, -0.01243398f, 0.06055027f, -0.01225633f, 
    0.24494028f, 0.10381729f, 0.09411873f, 0.13819526f, 0.14549178f, 0.27839896f, 0.15122785f, -0.04330448f, 
    -0.10366756f, -0.09354512f, 0.14535671f, 0.08107612f, 0.11782424f, -0.08330898f, 0.01219304f, -0.04418341f, 
    0.15344369f, 0.03386958f, -0.03649030f, 0.01868216f, -0.06853251f, 0.08996703f, 0.02171139f, -0.01949326f, 
    0.04983594f, -0.02837665f, 0.05206503f, 0.10527875f, -0.19470558f, -0.31585431f, -0.04434763f, -0.02744277f, 
    0.12556860f, 0.01200208f, -0.04137251f, -0.02213606f, -0.10563883f, -0.06577133f, -0.07459628f, -0.07788623f, 
    0.02002929f, -0.19195597f, -0.11155384f, -0.06571738f, 0.16980700f, 0.04618862f, 0.01741379f, 0.03409520f, 
    -0.08366627f, -0.09409796f, -0.06960171f, -0.17931615f, -0.21879700f, 0.16622923f, 0.19198330f, -0.14377734f, 
    0.11027061f, 0.03305202f, 0.01684190f, -0.06550972f, 0.09818070f, -0.01177375f, -0.07980703f, 0.12005001f, 
    0.23781440f, -0.35402709f, -0.04801177f, -0.03019677f, 0.06341758f, -0.05747266f, 0.05114492f, -0.05260385f, 
    -0.00948626f, -0.01645032f, 0.00879058f, -0.09109744f, -0.16490175f, -0.12101568f, -0.21207006f, 0.25101352f, 
    -0.06748526f, -0.01183829f, -0.03763786f, -0.11806602f, 0.15248379f, 0.10598458f, 0.18907665f, 0.28492776f, 
    -0.07625685f, 0.12311934f, 0.25343126f, 0.18409596f, -0.07703477f, 0.04084848f, -0.02336608f, -0.05583541f, 
    -0.02224534f, -0.08860955f, 0.02930464f, -0.09241720f, 0.09351011f, 0.25024608f, 0.06517927f, -0.21499099f, 
    -0.11165532f, -0.01059287f, 0.05845346f, -0.11212458f, 0.09057744f, 0.16128211f, -0.06975803f, 0.03649357f, 
    -0.10892561f, 0.24515502f, -0.16776165f, 0.30089420f, 0.08124914f, -0.06202585f, 0.00425924f, 0.05459823f, 
    0.08158965f, 0.12945469f, 0.09160937f, 0.09188027f, 0.80615973f, -0.31192729f, -0.14397825f, -0.14548671f, 
    -0.03123520f, -0.13586591f, -0.06327426f, 0.02841661f, -0.10334530f, -0.02257545f, -0.11034983f, -0.05508590f, 
    -0.26473659f, 0.03789723f, -0.03528541f, 0.13707355f, 0.00686648f, 0.04294797f, 0.09709244f, 0.18209699f, 
    -0.06504684f, -0.00978172f, 0.26713523f, 0.01290751f, 0.02901175f, -0.07590582f, -0.09000353f, 0.12611085f, 
    -0.04401217f, 0.14040038f, -0.16507502f, -0.00775493f, -0.07208356f, -0.07751749f, 0.02519244f, 0.07860354f, 
    0.01147733f, 0.39435092f, -0.05996251f, 0.06818761f, -0.11295730f, -0.04040318f, -0.11190332f, -0.08501264f, 
    0.12562075f, -0.01108468f, 0.05101110f, -0.06808911f, 0.29709920f, 0.03807098f, -0.17947873f, -0.57607949f, 
    0.05374771f, 0.11386903f, 0.01660235f, -0.13413778f, 0.11201723f, 0.18123414f, 0.03975735f, -0.00637578f, 
    -0.05755416f, -0.25205773f, -0.19716127f, 0.22524047f, 0.21028145f, -0.07405668f, 0.03242394f, -0.07823218f, 
    -0.17651385f, 0.03195829f, 0.01938464f, 0.06649763f, 0.05038435f, -0.17455980f, -0.08339017f, 0.21901545f, 
    -0.04108708f, 0.01271588f, 0.04561255f, 0.05188260f, -0.04477030f, 0.02111999f, 0.10774660f, -0.10305742f, 
    -0.11170521f, -0.22294949f, -0.17080490f, 0.16949402f, 0.15727650f, 0.09455086f, -0.02693591f, 0.07309521f, 
    -0.10447398f, -0.03436412f, -0.09460025f, 0.14372294f, 0.25031948f, -0.01808159f, 0.25678810f, -0.07003685f, 
    -0.05235990f, -0.03443358f, 0.00679067f, -0.04052916f, 0.06316829f, -0.00376909f, 0.02134101f, 0.09253769f, 
    -0.18756679f, 0.22157252f, 0.10798822f, 0.05441550f, -0.03844981f, 0.08365104f, 0.06011037f, 0.02411580f, 
    0.05019517f, 0.02199803f, 0.09113082f, 0.00401407f, -0.36049891f, -0.16509463f, 0.23157938f, 0.60310644f, 
    -0.09653821f, 0.18241197f, 0.05179362f, 0.15076046f, -0.07971456f, 0.03383296f, 0.14886147f, 0.12483421f, 
    -0.21689047f, 0.22211042f, 0.13623199f, -0.14585684f, -0.14185785f, 0.16489480f, 0.00106916f, 0.03253075f, 
    -0.00713015f, -0.06041616f, -0.12259857f, -0.02318837f, 0.32456547f, 0.05349186f, 0.04013228f, -0.19814324f, 
    -0.10095047f, 0.01508098f, 0.01555547f, 0.05675814f, 0.00641982f, 0.04873241f, -0.23166895f, -0.02403483f, 
    -0.06572615f, -0.06653614f, -0.12274725f, 0.08743825f, -0.10297883f, 0.09544144f, -0.07847636f, -0.12738268f, 
    0.07816375f, -0.07168398f, 0.00559558f, 0.22792356f, 0.03491757f, -0.03034977f, -0.03510669f, 0.00102950f, 
    -0.03899413f, -0.05828260f, -0.02440253f, -0.00938397f, -0.24831755f, -0.13322179f, -0.06799137f, -0.03507074f, 
    -0.14695267f, 0.52737045f, 0.06610466f, 0.14324100f, -0.12676923f, 0.10020362f, 0.03823755f, 0.01660161f, 
    0.04102877f, -0.10046147f, 0.21183588f, 0.15318426f, -0.27116922f, 0.06684627f, -0.07990291f, -0.04210792f, 
    0.04640157f, 0.07534388f, 0.06836785f, 0.14651652f, 0.06982326f, 0.08249281f, 0.01465223f, -0.04662607f, 
    -0.05680583f, -0.02499242f, -0.24304035f, 0.03885739f, -0.08341137f, 0.17170841f, -0.04309250f, -0.00612084f, 
    0.03869189f, 0.12168763f, -0.14859276f, -0.14835271f, -0.13297379f, 0.17246263f, -0.11633892f, 0.04941529f, 
    -0.03306994f, 0.09630919f, 0.13446717f, 0.06031036f, 0.25519902f, 0.24507543f, 0.10465033f, 0.11677841f, 
    -0.14807068f, 0.16785830f, 0.10381470f, 0.06493800f, -0.04786756f, -0.04689964f, 0.04366677f, 0.05347596f, 
    0.02786172f, 0.08970610f, -0.13637023f, -0.09076709f, -0.38892663f, 0.04560091f, -0.27454162f, 0.18495402f, 
    -0.09811251f, -0.13588719f, 0.03693611f, 0.01241988f, -0.03720277f, 0.13477384f, 0.06429140f, 0.13617527f, 
    0.03946894f, 0.05381925f, -0.20938341f, -0.06192202f, -0.11674713f, 0.00123403f, -0.19326705f, 0.06961361f, 
    -0.08535010f, 0.03852126f, -0.15798317f, -0.14920814f, -0.15663141f, 0.07866130f, 0.04583277f, -0.01784792f, 
    0.12001557f, 0.09554710f, -0.06369360f, 0.03855136f, 0.16349806f, 0.09124993f, 0.06081348f, 0.16341233f, 
    0.29849291f, 0.21948375f, 0.21534643f, -0.01449442f, -0.04346756f, 0.08719677f, 0.03216548f, -0.06868277f, 
    0.20904779f, 0.04526769f, 0.10316274f, -0.10946379f, -0.11996720f, 0.25338516f, -0.10700554f, 0.15414843f, 
    0.01601631f, -0.05124697f, -0.02816991f, 0.01291802f, 0.00468497f, 0.07000730f, 0.14108278f, 0.05169848f, 
    -0.02640835f, 0.01859603f, -0.08181366f, 0.14722264f, -0.10500441f, -0.04536152f, -0.08460417f, -0.05424772f, 
    0.17474918f, -0.01691174f, 0.13694750f, 0.18205039f, 0.19706401f, -0.09283131f, 0.03431157f, -0.23848687f, 
    -0.01975731f, 0.13956164f, 0.14484960f, -0.09480913f, -0.00122981f, -0.15272285f, -0.04164441f, 0.10381576f, 
    0.02857802f, 0.00885173f, 0.14204668f, 0.13055746f, -0.02008598f, 0.06184042f, 0.05782601f, 0.13566764f, 
    0.15688311f, 0.02850906f, 0.07087813f, -0.02070782f, -0.06295624f, -0.03656814f, -0.03579631f, -0.05726920f, 
    0.17671649f, 0.09092298f, -0.02352913f, 0.17588860f, -0.06096910f, -0.10684837f, -0.07359450f, -0.24527255f, 
    -0.19472557f, 0.10024944f, 0.21250956f, 0.17205155f, 0.04838814f, 0.17481065f, 0.16065630f, 0.14374495f, 
    0.05718647f, 0.01585285f, 0.09483483f, -0.09261441f, -0.03057931f, 0.10731146f, -0.04228695f, -0.24401471f, 
    0.09823776f, -0.05126926f, -0.04437896f, -0.06915100f, 0.10652207f, 0.09365918f, -0.06296268f, 0.00992179f, 
    0.06323316f, -0.07271776f, 0.12338088f, 0.32161203f, 0.06376205f, 0.06267753f, 0.04285597f, 0.03588893f, 
    -0.08604833f, 0.00172361f, -0.01416432f, 0.09615887f, 0.34871566f, -0.00640048f, -0.01105525f, 0.14453708f, 
    0.22213626f, 0.03778376f, 0.01473128f, -0.01025574f, -0.05607351f, 0.12010515f, -0.06963744f, 0.09448130f, 
    -0.46546483f, 0.10818776f, -0.01385369f, -0.08641745f, 0.16031851f, -0.12506427f, -0.16508871f, -0.04571829f, 
    -0.08873893f, -0.05616970f, 0.01202015f, -0.12093163f, -0.08487996f, -0.06914701f, 0.00351896f, 0.05787138f, 
    -0.03764664f, 0.06605480f, -0.07405268f, 0.16529478f, 0.15538564f, 0.00319839f, 0.10226940f, -0.00504237f, 
    -0.01642478f, 0.27826986f, -0.03573582f, 0.42949656f, 0.02470789f, -0.01277516f, -0.05856552f, 0.05896036f, 
    0.08388598f, -0.05745212f, 0.01850200f, 0.13184336f, 0.11293484f, -0.04796306f, 0.00076273f, -0.50067842f, 
    -0.11364798f, 0.01579472f, -0.08046030f, -0.14789437f, -0.03112818f, -0.04558857f, 0.15072207f, 0.20648141f, 
    -0.11629216f, -0.19014093f, 0.00145950f, 0.10076312f, -0.04195006f, 0.00978754f, -0.06256343f, 0.00012731f, 
    0.02215081f, 0.00079875f, 0.03009517f, -0.05411652f, 0.04629795f, -0.12196837f, -0.01168324f, 0.32661092f, 
    0.13890502f, 0.00569927f, -0.00646838f, 0.16252995f, 0.12673905f, -0.08668465f, -0.03066357f, -0.11037333f, 
    -0.31840354f, -0.26309875f, -0.13228913f, 0.05754941f, -0.05341547f, -0.01066249f, -0.00258446f, 0.06784006f, 
    -0.08401298f, 0.07170450f, 0.06793650f, 0.12348273f, 0.11983464f, -0.08255596f, 0.01577405f, -0.08008578f, 
    -0.04344961f, -0.03520435f, 0.08508307f, 0.04177415f, 0.03862149f, 0.11338472f, 0.10576363f, 0.11389258f, 
    -0.41317371f, -0.05197870f, 0.08967175f, -0.11072844f, -0.00238909f, -0.05416682f, -0.03862723f, 0.02100654f, 
    -0.08707631f, -0.06418496f, 0.07756733f, 0.01237496f, -0.01401590f, 0.36095843f, -0.02768060f, 0.26605394f, 
    0.01403729f, -0.11733022f, -0.00334388f, -0.09231704f, 0.01755421f, 0.20511007f, 0.02485411f, -0.19539654f, 
    -0.23753913f, 0.26840401f, -0.13226752f, -0.08365419f, 0.00169159f, 0.16243915f, 0.01038668f, -0.01556900f, 
    -0.04963881f, -0.13013041f, -0.02870132f, 0.09047704f, 0.13032235f, -0.00861421f, -0.00767225f, -0.03022263f, 
    0.04520741f, 0.10147393f, -0.05121866f, 0.06743824f, 0.07056027f, 0.07950647f, 0.06439897f, -0.06221599f, 
    -0.13616243f, -0.16855735f, -0.15447813f, 0.22716689f, 0.04677620f, -0.03018641f, 0.08212715f, -0.10992020f, 
    0.11319627f, -0.00074815f, -0.02218021f, 0.01098843f, 0.02150181f, -0.01492283f, -0.02756939f, -0.12770672f, 
    -0.12935457f, -0.05088827f, -0.08902207f, -0.15211619f, 0.15866123f, -0.02317146f, 0.07856622f, -0.01044744f, 
    -0.03590915f, -0.03035907f, 0.09359999f, 0.18952182f, -0.06044542f, 0.20493379f, -0.00997266f, -0.00026923f, 
    -0.04904822f, -0.01811903f, 0.11111250f, 0.07979673f, 0.00968119f, 0.07017703f, -0.14504562f, 0.22277345f, 
    0.13296245f, -0.04766787f, 0.12693033f, 0.07989252f, -0.08890959f, -0.07335546f, 0.01987100f, 0.05497748f, 
    -0.06139846f, -0.14245887f, 0.10464555f, -0.20731777f, -0.08715046f, 0.00330348f, -0.15943964f, -0.04741156f, 
    -0.01869977f, 0.03527417f, 0.05516506f, -0.01424450f, -0.28218615f, -0.08719899f, -0.20787302f, 0.15293330f, 
    -0.03499514f, 0.00545183f, -0.02819638f, 0.23064430f, 0.12768909f, 0.07665969f, 0.01781305f, 0.06896014f, 
    -0.39704096f, 0.39319479f, -0.31635347f, 0.26464182f, -0.12595645f, 0.09342556f, -0.03608533f, -0.02518884f, 
    0.12797303f, -0.03967738f, 0.06604425f, -0.01734136f, 0.12081834f, 0.08982491f, -0.08903641f, -0.35387924f, 
    0.03261370f, -0.03439883f, -0.03429805f, -0.05506929f, 0.01963608f, 0.16184974f, 0.08554922f, 0.00831858f, 
    -0.21088408f, -0.01937744f, -0.03455836f, 0.10134178f, 0.00492969f, -0.02654266f, -0.05475762f, -0.01890960f, 
    -0.02626823f, -0.15582737f, -0.14982520f, -0.04362511f, -0.17186201f, -0.15606277f, -0.15794815f, 0.07254107f, 
    -0.01485976f, 0.09183708f, -0.13097075f, 0.13420200f, -0.16379887f, 0.10502562f, 0.08402126f, -0.05960179f, 
    -0.00747510f, -0.13378660f, 0.19167243f, 0.14968798f, 0.10365302f, -0.01870477f, 0.07064123f, 0.05601161f, 
    -0.02382967f, 0.08533079f, 0.01666394f, -0.01897338f, 0.10735989f, 0.48705670f, 0.05826799f, -0.03321764f, 
    -0.30516285f, -0.05786538f, 0.00651286f, -0.16241138f, 0.09236892f, 0.08427559f, 0.05569089f, 0.06363084f, 
    0.14585161f, -0.03118087f, 0.21188875f, 0.12209582f, -0.06303158f, -0.00034291f, -0.04971070f, -0.13994196f, 
    0.04013065f, 0.04116497f, -0.06033566f, 0.03282828f, -0.09626417f, 0.36781150f, -0.12534177f, 0.07912245f, 
    -0.02477554f, 0.11413005f, 0.13061309f, 0.02770702f, 0.19630654f, 0.05809681f, 0.17682455f, -0.00756184f, 
    -0.06911073f, 0.15907976f, 0.12974206f, -0.05549871f, -0.03175645f, 0.09727698f, 0.01678422f, 0.06556296f, 
    0.15713970f, -0.01165175f, -0.08722452f, -0.17070219f, 0.25861755f, 0.22786902f, 0.26171285f, -0.09489442f, 
    -0.00177885f, -0.03897658f, -0.02799842f, -0.11834887f, -0.07410942f, -0.00920463f, -0.10082239f, -0.07515018f, 
    0.08916029f, -0.03898453f, -0.31907475f, 0.13189897f, -0.09167875f, -0.04754066f, 0.06005909f, -0.09920351f, 
    -0.08536897f, -0.00106066f, -0.01364425f, 0.00304058f, -0.05542611f, 0.10655778f, 0.08465471f, -0.03069830f, 
    -0.16348445f, 0.01853014f, -0.14453515f, -0.11117224f, -0.04317326f, 0.06253073f, -0.00173398f, -0.03745969f, 
    0.01089429f, 0.53129011f, 0.08959400f, 0.02848908f, -0.08329577f, 0.09403694f, -0.04463627f, -0.01976707f, 
    -0.02920310f, -0.01201053f, 0.23535046f, 0.02563668f, 0.20389724f, -0.02051968f, -0.17705618f, 0.02254077f, 
    0.07809160f, 0.12489969f, -0.04940036f, 0.08901903f, -0.04695644f, -0.01122337f, 0.04347002f, 0.04593555f, 
    -0.17136157f, -0.08959329f, -0.15120518f, 0.12280664f, -0.17266074f, 0.18546878f, 0.01529709f, -0.00781684f, 
    0.00149707f, 0.08272201f, 0.18029806f, -0.01399122f, 0.14233725f, 0.12510504f, -0.26260078f, 0.12590288f, 
    0.12251872f, 0.04888375f, 0.12718752f, 0.12190674f, -0.06158787f, 0.11583422f, -0.05000653f, 0.07243396f, 
    -0.01308540f, 0.30100325f, -0.08079825f, -0.23934829f, -0.09582232f, -0.01893878f, 0.02521027f, -0.05603300f, 
    0.14369170f, -0.12383103f, -0.02889840f, -0.09968309f, -0.18993357f, 0.28346911f, -0.22033322f, -0.23349147f, 
    -0.06065952f, -0.01275912f, 0.00999963f, 0.02200496f, -0.01968274f, 0.09159670f, 0.07199793f, -0.00747562f, 
    0.08585774f, 0.06850834f, -0.15144809f, -0.00552682f, 0.18155056f, -0.04876376f, -0.08260202f, 0.07674780f, 
    -0.16965677f, -0.08045448f, -0.07425775f, 0.03155309f, 0.07122666f, 0.15212077f, -0.06907459f, -0.26082984f, 
    0.07166325f, 0.04523848f, -0.00634859f, 0.01023874f, -0.06134512f, 0.04699824f, 0.18808980f, -0.04678367f, 
    0.60997242f, 0.21385048f, 0.23625238f, 0.08854354f, 0.23137839f, 0.19587380f, 0.00522395f, -0.14398758f, 
    0.07423832f, -0.00139240f, -0.04521205f, -0.09465612f, -0.30097461f, 0.07278389f, -0.02467244f, 0.01806642f, 
    -0.13961415f, -0.13757969f, -0.05447152f, -0.10406992f, 0.12701474f, 0.01329892f, 0.02106958f, 0.11974102f, 
    -0.07820510f, -0.02791470f, 0.15418930f, 0.22292189f, -0.12991802f, -0.09560560f, 0.02739898f, -0.02835134f, 
    0.14858423f, 0.15665251f, 0.18114957f, 0.10674449f, -0.18565661f, -0.15264890f, 0.28176516f, 0.37848738f, 
    -0.05150702f, 0.26761320f, 0.23553278f, -0.03334239f, -0.09405126f, -0.10887526f, 0.07047643f, 0.17467250f, 
    0.03961591f, 0.10614269f, -0.00819604f, -0.02918978f, 0.03629453f, 0.02213108f, 0.10121366f, 0.11820557f, 
    0.21026547f, 0.09718968f, 0.04483205f, -0.03560856f, -0.03773445f, 0.10569267f, 0.24468745f, -0.01180454f, 
    -0.11136085f, -0.08369692f, -0.05584234f, -0.00254683f, -0.15381445f, -0.10843186f, -0.19798048f, -0.10747712f, 
    -0.09616674f, 0.10260368f, 0.19100173f, -0.02201521f, -0.14861207f, 0.07978986f, -0.06613231f, -0.06853856f, 
    0.09823595f, -0.00665275f, -0.03986583f, 0.04040176f, 0.10089818f, 0.24044447f, 0.12522073f, -0.17640162f, 
    -0.07150365f, -0.06062585f, -0.10326599f, -0.11480139f, -0.16175397f, -0.01469329f, -0.11476715f, -0.01010396f, 
    0.11136425f, 0.31207448f, -0.09851184f, 0.17111099f, -0.00099441f, 0.05035688f, 0.21555716f, 0.12529424f, 
    0.07250153f, 0.11250933f, 0.11736887f, 0.15219945f, 0.16672368f, -0.22912546f, -0.19082539f, -0.01340387f, 
    0.09306357f, 0.00560783f, 0.06389785f, 0.08849904f, 0.11802105f, 0.03834871f, 0.07634801f, -0.04923746f, 
    -0.29730573f, -0.33761391f, -0.13404119f, 0.10240009f, -0.13178438f, 0.01607008f, -0.12471465f, 0.09471657f, 
    -0.01238936f, 0.01649026f, -0.06935488f, -0.15704884f, -0.00526768f, 0.05978516f, -0.11010554f, 0.09951629f, 
    -0.11204153f, -0.01205178f, 0.00688178f, -0.03851843f, 0.04939058f, 0.05263022f, 0.08641620f, 0.06332366f, 
    0.23340820f, 0.40380219f, -0.01072632f, 0.02172537f, 0.06158279f, -0.00019408f, 0.07734480f, -0.00777878f, 
    0.07595961f, 0.03919198f, 0.04678377f, -0.05598889f, -0.14136733f, 0.07188474f, -0.31923956f, -0.12348355f, 
    -0.02633342f, -0.02164698f, -0.07467604f, -0.07458031f, -0.07568862f, 0.01238215f, 0.02307024f, 0.01254383f, 
    0.15380321f, -0.10715882f, -0.17310649f, 0.10818177f, 0.02726547f, -0.11847366f, -0.16683526f, -0.04428476f, 
    -0.19711977f, -0.17366937f, -0.10453337f, -0.11311143f, 0.04285130f, -0.10823583f, 0.03846433f, 0.14321092f, 
    0.09217227f, -0.06679212f, -0.01873652f, 0.02568007f, 0.00983275f, -0.08430193f, -0.02149816f, -0.00386250f, 
    -0.15144308f, -0.11669229f, -0.09590405f, -0.04316081f, -0.02723269f, 0.06803848f, 0.08677650f, -0.08148725f, 
    0.00753463f, 0.06271729f, -0.03740108f, -0.02914518f, 0.35239941f, 0.21943560f, -0.03972824f, 0.25647521f, 
    -0.06581236f, -0.10642122f, -0.09655827f, -0.00895112f, 0.11383531f, -0.04323679f, 0.24049684f, 0.07681563f, 
    -0.14603652f, 0.03945335f, -0.10864774f, 0.12596020f, -0.10839009f, 0.07705057f, 0.01089339f, -0.03874594f, 
    0.07867985f, -0.04115377f, 0.03946404f, 0.19464827f, -0.03553336f, -0.04228396f, 0.29583901f, 0.18513027f, 
    -0.05873223f, 0.12776785f, 0.00979391f, 0.10722533f, -0.11574017f, 0.10625144f, 0.03813927f, 0.04686989f, 
    -0.18295281f, -0.10835224f, 0.22771338f, -0.04730375f, -0.07431875f, 0.10840119f, -0.05113345f, 0.15561208f, 
    0.11085911f, -0.08759479f, -0.10749584f, 0.00920621f, 0.03570576f, 0.14371030f, -0.04184121f, -0.22680011f, 
    0.10825142f, 0.06504614f, -0.01508154f, 0.08626342f, -0.02947769f, 0.10898136f, -0.12625429f, -0.14085904f, 
    0.37125099f, -0.22087145f, 0.17489183f, 0.11910583f, -0.12413388f, -0.02902712f, 0.01078344f, 0.02721725f, 
    0.00930945f, 0.04053134f, -0.15491794f, -0.01130274f, 0.18207560f, 0.03363620f, 0.02077895f, 0.04322047f, 
    -0.05940291f, 0.17125280f, -0.05039467f, -0.13932544f, 0.03582899f, -0.03072199f, -0.03268648f, 0.13987234f, 
    0.03693861f, 0.15317716f, -0.18687868f, 0.05236095f, -0.08569815f, 0.05100644f, 0.01888537f, 0.07983342f, 
    -0.03058976f, -0.08786836f, 0.02275267f, 0.09049094f, 0.04612075f, 0.11227801f, 0.09422016f, -0.18131928f, 
    0.05653707f, -0.20598483f, -0.11765451f, -0.02714597f, 0.08478677f, -0.08480769f, -0.01732786f, -0.05582551f, 
    0.17068289f, -0.18030798f, 0.12418359f, 0.09935278f, -0.17256625f, 0.08390483f, -0.04232488f, 0.05914878f, 
    0.10326557f, -0.07261022f, 0.00125072f, 0.01076734f, -0.12076944f, 0.00316517f, 0.17336008f, 0.20570116f, 
    0.08791059f, -0.04882222f, -0.07532729f, 0.15442783f, -0.02796214f, 0.22967295f, -0.00704799f, -0.07064144f, 
    -0.48924640f, -0.35194200f, 0.03823081f, -0.26658025f, 0.03985294f, 0.08134411f, 0.00891023f, 0.27277991f, 
    -0.00198655f, -0.09420337f, 0.06820004f, 0.09077191f, -0.00612795f, 0.14446884f, 0.08944064f, 0.08927919f, 
    0.05558694f, -0.08217944f, -0.05070300f, -0.18263511f, 0.05129886f, -0.08218098f, -0.09552413f, -0.05150366f, 
    -0.04653024f, 0.12411330f, 0.25970891f, -0.16688736f, -0.01772986f, -0.07565922f, -0.07208800f, -0.10201531f, 
    0.18191569f, 0.06672886f, -0.02313365f, -0.06386910f, 0.10208714f, 0.38466960f, 0.01212971f, 0.07250794f, 
    -0.07057226f, -0.06230226f, 0.04407436f, 0.14745060f, -0.03046602f, -0.07197830f, 0.03471479f, -0.08588570f, 
    0.17802100f, 0.01092145f, -0.26905462f, 0.05918816f, -0.02580035f, 0.03697252f, 0.03227964f, 0.06419723f, 
    0.08490197f, 0.04613211f, -0.05578531f, -0.02285193f, 0.01965463f, 0.01352882f, 0.02291665f, 0.28435358f, 
    0.02884315f, -0.00248307f, -0.02275078f, -0.07956049f, 0.00561887f, 0.01382481f, -0.16751949f, -0.04121496f, 
    0.24155094f, 0.02966805f, 0.05578124f, 0.18582645f, -0.03004664f, 0.09885768f, -0.05508970f, -0.02989042f, 
    -0.14662014f, 0.17969541f, -0.07198431f, -0.03229045f, -0.41842163f, 0.07480474f, 0.40181917f, -0.25439718f, 
    0.02732124f, 0.04281517f, 0.16655469f, 0.03765702f, -0.00205704f, -0.03403623f, -0.02757380f, 0.17457138f, 
    -0.19572346f, -0.17844485f, 0.12004627f, -0.05315731f, 0.04124991f, 0.04747221f, -0.05525075f, 0.09537118f, 
    0.03720465f, 0.06087938f, 0.02463834f, -0.00285492f, -0.11812378f, -0.08575880f, -0.00946232f, 0.26993456f, 
    -0.08830805f, 0.07511979f, -0.01590623f, -0.03778803f, 0.05767478f, -0.10011673f, 0.02656927f, 0.14692520f, 
    -0.22415555f, -0.14851958f, -0.03854091f, 0.11990687f, 0.12000574f, 0.00208014f, 0.14224026f, 0.13602583f, 
    0.11880232f, 0.16215695f, 0.14861874f, 0.02777113f, -0.09267151f, -0.02116215f, -0.15178244f, -0.16604850f, 
    -0.09615459f, -0.05544488f, -0.03001266f, -0.07335718f, 0.02106882f, -0.03684411f, -0.03384447f, -0.09486351f, 
    -0.01775798f, -0.36531344f, -0.00549492f, 0.31073740f, 0.13688295f, 0.16412801f, -0.03673397f, -0.01538885f, 
    -0.07998679f, 0.00356186f, 0.05435908f, 0.02941137f, 0.21224691f, 0.19172285f, 0.14852920f, 0.23112492f, 
    -0.02033431f, -0.18266793f, 0.05434309f, -0.08906593f, 0.11707310f, 0.05826391f, 0.05936117f, 0.24895559f, 
    -0.23999147f, -0.03573543f, 0.17090394f, -0.11178684f, -0.09299333f, -0.25346410f, -0.23340611f, 0.01245732f, 
    0.08934008f, -0.02438875f, -0.02113126f, 0.01806130f, -0.23468041f, -0.23203924f, -0.00727417f, 0.02409353f, 
    -0.00377939f, -0.04157248f, -0.13231656f, 0.16455750f, 0.07290846f, 0.13549256f, 0.09715049f, 0.02010384f, 
    -0.22986190f, 0.28348950f, -0.15269129f, 0.35760981f, -0.07876664f, 0.03229762f, -0.07331587f, -0.00115603f, 
    0.03318655f, 0.01776859f, 0.12813444f, 0.09410843f, 0.17079987f, -0.11621998f, 0.12889190f, -0.28972045f, 
    -0.01783001f, 0.01665020f, -0.06864865f, -0.02852240f, -0.06466305f, 0.00849012f, 0.09378897f, 0.15698776f, 
    -0.14264520f, -0.07411173f, 0.04270018f, 0.20722894f, -0.00772270f, 0.06170378f, 0.05376919f, 0.05063740f, 
    0.13671598f, 0.12836829f, 0.09467819f, 0.17857601f, -0.12621254f, -0.18098253f, -0.12720515f, 0.22738388f, 
    -0.12755744f, -0.10504928f, 0.07701038f, -0.00317535f, 0.08161695f, 0.09197478f, 0.07732046f, 0.07530408f, 
    -0.29377764f, -0.26176715f, 0.12590009f, 0.19483086f, -0.03746815f, -0.06182977f, -0.04460048f, 0.08556107f, 
    0.05989103f, 0.04236378f, 0.18702269f, 0.03596717f, -0.01244885f, 0.05324021f, -0.11877718f, -0.33135539f, 
    -0.15841059f, -0.00027540f, 0.02774188f, 0.09122776f, -0.04043752f, 0.02250113f, -0.06020540f, -0.09554537f, 
    -0.35903606f, -0.13325316f, 0.10248399f, -0.19383338f, 0.00724712f, -0.06281463f, 0.07081944f, 0.10677878f, 
    -0.01533157f, -0.01645089f, -0.10375203f, -0.12064937f, -0.12386228f, 0.39104086f, -0.15243907f, 0.12406253f, 
    0.00149155f, -0.11097604f, -0.01038611f, -0.07186933f, 0.18021004f, 0.24335063f, 0.10290863f, -0.04688321f, 
    -0.13608548f, 0.28891066f, 0.01284518f, 0.00586285f, -0.15539768f, 0.09305820f, -0.01489476f, -0.00248869f, 
    0.01188236f, -0.04308692f, -0.02551651f, -0.07349673f, 0.33675116f, 0.19393425f, 0.15720250f, -0.00006795f, 
    0.00548534f, 0.02611564f, 0.00492603f, -0.05051430f, -0.03996136f, 0.12586907f, 0.20939457f, 0.16944593f, 
    0.01361057f, 0.00052010f, 0.03538312f, -0.02790741f, -0.02820277f, -0.06208146f, -0.01525403f, -0.00973537f, 
    0.05705595f, 0.00695742f, -0.04925334f, 0.05516335f, -0.05287036f, -0.03260808f, -0.01542780f, -0.02954651f, 
    0.05307142f, -0.02747283f, 0.01176148f, -0.01533024f, -0.09263214f, 0.00720866f, -0.02302866f, 0.02909941f, 
    -0.04012962f, 0.00406502f, 0.04202614f, 0.04093117f, -0.04256314f, -0.05762820f, -0.00062437f, -0.06669949f, 
    -0.07912657f, -0.02142326f, 0.02076714f, 0.02364854f, -0.06278459f, -0.01225054f, 0.01263508f, -0.01617920f, 
    0.01308470f, -0.02893519f, -0.01694475f, 0.03339249f, -0.06603941f, -0.00639724f, -0.02103462f, 0.05869685f, 
    -0.05346722f, 0.02444054f, -0.05149082f, 0.03135625f, 0.04208279f, 0.03951231f, 0.05032779f, -0.03210510f, 
    -0.01546804f, 0.01793060f, -0.07704161f, 0.01178362f, 0.01943736f, -0.01597932f, 0.00364633f, -0.06849959f, 
    0.01881181f, 0.00213420f, -0.01806946f, 0.00111494f, 0.05301090f, -0.02853515f, 0.02872929f, 0.02543411f, 
    0.05917436f, 0.01183968f, -0.00480468f, -0.08198940f, -0.06067503f, -0.00673440f, 0.02477023f, 0.01503499f, 
    0.04121935f, -0.00447726f, 0.02816529f, 0.02243743f, 0.02430221f, 0.03797915f, 0.03503321f, -0.06616437f, 
    0.05015441f, -0.00553962f, -0.06632382f, -0.01947957f, -0.03747849f, -0.08306818f, -0.06607608f, 0.03113266f, 
    -0.06870155f, -0.03116964f, -0.06133365f, 0.04140723f, -0.02304277f, 0.06428016f, -0.05135129f, -0.07835826f, 
    0.05722283f, -0.04624426f, -0.03451121f, -0.07234056f, -0.06766509f, 0.03473826f, -0.06599208f, -0.08078507f, 
    0.01608916f, 0.03057097f, 0.04303002f, -0.01125708f, 0.02587127f, 0.04945683f, -0.08256159f, 0.00025022f, 
    -0.06995888f, -0.01296082f, -0.02228386f, 0.04000135f, -0.01729841f, -0.02955968f, 0.00365935f, 0.01828918f, 
    0.01970787f, 0.04109867f, -0.06531254f, -0.05848577f, -0.08076844f, -0.03087262f, 0.01184205f, -0.07719202f, 
    0.04880739f, 0.02154807f, -0.02024257f, 0.02661520f, -0.07515952f, -0.07739400f, 0.00490717f, 0.04904679f, 
    -0.00218520f, -0.03737306f, -0.02208522f, -0.01633071f, -0.07652785f, -0.02449039f, -0.08158045f, 0.01363248f, 
    -0.06769389f, 0.05637825f, -0.00177991f, 0.05712178f, -0.00122822f, -0.06793489f, -0.02135835f, 0.01562616f, 
    0.01619115f, 0.00143365f, -0.07840009f, 0.04172387f, -0.01082589f, -0.06817713f, -0.02199032f, -0.08715412f, 
    -0.06095485f, 0.00391854f, -0.06503800f, -0.01077060f, -0.02407898f, 0.04999009f, -0.00970036f, -0.05528633f, 
    -0.05263080f, -0.05504829f, -0.05437490f, -0.08344420f, -0.06863330f, 0.01912040f, -0.03739320f, 0.00655328f, 
    0.03814831f, 0.00677177f, -0.04689192f, 0.03709417f, 0.04172601f, -0.07155325f, -0.00824680f, -0.05137304f, 
    -0.04346282f, 0.10524629f, 0.18260916f, 0.09145954f, -0.15491465f, 0.06963547f, 0.05355488f, 0.00257992f, 
    -0.07614926f, -0.02979243f, -0.01333417f, -0.11565024f, 0.20538409f, 0.22164486f, 0.02116194f, -0.19883864f, 
    -0.12006850f, -0.15502362f, -0.09106255f, -0.04502591f, 0.03002584f, 0.14535980f, 0.03468635f, 0.01866904f, 
    -0.06286976f, 0.15837342f, -0.04555164f, 0.38604304f, -0.01581603f, 0.02058257f, 0.05185588f, 0.01688528f, 
    0.06264114f, -0.05431524f, -0.04618699f, 0.03283954f, 0.34061173f, -0.05601887f, 0.13020988f, 0.01837911f, 
    0.25079256f, 0.00685966f, 0.07009853f, 0.02003015f, -0.05880186f, 0.06067753f, -0.02359557f, 0.04542479f, 
    -0.32805249f, 0.08070722f, -0.06495735f, 0.07777929f, 0.20189953f, -0.04361770f, -0.02311559f, 0.17188670f, 
    0.04690507f, 0.08026551f, 0.18890138f, -0.09666373f, -0.25230333f, -0.14488901f, 0.07407453f, 0.21223247f, 
    -0.14796168f, 0.03839636f, -0.06677522f, 0.09598479f, 0.02524883f, 0.09832232f, -0.01480106f, -0.02056238f, 
    -0.21407388f, 0.35976726f, 0.02358774f, 0.24961221f, -0.03861475f, -0.06933510f, -0.00260074f, 0.15262230f, 
    0.08919009f, -0.09243287f, -0.11703237f, 0.04757722f, -0.17398910f, -0.07712068f, -0.08764534f, -0.31912941f, 
    0.20318231f, 0.07590466f, 0.09759588f, -0.15844594f, 0.03902087f, 0.02416189f, -0.05350955f, 0.06361388f, 
    -0.00034354f, -0.25458664f, -0.02066994f, 0.00856882f, -0.14092365f, -0.05077286f, -0.07100767f, 0.02870040f, 
    -0.07852501f, 0.02613662f, 0.12188349f, 0.04775619f, -0.00502552f, -0.07683036f, 0.05516716f, 0.21790367f, 
    0.04151199f, -0.16278338f, 0.00290403f, 0.06521242f, 0.04039091f, -0.02860773f, -0.12271351f, -0.17595780f, 
    -0.27089250f, -0.17452981f, 0.04095711f, 0.20582588f, 0.07399417f, -0.03339523f, -0.03182742f, -0.11918830f, 
    -0.09007576f, 0.05899151f, 0.16301480f, 0.09647422f, 0.17590901f, -0.06568273f, 0.06073889f, -0.05777208f, 
    -0.10102007f, -0.08766787f, 0.04895352f, -0.04838852f, -0.00025902f, 0.10993434f, 0.05939026f, 0.08293276f, 
    -0.06310654f, 0.24387589f, -0.04268418f, 0.12541576f, 0.00922616f, -0.09655356f, -0.00109190f, 0.01710182f, 
    -0.22777845f, -0.02430610f, -0.14393084f, -0.11637226f, 0.05373728f, -0.04479542f, 0.12384555f, 0.14067742f, 
    0.04856229f, -0.14260034f, -0.07541694f, 0.01189663f, -0.06001040f, 0.22728963f, 0.05188175f, -0.07306831f, 
    -0.31286997f, 0.35208195f, 0.04459919f, -0.07274412f, 0.14052656f, 0.07636016f, 0.01470811f, 0.01812519f, 
    -0.07563242f, -0.09555653f, -0.23437892f, -0.10691594f, 0.08098675f, 0.07123221f, 0.12202398f, 0.00529774f, 
    -0.02417824f, -0.05162705f, -0.14599766f, -0.07012711f, 0.05445281f, 0.04060680f, 0.09820158f, -0.01046807f, 
    0.00836395f, -0.07655499f, -0.03795481f, 0.01450789f, 0.05342904f, -0.02446838f, -0.05831910f, -0.04148611f, 
    0.00853064f, 0.01034936f, 0.00885812f, 0.02317358f, 0.02317942f, -0.09410440f, 0.03176335f, -0.10923939f, 
    -0.02686824f, 0.02155672f, -0.08600901f, -0.07027745f, -0.06083602f, 0.03732694f, -0.00678570f, 0.02779141f, 
    0.05264331f, -0.07722441f, 0.01782158f, -0.00349094f, 0.00588633f, -0.05654326f, -0.03752831f, 0.00541727f, 
    -0.01071567f, 0.02592600f, 0.04593671f, -0.02588262f, -0.04447297f, -0.03152700f, -0.06841367f, -0.09639945f, 
    0.00665336f, 0.02379487f, -0.03183055f, -0.03872782f, 0.03021440f, -0.02646993f, 0.00625489f, 0.01714131f, 
    -0.05347302f, -0.01176097f, -0.06301689f, -0.05524620f, -0.06663937f, -0.06634581f, -0.05233007f, 0.02761018f, 
    0.06140698f, 0.05675641f, -0.10859191f, -0.04934096f, 0.00990795f, 0.05008492f, -0.04782928f, 0.03266603f, 
    -0.06136088f, 0.03714520f, 0.02045456f, -0.08758685f, -0.03965719f, 0.04590965f, -0.00233259f, 0.02801929f, 
    -0.06927017f, 0.00349349f, 0.00432061f, 0.00851435f, 0.00269931f, -0.03825704f, -0.01399485f, -0.00727300f, 
    -0.09967527f, -0.09410696f, 0.01726270f, -0.08074310f, -0.00795798f, -0.06055029f, -0.01983376f, -0.09562740f, 
    0.00286332f, 0.00304444f, -0.00796254f, 0.00400786f, -0.08112016f, -0.07679223f, -0.01143179f, -0.07294796f, 
    0.06031770f, -0.07691828f, -0.02455701f, -0.05639040f, 0.03353124f, -0.06511486f, 0.03858679f, 0.00475278f, 
    -0.08228185f, 0.05297584f, -0.02276886f, -0.07472716f, 0.06427273f, -0.01201294f, -0.01697447f, -0.05944475f, 
    -0.04543018f, -0.00841045f, -0.06548428f, -0.03315971f, -0.07238735f, -0.09333250f, -0.05934366f, 0.02139214f, 
    -0.04961585f, -0.07916284f, -0.05723586f, -0.01662973f, -0.08036800f, 0.01491877f, 0.02292325f, -0.07390641f, 
    -0.00669095f, 0.01787629f, 0.05765264f, -0.04009122f, -0.06485046f, -0.01938482f, 0.02851872f, -0.02204966f, 
    0.02403233f, 0.00543129f, -0.09132686f, -0.09091188f, -0.01259755f, 0.01312538f, 0.01671111f, -0.04957210f, 
    -0.04021856f, -0.03236127f, 0.01446289f, -0.08605102f, -0.09480937f, 0.04390040f, -0.10030891f, 0.00154711f, 
    0.03560415f, -0.08320570f, -0.01752448f, -0.06210949f, -0.07428605f, -0.05730396f, -0.06495637f, -0.04328661f, 
    -0.00208027f, 0.02781337f, -0.03962160f, 0.04048440f, -0.00310847f, -0.01027627f, -0.05338439f, -0.09251127f, 
    -0.05930866f, -0.01241869f, -0.04489934f, 0.03133343f, 0.03555574f, -0.04764990f, -0.07077905f, -0.08128133f, 
    0.01810689f, -0.05353310f, -0.00827842f, -0.08709601f, -0.02918370f, 0.02488593f, -0.01672303f, 0.02066132f, 
    -0.02453699f, 0.02630103f, -0.04505387f, -0.01947452f, -0.04964006f, -0.02698943f, 0.00065039f, 0.04285766f, 
    -0.20460032f, -0.01877257f, 0.04199421f, -0.03685183f, 0.04074860f, -0.03811498f, 0.02616846f, 0.04513906f, 
    0.02098965f, -0.04470031f, 0.12368482f, -0.04867511f, -0.35831609f, -0.20259893f, -0.30119839f, -0.23777044f, 
    -0.13221213f, -0.12591317f, 0.00579366f, 0.09149598f, -0.09872964f, -0.09371629f, 0.07896648f, -0.05057870f, 
    0.14826109f, -0.41790485f, 0.10084690f, -0.04886658f, 0.13301778f, 0.17640647f, -0.11633945f, 0.22325137f, 
    0.03518823f, 0.08396721f, -0.00143433f, -0.00510147f, -0.07496102f, 0.22599968f, 0.09730925f, 0.18018363f, 
    -0.06316499f, 0.02029204f, 0.03106263f, 0.04688217f, 0.01661153f, -0.01189206f, -0.04534984f, 0.02736659f, 
    -0.22446260f, 0.06898998f, 0.04507048f, -0.35808149f, 0.00730158f, -0.10286338f, -0.04296985f, -0.09457628f, 
    0.10520578f, -0.02493691f, 0.00416195f, -0.08284727f, -0.06132248f, -0.04116168f, 0.20136967f, -0.02860503f, 
    -0.01714091f, 0.00704368f, 0.03796349f, 0.13815071f, 0.20410159f, -0.05018391f, -0.02546814f, -0.06412497f, 
    0.02245910f, -0.13301390f, 0.14583620f, 0.40191233f, -0.00526958f, -0.04118013f, 0.02586359f, 0.06734660f, 
    0.00648462f, 0.05604425f, 0.10831176f, 0.13547646f, -0.10708720f, -0.07990599f, 0.01860373f, 0.02962886f, 
    -0.14185005f, -0.09597068f, -0.28039095f, 0.00172551f, -0.00713268f, -0.00558393f, 0.06093729f, 0.23725981f, 
    -0.17477514f, -0.12981273f, 0.05188549f, 0.21383658f, -0.12705977f, 0.18378024f, 0.04161872f, 0.08026026f, 
    0.09623542f, -0.09785334f, 0.10174272f, -0.05944367f, -0.12269309f, -0.09856261f, 0.01415307f, 0.31492457f, 
    0.10653012f, 0.15034021f, 0.04399649f, -0.00667798f, 0.01391374f, -0.12167151f, -0.04434581f, 0.05476489f, 
    -0.46078998f, -0.13486205f, 0.04871767f, -0.06794360f, -0.12063846f, -0.12696877f, 0.00015302f, 0.20339920f, 
    -0.05577749f, 0.03610924f, 0.03032251f, 0.00438359f, 0.01742598f, 0.01166347f, -0.06294682f, -0.14079536f, 
    -0.06855024f, 0.09807257f, -0.02935252f, 0.03472478f, 0.03668247f, -0.02945762f, 0.21289702f, 0.06804250f, 
    -0.28793278f, -0.18432631f, -0.01355622f, -0.15551311f, 0.02235823f, 0.09657940f, -0.06321472f, 0.03834167f, 
    0.21383195f, -0.09391282f, 0.07866418f, 0.19914939f, 0.31756839f, 0.26730829f, -0.39608577f, -0.10641918f, 
    0.01538935f, -0.10976236f, 0.09007522f, -0.10885195f, 0.10862882f, 0.04948805f, -0.04732002f, -0.14721002f, 
    -0.09512916f, 0.08409252f, 0.07863688f, -0.16730127f, -0.07629557f, 0.16281094f, -0.00512364f, 0.10423732f, 
    -0.02548074f, 0.02208091f, 0.11233045f, 0.09083811f, 0.05424598f, -0.02925191f, -0.01835009f, 0.00368008f, 
    0.08749295f, -0.02961696f, 0.09582371f, 0.04169624f, 0.10225822f, 0.07197610f, 0.12567057f, -0.01113993f, 
    -0.03145642f, -0.01130137f, 0.04583771f, -0.06425936f, -0.05159253f, 0.00010039f, 0.01454757f, -0.06988057f, 
    -0.05991890f, -0.01107918f, 0.00279129f, 0.05320865f, -0.03984822f, -0.05020287f, 0.01916582f, 0.03788869f, 
    -0.00608925f, 0.04473257f, 0.01589433f, -0.05283549f, 0.01203909f, -0.00375715f, -0.00188728f, -0.03651372f, 
    0.05942333f, -0.03316511f, -0.04412947f, 0.04160652f, 0.04877963f, 0.01872972f, 0.05777223f, -0.02513203f, 
    -0.00143377f, 0.05659942f, 0.06109355f, -0.03283257f, 0.04791848f, 0.02939833f, 0.00343266f, -0.02623028f, 
    -0.01322807f, 0.05886364f, -0.03975131f, 0.00292409f, 0.03273367f, 0.03051092f, -0.03194759f, 0.02006813f, 
    0.05570237f, 0.02718302f, -0.03982253f, -0.01275445f, 0.03812302f, -0.00454498f, 0.01691571f, -0.03910888f, 
    -0.01124990f, -0.03592684f, -0.07202424f, -0.06841633f, 0.07771658f, 0.05492054f, 0.05040989f, 0.04451608f, 
    0.02418583f, -0.00979551f, 0.02791477f, 0.04695627f, 0.05581940f, -0.03744424f, -0.02393399f, -0.06632886f, 
    -0.04281121f, 0.02299327f, 0.01575530f, -0.05871040f, 0.06029246f, -0.02700086f, -0.03388325f, -0.00082385f, 
    0.01166094f, 0.00022048f, 0.02183027f, -0.03595071f, 0.04969018f, -0.05937225f, -0.06199291f, -0.01192069f, 
    -0.06764384f, -0.05880555f, -0.01120447f, -0.03682131f, -0.03933195f, -0.03568261f, -0.01030691f, 0.03043680f, 
    -0.01430146f, -0.06299007f, -0.03185660f, -0.01866402f, -0.06730215f, -0.00648972f, 0.05422980f, -0.00475137f, 
    0.05069028f, 0.06063997f, -0.02851089f, 0.03948689f, 0.06663733f, 0.06622254f, 0.03486598f, -0.02898522f, 
    -0.07821139f, -0.05291691f, 0.05620930f, -0.07311958f, 0.05361993f, -0.02750328f, -0.04096036f, -0.07765610f, 
    -0.06120789f, -0.04878131f, -0.01827152f, 0.01449835f, 0.00481523f, 0.02693786f, 0.02964339f, -0.04373446f, 
    -0.06223527f, -0.03723861f, -0.04316811f, -0.06219115f, 0.04953561f, -0.06401323f, -0.05511030f, -0.02500709f, 
    0.04283559f, 0.02365685f, 0.05600683f, -0.05806138f, -0.05900285f, 0.04665274f, 0.03033783f, -0.05518851f, 
    -0.01395716f, -0.07422953f, -0.06747960f, -0.05893673f, -0.01039014f, -0.04624341f, -0.07361416f, -0.03055964f, 
    -0.07536810f, -0.04546100f, -0.04018825f, 0.04823244f, 0.01457717f, -0.04070242f, 0.02436708f, -0.06203586f, 
    -0.03057256f, -0.02627886f, -0.02022567f, -0.00970103f, -0.03373678f, -0.03272934f, 0.00950655f, -0.02958311f, 
    -0.02634009f, -0.01259693f, -0.01657546f, 0.02196535f, -0.04301292f, -0.01828761f, -0.07563478f, -0.01440318f, 
    -0.06949059f, 0.05871027f, 0.02781952f, -0.07757669f, -0.01113596f, -0.03568804f, 0.05642384f, 0.03932248f, 
    0.01544191f, -0.06500968f, 0.00294320f, -0.06189875f, 0.05481320f, 0.00491682f, 0.02150056f, -0.07491611f, 
    -0.20878358f, -0.05790089f, -0.15615378f, -0.09396168f, -0.04335503f, 0.06614957f, 0.12264620f, -0.06878935f, 
    -0.04847873f, 0.01559389f, 0.04279520f, 0.16569124f, 0.11809158f, 0.10435762f, -0.10456888f, -0.11236440f, 
    -0.17511947f, -0.24381107f, -0.14476074f, 0.02718797f, -0.27077302f, -0.14516792f, -0.20234144f, -0.22079071f, 
    -0.11937901f, 0.12901899f, 0.03171757f, 0.15452559f, 0.02960623f, 0.09702615f, 0.13115162f, -0.01186784f, 
    0.10701532f, 0.00767534f, 0.26950148f, 0.08059967f, -0.18317874f, 0.14416538f, 0.03138898f, 0.15454994f, 
    -0.05907718f, 0.12071504f, 0.15893160f, 0.10720646f, 0.00762936f, -0.00531326f, 0.00475417f, -0.01451209f, 
    -0.40078452f, 0.06900398f, -0.05231924f, 0.09757638f, -0.27123895f, 0.04722517f, -0.07786875f, -0.06703198f, 
    -0.11354162f, -0.01851690f, -0.00817194f, 0.03051068f, -0.18610291f, 0.01184420f, -0.23114868f, -0.02020919f, 
    -0.13555863f, 0.15318161f, 0.04204671f, 0.02120195f, -0.00169222f, 0.12689619f, 0.01774613f, 0.00275926f, 
    0.01822058f, 0.46664795f, -0.11939511f, 0.18573233f, 0.11536786f, 0.01319507f, 0.09256721f, -0.01640976f, 
    0.05431357f, -0.08823585f, 0.05194806f, -0.00730857f, -0.15286861f, 0.03931170f, -0.24284106f, 0.08862245f, 
    -0.05843591f, -0.12352959f, 0.08490489f, 0.01744702f, 0.10802434f, 0.14392151f, 0.05013250f, 0.07092733f, 
    0.07135224f, -0.08213865f, -0.28276864f, -0.04469351f, -0.04974648f, 0.16714911f, -0.07706710f, 0.02826677f, 
    -0.14992689f, 0.00967060f, -0.08855649f, 0.02234964f, -0.11655761f, -0.26711544f, -0.08306985f, -0.00016984f, 
    0.04739870f, 0.03084025f, -0.07632121f, -0.10181729f, 0.03453574f, -0.08541710f, 0.04993425f, 0.13628328f, 
    0.02268398f, -0.00608525f, 0.25267074f, 0.03697299f, -0.03948310f, 0.07970765f, -0.04009731f, -0.07735769f, 
    -0.09896865f, -0.01483488f, 0.04951336f, -0.08074602f, 0.16786943f, 0.43499959f, 0.02626814f, -0.04340503f, 
    -0.07976171f, -0.15843524f, 0.03027448f, 0.04316595f, 0.13738704f, -0.11841355f, 0.21416619f, 0.10634983f, 
    -0.12878355f, 0.07693003f, 0.01355765f, 0.02029026f, -0.06402015f, -0.04765554f, -0.05062627f, 0.05659673f, 
    0.05205141f, -0.02418315f, -0.03429880f, 0.07353836f, 0.33907416f, -0.08461154f, -0.09285495f, 0.01061742f, 
    0.05845437f, 0.00448888f, -0.00015107f, 0.09714518f, 0.01970193f, -0.01867150f, 0.05173426f, 0.03419757f, 
    0.01917869f, 0.27938840f, 0.05478346f, 0.15738901f, -0.06402637f, 0.15444709f, 0.09593343f, 0.19004256f, 
    0.19267046f, -0.01416781f, 0.02123777f, -0.04406733f, 0.05747772f, 0.12298901f, 0.06653869f, -0.20887908f, 
    0.01896056f, -0.04503720f, -0.07788821f, 0.01028349f, 0.06354593f, 0.20558254f, -0.07599470f, -0.12463359f, 
    0.22863390f, 0.14382394f, 0.06874513f, -0.08449734f, 0.01970439f, 0.08203010f, -0.03550570f, 0.17664546f, 
    0.05201095f, -0.06725693f, -0.04230308f, -0.08565354f, -0.08943225f, -0.23505037f, -0.03329911f, 0.13090359f, 
    0.14675798f, 0.09105984f, 0.02789554f, 0.07446970f, 0.09189735f, -0.05122126f, 0.08411983f, 0.00453747f, 
    0.19658250f, 0.02731749f, 0.29045519f, -0.27145723f, 0.16548276f, -0.02899724f, -0.02484328f, 0.03534073f, 
    -0.00307237f, -0.05254187f, -0.25908858f, -0.07416958f, 0.05771832f, 0.01427942f, -0.01177975f, -0.06822284f, 
    -0.01535054f, -0.05741204f, -0.05220238f, -0.01011750f, -0.02842237f, -0.10635764f, 0.02791062f, -0.06777064f, 
    0.33587110f, -0.15347868f, -0.12526402f, -0.06865975f, 0.09247998f, -0.10809591f, -0.00066200f, -0.06530506f, 
    0.06527957f, 0.14674127f, -0.06340723f, 0.04795931f, 0.13386630f, 0.21475214f, 0.33827460f, -0.07593051f, 
    0.12014297f, -0.07297465f, 0.03812614f, 0.04448178f, 0.09064098f, -0.06172046f, -0.01274077f, 0.02942130f, 
    0.00907067f, -0.53046238f, 0.22507615f, -0.19129992f, 0.14154312f, 0.05275149f, 0.13827847f, 0.08257645f, 
    -0.03422839f, 0.12117539f, -0.07466098f, -0.02920687f, 0.10441440f, -0.05438862f, 0.35521454f, 0.15816882f, 
    -0.08271822f, -0.02777886f, -0.13477959f, -0.14758515f, 0.08700053f, 0.02802454f, 0.02277463f, -0.06414569f, 
    -0.05087579f, 0.12734105f, 0.20261961f, -0.12243883f, 0.00965943f, -0.00813465f, 0.10189796f, 0.15768674f, 
    0.25695524f, 0.14246099f, 0.20115794f, 0.00111245f, 0.09317261f, 0.14351092f, 0.14641818f, 0.06464644f, 
    0.08543130f, 0.20219071f, 0.04385664f, 0.11696409f, 0.09584591f, 0.06657685f, -0.19358616f, 0.00008882f, 
    -0.07678709f, 0.01194588f, -0.12314748f, -0.20260875f, 0.07508669f, -0.02943990f, -0.08130133f, 0.15919827f, 
    0.02548907f, -0.02574659f, -0.06735635f, 0.06009291f, -0.12115432f, -0.34206691f, 0.11989909f, 0.15765567f, 
    0.02460662f, 0.03840172f, 0.03656819f, -0.12339282f, -0.11244470f, -0.07562014f, -0.07684825f, -0.06138245f, 
    0.11469489f, -0.04991178f, -0.07808469f, -0.03647577f, 0.17769712f, 0.08584572f, 0.03922174f, 0.02857248f, 
    -0.06707434f, -0.02590347f, 0.04960337f, -0.12052053f, -0.03111785f, 0.20133571f, 0.02885567f, -0.11991250f, 
    0.04695668f, -0.06070260f, -0.00631440f, -0.07668471f, 0.07758925f, 0.01300870f, -0.14880446f, -0.05892887f, 
    -0.01231996f, -0.38100070f, -0.08844426f, -0.17406107f, 0.19040141f, 0.02606311f, 0.08286557f, -0.14237209f, 
    -0.18636730f, 0.06880768f, 0.06897782f, 0.14698099f, -0.08415520f, -0.17552496f, 0.00446457f, 0.24441426f, 
    0.01077906f, -0.04724395f, 0.09179535f, 0.07372782f, 0.11540074f, -0.10096442f, -0.06243089f, 0.16762787f, 
    0.25177422f, 0.44148847f, 0.18439083f, 0.10602364f, -0.00376526f, 0.11637507f, 0.02883727f, 0.02326482f, 
    0.06867744f, -0.01616419f, 0.12744199f, -0.03559839f, -0.23504132f, -0.15335245f, -0.06876349f, -0.01476047f, 
    -0.01672887f, 0.04256020f, -0.14519775f, -0.09964056f, 0.21353036f, 0.08587245f, 0.09408498f, 0.09334103f, 
    0.10232859f, 0.28608125f, 0.14438350f, 0.06465705f, 0.05149381f, 0.00086366f, 0.01740028f, 0.11365632f, 
    -0.09293250f, -0.06088154f, -0.12300310f, 0.03427660f, 0.36356020f, 0.09047167f, 0.05275475f, -0.06093671f, 
    0.15312663f, 0.00231385f, 0.03999250f, 0.10748057f, -0.04954995f, 0.08312309f, -0.05236492f, 0.15711309f, 
    -0.29210126f, -0.27490172f, -0.04782015f, 0.02930037f, 0.10463512f, -0.09898367f, -0.07537075f, -0.05459619f, 
    -0.10487089f, 0.02506810f, 0.08378699f, -0.03284239f, 0.14319575f, 0.17940225f, 0.04515570f, 0.13928558f, 
    0.10932922f, 0.07186437f, 0.02664229f, -0.04142614f, 0.00286551f, -0.06660043f, 0.08349811f, -0.01023313f, 
    -0.11382762f, 0.07415632f, 0.04362076f, 0.11091856f, -0.20075868f, -0.11955710f, -0.00451229f, 0.08655574f, 
    0.03290738f, -0.01321677f, -0.00462113f, 0.10111919f, -0.30843848f, -0.12275541f, 0.02552280f, -0.20283121f, 
    -0.05015888f, 0.01948724f, -0.08409647f, -0.15233594f, -0.09941074f, -0.08830585f, -0.10170487f, 0.10963796f, 
    0.09275202f, 0.09828477f, 0.11246838f, 0.09374492f, 0.30930361f, -0.04862326f, 0.04733545f, 0.07252047f, 
    -0.08523667f, -0.08466555f, 0.20019321f, 0.14061014f, 0.28011563f, 0.30527115f, 0.36946869f, 0.04939872f, 
    0.08480623f, 0.11176986f, 0.18734063f, 0.05960531f, -0.04795500f, -0.00812419f, 0.08585454f, -0.00755535f, 
    0.19570231f, 0.12395924f, 0.17289227f, 0.18394107f, 0.22511177f, 0.22650802f, 0.06364840f, -0.11991098f, 
    -0.09060085f, -0.00499881f, 0.02953744f, 0.10290188f, -0.38801137f, -0.31913543f, -0.11035584f, 0.00710019f, 
    -0.10618506f, -0.04765058f, 0.06348218f, -0.11418931f, -0.01662618f, -0.03219700f, 0.11311218f, -0.08908483f, 
    -0.06452349f, -0.01150593f, -0.19015065f, 0.06698596f, 0.10764217f, -0.04684455f, 0.13164894f, -0.00835332f, 
    -0.12612748f, 0.10739224f, 0.05125609f, -0.08185098f, -0.13755831f, 0.14415251f, 0.08928737f, 0.16167851f, 
    0.09798659f, 0.09226737f, -0.00635139f, -0.17736889f, 0.00257868f, 0.11327431f, 0.00658529f, 0.01199366f, 
    -0.03900142f, 0.05980670f, -0.01241236f, -0.01407541f, 0.22992934f, 0.01369594f, -0.02601305f, -0.05107303f, 
    -0.13574769f, -0.01822879f, -0.05065502f, 0.02996086f, -0.05504021f, -0.13260990f, -0.05510116f, 0.19663401f, 
    -0.08953535f, 0.07578917f, 0.02427915f, -0.10029441f, 0.05506927f, 0.00078526f, -0.03819467f, 0.15249655f, 
    0.08490031f, 0.05398804f, 0.05656391f, 0.21995281f, 0.12631677f, 0.10664067f, 0.05959723f, 0.15670915f, 
    0.05743424f, -0.13045104f, 0.00469358f, -0.16554452f, -0.17039877f, -0.11397373f, -0.15288702f, 0.04669653f, 
    -0.03439646f, 0.00658305f, -0.03346688f, -0.08284149f, 0.22353013f, 0.24161556f, 0.14838673f, 0.19138128f, 
    0.17904885f, -0.01304638f, -0.05700876f, 0.13777989f, 0.06397535f, 0.11043429f, -0.05182510f, 0.01924227f, 
    -0.04455941f, -0.04497598f, -0.31262246f, 0.00006922f, 0.39410478f, 0.18195471f, 0.13983171f, 0.05531915f, 
    0.08052683f, -0.02612278f, -0.09041943f, -0.08862098f, -0.01526690f, 0.06926098f, -0.14052653f, -0.02177409f, 
    -0.01895218f, 0.13746139f, 0.20841007f, -0.13010199f, 0.11809035f, -0.13545316f, -0.16264109f, 0.05847305f, 
    0.11682981f, 0.06613476f, 0.05477602f, -0.04494820f, 0.20765439f, 0.02252186f, 0.10863070f, -0.02656237f, 
    0.17704743f, 0.03757784f, -0.06514040f, 0.19211976f, 0.16620077f, 0.00187984f, 0.05007175f, 0.05238498f, 
    -0.07357284f, -0.07085894f, 0.19468749f, 0.22683454f, 0.13094953f, 0.10921369f, 0.04272756f, 0.14196175f, 
    0.02182338f, -0.05324272f, -0.08580295f, 0.09008235f, 0.15574828f, 0.09280103f, 0.38202479f, -0.16399486f, 
    -0.15577777f, 0.03132915f, -0.13350375f, -0.27605432f, 0.14117849f, 0.06450072f, 0.05184945f, -0.00369585f, 
    -0.01990855f, 0.05898561f, 0.17655793f, 0.11883716f, 0.19656384f, -0.13850068f, 0.09511054f, 0.00476168f, 
    0.31789768f, 0.13415244f, 0.05127573f, 0.11921381f, 0.08327106f, 0.07389669f, -0.00892721f, 0.02710554f, 
    0.04733218f, 0.03639098f, 0.08348271f, 0.05756574f, -0.05305910f, 0.03615475f, -0.10487026f, -0.16189592f, 
    -0.18035929f, -0.18641388f, -0.19915301f, 0.08712900f, 0.15066570f, 0.04935127f, -0.09048186f, 0.04509356f, 
    -0.00271673f, 0.00084992f, 0.03445627f, 0.20867941f, -0.08876242f, -0.19301534f, 0.10691589f, -0.02644953f, 
    0.00299269f, 0.05855592f, 0.04112011f, 0.07789076f, -0.16058001f, 0.01599588f, -0.07244162f, -0.03740105f, 
    -0.14682317f, -0.02274393f, 0.03261178f, -0.01681464f, 0.24231023f, 0.09209242f, -0.06451255f, -0.03309200f, 
    -0.23398960f, -0.10423519f, -0.08835961f, -0.26860237f, 0.00304063f, 0.24585801f, -0.07267046f, 0.10199628f, 
    -0.04742900f, -0.07871281f, 0.01193418f, -0.09301053f, -0.06673122f, 0.00480819f, -0.13331021f, -0.11275249f, 
    -0.09946783f, 0.17341788f, -0.11835794f, -0.29197553f, 0.01931686f, 0.02239188f, -0.03238948f, -0.21293756f, 
    -0.07070908f, -0.08414058f, 0.02275077f, -0.05110933f, 0.18325077f, 0.02881739f, 0.02089967f, 0.31238571f, 
    -0.18171406f, -0.09877377f, 0.06975488f, -0.02149744f, 0.10163108f, 0.09522913f, 0.15740900f, 0.29329059f, 
    -0.03397757f, -0.04163906f, -0.01164335f, 0.02730657f, 0.01868553f, -0.05257075f, -0.06237911f, -0.03779195f, 
    -0.00841629f, -0.07070219f, -0.06152890f, 0.04207991f, 0.00269393f, 0.06048834f, -0.03176602f, -0.00908235f, 
    -0.03178132f, 0.05397089f, 0.03231179f, 0.03416943f, -0.02774600f, 0.01886835f, 0.04392154f, 0.04978634f, 
    0.00563855f, -0.00743397f, 0.05056588f, 0.04884043f, 0.05028653f, -0.03708472f, -0.05146270f, -0.03420952f, 
    -0.05586255f, -0.03350859f, -0.03422233f, -0.01627369f, -0.00437571f, -0.02330945f, 0.02379137f, -0.07334331f, 
    -0.07580797f, -0.09507886f, -0.05787032f, -0.04039467f, -0.05555966f, 0.05421877f, 0.05639052f, 0.02241251f, 
    -0.07393581f, -0.07485048f, 0.04841015f, -0.08304849f, -0.00918959f, -0.00940126f, 0.03508744f, -0.07633823f, 
    -0.07433765f, 0.03956484f, 0.02777239f, 0.04363465f, 0.02396416f, -0.06717729f, -0.00804705f, 0.01915208f, 
    -0.00827284f, -0.01581405f, 0.05197557f, -0.04838556f, -0.05250520f, 0.04810375f, -0.05496642f, 0.06098960f, 
    0.03431046f, -0.07536437f, 0.04699108f, 0.01296979f, 0.05953498f, -0.02754235f, -0.01374907f, -0.06227882f, 
    0.05014251f, 0.03637810f, 0.02542201f, 0.01781463f, -0.02107338f, 0.04848220f, -0.05499347f, -0.07082716f, 
    0.01439588f, 0.02688710f, 0.05199817f, -0.00409700f, -0.01015623f, -0.06901345f, 0.00122927f, -0.05894483f, 
    -0.06460306f, 0.03390913f, -0.06317749f, -0.02128318f, 0.00842962f, -0.05480805f, -0.07019418f, 0.03068248f, 
    0.07438049f, -0.02091673f, 0.06921166f, 0.00249521f, -0.07135511f, -0.05418658f, 0.03844479f, -0.04390382f, 
    0.05219913f, -0.04947276f, 0.02500025f, 0.04353478f, 0.03215320f, -0.07482972f, -0.07380505f, 0.02297167f, 
    -0.01563792f, 0.01446982f, -0.03097732f, 0.04078374f, 0.05329881f, 0.04029860f, 0.00375386f, -0.05728821f, 
    -0.03306247f, 0.03596635f, -0.01595868f, -0.01948631f, -0.02883282f, -0.00852631f, 0.00763004f, 0.05158384f, 
    0.03072352f, -0.08225429f, -0.05760013f, 0.04734806f, -0.00328041f, -0.04481530f, 0.00327198f, -0.01920773f, 
    -0.04129257f, -0.05263449f, -0.03849297f, -0.02587631f, -0.08883883f, -0.06409298f, -0.06794475f, -0.03460515f, 
    0.01303313f, 0.02153094f, -0.06975339f, 0.04617264f, -0.03854083f, -0.05102729f, 0.04808125f, -0.06390035f, 
    -0.05252134f, -0.03205794f, -0.06963187f, -0.05681980f, 0.00464363f, 0.02136827f, -0.04613063f, -0.03407312f, 
    -0.00233698f, -0.07793596f, -0.03043189f, 0.04702538f, -0.07767970f, -0.06031493f, -0.07432095f, -0.07945510f, 
    -0.02524948f, -0.04762001f, -0.03819485f, -0.01400129f, -0.04696641f, 0.00758531f, 0.01547029f, 0.04597978f, 
    0.02665505f, -0.06219243f, -0.06669546f, 0.04683357f, -0.05245342f, -0.05052850f, 0.08145037f, -0.00354694f, 
    0.05943192f, -0.01164034f, 0.25567916f, -0.00118663f, -0.26069295f, 0.02018311f, 0.04322544f, 0.04229367f, 
    0.06456876f, -0.00527239f, 0.04359152f, -0.11580186f, 0.17024507f, 0.22301500f, -0.02092384f, -0.18903427f, 
    0.00147259f, 0.01308972f, 0.01638475f, -0.03832399f, -0.16682431f, 0.02694413f, -0.10567366f, -0.02569557f, 
    0.00459448f, 0.14507343f, -0.00736433f, 0.19358836f, 0.14544113f, -0.10946562f, 0.25645790f, 0.16435954f, 
    -0.02786114f, 0.06999545f, 0.01891929f, 0.04807857f, -0.08715567f, 0.03671599f, 0.11739540f, 0.13582034f, 
    0.04476592f, -0.04934119f, 0.19983241f, 0.15422437f, 0.14381525f, 0.01196702f, 0.02681563f, -0.14999335f, 
    -0.25668874f, -0.01960691f, 0.12153634f, 0.08933414f, -0.02594326f, 0.08626626f, 0.07583483f, 0.12239548f, 
    0.26867241f, 0.09061913f, 0.07596327f, 0.02108338f, -0.12195312f, -0.09957608f, 0.24935290f, 0.05330614f, 
    0.00896724f, -0.08548138f, -0.04280556f, -0.06680122f, 0.04921895f, 0.01852732f, 0.11682583f, 0.06313055f, 
    0.19220677f, 0.05585839f, 0.22115318f, 0.15350494f, 0.02280835f, -0.06039803f, 0.12266082f, 0.13826966f, 
    0.08971548f, -0.09584794f, -0.12344714f, -0.11783373f, -0.19334441f, -0.05108337f, -0.27229327f, 0.15658565f, 
    0.12662786f, -0.02765592f, 0.01257689f, -0.12009259f, 0.03596450f, 0.03690251f, 0.03398818f, 0.29803780f, 
    0.12945804f, -0.22484559f, -0.05671148f, 0.12211648f, -0.22227414f, -0.00798244f, -0.12850381f, -0.03285473f, 
    -0.07090548f, -0.06756014f, 0.04628430f, -0.20565872f, 0.07432911f, 0.05972369f, 0.14043126f, 0.33849818f, 
    -0.02688325f, -0.04382673f, -0.00738735f, 0.07699687f, 0.01988878f, -0.21832953f, -0.14689925f, -0.06416433f, 
    -0.32065746f, -0.08041656f, -0.05204235f, 0.09487309f, -0.14633834f, -0.02072049f, 0.15889797f, -0.08731874f, 
    -0.11834478f, 0.03768213f, -0.04665862f, 0.08459789f, 0.18693665f, 0.13304171f, -0.15690251f, 0.16031735f, 
    0.16187257f, -0.07845428f, -0.03543489f, -0.02134474f, -0.03909619f, 0.08293917f, 0.22800325f, 0.07027495f, 
    -0.14281033f, 0.03192675f, -0.15272255f, 0.08415155f, 0.04092924f, 0.18049821f, 0.00919099f, 0.21931009f, 
    0.13278678f, 0.05366834f, -0.04209580f, -0.05334429f, 0.17811526f, -0.04682362f, 0.30871722f, -0.07547105f, 
    0.05528289f, -0.01368969f, -0.11510274f, 0.20870383f, -0.08239084f, 0.06568880f, 0.03921590f, -0.00296286f, 
    -0.21919614f, -0.04309722f, 0.08740482f, 0.00349005f, -0.06071306f, 0.09540811f, 0.04726895f, 0.11026316f, 
    0.08474282f, -0.10466715f, -0.00088637f, 0.13249764f, 0.01223975f, 0.13005960f, -0.20447159f, -0.06160045f, 
    0.00079059f, 0.01121373f, -0.04535098f, 0.05766300f, 0.18724263f, 0.08641102f, 0.12364006f, 0.15088823f, 
    -0.04319268f, 0.05579333f, 0.00737893f, 0.03403528f, -0.01618365f, -0.01244126f, -0.00805183f, -0.07540298f, 
    -0.02335230f, -0.06103942f, 0.01222211f, -0.03243337f, 0.00954460f, 0.04107191f, 0.01129877f, -0.01046865f, 
    -0.01643846f, -0.02175606f, -0.01657495f, -0.03348831f, 0.02029232f, -0.02242254f, 0.04408732f, 0.00916005f, 
    0.06228419f, -0.03513417f, -0.02890457f, 0.05422735f, -0.07341556f, 0.04433160f, -0.00210927f, 0.03927077f, 
    -0.01410883f, 0.00660215f, -0.01420618f, 0.04919486f, 0.04019604f, 0.01101264f, 0.01547007f, -0.06253576f, 
    0.04988173f, -0.04310056f, -0.05193030f, -0.04273513f, -0.07742928f, -0.03239894f, -0.05472689f, 0.06187730f, 
    -0.05859035f, -0.00380506f, -0.02053535f, 0.06198749f, -0.02863050f, 0.03679349f, -0.07053091f, 0.03302708f, 
    0.02452333f, 0.03624333f, -0.05759926f, -0.04250850f, 0.01143295f, -0.06470696f, -0.06656303f, -0.02312636f, 
    0.06338422f, 0.02778118f, -0.00751546f, -0.00843499f, 0.03947047f, -0.06873552f, 0.05811256f, -0.01344141f, 
    0.04845111f, -0.03190097f, -0.00512988f, -0.04845938f, -0.05330999f, -0.01547880f, 0.04401766f, -0.06978636f, 
    0.01291227f, 0.00866656f, 0.02323891f, 0.03018735f, -0.02831140f, 0.04411914f, -0.00224031f, -0.01362241f, 
    -0.07303132f, -0.01961994f, 0.03487991f, 0.05546381f, 0.01769539f, -0.06291199f, -0.04779367f, -0.03153791f, 
    0.04763868f, -0.01747448f, -0.06627567f, 0.00530205f, 0.04785528f, 0.04109377f, -0.07425240f, -0.00067918f, 
    -0.04464182f, -0.06545012f, -0.02480761f, 0.01723291f, -0.06668133f, 0.00555889f, -0.06071685f, -0.02342028f, 
    -0.02988593f, -0.00793900f, -0.01246592f, -0.07973273f, -0.00315806f, -0.03583097f, -0.03349069f, 0.01347021f, 
    -0.05458619f, 0.04427435f, -0.01841378f, 0.05900340f, 0.04692950f, -0.07749517f, -0.07091648f, -0.00059833f, 
    0.00531267f, -0.07884739f, -0.01016108f, 0.02968439f, -0.05954204f, -0.00661582f, 0.03461551f, -0.00029038f, 
    -0.06684696f, -0.07532687f, 0.04417330f, 0.03338607f, 0.05561286f, 0.03587469f, -0.07288269f, -0.06276800f, 
    0.02307386f, -0.05914826f, 0.06061034f, -0.00240917f, -0.03187298f, -0.07942309f, 0.02688647f, -0.02429576f, 
    0.06153230f, -0.07889541f, 0.04999712f, -0.02166054f, -0.01273933f, 0.05875006f, -0.04654469f, 0.00667156f, 
    0.00674386f, 0.01091990f, -0.05167029f, 0.02908676f, -0.07936202f, -0.03666121f, 0.03094747f, -0.06750327f, 
    0.01100768f, 0.01389105f, 0.01811868f, 0.05943615f, -0.04297576f, 0.05564909f, 0.01093010f, 0.01982250f, 
    -0.03334171f, -0.04095272f, -0.04849197f, -0.08092058f, -0.02215029f, -0.04327267f, 0.02092678f, 0.02672724f, 
    -0.04341270f, 0.01091529f, -0.00999835f, -0.05582537f, -0.05775466f, 0.03116454f, -0.02569320f, 0.00708529f, 
    -0.02449024f, 0.10599091f, -0.26169285f, 0.01800609f, 0.06012023f, -0.05967660f, -0.02134697f, -0.00124887f, 
    -0.07422017f, 0.02219354f, 0.00349904f, -0.00500742f, -0.28857550f, -0.10921044f, 0.16554752f, 0.25405511f, 
    -0.37070718f, -0.14536068f, -0.26721239f, -0.22675450f, 0.10051436f, -0.09927224f, 0.00344551f, 0.13512701f, 
    0.03200703f, 0.27963969f, 0.12386342f, -0.04118468f, 0.06112861f, 0.11451679f, -0.01562196f, 0.03114931f, 
    -0.03635558f, -0.09944421f, 0.15160754f, -0.01343487f, 0.18569824f, 0.00433461f, -0.11502237f, 0.06229243f, 
    0.01523348f, 0.13196997f, 0.03380270f, -0.05659163f, -0.00482469f, 0.07028639f, 0.03944381f, 0.01792545f, 
    0.27184531f, -0.20209701f, -0.10310800f, 0.06658696f, -0.06888859f, -0.07254117f, 0.03039367f, -0.03155043f, 
    0.00498221f, 0.20674923f, 0.11611354f, 0.08153602f, 0.03832140f, -0.01138753f, -0.36186174f, 0.17502500f, 
    0.05007043f, 0.04764944f, 0.07210165f, 0.08024991f, -0.05495187f, 0.08200068f, 0.05738791f, 0.03886610f, 
    -0.10226802f, 0.45676956f, -0.20806749f, -0.21192563f, -0.04804324f, 0.01684012f, -0.11256607f, 0.06558081f, 
    0.02399538f, -0.00555765f, -0.04648027f, -0.11436500f, 0.07887557f, 0.25691581f, -0.18135437f, -0.23175628f, 
    0.03515923f, -0.01902512f, 0.06809438f, 0.18491909f, 0.02837869f, 0.04908766f, -0.04415983f, -0.08589627f, 
    -0.04970491f, 0.10563233f, -0.17959839f, 0.05072775f, 0.24439119f, 0.03133593f, -0.11180981f, 0.01340390f, 
    -0.08259513f, 0.06349359f, 0.16088046f, 0.13521406f, -0.03116782f, 0.06183945f, -0.01789870f, -0.26797932f, 
    0.02061804f, 0.14282300f, -0.09084333f, 0.09311426f, -0.07721237f, 0.13840634f, 0.10339188f, -0.03237527f, 
    0.45936000f, 0.21555743f, 0.31456068f, 0.13083075f, 0.26374075f, 0.08586458f, -0.08249806f, -0.04369960f, 
    0.04072217f, 0.06172444f, -0.07838725f, -0.02629581f, -0.32926106f, 0.11203190f, 0.13882114f, 0.00996550f, 
    -0.22872443f, -0.14524427f, -0.03219067f, -0.02518439f, 0.09637670f, -0.13483405f, -0.07904217f, 0.08238132f, 
    -0.02936767f, 0.01782477f, 0.05858252f, 0.17558718f, -0.05043732f, -0.06032949f, 0.16668765f, -0.01265741f, 
    -0.02325538f, 0.05482633f, 0.04160576f, -0.00039726f, -0.08293250f, -0.17067535f, 0.03636118f, 0.41974092f, 
    -0.01763153f, 0.22239164f, 0.09184714f, -0.05623916f, -0.02199115f, -0.01168104f, -0.04630489f, 0.22880580f, 
    0.23913381f, 0.10743695f, -0.00982659f, -0.00127410f, 0.06595849f, -0.07954916f, 0.11158080f, -0.14089346f, 
    0.13967820f, 0.23144405f, -0.04069718f, 0.01138591f, 0.19021837f, 0.06952998f, 0.12969083f, 0.04528939f, 
    -0.02669066f, -0.15031514f, -0.07062023f, -0.10867723f, -0.08488256f, -0.03178853f, -0.20482054f, 0.02373144f, 
    0.09989724f, 0.09506015f, 0.09528990f, -0.19787721f, -0.05334416f, -0.04183557f, -0.02404332f, -0.01464745f, 
    -0.00967417f, -0.07976792f, -0.07307886f, 0.00441394f, 0.07841428f, -0.03854844f, 0.08685088f, 0.00841656f, 
    -0.04905560f, -0.09582045f, -0.06905635f, 0.02952475f, -0.18815987f, -0.16984247f, -0.06212291f, -0.13589096f, 
    0.12729524f, 0.09213586f, 0.19850172f, -0.20329542f, 0.03791795f, -0.01193294f, -0.02495656f, 0.16231316f, 
    0.02584987f, 0.02837105f, 0.15535516f, -0.13375098f, -0.19917312f, -0.00650025f, -0.29717109f, 0.07494842f, 
    0.02441759f, -0.03951111f, -0.11279279f, 0.07685774f, 0.05623544f, 0.01178648f, 0.07182695f, 0.08365472f, 
    0.10269044f, -0.40310198f, -0.17992006f, -0.10448035f, 0.03579270f, -0.08573826f, 0.04010620f, 0.00678511f, 
    0.02311920f, 0.21709383f, -0.05896634f, -0.06154914f, 0.03670536f, 0.22560765f, 0.16644011f, 0.02402474f, 
    0.07670499f, -0.04986222f, 0.11908063f, 0.01059405f, 0.02943429f, 0.00890318f, -0.08962236f, 0.06931415f, 
    -0.00616873f, -0.16082720f, 0.07034729f, -0.38843328f, 0.06200120f, 0.01729886f, 0.14474085f, 0.09609919f, 
    0.03133624f, 0.11570790f, -0.00986612f, 0.01879886f, 0.05373816f, -0.05647967f, -0.05692048f, 0.14742103f, 
    -0.08885662f, -0.02951732f, -0.17034370f, -0.08568547f, 0.05730294f, 0.01656751f, 0.03562479f, 0.05017780f, 
    -0.02948585f, 0.10868777f, 0.05220363f, -0.11815036f, -0.01732909f, -0.07939666f, -0.05965050f, 0.21925603f, 
    -0.08176196f, -0.14424819f, -0.02395258f, -0.23482548f, 0.17027111f, 0.14883742f, 0.06230403f, -0.03376986f, 
    0.18620798f, 0.15084763f, -0.10301518f, 0.01563198f, 0.02879305f, -0.05309865f, -0.01669700f, 0.01391022f, 
    0.09759650f, 0.12798367f, 0.01898260f, -0.39097700f, -0.07338713f, 0.08448374f, -0.03525157f, 0.20239869f, 
    0.10600084f, -0.05981982f, -0.10740106f, -0.12101561f, 0.14119469f, 0.01746054f, 0.04368125f, 0.29377815f, 
    0.02077154f, 0.03654694f, 0.04565801f, -0.19293953f, 0.02664876f, -0.07859513f, 0.06826275f, -0.02675684f, 
    0.04995232f, -0.15032634f, -0.10603228f, -0.02675712f, 0.05046228f, 0.10687896f, 0.03282747f, -0.07868862f, 
    0.22650403f, 0.11552446f, 0.06505149f, 0.10030441f, -0.14727756f, 0.12595797f, 0.23403293f, -0.28740516f, 
    0.07013177f, -0.02876680f, 0.03472482f, -0.14313902f, 0.06464588f, 0.09289833f, -0.02682113f, 0.18592961f, 
    0.14806344f, -0.47321844f, -0.02976548f, -0.00966848f, 0.17727582f, 0.05767681f, -0.09737474f, 0.11281312f, 
    -0.03305787f, 0.07766411f, 0.14939600f, 0.13976602f, -0.39730179f, -0.01101349f, 0.11128885f, 0.21329033f, 
    0.13438706f, 0.08906206f, 0.08307932f, 0.05416154f, -0.02928078f, -0.11997005f, -0.18869002f, -0.02966749f, 
    -0.07553712f, -0.05695364f, 0.04863248f, -0.01749048f, 0.02286941f, -0.01461709f, 0.04169216f, -0.02923396f, 
    0.01903723f, 0.06177152f, -0.06468217f, -0.00560257f, -0.04294577f, -0.01754223f, 0.04654055f, -0.04419039f, 
    -0.06932209f, -0.05125830f, -0.02640011f, -0.04656127f, -0.07579213f, -0.03582523f, -0.03856514f, -0.00343034f, 
    0.02089123f, 0.03699917f, 0.06092110f, 0.02088788f, -0.04647316f, -0.03384848f, 0.02619356f, -0.01241624f, 
    0.05324303f, -0.05500358f, 0.04221394f, -0.07276125f, -0.02436570f, 0.05721847f, 0.01799248f, 0.03722880f, 
    -0.05211917f, -0.01807723f, -0.00795943f, 0.00924526f, 0.01127517f, 0.01676652f, 0.02811326f, -0.05796316f, 
    0.05202166f, 0.02076254f, -0.07771111f, -0.04477219f, -0.00878928f, 0.06310129f, -0.02126770f, -0.00544884f, 
    -0.03676990f, 0.02033635f, -0.02298624f, 0.01134835f, -0.01452117f, -0.02624164f, -0.06832207f, -0.07469077f, 
    0.05515847f, -0.00202058f, 0.01523737f, -0.00517724f, -0.06058034f, -0.04674631f, -0.05354150f, -0.02260504f, 
    -0.03392503f, 0.00409331f, -0.02861336f, -0.05378797f, -0.04863887f, -0.02661256f, -0.02064853f, -0.01053798f, 
    0.06602634f, 0.06641126f, 0.01213634f, 0.04067449f, -0.03698245f, -0.01230732f, -0.05568696f, 0.00440864f, 
    -0.02153444f, 0.05528402f, -0.07286699f, -0.06973827f, -0.06020597f, -0.06008375f, -0.00235365f, 0.06140202f, 
    0.05335821f, 0.05109288f, -0.04264773f, 0.00854357f, -0.03191435f, -0.08037105f, -0.01347628f, 0.06450830f, 
    0.02556948f, -0.07018150f, 0.05869731f, -0.04434144f, -0.06098639f, 0.03145876f, -0.07036459f, -0.00382113f, 
    -0.05121795f, 0.03040008f, 0.01248401f, -0.01327217f, -0.05333938f, 0.02327156f, -0.04329348f, -0.07471420f, 
    0.01600794f, 0.06411340f, 0.00080669f, 0.05906031f, -0.06581647f, 0.04044874f, 0.04156094f, 0.01583824f, 
    -0.05164826f, -0.06371552f, 0.05895700f, -0.05746695f, -0.04753968f, -0.02778025f, -0.05035576f, 0.03660751f, 
    -0.00422250f, -0.07462916f, -0.03276672f, 0.03906064f, -0.05853787f, 0.05089319f, 0.06016585f, 0.05316003f, 
    -0.04452524f, -0.01363993f, 0.03700303f, -0.04820823f, -0.03050961f, -0.05678545f, 0.00512077f, -0.01510989f, 
    0.03126925f, 0.02914594f, -0.01437551f, -0.00359397f, -0.08222277f, -0.01339885f, -0.07661761f, -0.04589844f, 
    -0.04838305f, 0.04245014f, -0.02600688f, -0.06851555f, -0.01205252f, 0.02390396f, -0.01045585f, 0.01746821f, 
    0.05973328f, -0.03340698f, -0.05095981f, -0.02629869f, 0.01575254f, 0.01339521f, -0.02648926f, -0.01683258f, 
    0.04859258f, 0.03761009f, -0.07464045f, -0.01532569f, -0.07148091f, -0.03157914f, -0.00493161f, -0.05103927f, 
    -0.05457161f, -0.04503925f, -0.03602068f, 0.01454868f, -0.07174730f, -0.03506453f, 0.04986775f, 0.01964919f, 
    -0.08895897f, -0.30005077f, 0.08318500f, -0.09373158f, 0.08163603f, 0.08651423f, 0.08509888f, 0.05439466f, 
    0.02736224f, -0.10472232f, -0.05810971f, 0.00188927f, -0.15228420f, -0.20059891f, -0.23625183f, -0.01762657f, 
    -0.01406314f, -0.06453855f, 0.07645617f, -0.04869286f, 0.04184505f, -0.08052434f, 0.10959489f, 0.02821085f, 
    -0.00572910f, -0.33647114f, 0.14676765f, 0.01994326f, 0.22156259f, 0.12379623f, -0.09962173f, 0.00146424f, 
    -0.00408740f, 0.00497623f, -0.10296962f, -0.02622466f, -0.21547057f, 0.47348338f, 0.38768220f, 0.18334098f, 
    -0.15695287f, -0.21565400f, 0.06818114f, 0.04487592f, 0.09432548f, 0.06333981f, 0.02979148f, 0.05604828f, 
    0.03712321f, 0.07535703f, 0.29186741f, -0.14641863f, 0.02160634f, -0.20583662f, -0.18152942f, -0.05661870f, 
    0.12584318f, -0.01333291f, -0.02656432f, 0.04177186f, -0.15218821f, -0.12025923f, 0.25153014f, -0.08091071f, 
    0.07434618f, 0.00380658f, -0.09611383f, 0.07554469f, 0.17160781f, 0.01015445f, -0.03341736f, -0.04352926f, 
    -0.24440384f, -0.41025719f, 0.18503079f, 0.33891791f, 0.15712284f, 0.06595340f, 0.11894733f, 0.13520853f, 
    -0.06594860f, -0.01906524f, 0.09446425f, 0.09660678f, -0.12607712f, 0.02732485f, 0.14776674f, 0.27827337f, 
    -0.01337439f, -0.08359566f, -0.11046295f, 0.04458708f, 0.03495826f, -0.00510377f, 0.07391673f, 0.20994397f, 
    -0.17098755f, 0.01869663f, 0.26909950f, 0.06276582f, -0.22870199f, 0.11871337f, 0.11241461f, -0.02965824f, 
    0.25937814f, 0.07198890f, 0.01230148f, 0.04380856f, -0.19852023f, -0.04829870f, -0.10726582f, 0.20911336f, 
    -0.04960424f, 0.07513373f, -0.05706128f, 0.03821296f, -0.12215083f, 0.01905252f, -0.08838166f, -0.02990106f, 
    -0.38080689f, -0.19674066f, 0.09563489f, -0.02499766f, -0.12780103f, -0.06146714f, 0.03983804f, 0.11155095f, 
    0.07580319f, 0.01657974f, 0.08194649f, -0.06595638f, 0.09574089f, 0.12177465f, -0.14393568f, -0.00536928f, 
    0.00217831f, 0.14806287f, 0.05286049f, 0.04361123f, -0.07305118f, 0.14825830f, -0.01846340f, -0.04897678f, 
    0.04512303f, -0.20038582f, -0.03160541f, -0.21685962f, 0.11377555f, 0.11686596f, 0.01541411f, 0.02085839f, 
    -0.05377013f, -0.04054686f, 0.01901907f, -0.12515245f, 0.51065385f, 0.32128066f, -0.29905593f, -0.41688666f, 
    0.01118582f, -0.16098915f, 0.13021734f, -0.00087028f, 0.17638835f, 0.13768469f, -0.13636462f, -0.12431791f, 
    -0.03046716f, -0.01208870f, 0.05297187f, -0.02783614f, -0.01974577f, 0.08559085f, -0.04881560f, 0.03868672f, 
    -0.02985437f, 0.02853885f, 0.08194864f, 0.04876969f, 0.11838651f, -0.10909528f, -0.03326039f, 0.17204492f, 
    -0.07714543f, -0.00187187f, 0.14688535f, -0.07669356f, 0.16458830f, 0.00474687f, 0.30430043f, 0.10083579f, 
    -0.01199633f, 0.29194281f, 0.35933381f, -0.01667758f, 0.10181271f, 0.20040980f, -0.03934576f, 0.16899760f, 
    0.01427518f, -0.18890755f, 0.05744246f, -0.08868752f, -0.07291313f, 0.04980272f, 0.06571498f, -0.00161754f, 
    0.12827596f, 0.04603178f, 0.02398742f, -0.00902408f, -0.11467965f, -0.01238936f, -0.01774792f, -0.16167274f, 
    0.21734428f, 0.36300334f, 0.32389531f, -0.17145146f, 0.20454304f, 0.11225262f, -0.03441443f, 0.15985236f, 
    0.05344402f, 0.17404509f, -0.08875384f, -0.06825835f, 0.25916421f, -0.13028766f, -0.28647125f, -0.06193336f, 
    0.04770571f, 0.01740783f, -0.11892154f, -0.02099105f, 0.09544914f, 0.06559546f, -0.06863032f, -0.06661528f, 
    -0.03226307f, -0.09180295f, -0.30957752f, 0.01203544f, 0.19315736f, -0.02779784f, -0.04922999f, 0.02669857f, 
    -0.16643509f, 0.11478741f, -0.04650013f, 0.02102113f, 0.19147778f, 0.22089951f, 0.24172238f, -0.02990345f, 
    0.18351142f, 0.14420126f, 0.00172581f, -0.12163358f, -0.07238633f, -0.18361290f, -0.06899270f, -0.07536672f, 
    0.32008764f, -0.04324576f, 0.35007429f, -0.03536756f, 0.07609636f, 0.07398691f, 0.07188736f, 0.11653553f, 
    -0.10194259f, 0.14169788f, -0.08526715f, -0.00490724f, 0.06503181f, 0.08819322f, 0.05829610f, -0.22186106f, 
    -0.20294802f, -0.00278384f, -0.13786964f, -0.23421849f, -0.01836502f, 0.03095531f, 0.02902916f, -0.00906784f, 
    0.02618780f, -0.05828923f, -0.05330099f, 0.10829806f, 0.19329359f, -0.05287636f, 0.02809076f, 0.12008978f, 
    -0.10803020f, -0.04225613f, 0.08816402f, -0.27645850f, 0.13294561f, 0.01367719f, 0.23879099f, 0.27087316f, 
    0.30208939f, 0.35401404f, 0.01865869f, 0.11435137f, -0.01011189f, 0.08361509f, -0.11496112f, 0.03041172f, 
    -0.16354863f, -0.05732835f, -0.24234149f, -0.27125457f, -0.00929667f, -0.04134395f, -0.02531958f, 0.07127553f, 
    -0.06594613f, -0.04904370f, -0.07555433f, -0.10225763f, 0.07886761f, -0.27392811f, 0.20441714f, -0.02446757f, 
    -0.11777724f, 0.00871052f, -0.04566219f, -0.09907441f, -0.07908010f, 0.04475292f, 0.14985728f, 0.04280109f, 
    -0.12879969f, -0.02040662f, -0.15510724f, 0.02156771f, 0.13179977f, 0.06918825f, 0.04693531f, 0.11220045f, 
    0.09998863f, 0.08548111f, 0.25403816f, 0.19395740f, 0.11072994f, 0.12873760f, 0.07584987f, 0.31776083f, 
    -0.03424650f, 0.02301328f, 0.00674823f, -0.13548264f, 0.00844221f, -0.00036931f, -0.19876941f, 0.04631347f, 
    -0.14127640f, -0.15419334f, -0.05813390f, -0.24475883f, 0.11411180f, 0.14193983f, -0.02353821f, -0.01529049f, 
    -0.11244252f, 0.06737967f, 0.08359155f, 0.24683182f, 0.05575346f, -0.13748834f, 0.08111658f, 0.00535035f, 
    -0.11851670f, 0.09539489f, 0.12098412f, -0.00753711f, -0.12080640f, -0.22057977f, -0.27015224f, -0.18795162f, 
    -0.06348988f, 0.01314833f, -0.06036849f, -0.06773702f, 0.02940203f, 0.05081319f, -0.05368688f, -0.08008903f, 
    -0.06039742f, 0.02081315f, 0.01274503f, -0.01079626f, -0.05472445f, 0.02635987f, -0.07716475f, 0.04636825f, 
    -0.07005670f, -0.04234053f, -0.07940125f, 0.03830492f, -0.07436930f, 0.03058494f, -0.05363586f, 0.04931880f, 
    -0.05038300f, 0.05443987f, -0.04492640f, -0.06791469f, 0.00815203f, 0.00018215f, -0.00892750f, -0.04807802f, 
    0.03719675f, -0.02110490f, -0.03793468f, -0.06747144f, 0.03721435f, -0.02357733f, 0.04718460f, -0.04611288f, 
    0.03836568f, -0.01890004f, -0.05889923f, 0.06249390f, -0.01752535f, 0.03930868f, 0.03403273f, -0.02251183f, 
    0.06256204f, -0.02764518f, -0.05969627f, 0.00142396f, -0.01890442f, -0.04720617f, 0.00772102f, -0.01112037f, 
    -0.01711019f, 0.00146749f, 0.05036107f, 0.04713723f, 0.00445644f, -0.06072648f, -0.07229824f, 0.04004277f, 
    0.03187662f, -0.03653258f, 0.03402138f, 0.01364770f, 0.02000888f, 0.05860721f, 0.05469172f, 0.00020819f, 
    -0.03233908f, -0.01897217f, 0.02038242f, -0.00656888f, 0.00185090f, 0.00415985f, -0.07511182f, 0.04201076f, 
    -0.05009067f, -0.05415528f, -0.02456185f, -0.03320732f, -0.07750828f, -0.06213645f, -0.03880841f, 0.04047285f, 
    0.06101624f, -0.04959372f, -0.03981913f, 0.04907978f, -0.00168487f, -0.02509213f, -0.07067598f, -0.06743394f, 
    0.05551184f, 0.03157075f, 0.04503657f, -0.06350199f, -0.00094975f, -0.05015779f, 0.01644359f, -0.05384199f, 
    0.04246101f, 0.04798102f, -0.04699833f, 0.04368431f, -0.00840797f, -0.02770407f, 0.01017586f, -0.02102066f, 
    0.03932035f, -0.03895446f, 0.03915785f, 0.05419007f, -0.05333432f, -0.07824520f, -0.02572575f, -0.05331985f, 
    0.01593299f, -0.03746256f, 0.01381437f, 0.03319665f, -0.08021240f, 0.06182072f, -0.06785592f, -0.06157551f, 
    0.01390134f, -0.02542223f, 0.00363219f, 0.03920831f, -0.07031012f, -0.07643263f, 0.03499710f, 0.05556221f, 
    0.03799575f, 0.02614631f, -0.06564914f, 0.06336860f, -0.02167630f, -0.01887252f, 0.06392325f, -0.05564142f, 
    0.05440700f, 0.03069913f, 0.03525577f, 0.03021274f, 0.03244145f, -0.05661727f, 0.04048569f, -0.04911954f, 
    0.03601375f, -0.00155062f, 0.00706049f, 0.03844662f, -0.05652013f, -0.05915730f, -0.01017621f, 0.05384574f, 
    -0.04124138f, 0.05315884f, 0.01120758f, -0.00320814f, 0.00800887f, -0.04269757f, -0.03197394f, -0.02023827f, 
    -0.07300112f, -0.07744350f, -0.02721129f, 0.05869356f, -0.07914349f, -0.01151195f, -0.07041150f, -0.05403442f, 
    -0.05134989f, -0.06721321f, -0.03381094f, 0.06054829f, 0.04744610f, 0.05838016f, -0.07503323f, -0.00802353f, 
    0.01828430f, -0.01016068f, -0.05902008f, 0.06115315f, 0.00521755f, 0.02738182f, -0.07676714f, 0.00572130f, 
    -0.04035852f, -0.12257973f, 0.16435127f, 0.12081750f, -0.15980577f, 0.14017881f, -0.15387970f, -0.03389973f, 
    0.08563305f, -0.09728310f, 0.01719574f, 0.05388599f, 0.13759869f, 0.22536349f, 0.10511202f, -0.06943113f, 
    -0.12740022f, -0.20707859f, -0.11775184f, -0.07701852f, 0.06133391f, 0.02928877f, -0.07025087f, -0.05455044f, 
    -0.14814505f, 0.38826349f, -0.04161992f, 0.28829759f, 0.14267819f, 0.07206760f, 0.05665698f, 0.27136907f, 
    0.02453590f, 0.03978627f, -0.02714008f, -0.01854746f, 0.13852254f, 0.05606388f, 0.09933849f, -0.01010690f, 
    0.01014101f, -0.26083112f, -0.04707021f, 0.05455787f, -0.08788519f, 0.01901458f, -0.01597403f, -0.10251326f, 
    -0.13766897f, -0.19802682f, -0.02807617f, 0.08826973f, -0.14211391f, 0.05496309f, 0.08174357f, 0.15498994f, 
    -0.04365019f, 0.00174158f, 0.08027822f, -0.12021396f, -0.30399352f, 0.02652551f, 0.10570608f, 0.18475802f, 
    0.03684777f, 0.06509104f, -0.05582014f, 0.14370792f, 0.14810599f, -0.03644432f, -0.02797144f, 0.09310424f, 
    -0.34270442f, 0.03600107f, 0.04747251f, 0.12157465f, 0.00415492f, 0.09980514f, -0.02610088f, 0.20092298f, 
    0.03086641f, 0.02538767f, 0.03431953f, -0.04134296f, -0.05873449f, 0.29311258f, -0.26081604f, -0.02000684f, 
    -0.02827871f, 0.00407601f, -0.06825291f, -0.02252128f, 0.04615958f, 0.00472526f, -0.11460491f, -0.06616603f, 
    -0.16817929f, -0.19454983f, -0.14430922f, -0.04134418f, -0.10533901f, 0.08423522f, -0.05847267f, 0.06777997f, 
    -0.06948280f, 0.08550915f, -0.15444222f, 0.06569322f, -0.21284819f, 0.03449049f, -0.05270796f, 0.23852475f, 
    -0.06499448f, 0.09394303f, -0.08396857f, 0.00600266f, -0.04523491f, 0.08133279f, -0.02795915f, -0.03005741f, 
    -0.17984679f, -0.15091272f, 0.00160496f, 0.06314710f, 0.10521550f, 0.08368388f, 0.07187445f, 0.07598960f, 
    0.11299136f, 0.03681323f, -0.08960563f, -0.06952540f, 0.31905645f, 0.29375008f, -0.00537614f, 0.32369328f, 
    -0.08985043f, 0.03505825f, 0.06040855f, -0.13325581f, -0.01359409f, 0.10840048f, 0.09195241f, 0.01054358f, 
    0.13573751f, 0.12343903f, 0.01549846f, 0.03505715f, -0.03256005f, 0.11380413f, 0.06294926f, 0.06414618f, 
    0.03807765f, 0.08627632f, -0.06361678f, 0.02002603f, 0.14243488f, -0.18268579f, 0.19237249f, -0.08341511f, 
    -0.13655578f, 0.07599859f, 0.23752668f, 0.16273469f, 0.09815536f, 0.03988459f, -0.04436957f, 0.11187410f, 
    -0.38007325f, 0.02668744f, 0.26822594f, -0.08336834f, 0.00646255f, 0.16487497f, -0.14618954f, -0.02571986f, 
    -0.07837974f, 0.02322130f, 0.01107197f, 0.00209398f, 0.28389826f, 0.03083081f, 0.08839767f, 0.07344993f, 
    0.00615324f, 0.03207668f, 0.04226110f, -0.00097991f, 0.00226299f, -0.09480268f, -0.01523358f, -0.04788896f, 
    -0.05798945f, 0.01567703f, 0.01506584f, 0.00879901f, -0.02463461f, -0.04745073f, 0.00287306f, 0.07114641f, 
    0.05327680f, -0.02560152f, -0.03493947f, -0.00754347f, -0.01398487f, 0.04021411f, -0.06227885f, -0.06153816f, 
    0.00866290f, -0.06714249f, 0.01200660f, 0.06804454f, 0.04752458f, 0.00831283f, -0.03157783f, 0.07097598f, 
    -0.02699904f, -0.01382787f, -0.04948135f, 0.07134055f, -0.05164394f, -0.04877225f, 0.00225539f, -0.07175104f, 
    0.00029585f, -0.06811430f, 0.04096544f, -0.04978904f, 0.05955041f, 0.01962118f, 0.00902709f, -0.03493238f, 
    -0.03114846f, -0.06290901f, 0.01109562f, -0.06174672f, -0.01225784f, -0.02147024f, -0.04916754f, -0.00386228f, 
    0.01094247f, -0.00689923f, -0.06868009f, -0.06996718f, -0.02551278f, 0.00868809f, 0.02168843f, -0.03275982f, 
    -0.00438336f, -0.02225481f, -0.03093567f, 0.06543809f, -0.06352406f, 0.03983983f, 0.02634584f, 0.03256119f, 
    -0.06316310f, -0.03743617f, -0.06245485f, 0.05031426f, 0.00913080f, -0.06899673f, -0.05106321f, 0.00647328f, 
    -0.04598368f, -0.00952219f, 0.05115202f, -0.06021237f, -0.03110896f, 0.07193651f, -0.05125482f, 0.01019213f, 
    0.06463113f, 0.06857561f, -0.02925417f, -0.01307542f, -0.06647857f, 0.02063536f, 0.02006024f, -0.01951889f, 
    -0.05128293f, 0.02701126f, 0.01621749f, -0.03406309f, 0.03277347f, -0.04647707f, -0.06753198f, 0.04548329f, 
    0.00322485f, -0.02558712f, -0.06239657f, 0.01984423f, -0.01911583f, -0.00982376f, 0.01956557f, -0.06299905f, 
    -0.06399166f, -0.01034597f, -0.03868986f, -0.06503986f, 0.00689947f, -0.02453922f, -0.03943789f, 0.05769192f, 
    -0.02828723f, 0.01907410f, 0.04866091f, -0.03214363f, 0.03221323f, -0.05545703f, -0.04076045f, -0.02363614f, 
    -0.00048673f, 0.00973694f, 0.06485865f, 0.01250382f, 0.04072925f, 0.06561540f, -0.06879859f, -0.01846131f, 
    0.04464917f, 0.03555683f, -0.00045491f, -0.01594588f, 0.06032136f, 0.03777568f, 0.01307340f, -0.04089643f, 
    -0.01563462f, -0.05730293f, -0.00995605f, -0.06291983f, -0.03047057f, -0.03171017f, 0.05954221f, -0.05493551f, 
    0.00859953f, -0.02548490f, -0.03728875f, 0.05183904f, 0.04589036f, -0.04528262f, -0.05697544f, 0.00346360f, 
    -0.03137323f, -0.04060598f, 0.06819904f, -0.06275741f, 0.07188607f, -0.06694765f, -0.04995190f, -0.01421215f, 
    0.05580193f, 0.04141177f, -0.07064883f, -0.03462979f, 0.02208239f, -0.06635078f, -0.05514782f, -0.05710693f, 
    0.04015647f, -0.06023171f, 0.00726692f, -0.04413465f, -0.01328792f, 0.02071313f, -0.02106604f, 0.00533226f, 
    -0.01894920f, -0.05025918f, -0.03720346f, 0.05531863f, 0.02130945f, -0.01700623f, -0.01422176f, 0.04069855f, 
    0.00338752f, 0.01879103f, -0.05504081f, 0.06311488f, 0.01479320f, 0.01770909f, -0.06563721f, 0.00042900f, 
    0.15308042f, 0.14984430f, -0.02115540f, 0.07948472f, 0.05846775f, -0.01576419f, 0.03549495f, 0.01667525f, 
    -0.06167774f, 0.03106211f, 0.02607904f, -0.12056896f, -0.04692286f, -0.19245803f, -0.15768349f, 0.07892789f, 
    -0.07109535f, 0.03779857f, -0.15312916f, -0.10138002f, 0.14272651f, 0.20952742f, 0.08766795f, 0.28924090f, 
    -0.03504310f, 0.07027383f, -0.19154409f, 0.05528373f, 0.14039116f, -0.11275207f, 0.07622467f, -0.05952232f, 
    -0.06430407f, -0.07863059f, -0.09901000f, 0.01304949f, 0.27384222f, 0.06754966f, 0.13307168f, -0.04584754f, 
    -0.02651175f, 0.01207012f, 0.05254699f, 0.01861517f, -0.02189853f, 0.12083864f, -0.04917085f, -0.07502825f, 
    -0.01167019f, 0.10214212f, 0.06132331f, 0.06867224f, -0.00176180f, -0.21126415f, 0.00567504f, -0.03806967f, 
    0.12131706f, 0.00174871f, 0.12623112f, 0.04455433f, 0.25029480f, -0.04299245f, -0.10594659f, -0.00877691f, 
    0.03655900f, 0.05536028f, -0.08005068f, -0.02616157f, -0.17095363f, 0.16107853f, 0.05011173f, -0.03936752f, 
    0.28043991f, 0.17609403f, 0.14781603f, 0.09799629f, 0.04487836f, -0.10440521f, -0.01038159f, -0.02012207f, 
    0.08519514f, 0.05041897f, 0.14195676f, -0.00792424f, -0.02059502f, -0.06097284f, 0.20718475f, -0.17715807f, 
    0.21394108f, -0.00734350f, 0.02684207f, -0.06280685f, -0.07169337f, -0.02378552f, -0.07100902f, -0.10697626f, 
    0.10374419f, 0.09661659f, 0.08736604f, 0.05730104f, 0.24388464f, -0.14855662f, 0.00162671f, -0.09876937f, 
    0.08431993f, 0.21808945f, 0.06024400f, 0.19324003f, 0.08554301f, 0.03368449f, 0.07376561f, -0.10843183f, 
    -0.07545198f, -0.16867554f, 0.16855840f, 0.04076210f, 0.03473881f, 0.02352489f, -0.05498889f, -0.19983077f, 
    0.10387562f, -0.04169754f, -0.03205379f, 0.09651287f, 0.16553558f, 0.09220105f, -0.06792734f, -0.15396962f, 
    -0.08616245f, -0.11223796f, 0.04531328f, 0.26397252f, -0.17223375f, -0.23833734f, 0.11752722f, -0.12475468f, 
    0.10209645f, -0.08172718f, -0.01186234f, 0.17732637f, -0.03592994f, 0.06478794f, -0.10973668f, -0.05723453f, 
    -0.21021307f, 0.13664596f, -0.14531183f, 0.10572281f, 0.12733746f, -0.17075758f, -0.05026072f, -0.10683832f, 
    -0.13197942f, -0.08070526f, -0.21343276f, -0.19615312f, -0.06636716f, -0.09941310f, -0.06019727f, 0.31580377f, 
    0.06679878f, 0.11455461f, -0.15853034f, 0.05915605f, -0.03512315f, 0.02984750f, -0.04315641f, -0.08922415f, 
    -0.02921890f, 0.18175735f, -0.07835961f, 0.01393826f, 0.11492680f, -0.06614470f, 0.02781443f, -0.13928746f, 
    -0.02237952f, 0.01183906f, -0.17304367f, -0.12662339f, 0.07990051f, 0.00235671f, -0.19416808f, -0.05786340f, 
    -0.18798208f, -0.12176358f, -0.10744070f, -0.09077419f, 0.00297871f, 0.10065277f, 0.30157697f, 0.18771379f, 
    0.17557353f, 0.20876460f, 0.14560226f, 0.00507716f, 0.26284593f, -0.05896210f, -0.08271982f, -0.02746614f, 
    0.01240432f, 0.07356236f, 0.01928352f, -0.12050947f, -0.08723556f, -0.05080194f, 0.07928904f, 0.14119433f, 
    0.03703540f, 0.02946715f, 0.02566411f, 0.00393445f, 0.24856500f, 0.07752137f, 0.10604000f, 0.05900777f, 
    0.26892614f, -0.33462602f, 0.00043927f, -0.23107006f, 0.11438498f, 0.06178985f, -0.03401226f, 0.00187575f, 
    -0.11126498f, 0.01844351f, 0.03020025f, -0.13841489f, -0.02149372f, -0.18169393f, -0.08015838f, -0.06345483f, 
    0.13953720f, 0.14807561f, 0.03788536f, 0.10430447f, -0.02116137f, -0.01527352f, -0.11024729f, -0.09120031f, 
    0.12075117f, -0.10218526f, 0.04138563f, -0.04315637f, 0.07144770f, 0.08893896f, 0.08437361f, -0.02294737f, 
    0.27552670f, -0.11659253f, -0.27513599f, 0.00288334f, 0.27537206f, 0.05872858f, 0.06310191f, -0.22713314f, 
    0.16097023f, 0.07335501f, -0.13907717f, -0.09254871f, -0.04669870f, -0.02705199f, 0.11647663f, -0.07024495f, 
    0.38293254f, -0.07008512f, 0.26479742f, 0.14118035f, 0.01843664f, -0.11292128f, -0.03278106f, -0.09358917f, 
    -0.10192442f, -0.01568556f, 0.03404381f, -0.13617603f, 0.30221066f, -0.12159660f, 0.20581624f, -0.07706229f, 
    -0.00914572f, 0.03303237f, 0.03194720f, -0.08802048f, 0.09069149f, 0.07419690f, 0.00283299f, -0.01985533f, 
    0.11420497f, -0.15987557f, 0.14756140f, -0.10518003f, 0.25697911f, 0.15371123f, 0.16847487f, -0.07152594f, 
    -0.15495811f, -0.13619296f, 0.03145419f, -0.07322362f, 0.28438646f, 0.07245136f, 0.12429604f, 0.13294420f, 
    0.04303868f, 0.05696674f, 0.00789069f, -0.09082976f, 0.00266833f, -0.03556535f, -0.04927742f, 0.04521823f, 
    -0.25127316f, -0.18048288f, -0.56787014f, -0.25105643f, -0.07979182f, 0.01674911f, 0.08035871f, 0.12090670f, 
    -0.11351612f, -0.05703850f, 0.03692924f, 0.06810834f, 0.23999523f, -0.19448186f, 0.27604300f, 0.07382806f, 
    0.07140906f, 0.11470513f, 0.07882963f, -0.02902099f, 0.09192660f, 0.09416633f, 0.07513140f, 0.08640512f, 
    0.07641008f, -0.01356632f, 0.07058654f, 0.16639119f, 0.00795082f, 0.12173011f, -0.03049505f, -0.04253350f, 
    0.07074819f, 0.12477868f, 0.12851602f, 0.00640634f, -0.28930011f, 0.09577258f, -0.03167351f, -0.01768188f, 
    0.12715711f, 0.19552734f, -0.04222130f, -0.15792094f, -0.09323627f, 0.04146359f, -0.00708464f, -0.19507669f, 
    0.05797382f, 0.02029115f, -0.22689658f, 0.07633206f, 0.02179078f, -0.03037233f, 0.06881708f, 0.10261756f, 
    -0.04586298f, -0.07867801f, -0.03729901f, 0.06829563f, -0.05039542f, -0.08750286f, -0.20652834f, -0.01232257f, 
    -0.11889733f, -0.03232895f, 0.10862869f, -0.00479867f, 0.09750462f, 0.15264563f, -0.03481082f, 0.10993603f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.19041111f, 0.14418052f, 0.03131097f, 0.21257412f, -0.11368114f, 0.12783717f, -0.02240716f, -0.07663806f, 
    -0.03342744f, 0.05125542f, 0.19180995f, -0.05051434f, 0.09193459f, 0.10062412f, 0.05480200f, 0.13147514f, 
    0.03934015f, 0.13665269f, 0.13028085f, -0.00871102f, 0.29683852f, 0.01315051f, 0.02650247f, -0.02281756f, 
    -0.07148759f, 0.17782629f, 0.26937690f, 0.06060424f, 0.14332892f, 0.28461680f, -0.02604862f, 0.09817283f, 
    -0.23462440f, -0.09247813f, -0.05714009f, 0.19427502f, 0.07252768f, 0.24596813f, 0.02149564f, 0.12022105f, 
    0.04573239f, -0.04685345f, -0.02288030f, 0.06609673f, -0.06688564f, 0.19025494f, -0.02432384f, 0.15078725f, 
    -0.05704707f, -0.04350925f, -0.09126580f, -0.08194976f, 0.20108509f, -0.02114812f, -0.04775241f, 0.19043036f, 
    -0.01129838f, 0.11760923f, -0.11816610f, -0.03668756f, 0.11061089f, -0.03827443f, -0.18482418f, -0.00252497f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.15666866f, -0.15063602f, -0.13341030f, -0.15292612f, 0.11583571f, -0.25082809f, 0.10812853f, -0.10914232f, 
    0.06391934f, 0.05148433f, 0.04058438f, -0.05915656f, -0.14691219f, 0.11879987f, -0.02415748f, -0.06041311f, 
    0.15034574f, -0.24299563f, 0.16095994f, 0.38630202f, -0.01597971f, -0.12492129f, -0.01871199f, 0.08908134f, 
    -0.00123281f, 0.13651757f, 0.24080911f, -0.24799806f, 0.06201868f, 0.09699234f, 0.00777825f, 0.18875581f, 
    0.16266015f, -0.17398442f, 0.33088607f, -0.16984764f, 0.11949294f, 0.32182965f, 0.22934107f, 0.14854780f, 
    -0.08016003f, 0.18585485f, 0.05878719f, 0.01430585f, -0.12244487f, -0.17183378f, -0.06885049f, 0.13760757f, 
    -0.21217078f, -0.06839507f, -0.04256207f, 0.02492799f, -0.03305769f, 0.00427051f, 0.20208116f, 0.10086025f, 
    -0.09552859f, -0.19520801f, -0.05455024f, 0.03715621f, -0.01333397f, -0.07939963f, 0.09168077f, 0.03732722f, 
    -0.07147493f, 0.04638444f, 0.09603917f, 0.41198185f, -0.03325882f, 0.22388436f, -0.02886749f, 0.09556228f, 
    -0.10433438f, -0.24558964f, 0.12406122f, -0.13250574f, 0.18767866f, -0.11410393f, -0.07849492f, 0.14985041f, 
    -0.02574835f, -0.13782766f, 0.01520718f, 0.11095203f, 0.19120324f, 0.05699945f, -0.08931430f, -0.05016885f, 
    -0.27717489f, 0.05540417f, -0.11331871f, 0.15453927f, -0.11909652f, -0.26248100f, 0.04705545f, 0.07058272f, 
    -0.27542070f, -0.22690631f, 0.20990095f, 0.25453246f, 0.05182606f, 0.07332021f, 0.17059220f, 0.12549576f, 
    -0.11783573f, -0.00808523f, -0.05823692f, 0.15907831f, 0.03892500f, 0.19440827f, 0.06647601f, 0.08642087f, 
    -0.19135214f, 0.10342430f, -0.01409966f, 0.12109742f, 0.21390954f, 0.05067276f, -0.09307026f, 0.09761747f, 
    0.12901369f, 0.01627710f, 0.01809772f, 0.02787062f, 0.18486698f, -0.11148033f, -0.05969370f, -0.18985699f, 
    0.07022946f, 0.03467533f, 0.07815627f, -0.04737665f, -0.14043215f, 0.16610840f, 0.03743145f, 0.05283575f, 
    0.10029662f, 0.01405793f, -0.03395372f, -0.11801700f, -0.03108809f, -0.00670536f, -0.04772076f, 0.09638730f, 
    -0.10933970f, -0.07392900f, -0.03337656f, 0.35786664f, -0.10757706f, 0.15443785f, 0.41388735f, -0.10067917f, 
    0.03291997f, 0.11422368f, -0.09831065f, -0.19408967f, 0.10896628f, -0.10155890f, 0.10610206f, -0.04430075f, 
    -0.06222772f, -0.16388090f, 0.05190016f, 0.09145616f, 0.02106038f, -0.20676789f, -0.13361168f, 0.02849591f, 
    -0.32634374f, 0.03023780f, -0.01072302f, -0.14277321f, -0.07110580f, 0.33657640f, 0.10561825f, 0.26223180f, 
    0.00555878f, -0.09711701f, 0.06976753f, -0.13730866f, 0.11751086f, 0.07150280f, -0.11638034f, 0.04682556f, 
    0.01885636f, -0.16293773f, 0.27289057f, -0.00987104f, -0.00062383f, -0.01824804f, -0.12278034f, 0.18624552f, 
    -0.22770232f, 0.07563400f, 0.15675405f, -0.17311485f, 0.23394458f, -0.29230130f, -0.03980112f, 0.05119655f, 
    -0.07078210f, 0.32605127f, 0.09657788f, -0.02684664f, -0.20650046f, 0.18941005f, 0.01462271f, -0.02548343f, 
    0.22102672f, 0.16453315f, -0.19578910f, 0.18151830f, -0.04935666f, 0.07504594f, 0.29779559f, 0.01166003f, 
    -0.21417862f, 0.05644290f, -0.00519025f, 0.22082670f, -0.10759261f, -0.20341760f, 0.06689322f, -0.04305409f, 
    0.35586840f, 0.04424494f, 0.25344002f, -0.10909240f, 0.31497231f, 0.06485690f, -0.10050111f, -0.16807133f, 
    -0.04081804f, 0.41119379f, -0.11040792f, 0.17580076f, -0.03572491f, 0.20382339f, -0.05293217f, -0.17230907f, 
    0.10995039f, -0.05321179f, 0.29068419f, 0.05785653f, 0.09028707f, -0.12138166f, 0.09723739f, -0.21637022f, 
    0.05818967f, 0.28348508f, -0.03438915f, 0.13078997f, 0.01832779f, -0.08828586f, 0.24878487f, 0.05991977f, 
    0.20345587f, -0.24136300f, -0.06419367f, 0.19347005f, -0.06302854f, -0.19590105f, -0.05669018f, 0.03293901f, 
    0.04534436f, 0.23294374f, -0.00774654f, -0.05840171f, -0.13909052f, 0.11009844f, -0.03820200f, 0.06633066f, 
    0.27215269f, -0.07763416f, 0.22607630f, 0.11046617f, -0.04162131f, 0.07454602f, -0.25768146f, 0.22219501f, 
    0.15698677f, -0.00875483f, 0.16758607f, -0.00973917f, 0.12308805f, 0.05334664f, 0.10393510f, 0.22458827f, 
    -0.04782264f, 0.09140355f, 0.19573638f, 0.06388447f, -0.20234802f, 0.16276002f, 0.21200354f, 0.00949338f, 
    -0.06242853f, -0.04154165f, -0.10181314f, -0.10147887f, 0.15030763f, -0.21597682f, 0.09260906f, 0.26573661f, 
    -0.06410263f, 0.05147265f, -0.16004315f, 0.01854673f, -0.05991413f, -0.03324909f, 0.42389119f, 0.14736471f, 
    0.03154344f, -0.20831460f, 0.10201812f, 0.10384388f, 0.17485660f, 0.11393376f, -0.03274565f, -0.00600159f, 
    -0.05292682f, -0.25495863f, 0.06175833f, -0.21183653f, -0.07413082f, 0.07047684f, -0.05892179f, 0.09045666f, 
    0.12485269f, -0.09864344f, -0.14090130f, 0.25237444f, 0.22244360f, -0.03849994f, -0.04667339f, 0.22921708f, 
    -0.14372960f, 0.05627924f, 0.10361809f, -0.11353073f, 0.02398493f, 0.07875742f, 0.01386487f, 0.13248573f, 
    -0.12738566f, -0.19795354f, -0.15739140f, -0.08353593f, -0.17213869f, 0.20188902f, -0.02679912f, -0.26488024f, 
    0.06793948f, 0.11187767f, -0.06977662f, 0.18455844f, -0.09254073f, -0.14238440f, 0.18437128f, 0.07881431f, 
    0.21594132f, -0.24998222f, 0.06943252f, -0.03931818f, -0.00536849f, 0.01488365f, -0.10802525f, 0.03130269f, 
    0.29251447f, 0.19434397f, 0.20742875f, -0.07463826f, 0.14813924f, 0.10935457f, 0.08427940f, 0.25536066f, 
    -0.04295623f, 0.14050673f, 0.17428933f, -0.00996545f, 0.07322346f, -0.07557271f, 0.02592668f, -0.01982467f, 
    -0.47422662f, 0.08032501f, -0.10543088f, 0.18597209f, -0.17825970f, -0.18242113f, 0.07762347f, -0.12454352f, 
    -0.00804547f, 0.00406249f, 0.08781326f, -0.12427194f, 0.19455893f, 0.11194985f, -0.05853568f, -0.09268183f, 
    0.22944985f, -0.18248008f, 0.16964556f, -0.01399346f, 0.06302609f, -0.01937276f, -0.10766748f, -0.01995622f, 
    -0.12921771f, -0.16476415f, -0.20391008f, 0.17200336f, -0.09501673f, -0.44466585f, -0.02851892f, 0.04157441f, 
    0.10420838f, -0.25090101f, 0.36787418f, 0.14224569f, 0.23499343f, 0.01855393f, 0.25924328f, 0.13575184f, 
    0.14202358f, 0.08307476f, -0.00682145f, 0.21154539f, 0.03638701f, -0.16177541f, -0.04629938f, 0.29020035f, 
    -0.09394521f, 0.11212356f, 0.14215718f, 0.01848603f, 0.08234537f, -0.11440963f, -0.01869999f, -0.21384583f, 
    -0.05085096f, -0.08929251f, 0.16752237f, -0.01007906f, 0.17161028f, -0.12143569f, 0.15670364f, -0.17974241f, 
    -0.21438384f, 0.09052857f, 0.04189835f, -0.13705012f, -0.00947742f, 0.25643286f, -0.04022968f, 0.06556082f, 
    0.13087177f, -0.06417761f, 0.07259107f, -0.08147388f, 0.05970555f, 0.11326621f, 0.06684274f, -0.03519661f, 
    -0.03606701f, -0.09171332f, 0.01363786f, -0.37584192f, 0.25374138f, -0.09309997f, 0.08853105f, -0.05005912f, 
    0.07072376f, -0.19211695f, 0.24782586f, 0.20210677f, -0.10791031f, 0.16764185f, -0.05148986f, -0.03314646f, 
    -0.08487051f, 0.20323628f, -0.21444167f, -0.08424868f, 0.06100629f, 0.29168862f, -0.01258261f, -0.05854226f, 
    0.24991646f, 0.30091926f, 0.01216172f, -0.06227944f, 0.09362078f, 0.19000864f, 0.03133893f, -0.18280074f, 
    -0.12268489f, -0.09392031f, 0.08225164f, -0.06879259f, 0.07276415f, 0.05924075f, -0.08978257f, -0.16326395f, 
    0.00934787f, 0.13195224f, -0.11964552f, 0.02216507f, 0.09561570f, -0.01249991f, 0.05751424f, -0.09188133f, 
    -0.17757457f, 0.25846535f, -0.24204981f, 0.45137319f, -0.01698968f, 0.18922152f, -0.01824939f, 0.08280180f, 
    -0.02924987f, 0.10421182f, -0.09085376f, -0.28134257f, 0.12465633f, 0.21740189f, -0.10551912f, -0.03032767f, 
    0.24867412f, 0.10381480f, 0.10143077f, -0.21929592f, 0.31738573f, -0.00767832f, 0.15692896f, -0.03380924f, 
    -0.20299345f, -0.11065459f, 0.08320848f, 0.25775382f, -0.02777786f, -0.07537917f, -0.03243094f, 0.04081477f, 
    0.04877139f, -0.02843184f, -0.21379101f, 0.02142853f, -0.02641226f, -0.08195114f, -0.04441709f, -0.20798974f, 
    -0.05802719f, 0.10261326f, 0.08185014f, 0.06553369f, 0.00707996f, 0.15290344f, -0.04628453f, 0.13002983f, 
    0.02622242f, -0.19654429f, 0.02461926f, 0.08775869f, -0.01156077f, -0.12764670f, -0.00185559f, 0.07780595f, 
    0.07846469f, 0.28378898f, -0.19595818f, -0.01042024f, 0.08904956f, -0.11766051f, 0.19868204f, -0.09173410f, 
    0.09322475f, -0.00139222f, 0.04145709f, -0.06540440f, -0.01237164f, -0.09690818f, -0.11344336f, -0.07703760f, 
    0.11510260f, 0.04505140f, -0.06654966f, -0.05062900f, 0.02937014f, -0.00793752f, -0.04688062f, -0.03894515f, 
    0.05093420f, -0.11164238f, -0.12319095f, -0.08696657f, -0.05344135f, -0.03296681f, 0.12105122f, -0.10853890f, 
    -0.07598589f, -0.03689720f, -0.11502995f, 0.00886706f, -0.12161388f, -0.08594406f, 0.03740337f, -0.07415204f, 
    -0.03408095f, 0.06106345f, -0.01668566f, -0.09707069f, 0.02348514f, -0.05410406f, 0.11462037f, 0.02170427f, 
    0.01967487f, 0.05965987f, 0.06151278f, -0.00654288f, -0.06383027f, -0.11373930f, -0.08819999f, 0.00115666f, 
    0.01702964f, 0.00616598f, -0.09754132f, 0.04600984f, -0.11582838f, -0.03168885f, -0.00784415f, 0.00285856f, 
    -0.08801726f, -0.05687900f, -0.00514063f, 0.07412954f, -0.09664935f, -0.07033738f, -0.03970604f, 0.00202356f, 
    0.27080584f, -0.15478754f, -0.08318838f, 0.23487432f, 0.03960414f, -0.10072768f, 0.11264423f, 0.00481466f, 
    -0.01194691f, -0.03573749f, 0.26513988f, 0.15315585f, 0.12942804f, 0.20487092f, -0.11320418f, 0.03984627f, 
    -0.02372208f, 0.15495571f, 0.20437096f, 0.15863663f, 0.03168726f, -0.00852656f, -0.21286254f, 0.07778978f, 
    -0.04675948f, 0.38082257f, -0.00096540f, 0.04622785f, 0.08395611f, -0.08907558f, -0.00287997f, 0.11298308f, 
    -0.29578608f, -0.12051900f, -0.17558531f, 0.23179996f, -0.19824584f, -0.26836097f, 0.09324291f, 0.19117266f, 
    -0.10804752f, -0.20937011f, 0.10168339f, -0.02009492f, -0.00497382f, -0.10677854f, 0.06154471f, 0.38183653f, 
    0.12909046f, -0.04800527f, -0.22128691f, 0.04836224f, 0.15638459f, -0.04369282f, 0.14356761f, 0.31364152f, 
    0.05051617f, -0.08872709f, 0.12832783f, -0.09048559f, 0.11146376f, -0.09273079f, 0.08969844f, 0.09471035f, 
    -0.12007444f, 0.05409530f, -0.13681628f, 0.01043375f, -0.00913407f, -0.04773629f, -0.12400880f, -0.06033725f, 
    0.10389277f, 0.00734136f, 0.09786868f, 0.02047067f, -0.12408515f, -0.02923159f, -0.04888218f, 0.00491933f, 
    0.06753613f, -0.18746167f, 0.13851818f, 0.08898679f, -0.06663843f, -0.00926123f, -0.14698683f, 0.01077708f, 
    -0.13018934f, 0.03882121f, 0.26315433f, -0.11110298f, 0.00837219f, -0.02676534f, 0.07365896f, 0.09742951f, 
    0.15783419f, 0.05267953f, 0.25493011f, 0.10175611f, 0.04057729f, 0.17855316f, 0.20758137f, 0.06309582f, 
    0.05047595f, 0.20084609f, 0.09328715f, 0.22652972f, -0.09383742f, -0.25643861f, -0.09255511f, 0.14896844f, 
    -0.25725839f, 0.08054191f, 0.08348449f, -0.03093609f, -0.04780387f, 0.00777385f, 0.11129006f, -0.15118529f, 
    0.05004056f, -0.20148875f, -0.14173661f, 0.10449421f, 0.09767759f, -0.08456914f, 0.18389747f, -0.19135913f, 
    0.15021983f, 0.13559593f, -0.03854358f, 0.07828543f, -0.19130535f, 0.13118254f, -0.02033593f, 0.01261103f, 
    0.05875324f, 0.06862791f, 0.13201414f, 0.09294865f, -0.11246298f, 0.00115340f, -0.07242385f, 0.02185687f, 
    0.17189083f, -0.07571787f, -0.02442617f, -0.26483202f, 0.06960736f, -0.11249119f, 0.05207216f, -0.22089997f, 
    -0.05151577f, 0.02649498f, 0.21192716f, 0.24835402f, -0.12135904f, -0.10659682f, 0.00245990f, 0.00610846f, 
    -0.12201087f, 0.04668934f, -0.13771778f, 0.04852457f, -0.10996138f, 0.22116058f, -0.10868996f, -0.14431120f, 
    0.10203354f, 0.10489424f, 0.11415236f, -0.07797283f, -0.04243190f, -0.03181126f, -0.08347824f, -0.16190737f, 
    0.18368664f, -0.19990793f, 0.20005244f, -0.01243277f, -0.24842520f, 0.05653927f, 0.02984527f, 0.05541120f, 
    -0.09766036f, 0.32515514f, -0.03375821f, 0.10081740f, 0.09748798f, 0.12334348f, -0.01980001f, 0.08025236f, 
    0.06154741f, -0.11897637f, 0.13454989f, -0.12058225f, 0.28923452f, 0.46301341f, -0.05129164f, -0.04230589f, 
    -0.08455671f, -0.05017604f, -0.08572854f, -0.12762162f, -0.05828180f, 0.03959279f, 0.08101758f, 0.14193547f, 
    -0.08079525f, 0.06244712f, 0.16957681f, -0.07306001f, 0.20370387f, -0.06488736f, 0.00482153f, 0.15001695f, 
    -0.18498169f, -0.37566721f, -0.06732094f, -0.11161154f, -0.22697172f, 0.23770113f, 0.12943256f, -0.03411710f, 
    -0.00168855f, 0.17890748f, -0.19312879f, 0.08820046f, 0.05425337f, -0.05779445f, 0.25332844f, -0.16377240f, 
    0.25676194f, -0.07952148f, -0.07293335f, 0.20376159f, -0.04614917f, -0.11053345f, 0.10917548f, -0.15959232f, 
    0.28203624f, 0.25802067f, 0.15727943f, 0.02710825f, 0.09634186f, -0.06564573f, 0.20828274f, 0.17132358f, 
    -0.06066073f, -0.07121508f, 0.15856305f, -0.09754039f, 0.06274046f, -0.12217928f, -0.02144573f, -0.15449420f, 
    0.35245037f, 0.03651024f, -0.24571206f, -0.06713120f, -0.06355533f, -0.04198050f, -0.02811512f, 0.05550794f, 
    -0.12959197f, -0.01956879f, -0.07704420f, -0.22618493f, -0.17642897f, 0.12261964f, 0.13134819f, -0.33801967f, 
    0.18515047f, -0.03190926f, 0.02458872f, 0.30573592f, -0.06389613f, 0.06049129f, 0.02744359f, -0.21137571f, 
    -0.04161304f, 0.17685266f, 0.15174633f, 0.07669381f, -0.03462034f, 0.12422557f, 0.08302977f, 0.24806708f, 
    0.09225283f, 0.09011944f, 0.12549378f, -0.21278085f, -0.15143175f, 0.11599697f, 0.10524088f, 0.07575195f, 
    0.12013830f, -0.01667964f, -0.03578877f, -0.12478583f, 0.03673989f, -0.18851206f, 0.05270994f, -0.31918633f, 
    0.33796442f, -0.20814915f, 0.00446914f, 0.07664502f, -0.07233416f, 0.02359853f, 0.33521023f, 0.15249641f, 
    0.03045648f, -0.03594812f, 0.35647464f, -0.08751103f, 0.20395780f, 0.00678959f, -0.07877617f, 0.13451137f, 
    0.25511006f, 0.06760290f, -0.18804562f, 0.28640854f, -0.12481363f, 0.20617099f, -0.07224630f, -0.10753208f, 
    -0.05713256f, 0.03711987f, 0.08052900f, -0.16434839f, -0.05766644f, -0.08396481f, 0.02114157f, -0.32370311f, 
    0.05311494f, -0.24186033f, -0.11328318f, 0.32658672f, -0.02996486f, 0.08679422f, -0.08915308f, -0.12666015f, 
    -0.02226806f, 0.07487148f, 0.18759176f, 0.02759737f, 0.11163330f, 0.22059728f, -0.05206148f, 0.11667244f, 
    -0.06174411f, -0.25435537f, 0.35919961f, -0.14269067f, -0.00404823f, 0.09812114f, 0.01508818f, 0.20266810f, 
    0.32182521f, -0.18608078f, -0.00762929f, 0.22047079f, 0.04480563f, -0.37103379f, 0.12170622f, -0.36897480f, 
    0.12459180f, -0.03236060f, 0.07812393f, -0.05370281f, 0.03930753f, 0.10028241f, 0.16686298f, 0.19708394f, 
    0.01177782f, -0.14088701f, 0.18588154f, -0.10056494f, 0.19424127f, 0.04251413f, -0.15835992f, 0.25533712f, 
    0.12206570f, -0.15652899f, -0.01085730f, -0.03931046f, -0.18382441f, -0.02656399f, 0.07365575f, 0.02743168f, 
    -0.01562555f, 0.08289634f, 0.11557819f, -0.17406178f, 0.16899277f, 0.12210120f, -0.01628196f, -0.04601634f, 
    0.28103098f, -0.18362182f, 0.01522432f, 0.22914204f, -0.01609242f, 0.03032156f, -0.32242498f, 0.03428653f, 
    -0.04895915f, -0.05578991f, -0.15487124f, -0.08638617f, -0.01547458f, -0.15105452f, -0.00207022f, 0.23129664f, 
    -0.15475130f, -0.14884193f, 0.44834012f, 0.06521648f, 0.20586209f, 0.18820959f, 0.20844889f, 0.33214769f, 
    0.14080375f, -0.05601848f, 0.04722745f, 0.19839647f, 0.05647377f, -0.25099173f, -0.05106789f, 0.14354281f, 
    -0.09951065f, 0.09672498f, 0.04846383f, 0.09410249f, 0.19977978f, -0.04688614f, 0.05141081f, 0.16645013f, 
    0.04416808f, -0.30766150f, 0.02406514f, -0.00705341f, 0.18516527f, -0.04130171f, -0.17652878f, -0.02839998f, 
    0.10921551f, 0.08015900f, 0.14476353f, -0.19019702f, -0.13104713f, -0.17898639f, 0.10807562f, 0.01424251f, 
    0.02087335f, 0.31120589f, 0.09274879f, 0.03588291f, -0.07599512f, 0.12778293f, -0.07760164f, 0.23295411f, 
    -0.15716717f, 0.05507549f, -0.03139253f, -0.14191446f, 0.07595296f, -0.08868112f, 0.10954063f, -0.13692094f, 
    -0.26086718f, -0.23117790f, 0.08990585f, 0.29220399f, -0.09400957f, 0.20648950f, 0.14255035f, -0.30910918f, 
    0.00028005f, 0.05763750f, -0.39842784f, 0.05502132f, 0.14775145f, 0.15798837f, -0.08430560f, -0.23141718f, 
    -0.02037397f, 0.22868976f, 0.09431510f, -0.00011844f, -0.07773419f, 0.53621733f, 0.11220960f, 0.19813335f, 
    0.13630925f, 0.05958315f, 0.02360027f, 0.05483838f, 0.07213116f, 0.10218376f, -0.21076564f, 0.18004660f, 
    -0.01230882f, 0.47456625f, -0.00723106f, -0.08636332f, 0.04587904f, -0.01642042f, -0.13482513f, -0.14505455f, 
    -0.26765549f, -0.00975126f, 0.10252831f, 0.25181231f, 0.17695209f, -0.07724452f, -0.05654369f, -0.02582569f, 
    -0.08403553f, 0.38043305f, 0.14746119f, -0.05161541f, -0.01391871f, 0.19887094f, 0.05394345f, 0.12274641f, 
    0.10431720f, 0.14115180f, 0.00083813f, 0.11705690f, -0.01183206f, 0.03069274f, 0.17188798f, 0.00846056f, 
    -0.37156969f, -0.03491002f, 0.01522523f, 0.33980221f, -0.04781751f, -0.40839764f, -0.03324097f, -0.09285621f, 
    0.35341752f, -0.07166670f, 0.01267642f, -0.15328358f, 0.21951523f, -0.09320296f, -0.19222033f, -0.18337777f, 
    -0.12292682f, 0.19960277f, -0.03670803f, 0.33743680f, -0.01571526f, 0.32502395f, 0.05929266f, -0.03591900f, 
    0.16968973f, 0.16694100f, 0.33597696f, -0.07716057f, -0.05346759f, 0.00609016f, 0.01456321f, -0.09012362f, 
    0.08995933f, 0.32969913f, 0.11608994f, 0.01462199f, 0.02450479f, 0.08110549f, 0.20529757f, -0.05382916f, 
    0.03344264f, 0.15754980f, 0.04791213f, -0.40296823f, -0.01155837f, -0.40122753f, 0.02758303f, -0.01901072f, 
    -0.05911861f, 0.51208431f, 0.14925934f, 0.16777267f, -0.09154177f, 0.18416145f, -0.00197058f, -0.03081253f, 
    0.18451773f, 0.11317329f, 0.05647386f, -0.03754882f, -0.08622418f, -0.02913265f, -0.07074603f, -0.00993204f, 
    -0.08592825f, -0.09927975f, 0.13608003f, 0.12194532f, 0.12235343f, 0.20336433f, -0.03097814f, -0.27720264f, 
    0.12904441f, 0.01414895f, -0.12012333f, 0.03465332f, 0.23570770f, 0.26578847f, -0.17721309f, -0.11872045f, 
    0.20757724f, 0.41238073f, 0.05446421f, 0.14153965f, 0.06453726f, 0.23375972f, -0.10410188f, -0.13755216f, 
    -0.03977938f, -0.06506640f, 0.01006589f, -0.01818599f, 0.19419305f, 0.04001607f, -0.09118116f, -0.04915605f, 
    0.04852903f, 0.36497527f, -0.15040804f, -0.09237248f, 0.12325589f, -0.09974790f, -0.07920346f, -0.09913136f, 
    0.16851963f, 0.23165353f, -0.18863612f, -0.02823666f, 0.03573940f, 0.16678616f, 0.11886737f, -0.02441818f, 
    -0.10566140f, -0.10296243f, -0.11016297f, -0.28997070f, 0.14566846f, 0.12239680f, 0.07670037f, -0.22586083f, 
    0.09029813f, -0.12990682f, -0.15819074f, -0.06356920f, 0.09508657f, 0.10384253f, 0.20856699f, -0.23104723f, 
    0.09955720f, -0.14301749f, 0.11886176f, -0.03311383f, 0.07661393f, 0.11011945f, 0.09869146f, 0.02775587f, 
    0.04997552f, 0.09703959f, 0.24090905f, -0.18523064f, -0.06122170f, 0.18961757f, -0.32466653f, -0.17891319f, 
    0.29210028f, 0.05293304f, -0.10560774f, -0.07811829f, 0.07069541f, 0.09355431f, -0.11339948f, -0.32219297f, 
    0.30427864f, -0.00388968f, 0.06759468f, -0.10158157f, -0.13558501f, -0.00831514f, -0.33437622f, 0.08740254f, 
    -0.03881025f, 0.17472799f, 0.02056239f, -0.12033360f, 0.13015346f, -0.00051267f, -0.14532439f, 0.03246082f, 
    0.05935938f, -0.06268779f, 0.15923619f, 0.01661067f, -0.03368147f, 0.17901735f, -0.05800438f, 0.00557116f, 
    0.11832726f, -0.09434137f, 0.17959008f, 0.13630310f, 0.07546961f, -0.24966939f, 0.00425261f, 0.17308334f, 
    -0.28134912f, -0.01179167f, 0.00499026f, 0.31831604f, 0.01576451f, -0.04128276f, 0.19699083f, 0.03084991f, 
    -0.01285823f, 0.00601814f, -0.36621729f, -0.13878188f, -0.28588858f, -0.22812867f, 0.06624745f, 0.22227931f, 
    -0.14852831f, -0.11067279f, 0.01917428f, 0.23944528f, -0.02917229f, 0.05105829f, 0.05661919f, 0.21248855f, 
    -0.02969786f, -0.12587298f, -0.09805990f, -0.02555702f, -0.00789516f, 0.29047328f, 0.10206822f, 0.06163466f, 
    0.13748716f, 0.15679446f, 0.02057199f, -0.12739804f, 0.01394177f, 0.12516646f, -0.01863750f, 0.14365846f, 
    -0.08664977f, -0.06609984f, 0.38766569f, -0.08025327f, 0.15835442f, 0.11626039f, -0.21912678f, 0.09431188f, 
    0.11074302f, 0.08637211f, -0.00790711f, 0.24445899f, -0.03045193f, -0.15469246f, -0.07163589f, -0.01228410f, 
    -0.03058016f, 0.27311122f, 0.16226502f, -0.01027500f, -0.14768288f, -0.01064051f, -0.10182539f, 0.07815927f, 
    0.19947033f, -0.26284716f, 0.16582365f, 0.11623482f, -0.03072776f, 0.06746770f, 0.00969757f, 0.04220262f, 
    -0.04286369f, 0.06865364f, 0.05101689f, -0.02669762f, 0.11663346f, 0.04766215f, -0.02595722f, 0.27672502f, 
    -0.27586418f, -0.11531956f, 0.05041767f, 0.15340957f, 0.01864841f, 0.16993752f, 0.06721833f, 0.11505398f, 
    -0.23287578f, 0.14383452f, -0.06081007f, -0.10394476f, 0.01371485f, -0.04767874f, -0.08393881f, 0.33943290f, 
    -0.20520824f, -0.17969726f, -0.17923172f, -0.08889782f, 0.04127960f, -0.04563080f, 0.31011441f, -0.03705923f, 
    -0.04733522f, -0.02607810f, -0.13531260f, -0.01607283f, 0.01387431f, 0.09599468f, -0.10017712f, 0.06881893f, 
    0.01223661f, -0.14232349f, 0.10052211f, 0.25103012f, 0.03157872f, -0.19485418f, 0.11154316f, -0.00285373f, 
    0.05532419f, 0.35291299f, 0.21618693f, -0.04074360f, -0.19325347f, -0.10350070f, 0.12026142f, 0.19685689f, 
    0.00489339f, -0.05526789f, 0.01602167f, -0.04633212f, 0.15206456f, 0.06555202f, -0.02859172f, -0.01236734f, 
    -0.03904409f, -0.11534408f, 0.04901354f, -0.02087531f, -0.00495714f, 0.18128765f, 0.08254580f, 0.28488678f, 
    -0.21605772f, -0.11270443f, -0.27000865f, 0.22565645f, 0.03897882f, 0.14031218f, 0.18136664f, 0.16596159f, 
    -0.19011933f, 0.11143750f, -0.04607771f, -0.03820762f, 0.05945751f, 0.03345929f, 0.02011497f, 0.13998759f, 
    -0.13892892f, -0.12942331f, -0.01249451f, 0.10311961f, 0.14602681f, 0.03396153f, 0.23165759f, -0.01377869f, 
    -0.12254846f, -0.01510260f, -0.19082293f, 0.04970814f, 0.18619600f, -0.04582720f, -0.11092366f, -0.32510358f, 
    -0.30340594f, -0.12846878f, -0.06214907f, 0.08713903f, 0.02810668f, -0.42298964f, -0.11067284f, 0.10471460f, 
    -0.09862211f, 0.34865588f, 0.13573076f, -0.06715570f, 0.05714746f, 0.21542938f, 0.03809614f, -0.01703025f, 
    0.16545978f, -0.07214557f, 0.06580373f, 0.23564300f, -0.19506079f, -0.11244979f, 0.17955072f, -0.13877426f, 
    -0.12678836f, 0.19871253f, -0.11435259f, 0.06579985f, -0.03289295f, -0.40116954f, 0.06053800f, -0.09495379f, 
    0.35119462f, -0.11300945f, 0.50438797f, -0.11293530f, 0.30971304f, 0.04962328f, -0.06173164f, 0.13343288f, 
    -0.18241900f, 0.12987526f, 0.08773127f, 0.27709603f, 0.10543457f, -0.03906930f, -0.04910712f, 0.12748070f, 
    -0.09934894f, 0.11866941f, 0.21366945f, 0.01344559f, 0.06119449f, -0.11348676f, 0.11835772f, -0.19137007f, 
    -0.10883854f, 0.00278535f, 0.13466470f, 0.09263139f, 0.01002790f, -0.11885095f, 0.25753301f, -0.10715555f, 
    0.25221241f, 0.13224436f, 0.15611006f, -0.32307309f, 0.10412060f, 0.15683484f, 0.10676420f, 0.04056707f, 
    -0.04644435f, 0.25468060f, -0.02525267f, -0.08968893f, -0.12512252f, 0.16362143f, -0.10646181f, -0.10430837f, 
    0.05796238f, 0.10053496f, -0.27968410f, 0.34414786f, -0.08273711f, -0.08975199f, 0.21013899f, -0.02709241f, 
    -0.11390255f, 0.15618213f, -0.10923458f, -0.00387751f, 0.14469373f, -0.18967184f, 0.06214257f, -0.11987764f, 
    0.38764766f, 0.10820638f, 0.09738834f, -0.31015390f, 0.28249124f, -0.10804392f, -0.09811277f, 0.01996971f, 
    -0.23640503f, 0.11934108f, 0.05159454f, 0.29523578f, 0.00896846f, 0.40738127f, -0.09682763f, -0.20343734f, 
    0.25579017f, 0.19267476f, 0.17993508f, -0.09812506f, 0.06126166f, -0.05629307f, -0.16827764f, 0.16161431f, 
    -0.04977349f, 0.06330028f, 0.31085223f, -0.07753048f, 0.06541295f, 0.08580367f, 0.06703342f, -0.13102069f, 
    -0.14115718f, -0.07484241f, -0.04487199f, -0.35567683f, -0.27906758f, 0.08903725f, -0.07153394f, -0.09374750f, 
    -0.05457647f, 0.08346528f, -0.04571361f, 0.00636568f, 0.14951505f, 0.07630601f, -0.07151925f, -0.06062898f, 
    0.21726306f, -0.07501093f, 0.07554017f, -0.07658103f, 0.16220109f, 0.11212771f, 0.01047069f, -0.15907361f, 
    0.05938764f, -0.28730109f, -0.13495393f, 0.07486045f, 0.15606147f, 0.03413405f, -0.09043964f, -0.18273957f, 
    -0.00596342f, -0.20293686f, 0.20265126f, -0.13518341f, 0.11105206f, 0.18242519f, -0.01092474f, 0.00066849f, 
    0.18469320f, 0.15810339f, -0.05869669f, 0.08588816f, -0.01444220f, 0.12259333f, 0.03598322f, 0.12495016f, 
    0.05802173f, -0.21884428f, 0.04695585f, -0.06685101f, 0.01260031f, 0.00736605f, -0.24078146f, 0.19291228f, 
    -0.05972632f, 0.08540821f, 0.19170758f, 0.02989956f, 0.23189373f, -0.07617325f, -0.19250172f, -0.16390045f, 
    -0.06948841f, 0.22238676f, 0.16710643f, -0.37108305f, 0.11901545f, 0.05462561f, 0.10237940f, 0.10634144f, 
    -0.04034343f, -0.08141216f, -0.20524769f, -0.06465553f, -0.09762795f, 0.24129899f, -0.00146832f, -0.07813451f, 
    0.06620087f, -0.01052852f, -0.15932389f, 0.44549865f, -0.10853960f, 0.09711949f, 0.46410355f, -0.04333813f, 
    -0.20635386f, 0.14291351f, 0.10283458f, -0.19647989f, 0.06878187f, -0.09822427f, 0.08954223f, 0.09563047f, 
    0.28550845f, 0.27178439f, 0.32187596f, -0.28173080f, 0.25500020f, 0.07161907f, 0.03068442f, 0.05391649f, 
    -0.11411119f, 0.31710973f, 0.12505966f, 0.09363970f, 0.05759641f, 0.13606772f, 0.04179426f, -0.13357076f, 
    0.10545412f, 0.17870101f, 0.29000464f, -0.01058756f, 0.13820027f, 0.08044290f, 0.00108379f, -0.00585649f, 
    -0.01739712f, -0.12398179f, 0.20669340f, 0.09483071f, -0.21225718f, -0.08088011f, 0.18753630f, 0.20624056f, 
    -0.11024020f, 0.17367579f, -0.04996616f, 0.26173744f, -0.34146491f, 0.17050985f, 0.00928422f, 0.08013219f, 
    -0.03348986f, -0.25299391f, -0.15944403f, -0.06308600f, 0.04298779f, 0.09701256f, 0.13043608f, -0.11011810f, 
    0.18856202f, -0.00011803f, -0.12182608f, 0.06940154f, -0.01141747f, 0.09824509f, 0.08281977f, -0.10321852f, 
    -0.00038467f, 0.22924349f, 0.11945801f, 0.15858139f, 0.05941833f, -0.15212378f, -0.13936014f, -0.00579147f, 
    -0.13002568f, -0.15070644f, 0.10237465f, -0.17411591f, 0.17931576f, -0.03291410f, 0.05215054f, 0.25394395f, 
    0.11353005f, -0.10364950f, 0.05960698f, 0.22005394f, -0.10184668f, -0.19101417f, -0.07208975f, 0.16159871f, 
    -0.38270846f, -0.06870922f, -0.15049890f, 0.08113696f, 0.17073652f, 0.12747008f, -0.22425131f, -0.13266633f, 
    0.10097132f, -0.05563777f, -0.09230950f, -0.06082463f, -0.07190762f, -0.11198036f, -0.02781845f, 0.06795213f, 
    -0.06405985f, -0.10872170f, -0.06209112f, 0.18018915f, -0.16555257f, -0.02739593f, 0.07564484f, 0.00717085f, 
    -0.05786660f, -0.04897549f, 0.05997346f, -0.26359832f, -0.18540286f, -0.12540214f, 0.09349804f, 0.03720346f, 
    -0.04318998f, 0.01794376f, 0.09581944f, -0.09940430f, 0.06024282f, -0.07268506f, -0.13769832f, -0.02132000f, 
    0.02417629f, 0.01549582f, 0.06366010f, -0.21168146f, -0.12604153f, 0.04553686f, -0.11127831f, -0.03001785f, 
    -0.04480049f, -0.07985368f, 0.09291764f, -0.05454824f, -0.02240865f, 0.02737741f, 0.02865442f, 0.05876652f, 
    0.06078355f, -0.14072138f, -0.11928497f, 0.10855734f, 0.02990522f, -0.19484033f, -0.11267730f, 0.05742028f, 
    -0.06344088f, 0.07331555f, -0.23339328f, 0.08138680f, -0.07536553f, -0.04984201f, 0.01739354f, 0.01944880f, 
    0.09846365f, -0.20724091f, -0.01512666f, 0.11244645f, 0.03225347f, 0.04653819f, 0.11741524f, 0.06690662f, 
    0.20966363f, 0.27474362f, 0.23355161f, -0.31488132f, -0.01567656f, 0.13140988f, -0.05110610f, 0.01041228f, 
    -0.08547849f, 0.09282131f, 0.12364740f, 0.15175405f, 0.02098927f, 0.17570621f, 0.05019361f, 0.10608260f, 
    -0.18760854f, 0.11179963f, -0.18566780f, 0.17062564f, 0.16217385f, -0.01676887f, 0.39740899f, -0.02358495f, 
    0.11986580f, 0.21039848f, 0.02248618f, 0.01083012f, 0.20600745f, 0.30385348f, -0.00843376f, 0.03695925f, 
    0.11720654f, 0.18386650f, -0.41555253f, 0.00508347f, -0.06972051f, -0.13955499f, -0.21561365f, -0.08634836f, 
    -0.13949886f, 0.01815410f, 0.04785275f, -0.21700048f, 0.01721255f, 0.26899946f, -0.05339401f, -0.09436240f, 
    0.17627628f, -0.09728582f, 0.15614702f, 0.02302127f, 0.16934572f, 0.12433130f, -0.20015894f, 0.04128556f, 
    0.00633014f, 0.31848255f, 0.07814682f, 0.03437077f, -0.16888435f, -0.05042535f, -0.15621009f, 0.21095012f, 
    0.21683463f, -0.14843270f, -0.00599905f, 0.10167450f, 0.20986287f, 0.25520989f, 0.05208209f, -0.02206923f, 
    0.10837938f, -0.17739193f, -0.21155611f, 0.16808003f, 0.04173836f, -0.05446375f, -0.03660395f, 0.06419352f, 
    0.08276253f, 0.24343272f, -0.02904061f, -0.07265828f, 0.12031402f, 0.06946698f, -0.07532529f, 0.27809200f, 
    -0.07410752f, -0.08728198f, -0.06254759f, 0.13103804f, -0.10028169f, -0.08477693f, 0.08627935f, -0.10939564f, 
    0.14330101f, 0.12518795f, 0.05015125f, 0.16295336f, -0.13453868f, -0.13091540f, 0.10210065f, 0.06423695f, 
    0.33669505f, -0.14966772f, 0.06482834f, 0.02884971f, 0.09151363f, -0.29659161f, 0.11574854f, -0.23164706f, 
    0.28488818f, 0.25382784f, 0.02780922f, -0.06244393f, 0.04478870f, 0.01726003f, 0.13585909f, 0.23266128f, 
    -0.00131247f, 0.04352324f, -0.04647366f, 0.05386943f, -0.04995984f, -0.04249227f, 0.15750760f, 0.02316365f, 
    -0.08015497f, -0.11723160f, -0.18190731f, -0.06906096f, -0.02765441f, -0.10493904f, -0.05691305f, 0.03004688f, 
    0.01559532f, -0.03615241f, 0.08590448f, -0.01785015f, -0.07938531f, -0.12366554f, 0.00065227f, -0.01756583f, 
    0.08328111f, -0.07071017f, -0.09976295f, -0.08597045f, 0.04054322f, 0.05010013f, 0.06393935f, -0.11348941f, 
    0.00290636f, -0.15888402f, -0.10104994f, -0.12171803f, -0.18544337f, 0.07391185f, 0.02951427f, -0.08976085f, 
    0.12056218f, 0.02763671f, -0.13136300f, 0.04663939f, -0.05740714f, -0.03251097f, 0.07619648f, -0.07814102f, 
    0.06847306f, -0.05735129f, -0.08974333f, -0.02854824f, 0.00285688f, -0.08322944f, -0.07641622f, -0.02770082f, 
    0.06316701f, -0.15434854f, 0.04889630f, -0.10902525f, -0.10196672f, 0.04937416f, 0.05729546f, -0.12036598f, 
    -0.12482348f, -0.01915454f, -0.11670905f, -0.01326469f, -0.00108436f, 0.00795341f, 0.04933088f, -0.13417123f, 
    0.03320498f, -0.00668419f, 0.16391046f, 0.18163112f, -0.19941896f, -0.17459306f, 0.12894195f, 0.01060530f, 
    -0.03335204f, -0.00035634f, 0.33118895f, 0.16662896f, -0.08151788f, -0.08110633f, -0.11506529f, 0.18235096f, 
    -0.30283618f, -0.06369434f, 0.01108719f, -0.04745282f, 0.16265599f, 0.04946921f, 0.00937501f, 0.06536019f, 
    -0.24959774f, 0.32174721f, -0.01788918f, 0.27839842f, 0.01815327f, -0.02359200f, 0.08010963f, -0.17707458f, 
    -0.22967142f, -0.07147905f, 0.04132761f, 0.02817714f, 0.09923331f, -0.03854556f, -0.05684385f, 0.28326190f, 
    0.09867675f, -0.01251517f, 0.02729146f, 0.20375983f, 0.02401229f, 0.19520056f, -0.09172279f, 0.19035697f, 
    -0.05985318f, -0.07014081f, -0.18959597f, -0.00646913f, 0.30773801f, 0.00435449f, -0.17385606f, 0.11873374f, 
    0.01837689f, 0.26048538f, 0.03518827f, 0.02896891f, 0.25281185f, 0.11737590f, -0.16197072f, -0.02036573f, 
    0.10367339f, -0.15108417f, 0.16622269f, -0.09464624f, -0.11791539f, -0.10288791f, 0.09101227f, -0.01532761f, 
    -0.03460394f, 0.32007569f, 0.23071924f, -0.07371806f, -0.07550418f, -0.22290017f, -0.08192469f, 0.08870375f, 
    0.10620402f, -0.30707639f, 0.07314526f, 0.10845998f, 0.02499409f, 0.07448046f, -0.24373330f, 0.11465250f, 
    0.12488033f, -0.17738105f, 0.02374648f, -0.00933611f, -0.02693434f, 0.16048709f, -0.09559375f, 0.30154458f, 
    -0.14094746f, -0.18639413f, -0.05715781f, 0.21960503f, -0.11843001f, 0.30110502f, 0.22328885f, -0.08164148f, 
    -0.10920217f, 0.00761356f, -0.07581159f, 0.05520253f, 0.13488291f, 0.13011441f, 0.04344999f, -0.02011522f, 
    0.05609873f, 0.05195578f, -0.13519989f, 0.12724130f, -0.14156774f, -0.07648870f, 0.43677777f, 0.07360642f, 
    -0.11184738f, 0.11723540f, 0.19762361f, 0.09353249f, 0.19011877f, -0.10128993f, -0.24997109f, -0.08106685f, 
    0.29969561f, 0.10620233f, -0.05221023f, -0.17584243f, 0.00540050f, 0.16440916f, -0.00769657f, -0.05216754f, 
    -0.10267847f, -0.34645742f, 0.20641419f, -0.00737412f, -0.04642659f, -0.12555073f, 0.05536839f, 0.17089713f, 
    -0.23576909f, -0.15800275f, -0.12886624f, 0.36223698f, 0.16335444f, 0.07936706f, 0.16041687f, 0.19200270f, 
    -0.30296552f, 0.22973593f, -0.09352118f, -0.27178007f, 0.08703256f, 0.06115004f, 0.02463728f, 0.27590898f, 
    -0.12134225f, -0.13189678f, -0.15214269f, 0.17045686f, 0.17952800f, 0.04455375f, -0.04726033f, 0.09605154f, 
    -0.17839915f, -0.08408582f, 0.03775885f, 0.03275722f, 0.09035856f, 0.15520926f, 0.07545948f, 0.06705413f, 
    0.03305503f, 0.10880030f, -0.23090355f, -0.07985455f, 0.05555806f, -0.02442103f, -0.10276783f, 0.09513297f, 
    -0.07745431f, -0.17107163f, 0.22465886f, 0.01353646f, -0.04313646f, 0.05066435f, -0.10712858f, -0.31150427f, 
    0.01525021f, -0.15935048f, -0.15406027f, 0.29837272f, -0.06522842f, -0.13427013f, -0.06116860f, 0.04670857f, 
    0.06214087f, 0.12868161f, 0.06099707f, 0.03560505f, 0.03628155f, 0.03612603f, 0.05762703f, 0.06328928f, 
    0.03445182f, -0.06694824f, 0.19842945f, -0.25859571f, 0.19074407f, 0.10480642f, -0.21634808f, -0.03450073f, 
    -0.14156647f, 0.01608583f, 0.39638531f, 0.01181552f, 0.06843752f, 0.20545350f, -0.13676284f, 0.18660590f, 
    -0.04461136f, 0.05390963f, -0.08480123f, 0.12537266f, -0.13782263f, 0.30150706f, 0.23017639f, 0.06642637f, 
    0.17360933f, 0.18745771f, -0.10928698f, 0.10345555f, 0.09136834f, -0.32332861f, -0.05559637f, 0.24285582f, 
    -0.15185450f, -0.05022354f, -0.21580802f, -0.08473469f, 0.15516768f, -0.09166133f, 0.03166952f, 0.05468666f, 
    0.11282960f, -0.07276902f, -0.29919904f, 0.02843646f, 0.03509383f, 0.01576085f, 0.05467897f, -0.08829634f, 
    0.12618630f, -0.16703840f, 0.18116236f, -0.18643440f, 0.12228826f, -0.09049656f, 0.04867771f, 0.00217155f, 
    0.02381081f, -0.01449683f, -0.14723064f, 0.25460207f, -0.16124086f, 0.11964674f, -0.07660457f, 0.07677844f, 
    0.15414064f, 0.08475927f, -0.01631754f, -0.23507927f, -0.14580910f, 0.06293415f, 0.07866056f, 0.30976537f, 
    0.24004379f, -0.03954364f, -0.20713545f, 0.04581808f, 0.12504345f, 0.04304158f, 0.10160867f, -0.11630931f, 
    -0.06078067f, 0.26682550f, -0.20287189f, 0.14376974f, 0.02868299f, -0.19284362f, 0.14910564f, -0.12193613f, 
    -0.02839757f, -0.25393090f, 0.11495561f, 0.05722154f, -0.02136310f, -0.16589241f, -0.06314968f, -0.00974587f, 
    0.20386055f, 0.25528839f, -0.01786920f, 0.09195914f, -0.04778058f, 0.04794005f, 0.09898942f, -0.05005452f, 
    0.07655446f, -0.20411532f, 0.04841778f, -0.10558500f, -0.34257463f, 0.09561175f, 0.19767798f, -0.02684662f, 
    0.39641735f, -0.09284785f, 0.21320641f, 0.00784554f, 0.19216943f, 0.34069416f, 0.06092333f, -0.13017179f, 
    0.10831144f, -0.12508777f, 0.12113223f, 0.16828319f, -0.02400421f, 0.05106644f, -0.11496982f, 0.17440113f, 
    -0.27794370f, 0.06187439f, 0.10323827f, 0.21473986f, 0.05780558f, 0.04618191f, 0.20981443f, 0.27497220f, 
    0.08091157f, -0.12127318f, -0.17161538f, -0.15995273f, -0.17682000f, 0.19661443f, -0.08870897f, 0.12357359f, 
    -0.12746534f, -0.00882477f, -0.17590940f, 0.27229065f, -0.00370196f, 0.08278692f, 0.19844449f, -0.08645859f, 
    0.03246755f, -0.04610150f, 0.13643089f, -0.25652650f, -0.01658282f, 0.07505133f, -0.03215243f, -0.14420782f, 
    0.33140516f, 0.13183159f, 0.11480530f, -0.04883838f, -0.15152228f, -0.04117453f, 0.21524036f, 0.21507046f, 
    0.02086772f, 0.06995448f, 0.21125770f, -0.09926881f, -0.07925972f, 0.11504747f, 0.03390139f, -0.08175112f, 
    -0.11235962f, -0.04675011f, 0.09191874f, 0.11056793f, 0.00410556f, 0.10733679f, 0.05809738f, 0.00150976f, 
    0.09376532f, -0.04901965f, -0.08627287f, -0.09998125f, -0.26206812f, 0.03968871f, -0.10283099f, 0.15260726f, 
    -0.00722187f, 0.16832878f, 0.24808510f, -0.31609619f, 0.30049941f, -0.03838844f, 0.04854044f, -0.08525938f, 
    -0.14172511f, -0.20661825f, 0.05063600f, 0.02938231f, 0.02243742f, 0.39303711f, -0.00002345f, 0.16323006f, 
    0.07626847f, 0.02465103f, 0.00298763f, -0.05354644f, 0.12171099f, 0.28755927f, 0.14606813f, -0.14726216f, 
    0.05978822f, 0.16133206f, -0.07818089f, -0.03298347f, 0.02482610f, 0.12727199f, 0.06615198f, -0.00936969f, 
    0.12178395f, 0.18802896f, 0.26167002f, 0.07947226f, -0.13549353f, -0.08473275f, 0.13966204f, -0.08980320f, 
    -0.03028477f, 0.23268579f, -0.25204372f, -0.09258258f, -0.05764826f, -0.06563215f, 0.24941175f, -0.03180460f, 
    0.23462433f, -0.05004565f, 0.02034693f, 0.00191912f, -0.21099120f, 0.08605696f, -0.07968307f, 0.10619743f, 
    -0.03466951f, 0.12227543f, 0.34063125f, 0.00452142f, 0.00065138f, 0.10357739f, 0.13333283f, 0.15540721f, 
    -0.17356350f, 0.04554798f, 0.11470270f, 0.07943509f, 0.23433204f, 0.13422994f, 0.08776201f, -0.03840891f, 
    -0.34310761f, 0.06240254f, 0.04178539f, -0.01189347f, -0.01110342f, 0.08129694f, -0.01130974f, 0.37476856f, 
    -0.29398882f, -0.23627155f, -0.19900145f, 0.19177933f, 0.03395964f, 0.26131791f, 0.01733019f, 0.19513017f, 
    -0.13373600f, 0.14426732f, -0.04170709f, 0.12946789f, -0.07029206f, 0.24240984f, -0.03383873f, 0.37139264f, 
    -0.20368430f, -0.06651994f, -0.14404885f, 0.02929826f, 0.13898094f, -0.08983193f, 0.02888108f, 0.11798547f, 
    0.05863033f, -0.03329358f, 0.15940078f, -0.03339180f, -0.04473832f, 0.05186115f, -0.24297258f, -0.31526810f, 
    0.00579874f, 0.04914784f, -0.00411451f, -0.00172675f, 0.01029717f, 0.09958854f, 0.00447596f, -0.03394105f, 
    -0.12527993f, -0.07683671f, 0.01246363f, 0.09086503f, 0.18068655f, 0.16020921f, 0.05367955f, -0.01892042f, 
    -0.06733014f, 0.05218783f, -0.13476209f, 0.16881059f, 0.10894498f, -0.08206101f, 0.00495594f, 0.00114513f, 
    -0.22840877f, -0.02979849f, -0.23231438f, -0.02018527f, -0.15265243f, -0.41676602f, 0.01098652f, 0.10148103f, 
    0.08473220f, -0.10563685f, 0.17794921f, 0.04267065f, 0.14545695f, -0.05318396f, -0.13563459f, 0.22821133f, 
    -0.18580531f, -0.13765398f, -0.03253889f, 0.07465325f, -0.10786973f, 0.02561543f, -0.07387482f, 0.10219743f, 
    0.12829681f, 0.10090191f, 0.10194938f, -0.02584535f, 0.11747825f, 0.01219680f, -0.02762903f, 0.00943604f, 
    0.10573296f, -0.19753642f, 0.10446777f, 0.06940487f, 0.17254432f, -0.08258781f, 0.07854424f, -0.01595916f, 
    0.09893985f, 0.19907764f, -0.30859950f, 0.58331746f, -0.19009618f, 0.23717469f, -0.05155496f, 0.06298878f, 
    -0.11422820f, -0.28061244f, -0.00616118f, -0.40955773f, 0.11172215f, 0.08270395f, 0.00092291f, -0.21197963f, 
    0.19097091f, -0.05213393f, 0.05966474f, 0.16521519f, 0.11214169f, 0.06509560f, -0.04207133f, -0.11666774f, 
    -0.00090219f, 0.23312163f, 0.16506925f, -0.07920638f, 0.12413704f, -0.03814179f, -0.07987624f, 0.12611999f, 
    -0.03062640f, -0.29167843f, 0.23664154f, 0.02300666f, 0.02328188f, 0.06086198f, -0.13353096f, 0.21910982f, 
    0.02295733f, -0.14199044f, 0.09444830f, -0.10700555f, 0.05891986f, -0.17935483f, 0.02390308f, 0.08512626f, 
    -0.12933116f, -0.40668121f, -0.11890096f, -0.05529903f, -0.07492590f, 0.03894061f, -0.09724921f, -0.11340287f, 
    0.11559354f, -0.03155886f, 0.05359522f, 0.12189584f, -0.08983690f, -0.05427422f, -0.07650325f, 0.05575632f, 
    -0.12758927f, -0.23261219f, 0.14377694f, -0.09268223f, 0.09248479f, 0.13482764f, 0.09507270f, 0.01116490f, 
    0.04588382f, 0.00041870f, -0.06056823f, 0.09466302f, -0.01360366f, -0.05577484f, 0.08909113f, 0.09792239f, 
    0.00247228f, 0.18401976f, 0.29513669f, -0.19260912f, 0.21609136f, 0.06005015f, 0.12209196f, 0.00393165f, 
    0.03776737f, -0.42542526f, -0.12800358f, 0.03404364f, -0.28893623f, 0.10749433f, 0.08260266f, -0.14559983f, 
    0.18806483f, 0.05599571f, 0.03723975f, 0.13448952f, 0.09086611f, -0.01562486f, 0.26719108f, 0.01116183f, 
    0.24908973f, -0.15114611f, -0.07907219f, -0.10072184f, -0.08108988f, -0.13736479f, -0.05650756f, -0.25610653f, 
    0.22209160f, 0.23085551f, 0.20691378f, 0.12050788f, -0.00218451f, -0.10289126f, 0.22393616f, 0.17407632f, 
    0.05814557f, 0.06108325f, 0.30417019f, 0.11497059f, -0.00928335f, -0.08597848f, -0.01250657f, 0.11860341f, 
    0.07454368f, -0.40987846f, -0.09110095f, -0.22355545f, 0.17965505f, -0.32794979f, 0.00088313f, -0.01817390f, 
    0.04588391f, 0.14893839f, 0.29288119f, -0.08983446f, -0.48329204f, 0.19032790f, 0.03863165f, 0.01373517f, 
    0.19495986f, 0.10506446f, 0.15370849f, -0.05486824f, 0.05726203f, 0.01427052f, -0.33152840f, 0.18123463f, 
    0.01264047f, -0.10923174f, 0.26173848f, -0.04184287f, -0.01072336f, 0.06996042f, 0.05035904f, 0.18563981f, 
    0.00428639f, -0.05945780f, 0.09992427f, 0.02507472f, -0.05586722f, 0.19839048f, 0.12188008f, -0.12677015f, 
    -0.21416210f, 0.18618791f, 0.10891943f, 0.11755844f, -0.02461703f, 0.03182317f, 0.08097205f, 0.26678234f, 
    -0.12166636f, 0.14248103f, -0.02889504f, 0.01644836f, 0.02560024f, -0.05640035f, 0.01110587f, -0.19100893f, 
    0.04447827f, -0.17086431f, -0.18961906f, 0.02029587f, 0.08440649f, 0.11261603f, -0.06174673f, -0.57539380f, 
    0.07782695f, -0.18853395f, -0.01528281f, 0.06528582f, 0.32735932f, 0.07967042f, 0.00253578f, -0.07943155f, 
    -0.08862761f, -0.10382704f, 0.15477711f, 0.17206657f, -0.06185014f, 0.20896539f, 0.04831669f, -0.10439197f, 
    0.09379297f, 0.33693895f, -0.07290632f, -0.14417329f, 0.04424737f, 0.03165994f, -0.26116890f, 0.18924120f, 
    -0.10586015f, 0.20131160f, 0.05690916f, 0.11075898f, -0.01070530f, 0.09950809f, 0.00037647f, -0.17140499f, 
    0.27325431f, 0.25333360f, 0.01769456f, -0.12461454f, -0.04889218f, -0.05750922f, -0.02472116f, 0.14558952f, 
    0.20025095f, 0.00962510f, -0.11628585f, 0.15230514f, -0.09786779f, -0.17213483f, 0.08603169f, -0.27353960f, 
    -0.06003188f, 0.24553263f, 0.13587731f, 0.05417999f, -0.06583169f, -0.01369862f, -0.12561919f, 0.01236422f, 
    -0.08654380f, -0.06232233f, -0.17191321f, 0.01307213f, -0.04826727f, -0.04845113f, 0.19762704f, 0.01684814f, 
    0.04985720f, 0.07203666f, -0.27620089f, 0.43969852f, 0.16620956f, 0.19744225f, -0.02562451f, 0.00241013f, 
    0.02868764f, -0.23302595f, -0.02411945f, -0.18710457f, 0.20868587f, 0.02717281f, 0.04189271f, 0.13313678f, 
    0.14748481f, -0.00799743f, -0.07295611f, -0.13732406f, 0.09737983f, -0.11115950f, -0.10349635f, -0.03234871f, 
    0.01154490f, 0.18301240f, -0.02637437f, 0.13150184f, 0.04835262f, -0.32488123f, -0.03122698f, 0.07338817f, 
    -0.08869588f, 0.05436465f, -0.10157914f, 0.09901170f, 0.04673341f, -0.14067836f, -0.20525965f, 0.06995358f, 
    0.11216486f, -0.21291563f, -0.04193127f, 0.19461043f, -0.03916018f, -0.03695024f, 0.05753604f, 0.15702404f, 
    0.05802047f, -0.14542456f, 0.08996361f, 0.09920126f, 0.17124248f, 0.11156680f, -0.34897733f, -0.09114760f, 
    0.02235068f, 0.00051000f, 0.12812364f, -0.10810348f, 0.09540960f, -0.02777226f, 0.12734644f, -0.08315050f, 
    0.22988510f, -0.07399729f, 0.02625912f, 0.17991833f, -0.06656653f, 0.30527148f, -0.05543937f, -0.08366665f, 
    0.02591844f, -0.17345124f, 0.08054729f, 0.25854748f, 0.05105259f, 0.02788729f, 0.03360746f, 0.06015731f, 
    0.12142466f, 0.12529688f, -0.04785714f, -0.44347608f, 0.12989333f, 0.07113162f, -0.32761258f, 0.11878057f, 
    -0.07695788f, 0.15278721f, -0.12862429f, 0.33235279f, 0.12612708f, 0.12962919f, 0.05930716f, -0.14012678f, 
    -0.09515256f, 0.18215758f, -0.22371185f, 0.16874498f, -0.02151735f, -0.00564869f, -0.08240137f, 0.19763029f, 
    0.33428496f, -0.00574095f, 0.01101960f, 0.01706371f, 0.09477269f, -0.20685957f, 0.01370215f, -0.09775700f, 
    0.18180174f, 0.15747067f, -0.24593593f, -0.07360981f, 0.20741248f, 0.09665757f, -0.18648195f, 0.26213565f, 
    0.12308857f, 0.06063407f, -0.17339428f, -0.07210308f, 0.24221040f, -0.10030816f, -0.13216862f, -0.15981339f, 
    -0.27068588f, -0.14179023f, -0.00035922f, -0.03244259f, -0.12276070f, -0.40437040f, 0.04441035f, -0.07434326f, 
    -0.11983310f, 0.32816094f, 0.24705864f, -0.11618880f, 0.03115364f, 0.13336582f, 0.01913472f, 0.03993012f, 
    0.15788363f, 0.22409774f, -0.05951454f, -0.32866997f, 0.17881064f, -0.09484377f, -0.09034726f, -0.12651661f, 
    -0.16652724f, 0.25565800f, 0.25613844f, 0.31223941f, -0.03278741f, -0.09382232f, -0.08536957f, -0.23003343f, 
    0.14747806f, 0.07363756f, 0.06371119f, 0.04268459f, 0.11385098f, 0.13345766f, -0.21991794f, -0.02145022f, 
    0.07268641f, 0.28083012f, -0.02403141f, 0.27073395f, -0.00995982f, -0.06496320f, -0.01873148f, 0.20331548f, 
    -0.08283526f, 0.02765660f, 0.16771056f, -0.08455125f, 0.22552498f, 0.09665822f, -0.08021259f, -0.14713858f, 
    0.01147521f, 0.27483743f, -0.18339160f, -0.02348857f, 0.12723091f, -0.05880381f, 0.18257418f, -0.04618549f, 
    -0.25334141f, 0.04633630f, -0.02479187f, -0.14586698f, -0.24883416f, -0.07848215f, -0.02785611f, 0.11800225f, 
    0.09883208f, 0.11408202f, -0.00237967f, 0.09767818f, 0.14402138f, 0.14624928f, -0.07511325f, 0.07985294f, 
    -0.13196938f, -0.02943327f, -0.06253468f, 0.17071779f, 0.12927458f, -0.08987632f, 0.12568295f, -0.20641226f, 
    -0.33473340f, -0.06304353f, 0.11328370f, -0.12009506f, -0.15475163f, -0.19122663f, -0.08068223f, 0.10691910f, 
    -0.06629687f, -0.10073353f, 0.29459566f, 0.14249530f, 0.34689313f, 0.18850720f, 0.15166876f, 0.28792053f, 
    0.05927353f, 0.37966305f, 0.08905592f, 0.20603928f, 0.00223052f, 0.31480440f, 0.05477439f, 0.17684613f, 
    -0.10116298f, -0.08565211f, 0.03456223f, 0.04618987f, 0.09093674f, -0.10291266f, 0.01749877f, 0.04802374f, 
    -0.03327289f, -0.03879317f, 0.13274695f, 0.10225596f, 0.18142745f, 0.10973702f, -0.13008222f, -0.25197411f, 
    0.05082455f, -0.13369064f, 0.17835917f, 0.27039024f, 0.10402612f, -0.18058418f, 0.06942511f, 0.04207714f, 
    0.01636424f, 0.29253060f, 0.16491045f, 0.20348199f, 0.12110861f, -0.04516799f, -0.04943192f, 0.25088772f, 
    -0.11278438f, 0.10905252f, -0.12477454f, -0.19172291f, 0.08203340f, -0.07010484f, -0.21292068f, -0.00527679f, 
    -0.12823057f, -0.10568309f, -0.37036172f, 0.30260739f, -0.17468712f, -0.06966588f, -0.07486188f, -0.04909026f, 
    0.09691518f, 0.04748121f, -0.10648095f, 0.09326039f, -0.01283401f, 0.08140376f, -0.12814592f, 0.07354499f, 
    0.22557503f, -0.00079177f, 0.02794673f, 0.15176342f, -0.08003474f, 0.04224964f, 0.05661975f, -0.07152334f, 
    0.04206102f, 0.06917384f, 0.14983939f, -0.01285483f, 0.22254087f, -0.06673887f, 0.01790199f, -0.08482694f, 
    -0.06008256f, 0.32603762f, 0.11116081f, 0.11105973f, 0.33487770f, -0.05162585f, 0.09243043f, -0.12060751f, 
    -0.24260212f, 0.11479469f, -0.16486044f, 0.24517947f, -0.24497661f, -0.02716406f, 0.05128073f, 0.02713345f, 
    -0.08800773f, -0.03040641f, 0.17014498f, -0.01959711f, -0.02332271f, 0.20301491f, 0.01084570f, 0.27231616f, 
    -0.01919900f, 0.24595672f, 0.23496000f, -0.27762240f, 0.06355702f, 0.04595207f, 0.09707379f, -0.20382369f, 
    0.07767221f, 0.15625764f, 0.35194421f, 0.14966081f, 0.02726707f, 0.20455326f, 0.10497283f, -0.11457713f, 
    -0.10890957f, 0.02241771f, -0.29464549f, 0.16286236f, -0.07909448f, -0.01312512f, -0.10566265f, 0.19355397f, 
    0.03821655f, 0.08847643f, -0.04455041f, 0.00377347f, 0.09590281f, 0.03720539f, 0.09204219f, 0.23837005f, 
    -0.28706074f, -0.11199476f, -0.04192647f, 0.04729786f, 0.15585764f, 0.10273315f, -0.06022745f, -0.03723503f, 
    -0.02836564f, 0.09946814f, -0.37195566f, 0.10422341f, -0.05064880f, -0.06557824f, 0.05171420f, 0.02950897f, 
    0.08475888f, 0.12955922f, -0.38182381f, 0.32698566f, -0.36413410f, 0.02487921f, 0.10310207f, -0.06058958f, 
    0.12278771f, 0.17660956f, 0.02225142f, -0.29320052f, 0.04174399f, -0.00576794f, -0.07293916f, 0.08783355f, 
    0.23713878f, -0.33584157f, -0.17064297f, -0.03139859f, 0.11342959f, 0.02816687f, 0.32569280f, -0.50419122f, 
    -0.15919662f, 0.03130986f, 0.22275257f, 0.00326433f, -0.05607864f, -0.05736261f, -0.04222463f, 0.20455296f, 
    0.08477415f, -0.45383886f, -0.02296580f, -0.10975702f, -0.09393801f, 0.15572426f, -0.30763730f, -0.24930093f, 
    -0.08865604f, -0.07911257f, 0.02457200f, 0.05926016f, 0.02941354f, 0.15555105f, -0.00846384f, 0.08874542f, 
    0.12944211f, -0.58329690f, 0.25282896f, 0.02994579f, -0.22413094f, -0.05698446f, -0.01630614f, -0.17438181f, 
    0.02595411f, 0.22647028f, -0.06290957f, -0.09750128f, 0.09962921f, -0.06119840f, 0.11915220f, 0.08706304f, 
    0.09675264f, 0.16871427f, 0.04138464f, 0.03742480f, -0.14902924f, -0.03524582f, -0.07439142f, 0.09650249f, 
    0.07932139f, 0.15017675f, 0.12398588f, -0.09514182f, -0.35590279f, -0.01350616f, 0.00047274f, -0.07578287f, 
    -0.01953503f, -0.11563621f, 0.09815302f, 0.16487172f, 0.04870779f, 0.05804682f, 0.13722870f, -0.03222173f, 
    -0.04058086f, 0.08932059f, 0.28318053f, -0.27058107f, -0.06024570f, 0.14521110f, -0.07594447f, 0.36242551f, 
    0.10512230f, -0.17433110f, 0.24146213f, 0.10558080f, 0.17079486f, 0.37278304f, 0.12991732f, 0.11862768f, 
    -0.15610379f, 0.21599789f, 0.00780526f, 0.13293535f, -0.00438786f, 0.21794178f, 0.11016436f, 0.24206789f, 
    -0.33836237f, 0.09028137f, -0.04254889f, -0.05860477f, -0.04671773f, 0.05890542f, 0.19995798f, 0.07856488f, 
    -0.00069576f, 0.04894262f, -0.08037194f, 0.00826019f, -0.16722003f, -0.08437583f, -0.02153294f, -0.02329742f, 
    -0.04749406f, -0.27143604f, -0.07755989f, -0.12238789f, 0.20296805f, -0.54048586f, -0.01216832f, -0.10044250f, 
    0.01572193f, 0.45385870f, 0.26819769f, -0.10453811f, -0.36245263f, 0.08255228f, -0.03822707f, 0.07638962f, 
    0.11051452f, 0.09611496f, 0.12823184f, -0.05097837f, -0.09433181f, -0.06506152f, -0.13625257f, 0.05794563f, 
    -0.09410286f, 0.24692176f, 0.12565334f, 0.07029122f, 0.13523483f, 0.05328691f, 0.13710977f, -0.03322364f, 
    0.23057167f, 0.01320239f, -0.00901449f, 0.04546482f, -0.11726151f, -0.05081981f, -0.08494791f, -0.01757008f, 
    -0.17639832f, 0.19664773f, -0.05172431f, 0.03929019f, 0.09119032f, -0.03443962f, -0.10212128f, 0.15864025f, 
    -0.05123417f, 0.05549403f, 0.00094572f, -0.03939547f, 0.10030681f, 0.03619048f, 0.17095950f, -0.09039878f, 
    -0.01838024f, -0.05177917f, -0.09060072f, -0.07622518f, -0.01556502f, -0.11403613f, 0.12754570f, -0.23703600f, 
    0.36189261f, 0.29208338f, -0.06926194f, -0.20530795f, -0.02993094f, 0.35464925f, 0.00418083f, 0.07307503f, 
    0.04792465f, -0.11443266f, 0.23408918f, 0.00372982f, 0.08920648f, 0.09954948f, -0.05820655f, 0.11575279f, 
    -0.21114452f, -0.04040077f, -0.02534683f, 0.01944041f, 0.14894593f, 0.04451297f, 0.16068904f, 0.13624737f, 
    -0.06821936f, 0.25632671f, 0.20369390f, -0.20347606f, 0.17599390f, -0.00631788f, -0.05532678f, 0.26076019f, 
    -0.38465232f, -0.11086660f, -0.41214085f, 0.21669418f, 0.05399388f, 0.06285834f, -0.00551696f, 0.12714890f, 
    -0.00958444f, -0.13857144f, 0.07680900f, 0.00117780f, -0.10098757f, 0.29286036f, -0.02280378f, 0.38510665f, 
    0.12679915f, -0.14725071f, -0.26686925f, 0.03564906f, -0.01551191f, -0.10321867f, 0.07151337f, 0.29182309f, 
    -0.08899054f, 0.03861669f, 0.04953586f, -0.08259809f, -0.04376793f, -0.04610226f, -0.28016257f, -0.18396251f, 
    0.07994996f, -0.08794538f, 0.00660648f, -0.00378953f, -0.07367845f, 0.03229040f, -0.00087817f, -0.11824414f, 
    0.09714274f, -0.04878264f, -0.09975807f, -0.02551493f, 0.00937414f, -0.04187517f, 0.07635310f, 0.04544552f, 
    -0.10041566f, 0.09432466f, -0.19099595f, -0.00223789f, -0.10970926f, 0.05211979f, -0.10976557f, 0.02117810f, 
    0.03509707f, -0.10268877f, -0.08403371f, -0.08616850f, -0.11654689f, -0.04794652f, 0.04443274f, -0.08068117f, 
    -0.05199012f, 0.01613336f, 0.00423227f, 0.03057057f, -0.09491405f, 0.00938627f, 0.01512301f, -0.04208225f, 
    -0.00095876f, -0.08422855f, -0.09873842f, -0.10770494f, 0.01186393f, 0.00795166f, 0.11144650f, 0.01003229f, 
    0.09390914f, 0.00781139f, 0.07266878f, -0.00647114f, -0.12681150f, 0.03176020f, -0.10005049f, -0.04733913f, 
    -0.08611357f, -0.05227473f, -0.06332715f, -0.06749965f, 0.05948975f, 0.00649747f, -0.01672493f, -0.12329932f, 
    0.03210655f, 0.18642688f, -0.17781247f, -0.23456860f, -0.12055495f, 0.07885446f, 0.06318206f, -0.02689806f, 
    0.02110254f, 0.06724259f, -0.09456859f, 0.04663383f, 0.08794251f, 0.10390910f, 0.05535603f, -0.03033968f, 
    0.04292791f, 0.24462320f, 0.22711346f, -0.39574265f, 0.29623023f, -0.05605542f, 0.07675836f, -0.20590535f, 
    0.09394420f, -0.05009083f, 0.37240738f, 0.22521742f, 0.21746078f, 0.35870466f, 0.13643296f, -0.27373239f, 
    0.09329408f, 0.16198726f, -0.19708478f, -0.22476520f, 0.04438938f, 0.08931536f, -0.28684038f, -0.17151700f, 
    0.23464870f, 0.26360455f, -0.01112074f, 0.03899855f, -0.03662853f, 0.12831372f, -0.02074627f, 0.03579158f, 
    0.00321115f, -0.16381969f, 0.20956683f, -0.01063418f, 0.06991571f, 0.06516769f, -0.15145923f, 0.15110780f, 
    0.10955158f, 0.40318993f, -0.40288088f, 0.07953116f, 0.05608720f, 0.04859100f, 0.06735883f, 0.04752099f, 
    0.27538249f, 0.01430132f, 0.08087358f, -0.01518179f, 0.34775352f, 0.22696859f, -0.02047779f, 0.02406695f, 
    -0.08332061f, -0.37213930f, -0.02301721f, 0.18028481f, -0.09011147f, 0.06750758f, -0.10773093f, -0.09720062f, 
    -0.19401586f, 0.08229601f, 0.00769479f, 0.39697090f, -0.10451091f, -0.05864832f, 0.33184487f, 0.23838329f, 
    -0.03406997f, 0.32417202f, 0.01158293f, -0.22715035f, -0.07914578f, -0.05280856f, -0.03079203f, 0.17425346f, 
    0.34431836f, 0.15681668f, 0.03527664f, 0.09812168f, 0.08893321f, -0.10097234f, 0.10547297f, 0.12946728f, 
    -0.13880564f, 0.03415854f, -0.04581304f, -0.15236603f, 0.03291213f, 0.00066996f, 0.11023888f, -0.27108720f, 
    0.05107870f, 0.03181744f, 0.12352765f, 0.02040968f, 0.14469562f, -0.06815127f, 0.10823897f, 0.03225187f, 
    0.02050096f, -0.15662615f, 0.21166603f, 0.07884890f, -0.24728112f, -0.08720702f, 0.11978285f, 0.14218742f, 
    0.14631197f, -0.16306131f, 0.09395322f, -0.00548083f, 0.15814306f, 0.09488030f, -0.10484757f, -0.09504782f, 
    0.11263314f, -0.05325245f, -0.25033122f, 0.13405685f, 0.21856324f, 0.02780869f, 0.07646426f, -0.03735363f, 
    -0.24178523f, 0.24089681f, -0.05572277f, -0.25097066f, -0.07331222f, -0.03304200f, 0.10853019f, 0.04002078f, 
    0.13339539f, 0.00785661f, -0.35089636f, 0.05243369f, 0.11588344f, 0.17738199f, -0.04601027f, -0.25959635f, 
    0.01330058f, 0.12278505f, -0.16534567f, -0.02114863f, -0.14272062f, -0.37830454f, 0.10214171f, -0.13133639f, 
    0.06929767f, -0.31784633f, 0.08500841f, -0.26239797f, -0.07330375f, -0.08555045f, -0.06656929f, -0.34869814f, 
    0.10646031f, 0.08151897f, 0.16143845f, -0.01328174f, -0.05578929f, 0.07634822f, 0.12345064f, -0.06682759f, 
    0.08614703f, -0.00244817f, 0.04052826f, 0.08631444f, 0.07144696f, 0.04375282f, 0.18593365f, 0.11650357f, 
    0.01092376f, -0.09510119f, 0.19397119f, -0.12481204f, -0.20724505f, -0.19541150f, -0.09615560f, -0.04939137f, 
    -0.13059337f, 0.12137445f, 0.12161861f, 0.08296970f, 0.11956711f, -0.20383562f, -0.05690679f, 0.07622668f, 
    -0.00911762f, -0.06291942f, -0.27445629f, 0.13338678f, -0.20591106f, -0.10203055f, -0.11748556f, -0.11033739f, 
    -0.10982049f, 0.03155761f, -0.34457350f, 0.27681372f, -0.01793648f, -0.14131145f, -0.07360808f, -0.07666092f, 
    0.17623246f, -0.05967493f, 0.42488006f, 0.08365577f, 0.14544815f, -0.00795941f, -0.01403890f, 0.14917202f, 
    0.03672436f, 0.28682101f, -0.06220929f, 0.11847444f, 0.06240270f, 0.18572167f, 0.02966290f, -0.15825327f, 
    0.06074266f, 0.09362087f, -0.00127102f, -0.08591841f, 0.05838048f, -0.05922893f, -0.08938077f, 0.00639342f, 
    -0.01559899f, 0.07310355f, 0.28341088f, -0.07558344f, 0.37161824f, -0.12101848f, -0.07588695f, 0.05253552f, 
    0.04993635f, -0.22825472f, 0.17052189f, -0.05119302f, 0.37591246f, 0.17822076f, -0.00737698f, -0.11439389f, 
    -0.04084068f, -0.15083945f, -0.14498302f, 0.06367774f, -0.20208237f, -0.00488036f, 0.10648717f, 0.11903622f, 
    0.29908654f, 0.12297285f, -0.11351612f, -0.09868044f, -0.14044653f, -0.02165302f, 0.02818559f, 0.27123216f, 
    -0.00510057f, -0.01047499f, 0.04978958f, -0.03971286f, -0.12849192f, 0.04123035f, -0.12603462f, -0.07208798f, 
    0.09021095f, 0.26831183f, 0.08529988f, -0.05223828f, 0.13918412f, -0.17326607f, 0.27054948f, -0.07583120f, 
    0.00654374f, 0.15068410f, 0.05928919f, -0.00837955f, -0.12238730f, -0.03761638f, -0.03276273f, -0.21060322f, 
    0.01257994f, 0.23180875f, -0.03565429f, -0.01222481f, -0.04539572f, -0.06261079f, 0.22582963f, 0.05129041f, 
    0.04299304f, -0.07627320f, -0.00429114f, -0.03862291f, -0.25091732f, 0.06446430f, 0.31011051f, -0.18804051f, 
    0.07156565f, -0.13623282f, -0.15187193f, 0.22706838f, 0.19175780f, -0.25018871f, 0.03759675f, 0.06946838f, 
    0.07240483f, 0.13024563f, 0.12836091f, -0.30738723f, 0.09534143f, 0.15090504f, -0.00895777f, -0.27604541f, 
    0.07984434f, -0.14379022f, -0.18733783f, 0.21017028f, -0.07323658f, 0.07099629f, -0.25309232f, 0.06048124f, 
    0.13853791f, 0.13679677f, -0.18099855f, 0.14264432f, 0.00403729f, -0.08567765f, -0.08137690f, -0.11063329f, 
    0.38395354f, -0.15519893f, 0.37277356f, -0.02006735f, -0.00411197f, 0.03026996f, -0.13470721f, 0.21903604f, 
    0.15256877f, 0.03724213f, 0.11597935f, 0.08539502f, 0.08616394f, 0.08569825f, 0.05708174f, -0.10110824f, 
    0.06591600f, 0.03904685f, 0.03711003f, 0.09275836f, 0.02327104f, 0.11829548f, 0.24896799f, -0.11194801f, 
    0.07268086f, -0.18994784f, 0.10253866f, 0.09611292f, 0.15143698f, -0.00457968f, 0.06611395f, -0.06331509f, 
    0.14526123f, 0.08860709f, -0.09914720f, 0.17996326f, 0.20945965f, 0.21899003f, -0.03649640f, -0.02082713f, 
    0.06514224f, -0.15197095f, 0.00133597f, -0.25701967f, 0.08246878f, -0.06416449f, -0.09290069f, -0.03868543f, 
    0.07848202f, -0.21758801f, -0.29157865f, 0.07995600f, -0.04553908f, 0.06826391f, 0.17958049f, 0.00830153f, 
    -0.00929322f, 0.12696692f, -0.25958225f, 0.02415919f, 0.03738412f, -0.05937907f, 0.05165726f, 0.21111915f, 
    0.18770371f, -0.00342103f, 0.05954386f, -0.04302688f, -0.19266841f, -0.04109235f, -0.25397620f, -0.22592269f, 
    -0.04621741f, -0.10605689f, 0.10514589f, -0.16413607f, 0.08075503f, -0.11079085f, -0.06114893f, -0.25433192f, 
    0.29026127f, -0.18317477f, 0.08844321f, 0.04456452f, -0.02010678f, 0.07837173f, 0.27920833f, -0.10753161f, 
    -0.10662897f, 0.03395706f, -0.00017564f, 0.08801606f, 0.10153031f, -0.07707188f, -0.09740444f, -0.11411104f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.02371612f, 0.19371480f, -0.12549588f, -0.06538676f, 0.04992769f, -0.08802370f, -0.02480833f, 0.19610693f, 
    0.08243994f, 0.10401584f, 0.21351649f, -0.12235221f, 0.20554601f, -0.07615297f, 0.13943084f, 0.05586799f, 
    0.10437717f, 0.18618178f, -0.05099526f, 0.15484780f, -0.04891058f, 0.06483005f, 0.22538604f, 0.19443613f, 
    0.03023000f, 0.01663485f, 0.18117489f, -0.23046441f, 0.06914394f, 0.11667518f, 0.12846626f, -0.02501053f, 
    -0.08458603f, 0.14803776f, 0.16897905f, 0.14759406f, 0.07022004f, -0.14404309f, 0.09227952f, 0.04346839f, 
    0.26348305f, -0.01946498f, 0.03128505f, -0.10702357f, -0.10990186f, -0.03716676f, 0.05555642f, 0.17300028f, 
    0.03125431f, -0.00155017f, -0.00890128f, 0.27814308f, -0.10050126f, 0.14655669f, -0.03221148f, 0.25189736f, 
    -0.18075727f, 0.25159088f, -0.05065103f, -0.13677868f, 0.08300361f, -0.20317963f, -0.12705854f, -0.07545556f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.00051907f, -0.23147827f, -0.05322345f, -0.09511022f, 0.11116184f, 0.17319441f, 0.02861902f, -0.25062278f, 
    0.15311754f, 0.06976540f, 0.08965723f, -0.06130331f, -0.07694559f, 0.20888425f, -0.07077037f, -0.81357479f, 
    -0.15028702f, -0.43497249f, -0.05011306f, -0.53212112f, -0.25030062f, 0.02961222f, -0.13310139f, -0.25364500f, 
    -0.11116496f, -0.13912849f, -0.07592879f, 0.11521392f, -0.04061233f, -0.03873058f, -0.05360305f, 0.23723561f, 
    -0.04545380f, -0.43155724f, -0.09277945f, -0.21377899f, -0.07643516f, 0.23333696f, 0.12343419f, 0.02328089f, 
    -0.51222152f, 0.02557696f, -0.51340371f, 0.21603815f, -0.13800864f, 0.01916772f, -0.17342868f, -0.16200227f, 
    -0.42532209f, -0.52994454f, -0.15064166f, 0.07635496f, -0.07124712f, -0.28957078f, -0.12802535f, -0.09501867f, 
    -0.11488543f, -0.01142773f, 0.23270884f, 0.35044608f, -0.45322677f, 0.20015940f, -0.09220180f, -0.27161160f, 
    0.08261173f, 0.05093653f, -0.25360811f, -0.50152224f, 0.20008241f, -0.04219302f, -0.39300931f, -0.02423430f, 
    -0.01410426f, -0.08769770f, 0.08908916f, -0.04721094f, 0.17064166f, 0.14907621f, 0.15734316f, 0.24114859f, 
    0.04369405f, -0.15371253f, -0.41898799f, -0.03430432f, 0.08294497f, -0.01310915f, 0.16865164f, 0.27339259f, 
    -0.59383690f, -0.39753065f, -0.17453499f, -0.48092547f, 0.00102759f, 0.11801846f, -0.16673647f, 0.11242871f, 
    -0.13536143f, 0.02241127f, 0.23823890f, 0.09526590f, 0.24436712f, 0.21737662f, 0.08163727f, -0.03188722f, 
    0.08800133f, -0.21222994f, 0.18999720f, 0.00777854f, 0.49205184f, 0.00561493f, 0.04010974f, 0.23831454f, 
    -0.34059173f, -0.27979210f, -0.03603188f, -0.04688067f, 0.27959022f, 0.07503348f, -0.02549239f, 0.15746999f, 
    0.01593047f, -0.03572476f, -0.02331784f, -0.19987263f, -0.24033426f, 0.11589690f, 0.07385638f, 0.07142652f, 
    0.16808170f, -0.28937650f, 0.03798947f, 0.15046087f, 0.19003926f, -0.14090146f, -0.14107712f, -0.06477387f, 
    -0.05036809f, -0.02120608f, 0.15356034f, 0.10556243f, -0.07180353f, -0.27986476f, 0.06231315f, -0.32415804f, 
    -0.25925341f, 0.19910030f, 0.08806130f, 0.17928143f, -0.47341228f, -0.15917507f, 0.15487199f, 0.26576185f, 
    0.17065586f, -0.00918186f, -0.08548472f, -0.18947081f, -0.32186854f, 0.04350023f, 0.17630009f, -0.50184590f, 
    0.00943481f, -0.04042793f, 0.21347544f, -0.28917477f, 0.17466965f, -0.12495296f, -0.05669119f, 0.08024941f, 
    0.12163536f, -0.16871779f, -0.46551365f, 0.00960130f, 0.35224631f, -0.04723606f, -0.40902093f, -0.18660602f, 
    0.22469915f, -0.04212162f, -0.08394466f, 0.14980558f, -0.67008734f, 0.19829634f, 0.31532654f, 0.13821056f, 
    -0.07143903f, 0.12833653f, -0.07354004f, 0.03678095f, -0.28526190f, -0.68799597f, -0.25036445f, -0.23102124f, 
    0.15804136f, 0.09446669f, -0.18037237f, 0.22373463f, -0.04597779f, -0.15567707f, 0.26016417f, -0.07165863f, 
    0.05011411f, 0.02523635f, -0.20944735f, 0.26203123f, -0.24354208f, 0.08757732f, -0.18037620f, -0.10543269f, 
    0.09885027f, -0.23477559f, 0.16211809f, -0.07628945f, -0.25195122f, 0.00950896f, -0.01408109f, 0.00593330f, 
    0.27856687f, 0.05495285f, -0.18075123f, 0.14832588f, 0.01904660f, 0.10947572f, -0.40888715f, -0.03858932f, 
    0.06048786f, -0.17483105f, 0.00726595f, -0.09578039f, 0.01746953f, -0.06149147f, -0.04919982f, 0.06791932f, 
    -0.12826033f, 0.13749354f, -0.34312660f, 0.03447777f, 0.29195267f, 0.07755368f, -0.25176227f, -0.22613055f, 
    0.03235207f, 0.02569771f, -0.06561727f, -0.30373091f, -0.50062323f, 0.18717569f, 0.04617632f, -0.39772177f, 
    0.02479209f, -0.36201981f, 0.07948473f, -0.34246671f, -0.01596261f, 0.02095037f, 0.27389508f, 0.00176287f, 
    -0.29288572f, -0.15693349f, 0.00799333f, 0.19337048f, -0.17362136f, 0.08849780f, -0.32770091f, -0.06897843f, 
    -0.59980243f, -0.06730416f, -0.15981559f, -0.11880986f, -0.36327180f, -0.06940785f, -0.11721383f, 0.31522933f, 
    -0.33855227f, 0.04149996f, 0.10325538f, 0.10795081f, 0.06081225f, 0.04228666f, -0.14786513f, -0.08506812f, 
    0.07822511f, 0.05392286f, -0.25616235f, 0.03517786f, 0.07117770f, -0.17316590f, 0.19060291f, 0.12093679f, 
    -0.08418215f, 0.06200083f, -0.07766433f, -0.31814355f, -0.21964972f, 0.12495308f, -0.04179370f, -0.02960530f, 
    -0.33181959f, -0.01630119f, 0.18838078f, 0.03854934f, -0.04933405f, 0.11731496f, -0.01586584f, 0.03487109f, 
    0.06585109f, -0.23701613f, 0.19948594f, -0.02088518f, -0.15150157f, -0.35526660f, 0.05721174f, -0.59232736f, 
    -0.20257139f, -0.14467473f, 0.11206449f, 0.21003585f, 0.17913012f, 0.04437960f, 0.09493461f, -0.16754423f, 
    -0.13534093f, 0.11651520f, 0.09458880f, -0.14496815f, -0.11322229f, 0.03331205f, -0.28093639f, -0.12854779f, 
    -0.05258768f, -0.02131693f, 0.17278297f, -0.39416626f, -0.07419842f, 0.09673761f, -0.02301831f, -0.16798924f, 
    -0.19487536f, 0.07282034f, 0.04996686f, -0.19176945f, 0.02567485f, 0.22951622f, -0.04245744f, -0.00774209f, 
    -0.20906550f, 0.20315130f, -0.22376324f, -0.07232535f, -0.11800008f, -0.13227278f, 0.30275163f, 0.00784983f, 
    -0.15451923f, 0.11326474f, 0.03144243f, 0.26576430f, -0.42654479f, -0.02813079f, 0.16287507f, -0.09618809f, 
    0.09326958f, 0.12222097f, -0.00067880f, 0.01809062f, -0.23408349f, -0.08708349f, 0.11075684f, 0.07150898f, 
    -0.33001575f, -0.10703601f, -0.01716936f, -0.11903945f, -0.10110060f, -0.11441283f, -0.17543726f, 0.23201655f, 
    -0.03435427f, -0.23398490f, 0.13099945f, 0.00432605f, -0.00210372f, -0.13496780f, 0.10210562f, 0.18347739f, 
    -0.20338473f, 0.17012034f, 0.01504119f, 0.12277473f, -0.31430611f, -0.39130834f, 0.11787971f, 0.17454599f, 
    0.27130261f, 0.09246638f, -0.31213740f, -0.14192529f, 0.05734264f, -0.78832436f, -0.50085717f, -0.44719163f, 
    -0.38501877f, 0.26219878f, 0.08006611f, 0.09788262f, -0.03367636f, -0.33850831f, 0.09633983f, 0.06657384f, 
    -0.02954025f, -0.22726749f, 0.02646474f, -0.16594251f, 0.13761418f, -0.27162281f, 0.15601303f, -0.37893799f, 
    0.03423256f, 0.12171573f, -0.27718544f, -0.27110398f, 0.15156429f, 0.04472889f, -0.41047919f, 0.03753926f, 
    0.15391606f, -0.16185345f, 0.06129220f, -0.41928095f, -0.67418128f, -0.30236682f, 0.17453775f, -0.15989372f, 
    0.17957319f, 0.09604926f, -0.06379277f, 0.30975154f, 0.30031869f, 0.09856368f, -0.15690707f, 0.06592309f, 
    0.00753306f, 0.23019618f, -0.49176937f, 0.20406523f, -0.31107420f, -0.29265505f, -0.38601056f, -0.07981694f, 
    0.21512008f, -0.35601047f, 0.00103060f, 0.26608962f, 0.09414092f, -0.40701824f, 0.04061865f, -0.18835476f, 
    -0.05737449f, -0.04932900f, -0.26649114f, -0.05876463f, -0.16448578f, -0.36167541f, 0.16061608f, 0.16384023f, 
    0.18658425f, 0.16888726f, 0.04044101f, 0.18841748f, 0.21913470f, -0.39545545f, 0.00430447f, -0.49834120f, 
    0.20569323f, 0.31961161f, 0.25266218f, 0.23478585f, 0.01691861f, -0.12130800f, -0.03484711f, -0.23893009f, 
    0.01644997f, -0.17049840f, 0.04444376f, -0.18470435f, -0.19508529f, -0.14014694f, -0.28230411f, -0.29805887f, 
    -0.12241860f, -0.05425400f, -0.02576328f, -0.32001221f, 0.07575113f, -0.17148811f, -0.10299790f, -0.32320026f, 
    -0.22445714f, 0.01062419f, -0.35681507f, -0.46730509f, 0.13350289f, 0.02261158f, 0.00011930f, -0.14351910f, 
    0.01131910f, 0.03892261f, -0.11316577f, 0.07717343f, 0.22197549f, -0.21627310f, 0.24116211f, 0.07055543f, 
    0.19567324f, 0.11696137f, 0.11509650f, -0.19849749f, -0.05594339f, -0.19095288f, -0.07294179f, -0.09500474f, 
    -0.34778529f, 0.02375978f, 0.03343193f, 0.14646707f, -0.30694357f, -0.51392913f, -0.02646146f, 0.13218549f, 
    0.13150747f, -0.41509777f, -0.50021458f, -0.02109016f, -0.33982694f, 0.04970114f, 0.16748437f, -0.07165774f, 
    -0.08805613f, -0.09742364f, -0.18191476f, 0.19744256f, 0.17413002f, -0.17610921f, 0.09458522f, -0.47227755f, 
    0.02990684f, 0.16737783f, -0.13162589f, 0.29223523f, 0.09815470f, -0.55317426f, -0.14920945f, -0.61252975f, 
    0.15421031f, 0.00613431f, 0.11852551f, -0.34255889f, -0.15390654f, -0.17376849f, -0.19909897f, -0.22813566f, 
    -0.09194881f, 0.22884519f, -0.64249855f, -0.03192542f, -0.25718522f, 0.30960599f, -0.54289818f, 0.18838696f, 
    -0.09456932f, -0.23152545f, 0.22224210f, -0.44855872f, 0.08347963f, -0.24820468f, -0.09837691f, -0.16043292f, 
    -0.15786193f, -0.25549555f, -0.55551106f, 0.11059918f, -0.55831164f, -0.03979935f, -0.31361490f, 0.27248165f, 
    0.05462297f, 0.04279949f, -0.53281993f, -0.09803817f, 0.05516363f, 0.11560809f, -0.09516305f, -0.02894093f, 
    -0.04584964f, 0.21347213f, -0.04798162f, 0.21436532f, 0.17094092f, -0.27907509f, -0.40341073f, -0.27837333f, 
    -0.29597473f, 0.06983992f, 0.13752678f, 0.11633124f, -0.08487551f, 0.09130581f, 0.24570733f, 0.02711307f, 
    -0.08215571f, -0.06409489f, -0.27348730f, -0.21208687f, 0.09013710f, -0.29072985f, -0.00925353f, 0.21229257f, 
    -0.03724799f, -0.14676993f, -0.17685765f, 0.15296385f, -0.29183683f, 0.15469894f, -0.20326628f, 0.21788284f, 
    0.02325273f, -0.04556428f, -0.13488188f, 0.04117180f, -0.21639006f, -0.03930175f, -0.30924672f, 0.03326273f, 
    0.03286358f, 0.32277319f, -0.07797775f, -0.35486111f, -0.29415831f, -0.10811495f, -0.27835226f, -0.34345809f, 
    -0.15264070f, 0.24258110f, 0.02084360f, -0.14277504f, 0.00825568f, 0.18562184f, 0.36478207f, 0.08973552f, 
    -0.15824696f, 0.11071031f, -0.05527429f, 0.04513708f, -0.00359792f, 0.14232939f, -0.38474187f, -0.09788402f, 
    0.21343258f, 0.16019878f, -0.06376301f, -0.04564740f, -0.30443338f, 0.18183249f, -0.00798538f, 0.08836018f, 
    -0.07566412f, -0.40929294f, 0.18462440f, -0.43957344f, -0.30365527f, 0.15571664f, -0.48331553f, -0.03269812f, 
    -0.00239577f, 0.13692425f, 0.28942847f, -0.16689835f, 0.02245081f, -0.43298998f, -0.03837820f, -0.04462780f, 
    0.10041660f, 0.04093767f, -0.39731237f, 0.27341095f, -0.32394889f, -0.39117944f, -0.24310084f, 0.01477659f, 
    -0.01897669f, 0.26350915f, 0.16263755f, -0.07657482f, -0.17046791f, -0.05008505f, -0.37393349f, -0.12840502f, 
    0.11351977f, -0.31915852f, -0.28305700f, -0.16999140f, 0.38773665f, -0.31415206f, -0.29979625f, -0.19438604f, 
    -0.08212880f, 0.22557126f, -0.15942150f, -0.12939373f, -0.03787842f, -0.08527566f, 0.24949639f, -0.11470032f, 
    0.07202032f, 0.05742076f, 0.35705054f, 0.03848324f, -0.23651710f, -0.07755994f, -0.21965207f, -0.09073911f, 
    0.26580665f, -0.20986101f, -0.01014721f, -0.00704685f, -0.13846476f, -0.27558821f, -0.05392303f, -0.14912035f, 
    0.06757560f, -0.06864507f, 0.00800421f, -0.27671099f, 0.17394044f, -0.19386530f, -0.27649802f, 0.28622940f, 
    -0.13090743f, 0.22716880f, -0.45756841f, -0.05575676f, 0.23940271f, -0.03589988f, -0.43008330f, -0.34430999f, 
    0.06394696f, 0.20860732f, 0.04654528f, -0.12125172f, -0.10957588f, 0.24174036f, 0.22399290f, 0.35908484f, 
    0.25692576f, 0.06043847f, 0.06672104f, 0.14990896f, -0.14801741f, -0.26774898f, -0.01918063f, -0.03712252f, 
    -0.09417175f, 0.02743539f, -0.16237026f, -0.22212681f, 0.00189480f, -0.17690913f, 0.09622448f, -0.19288328f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.20453222f, 0.13144478f, 0.27666640f, -0.22189331f, -0.08671238f, -0.01863362f, -0.11904706f, -0.17842172f, 
    -0.04654346f, 0.01557125f, 0.09966191f, -0.07174148f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
