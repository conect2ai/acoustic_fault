#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.00788256f, -1.05973387f, 0.12990101f, -0.11014592f, 0.42137057f, -0.74140584f, -0.86618149f, -0.86988741f, 
    -0.51521087f, 0.34404463f, 0.14204927f, 0.24441382f, 0.25765979f, -0.30010018f, 0.31242582f, -0.05077909f, 
    0.09290788f, -0.17308839f, -0.09695669f, -0.32258376f, 0.09900174f, -0.51690245f, -0.07791197f, 0.10148239f, 
    0.10081933f, -1.16849065f, -0.80224842f, 0.32800719f, 0.72853833f, 0.66114551f, -0.69879651f, -0.58820891f, 
    -0.46395603f, 0.18345879f, 0.47823888f, 0.16253647f, -0.15352829f, 0.23217972f, 0.30327451f, -0.14439678f, 
    -0.05722760f, 0.17528969f, 0.04646213f, -0.15937844f, 0.08580177f, -0.30730551f, 0.21882547f, -0.14801890f, 
    0.16184670f, -0.05807150f, 0.48231331f, 0.78769267f, 0.12724407f, -0.73014241f, 0.26151651f, -0.02666759f, 
    -0.09183282f, -0.17134853f, -0.49716124f, -0.70061719f, -0.17463906f, 0.39036617f, -0.29698443f, 0.30664772f, 
    -0.21868989f, -0.06242101f, 0.19668025f, 0.12147111f, 0.17525317f, -0.23588054f, -0.28984338f, 0.04441235f, 
    0.01768063f, 0.06469624f, 0.14707617f, 0.42755380f, 0.89001852f, 0.17024496f, -0.19660063f, -0.81315762f, 
    -0.12293925f, -0.25982967f, 0.08860329f, -0.34288678f, -0.37291911f, 0.11439092f, 0.33770472f, 0.12408864f, 
    0.34037277f, -0.18494233f, 0.11602005f, -0.03670245f, 0.05197603f, -0.39603865f, 0.11409178f, 0.37234136f, 
    -0.32650271f, -0.33820277f, -0.30803773f, 0.22573136f, -0.30887046f, 0.14369145f, -0.07125802f, -0.16230445f, 
    0.42381078f, 0.13333578f, 0.00091043f, 0.25559378f, -0.59999961f, -0.58573598f, -0.33854830f, 0.08461319f, 
    -0.20372023f, -0.20928733f, -0.42142344f, -0.37877014f, -0.08942650f, 0.09271117f, 0.22394060f, -0.32229674f, 
    0.08672869f, -0.12387153f, -0.11999500f, 0.09946563f, -0.08957911f, -0.44525546f, -0.27398190f, -0.06192706f, 
    0.26176280f, -0.19323687f, 0.68695247f, 0.28423339f, 0.23295811f, 0.42437452f, 0.00587618f, -0.07644070f, 
    -0.25920168f, 0.12516858f, 0.22473679f, -0.28868181f, 0.08863865f, -0.27991268f, -0.19763584f, -0.52927226f, 
    -0.65208721f, -0.13555901f, 0.35037905f, 0.15539978f, 0.00519279f, -0.10116077f, 0.35833555f, -0.03447142f, 
    0.04557714f, 0.24655345f, 0.23734014f, -0.20901123f, -0.22006837f, 0.17959751f, 0.11193173f, -0.20765489f, 
    0.39754841f, -0.04421781f, -0.04035969f, -0.02249070f, -0.03104063f, -0.35542259f, 0.12279436f, 0.11082597f, 
    0.04282933f, 0.14680277f, -0.07719612f, 0.06867403f, 0.10750894f, 0.04445424f, 0.14136654f, 0.50947219f, 
    0.15599439f, 0.27370852f, 0.29122946f, -0.23414765f, 0.10364395f, 0.16406955f, -0.11201753f, -0.30910733f, 
    -0.23415720f, 0.12393156f, 0.05699836f, 0.00126247f, -0.21168493f, -0.03918393f, -0.29327738f, 0.04204192f, 
    0.15912174f, -0.02229861f, 0.00694289f, -0.14328398f, -0.02204080f, -0.26752260f, -0.03622293f, -0.36919168f, 
    -0.60687751f, -0.31498596f, -0.30369648f, -0.17264295f, -0.79239810f, 0.56592411f, 0.01269696f, -0.44194764f, 
    0.19326036f, 0.65868562f, 0.18786398f, -0.42999360f, -0.29071257f, -0.06531882f, -0.29121879f, -0.21468386f, 
    -0.10307219f, -0.42401806f, -0.35074973f, -0.07785694f, -0.37325516f, -0.15449058f, -0.07523905f, 0.20460960f, 
    -0.21791086f, -0.42697093f, -0.27217197f, -0.04745488f, 0.06736688f, -0.31908005f, 0.45136291f, -0.12414129f, 
    0.05910900f, 0.00519574f, 0.31318218f, 0.22199851f, 0.15804425f, -0.09499569f, -0.37272373f, 0.30335444f, 
    -0.43155575f, -0.19459657f, 0.16017167f, 0.01627524f, 0.13350266f, 0.21602617f, 0.03019528f, 0.27021059f, 
    -0.03218102f, 0.00040021f, -0.89702535f, -0.54008764f, -0.70460302f, -0.61725807f, -0.50115192f, 0.03962985f, 
    0.05254080f, 0.51853538f, 0.43207183f, 0.46008176f, 0.11619450f, 0.08007423f, 0.22276746f, 0.22571865f, 
    -0.13250835f, -0.08160765f, 0.09726340f, 0.06048672f, 0.06107344f, 0.04556746f, -0.18388838f, -0.02929110f, 
    0.08541292f, -0.26652995f, 0.02143262f, -0.50307143f, -0.20208018f, -0.55430514f, 0.23303701f, 0.33673951f, 
    -0.00668331f, 0.30821353f, 0.00989966f, 0.38804060f, -0.44626987f, -0.03014731f, 0.06228365f, -0.16397505f, 
    0.07351735f, -0.08678242f, -0.33025277f, 0.13206299f, -0.04461313f, 0.25482339f, 0.33538395f, 0.05306654f, 
    -0.00145601f, -0.06267704f, 0.19885568f, 0.04940739f, 1.16103137f, -0.48662332f, -0.71273106f, -0.42578149f, 
    -0.80323482f, 0.70597970f, 0.18979408f, 0.33198544f, 0.19371517f, -0.05150210f, -0.05250406f, 0.22903126f, 
    -0.25196034f, 0.10078121f, -0.04925856f, 0.10165067f, 0.09639479f, -0.01668810f, -0.01355005f, -0.08168167f, 
    -0.01764237f, -0.00920620f, -0.11509638f, -0.07736539f, 0.37301195f, 0.31155321f, -0.46150815f, -0.09750681f, 
    0.43069667f, -0.32534057f, 0.18991570f, 0.19857535f, -0.06835628f, 0.17888965f, -0.45500237f, 0.51901400f, 
    -0.28532389f, 0.13602647f, -0.12146652f, -0.10531940f, -0.13898903f, -0.01182353f, 0.20883580f, 0.02575078f, 
    -0.28387508f, -0.14041026f, 0.21716088f, 0.04277963f, 0.14585900f, -0.08671183f, 0.15245962f, -1.08160317f, 
    -0.26895517f, 0.21236047f, 0.87958819f, 0.04955219f, -0.22351708f, -0.36769202f, -0.09326275f, -0.10280526f, 
    -0.13156290f, -0.14711398f, 0.26826423f, -0.29728949f, 0.24686809f, 0.05051588f, -0.15051049f, -0.32181987f, 
    -0.12841061f, -0.17256780f, -0.18467592f, -0.12961328f, -0.21465927f, -0.06697851f, -0.26924354f, -0.79290104f, 
    0.31694451f, 0.02480523f, -0.49172813f, 0.26682925f, -0.48521778f, -0.23730868f, 0.27794412f, 0.52572906f, 
    0.46170557f, 0.04234128f, 0.03130024f, -0.21850839f, -0.20759991f, 0.23987342f, 0.06032074f, -0.22096735f, 
    -0.20654070f, 0.17339812f, 0.25159401f, 0.08063167f, 0.04358440f, -0.19751662f, 0.22970451f, -0.20792557f, 
    0.19029972f, 0.55507886f, 0.50048769f, -0.53242040f, -0.72120178f, -0.55879682f, -0.14258133f, 0.15241265f, 
    0.42335159f, 0.14077526f, -0.08636703f, 0.18845226f, -0.21242461f, 0.32951766f, 0.02245906f, -0.43833292f, 
    0.15309878f, 0.10319887f, -0.04018686f, -0.03395689f, -0.00970089f, 0.04514563f, 0.03545575f, -0.13954298f, 
    0.04459773f, -0.08015030f, 0.24663430f, 0.13361013f, -0.16219595f, -0.22551431f, 0.46347535f, -0.43725812f, 
    -0.14156839f, -0.01260181f, 0.00074674f, -0.19529399f, -0.08773018f, 0.10018910f, 0.00498870f, 0.33191839f, 
    -0.17965573f, 0.25081533f, 0.08388767f, -0.37842822f, -0.01294647f, -0.29013678f, -0.01822784f, 0.10260063f, 
    -0.02749692f, 0.26848426f, -0.49210310f, -0.62298977f, -0.07607702f, 0.33425063f, 0.45044336f, 0.14551447f, 
    -0.28124127f, -0.31368953f, 0.72954768f, -0.38631144f, -0.32217392f, -0.04586332f, 0.07526810f, 0.26066530f, 
    0.03227762f, -0.01569129f, -0.09522752f, 0.02158867f, -0.18139453f, 0.21851738f, 0.15305889f, -0.04493139f, 
    0.18045712f, -0.27756500f, 0.25851408f, 0.15836093f, 0.15185347f, 0.26130641f, -0.25410858f, -0.40727890f, 
    -0.12416999f, 0.17964707f, -0.14624463f, 0.32129151f, -0.08643753f, -0.30370179f, -0.63978887f, -0.03575671f, 
    0.16552649f, 0.12620650f, -0.28534657f, 0.22476512f, 0.23920044f, -0.11143339f, 0.06356164f, -0.06332627f, 
    -0.19417690f, -0.40435928f, -0.56162190f, -0.70198035f, -0.26440987f, -1.08249092f, -0.18986122f, 0.55850351f, 
    0.52879149f, 0.71823961f, 0.32522798f, 0.24689071f, 0.04244899f, 0.18455753f, -0.08205737f, -0.23288281f, 
    -0.18194073f, -0.10005534f, 0.22326621f, -0.04440870f, -0.01167107f, -0.00560786f, -0.03478177f, -0.33524817f, 
    0.08610106f, -0.28248283f, -0.00812068f, 0.05438068f, -0.02670382f, 0.81105298f, -0.32481426f, -0.36211067f, 
    0.30148080f, -0.47213137f, 0.27790043f, 0.24315432f, 0.21869016f, -0.07828362f, -0.19649726f, -0.01930700f, 
    -0.23740284f, -0.12413884f, -0.19607963f, 0.20079328f, -0.03934093f, -0.09147320f, -0.02614344f, -0.06874871f, 
    -0.11999880f, -0.22242059f, -0.21330163f, 0.07248318f, -0.41123989f, -0.49708864f, -1.13654470f, -0.60115492f, 
    -0.59772551f, -0.49148640f, -0.22668673f, 0.20590451f, -0.01764105f, -0.12908334f, 0.09622125f, 0.18055126f, 
    -0.56221265f, -0.58870429f, -0.32646784f, -0.25256523f, -0.22630028f, 0.15638013f, 0.04815331f, -0.13268299f, 
    0.11724710f, -0.04281848f, -0.04679297f, -0.03168114f, -0.09177521f, -0.02516916f, -0.26805186f, -0.96954882f, 
    -0.78866994f, -0.60327786f, -0.07948742f, -0.48145759f, 0.10532752f, 0.10892717f, 0.03124663f, -0.35575065f, 
    -0.23493780f, 0.03438715f, -0.13510031f, -0.25501576f, -0.02972129f, -0.26324832f, 0.40369231f, -0.36388102f, 
    -0.26381853f, 0.22759899f, -0.31454957f, 0.08552935f, -0.33229777f, 0.01024041f, -0.15786828f, 0.04076842f, 
    0.63601339f, 0.09852991f, 0.18130119f, -0.21366836f, -0.49486992f, -0.02387723f, 0.13035615f, 0.30678669f, 
    -0.06430051f, -0.13952367f, -0.27639642f, -0.25628471f, 0.13777080f, -0.00394330f, 0.06796195f, 0.30117619f, 
    0.00483428f, -0.14146467f, -0.14819783f, -0.18547724f, -0.27356669f, -0.26301959f, -0.25090882f, -0.25227213f, 
    -0.13346471f, -0.18773614f, -0.54038686f, -0.26704311f, 0.06400163f, -0.75072002f, -0.60933459f, -0.31422302f, 
    -0.38375252f, -0.15167598f, -0.23182158f, 0.23810616f, -0.17219245f, 0.08453936f, 0.37679699f, 0.50487846f, 
    0.02278380f, -0.19366385f, -0.24603096f, -0.44114777f, -0.44099793f, -0.31430489f, -0.09284357f, -0.03943795f, 
    -0.27611464f, -0.06679826f, -0.41026193f, -0.33456507f, 0.26701173f, -0.14051560f, -0.01291195f, 0.68690151f, 
    0.92705345f, -0.83728921f, -0.54114610f, 0.16697033f, 0.16193216f, -0.07140371f, -0.12523718f, -0.04496826f, 
    -0.16151184f, 0.07589143f, 0.19982406f, -0.03032519f, -0.19206811f, 0.01501629f, -0.13858557f, 0.23034078f, 
    -0.07857286f, 0.08892029f, 0.01466881f, 0.13849239f, -0.37736702f, 0.00193907f, 0.40998206f, 0.10500064f, 
    0.43755141f, 0.42081347f, -0.88201278f, -0.54609203f, -0.75404114f, -0.22297983f, -0.09778371f, -0.20372757f, 
    0.26646349f, 0.28657719f, -0.06944173f, -0.21112476f, -0.38451293f, 0.58600122f, -0.24460830f, -0.17568581f, 
    -0.14991152f, -0.12818895f, 0.28430083f, -0.21551804f, 0.23404543f, 0.33389512f, 0.30991596f, 0.00034637f, 
    0.31563777f, -0.16761920f, 0.02405170f, 0.16684096f, -0.02703415f, -0.26303726f, -0.03580879f, 0.02623076f, 
    -0.10487776f, -0.23244727f, 0.03435079f, -0.15187797f, -0.01922054f, 0.02477833f, 0.10359203f, -0.20127818f, 
    0.28780800f, -0.22835222f, -0.24012609f, 0.22697131f, -0.27965662f, -0.82741141f, -0.59203309f, -0.50105691f, 
    0.21469440f, -0.43561539f, 0.28565270f, 0.17205952f, -0.00802707f, 0.43368101f, 0.56612265f, 0.12253449f, 
    0.02054338f, 0.16147509f, 0.13182357f, 0.09507796f, 0.05327362f, 0.04510913f, -0.15506990f, -0.24584948f, 
    0.05950357f, -0.10947557f, -0.05785740f, 0.03440242f, 0.16377033f, -0.15355119f, 0.63217539f, -0.85945076f, 
    -0.47809589f, -0.84018236f, -0.81663781f, 0.08406616f, 0.21922666f, 0.58388430f, 0.55687726f, 0.01475642f, 
    -0.28645083f, -0.34466577f, -0.00984644f, -0.26111099f, 0.50250441f, -0.27777472f, -0.25346115f, -0.08403624f, 
    0.26183039f, -0.21859738f, -0.14136721f, 0.16552292f, 0.06405590f, -0.06486890f, -0.02040555f, -0.22300921f, 
    -0.88849264f, -0.40045345f, -0.14339325f, 0.29132798f, 0.35292208f, -0.15026990f, -0.16115572f, 0.31659892f, 
    0.33556756f, -0.00508255f, -0.15234266f, 0.17683983f, 0.03181399f, 0.15000020f, -0.03753475f, -0.08677993f, 
    -0.31154251f, -0.04977776f, -0.26703325f, -0.16592327f, -0.26736528f, -0.41403177f, -0.29408985f, -0.30980736f, 
    0.34019741f, 0.33141837f, 0.21439472f, -0.01486542f, -0.19389351f, 0.06817099f, -0.14027257f, -0.17049348f, 
    -0.07942810f, -0.02188396f, -0.05645376f, 0.01256880f, 0.12598488f, 0.29784125f, -0.30041820f, 0.12089930f, 
    -0.07038981f, -0.19567391f, 0.01321898f, -0.23521467f, -0.33733135f, 0.04361184f, -0.01185258f, -0.02160000f, 
    0.19408898f, 0.66084039f, 0.45944092f, 0.34796804f, -0.13358501f, -0.18674916f, -0.29836383f, 0.00887360f, 
    0.10637744f, -0.07398224f, -0.35251120f, 0.07790276f, -0.06921625f, -0.05679775f, -0.18985721f, -0.17824258f, 
    -0.03799613f, 0.10335677f, 0.12885620f, -0.08379989f, 0.01065859f, 0.20704533f, -0.15269846f, -0.16723537f, 
    0.00010190f, -0.13480593f, 0.21941526f, -0.12609380f, -0.51559407f, -0.01645806f, -0.40488383f, -0.30169004f, 
    -0.10944456f, -0.24364012f, -0.04854210f, 0.36088535f, -0.01614027f, 0.34031785f, -0.24644348f, -0.11752780f, 
    -0.36549938f, -0.38182515f, -0.25681740f, 0.15138012f, -0.04194009f, -0.20415789f, 0.00704841f, -0.17125079f, 
    0.08036490f, 0.47057256f, 0.30917454f, -0.13319126f, -0.10397401f, -0.05672967f, 0.05433378f, 0.30088711f, 
    0.02440392f, -0.06036335f, 0.05214819f, 0.38953838f, -0.10372753f, -0.14568594f, -0.39884463f, -0.21027090f, 
    0.18372628f, -0.07411471f, 0.06986548f, 0.14326553f, 0.14954603f, -0.06820299f, -0.14426030f, -0.20443372f, 
    -0.27004653f, -0.35653681f, 0.08393181f, -0.19761670f, -0.26491997f, -0.18897897f, -0.50247103f, -0.12520096f, 
    -0.02384158f, -0.67856610f, -0.76901734f, -0.47250441f, -0.33148396f, -0.30512109f, 0.18120836f, 0.37772062f, 
    -0.17251250f, 0.19860117f, 0.28716666f, 0.23191217f, -0.02455789f, -0.21604601f, 0.26267335f, -0.20333920f, 
    -0.14987145f, 0.29292238f, -0.03253811f, 0.06673646f, -0.23594427f, -0.42914310f, -0.43939945f, -0.36922911f, 
    -0.55808574f, -0.58674818f, 0.37944317f, -0.06922831f, -0.44156161f, -0.14690620f, -0.17331749f, -0.36174998f, 
    -0.13267341f, 0.12039390f, -0.46550304f, -0.17979695f, -0.17538822f, -0.16737574f, -0.13530178f, 0.00596170f, 
    -0.36535808f, -0.14328468f, 0.34019104f, 0.03978540f, 0.06930271f, 0.45383802f, -0.38665345f, 0.03559147f, 
    -0.58612233f, -0.85833901f, -0.34976482f, -0.00413022f, 0.21083812f, 0.32701495f, 0.23083273f, 0.13408008f, 
    0.17560896f, 0.20976715f, 0.24868330f, 0.04066235f, -0.09731187f, -0.00181956f, -0.06291080f, -0.64962631f, 
    -0.51434857f, -0.31066161f, 0.40206254f, -0.10028807f, 0.09227240f, 0.35923535f, 0.28185591f, 0.48128986f, 
    -0.16029672f, 0.27008522f, 0.09603121f, -0.24556066f, 0.17184903f, 0.08476290f, -0.19910902f, -0.21201073f, 
    0.16720739f, -0.35488591f, 0.34732684f, -0.31329638f, -0.15731500f, -0.01731085f, 0.05838098f, -0.29108146f, 
    0.04541671f, 0.31050342f, 0.16975425f, -0.06466188f, -0.21448328f, 0.19021295f, -0.25415948f, -0.14160340f, 
    0.33285531f, 0.25465241f, -0.01702815f, 0.21004704f, -0.03064358f, 0.15098368f, 0.19614437f, -0.20809925f, 
    -0.19943826f, 0.20015949f, -0.16928898f, 0.00989220f, 0.13368095f, 0.02500083f, -0.23424442f, 0.05831599f, 
    0.23069084f, 0.16596596f, -0.15522121f, -0.07390209f, -0.11144106f, -0.02817882f, -0.12857990f, -0.04508362f, 
    -0.12433931f, -0.73194999f, -0.15585509f, 0.10942315f, 0.17609796f, 0.14348577f, 0.58172679f, 0.31802487f, 
    -0.20331812f, -0.56505495f, 0.24260807f, -0.32083848f, -0.02915294f, 0.04753517f, -0.26047850f, 0.02570561f, 
    0.08929648f, 0.22547352f, -0.23858739f, -0.11232635f, 0.27685913f, 0.06813933f, -0.11442599f, -0.24625634f, 
    -0.02174943f, 0.19993925f, 0.60880369f, 0.42805415f, -0.49389178f, -0.64020801f, -0.07098446f, 0.03889279f, 
    0.11642471f, 0.37398469f, -0.40305510f, -0.56412870f, 0.21345623f, 0.27774584f, 0.56026018f, -0.28041229f, 
    -0.19406405f, 0.14250626f, -0.27387473f, -0.03942853f, -0.09687651f, -0.26279113f, -0.01863541f, -0.00319633f, 
    0.23066367f, 0.28633055f, 0.18270665f, 0.31921345f, -0.76023549f, -0.44895393f, 0.42014971f, 0.50487047f, 
    0.36658874f, 0.45817634f, 0.06146875f, -0.31357244f, -0.20937981f, 0.18920042f, -0.09012338f, -0.10283786f, 
    -0.35610154f, 0.25489271f, 0.06270009f, -0.32144728f, -0.08237768f, 0.05493010f, 0.05064181f, -0.14734410f, 
    0.03625819f, -0.11556949f, 0.08387214f, 0.11818349f, 0.11725333f, 0.13014258f, -0.00229110f, -0.28208071f, 
    0.07855873f, -0.10545615f, 0.22477190f, -0.28843248f, 0.06829514f, 0.30824733f, -0.09988605f, 0.17397903f, 
    -0.08940770f, -0.11632829f, -0.23068117f, 0.19003105f, -0.23181115f, 0.14195994f, -0.19022964f, 0.08415915f, 
    -0.03520694f, 0.30514273f, 0.30201629f, -0.16807738f, 0.02672833f, 0.69849324f, 0.50003684f, -0.23392549f, 
    -0.43989009f, -0.36895913f, -0.18664964f, -0.17726237f, 0.11944047f, -0.20602763f, 0.45409629f, -0.00997424f, 
    0.08945993f, 0.04713895f, -0.20247282f, -0.19543344f, -0.05893545f, -0.09967891f, -0.15901072f, -0.18984310f, 
    -0.28668353f, -0.59592760f, -0.41880611f, -0.33207881f, -0.39398324f, -0.50499612f, 0.47894013f, 0.01048167f, 
    0.17116545f, 0.15142211f, -0.27087098f, 0.37605974f, 0.10822174f, -0.06246679f, 0.03200077f, 0.24096224f, 
    0.14912051f, 0.21192369f, -0.28198814f, 0.04411753f, 0.04692971f, 0.24628459f, 0.05006235f, -0.11282587f, 
    0.03099064f, -0.28116778f, -0.04765847f, 0.24438235f, -0.02016467f, -0.20807165f, 0.26802537f, -0.84233242f, 
    -0.63093638f, -0.15891784f, -0.62027436f, -0.54977375f, -0.21481183f, -0.26963273f, -0.77253151f, -0.40948948f, 
    0.19505711f, 0.17481552f, 0.17335072f, -0.29692665f, -0.29104763f, -0.39197692f, -0.20265408f, -0.18900712f, 
    -0.02795811f, -0.15405670f, -0.13948159f, 0.14581837f, 0.07832190f, -0.19217771f, 0.22631770f, -0.06737631f, 
    -0.58054703f, -0.50270075f, -0.21132444f, 0.06399831f, -0.09031294f, -0.65919852f, -0.64813805f, -0.53075582f, 
    -0.54500473f, -0.29816172f, 0.23278552f, 0.35427928f, 0.20242447f, 0.09449926f, -0.03135186f, -0.16012748f, 
    0.05027479f, -0.21410470f, -0.13987647f, -0.14850137f, 0.00143453f, 0.26177156f, 0.18763918f, -0.02770001f, 
    0.39545333f, -0.71174294f, 0.07945552f, -0.39957258f, -0.61892736f, -0.57928991f, 0.30700964f, -0.22910227f, 
    -0.36234766f, -0.46802843f, -0.50346810f, -0.15696049f, 0.06851268f, -0.08842986f, -0.29088673f, -0.07316796f, 
    0.44619307f, 0.08504955f, 0.19539861f, 0.21002357f, -0.01282118f, -0.16573846f, 0.27201959f, 0.16877449f, 
    0.00450242f, -0.06622010f, -0.72620034f, 0.24615955f, -0.28895757f, -0.05318846f, 0.25289217f, -0.11162603f, 
    -0.33909571f, 0.33856159f, -0.37267247f, -0.11253963f, -0.10580011f, -0.43339750f, 0.07852917f, 0.00726257f, 
    0.12486207f, 0.19245428f, -0.01097909f, 0.07092551f, -0.25598785f, -0.21302821f, -0.20923623f, -0.20129287f, 
    -0.21610084f, -0.32718167f, -0.19028865f, 0.16982506f, -0.36874011f, 0.16008456f, 0.55329853f, -0.10946557f, 
    -0.26370552f, -0.17410789f, -0.28306478f, -0.36136103f, -0.42349660f, 0.03979087f, 0.21444471f, 0.27534553f, 
    0.06406726f, 0.03065971f, 0.29358169f, -0.23917654f, 0.08944552f, 0.17115808f, -0.13492343f, -0.33592883f, 
    0.34506360f, 0.12620756f, 0.20258072f, -0.14014225f, -0.20935574f, 0.17043732f, 0.30840650f, 0.36925441f, 
    -0.09324906f, -0.26601347f, -0.62251306f, -0.54604340f, -0.20981978f, -0.01114694f, -0.04044280f, 0.21844046f, 
    -0.44487628f, -0.39337131f, 0.21989180f, 0.01461541f, -0.03479296f, 0.16648056f, -0.07125336f, 0.07418939f, 
    0.15892123f, 0.18586630f, -0.07314259f, 0.18227232f, -0.04545072f, -0.24085438f, -0.22158435f, -0.41637179f, 
    -0.18567233f, -0.02074558f, 0.31549513f, -0.05308729f, -0.51481026f, -0.45018700f, 0.66548431f, -0.19949853f, 
    0.20308092f, -0.24609990f, -0.27470818f, 0.06649406f, 0.26414105f, 0.06452116f, 0.22268541f, 0.29717597f, 
    -0.02324709f, 0.09035218f, -0.01221667f, -0.20128368f, -0.36880824f, -0.16767122f, 0.05809486f, 0.72789842f, 
    0.61767262f, -0.42514718f, -0.23852706f, -0.18330516f, -0.57455969f, -0.00041023f, 0.19288364f, -0.04746304f, 
    -0.10336623f, -0.32836732f, -0.15763597f, 0.39305332f, -0.17533424f, 0.06904555f, -0.19325802f, 0.01316419f, 
    0.34993210f, 0.21493815f, 0.03796734f, 0.14283244f, 0.12434224f, -0.43800253f, -0.05711209f, 0.07576124f, 
    0.02296912f, -0.20960535f, 0.08521330f, 0.04524864f, -0.10203021f, -0.17106450f, -0.08101332f, 0.27535698f, 
    0.48523706f, 0.11368605f, -0.16577889f, -0.23527695f, -0.05766857f, -0.03117315f, -0.14284512f, 0.02937164f, 
    0.14063902f, 0.08260828f, -0.51729578f, -0.16206087f, 0.17959039f, 0.11584038f, 0.29726031f, 0.20428219f, 
    -0.66031653f, 0.16496228f, -0.22700407f, 0.30818066f, 0.34958866f, 0.04899919f, 0.16520238f, -0.20306952f, 
    -0.15721183f, 0.17331779f, -0.04262444f, 0.60591304f, 0.27329397f, -0.56212592f, -0.15597114f, -0.40369764f, 
    0.32581279f, 0.06921042f, -0.11711418f, -0.10618314f, 0.30365574f, -0.21778010f, 0.13954173f, 0.06362668f, 
    -0.18077511f, 0.50409454f, -0.20722039f, 0.32043967f, -0.24141663f, -0.41620106f, -0.27959946f, 0.18031056f, 
    0.28354645f, -0.15180847f, -0.07093088f, 0.20716085f, -0.20584705f, 0.00016481f, 0.22820386f, 0.02326187f, 
    -0.42126703f, -0.02708157f, 0.00709344f, 0.15459992f, 0.15218718f, 0.31546813f, 0.27543989f, 0.28216818f, 
    -0.58360612f, -0.33850765f, 0.62604570f, 0.60591060f, -0.50262421f, -0.65802467f, -0.21030095f, 0.35065275f, 
    -0.39127433f, 0.33236715f, 0.01876272f, -0.44293210f, 0.12966111f, -0.09679478f, 0.04963992f, -0.15673558f, 
    -0.04890691f, -0.23776433f, 0.00577412f, 0.13447495f, 0.08588319f, 0.02538496f, 0.06498099f, 0.07075849f, 
    0.08430294f, -0.08815932f, 0.11790618f, 0.11237221f, 0.39214477f, 0.27289534f, -0.09735746f, -0.06067429f, 
    -0.13134815f, 0.08599165f, 0.14306138f, -0.21359307f, -0.17690572f, 0.26606885f, -0.13684431f, 0.23320946f, 
    -0.32855809f, -0.21415323f, 0.13176650f, 0.13760068f, 0.00690726f, 0.20728119f, -0.17208622f, 0.03496625f, 
    -0.06109930f, -0.28739008f, -0.09266494f, 0.22536555f, -0.26187655f, -0.16981511f, 0.22918658f, 0.16147134f, 
    0.32475933f, 0.45982251f, 0.49087954f, -0.08815224f, -0.08493312f, -0.10257695f, -0.39713067f, 0.12937410f, 
    -0.14168444f, -0.09743507f, -0.25037459f, 0.09666317f, 0.09143805f, -0.06047019f, -0.55150872f, 0.04324940f, 
    -0.26373288f, -0.07948512f, 0.36375475f, 0.18818815f, -0.22688593f, -0.06920024f, -0.33342680f, 0.30168557f, 
    0.21121602f, 0.16256805f, -0.20259325f, -0.00864325f, -0.20614447f, 0.16870293f, -0.08029576f, 0.09598127f, 
    -0.29804856f, 0.31910080f, -0.26136479f, 0.26455039f, 0.12331982f, 0.12125975f, -0.07969145f, -0.08149897f, 
    0.10008977f, 0.10099711f, -0.15972368f, -0.31721881f, -0.12551208f, 0.34102085f, 0.55870080f, -0.10489132f, 
    -0.11586316f, -0.25670913f, -0.19045466f, 0.27777225f, -0.30096126f, 0.25033906f, -0.10268801f, 0.07963957f, 
    -0.23510700f, -0.00664881f, 0.08340663f, -0.19173656f, -0.02739340f, 0.03787917f, 0.03793153f, -0.16218822f, 
    0.07908551f, 0.04635734f, 0.10060149f, 0.10591797f, -0.18145528f, 0.07940000f, 0.21796915f, 0.59077895f, 
    -0.19471455f, 0.36824661f, 0.28736913f, 0.65888101f, 0.11079408f, -0.23495513f, -0.51579142f, -0.57798195f, 
    -0.39844602f, -0.11735525f, 0.21750157f, 0.31128675f, -0.25319520f, -0.07228889f, 0.01014360f, 0.08481910f, 
    0.04955648f, -0.05421184f, 0.18520468f, 0.07338274f, -0.14303204f, -0.00798216f, -0.07280928f, 0.07174995f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.11980080f, 0.11908956f, 0.09058662f, 0.05709287f, -0.15459703f, -0.03515602f, 0.04117583f, 0.01495477f, 
    -0.14739931f, 0.23338822f, 0.26877445f, 0.13224779f, 0.35494846f, 0.19102107f, 0.02743394f, 0.34118575f, 
    0.34850088f, 0.24848014f, 0.29037830f, -0.12333177f, 0.32687905f, 0.19215086f, -0.19911474f, 0.03200978f, 
    0.09878618f, -0.25220817f, 0.27697280f, 0.17503858f, 0.10692991f, 0.11963315f, 0.23081316f, 0.07264213f, 
    0.06143716f, 0.31070337f, 0.16094190f, 0.02360775f, -0.09670886f, -0.04399697f, 0.23853192f, 0.07079181f, 
    -0.10399816f, 0.25177136f, 0.36554214f, 0.30333981f, 0.06014460f, -0.04323938f, -0.03117939f, -0.55825824f, 
    0.02652078f, -0.23836680f, 0.06993452f, 0.24183135f, 0.20018159f, 0.22608182f, 0.15669866f, 0.30316523f, 
    0.20588814f, 0.10853865f, 0.27173504f, 0.19764684f, 0.25261000f, 0.03079546f, 0.10837336f, 0.14890605f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.24405010f, 0.30877623f, -0.07010820f, -0.27553895f, -0.00091750f, 0.03443839f, -0.04760086f, 0.02857445f, 
    0.01828875f, -0.02080676f, -0.06682828f, -0.03716156f, 0.43221688f, 0.38613468f, 0.37070936f, -0.67256290f, 
    -0.01519300f, -0.09270548f, 0.07887261f, -0.13902918f, -0.03692489f, -0.11887255f, -0.16082744f, -0.08861700f, 
    0.09905566f, -0.06588855f, -0.48812565f, 0.03600965f, 0.07313023f, -0.08454461f, -0.10096118f, 0.05173614f, 
    -0.05873111f, 0.05890676f, -0.01713630f, -0.05551478f, 0.08183287f, -0.14712653f, -0.01081781f, -0.06101041f, 
    -0.09097590f, -0.04178261f, -0.11865941f, -0.03605967f, -0.00811628f, 0.14580621f, 0.03670172f, -0.07044930f, 
    0.20457347f, 0.10223939f, -0.25224182f, 0.11059590f, -0.26945093f, -0.02267328f, 0.00650962f, 0.05055008f, 
    -0.07693438f, -0.02092578f, 0.03272146f, 0.01210402f, 0.00348212f, -0.03204978f, -0.12600175f, 0.09862037f, 
    0.03017159f, -0.03761540f, -0.00335290f, 0.04162572f, -0.03537747f, 0.00023261f, -0.10256457f, 0.05135316f, 
    -0.04287012f, -0.07499592f, -0.01007154f, -0.02027005f, -0.12533799f, -0.04375940f, -0.00349600f, 0.05881540f, 
    0.00367019f, 0.04025175f, 0.01987213f, -0.02036525f, -0.15319647f, -0.09092001f, -0.04142066f, -0.10183715f, 
    0.00128908f, -0.00548885f, -0.05427946f, -0.00098828f, -0.06663997f, 0.03658551f, -0.00471284f, 0.14417042f, 
    0.13654491f, 0.07606312f, -0.02649543f, -0.07935777f, 0.03488154f, -0.02860310f, -0.07674346f, -0.01991820f, 
    -0.01494450f, 0.01328806f, 0.03712348f, -0.13206623f, 0.02190541f, -0.04577202f, 0.12552558f, -0.03101402f, 
    -0.00809609f, 0.05821197f, -0.00968062f, -0.00452674f, -0.06366631f, -0.01794587f, -0.14941421f, -0.02603264f, 
    0.15231159f, 0.10528233f, 0.06761248f, 0.02453024f, 0.10074161f, 0.15188691f, 0.02986587f, -0.03438216f, 
    -0.03248795f, 0.04011850f, 0.00755070f, 0.02639477f, 0.11102118f, 0.04688774f, -0.06053777f, -0.07294527f, 
    -0.02191330f, -0.02589728f, 0.05098940f, -0.24625602f, -0.08382252f, -0.03228477f, 0.05750333f, -0.05043598f, 
    -0.12603103f, -0.37748829f, -0.44698185f, 0.08219025f, -0.01029571f, -0.02660325f, -0.05071281f, -0.05956070f, 
    -0.04451158f, 0.03916916f, -0.10413415f, -0.08824660f, -0.04923132f, -0.11573278f, -0.24695703f, -0.08448949f, 
    0.01966444f, -0.03954912f, -0.09935724f, -0.01781152f, -0.02249581f, -0.16416542f, -0.17391545f, -0.02972730f, 
    0.20988548f, 0.08216605f, -0.03101372f, 0.04361402f, -0.12173829f, 0.02136881f, 0.09001891f, -0.23489466f, 
    -0.09439758f, -0.04484993f, 0.07470058f, -0.07124355f, -0.38967383f, 0.00329036f, 0.18543762f, -0.00435591f, 
    -0.03944168f, 0.00977323f, -0.06532889f, 0.09093523f, -0.00054593f, -0.15002787f, -0.04739617f, 0.00410117f, 
    -0.02381073f, -0.45028031f, 0.11852536f, 0.02253165f, -0.11264469f, -0.03715891f, -0.13192397f, -0.06283700f, 
    -0.06307475f, -0.16851705f, -0.11989626f, -0.21425161f, 0.08666950f, 0.00002331f, -0.08496221f, -0.06827933f, 
    -0.22956960f, -0.04639814f, -0.06654698f, -0.02227282f, -0.03765009f, -0.12283175f, 0.02562902f, -0.02153442f, 
    0.20686871f, 0.24194209f, 0.13273680f, -0.18394525f, -0.20158100f, -0.00946167f, 0.06710834f, -0.05546859f, 
    -0.04628971f, -0.07852294f, 0.02717823f, -0.22971980f, -0.05773502f, -0.10258155f, 0.12362894f, 0.01097586f, 
    0.01548619f, 0.00174355f, -0.16692811f, 0.00023355f, 0.09559178f, 0.00795166f, -0.01604118f, 0.14783479f, 
    0.40753207f, -0.23235559f, -0.16383272f, -0.03697730f, 0.00950744f, -0.00726555f, 0.06069493f, 0.00082707f, 
    0.05608156f, -0.01259915f, -0.01054011f, 0.14012960f, 0.02861672f, -0.43572882f, -0.20966530f, 0.05226880f, 
    -0.01227488f, -0.02145974f, -0.04158945f, 0.00408850f, 0.03574227f, -0.09019507f, 0.00296062f, 0.22863960f, 
    0.28352937f, 0.22303334f, 0.08027501f, -0.08640920f, 0.14650428f, 0.22258927f, 0.12401810f, 0.05042980f, 
    0.02064171f, 0.02712511f, -0.02169614f, -0.04654158f, 0.29200891f, 0.11276643f, -0.06221755f, -0.16801010f, 
    0.16840695f, 0.17039157f, 0.18137267f, 0.06712937f, -0.00763006f, -0.02690885f, -0.07605789f, 0.00551913f, 
    -0.43751621f, -0.41933307f, 0.15814604f, -0.02096285f, 0.03500833f, 0.00814016f, 0.01463475f, 0.04549640f, 
    -0.01808842f, -0.05389971f, -0.00611511f, 0.03423383f, 0.28766856f, 0.10879360f, 0.07016740f, -0.34883541f, 
    -0.06829276f, -0.06020358f, -0.02128424f, -0.10107601f, -0.03627271f, -0.00777600f, -0.00988740f, 0.01925878f, 
    0.29187649f, -0.00982835f, -0.14617498f, -0.04615602f, -0.16605699f, -0.06440654f, -0.01083510f, -0.25430074f, 
    -0.00001863f, -0.12097327f, -0.03461904f, -0.02778094f, 0.22923164f, -0.11989290f, -0.17475934f, -0.14138176f, 
    0.09247008f, -0.14740889f, 0.06719080f, -0.22537358f, -0.04534860f, -0.03043330f, -0.00565296f, 0.06703492f, 
    -0.30521286f, -0.06444672f, -0.20041285f, 0.31923571f, 0.00609781f, 0.04152124f, 0.02671705f, 0.03360767f, 
    0.01874166f, 0.04195735f, 0.00366786f, 0.03123605f, 0.10420396f, 0.10728391f, 0.06402492f, 0.02110371f, 
    0.04735423f, 0.07247204f, 0.02332116f, -0.01519695f, -0.00345553f, 0.01660667f, -0.02778452f, 0.01829552f, 
    0.15512697f, -0.26837894f, -0.12125032f, -0.00323865f, 0.15741788f, -0.05935942f, -0.19079101f, -0.01337515f, 
    -0.00862115f, -0.14819604f, -0.07078304f, 0.10868289f, -0.01077920f, 0.10806435f, -0.02555252f, -0.01609352f, 
    0.03740037f, 0.05572711f, 0.02436505f, -0.03404246f, 0.05594167f, 0.11182166f, 0.07402989f, 0.08250573f, 
    -0.24123943f, -0.24829134f, -0.26907834f, -0.03025908f, 0.05257695f, -0.04890091f, 0.00310922f, 0.04593517f, 
    -0.09508447f, -0.01779200f, -0.05326106f, -0.00986940f, -0.50757056f, -0.59057164f, -0.20175324f, 0.00651257f, 
    0.05550038f, 0.06828760f, -0.06891764f, -0.02935012f, 0.00689540f, -0.00740314f, -0.00681526f, 0.01844717f, 
    0.05808246f, 0.05063780f, -0.03475293f, -0.12218282f, 0.15576315f, 0.02684461f, -0.23836227f, -0.16879193f, 
    0.00064928f, -0.06658722f, -0.03708288f, 0.05916662f, -0.08419591f, 0.01237408f, 0.11583395f, 0.04349460f, 
    0.00112523f, 0.00301097f, 0.01717550f, 0.04586626f, 0.08771340f, 0.00055128f, 0.10038109f, 0.00822636f, 
    0.32457188f, 0.25799021f, -0.19565746f, -0.17364752f, -0.03974587f, 0.01829677f, -0.05445230f, 0.00096652f, 
    0.03949821f, 0.06052025f, -0.00664783f, 0.02714011f, 0.19989341f, 0.09687209f, -0.15615726f, -0.13467845f, 
    0.08423857f, 0.10987549f, 0.07846749f, 0.01221347f, -0.01539153f, -0.01919514f, -0.05597564f, 0.00670632f, 
    0.17623580f, -0.11574475f, -0.05580695f, -0.06408312f, 0.05895439f, 0.10830782f, -0.03645111f, -0.21688993f, 
    -0.20554081f, -0.18596834f, -0.00006443f, -0.03320379f, -0.26383770f, -0.01924109f, 0.20215549f, -0.19487007f, 
    0.05459927f, 0.00681891f, 0.07084727f, -0.07841442f, -0.04277975f, -0.05407869f, 0.06051280f, -0.07816804f, 
    -0.02342399f, -0.05138004f, -0.03665594f, 0.05380940f, 0.00520861f, -0.01772681f, 0.00221508f, 0.03147893f, 
    -0.01495827f, -0.03491667f, 0.07571901f, 0.06370176f, 0.25986296f, 0.17433295f, -0.34062576f, -0.16589545f, 
    -0.09109890f, -0.08719011f, 0.05816372f, 0.00822486f, -0.08942793f, -0.06633968f, 0.01642811f, -0.18842280f, 
    0.12017354f, -0.09378710f, -0.51735425f, 0.13797581f, 0.12595728f, -0.12215695f, -0.03713269f, -0.11904553f, 
    0.00230423f, -0.01977768f, -0.18527770f, -0.07984867f, 0.29788011f, -0.41363347f, -0.26392627f, 0.00923536f, 
    -0.12664504f, -0.04458787f, 0.05793488f, -0.10970827f, -0.02972709f, -0.07555476f, -0.08929069f, 0.02055993f, 
    -0.08648784f, 0.04100590f, -0.02548267f, -0.07118849f, 0.02982173f, 0.02258273f, 0.01099039f, 0.00186091f, 
    -0.00354500f, -0.02764053f, 0.01614574f, -0.03237861f, -0.36020187f, -0.04457704f, -0.25014710f, 0.08942699f, 
    0.00337574f, -0.01693049f, -0.08103698f, 0.03502166f, -0.19612427f, -0.07116038f, 0.00027938f, 0.11524415f, 
    -0.08440675f, -0.02034229f, -0.07328502f, 0.02958147f, 0.01397897f, 0.04399111f, 0.01365366f, -0.02364770f, 
    -0.23928905f, -0.23003483f, -0.16223955f, -0.08043800f, 0.33878154f, 0.21802171f, 0.03078239f, -0.22511593f, 
    0.14375763f, 0.23197994f, 0.18907681f, 0.13621314f, 0.01531463f, -0.03852400f, -0.02050155f, -0.05473402f, 
    0.23370557f, 0.31472725f, 0.01221517f, -0.38177666f, 0.02400272f, -0.02946013f, 0.04959753f, -0.06438082f, 
    0.01638904f, -0.01523636f, -0.00456768f, -0.03187853f, 0.25032401f, 0.19298175f, -0.20883121f, -0.09434181f, 
    -0.01922535f, 0.18601663f, -0.03366705f, -0.00212072f, -0.01446797f, 0.02709090f, 0.06220646f, 0.03469512f, 
    0.15219939f, 0.08743109f, 0.05012101f, -0.07337387f, -0.11648668f, 0.09727393f, 0.01578104f, 0.06612597f, 
    -0.14314781f, -0.08548898f, -0.04416639f, 0.02926976f, 0.08197629f, 0.06297791f, -0.04079609f, -0.08336217f, 
    -0.01310032f, -0.08843368f, -0.06174690f, -0.20350213f, -0.00410982f, 0.06508382f, -0.04879634f, 0.01255215f, 
    0.04667814f, 0.23990424f, 0.06796531f, -0.25381905f, -0.18007846f, 0.12216645f, -0.19102436f, -0.00120976f, 
    0.03939917f, 0.02506183f, 0.03246859f, -0.03349218f, 0.19769023f, 0.24637651f, -0.06042512f, -0.04837855f, 
    0.06379400f, 0.13126411f, 0.08165265f, -0.10574545f, 0.02118710f, 0.08032443f, 0.04999212f, 0.02304988f, 
    -0.34215781f, 0.04045182f, 0.03321132f, -0.08930493f, -0.01103908f, 0.03245666f, -0.08412617f, -0.08278842f, 
    0.02572257f, -0.09167455f, 0.00051504f, -0.04752973f, -0.18057823f, 0.03664483f, -0.06534038f, 0.05788032f, 
    -0.03409753f, 0.01781281f, -0.03692082f, 0.01545413f, 0.00297295f, -0.20803714f, -0.04996624f, -0.09898775f, 
    -0.10876947f, 0.37894237f, 0.19649957f, -0.00257856f, -0.18716119f, 0.00040881f, 0.14201926f, -0.04036127f, 
    -0.07590001f, -0.08487771f, 0.05736271f, -0.11174154f, -0.13832745f, -0.26490369f, 0.01663938f, 0.05726233f, 
    -0.17752615f, -0.23203519f, 0.16235015f, 0.20547755f, -0.01504807f, -0.22332111f, -0.08224191f, -0.02746937f, 
    0.01060688f, -0.18879092f, -0.46728021f, 0.03531820f, -0.16134535f, -0.10061882f, -0.00080660f, 0.01396715f, 
    0.03146127f, 0.00441572f, -0.08428913f, -0.11554634f, -0.08576797f, -0.05807465f, -0.09304106f, -0.00262525f, 
    0.03810234f, -0.04309482f, -0.08596542f, -0.03044054f, -0.02467233f, 0.04197069f, 0.03612709f, -0.00765466f, 
    0.16869481f, -0.34927610f, -0.04343392f, 0.12639180f, 0.05281439f, -0.02574776f, 0.06562555f, 0.05670507f, 
    -0.02083064f, -0.03379489f, 0.05837939f, -0.01617624f, -0.03672620f, 0.02657618f, 0.03226697f, -0.10702670f, 
    -0.07700961f, -0.01366810f, -0.01377953f, -0.01040371f, -0.04750606f, 0.02312324f, -0.04512974f, -0.02873917f, 
    -0.05296900f, -0.04048720f, -0.11747623f, 0.00349502f, -0.13220125f, 0.00129749f, -0.09788523f, -0.02208199f, 
    -0.00038504f, -0.04555160f, -0.08050482f, 0.01530790f, -0.05639504f, -0.09392287f, -0.34104294f, 0.04237863f, 
    0.00437231f, -0.16473486f, -0.20137623f, -0.15165029f, 0.02919299f, 0.02411853f, 0.06549099f, 0.03344926f, 
    -0.23748547f, -0.01564024f, -0.19520682f, 0.05108749f, -0.15393403f, 0.07449166f, -0.17119119f, -0.04257097f, 
    0.07889707f, -0.08125086f, 0.01195878f, 0.02141782f, -0.67911470f, 0.26699188f, -0.36320788f, -0.04651635f, 
    -0.04685095f, -0.22489476f, 0.18776020f, 0.03413114f, 0.00831477f, -0.01394157f, 0.02021110f, -0.01870981f, 
    0.38537902f, -0.30533332f, -0.32843801f, 0.05384862f, -0.24796815f, -0.21309200f, 0.03463217f, -0.00606145f, 
    -0.03395527f, 0.01520641f, -0.01792032f, 0.08275337f, 0.02360865f, -0.07652648f, 0.03667913f, -0.27461576f, 
    0.04729945f, -0.02787847f, 0.06527623f, 0.03627600f, 0.15680465f, -0.14597936f, 0.00938478f, 0.12493570f, 
    -0.06224963f, -0.39039585f, -0.15048732f, -0.27332136f, -0.03764949f, -0.03506194f, 0.02188980f, -0.11248731f, 
    0.03808874f, -0.03114539f, 0.02648630f, 0.02128443f, -0.01366866f, 0.03961917f, 0.14143783f, 0.11846868f, 
    -0.09166187f, -0.03979360f, 0.02074409f, 0.05599766f, -0.04759172f, -0.05476481f, -0.09524633f, -0.06539527f, 
    0.00525464f, 0.10415047f, 0.03110422f, 0.04081036f, 0.06750403f, 0.02671140f, -0.00772032f, -0.09017520f, 
    -0.01391660f, -0.03015780f, -0.02270368f, 0.08247683f, 0.16888976f, 0.07631656f, 0.11641584f, -0.02652156f, 
    -0.05600337f, -0.02228392f, -0.04661511f, -0.03469362f, 0.02756790f, -0.00658310f, 0.03282703f, 0.12339974f, 
    0.46542013f, 0.29105398f, -0.17014188f, -0.26210803f, 0.06145411f, 0.00045743f, 0.00418220f, -0.11901525f, 
    -0.05131099f, -0.07242316f, -0.17964868f, -0.27236369f, -0.08854341f, 0.15541449f, -0.08458016f, -0.07792819f, 
    0.01849578f, 0.01825748f, 0.04804004f, 0.07089376f, -0.11398152f, 0.06941022f, -0.11396609f, -0.00985939f, 
    -0.27162021f, -0.14326233f, -0.14425640f, -0.09293549f, -0.03717162f, 0.10219992f, 0.06603365f, -0.34665444f, 
    0.03704716f, -0.00866852f, 0.01343819f, -0.03941362f, -0.09429772f, -0.10174999f, -0.02657176f, 0.05384536f, 
    0.19015288f, -0.23432861f, -0.01334899f, 0.01916972f, -0.05248944f, -0.02715963f, 0.03084999f, -0.05068028f, 
    0.85255551f, -0.16171168f, -0.29976720f, -0.16279832f, -0.07059541f, 0.04939556f, 0.01202444f, -0.25361171f, 
    0.12221250f, -0.06086964f, -0.14649391f, -0.03054995f, -0.01796302f, 0.02283671f, -0.01716514f, -0.05098247f, 
    -0.10555878f, -0.04105127f, 0.02934065f, 0.05315289f, -0.02083123f, 0.13056369f, 0.19724505f, 0.00836344f, 
    -0.18156981f, -0.22892454f, -0.44723186f, 0.08126937f, 0.08683810f, 0.02099651f, 0.04170998f, 0.04260775f, 
    -0.01852517f, -0.10484668f, -0.04967740f, -0.26737234f, -0.23606396f, 0.04626073f, 0.05317115f, -0.00653621f, 
    0.12698567f, 0.01576191f, -0.09360281f, 0.03471944f, -0.00794800f, 0.11468835f, -0.01396357f, 0.13637550f, 
    0.02057250f, -0.24322508f, 0.16027954f, -0.18898319f, 0.04524396f, 0.11123045f, -0.08507612f, 0.07182316f, 
    0.11055668f, 0.12109376f, -0.01590034f, 0.04259307f, -0.08677620f, 0.00819876f, -0.06293818f, 0.04279342f, 
    0.22226633f, -0.02300966f, 0.11235999f, 0.00672262f, -0.00156227f, 0.06886850f, 0.00738083f, -0.01687465f, 
    -0.48725393f, 0.06538026f, -0.05995235f, 0.03006958f, 0.02668984f, -0.17931452f, 0.06637033f, 0.19317542f, 
    0.01179674f, -0.05983619f, 0.07711185f, -0.02136931f, -0.01535525f, -0.02191512f, 0.06061139f, -0.09428637f, 
    -0.00497729f, 0.08652268f, -0.09001329f, -0.00719056f, -0.60408723f, -0.07220038f, -0.00346719f, -0.16355114f, 
    0.37845829f, -0.14139734f, 0.10604975f, 0.25412869f, -0.03091517f, -0.00416837f, -0.02665046f, -0.05568713f, 
    0.09289062f, -0.12814693f, -0.15121563f, -0.08498820f, 0.43861428f, -0.00650266f, 0.17271851f, 0.04054426f, 
    -0.04175169f, -0.02288117f, -0.11183628f, -0.05815959f, -0.05595966f, -0.11629853f, -0.04202370f, -0.08956606f, 
    0.26810765f, 0.29890585f, 0.11915208f, 0.12138856f, 0.04442875f, -0.08486466f, -0.13149294f, -0.10318127f, 
    0.01572262f, -0.02094589f, -0.04326145f, -0.15371694f, 0.12474474f, 0.07577708f, 0.20516491f, 0.08582067f, 
    0.08994916f, 0.01798614f, 0.04173509f, -0.26726994f, 0.03990612f, 0.05130214f, -0.02080311f, -0.08749788f, 
    0.31444040f, -0.06359070f, 0.11426200f, 0.03312077f, 0.00956931f, -0.02565771f, 0.04567335f, -0.02524160f, 
    0.04535185f, -0.12740473f, -0.32129413f, -0.06444333f, -0.34118479f, 0.03005376f, 0.12558086f, -0.18758562f, 
    0.15757854f, 0.08009385f, 0.09979150f, 0.04326003f, -0.01175784f, 0.07577520f, 0.08389279f, -0.09038803f, 
    0.35415030f, -0.26784596f, -0.12102964f, -0.16533653f, 0.11927147f, 0.05069632f, 0.09315496f, 0.13747780f, 
    0.00097458f, -0.07506563f, 0.02310649f, 0.07501464f, -0.04681972f, -0.52098554f, 0.11635648f, -0.05371445f, 
    0.00484690f, -0.17439213f, -0.10009076f, 0.09573168f, 0.06763611f, -0.02883581f, 0.12034543f, -0.07211465f, 
    0.37117094f, 0.18456809f, 0.27923721f, 0.21879224f, -0.03973776f, -0.06465247f, 0.03084012f, -0.02359767f, 
    0.04747932f, -0.02181773f, 0.05476798f, 0.01586400f, 0.02096951f, -0.02881768f, -0.11412940f, -0.10360308f, 
    -0.02710992f, -0.00029634f, -0.00405010f, -0.03256634f, -0.04695808f, -0.01268278f, 0.10829794f, -0.04273225f, 
    0.06540687f, 0.18212223f, -0.21528830f, -0.14831071f, -0.09391303f, 0.17108981f, -0.07659120f, -0.19178760f, 
    -0.02925056f, 0.00169496f, -0.06007704f, -0.17293821f, 0.04141151f, -0.03763567f, -0.21228787f, 0.07528377f, 
    -0.02909478f, -0.00697990f, 0.03181583f, -0.00623076f, -0.27411738f, -0.09990926f, 0.03949590f, -0.25735784f, 
    0.14494494f, 0.15208402f, 0.14141311f, 0.15088470f, 0.00128888f, 0.00966212f, -0.00838907f, -0.04655822f, 
    0.02820299f, 0.00280297f, 0.01904127f, 0.02984240f, 0.32437301f, 0.05653930f, 0.24462017f, -0.00002280f, 
    -0.04861860f, -0.05849334f, 0.00964651f, -0.04821923f, 0.01583095f, 0.00206759f, 0.06097864f, 0.08580995f, 
    0.07860697f, -0.19935912f, -0.00514492f, -0.13029577f, -0.04125855f, 0.11877360f, -0.02869796f, 0.08019157f, 
    -0.02031374f, -0.03644778f, -0.06300543f, -0.00920048f, -0.07585861f, 0.05669028f, 0.03387566f, 0.02715311f, 
    0.01641046f, 0.00875078f, -0.03165241f, -0.07196648f, -0.03596358f, -0.13385279f, -0.10702733f, -0.15398788f, 
    -0.09691963f, -0.05241571f, -0.09857433f, 0.17636786f, -0.17803688f, -0.05100564f, -0.28053501f, 0.16170205f, 
    -0.09752589f, 0.04225235f, -0.00641873f, 0.00271900f, 0.16593944f, 0.25033551f, 0.16008459f, 0.04659516f, 
    0.00015295f, 0.20912227f, 0.05632993f, 0.07645644f, -0.03189279f, 0.03087186f, -0.04876224f, -0.00792853f, 
    -0.35530695f, -0.39742514f, -0.16614011f, -0.27037463f, -0.00688380f, 0.11893973f, 0.11755984f, 0.20124972f, 
    0.02296452f, 0.06300896f, 0.14867492f, -0.01709654f, 0.28156754f, 0.13805571f, -0.03222851f, -0.18951602f, 
    -0.07328799f, 0.05426995f, -0.10302355f, -0.04729167f, 0.11913568f, -0.00165864f, 0.08679794f, -0.13889286f, 
    0.04786495f, 0.05991354f, 0.07638786f, 0.03955520f, -0.02103796f, 0.06266229f, -0.04293298f, 0.01543642f, 
    0.05395640f, 0.05348938f, 0.02960185f, 0.08551893f, 0.07594736f, 0.03722466f, -0.01444863f, 0.09795937f, 
    0.02366940f, 0.05029693f, 0.02197385f, -0.02172291f, 0.21637681f, -0.01808950f, -0.03613397f, -0.03983784f, 
    0.25369826f, -0.22722565f, -0.12491497f, -0.13814236f, -0.14502843f, 0.11211780f, 0.17636929f, 0.02827622f, 
    -0.05945206f, 0.01721155f, -0.11459836f, 0.12377173f, 0.43547878f, -0.16192241f, 0.05594408f, 0.25807944f, 
    -0.03518324f, -0.01092812f, 0.05782182f, -0.08534853f, 0.07621048f, 0.12375324f, 0.09507724f, 0.12849011f, 
    0.13184851f, 0.00235078f, 0.08985774f, -0.05035261f, 0.03768933f, -0.03691183f, 0.00551857f, -0.00726842f, 
    0.00642801f, -0.02896992f, -0.11161799f, -0.01299133f, 0.13063385f, -0.13952035f, 0.14972095f, -0.07362137f, 
    0.02953823f, 0.00006639f, -0.05785802f, 0.05818171f, 0.02213106f, -0.19102573f, -0.32399195f, -0.25519270f, 
    0.18168758f, 0.10380371f, 0.05982556f, 0.09345945f, -0.04498830f, 0.04968885f, -0.07192642f, -0.00831646f, 
    -0.05665146f, 0.26078081f, 0.02156407f, 0.05690920f, 0.35574093f, 0.18097034f, 0.14446819f, 0.26598015f, 
    -0.12053606f, 0.09191022f, -0.35452965f, 0.01553738f, -0.05893171f, -0.03812411f, -0.05178853f, 0.06189899f, 
    -0.14240517f, 0.04730395f, 0.03224314f, 0.20178196f, -0.03387744f, 0.00080247f, -0.01388059f, 0.06916106f, 
    -0.03868012f, 0.03652527f, -0.04816910f, 0.00818491f, 0.07898530f, 0.24366105f, 0.11504384f, 0.09148075f, 
    -0.13566603f, 0.05301270f, -0.22851051f, -0.05825756f, -0.03057842f, -0.02371952f, -0.06257898f, -0.01721380f, 
    -0.29540738f, -0.19578187f, -0.02738844f, -0.03206504f, 0.24092393f, -0.00204610f, 0.06612808f, 0.06133771f, 
    -0.04646040f, 0.06540909f, -0.08545399f, -0.00961882f, -0.00999097f, 0.01203075f, -0.12835634f, -0.10909308f, 
    -0.15359335f, 0.12166896f, 0.03768560f, 0.25948802f, -0.17373201f, 0.04001278f, 0.07071951f, 0.02820030f, 
    -0.13312614f, 0.02100654f, -0.05484787f, -0.11850404f, 0.16639604f, -0.00224700f, 0.07610626f, 0.23869324f, 
    -0.07648455f, -0.03245092f, 0.00440693f, 0.02339143f, -0.00170383f, 0.02419200f, -0.00978222f, -0.02642438f, 
    -0.01985009f, 0.12590587f, -0.22283493f, -0.13699673f, 0.01617976f, -0.08101109f, -0.08952733f, 0.01206102f, 
    0.16879666f, -0.07456090f, -0.00516218f, -0.17471175f, -0.02581097f, -0.05572775f, -0.09016959f, 0.23653959f, 
    -0.08626828f, -0.09240738f, 0.05974292f, -0.06367941f, -0.13624379f, 0.26043224f, 0.18336610f, -0.07486053f, 
    -0.06871315f, 0.01583151f, 0.01863348f, -0.01932546f, 0.03569793f, 0.03575336f, 0.02130541f, -0.03977716f, 
    -0.26311955f, -0.14543904f, -0.01458898f, 0.21755320f, -0.00297337f, 0.11141220f, 0.02877279f, -0.00809938f, 
    0.14044972f, 0.01277628f, -0.15062238f, 0.15384987f, 0.19924083f, 0.04340018f, 0.03298115f, -0.17051280f, 
    -0.05551834f, 0.02378784f, -0.19273572f, 0.14296557f, -0.06842953f, 0.03609464f, 0.07289381f, -0.06085749f, 
    0.10107423f, -0.06476983f, 0.00513984f, -0.07657719f, 0.01349381f, 0.02261614f, 0.25415576f, 0.05813894f, 
    -0.14443210f, 0.03563488f, 0.00209054f, 0.00664312f, 0.05032230f, 0.03630462f, 0.10892559f, -0.05524047f, 
    -0.08107780f, 0.00588282f, 0.07039493f, -0.10705024f, 0.06416129f, -0.11389598f, 0.01653844f, 0.09561662f, 
    0.35055032f, -0.18001355f, 0.44671327f, 0.09713116f, -0.07374910f, -0.04002009f, 0.04888990f, 0.01567475f, 
    -0.00025197f, 0.11441612f, -0.09261002f, -0.01445447f, -0.05066483f, 0.03727261f, -0.03488654f, -0.02894471f, 
    -0.05024199f, 0.02719567f, -0.00660047f, -0.00054805f, 0.11377566f, 0.03294791f, -0.08307234f, -0.05790733f, 
    0.20155844f, 0.00452643f, -0.05989655f, 0.04062448f, -0.05726745f, 0.01983439f, -0.00625778f, -0.03707657f, 
    -0.05672961f, -0.00876603f, -0.01719293f, -0.04623628f, 0.09498241f, 0.16101958f, -0.13751997f, 0.00069239f, 
    -0.10429532f, -0.18502598f, -0.07944713f, -0.15863046f, -0.04515443f, -0.03676756f, -0.02629209f, 0.05760080f, 
    -0.16315573f, -0.65692902f, -0.26191199f, 0.09436969f, -0.03474163f, 0.08657983f, -0.22295777f, -0.10890946f, 
    -0.04092384f, 0.00982833f, -0.07893711f, -0.02396397f, 0.05339897f, -0.06127416f, -0.24121934f, 0.30309826f, 
    -0.12769136f, -0.09312389f, -0.13848908f, 0.10331547f, 0.00137666f, -0.11545327f, 0.02669110f, 0.00447954f, 
    -0.07240777f, -0.35838026f, 0.10643957f, -0.32678360f, -0.08914381f, -0.22845966f, -0.12767887f, -0.14370619f, 
    0.00220229f, -0.07034059f, 0.05263105f, 0.03229067f, -0.05055151f, -0.00108357f, 0.08436696f, -0.26816693f, 
    -0.02969666f, -0.06414000f, -0.36791280f, -0.12977700f, 0.04327985f, -0.04115843f, -0.14033519f, 0.05773906f, 
    -0.09539965f, -0.07030682f, -0.30712858f, -0.37284818f, -0.11730346f, -0.00494425f, 0.07811933f, -0.02305260f, 
    -0.01659631f, 0.00799365f, -0.00617775f, -0.11227152f, -0.21516287f, -0.08445207f, 0.11221093f, -0.00865175f, 
    0.03236067f, 0.01049460f, 0.01826746f, 0.00987915f, 0.03671127f, -0.09716523f, 0.19337389f, -0.12903216f, 
    -0.19597515f, 0.03910468f, -0.09098304f, 0.02358554f, -0.03896842f, 0.01243384f, 0.03027816f, 0.00468117f, 
    -0.02538765f, -0.03902157f, -0.03390334f, 0.00368357f, -0.14051539f, 0.07116098f, -0.05241292f, -0.26543799f, 
    0.02722820f, -0.07068745f, -0.05603223f, 0.06919193f, -0.05243217f, -0.04503212f, -0.02146356f, -0.00180537f, 
    0.08857336f, 0.31150362f, 0.44067794f, 0.27446538f, 0.01398704f, -0.01160404f, 0.04274587f, -0.05990843f, 
    -0.02291960f, -0.09431677f, -0.04493035f, 0.16947174f, 0.08430945f, -0.00441067f, 0.08087242f, 0.00652433f, 
    0.06917602f, 0.02583458f, -0.00674915f, 0.07711136f, -0.16061647f, 0.15674184f, 0.05368345f, 0.03890721f, 
    0.13027625f, 0.45177299f, 0.14554726f, 0.29408738f, -0.12606242f, 0.00437420f, 0.03873204f, 0.04771044f, 
    0.02854772f, -0.01842688f, 0.09941430f, 0.00398901f, -0.00401633f, 0.00594208f, 0.07379053f, 0.10907333f, 
    -0.00159980f, -0.07322978f, 0.01764902f, 0.19611898f, 0.06677195f, 0.05210797f, -0.00683064f, -0.08423906f, 
    -0.36581820f, 0.56675243f, 0.24301769f, -0.14393604f, -0.01666375f, 0.02232222f, -0.18367113f, 0.00911299f, 
    -0.02336082f, 0.00995423f, -0.16874947f, 0.13521525f, -0.22049157f, 0.12331013f, -0.03071114f, -0.02084505f, 
    -0.02300069f, -0.10693409f, -0.03969936f, 0.02538705f, 0.00618068f, -0.12562492f, 0.04154282f, 0.03323623f, 
    0.02450123f, 0.19091499f, -0.23551130f, 0.01588975f, -0.00946273f, -0.12623031f, -0.07901882f, 0.10472924f, 
    -0.07120076f, -0.01510520f, 0.00979820f, -0.03600244f, 0.22460806f, 0.16098990f, -0.03855938f, 0.18476149f, 
    0.05435251f, -0.00005457f, 0.02890652f, -0.02905992f, -0.03364835f, 0.07869292f, -0.21885872f, 0.05673384f, 
    -0.03623981f, 0.11579964f, -0.01555106f, 0.00627522f, 0.02655136f, 0.06992157f, -0.06441400f, 0.09020029f, 
    0.03831856f, 0.00575736f, -0.02352657f, 0.09283686f, -0.12120911f, 0.01505929f, 0.00028447f, 0.00707354f, 
    -0.01630070f, 0.09380365f, -0.01729806f, -0.03928972f, 0.03939904f, 0.10874286f, -0.00796593f, 0.05124647f, 
    -0.04589228f, 0.17848730f, -0.14281267f, 0.07899498f, -0.05808586f, -0.08733147f, 0.01340698f, 0.19339119f, 
    0.01134025f, 0.10001116f, -0.01587427f, -0.08798562f, -0.05099043f, 0.04169217f, 0.01818698f, -0.01521613f, 
    -0.00350530f, -0.09428681f, 0.02910916f, -0.02642841f, 0.08065396f, 0.12425478f, -0.05200743f, 0.09926040f, 
    -0.09438445f, -0.08440979f, 0.26326662f, 0.03908016f, 0.02358939f, 0.02825718f, 0.06697353f, 0.05239380f, 
    0.05907619f, 0.07033976f, -0.01951388f, -0.06753449f, -0.10307763f, 0.06744742f, 0.09924313f, -0.03290341f, 
    0.01532361f, 0.00376981f, 0.06030824f, -0.05625108f, 0.15854272f, 0.15060905f, 0.01587844f, 0.12306134f, 
    -0.42201990f, 0.08972122f, 0.40488556f, 0.41222689f, -0.00185415f, -0.10240977f, 0.08678945f, 0.06536315f, 
    0.03863356f, -0.04781862f, -0.01068330f, -0.06688275f, -0.05808348f, 0.11308279f, 0.55370456f, 0.10620850f, 
    -0.06967620f, 0.00625557f, 0.08114510f, 0.14835098f, 0.03584106f, -0.01462469f, 0.04740488f, 0.00233109f, 
    -0.08774926f, 0.07218281f, -0.12927353f, -0.04124828f, 0.04352599f, 0.02009221f, -0.03508620f, -0.08549307f, 
    0.02334340f, 0.07825884f, 0.01301448f, -0.01868535f, -0.66258562f, -0.58678687f, -0.01551150f, -0.17850296f, 
    -0.08561466f, 0.02480534f, 0.02248455f, -0.26102462f, -0.03559276f, 0.07168614f, 0.01877671f, 0.05529582f, 
    -0.01257734f, -0.11282052f, 0.23035616f, 0.10085189f, 0.14807856f, -0.10574232f, -0.23212552f, 0.14989643f, 
    0.05658807f, 0.05359715f, 0.09450543f, -0.00793505f, -0.14330547f, 0.33275095f, -0.06459416f, -0.06084908f, 
    0.08927400f, -0.10525706f, 0.01006864f, -0.01795733f, -0.06501417f, -0.00975148f, 0.11064899f, -0.15196046f, 
    0.09053698f, 0.07835251f, 0.03299670f, 0.07458965f, 0.00784206f, -0.00855777f, 0.09482294f, 0.03569293f, 
    -0.05044881f, -0.03677171f, -0.00714332f, 0.02925610f, 0.19510750f, 0.06649564f, 0.13858302f, 0.15012051f, 
    -0.00363966f, -0.03628704f, 0.07130333f, -0.05027089f, -0.13601750f, -0.01178633f, 0.04519693f, 0.14031102f, 
    -0.32531461f, 0.55642450f, 0.40393674f, 0.16741382f, -0.04733053f, 0.08683754f, 0.08981492f, -0.02726660f, 
    0.07262100f, 0.06969362f, -0.04221671f, -0.09932873f, 0.00552424f, -0.01331302f, 0.13490537f, 0.13408659f, 
    -0.04070204f, 0.01063957f, -0.01401819f, 0.00575990f, 0.10029325f, 0.06579200f, 0.19958477f, 0.07149426f, 
    -0.38497797f, -0.21678659f, 0.04196451f, -0.22008555f, 0.01280433f, -0.01671123f, 0.01435245f, 0.00226142f, 
    -0.02258423f, -0.12563123f, 0.09232336f, 0.00906097f, -0.24102418f, -0.11270443f, 0.12294837f, -0.20674597f, 
    0.03917617f, -0.04461392f, -0.01688546f, 0.04176746f, 0.03122368f, -0.00633637f, 0.00490978f, 0.02023362f, 
    -0.18546927f, 0.19769207f, 0.09048831f, -0.28285238f, 0.08557411f, 0.09992094f, -0.05726232f, -0.09975012f, 
    -0.06764866f, 0.00072582f, 0.06261242f, -0.03307823f, -0.03958758f, 0.01819937f, -0.07950889f, -0.01213321f, 
    0.05515744f, -0.03782414f, 0.07275426f, 0.03541464f, 0.25272363f, 0.04358004f, 0.06169791f, 0.03432031f, 
    -0.37254575f, -0.44735205f, -0.36011469f, -0.22119832f, 0.04436480f, -0.11158233f, -0.04033913f, -0.03412377f, 
    0.06121124f, 0.01602713f, -0.05038904f, 0.02178283f, -0.40294486f, 0.01655989f, 0.12156761f, 0.25906274f, 
    -0.08479086f, 0.08793572f, -0.16844243f, -0.02946918f, -0.03627646f, -0.05361592f, -0.03883777f, -0.02985655f, 
    0.33043754f, 0.17690954f, 0.05773357f, 0.06385855f, -0.02984808f, 0.05050220f, 0.09797308f, -0.06284775f, 
    -0.11646012f, -0.16273899f, -0.30498850f, 0.08781601f, -0.18873192f, 0.16311684f, -0.06498513f, -0.45604441f, 
    -0.05167590f, 0.03216320f, -0.02651128f, 0.08411919f, -0.04426587f, 0.00747598f, -0.02289288f, -0.01904786f, 
    -0.11042822f, -0.08221997f, -0.00077792f, -0.05975693f, -0.02159500f, -0.03985605f, -0.06144771f, 0.01434571f, 
    -0.09478883f, -0.13577622f, 0.05516247f, 0.01131421f, 0.16959223f, -0.09423894f, 0.08122821f, 0.15790834f, 
    0.13766260f, 0.09705789f, -0.09633081f, 0.03409752f, 0.04486760f, 0.16574852f, 0.05142557f, -0.06751961f, 
    -0.13051833f, -0.17843238f, 0.03072239f, -0.17537442f, -0.13929720f, -0.04187820f, -0.01615511f, -0.12688753f, 
    0.00458627f, 0.01494263f, 0.03115268f, -0.02800919f, 0.16932930f, 0.04298996f, 0.07734523f, 0.05856878f, 
    -0.04430315f, -0.03143911f, -0.00717553f, 0.09222621f, 0.00674126f, 0.01506753f, -0.03780141f, -0.05277700f, 
    0.03408090f, -0.09403411f, 0.06885368f, -0.11764576f, 0.06082127f, -0.00275102f, 0.01014445f, 0.07493939f, 
    0.02031311f, -0.05893064f, 0.02690656f, 0.00917416f, -0.07680970f, -0.04265843f, 0.03811422f, -0.02877060f, 
    -0.03975902f, -0.02005758f, -0.01090958f, -0.09745302f, 0.05223829f, 0.08911257f, 0.09095985f, 0.12473714f, 
    -0.15598820f, 0.00604045f, 0.00075877f, -0.06142490f, -0.01956873f, -0.01795503f, -0.07868012f, 0.05838807f, 
    -0.06021805f, -0.27027312f, -0.00244902f, 0.20288529f, -0.31992239f, -0.06993141f, -0.16124777f, -0.11338375f, 
    -0.00952107f, -0.15269421f, -0.14598301f, 0.09590738f, -0.01800328f, -0.05035356f, -0.02648435f, 0.02949544f, 
    -0.26865479f, -0.42853540f, -0.42604893f, -0.18999082f, 0.10144503f, 0.10082798f, -0.01302702f, 0.00089850f, 
    -0.02831259f, -0.03590878f, -0.02815421f, -0.06253687f, -0.25841710f, -0.19539711f, 0.07980693f, -0.26160365f, 
    0.01588828f, -0.10342237f, 0.01176048f, -0.02799692f, 0.01363552f, -0.02169668f, -0.01836680f, 0.01134378f, 
    -0.00875381f, -0.08055012f, -0.08621795f, 0.05293494f, 0.15264305f, 0.00264140f, 0.00485286f, -0.10907771f, 
    -0.11449102f, 0.03899202f, 0.07036959f, 0.01341758f, -0.21531720f, 0.09211913f, -0.06144178f, 0.00172017f, 
    -0.02722180f, -0.00921615f, 0.02838226f, -0.05947822f, 0.05445537f, -0.07413904f, 0.01568709f, -0.00364788f, 
    -0.13994406f, -0.03232861f, 0.06433878f, -0.23260555f, 0.04684493f, -0.10623563f, -0.17411967f, 0.15604162f, 
    0.00806017f, -0.00052434f, 0.00759974f, 0.03292460f, 0.04295180f, -0.26426330f, 0.01119917f, 0.05678956f, 
    0.02802161f, 0.03751950f, -0.07363103f, 0.20044431f, 0.05072537f, 0.04954635f, 0.02951759f, 0.08670753f, 
    -0.15343893f, -0.05711249f, 0.10711232f, -0.32497936f, -0.06223917f, 0.00141255f, -0.20421889f, 0.12315413f, 
    -0.03788606f, -0.01866165f, 0.05310849f, 0.03435313f, -0.26078829f, -0.07779715f, 0.01676533f, -0.02490657f, 
    0.10397044f, 0.06850415f, 0.02102707f, 0.03358465f, 0.01127340f, -0.08634921f, 0.06226198f, -0.01264367f, 
    0.03273025f, -0.20369345f, -0.26076928f, -0.07654419f, 0.10268898f, -0.06957325f, 0.04755055f, 0.07550275f, 
    0.03118255f, -0.09664997f, -0.00185789f, 0.05483136f, 0.07066382f, 0.21059050f, -0.14223008f, -0.08389586f, 
    0.10298165f, -0.04848853f, -0.02073711f, -0.07785600f, 0.15312679f, 0.06564100f, -0.04379638f, -0.01992718f, 
    -0.18199247f, 0.20663311f, 0.16710041f, -0.19391249f, -0.05739103f, 0.10292718f, -0.09037600f, -0.03926064f, 
    -0.01022555f, -0.02689203f, -0.06751775f, -0.04361337f, -0.00259236f, -0.04641166f, -0.01986828f, -0.09747384f, 
    0.08051343f, -0.01898591f, -0.03628332f, 0.06048110f, 0.00795945f, -0.14387345f, 0.07816701f, 0.01988630f, 
    -0.01330112f, 0.06015278f, -0.31051293f, -0.15308359f, 0.05758001f, -0.03811765f, 0.04100337f, -0.04209785f, 
    -0.02224886f, -0.00209978f, -0.07471244f, -0.08647463f, -0.06015474f, 0.04479928f, -0.04923277f, -0.01718885f, 
    -0.00946931f, 0.03043621f, -0.25134617f, 0.10737605f, -0.02599267f, 0.06591452f, -0.01270713f, 0.00771575f, 
    -0.10076033f, 0.08335473f, 0.02006857f, 0.01793726f, -0.12473738f, -0.03002904f, -0.02683962f, 0.05809362f, 
    -0.01733734f, -0.00448034f, -0.00293481f, -0.04147455f, -0.25607058f, 0.20862044f, -0.27587944f, -0.19518039f, 
    -0.09615415f, 0.00903154f, -0.06566576f, 0.10263436f, 0.03663325f, -0.01088629f, -0.03452119f, -0.02573240f, 
    0.00294628f, -0.02292936f, -0.20927927f, 0.11395448f, 0.02850544f, -0.02071009f, 0.07540088f, 0.04396532f, 
    -0.05798758f, 0.02616000f, -0.08482669f, -0.03754211f, -0.10645271f, 0.19242883f, -0.22639064f, -0.16312680f, 
    0.07822067f, 0.07346231f, -0.04495522f, 0.13808760f, 0.00034889f, -0.01107206f, 0.05800629f, -0.09015113f, 
    0.05703288f, -0.32928014f, 0.38962251f, 0.19545700f, -0.11436680f, 0.04139493f, -0.03147783f, 0.03108038f, 
    0.13478559f, -0.08582702f, -0.08139051f, -0.00899226f, -0.15141720f, 0.04443957f, 0.34404868f, 0.10135527f, 
    0.08571202f, 0.08179188f, 0.04858905f, 0.03376806f, 0.02696021f, 0.02378224f, 0.06825313f, -0.05316474f, 
    0.15696214f, 0.01934706f, 0.13791470f, 0.15217721f, 0.03091299f, 0.08468669f, 0.14313056f, -0.10119759f, 
    0.05158528f, -0.10213067f, 0.01123743f, 0.01947121f, 0.10428829f, 0.19699910f, 0.10695865f, -0.19160181f, 
    0.18229423f, 0.24948949f, 0.02887722f, 0.10232315f, -0.13028984f, -0.03269656f, -0.00932905f, 0.08197566f, 
    -0.52222347f, -0.29808286f, 0.02470525f, -0.06315560f, -0.31325972f, -0.08185662f, -0.21233124f, -0.03658356f, 
    -0.13805072f, -0.05235940f, -0.07212500f, 0.06097149f, -0.51209605f, 0.07608223f, -0.04586236f, 0.36103657f, 
    -0.09780028f, -0.16875520f, -0.05534106f, -0.04772799f, 0.20267658f, 0.07776906f, -0.08695311f, 0.04973143f, 
    -0.02234211f, -0.18571411f, 0.09384546f, 0.08488213f, 0.00394118f, 0.10372230f, -0.08074605f, -0.07527003f, 
    0.10476275f, 0.02047976f, 0.02966495f, 0.01976246f, 0.03698184f, -0.23300630f, 0.03145773f, -0.17923959f, 
    0.22401157f, -0.02064724f, -0.02287482f, -0.03601166f, 0.03164855f, 0.04727744f, 0.07541721f, -0.12618217f, 
    0.23357180f, -0.23880492f, -0.07261947f, 0.13524793f, 0.14387801f, 0.11564295f, 0.02148786f, -0.01168809f, 
    -0.03152780f, -0.00147746f, -0.04523029f, -0.03335556f, 0.35993403f, 0.20459883f, -0.29163873f, -0.39618537f, 
    0.07636856f, 0.02139487f, -0.07415886f, 0.05220586f, -0.08417536f, -0.06294174f, 0.14203851f, 0.04084115f, 
    -0.37261248f, -0.00819563f, 0.03758011f, 0.23818611f, 0.13117382f, 0.06116228f, -0.08781679f, -0.10814122f, 
    -0.11895908f, -0.08108188f, 0.17570174f, 0.05507849f, -0.49330169f, 0.00135270f, -0.05233134f, -0.00988033f, 
    0.01058311f, -0.06255758f, -0.04012699f, -0.08216204f, -0.12677458f, 0.11187553f, 0.04865612f, 0.03912712f, 
    -0.25656578f, 0.38924491f, -0.39173931f, 0.19814534f, -0.05344077f, -0.07272325f, -0.04030291f, -0.05469117f, 
    -0.04294322f, 0.07162601f, -0.10156167f, -0.03963936f, 0.84607881f, 0.07468840f, -0.27970022f, -0.28186348f, 
    -0.12276455f, -0.05067226f, 0.07430346f, -0.08568580f, -0.10890894f, -0.02703302f, -0.04436607f, -0.05408598f, 
    0.02065784f, -0.03563908f, 0.04323335f, -0.05171824f, -0.18055169f, 0.01476259f, -0.17848571f, -0.06546496f, 
    -0.02464197f, -0.13188452f, -0.19503956f, -0.06777918f, 0.10329421f, -0.06091183f, 0.12271021f, -0.13932149f, 
    -0.04516805f, -0.00776231f, -0.12033083f, -0.06159041f, -0.14352632f, 0.11307462f, -0.22920190f, -0.15739737f, 
    -0.17636353f, 0.17869774f, -0.33764282f, -0.45081913f, -0.09142921f, 0.01838840f, -0.11429040f, 0.09196722f, 
    -0.09765022f, -0.04590330f, -0.23693627f, -0.22673912f, 0.14429979f, -0.03592438f, 0.10817923f, 0.15134084f, 
    -0.09305138f, 0.02642649f, -0.08503844f, 0.01428429f, 0.09495141f, 0.21708658f, -0.00736115f, -0.01614662f, 
    -0.36381078f, 0.76658469f, -0.18744028f, -0.59162730f, 0.32820469f, 0.10067850f, 0.04813046f, -0.10880798f, 
    -0.34432894f, 0.00844274f, -0.00506158f, -0.06837124f, -0.44424424f, 0.18761200f, -0.09488957f, 0.05653045f, 
    0.05109946f, 0.10204745f, -0.05113364f, 0.03641884f, -0.07485764f, 0.12932825f, -0.11290674f, -0.08262678f, 
    0.22382003f, 0.02259152f, -0.07580427f, 0.03303226f, 0.05401227f, -0.02807877f, 0.00041397f, -0.04048799f, 
    -0.02030835f, 0.06077886f, 0.09796754f, 0.16177079f, -0.14354509f, -0.02610143f, -0.06252833f, 0.16719814f, 
    0.06380342f, -0.05541582f, -0.13441290f, -0.00519898f, -0.01133739f, 0.06198761f, 0.19994044f, 0.09886116f, 
    -0.03340539f, 0.10185390f, 0.16150136f, 0.00405456f, -0.05678159f, 0.02432253f, -0.00199998f, -0.00413693f, 
    0.00844383f, 0.12475188f, 0.12239267f, -0.07118117f, 0.02644148f, -0.08425573f, 0.03033053f, 0.13086617f, 
    0.03695437f, -0.01956629f, -0.03902258f, 0.19209056f, -0.03376275f, 0.07884280f, 0.10970763f, -0.07129852f, 
    -0.13900875f, 0.38829160f, -0.28294224f, -0.04892429f, 0.01973961f, -0.05407656f, -0.10890583f, -0.07811186f, 
    -0.09707399f, 0.02169587f, -0.07935572f, -0.02927793f, -0.31505007f, 0.15169781f, -0.13454749f, 0.44868070f, 
    -0.07341722f, 0.03429673f, 0.04484095f, 0.01636996f, -0.03046018f, -0.11645720f, -0.02384675f, 0.04129545f, 
    -0.17156272f, 0.02955876f, 0.17532134f, -0.07137097f, -0.14999332f, -0.11603773f, 0.01512387f, -0.00204500f, 
    0.09040028f, 0.13840519f, -0.13399729f, 0.09107441f, -0.08040947f, -0.12837313f, 0.04260059f, -0.06803019f, 
    0.12542586f, 0.08280570f, -0.04094420f, -0.04895379f, -0.02619626f, -0.04303597f, -0.06617651f, 0.00515880f, 
    -0.14242816f, -0.00223247f, 0.02404850f, 0.24549635f, 0.06637236f, 0.04380813f, 0.10972215f, -0.07439645f, 
    -0.02009259f, 0.04769887f, -0.04958867f, 0.15835032f, -0.24736336f, 0.04076105f, -0.09795727f, -0.01132159f, 
    0.08254675f, 0.04378299f, -0.04393693f, -0.06449046f, -0.08926222f, -0.03206939f, -0.12027416f, -0.03749180f, 
    -0.21560366f, -0.05392351f, 0.28758419f, -0.02736974f, -0.05281023f, -0.02631981f, -0.19877620f, -0.03178057f, 
    -0.02243218f, 0.08200292f, 0.15013845f, -0.08422191f, -0.20402816f, -0.11612184f, 0.28303182f, 0.01450957f, 
    -0.20369577f, -0.13011828f, 0.00344252f, 0.01186558f, 0.04122769f, 0.20918311f, -0.05114257f, -0.00688435f, 
    -0.07589632f, 0.04553223f, 0.06601770f, 0.12259565f, -0.02231438f, -0.05311554f, 0.05588251f, -0.15441611f, 
    0.06499687f, 0.17790399f, 0.00952202f, -0.08570883f, 0.20019585f, 0.06438366f, -0.15986654f, -0.15256910f, 
    -0.13837969f, 0.04216414f, 0.01452739f, -0.00913003f, -0.17331564f, 0.12483855f, 0.05222678f, -0.06497669f, 
    0.10783601f, -0.14922988f, -0.20468752f, 0.08106009f, 0.06805686f, 0.15710299f, 0.11302375f, 0.17435110f, 
    0.05040435f, -0.15368535f, 0.13790289f, -0.00655459f, -0.03151269f, -0.05763155f, -0.01121902f, 0.15092407f, 
    0.06149035f, -0.06518919f, -0.11646539f, 0.03516662f, 0.00701737f, 0.04045510f, -0.08815201f, 0.02596740f, 
    0.14122640f, 0.07032471f, 0.04959804f, 0.30669510f, 0.10441218f, -0.03961254f, 0.06502297f, 0.08988535f, 
    -0.07804954f, 0.21362157f, -0.04823624f, 0.15788592f, -0.53375798f, 0.29185787f, -0.22518463f, 0.07913985f, 
    -0.10231760f, -0.02998504f, 0.05003110f, 0.03349724f, 0.12862891f, -0.22851373f, 0.03850690f, 0.07863954f, 
    -0.16328925f, -0.16582270f, -0.18747903f, -0.26126108f, -0.04927015f, -0.13772285f, 0.10907192f, -0.00150762f, 
    -0.03997725f, 0.09580525f, -0.03528292f, 0.04383456f, -0.19972943f, 0.31732231f, -0.02694863f, -0.28631818f, 
    0.03281559f, -0.09945612f, -0.03567677f, -0.08858643f, -0.25436068f, -0.09781557f, -0.09381355f, -0.02368471f, 
    -0.17842604f, 0.16540080f, 0.10357617f, 0.40505755f, 0.14399326f, -0.03770711f, -0.00049046f, -0.09703530f, 
    -0.05464275f, 0.06244907f, 0.29349107f, -0.16707793f, -0.32390928f, 0.85848504f, -0.63013583f, -0.03826007f, 
    0.10729202f, -0.03142935f, -0.09854371f, -0.08205514f, -0.13615225f, -0.03033707f, 0.04120936f, -0.03583324f, 
    0.14807351f, 0.04969648f, -0.29468974f, -0.03469421f, -0.02072426f, -0.04484816f, -0.13385636f, -0.08156069f, 
    -0.08540721f, -0.06291815f, 0.04416040f, -0.04770064f, -0.20520633f, -0.05164372f, -0.00384782f, 0.07944141f, 
    -0.18542239f, -0.03429206f, -0.14853984f, -0.06334971f, 0.06528073f, 0.04864449f, -0.04186741f, 0.04996148f, 
    -0.29390323f, -0.24625012f, -0.48834744f, -0.07247686f, 0.09703943f, 0.05503515f, -0.16240302f, -0.11615898f, 
    -0.13263530f, 0.05715739f, 0.08723846f, -0.15139392f, -0.00024824f, -0.11751587f, -0.03715179f, 0.17143802f, 
    0.02225773f, -0.00361630f, 0.00644684f, 0.01501607f, -0.03520509f, 0.06823545f, -0.10415040f, 0.02316146f, 
    0.03248230f, -0.07939969f, -0.16035545f, 0.06355754f, 0.03538092f, 0.00821002f, -0.05770995f, 0.13524817f, 
    -0.05604067f, -0.05733590f, -0.07310563f, -0.11385114f, 0.08320212f, -0.16475709f, 0.02519769f, 0.27161390f, 
    -0.00048449f, -0.06391858f, 0.00250279f, -0.02677922f, 0.03744858f, 0.02249320f, 0.01041612f, 0.03059438f, 
    0.15496713f, -0.02143344f, -0.07759033f, -0.02056567f, 0.02550521f, -0.04426691f, 0.12748970f, 0.01628206f, 
    -0.06196341f, 0.03941993f, 0.02508678f, 0.05214404f, -0.15413217f, -0.05550433f, -0.07501672f, 0.35174677f, 
    0.07463052f, -0.17887594f, -0.00471817f, 0.13933405f, -0.01359413f, -0.14654249f, 0.07953995f, -0.04960986f, 
    0.12019247f, -0.12848040f, 0.00365324f, 0.00334091f, -0.06632951f, -0.04703974f, 0.06456717f, -0.02652695f, 
    0.07467683f, 0.02263411f, -0.12814650f, -0.02478829f, 0.06125654f, -0.11526747f, -0.10621024f, 0.03372066f, 
    -0.03096913f, -0.09658751f, -0.04235782f, -0.11011652f, -0.07858731f, 0.00334097f, -0.02526107f, 0.08710403f, 
    0.18391924f, -0.03923538f, 0.32415664f, -0.24868210f, -0.27364928f, 0.20448057f, -0.15026399f, 0.02174077f, 
    0.07029459f, -0.06480654f, 0.11820707f, -0.03957132f, 0.10347634f, -0.08551794f, 0.12921877f, -0.04002289f, 
    0.02207200f, -0.10127704f, 0.01863586f, -0.28263903f, -0.06200525f, 0.07923671f, 0.09150401f, -0.02049527f, 
    -0.02833812f, -0.04197799f, -0.24027649f, -0.48643523f, 0.09805523f, 0.25823134f, 0.01256849f, -0.27015746f, 
    -0.19884604f, 0.09005994f, -0.15702941f, 0.06137181f, -0.51271135f, -0.08079403f, 0.12844504f, 0.19111986f, 
    -0.05556776f, 0.10613847f, -0.26477164f, -0.27175647f, -0.09157133f, -0.00157217f, 0.03799089f, -0.07173701f, 
    -0.04763026f, -0.03940501f, 0.10945207f, 0.26830375f, -0.05215656f, -0.00459277f, -0.25806648f, -0.01150490f, 
    0.05683420f, -0.11172231f, -0.00815460f, -0.02425135f, 0.00000439f, 0.09157679f, 0.05025541f, -0.01776339f, 
    -0.10962423f, 0.02827863f, -0.09748237f, -0.02090681f, 0.01347441f, 0.17543416f, 0.06858739f, -0.00374674f, 
    -0.07290541f, 0.46170127f, -0.42456689f, -0.41880217f, 0.03656438f, 0.24280901f, -0.06256108f, 0.13793083f, 
    -0.18376383f, 0.09813920f, -0.13054444f, -0.04895029f, 0.17431086f, 0.21225256f, -0.02373675f, -0.11374861f, 
    -0.03387786f, -0.08292262f, -0.02548513f, 0.06735767f, 0.16070850f, 0.06199416f, 0.02932981f, -0.27567661f, 
    -0.36992121f, 0.21842602f, -0.23402075f, 0.05917473f, 0.02764305f, 0.10362028f, -0.07644679f, -0.06458653f, 
    -0.08408575f, 0.10988000f, -0.02897782f, 0.03589527f, -0.19699323f, 0.39165941f, 0.13733421f, 0.35295659f, 
    0.04288415f, -0.00572522f, 0.02508143f, -0.11273503f, -0.04447262f, 0.04292042f, -0.06890276f, 0.11875885f, 
    0.12858438f, 0.14324425f, 0.21394138f, 0.11119424f, -0.06901782f, 0.05406494f, -0.05941074f, 0.01421378f, 
    -0.07425354f, 0.06857519f, 0.02837539f, 0.00098912f, -0.03062847f, -0.14129366f, 0.03002206f, 0.13620093f, 
    -0.19862768f, -0.00128923f, -0.16188554f, -0.23989081f, -0.21131386f, -0.00625974f, -0.09298933f, 0.00956541f, 
    0.01177581f, 0.34473953f, -0.19127710f, 0.17084764f, 0.15661407f, 0.14510378f, 0.17025110f, -0.00583791f, 
    0.04127299f, 0.05750740f, 0.00411413f, -0.14260451f, 0.08360630f, 0.09985443f, -0.05374599f, 0.16800311f, 
    -0.00319504f, 0.07018621f, -0.27429149f, -0.05941988f, 0.12138709f, 0.04056781f, 0.01143965f, -0.09395940f, 
    -0.04924678f, -0.13939224f, 0.00081647f, 0.07279636f, 0.11790887f, 0.05695101f, -0.05057465f, 0.10813908f, 
    -0.04166584f, 0.02657320f, -0.05022109f, -0.13923144f, 0.41541073f, -0.12839970f, 0.15110901f, 0.17729691f, 
    -0.04785706f, 0.02160933f, 0.04362000f, 0.04130064f, 0.10812987f, -0.23640764f, -0.08372795f, -0.19297495f, 
    0.07719186f, 0.05021209f, 0.09947212f, 0.04256545f, 0.04586364f, -0.01255953f, 0.08221139f, 0.08548839f, 
    0.05940054f, -0.02023923f, 0.06419457f, -0.06401722f, 0.18423122f, -0.04596383f, -0.03942326f, 0.04367182f, 
    0.07626470f, 0.01535020f, 0.01898163f, -0.01200135f, -0.02120935f, 0.04907852f, 0.02750098f, 0.03164438f, 
    0.05477792f, 0.14273307f, 0.03489069f, 0.12318977f, -0.06780794f, -0.06811561f, 0.01516086f, 0.05618646f, 
    -0.02095037f, -0.06504799f, -0.07528527f, 0.15433612f, 0.15657942f, 0.16473696f, -0.14881724f, -0.02312749f, 
    -0.04929752f, -0.07365194f, 0.02081615f, -0.10269055f, -0.01741937f, -0.13007557f, -0.15964377f, 0.08706342f, 
    0.04100778f, 0.10755944f, 0.12930290f, 0.04245435f, -0.12276566f, -0.09219780f, -0.05584560f, 0.02924479f, 
    0.01380176f, -0.01176059f, -0.01911606f, 0.05985609f, 0.00338244f, -0.17075500f, 0.18168914f, 0.09598412f, 
    -0.22062770f, 0.02044306f, -0.26794767f, -0.03595717f, 0.01951819f, 0.03436127f, -0.15330388f, -0.03574288f, 
    -0.17738758f, -0.10636657f, 0.01888549f, 0.04886664f, 0.04256037f, -0.07846019f, -0.20605357f, 0.06747296f, 
    -0.04277070f, 0.02125084f, 0.03736001f, 0.00853206f, 0.17814678f, -0.21580869f, 0.26391670f, -0.24446867f, 
    -0.05280490f, 0.00636187f, -0.02682170f, 0.05075204f, 0.06494104f, -0.08118360f, -0.12266064f, -0.24099845f, 
    0.25457183f, -0.16066270f, 0.28178638f, -0.18933083f, -0.02821343f, -0.02140472f, -0.14967521f, 0.03308084f, 
    0.08696494f, 0.07696303f, 0.08685826f, 0.25056836f, -0.19049291f, -0.08559206f, -0.08809911f, -0.09431090f, 
    -0.13030978f, 0.02929023f, -0.05802049f, 0.04004197f, 0.04956739f, -0.03040052f, -0.10433140f, 0.02041214f, 
    -0.23255476f, -0.00855542f, -0.08603448f, -0.01259601f, 0.02508860f, 0.01639158f, -0.10404464f, -0.12597407f, 
    0.01605109f, -0.07832375f, 0.12034374f, -0.02415196f, 0.05222942f, 0.01827302f, -0.08971666f, 0.09763431f, 
    -0.09608554f, -0.15931845f, -0.07990869f, -0.03148043f, -0.10659822f, -0.08186093f, -0.03384769f, -0.15350711f, 
    0.13122278f, -0.29156759f, 0.16282672f, -0.17563489f, -0.09691284f, 0.00144376f, -0.19966038f, -0.08666759f, 
    -0.13078809f, 0.04357294f, -0.12552609f, 0.04966440f, -0.07773219f, 0.06418116f, -0.09043831f, -0.01519111f, 
    -0.00607372f, -0.08886714f, 0.03815581f, -0.00066589f, 0.10699727f, -0.13673538f, -0.01970662f, 0.38368896f, 
    -0.11015172f, -0.61399418f, -0.32653421f, -0.06424418f, -0.02478970f, 0.03522333f, 0.05463326f, 0.06108527f, 
    0.07463361f, 0.02400411f, -0.07245579f, -0.00170593f, -0.16620627f, 0.05586307f, -0.06504932f, -0.15976360f, 
    0.00097299f, -0.11265921f, 0.05337193f, -0.05743483f, 0.08906172f, -0.04006018f, -0.04074694f, 0.19922061f, 
    -0.28529784f, -0.17015049f, -0.05754514f, 0.03725557f, -0.10755277f, 0.01443683f, 0.02749213f, 0.02718201f, 
    -0.01083667f, 0.01453802f, 0.00841365f, 0.01142045f, 0.03158199f, -0.05279883f, 0.04522761f, 0.05649739f, 
    -0.11134872f, -0.10188833f, -0.07404150f, -0.06557554f, -0.03528388f, 0.02487082f, -0.15079454f, 0.00055505f, 
    -0.02256634f, 0.11101253f, -0.13205670f, -0.10939683f, 0.00150729f, 0.02424422f, -0.05516455f, 0.00859305f, 
    -0.07371860f, 0.02905118f, 0.01118219f, 0.20123355f, 0.19292861f, 0.26188275f, 0.20985107f, 0.20745464f, 
    -0.10068443f, 0.01706073f, 0.10577385f, 0.06808399f, 0.12983917f, 0.04558367f, -0.00468096f, 0.08354351f, 
    0.07375920f, -0.08035553f, -0.15746625f, 0.08665439f, 0.04361719f, -0.07266205f, 0.08978799f, -0.36255127f, 
    -0.22224934f, 0.06979935f, 0.13342747f, -0.14018574f, 0.15767424f, 0.07186431f, 0.07793319f, 0.00406769f, 
    0.00861917f, 0.03003974f, -0.08477349f, 0.21621266f, 0.00213952f, -0.00410465f, -0.21453790f, -0.01274137f, 
    0.05583587f, -0.23595011f, -0.24302496f, 0.03711259f, 0.11251895f, 0.00312624f, 0.03485344f, 0.01930149f, 
    0.00256098f, -0.00653789f, 0.02082324f, -0.02115244f, 0.20215331f, 0.06101326f, -0.04193391f, 0.06229469f, 
    -0.05422256f, -0.04604100f, 0.07774924f, 0.03134107f, 0.01667556f, -0.08746740f, -0.03872473f, 0.07115876f, 
    -0.38456115f, 0.04907127f, 0.02942471f, -0.07062742f, -0.15442719f, -0.08063956f, -0.05147708f, 0.02179291f, 
    -0.11235633f, -0.12784804f, -0.07341656f, 0.04335495f, 0.02771821f, -0.00862499f, 0.01546497f, 0.03860980f, 
    -0.09613422f, -0.00525860f, -0.06358211f, 0.01535336f, 0.23077250f, -0.03102947f, 0.03151552f, 0.08558058f, 
    -0.06579249f, -0.05528115f, -0.16455157f, 0.18706785f, 0.05202491f, 0.02636414f, 0.00365173f, 0.00788222f, 
    0.00225015f, 0.02889815f, -0.08587666f, -0.05184644f, 0.18362479f, 0.14581794f, -0.44927332f, 0.03719130f, 
    0.04650034f, -0.02553933f, -0.00334552f, 0.10357071f, 0.10257532f, -0.02638951f, 0.06264272f, -0.01756841f, 
    -0.15102884f, 0.02490396f, -0.06555849f, 0.05365544f, -0.04375237f, -0.00365574f, -0.02774684f, -0.01409633f, 
    -0.04063460f, -0.12575807f, -0.05180575f, -0.06653197f, -0.04087738f, 0.00900875f, 0.01113756f, -0.03260221f, 
    -0.01227321f, 0.05118039f, -0.05750468f, -0.00387644f, 0.00082259f, 0.11586282f, -0.05791336f, 0.17914680f, 
    0.03436802f, 0.13524911f, 0.32057980f, 0.24399638f, -0.14131193f, 0.04353006f, 0.02471469f, 0.14262235f, 
    0.09372889f, 0.02250445f, -0.01316673f, 0.01091774f, -0.02646338f, -0.00784161f, 0.01753059f, 0.09228812f, 
    -0.04051375f, -0.02845596f, -0.06559056f, -0.12431984f, -0.05953063f, -0.01282130f, 0.06426275f, -0.06113771f, 
    0.21374610f, 0.11770838f, 0.06765710f, 0.20625223f, -0.06136344f, -0.07031462f, -0.11148536f, -0.09014373f, 
    -0.15089981f, -0.20835242f, -0.01186236f, 0.00920391f, 0.10133920f, -0.19008633f, 0.08223220f, 0.22206211f, 
    0.15203239f, -0.04794643f, 0.05655447f, -0.07459282f, -0.04041217f, 0.09906750f, -0.06905996f, 0.07920925f, 
    0.04982444f, -0.00150303f, 0.02392004f, 0.01753845f, 0.04085441f, 0.05394894f, 0.09928864f, -0.00913245f, 
    0.09842979f, 0.05618398f, -0.01128580f, 0.07171253f, 0.06646465f, -0.36721593f, 0.02994108f, -0.08619308f, 
    -0.07381242f, 0.07698809f, 0.07703134f, -0.14389440f, -0.17854612f, 0.06773698f, -0.00355865f, -0.00266008f, 
    -0.02889424f, 0.01894076f, -0.03713565f, -0.05341340f, -0.02913201f, 0.04788204f, -0.18726091f, -0.06367496f, 
    -0.00190716f, -0.08896402f, -0.04628275f, -0.09038026f, -0.16344592f, -0.52265942f, 0.01138054f, -0.22244373f, 
    -0.05446847f, 0.05413730f, -0.15527201f, 0.05888398f, -0.08199034f, -0.07828284f, -0.11770906f, 0.00964107f, 
    0.05607928f, 0.00584486f, -0.16186000f, 0.00625521f, 0.05460724f, -0.05335084f, 0.06984056f, 0.04207207f, 
    0.05372678f, -0.06567512f, 0.01125811f, -0.09411699f, -0.00678413f, -0.01017055f, -0.13990749f, 0.02527960f, 
    0.03041398f, -0.07035381f, 0.00116451f, -0.06291931f, 0.06070292f, 0.14994243f, 0.18618347f, 0.30679539f, 
    0.08843958f, 0.01212884f, 0.04305219f, -0.02181594f, 0.05860566f, 0.01797679f, 0.09328876f, 0.05991996f, 
    0.13029642f, -0.02587938f, -0.18392168f, -0.01009614f, -0.05912514f, 0.13618073f, 0.07739192f, 0.17317028f, 
    0.00922168f, -0.06206344f, 0.03934326f, -0.10157512f, 0.01592469f, -0.00967514f, 0.04587924f, 0.05937657f, 
    0.07336308f, 0.13607101f, 0.25533128f, 0.17770879f, -0.07535196f, 0.01319312f, 0.10970395f, -0.05729803f, 
    0.05970691f, -0.02186602f, -0.00571628f, -0.01540588f, 0.03520614f, -0.06352708f, 0.09259215f, 0.14883748f, 
    0.01696501f, -0.16988437f, 0.01753723f, -0.00296565f, 0.06113664f, 0.00083279f, 0.01985469f, -0.03148957f, 
    0.05357189f, 0.02894328f, 0.07527120f, 0.06370781f, -0.03043288f, 0.03666967f, -0.15162414f, -0.01686915f, 
    -0.02268579f, -0.04005026f, 0.07778772f, 0.12076026f, 0.10354272f, -0.02056513f, 0.23486310f, -0.02585907f, 
    -0.13994220f, 0.04916787f, 0.04864370f, 0.15777153f, 0.03906159f, -0.00050718f, -0.02782338f, -0.09446864f, 
    -0.02304147f, -0.02646758f, 0.03219203f, 0.41168895f, 0.20997530f, -0.03765449f, 0.02406482f, -0.11280156f, 
    -0.01217850f, -0.01232261f, -0.00014588f, -0.01556952f, -0.09644455f, -0.01625342f, 0.06615622f, 0.11835726f, 
    -0.11529230f, -0.08407232f, -0.16209710f, -0.11169279f, 0.00682740f, -0.03683012f, 0.01703782f, 0.00655287f, 
    0.22869743f, -0.04988135f, -0.16035363f, 0.28610560f, -0.00621849f, -0.11594515f, -0.10515487f, -0.26442564f, 
    0.08469396f, -0.01938123f, -0.05824729f, 0.03187966f, -0.07522854f, -0.02927647f, -0.15172124f, 0.01617347f, 
    -0.02404406f, 0.08648385f, 0.03059505f, 0.12319319f, -0.09514020f, -0.09896009f, -0.24313149f, -0.11095810f, 
    0.05753688f, 0.03289097f, -0.25290117f, -0.06704947f, 0.12103098f, -0.29025781f, -0.14893207f, -0.07212966f, 
    -0.08491474f, -0.03321373f, -0.06231431f, -0.17388064f, -0.20534989f, -0.03025654f, -0.02836038f, 0.02843135f, 
    0.06980885f, 0.06035637f, 0.00883577f, -0.25540403f, 0.02234478f, 0.05338417f, -0.11479294f, 0.00065933f, 
    -0.12250166f, 0.08078384f, -0.00497446f, 0.02351937f, 0.13272229f, 0.01220103f, -0.08459385f, -0.12668951f, 
    -0.01730878f, -0.07227046f, -0.04969824f, -0.09546348f, 0.11304723f, 0.05193726f, -0.05979013f, 0.04504067f, 
    0.01097819f, 0.02150483f, 0.01131871f, 0.03162278f, 0.10599727f, -0.05694314f, -0.05873565f, -0.00245951f, 
    -0.14680091f, -0.53855884f, 0.17402512f, -0.23894355f, 0.10222182f, 0.03331398f, 0.04142584f, -0.03040125f, 
    -0.04585364f, -0.05055747f, -0.07789814f, -0.09024166f, -0.01425278f, -0.00954424f, 0.05379456f, 0.06331308f, 
    -0.04537473f, -0.11695527f, -0.05684486f, -0.01092580f, -0.09961706f, -0.06138874f, -0.05501958f, 0.09063426f, 
    0.06128331f, -0.03505473f, 0.04579252f, -0.02123627f, 0.03859224f, -0.02814416f, 0.03707552f, 0.06145855f, 
    0.02381506f, -0.04498573f, -0.03156019f, -0.07142216f, 0.30559975f, -0.07148712f, 0.31590217f, 0.15061532f, 
    0.04028169f, -0.05199775f, 0.14866209f, 0.12941995f, 0.02141571f, -0.01935433f, 0.04329316f, -0.01966270f, 
    0.15774365f, -0.00699664f, 0.30881038f, -0.10886087f, 0.20724054f, -0.03011991f, 0.00281886f, 0.10425043f, 
    0.06931659f, -0.03737793f, 0.00517905f, 0.01831361f, 0.14752102f, -0.51781559f, 0.53286403f, 0.04737011f, 
    -0.01033668f, 0.12496683f, 0.03146816f, 0.14699636f, 0.18938820f, -0.01777233f, -0.01947181f, 0.07500384f, 
    -0.24304651f, 0.26484293f, -0.21699829f, -0.10381526f, 0.21847463f, 0.08534078f, -0.10271991f, 0.02537848f, 
    0.04219313f, -0.00140796f, 0.02580935f, 0.08619812f, 0.10824170f, 0.02024740f, -0.27662596f, 0.37764221f, 
    0.00092828f, 0.02556480f, 0.02321393f, -0.06434638f, -0.19249076f, 0.02625643f, 0.03113082f, -0.03810177f, 
    -0.02589409f, 0.39796421f, -0.04190807f, -0.03441123f, 0.09993435f, -0.02239990f, -0.11629812f, 0.07466467f, 
    0.06549976f, 0.01610136f, 0.00508293f, -0.01966511f, -0.08835349f, -0.36102363f, -0.36898118f, -0.29149908f, 
    -0.01882707f, -0.02978639f, -0.04286939f, -0.01579687f, 0.05326573f, 0.10098063f, 0.04614174f, 0.07935845f, 
    0.05413414f, -0.16630363f, -0.05067105f, -0.00695222f, 0.16688569f, -0.01191463f, -0.14039758f, -0.08284437f, 
    0.00737157f, 0.00886254f, -0.07415353f, 0.03332420f, -0.02985961f, -0.14036496f, -0.12492924f, 0.01391634f, 
    0.08498338f, 0.07709627f, 0.00721471f, 0.04204783f, -0.01754543f, -0.06527501f, -0.02568308f, -0.24057993f, 
    -0.29370034f, -0.22720094f, -0.04914065f, -0.08363440f, -0.07694373f, 0.03781588f, -0.00027902f, 0.14464372f, 
    0.05521961f, 0.05623898f, -0.12440642f, 0.03163239f, -0.15652892f, -0.23458244f, -0.10663954f, 0.04193866f, 
    -0.07207536f, 0.03629704f, -0.04865878f, 0.05615667f, 0.16638426f, 0.08164240f, 0.30168185f, -0.07550755f, 
    -0.25367454f, -0.20108199f, -0.18792106f, -0.15733850f, 0.01598918f, -0.02600468f, -0.02283390f, 0.12233553f, 
    -0.05601055f, -0.11625506f, -0.02123648f, 0.00360609f, -0.00611870f, -0.03613090f, -0.11760350f, -0.07432596f, 
    -0.19532745f, 0.18367010f, 0.21881701f, -0.15857394f, 0.01958391f, 0.13081440f, -0.04056151f, 0.14451529f, 
    -0.16025703f, -0.05654343f, -0.14381558f, -0.26835555f, -0.03902728f, 0.05282651f, -0.04109238f, 0.15853976f, 
    0.06743979f, -0.13177870f, 0.03801638f, 0.05027528f, 0.30801162f, -0.06354446f, -0.22571412f, -0.01917908f, 
    0.15209037f, 0.04168041f, 0.09475841f, -0.16500121f, -0.00116896f, -0.09416040f, -0.06953533f, -0.05495989f, 
    0.14616174f, -0.02698285f, 0.43096262f, -0.08645365f, -0.05227612f, 0.01236204f, 0.05970391f, 0.00047873f, 
    -0.06463662f, -0.08241201f, -0.17730774f, 0.03161577f, -0.56535757f, -0.04885638f, 0.00520830f, 0.13147715f, 
    -0.04866546f, -0.01121561f, 0.10863425f, 0.08993444f, 0.01529889f, -0.04406768f, 0.09940612f, -0.05219213f, 
    -0.11699229f, 0.09220118f, -0.20709902f, 0.22235478f, 0.03265986f, -0.12087292f, -0.05988675f, 0.09190104f, 
    -0.06124475f, 0.06344876f, -0.05542138f, -0.01943144f, -0.02549816f, -0.05195297f, -0.09439638f, 0.03422841f, 
    0.01756800f, 0.09914750f, -0.15384842f, 0.00067666f, 0.15007502f, -0.02535843f, -0.01024130f, 0.12975846f, 
    0.23346080f, -0.17269881f, 0.06945691f, 0.24271123f, 0.02272432f, 0.12674321f, 0.08285834f, -0.13517056f, 
    0.13583097f, 0.05908331f, -0.01958694f, 0.12245691f, -0.07607269f, -0.05292236f, -0.07449424f, 0.00893272f, 
    0.00729677f, -0.00285371f, 0.05535880f, 0.10137081f, -0.04002259f, -0.17664808f, 0.09563111f, -0.73866791f, 
    -0.21900293f, -0.07513964f, 0.19310401f, -0.10854216f, -0.04376010f, -0.08337115f, -0.06448970f, -0.01691643f, 
    -0.00537499f, -0.08472870f, -0.13018063f, -0.00893883f, 0.02753056f, -0.14811307f, -0.30610147f, -0.14148229f, 
    0.03341484f, 0.09069348f, -0.00765362f, 0.05995272f, -0.07735334f, -0.05206490f, -0.13149217f, -0.41721392f, 
    -0.22160937f, 0.03310759f, 0.13264468f, -0.13737263f, 0.01593617f, -0.16409425f, -0.07927169f, 0.00581231f, 
    0.00177461f, 0.00163825f, -0.00497040f, 0.05897013f, -0.15120947f, 0.14005598f, -0.00200617f, -0.05359240f, 
    0.07430609f, 0.06473113f, 0.01597691f, 0.01394109f, 0.07565938f, -0.05291775f, -0.03076216f, 0.08955365f, 
    0.06036671f, -0.12916833f, -0.21302994f, 0.02146903f, -0.05118026f, 0.05120560f, 0.03837130f, 0.02410636f, 
    0.06687603f, -0.11357891f, -0.06010189f, -0.21299909f, 0.11024795f, -0.08433818f, 0.02122468f, 0.12387148f, 
    0.01308528f, 0.04367144f, -0.15295801f, -0.00065810f, -0.01071646f, -0.16209790f, -0.09634230f, -0.00114167f, 
    -0.26420894f, 0.18130307f, -0.01210389f, -0.20629711f, -0.01654368f, -0.11215508f, 0.04615505f, 0.05380524f, 
    0.26857466f, -0.03759155f, -0.11865102f, 0.07508626f, 0.09385139f, 0.30852163f, -0.02350364f, -0.33923608f, 
    -0.10212529f, -0.08991675f, 0.12182835f, -0.17575562f, -0.03873118f, 0.06668985f, -0.05365773f, -0.02612736f, 
    -0.17469175f, -0.13158748f, -0.22806735f, -0.04180412f, 0.06040024f, 0.04144407f, -0.09456208f, 0.08591838f, 
    -0.05855400f, 0.02412344f, -0.00034791f, -0.02971808f, -0.45799401f, -0.31858164f, -0.02752596f, -0.03085056f, 
    -0.00736142f, 0.05620259f, -0.06721398f, 0.12265258f, -0.00296780f, -0.01326431f, -0.03116361f, -0.11702491f, 
    0.40061191f, -0.31070909f, -0.12150937f, -0.21017952f, 0.10278188f, -0.05894559f, -0.07600322f, 0.21033615f, 
    0.12590639f, 0.03289332f, 0.01599175f, -0.18242517f, -0.04583705f, -0.24876539f, 0.13509209f, -0.18722342f, 
    0.01378632f, -0.02251883f, 0.02506403f, 0.03837184f, -0.02136401f, -0.09864973f, -0.04069588f, 0.03194423f, 
    0.16198981f, -0.11812384f, -0.31805447f, 0.07748634f, -0.03031836f, 0.01900451f, -0.00468990f, 0.02667535f, 
    0.05449888f, -0.01285097f, 0.01501906f, 0.08902130f, 0.04409217f, -0.16281700f, -0.36692369f, 0.15025334f, 
    0.05308191f, 0.08383838f, -0.02743366f, -0.01725010f, -0.01003392f, -0.01150734f, -0.02004485f, -0.11665317f, 
    0.18332493f, 0.12694550f, 0.08546779f, -0.02080969f, -0.09916458f, 0.13996065f, 0.01000924f, -0.00851739f, 
    0.11318496f, 0.00302309f, -0.02376013f, 0.07722428f, -0.02770227f, -0.10804091f, 0.00388585f, 0.01674781f, 
    -0.05625523f, -0.02190154f, 0.00561468f, -0.04393084f, -0.15883876f, -0.33783519f, 0.02664611f, 0.02484624f, 
    0.03254625f, 0.13234070f, 0.22209975f, -0.15918311f, 0.21208352f, -0.08645618f, 0.18586221f, -0.29774326f, 
    -0.03756839f, -0.02156267f, 0.00747045f, -0.05381809f, -0.04075886f, 0.02917163f, 0.03477751f, -0.11932497f, 
    0.08574779f, 0.07569715f, 0.12254348f, -0.01267600f, 0.02837270f, 0.02597390f, 0.06283435f, 0.06569636f, 
    -0.14599365f, 0.01845528f, -0.13310517f, -0.12463744f, -0.00446867f, -0.11260548f, -0.14541171f, -0.18513392f, 
    0.24347579f, 0.13864239f, -0.10118351f, -0.12657651f, 0.06123885f, -0.21249247f, -0.10286868f, 0.22146447f, 
    -0.05680740f, -0.04585069f, 0.00849436f, 0.19720075f, -0.04150404f, -0.00357490f, -0.05457493f, -0.02431440f, 
    0.05487301f, -0.12683272f, -0.01418796f, 0.00497579f, -0.01469794f, -0.04405554f, -0.00868385f, -0.00322307f, 
    0.07780621f, -0.17868493f, -0.01803502f, -0.20474026f, -0.29300916f, 0.08032196f, 0.03794141f, 0.05591700f, 
    0.03909391f, -0.22338422f, -0.10813858f, 0.20669806f, 0.02270116f, -0.06545576f, 0.01132234f, 0.03865011f, 
    0.02239581f, 0.13437964f, -0.11489252f, -0.29216495f, 0.04360443f, 0.14990024f, -0.15400003f, -0.00284438f, 
    0.06114257f, -0.11635680f, 0.04770351f, -0.00039330f, -0.04022730f, 0.12457636f, 0.15652905f, -0.26730394f, 
    -0.01063210f, -0.10228088f, 0.07188121f, 0.01115961f, 0.05314555f, -0.07538171f, -0.20125702f, 0.00808315f, 
    -0.13016161f, -0.00045547f, -0.05023963f, 0.13724032f, -0.18610351f, 0.04486765f, 0.03676524f, -0.07397019f, 
    0.09429943f, 0.05390569f, 0.04182005f, 0.15882428f, 0.20452876f, -0.08803200f, -0.13011391f, -0.02497775f, 
    0.01451427f, 0.03131943f, 0.08469403f, 0.00905566f, 0.07646641f, -0.34929916f, -0.13841563f, -0.44867393f, 
    -0.10019847f, -0.08932771f, -0.06958669f, -0.08935697f, 0.03371546f, -0.05400919f, 0.03016330f, -0.06756229f, 
    0.24480705f, -0.11397919f, 0.13447307f, 0.05795043f, -0.15542257f, -0.02352722f, 0.11431769f, -0.14337039f, 
    0.05655741f, 0.09313864f, 0.16685835f, 0.07194005f, -0.01277669f, 0.01672367f, 0.07750175f, -0.05688851f, 
    0.19157901f, 0.01224541f, 0.14080791f, -0.01802828f, 0.13413030f, 0.15962346f, 0.10163003f, 0.06711505f, 
    0.08131759f, 0.00639878f, -0.01182230f, 0.01425922f, -0.09870502f, 0.22843891f, 0.00697132f, -0.27185652f, 
    0.20661062f, 0.05349867f, 0.29587379f, 0.08724900f, -0.00095692f, -0.00154018f, 0.06912937f, -0.00715571f, 
    -0.04740157f, 0.28508025f, 0.18597370f, 0.03630849f, -0.15591274f, -0.17596883f, -0.10840425f, -0.10485589f, 
    0.15889604f, -0.16934116f, 0.00552813f, -0.09108741f, 0.03069040f, 0.05829779f, -0.08939221f, -0.06203340f, 
    0.21579914f, -0.03801568f, 0.08152454f, -0.16696039f, 0.09145699f, -0.03074298f, -0.08188163f, 0.07714348f, 
    0.13085169f, 0.01882030f, 0.11485034f, -0.09508047f, -0.08832031f, 0.07502148f, 0.02287221f, 0.16009122f, 
    0.06779581f, 0.05926333f, 0.00095328f, 0.02307137f, -0.07550552f, 0.02561904f, 0.13075402f, -0.23038334f, 
    0.14576964f, -0.14030956f, 0.13225168f, 0.33193186f, -0.10430076f, 0.05776500f, 0.07644664f, -0.01485976f, 
    -0.38024160f, -0.05423522f, -0.01406661f, 0.20304787f, 0.16431107f, -0.07827109f, 0.20910399f, 0.06185944f, 
    0.03840414f, 0.16904344f, -0.14148968f, 0.00999462f, 0.12907523f, -0.21885182f, 0.05677216f, 0.07346039f, 
    -0.02295139f, 0.00043573f, -0.06761084f, 0.03657442f, 0.04492383f, -0.01948456f, 0.15602472f, 0.21126485f, 
    0.15677400f, 0.12835257f, 0.19533689f, -0.15306371f, -0.08112663f, -0.12150377f, -0.00122726f, 0.17658390f, 
    -0.03910759f, -0.02923648f, 0.42718530f, -0.00537374f, 0.18440835f, -0.19639833f, -0.21461654f, 0.06739520f, 
    0.18868399f, -0.00568935f, 0.11872242f, 0.02167764f, -0.00445624f, 0.13847639f, -0.00924640f, 0.03711971f, 
    0.13877974f, -0.02246027f, -0.11401039f, -0.20634232f, 0.01501375f, 0.11931021f, -0.17497002f, 0.00964675f, 
    0.08947116f, -0.01335458f, 0.02746030f, 0.11188485f, -0.03037701f, -0.00575976f, -0.20063920f, 0.15033689f, 
    0.14223844f, -0.07300113f, -0.05769247f, 0.00553846f, -0.05105420f, 0.10930336f, 0.01359829f, 0.02720860f, 
    0.02174119f, 0.00955028f, -0.30309382f, 0.35118455f, -0.08590622f, 0.03356805f, -0.02311156f, -0.08963434f, 
    0.05355111f, -0.23162363f, 0.14866228f, 0.02140765f, -0.01220531f, -0.19268081f, 0.04986907f, 0.14615256f, 
    0.12285569f, 0.01264087f, 0.05531924f, 0.03400436f, -0.03931702f, -0.00495024f, 0.18756989f, 0.12066300f, 
    -0.08328273f, 0.00214086f, 0.00027851f, -0.03200138f, 0.14774951f, -0.02184433f, -0.02312284f, -0.01321084f, 
    0.07218310f, -0.01160318f, 0.00155993f, 0.12899211f, -0.00694164f, -0.25889152f, 0.04352348f, -0.19746707f, 
    -0.06627339f, 0.03259556f, -0.00890566f, 0.08748396f, -0.01938323f, -0.06194244f, 0.01874577f, -0.03927648f, 
    -0.57438433f, -0.46068564f, -0.52102989f, -0.16596261f, -0.31705031f, -0.18072040f, 0.10048048f, 0.16112277f, 
    0.01543883f, -0.10658920f, 0.04993827f, -0.05287302f, -0.21793333f, -0.50369561f, 0.00905182f, -0.03443298f, 
    -0.12658504f, 0.00426788f, -0.02726044f, 0.11862332f, -0.04726832f, 0.06525455f, -0.02805829f, 0.05117248f, 
    -0.10224764f, -0.41643164f, -0.04352780f, -0.21917330f, 0.10481447f, 0.21743104f, 0.16489071f, -0.18454428f, 
    -0.01903017f, -0.02250212f, -0.05627469f, 0.08858126f, 0.20501879f, -0.01712641f, -0.04472618f, -0.23669223f, 
    0.04261406f, -0.04120246f, 0.13040863f, 0.05818801f, 0.14341338f, 0.02866823f, -0.00132049f, -0.02743301f, 
    -0.02906365f, -0.23202829f, -0.05014012f, -0.14505440f, 0.18963933f, 0.01053754f, -0.00597930f, -0.17262381f, 
    -0.01322210f, 0.04507640f, -0.03071934f, 0.10419383f, -0.13652620f, 0.00149325f, 0.13187918f, -0.60367024f, 
    -0.00233293f, -0.02456268f, -0.04422911f, 0.03007028f, 0.05694633f, 0.20610714f, 0.01569608f, 0.30618468f, 
    -0.07516780f, -0.06864777f, -0.07372548f, -0.03236296f, 0.07312279f, -0.02097745f, 0.01289011f, -0.00938187f, 
    -0.05801790f, -0.09263079f, -0.06125098f, -0.01368063f, 0.07407473f, -0.10677404f, 0.00119618f, -0.02399025f, 
    0.07110534f, 0.04459936f, 0.15257245f, -0.05348881f, -0.02288887f, -0.05847033f, -0.02948119f, -0.02034799f, 
    -0.02831919f, -0.19177186f, 0.17631099f, 0.14961921f, -0.01630602f, -0.01291913f, -0.02445517f, 0.12592097f, 
    0.01714488f, 0.08232612f, 0.13350874f, 0.03696470f, -0.16097705f, 0.02341452f, 0.22303458f, 0.20829728f, 
    -0.11836334f, -0.03133432f, -0.05370234f, -0.15918069f, -0.04161716f, -0.06627415f, 0.00846459f, 0.04484739f, 
    -0.36481991f, 0.36015114f, 0.27135527f, 0.12003596f, -0.16200295f, -0.03744143f, -0.08615456f, 0.13802429f, 
    -0.06117610f, 0.05843055f, -0.08641885f, 0.01835637f, -0.27233881f, 0.09945125f, 0.02758852f, 0.08311210f, 
    0.00125915f, 0.02214441f, 0.02087433f, -0.11367547f, -0.00485112f, -0.04124804f, -0.00175697f, -0.06669349f, 
    0.16457678f, 0.43302879f, 0.02076305f, 0.27258652f, 0.06134794f, -0.10029667f, 0.26799130f, -0.02199929f, 
    0.10169943f, 0.03999176f, 0.18322234f, -0.11069948f, -0.16367547f, 0.04429105f, 0.10663673f, -0.10762148f, 
    -0.02673774f, 0.01860709f, 0.09485245f, -0.07896327f, 0.02327099f, -0.05288744f, -0.07574146f, -0.09595250f, 
    -0.30905038f, -0.21862940f, -0.22280645f, 0.28588057f, 0.05323538f, 0.05976874f, 0.07690147f, 0.11435806f, 
    0.09249843f, 0.11240567f, 0.19563556f, -0.01172840f, 0.14372799f, 0.00715529f, -0.12873562f, 0.08354510f, 
    -0.02127658f, -0.01189268f, 0.00674564f, 0.11151997f, 0.01438014f, 0.00972559f, 0.16500378f, -0.13977493f, 
    0.43799081f, 0.04023530f, -0.15102078f, 0.11446436f, 0.00196517f, -0.06531289f, 0.17681031f, 0.00295755f, 
    -0.02610725f, 0.00051564f, -0.06232125f, -0.18858401f, 0.01413969f, -0.06115115f, 0.16517229f, 0.01431864f, 
    0.02848973f, -0.02433966f, 0.05077777f, 0.03192008f, 0.00446573f, -0.12728129f, 0.03530542f, 0.05613221f, 
    -0.20847236f, 0.00954525f, 0.06033057f, 0.20846514f, 0.04752724f, 0.05942135f, -0.05801075f, -0.03111855f, 
    -0.04988209f, -0.06591058f, 0.05256712f, 0.17140239f, 0.07416445f, -0.00358377f, 0.05351079f, 0.04978168f, 
    -0.08746257f, 0.04409744f, 0.07403854f, -0.00879974f, 0.00108797f, 0.02384522f, -0.04142593f, 0.14606094f, 
    -0.07077766f, 0.04336328f, 0.06305251f, -0.03460376f, -0.00006855f, -0.03451024f, -0.02578807f, 0.09376820f, 
    0.07602602f, 0.04363828f, 0.11581354f, 0.05466420f, -0.02445042f, 0.15044373f, -0.00156167f, 0.00481795f, 
    -0.01465442f, 0.01367031f, 0.01664692f, -0.00281476f, 0.17740008f, -0.06817412f, 0.33163685f, 0.04459756f, 
    -0.23295119f, -0.74690700f, -0.55340970f, -0.18935555f, -0.06372417f, 0.01350537f, -0.04198257f, -0.12226940f, 
    0.04107235f, 0.01227888f, 0.00048663f, 0.04112689f, -0.53015286f, -0.61480939f, 0.26001766f, -0.06103022f, 
    -0.11911684f, -0.20429374f, 0.05926615f, -0.25957078f, -0.07526049f, 0.05912164f, 0.03127657f, -0.04340572f, 
    0.16638663f, 0.14742778f, 0.02441348f, -0.15514326f, -0.06640300f, 0.03229619f, 0.04736603f, -0.00104198f, 
    -0.01177789f, 0.09660602f, 0.24925007f, 0.14872769f, -0.26143467f, -0.33084014f, -0.62213171f, -0.48189616f, 
    -0.16002998f, -0.09302359f, -0.08307710f, -0.21995434f, -0.04905760f, -0.11084191f, 0.07250345f, 0.00464486f, 
    -0.00633665f, -0.28134233f, -0.01540824f, 0.03866881f, -0.02758547f, 0.03565882f, 0.00459692f, 0.09008540f, 
    -0.06622304f, 0.00611896f, 0.10312907f, 0.01864673f, -0.55368918f, -0.64969748f, -0.04849649f, 0.42998946f, 
    0.21975861f, 0.11299582f, 0.13918667f, -0.20691174f, 0.08039857f, -0.01658342f, -0.00968723f, 0.10431583f, 
    -0.09551229f, -0.07770801f, -0.11346726f, -0.13649611f, 0.04575891f, 0.09302276f, -0.00984088f, -0.05708288f, 
    -0.03785819f, -0.02541507f, 0.00594313f, -0.01008658f, -0.24554971f, 0.09998456f, 0.13708243f, 0.05972042f, 
    -0.05332042f, 0.03188364f, -0.00737233f, 0.09387281f, -0.04046692f, 0.01362207f, 0.05532962f, 0.03121202f, 
    0.05055030f, 0.53201789f, -0.17824015f, 0.45801821f, -0.03280147f, 0.06248049f, -0.03828444f, 0.10898158f, 
    0.12119130f, -0.02886635f, 0.17939395f, 0.09490836f, -0.00606953f, 0.26263690f, 0.03994988f, -0.08238245f, 
    -0.02366103f, 0.05116215f, 0.00567551f, 0.09343921f, 0.18115816f, 0.07333254f, -0.01832210f, 0.01550763f, 
    0.17226864f, 0.00189655f, -0.15012187f, -0.28021646f, 0.00675195f, 0.06698428f, 0.07670711f, -0.04535645f, 
    -0.06595673f, -0.00394001f, -0.15575522f, -0.05614993f, 0.09156626f, -0.08057551f, -0.03986445f, -0.31233087f, 
    0.07499623f, 0.00681757f, 0.09379616f, -0.11566485f, -0.05854431f, 0.06799100f, -0.04309414f, -0.00958235f, 
    -0.03958715f, -0.25905398f, -0.27812514f, 0.35112852f, -0.09105013f, -0.23663844f, 0.17061645f, 0.09187634f, 
    0.09909303f, 0.07908238f, -0.11672752f, -0.15199691f, -0.05828201f, 0.02772551f, 0.00922960f, -0.03270183f, 
    0.04119776f, 0.01410377f, -0.01974423f, 0.09203824f, -0.04137447f, 0.17114769f, 0.18733035f, 0.08931724f, 
    -0.42314833f, -0.44520918f, -0.62975544f, -0.08327653f, -0.18749020f, 0.03774102f, -0.16745231f, -0.28631124f, 
    0.04851018f, -0.06507063f, 0.02316225f, -0.03753337f, -0.40028414f, -0.56173271f, 0.04780746f, -0.30511615f, 
    0.11126096f, -0.39709765f, 0.03440990f, -0.24206106f, -0.03063097f, 0.00560693f, 0.01449530f, -0.02888706f, 
    -0.02952344f, 0.31172615f, 0.21337862f, 0.08280195f, -0.05120721f, -0.18660846f, -0.10517970f, 0.20630464f, 
    -0.00153515f, 0.05855386f, 0.06575269f, -0.08524632f, -0.12839806f, -0.03688973f, -0.10529532f, 0.12218708f, 
    -0.01387705f, 0.12576039f, 0.07657995f, -0.03941164f, 0.02925908f, -0.07453503f, 0.00076450f, 0.08563770f, 
    0.01308515f, -0.03003939f, -0.01799932f, -0.10213678f, -0.00545961f, 0.02697218f, 0.05304578f, 0.09261767f, 
    -0.20054135f, -0.00852564f, -0.25166386f, -0.04990522f, 0.02025825f, -0.11323609f, 0.10190815f, 0.16992663f, 
    0.06509763f, 0.02671046f, 0.09156902f, -0.07894932f, 0.02241724f, 0.04610077f, 0.09909488f, 0.02515565f, 
    0.21444225f, 0.09175810f, -0.04799227f, -0.27560133f, 0.07776523f, -0.17108029f, -0.01608194f, 0.10386418f, 
    0.03779347f, 0.10613940f, -0.18181829f, -0.13901040f, -0.28574225f, -0.01757855f, 0.03460142f, 0.14268920f, 
    0.08662020f, -0.01948737f, -0.06438848f, 0.13661842f, 0.08219534f, -0.12253679f, 0.12213753f, -0.18537499f, 
    0.00054900f, -0.12882875f, -0.21785221f, 0.03736226f, -0.11469033f, -0.09243454f, -0.06446150f, 0.03675187f, 
    0.02239639f, -0.07610123f, 0.04969561f, -0.07103429f, 0.25462246f, 0.06512091f, -0.13504320f, -0.11160208f, 
    -0.03208509f, 0.00039848f, 0.04697851f, 0.13938458f, 0.06648741f, 0.22058211f, 0.06289197f, 0.09163991f, 
    0.20902942f, 0.01112000f, -0.12450437f, -0.03667288f, 0.07672805f, -0.04185545f, 0.08770546f, -0.05769200f, 
    -0.03738571f, -0.18587717f, 0.01885090f, -0.31248900f, -0.56702787f, -0.53522229f, -0.13315429f, 0.16758695f, 
    -0.05529635f, -0.06357255f, -0.10400002f, -0.27321875f, -0.02027916f, 0.01525070f, -0.01232476f, -0.06255163f, 
    -0.74570131f, -0.53986686f, -0.36918741f, -0.15985352f, -0.23987791f, -0.34772336f, -0.43910050f, -0.37683895f, 
    -0.07410789f, -0.01256878f, -0.07164633f, -0.04953699f, -0.36591604f, -0.43239337f, -0.27868202f, -0.30291539f, 
    -0.01610368f, -0.14360943f, -0.26227421f, -0.21347086f, 0.03233319f, -0.01352134f, 0.03661574f, -0.07929578f, 
    -0.11680460f, -0.15796538f, -0.15426414f, -0.02028561f, -0.13921206f, -0.02172366f, 0.10671601f, -0.14939074f, 
    0.00330855f, 0.00168350f, 0.06454228f, 0.12207868f, -0.25726262f, -0.19704159f, -0.17828268f, 0.03179922f, 
    0.05941803f, -0.04987213f, -0.03174020f, -0.38590997f, -0.00452696f, -0.02093979f, -0.05976661f, 0.03080673f, 
    -0.07941861f, -0.29792577f, -0.37069270f, 0.06303022f, -0.12667024f, 0.11697726f, 0.07194784f, -0.25368962f, 
    -0.00263228f, 0.00425826f, -0.04165250f, -0.01037248f, -0.05645459f, -0.27917123f, -0.02499307f, 0.25142571f, 
    0.02223116f, 0.13076577f, 0.12368784f, 0.07533323f, 0.01586572f, 0.02988566f, -0.00876107f, 0.00420150f, 
    0.13349420f, -0.20032197f, -0.31524754f, -0.02728342f, 0.00003449f, 0.24406075f, 0.14920457f, -0.14905380f, 
    0.00820635f, -0.08370388f, 0.05135724f, 0.00542162f, 0.05478954f, 0.00547970f, -0.18348922f, 0.07918418f, 
    -0.05513903f, -0.04971964f, -0.00354486f, 0.07858367f, 0.02193285f, 0.16800255f, -0.10340813f, -0.19935673f, 
    -0.07881585f, -0.14619590f, 0.16651499f, 0.13636486f, -0.02164329f, 0.18791501f, -0.01383454f, -0.11504281f, 
    0.18874331f, 0.13330461f, -0.04710991f, 0.00112100f, 0.22104131f, 0.04329394f, 0.01073431f, -0.06296303f, 
    -0.02203481f, 0.07724502f, -0.11102933f, -0.05344385f, 0.11750854f, -0.11362728f, 0.04777441f, 0.01396840f, 
    0.24406531f, 0.02667375f, 0.20412071f, -0.26486441f, 0.02569816f, -0.02438157f, -0.06623045f, -0.08671615f, 
    0.10255592f, -0.05923466f, 0.02574108f, -0.00833400f, -0.00134782f, 0.03829934f, -0.08236456f, -0.12052597f, 
    0.03860703f, -0.00183496f, 0.05229176f, 0.03241734f, -0.01696290f, 0.01164993f, -0.06736829f, 0.00074078f, 
    0.08144228f, -0.15110569f, 0.15025586f, -0.11162096f, -0.00898491f, 0.04994892f, -0.13928899f, 0.04655906f, 
    0.07939684f, -0.06083532f, -0.00640927f, 0.19123808f, -0.04404697f, -0.10711876f, -0.12288388f, 0.15674771f, 
    -0.11189393f, 0.10132416f, -0.01102987f, 0.02980117f, 0.04969570f, -0.08300544f, -0.01060821f, -0.01161470f, 
    -0.00110255f, 0.01652477f, 0.01437894f, -0.06771110f, -0.07556205f, -0.07395571f, 0.07178596f, 0.05194574f, 
    0.02324774f, -0.04335826f, -0.01674709f, -0.05660394f, -0.47154370f, -0.50304323f, -0.13507082f, 0.16231592f, 
    0.16169129f, 0.27687275f, -0.00521399f, 0.01163784f, 0.02796576f, -0.07724535f, 0.01462251f, 0.03726042f, 
    -0.66147238f, -0.50049871f, 0.36741385f, 0.27627587f, 0.03531827f, 0.04566417f, 0.08314158f, -0.00832407f, 
    0.01344436f, 0.01377323f, -0.11071572f, -0.07813448f, 0.55381078f, -0.34869590f, -0.03852569f, 0.23197818f, 
    -0.02137097f, 0.12077136f, 0.06503411f, -0.05989860f, -0.02527823f, 0.01611604f, -0.09287401f, -0.02236351f, 
    -0.47171700f, 0.29865697f, -0.02125305f, 0.04440527f, -0.04692312f, -0.18179807f, -0.03358917f, -0.00051975f, 
    0.07257744f, 0.00558526f, 0.06001104f, -0.08332635f, -0.03436754f, 0.16008906f, -0.14238116f, 0.00439736f, 
    0.00501563f, -0.02703353f, 0.14390332f, 0.18036631f, -0.12116754f, -0.02540885f, -0.01142959f, 0.01126165f, 
    -0.14505789f, 0.43295145f, 0.09426517f, 0.17128147f, -0.03828039f, -0.08529492f, -0.02115127f, 0.05519653f, 
    -0.03943735f, 0.03061659f, -0.03107017f, -0.06162924f, 0.28411093f, 0.01350847f, -0.12392740f, -0.23142056f, 
    0.02933921f, 0.01172788f, 0.01080917f, 0.00912124f, 0.01408219f, 0.11141010f, -0.03813079f, -0.05858270f, 
    0.06904294f, -0.01368938f, 0.05485045f, -0.05243940f, -0.03969392f, 0.01534040f, -0.02854798f, -0.04928927f, 
    0.02028302f, 0.05883629f, 0.02388748f, -0.01973652f, 0.02328404f, 0.16130571f, 0.03144071f, -0.06033017f, 
    -0.03629158f, -0.04649483f, 0.00178103f, 0.02891345f, 0.03780163f, -0.01029346f, 0.06650458f, -0.04814715f, 
    0.26018953f, -0.53841972f, -0.01041108f, -0.14076388f, -0.12198155f, -0.03526953f, -0.17745161f, 0.15366493f, 
    0.02620332f, 0.07232553f, 0.10143581f, 0.02642310f, 0.16649312f, -0.14257923f, -0.03025504f, -0.21412729f, 
    -0.03702571f, 0.01357106f, -0.03848726f, 0.00363510f, 0.06248155f, -0.01542127f, -0.01851849f, -0.00841479f, 
    0.49795684f, -0.44960856f, -0.13546097f, -0.19697866f, -0.05635853f, -0.12233122f, -0.14378127f, -0.03936275f, 
    0.08027721f, 0.01100928f, -0.00133934f, 0.01581485f, 0.23160751f, 0.00313643f, -0.15522286f, -0.08763862f, 
    -0.26181456f, -0.04185385f, -0.17551252f, -0.10522255f, -0.00302771f, 0.02984261f, -0.04742074f, 0.03261833f, 
    -0.14510411f, -0.08212642f, -0.03423182f, 0.03588226f, -0.12729095f, -0.01507446f, 0.22493961f, -0.15779285f, 
    -0.08425272f, 0.09945849f, -0.00915732f, -0.05608416f, 0.06741016f, -0.00428405f, -0.00989022f, -0.10808919f, 
    -0.00821483f, 0.02514966f, 0.09095746f, 0.01261758f, -0.04002590f, -0.02597983f, -0.11285701f, 0.03095872f, 
    0.03687054f, -0.38869578f, 0.20264542f, -0.37264571f, -0.09680637f, -0.06893698f, 0.05100192f, -0.00835499f, 
    0.06512794f, -0.01555855f, 0.03536622f, -0.10955194f, 0.38907787f, -0.12761590f, -0.03841444f, -0.08795980f, 
    0.01613145f, -0.18823962f, -0.01790589f, -0.18951212f, -0.13384238f, -0.02535593f, -0.12626922f, 0.06437524f, 
    -0.19131736f, 0.01965067f, -0.07878068f, 0.02285654f, -0.07486841f, 0.06431804f, 0.04811484f, -0.03071605f, 
    -0.03323205f, 0.00750029f, 0.03619947f, -0.11438135f, -0.06214296f, 0.05168460f, 0.16026585f, -0.16170070f, 
    -0.12384323f, -0.00255701f, 0.07578825f, -0.00315963f, -0.07297778f, -0.03693632f, 0.02106339f, -0.09970690f, 
    0.43654707f, -0.30681345f, 0.16056713f, -0.30879787f, -0.16305332f, 0.09330928f, -0.13537097f, 0.04583018f, 
    -0.07842571f, 0.10643648f, -0.00212757f, -0.13649005f, -0.02692251f, -0.03534558f, 0.01941712f, 0.05847428f, 
    -0.08898708f, 0.01423673f, -0.01781783f, -0.11496425f, -0.00958852f, 0.02536178f, -0.05800239f, 0.08046009f, 
    0.19849899f, -0.15114474f, -0.06875890f, -0.30777100f, 0.00903276f, 0.03977596f, -0.02199157f, -0.06214012f, 
    0.09361383f, 0.13790137f, -0.01216985f, -0.12808701f, 0.06386935f, 0.00861730f, 0.04896892f, 0.07390617f, 
    -0.00185372f, -0.05062728f, -0.00862725f, -0.04460852f, -0.08549694f, 0.00635576f, 0.08085934f, 0.04118856f, 
    0.29570141f, -0.30458170f, -0.29360583f, -0.46367726f, 0.06560561f, -0.00116435f, 0.01236195f, 0.23967506f, 
    -0.00411686f, -0.09916477f, -0.02868290f, 0.04339304f, 0.28333187f, -0.43430322f, -0.32460579f, -0.35830897f, 
    0.02152143f, -0.13364217f, 0.10021932f, 0.29568112f, 0.01761065f, -0.08975467f, -0.06200130f, 0.03107984f, 
    -0.01579042f, 0.09217776f, -0.01957397f, 0.17083324f, -0.01506624f, -0.00535439f, 0.01619562f, 0.03419390f, 
    0.05364268f, 0.03516858f, -0.01327864f, -0.06601086f, -0.48969191f, -0.45935866f, -0.25371495f, 0.50118804f, 
    0.04313240f, 0.16621205f, 0.15225051f, -0.01764215f, 0.00803434f, 0.00491812f, -0.01809372f, -0.06005513f, 
    -0.00515809f, 0.05176676f, 0.18103266f, -0.05325530f, -0.14789352f, 0.03206151f, -0.00191531f, 0.09475453f, 
    -0.05084703f, 0.07726990f, -0.02642717f, -0.06682041f, -0.19010530f, -0.06363168f, 0.24431622f, -0.26445764f, 
    -0.06483738f, -0.06982310f, -0.02737256f, 0.12946945f, -0.08244753f, 0.05369613f, -0.07930503f, -0.09566741f, 
    -0.05387671f, 0.02845547f, -0.12188990f, -0.10987552f, 0.02884459f, -0.02951180f, -0.06252844f, -0.00338638f, 
    0.02128902f, 0.05801164f, 0.00111438f, 0.00000012f, 0.37369242f, -0.24182750f, -0.06234026f, -0.17373995f, 
    -0.02997416f, 0.00877759f, -0.03095886f, -0.05813343f, 0.07860766f, 0.07340059f, 0.02421614f, -0.02822800f, 
    -0.36529627f, -0.21794511f, -0.46985486f, -0.15430036f, -0.01813837f, -0.06897813f, 0.19237837f, -0.15301120f, 
    -0.03773985f, 0.00207863f, 0.10380526f, -0.06169323f, 0.19986251f, -0.33010158f, -0.02848807f, -0.36302364f, 
    -0.02794303f, -0.02154113f, 0.00357142f, -0.02720339f, 0.15038291f, 0.03284786f, -0.04246464f, 0.03235145f, 
    -0.01347034f, -0.05712276f, -0.00274937f, -0.07799291f, -0.01027544f, -0.02840709f, -0.03209399f, 0.00688049f, 
    -0.01430154f, -0.02088520f, -0.03495092f, -0.02303786f, -0.04294115f, 0.10394709f, -0.00618303f, -0.06903791f, 
    0.00839665f, 0.01619445f, -0.04059910f, -0.07155809f, 0.06126949f, 0.04662848f, 0.02170922f, 0.00755682f, 
    -0.45010665f, -0.48075143f, -0.02655546f, 0.03038679f, -0.10863032f, 0.01921215f, -0.04341813f, -0.18443075f, 
    -0.04287652f, -0.04164325f, -0.02048065f, -0.02315200f, 0.08691228f, -0.02194161f, 0.11837424f, -0.01378051f, 
    -0.01017394f, -0.03158132f, -0.05111462f, -0.11192602f, -0.02806818f, -0.04212923f, -0.16417241f, -0.10388023f, 
    -0.34459880f, -0.36192271f, -0.08281104f, 0.28014258f, 0.08913679f, 0.13985346f, 0.04994057f, -0.06024030f, 
    -0.00796599f, 0.02573702f, -0.00486690f, -0.00293413f, -0.42119393f, -0.35352588f, 0.04353682f, -0.28740522f, 
    -0.03303863f, 0.06349620f, 0.00736603f, 0.06825941f, 0.06459025f, -0.00670311f, 0.00834490f, -0.00507499f, 
    0.13757719f, -0.47041512f, -0.58477443f, -0.07480840f, 0.05881629f, 0.03431654f, 0.11941482f, -0.00299094f, 
    0.02990379f, -0.05495457f, 0.03024976f, 0.12934217f, -0.01963254f, 0.10011818f, 0.08416601f, 0.04121189f, 
    0.05828866f, -0.00787561f, -0.00976791f, -0.07003147f, -0.05816963f, 0.07609757f, 0.03410998f, 0.07163506f, 
    0.05682880f, 0.08866950f, 0.07118002f, 0.03239834f, 0.03849949f, 0.00065422f, -0.03320771f, 0.01641244f, 
    0.02911605f, -0.14765660f, 0.07124884f, 0.05746854f, 0.21767153f, -0.02134311f, -0.01782744f, 0.00330547f, 
    0.02405917f, -0.03483665f, -0.08752245f, -0.02358656f, -0.12022392f, 0.04619230f, -0.07293046f, -0.03832266f, 
    -0.41229689f, 0.28096163f, 0.03366015f, 0.38236615f, 0.06031029f, -0.17255390f, 0.10480832f, 0.01396492f, 
    0.00545516f, -0.05132857f, 0.05716307f, 0.03894405f, 0.03525063f, -0.08024149f, -0.00634982f, -0.21903443f, 
    0.02439792f, -0.02200259f, 0.10671034f, -0.04136414f, 0.04727009f, 0.01830786f, -0.01731704f, -0.24709797f, 
    -0.00898326f, -0.01238461f, 0.09435412f, -0.03950531f, 0.00067046f, -0.02458502f, 0.08871266f, 0.01714480f, 
    0.05030259f, 0.00884439f, 0.02241064f, 0.04949272f, -0.10884466f, 0.00670112f, 0.02398739f, 0.10595874f, 
    -0.02424403f, -0.02353268f, -0.03314139f, 0.05288542f, 0.11616072f, 0.05615516f, 0.17931892f, 0.09136628f, 
    -0.01233801f, -0.04027041f, 0.12339997f, -0.11557336f, -0.05470454f, 0.03977853f, 0.00785479f, 0.00643148f, 
    0.03835944f, -0.18846458f, -0.13363090f, 0.01481515f, -0.05196722f, -0.22371979f, -0.25566632f, -0.02808661f, 
    -0.07034346f, 0.05466824f, 0.01044301f, 0.21219417f, 0.01164103f, 0.00450396f, -0.08490869f, -0.01476520f, 
    -0.12200543f, -0.34946093f, 0.18569188f, 0.31195620f, 0.07409769f, -0.02868889f, -0.08422478f, -0.00815811f, 
    0.04204604f, -0.01618196f, 0.07760401f, -0.02047244f, -0.27131718f, -0.24454048f, -0.14922602f, -0.16105843f, 
    0.09034026f, 0.07035176f, 0.07853804f, 0.12592202f, 0.05177733f, -0.05370146f, 0.05427071f, 0.01269147f, 
    -0.07681641f, -0.00564402f, -0.28267151f, 0.01610695f, 0.06497548f, -0.05255806f, 0.12137259f, 0.00386516f, 
    -0.00054639f, -0.06277379f, -0.11411230f, -0.03285412f, -0.45456520f, -0.04767071f, 0.15993464f, 0.00844876f, 
    -0.05516687f, -0.09199378f, -0.04533714f, -0.06793611f, 0.00043446f, -0.01376806f, 0.02244782f, 0.00557762f, 
    -0.18010324f, -0.16115695f, 0.16890906f, 0.10006513f, 0.00528081f, 0.07260155f, -0.07667089f, -0.09352870f, 
    -0.00389245f, 0.04930435f, 0.00664668f, 0.02171993f, -0.17055558f, -0.18865448f, 0.09633110f, -0.30900931f, 
    -0.11033038f, 0.04674416f, 0.01911378f, -0.04203250f, -0.00170594f, -0.01547678f, 0.00973540f, -0.04149530f, 
    -0.17234938f, 0.23562473f, -0.16942759f, -0.06576133f, -0.04670720f, 0.12814580f, -0.09838271f, 0.00397972f, 
    -0.00810879f, 0.12508912f, 0.05659787f, 0.10079954f, 0.17706253f, -0.15154016f, 0.09207951f, -0.10121059f, 
    -0.02220448f, 0.08321740f, 0.04468871f, -0.05342541f, 0.03510780f, -0.10072657f, -0.07117456f, -0.03616157f, 
    0.35434324f, 0.16971588f, -0.02777329f, -0.13736567f, -0.01180653f, 0.04396289f, -0.02064046f, -0.03615944f, 
    -0.05258203f, -0.10110328f, -0.01455302f, -0.15802956f, -0.09267248f, 0.13382275f, -0.07345726f, 0.02974361f, 
    0.05682535f, 0.04299790f, 0.02374633f, 0.00400080f, -0.15477222f, 0.01051285f, 0.04670725f, 0.02312039f, 
    -0.15271911f, 0.23841999f, -0.08028851f, 0.04776396f, 0.08641250f, -0.18192792f, 0.16627769f, 0.05121079f, 
    0.05526869f, -0.02189893f, 0.03978674f, 0.02063633f, 0.03702454f, 0.09830552f, 0.05335333f, 0.03459756f, 
    -0.04043042f, -0.03507846f, -0.10499206f, -0.01772112f, -0.05208459f, 0.01448238f, 0.04037514f, -0.00085385f, 
    0.09291084f, 0.04565481f, -0.03279402f, -0.11879665f, 0.06197340f, -0.02372942f, 0.01243100f, 0.07432780f, 
    0.03851558f, -0.03930121f, -0.00782224f, -0.22154672f, 0.03964001f, -0.02940818f, -0.00557569f, -0.12871248f, 
    0.02118576f, -0.09367961f, 0.01718314f, -0.19219778f, -0.10346802f, 0.05118600f, -0.01185099f, 0.04739483f, 
    -0.06035844f, 0.00920936f, -0.01531343f, -0.01934007f, 0.05420773f, 0.08401581f, 0.13566153f, -0.03369735f, 
    0.04948793f, 0.02168074f, 0.02316055f, 0.00375941f, -0.01129187f, 0.02887899f, 0.10337112f, -0.22647734f, 
    -0.00969874f, -0.23297741f, 0.00661667f, 0.00586508f, 0.06401718f, 0.02559035f, 0.00127606f, -0.05753358f, 
    0.83755714f, -0.23299986f, -0.19105329f, -0.18521097f, 0.05641795f, -0.05548453f, 0.06637872f, -0.03410919f, 
    0.07998314f, 0.00759049f, 0.09795373f, -0.09094270f, 0.41628569f, 0.10161029f, -0.28679347f, -0.17627223f, 
    0.04836947f, -0.05207889f, -0.02606896f, -0.22717035f, 0.06463591f, 0.13276584f, 0.11132266f, 0.10571967f, 
    -0.54042304f, 0.16279110f, 0.18386754f, 0.11663218f, 0.04143948f, 0.01433261f, -0.01465359f, 0.08822234f, 
    0.00099303f, 0.03400882f, -0.03166467f, 0.06390247f, -0.25025570f, 0.02527488f, 0.06841955f, 0.16753289f, 
    -0.00076360f, -0.01905263f, -0.13385324f, 0.05957065f, -0.24222301f, -0.06430981f, -0.05785275f, -0.00795365f, 
    0.10651892f, 0.17203258f, -0.40140802f, -0.10715203f, -0.14963205f, -0.04574074f, 0.09633703f, 0.03948681f, 
    0.05828137f, -0.01157380f, 0.05049249f, 0.04486118f, -0.41585833f, -0.03669526f, -0.11751442f, -0.04257248f, 
    -0.04816425f, 0.03183712f, -0.04944677f, -0.03901894f, 0.17506853f, 0.23905151f, -0.01195388f, 0.01758798f, 
    -0.03107781f, 0.06311152f, -0.04316873f, -0.06571617f, 0.00520292f, -0.11421938f, -0.00910535f, -0.03914471f, 
    0.00040461f, 0.01832834f, 0.04975661f, 0.02360580f, -0.27799591f, -0.00681890f, 0.01043071f, 0.07704733f, 
    -0.07238834f, -0.03864919f, -0.12883067f, -0.06044162f, -0.24001846f, -0.07927582f, -0.12739524f, -0.12610145f, 
    -0.52735454f, -0.24407676f, 0.07793761f, -0.14667180f, 0.09276474f, 0.12816206f, 0.09708074f, 0.05824875f, 
    -0.04736628f, -0.11411796f, -0.01268047f, -0.32547137f, -0.03853034f, -0.16526568f, -0.00717544f, 0.11896253f, 
    -0.01960620f, 0.03172613f, 0.04989265f, 0.01755099f, 0.08213158f, -0.06463073f, 0.11521222f, 0.07362483f, 
    -0.29449344f, -0.43136859f, -0.30749279f, -0.06474210f, 0.09741707f, 0.15748072f, 0.17416447f, 0.22923355f, 
    -0.06193018f, -0.07721718f, -0.02752084f, -0.07278225f, 0.10889693f, 0.05551813f, -0.03530110f, -0.14090361f, 
    -0.02513120f, -0.06751646f, 0.21355715f, 0.04537435f, 0.05837754f, -0.13303508f, 0.06082255f, 0.07475846f, 
    -0.35283402f, -0.10206876f, 0.18028346f, 0.20360720f, 0.05914646f, 0.03254658f, 0.07831968f, -0.06295981f, 
    0.09235052f, 0.15356046f, 0.03601970f, 0.19187924f, -0.05208075f, -0.09323692f, -0.10634936f, 0.03819503f, 
    0.05073532f, -0.02170044f, -0.01607079f, -0.01039934f, 0.02726091f, 0.11807048f, -0.09226646f, 0.14336760f, 
    0.52696377f, -0.02162151f, -0.18370131f, -0.22703561f, 0.02225150f, 0.05844884f, 0.02038993f, -0.05737055f, 
    0.13894165f, -0.06065262f, -0.13209428f, -0.25031954f, 0.18439145f, -0.03363466f, -0.04618651f, -0.04912627f, 
    0.07327532f, 0.03071188f, 0.04563760f, -0.00037154f, 0.03623058f, -0.13021052f, 0.12339655f, -0.06222114f, 
    -0.12835623f, 0.24695279f, -0.00806198f, 0.10729443f, 0.22493970f, 0.00035637f, -0.04414384f, 0.12804863f, 
    -0.02040950f, -0.09440644f, 0.10078316f, 0.14530845f, -0.15010120f, 0.00460996f, 0.03060865f, -0.01515026f, 
    0.04920011f, -0.05622943f, -0.07372954f, 0.03715625f, 0.17919594f, 0.05970029f, 0.02064773f, 0.06979988f, 
    0.30611581f, -0.03056107f, -0.15199250f, -0.32030052f, 0.05737361f, 0.04413095f, 0.03543567f, 0.00259619f, 
    0.03775369f, 0.03423272f, 0.00108124f, 0.22745241f, -0.11526790f, 0.02417863f, 0.00167937f, 0.04267202f, 
    0.14406443f, 0.04284118f, 0.04236767f, 0.06979507f, -0.15879895f, -0.14287895f, -0.10520874f, -0.44265807f, 
    0.02929604f, -0.16258875f, -0.25320101f, -0.29323712f, -0.05958512f, -0.05822549f, -0.03390151f, -0.00155911f, 
    0.11513405f, -0.09068657f, 0.11976658f, -0.00163789f, -0.22363065f, -0.07416986f, 0.07922628f, -0.01352280f, 
    -0.01935396f, 0.04203293f, -0.03729557f, -0.05555684f, 0.01293864f, 0.00067523f, -0.14774437f, -0.15540603f, 
    0.00384187f, -0.21530005f, -0.50831717f, -0.26074958f, -0.01873545f, 0.04262727f, 0.12204589f, -0.05801968f, 
    -0.01827851f, 0.01999919f, -0.07992999f, 0.02703333f, 0.03385142f, -0.46528167f, -0.56763119f, -0.36723074f, 
    -0.05418324f, 0.11179820f, 0.10846342f, -0.11906834f, -0.07154695f, -0.02266520f, 0.00362363f, -0.08005656f, 
    -0.31985369f, -0.03805496f, 0.07766622f, 0.13508400f, -0.03383598f, -0.04886495f, -0.10422130f, -0.04429467f, 
    -0.04661980f, -0.01937249f, -0.03884836f, -0.25578406f, -0.03690955f, -0.39252973f, -0.31803441f, -0.43416443f, 
    0.07872506f, 0.00375013f, 0.11087562f, 0.05810978f, 0.01018818f, -0.06604671f, -0.02292114f, -0.09848909f, 
    -0.06896146f, 0.06387816f, 0.18352832f, 0.16288425f, -0.13104007f, 0.03600251f, -0.09927420f, 0.22531220f, 
    0.00851308f, 0.00996517f, -0.02093969f, 0.03343438f, 0.31583512f, 0.02089400f, -0.07444978f, -0.13414252f, 
    0.04484585f, 0.11700517f, 0.08033574f, -0.01788061f, 0.12221590f, -0.04247374f, -0.02141774f, 0.02680770f, 
    -0.00020403f, 0.12151932f, 0.21867999f, 0.00107525f, -0.07003141f, -0.10408117f, -0.06438900f, -0.03981904f, 
    -0.03973922f, -0.03304675f, -0.03426057f, -0.04429130f, -0.19552349f, -0.11129180f, -0.19949593f, -0.15006125f, 
    0.06128217f, 0.07421573f, 0.09937909f, 0.05924227f, 0.13971519f, -0.14350657f, -0.12288325f, -0.04611299f, 
    -0.09281985f, -0.42099574f, 0.06569745f, 0.28958139f, 0.11722150f, 0.13197789f, 0.05080632f, 0.03549956f, 
    0.00831622f, 0.09984940f, -0.02377879f, 0.19246148f, 0.14389205f, -0.14168337f, -0.03389616f, -0.10516317f, 
    0.01196011f, 0.07076608f, 0.07493679f, -0.00415485f, -0.19979641f, -0.13591543f, -0.13793901f, -0.38120046f, 
    -0.25570810f, 0.09095441f, 0.03729997f, 0.00329779f, 0.01123076f, -0.05342343f, -0.04304008f, -0.06142914f, 
    -0.00527890f, 0.01871601f, -0.01027623f, 0.00879077f, -0.31596702f, 0.12721491f, 0.14641058f, 0.11603686f, 
    -0.00128351f, -0.04114146f, -0.03974643f, -0.02231886f, -0.10066713f, -0.06562991f, -0.07762153f, -0.06694516f, 
    0.05067959f, -0.08761785f, -0.13261579f, 0.27188405f, 0.14546530f, -0.13535537f, 0.07377275f, 0.09827533f, 
    0.11451343f, 0.02004503f, 0.20569229f, 0.19553833f, 0.00203631f, 0.02984720f, -0.05546485f, -0.06933310f, 
    0.00000255f, -0.09456921f, 0.00036007f, -0.05248185f, 0.05450791f, 0.02658372f, 0.04300326f, -0.24224514f, 
    0.01880414f, -0.19427611f, -0.13047555f, -0.07791874f, -0.02761275f, 0.19218810f, 0.00281324f, 0.19702290f, 
    -0.07491844f, 0.01145537f, -0.02959773f, -0.03693238f, -0.08838467f, -0.50905496f, -0.33916578f, 0.05517023f, 
    0.05139297f, -0.04872860f, 0.00414773f, 0.00242491f, 0.04976100f, -0.00185778f, 0.04358307f, 0.11738719f, 
    -0.41731247f, -0.24911067f, -0.31101230f, 0.06918006f, 0.10269323f, 0.23219651f, 0.06433068f, 0.00027431f, 
    0.02782412f, 0.11546318f, 0.07045776f, 0.01252596f, -0.13497320f, -0.06068205f, 0.12974927f, 0.06199777f, 
    -0.03014156f, 0.02079337f, -0.19614853f, 0.00468875f, -0.16339730f, -0.06086920f, -0.10779305f, -0.07896262f, 
    -0.28259036f, -0.02384719f, -0.02076060f, 0.05844489f, -0.06320842f, -0.01855585f, -0.05544363f, -0.09856186f, 
    -0.08618302f, 0.01060140f, -0.16791439f, -0.04633188f, 0.03358012f, 0.05754645f, -0.02404390f, -0.00329533f, 
    -0.08358508f, 0.00908160f, 0.08625563f, 0.02963818f, -0.08378825f, -0.01717345f, -0.07179758f, -0.05726014f, 
    -0.53735250f, -0.16486588f, -0.03563315f, 0.16485575f, 0.00639330f, 0.09282715f, 0.07928798f, -0.01403795f, 
    0.07237061f, 0.05333992f, 0.03474688f, 0.12560752f, 0.15163867f, -0.05912924f, -0.07056944f, -0.15153231f, 
    -0.12917078f, 0.00162704f, 0.04306089f, -0.10414335f, 0.05395970f, 0.01923003f, 0.14682904f, 0.01660953f, 
    -0.04566123f, -0.00039019f, 0.04042832f, 0.07941138f, -0.04680682f, -0.06335139f, -0.06667504f, -0.09900614f, 
    -0.00283241f, 0.16403700f, -0.03381006f, 0.03217189f, -0.23054256f, -0.07880694f, -0.05581779f, 0.01270946f, 
    0.05185573f, 0.04110631f, -0.00343765f, 0.01553223f, -0.23341846f, 0.02480104f, -0.16930945f, -0.33079731f, 
    -0.24444625f, -0.01887233f, -0.06603000f, 0.03338882f, -0.04857055f, -0.10404418f, -0.00621166f, -0.01913897f, 
    0.03993845f, 0.10513577f, 0.05927583f, 0.06087721f, -0.33045626f, -0.45446825f, -0.52695954f, -0.25415072f, 
    0.10082226f, -0.16008674f, 0.04052005f, -0.20525417f, -0.01187117f, -0.03639461f, 0.08839218f, 0.05054332f, 
    0.09103820f, -0.45103899f, -0.42761022f, -0.12069096f, -0.00912595f, -0.04382336f, 0.01990968f, 0.02209925f, 
    -0.01678002f, 0.11109047f, 0.04719473f, 0.06179303f, -0.15955554f, -0.31324857f, -0.22704455f, 0.01690540f, 
    -0.06431228f, -0.00790638f, -0.08343145f, -0.07256806f, -0.03329258f, 0.04251768f, -0.09206273f, 0.04252306f, 
    0.18796220f, 0.07871186f, -0.17511269f, -0.06968991f, 0.05743562f, 0.04806281f, -0.01673092f, -0.02880691f, 
    0.11265670f, -0.00056112f, -0.03713764f, -0.24993733f, 0.18658206f, -0.09673057f, 0.02936217f, 0.07037322f, 
    -0.07096412f, 0.09891083f, -0.16288407f, -0.11699848f, 0.08579072f, 0.18538964f, 0.02775234f, 0.06645189f, 
    0.15934137f, 0.17421316f, 0.09289759f, 0.10990681f, -0.02326213f, -0.12434934f, -0.17185104f, -0.21623248f, 
    -0.03034559f, 0.05055020f, 0.03084959f, 0.01486800f, 0.10662442f, -0.17901477f, -0.09165770f, -0.00842611f, 
    0.10819212f, 0.10124411f, 0.19998190f, 0.04611469f, -0.10501686f, 0.01705045f, -0.11330809f, -0.15225145f, 
    -0.13948573f, -0.03827696f, 0.18583778f, 0.12598172f, 0.10654964f, 0.01812791f, -0.15316151f, 0.10721014f, 
    -0.17102556f, -0.01111763f, 0.03751935f, -0.03903172f, 0.01384259f, 0.03243791f, -0.04803570f, 0.09403197f, 
    0.02219880f, -0.10030937f, 0.00356074f, -0.07167314f, 0.13136949f, 0.15035594f, 0.09955204f, 0.21644320f, 
    0.19053666f, 0.07690468f, -0.11014318f, -0.01029395f, -0.19018809f, -0.14854738f, 0.06980799f, -0.09237041f, 
    0.12190962f, 0.04384312f, -0.01445977f, 0.09712984f, -0.14362775f, 0.02948621f, 0.03143395f, 0.04664798f, 
    0.04632059f, 0.02808869f, -0.17298198f, 0.02969505f, -0.08474644f, 0.02332800f, 0.06322506f, 0.04208463f, 
    -0.34112519f, -0.08740874f, 0.10719883f, 0.08111604f, -0.00476410f, 0.14066583f, 0.08564654f, 0.02970995f, 
    0.02910364f, -0.02453930f, 0.08655494f, 0.11541969f, -0.12816370f, -0.01597901f, 0.02961477f, 0.07683568f, 
    -0.03333556f, 0.01902529f, 0.04052451f, 0.00221710f, -0.09610494f, 0.00263670f, -0.12995173f, -0.04184584f, 
    0.00570891f, 0.17874429f, -0.02007557f, -0.12630016f, -0.18763269f, -0.06790439f, -0.06213959f, -0.03788858f, 
    0.10428505f, 0.02321287f, -0.02264745f, 0.13211662f, 0.06401785f, -0.01144234f, -0.07858941f, -0.07477167f, 
    0.07656968f, -0.06067643f, 0.07632034f, -0.04781601f, 0.01476410f, 0.04803032f, -0.02286330f, -0.05780581f, 
    -0.11739945f, -0.03249889f, 0.00649575f, 0.07996299f, 0.06837282f, 0.00442101f, -0.05254865f, -0.04323976f, 
    0.06128182f, 0.05622090f, 0.13412762f, 0.10687049f, 0.08024365f, 0.02902010f, 0.04370233f, -0.01646765f, 
    -0.11853991f, 0.04415375f, 0.00367318f, -0.33548111f, -0.00000953f, 0.02012623f, -0.03916740f, -0.05779929f, 
    -0.14452480f, -0.33240849f, 0.09660044f, -0.14333229f, 0.06597575f, -0.16173704f, 0.00926540f, -0.07844260f, 
    -0.03632413f, 0.07631770f, 0.00909477f, 0.07559525f, -0.49615854f, -0.31151646f, 0.02402059f, 0.27312955f, 
    0.03786519f, -0.06635332f, -0.12135519f, -0.09935416f, 0.07572024f, 0.03915502f, -0.05976409f, 0.03238315f, 
    -0.07637694f, 0.07605278f, -0.21185681f, -0.13162620f, 0.04724219f, -0.11450009f, 0.02159941f, 0.17761014f, 
    -0.00188187f, -0.05860276f, -0.09818569f, -0.15634085f, -0.19414216f, 0.43446258f, -0.38435349f, 0.06634907f, 
    -0.08059438f, -0.02211266f, 0.18283716f, 0.04021883f, 0.09358103f, -0.00659268f, -0.02678564f, -0.07914346f, 
    -0.37810215f, -0.27058879f, 0.10892060f, -0.01677931f, 0.04576015f, 0.01441385f, 0.06672355f, 0.08134995f, 
    -0.00450659f, 0.03180069f, 0.03170140f, 0.03657411f, 0.10581974f, 0.27001613f, 0.03766316f, 0.41421700f, 
    -0.05922491f, 0.02465842f, -0.04641359f, -0.03865417f, -0.06856257f, 0.03907468f, 0.09167440f, -0.12054495f, 
    0.02866380f, -0.33649436f, -0.17439239f, -0.05898014f, 0.04933185f, 0.14711697f, 0.17888977f, 0.04167428f, 
    0.01789253f, 0.00851353f, -0.06006050f, -0.11816271f, 0.05856688f, -0.23747811f, 0.02514238f, -0.07156789f, 
    -0.03970782f, 0.13258116f, 0.06720644f, 0.09487751f, 0.01806284f, 0.10128748f, 0.05629016f, 0.11976209f, 
    -0.15697250f, -0.08462186f, -0.12130336f, -0.29578534f, -0.04750790f, 0.04883971f, 0.08597472f, -0.09451479f, 
    -0.05151312f, 0.06307656f, 0.12439165f, 0.00803767f, 0.17690288f, 0.02924429f, 0.24648447f, -0.03953273f, 
    0.11440643f, -0.07094032f, -0.07875997f, -0.16761716f, 0.13877328f, -0.08022554f, -0.10475142f, 0.09993782f, 
    0.09417928f, 0.00201062f, 0.13865712f, 0.02484056f, 0.05138295f, -0.30083877f, -0.11768202f, -0.12138767f, 
    0.08462079f, 0.01418634f, 0.09201536f, 0.13378382f, -0.01554154f, -0.02831561f, 0.13010952f, 0.09130780f, 
    0.26254198f, -0.16343808f, -0.07234466f, 0.13530852f, 0.04331677f, -0.22133467f, 0.02619550f, 0.21773250f, 
    0.05644423f, -0.21035326f, 0.36604479f, -0.63943499f, -0.04978148f, -0.16081573f, -0.01664051f, 0.11498161f, 
    -0.15378819f, 0.08643447f, 0.10243468f, -0.15595953f, 0.25107008f, -0.03800587f, 0.00133160f, -0.00728382f, 
    0.11163104f, -0.04813256f, -0.29977131f, 0.10417955f, 0.09260865f, -0.00322750f, -0.06342727f, 0.02356776f, 
    -0.29478031f, -0.39895135f, 0.12903704f, -0.05480356f, 0.13119689f, -0.08421522f, 0.03047906f, -0.09562113f, 
    0.01827078f, 0.03774527f, -0.04627781f, 0.07987936f, -0.36364919f, -0.07303457f, 0.27852827f, 0.04032368f, 
    0.01479909f, -0.01274489f, -0.04765311f, -0.31445739f, -0.04045400f, -0.05138097f, -0.00642561f, 0.02946816f, 
    -0.15347326f, 0.38358718f, -0.52311349f, -0.27339071f, -0.16005291f, -0.09922130f, 0.09445269f, -0.04743340f, 
    0.11267701f, -0.12589759f, 0.00787764f, 0.01859572f, 0.09767176f, 0.10057785f, -0.14503281f, -0.18747221f, 
    -0.06489047f, -0.02101308f, 0.01771607f, 0.07602885f, -0.01802815f, -0.12679389f, -0.00150040f, -0.12612636f, 
    -0.33144984f, -0.16078860f, -0.11939042f, 0.05673201f, 0.08506376f, -0.10006768f, -0.05878639f, -0.02290353f, 
    0.02449294f, -0.10383896f, 0.00934094f, 0.10165159f, 0.00592984f, 0.07675144f, -0.23132551f, -0.09566166f, 
    0.04867184f, -0.05316999f, 0.04341498f, 0.06412415f, 0.14443369f, -0.05410707f, 0.04474165f, 0.28852171f, 
    0.21317087f, 0.05382064f, 0.21023570f, 0.45013401f, -0.01633452f, -0.04313461f, -0.10293927f, -0.00487261f, 
    -0.12991557f, 0.10443261f, 0.12129633f, 0.03995011f, 0.04429683f, -0.12719204f, 0.11181798f, -0.05618756f, 
    -0.04278884f, -0.04456571f, 0.00969816f, 0.10254268f, -0.00567509f, 0.03794027f, 0.04442354f, 0.19584048f, 
    -0.03657464f, 0.08161257f, 0.15049642f, 0.27913085f, -0.00170003f, 0.04105471f, -0.10740361f, 0.02210370f, 
    0.04656672f, 0.03495875f, 0.04889699f, 0.02967610f, -0.38213885f, 0.05902743f, -0.09251254f, 0.06046316f, 
    -0.02322233f, 0.06641856f, -0.08832493f, 0.13132852f, 0.06461147f, -0.03558574f, 0.06706733f, 0.00902826f, 
    -0.16995348f, 0.03058680f, -0.14004959f, 0.03484875f, 0.06485985f, -0.00394077f, 0.08591862f, 0.07828221f, 
    0.02068232f, 0.08757357f, 0.07100407f, 0.18449454f, 0.33035690f, 0.24823226f, -0.04563982f, 0.08368818f, 
    -0.06719399f, -0.23034485f, 0.01787386f, 0.12679781f, 0.03218323f, 0.03728006f, 0.01814424f, -0.00277513f, 
    -0.16996700f, -0.43661484f, 0.01286968f, -0.17480938f, -0.25871024f, 0.37204039f, -0.38378856f, 0.14755130f, 
    0.13521910f, -0.05598118f, -0.11468360f, -0.03906113f, 0.27095053f, -0.51474220f, 0.17211808f, -0.33038449f, 
    -0.14172588f, 0.17312133f, -0.14380774f, 0.09705591f, -0.02293258f, 0.04189919f, -0.05303127f, 0.04592939f, 
    -0.23389550f, -0.25175321f, -0.06202979f, 0.06300364f, 0.03496713f, 0.12057991f, 0.09590745f, 0.03816029f, 
    0.03043461f, -0.01253578f, 0.02937633f, -0.03658612f, 0.19009969f, 0.25150120f, 0.20674144f, 0.21701245f, 
    -0.15643868f, -0.02451574f, -0.18665682f, -0.16838829f, 0.07126349f, 0.03148756f, 0.01804588f, 0.11166956f, 
    0.20532696f, -0.38542962f, 0.16909476f, -0.41095740f, 0.04197436f, -0.31271926f, -0.01753025f, -0.08714814f, 
    -0.12698770f, -0.08279906f, 0.07028801f, -0.02323109f, 0.16019264f, -0.01113168f, 0.28220949f, 0.23504633f, 
    -0.04414455f, -0.03783292f, -0.05861486f, -0.11992058f, 0.02209744f, 0.10581435f, -0.01236169f, 0.11612470f, 
    -0.04823193f, -0.06318972f, -0.07515688f, 0.16527642f, 0.18459602f, -0.00460304f, 0.08270085f, 0.08947271f, 
    0.09026047f, -0.05315110f, -0.06255343f, -0.16388036f, -0.19075760f, -0.01409825f, -0.31409517f, 0.14608577f, 
    0.06539061f, 0.15960638f, 0.19054632f, 0.07430288f, -0.00172396f, 0.04823270f, 0.03327030f, 0.00821920f, 
    0.15799765f, -0.01017755f, 0.28569448f, -0.39755347f, -0.05470505f, -0.08536685f, 0.06126788f, 0.06570569f, 
    -0.19414778f, 0.06739829f, 0.04197413f, 0.15168391f, 0.01636268f, -0.05796498f, -0.09122930f, 0.23964094f, 
    0.03684257f, -0.00758961f, 0.09271319f, -0.02933174f, 0.09800988f, 0.08086719f, 0.01043862f, 0.09714533f, 
    0.19819745f, 0.21974416f, 0.06251806f, -0.13086008f, -0.05254861f, -0.09960821f, 0.10663817f, 0.06449652f, 
    0.03783990f, 0.05393539f, -0.02920409f, -0.04541626f, 0.17476113f, 0.01247409f, -0.13154595f, -0.45146424f, 
    -0.30992979f, -0.00440679f, -0.07542903f, 0.13651301f, 0.04845630f, 0.01928466f, -0.02062148f, 0.00816241f, 
    0.04816920f, 0.45673943f, 0.26795644f, -0.31732929f, 0.02376307f, -0.25437760f, -0.18097366f, -0.17734697f, 
    -0.07384875f, -0.00757113f, 0.02944109f, -0.03925776f, 0.10114845f, -0.45783982f, 0.00012914f, -0.34890208f, 
    0.06806329f, 0.01776673f, -0.07348654f, -0.16314191f, -0.06148836f, -0.06203448f, -0.04106543f, 0.04543113f, 
    0.02558295f, -0.16086559f, 0.00936537f, -0.08513630f, 0.14984457f, 0.02889101f, 0.09456874f, 0.02337407f, 
    0.23235309f, 0.14772801f, -0.05711716f, 0.04067697f, -0.28898963f, -0.18377341f, 0.04806358f, -0.09692119f, 
    -0.13092211f, 0.10645571f, -0.19387475f, 0.01292201f, 0.13752985f, 0.02927127f, -0.05746982f, 0.11236309f, 
    -0.17912844f, 0.17368437f, 0.12291078f, -0.21223950f, 0.07995409f, -0.22107902f, 0.07225136f, 0.04885233f, 
    0.01980884f, 0.01986604f, 0.01599236f, -0.05371247f, -0.06730493f, -0.29979208f, 0.26168564f, -0.14551780f, 
    0.14255321f, -0.01812698f, -0.08024037f, 0.01376497f, -0.18950634f, -0.00429751f, 0.05451595f, -0.06015892f, 
    -0.05464031f, -0.10635208f, 0.02694147f, -0.20048892f, 0.07049242f, 0.06024709f, 0.12077472f, 0.00776422f, 
    0.03190122f, 0.04840588f, -0.10094662f, -0.15234320f, 0.00319526f, 0.08754700f, 0.19076945f, -0.09044436f, 
    -0.02031221f, 0.02051106f, 0.09347136f, -0.02712329f, 0.02251320f, 0.06201543f, 0.15810055f, 0.12228842f, 
    0.14265282f, -0.16629468f, 0.03075824f, -0.11418671f, -0.04603250f, 0.07208929f, 0.02505918f, 0.09375531f, 
    0.06831492f, 0.19176652f, 0.03362826f, -0.15652823f, -0.30922821f, 0.00996808f, 0.25687620f, -0.24842276f, 
    -0.14021504f, -0.10909601f, 0.12294108f, -0.00829564f, 0.03477644f, 0.03463893f, 0.00858147f, -0.00209043f, 
    -0.14275043f, -0.02616426f, 0.05547750f, -0.08932770f, -0.10204791f, -0.15600331f, -0.04007019f, 0.16993541f, 
    -0.00780460f, -0.03402442f, 0.04712050f, 0.02034017f, -0.25744855f, -0.01213234f, 0.09910494f, -0.20489027f, 
    -0.16161227f, 0.05718320f, -0.00723060f, 0.11988073f, 0.09683769f, 0.02534675f, -0.00724067f, -0.02688220f, 
    -0.19573753f, 0.08159750f, -0.14001888f, 0.15895496f, 0.11545839f, 0.07304676f, -0.06147794f, 0.09927205f, 
    0.09665920f, 0.06893823f, -0.02226766f, -0.04722420f, 0.45160758f, -0.00935140f, -0.01462210f, -0.03121086f, 
    0.07495324f, 0.03462173f, -0.17221412f, 0.08442088f, 0.09199104f, -0.08815367f, -0.08344375f, -0.11815527f, 
    0.20549904f, -0.51924902f, -0.38014317f, 0.02223997f, -0.05465858f, 0.05982952f, 0.01608557f, -0.09408495f, 
    -0.02442373f, -0.03235075f, -0.00876116f, -0.04215442f, 0.10252380f, -0.24196444f, 0.15489529f, -0.35635397f, 
    -0.23275466f, 0.04445178f, -0.12461359f, -0.17655481f, 0.18422063f, -0.00993703f, -0.03354479f, -0.01834363f, 
    -0.01737706f, 0.44926232f, -0.68639022f, -0.01216288f, 0.03439951f, -0.03266937f, 0.08046276f, -0.11621041f, 
    0.03527173f, -0.07324000f, -0.13215742f, 0.16371891f, 0.15143542f, -0.12565479f, 0.04642195f, -0.01492207f, 
    0.02359891f, 0.00477171f, 0.01021067f, -0.10568936f, 0.00455566f, -0.07405676f, -0.10129724f, -0.03662966f, 
    -0.32568359f, -0.51680630f, 0.20232533f, 0.18146004f, 0.08576329f, -0.05550344f, -0.20629191f, -0.10988038f, 
    -0.06608367f, -0.13221127f, -0.10407808f, -0.06327575f, -0.03509174f, 0.15111393f, -0.26067743f, -0.35435855f, 
    0.05856971f, 0.04459027f, 0.07386088f, -0.10749906f, 0.08428123f, -0.07745577f, -0.12779166f, 0.09628968f, 
    -0.17496526f, 0.00414223f, -0.27478889f, -0.36356661f, -0.00099005f, -0.21823379f, 0.24403267f, -0.00531482f, 
    -0.16253240f, 0.00435706f, -0.05213114f, -0.07298716f, -0.13569839f, -0.06691194f, -0.06187368f, 0.00717087f, 
    0.02016491f, 0.09001934f, 0.13218693f, 0.13270509f, 0.00611269f, 0.02310780f, -0.09709863f, -0.03689252f, 
    -0.32114580f, 0.12107747f, 0.08532964f, 0.14991678f, 0.15416309f, 0.03144361f, -0.07639974f, 0.00822597f, 
    -0.09485094f, -0.06005676f, 0.08383134f, -0.03172357f, -0.06438314f, -0.02588721f, -0.18314296f, -0.08507721f, 
    0.11142305f, 0.05803078f, 0.10919992f, 0.01030114f, 0.08213177f, 0.02916328f, -0.18817452f, -0.11998397f, 
    0.04071857f, -0.10503190f, -0.14308140f, -0.18257183f, 0.07120620f, 0.02518651f, 0.11514607f, -0.05122671f, 
    -0.07522611f, 0.00334251f, -0.10990375f, -0.02765177f, 0.33625796f, -0.54234874f, 0.05423102f, -0.13188738f, 
    0.31835750f, 0.10813470f, 0.17300092f, 0.06200294f, 0.00945747f, -0.05669588f, -0.04167178f, -0.10179675f, 
    -0.55517119f, 0.24424003f, -0.05105595f, 0.02431127f, 0.00616116f, 0.00233103f, 0.16988456f, 0.07786528f, 
    -0.06117968f, 0.08608930f, 0.01363464f, 0.00155167f, -0.67263919f, 0.27483067f, -0.12905076f, -0.08050406f, 
    -0.01403563f, 0.14841051f, 0.11645772f, 0.04681926f, -0.06331884f, 0.04881839f, -0.10151190f, 0.12763827f, 
    0.06276403f, -0.11927877f, 0.50912333f, 0.01018103f, -0.21059477f, 0.00279669f, 0.09964350f, 0.01971974f, 
    -0.04908923f, 0.16449790f, 0.13346583f, -0.06119993f, -0.03921682f, -0.28038147f, 0.09702902f, -0.00021569f, 
    -0.09493737f, 0.03277986f, 0.07205343f, -0.04825427f, -0.10589739f, -0.05611509f, 0.01075210f, -0.08766679f, 
    -0.00472543f, -0.26948705f, 0.20369346f, 0.35077596f, -0.07679548f, 0.19027770f, -0.09214476f, -0.00972222f, 
    0.05942106f, 0.02169334f, -0.06979489f, 0.02322304f, 0.06129903f, 0.32287693f, 0.12385760f, -0.17827235f, 
    -0.05812049f, 0.00231730f, -0.01873979f, -0.14623715f, -0.07491244f, 0.03642222f, -0.07049784f, 0.03355623f, 
    -0.14495775f, 0.07095889f, -0.27321079f, -0.05390734f, -0.27201211f, -0.08121621f, 0.02633715f, 0.13377663f, 
    0.01088236f, 0.19697736f, 0.04561698f, 0.04665111f, -0.05434030f, -0.03119977f, -0.03175721f, -0.00725865f, 
    -0.14706118f, 0.07908686f, -0.08040429f, 0.00580176f, -0.11388525f, -0.04799169f, -0.19581382f, -0.20088218f, 
    -0.15165871f, 0.09471174f, -0.15054262f, 0.04326789f, 0.08210543f, 0.06669250f, -0.02663571f, -0.10360366f, 
    -0.02470298f, -0.14121640f, -0.41986135f, -0.38520089f, -0.01261858f, 0.18415111f, 0.08548634f, 0.18503962f, 
    -0.06237072f, 0.07737701f, -0.04577617f, 0.09601532f, -0.18218918f, 0.12263215f, 0.08492994f, 0.03680365f, 
    0.04068260f, 0.06701935f, 0.07782470f, -0.00293702f, 0.03865021f, -0.14121968f, -0.09477147f, 0.07382644f, 
    0.02206937f, 0.07779380f, -0.12962632f, -0.21327275f, -0.17786717f, 0.27669409f, 0.20782420f, 0.06125146f, 
    -0.04437356f, 0.01864362f, -0.01416219f, 0.00115412f, -0.02530577f, 0.05556067f, 0.12522635f, -0.05252264f, 
    -0.00525390f, 0.04497666f, 0.12024982f, 0.23691030f, 0.00113858f, 0.03025210f, 0.03915888f, -0.05913901f, 
    0.03200555f, 0.04742700f, 0.09594484f, -0.12567106f, -0.03230346f, 0.37227029f, 0.25121713f, 0.33259168f, 
    -0.17608540f, 0.01819023f, 0.04075837f, 0.00106128f, -0.14077860f, 0.05659126f, 0.12460320f, 0.21336617f, 
    -0.40213260f, 0.49588016f, -0.13167091f, -0.03581680f, 0.02071045f, 0.23489448f, 0.03709168f, 0.10808700f, 
    0.02734046f, -0.15816440f, -0.21363246f, -0.18210773f, -0.08674533f, 0.08588378f, 0.09793048f, -0.27977350f, 
    -0.14749506f, 0.15173160f, 0.15786128f, 0.00891021f, 0.08487733f, 0.00226675f, 0.08372927f, -0.14202423f, 
    0.11938420f, -0.04127366f, 0.11080535f, -0.11359424f, -0.16086596f, 0.00446945f, 0.10816632f, -0.10295308f, 
    -0.06184582f, 0.04010624f, 0.21699436f, 0.22284167f, 0.02413544f, -0.01187034f, 0.02925062f, 0.25745371f, 
    0.00185640f, 0.07242518f, 0.16510251f, -0.08960473f, -0.10670669f, 0.13035935f, 0.13130952f, 0.16376668f, 
    -0.30094865f, 0.43774736f, -0.15999983f, 0.10505145f, -0.06606491f, 0.03653475f, 0.02607789f, -0.01179443f, 
    0.01075663f, 0.03938384f, 0.05711838f, 0.00964415f, 0.11227603f, 0.15736368f, -0.00530178f, -0.07696775f, 
    -0.08023953f, -0.10591204f, -0.04144327f, -0.02163968f, -0.19213642f, -0.13619143f, -0.08185381f, -0.34264600f, 
    -0.40094277f, 0.40004620f, -0.40773499f, -0.00094069f, -0.03470935f, 0.03965247f, -0.07763095f, -0.00530120f, 
    0.09403712f, -0.05865019f, -0.01507917f, 0.01131711f, -0.16219643f, 0.19786306f, 0.01435889f, 0.11975290f, 
    0.00076189f, 0.01513922f, -0.00832747f, 0.03302774f, -0.08802480f, -0.11448981f, -0.13910988f, -0.21250257f, 
    -0.07769827f, -0.21111912f, -0.16230394f, -0.02772534f, -0.04476285f, 0.05355344f, 0.04901520f, 0.00407471f, 
    -0.11421772f, 0.08480481f, -0.02494873f, -0.19507962f, 0.08116895f, -0.01960094f, -0.21869531f, 0.03406156f, 
    -0.09185363f, 0.10458763f, -0.24884698f, 0.11162309f, 0.03861409f, 0.04732717f, -0.03190118f, -0.12163649f, 
    -0.10115564f, -0.11550046f, 0.02777474f, -0.08293173f, -0.00708375f, -0.08866689f, -0.06292254f, 0.10187087f, 
    -0.19740367f, -0.29359257f, -0.25528574f, -0.17323895f, -0.33473772f, 0.10823297f, -0.29964852f, 0.02726698f, 
    0.06598869f, 0.00244591f, -0.06916531f, -0.03230939f, -0.20677552f, 0.06107236f, -0.10701643f, 0.01662740f, 
    0.15652691f, 0.00973359f, 0.33273217f, 0.03518584f, 0.06908898f, -0.12155125f, 0.00536044f, 0.09293012f, 
    -0.14688429f, 0.16947469f, 0.05268345f, 0.06844661f, -0.04966602f, 0.21331100f, 0.18704306f, -0.05219137f, 
    -0.04443558f, 0.10338237f, -0.18953502f, 0.00354474f, 0.08201198f, 0.00346572f, 0.02664190f, -0.08327452f, 
    -0.24700628f, -0.19786416f, -0.07925247f, -0.19940495f, -0.18052475f, 0.04991289f, -0.12368127f, -0.05385428f, 
    0.00756030f, -0.01022744f, -0.01159627f, 0.02435734f, -0.28644249f, 0.14848492f, -0.01862711f, -0.18305050f, 
    0.10814891f, 0.08176263f, -0.07290165f, 0.10199888f, -0.12875809f, 0.06346067f, -0.09157843f, -0.13399455f, 
    -0.29594928f, 0.19506137f, 0.15153857f, 0.07902849f, -0.01742735f, -0.18309879f, 0.05029916f, 0.15164168f, 
    0.06696039f, 0.08929880f, 0.00506075f, -0.18980576f, -0.23690592f, 0.27150935f, -0.25096667f, -0.07916546f, 
    0.00062965f, -0.05008557f, -0.02576921f, -0.01183318f, -0.10243361f, -0.16440736f, -0.24752082f, -0.32915786f, 
    -0.05493058f, 0.16717146f, -0.25838783f, -0.10380032f, -0.15714073f, -0.10154395f, -0.00369343f, -0.00935694f, 
    -0.07722887f, 0.14799905f, -0.09253553f, -0.01873735f, -0.11669341f, -0.00244990f, -0.09892085f, 0.01714784f, 
    -0.11625424f, -0.11076534f, -0.09331697f, 0.01036466f, -0.07186450f, -0.04586713f, -0.02824749f, -0.03196383f, 
    -0.03960655f, 0.07207900f, 0.19384539f, -0.13310008f, -0.06695570f, 0.09904379f, 0.06235674f, 0.05851757f, 
    0.10919891f, -0.02472114f, 0.15713324f, 0.04022689f, -0.10666380f, 0.14998786f, -0.16334563f, -0.15320066f, 
    -0.10507290f, 0.07413153f, 0.02509150f, -0.01469617f, -0.07039185f, -0.18487014f, -0.12070808f, -0.16527453f, 
    -0.29937997f, -0.07248469f, 0.08859773f, -0.06767069f, 0.05563683f, -0.18083875f, 0.03739262f, -0.04706013f, 
    -0.11531188f, 0.07859469f, 0.00148205f, -0.04858123f, 0.03294673f, -0.15012279f, 0.14987551f, 0.07764831f, 
    -0.10332877f, -0.05497297f, 0.05752959f, 0.07336070f, 0.03152759f, 0.10746395f, 0.05305165f, 0.05904907f, 
    0.19508320f, -0.11094791f, 0.14588362f, -0.08799306f, -0.05467525f, -0.05761877f, 0.01738157f, 0.05724407f, 
    0.17575392f, -0.04735595f, 0.15765023f, -0.08493247f, -0.25107527f, 0.03510685f, 0.16522159f, 0.04335718f, 
    -0.01097408f, -0.05495032f, 0.05160621f, -0.08769134f, 0.15196034f, -0.09558684f, -0.13730519f, 0.09148625f, 
    -0.07319838f, 0.05661956f, -0.25186035f, -0.03072361f, -0.11496532f, -0.13825357f, -0.01881833f, -0.12867984f, 
    -0.17060119f, -0.08485654f, 0.01306170f, -0.04748315f, 0.06624847f, -0.28020442f, 0.11300171f, 0.05341449f, 
    -0.06211774f, 0.06505288f, 0.03538534f, -0.03209465f, -0.09546721f, 0.08111385f, 0.26120961f, -0.00242465f, 
    0.03479879f, -0.25027108f, 0.14378844f, 0.21955673f, -0.13107127f, -0.01618893f, -0.08406918f, 0.04576270f, 
    0.03046182f, -0.13206592f, 0.06461108f, 0.14570551f, -0.24183069f, 0.42735335f, 0.07646348f, 0.29693827f, 
    -0.04603726f, 0.00185108f, 0.00719095f, -0.07146996f, 0.03119082f, -0.12435023f, 0.08039537f, 0.10824412f, 
    0.03091610f, 0.07574866f, 0.04995678f, 0.05744874f, -0.05638308f, -0.18491466f, 0.07420384f, -0.06830671f, 
    -0.11274447f, 0.08406097f, 0.10641555f, 0.19984053f, -0.06576045f, 0.32616675f, 0.09432463f, -0.06283055f, 
    0.02890157f, -0.07017647f, -0.03284322f, 0.02276411f, -0.19399354f, -0.11007590f, -0.35888809f, -0.29060367f, 
    0.00017835f, -0.16452673f, -0.28747630f, -0.00820624f, -0.08129597f, -0.08161756f, -0.07928948f, -0.15752770f, 
    -0.34938803f, -0.02217298f, 0.04984595f, -0.00493671f, -0.10647209f, -0.19340536f, -0.20770748f, -0.16225031f, 
    -0.10715207f, -0.24457024f, -0.04683922f, -0.08679330f, 0.00222408f, 0.05042446f, 0.06322266f, -0.01569203f, 
    -0.30283010f, 0.03019915f, -0.03121454f, 0.00732851f, -0.09491736f, 0.01903705f, -0.03440290f, 0.03341471f, 
    -0.00256506f, 0.13070723f, 0.12850490f, 0.09497695f, 0.10534716f, -0.52104926f, -0.00867983f, 0.09230857f, 
    -0.04340040f, 0.09334181f, 0.04721922f, 0.19352871f, -0.01087578f, -0.06047670f, 0.04698527f, 0.01215434f, 
    0.11237245f, -0.04758089f, 0.07304380f, 0.05775861f, -0.05220719f, 0.12462837f, 0.04023845f, 0.10150662f, 
    -0.02554341f, 0.05648899f, -0.04997321f, -0.04542607f, -0.15220290f, -0.17464420f, 0.01082625f, -0.04052189f, 
    -0.00200032f, 0.15654674f, 0.02481029f, 0.07420789f, -0.09927686f, 0.03515498f, 0.07367516f, 0.15516573f, 
    -0.09395273f, -0.19725503f, -0.04631491f, -0.05331042f, 0.01539234f, -0.00084412f, 0.11455963f, -0.13102522f, 
    0.02837618f, -0.02050436f, 0.19613642f, 0.01844505f, -0.10933636f, 0.18878625f, -0.03772748f, 0.13524632f, 
    0.13116638f, -0.11666193f, 0.01234253f, -0.04927846f, -0.05315600f, -0.17183298f, 0.00124515f, -0.06486996f, 
    0.14911193f, 0.10425640f, -0.36851710f, 0.22430749f, -0.19495519f, -0.31843314f, 0.06320485f, -0.04003322f, 
    0.06106029f, 0.16349331f, -0.31656218f, 0.07581276f, 0.00217930f, 0.14212747f, -0.40643972f, -0.13191126f, 
    0.03652946f, 0.04008681f, 0.08871593f, -0.17068753f, 0.09150238f, 0.06568232f, -0.08474968f, 0.20310013f, 
    -0.27708009f, -0.10282558f, 0.20126516f, -0.18055059f, 0.01222649f, 0.18918714f, -0.04952049f, 0.27115571f, 
    -0.03765725f, -0.07796802f, -0.02470692f, -0.03137846f, -0.19611467f, -0.31627205f, 0.10076225f, 0.16348100f, 
    -0.07075939f, -0.35021228f, 0.27467802f, 0.20883916f, -0.12517224f, 0.06657472f, -0.12780863f, -0.07704057f, 
    0.09301257f, -0.07976431f, -0.03466985f, 0.40916812f, 0.00424688f, 0.00002104f, -0.00846541f, 0.05206655f, 
    -0.01696634f, 0.18307953f, -0.01818552f, 0.06665028f, -0.00315683f, -0.26966518f, 0.10983627f, 0.04176399f, 
    -0.11243570f, -0.03445593f, 0.04091808f, -0.09924190f, 0.02097315f, -0.06711524f, 0.05667872f, -0.00165900f, 
    0.00939610f, 0.01100143f, 0.15132467f, 0.08447220f, -0.05199534f, -0.05352838f, -0.04426894f, -0.04063142f, 
    0.00999644f, -0.06482285f, -0.02361372f, 0.14384870f, -0.17747332f, 0.07376989f, 0.30035767f, 0.03357730f, 
    -0.12904070f, 0.10434110f, 0.08775316f, 0.02419273f, -0.12383693f, -0.07088923f, 0.10284232f, -0.13971764f, 
    -0.00977510f, 0.02781700f, 0.11145258f, 0.26022664f, -0.12223988f, -0.00527466f, 0.01945879f, 0.01770264f, 
    -0.03186302f, 0.00038691f, 0.18232323f, 0.02340367f, -0.48950762f, -0.25186697f, -0.16825433f, 0.03896273f, 
    -0.05983763f, -0.00867879f, 0.05332392f, 0.27801025f, 0.05133877f, -0.07156479f, 0.08354095f, -0.05324410f, 
    -0.29184750f, -0.20061919f, -0.37002721f, 0.07480692f, 0.09234720f, -0.23422959f, 0.13391463f, -0.33245409f, 
    -0.06593490f, 0.10079045f, 0.05167471f, 0.03026301f, -0.12626421f, -0.21894273f, -0.22424473f, 0.23794466f, 
    0.19273150f, -0.02958457f, 0.05758115f, -0.08528062f, 0.00941805f, 0.02943557f, 0.22561027f, -0.10433297f, 
    0.36829367f, -0.04552074f, 0.32413706f, 0.02254421f, -0.03881009f, 0.13099055f, -0.19240700f, 0.03725569f, 
    -0.02845333f, 0.01942776f, 0.10708916f, 0.05133006f, 0.00910733f, -0.14450207f, 0.46945828f, -0.10243025f, 
    0.13451608f, -0.01907609f, -0.01143519f, -0.10860035f, 0.00761050f, 0.05961909f, 0.07958508f, 0.00232089f, 
    -0.13820316f, -0.19555962f, 0.32227558f, -0.07158192f, -0.07715351f, 0.07804129f, -0.20750886f, -0.04252099f, 
    0.08704145f, -0.00050502f, -0.04776827f, 0.05012089f, -0.32814276f, -0.29449540f, -0.22273140f, 0.20115574f, 
    0.06524596f, -0.11737254f, -0.04747814f, -0.03818002f, -0.09645992f, -0.14012034f, 0.07660306f, 0.00353841f, 
    0.25374508f, 0.22020918f, 0.09346171f, 0.02100981f, -0.09453229f, 0.00814418f, -0.02047592f, 0.02780732f, 
    0.01161215f, -0.14961888f, -0.08386919f, -0.13445859f, 0.02007135f, 0.19795500f, 0.01691212f, -0.01097363f, 
    -0.09079104f, -0.13597080f, 0.12008449f, -0.00882879f, 0.05825166f, 0.03891428f, 0.04303435f, -0.03389577f, 
    -0.23067284f, 0.11052576f, -0.15968698f, -0.07113707f, 0.06745615f, -0.07243939f, -0.03615658f, -0.05067302f, 
    -0.03530615f, 0.10201808f, 0.12793413f, 0.09329881f, -0.11932454f, 0.11917357f, -0.30054882f, 0.05231401f, 
    0.04372361f, -0.02339652f, 0.07088816f, -0.10017008f, 0.01750644f, -0.01430638f, -0.00539437f, -0.18234472f, 
    0.04211386f, -0.07007176f, -0.09517109f, -0.31937087f, 0.04242227f, -0.08046787f, -0.03234479f, 0.02005565f, 
    -0.03834995f, 0.09026303f, -0.00023468f, -0.11244126f, -0.13756076f, -0.01991656f, -0.07114442f, 0.03122247f, 
    0.18127652f, 0.28119436f, -0.11712902f, 0.09246695f, 0.06209895f, 0.03075913f, -0.09334649f, -0.07610761f, 
    -0.48145726f, -0.16735592f, 0.17078696f, 0.17709303f, -0.06904925f, -0.01248186f, -0.00202670f, 0.21739772f, 
    -0.14821130f, -0.10863557f, -0.13050009f, -0.00737440f, -0.17456664f, -0.05582871f, 0.03248511f, 0.45483524f, 
    -0.03673595f, -0.04310120f, 0.06668434f, 0.08201586f, -0.05862242f, 0.05222576f, 0.10705636f, -0.03333077f, 
    -0.48516899f, -0.14029954f, 0.00611945f, 0.11542796f, -0.02439302f, -0.00474692f, -0.00656513f, 0.08264365f, 
    -0.03486495f, 0.10146737f, 0.00022024f, 0.02749990f, 0.14913975f, -0.22564054f, 0.00205521f, -0.20021464f, 
    0.05306185f, 0.02999841f, 0.04722572f, 0.04521545f, 0.02643404f, 0.10822243f, 0.00878349f, 0.05981861f, 
    0.16824831f, -0.32741570f, 0.34993878f, 0.01057893f, 0.03033372f, 0.04317051f, 0.17216864f, 0.00969650f, 
    -0.08975966f, 0.04952699f, -0.05156776f, 0.04812042f, 0.07152262f, -0.00392041f, 0.10801022f, 0.00770017f, 
    -0.01279265f, 0.01079846f, 0.06663726f, 0.01766098f, -0.03858570f, 0.08365345f, -0.09006755f, 0.02079314f, 
    -0.11023514f, -0.44806841f, 0.30783004f, 0.33330208f, 0.31983688f, 0.02641184f, 0.00184479f, -0.10434741f, 
    0.03576578f, -0.11398195f, 0.12704553f, -0.10409571f, 0.16925859f, 0.12364836f, 0.00787403f, 0.02119626f, 
    0.05961857f, -0.02143129f, 0.06656746f, 0.12224751f, 0.07896130f, 0.24771655f, 0.09153241f, 0.03055693f, 
    -0.52557421f, 0.03143534f, -0.33671108f, 0.15052693f, 0.07891214f, -0.09017728f, 0.02074284f, -0.01733266f, 
    -0.08601714f, 0.01898223f, 0.10941125f, 0.20654096f, -0.12047272f, -0.01272764f, -0.12530810f, 0.09898474f, 
    0.01207041f, 0.00202156f, 0.11276579f, 0.16552818f, -0.03296451f, 0.00008779f, 0.09428283f, 0.06704966f, 
    0.05543346f, -0.12185889f, 0.01323411f, -0.25821379f, -0.03234248f, 0.03056850f, 0.08367890f, 0.01484963f, 
    -0.04307606f, -0.01873311f, 0.10491365f, 0.10107587f, -0.03051305f, -0.22982357f, -0.05773057f, -0.00114794f, 
    -0.12341359f, -0.01421146f, -0.09904739f, 0.07517483f, -0.00236993f, -0.02198123f, 0.06977748f, 0.05676441f, 
    0.12464367f, 0.01004966f, 0.12420966f, -0.18375364f, -0.01252944f, 0.01803998f, 0.05557290f, 0.10354469f, 
    0.07245757f, 0.05667333f, 0.07163057f, -0.01493371f, -0.45318353f, -0.32241118f, -0.10669257f, 0.12532634f, 
    -0.06770034f, -0.19258174f, -0.07178114f, -0.02141241f, 0.06711121f, -0.04270870f, 0.03248735f, 0.03848366f, 
    -0.79580903f, 0.41747713f, -0.21626171f, 0.36309507f, 0.07861763f, -0.04166602f, 0.08932774f, -0.19751392f, 
    -0.11111571f, -0.06037256f, -0.05677750f, -0.04110548f, -0.29903829f, 0.25133029f, -0.07741339f, 0.18539107f, 
    -0.00371989f, 0.00091452f, 0.15279037f, -0.04850321f, 0.05896593f, 0.07081851f, 0.05538067f, 0.20085494f, 
    0.25636354f, 0.14425032f, -0.00653900f, -0.06214043f, -0.05467771f, 0.03951679f, -0.03939178f, -0.02549883f, 
    -0.03234686f, 0.04916396f, -0.06332103f, -0.03792838f, -0.17882709f, -0.04566142f, -0.00772506f, 0.01595127f, 
    0.08320171f, -0.10507747f, 0.03512700f, -0.03497956f, 0.03597616f, 0.04740481f, -0.07137378f, -0.09777201f, 
    0.12818849f, -0.25140131f, 0.10646461f, -0.24180883f, 0.00065721f, 0.07562103f, 0.10102259f, -0.02771339f, 
    -0.17033981f, -0.03698948f, 0.05297581f, -0.04000546f, -0.20734935f, -0.02672529f, -0.15603034f, 0.04676345f, 
    0.02423986f, -0.11261592f, -0.04278013f, 0.01135455f, -0.01487107f, 0.01830312f, 0.02315947f, 0.03123684f, 
    0.25092852f, 0.05618732f, 0.28274462f, -0.04024648f, -0.04806563f, 0.09886269f, -0.00564193f, 0.03467430f, 
    -0.07917767f, -0.06450299f, 0.05468172f, 0.01389246f, 0.23481865f, 0.06731068f, 0.22570288f, -0.02062861f, 
    -0.06465736f, -0.02960236f, -0.08759141f, 0.01171000f, -0.11290473f, -0.03179227f, -0.01960771f, -0.08007431f, 
    -0.03092011f, -0.03753053f, -0.25544757f, 0.21255623f, 0.08740287f, -0.28683984f, -0.00084812f, 0.11848588f, 
    -0.21285637f, 0.12506551f, -0.09301557f, -0.04824350f, 0.14634027f, -0.08376338f, 0.01509794f, 0.06733360f, 
    -0.05116631f, -0.00095510f, 0.01748770f, 0.05671053f, 0.10026809f, 0.14084388f, 0.03775830f, 0.08430819f, 
    -0.07252594f, -0.01691274f, -0.06184281f, -0.02211369f, -0.01429292f, -0.13317187f, -0.26458344f, -0.03765856f, 
    -0.00423979f, -0.02537730f, -0.00577104f, 0.05637534f, -0.09522719f, 0.08564342f, 0.02759350f, -0.08475801f, 
    -0.15875286f, -0.18212871f, -0.14945915f, -0.07069150f, -0.04449961f, -0.01882610f, -0.11233626f, -0.14677747f, 
    -0.47310069f, -0.23854011f, 0.13825126f, -0.29546809f, 0.02675268f, -0.05298202f, 0.06081731f, 0.06229400f, 
    -0.07594753f, -0.01337281f, -0.05844050f, -0.10242176f, 0.04496050f, 0.01793854f, -0.10686459f, 0.16313428f, 
    -0.03168728f, -0.03436931f, 0.11949176f, 0.06142813f, -0.03271192f, 0.04606494f, -0.03357979f, 0.04031607f, 
    0.05951121f, 0.04473505f, 0.00564678f, -0.04273057f, -0.01895032f, -0.06463222f, 0.05801608f, 0.04212223f, 
    -0.08041709f, 0.08101638f, 0.07067916f, -0.12263564f, -0.36100057f, 0.16197136f, -0.13193537f, -0.09224303f, 
    0.01877473f, 0.04836509f, 0.16193971f, -0.03638937f, -0.00483711f, -0.06381490f, -0.01652661f, 0.00492447f, 
    0.18634006f, -0.13485780f, 0.29779801f, -0.15107952f, -0.09288169f, 0.07396707f, -0.16003738f, 0.20432276f, 
    -0.11750334f, 0.21430382f, -0.04029502f, -0.12892269f, -0.49858916f, 0.14648610f, -0.29069522f, 0.14042819f, 
    0.05296392f, 0.08777604f, 0.07277821f, 0.07894477f, 0.03300909f, 0.05085519f, 0.16681442f, -0.02639633f, 
    -0.06797674f, 0.09272139f, 0.13356413f, 0.16066137f, 0.00616974f, 0.11006908f, -0.04547001f, -0.09968440f, 
    -0.13048166f, -0.02390962f, 0.04757597f, -0.17656894f, -0.01830025f, 0.01616829f, 0.16649587f, -0.09996665f, 
    -0.02556560f, 0.07658726f, -0.07845846f, 0.00698601f, -0.02426610f, 0.06868079f, 0.15953192f, -0.04698684f, 
    -0.25933310f, 0.11876098f, -0.03322556f, 0.10196434f, -0.09450600f, -0.00723287f, 0.15313347f, 0.09134551f, 
    -0.10996895f, -0.04179030f, 0.06146105f, -0.07282455f, -0.04769107f, -0.17921652f, -0.31835181f, -0.15593491f, 
    -0.06958435f, -0.33659872f, 0.13963933f, -0.16462506f, 0.02153874f, 0.05503457f, -0.06355015f, -0.09560403f, 
    -0.02375120f, -0.13847850f, -0.05989334f, 0.16846603f, -0.02929952f, -0.09743148f, -0.02099516f, -0.23882574f, 
    -0.03140291f, -0.02735467f, -0.00791131f, -0.10426576f, -0.05978758f, 0.02425102f, 0.14040321f, 0.05129121f, 
    -0.10194959f, -0.03506986f, -0.00093275f, -0.18714386f, 0.06525694f, -0.01947991f, -0.12019224f, -0.02003649f, 
    -0.03149118f, -0.09571753f, 0.14414839f, -0.29725054f, -0.08186287f, 0.02790920f, -0.07965262f, 0.16818166f, 
    0.04856489f, 0.09672232f, 0.15977144f, 0.01865869f, 0.09198289f, 0.14005485f, 0.10915939f, -0.01746496f, 
    -0.06285696f, -0.01456118f, -0.00665614f, -0.00287241f, -0.05276069f, 0.00794086f, -0.02571602f, -0.01680639f, 
    0.12459208f, 0.22124143f, 0.03605008f, 0.02392601f, -0.05691915f, -0.23569599f, 0.01386441f, -0.03973728f, 
    -0.03878322f, -0.05671176f, -0.09702045f, -0.01801137f, -0.06508657f, 0.31843820f, -0.27885482f, 0.21144541f, 
    -0.06873734f, -0.07555234f, 0.21693069f, -0.14085165f, 0.07062153f, 0.07570203f, 0.01332007f, -0.00382448f, 
    0.39081576f, -0.45613948f, 0.63008046f, 0.10881530f, 0.15884823f, -0.08247247f, 0.07138890f, 0.02340402f, 
    0.00124924f, -0.06306387f, 0.07495175f, -0.01233625f, 0.07652539f, -0.02079486f, -0.12134770f, 0.10602234f, 
    0.02961541f, -0.12341531f, -0.06118511f, -0.00298394f, -0.20936786f, -0.06655204f, 0.01001500f, -0.28268304f, 
    -0.15507951f, 0.06586228f, -0.24214472f, 0.03819300f, 0.00469781f, 0.07645145f, -0.01111821f, -0.02683745f, 
    0.03267829f, 0.14272253f, -0.01265928f, -0.11266347f, -0.05000350f, 0.01418543f, 0.41745746f, 0.23274857f, 
    -0.18687777f, 0.06751585f, 0.13609019f, -0.22311360f, -0.02618502f, -0.07505651f, 0.15264666f, 0.13526455f, 
    0.09995683f, -0.12098521f, 0.29557681f, 0.04566894f, -0.05020508f, 0.08723807f, -0.23886254f, 0.13939437f, 
    -0.02468414f, 0.08201552f, 0.00713449f, -0.08862026f, 0.04351344f, 0.04905753f, 0.11880903f, -0.07459687f, 
    -0.06876943f, -0.05491417f, -0.05203744f, 0.02503105f, -0.05622105f, 0.03827204f, 0.03849830f, -0.11125950f, 
    -0.29636455f, 0.09818786f, -0.24098797f, -0.03392322f, 0.05415840f, 0.01310538f, -0.05123809f, -0.12199486f, 
    -0.14458939f, 0.08187149f, 0.03160010f, 0.01465354f, 0.04056288f, -0.01120874f, 0.03892811f, 0.01130516f, 
    0.05222114f, -0.02602464f, 0.04636539f, -0.01545613f, 0.08873908f, -0.06570138f, 0.03861091f, -0.05553013f, 
    -0.01605641f, -0.05821529f, 0.07114409f, -0.02081014f, -0.00918715f, 0.00004411f, -0.03780689f, 0.05057989f, 
    -0.14806820f, -0.05811265f, -0.16603902f, -0.11981674f, 0.24375652f, 0.46446601f, 0.07363573f, -0.07203204f, 
    -0.18424274f, 0.04104454f, -0.00467181f, 0.01371679f, -0.15763564f, 0.05645833f, -0.06665636f, -0.04752561f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.15631098f, 0.09375551f, 0.07862218f, -0.11940019f, -0.09847388f, 0.08283165f, 0.02044652f, -0.14845809f, 
    0.06368572f, 0.02792371f, 0.03779826f, 0.00464467f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
