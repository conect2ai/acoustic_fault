#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.07010996f, -0.40627468f, -0.23309425f, 0.27414697f, -0.26723611f, -0.75583911f, -0.51774973f, -0.05588203f, 
    -0.55918545f, -0.96422452f, 0.76611120f, -0.57655251f, -0.14552525f, 0.02037710f, 0.08635189f, 0.17181022f, 
    0.31944835f, -0.14214034f, -0.17546280f, 0.08985999f, -0.08808012f, 0.04820857f, 0.40247729f, 0.22539829f, 
    -0.09178723f, 0.15071541f, -0.02581142f, -0.42575651f, -0.61334914f, -0.46054634f, -0.72361559f, -0.58323103f, 
    -0.44149995f, -0.36550972f, 0.30544576f, 0.00957825f, 0.04893386f, 0.58271056f, -0.27971914f, -0.39916533f, 
    0.29828835f, 0.30247641f, 0.10537252f, -0.00013037f, -0.11994229f, 0.37510714f, -0.20457822f, -0.15166305f, 
    0.17386334f, -0.15311675f, -1.19802725f, -0.51456928f, -0.66338092f, -0.13884252f, 0.12985131f, 0.46903315f, 
    -0.24430294f, -0.35849109f, 0.20354709f, -0.27652413f, -0.01286478f, 0.30682859f, 0.69130933f, 0.12253394f, 
    0.20403303f, 0.14048520f, -0.33477527f, -0.08249558f, -0.50842482f, -0.24731490f, 0.26582006f, 0.15834424f, 
    -0.26788485f, 0.08287233f, 0.43444708f, -0.57599837f, 0.98271406f, 0.75094932f, 0.45167547f, 0.39241189f, 
    0.09457128f, -0.33011925f, -0.63822109f, -0.25973055f, -0.06799340f, -0.29857504f, 0.21989235f, -0.22410789f, 
    -0.05075745f, -0.40097588f, -0.12146245f, 0.20448148f, -0.02696208f, -0.22156297f, -0.04736229f, -0.09640935f, 
    -0.08695354f, -0.20089528f, 0.01821072f, -0.47392064f, -1.35590088f, -0.28350258f, -0.68374527f, -1.22625196f, 
    -0.50680101f, 0.45066652f, -0.07124206f, -0.02159555f, 0.11869062f, 0.68760622f, -0.23894973f, -0.28677318f, 
    0.07994141f, 0.05513262f, -0.29236069f, 0.20900948f, 0.04570761f, -0.00051601f, 0.01031226f, -0.23949450f, 
    -0.25484586f, 0.05103899f, -0.18159580f, -0.23085193f, -0.15039973f, -0.90333980f, -0.76210564f, -0.73143911f, 
    -0.52610207f, -0.24390481f, -0.51578587f, -0.89179963f, -0.61175203f, -0.81836176f, -0.42526641f, -0.13750377f, 
    0.38662407f, 0.16861479f, 0.35402778f, -0.04268642f, 0.22440447f, -0.12760203f, 0.00355468f, 0.05126263f, 
    -0.34940496f, -0.26864207f, 0.37378609f, 0.08535577f, -0.11112767f, -0.00187672f, -0.01611958f, 0.25846687f, 
    0.38311544f, 0.18377836f, -0.79540116f, 0.06985153f, 0.44491059f, -0.28604791f, 0.16956928f, -0.42565721f, 
    -0.02814163f, -0.20516816f, -0.52567554f, 0.21390539f, 0.23952171f, 0.07544553f, -0.18144196f, -0.22238900f, 
    -0.03005713f, 0.04814142f, 0.28665102f, 0.03413988f, -0.06936715f, -0.05752433f, 0.19322176f, 0.15705243f, 
    1.34029377f, 0.72859371f, -1.03973389f, -0.32152754f, -0.08470412f, -0.16507766f, 0.46771643f, -0.55300128f, 
    -0.63037562f, -0.14188355f, 0.04352513f, 0.35439008f, -0.29972115f, -0.17843431f, 0.22058073f, 0.25853705f, 
    0.12249160f, -0.00542052f, -0.10865838f, -0.08784418f, 0.13769521f, -0.60080683f, -0.29719502f, -0.29473376f, 
    -0.24603514f, -0.01716211f, -0.76644528f, -0.74991769f, -0.46720830f, -0.68632126f, -0.23691863f, 0.68280298f, 
    0.55332690f, -0.17080005f, -0.56358302f, -0.30379257f, -0.25778601f, -0.18650979f, 0.12467608f, -0.31819987f, 
    0.09262583f, -0.18298097f, -0.14796704f, -0.21955228f, -0.32581481f, 0.55790997f, 0.01259315f, -0.35904479f, 
    0.35619351f, -0.66563481f, -1.20396650f, -0.74635255f, 0.14628316f, -0.23605382f, 0.41761184f, 0.68865550f, 
    0.38117880f, 0.37304071f, 0.29865792f, -0.01903974f, 0.00905975f, 0.33550203f, -0.04041106f, -0.24876307f, 
    -0.07705504f, -0.16940925f, -0.06365835f, 0.41800648f, 0.31661671f, -0.11819576f, -0.03859092f, -0.03513897f, 
    0.08757976f, -0.23692228f, -0.73957342f, -0.65176845f, -0.14152735f, 0.60903376f, -0.65373605f, 0.64932370f, 
    0.33282390f, -0.43027106f, -0.33572125f, 0.52472472f, -0.42232788f, -0.34456411f, -0.24121149f, 0.11978547f, 
    0.13749593f, -0.07031040f, -0.16956191f, -0.21608409f, -0.28062892f, -0.20902617f, -0.27683157f, -0.59392965f, 
    -0.48985049f, -0.40159616f, -0.78594166f, 0.76788479f, 0.45251560f, 0.00306951f, -0.26421705f, -0.43314222f, 
    -0.17854969f, -0.41802582f, 0.32485402f, 0.31503478f, 0.35254309f, 0.03046571f, -0.22459432f, 0.07556096f, 
    0.11257062f, 0.07872196f, 0.04008677f, -0.03596992f, -0.41738158f, 0.05106721f, -0.07352976f, 0.03167805f, 
    -0.23177984f, 0.06208516f, -0.26100686f, 0.17007385f, -0.03839575f, 0.40393427f, 1.24593937f, -0.47840554f, 
    -0.50919253f, -1.05416989f, -0.86619914f, -0.27481422f, 0.14652920f, 0.49442849f, 0.32156554f, -0.28434184f, 
    -0.11006701f, 0.67642415f, 0.15583842f, -0.34203586f, -0.18273667f, 0.16922253f, -0.04184589f, -0.07829005f, 
    0.12550989f, 0.08127151f, -0.08574874f, -0.43600151f, -0.09145840f, -0.45740294f, 0.08040638f, 0.34069732f, 
    -0.10888062f, 0.12526064f, -0.13526596f, -0.13182470f, 0.07598227f, 0.02024164f, -0.05159346f, -0.17939757f, 
    0.09640959f, 0.17449763f, -0.64215225f, 0.73736715f, -0.33329126f, -0.05368665f, 0.15548550f, 0.17609651f, 
    -0.28983530f, -0.25598699f, -0.07768419f, -0.00993541f, 0.19184460f, 0.46401823f, -0.02631263f, 0.15906595f, 
    0.19971766f, 0.01291064f, -0.12276420f, 0.12272615f, 0.38007608f, -0.34529555f, 0.07532962f, -0.22229891f, 
    -0.04117858f, 0.26237330f, -0.20227675f, -0.05888944f, 0.17341901f, -0.46780506f, 0.41860673f, 0.18314432f, 
    0.10072448f, -0.44960052f, -0.19830893f, 0.18818621f, 0.26637727f, 0.21214254f, -0.35841820f, -0.04068284f, 
    -0.22217226f, 0.15960109f, -0.15265264f, 0.14640017f, 0.13292812f, -0.62515777f, -0.77357548f, -0.66277564f, 
    -0.86331892f, 0.17836301f, 0.33942556f, -0.29603884f, 0.34148344f, -0.42819747f, 0.10501171f, 0.01320760f, 
    0.19070508f, 0.34934831f, 0.18955395f, -0.34246972f, -0.03754121f, -0.00353215f, -0.21341880f, -0.34502462f, 
    -0.83763522f, -0.29890448f, -0.44018647f, 0.33197188f, 0.89921683f, 0.09452666f, -0.24903809f, 0.25288025f, 
    1.02758634f, 0.15534094f, -0.07586604f, -0.16816947f, 0.33570722f, -0.01970874f, -0.11645368f, 0.06614752f, 
    -0.24176152f, 0.05635934f, -0.00855169f, -0.23924336f, -0.01122442f, -0.40911001f, 0.01005350f, 0.40638098f, 
    0.02911200f, 0.33454895f, 0.80639625f, -0.76517516f, -1.30772817f, -0.31165430f, 0.37785766f, 0.59986973f, 
    -0.49111584f, -1.04380000f, -0.59222007f, 0.16306084f, 0.59972763f, -0.34877563f, 0.08299103f, 0.22114991f, 
    -0.43194777f, -0.38726482f, -0.40579155f, -0.09805667f, -0.66423029f, 0.70079690f, -0.28063759f, -0.24106225f, 
    0.17605968f, 0.00602890f, 1.24457538f, -0.54271126f, -1.04552591f, -1.15531600f, -0.93821341f, 0.73807293f, 
    0.21802546f, 0.43117031f, 0.57118696f, 0.02194702f, -0.01545362f, 0.09908921f, 0.06402529f, -0.25313091f, 
    -0.34119880f, -0.27771232f, -0.16400614f, 0.17457618f, -0.21560371f, 0.48141459f, 0.24642450f, -0.10812022f, 
    -0.08779084f, 0.24490792f, 0.08011510f, -0.60429066f, -0.50204265f, -0.41494200f, 0.48129401f, 0.82249707f, 
    0.39704934f, -0.10414936f, -0.89223808f, -0.66375571f, 0.54850227f, 0.27327546f, 0.26690602f, -0.34252360f, 
    -0.14164492f, -0.37003770f, -0.10148568f, -0.39139718f, -0.34598184f, -0.11321881f, 0.10269988f, -0.23473960f, 
    -0.31627044f, -0.29080433f, -0.04024144f, -0.35963613f, 0.34867343f, 0.37779859f, 0.58683759f, -0.04775497f, 
    0.10704393f, -0.09444529f, 0.53834391f, 0.03271770f, -0.29982656f, -0.34603834f, 0.07022338f, 0.04037789f, 
    -0.25407082f, 0.16603750f, -0.12104926f, -0.45261323f, -0.32384041f, -0.07905239f, -0.01862333f, 0.19889280f, 
    0.31932616f, 0.10816675f, 0.01427792f, -0.40835008f, -0.00176652f, -0.71410847f, -0.70875865f, -0.68999612f, 
    -0.16728698f, -0.33822757f, -0.14265986f, 0.06732082f, 0.16980051f, 0.43026271f, 0.41115293f, 0.46329489f, 
    0.27577102f, 0.26305360f, 0.49056089f, -0.16721319f, 0.11048495f, -0.20424308f, -0.18156236f, -0.11205402f, 
    0.02267395f, -0.17107563f, 0.13372143f, 0.05002755f, 0.16475090f, -0.15345396f, 0.08001023f, 0.51945537f, 
    0.17227560f, -0.20534186f, 0.34819150f, -0.69973779f, -0.75028783f, 0.24233080f, 0.58873194f, -0.27445507f, 
    -0.11135478f, 0.09896399f, -0.17480154f, -0.02857084f, 0.13922705f, -0.05116121f, 0.59268475f, 0.10224743f, 
    -0.53932416f, -0.15746669f, 0.10883217f, 0.06880278f, -0.35630381f, -0.21960200f, 0.18759121f, -0.77114946f, 
    -0.49704361f, -1.06935048f, -0.46761113f, 0.46820387f, 0.11441348f, -0.13923596f, -0.16094105f, 0.01792978f, 
    -0.14793663f, -0.56141496f, -0.19223678f, -0.25446737f, -0.39636001f, -0.13313447f, 0.18241063f, 0.01139520f, 
    -0.11618019f, 0.53914523f, 0.23807995f, 0.22686526f, -0.57292527f, -0.39750338f, -0.06408580f, -0.43103611f, 
    -1.01540840f, -0.58647561f, -0.74241066f, -0.25527909f, -0.37329993f, -0.14236785f, 0.09761226f, -0.44062579f, 
    -0.46877185f, 0.09823513f, -0.13417968f, -0.55425125f, -0.18007179f, 0.03899381f, -0.36460614f, -0.16148990f, 
    -0.22295515f, -0.24821773f, -0.41279912f, -0.49586454f, -0.28411350f, -0.20436744f, -0.00453914f, 0.24535421f, 
    -0.08806113f, 0.60027021f, -0.06036909f, 0.25276101f, 0.09533562f, -0.88870776f, 0.24440220f, -0.13332158f, 
    0.17618409f, -0.02389589f, -0.12925214f, -0.32888782f, -0.38425702f, 0.09571715f, 0.54917353f, -0.35422817f, 
    -0.40685806f, 0.02049248f, 0.18052664f, 0.01483137f, -0.09798384f, 0.22512332f, -0.37647396f, -0.49906889f, 
    -0.37138385f, -0.47151363f, -0.46517053f, 0.29554421f, -0.11775889f, 0.24119268f, 0.45326394f, 0.21704534f, 
    -0.01425813f, 0.14492409f, 0.53496152f, 0.35938099f, 0.04351313f, -0.20402649f, -0.05164540f, 0.31850767f, 
    0.01596891f, -0.06428863f, -0.07737540f, -0.21272269f, 0.17891698f, 0.12202276f, -0.32042050f, -0.01607147f, 
    -0.05728654f, 0.18671149f, 0.15096126f, -0.48861364f, -1.04887331f, 0.15068711f, 0.30995515f, 0.77600402f, 
    0.23777126f, -0.83060169f, -0.41868114f, 0.64470774f, -0.25896096f, -0.51314622f, 0.69153965f, -0.71414441f, 
    0.04258527f, -0.52524549f, -0.16682468f, 0.00436541f, -0.31898770f, -0.13820304f, -0.03074037f, 0.11476868f, 
    -0.13517830f, 0.06620703f, -0.27712265f, 0.21638007f, 0.39623228f, -0.56649983f, -0.29561466f, -0.16111913f, 
    -0.17791660f, -0.69381696f, -0.21359812f, -0.14060996f, -0.33976829f, -0.69630921f, 0.14681642f, 0.64294618f, 
    -0.12991880f, 0.04410298f, -0.41192782f, -0.41851053f, -0.54557490f, 0.42025924f, -0.11916318f, -0.41366869f, 
    -0.53048378f, -0.12455127f, 0.09638536f, 0.57314473f, 0.25365055f, -0.68956590f, -0.12048513f, -0.67737424f, 
    -0.51653045f, 0.09601957f, 0.34724477f, 0.41622731f, -0.32683012f, -0.05514357f, 0.72687894f, 0.17338672f, 
    0.38483608f, -0.26169294f, 0.00441722f, -0.15843914f, -0.19973789f, -0.44608465f, 0.23775722f, 0.19281408f, 
    -0.58621079f, 0.19793269f, -0.14519916f, 0.33414266f, 0.16086803f, 0.23791134f, -0.05816565f, -0.16958530f, 
    -0.22690332f, -0.10341668f, -0.30932495f, 0.55509567f, 0.19950533f, -0.17031221f, 0.32525241f, 0.41622400f, 
    0.06447670f, 0.33016288f, -0.24419206f, -0.03300861f, -0.10278735f, -0.47869751f, 0.14601727f, -0.23950168f, 
    -0.02623695f, 0.18469083f, 0.39097637f, 0.55665815f, 0.30313823f, 0.45496458f, 0.29485753f, 0.57968223f, 
    0.01945801f, 0.15675391f, -0.18037011f, -0.36586237f, 0.92861205f, -0.65475190f, -0.42677820f, 0.40950659f, 
    -0.33012584f, 0.07644748f, -0.13335538f, -0.06006012f, -0.09570657f, -0.34806240f, 0.40685648f, 0.16831015f, 
    0.35693437f, -0.21298541f, -0.32419756f, -0.01377930f, 0.04644335f, 0.03671746f, -0.05340288f, 0.23992294f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.28877982f, 0.29532561f, 0.67878181f, 0.21487953f, -0.28868258f, -0.57450271f, 0.15474617f, 0.14881156f, 
    0.34690586f, -0.05120838f, 0.09185132f, 0.46549085f, 0.38413599f, 0.42687720f, 0.36880323f, -0.15045623f, 
    0.50885504f, 0.12926249f, 0.60380548f, 0.13381730f, 0.15647601f, 0.30608144f, 0.32394972f, -0.07433025f, 
    -0.38486567f, 0.14360902f, 0.21403925f, 0.09739146f, -0.01572729f, 0.26570290f, -0.16860984f, 0.32711250f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.25599104f, 0.03919668f, -0.06891529f, -0.34527943f, -0.02727219f, 0.01570179f, -0.11114696f, 0.05836799f, 
    -0.00080996f, 0.12565033f, -0.02085770f, 0.00547626f, 0.19044290f, 0.15080605f, -0.06288361f, -0.18247540f, 
    0.04758127f, -0.05057115f, -0.16817002f, -0.08017608f, 0.03736376f, -0.02625206f, 0.06489898f, 0.11186862f, 
    0.16957477f, 0.21078122f, -0.15306212f, -0.25771308f, -0.05142721f, 0.07225465f, 0.11482838f, -0.24261549f, 
    -0.00335313f, -0.21456604f, -0.02798283f, -0.04290606f, -0.86625677f, 0.15537117f, -0.22889951f, 0.08887195f, 
    0.07624242f, -0.02329367f, 0.05135480f, 0.04797366f, 0.00821169f, -0.01357952f, -0.00075526f, 0.10026907f, 
    0.18751697f, 0.22190385f, 0.04933108f, -0.14087489f, 0.06439257f, 0.26498717f, 0.17419173f, 0.03902096f, 
    -0.07512636f, 0.04119928f, 0.04776296f, 0.02304525f, 0.45081845f, 0.40389967f, -0.05896218f, -0.35083356f, 
    0.10582815f, 0.22534645f, 0.08354776f, -0.12821917f, -0.02862322f, 0.05332097f, 0.00885910f, 0.02517773f, 
    -0.14956334f, -0.11230149f, 0.08631156f, -0.22825460f, -0.06466391f, 0.01781838f, -0.09898533f, 0.02818443f, 
    -0.17476033f, -0.08478024f, -0.03519592f, 0.10033976f, -0.16752270f, -0.04040284f, -0.14088662f, 0.39361414f, 
    0.02150589f, 0.02375195f, -0.19384144f, -0.24808070f, 0.03486789f, 0.01594740f, -0.03630651f, -0.03747878f, 
    0.00622027f, 0.02227170f, 0.21511137f, -0.18626404f, -0.02480602f, 0.10821039f, -0.06023573f, -0.04348532f, 
    -0.08297675f, -0.07601192f, -0.04396190f, -0.10040336f, 0.54486930f, 0.01628802f, -0.21806715f, 0.01548532f, 
    0.17996800f, 0.05173902f, 0.11192156f, -0.13614130f, -0.01518085f, 0.10365336f, -0.11070235f, 0.18933073f, 
    0.29850015f, -0.05099471f, -0.15137126f, -0.23814847f, -0.01709303f, -0.02532984f, 0.02265322f, -0.08601759f, 
    0.13016170f, -0.03590001f, 0.19646701f, 0.27883676f, -0.38466319f, -0.75394052f, -0.07322188f, 0.09691957f, 
    0.03321338f, 0.03031229f, -0.04252240f, 0.06532996f, -0.16433784f, -0.14203957f, -0.34227610f, -0.21944541f, 
    -0.06386790f, 0.18378970f, 0.17592749f, -0.32016277f, -0.30148110f, -0.06230937f, -0.06367297f, -0.19860752f, 
    -0.03404878f, -0.07124459f, 0.01123575f, -0.07027379f, -0.19276711f, 0.12443444f, -0.07844420f, -0.10794114f, 
    -0.24572721f, -0.27475721f, -0.09316602f, -0.14260472f, 0.10359880f, -0.22873132f, 0.04702545f, -0.19356866f, 
    -0.04408487f, -0.41394573f, -0.15305592f, -0.00696655f, -0.08474928f, -0.07642178f, 0.02354618f, -0.02206860f, 
    -0.11330998f, -0.11176920f, 0.03386164f, 0.01706166f, 0.50865144f, 0.21659772f, -0.50047255f, -0.14512636f, 
    -0.10688513f, -0.04497230f, 0.10923751f, 0.24515250f, 0.00553428f, 0.04007624f, -0.04165305f, 0.04773499f, 
    -0.07632115f, 0.11489893f, 0.06244036f, -0.08389963f, 0.06606252f, 0.05206402f, 0.04150262f, -0.02318473f, 
    -0.04768055f, -0.14883889f, -0.10639761f, -0.28770208f, 0.27657229f, 0.04574559f, -0.86821359f, 0.12513046f, 
    0.07815709f, 0.05274529f, -0.12865363f, -0.39513081f, -0.18570331f, -0.04851547f, -0.02737632f, -0.19900127f, 
    -0.02258919f, -0.35391429f, -0.50698709f, -0.01173095f, -0.00091782f, 0.04503575f, -0.08010085f, 0.02290996f, 
    -0.02796135f, -0.11325602f, 0.00811381f, -0.01525502f, 0.45399681f, 0.24315052f, -0.03106793f, 0.13821374f, 
    -0.11766808f, 0.00238730f, -0.01074046f, -0.15665957f, -0.16180189f, -0.13863304f, 0.10913414f, -0.02193952f, 
    -0.21777986f, -0.66083002f, -0.46560425f, 0.41036013f, 0.03330415f, 0.01829796f, 0.05015299f, 0.04535406f, 
    -0.01485642f, 0.00091021f, 0.05602048f, 0.02882805f, 0.17127596f, 0.21565184f, 0.07368232f, -0.04944162f, 
    0.11553457f, 0.02159772f, 0.02604696f, -0.01586374f, -0.12990481f, 0.06865164f, -0.03175243f, 0.08975788f, 
    -0.38334084f, 0.04470456f, 0.13840017f, -0.34013572f, -0.21933994f, -0.02200705f, -0.26044741f, 0.06922949f, 
    0.05737377f, -0.07930365f, -0.10358845f, -0.07969328f, 0.29074833f, 0.22870384f, 0.00764334f, 0.12690690f, 
    0.20016474f, 0.24700765f, 0.20669927f, -0.10399487f, 0.01006338f, 0.06619892f, 0.02727443f, 0.00420833f, 
    0.35673544f, 0.15544578f, -0.01199269f, -0.08502828f, 0.19209364f, 0.15408833f, 0.05795580f, 0.00120927f, 
    -0.21000735f, -0.20154265f, -0.19183004f, 0.02655493f, -0.24874716f, -0.39706531f, 0.11964881f, -0.06844560f, 
    0.03290059f, 0.00950500f, -0.20877700f, 0.07149715f, -0.08916774f, -0.21876073f, -0.01746673f, 0.08068142f, 
    -0.10155183f, -0.03753048f, 0.03412313f, 0.00588536f, -0.06095525f, 0.02461750f, 0.04029071f, 0.03408833f, 
    -0.09896337f, -0.06987198f, -0.28284398f, -0.38867092f, 0.37821132f, 0.17771465f, 0.16089952f, -0.12986600f, 
    -0.04630534f, -0.15591906f, 0.16231371f, -0.08179142f, 0.00366337f, -0.02529378f, -0.03699847f, -0.23836316f, 
    0.25207430f, 0.17480668f, -0.21252836f, -0.29999375f, 0.18021737f, -0.21159071f, -0.13260327f, -0.02304646f, 
    0.00718853f, -0.04960620f, -0.06832524f, -0.05386885f, -0.10418274f, 0.08887800f, -0.05451751f, -0.01039755f, 
    0.12941122f, 0.08218729f, 0.00050055f, -0.17974138f, -0.00241452f, -0.16636963f, -0.19518378f, 0.06492894f, 
    0.01443879f, 0.05153611f, 0.02746303f, 0.11509169f, -0.07502283f, -0.07525460f, -0.08715855f, 0.01366349f, 
    -0.10858504f, -0.06581648f, -0.01556096f, -0.10845407f, 0.10027935f, 0.11655641f, -0.54297578f, -0.11830445f, 
    -0.36276150f, 0.02159785f, -0.00724269f, 0.06052789f, -0.06783066f, -0.08025400f, 0.04057104f, 0.00716549f, 
    -0.17666133f, 0.17720777f, 0.06764792f, -0.10410404f, -0.03384325f, 0.09561536f, 0.33052883f, -0.08827737f, 
    -0.05216903f, 0.02238883f, 0.03372249f, 0.03245635f, -0.04137101f, -0.22757792f, -0.04408986f, 0.01209690f, 
    -0.00578116f, 0.17448184f, -0.21359749f, -0.31768814f, -0.03800909f, -0.08332919f, 0.04099831f, 0.03861452f, 
    -0.73595840f, -0.15837494f, -0.10554097f, 0.17829911f, 0.09871757f, 0.03135571f, 0.20672566f, 0.10308105f, 
    0.00775432f, -0.03835473f, 0.18519354f, 0.03387024f, 0.07916233f, 0.08889695f, -0.01716258f, 0.24971843f, 
    0.01546093f, 0.03306866f, 0.04015883f, 0.01907368f, 0.02885749f, -0.05595675f, -0.03538632f, 0.11105868f, 
    0.10367389f, 0.31420636f, -0.03494188f, 0.19807275f, 0.09460305f, 0.05981985f, -0.27724329f, -0.26399189f, 
    -0.08980585f, -0.00751782f, -0.10761089f, -0.18113051f, -0.04276059f, 0.18159203f, 0.31297150f, 0.54480207f, 
    -0.22251391f, 0.06025978f, -0.01654262f, 0.03449364f, -0.03677186f, 0.03967962f, -0.02310496f, 0.07493123f, 
    0.03413950f, -0.13719785f, -0.00199511f, 0.02271847f, -0.18845066f, -0.15181156f, 0.10552442f, 0.01361108f, 
    0.02003425f, 0.05598563f, 0.20803902f, -0.17691840f, 0.04964701f, -0.24396046f, -0.01874142f, -0.17160651f, 
    0.08541401f, -0.09144600f, 0.05937140f, 0.00137911f, -0.01497517f, -0.01393136f, -0.21371502f, 0.17354026f, 
    -0.33322904f, 0.55402720f, -0.04630625f, -0.12613478f, 0.17785408f, 0.08849607f, -0.01680891f, -0.20008208f, 
    -0.04257913f, 0.03779412f, -0.05746728f, 0.11613640f, 0.30800527f, -0.00917295f, -0.37640589f, -0.05352681f, 
    -0.11623392f, -0.05305205f, 0.11575294f, -0.14638370f, -0.04659445f, -0.17593238f, 0.09466532f, -0.03419467f, 
    0.18155660f, 0.04203885f, 0.01489593f, -0.10064086f, 0.06982645f, 0.00399309f, -0.04300904f, -0.08133336f, 
    -0.31383321f, -0.12580329f, -0.16374661f, -0.66012561f, 0.15258497f, -0.02479250f, 0.18009070f, -0.08859873f, 
    0.02448720f, 0.06392480f, 0.07682466f, -0.04877933f, 0.16149317f, 0.02486333f, -0.04494226f, -0.00909856f, 
    -0.08649652f, -0.15932541f, 0.13160300f, -0.41596967f, -0.00090943f, -0.00417740f, -0.28452483f, 0.45100319f, 
    0.13295962f, -0.16601165f, 0.12963219f, -0.10104211f, -0.11009406f, 0.11076016f, -0.00814603f, 0.13837279f, 
    0.12263039f, 0.21477461f, -0.00655871f, -0.08867765f, 0.06259340f, 0.10024893f, 0.00296182f, -0.05639889f, 
    0.02398766f, -0.13755929f, 0.21535151f, 0.00505612f, -0.05250035f, -0.03043777f, 0.15218687f, 0.01023271f, 
    0.02612368f, -0.02058703f, -0.07888485f, 0.07430882f, -0.01166630f, -0.01479814f, -0.36162505f, -0.16335681f, 
    -0.25622532f, 0.01429231f, -0.16229993f, 0.08444820f, -0.04402155f, 0.01127178f, -0.04460797f, 0.12673672f, 
    -0.37609404f, 0.05893167f, 0.15317090f, 0.14311768f, -0.03670892f, -0.09340578f, 0.03654638f, -0.06163731f, 
    0.10824497f, 0.10325725f, 0.04871854f, 0.19134571f, 0.23742917f, -0.71764797f, 0.07803760f, -0.21542786f, 
    -0.00046524f, 0.28180191f, 0.06475589f, 0.26039362f, 0.12225303f, -0.04643610f, -0.16824761f, 0.24414797f, 
    0.71728563f, -0.08061265f, -0.33598435f, -0.35191426f, 0.01009745f, 0.03860739f, 0.26921505f, -0.08204962f, 
    0.02389059f, 0.03353092f, 0.00046653f, -0.18288226f, 0.19705814f, -0.07441853f, -0.50745958f, 0.04509417f, 
    -0.06703161f, 0.08800143f, 0.04809543f, -0.01646087f, -0.15168914f, -0.02184350f, -0.34571207f, -0.14544843f, 
    0.79692531f, 0.33588743f, 0.15372464f, 0.07874760f, -0.04620382f, -0.05117080f, -0.08651835f, 0.00406223f, 
    0.00559875f, 0.04766857f, 0.08151203f, 0.05009886f, -0.37738869f, -0.27416298f, -0.32517648f, -0.08847857f, 
    0.00660345f, 0.05582462f, 0.08346643f, 0.09691238f, -0.03944283f, 0.02007012f, 0.06822227f, 0.02435710f, 
    -0.29958335f, 0.16616896f, 0.33176056f, -0.06105174f, 0.19279371f, 0.13492426f, 0.07884163f, 0.22258647f, 
    0.05819911f, 0.07829274f, -0.11363621f, 0.18861768f, -0.00636318f, 0.06562985f, 0.12619159f, 0.13068543f, 
    -0.08318125f, 0.04172595f, -0.29761556f, -0.18433835f, 0.04427237f, -0.14327917f, -0.06902726f, -0.11234565f, 
    0.49320990f, 0.06849959f, 0.36860839f, 0.09323803f, 0.15236835f, -0.10168611f, 0.12035256f, 0.08943319f, 
    0.06154319f, 0.03622347f, -0.06368038f, -0.16157413f, 0.30670217f, 0.03471729f, 0.09302057f, -0.35516313f, 
    -0.06152540f, 0.03058758f, -0.18467432f, -0.08418208f, -0.16525714f, -0.27332684f, 0.23146202f, -0.13487329f, 
    0.00997994f, 0.15928406f, 0.15818007f, 0.15031025f, -0.04472162f, -0.09132427f, -0.04540020f, -0.03802632f, 
    0.09290956f, 0.02662011f, 0.11425310f, 0.11319582f, -0.81435436f, 0.07472371f, -0.91732168f, -0.04272539f, 
    -0.09545959f, -0.01227333f, -0.17030396f, 0.21560107f, 0.07092836f, 0.01349825f, -0.10103505f, 0.00749091f, 
    -0.04309390f, -0.17768124f, -0.27046603f, -0.20602590f, -0.17514387f, 0.39569840f, -0.04201426f, 0.22199096f, 
    -0.10235550f, -0.00144831f, -0.10393848f, 0.17508034f, 0.13527738f, -0.00688240f, 0.01546934f, -0.24637769f, 
    -0.09255867f, -0.05324638f, -0.03812757f, 0.11530925f, -0.01809568f, -0.05681038f, -0.22779478f, -0.05742161f, 
    -0.00290883f, 0.08995202f, -0.07396089f, 0.00035660f, 0.11446875f, -0.08852220f, -0.07838137f, 0.06996091f, 
    -0.16427499f, -0.03240833f, -0.07700478f, -0.11894297f, 0.28321713f, 0.09932010f, -0.16705967f, -0.33947796f, 
    0.04639853f, -0.01273321f, -0.03355383f, 0.04937755f, -0.02444504f, 0.12997761f, 0.01460682f, 0.07592848f, 
    -0.41734493f, -0.26599732f, -0.39617911f, -0.15610206f, -0.06500594f, -0.11031662f, 0.13532738f, -0.21544783f, 
    0.02471883f, -0.05862963f, -0.01167303f, 0.03954308f, -0.10091212f, -0.48047805f, -0.11458137f, 0.13734180f, 
    0.03616449f, -0.00214704f, -0.00701632f, -0.08331110f, 0.04357541f, -0.01537127f, -0.00394748f, -0.01876543f, 
    0.35249022f, -0.29139030f, -0.02860858f, 0.37674263f, 0.11015309f, -0.03933536f, -0.09282224f, 0.31839675f, 
    -0.00140236f, 0.00411768f, -0.07686848f, 0.02905837f, -0.27170986f, 0.17149793f, -0.01548660f, -0.33063674f, 
    0.05877438f, -0.04908580f, 0.04471241f, 0.08374134f, -0.02068533f, -0.06706776f, 0.06387369f, 0.03886247f, 
    -0.03639247f, 0.57009566f, 0.48033410f, 0.79050976f, 0.02042280f, -0.03754466f, -0.02650400f, 0.12095054f, 
    0.05693172f, -0.05297014f, 0.00835966f, 0.07872906f, -0.72766232f, -1.09078443f, -0.44197723f, -0.45649093f, 
    -0.07397654f, -0.27899802f, -0.04207547f, 0.02530866f, 0.00271958f, -0.05309787f, -0.01126458f, -0.01453835f, 
    -0.09294710f, -0.02763298f, -0.25204012f, 0.05428152f, -0.13223839f, 0.02428717f, -0.09010743f, 0.12355577f, 
    -0.06959835f, 0.00903967f, -0.09665120f, 0.06760567f, 0.14892067f, -0.08370516f, 0.07559566f, -0.25451523f, 
    -0.01214222f, -0.11820017f, -0.25783640f, -0.16342014f, 0.07333218f, 0.01087177f, 0.10690638f, 0.05705416f, 
    -0.16611145f, 0.57140547f, 0.23443857f, 0.29737005f, -0.09698967f, 0.26406062f, -0.06455605f, -0.24692480f, 
    0.02940349f, -0.03177641f, -0.01998078f, 0.05049024f, -0.12773822f, 0.16516671f, 0.30878729f, 0.24522845f, 
    -0.12372649f, -0.03929599f, 0.03303400f, 0.04952550f, 0.07938075f, -0.06619167f, 0.19921753f, -0.24105087f, 
    0.17924906f, -0.09935986f, 0.44807220f, 0.19178733f, 0.05113669f, -0.04558826f, -0.05188576f, 0.03984936f, 
    0.00878431f, 0.18458027f, -0.01122191f, 0.13223337f, -0.49105495f, 0.31820580f, 0.05907883f, 0.01799840f, 
    -0.03009261f, 0.01608451f, 0.00783022f, -0.10697060f, -0.01452333f, 0.06217206f, -0.09493297f, 0.21854357f, 
    -0.01099514f, -0.10811660f, 0.07105002f, 0.07742062f, 0.19413579f, -0.05585845f, -0.24928644f, -0.24769649f, 
    0.07517442f, -0.06064552f, 0.09736168f, 0.07898100f, 0.02224907f, -0.05875504f, 0.01868022f, 0.07029186f, 
    -0.03256068f, 0.18922910f, -0.12031340f, -0.09705229f, -0.09604085f, 0.06980253f, 0.09276361f, -0.14579704f, 
    -0.03490645f, 0.18181941f, -0.07237462f, -0.06555030f, 0.02314427f, -0.14277637f, 0.02736997f, 0.03654819f, 
    -0.05503882f, -0.14787756f, -0.01940964f, 0.02556292f, -0.50463045f, -0.28538990f, -0.11355489f, -0.53440446f, 
    0.07899085f, -0.05212060f, -0.03330620f, -0.07479645f, 0.08097339f, 0.04397036f, 0.03792350f, 0.00927812f, 
    -0.20156488f, -0.06679543f, -0.17907538f, 0.17299046f, -0.02423931f, -0.03860748f, 0.06685083f, 0.06348372f, 
    -0.05457217f, 0.06052103f, 0.12999988f, -0.20044199f, -0.30471769f, -0.35473299f, 0.18275413f, -0.69128841f, 
    0.04811151f, -0.16472718f, -0.09563976f, -0.04728638f, 0.09531139f, 0.12189057f, -0.41022772f, -0.02916791f, 
    -0.36106548f, 0.76576906f, 0.23241691f, 0.18830456f, -0.16818997f, 0.03184825f, 0.16534649f, 0.00753068f, 
    0.08254076f, 0.10630968f, -0.09151670f, -0.02488012f, 0.04609310f, -0.08698630f, -0.01661749f, 0.05315040f, 
    0.03973746f, -0.07307635f, 0.01271715f, 0.10511768f, 0.01350972f, -0.04269172f, -0.12340474f, 0.00088288f, 
    0.19836251f, 0.00714695f, -0.27245361f, -0.41444406f, -0.02595322f, -0.06320114f, -0.08651551f, -0.00542656f, 
    -0.07001963f, 0.02784356f, -0.03328506f, -0.08964969f, 0.24713364f, 0.26016632f, 0.05090319f, 0.17887048f, 
    -0.06771303f, -0.02502286f, 0.08105750f, -0.10185024f, 0.01041697f, -0.08914365f, 0.05806078f, 0.06834914f, 
    -0.26934403f, -0.18974321f, 0.18980302f, 0.10460886f, 0.00151130f, 0.00183540f, 0.12043186f, -0.07700964f, 
    0.05529541f, 0.03289143f, -0.04255127f, 0.16404083f, -0.35300708f, -0.27545530f, 0.18952361f, 0.31212178f, 
    0.14611210f, -0.12198669f, 0.07377017f, 0.18842526f, 0.02543197f, 0.01544528f, 0.07778924f, -0.08014009f, 
    -0.29605982f, 0.04717710f, 0.52404326f, 0.00980113f, -0.10935596f, -0.17634232f, -0.04697948f, -0.07086223f, 
    -0.08172144f, -0.09874835f, 0.07226652f, -0.28645113f, -0.12320547f, 0.26536071f, -0.04397591f, -0.06079048f, 
    -0.04068154f, -0.02201495f, -0.04727592f, -0.05722168f, 0.06502580f, 0.15621668f, 0.40150771f, -0.09117329f, 
    -0.00444674f, -0.10202758f, -0.11634436f, 0.03653138f, -0.05750124f, 0.00990548f, 0.05042504f, 0.04106563f, 
    -0.20028523f, 0.10957878f, 0.07132621f, -0.06181080f, 0.00475122f, 0.30956021f, -0.46720210f, 0.06908745f, 
    -0.11033472f, 0.12185347f, -0.05319770f, 0.08625552f, 0.05162933f, -0.07045411f, 0.01479418f, -0.00929085f, 
    -0.59828454f, 0.12162907f, -0.27805459f, -0.28635544f, -0.18833259f, -0.09383976f, -0.05454177f, -0.20137678f, 
    -0.00327125f, -0.00693776f, 0.00691122f, -0.04877723f, -0.01111483f, -0.00843908f, 0.14990629f, 0.02562289f, 
    0.11139528f, 0.09594634f, -0.02546110f, -0.05283093f, 0.02408054f, -0.20334397f, -0.01347746f, -0.00369582f, 
    -0.07110750f, -0.03330574f, 0.02296314f, -0.02479337f, 0.09357757f, -0.09671036f, -0.12034134f, 0.03748696f, 
    -0.00548570f, -0.15665275f, -0.13776098f, 0.01580066f, -0.35694838f, 0.07752565f, 0.08350781f, -0.30961511f, 
    0.05324902f, -0.07442516f, -0.01817941f, 0.14385305f, -0.13273555f, 0.13828784f, 0.11236963f, -0.02517853f, 
    0.07291884f, -0.18616886f, -0.15975513f, 0.19237702f, 0.12791233f, 0.02537379f, -0.10373120f, 0.02756470f, 
    0.01757156f, -0.10794958f, -0.17791210f, -0.21727586f, -0.07026023f, -0.05633289f, -0.20545907f, 0.15390021f, 
    -0.10864822f, 0.05960809f, 0.14218578f, 0.00868559f, -0.04883894f, 0.03138161f, -0.08316324f, 0.03881409f, 
    -0.03324548f, -0.06751293f, -0.25295797f, 0.03719861f, 0.15357313f, -0.02991122f, -0.12525763f, 0.17498243f, 
    -0.18300793f, 0.19788891f, -0.24374467f, 0.05211292f, 0.02020696f, 0.82208526f, 0.46567616f, -0.12398147f, 
    -0.24846245f, 0.03506788f, 0.00012949f, -0.02913349f, -0.00881770f, 0.22389540f, -0.06905624f, 0.32715935f, 
    0.53756279f, -0.37251422f, -0.10175629f, 0.30648315f, 0.12757170f, -0.04763965f, 0.01276626f, -0.19868113f, 
    0.04042035f, 0.02502430f, 0.09679073f, 0.16108347f, -0.02525230f, -0.22870022f, -0.28253877f, 0.11333918f, 
    0.13631324f, 0.07035131f, 0.00354462f, 0.01099519f, 0.00667258f, -0.02068274f, 0.02062121f, -0.06001338f, 
    0.15610857f, 0.11662235f, 0.23405406f, 0.31869897f, -0.08124796f, -0.21731681f, 0.01959004f, -0.07752285f, 
    0.09923959f, -0.23050421f, 0.07750936f, -0.34610537f, 0.32022378f, 0.04440407f, 0.50859636f, -0.15965050f, 
    -0.25408420f, -0.12063379f, -0.19553293f, 0.10216091f, 0.11590625f, 0.14459307f, 0.12574475f, 0.07802387f, 
    0.40207008f, -0.06276348f, -0.05303206f, 0.29276225f, 0.02045167f, -0.06700022f, -0.10904549f, 0.04852989f, 
    0.04252917f, -0.01669434f, 0.05549973f, 0.03179029f, -0.47705016f, 0.15423654f, 0.11317555f, -0.06938518f, 
    0.45369843f, 0.23146003f, 0.09863790f, 0.09216025f, -0.11853284f, -0.08191139f, 0.06347594f, -0.17359322f, 
    -0.21689464f, 0.25566766f, 0.14518125f, 0.23598632f, 0.10532026f, 0.06456222f, -0.07148962f, -0.00483339f, 
    -0.13023169f, -0.03504865f, 0.14762415f, -0.09712205f, -0.82692856f, 0.32698137f, -0.08259505f, -0.16975227f, 
    -0.11627905f, 0.23783204f, -0.33359912f, -0.26607350f, -0.06602523f, -0.02379733f, -0.04517655f, -0.13669832f, 
    0.14684388f, -0.08535746f, 0.07162777f, -0.15775131f, -0.00782991f, 0.35291451f, -0.17546643f, -0.21578494f, 
    -0.06018078f, -0.12371551f, 0.12245592f, -0.14726356f, 0.17103769f, -0.21154502f, -0.00134743f, -0.19358878f, 
    -0.04949311f, -0.01348186f, -0.07123064f, -0.03350193f, -0.17378758f, -0.03947781f, -0.27594352f, 0.08289407f, 
    -0.24262464f, 0.00545276f, 0.07260551f, 0.01212035f, -0.16001426f, 0.03350405f, -0.12332423f, -0.05842663f, 
    -0.22763859f, -0.02330469f, -0.21408939f, 0.24848785f, -0.27107963f, -0.03499167f, -0.00296527f, 0.31241277f, 
    0.22819473f, 0.26716092f, -0.10014696f, 0.03557926f, 0.07854676f, -0.11897874f, 0.00852875f, 0.00775678f, 
    0.02321540f, -0.15723509f, -0.45833263f, -0.77941090f, 0.21931764f, 0.06339084f, 0.11063936f, -0.05740181f, 
    -0.27896985f, 0.06288619f, -0.08950659f, -0.07222960f, -0.17852184f, 0.13513927f, 0.14387822f, 0.48223558f, 
    0.01041757f, 0.05269171f, 0.17421284f, -0.01813788f, -0.19976902f, -0.13873205f, 0.02036647f, -0.07758363f, 
    -0.10741977f, 0.01840491f, 0.05294889f, 0.42811140f, 0.09534898f, -0.03996136f, 0.14306571f, -0.04701427f, 
    0.00128443f, 0.09219519f, 0.02987884f, 0.02843747f, -0.19338942f, 0.21224244f, -0.36292231f, -0.12064010f, 
    0.03269470f, -0.00875221f, -0.05487890f, -0.07126581f, -0.11849272f, 0.00397845f, -0.02115116f, 0.12020488f, 
    -0.52475590f, 0.04433506f, 0.03618779f, 0.19395477f, -0.01353668f, 0.19038929f, -0.01646464f, -0.06774375f, 
    0.04677099f, -0.24773619f, 0.10677100f, -0.12936713f, -0.12949269f, -0.30260783f, 0.04594842f, 0.18272379f, 
    -0.00383266f, 0.10497835f, 0.01707744f, 0.02748539f, -0.09372488f, -0.06815596f, -0.02306637f, -0.03285391f, 
    0.19730408f, -0.57253969f, 0.45130029f, -0.33265924f, -0.44330934f, 0.14805742f, -0.16094591f, 0.01345697f, 
    -0.15944003f, -0.14126107f, -0.37986377f, -0.08334256f, 0.22747736f, 0.04823925f, -0.10315746f, 0.00665097f, 
    0.11888534f, -0.15559177f, -0.02305683f, -0.12387510f, 0.05213350f, -0.03786037f, 0.22024854f, 0.04902843f, 
    -0.07999093f, -0.25148883f, -0.07509014f, 0.17351872f, 0.11333809f, 0.06743966f, -0.02655099f, -0.26333794f, 
    -0.04271292f, 0.13411713f, -0.05240975f, 0.09823056f, -0.37843829f, -0.36234441f, 0.09447465f, 0.07934200f, 
    -0.01603231f, 0.12825441f, 0.03783319f, 0.08620325f, 0.09638384f, 0.11562196f, -0.01675290f, 0.06457353f, 
    -0.41223615f, 0.05029346f, -0.11526776f, -0.41907570f, -0.08909863f, 0.23448087f, 0.07382077f, 0.21950985f, 
    -0.19548574f, -0.16847116f, 0.10243724f, -0.40633214f, -0.29912391f, 0.21583664f, -0.47378331f, -0.41612983f, 
    -0.07848730f, -0.13104525f, -0.00464667f, -0.00268138f, -0.14120990f, 0.16999443f, -0.09701382f, 0.15508883f, 
    -0.23499869f, -0.06511103f, 0.10963423f, 0.30704749f, 0.16731778f, -0.02948640f, 0.24315420f, -0.02098098f, 
    -0.10346525f, 0.10380626f, 0.27823797f, -0.19836675f, 0.30406633f, -0.19451073f, -0.37492090f, 0.13158022f, 
    0.17488573f, -0.13746217f, 0.08345589f, -0.25432774f, -0.03393170f, -0.03780624f, 0.16687737f, -0.08692466f, 
    -0.01000002f, -0.02558371f, -0.16434754f, 0.17155164f, 0.23110972f, 0.07433641f, -0.12547219f, -0.22976226f, 
    0.04686567f, 0.20495009f, -0.07715812f, 0.09673375f, -0.22343306f, -0.26964146f, 0.42167333f, -0.06223737f, 
    -0.08990578f, -0.00367077f, 0.14553435f, -0.16369490f, -0.21295603f, 0.23951355f, -0.07288902f, -0.05184066f, 
    0.01658282f, 0.16887902f, 0.25508943f, 0.13586751f, -0.18506335f, -0.10305921f, -0.03698616f, 0.16528679f, 
    0.01259201f, -0.01284811f, 0.06831188f, -0.00625887f, 0.01189251f, 0.12182270f, 0.19131170f, 0.15485732f, 
    -0.14567730f, -0.02771545f, -0.12981552f, -0.08655884f, 0.09531540f, 0.04554583f, -0.00642348f, 0.00584181f, 
    0.36024323f, 0.07672290f, 0.12117542f, 0.19115229f, -0.15488264f, -0.17161028f, -0.28160015f, -0.12684865f, 
    -0.02885828f, -0.16766538f, 0.03740383f, -0.04144432f, 0.73414987f, -0.63264149f, -0.24907401f, 0.69544119f, 
    0.00633534f, -0.04361342f, 0.05781001f, -0.05425230f, 0.06115046f, 0.10616381f, 0.00214200f, 0.08436031f, 
    -0.23782967f, 0.03880621f, 0.20244716f, 0.18247114f, -0.12506238f, -0.01903652f, 0.02567494f, -0.09782215f, 
    0.11935654f, -0.11154328f, 0.09086150f, 0.11280394f, 0.06803382f, 0.06733214f, 0.36526328f, 0.12784965f, 
    -0.23952781f, -0.01529538f, 0.02326400f, 0.26696944f, 0.12575001f, 0.10332508f, 0.05897444f, 0.01888777f, 
    0.03477461f, 0.03427403f, -0.30726886f, -0.07249764f, 0.14608854f, 0.02670591f, -0.18516193f, 0.04848193f, 
    -0.01374772f, 0.18383622f, -0.19815117f, -0.02534117f, 0.26632887f, 0.22394463f, -0.18560651f, 0.13308765f, 
    0.01348927f, -0.20898469f, 0.03862146f, -0.18764959f, 0.03115187f, -0.14842686f, 0.01697821f, -0.09932949f, 
    -0.39138979f, -0.16313536f, -0.02014082f, -0.14836001f, -0.08102366f, -0.05804702f, -0.11331781f, -0.06809477f, 
    -0.00764911f, -0.12600370f, 0.03926235f, -0.09690900f, -0.08848913f, -0.15636541f, 0.14879307f, 0.00524229f, 
    -0.16480173f, -0.05105961f, -0.01877653f, 0.18665832f, -0.02575019f, 0.09570874f, -0.25274080f, 0.04653949f, 
    0.03548202f, -0.07104137f, -0.15832928f, -0.02091403f, -0.12957221f, -0.10591127f, 0.12018746f, -0.00219229f, 
    0.29664955f, 0.12469654f, -0.02332577f, 0.34511754f, -0.25957623f, -0.24761030f, -0.20757283f, 0.03106570f, 
    -0.06984413f, 0.01324642f, -0.07117496f, 0.04331219f, -0.06321695f, 0.01354648f, -0.21741205f, -0.06272478f, 
    -0.33018842f, -0.04789340f, -0.19209903f, 0.49108240f, -0.20082872f, -0.04780364f, -0.32100803f, -0.41960236f, 
    0.11481801f, -0.04652351f, -0.00582129f, 0.04281240f, -0.08308315f, -0.02405471f, -0.07471585f, -0.01494625f, 
    0.16501710f, -0.26936927f, 0.06209958f, -0.01147999f, -0.19642121f, -0.17858408f, -0.16918275f, -0.23547013f, 
    0.08281513f, 0.06354550f, -0.14826785f, 0.15396631f, 0.10942424f, -0.14426798f, -0.00373129f, -0.22672547f, 
    -0.05700501f, -0.07083737f, -0.00916130f, -0.30023652f, 0.08449619f, 0.10006063f, 0.51871949f, 0.29188314f, 
    0.15557799f, -0.08218155f, -0.05614014f, 0.06841891f, 0.02994663f, 0.02143692f, -0.03073762f, -0.05683363f, 
    0.08919252f, -0.06511687f, -0.02419851f, -0.01543906f, -0.08171067f, 0.05505592f, -0.11138800f, 0.08364517f, 
    -0.20215185f, -0.20227128f, -0.11806300f, -0.05760207f, 0.27568635f, 0.09904706f, -0.05757340f, 0.07112349f, 
    0.08534865f, -0.33551329f, 0.08185887f, -0.07104292f, -0.04007274f, 0.04182946f, 0.04899764f, -0.05627589f, 
    -0.35358113f, -0.02763642f, 0.24348189f, -0.02649643f, -0.08456495f, -0.06647741f, -0.26051506f, -0.10194474f, 
    -0.05300051f, -0.15512803f, -0.18149368f, 0.06231133f, 0.04695079f, -0.08036898f, 0.19460304f, 0.12456848f, 
    0.10113610f, -0.14717950f, -0.09611631f, 0.00080922f, -0.07375497f, 0.13953066f, 0.16076262f, 0.16895641f, 
    -0.13204788f, -0.49637383f, -0.32496256f, 0.33274293f, 0.12751111f, 0.07138189f, 0.04098804f, 0.06700467f, 
    0.08424486f, 0.03182501f, 0.01659508f, 0.02854931f, 0.21207353f, 0.01917367f, -0.00487008f, 0.06285428f, 
    0.01241056f, -0.01728602f, 0.02296565f, -0.01875611f, 0.16715764f, -0.07879814f, -0.07203224f, 0.04391725f, 
    0.00527794f, 0.22468604f, -0.35957915f, 0.06675176f, -0.34706220f, -0.15567711f, 0.05732040f, -0.19558203f, 
    0.00965343f, -0.17183262f, 0.11320448f, -0.13024431f, -0.22547710f, -0.14310248f, 0.12895577f, -0.02055217f, 
    -0.21766801f, 0.12039945f, -0.29631492f, 0.03313034f, -0.03272451f, 0.05989586f, -0.07539310f, -0.03535649f, 
    -0.10368370f, 0.06935791f, 0.00255920f, 0.14302430f, -0.05519014f, -0.00868305f, 0.07000916f, -0.03601045f, 
    0.00380584f, -0.00120415f, 0.14011636f, 0.16562061f, -0.04841660f, 0.02154904f, -0.05986583f, -0.21237096f, 
    0.05062148f, -0.06753428f, 0.09507316f, -0.07534330f, 0.06865145f, 0.04294586f, -0.26125702f, 0.29067230f, 
    0.08286510f, -0.07916919f, 0.02615114f, 0.00468152f, 0.08829554f, 0.03236096f, 0.07205084f, 0.07523441f, 
    -0.20473434f, -0.12821759f, -0.38407823f, 0.14655672f, 0.12111872f, -0.27012527f, 0.29996699f, 0.08212910f, 
    0.03075870f, 0.14735025f, -0.08866322f, -0.09714847f, -0.17387027f, -0.05674665f, -0.02134653f, 0.05872354f, 
    0.03920579f, 0.02391549f, 0.16855718f, 0.19804846f, -0.20862672f, -0.06150861f, 0.05382947f, 0.09849824f, 
    -0.09757176f, -0.06450037f, -0.03134742f, -0.11056376f, 0.00630308f, 0.37737101f, -0.26774040f, 0.26050377f, 
    -0.04963624f, 0.01839295f, -0.06643873f, -0.15430811f, 0.09430275f, -0.17243479f, -0.00352982f, -0.16507486f, 
    0.28251612f, 0.20704547f, 0.03914295f, 0.04210999f, 0.01985309f, 0.12336062f, 0.06071322f, 0.00890661f, 
    0.05939800f, -0.11554188f, -0.14171182f, 0.04857574f, 0.23931216f, -0.15667798f, -0.07556804f, 0.13896878f, 
    0.12693034f, -0.07694113f, 0.02995977f, 0.09093028f, 0.05058857f, -0.19051406f, -0.06392495f, -0.15693961f, 
    0.22111705f, 0.13929757f, 0.06673416f, -0.00605318f, 0.24012868f, 0.19469388f, -0.03005271f, 0.01717185f, 
    0.02365894f, 0.00073124f, 0.12243217f, 0.06159205f, 0.30768910f, 0.25372660f, 0.30845231f, -0.17016108f, 
    0.28476486f, 0.03875598f, -0.07546042f, 0.36772189f, 0.00403687f, -0.00649823f, 0.14642465f, -0.05631368f, 
    0.15713158f, 0.15726891f, 0.08148847f, -0.20081814f, -0.00973911f, -0.00211578f, 0.02836683f, -0.15003563f, 
    0.18280333f, 0.10263056f, -0.15796061f, 0.09396549f, -0.67286390f, -0.42268863f, 0.32570314f, -0.05754486f, 
    0.10916563f, 0.01864131f, -0.07772031f, 0.05561244f, -0.02078756f, -0.08373588f, 0.07483176f, -0.22494844f, 
    -0.49173072f, -0.06980339f, 0.00564592f, -0.58533615f, 0.05183039f, -0.14761086f, 0.07392482f, 0.11146898f, 
    -0.01411111f, -0.13238810f, -0.13181710f, -0.09568482f, 0.02883952f, 0.11527381f, 0.10933004f, -0.22039102f, 
    0.37308103f, 0.00150728f, 0.08433858f, -0.11288805f, 0.06813061f, -0.05441524f, 0.01407652f, 0.05804763f, 
    0.03219951f, -0.07686469f, -0.11213668f, 0.06037838f, 0.13273343f, 0.19963676f, 0.05401259f, -0.07401410f, 
    0.02594269f, -0.07711615f, -0.03703146f, 0.13543789f, -0.25252813f, 0.19421677f, -0.35011470f, 0.15868755f, 
    0.07099606f, 0.12367314f, -0.00637373f, 0.06846219f, -0.06251109f, -0.17252934f, 0.11322219f, -0.24900529f, 
    0.33356094f, -0.10964089f, 0.13206644f, 0.09540008f, 0.14708836f, -0.01090013f, 0.07534770f, 0.22186518f, 
    0.11178658f, 0.04015471f, 0.09601609f, -0.02492967f, -0.36526939f, -0.54725987f, -0.30894268f, -0.16934143f, 
    0.01663142f, -0.03043138f, -0.07577211f, 0.02808705f, 0.01053063f, 0.11680274f, 0.03659761f, -0.03203781f, 
    -0.29528022f, 0.01706482f, 0.07553901f, -0.22949433f, 0.00709620f, 0.02128718f, 0.02617938f, 0.00226594f, 
    -0.10218947f, -0.07813624f, -0.29080662f, -0.33419713f, 0.36966920f, -0.11222073f, 0.03295427f, 0.12180720f, 
    0.08601470f, 0.03677036f, 0.10096065f, 0.07122391f, 0.00674603f, 0.06503592f, 0.04175295f, 0.07378263f, 
    -0.19725472f, -0.09944320f, 0.05214030f, 0.37919515f, 0.02871500f, -0.12066355f, 0.20081528f, 0.03065212f, 
    -0.27348152f, 0.13244359f, -0.25630075f, -0.10955296f, -0.01762417f, -0.18801697f, -0.00969902f, 0.01865088f, 
    -0.10633428f, 0.02361162f, -0.06504779f, 0.12642896f, -0.06854813f, 0.01556616f, 0.08966335f, 0.29774180f, 
    0.03382801f, 0.00759774f, -0.22024091f, 0.05586467f, 0.02279768f, 0.17249453f, -0.11241352f, 0.15861779f, 
    0.23536962f, 0.10974099f, 0.23104829f, -0.09890649f, -0.05852160f, 0.16955115f, 0.06535754f, -0.36361906f, 
    -0.06249676f, -0.27743515f, 0.04056003f, -0.19172335f, -0.07174785f, 0.01666269f, 0.13495634f, 0.01031588f, 
    0.09215878f, -0.33371541f, 0.28869724f, 0.13471557f, -0.12222506f, -0.04969878f, 0.01727142f, -0.01067543f, 
    0.04323568f, -0.15042591f, 0.04299458f, -0.02400170f, -0.08554715f, 0.30413982f, -0.13818802f, -0.48966390f, 
    -0.12570938f, -0.03105293f, -0.20214522f, 0.06484750f, 0.03901492f, -0.15777577f, 0.02842169f, -0.09665271f, 
    -0.02673393f, -0.18586908f, -0.15391582f, -0.32096514f, -0.09979192f, 0.07785612f, -0.35721406f, -0.00429789f, 
    0.03581098f, -0.08573326f, 0.03815822f, 0.10487127f, -0.28148049f, 0.04824766f, 0.42038542f, -0.20610170f, 
    0.10606460f, 0.04356187f, -0.04511205f, 0.14221865f, 0.17552806f, -0.38332582f, -0.18611901f, -0.05036821f, 
    -0.35353997f, -0.47266850f, -0.31465068f, 0.16414271f, 0.12915002f, -0.09450714f, 0.08077189f, 0.04847764f, 
    -0.02925486f, 0.12054595f, -0.06437845f, 0.09482972f, -0.16239844f, -0.22788411f, -0.04475440f, -0.11748237f, 
    0.03900465f, 0.00032243f, -0.08375634f, 0.03810143f, 0.03608314f, 0.10428696f, 0.00651177f, -0.15188253f, 
    0.03363133f, -0.44885120f, -0.16698354f, 0.35863340f, 0.13164520f, -0.16062988f, -0.26510686f, -0.13938837f, 
    -0.02704544f, 0.05570356f, 0.18573277f, 0.02195429f, -0.12053993f, 0.31390271f, 0.20787394f, -0.15923850f, 
    0.09513858f, -0.20188716f, 0.10715540f, 0.14970708f, -0.07760022f, 0.12828422f, 0.00825771f, 0.11270127f, 
    -0.29827648f, 0.12065085f, 0.02811285f, -0.13523023f, -0.00941963f, 0.15509114f, -0.11120059f, 0.06570460f, 
    0.14235936f, -0.02448111f, -0.11025089f, 0.03686659f, 0.09919745f, -0.11183873f, -0.18337058f, 0.20023234f, 
    -0.04145207f, 0.11114636f, 0.06907067f, 0.00670368f, -0.18361741f, -0.16681279f, -0.26460534f, -0.66282183f, 
    -0.11046782f, -0.12940834f, 0.09257238f, 0.15727252f, -0.02291224f, -0.04289901f, -0.05148238f, -0.05962108f, 
    -0.01996969f, -0.04287296f, 0.08417679f, 0.09467380f, 0.20063454f, -0.18001346f, 0.57630801f, 0.01780674f, 
    -0.07388911f, 0.04051507f, 0.07454782f, -0.13077587f, 0.13083641f, -0.12383378f, 0.08305632f, -0.00360903f, 
    0.36286694f, 0.19542599f, 0.12867153f, 0.01672034f, 0.11344231f, 0.26011688f, 0.05392684f, -0.28301045f, 
    0.07427649f, -0.04126687f, -0.06776521f, 0.09812501f, -0.67335445f, -0.25871685f, 0.25125089f, -0.37359577f, 
    -0.06954629f, 0.05483818f, 0.11512329f, 0.09932406f, 0.14500500f, 0.02107784f, 0.15774857f, 0.06605369f, 
    -0.11948428f, -0.20846733f, 0.02284368f, -0.05336345f, -0.25099126f, 0.06147411f, -0.04758321f, -0.21491712f, 
    0.29810533f, 0.02933643f, 0.16527911f, -0.05301177f, 0.05998249f, 0.15164283f, -0.10231528f, -0.09096002f, 
    0.20370363f, 0.11557566f, -0.26473030f, -0.12042803f, 0.13101333f, -0.18539934f, 0.11551906f, 0.14268515f, 
    -0.84666121f, -0.79010558f, -0.36198217f, -0.45798182f, -0.06689599f, -0.13267146f, -0.25207177f, -0.42383718f, 
    0.01776169f, -0.03400338f, 0.01246443f, -0.09422821f, -0.49070451f, -0.53412753f, -0.61937165f, -0.33447057f, 
    -0.11751816f, 0.11466208f, 0.13169998f, 0.13049552f, 0.13110276f, 0.04911955f, -0.07665906f, 0.00216060f, 
    -0.88752854f, 0.55220556f, 0.60255378f, -0.14514333f, 0.05191549f, -0.37156487f, 0.09780892f, -0.27102828f, 
    -0.08230423f, 0.15420440f, 0.01743939f, 0.09633195f, -0.19897519f, -0.34482402f, -0.35349205f, -0.02535885f, 
    0.01685607f, 0.11842517f, -0.12409001f, 0.02174227f, 0.06513453f, 0.10604140f, -0.06186261f, -0.05976282f, 
    -0.63249815f, -0.25246325f, 0.37773871f, -0.16206083f, -0.04395120f, -0.15389284f, 0.08788372f, 0.13302927f, 
    -0.07128534f, 0.12337302f, -0.01868142f, 0.04166069f, -0.82065678f, -0.80637920f, -0.54687029f, -0.39384007f, 
    -0.05729180f, -0.33404711f, -0.28381944f, -0.57968229f, -0.06152650f, 0.04238903f, -0.02412114f, -0.02215029f, 
    -0.06244275f, 0.02938057f, 0.19221660f, -0.08818246f, 0.20274504f, 0.05548677f, 0.28067839f, -0.19021420f, 
    -0.01985700f, -0.08730044f, 0.08282841f, 0.02075974f, 0.14894691f, -0.06401180f, 0.00740527f, -0.34440622f, 
    0.07899247f, 0.19424427f, 0.21772102f, 0.00587128f, 0.01742675f, 0.23044129f, 0.03092437f, 0.12543531f, 
    -0.68134904f, -0.05978883f, -0.26714078f, 0.14357528f, -0.11576419f, -0.08148348f, -0.00042463f, 0.08278567f, 
    0.02635550f, 0.01234534f, 0.06975479f, 0.02530229f, -0.52900290f, 0.43174762f, 0.40474799f, 0.03415292f, 
    -0.08036040f, 0.00180579f, -0.08990253f, -0.24034753f, -0.05667044f, 0.15690102f, -0.15438376f, 0.22513148f, 
    -0.00558363f, -0.09022766f, -0.07202806f, 0.16884561f, -0.04605228f, 0.05017642f, 0.16308777f, 0.05375372f, 
    0.14104110f, 0.07887172f, 0.07262482f, 0.18113253f, 0.49478838f, 0.16404499f, -0.16386861f, 0.16330305f, 
    -0.10477141f, -0.02552263f, 0.02076416f, 0.04925691f, -0.04277064f, -0.01466019f, 0.24583919f, -0.08608271f, 
    0.44455856f, -0.60261750f, -0.68662906f, -0.05233091f, -0.14225285f, 0.17812869f, 0.25269043f, 0.14114188f, 
    -0.02534955f, 0.14296348f, 0.00987121f, 0.06968286f, -0.05038395f, -0.20933709f, 0.16039246f, 0.13134551f, 
    -0.07386355f, 0.08353055f, 0.09849788f, 0.00957180f, 0.02392412f, -0.13287705f, 0.10670712f, 0.08561666f, 
    0.04045921f, -0.03805971f, 0.22585887f, -0.04097387f, -0.00058543f, 0.09600425f, -0.09296285f, -0.07961193f, 
    -0.01214013f, 0.06940785f, -0.19994508f, -0.03519334f, -0.29265782f, -0.60697186f, 0.04488073f, 0.40146047f, 
    0.17514418f, 0.21310045f, -0.06253009f, -0.48453614f, -0.01087759f, -0.04895730f, -0.01712628f, 0.03409965f, 
    -0.00294398f, -0.03059474f, 0.09997334f, -0.02910791f, 0.04040416f, -0.16278289f, -0.03154134f, 0.16349164f, 
    0.12538005f, 0.24768926f, 0.06026006f, 0.06243148f, 0.25414592f, -0.15404853f, 0.24888621f, -0.16746284f, 
    0.12943256f, -0.25005904f, 0.15993780f, -0.16306071f, 0.08138375f, 0.06517971f, 0.00391931f, 0.00193827f, 
    -0.07409847f, 0.48845580f, -0.05544152f, 0.50934488f, 0.12486041f, -0.13186713f, 0.04596373f, 0.18724048f, 
    0.10940463f, 0.09635738f, -0.12203231f, 0.11154766f, -0.32547796f, -0.33608502f, 0.00973684f, 0.32819656f, 
    0.06030535f, 0.03610330f, 0.09647147f, 0.09165502f, 0.20658191f, 0.20233364f, 0.24439335f, 0.02888333f, 
    -0.46501103f, -0.20940490f, -0.06374686f, 0.03840225f, 0.15147130f, 0.08282104f, -0.02781639f, -0.13765854f, 
    -0.09885357f, -0.11703768f, 0.01328476f, 0.07122970f, -0.46879259f, 0.37478068f, 0.40160099f, 0.01858131f, 
    -0.08699089f, -0.05162674f, -0.22742237f, 0.08554986f, -0.11644841f, 0.02072897f, 0.03975798f, 0.02844228f, 
    0.26456338f, -0.01591808f, -0.38749319f, -0.44332597f, -0.14005773f, 0.02442476f, 0.12290927f, 0.24952495f, 
    0.00585682f, 0.00438032f, 0.02943959f, -0.11866092f, -0.12634733f, -0.43879870f, -0.45815158f, 0.15954837f, 
    -0.26416165f, -0.00521086f, 0.24724144f, 0.00071624f, 0.03209798f, 0.03157016f, 0.02625530f, -0.01092489f, 
    -0.46725145f, -0.59843767f, -0.28873938f, -0.29780820f, -0.38256547f, -0.25945407f, -0.20094612f, -0.21339120f, 
    -0.07715214f, 0.01349138f, -0.06101079f, -0.00860741f, 0.10430973f, 0.09976034f, 0.07902784f, -0.19051063f, 
    -0.00173566f, 0.00928476f, 0.03507514f, -0.02608065f, -0.05294469f, 0.16152188f, -0.04161094f, 0.18893461f, 
    -0.09616458f, 0.00024136f, -0.01731316f, 0.02723822f, 0.08382887f, -0.07760607f, -0.05240399f, 0.10329362f, 
    -0.00051454f, -0.13539721f, 0.24284269f, -0.01616949f, 0.23019579f, -0.04137579f, -0.24192373f, 0.23654395f, 
    0.02095586f, 0.02926731f, -0.02462699f, 0.03457047f, 0.08789082f, 0.02753289f, 0.20052274f, 0.02317403f, 
    -0.37162209f, -0.30770877f, -0.01041665f, -0.57410026f, -0.20931338f, -0.34938201f, -0.13986228f, -0.38195431f, 
    -0.02968930f, 0.02720338f, -0.13011116f, -0.04877002f, -0.31336880f, 0.00357874f, 0.38400286f, 0.35847998f, 
    0.02315043f, -0.13322493f, 0.05495570f, 0.13192905f, -0.10968156f, 0.22516276f, -0.08137541f, -0.01143855f, 
    -0.07016388f, -0.01278128f, -0.09597869f, 0.03044958f, -0.08683441f, -0.33801028f, -0.03784056f, 0.02021825f, 
    -0.01653555f, -0.17878374f, -0.06094705f, -0.10102281f, -0.12715796f, -0.11777857f, 0.11294105f, -0.58765978f, 
    -0.02165883f, 0.09117896f, 0.13852243f, 0.00202534f, 0.12612519f, -0.02456506f, -0.05947297f, 0.00082797f, 
    -0.49452069f, -0.00239551f, -0.19121774f, 0.57289702f, 0.06463964f, 0.00028213f, -0.02468111f, -0.01104591f, 
    -0.01134914f, 0.00594489f, -0.03416515f, 0.02498995f, -0.63666314f, -0.50535202f, -0.33016646f, 0.12905598f, 
    0.09759049f, 0.04238658f, -0.01262275f, -0.07334822f, 0.04569751f, 0.02998152f, -0.06622092f, -0.01685135f, 
    0.43688831f, -0.81509632f, 0.21880318f, -0.65486705f, -0.02200517f, 0.10760453f, -0.01788128f, 0.01487767f, 
    -0.07323771f, 0.18627104f, 0.04134675f, 0.06544486f, 0.16773123f, -0.06429687f, -0.19721527f, -0.24777676f, 
    -0.04041392f, -0.02712118f, -0.10074645f, 0.04648454f, -0.00182260f, -0.00071089f, 0.10085437f, -0.01638935f, 
    0.57814902f, -0.53286415f, -0.31729564f, -0.48672757f, -0.00168615f, -0.01744524f, -0.06209967f, 0.20769154f, 
    0.15948789f, -0.09117799f, 0.00427784f, 0.02495514f, -0.22455350f, -0.30741608f, -0.09218859f, 0.07942846f, 
    0.09446569f, 0.17434664f, 0.08042612f, 0.03405173f, 0.03809666f, 0.06124018f, 0.06085106f, -0.07244837f, 
    -0.06736499f, 0.41343197f, 0.01271000f, 0.03439773f, -0.16239786f, 0.10100020f, 0.09073234f, -0.02696314f, 
    -0.02741313f, 0.09959210f, -0.12976207f, -0.01160169f, -0.19811824f, 0.32407740f, -0.40250984f, 0.08892448f, 
    -0.14880526f, 0.10384285f, 0.03270552f, 0.07481821f, -0.07902621f, 0.02983744f, 0.20436417f, 0.09787908f, 
    -0.84552193f, -0.02593852f, -0.48003706f, -0.03287695f, -0.00468809f, -0.09629382f, 0.37064731f, -0.10500177f, 
    -0.03558011f, 0.04481819f, -0.06802032f, -0.05635088f, 0.48969629f, 0.06092260f, -0.13997358f, -0.15248202f, 
    0.03609767f, -0.05659614f, -0.00445377f, -0.06159362f, 0.00309300f, -0.08418367f, -0.01061080f, -0.10266039f, 
    0.28010774f, -0.58657604f, -0.10879664f, -0.05146560f, -0.04581243f, -0.06116917f, -0.13917202f, 0.00308576f, 
    0.04602900f, 0.09649170f, -0.02305041f, 0.03538626f, -0.03688782f, 0.03715993f, 0.01187935f, -0.06202617f, 
    0.02906874f, 0.02798644f, -0.02560305f, 0.02307430f, 0.01684839f, -0.04300925f, -0.02712515f, -0.07470088f, 
    -0.45402959f, -0.21308863f, -0.23483919f, 0.09727641f, -0.18047981f, 0.16137911f, -0.22990249f, 0.08633205f, 
    -0.04142820f, 0.07916582f, 0.08769132f, 0.12247244f, 0.07038632f, 0.04696996f, -0.28095588f, -0.07303829f, 
    -0.12717855f, -0.03034978f, -0.00420710f, 0.07139750f, -0.13407275f, 0.00467844f, 0.09077632f, -0.09356958f, 
    0.02374123f, 0.08019458f, 0.02643223f, -0.17022859f, -0.03786637f, -0.02471973f, -0.02401923f, 0.06861709f, 
    -0.00705036f, -0.06575228f, 0.06493351f, -0.09498861f, -0.40145031f, -0.33100078f, 0.16016896f, -0.14005481f, 
    -0.01484188f, 0.10050034f, -0.11267178f, 0.19447093f, 0.03779479f, -0.04256118f, 0.02092377f, -0.02647380f, 
    0.37195989f, 0.01395979f, -0.10985223f, -0.34639299f, 0.02396663f, 0.10796887f, -0.01747610f, -0.05635978f, 
    -0.17110766f, -0.07445975f, -0.33209595f, -0.42587921f, -0.64091420f, 1.06431127f, 0.44651410f, 0.31009898f, 
    0.24375035f, -0.27015454f, 0.11380808f, 0.10624162f, -0.07937486f, -0.03098368f, 0.09884804f, 0.04590289f, 
    -0.96000218f, -0.59314531f, -0.61279172f, 0.05309289f, -0.17404860f, 0.06997271f, 0.18311243f, 0.00583587f, 
    0.02352679f, -0.13503022f, -0.02098356f, -0.06433898f, 0.22074130f, -0.24504590f, 0.28953499f, -0.29624552f, 
    -0.00943618f, -0.11314666f, 0.00355845f, 0.06981345f, 0.18537006f, 0.11489268f, 0.27809232f, -0.09440940f, 
    -0.06570253f, 0.22417009f, -0.08661401f, -0.07924917f, -0.05303079f, -0.02103699f, -0.03342124f, -0.03724418f, 
    0.11394102f, 0.07269805f, 0.01190389f, -0.16138066f, 0.66448492f, -0.51410192f, -0.24307476f, -0.22183344f, 
    0.02419935f, 0.00470532f, 0.06170299f, -0.07674520f, 0.00612785f, 0.18683052f, 0.08830227f, 0.04549686f, 
    0.02464843f, 0.03334386f, -0.13665675f, 0.01648588f, -0.05144066f, 0.04560189f, -0.02377502f, -0.22460815f, 
    0.03797894f, -0.01732882f, -0.02250235f, -0.07105305f, -0.24775426f, -0.37237626f, -0.16340582f, -0.46334890f, 
    0.05725702f, 0.13840027f, 0.06082978f, 0.26524714f, -0.03465704f, -0.06512771f, -0.13286059f, 0.00787763f, 
    0.18657406f, -0.58108377f, -0.25015509f, -0.28657764f, -0.11527985f, -0.16163643f, -0.09148764f, 0.24885470f, 
    -0.05009455f, 0.02927670f, -0.07085020f, 0.02683488f, 0.01607057f, 0.06234460f, -0.14207828f, 0.07672301f, 
    0.04135695f, 0.03169261f, -0.03281624f, 0.03991051f, -0.13156870f, 0.22543256f, -0.08589399f, 0.06555200f, 
    0.20831814f, 0.04325358f, -0.04118766f, -0.18512771f, 0.04563555f, 0.10910345f, 0.00977961f, -0.05567301f, 
    -0.27239853f, 0.03913784f, -0.18055283f, -0.27896613f, 0.27471176f, -0.47486785f, 0.47307673f, -0.03639569f, 
    -0.01563962f, -0.08293413f, -0.08069805f, -0.03568026f, 0.00918899f, 0.04677144f, -0.18409050f, -0.23097582f, 
    -0.81755382f, 0.26872388f, -0.13215424f, 0.26761642f, -0.07035946f, -0.16574435f, 0.02284152f, 0.07129979f, 
    -0.00467322f, -0.03476385f, 0.05796390f, 0.02661541f, 0.43900931f, -0.15000331f, -0.22248250f, -0.21416089f, 
    -0.06166007f, -0.00095007f, 0.02292728f, 0.07806498f, 0.05955277f, -0.21075739f, 0.13401553f, 0.03791964f, 
    0.12830172f, -0.04646935f, 0.06829011f, -0.09072536f, -0.10752055f, 0.04800787f, 0.14515539f, 0.09789344f, 
    0.12055770f, 0.03232725f, 0.11051960f, 0.03247240f, 0.11448517f, 0.12798601f, 0.31203124f, -0.29499292f, 
    0.04500748f, 0.02210808f, 0.00750460f, -0.01008634f, -0.01402053f, -0.07168070f, -0.03820825f, 0.10358284f, 
    0.29251564f, 0.10516982f, -0.33742511f, 0.01394607f, 0.03579880f, -0.06269089f, -0.22617523f, -0.02014590f, 
    0.02647955f, 0.05423267f, 0.09756989f, 0.14393118f, -0.11177904f, -0.55735058f, -0.25426635f, 0.39423746f, 
    -0.05723378f, 0.06936033f, 0.23522235f, 0.06017289f, -0.12683941f, -0.01639917f, -0.03167259f, 0.02072869f, 
    -0.03312376f, -0.82878309f, -0.53983539f, -0.15760083f, 0.09469288f, 0.08123604f, 0.06729934f, 0.01936625f, 
    -0.14256175f, 0.16245320f, -0.03829865f, 0.01366053f, 0.24558356f, 0.26514244f, 0.04450279f, -0.41229519f, 
    -0.06685930f, -0.16774105f, 0.04024663f, -0.19099469f, -0.19183896f, 0.06244427f, -0.13232432f, -0.10644173f, 
    -0.27867076f, -0.35555384f, -0.66993576f, -0.04247432f, 0.10069998f, 0.15746093f, 0.05280633f, 0.14972943f, 
    -0.13277377f, 0.04627180f, -0.17775147f, -0.17720030f, -0.16328178f, -0.74009544f, -0.66987681f, -0.24665438f, 
    0.09653307f, -0.15062267f, -0.12766264f, 0.07681389f, -0.05603084f, -0.01646230f, -0.03648011f, 0.01818508f, 
    -0.50129461f, -0.09123313f, -0.03342570f, 0.03420699f, -0.03514255f, -0.16568561f, -0.17104948f, 0.07705284f, 
    0.00936903f, 0.11675005f, 0.23657672f, 0.02637385f, -0.45318213f, -0.14990808f, 0.06200020f, 0.27355242f, 
    -0.01444588f, 0.19947465f, -0.21921359f, 0.21022785f, -0.34463289f, -0.09606037f, -0.14638236f, -0.26067460f, 
    0.18891189f, -0.43486068f, -0.41438946f, 0.19468932f, 0.04066768f, 0.10001038f, 0.02040269f, 0.19638197f, 
    0.01690971f, 0.06732111f, 0.05640759f, 0.12728624f, -0.06236864f, -0.37923434f, -0.29390025f, -0.07605355f, 
    -0.16998778f, 0.09931362f, 0.19781104f, 0.06724996f, 0.20593408f, -0.03730678f, 0.11198604f, -0.19559154f, 
    -0.00493711f, -0.07652673f, 0.06425146f, 0.11989986f, 0.13132814f, 0.04440508f, 0.08878894f, 0.04081144f, 
    -0.08046649f, -0.27540874f, -0.28859368f, -0.66516697f, -0.53623825f, 0.04836714f, -0.06631786f, 0.13651392f, 
    0.15067829f, 0.01157670f, -0.11057075f, -0.04059383f, -0.00208773f, 0.00840124f, 0.14035749f, 0.12707412f, 
    0.31322181f, 0.17248732f, -0.06528098f, -0.07832849f, 0.36523756f, -0.16665234f, -0.24109459f, 0.17339416f, 
    -0.12095929f, 0.02100184f, 0.24318498f, 0.00432942f, 0.31363943f, 0.08575042f, -0.11706181f, 0.08151579f, 
    -0.02183992f, -0.06797411f, -0.02061416f, 0.26387244f, 0.31342879f, -0.08325047f, 0.19312170f, 0.11694240f, 
    -0.22323449f, 0.18805844f, 0.13329798f, -0.07846355f, -0.04123403f, -0.12776396f, 0.00589266f, 0.14630596f, 
    0.07712102f, -0.02422260f, -0.10409383f, 0.22142842f, 0.09226950f, 0.01507919f, 0.00728069f, -0.14694406f, 
    0.06565520f, 0.13536271f, -0.22421701f, 0.00727801f, 0.07293846f, -0.06450438f, -0.12310740f, -0.05361409f, 
    0.39245194f, -0.17289031f, -0.33807161f, -0.36917752f, 0.00164947f, -0.05371537f, -0.02310283f, -0.06104138f, 
    0.17294444f, 0.21272957f, 0.13966607f, 0.02103851f, -0.94009113f, -0.29277980f, -0.17951626f, -0.19021383f, 
    -0.25722611f, 0.08202355f, -0.03217488f, -0.03432313f, 0.10551351f, 0.13361460f, 0.12820014f, 0.04545736f, 
    -0.47376347f, -0.21474251f, 0.39173594f, 0.55703819f, 0.08367962f, 0.15620807f, 0.24471684f, -0.06009470f, 
    0.03682599f, -0.07745559f, 0.25243494f, 0.08629888f, 0.30595881f, -0.08768555f, -0.12714374f, -0.20040284f, 
    0.11040008f, -0.03545343f, 0.11958394f, -0.12776650f, -0.04319096f, -0.04711578f, 0.11825931f, -0.40830368f, 
    -0.39714509f, 0.02281831f, 0.01502378f, -0.31766635f, -0.10910316f, -0.03156528f, 0.04200219f, -0.00321881f, 
    -0.19575660f, -0.03767205f, 0.08712418f, 0.04722318f, -0.11593895f, -0.51302654f, -0.30770031f, -0.29081643f, 
    0.03792219f, 0.21403831f, 0.07154718f, 0.08608180f, 0.00668250f, -0.24094249f, -0.11802813f, -0.20533074f, 
    -0.08287331f, 0.32432956f, 0.18100938f, 0.07210849f, 0.34998435f, -0.17820430f, 0.15425701f, -0.11108878f, 
    -0.03179851f, -0.00154658f, -0.02954523f, 0.07225323f, 0.45492283f, 0.05465218f, -0.45164534f, 0.13454361f, 
    0.00678364f, -0.09799753f, 0.19235890f, -0.22731170f, 0.03824815f, -0.13957810f, -0.04035689f, -0.13635215f, 
    -0.43989161f, -0.28296641f, -0.42724517f, -0.46466827f, -0.12882264f, -0.03495357f, 0.04454965f, -0.03098176f, 
    0.11531900f, -0.06275209f, -0.04313255f, -0.00907873f, -0.32452759f, 0.14311044f, -0.03460287f, 0.26272768f, 
    0.02887144f, -0.03021594f, -0.06122132f, 0.01131631f, 0.13092588f, 0.05559350f, -0.06891876f, -0.15409583f, 
    0.22123055f, -0.04868262f, -0.13702543f, -0.36898991f, -0.01452602f, -0.07453946f, -0.01767766f, -0.08873968f, 
    0.12699144f, 0.16825895f, 0.10644329f, 0.15740472f, 0.86446339f, 0.00559601f, -0.04488354f, -0.64403301f, 
    0.01993860f, -0.10200712f, 0.10964913f, -0.02719170f, 0.03289949f, 0.17188092f, 0.14741348f, 0.09091412f, 
    0.19498736f, -0.07732746f, -0.10050704f, 0.31096825f, 0.05570419f, -0.23292984f, 0.16875315f, -0.10876099f, 
    0.15765122f, 0.13232192f, 0.24048442f, 0.14589828f, -0.12717801f, -0.38177761f, -0.11702884f, 0.16375552f, 
    -0.09667227f, 0.12152312f, -0.00799767f, 0.03463021f, 0.06990292f, 0.08137590f, 0.00780926f, -0.01192850f, 
    -0.24974443f, -0.17820697f, -0.10983558f, 0.06774156f, -0.07537711f, -0.05903760f, 0.11614791f, -0.12143593f, 
    0.00432720f, 0.17381850f, 0.13521403f, 0.24080898f, -0.49617448f, 0.08324468f, 0.04112864f, 0.19888395f, 
    0.24744733f, -0.36044306f, 0.03166882f, 0.09453487f, 0.13739222f, 0.16565917f, -0.02604944f, 0.02365142f, 
    -0.06533597f, -0.04199023f, -0.20696297f, -0.18920533f, 0.17654283f, -0.12755309f, -0.08321016f, 0.28167525f, 
    -0.05079076f, 0.03673318f, -0.00494845f, -0.12598367f, -0.28420898f, 0.67578185f, 0.29796854f, -0.09750736f, 
    -0.07570789f, -0.17376433f, 0.09814186f, 0.06239394f, -0.01416649f, 0.05850220f, -0.00624467f, -0.01215475f, 
    -0.01488935f, 0.15368980f, 0.02237574f, 0.14140624f, -0.26539108f, 0.09117152f, -0.24573651f, -0.04596988f, 
    -0.05318001f, -0.07472298f, 0.05711194f, -0.05536686f, -0.10537353f, -0.63412833f, -0.09842575f, 0.09273086f, 
    0.14099179f, 0.20266910f, 0.16525465f, -0.02442277f, 0.03000695f, -0.04162556f, -0.02182029f, 0.02443225f, 
    0.00530817f, -0.44256106f, -0.13845493f, -0.12695600f, -0.34792295f, -0.04142357f, 0.02269345f, -0.11077236f, 
    0.17209291f, 0.11533727f, 0.17110918f, 0.06679476f, -0.79797596f, 0.04660231f, 0.05141371f, 0.13670436f, 
    -0.33747911f, 0.00144255f, 0.17598590f, 0.33540288f, 0.02622638f, 0.01832164f, 0.03717533f, -0.00293851f, 
    -0.02819773f, -0.20187937f, -0.45165482f, -0.18001725f, -0.09154201f, 0.03810364f, -0.06282715f, 0.16016175f, 
    0.01767977f, -0.14705013f, -0.10775244f, 0.03831203f, -0.52543241f, 0.31413174f, -0.35456744f, -0.05898918f, 
    0.01056163f, -0.15351592f, 0.20565493f, 0.24207947f, -0.11215626f, 0.04353711f, -0.13087885f, -0.03136486f, 
    0.07518543f, -0.22334008f, -0.09964168f, -0.23415332f, 0.06735737f, -0.46788767f, -0.05485932f, 0.01076325f, 
    -0.08184852f, 0.02664028f, 0.08690470f, 0.00543587f, 0.07279855f, 0.14495188f, 0.35805297f, 0.31709254f, 
    0.06013605f, -0.23633282f, -0.26315036f, -0.01635195f, 0.06676794f, -0.11845063f, 0.02665071f, 0.20777600f, 
    0.10127758f, 0.03288844f, 0.08766549f, 0.01351990f, -0.05948592f, 0.02573776f, -0.09820194f, 0.06144876f, 
    0.01762248f, 0.00165370f, 0.17434265f, 0.17172843f, -0.15888761f, 0.14392403f, -0.32130751f, -0.20737986f, 
    0.03991719f, -0.16123049f, 0.07788292f, -0.10190039f, 0.04697265f, 0.09875403f, 0.04050563f, 0.04586697f, 
    0.13704872f, 0.90668571f, -0.54745483f, -0.09432969f, -0.14508078f, -0.00860913f, 0.00655115f, -0.08941798f, 
    0.13954552f, 0.00983387f, -0.05613413f, 0.14376155f, -0.27259031f, -0.26746583f, -0.26470196f, -0.12382809f, 
    0.11505765f, -0.07335205f, 0.14273576f, 0.11735716f, -0.21232356f, -0.25973108f, -0.20864798f, 0.01484087f, 
    0.06430707f, -0.39066684f, -0.29081088f, 0.07874229f, 0.13265033f, 0.13662189f, -0.07640351f, 0.05164417f, 
    0.09659387f, -0.03139951f, 0.12442614f, 0.10237589f, 0.06993517f, -0.17014365f, -0.23678051f, -0.28200981f, 
    -0.18373141f, 0.14294238f, 0.14587380f, 0.27339211f, 0.14620006f, -0.08603920f, 0.00721833f, -0.25648454f, 
    -0.08894601f, 0.28262952f, 0.29905453f, 0.42332262f, 0.12968214f, -0.11530071f, -0.13199428f, -0.25863218f, 
    -0.00443771f, 0.00553040f, -0.25874868f, -0.01350717f, -0.10639218f, 0.25663415f, 0.32051209f, -0.87199014f, 
    -0.00522229f, 0.07979073f, -0.05190667f, -0.14830568f, 0.17392077f, 0.14862762f, -0.12959801f, -0.02484972f, 
    0.09447016f, 0.00082725f, 0.59493446f, -1.19890165f, 0.03461158f, -0.11449207f, 0.06281679f, -0.10158773f, 
    -0.18471985f, -0.11503203f, 0.14252770f, 0.04485660f, -0.06182219f, -0.63667089f, 0.40812442f, -0.26663521f, 
    -0.08096468f, 0.08164071f, -0.17826149f, -0.04714897f, -0.10566238f, 0.26344195f, 0.07476343f, -0.05952258f, 
    -0.25712618f, -0.16173227f, 0.07154874f, -0.10568473f, 0.09580576f, 0.12361673f, 0.00112745f, 0.07102586f, 
    0.09482536f, 0.05658822f, 0.00810995f, 0.04451577f, 0.24345833f, 0.18983401f, 0.33609262f, 0.16583250f, 
    -0.03119124f, -0.25168428f, -0.24286416f, -0.27257705f, 0.08030893f, -0.03789110f, 0.06147874f, 0.13556865f, 
    -0.31510904f, 0.26367611f, -1.04641676f, 0.24100496f, 0.01876975f, -0.10268667f, 0.13382508f, -0.30470297f, 
    0.11312010f, -0.06199636f, -0.19916041f, -0.07676372f, -0.25161114f, -0.14646244f, 0.10130697f, -0.15050966f, 
    -0.11144649f, -0.13246074f, -0.13170244f, -0.00185657f, 0.04250965f, 0.11101292f, 0.05462943f, 0.11856836f, 
    -0.17199931f, 0.07238710f, 0.02835290f, 0.24182764f, 0.08284768f, 0.11787958f, 0.11785142f, 0.19171701f, 
    0.08957711f, 0.06891256f, 0.02990461f, 0.00509897f, -0.02495625f, 0.06021350f, -0.24583000f, 0.05673403f, 
    0.06106657f, -0.02037761f, 0.24166512f, 0.11998289f, 0.15111983f, 0.02434910f, 0.04143913f, 0.48010468f, 
    -0.02204441f, -0.02262135f, 0.15144259f, 0.27723461f, 0.11149736f, -0.11007060f, -0.05668437f, -0.19222867f, 
    0.04094663f, -0.10348225f, -0.09376668f, 0.01951643f, -0.32662770f, -0.55009967f, -0.01626464f, 0.03646661f, 
    0.10178708f, -0.09249558f, 0.02077053f, -0.06321699f, 0.01956192f, 0.06076490f, -0.03133219f, 0.01793091f, 
    -0.03410401f, -0.14474098f, 0.06609818f, -0.10545757f, 0.10277613f, -0.07091250f, 0.10607239f, 0.19936888f, 
    -0.05791740f, -0.01224002f, 0.03064886f, 0.01805636f, 0.32348874f, -0.10269725f, 0.41655660f, -0.21489140f, 
    -0.01255096f, -0.20561855f, -0.16891550f, -0.30254459f, -0.20734558f, 0.11183350f, -0.15698978f, 0.09362411f, 
    0.29042748f, 0.07200854f, 0.16607866f, -0.12955058f, 0.02406351f, 0.23591812f, 0.07983802f, 0.06797104f, 
    -0.01420177f, 0.05252955f, -0.00517844f, 0.08754014f, -0.01251087f, -0.49501035f, -0.46234408f, 0.13681771f, 
    0.00257825f, 0.04862646f, 0.11982274f, 0.03348323f, 0.01929775f, -0.10565618f, -0.10984243f, -0.11932826f, 
    -0.33207631f, -0.23335804f, -0.26342902f, 0.32823059f, -0.08658718f, -0.06062760f, -0.15713187f, 0.21269286f, 
    0.02157513f, 0.07377511f, -0.04399710f, 0.28102648f, -0.21794806f, -0.27076524f, -0.00423103f, 0.20006561f, 
    -0.05186203f, 0.10035180f, -0.10257600f, -0.03103801f, -0.03165896f, -0.16077262f, -0.10346893f, 0.19495131f, 
    0.24716455f, 0.07633515f, 0.17415909f, 0.14402859f, -0.10038684f, 0.18436915f, 0.10254540f, 0.07652029f, 
    0.01850271f, -0.07231559f, 0.07848589f, -0.18566863f, -0.30745116f, -0.02977163f, 0.04744832f, -0.16131739f, 
    -0.33616042f, -0.15255596f, 0.07833993f, -0.05541441f, 0.13478895f, -0.11869809f, -0.06398301f, -0.10561500f, 
    0.19573840f, -0.02716208f, 0.00491340f, 0.04941170f, -0.04403190f, -0.37549087f, 0.12427799f, 0.15728517f, 
    -0.12646741f, 0.11142331f, -0.08990684f, -0.41391280f, -0.51028687f, 0.01648156f, -0.52545863f, 0.14986259f, 
    -0.07735853f, -0.15188053f, -0.33587369f, 0.14776984f, 0.01143530f, 0.29078028f, -0.01306184f, 0.10238430f, 
    0.30109209f, 0.11883208f, 0.44450179f, -0.01021431f, 0.02678045f, 0.13128580f, -0.10789861f, 0.03125812f, 
    0.23866089f, 0.09366659f, 0.11853405f, 0.10291059f, 0.42160645f, -0.69826257f, 0.16719359f, 0.14475334f, 
    -0.18800323f, -0.19535731f, 0.15097557f, -0.04731578f, -0.20106457f, -0.17896970f, -0.41335267f, -0.13449778f, 
    -0.04389678f, -0.13705747f, 0.14862309f, 0.06003201f, -0.12848240f, 0.10467788f, 0.25086594f, 0.14927712f, 
    0.18676883f, 0.05482559f, -0.08974531f, 0.00024668f, -0.51067638f, 0.21285582f, 0.25702175f, -0.33100900f, 
    0.08657140f, -0.03739305f, -0.14833128f, -0.19467138f, -0.15932518f, 0.02914832f, -0.14509849f, -0.24139526f, 
    -0.10416658f, 0.19763668f, -0.06255074f, -0.03978162f, 0.14219651f, 0.18714240f, -0.13062234f, 0.07660637f, 
    -0.09100552f, -0.25221565f, -0.46329579f, -0.47672117f, -0.01116353f, 0.09948284f, -0.22068377f, 0.12763584f, 
    -0.19293123f, -0.21225776f, -0.00053584f, 0.02231843f, -0.26882923f, 0.05944180f, 0.14156994f, 0.08445892f, 
    -0.17735995f, -0.05016544f, -0.37305915f, -0.29828903f, -0.19391596f, -0.29131579f, 0.31201646f, -0.06192436f, 
    -0.18862382f, 0.19815131f, -0.22232145f, 0.10836995f, -0.02122861f, 0.05490116f, 0.51161516f, 0.00907605f, 
    -0.10964340f, -0.02383896f, 0.28131711f, 0.18442602f, 0.36417636f, 0.21234030f, 0.12945701f, 0.38113809f, 
    -0.09304937f, 0.05840902f, 0.30044907f, -0.07363221f, -0.00831544f, -0.01763204f, 0.01171520f, 0.05960001f, 
    -0.09908167f, 0.24310914f, -0.05729502f, -0.04024065f, -0.02565877f, 0.05763591f, 0.10306693f, 0.11577028f, 
    0.07987437f, -0.18360268f, 0.29982236f, -0.27092448f, 0.00417906f, 0.03023510f, -0.11627540f, -0.04410747f, 
    -0.39999327f, 0.31309491f, -0.07095151f, -0.15364093f, -0.27088884f, 0.12341261f, -0.13141614f, -0.05481095f, 
    0.17735761f, -0.10453599f, 0.12476812f, 0.21794327f, 0.30851015f, -0.44301179f, 0.47429615f, 0.35563469f, 
    -0.12974846f, 0.08128437f, 0.14584465f, 0.03982891f, 0.04595705f, -0.11022430f, 0.29743108f, -0.07814762f, 
    -0.10191068f, 0.26799980f, 0.23361741f, 0.32545152f, -0.03039655f, -0.02674347f, -0.13767920f, 0.10971612f, 
    -0.02720685f, 0.13474289f, 0.00537025f, -0.48530364f, -0.35539901f, 0.36564741f, 0.03696373f, -0.00145985f, 
    0.17737480f, 0.12344178f, -0.04963114f, 0.05664362f, 0.04555709f, -0.04503736f, -0.28071281f, -0.12564573f, 
    -0.08848190f, -0.44718874f, 0.32461035f, -0.20548479f, -0.44509092f, -0.24972212f, 0.08248353f, 0.04198642f, 
    0.12626317f, -0.06620669f, -0.19678372f, -0.10580558f, -0.21220973f, 0.37645558f, -0.08075769f, -0.19170418f, 
    -0.01031118f, 0.08694144f, -0.05845373f, -0.01473248f, -0.16414152f, -0.13268012f, -0.18420108f, -0.02155585f, 
    -0.46004623f, 0.54058623f, -0.29870924f, -0.14723749f, -0.14612201f, 0.18073240f, -0.00195385f, 0.15475141f, 
    -0.21288332f, -0.02601333f, 0.11279161f, 0.11614534f, -0.09592025f, -0.19533455f, -0.37389046f, 0.03537266f, 
    0.03370613f, 0.14883456f, -0.19582696f, -0.33447638f, -0.25263807f, -0.00388156f, 0.05971458f, -0.24604970f, 
    -0.26088083f, 0.13067083f, -0.59533906f, -0.09692024f, -0.02217042f, 0.01852574f, 0.08953793f, 0.15283120f, 
    0.06991690f, 0.21436711f, -0.19983433f, -0.11943784f, -0.06065570f, 0.11020843f, -0.07921930f, 0.51927048f, 
    -0.00714015f, -0.20929073f, -0.15440947f, -0.08681858f, -0.26877519f, -0.35773987f, -0.25377008f, -0.56948763f, 
    -0.42938960f, 0.08063190f, -0.37447751f, -0.30759624f, -0.23477945f, -0.03282624f, 0.16162664f, -0.20717593f, 
    0.17118198f, 0.10954528f, -0.14913456f, 0.02504878f, -0.55698317f, 0.59807599f, 0.37518939f, 0.54141384f, 
    0.11443276f, -0.05797775f, 0.20536958f, 0.02423896f, -0.14134386f, -0.10925198f, -0.08992358f, -0.18192388f, 
    -0.27689987f, -0.14274180f, 0.34269559f, -0.07695812f, -0.03164857f, -0.15848546f, -0.31761661f, 0.02021487f, 
    0.11668943f, 0.11087819f, 0.22047970f, 0.08880451f, 0.17741454f, 0.35566273f, 0.02006858f, -0.04891157f, 
    0.06570639f, -0.03609222f, 0.25330865f, 0.01733582f, -0.03409985f, 0.26531821f, 0.13189700f, 0.09416337f, 
    -0.01402178f, 0.25638276f, -0.00649711f, -0.01040922f, -0.13150455f, -0.27928707f, -0.04737183f, -0.17417426f, 
    -0.17362246f, 0.31787601f, 0.38603646f, 0.18990812f, -0.13771884f, 0.23623519f, -0.36151731f, 0.44217646f, 
    -0.08236139f, 0.07760800f, 0.07710619f, -0.18754244f, -0.11795598f, -0.08225366f, -0.16645405f, 0.18582572f, 
    0.15528359f, 0.02807138f, 0.48740363f, 0.35581139f, -0.43167230f, 0.07204739f, -0.33162943f, -0.24523121f, 
    0.03403836f, -0.11006436f, -0.07165078f, -0.03422888f, 0.12715359f, -0.13272335f, 0.10671014f, -0.21654569f, 
    0.02259502f, -0.26499164f, 0.09908140f, 0.04609222f, -0.00609560f, 0.09333903f, -0.00614048f, -0.15165181f, 
    -0.47646275f, -0.58559406f, -0.00219739f, 0.17269644f, 0.12305476f, -0.27066413f, -0.14091243f, 0.06766918f, 
    0.01172995f, -0.09013939f, -0.01206764f, -0.34573171f, 0.25216198f, 0.33501464f, 0.05263199f, -0.22398221f, 
    -0.03315017f, -0.06738324f, 0.04536414f, -0.04623217f, -0.03875257f, 0.16485155f, -0.07520639f, -0.06416728f, 
    0.00742398f, 0.55159026f, -0.10382107f, -0.62019610f, -0.09225789f, -0.12742570f, 0.05225702f, 0.12506382f, 
    0.02374642f, 0.11455002f, 0.10935119f, -0.17336617f, -0.09487382f, -0.37903535f, 0.12048685f, -0.19013907f, 
    -0.11502016f, 0.05860281f, -0.14212054f, -0.36405748f, -0.00557973f, -0.10078693f, -0.07600629f, -0.12111594f, 
    -0.06831142f, 0.03298226f, 0.22444434f, -0.00524585f, 0.19162685f, 0.06482207f, 0.14623952f, -0.28784475f, 
    0.15328361f, -0.05915225f, -0.15886542f, 0.05002044f, 0.09969699f, -0.10859064f, 0.62583804f, -0.55132419f, 
    -0.06421961f, 0.07070026f, -0.14559205f, 0.24435653f, 0.00208518f, 0.16305728f, 0.12618835f, 0.23705444f, 
    0.23926005f, -0.13845506f, 0.25461772f, -0.62376565f, -0.09624445f, -0.10147641f, -0.16733572f, -0.11110261f, 
    -0.08425106f, -0.02275168f, 0.11336832f, -0.08785906f, -0.44956142f, -0.23720817f, -0.39223382f, -0.00047747f, 
    0.17956492f, 0.04008079f, 0.00118541f, 0.05796915f, 0.03565948f, 0.10679664f, 0.11158021f, -0.02756037f, 
    -0.48355493f, 0.16450228f, -0.39806178f, -0.02579060f, 0.05686430f, -0.13213660f, 0.12751842f, 0.03811612f, 
    -0.03524682f, -0.13186398f, 0.08957309f, 0.13983466f, 0.36024809f, -0.35830361f, 0.32102162f, -0.13576415f, 
    0.08022325f, 0.02219673f, 0.12709351f, 0.04263097f, -0.15350430f, -0.05112271f, 0.23860131f, 0.09409830f, 
    0.40594521f, -0.35483831f, 0.82714659f, 0.03875721f, 0.35378781f, -0.21031892f, 0.30428588f, 0.02855787f, 
    -0.04990279f, -0.03829406f, 0.05074154f, 0.07743937f, 0.16667345f, 0.37155125f, 0.11270124f, -0.34246659f, 
    0.07918376f, 0.15750328f, -0.03175927f, -0.02798371f, -0.06550510f, 0.27523115f, -0.10156377f, -0.11145082f, 
    -0.05817088f, 0.22377487f, -0.16930310f, 0.04581232f, -0.05894182f, 0.03428555f, 0.13744132f, -0.13673109f, 
    0.02076763f, 0.16991414f, 0.04782598f, 0.05018279f, -0.31592903f, -0.45273066f, 0.16998306f, 0.17767887f, 
    -0.52530593f, 0.01677539f, 0.05321173f, -0.20296510f, 0.03277845f, -0.08906745f, -0.02425767f, 0.16554090f, 
    -0.22456135f, -0.28281662f, -0.21695192f, 0.08708125f, 0.20962782f, -0.01321688f, 0.00085691f, 0.16407171f, 
    0.02929572f, 0.10112084f, 0.00295754f, 0.07555988f, -0.92248511f, -0.22923814f, -0.25590539f, 0.13503855f, 
    -0.32776406f, 0.36976430f, -0.28420299f, 0.07823531f, -0.03427710f, 0.07919541f, 0.07770794f, 0.20335817f, 
    -0.12487023f, -0.44427621f, 0.16710719f, -0.19509234f, -0.04260551f, -0.00754657f, -0.05025208f, -0.03283160f, 
    -0.18008356f, 0.19806428f, -0.10390412f, -0.12331599f, -0.58174437f, 0.15657681f, -0.47276342f, 0.17350236f, 
    0.02864264f, 0.06866647f, 0.08087564f, -0.01249669f, 0.08998856f, -0.03218160f, 0.13787666f, 0.03696328f, 
    0.12323005f, 0.26755095f, 0.38710889f, -0.24703327f, -0.18894646f, 0.10722452f, -0.01880538f, -0.04063455f, 
    0.04495046f, -0.11631339f, 0.03956592f, 0.16353980f, -0.09854124f, -0.20305775f, -0.14233759f, 0.09079344f, 
    0.01750982f, -0.13893770f, 0.11023579f, -0.02193620f, 0.02390673f, 0.12558712f, -0.05220914f, -0.16675191f, 
    0.94522715f, -0.19937128f, 0.28733614f, -0.03164111f, 0.10986350f, 0.18574631f, -0.15712799f, 0.26938859f, 
    -0.10806900f, 0.03935495f, 0.04053845f, -0.17662731f, 0.17344779f, -0.02642167f, 0.13505411f, -0.07146504f, 
    0.04613078f, -0.05796843f, 0.24284042f, 0.02587975f, 0.06055603f, 0.11099824f, 0.04822531f, 0.14425690f, 
    -0.28091747f, -0.19627176f, -0.36677289f, 0.18412539f, -0.13670586f, -0.10011143f, -0.23621888f, -0.13327257f, 
    -0.01661471f, 0.15016644f, 0.11794982f, -0.02881016f, 0.05069352f, -0.11384891f, 0.32856044f, 0.09434544f, 
    0.15771465f, -0.06176472f, 0.15535806f, 0.27187330f, 0.20125557f, 0.18844569f, 0.15568952f, 0.17487091f, 
    -0.13579585f, -0.17516884f, -0.09591331f, -0.00288265f, 0.15009251f, 0.09610777f, 0.03640587f, 0.13975337f, 
    0.25114372f, 0.04237083f, 0.01205310f, -0.01426538f, -0.07197070f, -0.56605107f, -0.05543215f, 0.55014688f, 
    0.29651546f, 0.07932218f, -0.15266104f, -0.11962739f, 0.04246625f, 0.07157330f, 0.00973405f, 0.02677244f, 
    0.12479834f, -0.14590515f, -0.22555177f, 0.21581885f, -0.23443651f, -0.03216498f, -0.11339279f, 0.31040156f, 
    -0.11221778f, 0.09754138f, -0.08489688f, -0.17116393f, -0.56923246f, 0.25803590f, -0.52036864f, 0.15819563f, 
    0.11806803f, -0.17445511f, -0.11424094f, 0.12145001f, -0.19178227f, 0.01518603f, -0.07135426f, -0.07789388f, 
    -0.40006942f, -0.02265344f, -0.02686901f, -0.02913145f, 0.15985204f, 0.13770878f, 0.04310891f, 0.09769546f, 
    -0.13127510f, -0.15806496f, -0.29842925f, -0.35823897f, -0.18972102f, -0.32441691f, 0.55383295f, 0.70524430f, 
    -0.33982748f, -0.01414627f, -0.11839864f, -0.16231997f, -0.24312423f, 0.12386433f, -0.08179314f, -0.02559761f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.21562654f, 0.12742004f, 0.10063227f, -0.08557962f, -0.10678557f, 0.10818792f, 0.02987766f, -0.15297227f, 
    0.12519166f, 0.00918738f, 0.06397877f, -0.03957259f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
