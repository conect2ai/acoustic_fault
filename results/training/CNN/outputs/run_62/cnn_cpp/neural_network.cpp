#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.99285126f, -0.23383082f, 0.07664958f, -0.43103501f, -0.30412841f, 0.42877856f, 0.25840968f, -0.42697415f, 
    -0.56557703f, -0.28010386f, -0.08229072f, 0.47028616f, 0.40211603f, 0.45390216f, -0.16920975f, -0.09669027f, 
    -0.06891531f, 0.31264290f, 0.34667209f, -0.27790430f, -0.06291801f, 0.11727259f, 0.05640152f, -0.13137902f, 
    0.42659125f, -0.16584909f, -0.52239984f, -0.44173124f, -0.44782081f, -0.08601816f, -0.05621721f, -0.14049882f, 
    0.28844398f, 0.18951856f, -0.48140103f, -0.13210452f, -0.10682661f, -0.34296677f, -0.24345627f, -0.18721223f, 
    0.48468903f, 0.22435276f, 0.24667281f, 0.29654774f, -0.01623846f, -0.03274836f, -0.48878497f, 0.25255474f, 
    0.15067385f, 0.30027679f, -0.48400345f, -0.98066020f, -0.58404541f, 0.35008571f, 0.74712956f, 0.81417352f, 
    0.89697134f, -0.20078009f, 0.42019573f, -0.11634417f, -0.05830957f, 0.16448067f, -0.25879389f, 0.21872732f, 
    0.11901809f, 0.06241408f, -0.03892047f, 0.17307192f, -0.00336462f, -0.21117444f, 0.03914596f, -0.00996364f, 
    -0.21832915f, -0.10652297f, -0.05749124f, 1.14914954f, 0.54108834f, 0.74703556f, -0.30745539f, -0.75449926f, 
    0.25550327f, -0.57559174f, 0.12496610f, 0.28279665f, 0.43734312f, 0.16324849f, -0.24217416f, -0.28617239f, 
    -0.04415460f, 0.20853180f, 0.08732265f, 0.02652107f, -0.19622293f, -0.17763147f, 0.18563050f, 0.03808845f, 
    0.03751160f, 0.04111642f, -0.07865547f, 0.07250176f, -0.72913879f, -0.25227568f, 0.67013675f, 0.52507842f, 
    -0.49053830f, -0.52177960f, -0.54818887f, 0.31542593f, -0.23293065f, 0.13732919f, 0.25302619f, 0.20350993f, 
    0.33599541f, -0.06066708f, -0.04395925f, -0.25503170f, -0.12400171f, 0.08716787f, 0.39625689f, -0.03193160f, 
    0.10285179f, -0.22085564f, -0.24399120f, 0.19369452f, 0.22978221f, 0.07355727f, -0.87199175f, -0.70960897f, 
    -0.56814128f, 0.16562794f, -0.69377249f, 0.00293215f, -0.16973606f, -0.50521040f, 0.58581626f, -0.30753294f, 
    0.29460105f, 0.00058832f, -0.13015828f, 0.13038333f, -0.05123871f, -0.05808467f, 0.04093387f, -0.21791403f, 
    -0.21655099f, 0.01004635f, -0.00005702f, 0.10796326f, -0.00770123f, -0.03457877f, 0.42237961f, -0.08076520f, 
    -0.00440782f, 0.37236604f, -0.21855748f, -0.41018587f, -0.94095206f, -0.61300600f, -0.51528537f, -0.50331175f, 
    -0.11322521f, -0.03705654f, 0.17279950f, -0.57349336f, -0.04425285f, -0.20019999f, -0.15608555f, -0.47694287f, 
    -0.37389952f, -0.04287827f, 0.10932555f, 0.14272776f, 0.12559204f, -0.05438809f, -0.01151261f, 0.57042277f, 
    0.41819903f, 0.28439128f, 0.42753336f, 0.76949924f, 0.43166134f, 0.54205137f, 0.47658908f, -0.08985489f, 
    -0.01205143f, -0.25991115f, -0.08633802f, 0.33758995f, 0.33134875f, 0.26656118f, 0.19299714f, -0.06465116f, 
    0.25095743f, -0.12424651f, -0.02901305f, 0.15489580f, -0.26840404f, 0.16122824f, 0.15682714f, 0.06592683f, 
    -0.14760382f, 0.59267497f, -0.57314771f, -0.53501523f, -0.46408269f, 0.49307731f, -0.56943995f, 0.25455588f, 
    -0.24810341f, -0.12187237f, 0.38364196f, 0.19355609f, 0.06926043f, 0.20047912f, 0.20853196f, 0.17945439f, 
    -0.22263739f, 0.13816270f, -0.39779100f, -0.09100784f, 0.16051680f, 0.04329776f, -0.14168993f, -0.32431197f, 
    0.07492106f, 0.59136719f, 0.21489806f, 0.31172177f, 0.83678585f, 0.15423472f, 0.44558284f, 0.01941340f, 
    0.14339592f, 0.21134828f, 0.25001189f, -0.56259227f, 0.04055615f, -0.38246354f, 0.04287847f, -0.26764554f, 
    -0.43031266f, 0.20814355f, -0.18385974f, -0.28212684f, -0.22489963f, -0.26233801f, -0.38220680f, -0.36302257f, 
    -0.30044103f, 0.05990538f, 0.41290972f, 0.36156699f, 0.53467107f, 0.38497365f, -0.94960099f, -0.68290281f, 
    -0.36613616f, 0.05340816f, 0.07846098f, -0.40035489f, 0.01874314f, 0.25842640f, 0.02242821f, 0.27496642f, 
    -0.18650497f, 0.04956809f, -0.27824727f, 0.10247141f, -0.10525406f, 0.07762294f, -0.19580548f, 0.26783019f, 
    0.14410751f, 0.26095164f, 0.06367357f, -0.48919621f, -0.53530848f, -0.16409805f, -0.16624288f, -0.61059982f, 
    0.20656940f, 0.70102936f, -0.16127713f, -0.07590649f, 0.39608330f, 0.25144964f, 0.11566003f, -0.15291262f, 
    -0.13956347f, -0.09449709f, 0.19649978f, 0.04125408f, -0.03735332f, -0.05929079f, 0.28272721f, -0.01985391f, 
    0.19764455f, 0.17200853f, -0.14055361f, 0.10463575f, -0.51493740f, -0.60449189f, -0.50707871f, -0.41435614f, 
    -0.38663456f, 0.51273191f, 0.80207324f, 0.05829563f, 0.17621391f, 0.36988655f, -0.26041946f, -0.20245858f, 
    0.17662114f, -0.18894798f, -0.00166933f, -0.33155665f, -0.00102747f, 0.05923027f, 0.23558407f, -0.25527319f, 
    -0.14222983f, -0.23343381f, -0.02566470f, 0.13938183f, 0.12658420f, -0.50859123f, -0.18457596f, -0.31366470f, 
    -0.48107594f, -0.09374508f, -0.00309767f, -0.17531638f, -0.11545980f, -0.16949269f, -0.50439888f, -0.05702625f, 
    -0.49324679f, -0.44718862f, -0.15071517f, 0.03332945f, -0.20255139f, -0.13285068f, -0.04292075f, 0.15068230f, 
    -0.04533443f, -0.13088271f, 0.52782220f, -0.34151483f, 0.15329626f, -0.28059322f, -0.69728518f, 0.13664371f, 
    -0.42666888f, -0.48752266f, -0.30287322f, -0.40241507f, -0.18374962f, -0.18166143f, 0.26370490f, 0.49909130f, 
    0.02762287f, 0.33491987f, -0.27918109f, 0.17164940f, -0.46121031f, -0.25117585f, 0.14839703f, 0.38223296f, 
    -0.09664124f, 0.13542433f, 0.10834485f, 0.01125480f, -0.15548331f, -0.09973306f, 0.14071609f, -0.02298270f, 
    -0.47995263f, 0.66012025f, 0.97890002f, -0.37292466f, 0.13154763f, 0.59800273f, 0.37660527f, 0.27412787f, 
    0.54534340f, -0.02371756f, -0.05772397f, -0.08079443f, -0.14924414f, -0.10486701f, -0.19926764f, -0.00308597f, 
    -0.28571275f, 0.20340255f, -0.31018147f, 0.23126380f, 0.12556213f, -0.16957845f, 0.06284181f, 0.20777614f, 
    0.38079038f, 0.40133995f, -0.22686590f, 1.01194656f, 0.13886747f, 0.46476603f, 0.34699488f, 0.29576451f, 
    0.39997044f, -0.03500418f, 0.01825297f, -0.26705182f, -0.03540806f, -0.21852253f, 0.12092210f, -0.26825923f, 
    -0.29968143f, -0.01431782f, -0.20878752f, 0.22879001f, 0.32552749f, -0.03029092f, 0.16945021f, -0.06500480f, 
    0.13575333f, 0.45085964f, 0.26579475f, 0.40273806f, -0.02412790f, 0.15197387f, -0.78973371f, -1.07357121f, 
    -0.42889693f, 0.25728315f, 0.44676310f, -0.00462428f, 0.05356039f, -0.09043162f, 0.06583299f, -0.04883588f, 
    -0.11266271f, -0.02699650f, -0.30344301f, 0.08995308f, 0.10576273f, 0.12739240f, 0.18767710f, 0.10527539f, 
    -0.36637905f, -0.14264782f, -0.46810952f, 0.16359003f, -0.72301906f, 0.24249655f, 0.44093376f, -0.73936707f, 
    0.15727335f, 0.01797935f, 0.09308182f, -0.35742030f, 0.41043067f, -0.02358704f, -0.00636306f, -0.01211602f, 
    0.47086090f, -0.02697912f, 0.20629784f, 0.14999413f, 0.18202429f, 0.05744059f, 0.29291040f, 0.41001275f, 
    -0.10641298f, 0.33188841f, 0.35367650f, -0.61190575f, -0.06142100f, 0.76534039f, -0.06367644f, -1.26011562f, 
    0.37282914f, -0.53058112f, -0.23521909f, 0.25156847f, 0.20346716f, 0.10223683f, 0.31448838f, -0.49138916f, 
    0.27988020f, 0.04471928f, -0.12536766f, 0.15834130f, 0.05831955f, -0.06266376f, -0.16814138f, -0.12555371f, 
    -0.04487097f, 0.07502449f, -0.13557176f, 0.06016829f, 0.90183288f, 0.13007341f, 0.52507013f, 0.77679086f, 
    0.87277281f, -0.12013304f, 0.16420454f, -0.41432357f, -0.71024179f, -0.32579270f, 0.44295704f, 0.15467741f, 
    0.11551809f, 0.14949699f, 0.08562689f, -0.20885934f, 0.15919061f, 0.06422470f, 0.31882212f, -0.16367060f, 
    -0.13062260f, 0.20542106f, -0.07568483f, -0.08229940f, 0.02581711f, -0.62134761f, -0.18064834f, -0.55146950f, 
    -0.47701797f, -0.36822799f, -0.50242007f, -0.15443721f, -0.22842318f, -0.31795824f, 0.21662700f, 0.43365499f, 
    0.28802299f, 0.40400222f, 0.03713841f, 0.05416134f, 0.38544920f, -0.17638499f, 0.07091292f, 0.22367595f, 
    0.06784885f, -0.35544455f, -0.08455345f, 0.12416493f, -0.05294821f, 0.07671760f, -0.30983654f, 0.82674927f, 
    -0.61425728f, 0.61775935f, -0.51607800f, -0.03552921f, -0.50355631f, -0.48743641f, -0.07622079f, -0.32986775f, 
    0.13884559f, 0.25188679f, 0.07557714f, -0.15925668f, -0.43574610f, -0.22067142f, -0.04077439f, -0.04395229f, 
    0.17708807f, -0.32759875f, -0.07085523f, -0.40280268f, -0.17491852f, -0.12655362f, 0.04501281f, -0.84675753f, 
    -0.47315675f, -0.54209363f, 0.19315676f, 0.52869701f, -0.67562819f, 0.66526693f, 0.62787700f, -0.45018926f, 
    0.04266925f, 0.13286401f, 0.07621417f, 0.19027378f, -0.09950086f, 0.16580078f, -0.01242221f, 0.15063374f, 
    0.00699833f, 0.05259199f, -0.11895438f, -0.12730891f, -0.14287980f, 0.08826859f, -0.09156106f, -0.04660143f, 
    0.47889435f, -0.09006332f, 0.64600456f, 0.19812107f, 0.06332611f, 0.29727557f, -0.15353540f, 0.35004237f, 
    -0.07992117f, -0.46635231f, -0.41729558f, -0.36876786f, -0.17501594f, -0.03017276f, 0.24013060f, 0.21387905f, 
    0.54159629f, 0.31048974f, 0.16378026f, -0.17830779f, 0.10498129f, 0.12837940f, 0.33212927f, 0.27715340f, 
    -0.09528615f, -1.12431371f, 0.87963682f, -0.46763349f, -0.06057210f, 0.01274523f, 0.38409448f, 0.87534928f, 
    -0.36779651f, -0.13949305f, 0.24695429f, 0.15853997f, -0.25679171f, 0.00979968f, -0.42914525f, 0.22458816f, 
    0.12481461f, -0.01586257f, -0.12304716f, -0.03410944f, -0.15514262f, 0.01955802f, 0.10936272f, 0.22165816f, 
    0.17965744f, 0.10296383f, -0.65127403f, 0.74597663f, 0.25267699f, 0.14881893f, -0.09057418f, -0.14630601f, 
    0.59453422f, 0.16619694f, 0.28736684f, 0.39685875f, -0.65307426f, 0.16534862f, 0.33735308f, 0.02992799f, 
    0.06067118f, -0.26052353f, 0.20594308f, 0.19270556f, -0.07046370f, -0.27982616f, 0.25184372f, -0.10954569f, 
    -0.14171681f, 0.01255909f, -0.11448363f, 0.92672050f, 0.44781724f, 0.46045810f, 0.56406492f, 0.69759244f, 
    0.11048579f, -0.18963610f, 0.08317811f, 0.37940955f, 0.13796321f, 0.05953118f, 0.02995108f, -0.19272892f, 
    -0.24038541f, 0.05362645f, 0.18789895f, 0.03951840f, -0.08603120f, -0.31709766f, -0.01328750f, 0.06534049f, 
    0.13526751f, 0.33099392f, 0.08505051f, 0.09193691f, -0.27863142f, -0.99364007f, 0.03342487f, 0.29213837f, 
    0.48826864f, -0.85515833f, 0.16914371f, -0.09077177f, -0.18222776f, 0.01479727f, 0.33289975f, -0.11049283f, 
    -0.03750595f, -0.21041662f, -0.09608512f, 0.21371755f, 0.36210802f, 0.19922228f, 0.09505882f, -0.15415232f, 
    -0.19609697f, -0.28308821f, -0.08831768f, 0.04059252f, -0.19131488f, -0.21184129f, -0.77166498f, 0.22763547f, 
    0.72161186f, -0.10542710f, 0.46057421f, 0.42470220f, 0.46445838f, 0.41333756f, -0.30278647f, -0.55737698f, 
    -0.04223349f, -0.34547970f, 0.54717129f, 0.21948574f, -0.17558937f, -0.07415894f, -0.31160155f, -0.19146198f, 
    0.35940054f, -0.30050066f, -0.05091348f, 0.04725873f, -0.15673253f, -0.10089067f, 0.60016656f, 0.68030661f, 
    0.42207360f, 0.57618862f, 0.73867548f, -0.11360084f, -0.44846794f, -0.04869572f, -0.05143284f, 0.17002398f, 
    0.35232353f, 0.07108297f, -0.03965394f, 0.16020897f, -0.21386498f, 0.13537616f, 0.17241545f, 0.31101671f, 
    0.19401084f, 0.48678553f, 0.09237176f, 0.00561080f, 0.31203169f, 0.03641586f, 0.04707430f, 0.62585175f, 
    1.01813304f, 1.05178726f, -0.31529915f, -0.44090921f, -0.61922914f, 0.63662273f, -0.36506507f, -0.24675269f, 
    -0.02691974f, 0.08791270f, 0.25236914f, -0.02338184f, 0.02548704f, 0.09970620f, 0.17446986f, -0.32523811f, 
    0.12035416f, 0.09562457f, -0.19795950f, -0.09729582f, 0.17604072f, 0.05577743f, 0.01294466f, 0.22704728f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.10048097f, 0.21479538f, 0.16938441f, 0.35275793f, 0.31883976f, 0.38350654f, 0.16792703f, 0.22947846f, 
    0.23446268f, 0.16851345f, 0.17752011f, -0.01303921f, -0.01357760f, -0.12733634f, 0.24254136f, 0.10379107f, 
    0.05238289f, 0.27709469f, 0.09484083f, 0.18726860f, -0.12288050f, 0.14622329f, 0.04925004f, 0.22990876f, 
    0.11150353f, -0.02954563f, -0.02375690f, 0.36938477f, 0.17650664f, 0.16913429f, 0.32300532f, 0.15900359f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.03073791f, -0.04858381f, 0.02341237f, 0.01447902f, 0.02569243f, -0.02828278f, -0.00458910f, 0.01092546f, 
    0.02376019f, 0.04101322f, -0.00479273f, 0.03339491f, 0.02218837f, 0.03093234f, -0.00546677f, 0.00249459f, 
    0.02219089f, -0.01686927f, -0.01378791f, -0.05030955f, 0.02940548f, 0.01032023f, 0.03710114f, 0.02782012f, 
    -0.04050285f, 0.03930784f, -0.01468972f, -0.04532754f, -0.03476959f, -0.05395466f, 0.01093706f, 0.02036166f, 
    -0.01622346f, 0.01358132f, 0.03704099f, 0.04334644f, -0.04736728f, 0.04113774f, -0.02082505f, 0.00459786f, 
    -0.04834544f, -0.00135682f, -0.04750134f, 0.02620285f, -0.00637897f, -0.04535096f, -0.04432720f, -0.05240412f, 
    -0.05013302f, -0.00374750f, -0.04433849f, 0.03215842f, 0.03227068f, -0.04535023f, -0.04263309f, -0.00004896f, 
    -0.05139923f, 0.02013909f, -0.01184886f, -0.02530667f, -0.05016884f, -0.03659378f, -0.00835750f, 0.01396006f, 
    0.03423231f, -0.02678801f, 0.00933576f, -0.01453329f, -0.03991259f, -0.02528834f, 0.01241770f, -0.04310834f, 
    -0.04584327f, -0.01813792f, -0.04051566f, 0.00210640f, -0.02410114f, -0.04755548f, -0.04490210f, -0.01530424f, 
    0.00694461f, -0.04596931f, -0.00813178f, -0.04083475f, -0.02419068f, 0.02102143f, 0.02009137f, 0.00860550f, 
    0.02876340f, 0.02388245f, -0.04553035f, -0.00388419f, 0.02174017f, -0.04792129f, 0.01428909f, -0.04628445f, 
    0.00670031f, -0.05354916f, -0.01168909f, 0.01886580f, -0.00412106f, -0.00736774f, -0.05269606f, -0.02604160f, 
    0.02062974f, 0.03825733f, -0.01859440f, 0.01054150f, 0.01347325f, -0.02403286f, -0.03769960f, 0.03662969f, 
    -0.00502842f, 0.02524905f, 0.03133062f, -0.04695141f, -0.03071636f, -0.05107412f, 0.02151388f, 0.01868951f, 
    0.04048066f, 0.02625853f, 0.03419723f, -0.01606795f, -0.03155630f, -0.03609497f, 0.02276421f, -0.05160732f, 
    -0.00683199f, 0.03847661f, 0.01501625f, 0.04082090f, -0.05316039f, -0.02193992f, -0.00416007f, -0.04417751f, 
    0.04220800f, -0.02526885f, -0.03541766f, -0.04060102f, 0.01643257f, 0.02339798f, 0.02437007f, -0.04041602f, 
    -0.02154438f, 0.01189172f, -0.04858213f, 0.02354357f, 0.00712062f, 0.03009133f, 0.02342362f, -0.04952841f, 
    -0.04840794f, 0.00386964f, 0.02607041f, -0.05467703f, -0.03600007f, -0.04947076f, -0.04089808f, -0.02112541f, 
    -0.02923218f, -0.04982726f, -0.00623664f, -0.05640481f, 0.00569170f, 0.03740051f, 0.02769491f, -0.03120422f, 
    -0.00390526f, 0.01420042f, 0.04313131f, 0.00646208f, -0.02145080f, 0.01526390f, 0.04345860f, -0.04521363f, 
    0.03383285f, 0.01145103f, -0.02290278f, -0.05429347f, 0.04194569f, 0.03348051f, -0.03396380f, -0.05398399f, 
    0.00753365f, -0.03171425f, -0.04189630f, 0.00932544f, -0.04697884f, -0.03889671f, -0.03670755f, 0.03955404f, 
    0.03192264f, 0.02259493f, 0.00639584f, 0.03691261f, 0.00321811f, -0.00229188f, -0.05266013f, -0.04676401f, 
    0.03612372f, 0.01241627f, 0.02200946f, 0.03967405f, -0.02569157f, -0.04425570f, 0.01923193f, -0.03567597f, 
    0.02874135f, -0.02348774f, -0.03976223f, -0.04641642f, -0.00119622f, -0.04113057f, 0.00472538f, -0.02763265f, 
    0.01301392f, 0.02915553f, -0.02370772f, 0.03485233f, 0.01801902f, -0.03090082f, 0.00458563f, -0.00865351f, 
    -0.05472654f, 0.03514693f, -0.01343964f, -0.04687073f, 0.04168775f, -0.00571115f, 0.02624706f, -0.02744615f, 
    -0.05504074f, 0.00338505f, -0.04320162f, 0.01116871f, -0.00663356f, -0.04921044f, -0.00869067f, -0.02898566f, 
    0.02779637f, 0.02202667f, 0.04199894f, 0.00949541f, -0.03778383f, -0.01973206f, -0.05200287f, 0.01628339f, 
    0.02531926f, -0.03445686f, 0.02751642f, -0.04524378f, -0.03753719f, 0.04245213f, 0.01251343f, -0.03759496f, 
    0.02296710f, 0.02395961f, 0.02010193f, 0.02331330f, -0.03676459f, -0.04133646f, 0.02089709f, -0.01987988f, 
    0.00839357f, 0.04226288f, -0.05192526f, -0.05648253f, 0.03739625f, -0.05299409f, 0.03122465f, -0.03289905f, 
    0.00413435f, 0.03403445f, -0.04435026f, 0.04136911f, -0.02608078f, 0.02330689f, -0.01549167f, -0.04971146f, 
    0.02105279f, -0.01359818f, 0.02756764f, -0.04951901f, -0.02789592f, -0.00770762f, 0.01759675f, 0.03337863f, 
    -0.03605497f, -0.05318391f, -0.02848213f, -0.01460417f, 0.02418329f, -0.02685275f, -0.05695553f, 0.01915062f, 
    -0.03375443f, 0.00377230f, 0.01716756f, 0.03023592f, -0.02834827f, 0.01058303f, 0.03382057f, 0.04002734f, 
    -0.04570295f, -0.01460287f, -0.02913740f, -0.02649406f, -0.02894719f, 0.03429130f, -0.00322615f, 0.01087074f, 
    -0.05262343f, -0.03434351f, 0.02899822f, -0.05485507f, 0.03296591f, -0.03461582f, 0.01697554f, -0.01969518f, 
    0.00396905f, -0.00699023f, -0.03035520f, -0.02070973f, 0.03564542f, -0.00281444f, 0.02624617f, 0.01502791f, 
    0.04467148f, -0.04004575f, 0.02446679f, 0.00715591f, -0.02499432f, -0.04415081f, 0.02753801f, -0.01542864f, 
    0.03624284f, -0.05247768f, 0.01758626f, 0.03895851f, -0.02666765f, -0.04744967f, 0.01568637f, 0.02377456f, 
    0.00752753f, 0.02935967f, 0.01581694f, 0.01158485f, -0.03626700f, 0.00033116f, -0.01760111f, -0.02418695f, 
    0.00603202f, 0.00120473f, -0.00368464f, 0.00348612f, -0.02295763f, -0.00024547f, -0.03121109f, 0.01322582f, 
    0.01682976f, -0.05341302f, -0.01114298f, -0.01053316f, 0.03237888f, -0.02390618f, 0.03082131f, -0.03870904f, 
    -0.00839147f, 0.00779110f, -0.00528644f, -0.05305803f, -0.02814173f, -0.01967536f, 0.03280484f, -0.03058821f, 
    -0.01122926f, -0.05260207f, -0.05238828f, -0.00498552f, 0.01447112f, 0.02699123f, 0.03321410f, -0.04338096f, 
    -0.15317582f, 0.19612667f, 0.15191723f, -0.20894834f, -0.01705106f, 0.18146098f, 0.00341799f, 0.05098986f, 
    0.08330335f, 0.12759429f, 0.02140167f, -0.01719911f, -0.05294266f, -0.10216136f, 0.01860836f, 0.05967052f, 
    0.05206265f, 0.07526912f, 0.04453300f, 0.15191934f, 0.10060726f, -0.04346691f, 0.03278683f, -0.02030667f, 
    0.06406963f, 0.12709551f, -0.08488549f, 0.10431443f, 0.00041505f, -0.11587123f, 0.14047687f, 0.13660587f, 
    0.04443143f, -0.02723713f, 0.01961279f, 0.00564054f, -0.30487150f, -0.10423164f, 0.30727014f, 0.09104258f, 
    0.08973738f, -0.00992706f, 0.09435113f, -0.05198787f, 0.03868518f, 0.03002541f, -0.03584744f, 0.07419460f, 
    -0.04112230f, 0.00907922f, -0.04246422f, 0.16709954f, -0.00887781f, 0.10394456f, 0.05224723f, -0.03351526f, 
    0.04158401f, 0.09028280f, 0.07857908f, 0.06255677f, -0.03133685f, -0.25694796f, -0.04424997f, -0.10374656f, 
    0.06880611f, 0.01142478f, 0.17332076f, 0.06942281f, 0.04393397f, 0.04171620f, 0.04571367f, 0.01496627f, 
    -0.14732820f, 0.13882440f, 0.09488738f, -0.01023355f, 0.15223937f, 0.20008898f, 0.07380726f, -0.06922973f, 
    -0.06199267f, -0.08838437f, -0.09313240f, 0.12119571f, -0.05156115f, -0.03625838f, -0.30153582f, -0.07261380f, 
    -0.00455831f, -0.02554071f, -0.03730100f, 0.06925555f, 0.00475864f, 0.15849666f, 0.01595001f, -0.04456406f, 
    -0.05900022f, -0.20602021f, 0.00887992f, -0.08002486f, -0.10027371f, 0.05491938f, 0.05494742f, 0.01416696f, 
    -0.12083449f, -0.05834708f, 0.02073391f, -0.01105683f, -0.13715184f, 0.02890343f, -0.11908547f, 0.09503244f, 
    0.08469599f, 0.02974329f, 0.02979166f, 0.06119492f, 0.01559518f, 0.00439464f, 0.01491645f, 0.04505382f, 
    -0.18270598f, 0.04763724f, 0.21665475f, 0.08270268f, 0.03963682f, 0.02216291f, -0.01545228f, -0.06130860f, 
    -0.00827121f, 0.10294194f, 0.04677193f, 0.11552318f, 0.10823475f, -0.10028481f, -0.02285500f, -0.12885530f, 
    -0.04429691f, 0.00762360f, -0.03458551f, 0.07999676f, 0.00909652f, 0.09823555f, 0.07752936f, 0.16759211f, 
    0.31335992f, 0.05686476f, 0.05275182f, -0.05820091f, 0.01257379f, -0.04832244f, -0.01460953f, 0.10556380f, 
    0.08216618f, 0.08566616f, 0.01655518f, 0.07738620f, -0.02407777f, -0.13437966f, -0.08723480f, 0.01476928f, 
    -0.03267696f, -0.00431884f, 0.09444781f, -0.08943166f, 0.01681303f, -0.03594724f, -0.04367112f, 0.07946575f, 
    0.04200332f, -0.21336778f, 0.05194407f, -0.02226273f, 0.08044600f, -0.03672217f, 0.13017690f, 0.13272259f, 
    0.04937331f, 0.04436908f, 0.06047673f, -0.04773600f, 0.04869269f, -0.04830308f, -0.09142515f, 0.14085157f, 
    -0.03646331f, 0.08389493f, 0.14163242f, 0.01288676f, 0.00620723f, 0.07290358f, 0.00178724f, 0.06084278f, 
    -0.02464315f, 0.08422644f, -0.18430880f, 0.08778634f, -0.00456796f, 0.11076320f, -0.05227703f, -0.06218344f, 
    -0.00877002f, 0.00699038f, 0.00016476f, 0.05533211f, -0.06244151f, -0.08569010f, 0.38258591f, -0.04239818f, 
    0.04245979f, -0.00290163f, -0.04184765f, -0.04152410f, -0.01390129f, 0.05371204f, 0.02730283f, -0.03580691f, 
    0.19117697f, 0.04641530f, -0.07611991f, 0.20870325f, 0.00154813f, 0.11355922f, 0.00491189f, 0.13414441f, 
    0.07571001f, 0.01534851f, 0.12874901f, 0.03137280f, -0.04582187f, 0.07086747f, -0.06328639f, 0.12660398f, 
    -0.02262367f, -0.01749156f, 0.14713956f, -0.03792391f, -0.04080550f, 0.05067502f, 0.04638602f, 0.04409713f, 
    0.12359212f, 0.19686165f, -0.31626263f, -0.21946870f, -0.07279705f, 0.04040859f, -0.07374840f, 0.12421218f, 
    0.01833830f, 0.07541560f, -0.02277767f, -0.01788816f, 0.02761585f, -0.12453932f, -0.01163853f, -0.01749673f, 
    -0.01422909f, 0.07400221f, 0.09831665f, 0.14340128f, -0.03734823f, -0.01072027f, -0.12676580f, -0.07445727f, 
    -0.10015997f, 0.06614893f, 0.13973925f, -0.06001827f, 0.09022899f, 0.05224771f, 0.00890027f, 0.02773507f, 
    0.02531583f, 0.05278938f, 0.04269539f, 0.01745298f, 0.04714228f, 0.11426140f, -0.19930306f, 0.17956458f, 
    -0.06737337f, 0.04514240f, -0.02731734f, 0.10683417f, 0.12014491f, 0.05456306f, 0.06664575f, 0.11229750f, 
    -0.04112872f, 0.13351482f, 0.02532341f, 0.03992336f, 0.12564142f, 0.05086453f, -0.03853115f, 0.06774926f, 
    -0.00638259f, 0.09026943f, 0.00606290f, 0.04169976f, 0.46108809f, -0.16640019f, 0.12027790f, -0.04153956f, 
    -0.01133621f, 0.03555384f, 0.16750045f, -0.13139655f, 0.09937636f, 0.02756796f, -0.01485019f, 0.14242597f, 
    0.32431924f, -0.01277347f, 0.00656677f, 0.07708926f, -0.03047107f, -0.00522333f, 0.08072625f, -0.01743665f, 
    -0.01162282f, 0.09304571f, 0.01466761f, -0.03578579f, -0.02306787f, -0.03614159f, 0.01531947f, -0.03747174f, 
    -0.06623282f, 0.01633044f, -0.04776250f, 0.03444415f, -0.00164059f, 0.04850122f, -0.03903700f, -0.06172121f, 
    0.22174299f, -0.14359504f, -0.14049233f, 0.23765361f, 0.08087894f, -0.01329026f, 0.08259311f, 0.09285484f, 
    0.04778205f, -0.02392727f, -0.07257015f, -0.07380817f, 0.09445578f, 0.10848209f, -0.20233856f, 0.10468156f, 
    0.05262794f, 0.07528162f, 0.05987764f, 0.18587309f, 0.11585426f, -0.01555788f, 0.02066720f, 0.05670444f, 
    -0.00130179f, -0.01161282f, 0.11416702f, -0.09360766f, -0.04312065f, -0.01466854f, 0.02702049f, 0.09582841f, 
    0.10710468f, 0.12702997f, -0.04589079f, -0.14245847f, -0.43404022f, -0.05590471f, 0.29744551f, -0.23829173f, 
    -0.00928325f, 0.19707851f, 0.00157452f, 0.08665773f, 0.02482972f, 0.03500567f, -0.07453188f, 0.03956145f, 
    -0.14944829f, 0.13991174f, 0.10662268f, -0.01609275f, -0.03815729f, 0.07003059f, 0.01535163f, 0.00691140f, 
    0.04973075f, 0.05902948f, 0.06220524f, 0.19776145f, -0.07730369f, -0.00979584f, 0.06068684f, -0.06021252f, 
    0.03737603f, -0.04222173f, 0.07380179f, 0.00563142f, 0.05497399f, -0.07909741f, 0.06719612f, 0.01510913f, 
    -0.52436090f, 0.14568612f, 0.00691906f, 0.04881737f, -0.06308605f, -0.09235188f, 0.12518665f, -0.03376776f, 
    0.13951218f, -0.08140191f, 0.11836300f, -0.07297506f, -0.05053317f, -0.19961461f, -0.02843577f, -0.07424064f, 
    0.03409676f, 0.12105497f, -0.09542111f, -0.04399042f, 0.08178833f, 0.10059199f, -0.08819598f, 0.00271235f, 
    0.00429413f, -0.02291154f, 0.04113658f, -0.01120709f, 0.11264286f, -0.01178000f, 0.11016877f, -0.03615835f, 
    0.08592651f, -0.07753833f, -0.00089140f, 0.08527164f, -0.32714963f, 0.16257364f, 0.03535921f, 0.14599599f, 
    0.08782036f, -0.11587166f, -0.04489517f, -0.05596481f, 0.04251137f, 0.07035441f, -0.02055201f, 0.01589019f, 
    0.30612484f, -0.19032519f, 0.27902988f, 0.27198350f, -0.03211673f, -0.06628467f, -0.08898919f, -0.00857078f, 
    0.11632715f, 0.08546700f, -0.01772009f, 0.10271516f, -0.07011274f, -0.01861351f, -0.10815050f, 0.08749067f, 
    -0.02070631f, -0.06416488f, -0.05482321f, 0.02289764f, -0.01051502f, 0.01952407f, 0.19550322f, -0.04562398f, 
    0.08049446f, 0.10365461f, -0.06304660f, 0.04986371f, 0.08839101f, -0.03376399f, -0.04845674f, -0.07408316f, 
    -0.06483990f, -0.09562653f, 0.10177227f, 0.08006220f, 0.07604616f, -0.03055246f, 0.04594200f, 0.18045013f, 
    -0.00110299f, -0.10741164f, 0.11628131f, 0.03152059f, -0.06913693f, 0.11985989f, 0.09593457f, 0.16231425f, 
    0.18526350f, -0.24334924f, 0.13070618f, 0.23951897f, 0.10401335f, -0.05286383f, -0.01676887f, -0.07252678f, 
    0.06825125f, -0.04085880f, 0.04162482f, -0.03584708f, -0.11243185f, 0.05066432f, 0.11541052f, -0.09063615f, 
    0.12157101f, 0.09573777f, 0.01530119f, 0.06279297f, -0.08254965f, -0.00366210f, 0.11571832f, 0.13470051f, 
    -0.24588549f, 0.03101903f, 0.03088481f, -0.06138100f, -0.04936349f, -0.01752400f, 0.16079420f, 0.06488845f, 
    0.06733132f, -0.01930826f, 0.00058934f, -0.00391014f, -0.09919339f, -0.06820652f, 0.05337155f, -0.01412491f, 
    0.08567325f, 0.03833148f, 0.20478439f, 0.03696195f, -0.01800307f, -0.08195332f, 0.12389120f, 0.03004470f, 
    0.14307718f, 0.13837290f, 0.04933665f, 0.08509761f, 0.17199247f, 0.04129495f, 0.01603291f, 0.06591612f, 
    -0.02136614f, -0.00675585f, -0.00560623f, 0.06043173f, -0.20411040f, 0.13966300f, 0.00437042f, 0.01938190f, 
    0.03337182f, -0.06766888f, -0.02842825f, 0.06309886f, -0.07354043f, -0.15775336f, -0.02186191f, -0.02790621f, 
    0.15528612f, -0.02812227f, -0.06067645f, -0.04624327f, -0.01835289f, 0.03256370f, -0.05789332f, -0.02350263f, 
    -0.02530845f, -0.07655950f, 0.03962773f, -0.16539039f, 0.03873705f, -0.21845470f, -0.02354782f, 0.17732142f, 
    0.08617078f, 0.06984812f, -0.09350363f, -0.02494883f, 0.02203796f, 0.07077115f, -0.02675442f, 0.08075012f, 
    -0.20937094f, 0.16530286f, 0.17169660f, -0.00591383f, -0.05381249f, -0.04975036f, 0.07175583f, 0.06630631f, 
    0.08393182f, -0.05354196f, -0.13622312f, 0.02289456f, 0.33091587f, -0.04174592f, 0.12351325f, -0.01026912f, 
    0.05321443f, 0.03691473f, -0.00799462f, -0.05548370f, 0.04533557f, 0.06952633f, 0.05136058f, 0.05169584f, 
    -0.08561751f, -0.06579497f, -0.00924459f, 0.14666907f, -0.09035493f, 0.10600085f, 0.02568471f, 0.02841040f, 
    -0.00822367f, -0.14358068f, -0.01569613f, 0.05949285f, -0.00138773f, -0.09215745f, -0.01906181f, 0.01960253f, 
    0.03153048f, -0.02749309f, 0.02715668f, 0.01584029f, 0.16368689f, 0.05489486f, 0.07882406f, 0.05990972f, 
    0.29484704f, 0.14421079f, 0.14229538f, -0.05077372f, -0.03694587f, 0.00516337f, 0.08731592f, -0.02178313f, 
    -0.05495907f, -0.00293830f, -0.01909414f, 0.03458658f, -0.37424374f, 0.12467007f, 0.03888828f, -0.04369195f, 
    0.04508926f, -0.04447935f, 0.09696112f, 0.01383531f, 0.01882544f, 0.08375002f, -0.12115607f, 0.08527341f, 
    0.10528452f, -0.01001178f, 0.10280366f, -0.06259242f, 0.02711414f, -0.02731305f, -0.01866852f, -0.03911532f, 
    -0.13317455f, 0.01011578f, 0.12402853f, 0.12512730f, 0.21679915f, 0.25301877f, 0.18342215f, 0.05782305f, 
    0.02930203f, 0.02722521f, 0.12630583f, 0.02906354f, 0.01621458f, -0.08278437f, -0.03845200f, 0.05223113f, 
    0.05303593f, -0.05635451f, 0.07398708f, 0.01063736f, -0.02745891f, 0.01588448f, 0.02704909f, 0.06619099f, 
    0.07019243f, 0.08421663f, -0.11976761f, -0.03061641f, -0.01132319f, -0.13454901f, -0.02382293f, 0.06132421f, 
    0.01444949f, 0.01423215f, -0.06386466f, 0.04509550f, 0.07700284f, 0.07341354f, -0.02726704f, -0.04049348f, 
    -0.38817930f, 0.12089346f, 0.02501310f, 0.12490273f, 0.07237015f, -0.00387469f, 0.03916246f, 0.05165077f, 
    0.06532931f, 0.18290113f, 0.01573655f, -0.05345654f, -0.16530167f, 0.00749632f, -0.03435586f, -0.04464156f, 
    0.04587360f, -0.08220355f, 0.02317541f, 0.06559441f, 0.04913833f, -0.07753610f, 0.04283243f, 0.01555968f, 
    -0.08214030f, -0.21145791f, -0.01026835f, 0.01534515f, 0.01155004f, 0.10840678f, -0.02888284f, -0.00481478f, 
    0.06295999f, 0.06556823f, -0.03418178f, -0.11986248f, -0.34664249f, 0.00826845f, 0.05007085f, 0.01101497f, 
    0.03885574f, 0.01894793f, -0.02159293f, -0.01068536f, -0.12385636f, 0.06123550f, 0.05541025f, -0.08864582f, 
    0.02620842f, -0.03352493f, -0.00263161f, 0.00059210f, -0.00913588f, -0.03723998f, -0.05241557f, -0.02572954f, 
    0.00194141f, -0.05801224f, 0.04731591f, -0.03626965f, -0.02646514f, -0.04413970f, 0.00627855f, -0.02919186f, 
    -0.04027469f, -0.05444250f, -0.05534349f, -0.03311562f, -0.05741225f, -0.03556668f, -0.01451837f, 0.02098390f, 
    0.00266449f, -0.00158773f, -0.02078652f, -0.01624724f, -0.03546531f, 0.04247032f, -0.03315767f, 0.04186034f, 
    -0.04095190f, 0.01519758f, 0.03704643f, 0.00617095f, -0.04709212f, 0.04174247f, -0.00846453f, 0.03566936f, 
    0.00409577f, -0.02300983f, -0.01954224f, -0.04762103f, -0.00529080f, 0.01876440f, 0.03829928f, -0.04953151f, 
    0.01111252f, 0.01831146f, -0.00018365f, -0.03116035f, -0.04637593f, -0.04721303f, -0.04391216f, 0.01825362f, 
    -0.04507059f, 0.01364421f, -0.02208664f, -0.03635337f, -0.01106917f, -0.02979775f, -0.04039645f, 0.01960332f, 
    0.00980848f, 0.03504514f, -0.02506421f, -0.03895127f, -0.00854449f, 0.00803387f, -0.05149345f, -0.03393349f, 
    0.03398139f, 0.02909091f, -0.00191756f, -0.02389546f, 0.03959683f, 0.04196298f, 0.03172911f, 0.00151620f, 
    -0.04055430f, -0.02721845f, -0.05825461f, -0.01593339f, -0.05058870f, -0.02651727f, 0.00391377f, -0.02805808f, 
    -0.05561589f, -0.02334875f, 0.01333816f, -0.04280741f, -0.00219616f, -0.00668566f, -0.04040001f, 0.03876780f, 
    -0.02362214f, -0.04202515f, 0.01544614f, 0.02955967f, -0.04241449f, -0.03699027f, -0.01967436f, 0.01365478f, 
    -0.03007174f, -0.05596963f, 0.00348111f, -0.00335474f, 0.03711792f, -0.02167945f, -0.00570940f, -0.00141715f, 
    0.03968933f, -0.01296843f, -0.02604337f, -0.02919005f, 0.01029546f, -0.00205071f, -0.05534621f, -0.04345375f, 
    0.02728138f, 0.00657473f, -0.02477671f, 0.00153991f, 0.01950493f, 0.00967226f, -0.00519247f, 0.02142463f, 
    0.00312459f, -0.00775723f, 0.04255729f, -0.02837047f, -0.00716392f, 0.02661108f, -0.01300735f, -0.01472573f, 
    0.03392842f, 0.00530875f, 0.04668806f, -0.04320760f, 0.00941349f, -0.00296839f, -0.03690364f, -0.03774532f, 
    0.03485612f, -0.00331832f, 0.03275912f, -0.03005528f, 0.01516116f, -0.02745951f, 0.00203277f, -0.04062673f, 
    0.02558201f, -0.03098979f, -0.04595361f, -0.02200882f, 0.03692731f, -0.02928678f, -0.03112165f, 0.03700991f, 
    -0.04141540f, -0.04967658f, 0.03443672f, -0.02501720f, -0.04437876f, 0.02982926f, -0.03790151f, -0.01700604f, 
    -0.03467217f, -0.05027384f, 0.00097155f, -0.04506148f, 0.01280226f, 0.01824719f, 0.03454261f, -0.05052467f, 
    -0.01101353f, 0.01595603f, 0.01068843f, -0.02731733f, 0.03587829f, -0.03274528f, 0.03816002f, 0.02131464f, 
    -0.05010751f, -0.00287600f, 0.01138264f, -0.03925963f, 0.01058756f, 0.03632188f, -0.02320935f, -0.03157254f, 
    -0.05664022f, -0.00849191f, -0.04424270f, 0.03717790f, 0.01486744f, -0.04155160f, -0.00681745f, 0.03909236f, 
    0.00730866f, -0.00585499f, 0.03621115f, -0.01444676f, 0.02364359f, -0.05242542f, -0.05476286f, 0.01477312f, 
    -0.02269293f, 0.01824740f, -0.00334587f, -0.03997929f, 0.01638325f, 0.02790085f, 0.01008968f, -0.03376133f, 
    0.01832386f, 0.01285453f, -0.05654991f, -0.04334396f, -0.00089554f, -0.03231223f, 0.03864066f, -0.02844348f, 
    -0.01123603f, 0.03018821f, -0.00060975f, 0.00940476f, 0.00796411f, 0.01142316f, -0.05387008f, -0.00204788f, 
    -0.05565085f, -0.01539342f, -0.04524660f, 0.02017872f, -0.04766559f, -0.05772958f, -0.00854882f, -0.03502794f, 
    -0.04306166f, 0.00590525f, 0.01074561f, -0.05114293f, -0.04284192f, -0.02916122f, -0.01186606f, -0.04558233f, 
    0.01910075f, -0.01163067f, 0.02204029f, -0.03092287f, -0.04868735f, -0.01408603f, -0.00692316f, 0.03479948f, 
    -0.05187730f, 0.01142897f, -0.05138718f, -0.02388586f, 0.02444990f, -0.05358145f, 0.00463765f, 0.01933653f, 
    -0.04870455f, 0.00896668f, 0.01687335f, -0.04308006f, 0.01252976f, -0.00169212f, -0.05471102f, 0.01303068f, 
    -0.04127206f, 0.03574470f, 0.00358767f, 0.03837714f, -0.00308280f, -0.01005981f, 0.03654880f, 0.01544470f, 
    0.00296910f, -0.00250872f, 0.03037426f, -0.00740985f, -0.01805394f, -0.01909086f, 0.00406685f, -0.00899300f, 
    -0.05224468f, 0.01422900f, 0.00487268f, 0.02562891f, 0.02866514f, 0.02899195f, 0.02343217f, -0.04244727f, 
    0.00843583f, -0.05641131f, -0.04399329f, 0.01424400f, -0.03102323f, -0.00808779f, -0.02613800f, -0.01210459f, 
    0.00184964f, -0.04729654f, -0.04729320f, 0.04092935f, 0.01252818f, -0.04450238f, -0.04977482f, -0.01871615f, 
    -0.01027600f, 0.03520304f, -0.02634915f, -0.02163768f, 0.01767838f, -0.04641400f, -0.03599723f, -0.00408193f, 
    -0.03965563f, -0.00753684f, -0.05573550f, -0.04263826f, -0.01766609f, 0.02129945f, -0.01866239f, -0.00071344f, 
    -0.02626030f, -0.04153974f, -0.02062495f, -0.03330835f, 0.03617245f, 0.02775736f, 0.02129138f, -0.03272584f, 
    0.03788852f, -0.00049498f, -0.01106452f, -0.02738998f, 0.01633171f, -0.02990830f, -0.04019267f, -0.00405692f, 
    0.02355755f, -0.03280861f, -0.01794123f, -0.02834657f, 0.02547049f, 0.03035387f, -0.02609525f, 0.00356793f, 
    -0.04174873f, 0.03031239f, 0.04005592f, -0.02936232f, -0.02428814f, -0.04744403f, -0.01367119f, -0.02886042f, 
    -0.00349213f, -0.01810681f, -0.05018723f, 0.03650826f, -0.03098527f, 0.03773244f, 0.00598746f, -0.03275544f, 
    0.01436607f, 0.03785850f, 0.02818522f, -0.03653221f, -0.00751733f, -0.02703092f, 0.01472334f, -0.01036444f, 
    -0.05797688f, -0.01080569f, 0.01874333f, -0.01290284f, -0.03519558f, 0.02241432f, -0.05046159f, -0.00089372f, 
    -0.03819418f, -0.04006879f, 0.02623933f, -0.02638754f, -0.03144941f, -0.00188156f, 0.01916491f, -0.00140358f, 
    0.04008584f, -0.04725886f, -0.01256932f, -0.02849543f, -0.00525716f, 0.00668736f, -0.03506780f, -0.00960766f, 
    -0.02624597f, 0.00003178f, -0.04591792f, 0.03965923f, 0.02701361f, 0.04123016f, -0.05071030f, 0.01457159f, 
    -0.00127533f, -0.00703079f, -0.02387359f, 0.03325467f, 0.00930458f, 0.01913612f, -0.01058152f, -0.02732997f, 
    0.03253119f, -0.00750522f, 0.00700598f, -0.03269614f, 0.02166678f, -0.05528498f, 0.02558498f, 0.02961375f, 
    -0.03002885f, 0.04215043f, 0.00069934f, 0.01432193f, -0.04632212f, 0.01009862f, -0.01019435f, 0.00776688f, 
    -0.00636663f, -0.01352742f, 0.00610240f, 0.02542844f, -0.00623577f, 0.00739889f, 0.02405990f, -0.03229501f, 
    -0.04432018f, 0.00380193f, -0.05040071f, -0.05518447f, 0.04295735f, -0.00918551f, -0.04907382f, 0.03290260f, 
    0.00909396f, 0.03967433f, -0.00337957f, -0.00923671f, -0.04751133f, -0.05132888f, 0.00558167f, -0.05519588f, 
    -0.01033904f, -0.04973836f, 0.00098847f, 0.04823319f, -0.05227722f, 0.01168296f, -0.00915766f, -0.03762370f, 
    -0.02863031f, 0.00181845f, -0.05331815f, 0.03016765f, 0.01027133f, -0.03591301f, -0.04935035f, -0.04072055f, 
    -0.02014536f, 0.01992225f, 0.01285368f, 0.01703578f, -0.05387689f, 0.03771427f, 0.02229729f, -0.04518047f, 
    -0.05387092f, -0.02719147f, -0.05515758f, -0.01366416f, -0.02004994f, -0.05250508f, 0.00600108f, -0.04321354f, 
    -0.00053275f, -0.00054205f, 0.01970568f, -0.00753268f, -0.02278861f, -0.03285759f, 0.01818592f, -0.00626674f, 
    -0.04346276f, -0.04059261f, -0.01683025f, -0.02191639f, 0.00420211f, 0.01765370f, -0.04130305f, -0.02280800f, 
    0.00199109f, 0.02439962f, -0.01332494f, -0.03244220f, 0.03581457f, 0.01691426f, 0.03520222f, -0.02341661f, 
    0.00416490f, 0.03591561f, -0.02247437f, -0.02084889f, -0.02966134f, -0.04339522f, 0.04179087f, -0.01081479f, 
    0.02815617f, -0.02036023f, 0.03743121f, 0.01688863f, 0.03027252f, -0.05359095f, 0.00442667f, 0.02962446f, 
    -0.05608062f, 0.03844385f, -0.04570111f, 0.01787487f, -0.04539375f, 0.02771493f, -0.02591091f, -0.04889490f, 
    0.03452234f, -0.05663175f, -0.05305851f, 0.00181020f, -0.05625078f, -0.04978986f, -0.02877011f, -0.02601221f, 
    -0.05736619f, -0.05396385f, -0.05171020f, -0.00013427f, -0.03121035f, -0.01131913f, -0.05715806f, -0.02647131f, 
    0.02289421f, -0.04312814f, 0.01108498f, 0.03798004f, 0.01967085f, -0.00609213f, 0.01553496f, -0.00324115f, 
    -0.04145278f, -0.00633369f, 0.02103923f, 0.03709079f, -0.01757424f, -0.02070271f, 0.01206483f, 0.02103389f, 
    -0.01177813f, 0.03449507f, -0.05730621f, -0.00498010f, -0.03892790f, -0.04250224f, 0.00412852f, 0.03955552f, 
    -0.02336688f, 0.02753899f, 0.04109664f, 0.02363024f, -0.03493216f, -0.02796827f, -0.02730741f, -0.03248200f, 
    0.01720762f, 0.04437203f, 0.02463631f, 0.03105771f, -0.05157376f, -0.00902450f, 0.00469632f, 0.04162031f, 
    0.03401189f, -0.01610630f, -0.02204782f, -0.05509650f, 0.02955198f, -0.04994868f, -0.01048224f, 0.02994810f, 
    -0.00724689f, -0.03393713f, 0.00476359f, -0.00551303f, 0.02979386f, -0.04440216f, -0.02544436f, 0.03858760f, 
    0.02099989f, -0.04217657f, 0.03600607f, -0.00990676f, -0.04745705f, 0.04122461f, -0.00936685f, -0.00396796f, 
    0.03965112f, -0.00567266f, -0.01658577f, 0.00185420f, -0.02880529f, -0.04846656f, -0.01596790f, 0.02268897f, 
    0.00783955f, -0.03986663f, -0.03253627f, 0.00012998f, -0.00745932f, -0.00340648f, -0.03500835f, 0.01712580f, 
    0.01805355f, -0.03994391f, -0.02594047f, -0.01353350f, -0.03228837f, -0.00674959f, -0.05689807f, 0.00444830f, 
    -0.04954803f, -0.00274198f, 0.01946377f, -0.01350442f, -0.03775659f, 0.03690328f, -0.00208590f, -0.02259015f, 
    -0.02555023f, -0.03807637f, 0.01054220f, 0.04190734f, 0.00098396f, 0.03061570f, -0.02944827f, -0.00090666f, 
    0.00653228f, -0.02694225f, -0.03027403f, 0.03442620f, 0.00704541f, 0.00392764f, -0.03633664f, -0.04977009f, 
    -0.04055519f, -0.03684980f, -0.01624259f, 0.03106429f, -0.02834930f, -0.03147227f, -0.04533820f, -0.01120147f, 
    0.02590655f, -0.05345695f, 0.00818714f, 0.00824803f, -0.01588275f, 0.02352016f, -0.05316051f, -0.02022255f, 
    -0.02563644f, -0.02267532f, 0.02279513f, 0.01224987f, -0.02455602f, 0.04091939f, -0.03157437f, 0.05122743f, 
    -0.01929263f, -0.03702705f, -0.00163677f, -0.03468415f, -0.04027513f, -0.01585474f, -0.03248276f, -0.00162498f, 
    -0.02077458f, 0.01111068f, 0.00488661f, 0.03744859f, 0.02734581f, 0.04233321f, 0.02354926f, -0.01091036f, 
    -0.04143824f, -0.01977930f, -0.01469217f, -0.03284886f, 0.04013203f, -0.03685548f, 0.00461303f, -0.05119931f, 
    -0.05516560f, 0.02831696f, 0.00576675f, -0.05090713f, -0.03724937f, 0.02207412f, -0.05068063f, 0.00939049f, 
    -0.05307484f, -0.05209270f, -0.03686237f, -0.02214174f, 0.00919517f, -0.04392291f, 0.02724248f, -0.02389207f, 
    0.02821580f, -0.04700779f, -0.02997111f, 0.02318751f, 0.04185830f, 0.01800274f, 0.04386311f, -0.00230646f, 
    0.03621309f, 0.04230161f, 0.03809055f, -0.01599682f, 0.03759817f, -0.00620628f, 0.04475115f, 0.00134853f, 
    0.04338699f, -0.02561881f, 0.00933726f, -0.04544958f, -0.01111452f, -0.01368136f, 0.03287373f, -0.02512045f, 
    -0.02872314f, -0.02660507f, 0.02281713f, -0.02367014f, 0.04293983f, -0.01108502f, 0.00204526f, -0.03922715f, 
    0.01039646f, 0.03910259f, -0.01107361f, -0.05351187f, 0.00035245f, 0.03159215f, -0.00886039f, 0.03037306f, 
    0.02953447f, -0.00050083f, -0.02353905f, 0.03197834f, -0.05061312f, -0.05433552f, -0.04835938f, 0.01842902f, 
    -0.02616091f, -0.05613516f, 0.03034928f, 0.02593595f, -0.04377844f, -0.00629250f, -0.01311428f, -0.03665573f, 
    -0.03721382f, 0.02722910f, -0.00992524f, 0.02332493f, -0.02302961f, 0.00775638f, -0.04901612f, -0.04248799f, 
    0.00678586f, 0.01387908f, -0.03949749f, -0.03573651f, 0.02313076f, 0.03039143f, 0.03250508f, -0.05418900f, 
    -0.00642265f, -0.02248777f, -0.02373121f, 0.01771868f, 0.03439769f, -0.00955355f, -0.01441058f, -0.05575178f, 
    0.02890775f, 0.01147062f, 0.01876652f, 0.00954785f, 0.04220146f, 0.04003742f, 0.03103128f, 0.01418264f, 
    0.03846185f, -0.00254189f, 0.03766154f, 0.03567903f, -0.05397299f, -0.00466070f, -0.01309769f, -0.04613403f, 
    -0.00895270f, 0.00917176f, 0.01916345f, 0.00440693f, 0.00221969f, -0.04615171f, 0.02928442f, -0.05221172f, 
    0.03569476f, 0.01016398f, 0.03015808f, -0.05637179f, 0.03050100f, -0.03289524f, -0.03050719f, -0.03612884f, 
    -0.02871862f, -0.03875909f, -0.04720562f, 0.04086753f, -0.01481443f, -0.02781478f, -0.03906538f, -0.02689673f, 
    0.00535791f, 0.00794987f, 0.02984170f, -0.03534216f, 0.01723410f, 0.03540499f, -0.00299369f, 0.03794300f, 
    0.00043156f, -0.00649094f, 0.02492624f, -0.02846096f, 0.01154624f, 0.03822436f, 0.01296750f, -0.04643091f, 
    0.03037555f, 0.01126326f, -0.01423972f, -0.01593876f, -0.05794932f, -0.02166159f, -0.00993599f, -0.02598900f, 
    -0.05801010f, -0.04248942f, 0.01123245f, -0.03663434f, -0.03120691f, 0.00656906f, 0.03353207f, 0.02729687f, 
    -0.04946182f, -0.00066505f, -0.03954350f, -0.03497221f, -0.01154910f, -0.01914431f, 0.00378288f, -0.04661794f, 
    0.03988360f, -0.01907839f, -0.00828762f, -0.00629848f, 0.02191987f, 0.02164087f, -0.02658018f, -0.02899537f, 
    -0.04239218f, -0.02110168f, -0.00572401f, -0.03055443f, 0.01810636f, 0.03075672f, -0.04341646f, -0.00461454f, 
    -0.04922774f, 0.03720814f, -0.04673307f, -0.01200448f, -0.05241460f, -0.05110099f, -0.05858866f, 0.02217596f, 
    -0.02649615f, -0.01139518f, -0.00188206f, -0.02806434f, -0.02686680f, 0.02741108f, -0.00215208f, -0.03598846f, 
    0.03276883f, -0.01069570f, -0.04622163f, 0.01025788f, -0.04885286f, 0.00890784f, 0.02426651f, -0.05593349f, 
    -0.01695977f, -0.02752095f, 0.02651719f, 0.02094571f, -0.01777497f, -0.01062076f, -0.02855043f, -0.02226079f, 
    -0.02221123f, 0.01595568f, -0.02830471f, -0.00862676f, -0.04077042f, -0.05717495f, 0.03511562f, 0.03139256f, 
    -0.02818987f, 0.00193401f, 0.02096971f, -0.05489557f, -0.00466924f, 0.03814562f, -0.05615231f, 0.02251945f, 
    -0.01389370f, -0.02536158f, -0.03021631f, -0.04433117f, -0.02788243f, -0.04382319f, 0.00305883f, -0.04621888f, 
    -0.05804718f, -0.00601763f, 0.01982491f, -0.02853745f, 0.01963373f, -0.04606784f, -0.03795695f, -0.01031647f, 
    -0.02490539f, 0.04265018f, -0.00023760f, 0.02747039f, 0.02400117f, -0.03369235f, -0.02544454f, 0.03071132f, 
    -0.00220641f, 0.00935821f, 0.02528987f, 0.01496170f, -0.01223501f, -0.00681211f, -0.05917768f, -0.01571485f, 
    -0.05369196f, 0.02245252f, -0.03345729f, -0.04455785f, -0.04172474f, -0.05573748f, -0.04172986f, 0.04108673f, 
    -0.05872017f, -0.02495105f, -0.01208507f, 0.01956934f, -0.01028572f, -0.00576034f, 0.02962100f, 0.00790930f, 
    0.01947358f, -0.02332084f, -0.00655241f, -0.04137743f, 0.01538862f, 0.02273309f, -0.00113688f, 0.03878160f, 
    -0.05217485f, -0.05876204f, 0.03173748f, 0.01439141f, -0.03774582f, 0.01543068f, 0.01771003f, -0.02274082f, 
    0.00981227f, -0.05653267f, -0.00175695f, 0.00898929f, -0.03868241f, -0.05477204f, -0.02225572f, 0.04018018f, 
    -0.05182642f, 0.01288190f, -0.03975733f, -0.00096212f, -0.02589460f, 0.02965186f, -0.02787176f, 0.01600188f, 
    0.01599773f, -0.04151655f, 0.03027198f, -0.00228330f, 0.02855121f, 0.01834084f, 0.03892687f, 0.01183339f, 
    -0.01299414f, -0.04728245f, 0.02082326f, 0.01078365f, -0.00143653f, -0.02735361f, -0.02849814f, -0.04909838f, 
    0.01334406f, -0.02986580f, -0.01935157f, -0.04843283f, 0.03885664f, 0.03561618f, -0.03866156f, -0.02416492f, 
    -0.01181705f, 0.03652581f, -0.00582456f, 0.00703601f, -0.02262142f, 0.03162562f, -0.02617267f, 0.00827583f, 
    -0.04485748f, -0.04564982f, -0.00057257f, 0.02654594f, -0.02130429f, -0.01669162f, 0.01609217f, 0.02095776f, 
    0.01128740f, -0.05234621f, -0.00034815f, -0.02825713f, 0.01319481f, 0.00897746f, -0.05235844f, -0.00926178f, 
    -0.04717204f, -0.01509473f, -0.05023060f, -0.04353557f, 0.02260889f, 0.00152284f, -0.05139408f, -0.03401392f, 
    0.02546171f, 0.02883762f, -0.02740096f, -0.00405294f, 0.00192375f, 0.00780368f, -0.02482262f, -0.00103911f, 
    0.01811026f, -0.03192402f, -0.05466509f, 0.02799985f, -0.02619455f, -0.04575029f, -0.00124969f, 0.00043973f, 
    -0.02379056f, 0.02392287f, 0.03563027f, 0.01306204f, 0.00629735f, -0.05030183f, -0.00494864f, -0.04892329f, 
    -0.02728953f, 0.02749569f, 0.00215107f, -0.02610206f, 0.03968479f, 0.03658447f, 0.03438015f, -0.04266978f, 
    -0.02215428f, -0.01640238f, 0.02208191f, 0.02971644f, 0.01213992f, 0.03279153f, -0.01896379f, 0.00266968f, 
    0.00048904f, 0.02222943f, -0.03354829f, -0.04380542f, 0.02185809f, -0.05139270f, -0.01466953f, 0.01197757f, 
    -0.02591780f, -0.00739749f, 0.01989328f, 0.01553809f, -0.03280794f, 0.02422811f, 0.02928724f, -0.02057493f, 
    -0.03287226f, -0.03355015f, 0.03751731f, 0.03737690f, 0.01308932f, -0.03102011f, -0.01699923f, -0.05698878f, 
    -0.35691178f, 0.01030205f, -0.15019962f, -0.12185021f, 0.10436006f, 0.08512478f, 0.02270625f, -0.16167258f, 
    -0.06620669f, 0.09650867f, 0.04766163f, 0.00370418f, -0.11584421f, 0.00902100f, 0.04748298f, 0.08033836f, 
    -0.07622635f, -0.18404254f, -0.06507847f, -0.04094886f, -0.13225846f, -0.00155612f, -0.03526119f, -0.07667170f, 
    -0.16824922f, -0.26213059f, 0.34727862f, 0.06893503f, -0.19923921f, -0.03832305f, 0.04674578f, 0.03100592f, 
    0.09265628f, -0.03975172f, -0.02027903f, -0.01685835f, -0.22348757f, 0.01436802f, 0.07465727f, 0.00729708f, 
    0.07916840f, 0.16227178f, -0.10919148f, -0.04570960f, 0.12055121f, 0.10724574f, -0.07035868f, -0.00294195f, 
    0.41289452f, -0.23529530f, 0.18176417f, -0.25913039f, 0.03066882f, 0.12023334f, 0.01854603f, 0.11285000f, 
    0.11342622f, 0.00742178f, -0.12541051f, 0.01288365f, -0.01298896f, 0.19240302f, 0.00034337f, 0.03317808f, 
    0.09145758f, -0.10488686f, -0.03250629f, -0.05037364f, 0.09562108f, 0.08602744f, -0.01041167f, 0.12587726f, 
    -0.11948481f, 0.07443400f, -0.11949801f, -0.00011320f, -0.00178174f, -0.02297524f, 0.00363502f, -0.02031871f, 
    0.04582414f, 0.01091119f, 0.03949999f, 0.10078166f, -0.08600494f, -0.02416833f, -0.05245014f, 0.05507414f, 
    0.10340446f, -0.00385582f, 0.00412256f, 0.00146623f, -0.14165644f, -0.05360390f, 0.07976511f, -0.10608549f, 
    0.10603685f, 0.22573021f, -0.04368506f, 0.06482039f, 0.14530495f, -0.06820035f, -0.04661679f, -0.04547282f, 
    -0.03382064f, -0.15919435f, 0.02321116f, 0.03791217f, -0.09338447f, 0.07536029f, 0.07769062f, -0.23450512f, 
    0.08446831f, 0.02377905f, 0.07967681f, 0.09444702f, 0.03648141f, 0.12183263f, 0.01609899f, 0.18150771f, 
    -0.00083849f, -0.15551175f, 0.12678941f, 0.00502215f, 0.03315491f, -0.00803368f, 0.02158512f, -0.08149391f, 
    0.05854261f, 0.12383171f, 0.01256407f, -0.11365866f, 0.17242219f, 0.07586166f, 0.40139115f, 0.16382861f, 
    0.07529993f, 0.11322740f, 0.05865870f, 0.00595212f, -0.02554569f, 0.02519445f, 0.04421945f, 0.02097107f, 
    -0.06836543f, -0.03749152f, 0.28725842f, 0.29217166f, -0.16911954f, -0.04457034f, 0.06961198f, -0.04361292f, 
    0.02390794f, 0.11127381f, 0.00837460f, 0.01897278f, -0.09439385f, -0.15684442f, -0.14038700f, -0.07706710f, 
    0.11671313f, 0.09230237f, 0.03581866f, 0.06018136f, -0.11338863f, -0.13695912f, 0.09484086f, 0.09546505f, 
    0.07632802f, 0.02429192f, 0.14668246f, 0.16361123f, 0.02321103f, -0.04804271f, -0.03354640f, -0.11985642f, 
    -0.07108038f, 0.05315470f, 0.03163308f, 0.02221290f, 0.14926511f, -0.03225837f, 0.08167502f, -0.13542216f, 
    0.04415230f, 0.03256047f, -0.01613256f, 0.10184904f, 0.03629112f, 0.03993076f, -0.03927953f, 0.01683383f, 
    0.23224932f, 0.03614671f, 0.01738998f, -0.13343056f, 0.08909770f, 0.04226798f, 0.03780909f, -0.07026191f, 
    0.06708724f, -0.05322014f, 0.01043506f, -0.06707793f, -0.06516538f, -0.00906262f, -0.20151289f, -0.12003340f, 
    -0.01420925f, 0.17774472f, -0.14786300f, 0.00189952f, 0.08329296f, 0.07235849f, 0.08277351f, -0.01193583f, 
    0.02338051f, -0.14876810f, 0.13022281f, -0.05054577f, -0.06094308f, -0.05903429f, 0.02926357f, 0.11355007f, 
    0.02905765f, -0.09675403f, 0.03178840f, -0.08104134f, 0.58467704f, -0.15056440f, 0.27776158f, -0.04034782f, 
    0.03073161f, 0.10504525f, 0.03847065f, 0.06390773f, -0.03674120f, -0.04360231f, -0.03786540f, -0.02721923f, 
    -0.03643613f, 0.11158087f, -0.10671987f, 0.01643240f, 0.20892924f, -0.03023202f, 0.04547454f, -0.02112159f, 
    0.01977073f, -0.05850069f, -0.01757089f, 0.05370223f, 0.02268064f, 0.11979784f, 0.07335491f, 0.09790566f, 
    0.01962353f, 0.12440757f, 0.06391723f, -0.03209040f, 0.01963953f, -0.09838178f, 0.02285704f, 0.00065660f, 
    0.06362203f, 0.04824983f, 0.21969108f, -0.16092229f, 0.08899096f, -0.05135065f, 0.02343684f, -0.01890320f, 
    -0.03182356f, -0.02283633f, -0.00479277f, 0.03651788f, 0.07265728f, -0.20241553f, 0.03207925f, 0.00259482f, 
    0.00787332f, -0.07872336f, 0.05678213f, -0.04236765f, 0.00345592f, 0.05802673f, -0.02010685f, 0.09096248f, 
    -0.02599499f, 0.07525462f, 0.09623516f, -0.29139131f, 0.03012089f, -0.00744719f, 0.01907648f, 0.08402309f, 
    -0.12739733f, 0.06938894f, 0.10256585f, 0.01243462f, 0.06427591f, 0.00027224f, 0.00329870f, 0.21001489f, 
    0.08621983f, -0.03942271f, 0.03383246f, 0.12189920f, -0.13638337f, 0.05669306f, 0.06370945f, -0.00926138f, 
    0.27407458f, -0.06885138f, 0.08042181f, 0.02241708f, -0.03339500f, 0.00838381f, 0.07237646f, 0.06895082f, 
    -0.02675868f, 0.12053993f, -0.09897879f, -0.00002936f, -0.10591429f, 0.13040069f, -0.05533730f, -0.11881107f, 
    0.16232981f, 0.08781657f, 0.01163729f, 0.00806995f, -0.00857870f, 0.06977026f, 0.01519082f, -0.04387916f, 
    0.03248343f, -0.08962092f, 0.12076671f, -0.26298469f, -0.01410188f, 0.01227658f, 0.05956436f, 0.04615869f, 
    -0.03211714f, 0.07891012f, 0.04086494f, -0.05331216f, 0.02209287f, -0.06118475f, 0.12570211f, -0.15363508f, 
    0.07948559f, -0.04873459f, 0.02249548f, 0.07786084f, 0.04615380f, -0.02948709f, -0.07384361f, 0.07652893f, 
    -0.13229784f, 0.13877596f, -0.20539330f, -0.03807641f, 0.15912189f, 0.10698061f, 0.04022520f, 0.04389260f, 
    0.00036218f, 0.03677570f, 0.04062014f, -0.12711029f, 0.18423763f, -0.24734636f, -0.00284145f, 0.10235360f, 
    0.04606780f, 0.11015751f, 0.06735662f, -0.01636478f, -0.03445287f, -0.04635441f, 0.05660881f, -0.08683640f, 
    -0.07294471f, 0.14856954f, 0.11946592f, 0.12730443f, -0.00107490f, 0.07387599f, 0.06518084f, -0.00848388f, 
    0.07462765f, -0.13874546f, 0.01316078f, 0.03737739f, 0.06750184f, 0.14761999f, -0.10142942f, 0.17924264f, 
    0.14674389f, -0.07131165f, -0.04516836f, 0.04353132f, 0.04846192f, -0.08972724f, 0.00119752f, 0.02648614f, 
    -0.38524210f, 0.04853325f, -0.01038654f, -0.25733566f, -0.01813026f, 0.05369738f, -0.08820768f, -0.04254718f, 
    0.10448485f, 0.05281533f, 0.00359262f, -0.00670219f, 0.06882129f, 0.07736884f, 0.12562822f, 0.07062463f, 
    -0.03232196f, 0.01891168f, 0.05430909f, -0.04979081f, 0.00796815f, 0.01763935f, 0.04990370f, -0.10558912f, 
    0.23414944f, -0.24293314f, -0.00349176f, -0.17731822f, 0.11041488f, 0.03606921f, -0.02352293f, 0.18532304f, 
    0.03968879f, -0.00440879f, -0.03084482f, 0.00480430f, -0.17636916f, 0.08538490f, 0.01488682f, 0.10379883f, 
    0.04762540f, 0.01385855f, 0.05660289f, 0.05600347f, -0.00477842f, -0.08035197f, -0.04784663f, -0.09584894f, 
    -0.21278039f, 0.02333354f, 0.07281689f, 0.06771752f, -0.14698792f, -0.08964574f, -0.05464080f, 0.03042813f, 
    -0.14840575f, 0.02369668f, 0.00991537f, 0.04721163f, 0.33696556f, 0.20091504f, 0.06576233f, 0.09865733f, 
    -0.00649789f, 0.07877664f, 0.07398228f, -0.04470807f, 0.05244663f, -0.00510666f, -0.11106288f, 0.04797781f, 
    -0.02544962f, 0.05314092f, -0.11891734f, 0.18616074f, 0.17393228f, 0.00929306f, -0.02735023f, -0.00847108f, 
    -0.05676328f, -0.00312081f, 0.04875831f, -0.03095484f, 0.07041927f, 0.19445470f, 0.18680231f, -0.23291716f, 
    0.03296569f, 0.06818877f, 0.07094464f, 0.01515642f, -0.12197693f, 0.06060840f, 0.03729320f, 0.02655300f, 
    0.05234307f, 0.12219615f, 0.05887241f, 0.04950061f, -0.11267337f, -0.00714215f, 0.07895438f, -0.04562143f, 
    -0.09479854f, -0.11990398f, 0.00912048f, -0.07801577f, -0.32078514f, 0.06418358f, 0.02058088f, 0.21044968f, 
    0.19200748f, 0.05420866f, 0.03755103f, 0.04381166f, -0.05838360f, -0.02992773f, -0.02412840f, -0.07135122f, 
    -0.33250424f, -0.00817834f, -0.07441469f, 0.22780277f, 0.10919715f, 0.04206853f, 0.08071364f, -0.00976340f, 
    -0.02182468f, 0.06752070f, 0.06368072f, -0.04864305f, 0.25460353f, 0.10966515f, 0.07204432f, -0.07216936f, 
    0.14325808f, 0.13618313f, 0.00477032f, 0.01866697f, -0.07525937f, 0.11265945f, 0.09781141f, 0.01704443f, 
    0.22226644f, 0.02625837f, 0.09500835f, 0.21496655f, 0.11615966f, 0.06144941f, -0.03667828f, 0.04342942f, 
    -0.09825297f, 0.08891598f, 0.00389912f, 0.00419019f, 0.00022471f, 0.14621624f, 0.11812168f, -0.11532304f, 
    0.06990911f, -0.09853344f, -0.15124276f, 0.11909015f, -0.00086542f, -0.00233236f, 0.01235085f, 0.05275088f, 
    0.11213846f, 0.16494285f, 0.18080646f, -0.11624185f, 0.05167474f, -0.08049592f, 0.08159302f, 0.03391968f, 
    -0.00741179f, -0.09926511f, -0.05024122f, -0.12111461f, 0.00420121f, -0.14036234f, -0.02369142f, -0.01886362f, 
    -0.05585500f, 0.00949557f, -0.00991793f, -0.02410951f, -0.02142919f, -0.12532349f, 0.01739112f, 0.08841422f, 
    0.04665630f, -0.36060122f, 0.18797874f, -0.14054881f, -0.01132749f, -0.00969339f, -0.07663202f, -0.02214310f, 
    -0.00394310f, -0.00482514f, -0.01996673f, -0.15972163f, 0.23866950f, -0.00143918f, -0.00578496f, -0.16202775f, 
    0.05258700f, 0.05931457f, -0.12888187f, 0.02687989f, -0.01334690f, -0.05705346f, -0.03713189f, -0.07262334f, 
    -0.05134853f, 0.16836904f, 0.19311693f, -0.08814754f, 0.18497838f, -0.01965847f, -0.01971738f, 0.03001080f, 
    -0.02311431f, -0.13447788f, 0.03307113f, 0.15273201f, 0.14075215f, -0.05572747f, 0.15428604f, 0.24762636f, 
    0.15373462f, 0.03022373f, 0.08731446f, -0.12133498f, -0.06388558f, 0.07791923f, 0.17957725f, 0.11210277f, 
    -0.26635972f, -0.07794059f, 0.25232923f, 0.01374388f, -0.14758874f, 0.04152566f, -0.04167468f, 0.11816534f, 
    -0.01549033f, -0.01435647f, 0.03463765f, 0.09387860f, -0.09807037f, -0.18740489f, -0.08053668f, -0.13592240f, 
    0.00133405f, 0.04807921f, 0.06528266f, 0.07286436f, 0.00711055f, -0.05200439f, 0.01901100f, -0.01269178f, 
    0.15756556f, 0.13076086f, 0.12294678f, 0.02000849f, 0.04322112f, -0.00804326f, 0.01125058f, 0.04213906f, 
    0.03283971f, -0.05127628f, -0.00647910f, -0.04620951f, -0.35965991f, -0.13643087f, 0.04496549f, 0.11612043f, 
    0.07418041f, -0.03657581f, 0.13141318f, -0.09463328f, -0.07441966f, 0.08826163f, 0.05892282f, -0.10710648f, 
    -0.07341937f, -0.03945360f, 0.15601686f, 0.02549792f, 0.14135608f, 0.13884953f, -0.03498104f, -0.01747281f, 
    -0.07390939f, 0.06608977f, 0.03948789f, 0.08223499f, 0.09838355f, 0.14664608f, 0.02351809f, -0.05033125f, 
    0.12389278f, 0.00969806f, 0.05243021f, -0.08767313f, 0.04547683f, -0.01315439f, -0.01360077f, 0.04751491f, 
    -0.10289931f, 0.10710432f, -0.04541896f, -0.26089975f, 0.04741988f, 0.04629612f, -0.05889296f, -0.02528884f, 
    0.11545572f, 0.05581589f, 0.03923233f, -0.02685935f, -0.34014058f, 0.12248804f, -0.00351532f, -0.12371172f, 
    -0.03923680f, -0.04801784f, 0.07274772f, 0.04864165f, -0.03649328f, 0.05492137f, -0.15358074f, -0.03390530f, 
    -0.12165467f, 0.07598031f, 0.08691155f, -0.10150751f, -0.05649504f, 0.00737322f, -0.00796950f, 0.00648814f, 
    -0.04126325f, -0.02282983f, -0.04865491f, 0.03887142f, 0.07553505f, -0.15329789f, 0.10215555f, 0.21229963f, 
    -0.05075934f, -0.08833841f, -0.00651513f, -0.09464788f, 0.04457275f, -0.08631548f, 0.09657768f, -0.02932918f, 
    -0.04794943f, -0.04533625f, -0.00027204f, 0.03075258f, -0.02392584f, 0.04173791f, 0.03787085f, 0.03665110f, 
    -0.05158064f, -0.01137792f, -0.03731224f, -0.03373525f, 0.03647917f, 0.00870411f, 0.01379585f, 0.01807439f, 
    -0.03450460f, -0.01900992f, -0.03620601f, 0.03040287f, -0.00058065f, 0.01711073f, -0.04355456f, -0.03037794f, 
    -0.05597660f, -0.00098668f, 0.01650959f, 0.02369185f, 0.00345683f, -0.02960772f, -0.05107716f, -0.00596684f, 
    -0.05221982f, -0.00607948f, 0.01566255f, -0.04057660f, -0.01588741f, -0.03789157f, -0.05077872f, 0.02121099f, 
    0.00481801f, -0.04170515f, 0.03388161f, -0.05722269f, 0.03501391f, 0.04266250f, -0.05598067f, -0.02299065f, 
    -0.00839116f, -0.01404884f, 0.00859700f, 0.00136757f, -0.03428848f, -0.04792604f, 0.03880183f, -0.01480717f, 
    0.02784893f, -0.02276403f, 0.01947816f, -0.03847712f, 0.01751434f, -0.02983281f, -0.04089126f, -0.00719729f, 
    -0.05810618f, 0.03923599f, -0.01665681f, -0.00968956f, -0.03578326f, 0.02855455f, -0.00474791f, -0.00703335f, 
    0.01809369f, -0.03324932f, 0.00041939f, 0.00183583f, 0.02776858f, -0.04461965f, 0.03888355f, -0.02080998f, 
    -0.00770413f, -0.00075330f, 0.02417757f, -0.05015866f, -0.04849811f, 0.03462617f, -0.00816010f, 0.03232745f, 
    -0.02778401f, 0.02255025f, -0.02992934f, -0.02421017f, 0.04149648f, 0.02701074f, -0.03804193f, -0.03868579f, 
    -0.04607859f, 0.01621576f, -0.02847855f, -0.03572426f, 0.00356707f, 0.00655165f, 0.02052064f, -0.04397184f, 
    0.00785050f, 0.02848361f, -0.00174085f, 0.03504819f, 0.02995006f, 0.03842220f, -0.03060824f, -0.03882594f, 
    -0.03371954f, -0.00099439f, -0.02976621f, -0.05475030f, -0.00009787f, -0.01746901f, 0.02114516f, -0.00269733f, 
    0.01787080f, 0.00646733f, 0.03307893f, -0.00987322f, 0.00133589f, 0.00777641f, -0.03694639f, 0.03764033f, 
    0.02896330f, -0.02288093f, 0.03104376f, -0.00355572f, -0.05463654f, 0.00885915f, -0.05264900f, 0.03823566f, 
    -0.01727305f, -0.00968571f, -0.00636563f, -0.01224413f, 0.03886984f, -0.02034139f, -0.01155227f, 0.03838331f, 
    0.01608688f, 0.02978677f, 0.01403303f, 0.00540541f, 0.02878317f, -0.03108048f, -0.00860487f, -0.01975206f, 
    -0.04741853f, -0.05881117f, 0.00642911f, -0.02445819f, -0.03995913f, -0.00297913f, 0.02641315f, -0.05424347f, 
    -0.05466741f, 0.03888885f, -0.05400588f, -0.04700273f, -0.02335755f, -0.02455336f, -0.03846923f, 0.01234195f, 
    -0.05280239f, -0.00589261f, -0.01593647f, 0.00859040f, 0.03236683f, 0.00190818f, 0.02944282f, -0.00648393f, 
    -0.02924462f, 0.03565217f, -0.03359153f, 0.03604422f, 0.01680775f, 0.03534527f, -0.05693905f, -0.02552936f, 
    -0.04812950f, -0.02658601f, 0.00395683f, 0.00332937f, -0.04750298f, -0.03972353f, -0.04504561f, -0.02420273f, 
    0.00593566f, 0.02424797f, -0.02835071f, 0.00363938f, -0.02935795f, 0.02531287f, -0.03896580f, -0.02093527f, 
    0.00724297f, -0.00455502f, 0.02533243f, -0.03589696f, 0.00393726f, 0.02629626f, 0.01746968f, -0.04917251f, 
    -0.03545995f, 0.01322050f, 0.02804643f, 0.04037704f, -0.03438462f, 0.00421541f, -0.00253967f, -0.05369971f, 
    0.02757587f, -0.02926272f, 0.02945123f, 0.03501533f, -0.05626126f, -0.05708535f, -0.04330092f, -0.02264916f, 
    -0.04401280f, -0.00701480f, 0.04227751f, -0.04036969f, -0.04672592f, 0.01635575f, -0.02692377f, -0.01936413f, 
    0.03060354f, -0.05157768f, -0.02103266f, 0.02157828f, -0.01186750f, 0.02754783f, -0.05731118f, 0.03094639f, 
    -0.03199369f, 0.00920093f, 0.03673149f, 0.00149126f, 0.02118698f, 0.00216734f, -0.01871186f, -0.03876419f, 
    -0.00156086f, -0.00006010f, -0.01464749f, -0.01376990f, -0.00487873f, 0.03627126f, -0.01117304f, 0.01499059f, 
    -0.00668737f, -0.04283872f, -0.02166473f, 0.00332977f, 0.01334641f, -0.02354511f, -0.03103650f, -0.02529438f, 
    -0.02504150f, 0.02640301f, -0.00540709f, 0.03235682f, -0.03692079f, -0.04231874f, -0.02827164f, -0.04861546f, 
    0.03297781f, -0.05222913f, -0.01226761f, 0.03273556f, -0.01336814f, 0.03570712f, 0.03383418f, -0.03723505f, 
    0.00410428f, 0.00079919f, -0.01777014f, -0.03801429f, -0.01572328f, 0.01754217f, -0.00312337f, -0.02512510f, 
    0.02068930f, 0.02463958f, -0.00579450f, 0.02274432f, -0.05811784f, -0.05019198f, -0.01735782f, -0.03319355f, 
    -0.01126158f, 0.03370500f, -0.03287756f, -0.05761738f, -0.02847416f, 0.04199959f, -0.01778206f, 0.03746620f, 
    0.01658410f, 0.04210462f, 0.02955995f, 0.01623171f, -0.01137776f, 0.01407117f, -0.02525817f, 0.03045114f, 
    0.04133203f, -0.04090950f, -0.04893970f, 0.00607376f, -0.03454777f, -0.02028246f, -0.03430387f, -0.05281469f, 
    0.04042280f, 0.00251444f, -0.00490581f, -0.01547695f, -0.01404045f, -0.04526690f, -0.01253376f, -0.03159140f, 
    -0.01092802f, 0.02500721f, -0.00065974f, -0.00432498f, 0.01183095f, -0.03644880f, -0.04865298f, -0.03904814f, 
    -0.05250319f, -0.01644293f, -0.04725662f, 0.01581623f, -0.00012969f, -0.00174324f, 0.02772410f, 0.03835538f, 
    -0.02515529f, -0.04963986f, -0.00042962f, -0.02470377f, -0.02550600f, -0.02682948f, -0.02442956f, 0.03320965f, 
    -0.03368908f, -0.00951887f, 0.02379108f, 0.00939474f, 0.03126122f, 0.03849369f, -0.03808405f, -0.04675868f, 
    -0.03575782f, 0.01458813f, 0.00962756f, -0.03997567f, -0.00341083f, -0.01750337f, -0.00467341f, 0.01295284f, 
    -0.01616736f, -0.03530777f, -0.01482605f, -0.05804676f, 0.00826259f, 0.01302238f, -0.03768748f, -0.04104894f, 
    -0.01315645f, -0.00328049f, -0.00493173f, -0.03922099f, 0.03287343f, 0.00418139f, -0.00883458f, -0.05466582f, 
    -0.00447204f, -0.02238903f, -0.03551474f, 0.01722947f, -0.02383873f, 0.01134654f, 0.03211800f, -0.05018006f, 
    0.00592308f, 0.03587177f, -0.01418691f, -0.05236666f, 0.00303129f, -0.05678896f, -0.01369226f, -0.01196462f, 
    -0.00132989f, 0.01505422f, -0.01134238f, -0.01783720f, -0.00270480f, -0.04850233f, 0.02437508f, -0.01808533f, 
    0.03444676f, 0.02755525f, 0.04146107f, 0.03671372f, 0.04457202f, -0.00721348f, -0.03538765f, -0.04825553f, 
    0.02470987f, 0.01445792f, -0.05255133f, 0.00631010f, 0.00432497f, -0.02017004f, -0.02023213f, 0.00476837f, 
    0.03862530f, -0.00748612f, -0.04182602f, -0.04308820f, 0.03890602f, -0.00353121f, 0.02573840f, -0.04152984f, 
    -0.01692834f, 0.00490203f, -0.00134573f, -0.04699164f, -0.05575039f, -0.00761328f, -0.01973354f, 0.01459912f, 
    0.04472187f, 0.04394918f, 0.00563458f, -0.05127326f, -0.04403052f, -0.01975362f, 0.03328163f, 0.02798233f, 
    0.02719900f, 0.01604648f, -0.00729701f, 0.01913366f, -0.00734600f, 0.00384464f, 0.03345976f, -0.03124592f, 
    0.04301298f, -0.05322143f, 0.01709177f, -0.04743178f, 0.01675938f, 0.02915985f, -0.02358388f, 0.01689915f, 
    -0.03690443f, -0.04150377f, -0.03349456f, 0.02319543f, -0.02238765f, -0.01730711f, 0.02183694f, 0.00408093f, 
    -0.04827247f, 0.02416755f, -0.01207267f, -0.01716749f, -0.03683887f, 0.01994821f, 0.01286186f, -0.04150574f, 
    0.00725943f, -0.02742728f, 0.03263169f, 0.01761339f, -0.02213873f, 0.00427499f, -0.03490647f, -0.01811617f, 
    -0.03203011f, 0.03289001f, 0.03097584f, 0.02915828f, -0.03599153f, -0.05584344f, -0.03242758f, 0.02464827f, 
    0.01638504f, -0.00076384f, -0.05562697f, -0.04529799f, 0.00007243f, 0.04302098f, 0.00198059f, 0.04278768f, 
    0.04499400f, -0.02157180f, -0.03369546f, -0.04272906f, 0.01401289f, -0.02462013f, -0.03377027f, -0.04058480f, 
    0.02149134f, 0.01204834f, 0.04032587f, 0.01666718f, -0.02535234f, -0.00170487f, -0.05272540f, 0.01630501f, 
    0.01545371f, -0.03435070f, -0.02564793f, -0.05250674f, 0.03801781f, 0.01281244f, -0.04569296f, -0.03206890f, 
    -0.00249391f, -0.02249830f, -0.00093780f, -0.01716710f, -0.00831282f, -0.05681188f, -0.05555427f, 0.01051478f, 
    0.01101043f, 0.03403812f, -0.01492857f, -0.04734481f, 0.02577779f, -0.05476006f, -0.02092195f, -0.01738693f, 
    0.02885707f, -0.01925648f, -0.03841936f, 0.04443143f, -0.04985943f, 0.03362910f, 0.00575491f, 0.01856029f, 
    -0.00281924f, 0.01502820f, -0.03530237f, -0.04180844f, -0.00267665f, -0.03825836f, -0.03360673f, 0.03763924f, 
    0.00587970f, -0.03292939f, -0.02911542f, 0.00748184f, -0.02140007f, -0.01966249f, -0.04482904f, 0.03015849f, 
    0.01900905f, -0.00308651f, -0.02298945f, -0.04005297f, -0.04648338f, 0.03422290f, -0.03292343f, 0.03307901f, 
    -0.00982509f, 0.00994924f, 0.01572474f, -0.02181586f, -0.04640395f, 0.02221340f, 0.00285073f, 0.00612294f, 
    -0.04917854f, -0.03951391f, -0.02098136f, -0.03256290f, 0.00779342f, -0.00725084f, -0.00843674f, 0.03645201f, 
    0.02763667f, -0.04512899f, 0.00151703f, 0.02290034f, -0.04485151f, 0.00834878f, -0.02859298f, -0.00655014f, 
    -0.00625392f, -0.05184095f, 0.00614324f, -0.01356060f, 0.03839821f, -0.01321718f, -0.03800902f, 0.04108118f, 
    -0.03902961f, -0.03894775f, -0.05647400f, 0.04195508f, -0.02551553f, -0.04203470f, -0.02839358f, -0.05495022f, 
    0.01785113f, -0.00005505f, -0.03684389f, 0.03175432f, 0.03264956f, -0.05599242f, -0.02331925f, -0.00793973f, 
    -0.01401177f, 0.04051044f, -0.03908750f, 0.00434701f, -0.01987554f, -0.00072238f, 0.04010019f, -0.00017904f, 
    -0.02769684f, -0.02072242f, -0.01812321f, -0.01841305f, 0.00529369f, -0.01013376f, -0.02474683f, -0.04853793f, 
    0.03584002f, 0.04322105f, -0.02186798f, -0.00110220f, 0.02523992f, -0.00020872f, -0.00468550f, 0.02532253f, 
    -0.04485840f, 0.03173890f, -0.00174398f, 0.04183876f, -0.05515208f, -0.04189631f, -0.00682012f, 0.03126734f, 
    -0.01848838f, -0.00896640f, -0.04450167f, -0.00516830f, 0.03293753f, -0.02917228f, -0.02496981f, 0.03389554f, 
    -0.02115694f, -0.04833233f, 0.02545722f, -0.04517580f, -0.03125607f, 0.00855178f, -0.02961294f, 0.00927500f, 
    0.01337464f, -0.04745313f, -0.00216335f, -0.02273557f, 0.04347179f, 0.00470212f, -0.02723285f, -0.03496514f, 
    -0.01147850f, -0.00648278f, 0.01874673f, 0.03189911f, -0.03334510f, 0.00976720f, -0.02720456f, 0.03040154f, 
    -0.02281517f, -0.00741730f, -0.00351610f, -0.05088853f, 0.03768179f, 0.00071431f, 0.00180186f, -0.05103508f, 
    -0.05476860f, 0.00823791f, 0.04280567f, 0.02415217f, 0.02911741f, 0.01001877f, 0.00160276f, 0.01837921f, 
    -0.02250615f, -0.03792078f, -0.02800865f, -0.00402271f, 0.01659021f, 0.03220417f, -0.01756844f, 0.01932799f, 
    -0.05452094f, 0.04103725f, -0.04817293f, 0.01906677f, -0.00827116f, -0.01398499f, 0.00382372f, 0.03900999f, 
    -0.03151107f, 0.02011659f, 0.00352625f, 0.00691553f, 0.00826254f, -0.03722561f, 0.01443938f, 0.02977000f, 
    0.02627554f, 0.01970443f, -0.05443433f, -0.01830477f, -0.04909252f, -0.04966806f, -0.03152331f, 0.03215837f, 
    0.02526087f, -0.04707145f, -0.00756932f, -0.00723898f, 0.04117141f, 0.02902918f, -0.02875462f, 0.04078925f, 
    -0.02030245f, -0.01058104f, -0.01681888f, -0.04838461f, 0.02847458f, -0.01401638f, -0.04876695f, 0.02922679f, 
    0.03194986f, -0.05634699f, -0.01931630f, 0.02612801f, -0.03075105f, -0.03289164f, -0.05405667f, -0.03629596f, 
    0.00214708f, -0.01744945f, -0.04849834f, -0.03580792f, -0.03949201f, -0.05582151f, -0.05302200f, -0.04276910f, 
    0.02097281f, 0.01390098f, -0.03575284f, -0.03704078f, -0.01509639f, 0.02385452f, -0.03451351f, -0.04211177f, 
    -0.03498203f, 0.01956038f, 0.03521722f, -0.05271404f, -0.00622488f, -0.05685743f, -0.02703238f, 0.01034260f, 
    -0.03311122f, 0.01444825f, -0.01094463f, 0.00715665f, -0.02301057f, 0.03699623f, -0.05075707f, -0.00905733f, 
    0.03408577f, 0.02896417f, 0.01556473f, 0.03783650f, 0.00329405f, 0.01807712f, -0.02164678f, 0.00314523f, 
    0.00344971f, -0.04011321f, -0.01061079f, 0.02603428f, 0.02245108f, 0.05326163f, -0.04676666f, 0.02468958f, 
    0.03034503f, 0.02920990f, -0.01556016f, 0.01437276f, 0.02312099f, 0.04192723f, -0.03761207f, 0.03686575f, 
    0.03229148f, 0.04144455f, 0.02964667f, -0.03890508f, -0.01426871f, 0.00372448f, 0.03973766f, 0.02453132f, 
    0.04437598f, -0.01414169f, -0.01722557f, -0.01675820f, -0.02219916f, 0.01035489f, 0.01447968f, -0.03732416f, 
    0.04046118f, -0.03496778f, 0.01143553f, -0.00459004f, 0.00421927f, -0.02417354f, -0.03515822f, 0.04218638f, 
    -0.05632003f, 0.02916978f, 0.02598313f, -0.00015013f, 0.02359466f, -0.01764639f, 0.03536617f, -0.03052662f, 
    -0.03222411f, -0.00201617f, -0.03296686f, -0.04208319f, 0.00013360f, 0.03472837f, -0.03951346f, -0.04418814f, 
    0.00503030f, 0.00314862f, -0.05176751f, 0.02997594f, 0.02407483f, 0.04383570f, -0.02955922f, -0.04376487f, 
    0.02151658f, -0.04411485f, -0.06449771f, -0.04446767f, -0.03341217f, 0.01200689f, 0.01667736f, -0.05071637f, 
    0.01860635f, 0.03163939f, -0.02243106f, 0.01968401f, 0.01907874f, 0.02466981f, -0.04321605f, 0.01843147f, 
    -0.04302013f, 0.00320869f, -0.05016649f, -0.00013323f, -0.05372069f, -0.01447910f, 0.03817085f, -0.04193467f, 
    0.00035925f, 0.01970746f, -0.04117789f, -0.02661363f, -0.03028967f, -0.02705150f, -0.00510354f, 0.02779253f, 
    -0.01670384f, 0.03034229f, 0.01005080f, -0.03374791f, -0.02386169f, -0.05249530f, 0.01677466f, -0.01865118f, 
    0.03822567f, -0.05030672f, 0.00154401f, -0.02694722f, -0.05351921f, -0.04588424f, -0.02216897f, -0.02045706f, 
    0.03920976f, -0.01201271f, 0.03899058f, -0.00181900f, 0.01506615f, 0.03552001f, 0.02993430f, 0.02548419f, 
    0.04241446f, -0.03611853f, -0.04258500f, -0.05587298f, -0.00366073f, 0.01746303f, -0.03563685f, 0.02361486f, 
    0.01368199f, -0.00981939f, 0.01662384f, -0.02636427f, -0.00814950f, 0.02154239f, 0.00411497f, 0.03177122f, 
    -0.05217694f, 0.02871137f, 0.02322984f, 0.01867284f, 0.01080677f, 0.00276238f, 0.03127118f, 0.01624685f, 
    0.03937292f, 0.02498634f, -0.01044315f, -0.02520456f, 0.01465577f, -0.03254789f, -0.03778576f, -0.02505045f, 
    -0.04245229f, 0.02624744f, 0.00731668f, -0.00452742f, -0.04351084f, -0.03973686f, 0.03131711f, 0.00402067f, 
    0.05247371f, 0.03966538f, -0.05378322f, 0.02874630f, 0.02996377f, 0.00013445f, 0.00586113f, -0.03448238f, 
    0.02827572f, -0.04544559f, 0.04406659f, 0.03312367f, 0.01890964f, -0.05475092f, -0.04055966f, 0.01563256f, 
    -0.02182859f, -0.04860777f, -0.04432168f, 0.03677101f, 0.01851607f, -0.02527910f, -0.02443248f, 0.01412565f, 
    -0.00267655f, -0.00684711f, -0.05515245f, 0.00779447f, 0.00238411f, 0.01622332f, 0.01711404f, -0.04140952f, 
    -0.03551519f, 0.02502559f, 0.00928745f, -0.04221846f, 0.01285744f, 0.00363413f, 0.03940456f, 0.04297082f, 
    0.01363987f, 0.01808788f, -0.05511894f, 0.03598659f, 0.04139910f, -0.05672378f, 0.02931710f, -0.04945124f, 
    -0.05117995f, -0.02744718f, 0.00488282f, 0.03860691f, -0.05989464f, -0.01883193f, 0.00677965f, 0.00603561f, 
    -0.04219803f, 0.01374784f, -0.04997715f, -0.02837004f, 0.01361077f, -0.05453809f, -0.01354115f, -0.03955872f, 
    0.02610143f, -0.00011468f, 0.00794399f, -0.04104703f, -0.03111245f, -0.01364866f, -0.03447907f, -0.05340384f, 
    -0.05297353f, 0.03608577f, -0.01120055f, -0.02271624f, -0.02930543f, -0.04991961f, -0.04800032f, -0.02803830f, 
    -0.04510056f, -0.04638474f, -0.00928008f, -0.05887343f, -0.00059308f, 0.02875708f, 0.02425240f, -0.04295010f, 
    -0.04644004f, -0.03220835f, -0.05657762f, -0.03714027f, 0.02855011f, -0.02438337f, -0.03345633f, 0.01764179f, 
    -0.05108778f, 0.02373640f, -0.00657366f, -0.00756757f, -0.03681734f, -0.05701357f, -0.03063332f, -0.05839145f, 
    -0.03199616f, -0.05310390f, 0.00377786f, -0.05992628f, -0.03245302f, -0.02035994f, -0.01667325f, 0.00195268f, 
    0.00265643f, -0.00102905f, -0.01813990f, 0.02253769f, -0.01511817f, 0.02564381f, -0.05617315f, -0.01148458f, 
    -0.02079883f, 0.00493964f, -0.02800993f, -0.03843664f, 0.01986954f, 0.02503376f, 0.00005480f, -0.01650162f, 
    0.03787081f, -0.00617593f, 0.02128590f, 0.03940986f, 0.04830872f, -0.04184800f, 0.01703746f, -0.00890109f, 
    0.01905973f, -0.04976420f, 0.00756145f, 0.03110054f, -0.05184323f, -0.04279569f, 0.00512391f, -0.05282633f, 
    -0.05789268f, 0.02597569f, 0.02386256f, -0.01636397f, -0.03091150f, 0.03126006f, -0.01625981f, 0.01021213f, 
    0.03384318f, -0.05071500f, 0.01910505f, 0.00749934f, 0.03062361f, -0.01118294f, -0.00801385f, -0.05485609f, 
    -0.02951179f, 0.01176332f, -0.02354226f, 0.01588444f, -0.00943807f, -0.00783678f, 0.00880782f, -0.00881960f, 
    0.01921366f, -0.02625830f, -0.03558048f, 0.03568248f, -0.04806450f, 0.02105992f, -0.03865873f, -0.01235643f, 
    -0.02510803f, 0.02828288f, -0.00102988f, 0.02729722f, -0.05019091f, 0.00981469f, -0.02168701f, 0.00945082f, 
    0.00609074f, -0.04018010f, 0.01545286f, 0.03734930f, -0.00935126f, -0.02146206f, -0.00515827f, 0.00445807f, 
    -0.10563279f, 0.00594058f, -0.06256730f, -0.14139371f, -0.05657412f, -0.00540793f, -0.03284294f, 0.00028300f, 
    -0.10876179f, 0.09578364f, -0.11881266f, -0.07545886f, 0.12207820f, 0.05229010f, 0.11561760f, 0.19019735f, 
    -0.05608348f, 0.03947511f, 0.08651868f, 0.17326789f, -0.11722838f, 0.12718087f, -0.01050580f, -0.03244754f, 
    0.10524144f, 0.01415896f, 0.14285032f, 0.14500903f, 0.00110217f, 0.08604874f, 0.08558424f, -0.05277539f, 
    -0.10128068f, 0.03016979f, -0.02106918f, 0.09976545f, 0.12392650f, -0.01879155f, -0.02213873f, -0.22810358f, 
    -0.03977955f, -0.08328068f, -0.05174744f, 0.14201905f, -0.06667681f, -0.10380396f, -0.00494302f, -0.02573218f, 
    0.07304779f, 0.09280653f, -0.11028536f, 0.05240524f, 0.05072520f, 0.07624557f, 0.02452474f, -0.12919824f, 
    -0.01899151f, 0.05159873f, -0.10730993f, -0.10906922f, 0.43228486f, -0.02969777f, 0.13317341f, 0.07299356f, 
    -0.06851761f, -0.10300821f, -0.03846423f, 0.04757453f, -0.06663600f, 0.02403186f, -0.06150476f, 0.05198627f, 
    -0.00871884f, 0.00779588f, -0.21093732f, 0.06341331f, 0.02960657f, 0.07638925f, 0.00834650f, -0.10974405f, 
    0.04250353f, -0.00381897f, 0.07317080f, -0.02376697f, -0.08232687f, -0.11366221f, -0.13572440f, -0.01148504f, 
    0.04933891f, -0.10930517f, 0.01440181f, -0.04799041f, -0.05411286f, 0.03102334f, -0.09118988f, -0.08886196f, 
    0.02985071f, -0.01732706f, 0.17350349f, -0.00547097f, -0.10792983f, -0.07557794f, 0.16153979f, 0.01225169f, 
    0.16690961f, -0.03932988f, -0.07607976f, -0.14554602f, 0.03263755f, 0.08097448f, -0.13043933f, -0.00176501f, 
    -0.09962407f, 0.10297183f, 0.05712748f, -0.00877040f, 0.13139337f, 0.06834286f, 0.01582164f, 0.05599755f, 
    0.16836776f, -0.03515736f, -0.13167615f, 0.02650686f, -0.10296179f, 0.08677137f, -0.08200832f, 0.01756227f, 
    0.04115775f, 0.06304513f, -0.00778026f, 0.03635821f, 0.22843622f, 0.24356125f, 0.35534066f, 0.12488048f, 
    0.04848976f, 0.07968501f, 0.00420964f, 0.02529725f, -0.00380987f, 0.05662737f, 0.01488659f, -0.06484801f, 
    0.14962980f, 0.17805840f, 0.36282840f, 0.20027740f, 0.17538907f, -0.02118796f, -0.00121863f, 0.15943164f, 
    -0.02537305f, 0.04739757f, -0.01914883f, 0.05535928f, -0.19309862f, 0.08615300f, -0.09870434f, 0.15395539f, 
    0.02142530f, 0.09645701f, 0.08001404f, 0.03008293f, 0.05178320f, -0.06837758f, -0.08622142f, -0.01185228f, 
    -0.04504028f, 0.01634345f, 0.14917876f, -0.02614382f, -0.00823495f, -0.02789401f, 0.08186087f, 0.01187457f, 
    0.04342669f, 0.05056388f, -0.05260524f, -0.00802993f, -0.10304364f, 0.09952132f, 0.01165129f, -0.00868551f, 
    0.00374735f, 0.05373237f, 0.20373918f, -0.11546549f, 0.06787581f, 0.14377667f, 0.01605452f, 0.04170857f, 
    -0.07794889f, -0.04912360f, -0.03701676f, 0.09786911f, 0.04548972f, 0.14057879f, 0.09846479f, -0.02272660f, 
    -0.06993083f, 0.03582503f, 0.13762772f, 0.13990541f, 0.03421247f, -0.05150316f, -0.19804473f, 0.09193038f, 
    -0.04505690f, -0.01211826f, -0.03923944f, -0.03537014f, -0.07974909f, -0.01560267f, 0.03820387f, -0.11351401f, 
    0.12330392f, -0.03016309f, -0.15661499f, -0.07145786f, 0.08317586f, -0.02197048f, 0.01624145f, -0.09249542f, 
    -0.08096682f, -0.05355966f, -0.02979569f, -0.05466851f, 0.19180192f, 0.07987198f, 0.01636204f, 0.05812681f, 
    0.01741943f, 0.10052311f, 0.05824657f, 0.15153830f, 0.08033625f, -0.04855501f, -0.04075248f, -0.08238741f, 
    0.06630212f, -0.04669905f, -0.15318197f, 0.21756271f, 0.00694856f, 0.06909214f, 0.04891966f, -0.02659491f, 
    0.04563993f, 0.02985334f, -0.06269652f, -0.13813144f, 0.14424285f, 0.06826819f, 0.10158142f, 0.03385241f, 
    -0.01493677f, 0.03195992f, -0.00186642f, 0.13118404f, 0.05909432f, 0.03875044f, -0.14132224f, -0.21259442f, 
    -0.17959417f, -0.06902066f, -0.28862652f, -0.06531889f, 0.08901495f, 0.00117906f, 0.05429507f, -0.09996824f, 
    -0.03913094f, 0.14832920f, -0.09201901f, -0.19810295f, 0.35227108f, 0.02323893f, 0.08451557f, 0.14863770f, 
    -0.01827030f, 0.01670069f, 0.01087993f, 0.06384693f, -0.02639807f, 0.03192699f, 0.01570835f, -0.06652106f, 
    0.03275455f, -0.08998428f, 0.02120715f, -0.08125047f, -0.01364422f, 0.04170161f, 0.03397194f, 0.00294937f, 
    -0.08825166f, -0.06309000f, -0.00165263f, 0.04972683f, 0.32726482f, 0.02518121f, 0.02390648f, -0.17669185f, 
    0.02445391f, -0.08464768f, -0.13575527f, 0.09618016f, -0.04616850f, 0.03162972f, 0.05197074f, 0.09042480f, 
    0.16240859f, 0.05584412f, -0.05248649f, -0.10484878f, -0.07486001f, 0.00461817f, 0.17155665f, -0.01937783f, 
    0.04584378f, -0.02305374f, -0.08622846f, 0.04911187f, 0.13065113f, 0.02609976f, -0.06277030f, 0.05054054f, 
    -0.04030857f, 0.08131705f, -0.07816053f, 0.00503032f, -0.11314394f, -0.02684277f, 0.00650950f, -0.17785968f, 
    0.30216748f, -0.13822006f, 0.08460583f, 0.27646104f, -0.16343853f, 0.03703547f, 0.12436650f, 0.04768427f, 
    0.02984775f, 0.04049085f, 0.00616189f, -0.00031833f, 0.35321262f, 0.08118966f, 0.01303142f, 0.05285619f, 
    0.02548854f, -0.02328503f, -0.08082863f, 0.05288117f, 0.08280969f, -0.08518780f, 0.11746048f, 0.14588667f, 
    0.09202050f, 0.07241125f, -0.02565248f, 0.12252349f, -0.05494909f, 0.01971001f, -0.01203019f, -0.02079461f, 
    -0.12909631f, -0.13990088f, -0.06161778f, -0.07693940f, 0.25912783f, -0.02556494f, -0.03076941f, -0.13727489f, 
    -0.08256542f, 0.02512367f, 0.01574767f, 0.01494860f, 0.00822543f, -0.03616343f, -0.05582111f, -0.09727588f, 
    0.08219284f, 0.13737471f, 0.20712984f, -0.05307240f, -0.08399853f, -0.03797142f, -0.01841332f, 0.18310545f, 
    -0.06045721f, -0.10748612f, 0.04179941f, -0.01962660f, 0.09720036f, -0.00618016f, -0.02326061f, 0.19750024f, 
    0.17764820f, 0.08960985f, -0.00711073f, 0.08704070f, 0.00420167f, 0.00873374f, -0.06005830f, 0.15673064f, 
    0.15719005f, 0.12325801f, -0.14652508f, -0.12370756f, 0.11017857f, 0.08874084f, -0.09467111f, -0.00474509f, 
    0.00149415f, 0.05816026f, -0.00161595f, 0.06675149f, 0.20056577f, -0.02062451f, 0.06099729f, -0.21592040f, 
    -0.05906743f, -0.14740056f, 0.12569469f, 0.01936710f, -0.04769028f, -0.07050368f, 0.06084530f, 0.02304650f, 
    0.01048122f, -0.00853493f, -0.23236644f, 0.08914418f, -0.05305137f, -0.06020465f, -0.09134757f, 0.11023957f, 
    -0.08053680f, 0.05549633f, 0.11861028f, -0.03802251f, 0.07962932f, -0.19720505f, 0.13827141f, 0.15882163f, 
    0.02902912f, 0.05357514f, 0.08689085f, 0.19243328f, -0.00953052f, -0.02343584f, -0.02246691f, -0.07531802f, 
    -0.16250871f, -0.02764339f, 0.09404297f, 0.12014768f, -0.08060152f, 0.02248619f, 0.06332374f, 0.02079502f, 
    -0.09167790f, -0.01650827f, 0.03562065f, -0.03070173f, 0.36229539f, 0.17160052f, 0.08657492f, 0.04591853f, 
    0.08670492f, 0.05737451f, 0.09199421f, 0.01210306f, 0.07808231f, 0.01805069f, -0.07906462f, 0.14235529f, 
    -0.18358974f, -0.09702301f, 0.10346325f, -0.12332180f, -0.04380320f, 0.02837011f, 0.14732233f, 0.08476838f, 
    0.10516570f, 0.12235241f, -0.05535575f, -0.00434285f, 0.21405588f, 0.10534207f, 0.01705205f, 0.13509120f, 
    0.06221333f, 0.06802303f, -0.08771040f, -0.00387608f, -0.10228932f, -0.01608358f, -0.00538509f, -0.16265032f, 
    -0.05885313f, 0.25632036f, -0.28379422f, -0.07757425f, -0.21669777f, 0.12552367f, 0.04446721f, 0.09419777f, 
    -0.09846946f, -0.00197850f, 0.09002703f, 0.07513693f, -0.18904483f, 0.03224488f, -0.00407069f, 0.11466277f, 
    -0.00355782f, -0.09969910f, -0.01346224f, 0.11914243f, 0.06581083f, -0.02115106f, -0.01352000f, 0.01171064f, 
    -0.12981385f, 0.08201416f, 0.00171636f, 0.08581078f, 0.13508120f, 0.04873088f, -0.05095645f, 0.06119238f, 
    -0.00328928f, 0.04705070f, 0.05949851f, -0.17105016f, 0.22655572f, 0.05517768f, 0.10376566f, 0.02276720f, 
    0.08398841f, 0.06553801f, -0.09239002f, 0.02025747f, 0.07964226f, 0.11270542f, -0.04153127f, 0.00322977f, 
    0.04304039f, -0.09456232f, -0.07988083f, -0.06483825f, -0.08498748f, 0.04761479f, 0.01625157f, 0.11413299f, 
    0.05553856f, 0.01178786f, -0.00944399f, 0.02291510f, -0.04400285f, 0.21184586f, -0.03155273f, 0.00225245f, 
    -0.12277444f, -0.01734782f, 0.03057607f, 0.08278434f, -0.08673637f, -0.02904874f, -0.09628829f, -0.14535828f, 
    -0.01868306f, 0.07828645f, 0.09938170f, 0.04985849f, 0.06875817f, 0.01158444f, 0.10455272f, 0.11335158f, 
    0.00452837f, 0.00477352f, -0.00305706f, 0.06213034f, -0.01674140f, -0.11275180f, 0.01385474f, 0.07671615f, 
    0.01530418f, -0.02781816f, 0.08155239f, 0.05726075f, -0.00053603f, -0.06799043f, 0.00476225f, 0.03484394f, 
    0.24925725f, -0.22256385f, -0.10586829f, -0.11590160f, 0.02362349f, 0.01279455f, -0.19203582f, -0.08705816f, 
    0.02408557f, 0.04966604f, 0.13741015f, -0.02108674f, -0.23327912f, 0.04114415f, -0.22792082f, -0.22274245f, 
    0.01106289f, 0.02303831f, -0.12665936f, 0.06344414f, 0.08205450f, -0.06254449f, 0.05699382f, 0.03566646f, 
    -0.03917333f, -0.03155335f, 0.31288800f, 0.12125608f, 0.12442825f, 0.02587702f, -0.03763781f, -0.02959716f, 
    -0.06245608f, -0.02830472f, 0.06761555f, -0.02352686f, 0.07428879f, -0.09320626f, 0.00701873f, 0.11471450f, 
    0.10058058f, -0.07413112f, 0.00261123f, 0.02308879f, -0.09960833f, 0.09467085f, 0.08308435f, 0.11313333f, 
    -0.31146717f, -0.32010588f, -0.17279899f, -0.08527847f, -0.01864939f, 0.08348040f, 0.01033267f, 0.10159496f, 
    -0.07368872f, -0.04391237f, -0.01001132f, -0.01975920f, 0.29031122f, 0.01768152f, -0.02311594f, -0.06376901f, 
    0.01642156f, 0.03881250f, -0.10966063f, 0.04005580f, -0.07686353f, -0.08001235f, -0.00333389f, -0.01397679f, 
    0.03808067f, 0.13203999f, 0.04740871f, 0.16942437f, -0.02209818f, 0.00783019f, 0.00838804f, -0.07755419f, 
    0.14279306f, -0.10113081f, -0.01536354f, 0.01703551f, -0.31306317f, 0.07322159f, 0.08517437f, -0.29662856f, 
    0.02946911f, -0.06463446f, -0.01198317f, -0.12504777f, 0.08756465f, 0.03971190f, 0.04770528f, -0.14480963f, 
    -0.19134933f, 0.08671191f, -0.13079759f, -0.10084481f, 0.06377997f, 0.04445076f, -0.08801534f, -0.03423531f, 
    -0.12840220f, -0.04718877f, 0.05531271f, -0.02518143f, 0.29512709f, 0.02473173f, 0.01964293f, 0.11036912f, 
    0.04860023f, 0.05340248f, 0.10127494f, 0.01415229f, 0.04130241f, -0.13865498f, 0.01320907f, 0.11457973f, 
    0.05333105f, -0.11929809f, -0.17983195f, 0.03723301f, 0.03324918f, 0.05102591f, -0.17370495f, -0.03158529f, 
    0.12863162f, -0.08796456f, -0.03690281f, 0.10099254f, -0.09399579f, 0.27675918f, -0.14582852f, 0.10792866f, 
    -0.05211356f, 0.07613618f, -0.03536322f, -0.06056119f, -0.01125570f, 0.13641548f, 0.01199412f, -0.10721084f, 
    0.03708431f, -0.06412575f, 0.01989049f, 0.22000331f, 0.00570140f, -0.09970251f, -0.01005058f, -0.02524936f, 
    -0.08248331f, -0.04954594f, 0.06083689f, 0.20789532f, 0.07080600f, 0.15499170f, -0.11729221f, -0.16970007f, 
    -0.03741106f, -0.00114775f, 0.03422353f, -0.00512575f, 0.07407237f, -0.03555891f, 0.10383079f, 0.07637762f, 
    -0.05058291f, -0.04672435f, -0.03531422f, 0.00899816f, 0.01452346f, -0.02351608f, 0.03114238f, -0.01418242f, 
    -0.04374727f, -0.03033167f, 0.00891429f, -0.03737018f, 0.04103781f, 0.03036094f, -0.00200024f, 0.00031464f, 
    0.04384408f, -0.02097910f, 0.01634496f, -0.01750199f, -0.02778097f, 0.01847454f, -0.02371689f, 0.01777570f, 
    0.00318316f, -0.03306968f, 0.00589766f, -0.01666952f, -0.01600011f, 0.02079847f, -0.02090738f, -0.05163026f, 
    0.02123734f, -0.04774713f, -0.02138646f, 0.02625798f, -0.03536277f, -0.05426830f, 0.03054227f, 0.04535814f, 
    -0.00975384f, 0.04091712f, -0.00629229f, -0.05348871f, -0.02509800f, -0.02395453f, -0.01906894f, -0.04490625f, 
    -0.01665419f, 0.01779444f, 0.02459452f, 0.03212298f, 0.01460896f, -0.02557418f, 0.03938408f, 0.03297187f, 
    -0.05242272f, -0.00907093f, 0.02522033f, -0.04124070f, 0.03130236f, 0.00159739f, 0.02439477f, -0.05089197f, 
    -0.02583015f, -0.01756643f, 0.01122382f, -0.00913519f, -0.00821446f, -0.04107166f, 0.03106740f, 0.00325032f, 
    -0.00656183f, 0.03209725f, 0.04151901f, -0.01178431f, 0.04773569f, -0.00426798f, 0.02000889f, -0.03029284f, 
    -0.02981883f, -0.04715880f, 0.03886856f, -0.03691346f, 0.01174360f, -0.05410162f, -0.02175024f, 0.03641671f, 
    -0.00269187f, 0.04339477f, -0.00139131f, 0.04466054f, -0.03341049f, -0.05453688f, 0.03102938f, -0.05040065f, 
    -0.05438180f, -0.03109258f, -0.02096766f, -0.02801961f, -0.02120937f, 0.00952298f, -0.02087834f, 0.04535479f, 
    -0.03284812f, 0.03189686f, 0.03544176f, 0.02889057f, -0.05057983f, -0.03740731f, -0.03204511f, -0.04696929f, 
    -0.02117121f, -0.05588151f, -0.04350388f, 0.04178435f, -0.02434937f, -0.03129215f, -0.05350739f, 0.04737538f, 
    0.02849192f, -0.02400890f, -0.00761856f, 0.00369514f, -0.04770761f, 0.02472649f, -0.00295111f, -0.02977134f, 
    -0.01677158f, 0.03219786f, -0.03477117f, -0.02111736f, 0.00503934f, 0.02091667f, -0.05615423f, -0.03042218f, 
    0.02891716f, 0.02227089f, 0.02402055f, -0.04911303f, -0.04383788f, -0.01119271f, 0.01880246f, -0.04366602f, 
    0.02982864f, 0.00071842f, 0.03353765f, -0.04887206f, 0.04162083f, -0.03815581f, 0.03199789f, -0.04577367f, 
    -0.02142378f, 0.00306203f, -0.02726508f, -0.05235586f, -0.04575329f, -0.04570842f, -0.04877494f, 0.01003440f, 
    0.00058572f, -0.03009460f, 0.03897917f, 0.00133345f, -0.00649973f, 0.03567587f, -0.01820323f, 0.02896656f, 
    -0.02767199f, -0.00981842f, 0.02877195f, -0.00248544f, -0.05492411f, -0.00754383f, -0.01029168f, -0.02545032f, 
    0.02219082f, -0.05443625f, 0.00685108f, 0.02859505f, 0.01646149f, -0.02290303f, 0.00389204f, 0.00489875f, 
    0.01678265f, -0.01367048f, 0.00859356f, 0.01902623f, 0.01087579f, -0.04489529f, -0.04843498f, -0.03183994f, 
    0.02995158f, 0.02722538f, -0.03263246f, 0.02625802f, -0.05472598f, -0.00373616f, -0.00770211f, -0.04268559f, 
    0.04399318f, -0.03594190f, 0.00188556f, -0.00590294f, 0.04143310f, -0.02780575f, -0.03119746f, 0.00817403f, 
    -0.01536551f, 0.03892628f, 0.00006080f, -0.01234587f, 0.03292795f, 0.00436396f, -0.00850847f, 0.01460139f, 
    -0.02201538f, 0.03101216f, 0.03366515f, 0.03337345f, 0.01629249f, 0.01525462f, -0.01337185f, -0.05030106f, 
    -0.04338268f, 0.02919045f, -0.04491515f, 0.01796155f, 0.01053987f, -0.03854953f, 0.03705061f, 0.02597095f, 
    -0.03115156f, -0.05227860f, 0.02411469f, -0.03459079f, -0.00373806f, 0.04030503f, 0.02563521f, -0.01266214f, 
    -0.02637604f, -0.02400648f, 0.02217386f, -0.00700516f, -0.01932873f, -0.00657845f, 0.03897764f, -0.00727416f, 
    -0.03810846f, -0.02689096f, -0.00940053f, 0.00345653f, -0.03551530f, 0.01374229f, -0.02590882f, -0.01228696f, 
    -0.04735420f, -0.01248994f, 0.01507928f, 0.03650034f, -0.04243164f, 0.03609604f, -0.04277885f, 0.02262639f, 
    -0.03278266f, -0.04276964f, 0.01589431f, 0.00677684f, -0.01234324f, 0.02029690f, 0.00622553f, -0.04121203f, 
    -0.04500386f, -0.00756317f, 0.01582859f, 0.03809616f, 0.00889424f, -0.05459648f, -0.04803515f, -0.01032054f, 
    -0.05247171f, -0.01849226f, -0.00692057f, -0.01675031f, 0.03752855f, -0.04912315f, -0.04900703f, -0.02215858f, 
    0.04200203f, -0.02058813f, -0.02155778f, -0.01797675f, -0.00026025f, -0.02667689f, -0.01410914f, -0.04539926f, 
    -0.04092545f, -0.00974682f, -0.04467194f, 0.02207508f, 0.00979433f, -0.04211448f, 0.03409945f, 0.00757107f, 
    0.01263794f, 0.02815617f, -0.00980826f, 0.00243926f, -0.00264389f, 0.02104103f, 0.04145669f, 0.03148063f, 
    0.00516258f, -0.02375095f, 0.03240563f, 0.00587602f, -0.03273736f, -0.05196457f, 0.02877560f, 0.04550953f, 
    -0.01349511f, -0.04354381f, 0.01950122f, -0.02505139f, 0.00579532f, -0.01961165f, -0.00814524f, -0.00449483f, 
    0.00851206f, -0.04076961f, -0.00002728f, 0.02365976f, -0.04884134f, -0.03553111f, 0.03094713f, -0.05274682f, 
    -0.02269077f, 0.02922055f, 0.01958180f, -0.05290594f, -0.04597519f, 0.04084581f, -0.01698227f, -0.02702921f, 
    0.02090377f, -0.00963752f, -0.04940200f, -0.01829875f, -0.00462336f, -0.02465835f, 0.03695303f, -0.02628734f, 
    -0.02198488f, -0.04244781f, -0.00729075f, 0.02980801f, 0.02061171f, 0.01815381f, -0.03408562f, 0.01179627f, 
    -0.05287970f, -0.04421311f, -0.00779579f, 0.00611322f, 0.02837872f, -0.01271446f, 0.04541292f, 0.03703763f, 
    0.02667050f, 0.01819956f, 0.01726731f, -0.01767439f, -0.00725710f, 0.04377256f, -0.02439679f, -0.04663432f, 
    0.02809145f, -0.03056965f, -0.03805692f, -0.04310418f, 0.00824203f, 0.02686811f, -0.03777015f, 0.01020905f, 
    0.25989386f, -0.16444655f, 0.17412694f, 0.23208335f, 0.05503494f, -0.03337851f, 0.07386611f, 0.13999522f, 
    0.09090361f, -0.14914280f, 0.06735674f, 0.13001938f, 0.04007208f, -0.02987566f, 0.05708620f, 0.01234284f, 
    0.02013976f, 0.03373083f, 0.01020195f, -0.03113066f, 0.10840464f, -0.02444691f, 0.03402185f, 0.05603406f, 
    0.06443457f, 0.16009577f, -0.20591478f, -0.18393943f, 0.07496728f, 0.09336292f, -0.01567839f, -0.02042873f, 
    0.02443834f, 0.00740238f, 0.08110588f, -0.02435349f, 0.20853375f, -0.10031448f, -0.14642096f, -0.08715189f, 
    -0.02693679f, 0.01591261f, 0.05334657f, -0.05883359f, 0.01302446f, 0.07843691f, 0.07768503f, 0.04126578f, 
    -0.10525415f, 0.15032715f, 0.05943385f, 0.07704239f, 0.02438991f, -0.10404822f, -0.01638131f, 0.05705335f, 
    -0.06527764f, -0.04727190f, 0.06243496f, 0.03465028f, -0.08929523f, 0.06106857f, -0.02997997f, 0.11592121f, 
    0.00683571f, 0.14358047f, -0.00872233f, 0.02370370f, 0.04251474f, 0.00340766f, 0.04147152f, -0.06415448f, 
    0.33690327f, -0.11944228f, 0.25029385f, 0.11001471f, -0.12492920f, -0.09363341f, -0.01906095f, 0.12388619f, 
    0.07458287f, 0.10113426f, -0.01835640f, -0.09849600f, 0.07906415f, 0.06125814f, 0.21108282f, -0.05310906f, 
    0.06018483f, 0.03748603f, 0.05238136f, 0.00588467f, 0.16460408f, -0.01853746f, -0.02163444f, 0.10117956f, 
    -0.01503306f, 0.06026452f, -0.10504158f, -0.06520585f, 0.04458459f, 0.04363643f, 0.08500430f, 0.00829511f, 
    0.05633885f, 0.24457751f, 0.05468707f, 0.05075380f, 0.15937205f, -0.09862667f, 0.07750760f, 0.11986879f, 
    0.04124994f, -0.04723987f, -0.03495159f, -0.00988376f, -0.02807399f, 0.01143138f, 0.02042087f, -0.06371106f, 
    0.08533527f, 0.02899454f, -0.14774740f, 0.02192568f, -0.03842697f, -0.02237151f, 0.04160058f, 0.10799006f, 
    0.06119795f, -0.06141198f, -0.05227824f, -0.00831474f, -0.32512078f, -0.10508808f, -0.27896771f, -0.04217545f, 
    -0.03850138f, -0.08407832f, 0.02299969f, -0.02340216f, 0.03128896f, -0.13125481f, -0.06032344f, -0.07338957f, 
    -0.25170225f, -0.04200312f, -0.29162791f, -0.17871000f, -0.04861804f, 0.04838361f, 0.11197265f, -0.05399838f, 
    -0.06383950f, -0.12858082f, 0.01676549f, -0.07759035f, 0.11594333f, 0.13916929f, 0.15771547f, 0.02656231f, 
    -0.04248722f, -0.03120770f, 0.01200938f, 0.03952103f, 0.07933971f, 0.16429685f, 0.02212891f, -0.01886158f, 
    0.08681687f, 0.25139970f, -0.11905462f, -0.03898199f, -0.05907420f, 0.12111890f, -0.02690217f, 0.05406497f, 
    0.02251790f, -0.02565728f, -0.01226767f, 0.05275317f, -0.16613479f, 0.09924829f, -0.06929429f, -0.05856572f, 
    0.02789591f, -0.04816479f, -0.17769045f, 0.07453505f, -0.03189541f, -0.07574399f, 0.01526325f, -0.14408602f, 
    0.02503775f, -0.06127955f, 0.15884613f, -0.07337771f, -0.01729239f, -0.07906681f, 0.06233277f, 0.12811838f, 
    0.06550443f, 0.05374510f, 0.09203124f, -0.08828378f, 0.18244629f, 0.09504172f, -0.03718842f, 0.22596893f, 
    0.13514708f, -0.01933578f, 0.07854619f, -0.01426274f, 0.04166812f, -0.04758149f, -0.02841539f, 0.02249918f, 
    -0.13567558f, 0.11345308f, 0.14448141f, -0.02801173f, -0.01345507f, -0.05666266f, -0.01692338f, -0.07116189f, 
    0.00346772f, 0.05616172f, -0.05058265f, 0.09887341f, -0.26317781f, 0.02905059f, 0.00837997f, -0.10370732f, 
    0.05506376f, -0.02108189f, -0.11878027f, 0.06107404f, 0.02860436f, -0.05357051f, 0.05048449f, 0.06841616f, 
    -0.02527921f, -0.23948047f, 0.42600200f, 0.25217596f, 0.04136095f, 0.13653064f, -0.01202033f, -0.11998153f, 
    -0.00997254f, -0.05853111f, 0.12409936f, 0.05996871f, -0.11918498f, -0.01324154f, -0.02561240f, 0.01524058f, 
    0.02152704f, -0.10465726f, -0.04057913f, 0.01907243f, 0.03475196f, 0.02698759f, 0.20622790f, 0.19874294f, 
    0.32984784f, -0.04871659f, -0.04867492f, 0.15710045f, -0.02945146f, 0.10297670f, 0.07109217f, 0.15581909f, 
    0.02352481f, -0.00557850f, -0.01589994f, 0.02291313f, -0.32719576f, 0.12303095f, 0.05565659f, -0.15345478f, 
    0.04597228f, -0.02856296f, -0.00675351f, -0.02937826f, 0.01670995f, -0.04574353f, -0.07847065f, -0.00272368f, 
    -0.08889595f, -0.04935634f, 0.00591336f, 0.16331784f, 0.01542696f, -0.09695875f, 0.06247319f, -0.07208053f, 
    0.12697509f, -0.04016572f, 0.08702340f, 0.03272704f, -0.48218292f, 0.29632941f, -0.03107579f, -0.07496884f, 
    -0.02123559f, 0.03853586f, 0.03052918f, 0.09453945f, 0.13647127f, -0.05213519f, 0.00132197f, -0.07352152f, 
    -0.41666692f, 0.12079141f, 0.00235293f, -0.05671349f, 0.01457695f, 0.13248496f, -0.11663137f, 0.05223547f, 
    0.04326535f, 0.00073522f, -0.03260598f, -0.02494578f, 0.05385335f, -0.12335160f, -0.03199220f, 0.04694603f, 
    0.03897635f, -0.07015573f, -0.00794078f, -0.06878948f, 0.06460850f, -0.00041128f, -0.01022829f, 0.15113455f, 
    -0.34908715f, 0.19144268f, -0.00057013f, -0.01269276f, 0.08309732f, -0.00061305f, -0.07557453f, -0.00929230f, 
    0.00433950f, -0.00683984f, 0.01368882f, 0.09523449f, -0.25174657f, 0.11870457f, -0.00043486f, 0.00819265f, 
    -0.01026642f, 0.01700079f, 0.01196086f, -0.16781627f, -0.10673761f, 0.04061230f, 0.00980845f, -0.11142737f, 
    0.06843521f, -0.17458224f, -0.01186916f, 0.17627721f, 0.04400395f, 0.04211875f, -0.02797998f, -0.04335724f, 
    0.07264441f, 0.04734548f, 0.03055665f, 0.20214923f, -0.02300234f, 0.23656648f, -0.12356381f, 0.14251703f, 
    -0.06511135f, -0.08611673f, 0.05330429f, 0.04640545f, 0.02277386f, 0.01549344f, 0.02537643f, 0.07805139f, 
    0.00021510f, 0.00377850f, -0.04359838f, 0.02157532f, 0.00448954f, -0.01278825f, 0.02015159f, 0.04597765f, 
    0.01212356f, 0.01001616f, -0.01758443f, -0.00579626f, -0.01486611f, 0.00834841f, -0.05070997f, 0.02666858f, 
    -0.01294106f, -0.05673391f, 0.01260608f, -0.00717788f, -0.02799344f, -0.04693545f, -0.03760091f, 0.04052019f, 
    -0.04134289f, 0.01111842f, -0.00745803f, -0.00009879f, -0.03610280f, 0.02898176f, -0.05241665f, -0.00589009f, 
    0.02218958f, 0.01677240f, -0.00980149f, 0.00002364f, 0.02221147f, -0.01280313f, 0.02402784f, 0.05012982f, 
    -0.01598246f, -0.02412287f, -0.02208517f, -0.00133517f, 0.04079759f, -0.01572400f, 0.01019473f, 0.01794987f, 
    -0.01975929f, 0.03311574f, 0.00750923f, 0.04439366f, 0.02906421f, -0.04960512f, 0.01519325f, -0.03731332f, 
    0.03438326f, -0.04877640f, -0.02027254f, 0.02182933f, -0.01926148f, -0.00031262f, -0.02404428f, 0.03319152f, 
    0.03728415f, 0.00158027f, 0.00513088f, -0.00383936f, -0.01437513f, 0.01013155f, -0.01152149f, -0.01968418f, 
    -0.04236050f, -0.03220974f, 0.03098563f, -0.02124029f, 0.01840205f, -0.02879260f, 0.04452972f, 0.02976719f, 
    -0.01083275f, -0.02315478f, 0.00534346f, -0.01124094f, -0.05437284f, 0.01008936f, 0.02944864f, -0.00158804f, 
    0.02939269f, -0.02255853f, -0.03292231f, -0.05613199f, 0.00140003f, -0.02550117f, 0.02053813f, 0.00763652f, 
    -0.02187032f, -0.04913839f, 0.00504212f, 0.02251005f, -0.00366529f, 0.01981454f, -0.02185115f, -0.04556042f, 
    0.01230788f, -0.03283200f, -0.04042996f, 0.04016988f, -0.01515930f, -0.01286690f, -0.03903658f, 0.01597857f, 
    -0.01856754f, 0.03171986f, -0.00959250f, -0.02905741f, -0.00413783f, -0.01336482f, -0.03779817f, -0.05318413f, 
    -0.02276911f, -0.01063491f, -0.05523215f, -0.03977696f, 0.03026691f, 0.03918521f, -0.05184655f, -0.02004828f, 
    -0.02593853f, 0.03958536f, -0.01680798f, -0.00891405f, 0.03605267f, 0.01172501f, -0.02061777f, 0.01804822f, 
    -0.04461561f, -0.04993048f, -0.04697985f, 0.01156779f, -0.04395559f, -0.04387122f, 0.03207880f, -0.00432783f, 
    0.01638495f, 0.04736910f, -0.01002736f, 0.03848108f, 0.02025255f, -0.03597423f, 0.03289855f, -0.02745759f, 
    -0.04740128f, 0.04801961f, 0.02711566f, 0.00195438f, -0.04303643f, 0.02767665f, -0.03732263f, 0.03733787f, 
    0.03419439f, -0.00404142f, 0.00952653f, -0.01069502f, 0.01039188f, -0.01675240f, -0.03666998f, -0.03642954f, 
    0.01717979f, 0.01740337f, 0.03687508f, 0.00322923f, 0.01723402f, -0.02402525f, -0.00175405f, -0.05336407f, 
    0.02517614f, -0.00462656f, -0.05406946f, 0.01349715f, -0.01630570f, 0.00512479f, -0.03251992f, 0.02865704f, 
    -0.01528039f, -0.03697700f, -0.03266393f, -0.03616751f, -0.05134391f, 0.03878750f, 0.01356860f, 0.02454687f, 
    -0.04894498f, 0.01247801f, 0.02253973f, -0.04462233f, -0.02795780f, -0.04355520f, -0.04796448f, 0.03437048f, 
    0.04322251f, 0.02774204f, -0.04750207f, -0.00726694f, 0.01889078f, -0.01343026f, -0.00389476f, -0.02062934f, 
    0.00266886f, -0.04515252f, 0.00499826f, -0.03270253f, 0.03923963f, -0.00548011f, -0.00232227f, 0.04102798f, 
    0.03397348f, -0.03797388f, 0.00525809f, 0.03421800f, -0.01508415f, -0.02356871f, -0.02167322f, 0.01692051f, 
    0.02850498f, -0.05272478f, 0.02651147f, 0.04978218f, 0.03047433f, 0.00068903f, 0.00302816f, -0.02480401f, 
    -0.00297444f, -0.01283463f, 0.01254672f, -0.01721643f, 0.00932550f, 0.00438328f, -0.03200237f, 0.02104428f, 
    -0.01001239f, -0.02260142f, -0.00794392f, -0.02357309f, 0.03321987f, -0.05109345f, 0.03986212f, -0.00489954f, 
    0.01742351f, -0.00590528f, -0.03393030f, 0.00340131f, -0.02388045f, -0.03732337f, -0.01722802f, -0.02601854f, 
    0.00263412f, -0.03079078f, -0.05276902f, -0.00889449f, 0.02816433f, -0.01535312f, -0.01521919f, -0.05313642f, 
    0.03558205f, -0.01555348f, -0.05271055f, 0.00767360f, -0.05535739f, 0.04429263f, 0.01767539f, -0.01839742f, 
    -0.03325165f, 0.03934702f, 0.01072364f, 0.04067051f, -0.01276894f, 0.02402645f, 0.00341040f, 0.03674519f, 
    -0.01829155f, 0.04098659f, -0.00060286f, 0.00322303f, 0.02252969f, 0.01282566f, 0.01911590f, -0.02845028f, 
    0.02254672f, 0.02718540f, 0.03360936f, -0.00359405f, -0.03809614f, 0.02953737f, -0.04907991f, -0.04920809f, 
    -0.01913727f, 0.03584839f, -0.00906470f, 0.01732918f, -0.04615002f, -0.00030787f, -0.03769050f, -0.00251744f, 
    -0.01512428f, -0.02165153f, -0.04652765f, -0.01410122f, 0.00829146f, 0.01240386f, 0.01495942f, -0.02997217f, 
    -0.00656222f, -0.00425800f, -0.05188368f, -0.02047141f, -0.03445450f, -0.00884041f, -0.05405338f, 0.02723443f, 
    -0.05118053f, -0.05033002f, 0.03309489f, -0.03014132f, -0.00168196f, 0.01541970f, -0.04200314f, 0.00691071f, 
    0.03490683f, -0.03355921f, -0.01711281f, -0.03948103f, -0.00171815f, -0.03371225f, 0.03031147f, -0.05071279f, 
    -0.01759920f, 0.01834821f, -0.01734358f, 0.03019979f, -0.05649360f, 0.02201629f, -0.01954114f, -0.00364586f, 
    -0.00201476f, -0.05599508f, -0.00866786f, -0.01080605f, -0.02019974f, 0.01494494f, -0.00439717f, 0.01645762f, 
    0.02874557f, -0.04233647f, -0.01083287f, -0.01206146f, -0.00704980f, 0.02901215f, -0.00646429f, -0.02908133f, 
    0.01258882f, -0.04721570f, -0.01223370f, 0.02088642f, 0.01027750f, 0.03407051f, -0.01277991f, 0.00615647f, 
    -0.04711589f, 0.00058974f, 0.00419849f, 0.00835373f, 0.00642499f, 0.01432826f, 0.00146709f, 0.01370432f, 
    -0.00610819f, -0.05075254f, -0.00073685f, 0.00110208f, -0.04631030f, -0.01707000f, -0.03565908f, 0.04229302f, 
    0.02625306f, -0.04528615f, -0.01113523f, -0.01643766f, 0.00973996f, -0.03170745f, 0.03083404f, 0.04419541f, 
    0.01376606f, 0.04313802f, -0.04926231f, 0.02925814f, -0.04655573f, 0.02352078f, -0.01905886f, -0.01606397f, 
    -0.02752606f, -0.03508935f, -0.05419572f, -0.04302336f, -0.02088100f, 0.03693583f, 0.00705323f, -0.02546755f, 
    -0.03885457f, 0.03682033f, 0.01586084f, 0.01925571f, -0.02651865f, -0.02807214f, -0.05477041f, -0.00600776f, 
    0.01946559f, -0.02383414f, -0.01846257f, 0.00837874f, -0.03497773f, -0.01941524f, 0.04269955f, -0.01256239f, 
    -0.04687785f, 0.02517359f, -0.04641693f, 0.04302663f, 0.04749906f, 0.00574578f, 0.00697833f, -0.02039350f, 
    0.03042346f, 0.03574055f, -0.04156359f, -0.02749091f, 0.00428655f, 0.02857515f, -0.03129343f, -0.05354541f, 
    -0.03278190f, 0.00161324f, 0.01235600f, 0.01544407f, -0.01220603f, -0.03742567f, 0.00658988f, 0.01463414f, 
    -0.01145886f, 0.02050361f, 0.03291146f, -0.00750160f, -0.03334625f, 0.02218361f, -0.03134767f, -0.05000215f, 
    -0.01865867f, 0.04139432f, -0.00581965f, -0.01659023f, 0.02230111f, -0.01744589f, -0.00678600f, 0.05030790f, 
    -0.03327386f, -0.04864281f, -0.04316693f, -0.00711550f, -0.01791750f, 0.00875905f, 0.02636418f, -0.01060985f, 
    -0.02223819f, -0.00921343f, 0.03083060f, 0.05054789f, 0.02507023f, -0.05239459f, -0.01395331f, 0.02179885f, 
    0.01628875f, 0.03068173f, 0.04389267f, 0.03765323f, -0.01930298f, -0.00029814f, -0.03279191f, 0.01765897f, 
    -0.03237247f, -0.02939442f, 0.04636837f, -0.03639420f, -0.03713869f, 0.02400539f, -0.02294124f, -0.05866246f, 
    -0.00700664f, 0.02516515f, 0.00678537f, 0.03685131f, -0.00101466f, -0.04427245f, -0.01519076f, -0.01621938f, 
    -0.04693671f, -0.04094212f, -0.03051218f, 0.04162287f, -0.03808243f, 0.00754701f, -0.01283530f, -0.03822790f, 
    0.00904269f, 0.00225385f, 0.01533567f, -0.02722861f, 0.00181030f, -0.01579832f, -0.02452532f, -0.01341136f, 
    0.03261509f, 0.01150228f, 0.02412766f, 0.03406259f, 0.02393157f, -0.02300177f, 0.02325355f, -0.01988311f, 
    0.00780431f, -0.01444660f, -0.02986237f, 0.04032618f, 0.04083404f, -0.03076445f, -0.04184347f, -0.00581058f, 
    -0.00809916f, -0.01953107f, -0.04903730f, -0.04708308f, -0.03381449f, 0.01121667f, -0.01382696f, 0.03186548f, 
    0.01664617f, -0.03767495f, -0.02891097f, -0.04769894f, -0.01715163f, -0.01385032f, 0.02855663f, 0.04052782f, 
    0.03456448f, 0.03838926f, 0.03932545f, 0.03709134f, 0.00992932f, -0.03456632f, 0.03281487f, -0.01805660f, 
    -0.02316658f, -0.00678815f, 0.04093593f, 0.04010828f, 0.01945440f, -0.02569133f, 0.02617903f, -0.01182466f, 
    -0.02484845f, 0.04384647f, 0.02599006f, 0.02455856f, 0.04081263f, 0.03270507f, -0.00259020f, -0.01893631f, 
    -0.01481844f, 0.01568265f, -0.00216143f, -0.05071893f, 0.00897355f, -0.00408336f, 0.02456599f, -0.02084674f, 
    -0.04112906f, -0.02906437f, -0.00336327f, -0.03510612f, -0.04076543f, -0.02558944f, 0.01865330f, 0.04636336f, 
    -0.02918329f, -0.01213547f, 0.02111117f, 0.03055383f, -0.00305638f, -0.00659365f, -0.01551043f, -0.02641578f, 
    0.00594654f, -0.03846385f, -0.05167945f, -0.02447033f, 0.02463118f, -0.02688550f, -0.04241918f, 0.03512560f, 
    -0.02624618f, -0.03115814f, 0.03591330f, -0.03770242f, 0.02062516f, -0.05517003f, -0.01185427f, -0.02956230f, 
    -0.01214957f, -0.04884472f, 0.00372819f, -0.00528727f, 0.04945600f, 0.00887514f, -0.03749578f, 0.03526857f, 
    0.02619182f, -0.00241657f, -0.03012755f, 0.02576377f, -0.04055601f, -0.03924632f, 0.03165320f, -0.02201664f, 
    0.03071280f, 0.03147074f, 0.02748266f, -0.01424198f, 0.01918490f, 0.01179902f, -0.00089709f, -0.02829854f, 
    -0.03124888f, 0.02681451f, 0.00414595f, 0.00279101f, -0.05170364f, 0.01561938f, 0.02692318f, 0.02216162f, 
    -0.02355540f, -0.04478744f, 0.01979345f, 0.03617364f, -0.00341226f, -0.04396173f, -0.03291974f, -0.02533970f, 
    -0.03715179f, 0.01988430f, -0.02731631f, 0.04400067f, -0.02520363f, -0.05740372f, -0.02379114f, -0.01274653f, 
    0.02840265f, -0.03384049f, -0.03091389f, -0.04416791f, -0.00545884f, -0.01037135f, -0.01196318f, 0.02265193f, 
    0.00853474f, -0.04094428f, 0.00227057f, -0.04630800f, 0.02638364f, 0.03490169f, -0.02289812f, 0.03427326f, 
    0.00443631f, -0.04297787f, 0.03927489f, 0.04684378f, 0.03131852f, 0.02478551f, -0.01838589f, -0.01666027f, 
    0.02941963f, -0.00813525f, -0.00982644f, -0.04293698f, 0.02864267f, 0.01160797f, 0.03605006f, 0.00845559f, 
    -0.03522912f, -0.04521905f, -0.04754279f, -0.05502692f, -0.04755061f, 0.02698807f, 0.00343201f, 0.04119376f, 
    -0.00344681f, -0.05244983f, 0.02161481f, -0.04061287f, 0.04788899f, -0.04687640f, 0.04010514f, 0.00073998f, 
    -0.02587953f, 0.01382608f, -0.03385733f, -0.04773253f, -0.03966004f, -0.01331259f, 0.02211794f, 0.03806081f, 
    -0.00178743f, 0.01339286f, -0.03683239f, 0.04403983f, 0.02399312f, -0.03452563f, -0.00736055f, 0.01647730f, 
    -0.02090670f, -0.01014878f, 0.01022364f, -0.04848212f, 0.04186131f, -0.01521184f, -0.02972958f, 0.02568301f, 
    -0.03216944f, -0.03678607f, 0.05437573f, 0.02082577f, -0.01279141f, 0.03015468f, -0.04239995f, -0.05103339f, 
    0.00690424f, 0.01699411f, 0.00957997f, 0.01438139f, -0.03674363f, 0.03459077f, 0.00538184f, -0.02795189f, 
    0.01180216f, -0.04317576f, -0.00063059f, -0.02438742f, 0.01258376f, 0.03487472f, -0.00844397f, 0.01185714f, 
    -0.00081016f, -0.04192208f, -0.01846620f, -0.04055513f, -0.04084579f, -0.02786000f, -0.05017206f, -0.01187476f, 
    -0.44704780f, -0.00952543f, 0.15888225f, 0.14808857f, 0.01354189f, -0.02293658f, 0.12737530f, 0.20014723f, 
    -0.14854862f, 0.09500916f, -0.06183534f, 0.09533695f, -0.00312375f, -0.11701680f, 0.11033218f, 0.08872665f, 
    -0.01145902f, -0.02018535f, -0.01930986f, -0.07699238f, 0.04378004f, 0.07303309f, -0.00046831f, -0.06124654f, 
    -0.23473126f, 0.14880340f, 0.18052669f, -0.02970047f, 0.04888554f, 0.10416052f, -0.00747745f, -0.11401699f, 
    0.09319797f, -0.05939569f, -0.07385426f, -0.06167176f, -0.20970306f, -0.15035830f, -0.20503981f, -0.04393792f, 
    0.03601155f, 0.07340130f, -0.01676753f, 0.09248998f, 0.04795465f, 0.04001882f, -0.01192770f, -0.01999952f, 
    0.26054546f, 0.02768031f, -0.06419848f, 0.11956278f, -0.00801282f, -0.02622199f, 0.09525511f, 0.07117406f, 
    0.06720261f, -0.12322203f, 0.01032922f, -0.01480963f, 0.15215781f, -0.11624697f, 0.09937615f, 0.22851357f, 
    -0.05988076f, 0.02620490f, -0.06931894f, 0.01778295f, 0.04493173f, 0.04142228f, 0.00960103f, -0.11029893f, 
    0.45096490f, -0.03783797f, 0.12558728f, 0.15426444f, 0.00758106f, -0.06264629f, -0.15222070f, -0.01347876f, 
    0.06398209f, 0.19666748f, 0.06495044f, -0.08324768f, -0.27275163f, -0.02510827f, 0.22401351f, -0.13278864f, 
    0.17812520f, -0.00862402f, 0.06531838f, -0.11879219f, 0.07755575f, -0.09992260f, 0.02843025f, 0.13071848f, 
    -0.12603979f, 0.22384521f, -0.02078096f, 0.08282617f, -0.08220828f, -0.13188271f, 0.14273532f, 0.06208412f, 
    0.08964746f, 0.13693963f, -0.16572970f, 0.01190663f, 0.03123094f, -0.11121919f, -0.12501088f, 0.02266018f, 
    0.00245962f, 0.07690705f, -0.05233216f, -0.02169223f, -0.08698836f, 0.07016684f, 0.00173929f, 0.09010173f, 
    0.00173430f, 0.16850550f, -0.15199980f, 0.00173165f, -0.12829155f, 0.05681644f, -0.02354947f, 0.06139814f, 
    0.04646425f, -0.01287967f, 0.01359031f, 0.02030065f, 0.17722979f, 0.14316858f, 0.16138685f, -0.00586438f, 
    0.15803820f, 0.02894204f, 0.01581838f, 0.07652336f, 0.06189172f, -0.09682079f, 0.01799141f, -0.08448005f, 
    0.03882856f, 0.26761535f, 0.07684246f, 0.05070490f, 0.03677703f, -0.01233114f, 0.13947348f, -0.02939686f, 
    0.00125066f, 0.01380626f, 0.03201054f, -0.21605751f, 0.01595038f, -0.04020222f, 0.00018511f, 0.14367343f, 
    0.07605805f, 0.03585636f, 0.11683122f, 0.04005095f, 0.10989048f, 0.15162644f, 0.08908758f, -0.09609720f, 
    0.11159142f, 0.22550090f, 0.00608451f, 0.12405933f, 0.03062472f, 0.00977395f, -0.01425265f, -0.12899065f, 
    -0.12273844f, -0.01556117f, -0.07967013f, 0.01911920f, 0.08076233f, 0.18514366f, -0.07144973f, -0.29686993f, 
    -0.01312219f, -0.03945863f, -0.05455856f, 0.05071950f, -0.05648353f, 0.04763217f, 0.04200149f, -0.11562481f, 
    0.09704914f, 0.22159271f, -0.02199797f, -0.30590272f, -0.00248137f, 0.06799049f, 0.02150547f, 0.06491245f, 
    0.14050415f, 0.01888343f, -0.08833559f, 0.03557856f, -0.12342798f, 0.13572657f, -0.06663020f, 0.07322393f, 
    0.05568340f, 0.11662389f, -0.08745532f, -0.07520417f, 0.11039732f, 0.03589947f, 0.11694607f, -0.00501900f, 
    0.02930458f, -0.01661513f, 0.14010012f, -0.15844686f, -0.04586756f, -0.18732633f, -0.01795398f, -0.05270190f, 
    -0.02670579f, 0.09760400f, 0.00853017f, 0.05520353f, -0.04247502f, -0.02253527f, 0.01920450f, 0.05311658f, 
    0.05333711f, -0.03717468f, -0.06339888f, 0.12415926f, 0.02848421f, -0.02267554f, -0.00039946f, -0.02122077f, 
    -0.05862875f, -0.21515793f, 0.23387881f, 0.18340656f, 0.08040596f, 0.24648999f, 0.06011627f, -0.10703082f, 
    -0.10446851f, -0.09453005f, 0.02605514f, 0.01625322f, -0.11340167f, -0.06699523f, 0.16147144f, -0.06216343f, 
    0.03591447f, -0.10307945f, -0.17293589f, 0.03746792f, 0.01838298f, -0.06605425f, 0.06133326f, 0.01614498f, 
    0.13819098f, 0.22423472f, -0.01562645f, 0.22252667f, 0.04206324f, 0.07432870f, 0.22357360f, -0.02713506f, 
    -0.11969931f, -0.00831276f, -0.04792020f, -0.08559556f, 0.22918549f, -0.06190719f, 0.15673757f, -0.20231651f, 
    0.11270329f, -0.03951988f, 0.03175803f, -0.01761307f, 0.06229524f, 0.00496559f, -0.21303914f, 0.08475412f, 
    -0.23929326f, -0.18926162f, -0.01114050f, 0.11583603f, 0.05885949f, 0.00735337f, -0.06514215f, 0.01049589f, 
    -0.06192914f, -0.02471378f, 0.08151571f, 0.02866175f, -0.13025990f, 0.48366091f, 0.30324438f, -0.02821751f, 
    0.06452788f, -0.08781581f, -0.00597650f, 0.10387947f, 0.03721398f, -0.07056662f, -0.01290503f, -0.09627997f, 
    -0.13808350f, 0.07808521f, -0.03537698f, -0.13265355f, 0.07420927f, -0.08667306f, -0.08321576f, -0.04386397f, 
    0.03915063f, -0.01049351f, -0.03600786f, 0.05706667f, -0.28598824f, -0.12993270f, -0.30107093f, 0.02722530f, 
    0.15100010f, 0.10133442f, -0.01340945f, -0.05035212f, 0.07123919f, 0.02278226f, 0.08525989f, 0.03474837f, 
    0.19327995f, -0.10418323f, 0.10501681f, -0.05241835f, -0.09785618f, 0.08918270f, 0.06145488f, 0.00303161f, 
    -0.07655527f, 0.07295137f, 0.05682969f, -0.03310568f, -0.10040444f, 0.08205779f, 0.06149095f, -0.06217312f, 
    -0.01027379f, -0.04589798f, 0.06716228f, -0.08950001f, -0.02295923f, -0.10701282f, -0.08575621f, -0.05305498f, 
    -0.26400688f, 0.03551413f, -0.15231489f, 0.04231016f, 0.12719899f, 0.15110384f, -0.02916865f, 0.02749486f, 
    -0.06345662f, -0.01309170f, 0.05364838f, 0.12886854f, -0.16611499f, 0.08328532f, -0.17100522f, -0.04395217f, 
    0.03209827f, 0.11564680f, 0.03622219f, -0.05776338f, -0.07252415f, -0.09470318f, -0.05139462f, -0.09028552f, 
    0.08998369f, -0.17632826f, 0.01445962f, -0.08453327f, 0.19976313f, -0.07152352f, 0.05401311f, -0.06597093f, 
    0.09198475f, -0.08445857f, -0.00794249f, -0.02814141f, -0.17334527f, 0.00994842f, -0.14057900f, -0.00654605f, 
    -0.05003305f, -0.24478987f, -0.04023930f, 0.06991179f, 0.03317909f, 0.04350848f, 0.00011923f, 0.07023530f, 
    0.39114478f, -0.42332655f, -0.00376790f, -0.05483032f, -0.01859293f, 0.06822895f, -0.01863510f, 0.09204134f, 
    -0.04605391f, 0.11735199f, -0.03519884f, 0.11285121f, -0.12462395f, 0.15515357f, 0.15603496f, 0.10067397f, 
    -0.08703075f, 0.10528203f, 0.00065533f, 0.03065126f, 0.03041996f, 0.01593132f, 0.14038767f, -0.07088549f, 
    -0.01684809f, -0.12755308f, 0.03239178f, -0.14536861f, 0.00923059f, 0.09865305f, -0.06973052f, 0.17077942f, 
    0.07224711f, 0.11758393f, -0.13246725f, -0.05948946f, 0.15024096f, 0.09876227f, -0.08440799f, -0.10444029f, 
    0.16587722f, -0.12117749f, 0.04853258f, 0.01273922f, -0.01983533f, 0.00855590f, 0.03968657f, 0.14836791f, 
    -0.24978308f, 0.06681355f, 0.02716908f, -0.18866938f, 0.04492486f, -0.00109923f, 0.07107522f, -0.02533187f, 
    0.12360080f, -0.04844651f, -0.00245079f, 0.05326680f, 0.23063950f, -0.05496374f, 0.15613274f, 0.08988430f, 
    0.08306976f, -0.06294671f, 0.05718257f, 0.09248716f, -0.01322912f, 0.00085243f, -0.04937857f, 0.06385246f, 
    0.11358089f, -0.03658605f, -0.14966181f, 0.02577338f, 0.06938040f, -0.01203855f, 0.07148716f, -0.04297254f, 
    -0.02483438f, -0.03058261f, 0.11991929f, 0.05001939f, 0.04399864f, 0.14185703f, 0.07160842f, -0.19296408f, 
    -0.00896319f, 0.18564658f, 0.06207640f, 0.11581769f, 0.00834618f, 0.01405264f, 0.09955501f, 0.12950675f, 
    -0.17714185f, -0.01605019f, 0.03727824f, -0.05190395f, 0.08011186f, 0.01443851f, 0.11402017f, 0.07828759f, 
    0.03239831f, 0.12842897f, -0.06394503f, -0.00349886f, 0.04973724f, -0.08852547f, 0.00974645f, 0.03112636f, 
    -0.11893324f, -0.06256181f, -0.00008253f, 0.07503626f, -0.05564949f, -0.00039050f, 0.01371172f, -0.09406152f, 
    0.02865499f, -0.26234221f, -0.03088106f, 0.18135527f, -0.08736606f, -0.09488760f, -0.09241116f, -0.07050212f, 
    -0.03494384f, 0.02276001f, -0.05162376f, 0.17939357f, -0.09485215f, -0.06487340f, -0.08903456f, -0.24653094f, 
    -0.08269154f, -0.00304445f, -0.03868209f, 0.00510961f, -0.07326297f, 0.02048246f, 0.07824544f, 0.11265223f, 
    0.04128388f, 0.03291673f, -0.05436567f, 0.05052651f, -0.08319924f, -0.04592349f, 0.01506914f, 0.03103737f, 
    0.14991020f, 0.08469869f, 0.04677925f, 0.05473584f, -0.00056209f, -0.17289805f, 0.12733582f, -0.03305921f, 
    -0.02476411f, 0.14857116f, 0.07804433f, 0.19723456f, 0.03385979f, 0.19809642f, 0.13803922f, -0.00538585f, 
    0.41689157f, -0.14815001f, 0.06641024f, 0.10594878f, 0.15285300f, -0.02847627f, 0.09922183f, 0.11776901f, 
    0.04845056f, -0.03699002f, 0.09517200f, 0.10159829f, 0.05766569f, 0.13708717f, -0.02228913f, 0.06342584f, 
    0.07969274f, 0.11512730f, 0.02942599f, 0.02116949f, 0.05777484f, -0.01807868f, 0.09901671f, 0.01908514f, 
    0.09351239f, 0.02055108f, -0.05044065f, 0.12909947f, 0.03876168f, 0.18750611f, -0.02343115f, 0.03294355f, 
    -0.00850212f, 0.00789546f, -0.02965080f, -0.15990610f, 0.23792450f, -0.13591617f, 0.13235614f, -0.25435975f, 
    -0.09067889f, 0.15226980f, -0.09630238f, -0.01953115f, -0.02608765f, 0.01137362f, -0.06309048f, 0.04650484f, 
    0.34169167f, 0.12730053f, 0.27635029f, 0.11839589f, 0.07685991f, 0.01925159f, -0.04233198f, -0.03667175f, 
    0.06349708f, 0.14223555f, -0.04768838f, 0.04322921f, 0.03449592f, 0.10423432f, 0.00213619f, 0.00325246f, 
    0.04256983f, 0.07210376f, 0.01258074f, -0.01166651f, -0.03981218f, 0.05016848f, -0.09548350f, 0.02985497f, 
    0.03035058f, -0.23143183f, 0.04340899f, -0.15692763f, 0.23133236f, 0.15301791f, 0.00616434f, -0.03887713f, 
    0.14992672f, 0.09890525f, 0.03271929f, 0.05067213f, -0.14002094f, 0.12666966f, -0.01953606f, 0.08477455f, 
    0.01756802f, 0.05783364f, 0.06359503f, 0.03993796f, 0.00295112f, -0.11720565f, 0.10395166f, 0.06260994f, 
    -0.10526618f, 0.17842355f, 0.20373954f, -0.15315267f, 0.07896074f, 0.02439987f, 0.02030699f, 0.04778051f, 
    0.08569474f, 0.03184942f, -0.05633251f, -0.01674326f, -0.06236028f, -0.21752894f, -0.18538256f, 0.03887795f, 
    0.05845227f, 0.03790992f, -0.00648703f, -0.02552450f, -0.10908404f, 0.05349218f, 0.06819724f, 0.01971148f, 
    -0.07185339f, 0.19346282f, 0.04857659f, -0.01629691f, -0.03303561f, 0.11003437f, 0.07482533f, 0.11455473f, 
    -0.06578328f, -0.01031585f, -0.09662762f, -0.03477909f, 0.22867595f, 0.23154324f, 0.17008185f, 0.06515575f, 
    0.02258897f, 0.01825722f, 0.14639507f, 0.13237669f, 0.11771352f, 0.15372734f, 0.07210982f, 0.07376812f, 
    0.13165960f, -0.00123012f, -0.07303762f, -0.02949369f, 0.02188223f, 0.02591820f, 0.05363459f, 0.10353163f, 
    -0.00431236f, -0.02080589f, 0.00434959f, -0.02901013f, -0.15119421f, -0.11523303f, 0.04725448f, -0.10983853f, 
    0.05875978f, 0.03038985f, -0.02126226f, 0.14834438f, 0.05305713f, 0.03350865f, 0.09301839f, 0.08272485f, 
    0.23315519f, 0.09918753f, 0.04960278f, 0.15996952f, 0.02652945f, 0.04331795f, 0.09267796f, 0.03075563f, 
    -0.00621938f, -0.01806943f, 0.07832247f, -0.12217873f, 0.02433479f, 0.28396514f, -0.01914922f, 0.14742722f, 
    -0.11316682f, -0.06018503f, 0.20717527f, -0.04424616f, 0.20310327f, -0.07077836f, 0.03038615f, -0.06498698f, 
    -0.14470398f, 0.01399869f, -0.00492151f, 0.10359103f, 0.18091409f, 0.11388899f, 0.01822912f, 0.02355959f, 
    0.04204524f, -0.05241584f, 0.01462903f, 0.17557850f, 0.02272625f, -0.12424377f, 0.00394114f, 0.07157522f, 
    -0.10848220f, -0.12672906f, -0.04580507f, -0.08179975f, -0.06046206f, -0.04220757f, 0.03142045f, 0.01493243f, 
    -0.22069509f, 0.02284612f, -0.18510842f, 0.01328138f, -0.06466460f, -0.12204495f, 0.11480249f, -0.05893123f, 
    0.08802857f, -0.06673159f, 0.01943440f, -0.03688511f, -0.15512997f, -0.19313379f, 0.15792845f, -0.03231786f, 
    0.10146981f, 0.31675425f, -0.07222301f, -0.02773742f, 0.12018344f, 0.10762203f, -0.05410028f, 0.00544443f, 
    0.19755760f, 0.01168138f, 0.25787246f, -0.15659051f, 0.14298986f, 0.06609785f, 0.08949951f, 0.08223614f, 
    0.02986922f, 0.00739311f, -0.08222670f, 0.05015396f, -0.14705560f, 0.29493609f, -0.16989449f, 0.18472907f, 
    0.09294809f, 0.02823244f, -0.07210311f, -0.05261251f, 0.08558140f, 0.12347207f, 0.00438079f, 0.00375953f, 
    0.23666373f, -0.08081329f, 0.28299430f, 0.10118368f, 0.03988357f, -0.00557815f, -0.12589321f, -0.00393854f, 
    0.14186853f, 0.05678637f, 0.00129362f, 0.11747783f, -0.06886590f, -0.04889921f, -0.11348338f, 0.01075256f, 
    0.01630699f, 0.02856705f, 0.07705977f, 0.04028509f, -0.02913602f, -0.04491537f, 0.10653789f, -0.07253543f, 
    0.11270116f, 0.15305872f, -0.03814290f, 0.05294169f, 0.16115844f, 0.01184453f, 0.02538898f, 0.01775157f, 
    -0.00467747f, -0.04100947f, 0.04458234f, 0.06292261f, -0.14849603f, -0.01671319f, 0.03731241f, -0.09177576f, 
    0.07957745f, -0.00834703f, 0.13740329f, 0.08305988f, 0.01236590f, 0.12278339f, 0.04665035f, 0.23808487f, 
    -0.00413917f, -0.15664200f, 0.18838671f, 0.00106822f, 0.02548845f, 0.00185143f, 0.14798237f, -0.00692563f, 
    0.10383315f, 0.02890487f, -0.01554955f, -0.00482338f, -0.32308203f, -0.13010244f, 0.07930038f, 0.08457604f, 
    0.07414129f, 0.01140219f, -0.02978108f, 0.03404541f, -0.12727214f, -0.06883480f, 0.04020870f, -0.03370002f, 
    -0.41431653f, -0.13942476f, 0.00410431f, 0.18276238f, -0.16505988f, -0.19216739f, 0.13368170f, -0.03514600f, 
    -0.02932879f, -0.04367277f, 0.06714546f, -0.01876640f, 0.04803105f, 0.02486035f, -0.14864014f, -0.09966590f, 
    -0.03757992f, 0.08510340f, 0.15030301f, 0.13706638f, -0.02328033f, -0.05301981f, 0.15515065f, 0.10972822f, 
    0.13574530f, 0.20441318f, 0.10657618f, 0.13555953f, -0.03418333f, 0.01067518f, -0.00150183f, -0.00723529f, 
    -0.08095559f, 0.09759754f, 0.02714359f, 0.16930652f, -0.16260178f, 0.09997325f, 0.07800158f, -0.24349168f, 
    0.05556439f, -0.08461116f, -0.08429911f, 0.11157078f, -0.01488756f, 0.02185706f, 0.07385098f, 0.06812322f, 
    0.14418861f, -0.01063961f, 0.01762171f, -0.20308626f, 0.13748860f, 0.02754901f, -0.01623624f, -0.06703456f, 
    0.07515827f, -0.07133411f, 0.09385742f, -0.09824423f, -0.09038302f, -0.06387326f, -0.03861624f, 0.15546224f, 
    0.08242166f, 0.21615431f, -0.02572025f, -0.11226279f, 0.09015463f, 0.04696719f, -0.03830092f, 0.08741561f, 
    0.03032999f, -0.06875783f, 0.19060700f, -0.06027732f, -0.11064796f, -0.12272687f, 0.07356308f, 0.01090751f, 
    0.08471397f, -0.07728218f, -0.10948198f, -0.08025151f, 0.47939593f, -0.18311197f, 0.28865254f, -0.28805512f, 
    0.02600488f, 0.01823390f, -0.07866666f, 0.16761123f, 0.02013017f, -0.07669135f, 0.05260751f, 0.04684202f, 
    -0.42392534f, -0.11413362f, 0.20013463f, 0.01099106f, 0.16314763f, 0.09464239f, 0.04382762f, -0.03414277f, 
    -0.00189305f, -0.10352010f, -0.04326937f, 0.10247102f, 0.03018202f, 0.02489135f, 0.07321899f, 0.04328651f, 
    0.04969438f, -0.01567641f, -0.01895817f, 0.00325047f, 0.04781975f, -0.01689884f, 0.17613642f, 0.13881420f, 
    0.35103247f, 0.05290694f, 0.15124457f, -0.05495016f, 0.01974924f, 0.06422286f, 0.12311037f, 0.15995438f, 
    -0.03071041f, 0.09993601f, -0.01704189f, 0.07383944f, -0.11113711f, -0.07290121f, 0.04867050f, 0.02951183f, 
    0.03893773f, -0.02751147f, 0.21317106f, -0.01555642f, -0.01228154f, 0.03551534f, -0.10387282f, 0.05494779f, 
    -0.01919221f, -0.05713869f, 0.10691101f, -0.23639266f, 0.10144416f, -0.01009743f, -0.00247252f, 0.01296351f, 
    -0.01206634f, 0.04224381f, 0.14444229f, 0.08376477f, -0.23097526f, 0.15889287f, -0.13776305f, 0.18827023f, 
    0.05702862f, -0.00714255f, 0.09762082f, 0.06580698f, 0.01107434f, -0.03105681f, -0.00336820f, -0.01152120f, 
    -0.02489668f, -0.06499363f, 0.12216964f, -0.00564149f, 0.02744632f, 0.08662194f, -0.01623558f, 0.16368289f, 
    -0.04328953f, 0.09091939f, -0.11310722f, 0.16106461f, -0.15953690f, -0.02845688f, -0.10135013f, -0.04735954f, 
    0.14446864f, 0.03864066f, 0.00179581f, -0.05434302f, 0.05230308f, 0.01934003f, 0.03721659f, 0.09228157f, 
    -0.26692915f, 0.23181033f, 0.06533974f, 0.00979573f, 0.14310448f, -0.01395721f, 0.01319150f, 0.07787699f, 
    -0.00885697f, 0.19003765f, 0.11150249f, -0.04561090f, -0.09854952f, -0.00908251f, -0.06403784f, -0.11317723f, 
    0.05810975f, -0.07927297f, 0.05001323f, 0.04001253f, 0.03101523f, -0.10655186f, -0.06325363f, 0.03805855f, 
    -0.25091100f, -0.09817231f, -0.12368273f, 0.09082779f, 0.09845732f, 0.17737125f, 0.04595009f, 0.03623236f, 
    0.08014228f, -0.04342703f, 0.00690497f, -0.09067955f, -0.20601025f, -0.17918231f, 0.10116972f, 0.19094612f, 
    0.02428124f, 0.03503725f, 0.08982010f, -0.06415486f, -0.02983908f, 0.00432950f, 0.08342095f, -0.01186307f, 
    -0.08277269f, 0.05409538f, -0.16387598f, 0.31626949f, 0.12493389f, 0.02888612f, 0.04232368f, 0.02801255f, 
    -0.00365943f, -0.01421030f, 0.11015479f, 0.07226877f, 0.07501404f, 0.01987176f, 0.10575476f, -0.04131294f, 
    -0.00148403f, 0.09120257f, -0.06536506f, -0.22158180f, 0.06803437f, 0.02126837f, -0.02344451f, -0.01054907f, 
    -0.12293285f, 0.12082459f, 0.10314813f, -0.00930142f, -0.02879603f, -0.01506157f, -0.07042751f, -0.00487553f, 
    0.09732476f, -0.11471239f, 0.04204199f, -0.06623417f, 0.00183787f, 0.12530413f, -0.15538183f, 0.23567662f, 
    0.10837457f, 0.09665006f, 0.02175025f, -0.02130131f, 0.04637202f, 0.09022580f, -0.06803803f, -0.02951539f, 
    0.32570669f, 0.17165738f, 0.16243476f, -0.11040454f, 0.09603122f, -0.03982044f, 0.15161973f, 0.03967610f, 
    -0.01873193f, -0.05466911f, 0.07703421f, 0.04814238f, -0.13671635f, 0.15775330f, -0.00597984f, 0.01907690f, 
    -0.03151149f, 0.17098401f, -0.04929348f, -0.12874343f, 0.08956936f, -0.00494374f, 0.00315539f, -0.01832852f, 
    0.32811800f, 0.02409743f, 0.08995060f, 0.05638251f, -0.05984206f, -0.12287894f, 0.02728912f, 0.15621226f, 
    0.05364393f, 0.10513088f, 0.06130433f, -0.00526897f, -0.35032302f, 0.09653948f, 0.23112288f, -0.03618655f, 
    0.00845751f, 0.05431540f, 0.03137796f, -0.08156423f, 0.13976534f, -0.06011515f, 0.10883144f, -0.00648813f, 
    -0.03410024f, 0.12661697f, 0.04954997f, 0.14998883f, 0.15182215f, 0.15960781f, -0.12381306f, 0.07758164f, 
    -0.03915857f, 0.02841797f, 0.02778821f, 0.05180105f, -0.06958590f, 0.00393001f, 0.10220247f, -0.18501592f, 
    0.02892098f, -0.08591162f, -0.11458209f, -0.11299611f, 0.03156110f, 0.02810205f, -0.00837146f, -0.03049245f, 
    0.18448333f, 0.04157372f, 0.08001514f, 0.01771595f, 0.04221417f, -0.05097979f, 0.01657446f, -0.08220135f, 
    0.01636272f, -0.05949185f, -0.02637599f, 0.06377010f, 0.06451568f, 0.03532936f, -0.03274330f, 0.08101622f, 
    0.14862996f, 0.03119805f, 0.08572482f, -0.16002306f, 0.04968696f, -0.01097365f, 0.03267766f, -0.03600430f, 
    -0.10827736f, 0.12200903f, -0.12714092f, -0.08280291f, -0.10234286f, 0.07899301f, 0.14568524f, -0.10766091f, 
    -0.05986129f, -0.03414082f, 0.01799621f, -0.15099886f, 0.09977939f, 0.06395701f, 0.18345910f, 0.18491501f, 
    0.17367299f, 0.03655766f, -0.05715407f, 0.18841146f, 0.03324280f, 0.07289607f, 0.06901197f, -0.02435525f, 
    -0.06993423f, 0.17341733f, 0.04342012f, 0.08909000f, 0.07968090f, 0.02888889f, -0.10098480f, -0.13375598f, 
    -0.08960215f, 0.02325599f, -0.04599275f, 0.13521691f, 0.33927512f, -0.09530743f, 0.07546455f, -0.16846697f, 
    0.06133220f, -0.10516936f, -0.18050696f, 0.00635394f, 0.07589240f, -0.13762537f, 0.00812152f, -0.01876269f, 
    -0.23177344f, 0.19467272f, 0.07105001f, -0.27624592f, -0.05766721f, -0.12114894f, -0.08687185f, 0.05142735f, 
    0.13998501f, 0.03088639f, -0.13473862f, -0.12891313f, 0.04176307f, 0.12706318f, -0.08914411f, -0.15055987f, 
    0.08736354f, 0.04027161f, -0.02253086f, 0.05019941f, 0.05750316f, 0.02029927f, -0.03798079f, 0.03856522f, 
    -0.18674548f, -0.07813913f, 0.22232002f, -0.04958745f, -0.01742031f, -0.12085325f, 0.02484896f, 0.09839408f, 
    0.04346964f, 0.07696424f, 0.04876908f, 0.10000764f, -0.07898799f, 0.02001759f, 0.13460778f, 0.33978662f, 
    0.21027663f, -0.09351152f, 0.00686306f, -0.05446144f, -0.02639822f, 0.00440438f, 0.04583419f, -0.07638616f, 
    -0.28459656f, -0.14355764f, -0.02806909f, -0.19652517f, 0.00138910f, 0.04607896f, 0.10498640f, -0.03085505f, 
    -0.08330785f, -0.09229224f, 0.11939932f, 0.09610374f, -0.12057285f, 0.02097511f, -0.01554977f, -0.02129819f, 
    -0.01645572f, -0.07045010f, -0.08109637f, -0.14031518f, 0.00950477f, -0.00928293f, 0.12998486f, 0.12807868f, 
    0.28141472f, 0.36627144f, 0.23984776f, 0.26212284f, -0.09349155f, -0.07686517f, 0.08483096f, 0.07149327f, 
    -0.04465507f, -0.02474421f, 0.10082375f, 0.14822914f, -0.03838953f, -0.23163772f, 0.13674761f, -0.09901407f, 
    0.07121346f, -0.09748456f, 0.09209681f, -0.07068988f, 0.05343368f, 0.09832260f, -0.05349822f, 0.04320508f, 
    0.06881913f, -0.14687519f, -0.09265440f, 0.01908145f, 0.00268607f, -0.01190317f, -0.03100658f, 0.02117664f, 
    -0.00194392f, 0.08079787f, 0.12278112f, 0.06116521f, -0.34489444f, 0.14393646f, 0.04021310f, 0.31141794f, 
    -0.01028990f, -0.01309976f, 0.04416085f, 0.22959770f, 0.05426518f, -0.03933462f, -0.01291235f, -0.07186277f, 
    -0.08284975f, -0.16675176f, 0.02852542f, 0.02117299f, 0.08775144f, -0.06145511f, -0.09314743f, 0.12023367f, 
    -0.02851397f, 0.05129825f, 0.06542604f, 0.05000992f, -0.46659604f, 0.04449802f, -0.05475502f, -0.23085701f, 
    0.16350350f, 0.02799497f, 0.01993818f, -0.07279801f, -0.02446664f, 0.00014745f, 0.04028078f, 0.10960110f, 
    -0.11264831f, 0.19624469f, 0.19566262f, -0.24089436f, 0.08394592f, 0.07877620f, -0.06061528f, -0.06529249f, 
    -0.04323837f, 0.12385762f, 0.06524578f, 0.02752464f, 0.08430911f, -0.11720335f, 0.21034947f, -0.14048314f, 
    -0.05269045f, -0.09350091f, 0.02729417f, -0.16559814f, -0.01192048f, 0.03517725f, -0.15897855f, -0.03501550f, 
    -0.27462032f, 0.10228514f, -0.05391097f, -0.29693246f, 0.17602128f, 0.10266020f, -0.00178844f, 0.00409897f, 
    0.02916547f, 0.10234617f, 0.03260816f, 0.18367304f, 0.13531263f, -0.30258998f, -0.11815765f, 0.23806787f, 
    0.13833202f, 0.01860166f, -0.01077359f, 0.02650459f, -0.05999148f, 0.04898773f, 0.07030928f, 0.20046058f, 
    0.06971713f, 0.26846373f, 0.32300749f, -0.25220883f, -0.11910189f, 0.00255827f, -0.02205973f, 0.01729948f, 
    -0.00750313f, 0.08082382f, 0.10179321f, -0.07060887f, -0.10675249f, -0.06116816f, 0.04716459f, -0.00964007f, 
    0.13691312f, 0.18090540f, 0.06959635f, 0.15685289f, 0.16827145f, 0.01440531f, -0.00104700f, 0.07504682f, 
    0.01163922f, 0.04671694f, 0.01102617f, -0.00313957f, 0.02086124f, -0.00206820f, 0.03619362f, 0.13258106f, 
    0.13385268f, 0.11766066f, -0.06418277f, -0.04362391f, -0.24191689f, -0.02742297f, 0.16128178f, 0.03768788f, 
    0.11698382f, -0.01963815f, 0.09429251f, -0.02019385f, -0.00898176f, -0.06386077f, 0.00996507f, -0.01672409f, 
    0.00520317f, -0.14411826f, -0.15266691f, 0.17062983f, 0.01238224f, 0.02944451f, 0.02497732f, 0.05408166f, 
    -0.00472588f, 0.04428756f, 0.08155759f, 0.08592799f, -0.02008722f, -0.29989734f, 0.22867267f, -0.06464786f, 
    -0.00558283f, 0.03302373f, 0.07260018f, 0.16735826f, 0.01177627f, -0.06171304f, -0.06731589f, -0.01439220f, 
    -0.19885053f, 0.06638195f, -0.00416565f, 0.08060461f, 0.03451073f, 0.14397430f, 0.02376536f, -0.02464991f, 
    -0.00310621f, -0.02763270f, 0.00314695f, 0.07074937f, 0.28670684f, 0.11387102f, -0.04758649f, 0.09532072f, 
    -0.10263150f, -0.05371727f, -0.05783901f, 0.01430970f, 0.00440448f, 0.18127301f, 0.00555331f, 0.08097768f, 
    -0.08517897f, 0.00007422f, -0.10474952f, -0.16763431f, -0.15579076f, -0.12665051f, 0.01422434f, 0.08707909f, 
    -0.07230995f, -0.00125786f, -0.02632050f, 0.05290477f, 0.08107427f, 0.05055344f, 0.05916097f, 0.36485648f, 
    -0.02168765f, 0.12006076f, -0.03599749f, 0.01382990f, 0.00090391f, -0.06275760f, 0.04100813f, -0.08336923f, 
    -0.18604118f, 0.01463688f, -0.02222805f, 0.06564858f, -0.01476056f, -0.01677931f, 0.01996103f, -0.02586776f, 
    -0.03457741f, 0.06730591f, 0.00041559f, 0.13292262f, 0.04934480f, -0.01604256f, 0.12180344f, -0.14012586f, 
    0.00516655f, -0.01295604f, -0.00287812f, 0.15054813f, 0.04739073f, 0.10961084f, 0.07028076f, 0.20494810f, 
    0.31720808f, 0.21697868f, 0.13726957f, -0.03907290f, 0.14818636f, 0.07583101f, 0.01230253f, 0.06634717f, 
    0.10205550f, 0.09872162f, 0.09163903f, 0.09206251f, 0.05975114f, 0.07904942f, 0.08897965f, 0.02460238f, 
    0.09922981f, -0.05983371f, 0.08158810f, -0.03006546f, 0.02845975f, 0.14047669f, -0.06981727f, -0.02241252f, 
    -0.05806452f, -0.14672957f, -0.02939490f, -0.01101059f, 0.15442541f, 0.02315234f, 0.10495409f, 0.07050662f, 
    0.06529204f, 0.00519041f, 0.12807113f, -0.06487034f, 0.16674103f, 0.15029137f, -0.06895924f, 0.30620027f, 
    -0.11697849f, 0.07642082f, 0.07317758f, -0.02864438f, -0.02301946f, -0.05272127f, -0.01287556f, 0.04872730f, 
    0.26195511f, 0.22089696f, -0.08896198f, 0.26921865f, -0.00989482f, 0.07850930f, 0.02342676f, -0.02333104f, 
    0.01291910f, -0.01555560f, 0.03940029f, 0.04500191f, -0.24236839f, -0.19946733f, 0.30312079f, 0.03588399f, 
    -0.00181085f, -0.07020988f, 0.07224110f, -0.06966266f, -0.03619237f, 0.00508931f, -0.03340663f, -0.03742855f, 
    0.25646314f, -0.08087108f, -0.07885378f, 0.00620118f, 0.06901365f, 0.10315174f, -0.03883671f, 0.11748001f, 
    0.10960734f, 0.05654963f, 0.13738723f, 0.05222911f, -0.15263256f, 0.23262787f, -0.17491871f, -0.07009198f, 
    0.00225875f, -0.06239447f, 0.08057775f, 0.08238266f, 0.01171959f, 0.00053205f, -0.04083082f, 0.10935935f, 
    0.21670201f, 0.24945995f, 0.05945701f, 0.00145450f, -0.12087826f, 0.03542982f, -0.01047441f, 0.04698164f, 
    0.06304934f, -0.00541281f, -0.01782238f, -0.00802161f, 0.09607049f, -0.08106551f, 0.04216714f, 0.07517700f, 
    0.15060058f, 0.00883619f, 0.16716914f, 0.12835696f, -0.04537842f, -0.00704396f, 0.05088581f, 0.01956919f, 
    -0.20741354f, -0.13576254f, 0.02142680f, 0.05041236f, 0.01238178f, 0.01018082f, -0.00608285f, -0.03246926f, 
    -0.03210020f, -0.09374942f, 0.06130854f, -0.03434889f, 0.20692186f, 0.10697345f, -0.05865231f, -0.01325455f, 
    -0.01734219f, 0.10126402f, -0.07374557f, 0.01536483f, 0.09102914f, 0.03112777f, -0.00798879f, 0.09537065f, 
    -0.02546703f, 0.24965400f, 0.13162538f, 0.23577115f, -0.00351697f, -0.01601679f, -0.04290552f, -0.00226423f, 
    0.04090847f, 0.15579723f, 0.03413368f, 0.03811821f, 0.29454324f, 0.08521207f, 0.12572046f, -0.20306240f, 
    0.09004461f, -0.03576198f, 0.05159437f, -0.17433673f, 0.06983604f, 0.04147642f, 0.04330524f, 0.07157802f, 
    0.42298675f, 0.14348708f, -0.04075556f, 0.14174223f, -0.04726471f, 0.02247628f, -0.01108762f, -0.08915780f, 
    0.02499417f, 0.05417778f, -0.01376198f, -0.13665847f, 0.17776240f, 0.00353722f, 0.21911307f, 0.27452412f, 
    -0.02696735f, -0.00639363f, 0.05973379f, 0.01166495f, 0.07782894f, 0.06767554f, -0.04024190f, 0.01938363f, 
    0.24074018f, -0.21932207f, -0.08171140f, 0.19006766f, 0.04811365f, 0.06272547f, -0.03176083f, 0.04370357f, 
    0.14995711f, -0.00570785f, -0.07192892f, 0.04789198f, 0.06311345f, 0.19672717f, -0.16461943f, 0.21838948f, 
    -0.10032623f, 0.13724461f, 0.03778709f, 0.12442771f, 0.05183909f, 0.07594624f, -0.03899610f, -0.02002338f, 
    0.04279372f, 0.02128594f, 0.27749732f, 0.03607634f, -0.19891082f, -0.00020770f, 0.04204595f, 0.01966395f, 
    0.08015130f, 0.04700328f, 0.04975591f, 0.01220816f, -0.38559040f, 0.15596047f, 0.07523198f, -0.17604306f, 
    0.08626767f, 0.09847055f, -0.01614057f, 0.03251249f, 0.03938973f, -0.04627882f, -0.04403343f, -0.03602139f, 
    -0.03255338f, -0.03437943f, 0.04561347f, -0.00917232f, -0.01558974f, -0.05875278f, 0.04720437f, -0.03165611f, 
    -0.01234390f, 0.01943229f, -0.01819495f, 0.00150221f, -0.02279869f, -0.05449511f, -0.00183676f, -0.03222961f, 
    -0.02404168f, -0.05061647f, -0.03817091f, -0.05190084f, -0.02236462f, 0.00020069f, -0.01126146f, -0.04905793f, 
    0.01701017f, 0.04431642f, 0.01448885f, 0.04092634f, 0.02117173f, 0.00603600f, 0.01215874f, 0.01620563f, 
    0.02375174f, -0.01106604f, 0.01172238f, -0.00281529f, -0.03180348f, -0.00217761f, -0.02834222f, -0.02735666f, 
    -0.02393853f, 0.03455415f, 0.02033314f, -0.05342266f, 0.02529160f, -0.02201360f, 0.00230888f, 0.03860857f, 
    0.02007936f, -0.01502459f, -0.02658682f, 0.00906548f, 0.01621480f, 0.01991810f, -0.05185436f, -0.02598401f, 
    0.03213938f, 0.02605979f, 0.02065059f, 0.00771257f, -0.01559715f, -0.01446851f, 0.03147609f, 0.03231208f, 
    0.03376774f, 0.00552477f, -0.03557008f, 0.00944454f, 0.00155280f, 0.01504814f, -0.00401548f, 0.01572155f, 
    -0.03856518f, 0.00539796f, -0.03975544f, 0.00248608f, -0.03270262f, -0.02271985f, -0.03480856f, -0.01206937f, 
    -0.00111499f, 0.03003848f, -0.01318164f, 0.02059942f, -0.04578035f, -0.03344955f, 0.00287140f, 0.02850295f, 
    -0.02714624f, 0.00988364f, 0.00887637f, 0.01753802f, 0.00645244f, 0.01172349f, -0.04831078f, -0.04277014f, 
    -0.02127255f, -0.05252399f, -0.03635926f, -0.01861281f, 0.00997869f, -0.00929519f, -0.03537129f, -0.02833294f, 
    0.01095940f, 0.01523922f, 0.03377566f, 0.00697419f, -0.03231435f, -0.00423392f, -0.02183799f, -0.00787703f, 
    -0.01269851f, -0.04634392f, 0.02398258f, -0.03883754f, 0.00918763f, 0.03076790f, 0.03839454f, -0.01497716f, 
    -0.00771440f, -0.02651574f, -0.03449563f, -0.04644861f, 0.03703992f, 0.01983679f, 0.02250635f, 0.04562111f, 
    -0.02816895f, -0.03455477f, -0.00565699f, -0.00304140f, -0.03081825f, -0.03310258f, 0.03131728f, -0.03600904f, 
    0.02066690f, 0.00974118f, 0.00465378f, 0.02090229f, -0.05496282f, -0.02203481f, 0.02032033f, -0.03021360f, 
    0.03048725f, -0.00059200f, 0.03057872f, 0.02675118f, -0.00570344f, -0.00524135f, 0.02327781f, -0.01177081f, 
    -0.06018715f, 0.00707240f, -0.00114978f, 0.02859071f, 0.02854225f, 0.01747742f, -0.01173582f, 0.00593399f, 
    0.02451384f, -0.02547522f, 0.00795878f, 0.03540294f, 0.00957946f, -0.05985735f, 0.03874626f, 0.01711088f, 
    0.01155115f, -0.03278649f, -0.03466098f, -0.01755166f, 0.01150931f, 0.00374627f, -0.03618248f, 0.02895094f, 
    0.03366370f, -0.00142839f, 0.00505005f, 0.00465163f, 0.02080069f, 0.01186062f, -0.04463581f, -0.00359144f, 
    0.01883023f, -0.01262873f, 0.01814841f, 0.03691784f, -0.03436654f, -0.00283982f, 0.02357116f, 0.02268565f, 
    -0.01954798f, -0.05670646f, 0.01835615f, 0.02470990f, -0.03985078f, -0.01277814f, -0.03830568f, -0.01424763f, 
    0.00153981f, 0.03138515f, 0.02703837f, 0.02820097f, 0.03515252f, -0.04123546f, -0.03569989f, 0.01652534f, 
    0.01468555f, -0.02365909f, -0.02191947f, -0.00429342f, -0.00778770f, -0.02526505f, 0.03640560f, -0.05870204f, 
    0.03047487f, 0.01861207f, -0.04729440f, -0.04541045f, -0.03012575f, 0.01909505f, -0.03413837f, -0.03573897f, 
    -0.00117010f, 0.00321928f, -0.04649036f, 0.04400456f, -0.00529124f, -0.00240971f, -0.02467195f, -0.05185726f, 
    0.01846884f, 0.03220219f, 0.01383450f, -0.03509945f, 0.00398307f, -0.00459091f, 0.00130626f, 0.00543859f, 
    0.00311792f, -0.03499769f, 0.00239612f, -0.02998629f, -0.02292143f, 0.00048005f, -0.04637635f, 0.04482254f, 
    0.02179184f, -0.00253482f, 0.04068000f, -0.00095751f, -0.03667261f, -0.04430077f, 0.01350514f, 0.00340885f, 
    0.05445877f, -0.03116294f, 0.01395171f, -0.04383602f, 0.02747500f, -0.04426645f, -0.01739368f, 0.04058664f, 
    0.03123522f, 0.03013062f, 0.01495849f, -0.01438943f, 0.00086643f, -0.04373376f, 0.01149655f, 0.01179828f, 
    0.03749651f, 0.03597450f, 0.00692466f, -0.05482032f, 0.00896272f, -0.02385914f, -0.00741460f, 0.00083138f, 
    0.03375199f, 0.03327369f, -0.01345969f, -0.02617517f, -0.01873558f, 0.01298981f, -0.00594330f, 0.01739890f, 
    0.00597969f, 0.01833219f, -0.01442906f, -0.00249427f, 0.00558986f, -0.03487841f, 0.01323237f, -0.01810895f, 
    -0.02990718f, 0.02970155f, -0.00956642f, -0.04855756f, -0.04602815f, 0.01977656f, -0.05082017f, 0.02458020f, 
    -0.03369145f, -0.03522323f, 0.01170742f, -0.02517288f, -0.04965489f, -0.01236841f, -0.00340932f, 0.02239696f, 
    -0.04463595f, 0.00797644f, -0.01077642f, 0.03134986f, -0.04137034f, 0.03623343f, -0.05251833f, 0.03261354f, 
    0.00229572f, -0.03636352f, 0.01442421f, 0.03032329f, 0.02623532f, -0.04353748f, -0.04399566f, -0.00774527f, 
    -0.04293632f, -0.02299761f, 0.03961323f, -0.02802595f, -0.00271518f, 0.02023819f, -0.03069571f, -0.00083315f, 
    -0.02731360f, -0.00624756f, 0.03932209f, 0.02449274f, -0.02593005f, -0.03980348f, -0.03636171f, 0.03096909f, 
    0.02323993f, 0.01544548f, -0.02781906f, -0.05063698f, -0.01395698f, -0.05153761f, 0.01782708f, -0.04621104f, 
    -0.00843134f, -0.05361633f, -0.01051681f, 0.03751739f, -0.00932667f, 0.01904238f, 0.01049266f, -0.02600183f, 
    0.00335531f, 0.02707924f, -0.04812579f, -0.00406579f, 0.02348643f, -0.00465056f, -0.03919527f, -0.03281106f, 
    0.02816275f, -0.04772594f, -0.02405043f, 0.00187503f, -0.01808134f, -0.01997349f, -0.01387909f, -0.05202647f, 
    -0.04329425f, -0.04345533f, -0.05331681f, -0.01191833f, -0.01931906f, 0.01816927f, -0.00752156f, 0.02012336f, 
    -0.04380810f, -0.01024724f, 0.03251284f, 0.00027812f, 0.02487166f, 0.04469359f, 0.01318226f, -0.03369742f, 
    -0.02411477f, -0.04049655f, 0.04097304f, 0.04169254f, 0.04388409f, 0.03052941f, -0.04913411f, 0.02352851f, 
    -0.02779479f, 0.02004008f, -0.02345941f, 0.04577016f, -0.05563166f, 0.00094657f, -0.05482477f, 0.01691573f, 
    0.02178426f, 0.00787473f, 0.04040669f, 0.02155848f, -0.00091916f, 0.01133272f, -0.00847994f, 0.01672273f, 
    -0.03212490f, -0.05442526f, -0.02748519f, 0.01087373f, 0.04005353f, -0.05438342f, 0.03770281f, -0.01572262f, 
    -0.03677894f, -0.04259064f, -0.00933192f, -0.03685329f, -0.01824532f, 0.02140102f, 0.01233504f, -0.02578856f, 
    -0.03453641f, -0.01017461f, 0.03928295f, -0.05602304f, -0.03551371f, -0.02937074f, -0.05574628f, -0.02994647f, 
    -0.04057089f, -0.05154604f, 0.04456583f, 0.02614705f, -0.01031746f, -0.05484020f, -0.02600646f, 0.01125296f, 
    -0.00773134f, 0.03062008f, 0.00961659f, -0.05278817f, -0.01967327f, 0.02146695f, -0.03058626f, -0.04225586f, 
    -0.00404351f, 0.00813677f, 0.02990830f, -0.04898828f, -0.02206106f, 0.00521625f, -0.00853693f, 0.02124673f, 
    0.04337155f, 0.03441963f, 0.03313646f, -0.04763469f, -0.01871481f, 0.04334825f, 0.03544073f, -0.01861358f, 
    -0.03141914f, -0.04402327f, -0.02770231f, -0.03125193f, -0.00224376f, 0.03164721f, 0.03501537f, -0.02282174f, 
    0.02282129f, -0.03591534f, -0.00141992f, -0.04168591f, -0.01871031f, 0.01247799f, -0.00418922f, 0.03172832f, 
    -0.01335172f, 0.03492966f, -0.04776053f, -0.00919107f, -0.04738039f, -0.04402228f, -0.01608397f, -0.04227478f, 
    0.04106784f, -0.02021650f, 0.03881876f, -0.05133604f, -0.04248827f, 0.02989492f, 0.02428785f, 0.00279861f, 
    0.03514261f, -0.05243703f, -0.00043033f, 0.03151688f, -0.01547668f, 0.03258150f, -0.03311022f, -0.00988133f, 
    0.02654199f, -0.03376992f, -0.00538711f, -0.00917500f, -0.04597288f, -0.03647291f, 0.04303309f, -0.01249121f, 
    -0.03907482f, 0.00924832f, 0.02821944f, 0.01763071f, -0.02052680f, -0.05045836f, 0.04307516f, -0.04328874f, 
    0.04050437f, 0.00941564f, -0.05463721f, -0.05313651f, -0.03391780f, -0.03670212f, -0.04476445f, -0.02192596f, 
    -0.00193402f, 0.02334103f, -0.01114091f, 0.03636521f, -0.02747881f, 0.01762858f, 0.02045207f, 0.01906558f, 
    0.04246043f, -0.04936228f, 0.01750128f, -0.02310867f, 0.00233230f, -0.04952832f, -0.03753537f, -0.04420441f, 
    -0.03205171f, 0.03135528f, 0.02256538f, -0.02496876f, -0.04852658f, 0.00771971f, -0.04215639f, -0.04560082f, 
    0.00185596f, 0.00128888f, 0.00028112f, -0.01844859f, 0.04329801f, -0.04666465f, -0.02474516f, 0.00545182f, 
    -0.03463077f, 0.03500024f, -0.05095105f, -0.02028826f, 0.02301630f, -0.04031317f, 0.01124441f, -0.04092844f, 
    0.01855494f, 0.00495845f, 0.02868344f, -0.05374682f, 0.03896815f, -0.01048409f, -0.03822358f, -0.05226469f, 
    -0.03460468f, 0.02781332f, 0.03384989f, -0.04335202f, -0.05243822f, -0.03992311f, -0.03510924f, -0.01650033f, 
    0.04309030f, 0.02998132f, 0.01328683f, 0.02658542f, -0.01732740f, -0.00948004f, 0.03241887f, 0.00572574f, 
    -0.04072725f, -0.03937748f, -0.05492622f, 0.00513105f, -0.00442583f, -0.02352834f, 0.01179776f, 0.00512483f, 
    -0.01359362f, -0.01334948f, -0.02341191f, -0.01023795f, 0.04257348f, 0.02110962f, -0.03479770f, 0.02486262f, 
    -0.00928028f, -0.05284715f, 0.01400088f, -0.03734508f, -0.05005148f, 0.04164403f, -0.05492863f, -0.02467415f, 
    -0.02857504f, 0.00544653f, 0.01793632f, 0.00665421f, -0.00332583f, 0.00218187f, 0.00459490f, 0.01848522f, 
    -0.03289849f, -0.03935103f, 0.00108024f, -0.02202244f, -0.05139069f, 0.02332803f, -0.00436401f, -0.00646501f, 
    0.00711469f, -0.04003941f, -0.03629641f, -0.00964846f, 0.03398024f, -0.00703534f, 0.02623805f, 0.02113368f, 
    -0.02647866f, 0.02146800f, 0.01575504f, -0.02410038f, -0.03050766f, 0.00838779f, -0.00716065f, -0.02544153f, 
    -0.00517656f, -0.00621691f, -0.01703303f, -0.03836271f, -0.03206306f, -0.00552838f, -0.02658575f, -0.02288095f, 
    0.04191855f, -0.04946418f, -0.05050462f, 0.03791181f, -0.03500327f, 0.04147884f, 0.04173824f, -0.05427695f, 
    -0.03088099f, 0.04476008f, -0.02336580f, 0.03372255f, -0.05328607f, 0.01725459f, -0.03473899f, 0.01599336f, 
    -0.03098889f, -0.03477854f, -0.04435245f, -0.03774503f, -0.02527724f, -0.04712846f, -0.03372180f, 0.03095211f, 
    0.04036360f, -0.04000447f, -0.00456057f, 0.04944993f, -0.00626898f, -0.04581549f, 0.03114445f, -0.05115099f, 
    0.02976662f, -0.00403732f, -0.01810392f, -0.02372750f, 0.01417163f, -0.01901830f, 0.03954653f, 0.02474945f, 
    0.04053871f, -0.05570494f, 0.02765388f, -0.02795439f, -0.04475139f, -0.01394190f, 0.04404169f, -0.00184096f, 
    -0.04966038f, -0.05083350f, -0.04156885f, -0.02155385f, -0.03292066f, -0.05130574f, -0.04835634f, 0.00952521f, 
    0.04384335f, 0.03033857f, 0.01577640f, 0.03053633f, 0.03954584f, -0.04861717f, 0.02897755f, -0.00093858f, 
    -0.02112725f, 0.03340157f, 0.01646393f, -0.01353892f, 0.00543616f, -0.01222995f, -0.01184700f, 0.01653623f, 
    0.02397588f, -0.00556890f, -0.00609322f, 0.00784448f, -0.03410094f, -0.01402395f, 0.01443345f, 0.02399329f, 
    0.00842319f, 0.00408118f, 0.00009668f, 0.00075830f, -0.00469473f, -0.01916253f, 0.04022987f, 0.03524593f, 
    -0.00251386f, -0.02187191f, 0.03563988f, -0.03946393f, -0.01381379f, 0.03622727f, -0.00769249f, 0.04163589f, 
    -0.01581963f, -0.02270374f, -0.01785889f, -0.00380133f, -0.02786045f, 0.03397444f, -0.03592756f, 0.00892796f, 
    0.07635008f, 0.28166839f, 0.29827502f, 0.10440373f, -0.06836015f, 0.06300597f, 0.00430170f, 0.10482521f, 
    0.01130512f, -0.02597710f, -0.01010013f, 0.16330329f, 0.11792033f, 0.08855481f, -0.00323322f, 0.15893325f, 
    0.13932201f, -0.01047972f, 0.10193634f, 0.07132055f, -0.02637094f, -0.06338385f, 0.04763633f, -0.00964029f, 
    -0.60477501f, 0.31811056f, -0.09234107f, -0.06589890f, -0.01875184f, -0.01419114f, 0.09508585f, -0.09070045f, 
    0.11975747f, 0.00643432f, 0.07465125f, -0.03399426f, 0.39438578f, -0.11681567f, 0.06031611f, -0.16132382f, 
    -0.04476148f, -0.01396372f, -0.07812650f, -0.10337193f, -0.00020937f, 0.04290152f, -0.01135701f, 0.02618741f, 
    0.01725907f, -0.00980844f, -0.00476876f, 0.04295949f, 0.07800261f, -0.08708151f, 0.12732166f, 0.01301179f, 
    -0.03034208f, -0.05718027f, 0.06139500f, 0.04948543f, -0.32673609f, -0.00386182f, 0.11038660f, 0.28844106f, 
    0.05878313f, -0.04221263f, 0.00229002f, 0.06167715f, 0.07422581f, 0.03701676f, 0.05811765f, -0.05077565f, 
    0.10873476f, -0.22199926f, 0.22357184f, 0.24936314f, -0.17475934f, -0.07110006f, -0.12483785f, -0.02232384f, 
    0.00112488f, 0.04718110f, -0.01575784f, 0.01067867f, 0.25320029f, 0.13363077f, -0.10424282f, 0.04459548f, 
    0.05155100f, 0.04794749f, 0.09923298f, 0.02970402f, 0.09492368f, -0.00160551f, 0.06136475f, 0.00867785f, 
    -0.03648281f, 0.10811536f, 0.00502282f, -0.00843402f, 0.08271593f, -0.03265684f, 0.01370081f, -0.08339264f, 
    0.05082258f, 0.06938528f, 0.01848117f, 0.06952402f, 0.18699080f, 0.00249361f, 0.08156068f, 0.18263617f, 
    0.07376029f, -0.04808948f, 0.12744260f, 0.05577487f, -0.09237518f, 0.10792675f, 0.05617375f, -0.00546349f, 
    0.26788402f, -0.02047606f, -0.08311751f, 0.19460700f, -0.17303297f, 0.03615676f, -0.04228948f, -0.08492814f, 
    -0.03800491f, -0.08713286f, 0.05497665f, -0.06168970f, -0.39097998f, -0.00728448f, 0.02270324f, 0.07528643f, 
    0.17227046f, 0.03946914f, 0.04902513f, 0.05067234f, -0.00254355f, -0.04024510f, 0.06204151f, -0.02289853f, 
    -0.35937503f, 0.05710452f, -0.01147023f, 0.01447041f, 0.13195987f, 0.03375783f, 0.17036764f, 0.02979260f, 
    0.05206513f, -0.05522852f, 0.07927757f, -0.00422046f, 0.11724235f, 0.05757047f, -0.01689792f, -0.00792362f, 
    0.09146190f, 0.09567845f, 0.13778485f, -0.03992707f, -0.01759841f, -0.00441383f, 0.05119329f, -0.07349753f, 
    0.30141148f, 0.03407037f, 0.01344429f, 0.13718033f, 0.13233219f, 0.12898968f, 0.00974421f, 0.15176837f, 
    -0.04316444f, -0.02112288f, -0.00675790f, 0.06069709f, -0.26328766f, 0.34917516f, -0.02803995f, 0.01124275f, 
    0.12868863f, -0.14916471f, -0.02703350f, 0.06293873f, -0.05282109f, -0.16674848f, 0.00066948f, -0.03420758f, 
    0.06247771f, 0.05631728f, 0.11664739f, 0.03263910f, 0.07522845f, 0.04100690f, -0.02404145f, -0.04933578f, 
    -0.09524954f, -0.07862972f, 0.02283381f, -0.17039272f, 0.10795121f, -0.31294671f, -0.06435453f, 0.16461727f, 
    -0.08564745f, -0.03075797f, -0.05411152f, -0.04973427f, 0.10209994f, -0.04182982f, -0.00352897f, 0.02235813f, 
    -0.06704103f, -0.01665974f, 0.13342568f, -0.16361415f, -0.10961998f, -0.13327411f, -0.05927543f, -0.10473356f, 
    0.06591000f, -0.01416369f, -0.04689791f, 0.02167535f, 0.17639001f, 0.00340781f, -0.09643856f, -0.20894904f, 
    -0.00046080f, 0.02185051f, -0.09525026f, 0.10112236f, 0.12780876f, -0.10327530f, 0.03592126f, -0.06579040f, 
    -0.13061011f, -0.07846434f, 0.15742391f, 0.24140738f, 0.10560308f, 0.05676737f, 0.02044044f, 0.02832159f, 
    -0.00349032f, -0.17546526f, 0.04837406f, 0.15295453f, 0.05648974f, -0.23523080f, 0.01662946f, 0.21323976f, 
    0.13654162f, -0.02566589f, 0.06513059f, 0.07153840f, 0.09613294f, 0.07161742f, 0.15214725f, 0.07581820f, 
    -0.03240952f, -0.04364237f, 0.07883465f, -0.08231790f, -0.19819167f, 0.03690608f, 0.01712030f, 0.11595504f, 
    -0.08029679f, -0.03406518f, -0.04183658f, 0.03793172f, -0.30195117f, 0.12053291f, 0.03609108f, -0.08279136f, 
    0.02227534f, -0.03030201f, 0.08278012f, -0.07026352f, -0.02005984f, -0.01262358f, -0.16704653f, 0.03772550f, 
    0.28244069f, -0.01831285f, 0.02647067f, 0.00912881f, 0.04133804f, 0.02364581f, 0.00032819f, -0.04740748f, 
    -0.01448779f, -0.06028519f, 0.15640062f, 0.07121184f, -0.03355787f, 0.14926530f, 0.24806808f, -0.10586264f, 
    -0.02471204f, 0.00390210f, 0.11183332f, -0.00020936f, -0.01794635f, -0.02755476f, 0.03194696f, 0.03636060f, 
    -0.02716702f, -0.04327099f, 0.08329280f, 0.02158136f, 0.08849630f, 0.02202586f, -0.00828733f, -0.02830650f, 
    0.02290376f, -0.00687672f, -0.00285020f, 0.07756262f, 0.24538743f, -0.12607943f, -0.08148508f, 0.14846694f, 
    0.03258185f, 0.04234057f, -0.02079973f, -0.07829749f, 0.06676657f, -0.01599746f, -0.04791405f, -0.01239698f, 
    -0.34728885f, 0.05589306f, -0.03595576f, 0.02162287f, 0.12686616f, 0.00560520f, -0.00342409f, -0.04583778f, 
    0.18156610f, 0.11795735f, 0.07088055f, 0.02803870f, -0.32126471f, 0.20267043f, -0.15310179f, 0.03529236f, 
    0.03122608f, -0.09998754f, 0.08980109f, -0.01749444f, -0.06448006f, 0.03110752f, 0.02007103f, -0.08407176f, 
    -0.02068084f, -0.16100797f, -0.00303687f, 0.14082792f, -0.02006770f, 0.03074679f, -0.01745883f, 0.05143883f, 
    0.07794017f, -0.01868702f, -0.07378066f, 0.05934394f, -0.04741841f, 0.01338593f, 0.08211114f, -0.05251196f, 
    -0.08098350f, -0.10257317f, -0.07407404f, 0.00164837f, -0.01808345f, -0.01112137f, 0.10337773f, -0.04512526f, 
    0.18127392f, 0.32395920f, -0.05394412f, 0.08215940f, -0.06795613f, 0.05746396f, 0.09438738f, 0.15725856f, 
    -0.09125707f, 0.12191658f, -0.00200768f, 0.09486032f, 0.08185940f, 0.09117676f, 0.04210611f, 0.10429298f, 
    0.06427456f, 0.11647120f, 0.13424242f, 0.02245273f, -0.01860297f, -0.06464376f, -0.05146469f, 0.08682045f, 
    -0.33529565f, 0.34472072f, 0.08897694f, 0.20551948f, 0.06981743f, -0.01243704f, -0.02534707f, -0.04814165f, 
    -0.00036567f, -0.01453764f, 0.00215281f, 0.07686088f, 0.75757140f, 0.15765427f, 0.00272983f, -0.13343354f, 
    -0.03141392f, -0.12568009f, 0.05947508f, 0.03391698f, -0.04984865f, -0.02060588f, -0.05115187f, 0.08630522f, 
    -0.07538660f, 0.14800438f, -0.15863931f, 0.22562036f, -0.09066315f, 0.02178004f, 0.12577942f, -0.09592424f, 
    -0.02170389f, 0.04886233f, 0.19391404f, 0.14957806f, -0.28792176f, -0.19740452f, 0.04559981f, -0.00677358f, 
    -0.08214387f, 0.03170237f, 0.06744840f, 0.02198477f, 0.01023457f, -0.03847717f, 0.03013462f, -0.09492751f, 
    0.00914691f, -0.00895668f, -0.10354336f, -0.00677189f, -0.01767632f, 0.00499153f, 0.12908037f, 0.04311505f, 
    0.03602449f, 0.10776369f, 0.03713927f, -0.02723595f, 0.04305566f, 0.11267963f, -0.02988382f, 0.04133201f, 
    0.14573850f, 0.09198148f, 0.06406213f, -0.06982971f, 0.12036430f, -0.04991981f, -0.06558511f, 0.01588195f, 
    -0.35716248f, -0.10157356f, 0.39212233f, -0.16999625f, 0.03949183f, 0.06950869f, -0.01578122f, -0.05566190f, 
    0.09674683f, 0.12589882f, -0.05957693f, 0.00333554f, 0.01411596f, -0.06370836f, -0.01160791f, 0.12639526f, 
    0.14870246f, -0.16312432f, -0.07648501f, -0.06805275f, 0.01109875f, 0.13490975f, -0.02028575f, -0.15118702f, 
    0.34751055f, 0.28354388f, -0.14271213f, 0.03210303f, -0.09858727f, 0.01054554f, -0.15911573f, -0.05609015f, 
    0.03525825f, -0.02467731f, 0.12167004f, 0.03114099f, -0.11055612f, -0.13921979f, -0.03000388f, -0.05045389f, 
    0.06469550f, 0.01941176f, 0.05799143f, -0.05688548f, 0.22022052f, 0.01314822f, 0.00141496f, -0.02068152f, 
    -0.01960662f, 0.02163352f, 0.14135720f, -0.11592861f, 0.24123985f, 0.17325450f, -0.02382139f, 0.13744409f, 
    0.09271768f, -0.05112777f, 0.04822775f, -0.03302826f, -0.11493966f, -0.10725193f, -0.05025516f, 0.10103150f, 
    0.09548724f, 0.02467566f, 0.00249601f, -0.00175281f, 0.13865529f, -0.02293033f, -0.01569468f, -0.08872624f, 
    -0.02604085f, -0.32865536f, -0.00574311f, 0.01266476f, -0.03463782f, 0.18111093f, 0.01892028f, 0.02605727f, 
    0.00055979f, -0.10562631f, -0.18901141f, 0.03351460f, -0.03069437f, 0.17014284f, -0.08315118f, 0.18649496f, 
    -0.02851552f, -0.02448545f, 0.05223772f, -0.11100365f, -0.01411628f, -0.02252804f, -0.11878136f, 0.06936515f, 
    -0.11974799f, 0.00278835f, 0.00276688f, 0.05732877f, -0.03336609f, 0.06338028f, -0.05588771f, 0.02886888f, 
    -0.14987764f, 0.05195002f, -0.05242149f, 0.05409361f, 0.16204178f, -0.01270799f, -0.00839266f, -0.18685916f, 
    0.00915511f, -0.03194572f, 0.01969688f, 0.17636298f, 0.05031781f, 0.05014071f, 0.00951724f, 0.04101092f, 
    -0.09154799f, 0.02077178f, -0.06370402f, -0.06004497f, -0.05075138f, -0.03714133f, 0.06820516f, -0.08125964f, 
    -0.02688657f, -0.02601228f, 0.01218775f, 0.09366544f, -0.11459664f, 0.08786536f, -0.11806057f, 0.12724635f, 
    -0.00283795f, 0.00356120f, 0.08664804f, 0.03351424f, 0.06160691f, -0.01796245f, 0.12502296f, -0.00120617f, 
    0.09936324f, 0.08107374f, -0.22890630f, 0.01988510f, 0.16952163f, 0.01297029f, 0.07836606f, 0.04816648f, 
    -0.09277724f, -0.03867198f, 0.09794863f, 0.04427443f, -0.29994917f, -0.29246309f, -0.12086077f, -0.05691834f, 
    0.00469810f, -0.04165944f, -0.13206756f, 0.09898230f, 0.00073213f, 0.10121565f, 0.05227409f, -0.09241852f, 
    -0.25834134f, 0.08637591f, -0.17476352f, -0.20161058f, -0.13955386f, -0.02001218f, 0.01596805f, -0.12502120f, 
    -0.06897392f, 0.00519546f, 0.05849701f, -0.03882229f, 0.03964676f, 0.01076901f, -0.03304251f, -0.03550626f, 
    -0.02017382f, -0.04105356f, 0.01460519f, -0.08559088f, 0.00973789f, 0.05245661f, 0.05156130f, -0.10681185f, 
    0.25780413f, 0.00335790f, -0.21063384f, 0.21157546f, 0.04802820f, 0.07277357f, 0.04696907f, -0.03607269f, 
    -0.10599767f, -0.19353019f, 0.04899378f, 0.01332037f, 0.31881237f, -0.17782725f, 0.24058612f, -0.12936257f, 
    -0.03303041f, 0.01699923f, -0.00251777f, -0.00027865f, 0.02306771f, 0.11261720f, 0.03081179f, 0.00624191f, 
    0.04487871f, -0.29455310f, -0.06080316f, 0.06585628f, 0.14955905f, 0.03437502f, -0.01336177f, -0.08294974f, 
    0.11461437f, -0.07570169f, 0.08388300f, 0.21719605f, 0.20122598f, 0.02873267f, -0.09968378f, 0.12796727f, 
    0.09271117f, 0.01903524f, -0.02586503f, -0.01317544f, 0.01923435f, -0.09616641f, 0.02169375f, -0.17150800f, 
    -0.11590492f, -0.03096644f, -0.04550247f, 0.09249277f, -0.02259524f, 0.05015769f, 0.01475532f, -0.16999605f, 
    0.07977908f, -0.03762947f, 0.03353242f, 0.08371471f, -0.03911872f, 0.14172719f, 0.05204167f, 0.15537727f, 
    0.05344123f, 0.00317140f, -0.00297313f, -0.08913813f, -0.07752825f, 0.06808230f, 0.06025596f, -0.06807001f, 
    0.16504717f, 0.03874237f, -0.01376957f, 0.15060501f, 0.06193421f, -0.07229158f, 0.01142712f, 0.00779619f, 
    -0.03772556f, -0.07234732f, -0.01943555f, 0.19509590f, 0.73806012f, 0.03896063f, 0.02522552f, -0.18893586f, 
    -0.03207774f, -0.02038931f, -0.11121482f, -0.02648659f, -0.19679151f, 0.08694359f, 0.06319222f, 0.09742440f, 
    -0.02247898f, -0.04778806f, -0.04949668f, -0.03548148f, 0.00144812f, -0.01544238f, -0.04244498f, 0.01411828f, 
    0.01671040f, -0.01028997f, 0.00036735f, -0.04362348f, -0.02230188f, 0.03075257f, -0.03040947f, -0.04909966f, 
    0.01947123f, 0.01006075f, 0.01201641f, -0.05848421f, -0.04531593f, 0.01349270f, -0.04291085f, 0.01452646f, 
    0.00478659f, 0.00959591f, -0.02068800f, -0.02362922f, 0.03350282f, -0.04967092f, 0.02297042f, 0.00314333f, 
    -0.00868150f, 0.00439151f, -0.02644862f, 0.01218683f, 0.02924083f, -0.02731491f, -0.04225413f, -0.00631533f, 
    0.03256128f, -0.00380250f, 0.03903734f, -0.05425247f, -0.02039057f, -0.02744617f, -0.05546728f, -0.03930261f, 
    -0.00766521f, -0.00738454f, -0.00410125f, 0.04111192f, -0.03665042f, 0.02661635f, -0.01118321f, 0.03913105f, 
    0.03899304f, -0.04386299f, -0.00413946f, -0.05463830f, -0.01112965f, -0.02259769f, -0.00064499f, -0.01651629f, 
    -0.02976845f, -0.02425236f, -0.00080057f, -0.05860088f, -0.02896115f, -0.00013439f, -0.03704052f, -0.05248585f, 
    -0.03382266f, 0.03351094f, -0.00961814f, -0.02897375f, 0.00141280f, -0.01770568f, -0.00217317f, -0.03703386f, 
    0.03098901f, -0.03239664f, 0.02381039f, -0.05229594f, -0.03884547f, -0.00001236f, 0.00910014f, -0.00856068f, 
    -0.04355774f, -0.03901843f, -0.01656284f, -0.02214812f, -0.04640064f, -0.01283381f, -0.03956310f, -0.01118002f, 
    0.04022630f, -0.01882637f, -0.00009173f, -0.00941189f, -0.03047234f, -0.05309180f, -0.02407403f, 0.01191563f, 
    -0.01461348f, 0.00008690f, -0.00266744f, 0.01064765f, 0.02095374f, -0.00666518f, -0.02021214f, 0.03589770f, 
    -0.00978264f, -0.02458159f, -0.03678012f, 0.01178883f, 0.01855360f, -0.03406605f, 0.03346805f, -0.01492870f, 
    0.02257842f, -0.04148500f, 0.00229783f, -0.04077737f, -0.03901192f, -0.03049739f, 0.03796349f, 0.00392820f, 
    -0.01594844f, -0.04924716f, 0.00418070f, -0.00935231f, 0.02544749f, 0.00834181f, -0.03412287f, 0.03911638f, 
    -0.01973832f, -0.05222765f, -0.02155102f, -0.02834621f, -0.05060952f, 0.02078246f, -0.05853048f, 0.02154570f, 
    -0.04743084f, -0.03483677f, 0.01436438f, -0.02617660f, 0.04062268f, 0.02631477f, -0.01294864f, -0.04376766f, 
    -0.05980627f, 0.01066963f, 0.00917381f, 0.01661548f, -0.00565890f, -0.02193526f, 0.04106143f, -0.03672649f, 
    -0.01050049f, 0.03674999f, 0.02317596f, 0.01547428f, 0.03737736f, -0.02619119f, -0.05194979f, 0.01538487f, 
    -0.00424239f, -0.05391007f, 0.02375384f, 0.00633320f, 0.00054468f, -0.04648814f, 0.00876797f, -0.03299520f, 
    -0.03708527f, -0.03172320f, -0.02976402f, 0.03799793f, 0.00891830f, -0.03538316f, -0.02634366f, -0.03453282f, 
    -0.02763316f, -0.03061739f, -0.01185026f, -0.01567007f, 0.03822409f, -0.05965533f, -0.04754569f, 0.03424536f, 
    -0.03473186f, 0.02292643f, -0.00296438f, -0.04562435f, -0.05310304f, 0.00795514f, -0.05170494f, -0.00813286f, 
    -0.02270851f, -0.03558275f, 0.00314638f, -0.01872417f, 0.03272202f, -0.04096537f, -0.02278356f, 0.03377276f, 
    0.02866915f, -0.01320890f, 0.00452007f, -0.03192962f, -0.04245926f, -0.03789116f, 0.03657462f, -0.03964848f, 
    0.00898976f, 0.00404173f, 0.01408214f, -0.01768431f, 0.00397655f, 0.00291650f, 0.02976788f, -0.01290549f, 
    -0.04257114f, -0.03303840f, -0.00649287f, -0.02097781f, 0.01153411f, -0.05183216f, 0.02002556f, 0.01219141f, 
    -0.01458741f, -0.00978046f, -0.05754697f, -0.03820537f, -0.03868635f, 0.00203671f, 0.02396849f, -0.00126700f, 
    -0.04610668f, -0.02626481f, -0.05634950f, 0.02278260f, -0.01222611f, -0.03546745f, -0.05049055f, -0.02335867f, 
    0.02421927f, 0.00763091f, 0.04001308f, -0.03462104f, 0.00155828f, -0.02207181f, 0.01164630f, 0.02357417f, 
    -0.04410706f, 0.03671940f, 0.02413735f, -0.03903583f, 0.01008161f, -0.02378650f, 0.03202077f, 0.00542441f, 
    -0.03077125f, 0.02856074f, 0.00010862f, -0.00800801f, -0.02557197f, -0.02070711f, -0.00581510f, 0.04185415f, 
    -0.05571076f, -0.03275969f, 0.00876247f, -0.03807566f, 0.00483904f, -0.02998904f, 0.01526409f, 0.00701736f, 
    0.01412786f, -0.00203875f, -0.05916031f, -0.03090598f, -0.05303761f, 0.00514667f, -0.00150676f, -0.04362751f, 
    0.04043877f, 0.01144891f, -0.02432700f, -0.02951596f, 0.00716691f, -0.01748005f, -0.03853412f, 0.03659936f, 
    -0.05953356f, -0.00139448f, 0.03750615f, 0.03929319f, -0.04180269f, -0.02831695f, -0.04009869f, 0.02277285f, 
    0.02760082f, -0.05319304f, 0.04115235f, -0.05438455f, -0.05337366f, 0.03066285f, 0.02279336f, -0.05998219f, 
    -0.04063833f, -0.00097541f, -0.01062104f, 0.01634150f, 0.01837702f, -0.02081909f, 0.00209381f, -0.00381679f, 
    -0.00166845f, -0.00824586f, 0.00325455f, -0.03896710f, 0.00865045f, -0.05493854f, -0.00229501f, 0.03813698f, 
    -0.00967822f, 0.01400816f, -0.02404988f, -0.05010012f, 0.01846229f, -0.02911861f, -0.00472384f, -0.02729214f, 
    0.03446271f, -0.05640041f, 0.02164462f, -0.00059786f, 0.00845266f, -0.05264197f, 0.02328388f, -0.05919825f, 
    -0.03691629f, -0.03588387f, 0.00400069f, -0.02462165f, 0.01995093f, -0.04999496f, -0.02673226f, 0.02371410f, 
    -0.03112465f, 0.00973359f, -0.05594392f, -0.05103080f, -0.05387076f, -0.02151166f, -0.04155306f, -0.02403912f, 
    0.03679214f, -0.04850925f, -0.03736079f, 0.00904009f, -0.04760215f, 0.00059293f, -0.01754056f, -0.03115251f, 
    0.00277597f, 0.01470247f, -0.03829300f, -0.02877453f, -0.03738160f, -0.01068844f, -0.02586581f, -0.02135310f, 
    0.02377236f, -0.04498078f, -0.02280185f, -0.03290884f, -0.04192911f, 0.02459996f, -0.00519492f, -0.03205444f, 
    0.01364707f, 0.10048789f, -0.33189803f, -0.10701391f, -0.04724820f, -0.07094546f, 0.08176257f, -0.07762817f, 
    -0.11169276f, 0.15281618f, -0.22377926f, 0.13393590f, 0.08708283f, 0.09986845f, -0.04620479f, 0.15463288f, 
    -0.11090196f, -0.00932631f, 0.03820923f, 0.12561986f, -0.11146002f, 0.07160497f, -0.00630481f, -0.14096163f, 
    -0.12148254f, -0.19738233f, 0.12070742f, 0.12476813f, 0.09989518f, -0.01956442f, 0.11908564f, 0.07117444f, 
    -0.03087505f, -0.03566081f, -0.00235265f, 0.01838693f, 0.32281917f, 0.09148003f, -0.07805840f, 0.15345795f, 
    -0.04517632f, 0.09416772f, -0.12193576f, 0.07298924f, -0.03827874f, -0.02910874f, 0.05519033f, 0.01672725f, 
    0.00452510f, 0.06872119f, 0.09079812f, 0.03096465f, -0.07017440f, 0.10178163f, 0.06503410f, -0.11274035f, 
    -0.01398847f, 0.01194471f, -0.17648391f, 0.04237492f, 0.17700100f, -0.05477676f, -0.05262689f, 0.01345670f, 
    -0.06026861f, -0.02418697f, -0.09960778f, -0.04365000f, -0.04771170f, 0.05877757f, 0.06557737f, 0.18082364f, 
    0.14951310f, -0.01311815f, -0.24889724f, -0.10610458f, 0.05301778f, 0.05441560f, -0.03574065f, -0.06493266f, 
    -0.04737154f, 0.06470171f, 0.18679054f, 0.17473634f, -0.23199745f, -0.03049036f, -0.12639941f, -0.10670970f, 
    -0.00775544f, -0.04813050f, -0.07028271f, -0.05216461f, -0.03667144f, -0.05903942f, -0.06165909f, -0.15945375f, 
    0.09886610f, -0.06056287f, 0.20104828f, 0.15401740f, -0.04590183f, -0.05055011f, 0.14615275f, 0.01927247f, 
    0.06068373f, -0.08319538f, -0.03778954f, -0.22368538f, -0.05829260f, -0.01441690f, -0.10282765f, -0.05387449f, 
    -0.06520142f, -0.07033944f, 0.08115847f, 0.11927675f, 0.17777273f, 0.22530015f, 0.11210827f, 0.14232425f, 
    0.07623004f, 0.09288310f, 0.02466355f, 0.08338900f, -0.04934245f, 0.01072487f, -0.12455073f, 0.02891325f, 
    -0.01411497f, 0.06408497f, 0.01923789f, 0.06306114f, 0.26542553f, -0.05393243f, 0.17878269f, -0.13619366f, 
    -0.03512761f, 0.14356616f, 0.00911552f, 0.04543376f, -0.04498868f, -0.06763306f, -0.03813367f, -0.09007922f, 
    0.03246949f, -0.07118950f, 0.19626406f, -0.10532814f, -0.06110853f, 0.05123228f, -0.01970318f, 0.16867030f, 
    0.01357514f, 0.03149707f, -0.13132732f, 0.19979614f, -0.23000580f, -0.06712333f, -0.04470329f, 0.21481286f, 
    -0.07544126f, 0.00103788f, 0.02668625f, 0.02327283f, -0.02317159f, -0.13852322f, 0.17062005f, 0.12961836f, 
    -0.08930201f, -0.18303636f, 0.14429411f, -0.08629995f, 0.03371051f, 0.03589623f, 0.10713939f, -0.08427168f, 
    -0.02844956f, -0.02122094f, -0.13293165f, -0.03219496f, 0.11628855f, -0.22750029f, -0.02054089f, -0.14983892f, 
    0.00270453f, 0.08004591f, 0.10340072f, -0.13134491f, 0.15165895f, 0.19990829f, 0.13530451f, 0.04929410f, 
    -0.02112604f, 0.02616329f, -0.22474594f, -0.09344520f, 0.02317833f, 0.09477188f, -0.08629135f, -0.16037373f, 
    -0.02322870f, 0.02477578f, 0.05753466f, 0.15837196f, 0.08532971f, 0.05466327f, -0.02218188f, -0.03884998f, 
    0.00313009f, 0.18109499f, -0.12724009f, -0.08308383f, -0.00535918f, 0.02558476f, 0.10618926f, -0.01612031f, 
    -0.03374602f, 0.14206116f, -0.05197337f, 0.05086958f, 0.03526611f, -0.13284223f, 0.09010885f, -0.19945823f, 
    -0.10796183f, -0.25833854f, -0.13870196f, -0.10243290f, 0.22901438f, -0.07037305f, 0.16596353f, 0.09988898f, 
    0.03340402f, 0.03494287f, 0.10799160f, 0.12427960f, -0.02593939f, 0.04318238f, 0.01580648f, 0.06574968f, 
    0.28103387f, 0.21788885f, -0.17923696f, -0.00536815f, 0.06149886f, 0.01587128f, 0.01493360f, -0.01265427f, 
    0.03058594f, 0.04057194f, -0.12735665f, -0.17705283f, -0.21761757f, -0.03718913f, -0.06934080f, -0.12720318f, 
    -0.19927035f, 0.09728620f, -0.12979800f, 0.05491012f, 0.05089680f, -0.08027940f, -0.33130670f, -0.34923059f, 
    0.00461473f, 0.28967020f, -0.04724824f, 0.02899080f, 0.06133203f, 0.02272659f, 0.01825025f, -0.06894647f, 
    0.02950943f, 0.22921143f, -0.02257588f, -0.01419855f, 0.19148035f, 0.04866016f, -0.05578361f, 0.10188930f, 
    0.03178761f, -0.01036930f, 0.02845901f, 0.09221917f, 0.04079634f, 0.13321276f, 0.06787602f, 0.00750216f, 
    0.09494149f, -0.08527261f, -0.04701210f, -0.00409188f, 0.03237999f, 0.04262481f, -0.14077607f, -0.05544314f, 
    -0.22713950f, 0.06821211f, -0.06876013f, 0.04424832f, 0.62185156f, -0.09621269f, -0.08070911f, -0.08147528f, 
    0.07432558f, 0.04616379f, -0.09847193f, 0.17047566f, -0.18501142f, -0.01807369f, 0.01149833f, 0.14015147f, 
    0.38075253f, -0.15146555f, -0.06291538f, -0.04921218f, -0.11456195f, 0.02911018f, 0.20720384f, 0.02233612f, 
    0.06477984f, 0.01505464f, -0.23689796f, 0.17422031f, 0.00015524f, 0.08743162f, 0.04771268f, -0.06420476f, 
    -0.00549310f, 0.03933411f, -0.13846673f, -0.08344884f, -0.01671091f, 0.07386255f, 0.11056636f, -0.14070004f, 
    0.28370479f, 0.01100020f, 0.15446211f, 0.20338047f, -0.06589732f, 0.00922724f, 0.13200420f, 0.08797977f, 
    -0.11348157f, 0.13773863f, 0.00940919f, -0.04978163f, 0.26389280f, -0.19930084f, 0.02570613f, -0.09765789f, 
    0.03661121f, 0.02222918f, -0.05231841f, 0.06427167f, 0.08995422f, -0.22499306f, 0.21074988f, 0.13339150f, 
    0.11025144f, 0.19868077f, 0.10943583f, 0.00831567f, -0.00851275f, 0.07043236f, -0.08768183f, -0.18786833f, 
    -0.03623422f, -0.16732167f, -0.15854870f, -0.27097166f, 0.32170489f, 0.10847102f, 0.12243532f, 0.04063486f, 
    0.01309071f, 0.05211814f, -0.13539732f, -0.03214084f, -0.03780815f, 0.01851384f, -0.02596042f, -0.05269180f, 
    0.09531187f, 0.41323307f, 0.11998772f, -0.10785959f, -0.10230681f, 0.08571606f, 0.01906969f, -0.02007503f, 
    0.04574521f, 0.00939677f, -0.05202010f, -0.01359205f, 0.18665940f, 0.00480360f, -0.07845531f, 0.08582597f, 
    0.13308412f, 0.12625968f, 0.08257755f, 0.10124347f, 0.03913867f, -0.03153602f, 0.06217757f, 0.04359906f, 
    -0.21261083f, 0.06044846f, -0.34292269f, 0.14021958f, 0.03396111f, 0.07527190f, 0.08848262f, 0.01885714f, 
    0.04083500f, 0.03159249f, -0.02455720f, -0.07638855f, -0.08798602f, 0.02426833f, 0.13432691f, 0.14698808f, 
    0.06528447f, -0.02273615f, 0.16779818f, 0.00304470f, -0.02647686f, -0.08481574f, 0.00070475f, -0.11643060f, 
    0.18108541f, -0.22945081f, 0.03633534f, -0.01353764f, 0.11625231f, -0.01631522f, 0.03909492f, -0.05169290f, 
    -0.00083497f, -0.00672885f, 0.01168077f, 0.01094224f, -0.14140002f, -0.06544687f, 0.21083495f, 0.05934073f, 
    -0.06824081f, 0.05340671f, -0.01006037f, 0.10730631f, 0.03483579f, -0.04192136f, -0.06757258f, 0.00054280f, 
    -0.21119605f, 0.02402579f, -0.07120300f, -0.03508959f, -0.02302964f, 0.16164045f, -0.02683184f, -0.05787107f, 
    -0.18849136f, -0.09221394f, 0.01298005f, 0.14142084f, 0.08380681f, 0.24901247f, -0.28877041f, 0.01150879f, 
    -0.21297327f, 0.04235990f, -0.05961286f, 0.05622864f, 0.04466098f, 0.12636444f, -0.05925896f, -0.00778945f, 
    -0.02471214f, -0.11746921f, 0.18301046f, 0.06228949f, -0.07487928f, 0.00735001f, 0.03583512f, 0.10678172f, 
    -0.05461571f, -0.16810900f, 0.03702822f, -0.07907512f, -0.02236589f, 0.25928932f, 0.08911402f, 0.15168609f, 
    0.00867254f, -0.00453113f, 0.11374101f, 0.02061213f, 0.02513951f, 0.05994186f, 0.02538764f, 0.08274568f, 
    -0.06196103f, 0.02479493f, 0.21516384f, 0.04202494f, -0.09931415f, -0.05807126f, 0.01422447f, -0.11653455f, 
    -0.07936481f, 0.05496042f, 0.03102423f, 0.08967370f, -0.28416416f, -0.11672858f, -0.12837349f, -0.01644704f, 
    0.14160210f, 0.08633383f, -0.02029573f, 0.04039862f, 0.06827746f, 0.11442277f, 0.09229852f, 0.12498847f, 
    -0.03541889f, -0.10728513f, -0.03167741f, -0.06159841f, 0.21054989f, 0.12073497f, -0.05775230f, 0.14973412f, 
    0.02092147f, 0.18406625f, 0.13183141f, 0.16394544f, 0.18969043f, 0.13605319f, 0.02604326f, 0.07821416f, 
    0.06126579f, 0.05517655f, 0.06970453f, 0.11466005f, 0.10270848f, 0.07982652f, 0.03746406f, 0.11852271f, 
    -0.06489336f, -0.34571126f, 0.17606974f, 0.06276850f, 0.18568915f, 0.03370793f, 0.10407500f, 0.04477241f, 
    -0.09886889f, 0.16678622f, 0.06641973f, 0.07591589f, 0.17686103f, 0.00986529f, 0.05984702f, 0.19642739f, 
    -0.01628564f, -0.01402123f, 0.09403887f, -0.18673135f, 0.06805397f, 0.00581943f, 0.08340500f, 0.12436647f, 
    -0.20772651f, 0.32432884f, -0.11645927f, 0.17197296f, 0.02924133f, 0.08150879f, -0.08505970f, -0.08604650f, 
    0.01390473f, -0.12200698f, -0.05260585f, 0.04654010f, -0.32820964f, -0.23299888f, 0.34588048f, -0.04019798f, 
    -0.11187384f, 0.04482013f, -0.01483261f, -0.11843689f, -0.09599698f, 0.01598722f, -0.07735573f, -0.05148368f, 
    0.23662755f, -0.28586975f, -0.07142587f, 0.08085860f, 0.02767523f, -0.01469681f, 0.02727091f, 0.04429180f, 
    0.02115923f, -0.04984263f, 0.09898324f, -0.07331166f, 0.02293103f, 0.25752446f, 0.00923868f, 0.05860221f, 
    0.09054570f, -0.09004504f, 0.06075103f, 0.09975267f, -0.00747660f, -0.00960633f, 0.10725605f, -0.03423617f, 
    -0.12396927f, 0.27608469f, -0.23702492f, -0.41909471f, -0.09691706f, -0.02815976f, -0.00366114f, 0.11653978f, 
    -0.03939750f, -0.09054985f, -0.00769717f, -0.00610496f, -0.01620660f, -0.24353437f, 0.05221129f, 0.16646597f, 
    0.06595352f, 0.04151975f, 0.04140471f, 0.08542794f, -0.07069894f, -0.04068496f, -0.01257028f, -0.06759506f, 
    -0.31149253f, -0.00370186f, 0.22754852f, 0.13311000f, -0.10029913f, -0.01271627f, 0.00772142f, 0.21099104f, 
    0.01039639f, -0.00169749f, -0.09088923f, -0.04370613f, 0.34790742f, -0.29991871f, -0.21046443f, 0.15427405f, 
    -0.08021045f, 0.07765751f, -0.01894158f, 0.07515544f, 0.09369363f, 0.00546446f, 0.03410222f, -0.01636389f, 
    0.24607751f, 0.21596269f, -0.09369933f, 0.06984581f, 0.06642071f, 0.05313676f, -0.09014915f, -0.01472442f, 
    -0.00660545f, 0.17523374f, -0.06061249f, 0.10723931f, 0.13506784f, -0.26384649f, -0.01451856f, -0.07417124f, 
    0.06549505f, 0.00613632f, 0.17065208f, -0.10340921f, 0.08096644f, -0.03710466f, 0.04900697f, 0.08238912f, 
    0.48268890f, -0.22831137f, 0.16435124f, 0.17762151f, 0.00308114f, -0.04278217f, 0.16562012f, -0.06506881f, 
    -0.10998323f, 0.06122234f, 0.00171436f, 0.11034265f, -0.18142225f, 0.19010377f, 0.17750895f, -0.02134191f, 
    0.00873614f, 0.04165764f, -0.02292233f, -0.05849016f, -0.11592250f, -0.02837010f, 0.01499079f, -0.01376129f, 
    0.27109486f, -0.14685839f, 0.09121541f, 0.11189011f, -0.01028900f, 0.04723697f, -0.05235655f, 0.04061351f, 
    0.22369504f, 0.21168169f, 0.01732161f, -0.00535404f, 0.18177444f, 0.14988421f, -0.25803435f, 0.04353351f, 
    0.00188782f, 0.14071254f, 0.13924764f, 0.07511689f, 0.06275507f, -0.10652424f, 0.00591902f, 0.01612388f, 
    -0.20864499f, 0.12894531f, 0.27041727f, -0.27842674f, -0.19916040f, -0.02920913f, -0.01555942f, -0.05606101f, 
    0.05249812f, -0.04237303f, -0.13681276f, -0.17393456f, -0.41796225f, -0.28506386f, 0.38768262f, 0.00096124f, 
    0.19594157f, 0.07725277f, -0.08453913f, -0.03449755f, 0.03181408f, 0.05115364f, -0.02660660f, 0.07159720f, 
    0.21730569f, -0.16106987f, -0.09574808f, 0.00811902f, 0.05276801f, 0.01263469f, -0.07908027f, -0.08864513f, 
    0.04022444f, -0.02380349f, -0.19602819f, -0.06827649f, 0.22788371f, 0.10464105f, 0.01424133f, 0.07506571f, 
    -0.06058983f, -0.08965195f, 0.09723254f, 0.10888788f, -0.08551954f, -0.03399797f, 0.10070658f, -0.03102423f, 
    -0.13040635f, -0.07992069f, -0.07891760f, -0.02321702f, 0.01858853f, 0.02939338f, 0.04963062f, -0.06845214f, 
    -0.02414930f, 0.14016160f, 0.06941712f, 0.06009814f, 0.17274821f, -0.01147292f, -0.01371644f, -0.10075963f, 
    -0.07626065f, -0.01216379f, -0.11125971f, 0.17623903f, 0.08850893f, -0.04354282f, 0.03259132f, -0.06645259f, 
    -0.08958375f, -0.10231821f, 0.13409929f, -0.18684216f, 0.12482380f, -0.01932215f, 0.02302412f, -0.06711574f, 
    -0.00816306f, -0.01450696f, -0.12880750f, -0.06033451f, 0.08408175f, 0.33482251f, 0.02421547f, 0.15409370f, 
    0.01298024f, -0.11564801f, -0.05674930f, 0.02819823f, -0.04542128f, 0.12404869f, 0.00430069f, 0.10799958f, 
    -0.07218222f, -0.10286824f, -0.11321086f, 0.03342916f, 0.04397498f, -0.06738077f, -0.09276437f, -0.11624588f, 
    0.08273187f, -0.05209161f, 0.12944329f, 0.06153343f, 0.04025538f, -0.15175593f, -0.24199818f, -0.02301785f, 
    -0.02926486f, 0.00169256f, 0.01188594f, 0.04756386f, -0.07741486f, 0.07947959f, 0.00326468f, -0.13158090f, 
    0.35773593f, -0.02238406f, 0.08242439f, 0.21334027f, 0.05081012f, -0.02487961f, 0.01488685f, 0.00422379f, 
    0.08129966f, -0.07989698f, 0.05425083f, -0.12536272f, 0.04383441f, 0.06646800f, -0.03624293f, -0.10316101f, 
    -0.11741976f, 0.03486350f, 0.10204720f, 0.08765209f, 0.13690268f, 0.15894161f, 0.18834038f, 0.20557287f, 
    0.22204839f, -0.27935892f, 0.13248773f, -0.02071920f, 0.09562416f, -0.05034675f, -0.05021678f, 0.07355855f, 
    0.04847293f, 0.01199144f, 0.07940077f, -0.04093903f, -0.04556127f, 0.19088918f, 0.14447834f, 0.20027867f, 
    -0.01450132f, 0.07811501f, 0.02551368f, -0.04194578f, -0.15665045f, 0.04459875f, -0.00862367f, -0.08880942f, 
    -0.36472839f, -0.16566287f, 0.14576367f, 0.12889856f, 0.03600069f, -0.13989960f, -0.06211619f, -0.03962458f, 
    -0.02112611f, 0.13170213f, 0.01297501f, 0.22229727f, -0.13409412f, 0.12986690f, -0.04583258f, 0.11605829f, 
    -0.04936559f, 0.02617468f, 0.07574555f, -0.04634194f, -0.10094320f, -0.13872780f, 0.04318623f, 0.14366990f, 
    0.00529380f, 0.11527997f, 0.10201479f, 0.01530796f, -0.02674172f, -0.04995403f, 0.05013441f, 0.10369569f, 
    0.10181122f, 0.00887933f, 0.02851404f, 0.09021947f, -0.27507502f, -0.08005686f, 0.04882416f, -0.12078410f, 
    0.10265713f, -0.04862043f, 0.09971857f, -0.06032563f, 0.00786445f, 0.10328811f, 0.06175466f, 0.15754569f, 
    -0.13326262f, -0.22113359f, -0.01448282f, 0.06024927f, 0.13878652f, -0.01551167f, 0.09890485f, 0.00685439f, 
    -0.03711180f, -0.04537178f, 0.13080499f, 0.01201976f, 0.07021709f, -0.05269137f, -0.19797465f, 0.07653835f, 
    -0.08932453f, 0.08533119f, 0.03208578f, 0.01779181f, -0.01744679f, 0.04793932f, 0.03497345f, 0.03998525f, 
    -0.16572408f, 0.06846051f, 0.01966518f, 0.03591100f, 0.04305376f, -0.01849451f, 0.10950450f, -0.02659364f, 
    -0.05219584f, -0.14329487f, -0.18411906f, -0.23145100f, 0.29673463f, -0.11000527f, 0.07763909f, -0.10289692f, 
    -0.02187881f, 0.07910119f, 0.01222338f, 0.08404873f, 0.01932486f, 0.05869192f, -0.02870814f, 0.04034486f, 
    -0.00487000f, -0.07093275f, -0.11838935f, -0.10065421f, -0.02333338f, -0.07552285f, 0.04025333f, 0.05757891f, 
    0.08264298f, 0.03073577f, 0.01932921f, -0.04359125f, 0.06007819f, 0.13838282f, 0.08415703f, 0.19672081f, 
    -0.06691844f, 0.10598058f, 0.13797531f, -0.00416438f, 0.06326806f, -0.01250665f, -0.22719875f, -0.17639603f, 
    -0.05424570f, -0.09183924f, -0.07454113f, -0.01184292f, -0.02393425f, 0.09805581f, -0.02693777f, 0.15507616f, 
    0.07834953f, 0.10133399f, -0.11069018f, 0.02801236f, -0.18134925f, 0.00701163f, 0.15810211f, 0.21194330f, 
    -0.04044968f, 0.06512828f, -0.01698058f, 0.10349075f, 0.04212782f, -0.00236094f, 0.08927833f, 0.00807400f, 
    0.23057778f, -0.06559405f, -0.02398929f, -0.20615053f, 0.03027224f, 0.03404098f, 0.01832581f, 0.01550329f, 
    -0.11725427f, 0.03024024f, -0.03013882f, 0.01316535f, -0.03362627f, -0.10678345f, -0.21464972f, 0.07600899f, 
    0.06923652f, 0.03009233f, -0.04812650f, -0.00914563f, -0.11040454f, -0.08007051f, -0.00852544f, 0.00657887f, 
    -0.06215666f, -0.05463107f, 0.04613052f, -0.03552844f, 0.01914919f, -0.10191259f, 0.19662564f, 0.07389029f, 
    -0.00761430f, 0.08797047f, -0.12185284f, 0.21823075f, 0.14895879f, 0.13001664f, 0.02095697f, -0.09541970f, 
    -0.16027094f, -0.04824051f, -0.01407651f, 0.04847158f, 0.03229709f, 0.01582831f, -0.00893792f, -0.06015804f, 
    -0.06574057f, 0.10673400f, 0.10991559f, 0.16216278f, -0.05229468f, -0.06559600f, 0.05721741f, 0.18455441f, 
    0.03515521f, 0.10167171f, 0.09687196f, -0.03736745f, 0.03178947f, -0.13305318f, 0.00538764f, -0.16862556f, 
    0.11115577f, -0.04606243f, -0.00149973f, 0.12455052f, 0.14980498f, -0.04399373f, 0.16809389f, 0.26885074f, 
    0.07820462f, 0.07082491f, -0.04716243f, -0.07470191f, -0.14003839f, 0.02716223f, -0.08705816f, -0.04360338f, 
    -0.02455607f, -0.12557276f, -0.06998462f, -0.32400250f, 0.12998329f, -0.21210313f, 0.19695061f, 0.12414807f, 
    0.13365459f, -0.08805247f, -0.05791623f, 0.03716210f, 0.17484520f, 0.08707522f, -0.04930770f, -0.09642641f, 
    -0.03849525f, -0.05177605f, 0.00033447f, 0.01819913f, 0.02272024f, 0.03117110f, -0.02246267f, 0.02431547f, 
    -0.05373125f, 0.00431751f, 0.01192608f, -0.02020464f, -0.03400565f, -0.03544488f, 0.02815027f, 0.00178047f, 
    -0.03629242f, 0.01597517f, 0.01991692f, 0.00453659f, -0.02857481f, -0.01486089f, 0.01256227f, 0.02419744f, 
    0.03187132f, -0.03062137f, 0.01904076f, -0.03087804f, -0.04824447f, 0.03028413f, -0.04435653f, -0.02693724f, 
    0.01901894f, -0.02074403f, 0.00715584f, 0.02820160f, 0.04140152f, -0.02835461f, 0.03940267f, -0.02196168f, 
    0.03913309f, -0.03771047f, -0.03394461f, -0.02581954f, 0.01377128f, 0.00731648f, -0.04646727f, -0.01956373f, 
    -0.00680642f, 0.03482699f, -0.02630454f, 0.04277628f, 0.03561652f, 0.04077643f, -0.03330812f, -0.00317184f, 
    0.03211529f, 0.02371684f, -0.05348368f, -0.04240691f, -0.03799835f, -0.06262422f, 0.02726208f, 0.05516947f, 
    -0.00662061f, -0.04491825f, 0.00887085f, -0.05122974f, -0.06560881f, 0.01470549f, -0.00215221f, 0.01953463f, 
    0.04899179f, -0.03416388f, 0.00295321f, 0.02893876f, -0.04599296f, 0.01460222f, 0.02558040f, 0.00762709f, 
    -0.04040573f, 0.02330566f, -0.00291830f, 0.02674961f, 0.01630308f, 0.03471191f, 0.01261884f, 0.02176746f, 
    0.03546389f, 0.01139488f, -0.04609735f, -0.00597088f, -0.04339502f, 0.00062814f, -0.01739288f, -0.02331366f, 
    -0.01564339f, -0.00417419f, 0.01254653f, -0.01050195f, -0.01941805f, 0.00570812f, -0.04331600f, -0.05096314f, 
    -0.05782726f, -0.05758613f, -0.00177053f, 0.01447269f, -0.02748766f, 0.00617105f, -0.01717527f, 0.01635946f, 
    0.03190813f, -0.06679669f, -0.04011909f, 0.03944402f, -0.03143602f, 0.03904153f, -0.00357147f, -0.01304129f, 
    -0.04808373f, -0.00775706f, 0.03278478f, -0.04403830f, 0.01461458f, -0.01992494f, -0.02195980f, -0.05401235f, 
    0.03148527f, -0.00183244f, -0.02176508f, 0.04072657f, -0.01036973f, 0.00630185f, 0.02253836f, -0.03189870f, 
    -0.01281894f, -0.04508867f, -0.02548087f, 0.03455545f, 0.02375042f, 0.00158314f, 0.02052426f, 0.01188820f, 
    0.03483095f, -0.04561638f, -0.03418637f, 0.00538205f, 0.04005274f, -0.02981990f, 0.02573547f, 0.02058174f, 
    0.00273270f, -0.03760283f, 0.03206553f, -0.00749254f, 0.01422664f, 0.00493167f, 0.00889726f, 0.03358121f, 
    -0.02525866f, -0.00301791f, 0.04800761f, 0.03452737f, 0.00135907f, -0.02241271f, -0.00123164f, 0.03474762f, 
    0.02588295f, 0.03925741f, 0.01853796f, -0.02085068f, 0.01598115f, -0.04362832f, 0.00649262f, 0.00509745f, 
    0.02737169f, -0.00086687f, -0.04603901f, 0.00728467f, 0.01380783f, -0.00180376f, 0.02642458f, -0.05326804f, 
    0.03656431f, 0.02503490f, 0.02145114f, -0.04390071f, 0.00894760f, 0.02850991f, 0.00833662f, 0.02779728f, 
    0.03570148f, -0.03682937f, 0.01892182f, -0.04399760f, -0.02250053f, 0.00046321f, -0.02087487f, 0.04008235f, 
    -0.00570438f, -0.03101633f, 0.00701499f, -0.04588305f, -0.02152784f, -0.01696775f, -0.00611882f, 0.02008875f, 
    0.02019551f, -0.02402216f, -0.04011121f, 0.03481681f, 0.02784066f, -0.04293031f, -0.04379873f, 0.03856523f, 
    -0.02293989f, -0.02751888f, -0.01979706f, 0.04730749f, -0.04938019f, -0.01972799f, 0.02925048f, -0.01261420f, 
    0.01765509f, 0.01956109f, -0.00943485f, -0.03779356f, 0.03014279f, 0.03507606f, 0.03408571f, -0.02237815f, 
    0.04206875f, 0.03989083f, 0.00370989f, -0.04915866f, -0.01301806f, -0.03641927f, 0.02439520f, 0.02501240f, 
    -0.01695035f, -0.03971504f, -0.03168632f, -0.02741870f, -0.01504973f, -0.00326707f, 0.03806269f, -0.01162442f, 
    -0.05630050f, -0.04374013f, 0.00433942f, 0.02671897f, 0.01242228f, -0.02592481f, 0.01975258f, -0.01854221f, 
    0.06335951f, 0.03111752f, 0.03527217f, -0.01215054f, -0.06144621f, -0.06115591f, 0.00929572f, -0.05768691f, 
    -0.02418841f, 0.04372193f, -0.04048775f, 0.01702195f, -0.00323597f, -0.02600563f, 0.01571682f, -0.05169677f, 
    0.00721101f, 0.04467717f, 0.00296702f, -0.05675936f, -0.05830068f, -0.05501254f, -0.02309972f, -0.03668269f, 
    -0.01330885f, -0.02938718f, -0.01985244f, 0.04826609f, 0.01199635f, 0.02515798f, -0.05848409f, -0.02668232f, 
    -0.03504552f, -0.03088002f, -0.01587077f, 0.02721312f, -0.05039737f, -0.03646138f, -0.01694677f, -0.02334319f, 
    -0.04297412f, 0.00583837f, -0.00130471f, 0.03911519f, 0.00636286f, -0.04930781f, 0.04784333f, -0.00024502f, 
    -0.01270105f, 0.01186220f, -0.03559550f, -0.04751709f, -0.02573919f, 0.00976652f, -0.04611264f, 0.01608103f, 
    0.01570465f, -0.02161634f, -0.03368245f, 0.03470147f, -0.03271665f, -0.03300346f, -0.01356728f, 0.01493550f, 
    -0.02773241f, -0.03030979f, 0.02560884f, -0.04134024f, 0.04002916f, -0.01322556f, 0.02329358f, 0.00211078f, 
    0.02535373f, -0.01663084f, 0.00287951f, 0.03121368f, 0.00113815f, -0.02856166f, -0.05251205f, 0.00866231f, 
    -0.00682352f, 0.03189750f, -0.00846337f, 0.03809140f, -0.02810915f, -0.01027984f, -0.02642673f, 0.02132726f, 
    -0.05148366f, -0.04422976f, -0.00361641f, -0.03261681f, -0.04339180f, -0.03660309f, -0.01136594f, 0.02290801f, 
    -0.02414400f, -0.00879765f, 0.03110692f, -0.01038518f, -0.01051377f, -0.01910871f, 0.01355306f, 0.01922920f, 
    0.02856401f, 0.02466924f, 0.02618166f, -0.03191191f, 0.01218754f, -0.02660100f, 0.02435798f, 0.02393983f, 
    -0.01483105f, 0.03874479f, -0.06049388f, -0.03641524f, -0.01014791f, 0.04414450f, -0.04735439f, 0.04097021f, 
    -0.00150769f, 0.03981293f, -0.06059533f, 0.02399864f, -0.01772927f, -0.05448727f, -0.04255315f, -0.06170662f, 
    0.00020009f, -0.02899535f, 0.02866941f, 0.00920846f, 0.02356991f, 0.01239150f, 0.00251512f, -0.03142764f, 
    -0.03813037f, 0.00485256f, -0.01433110f, 0.02438890f, -0.05150098f, -0.04119111f, -0.02667667f, -0.03691207f, 
    0.02046303f, -0.02532326f, -0.03648458f, 0.02113906f, 0.03864874f, 0.00826752f, -0.01136004f, 0.03334465f, 
    -0.02087170f, -0.00536300f, -0.02759713f, 0.01026437f, -0.01996190f, 0.03367912f, -0.00260645f, -0.02984620f, 
    0.03539217f, -0.00850912f, -0.00174262f, 0.03892965f, 0.00282997f, 0.01597985f, -0.04523955f, -0.01691995f, 
    -0.02950938f, 0.02435083f, -0.01408322f, -0.00672742f, -0.03972831f, 0.02852520f, 0.03519494f, -0.02730343f, 
    -0.02944560f, 0.03528514f, -0.04648672f, -0.03950576f, -0.00713338f, -0.02621793f, 0.02464404f, 0.02097108f, 
    -0.01628714f, -0.04402654f, -0.01851169f, 0.02395536f, 0.04484372f, 0.03553862f, -0.02441286f, 0.02111275f, 
    -0.01995646f, -0.00022869f, 0.00846475f, 0.04440049f, -0.03312796f, 0.02116406f, -0.02037421f, -0.01948998f, 
    0.01495043f, 0.03536221f, -0.01081962f, -0.00171474f, -0.04683577f, -0.03473967f, -0.00312676f, -0.04432385f, 
    -0.04140903f, 0.03579209f, -0.01453624f, 0.00473987f, -0.05099173f, -0.04202857f, 0.02561005f, -0.02019134f, 
    -0.00192143f, 0.02859753f, -0.05450187f, -0.01931710f, 0.01932830f, 0.01037184f, -0.02622472f, -0.01822700f, 
    0.03203582f, -0.03097125f, -0.00513665f, 0.04288618f, -0.02049077f, -0.01940144f, -0.04414143f, -0.01399232f, 
    0.01831118f, 0.03344794f, -0.05174894f, 0.00125609f, -0.03778164f, -0.02306210f, -0.03469921f, 0.02036430f, 
    0.00736304f, 0.03167854f, -0.00974249f, -0.02567852f, -0.03391374f, -0.01507602f, -0.03740038f, -0.02511624f, 
    -0.02476836f, 0.03186812f, -0.05574419f, 0.00615629f, 0.02693412f, -0.04712675f, -0.00200630f, 0.01881195f, 
    -0.03767587f, 0.01328443f, 0.03975428f, 0.04359875f, 0.00505583f, 0.01008904f, -0.04776217f, 0.03903979f, 
    0.04024914f, 0.03772213f, 0.02397641f, -0.05545476f, 0.01716947f, -0.00610590f, -0.02930492f, -0.02174825f, 
    -0.03841946f, -0.00259155f, -0.02139324f, 0.01888966f, 0.03891062f, 0.04355071f, -0.02330831f, -0.00183408f, 
    -0.01363134f, -0.01262513f, -0.05185118f, 0.04071755f, -0.04721664f, -0.03456349f, -0.03716403f, -0.05371373f, 
    0.01552610f, -0.03770719f, 0.02279647f, -0.03815855f, 0.01819816f, -0.00028814f, -0.01821202f, -0.02364091f, 
    0.03356538f, -0.03232747f, -0.04352265f, -0.00012952f, 0.02253420f, -0.01124063f, -0.03319447f, -0.01634770f, 
    -0.03498113f, 0.00618610f, -0.00866880f, 0.01191693f, 0.00838300f, -0.02565715f, -0.04445211f, -0.02825475f, 
    -0.03177522f, -0.05449074f, 0.00847224f, -0.01437551f, -0.05591161f, 0.03844705f, -0.02004540f, 0.01942905f, 
    0.01775243f, -0.01344191f, 0.01189748f, 0.01590329f, 0.01284294f, 0.01460521f, -0.02873964f, 0.01111575f, 
    -0.04642384f, -0.02448593f, 0.00226382f, 0.01318568f, -0.03186821f, -0.00477101f, -0.02246577f, -0.02211956f, 
    0.01240191f, 0.02109147f, -0.04662552f, -0.05580369f, -0.04488612f, 0.01071530f, -0.00278955f, 0.00902691f, 
    0.02411262f, -0.03090685f, 0.02585891f, -0.04783285f, 0.02359771f, 0.00700188f, -0.02635394f, -0.03735997f, 
    0.02582031f, -0.01691643f, 0.02738596f, 0.04419871f, 0.04072765f, 0.02979391f, -0.03823572f, -0.01134790f, 
    0.04205759f, -0.01536122f, 0.01684601f, 0.03412241f, -0.01139743f, -0.03956397f, 0.00600288f, -0.01720868f, 
    -0.03966423f, -0.01043284f, -0.00562287f, 0.00823416f, 0.05082067f, -0.01794763f, -0.05472156f, -0.05308663f, 
    0.01484633f, -0.01578568f, -0.04808826f, -0.03308102f, 0.03470989f, 0.01721165f, 0.02830077f, -0.02314080f, 
    0.04193738f, -0.03134405f, -0.05506030f, -0.01272349f, -0.04562876f, 0.04058476f, -0.01234761f, 0.02098109f, 
    0.02281540f, -0.03323862f, -0.04396252f, -0.02805392f, 0.02888689f, -0.05134564f, 0.01204344f, -0.01922455f, 
    0.03382833f, -0.04982654f, 0.01205826f, -0.02875737f, -0.02665498f, -0.04449736f, -0.01502735f, 0.00617615f, 
    0.02029467f, 0.02104502f, 0.03903360f, -0.03132627f, -0.03469864f, 0.03379519f, -0.01597137f, 0.04488014f, 
    -0.04055507f, 0.00411478f, -0.02050089f, 0.00719454f, 0.03529061f, 0.01789937f, -0.00446533f, -0.00855212f, 
    -0.05143514f, 0.01607848f, 0.00033877f, -0.03556898f, 0.02170554f, 0.04298334f, -0.01878320f, 0.03705148f, 
    0.04266353f, -0.00329345f, -0.00941654f, 0.01638452f, 0.03985120f, -0.03933965f, 0.01143388f, -0.01057791f, 
    0.03122353f, 0.03941889f, -0.04351521f, 0.03365750f, -0.03490410f, -0.00371870f, 0.02643828f, -0.05451797f, 
    0.04247584f, -0.02812394f, -0.05595145f, -0.00854043f, -0.05314783f, -0.00960187f, 0.03462192f, -0.01008451f, 
    -0.00028269f, -0.03640127f, -0.01571405f, -0.01190830f, 0.01537735f, -0.03092973f, 0.00758079f, 0.04508488f, 
    0.02385083f, -0.02991187f, -0.03912194f, -0.02209712f, 0.00802580f, -0.02240609f, 0.00638467f, -0.05300640f, 
    -0.03492659f, -0.03923393f, -0.00143134f, -0.04808187f, -0.01509892f, -0.05260003f, -0.01986561f, -0.01508173f, 
    -0.02880451f, -0.04885038f, 0.03049216f, 0.00329300f, -0.00694802f, -0.04349299f, -0.01454673f, 0.00504361f, 
    0.03336096f, -0.01779179f, -0.02754292f, 0.01957760f, 0.03157876f, -0.01719230f, -0.02935402f, -0.02307520f, 
    -0.02853134f, -0.02049631f, -0.01258500f, -0.01033435f, -0.04798339f, 0.02048352f, -0.00925743f, -0.01800750f, 
    -0.00582904f, 0.01417471f, -0.02870755f, 0.02403329f, -0.03171669f, -0.02021388f, 0.04080889f, -0.05538148f, 
    0.12956697f, 0.20254366f, -0.19766812f, -0.08535701f, 0.07405850f, 0.04647263f, 0.00481148f, -0.06156151f, 
    -0.07247771f, 0.12436221f, -0.03765724f, 0.05067937f, 0.09933415f, -0.14591715f, 0.04087098f, 0.06849643f, 
    -0.12193459f, 0.10111530f, 0.03329365f, 0.05922045f, -0.08696647f, 0.04380590f, 0.05441764f, -0.00470483f, 
    0.33131066f, -0.02835176f, -0.00144790f, 0.42781195f, 0.04576399f, -0.07349572f, 0.01872125f, 0.06710405f, 
    -0.00491003f, -0.00355877f, 0.01697827f, 0.03794889f, 0.11316754f, -0.06118455f, -0.01759665f, 0.00770539f, 
    0.02467966f, 0.06183354f, 0.02905644f, 0.13006571f, 0.00391936f, -0.09494700f, -0.05034984f, 0.04861848f, 
    0.09626097f, 0.24996701f, 0.18489332f, 0.05102986f, 0.02822171f, 0.01428468f, 0.02317828f, -0.04813582f, 
    -0.13654655f, 0.05108706f, 0.04208631f, 0.04864418f, 0.21441899f, 0.13090865f, -0.10370756f, 0.09602647f, 
    -0.08282422f, 0.03764685f, -0.05848288f, -0.06999581f, 0.03156289f, 0.13926081f, 0.03739798f, 0.06071189f, 
    0.12749058f, 0.03748484f, -0.11878052f, -0.16406134f, 0.05774847f, 0.15566255f, 0.04712687f, -0.04665275f, 
    0.15621482f, 0.09259131f, 0.08746060f, -0.01658221f, -0.12001672f, -0.07961278f, -0.21346296f, -0.03200668f, 
    0.06064175f, -0.00757244f, -0.02821447f, 0.03615951f, -0.04229910f, 0.04587182f, -0.02711236f, -0.02244126f, 
    -0.02275754f, 0.08556761f, 0.31074834f, -0.12488147f, -0.04289047f, 0.00343592f, 0.05377025f, 0.11894757f, 
    0.13524453f, -0.02983169f, -0.01068114f, -0.11780318f, -0.22286852f, -0.09132628f, -0.04302232f, 0.06571616f, 
    0.04519702f, -0.01173693f, 0.03193770f, 0.01535454f, 0.14976814f, 0.10949811f, 0.06550550f, 0.10267579f, 
    0.05452831f, -0.10385153f, 0.00892402f, -0.10421788f, 0.08585704f, 0.03485738f, -0.00791291f, -0.00013264f, 
    0.05701911f, 0.10968946f, -0.00872200f, 0.10002354f, 0.08369195f, -0.17305934f, 0.04328566f, -0.08521253f, 
    -0.03700038f, -0.04672511f, -0.04266648f, 0.08138186f, 0.09007592f, 0.07163238f, -0.01218850f, 0.03672049f, 
    0.07945655f, -0.14625147f, 0.23908359f, 0.09666163f, -0.04353358f, -0.08895504f, -0.05336421f, 0.16874763f, 
    -0.00869518f, -0.06624548f, -0.06487667f, 0.05303727f, -0.15425062f, -0.03919088f, -0.20249774f, 0.11417808f, 
    -0.13487887f, 0.04614772f, -0.01952955f, 0.15086091f, 0.07261050f, -0.02964114f, -0.02071247f, 0.06005645f, 
    -0.27505991f, -0.12194272f, 0.14765067f, -0.10413434f, -0.07730951f, 0.03341837f, 0.04883439f, 0.00023246f, 
    0.02640134f, 0.01362054f, 0.03044213f, 0.14742008f, 0.09868085f, -0.14408712f, -0.02544721f, -0.05484951f, 
    0.04205737f, 0.07427769f, 0.17350800f, -0.07801468f, 0.15057074f, 0.12710080f, 0.04493963f, 0.05658082f, 
    -0.06871481f, -0.01030616f, -0.22215758f, -0.00538631f, 0.05860595f, 0.05017270f, 0.01127907f, -0.07527563f, 
    -0.04224835f, 0.07207842f, 0.03476059f, 0.14421773f, -0.16775662f, 0.05758247f, 0.09170442f, -0.00600795f, 
    0.04978852f, 0.11211003f, 0.03240203f, -0.01826338f, 0.08009911f, 0.03010684f, -0.02109534f, -0.04026123f, 
    0.11455318f, 0.01965195f, -0.17991039f, -0.08026254f, 0.02713856f, 0.03481379f, 0.13769266f, 0.05888224f, 
    0.02633681f, -0.05128722f, -0.00842769f, 0.07287455f, 0.04685529f, -0.02917393f, 0.11838049f, -0.09656646f, 
    0.00885286f, -0.03885746f, 0.18491268f, 0.07388087f, -0.01279626f, -0.03534537f, 0.05613888f, 0.05951381f, 
    -0.20745008f, -0.03199317f, -0.23128183f, -0.00969515f, 0.09190336f, 0.02484441f, 0.00474094f, 0.09136815f, 
    -0.02945966f, 0.04556677f, 0.01794260f, -0.02780614f, -0.08572643f, 0.04511894f, -0.04219431f, -0.08516309f, 
    -0.14235204f, -0.00053411f, -0.09714531f, 0.14763108f, 0.00245415f, -0.06643458f, -0.02640892f, -0.13654591f, 
    0.10762098f, 0.11314366f, -0.24346992f, -0.03764052f, 0.11065853f, -0.01747998f, -0.01981869f, -0.06647523f, 
    -0.01175149f, 0.14300899f, -0.08085242f, -0.11833759f, 0.48841879f, -0.09599436f, 0.03175907f, 0.25659546f, 
    -0.10848192f, -0.01317000f, 0.03632770f, 0.00637044f, 0.04874515f, 0.08930185f, 0.08603260f, -0.07840335f, 
    -0.02743369f, -0.05437887f, -0.06898304f, -0.04770966f, 0.04422078f, 0.06269718f, 0.00340414f, 0.06466209f, 
    -0.11746477f, -0.04064063f, -0.02453334f, 0.12967028f, 0.19928984f, -0.03702699f, -0.10593282f, -0.02880688f, 
    0.01932495f, 0.04529452f, -0.13375446f, 0.12365334f, 0.03949478f, -0.07598073f, -0.07771119f, 0.09522170f, 
    0.29526189f, -0.17867038f, -0.03607389f, -0.05800994f, -0.11519681f, -0.02497444f, 0.11110997f, 0.06330535f, 
    0.01971684f, 0.04430562f, 0.01164088f, 0.12604798f, -0.17220101f, -0.05452557f, -0.06019716f, 0.05320586f, 
    0.14934209f, 0.13900763f, -0.07116880f, 0.00482161f, -0.07287379f, -0.03313635f, 0.01340862f, -0.03678054f, 
    0.13142151f, -0.06347018f, 0.16540605f, 0.31348023f, 0.01292429f, 0.00098519f, 0.10382479f, 0.00217913f, 
    0.02492129f, 0.01291066f, -0.00146151f, 0.03025886f, 0.43637609f, -0.09004509f, 0.09229207f, -0.01842940f, 
    0.08543930f, -0.02555211f, 0.01052396f, -0.01941233f, 0.00174576f, -0.01120532f, 0.18537760f, 0.13278985f, 
    -0.08656175f, 0.08939715f, -0.08160304f, 0.09747245f, 0.11404644f, 0.09388794f, 0.06436002f, -0.04161866f, 
    -0.00750962f, 0.01002124f, -0.05944353f, -0.02939153f, 0.20810355f, -0.02877371f, 0.03877972f, -0.06176245f, 
    0.15825748f, 0.11229135f, -0.00264627f, -0.07539311f, 0.00027782f, 0.04404001f, -0.00236752f, 0.12564331f, 
    -0.13901569f, -0.26381564f, 0.20343244f, 0.14500895f, 0.01855337f, 0.02494036f, 0.00301992f, 0.08365826f, 
    0.00419940f, 0.08266246f, -0.02479012f, 0.00689580f, -0.00485326f, -0.10300380f, 0.04230591f, -0.14795393f, 
    0.00723061f, 0.02270409f, -0.03324538f, -0.06137864f, 0.16135330f, 0.19165437f, 0.08866740f, -0.05544388f, 
    0.11111286f, 0.10746295f, -0.04911694f, -0.14243509f, 0.01156773f, 0.02778410f, 0.02458129f, 0.02094691f, 
    0.00598048f, -0.00020100f, 0.07379372f, -0.07365413f, -0.28623316f, -0.21871993f, -0.21854912f, 0.10161516f, 
    0.03568737f, -0.00418671f, 0.10167035f, 0.03797498f, -0.03953050f, 0.01601792f, 0.07106090f, 0.06474273f, 
    -0.19417286f, 0.11210144f, -0.07129922f, 0.18482725f, -0.06059929f, -0.01222388f, 0.02348085f, 0.03748960f, 
    0.10139415f, -0.03049830f, -0.03288524f, 0.04808923f, 0.10587349f, -0.17907175f, 0.05381389f, -0.13358386f, 
    0.02252545f, -0.01630874f, 0.07228041f, 0.02641032f, -0.05225538f, -0.08064755f, 0.03233377f, 0.05220630f, 
    0.41809872f, 0.02237409f, 0.13782015f, 0.13332416f, 0.11294919f, 0.09400358f, -0.01070892f, 0.02959483f, 
    -0.01540106f, -0.06836856f, -0.05975838f, -0.00985841f, -0.28107762f, -0.14669636f, 0.20410632f, -0.12958123f, 
    -0.02350364f, -0.03092290f, 0.00727982f, -0.02402649f, 0.06205524f, 0.01447182f, 0.07925107f, 0.03795889f, 
    0.10372894f, -0.04793463f, -0.11997725f, 0.06421349f, -0.18837243f, -0.10684676f, 0.13813114f, -0.00370614f, 
    -0.04545025f, 0.03496030f, -0.01952345f, 0.01759291f, 0.03548216f, -0.27417982f, -0.10068135f, 0.21472301f, 
    -0.10587449f, 0.01961980f, -0.01959362f, -0.00935831f, 0.00573090f, 0.00576944f, -0.12545779f, 0.06647550f, 
    -0.15132546f, 0.06333008f, 0.06458350f, 0.10026497f, 0.07971212f, -0.00207349f, -0.07437749f, 0.16814829f, 
    0.09739211f, -0.01270758f, -0.16731220f, 0.04889970f, 0.20727549f, 0.10865591f, -0.11433986f, -0.29792795f, 
    -0.09081814f, -0.03749157f, 0.03339120f, 0.01883075f, 0.05986165f, -0.02327436f, 0.04584312f, 0.05765630f, 
    0.32211813f, 0.22736733f, -0.18067032f, -0.31135312f, -0.06486686f, 0.01671459f, -0.01041419f, 0.01458274f, 
    0.01840811f, -0.05261926f, -0.09832563f, 0.04495095f, -0.12057662f, 0.01912383f, 0.18410072f, 0.10962528f, 
    0.01738846f, -0.12942448f, 0.14737341f, -0.04266038f, 0.01036264f, -0.00068976f, 0.12074251f, -0.04210615f, 
    -0.00208622f, 0.23064350f, -0.12779750f, -0.07610285f, 0.09162095f, -0.00187159f, 0.10046309f, -0.07182541f, 
    -0.00847397f, 0.08286216f, 0.01971461f, -0.10061605f, -0.08057037f, -0.11337110f, -0.09824216f, -0.00678159f, 
    -0.04859784f, 0.14854889f, 0.06469026f, -0.05937383f, 0.00969467f, 0.00299347f, 0.05481175f, -0.11146188f, 
    -0.06051794f, 0.03673546f, -0.06795067f, 0.02674538f, -0.13941668f, 0.06734301f, -0.02238202f, 0.05935403f, 
    0.10574840f, 0.01385629f, 0.01930448f, 0.02427635f, 0.10566331f, 0.26813090f, 0.08037188f, 0.20114926f, 
    0.13975842f, 0.01771994f, 0.10616278f, -0.01447442f, -0.02648224f, -0.02569044f, -0.02179105f, 0.05553405f, 
    -0.11629548f, 0.38801873f, 0.10556538f, 0.19894677f, 0.16951892f, -0.02779698f, 0.07518576f, 0.04218945f, 
    -0.08072507f, 0.12914644f, -0.04251907f, 0.05381588f, -0.35408252f, 0.08063295f, 0.01138095f, 0.22312254f, 
    0.03372024f, 0.07886504f, 0.02784379f, -0.08756036f, 0.06262242f, 0.17123055f, -0.03421917f, 0.06720502f, 
    0.26101208f, -0.15869147f, 0.14387290f, 0.05391667f, -0.20509344f, 0.21839172f, 0.08285218f, -0.02542035f, 
    -0.03830528f, 0.05545218f, 0.04908896f, -0.10473114f, -0.00711540f, -0.06610718f, -0.00145450f, -0.13015725f, 
    -0.03865677f, -0.02734954f, 0.00385653f, 0.06132456f, 0.10179819f, 0.00202464f, -0.07429297f, 0.08201306f, 
    0.40149802f, 0.27013111f, 0.10562082f, 0.32282591f, 0.05161394f, 0.08955675f, 0.18735480f, -0.00681462f, 
    0.12239814f, 0.08421324f, -0.04438592f, 0.16198106f, -0.27119234f, 0.31898132f, 0.07637361f, -0.09033345f, 
    0.07615305f, 0.01787062f, -0.04578387f, 0.10227603f, 0.05064965f, -0.02065463f, -0.11279414f, 0.13170654f, 
    -0.25576577f, -0.17392278f, 0.01004330f, 0.25504041f, -0.04701486f, 0.06745625f, 0.04128031f, 0.01985102f, 
    0.03902058f, 0.05474593f, 0.02113967f, -0.09443986f, 0.11638784f, 0.29019991f, 0.09256683f, -0.05469382f, 
    0.07378329f, 0.00388332f, 0.02178704f, 0.06759248f, 0.12564965f, -0.05949549f, 0.04866058f, 0.08927312f, 
    -0.22973220f, 0.24574178f, -0.10330503f, -0.01774988f, -0.07060388f, -0.13121974f, -0.03613998f, -0.00480072f, 
    0.08319873f, 0.00317350f, 0.02716594f, -0.08057168f, -0.17244951f, -0.14903229f, -0.04979220f, 0.01505193f, 
    -0.17317648f, -0.03958460f, 0.10889474f, 0.09791635f, 0.06735395f, 0.06699348f, 0.04640291f, 0.07640104f, 
    0.20203944f, 0.07136542f, -0.04458177f, 0.09626036f, -0.08260690f, 0.06878512f, 0.06978043f, 0.16361432f, 
    -0.04560776f, 0.00801994f, -0.06498618f, 0.02903126f, -0.06659361f, -0.06853580f, -0.03883292f, 0.06521625f, 
    -0.01333829f, 0.08115087f, -0.04791547f, 0.02672597f, 0.08756363f, -0.04309262f, 0.09390972f, -0.03270961f, 
    0.08289890f, -0.15300763f, -0.02933216f, -0.08674809f, -0.05795924f, 0.00980289f, 0.02781096f, 0.04796871f, 
    0.05677420f, 0.01100855f, 0.02376362f, 0.03280450f, -0.49687624f, 0.26973930f, -0.00817274f, -0.06075150f, 
    -0.04830007f, 0.09340861f, 0.00999091f, 0.14332937f, 0.00083265f, -0.03675307f, -0.12729746f, -0.16935904f, 
    0.03349646f, -0.22878309f, -0.19855796f, -0.09804450f, 0.05021796f, -0.06396215f, 0.05114932f, -0.03566488f, 
    0.09874813f, 0.07562491f, 0.16879418f, -0.06351300f, -0.20402159f, -0.01733479f, 0.10155784f, -0.06140245f, 
    -0.19800149f, 0.00492069f, 0.01075412f, -0.04220704f, -0.00453979f, 0.01673749f, -0.01820951f, 0.05916861f, 
    0.53710014f, -0.19481952f, 0.19442344f, 0.12128852f, -0.02301756f, -0.10433468f, 0.03816146f, 0.12330760f, 
    -0.05032200f, 0.00977509f, 0.01553362f, 0.15235546f, 0.03916794f, 0.04519527f, -0.08312948f, -0.05671800f, 
    0.08575616f, -0.03674922f, -0.00852901f, -0.02024049f, 0.04831697f, -0.00276645f, 0.00511943f, 0.22914222f, 
    -0.16413277f, 0.24560183f, 0.04132156f, 0.04822633f, -0.13291794f, 0.07067893f, -0.05328813f, 0.10040873f, 
    0.00359123f, 0.05837356f, 0.11531353f, 0.02522949f, 0.16466390f, 0.12008151f, -0.20238195f, -0.19007885f, 
    0.04579794f, 0.00452365f, 0.14052002f, 0.00574090f, 0.02216751f, 0.12923539f, 0.04320091f, 0.15195569f, 
    0.08040246f, 0.14034696f, 0.10945920f, -0.12400265f, 0.15966253f, 0.06387802f, 0.18451995f, 0.08911610f, 
    0.18249823f, 0.03596858f, -0.08781409f, -0.09432895f, -0.02641360f, -0.22306876f, 0.08378235f, -0.00885031f, 
    0.11218832f, 0.05803134f, 0.01351471f, -0.00456326f, -0.03931807f, 0.02735944f, 0.07721663f, 0.06334195f, 
    0.02904839f, 0.00651274f, -0.03375632f, -0.18547180f, 0.05624647f, 0.01522857f, 0.01121174f, -0.00855532f, 
    0.07044750f, 0.10140482f, 0.03068633f, 0.06004966f, -0.02336895f, -0.23735932f, -0.09863584f, -0.01883254f, 
    0.03812103f, 0.02954421f, -0.08136914f, -0.02976307f, 0.09944373f, -0.02331973f, -0.01942016f, -0.11472458f, 
    -0.08124759f, 0.01909919f, -0.11333945f, -0.05395231f, 0.17214783f, 0.02724726f, 0.00826721f, 0.02632103f, 
    0.11304436f, 0.13193329f, -0.05373759f, 0.01188231f, 0.30347842f, -0.02379867f, -0.00658962f, -0.07746452f, 
    -0.21687578f, -0.01444307f, 0.03466891f, -0.02337909f, 0.03129468f, -0.09560961f, -0.07402926f, -0.05438186f, 
    0.37075707f, 0.03500483f, 0.01436085f, 0.08581401f, -0.12071300f, -0.07208459f, -0.04763585f, 0.00094141f, 
    0.01180701f, -0.17910574f, -0.10255142f, -0.04381824f, -0.13081318f, -0.16801234f, -0.03959231f, -0.03336225f, 
    -0.12159845f, -0.12522539f, -0.13662928f, -0.06226018f, 0.00939521f, 0.03246361f, -0.07811365f, -0.02427797f, 
    -0.00545466f, 0.12176076f, -0.03296771f, -0.05427697f, -0.20234033f, 0.01891150f, -0.06116510f, -0.01744895f, 
    0.13623121f, -0.08249205f, 0.06798095f, -0.07153990f, 0.03967423f, -0.21452887f, -0.12986647f, 0.03688547f, 
    -0.01283006f, 0.13029176f, -0.03265004f, 0.14377502f, 0.01933318f, 0.06301553f, -0.12316160f, -0.07286569f, 
    0.29861963f, -0.37534070f, -0.09850958f, 0.07516596f, 0.04504800f, 0.05231096f, 0.02473965f, 0.09014777f, 
    0.04436148f, 0.16038707f, 0.04631556f, 0.07952730f, 0.16474536f, 0.24285485f, -0.06182972f, -0.02765363f, 
    0.24182528f, -0.02144756f, 0.00768518f, 0.10874783f, 0.01666473f, 0.04720103f, 0.04607899f, -0.02846890f, 
    -0.08476613f, 0.23168808f, -0.07001229f, 0.09677067f, 0.10697962f, 0.17501916f, -0.00598834f, 0.04804017f, 
    -0.00003930f, 0.04535229f, -0.01594586f, 0.19758689f, -0.08315852f, -0.17941567f, 0.08856491f, 0.04724915f, 
    -0.07103316f, 0.12468179f, 0.03729931f, -0.03252529f, 0.02453301f, 0.04737226f, 0.01568987f, 0.16708295f, 
    0.22229455f, -0.15690196f, -0.01970787f, 0.29561278f, 0.08798936f, -0.00798464f, -0.11025985f, -0.05814128f, 
    0.11682681f, 0.16937967f, 0.07192542f, 0.01018258f, 0.08597984f, 0.24556316f, -0.08221419f, -0.24791808f, 
    -0.02760571f, 0.06334259f, 0.00912434f, 0.06323864f, -0.01303803f, 0.04886383f, -0.00037429f, 0.09600411f, 
    0.23410033f, -0.00251902f, -0.22552173f, -0.17917179f, 0.16282800f, -0.07921643f, -0.06794532f, -0.18951631f, 
    0.15923721f, 0.05773497f, 0.12948550f, 0.04670583f, -0.02712771f, 0.25771043f, 0.03535655f, 0.09380985f, 
    0.04640828f, 0.00341657f, -0.00547955f, -0.02649113f, -0.02962947f, -0.02372039f, 0.09689207f, 0.00080811f, 
    -0.31639963f, -0.06004236f, 0.02602748f, -0.03028385f, -0.08889171f, 0.07582113f, 0.10353131f, 0.00088184f, 
    0.08089000f, 0.00023197f, -0.02702563f, -0.05938758f, 0.04037654f, -0.03416966f, -0.19199675f, 0.02425161f, 
    -0.06689248f, 0.06944717f, -0.07565932f, 0.02708251f, 0.04118854f, 0.10868395f, -0.11343927f, 0.04929693f, 
    -0.15016343f, 0.18383382f, -0.22916426f, -0.03622891f, -0.05487913f, 0.03228191f, -0.04129251f, 0.07970449f, 
    0.08746569f, -0.02337617f, 0.02553070f, -0.22121499f, 0.15139292f, -0.22272763f, -0.07302806f, 0.04684997f, 
    0.11680514f, -0.01783238f, 0.03012216f, 0.13650045f, 0.01331682f, 0.08115155f, 0.03484482f, 0.08320928f, 
    -0.06338029f, 0.04996964f, -0.08211985f, 0.07446261f, 0.03600441f, -0.08084166f, -0.02158766f, 0.03868858f, 
    -0.11928785f, -0.10974906f, 0.00723723f, 0.03670873f, 0.06942876f, -0.13127649f, 0.20148373f, 0.06013613f, 
    0.07680950f, 0.04239418f, -0.05585319f, 0.03926016f, 0.02800604f, 0.17048492f, 0.07982542f, -0.01256678f, 
    0.27620235f, -0.10742057f, -0.14267966f, 0.27406016f, 0.15617858f, 0.01236485f, -0.00578402f, 0.06743179f, 
    0.01688714f, 0.07437926f, 0.19075499f, 0.17230166f, 0.33692750f, 0.37081063f, -0.35559288f, -0.05463137f, 
    -0.01275238f, 0.01856600f, 0.03451384f, 0.03867994f, 0.09329654f, 0.09157694f, 0.04149237f, 0.10424620f, 
    0.06181269f, -0.00245982f, -0.08458915f, 0.01997564f, 0.03732050f, -0.00413635f, -0.01164113f, -0.05480712f, 
    0.00429987f, 0.01191050f, -0.01581964f, 0.01806054f, -0.03594777f, -0.05925508f, -0.04092545f, -0.08393732f, 
    -0.02297412f, -0.05712799f, -0.00934350f, 0.03179165f, 0.01221046f, -0.00487274f, 0.02153447f, -0.04364783f, 
    -0.06940246f, -0.02450744f, -0.02161323f, -0.05358171f, -0.00087595f, -0.08238547f, -0.02252437f, -0.01370542f, 
    -0.05574670f, -0.01324883f, -0.00891125f, -0.02738226f, -0.06031786f, -0.02942627f, 0.01284684f, 0.03417938f, 
    -0.05867182f, -0.04822926f, -0.03618485f, 0.00317723f, -0.04725040f, -0.03634599f, 0.00186132f, -0.08869734f, 
    -0.04822367f, -0.04613218f, -0.03774727f, -0.01658092f, 0.01125551f, 0.02173751f, -0.03891711f, 0.01266032f, 
    -0.01389422f, -0.05411309f, -0.09028596f, -0.00540473f, 0.01068592f, -0.05448367f, -0.06560446f, -0.05703641f, 
    -0.03830370f, -0.04516187f, 0.03739263f, -0.01669569f, -0.03861375f, -0.00799388f, -0.06374945f, -0.03483346f, 
    0.02776472f, -0.03328189f, -0.04453176f, -0.00502792f, -0.09349653f, -0.07586930f, 0.02985368f, -0.06464609f, 
    -0.08022643f, -0.08296263f, 0.01212494f, -0.03852839f, -0.00464488f, 0.00489832f, 0.02859978f, 0.00171287f, 
    -0.03986768f, 0.02964587f, 0.03096138f, 0.00618940f, -0.05225905f, -0.02781563f, -0.05155008f, -0.08650202f, 
    -0.00425088f, 0.02993956f, 0.01187911f, -0.03036982f, -0.03900160f, 0.02984834f, -0.07398668f, 0.01189750f, 
    -0.01197474f, -0.01529523f, -0.06300367f, -0.01452644f, -0.03193180f, 0.01558254f, 0.03593650f, 0.00269799f, 
    -0.04612732f, 0.02135615f, -0.04356516f, -0.01470315f, -0.02955605f, 0.03511226f, -0.05294521f, 0.01865035f, 
    0.03414584f, 0.00380935f, -0.02892942f, -0.03302662f, -0.07275984f, -0.00187722f, -0.06792806f, 0.04244550f, 
    0.02356663f, -0.01648363f, -0.01603849f, 0.00022956f, -0.03846092f, 0.04259323f, 0.02050120f, -0.05608174f, 
    -0.03029371f, -0.06519467f, -0.00715024f, -0.05211570f, 0.01403205f, 0.01073008f, -0.05928408f, 0.00866738f, 
    -0.05866083f, 0.02988053f, -0.03640643f, 0.03557128f, -0.00233325f, -0.09793877f, -0.01177547f, -0.00740877f, 
    -0.03216383f, -0.02062263f, -0.02259285f, 0.00076246f, -0.03053769f, -0.01545091f, -0.04970236f, -0.01867757f, 
    -0.02230746f, -0.01970469f, -0.00708904f, -0.01243565f, -0.06808066f, -0.00786468f, -0.03555022f, 0.00088416f, 
    -0.00635389f, -0.03173676f, -0.05955869f, -0.03015091f, 0.00902814f, 0.00397224f, -0.03065447f, 0.00706099f, 
    -0.06646994f, -0.04812434f, -0.05166139f, 0.00584792f, -0.06582993f, 0.00002536f, 0.05678489f, -0.00154521f, 
    -0.00311157f, -0.06882706f, 0.01157243f, 0.00992846f, 0.01116413f, -0.05725728f, -0.06054674f, -0.00298942f, 
    -0.06088363f, 0.00921396f, 0.04522932f, 0.03913908f, -0.01971686f, 0.02112226f, 0.03874117f, -0.03460783f, 
    -0.02296412f, -0.03430767f, 0.01489161f, -0.03671805f, -0.07807278f, 0.03148427f, -0.05299010f, -0.00887334f, 
    -0.00521398f, -0.06080767f, 0.02645049f, -0.02098795f, -0.04976573f, -0.01985379f, -0.04714303f, 0.00379859f, 
    -0.03950550f, -0.03791153f, 0.02617179f, -0.07278151f, 0.01740390f, -0.07071736f, -0.00081852f, -0.05368472f, 
    0.01703892f, -0.07543579f, -0.02902118f, -0.04106570f, 0.02118506f, 0.02596492f, 0.00852085f, 0.01048403f, 
    -0.03330332f, 0.03350702f, 0.00666232f, -0.07695557f, -0.06013948f, -0.01686238f, -0.02147876f, -0.03236381f, 
    0.00869484f, -0.08101822f, -0.01411637f, 0.03333988f, 0.03724126f, -0.02587464f, -0.01275853f, 0.02865957f, 
    -0.07553142f, -0.04165937f, 0.01995690f, -0.00155577f, -0.04056881f, 0.04113051f, 0.01576170f, -0.01870766f, 
    0.03992746f, 0.05284553f, -0.04127419f, -0.03885693f, 0.02036634f, -0.00815367f, -0.00804863f, 0.00758131f, 
    0.04125595f, -0.05250017f, -0.01755981f, -0.07376480f, -0.02014569f, 0.01233057f, -0.06624433f, -0.00220813f, 
    -0.03675107f, -0.07872485f, -0.07296664f, -0.00867552f, -0.04962493f, -0.00609329f, -0.03498919f, 0.00841260f, 
    -0.05200652f, -0.07246529f, -0.08205435f, 0.04874234f, -0.01323771f, -0.07345635f, -0.06174573f, -0.00389541f, 
    -0.05773515f, 0.00060007f, -0.03263717f, -0.02406693f, -0.06747271f, 0.01933294f, 0.02888104f, 0.02198319f, 
    -0.01908838f, 0.00350186f, -0.06440781f, -0.03819655f, -0.00039268f, 0.04360256f, -0.02975795f, 0.00618859f, 
    -0.02416275f, -0.04176603f, -0.00658660f, -0.01408524f, 0.04588470f, 0.00602232f, -0.05423219f, -0.00404569f, 
    -0.00854221f, 0.02410447f, 0.02123147f, -0.02513492f, -0.00977233f, -0.04621215f, -0.01083983f, -0.00156731f, 
    0.05794301f, -0.06420490f, -0.03469771f, -0.01415562f, 0.00327242f, -0.05002162f, 0.00718921f, -0.02632669f, 
    -0.05001294f, -0.04982246f, 0.01699506f, -0.01910635f, -0.03864584f, 0.01821029f, -0.01863229f, 0.02130135f, 
    0.02804372f, 0.02134917f, -0.04243574f, 0.01619064f, -0.06131707f, -0.02860036f, -0.05340156f, -0.03483666f, 
    0.01858037f, -0.07418950f, 0.01542955f, -0.01300673f, -0.07175359f, 0.03978105f, 0.06887627f, 0.04451654f, 
    -0.03984485f, -0.03949398f, -0.05167689f, 0.00653896f, -0.01842976f, -0.06642912f, 0.00368130f, -0.04428060f, 
    -0.00990297f, 0.00980143f, -0.04782679f, -0.04473560f, -0.06274880f, -0.02815804f, -0.02376637f, 0.01402416f, 
    0.01330847f, -0.04710610f, -0.00680946f, -0.00226556f, -0.02498135f, -0.01583813f, -0.01602294f, 0.01737151f, 
    -0.01428758f, -0.01105645f, 0.01511529f, -0.01237432f, -0.05243503f, -0.08868228f, -0.06918330f, -0.04347590f, 
    -0.02456426f, -0.22909172f, 0.24397656f, 0.11877894f, 0.00981201f, -0.02682758f, -0.04319143f, 0.03313437f, 
    0.13918360f, -0.02360743f, 0.00819479f, -0.00582148f, 0.07231124f, 0.07389000f, -0.00076423f, -0.13965274f, 
    0.13130592f, 0.03514374f, -0.00957237f, -0.00578741f, 0.14816365f, 0.12347469f, 0.05857638f, -0.02548010f, 
    -0.03809002f, 0.05426182f, -0.03395311f, -0.33191001f, -0.00694299f, 0.05854394f, -0.00402305f, 0.03140343f, 
    0.04360111f, 0.08206508f, 0.05683204f, -0.08431318f, -0.41527757f, 0.04268582f, -0.05985363f, 0.13713016f, 
    -0.01379231f, -0.08038604f, 0.10418466f, -0.02818645f, -0.03284631f, 0.07878701f, 0.11679088f, 0.04171464f, 
    -0.10355695f, -0.16851594f, -0.08935384f, -0.00458067f, 0.08926611f, 0.02468652f, -0.01787382f, 0.08162387f, 
    0.14323764f, -0.04961717f, -0.04207268f, -0.00800208f, -0.14757013f, -0.12264068f, 0.17604761f, -0.12155126f, 
    0.07969765f, -0.00802019f, 0.07640012f, 0.05702264f, -0.01548942f, -0.12569682f, -0.04995442f, -0.03092133f, 
    -0.00190256f, -0.01754468f, 0.04412527f, 0.23596013f, -0.00319403f, -0.05928691f, -0.03016756f, -0.05798754f, 
    -0.11840937f, -0.11720026f, -0.04857060f, 0.08583011f, -0.03913161f, 0.11130984f, 0.13212249f, 0.01864933f, 
    -0.15346776f, 0.01640397f, -0.01889575f, 0.02360941f, -0.03551808f, 0.09229475f, 0.09923791f, 0.07744663f, 
    0.16241099f, -0.10869951f, -0.25342530f, 0.22457886f, -0.01291153f, 0.01058438f, -0.10548986f, 0.00999610f, 
    -0.13329424f, -0.01932188f, 0.06625655f, 0.04713501f, 0.14379656f, 0.07709248f, 0.03690496f, -0.07240018f, 
    -0.07173250f, 0.04373464f, 0.07415652f, -0.07306375f, -0.09886447f, -0.13127203f, -0.05538085f, 0.03763429f, 
    -0.05013397f, -0.00175411f, 0.21559612f, 0.15682806f, 0.09008380f, -0.03905899f, 0.02028717f, -0.01441621f, 
    -0.10044169f, -0.04265415f, 0.00010807f, -0.00287075f, 0.04202362f, 0.22694662f, -0.14450416f, -0.04443132f, 
    0.06543843f, 0.08344188f, 0.05208812f, -0.02354441f, -0.06588487f, 0.06076799f, 0.02880493f, 0.10597316f, 
    0.16941683f, 0.24057321f, -0.26377451f, -0.21628346f, 0.05275882f, 0.10150416f, -0.05733792f, -0.12746541f, 
    -0.00084294f, 0.16298859f, 0.00593804f, 0.10885012f, 0.12268975f, 0.12423847f, 0.34624693f, 0.11514124f, 
    0.10481308f, -0.07558808f, 0.00992780f, -0.18987603f, -0.06981037f, 0.02602356f, 0.08730452f, -0.03203750f, 
    0.08961521f, 0.15594615f, -0.10969292f, 0.04012208f, 0.23341337f, -0.10511785f, -0.01694742f, 0.01679261f, 
    0.06222858f, 0.08353895f, 0.03961531f, -0.13034518f, 0.07386206f, 0.00370866f, 0.03555604f, 0.14953841f, 
    0.03492464f, 0.03141557f, -0.01711334f, -0.04228779f, -0.06267025f, -0.10028946f, 0.11850192f, 0.00724279f, 
    -0.07927364f, 0.10893819f, 0.12399180f, 0.08330446f, -0.05123147f, -0.06544010f, -0.02521315f, 0.03084694f, 
    0.11016305f, -0.08444617f, 0.01133419f, -0.03203619f, 0.09531430f, 0.04916865f, 0.07384392f, 0.01804326f, 
    0.02591503f, -0.04932583f, 0.01564140f, 0.01099440f, -0.11788684f, -0.03285183f, 0.01135843f, -0.00099690f, 
    -0.11533397f, 0.02944904f, 0.12142470f, 0.23954789f, 0.07566589f, 0.10424922f, -0.02471876f, 0.06335913f, 
    0.05293057f, 0.06994558f, 0.01477091f, -0.09014032f, -0.14490034f, 0.18814008f, -0.11075486f, 0.36363676f, 
    0.07924858f, 0.06030674f, -0.02889048f, -0.08867540f, 0.01172919f, 0.12686320f, -0.07344537f, -0.09004706f, 
    0.19915350f, 0.04105626f, 0.12916586f, -0.14037478f, -0.22810365f, -0.01363568f, 0.01616908f, 0.04172497f, 
    0.06923378f, 0.04227787f, 0.04630283f, 0.00796370f, 0.11569373f, 0.03303072f, 0.02358322f, 0.07210433f, 
    0.07019650f, -0.03057849f, 0.10219022f, -0.14193918f, 0.04834992f, 0.00637367f, -0.07193371f, 0.05914935f, 
    0.05397340f, 0.02930723f, 0.39076892f, 0.33701953f, -0.04819455f, 0.04275478f, 0.08457524f, 0.04041152f, 
    0.07460756f, -0.05009354f, 0.04478532f, 0.14253929f, -0.34100008f, 0.10853688f, -0.04951777f, -0.14292879f, 
    0.07666324f, 0.08409917f, -0.06848315f, 0.08240083f, 0.05822495f, 0.00971801f, -0.03747325f, 0.08845845f, 
    -0.02199658f, -0.00034986f, 0.10330638f, 0.15525211f, 0.02202793f, 0.01593262f, 0.06145228f, -0.01527932f, 
    0.13183297f, 0.12607853f, 0.00976098f, -0.03289329f, -0.09870319f, 0.08191674f, 0.06133185f, 0.03819044f, 
    -0.00365193f, 0.05815684f, 0.06890194f, -0.05001146f, -0.00967279f, -0.02233611f, 0.13897827f, 0.01305141f, 
    -0.15586516f, 0.15561354f, 0.01478227f, 0.08926696f, 0.06372272f, -0.08481260f, -0.04251492f, -0.01685404f, 
    -0.08375215f, -0.01587673f, 0.01477378f, -0.16306716f, -0.00838756f, 0.07654925f, 0.16009194f, -0.07185210f, 
    -0.19017780f, -0.05281512f, 0.08542795f, 0.03643061f, 0.08566741f, 0.11600396f, -0.00399659f, 0.06397023f, 
    0.11306749f, 0.10676695f, -0.01929708f, -0.13241924f, 0.02498936f, -0.00725571f, -0.03062484f, 0.16467375f, 
    -0.03129884f, -0.02020593f, -0.02291711f, 0.01072407f, -0.18153229f, 0.05720631f, -0.12413386f, 0.02500721f, 
    -0.08904802f, 0.07234649f, 0.04976980f, 0.07099438f, 0.01395325f, -0.06168317f, -0.06370495f, 0.01614352f, 
    0.05231062f, -0.00192205f, 0.19922982f, -0.30484885f, -0.19232179f, -0.07306878f, -0.00241717f, 0.09291127f, 
    0.09524801f, 0.03101858f, 0.00597100f, -0.08953622f, -0.50256330f, -0.09956275f, 0.17142068f, 0.09124614f, 
    0.05870219f, 0.00405026f, -0.04223455f, 0.06303950f, 0.17141151f, -0.06957290f, -0.03905236f, -0.06282130f, 
    -0.04516695f, 0.03542979f, 0.02416245f, -0.05805012f, -0.01877898f, 0.02747228f, -0.04311430f, -0.05459087f, 
    -0.02368248f, 0.01923134f, -0.00106182f, 0.02905868f, -0.04962941f, -0.04385293f, -0.00416894f, -0.04286706f, 
    0.00275678f, -0.03828194f, 0.03152916f, 0.00334344f, 0.02440234f, 0.04043795f, -0.03783140f, -0.02606631f, 
    0.02312226f, 0.00341791f, 0.03287528f, 0.04423494f, 0.03567329f, 0.01781865f, -0.04197599f, 0.03920823f, 
    0.03857106f, -0.03505993f, 0.03580220f, 0.03204508f, 0.02336930f, -0.02292031f, -0.00412620f, 0.00915127f, 
    -0.03692295f, -0.05098579f, -0.05427155f, 0.00338936f, 0.01290946f, 0.02774284f, 0.00093381f, 0.04611973f, 
    -0.01077950f, 0.00981648f, -0.04538380f, -0.03101374f, 0.00004163f, -0.00233595f, -0.03571517f, 0.00547239f, 
    -0.00432611f, -0.01408664f, 0.00485902f, 0.00407735f, 0.02491425f, -0.03724435f, 0.02151216f, -0.05574402f, 
    -0.04863516f, -0.03767526f, 0.01885490f, 0.00762306f, -0.02893797f, 0.01141543f, 0.02755636f, -0.02019406f, 
    0.03439813f, -0.01441473f, -0.00175194f, -0.03600400f, -0.02506443f, -0.04857492f, -0.01418948f, 0.00708873f, 
    -0.01620333f, 0.01309076f, 0.01047090f, -0.01305044f, -0.02669841f, -0.01957658f, -0.05758647f, -0.02782050f, 
    -0.00661955f, 0.00671191f, -0.04955836f, -0.05250059f, 0.02286162f, -0.01671137f, -0.01439415f, -0.01653410f, 
    0.01244782f, 0.05020860f, -0.00700593f, 0.01734938f, -0.04404819f, -0.05761075f, -0.00551434f, -0.04091905f, 
    0.04149833f, 0.02850603f, -0.00409005f, -0.04424131f, 0.00572606f, 0.02533613f, -0.02826258f, -0.05411451f, 
    -0.01905424f, -0.04924001f, 0.00176631f, -0.01855474f, -0.05058759f, -0.03983174f, 0.02878775f, 0.00298593f, 
    0.01492669f, -0.01039276f, -0.00342048f, -0.01453679f, -0.03266774f, 0.03879645f, -0.00099149f, -0.00836864f, 
    0.03582067f, 0.02155026f, -0.05455599f, -0.01661093f, 0.04300179f, -0.00343305f, -0.00234046f, -0.04913592f, 
    0.04194252f, -0.00641131f, -0.02796755f, 0.02671154f, -0.05189530f, -0.05561860f, 0.03911327f, 0.03887460f, 
    -0.03011505f, 0.04469883f, -0.00245947f, -0.03736093f, 0.03262365f, 0.01604705f, 0.00251466f, -0.00570467f, 
    0.02257317f, -0.04370531f, -0.01162862f, 0.00935166f, -0.03159732f, 0.02668290f, -0.02688271f, -0.00466022f, 
    -0.00278881f, 0.03547818f, -0.04532073f, -0.02965370f, -0.00528171f, -0.03675662f, 0.04313923f, 0.00118407f, 
    -0.00764739f, -0.03089200f, -0.03120253f, 0.01851297f, 0.02537436f, 0.00947225f, 0.04227494f, -0.02817916f, 
    0.02537687f, -0.04494561f, 0.01905333f, 0.00502663f, 0.01743246f, 0.01624828f, 0.03031729f, -0.00339747f, 
    0.03955165f, 0.00525448f, -0.01456865f, -0.02594029f, -0.03936592f, 0.04176380f, 0.03245346f, 0.01084740f, 
    -0.05852817f, -0.00981141f, 0.02370337f, 0.01069336f, 0.02913176f, 0.00050776f, 0.02172834f, 0.02698704f, 
    0.01022831f, 0.04035899f, -0.04683203f, -0.00073721f, -0.02247158f, -0.01982844f, -0.05115864f, -0.04601933f, 
    -0.00966167f, -0.03074886f, -0.03510100f, 0.02598207f, -0.00552834f, -0.03335142f, -0.02681329f, 0.04053533f, 
    -0.01587563f, -0.01726090f, -0.03072211f, 0.03031732f, 0.01590811f, -0.02055471f, -0.03353044f, 0.00007224f, 
    0.04149043f, 0.02601200f, 0.04297471f, -0.03865356f, 0.04349496f, -0.02314270f, -0.02812336f, -0.02751511f, 
    -0.04024610f, -0.01942916f, 0.01723968f, 0.01840252f, -0.04844990f, 0.01912750f, 0.02603982f, -0.00065734f, 
    -0.02920574f, -0.02548368f, -0.01456378f, 0.02118305f, -0.01874625f, -0.00314686f, 0.01607064f, -0.05295484f, 
    0.01054307f, -0.02428431f, -0.00305739f, 0.01267982f, -0.00656979f, -0.04077301f, 0.00002415f, -0.02773295f, 
    0.03708444f, -0.03578799f, -0.02244104f, 0.00867701f, 0.01106568f, 0.02497839f, 0.04008039f, -0.00249009f, 
    0.02782392f, 0.02696146f, -0.02333316f, 0.00826752f, -0.00902111f, 0.00206782f, -0.00802804f, 0.01092884f, 
    0.03850879f, 0.00753317f, -0.03437172f, -0.01553907f, -0.02028640f, 0.01160627f, -0.01192150f, 0.02577309f, 
    0.02805327f, -0.04982811f, -0.01766312f, 0.03143447f, -0.04922862f, 0.02155595f, -0.03354862f, 0.01609102f, 
    -0.03949649f, -0.05536284f, -0.03972610f, 0.02356850f, 0.01814201f, 0.02837619f, -0.01014010f, 0.01842967f, 
    -0.04341834f, -0.03352915f, -0.00584232f, 0.02472427f, -0.03167235f, -0.01078924f, -0.05634113f, 0.00394897f, 
    -0.03853409f, -0.00218990f, -0.02505337f, 0.02572010f, 0.00841589f, -0.01602900f, -0.02968603f, 0.01956143f, 
    0.03683114f, 0.01651646f, -0.04925583f, -0.00645423f, 0.04190212f, -0.04761529f, 0.03540275f, -0.03365242f, 
    0.03527654f, -0.03657286f, 0.04978455f, 0.01196156f, -0.02132951f, 0.01244085f, 0.03143692f, -0.02818681f, 
    -0.01096218f, -0.02629798f, -0.03423238f, -0.03884116f, -0.01132208f, 0.00932711f, 0.02225686f, -0.02081063f, 
    -0.02400952f, -0.02280498f, -0.03381051f, -0.04361890f, -0.03288311f, 0.03183933f, -0.02452401f, 0.00803204f, 
    -0.04782056f, 0.00602525f, -0.02236929f, -0.03123767f, -0.01892005f, 0.00186387f, 0.01025994f, 0.00792728f, 
    -0.03312412f, -0.04316900f, -0.03823938f, 0.03585582f, -0.04834688f, 0.02258240f, 0.01947001f, 0.00275178f, 
    -0.03042500f, -0.04171780f, 0.01338915f, 0.02295925f, -0.00721644f, 0.00705257f, 0.04168798f, -0.01928743f, 
    0.04027134f, 0.03246765f, -0.03517252f, -0.04705670f, 0.02332228f, -0.04601065f, -0.04153072f, 0.04088148f, 
    -0.00615383f, 0.03932932f, -0.03499009f, 0.00586038f, 0.00139416f, 0.00385503f, 0.04117614f, -0.03322754f, 
    0.03815604f, -0.00835054f, 0.01138088f, -0.02409312f, 0.04521754f, 0.03929115f, -0.04299342f, -0.04449345f, 
    -0.00112902f, -0.03157657f, -0.03919936f, -0.01953673f, 0.01860955f, -0.01976097f, 0.00517851f, -0.02296657f, 
    -0.03704240f, -0.03701032f, 0.02369743f, -0.04536196f, 0.01540347f, 0.01866959f, -0.03870292f, 0.01757506f, 
    -0.02297735f, -0.04822763f, 0.00976994f, 0.01560839f, -0.04329257f, 0.01609653f, -0.05015009f, -0.00970323f, 
    -0.00421037f, 0.01758994f, 0.01981382f, 0.04172743f, -0.04171611f, -0.03981481f, 0.02864370f, 0.02116004f, 
    0.01461078f, 0.01672862f, 0.03889774f, -0.04463008f, -0.00117415f, -0.01195285f, 0.00210585f, 0.01859489f, 
    -0.01184709f, -0.01019425f, -0.03813694f, -0.02761094f, -0.00430762f, 0.03340541f, 0.00956068f, -0.04803543f, 
    0.02429152f, -0.05224860f, -0.00127394f, 0.01837975f, -0.03721263f, -0.03744820f, -0.04777771f, -0.01309189f, 
    -0.00110200f, 0.01179079f, 0.01015879f, -0.04562388f, -0.04303703f, 0.00716570f, 0.02840587f, 0.03029377f, 
    0.02130687f, -0.01280555f, 0.03263637f, -0.03687254f, 0.03796012f, -0.05444556f, -0.02226385f, -0.02992828f, 
    -0.02157414f, -0.03097817f, -0.03975571f, -0.02694181f, -0.04038031f, -0.05244742f, -0.04971450f, -0.05074213f, 
    0.00174104f, 0.01404560f, 0.04379696f, 0.03112673f, -0.00892556f, 0.02928584f, -0.00308491f, 0.00540472f, 
    -0.00183713f, -0.04611287f, -0.02697371f, -0.02150071f, 0.04935911f, -0.04838853f, 0.00106294f, 0.00085969f, 
    0.00514775f, -0.03126813f, 0.02952253f, 0.02240372f, 0.03023973f, 0.01214396f, -0.03600507f, 0.03753693f, 
    0.00346160f, -0.02077226f, -0.04977486f, -0.05273089f, 0.01883072f, -0.04323409f, 0.00474243f, 0.00449524f, 
    -0.04003828f, -0.03670506f, 0.01198739f, 0.00011861f, -0.02935761f, 0.02019526f, -0.05509271f, 0.03503648f, 
    -0.01283569f, 0.04153565f, 0.03951968f, -0.01738218f, -0.00017823f, -0.01562049f, -0.01903313f, -0.02364410f, 
    0.03753278f, -0.03780703f, 0.02108669f, 0.03466498f, 0.00116398f, -0.00019897f, 0.01995284f, 0.02497411f, 
    -0.00005028f, -0.02795283f, -0.04427319f, -0.04266121f, -0.04504296f, 0.01841037f, -0.03997733f, -0.00286165f, 
    -0.00189953f, 0.00908398f, -0.02244557f, -0.00596044f, -0.03155840f, -0.02943459f, 0.01077176f, -0.03625325f, 
    0.01975289f, 0.02417669f, -0.04431522f, -0.04042619f, -0.02015466f, -0.05069189f, -0.03599184f, 0.03260157f, 
    -0.00139233f, -0.00887638f, 0.00838386f, -0.02974656f, -0.01764380f, 0.04350849f, 0.03077801f, 0.01586807f, 
    0.01248677f, 0.03198701f, 0.04074928f, -0.04866095f, 0.03014796f, -0.02868937f, 0.04098764f, -0.05075309f, 
    -0.05285140f, -0.02091670f, -0.02802667f, -0.05238258f, -0.01472274f, -0.05360941f, -0.02336121f, -0.00395219f, 
    -0.00285440f, 0.01566466f, -0.01175931f, 0.00411458f, -0.03362945f, 0.02968621f, -0.00287186f, 0.00295725f, 
    -0.02316823f, -0.04926036f, 0.03621572f, -0.04077544f, 0.02640928f, 0.03698272f, 0.02922910f, 0.00249560f, 
    -0.04178227f, -0.03150212f, -0.00448348f, 0.00989764f, -0.03303771f, 0.00796025f, -0.00752248f, -0.04415471f, 
    -0.01937628f, -0.00985776f, -0.02557863f, -0.03436544f, -0.03410072f, -0.03560250f, -0.02442938f, -0.00369997f, 
    0.02318114f, -0.04240765f, 0.02622948f, -0.00781215f, -0.00784600f, -0.05100125f, 0.02038822f, 0.00660171f, 
    -0.00028060f, 0.00929878f, -0.00758990f, -0.03606056f, -0.03793660f, 0.02391584f, -0.00185944f, -0.04937432f, 
    0.01250953f, -0.05515889f, 0.00521051f, -0.04682481f, -0.00670663f, -0.00163121f, 0.04407402f, -0.03047862f, 
    -0.01108654f, -0.02495614f, 0.01448710f, -0.00877195f, 0.02752725f, 0.03164256f, -0.02634650f, -0.04339543f, 
    0.01531259f, 0.04053648f, -0.01672249f, -0.05617134f, 0.03085467f, -0.02474723f, -0.04663862f, -0.04893655f, 
    -0.00168596f, 0.01937165f, 0.02451946f, -0.02449432f, 0.02786609f, 0.00355349f, -0.02177648f, 0.02825529f, 
    -0.02698195f, -0.00160839f, -0.01897296f, 0.03005039f, -0.00114575f, -0.01215662f, 0.00787943f, 0.00173727f, 
    0.03021440f, -0.01045266f, 0.02680154f, -0.03915833f, 0.01372861f, -0.00131515f, 0.00209361f, 0.03694946f, 
    0.00656867f, 0.01635365f, 0.04625944f, -0.00052611f, -0.03365227f, 0.01144321f, -0.05067578f, -0.00738163f, 
    -0.02967068f, -0.00626776f, 0.02533368f, 0.03281928f, -0.01075823f, -0.01527029f, 0.02350246f, -0.04185830f, 
    0.03109489f, -0.03993473f, -0.01731582f, -0.03129729f, 0.01894549f, -0.01868052f, -0.01694586f, 0.00119178f, 
    -0.05615105f, 0.01234029f, 0.00840765f, 0.00472782f, -0.01226307f, -0.02271169f, 0.03442165f, -0.00970613f, 
    0.00321961f, -0.03579448f, -0.01266290f, 0.03621529f, 0.01162120f, -0.01247764f, -0.01181455f, 0.02929503f, 
    0.02888153f, 0.01770820f, -0.01556207f, -0.05058347f, -0.03251638f, 0.01537934f, -0.04112736f, -0.00030328f, 
    -0.01162262f, -0.02274501f, -0.04451983f, 0.00691412f, -0.01047880f, 0.01653728f, -0.04309662f, -0.03732707f, 
    -0.04632530f, -0.04467428f, 0.00185774f, 0.01307586f, 0.02165527f, -0.03149895f, 0.03594328f, 0.01285248f, 
    -0.04895912f, -0.04069925f, -0.04694375f, -0.04093369f, 0.01090277f, -0.00293693f, -0.03311148f, -0.01879047f, 
    -0.00909556f, -0.00769969f, 0.03047264f, 0.02263829f, -0.00491951f, -0.01007042f, 0.03275132f, -0.03114218f, 
    0.00340749f, -0.02806886f, -0.05444363f, -0.01586301f, -0.02097542f, -0.00734162f, -0.00619880f, -0.02519878f, 
    0.01959015f, 0.02880633f, -0.02627332f, -0.01466908f, -0.03474700f, 0.03156377f, 0.00825416f, -0.01863159f, 
    0.02263116f, 0.00024014f, -0.00950269f, -0.05350009f, -0.02580957f, -0.04521284f, -0.04608235f, 0.02568389f, 
    -0.05605881f, 0.01143445f, 0.01142089f, -0.03321968f, -0.03481117f, 0.03846230f, 0.01998646f, -0.01729315f, 
    -0.05395743f, -0.00087107f, -0.02732245f, -0.04407299f, 0.01801178f, -0.04947976f, -0.02802578f, -0.01608079f, 
    0.05186408f, 0.03995114f, -0.00851873f, -0.03805365f, -0.04805859f, -0.03858018f, 0.01395258f, -0.02412135f, 
    0.03293870f, 0.01229903f, 0.00874956f, 0.02964639f, 0.02658836f, -0.04478160f, 0.03892759f, 0.00515689f, 
    -0.00976133f, -0.01560966f, 0.02822068f, 0.04119086f, 0.04679993f, -0.00046915f, 0.02396704f, 0.02800746f, 
    0.01629166f, -0.03688487f, -0.01630105f, 0.02411869f, -0.04576952f, 0.03094965f, -0.02155906f, -0.03213402f, 
    0.00480188f, -0.01998761f, -0.01654203f, -0.01264271f, 0.01179012f, 0.02534001f, -0.03303482f, -0.05043196f, 
    -0.02476133f, -0.00716604f, -0.04279735f, 0.03428114f, -0.04788169f, -0.05048411f, -0.05597219f, -0.04975023f, 
    0.02192732f, 0.02946562f, 0.02372986f, 0.02131801f, 0.04828565f, 0.00662642f, -0.01323879f, 0.03468539f, 
    -0.02332897f, -0.02078873f, 0.03728351f, -0.03204604f, -0.02296542f, 0.05008613f, -0.05267850f, 0.03498601f, 
    -0.03780242f, 0.02242219f, -0.00476443f, 0.00308991f, -0.05626941f, -0.04503219f, -0.03502858f, -0.04900929f, 
    0.00829055f, 0.01443668f, 0.02979002f, -0.04799963f, -0.01714578f, -0.02713756f, 0.00238242f, 0.04447231f, 
    0.00193154f, 0.00672314f, -0.01972366f, -0.02919773f, -0.04623181f, 0.00441127f, -0.04632179f, 0.03331197f, 
    -0.01784723f, 0.02499864f, -0.00904041f, 0.02111775f, -0.01387087f, 0.02344920f, -0.04329057f, -0.03793772f, 
    -0.01715207f, -0.03784833f, 0.00085144f, -0.00073919f, 0.02902351f, -0.04448666f, -0.04319388f, -0.03612148f, 
    -0.03604347f, -0.00682584f, 0.03976525f, 0.00745475f, 0.03526533f, -0.04920822f, -0.02661414f, -0.01170449f, 
    0.02689512f, 0.04120646f, 0.02845146f, 0.04333684f, -0.00672967f, -0.03972521f, 0.04035069f, -0.05633176f, 
    0.01866815f, -0.05169098f, 0.04402807f, 0.00703015f, -0.02364352f, -0.02851236f, 0.03829053f, 0.02143910f, 
    -0.03163767f, -0.03847549f, 0.00730455f, -0.01786658f, -0.00598753f, -0.00277164f, -0.01880732f, 0.03079171f, 
    -0.05430215f, 0.01006371f, 0.03812775f, 0.00483167f, -0.02348515f, 0.00497744f, 0.01521232f, 0.03447983f, 
    -0.04258960f, -0.04128640f, -0.00775960f, -0.04202181f, -0.00529541f, 0.02112287f, -0.01160247f, -0.03545452f, 
    0.03530089f, -0.03129077f, -0.04583503f, -0.00224111f, -0.04326912f, 0.05036768f, -0.01972436f, -0.04819969f, 
    -0.00349595f, -0.01918854f, -0.04738947f, -0.01261318f, -0.02971082f, -0.05794909f, 0.03703818f, -0.01702521f, 
    -0.02003909f, 0.01152032f, 0.03489309f, 0.00256413f, 0.03615030f, -0.04954978f, -0.00713304f, -0.04371097f, 
    -0.04897334f, -0.05388738f, -0.04265390f, -0.02124629f, -0.04757636f, -0.00930775f, 0.03280678f, -0.00289105f, 
    -0.01179290f, -0.02722730f, -0.02844870f, 0.01055113f, 0.01381993f, 0.03943944f, -0.02525602f, -0.01903112f, 
    -0.00568498f, -0.03638403f, -0.01733648f, -0.04351919f, 0.01737002f, 0.04096460f, -0.05015464f, -0.03768216f, 
    -0.03424750f, 0.00661602f, 0.04098937f, 0.00285398f, 0.02244163f, -0.05257904f, 0.01236172f, -0.01602467f, 
    -0.02906886f, -0.03604139f, 0.04006391f, -0.03755163f, 0.04437055f, 0.01828074f, -0.02264385f, 0.00700539f, 
    -0.05010784f, 0.01234283f, 0.04640460f, 0.03625037f, 0.01376731f, -0.04349519f, -0.00754121f, -0.03763539f, 
    -0.00205195f, -0.00109024f, -0.01201450f, 0.00211789f, 0.03088109f, -0.00258812f, 0.00308101f, -0.00883821f, 
    0.01171540f, -0.05443237f, -0.04660397f, -0.02313963f, -0.00724120f, -0.00026631f, -0.01270432f, 0.02652981f, 
    -0.04859122f, -0.00722329f, -0.04510524f, -0.01140773f, 0.02291750f, -0.00892946f, 0.02963179f, -0.04435637f, 
    -0.02176897f, -0.03843080f, 0.02545936f, -0.01103389f, -0.02790524f, -0.04814729f, 0.01356412f, -0.00126519f, 
    0.01763363f, -0.02414786f, 0.01334626f, 0.04346779f, -0.04106670f, 0.02788373f, -0.02567660f, 0.03357460f, 
    -0.03642383f, 0.01104510f, 0.01453877f, 0.04335211f, -0.02201174f, -0.04538312f, -0.02483538f, -0.00716988f, 
    -0.01919694f, 0.00536632f, -0.01159269f, 0.03022547f, 0.02654277f, 0.04078092f, -0.00574655f, 0.04068732f, 
    -0.01185591f, -0.02580247f, -0.04986881f, -0.06036148f, -0.00177539f, -0.02206013f, -0.02475676f, 0.03900946f, 
    -0.00960818f, 0.02493313f, -0.04289533f, 0.00774553f, 0.02794175f, 0.01227410f, 0.02058860f, -0.00289225f, 
    -0.04289847f, -0.03500330f, 0.04555050f, 0.04026944f, 0.01301064f, 0.02109013f, -0.03782046f, 0.02751726f, 
    0.01156212f, -0.02718782f, -0.04856561f, -0.03265379f, -0.04892910f, 0.03453024f, 0.02386991f, 0.03503761f, 
    -0.04171322f, 0.01888085f, -0.01031240f, -0.01309573f, 0.00654486f, -0.02618876f, 0.01170550f, -0.00297511f, 
    -0.00775137f, -0.01465718f, -0.04318059f, 0.00826957f, -0.04775942f, 0.01955961f, -0.02755714f, 0.03089920f, 
    -0.00705005f, -0.04099318f, -0.03645008f, 0.01667685f, -0.02927724f, 0.00106919f, 0.00949863f, -0.04881543f, 
    -0.03158838f, 0.00644687f, -0.03445078f, -0.02683907f, 0.01124116f, -0.00786953f, 0.04182895f, -0.02365389f, 
    -0.02668752f, -0.00399320f, 0.01331907f, -0.02581194f, -0.03096171f, -0.02377401f, 0.04231871f, -0.00257224f, 
    -0.00694550f, 0.00458745f, 0.01150329f, -0.04615278f, -0.05411471f, 0.00915792f, -0.00784989f, 0.01309151f, 
    0.46966082f, -0.05693702f, -0.03616600f, 0.15310325f, 0.06823668f, -0.14894331f, 0.04519236f, -0.00592172f, 
    0.06010591f, -0.11324744f, 0.15337811f, -0.10321966f, -0.15669350f, 0.09210331f, -0.05063490f, -0.21505095f, 
    0.06770106f, 0.19566679f, -0.03890886f, -0.07213910f, 0.14044674f, 0.09669924f, 0.02792364f, 0.08951633f, 
    0.22547252f, -0.09062725f, 0.04925345f, -0.03654721f, 0.15533242f, 0.14711140f, -0.11098134f, 0.04945798f, 
    0.02942171f, 0.12844081f, 0.02096316f, -0.03577877f, 0.04214146f, 0.26051763f, -0.22299427f, 0.18681563f, 
    -0.00784100f, -0.09671945f, 0.11487181f, 0.02194684f, -0.07468943f, -0.00193553f, 0.07185017f, -0.01516008f, 
    -0.02994621f, 0.01414725f, 0.02752905f, 0.03701822f, -0.10251569f, -0.13511252f, -0.00070932f, -0.00716023f, 
    -0.05179258f, 0.09739093f, 0.11663342f, 0.05178335f, -0.03713637f, 0.02262292f, 0.03189929f, -0.27594048f, 
    0.01772419f, 0.15870830f, -0.03316031f, -0.02876926f, 0.03193972f, -0.02232970f, -0.02260805f, 0.03686821f, 
    0.01754103f, -0.07918421f, -0.18663006f, -0.19321671f, -0.01910966f, -0.01439482f, 0.16733849f, 0.12125591f, 
    0.07969824f, 0.02560194f, 0.01375570f, -0.15907529f, 0.11317398f, 0.13616604f, 0.32989287f, 0.04584086f, 
    -0.07556295f, 0.05764358f, -0.02007037f, 0.00386342f, 0.08191753f, -0.01386346f, 0.02082462f, 0.08716477f, 
    -0.05281516f, 0.16360731f, -0.04808308f, -0.00501546f, -0.03985544f, -0.00540797f, -0.04443800f, 0.10592987f, 
    0.06936100f, 0.15207338f, 0.02995978f, 0.11238337f, 0.13131392f, -0.01357665f, 0.15062280f, 0.17551473f, 
    -0.02524773f, 0.04575320f, -0.15343745f, -0.12525329f, 0.00648560f, -0.09902804f, 0.02109871f, -0.10384192f, 
    -0.04267380f, 0.08649331f, -0.18768935f, -0.01122539f, 0.00831534f, -0.04439327f, 0.10958799f, 0.03620502f, 
    -0.01951393f, -0.03970987f, -0.08637533f, 0.13860072f, 0.08801965f, -0.10846303f, -0.22885141f, -0.17145911f, 
    -0.05903554f, 0.00128053f, 0.07186984f, -0.00955567f, 0.14065199f, -0.00483468f, -0.01863967f, 0.02578728f, 
    0.18266639f, -0.10355724f, -0.17559916f, -0.26073578f, 0.06467569f, 0.21510431f, 0.00114870f, -0.14928339f, 
    -0.00325440f, -0.03951819f, 0.04864562f, 0.03464550f, 0.03512986f, 0.12735640f, 0.17736459f, 0.01691607f, 
    -0.05116104f, -0.13018847f, -0.11455230f, 0.11029553f, 0.08995467f, 0.23705696f, -0.00628363f, 0.00159759f, 
    -0.27608606f, 0.01794337f, -0.18476440f, -0.09202470f, 0.02359899f, 0.02988139f, -0.02541774f, -0.06677296f, 
    0.09325562f, -0.13653733f, 0.04232895f, 0.03130352f, 0.37523562f, -0.19665238f, 0.02650996f, 0.16165096f, 
    -0.06091848f, 0.00107258f, -0.07189471f, -0.01870897f, 0.05792850f, -0.05600663f, 0.06434169f, 0.04705384f, 
    0.16860279f, 0.12947272f, 0.06375284f, 0.19176446f, -0.13916041f, -0.13795312f, -0.03262705f, 0.06094522f, 
    0.05869953f, 0.08711689f, 0.00911927f, 0.06931558f, -0.05683954f, 0.23002332f, 0.03128272f, -0.14106192f, 
    0.15319620f, -0.07080492f, 0.09320275f, 0.09771404f, -0.05718320f, -0.07258895f, -0.04021807f, -0.01591299f, 
    -0.15120995f, 0.10438068f, -0.03754791f, 0.09639642f, 0.06882554f, 0.08793660f, -0.07255256f, 0.01591518f, 
    0.03261492f, -0.00126650f, 0.02366919f, 0.20047013f, -0.41882381f, 0.10775949f, -0.06598335f, 0.13307384f, 
    -0.00176941f, -0.11622308f, 0.05135701f, -0.08362541f, 0.02160794f, 0.03519263f, 0.03837852f, 0.08441394f, 
    0.28128877f, 0.01587582f, 0.17383285f, 0.05792630f, -0.14078283f, 0.02172323f, 0.04484653f, -0.07590328f, 
    -0.00504287f, 0.06815811f, 0.08031922f, 0.02242913f, -0.15727682f, 0.10899456f, -0.04462882f, -0.04312119f, 
    -0.01043728f, -0.06072883f, -0.08043905f, -0.03927300f, -0.06542786f, -0.02385253f, 0.07702894f, 0.11484668f, 
    0.05929474f, -0.02353513f, -0.13353233f, 0.28711525f, 0.07864973f, -0.07580695f, -0.00994302f, -0.06434455f, 
    0.03360257f, -0.07084680f, 0.00431366f, 0.10111067f, -0.03515373f, -0.01231787f, 0.04871010f, -0.01681240f, 
    -0.02146509f, 0.10727647f, -0.04880814f, -0.04668171f, 0.06516657f, -0.01427467f, 0.14442712f, 0.03469495f, 
    -0.04544007f, 0.03912200f, 0.01028789f, 0.33656737f, -0.09368543f, 0.04637258f, 0.04170204f, 0.01548945f, 
    0.18799733f, 0.04563580f, -0.03099322f, -0.04236805f, -0.12225466f, 0.15589526f, -0.11543310f, -0.03101911f, 
    -0.01140877f, 0.05261177f, -0.03005550f, -0.00400389f, 0.03989028f, -0.01761880f, -0.03327568f, -0.00008768f, 
    0.02756536f, 0.04356153f, -0.02768430f, 0.02549151f, 0.03628188f, 0.01951747f, -0.03230135f, -0.06547796f, 
    0.03319540f, -0.02586202f, 0.08866474f, -0.03603847f, 0.04315513f, 0.11323332f, 0.18560147f, 0.08077144f, 
    0.01752208f, -0.02519090f, 0.05212042f, -0.03480559f, 0.02101967f, 0.00137567f, 0.06273616f, 0.08462930f, 
    0.14478482f, -0.06451483f, 0.08964787f, -0.09301008f, -0.05803745f, 0.02214158f, -0.04289264f, -0.02609920f, 
    0.09964349f, -0.05822826f, -0.03222940f, 0.10795227f, 0.07294674f, -0.13044246f, 0.21879236f, 0.08520336f, 
    -0.12611365f, 0.11383029f, -0.03385434f, -0.12489087f, -0.14500283f, 0.07814028f, 0.06406056f, -0.08138677f, 
    0.17938170f, 0.12329916f, 0.20351774f, 0.03730673f, -0.04838344f, -0.04742578f, 0.02735171f, -0.01284208f, 
    -0.04302052f, 0.10231237f, 0.06768233f, 0.16673374f, 0.09673983f, 0.27305710f, -0.21925518f, 0.10593580f, 
    0.09737819f, -0.06891768f, 0.00617098f, 0.07961527f, -0.03754115f, 0.06339911f, 0.03241085f, 0.07766767f, 
    -0.02812129f, 0.01651440f, 0.02374696f, -0.01149128f, -0.05125015f, -0.06135193f, -0.04451369f, -0.05220951f, 
    0.01621812f, 0.01523366f, -0.04120605f, -0.04486245f, -0.00551246f, 0.04414790f, -0.00396364f, 0.02180738f, 
    0.03650644f, 0.02821493f, -0.04486529f, 0.00953822f, -0.04360802f, -0.04966432f, -0.02085284f, -0.02662060f, 
    -0.06271607f, 0.02185739f, 0.00630976f, -0.00866723f, -0.01451749f, -0.00906561f, 0.05005729f, -0.04087160f, 
    -0.01342456f, 0.03917276f, 0.02520449f, -0.03805666f, -0.04929270f, -0.05543623f, -0.02270167f, -0.00171789f, 
    -0.03752819f, -0.04644160f, -0.05646447f, -0.00269368f, -0.04809235f, 0.01292890f, -0.03828102f, 0.02620079f, 
    -0.00724661f, -0.04989701f, -0.01837684f, -0.01396821f, -0.03010789f, 0.01959742f, 0.01722396f, 0.03692797f, 
    -0.00218068f, -0.06746062f, 0.02242003f, -0.00170761f, 0.01462699f, 0.03127619f, -0.03174870f, 0.04188823f, 
    -0.04153127f, -0.01348248f, -0.02743208f, -0.01492896f, 0.02857929f, -0.03806612f, -0.02922861f, -0.02189451f, 
    -0.03363635f, 0.04597256f, 0.00281482f, -0.03866389f, -0.02805592f, 0.03045971f, -0.05182892f, 0.01240223f, 
    0.02803955f, 0.03654681f, -0.01621831f, 0.01206586f, -0.03768555f, 0.00613198f, -0.01566676f, -0.00375022f, 
    0.01901521f, 0.00617021f, 0.00021987f, -0.00738453f, -0.03141835f, -0.04665168f, 0.02915059f, 0.02232719f, 
    -0.00888351f, -0.00911071f, -0.01659944f, 0.02450210f, 0.00394082f, -0.00236675f, 0.00910502f, -0.00455042f, 
    0.04467814f, -0.03283223f, 0.04532025f, -0.03639157f, -0.05667316f, 0.00497897f, -0.03124908f, -0.05284424f, 
    0.03426828f, 0.00528052f, -0.03904315f, -0.03376447f, 0.03783311f, -0.03149434f, 0.02990390f, -0.04118074f, 
    -0.05371189f, 0.00548796f, 0.02181037f, -0.02463204f, 0.03920459f, -0.02961669f, 0.01775391f, 0.00785663f, 
    -0.05562899f, -0.01977734f, -0.02207510f, -0.00581217f, 0.03839079f, -0.02373356f, 0.02148691f, -0.01807792f, 
    -0.03234190f, -0.00971443f, -0.02811018f, 0.02271880f, 0.03311670f, -0.05168805f, 0.02695996f, -0.04740789f, 
    0.02426033f, 0.01499285f, 0.00658969f, -0.00227984f, 0.03829975f, 0.01128535f, 0.01523985f, 0.01843675f, 
    -0.04180877f, 0.00573035f, 0.02040301f, 0.02935336f, 0.01337234f, -0.01095598f, -0.04616214f, 0.03618361f, 
    -0.00866105f, -0.02321154f, -0.03504315f, 0.01945883f, -0.02741725f, -0.05009079f, -0.03428387f, -0.00704363f, 
    0.00999930f, -0.03329933f, -0.01102342f, -0.02787603f, -0.00107822f, -0.04156578f, 0.05420774f, -0.04461642f, 
    0.00428870f, 0.02460889f, -0.03455916f, -0.04900995f, -0.04538364f, -0.01319311f, 0.00620704f, -0.05051407f, 
    -0.05678296f, -0.03147574f, -0.04018757f, -0.04905555f, 0.03199038f, 0.02350667f, -0.01200060f, -0.02144418f, 
    -0.03667496f, 0.00722289f, -0.01106016f, 0.04017694f, 0.00328316f, -0.04610156f, 0.01695268f, -0.03447859f, 
    -0.00367572f, 0.02247835f, -0.03172959f, 0.00595029f, 0.04415538f, 0.00039127f, 0.05009198f, 0.00508515f, 
    -0.04349488f, 0.04106355f, 0.01297404f, -0.04781320f, 0.00502360f, 0.03088959f, 0.00876436f, -0.00224479f, 
    0.02212213f, 0.03353336f, 0.01652404f, 0.00351254f, -0.01746248f, -0.01103377f, 0.00497389f, 0.00867150f, 
    -0.03300592f, -0.04050047f, -0.05862202f, -0.00594548f, 0.04271980f, 0.03660130f, 0.01771498f, -0.02184446f, 
    0.00578885f, -0.01420973f, 0.00071785f, -0.01395731f, -0.02475462f, 0.04291663f, 0.03592993f, 0.01252533f, 
    0.02098909f, 0.03775615f, -0.03946444f, 0.02704872f, -0.01216219f, 0.02960394f, 0.03184823f, -0.02575187f, 
    -0.05612765f, 0.03882364f, 0.01578439f, -0.03544463f, 0.01080214f, -0.05925532f, -0.05133704f, 0.04032534f, 
    -0.02400705f, 0.03886692f, 0.02536561f, 0.01793368f, 0.03189112f, -0.00089794f, -0.04862343f, -0.04199301f, 
    -0.04201850f, 0.02237004f, 0.01364555f, 0.01445295f, 0.04470053f, -0.04917823f, -0.04274873f, -0.03026943f, 
    0.03638884f, 0.01617326f, 0.00805973f, 0.01137416f, -0.01385366f, -0.04943924f, 0.01999711f, 0.00443895f, 
    0.02064988f, -0.02329782f, 0.01639218f, -0.05034838f, -0.00371949f, -0.03379470f, -0.04241446f, -0.00391823f, 
    0.00961434f, -0.02344231f, 0.00532264f, -0.01640043f, 0.01169849f, 0.02505837f, -0.04349690f, 0.02048839f, 
    -0.00493277f, -0.02232800f, -0.00161213f, -0.05450495f, 0.00030130f, 0.04202950f, 0.02648260f, 0.00591576f, 
    0.03569077f, 0.01125005f, -0.04826026f, -0.02266335f, 0.03055058f, -0.00172949f, 0.01672368f, -0.03645144f, 
    -0.01459549f, -0.05283171f, -0.04412996f, 0.03705366f, -0.01172194f, 0.01391635f, 0.00118728f, -0.04978218f, 
    0.02883717f, -0.03709988f, -0.05875535f, 0.00639806f, -0.03980232f, -0.03436990f, 0.04388619f, -0.00015624f, 
    0.03400980f, -0.01632959f, 0.01139847f, 0.01348250f, 0.01491385f, -0.00029706f, -0.01271480f, -0.03549043f, 
    -0.03828087f, 0.00281456f, -0.00146660f, -0.01890428f, -0.05774586f, -0.01125754f, -0.00387834f, 0.04231518f, 
    -0.04148769f, 0.01163795f, 0.02953463f, -0.02281646f, -0.03038455f, 0.00968263f, -0.01950384f, -0.01662009f, 
    0.02521877f, -0.04648394f, -0.03150634f, -0.01170982f, -0.02031351f, -0.05712596f, -0.00887194f, 0.03871467f, 
    -0.04144330f, -0.01745049f, -0.02264304f, 0.03730182f, -0.02252203f, 0.03150373f, 0.02211618f, 0.04190596f, 
    0.04190834f, -0.04021253f, 0.01652364f, 0.01315165f, 0.03994154f, 0.00139763f, -0.02574168f, -0.04877509f, 
    -0.02902414f, -0.02968980f, -0.05024110f, -0.04281214f, 0.03289451f, 0.02873295f, -0.06366926f, 0.02594700f, 
    -0.00217045f, 0.01821849f, -0.03991923f, -0.05294100f, 0.04496977f, 0.01434711f, 0.01460034f, 0.02645723f, 
    0.03581316f, -0.03746365f, -0.00793013f, 0.01999117f, -0.01689718f, -0.01553313f, 0.02610147f, 0.02700348f, 
    0.02725957f, 0.03545901f, 0.02873362f, 0.02380030f, 0.02181154f, -0.03213783f, 0.02368158f, -0.01643315f, 
    -0.00321530f, -0.01336753f, 0.00858535f, -0.05195275f, 0.00712027f, -0.00089584f, 0.01066164f, 0.02355138f, 
    -0.04108958f, 0.01680172f, 0.01797782f, -0.05229813f, -0.03006460f, 0.02717385f, 0.04951466f, -0.04163894f, 
    0.00509076f, 0.01220815f, -0.02435946f, -0.03703883f, 0.04941311f, 0.01557636f, 0.03676863f, -0.00060522f, 
    -0.04089731f, 0.01974597f, 0.00919228f, -0.01208778f, -0.01248894f, 0.00141911f, -0.04132342f, 0.03758340f, 
    -0.05212283f, 0.00115605f, -0.02279120f, -0.01904197f, 0.03529318f, -0.00127385f, 0.03318103f, -0.05247202f, 
    -0.02455727f, -0.05151706f, -0.01125789f, -0.02847138f, -0.03087879f, 0.00265793f, 0.03566691f, -0.06062498f, 
    0.00787897f, -0.02545443f, -0.00756590f, -0.04805970f, 0.02759511f, 0.02565945f, -0.05436577f, -0.01239869f, 
    0.02213412f, 0.02434519f, -0.04041775f, 0.02910395f, 0.02126248f, 0.01836487f, -0.00178804f, 0.04565268f, 
    -0.04646188f, 0.03381373f, -0.05222229f, -0.02066542f, -0.03621057f, 0.02869732f, -0.04328232f, 0.02595408f, 
    0.02420051f, 0.01073882f, 0.00204859f, -0.00463730f, -0.00153836f, 0.04615634f, -0.00209580f, -0.00593859f, 
    -0.01082845f, -0.03407976f, -0.04970606f, 0.01237434f, -0.00182386f, 0.06474320f, 0.02182694f, -0.04667523f, 
    -0.05906935f, 0.00597273f, 0.00298624f, 0.02571681f, 0.04352792f, -0.01484926f, -0.02304996f, 0.04556993f, 
    -0.00910875f, 0.03320011f, -0.03011907f, -0.02263035f, -0.05549814f, 0.03486443f, 0.03180609f, 0.01498123f, 
    0.03542589f, -0.04315152f, -0.01308838f, -0.05318659f, -0.00312518f, -0.02899984f, -0.03126523f, 0.03462129f, 
    0.02217834f, -0.03350645f, -0.05248203f, -0.02652410f, -0.04987559f, 0.01276880f, -0.02831693f, -0.05346046f, 
    0.03166382f, 0.01403699f, 0.01926741f, 0.00886699f, -0.02208490f, -0.00220780f, 0.00812151f, -0.03770622f, 
    0.02758721f, -0.00365489f, -0.06018278f, 0.04081674f, 0.00929233f, -0.02784397f, -0.01947218f, -0.05741171f, 
    -0.00058922f, -0.02347155f, 0.01234907f, 0.00462657f, 0.03946471f, -0.05125463f, -0.05944107f, -0.05961559f, 
    -0.04921201f, 0.02011672f, -0.02254267f, -0.04094167f, -0.02317532f, -0.05150627f, -0.00258321f, -0.02348277f, 
    -0.00081723f, -0.01126393f, -0.03578572f, -0.03569209f, -0.03487236f, 0.04447838f, -0.01420953f, 0.04499476f, 
    0.01634662f, -0.06229791f, 0.00746081f, -0.04184078f, -0.04182132f, 0.00817287f, -0.03999734f, -0.01111591f, 
    0.00078896f, 0.02095111f, -0.05037052f, 0.04329057f, 0.01095134f, -0.03089130f, 0.03192372f, -0.02642691f, 
    0.00210516f, -0.00251182f, -0.02997703f, 0.03452286f, -0.04042699f, 0.04673206f, 0.00767741f, -0.05023773f, 
    -0.00702443f, -0.03448682f, -0.04149769f, -0.02221148f, -0.03202548f, -0.02749445f, 0.01284338f, -0.05639443f, 
    -0.04246021f, 0.02582741f, -0.00458589f, 0.00031505f, 0.00298767f, 0.00366154f, 0.01529767f, 0.00317040f, 
    0.04230807f, -0.04017510f, -0.03501610f, -0.01295344f, -0.01706600f, 0.03428694f, -0.05603449f, 0.00380776f, 
    -0.05618948f, -0.00886450f, -0.03715647f, -0.02091741f, 0.01409117f, 0.04664505f, 0.03437653f, 0.00055163f, 
    -0.02797739f, 0.00278217f, 0.00557988f, -0.04206566f, 0.03093209f, -0.04826671f, 0.00111354f, 0.01381078f, 
    0.03831057f, 0.03642982f, -0.06239774f, -0.02333453f, 0.01948087f, 0.02494786f, -0.04777002f, -0.04339993f, 
    -0.03261569f, 0.04884940f, 0.01566547f, -0.01515410f, 0.02035912f, -0.02796031f, -0.02156823f, -0.05524026f, 
    0.01365718f, 0.03435764f, -0.04725046f, -0.00180513f, -0.00542241f, 0.00850762f, -0.02795727f, -0.03031913f, 
    0.03959435f, 0.01159740f, 0.02065020f, 0.00168355f, -0.02971534f, 0.02844163f, -0.04109080f, -0.05297226f, 
    -0.02191072f, 0.02975291f, -0.05533445f, 0.03045181f, 0.00429313f, 0.03777958f, -0.04026176f, 0.03048628f, 
    -0.02465684f, 0.01524956f, -0.00756366f, -0.02384279f, -0.02160996f, 0.01003066f, 0.00775272f, 0.04420058f, 
    0.01686789f, -0.04474298f, -0.04747554f, 0.02225550f, 0.04187050f, -0.02095079f, 0.00168423f, 0.03047800f, 
    -0.04220746f, 0.01390120f, 0.00592481f, 0.00801275f, 0.00509198f, -0.04084170f, -0.01391641f, 0.02997964f, 
    0.00072189f, -0.01867595f, -0.00478315f, -0.03063340f, -0.01173548f, -0.02215670f, 0.04568817f, -0.00210944f, 
    -0.01199919f, 0.04421099f, 0.02599336f, 0.04326911f, -0.02328525f, 0.02084456f, 0.00072147f, -0.04840836f, 
    -0.00021106f, 0.02064638f, 0.03053351f, 0.00116563f, 0.01223463f, -0.00957150f, -0.01453741f, -0.06650990f, 
    0.00965472f, 0.01753560f, -0.01679436f, -0.05763437f, 0.00220604f, -0.05049114f, 0.00112939f, -0.01162909f, 
    -0.00430679f, 0.00563070f, 0.02811344f, 0.02721404f, -0.04338262f, -0.03908506f, 0.03345526f, 0.03889730f, 
    -0.03369717f, 0.01153673f, 0.01376205f, 0.01418707f, -0.02575470f, -0.04046391f, 0.02654359f, -0.03412582f, 
    -0.04947900f, -0.05496013f, -0.02061990f, -0.02170282f, 0.03712774f, -0.03371332f, 0.02752989f, 0.04112554f, 
    -0.01351910f, 0.03028881f, -0.04850418f, -0.02621020f, 0.01873455f, 0.03033830f, -0.05001244f, -0.03894476f, 
    -0.05921128f, 0.00314246f, -0.04402772f, -0.02491372f, 0.00667595f, -0.04533859f, -0.02313543f, 0.03391527f, 
    -0.21321578f, 0.01846901f, 0.03940592f, 0.09948980f, -0.14706999f, -0.02429188f, 0.04296475f, 0.04302309f, 
    0.10672063f, 0.06209798f, -0.25223228f, 0.11270449f, 0.05262500f, 0.20971945f, 0.01613137f, 0.21035329f, 
    0.04371382f, -0.15762398f, 0.00621162f, 0.09356299f, 0.03495331f, -0.06311481f, 0.03674566f, -0.16732751f, 
    -0.50011224f, 0.04299941f, 0.21863128f, -0.11515101f, 0.06292135f, -0.04760649f, 0.17024502f, -0.11149415f, 
    0.01764155f, -0.00112032f, 0.09982438f, 0.05087291f, 0.38313213f, 0.11671956f, 0.15499477f, -0.00441102f, 
    -0.00976693f, 0.02868175f, -0.05857410f, 0.01573467f, 0.05145089f, -0.01610499f, 0.06079531f, 0.08123644f, 
    -0.01963390f, -0.02276192f, -0.18369046f, 0.03572631f, -0.00079330f, 0.10944504f, 0.10912800f, 0.01545078f, 
    0.14926569f, -0.06549673f, -0.05806455f, -0.00176834f, -0.22191902f, -0.17497684f, -0.05526804f, 0.01586810f, 
    0.08428000f, -0.14117667f, -0.03189057f, -0.02403844f, -0.02826461f, -0.00376232f, 0.03656440f, 0.14126316f, 
    -0.08563292f, 0.06886265f, -0.06558263f, 0.15340409f, 0.03069915f, -0.08637517f, 0.01901608f, 0.04128453f, 
    -0.12467463f, 0.04899552f, 0.07913552f, 0.14052445f, -0.07610869f, 0.07536308f, -0.13661750f, -0.11139771f, 
    0.08131780f, 0.01761252f, 0.03681554f, -0.00607794f, -0.01846430f, -0.18014851f, 0.03686218f, -0.02763730f, 
    0.01010943f, -0.22023645f, 0.00254606f, 0.26060236f, -0.00226408f, 0.06422055f, 0.05376659f, -0.05656007f, 
    0.02306335f, -0.05910811f, 0.05120578f, -0.11742530f, 0.08151659f, 0.11231352f, -0.08313695f, -0.16625929f, 
    0.06448773f, -0.07972121f, 0.23107760f, 0.03327330f, -0.01373641f, 0.12610877f, 0.11602709f, 0.15907885f, 
    0.11629672f, 0.25335702f, 0.19877194f, 0.22821009f, 0.02494965f, -0.05968541f, -0.13610287f, 0.06042339f, 
    0.00024295f, 0.01761746f, 0.03983073f, -0.07221409f, 0.20776623f, 0.06277119f, 0.04199490f, -0.02278372f, 
    0.17287336f, 0.18158565f, -0.03775571f, 0.02913783f, -0.02091543f, -0.03949179f, 0.07376265f, -0.11485519f, 
    -0.03461245f, 0.04846278f, -0.11927422f, -0.18748347f, -0.00441279f, 0.12206374f, 0.00626598f, 0.17254217f, 
    0.15139790f, -0.01800913f, -0.00440451f, 0.14879069f, -0.15699314f, -0.24583755f, -0.01543897f, 0.08047964f, 
    0.09327027f, 0.06205034f, 0.08203456f, -0.11236909f, -0.06301031f, -0.25475818f, 0.20484775f, 0.06650139f, 
    0.31539422f, -0.10691810f, 0.00465002f, 0.13543023f, -0.01193411f, 0.02417875f, 0.09022168f, -0.08617991f, 
    -0.12621896f, 0.04613468f, -0.20929328f, -0.14900924f, -0.13167538f, 0.02455626f, 0.01070632f, -0.11673634f, 
    0.09374302f, -0.01279996f, 0.02279142f, 0.07511052f, -0.06215226f, 0.02617842f, 0.03777333f, 0.08063823f, 
    -0.06379952f, -0.14168979f, -0.00365678f, -0.21307558f, -0.04995719f, 0.07369906f, 0.07752494f, -0.08718108f, 
    -0.05084382f, -0.11532339f, -0.01974202f, -0.03076687f, 0.33565992f, -0.00883060f, -0.01646270f, -0.12378325f, 
    0.06307953f, 0.13339902f, -0.11142491f, -0.03530271f, 0.06647191f, 0.09958997f, 0.20013706f, 0.15900645f, 
    -0.14742358f, 0.02589697f, 0.08798545f, 0.09125797f, -0.02204351f, -0.16628037f, -0.00594142f, -0.20608978f, 
    -0.08963401f, -0.07667254f, -0.12945700f, -0.07552802f, 0.32025546f, -0.10249925f, 0.02947482f, 0.17004894f, 
    0.05183542f, 0.15634207f, -0.07605699f, -0.05699800f, -0.00636921f, 0.12513936f, 0.00151774f, -0.01817657f, 
    0.23046315f, 0.13666403f, -0.23816337f, -0.08334586f, 0.11553210f, 0.01692607f, 0.05209804f, -0.08036340f, 
    0.01129175f, -0.08643240f, -0.05091326f, -0.00104573f, -0.06999657f, -0.19133565f, -0.07728673f, 0.07996925f, 
    0.01894019f, 0.03601447f, -0.16173121f, 0.01280066f, 0.18455622f, -0.02111523f, -0.17086001f, -0.18800132f, 
    -0.05213408f, 0.36409777f, 0.28274083f, -0.07699190f, -0.10620798f, -0.03713765f, 0.06253045f, -0.06704964f, 
    0.09294083f, 0.05753655f, 0.05431940f, 0.16134591f, -0.33099097f, 0.18953174f, -0.08452295f, -0.06063871f, 
    0.11441744f, -0.06440148f, 0.11057433f, 0.07603251f, 0.04559650f, 0.08607581f, 0.06282682f, 0.05089883f, 
    0.21140899f, 0.03415786f, -0.07717239f, -0.15100321f, 0.12538767f, 0.05050347f, -0.13487825f, 0.05135243f, 
    -0.19661298f, -0.18504478f, 0.03508221f, -0.12629333f, 0.55645639f, -0.40189362f, 0.16596754f, 0.01237025f, 
    -0.00389317f, 0.03992933f, 0.05875752f, 0.12748279f, -0.10434344f, 0.00025278f, 0.09380606f, 0.09439566f, 
    0.09718758f, -0.17111571f, 0.06479966f, 0.07786477f, 0.08718519f, 0.06506896f, 0.07733177f, 0.09913819f, 
    0.06018709f, -0.05576186f, -0.09883401f, 0.10047639f, 0.13027519f, 0.10556291f, -0.15656845f, -0.19311935f, 
    0.03243362f, -0.01443289f, -0.05409972f, 0.04789945f, -0.00582724f, 0.06446317f, 0.05128076f, -0.11755975f, 
    0.03542722f, 0.15952773f, -0.06836602f, -0.06298029f, 0.05921341f, -0.06155079f, 0.01731345f, 0.05368296f, 
    -0.06459832f, 0.04046378f, 0.08797723f, -0.09486189f, -0.21184440f, -0.07208968f, 0.02464139f, -0.15712193f, 
    0.10766036f, -0.07254043f, 0.06573829f, 0.15021488f, 0.11052284f, -0.14849944f, 0.05737993f, 0.08147145f, 
    0.16907844f, 0.03729450f, -0.00026850f, -0.09987763f, 0.04386126f, 0.02376892f, -0.09802080f, -0.03074895f, 
    0.06364696f, -0.14306791f, -0.07809865f, -0.17560381f, 0.28841493f, -0.03676008f, 0.14862950f, 0.08615025f, 
    -0.07524242f, 0.02274573f, -0.19554144f, 0.03510891f, -0.04684760f, 0.01334564f, 0.01654802f, -0.03151201f, 
    -0.01910028f, 0.01093837f, 0.03241433f, 0.02263837f, -0.01830692f, -0.03045514f, 0.00325147f, 0.03875999f, 
    -0.04221496f, -0.03250729f, 0.03805757f, 0.01175979f, -0.05598453f, -0.04986581f, -0.03561425f, -0.01659187f, 
    0.00765566f, -0.05350607f, 0.01362719f, -0.02182164f, 0.02600898f, -0.00243001f, -0.00806734f, -0.04708628f, 
    0.03883518f, 0.02197467f, -0.03686849f, 0.00089889f, 0.02667621f, 0.01635192f, 0.00379071f, 0.00865645f, 
    -0.01595905f, -0.02844187f, 0.00149712f, -0.05722892f, 0.00793632f, -0.02635503f, 0.01612748f, 0.03480455f, 
    0.03370710f, -0.05040858f, 0.01421745f, 0.03017760f, -0.03304880f, -0.04738758f, -0.00501658f, 0.01959694f, 
    0.04164951f, -0.04531582f, -0.00215915f, -0.01009854f, -0.05541476f, 0.02529003f, -0.04118255f, 0.03185645f, 
    -0.00776065f, -0.00815558f, -0.02631552f, -0.02298718f, 0.02995399f, 0.02400033f, 0.01891244f, -0.03952746f, 
    -0.02036103f, -0.00840514f, 0.00744423f, 0.01761052f, 0.03480494f, -0.05441763f, -0.04144805f, -0.05401893f, 
    0.02846418f, -0.03477625f, -0.01571986f, 0.02431415f, 0.01066419f, -0.02632695f, 0.02535315f, 0.01650424f, 
    0.00050940f, -0.04792230f, -0.01578981f, -0.00548633f, 0.00889355f, 0.01981324f, -0.01317279f, 0.00564135f, 
    0.00104311f, -0.03652710f, -0.00316602f, 0.02506204f, -0.02185108f, 0.01826833f, -0.05477240f, -0.02824589f, 
    -0.05655693f, 0.00413618f, -0.01285056f, -0.01535256f, 0.02156271f, -0.01023512f, 0.00098031f, -0.00212910f, 
    -0.04477197f, 0.03810276f, 0.02773343f, -0.03790715f, -0.02898005f, 0.03686266f, -0.02619521f, -0.01474629f, 
    -0.00585721f, -0.02507250f, -0.01393603f, -0.02378763f, 0.02587654f, 0.03831071f, -0.04865709f, -0.04605099f, 
    -0.00888266f, -0.05170980f, 0.00214216f, -0.00736091f, 0.01596749f, 0.00722709f, 0.02185961f, -0.03357436f, 
    0.00557664f, 0.04199255f, -0.05000394f, -0.03861128f, 0.03257600f, 0.02360337f, 0.03841031f, -0.04769257f, 
    -0.02380287f, 0.01862656f, 0.01390322f, -0.02836862f, -0.01205963f, 0.01995734f, -0.00603026f, -0.03929025f, 
    0.01794837f, -0.02282226f, 0.01178394f, -0.02232563f, -0.00311893f, -0.05151199f, -0.04554304f, -0.05267394f, 
    0.00440884f, -0.04856949f, 0.01804413f, 0.03522979f, -0.03995745f, 0.03112110f, -0.00145759f, -0.02019233f, 
    -0.04777593f, 0.01187154f, -0.01360914f, 0.00528218f, 0.01169135f, -0.02721336f, -0.01421797f, 0.02292935f, 
    0.01960595f, -0.04252948f, -0.01060108f, 0.02464086f, 0.03571097f, -0.00894415f, 0.03939134f, -0.03398652f, 
    0.02234297f, -0.02192381f, -0.04347331f, 0.03477529f, 0.01321257f, -0.03588600f, -0.00620493f, -0.01739183f, 
    -0.01387378f, -0.04226446f, -0.04824946f, -0.05232706f, -0.05351099f, 0.03240625f, 0.03605102f, -0.03678801f, 
    -0.03360166f, -0.02800062f, -0.04302879f, -0.03135001f, 0.00390726f, 0.00162839f, -0.01444206f, -0.03140582f, 
    0.00599397f, -0.03510901f, -0.04403686f, -0.04660350f, -0.03926767f, 0.03387520f, -0.04381149f, -0.01838263f, 
    -0.03552361f, 0.00767150f, 0.01023785f, 0.00664125f, -0.03353105f, 0.03557314f, -0.01708536f, 0.03335826f, 
    0.01512671f, 0.02292428f, -0.05798509f, -0.03787252f, 0.03822231f, 0.03564309f, -0.01476392f, 0.01798023f, 
    0.02003980f, -0.04150232f, 0.01785496f, -0.00756387f, -0.05358188f, -0.01044902f, -0.01334636f, -0.04057750f, 
    -0.03303677f, 0.03656198f, -0.03492903f, -0.03106321f, -0.01392674f, -0.03232019f, 0.00863426f, -0.02093236f, 
    0.02021482f, -0.02474467f, -0.03133670f, 0.01888890f, 0.00409786f, 0.01887343f, 0.02237888f, 0.03358422f, 
    -0.00141555f, -0.05066659f, 0.01662707f, -0.01762275f, -0.05567561f, -0.05018565f, -0.04355689f, 0.01851111f, 
    0.03119292f, -0.03883970f, -0.04484782f, 0.00436170f, -0.00553560f, -0.01175734f, 0.00466061f, 0.04105698f, 
    -0.01921596f, -0.02424033f, 0.00352356f, -0.03273911f, -0.02679932f, -0.03005935f, -0.05345615f, 0.02149287f, 
    -0.04900454f, -0.03821501f, 0.03271027f, -0.00481584f, 0.01453761f, 0.03680346f, 0.00298694f, -0.00616683f, 
    0.00781394f, -0.01573910f, -0.02402910f, -0.05639584f, -0.05682314f, -0.05273315f, -0.05467310f, 0.01514057f, 
    -0.04715940f, -0.00717823f, -0.00857658f, 0.03871392f, -0.03425523f, 0.02088577f, -0.04419131f, 0.02076202f, 
    -0.04348676f, -0.02964162f, -0.03781293f, -0.02696027f, -0.00602477f, 0.03329437f, -0.04169445f, -0.03674502f, 
    -0.05523397f, -0.05857399f, -0.00458818f, 0.00820482f, -0.03937142f, -0.02561508f, 0.01614909f, 0.03674132f, 
    -0.01942423f, -0.01742841f, -0.02272004f, -0.00738681f, 0.01411252f, -0.04648295f, -0.05724359f, -0.04141529f, 
    -0.02673673f, 0.01230302f, 0.01844092f, 0.03824291f, 0.03927946f, -0.03643878f, 0.00446468f, -0.05236006f, 
    0.03202920f, -0.00314045f, -0.03696978f, -0.05434581f, -0.02584828f, 0.03994093f, 0.02695829f, 0.03379275f, 
    0.00502881f, -0.04206811f, 0.02538267f, -0.04487059f, -0.04301591f, -0.01608024f, 0.01253959f, 0.03446151f, 
    0.00852135f, 0.01158244f, -0.04715285f, -0.05061994f, 0.00029387f, -0.02489285f, -0.03127977f, 0.02005795f, 
    0.03434402f, -0.00695274f, -0.05484181f, -0.04952762f, 0.01270975f, 0.01789360f, -0.01113486f, -0.02457219f, 
    -0.03777215f, -0.00141481f, 0.02853171f, 0.04209170f, 0.00271529f, 0.01953857f, 0.04048584f, -0.04479412f, 
    0.02511545f, 0.02857551f, -0.03942517f, 0.03132073f, 0.00511432f, 0.02393953f, -0.05631272f, -0.04430249f, 
    0.03385593f, 0.03666868f, -0.03086922f, -0.04783352f, -0.01458315f, -0.01781404f, 0.02826294f, -0.04959087f, 
    0.30600059f, -0.21842569f, -0.03640207f, 0.04353539f, -0.05036532f, -0.13831583f, 0.02437784f, -0.06643348f, 
    0.04908484f, -0.03045405f, 0.03920510f, -0.06321567f, -0.03033428f, 0.07181400f, 0.11965635f, -0.20604436f, 
    0.03555087f, 0.24141696f, 0.05523077f, -0.00050219f, 0.21378557f, 0.07902347f, 0.00772806f, 0.05875005f, 
    0.20315577f, 0.00414879f, 0.23795865f, -0.15344729f, 0.03663185f, 0.09672598f, -0.02567405f, 0.08730558f, 
    -0.07341535f, 0.07996423f, 0.00382816f, -0.04760254f, -0.15564898f, 0.13065839f, -0.27025387f, -0.00269043f, 
    -0.01131827f, -0.11749103f, -0.03786574f, 0.02917972f, -0.09084869f, 0.03409450f, 0.01991798f, 0.07114399f, 
    -0.01638535f, 0.06152650f, -0.09602766f, 0.07445368f, 0.01891416f, -0.07494711f, -0.06113023f, -0.03221371f, 
    0.02206017f, 0.02112297f, 0.07116039f, 0.07457630f, 0.04907590f, 0.01268438f, 0.25330335f, -0.14561100f, 
    -0.11511742f, 0.08886953f, -0.01254785f, 0.02187936f, -0.03344111f, -0.00630427f, -0.04379586f, 0.04549744f, 
    0.10209951f, -0.04984334f, -0.16501163f, 0.12457501f, -0.03048386f, -0.07634076f, 0.13636439f, -0.00889459f, 
    0.00836473f, 0.08613908f, -0.04224690f, -0.12385743f, 0.16267020f, 0.10764463f, 0.21113168f, 0.11921319f, 
    -0.00842479f, 0.01164194f, -0.04393100f, -0.01268580f, 0.06019501f, 0.05723506f, -0.00803029f, 0.02366485f, 
    0.12766807f, 0.14133939f, -0.08271093f, -0.05044954f, 0.03352791f, -0.04467165f, -0.04711808f, 0.05009544f, 
    0.01475467f, 0.06439052f, -0.01998725f, 0.09483463f, 0.32943472f, 0.00486240f, 0.05721747f, 0.13021553f, 
    -0.07432985f, 0.05162068f, -0.07655916f, -0.15647331f, -0.00476390f, -0.07443525f, -0.07169987f, -0.09232688f, 
    0.06606314f, -0.07166182f, -0.18394098f, 0.11547686f, 0.04224685f, -0.07509691f, -0.02896664f, 0.08252881f, 
    0.03545052f, -0.07482202f, -0.05716949f, 0.05511713f, 0.33467850f, 0.24768057f, 0.13600087f, -0.03417498f, 
    -0.00159288f, 0.04282457f, 0.11447220f, -0.08512861f, 0.05212150f, 0.03785902f, -0.00730237f, 0.04654271f, 
    0.37608734f, 0.24311180f, 0.00229477f, -0.10877709f, 0.06292914f, 0.11931111f, 0.03410968f, -0.08139348f, 
    0.02061353f, -0.03457408f, -0.03575641f, -0.02898569f, -0.06959110f, 0.12698142f, 0.33871940f, 0.23544687f, 
    0.08175191f, -0.13600728f, -0.07160728f, -0.01040678f, 0.01877951f, 0.16748880f, -0.05372842f, -0.02703534f, 
    -0.13308826f, 0.21299398f, -0.10737169f, -0.04124967f, 0.07391354f, -0.03926645f, -0.02488889f, 0.01058054f, 
    0.13080317f, -0.11687984f, 0.04144232f, -0.11340974f, 0.25250530f, 0.01913179f, -0.08675835f, 0.20771745f, 
    -0.01634866f, -0.04920894f, -0.10059526f, -0.00640142f, -0.02999500f, -0.08160783f, -0.01195234f, -0.06737852f, 
    0.14822176f, 0.01448007f, 0.03217890f, 0.19649784f, -0.12678190f, -0.10280954f, -0.00065003f, -0.00437350f, 
    0.04959685f, 0.03630140f, -0.00205763f, 0.00188341f, 0.05970253f, 0.04871793f, -0.24688314f, -0.04892371f, 
    0.18469898f, -0.10045988f, -0.03455286f, 0.00910816f, -0.07278822f, 0.02192995f, 0.02644049f, -0.00790383f, 
    -0.12442438f, 0.19832078f, 0.04837144f, 0.06029159f, 0.15468994f, 0.09863556f, -0.11883251f, -0.00601576f, 
    0.06666721f, 0.10224758f, 0.08498170f, 0.17938100f, -0.38008848f, 0.09682160f, -0.09436632f, 0.29944614f, 
    0.07808571f, -0.06525247f, 0.08344615f, -0.14961968f, 0.12103309f, -0.02015931f, -0.10279229f, 0.04540097f, 
    0.21928681f, -0.04987398f, 0.07228573f, 0.13385168f, -0.18164419f, 0.01582132f, 0.00042619f, -0.08308317f, 
    0.03046120f, 0.07595267f, 0.03238152f, -0.02901039f, 0.13992378f, 0.25355875f, 0.08460224f, -0.05390838f, 
    -0.06685364f, -0.02961584f, 0.05482224f, -0.00688899f, -0.00256247f, 0.03745861f, 0.02758188f, 0.09231640f, 
    -0.00814527f, 0.02255113f, -0.21563752f, 0.17996611f, 0.02024803f, -0.11439016f, -0.14814229f, -0.06404268f, 
    0.05912929f, 0.02286807f, -0.00247496f, 0.03720034f, -0.06571154f, 0.07564992f, 0.19306912f, -0.08924072f, 
    0.04348189f, 0.06465838f, -0.06373464f, -0.08444069f, -0.01383481f, 0.01566467f, -0.02494306f, 0.05909347f, 
    0.00865187f, -0.01074868f, 0.01775095f, 0.16822289f, -0.19312955f, -0.02496248f, 0.02463550f, -0.06295821f, 
    0.15645146f, 0.10674963f, 0.04716030f, -0.00325376f, -0.00210315f, 0.29569551f, -0.01227251f, -0.01881442f, 
    0.06557424f, 0.01460674f, -0.10789146f, -0.02271817f, 0.02102970f, -0.00909200f, -0.01312431f, 0.00259297f, 
    -0.04937316f, 0.16182101f, -0.19434798f, 0.02667115f, 0.03376376f, 0.03592229f, -0.15177920f, -0.08576712f, 
    0.07011252f, 0.03523529f, 0.06157520f, -0.18015669f, 0.15041155f, -0.11252619f, 0.08007102f, 0.08722842f, 
    -0.13072939f, -0.03424185f, 0.03592050f, -0.03821197f, 0.05408706f, 0.02586416f, -0.06592011f, 0.08784876f, 
    0.06915710f, -0.07752538f, -0.01337888f, -0.05455390f, -0.03177891f, 0.02330164f, -0.06684091f, 0.07988390f, 
    0.04031510f, -0.00087804f, -0.01569876f, 0.13795175f, 0.18630731f, -0.04611515f, 0.10623495f, 0.12101725f, 
    -0.07619941f, 0.02686260f, -0.01236724f, -0.01840177f, -0.01689460f, 0.03918802f, 0.00234047f, -0.11140504f, 
    0.08031546f, -0.02636600f, 0.10154642f, -0.01414158f, -0.03259727f, -0.06335055f, -0.03093237f, 0.01792048f, 
    -0.02037583f, 0.12391061f, 0.15495443f, 0.10520472f, 0.11323954f, 0.12837322f, -0.25737134f, 0.01186332f, 
    0.07875101f, -0.06160875f, 0.02378646f, 0.06396675f, 0.06086181f, -0.01901407f, -0.03786217f, -0.00112572f, 
    -0.13223566f, -0.12904505f, -0.02358202f, -0.14417359f, -0.00798778f, 0.00506512f, -0.07320659f, 0.12527193f, 
    0.08390954f, -0.04071653f, 0.02409781f, -0.04001375f, 0.25400841f, -0.03836203f, 0.27424899f, 0.20234658f, 
    0.02249658f, 0.07833041f, 0.05219229f, 0.07624091f, -0.06131867f, -0.00634718f, 0.06584715f, 0.06478900f, 
    0.52110612f, 0.16194439f, -0.12541933f, 0.08561698f, 0.00259813f, -0.05614949f, 0.07217036f, 0.01522847f, 
    -0.18757592f, 0.06839171f, -0.04168857f, 0.04212849f, -0.06674303f, -0.25591815f, 0.26194310f, -0.16066360f, 
    -0.00003703f, -0.08183545f, 0.03142776f, -0.04863698f, -0.02376758f, -0.06536841f, 0.05718546f, 0.20211157f, 
    -0.05322297f, 0.29852194f, -0.00691628f, 0.11606324f, 0.05662277f, 0.07713259f, -0.10728750f, 0.01903803f, 
    -0.07841682f, -0.00235198f, 0.02668627f, -0.00259178f, 0.50894964f, -0.00494735f, 0.03718212f, 0.33477050f, 
    0.07433735f, 0.12414599f, 0.16506496f, 0.13895628f, 0.00719425f, -0.03386267f, 0.06817186f, 0.01455441f, 
    0.11992291f, 0.17674074f, 0.18216862f, 0.16135003f, 0.00155028f, 0.16720678f, -0.00916471f, -0.00353150f, 
    0.02758760f, -0.04285234f, 0.04416385f, -0.00344722f, -0.00450573f, -0.13335972f, -0.21970718f, -0.02827438f, 
    0.04415674f, 0.01117345f, -0.00395651f, -0.02649407f, 0.07695375f, -0.00444136f, -0.07847014f, 0.05411315f, 
    0.08845259f, -0.11479172f, 0.14275795f, -0.10108645f, -0.06595675f, 0.03574993f, 0.18490858f, 0.10633731f, 
    0.08015431f, 0.07834582f, -0.07508819f, 0.04547370f, -0.05283388f, -0.05102718f, -0.15279984f, 0.00310427f, 
    0.01035900f, 0.04056269f, 0.01122199f, -0.05474067f, 0.03345304f, -0.15928596f, -0.07410880f, -0.07854240f, 
    -0.02982937f, -0.04940934f, -0.06479140f, -0.10081691f, -0.00240613f, 0.04483547f, 0.01344831f, -0.02684677f, 
    0.04434634f, 0.07450022f, 0.12852891f, 0.10437465f, -0.06846642f, 0.18602195f, 0.04589103f, 0.22679383f, 
    0.01113823f, 0.00012683f, -0.12131449f, 0.04410445f, -0.06725335f, 0.04213563f, -0.06965014f, 0.00052911f, 
    0.03841860f, 0.27188039f, 0.12076201f, 0.31441495f, 0.07760020f, -0.03674974f, 0.05950813f, 0.15242116f, 
    -0.09847572f, -0.06228900f, 0.10798123f, -0.27395010f, 0.25205135f, 0.17065401f, -0.05072967f, 0.13571651f, 
    -0.01317621f, 0.06795613f, -0.04321134f, -0.00032836f, 0.04092879f, -0.16208233f, -0.16293822f, 0.05288055f, 
    0.14614558f, 0.14077614f, 0.24961387f, -0.05745450f, -0.07881221f, -0.07856811f, 0.04697002f, 0.23019466f, 
    0.06400045f, 0.16599545f, 0.10195021f, 0.01126316f, -0.21018794f, 0.16989960f, -0.05367479f, -0.02453093f, 
    0.02072411f, 0.01529138f, 0.02152950f, 0.02122452f, -0.01388484f, -0.00780364f, -0.03589084f, -0.06033045f, 
    -0.29292953f, -0.09047378f, -0.07655114f, -0.03975527f, 0.11879098f, 0.02062619f, 0.07166724f, -0.01391155f, 
    0.07057340f, 0.08055273f, 0.13108516f, 0.06630892f, 0.15450035f, -0.09416901f, 0.01192765f, 0.20031188f, 
    -0.04761874f, 0.04149048f, 0.05119249f, 0.00693231f, -0.02953932f, 0.00846856f, -0.00363629f, -0.01768456f, 
    0.32952511f, -0.04984453f, -0.06931584f, -0.06152464f, 0.05290037f, -0.03395621f, -0.03767930f, 0.00671521f, 
    0.05955938f, 0.16316549f, 0.12891205f, 0.01838564f, -0.12912498f, 0.01748648f, -0.08239155f, 0.00296608f, 
    0.06653832f, 0.04266194f, -0.10511357f, 0.07367720f, -0.04503717f, -0.01764620f, 0.04152686f, 0.03088290f, 
    -0.43201452f, -0.23903519f, 0.03609801f, 0.11875065f, 0.08661538f, -0.06798920f, -0.03906432f, -0.02499447f, 
    0.13602121f, 0.07825010f, 0.06171610f, -0.09448967f, 0.40274060f, 0.21231456f, 0.01306034f, -0.00258194f, 
    0.06738422f, -0.00258249f, 0.08469719f, 0.11530374f, -0.10221814f, 0.02141802f, 0.10567782f, -0.02415499f, 
    -0.10031357f, -0.24523644f, -0.23565686f, -0.14993797f, 0.01569870f, -0.01168548f, 0.03208306f, 0.16437803f, 
    0.01334855f, 0.09317797f, -0.00469828f, -0.09741490f, 0.40079993f, -0.04596008f, -0.03155508f, 0.08838684f, 
    -0.02674336f, -0.01697022f, -0.01817912f, 0.04810839f, -0.04208393f, 0.02305309f, 0.00199606f, -0.08370043f, 
    -0.05257494f, -0.09697069f, 0.07603147f, -0.12695687f, -0.01141457f, 0.03324651f, 0.05181207f, -0.00609442f, 
    0.08283756f, -0.12030873f, -0.02720441f, 0.05381169f, -0.30111632f, -0.06023942f, -0.14723364f, -0.08240275f, 
    0.03152847f, 0.03936762f, -0.07261892f, -0.07517394f, -0.00198829f, 0.01601613f, 0.00641791f, -0.08494781f, 
    -0.21727741f, 0.09817559f, -0.15570800f, -0.08744171f, -0.04612992f, 0.07117990f, -0.08241279f, 0.05635864f, 
    -0.04123268f, -0.01643813f, 0.08692637f, 0.02069099f, 0.00551795f, -0.17875904f, -0.12257349f, -0.02622013f, 
    0.11533076f, 0.05681215f, 0.00160035f, -0.04094798f, -0.01832907f, -0.07138465f, -0.06868858f, 0.01257776f, 
    0.00687886f, 0.05112174f, 0.05212015f, 0.16158751f, 0.09517231f, -0.02070565f, -0.09507526f, 0.02284141f, 
    -0.01515325f, -0.01708759f, -0.03978133f, -0.00077538f, 0.33297059f, 0.15129779f, -0.07595407f, 0.10454164f, 
    -0.05191815f, -0.03205365f, 0.02013046f, 0.09686549f, 0.02564080f, 0.18325193f, 0.02084788f, -0.01067202f, 
    -0.14460994f, -0.19895700f, -0.15073805f, 0.05359117f, 0.13533552f, -0.04752430f, 0.01809138f, -0.06875765f, 
    -0.02514181f, 0.03380946f, 0.06897604f, 0.03843300f, -0.10783976f, -0.22890548f, -0.02953468f, -0.13395859f, 
    -0.00688899f, 0.00112721f, 0.05194905f, -0.03246534f, 0.19721080f, -0.04060788f, -0.02335981f, 0.09039915f, 
    -0.36099151f, -0.06481408f, 0.25402001f, -0.06768060f, -0.12167718f, 0.13029762f, -0.07588305f, 0.06431317f, 
    0.08784156f, 0.05896166f, -0.05066598f, 0.10478550f, 0.10222783f, -0.00482101f, 0.10821225f, 0.13748689f, 
    0.12731710f, 0.00451191f, 0.01944463f, 0.08233487f, -0.00484572f, 0.04818547f, 0.10798173f, -0.06506381f, 
    -0.22893186f, 0.27588668f, -0.01439687f, -0.10579747f, -0.02525131f, -0.10278092f, 0.10079838f, -0.03896545f, 
    -0.03438618f, -0.07009872f, 0.10201515f, 0.01447978f, -0.02467502f, -0.31209183f, 0.17075920f, -0.21944197f, 
    -0.00609617f, -0.00248097f, -0.11005024f, -0.10795975f, 0.11570622f, 0.08599725f, -0.00499870f, 0.17441969f, 
    -0.08786268f, 0.10077459f, -0.08434629f, 0.07345498f, 0.06352548f, 0.12673187f, 0.03039545f, -0.00448743f, 
    0.12569460f, -0.06881297f, 0.03477859f, -0.02232731f, -0.01294595f, -0.08704256f, 0.03801686f, 0.21327756f, 
    0.05315818f, -0.04752453f, 0.13351834f, 0.11913491f, -0.03409019f, 0.00751367f, 0.01510880f, -0.07966472f, 
    0.25166756f, 0.12167576f, 0.36195269f, 0.44666386f, -0.03305558f, -0.03286240f, -0.06255637f, -0.08651580f, 
    -0.06971896f, -0.01625319f, -0.05304973f, 0.08477492f, -0.13721649f, -0.16719298f, -0.11119287f, -0.01898441f, 
    0.00855765f, -0.04667531f, 0.02957753f, -0.03218285f, -0.02706674f, 0.08321871f, 0.10980396f, -0.04159410f, 
    0.08439944f, -0.15458578f, -0.08109096f, 0.02660053f, -0.02463035f, -0.08258485f, 0.10213344f, -0.16308817f, 
    0.01705927f, 0.05309701f, 0.01514773f, 0.04953555f, 0.00233736f, -0.14015135f, -0.10163473f, 0.01258997f, 
    0.03982625f, -0.04859995f, 0.08374790f, 0.07585048f, -0.03198484f, -0.02987401f, -0.01121307f, -0.02752364f, 
    0.16452624f, -0.02675870f, 0.15293397f, 0.19030350f, 0.00538205f, -0.01858522f, -0.06366728f, -0.07771391f, 
    0.03460662f, 0.03035478f, 0.08854071f, -0.05915246f, 0.08387894f, 0.25015438f, 0.07954779f, 0.11757746f, 
    0.18627435f, 0.06549901f, 0.01177150f, 0.01752621f, -0.08963902f, 0.02535902f, 0.12763846f, 0.06108605f, 
    0.00988497f, 0.29771525f, -0.00896330f, 0.10147032f, 0.04641292f, -0.02966631f, 0.13902023f, 0.09002312f, 
    0.00804996f, -0.03056577f, -0.00809779f, -0.07393540f, 0.05964146f, 0.00448780f, 0.00300722f, -0.00303672f, 
    0.06156009f, 0.14661729f, 0.23080331f, -0.18816404f, -0.03645115f, -0.17690726f, 0.04682735f, -0.07771453f, 
    0.39475742f, 0.24633554f, 0.02277275f, 0.07449889f, 0.06135862f, 0.07585751f, 0.05918751f, 0.12651853f, 
    -0.01869529f, 0.12279101f, 0.03147059f, -0.15203090f, -0.44263637f, 0.31856114f, -0.04432757f, -0.08305112f, 
    0.11666615f, -0.09025987f, 0.02872909f, 0.12869407f, -0.10827699f, -0.10196377f, -0.09707057f, -0.07734197f, 
    -0.04218572f, -0.13123754f, -0.00892084f, -0.09902061f, 0.13662003f, 0.05454317f, 0.04944557f, -0.04768693f, 
    0.03753470f, -0.02212649f, -0.02256081f, -0.10128707f, 0.26710868f, -0.15952325f, -0.02605434f, 0.20897499f, 
    0.01500457f, -0.00849907f, -0.05619650f, 0.01069706f, -0.03376641f, 0.01017006f, 0.06579877f, 0.07748853f, 
    -0.06846737f, 0.11538222f, 0.14571698f, 0.02803820f, -0.01329260f, -0.01969833f, -0.02614430f, 0.03922389f, 
    -0.00422031f, 0.13289082f, -0.01870071f, -0.08008626f, 0.14249867f, 0.02049477f, -0.05795864f, 0.04432990f, 
    0.00229332f, 0.07334521f, -0.05221615f, -0.00457645f, 0.05121147f, 0.08106519f, -0.00898224f, -0.00812306f, 
    -0.06123560f, -0.10298666f, 0.02429731f, 0.19480750f, -0.11026574f, 0.00575722f, 0.02199078f, -0.03912758f, 
    0.03178850f, -0.10043909f, 0.03354966f, 0.01850167f, 0.16672978f, -0.01213863f, 0.01592562f, 0.02763089f, 
    0.16346928f, 0.03596449f, 0.11899890f, 0.05983648f, 0.10936590f, 0.05037902f, -0.04513008f, 0.00304122f, 
    0.10947760f, 0.10620433f, 0.11412836f, -0.13726537f, -0.15417267f, 0.02821244f, 0.11595906f, 0.01366633f, 
    0.04389547f, 0.00010860f, -0.02092753f, -0.01223950f, -0.30803049f, 0.17130816f, -0.02828782f, -0.10495798f, 
    0.06116281f, 0.00748973f, 0.04392898f, 0.04852961f, -0.02822462f, 0.11115406f, -0.16064493f, 0.00078722f, 
    0.00916598f, -0.05710856f, 0.09016075f, -0.08155262f, -0.05470261f, -0.00571580f, 0.03957856f, -0.05534774f, 
    -0.05622399f, -0.06194127f, 0.08193259f, 0.02294101f, 0.11792635f, 0.08127385f, 0.25433275f, -0.05943063f, 
    0.11480036f, 0.09401572f, 0.13994548f, -0.03853783f, -0.00742752f, 0.10398219f, 0.04646347f, 0.08585370f, 
    -0.32716298f, 0.12070663f, -0.06038239f, -0.04385011f, 0.05752945f, 0.02498040f, 0.05078828f, 0.00171655f, 
    0.10837983f, -0.03162081f, -0.06847666f, -0.05083413f, 0.05314423f, -0.24964648f, -0.17337081f, 0.07201280f, 
    -0.10594548f, -0.03359097f, -0.06221340f, 0.03905808f, 0.05579020f, 0.02901231f, -0.04171406f, -0.03193628f, 
    -0.31452101f, 0.14916401f, -0.05192685f, 0.06762946f, 0.06308085f, -0.03233460f, 0.05982253f, 0.04877721f, 
    -0.03671147f, 0.02803122f, 0.04872369f, -0.04073362f, -0.22158548f, 0.13996086f, -0.16487856f, 0.05863093f, 
    0.01965596f, -0.04873946f, 0.04487509f, 0.08658501f, 0.01215708f, -0.09901108f, -0.06102557f, 0.01210219f, 
    0.01374338f, -0.25328845f, -0.13799684f, 0.03087953f, 0.00303682f, -0.03041597f, 0.00988728f, 0.10488440f, 
    0.13033026f, 0.03441962f, 0.00217772f, -0.00735881f, -0.18536553f, -0.14016870f, 0.02428070f, -0.06496606f, 
    -0.13981166f, -0.03498180f, -0.00096908f, 0.00654215f, 0.04456583f, -0.01068015f, 0.00379329f, -0.12468047f, 
    -0.02722399f, 0.02664308f, 0.02528240f, 0.03371823f, -0.00667871f, 0.02052187f, -0.03433404f, 0.02936055f, 
    -0.03248081f, -0.01862888f, -0.04655066f, -0.00006272f, -0.00699397f, 0.01475664f, -0.00457998f, 0.03194892f, 
    -0.05008587f, 0.01403747f, 0.01530577f, -0.01536010f, -0.03237339f, 0.00835497f, -0.02181612f, 0.00567888f, 
    0.02009002f, 0.01196076f, -0.01884511f, -0.05865547f, 0.02290688f, -0.01651480f, -0.04190961f, -0.01490053f, 
    0.02095950f, 0.04077253f, -0.03585859f, -0.00999121f, 0.00090287f, -0.00051278f, -0.01707807f, -0.03041207f, 
    -0.05986518f, -0.05351413f, -0.03209070f, 0.03943079f, -0.01838247f, -0.02512647f, -0.04124467f, -0.05794026f, 
    -0.05527940f, -0.01055812f, 0.03447555f, 0.03051779f, 0.04163073f, 0.01531898f, -0.01698738f, 0.01940234f, 
    0.00491625f, -0.01682273f, 0.02209827f, -0.00725510f, 0.01997899f, -0.02663469f, -0.04526272f, 0.03217020f, 
    -0.03416736f, -0.01585641f, 0.01014100f, 0.00172626f, 0.03113713f, -0.01859690f, 0.03435472f, 0.02763370f, 
    0.01255685f, 0.02423563f, -0.03573864f, -0.01438176f, -0.00158239f, -0.03963403f, -0.00933143f, -0.03265775f, 
    -0.04100632f, 0.03034819f, -0.00025809f, 0.02666235f, 0.02873758f, -0.00679153f, -0.02531143f, -0.01122636f, 
    -0.04313334f, 0.03249218f, -0.00541761f, -0.00620859f, 0.01648703f, 0.02967963f, -0.01617187f, -0.05152872f, 
    0.00722659f, 0.02176015f, -0.04643281f, 0.02226444f, 0.03260930f, -0.04828484f, -0.05816324f, 0.03643012f, 
    -0.04813147f, -0.03349641f, -0.01827506f, -0.05981435f, -0.04085116f, -0.04604988f, -0.00715873f, 0.03791912f, 
    0.02235621f, 0.00025334f, 0.01063680f, -0.05343642f, 0.00754336f, -0.01108345f, -0.02921925f, -0.02193276f, 
    0.02611663f, 0.02381714f, 0.02890982f, -0.04982667f, -0.04066625f, -0.06021747f, -0.05814430f, 0.03178670f, 
    0.03076225f, 0.03002988f, -0.03452719f, -0.03403892f, -0.05351264f, 0.00274424f, -0.01549167f, -0.05671276f, 
    -0.05561027f, 0.01854136f, -0.00415363f, -0.02404694f, -0.02937814f, 0.02282314f, 0.03828444f, -0.01042090f, 
    -0.00297726f, 0.00154364f, 0.00269875f, -0.00534671f, 0.00862314f, 0.00616226f, 0.00270958f, 0.00492314f, 
    0.00689157f, -0.05841010f, 0.03100148f, 0.03627614f, 0.04236524f, -0.04844944f, 0.02662951f, 0.03806971f, 
    -0.03166011f, -0.03652231f, 0.02038122f, -0.00992710f, 0.02060238f, -0.05492056f, -0.02564794f, -0.00726242f, 
    -0.05709362f, 0.00412146f, -0.01559119f, 0.00713352f, -0.04303567f, -0.00816722f, 0.02518991f, 0.00071136f, 
    -0.05872276f, 0.00306025f, 0.04089993f, 0.00406890f, 0.00438985f, -0.02971454f, -0.02514692f, 0.01763957f, 
    -0.03194347f, 0.03773574f, -0.01368328f, 0.04179903f, 0.02667573f, -0.03783012f, -0.03775287f, 0.00357333f, 
    -0.04833109f, -0.02847923f, -0.03005767f, 0.01863552f, -0.04046370f, -0.05503428f, 0.04064994f, 0.01917583f, 
    0.00363311f, 0.03026100f, -0.03423831f, 0.01926106f, 0.00636096f, 0.02818612f, -0.03569939f, 0.03143889f, 
    0.01706842f, -0.03214918f, -0.00281150f, -0.00619688f, 0.01589704f, 0.02719679f, -0.01009530f, 0.00126321f, 
    -0.02722460f, -0.04647314f, 0.01414981f, -0.00275654f, 0.02951978f, 0.03122359f, 0.02421127f, -0.04661861f, 
    -0.01788619f, 0.03504284f, -0.00774997f, -0.02495164f, -0.01321392f, 0.01849537f, -0.03875942f, -0.02039220f, 
    -0.02401777f, 0.00809811f, -0.00990250f, -0.01371316f, -0.05392317f, -0.06032870f, 0.02483034f, 0.03803131f, 
    0.02878782f, -0.01907530f, 0.00928157f, 0.03749134f, -0.03889039f, 0.04073191f, 0.03771532f, 0.01219654f, 
    -0.05590133f, 0.01106537f, -0.04714792f, -0.02883556f, 0.02634784f, -0.04177440f, 0.01061198f, -0.03209462f, 
    0.00562916f, 0.03905145f, -0.01102383f, -0.04183583f, -0.02533722f, -0.00014091f, -0.02432360f, -0.01641384f, 
    -0.00636412f, -0.02217996f, 0.03249291f, -0.02190685f, -0.02959953f, -0.04037912f, -0.05169199f, -0.02502058f, 
    0.01923749f, -0.01836998f, 0.00060344f, -0.05606742f, 0.01657786f, 0.02476694f, 0.03339586f, -0.04813306f, 
    -0.05886663f, -0.03977855f, 0.03007044f, 0.00265396f, 0.03215658f, -0.02801106f, -0.03627355f, -0.05404916f, 
    -0.04743639f, -0.05768131f, -0.04111961f, 0.00835472f, 0.01992287f, -0.04948895f, 0.00427586f, 0.02176106f, 
    0.00932683f, -0.03911130f, -0.01575661f, 0.01559441f, 0.00713924f, -0.00338250f, -0.03166715f, 0.00859023f, 
    0.01111995f, -0.05793932f, 0.00903604f, -0.01933342f, 0.04223037f, -0.02591707f, -0.02751262f, 0.03404236f, 
    -0.05008870f, 0.04120188f, -0.03519825f, -0.00732696f, -0.03187919f, -0.01146786f, 0.01888523f, 0.03673192f, 
    -0.05053790f, -0.05938679f, -0.02961908f, -0.03107561f, -0.04010475f, -0.01501249f, -0.03573754f, 0.04239766f, 
    -0.02392267f, -0.02010952f, -0.00881891f, 0.04152653f, -0.01831239f, -0.04555869f, -0.01758220f, -0.01917739f, 
    -0.02604290f, -0.03832520f, -0.01038138f, -0.05522013f, -0.00000848f, 0.00659513f, -0.04215876f, 0.02495535f, 
    0.03422165f, -0.04208660f, -0.03123584f, -0.03610326f, -0.01251808f, 0.00435275f, -0.05057975f, -0.01864074f, 
    -0.03535611f, 0.04042793f, -0.03591018f, -0.05639737f, 0.02609817f, -0.05424045f, -0.02135438f, 0.03236477f, 
    0.04332929f, -0.00932332f, -0.01016787f, 0.03685473f, -0.00460080f, -0.01981596f, 0.03994878f, -0.03545493f, 
    -0.03400460f, 0.00152096f, 0.03845856f, 0.00465693f, 0.00265196f, -0.00386862f, -0.00321805f, 0.00589968f, 
    0.02728826f, 0.01678868f, 0.03426663f, -0.03265934f, -0.03360318f, -0.00730337f, -0.03041383f, 0.03397529f, 
    -0.01289992f, -0.01500827f, -0.05370739f, -0.05239873f, 0.00319627f, -0.02782450f, 0.02769759f, -0.05224894f, 
    -0.04462652f, -0.02607716f, -0.04257415f, -0.01116501f, 0.02605432f, 0.02636034f, 0.00545793f, 0.03779265f, 
    -0.01114351f, 0.02011329f, -0.01538338f, 0.02299218f, -0.05855504f, -0.01731289f, -0.00135562f, 0.03548730f, 
    0.01218108f, -0.00080719f, 0.00471319f, -0.01237024f, -0.04082147f, -0.04276637f, -0.01925631f, -0.01406513f, 
    -0.03833621f, 0.02459522f, 0.02203417f, 0.03399130f, -0.00104103f, -0.03895163f, -0.04542390f, -0.02961892f, 
    -0.03554401f, 0.02946100f, -0.03876736f, 0.01666030f, -0.05448392f, -0.00821547f, -0.03531695f, 0.00233518f, 
    0.02889891f, -0.02724049f, 0.03892183f, -0.02813312f, 0.01493251f, -0.01901709f, -0.01820299f, 0.02881528f, 
    0.02671319f, 0.01897245f, -0.02334005f, -0.04460296f, -0.00684266f, -0.03001403f, 0.01057188f, -0.04257828f, 
    0.03966832f, -0.05349583f, 0.00663033f, -0.02136793f, -0.00485708f, -0.03340078f, 0.04140923f, -0.03304036f, 
    0.01085375f, 0.01875504f, 0.01691688f, -0.02473122f, -0.02303174f, -0.02176588f, 0.00954379f, 0.03164713f, 
    -0.04589891f, 0.03045348f, 0.02978001f, -0.02374158f, -0.05640638f, 0.03846913f, -0.02148829f, 0.00502407f, 
    -0.01658495f, 0.00351285f, -0.00213802f, -0.01871009f, -0.00752391f, -0.05074989f, -0.02697845f, -0.05598874f, 
    0.01392618f, 0.03766366f, 0.02833423f, 0.00087123f, 0.02876416f, -0.04597791f, 0.03706490f, -0.00732077f, 
    0.03206407f, 0.01323160f, -0.01473401f, 0.00003102f, 0.02058873f, -0.01305659f, -0.00699144f, -0.05009415f, 
    -0.03345605f, -0.02152788f, 0.01553014f, -0.02714388f, 0.00835119f, 0.02552473f, -0.05695654f, 0.00837237f, 
    0.03843392f, 0.02291689f, 0.01583582f, 0.02647805f, 0.01774634f, 0.03844327f, -0.03657750f, -0.03927319f, 
    0.03582944f, 0.02293949f, 0.02011529f, 0.02959303f, 0.00129371f, 0.00881354f, -0.04646381f, -0.01553856f, 
    -0.01365238f, -0.05013960f, -0.03809738f, -0.04842140f, -0.03592610f, -0.04531430f, -0.01109272f, -0.04376781f, 
    -0.00768795f, -0.02084704f, -0.01511572f, 0.04517213f, -0.00541190f, 0.02965785f, 0.01294339f, -0.00633046f, 
    0.00607887f, -0.00828181f, -0.00933436f, -0.03402629f, -0.04733219f, 0.01536951f, 0.03424634f, 0.02667317f, 
    -0.02404871f, 0.04100683f, 0.00747858f, -0.03382592f, -0.03929305f, -0.04122503f, -0.00993535f, 0.03834264f, 
    0.03988948f, -0.00378270f, -0.02226094f, 0.03823896f, 0.01810782f, -0.01409947f, -0.04225688f, -0.05845087f, 
    0.01318535f, -0.00233226f, -0.01400558f, -0.03573481f, -0.00520416f, -0.04296618f, -0.03926348f, -0.02447226f, 
    -0.00194547f, 0.01339688f, -0.00901319f, 0.02680111f, -0.02174203f, -0.05091589f, 0.00894699f, -0.02982500f, 
    -0.01267437f, -0.01489906f, 0.00067801f, 0.03815316f, -0.01291623f, -0.03023637f, 0.00604189f, 0.02313905f, 
    0.01036705f, 0.02092105f, 0.00743635f, -0.03712650f, 0.02175187f, 0.03463624f, 0.00916800f, -0.03437473f, 
    -0.01822065f, -0.05784823f, -0.03262298f, -0.03001322f, 0.02083170f, 0.03780293f, -0.02516437f, -0.04150373f, 
    -0.05477234f, -0.05281926f, -0.04159505f, 0.02800166f, -0.05797486f, 0.03306771f, -0.04310393f, -0.01626368f, 
    -0.02975590f, -0.03875140f, 0.00123452f, -0.02892133f, 0.02344492f, 0.03468519f, -0.03601089f, -0.01717052f, 
    0.01642452f, 0.02907030f, 0.04279487f, -0.03811235f, -0.01023145f, 0.00572172f, -0.01415956f, -0.00387969f, 
    0.04122315f, -0.01705049f, 0.02735254f, 0.00100452f, 0.00516588f, -0.03994649f, 0.01912815f, 0.01941770f, 
    -0.04427985f, 0.00634287f, -0.01779067f, -0.01196206f, -0.04583075f, 0.01787138f, 0.03202585f, 0.00809089f, 
    0.00994962f, -0.05383665f, 0.00914949f, 0.00054965f, 0.00835374f, 0.04003158f, -0.02219295f, -0.02371562f, 
    0.00890913f, 0.01915925f, 0.02742021f, -0.02129525f, -0.02831811f, -0.05234289f, -0.00663321f, -0.05455953f, 
    -0.04380816f, -0.00445801f, -0.05506758f, -0.01399431f, 0.01728621f, -0.04219805f, -0.02872767f, 0.00316253f, 
    -0.02203844f, 0.03735576f, -0.05156128f, 0.03958715f, -0.02259512f, 0.01472645f, -0.05002787f, -0.00664095f, 
    0.02869736f, -0.02352331f, -0.02659037f, 0.01503807f, -0.05387632f, -0.00542979f, 0.01276570f, -0.00097980f, 
    -0.01960372f, -0.05032514f, 0.00014929f, -0.03469991f, -0.01437927f, 0.00503135f, -0.01827502f, -0.04594423f, 
    -0.05578185f, -0.02591071f, -0.02561220f, -0.04526162f, -0.00688592f, -0.00867752f, 0.03220270f, -0.05399534f, 
    0.02158166f, 0.01869837f, -0.05196423f, 0.03920770f, -0.02635904f, -0.00318991f, -0.01818696f, 0.00804082f, 
    -0.00328363f, -0.04533431f, 0.01267933f, -0.04211031f, -0.05402631f, 0.02550753f, 0.02772500f, -0.03915048f, 
    0.03330762f, -0.01647430f, -0.04748850f, -0.04762806f, 0.02998194f, -0.02047605f, 0.03199029f, 0.01950418f, 
    -0.00292101f, 0.03059664f, -0.01732869f, 0.02045290f, -0.04352615f, 0.03337944f, -0.02118938f, -0.02509058f, 
    -0.00876963f, 0.01310982f, -0.05412821f, 0.01807147f, -0.01228248f, -0.01289477f, 0.03510040f, -0.02750343f, 
    -0.02627445f, -0.03085813f, -0.04897091f, -0.04748600f, 0.02592403f, 0.00960744f, 0.02612709f, -0.01140931f, 
    0.01248826f, 0.03251248f, -0.02824399f, 0.01822063f, -0.01316849f, -0.03924168f, -0.00534323f, -0.01687782f, 
    0.04234647f, -0.05687273f, 0.00993565f, -0.01869051f, -0.04756116f, -0.01161822f, -0.03786810f, -0.00503493f, 
    -0.04239721f, -0.04331716f, 0.03572724f, -0.01308168f, 0.02970249f, 0.00603862f, -0.01977700f, 0.02811292f, 
    0.04332606f, -0.13795471f, -0.01086588f, -0.01192137f, 0.15020582f, -0.01027662f, 0.01328035f, 0.04468964f, 
    0.00901901f, -0.07351134f, -0.10902210f, 0.02769432f, 0.03005259f, -0.14760384f, -0.15900290f, 0.11358205f, 
    -0.08007257f, -0.23976557f, 0.01872532f, 0.01017620f, 0.00701430f, 0.07181623f, 0.04794944f, 0.04281220f, 
    0.41311383f, -0.30674335f, -0.25744089f, -0.02112853f, 0.00104111f, 0.05692239f, 0.00575888f, 0.00946851f, 
    0.01174456f, 0.00730252f, 0.01850170f, 0.13517915f, -0.07881495f, 0.02836500f, 0.15974741f, 0.16869165f, 
    -0.06166429f, 0.09885515f, 0.10314336f, 0.08559708f, 0.09481253f, 0.03030152f, 0.11999802f, -0.04314041f, 
    -0.10292860f, -0.03927704f, 0.15475650f, -0.06377028f, 0.05974853f, 0.02073977f, -0.03349385f, 0.10764921f, 
    -0.02583280f, 0.03123250f, -0.10314345f, -0.09228691f, 0.17495488f, 0.08635396f, -0.12834667f, 0.04853342f, 
    0.17030376f, 0.04076900f, -0.07477158f, 0.01814221f, -0.05051278f, -0.02105378f, 0.09930527f, 0.13447082f, 
    0.04370693f, 0.08353177f, 0.06332950f, -0.10389054f, 0.12642047f, 0.10731359f, -0.01189036f, -0.01579783f, 
    0.06283761f, -0.12720825f, 0.09951036f, 0.06547286f, -0.10904793f, -0.11057432f, 0.02705437f, -0.09868784f, 
    -0.03715085f, -0.03064721f, 0.01735467f, 0.04774165f, -0.03728567f, -0.03545855f, -0.01037712f, 0.05074063f, 
    0.14704923f, -0.08830313f, 0.02831230f, 0.08265998f, -0.05433192f, 0.08038602f, 0.15818205f, 0.08385286f, 
    0.06287711f, 0.01416160f, 0.04567131f, -0.04154003f, -0.06334770f, 0.02792887f, 0.05493585f, -0.14285979f, 
    0.04705778f, 0.06431149f, 0.07799678f, 0.14465445f, 0.07677650f, 0.07617223f, 0.04890414f, 0.22929661f, 
    -0.23570985f, 0.03808451f, 0.03597470f, -0.19202025f, 0.00375139f, 0.07445338f, 0.13528076f, 0.18074158f, 
    0.08805554f, 0.04692450f, -0.03366200f, 0.00465283f, -0.25870878f, -0.17063919f, -0.16010135f, 0.01387325f, 
    -0.08053048f, -0.08051249f, -0.09301482f, 0.08485229f, -0.09632852f, -0.03739332f, -0.02270972f, -0.07519127f, 
    -0.11475410f, -0.24259362f, -0.15485083f, 0.02078559f, -0.11326966f, -0.11107652f, -0.12446877f, 0.01323563f, 
    -0.05055144f, 0.06882150f, -0.00648159f, 0.10242469f, 0.01011180f, 0.02215119f, -0.11148794f, -0.17018630f, 
    -0.13743401f, 0.01181360f, -0.01777917f, 0.02911802f, -0.04070002f, 0.01582424f, 0.05466266f, 0.21310058f, 
    -0.03277508f, 0.10610154f, 0.04632308f, 0.01864417f, -0.13093597f, 0.00626910f, 0.05820623f, -0.00571037f, 
    0.01934449f, 0.16290972f, 0.09084848f, 0.15989639f, -0.14322731f, -0.20094192f, 0.08639948f, -0.10934002f, 
    0.06512202f, 0.15455553f, 0.02193110f, 0.04555127f, 0.07101124f, 0.19078887f, 0.19718839f, 0.06713626f, 
    -0.04773109f, -0.13798168f, -0.02997964f, -0.04516704f, 0.12226959f, -0.01823051f, 0.07981079f, 0.09791727f, 
    0.06533480f, -0.03749447f, 0.09277711f, 0.03057722f, -0.00687462f, 0.23211981f, 0.14846958f, 0.12981844f, 
    -0.04625829f, 0.21201837f, 0.12635800f, -0.00551045f, 0.01948970f, -0.03948705f, -0.03559902f, 0.08315682f, 
    0.16069084f, 0.01476588f, -0.09595931f, 0.14165586f, 0.02375114f, 0.10459808f, 0.07919295f, -0.07829730f, 
    -0.00248247f, -0.10425052f, -0.04326564f, -0.23558095f, 0.11500516f, -0.03216689f, 0.19711775f, -0.30201036f, 
    -0.06212270f, 0.11746089f, -0.05231052f, 0.18214633f, -0.03836689f, 0.04003775f, 0.02636623f, 0.04795548f, 
    0.01008855f, 0.08748710f, 0.30698067f, -0.08720901f, 0.16036132f, -0.00445988f, -0.04212135f, 0.05700557f, 
    0.04055075f, 0.03189487f, -0.02934983f, -0.01366764f, -0.09378584f, 0.00060791f, -0.10367095f, 0.04234365f, 
    -0.03855001f, 0.06072615f, -0.01357088f, 0.08150945f, -0.03482217f, 0.00247624f, -0.08204527f, -0.02901643f, 
    0.18759292f, -0.06890646f, 0.19351670f, 0.12081160f, 0.16807173f, 0.20471713f, 0.17661101f, 0.16602838f, 
    0.10690853f, 0.08404550f, -0.02199283f, 0.08839243f, -0.00136869f, 0.06821331f, -0.07864551f, 0.15245327f, 
    0.03397087f, 0.04703004f, 0.10440499f, 0.12738204f, 0.03152248f, -0.07892255f, 0.12222187f, 0.01471165f, 
    -0.16428915f, 0.03357650f, 0.07782993f, -0.08318542f, 0.11876634f, 0.04963825f, -0.01072411f, 0.06996308f, 
    0.08353250f, 0.05515613f, -0.07211652f, -0.05982563f, -0.31703898f, -0.15150289f, -0.22315346f, -0.04055861f, 
    0.00399080f, 0.07215338f, 0.04723265f, 0.07873875f, 0.01880382f, 0.03210023f, -0.00208646f, -0.05545050f, 
    -0.13586344f, 0.03811765f, 0.11809589f, -0.05269281f, -0.06317154f, 0.01793721f, 0.13542213f, 0.09199395f, 
    -0.07781102f, 0.02841518f, -0.03273507f, 0.10521325f, -0.05886832f, 0.10824713f, 0.06024392f, -0.05306493f, 
    -0.02987628f, 0.02796276f, 0.04100709f, 0.06046179f, 0.07323422f, 0.10230514f, 0.10465866f, 0.06619941f, 
    0.03923080f, 0.19575357f, -0.04990077f, 0.01679138f, 0.03800872f, -0.00777856f, 0.09214320f, 0.18630202f, 
    -0.00728758f, -0.01791906f, 0.09017056f, -0.07756265f, -0.13870698f, -0.10722876f, -0.05636571f, -0.10209075f, 
    0.04156518f, 0.03670145f, 0.03459032f, 0.07856043f, 0.11202412f, -0.07403170f, 0.10733780f, 0.09032250f, 
    0.05393055f, 0.06025076f, -0.01783611f, 0.07386027f, -0.05083873f, 0.06763985f, 0.02571819f, 0.00728077f, 
    -0.01430585f, -0.07466073f, -0.04976334f, -0.07717314f, -0.19318631f, 0.20020193f, 0.12055147f, 0.15172942f, 
    -0.04073204f, -0.09685259f, 0.09891576f, 0.02214248f, 0.13310923f, -0.02829907f, -0.04513210f, -0.06849372f, 
    -0.02176733f, -0.04837837f, 0.00480414f, -0.05386157f, -0.00504254f, -0.04472155f, -0.01412380f, -0.03276421f, 
    -0.01151882f, 0.01207297f, -0.03516690f, -0.00710027f, 0.00920090f, -0.00898626f, -0.00638178f, -0.04698871f, 
    0.02338735f, -0.03059394f, 0.00611315f, -0.04248196f, -0.05808822f, -0.04702784f, -0.02994874f, -0.03898025f, 
    -0.05467832f, 0.01989538f, -0.04903782f, 0.01492985f, -0.01906431f, 0.02201366f, -0.01004227f, 0.01257206f, 
    -0.02471554f, 0.00067573f, 0.01424425f, -0.05806084f, -0.00120144f, -0.00461212f, 0.01422344f, -0.03455018f, 
    -0.03577864f, 0.01108360f, 0.03084750f, 0.00034770f, -0.04985406f, 0.03432050f, 0.03861670f, 0.02832296f, 
    0.01274238f, -0.05973386f, -0.02769323f, 0.03486679f, 0.02805040f, -0.02721288f, -0.01940447f, -0.03927945f, 
    -0.02228121f, -0.06231319f, 0.01321291f, -0.02487412f, 0.03453729f, 0.02281028f, 0.00245291f, -0.03944171f, 
    -0.01347530f, 0.03335118f, -0.00107712f, 0.05023700f, 0.00810457f, -0.03189582f, -0.02243722f, -0.03990578f, 
    0.03761967f, 0.03724584f, 0.04904401f, -0.03423499f, -0.05364540f, -0.00859504f, -0.00126216f, -0.00644104f, 
    -0.00846468f, 0.01764787f, -0.00420555f, -0.01777752f, 0.04339151f, 0.05322902f, -0.04814596f, -0.04748780f, 
    -0.00650809f, -0.00590649f, -0.04852930f, -0.02238688f, 0.02992379f, -0.05207242f, 0.02807672f, -0.04167014f, 
    -0.06516944f, 0.01653789f, -0.03955794f, -0.05227770f, 0.00777781f, 0.01380155f, -0.01082619f, -0.05228188f, 
    -0.05349122f, 0.02512665f, 0.00111490f, 0.02900889f, -0.01173883f, -0.02166436f, -0.04239913f, -0.03380286f, 
    -0.00202061f, 0.03032342f, -0.03761880f, 0.00317437f, 0.04678349f, -0.02747834f, 0.03881517f, -0.02023710f, 
    -0.02876481f, 0.02211214f, -0.04736922f, 0.01189253f, 0.00991595f, -0.00503509f, -0.01422040f, -0.05551085f, 
    0.00414268f, 0.02510203f, 0.01815639f, 0.02316739f, 0.00515296f, -0.02450062f, -0.01918742f, -0.06100948f, 
    -0.01815668f, -0.03749920f, 0.00955426f, 0.01096151f, -0.05104354f, -0.00198988f, -0.04544722f, 0.02380614f, 
    0.02093045f, 0.01339326f, 0.00190062f, 0.03752463f, 0.00181758f, -0.00309513f, 0.00262298f, -0.04977448f, 
    -0.05359276f, -0.04397015f, 0.01420106f, 0.00074529f, -0.00284615f, -0.01795226f, -0.03811603f, 0.02545553f, 
    -0.04810341f, -0.00779088f, 0.02783866f, -0.03763350f, -0.04806277f, -0.00903340f, 0.02259202f, -0.03181396f, 
    -0.03076711f, 0.00845245f, -0.04472463f, 0.03348787f, -0.00848583f, 0.04077968f, 0.00655646f, 0.00621846f, 
    -0.00142147f, -0.03323774f, 0.00229913f, 0.01644096f, -0.03330306f, -0.01849435f, 0.02133101f, -0.01126567f, 
    0.01090762f, -0.03968420f, 0.01345082f, 0.00157128f, 0.04196104f, -0.03843177f, 0.01148519f, 0.03860185f, 
    -0.04264949f, -0.02311174f, 0.04593269f, 0.01269349f, -0.05306363f, -0.04825339f, -0.04542546f, 0.03812562f, 
    0.02769914f, -0.00202191f, 0.04060882f, -0.00313469f, -0.02114209f, 0.04089539f, -0.02646374f, 0.00062733f, 
    -0.02566111f, 0.03411237f, -0.03149899f, -0.03875528f, -0.02754455f, 0.01192857f, -0.04172858f, -0.04512579f, 
    -0.03981123f, 0.02166713f, 0.03988156f, -0.00099584f, -0.05366390f, -0.01865194f, 0.02572944f, 0.02132812f, 
    0.01424803f, -0.02317554f, -0.05719154f, 0.00526335f, 0.03592008f, 0.03316179f, -0.04614263f, 0.04240089f, 
    -0.01930742f, -0.02270265f, -0.04429789f, 0.00176123f, 0.01003254f, 0.03391178f, -0.01610940f, 0.03289572f, 
    -0.03145843f, 0.00511769f, 0.02819449f, -0.03503554f, 0.02192692f, -0.05739329f, 0.00302852f, -0.03319766f, 
    -0.04903219f, -0.02384178f, -0.03876893f, -0.00974341f, -0.01026260f, -0.01767474f, -0.04293392f, -0.05365249f, 
    0.03525053f, 0.05131181f, -0.01976466f, -0.03264897f, 0.00370105f, -0.03946006f, -0.02983951f, 0.01303411f, 
    -0.05347789f, -0.01765542f, -0.00819611f, 0.00294337f, 0.03828846f, -0.02736661f, -0.05326146f, 0.03504696f, 
    -0.00589308f, 0.00653502f, 0.01535243f, -0.00751032f, 0.02091341f, 0.00627956f, -0.00252573f, -0.01268043f, 
    0.01518074f, 0.04424670f, -0.00234126f, 0.03017844f, -0.04798533f, 0.01127426f, -0.00012394f, -0.03071238f, 
    0.03234896f, 0.02988575f, -0.02356341f, -0.00336544f, -0.03165134f, 0.01664564f, 0.03580149f, -0.00710128f, 
    0.03819300f, -0.02257337f, -0.04398990f, 0.01086845f, -0.03774229f, 0.02829851f, -0.01189121f, -0.00858265f, 
    -0.01193978f, 0.00336857f, -0.02775081f, -0.04511710f, -0.03418813f, 0.02391881f, 0.03305649f, -0.03059809f, 
    0.01851918f, -0.04683047f, 0.03132986f, -0.03866630f, -0.00996730f, 0.03937413f, 0.00553822f, 0.02506387f, 
    -0.02808652f, 0.03335410f, -0.00754033f, 0.00147805f, -0.00473122f, -0.00580405f, 0.03618876f, -0.01562539f, 
    0.00274146f, -0.03891053f, -0.05602500f, -0.01552003f, -0.04181923f, -0.04036695f, 0.03073543f, -0.04255484f, 
    0.03114416f, -0.01468144f, -0.01500863f, -0.00135748f, 0.01195467f, 0.00350795f, 0.03881443f, 0.03857073f, 
    -0.02384646f, -0.01667853f, -0.02665810f, 0.03736210f, -0.03800315f, -0.01670509f, -0.01665344f, -0.02500797f, 
    -0.04543341f, -0.00956949f, -0.00432458f, -0.04662275f, -0.01189040f, -0.01034882f, 0.01911934f, 0.03232763f, 
    0.00217591f, 0.00912264f, -0.02741978f, -0.03042638f, 0.00448765f, 0.02962213f, -0.02343457f, -0.02479661f, 
    0.02525063f, 0.03065518f, -0.05239554f, 0.02909502f, -0.03812633f, 0.00295079f, 0.03689358f, -0.01542252f, 
    0.03909831f, 0.04127006f, -0.00601594f, -0.04015394f, -0.02379527f, 0.03501921f, 0.02449608f, 0.03943421f, 
    -0.01820378f, -0.03752344f, -0.05583146f, -0.05763341f, 0.01031128f, 0.03854608f, -0.00581179f, -0.03965905f, 
    0.00031855f, 0.00474163f, 0.01136316f, 0.01068455f, -0.04585606f, -0.04741578f, 0.03689767f, -0.00659827f, 
    -0.02173942f, -0.03177676f, 0.03082875f, -0.01433359f, 0.01941298f, -0.02554678f, -0.03009112f, -0.01433736f, 
    -0.02377022f, -0.02237451f, -0.01815361f, 0.02289438f, -0.01142294f, 0.04310097f, 0.03757748f, 0.00668978f, 
    -0.03835547f, 0.01034484f, 0.03283257f, -0.01982575f, -0.03964855f, -0.05442161f, -0.03770848f, 0.02969837f, 
    0.00634379f, 0.04172878f, -0.01548395f, -0.05538585f, 0.03461057f, -0.01071733f, 0.03463043f, -0.01745150f, 
    0.04218000f, -0.04255825f, 0.01048197f, 0.01789312f, 0.03402675f, -0.01468541f, -0.03767932f, 0.01389247f, 
    -0.02642925f, -0.05458909f, 0.04207445f, -0.03439014f, 0.00332706f, -0.05719832f, 0.02951307f, -0.02028320f, 
    -0.02220446f, -0.02109416f, -0.04097463f, -0.04967807f, 0.00933137f, -0.01328639f, -0.03307661f, 0.00800150f, 
    0.02280262f, -0.05823561f, 0.03857138f, -0.03453753f, 0.02265332f, 0.01291493f, 0.02723883f, 0.02268842f, 
    0.03478064f, -0.01799727f, -0.02754302f, 0.01600450f, 0.03962714f, -0.01777113f, -0.04376592f, -0.04673306f, 
    0.02020147f, -0.00173536f, -0.02814745f, -0.01883395f, -0.03268493f, -0.03592775f, -0.03684059f, -0.05829899f, 
    0.03989420f, -0.00470525f, -0.03315077f, -0.01435189f, 0.00895076f, 0.01697626f, -0.01129069f, -0.01892368f, 
    -0.02389433f, -0.05325235f, -0.02340348f, -0.03974091f, -0.04070095f, 0.00017358f, -0.01491643f, -0.02232363f, 
    -0.00445043f, -0.01773290f, -0.01294049f, -0.01030910f, -0.05748408f, 0.01753509f, -0.00135055f, -0.01734382f, 
    -0.01443115f, 0.01821464f, 0.02738109f, -0.05310770f, -0.04697921f, -0.01863748f, -0.00304495f, 0.03101982f, 
    0.01779159f, -0.02338088f, 0.00012961f, -0.05714035f, -0.02288678f, -0.02600407f, -0.04545161f, -0.02147850f, 
    -0.03031007f, -0.01518428f, 0.00974728f, -0.01200806f, -0.04485926f, -0.01543074f, -0.03838848f, -0.02841370f, 
    -0.01358790f, -0.01893933f, 0.00871538f, 0.00241385f, -0.02860392f, -0.03728654f, -0.01343946f, -0.02147373f, 
    0.02446956f, -0.04487211f, -0.00207757f, -0.05091815f, -0.01857269f, -0.02383214f, -0.03958301f, -0.02274120f, 
    -0.05615157f, 0.03110491f, -0.03470172f, 0.02306284f, 0.01137195f, -0.01145206f, 0.00330740f, -0.04445427f, 
    0.03487298f, 0.02667260f, -0.00800805f, 0.03978048f, 0.02913454f, 0.04313010f, -0.02396362f, 0.00712197f, 
    -0.00104631f, 0.02779898f, 0.00736073f, 0.02028901f, 0.00597503f, -0.01567644f, 0.01144891f, 0.03964749f, 
    -0.02585454f, -0.04388344f, -0.04864844f, -0.05158329f, 0.00959061f, -0.00585466f, 0.03283005f, -0.01106841f, 
    0.03626760f, 0.00152837f, 0.00427697f, 0.01693245f, -0.03171865f, -0.05400960f, 0.01524367f, -0.00363907f, 
    -0.04905481f, -0.00303847f, 0.03858522f, -0.00793744f, -0.05746416f, 0.00114005f, 0.02401049f, 0.00275596f, 
    0.03910145f, -0.00631402f, -0.02233332f, -0.02527399f, 0.02835133f, -0.03202352f, -0.04501449f, 0.01157778f, 
    0.01978572f, -0.04270365f, -0.01813671f, -0.03109789f, 0.00560809f, -0.00503384f, -0.04179835f, 0.00934297f, 
    0.01527322f, 0.00715395f, -0.00067135f, 0.00280748f, 0.00586776f, -0.02315697f, 0.01778744f, 0.00235691f, 
    0.02227165f, -0.02477454f, -0.01840925f, -0.03410425f, -0.04466802f, -0.00462005f, 0.00536150f, 0.03221266f, 
    -0.05742408f, 0.04426970f, 0.01771648f, -0.01143459f, -0.01781297f, -0.04459773f, 0.01819895f, 0.00039263f, 
    0.00856335f, -0.05848262f, -0.04020101f, -0.00153079f, -0.01936251f, 0.01742906f, 0.00760047f, 0.03683893f, 
    0.03026252f, 0.01650184f, -0.00832004f, 0.00864788f, 0.00864302f, -0.04826098f, 0.00159190f, -0.02481340f, 
    0.00431827f, -0.01340140f, -0.05535043f, 0.02060628f, -0.01375962f, -0.04475270f, 0.01181304f, -0.03018638f, 
    -0.02413471f, 0.01417058f, 0.02201636f, -0.04494463f, -0.03070973f, 0.04320384f, 0.00133097f, 0.01674446f, 
    0.03396342f, -0.04069917f, 0.01129323f, -0.03853160f, -0.04694056f, -0.05337881f, -0.00367710f, -0.03374850f, 
    0.01750286f, -0.05870814f, 0.02082622f, -0.02210042f, 0.00920099f, 0.02085945f, -0.02734001f, -0.02397819f, 
    0.02447400f, -0.03105748f, 0.02403283f, 0.01275509f, 0.01689469f, 0.00823109f, 0.00578430f, 0.01553117f, 
    0.00021088f, -0.00361951f, 0.03328405f, -0.00608429f, -0.05259228f, -0.05768358f, -0.01812464f, -0.05071555f, 
    -0.02642615f, -0.05689496f, -0.00892095f, 0.01946672f, 0.03618377f, 0.00734111f, -0.04911045f, 0.03334326f, 
    0.01766354f, 0.02762912f, 0.03941429f, -0.03623287f, -0.00052081f, 0.02288995f, 0.02119497f, 0.00873038f, 
    0.00568590f, 0.02882302f, -0.00185012f, -0.03804205f, -0.00421462f, 0.03979672f, -0.01386843f, -0.04413647f, 
    -0.01569804f, 0.00048390f, 0.00077801f, -0.04191051f, -0.03272266f, -0.01155143f, -0.02374152f, -0.01688841f, 
    -0.00965991f, -0.02167605f, 0.02318680f, 0.03780512f, -0.05135396f, 0.00297405f, 0.02378920f, 0.01417029f, 
    0.03813003f, 0.03831809f, -0.04926611f, -0.02383550f, -0.03641967f, -0.05787937f, 0.02434744f, -0.04063718f, 
    0.01829388f, 0.01758976f, -0.04622199f, -0.01773490f, -0.04665132f, -0.01263769f, -0.01691889f, -0.02138611f, 
    -0.01235367f, -0.05865441f, 0.00668095f, -0.00067025f, 0.02553811f, 0.01033437f, -0.00805151f, 0.03168523f, 
    -0.00533391f, -0.05374051f, -0.05203988f, -0.00120619f, 0.00457645f, 0.01584703f, 0.02392958f, -0.04458987f, 
    0.01142953f, -0.02245886f, -0.04811171f, -0.01241639f, -0.04351544f, -0.01114543f, 0.05058530f, 0.03126084f, 
    -0.05046624f, 0.01343964f, -0.05308124f, 0.00779345f, 0.00080253f, 0.04263701f, 0.00031503f, -0.05139915f, 
    -0.00316952f, 0.02447678f, 0.00063960f, -0.02908755f, -0.02317684f, 0.03695718f, -0.01567146f, 0.01686466f, 
    0.03959760f, -0.02901117f, 0.00782486f, 0.02948639f, 0.01912170f, -0.02420533f, -0.01416423f, 0.03326896f, 
    0.01918466f, 0.01171038f, 0.02439534f, -0.04767791f, 0.01852986f, -0.05713426f, -0.01498590f, 0.03645776f, 
    0.00160901f, -0.00478353f, 0.02885099f, 0.00763061f, -0.01746620f, 0.02606771f, 0.01921502f, 0.00958718f, 
    0.02267512f, 0.01830857f, -0.03724951f, -0.05610868f, 0.00081777f, 0.02256091f, -0.01253175f, -0.04690847f, 
    -0.03257075f, -0.04525822f, -0.04452043f, -0.04777988f, -0.02270894f, 0.05164319f, -0.05177212f, 0.02266249f, 
    -0.05937063f, -0.03145896f, -0.04240638f, 0.00949461f, -0.05559097f, -0.01845491f, -0.03718832f, -0.01740887f, 
    0.04190829f, 0.00283512f, 0.01775054f, 0.05441524f, -0.05492938f, -0.03355549f, -0.01455352f, -0.03042498f, 
    0.00935692f, 0.03766889f, 0.03921155f, 0.03640953f, 0.03971948f, 0.01190542f, 0.00280432f, -0.05121364f, 
    -0.01503839f, 0.03693249f, -0.05554485f, -0.05388960f, 0.01379371f, -0.01144436f, 0.03135980f, -0.00158150f, 
    -0.00445863f, -0.00523907f, 0.00026738f, 0.00509464f, -0.01780123f, -0.04781783f, 0.02762032f, 0.01245599f, 
    -0.02757510f, -0.00639760f, -0.00703000f, -0.01155963f, -0.05676424f, -0.03340856f, -0.05315447f, 0.00833337f, 
    0.01835423f, -0.03914015f, 0.01188389f, 0.02053793f, 0.02078134f, -0.01878161f, 0.01665397f, 0.03200293f, 
    0.04141544f, 0.02825097f, -0.01376438f, -0.02384368f, 0.03773542f, 0.01766800f, -0.02339121f, -0.03906042f, 
    -0.00396792f, 0.03458369f, 0.02065584f, -0.03008986f, -0.05181359f, 0.01270642f, 0.02079811f, 0.03627800f, 
    0.02157947f, 0.02570452f, -0.01436665f, 0.04371337f, -0.04747707f, 0.01158624f, 0.03440996f, -0.02068337f, 
    0.03769005f, -0.00938491f, -0.01252780f, -0.00507289f, 0.02309133f, 0.00472469f, -0.03776653f, 0.03870884f, 
    0.04258224f, -0.01906402f, -0.03634723f, 0.03668984f, 0.01229296f, -0.00737834f, 0.05866547f, -0.02860858f, 
    -0.00392331f, -0.03204587f, -0.02945340f, 0.01992332f, -0.03519880f, 0.00622029f, 0.01070812f, -0.04120712f, 
    0.00301515f, -0.00847776f, -0.03070795f, -0.01017846f, -0.01173347f, 0.00259470f, -0.00825761f, -0.00815825f, 
    0.02400604f, 0.01349740f, -0.03877261f, -0.04474726f, 0.03616793f, -0.00617407f, -0.02957372f, 0.03069872f, 
    -0.00566456f, -0.02916040f, -0.02436057f, 0.02927388f, 0.00367725f, -0.05578076f, 0.03950366f, -0.05286732f, 
    -0.04640573f, -0.05793247f, -0.00487709f, 0.00795564f, -0.00885276f, -0.04009202f, 0.03367765f, -0.06243325f, 
    -0.04877362f, 0.00909179f, -0.05263981f, 0.01588632f, -0.02474537f, 0.00556373f, -0.04598698f, 0.00939090f, 
    -0.04648868f, -0.01731754f, -0.03089895f, 0.03401300f, 0.01662398f, 0.03405451f, 0.00770279f, 0.03814507f, 
    -0.01481847f, -0.05513632f, 0.02574541f, -0.01333222f, 0.01751158f, -0.01753209f, -0.04462674f, -0.05282655f, 
    -0.01079519f, 0.02009903f, -0.01594916f, 0.02442954f, -0.04267108f, 0.04095263f, 0.01517269f, 0.01938219f, 
    0.01159898f, -0.05499315f, -0.03543605f, 0.03027339f, -0.04537685f, -0.01986800f, 0.02018107f, 0.01222354f, 
    -0.00937052f, 0.00390300f, -0.00566348f, -0.03485978f, 0.00932926f, -0.04018775f, -0.02452765f, 0.01759375f, 
    0.02518870f, 0.02870093f, -0.04000729f, 0.00683854f, 0.01955194f, 0.00499554f, 0.01352793f, -0.03827376f, 
    0.00548381f, -0.04617152f, 0.00426854f, 0.00586353f, 0.02846917f, 0.01006505f, 0.00691551f, -0.02733738f, 
    -0.01033952f, -0.02722684f, 0.04785299f, -0.02037440f, -0.03952909f, -0.03888502f, -0.04057795f, -0.02709646f, 
    -0.05190493f, -0.03736855f, 0.00388278f, 0.04099865f, 0.01433088f, -0.00726637f, -0.02447627f, 0.01576649f, 
    0.00559082f, -0.02709429f, 0.03137685f, 0.00585492f, 0.00584622f, 0.02350225f, 0.02300718f, -0.00847903f, 
    -0.00596380f, -0.04345019f, -0.01489029f, -0.05457976f, -0.00006291f, 0.01553059f, 0.00046545f, -0.03248873f, 
    0.02842570f, 0.02948247f, -0.01505551f, 0.03473448f, -0.03951766f, 0.01492100f, -0.00716027f, 0.01228588f, 
    0.02304026f, -0.00904885f, -0.00408794f, -0.03309149f, 0.03152208f, -0.00792099f, 0.00551343f, 0.02069235f, 
    -0.01954656f, -0.03848636f, -0.01061918f, -0.01951402f, -0.01583410f, -0.02547106f, -0.04540777f, 0.01052435f, 
    0.03267093f, -0.02327798f, -0.05482818f, -0.05253549f, -0.05693175f, 0.03229243f, -0.05552236f, 0.03988516f, 
    -0.02835277f, -0.01864360f, 0.00223602f, -0.03554602f, 0.00598026f, -0.04097405f, 0.02837672f, -0.00668253f, 
    0.00514433f, 0.02092231f, 0.03124677f, -0.04239663f, 0.03482471f, -0.01655736f, 0.00933853f, 0.03736246f, 
    -0.03087542f, -0.01025968f, -0.04906233f, -0.02724664f, 0.01267875f, -0.04303725f, -0.04291112f, 0.03585454f, 
    0.01262595f, -0.02917308f, 0.01439344f, -0.03445347f, -0.05156619f, -0.00943639f, 0.00963161f, 0.01879162f, 
    0.02294693f, -0.02987947f, -0.00402294f, -0.03184400f, 0.00730565f, -0.02412525f, 0.02588904f, -0.05439885f, 
    -0.01583671f, 0.02299347f, -0.04123288f, -0.00996500f, -0.04456668f, -0.00741820f, -0.05652700f, 0.02763206f, 
    -0.00482650f, -0.05019033f, -0.02079670f, -0.04146841f, 0.00778394f, -0.04272084f, -0.05006235f, 0.03950496f, 
    0.09875705f, 0.07416647f, -0.00128336f, 0.07793666f, -0.03258832f, -0.04593102f, -0.00070062f, -0.01773341f, 
    0.13550602f, -0.08457660f, 0.15742894f, -0.08015034f, 0.04487901f, 0.23845255f, 0.16602580f, 0.11435256f, 
    0.12068499f, 0.13430330f, 0.00139319f, -0.04718611f, 0.03100053f, -0.06148957f, -0.07549676f, 0.06632573f, 
    -0.04307313f, 0.20339088f, 0.20031141f, -0.08934531f, 0.01435780f, 0.03508043f, -0.03735372f, 0.03517140f, 
    0.02409825f, 0.09539527f, -0.00987067f, 0.05002462f, 0.29901525f, 0.15039413f, 0.10371564f, -0.15654342f, 
    -0.03020874f, -0.10717871f, -0.03662542f, -0.04618647f, 0.05206803f, 0.10795413f, 0.02519043f, 0.13772830f, 
    0.08257811f, 0.03383971f, -0.08085147f, -0.05739782f, -0.03495991f, -0.02714947f, -0.08105359f, 0.06325413f, 
    0.10243234f, 0.04695347f, 0.17174548f, 0.04789166f, -0.14959298f, 0.07633939f, 0.00194535f, 0.08714044f, 
    -0.01251266f, 0.03388507f, 0.16392255f, 0.08500126f, -0.04197056f, -0.00521238f, 0.02423224f, -0.05540611f, 
    -0.21094593f, 0.10704510f, 0.10212274f, 0.14853373f, -0.09292711f, -0.12558201f, 0.10581630f, 0.08780741f, 
    0.06740723f, 0.10238291f, -0.04696956f, -0.04868203f, 0.36180961f, 0.11828881f, 0.08436323f, 0.16847441f, 
    0.14162271f, 0.11879157f, 0.10044516f, -0.03740088f, 0.00425884f, -0.01426500f, -0.05808410f, 0.05636952f, 
    -0.03922657f, -0.01019252f, -0.02421550f, -0.06497389f, 0.23015681f, 0.03582492f, -0.05685428f, 0.00187294f, 
    0.01257737f, 0.18438208f, 0.07984911f, 0.14294021f, 0.12437134f, 0.11574391f, 0.06478322f, -0.23657283f, 
    0.12654468f, 0.00955831f, -0.11497753f, -0.11318059f, -0.09177633f, -0.09670936f, -0.00495197f, -0.17637751f, 
    0.20414352f, 0.06948815f, -0.00597995f, 0.01725428f, -0.00749121f, -0.00863055f, -0.03737487f, -0.11447363f, 
    -0.04502948f, -0.06964917f, 0.12029415f, -0.09214368f, -0.04474201f, 0.20858514f, 0.04228595f, 0.32815671f, 
    0.11138095f, 0.01255237f, 0.08110078f, -0.06387712f, -0.02792931f, -0.01876915f, -0.06227760f, -0.02741680f, 
    -0.03442590f, 0.19338383f, 0.00685745f, 0.22093154f, 0.05791116f, 0.07672288f, 0.12277234f, -0.03329406f, 
    0.00105304f, -0.06575773f, 0.03709391f, -0.14571957f, 0.17315933f, 0.00045817f, 0.13239340f, -0.02392176f, 
    0.17583019f, -0.00765800f, -0.10536218f, -0.03718698f, 0.00379232f, 0.01007096f, -0.08416758f, -0.15081489f, 
    0.10146370f, 0.04921804f, -0.02941841f, 0.14631645f, -0.06596968f, 0.04100781f, -0.00216365f, 0.02925924f, 
    0.04560059f, -0.13587438f, 0.00236261f, -0.13195691f, 0.02016448f, 0.17082742f, -0.01342220f, 0.06717762f, 
    0.11738377f, -0.12635164f, -0.11919826f, 0.09057960f, -0.09820189f, -0.09757895f, -0.17665538f, -0.02393953f, 
    0.04683615f, -0.10789939f, 0.18020353f, -0.01314935f, -0.01487995f, -0.05012711f, 0.00630891f, 0.09106899f, 
    0.03181882f, 0.04036546f, -0.04330580f, -0.11369060f, 0.22893329f, -0.11566547f, -0.17882736f, -0.13039201f, 
    0.03063116f, -0.18000099f, -0.07493535f, 0.09885643f, 0.03264437f, 0.01812237f, 0.02743764f, 0.05783132f, 
    -0.08948713f, -0.11469691f, 0.15980162f, -0.02007434f, -0.08556641f, 0.09432423f, -0.18631089f, 0.01831858f, 
    0.05762658f, 0.10415944f, 0.04340760f, 0.09571926f, 0.02151583f, -0.03957717f, -0.11081135f, 0.05544998f, 
    0.00743187f, 0.03484634f, -0.00300720f, -0.06691786f, 0.00512655f, -0.02821989f, 0.01189684f, -0.01571544f, 
    0.06654245f, 0.02500684f, -0.04892551f, 0.10096584f, 0.11389314f, -0.19063063f, -0.06833340f, -0.10493825f, 
    0.00867732f, -0.02755286f, 0.11823016f, 0.03192781f, 0.20260501f, 0.21935719f, 0.01451488f, 0.06959025f, 
    0.18343484f, -0.08383248f, 0.06771947f, -0.09466112f, -0.03612994f, 0.03643667f, 0.10858267f, 0.08241180f, 
    -0.19306195f, -0.11704787f, 0.03705604f, -0.21827704f, -0.17327659f, -0.09444145f, -0.19968623f, -0.02444397f, 
    -0.02415867f, -0.09731486f, 0.14156790f, 0.12413269f, -0.11166423f, -0.04857617f, -0.01543144f, -0.19225214f, 
    0.07614855f, 0.02924713f, -0.03221721f, -0.03028871f, -0.15133750f, -0.01542670f, 0.09525112f, -0.00969222f, 
    0.20820299f, 0.18198843f, -0.01188235f, -0.06665053f, -0.07562613f, -0.08826804f, 0.10406125f, -0.08006091f, 
    0.15252918f, -0.11248728f, 0.14338034f, -0.07520720f, -0.33620664f, -0.13162953f, -0.01032051f, 0.06760641f, 
    -0.06178620f, 0.01787270f, -0.03935627f, -0.06520671f, -0.03890401f, 0.13216576f, -0.00344094f, -0.06892698f, 
    -0.25753155f, 0.01197403f, -0.09902301f, 0.04117832f, 0.15440783f, 0.09433170f, -0.16830006f, 0.00383003f, 
    -0.05599044f, -0.03310885f, 0.16038448f, -0.08121826f, 0.28798327f, -0.09441345f, -0.00103586f, 0.06160503f, 
    0.06894837f, 0.02891732f, -0.00289564f, 0.00111917f, 0.00948225f, -0.00452474f, -0.02111369f, 0.02068418f, 
    -0.35333338f, 0.07241088f, -0.11321642f, -0.28963485f, 0.07490584f, 0.00865767f, -0.14171895f, -0.13756408f, 
    0.05483905f, -0.09101845f, 0.05730515f, 0.11985995f, -0.12844989f, 0.14297533f, 0.11263329f, 0.00165675f, 
    0.06661522f, -0.05758088f, 0.05876944f, -0.02444377f, 0.00106341f, 0.17606853f, -0.18813115f, -0.11519505f, 
    0.12515420f, -0.03814333f, -0.04747458f, 0.07259569f, 0.09748130f, -0.04777525f, -0.06427472f, 0.05432716f, 
    -0.02283363f, 0.02945480f, 0.09295729f, 0.11170343f, 0.63591415f, -0.13037026f, -0.15309398f, 0.02341406f, 
    -0.00448773f, -0.08030296f, 0.00103149f, 0.01972741f, 0.00810790f, 0.00120147f, 0.05895573f, 0.09336338f, 
    0.02388115f, 0.01323547f, -0.08104239f, 0.27906117f, 0.05925731f, 0.00574308f, 0.04596879f, 0.10921278f, 
    0.00177916f, 0.04091997f, -0.04204857f, 0.01266924f, 0.24584295f, 0.05694384f, 0.00660634f, 0.05685288f, 
    0.05375382f, 0.03729704f, -0.06503221f, -0.05338630f, 0.03769221f, 0.10762384f, -0.01491115f, -0.06996305f, 
    0.24380952f, -0.00967477f, -0.11818039f, 0.01531645f, 0.17777659f, 0.12472634f, -0.04899878f, -0.06518225f, 
    -0.07961205f, 0.08302347f, -0.03548576f, 0.03837485f, 0.24750669f, 0.23094219f, 0.05408652f, 0.28583968f, 
    0.01284518f, 0.02210115f, 0.13425691f, 0.15560091f, 0.00748456f, -0.07362436f, 0.01681530f, -0.05605109f, 
    0.04336147f, 0.17271411f, 0.04543506f, -0.05223357f, 0.00881346f, 0.01101387f, 0.03253790f, -0.01299113f, 
    0.10764304f, 0.03451364f, 0.01636302f, 0.04506795f, -0.00775334f, -0.12868540f, -0.18591343f, -0.14369059f, 
    -0.05454808f, 0.10553344f, -0.02451298f, -0.06539710f, 0.01383965f, -0.09496400f, -0.00048611f, -0.03960332f, 
    -0.04212624f, 0.22451882f, -0.10996493f, -0.17865996f, 0.01456752f, -0.02836140f, 0.15207404f, 0.12126486f, 
    -0.15060145f, -0.06742219f, 0.09591544f, -0.00260368f, -0.26069421f, 0.20426153f, 0.16553001f, -0.15740409f, 
    0.06103814f, 0.08718944f, 0.05441552f, 0.03633482f, 0.01856884f, 0.02585607f, -0.02995021f, 0.10017548f, 
    -0.06457797f, -0.29359761f, 0.16869065f, 0.21497004f, 0.03884021f, 0.20258275f, -0.05313819f, 0.14723518f, 
    0.09116961f, 0.06595976f, 0.02173266f, -0.02069345f, -0.06751198f, 0.18347262f, -0.01703734f, -0.33308229f, 
    0.08079477f, 0.00520579f, -0.04002400f, -0.10900483f, 0.09803508f, -0.00893392f, -0.07285229f, -0.12338047f, 
    0.05551792f, 0.40149477f, 0.21401492f, -0.05782072f, -0.01629137f, 0.00400265f, 0.01162606f, -0.00240623f, 
    0.00468769f, -0.08222715f, 0.04660025f, 0.02962850f, 0.01926838f, -0.03689536f, -0.45982516f, 0.12382922f, 
    0.03253159f, -0.02637536f, -0.00713460f, -0.13201979f, 0.18570678f, 0.00930548f, 0.04533700f, -0.09006188f, 
    0.08209310f, -0.14410484f, -0.32884273f, -0.15861055f, 0.13537829f, 0.10396520f, -0.09730241f, -0.07690645f, 
    0.06993322f, 0.07403287f, 0.05783931f, 0.07863351f, 0.17396560f, -0.02600292f, 0.06608231f, 0.18453583f, 
    0.01903529f, 0.05378070f, -0.12408524f, 0.06683278f, 0.12516932f, 0.06462976f, 0.02224299f, 0.01290826f, 
    -0.07704330f, -0.09610859f, -0.06569974f, -0.00446991f, -0.03902190f, -0.06953668f, 0.07226285f, -0.11321732f, 
    -0.09286052f, 0.10574728f, -0.11355644f, 0.02550467f, 0.17642525f, -0.18502928f, 0.06363939f, -0.09908482f, 
    0.09273507f, 0.07747295f, -0.01000277f, -0.13217339f, 0.11137726f, 0.09729091f, 0.00671980f, 0.13119130f, 
    -0.50097382f, 0.16710116f, 0.14805342f, -0.15488170f, -0.04624901f, -0.00831123f, 0.00437099f, 0.01871602f, 
    0.04654111f, 0.03745399f, -0.09476881f, 0.10371713f, 0.22258377f, 0.36132529f, 0.13109241f, -0.28236079f, 
    -0.01349379f, 0.00032276f, -0.00409891f, 0.08508479f, -0.06540712f, -0.02382316f, 0.00488745f, -0.00182227f, 
    0.12087623f, -0.06771927f, -0.03272740f, 0.19558597f, -0.07810518f, 0.09865988f, 0.08185206f, 0.06479383f, 
    -0.07257754f, 0.02637889f, 0.12044841f, -0.03470313f, -0.28303853f, 0.13531789f, -0.04058312f, 0.37658784f, 
    0.10541744f, 0.00849906f, 0.06254188f, -0.03075449f, -0.10423779f, 0.13622406f, 0.04189717f, -0.00683578f, 
    0.02242573f, 0.09941875f, -0.20719659f, -0.39976236f, -0.04133028f, -0.04283971f, 0.07354323f, 0.04957230f, 
    -0.04130751f, 0.02691578f, 0.03476650f, 0.06673138f, -0.13762924f, -0.05361376f, -0.15813956f, 0.04477094f, 
    -0.05053015f, 0.00937267f, -0.18733363f, -0.09662006f, -0.06455782f, -0.03396395f, -0.05221578f, -0.06824862f, 
    -0.08208440f, 0.14021482f, 0.24294935f, 0.28534085f, -0.02372950f, -0.02544352f, 0.04609340f, 0.00948304f, 
    0.07370467f, 0.01930097f, 0.14783527f, 0.13929586f, 0.08250211f, -0.22789837f, -0.14708500f, -0.05834964f, 
    0.08206845f, -0.02370337f, -0.04932224f, 0.08885574f, 0.01242725f, 0.04061577f, 0.10588189f, -0.13847561f, 
    0.05449811f, -0.01136871f, -0.18098234f, 0.11217383f, 0.09777442f, -0.01508087f, 0.06834736f, 0.08869437f, 
    0.04885172f, 0.03026755f, -0.11320684f, -0.18562947f, -0.20291919f, -0.41217914f, -0.09954382f, 0.15514760f, 
    -0.07640252f, 0.11197599f, 0.03595291f, 0.14494069f, 0.03475083f, 0.08977053f, 0.06891944f, -0.05820028f, 
    -0.10125872f, -0.19581893f, 0.05919152f, -0.04085843f, 0.08825084f, -0.12411834f, -0.00848070f, -0.00434806f, 
    0.01535169f, -0.06963410f, 0.25902700f, 0.12772712f, -0.22438468f, 0.27673855f, -0.02924740f, -0.28585440f, 
    0.07496312f, 0.11161974f, 0.04682646f, 0.05506746f, -0.02678354f, -0.00542285f, 0.12146945f, -0.00664406f, 
    0.22388591f, 0.25054377f, 0.07961109f, -0.26451007f, 0.01648165f, 0.08821125f, -0.08319332f, 0.01877668f, 
    -0.03127268f, -0.07391135f, 0.09835632f, 0.04551323f, 0.09214628f, -0.08313626f, 0.07018518f, -0.07226470f, 
    -0.07508373f, 0.09047361f, 0.11382236f, -0.08109827f, 0.05272087f, 0.02652803f, -0.05520529f, 0.00762869f, 
    -0.01449162f, 0.29060438f, 0.08434461f, -0.36807284f, 0.06860965f, -0.05936189f, 0.07123899f, 0.01270463f, 
    0.02301102f, 0.01396466f, -0.00530379f, 0.04259215f, 0.38986486f, -0.15834865f, 0.17737761f, 0.13720489f, 
    0.05428592f, -0.05220049f, -0.07569617f, 0.12308040f, 0.05704688f, -0.00604224f, -0.00409695f, 0.16835469f, 
    -0.01865329f, -0.04533245f, -0.05082158f, -0.01981478f, -0.00156235f, -0.02842687f, 0.00661117f, -0.04620576f, 
    -0.03624699f, 0.01951790f, 0.00150815f, -0.05263394f, -0.01459452f, 0.04326005f, -0.03301935f, -0.00960659f, 
    -0.01948570f, -0.00094104f, -0.00721880f, 0.04206192f, 0.03425317f, 0.03725845f, -0.04989338f, 0.01690158f, 
    -0.01163331f, -0.04935670f, 0.02835296f, 0.01885827f, -0.04339388f, 0.01998173f, 0.05286587f, -0.04119214f, 
    -0.01582558f, 0.00759417f, 0.02618061f, -0.01114452f, 0.03579753f, 0.04736324f, 0.04871048f, 0.00618234f, 
    -0.04517873f, -0.03596675f, -0.05465630f, -0.00462375f, 0.00956428f, -0.01618869f, -0.03125886f, -0.00678917f, 
    0.02052500f, 0.02638058f, 0.00298480f, -0.00092283f, 0.03469008f, 0.03008261f, -0.03616947f, 0.04168752f, 
    0.03837409f, -0.04040920f, -0.05411945f, 0.02370370f, -0.01256579f, 0.00652054f, 0.02143213f, 0.00009312f, 
    -0.02689457f, 0.02822390f, 0.00990874f, -0.00499222f, -0.04829578f, -0.00092553f, -0.01404833f, -0.03334372f, 
    0.02665641f, -0.03672764f, -0.04614204f, 0.02814966f, -0.04471031f, 0.00152495f, -0.03533133f, 0.03964582f, 
    0.01956864f, 0.00957652f, -0.03206271f, -0.05333742f, 0.02845470f, -0.01280937f, 0.01044010f, -0.00206983f, 
    0.05083191f, 0.00759700f, 0.00265796f, 0.02725290f, 0.03383776f, -0.02496378f, -0.01915241f, -0.03304823f, 
    0.00306565f, -0.00947863f, -0.02348834f, -0.00456886f, 0.03558880f, -0.03166525f, -0.02590914f, 0.04270128f, 
    0.02667124f, 0.01946202f, 0.01852025f, -0.00219381f, -0.04788407f, 0.03290697f, -0.02998410f, -0.00787855f, 
    0.02299070f, 0.01844317f, -0.00635328f, -0.01618625f, 0.01239972f, -0.03869861f, 0.03187830f, -0.04346831f, 
    0.01957975f, 0.04169051f, 0.04090784f, 0.03171259f, -0.03487273f, -0.01278916f, 0.01355962f, -0.00302591f, 
    -0.05223609f, -0.00437753f, -0.03278977f, -0.01664265f, 0.00927542f, 0.02407652f, -0.01274319f, 0.00879655f, 
    0.03300824f, 0.02113738f, -0.04767390f, 0.01338625f, 0.00626280f, 0.03991082f, -0.02769431f, 0.03102815f, 
    0.04348554f, 0.00745601f, 0.01783800f, 0.00132747f, -0.01577759f, 0.02345927f, 0.03688867f, 0.01506476f, 
    0.03961641f, 0.01879833f, 0.01122991f, 0.01009844f, -0.02188079f, -0.05692339f, -0.05612607f, 0.01828899f, 
    -0.05045062f, 0.02014515f, -0.00492557f, 0.01872483f, 0.03340203f, -0.05157256f, 0.00039858f, -0.01004753f, 
    -0.01952816f, -0.01662672f, 0.04173971f, 0.00198691f, -0.03657457f, -0.02192996f, -0.04029596f, -0.04790703f, 
    -0.03695599f, -0.02221421f, -0.06506955f, -0.02786314f, 0.01047780f, 0.03961369f, 0.03347740f, -0.01295458f, 
    0.00653582f, -0.01007363f, -0.03940680f, 0.04648587f, 0.02269766f, 0.02994324f, -0.00302581f, 0.02793265f, 
    0.03372962f, -0.01584801f, 0.03285868f, -0.00325360f, 0.03938059f, -0.05082740f, -0.04528347f, 0.01122156f, 
    0.04051124f, -0.02997695f, -0.00526026f, 0.01604451f, 0.02775883f, -0.01413304f, -0.00422964f, -0.01968556f, 
    -0.00568336f, -0.00988563f, 0.00090535f, -0.04032227f, 0.02166365f, 0.01408978f, 0.02966015f, -0.03335215f, 
    0.03915519f, -0.02038031f, -0.00565192f, -0.04174636f, 0.02597295f, 0.02779548f, -0.03188961f, 0.00285823f, 
    -0.05374310f, -0.00228410f, -0.02192734f, 0.03154447f, -0.04672370f, 0.01728317f, -0.04532908f, -0.01909288f, 
    0.02404520f, -0.05232558f, 0.00341349f, -0.00937069f, -0.00435766f, -0.04325259f, 0.00285253f, -0.02679912f, 
    0.00034344f, -0.04578738f, -0.03670393f, 0.00564059f, -0.03960886f, 0.04294720f, -0.02935137f, -0.03783595f, 
    0.01592971f, 0.02281680f, -0.00270298f, 0.00059602f, -0.04467787f, -0.06064050f, -0.01730513f, 0.03571087f, 
    -0.00643211f, -0.00759960f, -0.04741358f, -0.00304604f, -0.01483640f, 0.00907849f, -0.00794628f, 0.03621017f, 
    0.00298696f, -0.01488585f, 0.01613480f, -0.03453518f, 0.00742455f, 0.02259629f, -0.00537156f, 0.01220722f, 
    -0.01269634f, 0.04013251f, 0.01637404f, 0.00103614f, 0.04429558f, 0.02955038f, -0.01576630f, 0.01710344f, 
    0.02180927f, -0.04508907f, 0.03882500f, 0.04760307f, -0.02447036f, -0.03292788f, 0.01614574f, 0.00614663f, 
    -0.03291326f, 0.00409495f, -0.01965933f, 0.00290420f, 0.00553369f, 0.01896423f, -0.01424142f, -0.02008271f, 
    -0.00483896f, -0.04256938f, -0.03255408f, -0.04726389f, -0.04149570f, -0.03989387f, -0.05393762f, -0.01281925f, 
    0.02731477f, -0.00796023f, 0.03960107f, -0.00066188f, -0.04697225f, -0.01891281f, -0.04928079f, -0.04419864f, 
    0.04657266f, -0.01631752f, -0.04191941f, 0.04158828f, -0.03229852f, -0.04943921f, -0.00594373f, 0.00055281f, 
    0.02317555f, -0.02272300f, 0.00373028f, 0.04379353f, 0.01882533f, -0.03123509f, -0.01607535f, -0.00990679f, 
    0.02211928f, -0.00769583f, 0.01623936f, 0.03999270f, -0.03313947f, -0.00806743f, -0.00043779f, 0.03904388f, 
    -0.02154195f, -0.02741186f, -0.00543496f, 0.02777104f, -0.01568430f, -0.03682810f, 0.00838288f, -0.00659546f, 
    0.00448176f, 0.02941195f, -0.05360751f, -0.01846311f, -0.03821648f, -0.03381290f, -0.02368487f, -0.02654000f, 
    0.03512821f, -0.00706299f, 0.01740599f, -0.03803632f, -0.03594677f, 0.01581171f, 0.03345952f, 0.04217735f, 
    -0.03724915f, -0.04727219f, -0.03640778f, 0.03398087f, -0.03861946f, -0.01262496f, 0.03037215f, 0.01161381f, 
    0.04485350f, 0.04152440f, 0.04073790f, -0.05727826f, -0.03848861f, -0.04262876f, -0.03498767f, 0.03358483f, 
    0.00466324f, 0.04171774f, 0.01757804f, -0.00874040f, 0.04085543f, -0.05805683f, 0.00443892f, -0.00102895f, 
    0.02645869f, 0.00651157f, 0.01442196f, -0.04091092f, -0.02927144f, -0.01350401f, 0.01261360f, 0.00469704f, 
    0.03458932f, 0.04263987f, -0.03118076f, -0.05581947f, 0.03537840f, -0.01908864f, -0.03770975f, -0.02421233f, 
    0.02548115f, 0.02870206f, -0.02585337f, -0.05011393f, 0.01609115f, 0.02331103f, -0.01820808f, -0.01646571f, 
    -0.01299818f, 0.01358200f, -0.03840609f, 0.01547750f, 0.01944932f, 0.02125028f, -0.03317917f, 0.02253645f, 
    0.00440476f, -0.03969481f, 0.01232354f, -0.04958623f, -0.01073310f, -0.01183651f, -0.00764873f, -0.00564028f, 
    -0.03184540f, -0.02714392f, 0.02466443f, -0.01558560f, -0.03121497f, -0.03678118f, -0.02645620f, -0.01785608f, 
    -0.01399574f, 0.00099535f, -0.05556913f, 0.02442882f, 0.00886445f, -0.04667222f, 0.04169180f, -0.02534841f, 
    -0.04541643f, -0.02187464f, 0.02488555f, -0.05700472f, -0.05358185f, -0.03310827f, 0.00509437f, 0.01189447f, 
    0.02685448f, -0.03934724f, -0.03015438f, -0.01490739f, -0.00172646f, -0.02704345f, -0.02372115f, -0.04330023f, 
    0.00595174f, 0.02031374f, 0.00181303f, -0.04700632f, 0.02442578f, -0.03640684f, -0.02785526f, -0.04805896f, 
    -0.01648687f, -0.02916565f, 0.01781078f, 0.02540903f, 0.01831768f, -0.00737810f, 0.02518784f, -0.01998847f, 
    0.01663644f, -0.05706093f, 0.01922346f, -0.01868913f, -0.02858504f, 0.00739720f, 0.02766222f, 0.00379102f, 
    -0.00863997f, 0.03222102f, -0.04370068f, 0.04129198f, -0.01670451f, -0.00416126f, -0.01736113f, -0.04959993f, 
    0.01472676f, 0.03553180f, -0.02204007f, -0.01922167f, -0.04516866f, 0.03764497f, -0.00106866f, -0.04422284f, 
    0.03087001f, -0.04329873f, -0.01291566f, -0.01333862f, -0.01567907f, -0.00819239f, 0.03844852f, -0.03046604f, 
    -0.03239170f, -0.02226560f, -0.04335031f, 0.02752594f, 0.03652857f, -0.00694646f, -0.00192122f, 0.00335043f, 
    0.01454473f, -0.03985799f, 0.02622017f, -0.00219405f, 0.03362935f, 0.02773899f, -0.04569062f, 0.01606581f, 
    -0.00224629f, -0.01068947f, 0.04256295f, 0.01385240f, -0.00423398f, 0.00574614f, -0.00643514f, 0.02291419f, 
    0.02759523f, -0.01385899f, 0.03169379f, -0.04962153f, -0.00073556f, -0.05107881f, -0.02121290f, 0.01042631f, 
    -0.03000997f, -0.03041160f, 0.01195961f, -0.05768006f, -0.00838116f, -0.02755320f, -0.03903972f, 0.00459106f, 
    -0.02408702f, -0.00365208f, -0.01981220f, 0.03859152f, -0.04532606f, -0.03119445f, -0.05656334f, 0.00004494f, 
    0.02480415f, -0.03166148f, -0.05519233f, -0.01492534f, 0.00892627f, 0.00152690f, 0.00271901f, 0.01197863f, 
    0.04170984f, -0.05044368f, -0.02286689f, 0.00650210f, 0.00026797f, 0.01942495f, -0.01830465f, -0.05415479f, 
    -0.01216834f, -0.01244894f, -0.02544322f, 0.04193840f, 0.03945117f, -0.04391854f, 0.03023523f, -0.00423905f, 
    0.03738091f, 0.01032986f, -0.00360860f, -0.04053657f, -0.03426026f, 0.03306929f, -0.05135961f, 0.03686219f, 
    -0.03790561f, 0.01968908f, -0.01163302f, 0.03063308f, 0.04017179f, 0.03951224f, -0.00593530f, 0.03992323f, 
    0.02134374f, 0.00281835f, 0.03095987f, -0.02054961f, 0.04231057f, -0.05445671f, -0.02837295f, -0.00063230f, 
    0.02146431f, -0.04007830f, 0.01398089f, -0.00559976f, -0.04279889f, -0.03917408f, -0.02626278f, 0.03099133f, 
    -0.02899663f, 0.03516199f, -0.03720269f, 0.00651875f, 0.03370601f, -0.04413707f, 0.00067970f, -0.00619491f, 
    -0.04166491f, 0.01222801f, -0.02263553f, 0.01560210f, -0.02671393f, -0.04939971f, 0.01321614f, -0.01405891f, 
    0.02919991f, 0.00856073f, -0.02537443f, -0.03980922f, -0.01041789f, -0.03270165f, 0.03727501f, -0.04965112f, 
    -0.04386965f, 0.03663408f, -0.03756269f, -0.00729849f, 0.00789379f, -0.05223856f, -0.05054850f, -0.03019022f, 
    0.00946568f, 0.01132250f, 0.02721209f, 0.03007687f, -0.04136141f, 0.00639198f, 0.01994271f, 0.03257370f, 
    -0.02321631f, -0.00874286f, -0.02489432f, -0.04224311f, 0.00646199f, -0.00027608f, 0.02806934f, 0.02704172f, 
    0.03718650f, -0.01098647f, 0.03445537f, 0.03576671f, -0.02634267f, -0.01602432f, -0.04885858f, 0.01341820f, 
    0.02172801f, 0.01118674f, -0.04099225f, -0.05501890f, -0.00767756f, -0.05077136f, 0.03726603f, 0.00259951f, 
    -0.04465668f, 0.02584786f, 0.04516380f, -0.00730101f, -0.02432638f, 0.02706920f, -0.00389600f, -0.04539294f, 
    -0.00818611f, 0.02872862f, -0.04044992f, -0.03297657f, -0.05156432f, -0.03583335f, 0.03901915f, 0.02127324f, 
    0.02289947f, -0.03830733f, 0.00763976f, -0.05477639f, 0.02191803f, 0.02479719f, 0.03231095f, 0.01125786f, 
    -0.05727980f, 0.03530935f, -0.03827224f, -0.00775082f, 0.04276126f, -0.00741994f, 0.00396697f, 0.02099763f, 
    -0.03729039f, 0.04008228f, 0.02477411f, -0.00655871f, -0.00472653f, -0.05580683f, 0.04274748f, -0.04225162f, 
    -0.01311884f, -0.01524735f, 0.00130895f, -0.04632527f, 0.00908951f, -0.01315863f, -0.01583228f, 0.00064828f, 
    0.01380640f, 0.03267017f, -0.02068229f, -0.02241469f, 0.03361573f, 0.04043361f, -0.00299789f, -0.05372072f, 
    -0.03593951f, -0.04599904f, -0.01662035f, -0.04112322f, -0.00027646f, 0.03475366f, -0.01061035f, 0.03301941f, 
    -0.04472272f, -0.04328203f, -0.03733106f, -0.03686599f, -0.03002279f, 0.02352311f, -0.01224747f, -0.02788864f, 
    0.00134370f, -0.03798818f, 0.00659675f, -0.00973792f, -0.01394824f, 0.02223266f, 0.01910738f, 0.00061187f, 
    -0.02916780f, 0.04559585f, 0.01989946f, -0.05645810f, 0.03615075f, -0.04065913f, 0.03514040f, 0.04457026f, 
    -0.02365445f, -0.04364216f, -0.01028528f, -0.04408960f, 0.00692995f, 0.01937154f, 0.02185903f, -0.02356103f, 
    0.42469981f, -0.10759471f, 0.08155925f, 0.17390002f, -0.03008273f, -0.07790420f, 0.03972949f, 0.04812896f, 
    -0.01867539f, -0.12197553f, -0.03679396f, 0.03481724f, 0.02671367f, 0.14192417f, -0.12716450f, -0.02478831f, 
    0.01658800f, -0.04238114f, 0.01324270f, 0.04206274f, 0.05204069f, 0.02456187f, 0.05484649f, 0.03858465f, 
    -0.29001826f, -0.03162704f, -0.06365963f, -0.22463723f, 0.06492163f, 0.15334098f, -0.06183484f, -0.07551194f, 
    -0.00814564f, 0.11694998f, 0.09508002f, -0.02478655f, 0.40435639f, 0.15034606f, -0.19330722f, -0.12945978f, 
    -0.16928813f, -0.05632244f, -0.05713488f, 0.10072965f, 0.04275711f, -0.02965299f, 0.10833124f, -0.07620998f, 
    -0.08830424f, -0.12334406f, 0.02209392f, -0.08656465f, 0.07232893f, -0.05118719f, 0.08842921f, 0.07215837f, 
    0.00174446f, -0.04549251f, 0.00051811f, -0.05108874f, -0.22447222f, 0.19452110f, 0.13022049f, 0.08808064f, 
    0.10811449f, -0.03279905f, -0.14071754f, -0.00740810f, 0.03745298f, -0.04020831f, 0.00775525f, 0.09417155f, 
    0.14420542f, -0.25694838f, 0.00440452f, 0.13461703f, -0.04665462f, -0.08488198f, -0.04954771f, 0.02955989f, 
    -0.03227464f, 0.07331098f, 0.04494971f, -0.03216923f, 0.14838052f, 0.11553404f, 0.18729517f, 0.09807864f, 
    -0.03044825f, 0.01939366f, 0.05978364f, -0.00961730f, 0.02159526f, -0.05517679f, 0.03629299f, -0.04172064f, 
    0.16187294f, 0.13535711f, -0.08451349f, 0.20950417f, 0.01979600f, -0.02483580f, -0.02918656f, 0.01128040f, 
    0.00665009f, 0.03313110f, 0.03986838f, 0.02148376f, 0.35707474f, 0.12400732f, 0.20591195f, 0.05268599f, 
    -0.08575068f, -0.02109064f, 0.16165152f, 0.02753707f, -0.03727138f, 0.08963084f, 0.08837540f, 0.15335602f, 
    0.22655959f, -0.13066189f, -0.11894932f, 0.10784975f, -0.00122129f, -0.04572067f, 0.07803515f, 0.15016712f, 
    -0.03749435f, -0.07804970f, 0.02401591f, -0.01205398f, -0.23387444f, 0.05004746f, -0.11444210f, 0.05039155f, 
    0.04298780f, 0.07938147f, 0.03213658f, -0.05467597f, -0.08936504f, -0.06135886f, -0.02255672f, -0.09278619f, 
    -0.35391077f, -0.16645597f, -0.15401258f, -0.12778008f, 0.12070793f, 0.06412751f, 0.05635590f, -0.06642550f, 
    -0.02046472f, 0.02325436f, 0.04598002f, 0.16400243f, -0.01519738f, 0.17797208f, 0.15651141f, -0.02499939f, 
    0.05579926f, 0.07592941f, 0.05425028f, 0.10951094f, -0.05030730f, 0.02362492f, 0.17095912f, 0.06855590f, 
    0.06040441f, 0.17036924f, 0.01501104f, 0.05412236f, 0.04645315f, 0.15702902f, -0.05672089f, 0.07273460f, 
    0.03804309f, 0.05195699f, 0.04910158f, 0.11546432f, -0.13585259f, 0.11308902f, 0.11962943f, 0.05397608f, 
    0.04436541f, -0.05674970f, -0.07874973f, 0.07087179f, -0.08965267f, -0.07819700f, 0.13966261f, 0.01120028f, 
    0.05248826f, -0.00506941f, 0.16210248f, 0.11813699f, -0.01729272f, -0.09076138f, 0.06246618f, 0.00456459f, 
    -0.05125668f, -0.04937631f, 0.06376678f, -0.04611528f, 0.16843273f, 0.01552390f, -0.20520446f, 0.11631469f, 
    -0.04308033f, 0.09040491f, 0.01933051f, -0.00044895f, 0.01458306f, -0.10041599f, 0.05851454f, 0.09935366f, 
    -0.18418491f, 0.09348127f, 0.08651341f, -0.01998711f, 0.02333445f, -0.07458633f, 0.10346827f, -0.11124171f, 
    -0.03921021f, -0.14144328f, -0.19915244f, -0.16408487f, 0.05181744f, 0.04794358f, -0.01549027f, -0.15160742f, 
    -0.04137484f, 0.02191995f, -0.16794010f, 0.07375351f, 0.04758582f, -0.03504496f, -0.04108962f, 0.01516711f, 
    0.18544026f, -0.11818846f, 0.32415429f, 0.19603257f, -0.01039060f, 0.00485108f, 0.07361150f, -0.00573461f, 
    -0.01120994f, -0.02484984f, 0.01708073f, 0.07597110f, -0.06538839f, -0.01028317f, 0.00766006f, 0.17114311f, 
    -0.02451075f, -0.01497610f, -0.02234571f, -0.02157291f, 0.13628022f, 0.04294888f, 0.08912887f, 0.13581100f, 
    0.13187703f, -0.09710624f, 0.05768517f, 0.14309496f, -0.09399182f, 0.12729728f, 0.11041983f, 0.12095923f, 
    0.02284330f, 0.01627425f, -0.12816650f, 0.04839215f, -0.35783982f, 0.05942521f, 0.04091180f, -0.04047664f, 
    0.03269750f, 0.06519342f, 0.04352909f, -0.05830731f, 0.05903743f, -0.04038186f, -0.04960662f, -0.02733565f, 
    0.19169559f, -0.00148335f, 0.01630008f, 0.07757534f, -0.05648089f, -0.01681506f, 0.03328364f, 0.01180928f, 
    -0.02115980f, 0.01748502f, 0.03822153f, 0.01742786f, -0.12883124f, 0.17763810f, 0.04679465f, -0.00230262f, 
    0.02147815f, 0.05589614f, -0.01030851f, 0.04340145f, -0.08484242f, 0.01917917f, 0.05310428f, -0.09548692f, 
    -0.16796358f, 0.01197131f, 0.19662735f, 0.00548692f, 0.06812444f, 0.03065783f, 0.05930241f, 0.04886717f, 
    0.08041149f, 0.03437642f, -0.09352578f, 0.11259438f, 0.18859029f, 0.03526188f, 0.11489306f, 0.10977056f, 
    -0.12269514f, 0.02427045f, 0.05836450f, -0.02472178f, 0.04987369f, 0.06471491f, -0.02813587f, 0.01480378f, 
    -0.26486012f, 0.14566737f, 0.03189081f, -0.04692215f, -0.01050549f, 0.00867454f, 0.07587386f, 0.01342762f, 
    0.06322446f, 0.14294472f, 0.06040342f, 0.00994446f, -0.27788714f, -0.06100954f, 0.03779607f, -0.02599174f, 
    0.00607730f, 0.04641725f, 0.02129971f, -0.12776014f, -0.04499459f, -0.07791330f, 0.07119308f, 0.02762357f, 
    0.17196609f, -0.02898879f, 0.04759802f, 0.13857386f, -0.11012814f, 0.07199052f, -0.09171665f, 0.00188223f, 
    -0.07323561f, -0.09742489f, -0.04622710f, -0.03309910f, 0.08607569f, 0.20775025f, -0.04214289f, 0.21181916f, 
    -0.04531261f, -0.13838553f, 0.02045616f, 0.07276899f, 0.05076547f, -0.00776847f, 0.04209448f, -0.11191690f, 
    0.04343095f, -0.02538519f, -0.03484070f, 0.03645160f, -0.01370776f, 0.04164394f, 0.03021518f, 0.00085969f, 
    -0.02197357f, -0.03713438f, 0.00887677f, 0.03831092f, -0.00379651f, 0.02665486f, 0.03888590f, -0.05633274f, 
    -0.02968048f, 0.01905030f, -0.00015017f, -0.00582185f, -0.03333654f, -0.04475100f, -0.00565102f, -0.03545694f, 
    -0.05357395f, -0.00699475f, 0.04371970f, -0.05061811f, -0.00346334f, -0.03320098f, -0.04150574f, 0.00375003f, 
    -0.05391552f, -0.02682607f, -0.04295447f, -0.04341773f, -0.01497471f, 0.04052377f, 0.00923267f, -0.04913962f, 
    0.00660789f, 0.04119315f, -0.05128079f, -0.01480652f, 0.02954832f, 0.03687338f, -0.02516700f, -0.05068753f, 
    0.02809080f, -0.01461667f, 0.01667688f, -0.02247685f, -0.02024695f, -0.05424992f, -0.02701702f, -0.02474379f, 
    0.00970714f, -0.00752773f, -0.02984562f, -0.00651261f, -0.04836196f, 0.00664244f, 0.02048068f, -0.00757200f, 
    -0.01864159f, -0.02008715f, 0.04335095f, -0.00376512f, 0.00966367f, -0.03680781f, -0.01158165f, 0.03571557f, 
    0.00176557f, 0.02752936f, -0.04298906f, 0.03073561f, -0.05066082f, -0.04359119f, 0.03270628f, 0.04780931f, 
    0.00871180f, -0.04641124f, -0.02467935f, 0.04609089f, 0.02684696f, -0.03475856f, -0.04984896f, 0.04140329f, 
    0.00042101f, -0.02454618f, 0.00984242f, -0.02772424f, -0.04821865f, 0.04389910f, -0.01990821f, 0.00115826f, 
    0.02101287f, -0.00349412f, 0.03508595f, 0.03253010f, 0.02240368f, 0.01689754f, 0.00748222f, -0.01109433f, 
    -0.00616587f, -0.02950330f, -0.02099523f, 0.02488851f, -0.04726541f, -0.02005034f, 0.03138319f, 0.00762721f, 
    -0.02397316f, 0.01710334f, 0.03975415f, -0.01396782f, 0.01715643f, -0.04825759f, 0.03454399f, -0.04308860f, 
    0.01636467f, -0.01140737f, -0.05110965f, -0.04419867f, -0.01149605f, 0.02584251f, -0.05876101f, -0.04901509f, 
    0.04087019f, -0.00032567f, -0.01043509f, 0.02941442f, -0.04327978f, -0.00760107f, -0.04128271f, -0.00735643f, 
    0.02847379f, -0.04695246f, -0.05260764f, -0.03967669f, -0.04336921f, -0.05031212f, -0.01832089f, 0.04327614f, 
    0.02058887f, 0.02413044f, -0.01503388f, 0.03813108f, -0.01127908f, -0.03716788f, -0.00220025f, 0.02024885f, 
    0.01379667f, -0.03257741f, 0.00869893f, -0.01174674f, -0.00683015f, 0.04447115f, 0.00420209f, -0.00141557f, 
    0.01755310f, -0.02718032f, -0.00696630f, 0.00749106f, -0.01123668f, 0.00609613f, 0.01395086f, -0.03171983f, 
    -0.03798462f, 0.02496336f, 0.01342142f, -0.03151730f, -0.01539626f, -0.03282549f, -0.02802433f, -0.01381074f, 
    0.00767469f, 0.03468939f, -0.01225144f, 0.00951474f, -0.02403509f, 0.03192957f, -0.00946220f, -0.01722508f, 
    -0.04135162f, 0.00805156f, 0.01346656f, -0.04367834f, -0.00798458f, 0.03152665f, 0.01475922f, 0.00269942f, 
    -0.01147360f, -0.01078265f, 0.02349018f, -0.00658458f, -0.05563239f, -0.04685797f, -0.02231571f, -0.05046442f, 
    -0.01595115f, -0.00301194f, 0.00507018f, -0.04946389f, -0.02104425f, -0.03324630f, 0.00030420f, 0.04046674f, 
    -0.04706382f, 0.01775393f, -0.01554585f, 0.03597954f, -0.01634186f, 0.02635850f, -0.05313766f, -0.04359371f, 
    0.04115736f, -0.03694122f, 0.00939354f, 0.00513286f, 0.03241507f, -0.01559157f, -0.05485449f, 0.04374103f, 
    0.00419962f, 0.01639589f, 0.01436045f, 0.02048294f, 0.01760049f, -0.04755307f, 0.02364756f, 0.03523476f, 
    -0.03489688f, -0.02490053f, -0.01692353f, -0.01233692f, -0.02948561f, 0.04532713f, -0.02563429f, -0.03839976f, 
    -0.02933963f, 0.01546895f, -0.04875694f, 0.02399551f, -0.01487841f, 0.03469985f, -0.04070120f, -0.05123207f, 
    -0.03831214f, -0.01944146f, 0.02705623f, 0.02556216f, -0.02870545f, 0.02163715f, -0.02996245f, 0.02023792f, 
    -0.00612635f, -0.03886221f, -0.04409887f, 0.00208407f, 0.02779376f, -0.04826400f, 0.04524366f, -0.05065053f, 
    0.02894790f, -0.00099269f, 0.02699517f, -0.00778590f, -0.00880071f, 0.04148572f, 0.00546164f, -0.05237493f, 
    0.00946168f, 0.03718892f, -0.02606338f, -0.03167514f, -0.02501884f, 0.01157731f, -0.04921479f, -0.03523487f, 
    0.03120222f, 0.00355590f, 0.01051843f, 0.03873806f, 0.04166277f, -0.02076972f, 0.03259944f, -0.02889123f, 
    0.00453914f, 0.01402137f, -0.01418583f, -0.03599421f, 0.00309396f, 0.00672051f, -0.02779875f, -0.00590949f, 
    -0.03896509f, -0.02800912f, -0.04915639f, -0.01903305f, -0.01710426f, -0.04365364f, -0.04709335f, 0.01372125f, 
    0.03698529f, 0.03719340f, 0.00824709f, 0.01730439f, -0.02880685f, 0.00699403f, 0.03883155f, -0.02639024f, 
    0.01304648f, -0.04403798f, -0.05625539f, -0.00516192f, -0.03865157f, 0.04176601f, 0.03190568f, -0.00241499f, 
    0.00722105f, -0.02781245f, -0.01813550f, 0.02379136f, 0.04033139f, 0.03469727f, -0.00995134f, 0.01820130f, 
    -0.01850680f, -0.03551516f, -0.03132097f, -0.00234738f, -0.05050800f, -0.02307841f, -0.03422500f, 0.03667459f, 
    -0.03016238f, -0.03763662f, 0.03131327f, -0.05630284f, -0.03499818f, 0.01422834f, -0.04076168f, 0.04026017f, 
    0.03044394f, 0.01546361f, 0.04093732f, -0.03914244f, -0.05216276f, 0.00466571f, -0.00200034f, -0.00065905f, 
    -0.02730210f, 0.00929132f, 0.03294995f, 0.04355019f, -0.00910389f, -0.00932061f, 0.02174764f, -0.02731567f, 
    -0.03993556f, -0.00861247f, 0.02062758f, -0.00804589f, 0.01672279f, -0.04237771f, -0.05530566f, -0.01024847f, 
    0.03516230f, -0.02109154f, 0.03675257f, -0.05738051f, 0.03054869f, 0.02611241f, 0.01289473f, -0.05554266f, 
    0.02555328f, 0.00964110f, -0.04195469f, -0.03460884f, -0.04776648f, 0.03735382f, -0.04039413f, -0.00153664f, 
    -0.00147540f, -0.01857601f, 0.03071651f, -0.01506516f, 0.02134122f, -0.02930832f, -0.04241504f, 0.02376805f, 
    0.03094551f, 0.01531993f, 0.02584861f, 0.01533159f, 0.01064360f, 0.02443857f, 0.00256610f, -0.02940497f, 
    -0.03751976f, 0.01773972f, -0.02685952f, -0.00448465f, -0.02546148f, 0.03567472f, 0.03264208f, -0.05309313f, 
    0.01113136f, -0.03994393f, 0.00057141f, -0.04891955f, -0.05452915f, 0.03003280f, -0.03362493f, -0.00074820f, 
    0.03904727f, 0.02806398f, -0.00072453f, 0.03146444f, 0.03416113f, 0.03499871f, 0.01055686f, -0.00562334f, 
    -0.04482907f, -0.00887041f, 0.04261724f, 0.03207974f, -0.05278482f, -0.05480956f, -0.01152329f, -0.03921885f, 
    -0.03610067f, -0.04336291f, -0.04340099f, 0.03644291f, -0.03569708f, -0.04459896f, 0.01508069f, -0.01979590f, 
    0.02437284f, 0.01938453f, 0.05059040f, -0.03178758f, -0.01604654f, -0.00691461f, 0.00646471f, -0.05699490f, 
    0.01660499f, 0.03583192f, 0.01232010f, -0.05096988f, -0.05157100f, 0.03990351f, 0.04074140f, -0.01854433f, 
    -0.05617072f, -0.00082040f, 0.00302045f, -0.00151752f, -0.01955083f, 0.04659203f, 0.01217723f, 0.01766106f, 
    -0.04126313f, 0.03042248f, -0.01739534f, 0.04172632f, -0.04640055f, 0.00152264f, 0.02132926f, -0.04653590f, 
    -0.02529827f, 0.01488989f, 0.02840457f, -0.00358337f, 0.03742801f, 0.02573212f, 0.02833050f, -0.02814553f, 
    -0.03526239f, -0.03335227f, 0.03700341f, 0.00048656f, 0.04210348f, -0.01296808f, 0.01916333f, -0.04103010f, 
    0.03782941f, -0.00664646f, 0.02523987f, -0.00369595f, -0.04702378f, -0.01782968f, -0.01082314f, 0.03517384f, 
    0.05134335f, 0.04116244f, -0.04735122f, 0.02301633f, -0.00643298f, -0.04200529f, -0.00648942f, -0.01317870f, 
    -0.04097949f, 0.02911394f, -0.05633488f, -0.04507954f, -0.05321287f, 0.04219048f, -0.03272737f, 0.00296532f, 
    0.01665873f, 0.03554717f, 0.02962711f, -0.02546076f, -0.01451032f, -0.04976225f, -0.00615330f, 0.01251108f, 
    0.03892061f, 0.00758098f, -0.01000126f, -0.04373696f, -0.01396412f, -0.02882797f, 0.00178556f, 0.00302289f, 
    0.00282165f, -0.05546159f, -0.04977833f, 0.02631393f, -0.05319799f, -0.00959800f, -0.03910598f, -0.04118007f, 
    0.01262508f, 0.02840273f, -0.01052512f, -0.02035314f, -0.01397545f, -0.00426913f, 0.01441665f, 0.00140322f, 
    -0.03623075f, -0.00501064f, -0.04222267f, -0.04723139f, -0.04052153f, 0.05083374f, -0.01836806f, 0.00078978f, 
    0.00693939f, -0.03054515f, 0.01423013f, -0.03658455f, 0.01766616f, 0.02122344f, 0.02347479f, -0.05213489f, 
    0.04485271f, -0.03209393f, 0.03150248f, -0.01077333f, -0.01790741f, 0.03921578f, 0.00310185f, 0.04232785f, 
    -0.03536740f, -0.00360741f, -0.03187450f, -0.03916344f, -0.02016238f, -0.04475496f, 0.00721896f, -0.03712419f, 
    0.01899531f, -0.01365378f, 0.01901634f, 0.02986809f, 0.00997814f, 0.00574354f, -0.00253412f, 0.02038043f, 
    -0.01760978f, -0.03479307f, 0.01878321f, 0.04300857f, 0.03084517f, -0.03204042f, -0.01791351f, -0.00887574f, 
    0.02129624f, -0.04685038f, -0.01847364f, 0.00635299f, -0.00562467f, -0.05157527f, -0.00852375f, -0.01801638f, 
    -0.03834555f, -0.04769945f, -0.03683422f, -0.00879995f, -0.04169088f, -0.02026018f, 0.03561510f, -0.00113683f, 
    -0.01047953f, -0.01603565f, -0.04432709f, -0.00006950f, -0.03036917f, 0.03720502f, 0.04384715f, 0.03561974f, 
    -0.05498949f, 0.02160673f, -0.04104243f, 0.02351187f, -0.00091310f, 0.00450136f, -0.00835302f, -0.03864041f, 
    0.01354723f, 0.01984349f, -0.05146900f, 0.03699545f, -0.05127877f, -0.02680033f, 0.03426240f, 0.03147860f, 
    0.02285117f, 0.03727302f, -0.00682382f, 0.03507048f, -0.00110592f, 0.01898431f, 0.02202532f, -0.04850129f, 
    -0.05517422f, -0.03378696f, -0.01361852f, 0.00748359f, -0.04407580f, 0.02101145f, -0.04937886f, -0.00752953f, 
    -0.04629365f, -0.00163969f, 0.01291071f, 0.04546729f, 0.04446603f, -0.00959475f, -0.00438579f, -0.05021645f, 
    0.03063277f, -0.00938665f, -0.00571564f, 0.04377580f, -0.01751993f, 0.03192939f, -0.04173349f, -0.03339003f, 
    0.02930101f, -0.05674523f, 0.01253654f, -0.01076392f, -0.03241115f, -0.05092453f, 0.01663568f, -0.02873921f, 
    -0.00694810f, 0.01079945f, -0.05627394f, -0.04622131f, 0.04498933f, -0.03981969f, 0.01857995f, -0.03558967f, 
    0.03144250f, -0.04613598f, 0.04033571f, -0.03582427f, -0.02467637f, -0.01389390f, -0.03520913f, 0.02002186f, 
    -0.03717316f, 0.02385082f, 0.02838231f, 0.05026085f, -0.03789823f, -0.03952157f, -0.00192231f, -0.01235056f, 
    0.01545500f, -0.01542158f, 0.04191041f, 0.00180315f, -0.01540022f, 0.01751000f, -0.04603466f, -0.00492046f, 
    -0.02650886f, 0.01909120f, 0.00735067f, 0.01426741f, -0.00518401f, -0.01152327f, -0.02401221f, 0.03411672f, 
    0.00524979f, -0.03483058f, 0.02936883f, 0.01123806f, 0.02405947f, -0.01849623f, -0.04824338f, -0.04780282f, 
    0.04045118f, -0.05364817f, 0.03165020f, -0.03360995f, -0.00885731f, -0.02262152f, 0.01420732f, -0.02831885f, 
    0.00047637f, -0.01821774f, -0.01089304f, -0.02237165f, 0.05134138f, -0.01042355f, 0.02812178f, -0.00291602f, 
    0.00718572f, -0.02261201f, -0.03135468f, -0.02943514f, -0.04603501f, -0.05029655f, 0.01641577f, -0.05448987f, 
    0.02697223f, 0.02405313f, -0.01506679f, -0.00799677f, 0.00176741f, 0.04396041f, -0.03929022f, -0.02199819f, 
    -0.00589010f, 0.00803712f, 0.01827883f, 0.01043589f, -0.01348966f, -0.01903698f, -0.00951627f, -0.00378183f, 
    -0.02621629f, 0.01459486f, -0.02467068f, -0.03090184f, -0.05406921f, -0.04959774f, -0.03601408f, -0.03302504f, 
    -0.20117436f, 0.08380253f, -0.19221903f, 0.20350206f, 0.06428974f, 0.08901551f, 0.01582146f, 0.06412591f, 
    0.08378732f, 0.02750159f, 0.03021318f, 0.06421282f, 0.16018975f, 0.10604366f, 0.08029523f, 0.11885929f, 
    0.05698974f, -0.08437856f, 0.00651427f, -0.06527099f, -0.09036934f, -0.09591383f, -0.05513454f, -0.03201737f, 
    0.09125603f, 0.17315064f, -0.01688609f, 0.16093615f, 0.02786444f, -0.02606081f, -0.03598740f, -0.03390218f, 
    0.01549508f, -0.01199524f, -0.00468195f, 0.06233483f, 0.29989716f, 0.11888417f, 0.22355315f, 0.19911975f, 
    0.07663389f, 0.02625747f, 0.10483428f, -0.03753317f, 0.04862483f, 0.01994221f, -0.06769831f, 0.08535314f, 
    0.09482663f, 0.23652892f, 0.04013418f, -0.01331637f, -0.10011987f, 0.16220556f, 0.08659413f, 0.12002007f, 
    0.12953526f, 0.00553628f, 0.03670672f, 0.05336847f, -0.12991804f, -0.13662206f, -0.32004234f, -0.00088549f, 
    0.07534683f, 0.07851061f, 0.09201155f, -0.03185881f, 0.04598026f, 0.02430000f, 0.06583565f, -0.10977666f, 
    -0.02384366f, 0.29379001f, 0.15622509f, -0.08320940f, 0.05550137f, -0.02878193f, 0.04299625f, 0.16086297f, 
    -0.05434419f, 0.00372878f, 0.03888572f, 0.00888785f, -0.26293427f, 0.05113056f, -0.01160891f, -0.11683984f, 
    0.13380840f, 0.08244020f, 0.10452679f, 0.00226486f, 0.06864058f, -0.03102930f, -0.05990462f, 0.09376430f, 
    -0.21658765f, -0.28016943f, 0.26588154f, 0.01511111f, 0.11913109f, 0.17752226f, 0.01910846f, 0.05084197f, 
    0.10679433f, 0.00466582f, 0.03291783f, -0.02440476f, -0.25317204f, 0.04686030f, -0.07372297f, -0.32564768f, 
    0.19252457f, -0.09076772f, -0.05456360f, -0.09096886f, 0.03163891f, 0.08682777f, -0.02493214f, -0.12994209f, 
    0.05969509f, 0.41403911f, 0.21403366f, -0.05258562f, 0.01293626f, -0.03649963f, -0.00048759f, -0.09114325f, 
    0.02818386f, -0.02232062f, 0.06818034f, -0.01931797f, -0.07007691f, -0.02007673f, -0.26341000f, 0.13085410f, 
    0.03694187f, 0.03330828f, -0.03266617f, -0.11902998f, 0.14613777f, 0.02778755f, 0.03197304f, -0.10359782f, 
    0.00935938f, -0.04784884f, -0.18026812f, 0.01927133f, -0.09053678f, 0.04894318f, -0.00112447f, 0.04012801f, 
    0.08697689f, -0.06384666f, 0.10890510f, -0.13080959f, 0.09404207f, -0.19422954f, -0.11145414f, 0.06584697f, 
    0.00201422f, 0.09435672f, -0.09855597f, -0.02588135f, 0.06226508f, -0.08463399f, -0.00427854f, -0.06641156f, 
    0.13189186f, -0.19929357f, -0.01014555f, 0.09199166f, -0.14098243f, 0.01536521f, 0.00900281f, -0.04729716f, 
    -0.13102642f, 0.04211529f, -0.16980267f, 0.02876824f, 0.08123142f, -0.10794343f, -0.01525538f, -0.20661657f, 
    0.05968590f, 0.01953610f, -0.10514858f, 0.04688042f, 0.10817422f, 0.07797956f, -0.00930931f, 0.05269034f, 
    -0.42499959f, -0.09699672f, 0.05968349f, -0.44922155f, 0.03332131f, -0.01401014f, 0.04034900f, 0.01123678f, 
    0.03167691f, 0.07390423f, -0.11481799f, -0.01400941f, 0.20024344f, 0.26910734f, 0.19226219f, -0.21755747f, 
    -0.03422991f, -0.01743584f, 0.01854247f, 0.18365064f, 0.07522334f, -0.00116057f, 0.04558495f, 0.08236603f, 
    0.08584008f, -0.14124426f, 0.06335022f, 0.12919065f, -0.12432295f, 0.04439920f, 0.02409249f, 0.08061256f, 
    -0.01882632f, 0.03815434f, 0.07919538f, 0.01529615f, -0.03724512f, -0.02470543f, 0.00926329f, 0.17146534f, 
    0.05267641f, -0.02378725f, 0.03112471f, 0.02867585f, -0.09354813f, 0.09370921f, 0.16557762f, -0.00214318f, 
    -0.19358115f, 0.07997487f, -0.27815908f, -0.36785346f, 0.16833657f, -0.13044636f, 0.05004917f, -0.00479058f, 
    -0.07625179f, -0.06431600f, 0.10581852f, 0.13039418f, -0.14469573f, -0.10015468f, -0.15708558f, -0.07623193f, 
    0.10070796f, -0.01643766f, -0.07437790f, -0.05413990f, -0.06982162f, 0.02873723f, -0.03853317f, -0.03819418f, 
    -0.06920767f, 0.16529337f, 0.24488980f, -0.04868754f, -0.04410904f, 0.01094410f, 0.00046451f, 0.00087858f, 
    -0.03432073f, -0.04996337f, 0.14781201f, 0.06722888f, 0.05345031f, -0.09530597f, -0.17889579f, 0.00925764f, 
    0.11641904f, -0.10504239f, 0.06125454f, 0.09093525f, -0.01280417f, -0.00248894f, 0.09815549f, -0.11667575f, 
    -0.00950127f, -0.02295397f, -0.19127400f, -0.03468035f, 0.13495219f, 0.02472470f, 0.04080120f, 0.06744915f, 
    -0.02255609f, -0.07196692f, 0.03529976f, -0.14046650f, -0.11729905f, -0.49804333f, 0.04097040f, 0.19452766f, 
    -0.01079652f, 0.11216804f, 0.03238975f, 0.11521520f, 0.12320536f, 0.08507370f, 0.11784009f, -0.05030247f, 
    -0.09411401f, -0.24648094f, 0.03239428f, 0.00363944f, 0.14173970f, -0.02197250f, -0.03648237f, 0.09759018f, 
    -0.02528543f, -0.00756369f, 0.20122999f, 0.12377359f, -0.18482593f, 0.17863716f, -0.11756866f, -0.30501965f, 
    0.22653590f, 0.05068151f, 0.00988122f, 0.05759562f, 0.02359630f, -0.06364910f, 0.11753809f, 0.02522533f, 
    -0.03609193f, 0.21423733f, 0.00016978f, -0.20640320f, 0.13156712f, 0.08124720f, -0.00810936f, -0.02762529f, 
    -0.11808319f, -0.05372674f, 0.04498138f, -0.02233755f, -0.08185954f, -0.03594293f, 0.10697196f, -0.09727371f, 
    0.04800902f, -0.00637459f, 0.10679598f, -0.01966476f, -0.03832105f, 0.06905308f, -0.05668376f, -0.01328075f, 
    -0.05676769f, 0.12244865f, -0.03532631f, -0.22158380f, 0.21543258f, 0.03777992f, 0.03864682f, 0.09449235f, 
    0.08375896f, 0.10055394f, 0.05156673f, 0.20771925f, 0.42522627f, -0.30180112f, 0.12185200f, 0.06310048f, 
    -0.02359451f, -0.03906624f, -0.09344262f, -0.00796501f, -0.03249421f, 0.03046117f, 0.07386725f, 0.17561167f, 
    -0.19764389f, -0.33535805f, -0.27257124f, -0.04116167f, 0.07804831f, -0.02064677f, -0.04702915f, -0.06217610f, 
    0.07286487f, -0.05361855f, 0.02272571f, -0.06583104f, 0.08111697f, 0.12821870f, 0.22630693f, -0.00080190f, 
    -0.00804617f, 0.00572007f, -0.01914382f, -0.13484474f, 0.04704823f, 0.03435319f, -0.00173346f, -0.10674133f, 
    0.41332272f, -0.09167468f, 0.07079490f, -0.06840881f, -0.09663479f, -0.05175523f, 0.05010970f, 0.16397412f, 
    -0.07329966f, 0.05819255f, -0.01460798f, 0.01552493f, -0.34128410f, 0.03287886f, -0.02847368f, 0.09440296f, 
    0.08157927f, 0.02934724f, -0.06574335f, 0.01731945f, 0.00864968f, 0.02792517f, 0.08906348f, 0.05197786f, 
    0.22412090f, 0.10448958f, 0.22082070f, -0.19890605f, 0.16427650f, 0.00856654f, -0.05808454f, 0.15076020f, 
    0.07991379f, -0.03148066f, -0.09178907f, -0.04850036f, 0.24078886f, 0.26113769f, -0.02185277f, 0.07962239f, 
    0.00580476f, 0.08024290f, 0.02663139f, -0.07507744f, 0.11199815f, 0.00181950f, 0.06457160f, 0.03662303f, 
    0.12750830f, 0.22320333f, 0.03156383f, 0.03068628f, 0.02747395f, -0.15387055f, 0.09116023f, 0.10064455f, 
    0.09676245f, 0.01916656f, 0.07381874f, -0.03455403f, -0.19954124f, -0.15941368f, -0.02131081f, -0.08577308f, 
    0.08044318f, 0.02612196f, 0.08355906f, 0.04063807f, -0.06745982f, 0.04453497f, -0.03013932f, -0.05417037f, 
    0.15233405f, 0.07568666f, -0.09283126f, 0.10490783f, 0.17437336f, 0.05557057f, 0.00365822f, 0.02589233f, 
    0.05401638f, -0.02162550f, -0.01100964f, 0.02692241f, 0.03139861f, 0.01480508f, -0.03610722f, -0.31389728f, 
    -0.05037091f, 0.05446735f, -0.05090839f, -0.13525392f, 0.04448175f, -0.12326813f, 0.05205903f, 0.00670769f, 
    0.12160884f, -0.11880163f, 0.16634253f, -0.11689821f, 0.19642545f, -0.09601422f, 0.05869812f, -0.01774269f, 
    0.04964828f, 0.07292929f, 0.04220733f, 0.00767524f, 0.19520427f, 0.24841617f, 0.05584832f, 0.26216686f, 
    0.01854086f, 0.09282892f, 0.16715033f, 0.02084439f, -0.01398022f, -0.00843737f, 0.02270046f, -0.06592843f, 
    0.07554902f, 0.09538261f, -0.00053090f, 0.23510505f, -0.15001145f, 0.05085199f, 0.07715318f, -0.07337726f, 
    0.00399807f, -0.04031864f, 0.01293050f, -0.05768067f, 0.05426442f, 0.02824713f, 0.18169498f, 0.12554641f, 
    0.02566908f, 0.03689102f, -0.06740571f, 0.01242209f, -0.07051418f, 0.01684006f, -0.03277856f, 0.11736804f, 
    -0.07958803f, 0.29941162f, 0.18445332f, 0.05085669f, -0.00637621f, -0.10822343f, 0.02720659f, 0.01182247f, 
    0.07231724f, 0.01960263f, 0.07861863f, 0.02444975f, 0.14782760f, -0.23997650f, 0.00226159f, -0.16927096f, 
    0.01999015f, 0.01287267f, -0.09852074f, 0.03028780f, 0.11710828f, 0.06429721f, 0.07511275f, -0.04801436f, 
    -0.10745397f, -0.15189855f, -0.04815794f, -0.22927998f, -0.00243356f, -0.06922306f, 0.04629759f, 0.07379983f, 
    0.13626452f, 0.04868913f, 0.07977807f, -0.00567907f, 0.03317508f, 0.13465337f, -0.14653727f, 0.04964665f, 
    0.14766102f, 0.04673116f, -0.09084816f, 0.00855788f, -0.05140375f, -0.03501078f, 0.08521138f, 0.08531049f, 
    -0.05543695f, 0.02251047f, 0.18479113f, -0.01377163f, 0.03352591f, 0.02014330f, -0.02358660f, 0.09638692f, 
    0.03770521f, 0.08307423f, 0.04606489f, 0.02312148f, -0.05067395f, -0.06234477f, 0.19232851f, 0.22068402f, 
    0.09612300f, 0.06465443f, 0.02100011f, 0.02194371f, -0.14086224f, 0.00355414f, 0.07160269f, -0.00238475f, 
    -0.19828708f, -0.10770776f, -0.08769552f, -0.15287070f, -0.06749708f, -0.01847795f, 0.02029323f, -0.00260878f, 
    0.08102629f, 0.10966107f, 0.01575838f, -0.05048315f, 0.21760228f, 0.31455037f, 0.08232147f, 0.01083238f, 
    -0.02272107f, 0.02141989f, 0.08895100f, -0.07886182f, -0.02409861f, -0.07941859f, -0.00749766f, 0.09763023f, 
    0.23141645f, 0.10630657f, 0.06966965f, 0.21189716f, 0.03567076f, -0.16178736f, -0.05570310f, 0.09689941f, 
    0.08847787f, 0.03220044f, 0.10918351f, 0.09482207f, 0.08624183f, -0.19591233f, 0.07341215f, 0.05730304f, 
    0.04221594f, 0.03123904f, 0.02051319f, -0.02360082f, -0.09318741f, -0.00320202f, 0.03925394f, -0.04865313f, 
    -0.07427747f, -0.18946442f, 0.10092043f, -0.23701927f, -0.11147794f, 0.03930160f, 0.05529837f, -0.02088705f, 
    0.01116146f, 0.05798870f, 0.04042767f, -0.09630477f, -0.45550904f, 0.11064856f, -0.12738229f, 0.19464111f, 
    0.02959826f, -0.00574759f, -0.13416488f, 0.10803656f, -0.03307654f, 0.08703497f, 0.02203824f, -0.12918302f, 
    -0.28432819f, 0.06237442f, -0.11791150f, -0.05762829f, -0.01589549f, 0.04388177f, -0.08282340f, 0.11488588f, 
    -0.07195858f, 0.02836183f, 0.14723475f, -0.12175081f, -0.23147322f, -0.10988019f, -0.08101020f, -0.27772319f, 
    0.05218147f, 0.03358690f, 0.03128371f, -0.02361403f, -0.00925456f, 0.08987205f, 0.05025351f, 0.08452099f, 
    -0.06662491f, 0.25454223f, 0.16355075f, -0.13053899f, 0.07522204f, -0.00275256f, 0.03305149f, 0.14922476f, 
    -0.09924629f, 0.03152441f, 0.01374981f, -0.04749569f, 0.30474192f, -0.29757634f, 0.10490540f, -0.07418720f, 
    0.00350235f, -0.03327069f, 0.10212073f, 0.03152828f, 0.11522242f, 0.02141232f, -0.06434005f, 0.11566675f, 
    -0.12951998f, 0.06041965f, -0.23864038f, -0.14512134f, 0.10550366f, 0.04815216f, -0.00813270f, 0.05882847f, 
    -0.06551042f, 0.04023338f, 0.09793147f, -0.00694994f, 0.06237556f, -0.31580275f, -0.14384976f, 0.11459583f, 
    0.07079522f, -0.04470561f, 0.09176382f, 0.04251777f, 0.13106933f, -0.05215853f, -0.02123970f, 0.17006238f, 
    0.55295748f, 0.24293578f, -0.09435380f, -0.01560225f, -0.02733672f, -0.08310334f, 0.00044649f, -0.02392901f, 
    0.14550993f, -0.12478235f, 0.19203223f, -0.06838732f, -0.04145543f, 0.00578700f, -0.02177890f, -0.17822629f, 
    0.02926792f, 0.26483825f, 0.04421408f, 0.01343402f, 0.04645142f, -0.02960485f, 0.04835904f, 0.12328917f, 
    0.12871987f, 0.05855757f, -0.12931414f, 0.16350338f, 0.03563859f, 0.00195588f, -0.07032936f, 0.06711379f, 
    -0.03029101f, 0.10392023f, -0.00633790f, 0.00531048f, 0.21151708f, 0.22333798f, -0.05367667f, 0.14662820f, 
    0.01778781f, -0.00805015f, 0.09043151f, -0.05862933f, 0.01626205f, -0.06720968f, -0.02113625f, -0.02573975f, 
    0.02438864f, -0.02989109f, 0.05750041f, -0.02524437f, -0.00644897f, -0.12106425f, -0.03947457f, -0.05794340f, 
    -0.17162311f, 0.05830310f, 0.15671451f, 0.08285519f, -0.16181943f, 0.08753340f, -0.02433649f, -0.08239989f, 
    -0.13360801f, 0.18312818f, -0.00978187f, -0.00238431f, 0.05154498f, -0.00282405f, -0.03423214f, -0.08701573f, 
    -0.22234587f, -0.12047657f, -0.11039376f, -0.17665191f, -0.02292181f, 0.14256416f, 0.06581452f, 0.06055114f, 
    0.12644660f, 0.12229194f, -0.00212111f, -0.07849857f, 0.28012326f, 0.24644025f, 0.01363649f, 0.16385286f, 
    -0.07897174f, 0.01846432f, -0.09861126f, 0.04109675f, 0.06134861f, -0.00358279f, 0.00137964f, 0.03954514f, 
    -0.09843051f, 0.13548531f, 0.12460580f, -0.18797287f, 0.04208831f, 0.08614437f, -0.14391941f, 0.08073463f, 
    0.00493297f, 0.05109276f, 0.05358769f, 0.05274584f, 0.05885530f, 0.05187656f, 0.16419040f, 0.23613401f, 
    0.03834464f, -0.01388981f, -0.08098318f, -0.04730820f, -0.00103099f, -0.07725516f, 0.03952369f, -0.05163338f, 
    0.01503857f, -0.03697821f, -0.13605176f, -0.02010561f, 0.00374715f, -0.04437389f, 0.09192129f, -0.02320109f, 
    0.03196274f, -0.05782654f, 0.12504405f, 0.11295224f, -0.17626673f, -0.13858816f, -0.18689241f, -0.03860902f, 
    -0.05240859f, -0.03444887f, 0.03350274f, -0.04652382f, 0.06795298f, 0.08561485f, -0.08571665f, 0.16082017f, 
    0.01332407f, -0.11760887f, -0.05288041f, -0.15515594f, 0.15024655f, 0.13026451f, -0.05048696f, -0.04972741f, 
    0.00931605f, -0.01977569f, 0.05527547f, 0.00588945f, 0.02442755f, 0.02095697f, 0.06942448f, -0.07206353f, 
    0.02141411f, -0.10896777f, -0.20767342f, 0.16551709f, 0.06115688f, 0.22036952f, -0.09833658f, 0.01854376f, 
    -0.24755865f, -0.22827110f, -0.00973589f, -0.07834860f, 0.01840713f, 0.16371351f, -0.04455172f, 0.12089407f, 
    0.08069571f, -0.08019363f, 0.03842033f, 0.12753679f, 0.30411637f, -0.05674220f, 0.02296309f, 0.24819084f, 
    -0.00925726f, -0.09457301f, 0.00929330f, -0.10360824f, 0.03486675f, -0.13672340f, 0.01485374f, 0.12833631f, 
    0.04109193f, 0.08422461f, -0.05387149f, 0.20723502f, -0.07969765f, -0.09757477f, -0.07864848f, -0.02261390f, 
    -0.07124444f, 0.09940423f, -0.06179039f, 0.00510956f, -0.25557810f, -0.05144474f, 0.20103280f, -0.17044467f, 
    0.00914473f, -0.06890716f, 0.09707388f, 0.09476800f, 0.02166369f, 0.00347560f, -0.02188187f, -0.03698012f, 
    0.03818848f, -0.10822205f, -0.04880687f, -0.04921387f, -0.06268018f, 0.06268784f, -0.07047152f, 0.01038890f, 
    0.15390764f, 0.04078621f, 0.12716995f, 0.17445907f, -0.17663881f, 0.10721753f, -0.05033797f, -0.02651061f, 
    0.02269008f, -0.11933945f, 0.15887110f, 0.00706458f, 0.06164865f, -0.11431779f, 0.06211235f, 0.15628454f, 
    -0.00095664f, 0.13699250f, 0.01742606f, -0.05856235f, 0.03791182f, -0.04149881f, -0.01933176f, 0.07299607f, 
    0.03485547f, 0.05302598f, 0.04533875f, 0.00887323f, -0.11879373f, -0.03904859f, -0.01596730f, 0.01535599f, 
    -0.00657474f, -0.04917122f, 0.01120623f, 0.05184842f, -0.08685139f, -0.02042696f, 0.21539916f, 0.07251785f, 
    -0.15199482f, -0.10221811f, -0.15575792f, 0.03953192f, -0.00385996f, -0.05528862f, -0.19468175f, 0.07313260f, 
    0.04996969f, -0.07111403f, 0.08122461f, -0.00036786f, 0.19578847f, -0.10738256f, 0.00564053f, 0.09670220f, 
    -0.10962195f, 0.07468389f, -0.02892925f, -0.11190120f, 0.08806942f, 0.03173089f, 0.18934537f, -0.01044212f, 
    0.16668944f, 0.17093702f, 0.02525745f, 0.20154719f, 0.01770780f, 0.03090750f, -0.01553981f, -0.06122081f, 
    0.09972320f, 0.10465867f, 0.03105509f, 0.05244606f, -0.05308006f, -0.03706181f, -0.19168906f, -0.04320156f, 
    -0.02570063f, 0.03135244f, -0.01136267f, -0.10643447f, 0.06699632f, 0.02405225f, -0.04336631f, 0.08113404f, 
    0.26597950f, -0.12943111f, 0.01971514f, 0.12288317f, 0.05607104f, 0.10844767f, -0.00978509f, -0.02654297f, 
    0.01837285f, 0.02855164f, 0.12430467f, -0.04532068f, 0.07099178f, 0.05384718f, 0.20616089f, 0.11545866f, 
    0.13404341f, 0.02999394f, 0.05107792f, -0.08974233f, -0.04932307f, -0.11515635f, -0.05319748f, 0.09737960f, 
    -0.09390045f, -0.10731021f, 0.00382461f, 0.04351879f, 0.04952907f, -0.08749680f, -0.08173923f, -0.11986491f, 
    0.23408027f, 0.02035520f, 0.00046841f, 0.15282713f, 0.21599768f, -0.01671672f, 0.01147810f, 0.17816649f, 
    -0.02704452f, 0.05127041f, 0.06214400f, -0.08755347f, -0.15032405f, 0.19060397f, 0.00381830f, -0.09328231f, 
    -0.00913548f, 0.02373450f, 0.22553003f, 0.04947013f, 0.01718573f, -0.03748815f, 0.00058484f, -0.05799310f, 
    -0.05444313f, 0.04519758f, -0.00988831f, 0.08989586f, 0.11855287f, 0.00600871f, -0.04738354f, -0.02192502f, 
    0.20756753f, 0.00923297f, -0.05252879f, -0.05648757f, 0.07013107f, 0.11845192f, 0.06216927f, 0.22206049f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.03354340f, 0.00338279f, -0.01426267f, -0.04836909f, -0.05353025f, 0.00645150f, -0.06747055f, 0.03719018f, 
    0.02018180f, -0.00391522f, -0.02895192f, -0.06518491f, 0.02290826f, 0.04121237f, 0.06360658f, -0.05539790f, 
    0.02979400f, 0.02483227f, 0.02667379f, 0.02049695f, 0.04380733f, -0.00160852f, -0.01778386f, -0.04713958f, 
    -0.01883195f, 0.00755791f, 0.01224728f, 0.01465296f, 0.01546436f, 0.04773560f, -0.05305960f, -0.05083014f, 
    -0.00219766f, 0.06329234f, 0.03782420f, -0.01676379f, 0.03458562f, 0.02149829f, -0.05155599f, -0.03983598f, 
    0.04095635f, -0.04072018f, -0.02163825f, 0.06492331f, 0.02505193f, -0.03061726f, 0.11261827f, -0.00740309f, 
    -0.02675293f, -0.03125050f, 0.07141625f, -0.03438186f, -0.05024698f, -0.05411174f, 0.00810512f, 0.08078108f, 
    -0.00989175f, -0.04159835f, 0.01793282f, 0.02339876f, 0.01641169f, 0.08669395f, 0.07062268f, 0.04284356f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.02693939f, 0.21222682f, 0.28988689f, -0.06901004f, -0.10721625f, -0.11588266f, -0.24539112f, -0.37737280f, 
    -0.03276853f, -0.11082789f, 0.12042474f, 0.03573995f, -0.13415226f, 0.00841954f, -0.16073273f, 0.11534577f, 
    -0.13442469f, -0.08822943f, -0.17718822f, -0.47660527f, -0.36249384f, 0.21213417f, 0.01026040f, 0.07686019f, 
    0.16184045f, 0.24349919f, -0.11276286f, 0.29881251f, 0.02597134f, -0.03626777f, 0.00648987f, -0.06926154f, 
    -0.09851452f, 0.32372397f, -0.05308941f, -0.07741439f, 0.20605387f, 0.00741860f, -0.02623178f, 0.00950777f, 
    0.01461646f, -0.03979782f, 0.03579595f, 0.34225702f, 0.07290567f, 0.18530942f, -0.34739819f, 0.27421510f, 
    0.06077627f, 0.09780274f, -0.30544755f, 0.02403696f, -0.01564285f, 0.11060507f, -0.11250161f, -0.20554660f, 
    -0.00321705f, -0.10651662f, 0.04065668f, -0.12051947f, -0.07103024f, -0.31523496f, -0.66490930f, -0.04572033f, 
    -0.00611067f, -0.06999157f, -0.39358222f, -0.03512185f, 0.00058409f, -0.00073942f, -0.45179069f, -0.08009603f, 
    0.07600528f, 0.01030516f, -0.00499034f, 0.00921339f, 0.35414135f, -0.01403156f, 0.16203971f, 0.03441517f, 
    0.11280610f, -0.43617851f, 0.05729491f, -0.42570788f, -0.30423760f, 0.13376081f, 0.09056100f, 0.03517031f, 
    -0.07596929f, 0.01191855f, 0.05998653f, -0.32711068f, 0.02090694f, 0.15542392f, -0.04420356f, -0.04830702f, 
    -0.00182369f, -0.01091796f, 0.02677769f, 0.05120781f, 0.05165479f, 0.07467020f, -0.07681245f, 0.09869158f, 
    0.26410344f, -0.07783228f, -0.01486883f, -0.58229089f, -0.04660919f, 0.24046725f, 0.23788562f, -0.24160883f, 
    0.11605193f, -0.11436117f, 0.08377974f, -0.12458172f, -0.09700422f, 0.06689347f, 0.10256056f, 0.03702870f, 
    -0.08229955f, 0.04612994f, 0.11029776f, 0.06976793f, -0.00790664f, -0.29556146f, -0.06862211f, 0.16999567f, 
    0.01190301f, 0.09119716f, -0.39476043f, -0.04566145f, -0.08043258f, 0.00007669f, 0.31357327f, -0.09843402f, 
    0.03354097f, 0.02789403f, -0.09011129f, 0.35000601f, 0.17492984f, -0.12824556f, -0.55462861f, 0.00868602f, 
    -0.01158745f, 0.42166343f, 0.20384902f, -0.19664125f, -0.44904426f, 0.17817257f, -0.09080246f, 0.10351670f, 
    -0.34473482f, 0.00748982f, -0.02002825f, 0.38087985f, -0.04319692f, -0.42273313f, 0.07673254f, -0.03007302f, 
    0.22436266f, -0.05715112f, 0.12935662f, 0.01668212f, -0.43403313f, 0.06255033f, -0.08083136f, 0.01552630f, 
    -0.04024255f, -0.03906154f, -0.00799262f, -0.06397831f, -0.07056280f, -0.15383232f, 0.01903763f, -0.26803434f, 
    -0.05614891f, -0.02954104f, 0.13601293f, 0.00825351f, -0.10159093f, -0.04317978f, -0.22611552f, -0.18658730f, 
    -0.00409046f, 0.03129713f, -0.35656801f, 0.02114262f, -0.09488257f, -0.14038983f, -0.22315918f, -0.10851456f, 
    -0.05960093f, -0.25648257f, 0.27748722f, -0.12793897f, -0.02034779f, -0.08816656f, -0.12564804f, -0.49891409f, 
    0.08713583f, -0.06270657f, -0.08825770f, 0.00465098f, -0.21340246f, 0.00575445f, 0.43383652f, -0.01321851f, 
    -0.00569250f, 0.36434194f, -0.18932252f, 0.28318739f, 0.18278271f, -0.22332679f, 0.06570345f, -0.05798961f, 
    0.13553311f, -0.29032290f, 0.03066912f, 0.15538827f, -0.23845476f, 0.12641165f, -0.03305922f, -0.04725745f, 
    0.18248953f, 0.33992398f, -0.03059095f, -0.03062966f, -0.13483892f, -0.05640131f, -0.04332203f, -0.08582664f, 
    -0.07277197f, -0.03762551f, -0.04433317f, -0.26023600f, -0.02263214f, -0.06263306f, 0.07603127f, 0.11921300f, 
    -0.08811739f, -0.06694512f, 0.20211521f, -0.11034729f, 0.09826127f, 0.08986455f, -0.55185956f, -0.27046472f, 
    -0.09602506f, 0.04568747f, 0.22271289f, 0.12644467f, 0.09220743f, -0.35379571f, 0.01230514f, -0.22624932f, 
    0.11094136f, 0.04121478f, 0.28215450f, -0.07005854f, -0.01124431f, 0.03020282f, 0.17887370f, 0.35363066f, 
    0.03473847f, 0.07862268f, 0.02792127f, -0.17130731f, 0.07304578f, -0.10722387f, -0.00506730f, -0.09265753f, 
    -0.08190613f, -0.25721768f, 0.15768708f, 0.26140812f, -0.31887841f, 0.06350669f, -0.00741833f, -0.03331927f, 
    0.35279563f, -0.26150590f, -0.11220041f, -0.26340026f, 0.10792811f, 0.24106792f, 0.07333221f, -0.08621002f, 
    -0.18878746f, -0.20539029f, -0.28244609f, 0.06163058f, 0.08851990f, 0.08127902f, -0.11837143f, -0.07706410f, 
    -0.34249327f, 0.02670983f, 0.08921949f, 0.10544176f, 0.01367566f, -0.34845161f, 0.01781161f, 0.27417794f, 
    -0.07466686f, 0.02485495f, 0.17602393f, 0.06877919f, -0.04733746f, 0.10506472f, 0.04453513f, -0.31443277f, 
    0.07730947f, 0.09965993f, 0.18017735f, 0.11224543f, -0.03425407f, -0.22476768f, -0.15095548f, -0.11051802f, 
    -0.00458098f, -0.18858486f, 0.01751748f, 0.06030835f, -0.00977828f, 0.02358586f, -0.17655407f, 0.36249447f, 
    0.03984596f, 0.08206858f, 0.05550698f, -0.56292939f, 0.25254786f, -0.08716744f, 0.33948418f, -0.07156085f, 
    0.09712874f, 0.30230755f, -0.12100119f, -0.07668942f, 0.29668441f, -0.02120300f, 0.11712136f, 0.11637070f, 
    0.29413530f, 0.19525583f, -0.08659114f, -0.55615544f, -0.04218727f, -0.44907758f, 0.09124575f, -0.00291257f, 
    -0.34750673f, 0.00471002f, -0.24134892f, -0.01736828f, 0.13577648f, -0.02909885f, -0.06209926f, -0.08893155f, 
    0.14714846f, -0.10956549f, 0.04598926f, 0.02732101f, 0.06529339f, -0.01321105f, -0.33207616f, 0.03191632f, 
    0.09061585f, 0.04521528f, -0.05902091f, 0.05947877f, -0.07284638f, -0.04791756f, 0.25538853f, 0.19301160f, 
    -0.00519919f, 0.01474673f, 0.21833698f, -0.03137651f, -0.08989277f, 0.18496597f, -0.21542935f, 0.02078762f, 
    0.08203761f, 0.00974142f, -0.12074798f, -0.06038975f, 0.02741297f, 0.06615721f, 0.17745769f, 0.04434961f, 
    0.07988473f, 0.01638698f, 0.10056914f, -0.28272140f, -0.42433968f, 0.02457239f, -0.25242203f, 0.01666473f, 
    0.10203671f, -0.32177663f, 0.20166297f, -0.08706286f, 0.13720201f, -0.01048763f, 0.00213109f, 0.03314291f, 
    -0.41157907f, -0.38569638f, -0.03258251f, 0.27035099f, 0.15378697f, 0.17573486f, 0.04065302f, -0.05946912f, 
    -0.03596005f, 0.14370881f, -0.16712554f, 0.07015774f, 0.29793921f, -0.09700266f, -0.11387917f, 0.07364180f, 
    0.20211670f, 0.01829696f, 0.05904052f, 0.03030022f, 0.02034121f, -0.01031206f, -0.67236048f, -0.53489882f, 
    -0.02688951f, -0.10299762f, 0.27355644f, 0.09326546f, -0.06728382f, 0.04073610f, -0.37791410f, 0.28227249f, 
    0.09838127f, -0.07301522f, 0.14121902f, -0.06678501f, -0.02356509f, -0.05781593f, 0.11521560f, -0.00689436f, 
    0.04887328f, -0.31324580f, 0.02288631f, 0.01914945f, -0.08788592f, -0.06067701f, 0.31997490f, 0.27766508f, 
    -0.05589603f, 0.05146196f, 0.03135232f, 0.26895881f, -0.04821121f, 0.05286978f, -0.28844893f, 0.11558261f, 
    0.06386378f, 0.25311467f, -0.34113154f, -0.08720393f, 0.28564492f, -0.10312103f, 0.06156826f, 0.04979006f, 
    0.06218325f, -0.17286056f, -0.11275905f, 0.10699324f, -0.00419276f, 0.20742434f, 0.04826383f, 0.09757534f, 
    -0.09874295f, -0.17673323f, -0.38450056f, -0.04596456f, 0.13736382f, 0.08103792f, 0.00832317f, 0.06593218f, 
    -0.19583243f, -0.03478265f, -0.08082175f, 0.02958282f, 0.10716147f, 0.25055748f, 0.14639974f, 0.14234805f, 
    -0.11419437f, 0.01265546f, -0.43481785f, -0.03631198f, -0.03764806f, 0.09776282f, 0.23219025f, -0.02435749f, 
    0.02902169f, -0.13085823f, 0.05437320f, -0.07868791f, 0.07403423f, -0.24637087f, 0.30355161f, -0.18937887f, 
    -0.01430653f, -0.20378576f, 0.17196202f, -0.04176202f, -0.01840452f, 0.08152550f, 0.27608180f, -0.07614744f, 
    -0.04059339f, 0.08707204f, 0.05819857f, -0.24491353f, -0.15219593f, -0.07349045f, -0.00052520f, 0.04272117f, 
    0.06861924f, -0.31630480f, -0.00371065f, 0.07474949f, 0.17706037f, -0.01686012f, -0.03235151f, 0.10868046f, 
    0.05414514f, 0.09787270f, -0.11627277f, -0.14252424f, -0.18471520f, -0.08229775f, -0.11940941f, 0.01246299f, 
    0.19649740f, -0.48128122f, 0.21884224f, -0.00192039f, -0.42581418f, 0.10914962f, -0.08898459f, 0.02766433f, 
    0.25215262f, -0.07347170f, -0.05570365f, -0.55227441f, 0.02711898f, 0.23143978f, -0.21964395f, -0.41103002f, 
    0.07974213f, -0.00097230f, -0.26595062f, -0.06807303f, 0.01018749f, 0.03307841f, 0.26734254f, -0.42847419f, 
    0.03244661f, 0.10589191f, 0.08131006f, 0.01438959f, -0.10811682f, -0.29302707f, 0.01436227f, 0.29418340f, 
    -0.04055388f, 0.11275870f, -0.07729149f, 0.00877742f, -0.05893958f, -0.11250421f, 0.00178919f, 0.01353718f, 
    -0.09787868f, -0.05638574f, -0.01899441f, 0.07725694f, -0.05681462f, 0.02854112f, -0.37945342f, -0.01365163f, 
    -0.04097230f, -0.31494921f, -0.21977268f, -0.03109514f, 0.05646423f, -0.02481155f, -0.00570155f, -0.03983803f, 
    0.07187740f, 0.37834302f, -0.01953514f, 0.33583379f, 0.35011446f, 0.16251422f, -0.01496558f, 0.03632629f, 
    0.34170738f, -0.44843256f, -0.36538371f, -0.07447226f, -0.29196221f, 0.07086863f, 0.09929087f, -0.11902303f, 
    -0.18567103f, -0.05475997f, -0.10245032f, 0.14220057f, -0.01975263f, -0.54346800f, 0.04407962f, -0.20490274f, 
    0.02804900f, -0.10641915f, 0.02431425f, -0.05268813f, 0.06615186f, -0.00743242f, -0.11875257f, 0.29471108f, 
    0.01209375f, -0.08356044f, -0.10921413f, 0.07438095f, 0.07468051f, 0.31062433f, -0.25815335f, 0.13204920f, 
    0.07823835f, 0.20067492f, -0.08358670f, -0.09326827f, -0.06204583f, 0.02506720f, 0.03695948f, -0.28510886f, 
    0.10983540f, -0.08494800f, 0.09221851f, -0.26131195f, -0.19173551f, -0.06537422f, -0.08424574f, -0.12757583f, 
    -0.07621749f, 0.02670305f, -0.10838325f, -0.00913611f, 0.19288383f, 0.00192112f, -0.08978023f, -0.08610201f, 
    -0.43129933f, -0.45085534f, -0.03949406f, -0.52562016f, -0.04184480f, -0.32757244f, -0.02689437f, -0.09064244f, 
    0.04519207f, 0.20328279f, 0.17585245f, 0.06359700f, 0.15137264f, 0.08190747f, -0.08918255f, -0.10668702f, 
    -0.12517920f, -0.09787517f, -0.08089443f, -0.31806257f, 0.03083395f, -0.01266883f, 0.34214148f, 0.15873651f, 
    -0.04402095f, -0.04659614f, 0.02657580f, -0.10727002f, 0.05933135f, -0.08284225f, 0.01857860f, 0.17244585f, 
    -0.03529020f, 0.05888437f, -0.60968614f, 0.07876351f, -0.12094873f, 0.27240807f, 0.29768521f, -0.11298048f, 
    0.00033996f, -0.23877251f, -0.08577804f, -0.05356531f, -0.02001551f, 0.06710844f, 0.14430790f, -0.08855232f, 
    -0.02427656f, 0.11067302f, 0.04254952f, 0.05390815f, -0.20240445f, -0.05180035f, 0.04024805f, -0.12144279f, 
    -0.00657740f, -0.27196360f, 0.18913530f, -0.04848458f, -0.06122839f, -0.36836779f, 0.10248871f, 0.10995267f, 
    -0.06687708f, 0.15278929f, -0.10823815f, 0.20538695f, -0.58159935f, 0.26054484f, 0.04739271f, 0.02618032f, 
    -0.02069798f, -0.11389029f, 0.27156410f, 0.00653823f, -0.18711354f, 0.10843465f, 0.02523755f, 0.05318774f, 
    -0.14348023f, -0.03149685f, -0.08555559f, 0.33843291f, 0.07176384f, -0.12776238f, -0.04926690f, 0.11036544f, 
    0.10317462f, -0.08396226f, 0.15001030f, -0.03088512f, -0.07067215f, -0.04046073f, 0.28557169f, 0.15744834f, 
    0.04645434f, -0.06777734f, 0.14082761f, -0.10102355f, -0.12050714f, 0.21901235f, 0.11265930f, -0.26840290f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.04892394f, 0.15816361f, -0.11823482f, 0.07174311f, 0.15926972f, 0.01434355f, -0.12276705f, -0.08809561f, 
    -0.04936146f, -0.09379250f, 0.04374791f, 0.10394226f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
