#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.34417841f, -0.42129353f, -0.39524865f, -0.01519716f, -0.34104422f, 0.08962902f, 0.58554798f, -0.18283847f, 
    0.00269062f, 0.09261377f, -0.38922721f, -0.24039136f, -0.36802807f, 0.11001286f, 0.22439446f, -0.52015591f, 
    -0.00761722f, -0.22005144f, 0.15084384f, -0.18666366f, 0.03003203f, 0.02512916f, -0.26548108f, -0.21103662f, 
    0.13917144f, 0.47169730f, 0.19169706f, 0.63002735f, 0.88447696f, 0.02136080f, 0.03943358f, 0.27829039f, 
    0.38732317f, 0.25114182f, -0.04184828f, -0.43089804f, -0.14705187f, -0.07336048f, -0.10695511f, -0.08694690f, 
    -0.35796741f, -0.05840209f, -0.31358770f, 0.21354467f, -0.11852735f, 0.09613120f, -0.16526534f, 0.01584269f, 
    -0.07335319f, -0.20639935f, -0.38309997f, -0.74075276f, -0.76519758f, -0.15202709f, -0.31196570f, -0.11784121f, 
    -0.10844366f, -0.16631728f, 0.27017602f, 0.40693274f, 0.29178280f, 0.03654256f, -0.21240750f, -0.06364816f, 
    -0.22348456f, 0.02522362f, 0.25739750f, 0.14771521f, -0.16110937f, 0.14049645f, 0.02159512f, 0.05133934f, 
    0.15198627f, 0.26103151f, 0.14678681f, 0.28804827f, 0.25767851f, 0.46158710f, 0.15481146f, 0.69806796f, 
    0.53629178f, 0.30053994f, -0.44328836f, 0.12552746f, -0.10939963f, -0.14166893f, 0.41999587f, -0.04235862f, 
    0.20726249f, 0.26965588f, -0.13089679f, -0.12343434f, -0.22400433f, -0.19200709f, 0.24653859f, -0.17927556f, 
    -0.14596006f, -0.07151342f, 0.03419517f, -0.16716813f, -0.09703271f, 0.84915745f, 0.23883395f, 0.14644109f, 
    0.34935021f, -0.53387481f, 0.45767111f, -0.19728352f, 0.02840284f, -0.03564583f, 0.22029999f, -0.10647415f, 
    -0.02258028f, 0.04783527f, 0.27794766f, 0.18224299f, 0.26084033f, 0.25518692f, 0.13202889f, -0.02627408f, 
    0.00730160f, -0.05340260f, 0.21382348f, 0.17909430f, 0.23982857f, -0.26726320f, 0.79539734f, -0.05542823f, 
    -0.60792881f, -0.38352510f, -0.12591054f, -0.22906764f, -0.58418083f, -0.63901693f, -0.16444843f, -0.12917271f, 
    0.29550120f, 0.24976949f, -0.02041070f, 0.07178900f, -0.05752661f, 0.01370341f, 0.18047610f, 0.15731798f, 
    0.16152577f, 0.29681763f, 0.03053484f, 0.21077432f, -0.19799232f, 0.00591331f, -0.27155143f, -0.21825083f, 
    -0.23264726f, -0.06125186f, -0.33929852f, 0.10848029f, -0.25376114f, -0.21838711f, 0.39286920f, -0.32200426f, 
    0.23781887f, 0.27876344f, 0.29942188f, 0.16114321f, -0.45575207f, -0.34021604f, -0.19460841f, -0.16920936f, 
    -0.12943612f, -0.37944001f, -0.10057589f, 0.16094938f, -0.07487834f, -0.03095631f, 0.16298400f, -0.77036220f, 
    0.02103896f, 0.51471603f, -0.33923191f, -0.24106029f, 0.19820511f, -0.11375780f, -0.23950653f, 0.10854976f, 
    -0.01730098f, 0.05819041f, 0.06399941f, -0.27627057f, -0.27789664f, -0.22538017f, 0.01626398f, 0.17933567f, 
    0.17448819f, 0.15608288f, -0.38122988f, -0.06105210f, -0.20744595f, -0.01726773f, -0.02792828f, 0.06204053f, 
    0.78174466f, -0.32787809f, -0.89063460f, -0.40515634f, 0.44201949f, 0.26356727f, 0.26472950f, 0.20507941f, 
    0.42759973f, 0.40510428f, -0.56221008f, 0.06127618f, 0.02925097f, 0.07727314f, -0.15427935f, -0.10143942f, 
    -0.07649985f, 0.02478481f, 0.00171598f, -0.18893503f, -0.09324037f, 0.08403210f, -0.04026587f, 0.20496982f, 
    0.02077537f, -0.58009624f, -0.88669688f, -0.57669204f, 0.21383496f, 0.09796238f, -0.78394610f, 0.44871736f, 
    0.43080503f, -0.31119880f, 0.01706734f, 0.01520617f, -0.04701712f, 0.25290036f, 0.18502162f, 0.10194047f, 
    0.05308154f, 0.05483269f, -0.00237712f, -0.02673179f, 0.01651485f, -0.03279466f, -0.04814146f, -0.13428906f, 
    0.15640011f, 0.12138596f, 0.07940091f, 0.35966682f, -0.59935009f, -0.57980210f, -0.08155598f, 0.55614120f, 
    -0.30881980f, -0.22353709f, -0.29741830f, -0.27929705f, 0.02600795f, -0.20843908f, 0.39297804f, 0.25821438f, 
    -0.20665136f, -0.15649782f, 0.13173315f, -0.08266149f, -0.19353484f, 0.03574548f, -0.03759348f, -0.08273210f, 
    0.22595231f, -0.04588581f, -0.02902842f, 0.20217527f, -0.11149132f, -0.38172325f, -0.27297238f, -0.48685852f, 
    0.62510014f, 0.81916881f, 0.00799359f, 0.48594216f, 0.18666187f, 0.31010082f, 0.17475814f, -0.30114573f, 
    0.19890952f, 0.01921182f, 0.08780679f, -0.01361505f, 0.13965793f, 0.15385987f, -0.02435856f, -0.11199615f, 
    0.02054467f, 0.01445883f, -0.17282622f, -0.07338638f, 0.86725169f, 0.82485551f, -0.00158287f, -0.36932105f, 
    -0.40552238f, -0.21121886f, -0.28828004f, -0.19971493f, -0.13658255f, -0.09143338f, 0.07870574f, -0.06987214f, 
    -0.38837454f, 0.17166132f, -0.02894907f, -0.12517726f, -0.17107357f, -0.32920977f, 0.11301164f, -0.24568057f, 
    0.03971816f, 0.09135026f, -0.02468615f, -0.19246581f, 0.14436661f, 1.07423627f, 0.46837237f, 0.26624325f, 
    0.60301590f, 0.05058276f, -0.36615956f, -0.08220559f, -0.35890526f, 0.01046309f, -0.16272585f, 0.02468723f, 
    0.13400958f, 0.10496072f, 0.11189899f, -0.06118750f, -0.10697957f, -0.03892499f, 0.31260008f, -0.14408673f, 
    0.05446374f, 0.00168699f, 0.31986773f, 0.04087410f, 0.05700152f, 0.06425354f, -0.33692256f, -0.28701699f, 
    -0.50052762f, -0.43928084f, -0.20113592f, 0.03662474f, -0.54719508f, -0.10099439f, 0.31059262f, -0.12856609f, 
    -0.46873045f, -0.09431247f, 0.05727307f, 0.06562123f, -0.16133668f, 0.37251878f, 0.06514480f, 0.11234139f, 
    0.14307599f, -0.06778131f, -0.27125987f, -0.07541694f, 0.14024688f, -0.27578521f, -0.18905397f, 0.79924083f, 
    0.39569867f, 0.34461242f, -0.29813761f, -0.23008358f, 0.27749071f, 0.41659439f, 0.12428076f, 0.05551853f, 
    0.40504652f, 0.17669387f, 0.33302048f, 0.06233869f, -0.03415199f, -0.21898615f, 0.23458074f, 0.08087366f, 
    0.07977676f, -0.07694035f, 0.04690777f, 0.13527171f, -0.15269551f, 0.08389867f, -0.13431978f, -0.22714493f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.22736539f, 0.25068223f, 0.17687950f, 0.03258419f, 0.07145950f, 0.21989067f, 0.20142984f, -0.00204752f, 
    0.17153895f, -0.07018773f, 0.20666167f, 0.01225120f, 0.21451116f, 0.17591214f, 0.01146885f, 0.25644553f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.15764287f, -0.02272723f, 0.06945504f, -0.13534631f, 0.15296149f, 0.07030866f, 0.00002555f, 0.06650504f, 
    0.18069774f, 0.05689127f, 0.02258882f, 0.14354105f, 0.04727628f, 0.11254161f, -0.09912598f, 0.39942086f, 
    -0.03718645f, 0.01519420f, -0.00454223f, -0.12070071f, 0.04766308f, -0.03675884f, 0.06961797f, 0.11536448f, 
    0.07923264f, -0.10666763f, -0.24543157f, -0.11499278f, -0.05758951f, -0.12180538f, 0.05377120f, -0.07739343f, 
    0.02305260f, 0.09330145f, 0.00025645f, 0.03714095f, 0.25265601f, -0.15420121f, 0.17440714f, -0.01126963f, 
    -0.12354762f, -0.20584877f, 0.04422937f, -0.05990079f, 0.15234655f, -0.04954177f, 0.01633667f, 0.02788369f, 
    0.18866967f, 0.18033303f, -0.06205660f, -0.08285733f, 0.01124206f, -0.18959409f, -0.04025437f, 0.04244215f, 
    -0.10192142f, 0.03088429f, -0.02558247f, -0.12776403f, -0.35442409f, 0.28322813f, -0.01633920f, -0.20502770f, 
    0.00139542f, 0.11108714f, 0.09033071f, -0.00656603f, 0.09611680f, -0.12810773f, -0.06089369f, 0.18234360f, 
    -0.18043049f, -0.22598727f, -0.09904464f, -0.02692311f, -0.00531670f, -0.02643182f, -0.09601188f, 0.08981815f, 
    0.00524537f, 0.10684622f, -0.03110687f, -0.01601075f, 0.03307412f, -0.00148740f, 0.03947889f, 0.06015031f, 
    -0.12652567f, 0.00572073f, -0.01431335f, 0.02703530f, -0.05000636f, 0.14080147f, -0.13140361f, -0.03592418f, 
    0.28379351f, -0.21641995f, 0.12214919f, -0.26668584f, 0.10946975f, 0.06831611f, -0.00516218f, -0.05176568f, 
    -0.10325717f, 0.11614601f, -0.05544078f, 0.10296842f, 0.05553332f, 0.17900796f, -0.14927185f, 0.02954507f, 
    -0.05968993f, 0.02641466f, -0.00231594f, 0.04251002f, 0.11963762f, 0.07055037f, 0.17321725f, 0.00397619f, 
    0.18412723f, -0.18559572f, 0.12194134f, -0.22365484f, 0.05842810f, 0.03433460f, 0.05181222f, -0.13884987f, 
    -0.07655220f, -0.08890837f, -0.13912049f, 0.12126353f, 0.23900020f, -0.20539683f, -0.09346984f, -0.23960146f, 
    -0.05448326f, 0.03238820f, 0.15928823f, 0.11840858f, -0.01833789f, 0.08981622f, -0.07720763f, 0.04212339f, 
    0.09964100f, 0.19899577f, 0.00984895f, -0.20290340f, -0.02246040f, -0.06680130f, 0.06675029f, 0.04302339f, 
    -0.11577510f, -0.12015083f, 0.04643752f, 0.09509312f, 0.20109969f, 0.14110889f, 0.08974686f, 0.39102942f, 
    -0.16096880f, -0.02487160f, -0.19485433f, -0.00060706f, 0.06736358f, -0.02112138f, -0.07442866f, 0.07620604f, 
    0.07328028f, -0.08021182f, 0.05406740f, -0.17175898f, 0.08414540f, -0.06997376f, 0.12678848f, -0.01428941f, 
    0.04328355f, 0.00581286f, 0.01360475f, 0.06035772f, -0.09221350f, 0.07729540f, 0.06106992f, -0.17473908f, 
    0.02670289f, -0.12106858f, 0.01983220f, -0.05217066f, 0.08607386f, 0.01799344f, 0.13801304f, -0.06275322f, 
    0.31704184f, -0.05434619f, -0.01189833f, 0.05308914f, -0.00331879f, -0.01507157f, 0.07635672f, -0.01479921f, 
    -0.02805392f, -0.07336617f, 0.04826732f, -0.11114725f, -0.16619368f, -0.31295401f, -0.01943311f, -0.03314458f, 
    -0.06952022f, -0.10130556f, -0.12254514f, -0.02741221f, -0.11975793f, 0.06472015f, 0.13098098f, 0.02520801f, 
    0.22456720f, -0.04610395f, 0.13695742f, -0.20689908f, -0.06562439f, 0.03082518f, -0.00880267f, -0.12028236f, 
    0.02986585f, -0.08525940f, -0.09691893f, 0.04173478f, 0.09873404f, -0.36109820f, 0.09843677f, 0.16874002f, 
    -0.04343065f, -0.01532456f, -0.05345514f, -0.14682640f, 0.20328815f, 0.05466715f, -0.06520139f, -0.01760557f, 
    0.11904185f, 0.11449891f, -0.33254567f, 0.02861163f, 0.00265968f, 0.06683235f, -0.02768868f, -0.00678389f, 
    0.00362908f, -0.06945454f, 0.12896886f, 0.15564212f, 0.21138495f, 0.28038135f, -0.06906893f, -0.10054964f, 
    0.09141950f, -0.07169779f, 0.03095028f, -0.04634200f, 0.07670242f, 0.04448642f, 0.12624215f, -0.13054216f, 
    0.08979699f, 0.03388151f, 0.08341007f, -0.08705045f, 0.10683908f, -0.00543208f, 0.02228067f, 0.09673537f, 
    0.04910881f, 0.09216511f, 0.18270351f, 0.04614542f, -0.14537507f, -0.08807540f, 0.01135043f, 0.07865857f, 
    -0.26428765f, 0.13317324f, 0.00935637f, -0.05901858f, 0.07896121f, -0.09108412f, 0.01589142f, 0.07233523f, 
    -0.16623917f, 0.25710198f, 0.00687279f, 0.15915175f, -0.13818988f, -0.10846113f, 0.15333733f, 0.06110045f, 
    0.09118877f, 0.04132527f, -0.15422440f, 0.01300597f, 0.16189101f, 0.13206547f, -0.01457548f, 0.06784113f, 
    0.08183562f, 0.01962277f, 0.08909497f, -0.08308744f, 0.09684508f, -0.00567106f, 0.01884801f, 0.07599507f, 
    0.12176769f, 0.04275436f, -0.02763759f, -0.05074240f, 0.11614791f, -0.01754660f, -0.13570027f, 0.02190391f, 
    0.22262254f, 0.04954102f, 0.04742525f, 0.09514594f, 0.39248157f, -0.05728064f, -0.02751282f, 0.09796726f, 
    -0.07007258f, -0.01279032f, 0.05634935f, 0.08934457f, -0.05834138f, -0.15529552f, 0.07803484f, -0.03761648f, 
    0.18783127f, 0.07237101f, -0.07240164f, 0.04915150f, 0.05322034f, -0.01383489f, 0.04052546f, -0.06233238f, 
    0.13309540f, 0.06010303f, -0.06468604f, 0.07085451f, -0.05818803f, -0.26821852f, -0.09792603f, -0.01261781f, 
    0.17267717f, 0.00882018f, 0.09013606f, -0.09056248f, -0.06253039f, 0.12509777f, 0.11939674f, -0.17963585f, 
    -0.10137717f, 0.03095712f, 0.01324190f, -0.07976877f, 0.06232345f, -0.11973151f, 0.01686247f, -0.13219726f, 
    -0.03296603f, -0.14163479f, 0.05640479f, -0.10289371f, 0.02041355f, 0.03769679f, -0.14561392f, -0.03372867f, 
    0.07268436f, 0.06149623f, 0.00279946f, -0.04109902f, -0.07713707f, 0.02989705f, -0.00333035f, 0.08426556f, 
    -0.45523965f, -0.15225698f, 0.13744955f, 0.01505319f, 0.03921784f, -0.07526312f, -0.13084015f, 0.07383932f, 
    -0.04214357f, -0.05460339f, -0.04491555f, 0.25526464f, -0.05615285f, 0.18129058f, -0.01130817f, 0.12071491f, 
    0.05182621f, 0.12448738f, 0.13265368f, 0.03966687f, -0.10512055f, 0.06701721f, -0.02254057f, -0.00597865f, 
    -0.07969157f, -0.25432786f, -0.03994865f, 0.06681371f, -0.06813487f, 0.10027737f, 0.01430457f, 0.17981087f, 
    -0.00746702f, 0.04718532f, -0.04866477f, -0.03871038f, -0.21793711f, 0.20095895f, -0.14340566f, -0.21554963f, 
    0.01378292f, 0.04397317f, 0.02062927f, 0.20636292f, 0.05153362f, -0.07245432f, 0.22378130f, 0.04013261f, 
    -0.06218600f, -0.10968380f, 0.20030624f, -0.02522561f, -0.21120769f, 0.03690661f, 0.01878989f, -0.08123311f, 
    -0.11214834f, -0.07843230f, -0.06962970f, -0.24791881f, -0.27102497f, -0.11468591f, 0.24576929f, 0.00889826f, 
    -0.08390614f, 0.13523838f, 0.08750355f, 0.06499272f, -0.00970159f, -0.08661409f, -0.09702630f, 0.12084924f, 
    -0.03623204f, 0.02311736f, -0.12985958f, 0.02652080f, 0.00591914f, 0.11298741f, 0.06547031f, -0.15141554f, 
    0.03664736f, 0.03148723f, -0.05386217f, 0.11519723f, 0.14137620f, 0.02567303f, 0.07280339f, -0.17266239f, 
    0.11969838f, -0.02288922f, -0.03829696f, 0.03882054f, 0.03329901f, 0.23700294f, 0.04344616f, 0.10483634f, 
    -0.00395766f, 0.19036295f, -0.07201941f, 0.04881526f, 0.14577194f, -0.10952850f, 0.02547644f, 0.02871033f, 
    -0.10411213f, 0.03955962f, 0.06530749f, -0.02191772f, -0.54507303f, 0.16395575f, -0.23540051f, 0.18873201f, 
    0.13547899f, -0.07584515f, -0.04208791f, 0.07458327f, -0.06004348f, 0.01633960f, -0.12188333f, -0.01608696f, 
    -0.01238653f, 0.02223833f, 0.03376224f, 0.05333417f, -0.00468644f, 0.02666378f, -0.05778287f, 0.04708372f, 
    0.02323708f, -0.01449989f, -0.03032368f, 0.06589694f, -0.31483614f, 0.18593855f, 0.26051518f, -0.07704274f, 
    0.02757151f, 0.13512774f, 0.05586588f, 0.07916064f, 0.08877935f, 0.03922391f, 0.07380006f, 0.06961533f, 
    0.13601439f, -0.00758069f, 0.29832476f, -0.07051758f, -0.12796314f, -0.01359637f, 0.04156329f, 0.01506916f, 
    0.03633197f, -0.01418289f, 0.05846030f, -0.12053825f, 0.03820986f, 0.25809860f, 0.02558473f, 0.02004682f, 
    -0.11336821f, 0.00425469f, 0.01701115f, 0.01066500f, 0.03344576f, 0.00328178f, -0.08826505f, 0.01428519f, 
    0.21500818f, -0.28209624f, -0.00756248f, 0.06378333f, -0.05101668f, 0.02733211f, -0.04423277f, 0.04479231f, 
    0.21494853f, 0.00044472f, -0.05020479f, 0.14873171f, -0.04141770f, -0.02006171f, -0.00503846f, 0.01739190f, 
    -0.07707224f, 0.13049074f, -0.04644071f, 0.08156808f, 0.04040813f, 0.12572049f, 0.04903639f, -0.12780412f, 
    0.06576713f, -0.03086423f, 0.00547271f, -0.02547139f, -0.02577491f, 0.05350434f, 0.03009723f, 0.00281392f, 
    0.02766228f, -0.06190566f, -0.06511461f, 0.02027368f, 0.03796465f, -0.02685303f, -0.03077221f, -0.05487495f, 
    0.03460793f, -0.06453276f, -0.00011386f, 0.02536078f, -0.02444302f, 0.01434949f, 0.02442752f, -0.05565691f, 
    -0.03205533f, 0.02303939f, -0.00878454f, 0.00321000f, -0.04127433f, -0.04596967f, 0.04895359f, -0.03436776f, 
    0.05648744f, -0.04365390f, -0.03126390f, -0.01223877f, -0.01670311f, -0.07731087f, 0.00200619f, 0.02811591f, 
    -0.04140329f, -0.01505595f, -0.06934541f, 0.01723478f, -0.03349117f, -0.01071502f, 0.06095227f, 0.03379840f, 
    -0.04433724f, -0.06294587f, -0.04348662f, 0.03213006f, 0.02629868f, 0.05615148f, 0.00339481f, -0.05697515f, 
    -0.02567705f, -0.00075807f, 0.04230566f, -0.02593494f, 0.01443408f, -0.07050782f, -0.01980666f, -0.04935416f, 
    -0.07140389f, 0.03736237f, 0.02969713f, -0.06476319f, -0.02076778f, 0.02672572f, 0.05349887f, -0.07079373f, 
    -0.01634597f, 0.03749093f, 0.03502800f, -0.06254498f, -0.02664832f, 0.02160524f, -0.03907118f, -0.04803172f, 
    -0.00180044f, -0.07662147f, -0.07504668f, -0.01840783f, -0.03744302f, -0.02449920f, 0.03542878f, -0.05307161f, 
    0.01208099f, -0.05537875f, 0.05022886f, 0.02631417f, -0.05886053f, 0.02458176f, 0.06676466f, 0.05340685f, 
    0.00344501f, -0.07787441f, 0.05053073f, -0.06518357f, -0.02820927f, -0.07008667f, 0.04739586f, -0.01582290f, 
    0.06350218f, -0.05341032f, -0.06463699f, 0.04963382f, 0.05732561f, -0.04148087f, 0.04195064f, 0.00140818f, 
    0.05957698f, -0.07835747f, 0.05093359f, 0.00141792f, 0.01252940f, -0.06198331f, -0.03417795f, -0.06007221f, 
    -0.04180957f, 0.01252826f, 0.06261984f, -0.00644441f, 0.01776733f, 0.02613818f, 0.04956821f, -0.03772877f, 
    0.00721253f, 0.05208529f, -0.03684168f, 0.00115369f, -0.04118612f, -0.08003536f, 0.04903223f, -0.02457128f, 
    0.02723249f, -0.02041690f, -0.00031809f, -0.04588021f, 0.02213683f, 0.02729538f, 0.00762356f, -0.02704293f, 
    -0.07091901f, 0.04080937f, 0.00645211f, 0.05179328f, -0.00121794f, -0.07382324f, 0.02837503f, 0.03926035f, 
    -0.00387328f, 0.00355083f, -0.00020830f, -0.05693273f, -0.01366822f, -0.07375354f, 0.05823167f, 0.05275328f, 
    0.03426570f, -0.04201660f, -0.01650413f, 0.01091512f, 0.00311580f, -0.04191509f, -0.03354205f, -0.03232364f, 
    -0.00178506f, -0.03254374f, 0.02452598f, 0.01547602f, -0.06380061f, 0.07259942f, 0.06844185f, 0.01909051f, 
    0.04646769f, 0.03363248f, 0.06655871f, -0.03224454f, 0.02577220f, 0.06519903f, 0.03920485f, -0.05423182f, 
    0.03333968f, -0.02757456f, -0.05315769f, -0.00669249f, -0.06451192f, -0.00026101f, -0.04232666f, -0.03984808f, 
    -0.07655817f, 0.00012176f, 0.01523304f, 0.00122309f, -0.04970400f, -0.06250337f, 0.00035369f, -0.04995993f, 
    -0.07199616f, 0.01973106f, -0.02863235f, 0.02088909f, -0.02912787f, -0.06157487f, -0.04053529f, -0.00756061f, 
    -0.01374604f, 0.03680147f, 0.05536301f, -0.02515173f, -0.00834425f, -0.04138667f, 0.03460082f, -0.06353281f, 
    0.01170934f, 0.06692088f, -0.04908411f, -0.02641132f, -0.02406232f, 0.02304254f, 0.05956327f, 0.04258765f, 
    -0.01351107f, -0.00359073f, 0.04664125f, -0.02642416f, 0.06053664f, 0.06347707f, 0.06036244f, 0.05297282f, 
    0.01279364f, 0.04340768f, 0.01137126f, 0.06418162f, 0.01189585f, -0.05738675f, -0.02422750f, -0.05736265f, 
    -0.02135393f, 0.03238520f, 0.01250524f, -0.03979873f, 0.02791020f, 0.00205918f, -0.01595973f, 0.00349321f, 
    0.01564645f, 0.05834794f, 0.05741677f, -0.06364872f, -0.06968854f, 0.03832823f, -0.05120095f, -0.04712674f, 
    -0.04566296f, -0.02896866f, -0.00504459f, -0.01748661f, -0.03151331f, 0.03671397f, -0.00267187f, -0.02993985f, 
    -0.04132872f, -0.03336642f, -0.06755833f, -0.07626415f, -0.07214262f, 0.04316101f, -0.01614021f, -0.05345607f, 
    -0.04126690f, -0.03698311f, -0.02407803f, -0.00722611f, 0.00259329f, -0.07392900f, 0.03895635f, -0.06964202f, 
    -0.07532697f, 0.04381351f, 0.06488925f, -0.01679604f, 0.01825852f, 0.03999992f, 0.06064110f, 0.06211992f, 
    -0.02226192f, 0.00584362f, 0.00502024f, 0.02302743f, 0.00562283f, -0.04693438f, -0.04764920f, -0.06064510f, 
    -0.03365946f, -0.06381946f, -0.04052538f, 0.01920525f, -0.00473302f, -0.06624158f, 0.02065774f, -0.04201884f, 
    -0.00663888f, 0.01712734f, -0.03647323f, 0.04107992f, -0.01275425f, -0.01258894f, -0.06619947f, 0.01424448f, 
    0.02948437f, -0.07144132f, -0.02842567f, 0.05430132f, -0.06394409f, -0.06450572f, -0.05708453f, 0.05803123f, 
    0.03614286f, -0.01693515f, 0.01306994f, -0.00013523f, 0.05591561f, -0.04770936f, -0.02567429f, -0.05151866f, 
    -0.03527457f, 0.06579485f, -0.05310512f, 0.01082461f, -0.00479008f, -0.06422812f, 0.03947606f, -0.01876850f, 
    -0.01157211f, 0.05217493f, -0.04810466f, -0.04973332f, 0.01220516f, 0.01251006f, -0.04109499f, -0.00706201f, 
    -0.06540169f, -0.06040001f, -0.02170452f, 0.04176903f, 0.03481972f, 0.05630004f, -0.01998557f, -0.05141816f, 
    -0.06177295f, 0.03621398f, 0.05485115f, -0.03882624f, 0.05124058f, -0.07373209f, -0.03397302f, -0.04595487f, 
    0.02822947f, -0.04467906f, 0.00267140f, -0.00760453f, 0.00668979f, 0.01313954f, 0.01647846f, -0.06161248f, 
    0.01145832f, 0.00358504f, -0.00673156f, -0.03121977f, 0.04642203f, 0.01548629f, -0.02176612f, -0.02037115f, 
    -0.04204006f, 0.00507149f, -0.07323220f, -0.01775747f, 0.06204163f, 0.01484489f, -0.03584731f, 0.04327233f, 
    0.03249785f, 0.06960337f, 0.04488035f, 0.08455629f, 0.01165013f, 0.00306992f, 0.10774870f, 0.08915649f, 
    -0.03404774f, -0.08330123f, -0.01412758f, 0.21263580f, 0.00836677f, -0.09566561f, 0.02267921f, -0.26843393f, 
    0.10533848f, 0.05788803f, 0.11285126f, 0.01369161f, -0.10573026f, 0.03711436f, 0.03918963f, 0.10771145f, 
    0.19236088f, 0.06634254f, -0.00826192f, -0.01025445f, 0.01615080f, 0.00227853f, 0.03761513f, 0.08464755f, 
    -0.14560419f, 0.05535281f, -0.03332210f, -0.10430247f, -0.14806923f, 0.03845064f, -0.21888696f, -0.05399806f, 
    0.11369137f, 0.00486318f, 0.00636428f, -0.01487375f, 0.12603493f, -0.12277075f, 0.02635901f, 0.04887367f, 
    -0.05182491f, -0.09761570f, 0.14404093f, -0.10614796f, -0.00309418f, -0.04817308f, 0.04381013f, -0.00846701f, 
    0.03102324f, -0.01059622f, -0.07382200f, -0.15275607f, 0.17754865f, 0.07319539f, 0.18815294f, 0.21408395f, 
    -0.06447714f, 0.04199722f, -0.06749760f, 0.06271146f, 0.08147129f, -0.01319619f, -0.22347288f, 0.05887356f, 
    0.23289302f, 0.17015295f, 0.02319308f, 0.02275191f, 0.06207980f, -0.02836480f, 0.10341637f, -0.12213564f, 
    0.05179717f, -0.04039764f, 0.03649453f, -0.01659381f, 0.19131099f, 0.19538704f, 0.19068709f, 0.06521272f, 
    0.01805159f, 0.05601463f, -0.00243840f, 0.00679792f, -0.00926023f, 0.04077397f, 0.03615932f, 0.14023180f, 
    -0.09971403f, 0.10798860f, -0.17378432f, 0.03984503f, 0.12174312f, -0.14567770f, 0.10905348f, -0.03482788f, 
    -0.07701839f, 0.12171687f, 0.02486448f, -0.08179932f, -0.10209490f, 0.12432626f, -0.07621370f, 0.02671632f, 
    0.09734933f, 0.05749256f, 0.09605666f, 0.00983667f, 0.02705268f, 0.00802750f, -0.12615104f, -0.02712193f, 
    0.17023499f, 0.11154263f, 0.01503823f, 0.16092293f, 0.07584996f, 0.06078833f, -0.05275849f, -0.00573110f, 
    0.02705351f, 0.09519708f, 0.08052797f, 0.10127453f, -0.18617637f, 0.11312594f, 0.05890980f, -0.03060329f, 
    0.04407804f, 0.04654312f, 0.05651136f, 0.03682237f, 0.06198953f, -0.01977800f, -0.01471328f, -0.08193874f, 
    0.14600305f, 0.04817076f, 0.19132112f, 0.08231502f, -0.02529706f, 0.09273480f, 0.08694368f, -0.06449346f, 
    0.04665796f, 0.00341928f, 0.12615016f, 0.02105870f, -0.00164232f, 0.11882348f, -0.16898592f, -0.29759187f, 
    0.05542244f, 0.02191654f, -0.06594089f, -0.00814175f, 0.02503016f, -0.01505902f, -0.03616922f, 0.01941896f, 
    0.32935700f, 0.11498887f, 0.04541344f, 0.24738923f, -0.06972431f, 0.00751747f, -0.07411531f, -0.04692219f, 
    -0.04353562f, 0.00134007f, 0.02048670f, -0.01350282f, -0.16593403f, -0.16967049f, -0.11815030f, -0.14557678f, 
    -0.02685861f, 0.11208706f, -0.06448875f, 0.00855190f, 0.05874266f, 0.10604064f, -0.00626569f, -0.03843888f, 
    -0.05155233f, 0.03605925f, 0.06027163f, 0.03590956f, -0.05511887f, -0.00800155f, -0.00070801f, 0.05845812f, 
    0.03198505f, 0.00402809f, -0.05482466f, -0.01967882f, -0.05914763f, -0.01851579f, 0.02042175f, -0.03821025f, 
    -0.04995620f, -0.01031791f, 0.00382686f, -0.00419108f, -0.00339416f, 0.04846143f, -0.07271978f, 0.03409202f, 
    0.01742723f, -0.05385863f, 0.04520340f, -0.00916620f, -0.02849797f, -0.01158722f, 0.06343125f, 0.00459039f, 
    -0.00519011f, 0.01446956f, -0.04670744f, -0.06386647f, -0.03052166f, 0.07012837f, 0.01508489f, -0.02913190f, 
    -0.06788050f, 0.00154585f, 0.03650311f, -0.04494851f, -0.06180949f, -0.04298726f, 0.03570815f, -0.05755293f, 
    0.05333760f, 0.06422483f, -0.00423873f, -0.05107453f, -0.04162844f, -0.07562841f, -0.05504406f, -0.06235122f, 
    -0.07541233f, 0.05840656f, 0.05035185f, -0.00379783f, -0.06850391f, -0.04967406f, -0.03572936f, -0.00203355f, 
    -0.02013462f, -0.06163172f, -0.06301480f, -0.03189123f, 0.00693782f, 0.00980334f, 0.03271150f, -0.00754879f, 
    0.03874071f, -0.06917744f, -0.02192640f, -0.06997014f, -0.01357449f, -0.04555739f, 0.03717857f, 0.03769901f, 
    -0.00319706f, -0.06038021f, -0.03853565f, -0.01596305f, -0.03564220f, -0.02823727f, 0.03972524f, 0.05561465f, 
    0.05442072f, 0.05405850f, -0.05546093f, 0.01118334f, -0.05800055f, -0.03032186f, -0.01656454f, 0.02770147f, 
    -0.01938222f, -0.06611051f, -0.07398660f, -0.01561013f, -0.03906783f, 0.01852405f, 0.02424854f, -0.02386801f, 
    -0.07227693f, -0.06865070f, -0.04893835f, 0.03803618f, -0.07806814f, -0.01371190f, -0.02090258f, -0.00837155f, 
    0.03624558f, -0.01755955f, -0.05207706f, 0.01316268f, 0.03650359f, 0.06337311f, -0.00178053f, 0.02259043f, 
    0.06222760f, 0.01360437f, 0.05821229f, 0.04897902f, -0.06892129f, -0.02992792f, 0.00019824f, 0.01798335f, 
    -0.04324964f, 0.05421193f, -0.02067458f, 0.03686327f, 0.05149438f, -0.01667637f, -0.02128182f, -0.06342339f, 
    0.04951578f, 0.04429602f, -0.02135227f, 0.00657252f, 0.02909240f, -0.05800837f, 0.01432704f, -0.00690290f, 
    0.02179597f, 0.00523107f, -0.07253848f, -0.03174607f, 0.03343320f, 0.00504394f, -0.06746149f, -0.04644705f, 
    0.03401984f, 0.02314895f, 0.05887310f, -0.02028842f, -0.03620802f, 0.05425148f, 0.04953501f, 0.01883805f, 
    -0.03587886f, 0.06049465f, 0.00204627f, 0.05519011f, 0.04520877f, -0.00067138f, 0.02120636f, 0.05876116f, 
    0.07230923f, -0.00639313f, -0.06295939f, -0.02395835f, -0.01634106f, 0.06395673f, 0.05426811f, -0.02574251f, 
    0.04570428f, 0.00447503f, 0.01622246f, -0.03982708f, -0.07161666f, 0.05781676f, 0.01736391f, -0.00675706f, 
    -0.05776724f, -0.01755831f, -0.05611794f, -0.03273586f, -0.03556970f, -0.00529363f, -0.00797837f, 0.04566411f, 
    0.22634518f, 0.10585264f, -0.09713028f, -0.13268933f, -0.01336083f, 0.07266235f, 0.05938582f, 0.11558812f, 
    0.08716244f, 0.07746463f, -0.06298430f, -0.17057438f, 0.03368232f, 0.09530585f, 0.02928676f, 0.21065487f, 
    -0.00742986f, 0.01633874f, -0.10917570f, -0.01902901f, 0.02068312f, 0.05429871f, -0.03079548f, -0.08021799f, 
    0.15867120f, 0.09191930f, -0.27767625f, 0.02314640f, 0.00260309f, 0.00045161f, 0.13476273f, 0.07998684f, 
    0.13724135f, 0.00316424f, 0.04140130f, 0.08516543f, 0.08424145f, -0.16431099f, 0.37153575f, 0.07938887f, 
    -0.13475242f, -0.00231233f, -0.01206231f, 0.04338998f, 0.08803546f, -0.04096394f, 0.00154764f, -0.08752835f, 
    -0.24340977f, 0.27504817f, -0.08297946f, 0.30999482f, 0.01834363f, 0.05675726f, 0.13945316f, 0.01003829f, 
    0.18474342f, 0.12143029f, -0.02964461f, 0.17384146f, 0.01573695f, 0.17825527f, 0.01106829f, 0.04249267f, 
    0.10906547f, 0.09004908f, 0.17895085f, 0.04324231f, -0.02464026f, 0.11996534f, 0.16300304f, 0.03022463f, 
    -0.00139185f, -0.07580914f, 0.06793518f, -0.09496150f, 0.01055401f, 0.15299134f, 0.03985817f, 0.15670176f, 
    -0.10401066f, -0.11307439f, -0.02075332f, 0.03485542f, 0.03417842f, 0.02100584f, 0.00385554f, -0.08337040f, 
    -0.20486502f, -0.02066005f, -0.09368631f, 0.03866389f, 0.13847634f, -0.11556510f, -0.01272909f, -0.00173181f, 
    0.18048409f, -0.30824354f, 0.10177938f, -0.31417629f, 0.01030242f, 0.10571399f, -0.01865583f, -0.05468705f, 
    0.07152059f, -0.10353133f, 0.02446414f, 0.02379403f, -0.17206626f, 0.03810015f, -0.10653514f, -0.07874024f, 
    0.04914643f, 0.08302795f, 0.01665454f, 0.10344468f, 0.03977938f, 0.05578827f, 0.18834396f, 0.11772418f, 
    0.20052722f, -0.15701243f, -0.04691005f, -0.16140933f, 0.00783751f, 0.01977113f, 0.17673212f, -0.10280489f, 
    -0.05397024f, -0.07023418f, -0.02443570f, 0.08387139f, 0.22003882f, -0.20854835f, -0.21131431f, -0.09819961f, 
    -0.10046759f, -0.08099104f, 0.14163943f, -0.15565582f, -0.03901495f, 0.06067590f, -0.06428182f, 0.09349587f, 
    -0.17190954f, 0.04217850f, 0.00409889f, -0.01640934f, -0.02582125f, 0.00566122f, 0.09426892f, 0.08605553f, 
    0.13862953f, 0.02601430f, 0.02592094f, 0.13172336f, -0.00389859f, -0.13918918f, 0.30093491f, 0.28267094f, 
    0.02202180f, -0.05426984f, -0.09421056f, 0.01770671f, 0.05461302f, 0.06340440f, 0.05888542f, 0.00332832f, 
    -0.03511323f, -0.06436750f, -0.04820783f, -0.26178327f, 0.01774201f, -0.11313510f, 0.07549557f, -0.02416123f, 
    -0.09840793f, 0.11622800f, 0.02565510f, -0.07424034f, -0.13595757f, -0.01648726f, 0.04673015f, -0.07325464f, 
    0.09152086f, -0.14440726f, 0.07977504f, -0.09137350f, 0.04576869f, -0.08055992f, 0.04349814f, 0.08441816f, 
    0.09514049f, -0.03966524f, -0.04614369f, -0.03212190f, 0.11461928f, 0.06890792f, 0.04282055f, 0.02270151f, 
    0.00622616f, 0.16642407f, -0.01833420f, 0.04314289f, -0.09195509f, 0.12964426f, 0.05226926f, 0.21429703f, 
    0.05207099f, 0.07140765f, 0.01332712f, -0.04234473f, 0.03964368f, 0.03124960f, 0.02607903f, 0.11560822f, 
    -0.07431724f, -0.14656851f, 0.01215678f, -0.21199140f, 0.08763108f, -0.12959675f, 0.03038956f, -0.00476692f, 
    -0.02461993f, 0.04613246f, 0.05360467f, 0.04363406f, 0.22805637f, 0.15520214f, 0.03218628f, 0.11897272f, 
    -0.06016691f, 0.01284995f, -0.14367197f, 0.04963690f, 0.05754675f, 0.06790821f, -0.00250842f, 0.04582077f, 
    0.25914636f, -0.01635853f, -0.06112884f, -0.00819857f, -0.00859273f, 0.01766164f, 0.03361022f, -0.13084066f, 
    0.05881674f, -0.20545541f, 0.03829628f, 0.03387627f, -0.07461556f, -0.05044717f, -0.14045338f, -0.39938077f, 
    0.11079003f, 0.08150890f, 0.02538148f, 0.16245170f, 0.01704767f, 0.01823167f, 0.14607304f, 0.00689490f, 
    -0.09690163f, -0.05968961f, 0.10018962f, -0.02868543f, 0.10636532f, -0.04659062f, 0.04509628f, 0.15068573f, 
    0.16498515f, 0.19729814f, -0.04950226f, -0.00801352f, -0.16393079f, -0.29708251f, -0.36583829f, -0.04915504f, 
    0.07049859f, 0.13324019f, 0.15150380f, -0.09116933f, -0.10348850f, 0.07601791f, -0.00175837f, 0.01029229f, 
    -0.15258543f, 0.09455665f, 0.15564114f, 0.18383351f, 0.00092643f, -0.02504171f, 0.05773200f, 0.09346786f, 
    0.04484244f, -0.00796802f, -0.00102241f, 0.09410802f, 0.32207602f, -0.09648417f, -0.09972713f, -0.06332510f, 
    -0.09487103f, 0.05901628f, -0.05236683f, 0.08817295f, -0.02221399f, 0.05336994f, 0.10443479f, -0.02776040f, 
    0.03759906f, 0.04665916f, 0.05541242f, -0.15163216f, 0.05725511f, 0.17615773f, 0.12980108f, 0.00038250f, 
    -0.01476029f, 0.02654133f, -0.03139683f, 0.08730394f, 0.19920102f, -0.04795991f, 0.14026487f, 0.07936846f, 
    0.01254245f, -0.00513181f, -0.03969375f, 0.06921674f, 0.04526245f, 0.00357648f, 0.03025319f, -0.10314310f, 
    0.08355558f, 0.06527098f, 0.12635322f, 0.00058696f, -0.02431032f, 0.10121534f, -0.03364886f, 0.01512548f, 
    0.15873726f, -0.04808743f, 0.06596949f, 0.04501766f, 0.01623181f, 0.03871504f, 0.17626734f, -0.05130071f, 
    0.16852090f, 0.06071642f, -0.03321882f, -0.06050726f, 0.03225334f, 0.06038031f, -0.00981277f, 0.03261570f, 
    -0.41484076f, -0.06142053f, -0.06277112f, -0.13247406f, -0.04500631f, 0.04228519f, 0.12372758f, 0.27183098f, 
    -0.00215368f, 0.00065938f, -0.08736870f, 0.12765120f, 0.13211167f, 0.27845368f, 0.14347436f, 0.19548297f, 
    0.06232371f, 0.09732433f, 0.16111547f, -0.18323450f, -0.00202190f, -0.05134361f, 0.08058318f, 0.09126858f, 
    0.20823817f, 0.02169000f, -0.15794897f, 0.02370712f, -0.11395391f, -0.07575339f, 0.07512431f, 0.07425558f, 
    0.08852901f, 0.14039251f, 0.04194800f, -0.04405756f, -0.03573401f, 0.08796398f, 0.28357619f, -0.29891357f, 
    0.10890249f, 0.11765870f, -0.04159419f, 0.06194828f, 0.12748581f, 0.06811743f, 0.07423311f, -0.01858748f, 
    0.10143647f, 0.07206019f, 0.06886957f, -0.08167907f, 0.00636377f, -0.16739790f, 0.04531790f, -0.07580537f, 
    -0.04848780f, -0.01748512f, 0.05088581f, 0.09113012f, 0.00877575f, -0.03375845f, 0.08177609f, 0.12956873f, 
    -0.02318132f, -0.11768238f, -0.05520706f, 0.00916897f, -0.02781906f, 0.02145205f, -0.10574132f, 0.00037937f, 
    0.00350813f, 0.15624350f, -0.18321715f, 0.27672073f, -0.03545409f, 0.06723823f, -0.02002946f, -0.04671267f, 
    0.12702884f, -0.04502082f, -0.05230105f, 0.10147347f, 0.14456090f, -0.09237485f, -0.20029603f, -0.03766689f, 
    0.04011513f, 0.14640053f, 0.09607437f, 0.13255550f, 0.09073529f, 0.05569056f, 0.13272630f, -0.07197319f, 
    0.05891353f, 0.09009084f, 0.18499516f, -0.16523106f, 0.13453263f, 0.15479657f, -0.03876221f, 0.22272193f, 
    0.01326712f, 0.08436189f, -0.05935208f, -0.02321298f, 0.02887240f, -0.21295306f, -0.21315400f, -0.18934120f, 
    -0.10093541f, -0.01369024f, -0.08736510f, -0.07149262f, -0.10026556f, -0.08456919f, -0.04839159f, 0.22412138f, 
    -0.26024690f, -0.14856377f, -0.00319080f, 0.04515950f, -0.08626977f, -0.14959316f, -0.00674732f, 0.03584657f, 
    0.23953232f, -0.02121631f, 0.04825951f, 0.02538094f, -0.09536833f, 0.01311733f, -0.05496810f, -0.00412955f, 
    0.07532477f, 0.06562144f, 0.09680992f, 0.05188170f, -0.01551087f, -0.03567431f, 0.07806077f, -0.06411833f, 
    0.23528264f, -0.11038413f, -0.29674944f, -0.01881127f, 0.10455238f, 0.15251920f, 0.07718525f, 0.01434687f, 
    0.05565849f, 0.11444649f, 0.15443082f, 0.12452739f, 0.05232770f, -0.23942983f, -0.08418459f, 0.19884054f, 
    0.00666580f, 0.01084359f, 0.07180452f, 0.01472314f, 0.03859817f, 0.03586640f, 0.00967163f, -0.14217189f, 
    0.02301243f, 0.12913759f, 0.07312631f, 0.23924880f, 0.11917546f, 0.15023585f, -0.09646179f, -0.08373879f, 
    0.30142486f, 0.09137566f, -0.02560408f, 0.08931014f, -0.02686736f, -0.06910080f, 0.34908485f, -0.18967511f, 
    0.19565344f, -0.02617971f, 0.03712416f, -0.05448229f, 0.05512463f, 0.06153381f, 0.04905386f, 0.00279447f, 
    -0.18569185f, -0.05355188f, -0.04036116f, -0.01913953f, -0.12918231f, -0.05337165f, 0.17585869f, -0.00275396f, 
    0.01591458f, 0.06143734f, -0.06660154f, -0.01478663f, -0.04078003f, 0.11094122f, 0.06102751f, 0.20460467f, 
    0.06769541f, 0.27531624f, 0.06696076f, -0.16249672f, 0.03416423f, -0.07994353f, 0.06262367f, 0.10303095f, 
    -0.03338517f, 0.00709290f, 0.01284577f, 0.01622124f, 0.05328631f, 0.01481691f, -0.00305026f, -0.03387658f, 
    -0.05940170f, -0.06782097f, 0.02116181f, 0.00975866f, -0.00783939f, 0.00650247f, -0.04251503f, -0.01847815f, 
    0.00704179f, -0.03598849f, 0.00146260f, -0.04856848f, -0.05650325f, -0.06136742f, 0.03889243f, -0.05886301f, 
    -0.04407214f, -0.05507899f, -0.02493891f, -0.06858759f, 0.03705569f, -0.00800419f, -0.05737206f, 0.06596680f, 
    0.04968882f, -0.06641123f, -0.04938260f, 0.01840686f, 0.06667257f, 0.04022784f, 0.00520034f, -0.07198765f, 
    -0.02122049f, -0.06984100f, -0.05732239f, -0.03871559f, -0.00239092f, 0.06557471f, -0.01315886f, 0.01003773f, 
    -0.07247718f, 0.03679329f, 0.03638770f, 0.03876554f, 0.05661327f, 0.00688014f, -0.01977980f, -0.00837222f, 
    0.02763490f, -0.06451725f, -0.00309029f, -0.01703476f, -0.01614317f, 0.03451636f, -0.05295637f, -0.02843799f, 
    0.01894780f, 0.02497994f, 0.03286911f, 0.05464343f, 0.02903149f, -0.02836003f, -0.02479842f, -0.06092339f, 
    -0.03921474f, -0.02511927f, 0.00678504f, 0.00538684f, -0.05902820f, 0.05014233f, -0.06421202f, -0.06983817f, 
    -0.04899062f, 0.00477206f, 0.03347162f, 0.00905336f, -0.01286488f, 0.04925903f, 0.01931442f, -0.05729047f, 
    -0.06606181f, -0.02223148f, 0.03736344f, -0.04751395f, -0.03760257f, -0.04597648f, -0.05983147f, 0.00927750f, 
    -0.07647726f, 0.00003896f, 0.03577905f, -0.03384604f, 0.02297090f, 0.01626506f, -0.06063518f, -0.01186687f, 
    -0.05664629f, -0.00076474f, 0.00815145f, -0.03130739f, -0.05849541f, 0.03003108f, 0.03768587f, -0.03865415f, 
    0.03687260f, -0.03760608f, -0.00607795f, 0.03651036f, 0.05621738f, -0.02793239f, 0.05383798f, -0.02196810f, 
    -0.03348478f, 0.03189300f, 0.02517518f, -0.05304918f, 0.04648447f, -0.03719581f, 0.02764427f, -0.05233987f, 
    -0.02209266f, -0.03168163f, 0.06495617f, -0.07746509f, -0.07749033f, -0.02713342f, 0.01947953f, -0.05361136f, 
    -0.05263947f, 0.06680661f, 0.00751405f, -0.05933675f, 0.00664766f, 0.06172764f, -0.06125051f, -0.00599349f, 
    0.04382876f, -0.03636216f, -0.02691044f, -0.05248613f, -0.05884359f, -0.01220391f, -0.04336277f, -0.04109801f, 
    -0.06516340f, 0.07019772f, -0.03452598f, -0.00772855f, 0.00257643f, 0.01151861f, 0.04886021f, 0.02237662f, 
    -0.00844802f, 0.05740066f, -0.07699028f, -0.02041520f, -0.06646627f, -0.00623164f, 0.06805839f, -0.06079127f, 
    -0.04159702f, -0.00946096f, -0.01584175f, -0.00492810f, 0.04986492f, -0.05787947f, -0.00573061f, 0.05513874f, 
    0.04878470f, -0.03995618f, 0.04254534f, 0.04989655f, -0.03655013f, -0.06794786f, -0.06799542f, -0.00989072f, 
    -0.03972120f, 0.05527100f, 0.04981716f, -0.00806528f, -0.02805484f, 0.04581811f, 0.00790963f, -0.04488111f, 
    -0.29246777f, -0.10006922f, 0.09504738f, -0.12445562f, 0.21723467f, 0.08386140f, -0.07850862f, 0.03435776f, 
    -0.10084631f, -0.01398189f, 0.04932200f, -0.05708129f, -0.07535774f, -0.05498460f, -0.20766325f, 0.37977353f, 
    -0.00858926f, -0.11316609f, -0.02525943f, 0.02996163f, -0.00635894f, 0.00852091f, -0.00320408f, 0.01335037f, 
    -0.27727944f, -0.22793737f, -0.01874655f, 0.11675458f, 0.10746184f, 0.10987777f, -0.00424111f, 0.14091878f, 
    0.04026441f, 0.08326998f, -0.10712053f, 0.03258580f, 0.08305619f, 0.04528739f, -0.05260758f, -0.04467167f, 
    0.08596722f, 0.15404361f, 0.05953414f, 0.04793539f, 0.06600228f, 0.06087362f, 0.14779948f, 0.07098062f, 
    0.35286546f, -0.27362728f, -0.02433678f, -0.12888080f, -0.03534190f, 0.06885909f, -0.01752444f, -0.05348870f, 
    -0.00005889f, -0.10404578f, 0.21899922f, -0.07411715f, -0.27389368f, 0.16987480f, 0.10123818f, -0.26803347f, 
    -0.07436624f, -0.06593223f, -0.07160704f, -0.01520991f, -0.08048904f, 0.04592890f, 0.06170391f, 0.06497949f, 
    -0.16727765f, -0.13093004f, -0.08797895f, 0.15132441f, 0.01990923f, 0.01242854f, 0.05467534f, -0.05405324f, 
    0.02984105f, 0.02094144f, 0.06230919f, 0.03153035f, -0.10001036f, -0.09176362f, 0.11117550f, -0.06891711f, 
    0.08299045f, 0.01932041f, 0.13717592f, 0.07933296f, 0.07382689f, -0.01098082f, 0.13386644f, -0.03768322f, 
    0.17769276f, 0.41258168f, -0.02043529f, 0.10334072f, 0.02537282f, 0.05710990f, -0.06492748f, 0.04395859f, 
    0.01443549f, -0.01724447f, 0.02386869f, 0.09711738f, 0.13592996f, -0.02464339f, -0.02950628f, 0.06922833f, 
    0.09671066f, -0.11354414f, 0.02537061f, -0.00534780f, -0.02146170f, 0.02716490f, 0.03769876f, -0.02152740f, 
    -0.42180109f, 0.02648745f, 0.27274323f, -0.17067567f, -0.05329144f, -0.00377092f, -0.01263160f, -0.00943233f, 
    0.01128842f, 0.00312872f, -0.01894326f, -0.02757961f, 0.27429053f, 0.22258092f, 0.09724187f, -0.09072971f, 
    0.02094006f, 0.00335812f, -0.05375828f, 0.02323546f, -0.04331580f, -0.08485889f, -0.00913077f, -0.02463401f, 
    0.20673530f, 0.01609731f, 0.06032320f, -0.28537944f, -0.04593609f, 0.06386179f, 0.00635592f, 0.01594769f, 
    -0.18403122f, -0.04041283f, 0.03008298f, -0.04834835f, 0.16674398f, 0.09116708f, -0.10288858f, 0.27974948f, 
    -0.11060718f, 0.02521791f, 0.01814948f, 0.01559729f, -0.04011609f, -0.00009938f, 0.00426839f, -0.01335896f, 
    -0.04719280f, -0.13175723f, -0.00009176f, -0.02301746f, 0.18044053f, 0.08043344f, -0.09611017f, 0.06317052f, 
    0.11710858f, -0.14012875f, 0.08848451f, 0.05791500f, 0.44936341f, 0.10452123f, 0.04971850f, -0.05100820f, 
    0.04637709f, -0.10459707f, -0.02222905f, 0.09387989f, 0.05168957f, 0.22884576f, 0.00130064f, 0.03536137f, 
    -0.06870048f, 0.03760588f, 0.00391605f, 0.07663790f, 0.19896597f, 0.23316221f, -0.00209516f, -0.01184944f, 
    -0.04777790f, -0.20610812f, 0.11188421f, 0.01513802f, -0.10705887f, -0.08840787f, 0.17093405f, 0.24546851f, 
    0.16415899f, -0.15342574f, -0.15318482f, 0.08605415f, -0.09288166f, -0.07760311f, -0.14350593f, -0.18054040f, 
    0.02303432f, 0.03302322f, -0.05594233f, -0.18949445f, 0.18018159f, 0.23279980f, 0.19120474f, 0.02652130f, 
    0.00304789f, -0.03014117f, -0.16181728f, -0.14640860f, -0.63987964f, -0.03762576f, 0.12973215f, 0.15627632f, 
    0.04231629f, -0.09825800f, 0.00816680f, -0.03970717f, -0.21849251f, 0.10041897f, 0.03665593f, -0.02454204f, 
    0.09932952f, -0.20141703f, 0.00285229f, 0.05439181f, -0.01626843f, 0.03371878f, -0.23613223f, -0.05320936f, 
    0.12345421f, 0.11281762f, -0.23002546f, 0.04758940f, 0.12444781f, 0.12793607f, -0.09282207f, 0.07763726f, 
    -0.14161390f, -0.07949775f, -0.00531614f, -0.03286688f, -0.03586247f, -0.11879434f, -0.12605827f, 0.05430913f, 
    0.05786151f, 0.08078163f, -0.02718684f, 0.15574479f, 0.00124134f, -0.02525492f, 0.14267223f, -0.00938099f, 
    0.04194695f, -0.02893888f, -0.22429539f, -0.04823622f, 0.01493728f, 0.10605367f, 0.04207643f, 0.27785549f, 
    0.23205774f, 0.05096709f, 0.18632802f, 0.11421526f, -0.20748247f, -0.01733589f, -0.12577271f, -0.02235466f, 
    0.14465141f, 0.21574089f, 0.12197225f, 0.12665488f, 0.01952040f, -0.07304408f, -0.12011155f, 0.08533652f, 
    0.13768539f, -0.08918374f, 0.20829082f, -0.02751546f, 0.14355934f, 0.05784863f, -0.04662141f, -0.09310471f, 
    0.20177141f, 0.02240116f, 0.11244878f, 0.08010142f, -0.13372399f, -0.20206577f, -0.04687780f, 0.10691070f, 
    0.02876442f, -0.06762735f, 0.10129640f, 0.17625721f, -0.06779486f, 0.11879048f, -0.02948903f, 0.10648900f, 
    -0.19054340f, -0.02203704f, -0.10964194f, 0.07393254f, -0.23558666f, -0.24803559f, -0.04133905f, -0.00866786f, 
    0.10329368f, 0.01995966f, 0.09982970f, -0.10104565f, -0.01546867f, 0.11886104f, -0.01444744f, 0.04718200f, 
    0.03422243f, 0.16210404f, -0.04824892f, 0.08263119f, -0.04744370f, -0.08762248f, -0.04184093f, -0.07232477f, 
    -0.29449829f, 0.10872675f, 0.03522975f, -0.03850983f, 0.00851685f, -0.03493703f, -0.07105607f, 0.11288042f, 
    0.07901184f, -0.02377960f, -0.01969280f, 0.01079008f, -0.03947713f, -0.07825053f, -0.02792492f, 0.06066729f, 
    0.33375534f, 0.02156919f, -0.20072077f, -0.18988113f, 0.08712371f, 0.18754245f, 0.01120895f, 0.03607518f, 
    -0.12904651f, -0.03410415f, 0.04458746f, -0.03669581f, -0.13654079f, -0.27817386f, -0.08739057f, 0.10042889f, 
    -0.03472044f, 0.02212624f, -0.25136602f, 0.00675495f, -0.13385914f, 0.11769342f, -0.05559825f, -0.18648557f, 
    -0.12175178f, -0.07783090f, -0.11030523f, -0.04551447f, 0.04968631f, 0.12883569f, -0.02914482f, 0.02751591f, 
    0.10811632f, 0.00648012f, 0.01758261f, -0.12233842f, 0.06987130f, -0.03540923f, 0.06519631f, 0.24077800f, 
    -0.04504641f, 0.00360949f, 0.01679445f, -0.03931272f, -0.05704665f, 0.02735630f, -0.04774060f, -0.03654699f, 
    0.04615144f, -0.00716325f, -0.31016573f, 0.08979413f, 0.14129147f, 0.05092574f, 0.17124224f, 0.04167698f, 
    0.13976860f, 0.02946161f, 0.04083592f, 0.12170615f, 0.06222247f, -0.01589341f, 0.27523261f, 0.07880989f, 
    -0.06066828f, 0.08517000f, 0.09716854f, 0.08578356f, -0.03269473f, 0.04701595f, 0.06683403f, 0.11268260f, 
    0.02531038f, 0.04413382f, -0.07382799f, 0.15404065f, -0.00618207f, 0.11309229f, 0.00367980f, 0.07559908f, 
    0.14497818f, -0.03561448f, 0.09306353f, 0.04765727f, -0.13151005f, -0.00074538f, 0.09806392f, -0.03840457f, 
    0.02008318f, 0.03070089f, 0.06301294f, 0.12268544f, -0.04029770f, 0.16988218f, 0.16081972f, 0.07421488f, 
    -0.18082494f, -0.05735668f, -0.03872175f, 0.02602594f, -0.07465038f, 0.07729889f, -0.01070607f, 0.18113267f, 
    -0.07107737f, -0.14065412f, -0.09494958f, 0.01867123f, -0.19402678f, -0.01575874f, 0.01555858f, 0.04465223f, 
    0.03226689f, -0.02268047f, -0.22249749f, 0.00943507f, 0.18184495f, -0.00848362f, -0.02498135f, 0.00255208f, 
    0.14816946f, -0.24364197f, 0.10918557f, -0.25988913f, 0.12387096f, 0.05617995f, -0.05781634f, 0.09631293f, 
    0.03600702f, -0.03823402f, 0.07880621f, 0.03304771f, -0.26104572f, 0.08216812f, -0.20322102f, -0.03453377f, 
    0.11212545f, -0.06589507f, -0.01989734f, 0.02656995f, 0.03828430f, 0.09213805f, 0.16004835f, 0.08907927f, 
    -0.03856941f, -0.31510711f, 0.13491423f, -0.04518435f, 0.00008365f, -0.03994911f, 0.19851510f, 0.08097038f, 
    0.07811931f, -0.03928010f, -0.03515972f, 0.02494686f, 0.00747080f, -0.11789259f, -0.07589226f, -0.21655601f, 
    0.08318429f, -0.05921999f, 0.03030141f, -0.03332823f, -0.06847680f, 0.07991867f, -0.06532307f, 0.09027393f, 
    0.07917275f, -0.00606597f, 0.17350516f, -0.10311728f, 0.06844531f, 0.04542438f, 0.01844802f, 0.10674508f, 
    -0.03694211f, 0.00511520f, -0.12197702f, 0.08644507f, 0.13520680f, -0.04574483f, 0.04647186f, 0.22413614f, 
    -0.05201691f, -0.05937653f, 0.09215049f, 0.10152434f, -0.02708297f, -0.04087958f, 0.12551825f, 0.06840074f, 
    -0.00447316f, -0.01896458f, 0.06582947f, -0.14919044f, 0.01316324f, -0.04234969f, 0.07647748f, -0.11347726f, 
    0.03050201f, 0.13151149f, 0.08284408f, -0.04882202f, 0.08667598f, -0.00729358f, 0.09564976f, 0.02077524f, 
    0.09832649f, -0.14170730f, -0.05249187f, -0.02614249f, 0.10589740f, 0.04939769f, 0.05592148f, 0.08185802f, 
    0.18197748f, -0.02863667f, -0.09935898f, 0.26400134f, -0.03175575f, 0.07327465f, 0.04651488f, -0.02460476f, 
    0.13666902f, -0.00198312f, 0.10168104f, -0.14854087f, 0.12908930f, -0.02743534f, 0.01360204f, -0.54587024f, 
    0.03484732f, 0.01372853f, -0.16777334f, -0.05568770f, 0.05300249f, -0.04220640f, 0.00103091f, -0.01502655f, 
    0.15872253f, 0.24949530f, -0.04601475f, 0.01316546f, -0.01753320f, -0.16559783f, 0.07900475f, -0.10109266f, 
    0.06167472f, 0.01455281f, -0.13210236f, -0.04550036f, 0.02550833f, -0.11006307f, 0.02400249f, 0.00315916f, 
    -0.00744359f, -0.01338411f, 0.04424657f, -0.05834552f, 0.14571850f, 0.02589397f, -0.02846939f, 0.23923300f, 
    0.19184513f, -0.05863860f, -0.10183586f, 0.05758170f, 0.15233961f, 0.06923845f, 0.04582484f, 0.08928095f, 
    0.05428105f, -0.02935445f, -0.02920238f, 0.15696631f, 0.01255203f, -0.05975018f, -0.04621455f, 0.22050506f, 
    0.02773420f, 0.06241592f, 0.02192115f, 0.05259882f, -0.05321875f, 0.04790844f, 0.07500937f, -0.02311491f, 
    -0.11765392f, 0.04894083f, 0.06017428f, -0.06411412f, -0.11270546f, 0.07042628f, 0.00496829f, 0.13654847f, 
    -0.03746331f, 0.02808186f, 0.02415900f, -0.08205616f, -0.26646331f, 0.00399286f, 0.02920567f, 0.28086582f, 
    -0.07088464f, 0.03615216f, -0.03536284f, -0.17492627f, 0.01686562f, -0.12465377f, -0.07777685f, -0.05754571f, 
    -0.07318585f, -0.15043393f, -0.02496851f, -0.17551871f, -0.01501528f, -0.08257679f, 0.00674625f, 0.00352370f, 
    0.30074388f, -0.05179150f, 0.04905352f, -0.02459055f, -0.23480150f, 0.16431820f, 0.00746407f, -0.03503654f, 
    0.03201411f, 0.16129127f, 0.05771890f, -0.03508807f, 0.21016118f, 0.07583096f, 0.12590455f, -0.08430892f, 
    -0.05048563f, -0.33871537f, 0.08413544f, 0.27611595f, -0.01798637f, -0.02352608f, 0.04417114f, 0.04861875f, 
    0.06574102f, 0.02114470f, -0.08691317f, 0.11665294f, -0.08629300f, -0.19818191f, -0.10218540f, -0.06574412f, 
    0.06825452f, -0.07878714f, 0.08249419f, 0.07838580f, -0.04041229f, 0.00279856f, -0.05689146f, -0.04212245f, 
    0.40395424f, 0.34778678f, 0.09764267f, 0.17995633f, 0.11938868f, 0.19068819f, 0.05569688f, -0.01251195f, 
    0.00697927f, 0.08731821f, 0.05681735f, 0.04724470f, 0.13519624f, 0.11031578f, -0.07477954f, -0.48959863f, 
    0.12400416f, -0.06274484f, 0.06820590f, -0.09080877f, -0.06777513f, -0.05749028f, 0.12747727f, 0.15900180f, 
    0.21873909f, 0.27298185f, 0.03099675f, 0.06257254f, -0.02279744f, -0.21113421f, 0.03369264f, -0.21152961f, 
    -0.12581402f, 0.16987778f, 0.08670966f, -0.23684931f, 0.13986905f, 0.19157048f, 0.03279393f, -0.04654020f, 
    0.12691890f, 0.18353738f, -0.04343211f, -0.11607567f, 0.05124735f, -0.06859670f, -0.03794735f, 0.15792494f, 
    -0.03890334f, -0.12139487f, -0.07332143f, 0.11384634f, 0.05626811f, -0.06781775f, 0.04196164f, 0.08859792f, 
    -0.00484226f, 0.11094868f, 0.07603181f, 0.13300511f, -0.18629041f, -0.04041266f, -0.19523083f, 0.08969078f, 
    0.01412206f, 0.09184641f, 0.16111849f, -0.05616525f, 0.13807954f, 0.11602796f, 0.06254908f, 0.06862161f, 
    0.14691849f, -0.26509133f, -0.02520392f, -0.06652836f, -0.08651073f, -0.06334697f, -0.00431943f, 0.11789964f, 
    -0.01125012f, 0.00925062f, -0.01793205f, 0.06384225f, 0.16788489f, -0.07907515f, -0.15469651f, -0.00245085f, 
    -0.03306521f, 0.11544945f, -0.12135229f, -0.10670412f, 0.14659470f, 0.05412548f, 0.15659977f, -0.00180442f, 
    0.21534300f, -0.04585837f, -0.15790500f, -0.12679899f, -0.08930619f, 0.04590939f, 0.00934435f, -0.03657444f, 
    -0.19932714f, -0.11005812f, 0.09891095f, -0.09384937f, 0.01322908f, 0.18312861f, -0.01576663f, -0.21045227f, 
    0.02051526f, 0.10398909f, -0.03609467f, -0.02260621f, -0.03862078f, -0.04163935f, -0.06294138f, 0.05842165f, 
    0.12553382f, -0.01662867f, -0.08828591f, 0.04248350f, 0.15827161f, -0.07486395f, -0.02977428f, 0.02556282f, 
    0.19888733f, 0.01110338f, -0.03150813f, -0.04039710f, -0.14341992f, -0.10901075f, -0.06339987f, -0.08381043f, 
    -0.05785773f, 0.09131590f, 0.17641753f, 0.09537493f, -0.08726833f, 0.14748734f, 0.02484755f, 0.00187854f, 
    -0.06965362f, 0.24328330f, -0.07921647f, 0.33058369f, 0.05102150f, -0.11158810f, 0.08977282f, 0.15490785f, 
    0.01723001f, 0.11226680f, 0.02572999f, 0.03390554f, 0.35034108f, 0.01119395f, -0.10388009f, 0.18913238f, 
    -0.07116904f, -0.12823334f, -0.06583890f, 0.12788726f, -0.06141268f, -0.00171530f, -0.12511003f, -0.07697672f, 
    0.11217555f, 0.05971527f, 0.15164132f, -0.08680354f, 0.11465599f, 0.06152025f, -0.05208376f, 0.05344200f, 
    -0.07017162f, 0.09367397f, 0.02292315f, 0.02193704f, 0.19613299f, -0.12436845f, 0.16804354f, -0.22348201f, 
    -0.00541157f, 0.00914135f, 0.19590235f, 0.26864234f, -0.02070262f, -0.02240965f, -0.07444443f, -0.02317817f, 
    0.26691425f, -0.07134340f, 0.11089987f, -0.14098774f, -0.04195254f, -0.00375709f, 0.16675875f, -0.10545701f, 
    0.04402795f, 0.04019178f, 0.00206728f, -0.04577737f, 0.11900062f, -0.19126762f, -0.14083308f, 0.04292386f, 
    0.10359047f, 0.09360301f, -0.03936067f, 0.02183212f, 0.14736295f, 0.01993991f, -0.19773488f, 0.04160547f, 
    -0.09689333f, -0.12642723f, -0.03133373f, 0.14759757f, -0.04039306f, -0.04273642f, 0.01719516f, 0.10708569f, 
    -0.01174786f, -0.10915555f, 0.05227428f, 0.03980359f, 0.05098650f, -0.02948580f, 0.06082177f, -0.16471726f, 
    -0.02920555f, -0.07396209f, 0.04209142f, 0.01014733f, -0.07379545f, 0.05077114f, 0.02675562f, 0.09859139f, 
    0.15654400f, 0.13102499f, -0.08290800f, 0.07034628f, -0.08217178f, -0.08973177f, 0.00855967f, 0.04270517f, 
    -0.03330612f, -0.02744722f, -0.06588584f, 0.11717731f, 0.03123666f, 0.17541748f, 0.08087062f, -0.14278641f, 
    0.04575425f, 0.12908751f, -0.01013419f, 0.12659404f, -0.05745899f, -0.02449545f, -0.05004425f, -0.06678927f, 
    0.21508348f, 0.16438834f, -0.01338260f, 0.14917815f, 0.02423897f, 0.05358306f, 0.03665596f, 0.19778903f, 
    0.06012635f, 0.01985948f, 0.05386245f, -0.09514923f, -0.29282627f, -0.08257460f, 0.07690037f, -0.17931196f, 
    0.00006535f, 0.05599389f, 0.09683380f, 0.10567894f, 0.05964464f, 0.01259329f, -0.05180880f, 0.03386586f, 
    -0.25572678f, 0.05900083f, 0.29097110f, 0.08686443f, -0.12466789f, 0.08823593f, 0.15826556f, 0.09740449f, 
    0.09949201f, 0.25573862f, 0.01142529f, 0.02498383f, 0.05408864f, 0.05598683f, 0.07757799f, 0.17190017f, 
    0.16120511f, 0.00587845f, 0.01285627f, -0.05617207f, 0.03622555f, -0.08555928f, -0.07525073f, 0.02163215f, 
    0.16210113f, 0.01306426f, 0.04390869f, -0.11285121f, -0.02942536f, 0.14117862f, 0.13138258f, 0.00235588f, 
    0.01313230f, -0.05558659f, -0.05484646f, 0.03139214f, 0.37473178f, 0.34508654f, -0.00010085f, -0.06127799f, 
    -0.08086526f, -0.00339463f, -0.05671233f, 0.07373636f, 0.05043789f, 0.04900752f, -0.01273478f, 0.05110740f, 
    0.13337278f, -0.26929680f, -0.10113609f, 0.07585187f, 0.06062632f, -0.00689610f, 0.12403747f, -0.13863398f, 
    -0.08828361f, -0.00384468f, 0.04017102f, 0.05304388f, 0.05013344f, -0.00225375f, -0.13403668f, -0.08761293f, 
    0.18610719f, 0.07216579f, -0.06619854f, 0.14359435f, -0.01821941f, 0.10321082f, -0.05172864f, 0.09196936f, 
    0.10234458f, 0.14523166f, -0.16343026f, 0.13826992f, 0.08274376f, -0.07365697f, 0.15327972f, -0.03032905f, 
    -0.03608604f, 0.11506819f, 0.06032734f, 0.04692220f, -0.18196869f, 0.15260620f, -0.02536275f, -0.02638822f, 
    -0.05403802f, 0.08034953f, 0.12065610f, -0.03504186f, 0.01538336f, 0.09093995f, 0.04090861f, 0.11708619f, 
    -0.41256246f, -0.21258822f, 0.11021437f, -0.01371385f, 0.00169784f, -0.10751142f, 0.09355218f, -0.01848655f, 
    0.02691774f, 0.06213780f, 0.06076203f, 0.08315923f, -0.30120814f, 0.04528034f, 0.23217526f, 0.11477868f, 
    -0.14533380f, -0.00701931f, 0.02858352f, -0.02548790f, -0.01087475f, 0.17510392f, 0.05197534f, 0.06588784f, 
    0.28615537f, 0.05806098f, -0.03106181f, 0.02812096f, -0.04854007f, 0.11466875f, 0.13062549f, -0.01387252f, 
    -0.02882898f, -0.02519033f, -0.06635302f, 0.01491434f, -0.37359399f, -0.24024953f, 0.10287815f, -0.10522795f, 
    0.05242643f, 0.03866227f, 0.05295548f, 0.07387348f, 0.01156627f, -0.11098816f, 0.07264184f, -0.09878583f, 
    0.16931011f, 0.07959731f, -0.04660314f, 0.00302628f, -0.08312582f, -0.07003316f, -0.00539627f, 0.15896250f, 
    0.03077772f, 0.08150446f, -0.04493570f, -0.20658503f, -0.14413121f, 0.03221128f, -0.09758317f, 0.21818243f, 
    -0.09905398f, -0.04621147f, 0.03398623f, 0.08207046f, 0.06555343f, 0.00075912f, 0.01293597f, -0.13992497f, 
    0.26914579f, 0.04493287f, -0.14613491f, 0.42233106f, 0.00411993f, -0.00713767f, 0.05537752f, 0.15065525f, 
    0.02258101f, 0.02206700f, 0.01569568f, 0.02099399f, 0.00524650f, -0.12779802f, 0.23428461f, 0.15975226f, 
    0.00471533f, 0.08735956f, 0.14431848f, 0.13008812f, -0.10626585f, 0.09891867f, 0.04429184f, -0.09977569f, 
    -0.09979945f, 0.16692713f, -0.11482596f, 0.05077339f, -0.08275473f, 0.13412352f, 0.05684484f, 0.08284280f, 
    0.18350533f, 0.15161987f, 0.14817651f, 0.11836933f, -0.28743079f, -0.07147819f, 0.11088324f, -0.09624416f, 
    0.03456219f, 0.02335865f, 0.10245584f, 0.00762606f, 0.13616663f, 0.02142574f, 0.22219510f, -0.01396121f, 
    -0.07153877f, -0.20034803f, -0.20672935f, -0.07291257f, -0.03634900f, 0.04187609f, -0.07281771f, 0.14853853f, 
    -0.00395903f, -0.10153088f, -0.10305559f, 0.02000004f, 0.00010324f, 0.22403933f, -0.22300111f, -0.07738542f, 
    -0.11296161f, 0.09573381f, -0.04155994f, 0.00809244f, 0.04699939f, 0.10080265f, -0.06761509f, -0.06928199f, 
    0.36954278f, -0.29902786f, -0.03084080f, 0.11020180f, -0.02019145f, -0.00414926f, -0.00875281f, -0.03823362f, 
    -0.00094680f, -0.03523472f, 0.09095055f, -0.06628478f, 0.24096940f, 0.04498921f, -0.21868111f, 0.16358176f, 
    -0.04855746f, -0.01616122f, -0.13991068f, 0.05366056f, -0.08724307f, 0.05130057f, 0.00248472f, 0.00307585f, 
    -0.16043323f, -0.34714437f, 0.01375503f, -0.16256253f, 0.03221542f, -0.02490470f, 0.26408187f, -0.00653191f, 
    -0.03564491f, 0.07086053f, 0.03211454f, -0.02273893f, 0.24644062f, -0.01842764f, 0.04566500f, -0.00662246f, 
    0.02587562f, -0.05781376f, 0.11119466f, 0.09218248f, 0.01144551f, 0.09342011f, -0.07502127f, 0.02774012f, 
    -0.08502415f, -0.25133321f, 0.10273829f, -0.23521115f, 0.02770594f, -0.05056969f, 0.11867771f, 0.08872677f, 
    -0.00437319f, 0.00237671f, -0.01009325f, 0.07011261f, 0.02262746f, -0.25699309f, 0.11155440f, 0.47160557f, 
    -0.02300869f, 0.00443558f, -0.00251617f, 0.05459123f, 0.16506910f, 0.08025251f, 0.02101505f, 0.11949545f, 
    0.08041259f, -0.06621134f, -0.03890270f, -0.01468488f, 0.01696306f, -0.05254562f, 0.05183583f, -0.16722377f, 
    -0.00287111f, -0.04283961f, 0.08852691f, -0.05497108f, 0.08363190f, -0.09674256f, 0.11252480f, -0.19858114f, 
    0.14135839f, -0.16062522f, 0.04815071f, 0.01164672f, 0.11165474f, -0.12142305f, -0.05151224f, 0.05794767f, 
    0.05312017f, 0.18121380f, 0.10905528f, 0.06654648f, -0.09967225f, -0.02243149f, 0.08309054f, 0.04344901f, 
    -0.04816729f, 0.05133625f, 0.15602693f, 0.23573028f, 0.26095343f, -0.10087303f, 0.19594915f, -0.15208519f, 
    -0.03784887f, 0.02295416f, -0.01180525f, -0.05037863f, -0.01690496f, 0.07750572f, 0.03787642f, 0.00337492f, 
    0.05006500f, 0.25356871f, 0.02773896f, -0.05445191f, -0.10638665f, 0.08677418f, -0.00881667f, -0.02753677f, 
    -0.06964114f, 0.01446169f, 0.05698272f, -0.03911812f, -0.03591289f, 0.00613607f, -0.02068746f, 0.12379418f, 
    0.08050129f, -0.02985666f, -0.02230755f, 0.02172698f, -0.04863903f, -0.02777503f, -0.08636551f, -0.10491705f, 
    -0.15781747f, 0.17355357f, 0.17036811f, 0.09630587f, 0.03938061f, -0.05494668f, -0.09327263f, 0.07575329f, 
    0.04134130f, -0.07314470f, -0.06458047f, 0.00505304f, 0.35630825f, -0.05755162f, 0.11004489f, 0.33437106f, 
    -0.11253615f, 0.08628635f, -0.10793141f, 0.05438684f, 0.03606454f, -0.03931874f, -0.09078790f, 0.09984453f, 
    0.22653180f, 0.11815624f, 0.22097516f, 0.07972884f, -0.07519457f, 0.07359033f, -0.01682271f, -0.12916622f, 
    -0.03250050f, 0.09805612f, 0.14681287f, 0.06273663f, 0.21815865f, 0.21919915f, 0.29196844f, 0.11574887f, 
    -0.04066404f, -0.07554549f, -0.01455113f, 0.06199344f, 0.01367933f, 0.00929910f, 0.00799912f, 0.12214701f, 
    -0.10739333f, 0.14473522f, 0.02253096f, -0.00458220f, -0.05368574f, -0.01531002f, 0.04563012f, -0.06891164f, 
    0.04446827f, 0.13926530f, 0.00887580f, 0.02433262f, -0.32939145f, -0.01298863f, 0.32638830f, -0.08447488f, 
    0.06787021f, -0.05292984f, 0.10934951f, -0.06526399f, -0.02202149f, -0.07230227f, -0.10526925f, 0.11332848f, 
    0.45451587f, 0.33256850f, -0.09337110f, 0.35007948f, 0.03087904f, 0.01546544f, -0.12130301f, 0.05186755f, 
    0.07424139f, 0.08311090f, 0.03728939f, -0.00853906f, -0.28441697f, 0.03316112f, -0.10841301f, 0.22732460f, 
    -0.06027303f, 0.06474926f, -0.02022596f, 0.00871881f, 0.04657335f, 0.03475598f, 0.11639050f, 0.11327020f, 
    0.08003628f, -0.00856234f, -0.31428146f, 0.22325070f, -0.05703698f, 0.01230792f, -0.07363862f, 0.08579241f, 
    0.08640003f, 0.21855219f, 0.06856792f, -0.04424853f, 0.05214141f, -0.15112741f, -0.13235870f, -0.00938085f, 
    -0.04975445f, 0.04009315f, -0.03884458f, 0.02848683f, -0.11914750f, -0.14640357f, 0.08618846f, 0.01649225f, 
    0.08860298f, 0.10667954f, 0.04093023f, 0.05973556f, -0.09136359f, 0.07885791f, -0.06030068f, 0.09531692f, 
    0.12007712f, 0.07568334f, -0.02180255f, 0.08696701f, -0.18068555f, -0.06164357f, -0.15220067f, 0.17859527f, 
    -0.07391301f, 0.05093171f, -0.08667668f, 0.11456001f, -0.03145917f, 0.05561860f, -0.07820702f, -0.07346266f, 
    -0.07046953f, 0.03800440f, 0.05360378f, -0.01105539f, -0.06839456f, -0.03821908f, -0.06182694f, 0.06140129f, 
    -0.06290190f, -0.05093199f, 0.05090842f, -0.04889693f, 0.04259017f, 0.00114583f, 0.00065167f, 0.04951397f, 
    0.00683861f, -0.04215959f, -0.07158437f, 0.06342015f, 0.06136957f, 0.04514930f, -0.07039683f, 0.04943016f, 
    0.02263572f, -0.03250781f, -0.05294590f, -0.01853200f, -0.04190160f, 0.04576024f, -0.07143145f, -0.04612610f, 
    0.02429391f, 0.03790640f, -0.05742823f, 0.02183246f, -0.03311310f, -0.01729081f, -0.06002064f, -0.02041297f, 
    -0.03122565f, 0.01537923f, -0.05716372f, -0.01792667f, 0.05855118f, -0.04402078f, 0.01653416f, 0.02249609f, 
    0.05252755f, 0.00776187f, -0.02874364f, 0.05665275f, -0.02637228f, -0.00676358f, -0.02840591f, -0.01641025f, 
    -0.03416330f, 0.00664341f, -0.01643943f, 0.01353297f, -0.07665142f, -0.02799609f, 0.03329311f, -0.06786194f, 
    -0.03867111f, -0.04089282f, -0.03633513f, -0.06335919f, -0.04797433f, 0.00536261f, 0.01009159f, 0.04459588f, 
    0.05590672f, -0.00334422f, 0.06251268f, -0.00946950f, -0.03788979f, -0.07072771f, -0.02816576f, -0.07556311f, 
    0.04042506f, -0.01838552f, 0.04276123f, 0.01054958f, -0.04905115f, 0.02743242f, -0.05563061f, 0.01037748f, 
    -0.00088913f, 0.06312878f, -0.03390383f, -0.00654314f, 0.04511209f, 0.02368370f, 0.04851496f, -0.00977193f, 
    0.06217423f, 0.05188634f, -0.04000054f, -0.01638843f, -0.02317723f, 0.05643372f, -0.03046890f, -0.01617148f, 
    -0.05904081f, 0.02025187f, -0.06081776f, 0.03703016f, -0.00030065f, -0.06706540f, 0.01748020f, 0.04489210f, 
    -0.01733360f, -0.04295815f, 0.02215845f, 0.01810719f, -0.05724033f, 0.03179017f, -0.05931359f, -0.00863290f, 
    -0.04047718f, 0.02562430f, -0.00451800f, -0.05924075f, -0.05589601f, 0.01874814f, 0.03845431f, 0.03413950f, 
    -0.04729503f, -0.00977541f, -0.02757335f, -0.03896308f, 0.00811740f, -0.02156585f, 0.06289016f, -0.06640676f, 
    -0.04807253f, -0.07027840f, 0.00016266f, 0.02138788f, 0.00683797f, 0.03913958f, -0.07051884f, 0.01600613f, 
    0.04666648f, -0.02133897f, -0.07240058f, -0.03510947f, -0.04056009f, -0.00047043f, 0.04062260f, -0.02380479f, 
    -0.05784634f, -0.00029957f, 0.05265800f, -0.00107464f, -0.06465694f, -0.00345853f, 0.00288785f, -0.00923814f, 
    -0.03424052f, 0.04688803f, -0.05148485f, -0.02837440f, 0.06042814f, 0.04199728f, -0.04780425f, 0.03810607f, 
    0.05075927f, -0.04583408f, 0.06471738f, -0.00759904f, 0.04531642f, -0.02310336f, 0.00392702f, 0.02618770f, 
    -0.00632333f, -0.02145343f, -0.03057673f, 0.06129731f, 0.02773775f, 0.03057146f, 0.00307560f, -0.05940946f, 
    -0.06171542f, -0.04924710f, -0.07347310f, -0.06083502f, -0.05449134f, 0.02387604f, -0.04368283f, 0.03010463f, 
    -0.19236156f, 0.09755105f, -0.21227589f, 0.03759594f, 0.00336273f, -0.00868210f, 0.00818335f, 0.09009513f, 
    0.21784668f, 0.14602798f, 0.11282040f, -0.19970869f, 0.14870615f, 0.01904681f, 0.09061093f, 0.10395528f, 
    0.05721007f, -0.03319453f, 0.04998182f, 0.04776168f, -0.01113198f, -0.04571669f, -0.00701980f, -0.02695769f, 
    0.18190888f, 0.11581128f, -0.26921868f, 0.29607397f, -0.01103193f, 0.01498339f, 0.01403311f, 0.10686536f, 
    0.09193710f, 0.04187738f, 0.03206497f, 0.00006661f, 0.13777077f, 0.08148209f, 0.13529429f, 0.13558926f, 
    0.08605994f, -0.01380237f, 0.07358355f, 0.01327021f, -0.06681058f, 0.09708633f, 0.02204602f, -0.00016100f, 
    -0.09850964f, 0.15170535f, 0.00338080f, 0.15054840f, -0.03442998f, 0.08723579f, 0.08785220f, 0.04797745f, 
    0.08806934f, 0.07503083f, 0.05875355f, 0.04922116f, -0.05870430f, -0.24716096f, 0.19925597f, 0.15129077f, 
    -0.01868889f, 0.12861277f, 0.09075028f, 0.02073855f, -0.04448475f, 0.03123648f, 0.24605145f, 0.03001262f, 
    -0.06470589f, 0.01871555f, -0.04245469f, 0.08750382f, -0.13029508f, 0.09817050f, 0.10083066f, 0.07740632f, 
    -0.02089503f, -0.11370595f, -0.05938595f, 0.03247965f, -0.11445885f, 0.05702687f, 0.15196911f, 0.00034468f, 
    -0.09622067f, -0.00553047f, -0.12398082f, 0.15946311f, 0.09047552f, 0.04379629f, -0.00281033f, 0.14866176f, 
    0.13169305f, -0.11235870f, -0.03804993f, -0.09783585f, 0.07551146f, -0.00734375f, -0.04621355f, 0.02678461f, 
    0.07917013f, 0.04591502f, 0.15323493f, -0.16429773f, -0.45777944f, 0.13546751f, -0.08385374f, -0.02716300f, 
    0.05590939f, -0.09341494f, 0.03177813f, 0.06694197f, 0.04150598f, 0.14143877f, -0.06629115f, 0.06375055f, 
    0.06885854f, -0.25004172f, -0.00961573f, 0.17490703f, -0.04830311f, -0.06551511f, 0.09710024f, 0.22725734f, 
    0.11238313f, 0.05560464f, 0.02789932f, -0.02692208f, -0.08255424f, -0.15508367f, -0.07332552f, -0.06321631f, 
    0.03147670f, -0.09623291f, 0.07841101f, -0.09948866f, -0.05426844f, 0.01651986f, -0.00523562f, 0.14058688f, 
    0.19342077f, -0.09323723f, -0.00105465f, -0.08863859f, 0.00287843f, 0.00396097f, 0.09525048f, 0.11930531f, 
    0.05702943f, 0.07765250f, 0.07996027f, -0.02556653f, 0.08424360f, -0.28134230f, 0.01384437f, 0.22734225f, 
    0.06846967f, 0.03868295f, 0.04561529f, 0.03182720f, -0.03275110f, -0.12261448f, 0.16408789f, 0.12447940f, 
    0.16004637f, -0.19932657f, 0.04903660f, 0.02408630f, -0.23041870f, -0.07497379f, -0.06007165f, 0.01595811f, 
    0.11549497f, 0.19145350f, 0.18575135f, -0.00117801f, 0.09718811f, -0.07355353f, 0.06395242f, -0.07506500f, 
    0.14885773f, -0.06864098f, -0.03724040f, 0.11363395f, 0.12183730f, -0.08949316f, -0.04011752f, 0.09076089f, 
    -0.06672423f, -0.06698287f, -0.10357691f, -0.12123259f, 0.00458801f, 0.09159660f, 0.02031864f, 0.04587516f, 
    0.00639241f, 0.09068894f, 0.03099966f, -0.19760621f, 0.05312652f, 0.12540063f, -0.02840163f, 0.08750948f, 
    0.09076969f, -0.04532412f, -0.01538222f, 0.01334091f, 0.11531094f, 0.06414198f, -0.04342143f, -0.11375613f, 
    -0.12357689f, -0.07368928f, -0.11469870f, 0.04646021f, 0.12846531f, -0.04255162f, 0.01346234f, 0.02640008f, 
    -0.02090601f, 0.02843189f, -0.04521384f, 0.11382524f, 0.12013347f, 0.21379149f, 0.21536592f, -0.02873314f, 
    0.07405999f, -0.01883306f, -0.00753673f, 0.08090052f, 0.00981209f, 0.02460358f, -0.06790171f, 0.00107891f, 
    0.12521023f, -0.00628501f, 0.02888821f, -0.02880701f, 0.09491184f, 0.02552595f, 0.03362460f, 0.03890507f, 
    0.10905842f, -0.07220177f, 0.08286387f, 0.04702420f, -0.09159705f, -0.12413481f, 0.10435680f, -0.14264068f, 
    0.04062168f, -0.05790965f, 0.07405763f, 0.05124300f, -0.08223160f, 0.12397269f, 0.17109020f, 0.16097955f, 
    -0.34213731f, 0.11020768f, 0.02275887f, 0.07947715f, -0.06439840f, 0.04983799f, 0.03883205f, 0.18009096f, 
    -0.10181144f, -0.03623920f, -0.00252889f, 0.08671258f, -0.29370773f, -0.19691460f, -0.05960104f, -0.02090749f, 
    0.15058506f, 0.08385435f, -0.09367023f, 0.02254979f, 0.10062621f, -0.07624912f, 0.01684798f, -0.01621289f, 
    -0.01340486f, -0.22901057f, 0.18743616f, -0.26288345f, -0.03342335f, 0.05833817f, -0.03450711f, 0.00545722f, 
    0.16238829f, -0.07597898f, -0.02578893f, -0.02257580f, 0.15002209f, -0.18209098f, -0.13507311f, -0.05966838f, 
    -0.12044328f, -0.07994771f, 0.00601441f, -0.03790981f, 0.04594561f, -0.00066780f, 0.00784995f, 0.00423231f, 
    -0.22759031f, -0.21408862f, 0.14430557f, 0.03968188f, -0.00033702f, -0.02851366f, 0.06879982f, -0.00034607f, 
    -0.00674120f, 0.05954580f, -0.05296496f, 0.02626245f, 0.10669532f, -0.25101903f, -0.05971314f, -0.05976377f, 
    -0.05242845f, 0.02389716f, -0.05265264f, -0.08196503f, -0.07230335f, -0.02936411f, -0.03423671f, -0.01088658f, 
    -0.10892107f, 0.13617243f, 0.10614946f, 0.15162617f, 0.10115253f, 0.07298348f, 0.02853956f, 0.11763590f, 
    -0.06820804f, 0.02617916f, -0.09513074f, -0.00645799f, 0.02869364f, 0.09062152f, 0.05296953f, -0.02763342f, 
    0.05797138f, -0.04702656f, 0.14269871f, -0.02880157f, -0.06264040f, -0.05756748f, 0.05979081f, 0.02785841f, 
    -0.35614768f, -0.03253105f, -0.05970897f, -0.13884349f, 0.05914437f, 0.06626855f, 0.03735609f, 0.01604512f, 
    0.01239927f, 0.02911682f, -0.02056795f, 0.07484639f, 0.17423475f, 0.27276939f, 0.10380137f, 0.12741399f, 
    0.09936886f, 0.00805867f, 0.06120636f, -0.13529517f, 0.17415157f, 0.00815329f, 0.01105678f, 0.05866245f, 
    0.38776919f, 0.05147339f, -0.12276235f, 0.01894945f, -0.09390440f, 0.00048547f, 0.03964341f, 0.02533412f, 
    -0.03413529f, 0.03054050f, -0.08928485f, -0.15148075f, -0.09381265f, 0.07572670f, -0.02210515f, -0.14702925f, 
    0.02401292f, 0.03439173f, -0.10258277f, 0.00123618f, 0.15207911f, 0.04980817f, 0.02900899f, 0.05031896f, 
    -0.05796599f, 0.03274484f, 0.22731660f, -0.02021721f, 0.01539025f, -0.16836798f, 0.01545092f, -0.18450110f, 
    0.06134611f, 0.04915661f, 0.10979059f, 0.12231609f, 0.11762545f, 0.16732226f, 0.00925334f, -0.02471328f, 
    0.01766389f, 0.01682607f, -0.01500825f, -0.08523530f, 0.01737924f, 0.03337418f, -0.06119730f, 0.06633452f, 
    -0.00763855f, 0.00698436f, -0.05186060f, 0.05589851f, 0.14638704f, -0.04924308f, -0.08115287f, 0.04584449f, 
    0.03391092f, -0.05770402f, 0.08456827f, 0.21911918f, 0.10709105f, -0.16110381f, -0.25523892f, -0.20157973f, 
    0.13033743f, -0.00723615f, -0.07552405f, 0.00545513f, -0.00904919f, 0.12797092f, 0.12020841f, -0.11366469f, 
    -0.03522040f, 0.05702699f, 0.17586772f, -0.02031994f, 0.09048031f, -0.13054338f, -0.01145216f, 0.11199323f, 
    -0.00379088f, 0.10987169f, -0.02025695f, -0.04247257f, -0.06241583f, -0.05315067f, -0.24653585f, 0.05779013f, 
    0.10951255f, 0.05863280f, 0.05983177f, -0.12566477f, 0.01624686f, -0.21797059f, 0.06880356f, -0.04783837f, 
    -0.11768077f, -0.11227629f, 0.19524963f, 0.06337364f, -0.10525800f, 0.06171924f, -0.07077344f, 0.10775922f, 
    0.14539973f, -0.09163266f, -0.05231513f, 0.02813068f, 0.68202966f, -0.34665766f, 0.05644241f, -0.08089738f, 
    -0.23648839f, 0.05615493f, -0.02944052f, 0.01365470f, 0.08965171f, 0.01932524f, 0.12544908f, -0.00818247f, 
    -0.23888606f, 0.05923223f, -0.05651059f, -0.16392255f, 0.20041767f, 0.12363715f, 0.09219102f, -0.06954328f, 
    -0.01573391f, 0.12440749f, 0.08233050f, -0.01887082f, 0.18053800f, 0.14831084f, -0.00233533f, 0.07783064f, 
    -0.06092092f, -0.15279496f, -0.09228206f, -0.00773031f, -0.13450205f, -0.02850600f, 0.03671522f, -0.00503059f, 
    -0.40087333f, -0.04170702f, 0.02961228f, 0.12154605f, 0.22413823f, 0.03735603f, -0.02962325f, -0.08645594f, 
    0.01656769f, 0.07507952f, -0.08878538f, 0.05427505f, -0.23265594f, 0.07374845f, 0.26836178f, -0.20006324f, 
    0.15104744f, 0.06497591f, 0.09778018f, 0.01701019f, -0.00385858f, 0.11092007f, 0.13166311f, 0.05605095f, 
    -0.28791967f, 0.18909009f, -0.03117639f, -0.06020229f, 0.11350507f, 0.10164391f, 0.07958433f, 0.05983492f, 
    -0.11016967f, -0.00796829f, -0.07841749f, 0.07190292f, 0.13843529f, 0.13662614f, 0.15712294f, 0.13652718f, 
    0.03112218f, 0.11854954f, 0.05394014f, -0.11389843f, 0.02478869f, -0.14557196f, 0.11323420f, 0.12703572f, 
    -0.01888325f, 0.02206501f, -0.02981994f, -0.00353857f, 0.01481008f, 0.03523375f, -0.05510208f, 0.00883174f, 
    -0.05813059f, -0.04327853f, -0.06558406f, -0.06168873f, 0.01871859f, -0.06997491f, 0.02854666f, -0.05873269f, 
    -0.08448641f, 0.00740933f, 0.02388364f, -0.02432119f, -0.01627368f, -0.00162743f, -0.04686967f, -0.07589178f, 
    0.04459537f, 0.04733782f, -0.04381239f, 0.01613552f, -0.11352155f, -0.03155106f, -0.08032440f, -0.00089844f, 
    -0.04868544f, 0.03426192f, -0.01655879f, 0.00709696f, -0.02416697f, -0.01383393f, -0.08263294f, -0.01549132f, 
    -0.04961144f, 0.00640700f, -0.02793585f, 0.04160666f, -0.07612046f, -0.08530286f, -0.00569960f, 0.00925713f, 
    0.02801230f, 0.00388383f, 0.02581662f, -0.06889739f, -0.03092695f, -0.03104399f, -0.09133796f, 0.02005280f, 
    -0.07848159f, -0.06894077f, -0.03238559f, 0.02997295f, -0.08231488f, -0.11265518f, -0.09725339f, 0.04383335f, 
    0.05847416f, -0.03347909f, -0.04486008f, 0.03115403f, 0.00324887f, -0.03042878f, -0.11161444f, -0.08754878f, 
    -0.02774199f, -0.07373285f, 0.06414736f, 0.00401879f, 0.04296805f, -0.07403407f, -0.04671007f, -0.03515358f, 
    -0.06889815f, 0.00177991f, -0.02822847f, -0.03111598f, 0.06445041f, -0.06727903f, -0.02359807f, -0.10815826f, 
    0.05498791f, 0.02141556f, -0.01729858f, -0.09025391f, -0.05737351f, -0.01693578f, -0.05422163f, -0.02337332f, 
    -0.01053704f, -0.04891838f, 0.07387547f, 0.02982304f, -0.08263648f, 0.01109447f, -0.04427394f, -0.07001429f, 
    0.05354877f, -0.02942296f, 0.02646410f, 0.04666055f, 0.00788875f, -0.02813107f, -0.03957853f, 0.00163514f, 
    0.02979854f, -0.05022375f, 0.04806345f, 0.01252361f, 0.00238218f, -0.01146385f, -0.08025526f, 0.04317283f, 
    -0.02415839f, -0.01097331f, 0.02050372f, -0.05930047f, -0.07985699f, 0.03857637f, 0.04285979f, 0.02493360f, 
    -0.01624527f, 0.02343371f, -0.06234115f, 0.04758649f, -0.04793387f, -0.01409162f, -0.03705048f, 0.00352416f, 
    0.04307534f, 0.00243277f, -0.05878412f, -0.01388193f, -0.06578070f, 0.00547297f, -0.00421762f, 0.03292799f, 
    -0.08417264f, -0.06649446f, -0.11264157f, -0.04460855f, -0.01504818f, -0.03154445f, 0.00700752f, -0.00949013f, 
    -0.00472286f, -0.03133585f, -0.09887651f, 0.04837444f, -0.05626356f, -0.06667373f, -0.00568757f, -0.06717780f, 
    0.00003250f, -0.08649092f, 0.02905541f, 0.06602720f, -0.00752276f, 0.01567367f, -0.08913352f, 0.00996765f, 
    -0.01626582f, -0.01228308f, 0.02188163f, -0.02686609f, -0.11489603f, 0.00276122f, -0.03284470f, 0.01290363f, 
    0.06981587f, -0.00258804f, -0.00657687f, 0.07178077f, 0.02709558f, -0.02967073f, 0.01254265f, -0.04920678f, 
    0.07795049f, -0.04624910f, -0.06384745f, -0.07219411f, -0.03619699f, 0.00909282f, -0.07132836f, -0.00641260f, 
    -0.04403875f, 0.04520036f, -0.02566045f, -0.02863153f, -0.01823744f, -0.03865412f, 0.02271170f, 0.06475105f, 
    -0.06589692f, -0.00531858f, -0.01565760f, -0.05063841f, 0.00700582f, 0.01604785f, -0.01175711f, -0.00158983f, 
    0.06366568f, -0.00362064f, -0.05044976f, 0.00158445f, -0.05896331f, -0.01535991f, 0.03414768f, -0.06563327f, 
    -0.01544075f, -0.00268264f, 0.04100011f, -0.05318484f, 0.04836075f, 0.06286428f, 0.01861056f, 0.04946811f, 
    -0.04679696f, -0.01589749f, -0.06972865f, -0.05502447f, -0.06813264f, 0.00497634f, 0.02431738f, 0.06072921f, 
    0.05334160f, 0.01221212f, -0.06549581f, -0.02368966f, -0.03117962f, 0.01131270f, 0.01676712f, -0.01357950f, 
    0.06880166f, 0.01194420f, 0.06786263f, -0.02942860f, -0.04564980f, -0.07091108f, -0.02666576f, 0.01706638f, 
    -0.01008042f, -0.06496254f, -0.06587204f, 0.01345008f, 0.02891376f, -0.05884853f, 0.06372833f, 0.02156653f, 
    -0.01788438f, 0.06894698f, -0.06404572f, -0.04641786f, -0.06893286f, -0.00130202f, -0.01304939f, -0.04422256f, 
    -0.02863128f, 0.01102675f, 0.06449094f, -0.02214678f, -0.01400351f, -0.06314246f, 0.02032861f, 0.03757957f, 
    -0.05285452f, -0.05415583f, -0.04370412f, -0.06119733f, -0.03840355f, 0.06934556f, -0.03165571f, 0.02371863f, 
    0.03822276f, 0.02614920f, -0.02419000f, 0.06085007f, -0.07118212f, 0.02318644f, 0.04853356f, -0.05034554f, 
    -0.03690883f, -0.04873627f, -0.06064392f, 0.05754536f, -0.00230092f, -0.01790282f, 0.00327727f, -0.04267976f, 
    -0.03361887f, 0.05380914f, -0.00096866f, 0.01351103f, -0.06842906f, -0.04796878f, -0.04831374f, -0.04109282f, 
    -0.04802730f, -0.03900739f, -0.00510743f, -0.01395272f, -0.03891031f, 0.07210157f, 0.02622105f, 0.03514697f, 
    -0.01299292f, 0.06168896f, 0.01611398f, 0.02696852f, 0.06501837f, 0.01788272f, -0.04927838f, -0.05899071f, 
    -0.00524819f, -0.03529325f, 0.00020252f, -0.01488528f, -0.01921223f, -0.05155415f, 0.03817203f, -0.05692409f, 
    -0.02048141f, 0.06438167f, 0.06655384f, 0.00702711f, -0.05791283f, 0.06698753f, -0.03712309f, -0.01702981f, 
    -0.03437256f, 0.03725747f, 0.00704647f, 0.02836131f, 0.05844142f, 0.02172679f, 0.02254488f, 0.02856754f, 
    -0.02374592f, -0.00167239f, -0.00177026f, -0.05838378f, -0.04636836f, -0.02084016f, -0.05068385f, 0.00154854f, 
    0.04459963f, -0.00906078f, -0.06089116f, 0.01400089f, -0.01201885f, 0.01918243f, 0.00915643f, -0.03235831f, 
    0.02772786f, -0.00908000f, -0.04122331f, -0.01909576f, -0.03820711f, 0.00771458f, 0.00716059f, -0.05908866f, 
    -0.01303407f, 0.04096002f, -0.00281846f, -0.04614042f, -0.04057644f, -0.02496774f, -0.06210300f, -0.00221253f, 
    0.04315080f, -0.02925050f, -0.05383257f, 0.00138614f, -0.01433082f, -0.03342060f, 0.00904993f, 0.01719857f, 
    -0.06548796f, 0.03594790f, 0.17732440f, 0.12324128f, -0.03277736f, -0.03054675f, 0.07053611f, -0.03170124f, 
    -0.05031668f, -0.05066824f, 0.02509723f, 0.18726729f, 0.00098599f, -0.01529906f, 0.01715224f, -0.13110337f, 
    0.08221867f, 0.07472241f, -0.01402594f, -0.05868768f, -0.00668422f, 0.09209314f, 0.06866913f, 0.08042035f, 
    0.10306302f, 0.08282167f, 0.06159611f, -0.10927214f, -0.15999436f, -0.00735058f, -0.03591482f, 0.02200827f, 
    -0.02003041f, -0.01681626f, -0.04038087f, -0.11450893f, -0.13383056f, -0.14288788f, -0.11543088f, -0.03174386f, 
    0.03893680f, 0.00932275f, 0.03504824f, -0.02535660f, 0.07482236f, -0.06094981f, 0.02433969f, 0.05251344f, 
    -0.09818341f, -0.11581406f, 0.11118380f, 0.10558470f, -0.10697559f, -0.05463971f, -0.04056530f, 0.06194896f, 
    -0.03560002f, 0.08494229f, 0.03684387f, 0.03636065f, 0.14974935f, 0.06658489f, 0.07645919f, 0.16631769f, 
    0.03235058f, 0.00995898f, -0.06154577f, 0.00852758f, -0.00829371f, -0.11881663f, -0.10606027f, 0.07819958f, 
    0.31507853f, 0.10587466f, -0.04238267f, -0.02797443f, 0.05746343f, 0.00945546f, 0.01299983f, -0.19338477f, 
    0.07230096f, 0.00085108f, 0.12627466f, -0.01987774f, 0.18943776f, 0.19643191f, 0.25249261f, 0.09774834f, 
    -0.06135736f, 0.03239409f, -0.00921932f, 0.03870735f, 0.01655533f, 0.07862493f, 0.06684830f, 0.14860384f, 
    -0.14469449f, 0.32938099f, -0.10136712f, 0.21023861f, 0.02474733f, 0.03176576f, 0.12309523f, -0.11107400f, 
    0.00572953f, 0.02277642f, -0.01022431f, -0.01617733f, -0.28719142f, 0.22328065f, 0.06608655f, 0.09889957f, 
    0.12777710f, 0.10300619f, 0.03121358f, -0.01574871f, 0.06813178f, 0.08679302f, -0.14602955f, -0.00501203f, 
    0.21967436f, 0.10269851f, 0.02424063f, 0.20204252f, -0.03000562f, 0.11924048f, -0.05712515f, -0.01051565f, 
    0.18971914f, 0.06288411f, 0.03930633f, 0.14275974f, -0.11057451f, 0.21800141f, 0.05557538f, -0.02078891f, 
    -0.07819577f, 0.19783132f, 0.14278303f, -0.02360677f, 0.07276646f, 0.01759666f, 0.07505856f, -0.05806494f, 
    0.14047652f, 0.07834108f, 0.05107366f, 0.08177115f, 0.04447178f, -0.01608848f, -0.05788223f, -0.05730174f, 
    0.13212341f, 0.03981394f, 0.17535098f, 0.00003405f, -0.06202113f, 0.09539150f, -0.05866744f, -0.11379929f, 
    0.02061683f, 0.04727690f, -0.03672091f, 0.01493131f, 0.03734891f, 0.03782088f, -0.04442556f, -0.08266479f, 
    0.27587065f, -0.03483927f, 0.00742229f, 0.09840636f, -0.02167989f, -0.03105042f, -0.07813375f, -0.05048838f, 
    -0.00304993f, -0.06812122f, -0.02877152f, -0.04723810f, -0.21418302f, -0.06096417f, -0.04666322f, 0.01642533f, 
    -0.00225456f, 0.10615012f, -0.01749619f, 0.00279384f, -0.02973071f, 0.12115789f, -0.01209710f, -0.04259018f, 
    0.27299792f, 0.11152498f, -0.00695700f, -0.17318192f, -0.07273567f, -0.22988985f, 0.06386779f, -0.05492070f, 
    0.03710226f, -0.05577721f, -0.02574416f, 0.20312239f, 0.03191562f, -0.00149203f, -0.01479923f, 0.28906757f, 
    -0.00028539f, 0.05534420f, -0.10488988f, -0.08973189f, -0.02458600f, -0.01260632f, 0.10311251f, 0.06646024f, 
    0.00151191f, -0.11738492f, -0.01433867f, -0.06092488f, -0.10049920f, -0.01081403f, -0.09326410f, -0.01233800f, 
    -0.06785268f, 0.00385518f, 0.02224767f, -0.09270351f, 0.04241668f, -0.18098305f, 0.02333343f, 0.09409099f, 
    0.05758190f, 0.07118842f, -0.05044229f, -0.15581572f, -0.02326367f, -0.12636879f, -0.00937210f, -0.04820378f, 
    -0.35762739f, 0.30405483f, 0.04769056f, 0.05640462f, -0.05220827f, 0.05098714f, -0.05934120f, 0.06291031f, 
    0.17561601f, 0.01480998f, -0.01144628f, 0.09099825f, -0.05211047f, 0.04654602f, -0.00317448f, -0.24109820f, 
    0.08485258f, -0.01412310f, 0.06819485f, -0.10194635f, 0.14438464f, -0.01742077f, -0.10183176f, -0.11021008f, 
    0.27636591f, -0.10570192f, -0.13900498f, -0.04901192f, 0.13731572f, -0.09775633f, -0.15733668f, 0.02067148f, 
    0.08080290f, 0.08717644f, 0.23140462f, 0.02332041f, 0.06913336f, 0.13639875f, 0.02012036f, -0.07291699f, 
    -0.13462721f, -0.03891639f, 0.01050363f, 0.03372895f, 0.12877859f, 0.14517148f, 0.03828059f, -0.09584374f, 
    0.19905873f, 0.05429529f, -0.01030099f, 0.12877320f, -0.01656370f, -0.04578498f, 0.06360576f, 0.03931282f, 
    -0.11703002f, 0.11418843f, 0.09264731f, 0.14732777f, 0.13735127f, -0.02233531f, -0.12461632f, 0.00711684f, 
    -0.03853511f, -0.20263219f, 0.00786741f, 0.05697651f, 0.00064734f, -0.10440405f, -0.00105408f, 0.06899761f, 
    0.25858229f, 0.12287337f, -0.03425782f, -0.18539329f, 0.01065857f, -0.11061840f, -0.07171009f, -0.16206028f, 
    0.00209097f, 0.15904137f, -0.07796488f, 0.02472378f, 0.34238660f, 0.31907445f, 0.15783288f, 0.04956169f, 
    -0.13266876f, 0.01470504f, 0.10395242f, 0.04989597f, 0.07633355f, 0.00795771f, 0.12143406f, 0.15319924f, 
    -0.27267197f, -0.15670717f, 0.02117242f, -0.08350934f, -0.14270721f, -0.00810571f, 0.02013407f, -0.16128975f, 
    0.13324235f, 0.02721926f, 0.04572554f, -0.07490867f, -0.02366068f, -0.18399931f, 0.08952624f, 0.28319088f, 
    0.13091180f, 0.07418138f, -0.04854005f, 0.00483188f, 0.07531891f, 0.13119911f, -0.03654815f, -0.08700653f, 
    -0.10816708f, -0.37316677f, -0.14363897f, -0.10021138f, -0.01112441f, 0.00837240f, 0.09978889f, 0.05746164f, 
    0.04697489f, 0.08243141f, -0.01894446f, 0.06166395f, -0.30960640f, -0.07255891f, -0.00340344f, -0.07713179f, 
    -0.17781109f, 0.08484296f, 0.10727664f, 0.02547839f, -0.07387453f, 0.04840520f, 0.04697359f, 0.00308132f, 
    0.19597185f, 0.12657063f, 0.01007875f, 0.15198855f, -0.10374319f, -0.02495247f, -0.03527916f, 0.05898558f, 
    -0.00400948f, 0.14322981f, 0.03233668f, -0.06568096f, 0.05777077f, -0.04980169f, -0.09211493f, 0.02656821f, 
    0.05497229f, -0.22306597f, -0.00554916f, -0.01584972f, 0.07266463f, 0.06046403f, 0.07772258f, -0.01107047f, 
    0.18716700f, 0.22060414f, 0.16645284f, 0.30644664f, -0.01716713f, 0.01933222f, 0.08633018f, 0.07261973f, 
    0.03560778f, -0.03213261f, -0.01152856f, 0.10289394f, 0.16502823f, -0.19831271f, 0.02596833f, 0.23614627f, 
    0.05063865f, -0.03031828f, -0.05377340f, -0.00600744f, -0.02916211f, 0.04554411f, -0.10619605f, -0.08885182f, 
    -0.15299544f, 0.02795090f, -0.17752001f, -0.05791133f, -0.00552462f, 0.05794811f, -0.05380008f, 0.01025685f, 
    0.02631399f, 0.07876546f, 0.01970385f, 0.07893310f, 0.16764557f, 0.07250845f, -0.03606180f, -0.05711424f, 
    0.00364561f, 0.04120069f, -0.08326995f, -0.14337809f, 0.14421809f, 0.00316034f, 0.10794574f, -0.03633893f, 
    0.21195999f, -0.08129048f, -0.02305743f, 0.03237392f, -0.00819219f, -0.04965234f, 0.01965318f, 0.07838719f, 
    0.05606898f, -0.03230439f, 0.09827255f, -0.09998773f, 0.05360923f, 0.08642109f, 0.03546992f, 0.07881631f, 
    -0.15120819f, 0.04019425f, 0.02702284f, 0.17072475f, -0.12349604f, 0.06971499f, -0.08478775f, 0.05558395f, 
    0.28772375f, 0.13410628f, 0.04879275f, 0.24025951f, -0.17848422f, -0.03724745f, 0.04552047f, -0.03852599f, 
    -0.05823524f, -0.06136214f, 0.04283550f, 0.03522893f, 0.14877106f, 0.02617772f, 0.26620981f, 0.11759213f, 
    -0.07029530f, 0.04055726f, 0.02951804f, 0.06435817f, -0.01866766f, -0.07589298f, -0.06826138f, 0.16146018f, 
    0.08457459f, 0.11270489f, -0.19728772f, 0.07358606f, 0.05581703f, -0.05172953f, 0.04330460f, -0.01382460f, 
    0.01953793f, 0.00642730f, 0.03875523f, 0.09941835f, 0.34409106f, 0.21878046f, -0.07453107f, 0.11747349f, 
    -0.04456619f, -0.14411882f, 0.00065605f, 0.04192232f, -0.05448073f, 0.03951339f, -0.02032702f, 0.12158164f, 
    0.04497885f, -0.25713274f, -0.20899160f, -0.15299684f, 0.01068312f, -0.07248387f, -0.06928076f, -0.00118315f, 
    0.03565752f, 0.01796810f, 0.08473265f, 0.12186199f, 0.12391967f, -0.46190602f, -0.10636412f, 0.26650465f, 
    -0.07884103f, 0.05100621f, -0.09881990f, -0.03353636f, 0.08966479f, -0.09969179f, 0.02358807f, -0.03038360f, 
    0.11409561f, 0.07058197f, 0.12222484f, 0.11610585f, -0.05658483f, 0.07829213f, 0.03243625f, 0.00569361f, 
    -0.10559787f, -0.10512184f, 0.01215841f, -0.06552861f, 0.21350133f, -0.14865392f, -0.08077274f, -0.17589715f, 
    0.11341754f, -0.10580690f, -0.12666810f, -0.06251816f, 0.03222618f, -0.12721163f, -0.14128742f, 0.09643587f, 
    -0.03733665f, 0.11263601f, 0.05639258f, 0.11927995f, 0.06863528f, -0.07803841f, -0.01377888f, 0.00182378f, 
    0.13269916f, -0.03042889f, 0.06813941f, 0.15991154f, 0.18150945f, 0.15309903f, -0.08431129f, 0.02650887f, 
    -0.04447002f, 0.04017136f, 0.00317002f, 0.01294280f, 0.10038632f, -0.00957142f, 0.09482677f, 0.18815348f, 
    0.11347194f, 0.04608471f, -0.25400475f, 0.01379489f, -0.10997505f, -0.13616242f, -0.01555996f, 0.03684182f, 
    -0.02830066f, 0.04346913f, -0.01873637f, -0.19609173f, 0.35140342f, -0.04443304f, 0.09038858f, 0.25282601f, 
    -0.08851423f, -0.03483887f, 0.07361286f, 0.03460513f, 0.08503771f, 0.15955994f, -0.00841541f, 0.05294969f, 
    0.31352761f, 0.08017443f, -0.09253622f, -0.04853055f, 0.00955174f, -0.13392559f, 0.01790162f, 0.00281048f, 
    -0.08173704f, 0.07373068f, -0.09107092f, -0.15666452f, -0.29669392f, 0.05716124f, -0.17638278f, -0.09192504f, 
    -0.06306826f, 0.10699227f, 0.10299169f, -0.04990323f, 0.10836525f, -0.17184676f, 0.00724175f, -0.03521628f, 
    -0.14228070f, -0.18577214f, -0.11726484f, 0.04028420f, 0.08132008f, 0.00279310f, -0.05266187f, 0.01126482f, 
    0.15211727f, 0.10611714f, -0.03669951f, -0.10387243f, 0.00787473f, -0.15069874f, -0.08698445f, -0.00859049f, 
    -0.17115457f, 0.01500488f, 0.11160267f, -0.01207344f, -0.11444925f, 0.24657989f, -0.20096837f, -0.03646805f, 
    0.20990413f, 0.03042594f, 0.01600148f, -0.06543032f, 0.18878809f, 0.01195243f, 0.01605722f, 0.05618197f, 
    -0.01533165f, 0.14735381f, 0.02431161f, 0.03996844f, 0.02463685f, 0.19156042f, 0.00456150f, 0.12779750f, 
    0.00195083f, 0.04562028f, -0.04341175f, 0.03762886f, -0.02160547f, -0.04374844f, 0.02067923f, -0.05366936f, 
    -0.05738018f, -0.20200936f, 0.11827322f, -0.16383362f, -0.01556890f, 0.05418814f, 0.01225883f, -0.09247434f, 
    -0.21604151f, -0.02456701f, -0.02288157f, 0.04009099f, 0.17431371f, -0.11374082f, 0.22057420f, 0.03201288f, 
    0.09603195f, -0.03704894f, 0.05000754f, 0.11024658f, -0.00800562f, 0.06571640f, -0.08693652f, -0.03897095f, 
    0.42101768f, 0.19498207f, -0.16456695f, -0.25110313f, 0.00055829f, -0.05829652f, 0.12156544f, -0.04565328f, 
    0.07450459f, -0.05581966f, 0.12086494f, 0.08338320f, 0.51412618f, 0.22250964f, -0.24096231f, 0.00614778f, 
    0.00870053f, -0.04128876f, -0.03960571f, 0.01910508f, 0.04065937f, -0.06466593f, -0.05804760f, 0.06674981f, 
    0.01207500f, 0.10619368f, 0.04171501f, -0.03160352f, -0.03943296f, -0.07265441f, 0.01927784f, 0.12069220f, 
    0.10265085f, -0.00913944f, 0.04237358f, 0.09540037f, 0.33072278f, 0.16237658f, 0.08919553f, -0.13127165f, 
    -0.03361432f, -0.06362514f, 0.07654393f, -0.00513438f, -0.04453073f, -0.01284843f, -0.01560842f, -0.11061399f, 
    0.15854111f, 0.21519753f, -0.12038697f, -0.00091517f, -0.10716765f, 0.01032238f, 0.07003824f, 0.06761996f, 
    -0.02740582f, 0.07036305f, 0.06797598f, -0.12484159f, 0.15222113f, 0.02795945f, 0.14215526f, -0.18335782f, 
    0.11048052f, -0.07646485f, -0.07728238f, -0.03906076f, 0.05909819f, 0.01688114f, 0.01510195f, -0.03981090f, 
    0.13968903f, 0.21284525f, 0.18340600f, 0.10712548f, 0.01561622f, 0.04466943f, -0.02801015f, -0.00730809f, 
    0.09535230f, -0.05345227f, 0.06390069f, 0.11081425f, 0.03993846f, -0.16072401f, 0.10281767f, 0.20739363f, 
    0.00262948f, -0.03886002f, 0.03167746f, 0.06345145f, -0.11240850f, -0.04492641f, -0.17429027f, -0.02143377f, 
    -0.07673345f, 0.23257262f, 0.02317073f, 0.25209311f, 0.20383114f, 0.10938276f, -0.04979036f, 0.04562939f, 
    0.14320041f, -0.02292637f, -0.01390808f, 0.27853924f, 0.22353892f, -0.04555729f, -0.03763558f, 0.09298404f, 
    0.07088792f, 0.02798987f, -0.00394754f, 0.07782056f, -0.02295403f, 0.14073357f, 0.15737756f, -0.03045388f, 
    -0.00861180f, 0.04174722f, 0.23471929f, -0.04832446f, -0.06142762f, 0.08599520f, 0.03613180f, 0.21443421f, 
    -0.05383347f, 0.01271705f, 0.15808474f, 0.10379557f, 0.11061617f, 0.03740727f, 0.05124645f, 0.07780562f, 
    -0.08547629f, 0.02912192f, -0.08895221f, 0.05279160f, 0.08546150f, -0.20265666f, 0.04258605f, 0.13594958f, 
    0.07085879f, -0.22345117f, 0.11881521f, -0.04133456f, -0.01660420f, 0.13494660f, -0.00531840f, 0.00038062f, 
    0.20744723f, -0.08711211f, -0.02335873f, 0.08391660f, -0.09029866f, -0.04595074f, 0.19490971f, -0.10360977f, 
    0.00457942f, 0.06340642f, 0.08279717f, -0.06564648f, 0.04498734f, 0.08666875f, 0.06011782f, 0.04012342f, 
    0.14997424f, 0.04371621f, -0.17782657f, 0.10586423f, 0.00870512f, -0.06714245f, 0.04786000f, -0.01526410f, 
    0.07772411f, 0.06929678f, 0.10665338f, 0.11581929f, 0.05875544f, -0.00343869f, -0.24191490f, 0.21756180f, 
    -0.06321250f, -0.06375535f, -0.03037423f, -0.15916067f, 0.00208941f, -0.03066438f, 0.07113139f, -0.02156849f, 
    -0.05794948f, -0.00111917f, -0.24770947f, 0.24831507f, 0.06349297f, 0.11141958f, -0.08554731f, 0.13820608f, 
    0.06859854f, 0.15474755f, 0.08251340f, 0.00776367f, -0.05261211f, -0.16105258f, 0.16337904f, 0.08814832f, 
    0.12139632f, 0.10403679f, 0.15036720f, -0.06870184f, 0.00945253f, -0.10482415f, 0.19050497f, -0.06931719f, 
    -0.13230227f, 0.09983955f, 0.10146752f, -0.02686354f, -0.00975877f, -0.05308416f, -0.00912302f, -0.02133388f, 
    0.01006551f, 0.13678333f, 0.03504194f, -0.10216742f, 0.21605846f, 0.12198725f, -0.02081103f, 0.05870610f, 
    0.09485267f, 0.04770362f, 0.01285128f, -0.03762833f, 0.08999530f, -0.12225176f, 0.00257680f, 0.10768797f, 
    -0.26113510f, 0.24430609f, -0.01454539f, 0.12685440f, 0.03957710f, 0.00641711f, 0.04936539f, 0.04327025f, 
    0.07263210f, 0.06257264f, 0.07694039f, 0.09297261f, 0.30296004f, 0.20312728f, 0.06006516f, -0.08297186f, 
    0.01760253f, 0.10331623f, 0.02666549f, 0.09760088f, 0.04103447f, 0.02247658f, 0.03747291f, 0.01678558f, 
    0.12051891f, 0.16496232f, -0.02373406f, 0.31130108f, 0.07630504f, 0.05582031f, -0.04068866f, 0.24384780f, 
    -0.08087393f, 0.03565988f, 0.04904587f, -0.09538659f, 0.05651632f, 0.05493488f, 0.04343520f, 0.09606847f, 
    -0.04052014f, 0.02631466f, 0.07665352f, 0.08061526f, -0.21870814f, 0.05888290f, -0.10757428f, 0.05047728f, 
    0.05149275f, 0.21458183f, 0.19110918f, 0.04889190f, -0.11607842f, -0.06600340f, 0.06071778f, -0.09384751f, 
    -0.06589182f, 0.09124701f, -0.14834665f, -0.27918091f, -0.24463663f, -0.06915867f, 0.03400641f, 0.11853063f, 
    -0.15791033f, 0.06072029f, -0.04197692f, 0.04181498f, 0.12543544f, -0.00156823f, 0.03249001f, 0.01353736f, 
    -0.04382081f, -0.14003900f, 0.05031810f, -0.07937057f, -0.01915474f, 0.05051832f, 0.00605824f, -0.02672614f, 
    0.04638929f, 0.04031599f, -0.16613489f, -0.04159047f, 0.29069099f, 0.08991817f, 0.08095329f, -0.04634411f, 
    -0.05826246f, -0.03865287f, 0.00205247f, 0.14556274f, -0.22046967f, 0.24881217f, -0.16128515f, -0.00279454f, 
    0.29394853f, -0.15743995f, 0.03105697f, -0.04883973f, 0.22858480f, -0.01664575f, -0.13214245f, -0.10297803f, 
    -0.03009892f, 0.01579757f, 0.02392454f, 0.02112560f, -0.22333293f, 0.12291942f, 0.11011045f, 0.08661503f, 
    0.05844357f, -0.10850395f, -0.00369398f, 0.03470563f, -0.01724419f, -0.04430316f, -0.14315039f, -0.05692122f, 
    -0.03294309f, 0.08195426f, -0.21390796f, -0.10453863f, -0.13717072f, -0.14815499f, 0.01175907f, -0.01306632f, 
    -0.19336379f, -0.06874957f, 0.00394326f, 0.05458954f, -0.29419079f, -0.03544183f, -0.05454508f, 0.09578893f, 
    0.12992042f, -0.07622681f, 0.07889853f, -0.15909049f, 0.06609748f, 0.22405706f, -0.07911815f, -0.04437037f, 
    0.18259688f, -0.09499613f, -0.21400245f, -0.14359942f, -0.20006055f, -0.07011905f, 0.03898076f, 0.03172470f, 
    0.01964684f, -0.01764181f, 0.14390822f, 0.04194639f, 0.43317440f, 0.02373095f, -0.01271962f, 0.16424441f, 
    -0.03945406f, 0.04200837f, -0.04033525f, 0.01811714f, 0.01770143f, -0.12385971f, -0.01387830f, -0.04879032f, 
    0.13554949f, 0.05997133f, 0.18901847f, 0.19461827f, -0.05673991f, -0.00560902f, 0.05633996f, 0.06462340f, 
    0.12071177f, 0.04078126f, 0.07320365f, -0.03274211f, 0.13344078f, -0.04831646f, 0.04716189f, -0.06488853f, 
    -0.06870063f, 0.04161873f, -0.06971668f, -0.01104004f, 0.00511617f, -0.12440215f, -0.07949310f, -0.13978922f, 
    0.11644813f, -0.11834304f, 0.03039024f, 0.10468681f, -0.02711503f, 0.06998505f, 0.11513222f, -0.02759134f, 
    -0.01312836f, 0.02736269f, 0.07692144f, 0.10360421f, -0.13254637f, -0.13925830f, -0.26530665f, 0.09608614f, 
    -0.06430788f, 0.15095712f, 0.03643817f, -0.15912412f, 0.01108294f, 0.06698539f, 0.06425616f, 0.03731853f, 
    0.08101550f, -0.27659267f, 0.23890893f, 0.12513593f, 0.04624730f, 0.06515504f, 0.10452561f, 0.04104368f, 
    0.11174285f, 0.11924581f, -0.05109584f, 0.07403953f, -0.10924806f, 0.02887967f, -0.17178820f, -0.55092424f, 
    0.07654127f, -0.04736518f, 0.10239505f, 0.06499042f, 0.18468246f, -0.12509581f, -0.02072625f, 0.02727446f, 
    -0.07125457f, -0.27257064f, -0.02048923f, -0.20061915f, -0.01074839f, -0.04003751f, -0.09376139f, 0.05702820f, 
    -0.15893775f, 0.01159144f, 0.02704431f, -0.21369918f, 0.09333083f, 0.29794094f, 0.22767727f, -0.05808421f, 
    0.10009874f, 0.02538544f, -0.14381401f, -0.00378877f, -0.09506070f, -0.04555764f, -0.09460458f, 0.16450632f, 
    0.19633758f, -0.00927957f, -0.09591087f, 0.07811888f, 0.08321260f, -0.17696086f, 0.02938349f, -0.00556254f, 
    0.10075523f, -0.00045417f, 0.05254706f, 0.01336568f, 0.06655428f, 0.10328154f, 0.13463844f, 0.21393010f, 
    0.17963949f, 0.09364456f, -0.08378302f, -0.04491109f, 0.01243361f, -0.00369469f, 0.15368281f, 0.02325541f, 
    0.01907676f, 0.17749584f, -0.07248391f, 0.11765553f, -0.00279169f, -0.07224089f, 0.13381581f, 0.04410966f, 
    -0.00137765f, -0.00776860f, 0.04336086f, 0.02427085f, 0.51633787f, -0.02895446f, -0.22231652f, 0.19469289f, 
    -0.11104017f, 0.04876006f, -0.01254794f, 0.06819518f, -0.04534697f, 0.12738979f, 0.07693475f, -0.08297755f, 
    -0.11056811f, 0.10554647f, 0.05752691f, -0.09442735f, -0.03348121f, 0.09745551f, 0.00038484f, 0.01490689f, 
    0.14952755f, 0.13859501f, -0.01558398f, 0.02605203f, 0.12600046f, 0.23413333f, 0.03532225f, -0.28535116f, 
    -0.01361098f, 0.07337253f, 0.13438214f, 0.24443017f, 0.00198407f, -0.07820790f, -0.01433115f, -0.07374997f, 
    -0.24577029f, -0.02220092f, 0.36868924f, -0.03030227f, 0.11500211f, -0.01522445f, 0.05549348f, -0.23362343f, 
    -0.09947164f, -0.04959676f, 0.05548837f, 0.08100639f, -0.29524377f, 0.10938475f, -0.00004371f, -0.16003545f, 
    0.05191601f, -0.09939084f, 0.04022029f, -0.11014479f, 0.03107159f, 0.04640929f, -0.08796535f, 0.04456338f, 
    0.08412241f, -0.01691688f, 0.02878913f, 0.16381127f, 0.00269195f, 0.09371941f, 0.11360556f, 0.01664406f, 
    0.01956947f, 0.00696933f, 0.03577734f, 0.04515501f, -0.19888903f, -0.23352706f, 0.01606556f, -0.20412929f, 
    0.03081961f, -0.01800211f, 0.06592304f, -0.00337937f, 0.04750333f, -0.02060774f, 0.10834100f, -0.02172967f, 
    -0.08328150f, 0.10831033f, 0.11387069f, 0.00100624f, -0.00619086f, -0.06303452f, 0.10552443f, -0.01591425f, 
    -0.11959196f, 0.11354280f, 0.00879615f, 0.31949103f, -0.05011630f, 0.07760485f, 0.07537550f, -0.03359865f, 
    -0.08175227f, 0.03267713f, 0.09657907f, 0.00455058f, 0.03508078f, 0.12307326f, 0.11198316f, 0.18910278f, 
    0.04809221f, -0.11786184f, 0.11181414f, 0.03662615f, 0.01074347f, 0.04776421f, -0.10433393f, 0.08570784f, 
    -0.01792014f, -0.04794550f, 0.15775877f, -0.09365999f, 0.18809220f, 0.12162191f, -0.18528116f, -0.14241785f, 
    0.06234157f, -0.04906849f, 0.01129611f, -0.03095749f, -0.10396867f, 0.04491358f, -0.01089369f, -0.19504789f, 
    -0.19250794f, 0.02499150f, 0.21191923f, -0.12047991f, 0.00167311f, -0.08008845f, -0.08600388f, -0.01088963f, 
    -0.08989278f, -0.11074498f, -0.04511256f, -0.13962674f, 0.19203633f, -0.03836597f, 0.04919416f, -0.00532303f, 
    -0.02680772f, 0.04637719f, -0.11417665f, 0.13699935f, 0.03765779f, 0.01477261f, -0.25238413f, 0.06698207f, 
    0.16158280f, 0.06260334f, 0.01618390f, 0.12984012f, 0.16455685f, -0.00470660f, -0.11779816f, -0.08870041f, 
    0.12897845f, 0.10035326f, 0.08155528f, 0.06668196f, 0.31382522f, 0.12577239f, 0.01765409f, -0.00186234f, 
    0.18063150f, -0.03905472f, 0.10153659f, 0.18204790f, -0.20202844f, 0.14515732f, 0.02377881f, 0.03492760f, 
    0.02011946f, -0.01156200f, 0.09671024f, 0.16978139f, 0.04750286f, -0.03852027f, -0.00562404f, 0.03812920f, 
    -0.05998575f, 0.14675562f, 0.07611113f, 0.02760537f, 0.39720050f, -0.23121664f, 0.13216169f, 0.07196213f, 
    -0.18546395f, -0.11260615f, 0.06809293f, -0.07007359f, -0.14996922f, -0.14376415f, -0.17148134f, -0.02380703f, 
    0.37605718f, 0.49859896f, -0.01243987f, 0.17189443f, 0.04168218f, -0.06632259f, -0.11259879f, 0.06152886f, 
    -0.12168106f, 0.01334646f, 0.01124374f, -0.14743088f, -0.18923829f, 0.14259616f, 0.10240506f, 0.14574423f, 
    0.06280270f, 0.02447215f, 0.07413408f, 0.08966922f, -0.01206603f, 0.07057500f, 0.04017615f, 0.01835044f, 
    -0.22408260f, -0.28837124f, -0.09239667f, 0.01562220f, -0.05030609f, 0.00774748f, 0.02381781f, -0.01918133f, 
    0.02050017f, 0.15312377f, 0.07493773f, 0.00658103f, -0.06287557f, -0.09633985f, -0.04325167f, 0.09850498f, 
    -0.06018965f, -0.00292638f, -0.00678715f, -0.02974278f, 0.04429071f, -0.03177068f, -0.05185264f, 0.02027607f, 
    -0.10030303f, -0.07214640f, 0.06252734f, 0.18511246f, -0.10872875f, 0.17057553f, 0.06548692f, 0.30898476f, 
    0.19610374f, 0.02749785f, -0.02633695f, 0.24588735f, -0.34333369f, -0.04269359f, 0.00582991f, 0.11181919f, 
    -0.15335770f, -0.05589224f, 0.05326384f, 0.12918440f, -0.13756223f, 0.13455218f, -0.02461712f, -0.00479891f, 
    -0.11844028f, 0.17313509f, 0.14851373f, -0.05262022f, 0.03530459f, 0.00248759f, 0.01949653f, 0.16741124f, 
    0.10648506f, 0.09598055f, 0.01769902f, 0.11783400f, 0.25808382f, -0.13083637f, -0.03212234f, 0.19015430f, 
    -0.10840651f, -0.04394557f, -0.04194473f, -0.12229167f, -0.03256676f, -0.01251022f, 0.12669179f, -0.04949814f, 
    0.08176941f, 0.17601965f, 0.04922109f, 0.28686181f, 0.04739220f, 0.08519115f, 0.03354605f, 0.19333410f, 
    0.03278624f, -0.06135504f, 0.06003390f, -0.05904313f, 0.01559412f, -0.11091635f, -0.03000961f, 0.12261913f, 
    0.08258584f, -0.04405210f, -0.01386862f, -0.03961530f, -0.12411602f, -0.04108055f, 0.02553555f, -0.12398327f, 
    -0.43386650f, 0.11092577f, 0.08620127f, -0.07317177f, -0.08430484f, 0.01955954f, 0.01766242f, -0.15386565f, 
    0.09094907f, -0.03732682f, 0.04039066f, -0.08510840f, 0.10205384f, 0.05537345f, 0.16306825f, 0.04824743f, 
    -0.04443619f, -0.05176593f, 0.07168362f, -0.10763507f, 0.11087841f, -0.00771465f, -0.06026916f, -0.05063570f, 
    0.15224731f, -0.09161185f, -0.01000672f, 0.06826868f, 0.05304328f, 0.01208795f, -0.11556670f, -0.05101534f, 
    -0.02252883f, 0.00750488f, 0.07588257f, 0.00778541f, 0.08515751f, 0.21488503f, 0.13545024f, -0.10347027f, 
    0.02112096f, 0.02380932f, -0.02784284f, 0.30692652f, 0.01110270f, 0.09618253f, 0.06172252f, 0.01202807f, 
    0.26011512f, -0.06864852f, -0.08669662f, -0.01783415f, 0.01640263f, -0.01390963f, -0.01832772f, -0.07171619f, 
    -0.08324561f, 0.06840132f, 0.00631798f, 0.02646536f, -0.29513368f, 0.02548567f, 0.22304222f, -0.05378887f, 
    0.03123399f, -0.02487920f, -0.03221701f, 0.01917072f, -0.02913609f, -0.03545410f, -0.12997720f, 0.04201559f, 
    0.10933388f, 0.17161137f, 0.00260199f, 0.12463441f, -0.00045250f, -0.06639782f, -0.01121309f, 0.14122440f, 
    -0.09061675f, -0.06354908f, 0.04064110f, -0.06221576f, -0.01009182f, 0.20861781f, -0.03593775f, -0.09126893f, 
    -0.07936568f, -0.01911421f, 0.08807509f, -0.05536913f, -0.00006743f, 0.04696874f, 0.01785460f, 0.33574688f, 
    -0.09527400f, -0.24649312f, -0.13222031f, -0.07684402f, -0.12287043f, -0.04878934f, 0.15831070f, -0.05924123f, 
    0.03961902f, 0.07561626f, 0.05035348f, 0.05936594f, 0.28192183f, -0.37488842f, -0.19187561f, 0.41196179f, 
    -0.13314441f, -0.07971518f, -0.08228185f, -0.09515383f, 0.06245813f, 0.00091036f, -0.07827927f, -0.05628942f, 
    0.21800056f, 0.07706261f, 0.07642794f, 0.17316405f, -0.02200857f, 0.14621910f, 0.12130599f, 0.13095568f, 
    0.09353966f, 0.09283116f, 0.04220466f, 0.02571018f, -0.04513785f, -0.18701817f, -0.17821154f, -0.29272118f, 
    -0.13293748f, -0.04158788f, 0.07187492f, -0.13766840f, -0.07938252f, -0.03958898f, -0.07959967f, 0.04861692f, 
    -0.19415936f, -0.06075118f, 0.00428028f, -0.19022363f, 0.08790292f, 0.00582457f, -0.05710846f, 0.09942287f, 
    -0.01781774f, 0.12902854f, -0.10590828f, 0.03693621f, 0.08336337f, 0.28958702f, 0.08534636f, 0.31305516f, 
    -0.01090592f, 0.03116873f, -0.07519392f, -0.06707892f, -0.00158368f, 0.16257210f, 0.03778436f, 0.09229080f, 
    -0.35854429f, -0.11102611f, 0.08116738f, 0.00235741f, 0.09645382f, 0.05854947f, 0.08546311f, 0.07169888f, 
    -0.10061931f, 0.00078929f, -0.00744367f, 0.02881021f, 0.14323913f, 0.05834293f, 0.12034417f, 0.09292340f, 
    0.01133528f, -0.04004280f, -0.10207646f, 0.06288729f, -0.04811041f, 0.12798972f, 0.00141839f, 0.09523865f, 
    -0.10163261f, 0.22468384f, 0.05043240f, 0.16449672f, 0.03664458f, -0.00047021f, 0.04621183f, -0.04463897f, 
    0.16538566f, -0.01307916f, -0.05125608f, 0.07782270f, -0.11380520f, -0.04047006f, -0.07532327f, -0.28136185f, 
    0.07178427f, 0.02637538f, 0.14717136f, 0.08308969f, 0.00245413f, 0.08903503f, 0.12416749f, 0.14960864f, 
    -0.08798707f, 0.08678589f, 0.17846507f, -0.07306173f, 0.08978412f, 0.15946081f, -0.02693758f, 0.07828163f, 
    0.00326479f, 0.06823096f, 0.04699255f, 0.04435178f, 0.00504742f, -0.08405410f, -0.15186372f, -0.18211524f, 
    -0.06682291f, 0.00096197f, -0.02787951f, 0.08754648f, 0.04713232f, 0.00322016f, -0.00895203f, 0.01905281f, 
    -0.12870714f, -0.16318800f, 0.14847946f, -0.01614059f, 0.19515070f, 0.05577770f, -0.02741628f, 0.05645921f, 
    -0.05022847f, -0.04508140f, -0.00723113f, 0.13493796f, -0.22457916f, -0.13286223f, -0.12268825f, -0.19271451f, 
    0.05689988f, 0.06237741f, 0.05018527f, 0.12065938f, -0.00705007f, -0.11740532f, 0.03226639f, 0.01435743f, 
    -0.00239803f, 0.01915784f, -0.00418861f, -0.22711758f, 0.08466586f, 0.04525741f, 0.06934342f, -0.02161903f, 
    0.01154730f, -0.04606688f, 0.07344783f, 0.01636286f, 0.14637493f, -0.00670568f, -0.02259063f, -0.01103738f, 
    -0.02980235f, 0.08267280f, 0.02927782f, 0.03490664f, -0.11737537f, 0.01333561f, 0.13954149f, 0.09765699f, 
    -0.28049880f, 0.08560226f, 0.13176045f, 0.00924541f, 0.00263249f, 0.05518489f, -0.01695562f, 0.07705098f, 
    0.03524644f, 0.01487893f, 0.05416945f, -0.01057267f, 0.03797583f, -0.01511305f, 0.36481041f, 0.32015440f, 
    0.05890706f, 0.09165510f, -0.02121971f, -0.04462635f, 0.04477611f, 0.01975271f, 0.05983834f, 0.11783362f, 
    -0.39774430f, -0.25370136f, 0.02935293f, -0.17873539f, 0.01483690f, 0.11325007f, 0.08345915f, 0.27103597f, 
    0.07207582f, 0.02449899f, -0.07510566f, 0.02917630f, 0.10245474f, 0.14906934f, 0.13823116f, 0.14636706f, 
    -0.09087780f, 0.13710737f, 0.19244632f, -0.02077278f, 0.08568510f, 0.09422165f, 0.10335905f, -0.06399360f, 
    -0.17606275f, 0.01283334f, 0.11954246f, -0.01825295f, 0.01370449f, 0.04704033f, 0.06970764f, -0.00334683f, 
    -0.06802155f, -0.07970871f, 0.18532600f, 0.09139463f, 0.10647969f, 0.00786251f, -0.03424590f, -0.11602707f, 
    0.04433263f, -0.02642096f, 0.09943181f, -0.05580042f, -0.08683034f, 0.08895602f, 0.00446304f, 0.07301646f, 
    -0.01977157f, -0.04646333f, 0.13260366f, 0.00053994f, -0.00850497f, 0.15922219f, -0.07589415f, 0.05019445f, 
    -0.05168006f, 0.10519344f, -0.01966148f, -0.13851377f, -0.07620953f, 0.03308015f, -0.05830155f, -0.11206787f, 
    0.06969985f, 0.04767620f, -0.01698315f, 0.04513362f, 0.00980682f, -0.02510891f, 0.04890179f, -0.08805802f, 
    -0.02190499f, -0.13354632f, 0.27058038f, 0.03517760f, -0.05146555f, -0.00521463f, -0.08481804f, 0.04842380f, 
    -0.09259812f, -0.06466631f, 0.02495258f, 0.08131955f, 0.30132768f, 0.00626072f, 0.07769309f, 0.31368792f, 
    -0.09424923f, 0.00116478f, -0.08777218f, 0.00575547f, 0.00169707f, -0.08505250f, -0.09192071f, 0.00899997f, 
    0.20385402f, 0.10127442f, -0.03063050f, 0.14068991f, -0.07362774f, 0.08949117f, -0.00264015f, -0.11517906f, 
    0.00938003f, 0.04358655f, 0.17948471f, 0.10426044f, 0.13518532f, 0.08733524f, 0.41610870f, 0.06634284f, 
    0.17061582f, -0.06236317f, 0.03224901f, 0.06355482f, 0.01948869f, -0.01240810f, 0.10871818f, 0.05328408f, 
    -0.13033213f, 0.34771535f, -0.18774898f, 0.05342473f, -0.07424399f, -0.01273332f, 0.08537026f, -0.04820597f, 
    0.05727339f, 0.17692134f, 0.03005766f, -0.05180772f, -0.19688912f, 0.02833534f, 0.08246481f, 0.01458513f, 
    0.06620757f, -0.04290688f, 0.07277616f, -0.02781601f, -0.02984677f, -0.01515094f, -0.12260462f, 0.12330016f, 
    0.14396131f, 0.27621308f, 0.08743549f, 0.33201915f, -0.06802177f, 0.01002882f, -0.18883577f, 0.13827284f, 
    0.22649080f, -0.01385069f, 0.03247835f, 0.10121195f, -0.14217563f, 0.15805385f, 0.04988532f, 0.07180941f, 
    -0.05593491f, 0.12982267f, 0.07006758f, -0.06731136f, 0.06917313f, 0.00289335f, 0.04174313f, 0.07767835f, 
    0.03079666f, -0.06878577f, -0.10024263f, 0.14960212f, 0.04557863f, 0.03372386f, -0.06827130f, -0.07493721f, 
    0.06145665f, 0.06649025f, 0.15153107f, -0.04120642f, 0.03062477f, 0.12507947f, -0.24301060f, -0.11824566f, 
    0.03807832f, 0.03208849f, 0.07223060f, 0.05277077f, -0.03855545f, -0.08816439f, 0.10324090f, -0.04139469f, 
    0.19884327f, 0.01701551f, -0.04073922f, 0.21544057f, -0.06238025f, 0.11002538f, -0.14867252f, -0.01745230f, 
    0.08807045f, -0.07189466f, -0.01845347f, -0.04801422f, -0.17518727f, -0.08535212f, -0.12460573f, 0.03782170f, 
    -0.09877144f, -0.00231355f, -0.04342331f, 0.13375224f, -0.05190896f, 0.13996124f, -0.07637898f, 0.02808290f, 
    -0.13688126f, -0.01933324f, -0.11176622f, -0.04053582f, 0.19687973f, 0.12184250f, 0.01481033f, -0.08366210f, 
    -0.04845224f, 0.03009522f, -0.00166693f, -0.08299806f, 0.12824307f, 0.25777373f, 0.17904642f, -0.12918887f, 
    0.11111803f, 0.05347256f, -0.17472495f, 0.02692221f, -0.16323821f, -0.02239905f, -0.17907512f, -0.00153690f, 
    -0.22776544f, -0.08731627f, 0.11679309f, 0.10763534f, 0.26963636f, 0.16717310f, 0.05967991f, 0.05495252f, 
    0.00191093f, -0.01154487f, -0.05203106f, 0.06556905f, -0.24724200f, 0.30836007f, 0.07550957f, -0.19214810f, 
    0.08798093f, 0.02599759f, 0.10105750f, -0.00273064f, -0.02313441f, -0.15786430f, -0.09047686f, 0.18866464f, 
    0.16076900f, -0.12347684f, 0.33795235f, 0.08407205f, 0.03117608f, -0.02987878f, -0.00941949f, 0.02042901f, 
    0.11860088f, 0.01047619f, 0.06820291f, 0.10123933f, -0.02432603f, -0.13207488f, 0.02772550f, 0.20798123f, 
    -0.07934991f, -0.08129618f, -0.00276714f, -0.04505495f, -0.04526213f, 0.04841439f, 0.02126427f, -0.00950316f, 
    -0.25172007f, 0.07001210f, -0.05634724f, -0.02350989f, -0.00179494f, 0.04044629f, 0.15232268f, -0.03564389f, 
    -0.11403180f, -0.10040554f, -0.00729369f, 0.06560359f, 0.02655890f, -0.12618411f, 0.03388658f, -0.00597262f, 
    0.18457074f, 0.10180204f, -0.09101092f, -0.00074845f, 0.14429757f, -0.12846336f, 0.20130740f, 0.21414235f, 
    -0.05515702f, -0.01758589f, -0.09970238f, -0.14421234f, 0.08768220f, 0.08690205f, -0.00915469f, -0.06768808f, 
    0.01912046f, -0.02121861f, 0.02386346f, 0.06421795f, -0.25010580f, -0.01539568f, -0.17756958f, -0.04456118f, 
    0.13043590f, 0.02850611f, 0.05764415f, 0.00843612f, 0.08274139f, 0.04172872f, 0.03170976f, 0.02130700f, 
    -0.35539803f, -0.01637680f, -0.01929750f, 0.28084597f, 0.00204984f, -0.00081502f, 0.03635652f, -0.02242120f, 
    0.09820034f, -0.07398280f, 0.15236461f, -0.03363181f, -0.30088794f, -0.00145452f, -0.15253326f, 0.04855996f, 
    0.04319222f, -0.02063682f, -0.07797117f, -0.05842001f, 0.07344110f, -0.04674779f, -0.02596887f, 0.02110321f, 
    -0.01093191f, 0.14536868f, 0.18403287f, 0.22696392f, -0.01706495f, 0.10272043f, -0.09069330f, -0.03291519f, 
    -0.15126815f, 0.05661485f, 0.04379489f, 0.03800392f, -0.10529740f, 0.27822888f, 0.16670290f, -0.11367539f, 
    0.00857909f, -0.10400883f, 0.16089644f, -0.10741177f, -0.19048338f, 0.02015243f, 0.13541295f, 0.06592278f, 
    0.00794463f, 0.02979530f, -0.00327694f, 0.13025151f, 0.12134089f, 0.11639240f, -0.06225286f, 0.03548723f, 
    0.09020817f, 0.07256637f, 0.06722993f, -0.10408874f, 0.15978846f, 0.17855997f, 0.06274766f, 0.16278671f, 
    0.03269651f, 0.12190378f, -0.01232973f, -0.06502207f, 0.02873235f, -0.03539436f, -0.05226441f, -0.04142236f, 
    0.04845400f, -0.00891985f, -0.05674817f, -0.02292611f, -0.01653452f, -0.04495950f, -0.06478262f, 0.03946889f, 
    0.04048303f, 0.02404841f, 0.05127634f, 0.01192645f, 0.02676133f, 0.02906197f, -0.06374425f, -0.03238375f, 
    0.00015643f, -0.01448627f, -0.07396924f, 0.05296664f, -0.01939463f, -0.01790447f, -0.05052283f, 0.01399147f, 
    0.00566192f, -0.05431940f, -0.06909574f, -0.06592085f, 0.00625534f, 0.01899648f, -0.07218511f, -0.03365267f, 
    -0.06418260f, -0.01756116f, -0.01714351f, 0.02386575f, 0.03345131f, -0.04334286f, 0.02695425f, -0.00703077f, 
    -0.02406198f, -0.02684800f, 0.02446571f, -0.04717223f, 0.02569934f, -0.05001263f, 0.00412701f, -0.06213990f, 
    -0.02865421f, -0.00489977f, -0.01974792f, 0.01993147f, 0.00027693f, -0.03116243f, 0.03823629f, 0.02752086f, 
    0.05163438f, -0.06310015f, -0.02657870f, -0.06820291f, -0.04160227f, 0.05625310f, -0.03634496f, -0.01895791f, 
    -0.01293573f, 0.04220419f, 0.05247304f, 0.04638074f, -0.04565734f, 0.02603249f, 0.00077244f, 0.01557954f, 
    -0.06737696f, 0.05094074f, 0.04512088f, -0.06475584f, 0.04667924f, -0.04826761f, 0.03465984f, -0.06999833f, 
    0.04682915f, -0.06662600f, 0.04184586f, -0.01786139f, 0.02324253f, 0.02788053f, -0.03766162f, -0.06587532f, 
    0.04678768f, 0.02913380f, 0.01141425f, -0.05085859f, 0.04455633f, 0.01984654f, -0.05746158f, -0.06578518f, 
    0.03084598f, -0.06008355f, -0.01487864f, 0.02794174f, -0.05185636f, -0.02821782f, -0.01744241f, -0.06851378f, 
    -0.05509930f, -0.00077677f, -0.04308860f, -0.05309546f, -0.06985372f, -0.05713039f, 0.04880421f, -0.06841775f, 
    -0.02097231f, -0.02621366f, -0.05330955f, 0.03589999f, 0.03411658f, 0.05704981f, -0.01027647f, 0.03088977f, 
    0.05857554f, 0.04113821f, -0.01935377f, 0.00333709f, -0.04383145f, -0.06960623f, 0.00310458f, -0.00321207f, 
    0.00531752f, -0.02002319f, 0.01351176f, 0.02937699f, 0.00836223f, 0.00497060f, -0.02655311f, 0.03799321f, 
    -0.05881390f, 0.06890541f, -0.00062253f, 0.01918691f, 0.05066920f, 0.01528462f, -0.02978306f, 0.00439210f, 
    -0.07091868f, 0.02739410f, -0.08063430f, 0.00314450f, -0.05103974f, 0.03745759f, 0.02648449f, 0.02125706f, 
    -0.03992285f, -0.01710141f, -0.02030154f, 0.00870860f, -0.06473607f, 0.03266251f, 0.02898485f, -0.03948719f, 
    -0.04754561f, 0.06409336f, -0.02335503f, -0.02780219f, 0.00480667f, -0.05516746f, -0.00812114f, 0.05569311f, 
    0.02247097f, 0.05677992f, 0.03168253f, -0.05345742f, 0.01129564f, 0.02932092f, -0.03177326f, 0.00994555f, 
    0.00602323f, -0.02662052f, 0.01773789f, 0.05274815f, -0.07300456f, -0.04808714f, -0.04588660f, 0.03251055f, 
    0.05167750f, 0.04795604f, -0.06562628f, 0.04716621f, -0.08240649f, -0.07397533f, -0.03106848f, 0.06119146f, 
    0.09681876f, 0.13478050f, 0.06366914f, -0.13656896f, 0.07167001f, 0.07046741f, -0.01878223f, 0.12004280f, 
    0.04723378f, 0.08907939f, 0.04220078f, 0.03144651f, 0.21848980f, -0.09902280f, 0.02554241f, 0.36187789f, 
    -0.00312630f, -0.11556650f, -0.00725712f, 0.05184696f, 0.04324859f, -0.01995216f, 0.07445128f, -0.01530151f, 
    -0.10995717f, -0.03575283f, -0.15620343f, -0.03953357f, -0.00687990f, 0.00388620f, 0.10063431f, -0.02225949f, 
    0.04335678f, 0.05714978f, -0.01375074f, 0.13152732f, 0.34976861f, -0.15337208f, 0.29361680f, 0.11353325f, 
    -0.11795450f, -0.01116825f, 0.03785084f, -0.02907206f, 0.06800500f, 0.01926852f, -0.06413289f, -0.10603451f, 
    0.03362516f, 0.26632929f, -0.04445498f, -0.00935252f, 0.11671373f, -0.12157311f, -0.05166235f, 0.02709962f, 
    0.10025346f, -0.13196352f, -0.17358242f, -0.00057692f, -0.13837683f, 0.21695571f, -0.02735633f, -0.14722021f, 
    0.03504888f, 0.03096756f, -0.00897821f, -0.05365148f, 0.02382695f, 0.03228621f, 0.05691232f, 0.06908820f, 
    -0.07667243f, -0.07133822f, 0.10437189f, 0.10625246f, -0.08557251f, 0.01375601f, -0.03837468f, 0.02316828f, 
    0.00204033f, 0.05563673f, 0.04959279f, 0.00704407f, -0.13481753f, -0.08474527f, 0.05665822f, 0.19808398f, 
    0.00670047f, -0.10644294f, -0.05656064f, 0.22943075f, 0.02174379f, 0.06315395f, -0.00683315f, -0.03668999f, 
    0.15246527f, 0.01609182f, 0.19433135f, -0.22735065f, 0.03115798f, 0.09048388f, -0.08786394f, -0.04085360f, 
    0.02062594f, 0.11058868f, -0.01191865f, 0.03084918f, -0.10474750f, -0.03894672f, 0.06276987f, 0.00148994f, 
    -0.07299138f, -0.10439022f, 0.00469249f, -0.10684984f, 0.11141481f, -0.05159770f, 0.07073126f, 0.06580657f, 
    0.21818140f, 0.02451489f, 0.07609879f, -0.10587133f, 0.00277770f, -0.09725653f, 0.01932796f, 0.00354088f, 
    -0.08534960f, -0.12112327f, -0.05019943f, -0.00234687f, 0.22870618f, -0.16786484f, -0.15296715f, -0.10961492f, 
    0.01235961f, 0.05113002f, 0.01432228f, -0.11477441f, -0.02443267f, 0.03254876f, 0.05701657f, 0.08717360f, 
    -0.04534020f, 0.12263422f, -0.17859888f, -0.10219637f, -0.05665942f, -0.10582639f, 0.09052015f, 0.19634420f, 
    -0.01767722f, 0.05491890f, 0.02082780f, 0.00881791f, 0.26776049f, -0.04279156f, -0.09317750f, 0.25258985f, 
    -0.03656965f, 0.10554577f, -0.04700252f, 0.04040978f, -0.00730182f, -0.02598374f, 0.08951528f, -0.07830241f, 
    -0.16093336f, -0.09513066f, 0.08206134f, -0.14055738f, 0.03767127f, -0.05145231f, -0.02496674f, 0.13980740f, 
    -0.00345782f, 0.15323117f, 0.01389773f, 0.09176530f, 0.10522949f, 0.17976068f, -0.02949275f, 0.08525422f, 
    -0.00858676f, -0.17178363f, 0.05066044f, 0.04492467f, -0.05104071f, -0.03491250f, 0.04404308f, 0.00918589f, 
    -0.07615087f, -0.07940075f, -0.05828621f, 0.06346768f, -0.07103395f, 0.04028984f, -0.01203670f, 0.03749215f, 
    -0.06524047f, 0.03788625f, -0.05426756f, 0.05437161f, -0.01727396f, 0.03318072f, -0.05217496f, -0.03807980f, 
    0.01784139f, -0.01922859f, 0.01783110f, -0.02644350f, -0.06901117f, -0.03463480f, -0.07279253f, -0.00185813f, 
    -0.03174820f, -0.02228452f, 0.04500061f, 0.01849507f, 0.02325800f, -0.07141342f, -0.04010198f, 0.01841433f, 
    0.05781069f, -0.07262634f, -0.04391891f, -0.04220278f, -0.05299909f, -0.03644439f, -0.07812700f, -0.04246340f, 
    -0.01079436f, 0.04328062f, 0.01221767f, -0.06137384f, 0.02033867f, 0.03638512f, -0.04113439f, 0.03718844f, 
    -0.06270551f, 0.04346589f, -0.01398331f, 0.05886719f, 0.02877691f, -0.06125100f, -0.05116336f, -0.02243415f, 
    -0.05093098f, 0.04804710f, -0.00812351f, 0.00049134f, -0.07791704f, -0.01211938f, 0.00723460f, 0.03056718f, 
    -0.03254768f, 0.05089207f, 0.04405192f, -0.00417334f, 0.01861319f, -0.06974352f, -0.00535168f, -0.06906874f, 
    -0.06833248f, -0.05839850f, -0.04221344f, 0.02268511f, -0.05194995f, -0.04749916f, 0.02095303f, -0.03380906f, 
    -0.04535232f, -0.06945650f, 0.04667634f, 0.03670526f, -0.00151099f, 0.00265696f, -0.05214560f, 0.01007263f, 
    0.06006488f, -0.05914231f, -0.02534684f, 0.01726754f, -0.06392815f, 0.01292445f, -0.03814467f, 0.04479928f, 
    0.00359881f, 0.03332179f, -0.00844537f, -0.04773463f, -0.00747642f, -0.02820593f, -0.03159331f, 0.05572696f, 
    0.02997175f, -0.00197291f, 0.05313627f, 0.01935206f, 0.00027704f, 0.01705439f, -0.01866375f, -0.01104877f, 
    0.01875429f, 0.02452951f, -0.03048095f, 0.03926007f, 0.02747015f, 0.06116338f, -0.04511488f, -0.00559072f, 
    -0.00585478f, 0.02953445f, -0.01719565f, -0.03842950f, -0.00990825f, -0.00499370f, 0.00294734f, 0.04927341f, 
    -0.03917564f, 0.04177490f, -0.06644545f, -0.06000029f, -0.00994890f, -0.05553561f, -0.03808917f, 0.03219185f, 
    0.04805456f, -0.05949079f, 0.05624938f, -0.00482247f, -0.07892375f, 0.04681651f, 0.03554460f, -0.07687364f, 
    -0.02194382f, 0.03131498f, 0.04300605f, -0.00434730f, 0.03283769f, 0.00381923f, 0.06615534f, 0.05433021f, 
    0.02840100f, -0.03923724f, -0.06465309f, -0.02099343f, -0.02696104f, -0.05240326f, 0.02441739f, 0.02314435f, 
    -0.01154995f, 0.05174334f, -0.04569271f, -0.00658104f, -0.00386777f, -0.03977139f, -0.06118110f, -0.07029562f, 
    -0.00888742f, -0.01278030f, -0.06341978f, 0.03584005f, -0.06238237f, 0.04859262f, 0.01302379f, -0.07308702f, 
    -0.07277855f, 0.03283108f, 0.05215381f, 0.01062997f, -0.00533636f, 0.03571731f, 0.02913535f, -0.06211662f, 
    -0.00676161f, -0.07916176f, -0.03737469f, 0.00911543f, -0.00155420f, 0.02028521f, 0.03046320f, -0.02941758f, 
    0.20294647f, 0.14549594f, 0.10529764f, 0.01033191f, -0.10847048f, -0.01716154f, 0.04268613f, 0.04293542f, 
    0.03021917f, 0.04042591f, -0.00805528f, 0.04213259f, -0.17074436f, -0.05289562f, -0.10570994f, -0.24443284f, 
    0.02325507f, 0.11379594f, -0.06090448f, -0.00204882f, 0.10482664f, 0.03744141f, -0.07166462f, -0.01293267f, 
    0.04434875f, 0.18554857f, 0.03988612f, 0.13111079f, 0.00292224f, -0.01813142f, 0.13094601f, 0.13265689f, 
    0.09058810f, -0.01505996f, 0.17507607f, 0.04171556f, -0.43748963f, -0.01484735f, -0.27326289f, -0.36503521f, 
    0.04619907f, -0.07578827f, -0.03933191f, -0.06891707f, 0.04946748f, 0.05122588f, 0.11491096f, -0.04675666f, 
    -0.49770913f, -0.13347079f, -0.03582099f, -0.13010994f, 0.07693928f, 0.06283775f, 0.01152947f, -0.02515356f, 
    0.10461681f, 0.23546132f, -0.01402504f, 0.02499075f, 0.09001789f, 0.07836648f, 0.10051776f, 0.05113719f, 
    0.21245715f, 0.10353537f, 0.01061055f, 0.06136649f, -0.06083426f, -0.00662239f, -0.01597519f, -0.06135042f, 
    0.30096984f, 0.12165496f, 0.06515279f, 0.00455339f, 0.09634131f, -0.02562435f, 0.08104625f, 0.05181588f, 
    -0.02994413f, 0.06546039f, 0.14153780f, -0.03873703f, 0.02285792f, 0.27779478f, -0.04118976f, 0.18448168f, 
    0.07392555f, 0.10568159f, 0.02075914f, -0.08586533f, 0.00142618f, 0.00099123f, 0.12293930f, 0.00717972f, 
    0.12276315f, -0.16709594f, -0.03582195f, 0.01411211f, -0.04297566f, 0.01421071f, 0.00433229f, -0.07567587f, 
    0.05636320f, -0.04963902f, 0.12858126f, -0.14175887f, 0.20165670f, -0.10350808f, 0.05640837f, -0.00227097f, 
    -0.05309565f, 0.18269864f, -0.02658793f, 0.04970966f, -0.03400202f, 0.03115606f, 0.16033436f, 0.02487063f, 
    -0.01115078f, 0.08240470f, -0.08798060f, 0.08551038f, 0.14514628f, 0.03981051f, 0.00325140f, 0.10796489f, 
    0.01283421f, 0.12182908f, 0.07612614f, 0.00324650f, -0.02885783f, 0.27977976f, -0.08513270f, -0.14848074f, 
    -0.05490270f, 0.01704536f, 0.12438384f, 0.10998634f, 0.10748311f, 0.08439668f, 0.12192765f, -0.01070863f, 
    -0.43836451f, -0.01085145f, 0.23753574f, -0.03996822f, 0.10328482f, 0.03510248f, -0.00762939f, 0.03394417f, 
    0.02871114f, -0.04604566f, -0.04785383f, 0.13412297f, -0.40384868f, 0.00389415f, 0.08157481f, -0.40171483f, 
    0.04957200f, -0.06046551f, -0.00775393f, 0.03616421f, 0.03022713f, 0.10343806f, 0.05412025f, 0.01445883f, 
    0.32440603f, 0.22736932f, 0.07236574f, 0.12468614f, -0.01103384f, 0.10077888f, 0.10268850f, -0.10827381f, 
    0.00746733f, 0.06987705f, 0.01938155f, 0.00227785f, -0.39288753f, -0.22082596f, -0.08500960f, -0.22519889f, 
    0.15306404f, -0.00425893f, 0.03553235f, -0.08919675f, 0.06849628f, -0.00803291f, 0.06311283f, 0.04399939f, 
    0.11812656f, 0.13933392f, 0.10419606f, -0.33683479f, 0.14578058f, 0.18275943f, 0.05359717f, 0.03448769f, 
    0.01846026f, -0.02146362f, 0.15228038f, 0.17135341f, -0.01073591f, 0.05197927f, 0.15083462f, 0.07725047f, 
    -0.00747810f, 0.18384306f, -0.01179773f, 0.01551100f, 0.06069406f, -0.03722123f, -0.03372687f, 0.20050268f, 
    -0.11255736f, -0.03888482f, -0.25057685f, -0.37067759f, 0.00641751f, 0.00581650f, 0.06591200f, -0.14210734f, 
    -0.05822989f, 0.12813914f, -0.02339035f, -0.02023759f, -0.05136365f, 0.07892901f, 0.15008785f, -0.20986842f, 
    -0.09387343f, 0.06364904f, 0.13653183f, 0.11980369f, 0.06434570f, 0.00834159f, 0.05351977f, 0.11795564f, 
    -0.06299363f, 0.27008259f, 0.23371628f, 0.07535944f, 0.15683742f, -0.19226815f, -0.05157643f, 0.02289834f, 
    0.08970757f, 0.02968106f, -0.12134816f, -0.03223138f, -0.15925218f, 0.04300499f, 0.24020132f, 0.07279063f, 
    0.12304299f, 0.02040825f, 0.00117725f, 0.10313349f, -0.16718215f, -0.03635008f, -0.18732440f, 0.09211444f, 
    -0.20690262f, 0.12410902f, 0.19892198f, 0.10265809f, -0.01945941f, 0.08163746f, -0.00840369f, -0.07583174f, 
    -0.07773444f, 0.14623904f, -0.01603851f, 0.13132599f, 0.09210782f, 0.02883556f, 0.06488924f, 0.14075218f, 
    0.07752484f, -0.20999663f, 0.01334153f, -0.09317268f, 0.19031222f, -0.01626514f, 0.05090072f, -0.05408673f, 
    -0.04056365f, -0.20780608f, 0.08960376f, -0.39987719f, -0.00051583f, 0.11724725f, 0.10742748f, -0.02600255f, 
    -0.03802550f, 0.07745247f, 0.02853939f, 0.11316202f, -0.02519761f, -0.19001316f, -0.10886102f, -0.19583228f, 
    0.00706076f, 0.04890885f, 0.18180087f, 0.00441812f, 0.12769274f, -0.09744156f, 0.10820066f, 0.02124629f, 
    0.17688172f, -0.04886650f, 0.14792630f, 0.10930923f, 0.06119389f, -0.03293015f, 0.02318489f, -0.09744354f, 
    -0.06743342f, 0.00311317f, -0.00165237f, -0.01393578f, -0.14977545f, -0.28149924f, -0.17075616f, 0.01589552f, 
    0.02806981f, 0.14445652f, -0.04081235f, -0.18143860f, 0.09730445f, 0.09849401f, 0.10694505f, -0.02173502f, 
    -0.31921560f, 0.23393522f, 0.05230965f, 0.27856821f, -0.01367457f, 0.02987737f, 0.01003517f, 0.19329473f, 
    -0.10510156f, 0.02899863f, 0.04586244f, 0.03281071f, -0.16337511f, 0.38549611f, 0.17237274f, -0.11498308f, 
    0.00610077f, -0.07688614f, -0.00151992f, 0.16326080f, -0.07831226f, 0.08068506f, 0.06919425f, 0.13067350f, 
    -0.23123224f, 0.00193319f, -0.00732989f, -0.24712008f, 0.15327401f, 0.09451620f, 0.07097118f, 0.08201320f, 
    -0.09960664f, 0.17980994f, -0.05360731f, 0.04656753f, -0.45747200f, 0.17145646f, -0.01904150f, 0.31547710f, 
    -0.09014648f, 0.03573172f, 0.08392267f, 0.19452919f, 0.05898039f, -0.03472802f, 0.15295729f, -0.04383053f, 
    -0.23681225f, -0.09579016f, 0.03603245f, 0.09048388f, -0.00725665f, 0.11796673f, 0.09079984f, -0.05826535f, 
    -0.04993950f, -0.07406655f, 0.08931582f, -0.05800468f, 0.05737182f, 0.05731749f, 0.20317787f, -0.27639008f, 
    0.18079500f, 0.10007087f, -0.07114001f, -0.06305093f, -0.14854212f, 0.05991796f, -0.07550889f, 0.00193573f, 
    -0.03960593f, -0.02927616f, 0.16281426f, 0.01120664f, 0.06965180f, 0.02571413f, 0.03955954f, 0.03322298f, 
    -0.03603761f, -0.00076279f, 0.01688648f, 0.07755659f, -0.28603745f, 0.07539193f, -0.22325039f, -0.21933031f, 
    0.14782749f, -0.08123473f, -0.08134608f, 0.06538846f, 0.11102191f, -0.01009668f, 0.00169816f, 0.16988736f, 
    -0.07612837f, -0.08874936f, 0.15680604f, 0.21335803f, 0.05822390f, 0.03694458f, -0.01573516f, 0.01672048f, 
    0.14335380f, 0.03615451f, 0.04576994f, 0.13963446f, 0.13277256f, -0.17942111f, 0.04984180f, 0.22731213f, 
    -0.06567496f, 0.07535483f, 0.02517121f, 0.13252632f, 0.00632515f, -0.01942974f, 0.01656361f, 0.02798412f, 
    0.00393568f, 0.10451235f, 0.12798715f, -0.07414114f, 0.06864659f, 0.07634713f, 0.09763975f, -0.06411034f, 
    0.00786346f, -0.04604847f, 0.01540768f, 0.12456918f, -0.09009957f, 0.01675934f, 0.13199127f, -0.06779584f, 
    0.02989876f, -0.01571939f, -0.13201709f, -0.09133986f, -0.01219277f, -0.03562441f, 0.14744858f, 0.24549291f, 
    -0.26427343f, 0.17763583f, -0.19320640f, 0.04259127f, 0.04214256f, -0.02319388f, 0.14552702f, -0.09646020f, 
    0.16588712f, -0.10194426f, 0.01939505f, 0.04593420f, -0.53333426f, 0.12659663f, -0.14653991f, -0.01695750f, 
    0.25113899f, 0.01881628f, 0.14089434f, 0.04534581f, 0.02992077f, 0.13168566f, 0.02540851f, 0.06887954f, 
    0.00024225f, -0.00471014f, -0.07119779f, 0.20526995f, -0.06873252f, 0.09338481f, 0.06767113f, 0.08941413f, 
    0.23597537f, 0.02190481f, 0.08361646f, 0.12939852f, -0.21566518f, 0.10424317f, -0.06453283f, 0.03142124f, 
    0.04449497f, 0.13868478f, -0.05465847f, -0.00560971f, 0.06362541f, -0.04810550f, 0.08421341f, -0.04026188f, 
    0.15953872f, 0.26392457f, 0.32191220f, 0.24363019f, 0.04644280f, 0.13830809f, -0.03086038f, -0.01536846f, 
    0.11888086f, 0.09919345f, -0.00791190f, -0.06307425f, -0.12168594f, 0.27760440f, 0.15913904f, -0.27292272f, 
    0.09087422f, 0.03472678f, 0.04594377f, -0.02742363f, -0.06708440f, -0.02810839f, 0.12013838f, 0.07767996f, 
    0.19408499f, -0.07212914f, 0.03621340f, 0.13813506f, -0.00056807f, -0.00744888f, -0.07507623f, -0.10341498f, 
    -0.06071761f, 0.01924048f, -0.06715747f, -0.07628326f, -0.06097795f, 0.00967530f, 0.00180552f, 0.12449824f, 
    0.07274251f, 0.32656375f, -0.09832028f, -0.08486408f, 0.06047066f, 0.04803581f, 0.06577672f, 0.08413678f, 
    -0.01856709f, -0.06404206f, -0.03875617f, -0.08093273f, 0.01715497f, -0.06224890f, -0.18543708f, -0.01688853f, 
    -0.04114289f, 0.05393824f, 0.01002671f, -0.21250425f, -0.13538842f, 0.08776686f, -0.15273714f, 0.02561335f, 
    0.08278344f, -0.06621846f, -0.06557008f, 0.03541125f, 0.00279803f, 0.07135390f, 0.11558876f, -0.11347727f, 
    -0.12480945f, 0.00012872f, 0.38565820f, 0.02567690f, -0.02400293f, -0.06591345f, -0.10658938f, 0.04149965f, 
    0.07920042f, 0.01938530f, 0.02203928f, 0.17361774f, 0.16612060f, -0.03926440f, -0.07420213f, 0.08116150f, 
    0.08754484f, 0.01777715f, 0.01196306f, -0.04531290f, -0.01323528f, 0.06931095f, 0.03065498f, -0.02692324f, 
    0.20278169f, -0.05894808f, -0.08598267f, 0.10430168f, 0.16028868f, -0.00314523f, -0.03278363f, -0.01975217f, 
    0.06462343f, -0.11981967f, 0.12033667f, 0.19450372f, -0.04509954f, -0.01766758f, -0.20061655f, -0.33100733f, 
    0.01200128f, -0.15389797f, 0.03001090f, -0.00969173f, -0.04542289f, 0.20614548f, 0.10367897f, -0.14321360f, 
    -0.00430989f, 0.05593048f, 0.03562078f, -0.20080753f, 0.00423859f, -0.06642348f, 0.07038280f, -0.00233071f, 
    -0.00742317f, 0.08654474f, 0.07149111f, -0.02873166f, -0.07332937f, -0.28778738f, -0.12926292f, -0.16387327f, 
    0.04986940f, 0.13119592f, -0.03615955f, 0.00023191f, 0.08043893f, -0.10201927f, -0.03900555f, 0.04065339f, 
    0.01189751f, 0.16388282f, 0.11428829f, 0.18563198f, -0.07890859f, -0.02565727f, -0.07958069f, 0.04419063f, 
    0.05041967f, -0.03023155f, 0.04075375f, 0.03424686f, 0.40540883f, -0.02463078f, 0.03114120f, -0.12387890f, 
    -0.09032567f, -0.00291989f, -0.02268041f, 0.04782766f, 0.06893689f, -0.00008607f, 0.00019474f, 0.00928896f, 
    -0.48786595f, 0.15709132f, 0.02206170f, -0.17090756f, 0.03645442f, -0.09448219f, 0.06014515f, 0.02580127f, 
    0.07941682f, 0.03941084f, 0.04134777f, -0.08615386f, 0.40190962f, 0.23964392f, 0.05072236f, -0.05531076f, 
    -0.09474420f, -0.07360803f, -0.01975185f, 0.09669998f, -0.08267165f, -0.19850244f, 0.09054941f, 0.00223219f, 
    -0.19842368f, -0.01727949f, -0.01897974f, -0.16517602f, 0.12024540f, 0.14334749f, 0.04049385f, -0.07848805f, 
    -0.03156473f, 0.07115004f, -0.03846427f, 0.01066662f, -0.09777195f, -0.03864440f, 0.15658131f, 0.07630610f, 
    0.20778832f, 0.16566142f, 0.23251536f, 0.02817393f, 0.02688645f, 0.09905100f, 0.06485701f, -0.11226513f, 
    -0.37324265f, -0.00853478f, -0.14238471f, -0.07089698f, -0.02059789f, 0.01582760f, -0.11936829f, 0.06308325f, 
    0.03517424f, -0.06153487f, 0.05345862f, -0.08736520f, 0.41813615f, 0.13749750f, 0.10873950f, 0.04904867f, 
    0.05610709f, -0.00493906f, 0.08811673f, -0.09020147f, -0.04290817f, 0.06417213f, 0.01708694f, 0.16974424f, 
    0.12281406f, 0.12288470f, -0.02238044f, -0.09016388f, 0.08919686f, 0.11933962f, -0.06053516f, -0.01283098f, 
    0.07679305f, -0.02143501f, 0.08662788f, -0.18319823f, -0.07343401f, -0.10853947f, -0.16288212f, 0.23098433f, 
    -0.09704162f, -0.11757800f, 0.02168048f, 0.00453630f, -0.07671908f, 0.06287048f, -0.08063287f, -0.08747865f, 
    -0.04600718f, 0.11310487f, -0.04929199f, 0.11397602f, 0.10351580f, 0.09916587f, 0.09835768f, 0.04584815f, 
    0.20107469f, 0.04682466f, 0.01362998f, 0.11942238f, 0.06896547f, -0.07575417f, 0.22834589f, -0.13789681f, 
    0.05409703f, 0.04116819f, 0.07973260f, -0.12947169f, 0.10004893f, 0.03429403f, -0.09094458f, -0.02992343f, 
    -0.02597490f, 0.04525586f, 0.02358182f, -0.11712232f, 0.13132730f, 0.05991880f, 0.00319645f, 0.02223751f, 
    0.07917134f, 0.07689195f, 0.23175772f, 0.17648357f, -0.08062914f, 0.21745713f, 0.13618478f, -0.01366865f, 
    0.08247121f, -0.11790217f, 0.05257377f, -0.07933532f, -0.02439694f, 0.09761781f, 0.06281843f, -0.02231128f, 
    -0.08669768f, 0.05463836f, -0.12144284f, 0.14663580f, -0.12354659f, -0.02478652f, 0.08691546f, 0.04659975f, 
    -0.12118313f, 0.04249503f, 0.09223735f, -0.03283643f, -0.09953672f, 0.15810016f, 0.08423544f, 0.25262636f, 
    0.07834623f, 0.06305021f, -0.06697829f, 0.01994382f, 0.23598289f, -0.18610869f, 0.08529148f, -0.09441051f, 
    0.28050038f, 0.09703781f, 0.08656158f, -0.08787979f, -0.05971058f, 0.08434892f, -0.05667004f, 0.02407632f, 
    -0.01387021f, 0.01682083f, -0.02438082f, -0.07891026f, 0.39513826f, -0.07420066f, 0.03796210f, 0.01938559f, 
    -0.02031756f, 0.04091084f, -0.05128493f, 0.04854533f, 0.10797964f, 0.02071991f, 0.15714824f, 0.14249818f, 
    -0.26636437f, -0.07886920f, 0.21526694f, -0.02945887f, -0.02092631f, -0.01629059f, 0.03548450f, 0.01094045f, 
    0.05692928f, -0.03556296f, -0.04274655f, 0.03372953f, 0.37339592f, 0.10098591f, -0.05811384f, -0.18887146f, 
    -0.03882407f, -0.14568990f, 0.03956117f, -0.03452395f, -0.05894556f, -0.05066376f, -0.00043923f, 0.15225169f, 
    -0.18686856f, -0.06081932f, -0.00904335f, -0.21368265f, 0.11411845f, -0.15510948f, 0.11264757f, 0.06139698f, 
    -0.21702130f, 0.02342537f, 0.03164743f, 0.02472654f, -0.05050837f, -0.13677979f, -0.07138222f, 0.13426344f, 
    -0.12324248f, -0.03295222f, 0.09111252f, 0.10687036f, -0.05729608f, 0.01372139f, 0.04986285f, 0.08606578f, 
    0.06501041f, 0.12638472f, -0.01340426f, -0.12702954f, 0.16037118f, 0.00897302f, -0.01873278f, -0.16740622f, 
    -0.07418293f, -0.02966017f, 0.05856032f, -0.02160190f, 0.17123567f, 0.00587934f, 0.05194689f, -0.06348825f, 
    -0.00840736f, -0.21993062f, 0.03623884f, 0.04482216f, 0.02509853f, -0.04257896f, 0.01179795f, 0.04425301f, 
    -0.03552835f, 0.02332501f, -0.03460408f, 0.03392474f, -0.04417363f, 0.03483430f, -0.03666074f, 0.01129827f, 
    -0.03414240f, 0.02943666f, 0.06351781f, -0.07846957f, -0.04788122f, -0.01346796f, -0.05561794f, 0.05148584f, 
    -0.02398579f, -0.02803028f, 0.03538110f, 0.02847780f, -0.07862534f, -0.01996482f, -0.08430103f, 0.00921536f, 
    -0.06977966f, 0.04911727f, -0.03434990f, -0.06388243f, 0.04147665f, 0.04232028f, -0.03431638f, -0.07537618f, 
    0.03253635f, -0.06239060f, -0.02330875f, -0.06308133f, 0.03150520f, -0.01756256f, -0.07088700f, 0.04381983f, 
    -0.03177534f, 0.02137946f, -0.04666612f, -0.05189718f, -0.02061771f, -0.01466567f, 0.03918352f, -0.07015274f, 
    0.02513641f, -0.03132184f, 0.03609497f, 0.01727354f, 0.02678202f, -0.05042640f, -0.07135407f, 0.04440605f, 
    0.04794102f, -0.06472101f, 0.05969467f, 0.02441473f, 0.05973648f, -0.04073478f, 0.01861879f, 0.00314407f, 
    0.02458373f, -0.02464069f, -0.01948523f, 0.04839649f, -0.05942815f, -0.01381777f, -0.00698979f, -0.04474833f, 
    0.01815953f, -0.03112631f, 0.05679363f, -0.00712797f, -0.07256508f, 0.00060003f, 0.02017805f, -0.01402925f, 
    0.01027847f, 0.01048546f, -0.02929384f, -0.01177388f, 0.02441779f, 0.03398837f, 0.00230136f, -0.06855316f, 
    -0.03560849f, 0.03209198f, 0.04358231f, 0.02908250f, -0.05801618f, -0.04844577f, 0.06155996f, 0.03403432f, 
    0.00589916f, -0.02579887f, 0.05009717f, -0.04444529f, -0.03170983f, 0.04823736f, 0.05057498f, 0.03832290f, 
    0.04219069f, -0.04338882f, 0.05428222f, 0.02505654f, 0.04565911f, -0.06189279f, 0.05176376f, -0.03136262f, 
    -0.05633254f, 0.01306846f, 0.02500958f, -0.06582104f, -0.06750420f, -0.02690283f, 0.01843421f, -0.00419783f, 
    0.05302282f, -0.06044480f, -0.06618544f, -0.06456692f, 0.02324047f, 0.00933848f, -0.05201787f, 0.05032728f, 
    -0.00751069f, -0.00021647f, -0.07275193f, -0.02794902f, -0.05993748f, 0.02319919f, -0.02870429f, 0.02947827f, 
    -0.02667256f, 0.02729194f, 0.02980290f, 0.05292704f, -0.00955074f, 0.02468220f, -0.06872968f, 0.00206853f, 
    0.01079406f, 0.02746950f, -0.03162429f, 0.00090769f, -0.01403101f, -0.02934099f, 0.05406636f, -0.00617866f, 
    -0.07461607f, -0.00597540f, 0.06021048f, -0.03343610f, 0.00219066f, 0.03869842f, -0.05612190f, -0.01543382f, 
    -0.01399196f, -0.07382491f, -0.01280878f, 0.04470068f, -0.05859652f, -0.00771289f, -0.05058521f, -0.06907535f, 
    -0.06852055f, -0.05641458f, -0.07396532f, 0.04332795f, 0.00594120f, -0.03461144f, -0.00837934f, -0.02902305f, 
    0.06413857f, 0.06351285f, 0.00263088f, -0.03454712f, 0.00617346f, 0.01265914f, 0.05429610f, 0.00193038f, 
    -0.03617175f, 0.03044953f, -0.02302656f, 0.01209206f, -0.05264648f, -0.05779655f, -0.00950421f, -0.01151180f, 
    0.17936756f, -0.12762035f, 0.07014558f, -0.15503147f, -0.00913613f, -0.02385434f, 0.04963192f, 0.03548783f, 
    0.07490553f, -0.00971109f, 0.11560698f, 0.07144170f, -0.13188240f, -0.33312881f, -0.32569802f, 0.14252228f, 
    0.04325694f, 0.00288739f, 0.08571505f, -0.00164723f, 0.00891328f, 0.04474142f, 0.13710491f, 0.17500922f, 
    0.15654635f, -0.19200955f, -0.12609901f, -0.18186101f, -0.11209150f, -0.12626483f, 0.00224348f, -0.03161773f, 
    0.05649832f, 0.10392916f, 0.04758010f, 0.11973610f, 0.36210689f, -0.26602700f, 0.00869308f, 0.11763316f, 
    -0.03922069f, -0.03937004f, -0.09194173f, -0.05976838f, 0.15494408f, 0.05985517f, 0.09865551f, -0.19842429f, 
    0.12527557f, 0.15559120f, -0.39825708f, -0.11796258f, -0.01118040f, -0.03307627f, -0.07996575f, -0.04744152f, 
    -0.12290527f, -0.14718868f, 0.10721430f, 0.01356242f, 0.01369976f, 0.30655497f, 0.16032641f, -0.15222023f, 
    0.00460630f, 0.17035310f, -0.01908842f, -0.00990065f, 0.03117952f, 0.05072616f, 0.15855876f, 0.03988933f, 
    0.07393001f, -0.08331677f, 0.00284271f, 0.07361519f, 0.03470010f, -0.14508523f, 0.00400092f, 0.08666018f, 
    0.17554851f, 0.06705528f, 0.02088414f, 0.03277558f, -0.15737705f, -0.09714269f, 0.08128066f, -0.00828667f, 
    -0.10234373f, -0.08718339f, 0.04778531f, 0.19183204f, 0.12282015f, 0.06781058f, 0.07215025f, -0.09896071f, 
    0.05016832f, 0.14034228f, 0.04058349f, -0.04089053f, -0.06513935f, 0.08171954f, 0.08519201f, -0.02365596f, 
    0.08216489f, 0.09690754f, -0.05377950f, -0.02560668f, 0.19849408f, 0.08697013f, -0.07637589f, 0.15643246f, 
    -0.18939382f, -0.21176492f, 0.10399947f, -0.12108672f, 0.14448516f, -0.00500299f, 0.04305706f, 0.11307608f, 
    0.15631534f, 0.00967945f, 0.08737881f, -0.01156429f, 0.00401063f, 0.13339473f, 0.00226106f, -0.01567705f, 
    0.13561332f, 0.04776813f, -0.09556083f, 0.01086895f, 0.39123243f, -0.24206777f, -0.12527616f, -0.13528164f, 
    -0.14931296f, 0.10192744f, 0.07901826f, 0.11991157f, -0.08173795f, -0.20483203f, -0.00087997f, -0.07433424f, 
    0.29780468f, 0.00286697f, -0.01422145f, -0.17518982f, 0.02139684f, 0.08051841f, 0.13916354f, 0.01988804f, 
    0.04544546f, 0.01445939f, -0.04745599f, 0.02776810f, 0.05943150f, -0.19842967f, -0.27864695f, 0.06154202f, 
    0.17471521f, 0.09228399f, -0.01876462f, 0.03432053f, 0.00501780f, -0.00779305f, 0.00792538f, -0.03284300f, 
    -0.11599007f, -0.11202388f, -0.04294502f, -0.01821801f, -0.03831174f, -0.04581754f, 0.07701099f, 0.01107433f, 
    0.04275024f, -0.04949545f, -0.02593194f, 0.08273161f, 0.03828519f, 0.08406416f, -0.19905417f, -0.10607100f, 
    0.06542365f, -0.07536452f, -0.02398381f, 0.00473949f, 0.04698691f, 0.12765938f, -0.05929121f, 0.20437488f, 
    -0.07297716f, -0.12968266f, 0.17124112f, 0.05457078f, 0.01858916f, -0.06986108f, 0.03917962f, -0.14091173f, 
    0.01067000f, -0.12150456f, 0.05316828f, 0.22906311f, -0.08891848f, 0.06133165f, -0.06018320f, -0.10248863f, 
    0.02391416f, 0.12153715f, 0.16927917f, 0.03500482f, 0.02059783f, 0.08201790f, 0.14364585f, 0.18764651f, 
    -0.09005897f, -0.23125647f, 0.02115196f, -0.21792386f, -0.18718740f, -0.07960830f, -0.03199162f, -0.12753864f, 
    -0.07466178f, 0.10317598f, 0.05164862f, -0.11387270f, 0.17944561f, 0.06784541f, -0.10840639f, -0.01744319f, 
    -0.03225800f, 0.08134285f, 0.05397501f, 0.08823394f, 0.15049557f, -0.06187785f, 0.12209607f, 0.10997165f, 
    0.30545259f, -0.10636108f, 0.10002830f, -0.07599927f, 0.02415204f, -0.13133825f, -0.05801322f, 0.02440624f, 
    -0.24261828f, -0.12040371f, -0.05972789f, -0.17165598f, -0.06757002f, 0.08695634f, 0.09199492f, -0.12856565f, 
    0.03512315f, 0.01531266f, 0.05578069f, 0.05320358f, 0.03346981f, -0.04930196f, -0.09676228f, 0.07659175f, 
    -0.05518233f, -0.01606253f, 0.02370845f, 0.07866505f, 0.08265129f, -0.10934515f, -0.05147621f, -0.13611436f, 
    0.13731326f, 0.18809882f, -0.06709954f, 0.04438158f, -0.02958110f, -0.12940083f, -0.07326584f, -0.06791937f, 
    0.13102835f, -0.11792110f, 0.13707493f, 0.01668408f, -0.05209485f, 0.15591033f, 0.05037064f, 0.01023051f, 
    -0.23187391f, 0.29034531f, -0.00823256f, 0.16637099f, 0.09009038f, -0.08770615f, -0.00992994f, 0.02934684f, 
    0.03266781f, 0.16652270f, -0.00546581f, 0.03006867f, 0.06518108f, 0.02317064f, -0.10379722f, 0.13052665f, 
    -0.03755207f, -0.02737713f, 0.00762576f, 0.03469534f, 0.04424410f, -0.00871152f, -0.00542490f, -0.08353769f, 
    -0.01143937f, -0.00360627f, 0.15033418f, -0.06284895f, 0.07292794f, 0.04218095f, -0.17476664f, -0.06495031f, 
    -0.01644251f, -0.01552799f, 0.00311243f, 0.01602423f, 0.01684539f, -0.03583065f, 0.18452138f, -0.05154380f, 
    0.13808149f, 0.09908121f, -0.00034830f, 0.09033009f, 0.11913816f, 0.02113443f, 0.13605198f, -0.06835131f, 
    0.25630829f, 0.27639496f, 0.13046548f, 0.00830611f, 0.03668711f, 0.00232542f, 0.07641225f, 0.01827184f, 
    0.01964072f, -0.01942635f, 0.05827050f, -0.03389299f, 0.01143378f, 0.26312375f, -0.09371575f, -0.27516568f, 
    0.11551680f, 0.05196636f, -0.07638002f, -0.00348292f, -0.00103087f, 0.05782653f, -0.04886626f, -0.01440675f, 
    -0.15975094f, -0.06916458f, -0.01979351f, 0.11634214f, -0.08172195f, 0.04673921f, -0.11862490f, 0.06576908f, 
    0.09541048f, -0.08849310f, -0.04285956f, 0.02551315f, 0.10484486f, 0.15416676f, 0.02513801f, 0.14784792f, 
    -0.02358082f, 0.09314767f, 0.00916665f, -0.01521699f, -0.04197625f, 0.13892661f, 0.01023938f, -0.01736311f, 
    -0.18472670f, -0.06817408f, -0.29998437f, -0.02011816f, 0.02736867f, 0.01648303f, -0.08890954f, 0.08220419f, 
    0.11237619f, 0.15513968f, 0.03105186f, -0.23675483f, -0.06196997f, 0.18945400f, 0.04003436f, 0.05106030f, 
    -0.08166863f, -0.14201596f, -0.06687523f, -0.02980169f, 0.05975866f, 0.08470866f, -0.01985423f, -0.02028090f, 
    -0.17381462f, -0.19030190f, 0.03758586f, 0.19197257f, 0.07186575f, 0.00215458f, 0.10873998f, 0.06812757f, 
    0.07340131f, -0.03718220f, -0.00462241f, 0.13251846f, 0.14961006f, 0.13910431f, 0.21265864f, -0.04376499f, 
    0.03387257f, 0.04262536f, 0.01276209f, -0.07547700f, -0.06307563f, 0.06119431f, -0.06507323f, 0.01550022f, 
    0.17237547f, 0.05527453f, 0.01740396f, 0.18289006f, -0.01439144f, 0.03105280f, 0.08507975f, 0.04219414f, 
    0.15938401f, -0.13436598f, 0.11129984f, 0.18531340f, -0.18692656f, -0.25766084f, -0.02564868f, 0.07385274f, 
    0.04000589f, -0.02208246f, 0.04799384f, 0.00840976f, -0.07021793f, 0.10359622f, 0.15253462f, 0.01235573f, 
    -0.34071901f, 0.02176150f, -0.08614991f, -0.16992848f, -0.08874264f, 0.10938483f, -0.04369513f, 0.11492150f, 
    -0.09539408f, -0.00530856f, -0.03452935f, 0.09770247f, -0.04331967f, -0.14155976f, -0.24895644f, -0.20597076f, 
    0.17814523f, 0.10768471f, -0.08662907f, 0.12899226f, 0.16118103f, -0.11432809f, 0.00120344f, 0.07674354f, 
    0.00612570f, -0.19792077f, 0.06516293f, -0.05446189f, -0.10897268f, -0.05377103f, 0.01804888f, 0.09889161f, 
    0.11053566f, -0.05269193f, -0.00641142f, 0.04015807f, 0.16619837f, -0.14770429f, -0.34885788f, -0.13134961f, 
    0.09065291f, -0.01591968f, -0.11171702f, -0.03073685f, -0.08049802f, 0.05434661f, 0.11637906f, 0.02150751f, 
    -0.33527362f, 0.01406734f, 0.06116670f, -0.05976684f, 0.05090117f, -0.04434313f, 0.21174158f, 0.07874787f, 
    0.12378276f, 0.04144044f, -0.04059689f, -0.05574632f, 0.17701344f, 0.01945775f, -0.07045803f, -0.18620789f, 
    -0.06218539f, -0.10061479f, -0.02408510f, 0.11161455f, -0.05763559f, -0.03293392f, 0.04770432f, 0.07237799f, 
    -0.21328318f, -0.01869273f, 0.07086206f, -0.01962574f, 0.09590095f, 0.00580739f, -0.02635790f, 0.08082709f, 
    -0.06754126f, 0.05404062f, 0.03038699f, 0.01109319f, -0.08454097f, -0.13146137f, 0.29719698f, 0.33929169f, 
    -0.00801248f, -0.00114389f, 0.20557272f, -0.01633791f, -0.02616279f, 0.06195325f, 0.04040040f, 0.10311424f, 
    -0.40043133f, -0.34303597f, -0.28562602f, -0.02138374f, 0.08530837f, 0.14927748f, 0.01175426f, 0.12467330f, 
    0.05385180f, 0.00545163f, 0.10901365f, -0.03975572f, 0.29037955f, 0.17320351f, 0.21738259f, 0.04354513f, 
    0.13456438f, -0.10594140f, -0.07336275f, 0.03310101f, 0.15680757f, -0.06540902f, -0.02092577f, 0.10816292f, 
    0.35771531f, 0.15352997f, 0.04326152f, -0.10984791f, -0.01975166f, 0.05123545f, 0.00531938f, 0.02929569f, 
    -0.05659524f, 0.07032980f, 0.06598338f, -0.02499987f, 0.11277475f, 0.02141491f, -0.16620265f, 0.06026684f, 
    -0.05675761f, -0.06580003f, -0.08730632f, -0.24947779f, -0.07778887f, -0.10257491f, -0.06127734f, -0.05211627f, 
    0.03082624f, 0.08439758f, -0.08697093f, -0.14590792f, 0.01138608f, 0.07391725f, -0.10947151f, -0.06273130f, 
    -0.13270631f, 0.24437417f, -0.15413490f, -0.20891297f, -0.01505916f, 0.14334747f, 0.05125082f, 0.02744811f, 
    -0.10198765f, 0.02772303f, 0.02191611f, -0.00123995f, 0.13347892f, 0.05291254f, -0.06826574f, 0.02082145f, 
    0.07409384f, -0.19305933f, 0.03972361f, -0.01715457f, 0.18752189f, -0.20034873f, -0.15634799f, 0.08294509f, 
    -0.00742730f, -0.13540244f, 0.11488059f, 0.02478953f, -0.24332505f, 0.21891370f, 0.04042742f, -0.17471637f, 
    0.19265050f, -0.09413443f, -0.13286109f, -0.08449245f, 0.09017686f, -0.09104289f, -0.14899203f, -0.15962619f, 
    0.04008030f, -0.22831224f, -0.18623619f, -0.15215653f, -0.03053414f, -0.09297566f, -0.02642490f, -0.09957968f, 
    -0.09044823f, -0.00313912f, 0.04780161f, -0.10834362f, 0.03529030f, 0.11562154f, 0.14304484f, 0.04384692f, 
    0.07834003f, 0.01287742f, -0.00602148f, -0.06330575f, -0.06475554f, -0.00703594f, 0.03212186f, -0.19946840f, 
    0.23691647f, 0.31109539f, -0.02910944f, 0.13146003f, 0.01142642f, -0.13613151f, 0.02841689f, 0.00994122f, 
    -0.03299324f, 0.14258508f, 0.16852389f, -0.17182390f, 0.14838833f, 0.19187099f, 0.06360102f, -0.18052010f, 
    0.07066278f, 0.02425073f, 0.02017745f, 0.03929932f, 0.04847277f, -0.03414606f, 0.11146937f, -0.04874094f, 
    0.04673357f, 0.04684909f, 0.04166991f, -0.08027887f, 0.04357159f, -0.04386332f, -0.12304341f, 0.01187738f, 
    0.09914556f, 0.00549623f, -0.18537244f, 0.04436214f, 0.24781597f, 0.40207097f, -0.09119241f, 0.08646588f, 
    0.06906985f, 0.13292560f, 0.15167770f, -0.05770719f, 0.17333259f, 0.08223053f, -0.09377271f, -0.02332898f, 
    -0.10340646f, 0.16043672f, 0.15192446f, -0.03520957f, -0.00013891f, -0.17109035f, -0.13997336f, -0.11853318f, 
    -0.00763045f, -0.01442522f, 0.06144935f, 0.03934344f, 0.07000190f, 0.25541320f, 0.11149690f, -0.03488132f, 
    -0.08787509f, -0.16848594f, -0.11918963f, 0.07853652f, 0.10621202f, 0.00466732f, -0.01987024f, -0.06924970f, 
    0.29898706f, 0.14380875f, -0.14432052f, -0.20605874f, 0.09541145f, 0.04941944f, -0.07001305f, -0.08974811f, 
    0.00200187f, -0.14001791f, 0.03277419f, -0.08573134f, 0.00163256f, -0.01421066f, -0.00962494f, 0.09706563f, 
    0.20703997f, -0.10478741f, -0.15556297f, -0.10922004f, 0.19023809f, 0.12988213f, -0.02359881f, -0.11612429f, 
    -0.05722287f, -0.03963986f, -0.00294229f, -0.06915191f, -0.04625692f, -0.02226615f, 0.03774454f, -0.07152271f, 
    -0.07665503f, -0.00334010f, 0.03670338f, -0.04843643f, 0.05985555f, 0.04081607f, -0.06655724f, 0.01628180f, 
    -0.05385053f, -0.02677155f, 0.04374766f, -0.03289166f, 0.02965379f, -0.04654273f, 0.03228023f, -0.05207442f, 
    -0.06823280f, 0.06152167f, 0.02620748f, -0.03501914f, -0.01029262f, -0.03396466f, 0.01453062f, -0.01481947f, 
    -0.02199647f, 0.05525595f, 0.04454250f, 0.02409782f, -0.03722684f, -0.04270376f, -0.01985128f, 0.03701770f, 
    -0.02369451f, -0.05589353f, -0.04128030f, 0.02629765f, 0.06249913f, 0.05197799f, 0.03632269f, -0.03324818f, 
    -0.02796542f, -0.02894015f, 0.00453161f, 0.06485812f, 0.05829990f, 0.00959143f, -0.03046319f, -0.03352620f, 
    0.04909095f, 0.05151151f, -0.05842690f, -0.01836514f, 0.02946465f, -0.02210183f, -0.02505832f, -0.06548887f, 
    -0.06376207f, 0.06395824f, -0.00495568f, 0.02129618f, 0.02427048f, 0.02866016f, 0.02274000f, 0.04400458f, 
    -0.05291438f, -0.02741360f, -0.03713647f, 0.02690761f, -0.04699039f, 0.03188445f, 0.00292675f, 0.04111144f, 
    0.00167380f, -0.01862155f, -0.05519381f, 0.02450697f, -0.06903639f, 0.03611086f, -0.05290954f, -0.04487372f, 
    0.02551182f, -0.04116017f, 0.01688343f, -0.01016616f, -0.05442160f, -0.05478240f, -0.06786992f, -0.02867551f, 
    -0.03183085f, -0.02592057f, -0.03337698f, 0.03198403f, -0.00948619f, -0.05165447f, -0.02490105f, -0.07194669f, 
    0.02453094f, 0.02854954f, -0.05311108f, -0.07248279f, -0.02968477f, 0.03395792f, 0.03839396f, 0.02037514f, 
    -0.06955394f, -0.07428375f, -0.01056645f, -0.00697996f, -0.01556627f, -0.03062342f, 0.05903779f, -0.00920867f, 
    -0.07804941f, 0.00537660f, -0.06518400f, 0.01150466f, 0.01395538f, -0.05939836f, 0.04420335f, -0.02325177f, 
    -0.07498273f, 0.00452755f, -0.06508242f, -0.06483269f, 0.00225614f, -0.07658467f, 0.04917627f, 0.05911248f, 
    0.04911285f, -0.02163535f, -0.03899049f, -0.06768905f, 0.04665063f, -0.02457128f, -0.02964784f, 0.01660534f, 
    0.00612817f, 0.05273901f, 0.00087105f, -0.06626849f, -0.05288439f, -0.05842445f, 0.05708660f, -0.06251868f, 
    -0.04741683f, -0.03927813f, -0.01115667f, -0.07719803f, 0.00370089f, -0.07252562f, -0.01701331f, 0.02335191f, 
    0.02552550f, -0.01345194f, -0.00420307f, 0.00786503f, -0.05669897f, -0.04962383f, -0.03060943f, -0.05648423f, 
    0.02939291f, 0.06325298f, -0.05201837f, -0.06127706f, -0.01563799f, -0.03858091f, 0.02099915f, 0.05695901f, 
    0.04869614f, -0.02044649f, 0.02239064f, -0.02207490f, 0.02260316f, -0.02429978f, -0.03447926f, 0.04738309f, 
    0.00838599f, -0.04562176f, 0.03570011f, -0.05582855f, -0.00812870f, -0.02279112f, -0.01949139f, -0.07841011f, 
    0.11646293f, 0.04113642f, 0.13073617f, 0.05757095f, 0.00849396f, -0.04234307f, -0.02784756f, 0.09422218f, 
    -0.09226649f, 0.01903416f, -0.06456538f, 0.16806310f, -0.15378520f, -0.04999486f, -0.11477128f, 0.03728569f, 
    0.03320125f, 0.05740899f, 0.01794212f, 0.02072379f, 0.01750605f, -0.01022359f, 0.06357717f, -0.00790486f, 
    -0.01804017f, -0.00646356f, 0.21804392f, 0.22655615f, 0.09120665f, -0.02394247f, 0.00878288f, 0.07800085f, 
    0.04945107f, 0.09026029f, 0.17826495f, 0.02352000f, -0.19560367f, 0.08389862f, -0.18463534f, -0.26346388f, 
    0.08372571f, 0.00686351f, -0.09776568f, 0.02219683f, 0.02529735f, 0.00341518f, -0.00284804f, 0.01820152f, 
    -0.32762188f, -0.09720913f, -0.07656275f, -0.06774621f, -0.07254501f, -0.02915776f, -0.06754855f, 0.02471210f, 
    -0.03532797f, 0.13200882f, 0.02484643f, -0.09547943f, 0.01054052f, 0.04205655f, 0.04031408f, -0.20640621f, 
    0.10618183f, 0.08865654f, -0.02310629f, 0.06266018f, 0.06201264f, 0.11697469f, -0.04024978f, -0.00665231f, 
    0.13953464f, 0.06554212f, 0.03241974f, -0.07464510f, 0.11977198f, -0.00739604f, -0.02498368f, 0.12134608f, 
    0.06268223f, 0.01879665f, 0.02836250f, 0.00097334f, 0.11145785f, 0.17786768f, -0.09532308f, -0.06608027f, 
    0.07545277f, 0.17932986f, -0.01122131f, 0.10959869f, -0.14848612f, -0.02505869f, 0.16168645f, -0.00578281f, 
    0.10972349f, -0.10336325f, -0.04290942f, 0.30657646f, -0.00961754f, -0.08509185f, -0.00967084f, 0.08018830f, 
    -0.05632360f, -0.15203208f, -0.00926237f, 0.04736338f, 0.52019674f, -0.15518598f, -0.09458730f, 0.02408237f, 
    0.01925279f, 0.11649633f, -0.04551233f, 0.06220580f, -0.08831800f, 0.02606213f, -0.07857791f, 0.01669893f, 
    -0.12606443f, 0.19901614f, 0.00606793f, -0.14483531f, 0.05025004f, 0.05120745f, 0.06553317f, 0.04839600f, 
    -0.05505784f, 0.12855625f, -0.01807093f, 0.06024018f, 0.11508298f, 0.40554738f, 0.15037182f, -0.03729832f, 
    -0.14580378f, -0.12611116f, -0.01246327f, 0.15073377f, 0.08252312f, 0.00988302f, -0.00213285f, 0.02320805f, 
    -0.24433728f, -0.17283738f, 0.21021788f, -0.15783417f, -0.10009923f, -0.02248667f, 0.06317625f, -0.14279565f, 
    -0.01100200f, 0.00232876f, 0.09626465f, 0.07087245f, -0.37117454f, -0.19686723f, 0.11536099f, 0.00720466f, 
    -0.06448708f, -0.08589512f, 0.02768024f, -0.03797290f, 0.05709398f, 0.22008310f, -0.06476105f, 0.04110231f, 
    0.01525432f, -0.02827299f, 0.05046318f, 0.26768652f, 0.02229085f, 0.08873572f, 0.15582354f, 0.01754134f, 
    0.01174176f, -0.04445468f, -0.08738662f, 0.01417296f, -0.18151578f, -0.18257384f, 0.06936697f, -0.25291562f, 
    0.01217122f, 0.03217632f, 0.08165628f, -0.06663594f, -0.00615597f, -0.02372099f, 0.06375512f, 0.04031272f, 
    0.26082069f, 0.00867215f, 0.20107371f, -0.01681398f, -0.01566920f, -0.10911273f, 0.08688638f, -0.00141680f, 
    -0.04869996f, 0.07648791f, 0.01117011f, 0.30090567f, 0.00178796f, 0.07692987f, 0.00661242f, 0.12484525f, 
    -0.05355981f, 0.07424340f, 0.10412886f, -0.06845557f, 0.07960518f, 0.07197609f, 0.14267801f, 0.25721511f, 
    -0.02303356f, 0.00227836f, 0.06473747f, -0.12659892f, -0.04004356f, -0.07325315f, 0.04608850f, 0.01172290f, 
    -0.02055780f, 0.14682351f, 0.02411589f, -0.05661264f, 0.14823851f, 0.08474295f, -0.17111421f, 0.14661676f, 
    -0.10200507f, 0.02602815f, -0.00281144f, -0.00852474f, 0.09179125f, 0.02490984f, 0.03126035f, -0.04327685f, 
    -0.01601189f, -0.04579607f, -0.04560873f, -0.17193475f, -0.05079969f, -0.07196879f, 0.03179205f, -0.02157003f, 
    -0.15873732f, -0.03082938f, -0.14120670f, -0.16330661f, -0.03837250f, 0.03040325f, -0.06637017f, -0.35266933f, 
    0.04019089f, 0.03654969f, -0.00802222f, 0.06010000f, 0.06043489f, -0.05464247f, -0.15629509f, 0.04648096f, 
    0.17152074f, -0.05675301f, -0.05642890f, 0.03345972f, 0.22214024f, -0.06871117f, -0.02387207f, -0.04638793f, 
    0.19178022f, 0.25488743f, 0.02758028f, -0.02832353f, 0.10475481f, 0.05286440f, -0.17883085f, 0.07281350f, 
    -0.06815115f, -0.01528025f, 0.22754306f, 0.07326818f, -0.13384704f, 0.22008400f, -0.13393913f, -0.03514097f, 
    0.03335533f, 0.12849696f, 0.13766545f, 0.13989142f, 0.09693498f, -0.10255990f, 0.04800028f, 0.11645588f, 
    -0.14824246f, 0.07842519f, -0.00527623f, 0.06021380f, 0.49220309f, -0.05375902f, 0.05686756f, 0.03745107f, 
    -0.12823425f, 0.12554267f, -0.03280144f, 0.03971507f, -0.06353022f, 0.02271030f, 0.03889846f, -0.05339989f, 
    0.09193636f, 0.12003903f, 0.07324150f, -0.28456077f, 0.06695263f, 0.08299361f, -0.07051142f, -0.06932420f, 
    -0.11596863f, -0.00635759f, -0.05765530f, 0.00227579f, 0.12564796f, 0.10168690f, 0.16224107f, -0.01817635f, 
    0.01169488f, 0.06880167f, 0.13202699f, 0.20805357f, 0.03812687f, 0.07221141f, 0.06587511f, -0.00653981f, 
    0.03466280f, -0.05800709f, 0.02349318f, -0.06648441f, -0.09880441f, -0.06097992f, 0.02923880f, -0.11453244f, 
    0.03979591f, -0.04437599f, 0.09176539f, 0.11936095f, 0.11762888f, 0.07749671f, -0.10664819f, -0.06395727f, 
    -0.01699238f, 0.06687295f, -0.05858254f, 0.00178136f, 0.11110895f, 0.10389680f, -0.19603944f, -0.07479376f, 
    -0.07158975f, 0.04851680f, 0.01796678f, 0.00220165f, 0.01803391f, 0.11778028f, 0.11762348f, 0.16325735f, 
    0.06488873f, -0.01963677f, -0.06470658f, 0.07513772f, -0.10449615f, 0.06612673f, 0.06117689f, -0.00974819f, 
    -0.00237877f, 0.02125331f, 0.12180211f, 0.02785405f, -0.07043432f, 0.01524670f, 0.02645034f, -0.09252984f, 
    0.19256197f, -0.06520242f, -0.03255502f, 0.04661409f, -0.01723780f, -0.06439308f, 0.06338710f, 0.09461616f, 
    0.02612527f, 0.06995076f, -0.04678514f, 0.10630250f, -0.28453779f, -0.15332335f, -0.13772251f, 0.02798989f, 
    -0.04208823f, 0.03768158f, 0.18622248f, 0.10550065f, 0.04369153f, 0.04154649f, 0.11892370f, 0.15222105f, 
    0.28241640f, -0.25585553f, -0.10903107f, -0.13440096f, -0.17962198f, -0.07703140f, -0.05203344f, -0.04652103f, 
    0.03037854f, -0.06032830f, 0.10264249f, 0.07287990f, 0.16259174f, -0.20133139f, 0.00224836f, 0.01078279f, 
    0.00085076f, 0.06222374f, 0.02272323f, -0.00027389f, 0.17065454f, 0.01929000f, 0.06670988f, -0.02872199f, 
    -0.01149866f, 0.03059663f, -0.18744496f, 0.08462726f, -0.14868106f, -0.01419649f, 0.07577707f, 0.11370413f, 
    -0.10027277f, 0.17844549f, 0.03237900f, 0.01615916f, 0.09695804f, 0.13374647f, -0.00136106f, 0.05402340f, 
    0.13822456f, 0.17134000f, 0.11586724f, 0.05785248f, 0.06418770f, -0.06745017f, -0.00779148f, -0.02528311f, 
    0.16806486f, -0.02171130f, -0.12331656f, -0.00469316f, 0.20460241f, -0.04003997f, -0.14029695f, -0.01546224f, 
    0.11996439f, 0.06044202f, -0.02026309f, -0.00242535f, 0.04941126f, 0.00446588f, -0.01879570f, 0.00142216f, 
    -0.14040361f, -0.02523648f, 0.04811175f, 0.06788983f, -0.04520941f, 0.09358171f, -0.05542262f, -0.11686577f, 
    -0.14245859f, -0.01954850f, -0.07767154f, 0.23411052f, -0.02013553f, -0.09034558f, 0.10564874f, 0.05821659f, 
    -0.07762799f, 0.03085548f, 0.02802953f, -0.07974448f, 0.37845859f, 0.10734505f, -0.11491843f, 0.24706557f, 
    -0.11231112f, -0.04808910f, -0.00950665f, 0.02408948f, -0.11877244f, 0.04526605f, 0.00883731f, 0.05746041f, 
    0.30805358f, -0.05763874f, 0.05682949f, -0.10093267f, 0.20874742f, 0.11122797f, 0.02189315f, 0.07226398f, 
    -0.00752494f, 0.08513936f, -0.07249780f, -0.03253428f, 0.05840475f, -0.16865332f, 0.16942647f, -0.10605871f, 
    -0.01466218f, -0.06281721f, 0.19350053f, 0.24437222f, 0.02032320f, 0.04331004f, -0.04015887f, -0.04239078f, 
    0.19512060f, -0.03659824f, 0.16827483f, -0.03976975f, 0.04271746f, -0.04008457f, 0.13694084f, 0.07300338f, 
    0.10716987f, 0.00394567f, 0.08732526f, -0.04588159f, -0.15903056f, -0.11047319f, 0.03899570f, 0.02591076f, 
    0.01967147f, 0.02497821f, -0.08345802f, 0.05330595f, 0.14671136f, 0.02320875f, -0.15960985f, -0.04427069f, 
    -0.02817613f, -0.17740403f, -0.13705885f, 0.01087021f, -0.13647005f, -0.08489083f, 0.10350908f, -0.00259037f, 
    0.05254210f, -0.06212295f, 0.03017075f, 0.03664805f, -0.34084204f, -0.24984376f, -0.00279614f, -0.09838818f, 
    0.10074220f, -0.10097253f, 0.18436222f, 0.05240068f, -0.01652798f, 0.02510609f, 0.04836642f, 0.06167511f, 
    -0.13510421f, -0.12377856f, -0.11491097f, 0.04438242f, 0.01434470f, 0.04842761f, -0.03732263f, 0.10814758f, 
    0.07476111f, 0.11278928f, -0.10885593f, -0.24034023f, -0.01298966f, -0.09202287f, -0.12179981f, 0.26548406f, 
    0.06249475f, -0.17393546f, -0.13045712f, 0.00082092f, -0.02279905f, 0.06282819f, -0.07231089f, -0.12116148f, 
    -0.02858554f, -0.08642364f, 0.06829841f, 0.13432832f, 0.20591778f, 0.14273278f, 0.10868216f, 0.14545873f, 
    0.14528805f, -0.08015407f, -0.02467505f, 0.27417788f, -0.13670963f, -0.16123216f, -0.01780454f, 0.09655525f, 
    0.02315177f, 0.02405501f, 0.02549360f, -0.02865315f, 0.05932159f, 0.10578603f, 0.07120613f, 0.07152625f, 
    0.01515542f, -0.09002233f, -0.16669269f, 0.25735724f, -0.13021676f, 0.25433281f, -0.01607442f, -0.05118801f, 
    0.12148834f, -0.02858948f, 0.17197882f, 0.17765717f, -0.09536894f, 0.24477236f, 0.00043242f, -0.11832424f, 
    -0.08301379f, 0.09634133f, 0.06828000f, 0.10905130f, 0.12130861f, 0.16229218f, 0.22960068f, 0.08120642f, 
    -0.03091476f, 0.06534708f, -0.00193028f, -0.22239891f, -0.02091316f, 0.14145550f, 0.03582636f, 0.13575257f, 
    -0.01090197f, -0.15793574f, -0.09157497f, 0.08124035f, -0.20916596f, -0.02591683f, 0.02048216f, -0.14205627f, 
    -0.03415057f, 0.07881616f, -0.06490000f, 0.04392041f, 0.03902541f, -0.04532509f, 0.00315168f, 0.22235018f, 
    -0.10224256f, 0.03570212f, -0.06036659f, 0.16446082f, 0.01134104f, -0.08565579f, 0.10943557f, -0.00452426f, 
    0.06358505f, -0.10929710f, 0.11071988f, 0.06867343f, -0.40001011f, 0.09607594f, -0.17624615f, 0.15523729f, 
    0.14805186f, -0.09689709f, -0.03866157f, 0.11952589f, -0.03431033f, 0.11748029f, 0.14265156f, -0.02697573f, 
    -0.26037878f, -0.02765005f, 0.02838067f, -0.23311596f, 0.01942514f, 0.00483980f, 0.21641776f, 0.00322297f, 
    0.09161512f, 0.02905446f, 0.13912775f, -0.04131132f, 0.21589530f, -0.05988469f, -0.03531660f, -0.02492318f, 
    -0.01992691f, 0.07091592f, -0.00176404f, 0.04787985f, -0.01620496f, -0.10294544f, -0.10181504f, -0.00273109f, 
    0.15203634f, 0.04611994f, 0.27749360f, -0.20820074f, 0.03491086f, 0.16976523f, -0.09894498f, 0.01931551f, 
    0.00193767f, -0.03757274f, -0.02539732f, -0.06420512f, 0.03459945f, -0.24245749f, 0.19708051f, 0.24348193f, 
    0.00218123f, -0.02430346f, 0.01006810f, -0.06380815f, 0.05991174f, 0.06555488f, 0.05409244f, -0.01359877f, 
    -0.03887366f, -0.17457193f, 0.05802315f, -0.05139802f, -0.00236336f, -0.08578370f, 0.03185466f, -0.05529377f, 
    0.06542553f, 0.03199582f, 0.07369151f, -0.15271869f, 0.37644851f, -0.03265730f, -0.03917132f, -0.13335459f, 
    0.10665710f, -0.01276950f, -0.07179488f, -0.06231150f, 0.07465109f, 0.05480823f, 0.07163939f, 0.10999692f, 
    -0.30472174f, -0.04892303f, 0.04839727f, 0.03374460f, 0.19587286f, 0.07246653f, 0.05319830f, -0.05221872f, 
    0.07858694f, -0.04843181f, 0.02338352f, 0.26165661f, 0.09711085f, 0.08291052f, 0.01750232f, 0.34852198f, 
    0.04490140f, 0.13866787f, 0.13485876f, -0.05808436f, 0.07973121f, 0.00401075f, 0.15832433f, 0.22707443f, 
    -0.10274700f, -0.21296549f, -0.26844022f, 0.02319145f, -0.01847200f, 0.03631629f, 0.03659199f, 0.12188143f, 
    0.01756218f, 0.07593851f, 0.01106698f, -0.02772045f, 0.08695877f, 0.30839762f, -0.17989737f, -0.07892054f, 
    -0.03830301f, -0.01091206f, 0.07048306f, 0.10166396f, 0.07739189f, 0.02013653f, 0.16652447f, 0.04903009f, 
    0.14385745f, -0.13321286f, 0.04751539f, -0.14078580f, -0.08339949f, -0.12166973f, 0.02058883f, -0.07219392f, 
    -0.19559889f, -0.06072509f, -0.10083195f, -0.22502576f, -0.33827603f, 0.03078428f, 0.13109817f, -0.18055063f, 
    -0.05890704f, 0.13069242f, 0.13569169f, 0.05737971f, 0.06750920f, -0.15723947f, -0.05293674f, 0.09011832f, 
    -0.15621334f, -0.07110596f, -0.10715608f, 0.17073414f, 0.00274974f, 0.01250839f, -0.02884310f, -0.05840350f, 
    0.10520229f, 0.08304624f, -0.04348433f, 0.03201019f, -0.07917044f, 0.01227228f, -0.05037270f, -0.00526104f, 
    0.17371234f, -0.00460315f, 0.06504846f, 0.01211551f, -0.11252599f, 0.22686265f, 0.04864743f, 0.06346187f, 
    0.10580906f, 0.18771699f, -0.04545778f, -0.06335387f, 0.04482917f, 0.05312079f, 0.04656118f, 0.15467027f, 
    -0.04569189f, 0.12431300f, 0.10336691f, 0.05378856f, -0.31000340f, 0.13656519f, -0.18448019f, 0.14926001f, 
    -0.06812993f, -0.13540362f, 0.03590751f, 0.11904357f, -0.04128871f, -0.05298832f, -0.06965210f, -0.09356350f, 
    -0.03535878f, -0.10356786f, 0.19275443f, -0.05671030f, -0.08378938f, 0.06649911f, 0.02422273f, -0.01020588f, 
    -0.13079728f, -0.03960334f, -0.13052942f, -0.07228654f, -0.08855151f, -0.05193291f, 0.14786936f, -0.21306242f, 
    0.06135838f, 0.14355548f, -0.05408403f, 0.07073229f, 0.07065950f, 0.10470901f, -0.00550200f, -0.06355398f, 
    0.26867655f, 0.07002106f, 0.08634399f, -0.11131033f, -0.14345448f, 0.04673911f, 0.09156355f, 0.12274197f, 
    -0.05701990f, -0.01055701f, -0.03288044f, 0.00015700f, 0.30901125f, 0.23628807f, -0.06410625f, 0.09876046f, 
    -0.03618987f, 0.01426984f, -0.06289485f, 0.12876253f, 0.01705191f, -0.08752475f, -0.14072861f, 0.10601839f, 
    -0.01702728f, -0.14393300f, 0.05225759f, 0.04856400f, 0.01623617f, 0.08262640f, -0.01586512f, 0.15306011f, 
    0.20518002f, 0.00075681f, 0.01842544f, 0.05033007f, 0.23129885f, 0.15832660f, 0.11470401f, 0.05442904f, 
    -0.10348583f, 0.08103342f, 0.01218114f, 0.08149969f, -0.00934651f, 0.13952972f, 0.04455676f, -0.08412138f, 
    0.23339336f, -0.04529542f, 0.07393489f, 0.06211641f, -0.09185886f, -0.02772647f, 0.17636785f, -0.09176141f, 
    0.07852294f, -0.07419031f, -0.01183054f, 0.24690649f, -0.13848358f, -0.08387936f, 0.08446627f, -0.25581342f, 
    -0.01689889f, 0.14683378f, 0.02046799f, -0.01968032f, 0.06413461f, 0.02418379f, -0.04491865f, 0.20116098f, 
    0.19059561f, -0.06101546f, -0.20696786f, -0.29426283f, -0.09056461f, -0.07940068f, -0.11766474f, -0.07668561f, 
    -0.10432456f, 0.08803915f, 0.04715166f, -0.02669307f, 0.00860966f, 0.06651519f, -0.02777470f, 0.07767933f, 
    0.04250792f, -0.10560860f, 0.09812634f, 0.06243590f, 0.11728781f, -0.01632228f, 0.02635345f, 0.12479366f, 
    0.04542610f, -0.03032450f, 0.06307423f, 0.02687697f, -0.04289931f, -0.08924661f, 0.04315068f, 0.04855490f, 
    -0.10171098f, 0.01010377f, -0.13632211f, -0.09576763f, 0.13275310f, -0.10453635f, 0.04764314f, 0.13008776f, 
    0.08093359f, 0.14218585f, 0.07402047f, 0.01035065f, 0.03348542f, -0.04895821f, -0.02450188f, 0.05623074f, 
    0.04749439f, 0.07849593f, -0.01643262f, -0.06853950f, 0.02198224f, 0.00740044f, 0.06579587f, -0.12158656f, 
    0.01577995f, 0.19817427f, -0.02145795f, 0.09618504f, 0.06479765f, -0.08350836f, 0.04724765f, 0.07786117f, 
    0.05457161f, -0.11465895f, -0.01345356f, -0.01765620f, -0.06711162f, 0.10046896f, 0.03837172f, 0.06898537f, 
    -0.26235464f, 0.09122914f, -0.01613990f, 0.02389040f, 0.05143709f, -0.11159224f, 0.16485329f, 0.02651954f, 
    0.00187804f, 0.17251761f, -0.01833698f, 0.04134202f, -0.06279192f, 0.14468026f, -0.11374376f, 0.10168923f, 
    -0.03004133f, 0.03982088f, 0.05939645f, 0.00852542f, 0.09477764f, -0.02841516f, 0.01975842f, -0.08788203f, 
    0.29586533f, -0.13933411f, -0.00551891f, 0.12572992f, 0.07197655f, 0.09484416f, -0.06827530f, 0.04599297f, 
    0.07090843f, 0.09948906f, 0.01664180f, 0.08251235f, -0.09592253f, -0.27253065f, 0.02729508f, 0.02792999f, 
    0.02895498f, 0.13219751f, 0.06647640f, 0.13287570f, 0.06131403f, -0.01955981f, 0.04191219f, -0.20388116f, 
    0.20242408f, 0.17873289f, 0.16811207f, 0.24220054f, 0.15463285f, 0.05723434f, 0.09446020f, 0.05251795f, 
    0.06664480f, 0.11389474f, 0.05784814f, 0.08748993f, -0.05368483f, 0.29541296f, 0.04838818f, -0.27975699f, 
    0.11882569f, 0.01070580f, -0.04401759f, -0.03751468f, 0.00898103f, -0.00552026f, -0.12624516f, -0.04040106f, 
    0.13292952f, -0.02747376f, -0.09893708f, -0.02892124f, -0.18624702f, -0.05999632f, -0.01161630f, -0.05817714f, 
    -0.03080474f, 0.05776100f, -0.11501240f, 0.11639389f, -0.26418230f, -0.02637822f, -0.01516258f, 0.17667636f, 
    0.06737516f, 0.14237404f, 0.07235958f, 0.01977304f, 0.03767101f, 0.00508385f, 0.14110403f, 0.00338994f, 
    -0.12490489f, 0.19739334f, 0.01277243f, 0.06682029f, 0.09389902f, 0.07596342f, 0.07331273f, 0.12903272f, 
    0.11091708f, -0.05123839f, 0.09096430f, -0.04816753f, 0.30898800f, 0.11062466f, -0.12470534f, 0.03900546f, 
    -0.06853533f, -0.03247513f, -0.05722335f, 0.09249374f, -0.05950978f, 0.08862983f, 0.01607044f, -0.01438078f, 
    0.13424787f, 0.19821459f, -0.11492760f, 0.29291752f, 0.17232729f, 0.19246113f, -0.03154192f, 0.08636577f, 
    0.00230195f, 0.06509170f, -0.05353059f, -0.09469359f, -0.00605223f, -0.09405604f, 0.17742030f, -0.02193226f, 
    0.07875973f, 0.06756684f, 0.08326270f, 0.03673505f, -0.06055272f, -0.04076588f, 0.01303660f, -0.10117541f, 
    -0.06032741f, 0.12372821f, 0.06581492f, 0.00012303f, -0.09727914f, 0.02609068f, -0.05682816f, -0.08982525f, 
    0.05147346f, 0.03500167f, 0.00203018f, -0.05170152f, -0.07844013f, 0.14563724f, 0.13745353f, 0.24166614f, 
    -0.03355230f, -0.09150262f, -0.05178001f, -0.12764308f, -0.04876826f, 0.05668475f, 0.02483358f, 0.12227374f, 
    -0.02433847f, -0.05981981f, -0.10619096f, 0.00711064f, -0.14061768f, 0.10397121f, 0.03367354f, 0.02228713f, 
    0.00146483f, 0.00169014f, -0.00221699f, -0.03438666f, 0.03508039f, 0.26019892f, 0.44097060f, 0.06072322f, 
    0.00241317f, -0.03080370f, -0.04425519f, 0.24594802f, -0.01100724f, 0.06465380f, -0.07665144f, 0.03483221f, 
    0.24667557f, -0.14975539f, -0.13612720f, -0.20907713f, 0.11403870f, 0.01849465f, 0.08082498f, -0.09085271f, 
    -0.04366848f, 0.13544267f, -0.04223666f, -0.11386440f, -0.57088542f, 0.20545009f, -0.05373415f, 0.10553285f, 
    0.19264644f, -0.05958891f, -0.08068546f, 0.08162019f, 0.05443286f, -0.11805670f, -0.11969727f, -0.01170457f, 
    0.00596364f, -0.02428579f, -0.02890442f, 0.12649010f, -0.15328559f, -0.08073289f, 0.05560650f, 0.05136761f, 
    -0.02431663f, -0.00663184f, 0.10718282f, -0.04508352f, -0.23262201f, -0.05308258f, -0.03092095f, -0.16959575f, 
    -0.02181789f, -0.04564637f, 0.18051417f, -0.16974898f, 0.06182029f, 0.12426274f, -0.00317160f, 0.11560421f, 
    0.26491001f, 0.01072459f, -0.10489547f, 0.01228192f, -0.07992704f, -0.16185313f, 0.05344754f, -0.02527998f, 
    -0.13855933f, -0.03270914f, 0.03142332f, -0.01058834f, 0.29441845f, 0.04260384f, -0.09705400f, 0.25759527f, 
    -0.12442896f, -0.01817246f, -0.06211029f, -0.03838453f, -0.02574055f, -0.03142510f, -0.03985652f, -0.00082974f, 
    0.43339950f, 0.01053236f, 0.15019038f, 0.24916863f, 0.03386872f, 0.08876945f, 0.01056105f, -0.10255668f, 
    0.01733915f, 0.14119644f, 0.10379708f, 0.00953248f, -0.06484948f, -0.14323869f, -0.07050720f, -0.31387347f, 
    -0.02209291f, -0.14622706f, -0.06658351f, 0.00426663f, 0.03372985f, -0.02743712f, -0.04246961f, -0.04112171f, 
    0.05326386f, 0.04270812f, 0.03857563f, 0.00134788f, -0.05391334f, -0.01270682f, 0.02340758f, 0.03739505f, 
    -0.03142583f, -0.05331698f, 0.02885515f, 0.01308468f, -0.03811878f, 0.05576781f, 0.00254167f, -0.06310163f, 
    0.00304081f, -0.01791620f, -0.00724689f, 0.01811578f, 0.04579135f, -0.05087302f, 0.00071274f, -0.05733209f, 
    0.00490200f, 0.03779329f, -0.07070450f, -0.06655971f, 0.02582719f, -0.06123784f, -0.04690292f, -0.02467661f, 
    -0.04232682f, 0.01958133f, -0.02947586f, -0.00306009f, 0.05553765f, -0.00479817f, -0.01141496f, 0.01275772f, 
    -0.06635634f, 0.06398313f, -0.03190501f, 0.03741507f, -0.03562053f, -0.05830318f, -0.05785521f, -0.07251102f, 
    -0.00239322f, -0.04192863f, 0.02909505f, 0.00353421f, -0.01561790f, -0.01612970f, -0.02160347f, -0.03526977f, 
    0.00601205f, 0.02541398f, -0.05418632f, -0.06231649f, 0.05873609f, -0.03185664f, -0.05928178f, 0.05135412f, 
    -0.03370252f, -0.05862303f, -0.06018489f, -0.04812215f, -0.02767643f, 0.00498710f, -0.04616106f, -0.05075573f, 
    -0.05235220f, -0.03369527f, 0.04124561f, -0.00484230f, -0.04778119f, -0.05564971f, -0.07156651f, -0.02105373f, 
    0.00098837f, -0.00748514f, -0.01610496f, 0.00935204f, 0.04224682f, -0.03636185f, 0.06100677f, 0.03554260f, 
    -0.05123062f, 0.02011337f, 0.00855073f, -0.04175752f, -0.01202297f, -0.06450675f, 0.06128625f, -0.05398740f, 
    -0.01925906f, -0.01324717f, -0.05759495f, -0.02106154f, -0.03323428f, -0.02296877f, 0.00570147f, 0.00848271f, 
    0.04080631f, -0.03379572f, -0.06620674f, -0.02588706f, -0.07449322f, -0.00430600f, -0.07410449f, 0.00671755f, 
    -0.02049015f, 0.04835308f, -0.03915864f, 0.00027475f, 0.06335740f, 0.03757205f, -0.06025003f, -0.04625343f, 
    -0.02893982f, -0.01975844f, -0.03114498f, -0.00246296f, 0.00307137f, -0.00387158f, -0.02120989f, 0.00746382f, 
    0.05506593f, -0.03773812f, 0.04287002f, -0.07103965f, 0.03380746f, -0.04141893f, -0.00849617f, 0.00102671f, 
    0.03389706f, 0.05121828f, 0.01634493f, -0.04159309f, 0.03294470f, -0.01177295f, -0.02083643f, 0.05865216f, 
    -0.00080443f, 0.03321723f, -0.01860460f, -0.01578232f, 0.05832110f, -0.00355947f, 0.01039277f, -0.01853641f, 
    0.00008859f, 0.04003220f, 0.01379285f, 0.03910628f, -0.07447556f, -0.02012613f, -0.04778076f, -0.01472578f, 
    -0.02584894f, 0.04713776f, -0.00174886f, 0.00212774f, 0.00316235f, -0.06043261f, 0.02192918f, -0.00637909f, 
    -0.03895801f, -0.03015408f, 0.01784476f, -0.03814873f, 0.04105909f, 0.04064743f, 0.00865208f, -0.07145373f, 
    -0.03702253f, -0.06201958f, -0.07111137f, -0.06401683f, -0.01943137f, -0.02744036f, -0.06008749f, 0.06587007f, 
    -0.04075644f, 0.02884905f, 0.02902893f, -0.03997766f, 0.04073080f, 0.05453741f, 0.00974514f, 0.06527176f, 
    0.05581411f, 0.05648521f, -0.03990671f, -0.03092011f, 0.00151708f, 0.03348470f, -0.00402248f, -0.01358214f, 
    -0.01473514f, 0.02485630f, 0.00077212f, -0.02527849f, -0.02995615f, -0.05457616f, 0.05281341f, -0.00543234f, 
    0.05884001f, 0.01706478f, -0.07539345f, -0.04009078f, 0.04733438f, -0.01605111f, -0.07105572f, -0.01198268f, 
    -0.02432126f, -0.00613472f, 0.05272100f, -0.01646108f, -0.00377014f, 0.04665323f, 0.02705812f, -0.01457356f, 
    0.06198940f, 0.00153279f, -0.02168090f, -0.04697858f, -0.02892588f, 0.06138349f, 0.03132008f, -0.07838093f, 
    0.02704846f, -0.06573652f, -0.00258920f, 0.01857911f, 0.06345520f, 0.02681836f, 0.06019561f, -0.05893537f, 
    0.02053357f, 0.04263213f, -0.02718901f, 0.01768930f, -0.04996970f, -0.03219772f, -0.06017003f, -0.06088976f, 
    -0.07107352f, -0.04072244f, 0.05346571f, -0.03709537f, -0.05824640f, -0.00505158f, 0.05550717f, -0.04791176f, 
    0.04181165f, 0.02760043f, 0.01019726f, -0.07843093f, 0.00467709f, 0.01983681f, 0.00252315f, -0.00311079f, 
    -0.02075290f, 0.05627727f, 0.01586079f, -0.05322105f, -0.06442837f, -0.06062606f, -0.02340525f, -0.03969789f, 
    0.03380924f, -0.00589651f, 0.01246903f, 0.06152112f, 0.05872906f, -0.02455257f, 0.02578473f, 0.02976117f, 
    -0.02453919f, 0.05909766f, -0.03235675f, -0.01463367f, 0.00197620f, -0.02785871f, -0.05138448f, 0.02813612f, 
    -0.05123335f, -0.04890853f, 0.02538103f, -0.05761006f, -0.04798862f, -0.06389016f, 0.00909117f, 0.04519340f, 
    -0.01940383f, 0.01348077f, -0.00952400f, -0.03940894f, -0.03066415f, 0.01021648f, 0.02878536f, -0.01700381f, 
    -0.00572130f, -0.05807834f, -0.05510443f, -0.01384439f, -0.00677164f, -0.04904658f, -0.00495445f, -0.04124945f, 
    0.00431436f, 0.04889815f, 0.03408559f, -0.00996849f, -0.06352063f, 0.01804317f, 0.05829340f, -0.04435217f, 
    -0.01387851f, 0.04641511f, -0.01767399f, -0.05332980f, -0.07293472f, -0.06410957f, -0.06032849f, -0.00244530f, 
    -0.05606978f, -0.00584795f, -0.01768408f, -0.02266862f, 0.03584643f, -0.03208148f, 0.05334862f, -0.07192212f, 
    -0.02275250f, -0.03709948f, -0.05049033f, -0.01566365f, -0.05056389f, -0.02545407f, -0.01395837f, 0.00240819f, 
    0.05472514f, -0.06489624f, -0.02969205f, -0.06800439f, 0.03195043f, 0.01267170f, -0.01382803f, 0.05701669f, 
    0.00834249f, 0.04843545f, -0.02633232f, -0.00428653f, 0.05793926f, 0.05072961f, -0.05174290f, -0.06159767f, 
    0.03706452f, -0.02686665f, 0.01217135f, -0.05449643f, 0.02415359f, 0.02587154f, -0.05141053f, 0.00229740f, 
    0.01107501f, -0.07539634f, 0.04364659f, -0.04916420f, 0.03850356f, -0.05354568f, -0.00174843f, -0.02033264f, 
    -0.04885227f, 0.02509528f, -0.03529388f, 0.02199718f, -0.07246833f, -0.07322053f, -0.05705305f, -0.04517291f, 
    -0.05294412f, -0.05979991f, -0.03884775f, -0.04330596f, -0.04999994f, 0.01342232f, 0.04098183f, 0.01027312f, 
    -0.02548423f, -0.02384472f, -0.01799596f, -0.00281551f, -0.05029541f, 0.03582377f, 0.06472435f, 0.03076801f, 
    0.00203343f, 0.00330383f, 0.02673537f, -0.06378117f, 0.03408406f, -0.05965578f, 0.06286269f, 0.01441765f, 
    0.03409581f, -0.02608156f, 0.04218274f, -0.03810794f, 0.01950098f, 0.02366612f, 0.01304957f, -0.05125679f, 
    -0.04026706f, -0.05926286f, 0.02244075f, -0.04709353f, 0.00274289f, 0.06529424f, 0.02977958f, -0.05175059f, 
    -0.00718385f, -0.06765632f, -0.06278401f, 0.00267606f, 0.01576750f, 0.00796091f, -0.03765589f, -0.01198494f, 
    -0.06523128f, 0.06306107f, -0.06793948f, 0.04425496f, -0.01407062f, 0.03375578f, -0.03212975f, -0.02885689f, 
    0.06239751f, -0.05550928f, 0.02791534f, -0.01783254f, -0.06375503f, -0.02498442f, 0.00065809f, -0.01436061f, 
    -0.04548245f, 0.00614924f, 0.00335732f, 0.00074154f, -0.06239617f, 0.05295154f, 0.05987058f, -0.04864500f, 
    -0.03637909f, 0.03722152f, -0.03937810f, 0.05130995f, -0.00175961f, 0.05698673f, -0.00604059f, -0.00283774f, 
    -0.05459839f, -0.03572486f, -0.05336561f, 0.03838749f, -0.07516533f, -0.03030243f, -0.05713905f, -0.04652340f, 
    -0.02542194f, -0.07283772f, -0.00734327f, -0.04554196f, 0.05699907f, 0.03366785f, 0.03149162f, 0.05725671f, 
    -0.06926154f, 0.03217818f, 0.03253908f, 0.00387530f, 0.04890605f, -0.00360612f, 0.00630912f, -0.01877243f, 
    -0.04689492f, -0.07363240f, 0.02919946f, 0.02779418f, 0.01754101f, -0.00061516f, -0.02499939f, -0.07590628f, 
    -0.04480375f, -0.06756944f, -0.03473951f, -0.04994325f, -0.02849422f, 0.01573782f, -0.03346471f, -0.02422376f, 
    -0.02039180f, -0.00250381f, 0.01484715f, -0.02016416f, -0.05415067f, 0.01686107f, 0.00768611f, 0.04894086f, 
    -0.05027676f, 0.00280714f, -0.02564106f, -0.06484837f, -0.00691841f, 0.04166196f, -0.05713659f, -0.07054435f, 
    -0.05155590f, 0.02599386f, -0.05748990f, 0.00364840f, -0.00192573f, -0.05187967f, -0.07306605f, 0.00432908f, 
    -0.02932215f, 0.02702092f, 0.01969338f, 0.05590277f, -0.04817986f, 0.06028615f, 0.05820229f, -0.04298721f, 
    -0.03109358f, -0.03857246f, -0.03895859f, -0.01632768f, 0.06341584f, 0.02460131f, 0.00548167f, -0.07013599f, 
    -0.07046845f, 0.00373340f, -0.04636400f, -0.03435224f, 0.03595439f, -0.03640007f, -0.07157406f, 0.03917326f, 
    0.06173613f, -0.06100709f, 0.04657769f, -0.03160970f, -0.04153764f, 0.01666153f, 0.04394669f, -0.05806145f, 
    0.05104088f, 0.01922837f, 0.04825177f, -0.01896520f, 0.00628751f, -0.00545871f, 0.03206230f, -0.05560163f, 
    -0.02531432f, 0.00359020f, -0.03071693f, 0.01381868f, 0.00870497f, 0.04036727f, -0.04851822f, -0.07639316f, 
    -0.15842490f, -0.04841330f, 0.06611180f, -0.05087271f, 0.11882237f, 0.03112650f, 0.00096420f, 0.13474588f, 
    -0.06119431f, 0.01613117f, 0.07341991f, 0.10680821f, 0.10273065f, -0.06846445f, -0.13320315f, 0.26941514f, 
    -0.00188524f, 0.00152624f, -0.03313050f, -0.19679300f, 0.00440767f, 0.01506642f, -0.03227937f, -0.05366766f, 
    -0.26761690f, -0.06066054f, 0.18217480f, 0.12808619f, 0.10984582f, 0.14472759f, -0.06574119f, 0.08992388f, 
    0.08480082f, 0.07944924f, 0.06436232f, 0.06133154f, -0.12792565f, 0.36823952f, -0.15471350f, -0.34589881f, 
    0.22547728f, -0.04013957f, -0.11145275f, -0.03389988f, -0.05099326f, -0.10464714f, 0.03193716f, -0.15086851f, 
    -0.19443923f, -0.29542825f, 0.23449241f, -0.06607639f, 0.00242707f, 0.01944691f, -0.23451318f, -0.14937156f, 
    0.04394160f, -0.18878633f, 0.18405572f, -0.07510886f, -0.00002456f, -0.09883980f, 0.16181652f, -0.14158168f, 
    0.04002314f, -0.05146531f, -0.00902318f, 0.00176613f, 0.02208386f, -0.00247667f, 0.05476964f, 0.16372170f, 
    0.12589338f, 0.10237362f, -0.03196792f, 0.13515085f, -0.01243873f, -0.05030494f, 0.08161416f, 0.04147922f, 
    -0.02961622f, 0.04032953f, 0.03851598f, 0.09188710f, 0.13252208f, 0.16518340f, 0.13151973f, 0.06572556f, 
    0.28412539f, 0.11562999f, -0.04249779f, 0.08683737f, 0.01949651f, 0.07117250f, 0.20468600f, 0.11575685f, 
    0.08744152f, 0.16719086f, -0.14699087f, -0.03685155f, 0.06498658f, 0.05513747f, 0.05485900f, 0.10311058f, 
    -0.10229017f, 0.08558555f, 0.15502840f, 0.02954458f, 0.13462384f, -0.16519803f, -0.06320873f, -0.07658686f, 
    -0.01320296f, -0.02696852f, -0.06548321f, 0.07362634f, -0.10217408f, 0.03266369f, 0.01673126f, 0.06503991f, 
    -0.21719180f, 0.24518886f, 0.16209573f, 0.10530513f, -0.00789410f, -0.01366697f, -0.07062085f, 0.12084136f, 
    0.11791758f, 0.08161161f, -0.03577121f, 0.04672121f, -0.05394688f, 0.42726973f, 0.08924971f, -0.25825578f, 
    -0.02074233f, 0.05090169f, -0.01881756f, 0.09126420f, 0.06892879f, 0.05634203f, 0.03856295f, 0.07911412f, 
    -0.30420098f, -0.09028385f, 0.13112316f, -0.07403551f, -0.02723536f, 0.02613242f, 0.00752371f, -0.06315252f, 
    -0.02041459f, -0.01189660f, -0.03544258f, 0.04020235f, -0.20994642f, -0.07963120f, 0.03608754f, 0.04666084f, 
    -0.11599297f, 0.06372067f, 0.01960144f, -0.22489807f, -0.08825139f, 0.08076119f, -0.04864720f, 0.12946734f, 
    -0.00039333f, -0.05625948f, 0.00198175f, 0.25084287f, 0.09705829f, 0.26868203f, 0.02807730f, 0.09505870f, 
    0.14086229f, -0.08724520f, 0.01050687f, 0.13185109f, -0.00605396f, -0.11740115f, 0.01840361f, -0.10219640f, 
    -0.00373374f, 0.00980580f, -0.00767341f, -0.12572277f, 0.06237651f, 0.09101649f, -0.12986876f, 0.02034308f, 
    -0.10759597f, -0.09160667f, 0.11836823f, 0.15157601f, -0.07985844f, -0.04654047f, 0.10461408f, -0.01227621f, 
    -0.08776262f, 0.03065081f, -0.02244324f, 0.23025174f, -0.13846357f, 0.11232754f, 0.08196899f, -0.30418697f, 
    0.02451115f, 0.15691185f, 0.04693605f, 0.05490963f, -0.05638366f, 0.00203923f, 0.05213309f, 0.19229095f, 
    0.09128682f, -0.04921498f, 0.07113664f, -0.09585480f, -0.14070436f, -0.04138200f, -0.03097873f, -0.10117994f, 
    -0.16515435f, -0.04530086f, -0.01154851f, -0.12078727f, -0.01952002f, 0.05269917f, -0.12707326f, -0.00364970f, 
    0.08518906f, 0.02229458f, 0.01240128f, 0.02623999f, 0.04639822f, 0.01017857f, -0.03219857f, 0.09941406f, 
    0.05473255f, -0.10039475f, 0.10445148f, 0.07045225f, -0.11785423f, -0.11470539f, 0.05436015f, -0.01780592f, 
    -0.10196207f, 0.03158416f, -0.11245784f, -0.16021314f, 0.01044635f, -0.16853561f, -0.04936252f, 0.08979066f, 
    -0.01416492f, 0.14588870f, 0.03971782f, 0.12050280f, -0.02937807f, -0.07380985f, -0.14305669f, 0.05419489f, 
    0.09757946f, 0.06842384f, -0.05946054f, -0.05321166f, 0.12962399f, -0.04947353f, -0.00462822f, -0.17494941f, 
    0.11187275f, 0.11364929f, -0.01488824f, 0.05323295f, 0.30627841f, -0.10423844f, -0.06932279f, -0.12805763f, 
    0.04316594f, -0.04139009f, -0.02466599f, -0.00989534f, -0.17592812f, 0.20791425f, -0.00832222f, 0.06528265f, 
    -0.27496460f, 0.14938343f, -0.06047209f, 0.18386701f, 0.10023112f, -0.16496903f, 0.14905161f, 0.01993461f, 
    0.05126993f, 0.02561283f, -0.05119825f, 0.12957124f, -0.03470546f, 0.02068419f, -0.08864617f, 0.14740661f, 
    0.00252599f, 0.00237140f, -0.01041731f, -0.02623748f, -0.09544758f, 0.00600403f, -0.12725842f, 0.02017165f, 
    0.15683159f, 0.13977347f, -0.06019253f, 0.07787973f, 0.08655039f, 0.01945923f, -0.10432129f, -0.09414876f, 
    -0.04908158f, 0.05492704f, -0.01911816f, 0.15199918f, -0.16451880f, -0.09760723f, 0.19472337f, 0.11989667f, 
    0.01323620f, 0.11437207f, 0.06715420f, 0.14192015f, 0.13162978f, -0.01265725f, 0.08347734f, -0.08652074f, 
    0.13687736f, 0.10915729f, 0.16026315f, 0.13725032f, 0.06677523f, 0.07090235f, 0.04277554f, -0.04026778f, 
    0.20441312f, -0.01608068f, -0.00949542f, -0.05324593f, 0.00813299f, 0.25627655f, 0.11417445f, -0.25424725f, 
    0.17938741f, 0.06283183f, 0.02604001f, -0.08078834f, 0.01413416f, -0.02961141f, -0.08119622f, -0.06242206f, 
    0.02903229f, -0.03663678f, -0.03365226f, 0.15854819f, -0.17274576f, 0.07258393f, -0.05302686f, 0.06198603f, 
    0.06963237f, 0.00133967f, -0.02485960f, 0.02896589f, -0.16791920f, 0.01942840f, -0.07504229f, 0.02249250f, 
    0.05722173f, 0.23863608f, -0.01061043f, 0.05183668f, -0.10693293f, 0.10567139f, 0.06529101f, -0.04697055f, 
    -0.03690944f, 0.00283107f, 0.03037502f, 0.04925830f, 0.04060153f, 0.01816064f, -0.03115387f, 0.03957702f, 
    0.05292780f, -0.05130255f, -0.05867487f, -0.02929099f, -0.02446839f, 0.04225357f, -0.01236648f, -0.03518233f, 
    0.04686838f, 0.00948810f, -0.05257100f, 0.06074522f, -0.00481701f, -0.02951267f, 0.03291115f, 0.05549356f, 
    -0.00857918f, -0.03884687f, -0.03405486f, -0.06664792f, -0.04645165f, -0.05775364f, -0.01499468f, 0.02684292f, 
    -0.00257927f, 0.05026441f, -0.03789167f, 0.04032040f, -0.00667414f, 0.04898696f, 0.01223722f, -0.07626803f, 
    -0.04126374f, 0.02791345f, -0.06486605f, 0.03369997f, 0.04882866f, -0.07693615f, -0.04060414f, -0.04956853f, 
    0.01340148f, 0.05270177f, 0.00834343f, -0.00938656f, 0.00918614f, 0.04207414f, -0.00550228f, -0.06711581f, 
    -0.01789655f, 0.03137999f, -0.01907099f, -0.02320280f, 0.00275758f, 0.06447080f, -0.05221086f, 0.00054859f, 
    0.01508929f, 0.05719885f, -0.02991325f, -0.07622089f, -0.03582040f, -0.02877721f, 0.05432914f, -0.06913950f, 
    0.06277076f, -0.04736692f, -0.01551279f, 0.04313294f, 0.05234502f, 0.00674715f, -0.07320438f, 0.02205652f, 
    0.05045909f, 0.04714072f, -0.02697255f, -0.01865407f, 0.04059979f, -0.06477282f, -0.07396888f, -0.01018821f, 
    0.00520892f, 0.05063524f, -0.04108901f, -0.04173170f, 0.05182511f, 0.05994442f, 0.06425822f, 0.05592528f, 
    0.02601633f, -0.05756376f, 0.04681017f, -0.06484068f, 0.04503283f, -0.05220557f, -0.07150740f, 0.04666638f, 
    0.00228472f, -0.06216410f, 0.03879190f, -0.07580693f, 0.01470321f, -0.02669024f, -0.07500866f, -0.01037402f, 
    -0.01684924f, 0.01044962f, -0.07497380f, 0.02233774f, -0.04037588f, -0.05110931f, 0.02990992f, -0.03321286f, 
    -0.01775371f, -0.01290710f, 0.00545792f, 0.03336371f, -0.07587677f, -0.06263638f, -0.05476633f, -0.04784706f, 
    -0.07212341f, -0.04759841f, 0.06443345f, 0.02408327f, -0.02981546f, -0.05671572f, -0.01687838f, 0.05874228f, 
    -0.05050717f, -0.07102516f, 0.00019317f, 0.05732522f, -0.05674905f, -0.05365328f, 0.06057676f, -0.06265251f, 
    0.03374400f, -0.07373720f, -0.04143625f, -0.00735636f, -0.06833573f, 0.01108841f, 0.00350429f, -0.07136656f, 
    0.04880379f, -0.06124118f, -0.06590009f, -0.04785682f, 0.05579650f, 0.00506132f, 0.00018449f, 0.03101950f, 
    0.05876649f, 0.05112013f, -0.00942541f, -0.03709161f, 0.04446299f, -0.03816082f, -0.01046694f, -0.01422531f, 
    0.01986890f, 0.02003236f, -0.01541665f, 0.02372678f, 0.05001740f, -0.04910558f, -0.01725778f, -0.05836752f, 
    0.04464313f, -0.04410572f, 0.00760860f, -0.00125661f, 0.00810320f, -0.07284130f, -0.07184495f, 0.04914694f, 
    -0.07097875f, -0.06816930f, -0.03936686f, -0.05564602f, -0.01960085f, 0.04545929f, -0.01075334f, -0.01786465f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.00279197f, -0.01961688f, 0.02764880f, -0.01951412f, -0.01866061f, 0.05485072f, -0.05742425f, 0.01010387f, 
    0.15153784f, 0.24514015f, 0.05285598f, -0.04689153f, -0.08518545f, -0.00411488f, 0.17089362f, -0.02895951f, 
    0.05655145f, -0.00435584f, -0.03814785f, -0.06703260f, 0.09832320f, 0.11317169f, 0.14755054f, 0.03169616f, 
    -0.06468742f, 0.08768158f, 0.00202559f, -0.03920599f, -0.01094463f, 0.12495423f, -0.02127281f, 0.10868306f, 
    0.00414976f, -0.00274160f, 0.10193907f, -0.03253856f, 0.11642225f, 0.01563647f, -0.04237910f, -0.00732739f, 
    0.11275584f, -0.01435335f, 0.17456752f, 0.09386054f, -0.05829292f, -0.02473813f, -0.01802375f, 0.00663695f, 
    0.03632225f, -0.01151251f, -0.01425750f, 0.05696828f, 0.00775778f, 0.02946421f, 0.13754576f, 0.04050005f, 
    0.06060461f, -0.06810320f, 0.01178373f, 0.01601067f, -0.03911095f, -0.04973871f, 0.03774862f, -0.02970831f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.03516226f, 0.02195421f, -0.01763687f, 0.08101597f, 0.05679768f, -0.08144271f, -0.01238575f, -0.10976110f, 
    -0.02242812f, -0.10437490f, 0.10543726f, -0.13912930f, 0.05854233f, -0.00581732f, -0.06089864f, 0.05149382f, 
    -0.03543019f, 0.09992222f, -0.06953090f, 0.09748110f, -0.04024718f, -0.07044934f, -0.10571401f, -0.05309999f, 
    -0.12363108f, 0.03710109f, -0.09391332f, 0.07433008f, -0.05752844f, -0.11994279f, 0.09347433f, -0.10484893f, 
    0.06412982f, 0.00418608f, -0.11107818f, -0.10621744f, 0.02071855f, -0.07177921f, -0.15803821f, 0.04276142f, 
    -0.01153411f, -0.11208013f, -0.13667050f, -0.04775458f, 0.02535443f, 0.09233429f, 0.04320486f, 0.03475056f, 
    -0.15257844f, -0.06031760f, 0.03952989f, 0.07785213f, -0.02562935f, -0.11529128f, -0.09048937f, 0.08504350f, 
    -0.02437472f, 0.07902975f, -0.11156052f, -0.03570022f, 0.08001077f, 0.00155278f, 0.03468475f, 0.12769195f, 
    -0.16509251f, -0.08105808f, 0.06965768f, -0.11562818f, -0.03239661f, 0.18354756f, -0.03184770f, 0.00531001f, 
    -0.02059925f, 0.11591771f, -0.06508858f, -0.04243836f, 0.29827476f, 0.15988594f, 0.18430579f, 0.08819170f, 
    -0.01628541f, -0.01885643f, 0.20292045f, 0.06514502f, 0.28915200f, 0.10487554f, -0.08234479f, 0.08722091f, 
    -0.06732759f, -0.08642158f, -0.17341757f, 0.01250133f, 0.02430059f, 0.12809326f, 0.15783334f, -0.28186008f, 
    0.10587164f, 0.26418576f, -0.04633741f, 0.25554806f, 0.08304581f, 0.09373879f, 0.13064353f, 0.04312943f, 
    -0.13461094f, 0.00740899f, -0.00372578f, -0.17700946f, -0.06811141f, 0.11785612f, 0.11190289f, -0.05972381f, 
    0.02649446f, -0.38019183f, -0.07854646f, -0.27460304f, -0.00818274f, -0.05078485f, -0.10948147f, 0.11717267f, 
    0.01605694f, 0.13354099f, -0.07435960f, 0.02163137f, 0.00491755f, 0.04232056f, -0.13807735f, -0.07069492f, 
    -0.01153435f, 0.08286799f, 0.09743262f, 0.06430604f, -0.07641232f, 0.16540216f, 0.02348631f, -0.18539608f, 
    0.04961731f, -0.11981498f, 0.01829934f, 0.24114713f, 0.29823893f, -0.13552615f, -0.03572636f, 0.25601506f, 
    -0.07254146f, -0.13824542f, 0.02106429f, 0.06476498f, 0.03397969f, -0.15561202f, -0.09883505f, 0.00908969f, 
    0.04083616f, 0.15798661f, 0.07068264f, 0.09240040f, 0.17659643f, -0.07562765f, -0.11494392f, 0.28281569f, 
    0.10783347f, 0.03876472f, -0.11660844f, 0.18433617f, -0.12829909f, -0.11331373f, 0.03742317f, -0.01766296f, 
    0.15107627f, -0.20722044f, 0.02301749f, 0.11257818f, 0.16297397f, -0.13157222f, 0.28292906f, 0.14732787f, 
    -0.12740499f, 0.42136422f, 0.06936242f, 0.20102523f, 0.20081700f, 0.19911982f, -0.14606710f, 0.15220161f, 
    0.08707623f, 0.03156702f, 0.11462414f, -0.05315509f, 0.03962344f, 0.31065348f, 0.07499542f, 0.11222304f, 
    -0.11175862f, 0.08830135f, 0.00738114f, -0.12666097f, -0.05732971f, -0.05260256f, -0.00451367f, 0.09404726f, 
    -0.12197700f, -0.03068692f, -0.04102919f, -0.08888049f, -0.11867246f, -0.09625192f, -0.01796590f, -0.03346325f, 
    0.09493391f, 0.02077932f, -0.01410300f, -0.00348408f, 0.10053517f, -0.06345921f, -0.08975975f, -0.08688138f, 
    0.03302141f, -0.08567037f, -0.07829861f, -0.04148192f, -0.03630837f, -0.04792035f, 0.05849801f, 0.06808471f, 
    -0.08283082f, -0.02720843f, 0.02833952f, 0.01047676f, -0.02400838f, 0.08457972f, 0.07034542f, 0.00148833f, 
    0.00570664f, 0.01983348f, -0.04660621f, -0.11759509f, -0.12746540f, -0.04869045f, 0.00051466f, -0.07806155f, 
    -0.02916059f, -0.07176213f, -0.01620184f, -0.07150012f, 0.00894186f, 0.07666878f, -0.00797390f, 0.09241009f, 
    0.05419172f, -0.02525163f, -0.12161118f, 0.11224955f, -0.04460827f, 0.03447175f, -0.01292651f, -0.04104155f, 
    -0.10034781f, -0.40497005f, 0.07129663f, -0.01219921f, 0.06627458f, 0.04712650f, -0.03559115f, 0.19036958f, 
    -0.15028481f, 0.18189006f, 0.02985051f, -0.28375652f, -0.11862133f, 0.02328742f, -0.21681234f, -0.20394175f, 
    0.38208476f, 0.06699252f, 0.13881947f, 0.08951756f, 0.11952019f, -0.07163226f, 0.00901641f, -0.10421921f, 
    -0.08802579f, -0.01995187f, 0.24492195f, -0.01151204f, 0.00862247f, 0.13182934f, 0.15543553f, -0.01639749f, 
    0.33087432f, 0.09034240f, 0.11769377f, 0.07101150f, 0.19363098f, -0.08885810f, 0.04284966f, 0.07754461f, 
    0.14164175f, 0.32169896f, -0.00965226f, -0.12801637f, -0.10402856f, 0.05737114f, -0.44532287f, -0.13711534f, 
    0.22726639f, -0.26408890f, 0.02968914f, -0.02639403f, -0.04668125f, 0.03302008f, -0.19652800f, 0.03373389f, 
    0.18895200f, 0.17230834f, -0.10575221f, 0.04087979f, 0.07466675f, 0.09564634f, 0.14466266f, 0.06020159f, 
    0.02330855f, 0.07390280f, -0.05899996f, -0.00625764f, 0.04420556f, 0.10438581f, -0.10990478f, 0.12372217f, 
    0.00321212f, -0.05389203f, -0.05104567f, -0.09049481f, 0.09485911f, -0.02257705f, 0.06527019f, 0.03278357f, 
    -0.09445450f, -0.04819158f, -0.07066345f, 0.07880203f, 0.05731766f, -0.06888597f, 0.04787880f, -0.00111793f, 
    -0.07133910f, -0.05456826f, -0.06100154f, -0.07396828f, -0.07233861f, -0.08288237f, -0.05665372f, 0.07165951f, 
    0.09685554f, 0.11679222f, 0.08244316f, -0.07118098f, 0.01237221f, -0.01316072f, -0.04440898f, 0.11259980f, 
    0.05049425f, -0.00159515f, 0.00830357f, -0.06030357f, -0.10121608f, -0.09801430f, 0.05563428f, -0.08145355f, 
    0.08570132f, -0.05154935f, 0.02843392f, -0.07218120f, -0.08381128f, -0.08998780f, -0.10070540f, -0.09604661f, 
    -0.04313514f, -0.05891159f, -0.03353365f, 0.07928921f, 0.11605722f, -0.02572650f, -0.04184870f, -0.09828997f, 
    -0.29705110f, 0.32585561f, -0.11271029f, 0.07599491f, 0.06439395f, -0.08501305f, -0.11898783f, 0.14684288f, 
    0.17010742f, 0.28793627f, 0.09598805f, -0.13396297f, -0.25758672f, -0.18845735f, -0.23616904f, 0.21176320f, 
    0.09167002f, -0.15214157f, 0.03534549f, 0.06581622f, -0.05454002f, -0.10086948f, 0.08905180f, 0.01422849f, 
    0.01275043f, 0.21525320f, 0.46692762f, -0.00399590f, -0.17514229f, 0.14114965f, -0.18373445f, 0.12025499f, 
    0.17099604f, -0.08841502f, 0.20518282f, 0.15088560f, -0.08697966f, 0.00286639f, 0.03292509f, 0.02125311f, 
    0.00017056f, -0.14907075f, 0.22688997f, 0.20653990f, -0.15699416f, -0.06380954f, 0.07089698f, -0.01324433f, 
    -0.02612097f, -0.31168023f, 0.01751786f, 0.18266188f, -0.02850807f, 0.15369792f, 0.16806540f, -0.20492217f, 
    -0.04917154f, -0.17554440f, -0.04478401f, -0.00500156f, 0.08451106f, 0.05140811f, 0.10764354f, -0.00579920f, 
    -0.11756955f, 0.06492544f, -0.06597988f, -0.12301657f, 0.07605845f, -0.01588403f, 0.02546266f, -0.00195092f, 
    -0.00904732f, -0.06391580f, -0.11855483f, 0.09067435f, 0.03350489f, -0.09245777f, -0.03526548f, -0.00866721f, 
    -0.00908682f, -0.12239353f, -0.13048974f, -0.06220064f, -0.03664637f, -0.13980041f, -0.07973368f, 0.07975072f, 
    -0.01450089f, 0.03572385f, -0.05777239f, -0.13437797f, -0.06825105f, 0.00149972f, -0.07226174f, 0.07727832f, 
    0.04141232f, -0.15194078f, 0.07168915f, -0.09121472f, -0.11640877f, 0.07768028f, 0.00548220f, -0.00840330f, 
    -0.10931765f, -0.00888988f, -0.13936189f, 0.04800767f, 0.07707851f, -0.02521216f, -0.08359274f, -0.00046899f, 
    -0.04363065f, 0.07705155f, -0.02355935f, -0.08153234f, 0.00535607f, 0.04415527f, -0.12978227f, -0.05793025f, 
    0.05488483f, -0.05414794f, 0.06818388f, 0.01171213f, 0.09690490f, -0.03353659f, -0.05734039f, -0.07249976f, 
    0.31785995f, -0.02919524f, -0.04622197f, 0.07237111f, 0.12200393f, -0.28888714f, -0.11278581f, -0.02792090f, 
    0.08918392f, -0.16750777f, -0.02830043f, 0.11550332f, -0.51123154f, 0.10590979f, -0.39273471f, 0.27208486f, 
    0.00279676f, 0.29916057f, -0.10540086f, -0.07705432f, 0.04299311f, 0.08991651f, 0.05998208f, 0.04780377f, 
    -0.08582796f, -0.18862134f, 0.34873110f, 0.16692130f, 0.20540021f, 0.05232517f, 0.16296285f, 0.15832324f, 
    0.28913984f, 0.24883787f, 0.12414652f, -0.05184343f, -0.16860850f, 0.07869952f, 0.10091434f, 0.05867125f, 
    -0.03727976f, -0.23332784f, -0.30400500f, 0.15285198f, 0.03115642f, 0.09673787f, 0.16677125f, -0.10820085f, 
    0.11073369f, 0.18397303f, -0.02037777f, 0.27357838f, 0.33824983f, 0.01939217f, 0.00406654f, 0.17302248f, 
    -0.25310361f, 0.06468859f, -0.01608622f, 0.09402698f, 0.08794543f, 0.20650437f, -0.25509134f, -0.11625248f, 
    -0.39400154f, -0.08230788f, 0.03054470f, -0.05877467f, -0.05106150f, -0.14148387f, -0.01573954f, -0.03007975f, 
    0.02267446f, -0.09881883f, -0.04698004f, 0.20384449f, 0.41521484f, 0.03818129f, -0.11883279f, -0.14082864f, 
    0.16939934f, 0.16043174f, 0.11350881f, -0.05875108f, 0.20282206f, 0.00958952f, -0.02662862f, -0.13422900f, 
    0.12014490f, 0.10538051f, -0.11247832f, 0.04176511f, -0.20975304f, 0.07704704f, -0.13330601f, -0.33022675f, 
    0.05489296f, 0.15258308f, 0.08249778f, 0.05030722f, 0.03192521f, 0.05438615f, -0.16440625f, 0.07146804f, 
    -0.22504048f, 0.00911138f, 0.10609566f, 0.21835184f, 0.08986263f, 0.09033060f, -0.22909176f, -0.10160012f, 
    0.14909872f, 0.01912319f, 0.00741681f, -0.04765883f, -0.37759638f, 0.09135278f, 0.06752507f, -0.14504623f, 
    0.10919809f, -0.04364400f, 0.10137092f, -0.02755903f, 0.05415937f, 0.07554301f, 0.05494086f, -0.05423473f, 
    -0.22609501f, -0.09964129f, 0.00825714f, -0.00286644f, -0.09382830f, -0.18162857f, -0.04256863f, -0.01540876f, 
    0.08499078f, 0.15424126f, -0.05795963f, 0.28266954f, 0.50827020f, 0.22632024f, 0.10975641f, 0.05706922f, 
    -0.24006788f, -0.18274391f, -0.06089550f, -0.08937897f, 0.10486048f, 0.26250866f, 0.19642653f, -0.11596764f, 
    -0.04278436f, -0.00481791f, -0.51470727f, -0.15458339f, -0.12541994f, -0.02413984f, -0.24499100f, -0.07396392f, 
    -0.19275270f, -0.21962224f, 0.22603522f, 0.10755955f, 0.31695369f, -0.03719200f, 0.07649156f, -0.09902637f, 
    -0.18616879f, 0.01490444f, 0.21512865f, 0.24884406f, -0.02327510f, 0.04311564f, 0.06608141f, 0.01291203f, 
    0.25390860f, -0.09206022f, 0.10593140f, -0.14169022f, -0.27936512f, -0.38504717f, 0.26162207f, 0.15650520f, 
    -0.10636599f, -0.01199389f, -0.02350020f, -0.03918158f, -0.07897080f, 0.19527337f, -0.12172112f, -0.05479595f, 
    -0.20778425f, 0.10593602f, -0.11253212f, 0.08711307f, 0.00676134f, 0.23871300f, -0.01010869f, -0.07292099f, 
    -0.18983506f, 0.08803240f, -0.00326135f, 0.00167003f, -0.16218242f, -0.08652279f, 0.10445416f, 0.15586720f, 
    -0.00607783f, 0.00219526f, 0.33350971f, 0.08058896f, 0.13655905f, 0.02413917f, -0.26283106f, 0.06456821f, 
    -0.03887860f, 0.14711557f, -0.26662144f, 0.36827859f, 0.28189763f, 0.07816944f, 0.39238510f, -0.31338388f, 
    0.06125387f, 0.30923885f, -0.27608940f, 0.30063501f, -0.07886440f, -0.09683779f, 0.09865151f, -0.01901432f, 
    -0.20602942f, -0.36534417f, 0.09519236f, -0.11406964f, -0.08286029f, 0.09500132f, 0.05410200f, -0.05333215f, 
    0.00806133f, -0.48180085f, -0.12231852f, -0.14067818f, -0.11682417f, -0.06581730f, -0.04526212f, -0.06907780f, 
    0.02865195f, 0.35127819f, -0.03172313f, 0.08107791f, -0.10625836f, -0.21202771f, 0.15002801f, -0.01944694f, 
    0.39028710f, 0.06684218f, -0.12433647f, -0.03381312f, -0.12788969f, -0.06980742f, 0.02635530f, 0.20780978f, 
    0.20249598f, 0.04697743f, 0.07589859f, 0.22288980f, -0.01627730f, 0.17602529f, 0.28510264f, -0.07198627f, 
    -0.12515107f, 0.11165108f, -0.12904258f, -0.01561514f, 0.12509747f, 0.16665919f, 0.13241056f, -0.02108607f, 
    0.05216075f, -0.14229664f, -0.36973286f, 0.14438121f, 0.45375481f, 0.12731032f, 0.34914374f, -0.27167851f, 
    -0.15421818f, -0.05319106f, 0.00406051f, -0.16727312f, 0.21177730f, 0.09210256f, 0.12036452f, -0.12918743f, 
    -0.18258625f, 0.04444449f, -0.06998827f, 0.13820937f, 0.22678426f, -0.08721492f, -0.09685346f, 0.06805313f, 
    0.17525746f, 0.29136342f, 0.11842162f, -0.22885276f, -0.06124936f, -0.10756058f, -0.06436321f, 0.00369147f, 
    0.00167045f, 0.27052206f, 0.08177824f, -0.10767147f, 0.06061483f, -0.16042846f, -0.12821500f, -0.05497944f, 
    -0.11692279f, 0.03055711f, -0.03754638f, -0.10964149f, -0.06052347f, -0.16556497f, 0.12184609f, -0.09721419f, 
    -0.02146925f, -0.12066761f, 0.04250377f, 0.09752403f, -0.15018566f, 0.09762594f, -0.07607740f, 0.08573722f, 
    -0.05064323f, 0.10065150f, -0.07679491f, 0.04607174f, 0.01818642f, -0.00779856f, -0.05276510f, 0.03969915f, 
    -0.06563370f, -0.12974538f, -0.14456905f, -0.09666080f, 0.09299110f, 0.10463524f, -0.11612450f, 0.05645537f, 
    0.01970289f, -0.13500185f, -0.05960794f, 0.02071145f, -0.12926652f, -0.08401387f, -0.08170980f, -0.12391533f, 
    -0.10279074f, 0.07675067f, 0.01553209f, -0.11352376f, -0.03444720f, -0.04387737f, -0.12644914f, 0.05225871f, 
    -0.11198449f, 0.06807362f, 0.08194689f, -0.17057523f, -0.12694944f, 0.06245757f, -0.11750337f, -0.07762376f, 
    -0.13595921f, 0.08463448f, -0.10226573f, 0.11304659f, -0.02193196f, -0.03253426f, 0.00403098f, 0.09489578f, 
    -0.10796740f, 0.04980912f, -0.12937188f, -0.02654720f, -0.07859032f, -0.01699889f, -0.10786001f, 0.04293433f, 
    -0.01142726f, 0.14740838f, 0.06285135f, -0.10976902f, 0.37120697f, 0.14816444f, 0.19200410f, -0.24787880f, 
    0.00439703f, -0.04776595f, 0.13579628f, 0.05346087f, 0.07962715f, 0.21823829f, 0.14108586f, 0.03822646f, 
    -0.00142261f, -0.06016095f, -0.19162853f, 0.11586928f, -0.33108649f, 0.09415592f, -0.20944262f, 0.04541874f, 
    -0.04998148f, -0.00705897f, 0.03632293f, 0.09159992f, 0.21847819f, 0.11102019f, 0.06151856f, -0.10332196f, 
    0.19720703f, 0.04772937f, 0.22629300f, 0.32868171f, 0.17927523f, 0.12084074f, -0.16146399f, -0.20199719f, 
    0.31596500f, 0.03436511f, 0.03052513f, 0.11408254f, -0.16271235f, -0.23831405f, -0.02288851f, -0.16913635f, 
    -0.06303813f, -0.06159632f, -0.04519922f, 0.06606687f, -0.01676790f, 0.15038854f, -0.21970785f, -0.01515449f, 
    -0.11806972f, 0.37434143f, 0.06422549f, 0.03038783f, -0.01742786f, 0.04517601f, -0.00916266f, -0.30291748f, 
    0.07914713f, 0.03339723f, -0.01553597f, 0.35453993f, 0.47610331f, 0.05793496f, 0.33049938f, 0.40054688f, 
    -0.25541028f, 0.08013895f, -0.20695248f, -0.07726354f, -0.04486847f, 0.03666345f, 0.08077209f, 0.09703188f, 
    -0.00800383f, 0.07321002f, -0.25804892f, 0.13074772f, 0.08729595f, -0.11939280f, -0.23740233f, 0.34699130f, 
    -0.10536724f, -0.28404170f, -0.18372345f, 0.06326063f, 0.05714175f, -0.04199028f, -0.14909485f, -0.01849545f, 
    -0.03694733f, -0.27437577f, 0.02626433f, 0.26607549f, 0.17314783f, 0.08508009f, 0.60786897f, 0.18127929f, 
    0.02896260f, 0.20204134f, -0.04038228f, 0.04602373f, 0.18365739f, 0.26334739f, 0.21176289f, 0.18143168f, 
    0.16237512f, -0.21280643f, 0.11703831f, 0.01899699f, 0.05328915f, 0.07530254f, 0.13247874f, -0.08300645f, 
    -0.10652615f, -0.00663650f, 0.02181691f, -0.12256736f, 0.04957877f, -0.08169404f, -0.06376909f, -0.08940179f, 
    -0.01549570f, 0.00502139f, -0.00962313f, 0.04042753f, -0.09580080f, -0.09554291f, -0.00095410f, -0.04293657f, 
    -0.01546939f, -0.07225284f, 0.01865091f, -0.11771472f, -0.07109656f, 0.08273736f, -0.12665834f, 0.12150340f, 
    -0.04372172f, 0.03228442f, -0.09541177f, -0.12594013f, -0.11099613f, -0.08064428f, 0.01384529f, -0.07279221f, 
    0.04739612f, 0.10155550f, -0.00150604f, 0.05170249f, -0.00440970f, 0.04632851f, 0.03749334f, -0.11506200f, 
    -0.06339163f, 0.09043701f, -0.02488394f, 0.00649790f, 0.09080465f, 0.09282351f, -0.03976080f, -0.09453103f, 
    -0.04387098f, -0.00884852f, -0.04360642f, -0.03377096f, 0.09762640f, -0.09974180f, 0.10065264f, -0.07664920f, 
    -0.05068103f, -0.04168664f, 0.06110090f, -0.06701607f, -0.05497172f, -0.01600591f, -0.05732455f, -0.03526734f, 
    0.37948740f, 0.28760540f, -0.18715239f, 0.09871696f, -0.02562825f, -0.12787135f, -0.03087779f, 0.38615170f, 
    0.08738028f, 0.02338522f, 0.01341304f, -0.05651080f, -0.04352091f, 0.25250164f, 0.13531607f, 0.08557224f, 
    -0.01622455f, 0.13400197f, -0.06516653f, 0.05236440f, 0.16853195f, 0.09837891f, -0.09991422f, -0.07878225f, 
    0.10558149f, -0.11317208f, 0.07012059f, -0.06645972f, -0.19520132f, 0.19756261f, -0.20765436f, 0.10875541f, 
    0.06698676f, 0.04585313f, 0.13247025f, -0.07445790f, -0.02043469f, -0.07808733f, 0.27761263f, -0.09219545f, 
    0.04887899f, 0.27981666f, -0.02159655f, -0.15921728f, 0.24093336f, -0.00894379f, 0.53876632f, -0.04178997f, 
    0.08883397f, -0.24099183f, -0.08563113f, -0.13272673f, -0.17322502f, 0.27734381f, 0.14742281f, 0.08903541f, 
    0.09084675f, -0.01056839f, 0.10062575f, -0.08075239f, -0.01382485f, -0.12020832f, -0.18417881f, -0.09564306f, 
    0.08071425f, -0.30849338f, 0.45345783f, 0.05991473f, 0.05858243f, 0.24096330f, 0.05847267f, -0.18364854f, 
    0.08053244f, 0.03132794f, 0.01477163f, 0.03769184f, 0.02660951f, -0.18971576f, -0.21903269f, -0.07117628f, 
    0.13260347f, -0.37927580f, 0.21030582f, -0.11428455f, -0.11577019f, 0.03594254f, -0.23446950f, 0.16464235f, 
    0.05486739f, 0.34881920f, 0.22035517f, -0.18410458f, -0.01924494f, -0.13642453f, 0.20877898f, 0.19256985f, 
    0.25564989f, 0.13717008f, 0.08667837f, 0.31906003f, 0.15810792f, 0.03077147f, 0.11491092f, 0.07495569f, 
    0.20400789f, 0.28895098f, 0.19184029f, -0.31294760f, -0.19647385f, 0.00251246f, -0.18939857f, 0.16615646f, 
    -0.20540188f, 0.35763189f, -0.01645814f, 0.04774233f, 0.29310909f, -0.18265197f, -0.26265952f, 0.24234657f, 
    0.22725172f, 0.03624751f, -0.10754170f, 0.09093953f, 0.00814991f, 0.29706535f, 0.37340924f, -0.10208847f, 
    0.39472198f, -0.04267402f, 0.26879221f, 0.04389551f, 0.09139815f, -0.08226022f, -0.07188951f, 0.19941574f, 
    0.13426448f, -0.13099381f, -0.07021485f, 0.52131164f, 0.05912643f, 0.12959670f, -0.20704938f, 0.08713894f, 
    -0.19316609f, 0.14481840f, 0.03194929f, 0.01752102f, 0.01627684f, 0.17863029f, -0.23130988f, -0.06748547f, 
    0.04990184f, -0.11474026f, 0.02737202f, 0.02957885f, -0.04410440f, -0.01487805f, 0.14950705f, 0.12647869f, 
    0.11190840f, 0.15372087f, 0.23273729f, -0.06096599f, 0.02597652f, 0.13219824f, 0.28349257f, -0.10183537f, 
    -0.06233728f, 0.08829932f, -0.00902352f, -0.05613728f, 0.19123745f, -0.07109012f, 0.31322065f, 0.05762257f, 
    0.01140904f, -0.04061636f, 0.05949294f, 0.05926033f, -0.04363652f, -0.05740318f, 0.30995506f, 0.25150400f, 
    -0.15032689f, 0.11832411f, 0.09371141f, -0.01582784f, 0.10320155f, 0.06249953f, -0.25756678f, -0.09835462f, 
    -0.21415786f, 0.08669579f, 0.14030924f, -0.12351701f, 0.02653491f, 0.00283195f, -0.05181677f, 0.10875500f, 
    0.07043423f, 0.32120958f, 0.02703013f, -0.30012798f, -0.06432573f, 0.20536353f, 0.26791716f, -0.20469692f, 
    -0.01523281f, -0.16976574f, 0.14262412f, -0.07073287f, 0.12749645f, 0.19071329f, 0.00946328f, 0.05800075f, 
    0.10638033f, 0.13423693f, -0.10841395f, -0.20978528f, -0.15042490f, 0.23570779f, 0.14233486f, -0.36816931f, 
    -0.20548496f, -0.18396366f, 0.20939270f, 0.06521495f, 0.20151156f, -0.08287342f, -0.08411665f, 0.04455594f, 
    0.00362599f, 0.23798935f, 0.35916880f, -0.11992160f, -0.26395226f, 0.02561700f, -0.06594180f, 0.08033244f, 
    0.13130739f, -0.41409960f, 0.04299253f, -0.13899699f, -0.10437002f, -0.07729556f, 0.29495850f, 0.09009654f, 
    0.18545112f, -0.07584625f, 0.10258630f, 0.09791471f, -0.10110357f, -0.21466739f, 0.22947997f, 0.11722080f, 
    0.12550096f, -0.17274435f, 0.12026437f, 0.08908776f, 0.11206777f, 0.10504017f, -0.04235068f, 0.27280807f, 
    -0.21016453f, -0.18800537f, 0.11223643f, -0.00397033f, -0.05680399f, 0.23151043f, 0.03336813f, -0.13821314f, 
    0.16365121f, 0.31683046f, -0.11844342f, -0.10294946f, 0.24000105f, 0.02963998f, -0.21174884f, -0.02336344f, 
    0.05013393f, -0.01998685f, -0.01814139f, 0.14371346f, -0.00855178f, 0.12000051f, 0.24668600f, 0.03889124f, 
    -0.21569531f, 0.47414240f, 0.13342862f, 0.02228628f, 0.10942705f, -0.04661557f, 0.15775226f, -0.05154177f, 
    0.14155717f, -0.14707410f, 0.15575476f, -0.02431128f, 0.24394652f, 0.04889522f, -0.27035439f, -0.25724804f, 
    0.10614596f, 0.29219514f, -0.08309746f, 0.06115087f, -0.24968494f, -0.22657149f, 0.24901277f, 0.03481465f, 
    -0.26541555f, 0.40749010f, 0.07474770f, -0.02660246f, -0.08822605f, 0.31297702f, -0.32452756f, -0.08775149f, 
    0.17847985f, 0.23527090f, -0.26834580f, 0.06689515f, 0.02204585f, 0.04558928f, -0.10278603f, -0.01190625f, 
    -0.07573617f, -0.06887924f, 0.05311465f, -0.12756632f, -0.27524728f, -0.17417422f, -0.39836404f, 0.05022288f, 
    0.07584596f, 0.09110253f, 0.14357966f, 0.04219315f, -0.04113271f, 0.06950703f, 0.35340223f, -0.04521060f, 
    0.10482156f, 0.15206003f, 0.23536964f, 0.18100971f, -0.28673679f, 0.05173978f, -0.19656599f, 0.18120895f, 
    0.23855981f, 0.02127460f, -0.08545370f, 0.21792804f, -0.15661925f, -0.05933245f, 0.19576329f, -0.11231390f, 
    0.28151858f, 0.31439695f, -0.25115937f, 0.01050358f, 0.37334841f, 0.03262306f, 0.20032398f, -0.02410611f, 
    0.00290528f, 0.22238508f, 0.07110527f, 0.22169270f, 0.21929035f, 0.25248402f, -0.34867489f, -0.20555688f, 
    0.05350721f, -0.19330092f, 0.00680426f, -0.03743811f, 0.08540538f, 0.15616111f, -0.20647632f, 0.01758358f, 
    -0.05818301f, -0.14053455f, -0.19827141f, -0.11855085f, 0.08550222f, -0.00921305f, 0.04473959f, 0.11342536f, 
    0.01980675f, 0.06846387f, 0.02499041f, -0.15636185f, 0.14555214f, 0.26121467f, 0.47414532f, -0.10058124f, 
    0.08110198f, 0.10398123f, -0.02742380f, 0.02781844f, 0.04723201f, 0.28527290f, 0.18804327f, -0.09647673f, 
    -0.08790198f, -0.03827618f, -0.33107781f, -0.01450147f, -0.03714928f, 0.11571819f, -0.05572281f, -0.02789948f, 
    -0.28158012f, -0.07663360f, -0.06122674f, -0.14941618f, 0.17297922f, -0.02910629f, -0.01814548f, -0.02402879f, 
    0.20289899f, -0.01563900f, 0.14798306f, -0.07983659f, 0.15007302f, 0.05139738f, -0.11497964f, -0.18130127f, 
    0.23373513f, -0.02475426f, -0.00414112f, 0.13007520f, -0.14169750f, -0.00697886f, 0.17859128f, -0.12891665f, 
    0.15362991f, 0.09942481f, 0.00707375f, 0.01659776f, -0.04288986f, -0.02952291f, -0.22399309f, -0.10279892f, 
    -0.21897799f, 0.15804167f, 0.16381368f, 0.01971760f, 0.03104390f, 0.13801531f, -0.04966442f, -0.07561403f, 
    -0.19783425f, -0.06466595f, -0.06317648f, 0.24734777f, 0.46595520f, -0.02591035f, -0.18452892f, -0.10439544f, 
    0.19049320f, 0.06856623f, 0.11398161f, -0.00891510f, 0.02371651f, -0.14922267f, -0.21658988f, 0.08673779f, 
    0.01916577f, 0.09403214f, -0.23876545f, 0.21022293f, -0.18075749f, 0.06127319f, 0.22563915f, 0.06420711f, 
    -0.10332089f, 0.17899279f, -0.08952412f, 0.14450969f, 0.29761225f, -0.11352865f, -0.09752934f, 0.11282416f, 
    0.09583861f, -0.02543717f, 0.10918549f, 0.15908232f, 0.16461149f, -0.08614309f, -0.34036291f, -0.27002993f, 
    0.05924870f, 0.23392349f, 0.07538621f, 0.09344807f, -0.04223724f, -0.27506089f, 0.30369288f, -0.05530946f, 
    -0.07635231f, 0.35790735f, 0.03691597f, -0.06845938f, 0.06978823f, 0.38554990f, -0.21736485f, -0.04568163f, 
    0.24223898f, -0.16688718f, 0.13777694f, -0.04165070f, -0.11401024f, -0.29034835f, -0.02004902f, 0.10158841f, 
    0.15818183f, 0.11311346f, 0.05170721f, 0.21842125f, -0.11543161f, 0.13985835f, -0.31234279f, -0.04291066f, 
    0.04157747f, 0.49835360f, -0.19920181f, -0.04368228f, 0.16850643f, 0.04359297f, 0.04358616f, 0.01579096f, 
    -0.06874594f, -0.10644668f, 0.33143088f, 0.31322712f, 0.22281501f, -0.06692990f, 0.03229439f, -0.16841902f, 
    -0.21190533f, 0.23960173f, 0.23575211f, -0.27536213f, -0.22015958f, 0.10950007f, 0.02921527f, 0.09898837f, 
    0.04308500f, -0.01402850f, -0.13703981f, 0.34786442f, 0.22404464f, 0.09841548f, -0.06571653f, -0.13886839f, 
    0.17213105f, 0.44224715f, -0.00381377f, 0.33341065f, 0.19848073f, -0.01644040f, 0.21564463f, 0.15642339f, 
    -0.21483395f, -0.10995200f, 0.11421038f, -0.07101177f, 0.03133053f, 0.09723514f, -0.26658940f, -0.03264299f, 
    0.09251581f, 0.29996923f, -0.31090954f, -0.11695422f, -0.03993809f, -0.11646852f, -0.11303261f, 0.07584279f, 
    0.20073693f, 0.10200059f, -0.08921424f, 0.14224771f, -0.25277320f, -0.08627040f, -0.07523417f, 0.18861187f, 
    -0.15985692f, 0.20028025f, -0.19359197f, -0.03842009f, -0.09975412f, -0.05513307f, 0.11331998f, 0.00761040f, 
    -0.08168237f, -0.09241053f, 0.21980086f, 0.21017462f, 0.28898016f, 0.15639956f, 0.17935333f, -0.20240270f, 
    -0.10855022f, -0.16262203f, 0.07678916f, -0.10195311f, -0.10021650f, -0.12645960f, 0.16024116f, -0.02207993f, 
    -0.13125026f, -0.23548226f, -0.26095653f, 0.36943942f, 0.06236495f, 0.03541406f, 0.09129088f, 0.12773988f, 
    0.19237985f, 0.14878258f, 0.04552981f, 0.01501358f, 0.31234345f, 0.15244402f, 0.06297307f, -0.07181980f, 
    -0.00180279f, -0.19548763f, -0.06302201f, -0.04982951f, -0.01097959f, -0.27802587f, 0.06922295f, 0.06636688f, 
    -0.00623329f, 0.10292070f, 0.02768982f, -0.01894177f, -0.02877513f, 0.07698967f, 0.08214764f, -0.02522130f, 
    -0.10799979f, -0.02955767f, 0.08436777f, 0.06481870f, 0.01089452f, -0.02343337f, -0.01189531f, -0.02897738f, 
    0.10188894f, -0.02250522f, -0.06651266f, 0.12217811f, -0.08782591f, -0.04879614f, -0.10287992f, 0.11156876f, 
    -0.04985452f, 0.06149289f, 0.00279425f, -0.08574521f, -0.06900155f, -0.05638358f, -0.06564328f, 0.06016756f, 
    -0.11463262f, -0.06155516f, 0.07782096f, 0.03381366f, 0.08090819f, 0.12087534f, -0.12274007f, 0.03328606f, 
    -0.13737746f, -0.01369103f, -0.10201100f, -0.01589607f, -0.04741644f, 0.01498930f, 0.01541369f, 0.09076859f, 
    -0.04600225f, 0.01322798f, 0.08301879f, -0.06718960f, -0.03843840f, 0.00015903f, 0.04328355f, -0.05273120f, 
    -0.10822514f, -0.03192760f, 0.11513157f, -0.07568784f, 0.07907914f, 0.06559879f, 0.04927989f, 0.08724694f, 
    -0.10654195f, 0.11238091f, -0.31699464f, -0.03264894f, 0.00298354f, 0.26169837f, 0.11639382f, -0.18694262f, 
    -0.10183573f, 0.03700512f, 0.04943106f, -0.09989476f, 0.04139165f, -0.24355884f, 0.22043480f, 0.16330181f, 
    -0.08830436f, 0.02282231f, 0.28214538f, -0.05857816f, 0.17776838f, -0.06342033f, -0.06926001f, -0.14039926f, 
    -0.09053214f, 0.13970691f, -0.10931231f, 0.28812209f, 0.04241948f, 0.16587189f, 0.21850687f, -0.03864396f, 
    0.23746932f, 0.10052784f, -0.24435295f, 0.07601074f, -0.24735190f, 0.02815503f, 0.06373817f, 0.11175887f, 
    0.13886009f, -0.31061104f, -0.14356506f, -0.03934258f, 0.03066111f, 0.00412538f, 0.15457051f, 0.07575385f, 
    -0.31895021f, -0.35237578f, 0.09214067f, -0.06134536f, 0.12435389f, 0.04082805f, -0.25374591f, -0.02959123f, 
    0.18683983f, 0.23320358f, -0.09326684f, -0.09170948f, -0.07398295f, -0.16952403f, 0.00244939f, 0.07993078f, 
    0.43943757f, -0.14164065f, 0.12608697f, -0.12316970f, -0.11718965f, -0.03525782f, 0.07393162f, 0.35400015f, 
    -0.14302647f, 0.05014237f, -0.08035002f, 0.06629632f, -0.31261107f, 0.25025558f, -0.17608592f, 0.18639137f, 
    0.22931670f, 0.40778753f, 0.01689414f, 0.01248740f, 0.13969025f, -0.08777761f, -0.16816323f, 0.05007721f, 
    0.07256417f, 0.14789195f, 0.45769486f, 0.30707774f, 0.07712584f, -0.14467832f, 0.08555873f, 0.13552694f, 
    0.05221436f, 0.46731028f, -0.03056872f, -0.13806126f, -0.23946980f, 0.02805232f, 0.09603657f, 0.04959721f, 
    -0.03005869f, -0.18317205f, -0.18980032f, -0.21952219f, 0.16807100f, 0.10243337f, 0.19920471f, -0.13122231f, 
    0.00604476f, 0.08794476f, 0.02733459f, 0.23331620f, 0.15808941f, 0.25554159f, 0.18004267f, 0.02475083f, 
    0.04720585f, 0.37239942f, 0.05919579f, 0.00944379f, -0.06196345f, -0.04053820f, -0.16783282f, -0.08267372f, 
    -0.19443110f, 0.03613874f, 0.20279492f, 0.10520770f, -0.06596927f, 0.20704658f, 0.10365718f, -0.08678702f, 
    0.06312305f, -0.02948872f, -0.01480037f, -0.04138640f, 0.53670889f, -0.12425958f, 0.12477689f, 0.25298280f, 
    0.24937782f, 0.17686886f, -0.15563476f, 0.05891309f, 0.00705501f, 0.10673130f, 0.22635648f, 0.05216515f, 
    0.09710729f, 0.14287253f, -0.04595480f, -0.08199322f, -0.16817887f, -0.13207032f, -0.24407101f, 0.56284630f, 
    0.16451065f, -0.25658846f, -0.19232523f, 0.14590432f, 0.09732327f, 0.00937071f, -0.21251211f, 0.03176891f, 
    0.36141142f, -0.08371631f, 0.21095574f, 0.14896736f, 0.11502246f, -0.01420238f, -0.06975928f, 0.23551835f, 
    0.12746276f, 0.34593472f, -0.04941504f, 0.37485608f, -0.03910649f, 0.29209900f, -0.10225439f, -0.01496577f, 
    0.12273568f, -0.18875054f, 0.06386885f, -0.04407714f, 0.02292003f, 0.11009452f, 0.34419957f, 0.06408432f, 
    -0.21342766f, 0.28627339f, -0.32970867f, 0.04152959f, -0.09718319f, 0.00209654f, -0.03297288f, 0.06435262f, 
    -0.06704724f, 0.05971698f, -0.06728015f, -0.00309794f, -0.27969441f, -0.14382325f, -0.16885366f, 0.06515358f, 
    0.12889382f, 0.06188224f, 0.06592254f, 0.00260310f, -0.09126849f, -0.05165011f, 0.45945919f, -0.16111542f, 
    -0.05106135f, 0.08933052f, 0.30772179f, 0.32490778f, -0.31362528f, 0.18300663f, -0.38814563f, 0.35013503f, 
    0.05317008f, 0.08630733f, -0.11383647f, -0.00966268f, -0.23182181f, 0.08772659f, 0.07220513f, 0.08681742f, 
    0.36135933f, 0.01365296f, 0.01191171f, 0.40777031f, 0.38701472f, -0.05845184f, 0.29583409f, -0.13933825f, 
    0.04096451f, 0.06675702f, 0.09668634f, 0.35151541f, 0.13575089f, 0.15677054f, -0.06019245f, -0.33054215f, 
    0.01204335f, -0.24183689f, -0.11672176f, 0.12743481f, -0.11248053f, 0.14338025f, -0.08090886f, -0.03238124f, 
    -0.08848400f, -0.04330794f, 0.00997867f, -0.06773852f, -0.10162337f, -0.03150468f, -0.09817510f, -0.01113056f, 
    -0.11793676f, 0.07790637f, -0.08356902f, -0.05199203f, 0.28623837f, 0.06873468f, 0.23764259f, -0.05218741f, 
    -0.07624681f, 0.18513432f, -0.09783024f, -0.07592352f, 0.10948003f, -0.01942798f, 0.09637784f, -0.10047344f, 
    0.01331367f, 0.14837940f, -0.48912737f, -0.04689347f, 0.08903564f, 0.03250014f, 0.03061797f, -0.36952627f, 
    -0.31574091f, -0.26553044f, -0.08384094f, 0.13562573f, 0.03814691f, 0.11142489f, 0.03169351f, 0.09610176f, 
    0.00016013f, -0.11950115f, 0.11456250f, 0.17704616f, 0.06766530f, 0.07961378f, -0.02074963f, 0.07715648f, 
    0.08637227f, 0.06821437f, 0.04836570f, -0.39602163f, -0.36569950f, 0.20270029f, 0.09983636f, -0.10054076f, 
    0.09961940f, 0.17634317f, 0.01837504f, -0.11605899f, 0.08767751f, -0.12812573f, 0.19712561f, 0.00346345f, 
    -0.24282962f, -0.24851400f, 0.07543555f, 0.08163166f, -0.10242520f, 0.21729466f, 0.10435096f, -0.28812465f, 
    -0.18446362f, 0.04160767f, 0.05469471f, 0.00098509f, -0.21884318f, -0.22397594f, 0.29850936f, -0.01181928f, 
    0.05075845f, -0.08441520f, 0.21687153f, -0.08929783f, -0.02212478f, -0.20585790f, 0.04324465f, -0.00442690f, 
    -0.01049924f, 0.19231746f, 0.12229156f, 0.21550702f, -0.00747172f, 0.16997969f, 0.36796877f, -0.00077669f, 
    0.23027946f, 0.13750763f, -0.11589688f, 0.22239111f, 0.11590606f, 0.07333121f, -0.11600837f, -0.09932064f, 
    0.27569959f, -0.17737554f, 0.20429225f, -0.04099004f, -0.21323742f, -0.07073523f, -0.41478491f, 0.10118047f, 
    -0.10338560f, -0.42176798f, -0.01025662f, 0.14575413f, 0.02310122f, -0.23753634f, -0.09760769f, 0.12066677f, 
    -0.13719983f, 0.06611835f, 0.10917360f, 0.06196236f, -0.08860923f, -0.07238675f, 0.30846146f, 0.11856069f, 
    -0.06979808f, -0.06912664f, 0.11378285f, 0.05338573f, -0.10420435f, -0.01318103f, 0.20225883f, -0.09889942f, 
    -0.07541318f, -0.14062583f, 0.10407239f, 0.31429920f, 0.37391970f, 0.02901042f, -0.31946638f, -0.05573279f, 
    -0.04764918f, -0.14105162f, 0.26683205f, -0.00262593f, 0.00012509f, 0.05243921f, 0.05075623f, 0.05778885f, 
    0.02017647f, 0.01432494f, 0.15135248f, 0.04441354f, -0.07206322f, 0.08062975f, -0.17023788f, 0.02779265f, 
    0.35078070f, -0.03488915f, 0.05159705f, 0.23798254f, -0.04787851f, 0.07629003f, 0.11839947f, -0.11357957f, 
    -0.10120957f, 0.26971334f, -0.05955444f, 0.26315698f, 0.28712788f, -0.03457170f, 0.21118635f, 0.21421763f, 
    0.01959089f, 0.07310476f, 0.08300896f, 0.05518729f, 0.01796396f, -0.17233312f, -0.14616108f, 0.10404355f, 
    -0.10631191f, -0.00429280f, -0.07495105f, 0.11054374f, -0.05906284f, 0.47053549f, 0.01612028f, -0.08255516f, 
    -0.16209070f, 0.03280296f, -0.22056687f, -0.00441669f, -0.01831517f, -0.02488423f, 0.09125576f, 0.17175570f, 
    0.32217598f, 0.30016857f, 0.04627545f, -0.05773198f, -0.40086591f, -0.07412290f, -0.08894709f, 0.06813683f, 
    0.13817388f, 0.08224390f, -0.18811229f, 0.02720350f, -0.12807724f, 0.27903256f, 0.46727148f, -0.00970770f, 
    -0.05791155f, -0.21827798f, 0.15317938f, 0.10086548f, -0.16090523f, 0.02689170f, -0.18714760f, 0.05866250f, 
    0.10541137f, -0.31068277f, 0.19123311f, -0.21197318f, 0.15154570f, 0.11009420f, -0.03981442f, -0.03145355f, 
    0.07810527f, 0.05016325f, 0.00830576f, 0.44228551f, -0.08093994f, -0.05586896f, -0.01776827f, -0.07887741f, 
    0.22690286f, -0.32473707f, -0.11360654f, 0.30228710f, 0.15627401f, 0.04505687f, 0.00001307f, -0.20475349f, 
    0.07478600f, -0.31072670f, -0.01344121f, -0.01243812f, -0.00439300f, 0.10247511f, 0.07824248f, 0.09631766f, 
    0.30450377f, -0.21892297f, 0.17601222f, -0.07590193f, -0.07360819f, -0.07763427f, -0.02256621f, 0.18030478f, 
    -0.00555214f, -0.01468650f, 0.04367119f, -0.19727258f, -0.49615458f, 0.15898222f, -0.22033091f, 0.11668814f, 
    0.08090166f, 0.22086182f, 0.13200270f, 0.01518612f, 0.09806628f, -0.09785119f, -0.25880098f, 0.00716480f, 
    0.05702569f, -0.11799446f, 0.12015131f, 0.09555767f, 0.09916285f, 0.12853289f, 0.31352818f, -0.26952186f, 
    0.20773070f, 0.30033314f, 0.19544604f, 0.07618292f, -0.05770917f, 0.09654923f, 0.20225349f, 0.10578381f, 
    -0.11840194f, 0.12086254f, -0.04397662f, -0.38414031f, -0.20655656f, 0.07353187f, 0.05403386f, -0.10089014f, 
    0.14781244f, -0.51590186f, 0.11847550f, -0.15466420f, -0.02789885f, 0.27772152f, -0.04992250f, 0.10435580f, 
    0.05501266f, 0.25100628f, -0.05747913f, 0.10409641f, -0.03060234f, -0.09889046f, 0.20773220f, -0.01410547f, 
    0.04753572f, 0.04479489f, -0.06548575f, -0.07171936f, -0.04230514f, 0.09660911f, -0.00435182f, -0.05286556f, 
    0.01913697f, -0.02787907f, -0.06789716f, -0.01832035f, 0.08307740f, -0.05168375f, 0.08672754f, 0.05469069f, 
    0.09579134f, 0.09788115f, -0.15808913f, -0.09267235f, -0.05293188f, 0.04281255f, -0.03758094f, 0.00647734f, 
    -0.10637391f, 0.07252438f, 0.00912620f, -0.04108974f, -0.14001523f, -0.12127948f, 0.08222968f, -0.00163638f, 
    -0.01633440f, 0.00046678f, 0.06631330f, -0.08969866f, -0.00280396f, -0.05238520f, -0.02470346f, 0.09088149f, 
    0.00248957f, 0.00478258f, -0.11883348f, -0.10350914f, -0.13101916f, -0.06557915f, -0.00274628f, -0.03549420f, 
    -0.12798744f, 0.08392884f, 0.00799952f, 0.04430340f, 0.04865383f, -0.04978930f, -0.12156729f, 0.08733717f, 
    -0.13089180f, 0.06490535f, 0.11658999f, 0.05131311f, 0.09954984f, -0.08103485f, 0.08263454f, -0.05692224f, 
    0.05080616f, 0.08060777f, -0.05112904f, 0.01715768f, -0.12257771f, 0.05420336f, -0.00095096f, -0.03131308f, 
    -0.09158490f, 0.02967993f, -0.03393878f, 0.10912190f, -0.05498073f, 0.02903496f, -0.12939546f, 0.01921328f, 
    -0.12161817f, -0.02064712f, -0.02309943f, -0.00533609f, 0.08668768f, -0.11858197f, 0.02836792f, -0.01377743f, 
    -0.02996802f, -0.12411832f, -0.03160795f, -0.05364751f, -0.06929611f, -0.10231241f, -0.02855972f, -0.03122219f, 
    -0.09296242f, -0.13313681f, -0.01696680f, 0.09845851f, 0.10454838f, -0.11479294f, -0.00924964f, -0.03734715f, 
    0.05966853f, -0.06197804f, 0.06625266f, -0.06948882f, 0.00530291f, -0.06948079f, 0.06199560f, -0.06568368f, 
    -0.01588461f, 0.10020440f, 0.11871587f, 0.03514911f, -0.05503551f, -0.03109751f, 0.00246880f, 0.01069812f, 
    -0.02370835f, -0.00441645f, 0.02052411f, -0.08621285f, 0.04338849f, 0.08165213f, 0.02215337f, 0.07769734f, 
    0.21954556f, 0.02992898f, 0.20839573f, 0.08807685f, 0.00606182f, 0.12274426f, 0.07097393f, -0.06698509f, 
    0.28184831f, 0.32264116f, -0.04319422f, 0.14932269f, -0.01416557f, -0.00410173f, 0.06535082f, 0.12059962f, 
    0.06667449f, -0.01125355f, -0.12741043f, 0.04464312f, 0.00092931f, 0.18994758f, -0.09613502f, 0.07757301f, 
    -0.07551296f, 0.00286265f, -0.10844956f, -0.22120087f, 0.33964357f, 0.13800322f, 0.15512697f, 0.00296713f, 
    -0.18532017f, -0.34730089f, 0.34112293f, -0.07417798f, 0.25333089f, -0.11364041f, 0.06011714f, -0.06951040f, 
    -0.08494893f, 0.19078846f, 0.22922607f, -0.04586028f, -0.19041125f, -0.03135454f, 0.08539413f, 0.33966357f, 
    -0.02713014f, 0.00999388f, -0.03773374f, -0.03272884f, 0.08308825f, 0.05264605f, 0.26686135f, 0.18025869f, 
    0.13789363f, -0.05287142f, -0.01595461f, -0.07567095f, 0.01549285f, -0.06752630f, 0.42542255f, 0.00982239f, 
    -0.06641963f, 0.07244898f, 0.08833680f, 0.10588849f, -0.05780788f, -0.11858503f, 0.11778802f, -0.13371815f, 
    -0.15228465f, 0.01288970f, 0.00761138f, -0.05090062f, 0.03548339f, -0.00679493f, -0.13066842f, -0.02515563f, 
    -0.15547706f, 0.08647944f, 0.08374455f, -0.03875276f, 0.00195070f, -0.09911382f, -0.12307210f, 0.12213278f, 
    0.09627798f, -0.02244508f, 0.01084256f, -0.04627182f, -0.10649649f, 0.01206807f, 0.01656130f, 0.01113064f, 
    -0.02700806f, -0.01858966f, 0.06624891f, 0.07563657f, -0.09432686f, 0.01831885f, -0.03915804f, -0.01959199f, 
    -0.10766073f, -0.11956170f, -0.11959893f, -0.13544786f, -0.07029201f, 0.05985955f, 0.00574131f, 0.00385215f, 
    -0.04699207f, -0.05366445f, 0.03956908f, 0.01628343f, -0.10602286f, 0.08764781f, -0.14995350f, 0.06225449f, 
    -0.07692705f, -0.05339358f, 0.05078262f, 0.03403705f, 0.11930093f, 0.03097331f, 0.09043378f, 0.03955602f, 
    0.10444251f, -0.26624146f, 0.10042404f, -0.03690305f, -0.04741959f, -0.06608369f, 0.02879771f, -0.10421266f, 
    0.16027588f, 0.11193950f, -0.00167263f, 0.10001263f, -0.08552624f, -0.04601710f, -0.12268396f, 0.10117695f, 
    -0.07017314f, -0.00349210f, -0.10457403f, 0.04557704f, 0.03299643f, 0.22296566f, 0.19614421f, -0.01657178f, 
    -0.02879997f, -0.16875613f, -0.06931526f, -0.10843511f, 0.06074778f, 0.07157699f, 0.17081848f, -0.07516304f, 
    0.27911100f, -0.10344698f, 0.00428626f, -0.21503608f, 0.05214381f, 0.07488742f, 0.10905151f, 0.10422139f, 
    0.01340084f, 0.28057459f, 0.01817716f, -0.09468557f, 0.03464471f, -0.12753975f, 0.01698744f, 0.21013983f, 
    0.12193191f, -0.33376747f, 0.00622201f, 0.12961245f, 0.24045458f, -0.02858754f, -0.00267729f, 0.17560565f, 
    0.13991958f, -0.06789178f, -0.08432277f, 0.04283618f, -0.09929881f, -0.11991944f, 0.15366261f, -0.08206885f, 
    -0.20058584f, -0.03032411f, 0.24451481f, -0.05546231f, -0.02730028f, 0.28372297f, 0.05077584f, -0.07879881f, 
    -0.00560102f, 0.14769801f, -0.01634191f, -0.27792087f, 0.21234758f, -0.15511855f, 0.21633328f, 0.09021494f, 
    0.12873144f, -0.08446884f, -0.02681720f, 0.08658635f, 0.05397947f, -0.13217066f, 0.09914363f, 0.03599415f, 
    0.04724257f, 0.15200634f, 0.15042520f, -0.26325849f, 0.03609750f, 0.07086086f, 0.02527941f, 0.36749044f, 
    0.02609443f, -0.17483971f, 0.04171251f, 0.07029521f, 0.19668627f, 0.10961712f, -0.23938376f, -0.10695757f, 
    0.21259727f, 0.01460891f, 0.27308625f, -0.14260565f, -0.25615543f, -0.01423894f, -0.24543786f, 0.24229126f, 
    -0.21764369f, 0.27691606f, -0.06989312f, 0.21810098f, 0.22410338f, 0.11361579f, -0.05566162f, 0.01000952f, 
    0.32587948f, -0.10514563f, 0.02276890f, -0.04546222f, 0.11809921f, 0.12845920f, 0.47421896f, -0.06445380f, 
    -0.01647984f, 0.05772539f, 0.37744501f, -0.04911844f, 0.07228722f, 0.19352348f, -0.00080757f, -0.18449984f, 
    0.14163627f, -0.02006866f, 0.02049831f, 0.36292917f, 0.41485959f, 0.04919380f, -0.23219982f, 0.31003919f, 
    -0.18065870f, -0.26238963f, -0.02651446f, 0.11322851f, 0.12308671f, -0.08695301f, -0.31267193f, -0.05128810f, 
    -0.08568045f, 0.22300534f, 0.18612362f, -0.04382055f, 0.16721024f, -0.16653815f, -0.12373501f, 0.02229339f, 
    0.00762653f, -0.05059673f, 0.02073302f, 0.18482250f, 0.03132272f, 0.04639588f, 0.07355507f, -0.08561538f, 
    -0.07639370f, -0.02518499f, 0.23863210f, 0.07075278f, -0.25653988f, 0.03006351f, 0.14300087f, 0.39174166f, 
    -0.02977419f, 0.13804241f, 0.03594311f, -0.04395703f, 0.12253704f, 0.09999224f, 0.25914362f, 0.22454949f, 
    0.24970785f, 0.05876635f, 0.11199870f, -0.02667986f, -0.11304669f, 0.20144016f, 0.20311862f, 0.08382174f, 
    -0.15657268f, 0.07509274f, 0.11340324f, -0.00137175f, 0.03177030f, 0.23543607f, -0.19274662f, 0.10918443f, 
    -0.01010724f, 0.26511902f, -0.11025833f, -0.28075859f, -0.37781566f, 0.03088688f, 0.02681396f, 0.18646437f, 
    0.20952052f, 0.13839817f, 0.06484985f, 0.00161770f, 0.15067111f, -0.27008224f, -0.13868016f, -0.07415816f, 
    -0.12153195f, 0.21334396f, 0.29998368f, 0.01446216f, -0.26881948f, 0.05069487f, -0.05684780f, 0.14318298f, 
    0.02674111f, -0.00119229f, -0.07529756f, -0.02770947f, -0.17950465f, -0.04922541f, -0.21713525f, -0.03829315f, 
    0.29684132f, -0.21143046f, 0.26455262f, -0.31550038f, -0.30236211f, -0.09213073f, -0.07253075f, -0.17904127f, 
    -0.16041440f, -0.32528883f, -0.00391923f, 0.25266320f, -0.08742686f, 0.38593659f, 0.25719789f, -0.11138684f, 
    0.16535431f, 0.03324347f, -0.07951508f, 0.03991156f, -0.05165771f, -0.12816013f, 0.20685723f, -0.04484718f, 
    -0.00941262f, -0.08215600f, 0.03200217f, 0.04934496f, -0.04505080f, -0.03686915f, -0.08212820f, -0.06918899f, 
    -0.00672070f, -0.15850526f, 0.01659077f, 0.03143738f, 0.09166210f, 0.01922538f, 0.00416685f, -0.07383729f, 
    -0.00342948f, 0.09870763f, 0.09716740f, 0.11151639f, -0.11416901f, -0.15285750f, -0.01282902f, 0.08692254f, 
    -0.09425206f, -0.12376465f, 0.06338611f, -0.01830531f, -0.03100092f, 0.03651576f, 0.01458857f, -0.02680438f, 
    -0.06827168f, 0.01392767f, 0.02709857f, 0.08238263f, -0.14457393f, 0.08243480f, -0.02238813f, 0.01601923f, 
    0.08328766f, -0.15198039f, -0.01178782f, 0.03679773f, -0.02148968f, -0.12112017f, -0.05913878f, -0.03438095f, 
    -0.07355364f, 0.08306789f, 0.04900183f, -0.03573408f, -0.08242389f, -0.03881463f, 0.03014158f, -0.01422194f, 
    -0.11467995f, -0.13254862f, 0.12457569f, -0.02966401f, 0.07099128f, -0.09543748f, -0.02805872f, 0.02330889f, 
    0.02778057f, 0.40620947f, -0.29165766f, -0.07042582f, -0.02029656f, -0.08968248f, 0.08962804f, 0.20526144f, 
    -0.08508907f, 0.11128189f, -0.08587666f, -0.06410249f, -0.09943745f, 0.01916225f, 0.31122652f, 0.09912445f, 
    0.05307304f, 0.23459272f, 0.09581780f, 0.07164471f, 0.09890828f, 0.01670359f, -0.04693991f, -0.06787407f, 
    0.05033700f, 0.09434750f, 0.12646924f, 0.35661826f, 0.05359246f, 0.24165128f, -0.15914586f, 0.00716247f, 
    -0.26005563f, 0.28305849f, -0.02620136f, 0.10689193f, 0.03220533f, -0.04277242f, 0.17059967f, 0.04197208f, 
    0.10345520f, -0.00304262f, -0.04241464f, 0.23424391f, 0.29244396f, 0.01513868f, 0.16752742f, -0.13301730f, 
    0.02931133f, -0.10829783f, -0.06947816f, 0.06005630f, -0.16580734f, 0.02640816f, 0.21012262f, -0.22666429f, 
    -0.05921308f, 0.19456404f, 0.01861832f, -0.05026522f, -0.11585800f, -0.19206710f, -0.17207190f, -0.12307057f, 
    -0.01067009f, 0.04388089f, -0.08887290f, 0.08322260f, -0.00579368f, -0.06792162f, 0.01265667f, -0.01146596f, 
    0.08729713f, 0.02158027f, -0.01925187f, 0.01955425f, -0.12185219f, -0.07962620f, 0.02427946f, -0.05256553f, 
    0.10362570f, -0.03899338f, 0.10396567f, 0.09478110f, -0.10644662f, -0.03321937f, 0.11333461f, -0.10854530f, 
    -0.02533205f, -0.07705016f, -0.10344540f, -0.10328217f, 0.03241341f, -0.03090938f, 0.01543330f, 0.06842849f, 
    -0.08820561f, 0.05651212f, -0.12639691f, -0.03612973f, -0.00210964f, -0.06664414f, -0.08482885f, -0.05775812f, 
    0.06024858f, -0.00543920f, 0.05398991f, -0.05505974f, -0.10332760f, 0.07110292f, -0.09930176f, -0.01204158f, 
    0.01900766f, -0.05418589f, 0.02085996f, 0.05808593f, -0.09699043f, -0.07263631f, -0.05100096f, -0.12935248f, 
    -0.10803572f, -0.07037607f, 0.02834783f, -0.00438334f, -0.10915563f, -0.06828389f, 0.10820598f, 0.08439036f, 
    -0.05855027f, 0.12922873f, -0.03501161f, 0.11850158f, -0.11845216f, -0.03622550f, 0.08359128f, -0.10345637f, 
    -0.13533393f, -0.04081171f, 0.01300870f, 0.02594565f, -0.20769426f, 0.09762362f, 0.09431539f, -0.01869552f, 
    0.01691831f, 0.06991328f, -0.11804850f, 0.11461249f, 0.11180167f, 0.11544491f, 0.08388830f, 0.16287979f, 
    0.04234824f, 0.00188124f, -0.06577010f, 0.11876143f, 0.08093731f, 0.00310792f, -0.04325699f, -0.03944072f, 
    -0.11513169f, 0.09653229f, -0.18814246f, -0.01176123f, -0.08487646f, -0.00440141f, 0.08667114f, 0.12483987f, 
    0.16363218f, -0.16739634f, -0.23375085f, 0.11579707f, 0.17278384f, 0.09620664f, 0.20347759f, -0.02213131f, 
    0.05340675f, 0.08761818f, 0.05107680f, 0.12533191f, 0.03978577f, 0.15376104f, -0.06878410f, -0.05534125f, 
    -0.12706582f, -0.14018348f, 0.10827884f, 0.00328481f, -0.04074959f, -0.19210573f, -0.17401707f, 0.08234610f, 
    0.23809628f, 0.27486023f, 0.00764915f, 0.10824789f, 0.12502252f, 0.00099128f, -0.08412127f, 0.04816398f, 
    0.19152457f, -0.00917233f, -0.11633866f, 0.07746076f, 0.14003725f, 0.14147624f, 0.26704672f, 0.00573398f, 
    -0.23685569f, -0.45041284f, 0.16071902f, -0.04647825f, 0.13128302f, 0.00426559f, 0.09077711f, -0.03218551f, 
    -0.06779473f, 0.06365529f, -0.31727028f, -0.08457583f, 0.23978429f, 0.12577477f, -0.13234948f, -0.17021106f, 
    -0.01086902f, -0.38140476f, 0.20470335f, 0.09108143f, 0.01969830f, 0.09253298f, 0.20960848f, -0.08738759f, 
    -0.15663265f, 0.27413461f, 0.21065462f, -0.01849331f, 0.03103500f, 0.04836518f, 0.19604419f, 0.33065873f, 
    -0.00718875f, 0.08415735f, -0.00379601f, -0.38116848f, 0.13850483f, -0.08174981f, -0.07862196f, 0.27896935f, 
    0.28789082f, -0.16123116f, -0.08465946f, 0.11312394f, -0.09437517f, -0.09034681f, 0.10556491f, -0.10160941f, 
    0.31594306f, -0.30495149f, -0.05888323f, 0.02926595f, 0.11852849f, -0.17179452f, -0.10693511f, 0.06245468f, 
    0.13988283f, -0.08672711f, -0.11758393f, 0.13160759f, -0.01374622f, 0.22773705f, 0.12345104f, -0.09520397f, 
    0.15581240f, 0.25715038f, -0.28056785f, 0.12398189f, 0.07851716f, 0.09584099f, 0.03567284f, 0.00235877f, 
    0.04456103f, -0.15379614f, -0.12391824f, -0.17031917f, 0.15641883f, -0.04578105f, 0.12220332f, -0.00180212f, 
    -0.00043268f, -0.05116998f, 0.20651978f, -0.13759901f, 0.07183582f, 0.05822159f, 0.01602812f, -0.10896134f, 
    -0.16741695f, 0.25630268f, -0.06679022f, 0.10460130f, 0.28261483f, -0.02352561f, -0.16092944f, -0.00348753f, 
    0.35534382f, 0.05623450f, 0.08150369f, 0.09251905f, 0.11549095f, 0.00394191f, 0.02998023f, 0.17612325f, 
    0.07011344f, 0.23112099f, 0.07908678f, -0.03815465f, 0.07986715f, -0.02538880f, -0.05190062f, -0.04466073f, 
    0.09840305f, 0.05693303f, 0.07380191f, 0.00817884f, 0.07869060f, 0.08018904f, -0.01344434f, -0.03829378f, 
    0.00332404f, 0.05642954f, -0.04484285f, -0.09580394f, 0.00654735f, 0.08635933f, 0.02578989f, -0.07282903f, 
    0.09476858f, -0.01324348f, -0.08291270f, -0.02589557f, -0.13133238f, -0.11725204f, -0.05635292f, -0.10504076f, 
    0.07706939f, -0.08987242f, 0.01645363f, -0.04004921f, -0.00252531f, -0.12186921f, 0.00010089f, 0.03496073f, 
    -0.11120083f, 0.01678646f, -0.09890398f, -0.13392942f, 0.09856438f, 0.01118576f, -0.00876323f, 0.01791807f, 
    0.10751107f, -0.06204080f, 0.05218006f, -0.05479903f, 0.03555565f, 0.09666083f, 0.05581697f, -0.04308884f, 
    0.04288860f, -0.09993567f, 0.08813481f, -0.09641925f, -0.01836951f, 0.03982084f, -0.02985085f, -0.13258904f, 
    -0.07852484f, -0.05995145f, 0.03500082f, -0.04940752f, 0.08592249f, 0.01813528f, 0.03110657f, -0.03555172f, 
    -0.07201570f, -0.10006155f, -0.04148854f, 0.00270893f, -0.11709376f, 0.10725690f, 0.01580533f, -0.07038005f, 
    -0.11659209f, 0.01483306f, -0.08796510f, -0.05288196f, 0.04433085f, -0.04138601f, -0.05635121f, 0.08695003f, 
    -0.07863259f, 0.04248473f, -0.11651835f, -0.06730193f, -0.12344432f, 0.12374225f, -0.11533822f, -0.01938850f, 
    0.07339731f, -0.03103253f, -0.08611035f, -0.07082891f, -0.11101018f, -0.03910269f, -0.11242208f, -0.10655807f, 
    0.01058039f, -0.06428494f, 0.05378196f, -0.04966821f, 0.02214627f, -0.02817990f, 0.00110014f, -0.10486476f, 
    0.01921795f, -0.06396954f, -0.10401915f, -0.06953236f, 0.05163005f, -0.12414363f, 0.01722986f, -0.10450229f, 
    -0.08672632f, 0.00277732f, -0.09634756f, -0.09207915f, 0.02100024f, -0.04568002f, 0.01675370f, -0.03070810f, 
    -0.01593891f, -0.06116016f, -0.09070188f, 0.06203593f, -0.12208113f, -0.02709608f, -0.02217121f, -0.09833254f, 
    -0.08061086f, -0.02977939f, 0.03232777f, -0.00865351f, 0.10434800f, 0.07902601f, 0.04799848f, 0.01374765f, 
    0.00941814f, 0.06066285f, 0.05096774f, -0.01983937f, -0.08609027f, 0.05999207f, 0.04201458f, 0.02466092f, 
    -0.14128225f, -0.03214845f, 0.07008194f, 0.01274773f, -0.03407579f, 0.03981346f, 0.05784088f, -0.09040536f, 
    -0.02055609f, 0.09939057f, 0.08882920f, 0.01785071f, -0.07318344f, -0.08831367f, -0.05008458f, 0.00482887f, 
    -0.04162344f, -0.03599392f, 0.06845605f, -0.08108263f, -0.08296506f, 0.11404274f, 0.06156550f, 0.03244039f, 
    -0.08582929f, -0.07099906f, -0.06132204f, -0.07941768f, -0.04157893f, -0.10162678f, -0.10294810f, -0.02752027f, 
    -0.02917518f, -0.03371762f, -0.00007894f, 0.01504970f, 0.08384029f, 0.02017680f, 0.02623972f, -0.10826617f, 
    -0.07303624f, 0.09307389f, 0.01546581f, -0.03393761f, -0.08670914f, -0.11697188f, -0.08425710f, 0.10433046f, 
    -0.16400070f, 0.10991817f, -0.09114242f, -0.10179146f, 0.03211419f, 0.07262427f, 0.06363577f, 0.03896959f, 
    0.15776066f, 0.18199877f, 0.09815729f, -0.26586193f, -0.54287213f, -0.16002733f, -0.06968851f, 0.00213221f, 
    0.01174493f, 0.15571877f, 0.23645473f, 0.04357411f, 0.15059929f, -0.21353947f, 0.01378348f, 0.03672428f, 
    0.12335406f, 0.01764406f, 0.29417858f, 0.31023359f, -0.06143255f, 0.02250475f, 0.01718296f, -0.10452674f, 
    0.36483186f, 0.34554818f, 0.10755818f, -0.03016993f, -0.20535289f, 0.10785573f, -0.06857823f, 0.09394410f, 
    0.13567792f, -0.06855672f, -0.05223284f, -0.13328651f, -0.18683787f, 0.07887201f, 0.05262743f, -0.04476846f, 
    -0.04316465f, -0.42757922f, 0.11255708f, 0.31579140f, 0.12490505f, 0.24699350f, 0.08189353f, -0.08544502f, 
    0.04331040f, -0.11585070f, -0.00856313f, -0.09539341f, 0.03026807f, 0.03410702f, 0.16598406f, -0.01110096f, 
    0.01658845f, -0.11518564f, -0.00951184f, 0.00577085f, 0.04315361f, 0.04246986f, 0.01721901f, 0.07409461f, 
    -0.12716968f, 0.06273406f, -0.05642314f, -0.02842832f, -0.03520884f, -0.04141858f, -0.08813805f, 0.12465673f, 
    -0.06211307f, 0.09975687f, -0.07328007f, -0.06256121f, -0.04298916f, 0.09278549f, 0.06135313f, 0.02774779f, 
    -0.07977682f, -0.09823462f, 0.01468515f, 0.00481218f, 0.00107679f, -0.04337347f, -0.02980918f, -0.11700914f, 
    -0.10008029f, 0.10303186f, -0.03542097f, -0.09710903f, 0.06473752f, 0.03370827f, 0.11627531f, 0.02501173f, 
    -0.04446417f, -0.04645396f, 0.03945096f, -0.07950453f, -0.06624441f, 0.00333612f, -0.08075602f, 0.02760910f, 
    -0.07135301f, 0.11321835f, 0.05359290f, -0.01743277f, -0.06158160f, -0.05865971f, -0.01117836f, -0.04224189f, 
    -0.02699641f, 0.04720135f, 0.08029503f, 0.03477681f, 0.11231866f, 0.09169451f, -0.10743770f, -0.09620411f, 
    0.13706385f, -0.11446699f, 0.04671215f, 0.11104497f, 0.10350380f, -0.06197926f, -0.03568623f, -0.05987818f, 
    0.16981585f, -0.00972825f, -0.04697150f, 0.27139294f, -0.38718373f, 0.19115342f, -0.15143037f, 0.40419808f, 
    -0.09422223f, 0.15396558f, -0.36599997f, -0.03657636f, 0.06274298f, 0.20804721f, 0.12864473f, -0.05537006f, 
    0.00030279f, -0.20831466f, -0.11476546f, -0.01697397f, 0.20475940f, -0.10671140f, 0.01012180f, 0.31057411f, 
    -0.09448727f, -0.17977649f, 0.21589659f, -0.26868424f, -0.07523502f, -0.03558972f, 0.05671814f, -0.00986558f, 
    0.03823515f, -0.09876058f, -0.17434689f, 0.23158950f, 0.12122661f, 0.12286854f, 0.06834568f, 0.24263278f, 
    0.24580106f, -0.17074795f, 0.04942651f, 0.31427360f, 0.19678156f, 0.12808973f, 0.20659718f, 0.20867142f, 
    -0.17249918f, -0.20920157f, -0.01618260f, 0.03901216f, -0.02905337f, 0.08138852f, -0.08513411f, 0.12040618f, 
    -0.09329685f, 0.00004461f, -0.28743371f, 0.13084002f, 0.06374826f, -0.11718585f, -0.02772322f, 0.03796588f, 
    0.09007549f, 0.22707926f, -0.02934403f, -0.19914582f, -0.46603471f, -0.02074011f, 0.40463606f, -0.03175000f, 
    0.02258126f, -0.24014243f, 0.16243681f, -0.06294841f, 0.13379098f, 0.15821727f, 0.28741810f, 0.06822887f, 
    0.09743251f, 0.02082277f, -0.02083063f, 0.25877306f, 0.18450123f, 0.29104111f, 0.10596672f, -0.51432586f, 
    0.07982611f, -0.01752490f, 0.09330266f, -0.03963320f, 0.15016723f, -0.10105337f, 0.11061388f, 0.07335998f, 
    0.06470521f, 0.13320549f, 0.09649056f, -0.08138029f, -0.12171928f, -0.01095133f, -0.05353042f, -0.12143023f, 
    0.03450787f, -0.43987271f, -0.04421395f, -0.13708402f, 0.06062914f, -0.27158001f, -0.18622091f, -0.14164622f, 
    -0.02480681f, -0.05544972f, -0.09109636f, 0.05666290f, -0.08459498f, -0.13722174f, -0.03767161f, -0.03688521f, 
    0.19225980f, -0.13873397f, 0.22423500f, -0.04942590f, -0.09487659f, 0.25208250f, 0.11244813f, 0.20731950f, 
    -0.12802377f, 0.05598558f, -0.01809807f, -0.13929632f, 0.19780710f, 0.17711653f, 0.38306722f, -0.17574061f, 
    0.25564539f, 0.05996427f, 0.02024383f, -0.01570708f, 0.13578469f, 0.02378203f, -0.22082727f, 0.09794421f, 
    0.05698605f, 0.23570541f, -0.02877256f, 0.01039729f, 0.08580887f, 0.10441498f, 0.03648720f, 0.10316857f, 
    -0.30156273f, 0.03800894f, -0.16912714f, 0.03597974f, 0.01135510f, 0.01729989f, -0.04793728f, 0.10847577f, 
    0.19237365f, 0.21799903f, 0.22816029f, -0.32918987f, 0.05154170f, 0.06104363f, 0.06057853f, -0.02407969f, 
    -0.08719713f, 0.37547153f, 0.03996899f, -0.24273962f, -0.16662890f, -0.05418902f, -0.02230849f, 0.00611695f, 
    0.22940344f, 0.35702926f, 0.04697381f, -0.04354972f, 0.07773829f, -0.09526435f, 0.20858626f, 0.08368645f, 
    0.26220006f, 0.18000861f, -0.23450133f, -0.08772468f, -0.03115132f, 0.07271083f, -0.08912572f, 0.18648474f, 
    0.13318434f, 0.23698710f, 0.01496726f, -0.45668125f, -0.47624132f, 0.01476807f, 0.16336076f, 0.01692146f, 
    0.08115568f, -0.03168478f, 0.17425266f, -0.04085393f, -0.06749041f, -0.05506809f, 0.14386913f, 0.13140735f, 
    -0.01767446f, 0.11911502f, 0.06227726f, -0.09219910f, 0.26068553f, -0.05478413f, -0.07659550f, -0.23286691f, 
    -0.01945025f, -0.05417338f, 0.00147007f, -0.01845249f, -0.13146749f, -0.12372574f, 0.12616010f, 0.00360378f, 
    -0.00655104f, 0.11639587f, -0.02888278f, -0.36318666f, -0.17281102f, 0.04534692f, 0.11675324f, 0.16376664f, 
    -0.29834786f, -0.00878849f, 0.06886757f, -0.17401211f, 0.26694980f, 0.10064598f, -0.14009276f, 0.09181308f, 
    0.32238540f, -0.05130007f, 0.05075227f, 0.12057700f, -0.01541440f, -0.44777963f, 0.11874858f, 0.10482704f, 
    -0.33197117f, -0.22483957f, 0.04014252f, -0.00568270f, 0.00488923f, 0.13737488f, -0.08360916f, -0.10203541f, 
    0.05740121f, -0.17375724f, -0.11099942f, 0.01824332f, 0.26439357f, -0.06309843f, -0.15449674f, -0.09268679f, 
    0.29069144f, -0.03728845f, 0.10284153f, 0.11431889f, -0.01291787f, 0.08698130f, 0.26644802f, 0.06082731f, 
    -0.03103355f, 0.10575936f, -0.10543609f, -0.06662433f, -0.08752948f, 0.07398450f, 0.08618934f, 0.17699148f, 
    0.27449319f, 0.21578354f, -0.10256249f, 0.16242240f, 0.32730764f, -0.06861025f, -0.13921443f, -0.06338018f, 
    0.25545576f, 0.02148264f, -0.02331206f, 0.27990341f, 0.24821828f, 0.11921144f, -0.38713661f, -0.01891372f, 
    0.25240040f, 0.20839053f, -0.06615636f, 0.28410751f, -0.04887250f, -0.11198764f, -0.20343056f, 0.01793273f, 
    -0.14376715f, 0.10578829f, -0.02686714f, 0.01367899f, 0.01626900f, 0.37329194f, -0.04031640f, 0.01174769f, 
    -0.07231133f, -0.00168133f, -0.04176116f, -0.10846164f, -0.07631373f, 0.04725388f, -0.09619747f, 0.05282246f, 
    0.02434948f, -0.12366600f, 0.00945431f, 0.07501333f, -0.06607088f, -0.12844269f, -0.10827720f, 0.05510533f, 
    -0.07412160f, -0.13278790f, -0.00284112f, 0.03066728f, 0.02387834f, -0.07712886f, -0.12922192f, 0.02074043f, 
    0.09596097f, 0.00498775f, 0.08778208f, -0.05235020f, -0.11028946f, -0.10031314f, 0.05778205f, 0.02699695f, 
    0.02177842f, -0.09773944f, 0.04687234f, -0.00762752f, -0.11558670f, 0.02954315f, -0.04511696f, 0.01508871f, 
    0.08536231f, -0.10223027f, 0.07493187f, 0.06185253f, -0.10913632f, -0.02117687f, 0.00981937f, -0.07815041f, 
    -0.07904887f, -0.04061205f, 0.11883563f, 0.05753196f, -0.07081073f, 0.02835198f, 0.02236160f, -0.04466503f, 
    -0.01498556f, 0.06549942f, -0.01891215f, -0.07747623f, -0.08881477f, -0.00719503f, -0.07395270f, 0.12228914f, 
    -0.28297231f, 0.12789808f, -0.04688912f, -0.07873858f, -0.11415382f, -0.25039741f, -0.08177196f, -0.03633557f, 
    0.24425094f, 0.09016620f, 0.09345151f, 0.11221015f, -0.16142251f, -0.05256447f, -0.21692744f, -0.08106883f, 
    -0.19024374f, 0.02500652f, 0.06542911f, 0.03998313f, 0.03628952f, 0.00731517f, 0.20729069f, 0.01322243f, 
    -0.05830236f, -0.00054619f, 0.29605699f, 0.18169986f, -0.03187634f, 0.21686243f, 0.00230865f, -0.45018876f, 
    0.09796398f, 0.17059609f, 0.22608756f, -0.03928777f, 0.07295800f, 0.01619731f, 0.08604214f, 0.10572703f, 
    -0.11573589f, -0.42244679f, 0.05352574f, 0.46637538f, -0.03782580f, 0.07381182f, -0.05181536f, -0.01431000f, 
    0.23527090f, -0.31596854f, -0.02452844f, 0.22172870f, -0.02245469f, -0.31534261f, 0.25368431f, 0.05897927f, 
    -0.15651523f, -0.20559594f, -0.08733819f, -0.07521469f, -0.11572419f, 0.19585787f, 0.03486141f, -0.04827994f, 
    -0.00377961f, -0.09260003f, 0.02310380f, -0.04782890f, 0.01512982f, 0.00920178f, -0.03182106f, 0.02146432f, 
    -0.07635401f, -0.02367114f, 0.07142071f, -0.03774633f, 0.00408091f, -0.00832188f, 0.07566886f, 0.08969253f, 
    -0.10356274f, -0.03325416f, -0.06078763f, -0.01026604f, -0.06637278f, -0.11839341f, -0.00151086f, -0.01192610f, 
    0.05711029f, -0.00793119f, 0.11022829f, -0.08664054f, -0.05935167f, 0.03656159f, -0.05136220f, -0.12094654f, 
    -0.09327434f, -0.02116992f, 0.05188985f, -0.09497082f, 0.10852219f, -0.02613817f, 0.06888834f, 0.08673929f, 
    -0.06693740f, -0.01632103f, 0.07259542f, 0.12009169f, -0.07603703f, 0.09287460f, -0.09103657f, 0.02489997f, 
    -0.03657585f, 0.10996215f, -0.12214507f, -0.05418049f, -0.08403194f, -0.12239031f, -0.10723193f, 0.01227659f, 
    -0.03605042f, 0.03004597f, -0.11479475f, 0.03433390f, -0.04655367f, -0.05762525f, 0.06864302f, -0.11029358f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.04755731f, 0.07343486f, -0.07519406f, -0.09951764f, 0.11885247f, -0.08013102f, 0.02456802f, 0.03002861f, 
    -0.06370132f, -0.11006633f, -0.05523832f, -0.05401310f, 0.00537229f, -0.15393734f, 0.16223231f, -0.02598960f, 
    0.02277838f, 0.06726356f, 0.05764679f, 0.10478532f, 0.23054606f, 0.07340645f, 0.00757235f, 0.02172040f, 
    -0.08684652f, -0.15255828f, 0.07304130f, 0.01372322f, 0.01631809f, 0.03786645f, 0.09896868f, 0.08311852f, 
    0.05678121f, 0.06545178f, -0.06269730f, 0.15063894f, -0.01386829f, -0.03773314f, -0.12852074f, 0.15034178f, 
    0.03112222f, 0.03992157f, -0.01331479f, -0.02765971f, 0.00811374f, -0.04720857f, 0.09037466f, -0.09568412f, 
    -0.05432865f, 0.09105451f, 0.18682104f, 0.09221184f, -0.12114725f, -0.13453382f, 0.02300835f, -0.06217641f, 
    -0.04005207f, -0.03216670f, 0.10848563f, 0.16268687f, -0.08172892f, 0.02556334f, 0.09236930f, -0.10612038f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.02242450f, -0.14534301f, 0.13468423f, 0.06087074f, -0.13798887f, -0.02805568f, -0.41134024f, -0.05677556f, 
    0.24374256f, 0.11826038f, -0.11030108f, -0.36401218f, 0.10028210f, -0.00774321f, -0.40665796f, -0.02218000f, 
    -0.07467524f, 0.17667504f, 0.17412806f, 0.23043476f, -0.19289081f, 0.29015318f, 0.03716915f, -0.14073135f, 
    -0.14162271f, 0.26190469f, -0.10189994f, -0.06118873f, -0.58179921f, 0.36142266f, -0.16197532f, -0.18394582f, 
    -0.26608056f, -0.69007093f, 0.12180316f, -0.61046791f, 0.04976675f, -0.09485537f, 0.08944584f, 0.01759225f, 
    -0.01435718f, -0.06779146f, -0.11345257f, 0.11072560f, -0.15363084f, 0.09077039f, 0.06323978f, -0.06780905f, 
    -0.22383773f, -0.02186039f, 0.09000723f, 0.08660620f, -0.08791591f, -0.06236227f, -0.35900071f, 0.05063030f, 
    0.08674186f, -0.40598002f, 0.11547884f, 0.05472225f, -0.24145815f, -0.04705945f, -0.49807215f, -0.01615055f, 
    -0.07926100f, 0.06924803f, -0.30680025f, -0.03712642f, -0.07824267f, 0.07884726f, -0.31199461f, -0.08251809f, 
    0.25129139f, -0.26437935f, 0.15541738f, 0.31909949f, 0.20100524f, -0.05577310f, 0.00779455f, -0.08911218f, 
    -0.02479679f, 0.16062468f, -0.51203531f, 0.11074653f, 0.01937862f, 0.08160280f, -0.15370505f, 0.25426492f, 
    -0.07767434f, 0.24268292f, 0.09843159f, -0.04153415f, 0.21465810f, 0.16451626f, -0.42098886f, -0.17476213f, 
    -0.28228179f, 0.28497353f, -0.14038691f, 0.14446479f, 0.16389133f, -0.07276400f, -0.07650398f, -0.01693076f, 
    0.02412235f, 0.13910992f, -0.44464898f, -0.24673510f, -0.14763676f, 0.04358125f, 0.02879072f, -0.01934505f, 
    0.04747692f, -0.11032965f, 0.26900354f, 0.00380115f, 0.09142953f, 0.03237234f, 0.07351686f, -0.01225752f, 
    0.25614983f, 0.12552425f, -0.23156682f, -0.01392116f, -0.14806356f, 0.04135409f, -0.03908409f, 0.05382733f, 
    -0.06834812f, -0.57260466f, 0.10697156f, -0.09941534f, -0.06177728f, -0.06420274f, 0.07838196f, 0.03375249f, 
    0.28655791f, -0.16327108f, -0.16495334f, -0.41107547f, 0.07407075f, 0.12315008f, -0.26816234f, 0.20706499f, 
    0.06374715f, -0.00410340f, -0.15163584f, -0.04917102f, -0.27002639f, -0.52691734f, 0.17150824f, -0.32207790f, 
    -0.72503757f, 0.03883562f, 0.32746813f, 0.06066881f, -0.21031260f, 0.03279584f, 0.24240793f, 0.17716502f, 
    -0.22890136f, -0.38399592f, 0.09241889f, 0.29680228f, -0.13901395f, -0.01939217f, 0.07981233f, 0.13175879f, 
    -0.06081756f, 0.09935623f, 0.01250967f, -0.00582574f, -0.28427050f, -0.05678249f, -0.04171226f, 0.07292642f, 
    -0.07322282f, -0.10798746f, 0.05064297f, 0.06648172f, -0.10046506f, 0.10643001f, -0.05668064f, 0.04501199f, 
    0.24024653f, -0.21650153f, -0.48582810f, -0.17905727f, 0.14086771f, -0.09521969f, -0.11998333f, -0.05550550f, 
    -0.04920687f, 0.23913057f, 0.16008690f, -0.08309741f, 0.02706891f, -0.04060687f, 0.14369141f, -0.01804344f, 
    0.08594109f, 0.27328333f, -0.34421650f, 0.19668597f, -0.51037931f, -0.08464953f, -0.19699752f, -0.04067466f, 
    0.04942937f, 0.24806480f, -0.00193788f, 0.00030008f, -0.10327847f, -0.16688246f, 0.19745454f, -0.36013514f, 
    -0.22347860f, -0.47635901f, -0.40503705f, -0.09175920f, 0.15140899f, 0.20536582f, -0.06841683f, 0.08745835f, 
    0.12754075f, -0.11323114f, 0.21893041f, -0.38609496f, 0.27807787f, 0.02647961f, -0.10122619f, -0.23698087f, 
    -0.02826058f, -0.21636768f, -0.10863755f, 0.08784126f, 0.09536187f, -0.11268880f, 0.05646016f, -0.12079447f, 
    -0.26351333f, -0.13856173f, -0.93398035f, -0.08822670f, -0.02267769f, -0.05918164f, 0.16204123f, -0.09633738f, 
    -0.46810523f, -0.07224966f, -0.05335025f, 0.04268940f, -0.10528671f, -0.05154769f, -0.13564663f, 0.01205041f, 
    -0.00555707f, -0.02865453f, -0.14580330f, 0.02251455f, 0.21408167f, 0.08327891f, 0.09492783f, -0.02583901f, 
    0.07714524f, 0.11633474f, -0.23291342f, 0.10352494f, -0.18152598f, 0.07819121f, -0.19220878f, -0.37945968f, 
    -0.00673915f, -0.19714817f, 0.16839747f, -0.02347379f, 0.15797520f, 0.17036745f, -0.24601081f, -0.20323408f, 
    0.12491395f, 0.22155340f, 0.05958097f, 0.04104302f, -0.29695815f, 0.12762539f, -0.06010992f, -0.38354275f, 
    0.12934679f, 0.27938658f, -0.08249385f, 0.02008133f, 0.25945982f, 0.07033756f, 0.03273036f, 0.07610890f, 
    -0.08507331f, -0.03337390f, 0.11628435f, 0.11648612f, 0.22164781f, -0.05297369f, -0.23359427f, 0.10033526f, 
    -0.01643605f, -0.22670394f, -0.13530625f, -0.01579702f, 0.11461824f, -0.01783678f, 0.08374263f, -0.05568459f, 
    -0.01727293f, -0.08008154f, -0.04104081f, -0.18678190f, 0.07812452f, -0.10235938f, 0.31379437f, 0.04428335f, 
    -0.11618597f, 0.18054090f, -0.26270384f, -0.09852629f, 0.09258831f, 0.04511802f, -0.21707445f, 0.03205924f, 
    -0.50924432f, 0.28462696f, 0.30811188f, 0.09709642f, 0.14574997f, 0.05874491f, 0.32180610f, 0.01182821f, 
    -0.11652520f, 0.16917136f, -0.16935118f, 0.03988862f, 0.20524868f, 0.28400341f, -0.21339732f, 0.29598200f, 
    0.29403338f, -0.14706270f, -0.32479846f, -0.11025330f, 0.00761850f, -0.14579923f, -0.01652231f, -0.38544467f, 
    0.32946062f, -0.63767749f, 0.05264547f, -0.09548612f, -0.04818404f, -0.03798172f, -0.01360208f, 0.05211431f, 
    -0.14300175f, -0.07307485f, -0.09360212f, -0.00794075f, -0.30148840f, -0.01937670f, 0.10590691f, 0.02964470f, 
    0.00039059f, 0.00031901f, 0.12495997f, 0.06765518f, -0.07681942f, -0.01363229f, -0.58104420f, 0.06695092f, 
    -0.07150612f, -0.04610222f, 0.12633219f, -0.37296823f, 0.10082319f, 0.07810550f, -0.09076585f, 0.12341598f, 
    -0.05934027f, 0.02508468f, -0.32750168f, -0.02394111f, 0.18413158f, -0.11827627f, -0.03544414f, -0.04155197f, 
    -0.52496654f, -0.31889090f, -0.03466701f, -0.30034640f, 0.03898080f, -0.08047920f, -0.02444228f, -0.43046436f, 
    -0.03544630f, 0.10867675f, 0.26218101f, -0.07843058f, 0.24332522f, -0.36481732f, 0.25478697f, 0.01678284f, 
    -0.75641984f, -0.55773139f, -0.23529771f, 0.09523054f, -0.06456896f, -0.32081759f, -0.18000594f, 0.07702503f, 
    -0.37062699f, -0.11826798f, 0.06770155f, 0.11267427f, 0.12204159f, 0.03638595f, 0.04254044f, 0.14428107f, 
    0.00499368f, 0.19433370f, 0.13737625f, -0.05133578f, -0.10469896f, 0.09094024f, -0.14629534f, 0.10501929f, 
    0.02507292f, 0.24551353f, -0.03062944f, 0.04876947f, -0.00341195f, 0.09171463f, -0.12094671f, 0.02134865f, 
    -0.28835136f, 0.32816076f, 0.04308982f, 0.44814911f, -0.17188196f, -0.03865570f, -0.31383631f, 0.09021591f, 
    -0.07467336f, 0.10214064f, 0.20507382f, -0.09678973f, 0.05873761f, 0.10889667f, -0.27318859f, -0.11562244f, 
    0.10750565f, 0.00493941f, 0.07472996f, 0.04970075f, 0.03756969f, 0.06870829f, 0.17343016f, -0.23031089f, 
    0.01168757f, -0.50552684f, 0.21649569f, -0.34859490f, -0.41970870f, 0.09280805f, 0.11478084f, -0.04203203f, 
    0.11809273f, 0.14180385f, 0.00918580f, 0.08273761f, 0.13979214f, -0.08476101f, 0.06583534f, 0.17150822f, 
    -0.20583142f, 0.19954783f, 0.16618878f, 0.11359292f, -0.32886323f, -0.10889658f, -0.02451377f, -0.45500779f, 
    -0.09905913f, -0.25947836f, 0.10708701f, -0.22326024f, -0.18538631f, 0.04049145f, -0.00527771f, 0.07182883f, 
    -0.12075033f, -0.32091570f, 0.26778761f, 0.00597026f, 0.05819426f, 0.07279523f, -0.10476780f, -0.03246721f, 
    -0.12372762f, 0.11002631f, -0.02302660f, -0.26460937f, 0.41085121f, 0.06349558f, 0.17772323f, -0.02425498f, 
    0.07418102f, -0.10968359f, -0.11396574f, -0.01663957f, -0.45099452f, -0.06307293f, 0.34254643f, -0.10076286f, 
    -0.00323645f, 0.12974770f, 0.30448297f, 0.04814647f, 0.03642515f, 0.03922693f, 0.24057651f, 0.05958696f, 
    -0.05819384f, 0.01759748f, -0.24886979f, 0.05451641f, 0.06347863f, -0.05142253f, -0.09092209f, -0.08663654f, 
    0.20170683f, 0.08034720f, 0.22855467f, 0.04195443f, -0.09223463f, -0.23833507f, -0.45015374f, 0.20649956f, 
    0.00088829f, -0.01235049f, 0.27172789f, 0.22157523f, -0.38921285f, 0.09998227f, 0.04532066f, 0.00485233f, 
    -0.07195985f, -0.17906402f, -0.29555851f, -0.00554043f, -0.26625878f, 0.02601033f, 0.30398491f, -0.12506709f, 
    0.13452981f, 0.09477501f, -0.44015566f, 0.07227730f, 0.10653082f, -0.10311205f, -0.03566271f, 0.04344583f, 
    -0.02847084f, 0.20041400f, -0.44488215f, -0.27614361f, -0.16715170f, -0.11860989f, 0.49584961f, -0.08630536f, 
    -0.07771246f, -0.03582046f, 0.24157917f, 0.09840379f, -0.15923335f, 0.06753291f, -0.04065965f, 0.00044897f, 
    -0.11584486f, 0.13618651f, 0.25004643f, -0.35252503f, -0.23228793f, -0.09795859f, -0.04718276f, 0.40404409f, 
    -0.06431188f, -0.06266199f, 0.18597078f, 0.03922378f, 0.05251856f, -0.34723812f, -0.15289459f, -0.11873611f, 
    -0.01476568f, -0.39956933f, -0.17036669f, -0.08412270f, -0.34325007f, -0.30660525f, 0.20852380f, -0.29463607f, 
    -0.11157085f, -0.15441997f, 0.17470570f, 0.02602458f, -0.21045476f, -0.10428254f, 0.05415428f, 0.16199888f, 
    -0.06993904f, 0.11427923f, 0.21623044f, 0.30083773f, -0.03431294f, -0.18217522f, -0.53440022f, -0.07764447f, 
    -0.04156962f, 0.12481848f, -0.21289219f, 0.00966895f, -0.00064136f, 0.02435208f, -0.27796477f, -0.12218661f, 
    0.20657751f, -0.28474674f, -0.11708345f, -0.23513907f, 0.03647301f, -0.08557016f, 0.04312681f, -0.06985290f, 
    -0.12000530f, -0.31543174f, -0.07610904f, -0.01827380f, 0.00256157f, 0.06767069f, 0.20920843f, 0.09919374f, 
    -0.13797979f, -0.16701566f, -0.27192053f, -0.31556651f, -0.29919314f, 0.09037052f, 0.30480251f, -0.00874561f, 
    0.03391482f, 0.12438160f, -0.19728652f, -0.31110343f, 0.05981878f, 0.01114515f, 0.13527818f, 0.40199509f, 
    -0.11652637f, 0.01430499f, 0.02130545f, 0.07724178f, -0.12347525f, 0.07241254f, 0.22698696f, 0.34186924f, 
    -0.06665358f, -0.08163325f, -0.31463492f, 0.47801045f, -0.37465158f, -0.00768381f, 0.05935774f, -0.11274050f, 
    0.06819941f, -0.18092619f, 0.16653351f, -0.26201007f, 0.29446253f, -0.09034992f, 0.15798441f, 0.11318286f, 
    0.17652585f, -0.41835827f, -0.42227381f, -0.01845007f, 0.03396639f, 0.11128473f, 0.02622525f, 0.03214393f, 
    -0.15580036f, -0.05675561f, 0.05468879f, 0.02187851f, 0.03386165f, 0.02977697f, -0.14509533f, -0.10502462f, 
    0.01820305f, 0.09263887f, 0.07492968f, 0.03435813f, -0.18449901f, 0.05462264f, -0.01090008f, -0.06101706f, 
    -0.38424042f, -0.12221845f, -0.25691542f, 0.23127770f, 0.15379921f, 0.04618290f, -0.42051229f, 0.22898559f, 
    0.09391960f, -0.05048265f, -0.04361396f, -0.22399655f, 0.16176388f, -0.18922591f, -0.40941396f, 0.08732945f, 
    -0.36429825f, -0.29240412f, 0.14488642f, 0.01045764f, 0.19790244f, 0.03765733f, -0.01867248f, -0.27988154f, 
    0.46765548f, 0.02304548f, -0.70519519f, -0.31281853f, 0.00867184f, 0.01879047f, 0.00186279f, 0.14834470f, 
    0.11361998f, -0.19080722f, 0.17869759f, 0.14892738f, 0.18929049f, 0.04132921f, 0.11573690f, -0.03727721f, 
    -0.25058997f, 0.11624850f, -0.46949700f, -0.00710646f, 0.02806932f, -0.09291787f, -0.03384442f, 0.05698157f, 
    -0.36051434f, 0.14592569f, 0.21418038f, 0.38478792f, -0.64310777f, -0.05376771f, -0.22345568f, -0.08421893f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.16041549f, -0.10832131f, -0.03061425f, -0.02952173f, -0.03479443f, 0.10445973f, 0.01626671f, -0.17853126f, 
    0.02149634f, -0.09593449f, 0.11840428f, 0.10288051f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
