#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.96919864f, 0.49380103f, 0.40313557f, -0.37278050f, 0.54558349f, -0.59959561f, -0.07196605f, 0.48397541f, 
    0.30858776f, -0.44410160f, 0.53077388f, 0.90867096f, 0.60831136f, -0.03512055f, -0.53905141f, -0.51514137f, 
    -0.23483190f, 0.04038614f, -0.50078428f, 0.31940311f, 0.41470262f, 0.59818321f, -0.51673156f, 0.68409908f, 
    0.50869465f, 0.06764956f, 0.46502087f, -0.35957435f, 0.70130682f, -0.58525229f, -0.20440532f, -0.34505337f, 
    -1.06192040f, -0.14478067f, 0.20066035f, -0.36035669f, 0.32815170f, -0.97855681f, -0.53717780f, -0.41702133f, 
    -0.39987981f, -0.02178611f, -0.20045146f, 0.21357736f, 0.47711614f, 0.75116825f, 0.88498205f, 0.68222219f, 
    -0.19979098f, -0.63775879f, -0.09009827f, 0.39174730f, 0.21846284f, 0.39795688f, -0.59116888f, 0.54943877f, 
    -0.06959195f, 0.28815070f, -0.71771979f, -0.35341334f, 0.36807561f, -0.14954366f, 0.44516620f, -0.36285976f, 
    -0.54743886f, -0.67924291f, 0.25535551f, 0.24099007f, -0.86904281f, -0.33839434f, -0.06304988f, 0.01443625f, 
    0.37753347f, 0.11299774f, 0.23921800f, -1.04451239f, -0.72092503f, -0.60979098f, -0.12712182f, 0.30570823f, 
    0.18503276f, 0.08821123f, -0.77537417f, -1.05896127f, -0.07357004f, -0.53775007f, -0.34275600f, 0.17636019f, 
    0.21043898f, -0.28051883f, -0.68452752f, -0.46817875f, 0.84785503f, -0.21759394f, -0.11211339f, -0.64679277f, 
    0.17244232f, 0.34009871f, 0.02338384f, 0.90390420f, 0.29195067f, 1.17383850f, 0.51507282f, 0.17756990f, 
    0.42473698f, 0.00973570f, 0.09647828f, -0.34927440f, -0.91273248f, -0.23149961f, -0.24686952f, 0.55985779f, 
    0.88292629f, 0.16793184f, -0.05745773f, -0.24777003f, -0.03426766f, 0.27998659f, -0.83298403f, 0.47438759f, 
    -0.61789966f, -0.06742885f, 0.96044159f, 0.00555125f, -0.14241329f, 0.01881534f, -0.31458572f, -0.30287674f, 
    -0.06718684f, -0.73160321f, 0.32373899f, -0.68096852f, -0.49593103f, -0.47108573f, -0.47695234f, -0.84211904f, 
    -0.65261585f, -0.92162943f, -0.18211043f, 0.43099171f, 0.77172458f, 0.16506588f, 0.11916753f, -0.18331692f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.10052514f, 0.10286672f, -0.00816345f, 0.38621172f, 0.42936799f, 0.04636011f, 0.26500130f, -0.34765145f, 
    0.31822845f, 0.12574033f, 0.14570837f, 0.55623454f, -0.04883987f, -0.39718941f, -0.07439496f, 0.22305614f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.06901000f, -0.00239790f, -0.05716186f, -0.06491429f, -0.08290450f, -0.08380059f, 0.05072188f, 0.05866329f, 
    -0.07618031f, 0.04311553f, -0.05641200f, 0.06458079f, 0.00394607f, -0.07866300f, 0.05740869f, 0.00156717f, 
    -0.01597976f, 0.05554185f, -0.07633770f, -0.06974676f, -0.02066462f, -0.06848840f, -0.07667356f, 0.01949460f, 
    -0.04781551f, -0.01034690f, -0.00318609f, -0.01580767f, 0.02246823f, -0.05769552f, -0.08748801f, -0.00228351f, 
    -0.04508772f, -0.03455659f, 0.02333742f, 0.06244243f, -0.06476606f, 0.03828202f, 0.04424123f, 0.05484509f, 
    0.05361848f, 0.05735398f, -0.04354086f, -0.04701823f, -0.03042981f, -0.03619343f, -0.09623545f, 0.05238907f, 
    -0.07965081f, -0.05368475f, -0.02697951f, 0.01787600f, -0.04037762f, 0.01179539f, -0.06520062f, 0.05086287f, 
    -0.06411049f, -0.04119378f, -0.00075890f, -0.04290583f, -0.02629779f, -0.09140939f, -0.03003228f, -0.05862996f, 
    0.06180884f, -0.03097614f, 0.00203659f, 0.05701031f, -0.09136115f, 0.01305517f, -0.09658755f, 0.05287226f, 
    0.06924169f, -0.07975264f, -0.02779882f, 0.01651001f, -0.06155171f, 0.03097133f, 0.00889638f, -0.04896385f, 
    0.06125566f, 0.02444915f, 0.02775673f, 0.03565151f, -0.05365856f, 0.03840851f, -0.07965473f, -0.01737230f, 
    0.04390102f, -0.01804735f, -0.01519322f, -0.05637772f, 0.06478409f, -0.03609648f, 0.02013346f, 0.04025383f, 
    -0.08439650f, -0.07606455f, -0.06628469f, -0.06853385f, 0.00379554f, 0.05117093f, -0.08833594f, -0.01212006f, 
    0.00376843f, 0.03016342f, 0.01547501f, 0.00869197f, -0.08056096f, -0.07602618f, -0.05072370f, -0.03044578f, 
    0.05641543f, -0.03088364f, -0.09728104f, -0.01925462f, 0.03893332f, -0.09023278f, 0.02685382f, -0.01353086f, 
    -0.09033599f, 0.07032511f, 0.06341176f, 0.04406384f, -0.06257199f, 0.04822101f, -0.01359027f, 0.00231689f, 
    -0.02864751f, -0.01535969f, -0.03766735f, 0.00443340f, -0.09804313f, 0.01961365f, -0.04446553f, -0.05393782f, 
    -0.06399753f, -0.03354479f, -0.07691276f, 0.00603814f, -0.04211196f, -0.04691176f, -0.03802444f, 0.02966792f, 
    0.33400172f, 0.24070692f, 0.21896574f, -0.02849845f, -0.18961275f, 0.03725965f, -0.03684436f, -0.11580530f, 
    -0.10914884f, 0.12367976f, 0.05624891f, -0.30009207f, 0.12843671f, -0.01688411f, 0.07467177f, 0.06029244f, 
    -0.07289715f, 0.16468441f, -0.21989551f, -0.38603011f, -0.25564721f, -0.20853168f, -0.02148191f, 0.09150390f, 
    -0.03489884f, -0.09566681f, -0.14996010f, -0.14568423f, 0.13264790f, 0.18193507f, 0.11170052f, 0.01601003f, 
    0.06033863f, -0.06536528f, 0.03224474f, 0.04779917f, 0.09960385f, -0.22340465f, -0.24664971f, -0.08258567f, 
    -0.10777627f, -0.04711790f, -0.14166212f, -0.18941833f, 0.03016930f, 0.20470506f, 0.09664797f, 0.08576201f, 
    -0.04278988f, -0.13056542f, 0.04790447f, 0.17601001f, -0.02526803f, -0.04097766f, -0.23092574f, -0.09866101f, 
    -0.13694374f, 0.11555108f, 0.15493543f, -0.05195238f, -0.08092234f, 0.11225525f, 0.00565366f, -0.14610326f, 
    -0.07830595f, 0.18606211f, 0.12675592f, -0.00303719f, -0.23231073f, -0.01880177f, -0.23795673f, -0.03750053f, 
    0.34246016f, 0.14417890f, -0.24635324f, 0.06556731f, 0.06050857f, 0.26420239f, 0.17994247f, 0.18916959f, 
    0.20337106f, -0.08553453f, -0.01407406f, -0.13944556f, 0.30453315f, -0.02406107f, 0.14978591f, 0.30669132f, 
    -0.09318302f, -0.04840314f, -0.12243765f, 0.06568794f, 0.03016387f, 0.14219952f, -0.20671172f, -0.10567848f, 
    0.07597765f, -0.30383885f, 0.24224630f, 0.11782376f, 0.15702936f, 0.42933100f, 0.08471084f, 0.04535968f, 
    -0.12444496f, 0.08507606f, -0.00802238f, 0.11499258f, -0.94871765f, -0.04995899f, -0.04725971f, 0.18730070f, 
    0.08966405f, 0.05396552f, -0.05529670f, -0.07188135f, -0.07681621f, -0.08226252f, -0.24503222f, -0.13711135f, 
    -0.05768247f, -0.01756689f, 0.06863018f, -0.05715804f, 0.11074582f, 0.05871861f, -0.01863457f, -0.00696553f, 
    -0.25812012f, 0.09791040f, 0.09888015f, 0.21578616f, -0.17055960f, 0.01595228f, -0.05421633f, -0.64033854f, 
    -0.24918990f, 0.26253897f, 0.15560265f, 0.19223927f, 0.02288480f, -0.08704029f, -0.07153644f, -0.07133937f, 
    -0.17533997f, 0.12373862f, 0.21938039f, 0.15402539f, 0.13738339f, 0.10569941f, -0.12002138f, -0.11986837f, 
    0.12399658f, 0.01067689f, -0.02830398f, 0.26860544f, 0.00886035f, 0.01673560f, -0.18157959f, 0.04675765f, 
    -0.00346648f, 0.04196929f, 0.03613009f, 0.16804804f, 0.01140154f, 0.06847403f, -0.11224113f, -0.01706191f, 
    -0.05714684f, -0.12199072f, -0.10132491f, 0.63670939f, -0.37662306f, -0.36237946f, 0.10415497f, 0.14757682f, 
    0.26955840f, -0.06543791f, 0.13222358f, 0.20154198f, -0.51054192f, -0.53304899f, -0.12760836f, -0.02071860f, 
    0.07267535f, -0.04579509f, 0.10108199f, -0.08839675f, 0.12366512f, -0.39767414f, 0.10162217f, 0.19995917f, 
    -0.08993427f, 0.05511268f, 0.00404968f, 0.12284009f, -0.02298665f, 0.11258521f, 0.18011536f, -0.25274390f, 
    0.20316005f, -0.15114787f, 0.14972875f, 0.11610314f, 0.23119351f, -0.03324617f, 0.12041844f, -0.00075670f, 
    -0.31942618f, -0.25706401f, 0.09257009f, -0.11303567f, 0.08741995f, -0.14833817f, -0.00789453f, 0.08532412f, 
    0.23947427f, 0.18329012f, 0.31665114f, -0.13560782f, -0.12657419f, 0.13423076f, -0.09393638f, 0.02218523f, 
    0.37116659f, -0.54170716f, -0.21357991f, -0.01543970f, -0.07639307f, 0.01690073f, 0.05439426f, 0.25564522f, 
    -0.04943797f, -0.26011312f, -0.15641716f, -0.37707573f, -0.32772481f, 0.28938103f, 0.06315859f, 0.04526352f, 
    -0.00362241f, -0.09925709f, 0.05579294f, -0.26974493f, 0.17092517f, 0.17549093f, -0.00303582f, 0.10230780f, 
    0.06737332f, 0.20132825f, 0.00681273f, -0.22175393f, -0.36653945f, -0.01224686f, -0.46878722f, -0.23465528f, 
    0.18386945f, -0.13772757f, 0.26788104f, -0.04728425f, -0.28377181f, -1.01702499f, -0.11391934f, -0.34386164f, 
    0.11699042f, -0.32151562f, -0.03112457f, -0.09336633f, -0.16935761f, -0.00700164f, -0.04017324f, 0.02143553f, 
    -0.28896138f, -0.06749711f, 0.14914165f, -0.06205937f, 0.44214496f, 0.13609424f, -0.53891933f, 0.35945261f, 
    -0.33027655f, -0.40375355f, 0.11733214f, 0.01896228f, 0.00252319f, -0.02012116f, 0.02883534f, -0.05246041f, 
    0.00551373f, -0.09657310f, -0.03300402f, -0.06113341f, 0.02174052f, -0.09070554f, -0.07220442f, -0.01921791f, 
    -0.08510647f, -0.00762137f, -0.01260719f, 0.01157365f, -0.06964631f, 0.01987010f, 0.01049626f, -0.05750227f, 
    -0.05921166f, -0.05711752f, 0.06859523f, -0.04822561f, -0.05301047f, -0.06651234f, -0.09212033f, -0.06139613f, 
    0.00383310f, 0.00997219f, -0.08003418f, -0.02395806f, 0.05013880f, -0.06477491f, -0.01382830f, -0.03053000f, 
    0.04431776f, -0.08535902f, -0.06141658f, 0.00292558f, -0.06055173f, 0.05566508f, -0.01750113f, -0.08839533f, 
    0.00086658f, -0.06921361f, 0.01367322f, -0.02680306f, 0.01668585f, -0.06368200f, 0.00743732f, 0.05623232f, 
    -0.06267450f, -0.00454593f, 0.06334413f, -0.05311278f, -0.03595179f, -0.03407377f, 0.03947249f, -0.09607863f, 
    0.03338215f, 0.00205033f, 0.06393570f, -0.04843876f, -0.00165814f, 0.02421919f, 0.06527603f, 0.00452728f, 
    -0.00072172f, -0.01703611f, 0.05266355f, -0.06382063f, -0.00580787f, -0.05939503f, -0.01464503f, 0.06275105f, 
    0.04082263f, -0.08150417f, 0.02244299f, -0.08699401f, -0.09779133f, 0.05351327f, 0.00455694f, 0.05340859f, 
    -0.00866110f, -0.00397420f, 0.05284784f, 0.03041752f, -0.08961631f, -0.05172637f, 0.02688401f, -0.00700640f, 
    0.01963381f, -0.07782989f, -0.00014972f, -0.04561867f, 0.04890336f, -0.05073025f, 0.04683881f, -0.05240042f, 
    -0.00283860f, 0.05292480f, 0.05402433f, 0.01181779f, 0.06567024f, -0.00756512f, 0.06321302f, 0.05735583f, 
    -0.05925399f, -0.06479456f, -0.08541130f, 0.00411360f, -0.00139862f, -0.08766384f, -0.07250961f, 0.04574706f, 
    -0.01899818f, 0.05998113f, 0.03433578f, -0.07593000f, 0.01828489f, 0.03619974f, -0.06978952f, -0.03859766f, 
    -0.04269041f, 0.03316763f, 0.01444972f, 0.02331402f, 0.02904613f, -0.08532373f, 0.05120673f, 0.04833741f, 
    0.06335735f, -0.04505002f, -0.03214957f, -0.02164664f, -0.05269701f, -0.04629666f, 0.02690913f, 0.04287381f, 
    -0.06304334f, -0.01051855f, -0.08000786f, 0.04992990f, 0.02286742f, -0.07245889f, 0.03463051f, -0.00916623f, 
    0.03574503f, 0.17480077f, -0.18381129f, 0.01274695f, -0.04888083f, -0.02590694f, -0.11094942f, -0.24534667f, 
    -0.09629497f, -0.12700628f, 0.29883835f, -0.42879245f, -0.02352802f, -0.24067143f, -0.01793284f, -0.00060673f, 
    -0.00543747f, 0.10576699f, 0.22511674f, -0.05299425f, -0.21147303f, 0.16916184f, 0.01604345f, -0.03036362f, 
    -0.18254599f, -0.11839674f, -0.21125340f, -0.33670008f, 0.12455669f, -0.22810295f, -0.09214306f, -0.11148069f, 
    0.09799675f, 0.20863111f, -0.03590915f, -0.01381440f, 0.27578536f, -0.05087644f, 0.35369584f, 0.01602611f, 
    0.09236256f, -0.01837427f, -0.08771978f, -0.02420717f, -0.18361615f, -0.22074015f, 0.27772471f, -0.15383036f, 
    0.01458569f, 0.08890320f, -0.24613769f, -0.05640072f, 0.13334011f, 0.06511132f, -0.32878411f, -0.03424662f, 
    -0.19992658f, 0.01797857f, 0.01331518f, -0.03718032f, -0.12056745f, 0.06475815f, 0.04171894f, -0.29359764f, 
    -0.14480172f, 0.16506067f, 0.06275400f, 0.03422219f, -0.11245030f, 0.07277525f, -0.04520138f, -0.01273028f, 
    0.15915991f, 0.01778669f, -0.59360039f, 0.07540142f, -0.17695338f, -0.00463499f, 0.04862144f, 0.07769047f, 
    -0.08674391f, 0.00375312f, -0.00450704f, 0.20613629f, 0.01275416f, 0.17025000f, -0.14511167f, -0.02869253f, 
    -0.15161490f, -0.05131170f, -0.04520417f, 0.13596217f, 0.14788277f, -0.06529013f, -0.04037026f, -0.11387703f, 
    -0.03333490f, 0.06217033f, -0.04421736f, 0.32234764f, -0.13323091f, -0.01213061f, -0.13811260f, 0.09474842f, 
    -0.01014377f, 0.02824864f, -0.04064732f, 0.01745504f, -0.22994824f, 0.05081332f, 0.51127392f, 0.15795359f, 
    0.11489273f, 0.23936117f, -0.10492759f, 0.09101008f, 0.18481247f, 0.20114584f, -0.35489708f, -0.19988678f, 
    0.06058537f, -0.06672708f, 0.01005026f, -0.11616199f, 0.00346055f, 0.10697170f, 0.00919805f, 0.05727687f, 
    0.23677312f, 0.18088354f, 0.07504179f, 0.06908439f, -0.19006093f, 0.08431190f, 0.28442582f, 0.07626993f, 
    -0.34610575f, 0.27019289f, 0.07156816f, 0.19592640f, 0.04761275f, -0.07085567f, 0.02483094f, 0.15564923f, 
    0.41589075f, -0.12709829f, -0.37074319f, -0.10631288f, -0.00408683f, 0.12961608f, 0.12069672f, -0.01371705f, 
    0.15339497f, -0.24504349f, -0.16586207f, -0.03222005f, 0.06274920f, 0.00396757f, -0.23217393f, 0.10170206f, 
    0.01539997f, 0.13275176f, 0.25190216f, 0.11574095f, 0.17651543f, -0.06856947f, -0.08809858f, -0.14527109f, 
    -0.13220665f, -0.02506014f, 0.22852546f, -0.25476375f, -0.32360467f, -0.73723263f, 0.10969206f, 0.02541833f, 
    0.11855904f, 0.25429708f, 0.01774492f, 0.10640421f, 0.37335485f, 0.40232533f, 0.00261270f, 0.08814934f, 
    0.03399283f, 0.02796164f, -0.01199880f, 0.07463869f, -0.13676235f, 0.66881686f, 0.29481307f, 0.10133560f, 
    0.21991493f, -0.16566892f, -0.12752643f, 0.19916171f, 0.04334187f, -0.03247656f, -0.13532344f, -0.27495021f, 
    -0.21464524f, 0.14042453f, 0.03835078f, -0.01754296f, -0.01823457f, 0.11906473f, -0.17897698f, 0.45711902f, 
    -0.06304980f, -0.39071080f, 0.05655593f, -0.14962788f, 0.24228598f, -0.08653778f, -0.03738319f, 0.08929487f, 
    -0.00015910f, 0.04554329f, -0.12698023f, 0.36659688f, 0.01035811f, 0.18802433f, 0.10993928f, -0.10203572f, 
    0.02399825f, 0.48630294f, 0.46204421f, -0.09018157f, 0.32724655f, 0.09619040f, -0.08563314f, -0.10528230f, 
    -0.08473372f, 0.19140403f, -0.07830286f, 0.01529678f, -0.17882948f, 0.06424467f, -0.03980939f, 0.15865174f, 
    0.03245271f, -0.22418235f, 0.01086307f, 0.64620775f, 0.15072913f, 0.03321540f, -0.06808142f, 0.09751891f, 
    -0.17504083f, 0.09634225f, 0.05149692f, -0.10965922f, -0.42318237f, -0.40186280f, -0.16962284f, -0.06640578f, 
    0.05285868f, -0.04550988f, -0.32663968f, -0.04300882f, -0.17579533f, -0.47786278f, 0.04716659f, 0.26814893f, 
    -0.16543689f, 0.00112281f, -0.09311065f, 0.06047666f, 0.03516330f, 0.09640664f, -0.38055250f, 0.06744301f, 
    -0.19227681f, 0.14617775f, 0.06991494f, 0.17028384f, 0.02489012f, -0.23573503f, -0.08858944f, -0.17421520f, 
    0.09378005f, 0.28191561f, -0.07041366f, 0.07538923f, 0.03952460f, -0.14639887f, -0.10063414f, 0.08335963f, 
    -0.06548452f, -0.43492413f, 0.02647011f, 0.04559053f, 0.07460480f, -0.14217681f, 0.15433104f, -0.04016929f, 
    0.09381106f, -0.10641751f, -0.21724236f, -0.27849257f, 0.08481003f, 0.16063663f, 0.11080438f, -0.31911394f, 
    -0.05853441f, -0.11082423f, -0.13278545f, -0.10785045f, -0.21408492f, 0.11043143f, -0.00744647f, -0.07165696f, 
    0.10081201f, 0.01190849f, 0.27035654f, 0.50542253f, -0.26166934f, 0.29269513f, 0.06324562f, -0.09505355f, 
    0.05988486f, -0.02626323f, -0.04548439f, 0.09290871f, 0.11731406f, 0.00316171f, -0.00117001f, -0.15075077f, 
    0.07875369f, 0.07934591f, 0.04696994f, 0.06886780f, 0.19967876f, -0.23535278f, -0.67685717f, 0.04131970f, 
    0.09497921f, 0.08673445f, 0.27687591f, -0.28543851f, -0.13500643f, 0.11111793f, 0.18540692f, 0.07584916f, 
    -0.01062059f, 0.07517429f, -0.09788574f, -0.18205850f, 0.23059186f, -0.10619657f, -0.01760626f, -0.25213286f, 
    -0.02072770f, 0.11894730f, -0.19880144f, 0.00704877f, 0.06483474f, 0.07583016f, 0.09480345f, -0.01468918f, 
    0.45922473f, 0.13111645f, 0.14244336f, 0.19085552f, -0.00518132f, 0.08366682f, 0.15711403f, -0.22203891f, 
    0.18259205f, 0.02675978f, -0.16432640f, -0.15400691f, -0.21145000f, -0.03675294f, -0.07584494f, -0.07035717f, 
    0.02689040f, -0.12305681f, 0.21427338f, 0.27736437f, 0.31420660f, -0.23275882f, -0.11819173f, -0.04785174f, 
    -0.03465058f, 0.00952175f, -0.05745538f, -0.90958363f, -0.23901881f, -0.09146096f, 0.09724046f, 0.16427368f, 
    0.16017511f, -0.14886346f, -0.01984052f, -0.04474535f, 0.28840676f, 0.30520239f, -0.01020356f, -0.04244312f, 
    0.09068517f, 0.16826017f, 0.14876060f, 0.29955506f, 0.01794939f, -0.19201130f, -0.14250638f, 0.12922320f, 
    -0.23797537f, -0.18237604f, 0.07499466f, -0.06196148f, 0.12337161f, -0.06663390f, -0.21438381f, -0.13661094f, 
    0.23596016f, -0.03018517f, -0.04353189f, 0.24977320f, -0.18739176f, -0.12285434f, -0.13955034f, 0.26095399f, 
    0.04286976f, 0.13687825f, 0.09166799f, -0.12304977f, -0.24380434f, 0.07522471f, 0.15093420f, -0.12873492f, 
    0.10429657f, -0.14585921f, 0.35547420f, 0.04098698f, 0.06242558f, 0.24999999f, 0.05740331f, 0.07290469f, 
    0.04574095f, -0.17667361f, -0.25787520f, 0.02384123f, 0.03884786f, 0.20756884f, 0.07154614f, 0.02845459f, 
    0.09107149f, 0.22540198f, -0.14165758f, -0.13824911f, 0.14052615f, 0.12304188f, 0.08197875f, 0.20262435f, 
    -0.00025921f, -0.05176689f, -0.15521023f, -0.07817627f, 0.17705323f, 0.04354729f, -0.01134978f, -0.13304794f, 
    -0.24326068f, -0.03518906f, -0.14395340f, -0.14447853f, 0.21024187f, -0.04615579f, -0.12705399f, 0.05196128f, 
    -0.18921135f, 0.19561964f, 0.28930104f, 0.19261716f, 0.12442158f, 0.39419147f, -0.09222219f, -0.13669838f, 
    0.11484076f, -0.13080905f, 0.20711017f, 0.25590539f, -0.16351256f, -0.29769275f, -0.08799281f, 0.07744469f, 
    0.16506800f, 0.04719296f, -0.15251184f, 0.05229110f, -0.05970668f, -0.23726743f, -0.23031074f, -0.03677916f, 
    0.04291600f, 0.27504930f, 0.16639875f, -0.25270310f, 0.16661751f, 0.00357277f, 0.04682296f, 0.09590188f, 
    -0.25141323f, 0.03189861f, -0.15673117f, -0.23149098f, -0.00241327f, -0.20052232f, 0.09689718f, 0.07399411f, 
    0.02736833f, 0.21190158f, 0.16266121f, 0.14061414f, -0.32069975f, 0.06813974f, -0.15762118f, 0.14854971f, 
    -0.03446515f, -0.08817352f, 0.27710509f, 0.10524143f, -0.10993794f, 0.16238381f, -0.38808569f, 0.01407231f, 
    0.08936941f, -0.04310540f, 0.08156630f, 0.19548328f, -0.14650582f, -0.45934623f, 0.29993278f, 0.22382843f, 
    0.08197796f, 0.16550326f, -0.08759162f, 0.10337520f, -0.39959338f, 0.00589213f, 0.36208585f, 0.00680478f, 
    0.11165683f, -0.03614808f, -0.54494226f, 0.10896225f, 0.43726987f, -0.06531221f, 0.02013444f, -0.26064414f, 
    -0.30322579f, 0.15388452f, 0.01957891f, 0.35203484f, -0.15516742f, -0.12603177f, 0.08506145f, 0.07549139f, 
    0.12282175f, -0.07278028f, 0.13529687f, 0.09726316f, -0.18305369f, 0.11753114f, 0.24934448f, -0.13420092f, 
    0.03219168f, 0.36576724f, 0.01952910f, 0.05945135f, -0.09100859f, -0.16690695f, -0.00548603f, 0.18703942f, 
    -0.42986020f, -0.22849998f, -0.01150418f, 0.02768824f, -0.04051979f, -0.01849612f, -0.00419535f, -0.08398999f, 
    0.05502360f, -0.30878469f, 0.17583926f, -0.35561851f, 0.03340746f, 0.04210204f, -0.13378878f, -0.10670850f, 
    0.11508581f, -0.01865895f, 0.00358112f, -0.11048859f, -0.04840633f, 0.05306586f, -0.02075721f, 0.01326823f, 
    -0.02731341f, 0.06922054f, 0.03060115f, -0.25089777f, -0.35649502f, -0.02818081f, -0.04320292f, 0.06883721f, 
    -0.13290365f, -0.04149040f, 0.07754821f, -0.14076048f, -0.13132778f, 0.33882090f, 0.00111373f, -0.07200669f, 
    0.11654126f, 0.09766950f, -0.03276783f, -0.17461230f, 0.00904260f, -0.40453923f, 0.38076049f, -0.22474958f, 
    -0.07383519f, -0.19655469f, -0.04041637f, -0.00053305f, 0.10533457f, 0.00615122f, -0.19283617f, -0.03497260f, 
    -0.30438986f, -0.03414207f, -0.06059611f, 0.00429570f, 0.09671767f, 0.00802987f, -0.14678067f, 0.28371647f, 
    0.22979347f, -0.11363482f, -0.18615028f, -0.14649969f, 0.04928152f, -0.04043929f, 0.17050561f, -0.22321108f, 
    -0.34262222f, -0.31309733f, 0.01936634f, -0.15627412f, -0.05409759f, 0.13672231f, -0.23492572f, 0.03182168f, 
    -0.03419264f, -0.02916400f, 0.25966015f, 0.11992344f, 0.00663873f, 0.06094795f, 0.08979090f, 0.02073787f, 
    0.13982201f, 0.04673368f, 0.11253517f, -0.01867389f, 0.02405391f, 0.02646532f, 0.02115056f, -0.07523540f, 
    0.06806033f, 0.09152877f, 0.03881488f, 0.03613777f, 0.12760168f, -0.00922369f, 0.12669952f, 0.09483530f, 
    -0.09949980f, 0.12729350f, 0.01970740f, 0.25275829f, 0.63406336f, 0.27617556f, 0.23483756f, 0.24928838f, 
    0.07860926f, -0.00585054f, 0.17469245f, -0.09461889f, -0.15040578f, -0.22131476f, -0.11573108f, 0.03745983f, 
    0.16165343f, -0.07439835f, -0.12557937f, 0.06392369f, 0.09101077f, 0.12322911f, 0.09259203f, 0.12046164f, 
    0.03172822f, -0.11164451f, 0.03012534f, 0.20607682f, -0.10776464f, -0.03938633f, -0.21208133f, 0.44999313f, 
    0.29229537f, 0.35690725f, 0.22545981f, 0.08228602f, 0.08506004f, 0.11647436f, 0.16547599f, 0.04728624f, 
    -0.05393429f, 0.06667410f, 0.00727799f, 0.03549442f, -0.08060823f, -0.03379522f, -0.00062584f, -0.08718246f, 
    0.04452750f, -0.08477420f, -0.00495298f, -0.06920204f, 0.06020689f, -0.08101595f, -0.03087263f, -0.07986692f, 
    0.05196775f, -0.02575747f, -0.04894699f, 0.07394644f, -0.00148485f, 0.03365303f, -0.08498335f, 0.00216057f, 
    0.04738978f, -0.01733826f, 0.04853627f, -0.02389243f, -0.08346079f, 0.01485924f, -0.03926733f, -0.03053827f, 
    -0.06766834f, -0.01918046f, -0.07844369f, -0.08234712f, 0.02861632f, 0.04557433f, 0.05779445f, 0.06597906f, 
    -0.06407544f, 0.06622154f, -0.06647611f, -0.00548719f, -0.07090738f, 0.06335804f, 0.00509843f, 0.05372887f, 
    0.05091986f, -0.02631401f, 0.03409312f, -0.02717401f, -0.00225755f, 0.05658561f, 0.00401994f, -0.08059819f, 
    -0.08062889f, -0.07215837f, 0.06669052f, 0.04296540f, 0.02120168f, 0.02382978f, -0.07868100f, -0.01544079f, 
    -0.01703474f, -0.04654089f, -0.05335748f, -0.05927708f, 0.03065979f, 0.05685554f, 0.04998030f, -0.03142172f, 
    -0.00555313f, 0.04571333f, 0.03979165f, -0.04530383f, -0.04871348f, -0.06972449f, 0.01594220f, -0.04257164f, 
    0.01856703f, -0.07723130f, -0.08764522f, -0.08657410f, -0.02468105f, 0.02583474f, 0.06545381f, 0.00319062f, 
    -0.01426254f, -0.06660607f, -0.01853216f, -0.03424166f, 0.00746423f, 0.03008684f, -0.04501937f, -0.01083411f, 
    0.07413948f, 0.04083659f, 0.05133293f, -0.03750944f, -0.04421541f, -0.02753409f, -0.04362393f, -0.02878932f, 
    0.02926922f, 0.00145416f, -0.02989947f, -0.08998590f, -0.07790752f, 0.07426810f, -0.08770059f, 0.04099616f, 
    -0.06007079f, -0.08094945f, 0.07849201f, -0.02968518f, -0.07709586f, 0.04681922f, 0.02343013f, 0.02695591f, 
    -0.01998434f, 0.02815513f, -0.09250794f, 0.00182492f, -0.01978774f, -0.03676937f, 0.03059250f, -0.04072995f, 
    -0.03182204f, 0.04437406f, 0.06701417f, -0.03177159f, -0.01763924f, 0.03060809f, -0.07158252f, -0.05930741f, 
    0.00612660f, 0.04816724f, -0.08548854f, -0.06757120f, -0.08338966f, -0.07262921f, -0.06310111f, 0.00412844f, 
    -0.08823478f, -0.02007386f, 0.00023727f, 0.00563613f, 0.05991383f, 0.04624031f, -0.07436587f, 0.00487414f, 
    0.03890760f, 0.06935639f, -0.01832350f, -0.03190202f, 0.03059463f, 0.06191438f, -0.07558268f, -0.07800221f, 
    0.06949191f, -0.06471188f, -0.07446842f, -0.04988569f, 0.04809702f, -0.03546612f, -0.03129047f, 0.05066211f, 
    -0.06185849f, -0.06247138f, -0.03708439f, 0.05408458f, 0.01381283f, -0.05120832f, 0.04752370f, -0.07467911f, 
    0.04492551f, -0.07940939f, -0.05136642f, -0.01993189f, -0.08795573f, -0.02320634f, -0.03478242f, -0.03026367f, 
    0.05822854f, 0.06762636f, 0.04703580f, -0.03399498f, -0.00656173f, -0.02414904f, -0.04566393f, -0.07135958f, 
    0.06277645f, -0.01143050f, -0.05843971f, 0.04645919f, -0.02305455f, -0.08840693f, 0.06214729f, -0.00647286f, 
    0.03990523f, -0.03538159f, 0.04208137f, -0.05790398f, -0.01678261f, -0.02832937f, 0.04874834f, 0.00385425f, 
    -0.05250007f, -0.03974962f, 0.01350160f, -0.04314390f, -0.00653480f, 0.04246937f, -0.06226498f, -0.05749918f, 
    -0.04389764f, 0.00061513f, -0.00837460f, -0.06505107f, -0.08333501f, -0.03218983f, -0.05380205f, -0.07531054f, 
    0.06380983f, -0.07296260f, -0.06639481f, -0.00536081f, -0.02584666f, -0.08703405f, -0.00277386f, -0.07047442f, 
    -0.07344460f, -0.08441173f, 0.05041497f, 0.00725535f, -0.03253103f, 0.01695381f, 0.04834027f, -0.03914228f, 
    0.06234090f, -0.00189088f, -0.02956543f, -0.00428812f, 0.03920474f, -0.01333591f, 0.06445394f, 0.00975836f, 
    -0.02773511f, 0.00722675f, -0.01807499f, 0.02878962f, -0.03978930f, 0.00077671f, -0.07267813f, 0.04624785f, 
    0.01694406f, -0.05340477f, -0.03112561f, -0.07742788f, 0.02496731f, 0.02132235f, -0.06335195f, -0.03316732f, 
    -0.06935896f, 0.03763409f, -0.05305605f, -0.03795537f, -0.05890992f, -0.01473983f, -0.02214272f, -0.04949646f, 
    0.04672219f, 0.02310061f, -0.01106172f, -0.08283415f, 0.03807679f, 0.03471698f, 0.05360041f, 0.04433570f, 
    0.05541305f, 0.00781782f, -0.08597492f, -0.07689108f, -0.02383613f, -0.02920205f, -0.04619664f, -0.00738980f, 
    -0.00772437f, 0.30649549f, 0.10428791f, 0.04867505f, 0.01839487f, 0.02910178f, -0.11548257f, -0.03942920f, 
    -0.00628478f, 0.30028194f, -0.37878683f, -0.17794405f, -0.16598773f, 0.36093086f, 0.09724666f, -0.03605071f, 
    0.24676603f, 0.03207501f, 0.42465252f, 0.30772582f, -0.16630639f, 0.09954224f, 0.19838756f, 0.20887502f, 
    -0.04854839f, -0.37345180f, -0.10744931f, 0.12331827f, -0.36668560f, -0.05102609f, 0.07780328f, 0.10798515f, 
    0.09503298f, 0.09886325f, 0.06658710f, 0.04151605f, 0.16938832f, -0.61004078f, -0.13585736f, -0.01475737f, 
    -0.26553851f, -0.09270897f, 0.06972229f, -0.08624403f, -0.09701569f, -0.27905157f, 0.07644539f, -0.12347380f, 
    -0.00722619f, 0.08211147f, 0.22090152f, -0.13438648f, -0.11924218f, -0.16498350f, -0.24120753f, 0.40725568f, 
    0.10314882f, 0.06689093f, 0.05856173f, -0.06753594f, -0.26654190f, 0.03545412f, 0.24045052f, -0.30465952f, 
    -0.57053554f, 0.39170977f, 0.23866041f, -0.01120788f, -0.21890384f, 0.10036869f, 0.10975161f, 0.14603505f, 
    -0.07819328f, 0.11406446f, 0.11152371f, -0.05341407f, 0.16828437f, -0.12583520f, -0.07241501f, 0.02084363f, 
    0.02538104f, -0.25377363f, -0.91996408f, 0.09298790f, 0.03935732f, -0.05173544f, 0.04981639f, 0.12958305f, 
    -0.00678789f, -0.26563549f, 0.33414888f, -0.16768767f, -0.32125446f, -0.26623341f, -0.06326268f, 0.06034622f, 
    0.14459148f, -0.10399651f, -0.08938410f, -0.32346398f, -0.13321050f, -0.23049533f, -0.02754649f, -0.03298850f, 
    0.16001458f, 0.02099183f, 0.00425893f, 0.11672322f, 0.70097291f, 0.20587386f, 0.10058872f, -0.20029505f, 
    -0.30396324f, -0.11686874f, 0.24322505f, 0.08775336f, 0.02830715f, 0.14591007f, 0.23176093f, -0.18023205f, 
    -0.00142933f, -0.24255253f, 0.04870524f, -0.01773798f, 0.12079887f, 0.09953887f, -0.51184827f, -0.01454896f, 
    -0.07947662f, -0.13964830f, 0.08346105f, -0.08119047f, -0.21830416f, -0.16994502f, 0.09685560f, 0.41924319f, 
    0.14440204f, 0.40390337f, -0.08502539f, 0.23597220f, 0.09672035f, -0.12480374f, -0.07219060f, 0.23836830f, 
    0.07368038f, 0.03431123f, -0.03523513f, 0.06902710f, 0.06165856f, 0.02699991f, -0.04882357f, -0.07341897f, 
    -0.02592188f, -0.05541141f, 0.00516849f, 0.02212442f, -0.06168082f, 0.04871709f, -0.01913416f, -0.03522629f, 
    -0.01710078f, -0.00142249f, -0.04890379f, 0.01836446f, -0.02440484f, -0.04415620f, -0.01747591f, -0.06070362f, 
    0.01121000f, 0.02462026f, -0.04205211f, -0.00715285f, -0.05450160f, 0.04607068f, 0.02230321f, -0.00058486f, 
    -0.01080115f, -0.07209405f, -0.00908017f, -0.00584038f, 0.04372166f, -0.06175418f, -0.04407222f, 0.00063217f, 
    -0.01828488f, 0.04829516f, -0.08352413f, 0.00386941f, 0.00415222f, 0.01408932f, -0.01115875f, 0.06532487f, 
    -0.07618476f, -0.04521947f, 0.01471581f, -0.08901340f, -0.01582452f, 0.02782444f, 0.00108098f, -0.07483358f, 
    -0.07732283f, -0.04468995f, 0.01070739f, 0.03784496f, 0.03639746f, -0.07801505f, -0.06068942f, -0.01984673f, 
    -0.02094058f, 0.07130376f, -0.05876797f, 0.04395078f, -0.01412596f, -0.05702494f, 0.02870621f, -0.03123623f, 
    0.05340895f, 0.03247892f, -0.00390494f, -0.04300538f, 0.01174515f, -0.03014063f, 0.00328011f, 0.05139540f, 
    -0.00456855f, -0.03046787f, -0.06292353f, -0.01226292f, -0.02516518f, 0.01496832f, -0.08233048f, -0.08213201f, 
    -0.04198255f, -0.05161175f, 0.06183293f, 0.04044165f, -0.01792272f, -0.01772971f, -0.02339575f, -0.07328577f, 
    0.03425208f, -0.08680441f, 0.02536121f, -0.07171797f, 0.02681772f, 0.02917327f, 0.04186856f, -0.01184263f, 
    0.02344895f, 0.01057167f, -0.08426096f, 0.03781684f, -0.04109227f, 0.05158240f, 0.06093409f, 0.07415186f, 
    -0.08099820f, 0.02017281f, 0.02117478f, -0.04455801f, -0.08800816f, -0.02468826f, 0.01383523f, -0.03407893f, 
    -0.02374860f, 0.04607049f, -0.06128595f, 0.04810853f, 0.04629311f, 0.06194539f, -0.00282152f, -0.01297623f, 
    0.01536843f, -0.05335884f, 0.06431721f, -0.08209559f, 0.07556392f, 0.02473208f, -0.08439427f, 0.04120486f, 
    -0.04891679f, -0.02005902f, -0.08641620f, 0.05916580f, 0.02488973f, -0.00245444f, -0.07444905f, -0.00857447f, 
    -0.07283200f, -0.03500864f, 0.16483109f, -0.07512748f, -0.09949549f, 0.10209501f, 0.01888794f, 0.26057804f, 
    -0.13264132f, 0.46177450f, -0.13613410f, 0.15673710f, 0.15435514f, -0.12784117f, 0.17121258f, -0.23210052f, 
    0.17575845f, -0.06949062f, -0.01894828f, -0.22650330f, -0.28871277f, -0.10499882f, 0.05078503f, 0.02259615f, 
    -0.02132148f, -0.28327847f, -0.15581766f, 0.40771633f, 0.12558569f, -0.29233885f, -0.03366329f, 0.03778398f, 
    0.08048081f, -0.09352732f, 0.12862542f, -0.03960100f, 0.34107631f, 0.14093086f, 0.34594223f, 0.10942894f, 
    -0.05140064f, -0.15614197f, -0.02642411f, 0.17216778f, -0.06512108f, -0.65764850f, -0.57958853f, 0.01992933f, 
    -0.07592276f, 0.14968942f, -0.02449023f, 0.01729096f, -0.12736501f, -0.09056294f, 0.22562464f, -0.01269018f, 
    -0.07600285f, 0.19762026f, 0.03787222f, -0.23046997f, -0.17795379f, 0.03558757f, -0.05294468f, -0.15359989f, 
    0.08748834f, 0.11698464f, -0.09664427f, -0.04397356f, 0.18110290f, 0.05407479f, 0.20410053f, 0.03152556f, 
    0.08388082f, -0.17244543f, 0.14876944f, 0.05024523f, 0.07808745f, -0.11437596f, -0.07050394f, -0.03601146f, 
    -0.14002374f, -0.02960509f, -0.06719346f, 0.18063769f, -0.32283807f, -0.05566826f, -0.07703663f, -0.01205517f, 
    -0.00864686f, 0.25756228f, 0.02283746f, 0.03519953f, 0.10005395f, 0.20684551f, -0.10051429f, -0.08014762f, 
    0.11635549f, -0.29420921f, 0.12270477f, -0.06018847f, -0.03763651f, 0.36979431f, 0.01755616f, -0.05834803f, 
    0.13996464f, -0.02197113f, -0.07753374f, 0.06555571f, -0.01358962f, 0.21435337f, 0.00434684f, 0.23295601f, 
    0.05067370f, 0.21064955f, 0.09123007f, -0.07162633f, 0.24670701f, 0.16711500f, -0.34069434f, -0.05969035f, 
    -0.15063848f, -0.16175361f, 0.02548651f, 0.04223000f, 0.02745756f, -0.10722055f, -0.05152926f, 0.31907484f, 
    0.30070823f, 0.10019423f, -0.07220057f, -0.02873650f, 0.06328323f, -0.28446916f, 0.17402680f, 0.26001990f, 
    -0.04930684f, 0.11362536f, -0.09110101f, 0.01656946f, 0.14194821f, -0.01335575f, 0.10059393f, 0.00673714f, 
    0.34937102f, -0.00663246f, 0.04652788f, -0.28085849f, 0.01027458f, -0.02193095f, -0.01075136f, 0.23380123f, 
    -0.03879293f, -0.18740998f, 0.07734805f, 0.24942243f, -0.10142298f, -0.20241578f, 0.04939748f, 0.11633826f, 
    0.24085161f, 0.17479095f, -0.35855243f, -0.03059760f, -0.00558437f, -0.07254656f, -0.00991953f, 0.02617296f, 
    -0.09022703f, -0.11220513f, 0.10772377f, -0.10390051f, -0.16058850f, -0.05379021f, 0.24343985f, -0.11549558f, 
    0.06499339f, 0.08323903f, 0.16355252f, 0.16959894f, -0.54639459f, 0.06176405f, 0.02444924f, -0.02771408f, 
    0.07185993f, 0.15841840f, -0.19877379f, -0.00686543f, -0.05521685f, 0.23809162f, 0.47494134f, -0.05620800f, 
    -0.18590561f, -0.09833652f, -0.18486473f, -0.20582823f, 0.06520775f, 0.00719636f, 0.29764986f, -0.09504098f, 
    0.03893689f, -0.00747195f, 0.15560111f, 0.04679742f, -0.00218171f, 0.09615167f, -0.04882446f, -0.20110714f, 
    -0.23863700f, -0.10140338f, -0.02203934f, 0.11541303f, 0.06919140f, 0.12602465f, -0.07072819f, 0.15012182f, 
    0.15816718f, -0.18052399f, 0.14302146f, 0.11763192f, -0.03434931f, 0.27899686f, -0.01957155f, 0.20279709f, 
    0.04758848f, -0.07419403f, 0.16447504f, 0.21057412f, -0.08761319f, 0.01334384f, 0.02398346f, -0.07559400f, 
    -0.08222011f, -0.16032256f, -0.66515267f, -0.12408373f, 0.03576102f, 0.22683661f, 0.23035812f, 0.10790424f, 
    -0.21599543f, -0.03857508f, -0.09879632f, 0.21359561f, 0.23907311f, 0.23046499f, -0.19635415f, -0.15747111f, 
    0.12906027f, 0.29561979f, 0.10026543f, 0.03909005f, 0.59352416f, 0.01181159f, -0.04267592f, 0.18459404f, 
    0.02391250f, -0.16888581f, -0.01708066f, -0.26931834f, 0.00181402f, 0.09241314f, -0.46782506f, 0.29655996f, 
    -0.11556327f, 0.11239567f, -0.24206060f, 0.18274401f, -0.08849173f, 0.01985352f, -0.12704700f, -0.35190624f, 
    -0.23893617f, 0.26224020f, -0.11074227f, 0.18480660f, -0.11809739f, 0.03776814f, -0.06836732f, -0.09252620f, 
    -0.18821202f, -0.49750122f, 0.14038357f, 0.22639140f, 0.16346367f, -0.02905127f, -0.09080681f, -0.02742695f, 
    -0.42173046f, 0.36647981f, 0.04833049f, 0.10367008f, -0.05679921f, -0.01946679f, -0.01447014f, 0.08795796f, 
    0.01544852f, -0.16665892f, 0.07867569f, -0.38530749f, 0.17779168f, -0.04137847f, -0.04279370f, -0.06725407f, 
    -0.08117083f, -0.10743093f, -0.10265726f, -0.32330051f, -0.22525154f, -0.07207006f, 0.35338280f, 0.23046835f, 
    0.01664092f, 0.00902310f, 0.02002789f, 0.34088615f, 0.38150200f, 0.33767200f, -0.03469041f, 0.09838162f, 
    -0.06270988f, 0.17803214f, 0.07693668f, 0.31113389f, 0.06020353f, -0.24937342f, -0.14354585f, 0.16694693f, 
    0.03135579f, 0.21504992f, 0.22023483f, 0.02867159f, -0.21915765f, -0.51966548f, -0.03854758f, -0.17205232f, 
    0.11216863f, 0.04098269f, -0.29405072f, -0.07713856f, 0.06676693f, -0.11694855f, 0.16783042f, -0.05203959f, 
    -0.14313903f, -0.06600609f, -0.13486634f, 0.06476412f, 0.05110325f, 0.18417464f, 0.15738414f, 0.02096784f, 
    -0.16083413f, -0.29973015f, 0.12179237f, -0.07404750f, -0.00314263f, 0.11116527f, 0.19449939f, 0.39025179f, 
    0.23977372f, 0.37223512f, 0.17345586f, 0.11510456f, 0.07171888f, -0.26029903f, 0.03630144f, 0.09817301f, 
    0.04817314f, -0.00659786f, -0.00011255f, -0.15614493f, -0.06867852f, -0.07788958f, -0.28058621f, -0.02431825f, 
    -0.09450997f, 0.38465503f, 0.53356844f, 0.20891373f, 0.08074936f, -0.05446318f, -0.08043972f, 0.00031744f, 
    0.08329298f, 0.01563188f, 0.19061488f, -0.43607172f, 0.00006588f, 0.19996163f, 0.37491515f, -0.00204732f, 
    0.08904716f, 0.14823729f, -0.12801631f, -0.06146398f, 0.42165777f, -0.20867068f, -0.43874988f, -0.23421852f, 
    -0.03614821f, 0.18431717f, 0.09689056f, -0.12830400f, -0.10562656f, 0.04784974f, -0.46790135f, 0.09551074f, 
    -0.31198719f, -0.12762679f, 0.24424796f, 0.17493455f, -0.04931286f, -0.33986360f, -0.37167200f, -0.24131078f, 
    -0.13971514f, -0.05279468f, 0.18288092f, -0.34821922f, -0.02490466f, -0.23499940f, -0.08328101f, -0.15598458f, 
    0.30683753f, -0.06864502f, -0.02960997f, 0.14474812f, 0.12288912f, -0.12754372f, -0.06386443f, 0.20732148f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.01067612f, 0.11705122f, 0.33489132f, -0.00660920f, -0.01671714f, -0.00977263f, 0.20018497f, 0.08836366f, 
    0.08558081f, 0.05129521f, 0.04003217f, 0.10113552f, -0.03420294f, -0.14698240f, 0.06162686f, 0.37051639f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.16372123f, 0.16217069f, -0.18915163f, 0.12223528f, -0.07267040f, 0.20465080f, -0.01647699f, -0.08049092f, 
    0.50574791f, -0.24063066f, 0.17861420f, 0.22326958f, -0.20566460f, -0.37398052f, 0.28423432f, -0.03481840f, 
    -0.20407616f, -0.56819147f, 0.91489601f, 0.19652617f, 0.09202351f, 0.20223033f, 0.29368022f, -0.04600896f, 
    0.71044445f, 0.17307751f, -0.18106632f, -0.30968320f, 0.19879624f, 0.42888200f, 0.23499796f, -0.28613603f, 
    -0.18710001f, 0.33235505f, -0.41483566f, 0.04104437f, 0.03317282f, 0.53757775f, -0.32578379f, 0.18587960f, 
    -0.37653112f, -0.12879579f, 0.08895355f, -0.07990570f, 0.07994055f, 0.17596361f, 0.56275582f, -0.00551042f, 
    0.10728968f, -0.09835007f, 0.85599560f, 0.01517112f, -0.47466242f, -0.23168908f, -0.04362428f, -0.02538324f, 
    -0.23135422f, -0.22167560f, 0.21074702f, 0.24815759f, 0.03576470f, 0.30862519f, -0.17272976f, 0.78979748f, 
    -0.08083264f, 0.47991028f, -0.64793557f, 0.20589514f, -0.23217639f, 0.60108805f, -0.02026716f, 0.56065702f, 
    -0.28167468f, 0.16018337f, 0.00951675f, -0.30858263f, 0.00908116f, -0.14966027f, -0.17832865f, 0.27777860f, 
    -0.26489654f, 0.09983484f, 0.17794257f, 0.17114240f, 0.34665069f, -0.34058845f, -0.03615635f, 0.27393821f, 
    -0.23277637f, 0.22664186f, 0.16963521f, 0.50315225f, -0.03658855f, 0.50550318f, -0.18671186f, 0.21829747f, 
    0.22874792f, 0.10748097f, -0.12029062f, 0.14340720f, 0.07501810f, -0.23265824f, -0.00841031f, -0.25446010f, 
    -0.02999645f, 0.11402389f, -0.18668112f, -0.24386317f, 0.01117769f, 0.05480100f, -0.02002470f, -0.20487258f, 
    0.20697188f, 0.09756322f, -0.34329671f, 0.19984862f, 0.04607699f, -0.05024252f, -0.41314149f, 0.03911246f, 
    0.71149737f, -0.12271236f, 0.21915458f, -0.32355011f, 0.01881537f, -0.29809576f, 0.49918228f, 0.36086404f, 
    -0.01251335f, 0.01661307f, 0.42265010f, 0.24379262f, 0.14020897f, 0.33324975f, 0.31403035f, 0.04048418f, 
    0.36968580f, -0.19332676f, 0.23286007f, -0.30673552f, -0.02803288f, -0.38175780f, -0.06655940f, -0.06267611f, 
    -0.06459313f, -0.13578744f, -0.71619302f, 0.01611148f, -0.10595109f, 0.13680644f, 0.40150255f, -0.24929157f, 
    -0.52878934f, -0.12727425f, 0.12111460f, 0.24944182f, -0.18138082f, 0.17287575f, 0.18128729f, 0.74841708f, 
    -0.03679976f, -0.87600076f, -0.23797151f, 0.23293933f, -0.01711663f, 0.45390797f, 0.57808745f, 0.10097307f, 
    -0.12400152f, -0.10571002f, 0.18221033f, 0.27268970f, -0.03539385f, 0.16209613f, -0.64933217f, 0.10935447f, 
    -0.23032752f, -0.23427199f, -0.03534173f, -0.12737580f, 0.07258986f, -0.19793494f, -0.20686930f, -0.00344629f, 
    0.06891699f, 0.17608047f, -0.13593253f, -0.21848522f, -0.15099159f, -0.19761632f, -0.05273493f, 0.13578005f, 
    0.10675934f, 0.13204746f, 0.57336313f, -0.23724258f, -0.34259483f, -0.12381952f, -0.38694337f, 0.13427570f, 
    0.66843909f, 0.13729760f, -0.03269732f, -0.60148162f, -0.15477744f, 0.43576008f, 0.45375827f, 0.13409752f, 
    0.14449483f, 0.40853974f, 0.63845420f, 0.18796481f, -1.23714232f, -0.08491421f, 0.21725084f, -0.05951501f, 
    0.25010961f, 0.16485147f, 0.05178265f, 0.05626758f, 0.11074111f, -0.13027601f, -0.30401376f, 0.53856367f, 
    0.16791956f, -0.02092370f, 0.30525318f, 0.08309393f, -0.52134013f, 0.33531776f, 0.46915108f, -0.35403919f, 
    0.31384113f, -0.19085696f, -0.01492237f, 0.41546041f, 0.13840993f, -0.34628183f, -0.06290670f, 0.03473742f, 
    -0.22685926f, 0.00275711f, -0.21495000f, -0.11441153f, 0.48002139f, 0.01185660f, 0.28457674f, 0.05676270f, 
    0.65588534f, 0.02007363f, 0.15884495f, 0.00229746f, -0.06058258f, 0.41988337f, -0.58213419f, -0.38464123f, 
    -0.06001090f, 0.23619416f, 0.33407614f, -0.01246522f, 0.31528860f, 0.14032440f, -0.43542531f, 0.17726022f, 
    -0.84733284f, -0.16485780f, 0.19355658f, -0.01609733f, 0.04281738f, -0.35310566f, 0.26029578f, -0.32426918f, 
    -0.02025914f, 0.40826035f, -0.10056436f, 0.11573145f, -0.21825586f, 0.54020697f, -0.77106065f, -0.09509566f, 
    0.08278780f, -0.10544299f, 0.00885352f, 0.31565768f, 0.10003763f, 0.04075122f, 0.10004339f, 0.12699372f, 
    0.07697669f, -0.46587792f, -0.38326523f, 0.13304812f, 0.25654745f, -0.46216708f, 0.20232983f, -0.28189790f, 
    0.51785344f, 0.01848359f, -0.10702445f, 0.16755834f, -0.01114908f, 0.06143657f, 0.33550972f, 0.42371088f, 
    0.20481437f, -0.02924991f, 0.32676151f, -0.11830419f, -0.98034465f, 0.22774807f, -0.03236341f, -0.06796019f, 
    -0.08615561f, -0.13824536f, 0.12414748f, -0.11039185f, 0.09935963f, 0.38248691f, 0.35877305f, 0.03866155f, 
    0.05517924f, 0.05996878f, -0.11498096f, 0.18156540f, -0.10884154f, 0.17430709f, -0.21798509f, 0.09453528f, 
    -0.37935948f, 0.20783094f, -0.11543283f, 0.42276803f, -0.19963394f, -0.13365833f, 0.11614088f, 0.32811689f, 
    -0.17194802f, 0.20526005f, 0.47585714f, -0.20155829f, 0.66259974f, -0.20144090f, -0.56702536f, 0.02138244f, 
    0.38851473f, -0.21646984f, -0.13068083f, -0.05154096f, 0.06544045f, 0.36462796f, 0.56995922f, -0.27641174f, 
    0.11725456f, -0.72484618f, 0.33053932f, 0.03159598f, 0.00787069f, 0.45128253f, 0.67865533f, 0.34555811f, 
    -0.15183887f, 0.01032339f, 0.22490002f, -0.10688195f, -0.03688833f, 0.39592877f, -0.32915983f, -0.14622447f, 
    0.07705194f, -0.17484568f, 0.62323010f, -0.17004955f, 0.29900017f, -0.08925839f, 0.39611256f, -0.37334564f, 
    0.07924492f, -0.03441363f, 0.06275495f, 0.19436367f, 0.08427238f, 0.34395984f, 0.15349993f, -0.12658413f, 
    0.15509105f, -0.51090777f, 0.04688970f, -0.16412880f, -0.19700485f, -0.09896821f, 0.32249501f, -0.00136400f, 
    0.63479525f, 0.15544848f, 0.03980220f, 0.58663100f, 0.12245151f, 0.11663204f, -0.23825355f, 0.27108675f, 
    -0.23712714f, 0.24578254f, -0.72366500f, -0.08249158f, -0.14729668f, 0.28762841f, 0.30224976f, -0.09158082f, 
    0.02278045f, -0.06277718f, -0.15187103f, -0.83526009f, 0.04811969f, 0.24144772f, -0.16973665f, -0.19247852f, 
    0.18471885f, 0.84074777f, -0.00768388f, -0.07874571f, 0.16670278f, -0.12832147f, 0.21973556f, 0.50335187f, 
    -0.19982749f, 0.24054465f, -0.08368221f, -0.07144529f, 0.16923119f, -0.09511502f, -0.32141629f, 0.24628271f, 
    -0.13146332f, 0.12218191f, -0.10575560f, -0.17164192f, -0.03249352f, -0.23535532f, -0.13049343f, -0.16464138f, 
    0.11639044f, -0.05848855f, 0.13863885f, 0.17015842f, -0.24308994f, -0.17938483f, -0.17654492f, -0.11053415f, 
    0.04559619f, -0.11138263f, -0.14538917f, -0.01815081f, 0.32181218f, -0.33656549f, 0.37996772f, 0.17474855f, 
    0.26960969f, -0.16357139f, -0.19634500f, -0.25431436f, 0.04619294f, 0.50459313f, -0.33175385f, 0.41946876f, 
    0.07257159f, 0.00945952f, 0.04789003f, 0.07931834f, 0.58369821f, -0.29576552f, -0.19209720f, 0.03459434f, 
    -0.22391751f, 0.08236636f, 0.15330437f, 0.45324674f, -0.04309046f, 0.38090456f, 0.08043893f, 0.55129552f, 
    -0.24586871f, -0.02784398f, -0.20492166f, 0.06313038f, -0.08122956f, -0.02578949f, -0.09333967f, -0.24330322f, 
    0.26915684f, 0.16172311f, -0.06130040f, -0.16803034f, 0.04466107f, -0.08123837f, -0.28228083f, -0.02724248f, 
    -0.07043564f, 0.01336161f, -0.08668688f, -0.10802859f, 1.10026884f, -0.00866066f, 0.17069162f, 0.47329476f, 
    -0.15165633f, 0.17777117f, -0.23932169f, 0.55544937f, 0.02915280f, -0.04701286f, -0.41635633f, 0.04596674f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.02250383f, -0.01721151f, 0.22025478f, 0.50969160f, 0.35744333f, 0.16437328f, 0.03495671f, 0.38423783f, 
    0.33670670f, 0.08261047f, -0.08713517f, -0.00706130f, -0.03279318f, 0.26651928f, 0.30172172f, -0.23209573f, 
    0.38132218f, 0.07994390f, 0.37400958f, 0.33728892f, 0.48114192f, 0.30839872f, -0.17735232f, -0.24852824f, 
    0.58257413f, -0.22681457f, -0.14065722f, -0.16377144f, 0.25994140f, -0.20301893f, 0.09233490f, -0.23497586f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.01091224f, 0.26620883f, 0.09529453f, -0.21162976f, -0.47615987f, -0.14942631f, -0.06372546f, 0.41978300f, 
    -0.30524582f, 0.14439212f, -0.60102290f, 0.09045178f, 0.21066758f, -0.61428857f, -0.33976346f, -1.44075871f, 
    -0.82613498f, -0.22522812f, 0.82717603f, 0.04410666f, -0.01225324f, 0.32728860f, -0.11820000f, 0.17397894f, 
    0.23107262f, 0.37797740f, -0.79069370f, 0.14432992f, 0.05886132f, 0.10285212f, -0.10335226f, -0.32065341f, 
    0.06338610f, 0.37078306f, 0.11768464f, -0.03356429f, -0.35174307f, -0.33317742f, 0.01647310f, -0.15491471f, 
    0.12287990f, -0.35866892f, 0.06551130f, -0.08140790f, 0.17059618f, -0.00267519f, 0.45699653f, 0.16331843f, 
    -0.13820900f, 0.18248038f, -0.28960037f, 0.16622145f, 0.19632173f, 0.19109818f, 0.13671313f, 0.43926370f, 
    0.06135197f, 0.53869140f, -0.78001893f, -0.15435180f, -0.44340813f, -0.17413867f, -0.01155270f, -0.44603482f, 
    0.41627026f, -1.04615116f, 0.19521789f, -0.25731075f, -0.13691470f, 0.11927228f, -0.16576762f, -0.23324609f, 
    -0.51039231f, 0.45694003f, 0.03170815f, 0.15448816f, -1.32898295f, -0.25293547f, 0.33854574f, -0.44005802f, 
    -0.43984416f, 0.27393624f, 0.31976417f, -0.13902128f, 0.33701494f, -0.12614974f, -0.75687718f, -0.27800566f, 
    0.43608952f, -0.78218734f, -0.01989126f, 0.12623678f, -0.95533448f, 0.08997861f, -0.06993534f, 0.44262442f, 
    -0.81280947f, -0.11810848f, -0.08356202f, 0.08861027f, 0.05264728f, 0.29370606f, 0.11537069f, -1.09674859f, 
    -0.36118764f, 0.43121448f, 0.42938823f, 0.10100392f, -0.58681470f, -0.04900053f, 0.08626449f, 0.00583845f, 
    -0.44121286f, -1.92173254f, -0.23568632f, 0.15699302f, -0.03263816f, -0.45072764f, 0.45890146f, 0.31014907f, 
    0.14199959f, 0.19639155f, 0.12885702f, -0.13028467f, 0.11999679f, -0.06397261f, 0.06510130f, 0.16199796f, 
    -0.29119128f, -0.18507351f, -0.14619680f, 0.16208114f, 0.08708081f, 0.25848466f, 0.10253032f, -0.07982811f, 
    -0.32325679f, -0.29256472f, -0.92225921f, -0.11765969f, -0.09383729f, 0.13147072f, -0.55754584f, 0.00579955f, 
    -0.36571872f, 0.08771536f, -0.06883052f, -0.07957392f, 0.16549496f, -0.03989902f, -0.22455244f, -0.47064269f, 
    0.33903068f, 0.29045171f, 0.29429933f, 0.08077193f, 0.39622459f, 0.04244656f, -0.04006505f, 0.16157010f, 
    0.04532049f, 0.02802967f, -0.14479072f, 0.19421452f, -0.18537290f, -0.08197927f, -0.00458785f, 0.20264965f, 
    0.24328898f, -0.68581808f, 0.47345421f, 0.04724278f, 0.21352190f, 0.26730141f, 0.15966795f, 0.08946065f, 
    0.51100999f, -0.28819710f, 0.19255933f, 0.19107932f, -0.07298867f, 0.27409783f, -0.45594120f, -0.08675341f, 
    0.03288692f, -0.10148252f, -0.00016577f, 0.10351958f, -0.07008336f, -0.35848740f, -0.16382180f, -0.39430070f, 
    -0.23954825f, -0.24775378f, 0.23749627f, 0.08006077f, 0.04528519f, -0.03277394f, 0.12252835f, 0.10594491f, 
    -0.33603814f, 0.32490018f, -0.29789442f, 0.08945812f, 0.13860098f, 0.38047841f, -0.25794643f, -1.11640787f, 
    -0.86636335f, 0.05825708f, -0.51266116f, 0.15089129f, 0.06392524f, 0.04458790f, -0.12000307f, -0.14818774f, 
    -0.65271968f, 0.39201704f, 0.27772254f, 0.02289467f, -0.09293352f, 0.02331147f, -0.11409064f, -0.41793415f, 
    -0.23531607f, 0.38915840f, -0.66297817f, -0.11442851f, -0.75689882f, 0.34395993f, -0.15307294f, -0.33350655f, 
    0.08217131f, -0.93114102f, 0.13625763f, -0.13619648f, -0.08008268f, -0.63249165f, -0.41737342f, 0.63812822f, 
    -0.89488053f, 0.31683531f, -0.09692258f, -0.75448239f, -0.78143322f, 0.26384532f, 0.28673139f, 0.48284587f, 
    0.00304640f, -0.37171167f, 0.15486708f, -0.10714646f, 0.26746380f, 0.04958982f, 0.09388272f, 0.30679893f, 
    0.17841546f, 0.16159904f, 0.39469114f, -1.81331432f, 0.57482308f, -1.15313578f, -0.03493165f, 0.32151890f, 
    0.46381536f, -0.42862034f, 0.04783921f, 0.08847121f, 0.13785183f, -0.62403297f, 0.06375969f, 0.24824731f, 
    -0.31184673f, 0.38370121f, -0.83717328f, -0.03387101f, 0.03107333f, -0.06791403f, 0.16609852f, -0.27691886f, 
    -0.51052362f, -0.04201751f, 0.05221251f, 0.15672243f, -0.92874146f, -1.29724348f, 0.03338502f, -0.32252944f, 
    -0.13610108f, -0.52122074f, 0.21893908f, -0.16470957f, 0.28285605f, -0.05675302f, -0.07812581f, 0.12606078f, 
    -0.00795502f, 0.14089786f, -0.78188574f, -0.13681951f, -0.14663464f, -0.32327253f, -0.42643157f, 0.26493281f, 
    0.59046441f, -0.11706343f, 0.14147750f, -0.28974274f, 0.19473873f, 0.19851241f, -0.43532521f, -0.35988820f, 
    -0.32253402f, -0.76208955f, 0.31825304f, -0.13099335f, 0.32334799f, 0.04782589f, -0.02082624f, 0.11608119f, 
    0.26661894f, -0.06519107f, -0.43522003f, 0.04589193f, -0.03816228f, -0.23877239f, -0.13458365f, 0.20458637f, 
    0.42025331f, 0.29312238f, 0.21779361f, 0.01463174f, -0.47161591f, 0.53039300f, 0.64131153f, 0.09248050f, 
    -0.97841388f, -0.71135420f, 0.42881143f, -0.31158745f, 0.08623873f, -1.51806009f, -0.00830574f, -0.16821548f, 
    0.37552500f, -0.69662118f, -0.03737554f, -0.09105661f, 0.07385942f, -0.28236181f, -0.03699072f, -0.16372116f, 
    -0.09770028f, 0.00843775f, 0.18330272f, -0.12996989f, 0.30842134f, -0.21750686f, -0.10400999f, -0.24851853f, 
    0.40204287f, 0.08583307f, 0.55904138f, -0.01695044f, -0.41174611f, 0.01147049f, -0.08623669f, -0.54211372f, 
    -0.36521292f, -0.22055669f, -0.95104438f, 0.00858902f, 0.17619888f, -0.60460687f, 0.62583083f, -0.41908425f, 
    0.03482562f, -0.62809342f, 0.16140702f, -0.02060349f, -0.13152364f, -0.27704597f, 0.13603410f, 0.40320072f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.01596702f, -0.16486306f, -0.17158937f, 0.01897984f, 0.29922158f, 0.37164125f, -0.19571510f, -0.68276107f, 
    -0.08791851f, 0.36083323f, -0.04826671f, 0.00054302f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
