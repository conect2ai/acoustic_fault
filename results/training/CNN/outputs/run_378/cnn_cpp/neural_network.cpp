#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.24267483f, 0.71459997f, 0.49692467f, 1.07049918f, 1.21443510f, -0.09707163f, -0.09122245f, -0.28854325f, 
    0.10412458f, 0.45707446f, 0.30131739f, -0.09965535f, -0.00790010f, -0.35881758f, 0.08344519f, -0.23253860f, 
    0.06331218f, 0.30360347f, -0.17198826f, 0.21379857f, -0.02917294f, 0.13562399f, 0.04726605f, -0.19580638f, 
    0.04159640f, -0.23888350f, -0.92676610f, -0.46173960f, -0.06164733f, 0.16687681f, 0.66148549f, 0.98254430f, 
    0.40887424f, 0.25349137f, 0.71278572f, -0.68413216f, 0.46725810f, -0.21864700f, 0.17820284f, 0.24568275f, 
    -0.23809132f, 0.16466625f, 0.18918675f, -0.04042583f, 0.12320410f, 0.03512896f, -0.04695229f, -0.07394722f, 
    -0.03105880f, 0.23324721f, -0.74918342f, -1.10827398f, -0.97911525f, -0.55320764f, -0.56894624f, 0.07409196f, 
    0.38179746f, 0.23169276f, -0.04346400f, 0.16468026f, -0.56604499f, -0.07193318f, 0.03300928f, 0.39590222f, 
    -0.46511555f, -0.34804252f, -0.11796895f, 0.27443093f, -0.07532758f, -0.18459406f, 0.02454977f, -0.09321055f, 
    -0.49074760f, -0.04390762f, 0.25777575f, 0.39005262f, 0.60750622f, -0.71053165f, -0.42495123f, 0.27820972f, 
    0.82280225f, -0.60501528f, -0.85787362f, -0.95409709f, 0.34224364f, 0.68212336f, -0.22218028f, 0.13278335f, 
    -0.15815990f, -0.32572842f, -0.20743670f, -0.33199489f, 0.11156468f, 0.00747801f, -0.02096925f, 0.20703086f, 
    0.21452215f, 0.20120022f, 0.09953410f, -0.41319290f, 0.00921708f, -0.50093478f, -0.65245748f, 0.02060957f, 
    0.67466623f, -0.31139502f, 0.39766848f, 0.31554481f, 0.41501668f, -0.66735947f, -0.63819516f, -0.45070791f, 
    -0.47998106f, -0.71477741f, -0.46581829f, 0.04925970f, -0.18100771f, 0.03185250f, -0.10208307f, -0.44097424f, 
    -0.00632642f, -0.24684933f, -0.23026210f, -0.02336647f, -0.27152303f, -0.75482124f, -0.81879270f, -0.45587265f, 
    -0.36830646f, -0.15436882f, 0.16234511f, -0.53807402f, -0.73027480f, -0.01174357f, -0.41006237f, -0.65796173f, 
    0.41418481f, 0.03044054f, 0.21656439f, 0.16250841f, -0.10338657f, -0.22776115f, -0.16550881f, 0.18539919f, 
    0.16174810f, 0.10163464f, 0.37902647f, 0.18027365f, -0.34974045f, -0.15837263f, -1.16811216f, 0.47453681f, 
    -0.38234976f, -0.57160085f, -0.40179837f, -0.08819915f, 0.78860867f, -0.05054209f, -0.09324936f, 0.53171796f, 
    0.48892796f, -0.31420016f, 0.31721213f, -0.54552704f, -0.09150208f, -0.06382221f, 0.11065719f, -0.05148093f, 
    0.05487876f, -0.29723769f, -0.26737157f, 0.37517089f, 0.21494900f, -0.15542203f, 0.20218679f, -0.23224127f, 
    0.66431653f, 0.95053536f, -0.51289952f, 0.49996793f, -1.41848350f, 0.03458159f, -0.71939623f, -0.78916848f, 
    -0.49881640f, 0.44919235f, 0.29998928f, 0.01082231f, -0.04787269f, -0.20216094f, 0.00456576f, -0.42325577f, 
    -0.24242394f, -0.11490025f, 0.15425386f, 0.18796556f, -0.00321550f, -0.06301551f, 0.11861337f, -0.22858430f, 
    0.35644218f, 0.20396681f, -0.68671799f, -0.47595376f, 0.03243117f, 0.70337009f, 0.66199654f, -0.16279697f, 
    0.79096979f, 0.67584050f, -0.51947582f, -0.32062483f, -0.19357145f, -0.58557594f, -0.40600702f, 0.07354560f, 
    -0.14920516f, -0.15108919f, 0.13591453f, 0.04785758f, -0.10135178f, -0.42826355f, -0.44094190f, -0.09878676f, 
    -0.25518513f, -1.21531415f, 0.60953963f, -0.20264207f, -0.50419998f, -1.11693501f, 0.67449152f, 0.04191119f, 
    -0.70027125f, 0.56879306f, -0.23535708f, -0.06945522f, 0.22342144f, 0.28097710f, 0.12524733f, 0.29177123f, 
    -0.09408569f, -0.16088875f, 0.16661558f, -0.00553056f, -0.32969186f, 0.32326525f, 0.10714730f, 0.37866965f, 
    0.29596996f, 0.18870004f, 0.27415496f, 0.69758159f, 0.76793027f, 0.02164111f, 0.44807374f, 0.68133682f, 
    0.42884871f, 0.18346593f, -0.03509105f, 0.41948026f, -0.02663560f, -0.32905671f, 0.45179158f, -0.62470645f, 
    0.00245444f, 0.39245728f, -0.31812349f, -0.48046848f, -0.68762869f, -0.44075617f, -0.46075651f, -0.34972668f, 
    -0.22140780f, 0.08738498f, -0.42811048f, 0.07436131f, -0.40889916f, -0.78548115f, 0.39842564f, 0.65550268f, 
    0.90527475f, 0.65676469f, -0.25694475f, 0.53775209f, -0.47131282f, -0.30964831f, 0.09956123f, -0.58632499f, 
    0.47855023f, 0.67174262f, -0.19923232f, -0.33476764f, 0.03008875f, -0.35065892f, -0.00602481f, 0.48765510f, 
    0.16407314f, 0.04439567f, 0.43652689f, -0.15061450f, 0.08687583f, -0.39711264f, -0.16369504f, 1.08155608f, 
    0.70545006f, -1.19368982f, -0.08781459f, -0.40032411f, -0.72521824f, -0.04426849f, 0.53963959f, 0.14254402f, 
    -0.15009795f, 0.06225076f, 0.12888196f, -0.18371588f, 0.43758288f, -0.22251810f, 0.33094791f, -0.32103807f, 
    0.09438591f, -0.04432255f, -0.08434627f, 0.42548040f, -0.17532170f, 1.07933819f, 0.81598395f, 1.20247734f, 
    -0.50686157f, 0.61979395f, 0.26210651f, 0.23678447f, 0.01747934f, -0.08666713f, -0.12706433f, 0.44062433f, 
    0.38178015f, 0.21184288f, 0.13148575f, -0.12624341f, 0.40104407f, 0.22593746f, 0.09731895f, 0.17680275f, 
    -0.37196106f, 0.30086607f, -0.25245675f, 0.06767086f, 0.07825460f, 0.23717393f, -1.02014685f, -0.65280730f, 
    -0.51789159f, -0.40984735f, -0.27830482f, 0.85695964f, 0.61728477f, -0.31391129f, 0.47735098f, 0.62183231f, 
    0.14808397f, -0.23246199f, 0.47131449f, -0.25201347f, 0.10436761f, -0.20447885f, 0.30348504f, 0.28415185f, 
    0.08983026f, 0.02656110f, -0.26790240f, -0.41555038f, -0.26754034f, -0.04058044f, -0.01896788f, -0.66206777f, 
    -0.15609755f, -0.66781390f, -0.45456666f, 0.79749495f, -0.87147558f, -0.39927015f, 0.09311552f, -0.20286700f, 
    0.27485523f, -0.67180330f, -0.00594202f, 0.05801669f, -0.30796611f, -0.12998292f, 0.53614551f, -0.05577015f, 
    -0.02605956f, -0.39835367f, -0.35822713f, 0.33799779f, 0.40304235f, 0.10350901f, 0.36438558f, -0.19995178f, 
    1.08361816f, 0.11028972f, 0.74867696f, 0.96904576f, 1.02192652f, 0.82627290f, 0.04709746f, -0.15874715f, 
    -0.48517647f, -0.46111837f, -0.39029071f, 0.03415544f, 0.08855955f, 0.42338282f, -0.18580030f, -0.22842707f, 
    0.12552947f, 0.21826184f, 0.30158657f, -0.07789215f, -0.19108929f, 0.12863697f, -0.53223914f, -0.32614970f, 
    0.11683483f, -0.78029954f, 1.03572857f, 0.24257073f, -1.14325619f, -0.61528367f, 0.84521580f, 0.67371756f, 
    -0.33793670f, 0.44902757f, 0.61015952f, -0.23295966f, 0.15190798f, 0.10141902f, 0.21205328f, -0.29868633f, 
    -0.05095036f, -0.17521264f, -0.21427064f, 0.04395163f, 0.04466770f, -0.38712132f, -0.29075095f, 0.33767599f, 
    0.00903865f, 0.14429289f, 1.18241632f, 0.06238949f, -0.82509828f, -1.27794409f, -0.67489129f, -0.53445464f, 
    0.66968942f, -0.00105998f, -0.26358539f, 0.39654034f, 0.18300962f, -0.33770630f, 0.13837399f, -0.52658486f, 
    0.34703860f, 0.05097691f, 0.11434721f, -0.00944304f, -0.11638489f, 0.19669387f, -0.03963748f, -0.09941027f, 
    0.11813130f, 0.29249012f, 0.11059920f, -1.17781436f, 0.76996744f, 1.06251001f, 0.10670418f, 0.66980106f, 
    0.95136362f, 0.70634425f, 0.69789749f, 0.33460683f, 0.28415465f, 0.38355210f, -0.20698126f, 0.35435635f, 
    -0.07584400f, 0.05161357f, -0.31397536f, -0.09677009f, -0.16899005f, -0.08248269f, 0.07728678f, -0.01031350f, 
    0.21619239f, -0.17639489f, 0.24186569f, 0.15624975f, -1.05697465f, -1.24608934f, -0.25417385f, 0.43499404f, 
    0.48444438f, -0.27222973f, 0.79164910f, 0.13280654f, 0.08621498f, -0.37090075f, 0.21798833f, -0.13457827f, 
    -0.16193022f, 0.23921637f, 0.40409312f, 0.19258648f, 0.52573276f, -0.32072765f, -0.40830982f, 0.40085992f, 
    -0.11789600f, -0.03415077f, 0.43191743f, -0.12278469f, 0.11342154f, -0.95168000f, 0.42443907f, -0.87468743f, 
    -0.41922572f, 0.63117200f, -0.26287049f, 1.01032412f, 0.58972031f, 0.08299155f, 0.51498413f, -0.51232415f, 
    -0.24897619f, 0.08862612f, -0.43621904f, 0.23146878f, 0.09186693f, -0.07756626f, 0.13620819f, 0.12871063f, 
    -0.25986603f, 0.06631908f, -0.20917022f, -0.01328772f, 0.38733071f, -0.13090511f, 0.07973418f, -1.92210293f, 
    0.47542119f, 0.73179454f, 0.46101463f, 0.21570615f, 1.05741036f, 0.76054102f, -0.53342950f, 0.19130547f, 
    0.10964243f, -0.06197770f, -0.38649955f, 0.13837843f, -0.02009874f, -0.35629576f, -0.21685810f, -0.25437894f, 
    0.18856770f, -0.25877342f, -0.04075587f, -0.06955630f, 0.05300430f, 0.12438508f, -0.26187873f, 0.70956022f, 
    -0.15741038f, -0.27622101f, -0.75488353f, 0.99804461f, 0.77750432f, -0.20136711f, 0.66030169f, -0.02007514f, 
    -0.27758434f, 0.35008526f, 0.40288264f, -0.29753006f, 0.44229266f, -0.20573473f, 0.48706362f, 0.34581703f, 
    0.00113082f, 0.73101211f, 0.60393333f, 0.43730795f, 0.38510442f, -0.35495910f, -0.17793587f, -0.04256386f, 
    0.92192382f, 0.44809523f, 0.99141288f, 0.94122201f, 0.76606762f, -0.10394947f, 0.55988228f, -0.06718644f, 
    -0.39043486f, -0.57646406f, 0.20272049f, -0.01225351f, -0.56377262f, 0.15391225f, 0.13858449f, -0.17644267f, 
    -0.22050031f, -0.07938319f, -0.03517669f, 0.27752835f, 0.00915298f, 0.43617129f, 0.44440410f, 0.39279416f, 
    -0.02409887f, 1.04996586f, 1.18256545f, -0.52357036f, -0.86262745f, -0.36286792f, 0.42055008f, 0.26485783f, 
    -0.58261704f, 0.23657179f, 0.22856897f, 0.06953754f, 0.16914493f, -0.27515411f, 0.25758016f, -0.40486953f, 
    -0.06540141f, 0.09127330f, 0.03732477f, 0.03310439f, 0.31294438f, -0.18357526f, -0.03093853f, -0.36270669f, 
    -0.29335454f, 0.13742813f, -0.18458281f, 0.80147260f, 1.09851301f, 0.49528661f, -1.07319427f, -0.49211287f, 
    -0.34581384f, -0.15181828f, -0.52232558f, -0.17749085f, 0.52915567f, 0.32108954f, -0.24302456f, 0.11770619f, 
    -0.19897853f, 0.21182653f, 0.17774200f, 0.10279112f, 0.03414974f, 0.19933279f, -0.09739158f, -0.05755652f, 
    0.26038387f, -0.00173428f, 0.25084868f, -1.42754912f, 1.05899405f, 0.71000880f, -0.50009727f, 0.26847932f, 
    -0.80811399f, 0.32286710f, 0.63321900f, -0.10763063f, -0.21210213f, -0.15038598f, 0.35103717f, -0.22841826f, 
    0.24408931f, -0.09050915f, -0.35207260f, 0.07567885f, 0.12071293f, -0.24659847f, -0.04789936f, -0.04555673f, 
    -0.23738267f, -0.06229961f, -0.07839193f, -0.13926193f, -0.96915704f, 1.25790310f, -0.25814402f, -0.91249883f, 
    0.20473635f, 0.23816358f, -0.24814335f, -0.63244456f, -0.60217196f, -1.00085258f, -0.11010445f, -0.21074191f, 
    -0.03645017f, 0.17608646f, -0.38807622f, 0.00459190f, 0.12553482f, 0.25669476f, -0.29363295f, -0.35064334f, 
    -0.16590801f, 0.07316254f, 0.06649001f, 0.24509026f, 0.44656250f, 0.89854473f, 0.18378873f, -0.45398378f, 
    0.64616799f, -0.58126855f, -0.07598136f, -0.02947895f, 0.24500799f, -0.43383500f, -0.64564300f, -0.51933801f, 
    -0.08371460f, -0.44556338f, -0.38540471f, -0.66949844f, -0.20909178f, 0.25678703f, 0.68101001f, 0.46550867f, 
    -0.26212859f, -0.09643133f, -0.07199351f, -0.30331463f, 0.05175887f, -0.31180066f, 0.62084031f, -0.80047148f, 
    0.56683582f, 0.75158024f, 0.72668922f, -0.22829409f, -0.98817474f, -0.93551213f, -0.72122300f, -0.34694964f, 
    0.33242658f, 0.26086643f, 0.26427150f, -0.05884152f, 0.14931567f, -0.05383806f, -0.14353697f, -0.06029976f, 
    -0.13327831f, 0.41155839f, -0.40084735f, -0.14033143f, 0.15622045f, 0.23809022f, 0.24837078f, 0.24318965f, 
    -0.54811937f, -0.65055329f, -0.55380458f, -0.16978504f, 0.20013878f, -0.69728106f, -1.01140690f, -0.55186510f, 
    0.03933976f, 0.10184239f, 0.49369645f, 0.48873386f, 0.28897208f, 0.35068879f, -0.05690225f, 0.08369364f, 
    0.16977519f, 0.25765851f, 0.57219940f, -0.03623507f, 0.16380988f, -0.24425028f, -0.13829461f, 0.34677920f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.15088269f, -0.05191483f, -0.03372036f, 0.18872008f, -0.04853930f, 0.44278368f, 0.09250420f, 0.32357132f, 
    -0.20791754f, 0.24179757f, 0.19144177f, 0.32873428f, 0.48027152f, 0.16310419f, 0.11127364f, 0.20371217f, 
    0.18924187f, -0.11537460f, 0.34649813f, 0.24934107f, 0.19492634f, 0.16737060f, 0.28476465f, 0.20783059f, 
    0.25675184f, 0.17315933f, 0.23260885f, 0.11819130f, 0.29868871f, -0.11946651f, 0.35629395f, 0.33828127f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.23066942f, 0.00229229f, 0.11342779f, 0.34143075f, -0.38183069f, 0.02600051f, 0.07143999f, 0.13229328f, 
    -0.03541625f, 0.09120812f, -0.11414471f, -0.04349789f, 0.08216561f, 0.03466453f, -0.01089169f, -0.20399235f, 
    0.03720218f, 0.06836260f, 0.00989166f, 0.04814918f, 0.12495422f, 0.06077153f, 0.08359891f, 0.21106242f, 
    -0.19264421f, 0.04836546f, -0.16159615f, -0.32856998f, 0.05296559f, 0.05551140f, 0.09535341f, 0.08367465f, 
    0.09294545f, 0.00656915f, -0.08862311f, 0.07634032f, 0.05745474f, -0.14715809f, 0.34309092f, -0.22235568f, 
    -0.10604482f, -0.04561964f, 0.07429097f, -0.07313974f, -0.00455208f, 0.10429536f, -0.02056838f, -0.07343560f, 
    -0.43072996f, 0.32326773f, -0.04374208f, 0.00380052f, -0.00397918f, 0.07910148f, 0.13662301f, -0.02894205f, 
    -0.03333389f, 0.13675006f, 0.09617536f, 0.01531630f, -0.43734407f, -0.31341016f, 0.17105362f, -0.11914080f, 
    0.11438522f, -0.02733316f, 0.10720056f, -0.00698563f, -0.09950528f, -0.14281777f, -0.05939011f, -0.12042397f, 
    0.54225314f, 0.07709663f, 0.14170688f, -0.26458144f, -0.01419419f, 0.05599597f, 0.02866553f, 0.03016991f, 
    -0.00116727f, 0.02642396f, -0.06500574f, 0.02635719f, -0.05644741f, -0.16879047f, 0.00638105f, -0.17278627f, 
    -0.09655432f, 0.03676475f, -0.16077471f, -0.06351237f, 0.02157709f, -0.22067972f, 0.06587663f, -0.07224843f, 
    0.26853690f, 0.23071006f, -0.01205323f, -0.01184031f, -0.00518627f, 0.11261056f, 0.09527776f, -0.04857477f, 
    -0.02750441f, 0.04740050f, 0.09705126f, 0.16642459f, 0.55220449f, 0.16631484f, -0.11227253f, -0.13748163f, 
    0.00967202f, -0.05873961f, 0.11288267f, -0.02560698f, 0.05028973f, -0.04838600f, -0.07334532f, -0.03575722f, 
    -0.02083700f, -0.16580182f, 0.10233216f, -0.03099236f, -0.33240977f, -0.13473633f, 0.08463385f, 0.10755347f, 
    -0.08813258f, 0.00527692f, 0.04747823f, -0.16927338f, -0.11423659f, 0.07953911f, -0.00006806f, 0.08063836f, 
    0.06873130f, -0.08302145f, 0.00177771f, 0.00657178f, 0.02061707f, -0.16483298f, 0.00350327f, -0.09899250f, 
    0.21846598f, -0.09435880f, -0.04302275f, 0.31003839f, -0.02067168f, -0.08316828f, -0.07518012f, -0.16616833f, 
    -0.06877924f, -0.13211069f, 0.09522972f, 0.02840089f, -0.14892338f, 0.01544897f, 0.16022223f, -0.60993427f, 
    -0.32493263f, -0.08531717f, 0.02841694f, 0.06197698f, 0.09111919f, 0.02119495f, 0.04689587f, -0.10679045f, 
    0.37384841f, 0.06238040f, 0.02181874f, -0.25639606f, 0.15570655f, -0.02795793f, -0.14440463f, 0.03038386f, 
    0.00640775f, 0.01722580f, -0.03638751f, 0.01894255f, -0.25213167f, -0.00300302f, -0.04889773f, 0.06557067f, 
    0.00352603f, 0.06473154f, -0.09477070f, 0.07105605f, -0.00039205f, -0.06882188f, 0.01703360f, 0.09354417f, 
    0.24729270f, -0.17340265f, -0.08886003f, 0.23520167f, -0.23833518f, -0.09242199f, 0.07114667f, 0.03382390f, 
    -0.07032163f, 0.04383989f, -0.06239060f, -0.02019023f, 0.45113629f, -0.00627926f, 0.01648711f, -0.21319488f, 
    0.00373139f, 0.07461718f, 0.11430849f, 0.09891545f, 0.01716394f, -0.03767503f, -0.03993143f, 0.11777302f, 
    -0.69976211f, 0.03305448f, 0.20313922f, -0.46216932f, -0.01263955f, -0.05370802f, 0.02997840f, -0.07523556f, 
    -0.09813177f, -0.02319812f, 0.05022973f, 0.01172716f, -0.05500929f, -0.07269305f, 0.23356974f, 0.03629141f, 
    -0.07641913f, -0.02174985f, 0.11039857f, -0.23716500f, -0.09014773f, -0.04318788f, 0.05377762f, 0.06952667f, 
    -0.45676363f, 0.18255672f, 0.13591298f, 0.08024565f, 0.16171168f, 0.18123984f, -0.22865434f, 0.08774512f, 
    -0.07223283f, 0.07515007f, -0.02209339f, -0.06089554f, 0.17908956f, 0.28821597f, 0.10199150f, -0.32653329f, 
    0.09476510f, 0.03208427f, -0.05212578f, -0.02011850f, -0.15846997f, 0.11223035f, -0.12557831f, 0.07181346f, 
    -0.33064395f, 0.13042313f, -0.01217846f, 0.12536791f, -0.04056145f, 0.09547947f, -0.01743372f, -0.13881654f, 
    -0.04797098f, 0.01558035f, 0.02114928f, -0.09976604f, 0.15300277f, -0.23272160f, 0.08574758f, -0.37442493f, 
    -0.09834684f, 0.15599836f, 0.05539871f, -0.10338269f, 0.11571802f, -0.02184890f, 0.15505762f, -0.01247757f, 
    0.21187009f, 0.07020231f, -0.01148954f, 0.19390975f, -0.33630472f, 0.06682610f, -0.00300555f, 0.07944988f, 
    -0.03415696f, -0.21517850f, 0.04436973f, -0.21642043f, -0.13849373f, 0.02266630f, 0.05250312f, -0.48626792f, 
    0.00846493f, 0.15831223f, 0.03542279f, 0.16203868f, -0.04022055f, 0.07993919f, -0.11100394f, 0.06472217f, 
    -0.24579720f, 0.23242030f, -0.06400622f, 0.23227486f, -0.02580762f, -0.07945199f, 0.04489225f, -0.00031082f, 
    -0.07601304f, -0.08452918f, 0.03544554f, 0.03842844f, -0.81325340f, 0.04560250f, 0.07165759f, 0.09978175f, 
    0.00967552f, -0.02756808f, 0.12549677f, -0.10896861f, -0.13291298f, -0.03695274f, 0.03691099f, 0.03570082f, 
    -0.28845468f, 0.08113965f, 0.03864849f, -0.15663560f, 0.01464020f, -0.03157187f, 0.03810569f, -0.04044979f, 
    0.05375540f, -0.10414793f, -0.01640586f, -0.08429263f, 0.06883536f, 0.22062850f, -0.02193261f, 0.20922577f, 
    -0.14722720f, -0.06937229f, -0.29172972f, -0.05892512f, 0.08623020f, 0.09566217f, 0.08912314f, 0.10979813f, 
    0.29228795f, -0.44302982f, -0.00558676f, 0.17495194f, -0.10814621f, -0.09800930f, -0.04432055f, 0.13296801f, 
    -0.11709794f, 0.02845669f, -0.07537329f, -0.00863679f, -0.21473329f, -0.36767384f, 0.20802473f, -0.25101617f, 
    0.01070389f, 0.04388245f, 0.18026173f, -0.17766903f, -0.06126574f, -0.09207170f, -0.06395035f, 0.10009426f, 
    0.43830904f, -0.14510152f, 0.12202320f, 0.38587415f, -0.17975231f, -0.06560256f, 0.06988338f, 0.03038418f, 
    0.03000389f, -0.10391083f, 0.02864541f, -0.04415728f, 0.54903853f, -0.12160164f, -0.12051463f, -0.10845918f, 
    0.15352926f, 0.03093110f, -0.09458755f, 0.00391631f, 0.05103310f, 0.12948915f, 0.05630519f, 0.06887919f, 
    0.06209947f, -0.05126921f, 0.03136215f, 0.02226388f, 0.06369739f, -0.10366099f, 0.07854830f, 0.04766382f, 
    -0.11290310f, -0.11801745f, 0.03281955f, -0.09566754f, 0.11269846f, -0.10768761f, 0.04180402f, -0.44842190f, 
    -0.07346884f, -0.19912642f, 0.04497134f, -0.18379225f, -0.04065716f, -0.16642851f, 0.03353411f, -0.08471248f, 
    0.00021934f, -0.19756226f, 0.00779621f, -0.08724335f, 0.06626811f, 0.00240717f, -0.13231525f, 0.10996397f, 
    -0.03625630f, -0.03573025f, -0.28902397f, -0.04282677f, 0.03256806f, 0.07877322f, 0.06827938f, 0.06702819f, 
    -0.09120280f, -0.13856255f, 0.11655074f, -0.02155839f, 0.01138830f, 0.12159687f, -0.01665058f, -0.00621225f, 
    0.08396436f, -0.16076981f, -0.37392977f, -0.25263014f, -0.13239114f, -0.04915834f, 0.06564575f, -0.01872621f, 
    0.02910008f, -0.04937791f, -0.03623865f, 0.10383093f, -0.42882103f, 0.13930804f, -0.21183328f, -0.15336923f, 
    0.00666912f, -0.04885126f, 0.08783504f, 0.01807403f, 0.02693552f, 0.17918634f, 0.02384877f, -0.04262367f, 
    -0.10672551f, -0.15514669f, 0.20604235f, -0.09884021f, 0.15780285f, -0.05661326f, -0.29910576f, 0.03395663f, 
    0.07194167f, -0.11984796f, -0.08031696f, -0.07320002f, -0.68079650f, -0.43038929f, 0.00909222f, -0.02136566f, 
    0.07963376f, -0.06784695f, 0.00818493f, 0.16478841f, 0.17049688f, -0.06573121f, -0.08828849f, 0.12420601f, 
    0.21678485f, 0.19220577f, 0.16840595f, 0.12454657f, -0.09595457f, 0.26876473f, -0.02789572f, -0.06886761f, 
    0.01599740f, -0.13662502f, -0.00216652f, 0.12213243f, 0.36977232f, -0.22688857f, -0.20340888f, -0.05301477f, 
    0.08410293f, -0.09477171f, -0.04943220f, -0.08487717f, -0.17308296f, 0.13873753f, -0.13757062f, -0.01243593f, 
    -0.08497658f, -0.32327265f, -0.21340609f, 0.14260174f, -0.06098909f, 0.11984345f, -0.09509797f, 0.14598177f, 
    0.06532248f, 0.06854088f, -0.00291416f, 0.09522169f, 0.25273520f, 0.23414154f, 0.08367117f, 0.18012773f, 
    -0.02624567f, 0.02859825f, -0.10233748f, 0.06213216f, 0.22133446f, -0.07585545f, -0.01796009f, 0.03790312f, 
    -0.03221516f, -0.06410261f, 0.00592301f, -0.04405283f, 0.13892391f, 0.04067117f, -0.02219476f, -0.01900355f, 
    -0.07094982f, 0.01754691f, -0.03098797f, 0.06643473f, 0.05171996f, 0.05642153f, 0.00212452f, -0.70127153f, 
    0.02826586f, -0.06142582f, -0.03097761f, -0.02017627f, -0.03075665f, -0.02913654f, -0.21438000f, 0.06802675f, 
    0.30637601f, -0.02763417f, 0.19063979f, 0.10503423f, -0.14308220f, 0.08558840f, -0.14710782f, 0.00029905f, 
    -0.03082532f, 0.03515420f, 0.02749169f, -0.00599233f, -0.89578211f, -0.06214839f, 0.18148792f, -0.14809264f, 
    -0.07594588f, -0.14128591f, -0.04126532f, -0.19567651f, -0.01041099f, 0.05552437f, 0.06022501f, -0.13324115f, 
    0.63590568f, -0.24778815f, -0.00445676f, -0.37025836f, 0.04805073f, 0.02265642f, 0.07938937f, 0.16521604f, 
    -0.16772003f, 0.00763628f, -0.00975493f, 0.04194212f, -0.02489405f, 0.30595371f, 0.06588139f, 0.07596513f, 
    -0.12963545f, 0.05562861f, 0.04885760f, 0.03998883f, -0.16383803f, 0.18201382f, -0.02096955f, -0.16071254f, 
    0.18233716f, -0.01680811f, -0.10867012f, 0.12569392f, -0.04450442f, 0.13202296f, 0.06901426f, -0.01042115f, 
    -0.04600244f, 0.04997587f, -0.07935727f, 0.12509449f, 0.07389813f, -0.01708859f, 0.00830069f, -0.21864258f, 
    0.06585238f, 0.01609087f, -0.21844579f, 0.06864676f, 0.27265292f, 0.01937879f, 0.11656690f, 0.06819382f, 
    0.13987121f, -0.07944623f, 0.01428908f, 0.26844555f, -0.22772862f, 0.08445589f, 0.03390693f, 0.04010197f, 
    0.08488250f, -0.00536475f, -0.08308149f, -0.00316388f, 0.27063447f, -0.24176534f, 0.11846951f, -0.25148025f, 
    -0.03072297f, -0.05942302f, -0.18644089f, 0.16508153f, -0.21572527f, 0.11094287f, -0.06658771f, -0.00759440f, 
    0.10662511f, 0.04597823f, 0.28330827f, 0.27277693f, -0.25100702f, 0.01003341f, 0.06212208f, -0.05110520f, 
    -0.05226240f, 0.14792849f, 0.16248895f, 0.16799368f, 0.18713874f, -0.05303745f, 0.10770034f, -0.38728663f, 
    -0.04708090f, -0.14853093f, 0.04723131f, 0.01060752f, -0.20339271f, 0.06997875f, 0.08834156f, -0.09860429f, 
    -0.31180438f, 0.06675345f, -0.27245700f, -0.04619787f, 0.04238353f, 0.04658907f, -0.00338870f, -0.10100587f, 
    0.02189378f, 0.04006337f, 0.08353308f, 0.05962773f, -0.27299821f, 0.07455916f, -0.28217143f, -0.31684557f, 
    -0.00632180f, 0.00914469f, -0.01174864f, -0.07840582f, -0.13153400f, -0.16247335f, -0.02543529f, -0.15851939f, 
    0.02215923f, 0.10464117f, -0.22239852f, -0.51037937f, -0.00819560f, 0.17220631f, 0.12324045f, 0.04957534f, 
    0.06597970f, 0.10497428f, 0.08068911f, -0.03396549f, 0.17109992f, -0.40569204f, -0.22739978f, 0.20764798f, 
    0.01097145f, -0.04802902f, -0.08287074f, -0.00945333f, 0.11187825f, -0.26193956f, -0.14943212f, 0.10475393f, 
    -0.25565800f, -0.11810650f, 0.25948346f, -0.20968084f, 0.02580585f, 0.08347517f, 0.00339499f, -0.00086829f, 
    0.03341561f, 0.01423211f, 0.00789219f, -0.00946688f, 0.07347052f, 0.08894687f, 0.14818066f, -0.02321909f, 
    -0.02923966f, 0.01276207f, 0.03167109f, 0.15454945f, -0.09137934f, 0.23159106f, 0.11098357f, -0.07539557f, 
    0.00277508f, 0.11534753f, -0.07293192f, 0.03080628f, 0.08653391f, -0.01996015f, -0.04415607f, 0.02442413f, 
    0.04887147f, 0.06937978f, -0.07010661f, 0.06245364f, 0.25333217f, 0.03735933f, 0.25248751f, 0.20725362f, 
    -0.20230171f, 0.01410278f, 0.11559575f, 0.17472266f, -0.02082893f, -0.10743389f, -0.15206079f, 0.04282685f, 
    0.19546311f, 0.14674902f, -0.06551424f, 0.33276150f, -0.19180267f, -0.17493662f, 0.15519109f, 0.04359472f, 
    0.08010083f, 0.00645375f, -0.04394614f, -0.06844334f, -0.18388540f, -0.04551314f, 0.11890513f, -0.17990156f, 
    -0.05219082f, -0.09178853f, 0.00272507f, -0.04470168f, 0.09894983f, -0.08499195f, -0.07987958f, 0.00212263f, 
    -0.22865580f, -0.08897821f, -0.20697141f, -0.10265891f, -0.05407403f, 0.18625872f, -0.03238029f, -0.03588657f, 
    0.08065754f, -0.01335655f, -0.06487133f, 0.05959730f, -0.24590938f, -0.34113231f, 0.05476525f, -0.28302673f, 
    -0.22279425f, -0.13181700f, -0.00171246f, -0.07673182f, -0.05154324f, -0.02160285f, -0.11165879f, 0.03924870f, 
    0.21987021f, 0.07928431f, 0.22201921f, 0.00504316f, 0.21794896f, 0.06572691f, -0.09757088f, 0.05743124f, 
    -0.09641496f, -0.03918206f, 0.10101511f, -0.05762622f, 0.30673179f, 0.15414286f, -0.31645295f, -0.09600703f, 
    0.16253380f, 0.02269971f, -0.04392312f, -0.16473815f, 0.05756719f, -0.06633965f, -0.07987340f, -0.22261848f, 
    0.20162064f, 0.03745173f, 0.06279127f, 0.18243891f, -0.03585625f, 0.07777875f, 0.22181489f, 0.15028450f, 
    0.02362769f, 0.06549257f, 0.01359098f, -0.01516181f, 0.26432714f, 0.11563750f, -0.14129016f, -0.25581750f, 
    -0.06804964f, 0.02199753f, -0.10194108f, 0.01170639f, -0.14801838f, -0.11148673f, 0.00631682f, 0.05355956f, 
    0.18565951f, -0.21492542f, 0.06602945f, -0.13933764f, 0.08501025f, 0.03341930f, 0.02460224f, -0.07697270f, 
    -0.01539674f, -0.01420753f, 0.05927387f, -0.08697074f, -0.13660105f, -0.11574440f, 0.06442129f, -0.07950302f, 
    -0.00750841f, 0.04043048f, -0.00607205f, 0.03901306f, -0.00200060f, -0.15764892f, -0.07470308f, 0.06195751f, 
    0.46606624f, -0.06955650f, -0.20103408f, -0.08789469f, 0.05030060f, 0.03205053f, -0.07060158f, -0.10391276f, 
    -0.04928616f, -0.03879695f, 0.08805673f, -0.04563487f, -0.09291513f, -0.08333780f, -0.06958727f, -0.03469154f, 
    0.26828337f, -0.07295523f, 0.06752948f, -0.12582801f, -0.21294707f, -0.00305823f, 0.00581835f, -0.01566846f, 
    0.33753145f, 0.01000464f, 0.28202653f, 0.08331167f, -0.17833814f, -0.08856738f, -0.08482175f, 0.12558860f, 
    -0.06403749f, -0.02017536f, -0.04463452f, -0.11231095f, 0.26709363f, -0.57327551f, -0.25940078f, 0.10189885f, 
    -0.10937738f, 0.08996032f, -0.14837596f, -0.22326435f, 0.09102883f, 0.01558064f, -0.09577613f, 0.09111957f, 
    -0.45437601f, -0.10327628f, 0.00112282f, 0.05928535f, 0.19108427f, 0.06807948f, -0.04508322f, -0.03639297f, 
    -0.00277524f, -0.02193941f, -0.16265488f, 0.11455745f, 0.58344471f, 0.21985459f, 0.08887395f, -0.03072938f, 
    0.06298468f, 0.13766569f, -0.00175050f, 0.07493561f, -0.09767224f, 0.12145226f, 0.01777005f, -0.04054771f, 
    -0.08029607f, -0.13518119f, 0.08548640f, 0.04074252f, -0.09354956f, -0.17681260f, 0.00627179f, 0.04575027f, 
    -0.01661916f, -0.00550036f, 0.07087445f, 0.03744712f, 0.44467866f, -0.00986506f, -0.05590484f, 0.00247289f, 
    -0.08511040f, 0.01358565f, 0.00951199f, -0.11805034f, 0.09694973f, 0.05862867f, 0.05173685f, -0.01940729f, 
    0.63512689f, -0.34488776f, -0.16613433f, -0.13449362f, -0.16628249f, 0.06193132f, -0.19833529f, 0.06950326f, 
    0.09044735f, -0.09301984f, 0.10123301f, -0.13810241f, 0.06820171f, -0.02971545f, -0.13797556f, 0.19660610f, 
    -0.07251278f, 0.10344430f, -0.12337013f, -0.05087506f, -0.01843678f, -0.04673398f, -0.00017518f, 0.05797904f, 
    0.14308186f, -0.16489823f, 0.14993373f, -0.03689965f, -0.14147021f, 0.07588467f, -0.03458529f, 0.06799823f, 
    0.05304722f, 0.02109153f, 0.01736738f, -0.12069385f, -0.38137397f, 0.01973591f, 0.06195239f, 0.04882777f, 
    0.11213624f, 0.02795739f, 0.07237187f, -0.10171679f, -0.00937425f, -0.26559290f, -0.06344133f, -0.01123798f, 
    -0.07714403f, -0.04461180f, -0.20899920f, 0.03497706f, 0.17310233f, 0.06443803f, -0.13431025f, -0.09833815f, 
    0.10858476f, 0.02693418f, -0.00782416f, 0.01210122f, 0.23446684f, -0.12670080f, 0.01581556f, -0.30521581f, 
    -0.00382651f, -0.05473530f, 0.20836608f, -0.20327663f, -0.01140846f, 0.02132385f, 0.12342019f, -0.02071600f, 
    -0.09393223f, 0.09716789f, -0.23920071f, -0.07316478f, -0.02400937f, 0.11987345f, 0.08000657f, -0.08750224f, 
    -0.06110762f, -0.09387296f, -0.07953319f, -0.00561667f, 0.55456793f, 0.06996729f, -0.58234268f, -0.04296190f, 
    -0.02504009f, 0.20325407f, 0.16095656f, -0.03673796f, -0.09497311f, -0.03334297f, -0.02052498f, 0.10456845f, 
    -0.36494735f, -0.05857015f, -0.40840256f, -0.44021374f, 0.14156875f, 0.02689929f, -0.03125342f, -0.18264881f, 
    -0.01865867f, 0.08298533f, -0.01798142f, 0.11010940f, -0.26453558f, -0.13095801f, -0.08876318f, -0.08239634f, 
    -0.01174789f, -0.04281261f, 0.00409822f, 0.00569080f, -0.18225634f, -0.04659344f, -0.03973759f, -0.05553674f, 
    0.00416323f, 0.11892121f, -0.19196856f, 0.01574838f, 0.06571652f, 0.03059895f, -0.05516796f, -0.02285403f, 
    -0.20319386f, -0.03245800f, -0.03289156f, -0.17159320f, -0.43300495f, -0.20636676f, 0.16358134f, -0.35361496f, 
    -0.01735905f, -0.01036843f, 0.12468403f, -0.00176900f, -0.06028148f, -0.02796534f, -0.08331990f, -0.07638851f, 
    -0.24027221f, -0.35376644f, -0.21649621f, 0.17202725f, -0.02483191f, 0.10482828f, -0.04111400f, -0.12392219f, 
    -0.07102693f, -0.03348891f, 0.00819664f, 0.05891084f, -0.08989490f, -0.02217205f, -0.37640694f, -0.07113001f, 
    -0.08762031f, -0.29827309f, 0.07170302f, -0.16613677f, -0.19119522f, -0.11217849f, 0.02132348f, 0.04532379f, 
    0.02527237f, -0.15023738f, -0.11558499f, -0.12014586f, -0.18597087f, -0.21891491f, 0.12035091f, 0.01339000f, 
    -0.08269031f, 0.10695253f, 0.03655152f, 0.13535565f, 0.36534414f, 0.45405787f, 0.10177158f, 0.16662882f, 
    0.00985337f, 0.07357452f, -0.23543987f, -0.07001841f, -0.05181956f, -0.01266760f, 0.03913340f, 0.07392983f, 
    -0.14943297f, -0.10761709f, 0.20289004f, 0.06094600f, -0.08396444f, 0.03117642f, 0.08943315f, 0.00359288f, 
    -0.08278570f, 0.12505555f, 0.06153609f, 0.07098553f, 0.22244459f, 0.05158191f, -0.01229149f, 0.04110381f, 
    -0.15693957f, -0.00538635f, -0.14687501f, 0.10004099f, 0.00716699f, -0.03385289f, 0.04900666f, 0.01943785f, 
    -0.47320440f, 0.22687118f, 0.01607368f, -0.20734127f, -0.04213531f, 0.04691486f, -0.22774357f, -0.05603341f, 
    0.12043077f, -0.19274038f, -0.22198504f, 0.04665723f, -0.14621098f, 0.44968721f, 0.15248561f, 0.17311344f, 
    0.11427756f, 0.13064960f, 0.05872644f, 0.05426141f, -0.08300409f, 0.04538314f, 0.02885747f, -0.20019729f, 
    -0.31919211f, -0.00776255f, -0.09041316f, -0.10480367f, -0.11974373f, -0.08035371f, -0.06675336f, -0.13103400f, 
    -0.04751113f, 0.01445894f, 0.12429438f, -0.05528176f, 0.18201144f, 0.30474564f, 0.01673412f, -0.15016180f, 
    -0.11642912f, 0.02192981f, -0.07206471f, 0.04801301f, -0.05309254f, -0.10665803f, -0.08704916f, -0.02104946f, 
    -0.24594067f, -0.25868878f, -0.23244503f, -0.05291678f, -0.07605903f, -0.11178826f, 0.06099036f, -0.01479645f, 
    0.10043068f, 0.04136176f, -0.01582732f, 0.07128864f, 0.13231325f, 0.06808185f, -0.04009186f, 0.08734135f, 
    0.06910492f, 0.01982016f, 0.14953737f, -0.17002954f, -0.00514493f, -0.18898655f, 0.18734825f, -0.00047942f, 
    -0.39122334f, 0.00104231f, 0.20228226f, 0.08521899f, 0.15041259f, 0.13925226f, 0.08766598f, -0.04707562f, 
    -0.03062936f, 0.03678168f, -0.07604041f, -0.11144484f, -0.40211949f, -0.47781795f, -0.07486651f, 0.03248670f, 
    -0.14787734f, -0.12782066f, 0.14022569f, 0.06018770f, -0.07512946f, -0.00172130f, 0.06955436f, -0.06644865f, 
    -0.09429449f, 0.06566168f, -0.20948562f, -0.20625326f, -0.02665810f, -0.23228411f, -0.02387241f, -0.01405279f, 
    0.07329872f, -0.08779710f, -0.09329583f, 0.00903469f, 0.07003192f, 0.21705647f, 0.12067164f, 0.25926682f, 
    -0.01533844f, -0.11994245f, -0.14105195f, -0.17979854f, 0.00746032f, 0.18509632f, 0.02652793f, -0.03443374f, 
    -0.14001063f, -0.57812929f, 0.14876322f, 0.31757843f, -0.02771973f, 0.03968292f, 0.12872757f, -0.06232701f, 
    0.01734510f, -0.20146486f, -0.06702734f, 0.09836081f, -0.09781811f, 0.17902665f, 0.23613712f, -0.28330550f, 
    -0.02294094f, -0.01721514f, -0.08024502f, 0.14376198f, -0.01393114f, -0.15002351f, -0.09189600f, -0.10577460f, 
    0.03491635f, -0.18053755f, 0.03918945f, 0.04924504f, 0.01134154f, 0.04883578f, -0.08496038f, 0.11672893f, 
    -0.00276420f, 0.12329976f, 0.01963098f, 0.17489114f, -0.40454310f, 0.00207391f, -0.16121899f, -0.25909644f, 
    -0.00870502f, -0.16940707f, 0.03253160f, 0.08426874f, 0.05741072f, -0.04841263f, 0.03562056f, 0.00009070f, 
    0.05254878f, 0.15809596f, -0.02535811f, 0.15749377f, -0.20347640f, -0.10320926f, 0.06347697f, 0.04598777f, 
    -0.13769130f, -0.12163913f, -0.03978959f, -0.01680756f, -0.38709629f, 0.27914792f, -0.10963339f, -0.11604939f, 
    -0.04117418f, -0.16398826f, 0.13186419f, 0.01331659f, -0.03513870f, 0.05622508f, -0.12124780f, -0.04425936f, 
    0.09090593f, -0.11484477f, 0.00207563f, -0.08496559f, -0.07038622f, 0.09516017f, 0.07081453f, -0.03858718f, 
    -0.02533497f, -0.00316173f, -0.08675239f, 0.03690442f, -0.25038338f, -0.01659889f, -0.20232438f, -0.07360515f, 
    -0.24726225f, 0.14781387f, -0.02962027f, -0.08478194f, 0.04935270f, -0.11817730f, 0.14363612f, -0.11221586f, 
    -0.78504479f, -0.62449187f, 0.04554910f, 0.07161439f, -0.14725055f, 0.03860350f, -0.07635026f, 0.08896247f, 
    -0.01934271f, -0.16059649f, 0.20747276f, -0.13160931f, 0.20100619f, 0.23236533f, 0.04567807f, 0.00084692f, 
    -0.19977057f, -0.03021677f, -0.05820298f, 0.06205364f, 0.00126694f, 0.06145315f, -0.11822829f, 0.05393413f, 
    -0.26742056f, -0.16473846f, -0.17504773f, 0.23570621f, 0.02708722f, 0.06696350f, 0.01101991f, 0.17929579f, 
    -0.09002642f, 0.01168059f, -0.06429288f, -0.09265503f, -0.26449087f, 0.28460541f, 0.41713578f, -0.00897043f, 
    -0.05811881f, 0.09265894f, 0.11011551f, 0.08275997f, 0.06353516f, 0.04834257f, 0.00003384f, 0.15748177f, 
    0.65095657f, 0.30687171f, 0.04422062f, -0.11167185f, -0.03053423f, 0.02575097f, -0.14871366f, 0.06838340f, 
    -0.09322067f, 0.05152628f, -0.02987715f, -0.05573568f, 0.27731687f, -0.17323683f, 0.26318333f, 0.04076914f, 
    -0.02578482f, 0.05615438f, 0.14768516f, 0.06154880f, 0.11494082f, 0.07879725f, 0.06429466f, 0.17199488f, 
    0.17796333f, -0.08361439f, 0.12039275f, 0.26718247f, 0.16159442f, 0.18136173f, -0.05571020f, -0.07938986f, 
    -0.01124544f, 0.00790988f, -0.02258530f, -0.13678493f, 0.13025415f, 0.13950184f, -0.00745516f, 0.09412774f, 
    0.01043254f, 0.13332269f, -0.06185062f, -0.06284356f, -0.05288266f, -0.02912123f, -0.03367705f, -0.01017661f, 
    0.12678459f, -0.04120482f, -0.04267517f, -0.00284090f, 0.02879829f, 0.07134447f, -0.03587842f, 0.03406144f, 
    0.11028479f, -0.05021268f, -0.02176562f, -0.04328526f, -0.81028074f, 0.26509818f, -0.00826706f, 0.20415036f, 
    0.06216809f, -0.21302617f, 0.11733047f, -0.17633013f, -0.02224408f, 0.07418516f, -0.07896781f, 0.12450511f, 
    -0.49732465f, -0.10157922f, 0.09300395f, 0.19659029f, 0.13738967f, -0.13357235f, -0.01346150f, 0.18736616f, 
    0.03801803f, 0.00285326f, 0.02120139f, 0.02437897f, -0.30639645f, -0.05034615f, -0.28720570f, 0.12315410f, 
    -0.12705371f, 0.11775079f, -0.09424838f, -0.03884180f, -0.23279522f, -0.06720232f, -0.01946761f, 0.08922184f, 
    0.36079764f, -0.27919394f, -0.06856161f, -0.15639073f, -0.03187899f, -0.07947560f, 0.06542989f, 0.02415765f, 
    0.04667860f, -0.05475612f, 0.10833976f, 0.17582369f, 0.07475667f, 0.05052629f, -0.11440130f, -0.05486517f, 
    0.14753868f, 0.05925234f, -0.00136785f, 0.23882200f, 0.14665222f, -0.08700949f, 0.02385142f, 0.02836399f, 
    -0.27847776f, 0.10495912f, 0.15352479f, 0.05441355f, 0.09481811f, 0.02727577f, 0.14832990f, -0.06267904f, 
    0.03769961f, 0.10466494f, 0.09064191f, 0.03047518f, -0.58974552f, -0.06185982f, 0.27082062f, 0.07826997f, 
    -0.22817907f, -0.10205796f, 0.06511971f, -0.17516202f, 0.03851153f, -0.07807861f, -0.03592655f, -0.03196343f, 
    -0.41133866f, -0.14396387f, 0.09435078f, 0.32359049f, -0.03112871f, -0.01583096f, 0.04535867f, 0.11113728f, 
    -0.12572573f, -0.06833599f, 0.10448194f, -0.00395100f, 0.27821863f, -0.19926745f, -0.15317769f, -0.37712222f, 
    0.03691423f, 0.08787464f, 0.10500010f, 0.00398606f, -0.03186202f, -0.19670205f, -0.21702665f, -0.11061811f, 
    -0.19512469f, 0.18744072f, -0.27097914f, 0.08880258f, 0.01800414f, 0.08423147f, -0.15627062f, 0.26589814f, 
    -0.09392295f, 0.19976680f, 0.09389660f, 0.01250693f, 0.01970788f, -0.03418013f, -0.19807850f, -0.29051223f, 
    -0.04816166f, -0.03773037f, 0.01314778f, -0.05918670f, -0.14366698f, -0.16634008f, 0.04660272f, 0.07067522f, 
    -0.28534439f, -0.08516505f, 0.10230941f, 0.20577432f, 0.07778972f, -0.11029243f, -0.07794371f, -0.08163720f, 
    0.06912837f, 0.03786430f, -0.01889361f, -0.10100386f, -0.26046532f, -0.03237723f, -0.09332270f, -0.17433442f, 
    -0.11098622f, 0.03560139f, -0.02668235f, 0.04267039f, 0.16058953f, -0.08609112f, -0.04943607f, -0.08059739f, 
    -0.36030975f, 0.05284050f, -0.02002723f, 0.23988134f, 0.01111654f, 0.00141780f, 0.17325372f, 0.09322776f, 
    0.01220499f, 0.00450998f, 0.14827940f, 0.05333596f, 0.25396094f, 0.02507683f, -0.01022200f, 0.24070327f, 
    -0.13967519f, -0.04023023f, 0.10169816f, -0.05784356f, 0.00832765f, 0.16052620f, 0.10776801f, -0.12875053f, 
    0.13591577f, 0.38460067f, -0.01232677f, -0.04851047f, 0.04048091f, -0.08683608f, 0.06009939f, 0.22003593f, 
    0.03971180f, 0.02819666f, -0.01131086f, 0.03413875f, 0.23448206f, 0.08001233f, 0.07401559f, 0.13041912f, 
    0.08471119f, -0.06078760f, -0.00441380f, 0.10657882f, 0.01042399f, 0.17569681f, -0.12540074f, 0.04295187f, 
    0.08056245f, -0.33633566f, 0.07025016f, 0.04674771f, -0.09915321f, 0.00863227f, 0.07701312f, -0.06251713f, 
    0.17451853f, -0.03782696f, -0.04671218f, -0.09210448f, 0.15326259f, 0.39111325f, -0.37441686f, 0.02867945f, 
    0.06175735f, 0.00581994f, 0.13136488f, 0.11057787f, -0.04225548f, -0.05266613f, 0.15746616f, 0.04959638f, 
    -0.61689627f, 0.12726189f, -0.11663777f, -0.13811406f, 0.08173767f, -0.11494511f, -0.06644041f, 0.12303859f, 
    -0.09560428f, -0.20230676f, 0.17198381f, -0.01781737f, -0.21032482f, -0.08091079f, -0.09335823f, 0.08113900f, 
    -0.14369231f, 0.06222326f, 0.10159228f, -0.08310690f, -0.10428208f, -0.04023067f, -0.08278330f, 0.08470700f, 
    -0.94879383f, 0.28041369f, -0.17656596f, -0.20960550f, 0.07875045f, -0.08401879f, 0.04619902f, 0.11974659f, 
    -0.07743946f, 0.02988909f, -0.00442804f, -0.04261568f, -0.15406656f, -0.01935276f, -0.30423197f, 0.03496541f, 
    0.02823960f, -0.18440601f, 0.04868816f, -0.29640883f, 0.14868988f, -0.16935161f, 0.02369621f, -0.12060736f, 
    0.01469433f, 0.25618973f, 0.20866531f, 0.00756581f, 0.01039636f, -0.00919475f, -0.05598100f, 0.07976790f, 
    0.01864491f, -0.05441691f, 0.11412435f, -0.07157762f, -0.16105723f, -0.38247088f, 0.13186218f, 0.12464593f, 
    -0.07540695f, -0.09645782f, 0.08271816f, 0.12158902f, 0.02267549f, -0.09455986f, -0.01913342f, -0.00002735f, 
    -0.04899685f, -0.42599627f, 0.12792152f, -0.19779359f, -0.13333632f, 0.08562181f, -0.04987366f, 0.04177993f, 
    -0.02800344f, -0.03012619f, -0.10766787f, -0.19021618f, 0.30412814f, 0.27011907f, -0.00174153f, -0.10841487f, 
    -0.09929912f, -0.02688698f, 0.04931522f, 0.03157654f, 0.00288502f, 0.00609512f, -0.14935862f, 0.05705896f, 
    0.21875070f, 0.13960949f, 0.11583579f, -0.32116425f, -0.01390062f, 0.01142967f, 0.14937501f, 0.05140411f, 
    -0.02250321f, -0.00350907f, 0.07861279f, 0.05696645f, 0.15099595f, 0.24753892f, 0.08354435f, -0.18998013f, 
    0.07739301f, 0.04571038f, 0.10956547f, 0.00138447f, -0.13675651f, 0.14247780f, 0.07388446f, 0.09007002f, 
    -0.33761382f, 0.04537008f, 0.39517730f, 0.08234248f, 0.08582829f, -0.04707395f, -0.11640996f, -0.05281365f, 
    0.17158614f, -0.07580471f, -0.07703233f, -0.05213466f, 0.01079581f, -0.05078003f, 0.15279573f, 0.23557313f, 
    0.04622521f, 0.08738521f, 0.06392579f, 0.04601569f, 0.15823537f, -0.14841604f, 0.00164123f, 0.12799749f, 
    -0.01379297f, 0.02380016f, -0.00105640f, -0.29652229f, 0.04727625f, 0.02087946f, -0.04265615f, -0.04683829f, 
    0.05131283f, 0.09812103f, 0.10074955f, 0.20943625f, -0.35508916f, 0.16596478f, -0.02513544f, -0.15739235f, 
    0.07978695f, 0.10690649f, -0.05940971f, 0.01303805f, -0.00792091f, -0.11527605f, 0.15056369f, -0.17991006f, 
    0.01308125f, -0.13535996f, -0.49557424f, 0.03428950f, 0.18644080f, 0.19320136f, -0.18399699f, -0.07382406f, 
    0.10026121f, 0.06234027f, 0.14928298f, -0.13870524f, -0.23847434f, -0.22750120f, 0.13721649f, 0.20235844f, 
    0.12452891f, 0.00177272f, 0.02066765f, 0.16260053f, 0.07249437f, -0.02531707f, -0.08486260f, -0.15821831f, 
    0.17809494f, 0.26033509f, 0.12101947f, -0.09161214f, 0.12118513f, 0.09628500f, -0.02508745f, -0.18969376f, 
    0.17705718f, -0.13934362f, -0.03946944f, -0.30654258f, -0.27951810f, -0.12686549f, -0.26127547f, 0.05720839f, 
    0.08979287f, 0.13063985f, -0.11378025f, 0.08582525f, -0.17602487f, 0.19052549f, 0.14719419f, 0.03332613f, 
    -0.50508332f, -0.30305070f, -0.10252923f, 0.02943534f, 0.13747074f, -0.14961170f, -0.00174958f, -0.13579364f, 
    0.07992824f, -0.20732629f, -0.02406667f, 0.11388253f, 0.23554349f, 0.05459937f, 0.10871914f, 0.20744814f, 
    -0.10979276f, -0.17215207f, 0.06318357f, 0.11375506f, -0.24384160f, 0.01928956f, -0.11381721f, 0.28888386f, 
    0.42165670f, 0.14630300f, 0.00604162f, -0.35241476f, -0.02066810f, -0.08987970f, -0.32751456f, -0.11862710f, 
    -0.06145553f, 0.09096365f, -0.10109053f, -0.13636008f, -0.47532335f, -0.12348316f, -0.03327711f, 0.17194372f, 
    -0.14296736f, -0.06247849f, -0.01888738f, 0.12537113f, -0.04271179f, 0.02969930f, 0.14906321f, -0.03312309f, 
    0.01303124f, 0.11369488f, 0.16359776f, 0.11445075f, 0.14795552f, -0.18478075f, 0.07302006f, -0.05685107f, 
    -0.10641561f, -0.01589548f, -0.36835250f, -0.12309310f, -0.30569300f, 0.16795266f, 0.09138007f, -0.39061114f, 
    -0.04497652f, 0.09504616f, 0.02554424f, 0.15237094f, 0.23656181f, 0.24348328f, -0.03826387f, -0.07383189f, 
    0.10006835f, 0.09611680f, 0.29954726f, -0.40395147f, -0.01664444f, -0.01862855f, -0.02348771f, 0.05259947f, 
    -0.10394400f, -0.01528775f, -0.01276799f, 0.07700756f, 0.20219654f, 0.06569958f, 0.31666198f, 0.19178493f, 
    -0.00747227f, 0.15779464f, 0.06828615f, -0.11445108f, -0.05490755f, -0.04624980f, 0.04382072f, 0.23359348f, 
    -0.62281156f, -0.14554465f, -0.21429566f, -0.09262598f, 0.01166731f, 0.16765684f, 0.02527877f, -0.24938375f, 
    0.04675996f, -0.08223719f, 0.10474047f, -0.14239885f, -0.24111582f, -0.02685816f, 0.02403601f, -0.21146283f, 
    0.20804687f, 0.23062766f, 0.05963537f, 0.26516566f, -0.13168861f, -0.13923663f, -0.00002745f, -0.27804786f, 
    0.07206302f, -0.00604119f, 0.14895763f, 0.03895422f, 0.03857340f, 0.04277123f, 0.07369842f, -0.13342696f, 
    -0.02435947f, -0.06589415f, 0.11960419f, 0.15829560f, 0.07244776f, -0.36972195f, -0.15605171f, -0.10502894f, 
    -0.08495335f, -0.05514884f, -0.00407119f, -0.13469656f, -0.09018018f, -0.11055525f, 0.05771686f, 0.00161606f, 
    -0.16355367f, -0.02988039f, -0.03554222f, -0.04998055f, -0.01307323f, 0.00939411f, -0.05019970f, 0.00912802f, 
    -0.06898271f, 0.08665016f, -0.07663242f, 0.03587499f, -0.34032792f, -0.12551260f, 0.24167873f, -0.03176105f, 
    0.03964780f, -0.04207930f, 0.05129483f, -0.09337408f, 0.16504140f, -0.03565846f, -0.13106483f, -0.05328805f, 
    -0.50333291f, 0.12785764f, -0.18113536f, -0.37675047f, 0.20058048f, 0.10888141f, 0.16481006f, -0.13762400f, 
    0.10042053f, 0.10403565f, -0.14838031f, 0.13162683f, -0.19533195f, 0.10571647f, -0.05372818f, -0.13850236f, 
    -0.11765618f, 0.03912960f, 0.12074330f, -0.19502415f, 0.07404086f, -0.16802517f, -0.01283609f, -0.09186919f, 
    -0.45165706f, 0.39684108f, 0.13467081f, -0.19891724f, 0.14034879f, 0.02386488f, -0.05024092f, -0.04428276f, 
    -0.15016700f, -0.13191792f, 0.00125593f, -0.12833823f, 0.01031429f, 0.08050279f, 0.26274312f, -0.08993363f, 
    -0.06103271f, -0.16378014f, 0.00304039f, 0.09287791f, 0.13562548f, 0.18110615f, -0.11703641f, 0.20386457f, 
    -0.01369144f, 0.14478163f, 0.07654908f, 0.09940530f, -0.10954144f, 0.08397917f, -0.01454706f, 0.03396481f, 
    0.12959492f, 0.11103301f, -0.08811903f, 0.03964669f, 0.17823905f, -0.03162833f, -0.12067945f, 0.05446665f, 
    -0.10276710f, 0.08846818f, -0.07903952f, -0.06215279f, -0.03165154f, -0.20857149f, 0.08672822f, -0.04711442f, 
    0.02791612f, 0.04940566f, -0.00444603f, 0.00636630f, -0.14584528f, 0.03002272f, -0.04308705f, 0.08007918f, 
    0.17169981f, 0.05672536f, 0.08705377f, 0.15297222f, -0.03883418f, -0.22996973f, -0.20736802f, 0.33576706f, 
    0.08083802f, -0.18960716f, -0.13334201f, 0.11409235f, 0.11749279f, 0.06421107f, -0.02269141f, -0.01215668f, 
    -0.20532446f, -0.17942201f, 0.41011474f, 0.57500744f, -0.15358120f, -0.05558232f, -0.03397109f, -0.02220698f, 
    0.06811256f, -0.10499186f, 0.07509404f, 0.02099453f, 0.12890255f, 0.01984445f, 0.04014959f, -0.18450381f, 
    -0.12910242f, -0.01233141f, -0.19660816f, 0.20203756f, -0.01009712f, -0.02638455f, 0.11275310f, -0.08438879f, 
    -0.06520461f, -0.04306880f, -0.10931909f, 0.07640074f, -0.26448432f, 0.07349604f, 0.07777717f, 0.06991433f, 
    -0.04700734f, -0.07039930f, 0.11048896f, 0.31756759f, -0.23136924f, -0.29336566f, 0.00154637f, 0.14281061f, 
    -0.01441986f, -0.13417380f, -0.05781357f, 0.05714871f, 0.02005824f, 0.16200547f, 0.20117930f, 0.21665861f, 
    0.01115657f, 0.41089809f, 0.29684591f, -0.46213022f, -0.17444856f, -0.00633395f, 0.03659257f, 0.12011044f, 
    0.01530553f, -0.02456546f, -0.05059065f, -0.05768591f, -0.25206232f, -0.48676679f, 0.19904274f, -0.14237608f, 
    -0.04911314f, 0.05103468f, -0.10529562f, 0.00411332f, -0.07249539f, 0.03574712f, -0.00884248f, 0.15674996f, 
    -0.20135286f, -0.04272639f, -0.31857327f, -0.45326918f, -0.13837054f, -0.10326230f, 0.03216687f, -0.16546933f, 
    -0.00440559f, 0.08626011f, -0.01238249f, 0.28733078f, 0.21151999f, -0.04225558f, -0.40156060f, 0.05176853f, 
    -0.05934752f, 0.19650039f, -0.04856712f, -0.05838098f, -0.04919734f, 0.03250324f, 0.05766045f, -0.03309241f, 
    -0.07867128f, -0.14007732f, -0.22735246f, -0.24496059f, 0.01810927f, 0.01105413f, -0.00184501f, 0.09206669f, 
    -0.08538680f, 0.02573624f, -0.00753014f, 0.19385299f, 0.09964436f, 0.02745064f, -0.11487157f, -0.46187976f, 
    -0.02976813f, -0.01836967f, 0.10772914f, -0.19379191f, -0.00392450f, 0.03836473f, -0.00762625f, 0.06520052f, 
    -0.13496971f, 0.01561480f, -0.09116247f, 0.05432945f, -0.03624664f, 0.01302249f, 0.14538269f, 0.01929411f, 
    -0.05313361f, -0.03206544f, 0.02344352f, -0.03697657f, 0.14140289f, -0.01723231f, 0.03068673f, -0.13194527f, 
    0.25609490f, 0.22047953f, -0.06102520f, 0.02757864f, -0.08311021f, -0.23240525f, 0.01399253f, 0.10129649f, 
    -0.40185544f, -0.15717845f, -0.20207144f, -0.02629378f, -0.16789334f, 0.17806603f, 0.11827692f, -0.02826787f, 
    0.00750065f, -0.00087220f, 0.00041297f, 0.17191584f, 0.15989752f, -0.06479805f, 0.12391190f, 0.33847064f, 
    -0.06262476f, 0.07403104f, -0.09343985f, -0.16945077f, -0.23656042f, 0.16328612f, -0.10867513f, -0.13495363f, 
    -0.20647565f, 0.04080079f, 0.10318740f, 0.12396863f, -0.13800794f, -0.01998310f, 0.19045618f, 0.24253386f, 
    -0.15038602f, 0.18057275f, 0.20999441f, 0.15456833f, 0.01770017f, -0.15380920f, 0.15262088f, -0.02608243f, 
    0.01902694f, 0.20930599f, 0.02612072f, -0.13970570f, 0.06513008f, -0.12522516f, -0.03029801f, -0.03031630f, 
    0.41444373f, 0.08676659f, -0.22235049f, -0.03308521f, -0.11581419f, 0.11224677f, 0.23613937f, -0.03737115f, 
    0.08827411f, -0.00305573f, 0.00117275f, -0.14687806f, -0.38184464f, 0.23585768f, 0.00402956f, 0.21905683f, 
    -0.08097899f, -0.22294366f, -0.00220694f, 0.05327519f, 0.02709427f, 0.06630746f, 0.00532478f, -0.03421462f, 
    0.09292135f, -0.30010474f, -0.44742444f, -0.24066849f, -0.25039241f, 0.07443480f, -0.17603217f, -0.02156619f, 
    0.07277424f, 0.22489974f, -0.20768170f, 0.19234550f, -0.25471899f, 0.03425419f, 0.03268835f, -0.33794287f, 
    -0.03319594f, -0.25552437f, -0.01286172f, -0.13283262f, -0.04743443f, -0.00152647f, 0.02017068f, 0.02952877f, 
    0.19424909f, 0.02350196f, 0.08559911f, -0.39696509f, -0.23051153f, -0.05124088f, -0.03138427f, 0.00462606f, 
    0.09169919f, -0.02478676f, 0.02204677f, -0.22508462f, -0.02988786f, -0.13982113f, -0.18574990f, 0.49015939f, 
    -0.10283951f, 0.11742091f, 0.17488176f, 0.08727077f, -0.03722149f, -0.01683630f, -0.06720059f, 0.08792639f, 
    -0.41341144f, -0.06226473f, -0.21559137f, 0.32278666f, 0.10792747f, 0.00035364f, -0.07255746f, 0.02309568f, 
    0.14399122f, -0.01617124f, 0.07359193f, -0.28714332f, 0.37477118f, -0.48222798f, -0.03688385f, 0.22872344f, 
    -0.11538404f, -0.06874060f, 0.05635195f, 0.10223821f, -0.00270204f, -0.02469634f, 0.03024426f, -0.05599254f, 
    0.21276312f, -0.34085441f, -0.01477220f, 0.09360050f, -0.03428300f, 0.05671336f, -0.01557025f, 0.11224601f, 
    -0.04748165f, 0.00514821f, 0.10447075f, -0.17766540f, -0.40716878f, -0.19012268f, 0.01704129f, 0.00005005f, 
    0.00419709f, 0.00016934f, -0.06903874f, 0.07557759f, -0.12092903f, 0.06488591f, -0.23628168f, 0.15775606f, 
    0.71009922f, -0.56938922f, 0.21114428f, -0.07232484f, -0.19000500f, -0.03938779f, 0.17682794f, 0.01892842f, 
    0.10725218f, 0.06801648f, 0.03529770f, 0.16935080f, -0.04576162f, -0.22075737f, -0.13825667f, 0.10083161f, 
    0.08613584f, 0.14791612f, 0.06657040f, -0.03293710f, -0.18123944f, -0.03329327f, -0.07651937f, -0.12161393f, 
    0.20025516f, 0.12301498f, 0.14248966f, -0.33362108f, 0.29119244f, -0.09052290f, -0.03282256f, 0.10773213f, 
    -0.05241947f, -0.02817685f, 0.08669318f, -0.00736933f, -0.22807239f, 0.01393177f, -0.24808936f, 0.44001627f, 
    0.11295163f, 0.03155018f, 0.14466864f, -0.03810428f, 0.13781866f, 0.00736764f, -0.10632019f, 0.02840976f, 
    0.05652066f, 0.01322576f, 0.27282038f, -0.08233276f, 0.21099755f, -0.05267655f, 0.11152304f, -0.01963907f, 
    0.05931629f, -0.01327802f, -0.10465295f, -0.27130955f, 0.19485901f, -0.02639062f, 0.03089614f, -0.12076506f, 
    -0.06136904f, -0.03420655f, 0.10040479f, -0.07602124f, -0.02832158f, -0.01711602f, 0.07365885f, 0.08619089f, 
    0.16662842f, -0.33261302f, -0.10202756f, 0.19880216f, 0.02862523f, -0.20390727f, 0.01694375f, 0.13183942f, 
    -0.00543873f, 0.09149882f, -0.27832529f, 0.03343666f, 0.08566161f, -0.24633306f, 0.12550718f, 0.02373211f, 
    0.09322792f, 0.05200504f, 0.29015896f, 0.13231955f, 0.09954862f, 0.10690373f, -0.11166478f, 0.10819367f, 
    0.31804943f, 0.17384003f, 0.04433548f, -0.32498130f, -0.02283541f, -0.04844676f, 0.11333769f, -0.08854257f, 
    0.01032945f, 0.01301503f, -0.03220048f, -0.19861183f, -0.07103565f, -0.06107315f, -0.19551270f, -0.10421066f, 
    0.08561730f, -0.10950471f, -0.05275642f, -0.05288266f, 0.06260247f, -0.26038796f, -0.11830547f, -0.11390755f, 
    -0.52300709f, -0.01663862f, -0.09516443f, -0.15938424f, 0.04256719f, 0.04765734f, -0.08163656f, -0.09675670f, 
    -0.04882605f, -0.06439102f, 0.06943072f, -0.18818402f, 0.04148237f, -0.08416108f, 0.18890312f, 0.00222824f, 
    -0.17541043f, 0.16735733f, -0.03378619f, -0.02299774f, 0.06196941f, 0.10003944f, -0.00946623f, -0.08715647f, 
    0.09345537f, 0.19049363f, 0.22354992f, 0.25911269f, 0.11868627f, 0.09488203f, 0.09845493f, -0.05682164f, 
    -0.06476104f, 0.05943841f, -0.10031071f, -0.02814851f, -0.45786288f, -0.04026249f, 0.07807778f, 0.16921628f, 
    -0.12301415f, -0.07622889f, -0.10262531f, -0.03447490f, -0.05167609f, 0.02452918f, 0.03772129f, -0.03576847f, 
    0.20147669f, 0.11900843f, 0.17535451f, -0.00674658f, -0.00973524f, -0.01882344f, 0.00961857f, -0.11056022f, 
    -0.00477252f, 0.00405982f, -0.01182345f, -0.14902923f, 0.06868684f, 0.21825226f, 0.11157048f, 0.21026558f, 
    0.06410194f, 0.06537448f, 0.13344486f, -0.13725764f, -0.09689996f, -0.03970641f, -0.09486653f, -0.09067226f, 
    0.08825962f, 0.25494307f, 0.20330960f, 0.21598087f, 0.13039625f, -0.05099335f, -0.03469236f, 0.01497272f, 
    0.09391891f, -0.00564377f, -0.00625234f, -0.12655239f, 0.12518705f, -0.63099581f, 0.14442381f, 0.25029042f, 
    -0.17359121f, -0.13631022f, -0.02998142f, -0.00373602f, -0.03283474f, -0.02985093f, 0.02952311f, -0.01117913f, 
    0.19522634f, 0.21528760f, -0.06831538f, -0.03208390f, 0.00987774f, 0.02523595f, 0.02878401f, -0.06424914f, 
    0.00358638f, 0.01865497f, -0.07006837f, 0.03632207f, 0.17030728f, 0.27865720f, 0.07077794f, 0.30977347f, 
    0.09816582f, -0.13302471f, 0.08247995f, 0.00141724f, -0.06066442f, 0.04014746f, -0.00053763f, -0.05535576f, 
    -0.11959309f, -0.04885489f, -0.06236218f, -0.13078704f, 0.03223247f, -0.00325882f, -0.04016667f, -0.06771988f, 
    -0.10902785f, -0.07434407f, -0.13562731f, 0.03632928f, -0.33151981f, 0.13581891f, -0.01528334f, -0.11274397f, 
    -0.10980763f, -0.05494056f, -0.06553746f, -0.02118342f, -0.03148203f, -0.03269218f, -0.08102835f, -0.04042064f, 
    0.24238740f, -0.10721686f, 0.00599290f, -0.15208989f, -0.08127754f, -0.14662524f, -0.11512461f, -0.13167374f, 
    0.02814093f, -0.03323646f, 0.01332484f, -0.16828433f, -0.22698399f, -0.14834867f, -0.07802170f, -0.07610992f, 
    0.08044306f, -0.08981313f, 0.02727654f, -0.02283633f, -0.05589578f, -0.03083157f, 0.01170387f, -0.05296947f, 
    -0.17825630f, 0.23013583f, 0.12136260f, 0.20115021f, 0.16943173f, 0.15568115f, 0.02516437f, -0.01606571f, 
    -0.01271571f, 0.03138873f, 0.05389561f, -0.14396261f, 0.01416895f, -0.18576673f, 0.30153367f, 0.33127916f, 
    0.06077422f, -0.00312901f, -0.09749507f, 0.05992601f, -0.06174939f, -0.12685084f, -0.00887425f, -0.04875694f, 
    -0.27354622f, 0.06923019f, 0.00729127f, -0.04082198f, -0.00993349f, 0.08048539f, -0.00448431f, -0.13983086f, 
    -0.11830567f, 0.04713350f, -0.07328910f, -0.07360186f, 0.02763381f, 0.18713485f, 0.10316569f, 0.08023346f, 
    0.17102744f, -0.07579526f, -0.04854781f, -0.06102087f, 0.16004053f, 0.02024498f, -0.11500663f, -0.03078015f, 
    -0.01409375f, 0.13662919f, -0.01296110f, 0.12590495f, -0.03918806f, -0.02093648f, -0.15920891f, -0.03874684f, 
    -0.01287793f, 0.07729889f, -0.04251189f, -0.04053580f, -0.00897114f, -0.08459538f, 0.05630075f, -0.11911018f, 
    0.04901407f, 0.00029948f, -0.09948318f, -0.07033000f, -0.09284831f, -0.07438400f, -0.00798681f, 0.04526417f, 
    0.03603740f, -0.09895185f, 0.22158034f, -0.26829931f, 0.07253125f, 0.03718439f, -0.05396274f, 0.07770780f, 
    -0.03760161f, 0.08846644f, 0.01883096f, 0.10933997f, -0.05653582f, -0.05051969f, 0.16859911f, 0.13671115f, 
    0.00043591f, -0.03229083f, -0.04647939f, 0.09577577f, -0.03346673f, -0.03985681f, 0.00204321f, 0.03405498f, 
    0.14570245f, -0.24917848f, -0.02496680f, -0.30935502f, -0.10127354f, -0.00292615f, -0.03810627f, 0.03532500f, 
    -0.08392192f, 0.14065936f, -0.05630117f, -0.06600984f, -0.15838650f, 0.02832638f, -0.25374004f, 0.09936319f, 
    0.08920983f, 0.01512392f, -0.02586959f, -0.10702908f, -0.10152958f, -0.03656602f, -0.04179048f, 0.01599981f, 
    -0.07759020f, -0.39292842f, -0.21798807f, 0.03405097f, -0.12282477f, 0.03810526f, -0.03083318f, -0.10129783f, 
    0.01555671f, -0.05835809f, -0.03636259f, 0.04046584f, -0.17137253f, 0.09876512f, -0.20442018f, 0.10903993f, 
    0.06922109f, -0.12061177f, -0.02120017f, 0.05417697f, 0.08474914f, 0.02114535f, 0.04387720f, -0.01880429f, 
    0.11141381f, -0.54804337f, -0.03780157f, 0.17298274f, 0.07710379f, -0.22108527f, -0.04478750f, -0.05720688f, 
    -0.07517540f, 0.02862734f, -0.05513581f, -0.11314794f, 0.35211161f, -0.59254456f, 0.34220096f, 0.13513379f, 
    0.26405489f, -0.08950249f, -0.09086055f, -0.12279531f, -0.04343434f, -0.08641643f, -0.18090004f, -0.05673962f, 
    -0.04803232f, 0.08446345f, 0.16288649f, 0.34312487f, 0.13497204f, -0.16985619f, -0.16968638f, 0.01314011f, 
    -0.01995183f, 0.00282835f, 0.00628378f, -0.04052820f, 0.07885162f, 0.09967495f, 0.22876801f, 0.16527124f, 
    -0.10440319f, -0.07621765f, -0.00196701f, -0.00038340f, -0.06909163f, 0.12368673f, 0.03073516f, -0.12733707f, 
    0.01491616f, 0.04296711f, -0.37517080f, 0.10710867f, -0.07562918f, -0.10709038f, -0.05934062f, -0.08897206f, 
    -0.08278697f, -0.05996817f, -0.11238261f, -0.03842977f, -0.01902889f, 0.08342256f, -0.07643865f, 0.09966435f, 
    -0.10923856f, -0.07956471f, -0.18187481f, -0.06181596f, -0.00662206f, -0.08643974f, -0.02741619f, -0.06480172f, 
    -0.01150262f, -0.10379194f, 0.05771198f, 0.20571876f, 0.31590366f, 0.02274255f, -0.09931439f, -0.11286265f, 
    0.06842302f, 0.08733442f, 0.01057217f, -0.07741100f, 0.01838061f, 0.08229887f, 0.07282385f, 0.10102078f, 
    -0.19224960f, -0.03694845f, 0.03068575f, 0.03059441f, -0.09818341f, 0.03728681f, -0.02675881f, -0.17890684f, 
    -0.38337094f, -0.26824126f, 0.29322740f, -0.14363374f, 0.08206969f, 0.11910685f, -0.14771435f, -0.06159239f, 
    -0.01276695f, -0.08639561f, 0.04838290f, -0.40888157f, -0.15983170f, 0.20903745f, -0.24358867f, -0.06525964f, 
    0.18066776f, -0.07683393f, -0.10469931f, 0.12493921f, 0.16009855f, 0.02691286f, -0.02951663f, 0.06313244f, 
    -0.33114016f, -0.05294428f, -0.03605070f, -0.16264799f, -0.01789106f, -0.16894452f, 0.07338458f, -0.11166716f, 
    -0.06129558f, 0.02538220f, -0.14050026f, -0.06511930f, -0.20550509f, -0.22965914f, 0.16520932f, -0.22926766f, 
    0.08144581f, -0.15570475f, -0.09828925f, 0.00563418f, 0.06454303f, -0.02868470f, -0.01675767f, -0.13273843f, 
    -0.03704713f, 0.00025512f, 0.01639815f, 0.15172276f, -0.01164661f, -0.00547192f, 0.13275056f, 0.06745358f, 
    -0.02819413f, -0.12055643f, 0.02730149f, 0.06459098f, -0.14930829f, -0.05682238f, -0.29818612f, -0.22898088f, 
    0.01135402f, -0.12828860f, 0.02612787f, 0.12072697f, 0.12167087f, 0.15184513f, -0.04579058f, 0.11002543f, 
    0.17316233f, 0.15340433f, -0.07925881f, 0.14836197f, -0.16571636f, 0.11857312f, -0.07531881f, -0.09315718f, 
    -0.18467149f, 0.08137761f, -0.06992216f, -0.03155559f, 0.28304866f, -0.01705539f, 0.06829426f, -0.18682365f, 
    0.13590957f, -0.05795744f, 0.02461349f, -0.04172404f, 0.13095945f, 0.12139554f, 0.19522789f, 0.05988861f, 
    0.07790920f, 0.07088030f, -0.12519719f, 0.00249302f, 0.07683734f, -0.05564714f, -0.12861565f, -0.15982771f, 
    -0.03553528f, 0.00712003f, -0.24922146f, -0.13829139f, 0.19380657f, 0.06372779f, 0.12876596f, 0.01347244f, 
    -0.02399313f, -0.02607179f, 0.08257256f, 0.13113689f, -0.06684219f, 0.00618074f, -0.13269445f, 0.05183235f, 
    -0.32879314f, 0.06441779f, -0.27321091f, -0.17518154f, -0.01145882f, -0.11465754f, 0.09982431f, 0.17088208f, 
    0.08904701f, -0.06982592f, -0.00915175f, 0.06035848f, 0.12763515f, 0.28139722f, -0.24777851f, 0.13592081f, 
    0.07224565f, 0.00875213f, -0.03419264f, -0.07627492f, -0.12720294f, 0.01978104f, 0.03567692f, 0.07946538f, 
    -0.18776828f, -0.09838013f, 0.18358712f, 0.08561568f, -0.13405260f, 0.01367030f, -0.08045328f, -0.08437495f, 
    0.03390596f, 0.05321728f, 0.01394645f, -0.07378745f, -0.40915778f, 0.06545970f, 0.05465678f, 0.05354585f, 
    0.06178322f, -0.13948108f, -0.11188330f, 0.07729375f, 0.04647708f, 0.02509361f, -0.15289016f, 0.08040365f, 
    -0.11874088f, -0.04179729f, 0.13505715f, 0.28320998f, 0.04634317f, -0.03137577f, -0.07146598f, -0.12546226f, 
    0.11120459f, 0.07332509f, 0.25031224f, -0.11246563f, 0.30302459f, 0.19560927f, -0.26933563f, 0.19840056f, 
    0.07877228f, 0.00024058f, 0.04863726f, 0.01719808f, -0.04224965f, -0.15571779f, 0.13580926f, 0.08415248f, 
    -0.13725397f, 0.40747687f, -0.33577177f, -0.13716836f, -0.12080514f, 0.07954072f, 0.06637858f, -0.20725088f, 
    0.05819439f, 0.09221715f, -0.12626895f, -0.01488459f, 0.25333422f, -0.04922301f, -0.00311886f, 0.13316676f, 
    -0.03169676f, -0.08959936f, -0.17077065f, -0.07792644f, 0.08344204f, -0.05928349f, -0.08094437f, -0.19003575f, 
    -0.36030382f, -0.21736941f, 0.16724093f, -0.08573054f, -0.05383809f, -0.17871563f, 0.06501565f, -0.29522249f, 
    0.09544494f, 0.02418549f, -0.19327907f, 0.22480115f, 0.09290341f, 0.05030570f, 0.09222151f, 0.15884922f, 
    -0.08226924f, -0.05599018f, 0.02746485f, -0.21950267f, 0.00809562f, -0.06017998f, -0.08600311f, -0.23972513f, 
    0.02539626f, -0.11292584f, 0.04994083f, 0.17937443f, 0.03839632f, -0.10212497f, 0.04180321f, -0.08311248f, 
    0.06730348f, -0.06659616f, -0.02503660f, 0.10654321f, -0.14835484f, 0.20809835f, -0.16054365f, -0.05969255f, 
    -0.20425062f, -0.09860292f, -0.10302927f, 0.07861623f, 0.04022072f, 0.01765586f, 0.09299427f, 0.11903077f, 
    0.12892960f, -0.07652355f, -0.08944016f, 0.31489408f, 0.12017914f, 0.00718717f, -0.03018327f, -0.11459570f, 
    -0.01029399f, 0.23596926f, -0.20789593f, 0.15010409f, 0.14268374f, 0.23240533f, -0.50167161f, -0.02915786f, 
    0.07084444f, 0.10861909f, -0.41801798f, -0.11665991f, -0.01987715f, -0.02637519f, 0.05617318f, 0.08677477f, 
    0.17683804f, -0.06508841f, -0.03704641f, -0.16361955f, 0.05666687f, -0.06617464f, 0.07114437f, -0.04439016f, 
    0.03440095f, -0.02382013f, 0.00983286f, 0.14179143f, 0.03688896f, 0.00093953f, 0.16192089f, -0.06876200f, 
    0.06561882f, 0.15227839f, -0.23471972f, -0.25986567f, -0.06558150f, 0.00033125f, -0.08301206f, 0.01695959f, 
    -0.27114332f, 0.07882069f, -0.16159515f, -0.41926110f, 0.04725629f, -0.00757249f, -0.19726136f, -0.09979330f, 
    0.07775249f, -0.08919314f, 0.18804985f, -0.04773283f, -0.15523164f, -0.14417344f, -0.10469850f, -0.20348369f, 
    -0.04401975f, -0.14327955f, 0.00196290f, 0.06795584f, 0.11087693f, -0.05239172f, 0.13057421f, 0.02199449f, 
    -0.25961971f, -0.12944523f, -0.25817358f, -0.00480297f, -0.01531704f, 0.10205308f, 0.05761407f, -0.16188796f, 
    -0.01990131f, 0.10497605f, 0.01258846f, 0.07772789f, -0.00690551f, 0.19380109f, -0.10010618f, -0.29505083f, 
    -0.08518501f, -0.02560218f, -0.19986206f, -0.09272864f, 0.04479207f, 0.08263092f, 0.16372362f, 0.03045026f, 
    -0.43257022f, 0.13701899f, -0.11844187f, -0.16334023f, 0.10928468f, -0.07626171f, -0.02662558f, -0.10721988f, 
    -0.06771533f, -0.15014952f, -0.02871003f, -0.14765710f, -0.13177067f, -0.24551532f, -0.06007784f, -0.03228800f, 
    0.21632929f, -0.14599389f, -0.03504086f, -0.10635361f, 0.19701767f, -0.11585369f, -0.06411123f, -0.05899346f, 
    0.00148082f, -0.09612811f, 0.10587440f, 0.04178451f, 0.02452755f, 0.07727315f, 0.04217429f, 0.09633379f, 
    -0.06975389f, 0.11163925f, -0.23600051f, 0.15604347f, -0.22170576f, 0.31445324f, 0.08476438f, -0.29360196f, 
    -0.16703168f, 0.05241627f, 0.05216119f, -0.01705195f, 0.05183828f, 0.06637421f, 0.07294843f, 0.03597396f, 
    0.01754127f, 0.14183970f, -0.30063361f, 0.44054282f, -0.04047671f, -0.06303227f, -0.04342795f, -0.02801580f, 
    -0.18610555f, 0.03570257f, 0.02379542f, 0.15835489f, -0.33651006f, -0.05270543f, -0.09079124f, 0.29567644f, 
    -0.02796455f, 0.01920661f, -0.01503556f, -0.12159631f, 0.10798279f, -0.13211751f, -0.03275281f, 0.05526797f, 
    0.28736529f, -0.63859916f, -0.18839644f, 0.11513206f, -0.02375001f, -0.05400953f, -0.12002943f, 0.10313217f, 
    -0.07462452f, 0.28530860f, -0.07036180f, 0.04537519f, -0.09468591f, -0.19295253f, -0.03624418f, -0.42977560f, 
    -0.07284807f, 0.07471144f, -0.02832808f, -0.06943141f, 0.04390463f, 0.14076713f, 0.13623491f, -0.10781322f, 
    -0.30388182f, 0.24619861f, 0.21193697f, -0.00247818f, 0.10763805f, -0.09861217f, 0.15773632f, 0.12660110f, 
    0.08737630f, 0.09861976f, 0.05375225f, 0.03309153f, -0.46575692f, -0.10406511f, 0.27174479f, 0.24470165f, 
    -0.03144790f, -0.01233319f, -0.02501911f, -0.03993997f, 0.06967921f, -0.12953681f, -0.00520752f, 0.12424701f, 
    0.04385488f, -0.06405317f, 0.06708056f, -0.11328913f, 0.04253062f, 0.01651793f, 0.00029079f, -0.21016982f, 
    0.26993254f, -0.07224398f, 0.20963545f, 0.10084090f, -0.41514274f, 0.44017199f, -0.19331597f, 0.33956909f, 
    0.08693384f, -0.05341956f, -0.07422221f, -0.04548422f, -0.00458735f, -0.11112722f, 0.05785348f, -0.06035965f, 
    -0.36256292f, 0.02171462f, -0.07531688f, -0.28776309f, -0.05661967f, -0.00143672f, -0.11127533f, -0.02720112f, 
    0.03289366f, 0.09569392f, 0.03114486f, -0.05805339f, 0.14781082f, 0.02082908f, 0.04380995f, -0.11757129f, 
    0.22225299f, 0.08561382f, -0.22809048f, -0.19342282f, -0.18442804f, 0.01246135f, 0.05150789f, -0.13100103f, 
    -0.24806218f, -0.28356338f, 0.02113086f, -0.07040739f, 0.11675072f, 0.00776188f, 0.07244596f, 0.00987773f, 
    0.07882946f, 0.11269595f, -0.01418759f, 0.07352072f, 0.35020584f, -0.44116405f, -0.20382768f, 0.14484195f, 
    0.02083084f, 0.12355676f, 0.01175898f, 0.00549449f, -0.00967880f, -0.10140970f, 0.11455676f, 0.12651272f, 
    -0.11610053f, 0.37525037f, -0.48634124f, -0.18397363f, 0.18504758f, -0.08688151f, 0.14911085f, 0.11050667f, 
    -0.15573345f, 0.04416341f, -0.18700480f, 0.00665742f, -0.21064614f, -0.24065946f, 0.28724840f, -0.25732762f, 
    -0.06944527f, -0.14256923f, -0.09069330f, -0.07237487f, 0.11917850f, -0.10996182f, 0.06702191f, -0.04685195f, 
    -0.05102270f, 0.30256885f, -0.08964008f, 0.28110895f, -0.03356756f, -0.04178979f, -0.02283113f, 0.11069548f, 
    -0.01564560f, -0.12942185f, 0.01211717f, 0.12516093f, 0.08195842f, -0.13159372f, -0.07808751f, -0.24809498f, 
    0.10969721f, 0.08956709f, -0.13798819f, -0.10429247f, 0.01618962f, -0.11666244f, 0.07980014f, 0.21289913f, 
    0.39053246f, -0.05755828f, -0.12895478f, 0.33463466f, -0.07156063f, 0.02026685f, 0.13419661f, -0.12914540f, 
    -0.02273632f, -0.04905211f, 0.01629105f, -0.05775257f, 0.52302623f, -0.47848406f, -0.00501136f, 0.12817961f, 
    0.19853944f, -0.00402382f, 0.02144170f, 0.16964315f, -0.02181135f, -0.04506579f, 0.06511324f, -0.04824890f, 
    0.46460792f, -0.00192346f, -0.20155542f, -0.12768260f, 0.19687760f, -0.01339080f, -0.05632769f, -0.08490155f, 
    -0.00115859f, 0.05179743f, 0.12360273f, 0.06605767f, 0.24573147f, 0.34559667f, -0.20402849f, 0.17805092f, 
    0.02296907f, 0.10388693f, 0.09138381f, -0.01141629f, -0.03934224f, -0.02839054f, 0.06822918f, -0.23268670f, 
    -0.25634989f, 0.01057521f, -0.24772665f, -0.18887599f, 0.10637452f, -0.06550576f, 0.01871297f, 0.12041820f, 
    -0.11614633f, -0.22729965f, -0.10386884f, 0.03242943f, -0.15780698f, 0.31004572f, 0.41474873f, -0.10256109f, 
    0.07544334f, 0.09191420f, -0.12797235f, 0.07468053f, -0.05153443f, 0.05334858f, 0.04253282f, -0.06931937f, 
    0.09756973f, 0.23331916f, 0.35975865f, -0.02212164f, 0.03549068f, 0.09224823f, -0.19922239f, 0.03465223f, 
    -0.04525402f, 0.14524540f, 0.02171705f, -0.12371115f, 0.32944471f, -0.65145916f, 0.24982892f, -0.01299809f, 
    -0.02564114f, -0.01575813f, 0.08080786f, 0.11441569f, -0.02124866f, 0.11636103f, 0.12156765f, -0.03512429f, 
    -0.23190534f, -0.40473747f, -0.07889882f, -0.24182779f, -0.01935337f, 0.05375898f, -0.07383001f, 0.08180236f, 
    -0.14190543f, -0.14471927f, -0.03654527f, 0.00980373f, -0.28444627f, 0.25321069f, -0.09983667f, 0.20805821f, 
    0.06941172f, -0.00686070f, 0.03812235f, -0.25313821f, -0.11078286f, 0.00758674f, -0.05698011f, -0.05771795f, 
    -0.01971021f, 0.26027173f, -0.26605636f, -0.38969153f, 0.06016270f, -0.04869793f, 0.01049817f, 0.12648697f, 
    -0.06660509f, 0.03586533f, -0.01547577f, -0.03200832f, -0.08451167f, 0.09527182f, -0.02388581f, -0.15125978f, 
    0.07047558f, 0.09288216f, -0.00632747f, -0.10493059f, -0.03298682f, -0.07342792f, -0.23208907f, -0.08300021f, 
    -0.84664291f, -0.30706117f, -0.16901167f, -0.26256680f, 0.07416952f, -0.08880316f, -0.03323099f, -0.01973662f, 
    -0.08160064f, 0.03816522f, 0.00811458f, 0.09597680f, 0.37606332f, 0.20912345f, -0.11448512f, -0.04388212f, 
    -0.14383806f, 0.06641820f, 0.06766952f, 0.16394022f, 0.02089886f, 0.04631808f, 0.04262753f, -0.08176794f, 
    0.31685528f, 0.16750745f, 0.06199428f, -0.10322498f, -0.25441235f, 0.08507198f, -0.27399570f, -0.04811479f, 
    -0.02466709f, -0.19435048f, 0.00953085f, -0.21116331f, 0.10254853f, -0.11709416f, -0.16234247f, -0.06369074f, 
    0.12196551f, 0.04499082f, 0.08392678f, 0.13777013f, 0.21153608f, 0.05681630f, -0.07746378f, 0.04425806f, 
    0.13954206f, -0.08990575f, -0.07144683f, 0.04512491f, -0.02761377f, -0.07477767f, 0.01271901f, 0.02367681f, 
    -0.05256807f, -0.18962087f, -0.10049394f, -0.21389897f, 0.22797561f, 0.10651714f, -0.13887820f, 0.04452508f, 
    -0.02673549f, 0.03250280f, 0.20659253f, -0.09450284f, 0.08659916f, 0.15619667f, -0.04503055f, -0.12493949f, 
    0.05557800f, -0.00127863f, -0.13774815f, 0.19197963f, -0.09652392f, -0.08184166f, -0.00089218f, -0.06595117f, 
    -0.15465815f, 0.00798457f, 0.02093328f, -0.00136704f, 0.20400855f, 0.18695255f, 0.06605460f, -0.17713358f, 
    0.12161971f, 0.08765413f, -0.01670492f, 0.21288884f, 0.04674819f, 0.08000205f, -0.04697217f, 0.17012505f, 
    -0.24194944f, -0.19699940f, -0.27894026f, -0.10260941f, 0.04473659f, -0.00528523f, 0.06500766f, -0.13053457f, 
    -0.02021974f, -0.21789233f, -0.16647877f, -0.17934886f, 0.06293483f, 0.11056314f, -0.22285210f, 0.01110688f, 
    -0.07629477f, 0.00004980f, 0.11600025f, -0.09427217f, 0.01427141f, 0.21591675f, 0.12580714f, 0.00768689f, 
    -0.29446405f, -0.04227074f, -0.14239705f, -0.12537986f, 0.08333584f, 0.01965095f, -0.24436311f, -0.07763974f, 
    0.06947520f, -0.42258838f, -0.04149167f, -0.13728575f, 0.16073194f, -0.04030108f, -0.00990963f, 0.30013293f, 
    -0.03792711f, -0.03906008f, 0.05923168f, 0.13939856f, 0.13792041f, 0.23412773f, -0.02399484f, -0.00622033f, 
    0.31066036f, 0.22529979f, 0.13523428f, 0.20608985f, -0.02955308f, 0.04289360f, -0.03041573f, 0.12277456f, 
    0.01143385f, -0.07200832f, 0.06291968f, 0.22992806f, -0.71733487f, -0.46363598f, -0.27051526f, -0.25731808f, 
    -0.03513066f, 0.03866711f, -0.11509961f, 0.00539977f, -0.01034239f, 0.00041415f, 0.07076244f, 0.19277439f, 
    0.21275623f, 0.27308100f, -0.10345759f, 0.12686646f, -0.01221692f, -0.19509327f, 0.06335807f, -0.10013124f, 
    -0.04566079f, -0.04527493f, -0.01864464f, 0.02592446f, 0.09054916f, 0.10065368f, 0.11572618f, -0.12226495f, 
    -0.08572258f, 0.06225963f, 0.09731726f, 0.09521171f, 0.04572411f, 0.02487992f, 0.06002785f, 0.13669105f, 
    -0.71885300f, -0.30446276f, -0.15476763f, -0.36801231f, -0.02877709f, -0.12723632f, -0.07986711f, 0.04063775f, 
    0.01043674f, 0.03822193f, 0.12183934f, -0.06444836f, -0.42158073f, -0.03794643f, -0.51799870f, -0.08755134f, 
    -0.02314901f, -0.01409602f, -0.10543080f, 0.06127094f, -0.06022219f, 0.04728711f, 0.06462634f, -0.09995753f, 
    -0.14894930f, -0.20365299f, 0.10954933f, -0.02514078f, 0.00239916f, 0.17489682f, -0.01345806f, -0.12980156f, 
    0.14583579f, -0.00075401f, -0.03824406f, -0.09589890f, -0.16686001f, 0.07546446f, -0.16592720f, -0.32827145f, 
    0.11113239f, 0.03644947f, -0.08685607f, -0.00693732f, 0.15065144f, 0.00080038f, -0.05715531f, 0.02260552f, 
    0.17826964f, -0.05414241f, -0.03336807f, 0.20504718f, -0.10216519f, -0.00555542f, 0.07149673f, 0.04490448f, 
    0.11395878f, 0.04918451f, -0.11895351f, 0.02831547f, 0.19235714f, -0.10468008f, -0.01419120f, 0.01966172f, 
    -0.11630213f, -0.01576862f, -0.04419517f, -0.05378639f, 0.00354155f, 0.19516942f, 0.15096606f, -0.13682333f, 
    0.23525882f, -0.06464308f, 0.05475900f, 0.29534772f, -0.04207790f, -0.24248265f, -0.22547065f, 0.01979727f, 
    -0.08056218f, -0.17934525f, -0.07422313f, -0.04309867f, 0.09309361f, -0.13647974f, 0.19306307f, -0.01746377f, 
    0.20534597f, -0.03420694f, 0.01332663f, 0.22219172f, 0.03250288f, 0.19535843f, 0.10817690f, 0.26990241f, 
    -0.51594907f, 0.18219629f, -0.21677878f, -0.40830857f, -0.00429260f, -0.03577594f, -0.01714009f, 0.02233770f, 
    -0.00025850f, 0.18845074f, -0.11164506f, 0.11718524f, -0.63130271f, -0.33753306f, -0.07969182f, 0.16991661f, 
    0.21260525f, -0.00087006f, -0.01272902f, -0.09037619f, -0.06350230f, -0.08190130f, -0.08751852f, -0.00495152f, 
    -0.51857257f, 0.27531216f, 0.11330315f, 0.07011406f, -0.02083713f, -0.10780358f, 0.03786782f, -0.07951605f, 
    0.02220477f, 0.10450309f, 0.11976071f, 0.15080538f, -0.72090918f, 0.24550587f, -0.31646010f, -0.11368933f, 
    0.18527734f, 0.05459395f, -0.13754570f, 0.01569201f, 0.08350173f, -0.00810732f, -0.00261274f, -0.03835753f, 
    -0.09073494f, 0.05368238f, -0.08071794f, -0.04655595f, -0.02272568f, 0.19577263f, 0.11554469f, -0.05660814f, 
    0.00288129f, 0.11151470f, -0.10817126f, -0.10770124f, -0.53554410f, -0.13014457f, -0.04890107f, -0.18929362f, 
    -0.08597328f, 0.11182846f, -0.15947600f, -0.27743235f, 0.03433479f, -0.11513538f, -0.02349039f, -0.11970975f, 
    0.24875493f, 0.25227275f, 0.08828940f, -0.11663240f, 0.01699278f, 0.01475752f, 0.08947183f, 0.04444154f, 
    0.02095349f, 0.17860536f, 0.11439321f, 0.06100143f, 0.26162818f, 0.07422540f, -0.29552159f, -0.07512701f, 
    0.06155408f, 0.12151163f, 0.07136132f, 0.11199431f, 0.04789566f, 0.11286943f, 0.11626530f, 0.06123710f, 
    0.26746845f, -0.00809199f, -0.30401289f, -0.15730976f, 0.05403913f, -0.02682967f, -0.01226519f, 0.06568634f, 
    0.03925888f, -0.03334458f, -0.00318518f, -0.01988846f, -0.19555153f, -0.14881958f, -0.05639016f, 0.02531745f, 
    -0.05171775f, 0.09338494f, 0.10810428f, 0.11458411f, -0.13134335f, -0.03309491f, -0.11710383f, -0.24022342f, 
    0.01686130f, 0.05479565f, -0.04906606f, 0.02942807f, -0.12514746f, 0.05877770f, -0.06964164f, -0.21207960f, 
    0.09965385f, -0.05113639f, 0.08679316f, -0.11267055f, 0.39927921f, -0.40848696f, -0.19785674f, 0.36664966f, 
    0.11683159f, -0.04327381f, -0.04843845f, 0.03287295f, -0.02524005f, 0.00532068f, -0.07756913f, 0.07502959f, 
    -0.20863694f, -0.00689731f, 0.01645980f, -0.01982280f, -0.01743401f, -0.17088535f, -0.01946964f, -0.07662121f, 
    0.05992555f, 0.03276246f, 0.09748106f, -0.04046476f, 0.14322308f, 0.06518343f, -0.02088302f, 0.10488222f, 
    -0.01371873f, 0.01736743f, -0.13496214f, -0.04251619f, 0.15085551f, -0.18283650f, -0.09025875f, 0.01280890f, 
    -0.07481787f, -0.09098960f, 0.08294708f, 0.03143373f, -0.17562319f, 0.15978558f, -0.02755344f, -0.01096458f, 
    -0.11153530f, 0.15882146f, -0.03190184f, -0.15529759f, 0.46090752f, 0.00865033f, -0.30461287f, 0.44183776f, 
    -0.05525016f, 0.01187366f, 0.03276395f, 0.09951056f, 0.11248992f, 0.00776462f, 0.06305595f, -0.14758436f, 
    0.08728794f, -0.14397606f, -0.23049560f, -0.19552225f, -0.06211876f, -0.04707132f, 0.14892314f, 0.14920747f, 
    0.13461339f, 0.01009333f, 0.03559503f, 0.05001841f, 0.03791404f, -0.17009634f, -0.20749655f, 0.05274609f, 
    -0.06969630f, 0.12594533f, -0.21962582f, -0.10893425f, -0.03211429f, 0.13969655f, -0.18682505f, 0.03815160f, 
    0.04605072f, -0.18125370f, -0.09808303f, -0.19153340f, 0.02956014f, 0.09279320f, 0.00948868f, -0.00511660f, 
    0.12193051f, 0.15283254f, 0.03922644f, 0.04642319f, 0.12671420f, -0.22601889f, 0.25362724f, 0.24850926f, 
    -0.05754431f, 0.03588701f, 0.02010038f, -0.08274304f, -0.01919797f, 0.02308419f, 0.01931850f, 0.08097503f, 
    -0.10462052f, 0.04555769f, -0.18795377f, -0.01952096f, 0.23986354f, 0.00939382f, 0.03039294f, 0.00854554f, 
    -0.14512646f, -0.03979613f, -0.04495142f, -0.04617976f, 0.59174722f, -0.18558747f, -0.37138554f, 0.22385626f, 
    0.01483235f, -0.03648439f, 0.09058733f, -0.01684138f, 0.07411586f, 0.12860934f, -0.09577210f, -0.17981309f, 
    0.34941369f, -0.22025955f, 0.13255341f, -0.03021176f, -0.01002570f, 0.00288602f, 0.04855287f, 0.15161064f, 
    -0.02364512f, -0.18732248f, -0.15930495f, -0.04895293f, -0.26996431f, 0.21169288f, -0.25009659f, -0.02065207f, 
    -0.05198009f, -0.11047178f, 0.13560449f, 0.05924192f, 0.17353703f, -0.01826374f, 0.02896629f, -0.02844040f, 
    0.06873275f, -0.36580244f, -0.01061461f, -0.05530539f, 0.00411010f, 0.05658357f, -0.07775607f, -0.05898470f, 
    0.02883837f, 0.08687633f, -0.09228416f, 0.06239325f, -0.33102521f, -0.04417928f, -0.05916693f, 0.12243119f, 
    0.07905003f, 0.07262619f, -0.23260693f, -0.03965147f, 0.04098545f, -0.03716506f, -0.11402026f, -0.01398437f, 
    0.21503381f, 0.25131223f, 0.10708173f, 0.04397004f, 0.09894168f, -0.12195153f, -0.01465953f, -0.20008989f, 
    -0.12244406f, 0.18208735f, -0.06762391f, 0.19219179f, -0.62924993f, -0.30414146f, -0.00350431f, -0.14369410f, 
    -0.03540572f, 0.01733074f, -0.07469386f, 0.20612799f, -0.10087530f, 0.11448724f, -0.01651391f, 0.06288123f, 
    -0.01771481f, 0.24099797f, 0.15533130f, -0.28998125f, -0.09019455f, -0.27759993f, -0.05985828f, 0.04405674f, 
    0.00092484f, 0.08002221f, 0.08454078f, -0.16356067f, -0.14353101f, 0.09435458f, -0.09128626f, 0.00113286f, 
    0.13928781f, -0.11822567f, 0.02812283f, 0.08802623f, -0.03958650f, -0.09878083f, 0.17691289f, -0.06196167f, 
    -0.66315168f, -0.10712606f, -0.23434170f, -0.09342616f, 0.09579459f, 0.07907350f, 0.09337658f, 0.00640525f, 
    0.03373682f, 0.01410975f, 0.02203742f, 0.24444234f, -0.04951623f, -0.10764874f, 0.10025689f, 0.42700243f, 
    0.11764159f, -0.03774725f, -0.02069751f, -0.06396603f, -0.21779414f, -0.06093461f, -0.24506758f, -0.16443738f, 
    0.52237767f, -0.23998696f, -0.24366273f, -0.22130522f, 0.06995972f, 0.01372671f, 0.02458627f, -0.08840859f, 
    0.03441855f, -0.13809399f, -0.00400776f, -0.11731016f, 0.24381229f, -0.02667052f, -0.09793984f, 0.24855210f, 
    0.01788224f, -0.01147136f, 0.09843045f, -0.03892081f, 0.18848982f, 0.15305579f, 0.03474775f, 0.04032560f, 
    0.63838822f, -0.12996648f, -0.06855895f, 0.07203493f, 0.03428671f, -0.00067609f, -0.05125814f, 0.02134641f, 
    -0.01730822f, -0.08534072f, 0.02202103f, 0.08399926f, -0.47265795f, 0.21845721f, 0.17212990f, 0.02451560f, 
    -0.13387196f, 0.08117057f, -0.18178627f, 0.15912101f, 0.14276873f, 0.01467550f, 0.06207196f, 0.08243758f, 
    -0.14608707f, -0.25294882f, -0.16391376f, 0.33802429f, -0.00856858f, 0.00756265f, 0.02386759f, -0.12187403f, 
    0.08941963f, -0.08555389f, 0.11731490f, 0.07140627f, -0.26920149f, 0.15431812f, -0.15690064f, -0.08917098f, 
    0.12509929f, 0.12451040f, 0.14716801f, -0.28759146f, -0.18191029f, -0.09822161f, -0.22965774f, -0.24881478f, 
    -0.04922482f, -0.16845694f, -0.16693166f, 0.24763051f, 0.17578280f, -0.24337843f, 0.05127031f, 0.06574991f, 
    0.12841611f, 0.02417420f, -0.10895631f, -0.00349884f, 0.15089574f, -0.20185485f, -0.13976502f, 0.16742405f, 
    0.08632244f, -0.08864892f, -0.03888891f, 0.06606758f, 0.04633487f, 0.02108689f, -0.16431797f, -0.11379403f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.06055938f, 0.01527557f, -0.08102558f, -0.01936736f, 0.02380802f, -0.02302638f, -0.04214761f, -0.10927700f, 
    0.00680363f, 0.02903685f, 0.04271530f, 0.05909937f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
