#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.85652363f, -0.03750087f, 0.18675143f, -0.65860426f, -1.03272748f, 0.07492740f, -0.10954888f, 0.02337230f, 
    0.39604476f, -0.15424304f, 0.32812950f, -0.18368728f, -0.11137168f, 0.39666626f, -0.24645163f, -0.26912260f, 
    -0.15129437f, 0.09120916f, -0.09159648f, -0.10368848f, 0.03995693f, 0.15827216f, -0.17746562f, 0.01511528f, 
    -0.35126537f, -0.04006156f, 0.03982770f, 0.07561931f, 0.23773955f, 0.27642986f, 0.19934794f, 0.23807584f, 
    -0.27159786f, -0.12947883f, 0.13827479f, 0.18644130f, -0.30482686f, -0.00138864f, -0.22566375f, -0.27336088f, 
    0.20056967f, -0.22153033f, 0.08006427f, 0.13294609f, 0.18836841f, 0.28224504f, 0.02677874f, -0.49238011f, 
    -0.01057131f, -0.39528883f, 0.15876038f, -0.29805335f, 0.31795660f, 0.35169622f, 0.28736538f, 0.29303551f, 
    0.19528131f, 0.06700712f, -0.21509002f, -0.14835203f, -0.29571345f, -0.01371042f, -0.08158427f, -0.19894153f, 
    -0.16317226f, 0.02451221f, -0.10924221f, 0.20323837f, 0.08378899f, -0.21518201f, -0.37309632f, -0.01974324f, 
    0.23737684f, 0.14638892f, -0.26509744f, -0.25249758f, -0.45440170f, -0.59479213f, -0.05908099f, 0.22474429f, 
    0.31034914f, -0.32592005f, -0.62794787f, -0.51912880f, -0.01213840f, -0.07486615f, -0.36616176f, -0.20917939f, 
    0.42058122f, 0.21209843f, -0.11257580f, 0.14472769f, -0.20495296f, -0.21502435f, -0.53046197f, -0.38053387f, 
    -0.04691925f, 0.05479069f, -0.17095797f, 0.00079616f, -0.60125238f, -0.22586915f, 0.16964783f, 0.11530629f, 
    0.31927645f, -0.03608001f, -0.27755123f, -0.11728439f, 0.08268300f, -0.17041039f, 0.38444683f, 0.01826657f, 
    -0.25833383f, 0.16429345f, -0.24151650f, 0.32300228f, -0.13366081f, -0.25815281f, -0.14353782f, -0.14611076f, 
    -0.14989898f, 0.30100444f, 0.12534066f, 0.32040015f, 0.30067936f, 0.37785324f, 0.07482669f, 0.21663919f, 
    0.00811226f, 0.40179113f, -0.13677406f, -0.33630940f, 0.46285635f, 0.13116495f, 0.05574732f, -0.03021965f, 
    -0.34539700f, -0.09091961f, 0.38831910f, 0.12938412f, 0.00328768f, -0.07973283f, 0.08453369f, 0.00770960f, 
    -0.22006774f, -0.13088118f, -0.15835182f, 0.05183747f, 0.24343304f, 0.31411749f, -0.83002478f, -0.40647179f, 
    -0.17759150f, -0.16615842f, -0.01348634f, -0.43062803f, -0.48712867f, 0.74613786f, 0.30890489f, 0.69701898f, 
    -0.05515323f, -0.27911586f, -0.23189844f, -0.14174323f, 0.50039107f, -0.06237942f, -0.05373964f, -0.01320991f, 
    0.50471449f, 0.11561766f, -0.29076838f, -0.26652145f, 0.09767696f, -0.29821455f, 0.06960531f, -0.41156504f, 
    -0.16762930f, -0.24138796f, -0.21565506f, 0.16964152f, 0.84023219f, -0.45340121f, -0.37884989f, -0.03561839f, 
    0.21304713f, 0.04619241f, -0.11585309f, 0.24983759f, 0.20984247f, -0.19538614f, -0.08615672f, -0.42009884f, 
    0.47966570f, 0.23898247f, -0.10351665f, -0.23018926f, 0.21418372f, -0.15901339f, -0.06585226f, 0.24739838f, 
    0.68222308f, -0.34216529f, 0.37364596f, -0.11713281f, 0.40907997f, 0.22476177f, 0.13563345f, 0.12180427f, 
    -0.28043631f, 0.02828507f, 0.23554638f, -0.19490561f, -0.30290288f, -0.33337557f, 0.26743823f, -0.14781390f, 
    -0.05727600f, 0.20324752f, 0.01254353f, -0.26901573f, -0.23671824f, -0.07771014f, -0.16783342f, -0.37044975f, 
    -0.22818024f, 0.10960530f, -0.67011875f, -0.45060748f, 0.07440042f, 0.01403365f, -0.12880084f, -0.11591110f, 
    -0.47178623f, -0.62550902f, -0.38629612f, 0.15059417f, 0.37242380f, -0.07911897f, -0.18188515f, 0.16844873f, 
    0.02645658f, 0.27248627f, 0.06529720f, 0.27661350f, 0.16733430f, -0.08199365f, -0.35566229f, 0.04454088f, 
    0.44260877f, 0.01342129f, 0.55620158f, 0.80254340f, -0.10091239f, -0.43228006f, 0.51857084f, -0.10615110f, 
    0.25663152f, -0.39520729f, -0.60454857f, -0.55539882f, -0.07665958f, 0.10422204f, -0.14070848f, 0.07318404f, 
    0.28712812f, 0.34454355f, -0.22892646f, 0.18501420f, 0.05916341f, 0.03667337f, -0.00132190f, 0.03216236f, 
    -0.06008387f, 0.04094246f, -0.27148172f, 0.24067825f, 0.27031785f, -0.01632892f, 0.11275978f, -0.06648838f, 
    0.06302077f, 0.05611580f, -0.44501269f, -0.11076280f, 0.03715122f, 0.20485204f, -0.23491563f, -0.01244877f, 
    0.33505073f, -0.19876029f, 0.16284637f, -0.03466290f, 0.25770882f, -0.36256820f, 0.06194419f, -0.17012039f, 
    0.26947251f, 0.30094802f, 0.20678303f, 0.02165668f, -0.21531093f, 0.43095142f, 0.31938794f, -0.42471379f, 
    0.21707198f, 0.08729131f, 0.30228081f, -0.10960158f, -0.32757083f, -0.46163341f, -0.27192041f, 0.38164055f, 
    0.50271833f, -0.16176172f, -0.13395309f, -0.26029494f, -0.06313758f, 0.02037242f, -0.12631245f, 0.29677716f, 
    0.42322326f, 0.21528192f, -0.46856576f, -0.18467003f, -0.12065974f, -1.11722362f, 0.07017871f, 0.18733895f, 
    0.56251264f, 0.52376890f, -0.59832406f, -0.57482576f, 0.21509394f, 0.51634520f, 0.46088868f, 0.22570808f, 
    0.27341661f, 0.06904528f, -0.14995159f, -0.06438131f, 0.07034566f, -0.01774587f, 0.22492802f, -0.40708071f, 
    -0.13456422f, -0.11886059f, -0.22010201f, 0.17057590f, 0.08988477f, -0.05027112f, -0.67915428f, -0.75812256f, 
    -0.52727413f, -0.39245960f, 0.21097893f, 0.00046877f, 0.11013384f, 0.24401508f, 0.51652396f, 0.53854769f, 
    0.18080288f, 0.17290455f, -0.22148935f, 0.03511934f, 0.22109985f, -0.39112151f, 0.08921773f, -0.10251553f, 
    -0.47291687f, -0.10655539f, 0.28810525f, 0.11294743f, -0.15961173f, 0.32033366f, 0.18107629f, -0.21361676f, 
    1.10744441f, 0.64772505f, -0.43355289f, -0.21779740f, -0.56439757f, -0.59149653f, 0.37822121f, 0.37319326f, 
    -0.41874528f, -0.35420293f, -0.27549341f, 0.45287868f, -0.12248000f, -0.17412819f, 0.21747747f, 0.23944376f, 
    0.17922129f, 0.05689630f, -0.23215674f, -0.14481866f, 0.02197691f, -0.09713911f, 0.08933859f, -0.18455222f, 
    -0.09573466f, 0.24819629f, 0.13223146f, 0.11165507f, 0.08969189f, -0.45102859f, -0.01256759f, -0.07677157f, 
    0.39519370f, 0.20496963f, -0.03968904f, 0.14556706f, 0.07549568f, -0.35362276f, -0.12029601f, -0.17730382f, 
    -0.15341067f, -0.26650527f, 0.00238725f, 0.24450357f, 0.15246838f, -0.15585664f, 0.27932966f, 0.10255542f, 
    0.02991935f, -0.73302370f, -0.84215665f, 0.40199864f, 0.21951646f, 0.40208730f, -0.13899523f, 0.15160817f, 
    -0.96153355f, -0.79631931f, -0.40734291f, -0.32126352f, -0.24327110f, -0.23289999f, -0.34084725f, -0.36372009f, 
    -0.37154534f, -0.08194648f, -0.12758835f, 0.23814636f, 0.01859957f, 0.18280345f, -0.01813195f, 0.08451260f, 
    -0.16734473f, -0.15966724f, 0.85336709f, -0.05634446f, 0.08709947f, -0.44479635f, -0.59955597f, -0.19744566f, 
    -0.14620604f, 0.13905199f, 0.05068513f, 0.00975896f, 0.18026121f, -0.17121433f, 0.72550094f, -0.48834670f, 
    -0.28306726f, -0.05085963f, 0.21220310f, -0.20301856f, 0.12935765f, -0.13072939f, 0.07812515f, -0.07152697f, 
    0.08780526f, 0.31714383f, 0.14198765f, -0.24158843f, 0.28787613f, 0.16992696f, -0.79100543f, -0.41729504f, 
    0.04689747f, -0.15481824f, -0.07469761f, -0.18795006f, -0.10867075f, 0.30735078f, 0.47056955f, 0.45586571f, 
    0.08358409f, 0.17695034f, -0.34235880f, -0.29033947f, -0.25111553f, -0.16180271f, 0.25359559f, 0.21338281f, 
    0.32195464f, -0.02430186f, -0.11510552f, -0.11493787f, 0.65944684f, 0.54338145f, 0.31586105f, 0.16796324f, 
    0.27885157f, -0.16609740f, -0.39337319f, -0.32038540f, -0.31651244f, -0.50597274f, -0.03424263f, 0.13815540f, 
    -0.01031517f, -0.06831560f, -0.10412603f, 0.27407533f, -0.15279661f, 0.03592433f, -0.06913201f, -0.09353516f, 
    -0.00561639f, 0.06359573f, -0.07683933f, 0.14891678f, 0.27929518f, 0.83395654f, -0.70647889f, -0.64882553f, 
    -0.09485164f, 0.86943716f, 0.15363751f, 0.47279343f, 0.31366906f, -0.51373655f, -0.66751277f, -0.15235569f, 
    0.05258733f, 0.46956724f, -0.33121794f, -0.02044495f, 0.15748288f, -0.28864309f, 0.15903625f, -0.04711339f, 
    0.21923508f, 0.18818410f, -0.17079107f, -0.09417745f, 0.04634839f, -0.10930342f, -0.62180394f, 0.50170290f, 
    0.30330524f, -1.04594433f, -0.71067959f, -0.02484031f, 0.32751209f, 0.17613293f, 0.17091788f, 0.30545515f, 
    -0.17441195f, -0.08064160f, 0.39004651f, -0.08516391f, -0.13511094f, 0.22607456f, 0.00155344f, -0.06928019f, 
    0.01284928f, 0.17730290f, -0.13968775f, 0.28733638f, -0.21056907f, -0.22849512f, -0.25505450f, -0.90078795f, 
    -0.19599065f, -0.48125088f, -0.78511244f, -0.78727031f, 0.59718937f, -0.01587118f, -0.12638254f, 0.01410861f, 
    0.15321279f, -0.21628614f, -0.47953263f, -0.39575264f, -0.48285475f, -0.39376104f, -0.03800824f, -0.12425289f, 
    -0.25835407f, 0.10143583f, 0.13021007f, -0.09450284f, 0.08989000f, 0.03593552f, -0.07312817f, -0.02195760f, 
    0.21936184f, -0.08585886f, 0.27287456f, 0.16790402f, 0.08108307f, 0.19375238f, 0.10811382f, 0.13301009f, 
    -0.26226249f, 0.05292063f, -0.08421966f, -0.40250751f, 0.73195279f, -0.59484196f, 0.00101668f, 0.07456069f, 
    -0.18519773f, -0.06285228f, -0.05323851f, -0.25689280f, 0.11519948f, -0.12402876f, -0.10151789f, 0.07323616f, 
    0.38120198f, -0.51232409f, 0.19865943f, -0.40617320f, -0.69607502f, -0.48090562f, -0.16229446f, -0.22566912f, 
    0.08225639f, -0.41152680f, -0.44190851f, 0.17768517f, -0.06038576f, 0.05035554f, 0.12071046f, 0.40555999f, 
    -0.02771778f, -0.16374466f, 0.15176608f, -0.10131402f, -0.14352722f, 0.24447657f, 0.21565737f, 0.11431754f, 
    0.08673765f, 0.54289126f, -0.14707321f, -0.37871498f, -0.23896815f, 0.12610772f, -0.15882091f, -0.55229408f, 
    -0.59268653f, -0.16980985f, -0.32493362f, -0.53094065f, 0.43680480f, 0.49529576f, -0.31187099f, 0.29072899f, 
    -0.25015080f, 0.06629161f, -0.01440567f, -0.08470676f, -0.25320289f, -0.12252004f, -0.38270107f, -0.15633236f, 
    0.07372005f, -0.29762709f, -0.24539647f, 0.00554666f, -0.37766069f, -0.46987653f, -0.16888569f, -0.28065684f, 
    0.24252199f, 0.23686434f, 0.05773038f, -0.25988093f, 0.07755434f, -0.17377664f, 0.04114095f, -0.19118854f, 
    -0.22408618f, 0.09941803f, 0.39883634f, 0.03499832f, 0.13570644f, 0.30297324f, -0.15264302f, 0.04907720f, 
    -0.35827520f, -0.15802020f, -0.49182138f, -0.55076313f, 0.59314322f, -0.05889393f, -0.19702290f, 0.55508792f, 
    0.32925013f, -0.31059602f, -0.15726992f, -0.27867112f, -0.26455995f, 0.28671044f, 0.17347030f, -0.02451977f, 
    0.01875853f, -0.08045793f, -0.09472457f, -0.26490566f, 0.07381148f, -0.01100321f, 0.21282549f, 0.04928873f, 
    0.33818525f, -0.19910315f, 0.14834467f, -0.11432334f, -0.43538165f, 0.35013658f, 0.45896512f, 0.26868570f, 
    -0.04796040f, 0.03417784f, 0.05724061f, -0.32091871f, -0.36941653f, -0.11939910f, -0.22207613f, 0.14992757f, 
    0.22706331f, 0.09197272f, 0.43083748f, 0.32675701f, 0.21425329f, -0.15144774f, 0.03240501f, -0.14232759f, 
    0.08406091f, -0.04683552f, 0.10767578f, 0.10110745f, 0.21093832f, 0.42009321f, -0.23820035f, 0.09874357f, 
    -0.05393241f, 0.19831786f, 0.23064017f, -0.35241422f, -0.02168970f, 0.14857799f, 0.11235572f, -0.17637101f, 
    -0.12358466f, 0.04329004f, -0.26495385f, 0.10773900f, 0.31500229f, -0.21200098f, -0.01606483f, -0.26447845f, 
    -0.03103771f, -0.12214936f, -0.00358595f, 0.22258480f, 0.41907978f, 0.13182230f, 0.28192970f, -0.06872642f, 
    0.37851325f, 0.17825188f, -0.40633920f, 0.25876471f, -0.01890281f, -0.08029211f, -0.26209772f, -0.08331183f, 
    0.25238746f, -0.24411030f, -0.13523270f, 0.14883877f, -0.28661779f, 0.26805687f, -0.00455992f, 0.24754934f, 
    -0.15795375f, -0.22781588f, -0.17619476f, -0.26405603f, -0.29759693f, 0.07236978f, -0.16493456f, -0.43288425f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.11950836f, 0.10176173f, -0.09666683f, 0.16404617f, 0.26639622f, 0.14348836f, 0.05831160f, 0.28975919f, 
    0.23441210f, -0.10445654f, -0.02520218f, 0.20117460f, -0.01193515f, 0.19193728f, 0.26316988f, 0.19424348f, 
    0.36273053f, 0.01339117f, 0.04395559f, 0.03387074f, 0.12900092f, 0.17681041f, -0.06723119f, -0.23171201f, 
    0.13317749f, -0.09134265f, 0.14956428f, -0.18048501f, 0.15612836f, -0.18225022f, 0.24620467f, 0.34611413f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.02050407f, 0.01508397f, -0.01070426f, -0.00247218f, -0.04017490f, 0.04222851f, 0.02865507f, 0.00391996f, 
    0.02457585f, -0.04406033f, -0.02066771f, 0.01249760f, 0.04680256f, 0.02479717f, -0.00891088f, 0.03491947f, 
    -0.01969169f, 0.03402472f, 0.02228219f, 0.01021330f, -0.03493634f, 0.00811343f, 0.02719080f, -0.00159087f, 
    -0.03778573f, 0.01533786f, 0.03064709f, -0.01588134f, 0.03974983f, -0.04920932f, -0.02439399f, 0.04871188f, 
    -0.01635697f, -0.02885258f, -0.02989320f, -0.04767810f, 0.02781016f, -0.01276917f, 0.03161286f, -0.04173294f, 
    0.02857127f, -0.00779222f, -0.01127511f, -0.01885951f, -0.04910546f, -0.01414667f, 0.01792942f, -0.04224471f, 
    -0.01481917f, 0.03701797f, -0.04497864f, 0.02834558f, -0.00888713f, 0.04804961f, -0.02616681f, 0.03025306f, 
    -0.03835440f, 0.00571099f, -0.00659205f, 0.04228773f, 0.03711798f, 0.04500391f, -0.03887230f, 0.01797662f, 
    -0.01034187f, -0.02343997f, -0.02045168f, -0.02707398f, 0.02190976f, -0.03190987f, 0.02066706f, 0.01599730f, 
    0.02256669f, -0.00282657f, -0.04505718f, 0.04064158f, 0.02302862f, -0.03784952f, -0.03316560f, 0.00262926f, 
    0.01450366f, 0.02477434f, 0.02912017f, 0.00952341f, 0.05063805f, -0.01300279f, 0.03023756f, 0.00507697f, 
    0.03711827f, 0.00177339f, -0.01847201f, 0.00115366f, 0.04615135f, -0.00733761f, -0.01747981f, -0.03351262f, 
    -0.03507297f, -0.05023977f, 0.02655027f, -0.02676084f, 0.03180749f, 0.01446998f, 0.04489848f, -0.03264876f, 
    -0.01597356f, -0.01903638f, -0.02589259f, -0.05048195f, -0.04068263f, 0.02722074f, 0.02885785f, -0.04027930f, 
    -0.01984439f, -0.03097920f, 0.02148760f, 0.02950405f, -0.01842854f, -0.04072019f, -0.02049112f, 0.02436794f, 
    0.03074220f, -0.02698139f, -0.04522932f, 0.00302046f, 0.04036171f, -0.03870490f, -0.05080119f, 0.00473937f, 
    0.02943856f, 0.03813588f, -0.03043148f, -0.02815235f, -0.03037561f, -0.04078185f, -0.02779702f, -0.02979223f, 
    -0.02839957f, 0.02634134f, -0.01509486f, -0.04750176f, 0.04987098f, -0.00321494f, -0.04462003f, -0.03302081f, 
    0.01934263f, 0.01208012f, 0.03039166f, 0.04164948f, 0.02466307f, 0.00241029f, 0.01842793f, -0.04268400f, 
    0.03672176f, 0.03669761f, 0.00516311f, 0.01455329f, 0.03578676f, -0.02769653f, 0.02201194f, -0.04226560f, 
    -0.01669190f, -0.01217454f, -0.00751583f, 0.01572898f, -0.01545892f, -0.03297166f, -0.04909332f, -0.03169697f, 
    -0.04611840f, -0.00274271f, 0.03794212f, -0.03184089f, 0.00983042f, -0.04743457f, 0.03324176f, -0.03831258f, 
    -0.03338165f, 0.04440973f, -0.03424039f, 0.00466041f, -0.02964468f, -0.00518832f, 0.01615352f, 0.04626760f, 
    0.03205429f, -0.01919729f, 0.01230614f, -0.04432698f, -0.04256443f, 0.00159687f, 0.00350746f, -0.01179620f, 
    -0.04072065f, -0.04917259f, -0.04466679f, -0.03195036f, -0.01364212f, -0.01416380f, -0.04671524f, 0.04103032f, 
    -0.02779742f, 0.03796428f, 0.04463488f, 0.03879458f, -0.03528607f, -0.00094717f, -0.04007242f, -0.03230173f, 
    0.00436026f, -0.02451692f, -0.04548787f, -0.01717265f, -0.02418887f, 0.01513049f, 0.02078750f, -0.02464464f, 
    -0.02170207f, -0.05083890f, 0.02223854f, 0.04293248f, 0.01233498f, 0.03092361f, 0.04477762f, -0.02582257f, 
    -0.01748144f, 0.03591654f, -0.04300007f, -0.02845444f, 0.03044926f, 0.02591668f, 0.00141431f, -0.03589365f, 
    0.01155306f, -0.00916194f, -0.02114615f, 0.04068234f, -0.02723346f, 0.02000323f, 0.00176507f, -0.01449822f, 
    0.04236475f, 0.02935256f, -0.02860643f, -0.01497929f, 0.01226227f, 0.01605325f, 0.04808660f, 0.00484254f, 
    -0.02292559f, -0.00907364f, -0.01311892f, -0.04651777f, -0.01779807f, -0.00573320f, -0.00055604f, 0.01527115f, 
    0.00042725f, -0.01415086f, -0.03944135f, -0.03831085f, 0.01901032f, -0.02316178f, 0.02067123f, -0.02046764f, 
    -0.01360550f, -0.01453457f, -0.01144469f, 0.03685606f, -0.04248691f, -0.01256509f, -0.00981875f, -0.02361221f, 
    -0.03965426f, 0.04274939f, -0.01072538f, -0.00528196f, -0.04868267f, -0.03827704f, 0.01974919f, -0.00878840f, 
    -0.02084442f, -0.03497818f, -0.02868482f, -0.00368040f, 0.04066437f, 0.02250979f, -0.00955556f, -0.04483465f, 
    0.02100017f, -0.03103562f, -0.04302186f, 0.02668316f, 0.00681683f, -0.02829192f, 0.01583551f, -0.04187920f, 
    -0.02020913f, 0.02675001f, 0.04218494f, 0.03111230f, -0.02957122f, -0.00769670f, 0.01550068f, -0.03668074f, 
    0.00057481f, 0.04638920f, 0.03154235f, 0.04404370f, 0.05031665f, 0.04456056f, 0.02983956f, 0.01920769f, 
    0.01143078f, 0.03029574f, 0.04478168f, 0.02177175f, -0.03346103f, 0.03315857f, -0.01898813f, -0.02490812f, 
    -0.02345399f, -0.01754488f, 0.03988169f, 0.01366960f, -0.03931218f, 0.04176293f, 0.02798223f, -0.03665468f, 
    -0.03100674f, -0.00946174f, -0.00090659f, 0.03801389f, 0.02432116f, -0.03070816f, -0.02139017f, -0.00118246f, 
    0.00837787f, -0.04055744f, -0.02458812f, 0.02856733f, -0.02740119f, -0.01077080f, 0.00193246f, -0.02336865f, 
    -0.01337982f, -0.03319418f, 0.04590921f, -0.03287743f, 0.03360454f, -0.00605206f, -0.04625740f, -0.01378592f, 
    -0.04023057f, -0.01780269f, -0.02577931f, 0.04354647f, -0.02748283f, -0.00450338f, -0.01199866f, -0.03906313f, 
    0.04637306f, 0.03588272f, 0.02307726f, -0.02367934f, -0.02429073f, -0.03590721f, -0.01523049f, 0.02503470f, 
    -0.02169214f, -0.03013158f, 0.04046506f, -0.01031032f, -0.02257584f, -0.00931509f, 0.03807533f, -0.00917069f, 
    -0.03299759f, 0.03549975f, 0.03438649f, -0.01533544f, -0.04229413f, -0.00615399f, -0.04959952f, -0.02206363f, 
    -0.23550022f, 0.13847636f, 0.09365018f, -0.10145500f, -0.01472803f, -0.04825189f, 0.02407353f, 0.10932536f, 
    0.11965968f, 0.09168025f, -0.06482147f, 0.11678160f, -0.11610170f, -0.09358091f, -0.10471192f, 0.08185556f, 
    -0.04709302f, 0.09138117f, 0.08157346f, -0.06196881f, -0.06775040f, -0.05051463f, -0.06977545f, 0.05746109f, 
    -0.31671676f, -0.01667105f, -0.02704185f, 0.01099040f, -0.00768545f, -0.03352248f, -0.02073661f, -0.06436154f, 
    -0.02764250f, -0.02302734f, -0.08805459f, 0.05239443f, -0.04901854f, -0.15343873f, -0.16840544f, 0.23710813f, 
    0.06164483f, 0.10242832f, 0.14564021f, 0.00911910f, -0.08135675f, 0.05938736f, 0.12023138f, -0.00155993f, 
    0.05590583f, 0.19373812f, -0.21130195f, 0.05777619f, 0.06417862f, -0.06891926f, 0.01153418f, 0.08583562f, 
    -0.01580471f, 0.11242004f, 0.03182679f, 0.06478114f, -0.22903730f, -0.04640730f, -0.11180430f, -0.00193037f, 
    0.08780628f, -0.01462078f, 0.03158665f, 0.07979045f, 0.01937574f, -0.02120885f, -0.04698524f, -0.00074727f, 
    -0.22730577f, 0.25961709f, 0.10993814f, 0.11081250f, 0.15463397f, 0.09206166f, 0.00837557f, -0.02582740f, 
    0.22288050f, 0.09709219f, 0.07688665f, 0.07206218f, 0.02513224f, 0.10114760f, -0.27092367f, 0.52496946f, 
    0.26788494f, -0.09180722f, 0.11301640f, -0.03177716f, -0.08070557f, -0.00702150f, 0.02788479f, -0.05235542f, 
    -0.17130548f, 0.03212841f, -0.06219023f, -0.00584843f, -0.03919298f, 0.02093623f, -0.05061503f, 0.04360262f, 
    -0.21625313f, 0.18871763f, 0.05049115f, 0.18203288f, -0.04183054f, 0.04762439f, 0.04458512f, 0.28415471f, 
    -0.08173718f, -0.09931048f, -0.06305760f, 0.03879165f, 0.02195540f, -0.07598078f, 0.01087554f, -0.14983638f, 
    0.06085138f, -0.20537886f, 0.08248902f, -0.07080760f, 0.09373569f, 0.15588334f, 0.02594451f, 0.14584722f, 
    -0.10083412f, 0.04152728f, -0.03447772f, 0.05124584f, 0.04064510f, -0.10761151f, -0.07753062f, 0.08333547f, 
    0.12704189f, 0.05317701f, 0.06331271f, -0.01586425f, -0.06529063f, 0.17712970f, -0.03461511f, -0.00583654f, 
    0.02013752f, -0.14803489f, -0.13906261f, -0.27812663f, 0.14651754f, -0.29369304f, 0.07894833f, 0.01219329f, 
    0.05702428f, -0.07042109f, -0.04245643f, -0.03263196f, -0.23357765f, 0.27985030f, -0.18165560f, -0.08241444f, 
    -0.01201858f, 0.03333791f, 0.04897769f, -0.01027013f, 0.08687542f, 0.10718215f, 0.01640464f, 0.25245509f, 
    -0.07971197f, 0.46693271f, 0.15527105f, 0.19676006f, 0.06519508f, 0.16646692f, 0.10478556f, -0.01492042f, 
    -0.09767222f, -0.10580613f, -0.13867907f, 0.09678297f, 0.27777731f, -0.47713307f, 0.24955904f, -0.11625639f, 
    0.03428970f, -0.16145056f, -0.02495817f, 0.00220156f, 0.09779383f, -0.09153581f, -0.13289176f, -0.02909935f, 
    -0.02798651f, -0.00513006f, 0.13980426f, -0.00310464f, 0.01520710f, 0.04874061f, -0.01957645f, 0.06952660f, 
    0.02246583f, -0.05987188f, 0.00757925f, 0.02710329f, -0.16539207f, -0.21371734f, -0.32278216f, 0.08740817f, 
    0.02790834f, 0.04642272f, -0.02344545f, -0.11534044f, 0.06834400f, -0.09678552f, -0.04942403f, 0.05599928f, 
    -0.10578128f, 0.06568028f, 0.14315476f, 0.01572552f, 0.05240531f, 0.07036647f, 0.06648724f, 0.17662725f, 
    -0.14079824f, -0.02032782f, 0.07687896f, -0.06822507f, 0.32377812f, -0.02627045f, 0.05094132f, -0.19448274f, 
    -0.01752785f, 0.02759988f, -0.01046774f, -0.05569168f, -0.02155233f, 0.02428261f, -0.17001982f, -0.05918790f, 
    -0.22744928f, -0.10641225f, 0.04155146f, -0.01494493f, 0.09832729f, 0.20499109f, 0.10453203f, 0.10185720f, 
    0.01229186f, 0.02735738f, -0.01439328f, -0.02239275f, 0.11142958f, -0.10521297f, -0.06265789f, 0.16323568f, 
    0.05438422f, 0.05976833f, -0.24469644f, 0.01484453f, 0.00556701f, -0.08442649f, 0.02613555f, -0.00602060f, 
    0.46279040f, 0.21417379f, 0.40835959f, 0.09668734f, 0.02597841f, -0.11447951f, -0.22262456f, -0.00418021f, 
    0.15147926f, 0.12804742f, 0.09211925f, -0.03314383f, 0.31328642f, 0.07178757f, 0.09592162f, 0.20316102f, 
    0.03682573f, 0.13717040f, -0.12446451f, -0.17275009f, -0.00063650f, 0.10103980f, 0.03094771f, 0.06127972f, 
    -0.18484946f, -0.02045012f, 0.16969842f, 0.10589354f, -0.02140006f, 0.03604997f, -0.00589114f, 0.04097020f, 
    0.04200753f, -0.03659495f, 0.18786211f, -0.01795736f, 0.17953648f, 0.07276170f, 0.26770633f, 0.23370481f, 
    -0.14513323f, -0.05190082f, 0.03899958f, 0.15606719f, -0.06883059f, -0.01886141f, -0.00604106f, -0.13977182f, 
    -0.07211633f, 0.04598697f, -0.06518216f, -0.11697651f, 0.08253507f, 0.05908009f, 0.04952163f, 0.30748588f, 
    0.00523908f, 0.19548433f, -0.04624484f, 0.04565839f, 0.13314641f, 0.07498619f, 0.11967099f, 0.22363123f, 
    0.03738567f, 0.06586474f, -0.12434026f, 0.00075080f, 0.21820836f, 0.24539056f, 0.01092049f, 0.12245061f, 
    -0.24703379f, 0.19151048f, 0.01689076f, 0.29883188f, 0.06516667f, 0.10934859f, 0.00850389f, -0.19983080f, 
    -0.09329007f, -0.02511264f, -0.06624716f, 0.07562386f, 0.07832217f, -0.12460385f, -0.02650706f, 0.01866979f, 
    0.05466747f, -0.05302463f, -0.07257684f, 0.07295725f, 0.09200723f, 0.06958881f, -0.00502538f, -0.04529756f, 
    0.07195567f, -0.03166482f, 0.00420400f, 0.02281908f, 0.18753757f, -0.04885007f, 0.03768058f, 0.01136157f, 
    0.04653830f, -0.05021450f, 0.16935879f, 0.19094327f, 0.01078330f, 0.07893039f, -0.00479634f, 0.06034940f, 
    -0.01567121f, -0.06363913f, 0.07170216f, -0.13864312f, -0.17160535f, 0.20090741f, -0.00061251f, 0.08660112f, 
    -0.02386305f, 0.02833155f, -0.04361285f, 0.02024741f, -0.03925958f, 0.01329349f, 0.01977488f, 0.03019732f, 
    -0.04826455f, 0.02231089f, -0.03614274f, 0.02893263f, 0.01199485f, -0.05507796f, -0.03597392f, -0.03068105f, 
    -0.00339789f, -0.02785891f, -0.04915345f, -0.02454962f, -0.00246873f, 0.01820093f, -0.04216810f, 0.01990306f, 
    0.04856461f, -0.00573086f, -0.01960978f, -0.05101999f, 0.03732725f, 0.01853111f, 0.04161311f, -0.01070159f, 
    0.00085815f, -0.00022109f, 0.01696814f, 0.03890151f, 0.01449322f, -0.02617542f, -0.05185339f, -0.00403248f, 
    -0.00446880f, -0.05374227f, -0.00384749f, 0.01033115f, -0.01187020f, -0.04536531f, -0.04110708f, 0.04197786f, 
    -0.04634630f, 0.00761370f, 0.02743590f, 0.03057253f, 0.03289201f, -0.02710065f, -0.01315680f, -0.01881852f, 
    -0.02098492f, 0.02165747f, -0.03088451f, -0.03808169f, -0.03107526f, 0.03547853f, -0.05529425f, 0.01510979f, 
    0.01346163f, 0.01987956f, -0.00283515f, -0.04474738f, 0.02857030f, 0.01947116f, 0.01842248f, 0.04278651f, 
    0.01202641f, -0.04484528f, 0.01275603f, -0.05434480f, 0.02204220f, -0.00714503f, 0.00900383f, 0.01787920f, 
    -0.05313655f, 0.03226892f, 0.03209418f, -0.03726585f, 0.01012114f, -0.02259444f, 0.04440716f, -0.00991943f, 
    0.03507809f, 0.04142847f, 0.00395072f, -0.03482111f, 0.00247623f, -0.00016006f, 0.02361777f, 0.02917419f, 
    0.02844046f, 0.01277376f, -0.01799229f, -0.04731923f, -0.01179930f, 0.00258333f, 0.01650005f, 0.01693733f, 
    0.03841997f, 0.02520651f, -0.02906749f, 0.02619154f, 0.05428842f, 0.00471442f, 0.02369523f, -0.04470301f, 
    -0.01379365f, 0.00678759f, -0.04630742f, -0.03937127f, -0.02841446f, -0.04033961f, 0.02168067f, -0.00369104f, 
    0.04401077f, 0.03604044f, 0.03996026f, -0.04023136f, -0.02800958f, -0.01932895f, 0.03727418f, -0.02052901f, 
    -0.03534343f, 0.00348029f, 0.00342212f, 0.00708709f, 0.02418841f, -0.02543321f, -0.00887635f, 0.01196017f, 
    -0.04306838f, -0.02201803f, -0.03889687f, 0.01663670f, -0.04089745f, 0.03763457f, 0.00933043f, 0.03627484f, 
    0.03085453f, 0.03520825f, 0.02321342f, 0.00563942f, -0.01080507f, -0.04609060f, -0.02086507f, 0.00128918f, 
    -0.03336689f, 0.01761725f, 0.00274060f, -0.05038843f, 0.03955821f, -0.05473437f, -0.01829218f, 0.00942720f, 
    -0.01147623f, 0.04083889f, -0.04362136f, -0.01538575f, 0.04264383f, 0.03016534f, -0.00744781f, -0.01755163f, 
    0.01981344f, -0.02258989f, -0.02094139f, 0.00300142f, -0.03151431f, -0.01178983f, -0.01433140f, 0.01311325f, 
    -0.01317036f, -0.03921635f, -0.01914726f, 0.02927442f, 0.01839946f, 0.03343675f, -0.05140363f, 0.00456505f, 
    -0.00147220f, -0.00999094f, -0.04032853f, -0.03214122f, -0.03368105f, 0.00988543f, 0.01728455f, -0.02087347f, 
    -0.04467646f, -0.03760122f, -0.03450232f, -0.05265279f, -0.05131665f, -0.02269509f, 0.01054025f, 0.01909082f, 
    0.00077843f, -0.01333600f, -0.05561690f, 0.02566770f, -0.02606129f, -0.02720248f, 0.02562127f, 0.01068090f, 
    -0.03345908f, 0.04190167f, 0.00833844f, -0.00054308f, 0.01215638f, -0.02032571f, -0.04512817f, -0.04117287f, 
    0.00790538f, -0.03556320f, -0.00469468f, 0.01330889f, -0.00514015f, 0.01822751f, 0.00839302f, -0.02541729f, 
    0.03149768f, 0.00354914f, -0.00053625f, -0.05534552f, -0.02276270f, -0.03235493f, 0.04271106f, -0.05176284f, 
    0.01641575f, 0.01102953f, 0.02240957f, 0.04191650f, 0.03315521f, -0.05171782f, 0.03817743f, 0.00999137f, 
    0.04714499f, -0.03518083f, 0.03953075f, -0.01935004f, 0.01059395f, 0.00163635f, -0.00161634f, -0.03699220f, 
    -0.03249343f, 0.01860013f, -0.04107558f, -0.03817630f, 0.01236333f, -0.00172164f, -0.02463897f, 0.02634730f, 
    -0.02840380f, -0.01042582f, 0.02661473f, -0.00918087f, -0.00145862f, -0.05529889f, -0.02800919f, -0.03930016f, 
    -0.03043389f, -0.00156242f, 0.01603733f, 0.03929633f, -0.01574253f, -0.03159299f, 0.04092335f, 0.01749220f, 
    0.02576798f, 0.00473368f, -0.00238495f, -0.01712624f, -0.00670638f, 0.03008665f, 0.03982759f, -0.02042865f, 
    -0.04969393f, -0.04923251f, 0.02676530f, 0.01584387f, -0.01803790f, -0.00970294f, -0.00882168f, -0.01957656f, 
    -0.03342044f, -0.00540399f, 0.00218777f, -0.03057924f, 0.00443517f, -0.04904657f, -0.02252747f, -0.03218571f, 
    -0.02838213f, -0.00033957f, 0.04300391f, 0.01868933f, -0.05674137f, -0.04559711f, -0.00339957f, -0.01911027f, 
    -0.00642019f, -0.00055098f, -0.02294549f, -0.02628297f, 0.01717343f, -0.01685478f, -0.04892108f, 0.02694553f, 
    -0.02992949f, 0.00192156f, -0.04843102f, -0.04072026f, 0.03490807f, 0.04226664f, 0.03152490f, 0.00255212f, 
    -0.01591872f, 0.02367095f, 0.02403813f, 0.02918558f, 0.00775603f, -0.03807840f, -0.01018036f, -0.00236975f, 
    -0.01905755f, -0.01607799f, -0.00189098f, 0.02754238f, 0.01325114f, 0.01342516f, 0.00440533f, -0.03933466f, 
    0.03524444f, 0.03632706f, -0.03202105f, -0.04244938f, -0.05448174f, -0.03647710f, -0.05199536f, -0.04877290f, 
    -0.05188274f, 0.01535819f, -0.01689956f, 0.03200560f, 0.01882105f, -0.05555652f, 0.00324182f, -0.02345145f, 
    -0.02314251f, -0.00718996f, -0.00093104f, -0.03167806f, -0.05080393f, -0.00404064f, -0.02599096f, -0.01924861f, 
    -0.02887114f, 0.03205233f, 0.03427358f, 0.01787473f, 0.02131045f, 0.03698903f, -0.00868252f, -0.02798143f, 
    0.01165678f, -0.05071769f, 0.00270773f, -0.01545800f, -0.00124156f, -0.01733716f, 0.01185990f, -0.00570410f, 
    -0.04615474f, 0.01588375f, -0.00294344f, -0.03720857f, 0.01721263f, -0.00056529f, -0.03394625f, -0.04585214f, 
    -0.16331737f, -0.36552361f, 0.13492566f, 0.31716678f, 0.08089060f, -0.03414111f, 0.00794931f, -0.07716433f, 
    0.02997453f, 0.03226594f, 0.03485151f, 0.14887197f, -0.25752202f, 0.08335731f, 0.06828685f, -0.20435540f, 
    -0.14664298f, 0.19747430f, 0.20722134f, 0.02903525f, -0.11681025f, -0.03673011f, 0.09569343f, 0.03033085f, 
    -0.11026645f, 0.11532219f, -0.13582660f, -0.01596354f, 0.10295051f, 0.10835906f, 0.03209353f, 0.12813126f, 
    -0.05433659f, 0.09475511f, -0.07257397f, 0.18042961f, 0.19760723f, 0.03745788f, -0.08328940f, 0.05734621f, 
    -0.09221146f, 0.14388084f, -0.10899880f, 0.02166246f, 0.02362445f, 0.09223095f, 0.04956339f, 0.03878811f, 
    0.06971598f, 0.02143222f, 0.03242904f, -0.07287034f, -0.00424392f, 0.06374120f, -0.12622994f, -0.05849988f, 
    -0.04897832f, -0.13762502f, -0.08442434f, -0.23837295f, 0.03175412f, -0.20116179f, -0.12507541f, -0.16860437f, 
    0.20531461f, -0.15543081f, -0.19795109f, -0.16569804f, -0.11534113f, -0.03260459f, -0.26761478f, -0.18735747f, 
    0.52132857f, -0.09633098f, -0.15529265f, -0.38234550f, 0.05689985f, 0.09720108f, -0.07600329f, -0.07344214f, 
    0.05697928f, -0.08042928f, 0.16607289f, 0.07808151f, -0.01609474f, -0.07769011f, -0.24735315f, -0.19517139f, 
    -0.06379860f, 0.05491726f, -0.06989544f, -0.06074153f, -0.07351690f, -0.15999685f, 0.06866345f, -0.19264367f, 
    -0.32334548f, -0.07045445f, -0.02164118f, -0.01299637f, 0.00080619f, -0.12227907f, 0.03508916f, -0.09009660f, 
    0.06168927f, 0.17827724f, 0.05320831f, 0.28121805f, 0.22502817f, 0.16053918f, -0.11622616f, 0.08715977f, 
    0.15495187f, 0.13192393f, 0.06725319f, 0.10444353f, 0.06764305f, 0.12746532f, 0.02346068f, -0.14582440f, 
    0.07542851f, 0.34376201f, 0.11560094f, 0.41987106f, 0.11112704f, 0.12572235f, 0.10197966f, 0.13202550f, 
    -0.01559655f, 0.08967531f, 0.01972800f, -0.16735351f, -0.15959412f, 0.07815111f, -0.12352969f, 0.03657874f, 
    0.03303798f, 0.03570043f, -0.16549920f, -0.01833615f, -0.20771593f, -0.10451476f, -0.26663208f, -0.48682234f, 
    -0.27645469f, 0.01722964f, 0.17086762f, 0.03414957f, -0.00845744f, 0.10347165f, 0.08676438f, 0.00359591f, 
    0.10191439f, -0.02653484f, -0.03211373f, 0.02853145f, 0.12223285f, 0.11079066f, 0.35358459f, -0.35121480f, 
    -0.04104521f, -0.04666040f, -0.08127604f, -0.33367351f, -0.05899369f, 0.15827140f, -0.01850834f, -0.04217399f, 
    0.18467569f, 0.03109710f, -0.10100389f, -0.16680107f, 0.26021013f, 0.00734432f, 0.02961987f, -0.26491103f, 
    -0.16910611f, 0.07292455f, -0.14476679f, -0.04463203f, 0.32057369f, 0.12309510f, 0.18285672f, 0.11257534f, 
    -0.20043220f, 0.03969470f, 0.04413694f, 0.11593198f, 0.08024522f, -0.09421933f, 0.09709846f, -0.04221320f, 
    -0.14050634f, -0.00812570f, 0.11745714f, -0.34463558f, -0.02071938f, -0.03225251f, -0.05133193f, -0.09442996f, 
    -0.13651180f, -0.05023250f, -0.04468165f, -0.06338564f, 0.26778752f, 0.07856707f, 0.08526380f, 0.25279200f, 
    0.06191471f, 0.08267872f, 0.02748288f, 0.04313321f, -0.03981734f, -0.14436355f, -0.02854753f, 0.15195328f, 
    -0.23795143f, -0.12884335f, -0.06274537f, 0.13337149f, 0.16473550f, -0.02257278f, 0.06226204f, 0.09790539f, 
    -0.04797776f, 0.20755611f, -0.10447791f, -0.19310138f, 0.02313123f, 0.13224925f, -0.13333732f, 0.14225508f, 
    -0.01369251f, -0.08808629f, 0.08973159f, -0.10307356f, 0.05208342f, -0.02312282f, 0.02606703f, -0.08756698f, 
    0.19500484f, 0.09365302f, 0.22624040f, 0.17483804f, 0.14161693f, -0.03151215f, -0.06574506f, 0.03967401f, 
    -0.16191258f, 0.03580573f, -0.09158158f, -0.30151859f, -0.06957671f, 0.13416442f, 0.00939998f, -0.02444426f, 
    0.28046644f, 0.07535854f, -0.07859406f, -0.09808370f, -0.04762727f, -0.00063321f, -0.04727709f, -0.08728303f, 
    0.07654105f, -0.10380735f, 0.18220648f, 0.16532326f, 0.27325952f, 0.10259333f, 0.07652484f, -0.07070230f, 
    -0.02739937f, 0.03415179f, 0.12224071f, 0.19985704f, 0.20625049f, -0.28663269f, -0.12989774f, -0.00984541f, 
    0.15066366f, 0.09793985f, 0.08553028f, 0.14032757f, 0.07520102f, 0.09268500f, 0.25255591f, 0.14319523f, 
    -0.13006742f, 0.27875683f, -0.02943936f, -0.05492846f, 0.24156275f, -0.05257557f, -0.17562412f, 0.00664021f, 
    -0.04792660f, -0.02623576f, -0.20376863f, -0.15948820f, 0.21975590f, 0.02102413f, -0.02865742f, 0.21138375f, 
    0.05397707f, 0.00707852f, 0.17962629f, 0.06105877f, 0.10537384f, 0.02801048f, 0.05333312f, -0.17016961f, 
    0.29301295f, 0.03368498f, 0.08271659f, 0.12441459f, 0.08651285f, 0.10497338f, 0.01954387f, 0.27832404f, 
    0.15211971f, 0.00729177f, 0.04731588f, -0.06041631f, 0.10123479f, 0.09307595f, -0.18104230f, 0.22128636f, 
    0.12478451f, 0.16787757f, 0.25210899f, 0.08088949f, -0.04397325f, 0.06556635f, 0.07513854f, 0.18511523f, 
    -0.12637517f, -0.06072500f, -0.03840110f, 0.03993299f, -0.18874873f, 0.14316420f, 0.15793647f, -0.12294268f, 
    -0.10066286f, 0.08389996f, -0.05360207f, 0.11004945f, 0.24955310f, 0.30834949f, 0.01321206f, -0.08467553f, 
    0.03094814f, 0.00137667f, -0.02444337f, -0.00418859f, -0.19306526f, 0.05835713f, -0.12858468f, -0.45030060f, 
    -0.03390081f, -0.07296655f, -0.03383884f, -0.34560162f, 0.03348745f, -0.05653964f, -0.03969007f, -0.21665466f, 
    -0.09208663f, -0.35098857f, -0.16153473f, -0.24307817f, -0.12279607f, 0.01898481f, -0.17493655f, -0.08896871f, 
    -0.08066735f, -0.14548358f, -0.00963682f, -0.17823194f, 0.11560318f, -0.00550658f, 0.07124270f, 0.20613869f, 
    0.36499113f, 0.07921265f, -0.06040420f, -0.09947718f, 0.00012828f, -0.02674371f, 0.08472835f, 0.15319085f, 
    -0.03621035f, -0.11246409f, -0.10803529f, -0.03557368f, -0.10787810f, -0.22979578f, 0.01083136f, 0.12916836f, 
    0.03835974f, -0.05837392f, -0.07563689f, -0.11620200f, 0.06828631f, 0.03592191f, -0.06281430f, 0.11630933f, 
    -0.07441606f, -0.37458056f, 0.14063689f, 0.20381641f, 0.04333556f, -0.03388884f, -0.08873592f, -0.02521655f, 
    0.01465751f, 0.05504664f, -0.06957733f, 0.08009182f, 0.32411915f, 0.30663267f, 0.15311505f, 0.06840684f, 
    0.12051009f, 0.07174400f, 0.11546335f, 0.21145615f, 0.08854565f, -0.05111621f, -0.02819348f, -0.00449467f, 
    0.12570241f, 0.33750850f, 0.37744862f, 0.08664484f, 0.04834977f, 0.07393837f, 0.06157369f, -0.09231374f, 
    0.01951913f, -0.04642899f, 0.00102151f, 0.00462121f, -0.32923582f, -0.19182017f, -0.16822231f, 0.05740585f, 
    -0.06140599f, 0.01480918f, -0.08843069f, -0.02204014f, 0.04187250f, 0.05313158f, -0.09126088f, 0.03286743f, 
    -0.31738412f, 0.24498338f, 0.11573337f, 0.05006124f, 0.13960750f, 0.04599420f, 0.00202052f, 0.19457097f, 
    0.06287326f, 0.04373394f, -0.11845326f, 0.08887736f, 0.05211426f, 0.25083467f, -0.01302542f, 0.02828642f, 
    -0.07425286f, 0.22605002f, 0.19177972f, -0.00634953f, 0.09237732f, -0.13219616f, 0.00876012f, 0.10062839f, 
    -0.17380820f, -0.23891340f, -0.24289550f, -0.11411082f, 0.08857840f, -0.01631622f, 0.00868944f, 0.04041289f, 
    -0.12832423f, -0.16785847f, 0.01519274f, -0.08549009f, 0.35091323f, 0.27637491f, 0.08141204f, 0.16914110f, 
    0.15007016f, 0.08344650f, 0.00220890f, 0.13099210f, -0.00642950f, 0.00793566f, 0.02011851f, -0.02150359f, 
    0.01348598f, -0.04924549f, -0.28670064f, -0.06781106f, 0.01748552f, -0.01789873f, 0.13675193f, -0.05786270f, 
    -0.05273902f, 0.00725420f, 0.04563169f, -0.04143523f, 0.01267985f, -0.01012337f, -0.05179750f, 0.05327579f, 
    -0.05747749f, 0.01630391f, -0.03918094f, 0.01853709f, -0.03797818f, -0.00293502f, 0.02292602f, -0.02139732f, 
    -0.02910221f, -0.10001091f, -0.22007616f, 0.21169248f, -0.02842924f, 0.06450377f, 0.01163911f, -0.06307379f, 
    0.05905741f, -0.06860541f, -0.03546687f, -0.09236623f, -0.58544147f, 0.01353584f, 0.23578049f, -0.08943609f, 
    -0.12694755f, 0.02916222f, 0.01704145f, 0.10013618f, -0.10934659f, -0.06480914f, 0.00182504f, -0.02611439f, 
    0.19605388f, 0.14357129f, 0.11463321f, -0.01473778f, -0.16007979f, 0.01126356f, 0.01504710f, 0.07141722f, 
    0.06480903f, -0.08239824f, 0.05427307f, -0.17194295f, -0.39996475f, 0.15697686f, -0.04365923f, 0.28442293f, 
    -0.05822569f, 0.06414097f, -0.11373983f, -0.18261416f, 0.01423504f, 0.10969456f, 0.04351177f, 0.01191653f, 
    -0.36390454f, -0.17852898f, -0.11852358f, 0.14183360f, 0.05692247f, -0.01388794f, -0.09281728f, 0.06252120f, 
    0.04815146f, -0.03490044f, 0.06989324f, 0.03104086f, 0.40337640f, 0.02489505f, 0.24543494f, -0.02554052f, 
    0.07586160f, 0.03417748f, 0.14504367f, 0.14691195f, 0.03810772f, -0.00761926f, -0.12465306f, -0.03483123f, 
    0.14380075f, -0.08844598f, 0.10877588f, -0.00452485f, -0.14645196f, -0.04452658f, 0.01974204f, 0.21081160f, 
    -0.06999893f, -0.10648086f, 0.00855897f, 0.15409465f, 0.17629175f, 0.02724762f, -0.02327054f, 0.07942270f, 
    0.08613759f, 0.10182488f, 0.17851588f, 0.17471455f, 0.04896487f, -0.10247566f, 0.11237093f, 0.00010529f, 
    -0.10403185f, -0.09039436f, -0.36551353f, 0.06796049f, -0.08915960f, -0.02502128f, -0.04298843f, 0.01854364f, 
    -0.00972892f, 0.00914736f, -0.03431355f, 0.02084184f, 0.30220634f, -0.29047748f, 0.08802044f, -0.18458124f, 
    -0.25353751f, 0.07688141f, -0.06096370f, 0.13836783f, -0.08351298f, -0.11311109f, 0.17736876f, 0.20940767f, 
    -0.11184268f, -0.11880118f, 0.20224413f, -0.00499983f, 0.10145272f, -0.04563290f, 0.06243824f, 0.03983784f, 
    0.14956105f, -0.01163160f, -0.05203142f, 0.03674029f, 0.13522847f, 0.30328128f, 0.02017549f, -0.05272833f, 
    0.18737262f, 0.14594831f, 0.04328351f, 0.11829833f, -0.03110474f, -0.07837685f, -0.11570949f, -0.11777941f, 
    0.04166699f, -0.41971040f, 0.11651489f, 0.14864700f, -0.07172228f, 0.00672938f, -0.05941629f, 0.02332133f, 
    0.07530496f, -0.03804726f, -0.02582417f, 0.20711724f, 0.19545464f, 0.26855680f, 0.35132194f, 0.23728596f, 
    0.03694168f, 0.04497371f, 0.18480641f, 0.17735635f, -0.02341582f, -0.07876399f, 0.00535191f, -0.00890151f, 
    0.20255384f, 0.30769125f, 0.28099394f, 0.15940064f, 0.15839058f, 0.11207385f, 0.08952960f, 0.08784064f, 
    0.02295666f, 0.06443389f, -0.05789312f, 0.00814854f, 0.10886960f, 0.11035613f, 0.08729824f, 0.01203886f, 
    0.20456704f, 0.05422027f, -0.05338014f, 0.05082861f, -0.04304687f, -0.04547998f, 0.06482505f, 0.12439117f, 
    -0.19679448f, -0.16215698f, -0.12502797f, -0.17349745f, 0.06979953f, -0.16756590f, -0.18887770f, 0.06694432f, 
    -0.04222101f, 0.05799496f, 0.07413419f, -0.01984940f, -0.03322885f, -0.07687382f, -0.13937478f, 0.01352949f, 
    -0.10657370f, 0.00059661f, 0.02681981f, -0.02180958f, -0.03614660f, 0.08045199f, -0.02776588f, -0.00107053f, 
    -0.21279065f, 0.08032964f, 0.07905908f, 0.08313403f, -0.09928560f, -0.01133768f, -0.05797519f, 0.00925119f, 
    0.03640764f, 0.06485206f, -0.00048475f, -0.08587530f, -0.28386506f, -0.03702544f, -0.04857551f, 0.03220697f, 
    -0.00103158f, 0.05064184f, -0.04966459f, 0.04753417f, -0.07249215f, -0.16693351f, -0.01491714f, -0.06325297f, 
    0.32275483f, -0.27035335f, 0.13989410f, 0.26743308f, -0.01725108f, 0.12105045f, -0.00367926f, 0.10417737f, 
    -0.11757921f, -0.03924507f, -0.03828719f, -0.08664443f, -0.01426876f, 0.06124028f, -0.11615376f, 0.02060301f, 
    -0.03287205f, -0.13178021f, -0.04754017f, 0.01316139f, 0.09726887f, -0.08588991f, -0.11048565f, -0.10524739f, 
    0.20985061f, 0.11490491f, 0.00512014f, -0.00081679f, -0.14922340f, -0.10965088f, -0.06360663f, -0.16984576f, 
    -0.03934243f, -0.09855621f, -0.09970955f, -0.01763291f, 0.01936444f, 0.26166004f, -0.02913360f, 0.05295097f, 
    0.03142118f, -0.09792498f, -0.01703577f, 0.01904182f, -0.01409019f, 0.00188837f, -0.07507455f, 0.19648811f, 
    -0.03177189f, -0.05991102f, -0.02784734f, -0.02910126f, 0.23029691f, 0.10093045f, 0.23633158f, 0.07066976f, 
    0.08490644f, 0.14425883f, 0.07557599f, 0.24720281f, 0.16391332f, 0.07569893f, 0.12727171f, -0.04089296f, 
    -0.12827148f, -0.00634126f, -0.06302974f, -0.07767842f, -0.04486672f, 0.01616569f, -0.05731501f, 0.07307685f, 
    -0.33875248f, -0.07921247f, 0.01820444f, -0.17805304f, -0.04340320f, -0.02072738f, -0.01083991f, 0.10883483f, 
    0.10542229f, 0.15359102f, -0.18304618f, -0.01541539f, -0.09884885f, 0.05298237f, -0.12989497f, 0.14324372f, 
    0.11816594f, 0.13933605f, 0.17103617f, 0.22759739f, 0.05766752f, 0.14258698f, 0.14030445f, 0.12033542f, 
    0.08197861f, 0.20765167f, -0.07154234f, 0.00094758f, -0.01788834f, 0.00396530f, -0.07280552f, -0.03560092f, 
    -0.03501323f, -0.17270470f, -0.19774072f, -0.11179770f, -0.11073430f, 0.33356014f, 0.08413258f, 0.07358027f, 
    0.14766991f, 0.13896668f, 0.08609819f, 0.01395865f, 0.01040974f, 0.05281028f, -0.01578392f, 0.14216824f, 
    -0.11838268f, -0.03073939f, 0.02295769f, -0.20503180f, 0.02681787f, 0.07245982f, -0.01331024f, 0.09773617f, 
    0.02651474f, -0.06082644f, 0.00066921f, 0.00993230f, 0.03274183f, -0.02730658f, -0.06523742f, -0.02043373f, 
    -0.00198513f, 0.00212257f, 0.06453676f, -0.15471369f, 0.06219605f, 0.15986651f, 0.01677486f, 0.13412286f, 
    0.22653528f, 0.09302571f, 0.05475930f, 0.01979483f, -0.08744773f, -0.01729009f, -0.09207261f, -0.00791785f, 
    -0.02027414f, -0.12612957f, 0.21274410f, 0.08172552f, 0.08991305f, 0.02898670f, 0.04324207f, -0.13548835f, 
    -0.00568986f, -0.08394200f, -0.07302724f, -0.07938565f, 0.15807444f, 0.05642169f, 0.08439481f, 0.16985947f, 
    -0.52804112f, -0.23950364f, -0.33033049f, -0.19685213f, -0.01399244f, 0.09123592f, 0.04260392f, 0.15515885f, 
    0.08136605f, 0.06210463f, 0.13592570f, 0.09747398f, 0.42071867f, -0.18227230f, 0.58688265f, -0.10559548f, 
    0.23271599f, 0.15607017f, 0.04444774f, 0.20093441f, -0.19054590f, 0.01004586f, 0.03594909f, -0.05158018f, 
    0.32349631f, 0.20663454f, 0.28094569f, 0.09812092f, -0.08783414f, -0.08241253f, -0.02561699f, -0.04434060f, 
    -0.02585512f, 0.02796159f, -0.00073223f, 0.08965692f, 0.16942039f, 0.22673240f, -0.00760914f, -0.04034619f, 
    0.00353973f, -0.03581340f, 0.19126743f, 0.04756233f, -0.00716069f, 0.10800192f, 0.00050498f, 0.01743909f, 
    0.23623930f, -0.13707711f, 0.28905672f, 0.11462300f, 0.08990129f, 0.08225895f, -0.05839514f, 0.05281746f, 
    0.08052256f, -0.09514643f, 0.20161448f, 0.00271155f, -0.08665860f, -0.44745815f, -0.02150966f, -0.11478786f, 
    -0.11016065f, 0.00928071f, -0.03127012f, 0.15784022f, -0.06600711f, 0.06448389f, -0.01138630f, -0.07777040f, 
    0.22714210f, 0.10275067f, 0.11468141f, -0.10947140f, -0.02178601f, -0.01521059f, -0.16588242f, -0.11508878f, 
    -0.03022292f, 0.01605641f, 0.00892802f, 0.11569797f, 0.28667140f, 0.31441203f, -0.18606950f, 0.11070645f, 
    -0.10155340f, 0.20836103f, 0.09653375f, 0.23517548f, -0.08499131f, -0.03683855f, 0.01275360f, 0.11537990f, 
    -0.10372934f, -0.40923154f, 0.12329575f, 0.02826437f, 0.04938236f, -0.08382728f, 0.00761853f, 0.04434162f, 
    -0.12752672f, 0.02689273f, -0.08998200f, -0.11743411f, 0.16311952f, 0.09477814f, -0.11513229f, 0.02347980f, 
    -0.02350776f, 0.10402172f, 0.20693141f, -0.01338209f, -0.07134008f, 0.03419369f, -0.03350643f, -0.00832167f, 
    0.23038948f, 0.05838069f, 0.16943282f, 0.10863204f, -0.15361200f, -0.02490149f, -0.07246113f, -0.07110445f, 
    0.04124672f, 0.01215080f, 0.21216223f, 0.14845438f, -0.06992398f, -0.13647036f, 0.08371288f, -0.02717962f, 
    0.21033268f, 0.21814579f, 0.02749369f, 0.19624415f, -0.08765099f, -0.08495488f, -0.03841262f, 0.01696499f, 
    0.03590715f, 0.10477709f, 0.23183647f, -0.01138649f, -0.02477829f, -0.03351395f, -0.09827043f, -0.12792808f, 
    -0.16848718f, -0.02179348f, -0.08527880f, 0.01432529f, -0.02982543f, 0.21044450f, -0.02929356f, -0.04750207f, 
    0.06708678f, -0.09088084f, 0.02378807f, 0.05456033f, -0.14590520f, -0.06092110f, -0.05661396f, -0.22368868f, 
    0.18470550f, 0.40279707f, 0.02150836f, 0.13114230f, 0.00875267f, -0.10394891f, -0.06508701f, -0.01779046f, 
    -0.09140942f, 0.00549520f, -0.08681890f, -0.02951706f, 0.09159765f, -0.15430330f, -0.12898894f, -0.14525983f, 
    -0.02687888f, -0.02654307f, -0.17199688f, -0.15962674f, -0.01048987f, 0.00850076f, 0.01430923f, 0.05316008f, 
    0.05028677f, -0.02837669f, -0.03794586f, -0.04061277f, -0.07654198f, 0.09315626f, -0.14183749f, 0.04272263f, 
    0.07536296f, 0.15439105f, -0.03846189f, 0.04536607f, -0.14121762f, 0.07929656f, 0.16359508f, 0.08523565f, 
    -0.00627338f, 0.05262135f, 0.05098739f, 0.14010023f, -0.06578878f, 0.12593958f, -0.09095597f, -0.06513617f, 
    0.00245787f, -0.22523773f, 0.20171519f, 0.49748859f, -0.00000929f, 0.07949185f, -0.02970161f, -0.00894155f, 
    -0.01884871f, 0.12325319f, -0.06724741f, 0.05753993f, 0.07106488f, 0.24280545f, -0.00334832f, -0.19111203f, 
    -0.08097392f, 0.01962325f, 0.05535801f, 0.01923910f, 0.01639976f, 0.01451368f, 0.08572172f, -0.10801289f, 
    0.02105840f, 0.27604547f, -0.18074125f, -0.13719280f, -0.12052125f, -0.07998241f, -0.00067105f, -0.00451384f, 
    0.02212136f, 0.00419976f, 0.01371839f, 0.03142044f, -0.04996124f, 0.08612953f, -0.05719720f, 0.08334211f, 
    0.02640195f, -0.05485867f, -0.09667562f, -0.08259452f, 0.02307869f, 0.02268488f, -0.01353004f, 0.09014235f, 
    0.14790377f, -0.14145431f, -0.15574948f, -0.05138864f, 0.06345273f, 0.02593207f, -0.03436572f, 0.05277066f, 
    0.05008437f, 0.16998616f, 0.09701931f, -0.02954652f, 0.20316876f, 0.14984243f, 0.11246098f, -0.18675159f, 
    -0.08393291f, -0.08837852f, -0.03189461f, 0.03005878f, 0.04361998f, 0.03236869f, 0.03641002f, 0.10348731f, 
    0.28570908f, -0.11658137f, -0.24902092f, -0.15879473f, 0.16753933f, 0.19679193f, 0.13042448f, 0.01284802f, 
    -0.01600380f, -0.08673751f, 0.01939985f, 0.07034890f, -0.07194423f, -0.10231621f, 0.12006649f, 0.04130317f, 
    0.11235981f, 0.07804041f, 0.07124019f, 0.29704463f, -0.05029525f, -0.01646964f, 0.04243772f, -0.06452510f, 
    -0.10720257f, 0.28585944f, -0.03532380f, -0.01429859f, -0.08452167f, -0.07752695f, -0.07936307f, -0.03539155f, 
    0.12852581f, 0.08125048f, 0.05122464f, -0.00212736f, -0.15932728f, 0.05221659f, -0.12974462f, 0.19523570f, 
    0.05370642f, -0.02357450f, 0.03416416f, 0.00520337f, -0.02125973f, -0.08016176f, -0.06082369f, -0.04344895f, 
    -0.11319051f, 0.10711826f, 0.33512068f, 0.06332575f, -0.04258068f, 0.01827864f, -0.01104243f, 0.14299288f, 
    -0.01739685f, -0.00539502f, 0.05058460f, 0.05812251f, -0.03201424f, 0.02846326f, -0.00473637f, 0.00408736f, 
    0.04714942f, -0.06419431f, -0.03273809f, 0.00552050f, 0.02547526f, 0.07171026f, 0.02506042f, 0.08580004f, 
    0.16449590f, 0.13243464f, 0.27209952f, -0.03823734f, -0.11049560f, 0.01686365f, 0.06388809f, -0.11649394f, 
    -0.21427841f, 0.12466389f, 0.05942762f, 0.13119699f, 0.63496619f, -0.07962184f, -0.06527387f, -0.27302429f, 
    0.06023910f, -0.08432412f, -0.01296336f, -0.06914348f, 0.05732749f, 0.04043126f, 0.07908246f, 0.02934998f, 
    -0.21180081f, -0.19180818f, -0.31822386f, -0.14346614f, 0.12706284f, 0.08487075f, 0.09449212f, 0.12204730f, 
    0.02668557f, 0.22381282f, 0.09126123f, 0.03269847f, 0.67904311f, 0.02022266f, 0.58118767f, -0.10222819f, 
    0.00342950f, 0.00063396f, 0.06003002f, 0.10769700f, -0.20263214f, 0.05697891f, 0.09076589f, 0.04361655f, 
    0.43502873f, 0.26076531f, 0.21823528f, -0.06373258f, -0.09859459f, -0.13264835f, 0.01947574f, -0.01824681f, 
    -0.10914382f, 0.10066950f, 0.05422514f, 0.01015038f, 0.04577184f, 0.25846100f, -0.12159287f, 0.09451949f, 
    0.02066562f, -0.01485313f, 0.06188808f, 0.01586251f, -0.06486745f, -0.01177042f, 0.03495808f, 0.02390439f, 
    0.08194911f, -0.13403487f, 0.14069146f, 0.46636894f, 0.08308142f, -0.10026229f, 0.03934969f, -0.04419146f, 
    0.04494167f, 0.04873470f, 0.05468531f, -0.04965874f, -0.09284591f, -0.24826956f, 0.05149041f, 0.30003199f, 
    -0.04320261f, 0.01200117f, 0.02632152f, 0.04777203f, -0.11151513f, 0.07741370f, 0.05597097f, -0.04548943f, 
    0.14273363f, 0.09329070f, 0.26599869f, -0.16164364f, -0.06724671f, -0.09711865f, -0.13038488f, -0.05841318f, 
    0.00935467f, 0.04496086f, -0.05781103f, 0.01896165f, -0.06532164f, 0.60584116f, 0.00210826f, 0.54953629f, 
    -0.04214390f, 0.19614758f, 0.18328319f, -0.00213740f, -0.07182298f, 0.04986398f, 0.00091718f, 0.01461068f, 
    0.44029969f, -0.36420587f, 0.02526061f, 0.25020584f, 0.05276443f, 0.26120940f, 0.08329967f, 0.05896765f, 
    -0.17253582f, 0.07387526f, 0.06747761f, -0.00231113f, 0.31426099f, -0.23563503f, -0.03041835f, 0.16189742f, 
    0.13620420f, 0.02096335f, 0.07279741f, 0.03973868f, -0.03696270f, 0.00306667f, 0.04413283f, -0.02913921f, 
    0.08167933f, 0.34449214f, 0.01943766f, -0.10106771f, -0.07372532f, -0.06258091f, 0.02423494f, -0.12727156f, 
    0.02120046f, 0.12634750f, 0.04484827f, 0.07340328f, 0.04631012f, -0.20761727f, -0.05266712f, 0.07607560f, 
    0.13345259f, -0.00155413f, -0.09429447f, 0.06393076f, -0.00450631f, -0.02592514f, -0.09423489f, -0.11256360f, 
    -0.06066935f, -0.16712882f, -0.04558752f, 0.03645049f, -0.03236162f, 0.07930349f, -0.09044249f, -0.02623700f, 
    -0.02328030f, -0.06025574f, -0.01385359f, -0.02469817f, -0.02280437f, 0.07663452f, -0.11837161f, 0.20783406f, 
    0.07054841f, 0.18401273f, 0.36999077f, 0.07812483f, -0.11831520f, -0.10165847f, -0.06452681f, -0.25999936f, 
    0.02551760f, 0.36746860f, -0.00833416f, 0.09386560f, -0.19359002f, 0.07623298f, -0.03907938f, -0.00085875f, 
    0.05538431f, 0.03856028f, -0.00848613f, -0.01581552f, 0.01212769f, 0.08004758f, 0.06615984f, -0.14154182f, 
    0.13211694f, 0.08822695f, -0.05337598f, 0.06045774f, -0.02759633f, -0.02939176f, 0.10485239f, 0.03575337f, 
    0.17445137f, 0.08446386f, -0.04644342f, -0.18712392f, -0.02461905f, 0.03962848f, -0.04212070f, 0.04703638f, 
    0.03461724f, 0.04537481f, 0.10832945f, 0.03213784f, -0.03401500f, -0.05062749f, 0.03004348f, -0.20623755f, 
    -0.03666602f, -0.01984486f, -0.01897757f, 0.11225753f, 0.10781022f, 0.13574201f, 0.03657320f, -0.03747828f, 
    -0.05648874f, -0.00936277f, 0.01967262f, -0.03684674f, 0.02864104f, -0.04952357f, -0.01772241f, -0.03039362f, 
    0.01672478f, 0.00535087f, 0.01873741f, -0.04638748f, 0.00340550f, -0.01851640f, 0.04657684f, -0.04762132f, 
    -0.01389717f, -0.05161558f, -0.01648833f, 0.00215075f, 0.02465089f, -0.02595996f, -0.04062854f, 0.04439318f, 
    -0.01650958f, 0.04337170f, 0.00473077f, -0.04630557f, -0.03939902f, -0.04305024f, -0.04239497f, 0.00475009f, 
    0.01634903f, -0.01880361f, 0.03464682f, 0.01248548f, 0.01585412f, -0.00578152f, 0.03349933f, -0.04047025f, 
    0.01226024f, -0.04490752f, 0.00366673f, -0.01856944f, 0.01401418f, -0.02810397f, -0.00020755f, -0.02035221f, 
    -0.03283168f, 0.03391346f, 0.02932103f, -0.05380343f, -0.03336205f, 0.00060343f, 0.02405788f, 0.01921454f, 
    0.02992540f, -0.05690624f, -0.03241672f, 0.01028546f, 0.00140721f, -0.01035598f, 0.00786091f, 0.03178596f, 
    0.03258610f, -0.02543650f, 0.01385479f, -0.04868082f, -0.05516272f, 0.03647435f, -0.04050796f, -0.00817027f, 
    -0.01099411f, 0.03121244f, -0.04271318f, -0.02091579f, 0.02542663f, -0.04009491f, -0.05480568f, -0.02474187f, 
    -0.03024986f, 0.01755447f, 0.00944033f, -0.05666691f, 0.01400543f, -0.02222225f, -0.04116057f, -0.05703208f, 
    0.01792719f, -0.04792217f, 0.00628870f, -0.02717327f, 0.04432533f, 0.01618921f, 0.00505279f, -0.05082516f, 
    -0.00219468f, -0.01903332f, 0.04069592f, -0.05676420f, 0.03602789f, 0.01013797f, 0.01958599f, 0.01153320f, 
    -0.02374752f, 0.03124660f, -0.04216171f, -0.04394583f, -0.03477851f, 0.02292344f, -0.01528863f, -0.03938521f, 
    0.03646349f, 0.03068888f, -0.05211108f, 0.03941273f, 0.00393609f, 0.00139935f, -0.00714184f, 0.00924848f, 
    -0.03954920f, -0.01312135f, 0.04450784f, 0.00045332f, -0.00797356f, 0.01668006f, -0.03339263f, 0.02532915f, 
    0.03474395f, 0.01136162f, -0.05025168f, 0.02979957f, 0.01660876f, 0.00794944f, -0.02884951f, -0.00752916f, 
    0.00922965f, 0.02808090f, 0.03297434f, -0.03163944f, -0.04384954f, -0.05345775f, -0.04158841f, -0.02288298f, 
    -0.01980191f, -0.03448356f, 0.00480557f, 0.01009630f, -0.05535237f, -0.02415541f, 0.01136527f, -0.05497284f, 
    0.03694702f, -0.05075162f, -0.04015374f, -0.05543727f, 0.02713977f, -0.04945384f, 0.03616388f, 0.01677411f, 
    -0.00176863f, 0.02087274f, 0.04377800f, 0.01072909f, -0.00262843f, -0.03403611f, 0.03132312f, 0.00759343f, 
    -0.05002230f, -0.03581990f, -0.03856935f, -0.04756961f, -0.04503816f, 0.00467715f, -0.04604517f, 0.00845798f, 
    -0.03307477f, -0.01889291f, -0.01772434f, 0.04037683f, 0.03767101f, 0.03038671f, 0.04151014f, 0.02274156f, 
    -0.00270910f, -0.03354482f, -0.05452287f, 0.01692964f, 0.00517388f, 0.02030908f, -0.04556973f, 0.03123398f, 
    0.00101483f, -0.00199714f, -0.00852326f, -0.03500310f, 0.00451602f, 0.02411656f, 0.03018054f, -0.04211278f, 
    0.03528778f, 0.02526736f, -0.03330496f, -0.01583707f, -0.00991452f, -0.00128736f, -0.00523619f, -0.03882026f, 
    -0.01823163f, -0.02336416f, 0.00136770f, 0.01130512f, -0.02524574f, -0.04295792f, -0.05216119f, 0.03584298f, 
    -0.03662143f, -0.04753286f, 0.01269246f, -0.04428641f, 0.01910725f, 0.00830992f, -0.02737644f, -0.00238421f, 
    0.00787189f, -0.01121672f, -0.02427853f, -0.03856565f, 0.01202207f, 0.02014100f, -0.00668565f, -0.00444694f, 
    0.00678876f, -0.03525210f, -0.03183453f, -0.00056693f, 0.03209953f, -0.04939700f, -0.00285569f, 0.02903443f, 
    -0.02230594f, 0.02421303f, 0.01106278f, -0.01051304f, 0.02104265f, 0.02381919f, -0.05673421f, 0.02873928f, 
    -0.02595117f, 0.00985855f, 0.00011994f, -0.01294804f, 0.01309585f, -0.00954738f, 0.02695317f, 0.02095017f, 
    0.01152157f, 0.04619785f, 0.00969428f, 0.00209381f, 0.03934711f, -0.03727002f, -0.01462820f, 0.03735868f, 
    -0.00590581f, -0.02436420f, -0.00966047f, -0.04383703f, -0.05081590f, -0.05237938f, 0.00742834f, -0.04685458f, 
    -0.02285552f, -0.04651866f, 0.04157348f, -0.02608065f, -0.01003646f, -0.00358340f, 0.02080625f, -0.00380345f, 
    0.01617272f, -0.01365477f, -0.03625847f, -0.03497739f, 0.02919765f, -0.02520131f, -0.00345591f, -0.03072749f, 
    -0.00259761f, 0.04965223f, -0.04720268f, 0.00904106f, 0.03871879f, -0.00826289f, 0.01132840f, -0.05601425f, 
    -0.05242893f, 0.00165210f, -0.02662637f, -0.01634999f, 0.03751060f, -0.05051912f, -0.03469592f, 0.01178000f, 
    -0.04737460f, 0.01922012f, -0.04695336f, 0.02550257f, -0.03719914f, -0.03381767f, -0.03615477f, -0.03976180f, 
    0.01333357f, 0.02357216f, -0.01289901f, 0.01769675f, 0.01930407f, 0.00304131f, -0.00552516f, 0.00977139f, 
    -0.05368403f, -0.01365772f, -0.03521796f, 0.01007878f, -0.02101445f, 0.02759861f, -0.01837598f, 0.03671886f, 
    0.04075809f, 0.03399615f, -0.01940443f, 0.02793939f, -0.00956369f, 0.02244905f, -0.00712692f, -0.00125207f, 
    -0.04104390f, -0.04599491f, 0.01286549f, -0.00868643f, 0.00958215f, -0.01586841f, -0.02838337f, 0.00149577f, 
    -0.00317032f, -0.03676433f, -0.02719941f, -0.02382867f, 0.02525320f, -0.02618601f, 0.00800798f, -0.01243207f, 
    0.02650544f, 0.00482893f, -0.02997718f, -0.01675595f, -0.01094360f, 0.01786886f, -0.02211440f, -0.04598862f, 
    0.01857458f, -0.04678580f, -0.03451672f, 0.04083285f, 0.00848867f, 0.03044066f, 0.04157934f, -0.04836167f, 
    0.02880962f, 0.00039921f, 0.02307143f, -0.04841588f, -0.03932767f, 0.01841079f, 0.02395949f, -0.01218538f, 
    0.02532352f, -0.01124373f, 0.00792840f, -0.05127107f, 0.03952364f, -0.00481384f, 0.04113276f, 0.03566973f, 
    -0.43254492f, 0.16863176f, -0.06805028f, 0.05938597f, -0.04454757f, 0.04770885f, -0.15026602f, -0.03110478f, 
    0.15541774f, 0.17681184f, 0.02226094f, 0.12564637f, 0.13089935f, 0.15158240f, -0.10204129f, -0.21017915f, 
    -0.07825875f, 0.01472687f, -0.07786101f, 0.14712036f, -0.07875454f, -0.13024157f, 0.15506701f, -0.11026919f, 
    -0.09802419f, 0.24683768f, -0.09869921f, -0.13468476f, -0.00623071f, -0.27192098f, 0.08462670f, 0.01015510f, 
    -0.04339223f, 0.01240359f, 0.14267713f, 0.01312712f, -0.01891226f, -0.28636539f, 0.14311479f, 0.00966883f, 
    0.06445585f, -0.05403112f, 0.06474707f, -0.02487759f, -0.15911981f, -0.09457105f, 0.01491766f, -0.14034928f, 
    0.21840180f, 0.08985975f, -0.08510205f, -0.05666173f, 0.06249125f, 0.00065296f, 0.01482482f, 0.13484444f, 
    0.08380667f, 0.15405817f, 0.02221129f, 0.03424934f, -0.33731428f, 0.12294368f, -0.00274487f, 0.04290909f, 
    -0.06078455f, -0.17632879f, 0.03011436f, -0.19900262f, -0.04616062f, -0.01816820f, 0.13094832f, 0.04688095f, 
    0.23681250f, 0.03005129f, -0.26253757f, -0.00590704f, 0.20407663f, 0.15369685f, 0.12006053f, -0.13833603f, 
    0.05658970f, 0.09999104f, 0.10612418f, -0.00679908f, 0.15525803f, -0.06235031f, -0.05702605f, -0.03543199f, 
    0.16271633f, 0.16692030f, -0.09174906f, 0.19884919f, -0.04187335f, 0.04914669f, 0.27963620f, -0.08265243f, 
    -0.08295783f, 0.12086057f, 0.06861830f, 0.07236273f, -0.01183998f, -0.12942736f, -0.16439086f, -0.24191521f, 
    0.01664713f, 0.21335377f, -0.05859633f, 0.19671802f, -0.12774488f, -0.13357009f, -0.14255282f, -0.09087020f, 
    -0.09487285f, -0.09818380f, 0.16644222f, -0.03286939f, 0.09252687f, -0.13028140f, 0.12127377f, 0.02263186f, 
    -0.52916127f, -0.40712202f, 0.14229859f, -0.06599236f, -0.09915476f, -0.11945496f, -0.07870413f, 0.08167583f, 
    -0.01512422f, 0.05696363f, -0.00780531f, 0.07608770f, -0.31997260f, -0.09055399f, 0.02241839f, -0.16579007f, 
    0.04182746f, -0.16713993f, -0.08461781f, 0.04753807f, -0.14260842f, 0.01847669f, 0.08053321f, -0.00862430f, 
    0.38104275f, 0.24816224f, -0.08946293f, -0.23557590f, 0.14238000f, -0.20090970f, -0.07658347f, 0.10347115f, 
    -0.17567004f, 0.08632676f, 0.00589334f, 0.05961112f, 0.51514643f, 0.01173158f, -0.21551263f, -0.16350380f, 
    0.08568368f, -0.25035542f, 0.04407739f, -0.04095069f, 0.01795237f, -0.05626332f, -0.06731576f, 0.14068422f, 
    0.17985091f, 0.06784544f, -0.05149004f, 0.01316020f, 0.06035948f, 0.19819006f, 0.03392895f, 0.04334288f, 
    -0.05418331f, 0.06969704f, -0.15159222f, 0.03969296f, -0.16118194f, -0.00368504f, 0.18258853f, -0.00886872f, 
    0.03427577f, -0.01700601f, 0.06292547f, 0.01326562f, 0.01402709f, -0.02316918f, 0.11124746f, 0.05377507f, 
    0.11679278f, 0.17988256f, 0.26317805f, 0.03673396f, 0.00661616f, -0.17294553f, -0.10450842f, -0.00255950f, 
    0.04582001f, 0.01317441f, 0.03151949f, 0.06432613f, 0.07650454f, 0.21656413f, -0.24713439f, -0.26181662f, 
    -0.00496199f, -0.15184140f, 0.02579255f, 0.07823135f, -0.05969202f, -0.04579757f, 0.00555192f, -0.02115559f, 
    -0.31988907f, 0.10164241f, -0.20872338f, 0.00491043f, 0.02987920f, 0.02675843f, 0.11555371f, -0.07998022f, 
    -0.03686582f, 0.01931900f, 0.05019830f, 0.24453239f, 0.03901575f, -0.15512341f, -0.35636219f, 0.09850160f, 
    0.22329263f, -0.02494557f, -0.05559701f, 0.21907544f, -0.04524744f, 0.10137269f, -0.05068282f, 0.05056105f, 
    -0.45228347f, 0.09484090f, 0.23279640f, -0.05667591f, -0.08259217f, -0.16958214f, -0.11098774f, -0.10109939f, 
    -0.04641644f, 0.05864007f, 0.07590102f, 0.11531467f, 0.29726174f, 0.19053005f, -0.15782566f, 0.52143431f, 
    -0.15515675f, -0.17012474f, 0.30596435f, -0.03224295f, 0.18555072f, 0.12314828f, 0.05770934f, -0.02562007f, 
    0.47972327f, 0.05717555f, 0.01949152f, 0.46511576f, -0.04979023f, 0.19585077f, -0.05427916f, -0.08193984f, 
    -0.08121999f, 0.06593896f, 0.05631214f, 0.15789129f, 0.24165401f, 0.37749869f, 0.17452735f, 0.23420079f, 
    -0.03351843f, 0.03349699f, 0.01595628f, 0.03842826f, -0.00007436f, 0.01893319f, -0.07665399f, -0.01356540f, 
    0.09621502f, 0.25739679f, -0.33704761f, 0.05814588f, 0.02680770f, 0.02149274f, 0.07089937f, 0.00970789f, 
    0.09136112f, 0.04905145f, 0.25206053f, -0.05816455f, -0.05056335f, -0.22911580f, -0.15306178f, 0.01563951f, 
    0.07582506f, 0.17394748f, 0.01737776f, -0.04202649f, 0.00879263f, 0.11669615f, -0.08177885f, -0.21840255f, 
    -0.08356986f, -0.07594858f, -0.39806533f, -0.17558581f, -0.02888973f, 0.01571707f, 0.03118156f, 0.09509586f, 
    -0.02274587f, 0.00313376f, -0.04716852f, 0.03291927f, 0.10330720f, -0.12416705f, 0.16460939f, 0.24104778f, 
    0.21836965f, 0.14114395f, 0.10279214f, -0.08096542f, 0.07324152f, 0.00717377f, 0.18796085f, 0.07906244f, 
    -0.42088583f, 0.38372305f, 0.13418818f, 0.11384570f, -0.01744263f, -0.00993559f, -0.00238688f, -0.09629689f, 
    0.00760369f, -0.06866243f, 0.06735794f, 0.18961778f, -0.70446742f, -0.07205063f, -0.02346863f, -0.24489483f, 
    0.01958613f, -0.16686220f, -0.19180541f, -0.07614314f, -0.05880314f, -0.08959150f, -0.08303738f, -0.01309857f, 
    0.14310080f, 0.00989250f, 0.00085345f, 0.05577043f, -0.02210234f, 0.06635717f, 0.04431013f, -0.02122516f, 
    -0.06386483f, 0.03277859f, 0.01630670f, 0.22336769f, -0.01606841f, -0.17380105f, 0.05201714f, -0.04238236f, 
    0.06163630f, -0.10030720f, -0.12858817f, -0.04716566f, -0.04996768f, 0.06057661f, -0.08538323f, -0.03841550f, 
    -0.20450667f, -0.11628774f, -0.16662526f, -0.32131797f, -0.10073765f, -0.03110144f, -0.18711181f, 0.08725053f, 
    -0.05775261f, -0.13978380f, -0.03533327f, -0.01314541f, 0.05829738f, 0.04512575f, 0.01828328f, 0.17006709f, 
    0.00642375f, 0.12348003f, -0.01384612f, 0.09374538f, 0.23380092f, 0.18937799f, -0.03863266f, -0.01016262f, 
    0.35253036f, 0.01328561f, 0.20281859f, 0.30662316f, 0.02880152f, 0.05230083f, 0.12370817f, 0.06915089f, 
    0.06304664f, 0.08786211f, 0.12345731f, 0.06954272f, 0.10873004f, -0.12891041f, -0.30600700f, -0.17054583f, 
    0.09353606f, -0.02625484f, 0.00043634f, 0.12683856f, -0.00296119f, 0.06701207f, -0.04792918f, -0.23830058f, 
    0.02294227f, 0.19470777f, -0.02675813f, 0.14058429f, 0.09119403f, 0.21489549f, 0.15973532f, -0.18579066f, 
    -0.00077180f, -0.12464941f, -0.15459800f, 0.14641954f, 0.15639423f, 0.15763335f, 0.14256944f, 0.15742119f, 
    -0.07932905f, 0.06138771f, 0.06999350f, 0.02150604f, 0.14565961f, 0.03492958f, 0.00414049f, -0.02347812f, 
    -0.27768493f, 0.13217442f, 0.10394014f, -0.05709333f, -0.18576376f, -0.30417341f, -0.07233151f, -0.43469110f, 
    -0.29475555f, -0.02302026f, -0.11774326f, -0.15628597f, -0.04826579f, -0.07078575f, -0.15963075f, -0.17745227f, 
    -0.04797143f, 0.23346089f, -0.08123346f, -0.28973985f, -0.09280278f, -0.11318013f, 0.22854988f, -0.02633496f, 
    0.21185164f, 0.02658068f, 0.00897219f, 0.09698869f, 0.12083369f, -0.00062993f, 0.02771942f, 0.06971829f, 
    0.17995484f, 0.15277262f, 0.03502071f, 0.05136564f, 0.14932786f, 0.13795651f, -0.22498927f, 0.10287769f, 
    0.20904148f, 0.20106758f, 0.03364155f, 0.08087824f, -0.00087553f, 0.00635637f, -0.05172825f, 0.06905355f, 
    0.10517094f, 0.18630895f, -0.04018955f, 0.10759281f, -0.12537217f, 0.01557328f, -0.03070382f, -0.06248660f, 
    0.12380691f, 0.01868229f, 0.05078175f, 0.03904268f, 0.17020451f, 0.12917538f, 0.01350488f, 0.11552756f, 
    -0.13776979f, -0.03324304f, 0.02095082f, 0.00953639f, 0.02029809f, -0.06664353f, 0.01472643f, -0.03175838f, 
    0.06980923f, -0.00965738f, -0.04685830f, 0.21340466f, 0.06028981f, 0.10783383f, -0.17410937f, 0.06368668f, 
    0.02858106f, 0.05479097f, 0.01622011f, -0.12275308f, -0.20152703f, 0.03149269f, 0.26970342f, 0.08293699f, 
    0.03632672f, 0.02149973f, 0.04862598f, 0.00675521f, -0.06033680f, -0.15277989f, -0.20662184f, -0.09774769f, 
    0.10176189f, -0.21407615f, -0.19763359f, -0.42492914f, -0.10826200f, 0.05982565f, 0.06809842f, -0.04338691f, 
    0.01721519f, -0.04147173f, 0.03258385f, -0.04753402f, 0.00733120f, 0.18390998f, -0.11491371f, -0.00742159f, 
    -0.05754851f, -0.21683931f, -0.13281146f, -0.07990912f, 0.11960762f, -0.01516995f, 0.06512453f, -0.05008690f, 
    -0.03923345f, 0.23284572f, 0.02799137f, 0.04075254f, 0.02245287f, 0.06190662f, 0.02259717f, 0.01570070f, 
    0.08159985f, 0.01411470f, 0.00972184f, 0.10189133f, -0.17576902f, -0.13389204f, 0.12979859f, -0.20464633f, 
    0.18519452f, 0.00767480f, 0.14730738f, 0.22673655f, -0.03694307f, -0.06259562f, -0.05160039f, -0.15772569f, 
    0.04540220f, 0.13811129f, -0.04718611f, -0.17082787f, -0.10655309f, 0.02875071f, -0.00461426f, -0.13290919f, 
    0.01852125f, -0.06277326f, 0.05386724f, -0.08785035f, -0.18865390f, 0.15187359f, -0.33863023f, -0.18608642f, 
    0.22196570f, 0.07701296f, -0.03405152f, 0.09691807f, 0.10991848f, 0.13035472f, 0.05795632f, -0.05479236f, 
    0.37106913f, 0.23754515f, 0.04453360f, 0.35378310f, -0.17957309f, -0.07483291f, -0.11377140f, 0.03376451f, 
    0.03997296f, -0.01774843f, 0.05126060f, 0.01678894f, 0.53873241f, -0.12248936f, 0.08280802f, 0.05374540f, 
    0.06085616f, 0.04156312f, -0.03615353f, -0.12581907f, 0.12478466f, -0.07206772f, -0.02969983f, -0.02697424f, 
    -0.31500539f, 0.04051502f, 0.02758862f, -0.00823954f, 0.00050362f, -0.06820063f, -0.16035646f, -0.12264305f, 
    -0.06056250f, 0.03717939f, 0.02606331f, 0.00109965f, -0.31609991f, -0.42009047f, -0.61527753f, -0.42582428f, 
    -0.09910318f, -0.18798092f, -0.10917625f, 0.11867741f, 0.04496680f, -0.07415706f, -0.05446869f, 0.03175374f, 
    0.39335054f, 0.00533258f, 0.15925452f, 0.26637429f, 0.02836836f, 0.03527202f, 0.05196715f, 0.04193592f, 
    0.11082388f, -0.00225687f, 0.14404702f, 0.08677503f, -0.03713165f, -0.01825463f, 0.01157760f, 0.08880734f, 
    0.05761816f, 0.34580693f, 0.19064423f, 0.02277919f, -0.04355653f, 0.00065138f, -0.01640315f, 0.03773935f, 
    -0.06732336f, 0.02593654f, -0.06269433f, 0.01952750f, 0.29716101f, -0.11861230f, 0.07721171f, 0.17517453f, 
    0.00977180f, 0.07719702f, -0.07122039f, -0.01860094f, -0.00127954f, 0.01010080f, -0.05971824f, -0.20386934f, 
    0.21443881f, -0.46333364f, -0.27881864f, -0.21864159f, -0.03205802f, -0.13791163f, 0.00739266f, 0.31026047f, 
    0.19389690f, 0.12740646f, -0.00951723f, 0.07641852f, 0.01313843f, -0.06705178f, -0.07342329f, 0.04209501f, 
    0.14451106f, 0.03068418f, 0.08717351f, -0.02018017f, 0.02244516f, 0.13818294f, 0.01487067f, 0.16684416f, 
    -0.00686875f, -0.01042309f, -0.02915841f, -0.03477321f, -0.05160446f, 0.01359908f, -0.00620637f, -0.02148659f, 
    0.06137032f, 0.17688772f, 0.16783698f, 0.20180152f, -0.09588111f, -0.04924672f, 0.05243437f, -0.02281340f, 
    -0.05020830f, -0.04257452f, -0.12816204f, -0.08414204f, 0.01784248f, 0.09698011f, 0.08839768f, 0.00964362f, 
    0.00618524f, 0.02544326f, -0.02403240f, -0.05834933f, -0.00848632f, -0.14514217f, -0.17285047f, -0.23556122f, 
    0.32911763f, 0.34938952f, -0.24275276f, 0.02322431f, -0.04860996f, 0.03066624f, 0.04094055f, 0.06357286f, 
    0.04578630f, -0.04174268f, 0.00619365f, -0.11284871f, 0.02196479f, -0.07109120f, 0.04195360f, 0.14182138f, 
    -0.00435578f, -0.20213760f, -0.11609927f, 0.04688244f, 0.13966773f, 0.02437533f, -0.13137287f, -0.04703858f, 
    0.55111122f, 0.04297834f, 0.32199797f, 0.30298075f, -0.25735721f, -0.09612349f, -0.11236773f, -0.18392187f, 
    0.05371705f, -0.19609331f, -0.01030678f, -0.15210436f, -0.01293695f, 0.15737483f, 0.13851535f, -0.15740815f, 
    0.02588640f, 0.05947678f, 0.03961473f, 0.03501391f, 0.09727010f, -0.02284960f, -0.17662558f, 0.12624753f, 
    0.05952837f, -0.01138956f, 0.07023679f, -0.08885840f, 0.04102741f, 0.13833563f, 0.20316462f, -0.03594084f, 
    0.09417810f, -0.07552003f, -0.06104812f, 0.01878425f, 0.02255487f, 0.12428621f, 0.33056501f, 0.15397340f, 
    -0.07647385f, 0.00410976f, -0.14355284f, -0.00315371f, -0.03693370f, 0.09592204f, 0.06500511f, 0.17637067f, 
    -0.35858855f, 0.00345774f, 0.14330684f, 0.12349287f, -0.12565823f, -0.04552885f, 0.07699414f, 0.28750706f, 
    -0.05108261f, -0.03305932f, -0.15563717f, 0.02615514f, 0.00075972f, 0.11185592f, 0.14227213f, -0.10752822f, 
    -0.01485824f, 0.17601593f, 0.06920879f, 0.03634268f, 0.20984975f, 0.07627153f, 0.01753746f, 0.19543603f, 
    0.40608248f, -0.19697013f, 0.01611617f, 0.06024360f, -0.02459758f, -0.08539304f, 0.03046873f, 0.06454712f, 
    0.02847785f, -0.17319381f, -0.15373892f, -0.17679195f, -0.04653757f, -0.01933487f, 0.11042217f, -0.09588665f, 
    0.20714262f, 0.20929317f, 0.02454438f, -0.10993166f, -0.20125405f, 0.07905897f, 0.05606610f, 0.11169269f, 
    -0.49703255f, -0.06986404f, -0.19267078f, -0.25055099f, 0.08366890f, -0.16059135f, 0.15982474f, -0.04089061f, 
    0.05457973f, -0.07991102f, -0.10100301f, -0.07015717f, 0.04126566f, -0.09683448f, -0.07775825f, -0.00158865f, 
    0.11895186f, 0.15141277f, 0.02276597f, 0.07422660f, 0.24177460f, 0.09591737f, 0.22429708f, 0.19152421f, 
    0.09171011f, -0.01494638f, -0.02751314f, 0.18170999f, -0.01849327f, 0.09232584f, 0.00100115f, 0.19181214f, 
    0.10947490f, -0.09006359f, 0.02033864f, -0.16945042f, 0.21185640f, -0.19597091f, 0.04007716f, 0.27453932f, 
    -0.14115775f, -0.00099160f, -0.01912627f, -0.05535774f, 0.12850764f, -0.07504591f, 0.15367313f, -0.09358723f, 
    -0.07910072f, -0.08488470f, 0.08006989f, -0.05160390f, -0.17822351f, 0.07007398f, -0.02504468f, 0.16523428f, 
    0.23595446f, 0.01115309f, 0.17848966f, 0.04166336f, -0.24806999f, 0.37978342f, -0.26181310f, 0.27280390f, 
    0.10845078f, 0.15603130f, 0.15690063f, 0.05608454f, 0.01504825f, -0.06714746f, 0.05267396f, -0.10748414f, 
    0.03796022f, 0.10482072f, -0.09208915f, 0.15001717f, 0.01077003f, -0.01367799f, 0.03576805f, -0.05006457f, 
    0.04907267f, -0.04427012f, 0.06681376f, 0.01552020f, 0.09988068f, 0.03274126f, 0.26534602f, -0.06981291f, 
    0.11003586f, -0.01892695f, 0.04588131f, 0.07574236f, -0.00440211f, 0.08895525f, 0.05780138f, -0.00291304f, 
    0.01421722f, 0.11375523f, -0.05121485f, -0.01929620f, 0.06236564f, 0.01968857f, 0.02261263f, 0.18339258f, 
    0.21790363f, -0.09982245f, 0.15225735f, 0.19206268f, 0.02896747f, -0.04015713f, 0.06476353f, -0.03258318f, 
    -0.05133038f, 0.01053355f, 0.00712301f, 0.01955199f, 0.18918416f, 0.01277767f, 0.06375479f, -0.06491722f, 
    -0.19218755f, -0.06491230f, -0.30382702f, 0.05140388f, 0.12098128f, 0.05688423f, 0.10684238f, 0.13283576f, 
    0.02095241f, -0.13635693f, 0.02585275f, 0.04849390f, 0.03957913f, -0.21019748f, -0.04989626f, -0.41733530f, 
    -0.01836484f, 0.05097537f, 0.00559670f, 0.20204233f, 0.07738952f, 0.00398953f, 0.00145673f, 0.15715939f, 
    -0.40695250f, -0.16048737f, -0.28764758f, -0.18173672f, 0.07579653f, -0.13681582f, 0.17568342f, 0.23195209f, 
    0.12397276f, -0.08400657f, -0.08571220f, 0.00967017f, -0.32930109f, 0.01266755f, -0.07091953f, -0.08193307f, 
    -0.04115508f, -0.09887353f, 0.06078835f, 0.07138609f, 0.00792476f, -0.10017026f, -0.08991238f, -0.00237015f, 
    0.19602536f, -0.22911157f, 0.10609819f, 0.27550623f, -0.17682341f, -0.04766404f, -0.15407585f, 0.03973001f, 
    -0.01919182f, -0.03849290f, 0.16445416f, 0.13731964f, -0.13564943f, 0.04825966f, -0.05065727f, -0.17275165f, 
    0.06765305f, 0.17407741f, 0.01589200f, -0.02718876f, -0.05164333f, -0.03958424f, -0.04797831f, 0.15748036f, 
    -0.02056036f, 0.12632178f, 0.14022966f, 0.08732419f, 0.04513140f, 0.00556263f, -0.00026214f, -0.27815351f, 
    0.02595766f, -0.01248787f, -0.02046059f, -0.08873273f, -0.08031956f, -0.07702904f, 0.03271400f, -0.26246414f, 
    -0.03106468f, -0.09653310f, -0.06269463f, 0.06227436f, -0.08432277f, -0.06099141f, 0.09159349f, -0.05332879f, 
    0.22964695f, -0.22535606f, 0.12747301f, -0.13921225f, 0.09269612f, 0.07808324f, 0.05258417f, 0.17218429f, 
    -0.01677590f, 0.06240383f, -0.11999700f, -0.09554610f, -0.35339931f, -0.13145696f, -0.20902535f, 0.01379626f, 
    -0.10612704f, 0.00060733f, 0.11748705f, 0.08059668f, 0.07425991f, 0.00609727f, 0.00038930f, 0.00652795f, 
    -0.08562700f, 0.02215682f, 0.02632501f, 0.04345114f, -0.03378220f, 0.01193093f, 0.07831064f, -0.14793123f, 
    0.07191829f, 0.26226023f, -0.10450251f, 0.03871755f, 0.02892224f, 0.15660225f, 0.10468262f, 0.24751240f, 
    -0.03890311f, -0.01232591f, 0.09286567f, 0.08770774f, 0.08698380f, -0.07858889f, 0.09154461f, 0.01218739f, 
    0.00901886f, -0.01838562f, 0.04347945f, -0.02163983f, -0.03249550f, -0.00677614f, 0.03649658f, 0.00807342f, 
    -0.05387020f, -0.01223944f, -0.00768711f, -0.00006903f, 0.00653356f, -0.05590361f, -0.04046292f, 0.00227615f, 
    0.00800508f, 0.03664907f, 0.03239649f, 0.02728267f, 0.04551231f, 0.00652042f, 0.01400474f, -0.05148561f, 
    -0.03919019f, -0.02573084f, -0.04337269f, -0.01500934f, -0.05141685f, -0.02740503f, -0.00546553f, 0.03512912f, 
    0.03681414f, -0.01640023f, -0.02368288f, -0.05536405f, -0.00839786f, 0.04417437f, 0.04183978f, -0.02691043f, 
    0.03614910f, -0.00412536f, 0.03545985f, -0.01756359f, -0.01605048f, -0.00287660f, -0.01210948f, -0.02127175f, 
    0.02130382f, 0.01047076f, 0.02135771f, -0.04612273f, 0.00202596f, -0.04857531f, 0.02470987f, -0.02577486f, 
    -0.03273647f, -0.01613417f, -0.00954916f, 0.04021731f, -0.04567009f, -0.05463074f, -0.04535465f, -0.04698328f, 
    -0.03676543f, 0.00318408f, 0.04249204f, -0.00766643f, 0.00189601f, -0.02692411f, -0.04211058f, 0.01557164f, 
    -0.03926972f, -0.01369722f, -0.00147679f, 0.00288124f, -0.01128487f, -0.03689951f, 0.04238511f, -0.00250256f, 
    0.00945932f, 0.03986781f, -0.02901176f, 0.01528276f, -0.04243533f, 0.02068128f, 0.03448591f, 0.02545284f, 
    0.03966538f, -0.01597584f, 0.00340745f, -0.02921039f, -0.02177805f, -0.04792968f, -0.00677383f, 0.00192770f, 
    -0.02947323f, -0.05252308f, -0.02356650f, -0.03144869f, -0.01741442f, 0.03267683f, -0.00578022f, -0.05108178f, 
    0.02773364f, -0.00640742f, -0.05031187f, 0.03571137f, 0.02482436f, -0.03308160f, -0.03115021f, -0.04695873f, 
    -0.05114337f, 0.01388351f, -0.04053211f, 0.00400284f, 0.02151561f, -0.01671333f, -0.03368422f, 0.03652937f, 
    0.02303312f, -0.00045123f, 0.00785266f, -0.01059182f, -0.00532894f, -0.00907429f, -0.02911634f, -0.01655248f, 
    0.02197424f, -0.02515155f, 0.00360458f, 0.00803158f, 0.00149904f, 0.02080879f, 0.01555795f, 0.01118128f, 
    -0.00137309f, 0.02940805f, 0.00602674f, 0.03073964f, 0.02807306f, -0.02787767f, -0.01306619f, -0.04904377f, 
    -0.05065086f, -0.03714639f, 0.00002314f, -0.00424116f, -0.04518953f, 0.03253736f, -0.02381342f, -0.01411650f, 
    -0.03729904f, -0.04086608f, -0.03962452f, -0.02477347f, -0.04209793f, 0.00553131f, 0.03665813f, -0.03899172f, 
    0.04421244f, -0.03273991f, -0.02994646f, 0.03701727f, 0.01345345f, 0.02893345f, -0.05399609f, -0.01749604f, 
    0.02412233f, -0.03278900f, -0.03325247f, 0.02187427f, -0.02346465f, -0.04907963f, -0.00609097f, 0.04328211f, 
    0.01943570f, -0.00884458f, -0.00329448f, 0.03141511f, -0.01787061f, -0.01759084f, 0.04377971f, 0.00910753f, 
    0.03279703f, -0.02069387f, 0.01312146f, 0.02323053f, 0.01746798f, 0.03980035f, 0.01326489f, 0.02278138f, 
    0.04277502f, -0.03323908f, -0.00477937f, 0.01685650f, 0.00423250f, 0.01569132f, -0.04682337f, -0.00743440f, 
    0.03923519f, -0.03103528f, 0.03813233f, -0.03951950f, -0.02531672f, 0.00336612f, 0.00462754f, 0.02679339f, 
    -0.00704401f, -0.01137334f, -0.01349038f, -0.01581047f, 0.00147566f, 0.01088536f, 0.02780065f, 0.02548978f, 
    -0.02997227f, -0.05418707f, -0.05215892f, -0.03248909f, 0.04645244f, -0.04246881f, -0.04700097f, -0.02621553f, 
    0.04408418f, -0.01734691f, 0.03162162f, -0.03617324f, 0.01795813f, 0.01036825f, -0.02328481f, 0.00932964f, 
    0.02388295f, 0.02371508f, -0.04577201f, 0.02991045f, -0.02928721f, 0.01127287f, 0.03980544f, -0.00726735f, 
    -0.01789603f, -0.03844302f, 0.02757800f, 0.00228108f, 0.01498838f, 0.02870355f, 0.02185143f, -0.04771471f, 
    -0.02193341f, -0.03134537f, 0.00349859f, -0.02805463f, -0.00209878f, 0.02247289f, 0.04343896f, -0.01113224f, 
    0.00536585f, 0.01710324f, 0.01827451f, 0.00774795f, -0.04019075f, -0.04924408f, -0.01298722f, -0.02313013f, 
    -0.05203732f, -0.03167466f, -0.04984823f, 0.03432099f, -0.01514918f, 0.03729464f, 0.03016704f, 0.03419002f, 
    0.02885122f, -0.04196979f, -0.02522312f, -0.01485022f, -0.01762767f, -0.02518828f, -0.05568486f, -0.04043821f, 
    0.04467060f, 0.04419853f, -0.02670282f, -0.04523785f, 0.04002008f, -0.04536969f, -0.03453873f, 0.01088741f, 
    -0.00383102f, -0.00521811f, -0.02108356f, 0.02235210f, -0.03443754f, -0.00772046f, -0.01738262f, -0.04950775f, 
    -0.01077144f, 0.03565200f, -0.03540568f, 0.00673648f, 0.01869342f, 0.02026806f, 0.01851357f, -0.00013127f, 
    -0.04137900f, -0.02942198f, -0.03466433f, -0.05547238f, 0.02770475f, 0.02081745f, 0.03255165f, -0.05182519f, 
    0.02875654f, -0.05371044f, -0.01808435f, 0.01246267f, 0.02673032f, 0.02091361f, -0.02653546f, -0.05478525f, 
    -0.04708781f, -0.02369792f, -0.05481882f, 0.01084998f, 0.01865820f, -0.05606823f, 0.02454473f, -0.00548168f, 
    0.03467091f, -0.04237433f, -0.04965138f, -0.04121456f, 0.04300496f, 0.03463575f, -0.03735357f, -0.02308340f, 
    -0.00877079f, -0.02956040f, -0.04810498f, 0.03286390f, -0.00670151f, 0.02397821f, 0.02769871f, -0.03332026f, 
    0.03401541f, 0.02617229f, -0.05416998f, -0.02425665f, -0.04857139f, 0.04609651f, 0.00226409f, -0.02070841f, 
    -0.04523820f, -0.04852762f, -0.03292448f, 0.03563809f, -0.01919999f, 0.02678323f, -0.03715405f, 0.03992498f, 
    0.04032663f, -0.04214462f, -0.03698920f, -0.02338351f, 0.02108338f, 0.03428410f, 0.02872981f, 0.02916832f, 
    -0.00760462f, -0.00960669f, -0.02992333f, -0.04985913f, -0.01391967f, -0.04599685f, -0.00025748f, -0.02698997f, 
    -0.04265011f, -0.01234292f, -0.05462708f, -0.02831411f, 0.01511085f, 0.01601901f, -0.02608681f, -0.04986980f, 
    0.36742088f, 0.40492070f, -0.29574999f, -0.03171034f, -0.00533833f, 0.07686009f, -0.09603168f, 0.07122866f, 
    0.06884411f, -0.02310022f, 0.02679081f, -0.17630140f, 0.08135733f, 0.01912072f, -0.01973921f, 0.01859863f, 
    -0.00028605f, -0.10046464f, 0.08103901f, 0.08596207f, 0.09950327f, -0.07481075f, -0.01576374f, -0.16339053f, 
    0.25620279f, 0.06955522f, 0.28293657f, 0.06780340f, -0.08333988f, -0.02022681f, -0.11256076f, -0.06481847f, 
    -0.02249892f, -0.05655871f, 0.01683615f, -0.01689366f, -0.13245381f, 0.10215395f, 0.12093499f, -0.13530593f, 
    -0.01606159f, -0.00087952f, 0.08312315f, -0.02526887f, 0.18061531f, -0.04591504f, -0.07695917f, 0.05274688f, 
    -0.09104222f, -0.10853241f, 0.07254697f, -0.11011983f, 0.18015371f, 0.08827031f, 0.12493847f, 0.13358670f, 
    0.11070746f, 0.17038031f, 0.18121749f, 0.03644128f, -0.12149264f, 0.06145389f, 0.11549577f, 0.05095082f, 
    -0.05970081f, -0.03156742f, -0.01224095f, -0.06434816f, -0.06362827f, 0.04103518f, 0.09971018f, 0.16432703f, 
    -0.26211175f, -0.02643169f, 0.20709771f, 0.19952412f, -0.02300630f, 0.13583772f, 0.10696288f, 0.22468272f, 
    0.00662460f, 0.04856316f, 0.21577281f, 0.01393106f, -0.12360901f, 0.09429478f, 0.21821739f, -0.00898564f, 
    0.26550376f, 0.16330783f, 0.20210129f, 0.12924232f, 0.32971802f, 0.30232388f, -0.03842451f, 0.20673268f, 
    0.21453719f, -0.07940315f, -0.02451367f, -0.02548156f, 0.01136712f, 0.05055149f, 0.02097159f, 0.07509559f, 
    0.05496814f, -0.14992754f, -0.19913276f, -0.14322846f, -0.22067863f, -0.06089897f, 0.17811134f, -0.23008133f, 
    0.18564713f, 0.25307196f, 0.12717041f, -0.13570273f, 0.00541970f, 0.00703922f, 0.03522619f, 0.05871591f, 
    -0.24121951f, -0.20502195f, -0.08275761f, -0.14739662f, 0.19011408f, 0.01363245f, 0.18768981f, 0.13603045f, 
    0.05624959f, -0.08927918f, -0.14839929f, -0.05739283f, -0.05876766f, -0.12612228f, -0.07844260f, -0.06856725f, 
    0.18288684f, 0.07007887f, 0.03634808f, 0.06233406f, 0.07433347f, 0.05685554f, 0.06980632f, 0.16087152f, 
    0.19948757f, -0.13019173f, 0.04384292f, 0.02123464f, 0.04270308f, 0.03657639f, 0.08605482f, -0.02218008f, 
    0.02743837f, -0.23490690f, 0.02558691f, 0.16312139f, 0.22225429f, -0.10057710f, 0.04014578f, 0.23364101f, 
    0.07089791f, -0.11310142f, -0.07201584f, 0.09472616f, 0.22386299f, 0.06931726f, 0.07131863f, 0.05593564f, 
    -0.30092669f, -0.15559360f, 0.13842167f, 0.14077546f, -0.00819874f, 0.01634883f, 0.08630015f, 0.18615247f, 
    0.09845082f, 0.17290333f, 0.14113905f, 0.00576357f, -0.07631011f, 0.13046099f, -0.21508686f, 0.25108272f, 
    0.24847604f, 0.32260197f, 0.29355064f, 0.04433013f, -0.20835425f, -0.00564061f, 0.08011270f, -0.03232448f, 
    0.08767407f, 0.00828214f, 0.01112426f, 0.19681866f, -0.05128063f, 0.02972809f, 0.02828319f, -0.03430988f, 
    0.00812185f, 0.02474510f, 0.09277955f, 0.13320795f, -0.02944433f, 0.22277799f, 0.15909155f, -0.15830643f, 
    0.03645879f, 0.07694139f, 0.05707876f, 0.07160831f, 0.02724296f, 0.18770063f, 0.05740258f, 0.09850834f, 
    0.09075135f, 0.16806258f, -0.24537560f, 0.16058795f, 0.08780997f, 0.06740399f, 0.07751275f, 0.07277987f, 
    0.05537023f, -0.06226645f, 0.01685496f, 0.06584968f, 0.08375415f, -0.03269230f, 0.08826361f, 0.04890418f, 
    -0.04917934f, -0.07946056f, -0.07363688f, -0.04523807f, 0.07889536f, 0.01212475f, -0.12957694f, -0.01815515f, 
    -0.33212107f, -0.20891064f, -0.27627158f, -0.06645826f, 0.24608460f, 0.09392504f, 0.06818653f, -0.05289197f, 
    -0.06609245f, -0.07950350f, 0.04548912f, 0.01287313f, 0.05161593f, 0.17373151f, -0.15201759f, -0.11937642f, 
    0.15962701f, 0.12370335f, 0.26064003f, 0.19734390f, 0.18162408f, 0.08487310f, -0.17973472f, 0.21113366f, 
    0.04578472f, 0.01476073f, -0.26465419f, 0.04705430f, 0.18996425f, -0.02371058f, 0.13626125f, 0.08467008f, 
    0.04827614f, 0.00443887f, -0.29692239f, -0.01451497f, -0.27464452f, -0.01386694f, 0.12672085f, -0.00226722f, 
    -0.01183389f, -0.07795241f, 0.09540196f, -0.07313372f, 0.07228208f, 0.11377598f, 0.05664959f, 0.03465682f, 
    0.00061173f, -0.16232060f, -0.04738969f, 0.19364513f, -0.10188167f, -0.03612528f, -0.02479526f, -0.00461869f, 
    0.05830383f, 0.03613348f, 0.15459263f, 0.21247144f, -0.25812122f, -0.09572908f, -0.03413958f, -0.12176051f, 
    0.15114467f, 0.25346515f, 0.05228970f, -0.03430933f, 0.00568220f, 0.02573844f, 0.01344090f, 0.00214223f, 
    -0.15521243f, 0.07335192f, -0.06925090f, 0.02241098f, -0.03672090f, -0.03993433f, 0.04504506f, -0.16118023f, 
    -0.07713524f, 0.00340213f, -0.07372125f, -0.01205346f, -0.01390322f, -0.03129031f, 0.05222182f, -0.16382371f, 
    -0.11366205f, 0.08321390f, -0.01537403f, 0.19823371f, 0.07753503f, -0.00414025f, 0.00422854f, -0.36801618f, 
    0.18428862f, -0.05244135f, 0.05488134f, -0.13077018f, 0.08743186f, 0.27917591f, 0.10391871f, 0.07905184f, 
    -0.01092376f, -0.05324134f, -0.09160333f, 0.02309256f, -0.24428843f, -0.15913975f, -0.03284891f, -0.07116448f, 
    -0.09447452f, -0.07028013f, 0.02610172f, 0.00417404f, -0.02266327f, -0.04028030f, 0.00864302f, 0.06889829f, 
    -0.16465259f, -0.00669190f, 0.00089684f, 0.10980289f, -0.07320171f, 0.14361784f, -0.01499915f, -0.04188250f, 
    0.06879745f, 0.22695896f, 0.14942746f, 0.15879713f, 0.19410300f, 0.06082423f, 0.13447459f, 0.16800354f, 
    0.01765735f, 0.05158379f, 0.10065661f, 0.04996705f, 0.06644169f, 0.07936301f, -0.00751128f, -0.07642867f, 
    -0.06278234f, 0.25261417f, 0.31834072f, 0.32846361f, 0.13826646f, -0.03453012f, 0.17496701f, -0.03080293f, 
    0.05273920f, 0.16576768f, 0.08861758f, 0.12298366f, -0.08088978f, 0.10494979f, -0.01650152f, -0.14570671f, 
    -0.07065083f, -0.03385372f, -0.06277428f, 0.03736001f, 0.06034544f, 0.01759868f, 0.00396784f, 0.04829067f, 
    -0.29840010f, 0.24522620f, -0.15893385f, -0.16616164f, -0.13921638f, -0.04973222f, -0.03234627f, -0.07055946f, 
    0.05630448f, -0.01116882f, -0.02709172f, -0.01594825f, -0.24110471f, 0.00009579f, -0.07726966f, 0.23353836f, 
    -0.05906102f, -0.00414233f, -0.04408022f, 0.02690265f, 0.12460355f, 0.12602195f, -0.00901041f, 0.21514058f, 
    0.03904966f, -0.06053414f, -0.26410517f, 0.05732435f, 0.00344417f, 0.09094483f, 0.02768034f, 0.07788219f, 
    -0.00017086f, 0.09773639f, -0.03436358f, 0.08030433f, 0.19297652f, -0.05117337f, 0.02689133f, -0.14390320f, 
    -0.23758070f, -0.01985995f, -0.06103835f, 0.06790738f, 0.03153798f, -0.02710639f, 0.11193856f, -0.03938659f, 
    0.01035973f, 0.03575071f, 0.03512866f, 0.04882966f, -0.00161073f, 0.02878407f, 0.10006056f, 0.12218741f, 
    0.01293821f, 0.07471051f, 0.11579179f, 0.04516739f, -0.08944803f, -0.06140386f, 0.05680836f, 0.29656303f, 
    0.11130449f, -0.15101765f, 0.07697488f, 0.19488397f, -0.07058702f, 0.03327233f, -0.02258430f, -0.13434285f, 
    -0.08417193f, 0.36902925f, 0.01464877f, -0.13787600f, -0.00379447f, 0.03248211f, -0.05280196f, 0.08699985f, 
    0.15969853f, 0.19109020f, 0.05378769f, 0.03857551f, -0.42664632f, -0.06239260f, 0.10859080f, 0.20277074f, 
    -0.02950673f, 0.13485597f, -0.11364377f, 0.03770230f, -0.06320339f, -0.00242679f, -0.07318889f, -0.07065208f, 
    -0.08577142f, 0.00594117f, 0.39110288f, -0.09906197f, 0.05948161f, 0.09246720f, -0.04925829f, 0.08192984f, 
    -0.02161632f, -0.07123822f, -0.02648352f, 0.05150927f, -0.06123428f, -0.09650777f, -0.04516234f, -0.00556665f, 
    -0.09853218f, -0.03536812f, 0.11852410f, 0.00088236f, -0.11085100f, 0.09000380f, -0.13617828f, 0.00554816f, 
    0.04871882f, -0.15657915f, 0.22506747f, -0.24305122f, -0.03235219f, 0.02525008f, 0.02753058f, -0.05510706f, 
    -0.06976761f, 0.01834036f, 0.02576889f, 0.08223179f, 0.23524076f, -0.05343810f, -0.42880133f, -0.13062589f, 
    -0.02406779f, -0.07736965f, 0.06030913f, -0.04034127f, 0.04728522f, 0.10519450f, 0.16742902f, 0.07374335f, 
    -0.18854102f, 0.01062094f, -0.01966168f, 0.22190647f, 0.00893599f, -0.14304043f, -0.03388458f, -0.00049812f, 
    0.04642492f, 0.06232456f, 0.07493179f, 0.04183603f, 0.67996091f, -0.13597471f, 0.31371856f, -0.08195177f, 
    0.10599104f, 0.01566157f, 0.10832712f, 0.05494066f, -0.11124837f, 0.01488747f, 0.06504308f, 0.09093288f, 
    0.40845546f, 0.19129503f, 0.13822010f, -0.05180449f, -0.15172476f, -0.06812413f, 0.06090355f, 0.02517404f, 
    -0.11237004f, 0.06064552f, 0.01985200f, -0.01642148f, -0.45899561f, -0.05761372f, -0.04785104f, 0.42781749f, 
    -0.04998988f, 0.09681097f, -0.05756942f, -0.16208011f, 0.03222369f, 0.05475914f, 0.04399855f, 0.01863475f, 
    0.07620586f, -0.12447231f, 0.19833294f, 0.31642172f, 0.09838057f, 0.10138961f, 0.02182092f, 0.18410739f, 
    0.02175005f, -0.07162874f, 0.11244642f, -0.17935652f, 0.02109164f, -0.14755359f, 0.27671638f, 0.08059642f, 
    -0.12860298f, -0.07805387f, 0.05034604f, -0.06476855f, -0.06824212f, 0.00876573f, -0.09550363f, -0.04730141f, 
    0.00939501f, -0.04712177f, 0.35487515f, -0.08013707f, -0.03390314f, -0.02177757f, -0.11509408f, -0.00134338f, 
    -0.03174793f, -0.04594223f, 0.05883104f, -0.01413446f, -0.36820766f, 0.38156188f, 0.15474348f, 0.13222976f, 
    0.05613312f, 0.29201859f, -0.08348496f, 0.17978913f, -0.03706225f, -0.03774019f, 0.06324848f, 0.07346258f, 
    0.47493938f, -0.03508931f, 0.08191269f, 0.10020217f, -0.01192875f, -0.08194522f, 0.13763726f, 0.10256651f, 
    -0.03102383f, -0.03433192f, 0.00693581f, -0.00405136f, -0.12810574f, -0.31482396f, 0.01971076f, 0.28956521f, 
    0.01150003f, -0.17252694f, 0.05761358f, -0.11930818f, 0.04258926f, 0.07585640f, 0.04588880f, 0.07105365f, 
    -0.17167610f, 0.21041554f, 0.28452665f, -0.19057654f, 0.02313574f, -0.01651791f, -0.13244441f, -0.02919904f, 
    -0.06996016f, 0.03264462f, 0.15560904f, 0.05627674f, -0.13410375f, -0.19890803f, 0.00173262f, 0.01683173f, 
    -0.06231826f, -0.00476990f, 0.00590973f, 0.13754599f, 0.00533786f, -0.05427100f, 0.02252742f, -0.01530772f, 
    -0.21611726f, -0.18055421f, 0.08458684f, 0.11660077f, 0.03892327f, 0.03694157f, -0.01114372f, -0.08034075f, 
    0.12418746f, -0.02190395f, 0.11715619f, 0.03399237f, -0.19290490f, -0.04428449f, -0.00721590f, 0.02447902f, 
    -0.06522220f, -0.04973166f, 0.00671935f, 0.18884499f, -0.05528287f, -0.00052122f, -0.15542157f, -0.10860733f, 
    0.18708748f, 0.11921851f, 0.02379054f, 0.19535372f, 0.05089843f, 0.14630462f, -0.07116432f, -0.01170166f, 
    -0.04233111f, -0.04324484f, -0.10204779f, -0.03765994f, -0.06511082f, -0.21349363f, 0.04478753f, -0.22118607f, 
    -0.01869485f, -0.04671734f, -0.17297189f, -0.13306668f, -0.15177362f, -0.00704338f, 0.00724571f, -0.03666295f, 
    0.11425570f, -0.02816020f, -0.22218786f, -0.19231024f, -0.09225994f, -0.02072762f, -0.00507059f, 0.15740027f, 
    0.03721702f, 0.05015210f, 0.02590360f, -0.00029574f, 0.13111436f, 0.09815249f, 0.12236863f, -0.12672861f, 
    0.05830102f, -0.05114364f, 0.10138769f, -0.01840135f, 0.27405211f, 0.26977235f, 0.22346653f, 0.12600033f, 
    0.02265458f, 0.00699839f, 0.00451982f, -0.05670496f, -0.02942375f, 0.04202356f, -0.05583948f, -0.03167627f, 
    -0.03025099f, 0.02565734f, -0.00666428f, 0.01828752f, 0.03328001f, 0.03756491f, -0.04247427f, 0.03765936f, 
    0.00266674f, 0.00926577f, -0.02120384f, -0.02719627f, -0.01405855f, -0.01814166f, -0.00942991f, -0.04318780f, 
    -0.03904931f, 0.02032127f, -0.04303449f, -0.04279748f, -0.04978962f, 0.00141274f, -0.04399949f, -0.01330590f, 
    0.03453774f, 0.03784644f, 0.03895921f, -0.04056266f, -0.05966658f, -0.02878175f, -0.05489200f, -0.04710409f, 
    -0.00631216f, 0.04109321f, 0.02326074f, 0.02643225f, 0.02731638f, -0.01404636f, -0.01150011f, 0.00091739f, 
    0.01608725f, -0.01724632f, 0.01063121f, -0.00738491f, -0.03845890f, -0.03372315f, -0.03004348f, -0.04528454f, 
    -0.02631360f, -0.04648688f, -0.02881165f, -0.00525971f, -0.00250667f, -0.00663869f, 0.04261752f, -0.01084519f, 
    0.02219119f, -0.04591793f, -0.05177967f, -0.04362925f, -0.02364110f, 0.00491698f, -0.00962065f, 0.00983556f, 
    -0.04982741f, 0.03878795f, -0.05110782f, 0.03335693f, -0.02902606f, 0.01339191f, -0.04822442f, -0.00167626f, 
    0.01747183f, 0.02565220f, -0.01155430f, 0.02626188f, -0.03357030f, 0.03684505f, 0.00092519f, 0.01010804f, 
    0.01098471f, -0.03372865f, -0.02911489f, 0.00550952f, 0.03297113f, -0.05412740f, 0.02847120f, -0.00437795f, 
    0.03675199f, -0.03832385f, -0.04958211f, -0.00281750f, -0.02086334f, 0.01553819f, 0.02122851f, -0.02754825f, 
    -0.03799914f, -0.03250637f, -0.04569104f, 0.00497861f, 0.03907636f, -0.00533115f, -0.02123259f, 0.00741951f, 
    0.00378026f, 0.02018359f, -0.01601438f, 0.03990028f, -0.03541715f, 0.02105891f, -0.02231243f, -0.04251866f, 
    -0.03489656f, 0.01252453f, -0.04986418f, -0.02116333f, 0.03015158f, -0.02186250f, -0.01139397f, -0.03650359f, 
    -0.01877514f, 0.03414290f, 0.03108329f, 0.02331868f, 0.02488624f, -0.05147558f, -0.05143582f, -0.00825540f, 
    -0.03821431f, 0.02209006f, -0.01990759f, 0.02014282f, -0.01413238f, 0.03166486f, 0.04404038f, 0.04248120f, 
    0.03344389f, -0.04825011f, 0.00156306f, -0.00880868f, 0.04603524f, -0.02983824f, 0.02887989f, -0.02726617f, 
    -0.01142948f, -0.01753058f, -0.04364969f, -0.02524611f, -0.04099286f, -0.00361478f, 0.00883070f, 0.00504365f, 
    0.00913497f, 0.00326416f, -0.04108850f, 0.01906711f, -0.02769874f, 0.01463913f, 0.00957166f, -0.01064488f, 
    0.00570688f, 0.04624692f, -0.02560038f, 0.02538185f, -0.04511672f, -0.03687136f, -0.02891701f, -0.02464305f, 
    -0.05065394f, -0.00502732f, 0.02696560f, 0.03317305f, 0.02324851f, -0.01988719f, -0.01688002f, -0.00058606f, 
    -0.02402340f, 0.02977441f, 0.02221345f, 0.00047793f, -0.02390388f, 0.00942975f, -0.00395116f, 0.03626885f, 
    -0.00389748f, -0.03632297f, 0.01659259f, 0.00527780f, 0.03021707f, -0.01376070f, -0.01457503f, 0.03628563f, 
    -0.00621814f, 0.03437046f, -0.04191624f, -0.00376327f, -0.02016821f, -0.06017660f, -0.01136242f, -0.04010173f, 
    -0.03233214f, 0.01948734f, -0.03763478f, 0.02494653f, -0.00554924f, -0.02640898f, 0.04602138f, 0.02382730f, 
    -0.03590575f, 0.01932532f, 0.00063890f, -0.00959160f, 0.00618463f, -0.00898139f, -0.00553383f, 0.00430267f, 
    0.00245293f, 0.00074612f, -0.02826957f, 0.04300084f, -0.00914556f, 0.03167260f, -0.04025932f, -0.05694480f, 
    0.00660291f, -0.02781853f, -0.05761489f, -0.01413793f, -0.04234653f, -0.00125267f, 0.01092653f, -0.03795245f, 
    -0.00008632f, 0.03270210f, 0.02845764f, -0.02178587f, 0.00416477f, -0.03827778f, -0.04703948f, -0.01181760f, 
    -0.00279491f, -0.03359723f, 0.03307600f, -0.03908594f, 0.00073514f, -0.01471801f, -0.00724303f, 0.02873748f, 
    0.03490450f, -0.02659419f, 0.02292648f, -0.04864394f, 0.00862678f, -0.05377239f, 0.02194379f, -0.01015756f, 
    -0.03847488f, 0.00616508f, -0.04008175f, -0.05823049f, 0.03832588f, 0.01111110f, -0.01671646f, -0.03447109f, 
    -0.05670571f, 0.02024710f, -0.02099556f, -0.03265487f, -0.01848408f, 0.02978834f, 0.01533685f, 0.02927431f, 
    0.01673695f, -0.04188435f, 0.03853687f, -0.04813449f, -0.00398837f, -0.04620593f, 0.02894907f, -0.00846942f, 
    -0.00555404f, -0.01686590f, -0.03236242f, -0.03501281f, 0.00927522f, -0.01322777f, -0.05074683f, -0.04827243f, 
    0.03673009f, 0.01826554f, -0.00255776f, 0.01497522f, -0.01210976f, 0.02624740f, -0.00809228f, 0.00652601f, 
    0.00702874f, -0.01273519f, -0.04875743f, -0.04269407f, 0.02161802f, -0.03545029f, -0.04835301f, 0.01403340f, 
    -0.04208975f, 0.00357084f, 0.01898929f, -0.05596726f, 0.03085567f, 0.03337343f, 0.01911952f, -0.02878504f, 
    -0.00673214f, -0.01424066f, -0.00571228f, 0.02960335f, 0.00197896f, -0.00653257f, 0.03739816f, -0.01326987f, 
    -0.00322275f, -0.02171175f, -0.01074766f, 0.03587371f, -0.04530367f, -0.03623950f, 0.03000346f, -0.03784754f, 
    0.00180868f, 0.02546589f, -0.05426693f, -0.02445171f, -0.03709590f, -0.00120687f, 0.03768114f, -0.05512014f, 
    -0.01607331f, 0.02252261f, 0.02982651f, -0.01072005f, 0.02444841f, -0.03239742f, 0.01834027f, 0.03627722f, 
    -0.00194665f, -0.04145382f, -0.03589889f, 0.03346537f, 0.03306842f, -0.04138209f, 0.03332838f, -0.00416190f, 
    0.02611855f, -0.02875351f, 0.00792903f, -0.03773978f, 0.02051204f, 0.03994652f, -0.03452533f, -0.05811002f, 
    0.01122002f, -0.01210998f, -0.05315146f, -0.04149869f, -0.03411900f, 0.00116058f, -0.05288749f, -0.03365668f, 
    -0.04443157f, 0.04559201f, 0.03202233f, -0.05392753f, 0.00527574f, -0.04693914f, -0.04402936f, 0.01670190f, 
    -0.09899633f, 0.02448905f, -0.04387490f, 0.13129362f, 0.07257430f, 0.14190614f, -0.06522028f, -0.05771237f, 
    -0.07736348f, -0.03399789f, 0.10700591f, 0.07199784f, -0.19154568f, -0.16012822f, -0.04476330f, 0.03572305f, 
    -0.00172358f, -0.00787655f, 0.12201784f, 0.16953799f, 0.14867313f, 0.06161476f, 0.00099002f, 0.10404018f, 
    0.17185067f, -0.06383573f, -0.03390280f, 0.18281439f, 0.12472651f, -0.01045707f, 0.00907388f, 0.08615077f, 
    -0.00381840f, 0.12649222f, 0.00626123f, -0.02641371f, 0.23567612f, 0.16827796f, 0.23529740f, -0.12483957f, 
    -0.01259907f, 0.08964719f, -0.15691297f, 0.01066148f, 0.17814840f, -0.12247182f, -0.06397527f, -0.01274533f, 
    0.13322410f, 0.13881315f, 0.42429402f, 0.04960887f, -0.03933825f, 0.11058939f, -0.02229496f, -0.05381274f, 
    0.14760439f, -0.20247854f, -0.09689485f, -0.02648533f, 0.09715354f, -0.45177183f, -0.11597773f, -0.02366258f, 
    0.17763558f, -0.08090969f, -0.11588962f, -0.05033078f, -0.14950950f, -0.01890195f, -0.04165175f, -0.16045073f, 
    0.36708358f, -0.27071372f, 0.21066161f, -0.02702109f, 0.08716431f, -0.13952699f, 0.07534848f, 0.18103641f, 
    -0.03918577f, -0.18916000f, 0.06696554f, 0.03826312f, 0.11833159f, 0.01334090f, 0.08594623f, -0.34803706f, 
    -0.06952744f, 0.17481931f, -0.13764702f, -0.08393434f, 0.10400324f, -0.03990805f, 0.02915550f, 0.04804891f, 
    0.00030807f, -0.41262376f, -0.16475797f, -0.01109544f, 0.05906826f, -0.14231935f, 0.04287358f, -0.04293894f, 
    0.16809557f, 0.14263000f, -0.05794524f, 0.05205144f, 0.52401459f, 0.23573214f, 0.13929856f, 0.07393132f, 
    0.24721314f, 0.20584390f, 0.15529449f, -0.02469851f, -0.07799835f, 0.12747057f, -0.03523185f, 0.00321634f, 
    0.01380557f, 0.57373708f, -0.38244644f, 0.11205646f, 0.16081841f, 0.07674902f, -0.01674361f, 0.14078853f, 
    0.19619811f, -0.00509660f, -0.03601573f, -0.10383166f, -0.02342424f, -0.09833162f, -0.00338713f, -0.08952460f, 
    0.06889058f, 0.12248243f, -0.08812194f, 0.14343430f, 0.07086574f, -0.32430574f, 0.05088887f, -0.17796418f, 
    -0.05534134f, 0.08369213f, -0.18051258f, 0.08743691f, 0.09790337f, 0.21902555f, -0.19944687f, 0.18208303f, 
    0.24066532f, -0.08648658f, -0.00554120f, -0.00139629f, -0.28552505f, -0.28656778f, 0.35542566f, 0.37816256f, 
    -0.03377043f, -0.02004211f, 0.02672530f, -0.11352608f, -0.11150239f, 0.14168084f, -0.07806508f, -0.08272070f, 
    0.36082634f, -0.06459729f, 0.16885477f, 0.11342403f, 0.04986679f, -0.07354768f, 0.08836107f, -0.03051190f, 
    0.05583317f, -0.00585660f, -0.01191003f, 0.01323729f, -0.14589846f, 0.29131928f, -0.24801716f, 0.26027977f, 
    -0.07830016f, 0.03436312f, -0.15416719f, 0.02347835f, 0.20705104f, -0.05842137f, 0.22736871f, -0.05643344f, 
    -0.22603706f, -0.15041746f, -0.17626655f, 0.01524036f, 0.09312593f, -0.00689158f, 0.01028816f, -0.12340726f, 
    0.02132633f, -0.12447544f, -0.09430649f, 0.00180819f, 0.29292810f, 0.28987575f, 0.39193469f, 0.06829741f, 
    -0.05453165f, -0.00963532f, 0.03612148f, 0.07941515f, 0.06501647f, 0.04726933f, -0.04343057f, 0.03617281f, 
    -0.25126174f, 0.16376473f, -0.11766069f, -0.24595357f, 0.10379656f, 0.19300242f, -0.07002112f, -0.06185818f, 
    0.10001316f, -0.00736837f, -0.08074462f, -0.08176316f, 0.06656118f, 0.41054612f, -0.16271177f, 0.05609372f, 
    0.12416514f, -0.03777312f, 0.05539086f, -0.00596945f, 0.19322562f, 0.02252601f, -0.00815244f, 0.02834662f, 
    0.06676553f, 0.12017161f, 0.14063269f, 0.34873399f, 0.19529194f, -0.03260047f, 0.03002535f, 0.26297179f, 
    -0.01700087f, -0.10795352f, -0.01960327f, -0.22045633f, 0.03974660f, -0.02408694f, 0.12604156f, -0.48111185f, 
    0.11901145f, 0.02192730f, 0.08745756f, 0.03985093f, 0.03338505f, 0.00237651f, -0.03466675f, -0.06083233f, 
    -0.46169245f, 0.15518329f, -0.09488212f, -0.07622840f, 0.28351977f, 0.08585111f, 0.12828271f, 0.16174161f, 
    0.05566446f, -0.05899774f, 0.12107331f, 0.28260523f, -0.24512090f, -0.01973762f, 0.08182885f, -0.25733304f, 
    -0.01617722f, -0.00516102f, -0.00371451f, 0.14506307f, 0.10386108f, -0.06111260f, 0.13134350f, 0.35317719f, 
    0.06845388f, -0.07527401f, -0.17640524f, -0.16535278f, 0.14011735f, -0.00511221f, -0.08629705f, 0.01927632f, 
    -0.03895922f, 0.07352690f, -0.13930625f, -0.21078187f, 0.35885414f, 0.36706549f, 0.12502240f, 0.28596139f, 
    0.07656285f, 0.06369424f, 0.10713045f, 0.04229759f, 0.08383255f, -0.00527072f, -0.03576166f, 0.00398016f, 
    0.46254474f, 0.37682539f, 0.26779670f, 0.13280995f, 0.26077464f, 0.02885003f, 0.03049311f, -0.10794039f, 
    0.08564936f, -0.05264336f, 0.07234121f, 0.01197344f, 0.04959193f, 0.13868819f, 0.00100034f, -0.03733920f, 
    0.09287875f, 0.07364978f, 0.16917211f, 0.05111812f, -0.03270249f, 0.04123802f, 0.22046213f, 0.33731276f, 
    0.18013179f, -0.40250406f, 0.11499338f, -0.10285584f, -0.01732801f, -0.12878263f, 0.01647746f, 0.16228648f, 
    0.19246189f, -0.04431073f, -0.12367112f, 0.03636756f, -0.14937595f, 0.15961073f, 0.03063601f, 0.08180596f, 
    -0.12562552f, 0.19244002f, 0.17430653f, 0.09772798f, -0.07921410f, -0.06444833f, -0.09081885f, -0.05178848f, 
    -0.15949313f, -0.19934876f, 0.06805024f, 0.09583411f, -0.06839012f, -0.08910468f, -0.08033832f, -0.20763075f, 
    -0.16000512f, -0.02051684f, -0.26777610f, -0.08670919f, -0.10850109f, -0.03092359f, -0.08905101f, 0.08895444f, 
    -0.09480316f, 0.10895103f, -0.05751730f, -0.05533731f, 0.16035405f, -0.10486762f, 0.09711387f, 0.01549993f, 
    -0.03815766f, 0.03126151f, 0.01549924f, 0.03108731f, 0.04256650f, -0.04460738f, 0.02374443f, 0.01843703f, 
    -0.02928410f, -0.03316623f, -0.01986635f, -0.00164491f, -0.02327325f, -0.00566529f, 0.00256881f, -0.00737658f, 
    -0.03500120f, 0.04083826f, -0.00943849f, -0.00438452f, 0.02074045f, -0.03307074f, 0.01619597f, -0.01331940f, 
    -0.02213105f, 0.01426104f, 0.03296081f, -0.02019422f, 0.00123952f, -0.03485875f, 0.02287189f, -0.00999848f, 
    0.01553653f, -0.01178706f, -0.04532582f, -0.01659826f, -0.04010442f, -0.04404489f, 0.05006417f, 0.01438233f, 
    0.00163905f, 0.02424624f, 0.01348607f, -0.00184014f, 0.00433867f, -0.01731748f, 0.03755075f, -0.01845746f, 
    -0.02086990f, -0.00777046f, 0.02507416f, 0.02782572f, -0.05009214f, -0.02474123f, -0.02920054f, -0.00329369f, 
    -0.02678126f, 0.03771107f, 0.01681962f, -0.04930395f, -0.02380974f, -0.04570883f, -0.00507194f, 0.03436206f, 
    0.03565723f, -0.00526052f, 0.02385789f, 0.02424897f, -0.04700852f, -0.03933859f, -0.00246573f, -0.00590617f, 
    0.00383767f, -0.03289230f, 0.00032148f, 0.02107250f, 0.04986532f, 0.01862635f, 0.00120879f, 0.00080998f, 
    -0.01900349f, -0.04064823f, 0.01805411f, -0.04198310f, 0.01463098f, 0.00593702f, 0.01953821f, -0.00223942f, 
    -0.03711934f, -0.05022357f, -0.00715727f, 0.01051992f, 0.00304863f, 0.01297259f, 0.02148418f, -0.04717278f, 
    -0.04358092f, -0.03749856f, 0.01017174f, -0.04822120f, -0.03587973f, -0.00699412f, 0.01660869f, 0.01421058f, 
    -0.03681136f, -0.04196209f, -0.00879406f, -0.04624569f, -0.02906613f, 0.03851052f, 0.04202545f, 0.00173039f, 
    -0.04326349f, 0.01981505f, 0.04175536f, 0.03891889f, -0.00566419f, -0.03710627f, -0.02445010f, -0.03941849f, 
    0.02208958f, 0.01662025f, -0.02078849f, -0.00464559f, 0.00976316f, -0.04831737f, 0.00078783f, -0.03398049f, 
    -0.04255299f, -0.04810941f, 0.05000037f, -0.01552704f, -0.01915567f, -0.01864853f, -0.00931191f, -0.04101902f, 
    0.04624223f, 0.00902724f, 0.02226184f, -0.04193998f, 0.00165193f, -0.01425136f, 0.00900940f, 0.00707424f, 
    0.04744988f, 0.02740778f, -0.01057835f, 0.01225880f, -0.00952523f, 0.04936359f, -0.04168006f, -0.02041119f, 
    0.01411329f, 0.03790088f, -0.02130068f, 0.03445442f, 0.03946915f, -0.05078258f, 0.04843248f, -0.01465191f, 
    0.02755861f, 0.03725855f, 0.02264433f, -0.01000031f, -0.01966746f, 0.02494551f, 0.00176604f, -0.01757826f, 
    -0.05035030f, -0.04692084f, -0.02349614f, -0.04809063f, -0.02866594f, -0.04556513f, -0.02444539f, -0.04275804f, 
    0.00090775f, 0.00190070f, -0.00042686f, 0.04158429f, -0.04872253f, -0.03785306f, 0.04263152f, -0.00895341f, 
    -0.04074868f, 0.00102381f, 0.00551701f, 0.01136719f, -0.03292198f, 0.03915859f, -0.02312627f, -0.04694536f, 
    -0.04335363f, 0.04107800f, -0.00558064f, -0.00464642f, 0.03427960f, 0.04647203f, 0.03814295f, -0.00250459f, 
    0.01624393f, -0.04846288f, -0.02556310f, 0.03965655f, 0.02524188f, -0.00373117f, -0.02818868f, 0.04102790f, 
    0.03267632f, -0.03037065f, -0.03499271f, -0.03021079f, -0.04624372f, -0.04201678f, -0.00790248f, -0.00208413f, 
    -0.04374886f, 0.00786049f, 0.00229605f, 0.04626387f, -0.01503579f, -0.02020212f, -0.04923731f, 0.02755162f, 
    -0.03065895f, -0.00230929f, -0.01014248f, -0.04062073f, -0.02548120f, 0.03563185f, 0.02493397f, 0.01035356f, 
    0.01663772f, 0.00626537f, 0.03132225f, -0.01592002f, -0.01748059f, -0.01794324f, 0.03696149f, 0.02845818f, 
    0.03291211f, -0.02190420f, -0.00647338f, -0.01014689f, -0.00048711f, 0.00030863f, 0.03916869f, -0.02862008f, 
    -0.02959961f, -0.03853648f, 0.00068846f, 0.03541830f, -0.04639836f, -0.03561749f, -0.04563885f, -0.02083561f, 
    0.03174333f, 0.01018414f, 0.04310992f, -0.01611351f, -0.03613528f, -0.04266126f, 0.00728469f, 0.02017570f, 
    -0.04237771f, 0.04139818f, -0.00501521f, -0.03043531f, 0.00080059f, -0.04246191f, -0.03185448f, 0.04489327f, 
    -0.01075227f, 0.02923783f, 0.02929534f, -0.04792393f, 0.00242447f, -0.00204392f, -0.03209155f, -0.04242337f, 
    -0.01168478f, 0.04530719f, 0.00668103f, -0.04399130f, 0.00260868f, 0.03425406f, 0.00723597f, -0.03037926f, 
    0.01145883f, 0.04354150f, -0.02528852f, -0.04670347f, -0.03925470f, -0.03364865f, 0.01999649f, -0.00607884f, 
    0.01345119f, 0.03000633f, 0.04080966f, -0.03167333f, 0.03963449f, -0.02343149f, 0.00351945f, -0.02963911f, 
    0.04149619f, 0.01402810f, -0.02433152f, 0.02078050f, 0.03717572f, -0.02234078f, -0.04719616f, -0.00306894f, 
    -0.03934421f, -0.02265114f, -0.01848092f, 0.03571497f, 0.04715887f, 0.03397911f, -0.00084187f, -0.02221128f, 
    -0.02404137f, -0.01866156f, 0.00929457f, -0.03666757f, 0.04440597f, 0.02167497f, 0.04359413f, 0.03632013f, 
    -0.02695587f, -0.02972237f, -0.05050034f, -0.00580199f, -0.04932471f, 0.01896446f, 0.04205817f, -0.04424881f, 
    -0.02298791f, 0.01747930f, -0.00113527f, 0.04443651f, 0.01646219f, 0.02862709f, -0.03469177f, -0.04724988f, 
    -0.04238714f, 0.03121231f, -0.03196329f, -0.03078140f, -0.01411034f, 0.01853037f, 0.01389936f, -0.01581406f, 
    0.04191152f, -0.01930856f, 0.02297641f, 0.00359843f, -0.03398731f, 0.03012121f, -0.05095548f, -0.01940280f, 
    0.04323985f, -0.02466185f, -0.02641707f, -0.02403668f, -0.04396619f, 0.04143065f, 0.04009837f, -0.00601222f, 
    0.01280541f, 0.04950108f, 0.02489945f, -0.04700090f, 0.04564997f, -0.00929284f, -0.00953759f, -0.04257483f, 
    -0.00037340f, -0.00903264f, -0.02809825f, 0.03311053f, 0.01254140f, -0.03478875f, -0.03978011f, -0.04171875f, 
    -0.24712506f, 0.11924551f, -0.08351356f, 0.09654299f, 0.01992101f, 0.01154644f, -0.08906313f, -0.15405172f, 
    0.18226729f, 0.02755848f, 0.07135043f, 0.13721325f, 0.01568920f, 0.15150529f, 0.01437661f, -0.11034368f, 
    0.02019875f, 0.06274030f, 0.03545439f, 0.16812094f, -0.06631754f, -0.14284682f, 0.08268370f, 0.01393381f, 
    -0.08263642f, 0.30327860f, -0.17545392f, -0.06622999f, 0.12765145f, -0.08023364f, 0.13173115f, 0.06296115f, 
    -0.07440110f, 0.04319105f, 0.08125202f, 0.05958437f, 0.10064430f, -0.04033343f, 0.01755451f, 0.04476985f, 
    -0.03285708f, 0.04076589f, -0.16142793f, -0.07656544f, -0.06999818f, 0.04928711f, -0.05801714f, -0.05233349f, 
    0.15255380f, 0.12563261f, -0.00668183f, -0.06838728f, -0.05846347f, -0.00542907f, -0.13142465f, 0.04515471f, 
    -0.09183844f, -0.10320914f, -0.20813671f, -0.14406523f, -0.15207025f, -0.04947772f, 0.01056308f, 0.16786663f, 
    0.13589719f, -0.00917147f, 0.01034639f, -0.07433660f, -0.19929335f, 0.00544916f, -0.10334662f, -0.07714910f, 
    0.35601088f, 0.08679445f, -0.02291014f, -0.00588458f, -0.01167886f, 0.18141884f, -0.04317635f, -0.06679188f, 
    0.01361887f, 0.01686946f, 0.15294480f, 0.09142342f, 0.08996890f, 0.08315320f, -0.10588002f, -0.15169990f, 
    0.06535622f, 0.10641512f, -0.16396745f, 0.05752003f, -0.00961533f, -0.01289363f, 0.15737659f, -0.08235130f, 
    -0.20118223f, 0.11254749f, 0.00229964f, 0.09936349f, 0.14279102f, -0.25537872f, -0.01007621f, -0.10411957f, 
    0.16319385f, 0.19022708f, -0.09438237f, 0.28618252f, -0.00123919f, 0.02082703f, -0.20297323f, -0.01598404f, 
    -0.01369540f, -0.00582842f, 0.01257033f, 0.01330298f, 0.03730545f, 0.05235269f, 0.09238873f, 0.00546792f, 
    -0.39233905f, -0.05480630f, 0.17262608f, 0.30933276f, 0.14350235f, -0.06576370f, -0.03242719f, 0.12609060f, 
    0.03541769f, -0.03510014f, 0.06121515f, -0.06773953f, -0.25588262f, -0.12526257f, -0.02468370f, 0.00518297f, 
    0.06427430f, 0.01748550f, -0.05285208f, 0.16602038f, -0.30420151f, -0.19969016f, -0.11443228f, -0.24274410f, 
    0.25660956f, 0.14521542f, 0.11588722f, -0.11745536f, 0.18145481f, -0.11552102f, -0.03222404f, 0.23556174f, 
    0.02940054f, -0.08588926f, 0.08595835f, -0.05775350f, 0.32649150f, 0.02937068f, 0.17078325f, -0.04026946f, 
    -0.26161420f, 0.02708408f, 0.02650921f, -0.02681949f, -0.08592759f, -0.00103596f, -0.02292924f, -0.00785688f, 
    0.28947049f, 0.09433872f, 0.05151245f, 0.03514976f, 0.00651755f, 0.11325485f, 0.00292421f, -0.11524606f, 
    -0.07888953f, 0.08467795f, -0.19928356f, -0.01850508f, 0.05394203f, -0.03683389f, 0.17362033f, -0.00484243f, 
    -0.28611082f, 0.10115218f, 0.00274801f, -0.02540660f, 0.03434003f, -0.05194882f, 0.11959042f, -0.06723630f, 
    -0.22735687f, 0.07404054f, 0.11447503f, -0.22014791f, 0.07334721f, -0.08714836f, -0.01557734f, -0.04482078f, 
    -0.12653349f, -0.24004118f, 0.01896935f, -0.03824300f, 0.07866943f, 0.19002762f, -0.12657516f, -0.02031460f, 
    0.15884463f, 0.01653145f, -0.05203944f, 0.06755465f, -0.05178567f, -0.11080567f, -0.02645105f, 0.01888063f, 
    -0.39732566f, 0.04825742f, -0.21871792f, 0.05335563f, 0.02482908f, 0.08377691f, 0.06547638f, -0.00068770f, 
    -0.05630499f, 0.15123791f, -0.12598112f, -0.03612072f, 0.21695264f, 0.08908771f, -0.24950881f, 0.14855810f, 
    0.16102844f, -0.11330797f, 0.02046782f, -0.00588312f, 0.10810586f, 0.03207277f, 0.03882650f, 0.01885642f, 
    -0.32559332f, 0.03080504f, 0.18733239f, 0.15510151f, 0.11300956f, -0.00541072f, -0.00807777f, 0.14134000f, 
    -0.11040800f, -0.04696418f, -0.02296731f, -0.17474607f, 0.00942548f, 0.21693167f, -0.13715540f, 0.22298260f, 
    0.15315914f, -0.07708573f, 0.20461440f, 0.03976671f, 0.15630139f, 0.06252334f, 0.12436258f, -0.07744865f, 
    0.52207178f, 0.06598535f, 0.00661842f, 0.35742682f, 0.12079404f, 0.14658952f, -0.01292039f, -0.11214210f, 
    0.03074692f, -0.05738886f, 0.07281233f, 0.23911630f, 0.12717639f, -0.02634541f, 0.04102446f, 0.10748980f, 
    -0.01082602f, -0.02840008f, -0.01335844f, 0.04342968f, 0.09805214f, 0.04686719f, -0.01897614f, 0.08400496f, 
    -0.00115228f, 0.34600484f, -0.26936707f, 0.00872275f, 0.29440188f, -0.12510754f, -0.05644098f, 0.20782538f, 
    -0.09276754f, -0.04435813f, 0.03157967f, -0.21604072f, 0.10124522f, -0.11362880f, -0.09695676f, 0.14577033f, 
    -0.05929953f, 0.07814558f, -0.01923854f, -0.05937638f, -0.01507640f, -0.04575064f, -0.14113748f, -0.13370176f, 
    0.14111841f, -0.00054744f, -0.06395718f, -0.06323599f, -0.00691284f, -0.00230238f, -0.02465850f, 0.06643949f, 
    0.16315329f, 0.06383073f, 0.02554831f, 0.02416918f, 0.06726652f, -0.02028811f, -0.11787037f, 0.15520778f, 
    0.09631792f, 0.05382850f, 0.12961620f, -0.13676253f, 0.06639417f, 0.08770482f, 0.16727926f, 0.13089015f, 
    -0.38739416f, 0.08971404f, 0.19363478f, 0.04818208f, 0.01031229f, 0.02408044f, 0.08124163f, 0.05842118f, 
    0.11620393f, -0.04554913f, -0.08969092f, 0.24275208f, -0.48522285f, 0.09545522f, 0.00294905f, -0.05716216f, 
    -0.05160455f, 0.06713431f, 0.02213333f, 0.16031162f, -0.23192923f, -0.02062876f, -0.11854565f, -0.37597853f, 
    -0.04078196f, -0.12434968f, 0.02839096f, 0.03713326f, 0.00443832f, 0.03858008f, 0.11384819f, -0.15974870f, 
    -0.22223574f, -0.27147570f, -0.18337125f, -0.15663908f, 0.03812982f, -0.01176200f, -0.07589322f, 0.06555017f, 
    -0.05515031f, -0.08750838f, -0.03877177f, -0.14368241f, 0.11670046f, 0.03020567f, 0.01291029f, 0.10851509f, 
    0.09697179f, -0.40122035f, -0.00492334f, -0.06028381f, -0.12262388f, 0.02150157f, -0.02952321f, 0.30714887f, 
    -0.01687918f, -0.10175028f, -0.16786036f, -0.08268098f, -0.02742320f, -0.00320450f, 0.00295353f, -0.00128686f, 
    -0.10852128f, -0.15334962f, 0.03784448f, -0.12631431f, -0.03063186f, 0.02777519f, -0.09715630f, -0.12259539f, 
    0.08575937f, -0.16872403f, 0.19998816f, 0.12835802f, -0.07490731f, -0.10076014f, -0.01956908f, -0.14727546f, 
    -0.05223937f, -0.01887542f, -0.11652361f, -0.01378601f, 0.28602037f, 0.13522489f, 0.07817345f, -0.03201911f, 
    0.19748670f, 0.09400057f, 0.29166561f, 0.03637597f, 0.02321777f, -0.04428853f, 0.02067970f, 0.03186456f, 
    0.02284469f, 0.14029413f, 0.11071970f, -0.05042168f, 0.08520738f, 0.05649709f, 0.25892329f, 0.03215336f, 
    0.04564098f, 0.04385353f, 0.10480064f, 0.15586548f, -0.15379597f, 0.03453339f, 0.07274401f, -0.00729280f, 
    0.04314007f, -0.01042927f, -0.01093378f, -0.16715191f, 0.08788139f, 0.05041462f, -0.11670011f, 0.05210484f, 
    -0.21464644f, 0.11876354f, -0.00730574f, -0.15690744f, 0.19322734f, 0.01863617f, -0.05112233f, -0.06867857f, 
    0.23254205f, 0.11203455f, -0.14977397f, -0.10688862f, 0.13411325f, 0.03862012f, -0.19173588f, -0.11203101f, 
    0.10107051f, 0.22544453f, 0.19511609f, -0.03272115f, 0.11547901f, 0.09082168f, 0.12963831f, 0.15814857f, 
    -0.06168819f, -0.20418662f, -0.05178192f, 0.06284020f, -0.09812548f, -0.00546621f, -0.09011196f, -0.06693055f, 
    -0.15366870f, -0.19350940f, -0.20800039f, -0.11422332f, 0.33133373f, 0.27654171f, -0.03027610f, -0.14826705f, 
    0.03907670f, 0.09075644f, 0.10404011f, 0.04603721f, -0.05190499f, -0.16766275f, 0.06577922f, 0.07433590f, 
    -0.03586448f, -0.10204531f, -0.29254493f, -0.24367832f, 0.06053774f, 0.14138314f, 0.08165098f, 0.02683222f, 
    -0.06927586f, -0.00348911f, -0.08468023f, -0.03443700f, -0.03327877f, -0.04547366f, -0.06033313f, -0.05927927f, 
    0.20249723f, 0.07184143f, 0.06544664f, -0.05621811f, 0.10619907f, 0.18718253f, 0.11368508f, 0.07713484f, 
    -0.02168232f, 0.23513672f, -0.21646747f, 0.12136240f, -0.01036452f, -0.04259598f, -0.03781486f, 0.07507928f, 
    -0.00806970f, -0.07567120f, -0.00856616f, 0.02682358f, -0.12299139f, 0.00010865f, 0.28832331f, -0.07612454f, 
    0.06521884f, -0.00023722f, -0.15841882f, -0.12318955f, 0.21719417f, -0.07793684f, -0.01994397f, 0.09278657f, 
    -0.09217586f, 0.02440540f, -0.04041180f, -0.12754913f, 0.03415109f, 0.14565878f, 0.00798323f, -0.05301851f, 
    0.13242851f, 0.00028940f, 0.22033449f, 0.01471326f, -0.45987853f, -0.04041689f, 0.12685023f, 0.36074170f, 
    0.34382981f, 0.02687829f, 0.03387497f, 0.11763482f, -0.04226210f, 0.04626930f, -0.05457046f, -0.03193843f, 
    -0.06832065f, 0.04693504f, 0.15712743f, 0.16967283f, -0.02009886f, 0.00654466f, -0.04578958f, -0.06526585f, 
    0.08761189f, 0.00342517f, 0.07898169f, 0.03950339f, 0.50762784f, 0.14416128f, -0.00424579f, -0.34515327f, 
    -0.05536912f, -0.02114338f, 0.19511852f, 0.15566750f, 0.07441527f, 0.08194539f, 0.00297910f, 0.04606184f, 
    0.11187281f, -0.11272487f, 0.05975813f, -0.15270820f, -0.00206809f, 0.04544653f, 0.03120074f, 0.10174043f, 
    -0.02308726f, -0.02247605f, 0.09864689f, 0.19014564f, 0.10218237f, 0.02444633f, -0.05520940f, -0.15516962f, 
    -0.15368125f, 0.03798364f, 0.06578648f, 0.14440568f, 0.06537839f, 0.07242028f, 0.00850829f, 0.04811530f, 
    -0.09301879f, -0.06642201f, -0.29545653f, 0.00715332f, 0.03550868f, -0.00128322f, -0.04276634f, 0.02698431f, 
    -0.02253877f, -0.01343499f, 0.00831049f, -0.00061942f, 0.51011407f, -0.19344692f, -0.24926448f, -0.04768209f, 
    -0.16303021f, -0.00247416f, -0.01773858f, -0.01434509f, -0.04315999f, 0.01280066f, -0.03832713f, 0.07916938f, 
    -0.60712802f, -0.20133045f, 0.07646609f, -0.16855219f, 0.02583300f, -0.00103852f, -0.09902357f, 0.16342704f, 
    -0.04993702f, 0.03878870f, -0.12791578f, -0.07910511f, 0.34361267f, 0.46424788f, -0.07939275f, -0.19428092f, 
    0.15549161f, 0.20447369f, 0.09155700f, 0.11602139f, -0.06454676f, 0.00623611f, -0.10035785f, -0.03978747f, 
    0.03477917f, -0.19176760f, -0.02572140f, 0.28331667f, -0.08174112f, 0.04077850f, 0.00638637f, -0.11524202f, 
    0.04473844f, -0.06226752f, -0.00332065f, 0.16254826f, 0.14934802f, 0.17097142f, 0.05016796f, -0.11747485f, 
    0.14085859f, 0.24216966f, 0.12344016f, 0.12111197f, -0.20621119f, 0.01231724f, 0.01995648f, 0.01935968f, 
    0.27911136f, 0.32877094f, 0.06496324f, -0.03831894f, 0.11830175f, 0.07549458f, 0.07271583f, 0.17644604f, 
    -0.11876744f, 0.05546216f, -0.13769311f, 0.02704397f, 0.19371119f, 0.18735126f, -0.00111313f, -0.07119113f, 
    0.24647304f, 0.07949709f, -0.01940247f, 0.11880400f, -0.06182457f, 0.04763015f, 0.02675440f, -0.17019050f, 
    -0.05781735f, 0.21190567f, 0.06372604f, -0.01475198f, 0.03073200f, -0.04669278f, 0.00079199f, -0.12213876f, 
    -0.17333199f, -0.06449040f, 0.02901095f, -0.11839960f, 0.00203071f, 0.03089309f, -0.07910585f, -0.06510307f, 
    0.15693380f, 0.05938525f, 0.02450259f, -0.03837173f, 0.01637676f, 0.06908463f, 0.06136322f, 0.04937914f, 
    -0.05384504f, 0.01845139f, 0.06946844f, -0.06941876f, 0.05694814f, -0.02105800f, -0.05678652f, -0.02785366f, 
    0.08918358f, 0.19477047f, 0.08049809f, 0.10366011f, -0.21574640f, 0.15601085f, 0.17383657f, 0.16708764f, 
    0.07474636f, 0.01594517f, -0.00617648f, 0.02714021f, -0.19793881f, -0.00424006f, -0.11551577f, -0.19308136f, 
    0.73628134f, 0.17121881f, -0.15999700f, -0.14854522f, -0.00703962f, -0.06856057f, -0.12986754f, -0.02343491f, 
    0.13162579f, 0.02597704f, 0.09331439f, 0.02938240f, 0.21629898f, 0.07428258f, 0.02523284f, 0.19476196f, 
    0.03787125f, 0.02199689f, 0.03433925f, 0.04440669f, 0.12391348f, -0.04514819f, 0.00575771f, -0.08729096f, 
    0.29937163f, 0.04174659f, 0.10727378f, 0.14231592f, -0.01302363f, 0.01547521f, -0.02527856f, 0.00714132f, 
    -0.04501138f, 0.05444253f, 0.03995116f, -0.05033215f, -0.07978875f, -0.00788650f, -0.63677764f, -0.15151308f, 
    0.17064984f, -0.03022116f, 0.04580648f, -0.09297354f, -0.15315168f, -0.02469445f, -0.03292053f, 0.05571871f, 
    -0.27104014f, -0.12587570f, 0.18225211f, -0.18425496f, 0.01863867f, -0.08775338f, 0.14524071f, 0.19093317f, 
    0.03982736f, 0.04343927f, -0.01266385f, -0.11685724f, 0.06418065f, 0.17503670f, 0.08789578f, 0.12999654f, 
    -0.09785593f, 0.01770765f, 0.00703450f, -0.02273348f, -0.05684455f, 0.04862369f, -0.06388537f, 0.01741907f, 
    -0.39653441f, 0.34606564f, -0.10624022f, 0.24328712f, -0.42138025f, 0.12745623f, 0.04930110f, 0.13431931f, 
    -0.00112252f, -0.02938363f, 0.15697728f, 0.00839294f, -0.27142838f, 0.12398686f, 0.12382112f, -0.07340767f, 
    -0.01473637f, -0.19832668f, 0.02530586f, -0.10248407f, -0.01706046f, 0.00722190f, -0.05064564f, 0.18128450f, 
    0.18585002f, 0.16345306f, 0.10944414f, 0.22356504f, 0.10245849f, 0.03824352f, 0.07304265f, 0.06263364f, 
    -0.07271931f, -0.10355990f, 0.09722488f, 0.00391403f, -0.42860630f, -0.44608983f, -0.49666107f, -0.14207655f, 
    0.06432202f, 0.02053934f, -0.01584605f, -0.27165374f, 0.03766725f, 0.01837315f, -0.06675746f, -0.02322336f, 
    0.08534490f, -0.31302899f, -0.12255179f, 0.25292492f, 0.24898002f, -0.05676366f, 0.21481243f, -0.15225703f, 
    -0.05895626f, -0.02345563f, 0.05498179f, -0.08592258f, 0.13787267f, -0.07139805f, -0.09853105f, 0.01904340f, 
    -0.03627386f, 0.06363552f, 0.02269753f, 0.06679966f, -0.07069056f, -0.12202013f, -0.10431572f, -0.02170386f, 
    0.08466967f, -0.33955687f, 0.02379630f, 0.31983578f, 0.22354239f, 0.08282201f, 0.10158237f, -0.09244876f, 
    0.16582450f, 0.06065431f, 0.07507492f, 0.07410055f, -0.27356556f, 0.18767521f, 0.17277300f, 0.13013804f, 
    -0.13675386f, 0.08271450f, -0.03513672f, 0.23318154f, 0.12431299f, 0.03025551f, 0.03096293f, 0.01060790f, 
    -0.22033095f, 0.35456282f, 0.18072046f, -0.05004175f, -0.15097411f, -0.05886195f, -0.02553546f, 0.09667756f, 
    0.05338622f, 0.06460951f, 0.17013471f, -0.06839425f, 0.16418007f, 0.03112473f, 0.00702844f, -0.57826036f, 
    -0.09914000f, 0.14908378f, 0.21279326f, -0.09748064f, 0.00446330f, 0.09783819f, -0.21559952f, 0.09733801f, 
    -0.03068446f, 0.11372242f, -0.05300979f, 0.13448989f, 0.00286250f, -0.03979458f, 0.06001911f, 0.03946978f, 
    -0.07281744f, 0.04897514f, 0.03858930f, -0.03324907f, -0.06720300f, -0.53448105f, -0.60064274f, 0.16172783f, 
    0.18796597f, 0.06845266f, -0.03928250f, -0.13765374f, -0.10872607f, 0.03804847f, 0.20268399f, 0.05436384f, 
    0.54166883f, 0.03468642f, -0.51518095f, -0.00321178f, -0.03528592f, -0.13090959f, 0.17834304f, -0.04395414f, 
    0.00495560f, 0.18831901f, -0.20445287f, -0.12757976f, -0.00754305f, -0.18118247f, 0.01010355f, 0.06932402f, 
    0.03970737f, -0.00727393f, -0.17827362f, 0.01435672f, 0.05870569f, -0.05544738f, 0.19573727f, 0.10290124f, 
    0.41869664f, -0.09692074f, -0.17136721f, 0.08756053f, 0.02473418f, 0.16497663f, 0.16336453f, -0.17219292f, 
    -0.07005402f, -0.03639795f, -0.10247519f, 0.12518542f, 0.02239911f, 0.35116783f, -0.09495692f, 0.54626107f, 
    0.36252937f, -0.08522443f, 0.04470937f, -0.05737886f, -0.05805007f, 0.10444551f, 0.15267327f, -0.13303258f, 
    0.38448426f, -0.22524492f, -0.06053995f, -0.05871678f, -0.10585175f, -0.02737542f, 0.01129043f, -0.05965978f, 
    0.17119008f, 0.11057988f, -0.02930999f, 0.04051512f, -0.19800144f, -0.60383391f, -0.20568720f, -0.08954588f, 
    0.12058894f, -0.03809974f, -0.15275979f, -0.07755946f, -0.06679290f, -0.02611750f, 0.06342290f, -0.06897677f, 
    0.24579577f, 0.10978182f, 0.04925103f, 0.06679446f, -0.02587552f, -0.01878331f, 0.02239813f, 0.00679918f, 
    0.02441833f, 0.16868085f, -0.17038167f, 0.17378473f, -0.26328081f, -0.40671334f, -0.29538229f, -0.48415771f, 
    0.02407160f, -0.13363595f, 0.01998496f, -0.31074482f, -0.05225187f, -0.10676929f, -0.03092470f, -0.07021892f, 
    -0.37444013f, -0.26316112f, 0.21489750f, -0.26382703f, -0.07546924f, 0.15701960f, -0.03054905f, -0.08043120f, 
    0.01001226f, -0.08576083f, -0.03029449f, -0.04130403f, 0.05813609f, -0.01240481f, -0.17191395f, 0.04517989f, 
    -0.03751094f, -0.04394413f, 0.04723683f, -0.13678837f, 0.00321895f, 0.07157145f, 0.01264390f, -0.06290245f, 
    0.06713598f, -0.04561185f, -0.04263940f, 0.21524914f, 0.00183472f, 0.02093700f, -0.05294342f, 0.16924024f, 
    -0.01336103f, -0.06085607f, 0.12420063f, 0.04611708f, 0.08023094f, -0.10376543f, -0.12741353f, 0.09089864f, 
    0.02302544f, 0.01130885f, 0.02818867f, -0.03306858f, -0.00831062f, -0.04626750f, -0.07115600f, -0.03613809f, 
    -0.12177441f, 0.05470292f, 0.09987757f, 0.13790873f, 0.04100214f, 0.05982011f, -0.02036581f, 0.08523277f, 
    -0.05981917f, -0.02869667f, 0.05536938f, -0.06567893f, 0.25624591f, 0.06234989f, 0.01137399f, 0.07410587f, 
    -0.01408919f, 0.00725768f, -0.02098199f, 0.17680520f, -0.06505295f, 0.06434558f, 0.07144623f, 0.08194719f, 
    -0.05385031f, 0.05497209f, 0.23620264f, -0.18334596f, 0.06320923f, -0.09149425f, 0.20029142f, -0.11192560f, 
    0.08359451f, 0.07854383f, 0.25906679f, 0.25586030f, -0.01148796f, -0.09900142f, -0.00292341f, 0.12154785f, 
    0.06245308f, 0.01574905f, -0.01832131f, 0.07872649f, -0.06218167f, 0.17423473f, 0.09407631f, 0.09521216f, 
    0.06868135f, -0.26961598f, -0.11054410f, -0.07702723f, 0.06608011f, 0.00996453f, 0.07406792f, -0.10452123f, 
    -0.01378543f, -0.00637749f, 0.08352868f, -0.11504740f, -0.01693772f, -0.04526050f, 0.33448011f, 0.00303814f, 
    0.03703858f, 0.00215375f, 0.06447235f, 0.01528632f, 0.03569427f, -0.00510131f, 0.07213590f, -0.01482447f, 
    -0.08912279f, -0.12691030f, 0.05828426f, 0.22740832f, 0.11426739f, 0.06483429f, -0.01107353f, 0.01757523f, 
    -0.03783040f, -0.19925909f, -0.04202422f, -0.05799537f, 0.32533434f, 0.04308615f, -0.03054698f, 0.01703223f, 
    0.13386299f, -0.00154421f, 0.07926025f, 0.02539018f, -0.03876141f, -0.08658063f, -0.00913088f, -0.17065845f, 
    -0.00980651f, -0.02832581f, 0.18740344f, 0.13782753f, -0.10970504f, -0.06971743f, -0.15336502f, -0.16249619f, 
    0.06352501f, 0.11941741f, 0.14569241f, 0.09394135f, 0.08894704f, -0.03015582f, 0.25420129f, -0.00786138f, 
    -0.00222584f, -0.13199182f, -0.12877150f, 0.13330457f, 0.06181152f, -0.02476424f, 0.00342967f, -0.04497956f, 
    0.29700685f, -0.09207185f, 0.08036182f, -0.09287272f, 0.02801441f, 0.03946894f, -0.05485140f, 0.05537734f, 
    0.09466500f, 0.07302070f, 0.18198177f, 0.06049016f, 0.16765423f, -0.21996209f, 0.18229906f, -0.13053320f, 
    -0.20010291f, 0.01687484f, 0.03937520f, 0.18233214f, -0.03759816f, -0.06584381f, -0.17767341f, -0.02717101f, 
    0.24124172f, 0.24180016f, -0.17986684f, -0.08858623f, 0.07040837f, 0.05725746f, -0.12874123f, 0.29924402f, 
    0.11755157f, 0.01878529f, 0.01913013f, 0.02267633f, 0.08463168f, 0.02238771f, 0.13507026f, 0.04198922f, 
    0.16763480f, 0.19546640f, 0.19458097f, 0.18390699f, 0.09036638f, -0.17832525f, -0.03424160f, -0.14011151f, 
    -0.23641333f, 0.05081265f, -0.04126637f, -0.03408050f, -0.04915519f, 0.06439634f, 0.02098608f, 0.20703268f, 
    0.06591164f, 0.21908192f, 0.04008112f, 0.07080265f, -0.07129025f, -0.09610280f, -0.14878663f, 0.33864409f, 
    0.11076257f, 0.10973905f, -0.08331705f, -0.12351210f, 0.09986913f, 0.09821600f, 0.11916883f, 0.13628632f, 
    0.12640199f, -0.08739939f, 0.31978148f, 0.31566414f, -0.00133151f, -0.13738585f, -0.05161767f, -0.09950654f, 
    0.09413901f, -0.11504520f, -0.05584951f, 0.19877243f, -0.17998515f, 0.09735052f, -0.24842270f, -0.18907467f, 
    0.31131715f, -0.06483396f, 0.07769126f, 0.09964253f, 0.06811416f, -0.22663996f, 0.06503251f, -0.07881348f, 
    0.06735127f, -0.20506430f, -0.16187158f, 0.09334480f, 0.02466334f, 0.18153191f, 0.09405406f, 0.03022499f, 
    -0.00760158f, 0.02178415f, -0.14700696f, -0.03329943f, -0.07981078f, -0.13277730f, 0.18205038f, -0.00767086f, 
    -0.11930869f, -0.01697757f, -0.11518278f, -0.05749312f, 0.04451705f, 0.02306810f, 0.04153140f, -0.15359204f, 
    -0.05295601f, 0.07232823f, 0.23423684f, -0.39369169f, 0.11988720f, 0.15881482f, 0.04889659f, 0.08135498f, 
    -0.00306490f, -0.16560362f, -0.07708813f, -0.08293283f, -0.27708814f, 0.29264855f, 0.14014493f, -0.00532194f, 
    0.00887248f, -0.06669025f, -0.05704048f, -0.06881137f, 0.13007861f, 0.08372124f, -0.00402001f, 0.13782659f, 
    0.36243504f, 0.22068232f, 0.10660015f, -0.05563515f, 0.05577043f, 0.10033306f, 0.08508201f, 0.17094037f, 
    -0.05145329f, -0.04066617f, -0.03771861f, -0.12854481f, -0.02873788f, -0.50088459f, 0.42912361f, -0.47961837f, 
    0.08280397f, 0.15175903f, 0.23830973f, 0.23064582f, 0.11696811f, 0.04060230f, -0.09888517f, 0.13853365f, 
    -0.49547777f, 0.35044137f, -0.08558010f, -0.30076823f, -0.20084158f, -0.06863543f, -0.06354889f, 0.00137617f, 
    0.14306709f, 0.04908998f, 0.29325679f, 0.10800675f, -0.33966318f, 0.20949306f, 0.14097770f, -0.00062089f, 
    -0.12173994f, -0.09388288f, -0.02548021f, -0.01007673f, 0.01340371f, -0.04429591f, 0.09032425f, 0.07095149f, 
    0.03203625f, -0.19782661f, -0.06074689f, -0.32314554f, -0.00221172f, 0.09745447f, 0.01571342f, -0.00292022f, 
    -0.08899906f, 0.03784744f, -0.14215048f, -0.22624151f, -0.15233085f, 0.22335088f, 0.01259067f, -0.22739126f, 
    -0.03104528f, -0.18950218f, -0.04729648f, -0.13472103f, -0.00990383f, -0.11228094f, -0.05715005f, -0.00483652f, 
    -0.03575340f, -0.10372137f, 0.09592536f, 0.15535539f, -0.00396955f, -0.05244184f, 0.11456664f, -0.06813620f, 
    0.07296279f, 0.01268357f, 0.14569120f, 0.06629271f, -0.10297594f, -0.12696610f, 0.07541614f, -0.19009680f, 
    -0.20067936f, -0.05181903f, 0.00065165f, 0.03227743f, 0.25489861f, -0.01989848f, 0.04268693f, 0.18717757f, 
    0.49357590f, -0.14309828f, 0.01809763f, -0.07261907f, 0.04040645f, -0.10510117f, 0.22496316f, 0.19441895f, 
    0.10261554f, 0.01009573f, 0.03771630f, -0.08755721f, 0.24801488f, 0.19829559f, 0.15443742f, 0.03819119f, 
    0.11899241f, 0.10922184f, 0.12402802f, 0.14631218f, 0.09570248f, -0.03975455f, -0.01258884f, -0.01408801f, 
    0.05437509f, -0.00676305f, -0.04626057f, 0.04037194f, 0.24531403f, 0.00378499f, 0.05250441f, -0.04500093f, 
    -0.03065306f, -0.10793290f, -0.17525488f, -0.19865203f, 0.11711428f, 0.06524097f, 0.05911382f, 0.01218641f, 
    0.07049910f, 0.05245033f, 0.01918088f, -0.13769482f, 0.17590100f, 0.02890122f, 0.27642331f, 0.13370307f, 
    0.02291583f, -0.05176575f, -0.00053826f, 0.05742137f, -0.03210276f, -0.04978685f, 0.02153417f, 0.02054646f, 
    -0.01012755f, -0.00844524f, 0.04398941f, -0.00882565f, 0.03530214f, -0.06027147f, -0.04409761f, 0.02324919f, 
    0.00207128f, -0.03147500f, 0.01263943f, -0.04431375f, -0.02121001f, 0.01705234f, -0.05326602f, -0.03825229f, 
    0.04695157f, -0.00043641f, -0.00472339f, -0.04486502f, -0.05379628f, 0.01692436f, 0.01275131f, 0.02146943f, 
    -0.05930176f, -0.04481237f, -0.02186790f, 0.00260878f, 0.03564920f, -0.04485282f, -0.00519227f, -0.03978914f, 
    0.03105086f, 0.01525511f, -0.02795475f, 0.04514769f, 0.04342487f, -0.02749033f, -0.01224802f, 0.00016984f, 
    -0.00678829f, -0.02064179f, -0.03663476f, 0.01658594f, 0.01926541f, -0.01514230f, -0.04611865f, -0.05437928f, 
    0.01040425f, -0.00370256f, -0.02982786f, -0.03707983f, 0.01109921f, -0.00528235f, 0.02990185f, -0.01645437f, 
    -0.03820840f, -0.04157807f, 0.01850449f, 0.00842558f, -0.05082099f, 0.02776603f, 0.02887006f, 0.02379592f, 
    0.01375300f, -0.03215418f, -0.05673064f, 0.02813642f, -0.00936106f, -0.03688891f, -0.04269464f, -0.02677147f, 
    0.00014842f, -0.00306590f, -0.03413829f, 0.01529735f, 0.01055462f, -0.02229536f, -0.02660721f, 0.02805588f, 
    -0.00450297f, 0.00322003f, 0.02820285f, 0.03264328f, -0.01728323f, -0.04212050f, -0.05445907f, 0.02571251f, 
    -0.02309291f, -0.05597196f, -0.04309274f, -0.05715337f, 0.00074450f, 0.02325804f, -0.06116728f, 0.02910785f, 
    -0.01181682f, 0.01394461f, -0.03211741f, 0.02610082f, 0.03088592f, -0.00030740f, -0.04561369f, 0.03891509f, 
    -0.01434272f, 0.02419202f, -0.01307185f, -0.03208126f, -0.01109706f, -0.02058191f, -0.02586880f, 0.02976174f, 
    0.01635410f, -0.00026036f, -0.00766282f, -0.04865546f, -0.02379949f, 0.01121550f, -0.02297693f, -0.04358611f, 
    -0.03857613f, -0.05815084f, -0.01406251f, 0.03030935f, 0.01869070f, -0.05327015f, -0.00068734f, -0.02928996f, 
    -0.02785697f, 0.00578055f, 0.02611116f, 0.03739345f, -0.02919802f, -0.01319046f, -0.00544875f, -0.01318776f, 
    0.00957937f, 0.01325241f, 0.00825921f, -0.06039205f, -0.05907397f, -0.03145801f, 0.02984104f, -0.05794862f, 
    -0.00530894f, -0.05240967f, -0.04433183f, -0.03635402f, -0.04177692f, 0.03709665f, -0.01998852f, 0.01997568f, 
    -0.05808228f, 0.00824646f, -0.01289310f, -0.05086809f, -0.02513860f, 0.02491705f, -0.03144897f, -0.05312146f, 
    -0.05186711f, 0.01134726f, 0.00847237f, -0.04064940f, -0.05456002f, 0.01531302f, 0.03195121f, 0.02535579f, 
    -0.00407005f, -0.05249807f, 0.01089711f, -0.00253411f, 0.04004230f, 0.00250689f, -0.04741068f, 0.02621315f, 
    -0.04198550f, -0.03113597f, 0.00653572f, 0.01958657f, -0.01290240f, 0.00091680f, -0.04362280f, 0.02770021f, 
    0.04729852f, 0.04202621f, -0.00939651f, -0.00399632f, -0.04548586f, -0.00510235f, 0.03478086f, 0.03199959f, 
    0.01166640f, -0.02854576f, -0.00010868f, 0.00279959f, -0.00829677f, -0.01306674f, -0.02856670f, -0.03396628f, 
    0.01640527f, 0.04211422f, 0.03734801f, -0.03352699f, 0.01802979f, -0.02071735f, -0.00523928f, -0.03550698f, 
    0.02560044f, -0.04169555f, -0.02504056f, -0.05636378f, 0.01213032f, 0.03701369f, -0.05044058f, -0.00660296f, 
    0.03364464f, -0.00560483f, -0.05383640f, -0.00084352f, -0.02144285f, -0.03849956f, -0.05142686f, -0.00332917f, 
    -0.01706537f, 0.00809320f, -0.02544650f, -0.06092121f, -0.01921070f, -0.01968925f, 0.02696692f, -0.00428209f, 
    -0.00337011f, -0.02037530f, -0.01874159f, -0.03592976f, 0.00444236f, -0.00274865f, 0.03051711f, 0.03532655f, 
    -0.02880473f, 0.00278426f, 0.00936166f, -0.01440849f, 0.00771634f, -0.00544994f, 0.02923618f, -0.02803645f, 
    -0.04589481f, -0.03920974f, -0.03877046f, -0.01846684f, -0.01671402f, -0.03416383f, 0.03543004f, 0.02207631f, 
    -0.03083862f, 0.04112630f, 0.02207271f, 0.03875595f, 0.00890318f, -0.04831978f, 0.02658795f, -0.05360243f, 
    0.03311185f, -0.03705429f, -0.03932346f, -0.02788768f, -0.04744854f, -0.01781812f, 0.03246763f, -0.05083808f, 
    0.02360237f, 0.00365406f, -0.01456151f, -0.00662951f, 0.00044646f, 0.00969249f, -0.03826797f, 0.00913798f, 
    0.00653447f, 0.03914711f, -0.02911644f, -0.01713322f, -0.01727719f, -0.03428321f, -0.00921116f, 0.03262473f, 
    -0.05500367f, -0.01588868f, -0.03419118f, 0.02552382f, -0.03322063f, 0.02572076f, 0.03717342f, 0.01386110f, 
    -0.01706854f, 0.04276652f, -0.01823236f, 0.00270603f, -0.04645845f, -0.05304949f, 0.03314257f, 0.03557150f, 
    -0.02554764f, 0.02130960f, -0.01997618f, -0.00948363f, -0.04654832f, -0.03885012f, 0.01201426f, 0.00545493f, 
    0.04386415f, -0.00397303f, 0.02261038f, -0.00330481f, 0.01527767f, 0.03366404f, -0.04135783f, -0.02389557f, 
    -0.01813071f, -0.01629829f, -0.00168284f, 0.03770524f, -0.00317617f, -0.05519672f, 0.00113228f, 0.03366859f, 
    0.00867609f, 0.02196886f, 0.03756732f, -0.04166802f, -0.02878107f, 0.03448757f, -0.02627465f, -0.04362163f, 
    0.00269981f, -0.01172261f, -0.04676602f, -0.01432163f, 0.01337746f, -0.02736453f, 0.03450514f, 0.03781106f, 
    -0.01894565f, 0.01583078f, -0.00062080f, 0.00435017f, -0.00605046f, 0.02225390f, 0.02397022f, 0.03772041f, 
    -0.04124670f, -0.05323444f, -0.02825370f, 0.01943222f, 0.02558293f, 0.03674676f, 0.01431620f, -0.00393489f, 
    0.01824486f, -0.01077085f, -0.04596617f, -0.02378150f, 0.02614954f, -0.04618159f, -0.00806965f, 0.02247728f, 
    0.02515216f, 0.02925676f, -0.02616046f, -0.03776985f, 0.00967206f, 0.00675115f, -0.00828664f, -0.03042047f, 
    -0.11913874f, -0.42103612f, 0.31838527f, 0.14784424f, -0.05193384f, 0.12434071f, 0.24438958f, 0.13428988f, 
    -0.02356145f, -0.07841764f, -0.01658020f, 0.23582636f, -0.05882429f, 0.08461759f, 0.05910725f, 0.18916643f, 
    -0.10355820f, 0.10206416f, 0.13719210f, -0.02207299f, 0.18794054f, -0.08366767f, 0.00341498f, 0.26567957f, 
    -0.07433772f, 0.04272613f, 0.05692082f, 0.04835564f, -0.06465308f, 0.04934739f, -0.01193397f, 0.02916722f, 
    0.00980543f, 0.22201920f, -0.02812852f, 0.03439034f, 0.04775494f, 0.14883794f, -0.36136773f, 0.16311865f, 
    -0.06286131f, 0.09983126f, 0.01357254f, 0.03455260f, 0.22699109f, 0.07295979f, 0.16868195f, 0.21675885f, 
    -0.14245582f, 0.21668781f, -0.12629886f, 0.03925901f, 0.07722320f, 0.04473444f, -0.00371104f, -0.02740211f, 
    -0.09676132f, -0.07488264f, -0.03696374f, 0.07315796f, 0.37182149f, 0.01791808f, 0.20169674f, 0.09618694f, 
    0.06825139f, -0.02412244f, 0.01566374f, 0.07875924f, -0.03337555f, 0.15495242f, -0.11523877f, -0.04426967f, 
    -0.04699033f, 0.18041213f, 0.30009744f, -0.15443888f, -0.11662282f, 0.03646787f, -0.02699152f, -0.10245091f, 
    0.08770934f, 0.17562933f, -0.00159711f, 0.05256804f, 0.06041981f, 0.18010344f, -0.19447272f, 0.36033061f, 
    -0.06758884f, -0.05034032f, 0.10256428f, -0.04155028f, -0.10527388f, -0.08544701f, 0.12432955f, -0.20608512f, 
    0.10809689f, 0.24717766f, -0.00859672f, 0.03738748f, -0.06838822f, 0.02120706f, 0.14807625f, 0.05558672f, 
    0.07965933f, 0.25797945f, 0.17951907f, 0.27633870f, -0.03401759f, 0.18855438f, -0.16071881f, -0.17318505f, 
    0.02516189f, -0.19168095f, -0.24813977f, 0.19660765f, -0.22136876f, 0.03696153f, -0.08573288f, -0.14209750f, 
    0.29565561f, 0.30543169f, -0.02390375f, -0.18568783f, 0.08731883f, 0.14539713f, 0.00687760f, -0.06385387f, 
    -0.15718570f, -0.07322381f, 0.09697709f, -0.04365933f, 0.04893589f, 0.05980450f, 0.09355640f, 0.12667386f, 
    0.18781014f, 0.06701606f, 0.02978136f, -0.08645707f, -0.32318249f, 0.01261706f, -0.24079843f, -0.12580287f, 
    -0.04109829f, 0.08588962f, 0.12162321f, -0.01559380f, -0.00909062f, -0.02035034f, 0.04301387f, 0.06950343f, 
    0.21843925f, -0.11825518f, 0.04874429f, 0.12420957f, -0.43796030f, 0.18135425f, 0.28068334f, -0.04494160f, 
    -0.09970579f, 0.21462369f, -0.05417222f, 0.06607774f, -0.00728488f, 0.04995193f, 0.11689125f, 0.01649628f, 
    -0.16420124f, 0.30892330f, 0.08316781f, -0.11754727f, -0.10646185f, 0.06852553f, -0.02287507f, -0.16887373f, 
    -0.00797144f, -0.03726899f, -0.12088922f, -0.16417281f, 0.21316923f, -0.24105793f, 0.68100548f, 0.09418315f, 
    0.05084729f, 0.01519442f, 0.09473969f, 0.02991647f, 0.04726862f, 0.02334304f, -0.15329090f, -0.02044415f, 
    0.10927729f, 0.26554167f, 0.26133063f, -0.03925616f, -0.00918852f, 0.17048395f, 0.01269297f, 0.05278237f, 
    -0.10589625f, -0.06555891f, 0.05123987f, -0.10075313f, 0.02627441f, -0.27019772f, -0.25953379f, -0.14133900f, 
    0.03818108f, 0.08530877f, 0.03949457f, -0.03541668f, 0.04585638f, -0.01472780f, -0.11631961f, -0.05316385f, 
    -0.06873798f, -0.20276001f, 0.52914226f, -0.21614148f, -0.01148284f, 0.03715963f, -0.04614660f, 0.16775811f, 
    -0.20787536f, -0.05954953f, 0.03883671f, -0.03871248f, -0.04623200f, -0.23405501f, 0.11248835f, -0.20699258f, 
    -0.18124038f, 0.04269009f, 0.10038895f, -0.06968068f, 0.18078548f, 0.10294208f, -0.22805883f, 0.02992543f, 
    0.33846155f, 0.21013151f, 0.02622028f, 0.04488330f, 0.01452209f, 0.02373936f, -0.07438371f, 0.15385561f, 
    -0.18117413f, -0.02340816f, 0.00014937f, -0.16137566f, 0.07815772f, -0.07320291f, -0.05788941f, -0.03138084f, 
    0.14927940f, 0.28448588f, 0.06174364f, 0.31811750f, 0.03857028f, -0.09139479f, -0.02430763f, 0.09753039f, 
    -0.05965852f, -0.19735132f, 0.21886706f, -0.27335718f, -0.14222316f, -0.07041242f, 0.06465434f, -0.11942425f, 
    0.29576018f, 0.00024185f, 0.00089436f, 0.10635618f, 0.16536996f, -0.07362531f, -0.32265615f, -0.24874572f, 
    0.05760706f, 0.05262234f, -0.04591360f, -0.00524050f, 0.05051349f, 0.09159206f, 0.06142287f, 0.13086930f, 
    -0.02181777f, 0.05568722f, 0.54999554f, 0.08604541f, 0.01582013f, 0.00517395f, 0.00306115f, 0.08658698f, 
    0.01102891f, -0.00455470f, 0.05481054f, 0.11923772f, 0.22211221f, -0.08983754f, 0.00767370f, -0.23155919f, 
    -0.18377902f, 0.00009227f, -0.00676543f, 0.12515247f, -0.12426680f, -0.19143160f, -0.11914011f, -0.08313286f, 
    0.10136142f, 0.09064086f, 0.15847300f, -0.14362921f, 0.04152808f, -0.05194207f, -0.13551483f, 0.24965759f, 
    0.21605398f, 0.30174750f, 0.10282111f, 0.15161569f, 0.03281229f, 0.03776376f, -0.12219864f, -0.12445774f, 
    0.08188617f, -0.11579195f, -0.18941851f, -0.12514909f, 0.13937157f, 0.10787369f, -0.06585719f, 0.21024320f, 
    0.08038966f, 0.29787561f, 0.10363425f, 0.15665831f, -0.03550567f, 0.11927425f, 0.13401806f, -0.05963919f, 
    -0.02179111f, -0.04368896f, -0.03926311f, -0.03656075f, 0.29355448f, 0.01930832f, 0.07537141f, 0.02429785f, 
    0.10217141f, 0.11526860f, 0.02006862f, -0.00764605f, -0.22957538f, 0.03716681f, -0.03683030f, -0.05983242f, 
    0.07798535f, 0.08979096f, 0.00911915f, 0.01369445f, 0.11197394f, 0.09190186f, -0.10844637f, 0.04156871f, 
    -0.05199790f, -0.18448043f, -0.09824363f, -0.22768676f, 0.02740090f, 0.36321515f, 0.17395283f, 0.07113691f, 
    0.00183505f, 0.05911468f, 0.10148939f, -0.01680156f, 0.05178914f, 0.23351386f, 0.10036890f, 0.26090175f, 
    0.02651361f, 0.44987041f, -0.03685447f, -0.14155965f, 0.12119675f, 0.05651974f, 0.24900216f, -0.06039591f, 
    0.12599429f, 0.07301683f, 0.22866863f, 0.09796129f, -0.14170980f, -0.09934575f, 0.10931223f, 0.07297152f, 
    -0.01158232f, 0.05583695f, 0.16181964f, 0.10666937f, 0.12918794f, 0.19606094f, 0.15879035f, 0.13865265f, 
    0.11418669f, -0.00293013f, 0.16431126f, 0.02824286f, -0.04960057f, 0.06897960f, -0.15231796f, -0.09423742f, 
    -0.10986505f, 0.08734304f, 0.11395624f, 0.07483331f, -0.01305472f, -0.03336928f, 0.11663061f, -0.02841896f, 
    -0.00440248f, 0.08473237f, -0.06058324f, 0.06005527f, 0.17011566f, -0.02998844f, 0.04833920f, 0.08261029f, 
    0.00113088f, 0.00196917f, 0.16183047f, 0.13199058f, 0.01886985f, 0.05269124f, -0.12770434f, -0.05329934f, 
    -0.00310058f, -0.23522428f, -0.03192941f, -0.20892693f, 0.14069729f, -0.15159826f, -0.01637150f, 0.07001372f, 
    0.13800542f, -0.16851647f, -0.12786771f, -0.18377908f, -0.11423685f, -0.03692163f, 0.10460129f, -0.15239863f, 
    0.37326777f, -0.06991760f, 0.29650745f, 0.26669773f, -0.00305311f, -0.13154119f, 0.00517410f, 0.11264335f, 
    0.05961174f, -0.09642737f, 0.14545478f, 0.10290594f, 0.15530810f, 0.00247274f, 0.33084181f, -0.19127782f, 
    -0.08841043f, 0.03904071f, -0.11378719f, -0.01309847f, 0.17923360f, -0.01837223f, -0.09678879f, -0.04541301f, 
    0.09240544f, -0.18182822f, 0.04405174f, -0.02291282f, -0.05553241f, -0.00705358f, 0.11707118f, 0.06401046f, 
    0.16849244f, 0.19936548f, 0.26823804f, 0.06720565f, -0.05572036f, -0.15842412f, 0.16358779f, -0.10421687f, 
    0.05380003f, 0.11914808f, -0.00662448f, 0.05700787f, -0.20666257f, 0.00223810f, -0.01543327f, -0.11464671f, 
    -0.12131335f, 0.21340753f, -0.24880581f, -0.11500912f, 0.13312165f, 0.08516780f, 0.04825222f, 0.01432695f, 
    -0.00716641f, -0.10284598f, -0.10267042f, -0.01540256f, -0.02225245f, -0.05548255f, 0.05604584f, -0.08086555f, 
    0.06996544f, 0.19411111f, 0.05594771f, 0.13036259f, -0.04482572f, -0.29527247f, -0.11664534f, -0.27891389f, 
    -0.24105279f, -0.02768657f, 0.13990003f, -0.08398789f, 0.05139680f, 0.23259088f, 0.00672754f, 0.18909314f, 
    0.19594488f, -0.00027365f, 0.03446893f, -0.01143884f, -0.10763836f, -0.13567352f, -0.02409048f, 0.26908445f, 
    0.01666642f, 0.18238713f, -0.05886893f, -0.09723856f, 0.12953988f, 0.15042126f, 0.08282975f, -0.17997023f, 
    0.43258035f, 0.12637211f, 0.44971675f, 0.28651407f, -0.04239499f, -0.26912862f, -0.07858319f, -0.14739434f, 
    0.05688235f, -0.06975766f, -0.06058175f, -0.05734138f, -0.33473605f, 0.44067153f, -0.58504033f, 0.19779150f, 
    0.08210750f, 0.00592892f, 0.03597616f, -0.09830595f, 0.04552006f, -0.02890297f, 0.01770438f, -0.03528844f, 
    -0.09162039f, -0.05994418f, -0.22467482f, -0.01055240f, 0.11655924f, 0.09356260f, 0.07390696f, -0.04441964f, 
    -0.01328767f, -0.09553824f, -0.07212442f, 0.00380449f, -0.26494077f, -0.05225991f, 0.27708492f, 0.23502880f, 
    0.11523388f, 0.12632570f, -0.06841755f, 0.02251532f, 0.15177912f, 0.06779047f, 0.11689679f, 0.09115413f, 
    -0.36264023f, 0.32178631f, -0.06522645f, -0.32413879f, 0.10458253f, 0.14386554f, 0.07301154f, 0.08114367f, 
    0.00975502f, 0.06778654f, -0.11730069f, -0.17397462f, 0.13646466f, 0.56056076f, 0.08869357f, -0.10654591f, 
    -0.05782904f, -0.04397958f, 0.03566105f, -0.08208437f, 0.27663943f, -0.04367143f, -0.07141294f, -0.04012229f, 
    0.12869157f, 0.09300123f, 0.04514551f, 0.21575470f, 0.21028140f, -0.00175811f, 0.00231108f, 0.07127057f, 
    -0.18817940f, -0.11152951f, -0.09134305f, -0.22934557f, -0.24107206f, -0.26284903f, 0.39830434f, -0.51745456f, 
    0.20365673f, 0.09776752f, 0.09527851f, 0.22468112f, 0.15081669f, 0.01479121f, -0.06274350f, -0.08318591f, 
    -0.22179972f, 0.47910658f, -0.19992559f, -0.34512413f, -0.00356734f, -0.08111668f, 0.17678712f, 0.01472000f, 
    0.20778733f, 0.02754988f, 0.02524050f, 0.28526175f, -0.48479423f, -0.26240453f, 0.16658807f, -0.03158842f, 
    -0.11273410f, -0.13185024f, 0.03060834f, 0.16168123f, 0.15313570f, 0.01424217f, 0.16238618f, 0.30903590f, 
    0.03873088f, 0.02699064f, 0.07790353f, -0.09669958f, 0.04964161f, -0.04529612f, -0.16714820f, 0.03630650f, 
    -0.18841577f, 0.01921755f, -0.05569757f, -0.10305420f, -0.10524735f, 0.29987594f, -0.05328474f, -0.05632599f, 
    -0.00179626f, -0.09183174f, 0.02198996f, -0.08482341f, -0.07770706f, -0.19469948f, -0.08101500f, 0.06947491f, 
    -0.01405324f, -0.00860821f, 0.04037192f, 0.17502467f, 0.12846144f, 0.02454645f, 0.14394394f, 0.08116437f, 
    0.19084787f, 0.01866270f, 0.18508911f, 0.02702086f, -0.19850169f, -0.10223891f, 0.03143574f, -0.26610148f, 
    -0.15948066f, 0.06194414f, 0.10765443f, 0.17245866f, 0.10406259f, -0.00888179f, 0.12556596f, 0.23226377f, 
    0.27109787f, -0.55040246f, 0.00291380f, -0.12627707f, 0.10445725f, 0.20188531f, 0.09318572f, 0.16928621f, 
    0.08373581f, -0.09603727f, -0.17443508f, 0.07861550f, -0.21046136f, 0.03539044f, -0.02039583f, -0.02753267f, 
    -0.07991597f, 0.06021791f, 0.18456540f, 0.04427511f, -0.05540003f, -0.08037219f, -0.05526755f, -0.20535536f, 
    -0.07333499f, -0.00832135f, -0.04516387f, 0.09846953f, 0.16628723f, -0.06937257f, -0.09506667f, -0.28184465f, 
    -0.17470381f, -0.17163326f, -0.20688668f, -0.21230109f, 0.12248787f, 0.08611782f, -0.07677071f, 0.13403389f, 
    0.01383010f, 0.07189123f, 0.04440958f, -0.12617080f, 0.24194564f, 0.05858267f, 0.22144677f, 0.25133771f, 
    0.12944181f, 0.23298320f, 0.17645557f, -0.31655046f, 0.00166514f, -0.05669295f, -0.08194007f, 0.08430803f, 
    0.15552711f, 0.12555753f, 0.14957142f, 0.21229640f, 0.30990297f, -0.08913629f, -0.20070751f, -0.01109216f, 
    0.10610857f, 0.02370100f, -0.10466968f, 0.01780000f, -0.07093907f, 0.02588124f, 0.10578138f, -0.05426595f, 
    0.08324984f, -0.08671486f, 0.03460656f, -0.01154559f, 0.10837181f, -0.11467847f, 0.05625717f, -0.01812248f, 
    -0.08644094f, 0.08947769f, 0.08694840f, 0.00010839f, 0.04338371f, -0.25863776f, 0.39214814f, 0.19186005f, 
    0.27374312f, -0.01064425f, 0.10360435f, 0.17968117f, -0.00797273f, 0.10132297f, 0.11464861f, -0.05529276f, 
    -0.14764485f, -0.03707815f, -0.00156361f, 0.17852966f, 0.20817985f, -0.01557963f, 0.08803115f, 0.22738773f, 
    -0.11970779f, 0.05355163f, 0.04595086f, -0.07653835f, -0.23994783f, 0.21763691f, -0.19689094f, 0.08727992f, 
    -0.10318580f, 0.06363264f, 0.13164347f, -0.11823469f, -0.02525811f, -0.06404265f, -0.09794468f, -0.16355731f, 
    -0.33128631f, 0.25949353f, -0.29829824f, 0.34341538f, 0.06977604f, 0.14005527f, 0.01928218f, -0.23866522f, 
    0.10270642f, 0.14737281f, -0.02294135f, 0.03957473f, -0.11787049f, 0.20167087f, 0.17504963f, 0.10382456f, 
    0.10788459f, 0.00369939f, 0.06939062f, 0.14035138f, -0.00731765f, 0.00062524f, 0.07666059f, -0.02854914f, 
    0.10882472f, 0.05378359f, -0.04590547f, -0.04867748f, -0.01301649f, 0.01426233f, -0.20561261f, -0.07369657f, 
    -0.10721850f, -0.08954491f, 0.11583812f, 0.09920894f, 0.02572617f, -0.20762698f, 0.04670033f, 0.07388615f, 
    -0.27778497f, -0.03389330f, 0.20245308f, 0.08576526f, 0.13654047f, -0.08354023f, -0.16907583f, -0.03441018f, 
    0.26375151f, -0.23179717f, -0.22267015f, 0.14305846f, -0.02739889f, -0.09791663f, 0.02263064f, 0.05360191f, 
    -0.09470904f, -0.02720133f, -0.07128426f, 0.02889166f, -0.00367117f, -0.06466876f, -0.13295595f, -0.09228398f, 
    -0.02562712f, -0.02880767f, 0.01764088f, 0.13780411f, 0.00425419f, -0.07862777f, -0.07018275f, -0.09764571f, 
    0.28983244f, -0.02675547f, -0.28274536f, 0.20786855f, 0.18271610f, -0.36648151f, 0.06741200f, -0.11166473f, 
    -0.13117215f, 0.24168938f, 0.07766308f, 0.12008665f, -0.24503280f, -0.12018407f, -0.22688650f, 0.13048816f, 
    0.01843072f, -0.13677433f, -0.04023695f, 0.07277051f, 0.03319736f, 0.04657342f, -0.07356828f, 0.10341731f, 
    0.05970703f, 0.16803741f, 0.08761732f, 0.18933235f, -0.11080036f, 0.14107725f, -0.06242717f, 0.07195477f, 
    -0.03406916f, 0.01032377f, -0.04877159f, 0.00130711f, -0.05808138f, -0.20436531f, -0.07604265f, -0.42112345f, 
    0.18552972f, 0.01531782f, 0.15383092f, -0.13791704f, 0.06056618f, 0.15454778f, -0.04093584f, -0.04250170f, 
    -0.01962577f, -0.20526525f, -0.04171295f, 0.14301105f, 0.10955807f, 0.04089672f, -0.03037296f, -0.03210545f, 
    0.02307634f, 0.02866512f, -0.15004778f, -0.03885984f, 0.02103325f, -0.10992587f, -0.12442867f, -0.14423312f, 
    -0.00553523f, -0.10208180f, 0.06356618f, -0.00214991f, 0.04062599f, -0.01802727f, -0.00968320f, -0.04576819f, 
    0.32685393f, 0.04415333f, -0.27036345f, -0.26811051f, 0.07700052f, 0.04718265f, 0.26929960f, -0.12252200f, 
    -0.07718118f, -0.00824436f, -0.21029665f, -0.17957050f, 0.06104892f, 0.11928441f, -0.14277929f, 0.22547801f, 
    0.25354627f, 0.00090393f, -0.07812879f, 0.04081272f, -0.05274976f, -0.03097920f, 0.09600215f, 0.22245403f, 
    0.01551192f, 0.02742118f, 0.05042584f, -0.10385347f, -0.19801822f, -0.09849498f, -0.04408668f, -0.18461823f, 
    -0.08509429f, -0.11257349f, -0.11123352f, -0.00808318f, 0.43343696f, -0.02123118f, 0.20522572f, 0.33555266f, 
    -0.11455498f, -0.05542012f, 0.24184351f, -0.10483616f, 0.29825342f, 0.10391213f, -0.01311137f, 0.01597871f, 
    0.27912378f, 0.19118391f, -0.00722784f, 0.20833154f, 0.02252504f, 0.13175349f, -0.18519168f, -0.17167050f, 
    -0.12175683f, 0.11645217f, 0.10500155f, 0.12801670f, 0.20464119f, 0.60842359f, 0.29846698f, 0.30647847f, 
    0.03954311f, 0.16970392f, -0.06946094f, -0.06820537f, -0.00783286f, -0.07628120f, 0.00531237f, -0.11933741f, 
    0.23729162f, 0.03891301f, -0.40859267f, 0.01746493f, -0.00011387f, 0.00323364f, 0.09046328f, -0.05482886f, 
    0.03315071f, 0.04229336f, -0.12478866f, -0.03654779f, -0.15333518f, 0.11635748f, 0.11705822f, 0.06673516f, 
    0.05606330f, -0.01550318f, 0.03254445f, -0.07927597f, -0.10755536f, 0.05087543f, -0.01045913f, -0.26174042f, 
    -0.19427441f, -0.08655935f, -0.17936981f, 0.07078578f, -0.12853968f, -0.01097183f, 0.11034504f, 0.22918129f, 
    0.11639212f, 0.03650906f, 0.02560990f, 0.14769864f, 0.07000721f, 0.01870921f, 0.18415463f, 0.16296093f, 
    0.15121031f, 0.10727372f, 0.00047013f, -0.11970076f, 0.25234494f, 0.00920028f, 0.17913681f, 0.10610311f, 
    -0.13642280f, 0.26237810f, -0.07423578f, 0.15013006f, 0.01909495f, -0.09046581f, -0.05918642f, 0.04854601f, 
    -0.02065663f, -0.09044831f, 0.19388308f, -0.01775287f, 0.01610616f, -0.06386145f, -0.15067242f, 0.06508277f, 
    0.17527469f, -0.05990605f, -0.04816426f, -0.06912450f, 0.03161285f, -0.14150034f, -0.11599149f, -0.06559990f, 
    -0.05575028f, -0.10136806f, -0.09178909f, 0.07343946f, 0.12268464f, 0.13086344f, 0.04172270f, 0.06461504f, 
    -0.10027920f, -0.03972250f, -0.00278607f, -0.12109326f, 0.16491710f, -0.26525754f, 0.01474715f, -0.12245102f, 
    0.13701119f, -0.00955250f, -0.09707595f, -0.01173657f, -0.08626127f, 0.03756846f, -0.02328566f, -0.04706656f, 
    0.00702023f, -0.01856889f, -0.04373258f, 0.01001248f, -0.05043833f, 0.03654673f, -0.03471817f, 0.00294984f, 
    0.01658084f, -0.01914046f, -0.04277910f, -0.00560182f, -0.04395718f, -0.00091303f, -0.02626598f, -0.04356451f, 
    -0.03716158f, -0.05856755f, -0.04409999f, -0.03510933f, 0.02179043f, 0.01689959f, -0.06774529f, -0.00509509f, 
    -0.00464012f, -0.00720309f, -0.04069946f, -0.01548337f, -0.03256533f, -0.00647434f, -0.00988793f, 0.01582284f, 
    0.01366891f, -0.01597461f, -0.02022081f, -0.02882610f, -0.07084088f, -0.06640788f, -0.05768123f, 0.02474260f, 
    -0.00532577f, -0.05109084f, -0.00617362f, -0.06310183f, -0.03018733f, -0.01515369f, -0.04006479f, -0.04420610f, 
    -0.00075026f, -0.01664659f, -0.06920521f, -0.06992514f, -0.06047363f, 0.00545442f, -0.05141534f, -0.01751378f, 
    -0.06014339f, -0.02317746f, 0.01442072f, 0.00017964f, 0.02491611f, -0.05480274f, -0.02000896f, -0.00679875f, 
    -0.03035873f, -0.04745494f, -0.02033117f, -0.02914124f, -0.04797433f, 0.00162531f, -0.04468294f, -0.04920901f, 
    -0.06460344f, -0.06707253f, -0.04086613f, -0.04415935f, -0.06524369f, -0.06236370f, 0.00417160f, 0.00950984f, 
    0.00942579f, -0.01386399f, -0.00405192f, -0.05772293f, -0.03332902f, 0.00774479f, -0.04039104f, -0.06853160f, 
    -0.06026939f, -0.02172445f, -0.00825875f, 0.00768289f, -0.04876949f, -0.03119718f, -0.05851984f, -0.04477364f, 
    -0.04132115f, -0.02875725f, -0.03553461f, 0.00127347f, 0.00131691f, -0.00094602f, -0.02927455f, -0.00898825f, 
    0.00637151f, -0.04785693f, 0.01157169f, -0.05402980f, 0.01240849f, -0.04528765f, 0.03362610f, 0.02525685f, 
    -0.05736310f, -0.04271455f, 0.01905158f, -0.05924795f, 0.03607114f, 0.01259052f, 0.00163953f, -0.02469009f, 
    -0.04593832f, -0.05167196f, -0.01759104f, -0.04374801f, -0.04677302f, 0.01931911f, -0.02539385f, -0.03950702f, 
    0.02275408f, 0.01645039f, 0.01068190f, -0.05327130f, -0.03738682f, 0.02823685f, -0.03924152f, -0.04551536f, 
    -0.06091347f, 0.01714972f, -0.03098641f, -0.05422355f, 0.02597491f, -0.02542088f, -0.03697834f, -0.00303275f, 
    0.01746157f, -0.05465245f, -0.03693064f, 0.02376780f, 0.03138114f, -0.01276816f, -0.04183090f, -0.06123062f, 
    -0.05706866f, -0.04954771f, 0.00944735f, 0.00332806f, 0.02105747f, -0.05241674f, 0.00413966f, 0.00819513f, 
    -0.00347155f, 0.01997972f, -0.05717407f, -0.01350030f, 0.00160350f, 0.00840097f, 0.02749166f, 0.00789611f, 
    -0.02646234f, -0.06794120f, -0.04715649f, 0.01812242f, -0.04908755f, -0.06690194f, -0.01506044f, -0.05051405f, 
    0.00786451f, -0.05292210f, 0.01857154f, 0.02221186f, -0.06001431f, -0.04395132f, -0.02177400f, -0.05058214f, 
    0.02587294f, -0.00433148f, -0.05513468f, 0.00123045f, -0.00744712f, -0.00957258f, 0.03385073f, -0.03440015f, 
    0.01834338f, -0.06155653f, 0.02844464f, 0.00838836f, 0.01681677f, 0.03216892f, 0.02062948f, -0.05792416f, 
    -0.02288194f, -0.00824198f, -0.04608599f, 0.01845943f, 0.01477158f, 0.00644608f, -0.01118519f, -0.06256167f, 
    -0.03522692f, -0.00495187f, -0.03868289f, -0.01349292f, 0.02500753f, 0.02949791f, -0.03228843f, 0.03705996f, 
    -0.01379965f, 0.00271313f, -0.05186755f, -0.01463844f, -0.02143888f, -0.01969323f, -0.00825909f, -0.05001332f, 
    0.03231670f, 0.00498712f, -0.00927679f, -0.01625500f, -0.05178535f, -0.00663508f, -0.03496331f, -0.05054119f, 
    -0.02485908f, -0.05969338f, -0.01175392f, 0.01365601f, -0.06966943f, -0.05764158f, -0.03785287f, 0.02607886f, 
    -0.00623132f, 0.03061453f, -0.05674234f, 0.02465788f, -0.04851056f, -0.06331645f, -0.00443782f, 0.02931301f, 
    0.02754574f, -0.02334310f, -0.06251922f, -0.00292385f, -0.06204888f, -0.03043325f, 0.01016904f, -0.07133741f, 
    0.02447298f, -0.01507831f, -0.04129198f, 0.01148839f, -0.04173189f, -0.00456848f, 0.01438518f, -0.04246970f, 
    -0.01332766f, 0.03276029f, -0.06107103f, 0.03131299f, -0.06010747f, -0.01924587f, -0.01602901f, 0.01504265f, 
    0.01946009f, 0.02960827f, -0.02150925f, -0.05011646f, -0.03093920f, -0.04903403f, -0.00697459f, -0.01553628f, 
    0.02493159f, 0.03053165f, -0.04503629f, -0.04867025f, -0.01724495f, 0.03936416f, -0.03557440f, -0.04233924f, 
    -0.00834724f, -0.04578426f, 0.01713739f, -0.03874159f, 0.00170593f, -0.01165638f, 0.00101437f, 0.01870023f, 
    0.01792382f, -0.01603958f, -0.00485946f, 0.02385090f, -0.06220242f, 0.01517832f, 0.00354289f, -0.07619453f, 
    -0.00710677f, -0.02333313f, 0.00572386f, -0.05546653f, -0.01325895f, -0.00345813f, -0.02514939f, -0.03824012f, 
    0.02656204f, -0.01591968f, 0.01352384f, -0.06514781f, 0.01745136f, -0.03776387f, -0.02481498f, 0.01285003f, 
    -0.05929815f, -0.01767948f, 0.00077609f, -0.05995524f, -0.00165930f, 0.01038568f, -0.05107300f, -0.02230583f, 
    -0.06535214f, -0.04865320f, -0.04735872f, -0.06805494f, 0.02978605f, -0.05959647f, -0.00866200f, -0.04661606f, 
    -0.05792406f, 0.03291684f, -0.01731726f, 0.00985277f, 0.00912243f, 0.03487113f, -0.06155559f, -0.01505698f, 
    -0.01159607f, -0.03560602f, -0.05349052f, -0.04791212f, -0.03454953f, -0.05824260f, 0.03382663f, 0.00933990f, 
    -0.00574105f, -0.02932449f, -0.06141245f, -0.01731514f, -0.00020181f, -0.05867402f, -0.03925639f, -0.01213508f, 
    -0.03537106f, 0.02979610f, 0.01527731f, -0.04333513f, 0.01961538f, 0.00455406f, -0.00135134f, -0.02210953f, 
    -0.04089211f, -0.04643199f, 0.00484626f, 0.03283775f, 0.00899980f, 0.03380966f, 0.01858599f, 0.01214716f, 
    -0.00936157f, -0.04901135f, 0.00753642f, 0.00267044f, -0.02020744f, 0.00449233f, -0.07201140f, -0.01735455f, 
    -0.01561593f, -0.43535474f, 0.13569482f, 0.06229893f, -0.08639468f, 0.04633334f, 0.03464277f, 0.21914677f, 
    0.00173959f, -0.07618761f, 0.01532768f, 0.04871909f, 0.02330868f, 0.15600519f, -0.02164822f, 0.07346421f, 
    -0.04660097f, 0.03333833f, 0.10773293f, 0.00609775f, 0.10597795f, 0.03040557f, 0.09804699f, -0.02151318f, 
    0.47386622f, 0.04890146f, 0.21156608f, 0.10790556f, 0.04065495f, -0.00572815f, -0.01989625f, 0.00807512f, 
    0.02735171f, 0.11676846f, 0.16784310f, 0.06774097f, 0.14083128f, -0.17367181f, -0.18396205f, -0.33382708f, 
    0.06117899f, 0.03254054f, 0.12232477f, -0.03601678f, 0.03527513f, 0.09098329f, 0.12499841f, -0.00332217f, 
    -0.12341001f, -0.23992580f, 0.01164234f, 0.15815122f, 0.05928950f, 0.04656968f, -0.05385145f, -0.01571978f, 
    -0.03713517f, 0.01976158f, 0.06118815f, -0.12170994f, 0.20294802f, 0.28911507f, 0.16920853f, -0.00862014f, 
    0.01857776f, -0.07069305f, -0.00808993f, -0.08365580f, -0.05063042f, 0.12628122f, 0.00797952f, -0.03946162f, 
    0.10228830f, 0.03446757f, -0.18748723f, -0.20584600f, -0.10308623f, -0.04642934f, 0.08972090f, -0.07043287f, 
    -0.08857896f, 0.02448638f, 0.00158612f, 0.05000677f, 0.08925943f, -0.07908465f, 0.08218218f, -0.12244675f, 
    -0.16292018f, 0.06223515f, 0.01027685f, 0.01704289f, -0.13007195f, 0.08157866f, 0.04782740f, -0.15425950f, 
    0.17731439f, 0.09401668f, 0.10820653f, -0.05799436f, 0.02037967f, 0.05655137f, -0.02490544f, -0.01407853f, 
    0.13827835f, 0.19071141f, 0.05662296f, 0.18297890f, 0.25226828f, -0.02834368f, -0.38102287f, -0.00922419f, 
    -0.13965550f, -0.10465432f, -0.03504950f, 0.06643948f, -0.12905650f, -0.04425403f, -0.13101041f, -0.01231858f, 
    0.04867812f, 0.28763506f, -0.02351466f, 0.03325526f, -0.03514225f, 0.05405987f, 0.02203301f, 0.03681636f, 
    0.01757242f, 0.00901556f, 0.00091389f, 0.06362751f, -0.03883675f, 0.09297743f, 0.08595388f, -0.00731398f, 
    0.06166574f, -0.08292289f, -0.09855577f, -0.03324325f, -0.13777781f, -0.03038566f, -0.01980153f, -0.04572047f, 
    0.03099426f, 0.13165584f, 0.11464068f, 0.25268936f, -0.00875486f, -0.04970941f, -0.07091394f, 0.03158465f, 
    -0.05947291f, 0.03885042f, 0.05557591f, 0.11583806f, 0.34961987f, 0.05088557f, 0.11893087f, -0.15402615f, 
    0.00762679f, 0.18169253f, -0.04183186f, 0.00499534f, 0.15030809f, 0.01697480f, 0.07937694f, 0.06811306f, 
    0.00033085f, -0.23596546f, -0.31644052f, -0.33142781f, -0.01801725f, 0.16054758f, 0.15045092f, 0.00664408f, 
    0.05099553f, -0.02541163f, 0.05418697f, -0.09490801f, 0.05229638f, 0.33588144f, 0.19935846f, 0.15197378f, 
    0.17053862f, 0.11315105f, 0.23220864f, 0.14764148f, 0.03718367f, -0.03445824f, 0.00860878f, -0.02622016f, 
    0.11839714f, 0.21214171f, 0.04673833f, -0.06196225f, -0.03240780f, -0.03410722f, 0.04409408f, -0.09666216f, 
    0.03463111f, -0.06874766f, -0.06077411f, -0.01702819f, 0.25027487f, -0.27203643f, -0.04783756f, -0.25461191f, 
    0.04208625f, -0.06250785f, 0.04273459f, 0.04338560f, 0.02044231f, 0.06954752f, 0.05884874f, 0.00526801f, 
    0.07546384f, -0.05812859f, 0.04235256f, -0.00709704f, 0.08825697f, -0.01435998f, -0.03752068f, -0.15840898f, 
    0.00573136f, -0.01568520f, -0.03190785f, -0.18862027f, -0.35895404f, -0.14823909f, -0.08632866f, 0.08914273f, 
    -0.02708862f, -0.02953114f, -0.02259921f, 0.12756902f, 0.13695264f, 0.18779999f, -0.00192724f, -0.03747865f, 
    0.34849113f, 0.26150727f, 0.00487183f, 0.00862412f, 0.02320730f, -0.18665609f, -0.09988681f, -0.14525908f, 
    -0.12757094f, -0.01228076f, -0.03393537f, -0.01223385f, 0.13140960f, 0.05261209f, 0.19740421f, 0.35064015f, 
    0.13136078f, 0.12587233f, 0.15246455f, 0.04635436f, 0.07517967f, 0.08033060f, -0.09352827f, 0.05459302f, 
    -0.56579483f, -0.45640481f, -0.30555233f, -0.08658704f, -0.15028919f, 0.12469342f, 0.15122475f, 0.04600269f, 
    0.05743779f, -0.08367447f, 0.02140999f, 0.00267979f, -0.06161363f, -0.21529204f, -0.34252593f, -0.31182057f, 
    -0.04231634f, -0.08232158f, 0.02433285f, 0.18855569f, -0.02725824f, 0.05100187f, 0.12961511f, 0.13419494f, 
    0.22844356f, 0.16942887f, 0.06461903f, 0.03452393f, -0.06330974f, 0.00454950f, 0.07845954f, -0.08109787f, 
    -0.00345709f, 0.05856165f, -0.04684465f, 0.02202743f, -0.16785848f, -0.19746976f, -0.16947760f, -0.23024790f, 
    0.14245073f, 0.03840417f, 0.07197429f, -0.00230598f, -0.04214109f, -0.07878430f, -0.19399403f, -0.12558305f, 
    0.03603158f, -0.19978672f, -0.04906825f, 0.01708048f, 0.06803065f, -0.01359390f, 0.08214200f, 0.16544357f, 
    0.13484621f, 0.00579101f, 0.08387295f, 0.01414632f, -0.06365801f, -0.07147352f, -0.36013541f, -0.14616005f, 
    -0.00502351f, -0.12549040f, 0.20031522f, 0.00419556f, 0.08624693f, -0.03052977f, 0.00047218f, 0.09029336f, 
    0.14220512f, 0.19298649f, 0.03195849f, -0.02238415f, -0.08573744f, 0.12149572f, 0.07392050f, -0.03999784f, 
    0.03385006f, 0.01928764f, 0.05960278f, 0.06957278f, 0.00735165f, 0.07729002f, 0.07003355f, -0.02468488f, 
    -0.07508552f, -0.01697458f, 0.06529772f, 0.02784643f, -0.12105801f, -0.12758999f, 0.06453995f, -0.07274359f, 
    0.01234709f, 0.08468173f, 0.01874956f, 0.03976944f, 0.04062390f, 0.02537502f, -0.07192554f, -0.05337507f, 
    -0.14300755f, -0.16786551f, -0.07682856f, -0.07450029f, 0.17727214f, 0.18227418f, 0.09414370f, -0.05687938f, 
    0.01842874f, 0.09579094f, 0.03408575f, 0.08977617f, 0.07290573f, -0.10519593f, -0.07272252f, -0.03696780f, 
    -0.01273453f, 0.04336777f, 0.00704785f, 0.04496914f, -0.04573939f, 0.01668503f, 0.01719498f, -0.04227186f, 
    -0.03804035f, -0.01086562f, -0.00423344f, -0.01294415f, 0.00385585f, 0.03752133f, -0.01213375f, -0.00356431f, 
    -0.03491524f, 0.00955441f, 0.00524383f, 0.03546380f, 0.03318499f, -0.00466173f, -0.04591694f, 0.02976947f, 
    -0.03301540f, 0.03137177f, 0.04265011f, 0.01276498f, 0.01123796f, -0.01546856f, 0.01064946f, -0.01945936f, 
    -0.01992937f, -0.05066356f, 0.02618065f, 0.03462196f, -0.02844949f, -0.03281377f, 0.02869545f, -0.00336312f, 
    -0.04743499f, -0.03688474f, 0.04268748f, -0.04207647f, 0.01345595f, -0.05336790f, -0.05156508f, 0.00316430f, 
    0.01482911f, -0.04970717f, -0.00265096f, 0.00842249f, 0.03755042f, 0.03385844f, 0.03586247f, 0.02189727f, 
    -0.04781627f, 0.00276940f, -0.04205568f, 0.00576654f, -0.05517902f, 0.02515523f, -0.04639378f, -0.01118445f, 
    0.01949110f, 0.03180532f, 0.01537909f, 0.00485415f, 0.02932631f, 0.00281819f, 0.00565521f, -0.02178480f, 
    -0.04624779f, -0.03025750f, -0.02205591f, -0.00370069f, 0.00707971f, 0.01783961f, 0.03156405f, 0.00792887f, 
    -0.03047465f, -0.05756175f, 0.00634927f, 0.01356936f, 0.03760390f, 0.03787003f, -0.02285169f, 0.02447458f, 
    0.03588054f, -0.05415814f, 0.00809478f, -0.00158569f, -0.00076229f, -0.00633578f, 0.02946108f, 0.03925961f, 
    -0.02716577f, 0.02109396f, 0.00863014f, 0.04292702f, 0.01968173f, 0.01100564f, -0.00449958f, -0.05705282f, 
    -0.04967567f, -0.05311565f, 0.01081752f, -0.04669823f, -0.03046613f, -0.00171946f, 0.00041075f, 0.02346029f, 
    0.02315561f, -0.02821690f, 0.03456485f, -0.02189641f, -0.03365079f, -0.00118414f, 0.00383516f, 0.01350916f, 
    -0.03499586f, -0.05946742f, -0.01592467f, -0.04084387f, 0.03790427f, 0.02363513f, -0.02035641f, 0.01841290f, 
    -0.03837157f, -0.04245972f, -0.00040639f, 0.02965710f, -0.02028863f, -0.00900220f, -0.05389645f, 0.00242454f, 
    -0.02615762f, 0.01518383f, -0.04903624f, -0.04866757f, 0.02937404f, -0.05289634f, -0.03368030f, 0.01097813f, 
    -0.03409251f, 0.00678641f, -0.05499868f, -0.03693878f, -0.03546232f, -0.04165619f, 0.00225229f, -0.00030735f, 
    -0.03298070f, -0.05799295f, 0.02668338f, 0.03967043f, 0.00323932f, -0.05173951f, 0.02300695f, -0.03816365f, 
    -0.00216054f, 0.01408773f, -0.01168679f, 0.03657120f, -0.05099629f, 0.00477590f, 0.00567611f, -0.02459394f, 
    -0.00025163f, -0.02009143f, 0.03325944f, -0.03176235f, -0.00597438f, -0.05714295f, -0.01614002f, -0.03315079f, 
    0.01194885f, -0.05395586f, -0.01161245f, -0.04117576f, 0.00522492f, 0.00117793f, -0.00763661f, 0.00977209f, 
    -0.00059877f, 0.02909976f, -0.03799208f, -0.05421571f, 0.03248851f, 0.01095949f, -0.01523182f, 0.01686992f, 
    0.03909053f, 0.01361886f, -0.03889583f, 0.02873185f, 0.02086854f, 0.02703601f, -0.01509066f, -0.04998526f, 
    0.02655415f, 0.02443124f, -0.04556034f, 0.01659532f, -0.02913645f, -0.04376974f, -0.04621700f, -0.03709024f, 
    0.04275852f, 0.00581504f, 0.02529462f, -0.05101432f, -0.05644887f, 0.03689261f, 0.01341944f, -0.02756237f, 
    -0.03715254f, -0.05320069f, -0.04330868f, -0.05590047f, 0.03900085f, 0.00687389f, -0.03214572f, 0.00881785f, 
    -0.01553688f, -0.05224545f, -0.01250059f, -0.01428836f, -0.04540313f, 0.00775108f, 0.00820095f, -0.00426867f, 
    0.04174273f, 0.02948598f, 0.01096015f, -0.00429675f, -0.05387356f, 0.02127291f, -0.03517482f, -0.02598302f, 
    0.02223747f, -0.03303576f, -0.05857993f, 0.02746211f, -0.00510984f, -0.00024539f, 0.03758657f, 0.03544964f, 
    0.02853169f, -0.03854066f, -0.03709563f, -0.01649701f, -0.04574835f, 0.00926661f, -0.05728613f, -0.02320185f, 
    0.04192660f, 0.03850641f, 0.00731095f, 0.00051722f, -0.05664595f, -0.03047992f, 0.02168149f, 0.03620375f, 
    0.01233678f, 0.00714994f, 0.01578565f, 0.01473848f, 0.02810646f, 0.02875359f, -0.02322922f, -0.02630430f, 
    0.00573503f, -0.03567752f, -0.05570626f, -0.05539035f, 0.02979933f, -0.04784166f, -0.00566218f, 0.01847927f, 
    -0.03894912f, -0.01836752f, 0.01311214f, -0.04896471f, -0.01529122f, 0.01977998f, -0.03624270f, -0.05838408f, 
    -0.00689042f, -0.01644324f, 0.01185671f, -0.00491434f, 0.00243169f, -0.02454765f, -0.04099860f, 0.00601254f, 
    -0.02886518f, -0.02078473f, -0.04386260f, -0.03844144f, -0.00077050f, -0.01033276f, -0.02786556f, 0.03724212f, 
    -0.04532333f, 0.02713129f, -0.05210442f, -0.00643753f, 0.02960973f, -0.00975820f, -0.03776808f, 0.01104446f, 
    0.02177355f, 0.01392747f, -0.03373772f, 0.02937145f, -0.01193964f, 0.03010408f, -0.02537425f, -0.01257415f, 
    0.00440237f, -0.05962770f, 0.02206882f, -0.03314514f, 0.00273049f, -0.00252149f, 0.04100508f, 0.00183570f, 
    -0.02502881f, -0.00900214f, -0.02773971f, 0.03150118f, 0.02360574f, 0.02314755f, 0.03877744f, 0.00445203f, 
    -0.02787505f, -0.04422288f, 0.03791249f, -0.02706703f, -0.04286980f, -0.03683748f, -0.03523558f, -0.03978822f, 
    -0.05582184f, -0.02806755f, 0.04090191f, -0.00559692f, -0.00355558f, 0.00165215f, -0.05522254f, -0.04711374f, 
    -0.01561851f, -0.05109706f, 0.03094692f, -0.00460253f, -0.05399476f, -0.03321869f, -0.05248028f, -0.01621692f, 
    -0.04315727f, -0.02207313f, -0.00623326f, 0.03795138f, 0.02823076f, -0.01560702f, 0.04235428f, -0.02352235f, 
    -0.05313765f, 0.04001931f, 0.01682426f, -0.03293614f, -0.00687916f, -0.00501141f, 0.00009517f, 0.03806775f, 
    -0.02370295f, -0.02515578f, -0.04488643f, 0.01957685f, -0.01228775f, -0.03167870f, -0.02486571f, 0.02536136f, 
    0.02413015f, 0.33953872f, 0.28844523f, -0.00946456f, 0.02355445f, -0.12002639f, 0.19214930f, 0.07027470f, 
    0.13675706f, -0.04086902f, -0.00021962f, 0.07662338f, 0.08674692f, -0.22007453f, 0.02118172f, 0.15582334f, 
    0.04217394f, 0.07530037f, -0.04051804f, 0.00475024f, 0.11842024f, 0.04270278f, -0.01369792f, 0.20528255f, 
    -0.28426284f, -0.06176756f, -0.09505708f, 0.02608605f, -0.04428342f, 0.09059093f, -0.03146074f, -0.04580007f, 
    -0.04196702f, 0.04973864f, -0.18409297f, -0.07248440f, -0.18401238f, 0.07113613f, -0.11263046f, 0.27853796f, 
    0.04106663f, 0.13029702f, -0.04924306f, -0.00204022f, 0.01572017f, 0.05191236f, -0.08690572f, 0.11867407f, 
    0.03221924f, 0.19839247f, -0.05984875f, 0.11211241f, 0.01135262f, 0.05504136f, -0.02309746f, 0.11321004f, 
    0.05009635f, 0.05962969f, -0.03478463f, 0.12706481f, -0.13609625f, -0.18703935f, -0.26213649f, 0.13616975f, 
    -0.21732798f, 0.05684470f, -0.02873519f, 0.00877338f, -0.00958077f, 0.05913798f, -0.07692506f, -0.21144319f, 
    -0.21288864f, 0.17133735f, 0.01281129f, 0.21243145f, 0.04121142f, 0.04582325f, 0.02543705f, 0.04756372f, 
    -0.06247301f, 0.01782171f, -0.03606008f, -0.02264496f, -0.12940870f, 0.18847728f, -0.07770324f, 0.37165210f, 
    0.13570093f, -0.18863671f, 0.10742763f, -0.08980565f, -0.12819289f, 0.08465491f, 0.01187590f, -0.17247771f, 
    -0.23261069f, 0.19593523f, -0.12867236f, -0.00684065f, -0.04383187f, -0.01896086f, -0.03688335f, 0.01415870f, 
    -0.03081534f, 0.19052371f, 0.13239633f, 0.10552478f, -0.22294430f, -0.03244581f, 0.17160127f, 0.41540053f, 
    0.03433150f, 0.01700435f, -0.14018609f, -0.04842743f, -0.03643344f, 0.04266161f, -0.05205308f, -0.10810331f, 
    0.27276012f, -0.13131852f, 0.24079198f, 0.16768312f, 0.11644220f, 0.18331894f, 0.10549712f, 0.08856104f, 
    -0.07956035f, -0.04508635f, 0.08477011f, 0.01198711f, 0.04358745f, -0.03572774f, -0.13367306f, 0.01943699f, 
    0.00631030f, 0.07783052f, 0.00243357f, 0.05916645f, -0.07047570f, 0.01724461f, -0.20733501f, -0.02272668f, 
    0.12089895f, -0.35954285f, 0.04254478f, -0.07651230f, 0.05341827f, -0.07632630f, 0.16862617f, -0.13040157f, 
    0.19823568f, 0.00886075f, -0.05082008f, 0.06140753f, -0.62244630f, 0.00982223f, -0.38351640f, 0.04179551f, 
    -0.01537481f, -0.05524779f, -0.00581686f, -0.06093190f, -0.08680796f, 0.15973936f, -0.07234450f, 0.07723700f, 
    0.13384292f, 0.38675016f, 0.26660436f, 0.30837697f, 0.03572582f, -0.12354566f, 0.03013185f, 0.09124066f, 
    -0.13268711f, 0.02598404f, -0.07016270f, 0.07221869f, 0.68550235f, -0.29881302f, 0.10745562f, -0.29430488f, 
    -0.16990305f, -0.03159341f, -0.03575902f, -0.11807483f, 0.07577626f, -0.03755257f, -0.06020898f, 0.03093568f, 
    0.05142758f, -0.08078894f, 0.03930366f, 0.10624325f, -0.00482757f, -0.03420006f, -0.05355256f, -0.04344637f, 
    -0.02956703f, 0.04053836f, -0.03333745f, -0.18853736f, -0.42882881f, -0.27161664f, -0.01314333f, 0.37436572f, 
    0.09024698f, 0.18934584f, -0.02063431f, -0.26285005f, -0.01850497f, -0.09936213f, -0.11382394f, 0.03718493f, 
    -0.00925082f, 0.01276158f, 0.07165330f, 0.09184033f, 0.06100924f, 0.14279786f, 0.13927016f, 0.17521745f, 
    -0.08686690f, 0.02314624f, -0.00950310f, -0.19004829f, 0.12317507f, 0.08211648f, 0.21995364f, 0.02248909f, 
    0.05696939f, 0.05713028f, 0.03535375f, 0.03413383f, 0.06581403f, -0.06191583f, -0.01164054f, 0.02768550f, 
    0.01807255f, -0.13907672f, 0.29229438f, 0.16088745f, -0.05030125f, 0.10667682f, 0.06624721f, -0.01506594f, 
    0.01195178f, 0.01317539f, -0.03909916f, -0.10230862f, -0.18050322f, 0.13452122f, 0.26105583f, 0.05791068f, 
    0.09726389f, 0.08749838f, -0.24411619f, 0.03846615f, 0.16118985f, -0.12161798f, 0.11551320f, 0.04744796f, 
    0.67624140f, 0.29179525f, 0.26826295f, 0.03583164f, 0.08874184f, -0.24462597f, 0.00659160f, 0.05348554f, 
    0.03948639f, 0.00274376f, 0.03369574f, -0.00350781f, -0.00313730f, -0.14362448f, 0.16673774f, 0.35320362f, 
    0.03832105f, -0.08649234f, -0.16468090f, -0.08420017f, -0.06052973f, -0.05308840f, 0.01040511f, 0.07477128f, 
    -0.12843475f, -0.01840432f, 0.14750643f, -0.02863776f, -0.03809897f, 0.02601018f, -0.01759213f, -0.01148783f, 
    -0.04271853f, -0.07430934f, 0.04908808f, -0.00480080f, 0.13117775f, 0.03185349f, 0.20603059f, 0.26226184f, 
    -0.09751242f, -0.11361712f, 0.03354353f, 0.15211853f, 0.10380152f, -0.05952142f, 0.06005266f, -0.12197982f, 
    -0.08552030f, 0.00804578f, 0.26766548f, 0.09091266f, 0.09221267f, 0.07206561f, -0.03449446f, 0.10351296f, 
    0.13468681f, 0.01365124f, 0.11500599f, 0.20287296f, -0.05557695f, 0.02496609f, 0.19038814f, 0.17793489f, 
    -0.02962426f, 0.01958019f, -0.07165660f, -0.07233489f, 0.08378135f, 0.00806738f, -0.12086686f, 0.24681516f, 
    -0.04514172f, -0.21387053f, -0.04547334f, 0.40937552f, 0.05207858f, -0.04128692f, -0.10351390f, -0.04241201f, 
    0.06107834f, -0.08795653f, 0.04358538f, 0.08846333f, 0.09577658f, -0.23080540f, -0.13994415f, -0.03661503f, 
    0.10277970f, 0.24016665f, 0.09970517f, -0.06781390f, -0.01994923f, 0.07421288f, -0.04640735f, -0.00577818f, 
    0.09281209f, 0.01556193f, -0.04348108f, 0.05628442f, 0.12127464f, 0.06473826f, 0.02429384f, 0.10614295f, 
    -0.03678429f, -0.13355695f, 0.13035993f, -0.06700360f, 0.20490940f, -0.05116051f, -0.01774179f, -0.02198683f, 
    -0.09107792f, -0.16028546f, 0.03912637f, -0.09101380f, 0.06220765f, 0.11787672f, 0.13842125f, 0.13847706f, 
    0.01510419f, -0.05302597f, -0.04995975f, 0.02989257f, -0.00373125f, -0.01557669f, 0.04088793f, 0.03719911f, 
    0.03453074f, -0.00718583f, 0.04625171f, 0.03021899f, 0.03667243f, -0.03113028f, 0.04091594f, -0.03571976f, 
    0.00923984f, 0.02820997f, -0.04853347f, 0.00704140f, -0.02514536f, 0.05348572f, 0.01755091f, 0.01021831f, 
    0.00951110f, 0.00906440f, 0.04189050f, -0.02470074f, 0.04314083f, -0.02923889f, 0.03233120f, -0.01388038f, 
    0.05400896f, -0.03938762f, 0.01255374f, -0.00972588f, 0.02589111f, -0.00058915f, 0.01610399f, -0.02117175f, 
    0.01410638f, 0.00617058f, 0.00753504f, -0.00880576f, 0.03214598f, 0.02621064f, -0.04548622f, 0.01093701f, 
    0.01857122f, 0.03019699f, 0.00219092f, -0.02321455f, -0.04249609f, -0.05192399f, 0.03772516f, -0.03613456f, 
    -0.02203616f, -0.00105069f, -0.03933493f, -0.01335901f, 0.02228545f, 0.01972840f, 0.02201072f, -0.00571610f, 
    -0.01874622f, 0.01868496f, -0.03227483f, 0.02422443f, -0.04560772f, -0.02680865f, -0.03812452f, -0.03207266f, 
    0.04699622f, -0.01722640f, 0.04533856f, -0.04375898f, 0.00804020f, 0.00878896f, -0.01139685f, 0.03809192f, 
    -0.02954815f, -0.02691513f, 0.00421421f, -0.00640419f, -0.00650605f, 0.00813667f, -0.02591500f, -0.00481040f, 
    -0.05040365f, -0.03617679f, 0.01143602f, -0.02908684f, 0.00200086f, 0.01169092f, 0.00901063f, 0.03237604f, 
    0.00176726f, 0.00710694f, 0.00808533f, -0.00532361f, -0.00079002f, -0.03616901f, 0.00747827f, -0.02254480f, 
    -0.03982786f, -0.03780576f, -0.02154849f, 0.04239792f, -0.02647965f, -0.01965007f, 0.04068288f, -0.02908221f, 
    -0.03710987f, -0.00692659f, 0.02758068f, 0.01583268f, 0.00613411f, -0.00948772f, 0.01977733f, -0.01188692f, 
    -0.04856306f, -0.04420513f, -0.03330302f, -0.01265333f, 0.01574622f, -0.03694333f, 0.02637849f, -0.03001804f, 
    0.03036634f, 0.02712217f, -0.04907738f, 0.02381144f, 0.02491770f, 0.00374227f, -0.05194325f, -0.05644451f, 
    -0.01953457f, 0.03044996f, -0.01751175f, -0.04660489f, -0.02293933f, 0.02337372f, 0.00197956f, -0.04127258f, 
    0.00593972f, 0.01739591f, -0.05167326f, -0.03229295f, -0.03450175f, -0.00422562f, 0.00363991f, 0.04022771f, 
    -0.04683332f, 0.01728969f, -0.05010767f, 0.00370060f, -0.03472126f, 0.01637040f, -0.05253943f, -0.00453310f, 
    -0.03060520f, -0.01896347f, -0.01159422f, -0.00572665f, 0.01030370f, 0.04022095f, 0.03604831f, 0.03014510f, 
    -0.03082470f, -0.00808913f, -0.03026263f, -0.01543150f, 0.00620759f, 0.01802728f, -0.01441316f, -0.00535425f, 
    -0.02385836f, -0.04065325f, 0.00631938f, 0.02586243f, -0.00925203f, -0.03918800f, -0.03142409f, -0.02378779f, 
    -0.02564938f, 0.03508796f, -0.01818419f, 0.00066589f, -0.04916363f, -0.01620596f, -0.04513722f, -0.04475933f, 
    0.01240104f, 0.04589263f, -0.01518793f, 0.01579035f, -0.03806383f, -0.01564576f, 0.01906424f, -0.03531381f, 
    0.00339549f, 0.02841760f, -0.01254457f, -0.02729720f, -0.05170999f, 0.02957870f, -0.01535727f, 0.03739880f, 
    -0.03367395f, -0.01277440f, 0.03369607f, -0.02041432f, -0.01358404f, -0.00500394f, 0.01390194f, 0.00621877f, 
    -0.04841096f, -0.04267953f, -0.00293969f, -0.00623648f, -0.00324427f, 0.02902658f, 0.03196393f, -0.04039511f, 
    0.00500688f, -0.03084675f, -0.02946797f, -0.02006324f, -0.04789804f, 0.03831987f, 0.02444300f, -0.02551383f, 
    0.02993249f, 0.01462245f, -0.00660451f, 0.02406431f, 0.01615966f, -0.01636554f, -0.04070307f, -0.00225610f, 
    -0.03911044f, 0.01668988f, -0.00512379f, -0.03950898f, 0.00972972f, 0.03884662f, 0.00776554f, 0.02843266f, 
    -0.04753499f, -0.05200579f, 0.00032087f, -0.03121221f, -0.04025163f, -0.00283998f, 0.02521471f, 0.00926128f, 
    -0.01296123f, -0.04569685f, -0.01500157f, -0.03775214f, 0.04163643f, 0.01026295f, -0.02928327f, 0.02278696f, 
    -0.03278841f, -0.05091032f, -0.05090130f, -0.03834467f, 0.03811511f, -0.03711046f, -0.03859267f, 0.03454233f, 
    -0.01506420f, -0.04124220f, -0.00228325f, -0.04433343f, -0.02113248f, -0.02358645f, 0.00091042f, -0.00824110f, 
    -0.02405619f, 0.01111680f, -0.02480256f, 0.02856898f, -0.00504480f, -0.02195694f, 0.03564514f, -0.02411347f, 
    0.00886957f, 0.02973986f, 0.03442933f, -0.01589616f, -0.04247293f, 0.02679845f, 0.01500913f, 0.03810303f, 
    0.03100969f, -0.03704461f, -0.05502265f, 0.00608632f, -0.00834715f, -0.01728207f, -0.05658128f, 0.02913970f, 
    0.02749314f, -0.00561147f, -0.04469880f, 0.00827891f, 0.04717046f, 0.02397311f, -0.04483778f, 0.01783093f, 
    0.03436635f, 0.04733961f, 0.03679422f, 0.00421610f, 0.00753972f, -0.04928224f, 0.03333765f, -0.03425027f, 
    -0.01713911f, -0.02730481f, 0.02633920f, -0.02639414f, 0.02082314f, 0.01017718f, -0.00828962f, 0.04743177f, 
    0.01980757f, 0.01022482f, 0.04742639f, 0.01734432f, -0.00946529f, 0.02840305f, -0.00141029f, -0.01309953f, 
    -0.03070919f, 0.02893646f, -0.01991218f, -0.00362592f, -0.04368930f, 0.04473957f, 0.00796123f, 0.00831536f, 
    -0.02068075f, 0.02092652f, 0.01208650f, 0.03394930f, -0.04301798f, -0.03207454f, -0.00515281f, -0.04614155f, 
    0.00972077f, -0.04860496f, 0.03334937f, -0.00181027f, 0.01389514f, -0.05686595f, -0.02499515f, -0.04010141f, 
    -0.00828548f, -0.03331314f, -0.03837693f, -0.03653794f, -0.03287730f, 0.04468661f, -0.04151666f, -0.00492619f, 
    -0.00223173f, -0.02981717f, 0.01897616f, 0.03619708f, 0.01296816f, -0.02080480f, 0.00457754f, -0.03616048f, 
    -0.00699568f, -0.04630551f, 0.02801115f, 0.03756616f, -0.01892137f, 0.01014110f, -0.02789617f, 0.00612239f, 
    -0.02668909f, 0.00761531f, -0.03865966f, -0.01088440f, 0.01314453f, -0.02985382f, 0.01356718f, -0.00538881f, 
    -0.00882061f, -0.00996451f, -0.04503658f, -0.05076728f, 0.00133272f, -0.02323258f, -0.05401438f, -0.02536039f, 
    0.00279348f, -0.05460468f, -0.05374961f, 0.03455490f, -0.03430767f, -0.03193591f, 0.00467795f, 0.04352854f, 
    0.04505433f, -0.02510859f, 0.00751579f, 0.03957926f, -0.02596509f, -0.02247974f, 0.00003376f, 0.01829793f, 
    -0.01154603f, -0.03458747f, -0.03745041f, -0.00558774f, 0.01968427f, -0.05562445f, -0.03418023f, -0.00039133f, 
    -0.04773828f, 0.03844833f, -0.01280017f, -0.01347499f, -0.02566402f, 0.02640792f, -0.04320465f, 0.03646341f, 
    -0.00793702f, -0.00664803f, -0.01875763f, 0.02413170f, 0.02132915f, -0.03361625f, 0.00808578f, 0.03340599f, 
    -0.00467756f, 0.00194009f, 0.02106186f, 0.03819614f, 0.03660090f, -0.02599675f, 0.01965613f, -0.05097375f, 
    -0.03987896f, -0.04328765f, -0.01763897f, 0.03143287f, -0.01289396f, 0.04426485f, 0.03244342f, -0.05592419f, 
    -0.03968101f, -0.02284624f, -0.04190478f, -0.03442691f, -0.03419784f, -0.02356121f, -0.02038710f, 0.01350006f, 
    -0.03293652f, 0.03723960f, -0.02470291f, 0.02178530f, -0.00398458f, 0.00321427f, -0.00743281f, -0.02582207f, 
    0.02912739f, 0.02373271f, -0.03301293f, -0.03163767f, 0.00854238f, -0.03501964f, -0.01251564f, -0.03555555f, 
    0.00779321f, 0.01564515f, 0.02181351f, -0.00017673f, -0.03478968f, -0.05249197f, -0.01422458f, -0.02137946f, 
    -0.01168662f, 0.03630923f, 0.01168997f, 0.03397148f, -0.01317623f, -0.02222409f, -0.04092903f, -0.04670260f, 
    -0.01904025f, -0.04145527f, -0.03305198f, -0.05125640f, 0.03611280f, 0.00573057f, -0.02163282f, -0.03310185f, 
    -0.05275574f, 0.01088725f, 0.03276948f, 0.02819889f, -0.00670963f, -0.03765656f, -0.03234653f, 0.00931831f, 
    -0.01016878f, -0.02685571f, -0.02513482f, 0.01809942f, -0.01374690f, 0.00734782f, -0.00057987f, 0.03399909f, 
    0.01935835f, 0.00542305f, -0.04692854f, -0.04652568f, -0.05245661f, -0.05114602f, 0.03086809f, 0.00630961f, 
    0.04020032f, -0.01296797f, 0.01096327f, -0.03102774f, 0.00117376f, 0.00347103f, -0.04761253f, 0.01948849f, 
    -0.03986805f, 0.03302513f, 0.02889404f, -0.03869134f, 0.00731459f, -0.02524634f, -0.00894805f, -0.04296475f, 
    0.04469474f, -0.02184507f, -0.00879066f, -0.04745357f, -0.02932203f, 0.02724198f, -0.03886278f, -0.03201484f, 
    0.02157544f, 0.03047366f, 0.02660567f, 0.04044715f, -0.04469646f, 0.02137589f, -0.03632399f, 0.01999370f, 
    -0.00563445f, 0.02979573f, -0.00246542f, 0.00981371f, 0.01694113f, -0.00790103f, -0.04885044f, 0.03483840f, 
    0.02903345f, 0.00475515f, 0.03480054f, -0.02568868f, 0.00145327f, -0.03505468f, 0.01731967f, -0.04616093f, 
    -0.03796526f, 0.00110979f, -0.00666289f, -0.00395985f, -0.02020612f, -0.01545899f, -0.03311371f, 0.00830293f, 
    -0.05074041f, 0.02806173f, 0.00794130f, 0.00914320f, -0.02581427f, 0.02836985f, 0.00103769f, -0.02715216f, 
    0.02193653f, -0.05138398f, 0.00788467f, -0.03316554f, 0.03972582f, -0.04522616f, 0.01417102f, -0.05636758f, 
    0.01961599f, -0.03716238f, 0.00188248f, -0.05043974f, -0.02163604f, -0.00154315f, -0.01958254f, 0.01033838f, 
    -0.04990253f, 0.02421861f, -0.02121837f, -0.04976166f, -0.03633564f, 0.00232956f, -0.02321487f, -0.00667118f, 
    -0.04742274f, 0.04349669f, -0.03910495f, 0.00209475f, 0.03776892f, 0.03987206f, 0.03683097f, -0.00529726f, 
    -0.02153390f, 0.03032763f, -0.05372946f, 0.03718822f, -0.01169728f, 0.02364641f, 0.02126252f, -0.02921448f, 
    0.00310330f, -0.05157607f, 0.02796094f, 0.03946614f, 0.00474190f, 0.03052273f, -0.01540534f, -0.03823475f, 
    -0.02148097f, 0.04391086f, -0.00393504f, -0.03388213f, -0.03804765f, 0.04476614f, 0.00975247f, 0.00196941f, 
    -0.00720882f, -0.03227740f, -0.01181674f, -0.02683087f, -0.01870589f, 0.01249930f, -0.03580608f, -0.01531881f, 
    0.01951684f, -0.02907041f, 0.02747243f, -0.02968996f, 0.01840204f, -0.00628776f, -0.02444636f, -0.04598958f, 
    0.03096041f, -0.02312088f, 0.00627748f, -0.02119922f, -0.02051715f, -0.04620158f, -0.00949452f, -0.04492361f, 
    -0.00475218f, 0.01691268f, -0.01524714f, 0.03742850f, -0.05420219f, 0.02978521f, -0.03452667f, -0.01939662f, 
    0.01266638f, -0.03427152f, 0.00490746f, -0.00097549f, -0.02167065f, -0.00575751f, 0.00594173f, -0.01112695f, 
    -0.02802955f, -0.03051876f, 0.04081211f, -0.03084072f, 0.04429315f, 0.02553873f, 0.04437977f, 0.01327808f, 
    0.00387353f, 0.00482821f, -0.05237615f, 0.02482538f, -0.01488291f, 0.00226831f, -0.04599955f, -0.05372426f, 
    0.01281181f, 0.00217462f, 0.03888955f, 0.03976227f, 0.01736844f, 0.03337887f, 0.04819170f, -0.02343079f, 
    0.01468192f, -0.04077099f, 0.00573800f, -0.05262427f, 0.04266743f, -0.05620429f, -0.05336797f, 0.00614578f, 
    -0.01172143f, -0.05335232f, -0.02339700f, -0.04207193f, 0.00722933f, 0.03241013f, 0.01426227f, -0.01949434f, 
    -0.03746723f, 0.02888401f, -0.04425970f, 0.01507493f, -0.04056625f, 0.00727932f, -0.00814943f, -0.01220232f, 
    0.01433215f, -0.01351051f, 0.02006269f, -0.05649588f, -0.01803258f, -0.03956082f, 0.02377754f, -0.05438272f, 
    -0.02813036f, -0.05454035f, 0.01090946f, 0.02585581f, -0.00424546f, 0.03258931f, -0.04896516f, 0.01516698f, 
    0.03390718f, -0.02919696f, -0.00187000f, 0.02495038f, -0.02947993f, -0.01834527f, 0.00109720f, -0.01200077f, 
    -0.03095266f, -0.01909451f, 0.04040087f, -0.04494851f, -0.05254794f, 0.00330978f, 0.00604605f, 0.00543943f, 
    0.08441494f, 0.16557670f, 0.10767482f, 0.31268436f, 0.07320471f, -0.00472987f, 0.09896252f, -0.07510787f, 
    0.02537470f, 0.23743874f, 0.14602658f, 0.01091474f, 0.14694430f, 0.14100932f, 0.07281842f, -0.14785041f, 
    0.01963050f, 0.04481963f, 0.01447620f, -0.01807447f, -0.06994771f, 0.05396693f, 0.07981826f, -0.03656688f, 
    -0.16787151f, 0.25927413f, -0.20148845f, -0.16009600f, 0.00511517f, 0.04735958f, -0.01747037f, -0.01771613f, 
    0.06449986f, -0.04641626f, 0.02323249f, -0.03947597f, -0.23577951f, -0.08465991f, 0.09574986f, 0.05893729f, 
    -0.06226082f, -0.05474704f, -0.02271681f, 0.00565928f, -0.05420136f, 0.03657771f, -0.02276295f, 0.04356192f, 
    -0.00705671f, -0.26291889f, -0.00133144f, -0.07072346f, 0.00792955f, 0.01259837f, -0.10665433f, 0.11459364f, 
    -0.03607833f, 0.14323400f, 0.11626133f, -0.05988565f, 0.11043230f, 0.07723717f, 0.05106914f, -0.04720610f, 
    0.00856724f, -0.07506407f, -0.08188787f, -0.02271659f, -0.04907443f, -0.09697489f, 0.08873232f, -0.03098815f, 
    0.32433969f, -0.34983942f, -0.21041147f, 0.06225993f, 0.12722330f, -0.06328494f, 0.00557820f, 0.22532590f, 
    -0.02893070f, -0.00685878f, 0.18770534f, 0.17376772f, -0.09170945f, -0.21636330f, 0.26067191f, -0.08983941f, 
    0.04347560f, -0.07534160f, 0.02512223f, 0.21612635f, 0.10662679f, 0.24588449f, -0.17236833f, 0.09319598f, 
    0.04340635f, 0.24618860f, 0.17732868f, 0.05971749f, -0.02248735f, 0.04004273f, -0.01717700f, 0.01391766f, 
    0.10244427f, -0.01803926f, 0.15837541f, -0.00986103f, -0.29980457f, -0.24193223f, 0.04256019f, 0.04499704f, 
    -0.04393168f, 0.07053030f, 0.17344238f, -0.07881164f, 0.08917794f, -0.01455918f, 0.01132628f, -0.01120808f, 
    -0.16094039f, -0.06195433f, 0.36169460f, 0.06898626f, -0.00147672f, 0.01269466f, 0.09701230f, 0.28320009f, 
    0.19756237f, 0.01708768f, -0.00503166f, 0.02339754f, -0.05582473f, -0.03186451f, -0.02550385f, -0.06066141f, 
    0.00295899f, 0.07607143f, 0.04054629f, 0.04600685f, 0.18914691f, 0.03248189f, -0.00622736f, -0.03078395f, 
    -0.02582921f, 0.04546619f, 0.33233920f, -0.11781947f, -0.10973256f, 0.26376796f, 0.04575238f, -0.05015787f, 
    -0.14961129f, 0.14802842f, 0.01557899f, 0.00009603f, 0.75990385f, -0.03712499f, -0.32305524f, -0.00427237f, 
    0.17944776f, -0.16154344f, -0.05779686f, -0.09738066f, 0.01041809f, 0.16333498f, 0.01495333f, 0.01787289f, 
    0.17954914f, -0.22262497f, 0.01194132f, 0.19522247f, 0.17440207f, -0.23101628f, -0.00262694f, -0.00000385f, 
    0.07050914f, 0.21127859f, 0.16355048f, 0.30378366f, 0.41350558f, 0.26914442f, -0.22804536f, -0.03372694f, 
    0.02636638f, 0.23210402f, 0.16058046f, 0.07429154f, -0.08144317f, 0.04585339f, 0.02279969f, 0.04040882f, 
    0.28701010f, -0.07852604f, -0.03127281f, 0.00622779f, -0.01782869f, 0.00334736f, 0.03400572f, -0.06574259f, 
    -0.05435542f, 0.07484010f, -0.03621132f, -0.02673746f, -0.33893326f, 0.05401472f, 0.08597836f, 0.31134459f, 
    0.02450426f, 0.14926732f, -0.06498448f, 0.03049611f, -0.14491364f, -0.03072608f, 0.11900651f, 0.04453820f, 
    -0.04018822f, -0.03083927f, -0.13530977f, 0.32590812f, 0.18690711f, -0.01473827f, 0.17081837f, 0.08280788f, 
    0.16871057f, 0.04510930f, -0.08752212f, -0.13796943f, -0.04914582f, 0.13507535f, 0.28993139f, 0.33504653f, 
    -0.05221741f, 0.01823581f, 0.04667541f, -0.05927046f, -0.16927841f, 0.06198665f, 0.14127676f, -0.01431674f, 
    -0.11587504f, -0.10375558f, 0.24640544f, -0.08031144f, 0.09425349f, 0.08859186f, 0.02239361f, -0.02022207f, 
    0.00899328f, 0.04245106f, -0.05893527f, -0.03820611f, -0.44864678f, 0.49284780f, 0.33740485f, 0.22449423f, 
    0.14020303f, 0.09867700f, 0.05533703f, -0.02787326f, -0.03382756f, -0.00816027f, 0.07739110f, 0.05460141f, 
    0.36121562f, 0.02072226f, -0.12986477f, 0.13866663f, -0.11169489f, 0.12303488f, 0.18983378f, 0.04968962f, 
    -0.01797695f, 0.02147904f, 0.24644950f, 0.10035970f, -0.15329340f, -0.32906049f, 0.08971814f, 0.18522315f, 
    -0.03108640f, -0.05819524f, 0.05294287f, -0.03557057f, 0.00480705f, 0.03180438f, 0.17550407f, 0.11165413f, 
    -0.13589902f, 0.28643727f, -0.17103852f, -0.19025308f, 0.02445839f, -0.02728635f, -0.01101121f, -0.05386725f, 
    -0.06946578f, 0.08032594f, -0.08252322f, -0.09808075f, -0.12812419f, -0.11685127f, -0.14743578f, 0.01494911f, 
    0.08833227f, -0.07102951f, -0.01588923f, 0.05481422f, 0.10434604f, 0.03274697f, 0.03903357f, -0.00956329f, 
    -0.25927094f, -0.29053211f, 0.00179181f, 0.17139749f, 0.04321414f, 0.07389514f, -0.04997309f, -0.18846874f, 
    -0.02838123f, -0.15927212f, 0.20205824f, -0.08910336f, -0.10578962f, -0.08982368f, -0.06435578f, 0.06326801f, 
    -0.20827611f, 0.06945843f, 0.29545894f, 0.12826945f, -0.01367466f, 0.05522055f, 0.02462972f, -0.20301312f, 
    0.22455154f, -0.16222571f, 0.01478130f, 0.05480310f, -0.00856887f, 0.15616812f, 0.02072025f, 0.03405499f, 
    0.08384049f, 0.09372953f, -0.06577852f, 0.00058586f, -0.00561609f, 0.03312553f, 0.04468310f, -0.13191241f, 
    0.02306349f, 0.06286062f, 0.04894758f, 0.01078740f, 0.08771572f, 0.02035299f, -0.00140645f, -0.07374507f, 
    0.09134401f, -0.02247439f, -0.20491414f, -0.07749044f, 0.00749851f, 0.00084598f, -0.11330161f, -0.00784933f, 
    0.07030687f, -0.05779558f, 0.06354848f, -0.01741444f, 0.22431207f, -0.05070192f, 0.11494815f, -0.00671466f, 
    -0.07087968f, -0.04604838f, 0.02472871f, 0.00593667f, 0.39424306f, 0.08342166f, 0.16242003f, 0.02842618f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.00115102f, -0.01223687f, -0.02078766f, -0.17228627f, -0.03632320f, 0.12579831f, -0.00193964f, 0.00952199f, 
    0.05904057f, -0.04526279f, 0.18672639f, 0.00974309f, 0.26918817f, 0.17301445f, -0.00029084f, 0.00696578f, 
    -0.02485462f, -0.08098121f, 0.12397952f, 0.06081553f, 0.19435368f, 0.02458584f, 0.06785833f, 0.10915235f, 
    0.08296359f, 0.00734455f, 0.07070144f, -0.02219570f, 0.04654580f, -0.04731309f, -0.05408325f, 0.09248116f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.04147166f, -0.14384490f, 0.10743778f, -0.01180865f, -0.30585635f, 0.09497997f, 0.16800047f, -0.16079390f, 
    0.13128839f, -0.07199822f, 0.11887879f, 0.04678957f, 0.21238330f, 0.23283651f, -0.06430290f, 0.05284776f, 
    -0.09693450f, -0.22234386f, -0.01564641f, -0.41596806f, 0.20920800f, -0.09454123f, 0.04636256f, 0.17026703f, 
    -0.23995207f, -0.07004333f, 0.06506469f, 0.00982445f, -0.27618265f, 0.15381154f, 0.03760894f, 0.39116421f, 
    0.01799272f, -0.03875238f, 0.16672030f, -0.24223098f, 0.06814002f, 0.27949560f, 0.12763695f, 0.03510548f, 
    0.58561486f, 0.15743083f, 0.20533484f, -0.01147492f, 0.06473112f, 0.00928941f, 0.10586947f, 0.09914595f, 
    -0.00687284f, 0.08865654f, 0.28268290f, -0.49208394f, 0.20711376f, -0.08261646f, -0.25199777f, -0.14430234f, 
    0.20883928f, 0.01407031f, 0.16166358f, -0.16544411f, -0.32015845f, 0.16392872f, 0.03200301f, 0.08504190f, 
    -0.06973562f, 0.14187884f, 0.01486213f, -0.15293115f, -0.00868248f, 0.31215531f, -0.00098485f, -0.11894236f, 
    -0.39264837f, -0.43666974f, 0.19448803f, -0.10841332f, 0.07883943f, 0.37091479f, -0.07719138f, -0.06685735f, 
    -0.02110624f, -0.25814420f, 0.07130334f, 0.15127306f, 0.12452651f, -0.04865630f, -0.04722884f, 0.01889241f, 
    -0.04332202f, -0.08840234f, -0.06875528f, 0.17365859f, 0.29036534f, 0.14291592f, 0.02091572f, 0.03558384f, 
    0.12903744f, 0.23821428f, 0.12391751f, -0.45525378f, -0.17311110f, -0.24398990f, -0.23841965f, -0.12003817f, 
    0.07959288f, -0.10802183f, 0.06082804f, -0.04674113f, 0.30941740f, -0.04226318f, 0.06618541f, -0.14502880f, 
    -0.00126632f, -0.21854010f, -0.03170977f, 0.15613568f, 0.41792569f, -0.12418093f, 0.01129515f, 0.43973032f, 
    0.36552882f, 0.01898133f, 0.04496513f, 0.13982442f, 0.14644602f, 0.09838901f, 0.04399313f, 0.01688398f, 
    -0.06797007f, -0.02313718f, 0.11673509f, 0.21940871f, 0.11440638f, -0.05385648f, 0.23197450f, 0.02442688f, 
    -0.42316386f, -0.23685043f, 0.11168294f, 0.13115555f, 0.13307670f, 0.01538473f, 0.08343131f, 0.11224484f, 
    0.01613411f, -0.10446292f, -0.24792260f, 0.27175212f, -0.24142572f, -0.00333283f, -0.21666206f, 0.01650153f, 
    -0.13519070f, -0.00127444f, -0.15584180f, -0.10816896f, 0.31566736f, -0.08047646f, -0.15077968f, 0.27361509f, 
    -0.07067224f, -0.10514115f, 0.16593957f, -0.16203998f, 0.17188542f, -0.03747891f, -0.21282233f, -0.00259713f, 
    -0.51850986f, -0.18670571f, 0.36080965f, 0.13140224f, 0.14746460f, 0.26695207f, -0.02820363f, 0.07412246f, 
    0.11452080f, -0.30559966f, 0.09777456f, -0.42365661f, 0.23106922f, 0.08431669f, 0.17307407f, 0.36173365f, 
    -0.41891316f, 0.08900433f, -0.06026771f, -0.05823344f, 0.07238510f, 0.08281609f, 0.16151321f, 0.00354687f, 
    -0.15974462f, 0.13208289f, -0.12191000f, 0.08731515f, -0.00272283f, 0.28384122f, 0.23519129f, -0.16691330f, 
    0.19848269f, -0.12812702f, -0.24067910f, 0.01978996f, 0.08977513f, 0.17759320f, -0.05560822f, 0.21446069f, 
    0.10833348f, -0.18864511f, -0.04744726f, -0.60930538f, 0.14881212f, -0.13413911f, -0.01254094f, -0.13544971f, 
    0.00635232f, -0.16882178f, -0.25777262f, 0.02645952f, 0.22596721f, 0.07666603f, -0.13666320f, -0.00062912f, 
    -0.15379845f, -0.04330685f, 0.12708732f, -0.29114708f, 0.05104581f, 0.29724365f, 0.24212536f, -0.01540155f, 
    0.30756640f, -0.44879851f, 0.13225569f, 0.00303660f, 0.11607363f, 0.32381147f, 0.00289153f, -0.27737480f, 
    -0.10247852f, -0.22283551f, -0.02947852f, 0.19524804f, -0.25179958f, -0.08803581f, -0.05992079f, -0.24599953f, 
    0.27838239f, 0.04544530f, 0.16369337f, 0.09573331f, 0.30400982f, 0.12558758f, -0.06317086f, 0.24407008f, 
    0.15840358f, 0.01069411f, -0.14412650f, 0.11107150f, 0.11900475f, 0.26926774f, -0.08846845f, 0.16258644f, 
    -0.57347614f, -0.08949934f, 0.04556143f, 0.06644227f, -0.14495774f, -0.01594266f, -0.04126046f, 0.14042865f, 
    -0.00350569f, -0.30912107f, 0.24158853f, -0.18763591f, 0.25950581f, 0.02030633f, 0.33531570f, 0.06102113f, 
    -0.19714843f, -0.02431552f, 0.25167575f, -0.05829212f, -0.12724003f, -0.01488018f, 0.05416110f, -0.12841411f, 
    -0.17238358f, -0.12668462f, -0.14196253f, 0.02135421f, -0.17326030f, 0.14767124f, 0.01346584f, 0.17503700f, 
    0.07293099f, -0.01575731f, 0.02314602f, 0.12404142f, -0.13785711f, -0.14918076f, 0.17298649f, 0.06403369f, 
    -0.13631067f, -0.15639104f, -0.17722161f, -0.08890603f, -0.16103679f, -0.06657840f, -0.15725176f, -0.06466026f, 
    -0.04960022f, -0.03139476f, -0.18536350f, -0.14053397f, -0.17200759f, 0.04524106f, -0.04416307f, -0.17315677f, 
    0.13114807f, -0.18278529f, -0.05434783f, 0.48760664f, 0.08264943f, -0.02434472f, 0.01025038f, -0.05296206f, 
    -0.01122957f, -0.05651096f, 0.19965866f, 0.14384259f, 0.01519078f, -0.14426942f, 0.10279299f, 0.51583338f, 
    0.17629667f, 0.57231086f, 0.01166262f, -0.48955289f, -0.04330064f, 0.12396192f, 0.03538167f, 0.41164520f, 
    -0.26688400f, -0.12274403f, 0.09928885f, 0.04641544f, -0.32163131f, -0.15225682f, 0.10467736f, -0.04472275f, 
    -0.00732434f, -0.25050330f, 0.12979373f, -0.16173235f, -0.04212362f, 0.19857748f, 0.12851894f, 0.09643088f, 
    -0.07494358f, -0.15567155f, -0.05081392f, -0.04555883f, 0.13490532f, 0.05057221f, -0.10869385f, 0.15507798f, 
    -0.10355841f, -0.20675665f, 0.12280679f, 0.17488420f, -0.01797252f, 0.11866668f, -0.25294793f, 0.20144482f, 
    0.10345863f, -0.13356043f, 0.18537426f, 0.13795406f, -0.23083818f, 0.04740635f, 0.06714303f, 0.30900329f, 
    0.13280642f, 0.07069202f, 0.12290790f, -0.07639266f, -0.02435535f, -0.02832980f, -0.12259248f, 0.15460479f, 
    0.04162461f, -0.07656401f, 0.14994471f, -0.05268202f, -0.10360714f, -0.06139651f, 0.10778201f, -0.04283934f, 
    -0.06304760f, -0.12794523f, -0.08029668f, -0.13471302f, -0.21924077f, -0.04227055f, -0.03352407f, -0.04641196f, 
    -0.04976171f, -0.12387609f, -0.13846150f, 0.11939675f, -0.08724035f, 0.13091576f, 0.05923411f, -0.16193804f, 
    -0.05187181f, -0.12283016f, 0.02154236f, -0.40978417f, -0.05198934f, -0.18316574f, -0.10251901f, -0.08517060f, 
    -0.02894795f, -0.05541351f, 0.45658967f, 0.14138544f, 0.36815774f, 0.13859499f, -0.09672633f, 0.22410119f, 
    -0.12029728f, -0.33277354f, -0.24268305f, 0.25019827f, 0.45395190f, 0.03459780f, 0.01076444f, 0.37036514f, 
    0.28796610f, -0.03914281f, 0.03692294f, -0.13185467f, -0.07485586f, 0.09910611f, 0.05646211f, 0.13956895f, 
    0.06092097f, 0.15183480f, 0.04828098f, 0.58961827f, 0.25710189f, -0.33157206f, -0.16082160f, 0.13119309f, 
    0.14955033f, -0.07545783f, -0.22435801f, 0.02571085f, -0.24972422f, -0.08622906f, -0.10941503f, 0.34336767f, 
    0.00864742f, -0.06617254f, 0.29701439f, -0.11684549f, 0.10597461f, -0.06563234f, -0.03118807f, -0.04848897f, 
    0.43970490f, 0.11159633f, -0.22656097f, -0.13224548f, 0.27106830f, 0.10615472f, -0.07787786f, 0.08685804f, 
    0.01236816f, 0.11953581f, -0.07059902f, 0.11905776f, -0.26074928f, 0.10545475f, 0.30566755f, -0.11255433f, 
    0.35173777f, -0.56543255f, 0.20463924f, -0.09395961f, 0.00986434f, 0.38146999f, 0.00755810f, -0.10100715f, 
    -0.12296977f, 0.35379592f, -0.18899870f, -0.06850348f, -0.26565403f, -0.01263409f, 0.00790054f, -0.12296026f, 
    -0.11604851f, -0.01084466f, -0.14715543f, 0.07597786f, 0.00921054f, 0.08676297f, -0.13642737f, 0.34622994f, 
    0.08965330f, -0.06824970f, 0.03947029f, -0.09882261f, 0.33222911f, 0.13682735f, -0.16338895f, -0.08950034f, 
    -0.16749972f, 0.13011296f, 0.25428316f, -0.10309172f, 0.10988391f, -0.30237010f, -0.10190249f, 0.27672613f, 
    -0.00650431f, -0.10788941f, 0.13729937f, 0.14527206f, 0.11681080f, -0.06842048f, 0.01563018f, -0.11392288f, 
    0.38959002f, -0.11620612f, 0.17912507f, -0.14094324f, -0.14358075f, -0.07302606f, 0.15500158f, -0.23529591f, 
    -0.16343820f, -0.30471662f, 0.13845572f, 0.54975885f, -0.30514073f, 0.14072213f, 0.27120245f, 0.12072711f, 
    -0.59307015f, 0.06357513f, 0.04370749f, -0.04951198f, 0.07354878f, 0.08306511f, 0.05188910f, -0.09673879f, 
    -0.12831256f, -0.24891880f, -0.10278632f, 0.29678771f, 0.09751727f, -0.14074831f, 0.37233385f, -0.03214997f, 
    -0.03710044f, -0.02489465f, 0.49525800f, 0.00173838f, -0.06770311f, 0.05269552f, -0.15936728f, 0.06543140f, 
    -0.12036103f, -0.01674419f, 0.05088903f, 0.07119318f, 0.22746332f, 0.08825732f, 0.10997267f, 0.09542495f, 
    0.14639805f, 0.12192281f, 0.32149741f, -0.01792010f, 0.08650836f, -0.14620566f, 0.06098876f, -0.10451375f, 
    0.00947588f, 0.07061978f, 0.20633905f, -0.01476053f, -0.09065901f, -0.07851366f, 0.12934786f, -0.00207529f, 
    -0.19915473f, 0.08271980f, -0.26589161f, 0.16655827f, -0.10542507f, -0.15474977f, 0.14824374f, -0.03354633f, 
    -0.02840984f, 0.31468040f, -0.13712971f, 0.09500484f, 0.36953428f, -0.24959701f, -0.16913848f, -0.14776133f, 
    0.15997484f, 0.01396561f, -0.02267038f, 0.08305816f, 0.03003154f, 0.07010621f, 0.17190582f, 0.17868304f, 
    -0.12875018f, 0.44714376f, -0.03154761f, 0.02238195f, -0.17939259f, -0.04622255f, 0.26557350f, 0.30357248f, 
    0.25434577f, 0.11499969f, -0.35796353f, -0.13265213f, 0.55843288f, -0.14517030f, 0.09740543f, -0.15419851f, 
    -0.11570134f, 0.08845227f, -0.12030231f, -0.14058374f, 0.05454181f, -0.10258327f, 0.01745795f, -0.00865987f, 
    0.00572161f, 0.15079178f, 0.15541105f, -0.00387161f, 0.04270079f, -0.19333245f, 0.07992608f, -0.36873272f, 
    0.13479419f, 0.02877825f, 0.12279089f, -0.13423358f, 0.34602982f, 0.14994945f, -0.28863010f, -0.21080019f, 
    0.02284343f, 0.17580260f, -0.06208756f, 0.05945507f, 0.20186746f, -0.05361687f, 0.05630528f, 0.00933616f, 
    0.09863304f, -0.12376366f, 0.08452780f, 0.10312092f, 0.06417989f, 0.03401963f, -0.18951386f, 0.09666594f, 
    0.04103433f, -0.00639654f, 0.15132019f, 0.16259193f, -0.08780047f, -0.11097628f, 0.02151107f, 0.03055327f, 
    -0.14327760f, 0.03313391f, -0.05987508f, 0.07963806f, -0.09453306f, -0.09884110f, -0.11823653f, -0.17282471f, 
    -0.10214366f, 0.10635089f, 0.10735725f, 0.14434507f, 0.03257062f, -0.09343499f, 0.02716215f, -0.10462157f, 
    -0.17033316f, 0.05515751f, 0.11643640f, 0.06338876f, -0.18542123f, -0.12822674f, 0.36512592f, -0.08506422f, 
    0.73010808f, -0.28015724f, -0.31303069f, 0.16054481f, 0.06707156f, -0.16361736f, 0.00636993f, 0.10676308f, 
    -0.14125422f, 0.43667930f, -0.01987280f, -0.39193645f, 0.00075388f, -0.08292203f, 0.06474428f, 0.02440833f, 
    0.22784168f, -0.02273310f, 0.27682507f, -0.01917867f, -0.19457650f, 0.10739153f, 0.16994374f, -0.06041578f, 
    0.03956421f, 0.28536379f, -0.03247883f, 0.27004814f, -0.14407814f, 0.14510927f, 0.45452753f, 0.00086908f, 
    -0.05663276f, -0.33428338f, -0.24784228f, 0.03493673f, 0.11693288f, 0.29027274f, -0.03053381f, -0.26308292f, 
    0.09462070f, -0.16523270f, 0.28235832f, -0.24232399f, -0.04954203f, -0.01295902f, 0.21149696f, -0.35809326f, 
    -0.25490284f, -0.09206070f, 0.06891123f, 0.13090414f, -0.12197378f, -0.11579578f, -0.09379587f, 0.22341089f, 
    0.12703338f, -0.14770228f, 0.03803556f, 0.29098237f, -0.12655322f, -0.08110435f, 0.18149519f, -0.12171514f, 
    -0.22952414f, -0.06552709f, -0.28442299f, 0.09140483f, -0.23790291f, 0.33689123f, -0.13880588f, 0.10777974f, 
    -0.01580857f, 0.22375585f, -0.48663384f, 0.32091188f, 0.27421755f, 0.18148789f, 0.09948095f, 0.41031471f, 
    0.15468344f, 0.01011599f, -0.10608175f, -0.10281788f, 0.27428544f, -0.15251067f, -0.12485247f, 0.22439703f, 
    0.06030076f, 0.23919091f, 0.08496968f, -0.06979526f, -0.11543199f, 0.34923977f, 0.11660647f, -0.03457280f, 
    -0.07931232f, -0.07164185f, -0.12155705f, 0.09179445f, -0.12502651f, 0.32729337f, 0.00922714f, 0.07865409f, 
    0.07380796f, 0.00589330f, -0.03333852f, -0.28357336f, 0.19601323f, 0.16587019f, 0.35872009f, -0.32488400f, 
    -0.10669468f, 0.04858126f, -0.19280398f, 0.11820153f, 0.39632693f, -0.10295918f, -0.08636906f, -0.04557985f, 
    -0.06182395f, 0.04059425f, 0.05849700f, -0.11655664f, 0.05116193f, -0.26282492f, -0.08552754f, -0.10046641f, 
    -0.10549594f, -0.02124208f, 0.00595452f, -0.07689728f, 0.03609007f, 0.00534339f, -0.03507450f, 0.30374056f, 
    0.01063445f, -0.02268577f, -0.31528887f, -0.09704005f, -0.10863152f, 0.13361368f, 0.07783361f, -0.19178198f, 
    -0.18699244f, -0.04546766f, -0.46879479f, -0.13637283f, 0.35198331f, -0.04409645f, -0.07772896f, -0.00244057f, 
    0.14471841f, -0.11378477f, -0.17391561f, 0.13655417f, -0.06375039f, -0.11310485f, 0.04728751f, -0.08983097f, 
    -0.17433839f, -0.16871098f, -0.06898492f, -0.16968475f, 0.01782655f, -0.07572170f, -0.14204489f, 0.06313160f, 
    -0.01827508f, -0.04737721f, -0.16025920f, -0.10988344f, -0.13933203f, 0.05133581f, -0.05556249f, 0.09593378f, 
    -0.14115566f, -0.13653669f, -0.05279458f, -0.08866137f, -0.04520142f, -0.08078293f, 0.12103523f, -0.02242380f, 
    -0.01643948f, -0.38253567f, -0.15395275f, -0.08296242f, -0.17675896f, 0.11902899f, 0.14767712f, 0.08153516f, 
    0.38187209f, 0.24256274f, 0.32133624f, -0.00913124f, -0.14186646f, -0.06933453f, -0.07312026f, 0.02813802f, 
    0.01753180f, 0.21445151f, -0.02217289f, -0.08558384f, 0.15173657f, -0.14673193f, -0.14053945f, 0.03169470f, 
    0.06245754f, -0.16687694f, 0.05811446f, 0.10472168f, -0.31422201f, -0.08997638f, 0.03360748f, 0.06510093f, 
    -0.05510131f, 0.04606884f, 0.15881813f, -0.67288482f, 0.28548488f, 0.43908677f, 0.10519978f, 0.05062865f, 
    0.01745835f, 0.04860096f, 0.03376515f, 0.13211474f, 0.13060045f, 0.11459555f, -0.00062712f, -0.05515357f, 
    0.00531775f, -0.29919541f, 0.32570648f, 0.02754533f, -0.22643179f, -0.01790943f, 0.30603680f, -0.13177149f, 
    0.13463701f, -0.13996470f, 0.03804861f, -0.03603323f, 0.17493771f, 0.12609187f, 0.09192818f, -0.20258012f, 
    -0.07192048f, -0.09336862f, -0.03373422f, -0.09248147f, 0.36714849f, 0.42158148f, 0.22085695f, -0.02727677f, 
    -0.09292093f, 0.15112321f, 0.20765257f, 0.14335585f, 0.16302028f, -0.23790719f, -0.07435394f, 0.19218595f, 
    -0.03243183f, -0.24730586f, 0.41172937f, 0.14985062f, -0.20704687f, -0.02371257f, 0.08852100f, -0.47818309f, 
    0.19640373f, 0.05564683f, 0.31309426f, 0.13008606f, -0.15920949f, -0.14293391f, -0.14107384f, -0.14985657f, 
    0.05133705f, -0.10763086f, -0.05629389f, 0.27052602f, -0.04847724f, -0.08838275f, -0.08282850f, -0.06291483f, 
    -0.31306386f, 0.07968799f, 0.04490731f, -0.04948748f, 0.09666383f, -0.09880840f, 0.10801043f, 0.45608962f, 
    -0.16341102f, 0.30630699f, -0.19175525f, 0.35399878f, 0.10870386f, -0.08681916f, -0.16404776f, 0.43724149f, 
    -0.13684155f, 0.19446778f, -0.25475836f, 0.13678962f, 0.30410358f, -0.01581157f, 0.09940933f, 0.25109974f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.21884342f, 0.03993822f, 0.30104184f, 0.19908556f, -0.14783339f, 0.10864364f, 0.13825928f, 0.01220286f, 
    -0.17654674f, -0.23112360f, 0.12604900f, 0.14706375f, -0.10107984f, 0.36409768f, 0.01671780f, -0.07865648f, 
    0.23054799f, 0.26549542f, -0.13538252f, -0.06553753f, 0.08692183f, -0.03939261f, 0.12000787f, 0.07327519f, 
    -0.23999017f, 0.19262062f, -0.00129401f, -0.09452996f, 0.08653300f, -0.01175692f, 0.10601421f, 0.05751547f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.25255826f, 0.14546330f, -0.36868510f, -0.30158627f, -0.29336175f, -0.30519900f, -0.20993963f, -0.50211090f, 
    0.18967405f, 0.00049957f, 0.30423406f, -0.49411568f, -0.07218976f, -0.59500170f, 0.26285061f, -0.39785653f, 
    0.14102745f, -0.44486934f, 0.26887277f, 0.19702715f, 0.14903340f, -0.11315613f, 0.32444423f, -0.06921402f, 
    -0.43988463f, 0.05471240f, -0.29922456f, 0.08398683f, -0.19960727f, -0.01515644f, 0.15800960f, -0.03510150f, 
    -0.28820097f, 0.13001809f, -0.05436159f, 0.11416915f, -0.43295199f, -0.43960869f, -0.00238299f, 0.29445705f, 
    0.06183722f, -0.13584061f, -0.84285486f, -0.03733701f, 0.04615598f, 0.05633127f, 0.22760779f, -0.60046560f, 
    0.23962142f, 0.37040758f, -0.06506716f, -0.00621921f, -0.21330032f, 0.00696256f, -0.00616900f, -0.10873944f, 
    -0.02139601f, -0.00533977f, 0.01099582f, 0.10268792f, -0.13963032f, 0.28753570f, 0.23801586f, -0.28880364f, 
    -0.01334091f, 0.22802463f, -0.11639211f, 0.26363736f, -0.27407765f, -0.08043829f, -0.00425432f, 0.10133584f, 
    -0.57593536f, -0.05472699f, -0.15046112f, -0.15207314f, -0.13864493f, 0.26249295f, -0.19961002f, 0.23519748f, 
    -0.06941102f, -0.73850554f, 0.00546180f, 0.10042017f, 0.10181976f, -0.19976133f, 0.31773058f, -0.35882241f, 
    0.11249565f, 0.17959163f, -0.20897511f, -0.10163534f, -0.04855816f, 0.01537246f, -0.41080797f, 0.01572620f, 
    0.00341772f, -0.07119541f, -0.17999007f, -0.47771484f, 0.29067510f, -0.62602502f, 0.27173975f, 0.13396046f, 
    -0.59262121f, -0.08336460f, -0.03741029f, -0.08752348f, 0.06093385f, -0.46304348f, 0.21724814f, 0.24989678f, 
    -0.20458029f, 0.01837537f, -0.05395726f, 0.20102179f, -0.10082028f, 0.09243960f, 0.25106278f, 0.07874355f, 
    0.21251044f, 0.10920645f, -0.10255758f, 0.14468046f, -0.75666940f, -0.04554338f, -0.14827205f, 0.13465811f, 
    -0.47408444f, -0.09367589f, 0.02355948f, -0.18772258f, 0.26935273f, -0.00903546f, 0.03274352f, -0.24652544f, 
    0.05570620f, -0.13700677f, 0.04955620f, -0.31064934f, 0.09291849f, -0.06020644f, 0.22910871f, -0.31470531f, 
    0.04002438f, 0.02802001f, -0.03869347f, 0.16256388f, 0.06531354f, -0.13916270f, -0.10689729f, -0.43694070f, 
    0.32214934f, 0.15998314f, 0.29198042f, 0.11043653f, 0.27856189f, -0.10682549f, -0.11318695f, 0.18339257f, 
    0.11252026f, 0.16512442f, 0.06077863f, -0.23196097f, 0.28180388f, 0.22147179f, -0.01476831f, -0.05803770f, 
    0.11438446f, 0.08944527f, 0.28064701f, 0.20309813f, -0.06307171f, 0.15232244f, -0.16077334f, -0.19120082f, 
    0.12969638f, -0.27216327f, 0.14500287f, -0.16164342f, -0.35260719f, -0.01608555f, -0.36683097f, -0.19869399f, 
    -0.72930413f, 0.00216717f, -0.34269431f, -0.21606900f, -0.25089693f, 0.10250132f, 0.15937775f, 0.18253921f, 
    -0.05437552f, -0.61870444f, 0.24220802f, 0.20862390f, 0.41565105f, -0.09111653f, -0.67660010f, 0.25948694f, 
    -0.36395752f, 0.03622562f, -0.60324210f, 0.09520722f, 0.12319198f, 0.20926370f, -0.53563756f, 0.04740463f, 
    -0.09003923f, 0.04566343f, -0.17690527f, -0.04499977f, -0.04925228f, 0.14465095f, -0.27778280f, -0.24365619f, 
    0.33445504f, -0.10290877f, -0.17087683f, -0.14008251f, -0.36419711f, -0.23433578f, -0.27875462f, 0.12290659f, 
    0.21540456f, 0.24151720f, -0.53223896f, -0.18441918f, 0.05867986f, 0.08140738f, -0.47413179f, -0.02236918f, 
    -0.09824011f, -0.13535906f, 0.56230599f, 0.12517428f, -0.05078703f, 0.08038271f, -0.19511174f, 0.02557432f, 
    -0.24485305f, 0.09168129f, -0.19345863f, -0.41602185f, 0.12579225f, 0.01516050f, 0.16916239f, -0.15080647f, 
    0.13617909f, -0.43629453f, -0.18367392f, -0.05061951f, 0.11738641f, -0.46197346f, -0.10523853f, -0.03913339f, 
    0.19920911f, 0.26391497f, -0.02125585f, 0.08407446f, -0.08052912f, -0.02116116f, -0.04410479f, 0.14861175f, 
    -0.18184115f, -0.24672955f, -0.16868855f, 0.10188676f, -0.19454941f, -0.00215955f, -0.57626367f, 0.28410655f, 
    -0.42302650f, 0.01731630f, 0.04422260f, -0.62519896f, 0.00616527f, -0.06858051f, 0.32884842f, 0.32364222f, 
    -0.50353628f, 0.02698123f, -0.18616274f, 0.08611798f, -0.22779468f, -0.08766425f, -0.02876192f, -0.53270257f, 
    0.11389700f, -0.39821938f, -0.17814466f, 0.38697284f, -0.18710640f, 0.32138145f, -0.29497844f, -0.37721470f, 
    0.26904550f, 0.02723447f, 0.09593584f, 0.00030210f, 0.00479364f, 0.21548589f, 0.13636908f, -0.58812159f, 
    -0.08992238f, -0.12244058f, -0.19173272f, 0.11526907f, 0.04332969f, -0.15537266f, -0.20564011f, -0.23121686f, 
    0.02519524f, -0.21588159f, -0.35626090f, -0.11646526f, -0.35904080f, -0.21818958f, -0.50233352f, 0.26731491f, 
    0.00655328f, -0.38123265f, 0.26662368f, -0.21731733f, 0.17512874f, 0.30523318f, -0.01542397f, 0.23706992f, 
    0.03599525f, -0.20406035f, -0.60235226f, -0.43119666f, -0.14448628f, -0.11872426f, -0.44303823f, 0.21168916f, 
    -0.34180275f, -0.11572506f, 0.24226539f, 0.22932491f, -0.36243165f, 0.10334898f, -0.61499631f, 0.05884006f, 
    -0.41424483f, 0.31761590f, 0.18601935f, 0.06567715f, -1.34634602f, 0.33422443f, 0.00172733f, -0.27405611f, 
    0.18581492f, -0.28858238f, 0.04351427f, -0.17142178f, -0.13460317f, 0.07075872f, 0.24241401f, -0.03883740f, 
    0.49349925f, -0.15300871f, -0.25372732f, -0.07167985f, -0.00588841f, -0.06976716f, -0.00228217f, -0.03919138f, 
    -0.38464105f, 0.26015940f, -0.37584651f, -0.41428208f, 0.07228213f, 0.03777399f, -0.06384404f, 0.29708543f, 
    0.24027073f, 0.38582402f, -0.19234493f, -0.02481708f, -0.82138503f, 0.00855893f, -0.10200953f, -0.12239610f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.04536930f, 0.15773194f, 0.05433362f, 0.01830531f, -0.03880690f, 0.07967516f, 0.01542802f, -0.19378388f, 
    0.26303929f, 0.08961914f, 0.17656903f, -0.22083859f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
