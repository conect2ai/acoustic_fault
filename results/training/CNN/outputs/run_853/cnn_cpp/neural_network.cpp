#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.01733903f, 0.67459142f, -0.76286846f, -0.71930468f, -0.32056630f, 0.29804155f, -0.14634480f, -0.12829925f, 
    -0.37374380f, -0.43206391f, 0.15993848f, 0.02441812f, 0.44004002f, 0.43939230f, -0.06440227f, -0.06875977f, 
    0.01720510f, 0.11680620f, 0.05226952f, 0.14516796f, 0.03818245f, 0.09865648f, 0.08153042f, -0.06316835f, 
    0.29581282f, 0.73292416f, 0.47391003f, 0.64821792f, 0.65149570f, 0.75640804f, -0.50852919f, 0.18151329f, 
    -0.06519440f, -0.35442132f, -0.15543765f, 0.31287819f, 0.04915567f, -0.15983810f, 0.28746977f, -0.10146709f, 
    -0.01569941f, -0.14953303f, 0.33870429f, 0.16595107f, 0.32483089f, -0.16116996f, -0.17952409f, -0.11381991f, 
    -0.01165805f, -0.06627756f, 0.17825297f, -0.68041831f, -0.17632185f, -0.13947453f, -0.44264477f, 0.13096839f, 
    0.34300506f, 0.71298069f, 0.47213662f, -0.34552804f, -0.14604194f, -0.19434334f, -0.36764205f, -0.11528307f, 
    -0.16398416f, -0.00269475f, 0.09260222f, -0.21251476f, 0.15130048f, 0.17261089f, -0.01141882f, -0.32457310f, 
    0.35342169f, -0.34048814f, 0.02016507f, 0.70257729f, -0.13749574f, 0.13445988f, 0.68895769f, 0.37859160f, 
    0.42004630f, 0.05214489f, -0.16353332f, 0.46290368f, 0.03140802f, -0.40127757f, 0.07168847f, -0.25026521f, 
    0.22234729f, -0.18783724f, 0.17705768f, 0.04267560f, 0.28276581f, 0.31695002f, 0.27076104f, 0.11980896f, 
    0.18647709f, -0.18337993f, -0.32316515f, -0.11690938f, 0.19114745f, 0.57235497f, -0.73284298f, -0.70893794f, 
    -0.35962185f, 0.01460078f, 0.03383996f, 0.33316085f, 0.34016013f, 0.57491672f, -0.10095979f, -0.22235315f, 
    -0.17094813f, -0.26100981f, -0.36770508f, 0.13572069f, 0.12209211f, -0.10006315f, 0.33536205f, 0.04607537f, 
    -0.41899359f, -0.37680078f, -0.25359419f, -0.06965733f, 0.17510889f, 0.93053931f, 0.49293348f, 0.46349689f, 
    -0.23949508f, -0.33037576f, 0.22498974f, -0.14277413f, -0.27958131f, 0.25949961f, 0.03913458f, 0.37968341f, 
    0.08535983f, 0.22154862f, 0.05042602f, 0.26459458f, 0.07223956f, 0.27637765f, -0.11470423f, 0.01604413f, 
    0.09088565f, -0.27799177f, -0.18965270f, 0.19294420f, -0.04972820f, 0.27679628f, -0.49156287f, 0.60276049f, 
    -0.60037577f, 0.37083513f, -0.85696030f, 0.34866503f, -0.14792506f, -0.18016361f, 0.01131417f, -0.46143037f, 
    0.15672612f, -0.30988815f, -0.34369057f, 0.04615195f, 0.03632035f, 0.27329546f, -0.13439779f, 0.03240938f, 
    -0.02609163f, 0.37595215f, -0.26343033f, -0.18600193f, 0.15500823f, 0.28108650f, 0.00494339f, -0.33781984f, 
    -0.80082512f, -0.57854772f, 0.71792883f, -0.23479207f, -0.26219568f, 0.61692327f, -0.22122207f, 0.25282592f, 
    0.09139465f, 0.31309444f, 0.00000584f, 0.01098356f, -0.07890812f, -0.46678320f, -0.07781295f, 0.24166560f, 
    -0.13427095f, -0.34486574f, -0.30997238f, -0.03114673f, 0.08579072f, -0.08588479f, 0.25763553f, -0.18977660f, 
    -0.77141100f, 0.31584197f, 0.25679845f, -0.60603023f, -0.38988468f, 0.72184783f, 0.71707332f, 0.33241120f, 
    0.25432774f, 0.21705338f, 0.29810691f, 0.16720109f, 0.16286561f, -0.26848206f, -0.29723614f, 0.25388825f, 
    -0.07683219f, 0.15130451f, 0.06553891f, -0.19789389f, 0.06674169f, -0.40507233f, 0.09918886f, 0.00758059f, 
    0.07903641f, -0.60493177f, 0.08640724f, -0.09713449f, 0.23056208f, 0.03202638f, -0.95603114f, 0.02852176f, 
    0.10045972f, -0.18291403f, -0.51020885f, 0.19738147f, 0.04738142f, 0.19459607f, -0.10771763f, 0.41586831f, 
    0.19586596f, 0.27665284f, 0.09426624f, 0.32481727f, -0.22001821f, 0.08399565f, 0.15728825f, -0.39878178f, 
    0.01697535f, 0.22886658f, -0.06395040f, 0.46437788f, 0.19698244f, 0.11250545f, 0.36018521f, -0.44831678f, 
    -0.27005184f, -0.57147199f, -0.37452078f, -0.16823117f, -0.44225389f, 0.25075820f, -0.05599167f, 0.41420472f, 
    -0.00472546f, -0.16905525f, -0.25845325f, -0.21128030f, -0.29485574f, -0.21949048f, -0.01868604f, 0.20673800f, 
    -0.11085369f, -0.20256573f, -0.04659491f, -0.48182589f, 0.22426756f, -0.16580893f, -0.25561786f, -0.16200031f, 
    -0.41437948f, -0.37309051f, -0.19713384f, -0.31610340f, -0.36842990f, -0.47156781f, 0.02017484f, 0.29886249f, 
    -0.24064250f, 0.36582139f, -0.22474608f, -0.43167615f, -0.08415300f, -0.34608182f, -0.44458923f, -0.01058318f, 
    -0.25171253f, -0.24091335f, -0.25361261f, -0.23683140f, 0.80505568f, 0.04184641f, 0.17538245f, 0.95563722f, 
    0.36899984f, 0.36021847f, 0.38389021f, -0.44988075f, 0.16787474f, 0.27746174f, -0.19653203f, -0.16222836f, 
    -0.40058836f, -0.45829427f, -0.32970741f, -0.39997616f, -0.09572208f, -0.15114644f, -0.27774769f, -0.05852100f, 
    0.29213703f, 0.41569224f, -0.18096602f, 0.07448326f, 0.11412972f, 0.57056963f, 0.18560900f, 0.73010510f, 
    0.07505661f, 0.13406703f, 0.41505358f, -0.36556953f, -0.38320765f, -0.36000735f, -0.43380773f, 0.28832901f, 
    0.45974568f, 0.24881124f, 0.25013235f, -0.29442340f, -0.17142692f, 0.04277664f, -0.18139119f, 0.10228954f, 
    -0.03520179f, 0.14049333f, 0.30007654f, -0.22410491f, 0.01021657f, 0.33354753f, -0.05091818f, -0.18652451f, 
    0.45967469f, -0.56757420f, -0.51597810f, 0.43636483f, -0.81755537f, 0.49507043f, 0.48163858f, 0.12637043f, 
    -0.17946193f, 0.00099739f, -0.02963618f, 0.21510929f, 0.36751127f, 0.24022071f, 0.50023919f, -0.24598883f, 
    -0.26602992f, -0.47827384f, -0.34541392f, 0.06993829f, 0.24558271f, -0.34630024f, 0.03475291f, 0.07581759f, 
    0.14783275f, 0.73256409f, 0.67712790f, 0.41124773f, -0.06952620f, 0.48068792f, 0.15907693f, 0.04393214f, 
    0.52040923f, -0.31091043f, -0.21619387f, -0.34068325f, -0.17630026f, -0.13516952f, -0.24376158f, -0.23509219f, 
    -0.16954449f, 0.18050188f, -0.33323598f, 0.04611896f, 0.07129480f, -0.15658437f, -0.32282919f, 0.02244440f, 
    -0.22859921f, -0.01203860f, 0.08731879f, -0.51824200f, -0.30792537f, -0.48369497f, -0.15730728f, 0.19321176f, 
    0.30796999f, -0.64147311f, 0.13608845f, -0.24860194f, 0.17653766f, -0.22671916f, 0.15395084f, 0.49456418f, 
    -0.43233746f, -0.09038291f, -0.49551216f, -0.37256983f, -0.13380003f, 0.02812875f, 0.15073064f, 0.41035682f, 
    0.08539933f, 0.23061021f, 0.58552200f, 0.26676899f, -0.32616222f, -0.33587939f, -0.50072670f, -0.22541012f, 
    -0.21474622f, -0.04111286f, -0.28839764f, -0.10605565f, 0.19919775f, 0.22880782f, 0.29299116f, 0.01209769f, 
    0.26871073f, -0.15151568f, -0.04227532f, 0.12333753f, 0.13868664f, -0.46536362f, 0.21336047f, 0.06043147f, 
    -0.49543568f, -0.22628063f, -0.55680007f, -0.37819201f, 0.68937814f, 0.39968088f, 0.07278075f, 0.12985362f, 
    0.33863270f, 0.44384646f, 0.44811380f, -0.05916308f, -0.11827054f, -0.16226046f, -0.22866103f, -0.27511781f, 
    -0.05360918f, 0.35422543f, 0.20316195f, -0.02534845f, 0.24327174f, -0.03674707f, -0.02392751f, -0.09820025f, 
    -0.37188986f, -0.16845058f, -0.19872639f, -0.67076045f, -0.07604092f, 0.45962089f, -0.50082690f, -0.05723418f, 
    -0.56344539f, 0.23112863f, -0.19468540f, -0.44486180f, -0.13836235f, -0.47783035f, -0.03008647f, -0.06413572f, 
    0.19732530f, -0.23714648f, 0.01306869f, -0.33016425f, -0.30706111f, 0.23444936f, -0.41106570f, 0.01897238f, 
    0.07689243f, 0.27551076f, 0.09340801f, 0.52443039f, -0.12498397f, -0.09121650f, 0.72652167f, 0.05712901f, 
    0.69329393f, 0.61159420f, 0.26270849f, 0.28275996f, -0.08093004f, -0.27781793f, 0.34599164f, 0.09583312f, 
    -0.25613347f, 0.16486545f, -0.13201667f, -0.26514053f, 0.25000846f, -0.27372772f, -0.05604344f, 0.24033411f, 
    -0.23402222f, -0.11961263f, 0.09792078f, 0.09070167f, 0.42715344f, -0.15761039f, 0.16376394f, -0.24517232f, 
    -0.42501423f, -0.32849592f, 0.27621698f, -0.61820477f, -0.30251089f, -0.62441224f, -0.11360121f, -0.36776042f, 
    0.05959137f, 0.28671220f, 0.39418766f, 0.28282502f, 0.42003039f, 0.33555096f, 0.42398208f, 0.11016975f, 
    -0.10999487f, 0.09160862f, -0.03064651f, -0.36620542f, -0.09080090f, 0.42910478f, 0.50939614f, 0.68234283f, 
    -0.45217144f, 0.12310289f, -0.22413036f, 0.26748046f, -0.12832901f, -0.22946931f, -0.26274216f, -0.04637006f, 
    0.00637321f, -0.29870334f, 0.37433010f, -0.07517222f, 0.21722099f, 0.18490188f, 0.00938118f, -0.34394458f, 
    0.36409026f, 0.22305746f, 0.07210796f, -0.20702381f, 0.10544825f, -0.52253747f, -0.09911098f, -1.07657623f, 
    0.50763774f, 0.46612826f, -0.11197376f, 0.12107971f, -0.34696835f, 0.57842320f, 0.21713431f, -0.32925323f, 
    -0.42402840f, 0.01679796f, 0.17370032f, -0.17882709f, 0.20338567f, 0.27149442f, 0.34650308f, 0.17954625f, 
    0.11924753f, -0.13840836f, 0.19936691f, -0.12752697f, -0.14748380f, 0.07638924f, 0.14425756f, 0.06506332f, 
    -0.60514873f, 0.04105959f, -0.70981210f, -0.52063310f, -0.43421265f, 0.39159510f, -0.42398003f, 0.15761754f, 
    0.49333674f, 0.36148283f, -0.46837294f, -0.29427743f, -0.12156206f, -0.16786686f, -0.52036709f, 0.10479539f, 
    0.07590231f, 0.13821469f, -0.23484799f, 0.12903534f, 0.10135653f, -0.14047077f, 0.03878838f, -0.09326766f, 
    0.20644391f, 0.59162587f, 0.50531203f, 0.08456498f, -0.14829461f, -0.41714904f, -0.04035000f, -0.13948551f, 
    -0.64342266f, -0.12460230f, -0.43336591f, -0.19489527f, -0.36748651f, 0.14582023f, 0.41424903f, -0.32799992f, 
    -0.41675153f, -0.38005370f, -0.15835157f, 0.02049820f, 0.19109526f, 0.10344171f, 0.06235282f, 0.26693332f, 
    0.10546480f, 0.09456346f, -0.61049056f, -0.15006900f, -0.04784494f, -0.46547654f, -0.04529675f, -0.37389222f, 
    -0.28691685f, -0.31170046f, -0.50638199f, -0.43959385f, -0.32688236f, 0.50881243f, -0.21041708f, -0.19961432f, 
    -0.25903085f, -0.02676421f, 0.14753997f, 0.06041074f, -0.00372798f, -0.05835661f, -0.17794631f, 0.04390780f, 
    0.28297684f, 0.06576711f, -0.13740283f, -0.89487571f, -0.16272731f, -0.52694440f, -0.01831564f, -0.25312155f, 
    0.36201441f, 0.57276076f, 0.11770223f, 0.20766014f, -0.34454668f, -0.31651902f, -0.22506894f, 0.25368571f, 
    0.20410615f, 0.22899224f, -0.05017204f, -0.21369728f, -0.10881078f, -0.04964318f, -0.18719912f, 0.14060770f, 
    0.18505418f, 0.17309430f, -0.03927727f, -0.10716222f, -0.32703194f, 0.59115791f, -0.02473364f, 0.73052633f, 
    0.52219534f, 0.25438830f, 0.44911236f, 0.53300905f, 0.07201729f, 0.44551364f, -0.51447505f, -0.34467331f, 
    -0.11709601f, -0.08666033f, -0.00668721f, 0.03254734f, 0.01782732f, -0.04455060f, 0.12847279f, 0.04824891f, 
    -0.14989905f, -0.17196576f, -0.08528727f, 0.32344788f, -0.27057770f, 0.42369580f, 0.65729266f, 0.69121563f, 
    0.69201201f, -0.23553982f, -0.09121580f, -0.18288656f, -0.23638590f, -0.30628657f, 0.16402005f, 0.09000402f, 
    0.09538849f, 0.06685187f, 0.24887335f, 0.12380724f, 0.25953519f, -0.21468793f, -0.10386059f, 0.18129648f, 
    -0.08874692f, -0.11175125f, 0.13628460f, -0.06609312f, 0.12322819f, 0.22445709f, -0.05742704f, -0.83058220f, 
    0.21850026f, 0.21204345f, -0.40068045f, -0.16731946f, 0.07859983f, 0.08454397f, -0.56064576f, -0.47742787f, 
    0.39207605f, 0.29941946f, 0.04561377f, 0.21453752f, 0.10613161f, -0.49753064f, -0.15728909f, -0.31834379f, 
    -0.05567312f, -0.22217119f, -0.21973889f, 0.41762307f, 0.28166699f, 0.25344348f, 0.10603385f, 0.01967994f, 
    -0.65296584f, -0.42333224f, 0.66166741f, 0.31038645f, -0.69691020f, 0.53081948f, 0.49347147f, -0.81152892f, 
    -0.23330848f, -0.23453845f, -0.08022896f, -0.14107819f, 0.28681111f, 0.05871427f, 0.06828585f, 0.14600448f, 
    -0.08465014f, 0.09719670f, -0.06747764f, 0.12235781f, 0.15953338f, 0.09219406f, 0.19636846f, -0.11301278f, 
    -0.57877880f, -0.43932876f, -0.37771103f, -0.18537933f, 0.04799934f, 0.25336352f, 0.97771269f, -0.34060934f, 
    0.20669055f, 0.03604795f, 0.15109918f, -0.28676483f, 0.09184664f, -0.26294965f, 0.18237469f, -0.04042725f, 
    0.17303029f, -0.11885051f, 0.05149003f, -0.06081758f, -0.02601272f, -0.28618255f, -0.11559843f, -0.09260362f, 
    0.00274707f, 0.96983832f, 0.55727935f, 0.11000394f, 0.27749798f, -0.74684089f, -0.20121458f, -0.41242754f, 
    0.26671478f, 0.29938436f, 0.41882071f, 0.24459784f, 0.02902634f, -0.09033175f, -0.01320143f, -0.22791757f, 
    -0.02078037f, -0.24002749f, -0.19841988f, -0.15063867f, 0.23686519f, -0.03563360f, 0.12840636f, 0.04506184f, 
    -0.06072467f, 0.03027141f, 0.72043926f, 0.34062025f, 0.51530981f, -0.13335702f, -0.11959514f, -0.13975936f, 
    -0.06140381f, 0.20544638f, 0.24015440f, 0.23642284f, -0.17711109f, -0.17311957f, 0.16568603f, -0.21496783f, 
    0.35673052f, 0.05339502f, -0.14357294f, 0.23956306f, -0.19529670f, 0.36800721f, 0.40955758f, -0.22620362f, 
    0.13932361f, 0.06632080f, 0.32507131f, 0.38099909f, 0.10825972f, -0.59977782f, -0.26924375f, 0.18514271f, 
    -0.04744243f, 0.54544789f, 0.66965705f, 0.34365407f, 0.43716380f, -0.04130635f, -0.21798912f, 0.11496446f, 
    -0.49653617f, 0.35222924f, -0.32629094f, -0.24185634f, -0.28207257f, 0.10174494f, -0.08083813f, 0.06800213f, 
    0.05437160f, -0.34217247f, -0.20505925f, -0.32671362f, 0.23290516f, 0.36783066f, 0.46036947f, 0.35955474f, 
    0.04292552f, -0.28066120f, -0.63907254f, -0.45294791f, 0.15641116f, -0.51199025f, 0.09244335f, -0.20151283f, 
    -0.05278659f, 0.07057673f, -0.17597674f, 0.26066449f, 0.02670464f, -0.09323503f, -0.12896852f, 0.01569538f, 
    -0.12717584f, 0.47594622f, 0.24141994f, -0.02702658f, 0.09592908f, 0.83997333f, 0.40964112f, 0.59350526f, 
    0.15153007f, -0.55784518f, 0.24485189f, -0.25093344f, 0.16915269f, -0.32104847f, 0.30823261f, 0.39105618f, 
    0.26241550f, -0.13846591f, 0.24565454f, -0.13960895f, -0.30631587f, -0.07138792f, 0.02430580f, -0.03497643f, 
    -0.22692415f, -0.00101156f, -0.05808784f, -0.21871783f, 0.00438893f, 0.05768452f, 0.65247834f, 0.51643741f, 
    0.16379841f, -0.05075367f, -0.02069551f, 0.23871988f, 0.26147708f, 0.44510484f, 0.23332278f, 0.51670778f, 
    -0.02177438f, 0.31747749f, -0.27662334f, -0.12282325f, -0.28079391f, 0.23703302f, -0.13241655f, -0.10299135f, 
    0.01281256f, -0.07282489f, 0.09483916f, -0.32014108f, -0.08803558f, -0.10538194f, -0.21263091f, -0.41682827f, 
    0.48460028f, 0.59491402f, -0.03040552f, 0.19270916f, -0.19429441f, -0.26830316f, -0.30830747f, -0.62270266f, 
    -0.16790244f, 0.17033590f, 0.13058282f, 0.19237262f, -0.44556043f, -0.31517389f, -0.43540326f, 0.06316322f, 
    0.04557466f, -0.21318443f, 0.32764798f, 0.15607290f, -0.15171985f, -0.45851028f, -0.18366124f, -0.12340127f, 
    -0.66546631f, -0.67600203f, -0.63653940f, -0.00591897f, -0.02634196f, 0.47628275f, 0.44343263f, -0.10416529f, 
    0.66000772f, 0.37672821f, -0.19281843f, 0.08275864f, 0.03438190f, 0.36363265f, 0.30967057f, -0.04961854f, 
    -0.08008742f, -0.02761680f, 0.00335159f, -0.07713468f, 0.19160539f, -0.11014912f, -0.19820802f, 0.23448913f, 
    0.08782413f, -0.72204268f, -0.24719264f, -0.11975756f, -0.41697019f, 0.32612443f, 0.51637095f, -0.47686085f, 
    0.09587611f, -0.65312159f, -0.27069002f, 0.03226432f, 0.38898739f, 0.33008501f, 0.28965831f, -0.25829065f, 
    0.14911704f, -0.06713559f, 0.04399103f, -0.20299579f, 0.09861840f, 0.05102185f, -0.33857691f, 0.09389832f, 
    0.00879708f, -0.25414616f, -0.61889869f, -0.48173192f, -0.26005438f, -0.33855182f, -0.35767874f, 0.27872372f, 
    0.60454327f, 0.18483135f, 0.00976355f, 0.46778169f, -0.16377169f, -0.15420732f, -0.11012790f, -0.17352958f, 
    0.29716563f, 0.22439103f, 0.05880785f, -0.06985545f, 0.00123960f, 0.09332936f, -0.09009991f, 0.05372231f, 
    0.20939812f, 0.10308297f, 0.30536667f, 0.38698038f, -0.13894534f, -0.45628023f, -0.72980279f, -0.04129557f, 
    -0.05124522f, 0.43264627f, 0.14141747f, 0.42385966f, 0.31896776f, 0.31377089f, -0.10594499f, -0.11355500f, 
    -0.19148892f, 0.10480646f, 0.23832177f, 0.44561815f, 0.21816164f, 0.25461042f, -0.09144055f, 0.19068462f, 
    -0.00044907f, 0.20336257f, -0.39785874f, 0.49563360f, 0.37604132f, -1.06301606f, -0.41646048f, 0.51785576f, 
    0.34027362f, -0.17042832f, 0.67884010f, 0.42319077f, -0.06573893f, 0.39590287f, 0.09272885f, 0.21820310f, 
    -0.48877209f, -0.11404675f, 0.05251775f, 0.09587743f, -0.13867335f, -0.04113337f, 0.21925083f, -0.16917199f, 
    0.16887388f, -0.03326346f, 0.07227741f, 0.04051443f, -0.02020103f, 0.62604105f, 0.04746892f, 0.68489844f, 
    0.59548360f, 0.47935352f, 0.72560275f, -0.00068474f, -0.39136755f, -0.30160356f, -0.24743104f, 0.04696571f, 
    0.34322405f, 0.06644518f, 0.18961927f, -0.05413701f, 0.14945628f, 0.03380007f, 0.24187070f, 0.15661028f, 
    -0.09357354f, 0.13621020f, 0.21386600f, 0.24024361f, 0.08322396f, 0.18629523f, 0.79050350f, -0.32869565f, 
    0.62473011f, 0.10887909f, -0.24682215f, -0.01348766f, -1.01725268f, 0.21571127f, 0.09641983f, 0.15384361f, 
    0.08567097f, -0.19385365f, -0.27038193f, -0.06393731f, -0.14588434f, -0.07486586f, 0.17409508f, 0.28996602f, 
    0.00751490f, -0.14113413f, 0.25743711f, 0.16991603f, 0.13849875f, 0.33630788f, -0.05301923f, -0.84153593f, 
    0.90095401f, -0.43582499f, 0.12116424f, 0.33539060f, 0.99471509f, -0.53405428f, -0.80156255f, 0.24069829f, 
    -0.37134656f, -0.07473087f, -0.00098664f, -0.22445716f, 0.22163413f, -0.30924580f, -0.15751618f, -0.05367663f, 
    0.04930408f, -0.31666809f, 0.07149582f, 0.14191155f, 0.01521402f, 0.01498795f, -0.02691218f, -0.22911377f, 
    -0.64841342f, -0.37752131f, -0.42645451f, -0.34649804f, -0.18636106f, 0.03474222f, 0.65185577f, 0.02396933f, 
    0.09127478f, 0.05547205f, 0.52681047f, -0.25270298f, -0.19006017f, -0.45105964f, 0.28858817f, 0.13006449f, 
    -0.19044991f, -0.07146268f, 0.04077972f, -0.20309088f, -0.03441982f, -0.04918676f, 0.23047309f, 0.11386048f, 
    -0.00914006f, 0.29760841f, 0.37687266f, 0.42087153f, -0.19579870f, 0.56905067f, -0.49010271f, 0.67981398f, 
    0.47103649f, -0.36880490f, 0.18953849f, -0.13594681f, -0.15771422f, -0.23668894f, -0.07172987f, -0.36386159f, 
    -0.22319953f, -0.01096497f, -0.03206473f, -0.25644264f, -0.36110422f, 0.14278151f, 0.05517187f, 0.20065254f, 
    -0.07228592f, -0.18144386f, -0.66789758f, 0.15032840f, 0.51399058f, 0.48908693f, -0.49252164f, 0.07806958f, 
    0.12838964f, 0.21213962f, 0.45631120f, -0.36615744f, 0.10914844f, 0.31507245f, -0.05914678f, 0.22874792f, 
    -0.07623459f, -0.51483667f, -0.16535477f, -0.09398989f, -0.32456931f, -0.19376259f, 0.25203106f, -0.15102436f, 
    -0.08991437f, 0.20616001f, 0.11039855f, 0.86030787f, 0.18833680f, -0.73847395f, 0.36114818f, 0.79729080f, 
    0.14229117f, -0.05320551f, 0.20929459f, 0.35604900f, -0.20432711f, 0.01749215f, -0.10085440f, 0.21130386f, 
    -0.22899222f, 0.13860105f, 0.11016621f, -0.42328584f, -0.29728982f, -0.33936715f, -0.12504466f, 0.39963689f, 
    -0.04847865f, 0.03205923f, 0.17505659f, 0.08242612f, 0.18089211f, -0.81790495f, -0.32193172f, -0.45480961f, 
    -0.23261525f, 0.16010889f, 0.62240505f, -0.64392728f, -0.22555846f, 0.34354237f, 0.01074681f, 0.21408224f, 
    -0.11941603f, 0.35610256f, 0.25985536f, -0.14685023f, 0.11824638f, -0.00294114f, -0.14885345f, 0.13141105f, 
    0.07360391f, -0.01666120f, 0.28417844f, -0.15102050f, -0.09419434f, 1.02292323f, -1.00182176f, 0.18776140f, 
    0.84504348f, 0.30449298f, -0.63813508f, 0.36339858f, 0.30793282f, 0.41942891f, -0.24452941f, 0.24521197f, 
    -0.01527650f, -0.15238896f, -0.06911707f, -0.14408493f, -0.01703341f, 0.02984920f, 0.02020566f, 0.24070957f, 
    0.08851904f, -0.12010762f, -0.02934485f, 0.17463830f, 0.11539464f, 0.02989144f, 0.34180298f, -0.12747218f, 
    0.17006408f, 0.32389185f, 0.41012192f, -0.51115662f, 0.31686324f, 0.02370409f, 0.09583839f, 0.25867176f, 
    -0.10169242f, -0.04662368f, -0.09716865f, 0.01012386f, 0.36050627f, 0.33728668f, 0.00687525f, -0.44364148f, 
    -0.26816276f, -0.04709807f, -0.42292544f, -0.42391977f, -0.52901542f, -0.06701826f, -0.04253397f, -0.23010936f, 
    -0.68022174f, -0.58677137f, -0.09104700f, -0.35059610f, 0.47977805f, 0.51218969f, 0.03457299f, -0.09154221f, 
    0.25644872f, 0.06145767f, -0.08597622f, 0.05866986f, 0.28585353f, 0.17282587f, -0.42143071f, 0.19469061f, 
    0.16897032f, 0.33136064f, 0.11409417f, -0.09730369f, -0.01436587f, 0.11145680f, -0.37771860f, 0.02614984f, 
    0.50877100f, 0.84662044f, 0.28837365f, 0.38481671f, 0.26484549f, -0.47446319f, 0.36370113f, -0.81019014f, 
    -0.07088817f, 0.29090670f, 0.00464739f, -0.01587760f, 0.16617425f, -0.35336834f, 0.21384631f, 0.07527211f, 
    0.11827801f, 0.23385330f, 0.05183022f, -0.04343968f, -0.35784662f, 0.34202784f, -0.21563862f, -0.00908245f, 
    0.12613669f, 0.58619869f, 0.83863562f, -0.38994697f, -0.65592670f, -0.50332272f, 0.09400570f, -0.03729085f, 
    0.02900811f, -0.32527834f, 0.43269390f, 0.09473486f, 0.18753427f, -0.04957909f, -0.16523123f, 0.13501424f, 
    -0.12742412f, -0.10771372f, 0.20638096f, -0.07062305f, -0.16858023f, 0.11233626f, 0.08991626f, 0.01610692f, 
    0.00797950f, -0.17056935f, -0.79176301f, -0.54586619f, 0.26415145f, 0.06477592f, 0.09166394f, -0.13575812f, 
    0.38691077f, -0.38616803f, 0.23400542f, -0.19788519f, -0.01899157f, 0.21587294f, 0.26225141f, 0.07664800f, 
    -0.31265125f, -0.23534903f, -0.19058575f, 0.25121379f, -0.25348887f, -0.27775374f, 0.30261332f, 0.30579534f, 
    -0.22237097f, 0.02948865f, 0.07165264f, 0.27129108f, 0.28832233f, 0.06463294f, 0.08812051f, 0.64860135f, 
    -0.02027350f, 0.18240446f, -0.13706237f, 0.48833025f, 0.58372903f, 0.19176073f, 0.36301044f, -0.39716741f, 
    -0.34512374f, 0.03661565f, -0.26854214f, -0.11721114f, 0.00686379f, -0.04497799f, -0.25059637f, -0.21373032f, 
    -0.16994782f, 0.40692449f, -0.09865689f, -0.31849748f, 0.10185643f, -0.81693810f, 0.49929035f, 0.72820735f, 
    -0.37159476f, 0.51969421f, -0.71704012f, 0.46459422f, 0.23482955f, -0.38444173f, 0.13750473f, -0.38514256f, 
    -0.23478766f, 0.12061036f, 0.00960207f, 0.06074018f, 0.21391617f, -0.00032158f, -0.19801295f, 0.19188166f, 
    0.18595290f, -0.21003695f, 0.39168310f, 0.04851608f, 0.11666498f, 0.47584319f, 0.16024031f, -0.51226646f, 
    -0.90421617f, -0.41995427f, 0.09294309f, -0.21254535f, -0.03153254f, -0.39205030f, -0.50030333f, 0.37588561f, 
    0.04840864f, 0.17722107f, -0.05819241f, -0.06476394f, -0.16947971f, 0.11091019f, -0.18154822f, -0.08849313f, 
    0.21021880f, -0.03484115f, -0.19867752f, 0.05691604f, -0.10438129f, -0.20462751f, 0.76739746f, -0.59321737f, 
    -0.74828804f, -0.44924769f, -0.04580540f, 0.68434179f, -0.49197745f, -0.00404452f, 0.05349825f, -0.04457707f, 
    -0.39645275f, -0.16778773f, -0.16379383f, 0.08324057f, -0.25010034f, -0.05976591f, -0.15403356f, -0.19570850f, 
    0.01555085f, -0.14936210f, -0.09962631f, -0.08140492f, 0.02477073f, 0.32851034f, 0.16453223f, -0.03877197f, 
    0.63533944f, -0.04616861f, -0.35997993f, 0.08340415f, -0.65231180f, -0.88386822f, -0.22251859f, -0.06763981f, 
    0.15490617f, 0.40099427f, -0.02505434f, -0.33192021f, -0.20623082f, 0.21044548f, -0.05706671f, -0.02775759f, 
    -0.38885713f, -0.21559623f, -0.11467078f, 0.41845235f, 0.24506079f, 0.17903127f, -0.02752210f, -0.01845432f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.27975571f, -0.13901131f, -0.10651107f, 0.17711689f, 0.09702446f, 0.08852002f, 0.28644770f, 0.23733796f, 
    0.10584845f, 0.14509977f, 0.09754119f, 0.19773233f, 0.10450779f, 0.09965926f, 0.13403238f, 0.13819024f, 
    0.14388348f, 0.05984608f, 0.11104043f, 0.10681760f, 0.13530283f, 0.07488221f, -0.06013962f, 0.09437696f, 
    -0.17716943f, -0.03288122f, -0.08516100f, 0.09838603f, 0.13911003f, 0.03312919f, 0.16070816f, -0.16294913f, 
    0.14566509f, 0.17665032f, 0.30324322f, 0.08816603f, 0.26665336f, 0.27498546f, 0.14149319f, 0.06760179f, 
    0.12607107f, 0.19153020f, 0.11742863f, 0.24954259f, 0.23706785f, 0.05432897f, 0.18555474f, -0.15062164f, 
    0.08343047f, 0.19893414f, 0.22900799f, 0.04789957f, 0.35775125f, -0.07245723f, 0.16420747f, 0.22903521f, 
    0.02952394f, 0.25280625f, 0.16448165f, -0.05088610f, 0.09311312f, 0.19047093f, 0.20016588f, 0.19128561f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.12291972f, -0.02408923f, 0.02524074f, 0.01887282f, -0.06575435f, 0.03984191f, 0.10644694f, -0.00051155f, 
    -0.00266438f, 0.04892506f, -0.05377513f, -0.03817485f, 0.41733822f, 0.14679287f, 0.14506802f, 0.24180411f, 
    -0.08865533f, 0.07781241f, 0.00175212f, 0.00297866f, -0.01354325f, -0.01985352f, 0.03576724f, 0.08264230f, 
    0.09875833f, 0.06345436f, -0.15236956f, 0.14288221f, 0.05683473f, -0.03476271f, 0.03972707f, 0.03635795f, 
    -0.00001920f, 0.12761006f, -0.01924479f, 0.06132466f, 0.28737924f, -0.12913606f, 0.02266280f, 0.10650201f, 
    0.08250230f, -0.05470578f, -0.07391348f, 0.02618017f, 0.07871033f, -0.01327002f, -0.02340240f, -0.06756774f, 
    0.22935933f, -0.04786875f, 0.07572088f, -0.16677591f, 0.10077649f, -0.01489691f, 0.04241163f, -0.02225437f, 
    -0.07624399f, -0.02492960f, 0.01716959f, 0.02719614f, 0.04537894f, 0.06738793f, -0.05138874f, -0.00041436f, 
    -0.04929930f, -0.03761152f, 0.12753417f, 0.01713884f, -0.07516325f, 0.01534817f, -0.02373858f, -0.06189685f, 
    0.08625902f, 0.08559819f, -0.05731279f, 0.05268430f, -0.03953482f, -0.02162925f, 0.03868704f, 0.07408586f, 
    -0.01486208f, -0.00210949f, 0.00171698f, -0.01488063f, 0.05257460f, -0.01913047f, -0.13405983f, -0.05834738f, 
    0.03587296f, 0.09387282f, -0.03235745f, 0.03769309f, -0.01504598f, 0.08964635f, 0.06008203f, 0.00692570f, 
    0.08167665f, 0.00014609f, 0.05543551f, -0.11406655f, 0.12483852f, -0.01104223f, 0.00628042f, -0.02074510f, 
    0.12507895f, 0.03158180f, -0.00839018f, -0.10488594f, 0.16960953f, 0.06879801f, -0.07700586f, 0.00227568f, 
    0.12724753f, -0.03411886f, -0.09324486f, 0.02689525f, -0.05339440f, 0.06135291f, -0.04623426f, -0.00107619f, 
    0.07279738f, 0.07837395f, 0.08611612f, 0.12970896f, -0.06759674f, -0.03898337f, 0.01456932f, -0.03700467f, 
    -0.13516097f, 0.04556411f, -0.01897151f, 0.01378154f, -0.12598012f, 0.17413016f, 0.05817327f, 0.00277122f, 
    0.07652640f, -0.10871494f, -0.03562578f, 0.10463471f, -0.15549533f, 0.01444217f, 0.05847540f, 0.00522424f, 
    0.17354421f, -0.03087989f, 0.04015873f, 0.12219130f, -0.12144069f, -0.02515852f, -0.08243805f, 0.10038465f, 
    -0.04447614f, 0.16510916f, 0.07450304f, -0.06500342f, -0.10060991f, -0.01234278f, 0.19911140f, 0.18816712f, 
    -0.06861784f, -0.01973766f, 0.01182745f, -0.01800747f, -0.05656638f, -0.03274396f, -0.14424972f, 0.07503749f, 
    -0.16786259f, 0.02151360f, -0.19021559f, 0.10327543f, -0.02798948f, -0.08131175f, -0.00026267f, -0.03068208f, 
    0.00007749f, 0.00226888f, 0.00964785f, -0.09261801f, 0.06341291f, 0.02323135f, 0.12704152f, 0.10325411f, 
    -0.02811214f, 0.04395675f, 0.10284305f, -0.03238223f, 0.02639294f, 0.10100508f, 0.07555373f, -0.06124745f, 
    -0.10247070f, -0.07184777f, -0.13313912f, 0.16046523f, -0.01513491f, -0.04676378f, 0.03484702f, -0.03912444f, 
    0.06091723f, 0.06385531f, -0.04661957f, -0.14512885f, -0.11079145f, 0.17220476f, -0.03841813f, 0.05100058f, 
    -0.07988463f, 0.10055624f, -0.00604347f, 0.04316377f, 0.06762248f, -0.04264146f, -0.06490096f, -0.07755788f, 
    -0.05799442f, 0.10424846f, 0.00099636f, 0.03864172f, 0.00794134f, 0.06872905f, 0.08419904f, 0.05704812f, 
    0.01049984f, 0.07622083f, -0.03828273f, -0.02936308f, 0.03604418f, 0.02653727f, -0.04941583f, 0.22631627f, 
    0.05617774f, 0.04992165f, -0.13376927f, 0.19154409f, -0.04479446f, 0.04146390f, -0.00791041f, -0.02242129f, 
    -0.18774989f, -0.03997873f, 0.23029386f, 0.07276771f, -0.02675541f, 0.08386089f, 0.05330243f, -0.03964222f, 
    0.00614203f, 0.00831317f, -0.02699464f, 0.05661374f, -0.20463006f, 0.12405182f, 0.06547771f, 0.07892152f, 
    0.05294959f, -0.04880621f, 0.12145600f, 0.06114818f, 0.07891091f, 0.02829284f, 0.01444190f, 0.11236092f, 
    0.02972546f, 0.00830713f, 0.19586514f, -0.03256496f, -0.16432473f, -0.01455518f, 0.09060840f, 0.04933831f, 
    -0.08078072f, 0.05564120f, 0.00158675f, 0.07320950f, 0.04361352f, 0.04685051f, 0.02145841f, 0.02333923f, 
    0.07026994f, 0.00536606f, -0.00990707f, 0.01081398f, 0.00188469f, 0.04292842f, -0.02002270f, 0.02415679f, 
    0.35049611f, 0.14793019f, -0.03586744f, 0.14112708f, 0.17833127f, -0.00254860f, 0.02761511f, -0.03512673f, 
    0.04889192f, 0.05841534f, -0.04363771f, -0.04841284f, 0.10828396f, 0.01646592f, 0.00366139f, 0.09999914f, 
    -0.10030592f, -0.05241932f, 0.00553746f, 0.12879398f, -0.09653222f, 0.05328345f, 0.00227195f, 0.02251023f, 
    -0.03314126f, 0.10421981f, 0.18717694f, 0.08491537f, 0.15169543f, -0.02863894f, -0.06082764f, 0.00695498f, 
    0.00328711f, 0.07494822f, 0.10849251f, 0.04508767f, -0.14428686f, 0.14008488f, -0.07972071f, -0.06799952f, 
    0.04740655f, 0.12396710f, -0.05410653f, 0.08426924f, 0.13641275f, 0.01089145f, 0.07953858f, 0.10533112f, 
    -0.00872751f, 0.13413513f, 0.24341924f, 0.01254929f, -0.04158934f, 0.05710512f, 0.07052250f, 0.02309090f, 
    0.04506536f, 0.03801656f, -0.00579820f, -0.03413505f, 0.06340172f, 0.19916221f, -0.10012176f, 0.08944681f, 
    -0.10414341f, 0.05967453f, 0.05783688f, -0.00600397f, -0.11066362f, 0.06723553f, -0.07277434f, 0.10313555f, 
    -0.07413974f, -0.08685452f, 0.00041417f, 0.10377821f, -0.10130661f, 0.04636550f, -0.09659316f, 0.03943548f, 
    -0.09080479f, -0.04898819f, -0.09256727f, -0.09524304f, 0.29377043f, 0.01807844f, 0.08914898f, -0.02730444f, 
    0.07319830f, 0.13277121f, -0.08719904f, -0.04558586f, 0.10440134f, 0.04396348f, 0.06945547f, -0.02608400f, 
    0.01856558f, 0.08182872f, 0.11665472f, -0.17826381f, -0.03079762f, 0.08805289f, -0.08562663f, 0.10909829f, 
    0.00077628f, 0.02589159f, 0.01615143f, 0.01186648f, 0.19757088f, 0.05048972f, -0.05407126f, 0.01378107f, 
    -0.19776183f, 0.00130973f, -0.00058111f, 0.05659245f, -0.15571895f, 0.03001054f, 0.03199640f, 0.00980991f, 
    0.09978139f, 0.07183523f, -0.06603848f, -0.03200310f, -0.00162535f, -0.09358644f, 0.06351690f, 0.05126911f, 
    -0.00361432f, -0.02073341f, -0.03697808f, -0.04402026f, 0.04742037f, 0.02933010f, 0.09730094f, -0.19429605f, 
    0.11217636f, -0.08811222f, -0.00642494f, -0.09697999f, 0.02748838f, -0.05197388f, 0.01438035f, 0.04733970f, 
    0.07282728f, 0.00754464f, -0.15355784f, 0.15645424f, -0.07375655f, -0.02400281f, -0.03134267f, -0.10851873f, 
    -0.04850733f, 0.06572330f, -0.12055341f, 0.02696094f, 0.01027751f, 0.09526253f, -0.02301705f, -0.03718181f, 
    -0.13870211f, -0.00620622f, 0.03657814f, 0.01830800f, -0.09328321f, 0.01521785f, 0.03013037f, -0.03118796f, 
    0.23213428f, -0.03614317f, 0.18018015f, -0.09800631f, -0.05255037f, -0.07681132f, -0.01480854f, 0.07140989f, 
    -0.03039110f, 0.05565785f, -0.03126848f, -0.02093808f, -0.07929056f, -0.12092288f, -0.05627457f, 0.22683075f, 
    -0.05882204f, -0.06448832f, 0.10517612f, -0.15559977f, -0.07743505f, 0.11156702f, 0.05611178f, 0.00932318f, 
    0.04000708f, 0.06861717f, -0.14174241f, -0.12910549f, 0.10287259f, 0.01483257f, 0.02109947f, 0.04966939f, 
    0.03096597f, 0.01330150f, 0.00155071f, 0.04176344f, -0.12420430f, -0.16662452f, 0.15905978f, 0.09905309f, 
    0.08168596f, 0.05452192f, -0.07185505f, -0.02328464f, 0.02164704f, 0.03785190f, -0.05274985f, -0.13164262f, 
    0.11566199f, 0.10858983f, -0.01919050f, 0.01023706f, 0.07754217f, 0.08135314f, 0.01493185f, 0.09977236f, 
    0.00915676f, 0.02484906f, -0.01403422f, 0.04969310f, 0.02244406f, -0.08764577f, -0.02373483f, -0.13111614f, 
    0.00234804f, 0.00683242f, 0.01021697f, -0.07281522f, 0.01769442f, -0.07316458f, -0.11202779f, 0.07425140f, 
    0.11808398f, -0.04918021f, 0.07073871f, -0.11159546f, -0.04785170f, 0.10283309f, 0.00879258f, -0.00416758f, 
    -0.00370486f, 0.01818032f, -0.06287152f, -0.02945395f, 0.13406573f, -0.09466086f, 0.26201597f, 0.23030131f, 
    -0.05966317f, -0.08182940f, -0.04956664f, 0.01525555f, -0.04172710f, 0.03759740f, -0.04759767f, 0.09181557f, 
    -0.02562143f, -0.07434069f, -0.08573814f, 0.04335822f, -0.13520534f, -0.06205441f, -0.04217324f, -0.03848677f, 
    0.03872507f, -0.09638031f, 0.04654802f, 0.09821913f, 0.12892391f, 0.01895637f, 0.12656307f, 0.07671694f, 
    -0.07261319f, 0.03928544f, 0.10566821f, -0.08208087f, -0.10541179f, 0.04476716f, -0.05370642f, 0.08892724f, 
    0.16948561f, 0.17576782f, 0.11630134f, -0.14535624f, 0.12861550f, 0.07362971f, 0.03687297f, 0.11012403f, 
    0.02930240f, -0.02257941f, -0.02024703f, 0.00392932f, 0.05324866f, 0.11247924f, 0.14277154f, -0.12658620f, 
    0.00123124f, -0.03592665f, -0.00409971f, -0.02684849f, 0.05935622f, 0.04036283f, 0.03230189f, 0.08165479f, 
    -0.22215170f, 0.04148382f, -0.06676582f, 0.07971314f, -0.04200734f, -0.03283598f, -0.00962635f, 0.03203878f, 
    -0.06166146f, -0.04527388f, -0.01467110f, 0.03338058f, 0.17663218f, 0.06361259f, 0.00207612f, -0.24993318f, 
    -0.06394364f, -0.01117182f, 0.05508229f, -0.02383078f, -0.06475639f, 0.05999089f, 0.07117088f, -0.10318643f, 
    -0.02581838f, -0.14620179f, 0.05773157f, -0.07082365f, -0.09892612f, -0.04856094f, -0.01416192f, 0.00193815f, 
    -0.01356611f, -0.02558049f, -0.05496685f, -0.02488109f, 0.36799842f, 0.09684126f, -0.14901073f, 0.19137113f, 
    -0.10294286f, 0.03839137f, -0.07275232f, 0.03843575f, 0.07223302f, -0.00349591f, -0.06520656f, -0.08184987f, 
    0.27700648f, -0.03553213f, 0.03661106f, -0.04253108f, 0.03729479f, 0.08287682f, 0.10722998f, -0.01397009f, 
    -0.07970600f, -0.05748208f, -0.01427739f, -0.17747417f, -0.04349644f, 0.02815689f, -0.16171719f, -0.07969406f, 
    0.05619358f, -0.02380890f, -0.02682345f, -0.02237918f, 0.06311941f, -0.08954806f, -0.01523906f, 0.03777286f, 
    0.26580915f, 0.10661817f, 0.09820078f, -0.02296114f, -0.11160534f, -0.02572353f, -0.00021650f, 0.02352626f, 
    0.01751248f, -0.07505316f, -0.07250810f, -0.01624441f, -0.02337551f, -0.11195518f, 0.05018609f, -0.21083547f, 
    0.00977548f, -0.06075732f, 0.11748023f, 0.00268799f, -0.01866265f, -0.02662357f, -0.01882792f, -0.10458147f, 
    -0.08841702f, -0.10188390f, -0.01643507f, 0.00669199f, -0.01795663f, 0.00860480f, 0.07276403f, 0.06452385f, 
    -0.09077308f, 0.06045052f, -0.03030499f, -0.09103107f, 0.18365172f, -0.07028617f, 0.15917701f, -0.11499553f, 
    -0.06847391f, 0.01587041f, 0.03567602f, 0.06142392f, -0.01393209f, -0.05833628f, 0.04115539f, -0.03977668f, 
    -0.24766795f, -0.10622649f, -0.11497787f, 0.15628241f, 0.03949434f, 0.05176578f, -0.03459521f, -0.03880855f, 
    0.07235670f, -0.02227298f, -0.00860466f, 0.02953422f, -0.08193334f, -0.09810961f, 0.11283717f, 0.06598783f, 
    0.03560084f, 0.00079124f, 0.14192140f, 0.02704565f, -0.08436868f, -0.03846510f, 0.01794468f, -0.02312681f, 
    0.25570002f, -0.31305683f, -0.05247113f, -0.23016241f, 0.05332250f, -0.06595641f, -0.05413967f, 0.03542933f, 
    -0.06963684f, 0.05315794f, 0.00283371f, -0.02358219f, -0.27677655f, -0.13781646f, 0.11119477f, 0.15497762f, 
    -0.10607255f, -0.03580463f, 0.02027863f, -0.11051191f, -0.02386227f, -0.02809195f, 0.03236550f, -0.03849936f, 
    -0.02060662f, -0.02466776f, -0.04299122f, 0.00935479f, -0.03865036f, 0.00229979f, -0.03333052f, 0.00627071f, 
    -0.01220145f, -0.00757197f, -0.02307763f, -0.03901521f, -0.00419524f, -0.02582964f, -0.00406390f, -0.01406584f, 
    -0.00840105f, -0.02669943f, -0.04218122f, 0.01365761f, -0.01787148f, -0.00566950f, 0.00785010f, 0.00975169f, 
    -0.01378928f, -0.03939615f, 0.01201938f, -0.03568244f, -0.03923790f, 0.00474906f, 0.00789245f, -0.02399199f, 
    -0.02187475f, 0.00211332f, -0.03416635f, 0.00327154f, 0.00637551f, -0.02229670f, -0.03568197f, -0.02663385f, 
    0.00615157f, 0.01912653f, 0.00442552f, 0.00117186f, 0.01407829f, -0.01636479f, 0.01821701f, -0.01646545f, 
    -0.01114614f, -0.01456562f, -0.03047467f, -0.00282071f, -0.01335102f, -0.02474362f, -0.02365848f, -0.00257460f, 
    0.00285039f, -0.00377145f, -0.00933925f, -0.01298212f, -0.00288548f, -0.02668054f, -0.01224082f, -0.00096855f, 
    -0.01042239f, -0.02830816f, -0.00347751f, -0.00680136f, -0.00969359f, -0.03059133f, -0.01383266f, 0.01973544f, 
    -0.00326106f, 0.02613115f, -0.00318537f, 0.02383530f, -0.03775145f, -0.00112796f, -0.03361783f, -0.01377503f, 
    -0.02627747f, -0.02062132f, 0.01462900f, -0.00823049f, -0.01108799f, 0.02059305f, -0.00280956f, 0.00208366f, 
    -0.00582958f, -0.01783638f, -0.01879770f, 0.00907369f, 0.02746547f, -0.04222744f, -0.03512599f, -0.02391410f, 
    -0.00105523f, -0.01391976f, -0.02770806f, -0.02219737f, -0.03004011f, -0.02917152f, 0.03265816f, -0.03738445f, 
    -0.01587120f, 0.00701510f, 0.02300888f, -0.00241842f, -0.01278034f, -0.03672741f, -0.00091511f, 0.01876079f, 
    -0.01799713f, -0.01002551f, -0.02065764f, 0.00811416f, -0.03662567f, 0.01878901f, -0.03640275f, -0.01622070f, 
    -0.04049350f, 0.01098108f, -0.03953675f, 0.00750064f, -0.00160317f, -0.04245167f, -0.01911962f, 0.01625097f, 
    0.00028112f, -0.01170378f, -0.00704103f, 0.00056916f, -0.00716657f, -0.00420772f, 0.02270398f, -0.00054571f, 
    0.01157212f, 0.01717925f, -0.00081276f, 0.00821904f, -0.02737735f, 0.01167055f, -0.01193621f, -0.00328419f, 
    0.01044008f, -0.04065361f, 0.02645029f, 0.01839763f, -0.03765626f, -0.03740862f, -0.00010209f, 0.00138413f, 
    0.02557065f, -0.02971616f, -0.00841257f, -0.02539837f, 0.01613368f, -0.03218374f, -0.02625686f, -0.01714638f, 
    -0.02447948f, -0.00242543f, 0.01001203f, 0.00746976f, 0.00101731f, 0.02693643f, 0.02522023f, -0.00958721f, 
    0.02000681f, 0.02705215f, -0.04426896f, -0.03230850f, -0.02362025f, 0.00018081f, 0.00295872f, 0.02488414f, 
    -0.03158024f, 0.00890874f, -0.01932302f, 0.00591639f, -0.03317962f, 0.01136400f, -0.00393132f, -0.02887317f, 
    0.00644770f, -0.00556416f, 0.01758554f, -0.03749416f, -0.01342835f, 0.01270697f, 0.00218444f, 0.02575916f, 
    -0.00207542f, -0.00751460f, 0.00144091f, -0.02232732f, -0.04175983f, -0.02310339f, -0.02703319f, -0.03587086f, 
    -0.02190786f, -0.02912842f, 0.02256735f, -0.02565482f, 0.01904775f, -0.04351664f, -0.03580692f, -0.00295356f, 
    -0.03657125f, 0.02548554f, 0.00958347f, 0.02451066f, 0.02447836f, -0.01678876f, 0.02705229f, 0.01296775f, 
    -0.00138662f, -0.04086795f, -0.00078572f, -0.01219112f, 0.01539474f, -0.03896336f, -0.00202155f, -0.01311555f, 
    -0.04476748f, -0.03942442f, 0.00483301f, 0.00621137f, -0.04010429f, -0.02672750f, 0.00500737f, 0.01520455f, 
    -0.00287960f, -0.00218277f, -0.01014327f, -0.01090364f, -0.02785101f, 0.01757489f, -0.01697989f, -0.04366149f, 
    0.00145594f, 0.00586852f, -0.01935993f, -0.03236781f, 0.01849386f, -0.03301416f, -0.01218553f, -0.02114177f, 
    -0.02605855f, 0.00184232f, -0.00955413f, -0.03382548f, -0.00055670f, -0.00187120f, -0.01861947f, -0.00556428f, 
    -0.03725751f, 0.00787215f, 0.00287499f, 0.01602676f, 0.00440019f, 0.01106364f, -0.02912632f, -0.03801055f, 
    -0.02050280f, -0.01710413f, -0.01001745f, 0.02671591f, -0.04006901f, -0.01641350f, -0.03271392f, 0.01390324f, 
    -0.00062146f, 0.01911076f, 0.00588009f, 0.01951161f, -0.01295249f, 0.01453055f, -0.02964947f, -0.01464396f, 
    -0.01571861f, 0.01814560f, -0.03544257f, -0.00049565f, 0.02113381f, 0.01719091f, -0.02769732f, 0.00281099f, 
    -0.03690245f, -0.01731915f, -0.00530827f, -0.04402291f, 0.02398442f, 0.01225646f, 0.00649765f, 0.02284065f, 
    -0.02070060f, -0.04250518f, 0.01404091f, -0.00869650f, 0.02338246f, -0.02515793f, 0.02634969f, 0.02576542f, 
    0.01754325f, 0.01445839f, -0.01125748f, 0.02603692f, -0.01244770f, 0.00272271f, 0.00958250f, -0.02898876f, 
    0.00173287f, -0.01157521f, -0.01252476f, 0.02398220f, 0.02630870f, 0.00834905f, -0.00075877f, -0.00170707f, 
    -0.01034188f, 0.01178851f, 0.02050754f, -0.03952455f, -0.03742496f, -0.04385673f, -0.00023273f, -0.02746485f, 
    0.01921811f, 0.01336237f, -0.00844617f, 0.01212834f, -0.03544694f, 0.01596581f, -0.00900191f, -0.03381753f, 
    -0.00389886f, 0.00398831f, 0.01669229f, -0.00850285f, -0.00965031f, 0.00354831f, 0.00183528f, 0.02071972f, 
    -0.03027069f, -0.00983683f, 0.02529948f, 0.01385462f, 0.02153414f, 0.00004505f, 0.00383624f, 0.01195012f, 
    0.02742779f, -0.01299551f, -0.00772022f, 0.02801532f, -0.03924882f, 0.01611775f, -0.00792451f, -0.01373120f, 
    0.01693769f, -0.01183752f, 0.00901035f, -0.01135511f, -0.00838990f, -0.00106542f, -0.02621907f, 0.00038129f, 
    -0.03536172f, -0.02996525f, 0.02022655f, -0.02469860f, -0.01786756f, -0.04062473f, 0.02093904f, -0.00914941f, 
    -0.00532251f, 0.01923118f, -0.02821919f, -0.00931169f, -0.03418789f, -0.01965086f, 0.02527056f, 0.00324060f, 
    -0.02676337f, 0.01551184f, -0.03784013f, -0.03253859f, -0.02601530f, -0.00698394f, -0.01063109f, 0.01615410f, 
    0.00701681f, -0.03841094f, 0.01304217f, 0.00988435f, 0.01241304f, -0.01620878f, 0.02493715f, -0.02470370f, 
    -0.00113091f, -0.00963234f, 0.00779645f, -0.00546466f, 0.01665113f, 0.02688318f, 0.00899603f, -0.00015936f, 
    -0.00381035f, 0.00287748f, -0.00032252f, -0.03066142f, -0.02290312f, -0.04387468f, -0.03979024f, -0.03884928f, 
    -0.02765671f, -0.03389363f, -0.02011565f, -0.02079993f, 0.02549683f, -0.00104108f, -0.00987346f, -0.01987232f, 
    -0.03007756f, -0.03778617f, -0.02024072f, 0.00451551f, 0.02737069f, -0.04296474f, -0.00096734f, 0.00428453f, 
    0.02583906f, -0.00739124f, -0.03402524f, -0.02960507f, 0.00675754f, -0.01576901f, -0.03202599f, 0.01397610f, 
    -0.03340516f, -0.00667746f, -0.02364803f, -0.01850722f, -0.00869610f, 0.00258400f, -0.00533892f, 0.02554835f, 
    0.01097170f, -0.01523750f, -0.01653364f, -0.03307453f, -0.03583184f, 0.02413728f, -0.03281453f, -0.03064985f, 
    -0.02544732f, -0.02899431f, -0.00015334f, 0.02731696f, -0.00918704f, 0.01974917f, 0.00048873f, 0.01214747f, 
    0.00461262f, 0.01064387f, -0.01629031f, 0.00452062f, -0.01393509f, 0.00218975f, 0.02120635f, -0.02355533f, 
    0.02141104f, -0.01034301f, -0.00997315f, -0.00908116f, -0.02592755f, -0.03921963f, 0.02482939f, 0.01708405f, 
    0.00667758f, -0.01192683f, 0.01770123f, -0.04444822f, -0.01674380f, -0.03072619f, 0.00015405f, -0.00098732f, 
    -0.02219481f, 0.01784346f, -0.00412308f, 0.02246028f, 0.00112521f, -0.00939079f, 0.02006973f, -0.00333477f, 
    -0.01718503f, 0.00307143f, 0.01500263f, 0.02337671f, -0.02431595f, -0.01853126f, 0.02405727f, -0.03385758f, 
    -0.01041899f, -0.02919682f, 0.01360555f, -0.04305770f, 0.00776467f, -0.04278987f, -0.01773943f, 0.01074650f, 
    0.02540500f, -0.02114256f, 0.00905224f, -0.04006911f, 0.01626022f, 0.01551058f, 0.02912769f, -0.01776752f, 
    -0.01624154f, -0.00516026f, -0.04431309f, -0.03422583f, -0.04494018f, -0.01520047f, -0.01981514f, 0.00374870f, 
    -0.01897696f, 0.01709025f, -0.02351642f, -0.03829988f, -0.01992093f, -0.04357586f, 0.00386554f, -0.04296792f, 
    -0.01752272f, 0.00607364f, -0.01650102f, -0.03035808f, -0.04411178f, -0.00580182f, -0.02654120f, 0.01099907f, 
    -0.03691912f, 0.02441307f, 0.01572665f, 0.02312128f, -0.01916226f, -0.03542265f, -0.01988465f, -0.02548006f, 
    -0.00120127f, -0.02076024f, -0.01582487f, -0.04144971f, -0.02185618f, 0.02543484f, -0.02702733f, 0.01167686f, 
    -0.03028464f, -0.02193931f, 0.01921657f, -0.00006590f, 0.00876072f, 0.02550110f, 0.02236345f, -0.02867518f, 
    0.01274788f, 0.01465780f, -0.02339137f, 0.02142802f, -0.01380272f, 0.00635219f, 0.01939538f, -0.04385657f, 
    -0.03763681f, -0.00271405f, 0.00461775f, 0.01127418f, 0.00404581f, -0.04186946f, 0.01469827f, 0.01150045f, 
    0.00977474f, -0.00170944f, -0.04069896f, -0.03830545f, -0.03837626f, 0.02460723f, 0.02262632f, -0.04382524f, 
    -0.03652779f, -0.04042803f, 0.02529305f, 0.01706608f, 0.01900426f, 0.02375303f, -0.01047782f, -0.00636114f, 
    -0.01113721f, -0.04181969f, -0.00584168f, -0.01053707f, -0.04264095f, -0.03458557f, -0.02798222f, 0.00268266f, 
    0.01847719f, 0.02626048f, -0.02195874f, 0.02317030f, 0.02659470f, -0.02413283f, -0.00642212f, -0.01465407f, 
    -0.03917110f, 0.02603162f, 0.01250551f, 0.02130703f, -0.01421881f, -0.01067815f, 0.01729298f, 0.01656430f, 
    0.02213494f, -0.01837157f, 0.02410373f, -0.04029340f, 0.01541369f, -0.00233709f, -0.02342363f, 0.01109583f, 
    -0.04039128f, 0.00323571f, -0.02262486f, -0.02261035f, -0.01345196f, -0.04080363f, 0.00990417f, 0.02277505f, 
    0.00451947f, -0.00373463f, 0.00423008f, 0.00690835f, -0.02741733f, 0.01289843f, 0.00607354f, -0.00759964f, 
    -0.00725492f, 0.00131721f, -0.02675705f, 0.01710384f, 0.00525689f, -0.03656197f, 0.01790078f, 0.02765463f, 
    -0.01206302f, -0.03280653f, -0.00323633f, 0.01520186f, -0.02721209f, -0.01945356f, -0.03826423f, -0.01031695f, 
    -0.00322944f, 0.02518640f, 0.02671981f, 0.01846223f, 0.02703189f, 0.01695322f, 0.01125170f, -0.01144366f, 
    0.01954936f, -0.01091711f, -0.00654787f, 0.00265080f, -0.01609338f, -0.00678662f, -0.04291392f, 0.00022703f, 
    -0.02199366f, 0.00468222f, 0.02989398f, 0.01776474f, -0.00330801f, 0.02136141f, -0.01241611f, 0.00612202f, 
    0.01875507f, 0.00329004f, -0.03104823f, -0.02872692f, 0.00070045f, -0.04063548f, -0.02085862f, 0.01609374f, 
    -0.04427186f, -0.01123640f, -0.01721479f, -0.02789376f, -0.02942369f, 0.00649762f, 0.02301639f, 0.00010796f, 
    -0.00346247f, 0.01326399f, -0.01789684f, -0.03408413f, -0.02322616f, -0.02704845f, 0.01494214f, -0.04353736f, 
    -0.01419056f, -0.01176075f, -0.01861649f, -0.01163018f, -0.04394940f, -0.02929549f, 0.01756553f, -0.01618701f, 
    -0.01157237f, 0.01512435f, -0.00567129f, -0.01004029f, -0.02892445f, -0.02730015f, -0.02896826f, 0.00009397f, 
    0.00598877f, 0.00776516f, 0.02007502f, 0.01043895f, -0.01510475f, -0.01511721f, -0.01200516f, 0.00463744f, 
    -0.00124213f, 0.02111529f, 0.00265549f, 0.01885897f, 0.01802325f, 0.00530641f, -0.01165517f, -0.00076160f, 
    0.00051636f, 0.02606083f, -0.00384393f, 0.00523840f, 0.00626478f, -0.04273682f, 0.01632555f, -0.00063921f, 
    -0.01562389f, -0.04028813f, 0.00154081f, 0.02415662f, 0.00917050f, -0.01535120f, -0.01065419f, 0.00046677f, 
    0.00586700f, 0.01291648f, 0.02367378f, 0.00229107f, 0.00464965f, -0.00869314f, -0.02179856f, -0.03504165f, 
    0.17607456f, 0.17218252f, -0.19913337f, 0.11509431f, 0.08316240f, -0.07753909f, -0.00864406f, -0.02905094f, 
    -0.09957310f, -0.09944255f, -0.05867756f, -0.01434765f, -0.03977084f, 0.12091247f, 0.17626610f, -0.17823952f, 
    0.15068741f, 0.07113928f, 0.04853665f, 0.00897753f, -0.11474590f, 0.04952503f, -0.08797032f, -0.07766452f, 
    -0.11999046f, -0.09074499f, 0.17115621f, 0.01816194f, -0.06866756f, -0.01838215f, -0.04869817f, 0.05712643f, 
    0.00367225f, -0.04363940f, 0.02773261f, 0.17362726f, -0.10329098f, 0.13247600f, 0.00482508f, -0.12948748f, 
    -0.05709752f, 0.10267924f, 0.09801893f, -0.02850666f, -0.03386046f, -0.09593837f, -0.11661924f, -0.13133927f, 
    -0.34432036f, -0.07593361f, -0.01738328f, 0.32623315f, 0.08459591f, 0.04555902f, 0.13494305f, 0.08287403f, 
    0.08113070f, 0.05256037f, 0.10259599f, -0.03152239f, -0.35936752f, 0.02197752f, -0.02631064f, 0.10102876f, 
    -0.00490109f, 0.13045964f, 0.00846719f, 0.07339810f, 0.09033582f, 0.07906291f, -0.00751676f, -0.08777500f, 
    0.08463597f, 0.18371516f, 0.00332628f, 0.17385693f, -0.00871357f, -0.04660062f, 0.00055255f, -0.06851815f, 
    0.01629414f, -0.14634797f, 0.14949721f, 0.07645315f, 0.31345779f, -0.14181738f, 0.21971431f, -0.04644559f, 
    0.00702643f, 0.00609092f, -0.04361730f, 0.00537075f, -0.01857091f, 0.05226827f, 0.17204063f, 0.03857390f, 
    0.11841128f, 0.09166028f, -0.01794329f, 0.21623951f, -0.08498934f, -0.07185340f, 0.06808525f, 0.14304061f, 
    -0.17252292f, 0.08071759f, -0.06163866f, 0.08014090f, 0.18235779f, -0.10259549f, 0.07351565f, 0.05079833f, 
    0.05612934f, 0.04103803f, 0.09700533f, 0.03139715f, 0.06481708f, -0.00607548f, -0.11570288f, -0.04656804f, 
    -0.14125881f, 0.05246997f, 0.10678001f, 0.00138995f, 0.10745707f, 0.06798204f, -0.03029773f, -0.01487645f, 
    0.06993329f, 0.04475994f, 0.05256600f, 0.10263629f, 0.11197796f, 0.05002942f, 0.08588694f, -0.09946079f, 
    0.01113911f, -0.05748439f, -0.01848113f, -0.02131844f, 0.02659108f, 0.02357505f, 0.06436405f, 0.11996543f, 
    0.04888959f, 0.08076128f, -0.00086143f, -0.15286256f, 0.00556934f, 0.07962479f, -0.03380163f, 0.00013474f, 
    -0.03568963f, -0.07462541f, 0.10828337f, 0.13542958f, -0.19325539f, -0.01511552f, -0.03357471f, 0.02400143f, 
    0.09727765f, 0.05914789f, -0.03090382f, -0.01455624f, -0.01131084f, -0.07162934f, -0.03907719f, -0.08272550f, 
    -0.10390360f, 0.13699858f, -0.12550303f, 0.13752091f, 0.03698704f, 0.06681128f, -0.08564495f, 0.02242880f, 
    -0.01776022f, 0.11652564f, -0.00381396f, -0.02440141f, 0.01946823f, 0.10725487f, -0.03764233f, -0.02643474f, 
    -0.00175140f, 0.13862152f, 0.09803915f, 0.14612606f, 0.05656251f, 0.03995382f, 0.09730301f, 0.09487130f, 
    0.19326472f, 0.04900665f, -0.14656821f, 0.01463791f, -0.03524343f, -0.09147061f, -0.09219712f, -0.11849077f, 
    -0.06979912f, 0.01926012f, 0.03372474f, 0.02425756f, -0.10874100f, -0.04397078f, -0.03751472f, 0.01923726f, 
    0.03379234f, 0.11342031f, 0.10290454f, 0.03491925f, 0.07706644f, 0.04607737f, 0.00809406f, 0.01573144f, 
    0.16270985f, -0.19955300f, -0.11423377f, -0.08346165f, -0.05316381f, 0.04043390f, 0.09655359f, 0.09601784f, 
    -0.03954078f, 0.01304204f, 0.00699108f, -0.04511119f, 0.19198960f, 0.01375635f, -0.05232996f, -0.13307787f, 
    -0.00027948f, -0.05859062f, 0.03676591f, -0.10717675f, -0.00370272f, -0.04059444f, 0.03582522f, 0.06554743f, 
    0.25438648f, -0.10079774f, -0.13071159f, 0.12676243f, -0.06209921f, -0.20111343f, -0.02601895f, 0.03315052f, 
    0.13975483f, -0.04321259f, -0.02329311f, -0.15234172f, 0.14490238f, -0.00676210f, 0.09832156f, 0.12295645f, 
    0.14158049f, -0.00388999f, -0.06580374f, 0.07631280f, -0.05010064f, -0.15365289f, -0.07374647f, -0.00043701f, 
    -0.04961323f, 0.01850002f, 0.00222109f, 0.04710145f, 0.14028783f, 0.08345903f, 0.06366594f, 0.09629257f, 
    0.00327072f, -0.05824499f, 0.10678887f, -0.12337323f, 0.27734861f, -0.00272745f, -0.01449678f, -0.07836913f, 
    -0.03422055f, 0.02035912f, -0.03419408f, -0.05391802f, -0.07019321f, 0.05945409f, -0.01482334f, -0.12528540f, 
    -0.24920459f, 0.13024601f, 0.12473048f, 0.26827714f, -0.10999865f, -0.17155196f, 0.06669101f, 0.01727840f, 
    0.00059481f, 0.11093046f, 0.10133559f, 0.09549644f, -0.27996671f, -0.13944854f, 0.06422530f, -0.02689151f, 
    0.12826885f, -0.02023046f, -0.06254626f, -0.01021604f, 0.08642856f, 0.07576393f, 0.11780424f, 0.09204342f, 
    0.25015068f, -0.09475526f, 0.17825742f, -0.14551188f, -0.02603230f, 0.06298472f, -0.06820498f, 0.06289171f, 
    -0.02087067f, -0.03686058f, -0.03434002f, 0.14920630f, 0.12048554f, 0.03185931f, 0.03973861f, 0.05878340f, 
    -0.04001685f, -0.05149161f, -0.02337480f, -0.12341984f, 0.02684305f, -0.01748373f, -0.08155384f, 0.01924527f, 
    0.03595474f, -0.10888121f, -0.06664593f, -0.00969990f, -0.00800769f, -0.02008478f, 0.00520051f, 0.03167199f, 
    0.05949568f, 0.01927352f, 0.08576375f, -0.02191132f, -0.24298961f, -0.04729775f, 0.05628055f, -0.05076447f, 
    0.04863383f, -0.02614418f, 0.00953322f, -0.00670817f, 0.13798732f, 0.03648458f, -0.07170273f, -0.14584033f, 
    0.22311105f, 0.02778092f, 0.18522698f, -0.20883659f, 0.04738607f, -0.04451999f, 0.05600954f, -0.04096176f, 
    0.04796276f, -0.06943447f, -0.00848986f, -0.01950853f, 0.33680186f, -0.13905479f, 0.07873308f, -0.01282799f, 
    0.07276220f, -0.06307751f, 0.12204981f, -0.03823724f, -0.07428377f, -0.03745046f, -0.06528690f, -0.02073477f, 
    -0.10725881f, 0.04590867f, 0.00725547f, 0.12158955f, -0.03545297f, -0.05928645f, 0.06916620f, 0.12157019f, 
    0.09166580f, -0.01916408f, 0.07648730f, -0.05836368f, -0.44886172f, -0.01453907f, 0.01659549f, 0.01358737f, 
    -0.10723425f, 0.12283563f, 0.12585612f, 0.04820797f, -0.04804807f, 0.02093520f, -0.02689707f, -0.10270257f, 
    -0.30983913f, -0.01088287f, 0.09444001f, -0.01530873f, 0.02878042f, -0.02746485f, 0.01787403f, -0.03271037f, 
    0.01544410f, 0.02084601f, 0.10665557f, -0.12675200f, -0.01002330f, -0.09771991f, 0.02805680f, 0.16794407f, 
    -0.07343783f, 0.02464563f, 0.05832170f, 0.09980545f, 0.00201516f, -0.02864809f, 0.03411879f, 0.07467915f, 
    -0.10536958f, 0.00467741f, -0.04777997f, 0.03119635f, 0.04079951f, 0.03517332f, -0.00414251f, -0.04193853f, 
    -0.05128965f, -0.00266644f, 0.09598787f, 0.01429563f, -0.33246553f, -0.01316783f, 0.06176142f, 0.01988528f, 
    0.04204242f, 0.08416745f, 0.03397904f, 0.11761628f, 0.08129513f, 0.07429013f, -0.06266217f, 0.01705315f, 
    -0.24520712f, 0.00844031f, 0.01389174f, 0.07091206f, -0.02558167f, -0.02971469f, 0.13111903f, 0.10160149f, 
    0.02633252f, 0.00169166f, 0.03259180f, 0.04239814f, 0.05553598f, 0.05841682f, 0.06727937f, 0.00991816f, 
    0.05419456f, 0.08114761f, 0.06994824f, -0.02210384f, 0.01425247f, 0.00868673f, -0.04470453f, -0.08451558f, 
    0.07114925f, -0.05758712f, 0.17858301f, 0.14382322f, -0.08033373f, -0.02341765f, -0.04591261f, -0.04483465f, 
    -0.09261259f, 0.03697041f, 0.00374181f, -0.03399026f, 0.28484005f, 0.28853157f, -0.08302989f, -0.03422766f, 
    0.01409271f, -0.06144581f, 0.09475878f, 0.05522723f, -0.02034608f, -0.06398765f, -0.06404567f, -0.05570194f, 
    0.13023403f, -0.01861665f, 0.05464909f, 0.13567054f, -0.00702411f, -0.01857490f, -0.08042336f, -0.00402115f, 
    -0.07498045f, -0.06222510f, 0.06551590f, 0.05553743f, -0.21382806f, -0.05403114f, 0.09360963f, 0.17390262f, 
    -0.07066656f, -0.01569990f, 0.04330274f, -0.05714709f, 0.02141167f, -0.00100451f, 0.02303312f, -0.13963149f, 
    0.29228783f, -0.09690934f, 0.20657967f, -0.07168861f, -0.06023435f, -0.00905956f, 0.03836819f, 0.07390296f, 
    0.02905987f, 0.05075461f, 0.07907268f, 0.02828563f, -0.21903460f, -0.00693050f, 0.02972030f, -0.18204190f, 
    0.05112847f, 0.09389808f, -0.06164804f, 0.02063295f, -0.04233391f, -0.10371827f, -0.10008264f, -0.08622143f, 
    -0.30307195f, 0.09677882f, 0.02101445f, 0.05160981f, 0.02040174f, 0.07725411f, 0.10903545f, -0.04347479f, 
    0.02019594f, 0.07143740f, -0.08143308f, 0.05294205f, 0.42939216f, 0.18490817f, -0.12146809f, 0.00689897f, 
    0.06475354f, 0.15195243f, 0.02491195f, 0.05829457f, 0.01147802f, -0.03783408f, 0.05881860f, 0.01449390f, 
    0.00203203f, 0.14001362f, 0.11425759f, 0.16986054f, -0.02075153f, 0.07431740f, -0.00487597f, 0.01070203f, 
    -0.03308335f, -0.04013552f, 0.11743246f, 0.05360357f, -0.00917659f, -0.12021264f, 0.07162058f, 0.12906981f, 
    0.15514064f, 0.02051948f, 0.02975425f, 0.11416499f, -0.03318367f, -0.00587742f, -0.04688862f, 0.21743871f, 
    0.22724538f, -0.07260855f, 0.05002238f, -0.11707944f, 0.05550588f, 0.08899499f, 0.04743298f, -0.00184908f, 
    0.02007529f, -0.03756560f, 0.01520902f, 0.07292753f, 0.23304133f, -0.01988730f, -0.03124860f, 0.04682460f, 
    -0.09987245f, -0.11549607f, 0.02155281f, -0.10503225f, -0.09554666f, -0.03731889f, 0.07300712f, -0.00842996f, 
    0.02755693f, 0.22520918f, 0.09673256f, -0.09700530f, 0.04270867f, -0.04796042f, -0.00050787f, 0.07561883f, 
    0.06475706f, -0.01106561f, -0.04580228f, 0.03268963f, 0.26608378f, 0.19465740f, 0.08579717f, -0.29616141f, 
    0.09082440f, 0.04557372f, 0.00985003f, 0.06108106f, -0.08179568f, -0.02353013f, 0.01617823f, -0.05285834f, 
    0.02250509f, 0.15699993f, 0.09594487f, -0.02277927f, -0.00042987f, 0.05540828f, 0.04023852f, 0.15348446f, 
    0.01947657f, -0.04682265f, 0.15358707f, -0.04904261f, -0.08589070f, 0.08562475f, 0.13981964f, 0.12016080f, 
    -0.10691892f, 0.01702256f, 0.10399508f, -0.01717567f, -0.01789122f, 0.08314489f, -0.04354149f, 0.03037997f, 
    -0.30824852f, 0.07507675f, 0.09499249f, -0.07277545f, 0.04999240f, 0.22170588f, 0.00290542f, 0.05433514f, 
    -0.00096831f, -0.08624762f, -0.10689084f, 0.05766829f, -0.14189902f, -0.05460166f, -0.10919002f, 0.20141865f, 
    -0.03505746f, -0.02681742f, -0.01697576f, 0.01516665f, -0.02663953f, -0.08586158f, 0.00299768f, -0.00081302f, 
    0.17202598f, 0.09201683f, 0.05876206f, -0.13043207f, 0.08631095f, 0.06336240f, 0.00699993f, -0.12943347f, 
    -0.00249593f, -0.01168605f, -0.05080385f, 0.06534519f, -0.08645309f, -0.00317703f, -0.02256660f, 0.06216326f, 
    0.07545843f, 0.01731160f, -0.07910373f, 0.00196868f, -0.08627291f, 0.03631830f, -0.01408291f, 0.24267255f, 
    -0.21457282f, 0.09716112f, 0.06227629f, -0.17010754f, -0.14160256f, 0.09988182f, 0.01704304f, -0.07474945f, 
    0.02805025f, -0.09917348f, -0.03711212f, -0.07992975f, 0.03138804f, 0.03995852f, -0.12317125f, 0.08171603f, 
    -0.00695410f, -0.01211477f, 0.03607003f, 0.00643664f, -0.02485274f, 0.03194286f, 0.00319752f, -0.02157992f, 
    -0.28596053f, 0.11333357f, -0.17554377f, 0.05991562f, -0.01379936f, 0.03812914f, 0.01838092f, -0.05547615f, 
    -0.06181191f, 0.01518120f, -0.08514711f, 0.04901354f, -0.20671135f, -0.07397033f, -0.14945602f, 0.02884021f, 
    0.03490423f, -0.01053881f, 0.02904108f, -0.08500458f, -0.04992306f, 0.02509601f, 0.02437272f, 0.01118407f, 
    -0.07307344f, 0.13445225f, -0.14165044f, -0.07342270f, -0.02165581f, 0.01633514f, 0.12466829f, 0.05834880f, 
    0.04854835f, 0.14113162f, 0.20686853f, -0.03572799f, -0.06056677f, -0.27026236f, -0.11696650f, 0.38691667f, 
    0.12965876f, 0.08392609f, -0.00224274f, -0.04754741f, 0.01154808f, 0.05701348f, 0.24231726f, 0.04542055f, 
    -0.10493813f, 0.05206075f, -0.02200565f, -0.02066512f, -0.01921182f, 0.03646313f, -0.10704221f, -0.01314968f, 
    0.04594955f, 0.15854828f, -0.13417022f, -0.04067085f, 0.08564886f, -0.15542862f, -0.02939327f, 0.15827754f, 
    0.06283614f, -0.10535171f, -0.00191904f, 0.02454807f, 0.05916491f, 0.02623037f, 0.14672126f, 0.10274942f, 
    0.09197418f, 0.05813460f, 0.00529466f, -0.01859498f, -0.12949081f, 0.12812907f, -0.11572665f, -0.10983656f, 
    -0.20667876f, -0.11641271f, -0.01777632f, 0.09046882f, 0.01235446f, -0.09841384f, -0.11478963f, -0.08610202f, 
    0.04759412f, 0.01076148f, 0.07850202f, -0.05073716f, -0.06514074f, 0.01994487f, 0.04744403f, 0.19189876f, 
    0.04115407f, 0.03954046f, -0.10714387f, -0.35338047f, 0.18269821f, 0.03071385f, 0.10325961f, 0.09286748f, 
    -0.01071420f, 0.20415720f, -0.04538988f, 0.13647741f, -0.03173435f, 0.05486175f, -0.08390874f, 0.07177799f, 
    0.01396389f, -0.00392776f, -0.03115165f, 0.04941129f, -0.02176442f, -0.13610803f, -0.05750469f, 0.04414506f, 
    -0.07935251f, 0.35806772f, 0.09068608f, -0.02723821f, -0.08645946f, 0.00056242f, -0.04162041f, -0.03061254f, 
    0.01209635f, -0.08894395f, 0.17423861f, 0.05362044f, -0.08130451f, 0.08636216f, 0.04071156f, -0.11002154f, 
    0.06635085f, -0.02231536f, -0.13691582f, -0.01048504f, 0.01360226f, 0.01805323f, 0.08284786f, 0.14111601f, 
    0.08485755f, 0.01302452f, 0.13113870f, 0.35565484f, -0.03408275f, 0.06978708f, -0.00213761f, -0.02524773f, 
    0.11848376f, -0.06020811f, 0.07425181f, -0.08211200f, 0.02841044f, 0.05224919f, 0.08718979f, -0.11997820f, 
    0.00471309f, 0.12803803f, -0.00045270f, 0.02344576f, -0.04955717f, -0.05020588f, 0.05336108f, -0.11377356f, 
    0.31012344f, -0.19485071f, 0.07136361f, 0.18846759f, 0.02026814f, 0.04271892f, 0.05021117f, 0.13040003f, 
    0.14803284f, -0.01449708f, 0.00865121f, -0.12693748f, -0.12672511f, -0.03633921f, 0.18790191f, 0.28244042f, 
    0.06996173f, 0.06745813f, 0.01421558f, 0.05342216f, 0.10851729f, -0.03048406f, -0.02082349f, 0.04690141f, 
    -0.06109025f, -0.03882645f, 0.01362360f, 0.00727392f, 0.07860439f, 0.04078623f, 0.13973916f, -0.10601617f, 
    0.02399387f, 0.00889054f, -0.07800679f, 0.05233658f, -0.02363028f, 0.08588046f, -0.14558950f, 0.14874801f, 
    -0.02033088f, 0.01350440f, -0.03035453f, 0.14079952f, -0.00583731f, 0.02166428f, 0.09959185f, -0.17868216f, 
    -0.03123352f, -0.01279256f, 0.11736274f, -0.06666873f, 0.05519892f, 0.07627863f, 0.20798317f, 0.01439131f, 
    0.00690025f, -0.04834322f, -0.08831026f, 0.05226027f, 0.06600796f, 0.08149011f, -0.13443059f, -0.13804224f, 
    0.03699953f, 0.01114763f, 0.06184580f, -0.06134832f, 0.07069451f, 0.07859519f, 0.11807619f, -0.00650862f, 
    -0.04968603f, 0.22460660f, 0.05083402f, 0.00353308f, -0.00989661f, -0.02705052f, -0.09995846f, -0.03102517f, 
    -0.04654810f, 0.06352687f, -0.05376275f, 0.07763398f, 0.05141143f, 0.27245408f, -0.05764274f, -0.00966979f, 
    0.07298176f, -0.00642170f, 0.09252843f, 0.07572195f, 0.05879022f, -0.09692529f, 0.04874296f, -0.07539839f, 
    -0.09223512f, 0.14134759f, 0.13881153f, -0.02569197f, 0.02231698f, 0.03408251f, 0.03028726f, -0.07305771f, 
    -0.03881118f, -0.09240679f, -0.03265091f, 0.05284983f, -0.10216674f, -0.09063416f, 0.07236417f, -0.04592206f, 
    -0.04486325f, -0.00050496f, 0.04810879f, 0.02979858f, 0.06946417f, 0.14298278f, 0.25246835f, 0.17482808f, 
    0.20689100f, -0.10213848f, -0.13546783f, -0.03871109f, 0.16721974f, -0.11313778f, -0.03559883f, -0.14515340f, 
    -0.05407865f, 0.13907231f, 0.00341726f, -0.00820711f, -0.31994468f, 0.22368282f, -0.01912799f, -0.12489129f, 
    -0.00222285f, 0.04483599f, 0.02325724f, -0.03368730f, -0.04234871f, 0.06592901f, -0.00817502f, 0.22595188f, 
    -0.08333564f, -0.12998478f, 0.01198888f, 0.29213071f, 0.08907259f, 0.02320243f, -0.06428392f, -0.00677735f, 
    0.09141660f, -0.05217259f, 0.02238725f, -0.16888273f, 0.04195843f, 0.01254981f, 0.07846525f, 0.04296932f, 
    -0.09002139f, -0.09752019f, 0.13286926f, 0.01059741f, 0.08286159f, 0.02753306f, 0.02820346f, -0.17429347f, 
    0.13389522f, 0.15618274f, 0.05078026f, -0.13213880f, 0.06537189f, -0.05708561f, 0.02267010f, 0.02653664f, 
    0.05060925f, 0.12845580f, 0.06186060f, 0.07796392f, -0.29077852f, 0.01951899f, -0.12048461f, -0.09535227f, 
    -0.04357364f, 0.04140342f, 0.17623959f, 0.08136232f, 0.03973170f, -0.08116309f, 0.03286403f, -0.15503556f, 
    -0.03807083f, 0.19410823f, 0.03478005f, 0.11364695f, 0.09537444f, -0.00853691f, -0.01414578f, 0.00938377f, 
    0.01391663f, 0.07239988f, 0.06770934f, -0.05753605f, -0.04789009f, -0.22593258f, -0.05132598f, 0.28470665f, 
    0.03057303f, -0.04086109f, 0.04111573f, 0.05752161f, 0.06137336f, 0.02752666f, 0.04146019f, 0.15477757f, 
    -0.20275950f, 0.04338148f, 0.08646496f, -0.05164696f, 0.05702373f, 0.01072863f, 0.06471239f, 0.03232222f, 
    -0.06796529f, -0.00875437f, -0.02849806f, -0.07360962f, -0.25366247f, 0.04430283f, 0.00252974f, 0.02504920f, 
    0.04688067f, -0.10195144f, -0.04445070f, 0.01914911f, -0.00158743f, -0.09189353f, -0.07409320f, 0.08219811f, 
    -0.18527348f, 0.07148758f, -0.00248955f, 0.03979739f, 0.02203803f, -0.01619629f, 0.02207506f, -0.01635121f, 
    0.02591988f, 0.00182590f, -0.05468538f, -0.06905856f, 0.28027135f, -0.25518641f, -0.09966305f, -0.08599342f, 
    -0.03078697f, -0.02181163f, -0.00214369f, 0.01941064f, 0.01365123f, 0.14622080f, 0.06757109f, 0.01873068f, 
    0.07413385f, -0.17718513f, -0.04934696f, -0.10112553f, 0.00585693f, -0.02568819f, -0.09398799f, 0.00047737f, 
    0.06627971f, 0.04874253f, -0.07792439f, 0.03996420f, 0.53911072f, 0.00380870f, -0.00777540f, 0.07581279f, 
    -0.15766405f, 0.04462346f, -0.12024972f, -0.06995433f, -0.08374713f, -0.00178281f, -0.04226932f, -0.21824153f, 
    0.02520845f, 0.02478654f, 0.07223644f, 0.30437362f, 0.00661662f, 0.04263958f, 0.03934794f, 0.07773747f, 
    0.18051185f, 0.03254645f, -0.05054024f, 0.16887860f, -0.12891974f, -0.11165401f, -0.03464832f, 0.01141473f, 
    0.06591546f, 0.06102774f, -0.00501231f, -0.00925434f, 0.06113379f, -0.12566537f, 0.13245405f, -0.05332358f, 
    0.31687096f, -0.13875279f, -0.00919742f, -0.10877369f, 0.06489737f, 0.09405655f, -0.10389358f, 0.00427702f, 
    -0.07743178f, -0.01487597f, -0.12997234f, 0.08771907f, -0.12047578f, -0.01940493f, 0.06222847f, 0.25005049f, 
    0.05052022f, 0.05700131f, -0.12195449f, 0.02472872f, -0.06532092f, 0.11192610f, 0.05636441f, -0.07962321f, 
    0.14130551f, 0.18316112f, 0.01398404f, 0.23050323f, 0.06026266f, -0.00335148f, 0.04038023f, 0.09884237f, 
    0.00280222f, -0.02012215f, 0.03803992f, -0.09133556f, -0.08714756f, 0.11614466f, 0.11174971f, 0.03411109f, 
    -0.03365812f, -0.11633485f, 0.10838806f, 0.09611294f, -0.15142229f, 0.11680130f, 0.12600076f, 0.04841045f, 
    -0.19100562f, 0.03328363f, 0.07038432f, 0.09782538f, -0.04686902f, 0.01265869f, -0.01130437f, 0.07990128f, 
    -0.00533762f, 0.01346542f, -0.02901473f, -0.00185837f, 0.18152004f, -0.02417842f, 0.06845341f, -0.06106465f, 
    -0.08061792f, -0.00042960f, 0.01693062f, 0.03369506f, 0.00199520f, 0.09668060f, 0.01598319f, 0.18462273f, 
    -0.18437211f, 0.17616750f, -0.04792843f, 0.15155636f, 0.02284325f, -0.05557497f, 0.02073898f, -0.01243168f, 
    0.01543047f, -0.00355604f, -0.12511490f, 0.02921714f, 0.00639700f, -0.14573482f, 0.24659383f, 0.36783487f, 
    0.00216594f, 0.06170118f, 0.04464107f, -0.00588954f, 0.16126807f, -0.06981757f, 0.00445331f, 0.25602046f, 
    -0.27706277f, 0.03750452f, 0.02721616f, 0.14882091f, 0.03675316f, 0.05345080f, -0.09494301f, 0.05947435f, 
    0.23967111f, -0.00826129f, 0.16542597f, 0.06976540f, 0.39297470f, 0.02275476f, -0.04009320f, -0.16584392f, 
    -0.00088085f, 0.01538952f, 0.04469069f, 0.01390097f, -0.00696108f, 0.03287784f, 0.02261775f, -0.13605696f, 
    -0.04617539f, 0.02018234f, 0.03617045f, 0.06577823f, -0.04521365f, -0.05028901f, 0.07898310f, 0.00708765f, 
    0.02717994f, -0.06115552f, -0.06640176f, 0.01066327f, -0.00623284f, 0.20481943f, -0.09869345f, -0.02802778f, 
    0.00745318f, 0.00005351f, 0.06261203f, -0.01421263f, 0.13793710f, -0.01472370f, -0.08655873f, -0.10576764f, 
    -0.15192766f, -0.10083537f, -0.16533034f, -0.08870240f, -0.06099682f, -0.03080530f, -0.01204728f, 0.05968043f, 
    -0.10358591f, -0.00799364f, -0.00039370f, -0.01096974f, 0.61375606f, -0.22435187f, -0.13907436f, -0.04629357f, 
    -0.00396514f, 0.02377837f, -0.00538908f, -0.07200778f, -0.06946469f, 0.06957167f, -0.31482160f, -0.00137027f, 
    0.12886681f, 0.04825363f, 0.11433186f, 0.15170528f, -0.03096199f, -0.04277260f, 0.02534014f, 0.08327893f, 
    0.02424641f, -0.03057690f, 0.00759321f, 0.05626594f, -0.49710000f, 0.00152613f, -0.04572854f, 0.05370576f, 
    0.05111178f, -0.03103587f, -0.06659603f, -0.01812883f, 0.06465226f, -0.02396638f, -0.05041658f, -0.04831839f, 
    -0.00046762f, 0.00146630f, -0.00968582f, 0.13520218f, -0.00788264f, -0.01462576f, 0.01287643f, 0.05558473f, 
    -0.16521436f, 0.10195264f, -0.13240230f, -0.01986112f, 0.05505614f, 0.12961490f, -0.04457536f, 0.24371129f, 
    -0.05705409f, -0.03531286f, 0.09079964f, -0.00424765f, -0.08337802f, -0.03177226f, 0.11050385f, -0.04686500f, 
    0.01732219f, -0.18124954f, -0.04361743f, 0.11395860f, -0.01818893f, 0.00886260f, 0.04191664f, -0.13266338f, 
    -0.00961028f, -0.11255724f, 0.08989952f, 0.06301366f, -0.06053930f, -0.12709758f, -0.08399458f, -0.17583480f, 
    0.04738990f, -0.01457726f, -0.06822246f, 0.09355278f, 0.01846399f, -0.00700830f, 0.00960780f, -0.02462310f, 
    -0.12697361f, 0.09831987f, -0.04541478f, -0.09306747f, -0.01012669f, 0.09192789f, -0.06869173f, 0.03340974f, 
    0.05556386f, -0.01782328f, 0.07158644f, -0.12399334f, 0.22359231f, -0.12697989f, -0.10467640f, 0.10710755f, 
    -0.02397289f, -0.02520817f, 0.11577940f, -0.03928294f, -0.05318734f, -0.08035979f, -0.11421084f, -0.08133169f, 
    -0.44344562f, 0.01008131f, -0.04667616f, 0.07078040f, -0.02602868f, -0.02031541f, -0.03583188f, 0.01976241f, 
    0.14365636f, 0.11432663f, 0.00478562f, 0.19195180f, 0.12572600f, 0.16187938f, 0.17957854f, -0.08339430f, 
    0.00358048f, -0.02674486f, 0.02561885f, 0.03438549f, 0.05497187f, 0.16021994f, 0.01767851f, -0.05795112f, 
    -0.28291932f, -0.08589079f, 0.07851829f, -0.00125824f, 0.02441912f, 0.06655817f, 0.09609867f, 0.09301414f, 
    0.05487984f, -0.04681589f, -0.00289354f, -0.08495929f, 0.04447327f, 0.15833846f, 0.06486169f, 0.11905686f, 
    -0.02699194f, -0.01990131f, 0.00552920f, 0.01095292f, -0.00026732f, 0.03726232f, -0.23523882f, 0.11882186f, 
    0.00529312f, -0.02854632f, -0.00032310f, 0.01838562f, 0.01740381f, -0.03254183f, 0.01872738f, 0.02586418f, 
    0.02350894f, -0.03606934f, -0.03456775f, -0.02057783f, -0.01541357f, -0.03189524f, 0.00528041f, -0.00658995f, 
    0.03228963f, -0.03686005f, -0.00902646f, -0.00650041f, -0.00462080f, 0.01056332f, -0.02535915f, 0.02237029f, 
    -0.01332211f, 0.02141217f, -0.03642260f, -0.01697842f, -0.02424131f, -0.02534237f, 0.02135560f, 0.01418682f, 
    0.02256249f, -0.00226646f, -0.02263549f, 0.00659060f, -0.00329825f, -0.03232447f, -0.01914318f, -0.00403463f, 
    0.00624801f, 0.02789908f, -0.01216920f, -0.02714010f, 0.01358004f, 0.02767411f, 0.02366742f, 0.01383584f, 
    0.01861282f, 0.02341354f, -0.02903119f, 0.01375934f, -0.00544753f, 0.00225837f, -0.04049832f, -0.00766470f, 
    0.02441015f, -0.01885016f, -0.00353626f, -0.00711837f, -0.01236738f, -0.01503784f, -0.03880295f, 0.02639867f, 
    0.02683201f, 0.01804465f, -0.02001243f, 0.00117562f, 0.02152362f, -0.00851005f, 0.02702268f, 0.00390505f, 
    -0.03546336f, -0.02071612f, 0.00678251f, 0.02902339f, -0.00704201f, 0.02632681f, 0.02721423f, -0.00365590f, 
    -0.00285210f, 0.02245177f, 0.02154631f, -0.02561456f, 0.01134682f, 0.00812379f, -0.00405351f, -0.00680876f, 
    -0.02327392f, -0.04135795f, 0.03347825f, 0.01058500f, 0.02767195f, 0.00525194f, 0.02536754f, -0.01966967f, 
    -0.03194416f, -0.03539747f, -0.02816782f, -0.04137225f, -0.00189474f, -0.02737631f, 0.01079572f, -0.00153431f, 
    0.00534791f, -0.01525383f, 0.02406001f, 0.02752062f, 0.02922181f, 0.00200256f, -0.00879968f, -0.03552568f, 
    0.00990444f, -0.03633570f, 0.00411755f, -0.04010858f, -0.03848435f, 0.02173462f, -0.03845330f, -0.01104335f, 
    0.00098744f, -0.02649909f, 0.02372818f, -0.03240946f, -0.00184864f, -0.01240878f, 0.00574429f, -0.00581635f, 
    -0.02642810f, 0.02554721f, -0.00621941f, 0.02635925f, -0.00431160f, 0.00594115f, 0.02053455f, -0.01679339f, 
    -0.02028363f, 0.01436942f, -0.03001358f, -0.02889645f, 0.02579946f, -0.00041680f, -0.02652200f, 0.03333328f, 
    -0.00086602f, -0.00722785f, -0.00118357f, -0.02052354f, -0.03753569f, -0.02285383f, -0.01409292f, 0.00391361f, 
    -0.00444267f, 0.00930903f, -0.03675692f, -0.02715327f, -0.03190122f, -0.03799304f, 0.02569506f, -0.03095944f, 
    0.00851714f, -0.00022879f, 0.02246064f, -0.00638538f, -0.00922454f, 0.02799002f, 0.00384062f, 0.01084024f, 
    0.01037780f, 0.00112587f, -0.03676929f, -0.01832600f, -0.00450308f, -0.03307323f, 0.02499449f, -0.02338457f, 
    0.00222770f, -0.01720703f, -0.01729552f, -0.03683704f, -0.01031535f, -0.03057449f, 0.01781763f, 0.02947932f, 
    -0.02199468f, -0.03603273f, 0.00873667f, -0.02575224f, 0.00336625f, -0.03387453f, 0.03683013f, -0.00229432f, 
    -0.00671632f, 0.00520447f, 0.01810792f, -0.03604931f, 0.00347055f, 0.01672855f, -0.02556375f, 0.01265880f, 
    -0.01000573f, -0.02307007f, -0.00737574f, -0.03067633f, -0.02838947f, -0.02635956f, -0.02170676f, -0.01929662f, 
    -0.02567296f, -0.00636204f, 0.01905156f, 0.00312553f, -0.01180524f, 0.03103636f, -0.03544266f, -0.00575318f, 
    0.02178088f, 0.02010447f, 0.00134690f, -0.01250484f, -0.02898482f, 0.00863992f, 0.02749109f, 0.03078062f, 
    0.00260023f, -0.03632472f, -0.00740584f, 0.02167401f, 0.02851659f, 0.03058759f, 0.02441694f, 0.01509919f, 
    -0.02046043f, 0.00441407f, 0.01795564f, 0.00751280f, 0.02613920f, -0.03633079f, -0.01255051f, -0.03079902f, 
    0.01286844f, 0.00104708f, -0.03713517f, -0.03225670f, 0.02102268f, -0.00470588f, -0.00199263f, 0.03015676f, 
    0.00836244f, -0.02457101f, 0.02225261f, 0.02121961f, 0.01009295f, 0.02863610f, -0.00559652f, -0.00245873f, 
    0.01242009f, -0.03151169f, 0.01058047f, 0.00662989f, 0.02132940f, -0.02811585f, 0.02255792f, -0.03603176f, 
    0.00194407f, -0.04096375f, 0.00212812f, -0.01756516f, -0.02083908f, -0.01710712f, 0.01855890f, -0.03439864f, 
    0.01143220f, 0.02278661f, -0.02588136f, -0.02835451f, 0.00091898f, 0.02593380f, -0.00123526f, 0.00731476f, 
    0.03199900f, -0.01325580f, 0.02451244f, -0.01436737f, 0.00123476f, -0.03760024f, 0.00937179f, 0.01506343f, 
    0.01832485f, -0.01462685f, -0.01970592f, 0.03630567f, 0.02955850f, 0.01271781f, -0.02231872f, 0.01718922f, 
    0.01986476f, 0.02915023f, -0.01854748f, -0.02512004f, -0.03554016f, 0.00702517f, 0.02005423f, -0.00392588f, 
    0.03112374f, 0.02119009f, -0.01400997f, -0.01493246f, -0.02968845f, 0.00346043f, 0.02606386f, 0.03112635f, 
    0.00089351f, -0.01784408f, 0.02845646f, 0.02510193f, 0.00541496f, -0.02122186f, -0.00394301f, -0.00997371f, 
    -0.00712491f, 0.01259184f, 0.01070758f, -0.03348627f, -0.01115914f, 0.03346537f, 0.01922971f, -0.03610723f, 
    0.00744962f, -0.00958792f, 0.02855453f, 0.00886412f, -0.01087447f, 0.00925938f, -0.03206423f, -0.00974011f, 
    -0.00675881f, -0.01809013f, -0.02986294f, -0.01389403f, -0.00315598f, -0.03533185f, -0.00542954f, 0.01361405f, 
    -0.01077913f, -0.00606122f, -0.02547839f, -0.00267566f, 0.02205036f, -0.00852631f, -0.03089578f, -0.01448664f, 
    0.02279340f, -0.01729142f, 0.01304189f, -0.00527740f, -0.01178333f, 0.01166759f, -0.01335339f, -0.01115522f, 
    0.00273666f, -0.00160800f, 0.02102141f, -0.03317921f, 0.00971710f, 0.01580018f, 0.01665693f, -0.02602175f, 
    0.01584110f, -0.01173441f, 0.02502521f, -0.02159679f, 0.00201208f, 0.02698407f, -0.02322169f, -0.03589043f, 
    -0.00243970f, -0.03764353f, 0.03705432f, 0.01846881f, -0.02653224f, -0.01292242f, -0.03446867f, 0.00676334f, 
    -0.01568444f, 0.02494326f, -0.03584911f, 0.02674841f, 0.01412940f, 0.00741096f, -0.00949103f, 0.01866260f, 
    0.01425747f, 0.00066589f, 0.00093619f, 0.01065775f, -0.02972655f, -0.02569889f, -0.01857366f, 0.03323087f, 
    -0.03290693f, -0.02937618f, -0.03633316f, 0.02183025f, -0.02750384f, 0.00057493f, -0.03420146f, 0.00274868f, 
    -0.04487789f, -0.02965097f, -0.00844898f, 0.00234967f, -0.01338014f, -0.02062774f, 0.00124781f, -0.01626761f, 
    -0.00727982f, 0.02593031f, 0.00601152f, 0.01488212f, -0.03145353f, -0.00162878f, -0.03959785f, -0.01437902f, 
    -0.00711071f, 0.02054900f, -0.00747175f, -0.03478675f, -0.01459130f, -0.02508084f, 0.02072954f, -0.00110352f, 
    -0.00500120f, -0.01374859f, -0.01180904f, -0.01847317f, 0.01381454f, 0.00192160f, -0.01929590f, 0.02671164f, 
    -0.00130220f, 0.00144489f, -0.03005819f, 0.02009368f, -0.01117107f, 0.01350559f, -0.00173341f, 0.02657004f, 
    -0.02846757f, 0.02664653f, -0.02389680f, 0.00259444f, 0.02454677f, -0.02913583f, 0.00402894f, 0.03034178f, 
    -0.03577276f, 0.00782117f, 0.00724592f, -0.00728317f, 0.00638917f, 0.00903944f, -0.03735454f, 0.02985485f, 
    -0.03514424f, 0.02857591f, -0.01714433f, 0.01549519f, 0.00050663f, 0.03371622f, 0.01379971f, -0.02334352f, 
    0.03453428f, -0.01787471f, -0.02391693f, 0.01741520f, -0.03083110f, -0.01150558f, -0.00260221f, -0.00350592f, 
    -0.03342716f, -0.03418274f, -0.01832978f, 0.01583967f, -0.00641945f, -0.02838938f, 0.01685328f, -0.01841332f, 
    0.03133528f, 0.02707004f, -0.00999873f, -0.01776395f, 0.03441451f, -0.00427579f, -0.01646928f, -0.03499076f, 
    -0.03731715f, -0.02573217f, -0.02382720f, -0.02581089f, -0.00888233f, -0.01943012f, -0.01382666f, -0.03691828f, 
    0.01737245f, -0.03323375f, 0.02487335f, 0.00022183f, -0.01808387f, -0.01293737f, 0.00987241f, -0.00717651f, 
    -0.00352134f, -0.01943274f, -0.00986009f, 0.01186397f, 0.02082059f, -0.02947293f, -0.00655551f, 0.00714948f, 
    -0.02158709f, -0.00766342f, -0.01421881f, -0.03916613f, 0.01453597f, 0.02059916f, 0.00026671f, 0.00492509f, 
    0.03121721f, -0.02948777f, -0.01721002f, -0.00551048f, -0.00579732f, -0.01355525f, -0.02455244f, -0.01638294f, 
    -0.01183551f, 0.00948002f, 0.01446383f, 0.00426608f, 0.01657571f, -0.00665999f, -0.03778702f, -0.02940615f, 
    0.02644436f, 0.00801993f, -0.02416256f, -0.02554737f, -0.02830108f, -0.01131990f, 0.00968458f, -0.02434465f, 
    -0.01404474f, 0.02472541f, -0.01368969f, -0.00735840f, -0.00851936f, 0.02095453f, -0.00929155f, 0.01980963f, 
    -0.02883742f, -0.03877829f, 0.01810634f, -0.03684149f, 0.03343200f, -0.01633708f, -0.02739411f, -0.03240948f, 
    0.02690802f, -0.01481647f, 0.00858978f, -0.01944546f, -0.03732020f, 0.01199795f, -0.02119960f, -0.02670996f, 
    -0.02351373f, -0.01033422f, -0.02694005f, 0.01946922f, -0.01532045f, 0.00461064f, -0.03297928f, -0.01132761f, 
    0.00428337f, 0.01163538f, -0.02428228f, 0.00778959f, -0.01559381f, 0.03031357f, -0.03204667f, 0.01259749f, 
    -0.02835064f, 0.02167221f, -0.02424900f, -0.03420665f, 0.03166242f, 0.00050483f, -0.01628680f, -0.02540284f, 
    0.00183419f, -0.01049368f, -0.03162926f, -0.02341339f, -0.03494656f, 0.01721266f, -0.02419837f, 0.02655579f, 
    0.00895946f, 0.00435236f, 0.02412122f, -0.00885403f, -0.03606330f, -0.01329582f, -0.01945677f, 0.00536190f, 
    0.00437692f, 0.00283153f, -0.03160125f, -0.02271794f, -0.02622228f, 0.02646721f, 0.03145994f, -0.04053228f, 
    0.00807727f, -0.00369189f, -0.01799192f, 0.00009148f, -0.03447941f, -0.03837806f, -0.03994140f, -0.02069751f, 
    -0.00265562f, -0.03704571f, -0.00980852f, -0.02925645f, -0.02036364f, 0.01142891f, -0.00115797f, -0.00414798f, 
    -0.03075334f, 0.00509510f, 0.03012711f, -0.02310185f, -0.00998602f, -0.03013577f, 0.01065107f, 0.01132339f, 
    0.00427467f, 0.02025707f, 0.00806161f, -0.02754052f, 0.01097363f, -0.02808146f, 0.01346682f, 0.00663404f, 
    0.01547414f, -0.02913285f, -0.02255489f, 0.00811171f, 0.00938216f, -0.03966582f, -0.02982183f, 0.02329685f, 
    0.01531590f, 0.01870190f, 0.00235516f, 0.02323429f, 0.00261451f, -0.02882398f, 0.01548157f, 0.01383421f, 
    0.01236362f, 0.00982127f, 0.00719634f, 0.02843551f, -0.00513172f, 0.03243223f, 0.02858188f, 0.01644735f, 
    0.00777993f, -0.00139431f, 0.00132841f, 0.00426929f, -0.01714061f, -0.00781113f, 0.01896406f, -0.03921876f, 
    0.00660483f, -0.03603273f, 0.01502936f, -0.01807166f, -0.02283327f, 0.00295601f, -0.00674901f, -0.02544439f, 
    -0.01741932f, 0.00202476f, 0.02126455f, -0.01533703f, 0.02445168f, -0.00981811f, -0.00365028f, -0.03271418f, 
    -0.01856987f, 0.02910085f, -0.00480613f, -0.00012484f, -0.01018558f, 0.01329833f, 0.01380868f, -0.04221929f, 
    -0.00307271f, -0.02538326f, -0.01040106f, 0.00520988f, -0.00260032f, -0.00130144f, -0.01812222f, -0.01826323f, 
    -0.01934007f, 0.00817830f, -0.00646976f, 0.02474818f, -0.01216040f, 0.00734886f, -0.04351309f, 0.01529509f, 
    -0.03006846f, -0.03266653f, -0.02571991f, 0.00959590f, -0.02833103f, 0.00765644f, -0.02713626f, -0.01535155f, 
    -0.01125654f, 0.00278713f, 0.02830153f, 0.01055668f, -0.01035244f, 0.00555825f, 0.00956251f, 0.03185593f, 
    0.00503554f, -0.02942798f, 0.00014403f, 0.02946618f, -0.02752752f, 0.03152739f, 0.01725574f, -0.02343083f, 
    -0.03415088f, -0.00278776f, -0.02341782f, -0.01091528f, -0.02142090f, -0.01778856f, -0.01509251f, -0.00904246f, 
    -0.03206803f, 0.02755781f, 0.01033735f, -0.02335591f, -0.03542249f, -0.02096961f, -0.02676846f, 0.01978772f, 
    -0.02141289f, 0.11790024f, -0.14259459f, -0.18981610f, 0.06844289f, -0.03440236f, 0.04048902f, 0.07726165f, 
    0.01597601f, -0.03164142f, -0.03526656f, 0.05693139f, 0.00251104f, -0.09778580f, -0.17284524f, 0.01087742f, 
    -0.03381656f, -0.11462978f, -0.12701175f, 0.06737809f, 0.01538665f, -0.00177700f, -0.02255290f, -0.22657315f, 
    -0.18428276f, 0.10056939f, 0.22413149f, -0.02167304f, -0.05852693f, 0.06471940f, -0.03917976f, 0.00874544f, 
    0.11867822f, -0.13566366f, 0.13903695f, 0.07587955f, 0.09592672f, -0.13682050f, -0.02852334f, 0.15219015f, 
    -0.01448308f, -0.06119021f, 0.04295601f, -0.00922740f, 0.07827649f, -0.04151739f, 0.01034864f, -0.00235275f, 
    -0.25748655f, 0.01913019f, -0.08145787f, 0.15017433f, 0.00839581f, -0.01164931f, 0.16050290f, -0.00643607f, 
    -0.00235280f, -0.03955661f, 0.08037335f, 0.01213160f, -0.31930408f, -0.10352926f, 0.04374937f, -0.12967673f, 
    -0.05495894f, -0.03558571f, 0.05378864f, 0.00239513f, 0.16115464f, 0.09127454f, 0.00948270f, 0.04067494f, 
    0.26827258f, -0.02329229f, -0.11077429f, -0.15879148f, -0.04795881f, -0.03133528f, -0.16328126f, -0.04331443f, 
    -0.02722700f, 0.01465952f, 0.04935782f, 0.07973585f, 0.22833535f, 0.07983880f, -0.00185972f, 0.08121518f, 
    0.02628260f, -0.02666254f, -0.01665409f, 0.07073721f, -0.01628013f, -0.05493710f, -0.07656432f, 0.08813976f, 
    0.46691269f, 0.33158961f, 0.12545189f, -0.05956360f, -0.13151693f, 0.00985697f, 0.12866530f, 0.11529239f, 
    -0.23579472f, 0.03350580f, -0.07786682f, 0.04158385f, -0.11761945f, 0.08813532f, 0.03851171f, 0.01794052f, 
    0.01165844f, -0.00302562f, 0.08907008f, 0.01227451f, 0.09713844f, -0.00388851f, -0.04661401f, 0.05005328f, 
    -0.07536958f, 0.04614152f, 0.18188213f, 0.05506309f, 0.04971886f, 0.08559462f, -0.10628165f, -0.04740334f, 
    0.09121844f, -0.03142750f, -0.07628208f, 0.00853403f, 0.04878132f, -0.03977062f, -0.07898614f, -0.16953069f, 
    0.01547230f, 0.01312047f, 0.05781315f, -0.05362485f, 0.04900527f, 0.03896051f, -0.09047562f, 0.06862190f, 
    0.30549252f, 0.04526817f, -0.00006592f, 0.23465647f, 0.01478758f, 0.01669251f, 0.09147732f, -0.14887752f, 
    -0.08369569f, -0.07067112f, 0.09072481f, 0.23201771f, -0.13714190f, 0.08910221f, 0.03423210f, -0.09134513f, 
    0.10564756f, 0.06681319f, -0.04902589f, -0.12800165f, 0.09913156f, 0.05944480f, -0.00390152f, -0.01509000f, 
    0.20907544f, -0.04466408f, 0.06698644f, -0.00199251f, -0.05910689f, 0.13011397f, -0.15324986f, 0.10961054f, 
    -0.03287206f, 0.13166460f, 0.04676333f, -0.06296200f, 0.00946726f, 0.02673405f, -0.11257517f, 0.13434592f, 
    -0.01266766f, 0.04870066f, -0.01131773f, 0.02308313f, 0.00105456f, 0.04912382f, 0.08198463f, 0.06161936f, 
    0.08580384f, 0.05342617f, -0.02702280f, -0.16318303f, 0.01589430f, 0.00366970f, -0.04506584f, -0.14605498f, 
    -0.03023544f, 0.04323447f, -0.00916063f, 0.00749798f, -0.23356657f, 0.11148808f, -0.10633249f, -0.18336041f, 
    0.07400412f, -0.02588464f, -0.01295505f, 0.06326018f, -0.09874575f, 0.00271692f, -0.02408936f, -0.07739970f, 
    0.05648317f, -0.00217379f, -0.03614788f, 0.11244381f, -0.08810378f, -0.00617428f, 0.12018932f, 0.17875502f, 
    -0.03579450f, 0.02195351f, 0.01349574f, -0.02290303f, -0.01619201f, -0.07095940f, 0.02429960f, -0.01524126f, 
    0.04446333f, 0.09461945f, -0.00275291f, 0.01930702f, 0.09208771f, -0.00139803f, -0.13070157f, 0.05696367f, 
    0.09093780f, 0.05243317f, -0.14351404f, -0.18265449f, -0.01148209f, -0.08611213f, -0.05793433f, -0.07994592f, 
    0.14300172f, -0.04262979f, 0.02981622f, -0.11999295f, -0.01059913f, -0.04184712f, 0.14077823f, -0.08597972f, 
    0.06458970f, 0.04770072f, 0.03559047f, -0.06742857f, 0.08926754f, 0.05250811f, -0.18548536f, 0.03472786f, 
    -0.09428912f, 0.01189601f, -0.20996679f, -0.08125335f, -0.04579373f, 0.04274876f, -0.04506626f, 0.05955385f, 
    0.10092333f, -0.11987100f, 0.09177538f, -0.11958698f, -0.06363832f, 0.21093753f, -0.17036167f, -0.03230138f, 
    0.04375491f, -0.05856137f, 0.01046794f, 0.02447025f, -0.02189173f, 0.06132394f, 0.03320465f, -0.01277750f, 
    0.09144335f, -0.11921614f, -0.05787686f, 0.14009626f, -0.07177180f, -0.06738599f, 0.04855736f, 0.08851927f, 
    -0.06905638f, 0.05894183f, 0.03548363f, 0.01697933f, -0.12322021f, 0.08524701f, 0.16841087f, -0.14172587f, 
    -0.02866873f, 0.07470306f, -0.13826561f, -0.03355749f, 0.01130153f, 0.12931259f, 0.01317984f, 0.06204943f, 
    -0.04912264f, -0.02598865f, 0.10365529f, -0.08511798f, 0.14870705f, 0.00545122f, 0.03289088f, -0.05722264f, 
    -0.04276925f, -0.01896469f, -0.03905133f, -0.02983148f, 0.51683968f, -0.02703399f, -0.01984194f, -0.11963843f, 
    -0.08277699f, -0.03929200f, -0.03800486f, -0.04953125f, 0.04178793f, -0.04278534f, -0.01856201f, 0.05062039f, 
    0.14794470f, -0.04268032f, -0.12297589f, 0.22799520f, 0.00244667f, 0.00461092f, -0.01707381f, -0.04120525f, 
    0.11818477f, 0.04671439f, 0.03271355f, 0.07027452f, -0.24221909f, -0.01811547f, -0.06151959f, 0.18567285f, 
    0.08651890f, -0.04446771f, -0.14003007f, -0.02594860f, 0.08435618f, 0.04036676f, -0.07637336f, -0.07469412f, 
    -0.12856555f, -0.01472160f, -0.09212496f, -0.17413406f, 0.14721082f, -0.03068624f, -0.00855999f, -0.09827784f, 
    0.10888454f, 0.09981564f, 0.00087286f, 0.06035228f, 0.26078525f, 0.09471743f, -0.14678805f, 0.24596474f, 
    0.05769996f, -0.03753879f, -0.09450766f, -0.05795638f, 0.05274229f, -0.10119748f, 0.00238481f, 0.04832388f, 
    0.19946370f, 0.03969999f, 0.13745992f, -0.05025684f, -0.05758258f, -0.03942598f, 0.07028230f, 0.09343891f, 
    -0.00614132f, -0.10406855f, -0.03979777f, 0.08294814f, -0.28606138f, -0.37464729f, -0.09394530f, 0.13721770f, 
    0.03285612f, -0.05392164f, -0.01627742f, -0.04710799f, 0.01440544f, 0.05838781f, -0.07332016f, 0.06310242f, 
    -0.07667335f, -0.17055860f, -0.04958609f, -0.04834004f, 0.07137466f, -0.02589160f, -0.06606559f, -0.06775948f, 
    0.03395673f, 0.07349060f, -0.07599344f, 0.01919695f, 0.02662307f, 0.00024343f, -0.03328028f, 0.05754516f, 
    -0.08535893f, 0.10741989f, 0.15548950f, 0.02518470f, -0.06367324f, -0.03034472f, 0.04201507f, 0.14320548f, 
    -0.07536916f, 0.11752328f, 0.10203001f, 0.07687819f, 0.02137629f, -0.02367990f, -0.18874733f, 0.00566855f, 
    0.00480881f, 0.00112962f, -0.04745512f, -0.00870127f, -0.28206789f, -0.15627031f, -0.02065380f, -0.02768599f, 
    0.03376766f, -0.01080746f, -0.00784870f, -0.05846724f, -0.07895575f, 0.01175134f, -0.11616181f, 0.09478027f, 
    -0.06902807f, -0.17286703f, -0.12518144f, -0.00453064f, 0.06166894f, 0.04621996f, 0.03656786f, 0.00306355f, 
    -0.05087724f, 0.08365838f, 0.08413015f, -0.05354084f, -0.03952023f, 0.16780353f, 0.16383632f, -0.11850250f, 
    -0.03389521f, 0.01441120f, 0.03808819f, -0.02927537f, 0.03049378f, -0.13058813f, -0.12948152f, 0.00973289f, 
    0.32137010f, 0.07170629f, 0.18615285f, 0.19109906f, -0.00247867f, -0.03253579f, 0.03601179f, 0.14675629f, 
    -0.07716872f, -0.08343957f, -0.06233910f, 0.01208673f, 0.04427885f, 0.27259132f, 0.07766820f, -0.23527656f, 
    0.00408374f, 0.00825482f, 0.04860255f, 0.04591462f, 0.00706726f, -0.01295128f, -0.10970053f, -0.07102770f, 
    0.20425554f, -0.06934051f, 0.20655236f, -0.00600868f, 0.07360022f, -0.05714805f, 0.00622503f, 0.10496883f, 
    0.00886255f, -0.07731406f, -0.06158858f, 0.08401667f, -0.16619101f, 0.08911100f, 0.16452278f, 0.05528627f, 
    -0.01560915f, -0.04603320f, 0.06971175f, -0.01227354f, -0.01938145f, -0.00026904f, 0.03543931f, -0.04141862f, 
    -0.03110762f, 0.05144122f, -0.03626665f, 0.22652027f, 0.03410261f, -0.05345199f, 0.11002828f, 0.02418550f, 
    0.04585440f, 0.07248087f, 0.13999495f, 0.03134533f, -0.05545771f, -0.03670270f, 0.03381268f, -0.07972696f, 
    0.02770026f, -0.02705774f, -0.00012221f, 0.00203581f, 0.06462821f, 0.00524954f, 0.00066609f, -0.02051865f, 
    -0.23508406f, 0.01176908f, 0.14727643f, 0.11352942f, -0.02106791f, 0.04912546f, 0.05202830f, -0.05056984f, 
    -0.05216472f, 0.16927122f, -0.03010313f, 0.03756449f, 0.25437671f, -0.05642768f, 0.03658628f, -0.19376898f, 
    0.11467180f, -0.09659787f, -0.04383789f, 0.03354003f, 0.09238581f, 0.09646232f, 0.05300618f, -0.02407171f, 
    0.25664729f, -0.01884751f, 0.12853146f, 0.00383085f, -0.05263475f, -0.04698487f, 0.00013073f, 0.06557470f, 
    -0.07724406f, -0.06484064f, 0.06197838f, 0.07581587f, -0.03811655f, 0.07548941f, -0.12530489f, -0.09476835f, 
    0.06274029f, -0.02364861f, -0.13697132f, -0.07833812f, -0.02421004f, 0.03047883f, 0.00808367f, 0.02759671f, 
    0.19561921f, 0.05862669f, -0.06155067f, -0.05876883f, 0.00734068f, 0.07548743f, 0.08386978f, -0.05718175f, 
    0.09140516f, -0.02573846f, 0.01841847f, -0.02879561f, 0.40031901f, -0.23331296f, -0.05260586f, 0.02171786f, 
    -0.00168559f, -0.00470535f, 0.09756995f, 0.03004127f, -0.01724092f, 0.12443641f, 0.03368393f, -0.04956355f, 
    -0.10339702f, 0.04122636f, 0.22792880f, -0.17686987f, 0.03859884f, -0.02622544f, 0.05300508f, 0.03765833f, 
    0.04678456f, -0.00074397f, -0.01483236f, 0.09490310f, 0.21559377f, 0.03016472f, -0.24243455f, 0.13488492f, 
    0.00014446f, -0.01183446f, 0.00317121f, 0.00946004f, -0.02690224f, 0.01510597f, 0.02277445f, -0.06367297f, 
    0.00294016f, -0.02974414f, -0.12394257f, 0.12753990f, -0.02109881f, -0.07693487f, -0.04214295f, 0.08946700f, 
    0.10004060f, -0.01471127f, 0.11376954f, 0.02801737f, 0.10356645f, 0.10702055f, 0.21106492f, 0.03306631f, 
    -0.10710757f, 0.01582412f, 0.08977919f, 0.07017955f, 0.00977606f, 0.02672518f, -0.08283084f, 0.10958921f, 
    -0.12532604f, 0.00760357f, -0.06885358f, 0.12763864f, -0.01204501f, 0.01430042f, -0.07468653f, 0.06520996f, 
    0.07638733f, 0.06540807f, -0.11296955f, -0.05530886f, -0.19531469f, 0.04434475f, -0.01776738f, 0.03466168f, 
    -0.01768961f, -0.02174746f, 0.07040055f, -0.05466925f, 0.04988180f, 0.00001466f, -0.03213229f, 0.00840972f, 
    0.17024271f, 0.07471722f, 0.05965945f, -0.11871907f, 0.02180122f, 0.04394338f, 0.01939053f, 0.08827380f, 
    0.04775451f, 0.00519295f, -0.05110320f, 0.02184349f, -0.06026759f, -0.15662543f, -0.06709228f, 0.17071171f, 
    0.06606252f, 0.02783476f, 0.06642829f, 0.02650370f, -0.07533656f, 0.06181355f, 0.00891439f, 0.03202270f, 
    -0.13974953f, -0.01263612f, 0.00597066f, 0.12401041f, -0.05353791f, 0.01531010f, 0.02097916f, 0.02450354f, 
    -0.02210219f, -0.01095014f, -0.13437815f, 0.02657893f, -0.20932594f, 0.17875300f, -0.02632420f, -0.25458822f, 
    -0.00068981f, 0.13388412f, 0.13319133f, 0.05945078f, -0.07544673f, -0.09939763f, 0.03178623f, -0.00223569f, 
    -0.19659592f, -0.05712929f, 0.01098902f, 0.05809056f, 0.06518997f, -0.04242172f, 0.09961895f, -0.01021236f, 
    -0.15904111f, -0.03104256f, 0.01579203f, 0.02993620f, 0.02960489f, 0.16643153f, 0.00372543f, -0.08999377f, 
    0.10423481f, -0.01312903f, 0.01695006f, -0.10231078f, 0.04547844f, -0.01548016f, 0.11408810f, -0.00552140f, 
    -0.02972920f, -0.00355091f, 0.02609591f, -0.01662245f, 0.02484444f, -0.03867664f, 0.03257319f, -0.00647117f, 
    0.01438873f, 0.01322110f, 0.01541952f, 0.02688884f, -0.00372574f, 0.01459709f, 0.01214159f, -0.00697292f, 
    -0.01875427f, -0.04188146f, 0.01488466f, -0.01551506f, -0.03391272f, 0.01594647f, -0.01234384f, 0.01916473f, 
    0.00033384f, 0.02334128f, 0.00200073f, 0.02987848f, -0.02630383f, -0.03324336f, -0.01261258f, -0.01435944f, 
    -0.01625140f, -0.03904643f, 0.01142822f, -0.03009151f, 0.00887954f, 0.02931200f, 0.01141986f, -0.00485264f, 
    0.01689069f, 0.02090987f, 0.00877986f, -0.02294907f, 0.01213164f, 0.00862838f, -0.00572472f, 0.01149616f, 
    -0.01563522f, -0.00956787f, 0.02340354f, 0.01980473f, -0.03509896f, 0.02438480f, 0.02565197f, -0.00360367f, 
    -0.00838094f, -0.00545690f, -0.00191701f, 0.01387894f, -0.01451326f, 0.02153793f, -0.00797468f, 0.01803391f, 
    0.00212552f, -0.03818792f, -0.02486495f, -0.02671819f, -0.00954635f, -0.02869298f, 0.00664879f, -0.00796944f, 
    -0.01635384f, 0.01538984f, -0.04027193f, -0.02013568f, -0.03408742f, 0.02282607f, -0.00391546f, -0.01518624f, 
    0.01070262f, -0.01048445f, -0.01709769f, -0.01190552f, -0.03912101f, -0.02276509f, 0.02918088f, -0.00452344f, 
    0.00492243f, -0.00519981f, -0.01536841f, -0.01502661f, -0.01409105f, -0.04161173f, -0.02788946f, 0.02353736f, 
    0.00674093f, 0.00119420f, -0.02034968f, -0.00121072f, -0.00869526f, 0.01204788f, 0.02361093f, 0.03133885f, 
    0.02414339f, 0.01569644f, -0.02901682f, 0.01077520f, 0.02826767f, -0.03402192f, -0.03296644f, -0.02008789f, 
    0.00869366f, -0.02829849f, -0.00305336f, 0.00648614f, 0.02773299f, -0.01040284f, 0.02458385f, -0.01895343f, 
    -0.02467546f, -0.03185147f, 0.00140703f, -0.03517239f, -0.02018183f, 0.00960727f, -0.00615451f, 0.01083966f, 
    -0.00722201f, -0.01477571f, -0.01551358f, -0.00959205f, -0.02958371f, -0.00247512f, 0.02583767f, 0.01832998f, 
    -0.03904338f, 0.01938452f, -0.01273162f, 0.01947813f, 0.00659145f, 0.00725278f, -0.01123005f, 0.00169589f, 
    -0.02702098f, 0.00010561f, 0.01074197f, -0.02293511f, 0.02634406f, -0.04208624f, -0.02146167f, -0.00816150f, 
    -0.02929651f, 0.01704525f, 0.00404458f, 0.00370775f, -0.03187272f, 0.01313248f, 0.00615263f, 0.00869917f, 
    0.02499367f, 0.02120975f, 0.02442197f, -0.01468575f, -0.01085630f, -0.03718600f, -0.00688052f, 0.01548727f, 
    0.01892835f, 0.00469917f, -0.03185590f, 0.02745654f, 0.00902091f, -0.02028457f, -0.03604959f, -0.00814277f, 
    -0.02385449f, -0.01554278f, 0.02519884f, -0.00423637f, 0.02874544f, -0.01898204f, -0.03899639f, -0.03076831f, 
    -0.01100957f, -0.00187772f, 0.02028090f, 0.02929251f, 0.02948851f, -0.02389104f, -0.01582691f, -0.02936664f, 
    0.00296223f, 0.01570019f, 0.00429405f, 0.01282794f, -0.02413286f, -0.01088552f, 0.01178969f, -0.02129626f, 
    -0.03957180f, -0.03682379f, 0.00860650f, -0.04186786f, 0.01463580f, -0.01129656f, 0.04082623f, -0.04091322f, 
    0.01645981f, -0.03206524f, -0.01917143f, -0.00503332f, -0.00340021f, -0.02381524f, 0.01459126f, 0.01719232f, 
    0.02305114f, 0.01868882f, -0.03734118f, 0.02949582f, -0.04184813f, -0.01294621f, -0.03731271f, 0.02247249f, 
    0.02069850f, -0.00288740f, -0.00212463f, -0.00647101f, 0.01399305f, -0.00785797f, -0.00622783f, -0.01536717f, 
    -0.01239588f, -0.03874048f, -0.00829048f, 0.00098879f, -0.01313548f, 0.01432106f, 0.02712301f, -0.01111351f, 
    0.02969045f, -0.04139514f, -0.01338058f, -0.03570322f, -0.00219181f, -0.01296592f, 0.01958532f, 0.02615395f, 
    -0.01374969f, 0.01872036f, 0.01493825f, -0.00044435f, 0.00134321f, -0.03856450f, 0.01690174f, -0.02013151f, 
    0.01155403f, -0.02459095f, -0.01108049f, -0.03190275f, -0.01101703f, -0.01599240f, -0.00902696f, 0.00515865f, 
    -0.04111430f, -0.01561690f, -0.01538587f, -0.03785864f, -0.02626121f, 0.00951626f, 0.00966342f, -0.00178366f, 
    0.02485794f, -0.04182909f, -0.02369327f, 0.03585200f, -0.01154428f, 0.01538845f, -0.04014259f, 0.01635152f, 
    0.01458482f, -0.02152097f, 0.00289536f, 0.01341728f, -0.01220016f, -0.00813876f, -0.00015593f, 0.00196751f, 
    -0.03388165f, 0.01861791f, 0.01372774f, -0.03367611f, -0.01876521f, -0.03229752f, 0.00877745f, 0.01653551f, 
    -0.01356187f, -0.01305304f, -0.00843564f, -0.00805711f, 0.02022615f, 0.01737001f, 0.03951330f, 0.01519654f, 
    -0.01269007f, -0.00614760f, 0.02019642f, -0.00646970f, -0.01728096f, -0.02085131f, -0.03335176f, 0.01678015f, 
    0.02804206f, 0.01851441f, -0.04055666f, -0.00329171f, -0.00005509f, 0.02673914f, -0.01694813f, 0.01433865f, 
    -0.01078450f, -0.00362957f, -0.02269525f, -0.01593118f, -0.01529828f, -0.00505600f, -0.02332382f, -0.03233185f, 
    -0.02346747f, 0.02021039f, -0.00505530f, -0.01324539f, -0.02600938f, -0.01866238f, -0.03559894f, 0.02673539f, 
    -0.00842561f, -0.00042339f, 0.00836835f, 0.00552216f, -0.01048061f, -0.01405201f, 0.01858185f, 0.00225057f, 
    -0.00623456f, -0.01347281f, -0.00450926f, -0.02866630f, -0.04127324f, -0.02991255f, 0.00761137f, 0.00329575f, 
    0.01221648f, 0.00950398f, 0.03866185f, -0.03470961f, 0.01252239f, -0.01827299f, -0.02402006f, -0.03453660f, 
    -0.01746694f, -0.03261391f, -0.01376189f, 0.02210316f, -0.00020293f, -0.00530128f, 0.00875478f, 0.03570561f, 
    0.01192888f, 0.01099745f, -0.01394289f, 0.00901808f, -0.01713683f, -0.00645285f, -0.00743735f, 0.00916698f, 
    -0.01422649f, -0.02441514f, 0.00140627f, 0.02481502f, -0.04043444f, -0.01909800f, 0.00346684f, 0.02305853f, 
    0.02970853f, -0.03511664f, 0.01676082f, 0.02211124f, 0.00738308f, -0.02287064f, -0.00858457f, 0.00087433f, 
    -0.00812622f, -0.04061371f, 0.01745070f, -0.01975176f, -0.02056619f, -0.00259400f, -0.00276120f, 0.01601682f, 
    -0.03345886f, 0.02488428f, 0.00366436f, 0.00119257f, -0.02787046f, 0.01368507f, 0.00305626f, -0.00749698f, 
    0.02082960f, 0.01701242f, 0.02660244f, 0.01012404f, -0.03393313f, 0.00078015f, -0.02399141f, 0.03667509f, 
    -0.03493963f, -0.00017872f, -0.04066857f, -0.00597662f, -0.02249053f, -0.02464432f, -0.01618938f, -0.03220294f, 
    0.02091496f, -0.02855770f, 0.01607521f, 0.01068474f, -0.03566694f, 0.01942285f, 0.01485989f, -0.02661396f, 
    0.02998073f, -0.02012906f, -0.03617257f, -0.02113735f, 0.02745512f, 0.01384488f, 0.02296569f, 0.02061470f, 
    0.01877808f, -0.00951249f, -0.01087461f, 0.02186909f, 0.00412138f, 0.02278833f, -0.00202821f, -0.03252494f, 
    0.01274410f, 0.02387285f, 0.02452622f, -0.02834732f, 0.00112997f, -0.03919790f, 0.00765413f, 0.02736983f, 
    0.04204272f, 0.01388868f, -0.00061858f, 0.02116379f, -0.01210716f, -0.01274957f, -0.00768232f, -0.01603905f, 
    -0.00503938f, -0.00148503f, -0.02556814f, -0.02174068f, 0.01850729f, -0.04001100f, -0.01138577f, 0.01808963f, 
    0.02610609f, -0.03813471f, 0.01794130f, -0.02535966f, -0.01013201f, 0.01350220f, -0.02065887f, -0.00448478f, 
    -0.01090340f, -0.02005998f, 0.01474250f, -0.03307605f, 0.03251937f, -0.02081447f, -0.02326444f, 0.00114409f, 
    -0.03104490f, -0.04061049f, -0.00638395f, -0.02510748f, -0.01650600f, 0.00068246f, -0.02673969f, -0.00294550f, 
    -0.00508277f, 0.00058588f, 0.01444169f, 0.00642316f, -0.01327121f, 0.01999007f, 0.02176722f, 0.02729167f, 
    0.03433751f, 0.00707075f, 0.00948159f, -0.03149109f, -0.01440512f, 0.02308437f, -0.02319998f, 0.00109065f, 
    -0.01411787f, -0.03965439f, -0.02021895f, -0.02006815f, -0.01884472f, 0.01254853f, 0.00843254f, 0.01723155f, 
    -0.03792100f, 0.02765274f, -0.00733235f, 0.01315704f, 0.00926433f, -0.00992150f, 0.02309567f, -0.01948111f, 
    -0.02234223f, 0.00602330f, 0.00282102f, -0.02369232f, 0.00074971f, 0.00460885f, -0.02092162f, 0.00347852f, 
    0.01108177f, 0.02052704f, -0.02959424f, -0.02776071f, -0.01021499f, 0.02808255f, 0.02174910f, 0.00918708f, 
    0.01476837f, 0.01377400f, -0.02103510f, -0.00947918f, 0.03998869f, -0.03943711f, -0.01359920f, -0.00555604f, 
    -0.01488375f, 0.00983288f, 0.01470333f, 0.00155326f, -0.03820506f, -0.03624571f, -0.01654818f, -0.00285197f, 
    0.02184214f, 0.00788203f, 0.02539014f, -0.02521811f, -0.01976361f, -0.02676194f, -0.03596275f, -0.02832166f, 
    -0.01237274f, -0.01331893f, 0.00685842f, 0.00246146f, 0.00062040f, 0.01915282f, -0.01311014f, 0.02451760f, 
    -0.00642149f, -0.01552555f, 0.00361224f, 0.01832395f, -0.00310029f, 0.01196588f, 0.00789578f, 0.00875881f, 
    -0.03059037f, 0.02041173f, 0.01038454f, -0.03094484f, -0.04027128f, -0.01238256f, -0.01417408f, 0.01062105f, 
    -0.03890615f, 0.02396439f, -0.02628804f, -0.01685396f, 0.00238045f, 0.01996893f, -0.01606098f, -0.01010637f, 
    0.01607907f, -0.00477482f, 0.01362569f, 0.01925418f, -0.01280570f, 0.00671404f, 0.03071332f, 0.02604262f, 
    0.01503245f, 0.02455886f, 0.03005821f, -0.02347333f, 0.02901533f, 0.00578811f, -0.01481980f, -0.02789614f, 
    -0.00731463f, -0.01136772f, -0.01534687f, 0.02595895f, -0.01362856f, -0.01566337f, 0.00105173f, 0.00273229f, 
    0.00646634f, 0.00524673f, -0.01169554f, 0.01133339f, 0.01295766f, -0.02774135f, -0.02651260f, 0.00705690f, 
    -0.01844661f, 0.00500040f, 0.00744178f, 0.02830047f, -0.02384545f, 0.02289314f, 0.02728645f, 0.02592510f, 
    -0.02754371f, 0.02588197f, -0.02193086f, 0.02379472f, 0.00779864f, -0.00027176f, -0.03923622f, -0.00120350f, 
    0.01999846f, -0.01457222f, -0.02501537f, 0.01327490f, -0.01737960f, -0.02517653f, 0.00028811f, -0.03854299f, 
    -0.03747810f, -0.02710212f, -0.04096189f, -0.01495064f, -0.03329013f, -0.03228231f, -0.04094253f, -0.02206916f, 
    -0.01458931f, -0.02700836f, -0.01607379f, -0.02666373f, -0.00416626f, 0.00291287f, -0.00715946f, 0.00820112f, 
    -0.02809469f, -0.01465611f, -0.00515133f, 0.02793867f, 0.00708833f, -0.00672913f, 0.00372780f, -0.02382386f, 
    0.00552341f, -0.00624967f, -0.01173960f, -0.03267233f, -0.01226697f, -0.01982757f, -0.00478413f, 0.00037289f, 
    -0.01220640f, -0.00497661f, -0.00656614f, 0.02642342f, -0.00853860f, -0.03691986f, 0.00348544f, 0.00283626f, 
    0.00739934f, 0.02030581f, 0.01990666f, 0.01041245f, -0.00704673f, -0.03259571f, -0.04004271f, -0.03693847f, 
    -0.01471978f, -0.02851489f, -0.03669029f, 0.01682794f, 0.00290556f, 0.02635409f, 0.00330510f, -0.01459242f, 
    -0.03809974f, -0.02759574f, 0.01192895f, -0.04042619f, 0.00189631f, -0.03132182f, -0.02833298f, -0.01572489f, 
    -0.01754083f, -0.02632674f, -0.01262058f, 0.02122719f, 0.01660126f, 0.00410405f, 0.03796757f, 0.02038437f, 
    -0.00624877f, 0.00074487f, -0.01443159f, 0.01944088f, -0.02888066f, 0.01191943f, -0.01294047f, 0.01931090f, 
    0.02065235f, -0.02214666f, -0.03863293f, -0.01794986f, 0.02325764f, -0.03736495f, -0.00918904f, 0.01022697f, 
    -0.01428502f, -0.00792500f, -0.02833553f, 0.00583461f, 0.00992906f, 0.01049471f, -0.00362496f, -0.01411917f, 
    -0.01071086f, -0.00454707f, -0.00855171f, -0.03782403f, 0.00620394f, -0.02315649f, -0.02923536f, 0.02854563f, 
    -0.01859714f, 0.00764779f, -0.03999869f, 0.02344012f, 0.03070121f, -0.03810581f, -0.00428119f, -0.00347326f, 
    -0.02757931f, 0.02540812f, 0.01722785f, -0.03390058f, 0.00941385f, 0.03110549f, -0.03950404f, -0.00352143f, 
    0.02103445f, 0.02770514f, -0.01456697f, -0.01764416f, -0.01825425f, -0.00903534f, -0.02512691f, -0.03541215f, 
    -0.00611469f, -0.03684379f, -0.00612147f, 0.02806048f, -0.01896550f, -0.00752974f, 0.03121361f, -0.00015473f, 
    -0.00569295f, 0.02099830f, 0.00657984f, 0.00577008f, -0.02400942f, 0.01897307f, -0.03350511f, 0.01774153f, 
    0.02003840f, 0.00210294f, -0.00654310f, -0.00219261f, 0.00333721f, -0.00720434f, 0.01714094f, 0.00549314f, 
    0.02141115f, -0.01221761f, 0.03023772f, 0.02833337f, -0.03555347f, -0.03572898f, -0.01351867f, -0.01847378f, 
    -0.02255439f, -0.03348440f, -0.01427861f, -0.02132544f, 0.02195678f, -0.02889815f, -0.03665319f, 0.00247613f, 
    0.01064128f, 0.01714718f, 0.00011774f, 0.01857404f, 0.00440512f, 0.02784424f, -0.00668975f, -0.04143187f, 
    -0.01369936f, -0.01066759f, 0.02535097f, -0.02550407f, -0.03343161f, -0.00551998f, 0.01868878f, 0.02531693f, 
    0.00816901f, -0.04222843f, 0.02452274f, 0.00487164f, 0.00577288f, 0.02886209f, -0.02628084f, 0.02776765f, 
    0.00491465f, -0.00428411f, -0.03640582f, -0.01565408f, -0.02113443f, -0.03080677f, 0.03421624f, -0.03616348f, 
    0.00814138f, -0.02167112f, 0.00118518f, -0.02585780f, -0.00671825f, -0.00681344f, -0.02170655f, -0.00414144f, 
    -0.04139800f, 0.02199736f, 0.02054882f, -0.03306092f, 0.02391762f, -0.03774500f, -0.00260634f, -0.03873151f, 
    -0.00466377f, -0.02416432f, -0.02906144f, -0.01568011f, 0.02655013f, -0.02491105f, -0.03087016f, 0.00842750f, 
    -0.03273590f, 0.01331681f, -0.00453991f, -0.00225216f, -0.00337077f, -0.02966988f, 0.02554489f, -0.04100693f, 
    -0.01673639f, 0.00454970f, 0.02106905f, 0.03133861f, -0.04060340f, -0.02820911f, 0.02684159f, -0.04210825f, 
    -0.01212204f, -0.00962753f, -0.01306017f, -0.00102905f, -0.00234809f, 0.00565386f, 0.03853717f, -0.01747171f, 
    0.00075663f, 0.02454659f, 0.02364349f, 0.01012210f, -0.01613091f, 0.00347446f, 0.02834827f, -0.03594642f, 
    0.02849371f, 0.01492193f, 0.02136630f, 0.02068712f, 0.02320267f, 0.00259693f, -0.03200051f, 0.01543876f, 
    -0.02607817f, -0.04443542f, 0.02678611f, -0.04043473f, -0.02983975f, -0.02440345f, 0.02227966f, 0.02162456f, 
    -0.03332328f, 0.02018904f, 0.01559498f, 0.01123805f, 0.01272104f, -0.01967832f, -0.04454883f, -0.03825194f, 
    -0.03822784f, 0.03343707f, -0.01943351f, -0.03039832f, 0.02228228f, -0.01615550f, 0.00384605f, -0.02912351f, 
    -0.00710449f, -0.03732681f, -0.00898140f, 0.01390881f, -0.00594627f, -0.01541207f, -0.00285393f, -0.02616104f, 
    -0.00095697f, -0.01961627f, -0.00347678f, -0.03213819f, -0.00488282f, -0.01548805f, -0.03540239f, -0.02051124f, 
    0.02422648f, 0.00493710f, -0.01270362f, -0.00987966f, -0.00290401f, -0.03390392f, -0.00342348f, -0.03575915f, 
    -0.03633272f, -0.00337794f, -0.01603703f, 0.00332730f, -0.01887380f, -0.02131826f, -0.02716977f, 0.02600998f, 
    -0.03247079f, 0.01980056f, -0.00937315f, -0.02221872f, -0.00092096f, -0.01733827f, -0.01472792f, 0.02365469f, 
    0.00950839f, -0.01337553f, 0.02926511f, 0.00050042f, 0.00934195f, 0.00268795f, -0.03221624f, 0.00621322f, 
    -0.01940540f, -0.01527098f, -0.00684089f, 0.01949655f, -0.01263497f, 0.03155826f, -0.04286110f, -0.01176095f, 
    0.00635582f, -0.03399250f, 0.03268084f, 0.00005959f, 0.00299284f, -0.00914251f, -0.00413328f, 0.00713531f, 
    -0.02649030f, -0.01560239f, 0.00270037f, 0.02344978f, -0.01510793f, -0.03078810f, 0.01722664f, 0.00718340f, 
    -0.01525959f, -0.01235188f, -0.00262465f, -0.01935753f, -0.01184233f, 0.02717382f, -0.03731779f, -0.03709436f, 
    0.01146855f, -0.02062282f, -0.01317803f, 0.01211759f, 0.01694123f, 0.00249703f, 0.03210996f, -0.04122293f, 
    0.00875247f, -0.00421323f, -0.01769942f, -0.01629867f, 0.01998373f, -0.03859849f, -0.00143526f, 0.01783425f, 
    0.00786432f, -0.02802009f, 0.02118261f, 0.02154896f, 0.00688095f, -0.01739761f, -0.01176531f, -0.02260116f, 
    -0.03701355f, 0.00658783f, 0.01946878f, -0.04313189f, -0.00001147f, 0.00002207f, 0.01779085f, -0.03406394f, 
    -0.03426125f, 0.02078339f, -0.01087956f, -0.00546567f, 0.00338443f, 0.02695800f, 0.01368620f, 0.02733319f, 
    -0.00369473f, 0.02852177f, -0.00966476f, 0.02010605f, -0.04492216f, 0.01194767f, -0.02105170f, -0.00437722f, 
    0.01452849f, -0.00204590f, 0.01761013f, 0.01027853f, 0.01388744f, 0.01946416f, 0.01589700f, -0.01414902f, 
    0.03317701f, -0.00249057f, 0.02472051f, 0.03218940f, 0.02141052f, -0.02476600f, -0.02213639f, 0.01575877f, 
    -0.00746486f, -0.03013019f, -0.03077128f, -0.01394462f, 0.02115411f, 0.01903385f, -0.01751790f, 0.01885272f, 
    0.00116140f, 0.00648025f, -0.01239610f, -0.00389807f, 0.00482087f, 0.01869234f, -0.01945420f, -0.04293020f, 
    -0.00761309f, -0.04353371f, 0.00277947f, -0.03230878f, 0.01010580f, -0.01799078f, -0.02147865f, -0.02140030f, 
    -0.00551229f, -0.01813047f, 0.01905880f, 0.02235427f, -0.04457635f, -0.01297150f, -0.00311352f, -0.01802082f, 
    -0.01994761f, -0.01493353f, 0.02848598f, 0.02415925f, 0.01543500f, -0.04030759f, 0.02614755f, -0.01497195f, 
    0.00431058f, -0.01823969f, -0.01122961f, 0.02669232f, 0.00255110f, 0.01909113f, -0.02755427f, 0.02367054f, 
    0.00397322f, -0.00469950f, 0.03188388f, 0.00498634f, 0.00544813f, 0.00792619f, -0.01251226f, -0.03473707f, 
    0.00369768f, -0.00102338f, -0.03232305f, 0.01022466f, 0.00939345f, -0.01676665f, -0.04048467f, 0.00055675f, 
    0.00566919f, 0.00054898f, -0.00109190f, -0.01516780f, 0.02001064f, -0.03362103f, -0.00614650f, 0.01667474f, 
    -0.02280862f, 0.00848288f, 0.00064619f, 0.01499515f, -0.00573570f, 0.02647836f, -0.02772327f, 0.01953694f, 
    -0.03611426f, -0.00473266f, 0.01945035f, 0.02392333f, 0.02625452f, 0.02925907f, 0.01862810f, -0.01540311f, 
    -0.00269161f, 0.00018916f, 0.01538913f, -0.03438111f, -0.02391873f, 0.02398477f, -0.03097601f, -0.02124765f, 
    -0.02242708f, 0.02476474f, -0.03009154f, -0.00030113f, -0.02004284f, -0.01728277f, -0.03003107f, 0.02731920f, 
    0.01368476f, -0.00184435f, -0.01427222f, -0.01443162f, -0.01468213f, -0.03308113f, 0.01858919f, 0.02730306f, 
    -0.01315958f, 0.01170117f, -0.00494907f, 0.00977860f, -0.02828674f, 0.01431724f, -0.03485731f, -0.00616897f, 
    0.02574147f, -0.00378613f, -0.01510136f, 0.02653277f, -0.00105892f, -0.01386779f, -0.00702661f, -0.01748739f, 
    -0.02143605f, -0.01743681f, -0.00550407f, 0.00827788f, -0.02812156f, -0.00625255f, -0.04191668f, 0.02563716f, 
    0.01553645f, -0.02315716f, -0.01676302f, -0.01414170f, 0.01331984f, -0.01322930f, 0.02411619f, 0.02078718f, 
    0.00021314f, 0.01758838f, 0.00987719f, -0.02725910f, 0.02085106f, -0.00013548f, 0.02114028f, -0.03450843f, 
    -0.00314316f, -0.03420941f, -0.01991002f, 0.02639908f, -0.02394451f, 0.02841042f, 0.02630020f, 0.02697464f, 
    0.03069342f, -0.03431616f, -0.02935176f, -0.00009035f, -0.04064078f, 0.02346767f, 0.00576493f, 0.01369753f, 
    0.01200623f, 0.00888369f, -0.01130065f, -0.03588852f, -0.01628604f, 0.01851885f, 0.00960905f, -0.03703729f, 
    0.00304719f, -0.01156569f, -0.02443759f, -0.03715394f, -0.04519358f, -0.01683849f, 0.02853432f, 0.02475810f, 
    -0.02609039f, 0.01766105f, -0.03145125f, -0.01230930f, 0.00126298f, 0.01772913f, -0.00474701f, 0.01012608f, 
    -0.01376378f, 0.02457280f, -0.03394708f, 0.01660244f, -0.01123258f, 0.01296567f, 0.01836292f, -0.00515257f, 
    -0.03553393f, -0.00318098f, -0.03631812f, 0.01464739f, 0.01172562f, -0.00265901f, -0.01535568f, -0.02831929f, 
    -0.03801721f, -0.02324390f, 0.02914407f, 0.01073704f, -0.01530704f, 0.00725155f, 0.01249307f, -0.01557410f, 
    -0.02030071f, 0.02417288f, -0.01023027f, -0.01068955f, -0.00468710f, -0.01943073f, -0.04153969f, -0.00417244f, 
    0.02194940f, -0.01005705f, 0.01031340f, -0.00936123f, 0.01458721f, 0.01114174f, -0.02900720f, 0.02564181f, 
    -0.03016716f, -0.02516230f, 0.01809722f, 0.01698831f, -0.03123573f, 0.00124166f, -0.01800263f, 0.02985019f, 
    -0.04005719f, -0.00605045f, -0.03283351f, 0.01265086f, -0.01666522f, 0.01849014f, -0.04574843f, 0.00157479f, 
    -0.03840775f, -0.01643962f, -0.00888793f, -0.02164597f, -0.02895214f, 0.03766637f, -0.01066643f, -0.01143395f, 
    -0.02932046f, 0.01365262f, 0.03565650f, 0.02345275f, -0.00968782f, 0.02545681f, -0.01085213f, -0.00987270f, 
    -0.01632532f, -0.01784286f, -0.03980717f, 0.01132527f, -0.03601491f, -0.00184784f, 0.00613477f, 0.01543800f, 
    0.00243716f, 0.00876161f, 0.02005499f, -0.02943117f, -0.03740165f, -0.04009292f, 0.01112586f, 0.00251533f, 
    0.01625906f, -0.00159930f, 0.00787511f, -0.03203649f, -0.02378863f, 0.01679078f, -0.02655855f, 0.01378013f, 
    -0.02654695f, 0.01261877f, -0.03237739f, -0.03846348f, -0.03470130f, -0.00735439f, 0.02219962f, -0.03802786f, 
    0.02904994f, -0.04338046f, 0.02359534f, 0.00592356f, 0.01082603f, -0.02974174f, -0.00309501f, 0.00300494f, 
    -0.01087527f, 0.02953753f, -0.04116858f, 0.00884911f, 0.00438042f, -0.03644559f, -0.01241440f, -0.01304947f, 
    -0.00205389f, 0.01618120f, 0.01714548f, -0.01062746f, -0.01134512f, 0.02094826f, 0.00914165f, -0.01339734f, 
    0.02348041f, 0.00015731f, 0.02933404f, 0.02732199f, -0.03653676f, 0.01745594f, -0.04216518f, 0.01630002f, 
    -0.03428551f, -0.01940066f, 0.02421246f, -0.00555306f, 0.00149571f, -0.04063135f, 0.00498435f, 0.01171732f, 
    -0.01629184f, 0.00346529f, 0.01490553f, 0.01728503f, -0.03596822f, -0.02533019f, -0.02898885f, -0.02095343f, 
    -0.02003641f, 0.01068063f, -0.00348602f, -0.00153996f, 0.01875947f, 0.02897568f, 0.00229465f, -0.01429658f, 
    0.00701594f, -0.03632354f, -0.02853191f, -0.00888208f, -0.02422233f, 0.00483356f, 0.00185981f, 0.02857852f, 
    -0.03734856f, -0.00876527f, 0.01935737f, 0.01663201f, 0.00274292f, -0.00187634f, -0.04063081f, 0.00393631f, 
    -0.00067367f, 0.01333716f, -0.01530740f, 0.00850312f, -0.00700302f, -0.03170247f, -0.03748266f, -0.00263734f, 
    -0.03174735f, 0.00123977f, 0.00871555f, -0.02775291f, 0.02427262f, 0.00913688f, -0.00210161f, 0.02654057f, 
    -0.04451442f, -0.04044776f, -0.02176381f, -0.02835796f, -0.01091472f, -0.01977910f, 0.00440535f, 0.00864171f, 
    0.00081531f, 0.00473194f, -0.00241483f, -0.02374712f, -0.03257203f, -0.00647168f, 0.01558539f, 0.02103555f, 
    -0.03385890f, -0.04433744f, 0.01667131f, -0.01621227f, 0.01348958f, 0.01055200f, -0.02179378f, -0.03096638f, 
    0.03062583f, -0.02916331f, -0.01635386f, -0.00518574f, 0.01214723f, -0.02096908f, -0.02839788f, 0.03004310f, 
    -0.03367497f, -0.03825428f, -0.03067886f, -0.03890639f, 0.01812539f, -0.03489558f, -0.02677502f, -0.02043294f, 
    0.02831790f, -0.04453119f, 0.00659698f, 0.00465864f, 0.01261598f, 0.03502401f, -0.00603911f, -0.03048488f, 
    0.00004132f, -0.01573143f, 0.02781052f, -0.02816873f, -0.03261055f, 0.03134587f, 0.00260240f, 0.02384521f, 
    -0.03332032f, -0.01782648f, 0.03142070f, 0.02749876f, 0.00122168f, -0.03936656f, -0.03417655f, 0.00599402f, 
    0.01399483f, -0.01807599f, -0.01785256f, -0.02996308f, -0.02372847f, 0.00429182f, -0.00858121f, -0.02825690f, 
    -0.00187193f, -0.03813115f, -0.01387308f, 0.00007877f, -0.01727524f, 0.01686708f, 0.03851338f, 0.01319729f, 
    -0.01545796f, 0.02313009f, 0.00153606f, 0.02672072f, -0.00678453f, 0.00947507f, -0.01929975f, -0.01760289f, 
    0.03322978f, 0.01812417f, 0.02992739f, -0.01411058f, -0.00281342f, 0.01844225f, -0.00484075f, 0.01458550f, 
    0.01126937f, 0.00104171f, 0.02895294f, -0.00666561f, -0.01150424f, 0.01050931f, 0.02491085f, 0.03083743f, 
    -0.03695229f, -0.02639828f, 0.00752215f, -0.01735126f, -0.03247736f, 0.01492593f, -0.03604305f, 0.01731125f, 
    -0.00055523f, 0.02999858f, 0.01996549f, 0.01923618f, -0.00709814f, -0.03517823f, 0.02364086f, -0.03627412f, 
    -0.03167759f, -0.01205599f, -0.02734144f, -0.03478926f, -0.01940401f, 0.02648345f, -0.01077284f, -0.00739398f, 
    0.03439077f, -0.01465542f, 0.00956075f, 0.00307562f, 0.00099666f, -0.03902974f, -0.01259788f, -0.02115053f, 
    0.00923612f, 0.02709215f, -0.00610100f, -0.00896279f, -0.02436570f, -0.02063562f, 0.01566442f, -0.03327416f, 
    -0.03476914f, -0.00385593f, -0.01011602f, 0.01652212f, -0.02670709f, -0.00358878f, -0.01334594f, -0.00165486f, 
    0.02392565f, 0.00883422f, -0.00945501f, -0.02889938f, 0.02557938f, -0.03580768f, 0.02208534f, 0.00782181f, 
    -0.02204739f, -0.00156004f, -0.03791656f, 0.01388244f, -0.03439650f, -0.02539307f, 0.01431201f, 0.01496812f, 
    -0.02503927f, -0.03045511f, 0.01458810f, 0.02612017f, 0.02282698f, -0.03105644f, -0.00331561f, -0.01677019f, 
    0.02347801f, 0.02524116f, -0.03591438f, -0.02264029f, -0.03477544f, -0.02893052f, -0.01022241f, -0.02475477f, 
    -0.03714143f, 0.00276387f, -0.01164276f, -0.00973182f, 0.01392702f, 0.01942546f, -0.03580927f, 0.02421058f, 
    0.02257447f, 0.00153337f, -0.04085236f, 0.01644410f, -0.02880058f, 0.00008296f, -0.01164924f, -0.01136901f, 
    0.02920302f, -0.03010497f, -0.00641594f, 0.01801125f, 0.01563284f, 0.01685594f, -0.04020248f, -0.00135215f, 
    0.01680660f, -0.04046843f, 0.01238686f, 0.01362901f, -0.00579696f, -0.02393547f, -0.01424265f, -0.02085052f, 
    -0.01569876f, -0.03826039f, -0.00676517f, 0.01986322f, -0.04088200f, -0.02055699f, 0.01200922f, 0.03697194f, 
    -0.02999415f, 0.02372964f, 0.01285054f, -0.00190694f, 0.01812243f, 0.02688924f, -0.03159935f, 0.03214734f, 
    0.01104310f, 0.00315332f, -0.02707279f, 0.02493209f, 0.02329234f, -0.02619768f, 0.00462146f, -0.01467432f, 
    -0.00447001f, 0.01402862f, 0.00608293f, 0.01475028f, -0.00039617f, -0.00153799f, 0.01265748f, -0.03915028f, 
    -0.01932991f, 0.01489195f, -0.02210663f, -0.00529894f, -0.02461780f, 0.01452604f, -0.00282184f, 0.01364930f, 
    0.00844177f, -0.03366292f, -0.02591278f, 0.01945685f, -0.02097979f, 0.02839328f, -0.04074940f, -0.03209839f, 
    -0.00615286f, -0.03605336f, -0.00680591f, 0.01955510f, 0.00337688f, 0.00607654f, -0.02476778f, -0.01844875f, 
    0.01486424f, 0.02677359f, -0.03489236f, -0.02582234f, -0.03793756f, -0.01780992f, -0.03077070f, 0.02630689f, 
    0.01059964f, 0.02929278f, 0.01746273f, 0.02387248f, -0.01261632f, -0.00055158f, 0.00688689f, 0.02908600f, 
    -0.01731584f, 0.02392369f, -0.00691410f, 0.02247362f, -0.02742137f, 0.01565772f, -0.01966142f, 0.03678149f, 
    0.03022791f, 0.02458375f, 0.00514354f, -0.00490347f, 0.00547349f, 0.02919954f, 0.01243852f, 0.00261946f, 
    0.00583698f, -0.00540750f, 0.02281380f, 0.02796152f, -0.03707915f, -0.03572176f, 0.01959286f, 0.03006721f, 
    -0.03190225f, -0.04008651f, -0.00934999f, -0.02717989f, 0.02779068f, -0.03325788f, 0.02429428f, -0.02816311f, 
    -0.03544440f, -0.01701828f, -0.02506829f, -0.03152874f, 0.00395479f, -0.01601735f, -0.03966644f, -0.02093872f, 
    0.02928726f, 0.03547577f, -0.00312081f, -0.03643805f, -0.01451978f, 0.02215866f, -0.03105152f, 0.01685302f, 
    0.01850697f, -0.00767315f, 0.02946178f, -0.00871210f, 0.01060364f, 0.01821388f, 0.00462637f, -0.04007579f, 
    0.01080233f, 0.00905603f, -0.00936245f, 0.01149022f, 0.02302628f, -0.02688036f, -0.01057649f, -0.02413519f, 
    -0.01657600f, 0.00360608f, -0.00530923f, 0.03109855f, 0.00017397f, -0.03824452f, 0.01633630f, -0.02098144f, 
    0.00264498f, 0.00602124f, 0.00786604f, -0.03061511f, 0.00475686f, 0.03292324f, -0.02734993f, 0.00019781f, 
    0.00595308f, 0.02832732f, 0.02010653f, -0.00767958f, -0.00589566f, -0.00607098f, -0.00606298f, 0.01103371f, 
    0.03243627f, 0.03533036f, -0.01423282f, 0.01264830f, -0.00552487f, -0.01829541f, -0.00816244f, 0.02141372f, 
    -0.02675873f, 0.00886001f, 0.00105802f, -0.00000198f, -0.00775993f, 0.00327045f, -0.00860703f, 0.02481565f, 
    -0.03538111f, -0.00294647f, 0.02803118f, 0.02441602f, -0.02023346f, 0.01238685f, -0.01583821f, -0.01650535f, 
    0.00439738f, -0.00868059f, 0.01938717f, -0.01195646f, -0.01631375f, 0.00775894f, 0.00532320f, -0.02735823f, 
    -0.02562142f, -0.01920875f, 0.02739693f, 0.01636851f, 0.01616056f, -0.01068699f, 0.02534968f, -0.03760274f, 
    0.01631722f, 0.01683357f, -0.03616035f, -0.00319227f, 0.03494548f, 0.00098325f, 0.02802811f, -0.01209962f, 
    -0.02696006f, -0.01935411f, -0.03386421f, -0.01928070f, 0.03146923f, 0.00180193f, 0.02428817f, -0.02413344f, 
    0.02538770f, -0.01866697f, 0.01207618f, 0.01586053f, -0.03250124f, 0.01344667f, -0.00827262f, -0.03883588f, 
    0.03278267f, 0.00401319f, 0.00517312f, -0.01887523f, 0.01364980f, 0.01947298f, 0.00429354f, -0.03420709f, 
    0.03064778f, -0.03432784f, 0.00967448f, 0.02286851f, -0.00464427f, -0.00588209f, -0.00531012f, -0.02862123f, 
    -0.02207081f, 0.00225724f, -0.00253308f, -0.01337158f, -0.00491318f, 0.03169283f, 0.00130595f, -0.01256377f, 
    0.01057949f, 0.02189633f, -0.02941618f, -0.02075689f, -0.01556289f, 0.00266721f, 0.02167921f, 0.00879149f, 
    0.01585604f, 0.03303514f, 0.01631243f, -0.01053537f, 0.01292673f, -0.01001801f, -0.01318508f, -0.01778033f, 
    -0.04051848f, -0.03376459f, -0.03741484f, 0.02470399f, 0.00514351f, -0.01597819f, 0.00414296f, 0.02460700f, 
    0.00375957f, -0.01964726f, 0.00233121f, -0.02041735f, 0.01508015f, 0.01127381f, -0.01575030f, 0.01623161f, 
    0.02959831f, -0.02325765f, -0.03112310f, 0.00495411f, 0.02967586f, 0.02197435f, 0.01004570f, 0.00861576f, 
    -0.00790951f, -0.00738072f, 0.00425970f, -0.02447828f, 0.00208323f, 0.00843571f, -0.03518599f, -0.02824626f, 
    0.02427595f, 0.01571357f, -0.00890147f, -0.03339613f, -0.04008871f, 0.01978599f, -0.03391661f, 0.02744947f, 
    0.01892078f, -0.02161602f, 0.01249532f, 0.01983405f, -0.02183767f, -0.01983796f, -0.03290482f, 0.02408491f, 
    -0.02990080f, 0.00691996f, 0.02254885f, -0.02638458f, -0.03767467f, -0.02624767f, 0.00458226f, -0.03722956f, 
    0.02936838f, 0.03140324f, -0.01069854f, -0.02335232f, -0.02262825f, -0.01007967f, 0.00822622f, 0.01886681f, 
    -0.01124494f, -0.01926982f, 0.00286505f, 0.00069523f, -0.02039232f, -0.00510407f, 0.02952475f, 0.00482162f, 
    -0.03237634f, -0.00674215f, 0.02010997f, -0.02389267f, 0.01431258f, -0.01089248f, -0.01906599f, -0.04178008f, 
    -0.02558213f, -0.02005895f, 0.02509707f, -0.02719699f, -0.02979167f, -0.02973302f, 0.00410909f, 0.01068927f, 
    0.01326657f, 0.02999830f, 0.02860124f, -0.03979553f, -0.01599625f, 0.01124089f, 0.01258412f, -0.01782829f, 
    0.00373212f, -0.01435106f, 0.02713570f, 0.01828435f, -0.00039776f, 0.01436075f, -0.00053540f, 0.00752866f, 
    -0.00993198f, -0.00499269f, -0.02664758f, 0.02500839f, 0.02449618f, 0.02017872f, 0.00930708f, -0.02594642f, 
    -0.01591729f, -0.02835400f, -0.03173570f, -0.01938771f, 0.00552307f, -0.03341160f, -0.02143579f, 0.02831148f, 
    -0.00075629f, 0.02481204f, -0.02927633f, -0.00319016f, -0.02793885f, 0.01483911f, -0.01470721f, 0.02172664f, 
    0.01121860f, -0.02817454f, 0.02212573f, 0.02656637f, 0.00065746f, 0.02555308f, -0.03217847f, 0.01242102f, 
    -0.03976030f, 0.01214746f, -0.02966790f, 0.00928475f, 0.00914797f, 0.02535088f, 0.00238750f, -0.03920808f, 
    -0.02915268f, -0.01425368f, -0.01891523f, 0.01382907f, -0.02701206f, -0.02998006f, -0.00161118f, 0.01072379f, 
    0.01678615f, 0.01639749f, -0.01788574f, 0.01577330f, -0.03200057f, 0.02637755f, -0.03752734f, -0.00966923f, 
    0.02487538f, 0.00946163f, -0.03591071f, 0.00818115f, -0.02826151f, -0.00377029f, 0.02972906f, 0.00258037f, 
    -0.01124302f, -0.03869876f, -0.01484877f, 0.02083507f, -0.03229451f, -0.00947510f, 0.01695885f, -0.01604214f, 
    -0.01456988f, -0.00345395f, 0.00405345f, 0.01418777f, -0.01950250f, -0.00114092f, -0.00014947f, 0.02846522f, 
    -0.03082107f, -0.02617301f, -0.02719380f, -0.01599353f, 0.00247775f, 0.00356322f, -0.00773512f, -0.00977762f, 
    -0.02070263f, 0.03018260f, -0.00702119f, 0.02632875f, -0.01443620f, 0.02737433f, 0.00517679f, -0.02694280f, 
    -0.01211842f, -0.03122806f, -0.02169810f, 0.00158109f, 0.01156096f, -0.00172381f, 0.02297290f, -0.03615059f, 
    -0.01238970f, -0.00615544f, -0.01325386f, -0.00893167f, -0.00259836f, -0.00524730f, -0.01053448f, -0.00132739f, 
    0.02564094f, 0.02558895f, 0.01069617f, -0.00408103f, 0.03147590f, 0.02318734f, -0.02762678f, -0.00442076f, 
    0.00331028f, -0.00218724f, 0.01266409f, 0.01383267f, 0.01212859f, -0.02249714f, 0.01367917f, -0.00112586f, 
    0.01903132f, -0.02680589f, -0.03165204f, -0.02403832f, -0.02509910f, -0.02961759f, -0.02983116f, -0.01560567f, 
    -0.02184254f, 0.00643754f, 0.03164697f, -0.00958023f, -0.03845115f, -0.02865505f, 0.02169354f, 0.03117660f, 
    -0.03291165f, 0.02589403f, -0.03500665f, 0.02605244f, 0.02949106f, -0.03823410f, 0.02254024f, -0.02352742f, 
    0.01024225f, -0.02087737f, 0.01624580f, 0.02805683f, 0.01533967f, 0.00691157f, 0.02623344f, -0.02953947f, 
    -0.01318835f, 0.00094394f, -0.02973154f, -0.01440436f, 0.01520588f, 0.02450761f, -0.00839122f, -0.01899829f, 
    0.00537625f, 0.02307180f, -0.01420431f, -0.01887249f, -0.01349175f, 0.03056745f, 0.02696680f, -0.02750477f, 
    -0.01562411f, -0.03582364f, -0.03163385f, 0.02137380f, 0.02965795f, 0.03367811f, 0.02463185f, 0.01407648f, 
    -0.00124695f, -0.01589037f, -0.04069881f, 0.01360256f, 0.01537249f, 0.00567514f, -0.01433915f, 0.02470989f, 
    -0.02224949f, 0.02576265f, 0.02609891f, 0.02609610f, 0.00197327f, -0.02668953f, 0.01158282f, -0.03329750f, 
    -0.01739318f, 0.00329540f, 0.00630065f, -0.02175652f, 0.01350583f, -0.00817707f, -0.00979265f, -0.00824685f, 
    -0.01116502f, 0.00659552f, 0.01783739f, 0.01390900f, 0.02058925f, 0.02309984f, 0.01276215f, -0.00247531f, 
    0.02338595f, 0.01463114f, 0.01615521f, -0.00881045f, 0.02959329f, 0.00437440f, 0.02621378f, 0.02952688f, 
    0.01489161f, -0.01728349f, 0.01993132f, -0.01871175f, 0.03025245f, -0.01744836f, -0.04106066f, 0.00353501f, 
    -0.00352150f, -0.00517230f, -0.00497666f, -0.00947056f, 0.00770176f, 0.00291628f, -0.00245993f, -0.02704932f, 
    -0.00855899f, -0.01290115f, -0.01235492f, -0.00357483f, -0.01125975f, 0.01265729f, 0.00274907f, 0.03143210f, 
    0.02856587f, 0.01365972f, -0.02008313f, 0.02707388f, -0.02582723f, 0.00125969f, -0.02305105f, 0.00009108f, 
    -0.03873679f, -0.00231467f, 0.03514193f, -0.02223610f, -0.01716342f, 0.00171963f, -0.01364613f, 0.00083395f, 
    0.02043738f, 0.01718872f, -0.03672229f, -0.01948769f, -0.00330787f, -0.02608273f, -0.00625800f, 0.02208018f, 
    0.04081113f, 0.00578760f, -0.01724627f, -0.02999718f, 0.01738160f, -0.02679858f, -0.00218662f, -0.02934279f, 
    -0.01883933f, 0.02226581f, 0.00081323f, 0.02586784f, -0.00451594f, -0.01481948f, 0.00650881f, 0.01878948f, 
    -0.02230471f, 0.00633207f, 0.02020215f, 0.01777702f, 0.01776345f, -0.04320662f, -0.01312526f, 0.01973493f, 
    0.00874899f, -0.04361100f, 0.02001113f, -0.03819386f, -0.02015485f, 0.02709735f, -0.02453471f, -0.01497815f, 
    -0.01080947f, -0.00770908f, 0.01358805f, 0.01994666f, -0.00319878f, 0.01714060f, -0.02214864f, -0.04369924f, 
    -0.00112303f, -0.04200665f, -0.03206780f, -0.03978169f, 0.01280762f, -0.00347433f, 0.01246114f, -0.00233781f, 
    -0.04219584f, -0.03555131f, -0.03169736f, 0.02320004f, -0.03322558f, 0.02000708f, 0.01163904f, -0.02684382f, 
    0.00801097f, -0.01741571f, -0.03512314f, 0.01265088f, -0.03660559f, -0.02375733f, -0.02437258f, -0.03883245f, 
    -0.00748548f, 0.02233385f, 0.01872210f, -0.03714491f, 0.01754600f, -0.01341186f, 0.02225918f, 0.01058747f, 
    -0.00117838f, 0.00567969f, -0.00416500f, 0.00602874f, 0.02185310f, 0.01901700f, -0.03332875f, -0.00922227f, 
    -0.01671531f, -0.02340237f, -0.01715421f, 0.01561804f, 0.00811149f, 0.00980186f, 0.01447374f, 0.01543893f, 
    0.02042800f, 0.02452006f, -0.01432685f, -0.01974824f, -0.03633042f, 0.00261279f, 0.01559939f, -0.03064015f, 
    -0.03470615f, -0.01687540f, 0.01310422f, -0.00239524f, 0.01940140f, -0.03582108f, -0.02613226f, 0.00730339f, 
    -0.03800648f, 0.01110417f, 0.01895214f, 0.00342904f, 0.00034158f, 0.03091237f, 0.01990888f, 0.00316555f, 
    -0.02141158f, -0.01803884f, 0.00765047f, 0.02873929f, -0.00609921f, -0.00063979f, 0.01401642f, -0.03383385f, 
    0.00907523f, -0.01291648f, -0.00304064f, -0.01115042f, -0.03197465f, 0.00015309f, -0.00962273f, -0.02315648f, 
    0.00486723f, -0.02040632f, 0.00778874f, -0.03654686f, -0.02893583f, 0.00365084f, -0.02151571f, -0.02522716f, 
    0.01361132f, 0.01760022f, -0.02742648f, -0.03126709f, -0.00725536f, -0.02099757f, 0.00609714f, -0.02651261f, 
    -0.03918803f, -0.01667442f, -0.04211001f, -0.03397169f, -0.02649594f, -0.02775318f, 0.01178242f, 0.02058858f, 
    0.01327130f, -0.00491057f, -0.02802647f, -0.01368624f, -0.02807793f, -0.03567105f, 0.00858330f, -0.04358579f, 
    0.01015612f, -0.02877014f, -0.03921171f, -0.02093675f, 0.01395158f, 0.01977726f, -0.01423131f, 0.01352797f, 
    0.00597092f, -0.00877410f, -0.04136769f, 0.01308441f, 0.02072209f, 0.02346569f, -0.01984403f, -0.03388961f, 
    -0.02615857f, 0.01031640f, 0.00249475f, 0.00212381f, 0.03494950f, -0.01694796f, -0.02691190f, 0.01763897f, 
    0.00196612f, -0.02346896f, -0.01193575f, -0.03775841f, -0.04084070f, 0.00962506f, -0.02786706f, -0.02985069f, 
    0.00025476f, -0.03337424f, 0.00294412f, -0.00280847f, 0.02852714f, -0.00667127f, -0.03553792f, 0.00374110f, 
    -0.02235820f, 0.00878492f, 0.00712917f, -0.03995774f, -0.01088488f, 0.02521645f, -0.00985596f, 0.00255792f, 
    -0.03390195f, -0.03337952f, -0.03147598f, 0.00306224f, 0.02530805f, 0.01246760f, -0.03467028f, -0.02676154f, 
    -0.00802403f, -0.02692915f, -0.00009896f, 0.02580745f, -0.00729865f, -0.03605773f, -0.01909956f, 0.00573216f, 
    0.00928503f, -0.02513624f, -0.04653262f, 0.00716160f, 0.01795288f, -0.03471217f, -0.02515894f, -0.00443584f, 
    -0.01467987f, 0.02784633f, -0.03672603f, 0.01696881f, -0.03243235f, -0.04270582f, 0.01969536f, -0.00846356f, 
    -0.01789244f, 0.02506468f, -0.03988213f, -0.03626068f, 0.00452691f, 0.00139593f, -0.01025107f, -0.01796704f, 
    -0.03451960f, -0.02501550f, -0.00218722f, 0.01061295f, 0.00098156f, -0.00930467f, -0.00412171f, -0.01698612f, 
    0.01459177f, -0.02949355f, -0.01493488f, -0.03916576f, -0.01058025f, -0.00211158f, 0.02503747f, -0.00368141f, 
    -0.00113553f, 0.02792009f, 0.02756223f, 0.00365580f, 0.01247462f, -0.00322958f, 0.00689155f, -0.02111740f, 
    -0.02942095f, -0.03105392f, 0.02364171f, -0.02997860f, -0.00313303f, 0.02376377f, -0.02094913f, -0.01246157f, 
    0.00819364f, -0.01542415f, 0.00678293f, -0.02753897f, -0.03989401f, 0.00116286f, -0.00588168f, 0.01321318f, 
    0.01159419f, 0.00513933f, 0.03630965f, 0.00458100f, -0.02173162f, 0.02260863f, 0.02664728f, -0.00400623f, 
    -0.00543929f, -0.01887548f, -0.01318249f, 0.00261084f, -0.02500430f, -0.01617477f, -0.00801867f, 0.00284609f, 
    0.00512823f, -0.00451961f, -0.04027716f, -0.01110189f, -0.00466609f, -0.01345617f, -0.01037867f, 0.01947976f, 
    0.01772285f, -0.00215629f, 0.00370202f, 0.00776749f, 0.02212803f, 0.02710933f, -0.01059158f, 0.00051703f, 
    -0.04546617f, 0.02265359f, 0.01853341f, 0.02381118f, -0.04009946f, -0.02130738f, -0.01548509f, -0.02272040f, 
    0.00407006f, -0.02211436f, 0.01883715f, 0.02551906f, -0.01847689f, -0.03152959f, 0.00555120f, 0.02549962f, 
    0.01205857f, 0.01070370f, -0.00281831f, -0.02263097f, 0.01460175f, -0.01831947f, 0.00073656f, 0.02053677f, 
    -0.00944638f, -0.00776713f, -0.00155379f, -0.02330432f, -0.00607048f, 0.01474406f, 0.02269473f, 0.02555292f, 
    -0.03824575f, 0.01565406f, -0.00887471f, -0.04080723f, -0.01998288f, 0.00559285f, -0.02391767f, -0.01182331f, 
    0.02935965f, 0.03500663f, 0.00200488f, 0.00699347f, 0.01605015f, -0.03629938f, 0.01406425f, -0.00875352f, 
    0.00521812f, -0.03001910f, 0.02481337f, -0.00604003f, -0.03854910f, -0.04332471f, -0.03494170f, 0.00360021f, 
    0.02275742f, -0.02474866f, 0.01883943f, -0.03719428f, 0.02117276f, -0.04149387f, 0.01150457f, 0.01025190f, 
    0.00721346f, -0.03386320f, -0.00471600f, -0.01564694f, 0.01590934f, 0.02765042f, -0.03663164f, -0.03607534f, 
    -0.00332656f, -0.01894405f, 0.00393095f, -0.02620671f, -0.03423798f, 0.01382575f, -0.01508363f, 0.02671424f, 
    -0.01560136f, -0.03789218f, 0.01557985f, -0.02706918f, 0.01006277f, 0.02315646f, -0.01420514f, 0.01083093f, 
    0.00064434f, 0.00635732f, -0.01094074f, -0.03319343f, -0.02555193f, -0.00731440f, -0.00459067f, -0.00580204f, 
    -0.00763552f, -0.02908905f, 0.02044402f, 0.02796703f, -0.03095902f, -0.02531506f, -0.03024587f, -0.04380956f, 
    0.00397353f, -0.00894277f, -0.00045611f, -0.02134876f, -0.03457975f, -0.02461892f, -0.01523185f, -0.01409405f, 
    -0.03622489f, -0.00670557f, 0.01506049f, -0.02102133f, -0.03979681f, -0.04113970f, -0.04112297f, -0.02986478f, 
    -0.00608731f, -0.00768912f, 0.01872495f, 0.02098686f, -0.01811400f, -0.00595608f, 0.01043350f, -0.04021515f, 
    -0.02987294f, -0.03897387f, 0.01015649f, 0.00275777f, 0.00146207f, 0.00433016f, 0.02084466f, -0.01673989f, 
    -0.04207030f, -0.03414009f, 0.01827087f, 0.02264774f, -0.04581338f, -0.00621662f, -0.01024504f, -0.01220835f, 
    0.02324965f, 0.02671923f, -0.02520172f, -0.01108093f, -0.02491885f, 0.01550375f, 0.00522945f, -0.02676989f, 
    0.01979602f, -0.01161865f, -0.00990069f, -0.03804404f, 0.00793848f, 0.00801499f, -0.01221709f, -0.02817161f, 
    0.02395495f, -0.02479556f, -0.02230355f, -0.01440478f, -0.01514106f, -0.01308426f, 0.02733067f, -0.00232882f, 
    0.00437427f, 0.01888954f, -0.02053536f, -0.03639617f, -0.00720090f, 0.02015544f, 0.01571768f, -0.02855226f, 
    0.00132418f, -0.00894205f, -0.03341348f, -0.00124629f, -0.03539650f, -0.00919909f, 0.01702790f, 0.01227843f, 
    -0.00510708f, -0.00079514f, -0.03055555f, 0.00763675f, -0.01037050f, 0.02714722f, -0.03215800f, -0.03631290f, 
    -0.03859899f, 0.02136446f, -0.04295083f, 0.01771876f, -0.03919818f, 0.01659325f, -0.01895218f, -0.00868212f, 
    0.01405173f, 0.01890718f, 0.02094570f, -0.00987121f, -0.04031710f, -0.01826101f, 0.01786993f, -0.02258389f, 
    -0.02203836f, 0.02236642f, 0.01840859f, -0.01735745f, 0.00071687f, -0.03066226f, 0.00807214f, 0.01814111f, 
    -0.01827108f, 0.01796161f, 0.00289741f, 0.00052043f, -0.03029304f, -0.03172178f, -0.02968730f, 0.01098377f, 
    0.02145511f, 0.00363858f, 0.01412937f, -0.01446300f, 0.02522272f, -0.00133374f, -0.01264362f, 0.01571878f, 
    0.01293746f, -0.02214884f, -0.01084604f, 0.01509471f, -0.01923455f, 0.02497380f, -0.02582296f, -0.00976575f, 
    0.01257935f, -0.01828109f, -0.03799343f, -0.02857833f, -0.03292537f, -0.04094690f, 0.01033837f, 0.01714738f, 
    0.00556417f, -0.01958315f, -0.00979180f, -0.02247520f, -0.02103790f, 0.00909227f, -0.03428563f, 0.02482364f, 
    0.02159891f, 0.01191974f, -0.03245030f, -0.00788493f, -0.01214913f, 0.00895084f, -0.01088897f, -0.02448136f, 
    -0.02949755f, 0.00832334f, 0.02264050f, 0.01617474f, -0.03811714f, 0.00073067f, -0.03833057f, -0.03752153f, 
    0.00319269f, -0.00314662f, -0.03790301f, 0.02396964f, -0.02462900f, 0.00025627f, 0.02187241f, -0.03674736f, 
    -0.00643818f, -0.01750191f, -0.04362743f, 0.02210519f, 0.02196941f, -0.02199816f, -0.01083345f, -0.02268308f, 
    0.01025268f, -0.01663396f, 0.02748815f, -0.03945481f, -0.02263700f, 0.02370187f, 0.01564865f, -0.00276157f, 
    -0.01664785f, 0.02977215f, 0.00052938f, -0.04125169f, -0.00107657f, 0.01694903f, 0.01791967f, 0.01364928f, 
    0.01906918f, 0.00594327f, 0.02477867f, 0.00957281f, 0.01930992f, -0.00122108f, -0.03725147f, 0.02285134f, 
    -0.03811802f, 0.02159329f, 0.01268715f, 0.01323420f, -0.01897821f, 0.02237249f, 0.02933395f, -0.00541053f, 
    -0.03277982f, 0.00779122f, 0.00152041f, 0.00795020f, 0.00311708f, -0.00823169f, -0.01466855f, 0.01114532f, 
    0.02066328f, -0.03650198f, -0.01945313f, -0.02187666f, -0.01778228f, 0.00743187f, -0.01821424f, 0.01584019f, 
    0.01406045f, -0.01143871f, 0.00318276f, -0.00579123f, 0.00042323f, -0.02556565f, 0.00889271f, 0.02408189f, 
    0.00245629f, 0.02700686f, -0.02140072f, 0.01422251f, -0.00245230f, 0.01117997f, -0.03447294f, -0.02835438f, 
    -0.02370642f, 0.01174187f, -0.02598423f, -0.01565000f, -0.01289695f, 0.01341315f, -0.03301325f, 0.02605116f, 
    0.00846178f, 0.00921023f, -0.02688253f, -0.03703715f, 0.00465909f, 0.00651507f, -0.00055047f, -0.02642133f, 
    0.01065813f, 0.02529892f, 0.02720982f, -0.00844282f, -0.01000858f, 0.01696628f, 0.00248565f, 0.00085900f, 
    0.02692519f, -0.01427960f, 0.00883070f, -0.03014010f, 0.01649523f, -0.01362285f, -0.02134342f, -0.02460595f, 
    0.00055624f, 0.01306302f, 0.01252411f, -0.03547290f, 0.01829054f, 0.01197051f, 0.00097007f, -0.00957429f, 
    0.00134154f, 0.00300479f, 0.00478851f, -0.00948865f, 0.00735543f, -0.03492470f, -0.03685544f, 0.02133008f, 
    0.01048258f, -0.02177434f, 0.00357526f, 0.00292932f, -0.00248465f, -0.00913760f, 0.02502663f, -0.03369580f, 
    0.00731471f, -0.01665888f, -0.03529420f, -0.03822383f, 0.00724240f, -0.02815803f, 0.02521849f, -0.03393495f, 
    -0.04144770f, -0.01849843f, 0.01868758f, 0.01423729f, -0.01896058f, -0.01611398f, -0.00981936f, -0.01982958f, 
    -0.02340307f, 0.00224595f, -0.01858098f, -0.02736956f, 0.01331890f, 0.01177768f, 0.01170675f, -0.01599822f, 
    -0.04224358f, -0.00428257f, -0.02913787f, -0.01248754f, 0.02285371f, -0.03583287f, -0.02319678f, 0.02139074f, 
    -0.02693538f, -0.01332726f, -0.01592146f, 0.00235334f, -0.00683677f, 0.02556646f, -0.01458303f, 0.02263893f, 
    0.02092555f, 0.01840595f, -0.01548200f, -0.03792607f, -0.01886499f, 0.01024891f, 0.00420880f, 0.01136683f, 
    -0.01011597f, -0.00925361f, 0.01767229f, 0.02514979f, 0.01886792f, 0.02113550f, 0.01574446f, -0.03550083f, 
    -0.01835376f, -0.01054644f, 0.01399966f, -0.00566587f, -0.00925397f, 0.00252115f, 0.01616775f, 0.01980070f, 
    -0.00243695f, -0.01178057f, -0.01664367f, -0.01192346f, 0.02166430f, 0.01530596f, 0.00172141f, -0.00827595f, 
    -0.04226928f, -0.02548938f, 0.02639541f, -0.03402556f, 0.00061062f, -0.04170546f, -0.03255969f, 0.00020890f, 
    0.02001408f, 0.02111243f, 0.00729001f, -0.02846182f, 0.02620289f, 0.00237042f, 0.00865762f, 0.00142218f, 
    0.02684337f, -0.01824146f, 0.00414932f, -0.03886624f, -0.00574954f, 0.01527736f, -0.03201411f, -0.04240292f, 
    0.00415962f, 0.02463373f, -0.00612432f, -0.02491601f, -0.03424485f, 0.02527475f, -0.01321771f, 0.00977271f, 
    0.02175830f, 0.02852040f, 0.00267839f, 0.02838658f, -0.01273308f, -0.03843821f, 0.02966702f, -0.02379495f, 
    0.01383477f, 0.02629863f, -0.02939296f, -0.01020816f, -0.03190845f, -0.01043184f, -0.03183833f, -0.01928641f, 
    -0.00119386f, 0.00414162f, 0.00679620f, 0.00512382f, 0.00389385f, -0.00631184f, -0.02805755f, -0.01727385f, 
    -0.01714464f, -0.00814745f, -0.03963693f, 0.01150434f, -0.00909825f, -0.02532974f, -0.00099895f, -0.03623091f, 
    0.02117184f, 0.00571553f, -0.00353860f, -0.02388470f, 0.01418264f, 0.01722753f, -0.01388331f, -0.02834766f, 
    0.00309273f, -0.00314423f, -0.02527343f, 0.00045174f, 0.02364924f, -0.02639099f, -0.01242292f, 0.00901589f, 
    -0.00474965f, 0.01290333f, -0.04208700f, -0.03312941f, -0.01039943f, 0.01175625f, -0.03367217f, 0.01960264f, 
    -0.03292880f, -0.00305119f, -0.02308398f, -0.02915323f, -0.03498806f, 0.00294107f, -0.00466652f, -0.04137106f, 
    -0.03506459f, -0.03029166f, -0.00524542f, -0.00538133f, 0.01732654f, 0.01735913f, -0.00480809f, 0.02588122f, 
    -0.02232119f, 0.00715125f, 0.01242991f, 0.01287152f, -0.01922167f, -0.02414083f, -0.04070343f, 0.02548997f, 
    0.00007359f, -0.00171677f, -0.00605319f, 0.00954802f, -0.00566819f, 0.00549234f, 0.02690081f, 0.00218394f, 
    0.02200484f, 0.02695505f, -0.00416629f, -0.02245458f, -0.02343383f, -0.03659387f, 0.01522336f, -0.00667501f, 
    -0.00028008f, 0.01114448f, -0.03257453f, 0.00166023f, 0.02509035f, -0.03972785f, -0.03632757f, -0.02664523f, 
    -0.03066812f, -0.02609446f, -0.02923839f, 0.00781999f, 0.02799243f, -0.01781355f, -0.03885810f, -0.03032579f, 
    0.01900272f, -0.03421896f, 0.00474432f, 0.00216642f, 0.00372454f, -0.03979440f, -0.02927011f, -0.03489625f, 
    0.00201067f, -0.02280970f, 0.01602706f, -0.01687014f, 0.02783053f, -0.03707294f, 0.02071304f, 0.02121380f, 
    -0.02819934f, 0.01443634f, -0.03419692f, -0.01851649f, -0.00177900f, -0.00145857f, 0.01914124f, -0.04213449f, 
    0.00671817f, -0.04000420f, -0.03985729f, 0.01327735f, 0.01360171f, 0.01006954f, 0.02019396f, -0.01300375f, 
    -0.02667577f, 0.01262729f, 0.01929478f, -0.03538973f, -0.04347810f, -0.01529901f, -0.02691135f, 0.02476974f, 
    0.00874243f, 0.00111164f, -0.01457977f, -0.02936418f, -0.03938390f, -0.00102824f, -0.00894026f, -0.00552210f, 
    0.01561370f, 0.00887459f, -0.02920892f, 0.02330134f, -0.00494182f, 0.01695164f, -0.03246510f, -0.04011451f, 
    0.02368575f, -0.00941283f, 0.00289798f, 0.01720996f, 0.02799587f, -0.01228495f, 0.01385672f, -0.01768016f, 
    0.01996325f, -0.00514904f, -0.00484759f, 0.00031373f, -0.00160701f, 0.01673059f, 0.02891367f, 0.00458693f, 
    0.02097910f, 0.02426073f, -0.01706368f, 0.00772094f, -0.01958837f, 0.00190322f, 0.01981130f, -0.02223743f, 
    -0.01548523f, -0.02463848f, 0.01006389f, -0.01976299f, 0.00852294f, -0.02641299f, 0.01526001f, -0.00662106f, 
    -0.03393260f, -0.03098908f, -0.02060719f, -0.01336506f, -0.00118281f, -0.01854653f, -0.03495730f, 0.02819699f, 
    0.01068822f, -0.02656708f, -0.01577970f, -0.03159473f, -0.01872270f, 0.00282957f, 0.01544526f, -0.01268589f, 
    -0.03085726f, -0.01999145f, 0.02136264f, -0.03792861f, 0.00771097f, 0.02362210f, -0.03352249f, -0.03157395f, 
    -0.02394328f, -0.03278439f, -0.01087772f, -0.00070132f, 0.01250619f, -0.00105957f, -0.01401207f, 0.00496892f, 
    0.01011472f, 0.01365124f, -0.00251708f, 0.00135913f, -0.00910658f, -0.01286873f, 0.01707744f, -0.01231476f, 
    0.02343650f, -0.01078757f, -0.00479744f, -0.00364194f, 0.02098154f, 0.02695170f, -0.02869639f, 0.00800256f, 
    0.01669598f, 0.02332008f, -0.01029639f, -0.03880471f, -0.02192423f, -0.01096965f, 0.01521502f, 0.01255196f, 
    -0.03860377f, 0.02367736f, 0.02476493f, -0.00480540f, -0.00273199f, -0.04035532f, 0.00302122f, -0.02575872f, 
    -0.02652654f, -0.03040965f, -0.01202033f, -0.03822072f, -0.00956519f, -0.04204199f, 0.00871837f, 0.00076992f, 
    -0.03998761f, 0.01481929f, -0.01418398f, -0.01843254f, 0.00760597f, -0.02394320f, -0.03117799f, -0.01677353f, 
    0.02763496f, -0.00162427f, -0.00375027f, 0.02792217f, -0.02350735f, -0.01355025f, 0.01819058f, -0.02454139f, 
    0.02133979f, -0.02845418f, -0.02212027f, -0.01495789f, 0.02177428f, -0.03888208f, -0.02320985f, -0.02980166f, 
    0.02669859f, 0.01217796f, 0.01306987f, 0.00508744f, -0.02933503f, -0.04215800f, -0.01582443f, -0.02859488f, 
    0.00010558f, -0.02593262f, 0.02528577f, -0.02594992f, 0.02578076f, -0.01571538f, -0.03755156f, -0.03765740f, 
    -0.00054275f, -0.01204475f, -0.02928946f, -0.00970733f, -0.02008480f, 0.01751165f, -0.01605334f, -0.02172466f, 
    -0.03763254f, -0.01436025f, 0.02911435f, 0.02192239f, -0.00360990f, -0.01140386f, -0.03348112f, 0.00749716f, 
    0.00096053f, -0.03126245f, -0.01747814f, 0.02652710f, -0.03657220f, -0.01797961f, -0.01650263f, -0.02475742f, 
    0.02113532f, -0.01519110f, 0.02821281f, 0.01099887f, 0.01378295f, 0.01045926f, 0.00074144f, -0.03506883f, 
    -0.01550554f, -0.00177896f, -0.01676023f, -0.01564504f, -0.03167392f, -0.00455459f, -0.00829699f, -0.02091501f, 
    -0.03798307f, -0.00331843f, -0.02037622f, -0.03623242f, -0.03519919f, -0.02881250f, 0.02424326f, 0.01367615f, 
    -0.01858439f, -0.01023512f, -0.01609778f, 0.02544205f, 0.01933205f, -0.02511152f, -0.01408301f, 0.02405008f, 
    0.00497874f, 0.00096066f, -0.01820973f, -0.02493745f, -0.01273119f, -0.03776282f, 0.02276588f, -0.02429697f, 
    0.00467046f, 0.01529659f, -0.02750377f, -0.01806423f, -0.02487320f, 0.01240538f, 0.02453140f, -0.03020268f, 
    -0.01591267f, 0.00654517f, 0.00622509f, 0.02168272f, -0.04010525f, 0.00644114f, -0.01623871f, -0.02172925f, 
    0.02637541f, 0.02770959f, -0.00123882f, -0.00501924f, 0.00438223f, -0.00141384f, -0.04277864f, 0.00743639f, 
    -0.02425075f, 0.02623152f, -0.04170373f, 0.01774065f, -0.03132910f, 0.02339450f, -0.01081552f, 0.01484024f, 
    0.00066952f, -0.01376374f, 0.02513421f, -0.03508123f, -0.02047564f, -0.02268694f, -0.02000015f, 0.01183664f, 
    0.01549875f, -0.00574855f, -0.02154057f, 0.01777302f, -0.02900754f, -0.01178765f, -0.01604599f, -0.03906950f, 
    -0.02247446f, -0.01965252f, -0.03448480f, 0.02122994f, 0.01477026f, -0.02650668f, -0.00102205f, -0.03362764f, 
    -0.03565200f, 0.00305137f, 0.02084425f, -0.01279735f, -0.02857088f, -0.01052632f, 0.00778630f, -0.03151308f, 
    0.00956921f, -0.04049357f, -0.03303304f, 0.02089681f, 0.01630108f, -0.01005865f, 0.00520498f, 0.02636024f, 
    0.01425471f, 0.00938835f, 0.00147518f, -0.02943218f, -0.00239155f, 0.01885146f, 0.01400378f, -0.01060616f, 
    -0.00685689f, -0.01148024f, 0.02901919f, -0.02696186f, 0.02672096f, 0.02105678f, -0.00152981f, 0.00295827f, 
    0.00525407f, -0.03478712f, 0.02045869f, 0.01976274f, -0.02738096f, -0.02896580f, -0.00620088f, -0.03066747f, 
    0.00843802f, -0.00097311f, 0.00014915f, 0.02181003f, 0.01587582f, -0.03411988f, 0.01059447f, -0.01412095f, 
    -0.00143784f, -0.04189745f, -0.02884557f, -0.01918335f, -0.02000276f, -0.01457694f, 0.00594245f, -0.01748135f, 
    0.02344595f, 0.00766140f, 0.00410009f, -0.02076479f, -0.02907165f, -0.04070545f, 0.00096674f, -0.00818968f, 
    -0.03953806f, 0.02744514f, -0.02633241f, 0.00327032f, 0.01640484f, -0.02913308f, 0.01681229f, -0.01896808f, 
    0.02164365f, 0.00425036f, -0.02908645f, -0.00684822f, -0.01425030f, 0.00493654f, 0.01221424f, -0.01578458f, 
    -0.01579216f, 0.02232445f, -0.03348048f, 0.01076305f, 0.00376359f, -0.00658040f, 0.02301523f, -0.03085950f, 
    -0.03078236f, -0.01059689f, -0.03061401f, -0.01324952f, -0.00419012f, -0.03819630f, 0.01654954f, -0.00382804f, 
    -0.03313099f, -0.02842441f, -0.02877081f, -0.01183091f, 0.01799812f, 0.02521248f, -0.03953943f, -0.00643141f, 
    -0.03204744f, -0.03823864f, -0.00515343f, -0.01821163f, -0.01409483f, 0.01287394f, 0.00504056f, -0.02668561f, 
    -0.00235657f, 0.02119085f, -0.00566724f, -0.02090397f, 0.00862661f, -0.02407246f, -0.01373469f, -0.03902473f, 
    -0.04252720f, -0.03503767f, -0.03006828f, 0.02272940f, 0.02201096f, -0.02100687f, -0.01986114f, -0.03612830f, 
    -0.03279937f, -0.03228915f, 0.02594649f, -0.01520465f, 0.00183485f, -0.04180698f, -0.02300452f, 0.00570454f, 
    0.01585046f, -0.00787862f, -0.00180062f, -0.00346357f, -0.03396305f, -0.00802749f, -0.02903123f, 0.00713015f, 
    0.00321465f, 0.02885727f, -0.04147302f, -0.03048729f, 0.00036912f, -0.02502122f, 0.00363888f, 0.01465743f, 
    -0.04049011f, 0.01781145f, 0.01941336f, -0.03631783f, -0.01050733f, -0.00353820f, -0.00353695f, -0.02156329f, 
    0.00374648f, -0.00007633f, -0.01057573f, -0.00631843f, 0.00715588f, -0.02363414f, 0.00701547f, -0.00722756f, 
    -0.03055171f, -0.02266173f, -0.02292894f, -0.00299013f, -0.01625769f, -0.01227392f, 0.02864849f, -0.01069905f, 
    0.01818328f, -0.01321493f, -0.03958946f, 0.02868412f, 0.01684023f, 0.01844581f, 0.00015679f, -0.01907249f, 
    0.00242246f, 0.01612295f, -0.01410390f, 0.00464802f, 0.01187793f, 0.01344641f, -0.01412741f, -0.01222959f, 
    -0.01997961f, 0.02103663f, 0.01241558f, -0.03978954f, -0.03785976f, -0.04127518f, 0.00110889f, 0.01854673f, 
    0.00188408f, -0.02782680f, -0.03603277f, -0.03009247f, -0.00244311f, -0.03216730f, -0.04242032f, 0.02477328f, 
    -0.03288615f, -0.00161436f, 0.01607129f, -0.02197205f, 0.00931142f, 0.00202195f, -0.03034138f, 0.01924635f, 
    -0.01701206f, -0.01438553f, 0.01688578f, -0.03607748f, -0.02952619f, -0.02595972f, 0.00597556f, -0.00896623f, 
    0.01858448f, -0.01448446f, -0.04075379f, 0.01760307f, 0.02035148f, 0.02873421f, -0.02054936f, 0.00014723f, 
    0.02141887f, -0.00747656f, -0.02844114f, 0.01605169f, -0.00413655f, -0.01696941f, 0.00930097f, -0.03855361f, 
    -0.02177169f, 0.02787280f, -0.03751470f, -0.02586834f, -0.00012383f, 0.01835728f, -0.00999063f, -0.00247278f, 
    0.03008192f, 0.03841111f, 0.09506182f, 0.22402701f, -0.01942465f, 0.03602491f, -0.00057311f, 0.01948556f, 
    0.02020222f, -0.05310686f, 0.02381819f, 0.01689493f, 0.02853194f, 0.01271954f, 0.01090400f, -0.10942294f, 
    -0.27396405f, -0.05220382f, 0.04422792f, 0.02838011f, 0.06546103f, 0.01444880f, 0.10083059f, -0.07264622f, 
    0.04438516f, 0.28661293f, 0.02727016f, 0.05579386f, 0.07062291f, 0.12625951f, -0.00841457f, -0.17376024f, 
    0.05003959f, 0.05207018f, 0.01938278f, -0.05995543f, 0.03409898f, 0.33585876f, -0.12101246f, 0.09753963f, 
    -0.00646579f, -0.04355114f, 0.13499694f, -0.00884836f, 0.07373936f, 0.07840673f, 0.07866410f, 0.07086291f, 
    0.16861346f, -0.03624214f, -0.04111740f, 0.01062826f, 0.00440487f, -0.03204202f, 0.01528254f, -0.01431483f, 
    0.07453877f, 0.05086400f, 0.00973456f, 0.05645974f, -0.05010357f, 0.07855438f, 0.08505429f, -0.05389268f, 
    -0.14580585f, 0.01601093f, 0.01082387f, 0.02182161f, 0.08094535f, -0.10330133f, -0.01408625f, 0.07475132f, 
    0.14812149f, -0.01990208f, 0.15596630f, -0.07616244f, -0.01238512f, -0.01129246f, -0.03147594f, -0.06375199f, 
    0.03426865f, 0.06722043f, -0.03985352f, -0.13323329f, -0.43793491f, 0.31789023f, 0.07472821f, -0.05720986f, 
    0.04881486f, 0.12967981f, -0.12647472f, 0.08221649f, -0.01451166f, -0.03477005f, -0.00311692f, -0.02742722f, 
    0.11391254f, 0.06641505f, 0.08991383f, -0.02130815f, 0.07919654f, 0.10660035f, 0.06979575f, -0.10327547f, 
    0.07480182f, 0.04859269f, -0.04139724f, 0.03521619f, -0.10620147f, -0.19504645f, 0.13977762f, 0.09850149f, 
    0.05365840f, -0.03246537f, 0.01695392f, 0.08604710f, 0.18793355f, -0.00220652f, 0.07787389f, 0.00386720f, 
    -0.11165444f, -0.05947679f, 0.20651096f, 0.12027489f, -0.10461444f, -0.08595711f, -0.08141736f, 0.02420893f, 
    -0.13785502f, 0.03670910f, 0.04232452f, 0.01354048f, -0.00702906f, -0.07107876f, 0.13075861f, 0.15669240f, 
    0.06567755f, -0.01231581f, 0.11996018f, 0.03019000f, -0.03179492f, 0.01882116f, -0.00048842f, -0.05569076f, 
    -0.05844075f, 0.28112575f, 0.03405404f, 0.11596458f, -0.02640121f, -0.09061532f, -0.09614374f, 0.01959579f, 
    0.03161903f, -0.03313882f, -0.05445627f, 0.05505637f, -0.09669559f, 0.08184958f, 0.03692659f, -0.10500164f, 
    -0.09263342f, -0.03573963f, -0.01912864f, -0.06058799f, 0.01004567f, -0.01607483f, -0.02303509f, 0.11777823f, 
    0.42434391f, -0.24766554f, -0.10172799f, -0.02125392f, 0.06083184f, 0.03331568f, 0.00814312f, 0.04842338f, 
    0.01414663f, 0.04179054f, 0.04494538f, 0.11398977f, 0.05205142f, 0.11135715f, 0.08109093f, 0.00099342f, 
    -0.06825805f, -0.07113974f, -0.02028389f, -0.06410934f, -0.02403076f, -0.02621845f, -0.05717226f, 0.06885555f, 
    0.19904765f, -0.07908856f, 0.08208531f, 0.17095511f, 0.05349043f, -0.00758058f, 0.15184602f, -0.00662566f, 
    -0.01465033f, 0.01945113f, -0.02202071f, -0.10809382f, 0.21682635f, -0.04080881f, 0.15028237f, 0.14569007f, 
    -0.03156007f, -0.05694383f, -0.02309394f, 0.06376770f, -0.08721207f, 0.02395806f, 0.04899164f, -0.08150177f, 
    0.02273645f, 0.06704425f, 0.05201030f, 0.00067035f, 0.09654286f, 0.03507908f, 0.07578617f, 0.11111165f, 
    0.10899990f, 0.02729727f, 0.09345420f, 0.07246280f, 0.00282648f, -0.27629960f, 0.22058502f, 0.25460988f, 
    0.08598001f, 0.07548143f, -0.01748177f, 0.02247074f, -0.05198054f, -0.11916805f, -0.11133609f, -0.04989072f, 
    -0.15753403f, 0.06078047f, -0.11073389f, -0.25084877f, 0.14864784f, -0.01021932f, 0.07854706f, -0.03219739f, 
    0.07390495f, -0.02402127f, -0.05739960f, 0.06521937f, -0.06381680f, -0.05277588f, 0.25261375f, 0.11754786f, 
    0.07142932f, -0.04511539f, -0.05039521f, -0.06599560f, 0.06881620f, 0.12461353f, 0.04001693f, 0.07685512f, 
    -0.06989677f, 0.23026793f, 0.10212640f, 0.05532932f, -0.13758470f, 0.02471191f, 0.10130841f, 0.04493953f, 
    -0.05787938f, -0.00034079f, 0.09036031f, 0.00437355f, 0.03213339f, -0.15894257f, 0.18095207f, 0.14662492f, 
    -0.01737987f, -0.05832116f, 0.11543665f, -0.00918039f, 0.03059393f, 0.05409388f, 0.04326004f, 0.05981073f, 
    0.43747202f, -0.00703368f, 0.00645608f, 0.18476038f, 0.22727783f, 0.14844078f, -0.02033796f, -0.01901046f, 
    -0.08802442f, -0.02099853f, 0.02793297f, -0.06154871f, -0.05535311f, 0.15816917f, 0.10964325f, 0.13331716f, 
    -0.13108708f, 0.07919996f, -0.07161019f, -0.00920568f, 0.08988601f, -0.10969820f, -0.04505090f, -0.01419215f, 
    0.01642062f, 0.00771808f, 0.25068381f, 0.26490018f, 0.13645436f, 0.12919965f, -0.00706033f, 0.04375986f, 
    0.01336070f, -0.06216929f, 0.00676816f, 0.04883482f, -0.15760699f, -0.12990716f, -0.03013453f, -0.00695037f, 
    0.19426139f, 0.04361794f, 0.05832054f, 0.08598804f, 0.06921461f, 0.05352150f, 0.03072958f, 0.01272884f, 
    0.17436968f, 0.14868757f, 0.18529838f, -0.02251671f, -0.04926745f, 0.05534302f, 0.06107719f, -0.00774945f, 
    0.03346283f, -0.02359229f, -0.11734167f, 0.02688623f, -0.10469656f, 0.07547454f, 0.13844329f, -0.06824123f, 
    -0.08855710f, -0.09619560f, -0.05226874f, -0.02239568f, 0.01873504f, -0.05718247f, 0.03726878f, -0.01292339f, 
    -0.29938585f, -0.11445317f, 0.01346530f, 0.00738420f, -0.02138251f, 0.03502304f, 0.08120497f, 0.01769529f, 
    -0.10700006f, 0.02041462f, 0.02763297f, 0.17555577f, -0.18225172f, 0.19892201f, -0.05003932f, -0.09039202f, 
    0.02664721f, 0.04712342f, -0.00875230f, -0.00444164f, -0.04022779f, 0.01629254f, 0.01100981f, 0.02233068f, 
    -0.33743036f, 0.09063028f, 0.04503932f, -0.02920450f, 0.02214961f, 0.11279605f, 0.06539923f, -0.06601349f, 
    0.04798024f, 0.00014699f, 0.01269551f, 0.02204215f, -0.17248809f, -0.08192238f, 0.14120719f, -0.10144441f, 
    -0.05293053f, 0.02792889f, -0.08236189f, -0.16792707f, 0.12023618f, -0.04420953f, 0.01253697f, -0.03392955f, 
    0.15846922f, -0.04958981f, -0.01375049f, -0.07232837f, -0.06901480f, -0.03460230f, -0.00298040f, -0.10005309f, 
    0.00781752f, 0.06708356f, -0.07578880f, 0.02926796f, -0.13447042f, 0.04890609f, 0.01038891f, -0.03857235f, 
    -0.11941871f, -0.02824602f, -0.01347228f, -0.10892282f, 0.05275220f, 0.05585863f, 0.11815749f, -0.00413110f, 
    -0.09255422f, 0.08922902f, 0.22108142f, 0.04583172f, -0.05266492f, -0.11297709f, -0.10032384f, -0.08040727f, 
    0.09636842f, 0.00451198f, -0.04193031f, 0.04447629f, -0.03627665f, -0.06031667f, 0.02706656f, -0.17529237f, 
    0.06919394f, 0.02431690f, -0.04592644f, -0.04191094f, -0.07661140f, -0.03769990f, -0.00766708f, -0.06779336f, 
    -0.04389865f, -0.05896364f, 0.04511527f, 0.02222552f, -0.05725500f, 0.06594918f, -0.00467056f, -0.01305631f, 
    0.07743738f, 0.02767720f, -0.04378402f, -0.06967939f, -0.26648223f, -0.05816633f, 0.20775963f, -0.05116984f, 
    -0.07293066f, -0.00264703f, 0.01427266f, -0.01760217f, 0.10756777f, -0.01381948f, -0.10588682f, 0.06532552f, 
    -0.41707829f, -0.05429706f, 0.04277146f, -0.01262546f, 0.14574586f, 0.10631929f, 0.11905555f, 0.00051890f, 
    0.09031793f, -0.03815134f, 0.06378724f, -0.01810127f, -0.36457425f, -0.10133488f, 0.10413349f, 0.06635369f, 
    0.15883702f, 0.13252619f, -0.07100675f, -0.08089276f, 0.06882234f, 0.08119597f, 0.06368874f, 0.02455342f, 
    -0.26919755f, 0.04307267f, 0.10541092f, 0.00714215f, 0.16261531f, 0.15193294f, 0.03029378f, 0.03489648f, 
    0.01454994f, -0.05433425f, 0.00682072f, 0.09075680f, -0.13138700f, 0.07043912f, 0.09074841f, -0.01369115f, 
    0.03619503f, 0.08420855f, 0.03459011f, -0.05858986f, 0.04995820f, -0.00436011f, 0.01185207f, -0.03059266f, 
    -0.45254204f, 0.36001381f, 0.00616399f, -0.07986703f, 0.05732077f, 0.01006194f, -0.09986565f, -0.02851986f, 
    -0.03732448f, 0.14182390f, -0.05291045f, -0.08514590f, -0.05871000f, 0.29879609f, -0.04435322f, -0.07111243f, 
    0.00768196f, -0.11216295f, 0.08551262f, 0.02151660f, 0.06453274f, 0.09639395f, 0.02735741f, 0.02466065f, 
    0.33920321f, -0.19704802f, -0.01749898f, 0.00229723f, 0.02486653f, -0.08304176f, -0.13340151f, 0.00416551f, 
    -0.00106420f, 0.18232785f, 0.02520247f, 0.01552987f, -0.28298420f, 0.25700283f, 0.29171276f, -0.15401693f, 
    -0.11292145f, 0.03007379f, 0.00494129f, -0.03348129f, -0.02110171f, -0.04215049f, 0.01623664f, 0.07598780f, 
    -0.25765085f, 0.00291890f, 0.07519992f, -0.03157256f, 0.17867136f, 0.08355553f, 0.20159929f, 0.02107439f, 
    -0.01381978f, 0.08325616f, 0.11045413f, 0.00914915f, 0.22183129f, -0.17625304f, 0.04011112f, 0.03146864f, 
    -0.16123913f, 0.05840668f, -0.10888774f, -0.07603793f, -0.04002273f, -0.03517528f, 0.05802764f, -0.19471167f, 
    0.01695306f, -0.06235537f, 0.04867185f, -0.01110980f, 0.02717382f, -0.01610787f, 0.01895783f, -0.04312441f, 
    0.07229863f, -0.05933423f, 0.04158981f, 0.01951672f, 0.22983436f, 0.02772014f, -0.09388620f, -0.10735492f, 
    -0.03675597f, 0.04293301f, -0.06357309f, 0.11615860f, 0.03450033f, -0.07031267f, 0.10860871f, -0.01107032f, 
    -0.45287392f, 0.06483696f, 0.13774262f, 0.07916987f, -0.02694733f, -0.03763307f, 0.01249575f, -0.01100514f, 
    0.07956111f, 0.08881122f, -0.01263303f, 0.03885128f, -0.15934736f, 0.15350175f, -0.06719956f, 0.17545974f, 
    -0.11954615f, 0.04141584f, -0.00148058f, -0.06327698f, 0.07757681f, -0.05174351f, 0.04871410f, 0.02629883f, 
    -0.02887942f, 0.07494781f, 0.00349151f, 0.00897903f, -0.08273838f, -0.03539487f, 0.01762761f, 0.14106333f, 
    0.03394844f, 0.04002242f, 0.05854031f, 0.04835807f, -0.36322615f, 0.14485121f, -0.02091572f, 0.04840386f, 
    0.12740169f, 0.07030917f, -0.03378046f, 0.04380142f, 0.01703590f, 0.09751549f, 0.04079027f, 0.06000086f, 
    -0.11816742f, 0.11538848f, 0.16647665f, -0.01085507f, -0.11260082f, -0.14746128f, -0.04034852f, 0.10967384f, 
    0.12771177f, 0.10981587f, -0.01689182f, 0.04407450f, -0.19085585f, -0.06467783f, 0.08384727f, 0.10567794f, 
    -0.01368283f, -0.02097082f, 0.04120127f, -0.08077029f, -0.03549200f, -0.07639124f, -0.06528465f, -0.10253293f, 
    -0.28441259f, 0.04713339f, 0.10312145f, -0.07343559f, 0.17728232f, 0.03668798f, -0.02169665f, 0.01811264f, 
    -0.01983925f, 0.16942023f, -0.01932536f, -0.00374242f, -0.10774893f, 0.03280593f, -0.03583224f, -0.05681536f, 
    0.11244692f, 0.05554948f, -0.02832643f, 0.00407302f, -0.02223746f, 0.04327148f, 0.01755450f, -0.08049370f, 
    0.26401934f, -0.01525971f, -0.02545823f, 0.00507250f, 0.10495247f, -0.05388776f, 0.01773874f, -0.03302905f, 
    -0.04815440f, -0.15052892f, -0.04458029f, 0.05058754f, -0.11835255f, 0.12732132f, 0.07594310f, 0.17183681f, 
    0.05388914f, 0.07873434f, -0.00420454f, -0.03665951f, 0.06005628f, -0.11753133f, -0.04795051f, 0.06365362f, 
    0.17803156f, 0.16194129f, -0.05238301f, 0.17180398f, 0.07321589f, 0.01914310f, 0.00168189f, 0.06070024f, 
    0.05793608f, 0.00296748f, 0.06529191f, -0.08072671f, 0.09897434f, -0.04753231f, 0.00186453f, 0.29175135f, 
    0.04115625f, -0.13471198f, -0.04155780f, 0.03797733f, -0.01508287f, 0.10365929f, 0.05089418f, 0.04221847f, 
    -0.02131516f, -0.01703702f, 0.01438165f, 0.01307246f, -0.01456912f, -0.02696759f, -0.00990136f, -0.03299728f, 
    0.01014481f, -0.02822704f, 0.02801037f, 0.01037327f, 0.02413106f, -0.00085459f, -0.02561808f, 0.01883622f, 
    -0.03512989f, -0.04239489f, -0.02532374f, 0.02148845f, -0.04421856f, -0.00062858f, -0.01964820f, -0.03220217f, 
    0.04251591f, -0.01061612f, -0.03491456f, 0.00599503f, 0.02257528f, 0.00126570f, -0.01870142f, -0.02092465f, 
    0.01081452f, -0.01436900f, 0.03322239f, 0.00105452f, -0.02539292f, -0.01881706f, 0.00562834f, -0.00213710f, 
    -0.03201726f, 0.01668054f, 0.00282807f, -0.02937879f, 0.00743107f, 0.03090747f, -0.02310037f, 0.00800244f, 
    0.01754588f, -0.00716722f, -0.00318486f, 0.02028460f, -0.00029255f, -0.02263645f, 0.00431966f, -0.02494789f, 
    -0.01099021f, -0.03806487f, -0.02397390f, -0.03576578f, -0.02146698f, -0.04135878f, -0.01037839f, -0.02024914f, 
    -0.03710548f, -0.00196907f, -0.02089287f, -0.00548165f, 0.01187205f, -0.01010999f, 0.00546207f, 0.01164375f, 
    -0.00660594f, -0.01114428f, -0.00603703f, -0.02276427f, -0.00149682f, 0.02816761f, 0.00247706f, 0.01307159f, 
    0.00234460f, -0.02357251f, 0.00604931f, 0.01032380f, -0.02136520f, 0.00656869f, -0.03568889f, -0.01227988f, 
    0.02558033f, -0.02046429f, 0.00017347f, 0.02713971f, -0.02088042f, 0.02078466f, 0.01341737f, 0.00599592f, 
    0.02960638f, -0.00818152f, -0.01301695f, 0.03097448f, 0.02394720f, -0.03675669f, 0.01260545f, -0.02697582f, 
    0.00749964f, 0.00306787f, -0.03481850f, 0.00182907f, 0.00610981f, -0.01539893f, -0.01523012f, 0.02824844f, 
    -0.03495513f, -0.03116709f, -0.01659597f, 0.00264168f, 0.00210506f, 0.00407371f, -0.03933560f, 0.00895491f, 
    -0.03810381f, -0.02482560f, -0.01611718f, 0.01542530f, 0.01349588f, -0.01645320f, -0.00746974f, -0.01972049f, 
    -0.00103128f, -0.01456793f, -0.03229317f, -0.03110408f, -0.01196304f, 0.01369954f, -0.00078143f, 0.02014949f, 
    -0.01877911f, -0.00867326f, 0.01694135f, 0.00209995f, -0.00842548f, -0.01540476f, -0.03464805f, 0.00761383f, 
    0.01918346f, -0.02652458f, 0.02037138f, 0.01516307f, 0.01492792f, -0.01154783f, 0.00915449f, 0.02467535f, 
    -0.01363589f, -0.04145099f, -0.03972597f, -0.01442989f, 0.02840416f, 0.00362635f, -0.00485467f, -0.00693844f, 
    -0.03172687f, 0.01301147f, 0.02176761f, 0.02850034f, -0.02814624f, -0.00737623f, 0.03211942f, -0.00946317f, 
    -0.04616377f, 0.00002735f, -0.03056114f, -0.02380894f, 0.01989182f, -0.04188976f, 0.00443390f, -0.01353861f, 
    -0.03420343f, -0.02109810f, -0.02513809f, 0.01597862f, -0.04316441f, -0.02576851f, -0.01151380f, 0.00280003f, 
    0.02755624f, -0.03439157f, 0.02570424f, -0.03815616f, 0.00462852f, -0.00404834f, -0.04514359f, 0.01478211f, 
    -0.01310807f, -0.02256358f, 0.01759048f, -0.02296063f, -0.01069131f, 0.02134619f, -0.00973073f, 0.03203015f, 
    0.01321402f, -0.03958443f, -0.02905455f, 0.02676229f, 0.02859733f, -0.02792768f, -0.04212200f, -0.02793328f, 
    -0.02756317f, -0.04397211f, -0.00216974f, -0.03241157f, -0.03131217f, -0.03719248f, -0.01914532f, 0.01325692f, 
    0.00850460f, 0.01313284f, -0.03528073f, -0.03792174f, -0.03406809f, 0.00266170f, 0.01197843f, 0.01942875f, 
    0.00218411f, -0.04010342f, -0.01991783f, -0.03099079f, -0.02810265f, 0.03368482f, 0.00026519f, 0.02982336f, 
    -0.02250528f, -0.02215329f, 0.02982652f, 0.00729897f, -0.03638342f, -0.02068684f, 0.02232147f, -0.00095045f, 
    0.01951472f, -0.03119138f, 0.00018606f, -0.00308563f, 0.00260162f, -0.01687945f, 0.03102972f, -0.01712151f, 
    -0.02635880f, 0.00180542f, -0.00573924f, -0.01447660f, 0.03620634f, 0.01794842f, 0.03005238f, -0.00130126f, 
    0.02243508f, -0.00920184f, -0.03172826f, -0.01587676f, 0.01883466f, -0.01363247f, -0.02411939f, -0.02678149f, 
    -0.01077359f, 0.02727915f, 0.00328430f, -0.01272688f, -0.04055727f, -0.02542385f, 0.01207709f, -0.02306225f, 
    -0.00245269f, -0.01868449f, -0.04055873f, -0.00633694f, 0.00556872f, -0.01060375f, 0.00481153f, 0.00835979f, 
    -0.03407893f, -0.01897142f, -0.03921923f, 0.01781370f, 0.00091453f, 0.01150097f, -0.02056286f, -0.00439052f, 
    0.02976818f, -0.00306563f, 0.02153862f, 0.03466252f, 0.01119439f, -0.00405168f, -0.02813449f, -0.04403888f, 
    0.00763613f, 0.00231349f, -0.02711249f, -0.03263637f, -0.01468175f, -0.02526654f, -0.00314369f, -0.03269540f, 
    -0.00502663f, -0.01732773f, 0.03069534f, -0.03347614f, 0.00711624f, -0.03853586f, -0.02316480f, 0.01160371f, 
    0.02759259f, 0.01725361f, -0.01721645f, -0.01675119f, -0.01544019f, -0.03922043f, -0.01520780f, -0.00873888f, 
    -0.03610430f, 0.01540377f, -0.02535701f, 0.00791031f, 0.00852005f, 0.00724687f, 0.03070429f, -0.00458784f, 
    0.02721064f, -0.02766405f, 0.02339262f, 0.00032753f, -0.03734004f, -0.02302626f, -0.01091935f, 0.00608351f, 
    0.01128257f, -0.00584117f, -0.00090333f, -0.01419012f, 0.02567472f, -0.03770692f, -0.03016828f, -0.00816665f, 
    -0.02938238f, 0.00431218f, 0.00811681f, -0.01343021f, -0.03829039f, -0.00567236f, -0.01588364f, -0.03206669f, 
    -0.03472113f, 0.01736056f, 0.02118437f, 0.01403814f, 0.03035321f, -0.02208341f, 0.02545058f, 0.01216182f, 
    -0.03363863f, -0.04629644f, -0.02664743f, 0.01593305f, -0.00594385f, 0.03076146f, 0.01643210f, -0.00284300f, 
    0.00411672f, 0.01329067f, -0.01940245f, -0.02206245f, -0.02669030f, 0.01872029f, -0.02534906f, -0.03382174f, 
    -0.03338928f, -0.03080185f, -0.03484548f, -0.02971729f, 0.02705541f, -0.02420126f, -0.03892274f, -0.02730833f, 
    -0.03512932f, 0.00068226f, 0.03938361f, -0.03208300f, -0.02818838f, 0.02447382f, 0.01310503f, -0.04143785f, 
    0.01290216f, -0.02743689f, -0.02150502f, 0.02037468f, -0.01846549f, 0.01494666f, -0.00510585f, 0.01156381f, 
    -0.01250866f, -0.01276220f, 0.01615867f, 0.00617748f, 0.00082083f, 0.01802944f, -0.02030334f, -0.02228544f, 
    -0.00985259f, 0.01279061f, -0.01954154f, 0.01397657f, -0.00359666f, 0.00024887f, -0.03118030f, -0.00335193f, 
    0.02645955f, -0.01826771f, 0.02907863f, 0.02925752f, 0.00182255f, -0.01500119f, -0.00961665f, 0.02747228f, 
    0.03201250f, 0.02716860f, 0.01867133f, 0.02918842f, -0.03954474f, 0.00215171f, -0.00869047f, -0.02565561f, 
    0.01555353f, -0.01261827f, -0.00118663f, -0.02690434f, 0.00160006f, -0.03369171f, -0.02169491f, -0.04126558f, 
    -0.03448785f, -0.00330103f, -0.01969950f, -0.03300417f, -0.01491178f, 0.01164257f, -0.00444032f, 0.01164636f, 
    0.00302266f, -0.00221783f, -0.00579123f, -0.02977649f, -0.00454695f, 0.01277232f, 0.02117565f, 0.01485288f, 
    -0.03012529f, -0.01649351f, 0.00881109f, -0.03310835f, -0.01485614f, -0.00638181f, -0.01381301f, 0.00525570f, 
    -0.00915010f, 0.00038368f, 0.01623572f, -0.00845213f, 0.02109692f, -0.02407862f, 0.01176145f, -0.02684348f, 
    0.02448625f, -0.00118352f, 0.00143215f, 0.01119075f, -0.03083473f, 0.02673289f, 0.01102570f, 0.01248663f, 
    -0.01730573f, -0.01604406f, -0.03026650f, 0.02133671f, -0.02944027f, -0.01513156f, 0.02253987f, 0.00477989f, 
    0.02847395f, 0.00636769f, -0.00120609f, 0.02407215f, -0.02803699f, -0.00500502f, 0.00445548f, 0.03936521f, 
    -0.00111231f, -0.00317190f, 0.02395429f, 0.00907025f, -0.03417885f, 0.01721136f, 0.00711453f, -0.02555482f, 
    -0.02593433f, 0.02051664f, -0.01240401f, -0.01406582f, 0.02591625f, 0.02590377f, 0.00915741f, -0.02010318f, 
    0.00591660f, 0.03100963f, -0.03490232f, 0.01232662f, 0.02578608f, 0.01340763f, -0.03623999f, -0.00268471f, 
    0.00196796f, 0.00882124f, -0.02881759f, -0.01078150f, -0.03591515f, 0.02330635f, 0.00190551f, 0.01270577f, 
    -0.03483693f, 0.02388744f, -0.00622409f, -0.03071111f, -0.02152994f, 0.01662187f, 0.02802300f, 0.00353227f, 
    0.01066643f, 0.01063805f, -0.02134033f, -0.00794846f, 0.01803768f, 0.00687936f, 0.01105368f, -0.03222686f, 
    -0.02274061f, -0.03860309f, 0.02125991f, -0.02058135f, -0.00802917f, -0.03062086f, -0.03570048f, 0.01650123f, 
    -0.02291823f, 0.01902288f, -0.01436267f, -0.03367229f, -0.03922448f, -0.00883029f, 0.02702789f, 0.02881031f, 
    -0.00545027f, 0.02209987f, 0.01258282f, -0.01163190f, 0.02277468f, 0.01158624f, 0.02363311f, 0.01480906f, 
    -0.00253869f, 0.02536382f, -0.00465020f, 0.02436205f, -0.00685640f, -0.00919443f, 0.01176589f, -0.00201493f, 
    -0.01059472f, 0.01534157f, 0.03659363f, -0.01470289f, -0.02876796f, 0.03412473f, 0.02666876f, -0.01397152f, 
    0.02149728f, 0.01539071f, -0.03457997f, -0.00074466f, -0.00910171f, 0.01420512f, -0.02496248f, 0.02116104f, 
    -0.01849674f, -0.01594899f, 0.01491154f, 0.01435783f, 0.02669305f, -0.00415111f, -0.02834237f, 0.02457035f, 
    -0.00219886f, -0.01871025f, 0.00029749f, -0.04365887f, 0.00951788f, 0.01740527f, -0.00509026f, -0.00938612f, 
    0.02257986f, 0.00659222f, 0.02824424f, 0.02634880f, 0.02330022f, -0.01763540f, -0.04030135f, 0.01855875f, 
    0.03272989f, -0.02978863f, 0.00636790f, -0.02839567f, -0.03506010f, -0.01397335f, -0.00631320f, -0.01879979f, 
    0.00937518f, 0.03005340f, 0.01372529f, -0.00136720f, -0.00107675f, 0.02545094f, -0.02058537f, -0.01495628f, 
    0.00809670f, 0.02301707f, 0.02358806f, 0.02442326f, -0.03085068f, -0.04506970f, -0.01593029f, -0.02263496f, 
    0.03382469f, -0.02314096f, -0.04397880f, -0.02158251f, 0.01237668f, 0.02456157f, -0.00819112f, 0.00950448f, 
    -0.03462150f, 0.02476862f, -0.01988097f, 0.02032748f, 0.00797524f, -0.01605562f, -0.04219707f, -0.04092796f, 
    -0.01358425f, -0.01797909f, 0.01462945f, -0.01925211f, -0.01427476f, -0.02623357f, -0.01292486f, 0.00088307f, 
    0.00042630f, 0.01791183f, -0.02265587f, -0.02167292f, -0.03592798f, 0.00611264f, 0.02048037f, 0.01341362f, 
    -0.00098637f, -0.00626828f, -0.03999976f, 0.00401671f, 0.00322050f, 0.02731497f, -0.03966638f, -0.04410200f, 
    0.00300673f, 0.02667435f, 0.00521185f, 0.01132377f, 0.01502716f, -0.01049457f, -0.03014819f, 0.00131699f, 
    0.02059535f, 0.01611401f, -0.02629884f, 0.02534713f, 0.00793378f, -0.01030216f, -0.03395014f, 0.02481823f, 
    0.00052009f, 0.02594107f, -0.00495398f, -0.01635347f, 0.02791305f, 0.01434776f, 0.02689758f, 0.01069455f, 
    -0.00903393f, -0.03286778f, 0.01414689f, 0.00355990f, -0.03044709f, -0.00977575f, -0.00585981f, -0.03094863f, 
    -0.03070031f, 0.01061749f, 0.03288441f, -0.03796867f, -0.03562878f, 0.00365344f, -0.01892490f, -0.02518262f, 
    0.00849775f, 0.00610575f, 0.02380849f, -0.00595810f, 0.01845411f, -0.01351493f, -0.00756423f, 0.01271268f, 
    -0.00712944f, -0.02115648f, -0.02667172f, -0.03421987f, -0.01951494f, -0.00349343f, 0.00349681f, -0.01248096f, 
    0.00659986f, 0.00828275f, -0.03010190f, 0.01798711f, 0.01758163f, 0.00622161f, -0.01389912f, -0.00054643f, 
    0.00667197f, 0.03049676f, -0.03087348f, -0.01687128f, -0.00034063f, -0.02939041f, -0.00730948f, 0.01241326f, 
    0.00092877f, -0.02445998f, -0.02705997f, -0.02461797f, -0.03456545f, 0.02675769f, 0.02826442f, 0.01747381f, 
    -0.00859373f, -0.02744954f, -0.02920165f, 0.01754525f, -0.03237299f, -0.00831747f, -0.00753830f, 0.03246916f, 
    -0.01439461f, 0.00363183f, -0.00171749f, -0.01463784f, -0.01798541f, -0.01133081f, 0.00500289f, -0.03731032f, 
    0.00433899f, 0.00581556f, 0.01874406f, -0.00070614f, 0.02037928f, 0.00735239f, -0.01209174f, -0.00730932f, 
    -0.01666374f, -0.01521570f, 0.00901140f, -0.00440527f, -0.02023104f, -0.03706628f, -0.04022644f, -0.00008235f, 
    0.02450011f, -0.01883247f, -0.03549289f, -0.00107015f, -0.00182524f, 0.01058524f, -0.03072345f, -0.03790033f, 
    0.00306896f, 0.00890726f, 0.01439433f, -0.02893071f, -0.00531832f, 0.01192396f, 0.02773882f, -0.03703716f, 
    0.01463594f, -0.03826240f, -0.00250054f, -0.00986500f, -0.00701759f, -0.00488611f, 0.02143315f, -0.00762682f, 
    -0.02178112f, -0.00329401f, -0.00905648f, 0.02504012f, -0.02245847f, 0.02618892f, 0.00400051f, 0.02896888f, 
    0.00142590f, -0.02927824f, -0.02319683f, 0.02101279f, -0.03019769f, 0.02393111f, 0.02774453f, -0.01731541f, 
    0.02566881f, 0.00650284f, 0.02677768f, -0.03024304f, -0.00909516f, -0.01121842f, -0.02695689f, 0.01825995f, 
    0.03087352f, 0.01135418f, 0.00229980f, -0.03196109f, 0.01054152f, -0.01271833f, -0.03484635f, 0.02222005f, 
    -0.03706971f, -0.01166649f, -0.02804653f, -0.00828490f, 0.00470475f, -0.00393887f, 0.01741428f, -0.03729398f, 
    -0.00647842f, -0.01004351f, 0.01415319f, -0.01336866f, 0.01424526f, 0.01987769f, -0.02765553f, 0.02558929f, 
    -0.03045888f, -0.00325782f, 0.00556145f, -0.00555082f, -0.00612007f, -0.00143917f, 0.00754799f, -0.00782330f, 
    0.00048232f, 0.02661752f, -0.04144039f, -0.04126874f, -0.02670579f, 0.00461660f, 0.01661289f, 0.01241161f, 
    0.01150942f, -0.02033938f, 0.00930393f, 0.00885403f, -0.00481734f, 0.01540636f, -0.02880756f, -0.00262380f, 
    -0.02853993f, 0.02923948f, -0.00474696f, -0.01194731f, -0.01620679f, -0.01728202f, 0.01084698f, 0.01112304f, 
    -0.00465028f, -0.02778325f, 0.02602030f, 0.00254008f, 0.02870231f, -0.02785431f, 0.01868167f, 0.00579520f, 
    0.02599607f, -0.00757224f, -0.01762360f, 0.01303816f, -0.01752997f, -0.03277401f, 0.02686863f, 0.02421737f, 
    0.00411923f, -0.01345105f, -0.03842930f, 0.02419746f, 0.02015890f, 0.02388778f, 0.02261005f, -0.03986797f, 
    0.02960447f, -0.03120690f, 0.01531336f, 0.01410506f, -0.00312661f, 0.00449100f, -0.01544574f, -0.00412357f, 
    -0.01244702f, -0.04012443f, 0.00786976f, 0.00168182f, 0.00453253f, 0.01639399f, -0.03479349f, 0.00904871f, 
    -0.03579849f, -0.00869965f, 0.02970480f, 0.01969827f, 0.02919144f, -0.01459304f, -0.00164063f, -0.01749352f, 
    0.00779291f, -0.00836974f, -0.01327927f, 0.01020078f, 0.01544637f, 0.01708831f, -0.00612440f, 0.01620786f, 
    0.00247889f, 0.00459908f, 0.00829671f, -0.02869337f, -0.03565542f, 0.01982298f, -0.02172056f, 0.00895648f, 
    0.02015395f, -0.01674759f, -0.00688756f, 0.02015028f, -0.00091988f, -0.03792701f, -0.03216228f, 0.00432965f, 
    -0.02799874f, -0.01011651f, -0.00681919f, -0.00283054f, -0.00005317f, -0.01019174f, -0.03518106f, -0.02087365f, 
    0.00309899f, -0.03946383f, -0.03435744f, 0.01241027f, 0.00311870f, -0.00342585f, -0.02810435f, 0.01825711f, 
    -0.02440499f, 0.00943703f, 0.02234401f, -0.04291453f, 0.01840538f, -0.03789716f, -0.01683618f, 0.02624726f, 
    0.02779103f, -0.01880582f, -0.03001629f, 0.00156558f, 0.01814714f, 0.00739663f, 0.02116990f, -0.01532070f, 
    0.01995998f, -0.01192599f, -0.02861972f, -0.00148637f, 0.00027164f, 0.01064991f, -0.01406900f, -0.00853779f, 
    0.01457891f, -0.03643545f, -0.03963332f, 0.02052720f, 0.01820065f, 0.01228936f, -0.02356302f, -0.03028675f, 
    -0.02308602f, 0.01045579f, -0.00159593f, -0.01541869f, -0.00810455f, -0.03554025f, -0.01278064f, -0.03069455f, 
    -0.01343441f, 0.01592038f, 0.02489900f, -0.02800285f, 0.01860766f, -0.01073840f, 0.01059927f, -0.03020239f, 
    -0.01739519f, 0.02070934f, -0.00679879f, 0.02248826f, -0.03854533f, 0.02370650f, 0.01442479f, 0.01260924f, 
    -0.03491824f, 0.00751730f, -0.01944302f, 0.02581936f, -0.03316858f, 0.02989710f, -0.01220845f, -0.03306026f, 
    -0.01395732f, -0.02346686f, 0.00054784f, -0.03997375f, 0.02036403f, 0.02506611f, -0.01571709f, 0.01529520f, 
    -0.00560928f, -0.02251481f, 0.02726538f, -0.02882141f, 0.00039879f, -0.02941111f, -0.02781407f, -0.01780912f, 
    0.00938883f, -0.01612106f, 0.01989844f, 0.00646971f, 0.00166337f, -0.01785082f, -0.01851464f, -0.02660906f, 
    -0.02790632f, -0.01054540f, -0.03943129f, 0.02631228f, -0.01084365f, -0.03317291f, -0.00939982f, -0.00835831f, 
    -0.01933167f, 0.00223364f, 0.00454615f, -0.01200219f, -0.00980746f, 0.01049192f, -0.00459270f, -0.02173273f, 
    -0.01547917f, -0.04235531f, -0.00626919f, -0.03644805f, -0.00658577f, -0.03864975f, 0.01583632f, 0.00734034f, 
    -0.00772027f, 0.00484087f, -0.02822842f, 0.01173589f, -0.01470772f, -0.03334038f, 0.00099693f, 0.00429405f, 
    -0.03465991f, -0.02945775f, -0.01012508f, -0.04082246f, -0.04231436f, 0.01770102f, -0.01280897f, 0.01779507f, 
    0.01017143f, -0.02956454f, -0.01963464f, 0.02499095f, 0.00579555f, 0.03142214f, 0.00512670f, -0.02201437f, 
    0.00653912f, -0.01899823f, -0.01452330f, -0.01214657f, -0.01103079f, -0.00242298f, -0.03867701f, -0.02327469f, 
    -0.02591228f, -0.03800833f, 0.02365752f, 0.01118965f, 0.02856788f, -0.02369047f, -0.02205952f, -0.01828508f, 
    -0.03674497f, 0.01580671f, 0.01089897f, -0.03058309f, 0.02287205f, -0.03076284f, -0.04075938f, -0.03729222f, 
    0.00743080f, -0.00229549f, 0.01699924f, 0.00514099f, -0.00460776f, -0.02365617f, -0.01758704f, 0.03048532f, 
    0.02540803f, 0.03140008f, -0.04312003f, -0.04095587f, 0.00559378f, -0.01056012f, 0.00558719f, -0.02100361f, 
    -0.02257687f, -0.00586437f, 0.00754375f, -0.01792545f, -0.00995379f, -0.00826006f, -0.02679189f, -0.03146391f, 
    -0.00134404f, -0.01251470f, 0.02055490f, -0.03006400f, -0.03630188f, -0.03810973f, -0.00826710f, 0.02631781f, 
    0.01657785f, -0.03806934f, -0.02860671f, 0.01748802f, -0.01260428f, 0.01804860f, 0.02540164f, 0.00242550f, 
    0.00033208f, -0.04036092f, -0.00459595f, 0.02319765f, 0.02541946f, 0.00643036f, -0.00406828f, -0.01738862f, 
    -0.02655042f, -0.00706026f, -0.01251384f, -0.04246023f, -0.00312500f, -0.02298222f, -0.02615614f, -0.01118438f, 
    0.03021268f, 0.02930502f, 0.01304047f, 0.00435423f, -0.02638147f, -0.01786723f, 0.00464104f, -0.03042362f, 
    0.00471111f, -0.02153907f, -0.00400061f, -0.04195798f, 0.01347338f, 0.01303838f, 0.00119469f, 0.02661786f, 
    0.00541557f, -0.03781652f, 0.03033137f, 0.02509133f, -0.01709751f, -0.01086726f, -0.03968076f, 0.01479063f, 
    0.03079820f, -0.00787792f, 0.00620503f, 0.00475109f, -0.01059954f, -0.02172321f, -0.00618856f, -0.01848607f, 
    -0.03155296f, -0.03592680f, -0.01989530f, -0.03920367f, -0.01277637f, -0.01944225f, 0.01669238f, -0.00256284f, 
    -0.00825709f, 0.01035692f, -0.00306215f, 0.01086975f, 0.01232509f, -0.00916275f, -0.03727713f, -0.02207492f, 
    0.01434132f, 0.01616170f, -0.00571592f, 0.01807566f, 0.00285669f, -0.01779505f, -0.03367674f, -0.03095417f, 
    -0.02831346f, -0.01252834f, -0.03747045f, -0.02964958f, -0.02286399f, -0.03509565f, 0.01520555f, 0.00848699f, 
    0.02678400f, -0.00319499f, -0.03419182f, -0.02190306f, 0.01188701f, 0.01581712f, -0.03969923f, -0.03346255f, 
    0.00894026f, -0.00056423f, -0.01798360f, 0.00150699f, -0.00825141f, -0.01217818f, 0.01945466f, 0.00240190f, 
    0.00013538f, -0.00302597f, -0.02737519f, -0.02545961f, 0.00494935f, 0.00648457f, 0.02257195f, 0.02967487f, 
    -0.03244568f, -0.01313672f, -0.00955258f, 0.02785739f, -0.00919283f, 0.00033979f, -0.01496059f, 0.01968917f, 
    -0.03709195f, -0.02649155f, 0.00303192f, -0.01300355f, -0.02545848f, 0.00665226f, 0.02675492f, 0.01693876f, 
    0.00879887f, 0.00243886f, 0.00157794f, 0.01119758f, -0.02527898f, 0.00376351f, -0.04210100f, -0.04331401f, 
    -0.00149015f, -0.03248566f, -0.04073782f, -0.00523183f, -0.00106040f, 0.02072512f, -0.03068229f, -0.01183171f, 
    -0.00094039f, 0.00563494f, -0.02613347f, -0.00656700f, 0.01408537f, -0.01062175f, -0.04028003f, -0.03756837f, 
    0.01425735f, 0.01632904f, -0.02941594f, -0.00069225f, 0.02046573f, -0.00878699f, 0.03414674f, 0.02836487f, 
    -0.03339197f, -0.02430486f, -0.01278887f, -0.02498130f, -0.03369860f, 0.00313101f, 0.02781561f, -0.01061309f, 
    -0.03004834f, -0.00613461f, -0.02230553f, 0.01478875f, -0.00552162f, -0.03082174f, -0.03165974f, -0.03644623f, 
    -0.00397839f, -0.02924337f, 0.00133647f, -0.01561664f, -0.00046660f, -0.02981419f, -0.02410049f, 0.00663360f, 
    -0.03439568f, -0.01419776f, -0.02237823f, -0.01082061f, 0.01999342f, -0.01945042f, -0.02233121f, -0.01090211f, 
    -0.00048705f, -0.02489034f, 0.00203936f, -0.00258758f, 0.01875410f, -0.02837755f, -0.03139159f, 0.00787196f, 
    -0.02207928f, -0.01440470f, 0.02074632f, -0.02415159f, 0.00991879f, 0.01838416f, -0.00485197f, -0.03590370f, 
    -0.02851030f, -0.03299263f, -0.03491154f, -0.02817435f, 0.02852771f, 0.03025803f, -0.04415409f, 0.03327345f, 
    -0.00189482f, 0.02821467f, -0.03917390f, 0.00053714f, -0.01501587f, 0.01713985f, -0.02172767f, -0.01726273f, 
    -0.03798771f, 0.02384521f, -0.02308887f, -0.00929116f, -0.02413343f, 0.02301993f, 0.00771568f, -0.02611610f, 
    -0.00425424f, 0.01982320f, -0.03848949f, 0.00820135f, 0.02518150f, -0.02693340f, -0.04029863f, 0.03184204f, 
    -0.00868421f, 0.02398990f, 0.00888750f, 0.01774102f, -0.03503829f, -0.02017601f, 0.01272442f, -0.01040616f, 
    -0.02702708f, 0.02621115f, -0.01769074f, 0.01586401f, -0.01714107f, 0.00769469f, -0.00542867f, -0.01792924f, 
    0.02664769f, -0.00550668f, -0.01502029f, -0.01602394f, 0.00708126f, 0.01212558f, -0.00654466f, -0.02971830f, 
    -0.01686783f, 0.00230686f, 0.02089476f, -0.00641983f, 0.01061856f, -0.00614101f, -0.00491441f, -0.03310070f, 
    0.02338834f, -0.02160485f, -0.01544032f, 0.03058231f, 0.00749287f, -0.03674600f, -0.01995689f, 0.01912008f, 
    -0.02818608f, -0.00637051f, 0.02267495f, -0.01767724f, -0.01795420f, -0.03352426f, 0.01320477f, -0.03494834f, 
    0.01263635f, -0.02739579f, -0.02051630f, -0.04183952f, -0.00978200f, 0.02590572f, 0.00197323f, 0.02414193f, 
    -0.00939099f, -0.00680071f, 0.00097849f, -0.00021659f, -0.00955717f, -0.03280678f, -0.04020995f, -0.00748361f, 
    -0.02591277f, -0.01804527f, -0.02511502f, 0.02457561f, -0.00608669f, -0.00849711f, 0.02494905f, -0.01400526f, 
    -0.02060130f, 0.02065173f, 0.02550711f, 0.02032762f, -0.03805780f, 0.02879968f, -0.02911036f, -0.00422108f, 
    -0.02546026f, -0.01251207f, -0.01263234f, 0.01815162f, -0.04273446f, 0.01791078f, -0.03236122f, 0.03478877f, 
    -0.00484142f, -0.00454069f, 0.01265637f, 0.02452103f, 0.02181320f, 0.00912992f, 0.01791198f, 0.01946778f, 
    0.00077054f, -0.02620989f, 0.02606449f, -0.03018891f, -0.02641653f, -0.00218249f, 0.02038015f, -0.01553624f, 
    0.00142850f, -0.03044010f, -0.03325580f, -0.02626388f, -0.02519406f, 0.01164870f, -0.01195791f, 0.00542210f, 
    -0.01020312f, 0.00982043f, 0.02735225f, -0.02101353f, 0.01307293f, -0.00253087f, 0.03295228f, -0.01172469f, 
    -0.28309765f, -0.02382885f, -0.02268787f, 0.09604931f, 0.01868230f, 0.08594041f, -0.01840785f, -0.00727242f, 
    -0.00081357f, 0.08810079f, 0.13573892f, -0.01222460f, 0.00023859f, -0.02047592f, -0.12872520f, 0.00244809f, 
    0.18220031f, -0.02646426f, -0.04016331f, -0.09904175f, 0.06567911f, 0.02160407f, 0.12544407f, 0.13934253f, 
    -0.16519602f, 0.21987230f, -0.13771451f, 0.11263075f, 0.06283732f, 0.03905658f, 0.00488345f, -0.02557294f, 
    -0.03633532f, -0.02800814f, -0.14074637f, -0.02217802f, -0.21070139f, 0.17377371f, 0.03969997f, -0.01698737f, 
    0.09434538f, -0.06231591f, 0.06473406f, 0.06050207f, 0.02009536f, 0.03633482f, 0.10030482f, 0.21527539f, 
    0.07752750f, -0.04114757f, 0.06903520f, 0.19909501f, -0.14279369f, -0.02540210f, -0.02926139f, 0.01177977f, 
    -0.14729664f, -0.01507574f, 0.01057580f, 0.03333515f, 0.34190598f, 0.10191262f, 0.09054109f, -0.00617389f, 
    0.08708477f, 0.09879461f, 0.05658108f, -0.02143024f, -0.02065352f, -0.02625851f, 0.00625737f, 0.13206902f, 
    -0.14181416f, -0.09046257f, 0.05148497f, -0.23572847f, 0.17266548f, 0.05490705f, 0.00504976f, -0.02136807f, 
    0.02265960f, 0.10225244f, -0.06097165f, -0.00154017f, -0.31779525f, -0.01196581f, 0.07627467f, -0.01877533f, 
    -0.01988307f, 0.06117232f, -0.08626109f, 0.08613668f, 0.00709877f, 0.03007763f, 0.02015685f, 0.00971862f, 
    0.11195075f, -0.07411908f, 0.03868353f, 0.11918671f, -0.00224236f, 0.04104458f, 0.02184302f, -0.04378965f, 
    0.06580101f, -0.06341405f, 0.07374946f, -0.04022312f, 0.19983715f, -0.11849979f, -0.18959625f, -0.07391525f, 
    -0.02924526f, -0.02272906f, -0.03174860f, 0.07087818f, 0.10213634f, -0.04289875f, 0.10496251f, -0.01300856f, 
    -0.00324417f, 0.03045197f, -0.03692119f, 0.03942927f, -0.07525371f, -0.01463790f, -0.02422555f, 0.00105967f, 
    0.00259544f, -0.01368948f, 0.05999252f, -0.04602624f, -0.01353138f, -0.08212952f, -0.03488592f, -0.02503856f, 
    0.06167661f, 0.14866239f, 0.17549618f, 0.06938746f, 0.02686659f, 0.03627779f, 0.01058596f, -0.16915837f, 
    0.02818578f, 0.04484002f, 0.12566549f, -0.12240744f, 0.17985328f, 0.00775924f, -0.02922743f, 0.04324286f, 
    0.18670860f, -0.02157762f, 0.00284654f, 0.03830875f, 0.07718646f, 0.23302133f, 0.01285878f, -0.07208081f, 
    0.07505874f, 0.05142010f, -0.00012038f, -0.01811298f, 0.08785859f, -0.06864520f, 0.03589500f, 0.14750324f, 
    0.23100968f, -0.07001006f, 0.05524052f, -0.03443377f, 0.06461896f, -0.01368419f, 0.12848291f, -0.00522999f, 
    -0.01209526f, -0.12066026f, -0.01215756f, 0.20043683f, 0.06848746f, 0.05634663f, -0.04698703f, -0.05159541f, 
    0.14027686f, 0.01251721f, -0.05382946f, -0.00554923f, -0.06813373f, 0.05245055f, -0.05738684f, -0.04003171f, 
    -0.01660543f, -0.06514121f, 0.04355821f, 0.09984895f, -0.00775676f, 0.12303434f, 0.11284667f, 0.11505157f, 
    0.06204007f, -0.02232226f, -0.05511715f, 0.03258233f, 0.03914321f, -0.00473094f, 0.03390529f, -0.03318330f, 
    0.03832024f, 0.03806029f, 0.07429393f, -0.10284919f, -0.07279965f, 0.04144627f, 0.03858690f, -0.02963222f, 
    0.13501655f, 0.03578924f, -0.09489295f, 0.06048065f, 0.00024105f, -0.06520763f, -0.03960437f, 0.01984998f, 
    0.07656302f, -0.03715832f, 0.01591937f, 0.03297559f, -0.00956533f, -0.15171288f, -0.13027821f, -0.02722202f, 
    -0.05062902f, 0.01403191f, 0.00322664f, -0.13536793f, 0.01723610f, 0.01024894f, 0.11078270f, -0.01227276f, 
    0.13217431f, 0.18617378f, -0.10019636f, -0.01765428f, 0.12536894f, -0.01597867f, 0.07685857f, -0.01252662f, 
    -0.03219170f, 0.05203041f, -0.00017487f, 0.11623849f, -0.18596891f, -0.08240157f, 0.01386774f, -0.15823910f, 
    0.04550794f, -0.01397136f, -0.05844411f, -0.04847027f, -0.02881711f, 0.02344402f, 0.03942961f, 0.06622694f, 
    -0.06268187f, -0.02312913f, -0.04679711f, 0.00352946f, 0.11046047f, -0.02456437f, 0.06725609f, -0.10351733f, 
    -0.00660922f, 0.08031312f, 0.10545637f, -0.00228983f, 0.29553205f, -0.05975017f, -0.20868047f, 0.06634568f, 
    -0.05286468f, 0.05528434f, 0.01975397f, 0.08630440f, 0.02531374f, -0.04675878f, 0.04378497f, 0.09888514f, 
    -0.00832316f, -0.26655257f, -0.00250703f, 0.16393238f, 0.07217921f, 0.07173456f, -0.17742334f, 0.00608201f, 
    -0.04400994f, -0.03466047f, -0.02474097f, -0.10195404f, 0.02516096f, 0.15721141f, -0.03542744f, 0.01691932f, 
    0.06173864f, 0.05895880f, 0.10879888f, -0.05651923f, 0.08551663f, -0.00389086f, -0.08214545f, -0.20037992f, 
    -0.13442296f, -0.04911084f, -0.10317031f, -0.13174640f, 0.03897633f, -0.00225065f, 0.06139863f, -0.00611927f, 
    0.02123095f, 0.08086058f, 0.05475466f, 0.06224009f, -0.23216783f, -0.13078168f, -0.01529862f, 0.02056294f, 
    0.06210168f, -0.03080489f, 0.12213412f, 0.10940321f, 0.07036746f, -0.08075144f, 0.02110104f, -0.02212418f, 
    0.15394494f, 0.00385661f, -0.00258028f, -0.09946163f, 0.14317591f, -0.03594707f, 0.08264492f, -0.03157753f, 
    -0.04567745f, 0.03384565f, 0.05138586f, 0.04660985f, 0.17787305f, 0.11631112f, 0.14009669f, -0.04774894f, 
    0.01033313f, 0.10429118f, -0.08357053f, 0.01666179f, 0.03784207f, 0.02108063f, 0.04223805f, 0.09967210f, 
    -0.16786087f, 0.02806655f, -0.08333720f, -0.11056843f, -0.02613140f, 0.00753425f, 0.11973947f, 0.08314090f, 
    -0.06842818f, 0.03716512f, 0.03141201f, 0.04695633f, -0.06843852f, 0.23560666f, -0.31777632f, -0.10165287f, 
    0.00056926f, -0.01345648f, -0.01805470f, 0.07154529f, -0.07224160f, -0.01490792f, 0.10962735f, 0.04180889f, 
    -0.10478678f, -0.14434387f, 0.04775352f, -0.01983857f, -0.01202798f, -0.01942642f, 0.02076709f, -0.07992801f, 
    0.04251978f, 0.01331909f, -0.04335442f, -0.08176538f, 0.13920777f, 0.12654476f, 0.21484329f, -0.10129051f, 
    0.14388530f, -0.03892412f, 0.10285223f, -0.09445781f, 0.04209504f, 0.03598573f, 0.09002642f, -0.03253173f, 
    0.12667568f, -0.00580286f, 0.14925480f, -0.00397653f, 0.01746134f, 0.10389303f, 0.02480268f, -0.09036887f, 
    0.00113034f, 0.06186633f, -0.05084412f, 0.01226350f, 0.15072359f, 0.11729393f, -0.01335690f, 0.17132106f, 
    -0.09655683f, 0.02974680f, -0.01740633f, 0.01645818f, 0.07014132f, 0.05753656f, 0.03637339f, -0.09159632f, 
    0.00919493f, 0.13964163f, 0.15881677f, -0.02960155f, 0.01953993f, 0.02210660f, 0.02765696f, -0.06258074f, 
    0.06924926f, -0.00147103f, -0.04057433f, 0.11126702f, 0.16981229f, 0.04399128f, 0.08103736f, -0.10895088f, 
    0.17236568f, 0.12635146f, 0.02221717f, -0.01733921f, -0.00825657f, 0.01681196f, 0.04635465f, -0.02211599f, 
    0.27628413f, -0.02932065f, -0.02196733f, 0.05699173f, 0.12402950f, 0.05582022f, 0.00287668f, 0.04561527f, 
    0.04756376f, 0.02433874f, 0.00031337f, 0.04343582f, 0.04669088f, 0.02381497f, -0.00448815f, 0.04173104f, 
    -0.14751869f, 0.02062510f, -0.07933170f, 0.11915582f, 0.11510421f, 0.10115917f, -0.03287681f, 0.15419096f, 
    -0.19551593f, -0.15668891f, -0.03571251f, 0.07968324f, 0.04586134f, 0.01649120f, -0.00574296f, 0.14119099f, 
    0.03656377f, -0.02434199f, 0.03927093f, -0.05073696f, -0.26963735f, -0.10811418f, 0.00194382f, -0.00788942f, 
    -0.04899986f, 0.06628153f, -0.02665888f, 0.08249960f, -0.11913062f, 0.17526558f, 0.18042450f, 0.09285633f, 
    -0.25095159f, -0.04105256f, 0.00721034f, 0.12472181f, -0.02966010f, 0.00346051f, -0.02988751f, 0.06953489f, 
    -0.00842130f, 0.04343216f, -0.00860236f, -0.04528538f, 0.05577587f, -0.05720813f, 0.08574836f, 0.20676929f, 
    -0.01675113f, -0.01629078f, -0.01277202f, 0.14891033f, -0.05747053f, -0.05934760f, 0.05746417f, 0.07417303f, 
    -0.35835990f, 0.26939127f, -0.12406105f, 0.10200089f, 0.11988853f, -0.07597994f, 0.00383776f, 0.04012289f, 
    0.06256260f, -0.05088735f, 0.03816518f, -0.01435379f, 0.08153825f, 0.23912607f, 0.03401399f, -0.01644604f, 
    0.15727516f, 0.08859400f, 0.05801006f, 0.01126429f, 0.11826012f, -0.00693789f, 0.08994355f, 0.10592389f, 
    -0.02074062f, 0.01870706f, 0.18269506f, -0.06924004f, 0.06412099f, 0.01331700f, -0.06655347f, 0.01764297f, 
    0.13903716f, 0.01795419f, 0.17646398f, 0.04841882f, -0.40961099f, -0.15404542f, 0.14423737f, -0.17568260f, 
    -0.06035997f, 0.09095392f, 0.00521807f, 0.01178422f, -0.00608995f, -0.03572068f, -0.06083976f, 0.04463906f, 
    -0.33121696f, -0.27140468f, -0.11575779f, 0.01757331f, 0.01180412f, 0.00567102f, 0.06803165f, 0.03384079f, 
    -0.01582098f, -0.03283582f, 0.03852479f, -0.08540121f, 0.17097969f, 0.04863774f, -0.17089583f, 0.00133713f, 
    0.05413690f, -0.03862230f, 0.03246118f, -0.02139001f, -0.00393285f, 0.01528336f, 0.06734321f, -0.10524884f, 
    0.16469759f, 0.02097246f, -0.07568270f, -0.07806981f, -0.01706892f, -0.00726949f, -0.08181380f, 0.12541534f, 
    0.04823498f, 0.07240634f, -0.02442176f, 0.04129758f, -0.02596131f, -0.02871954f, -0.12202195f, -0.03139058f, 
    0.17488322f, -0.01764122f, 0.04329003f, 0.00449272f, 0.17233710f, 0.04377276f, -0.08604119f, 0.05305495f, 
    -0.15613063f, -0.07128424f, 0.03608575f, 0.09494626f, 0.06250096f, 0.07942755f, 0.05860445f, 0.09018840f, 
    0.09678933f, -0.04302474f, 0.05743519f, -0.04484303f, -0.52101111f, 0.08347164f, -0.06977778f, -0.13190149f, 
    0.15763436f, -0.10805582f, 0.02126980f, -0.02354782f, 0.02977728f, -0.05945951f, 0.07320040f, 0.14173464f, 
    0.01018014f, 0.00593932f, 0.01707852f, -0.00456641f, 0.10406187f, -0.04246974f, -0.03469789f, 0.05021155f, 
    -0.01347004f, 0.14781371f, 0.03296286f, 0.05550829f, -0.15927313f, 0.05283043f, 0.05218989f, 0.12210947f, 
    0.08985791f, -0.00399159f, 0.03131605f, 0.04067539f, 0.00679107f, -0.07225436f, 0.07688601f, -0.05520814f, 
    0.05762780f, -0.05805428f, 0.17326142f, 0.02803912f, 0.10772952f, -0.05378335f, 0.00325769f, -0.04028737f, 
    0.07793991f, 0.04701934f, 0.10748921f, 0.11051137f, 0.01423610f, -0.06069744f, -0.04715112f, 0.06154203f, 
    0.02152279f, -0.02157830f, 0.09814119f, -0.00362266f, 0.06170452f, -0.03050570f, 0.02023038f, -0.02794427f, 
    0.00060338f, -0.05255318f, -0.12154192f, 0.02237567f, 0.08447012f, 0.01095424f, -0.06362690f, -0.01961453f, 
    0.09282364f, 0.08691498f, 0.02872199f, 0.00934076f, 0.22594465f, -0.03280175f, -0.02515214f, -0.07912257f, 
    0.09657446f, 0.05237256f, -0.00412988f, 0.03651448f, 0.03683558f, 0.04384068f, 0.02737685f, -0.07588205f, 
    -0.08974059f, -0.06527907f, 0.02316123f, -0.11666451f, 0.10870490f, -0.03364477f, -0.00737779f, 0.02485840f, 
    0.02636281f, -0.05355436f, 0.08667005f, 0.11656848f, -0.18900640f, 0.01187654f, 0.12589987f, -0.02116283f, 
    0.04135125f, -0.01237737f, -0.00995811f, -0.02369400f, 0.10630333f, 0.12132277f, -0.00980848f, 0.06135128f, 
    -0.33131996f, 0.12511234f, 0.07817707f, 0.15042809f, 0.07281014f, -0.03170418f, -0.00720893f, 0.08459238f, 
    0.13196543f, 0.01139569f, 0.08353967f, -0.01825197f, 0.19035941f, 0.04504347f, 0.22490534f, 0.03033102f, 
    -0.04495101f, -0.03388798f, 0.09850302f, 0.08496018f, 0.07276676f, -0.00863929f, -0.13896929f, 0.07182053f, 
    -0.06598270f, -0.02816295f, -0.04319037f, -0.28562593f, 0.05797294f, 0.12568371f, 0.14836180f, -0.06531156f, 
    -0.00742245f, 0.05700589f, 0.08747549f, 0.07066357f, 0.27820343f, 0.06172320f, -0.16717483f, 0.13121548f, 
    -0.09098572f, -0.06369144f, -0.08780981f, 0.02544974f, 0.03521736f, 0.03288665f, -0.05717552f, 0.19937758f, 
    0.11174570f, -0.11480292f, 0.03549101f, -0.08517761f, -0.02527539f, -0.08334185f, 0.03917661f, 0.05338578f, 
    0.18798590f, -0.01381921f, 0.01966793f, -0.01340798f, 0.13244885f, -0.32163256f, 0.06984770f, 0.12382212f, 
    -0.06317358f, 0.03617363f, -0.07959294f, 0.08326145f, 0.00733944f, 0.01093255f, 0.05571587f, -0.02507165f, 
    0.06245330f, 0.10342915f, 0.07849063f, -0.21400602f, 0.07522430f, -0.06116508f, 0.04413855f, -0.06728459f, 
    -0.00411132f, -0.07924694f, 0.01931153f, -0.01448835f, -0.04113618f, -0.02426282f, 0.06691021f, -0.08092116f, 
    0.04236811f, -0.13096550f, -0.03433639f, -0.04581738f, 0.00381969f, 0.09466355f, -0.02012743f, 0.10111098f, 
    0.02443813f, -0.17202796f, -0.03156353f, 0.13296832f, -0.11496935f, 0.01840509f, -0.04237499f, -0.03392144f, 
    0.04762380f, 0.08245553f, -0.04927997f, 0.11721712f, 0.29664972f, -0.05907086f, -0.11424900f, 0.03837730f, 
    0.06231436f, -0.01635516f, -0.01777843f, -0.02304196f, -0.00853089f, -0.08118916f, -0.05093281f, 0.09423121f, 
    0.22223327f, 0.06563557f, 0.04113300f, -0.12417565f, -0.04190664f, -0.04628009f, -0.04289767f, 0.05450705f, 
    -0.03171529f, -0.05792689f, 0.04267780f, 0.02016001f, -0.05527212f, 0.13081758f, -0.01416224f, -0.02600233f, 
    0.00978783f, 0.04480334f, -0.08158606f, -0.07696529f, -0.13142279f, 0.11911824f, 0.07631077f, 0.06138801f, 
    0.09858648f, 0.02469145f, -0.14286207f, -0.20942475f, 0.03679080f, 0.01019313f, 0.05811466f, -0.00848479f, 
    0.10482374f, 0.03066006f, -0.11074855f, -0.12868798f, -0.03434323f, 0.08964255f, -0.12358519f, -0.04481729f, 
    -0.03427788f, -0.01227052f, -0.16515514f, -0.09282946f, -0.00568937f, -0.11153954f, -0.05782538f, -0.03346288f, 
    0.21615325f, -0.02817928f, 0.10299000f, 0.12320969f, 0.02970945f, 0.09630075f, 0.09820573f, -0.00923422f, 
    -0.02678240f, 0.01836278f, -0.00616397f, 0.03119441f, 0.00960157f, 0.00385378f, -0.00072413f, -0.10535442f, 
    -0.02543888f, 0.02155456f, -0.01462925f, -0.00966163f, 0.08425655f, 0.11393100f, 0.06007906f, 0.00708065f, 
    -0.29840881f, 0.26372433f, 0.03901649f, -0.00254244f, -0.11546268f, -0.05716039f, 0.06802461f, -0.00301211f, 
    -0.10189968f, -0.02538787f, 0.05289520f, -0.14780729f, 0.19821170f, 0.08736638f, 0.03570992f, 0.07226451f, 
    0.08298604f, 0.09630624f, -0.00319629f, -0.00042610f, 0.04380510f, 0.07482643f, -0.09839079f, -0.07418752f, 
    -0.18047057f, 0.04154142f, 0.03209176f, -0.20736566f, -0.02718771f, 0.11521658f, -0.06992608f, 0.00425107f, 
    -0.02423733f, -0.05351684f, -0.01632185f, 0.08405341f, -0.19610092f, 0.13292922f, -0.07549050f, -0.17015021f, 
    0.14052185f, -0.13384846f, -0.04225907f, -0.03386386f, -0.04087416f, -0.02596435f, 0.00410802f, 0.04487271f, 
    0.01889795f, 0.07967142f, -0.00931428f, 0.11136633f, 0.03416083f, 0.14057827f, -0.02449113f, -0.02706383f, 
    -0.03260689f, 0.01270873f, -0.06242815f, -0.02399567f, -0.07309692f, 0.10339669f, -0.08467967f, 0.03879418f, 
    -0.00871062f, 0.18837260f, 0.03278479f, 0.08227762f, 0.10782593f, 0.10874555f, -0.12867311f, 0.02551542f, 
    -0.00877993f, -0.02122926f, 0.15056440f, 0.11256153f, -0.07922031f, 0.20349592f, -0.03435954f, 0.01816074f, 
    0.04797300f, 0.11024349f, 0.05005063f, 0.06274759f, -0.09053589f, 0.13340934f, -0.14694552f, -0.09279804f, 
    -0.03517465f, 0.06844791f, 0.03855978f, 0.01415371f, 0.02824675f, 0.04014151f, -0.03085684f, -0.03231399f, 
    -0.13119510f, -0.13842611f, -0.05565909f, -0.14826621f, 0.03579506f, -0.08575664f, -0.07177439f, 0.04458737f, 
    0.08605716f, 0.05389550f, -0.08288812f, 0.02416634f, -0.25903723f, 0.10562196f, -0.21399939f, -0.06136624f, 
    0.00863870f, 0.09170818f, -0.07278229f, -0.06101193f, 0.02531934f, 0.07221464f, 0.01244995f, 0.04696907f, 
    0.04845641f, 0.18647273f, -0.01430071f, -0.17270935f, -0.04634544f, -0.07319994f, 0.06174883f, 0.02623606f, 
    0.06708134f, -0.00158068f, -0.04282008f, -0.01866763f, 0.12149338f, -0.03916690f, 0.06683517f, -0.10473428f, 
    -0.03162338f, 0.00330129f, 0.01991603f, 0.03379712f, -0.09222641f, 0.19409430f, -0.06440751f, -0.02211759f, 
    -0.05472299f, -0.10993400f, -0.09945749f, -0.20401567f, 0.08669043f, -0.08626220f, 0.19153203f, -0.11861375f, 
    -0.08377828f, 0.02536637f, 0.04369336f, -0.22861314f, 0.31986198f, 0.07557533f, 0.11700971f, -0.02561940f, 
    -0.09932791f, -0.02976516f, -0.04613432f, -0.04353923f, 0.03251429f, 0.02255401f, -0.01087802f, -0.02085743f, 
    0.06456745f, 0.00438600f, -0.02220012f, 0.12304948f, 0.01043335f, 0.10172168f, -0.05740014f, -0.03804729f, 
    -0.00497148f, 0.05838639f, 0.00942535f, 0.04143194f, 0.08489772f, 0.15366757f, -0.06123932f, 0.02558222f, 
    -0.03288793f, 0.04228496f, -0.02574169f, -0.00714381f, 0.02267112f, 0.12224390f, 0.02287723f, 0.11650592f, 
    0.05398990f, -0.10549149f, -0.17349641f, 0.12657200f, 0.12171645f, 0.00670710f, -0.00303965f, -0.18109313f, 
    0.09425805f, 0.06002049f, -0.04315517f, -0.12342119f, 0.30189413f, -0.02661337f, -0.11080232f, 0.11823684f, 
    -0.05614996f, 0.09382499f, -0.12850052f, 0.05799900f, 0.09809290f, -0.01146897f, 0.05428428f, -0.09561934f, 
    0.45575121f, 0.07758823f, 0.11366922f, -0.08971500f, 0.04064070f, 0.00817275f, -0.04153537f, -0.00086944f, 
    -0.01157934f, 0.07913621f, -0.03125708f, 0.05753607f, -0.10723811f, 0.01852716f, 0.00455000f, 0.18225622f, 
    0.06359588f, -0.17028469f, -0.00123786f, 0.09078215f, -0.03554376f, 0.01130974f, -0.08711948f, 0.18585812f, 
    0.03180307f, 0.02215207f, -0.00690154f, 0.07991635f, -0.01575373f, -0.03887549f, -0.02031527f, 0.15900898f, 
    0.00637270f, 0.00459618f, -0.00093456f, 0.10194926f, 0.15229663f, 0.07821577f, -0.00129607f, -0.05196018f, 
    0.08221023f, -0.01680952f, 0.04915031f, 0.11891380f, 0.07101932f, 0.03633709f, -0.08066708f, 0.02822620f, 
    -0.01781551f, 0.06613048f, -0.06680109f, -0.08209728f, 0.03741277f, -0.06174819f, 0.06095352f, 0.06476212f, 
    -0.08736506f, 0.00369102f, -0.01282194f, 0.11558393f, -0.10251500f, 0.08606506f, -0.01374206f, 0.08227712f, 
    -0.05515382f, -0.06256960f, -0.00819765f, 0.00031944f, -0.01916044f, 0.02494431f, -0.04946098f, 0.06647628f, 
    0.13507868f, 0.05841409f, 0.00608948f, -0.06307849f, 0.10070290f, -0.04660951f, 0.02587831f, -0.02418981f, 
    0.03101810f, -0.00939081f, 0.03444758f, -0.00333528f, 0.13588116f, 0.11171876f, -0.06913619f, -0.22418666f, 
    -0.03450577f, -0.11395615f, 0.00469361f, -0.13868177f, 0.00867456f, -0.14413612f, 0.04417722f, -0.14767000f, 
    0.46809950f, 0.15740767f, 0.08528057f, 0.06593435f, 0.02406486f, -0.02833451f, 0.01477591f, 0.11070317f, 
    0.01445827f, 0.10438208f, -0.06676251f, 0.02051038f, 0.11589144f, 0.13696314f, 0.08242642f, -0.09817027f, 
    -0.05566781f, -0.01784666f, 0.03660449f, -0.06492343f, -0.05970001f, -0.03926421f, -0.05680411f, -0.04421005f, 
    0.25975385f, 0.10975158f, 0.08001032f, -0.00961382f, -0.00236522f, 0.03659441f, 0.00438179f, -0.01917331f, 
    0.09297585f, 0.20323730f, -0.00162566f, 0.08976031f, 0.09239335f, 0.07820913f, 0.00686523f, -0.02753957f, 
    0.08205528f, 0.01724078f, -0.03427698f, -0.03589667f, 0.03071190f, 0.11581618f, 0.10385533f, 0.05520589f, 
    0.30866948f, -0.20073864f, 0.02913110f, 0.11717229f, -0.07993042f, 0.04674277f, 0.00614146f, 0.11472719f, 
    0.01319976f, -0.04569685f, 0.04032962f, 0.09363105f, 0.12555349f, -0.19273727f, 0.07804156f, -0.01246019f, 
    -0.05192558f, -0.00443238f, 0.02462262f, -0.01677795f, -0.00448021f, 0.06579830f, 0.10185783f, -0.06062687f, 
    -0.33927649f, 0.19094594f, 0.14932977f, 0.05463083f, -0.00525925f, -0.15977190f, 0.10964838f, -0.03924805f, 
    -0.04911231f, -0.03852603f, 0.11809535f, -0.00342027f, -0.39599100f, -0.34941509f, -0.02553757f, 0.05619793f, 
    0.14515449f, -0.12930267f, -0.03955317f, -0.03436869f, 0.11724935f, 0.05712579f, -0.05327142f, -0.02302931f, 
    0.48395091f, 0.07764779f, 0.10989906f, -0.09289663f, -0.01713299f, 0.02154664f, -0.07305902f, -0.04659861f, 
    0.06484060f, -0.02106051f, -0.15751684f, 0.00744153f, 0.07538101f, 0.24984874f, -0.00709893f, -0.14855522f, 
    -0.05614669f, -0.07645043f, 0.02890645f, 0.01836825f, 0.06977171f, -0.02093461f, -0.03384834f, 0.06048342f, 
    -0.12741932f, 0.07679555f, -0.03222618f, 0.15857856f, -0.07384979f, 0.07422528f, 0.06174426f, 0.04742513f, 
    0.03016936f, -0.01948699f, -0.06351615f, -0.13181195f, -0.16493863f, -0.03743250f, 0.19964409f, 0.16548516f, 
    -0.02530351f, -0.03077405f, 0.05957075f, 0.13855086f, 0.06541219f, 0.05001630f, -0.04735327f, 0.05579522f, 
    0.32534352f, -0.01131053f, 0.02910968f, -0.09413885f, -0.01587228f, 0.01560690f, 0.15771469f, -0.00442891f, 
    -0.10282205f, 0.00956387f, 0.05429338f, -0.05244405f, 0.24640653f, -0.24035467f, -0.13547403f, 0.07060919f, 
    -0.07383801f, 0.03522587f, -0.04159284f, 0.00976496f, 0.06108635f, 0.06231709f, -0.01944216f, 0.02989358f, 
    0.13095620f, -0.08047202f, -0.05709313f, -0.07281738f, -0.04189431f, 0.06273997f, -0.07887477f, -0.07411087f, 
    0.02390653f, -0.01938210f, -0.17478922f, 0.02314598f, 0.35620114f, -0.01874657f, 0.03057785f, -0.00803086f, 
    0.06624734f, -0.02415622f, 0.02470819f, 0.03725266f, -0.05479837f, 0.05544861f, 0.00395680f, 0.01534914f, 
    0.29697952f, 0.11620796f, -0.16368693f, 0.08261830f, -0.02771628f, -0.03210767f, 0.03450523f, 0.04937157f, 
    -0.01285606f, 0.02578066f, 0.02462844f, -0.15349501f, 0.12413686f, 0.15492666f, 0.00150651f, -0.22284976f, 
    0.05374848f, -0.00461884f, 0.06745110f, 0.04084611f, 0.02793051f, 0.03972127f, 0.03739789f, 0.06112336f, 
    0.14404896f, -0.11680897f, -0.02428079f, 0.00997666f, -0.05442464f, 0.02337292f, 0.04428351f, 0.10903532f, 
    0.01783503f, -0.10302778f, -0.02328467f, -0.04852978f, 0.07862287f, -0.08621275f, 0.00774395f, 0.12276887f, 
    -0.17654096f, -0.12743658f, 0.10265829f, 0.07840190f, 0.03843458f, -0.03755011f, 0.02435583f, -0.11912843f, 
    -0.30665356f, 0.00512137f, 0.13845862f, 0.26158312f, -0.02766937f, 0.07550357f, -0.00898934f, 0.02538805f, 
    0.06642187f, 0.17164975f, 0.00309480f, 0.08573913f, -0.05811050f, 0.02191806f, -0.05505217f, -0.18209659f, 
    0.01288095f, -0.00135232f, 0.05858488f, -0.14312142f, -0.15968998f, 0.02132758f, 0.00496260f, 0.01176742f, 
    0.07373910f, -0.30669668f, 0.09684505f, -0.29534385f, 0.10251722f, -0.02044811f, 0.00153188f, -0.00987438f, 
    -0.05110222f, -0.05879214f, -0.01885388f, 0.02528884f, 0.02194272f, 0.20008861f, 0.10828850f, -0.26945579f, 
    0.05922081f, 0.10948288f, 0.09307116f, 0.04991286f, 0.00472004f, -0.03515939f, 0.00204954f, 0.02537547f, 
    -0.01734944f, -0.03411587f, 0.02563759f, 0.02120825f, 0.00460706f, 0.01334427f, 0.02860096f, -0.01364227f, 
    0.02666132f, -0.00849016f, 0.03007394f, -0.04073982f, -0.00055497f, 0.02931732f, -0.01605240f, -0.03416875f, 
    -0.04180582f, 0.00308512f, -0.03361198f, -0.01554616f, -0.02593256f, -0.01646226f, 0.02621497f, 0.02372856f, 
    -0.02948329f, -0.02773307f, -0.00678853f, -0.02475981f, -0.03677675f, -0.03681455f, 0.02285085f, -0.02702004f, 
    -0.00943663f, 0.01512272f, 0.00098213f, -0.00806017f, 0.02264992f, 0.00005007f, 0.02076948f, 0.00354498f, 
    -0.00739510f, 0.02345661f, 0.00563716f, -0.01663531f, -0.04139195f, -0.03713822f, -0.01673127f, -0.00891802f, 
    -0.02788275f, -0.02328296f, 0.00958389f, -0.00143440f, -0.01704128f, -0.02118839f, -0.00123939f, -0.03811743f, 
    0.02414887f, -0.04001891f, -0.02500194f, -0.01808103f, -0.00775528f, 0.02795857f, -0.00425929f, -0.01365381f, 
    -0.03101230f, 0.01408919f, 0.02004752f, 0.01359038f, -0.03684977f, 0.00411885f, -0.03237604f, -0.03107136f, 
    -0.01769412f, -0.04152083f, -0.01633129f, -0.01578879f, 0.00905202f, 0.00783875f, -0.03958471f, -0.01782533f, 
    0.00946278f, -0.00579364f, 0.00057280f, -0.00050610f, 0.00409515f, 0.02510478f, 0.02908544f, -0.00976822f, 
    -0.01460236f, 0.00230384f, -0.03359539f, -0.01408526f, 0.01836412f, -0.00409624f, -0.00694256f, 0.02069732f, 
    0.02028199f, -0.02906662f, -0.02313577f, 0.02816750f, 0.01200235f, 0.00783491f, 0.00499685f, 0.01981379f, 
    -0.00676322f, -0.02845551f, -0.02445426f, 0.02713253f, -0.01704508f, 0.02304785f, -0.03440243f, 0.00737338f, 
    -0.02799260f, -0.01443509f, -0.02932127f, 0.01204281f, -0.01639122f, 0.00907763f, -0.03606100f, 0.00279917f, 
    0.02445889f, -0.00678525f, -0.03342522f, -0.03723237f, -0.02610243f, -0.01361722f, -0.02618372f, -0.03208396f, 
    -0.03033823f, -0.03593885f, 0.02214674f, -0.00648290f, -0.02002757f, 0.00823876f, -0.00031706f, -0.00768442f, 
    0.01077466f, -0.04146125f, -0.01782076f, -0.02677913f, 0.01496459f, 0.02882322f, -0.04069348f, -0.01938250f, 
    0.01034164f, 0.00285682f, 0.00214412f, -0.01937648f, 0.01102061f, 0.00391283f, 0.01425546f, 0.00764323f, 
    -0.02524018f, 0.01057405f, -0.03182201f, 0.00094323f, -0.01342035f, 0.00327315f, 0.01314314f, -0.01511064f, 
    0.03006667f, 0.01708920f, 0.02635675f, -0.00475555f, 0.02850330f, -0.03345853f, -0.02911453f, -0.00749949f, 
    0.02074249f, -0.01079347f, 0.01901497f, -0.03635648f, -0.00537931f, 0.02271053f, 0.02140991f, 0.01279980f, 
    -0.03033431f, -0.03935693f, 0.01819693f, -0.00531688f, -0.02300283f, -0.00496610f, -0.01603898f, -0.03013161f, 
    -0.00861241f, -0.01688658f, -0.04010709f, 0.02948523f, 0.02580217f, 0.01838217f, 0.02369334f, 0.01526951f, 
    0.02480494f, -0.03917046f, -0.01950717f, 0.01496357f, 0.00712530f, 0.01315869f, -0.00077359f, -0.02492818f, 
    0.02845802f, -0.02688137f, 0.00528300f, -0.03217058f, -0.00276057f, 0.01025699f, -0.00544155f, 0.00461369f, 
    0.02222598f, -0.01185087f, -0.01189119f, 0.00591879f, -0.01118264f, -0.00603333f, 0.00360857f, -0.02248485f, 
    0.00747611f, -0.03981390f, -0.02148749f, 0.02109147f, 0.00125217f, -0.03726979f, -0.00433441f, 0.02554298f, 
    -0.03745231f, -0.03747776f, 0.00217910f, -0.02029161f, -0.02990172f, -0.01280458f, 0.02214726f, 0.01471949f, 
    -0.00684546f, -0.00554593f, 0.00315421f, 0.02617161f, -0.02806720f, -0.03349762f, 0.02900756f, 0.02344288f, 
    -0.01388107f, -0.01241934f, 0.00915367f, 0.02826050f, 0.02545025f, 0.02139651f, 0.01721525f, -0.03657598f, 
    0.00719954f, -0.02636533f, -0.02710941f, -0.02550436f, 0.02025178f, -0.03323966f, -0.02404221f, 0.02604012f, 
    0.01944731f, -0.01423832f, 0.00616029f, -0.03908501f, 0.00514417f, -0.01048829f, 0.02577303f, -0.02635106f, 
    0.01183644f, -0.00572728f, 0.02708510f, 0.01422574f, -0.01151704f, -0.02836549f, -0.03649623f, -0.03880193f, 
    -0.04143686f, 0.02102873f, -0.03899687f, -0.02836495f, -0.00735925f, -0.01936410f, 0.00368614f, -0.03819915f, 
    0.02841757f, 0.02718726f, -0.03667581f, -0.01248395f, -0.04180144f, -0.02702563f, -0.02593944f, -0.00315630f, 
    -0.04000952f, -0.03292885f, -0.02961402f, -0.02741635f, -0.01078272f, 0.02499266f, -0.04087858f, -0.00171539f, 
    -0.02272801f, 0.00701249f, 0.02216481f, 0.00668202f, -0.03276924f, -0.02223440f, -0.00608952f, 0.00500655f, 
    -0.02419650f, 0.01612379f, 0.00239604f, -0.00148107f, -0.00460024f, -0.01440570f, -0.02087802f, -0.03977507f, 
    0.01536091f, 0.00505102f, -0.03486817f, 0.01169755f, -0.03342494f, 0.02924180f, -0.00141127f, 0.02980487f, 
    -0.00064442f, 0.02395433f, 0.00582770f, -0.03054553f, -0.03331817f, 0.01123742f, 0.00195035f, 0.02135243f, 
    -0.01893471f, -0.02441914f, -0.01036980f, -0.03094403f, 0.01412313f, -0.03237601f, 0.00452211f, -0.02152044f, 
    0.02739534f, -0.00555607f, 0.00401094f, 0.02950049f, -0.03897965f, -0.03695710f, -0.00567667f, -0.04063303f, 
    0.01657541f, 0.02247067f, -0.00106451f, 0.01794047f, -0.00942856f, -0.00004055f, -0.01184910f, -0.01684803f, 
    -0.03381573f, -0.02586555f, -0.00412594f, -0.03226643f, -0.01130094f, -0.00979517f, -0.03529374f, -0.01455557f, 
    -0.03207560f, -0.03801978f, -0.01661927f, -0.02977173f, -0.01966402f, -0.03392273f, 0.01296179f, -0.02856641f, 
    -0.03707175f, 0.01696021f, -0.00673106f, -0.02266355f, -0.01056745f, 0.02844525f, 0.00386304f, 0.01277940f, 
    -0.00794963f, 0.01255640f, -0.02747808f, -0.03356723f, -0.03960892f, 0.01886684f, 0.01381857f, 0.01774466f, 
    0.02907044f, 0.01573882f, -0.01564718f, -0.02845760f, -0.01653964f, 0.02678974f, 0.00960703f, -0.01852601f, 
    0.01718323f, -0.00519228f, -0.00917061f, 0.01920158f, 0.00193909f, 0.00986745f, -0.03466849f, 0.02844481f, 
    -0.02095170f, -0.02269233f, 0.02543180f, -0.03867378f, 0.00439018f, -0.01909469f, -0.02408635f, 0.00535011f, 
    -0.01750674f, 0.02670684f, -0.02857784f, 0.02059595f, 0.00145596f, -0.03482389f, 0.02288349f, 0.01781864f, 
    0.02110221f, -0.00847641f, -0.01710960f, -0.03942592f, -0.00755106f, -0.03102885f, -0.04014964f, 0.00645850f, 
    -0.01539953f, -0.01405140f, 0.02370302f, -0.03750432f, 0.01645160f, 0.02167886f, -0.00615250f, -0.02583807f, 
    -0.04142660f, -0.00909861f, -0.02775148f, 0.00553873f, -0.01796738f, -0.03120792f, -0.02365452f, 0.01014838f, 
    -0.02583900f, -0.00518335f, 0.00769886f, 0.00654627f, -0.01205186f, -0.00880846f, 0.02319346f, 0.02484341f, 
    -0.02535571f, 0.00268764f, -0.00167377f, -0.02138364f, 0.01823031f, 0.01488643f, -0.00165277f, 0.02583097f, 
    0.00751391f, 0.01263958f, -0.03675409f, -0.04016322f, 0.02990936f, 0.00736486f, -0.02746969f, -0.01267601f, 
    -0.04056268f, 0.00082125f, -0.00433414f, -0.03534333f, 0.02542356f, -0.02611319f, 0.00367720f, 0.00693663f, 
    -0.02360676f, -0.01160715f, 0.00007784f, -0.01664909f, -0.02364730f, 0.02018660f, -0.01882966f, -0.02990303f, 
    0.01858501f, -0.03986374f, 0.00987635f, -0.03783629f, -0.03566258f, 0.02887187f, -0.01808628f, -0.03076495f, 
    -0.02975234f, 0.02043888f, 0.00886706f, 0.01584225f, 0.02607563f, -0.03246193f, -0.01506443f, -0.02136903f, 
    0.01582682f, 0.01260748f, -0.01986608f, 0.00716396f, -0.00698230f, 0.02631163f, -0.01680366f, 0.00467617f, 
    -0.01346374f, 0.01807551f, 0.00252078f, 0.01869704f, -0.03968439f, -0.01959698f, -0.01373460f, 0.00405389f, 
    -0.01967603f, -0.01489133f, -0.02939950f, -0.00545378f, 0.00922466f, -0.02129895f, 0.00739004f, 0.02942333f, 
    0.02513660f, 0.01955132f, -0.01778272f, 0.01207581f, -0.03918982f, -0.03643307f, -0.02399046f, 0.01549234f, 
    0.00080531f, 0.01488712f, 0.02548070f, -0.01775568f, -0.00581520f, 0.00397607f, -0.02505963f, 0.02401109f, 
    -0.04003926f, -0.04044854f, 0.00189832f, -0.02610184f, -0.01033019f, -0.00828057f, 0.01657626f, 0.00717016f, 
    -0.00866953f, -0.03218038f, -0.00028870f, -0.00436180f, 0.01839540f, 0.01610463f, -0.01556220f, -0.03638680f, 
    -0.01151115f, -0.00014619f, -0.03800080f, -0.01731866f, 0.02421013f, 0.02549151f, -0.00557407f, 0.00389031f, 
    -0.00502285f, 0.02888399f, -0.02407259f, -0.03884434f, 0.01881296f, 0.00441934f, -0.00376043f, -0.03787858f, 
    0.01747561f, 0.00991946f, -0.00730698f, -0.00841621f, -0.03045034f, 0.00092347f, -0.03478835f, -0.04021560f, 
    -0.01782578f, -0.02123688f, -0.01288265f, 0.01877993f, -0.04034649f, -0.03295066f, 0.02558151f, -0.03766386f, 
    -0.03188736f, -0.01824532f, -0.02136195f, -0.03036550f, -0.02598852f, -0.01608971f, -0.01116481f, -0.03708367f, 
    0.00430141f, 0.00303108f, -0.01559046f, -0.02603034f, -0.03071618f, -0.02239729f, 0.01423038f, 0.02874777f, 
    0.01671472f, 0.01293976f, 0.02718663f, 0.01058452f, 0.02203586f, -0.00255286f, -0.04051605f, 0.00769242f, 
    -0.01720588f, -0.00448909f, 0.02168871f, 0.02479569f, -0.03100703f, -0.02558133f, -0.02779239f, -0.00801379f, 
    -0.02668147f, 0.02366346f, -0.00765524f, -0.02002152f, -0.04061031f, -0.02786614f, -0.02173871f, -0.01652328f, 
    0.00978180f, -0.02399852f, 0.01622409f, -0.00419849f, 0.00696378f, -0.03678731f, -0.01672365f, -0.01295671f, 
    -0.02286468f, -0.02767385f, -0.02281012f, -0.04134620f, -0.00965400f, -0.01619715f, -0.02881113f, 0.02375471f, 
    -0.03674678f, -0.04179990f, -0.02373510f, -0.02112985f, 0.02301516f, -0.03650617f, -0.01521332f, -0.02229413f, 
    -0.01319886f, -0.03041486f, 0.02990882f, 0.00647930f, -0.01292298f, -0.03663154f, 0.02461871f, 0.01644741f, 
    -0.03221783f, 0.00871805f, -0.00799187f, 0.02788250f, 0.00211237f, -0.03226161f, -0.03153699f, -0.00472430f, 
    0.02809282f, -0.03452120f, -0.03616745f, -0.01980749f, 0.00113014f, 0.01049121f, 0.02585076f, 0.01503690f, 
    -0.01049099f, -0.02860298f, -0.02866972f, -0.02678549f, 0.02991156f, -0.03576998f, -0.00578363f, 0.00867736f, 
    -0.01598830f, -0.01405774f, -0.03063109f, 0.01710245f, 0.02922664f, -0.00843410f, -0.02862240f, 0.02363013f, 
    -0.02910833f, -0.00849523f, 0.01611122f, -0.02262459f, -0.03486503f, -0.01460213f, 0.00124144f, -0.03136016f, 
    -0.01559240f, -0.02976761f, 0.02994182f, -0.03967737f, -0.00572118f, -0.01852750f, 0.00890420f, -0.02946531f, 
    -0.03562048f, -0.00774193f, 0.02919064f, 0.01629098f, 0.00822142f, 0.02541742f, -0.03029549f, 0.00422764f, 
    -0.01167275f, 0.01206093f, -0.04013948f, 0.00554179f, -0.03371374f, 0.00063746f, 0.00958372f, 0.02469415f, 
    0.00620703f, -0.01844106f, -0.00989186f, -0.01519310f, -0.01827073f, -0.00401779f, 0.01927163f, 0.01251457f, 
    -0.01876469f, 0.00732651f, 0.00572456f, 0.01883048f, -0.01507202f, -0.00847284f, -0.03636237f, -0.03836118f, 
    0.00533306f, -0.03129731f, 0.02776373f, 0.01004150f, -0.02084253f, 0.00786154f, 0.00182807f, -0.02115712f, 
    0.00111438f, 0.02128575f, -0.02122935f, -0.00104496f, 0.01086948f, 0.02093867f, 0.00153033f, 0.01056001f, 
    0.00334881f, -0.02802551f, -0.02400812f, -0.02458399f, 0.00378553f, 0.00778653f, 0.00796479f, -0.03537721f, 
    0.01611532f, -0.03108228f, 0.03580991f, -0.00197302f, 0.01207418f, -0.00931246f, 0.00625240f, -0.03139406f, 
    0.17790754f, 0.25490665f, -0.17665173f, 0.14023989f, -0.02310311f, -0.04570106f, -0.07032897f, 0.00552792f, 
    0.00123827f, 0.02366687f, 0.06816617f, 0.02233058f, 0.02965713f, 0.06411175f, 0.20146060f, -0.07051180f, 
    -0.01436989f, 0.00893955f, 0.00268739f, -0.01345458f, -0.11896275f, 0.12735803f, 0.15159974f, 0.07819684f, 
    0.10580683f, -0.04854954f, -0.03347869f, -0.16887185f, -0.01916433f, 0.04681086f, 0.04801520f, -0.07860409f, 
    -0.01625816f, 0.07562882f, -0.10451955f, 0.09657221f, -0.09093964f, 0.04162520f, 0.15567064f, -0.10459463f, 
    -0.07262660f, -0.01766608f, 0.03628873f, -0.03086754f, 0.09834100f, 0.05728244f, 0.07123306f, -0.05872424f, 
    -0.15440293f, 0.04016118f, -0.21373148f, 0.18023744f, 0.18734303f, 0.16961658f, -0.02063528f, -0.06392148f, 
    0.07470298f, -0.07754125f, 0.01874407f, 0.04946193f, -0.35311747f, 0.12095483f, -0.12700011f, 0.18005385f, 
    0.08070327f, 0.02343474f, 0.08136048f, -0.02836531f, 0.09076935f, -0.01087574f, 0.04134751f, -0.01034943f, 
    0.13780518f, 0.22667165f, 0.09496685f, 0.26298818f, 0.04378444f, -0.12365805f, 0.08310374f, -0.06555060f, 
    0.07811724f, 0.01667316f, 0.03701945f, 0.10856947f, 0.09569293f, -0.02667024f, 0.16408382f, -0.09774929f, 
    0.05006083f, -0.02269697f, -0.01574089f, -0.04846524f, -0.02259738f, -0.12032356f, 0.09176672f, 0.07904116f, 
    0.11161096f, 0.11685111f, -0.11595783f, 0.11286807f, -0.09074428f, 0.03948378f, 0.04599036f, -0.05424190f, 
    0.00451370f, -0.09894525f, 0.07006947f, 0.14987467f, 0.11734927f, -0.12444079f, 0.17020209f, 0.00721807f, 
    0.08611622f, 0.07311947f, -0.02590910f, 0.03281080f, 0.05889477f, 0.07701251f, 0.02106894f, 0.06315892f, 
    0.05392804f, -0.00243704f, 0.07144316f, 0.02314248f, 0.07285933f, 0.05913428f, -0.03842637f, 0.06446689f, 
    -0.11949623f, -0.00792775f, 0.05775650f, -0.06423319f, 0.11598317f, 0.01335520f, 0.07656742f, -0.01534021f, 
    0.07355995f, -0.07736643f, -0.10196293f, 0.03418344f, -0.08253110f, -0.02165930f, 0.03258676f, -0.01353437f, 
    0.13688274f, -0.09389137f, 0.10346255f, -0.08781537f, -0.15264492f, -0.05708629f, -0.11484648f, 0.03529263f, 
    0.02562097f, -0.05461163f, 0.11510026f, -0.07594746f, -0.05485184f, -0.05401816f, -0.03099779f, 0.23086545f, 
    0.03288597f, 0.00504552f, -0.01357402f, 0.02237462f, 0.00621516f, -0.11622727f, 0.05204458f, 0.03382199f, 
    -0.19115630f, 0.05247763f, -0.13169217f, 0.19852525f, 0.12796195f, 0.01259096f, 0.10109183f, -0.12194618f, 
    0.04383520f, 0.20705554f, 0.01689725f, 0.00630210f, 0.09750844f, 0.15510938f, -0.02632153f, 0.00368493f, 
    -0.00823083f, -0.02212010f, -0.05665404f, 0.01051578f, 0.02457072f, -0.02314563f, 0.10374361f, -0.04763393f, 
    0.05895144f, 0.03106473f, 0.02546221f, 0.00602732f, 0.11204749f, -0.02920757f, 0.03800032f, -0.05766938f, 
    -0.04074804f, -0.01466724f, 0.03061232f, 0.03081447f, 0.05915346f, 0.06871853f, -0.00872576f, 0.01751675f, 
    0.06526545f, -0.01661612f, 0.03452210f, 0.10716595f, -0.00575260f, 0.09099701f, 0.10998125f, 0.02310878f, 
    0.00604434f, -0.09134440f, 0.00115679f, -0.03582836f, 0.08994804f, -0.05309821f, -0.05417542f, -0.02993322f, 
    0.02001062f, -0.01505309f, 0.04737553f, 0.02636614f, 0.16617775f, 0.00346427f, 0.01631568f, 0.08782284f, 
    -0.00151989f, 0.09299781f, 0.10211155f, -0.08584442f, -0.03943353f, -0.10487258f, 0.09311914f, -0.01971662f, 
    0.00477943f, -0.03108906f, 0.11176280f, 0.11004034f, -0.03544921f, -0.00413992f, 0.05719777f, -0.08441198f, 
    0.20230097f, -0.00595503f, -0.05617622f, -0.00111715f, 0.06666434f, 0.04037500f, 0.00007116f, 0.19730805f, 
    0.10491355f, -0.09159113f, -0.12953299f, 0.03652279f, 0.04033612f, 0.00649148f, 0.28987068f, 0.08634584f, 
    -0.07518894f, 0.15973327f, 0.00261581f, 0.13440257f, 0.10449919f, 0.00229008f, 0.01626612f, 0.04931383f, 
    0.03511894f, 0.06372980f, 0.05814585f, -0.09013048f, 0.03604933f, -0.18929680f, 0.13702126f, 0.00222615f, 
    0.08119709f, 0.01016505f, 0.03684204f, -0.11990672f, 0.03802503f, 0.18794814f, -0.11780928f, 0.04477971f, 
    0.08073824f, 0.18002756f, -0.01032733f, 0.13156807f, 0.02005243f, 0.06553210f, 0.14905265f, -0.09058440f, 
    0.00227187f, -0.00204101f, -0.00221264f, 0.01937343f, -0.28152710f, -0.14708686f, 0.07390275f, 0.17775427f, 
    0.01560783f, -0.02960036f, 0.03810655f, -0.01205607f, 0.04436239f, 0.01409689f, 0.06581251f, -0.05214007f, 
    0.15039298f, 0.04438932f, 0.07318256f, -0.01763504f, 0.01814527f, 0.09189116f, -0.03295019f, 0.02444424f, 
    0.08183648f, 0.02496408f, -0.06098873f, 0.27726492f, -0.09520183f, -0.03759136f, 0.04942377f, -0.17049190f, 
    0.00871101f, 0.01602112f, 0.05220209f, -0.08171383f, -0.00548122f, 0.06852948f, 0.05747245f, -0.05829622f, 
    0.02156041f, 0.16252314f, 0.19164887f, -0.06812488f, -0.10638777f, -0.04152072f, -0.04827804f, -0.08000509f, 
    0.10546669f, 0.04021739f, 0.02305744f, -0.02118064f, -0.22196554f, -0.05105866f, 0.08757595f, 0.04213229f, 
    0.07929514f, -0.06838118f, 0.08650989f, 0.00364316f, 0.01991232f, 0.08333403f, 0.08825459f, 0.02059199f, 
    0.13695449f, -0.07210764f, 0.28528628f, -0.16960771f, 0.02708207f, -0.01629848f, 0.16627012f, 0.01945626f, 
    0.03142846f, -0.08246462f, 0.03393035f, -0.03247907f, 0.17136674f, -0.10104230f, 0.12585752f, -0.14538293f, 
    0.06827975f, -0.09151568f, 0.15644421f, -0.05588361f, -0.03774763f, -0.00090149f, -0.01653570f, 0.03303138f, 
    -0.22158827f, 0.11296217f, -0.16080095f, -0.03312269f, -0.04009036f, 0.10768843f, -0.01476074f, -0.01345421f, 
    0.11310160f, -0.05920608f, -0.01823729f, 0.04434098f, -0.38925564f, -0.02865690f, -0.06877834f, 0.05490846f, 
    -0.05923846f, 0.11575140f, 0.05746253f, 0.00713588f, -0.02819629f, 0.06355114f, 0.06367222f, 0.01388350f, 
    -0.15793931f, 0.01188080f, 0.11615726f, 0.04469207f, 0.03853145f, -0.05672628f, -0.02417121f, -0.03415951f, 
    0.03850041f, 0.06258079f, 0.11899456f, 0.00150591f, -0.05492398f, -0.07306939f, -0.08147186f, -0.06083367f, 
    -0.14097439f, -0.00481897f, -0.06460655f, 0.00117300f, -0.05297238f, -0.06749813f, -0.04485518f, -0.03369606f, 
    -0.12650353f, -0.06752739f, -0.00328863f, 0.12809144f, 0.01935939f, -0.09481993f, -0.00613661f, 0.04157962f, 
    -0.02321721f, 0.03946038f, 0.07172882f, 0.11148367f, -0.29855651f, 0.05624739f, -0.04480838f, 0.15946792f, 
    0.12155554f, 0.06735801f, -0.06850807f, 0.01956835f, -0.02595471f, -0.14712436f, -0.05671680f, -0.01146504f, 
    -0.10798897f, 0.05719824f, -0.00692114f, 0.11394968f, -0.12631692f, -0.03508406f, -0.09009359f, 0.04961465f, 
    -0.01754702f, -0.04812421f, -0.05599584f, 0.15779324f, -0.02007819f, -0.03113449f, 0.19281617f, 0.08387780f, 
    0.11815728f, -0.01857034f, -0.08194895f, -0.05817645f, -0.00686975f, 0.08735220f, 0.01342453f, 0.00367147f, 
    -0.22370327f, -0.04848474f, 0.07738717f, -0.04727492f, -0.00458853f, 0.11838278f, 0.05510307f, -0.05797055f, 
    -0.02510185f, 0.06139166f, 0.07529495f, -0.08607708f, 0.04282556f, 0.00871293f, 0.05036809f, 0.08040041f, 
    0.03206658f, 0.00837889f, 0.11340255f, -0.04779441f, -0.01869706f, -0.03648945f, 0.03676941f, 0.11012085f, 
    -0.01910261f, 0.04814135f, -0.05333997f, -0.06070472f, 0.07046194f, 0.19878711f, 0.04106904f, -0.11289719f, 
    0.00288034f, 0.01086710f, -0.01660875f, 0.16439289f, -0.18458268f, 0.01250975f, -0.04674818f, -0.05243973f, 
    0.03744637f, 0.08070163f, 0.02007022f, -0.07355553f, 0.10219398f, 0.03390455f, -0.00201593f, -0.02476729f, 
    0.33195248f, -0.03466991f, 0.16812141f, -0.18838768f, -0.05725811f, -0.09720435f, -0.07946440f, 0.05505711f, 
    0.02333338f, 0.03531957f, -0.09417149f, -0.00814898f, -0.14074910f, -0.01252149f, 0.09392079f, 0.05591981f, 
    -0.03241464f, 0.07308178f, 0.04664102f, -0.00057247f, 0.04684895f, -0.00236699f, 0.09695485f, 0.13577940f, 
    -0.22581714f, -0.05378400f, -0.02776663f, 0.20993423f, 0.04277154f, 0.02650545f, -0.01182114f, 0.02194491f, 
    0.06839629f, 0.03814583f, 0.03098380f, 0.04784196f, 0.30241936f, 0.03986859f, 0.15688883f, 0.05605125f, 
    -0.02676641f, 0.02728751f, -0.08363384f, 0.03925819f, 0.07555260f, 0.06462151f, 0.00126431f, -0.02784546f, 
    -0.17384785f, 0.08525282f, 0.07680028f, -0.06392589f, 0.06722779f, 0.04118549f, 0.15476073f, -0.10785507f, 
    0.00488118f, 0.02206196f, -0.03503253f, 0.16928698f, 0.14422612f, -0.12963063f, 0.13598563f, 0.08258522f, 
    -0.00575199f, -0.02761778f, -0.04622605f, 0.01465753f, 0.03402351f, -0.06135307f, -0.09259400f, 0.03053841f, 
    0.07087341f, -0.24893118f, 0.12065956f, -0.09103676f, 0.12033704f, -0.02128960f, 0.00797546f, 0.06034892f, 
    -0.02547291f, 0.02376093f, 0.04485840f, 0.04869162f, 0.09948036f, -0.11934515f, -0.00444285f, -0.16267127f, 
    -0.17258705f, 0.05588214f, -0.03503660f, -0.05051924f, -0.06048087f, -0.06528983f, -0.04517212f, 0.03880318f, 
    -0.11881407f, 0.18846589f, -0.00262449f, -0.09036966f, -0.03023140f, -0.00678690f, 0.07993402f, 0.03043817f, 
    0.07860314f, 0.03470796f, 0.07341132f, 0.10378526f, 0.21220246f, 0.09721889f, 0.09290794f, -0.05094382f, 
    0.01024912f, -0.04144460f, 0.02786250f, -0.07771643f, -0.05766626f, -0.03589660f, 0.04192042f, -0.04515639f, 
    0.05377783f, 0.13086194f, 0.08374956f, 0.10243089f, 0.04087957f, 0.08334671f, 0.00617999f, 0.06407150f, 
    -0.04783981f, -0.04453713f, 0.02949081f, -0.06470409f, -0.19606574f, 0.08664116f, -0.10146935f, -0.04185473f, 
    -0.12163433f, 0.01052501f, 0.02970927f, -0.01241345f, -0.00445530f, 0.11654246f, 0.10794682f, 0.05365118f, 
    -0.34639314f, 0.09299167f, 0.06030839f, 0.01684079f, 0.03222187f, 0.10709677f, -0.02143067f, -0.01328311f, 
    0.01316894f, -0.10850581f, 0.00804280f, 0.19278038f, -0.30718926f, 0.03058482f, -0.29366785f, 0.25043115f, 
    0.04945239f, 0.02111756f, -0.00803892f, 0.03268750f, 0.03228042f, -0.10288036f, -0.06787379f, -0.07571802f, 
    0.02276133f, -0.05787649f, 0.01799487f, -0.12936863f, 0.18240909f, 0.11684217f, -0.09067238f, -0.02722521f, 
    -0.02599704f, 0.09688855f, 0.11754279f, -0.12258972f, -0.04795625f, 0.03908168f, -0.06392875f, 0.00641762f, 
    0.05822989f, -0.09480070f, 0.00020287f, -0.10799123f, -0.08385223f, -0.02244910f, -0.12219498f, 0.21933751f, 
    -0.30516762f, -0.07827004f, -0.00037431f, -0.04552253f, -0.07811129f, 0.05650178f, 0.15705821f, -0.06429188f, 
    0.11800006f, 0.07435483f, -0.17104062f, 0.07450405f, 0.12416826f, 0.17089120f, -0.20677398f, 0.14071953f, 
    0.06915754f, -0.06659469f, -0.08721022f, 0.05952326f, 0.03101834f, -0.02183479f, -0.13849664f, -0.01783108f, 
    -0.02355500f, -0.00124865f, -0.07564038f, -0.12493871f, -0.14394429f, 0.18707205f, 0.06788234f, -0.04491614f, 
    0.12332053f, -0.05431279f, -0.12277893f, -0.02542473f, -0.31361067f, -0.04178112f, -0.07423551f, 0.17683606f, 
    0.22495171f, -0.04238353f, -0.04989221f, -0.01536161f, -0.02697650f, 0.03755050f, -0.04062206f, 0.02972740f, 
    -0.03277199f, 0.00619485f, -0.03413246f, 0.01362358f, -0.00045610f, -0.03446780f, -0.00435791f, 0.02946334f, 
    0.01660050f, -0.01985316f, 0.00406863f, -0.01909967f, 0.00749838f, -0.03820174f, 0.02213884f, -0.01052623f, 
    -0.04339248f, -0.02726592f, -0.02628255f, -0.03093846f, -0.02581340f, -0.02258980f, -0.00589516f, -0.02077421f, 
    -0.01213957f, 0.02077096f, 0.00825680f, -0.03234249f, 0.00389814f, -0.03573053f, -0.01413904f, -0.02081713f, 
    -0.03315773f, -0.01430921f, -0.01828651f, 0.01342991f, -0.00693445f, 0.02972014f, -0.01831324f, -0.00101702f, 
    -0.02486503f, -0.00702070f, -0.01803557f, 0.00607428f, -0.01120265f, -0.00122875f, -0.01816863f, -0.00003219f, 
    0.02172727f, -0.01553240f, 0.02586971f, 0.01004123f, -0.01814506f, 0.01712482f, -0.03590897f, -0.02546280f, 
    0.01430826f, 0.00587815f, 0.01195083f, 0.02061871f, -0.00888782f, -0.01013521f, 0.01581771f, -0.03470196f, 
    0.00050946f, 0.01538716f, 0.00943931f, -0.01516314f, -0.00103557f, -0.00959714f, 0.01148774f, -0.02360881f, 
    -0.02215969f, 0.00953110f, -0.01733725f, -0.02897122f, -0.03636211f, -0.00318715f, -0.00979557f, -0.01232186f, 
    -0.02765020f, 0.00643624f, -0.02046773f, -0.01828728f, 0.01588406f, -0.03884101f, -0.04326401f, -0.00327478f, 
    0.01123037f, 0.00631660f, 0.01153091f, 0.01900570f, -0.02030885f, -0.04111802f, 0.02597260f, 0.02707073f, 
    0.02092879f, -0.03075923f, -0.03719439f, -0.03876488f, -0.01847723f, -0.02525090f, -0.03850628f, 0.00557847f, 
    -0.03851628f, -0.00014617f, -0.02151395f, -0.00112341f, -0.00042902f, 0.01490985f, 0.01346881f, -0.00802442f, 
    -0.02892264f, -0.01819163f, -0.02192439f, -0.00099917f, -0.03018227f, 0.00778890f, -0.04308381f, 0.01325767f, 
    -0.03595101f, -0.02274226f, -0.02541031f, 0.01198458f, 0.00358882f, 0.02233928f, 0.00507046f, 0.02355172f, 
    -0.01645726f, -0.03599060f, -0.03179979f, 0.00801358f, -0.00085734f, 0.02413833f, -0.01169490f, 0.01533140f, 
    -0.02754902f, -0.00589690f, 0.00496998f, -0.00285367f, -0.04153613f, -0.03980604f, 0.02800629f, -0.00472282f, 
    0.01979618f, 0.01844361f, -0.02407932f, -0.01627788f, -0.00721825f, 0.00881807f, -0.02823018f, -0.03429481f, 
    -0.00723222f, -0.00911456f, -0.04223085f, -0.02237853f, -0.03905144f, 0.02156956f, 0.01070870f, 0.00908013f, 
    0.00737126f, 0.02219832f, 0.01111615f, 0.02200971f, -0.02558114f, 0.03115414f, 0.00962732f, 0.01931078f, 
    0.02505079f, -0.02319044f, 0.00295780f, -0.00464577f, 0.01033394f, -0.00399520f, -0.00565117f, -0.03180793f, 
    -0.01639150f, -0.00718506f, -0.01538492f, 0.01239838f, 0.01139256f, -0.00751003f, -0.03118775f, 0.00546472f, 
    -0.03040598f, 0.01569781f, 0.02655135f, -0.01317670f, 0.02862679f, -0.04144984f, -0.03196421f, 0.02515751f, 
    0.00953460f, 0.00093646f, 0.01959326f, -0.00883191f, -0.02770830f, 0.00365333f, 0.00285906f, 0.01891822f, 
    0.01215428f, -0.03349568f, -0.00608320f, -0.03178596f, -0.01222720f, -0.02266972f, 0.00408296f, -0.03321499f, 
    -0.02713594f, -0.04232665f, -0.04120031f, 0.00534356f, 0.02899473f, -0.03109324f, 0.02252228f, -0.03606831f, 
    0.02253171f, -0.00837823f, 0.00699880f, 0.01465904f, -0.02888922f, -0.03282441f, 0.02819330f, 0.01955068f, 
    0.00424390f, 0.01321057f, -0.03514826f, -0.00793127f, -0.00405892f, -0.03458147f, -0.01721255f, 0.02234313f, 
    0.00188503f, 0.00522233f, 0.00810219f, 0.01234755f, -0.00172293f, -0.02682356f, -0.03447928f, -0.03205663f, 
    0.03019889f, 0.00968070f, -0.03091858f, -0.01363108f, -0.03374071f, -0.02887839f, -0.03247908f, -0.01586466f, 
    -0.03180565f, 0.02422993f, 0.02767401f, 0.00275052f, 0.01028724f, -0.00983260f, -0.04171363f, 0.01550728f, 
    0.02482005f, -0.01776583f, -0.02910316f, 0.01679445f, -0.00920165f, -0.04042311f, 0.01246985f, 0.02612054f, 
    -0.02423408f, 0.00250404f, -0.00449424f, -0.01275054f, -0.04014955f, -0.00127609f, -0.00876322f, 0.01456386f, 
    0.03236936f, 0.02791834f, 0.02858222f, -0.03126521f, -0.01713336f, 0.01348076f, -0.03285709f, 0.02649608f, 
    -0.03672131f, -0.03200409f, -0.02152959f, 0.00504208f, -0.01783321f, -0.01244932f, -0.04146807f, -0.02289175f, 
    0.02816499f, -0.03337552f, -0.03251707f, -0.03481260f, 0.02697622f, -0.02558233f, -0.01394788f, 0.00355347f, 
    0.00603844f, 0.02766864f, -0.01342100f, 0.01659355f, -0.03418144f, -0.01090193f, -0.02169246f, 0.00029621f, 
    -0.01644408f, -0.00555382f, 0.00868074f, -0.02301646f, -0.03066625f, 0.03005494f, 0.02917753f, -0.02997322f, 
    -0.00989194f, 0.02432918f, 0.01678108f, -0.03662514f, -0.02929126f, 0.00419724f, -0.02069069f, -0.02914663f, 
    0.02675872f, -0.02186616f, 0.01715230f, 0.02885856f, -0.00627736f, 0.00976664f, -0.00209691f, 0.02771161f, 
    -0.02183074f, 0.02786960f, 0.02278894f, -0.01290672f, -0.00504304f, -0.02759110f, -0.00114100f, -0.02214842f, 
    -0.04104400f, -0.01067239f, 0.01665708f, -0.01106112f, -0.01677647f, -0.01398183f, -0.00797676f, 0.00283476f, 
    0.01589952f, -0.03740604f, 0.00155889f, 0.00932921f, -0.01901743f, -0.02506082f, -0.00539553f, -0.00880768f, 
    0.02872694f, 0.00103558f, -0.02139604f, 0.00321160f, 0.02865959f, 0.02286593f, 0.02158082f, 0.01841975f, 
    -0.00889425f, 0.01399748f, -0.00038806f, -0.02570571f, -0.00329627f, -0.01820582f, -0.01151524f, -0.01875010f, 
    0.00237015f, 0.02432313f, 0.00434912f, 0.02135256f, -0.02800029f, 0.02887976f, -0.02975844f, -0.02348017f, 
    0.01628162f, 0.00539839f, 0.02367269f, -0.01516811f, -0.02416558f, -0.02398108f, -0.00805836f, 0.01136716f, 
    -0.00855429f, -0.03164706f, -0.03150472f, 0.02756532f, 0.01328150f, 0.02360880f, 0.01450791f, -0.01282084f, 
    0.01284379f, -0.03565957f, 0.01486234f, -0.02276555f, -0.02075149f, -0.02571738f, -0.02530950f, 0.01695963f, 
    -0.01502590f, -0.04180834f, 0.00412145f, -0.03003832f, 0.02508426f, 0.00801801f, -0.03306702f, -0.00997612f, 
    0.02279533f, 0.02793629f, 0.02070093f, 0.00752906f, -0.04164575f, -0.00404906f, -0.03167485f, -0.03219797f, 
    0.02325386f, 0.00635171f, -0.03323366f, 0.00928654f, -0.02633593f, -0.02785388f, 0.02802301f, -0.00614566f, 
    0.01811908f, 0.02956638f, -0.00741185f, 0.02192696f, -0.03352287f, 0.00315147f, 0.01021142f, 0.01289961f, 
    -0.02915006f, 0.00577342f, -0.01803485f, 0.02856170f, 0.01361161f, 0.00818355f, -0.00312047f, 0.00347854f, 
    -0.03669719f, -0.03951285f, -0.00502486f, 0.00134927f, 0.02800616f, -0.03412615f, -0.01660000f, -0.02416125f, 
    -0.03713018f, 0.02601906f, 0.02116705f, -0.03610279f, -0.00004796f, -0.02820968f, 0.00027270f, 0.00719124f, 
    0.02680393f, -0.01850013f, 0.02223507f, -0.01194365f, 0.01227535f, -0.00619658f, -0.02111120f, -0.00916841f, 
    -0.00580178f, 0.02785014f, -0.02025121f, -0.01657085f, -0.00686248f, 0.02507378f, -0.02483566f, 0.02035343f, 
    -0.03499391f, 0.00530890f, 0.02006846f, 0.00242207f, 0.00406346f, 0.01349998f, 0.02602644f, 0.02173232f, 
    0.00585304f, -0.00487180f, -0.02589611f, 0.00913706f, -0.01917455f, -0.02835983f, -0.00803455f, 0.01932409f, 
    -0.02198632f, -0.02798859f, 0.02719173f, -0.02677424f, -0.03374887f, 0.00385610f, -0.00850414f, -0.03896824f, 
    -0.01846754f, -0.03669981f, -0.03356702f, -0.00113752f, -0.03337789f, 0.01779459f, -0.01378638f, 0.01631654f, 
    -0.04065459f, 0.01825223f, 0.02099126f, 0.00537710f, -0.00575892f, -0.01714963f, -0.03217284f, -0.02364580f, 
    0.02480820f, 0.02430313f, 0.01359868f, -0.04100591f, 0.01165235f, -0.01006483f, -0.04147515f, -0.02253083f, 
    -0.01080490f, 0.01786055f, -0.03280705f, 0.01828043f, 0.02839255f, -0.01075453f, -0.03872122f, 0.00125437f, 
    -0.03602671f, 0.00499643f, -0.03500554f, -0.00589060f, -0.01732607f, -0.00029870f, 0.00631202f, 0.02457112f, 
    -0.00674130f, 0.01539198f, -0.01756458f, -0.01753050f, -0.02308507f, 0.01070414f, 0.02228843f, 0.01460297f, 
    -0.02697885f, 0.02785037f, -0.01433840f, 0.01807598f, 0.03079876f, 0.02120742f, -0.03253492f, 0.00865205f, 
    0.02706953f, 0.02384961f, -0.03069301f, -0.00598858f, -0.01821008f, 0.01582258f, -0.01032599f, -0.01565964f, 
    -0.02560231f, 0.02869662f, 0.01021738f, -0.02736939f, -0.02929660f, -0.04050533f, 0.00996214f, -0.00834968f, 
    0.01653998f, -0.00125907f, 0.01459524f, -0.00604190f, -0.00759024f, 0.01622283f, 0.02251634f, -0.03572167f, 
    -0.04052130f, -0.01532431f, 0.02566691f, -0.00215506f, -0.00345110f, -0.02986274f, -0.03382928f, -0.02150280f, 
    0.01550127f, -0.00198263f, -0.00508683f, 0.00030271f, -0.00753011f, 0.00493683f, -0.02701144f, -0.03232294f, 
    0.02826525f, -0.02024668f, -0.00683149f, 0.01736282f, -0.01072144f, 0.02344508f, 0.00314587f, 0.01678793f, 
    -0.00891806f, 0.01034573f, -0.02627906f, 0.02541335f, -0.03132589f, 0.00006594f, -0.01111704f, -0.02582933f, 
    -0.01728674f, -0.03130422f, -0.02816783f, -0.02501481f, 0.02456207f, -0.03799880f, -0.01098376f, 0.02102172f, 
    -0.02129965f, 0.00175063f, 0.02395889f, -0.02879186f, 0.01417026f, 0.02857338f, -0.02894916f, -0.02985249f, 
    -0.00155589f, 0.00934133f, -0.01411476f, -0.03940827f, -0.04008686f, -0.04108665f, -0.03379546f, 0.02111044f, 
    0.01947401f, 0.02209413f, -0.03760139f, 0.02676213f, -0.01737795f, 0.00048369f, 0.01466689f, -0.00702066f, 
    -0.02181819f, 0.00077854f, -0.00657079f, -0.02269204f, -0.02496541f, -0.04078528f, -0.01970406f, -0.03424585f, 
    -0.02950655f, 0.00924202f, 0.02011063f, -0.01794668f, -0.04151767f, 0.01393341f, -0.03027498f, -0.03762555f, 
    0.00512255f, -0.00485032f, 0.02356759f, -0.03057627f, -0.01631142f, 0.01927063f, -0.01758596f, 0.01502398f, 
    -0.00562930f, -0.02511826f, -0.02686690f, -0.00154680f, -0.03582964f, -0.03926953f, -0.01081879f, 0.00630728f, 
    -0.03816945f, 0.02448998f, -0.00741365f, -0.01610253f, -0.00188929f, 0.01078970f, -0.01015167f, -0.03401072f, 
    -0.01614727f, 0.00221496f, -0.03054695f, -0.03860098f, 0.00829960f, 0.00339753f, -0.01098563f, 0.01268058f, 
    0.02024581f, -0.02116281f, 0.00019339f, -0.01497841f, 0.01085006f, 0.00795142f, 0.00474382f, 0.01606359f, 
    0.02171623f, -0.03339629f, 0.01512744f, 0.01021836f, 0.00955196f, -0.03680542f, 0.00226751f, -0.01491113f, 
    -0.00859018f, -0.01294849f, 0.01818650f, -0.00301533f, 0.00343758f, -0.03515953f, -0.00927973f, 0.01855426f, 
    0.02540026f, -0.02516876f, -0.02650779f, -0.01376905f, 0.01859237f, -0.03865932f, 0.01408172f, 0.02206834f, 
    0.01632817f, -0.03668404f, -0.01828223f, -0.02970544f, -0.00927302f, -0.02017183f, -0.00354965f, -0.03787751f, 
    0.01294667f, -0.03413082f, 0.00171453f, -0.00942071f, -0.02489923f, 0.00489372f, -0.03141210f, -0.03404537f, 
    -0.01148128f, -0.00038798f, 0.02442101f, -0.00891032f, -0.00234853f, 0.02323755f, 0.00702443f, 0.02815899f, 
    -0.03276490f, -0.00444031f, -0.03510941f, -0.02070290f, 0.01359817f, -0.00783949f, -0.01138372f, -0.00438116f, 
    -0.03325670f, -0.02666201f, 0.01738680f, 0.02192732f, -0.00379178f, -0.01876979f, 0.01377651f, 0.03033615f, 
    -0.02847991f, 0.00058919f, -0.02567113f, 0.00215952f, -0.01809705f, -0.00477459f, 0.01442263f, -0.02200571f, 
    -0.28570065f, 0.01126830f, 0.27658087f, -0.08689418f, -0.01246520f, 0.05397893f, 0.00813618f, 0.02178675f, 
    0.07153562f, 0.03997126f, 0.03840880f, 0.01845087f, -0.12344807f, 0.16168296f, -0.03068122f, -0.05827352f, 
    0.06845231f, -0.12500994f, -0.02805924f, -0.04614485f, 0.00546779f, -0.12638496f, -0.07107062f, 0.10803510f, 
    0.49426213f, 0.06865865f, -0.04973315f, 0.17143707f, 0.09030994f, 0.06221017f, 0.11293156f, 0.10122705f, 
    -0.00672562f, -0.04134715f, -0.08057642f, 0.03209997f, 0.04322882f, 0.18524213f, 0.03547092f, 0.01348749f, 
    0.05812531f, -0.02413318f, -0.09067564f, -0.00119374f, -0.05414756f, 0.10532383f, 0.10649510f, 0.09274100f, 
    0.21438029f, -0.06881300f, 0.17787965f, -0.10885622f, 0.01565596f, -0.08519392f, 0.03667364f, 0.11051077f, 
    -0.05538774f, -0.06347631f, -0.03437060f, 0.01494746f, -0.00728056f, 0.10795011f, 0.16455793f, -0.05530176f, 
    0.14330800f, 0.03773364f, -0.05139534f, -0.07775702f, -0.08206332f, -0.10143371f, 0.00506290f, -0.02747853f, 
    -0.36472744f, -0.05125203f, 0.10115898f, 0.16612412f, -0.03408029f, 0.10355258f, 0.02215038f, 0.04680372f, 
    0.02007144f, -0.01754008f, -0.04187742f, -0.08882695f, 0.01426984f, -0.19285780f, 0.02956412f, 0.03002814f, 
    -0.01593383f, 0.04461810f, -0.05907671f, 0.07095528f, 0.01654137f, 0.14060488f, 0.03730489f, -0.02670633f, 
    0.16779618f, -0.11243588f, 0.03818170f, -0.01139818f, 0.17557518f, -0.04744214f, 0.03815414f, 0.02742305f, 
    0.10060292f, 0.03881657f, 0.05084962f, -0.08911793f, 0.47140768f, -0.24508394f, -0.07588213f, 0.04712524f, 
    -0.00534541f, -0.01801274f, -0.09530120f, 0.02245470f, 0.01876274f, 0.06822622f, 0.06964208f, -0.02687742f, 
    -0.07913986f, -0.16732976f, -0.09745812f, -0.16128869f, -0.05463302f, -0.03409302f, 0.03296330f, -0.07258957f, 
    -0.09779558f, 0.08763946f, -0.15970300f, 0.00603461f, 0.15491663f, -0.11884684f, -0.08141436f, 0.14804704f, 
    0.03975831f, 0.04279956f, 0.08539128f, 0.00137983f, 0.00826217f, -0.11698721f, -0.01328051f, -0.07587424f, 
    -0.32207334f, 0.24990316f, -0.05843081f, -0.15016794f, 0.11833968f, 0.00675558f, 0.00589077f, -0.01794419f, 
    0.00296035f, 0.12321074f, -0.05964382f, 0.01231236f, -0.05165498f, 0.22197574f, -0.03420868f, -0.28567830f, 
    -0.01948913f, -0.02458377f, 0.03990537f, 0.00361990f, -0.08792111f, 0.06240670f, 0.01383881f, 0.02111394f, 
    0.01430122f, 0.16904974f, 0.09597227f, 0.03448397f, 0.05621214f, -0.09873652f, 0.14291470f, 0.05437431f, 
    -0.04608041f, -0.05136346f, -0.09098298f, 0.02659272f, 0.15874030f, -0.16700278f, 0.13188121f, -0.06334263f, 
    0.09179166f, 0.08011564f, 0.01811376f, -0.13443308f, -0.05187152f, 0.00595714f, -0.20728055f, 0.00244869f, 
    0.07221152f, -0.09022430f, -0.03855550f, 0.18173371f, 0.01310459f, 0.11227506f, 0.00059874f, 0.10008369f, 
    0.06955211f, -0.09492677f, -0.00148985f, 0.03130312f, -0.16870613f, -0.12683560f, 0.06712710f, -0.02459977f, 
    0.06221502f, 0.03539330f, -0.05524507f, -0.03630017f, -0.06554323f, -0.03005752f, -0.07258434f, 0.03762218f, 
    0.31505919f, -0.02974848f, -0.10651632f, 0.09220636f, 0.15898143f, -0.01502103f, 0.01538847f, -0.13657340f, 
    0.04621270f, -0.05192291f, -0.02054268f, -0.03416191f, 0.15359285f, -0.28945729f, -0.01823678f, 0.05401891f, 
    0.04103053f, 0.06655665f, -0.02080884f, -0.02541491f, -0.02814168f, 0.15110612f, 0.05365860f, 0.02939108f, 
    0.02909510f, 0.12714547f, -0.02877206f, -0.10710694f, 0.08062421f, 0.09242506f, -0.03879247f, 0.10628859f, 
    -0.02528764f, 0.11960410f, 0.02313589f, 0.13986456f, -0.14843163f, 0.15366878f, -0.02399009f, -0.16682063f, 
    0.03183237f, 0.00227569f, -0.10890847f, -0.00390285f, -0.10997748f, -0.00961520f, -0.19760202f, 0.00704468f, 
    -0.40374100f, -0.02227852f, 0.11119506f, -0.14095426f, -0.07479340f, 0.03332182f, 0.00366925f, -0.00673811f, 
    0.07419027f, 0.03712645f, -0.10765888f, 0.13543931f, 0.46246096f, -0.26705888f, -0.21438503f, 0.04763140f, 
    0.06754803f, 0.01176204f, -0.03061523f, 0.00881735f, 0.02852401f, -0.10306744f, -0.02886440f, -0.04415239f, 
    0.08568487f, 0.09747081f, 0.17628117f, 0.08110030f, 0.09380083f, 0.09016248f, -0.03431113f, 0.11738443f, 
    0.01167854f, 0.01539132f, 0.04153568f, 0.03377530f, -0.32892510f, -0.02125301f, 0.05575734f, 0.02472917f, 
    -0.08759411f, 0.16393472f, 0.11620820f, 0.00086328f, -0.07380488f, 0.01022283f, -0.03769770f, -0.01792134f, 
    0.14328583f, -0.08084457f, 0.04990855f, 0.18046294f, 0.15966840f, 0.00220109f, 0.12473831f, -0.09460209f, 
    -0.04081863f, 0.01892651f, 0.05079568f, -0.13762133f, 0.12755522f, 0.11307380f, 0.02133286f, 0.23262878f, 
    0.02351135f, -0.03316376f, 0.01916035f, 0.06297660f, 0.07496785f, 0.09207004f, -0.02814122f, 0.06691416f, 
    0.21827875f, -0.08531757f, -0.02155956f, -0.11119542f, 0.09285808f, 0.12641720f, -0.05576581f, -0.08075172f, 
    0.01250676f, 0.00984391f, 0.10064038f, 0.05424353f, -0.16888721f, 0.19675417f, 0.05040043f, -0.21253143f, 
    -0.03532821f, 0.17086983f, -0.05049266f, -0.11099663f, -0.11786864f, 0.00524408f, 0.03758882f, 0.03919300f, 
    0.21197623f, -0.01586416f, -0.12298419f, 0.12461672f, -0.10836302f, -0.03151910f, -0.07129390f, -0.00022220f, 
    0.03068917f, 0.06758274f, -0.01970181f, 0.11517470f, 0.48357052f, -0.18250355f, -0.19758503f, -0.06545921f, 
    -0.27422374f, 0.07152528f, -0.09640916f, 0.10980565f, 0.04696105f, 0.15984465f, 0.10818412f, -0.01394932f, 
    0.16453880f, 0.09498479f, 0.05755408f, 0.01884564f, 0.10331453f, 0.01454791f, -0.08495668f, 0.02119646f, 
    0.03389367f, 0.06584141f, -0.02612671f, -0.01711123f, 0.01662587f, 0.30926034f, 0.21005008f, -0.01527481f, 
    -0.00444656f, -0.00368861f, 0.12655948f, -0.08948494f, -0.04779401f, -0.05209314f, -0.01551127f, 0.03555269f, 
    0.06107873f, 0.00569089f, 0.04596446f, -0.00688028f, 0.06661443f, 0.08373419f, 0.00166502f, -0.08549108f, 
    -0.04503009f, -0.09177737f, 0.04908595f, 0.16040201f, 0.24606453f, 0.16297568f, 0.09272104f, -0.01075019f, 
    0.11384537f, -0.05976995f, -0.00503793f, 0.03928271f, 0.05142960f, 0.09256560f, -0.12221837f, 0.05147979f, 
    -0.14223972f, 0.04065606f, 0.03381395f, -0.06924166f, 0.03770623f, 0.00027457f, 0.00996320f, -0.06680053f, 
    -0.11161391f, 0.10124377f, 0.04297234f, 0.03138062f, -0.09496906f, 0.15913776f, 0.10200461f, -0.02927836f, 
    -0.09940267f, 0.06254340f, 0.14968424f, -0.05376085f, -0.04981607f, 0.03915615f, -0.04300229f, 0.00894673f, 
    0.22559036f, 0.19172181f, 0.09257299f, 0.00165961f, 0.11504943f, -0.03177524f, 0.03234450f, -0.09978054f, 
    -0.00581449f, -0.10229551f, 0.03982136f, -0.05930262f, 0.10921553f, -0.07201350f, -0.09187420f, -0.06399921f, 
    -0.06200612f, -0.11718015f, 0.01021530f, -0.10088334f, -0.01718064f, 0.06750692f, 0.03166977f, 0.04554780f, 
    0.04740302f, -0.03655052f, -0.01829304f, 0.04282692f, 0.03833390f, -0.02772129f, -0.02732017f, -0.00088269f, 
    0.05581237f, 0.09158577f, 0.00062914f, 0.09628971f, 0.10657938f, -0.12275149f, -0.02447473f, 0.06746961f, 
    -0.01235537f, -0.08883115f, -0.08775225f, -0.03516893f, 0.02997147f, 0.03897334f, 0.00734208f, -0.09346559f, 
    0.17829886f, 0.09446112f, 0.04751939f, 0.09619538f, 0.06578592f, -0.08446891f, 0.06896181f, -0.05564586f, 
    0.01385889f, 0.15444215f, 0.06812168f, 0.04641862f, 0.06502223f, -0.09424791f, -0.00633789f, 0.12071612f, 
    0.06309558f, 0.09029115f, -0.15429609f, 0.10091340f, -0.00275386f, -0.05506039f, -0.01564600f, 0.11807993f, 
    0.27601746f, -0.19538218f, -0.07998187f, 0.00755433f, 0.01019368f, 0.06651381f, -0.02000703f, 0.00243637f, 
    0.04774347f, 0.01316109f, 0.05988449f, -0.05556061f, -0.08312507f, 0.31238955f, -0.07501644f, -0.29992375f, 
    0.07224296f, -0.06924347f, -0.00842757f, 0.01346393f, -0.07611473f, 0.05297200f, 0.07452374f, -0.13081951f, 
    0.02688074f, 0.10387608f, 0.05351486f, -0.06591780f, -0.10607876f, -0.04431951f, 0.04571656f, -0.09767887f, 
    -0.00754206f, 0.01543394f, 0.10884028f, -0.03184878f, -0.80479133f, -0.01460003f, 0.05330336f, -0.04466080f, 
    -0.01635236f, -0.06046396f, -0.03718432f, 0.03645178f, -0.15977590f, -0.03449696f, 0.02519788f, 0.00320863f, 
    0.28668568f, -0.02354430f, 0.04188544f, 0.12251278f, 0.11536133f, 0.04685793f, -0.03532767f, 0.04497891f, 
    0.06242764f, 0.00111218f, -0.02230946f, -0.06311968f, 0.25385061f, -0.09591309f, -0.03810122f, -0.06008360f, 
    0.02440902f, -0.01985404f, 0.02575035f, -0.01093075f, -0.09082232f, 0.02911665f, 0.04488814f, -0.04650801f, 
    0.02650668f, 0.10541132f, -0.04838195f, 0.14514224f, -0.05454575f, 0.07818645f, 0.09825062f, -0.01255572f, 
    0.01189580f, 0.07587900f, -0.07398860f, -0.00492156f, -0.38626119f, 0.23175229f, -0.03739589f, 0.01573874f, 
    0.13472395f, 0.02146187f, -0.02659307f, -0.00230012f, 0.07766668f, -0.04739689f, 0.10133325f, -0.01476932f, 
    0.10956908f, -0.05646302f, 0.00408608f, 0.02188010f, -0.03495000f, 0.06030526f, -0.00971102f, 0.04000238f, 
    0.06534886f, 0.03036691f, -0.00119683f, -0.05273135f, 0.30819213f, -0.16538124f, -0.17853954f, -0.05649504f, 
    -0.09584074f, -0.03356829f, 0.02999198f, -0.07600730f, 0.03394931f, -0.03361569f, 0.06722162f, 0.15549923f, 
    0.13001858f, -0.17562766f, 0.00753384f, -0.16717739f, 0.06583335f, 0.03974421f, -0.04992501f, -0.15441781f, 
    -0.00723158f, -0.07226977f, -0.04163395f, -0.03954623f, 0.08808739f, 0.09862991f, 0.02552229f, 0.03817573f, 
    0.13376883f, 0.01526777f, 0.00143290f, 0.00533451f, 0.00113709f, -0.05511630f, -0.01876368f, -0.03353799f, 
    0.04859456f, -0.04812862f, 0.20298684f, -0.15628855f, 0.05713476f, -0.05292840f, -0.03318683f, -0.01421730f, 
    0.07965641f, 0.04928008f, -0.00814501f, -0.07110582f, 0.09454036f, -0.01473074f, 0.17865933f, -0.08914119f, 
    -0.05597351f, -0.03116287f, 0.12394460f, -0.02675211f, -0.00098566f, 0.02039091f, 0.11685026f, 0.05843811f, 
    0.20414443f, -0.26349241f, -0.10998876f, 0.11636581f, -0.02218607f, -0.03642341f, 0.08071806f, 0.03645014f, 
    -0.04108379f, 0.05086293f, 0.00159767f, 0.05679877f, 0.08394174f, 0.06478555f, 0.06760141f, -0.14379066f, 
    -0.04063651f, -0.05981408f, -0.08073319f, -0.02282252f, 0.04209778f, -0.00872415f, 0.04964321f, -0.17092437f, 
    0.26111040f, 0.18873863f, -0.05457892f, 0.08411877f, 0.11067055f, -0.02100191f, -0.08589774f, -0.05861421f, 
    0.01728458f, 0.10963564f, 0.08611432f, -0.06572797f, -0.12233079f, -0.03490644f, 0.06133066f, 0.06400403f, 
    0.06434929f, -0.04360033f, -0.09447920f, 0.02537842f, -0.03444747f, 0.03013805f, 0.04822394f, -0.02192205f, 
    0.08058526f, 0.05485939f, 0.14133112f, 0.02995504f, 0.07421215f, 0.05347922f, -0.08172596f, 0.02318127f, 
    -0.01187501f, 0.01034543f, 0.08711316f, 0.04900037f, -0.08221527f, -0.19071727f, 0.18185517f, -0.25368780f, 
    0.00323547f, 0.04101712f, 0.08855713f, -0.07408696f, 0.04513574f, -0.00221407f, 0.13453859f, 0.01557625f, 
    -0.03516869f, 0.13923331f, 0.28720444f, -0.13061319f, -0.00490416f, 0.00561357f, -0.01448006f, 0.06678156f, 
    0.04884286f, -0.01975377f, -0.11744998f, 0.04984188f, -0.38618872f, -0.15619065f, -0.11967723f, -0.04739026f, 
    -0.03942243f, 0.03657065f, 0.06890958f, 0.04324583f, 0.06550188f, -0.08913358f, -0.09111349f, -0.26310521f, 
    0.17830834f, 0.12024029f, 0.13732933f, 0.09178365f, -0.09100003f, 0.07044055f, 0.01439164f, 0.12418828f, 
    0.06598372f, 0.03277300f, 0.24732114f, -0.03601903f, 0.00852941f, 0.05860423f, -0.15940817f, 0.10435868f, 
    0.03515449f, -0.00364947f, 0.03286228f, -0.03903569f, -0.02225659f, -0.04093037f, 0.00524604f, 0.08766934f, 
    -0.03374081f, 0.09128957f, 0.09332880f, -0.17918776f, -0.12106503f, 0.02686191f, 0.15246636f, 0.14657897f, 
    0.11298005f, 0.16806567f, 0.00017332f, -0.07525543f, -0.20205784f, -0.09748302f, 0.05703271f, -0.17214108f, 
    -0.08371663f, -0.03783064f, 0.01243722f, 0.06327966f, 0.01844471f, -0.04594602f, 0.03019071f, -0.07854494f, 
    0.08386078f, 0.10816845f, -0.04111528f, -0.13444437f, -0.05041218f, 0.05115932f, -0.08674413f, 0.17062882f, 
    -0.02479003f, -0.03988641f, 0.06984494f, -0.14280821f, 0.07942271f, 0.09894454f, 0.04238599f, 0.13465501f, 
    -0.02377630f, -0.05520941f, 0.10417639f, 0.02833475f, 0.06575948f, 0.13111365f, -0.09248797f, -0.10549024f, 
    0.17382102f, 0.26045880f, 0.24013296f, -0.19992743f, 0.10584699f, -0.05953953f, 0.03749905f, 0.08469409f, 
    -0.01745444f, 0.14615090f, -0.01634879f, -0.03573269f, 0.00958434f, 0.15239321f, 0.04611189f, 0.08015916f, 
    0.00967808f, -0.09301364f, 0.16773067f, 0.03145461f, -0.03807708f, 0.07403119f, -0.04107206f, -0.03196571f, 
    0.04707886f, 0.02815829f, 0.03787645f, 0.07545873f, 0.04824276f, 0.08184805f, -0.02213991f, -0.02016722f, 
    -0.00748929f, 0.02414463f, -0.06151463f, 0.08567358f, 0.03877987f, 0.05427167f, -0.01728994f, 0.05662452f, 
    -0.01139871f, 0.02730414f, 0.14950670f, 0.08480622f, 0.04659038f, 0.19988221f, -0.04142589f, 0.07401314f, 
    -0.32813075f, 0.02966296f, -0.30138743f, 0.05826956f, 0.01794534f, -0.03642193f, 0.02625389f, -0.11801827f, 
    -0.10293899f, 0.06597337f, -0.06914725f, 0.09263723f, 0.03870552f, 0.00200255f, -0.09298487f, -0.11015386f, 
    0.09996247f, 0.01646043f, 0.04664810f, -0.01062794f, -0.07895222f, 0.13730992f, -0.06915709f, -0.08718503f, 
    0.29389486f, -0.13529386f, 0.10676588f, -0.11006422f, -0.01098004f, 0.15302287f, -0.20552996f, 0.14522533f, 
    0.04531302f, 0.13466269f, 0.04518748f, 0.05070284f, -0.22534212f, -0.24223803f, -0.03182068f, -0.04311604f, 
    0.01557080f, 0.02598253f, -0.01650241f, -0.21054912f, -0.03427101f, -0.05972536f, -0.01624046f, 0.18718445f, 
    0.18058608f, 0.05529117f, 0.02786626f, 0.05068634f, -0.03639515f, 0.02481101f, -0.06271719f, -0.01535025f, 
    0.06220514f, 0.12873732f, 0.06438380f, -0.04878104f, -0.05080306f, -0.01749770f, 0.05185032f, 0.04549135f, 
    -0.03580623f, 0.05394751f, -0.15018062f, 0.12165444f, 0.05763971f, 0.00572964f, -0.02080802f, -0.04773943f, 
    -0.02047794f, 0.08437803f, 0.18852074f, 0.09328200f, -0.04332333f, -0.03478565f, 0.14450485f, 0.08007808f, 
    0.03511935f, 0.02814364f, 0.09114861f, -0.01573717f, 0.05318746f, -0.03154705f, 0.26291701f, 0.06785692f, 
    0.09897635f, 0.02166761f, -0.05474477f, 0.04968031f, -0.05762719f, 0.08936220f, 0.01744721f, 0.16511202f, 
    -0.07039815f, -0.01391233f, -0.10983573f, -0.24230444f, 0.11502647f, -0.07065507f, -0.06385732f, 0.02614788f, 
    0.00100830f, -0.05057076f, 0.06875215f, -0.02260008f, 0.06596383f, -0.08760490f, 0.07158109f, -0.12672661f, 
    0.02724234f, 0.07977739f, 0.04268769f, -0.07154732f, 0.00260125f, 0.03360053f, -0.28111404f, 0.01657947f, 
    -0.02719107f, 0.01485578f, 0.11776483f, -0.13067825f, -0.06896541f, 0.17742519f, -0.04528593f, 0.04586359f, 
    0.02836005f, -0.10531180f, -0.00028687f, 0.17091925f, 0.06362667f, 0.17166635f, 0.21411219f, 0.07745449f, 
    0.04621940f, -0.14474984f, 0.05406981f, 0.07934144f, 0.06044115f, -0.08843867f, 0.00279877f, -0.01399746f, 
    0.18515445f, 0.20423296f, 0.01428473f, -0.05229915f, 0.03006385f, 0.05217174f, 0.06440081f, 0.10879022f, 
    -0.01059165f, 0.06061465f, 0.02991256f, 0.05970678f, 0.00313066f, 0.09831507f, 0.07296963f, -0.13711424f, 
    0.00563609f, 0.06067044f, -0.09223478f, -0.03527084f, 0.02476921f, 0.00640317f, -0.03922440f, 0.22118242f, 
    -0.04503869f, 0.07735485f, 0.12665112f, 0.29637396f, 0.07544608f, 0.06132627f, -0.06698703f, 0.04186044f, 
    -0.01039635f, -0.05852382f, -0.05525245f, -0.14991200f, 0.38749766f, 0.11688816f, 0.00044080f, 0.16874668f, 
    -0.05595800f, -0.01000251f, -0.04969032f, -0.00496264f, 0.05203239f, 0.03425761f, 0.04920709f, 0.12959094f, 
    -0.07264177f, -0.08076025f, -0.07112096f, 0.06679036f, 0.01567015f, -0.02545714f, 0.04355064f, 0.03149373f, 
    0.08051174f, -0.08539321f, 0.02237071f, 0.01494027f, -0.09188887f, -0.09953770f, -0.17805170f, -0.00789626f, 
    0.03588517f, 0.05140251f, -0.02686658f, -0.11072444f, -0.04664473f, -0.09241053f, -0.06879687f, -0.07605679f, 
    0.19479397f, 0.12398525f, -0.01708226f, 0.08859078f, -0.18001230f, 0.08925071f, -0.16176265f, 0.05873578f, 
    0.09074811f, 0.23575711f, 0.12252838f, 0.17287356f, 0.16236553f, 0.03665116f, 0.31065866f, 0.22492240f, 
    -0.08993563f, 0.07241292f, 0.06561861f, 0.04850911f, 0.09021670f, 0.08301654f, -0.01733229f, 0.03107296f, 
    0.13489619f, 0.13424878f, 0.20002021f, 0.07470848f, -0.05253892f, -0.08655427f, 0.09927171f, 0.09011327f, 
    -0.01969604f, -0.03028335f, -0.00239682f, 0.07373017f, 0.07560312f, -0.22456004f, -0.13366143f, -0.10927001f, 
    0.04343177f, 0.04894912f, -0.04303832f, -0.04020360f, 0.09828173f, -0.06936812f, -0.09598588f, -0.01082684f, 
    -0.05128912f, -0.16652834f, -0.20106794f, -0.12632342f, 0.07463133f, 0.08700366f, 0.02800223f, -0.05041540f, 
    0.04583084f, 0.05115946f, 0.00590634f, 0.05145010f, -0.16856211f, 0.09399097f, -0.08418283f, -0.03265754f, 
    0.06205206f, -0.01617438f, 0.10993949f, -0.03475820f, -0.03219512f, 0.10183749f, 0.09756973f, 0.06731605f, 
    0.01724028f, -0.05967334f, -0.06300091f, -0.05772769f, 0.06010330f, 0.06854347f, -0.07603612f, -0.03438433f, 
    0.04678765f, -0.05264821f, -0.05781576f, -0.22086897f, -0.00354736f, -0.16665232f, -0.11330431f, -0.07310679f, 
    -0.04503702f, -0.02645858f, 0.14786965f, -0.07361820f, 0.01242530f, 0.14020635f, -0.01240599f, -0.00231675f, 
    -0.27989814f, -0.08979082f, -0.09184553f, -0.06917446f, -0.02877140f, 0.02942503f, 0.13794531f, -0.09243102f, 
    0.01167933f, 0.05270834f, 0.09904906f, -0.16904308f, -0.05544733f, 0.06050996f, 0.07165226f, 0.05858627f, 
    0.09191475f, 0.00897950f, 0.13379024f, 0.11465785f, 0.02434181f, -0.07105164f, -0.13952403f, 0.12846236f, 
    0.09023113f, 0.17190719f, 0.01394238f, 0.02856695f, -0.04710112f, -0.16351345f, 0.09529439f, -0.03167041f, 
    0.06497762f, -0.01087820f, 0.05894382f, 0.04649567f, 0.03693571f, 0.07575017f, -0.01967482f, 0.00929443f, 
    0.04437175f, -0.01055758f, -0.13750097f, 0.02804917f, 0.09709064f, -0.02263382f, -0.07582633f, -0.04883535f, 
    0.21547768f, 0.03300115f, 0.18127117f, -0.09663270f, 0.00940117f, -0.07263421f, 0.01696658f, 0.06470491f, 
    0.03948494f, -0.04919484f, 0.09116123f, -0.03557434f, -0.13591635f, 0.07613342f, 0.12481600f, 0.00311467f, 
    -0.06531659f, 0.01184800f, 0.05326462f, 0.02494027f, 0.00545432f, -0.04293134f, -0.09045479f, 0.02720421f, 
    -0.15500420f, 0.07547165f, -0.03332141f, 0.11176409f, 0.05974632f, 0.05510671f, 0.04575297f, -0.11304522f, 
    -0.06104232f, 0.09341817f, 0.14472874f, -0.04746366f, -0.10305168f, -0.03874600f, -0.29233631f, 0.01266553f, 
    0.05376916f, -0.09655731f, -0.02100049f, 0.03797593f, -0.09359631f, -0.00586067f, -0.10667640f, -0.14990546f, 
    0.25095749f, -0.10496275f, -0.10290516f, 0.04223986f, -0.09739049f, 0.11953519f, 0.06541218f, -0.03141284f, 
    -0.12305600f, 0.13239208f, -0.19746841f, -0.01764964f, 0.39207652f, 0.39628032f, -0.06654584f, 0.13218494f, 
    0.16465110f, -0.13247566f, -0.00080529f, -0.00419297f, 0.02418755f, -0.02652029f, -0.01188905f, -0.03811995f, 
    0.18585032f, 0.13807532f, 0.15460145f, 0.08845811f, -0.03296923f, -0.10418616f, 0.01193563f, 0.06687300f, 
    0.06088020f, 0.02634259f, 0.12331506f, 0.02790104f, -0.23703790f, -0.24753980f, 0.00394949f, -0.10868785f, 
    0.01612125f, 0.09458452f, -0.14263201f, -0.07700321f, -0.12136844f, 0.07279820f, 0.09457233f, -0.03104457f, 
    0.06874549f, 0.19044705f, -0.03408937f, 0.09625099f, 0.03711867f, -0.02725616f, 0.09625405f, -0.19689514f, 
    0.06744998f, 0.03225683f, 0.05867342f, 0.07498302f, 0.00153178f, 0.18153274f, -0.07306029f, 0.00276884f, 
    0.08659618f, 0.04430170f, 0.02044853f, 0.03386417f, 0.03137882f, 0.04235281f, 0.26339608f, -0.02055879f, 
    -0.16581666f, -0.03761807f, 0.01389985f, -0.02825414f, -0.09647132f, 0.00312214f, -0.06837086f, -0.07674933f, 
    -0.01744806f, 0.04654903f, 0.03378372f, 0.08088785f, 0.08218797f, 0.00774651f, -0.05788571f, 0.23324545f, 
    -0.05243891f, 0.12426738f, 0.01052349f, 0.09236526f, 0.06576229f, 0.02838231f, 0.03356131f, 0.03086416f, 
    -0.13733259f, -0.17433386f, -0.10417774f, 0.05783809f, 0.02770713f, -0.07286754f, 0.12044993f, -0.05368590f, 
    0.12800276f, 0.00317298f, 0.10809375f, 0.06439501f, 0.15710588f, -0.00604396f, 0.10251421f, -0.12832429f, 
    -0.04697530f, 0.03643998f, -0.11893517f, 0.04618750f, -0.01319586f, -0.00924411f, -0.02370244f, 0.04078604f, 
    -0.21039645f, -0.13228530f, -0.11577970f, -0.02180155f, 0.01974144f, 0.03868731f, -0.04789258f, 0.07450344f, 
    0.01329674f, 0.12300270f, -0.10447209f, -0.12920991f, -0.08501017f, -0.00443669f, 0.32855317f, -0.04131256f, 
    -0.06076430f, 0.02405488f, 0.01766347f, -0.08708550f, -0.02316860f, 0.06496460f, -0.03307411f, 0.09812390f, 
    0.07547188f, 0.13231829f, 0.20006733f, 0.15835509f, -0.12070175f, -0.10278112f, 0.19372950f, 0.02977055f, 
    -0.02656448f, 0.05205821f, -0.09979490f, 0.16671836f, -0.24347800f, 0.06010350f, -0.03575160f, -0.03018823f, 
    0.12718301f, 0.22017291f, -0.00087125f, 0.00495749f, -0.01464283f, 0.02586433f, 0.10986631f, -0.07639574f, 
    0.58732408f, 0.07363308f, -0.11780416f, 0.21560457f, 0.05309932f, 0.04541692f, -0.04706252f, 0.07900448f, 
    -0.06851465f, 0.00620254f, 0.08437961f, -0.15744038f, -0.07001795f, 0.08847423f, 0.07790134f, -0.13182305f, 
    -0.05923121f, 0.16228239f, 0.04881656f, 0.11877450f, 0.05935573f, -0.07668716f, 0.02272493f, 0.04903026f, 
    0.07499998f, 0.24389683f, 0.09750735f, 0.24598645f, 0.08430991f, -0.00488333f, -0.04575482f, 0.09828497f, 
    -0.10501202f, 0.09219936f, 0.10958537f, 0.08847988f, 0.17383127f, 0.01595752f, 0.01660858f, 0.02708211f, 
    0.08213287f, 0.04229297f, 0.01660181f, -0.09831220f, 0.04838725f, 0.02059104f, 0.16284905f, -0.09933608f, 
    0.00666010f, -0.01307129f, -0.04056013f, 0.02463646f, -0.03638389f, -0.01481241f, -0.02993742f, -0.00918030f, 
    -0.03758873f, 0.00389974f, -0.01973172f, 0.00269126f, -0.02776745f, 0.01553962f, 0.01331479f, -0.03683583f, 
    -0.00449097f, -0.01652080f, -0.01757716f, -0.00095231f, 0.02630966f, 0.02892774f, -0.00720862f, 0.01386661f, 
    0.01311812f, 0.02505703f, -0.01116424f, -0.03861879f, -0.03249111f, 0.00501542f, -0.02477297f, 0.02429021f, 
    0.00905289f, -0.00237910f, -0.00370950f, -0.01576828f, 0.01942862f, -0.00610447f, 0.02055722f, 0.00848452f, 
    -0.04027814f, -0.02990328f, -0.01961881f, 0.01439450f, -0.00859765f, 0.02076203f, 0.02553670f, -0.03622285f, 
    -0.01296290f, -0.00897139f, -0.02746011f, 0.00763859f, 0.00299768f, 0.00980667f, -0.03504740f, 0.00645803f, 
    0.00238451f, -0.03778319f, 0.01507448f, -0.02585915f, 0.01180398f, 0.02051379f, -0.01701963f, -0.00295077f, 
    -0.01099893f, -0.03471298f, 0.02964608f, 0.01269216f, -0.03056676f, 0.00705711f, 0.02479920f, -0.01834046f, 
    -0.02242896f, 0.00907558f, -0.00041131f, -0.02094382f, 0.00470431f, -0.01258931f, -0.00538751f, 0.00891259f, 
    0.00647122f, -0.02639696f, -0.01111348f, -0.00542400f, -0.02541154f, -0.01637951f, 0.02757618f, -0.03244623f, 
    -0.01683953f, 0.00380465f, -0.03480663f, 0.00788294f, -0.00364778f, -0.03138053f, 0.02250664f, -0.01704584f, 
    0.02569509f, -0.03600755f, -0.00207572f, -0.00823418f, -0.02023846f, 0.01299837f, -0.01480269f, 0.00647468f, 
    -0.00218888f, -0.01292540f, -0.00189411f, 0.01003214f, -0.02200063f, -0.04169311f, -0.03862115f, -0.03909725f, 
    -0.03557386f, -0.03509453f, -0.00863395f, 0.01909156f, 0.00624499f, 0.01626853f, -0.03621973f, -0.00042954f, 
    0.02539741f, -0.03508383f, -0.02508308f, -0.01510742f, 0.00539464f, -0.01119933f, -0.02170381f, -0.03769087f, 
    0.01940592f, 0.00220173f, 0.01386075f, -0.00903839f, -0.04184752f, -0.03633221f, 0.00900499f, -0.01623695f, 
    -0.01384024f, -0.00838609f, -0.01485281f, -0.02120414f, -0.03645069f, -0.04034854f, -0.01606133f, -0.02565451f, 
    -0.03341846f, -0.03347050f, -0.03158437f, -0.03073056f, 0.02485588f, -0.01553136f, -0.02731199f, 0.01083398f, 
    -0.02953766f, -0.02812380f, -0.03571546f, -0.01709275f, 0.01262265f, 0.00321311f, -0.03561908f, -0.02950255f, 
    -0.00000712f, -0.02391578f, 0.01312112f, -0.03194424f, 0.00349239f, -0.00997754f, 0.00875574f, -0.02353862f, 
    0.01255165f, 0.01597262f, -0.02936496f, -0.02636659f, -0.02962995f, -0.02160332f, 0.01975225f, 0.01383260f, 
    -0.01899311f, 0.02471127f, -0.03050515f, -0.03963935f, 0.00485574f, -0.03825295f, 0.01567844f, 0.01741271f, 
    -0.01103220f, 0.00957878f, 0.00549038f, -0.00164357f, 0.00991831f, 0.02430714f, 0.00223825f, -0.02440406f, 
    0.01901040f, 0.01781229f, -0.00216778f, 0.02381469f, 0.02100888f, 0.00635706f, -0.02521760f, -0.03772201f, 
    -0.01074789f, -0.03682288f, -0.00288741f, 0.02863541f, 0.00648566f, 0.00900893f, 0.02439352f, 0.01918634f, 
    0.02874560f, -0.02740460f, 0.00029361f, -0.02412053f, 0.01932931f, 0.01262363f, -0.01704966f, -0.02664711f, 
    0.02942468f, -0.00952961f, -0.01092174f, 0.02226449f, -0.02712573f, -0.02326265f, 0.01740399f, -0.00429528f, 
    0.02643918f, 0.01661601f, 0.00108754f, 0.02784014f, 0.01831465f, -0.02366240f, -0.01162435f, 0.02307759f, 
    0.02779542f, -0.02228946f, -0.00106670f, -0.01786654f, -0.00799348f, 0.00604917f, -0.01086143f, -0.00427871f, 
    -0.02345763f, 0.02902836f, -0.01589906f, 0.01003564f, -0.02235931f, -0.00600231f, 0.01171086f, -0.02958826f, 
    -0.01505784f, 0.02789357f, 0.02543411f, -0.03676255f, 0.00107102f, 0.02223598f, 0.01689349f, 0.00704985f, 
    -0.03028368f, -0.00115310f, 0.01896212f, 0.01157632f, -0.02682815f, 0.00548328f, -0.02030792f, -0.02123440f, 
    0.02642242f, 0.01753384f, -0.01392761f, -0.01148228f, -0.03116293f, 0.02101082f, -0.01192706f, -0.02630099f, 
    -0.00863005f, -0.02151527f, -0.00771972f, -0.03080492f, -0.01654614f, -0.04044468f, -0.02318621f, 0.00161307f, 
    0.00394448f, -0.02676361f, 0.02514433f, 0.02863222f, -0.04188781f, -0.00702220f, -0.01894519f, -0.03882430f, 
    0.02125027f, -0.03201061f, -0.00753713f, -0.03943896f, -0.03074015f, -0.00843935f, -0.02941420f, -0.03782786f, 
    -0.00993681f, 0.00721170f, 0.00565789f, -0.01820601f, 0.01744640f, 0.01031469f, -0.00465583f, -0.01706706f, 
    0.01882924f, -0.00339305f, -0.03020590f, 0.02382310f, 0.00788518f, -0.02000523f, 0.01190016f, 0.00918232f, 
    -0.02998899f, -0.00178162f, 0.01677000f, -0.00083322f, -0.03382032f, -0.01946745f, 0.01390077f, -0.03083004f, 
    0.00408713f, 0.01987446f, -0.01233452f, 0.01972693f, 0.00899787f, -0.04005654f, 0.01774526f, 0.02629039f, 
    0.00391488f, -0.02370400f, -0.03337773f, -0.02613192f, -0.02558371f, 0.02800019f, 0.01613595f, -0.02781769f, 
    -0.03179948f, -0.02086314f, -0.00244000f, -0.03317140f, -0.03370242f, -0.00265914f, 0.00182979f, 0.01195650f, 
    -0.02016344f, 0.01887264f, -0.02122769f, 0.00704965f, -0.02494477f, 0.00213662f, -0.02119645f, 0.01731315f, 
    -0.03154171f, 0.02496225f, 0.00716251f, -0.03504487f, 0.03253005f, 0.01498428f, 0.01385726f, 0.01613050f, 
    0.00318872f, 0.00001957f, 0.02171219f, -0.00926512f, -0.02712072f, -0.01073087f, -0.03507129f, 0.02223000f, 
    -0.03944159f, -0.02165601f, 0.02603303f, -0.00271867f, 0.00861485f, -0.03307831f, -0.03510864f, 0.01234318f, 
    -0.03777975f, -0.00535224f, -0.02706453f, -0.00167798f, 0.01027964f, -0.02604813f, -0.03853530f, -0.01296164f, 
    0.00333381f, -0.03877267f, -0.03746014f, -0.00038784f, 0.00092108f, 0.01783383f, -0.03100481f, 0.00636718f, 
    0.00640187f, -0.01763148f, -0.02082620f, 0.00860840f, -0.02057897f, 0.00370871f, 0.01220500f, 0.01854823f, 
    -0.01455034f, 0.00521943f, -0.02652035f, -0.00799163f, -0.01562028f, -0.00408533f, -0.00626625f, 0.01464275f, 
    -0.02809253f, 0.01852191f, -0.00470793f, -0.03847862f, -0.01987223f, 0.01559752f, 0.01406801f, 0.00788232f, 
    -0.02702519f, 0.02271084f, -0.01547831f, -0.03984815f, -0.03514231f, -0.03858243f, -0.03984336f, 0.02726387f, 
    -0.03761260f, -0.00802077f, -0.02030520f, 0.00394073f, 0.02589661f, -0.01785750f, 0.01111546f, 0.02227516f, 
    -0.02708911f, -0.01516712f, -0.00256386f, -0.02188242f, -0.00724298f, 0.00691554f, -0.00603100f, -0.02567983f, 
    -0.03698606f, -0.01992274f, -0.01752261f, -0.02069155f, -0.00120267f, -0.01817317f, -0.03001200f, 0.02614501f, 
    -0.01740371f, -0.00101681f, -0.00109550f, 0.01337268f, -0.00049632f, 0.02753972f, 0.02844050f, -0.01817223f, 
    -0.02890888f, -0.03228560f, 0.01643975f, -0.02764167f, 0.00081028f, -0.02740194f, -0.01971118f, 0.00285652f, 
    -0.01479124f, 0.02330490f, -0.00285931f, 0.01260425f, -0.04010493f, 0.01191067f, 0.02440361f, 0.00176507f, 
    -0.04003112f, -0.01023105f, 0.01919851f, -0.02687931f, 0.00919441f, 0.01865799f, -0.01707883f, -0.03800982f, 
    -0.01497790f, 0.02427811f, 0.02636603f, -0.00689480f, 0.00198786f, -0.01565034f, -0.03866021f, -0.02248804f, 
    -0.04021748f, 0.01182156f, -0.02518032f, -0.00479778f, 0.02842548f, -0.02770885f, -0.00739639f, -0.01348206f, 
    -0.01349902f, 0.00775147f, -0.01274654f, -0.00207159f, 0.01567076f, 0.01558610f, 0.02810777f, 0.02219464f, 
    -0.02554625f, -0.02945737f, -0.00040093f, 0.00429882f, 0.02506915f, -0.02668452f, -0.02848617f, -0.01614398f, 
    -0.01222405f, -0.01607664f, -0.00448059f, 0.02629076f, 0.02125024f, 0.00070051f, 0.02476185f, 0.02465577f, 
    -0.03046173f, 0.02314252f, 0.01155128f, 0.02472528f, -0.02849150f, 0.02874559f, -0.03589966f, 0.01980397f, 
    -0.01860652f, -0.02935775f, 0.01709529f, 0.02947462f, 0.01341251f, -0.01082550f, -0.02748142f, -0.02717873f, 
    -0.03723434f, 0.00924941f, 0.02272895f, -0.01281454f, 0.00932447f, -0.00374217f, -0.02651422f, 0.01533164f, 
    0.01096875f, -0.03002520f, -0.01486696f, 0.02517793f, 0.01727443f, 0.00925111f, -0.01899974f, -0.00331043f, 
    -0.01792469f, -0.03940880f, 0.02499531f, 0.00134336f, -0.00983186f, -0.01930220f, 0.02467533f, -0.00189079f, 
    -0.02434792f, -0.03813801f, -0.02326479f, 0.01373829f, -0.03691004f, -0.01621856f, 0.02601951f, -0.04019355f, 
    -0.00405720f, -0.00218001f, 0.02563259f, -0.04195311f, 0.01285557f, -0.00523086f, -0.01920918f, 0.01934492f, 
    -0.02733488f, -0.00581389f, -0.02398928f, 0.02730837f, 0.00940340f, -0.00334368f, -0.00678858f, -0.00166398f, 
    0.01062515f, -0.01505315f, 0.02842923f, 0.01436373f, -0.04098107f, 0.01092222f, 0.01212763f, 0.01454844f, 
    -0.02855862f, -0.03891123f, -0.04023377f, -0.03093826f, -0.03923214f, -0.01353406f, -0.02116632f, -0.03993069f, 
    -0.03282982f, 0.02649252f, -0.03055530f, -0.02322860f, -0.00026062f, -0.01639420f, -0.02653232f, -0.00666703f, 
    0.02903006f, -0.03740770f, 0.01193924f, -0.03399027f, 0.02106370f, -0.00427575f, -0.00618080f, 0.00158497f, 
    0.01328652f, 0.01527346f, 0.00373504f, -0.02939620f, -0.03441251f, -0.02954918f, 0.00803406f, -0.00214243f, 
    0.00515975f, 0.00101307f, -0.03849651f, 0.02826407f, 0.02400270f, 0.02061757f, -0.01204037f, -0.03923951f, 
    -0.01229835f, 0.02946216f, -0.01557854f, 0.00771497f, 0.01251780f, -0.01765838f, 0.00852452f, -0.04143592f, 
    -0.00525150f, -0.02973833f, -0.01372241f, 0.01254777f, -0.00349156f, 0.01377828f, -0.03341913f, 0.00829826f, 
    0.02930179f, -0.01271862f, -0.00559294f, -0.03221400f, -0.03378786f, 0.00836802f, 0.01222746f, -0.02222705f, 
    0.00534463f, -0.03799112f, -0.04176112f, 0.00304511f, 0.01248603f, -0.03352237f, -0.04052323f, 0.00180246f, 
    -0.02316144f, -0.01356264f, 0.01530043f, 0.02432220f, -0.03032075f, -0.01048092f, -0.02605836f, -0.00056876f, 
    0.03382518f, 0.01915696f, 0.00257330f, 0.01720405f, 0.00266444f, -0.02399921f, 0.01770759f, 0.00811721f, 
    -0.02191628f, -0.03050642f, -0.02841592f, 0.02785500f, 0.01966751f, 0.01282106f, 0.00362874f, 0.01120911f, 
    0.01252733f, -0.01563958f, 0.00847865f, 0.01602252f, 0.02629596f, -0.01662287f, -0.03611419f, -0.03872623f, 
    -0.00316334f, 0.02735956f, 0.01954297f, -0.01105817f, 0.01606699f, 0.00081979f, -0.00041109f, -0.04037170f, 
    0.00365103f, 0.02563030f, -0.03032945f, -0.02332320f, 0.02663634f, 0.02680809f, -0.01990949f, 0.01802201f, 
    -0.00474309f, 0.00721843f, 0.00814065f, -0.01303194f, -0.02760564f, -0.00817004f, 0.00279443f, 0.01231875f, 
    -0.04136367f, -0.02987958f, 0.02330060f, 0.00534763f, -0.03137881f, -0.01410686f, -0.00131816f, 0.00065817f, 
    0.00418544f, -0.00459491f, -0.03576443f, 0.00184765f, -0.03342523f, -0.01256498f, 0.00371403f, 0.01337786f, 
    -0.00448811f, -0.03270392f, 0.03347109f, 0.01352669f, -0.03546656f, 0.00820642f, -0.00553963f, -0.04127055f, 
    0.00738971f, -0.02153184f, -0.00102893f, -0.03769231f, -0.03673691f, -0.04135567f, -0.02450502f, 0.01149492f, 
    -0.04202064f, -0.04150972f, 0.00150833f, -0.01586535f, 0.02114247f, 0.02190652f, 0.01203903f, -0.02052483f, 
    -0.03595032f, -0.00311385f, 0.00972940f, -0.03995662f, -0.00112682f, 0.00381026f, -0.00068258f, -0.02571307f, 
    -0.00474786f, -0.02013959f, 0.01454542f, 0.01314946f, 0.00510065f, -0.04019615f, 0.02477043f, -0.04002007f, 
    0.02434136f, -0.00536288f, -0.02271012f, -0.04048549f, -0.01177501f, -0.02638497f, -0.03144471f, -0.00190121f, 
    -0.03148104f, -0.02853293f, -0.02085448f, 0.02710977f, -0.01955726f, -0.01532432f, -0.04090805f, -0.00581220f, 
    -0.03825546f, -0.00168758f, -0.01718902f, 0.02584258f, -0.02574065f, -0.01021051f, -0.03142173f, -0.03094662f, 
    0.00227534f, 0.02848793f, 0.01910567f, -0.04347248f, -0.01242980f, -0.01882050f, 0.02228302f, 0.01290239f, 
    0.02260750f, -0.01750099f, 0.02126518f, -0.03919736f, 0.01239941f, -0.04113566f, -0.03775516f, -0.02359061f, 
    0.00001936f, -0.04229120f, -0.02681326f, -0.01511114f, -0.02401667f, -0.02960201f, -0.02138826f, 0.00592890f, 
    -0.02582511f, -0.00533421f, 0.00105547f, -0.03699467f, -0.01739820f, -0.00561616f, -0.02133089f, -0.00954245f, 
    -0.01343249f, -0.01962978f, -0.01924780f, -0.02816155f, -0.04115561f, -0.00915065f, -0.00516661f, -0.02628179f, 
    -0.04187120f, -0.02395891f, -0.03699328f, -0.03966033f, -0.01551429f, 0.01652286f, -0.01153996f, -0.03304778f, 
    -0.02471883f, 0.02726713f, -0.00048430f, -0.02658509f, -0.04139050f, -0.03072288f, -0.00735602f, 0.01679796f, 
    -0.03893309f, -0.00881758f, -0.03404208f, -0.00410725f, -0.04126906f, 0.01401988f, -0.01895599f, 0.00043776f, 
    0.01340868f, -0.00396595f, -0.02181538f, 0.03278008f, -0.03967467f, -0.00880775f, -0.03876895f, -0.02750049f, 
    -0.02731688f, -0.02677711f, 0.01135603f, 0.00785332f, -0.02956831f, -0.00999005f, -0.03135620f, 0.01157410f, 
    -0.01359356f, -0.00862821f, 0.00882245f, 0.00227629f, 0.00168342f, -0.03164423f, 0.00002046f, -0.01921358f, 
    -0.01524531f, -0.02915804f, -0.01013818f, -0.04167289f, -0.02310252f, -0.04572114f, -0.01075419f, 0.00674748f, 
    0.01413079f, -0.00409748f, -0.01456812f, -0.03598441f, 0.01473940f, -0.03754738f, -0.03447141f, -0.02956735f, 
    -0.04176960f, 0.00391132f, -0.04470460f, -0.03574527f, -0.03092054f, -0.01151539f, -0.04108797f, -0.02463517f, 
    -0.02938525f, -0.01421657f, 0.01166193f, 0.01905014f, 0.01660015f, 0.00145400f, -0.01790577f, 0.00371304f, 
    -0.02712802f, -0.00244318f, 0.00919963f, -0.04622563f, 0.00325520f, 0.01378950f, 0.02536141f, -0.01471396f, 
    -0.04135633f, -0.02988526f, -0.02415638f, 0.02807630f, -0.02950433f, 0.00176614f, -0.00416836f, 0.01556369f, 
    0.00988093f, -0.00762000f, -0.01432159f, 0.02367790f, 0.00194796f, -0.04217247f, -0.01054442f, -0.04026748f, 
    -0.03905019f, -0.02260058f, 0.01789417f, 0.01489671f, -0.00468388f, 0.01439789f, -0.02756253f, -0.01995851f, 
    0.01531088f, -0.02222771f, -0.02391645f, -0.01615725f, 0.01090736f, 0.00134310f, -0.02781306f, -0.04839432f, 
    0.01379552f, -0.00654002f, 0.02597641f, -0.03127636f, -0.03606346f, -0.00670900f, -0.03360894f, 0.00606067f, 
    -0.00836691f, -0.04236518f, 0.01495809f, -0.00977558f, 0.00100663f, -0.02706968f, -0.03475879f, -0.04239180f, 
    -0.01577966f, -0.04527656f, -0.01669898f, 0.01115850f, -0.04110140f, -0.04416123f, -0.00370290f, -0.02131802f, 
    -0.03145237f, -0.04268920f, 0.02676542f, 0.01303662f, -0.02799057f, -0.03859085f, 0.02892620f, 0.02528684f, 
    0.00232432f, 0.01715267f, -0.04228955f, -0.03072842f, 0.01141462f, -0.01042682f, -0.03016575f, -0.04508501f, 
    -0.01286479f, -0.03440290f, 0.00531813f, 0.02228119f, 0.00015645f, -0.02744769f, -0.03700550f, -0.01691382f, 
    0.01219661f, -0.01268844f, 0.00579989f, -0.00175403f, 0.02815962f, -0.02442513f, -0.00258702f, 0.01423278f, 
    -0.02186594f, -0.01155833f, 0.02766679f, 0.01089907f, -0.04436084f, -0.01084666f, -0.01237168f, 0.02244329f, 
    -0.03396798f, 0.00410821f, 0.02470515f, -0.02227763f, -0.00188953f, -0.03786495f, -0.00603053f, 0.01357911f, 
    -0.04535924f, -0.01807958f, -0.00020594f, -0.01668026f, 0.00058377f, -0.00159318f, -0.00292143f, 0.02926590f, 
    -0.04509537f, -0.02365772f, 0.01703152f, -0.03770998f, 0.01378932f, -0.02425731f, -0.04225145f, -0.00983991f, 
    0.01339388f, 0.02282122f, -0.03907306f, 0.01609959f, 0.01528567f, 0.02500594f, -0.02128494f, 0.01908472f, 
    -0.00938342f, 0.00443388f, -0.01291609f, 0.02020377f, -0.02690496f, -0.03199553f, -0.03013772f, -0.00356400f, 
    -0.04247111f, -0.00918765f, 0.00952686f, 0.02277000f, 0.02205136f, 0.01850917f, 0.01375071f, -0.03591851f, 
    0.00323245f, 0.01491870f, 0.01818638f, -0.02724345f, -0.01891371f, -0.03890387f, 0.01694503f, 0.00005775f, 
    -0.03424378f, -0.02790323f, -0.01946356f, 0.00487665f, -0.01746063f, -0.03438535f, -0.00470836f, -0.04094403f, 
    -0.00866236f, -0.03402187f, -0.01966302f, 0.01858457f, -0.04049989f, 0.02858751f, 0.01358386f, -0.00476954f, 
    -0.00283249f, -0.04455043f, -0.03443509f, -0.03359832f, 0.00056330f, 0.02338423f, 0.01510353f, -0.03509306f, 
    -0.00135406f, 0.01572290f, -0.00419046f, -0.03889614f, 0.01871120f, 0.02573844f, 0.00382721f, -0.03796674f, 
    0.02468931f, -0.00821313f, -0.04212702f, 0.02119676f, -0.03716121f, -0.03293256f, 0.02494323f, -0.04146596f, 
    0.00094679f, -0.01439789f, -0.02744090f, 0.01224916f, 0.00123673f, 0.00847967f, 0.02659638f, 0.02542420f, 
    0.01529380f, -0.03551813f, -0.03050751f, 0.02372630f, -0.03326325f, 0.01653308f, -0.03641709f, -0.00208545f, 
    -0.03774540f, -0.02974521f, -0.04760723f, 0.01264683f, 0.01605162f, 0.01112320f, -0.02045572f, -0.00904516f, 
    0.01708982f, 0.02416943f, -0.02970958f, -0.04066736f, -0.02706208f, 0.02474684f, -0.04569856f, 0.00099956f, 
    -0.04172765f, 0.02469226f, 0.00150937f, -0.04042332f, 0.00086745f, -0.02220290f, 0.00663237f, 0.01040070f, 
    -0.00270045f, -0.02536334f, -0.02829363f, 0.00429134f, -0.00945266f, -0.00523709f, -0.02971578f, 0.01467535f, 
    0.01400831f, -0.00269796f, -0.02876633f, 0.01132280f, -0.02415427f, 0.01775257f, -0.00683487f, -0.00386381f, 
    0.00976187f, -0.04293080f, -0.01904213f, -0.01491134f, -0.03812885f, -0.03994694f, -0.01850372f, -0.04150731f, 
    0.01626624f, -0.03153214f, 0.01595731f, -0.02433714f, -0.03477392f, -0.02536998f, -0.02698786f, 0.01227146f, 
    -0.02699719f, -0.03788883f, -0.01236233f, -0.01093457f, 0.01258162f, -0.00870921f, -0.03513145f, -0.04968123f, 
    0.00080331f, 0.00139199f, -0.02449790f, -0.02738668f, 0.02629705f, -0.00071409f, -0.01630207f, 0.00046539f, 
    -0.01490741f, 0.02428890f, -0.03251408f, -0.01780857f, -0.02496020f, -0.04094064f, -0.01055876f, 0.02235465f, 
    0.01244884f, -0.03991221f, -0.00550665f, 0.03048230f, -0.00067561f, -0.03451674f, -0.03101163f, 0.02094751f, 
    0.01361158f, 0.01277748f, -0.02445027f, -0.02208737f, 0.00617237f, 0.01327252f, 0.00084052f, 0.02136747f, 
    0.02635060f, -0.02633846f, 0.00110328f, -0.01067423f, -0.01584166f, -0.02298698f, -0.00270474f, -0.01430678f, 
    -0.01162434f, 0.01377753f, -0.00948416f, -0.00211318f, -0.02952966f, 0.02500432f, -0.01089092f, -0.03232706f, 
    -0.00790781f, 0.00646629f, 0.00292725f, -0.02609395f, -0.02835739f, -0.03943941f, -0.00897444f, -0.02910019f, 
    0.02404761f, 0.01255506f, -0.04101083f, -0.00402486f, -0.03048706f, -0.00508321f, -0.00762864f, -0.03188498f, 
    -0.03220222f, -0.00255088f, -0.01249929f, 0.01957095f, -0.01566265f, 0.02289531f, 0.02553475f, 0.01593153f, 
    -0.03223320f, -0.03823325f, -0.01602772f, 0.00822598f, 0.00519951f, 0.02792677f, -0.01931810f, -0.03154505f, 
    0.01872097f, 0.02096951f, -0.00348487f, -0.01837815f, -0.01996375f, 0.02857552f, 0.02009799f, 0.01179071f, 
    -0.02460751f, 0.01653610f, 0.00903596f, -0.00784389f, -0.00674875f, -0.02226107f, 0.02562411f, 0.00718804f, 
    0.02601193f, -0.04242638f, -0.02850487f, 0.00791778f, -0.01269446f, -0.02154368f, -0.03164842f, 0.01773649f, 
    -0.01702283f, 0.01224515f, -0.03183823f, -0.03481095f, 0.01236141f, -0.03042383f, -0.00578191f, -0.04105077f, 
    -0.03391429f, -0.01460813f, 0.00285323f, 0.02984249f, 0.00057061f, 0.01538121f, 0.02820980f, 0.01334529f, 
    -0.01680119f, 0.00160689f, -0.04252922f, 0.01749605f, -0.04386637f, 0.02464221f, -0.00957320f, -0.00704641f, 
    -0.00969637f, -0.01512218f, 0.01032905f, -0.00331205f, -0.01786415f, -0.04314047f, 0.00835074f, -0.04396192f, 
    0.00408504f, 0.00600994f, -0.00324690f, 0.00268629f, 0.01986401f, -0.04129013f, -0.03108262f, 0.02632323f, 
    0.00281124f, -0.03672011f, 0.01943242f, -0.00072034f, 0.00576699f, -0.01361946f, 0.01620449f, -0.02103271f, 
    0.00331229f, 0.01383894f, -0.02320657f, -0.02035672f, -0.00447024f, -0.03208791f, -0.02361632f, 0.00188260f, 
    0.01049375f, 0.02456316f, -0.01122748f, 0.01621515f, 0.02629000f, -0.03229126f, -0.02809193f, 0.02372935f, 
    -0.02850796f, -0.03408508f, 0.00757553f, -0.03483811f, 0.02213833f, 0.00271445f, -0.00411136f, -0.00861653f, 
    -0.00601841f, 0.00717770f, 0.00313798f, -0.01412070f, -0.02326206f, -0.00943252f, -0.00427919f, -0.00625839f, 
    -0.02356559f, 0.01235662f, 0.02992009f, -0.01974411f, -0.02612453f, 0.00045391f, -0.02013272f, -0.00654079f, 
    0.01867631f, -0.02044792f, -0.02203226f, -0.00184122f, 0.01405128f, -0.03191255f, -0.03827603f, -0.03572989f, 
    -0.01383729f, -0.03368214f, 0.02108063f, 0.00225503f, 0.01384149f, -0.03926207f, -0.01518347f, -0.00892909f, 
    -0.00327337f, -0.01317466f, 0.02336764f, -0.01248212f, 0.00316409f, 0.02094381f, -0.00252136f, 0.01540818f, 
    -0.03021888f, 0.01010676f, 0.01594059f, -0.03308492f, 0.00394844f, 0.00347427f, -0.03783099f, -0.02449136f, 
    -0.02031015f, 0.01405929f, -0.00152837f, 0.01026769f, -0.02038693f, 0.01735825f, -0.00407263f, -0.01317981f, 
    -0.00140073f, -0.04145344f, 0.01013549f, -0.03407928f, 0.00880470f, 0.02566071f, -0.01801675f, -0.03396985f, 
    -0.03897323f, -0.03377518f, -0.01253427f, -0.01571877f, -0.03395474f, -0.00870269f, -0.02895865f, -0.01137814f, 
    -0.03349182f, 0.00981620f, -0.01654357f, 0.00447772f, 0.02662773f, 0.02784521f, 0.00191037f, -0.00551382f, 
    -0.03563404f, -0.03377322f, -0.01237906f, -0.00671963f, -0.03565516f, -0.00625657f, -0.00594587f, -0.04262669f, 
    0.00702636f, -0.01872156f, -0.02069687f, 0.01013816f, 0.01528291f, 0.00974145f, -0.04370833f, -0.02786877f, 
    -0.00178287f, -0.01652251f, -0.02155156f, -0.01337217f, -0.00370842f, -0.02313571f, -0.03955401f, -0.01605137f, 
    -0.02579491f, -0.03539526f, -0.03580675f, 0.02226669f, -0.03175800f, -0.01361264f, -0.01141383f, -0.01485393f, 
    -0.02257348f, -0.01388736f, -0.02514753f, -0.03388946f, -0.01088351f, 0.00455782f, -0.02633480f, 0.01575883f, 
    0.02661370f, -0.01702594f, 0.00111567f, -0.01499512f, -0.02473993f, -0.01787481f, -0.04478548f, 0.00895016f, 
    -0.04310231f, -0.04469107f, -0.04428028f, -0.04245752f, -0.04324242f, 0.01848020f, -0.04033770f, 0.02860245f, 
    -0.02332522f, -0.04231306f, -0.01438357f, -0.04225734f, -0.03181298f, -0.01558637f, -0.02115972f, -0.03244750f, 
    -0.01653353f, -0.04585116f, -0.04449271f, -0.04524067f, 0.01204674f, 0.00325381f, -0.04335860f, -0.00138304f, 
    -0.00759747f, 0.00522217f, -0.03394219f, 0.00598170f, 0.00683290f, -0.01445573f, 0.00025713f, 0.00867183f, 
    -0.02826077f, -0.03509142f, 0.02641587f, 0.00000029f, -0.03233946f, -0.00250137f, -0.02785338f, -0.04155590f, 
    0.02619911f, -0.03183834f, -0.00102786f, 0.03291522f, -0.02354272f, -0.03137233f, -0.01645180f, 0.00605250f, 
    -0.02877650f, 0.00059975f, 0.02226168f, -0.03382440f, 0.02515777f, 0.02548736f, -0.03600428f, -0.04004870f, 
    -0.01897662f, -0.03230409f, -0.02588126f, 0.00123235f, 0.02565182f, -0.03218693f, -0.02023994f, -0.00554582f, 
    -0.02845999f, 0.01945652f, -0.00930938f, 0.01262948f, -0.03504854f, -0.03387592f, -0.00090906f, -0.02274260f, 
    0.00518652f, -0.03027125f, 0.02426023f, -0.03230133f, 0.00849184f, -0.00377726f, -0.02919138f, 0.02103153f, 
    -0.03811806f, -0.03340917f, -0.03446031f, 0.01583751f, -0.03511201f, -0.00565141f, 0.01201900f, 0.01793155f, 
    0.01466071f, 0.02763726f, -0.02255637f, -0.02175860f, -0.00376356f, 0.00476393f, 0.00682291f, -0.01483066f, 
    -0.03078495f, 0.02277848f, 0.02956475f, 0.00967668f, -0.03680830f, -0.02922991f, 0.01121526f, 0.01830001f, 
    -0.01349971f, -0.02760257f, -0.00356075f, 0.00161209f, 0.02537678f, 0.00948216f, 0.02142668f, -0.01672634f, 
    -0.01995623f, -0.03703550f, 0.00029775f, 0.02629738f, -0.02977304f, -0.00488494f, -0.00905683f, 0.02392506f, 
    -0.01682443f, 0.00146134f, -0.00866122f, -0.00851210f, -0.01963262f, -0.03636340f, -0.01404754f, -0.03479908f, 
    -0.00184086f, 0.00569648f, 0.01172110f, -0.01595844f, -0.00880457f, 0.00386971f, 0.00910138f, 0.01117465f, 
    -0.02959898f, -0.00182308f, -0.01936432f, 0.01781170f, -0.03497702f, -0.03795166f, 0.01083805f, 0.00566032f, 
    -0.03444452f, -0.01928647f, 0.01377953f, 0.01671683f, -0.02251075f, -0.02940552f, 0.02020917f, 0.02833979f, 
    0.00944434f, -0.01625257f, 0.02414701f, -0.00359671f, 0.01794655f, -0.00520274f, 0.00936900f, -0.03508811f, 
    0.00874459f, 0.02344903f, -0.01247125f, -0.03846044f, 0.02626402f, 0.01273623f, 0.02978430f, -0.01886789f, 
    -0.03873756f, -0.01433994f, -0.00201436f, 0.02359591f, -0.02260979f, 0.02065826f, -0.04162751f, -0.03839222f, 
    -0.01673202f, -0.00033974f, -0.02754681f, 0.01114287f, 0.01810535f, -0.02821064f, -0.02020115f, 0.00700275f, 
    -0.01256442f, -0.00318061f, -0.03731215f, -0.03636082f, -0.03960128f, 0.02062211f, -0.00899466f, -0.03422990f, 
    -0.03039495f, -0.03671935f, 0.01496811f, 0.00028814f, -0.01339786f, -0.01522614f, -0.00677637f, -0.03916626f, 
    -0.02676043f, 0.00396198f, -0.03907407f, 0.02637107f, 0.00971479f, 0.01420935f, 0.01904608f, -0.00852315f, 
    0.00662698f, -0.00083899f, -0.01267986f, -0.04204473f, 0.01765208f, -0.01053106f, -0.03275329f, -0.02112836f, 
    0.01296816f, 0.00289897f, -0.03526302f, -0.00707481f, -0.02838520f, -0.00120122f, 0.00468814f, -0.02088930f, 
    -0.02064155f, -0.01276863f, 0.02143786f, -0.00230493f, -0.01817659f, 0.02350747f, -0.01386438f, 0.02673761f, 
    -0.03615676f, 0.00565643f, 0.00857331f, 0.01726771f, -0.03567519f, 0.02895702f, -0.01373963f, -0.03000188f, 
    -0.03641605f, -0.02540206f, 0.01886971f, -0.00351997f, -0.01251142f, -0.02977610f, -0.00469503f, -0.02286635f, 
    -0.02067072f, 0.01132065f, 0.00595256f, -0.02883563f, 0.02438703f, 0.02735818f, 0.01475947f, -0.00125757f, 
    -0.02289310f, 0.00921068f, -0.01414074f, 0.02068528f, -0.01070077f, -0.00319288f, 0.02668511f, 0.01620321f, 
    -0.00251481f, -0.01183616f, -0.02805033f, -0.02643105f, 0.00779830f, -0.00458844f, 0.01759954f, -0.00133988f, 
    0.00678210f, 0.00932323f, -0.00228530f, 0.02276676f, -0.03947772f, -0.04043316f, -0.01537454f, -0.03476473f, 
    0.01397073f, -0.03274148f, -0.01991850f, 0.00330344f, -0.02651549f, 0.00888122f, 0.00026837f, 0.01946969f, 
    -0.03278616f, -0.00865255f, 0.01239609f, 0.02396985f, 0.02956463f, -0.02702408f, 0.01907465f, -0.02333621f, 
    0.01604636f, 0.00233584f, -0.04093927f, -0.02772295f, 0.01049051f, 0.01453760f, -0.03299663f, 0.01883823f, 
    -0.00749043f, 0.02715665f, 0.00947025f, -0.03651550f, 0.02547286f, -0.03337877f, -0.03334862f, -0.00960479f, 
    -0.02561218f, 0.00843945f, -0.02312547f, 0.00908630f, -0.00799957f, -0.00551093f, 0.01931278f, -0.02882308f, 
    -0.04076225f, 0.01725979f, -0.00527498f, 0.01782175f, 0.00641350f, -0.00877078f, -0.00782439f, -0.03021671f, 
    -0.01885714f, -0.02831172f, -0.02401787f, -0.01144139f, -0.00158416f, 0.00696955f, -0.03025401f, -0.01425759f, 
    -0.04069159f, 0.01233676f, 0.00044094f, -0.01603191f, -0.04038035f, -0.02894857f, 0.01687679f, -0.01109102f, 
    -0.01289254f, -0.00160500f, 0.02835282f, 0.01812338f, -0.00498008f, -0.03493109f, 0.02058434f, -0.03313122f, 
    0.02371355f, 0.01193258f, 0.02213286f, -0.00469499f, -0.00430056f, -0.01424366f, -0.01917684f, 0.01689625f, 
    -0.01963140f, -0.02942777f, -0.00656674f, 0.00864995f, -0.02492235f, -0.03515771f, -0.02580485f, 0.02476874f, 
    0.01426719f, 0.02947964f, -0.01723628f, -0.01883694f, -0.01200273f, -0.01060624f, 0.02815880f, 0.00463760f, 
    -0.00338354f, -0.01905909f, 0.01064370f, 0.01232776f, 0.02668804f, -0.01755013f, 0.00620887f, -0.02465939f, 
    -0.01158184f, -0.01830776f, 0.00577524f, 0.01157150f, 0.02938663f, 0.00494077f, 0.01050497f, 0.01459914f, 
    -0.00161078f, -0.02384144f, 0.00828653f, -0.04162998f, -0.01518602f, -0.00352402f, -0.00778073f, -0.01992879f, 
    -0.01283454f, 0.02823065f, -0.00927502f, 0.00297959f, 0.01681668f, -0.00247075f, 0.00600418f, -0.02561866f, 
    -0.01978158f, -0.00189243f, 0.02365478f, -0.02490496f, 0.02090235f, 0.01789416f, -0.03186434f, -0.00850642f, 
    0.00847944f, -0.03082600f, -0.00469537f, -0.04011174f, 0.02345874f, -0.03808847f, -0.00017897f, 0.02532885f, 
    -0.01806857f, 0.01758360f, 0.00366535f, -0.02992180f, 0.00153429f, 0.01496954f, 0.02554403f, -0.02490168f, 
    0.02708584f, -0.03595442f, -0.00931306f, -0.01365960f, -0.03764635f, -0.02011102f, -0.01189728f, 0.01131523f, 
    0.00847558f, -0.02926260f, 0.02370498f, -0.00569940f, -0.04207367f, -0.02189391f, 0.02062651f, 0.01405575f, 
    -0.00242743f, -0.00518808f, -0.01364885f, -0.02835826f, 0.01186041f, 0.02993012f, -0.03920893f, -0.01318979f, 
    -0.00053949f, -0.02875473f, 0.00075437f, -0.00850358f, -0.03520467f, -0.03867390f, 0.01745308f, -0.02501234f, 
    0.02397682f, -0.02602257f, -0.00588386f, -0.03932678f, -0.00600771f, -0.01419903f, 0.01559441f, -0.03332110f, 
    -0.00407193f, 0.00975407f, -0.01050476f, 0.02373794f, -0.03768160f, 0.01358650f, -0.04176256f, -0.01568215f, 
    -0.02932995f, -0.02567611f, 0.02693861f, -0.01887264f, 0.02167172f, -0.02103704f, 0.00486205f, -0.02654943f, 
    -0.03656076f, 0.02671010f, -0.01994339f, -0.00551129f, -0.03371380f, 0.02227360f, -0.00553571f, -0.00860034f, 
    -0.01121084f, -0.02325879f, 0.02733323f, 0.00501187f, 0.00953745f, 0.02986054f, -0.03073305f, -0.00529022f, 
    -0.01742698f, 0.01466307f, -0.03826554f, 0.01151657f, 0.01388215f, 0.02532985f, -0.02398094f, -0.03069730f, 
    0.02559413f, 0.01264911f, -0.02133434f, -0.00555058f, -0.01489190f, -0.03180636f, 0.01590007f, -0.01780985f, 
    -0.00712466f, 0.00079231f, 0.01341826f, -0.04096513f, 0.01589130f, 0.00631565f, -0.00747182f, -0.01261370f, 
    -0.01980387f, -0.02036109f, 0.01629210f, -0.01375475f, -0.01067045f, -0.01478452f, 0.01878453f, 0.00152189f, 
    0.00402499f, 0.01450401f, 0.00055762f, 0.02044236f, 0.02122090f, -0.02784435f, -0.02696131f, 0.02450068f, 
    0.00628656f, 0.00806258f, 0.02124390f, -0.02325515f, -0.00850879f, -0.03746318f, -0.02506023f, -0.01500865f, 
    -0.00901375f, 0.01394639f, 0.00245812f, -0.00050521f, -0.01045402f, 0.00375488f, 0.00306988f, -0.02630882f, 
    -0.03754004f, -0.02545328f, -0.03985093f, 0.02469074f, 0.00102693f, 0.02004825f, -0.00511750f, 0.00601127f, 
    0.02382099f, -0.02774416f, -0.00266860f, 0.00204126f, -0.00308986f, -0.02352713f, -0.03280721f, 0.01319880f, 
    -0.02239907f, 0.01899656f, -0.02286124f, 0.00905206f, -0.03009519f, -0.03517257f, 0.02634295f, -0.02420175f, 
    -0.02999289f, -0.02318799f, 0.02963318f, -0.01832368f, 0.01523675f, -0.00470188f, -0.01080276f, -0.00771604f, 
    -0.02417936f, 0.00404848f, -0.01790884f, 0.00168880f, 0.02964921f, 0.02774155f, -0.01994874f, 0.00029625f, 
    -0.00569987f, -0.02415346f, 0.02635941f, -0.02957359f, 0.01583885f, -0.00516020f, -0.03355077f, 0.02959201f, 
    0.00036228f, 0.02372352f, 0.00394352f, -0.04199073f, -0.01453868f, 0.02580203f, -0.03859213f, 0.02597378f, 
    -0.02624136f, 0.00723066f, -0.03379150f, 0.01343769f, 0.00010599f, -0.00323899f, 0.01187970f, 0.01843428f, 
    0.00043880f, -0.00801359f, -0.02953134f, 0.00359069f, 0.02343401f, -0.01183579f, 0.00194731f, 0.02091380f, 
    -0.00119938f, -0.03881894f, -0.03272064f, -0.02389356f, -0.03588060f, -0.03294919f, -0.01746952f, 0.01796007f, 
    -0.01570188f, 0.02447651f, -0.00315701f, -0.03372204f, -0.01515356f, 0.00083340f, -0.02911221f, 0.01927215f, 
    0.02386845f, -0.03724054f, 0.01592242f, -0.01283164f, 0.00342317f, -0.00331478f, -0.01381218f, -0.00552286f, 
    0.00202994f, -0.03414519f, -0.02416270f, -0.02217899f, 0.00258564f, -0.04031737f, -0.01143547f, -0.04170552f, 
    -0.02746560f, -0.02582362f, 0.01249276f, -0.03634820f, -0.01872401f, -0.01817159f, -0.01717251f, -0.00128598f, 
    -0.00552690f, 0.02035548f, 0.01673217f, -0.00161048f, 0.02214690f, 0.00655872f, 0.02012127f, -0.00503096f, 
    0.00237575f, 0.00161492f, -0.02131327f, 0.01759327f, -0.00244307f, 0.00422116f, 0.00452549f, 0.02498012f, 
    0.02085125f, 0.00102928f, 0.01771552f, -0.03159012f, 0.02432295f, -0.00566325f, 0.01991393f, 0.01024234f, 
    -0.01807025f, 0.00113568f, -0.02746811f, 0.01011525f, -0.00224328f, 0.01842357f, 0.01104586f, -0.04112208f, 
    -0.03592877f, -0.01325469f, 0.02876898f, 0.01195143f, -0.01547351f, -0.01278765f, -0.00576737f, 0.00649869f, 
    -0.03661855f, -0.02074889f, 0.00581200f, 0.02042217f, 0.02931894f, -0.03412117f, 0.02204195f, -0.04122671f, 
    -0.02267293f, 0.01723438f, -0.00329399f, -0.03178776f, -0.00332287f, 0.01685912f, 0.01659982f, -0.03854890f, 
    -0.03531283f, -0.00096906f, -0.01922002f, -0.02120518f, -0.02154107f, -0.03413910f, -0.02496828f, -0.00408229f, 
    0.00968462f, -0.04097567f, -0.00373067f, -0.03420172f, -0.03123860f, 0.00110549f, -0.01212895f, 0.01387700f, 
    -0.02716180f, -0.00182070f, -0.02892386f, -0.01596210f, 0.00392997f, 0.03002507f, -0.02371308f, 0.00829512f, 
    -0.03513133f, -0.04053972f, 0.00737471f, -0.00526157f, 0.02366295f, 0.00846340f, 0.00097316f, -0.02767591f, 
    -0.03237059f, -0.00377716f, -0.00800767f, 0.01667267f, -0.02678555f, -0.01634670f, -0.03288461f, 0.00141451f, 
    -0.01226481f, 0.00680451f, -0.01303050f, -0.03863918f, -0.00945321f, 0.00722428f, -0.03152474f, 0.00135730f, 
    0.01727299f, -0.00494555f, -0.02806114f, -0.00131684f, -0.02199805f, 0.01742261f, -0.02177106f, -0.03764055f, 
    -0.00476932f, 0.02165754f, -0.00078626f, 0.00485838f, -0.02449783f, -0.02608635f, 0.02817067f, 0.00255903f, 
    -0.01584351f, 0.00743139f, 0.02158958f, -0.01814957f, -0.03290786f, -0.01225839f, 0.01110457f, -0.00094714f, 
    0.03510498f, -0.38087994f, 0.09367360f, -0.03667293f, 0.08186691f, 0.04061616f, 0.12096339f, 0.06197413f, 
    -0.04545650f, -0.00979402f, 0.00293258f, -0.05985561f, -0.14013363f, 0.11287051f, 0.24789357f, -0.09095410f, 
    -0.06727951f, -0.05928482f, 0.00154979f, 0.07762658f, 0.12806664f, 0.02009831f, -0.15799238f, -0.08517750f, 
    -0.07508928f, -0.10830840f, 0.07057769f, 0.03195770f, -0.04702754f, 0.01215819f, -0.12566532f, 0.00565734f, 
    0.00629847f, -0.03427447f, 0.09299194f, 0.17987366f, 0.21157585f, 0.06914325f, -0.06064180f, -0.00176870f, 
    0.04150620f, 0.08493686f, -0.06106136f, 0.11980924f, 0.03752636f, -0.01899725f, -0.09580902f, -0.03423041f, 
    -0.01305514f, -0.35286388f, 0.17818797f, -0.09393062f, 0.03899091f, -0.10824406f, 0.08970114f, 0.12501428f, 
    0.02068486f, 0.07488374f, 0.13295071f, 0.08245876f, -0.07351365f, -0.09180997f, 0.14329170f, 0.06151740f, 
    -0.00828986f, 0.01540488f, -0.11358626f, 0.02805161f, 0.04615586f, 0.05620713f, 0.09067324f, -0.01591058f, 
    -0.12481688f, -0.00115721f, 0.16016674f, 0.04988832f, 0.04566839f, 0.14705366f, 0.06448250f, -0.03590916f, 
    0.07093036f, -0.00879025f, 0.05414649f, 0.09714666f, -0.00276443f, -0.06992090f, -0.29166201f, 0.14802991f, 
    0.06470878f, 0.06824930f, 0.03241118f, 0.12552291f, 0.08580384f, 0.02197138f, 0.18145777f, 0.06135416f, 
    -0.39213219f, -0.20817855f, -0.12231114f, -0.05461997f, 0.01844090f, 0.01917025f, 0.04665784f, 0.07441173f, 
    -0.02631210f, 0.17572327f, -0.02569045f, 0.08028044f, -0.16566470f, -0.01984532f, 0.05016889f, 0.13991788f, 
    -0.01305447f, 0.15932821f, 0.04940278f, 0.05259086f, 0.02152816f, 0.01639312f, -0.01378308f, 0.02809827f, 
    -0.07811001f, 0.06226846f, 0.20268723f, -0.04995662f, 0.04463652f, 0.00059512f, 0.06994423f, -0.03627789f, 
    0.13579024f, 0.05394450f, -0.01451345f, 0.16248828f, 0.00452740f, -0.01279382f, 0.10888573f, 0.05441178f, 
    -0.01537002f, 0.04003436f, -0.05822720f, 0.04684542f, 0.05992828f, -0.06744135f, 0.00099890f, 0.18933652f, 
    0.08587449f, 0.13153842f, 0.08079562f, 0.04348829f, -0.04740975f, 0.17754151f, 0.11335573f, 0.01986322f, 
    -0.07608129f, -0.02055634f, 0.08565363f, 0.20665126f, -0.08320049f, 0.05119901f, 0.20165689f, -0.20048025f, 
    -0.10569120f, 0.06088571f, -0.04109318f, 0.04977166f, 0.01462172f, 0.00383415f, 0.07881309f, -0.07065894f, 
    0.03804556f, 0.08067659f, 0.10387468f, -0.09856779f, -0.08159475f, 0.01542645f, 0.00995658f, 0.00845741f, 
    -0.00152569f, -0.08143004f, 0.06310325f, -0.09194629f, 0.00568856f, 0.08560193f, 0.10833989f, 0.16930117f, 
    -0.08376939f, 0.09570117f, 0.05296956f, 0.19110166f, 0.04130328f, 0.12400324f, 0.01853970f, 0.10846639f, 
    0.08943725f, -0.07390038f, -0.00650365f, -0.05373127f, -0.01565995f, -0.03134748f, -0.01857043f, 0.02221735f, 
    -0.03538457f, 0.01393252f, -0.01559770f, 0.15852766f, -0.13568455f, -0.00911994f, 0.11162417f, -0.02811874f, 
    0.02157275f, -0.03672718f, 0.16478327f, -0.06435367f, 0.07544147f, 0.00500910f, -0.07800882f, 0.16534692f, 
    0.06509196f, 0.03179179f, -0.17432755f, -0.02988539f, 0.10944679f, 0.12183439f, 0.03226906f, 0.10498238f, 
    -0.04884194f, 0.03066406f, -0.01143270f, -0.01884158f, -0.02086152f, 0.10687133f, -0.12891589f, -0.21476750f, 
    -0.01139239f, -0.15945816f, -0.00541712f, 0.15810207f, 0.06141408f, 0.14053641f, 0.00802685f, -0.00904767f, 
    0.15233485f, 0.13930559f, -0.15830132f, -0.02928062f, -0.03969756f, -0.10523769f, -0.05106907f, 0.21281576f, 
    -0.17111485f, -0.00875683f, 0.09911960f, -0.12686242f, 0.22884408f, 0.04513907f, 0.21043684f, 0.08667331f, 
    -0.03417779f, 0.14019352f, 0.11234504f, 0.03692409f, -0.03183948f, -0.03842437f, -0.07396677f, -0.08627453f, 
    0.15962589f, -0.28273341f, 0.03032940f, 0.04304761f, -0.05151393f, 0.06174357f, 0.05590848f, -0.01129014f, 
    -0.09166572f, -0.04086955f, -0.04503288f, 0.03974728f, -0.13540263f, 0.20170443f, -0.15715653f, -0.14412118f, 
    -0.07256486f, 0.11746004f, -0.03433748f, 0.01452535f, -0.01275479f, -0.03654381f, 0.00541554f, -0.05747335f, 
    -0.41724926f, -0.26541117f, -0.03628684f, -0.19981772f, -0.15534307f, -0.23034582f, 0.02225277f, 0.12743345f, 
    0.16629003f, 0.03447024f, 0.09299918f, 0.12694739f, -0.14779687f, -0.01066514f, 0.15955760f, -0.04882356f, 
    0.00078298f, -0.02640161f, -0.01275971f, 0.10369217f, -0.13400544f, -0.02671940f, 0.02568645f, 0.07560427f, 
    0.18610616f, -0.01080743f, 0.10595459f, -0.03501543f, -0.00516071f, -0.01254201f, 0.08167343f, 0.08496122f, 
    0.12510835f, 0.07185303f, 0.11855454f, 0.02750043f, -0.03203207f, 0.04966765f, -0.11961998f, 0.06664748f, 
    0.05738942f, 0.04048375f, -0.01125975f, 0.02172661f, -0.00038349f, 0.00255463f, -0.12759420f, 0.05559071f, 
    0.15197039f, -0.08386368f, -0.14463899f, 0.18404746f, 0.01080634f, 0.16132034f, -0.02828019f, 0.14794382f, 
    -0.04808240f, 0.12637536f, 0.09537265f, 0.11649575f, -0.23365742f, 0.02892200f, 0.25782412f, 0.04477424f, 
    -0.10872480f, -0.00477253f, 0.02964495f, 0.05320945f, 0.12811129f, 0.00003283f, -0.04659035f, 0.03392124f, 
    -0.18138720f, 0.15765411f, -0.13974105f, 0.06217275f, 0.13889003f, 0.01479851f, -0.05377064f, 0.01298935f, 
    0.05227758f, -0.05469348f, -0.00278897f, -0.01549324f, -0.32734275f, -0.00848568f, -0.22128986f, 0.25645825f, 
    -0.01544497f, -0.05609726f, -0.09702892f, 0.02163738f, -0.04216348f, 0.01992249f, -0.00017710f, -0.00688556f, 
    -0.05400023f, -0.19123338f, -0.16943835f, 0.07224227f, 0.17757246f, 0.01531167f, 0.07930647f, 0.09647387f, 
    -0.04989624f, 0.09672348f, 0.04172985f, 0.01670805f, 0.02577540f, -0.05313284f, 0.17316820f, 0.23890382f, 
    -0.13514072f, -0.09181834f, 0.09198322f, -0.01847584f, -0.00904781f, -0.02941346f, -0.06604932f, 0.07065679f, 
    0.05755064f, -0.04164126f, 0.18070412f, 0.19136035f, -0.00873362f, -0.02866743f, 0.01667163f, 0.07253964f, 
    0.05050104f, 0.02355757f, 0.02060472f, 0.06036195f, 0.13262786f, -0.22733617f, 0.15827468f, 0.01557448f, 
    0.14676787f, 0.03752737f, 0.03252219f, 0.11586493f, 0.12899821f, 0.03634384f, 0.02937121f, 0.13166745f, 
    0.02255155f, 0.14221631f, 0.16383390f, -0.00129936f, 0.05549520f, 0.07335362f, 0.08426169f, 0.01339650f, 
    0.01464244f, 0.03378679f, 0.11594063f, 0.04466043f, -0.06938946f, -0.00539319f, 0.16238548f, 0.08501771f, 
    -0.12412210f, 0.06457433f, -0.02953153f, 0.03471615f, 0.14050332f, 0.03648372f, -0.00990600f, 0.02445617f, 
    -0.14234315f, 0.03394043f, 0.12506770f, 0.06724192f, 0.03044660f, 0.00624488f, 0.05180792f, -0.03832089f, 
    0.10552509f, 0.00243924f, 0.08714197f, 0.04201122f, -0.10767349f, 0.10840993f, -0.02788913f, -0.22606778f, 
    0.01095738f, 0.12619185f, 0.03032145f, -0.03177790f, 0.01049975f, -0.09628981f, 0.12680876f, 0.00745965f, 
    0.08645058f, -0.08586235f, -0.23971531f, -0.05484834f, 0.08919452f, -0.06514149f, -0.05712776f, 0.00720424f, 
    -0.02079266f, 0.05912276f, -0.01318014f, 0.08903393f, 0.25101596f, 0.03972026f, -0.15604672f, -0.07715543f, 
    -0.04424622f, -0.08306503f, 0.04270757f, 0.02478893f, 0.11513562f, 0.00522556f, -0.04835157f, -0.06914959f, 
    -0.15886869f, -0.19780745f, -0.22392347f, -0.03676672f, 0.01638963f, -0.07972652f, -0.02562533f, 0.05708741f, 
    0.03669349f, -0.00147897f, 0.01893676f, 0.01167226f, 0.18660527f, -0.23246711f, 0.02961337f, -0.09057701f, 
    0.01252238f, -0.04599475f, 0.03914575f, 0.16846870f, -0.03953941f, 0.04736029f, 0.08713939f, -0.06641611f, 
    -0.00584710f, -0.16153686f, -0.07072771f, 0.02317854f, 0.01276106f, 0.05167088f, 0.11064160f, -0.01288800f, 
    0.06891835f, 0.01798810f, 0.05130932f, 0.09187784f, 0.00553334f, 0.17427659f, 0.11155079f, -0.24404362f, 
    -0.04230805f, -0.05543888f, -0.02672349f, 0.11996587f, 0.02126366f, -0.09232330f, -0.02856183f, -0.04139435f, 
    0.05901248f, 0.06113701f, 0.13776535f, 0.15984437f, 0.03088969f, 0.01019047f, 0.14129375f, -0.01690335f, 
    0.09934384f, 0.00724703f, -0.04341754f, 0.00295685f, -0.06412004f, -0.10336848f, -0.29331505f, -0.21398789f, 
    0.00349410f, 0.13971972f, 0.02324796f, 0.00361466f, 0.00685920f, -0.03736267f, 0.05851967f, -0.04097060f, 
    0.02261101f, -0.05150710f, -0.26167998f, -0.01408382f, -0.03159457f, 0.03578621f, -0.09628811f, 0.05077230f, 
    -0.00319489f, -0.00033158f, 0.07304651f, 0.04079522f, -0.08656859f, 0.17950313f, 0.08762722f, 0.09118064f, 
    -0.05074212f, 0.09959520f, 0.07727583f, 0.08405587f, 0.05372026f, 0.06060310f, 0.08922780f, 0.13099943f, 
    -0.13734457f, 0.23469500f, -0.03143901f, 0.05399425f, -0.00836339f, 0.11703156f, 0.10141379f, 0.05959682f, 
    -0.01085363f, -0.07884156f, -0.08094531f, 0.00924884f, 0.24176744f, -0.06458394f, 0.06479251f, 0.17021742f, 
    -0.16797107f, -0.02369103f, -0.00193067f, 0.01278667f, -0.03940905f, -0.01114604f, -0.06687024f, 0.05607616f, 
    0.09021416f, -0.08260029f, -0.02409657f, 0.08522186f, 0.18015707f, -0.00665228f, 0.04982624f, 0.16000095f, 
    0.00514145f, 0.05629611f, -0.09765873f, -0.02175827f, 0.08101257f, -0.02005399f, 0.09019595f, 0.12834485f, 
    0.02939976f, 0.02595236f, -0.00437336f, -0.00294107f, -0.01661379f, 0.04374049f, -0.04875629f, 0.10326247f, 
    0.02433014f, 0.02833505f, 0.10403910f, 0.03731850f, -0.05202387f, 0.00636380f, -0.01191517f, 0.05646607f, 
    0.13022549f, 0.01652221f, 0.05879708f, 0.04155762f, 0.09919437f, 0.02989484f, -0.04631980f, 0.13796936f, 
    0.02490360f, 0.08647636f, 0.11740432f, 0.02871816f, 0.03003197f, 0.06210958f, -0.03871089f, 0.03160724f, 
    0.07496876f, -0.03966273f, 0.21678038f, -0.05331630f, -0.11026541f, 0.02408516f, 0.11433678f, 0.00525727f, 
    0.11856833f, -0.05639984f, 0.02262310f, -0.06064120f, 0.16169095f, -0.16526683f, 0.18779953f, -0.05530142f, 
    -0.05740605f, 0.00713016f, 0.11151370f, -0.03256750f, -0.00280331f, 0.02981015f, 0.00390055f, 0.08742023f, 
    0.05031428f, 0.20941420f, -0.24444796f, 0.00329272f, 0.07777422f, -0.02448217f, 0.03704819f, 0.05892853f, 
    0.00569958f, -0.12524565f, -0.00530536f, 0.06408106f, -0.05724606f, 0.05318331f, 0.10632885f, 0.06726794f, 
    -0.24404764f, -0.10178506f, -0.02757940f, 0.05056350f, 0.09174632f, -0.01047895f, 0.02880764f, 0.00470834f, 
    0.00168784f, 0.23070778f, -0.01149400f, -0.03715029f, 0.08675232f, 0.02869215f, 0.01825467f, 0.00652009f, 
    0.05789249f, -0.04461145f, 0.08205079f, 0.08191645f, 0.11670645f, -0.22666770f, 0.17301963f, 0.08477703f, 
    0.01522576f, 0.08858332f, 0.16426143f, -0.01521698f, -0.11781973f, 0.10073762f, 0.20376217f, -0.05097897f, 
    -0.00738193f, -0.10812638f, -0.01709861f, 0.01367457f, 0.07274810f, -0.03832372f, 0.02635455f, 0.02197978f, 
    0.00022074f, 0.00173763f, 0.04648801f, 0.04987400f, 0.09222797f, -0.04947498f, -0.02237914f, -0.04242332f, 
    -0.10242665f, 0.06342576f, 0.10728729f, -0.03090577f, -0.03412431f, 0.01995204f, 0.09975829f, -0.03587767f, 
    0.11656430f, -0.05799975f, 0.05262289f, 0.00051778f, -0.06842511f, 0.09509268f, -0.05965028f, 0.02802921f, 
    0.13191138f, 0.05005153f, 0.04079328f, 0.03309908f, 0.17821805f, 0.16307738f, 0.18976110f, 0.24196301f, 
    0.02210435f, -0.00855324f, -0.02466142f, 0.00891399f, 0.11772330f, 0.04005275f, 0.09948035f, 0.21823305f, 
    0.05699094f, -0.05931780f, -0.19222265f, -0.05914882f, 0.08176387f, -0.04000637f, 0.10491414f, 0.02266962f, 
    -0.09973766f, 0.01534241f, 0.03306117f, 0.06871954f, 0.19542874f, -0.05939494f, 0.15593097f, 0.09526390f, 
    0.01794299f, -0.04637730f, -0.05411713f, 0.03986222f, 0.01437624f, 0.03166254f, 0.02677067f, 0.05751622f, 
    0.16175093f, 0.19217917f, -0.02769741f, -0.22235915f, 0.07704992f, 0.08923919f, -0.13362804f, -0.00494196f, 
    0.10503850f, -0.01017691f, -0.00445291f, 0.05077052f, 0.47020736f, 0.20416664f, -0.16657852f, 0.11701601f, 
    0.05392802f, -0.08126207f, 0.08905263f, -0.06392748f, -0.02300227f, -0.03136664f, 0.01423532f, 0.03021716f, 
    0.03318115f, 0.04002032f, 0.00689835f, 0.10227308f, 0.02700225f, -0.00723105f, 0.08557291f, 0.01134013f, 
    0.06296016f, -0.01860492f, -0.00147870f, 0.01744280f, -0.08154407f, -0.02026957f, -0.15257166f, -0.01008581f, 
    0.02039071f, -0.02285310f, 0.17957532f, -0.06287409f, 0.06629583f, 0.05083484f, -0.02164499f, 0.04549647f, 
    -0.17867637f, -0.24181341f, -0.10131689f, -0.08047117f, 0.10114022f, 0.04352067f, -0.06332938f, -0.06036392f, 
    0.14100753f, -0.08263111f, 0.04679814f, 0.02537153f, -0.14576183f, 0.07445713f, -0.01482044f, -0.00047375f, 
    -0.02131457f, 0.01807983f, 0.02877515f, -0.02906716f, -0.08098542f, -0.01018238f, 0.03429333f, 0.08776482f, 
    0.11680803f, 0.00047947f, -0.11845420f, -0.03744248f, 0.00199123f, 0.05692081f, 0.02098336f, 0.08879763f, 
    -0.00951300f, -0.04769175f, 0.06561466f, -0.00492540f, -0.18564983f, 0.01975525f, -0.04765170f, 0.07970833f, 
    -0.03809872f, 0.04861202f, -0.06404470f, 0.06845573f, 0.02813526f, -0.02596113f, 0.10491510f, 0.04401044f, 
    0.10375064f, -0.14454384f, 0.02583741f, 0.10932037f, -0.05924252f, -0.02771983f, 0.01186277f, 0.05301207f, 
    -0.05286494f, 0.15644459f, -0.08133090f, -0.06615932f, 0.39584225f, -0.07726995f, -0.03689463f, 0.13931678f, 
    -0.00874426f, -0.00289850f, 0.01619207f, 0.08525176f, -0.02003057f, 0.01249912f, 0.06120525f, 0.02507017f, 
    -0.06747828f, 0.02367632f, 0.08027791f, -0.07447305f, -0.01112062f, -0.03745081f, 0.07744271f, -0.04196460f, 
    0.10699051f, -0.01047773f, 0.05745009f, 0.04945820f, 0.08674303f, 0.01723199f, 0.07105619f, 0.09862442f, 
    -0.02437216f, -0.11609147f, -0.01592831f, 0.00554598f, 0.11922827f, -0.00237112f, 0.08636664f, -0.02814831f, 
    -0.21932285f, 0.02479603f, 0.01336105f, -0.05035304f, 0.07343265f, -0.00629802f, -0.03399697f, 0.11401661f, 
    0.08730219f, 0.09974732f, 0.01543799f, 0.00019127f, 0.14110915f, 0.07338069f, 0.00182914f, 0.02387885f, 
    0.04030649f, 0.03204254f, -0.07810464f, 0.13358711f, 0.11335211f, -0.02600000f, 0.00421406f, 0.11715756f, 
    -0.13851903f, 0.04600752f, 0.13765503f, 0.18970978f, 0.06745493f, -0.06783431f, -0.08367620f, -0.07548379f, 
    0.05741307f, 0.05785399f, 0.06386419f, 0.02258746f, -0.20099567f, 0.14178792f, -0.00211954f, -0.03292634f, 
    -0.04411347f, -0.02587510f, 0.05476854f, 0.04865713f, -0.00229588f, 0.02129818f, 0.07377603f, -0.00418921f, 
    -0.04112536f, -0.02662058f, 0.24217638f, 0.15852471f, -0.01795493f, 0.08199771f, 0.04053821f, -0.00173244f, 
    -0.06162959f, 0.05999827f, 0.04078541f, 0.07876864f, -0.05427478f, 0.11736894f, -0.10719615f, -0.02125837f, 
    -0.06196183f, -0.01791752f, 0.03770222f, 0.07424184f, 0.12050799f, 0.02795378f, 0.16975684f, -0.05594813f, 
    0.34461865f, 0.06621372f, 0.02677864f, 0.07940188f, 0.00444958f, -0.01065091f, -0.06635533f, -0.00846021f, 
    0.05296632f, 0.11953793f, -0.14923713f, 0.10715761f, -0.29229754f, 0.00718328f, 0.20554847f, 0.05102995f, 
    0.09663364f, 0.03313185f, 0.03580909f, 0.05584000f, 0.07913392f, 0.03391032f, -0.00093865f, 0.08352406f, 
    -0.06264503f, -0.09590306f, -0.01235437f, -0.40198109f, -0.01403309f, 0.07394936f, 0.02391400f, -0.04203193f, 
    0.08811288f, -0.06349611f, 0.01263888f, 0.05045772f, 0.29878539f, -0.02908053f, -0.14337282f, 0.07951097f, 
    0.04970067f, -0.01611348f, 0.04919051f, 0.03137445f, -0.00395281f, -0.10523845f, 0.08009911f, -0.00185308f, 
    -0.25260004f, 0.06452282f, -0.19105695f, -0.00874523f, -0.06304212f, 0.02846502f, -0.04043932f, 0.09123815f, 
    0.08925486f, 0.06674554f, 0.00395200f, 0.08955092f, -0.09304281f, -0.01304798f, 0.03297674f, -0.08126205f, 
    0.07266444f, 0.05385354f, 0.00174345f, 0.03666335f, -0.02000985f, 0.03812211f, 0.06808718f, 0.06638619f, 
    -0.04943948f, 0.18288243f, 0.22637819f, 0.12782253f, -0.04176062f, -0.02763176f, 0.04013689f, -0.00779325f, 
    -0.03250594f, 0.01003961f, 0.03823971f, 0.02782159f, 0.36475307f, 0.05929796f, 0.02251434f, 0.13988677f, 
    -0.01102468f, 0.00273760f, 0.09334965f, 0.04872563f, -0.07928697f, 0.00749733f, 0.06574228f, 0.10519952f, 
    -0.00085182f, 0.02973952f, 0.03571546f, 0.12647027f, 0.00678139f, 0.03450085f, -0.05916912f, 0.13229387f, 
    0.04286370f, -0.01727569f, 0.06537656f, -0.03867907f, -0.36558437f, 0.06794231f, 0.11020122f, 0.01898786f, 
    0.01789936f, -0.00723663f, 0.06272008f, 0.06230756f, 0.10978935f, -0.02021027f, 0.08299765f, 0.04898268f, 
    0.04748955f, -0.07546114f, -0.19459368f, -0.04691228f, 0.00941075f, 0.09417198f, -0.04994892f, -0.01793590f, 
    0.00234445f, 0.02759936f, 0.01512561f, 0.04130622f, 0.44918442f, 0.12239744f, -0.11583336f, 0.07876706f, 
    0.11028084f, -0.00860540f, -0.08869769f, 0.09993793f, 0.06360886f, 0.03113663f, 0.02788361f, 0.10042889f, 
    0.29569274f, 0.19394921f, -0.05891738f, 0.18126917f, -0.02232689f, 0.04755522f, 0.03225296f, 0.08843408f, 
    0.02854974f, 0.03109242f, 0.02686757f, -0.01745896f, -0.10221149f, 0.12290094f, -0.07987811f, -0.07936458f, 
    0.14435560f, -0.02309304f, -0.06719138f, 0.08945873f, 0.00663143f, 0.00689872f, -0.04061439f, 0.00976355f, 
    0.14298214f, -0.09171001f, -0.11507829f, -0.04913292f, 0.04016116f, 0.02737309f, 0.09811500f, 0.08647568f, 
    0.03246269f, -0.01627693f, 0.04556941f, -0.03983588f, 0.52193856f, 0.16497301f, -0.02565949f, 0.17312831f, 
    -0.06599198f, -0.07502940f, -0.03101175f, -0.00357699f, 0.04574893f, -0.03761017f, 0.12035649f, 0.02795268f, 
    0.20701642f, 0.19414459f, -0.03477606f, 0.11403015f, -0.02337113f, -0.01925220f, -0.06939320f, 0.00220330f, 
    0.02596124f, 0.10065424f, -0.01299494f, 0.14641847f, 0.09246361f, 0.03479861f, -0.04313523f, -0.01825626f, 
    0.09296751f, 0.00681497f, 0.05682186f, 0.02976143f, -0.06159898f, 0.05704701f, 0.07976295f, 0.04882314f, 
    -0.08233647f, -0.04193134f, -0.09045906f, -0.16976403f, 0.01488277f, 0.17646270f, 0.08772326f, -0.05429850f, 
    0.02595705f, 0.00509091f, 0.07866512f, 0.07944199f, -0.07971030f, -0.23494722f, -0.02827657f, 0.02146176f, 
    0.00651886f, 0.13178931f, 0.01503445f, 0.01436659f, 0.16278231f, 0.03710267f, 0.03493646f, 0.05989346f, 
    -0.05640352f, -0.04280181f, -0.14810009f, -0.22796786f, -0.03642593f, 0.07398628f, 0.08548490f, -0.03294403f, 
    0.04443081f, 0.01414974f, -0.05748831f, -0.01072713f, 0.16307551f, 0.04382055f, -0.15864214f, -0.15708530f, 
    0.08137216f, 0.11032386f, -0.01248052f, 0.05508751f, 0.07895190f, -0.01262859f, -0.06091429f, 0.05578059f, 
    0.09650390f, -0.02454498f, 0.06478713f, -0.01521880f, -0.03729064f, 0.03564222f, -0.05181462f, -0.01877566f, 
    -0.01063873f, -0.04319471f, -0.06577948f, 0.09657552f, 0.27101430f, -0.05579978f, 0.03108861f, 0.25608227f, 
    -0.09020278f, 0.02279406f, 0.02078878f, -0.02397990f, -0.00757693f, 0.04863125f, 0.01882890f, 0.08051694f, 
    0.36287028f, -0.08051986f, -0.07527150f, -0.01541357f, -0.00366221f, 0.04003928f, 0.01909864f, 0.05933641f, 
    0.05290389f, -0.18095735f, 0.04768075f, -0.00840925f, 0.08242667f, -0.22373651f, 0.10029201f, 0.20474012f, 
    0.00588208f, -0.02299554f, -0.06406281f, -0.00054685f, 0.08263739f, 0.09256440f, -0.06243717f, -0.00280994f, 
    -0.06962510f, -0.03593433f, -0.14159860f, -0.10324986f, -0.01573936f, -0.01144322f, 0.00044641f, -0.02165710f, 
    0.07214624f, 0.07783015f, -0.13713206f, 0.03929285f, -0.05406301f, 0.06079880f, 0.09793661f, 0.03215060f, 
    -0.00140587f, 0.01040788f, 0.01918316f, 0.04183258f, 0.03657304f, 0.05028367f, 0.03135958f, 0.02043555f, 
    -0.10307880f, -0.08443660f, 0.12405975f, 0.19365980f, 0.10671968f, -0.09362249f, -0.02282693f, -0.02450622f, 
    -0.02537071f, 0.05191480f, 0.02912495f, 0.10548338f, -0.27665341f, 0.14214025f, 0.23183621f, -0.01995270f, 
    -0.00182694f, 0.14621072f, -0.06113798f, 0.04284408f, 0.05397103f, 0.05402722f, 0.02178886f, 0.06397579f, 
    0.15418348f, -0.08497073f, -0.13053294f, 0.01645811f, 0.01339120f, 0.10524738f, -0.01320567f, 0.01316281f, 
    -0.05510030f, 0.01819330f, 0.09459504f, -0.00666736f, 0.10174524f, -0.20599036f, 0.27085638f, 0.18337238f, 
    0.03313506f, -0.03201874f, 0.06584144f, 0.00241704f, 0.04860874f, 0.05269580f, 0.02810312f, 0.06471701f, 
    0.03060172f, -0.02184450f, 0.02372014f, 0.11717457f, 0.02456192f, 0.12418216f, 0.02997720f, -0.07640785f, 
    0.00343525f, 0.00361602f, -0.07073411f, 0.04043577f, -0.00421833f, -0.13144730f, -0.10998417f, -0.21862002f, 
    0.06131104f, 0.00486588f, -0.03814483f, 0.03788523f, 0.05643904f, -0.11715046f, 0.00558327f, -0.01195303f, 
    0.32580659f, 0.14139435f, -0.12107547f, 0.10833370f, 0.01404436f, -0.03651765f, 0.10138510f, -0.01140928f, 
    0.00349120f, -0.07444444f, 0.05344533f, 0.09777412f, 0.30547270f, 0.20151378f, -0.01422376f, -0.01342531f, 
    0.11498632f, 0.09312020f, -0.04652912f, 0.12055518f, 0.00644976f, 0.13505660f, 0.05566111f, 0.04046367f, 
    -0.16679759f, -0.16786605f, 0.01350450f, 0.13406086f, 0.02183781f, 0.02795006f, 0.00369939f, 0.10269435f, 
    -0.02235194f, 0.01427639f, 0.05137769f, 0.00399373f, 0.11163566f, 0.13285683f, 0.09892237f, 0.04545527f, 
    -0.00547558f, -0.00796225f, 0.05838918f, -0.02669145f, 0.17694624f, 0.01351797f, -0.00381172f, 0.07002649f, 
    0.16740718f, -0.16159342f, 0.00425405f, 0.07398197f, 0.09764042f, -0.02565690f, 0.08895237f, 0.07806580f, 
    -0.00115450f, 0.11652140f, 0.03043002f, 0.03947373f, 0.19081622f, -0.02814546f, -0.05723191f, 0.04269239f, 
    0.00961563f, 0.05815400f, -0.00766053f, 0.09951828f, 0.08914509f, 0.04054204f, 0.02181618f, 0.07341842f, 
    0.32679906f, -0.03193656f, 0.12602723f, -0.22255903f, -0.05117657f, 0.01695674f, 0.05399029f, 0.04815060f, 
    0.07665321f, -0.00495576f, 0.07422785f, 0.03562573f, -0.03959275f, -0.02178330f, -0.00328638f, -0.01513050f, 
    0.03751001f, 0.13385150f, -0.05180578f, 0.12719616f, 0.08153844f, 0.00236602f, -0.01262086f, 0.03340688f, 
    0.16528386f, -0.14896557f, -0.01490085f, 0.20394671f, 0.04719395f, 0.02227501f, 0.05391439f, -0.00331199f, 
    0.03133644f, 0.07237735f, -0.04051906f, -0.01424287f, -0.26756084f, -0.31425086f, -0.23897013f, -0.22864448f, 
    -0.02186641f, 0.13121814f, 0.03328525f, -0.09175725f, -0.00413330f, -0.05722678f, -0.03233387f, -0.15791389f, 
    0.03875861f, -0.09501356f, 0.16492462f, -0.10826954f, -0.00352856f, 0.05982882f, -0.08686966f, -0.00402360f, 
    -0.05081078f, 0.11894602f, 0.03782149f, -0.09064992f, -0.37550759f, -0.32143223f, -0.05076961f, -0.26078656f, 
    -0.08338485f, 0.02156070f, 0.06862085f, -0.03341689f, -0.00342648f, -0.08372095f, 0.05236888f, 0.07585019f, 
    -0.07905552f, 0.03925516f, -0.04505887f, 0.06009810f, -0.09591652f, 0.09454124f, -0.00729392f, 0.02722898f, 
    0.01447238f, 0.04126209f, -0.05809181f, -0.04226420f, -0.16133121f, -0.27884847f, 0.03950403f, -0.11547903f, 
    -0.01956472f, -0.05649316f, -0.13142830f, 0.07562594f, 0.01472605f, 0.08311261f, -0.04092733f, 0.03967659f, 
    0.08896594f, -0.09642364f, 0.02420195f, 0.17698716f, 0.07642352f, 0.03164621f, -0.02354033f, 0.10609832f, 
    0.01238783f, 0.10344128f, -0.04247792f, -0.00108327f, 0.11675303f, 0.26266178f, 0.10428935f, -0.00043959f, 
    0.01818632f, -0.15362160f, 0.14034317f, 0.08362485f, 0.01920205f, -0.06088542f, -0.01849503f, -0.06945065f, 
    -0.26085466f, 0.10010220f, 0.07046060f, -0.05199919f, -0.08324283f, 0.08499997f, -0.09149645f, 0.10461315f, 
    -0.07268947f, 0.04228529f, 0.02287630f, -0.00900986f, -0.05559795f, 0.28440264f, 0.20659304f, -0.03686973f, 
    -0.03083166f, 0.03459587f, -0.04681966f, -0.09580787f, -0.11405686f, 0.02623889f, 0.02626956f, 0.04005939f, 
    0.29159665f, 0.09878834f, 0.06901170f, 0.21137641f, -0.03538280f, -0.03138499f, 0.04445315f, -0.01382011f, 
    0.18843837f, 0.02805217f, 0.07065596f, -0.00280147f, 0.23571481f, 0.08699700f, 0.02130428f, 0.06854586f, 
    -0.03486429f, 0.13240038f, -0.02972865f, -0.08922411f, 0.11304878f, 0.04094877f, -0.01316888f, -0.03137876f, 
    -0.25224477f, -0.35537362f, -0.21301931f, -0.34054050f, 0.04491029f, 0.04392903f, 0.03196474f, -0.01247082f, 
    0.09096774f, -0.14108199f, -0.00665809f, 0.06218069f, 0.02644445f, -0.26083934f, -0.12507071f, 0.14774959f, 
    0.03425733f, -0.09256970f, -0.04687836f, 0.04666315f, -0.01430382f, 0.07343579f, -0.01574053f, -0.01525037f, 
    -0.05241580f, -0.01001187f, -0.01072855f, 0.07988120f, 0.03519997f, 0.09884009f, 0.04707187f, 0.01386344f, 
    -0.01257154f, -0.06633733f, 0.03539939f, -0.08584277f, -0.26284283f, -0.22287932f, -0.23457000f, -0.37017933f, 
    -0.00597897f, 0.01809941f, -0.02224237f, -0.00289141f, 0.05693530f, -0.02468427f, 0.02522850f, 0.10112485f, 
    0.16923970f, 0.07786659f, 0.19117187f, 0.05575907f, -0.04364593f, 0.06302729f, 0.03780373f, -0.08907561f, 
    -0.04477242f, 0.01290213f, 0.01140011f, 0.10279828f, 0.20091765f, 0.05354743f, 0.01547999f, 0.20999624f, 
    -0.04737941f, 0.00938375f, -0.08492326f, -0.11525187f, 0.06013939f, -0.01129449f, 0.02367613f, -0.05292140f, 
    -0.17431188f, 0.16375579f, 0.05756526f, -0.36249134f, 0.03172092f, 0.02428181f, -0.13256487f, 0.04258250f, 
    -0.06847093f, -0.01968343f, 0.00677390f, 0.02321906f, 0.13874109f, 0.30325973f, 0.17748736f, 0.18769704f, 
    -0.00689058f, -0.02630564f, -0.01218004f, -0.01314704f, 0.22028525f, 0.04885580f, -0.02322969f, 0.10216533f, 
    -0.20835119f, -0.07663437f, -0.07101663f, -0.14999628f, 0.03829522f, 0.06445144f, -0.03613745f, 0.06045639f, 
    -0.10148461f, 0.03251326f, 0.08114054f, 0.02301095f, 0.39861012f, -0.08364646f, -0.15788169f, 0.28941643f, 
    -0.09045845f, 0.07447862f, 0.11038173f, -0.11881860f, -0.01698693f, 0.00157486f, -0.02952522f, -0.07664938f, 
    -0.01781210f, -0.22856824f, -0.09158123f, 0.15153362f, 0.10600938f, 0.01831474f, -0.11803511f, 0.00328381f, 
    -0.01538516f, -0.05003399f, -0.00793261f, -0.01155392f, -0.24002424f, 0.21967982f, 0.12583041f, 0.06111791f, 
    -0.04834959f, 0.02167071f, -0.05559299f, 0.06969611f, -0.05106834f, 0.07462543f, 0.03247011f, 0.07172607f, 
    0.05813144f, 0.15254009f, -0.00834209f, 0.06345662f, -0.06819914f, 0.04529759f, 0.08685077f, -0.06131087f, 
    -0.06041816f, 0.01631519f, -0.00394540f, -0.13668719f, 0.21537443f, 0.08019127f, -0.02246862f, 0.03439116f, 
    0.01528933f, -0.05373509f, -0.07652006f, -0.04274524f, 0.10105878f, 0.05820651f, -0.02217121f, 0.08561202f, 
    0.28494298f, 0.14799608f, -0.08297911f, 0.16082886f, -0.11111386f, -0.03297305f, -0.04401163f, -0.05563584f, 
    0.01463913f, 0.01577707f, -0.09174672f, -0.22303857f, 0.17552339f, 0.08988044f, -0.03132502f, 0.09836382f, 
    -0.03484035f, 0.04985316f, 0.09643608f, -0.04508486f, -0.05884460f, 0.01274431f, 0.04889301f, 0.02100970f, 
    -0.35296270f, -0.09321528f, -0.26036555f, -0.28442559f, 0.10192479f, -0.04882624f, -0.07616795f, 0.13601416f, 
    -0.03053530f, -0.01420543f, 0.06487166f, 0.04510411f, 0.12306844f, -0.22243932f, -0.09127482f, -0.02881900f, 
    0.08434062f, -0.06983700f, -0.04584009f, 0.03173431f, 0.00751355f, -0.03358335f, 0.08842703f, 0.04140682f, 
    0.16576998f, 0.20151462f, 0.02053064f, 0.16469403f, 0.09511866f, -0.05914608f, 0.04311844f, -0.03532480f, 
    0.13177277f, 0.12053870f, 0.02785490f, -0.03210364f, -0.09710565f, -0.08318865f, 0.36725974f, 0.20041032f, 
    0.07644796f, 0.02379877f, 0.03102286f, 0.07966813f, -0.01040382f, -0.04756562f, -0.07129234f, 0.03648867f, 
    0.11349734f, 0.17956004f, 0.04863690f, 0.16811147f, 0.05870866f, -0.00989532f, 0.19801827f, 0.01240911f, 
    -0.08099863f, -0.08630924f, 0.04097511f, -0.07587898f, -0.06682682f, -0.13520500f, -0.09925902f, -0.20934063f, 
    0.04773954f, 0.07385316f, -0.05584427f, 0.05340105f, 0.07619242f, 0.06624006f, 0.04169582f, 0.09868860f, 
    -0.27683458f, -0.04773628f, -0.04508203f, -0.19247600f, -0.00090122f, 0.04780495f, 0.01632557f, 0.10439486f, 
    0.01321556f, 0.00886594f, 0.03201941f, 0.20242593f, 0.07632233f, -0.13239832f, -0.08581778f, -0.02479849f, 
    -0.00233027f, 0.13855192f, 0.04107469f, 0.03563854f, -0.04480662f, -0.01985147f, -0.00144026f, -0.07830217f, 
    0.19037759f, 0.03516245f, 0.10898358f, 0.04669970f, 0.02001015f, 0.07736683f, 0.06133917f, 0.02859762f, 
    0.00231811f, -0.01341148f, 0.09052633f, 0.03436265f, -0.13984674f, -0.25973919f, -0.04092944f, -0.09275193f, 
    0.10174641f, -0.06050718f, 0.00078530f, 0.03006370f, 0.12228281f, 0.07645120f, 0.05403432f, 0.04619980f, 
    -0.37093553f, -0.18687826f, -0.20662905f, -0.29793280f, 0.09578551f, 0.11226239f, 0.03391473f, -0.03298527f, 
    0.01208244f, -0.07340215f, -0.02111827f, 0.10899317f, 0.09984942f, 0.17867145f, 0.02856392f, 0.25999871f, 
    0.05509233f, 0.16490380f, -0.09290440f, 0.14222012f, -0.01688771f, 0.03033009f, -0.02496050f, -0.03141612f, 
    0.28602162f, 0.09040169f, 0.00477468f, 0.06622820f, -0.02634072f, -0.01071449f, 0.03869574f, 0.09640710f, 
    0.03688629f, -0.08214754f, 0.01905423f, -0.05240971f, 0.20648980f, 0.19328700f, 0.00063209f, 0.14761348f, 
    -0.02208007f, -0.02627801f, 0.07585222f, 0.09441273f, 0.01984630f, -0.04324041f, 0.04885403f, 0.05929961f, 
    0.10546071f, 0.17162563f, 0.00701232f, 0.14950931f, -0.06481465f, 0.02071657f, -0.01226550f, 0.09178055f, 
    0.00142458f, -0.00049002f, 0.05586469f, -0.18005835f, 0.17659923f, -0.00959078f, 0.14741656f, 0.06578782f, 
    -0.00998397f, -0.06484186f, 0.10414013f, -0.04196563f, -0.08995193f, 0.11503226f, 0.01204712f, 0.01804932f, 
    -0.07387315f, -0.00399435f, -0.06305400f, 0.02335721f, 0.10305654f, 0.00273632f, 0.11152498f, -0.02391097f, 
    0.00716752f, -0.05919129f, -0.01365744f, 0.02239792f, -0.18748295f, -0.46647581f, -0.23617516f, 0.01061174f, 
    0.00360257f, 0.05005371f, 0.04053848f, -0.02775085f, 0.02608262f, -0.06200846f, 0.01361186f, 0.04012883f, 
    -0.04909978f, 0.08945755f, -0.03488546f, -0.07119610f, 0.14944737f, -0.04064059f, -0.01127030f, 0.07800360f, 
    -0.03115290f, 0.10628693f, 0.03584220f, 0.01574562f, 0.40434605f, 0.34357846f, -0.23547105f, 0.12167979f, 
    0.14635970f, -0.02114219f, 0.11462534f, 0.03184075f, 0.03338733f, -0.04401380f, 0.10157987f, -0.01005063f, 
    0.13751380f, 0.15709324f, 0.10509259f, 0.17498326f, -0.02634458f, -0.05447116f, 0.00582903f, 0.02322887f, 
    0.01209730f, 0.02603237f, 0.10008655f, 0.01657290f, -0.23960908f, -0.08162554f, -0.17543207f, -0.13314179f, 
    -0.03733990f, 0.14927952f, 0.06142925f, -0.01345642f, 0.00414466f, -0.04537578f, 0.03331521f, 0.01011257f, 
    -0.07334940f, 0.08520677f, -0.00041279f, -0.17411838f, -0.05950588f, 0.04452646f, -0.02571394f, 0.06121092f, 
    0.01143467f, 0.07063313f, 0.02209178f, -0.03406865f, 0.04271965f, -0.30315775f, -0.05454276f, 0.05934503f, 
    0.13067098f, 0.04010838f, 0.08373059f, -0.00365141f, 0.02281122f, -0.08569278f, 0.01101534f, 0.12526610f, 
    0.20666550f, 0.04130592f, -0.12265074f, 0.16049476f, 0.05880139f, -0.01668968f, 0.00479273f, 0.06313125f, 
    0.02324888f, -0.02314182f, 0.01360687f, -0.02132791f, -0.49487749f, -0.05458555f, 0.07761737f, -0.32790816f, 
    0.14471871f, 0.02061020f, 0.01784036f, 0.05821168f, 0.02739805f, 0.05429541f, -0.03459214f, -0.06368305f, 
    -0.26276141f, 0.06891682f, -0.08928427f, -0.08339272f, -0.04468273f, -0.13614029f, 0.00365278f, -0.05040402f, 
    -0.02533711f, -0.03041382f, -0.08791666f, 0.12350696f, 0.36430386f, 0.00793733f, -0.03461431f, 0.16285689f, 
    -0.08747996f, 0.07593539f, 0.08901042f, -0.00986312f, -0.01401117f, 0.01701382f, 0.00702176f, 0.00610298f, 
    -0.11007144f, -0.19727315f, -0.23320304f, 0.00035796f, 0.08928106f, -0.02766405f, -0.03328921f, -0.06397488f, 
    -0.13667428f, 0.07635109f, 0.05713444f, 0.08019449f, -0.02369921f, -0.11263857f, 0.02704804f, 0.13892367f, 
    0.02901447f, 0.11782276f, -0.11703607f, 0.01011723f, 0.04150419f, 0.07690748f, 0.01337416f, 0.03488294f, 
    0.19797339f, 0.34283480f, 0.06513005f, 0.06584157f, -0.05137260f, -0.01796429f, 0.03350939f, -0.06702349f, 
    0.10428502f, -0.01524831f, 0.08270740f, -0.00450701f, -0.22891888f, -0.06885019f, -0.21230958f, -0.09520736f, 
    -0.06113808f, 0.08403097f, 0.06956285f, 0.02668341f, 0.03199647f, -0.04099819f, 0.04436610f, -0.01163920f, 
    0.09859613f, 0.00996256f, 0.07151694f, -0.07901560f, 0.06380906f, -0.05132295f, -0.01399973f, 0.11402901f, 
    0.01845288f, 0.07642196f, 0.14833479f, -0.03589101f, 0.15426430f, -0.04371383f, 0.05663945f, 0.10198756f, 
    -0.07114951f, 0.01847808f, 0.01791956f, -0.06450878f, 0.06246901f, 0.06166770f, -0.01793271f, -0.06399452f, 
    0.05260409f, 0.05371851f, -0.02769710f, 0.30259717f, -0.00397239f, -0.06301356f, 0.00631911f, 0.01231936f, 
    0.00373382f, 0.07517014f, 0.08528857f, -0.01017680f, 0.46217287f, 0.31696412f, -0.03728403f, 0.11654953f, 
    0.06041970f, 0.09431798f, -0.05620845f, -0.05252430f, -0.02701381f, 0.03657300f, -0.06993605f, 0.08584573f, 
    -0.04287737f, -0.03196540f, -0.09172204f, 0.31064510f, 0.05186202f, -0.00360259f, -0.02863458f, -0.08553381f, 
    -0.05007009f, -0.12131307f, -0.16915229f, 0.03041661f, 0.39346918f, 0.26762968f, -0.02723720f, -0.13819778f, 
    -0.01174137f, 0.09022576f, 0.05927320f, 0.02453239f, -0.00242166f, -0.00653271f, -0.09936205f, -0.04752067f, 
    -0.47954950f, 0.21908848f, -0.03434959f, 0.07017247f, 0.06354381f, -0.03997283f, -0.03900128f, -0.02641187f, 
    -0.00820810f, -0.02349060f, 0.05600336f, 0.03755125f, -0.20114151f, 0.12979038f, -0.02120571f, -0.13264686f, 
    0.05691856f, -0.00687964f, 0.14135197f, -0.01733617f, 0.00252824f, -0.04916312f, -0.16817585f, -0.04791953f, 
    -0.10825187f, 0.09195443f, -0.04014383f, 0.33607349f, 0.02071644f, -0.04661903f, 0.16024262f, 0.02440621f, 
    0.07864001f, 0.17833197f, 0.00472330f, -0.05274476f, 0.20552541f, 0.03348467f, 0.01187426f, 0.01396621f, 
    -0.10725974f, 0.04601380f, 0.05841649f, 0.12458887f, 0.05652538f, 0.02180229f, -0.07487728f, -0.12515359f, 
    0.26099181f, 0.02465882f, -0.01725369f, -0.01508437f, -0.00108247f, -0.05889541f, -0.15574412f, -0.00263215f, 
    -0.06919019f, -0.08777078f, 0.10025425f, -0.09013827f, -0.08315597f, 0.18729357f, 0.17660807f, -0.27281395f, 
    -0.04276909f, 0.06967999f, 0.03993532f, -0.00935586f, -0.03444040f, 0.19085963f, 0.11033877f, -0.13820061f, 
    0.20732003f, -0.07572859f, 0.06989975f, 0.08814109f, 0.05082414f, 0.12402851f, 0.03245446f, -0.02680459f, 
    0.00429383f, 0.04178786f, -0.18336955f, -0.07188807f, 0.08068822f, 0.14748052f, -0.11564118f, 0.00511143f, 
    -0.01035897f, -0.07226045f, 0.12643051f, -0.01457383f, 0.02754778f, -0.04646140f, -0.11868384f, -0.17424256f, 
    0.02296693f, 0.13630933f, -0.04785181f, 0.05204339f, -0.07501231f, -0.06178179f, -0.00215051f, 0.02111784f, 
    0.01186580f, 0.08875790f, 0.06723169f, 0.13634276f, -0.18671767f, 0.12223558f, -0.00318900f, -0.00242899f, 
    0.02141277f, -0.04613661f, 0.13511829f, 0.03944759f, 0.06039034f, 0.22065827f, 0.10719798f, 0.03303432f, 
    -0.01188508f, -0.00934162f, -0.00456340f, -0.14423771f, 0.14900437f, -0.12431273f, -0.00139380f, 0.05093843f, 
    0.01468788f, 0.07430082f, 0.07219143f, 0.17080548f, 0.06977843f, 0.01538542f, -0.03118023f, 0.10447953f, 
    0.01681297f, -0.06028318f, 0.02902998f, -0.08664344f, 0.04554481f, -0.10536418f, -0.19115730f, 0.03413869f, 
    0.20674339f, -0.15655303f, -0.17287447f, 0.09510478f, -0.04192702f, 0.14372581f, -0.13445781f, 0.12529449f, 
    0.03134716f, -0.00162993f, 0.11131173f, 0.04416733f, 0.00590109f, -0.04035693f, 0.00660016f, -0.22211461f, 
    0.04205914f, -0.02735554f, 0.12995206f, 0.03080664f, -0.04368490f, 0.04179969f, 0.09635805f, 0.26476860f, 
    -0.02066506f, 0.07621171f, -0.11376970f, 0.17176083f, -0.06053469f, -0.05408315f, 0.01032314f, -0.05897409f, 
    0.04929600f, 0.16650659f, 0.10045225f, -0.26491246f, 0.16007522f, 0.10219599f, -0.02665712f, 0.29271081f, 
    -0.14722770f, 0.11253498f, 0.00886208f, 0.01811604f, 0.10972696f, -0.03453007f, -0.01237798f, -0.18863928f, 
    -0.12346496f, -0.03913721f, 0.04673607f, -0.17331830f, -0.19258857f, 0.04895538f, 0.13241130f, 0.21263172f, 
    0.08132353f, 0.04085496f, 0.04602239f, -0.01446419f, -0.03875098f, -0.05831257f, -0.11243162f, 0.16406660f, 
    -0.11759408f, -0.02255347f, -0.08315264f, -0.12659580f, -0.02972063f, -0.08614533f, 0.04464692f, 0.04351063f, 
    0.03262230f, -0.22017527f, -0.02397579f, 0.08341159f, 0.05188200f, -0.11099957f, 0.03685432f, -0.07701379f, 
    0.10002247f, 0.03124208f, -0.03105110f, -0.06205218f, -0.05630925f, -0.09195054f, 0.03363986f, 0.15700039f, 
    0.04472722f, -0.04711312f, 0.07667325f, -0.00668577f, 0.08952498f, -0.10790673f, -0.12725429f, -0.04381235f, 
    0.08824529f, 0.16460827f, 0.17948925f, 0.19619258f, -0.00513256f, 0.08865168f, 0.14610165f, 0.10233917f, 
    -0.10430610f, -0.13150349f, 0.19338199f, -0.03539439f, 0.34031612f, 0.05588496f, 0.09987865f, 0.13292527f, 
    -0.03663003f, -0.10537781f, 0.01896582f, 0.10355795f, -0.07839013f, -0.03915491f, 0.10272408f, -0.06123761f, 
    0.37919691f, 0.07766082f, -0.22942324f, 0.22308198f, 0.02258583f, 0.07505602f, -0.05363025f, -0.08186943f, 
    -0.19127843f, 0.04912722f, -0.03470572f, 0.07423040f, 0.33592260f, 0.25617468f, -0.18351258f, 0.06081455f, 
    0.14480014f, 0.03526726f, -0.10851242f, -0.06259542f, 0.10457741f, -0.00820408f, -0.00889688f, 0.16992325f, 
    -0.30176878f, 0.02212379f, -0.04130638f, 0.04024867f, -0.10628820f, -0.01132548f, -0.19742581f, -0.00061965f, 
    -0.05326571f, -0.06524947f, 0.05951996f, 0.02667456f, -0.05200999f, -0.09448348f, 0.04923550f, -0.02268798f, 
    0.05606325f, 0.01842180f, -0.14925319f, 0.07404549f, 0.06337262f, -0.06233185f, 0.06284066f, 0.12606774f, 
    -0.11897808f, -0.09181573f, 0.08810500f, -0.20276999f, 0.01045829f, -0.04846680f, 0.11547051f, 0.04124736f, 
    -0.05849031f, -0.08313552f, -0.05660704f, -0.06660075f, 0.36015812f, 0.15239550f, -0.00222221f, -0.07997628f, 
    -0.04437400f, -0.01987254f, -0.00317531f, 0.00192891f, 0.00003386f, -0.08009318f, -0.06049258f, -0.08367087f, 
    -0.10827921f, -0.08427488f, 0.12317870f, -0.13331927f, -0.02335694f, 0.07070545f, 0.01456348f, 0.00444076f, 
    0.02398995f, 0.01675001f, 0.11357299f, 0.00610859f, 0.09102535f, 0.19950496f, 0.05524043f, -0.14009996f, 
    0.28512603f, 0.05777337f, 0.08751106f, -0.09652576f, -0.00654059f, -0.01711196f, 0.05447773f, 0.00104564f, 
    0.06812948f, -0.09980032f, 0.14581729f, -0.07284795f, -0.16531169f, -0.03444180f, 0.03535755f, 0.04697062f, 
    0.01337984f, -0.01199176f, 0.09359641f, -0.03770118f, 0.05659696f, 0.11473394f, 0.06131370f, -0.14065894f, 
    0.00211514f, 0.05817894f, -0.05986504f, 0.09772225f, 0.02961875f, 0.00228487f, 0.08545690f, -0.11647467f, 
    0.00636469f, 0.19737619f, 0.00291219f, -0.10408287f, 0.02914140f, 0.02051716f, 0.10909351f, -0.05295932f, 
    0.01553640f, -0.04308883f, 0.00882711f, -0.18806337f, -0.45083800f, 0.02264599f, -0.05288008f, 0.09118948f, 
    0.06275944f, 0.03757644f, 0.18835646f, 0.00014746f, 0.08926591f, -0.04789578f, 0.27216795f, 0.26894358f, 
    0.13582452f, 0.09591769f, -0.07319915f, -0.05765594f, -0.08704542f, 0.03409095f, -0.12649654f, -0.06226640f, 
    -0.01579843f, -0.08749048f, -0.04433738f, -0.14548208f, 0.26790500f, -0.03591043f, 0.07354730f, -0.21046087f, 
    0.04647700f, -0.03335391f, -0.02018531f, 0.11414885f, 0.08030761f, 0.14449067f, -0.01421599f, 0.02465352f, 
    -0.11512380f, -0.08648227f, -0.04657364f, -0.05454515f, 0.02136587f, 0.00656253f, 0.11561516f, 0.16927765f, 
    0.11905572f, 0.08046674f, 0.13286327f, -0.10566261f, 0.11542513f, -0.00977838f, 0.02759637f, 0.20956789f, 
    -0.14318398f, 0.05062155f, 0.12023272f, 0.11571825f, 0.14864720f, -0.01276416f, -0.05969958f, 0.16251558f, 
    -0.19522090f, -0.10454325f, 0.02789628f, -0.01675381f, -0.08349197f, 0.02387943f, 0.05301191f, 0.04548152f, 
    -0.02862220f, -0.10216221f, -0.04349894f, 0.09897704f, -0.29980356f, -0.07047144f, 0.05924089f, 0.09959391f, 
    0.08797001f, 0.19891602f, -0.05536138f, 0.05068657f, -0.03067457f, 0.04480302f, 0.02458464f, 0.05060336f, 
    -0.02307496f, 0.07949239f, 0.05850217f, 0.15952204f, -0.04700896f, 0.02904500f, -0.08819076f, 0.14372723f, 
    -0.01335619f, -0.16117473f, 0.01990397f, -0.05321787f, -0.05970524f, 0.07842106f, 0.11176161f, 0.21645167f, 
    0.02015086f, -0.07138322f, 0.14327170f, -0.15724912f, -0.08154240f, -0.12679936f, -0.10018272f, -0.14833082f, 
    -0.25661775f, 0.18558426f, 0.04458232f, -0.09711054f, 0.06914870f, -0.00594545f, 0.02143895f, -0.03197422f, 
    -0.01891145f, 0.05978958f, 0.08764212f, -0.12749410f, 0.20255211f, -0.09950576f, -0.03671876f, 0.00760681f, 
    0.05021537f, 0.05614403f, 0.00338796f, 0.03025101f, -0.03596353f, 0.02195227f, -0.10895829f, -0.02304346f, 
    0.12183345f, -0.03267950f, -0.06788594f, -0.26282942f, 0.06516740f, -0.02934637f, -0.13559382f, 0.04935535f, 
    -0.15975119f, -0.02351653f, -0.08365948f, 0.02349183f, 0.31585184f, 0.07894333f, 0.32421172f, 0.20756672f, 
    -0.12252492f, 0.14826699f, 0.09205234f, -0.03664070f, -0.01408789f, -0.07122532f, -0.02942537f, 0.23231536f, 
    -0.17860086f, -0.04202912f, 0.16049862f, 0.03957078f, 0.04117863f, 0.15029188f, 0.01820311f, 0.07845102f, 
    -0.09009674f, 0.08022507f, 0.22116089f, -0.14547044f, -0.11821469f, -0.07344741f, 0.02577071f, 0.06503262f, 
    0.10577404f, -0.00359863f, 0.01488227f, -0.00171052f, -0.08624125f, 0.03310347f, 0.09857395f, 0.07484505f, 
    0.25680864f, -0.01352218f, 0.09515639f, -0.15783672f, 0.01103345f, -0.01283084f, -0.11941637f, 0.01296649f, 
    0.06015432f, 0.00540924f, 0.09238502f, 0.08391998f, -0.05419750f, 0.08569323f, -0.02357237f, -0.09286397f, 
    0.17023170f, -0.05871082f, 0.07719379f, 0.00798863f, 0.02407460f, 0.03007456f, 0.30281585f, -0.03383379f, 
    -0.21861611f, -0.14694017f, 0.10209156f, 0.00193286f, 0.02687950f, 0.02038827f, -0.06183720f, -0.01893722f, 
    0.06791352f, -0.02789648f, -0.00574895f, -0.01046414f, -0.03694778f, 0.41319579f, -0.04635614f, -0.27963871f, 
    0.13207224f, 0.08529188f, 0.01217265f, 0.13426334f, 0.03608184f, 0.02459631f, 0.04164319f, -0.09301218f, 
    0.04629670f, 0.14854455f, -0.01160927f, -0.07805318f, 0.02677592f, -0.02356001f, 0.16858827f, 0.20080391f, 
    -0.04914030f, 0.12214947f, 0.24661353f, 0.04271273f, -0.23024681f, -0.13564685f, 0.14466490f, 0.02138008f, 
    0.06713486f, -0.00424481f, -0.04130246f, 0.02695220f, 0.09919813f, 0.01939941f, -0.01894282f, 0.06065123f, 
    0.08965091f, 0.25568259f, 0.05430823f, -0.02484339f, 0.08567864f, -0.05783047f, 0.01595276f, 0.04852007f, 
    -0.01554560f, 0.11899333f, -0.11882723f, 0.06829794f, -0.05736304f, -0.03828956f, -0.03109799f, 0.24448343f, 
    0.05120973f, 0.03453720f, 0.04164387f, -0.05313221f, 0.01750964f, -0.04518868f, -0.03476619f, -0.03235172f, 
    -0.05706410f, 0.05892173f, 0.15408033f, -0.06736214f, -0.02632891f, 0.02349351f, 0.05193880f, -0.17741144f, 
    0.01048766f, 0.17308629f, -0.05628656f, 0.06945924f, 0.08464654f, -0.01837639f, 0.02591474f, -0.11080859f, 
    0.22796622f, 0.19851112f, 0.04209402f, 0.15322134f, -0.00588592f, 0.13617159f, 0.20341791f, 0.14599916f, 
    0.02057980f, -0.28064418f, 0.01535262f, -0.25786796f, 0.03391308f, -0.02991466f, -0.07505754f, 0.08295838f, 
    -0.04624429f, -0.33043578f, -0.02953865f, -0.08667235f, -0.24369666f, -0.20490769f, -0.08344583f, 0.20117232f, 
    0.04882354f, 0.05748839f, 0.09163709f, -0.07169035f, 0.03967058f, -0.06557458f, -0.03549284f, 0.11144995f, 
    0.03752150f, 0.00185161f, -0.20046197f, 0.19577327f, 0.07487653f, -0.17984495f, -0.03436501f, 0.00763068f, 
    -0.04518150f, 0.17388427f, 0.00648094f, 0.08165739f, 0.17042178f, -0.02024798f, -0.02419464f, 0.20996346f, 
    -0.13683750f, -0.03987671f, -0.06807221f, -0.00938873f, 0.01017903f, 0.06675605f, 0.12851106f, -0.04908663f, 
    -0.03261369f, -0.02695187f, 0.01400901f, -0.00421557f, -0.04120577f, 0.00903997f, -0.01404107f, -0.02418132f, 
    0.03407282f, 0.01556845f, -0.00360116f, -0.03078652f, -0.01695292f, -0.00217388f, -0.03901822f, -0.01963121f, 
    0.02450734f, 0.03821572f, 0.04400390f, -0.02002562f, -0.00002785f, 0.03106139f, -0.03480313f, -0.02426649f, 
    -0.02646334f, 0.01235404f, -0.03912756f, 0.01287239f, 0.02666453f, -0.04006158f, 0.00848452f, 0.00953114f, 
    -0.02176066f, -0.03726029f, -0.00639304f, -0.02203034f, -0.02646150f, 0.01705800f, -0.00235247f, 0.01612718f, 
    -0.02790285f, 0.02519982f, -0.03555771f, -0.03950616f, -0.03649775f, -0.03583568f, 0.01799511f, 0.02954337f, 
    0.00999045f, 0.01777217f, 0.02102036f, -0.01557859f, -0.02398930f, 0.01589533f, 0.01382692f, -0.02426353f, 
    -0.01686063f, 0.00929433f, -0.02031432f, 0.01835343f, 0.01465362f, -0.00326839f, -0.01519902f, -0.02420853f, 
    -0.01239431f, -0.03981075f, 0.01940796f, -0.01535579f, -0.01830212f, -0.00846755f, -0.00540156f, -0.01430409f, 
    -0.00507216f, -0.02489976f, -0.03995905f, 0.00303835f, 0.01460215f, -0.00872108f, -0.00330469f, -0.02623373f, 
    0.00163362f, 0.01766547f, 0.00245015f, 0.00238129f, 0.02377249f, -0.04129849f, -0.00843460f, 0.00776542f, 
    0.00604864f, 0.02793586f, -0.00266064f, -0.00769164f, -0.02182483f, 0.01890166f, 0.01530412f, -0.03407986f, 
    0.01691290f, 0.01140886f, 0.00876339f, -0.01646704f, -0.03749048f, -0.02200859f, -0.01650308f, 0.01205960f, 
    0.00044785f, -0.02312254f, -0.00092598f, 0.01647368f, 0.00150302f, -0.00376791f, 0.01121605f, -0.04159262f, 
    -0.03866293f, -0.00575073f, -0.00419149f, -0.04173965f, -0.03921192f, 0.01727466f, -0.02441426f, -0.03680076f, 
    0.01754466f, 0.00347980f, -0.03106492f, 0.01543644f, -0.00589510f, -0.01540459f, 0.02614610f, 0.00802146f, 
    0.00466960f, -0.01892975f, -0.03022595f, -0.02526983f, 0.01156688f, 0.01916827f, -0.01677122f, -0.01774565f, 
    0.02381894f, -0.02456462f, 0.00975749f, 0.01582474f, -0.02739197f, -0.01569903f, 0.02465011f, 0.01129411f, 
    0.01702589f, -0.00659342f, -0.02698037f, -0.01416317f, 0.00394367f, 0.02672725f, -0.02042940f, -0.01228464f, 
    -0.01463549f, -0.04364737f, -0.00941763f, 0.00065229f, 0.02645032f, -0.01373017f, 0.01012649f, -0.00066883f, 
    -0.02324869f, 0.01219733f, 0.02061437f, 0.02331056f, 0.02068977f, 0.01673455f, -0.04036364f, 0.00222097f, 
    0.00454532f, -0.02941818f, 0.01223945f, -0.00723104f, -0.03868137f, 0.00407992f, -0.01937374f, -0.00121309f, 
    -0.00670256f, -0.03245546f, 0.00877735f, -0.00286217f, -0.02993620f, -0.01100432f, -0.01351087f, 0.00206355f, 
    -0.00918518f, -0.01663587f, -0.02791552f, -0.04202938f, -0.00804680f, -0.01477557f, 0.00099352f, -0.00836493f, 
    0.01139069f, 0.02444946f, 0.01342341f, 0.02946856f, -0.03847948f, -0.01649581f, 0.00517280f, 0.01892792f, 
    -0.03074323f, -0.02809508f, -0.02250266f, 0.01887323f, 0.02320476f, -0.03201572f, 0.00202680f, 0.02584999f, 
    -0.01857853f, -0.00399708f, 0.00018536f, 0.02206095f, -0.03498240f, 0.01332252f, -0.03224056f, 0.01488116f, 
    0.00221025f, -0.01679989f, 0.02352203f, -0.00713636f, 0.02531496f, -0.02504136f, 0.02451902f, -0.01398674f, 
    -0.00721940f, -0.03547341f, 0.02349805f, -0.00798156f, 0.01387973f, 0.01848476f, 0.00882584f, 0.01793543f, 
    0.02148434f, -0.03521705f, 0.01381090f, -0.00004865f, -0.02154194f, -0.00570327f, -0.00884474f, -0.04206093f, 
    0.01501289f, -0.00123402f, -0.00322135f, 0.03648410f, -0.03663485f, 0.01746815f, -0.02517112f, 0.00131298f, 
    0.02156392f, 0.00695079f, 0.02251498f, -0.01101102f, -0.02221388f, -0.00288496f, -0.00526095f, 0.00063615f, 
    -0.04238037f, -0.04348797f, -0.00284086f, 0.03297623f, -0.02076578f, 0.00996078f, 0.02671447f, -0.02357859f, 
    -0.00484022f, 0.00425155f, -0.02874450f, -0.03427541f, 0.00531505f, -0.00267473f, 0.02889769f, -0.01101845f, 
    0.01464930f, -0.03936704f, -0.01073939f, -0.01874078f, -0.00987973f, -0.00941272f, 0.02372167f, -0.01970387f, 
    -0.03615195f, -0.02440199f, -0.03636289f, 0.01482468f, 0.01774463f, 0.01735275f, -0.00758665f, -0.02436527f, 
    -0.00858226f, 0.02004568f, -0.01654394f, -0.00819368f, -0.04040800f, 0.00883624f, -0.03170494f, 0.01751924f, 
    -0.01404122f, 0.01659327f, 0.01225427f, -0.04097028f, -0.00705973f, -0.03446706f, 0.01235361f, 0.00534998f, 
    -0.00855619f, -0.00309129f, 0.02454691f, 0.01831150f, -0.03891378f, 0.02197791f, 0.01345861f, -0.00770907f, 
    -0.00449447f, -0.02076664f, -0.00546924f, -0.00576654f, -0.01180860f, -0.00294420f, -0.03089901f, 0.00841630f, 
    -0.03626063f, -0.03108683f, 0.00151101f, -0.04290654f, 0.02225040f, 0.01316554f, -0.02990178f, -0.00311402f, 
    0.01482415f, -0.00016767f, 0.00575471f, -0.02610055f, -0.00601526f, -0.03558739f, -0.03064544f, -0.03150124f, 
    -0.02628393f, -0.01975229f, 0.02521676f, -0.02553251f, -0.03573707f, -0.01340967f, -0.03104925f, -0.04209511f, 
    -0.02443779f, 0.01484348f, 0.01621610f, -0.01114724f, 0.01816583f, 0.00285277f, 0.01740219f, -0.00181622f, 
    -0.00545107f, -0.00858852f, 0.02846473f, -0.03263594f, 0.02409215f, -0.03757685f, 0.01865838f, -0.01784042f, 
    -0.03118114f, 0.01833425f, -0.02308442f, -0.01463147f, -0.03107337f, -0.00918792f, -0.03076254f, -0.02934384f, 
    0.02607529f, -0.01221689f, 0.00520448f, -0.03703288f, 0.01195821f, 0.01208962f, -0.00923791f, -0.01178685f, 
    -0.02060465f, -0.00128121f, 0.00452602f, -0.04253752f, 0.01131505f, -0.02811966f, 0.01536913f, -0.02611516f, 
    -0.03782502f, -0.02840580f, -0.02554701f, -0.03308716f, -0.01960996f, 0.01903925f, 0.00226989f, -0.02405263f, 
    -0.00303753f, 0.01295170f, -0.00767114f, -0.01018304f, 0.01899422f, -0.02228371f, -0.00208859f, -0.00922473f, 
    -0.02205143f, 0.03075164f, -0.01476431f, -0.04267740f, -0.04001983f, 0.01790305f, 0.00746793f, 0.00539610f, 
    0.00092153f, 0.02075861f, -0.02214693f, 0.00408947f, -0.01159151f, 0.00719965f, 0.02323375f, 0.01867461f, 
    0.00779211f, -0.00187085f, 0.00795335f, -0.02536162f, -0.02081601f, -0.02334632f, -0.02280247f, -0.02985516f, 
    -0.00268465f, 0.01532478f, -0.01033813f, -0.02632265f, -0.01241321f, -0.00663339f, -0.01704556f, 0.01086876f, 
    -0.00642436f, -0.01504861f, -0.04012401f, -0.04256132f, 0.01315537f, 0.02303983f, -0.01265607f, 0.02228616f, 
    0.00565576f, 0.02712637f, -0.03835278f, -0.02689786f, -0.02743162f, -0.01580540f, 0.02498626f, -0.01042075f, 
    -0.03853454f, -0.03313571f, 0.00402823f, 0.01518599f, 0.00245632f, -0.03889277f, 0.00687459f, 0.00943582f, 
    -0.01974875f, -0.00288477f, 0.02550858f, 0.01644213f, 0.02005622f, -0.02085964f, 0.02668353f, 0.01557725f, 
    0.01727385f, 0.02581836f, 0.00860719f, 0.00770750f, -0.03641502f, 0.00729084f, -0.01018023f, -0.04127427f, 
    0.02687744f, 0.00222970f, 0.01584525f, 0.01163586f, 0.01584803f, -0.01005537f, -0.02158022f, 0.00338061f, 
    0.00787539f, 0.02635337f, 0.02098992f, -0.00787326f, -0.02045058f, -0.01522017f, 0.02170417f, 0.00957964f, 
    -0.02838402f, -0.01483891f, 0.01893517f, 0.00135117f, 0.00484343f, -0.04389203f, 0.00458228f, 0.00357791f, 
    -0.01379781f, 0.00652340f, -0.03447863f, -0.00231068f, 0.00338872f, -0.01914034f, -0.01536844f, 0.01921203f, 
    -0.00283343f, 0.01729039f, -0.00520519f, -0.02512038f, -0.03779158f, -0.02310044f, 0.01614745f, 0.01949004f, 
    -0.00246435f, 0.00388353f, -0.01073838f, -0.02326437f, 0.01291314f, -0.01618844f, -0.01315463f, 0.02561453f, 
    0.02569620f, -0.02331707f, -0.00013070f, -0.03591236f, 0.02044512f, 0.00554916f, -0.02723220f, -0.02997963f, 
    0.00828491f, 0.02476399f, -0.02027769f, 0.00735558f, -0.03677229f, -0.01642350f, 0.00031635f, -0.00556404f, 
    -0.01444752f, 0.02641217f, 0.02558109f, -0.01651833f, 0.00094112f, 0.03258699f, 0.02433787f, -0.00512609f, 
    -0.00817678f, 0.01096244f, 0.01041462f, 0.02199347f, 0.00093041f, -0.00740375f, -0.02667658f, -0.00309303f, 
    0.00103514f, 0.01756980f, 0.02895449f, -0.02717685f, 0.00735418f, -0.02341749f, -0.00036892f, 0.01094238f, 
    0.00499423f, 0.01763639f, 0.00082226f, -0.02851316f, -0.00660875f, 0.00480190f, 0.02429871f, -0.01123830f, 
    -0.03551763f, -0.00086070f, -0.00260115f, -0.00389881f, -0.02399664f, 0.01511787f, -0.00812753f, -0.00335390f, 
    0.00322598f, -0.00680215f, -0.00786446f, -0.03038582f, -0.00793319f, 0.01209223f, -0.00080204f, -0.01797563f, 
    0.02651725f, 0.02963320f, -0.01270928f, -0.04310490f, -0.02972504f, -0.02482995f, 0.01920529f, 0.02652931f, 
    -0.03171946f, -0.04246558f, 0.01195655f, -0.02080487f, 0.00641886f, -0.03548954f, -0.01732721f, 0.02481626f, 
    -0.00616805f, -0.02281706f, 0.02744361f, 0.01052543f, -0.01715212f, 0.01740790f, -0.00439582f, -0.00616779f, 
    -0.04216302f, -0.00151386f, 0.01282757f, 0.03126111f, -0.01251217f, -0.00122659f, -0.00516704f, 0.02557300f, 
    -0.00024118f, -0.02415443f, -0.02544968f, 0.01182534f, -0.00343453f, 0.01364910f, 0.01161598f, 0.02440063f, 
    0.02952323f, -0.00513233f, 0.00687967f, -0.00578235f, -0.03365963f, 0.01108397f, 0.01656470f, 0.02410672f, 
    0.01991187f, 0.02712784f, 0.02242356f, 0.00310193f, 0.03159572f, -0.00637838f, -0.01108171f, 0.03335384f, 
    -0.00764890f, 0.01156749f, 0.02439836f, -0.01139675f, -0.02666116f, 0.02292235f, -0.00945863f, 0.01904938f, 
    -0.02387626f, 0.00251956f, -0.00120854f, -0.03179513f, 0.02054961f, 0.03038510f, 0.00002998f, -0.00643569f, 
    0.01554945f, -0.03556380f, 0.00814876f, -0.01699311f, -0.03819072f, 0.00950304f, -0.03637213f, 0.00348506f, 
    -0.02777418f, -0.02159380f, 0.02636816f, -0.02934229f, 0.01141051f, -0.02379908f, 0.00683812f, 0.01646305f, 
    0.02403886f, 0.02156938f, -0.00250577f, -0.01426871f, -0.00062415f, 0.01020195f, -0.00640661f, 0.02051726f, 
    -0.02836868f, -0.01192429f, 0.00920965f, 0.00389195f, 0.01552752f, -0.03360598f, -0.00046720f, 0.00144834f, 
    0.01655375f, 0.02533255f, -0.03721012f, -0.00073185f, -0.02674962f, -0.02225643f, 0.03222135f, -0.03431391f, 
    -0.00169628f, 0.01272112f, 0.01089408f, -0.03399805f, 0.01965565f, -0.02167003f, 0.02495305f, -0.01694560f, 
    -0.01571635f, -0.00810957f, -0.00338079f, 0.01526066f, -0.01943227f, -0.01123088f, 0.01394473f, 0.00517589f, 
    -0.00426365f, -0.02961004f, -0.02149837f, 0.00361756f, -0.02079066f, -0.01234183f, 0.02563855f, 0.00127242f, 
    -0.01452243f, 0.02419189f, 0.00237644f, -0.04368276f, -0.00792345f, -0.02534821f, 0.00565181f, -0.01287225f, 
    -0.01625545f, 0.00235462f, 0.00406389f, 0.01879998f, 0.01406730f, 0.01870731f, -0.02318149f, 0.00403359f, 
    -0.01413141f, -0.00974737f, 0.01468798f, -0.02423739f, -0.00615161f, 0.01662526f, 0.01305545f, -0.01206179f, 
    0.01605824f, 0.01771626f, -0.02050679f, 0.02964534f, -0.03848063f, -0.02990963f, -0.01353446f, -0.03995060f, 
    -0.00472246f, -0.03068532f, -0.03298583f, 0.00742191f, -0.02701592f, -0.01033863f, -0.02341674f, -0.01440080f, 
    -0.02161394f, -0.01465714f, -0.01736300f, 0.01948019f, 0.00611677f, -0.03242001f, -0.03172015f, 0.00872517f, 
    0.13660669f, 0.03065273f, -0.20601952f, 0.00849790f, 0.18227287f, 0.06046831f, -0.07196323f, -0.04347838f, 
    0.06193094f, 0.00659199f, 0.00246753f, 0.02695113f, 0.05440171f, 0.08013295f, -0.13890670f, -0.13477638f, 
    0.13654596f, -0.08464973f, -0.09769626f, -0.07343748f, -0.01139037f, 0.01049163f, -0.10181157f, 0.03813352f, 
    -0.14681236f, -0.10201844f, 0.13084270f, -0.15564732f, -0.03593737f, 0.01213450f, 0.06062805f, 0.07462332f, 
    0.02550637f, -0.15524335f, -0.03843298f, 0.04568667f, -0.16725308f, 0.00615414f, 0.20023729f, -0.15658590f, 
    -0.10953390f, 0.10868149f, -0.01367064f, 0.05830760f, -0.12629300f, -0.01974664f, -0.04579239f, -0.04895153f, 
    -0.23443681f, 0.07442320f, -0.05372436f, 0.28847674f, 0.09003128f, -0.02921692f, -0.00075334f, 0.00792469f, 
    0.10898820f, 0.00015132f, 0.00236761f, 0.00674670f, 0.06562118f, 0.01110807f, 0.04719701f, 0.03850900f, 
    0.04054215f, 0.01818284f, -0.09688564f, -0.10764622f, 0.11348737f, 0.06772128f, 0.01283534f, 0.02917423f, 
    -0.07498457f, -0.14224017f, 0.09876371f, 0.24771999f, 0.00005447f, -0.03749595f, 0.00121394f, -0.05633529f, 
    0.01359821f, -0.06440273f, 0.00905844f, 0.10998883f, 0.10358843f, 0.00668539f, 0.21371329f, -0.00887601f, 
    0.08385938f, -0.11291809f, 0.00458872f, -0.00083442f, -0.01868904f, -0.01604176f, 0.02456372f, 0.09673303f, 
    -0.01848351f, -0.11424462f, -0.19862203f, 0.19533849f, -0.07514613f, 0.02417560f, 0.02717144f, 0.04416671f, 
    -0.10115278f, -0.01977222f, 0.01354419f, 0.00644687f, -0.05837787f, -0.10468463f, 0.06765557f, -0.07012231f, 
    -0.03320942f, 0.04986428f, 0.00375239f, -0.02996535f, 0.03640468f, -0.09912340f, 0.06167715f, 0.00069764f, 
    -0.06302571f, -0.06221548f, -0.18627641f, -0.17561843f, -0.00922343f, -0.01421316f, 0.04139337f, 0.04822898f, 
    0.23163170f, 0.02540252f, 0.02405512f, -0.04248293f, 0.08505331f, -0.13251917f, -0.15758745f, -0.00842486f, 
    -0.04173553f, 0.06355585f, -0.06058513f, -0.13150562f, 0.10324918f, -0.03058055f, -0.03087420f, -0.02422945f, 
    0.10981369f, 0.04087043f, 0.05671431f, -0.19685148f, 0.12379746f, 0.10534332f, 0.08193347f, -0.01444999f, 
    0.04628149f, -0.12949784f, 0.04114348f, 0.08680671f, 0.09726223f, -0.00893186f, -0.19230118f, -0.12168964f, 
    0.05317834f, -0.02224621f, -0.01243677f, -0.01757598f, 0.15836102f, 0.04356495f, 0.18158664f, -0.05094039f, 
    -0.06157492f, 0.14893800f, 0.02380321f, 0.02372355f, -0.07128237f, 0.00365535f, 0.03260673f, 0.02002616f, 
    -0.07100579f, -0.04399035f, -0.00429476f, 0.00072808f, 0.21420062f, 0.02668715f, -0.10334238f, -0.13084170f, 
    0.06965641f, -0.00421159f, -0.04758848f, 0.05602648f, 0.02858494f, -0.02464547f, -0.00785335f, 0.06999845f, 
    -0.00130876f, 0.05987925f, 0.08830497f, -0.12148432f, 0.02896900f, 0.05982528f, -0.04092905f, 0.03673585f, 
    -0.10417394f, -0.04487355f, 0.05991159f, 0.12262222f, 0.08357824f, -0.05903059f, -0.03888796f, 0.04273975f, 
    0.09634627f, -0.05793725f, -0.00965306f, -0.05533885f, -0.01721378f, 0.01860294f, 0.04708882f, 0.04909610f, 
    0.05247448f, -0.15083440f, -0.07595454f, -0.09871214f, 0.02752537f, 0.00402381f, -0.14421511f, -0.01117609f, 
    -0.04314540f, -0.07817505f, 0.00660812f, 0.03479384f, -0.03619884f, 0.00059003f, -0.04420448f, -0.11134057f, 
    -0.10685926f, -0.02507387f, 0.09380647f, -0.14104690f, 0.12834050f, 0.03793539f, 0.03101984f, 0.03533178f, 
    0.31420767f, -0.04301913f, -0.15075958f, 0.13681166f, -0.04640029f, 0.00265627f, -0.06948305f, 0.04759904f, 
    -0.00321485f, 0.09767328f, 0.06931351f, 0.02478369f, 0.14907010f, 0.00432343f, -0.27180213f, 0.07256187f, 
    -0.04410732f, 0.04192173f, -0.01010833f, 0.01223464f, -0.06105192f, -0.05900759f, 0.05638686f, -0.18775593f, 
    -0.11822482f, 0.01376870f, -0.13563931f, 0.14021070f, 0.15920360f, -0.01639699f, -0.07388508f, -0.01965318f, 
    0.04960557f, -0.01588622f, -0.01613965f, -0.08791761f, 0.06862456f, -0.13462870f, -0.12086969f, 0.00231675f, 
    -0.08714063f, 0.09070210f, -0.10665227f, 0.01824293f, -0.08444346f, 0.01937026f, 0.09850444f, -0.04131513f, 
    -0.28956431f, -0.03900295f, 0.13138524f, -0.03632658f, -0.14467296f, -0.02309846f, 0.07105625f, -0.01725004f, 
    0.00980272f, -0.01368249f, -0.01723377f, 0.00267803f, 0.07725355f, -0.03925265f, -0.03993610f, 0.03836535f, 
    0.03543863f, -0.00540713f, -0.00118194f, -0.04851777f, 0.03551535f, 0.05159540f, 0.05370072f, -0.05492495f, 
    0.07243060f, -0.20204078f, -0.23161538f, -0.22588910f, -0.09414051f, -0.00583374f, 0.04706995f, 0.01171169f, 
    -0.07005444f, -0.00854567f, -0.03451354f, -0.11638075f, 0.10208909f, -0.12064819f, 0.16304895f, 0.04599272f, 
    0.03623542f, -0.03267992f, 0.02404217f, -0.10176737f, -0.11202617f, -0.03693281f, -0.06265546f, -0.06333514f, 
    0.07618560f, -0.12399701f, -0.17041452f, -0.00970335f, 0.05446612f, -0.02306861f, -0.08432559f, 0.01269749f, 
    -0.08960029f, 0.02521478f, -0.00931067f, 0.03230291f, 0.11338259f, -0.04377227f, 0.15168971f, -0.04095486f, 
    0.07618690f, 0.01771189f, -0.01059365f, -0.04845161f, 0.10883337f, 0.04813753f, 0.03894502f, -0.04532524f, 
    0.12816368f, -0.04605889f, 0.00571532f, -0.07287903f, 0.22077699f, -0.06013127f, 0.11618492f, -0.12146350f, 
    0.16727555f, 0.04128512f, -0.01779851f, -0.04003142f, 0.04569916f, -0.08882144f, -0.13626070f, -0.01010951f, 
    -0.03092794f, -0.03588160f, 0.07993607f, -0.01216333f, -0.04447015f, -0.06443485f, -0.00029010f, -0.03220605f, 
    0.15364762f, -0.05955290f, -0.01447414f, 0.12060822f, 0.06946370f, -0.02088321f, 0.04618383f, 0.02035821f, 
    -0.02905635f, -0.00154647f, 0.02293725f, -0.01391530f, -0.18512745f, 0.17296107f, 0.05745574f, 0.06620599f, 
    0.20174010f, 0.04393711f, -0.00752954f, 0.02504509f, 0.00328465f, 0.04330726f, 0.02992832f, 0.02647760f, 
    -0.05270484f, 0.15325427f, 0.08720316f, 0.08457475f, 0.00824780f, 0.02513969f, 0.01257153f, 0.04774874f, 
    0.00732055f, 0.00863572f, 0.06185979f, 0.01618837f, 0.01700860f, -0.01346434f, -0.08329520f, 0.18484221f, 
    -0.03505357f, 0.11886777f, 0.05368582f, 0.13228375f, 0.12446720f, 0.01300946f, 0.01153799f, 0.01673354f, 
    -0.00276991f, 0.05065190f, 0.14262562f, -0.15969557f, 0.00292266f, 0.01613603f, 0.07553723f, 0.08458728f, 
    -0.07743593f, 0.01452539f, 0.12606475f, 0.04704785f, 0.07051028f, 0.06672657f, 0.03224174f, 0.03995546f, 
    0.10436432f, 0.00199178f, -0.06113129f, 0.00734718f, 0.12848602f, 0.02699016f, -0.01886148f, 0.06740108f, 
    -0.08591976f, 0.08645930f, -0.14158528f, 0.09540080f, 0.12206548f, 0.07926572f, 0.03860164f, 0.04673240f, 
    0.08403801f, -0.08446218f, 0.03281106f, 0.08393729f, 0.28297591f, 0.07995909f, -0.02623588f, -0.20825736f, 
    -0.02250959f, 0.04993603f, -0.08453158f, 0.06896591f, 0.09332708f, -0.09143089f, 0.03231725f, -0.09439320f, 
    0.15533781f, -0.07673319f, 0.21415325f, 0.12126279f, -0.05179972f, 0.06325282f, -0.05236883f, -0.00344815f, 
    -0.14652716f, 0.07022668f, -0.02945276f, -0.01683240f, 0.22778213f, 0.19107790f, -0.08694742f, -0.09988923f, 
    -0.03675210f, 0.00889836f, 0.09352716f, 0.07603635f, -0.09337466f, -0.02949791f, 0.04690059f, 0.13433465f, 
    -0.02211610f, -0.05505688f, -0.03313482f, 0.14194708f, 0.02729254f, 0.00845642f, 0.05459471f, -0.03659384f, 
    0.01417960f, 0.02207082f, 0.08977071f, -0.05630749f, 0.08731979f, 0.13485366f, 0.03938105f, 0.23144227f, 
    0.07838663f, -0.00044803f, -0.00967024f, 0.03447701f, -0.02764211f, 0.09270553f, 0.12108214f, -0.16096249f, 
    0.22156478f, -0.10005442f, -0.01175087f, 0.07112910f, 0.00149675f, -0.08210185f, 0.06676439f, 0.12437881f, 
    0.02797639f, -0.04434422f, 0.04966872f, 0.09900640f, 0.03349955f, 0.00381969f, -0.08797088f, -0.24468781f, 
    0.01575701f, 0.11390067f, 0.00577196f, -0.07598846f, 0.05876214f, 0.00015587f, 0.06279454f, -0.06415939f, 
    -0.12641557f, 0.22882333f, 0.11102667f, -0.11102086f, 0.12255558f, -0.07577312f, 0.06816295f, 0.04326363f, 
    -0.07078330f, -0.01184363f, 0.04601226f, -0.07087038f, -0.40120563f, -0.25934237f, -0.06511681f, 0.06043550f, 
    0.07537393f, 0.05722262f, -0.05464796f, 0.10290000f, 0.12877147f, -0.02755672f, 0.08948302f, 0.01652349f, 
    -0.03213321f, -0.06854454f, 0.04961231f, 0.16612141f, -0.02695219f, 0.03362058f, -0.04098007f, -0.12519722f, 
    -0.09148325f, 0.05106460f, 0.02420865f, -0.07770686f, 0.15371154f, 0.07852519f, -0.15426137f, 0.11726788f, 
    0.09294289f, -0.08468868f, 0.12254946f, 0.07128590f, 0.05526555f, -0.00791234f, 0.04086270f, 0.08682703f, 
    0.23249030f, -0.11572840f, 0.10527755f, -0.02491779f, 0.00938327f, 0.09222821f, -0.04441944f, -0.01036736f, 
    0.10308141f, 0.04519198f, -0.03840045f, -0.03127985f, -0.33934656f, -0.09308048f, 0.08069719f, 0.22761147f, 
    0.04532425f, -0.02484724f, -0.00707626f, 0.04349495f, 0.09342878f, -0.01360044f, 0.00012552f, 0.11819099f, 
    0.33297020f, 0.17552604f, -0.05873488f, 0.00912420f, 0.17634656f, 0.06666941f, 0.06812529f, -0.01918471f, 
    0.00545720f, 0.04974231f, 0.01225148f, -0.00382424f, 0.05504798f, -0.08528113f, 0.14263828f, -0.34486124f, 
    0.20320426f, -0.06034282f, 0.02877349f, -0.06906862f, -0.07519412f, 0.03959535f, 0.09801556f, 0.01407658f, 
    -0.08034896f, 0.08549885f, 0.00156865f, -0.01868675f, 0.00201974f, -0.00187061f, -0.10102449f, -0.02504934f, 
    0.01814533f, 0.00298473f, 0.00375925f, 0.16925144f, 0.19536756f, 0.03799611f, 0.17540024f, 0.06711011f, 
    -0.03584433f, 0.04378761f, 0.10272048f, 0.00907174f, 0.00231944f, 0.07728894f, -0.04031201f, 0.01123958f, 
    0.03732419f, 0.15355475f, -0.09737068f, 0.04774265f, 0.14209628f, 0.02131242f, 0.04964112f, -0.06614432f, 
    0.00729707f, 0.02048163f, 0.10273205f, 0.02401494f, 0.21192963f, 0.18225974f, -0.15622112f, 0.20791562f, 
    -0.02042157f, 0.08570219f, -0.03596463f, 0.07049149f, 0.03583322f, 0.10073873f, 0.06482821f, 0.03070126f, 
    0.13653210f, 0.01468165f, 0.02286440f, -0.05421061f, 0.03909536f, 0.09522608f, -0.08924263f, -0.01341477f, 
    0.08249155f, -0.03879217f, 0.03557248f, 0.01700310f, -0.08676291f, -0.00190979f, -0.11488928f, 0.08512350f, 
    0.00498009f, -0.16343538f, -0.00149218f, -0.02693821f, 0.04858794f, 0.06146805f, 0.00999140f, 0.13826884f, 
    -0.14007856f, 0.09857491f, 0.22123009f, -0.22356899f, -0.05667327f, 0.00928456f, -0.00325068f, 0.00060199f, 
    0.02385173f, 0.01205201f, 0.02904311f, 0.00783426f, 0.12780739f, 0.04430495f, -0.26533961f, -0.01178692f, 
    0.07417899f, 0.01400593f, -0.03069931f, -0.07199460f, 0.05607992f, 0.06021775f, 0.05501939f, 0.06063713f, 
    -0.09911928f, 0.20778546f, -0.04287215f, -0.05228265f, -0.07008301f, 0.02235903f, 0.03774200f, -0.08337805f, 
    0.08995036f, -0.00653996f, -0.09024756f, 0.09371547f, 0.14225112f, 0.15227224f, -0.09014741f, -0.21600239f, 
    0.05718289f, 0.07684570f, -0.00481950f, 0.09661880f, 0.04622243f, 0.07134773f, -0.00361795f, 0.01015267f, 
    0.00026202f, -0.01009383f, 0.03674629f, -0.02409174f, -0.01288146f, 0.01027529f, 0.03502412f, -0.02321056f, 
    -0.00044708f, 0.00284838f, -0.02218393f, 0.01381022f, 0.01659005f, 0.02727346f, -0.03657086f, 0.02059809f, 
    -0.00651906f, -0.00913728f, 0.01679388f, -0.01772277f, 0.01683497f, -0.01707314f, 0.04014598f, -0.00401589f, 
    -0.01279691f, 0.02234545f, -0.00188810f, -0.00316976f, -0.02076923f, 0.00750829f, -0.02416604f, 0.00779251f, 
    0.02179332f, -0.03298888f, -0.01537575f, -0.01950085f, 0.00672744f, 0.01314130f, 0.00663430f, -0.03463332f, 
    -0.00176626f, -0.04404564f, -0.03529660f, -0.04233614f, 0.00561536f, 0.01525333f, -0.00757541f, -0.02717501f, 
    -0.00053604f, -0.01152300f, 0.02793162f, 0.00759250f, -0.00789848f, -0.04097227f, 0.02361560f, 0.00659699f, 
    0.01656202f, -0.00919482f, -0.00678867f, -0.04334955f, 0.01821596f, -0.03393326f, 0.02806189f, -0.02747814f, 
    -0.00479696f, 0.02437556f, 0.01405796f, -0.00045979f, 0.01239679f, -0.00374092f, -0.02266673f, 0.01351923f, 
    0.02707616f, -0.02552385f, -0.03266899f, -0.00355502f, 0.02356294f, 0.00963980f, 0.01093440f, -0.01275384f, 
    -0.00947779f, 0.01477537f, 0.00913114f, -0.03515456f, -0.01356884f, -0.04112903f, -0.03789026f, 0.00863733f, 
    0.01147032f, 0.02598832f, 0.01060401f, -0.02253302f, -0.03230700f, -0.04162650f, -0.02754998f, 0.02104028f, 
    0.01824475f, -0.01578878f, 0.00071347f, 0.00693529f, 0.00729308f, 0.01921934f, 0.01870834f, -0.02616170f, 
    0.00850444f, -0.01907908f, 0.01498142f, 0.02603885f, -0.02371988f, 0.02381228f, 0.02653071f, -0.01660012f, 
    -0.02812088f, 0.02061927f, -0.01149155f, -0.02532397f, -0.00627969f, -0.02427951f, -0.04070341f, 0.02284538f, 
    -0.02066201f, -0.01174674f, -0.01671104f, -0.00558231f, -0.00615752f, 0.02429501f, 0.01509001f, -0.00181447f, 
    0.01304516f, 0.02358107f, -0.00900406f, -0.03628768f, 0.02055455f, 0.01986002f, 0.01324466f, 0.01377781f, 
    0.02539447f, -0.04109787f, 0.02659540f, 0.02388581f, -0.03561244f, -0.01157107f, 0.02081455f, 0.02659863f, 
    0.00662016f, -0.01844959f, -0.02633975f, 0.02357982f, -0.01564082f, -0.03909707f, 0.02621037f, -0.02699774f, 
    0.01103215f, -0.00740673f, -0.01017941f, -0.03514126f, 0.02417561f, 0.01271325f, -0.01935299f, -0.01020137f, 
    -0.04385166f, -0.01642334f, 0.03334556f, 0.01274444f, 0.02734606f, -0.03817926f, 0.00373733f, -0.02809484f, 
    -0.02259389f, 0.00729406f, -0.03568479f, -0.02583575f, 0.03369409f, -0.00930786f, 0.00494143f, -0.00523069f, 
    0.00462686f, 0.00447073f, 0.01970451f, -0.02487701f, 0.02550406f, -0.04235283f, 0.01541624f, -0.00273332f, 
    -0.01135612f, -0.00546660f, 0.02455318f, -0.00694997f, -0.03390018f, -0.02717563f, -0.01611348f, -0.00451276f, 
    0.01771024f, 0.03892472f, -0.00202571f, -0.03529319f, 0.01282918f, 0.00077705f, -0.00077507f, 0.02045292f, 
    -0.01174201f, 0.00965415f, -0.01577133f, -0.00833402f, -0.03050736f, -0.03223507f, -0.00090812f, -0.02297836f, 
    -0.00253835f, -0.00359683f, 0.01579498f, -0.02225183f, -0.03647275f, 0.02355400f, -0.01467241f, -0.02811832f, 
    -0.03958048f, -0.03787954f, -0.03882094f, -0.02263790f, 0.02385099f, -0.00487213f, -0.02215313f, -0.04351177f, 
    -0.00585506f, 0.00164968f, 0.00144622f, 0.01979920f, -0.01664584f, -0.03434354f, -0.00039052f, -0.02678864f, 
    -0.03203578f, -0.03950058f, 0.00348873f, -0.02119770f, -0.00814934f, -0.03017728f, -0.01560282f, -0.00102739f, 
    -0.04026126f, -0.04040135f, -0.03142496f, -0.02358477f, -0.02098050f, 0.00060641f, 0.01360348f, -0.03816624f, 
    0.00529450f, 0.00345262f, -0.00874016f, -0.02043424f, -0.02997599f, 0.01241879f, -0.00787684f, -0.01458158f, 
    0.02474847f, -0.02377989f, 0.00276156f, 0.02380939f, -0.01467499f, -0.02752665f, 0.00842230f, -0.00500775f, 
    0.01780718f, 0.02425165f, -0.03410659f, -0.04384896f, 0.02730510f, -0.03266859f, 0.00628430f, -0.01339005f, 
    -0.00054094f, 0.00506834f, 0.02668276f, -0.02021092f, 0.01264247f, -0.03256639f, 0.01396947f, -0.01859674f, 
    -0.00018982f, -0.01550046f, 0.02911192f, -0.03135089f, -0.00048659f, -0.02619056f, -0.03536408f, 0.01005136f, 
    -0.00869148f, -0.02747677f, -0.01285072f, 0.02330812f, 0.02784868f, -0.01047520f, -0.00130635f, 0.00787311f, 
    -0.00371837f, 0.01348934f, -0.01877431f, 0.01097974f, 0.00929817f, 0.00337688f, -0.00540790f, -0.02098325f, 
    -0.02236679f, -0.00478556f, 0.00581580f, -0.01231428f, 0.00564014f, 0.01662366f, -0.03130900f, -0.02891337f, 
    -0.00781111f, 0.00666606f, -0.04404387f, -0.03912184f, -0.03034014f, -0.00408686f, -0.00767277f, 0.02813621f, 
    0.02342491f, -0.01705909f, -0.01775938f, -0.00094583f, 0.02707668f, -0.01199918f, -0.00964945f, -0.02603034f, 
    -0.01559736f, 0.01411924f, -0.00782663f, 0.01453730f, 0.02150698f, 0.00108091f, 0.03708131f, -0.03482340f, 
    0.00918376f, 0.00959221f, 0.01437688f, -0.01022078f, 0.00252211f, -0.02276580f, 0.02316115f, -0.00387722f, 
    0.00042936f, 0.02197573f, -0.01598827f, -0.00405017f, -0.01841139f, 0.01702681f, 0.01358992f, -0.03886731f, 
    -0.00644157f, -0.02820396f, 0.01724430f, -0.03059728f, 0.01025129f, 0.02869018f, -0.03173976f, 0.02559338f, 
    0.00230423f, -0.02266314f, -0.03025784f, -0.00948072f, -0.00401072f, 0.01582022f, 0.03327928f, -0.03570367f, 
    -0.00437518f, 0.02081419f, -0.02981531f, -0.00037655f, 0.00177152f, -0.01385732f, -0.00684497f, 0.03244506f, 
    -0.03710651f, -0.00942170f, -0.03267574f, -0.00583262f, -0.02948037f, 0.01024814f, -0.02303642f, 0.01247704f, 
    0.01456521f, -0.00821820f, -0.01876795f, -0.00604130f, 0.00811602f, -0.01780086f, -0.03567530f, -0.02131390f, 
    -0.00389655f, -0.02607796f, -0.02594114f, -0.01090621f, -0.03496262f, 0.01589532f, -0.03013567f, 0.02250379f, 
    0.01467241f, -0.00620972f, 0.01498831f, -0.01458624f, 0.01562390f, -0.00603750f, -0.00679399f, -0.00597640f, 
    0.01247408f, -0.02155697f, 0.02264219f, 0.01392121f, 0.00635125f, -0.03670797f, 0.02578108f, -0.03287274f, 
    -0.03246560f, 0.00397714f, -0.01484110f, 0.02122381f, -0.00480739f, -0.00468014f, -0.00710004f, -0.03076790f, 
    0.00432025f, -0.03400427f, -0.01743818f, 0.00278757f, 0.01506429f, 0.02093620f, 0.03638346f, -0.03411715f, 
    -0.03651286f, -0.02763182f, -0.02139517f, -0.03277415f, -0.01474763f, 0.02103739f, 0.02065588f, -0.02197241f, 
    0.00597997f, 0.02541436f, -0.02439490f, 0.01588934f, -0.01224485f, -0.04054983f, -0.00253567f, -0.03883170f, 
    0.01275836f, -0.01247411f, 0.00229953f, -0.00299046f, 0.00986394f, -0.02477471f, -0.02196576f, 0.02593922f, 
    -0.00053107f, -0.04015895f, -0.02802796f, 0.01638641f, -0.02164214f, 0.02468988f, -0.00418716f, 0.00088517f, 
    -0.00373804f, 0.00138468f, 0.00445406f, -0.02419570f, -0.02988795f, -0.01269877f, 0.02020246f, 0.00938002f, 
    -0.03290736f, 0.01260487f, 0.01090333f, 0.00768985f, 0.00975276f, 0.02705494f, -0.00867539f, 0.02437264f, 
    0.00988980f, -0.01446404f, 0.00099840f, -0.02402748f, -0.01581988f, -0.01101615f, 0.01176127f, 0.00116488f, 
    0.01187651f, 0.01889306f, 0.02047059f, 0.02906162f, 0.02674468f, -0.02962061f, -0.02978630f, 0.02459813f, 
    -0.02982819f, 0.00119696f, 0.00240295f, 0.02589391f, 0.00204599f, -0.02759532f, 0.02628967f, -0.00021419f, 
    0.02459034f, 0.02518944f, 0.01339058f, -0.02588931f, -0.03281115f, 0.01517897f, -0.01193079f, 0.00456417f, 
    -0.03188232f, 0.00716676f, -0.02441718f, -0.02782909f, 0.01398944f, -0.01437886f, 0.02753357f, 0.00823130f, 
    0.00341767f, 0.00672565f, 0.00846367f, 0.02689832f, -0.03907429f, -0.03294366f, -0.00040298f, -0.03097046f, 
    0.00587195f, -0.00577752f, -0.01964509f, -0.03945042f, -0.03201525f, 0.00726104f, 0.02284896f, -0.03278125f, 
    -0.02132419f, -0.03350542f, -0.03166125f, -0.01012906f, -0.01847695f, -0.00954898f, -0.00767673f, 0.01321551f, 
    -0.01267255f, 0.00983248f, -0.02598850f, -0.01624009f, 0.02451176f, -0.02284293f, 0.01992556f, 0.01830858f, 
    -0.03867631f, -0.01933848f, 0.03180891f, 0.02280084f, -0.01150481f, -0.00331242f, -0.03144378f, -0.00781003f, 
    0.01155943f, -0.03079428f, -0.02332100f, -0.02082505f, -0.00986819f, 0.01828941f, 0.03106145f, -0.02120462f, 
    0.01570979f, -0.02244052f, -0.03121188f, 0.02612423f, 0.04142516f, -0.00995738f, -0.03588127f, 0.00246034f, 
    -0.00843357f, -0.03791982f, -0.02431257f, -0.01798301f, -0.01294873f, 0.00215089f, -0.00106211f, 0.02141066f, 
    -0.02409460f, -0.00552083f, 0.00122736f, 0.01367122f, 0.00711803f, -0.02994420f, -0.03443763f, 0.01361729f, 
    0.02825412f, -0.03036007f, 0.02109539f, -0.00728340f, 0.01743300f, -0.01682718f, -0.00667549f, -0.00345383f, 
    -0.01922402f, 0.02420619f, 0.01759212f, -0.00662878f, 0.01213927f, -0.02441568f, 0.03358741f, -0.01245824f, 
    0.00495787f, 0.01248492f, -0.03699538f, 0.01011755f, -0.01057727f, -0.01736279f, -0.00299177f, 0.02555309f, 
    0.00496850f, 0.01495876f, -0.00144886f, 0.01406156f, 0.00815570f, -0.01580089f, 0.02101200f, 0.03699738f, 
    -0.01868296f, -0.00204143f, -0.03810344f, -0.03268635f, -0.04264034f, -0.03276814f, 0.02080848f, -0.01581851f, 
    0.01439293f, -0.03807628f, 0.00736317f, -0.03784867f, -0.02173583f, 0.01316321f, 0.00163037f, -0.02457083f, 
    0.02584859f, -0.00344485f, -0.02803366f, 0.00855385f, -0.03422935f, 0.00058377f, -0.02283608f, 0.00888220f, 
    -0.00810323f, 0.00393878f, 0.01784111f, 0.01730906f, 0.01190245f, -0.00959956f, -0.03586875f, -0.01218366f, 
    -0.03224805f, 0.01102515f, -0.03960615f, -0.01092482f, 0.00118930f, -0.04225603f, 0.00794630f, 0.00977961f, 
    -0.03486994f, 0.02370457f, -0.02143690f, -0.00437752f, -0.01355539f, -0.00703863f, -0.01910614f, -0.00720263f, 
    -0.01855579f, -0.03894459f, -0.02808734f, -0.01908133f, -0.00407903f, -0.03941812f, -0.04139064f, -0.00647084f, 
    0.02852925f, -0.00766309f, -0.03048718f, 0.01974597f, 0.00781390f, 0.01046088f, 0.00412816f, -0.02704711f, 
    -0.00186515f, 0.02023216f, -0.02380618f, 0.02904849f, 0.01387765f, -0.01798355f, 0.00637764f, 0.00032520f, 
    -0.03737174f, -0.00534421f, -0.03508639f, 0.01748641f, -0.02001812f, -0.00660845f, 0.01559627f, -0.03069775f, 
    -0.03705482f, 0.00230462f, 0.01855070f, 0.00798638f, 0.02204213f, 0.01941255f, 0.01575143f, -0.00983712f, 
    0.02573347f, -0.02299332f, -0.01502485f, 0.02858346f, -0.02319528f, 0.02148032f, -0.03436877f, -0.01784676f, 
    0.02396536f, -0.02625274f, -0.00455735f, 0.00387789f, -0.01298177f, 0.02733821f, 0.02472314f, -0.03904083f, 
    0.00788483f, -0.01870018f, 0.02300363f, -0.00277574f, -0.00913914f, -0.02670286f, -0.03722235f, 0.01462837f, 
    -0.01921170f, -0.01870026f, 0.00959340f, -0.02679475f, 0.01694641f, -0.03903937f, -0.03148838f, 0.02644297f, 
    -0.01129920f, -0.03136667f, -0.01701585f, -0.01330719f, -0.01010654f, 0.03593623f, -0.01609243f, -0.01176269f, 
    -0.03542376f, -0.02924234f, 0.01792351f, -0.00756014f, 0.02264263f, -0.03239924f, -0.00911534f, -0.01127568f, 
    -0.01838331f, -0.04385428f, -0.02263184f, -0.02332935f, 0.01209221f, -0.03233634f, -0.03356471f, -0.01788476f, 
    0.02038186f, 0.01730392f, -0.00065847f, 0.01483809f, 0.01027053f, -0.00548081f, 0.01027659f, 0.00170740f, 
    -0.01344810f, 0.02951635f, 0.02507254f, -0.03340632f, 0.00536106f, 0.00147332f, -0.03810599f, -0.02129055f, 
    -0.00904939f, -0.01224127f, 0.00385875f, -0.02265138f, -0.03545502f, -0.01974307f, 0.03277913f, 0.00566161f, 
    0.03521006f, 0.00214903f, -0.03797100f, -0.00048660f, 0.00601517f, -0.03989034f, -0.01528134f, 0.02517704f, 
    -0.00437964f, 0.00221345f, -0.01577466f, -0.03866275f, 0.02455050f, -0.03779910f, 0.01664429f, -0.00243638f, 
    -0.03139377f, -0.00725214f, 0.01424413f, -0.00423683f, -0.03814748f, 0.00543048f, 0.02356399f, -0.02250739f, 
    -0.02244312f, -0.02331385f, 0.02615184f, 0.02122537f, 0.02705717f, 0.00524476f, -0.02913605f, 0.02456771f, 
    0.02593865f, 0.00703313f, 0.03020793f, -0.01343462f, -0.03558322f, -0.00748954f, 0.02002385f, -0.00745274f, 
    -0.04237584f, 0.00608635f, 0.00601372f, -0.02117357f, -0.03823851f, -0.03868601f, 0.03344020f, -0.00219952f, 
    0.02485548f, -0.02068764f, -0.03440297f, 0.00434652f, -0.00485029f, -0.04440147f, -0.00667660f, -0.03092083f, 
    -0.03711117f, -0.00595323f, 0.02427177f, -0.00683451f, -0.01779721f, -0.04500949f, -0.03551889f, 0.02162790f, 
    -0.00066747f, -0.00184642f, 0.01584377f, -0.02499361f, 0.03403162f, -0.00655638f, -0.01030674f, 0.01048021f, 
    0.01188700f, 0.02822230f, -0.03741157f, -0.01748820f, -0.03739829f, -0.00822894f, 0.02443443f, -0.03216819f, 
    -0.00794832f, -0.00624138f, 0.00966101f, -0.01396007f, 0.00137197f, -0.03354750f, -0.00024203f, -0.01810375f, 
    -0.01147037f, 0.00999231f, 0.01954171f, -0.01904022f, -0.03684438f, -0.01575284f, -0.00391607f, -0.02019156f, 
    0.02224290f, -0.01159874f, -0.00102079f, -0.00171001f, 0.01536243f, -0.00452368f, 0.00550100f, -0.00790132f, 
    -0.03070393f, -0.00899854f, -0.00794494f, -0.02853676f, 0.02223437f, 0.02690988f, 0.01423818f, -0.00412680f, 
    -0.03311170f, 0.01718843f, 0.00542879f, -0.03429205f, -0.03028055f, -0.03265113f, -0.03025123f, -0.01659110f, 
    -0.02952169f, -0.03444923f, 0.02368678f, -0.02726696f, 0.01949816f, 0.02924898f, 0.01915795f, -0.02835063f, 
    0.01233756f, 0.01947578f, -0.01093869f, -0.00131814f, 0.01586012f, 0.01687115f, -0.04119031f, -0.00056572f, 
    0.00920813f, -0.01660616f, 0.03009964f, -0.03091764f, -0.01552821f, 0.00465558f, 0.00775743f, 0.01791709f, 
    -0.02973014f, 0.02791863f, -0.03517160f, 0.00156134f, -0.02166669f, -0.02407659f, -0.01634244f, -0.01579143f, 
    -0.01426586f, -0.00626938f, -0.03028244f, 0.01136198f, 0.00535790f, -0.00998560f, -0.03265467f, 0.00534121f, 
    0.03344732f, 0.02167322f, 0.01930087f, -0.01104266f, 0.00004183f, 0.00319423f, 0.03517276f, 0.01813516f, 
    -0.02962702f, -0.02741182f, 0.02769496f, -0.02185374f, 0.02932229f, -0.02998653f, 0.02812717f, -0.03549087f, 
    0.00865505f, 0.01644496f, -0.01302897f, 0.02471490f, 0.03059023f, 0.00857629f, 0.00749629f, 0.01996108f, 
    0.02335288f, -0.02659399f, -0.00030714f, -0.00355877f, -0.04304412f, 0.00929994f, 0.01649474f, -0.01197197f, 
    0.00038216f, -0.03464396f, -0.01400988f, 0.00079630f, -0.03499771f, -0.00429349f, 0.01773374f, -0.01712221f, 
    -0.00726358f, 0.01272877f, -0.03357884f, 0.02128672f, -0.01549713f, 0.01712636f, -0.02754346f, -0.00486046f, 
    -0.00007088f, -0.03004453f, 0.00429183f, -0.01349345f, -0.03230450f, -0.01718676f, -0.02320924f, -0.00135891f, 
    -0.03074300f, -0.00509957f, 0.02134185f, -0.03698420f, -0.04132395f, -0.03645752f, 0.01960496f, -0.04048017f, 
    -0.01835008f, -0.03374780f, -0.02967483f, 0.02489839f, 0.00735852f, -0.03014822f, -0.03265689f, -0.03665180f, 
    0.01242643f, -0.02734341f, 0.00602635f, -0.03104521f, 0.00403976f, -0.01237268f, 0.00385114f, -0.00756519f, 
    -0.03628464f, 0.00286746f, 0.01178243f, 0.01705258f, -0.01621534f, 0.02887273f, 0.02393050f, 0.01010501f, 
    0.02135079f, 0.01815538f, 0.02194372f, 0.01359174f, 0.03944458f, 0.01741519f, -0.02293821f, -0.01545191f, 
    0.01808732f, -0.02603976f, -0.02346497f, 0.00265126f, 0.01974694f, -0.00337138f, -0.01117230f, 0.02015268f, 
    -0.01117457f, -0.00694282f, 0.00938506f, -0.00807765f, -0.03361474f, -0.00680216f, -0.00724130f, 0.02150686f, 
    -0.02115136f, -0.01024578f, -0.00562692f, 0.00304974f, 0.00693242f, 0.01822877f, -0.02408227f, 0.01766063f, 
    0.01976872f, 0.01866169f, -0.03874427f, -0.03249248f, 0.01053510f, 0.00169167f, -0.00175575f, 0.01042191f, 
    -0.03225514f, -0.01857982f, 0.01341402f, -0.02682126f, 0.02581026f, 0.00386952f, -0.04541790f, -0.03346885f, 
    0.00783490f, 0.02446863f, 0.01029279f, 0.01532658f, 0.00218529f, -0.03427237f, -0.00472355f, 0.02716885f, 
    -0.00633252f, 0.01813207f, -0.01582276f, 0.00735141f, -0.02046789f, -0.00622715f, -0.00429378f, 0.02052074f, 
    -0.02488683f, -0.02796616f, -0.02203426f, -0.03515153f, -0.02622883f, -0.02425605f, 0.01249651f, -0.01788745f, 
    0.02447861f, -0.02993883f, -0.01758019f, -0.01496427f, -0.00851943f, -0.01043598f, -0.00177971f, -0.04026274f, 
    -0.02096762f, 0.01746897f, 0.01802742f, -0.04563565f, -0.00885035f, 0.00799221f, 0.00323465f, 0.00023507f, 
    -0.00972474f, -0.00957915f, 0.02399413f, -0.02971293f, 0.00026756f, -0.03390586f, 0.01123778f, 0.00220709f, 
    0.01826700f, -0.02416855f, 0.02100550f, -0.00007587f, 0.03015203f, -0.00961104f, 0.02807569f, -0.00352189f, 
    0.00727346f, -0.03962244f, 0.00447084f, -0.02807640f, 0.02339331f, 0.02282347f, -0.01233116f, -0.01514680f, 
    -0.03894512f, 0.03230838f, -0.01392000f, -0.00830676f, -0.00564460f, -0.03670117f, -0.02542660f, -0.02567222f, 
    0.00972258f, -0.00383540f, -0.01393372f, -0.02293076f, -0.01623327f, 0.03540796f, -0.00305093f, -0.03650271f, 
    -0.02082497f, 0.00910378f, -0.00482578f, -0.03624485f, 0.00164673f, -0.02951168f, 0.03104715f, -0.03225639f, 
    0.01694503f, 0.00950416f, 0.01453338f, -0.03091580f, -0.02955675f, 0.00293413f, -0.01145011f, -0.01145922f, 
    -0.03624625f, -0.03456074f, -0.02168133f, -0.03052320f, -0.01793399f, 0.00025197f, -0.04072077f, -0.02530325f, 
    -0.00675127f, 0.01406435f, 0.01156573f, -0.03323176f, 0.02720182f, 0.02954866f, -0.01474494f, -0.03050507f, 
    0.01926249f, -0.02710303f, -0.00910681f, 0.02708500f, -0.03309242f, -0.03634213f, 0.01026670f, -0.01319003f, 
    0.02353072f, -0.02248538f, -0.01686504f, 0.00060955f, -0.03312278f, -0.01533900f, 0.00228556f, -0.02999420f, 
    0.01845491f, -0.02256001f, -0.01684579f, -0.02605538f, 0.01341125f, 0.03341516f, 0.00000050f, -0.02191600f, 
    0.03016078f, 0.01615074f, -0.01050827f, 0.03287238f, -0.00064528f, 0.02029489f, -0.01928193f, 0.02014889f, 
    0.02430426f, -0.03043765f, -0.01171014f, 0.02794893f, 0.02797062f, 0.00922480f, 0.02660997f, 0.00661413f, 
    0.01872565f, 0.02207369f, 0.02601816f, -0.02590183f, 0.02595418f, -0.01466457f, -0.01832069f, -0.01629279f, 
    -0.01778203f, -0.01872556f, 0.01899307f, -0.02682728f, -0.00050945f, -0.03461646f, 0.02996344f, -0.02219020f, 
    0.00977781f, 0.01868691f, 0.01125875f, 0.00029573f, 0.01618868f, -0.01469841f, -0.00899421f, 0.02205717f, 
    0.02201196f, -0.03636854f, -0.02354509f, 0.02767125f, 0.00852349f, 0.01129500f, -0.03856469f, 0.01010307f, 
    -0.02803620f, 0.01139406f, 0.01757289f, -0.00178054f, 0.02278207f, 0.01188859f, 0.02146558f, -0.03468919f, 
    0.01889606f, -0.03267661f, -0.02379979f, -0.01861565f, -0.00127707f, -0.03650226f, 0.00199514f, -0.02399730f, 
    -0.01037597f, -0.02145955f, 0.01585924f, 0.03073596f, -0.03752165f, 0.00993347f, 0.00813227f, 0.01762493f, 
    0.00317457f, 0.00404670f, -0.02836035f, 0.01801440f, 0.00936638f, 0.01449115f, -0.03617388f, -0.00297107f, 
    -0.00148649f, -0.02720340f, -0.00568822f, -0.03433608f, -0.02188606f, 0.01837458f, -0.00010898f, 0.02544950f, 
    -0.02593148f, -0.02949178f, -0.00117668f, 0.03013072f, -0.02892376f, 0.01874281f, 0.02764531f, 0.03009625f, 
    -0.01446737f, -0.01571221f, -0.03642521f, -0.01483225f, 0.00490271f, -0.00846539f, -0.00637331f, 0.00122451f, 
    0.00661110f, -0.00122706f, -0.00999634f, 0.03535640f, -0.00826782f, 0.01644705f, -0.02604220f, 0.00785899f, 
    -0.02406215f, -0.00147693f, -0.01117410f, -0.02383145f, 0.01920649f, 0.01079837f, -0.00410466f, 0.02520095f, 
    0.01827380f, -0.03922996f, -0.00183648f, -0.00597339f, -0.00414884f, 0.02791448f, 0.01288470f, -0.02795150f, 
    0.02014234f, -0.00516879f, 0.00522494f, -0.00857106f, -0.00892515f, -0.02428558f, -0.03528122f, -0.00362634f, 
    0.02651662f, 0.00628761f, 0.00520199f, -0.04128548f, -0.00701985f, -0.01453640f, -0.02992474f, -0.01446806f, 
    0.00339721f, -0.02008716f, 0.02496392f, -0.03011185f, -0.03936418f, -0.03703665f, 0.00037322f, 0.00621064f, 
    0.02382880f, -0.03056889f, 0.03116709f, 0.00327895f, -0.03513531f, 0.02238148f, -0.02355209f, -0.00756844f, 
    0.02154067f, -0.00801555f, 0.02185173f, -0.02267606f, -0.03918121f, -0.00525017f, 0.01798304f, -0.03437613f, 
    0.00841049f, -0.03281378f, 0.02881604f, -0.03731315f, 0.01661229f, -0.00256874f, 0.01614407f, -0.02996822f, 
    -0.02271707f, -0.01480973f, -0.03526933f, 0.00529114f, 0.00325563f, 0.01507168f, -0.02617824f, -0.03477509f, 
    0.00243855f, -0.03859637f, 0.00499178f, -0.03451393f, -0.01775800f, -0.00758576f, -0.01459008f, 0.03186880f, 
    -0.01314019f, -0.00330189f, -0.00326590f, -0.00742540f, 0.00064219f, 0.00575995f, -0.02068764f, -0.00095684f, 
    -0.00853474f, -0.03489378f, 0.00432173f, -0.02281146f, -0.04649703f, -0.01469990f, 0.02389091f, -0.00879400f, 
    -0.02304091f, -0.03700240f, 0.00961640f, -0.02580242f, 0.02928895f, -0.03145978f, -0.01029723f, -0.00235218f, 
    -0.00743781f, -0.02093974f, 0.01134421f, 0.01372796f, 0.02172404f, -0.02164260f, 0.01444860f, 0.02822268f, 
    0.02529204f, -0.02417432f, 0.01879390f, -0.03788573f, -0.01600982f, 0.02440062f, 0.01591459f, 0.01265782f, 
    0.00782091f, -0.02882018f, -0.04190860f, -0.03129321f, 0.02098262f, 0.02332172f, 0.01026516f, 0.01660296f, 
    -0.02733219f, -0.02767692f, -0.00950633f, -0.00144245f, 0.01410139f, -0.00611986f, -0.03489563f, -0.01647372f, 
    -0.04059276f, -0.00574284f, -0.02439252f, 0.01388996f, -0.03092000f, 0.02096819f, -0.02252602f, -0.02822567f, 
    0.01861792f, 0.02331316f, -0.01523300f, 0.02549110f, -0.00645573f, 0.00104448f, -0.03677905f, 0.02247743f, 
    0.01437359f, -0.01585054f, -0.03616093f, 0.01688830f, 0.02721577f, -0.02002398f, -0.03574461f, -0.03423711f, 
    -0.02316444f, -0.03849119f, -0.01997174f, 0.02207696f, 0.01651087f, -0.00470139f, -0.01385342f, -0.00378802f, 
    0.02514041f, -0.03909422f, 0.03406044f, -0.02133161f, 0.02828517f, 0.02080743f, 0.00442430f, -0.00393303f, 
    0.00859266f, -0.01878115f, -0.03774417f, 0.02533185f, -0.04067040f, 0.00291472f, -0.04498674f, -0.01768734f, 
    -0.00732359f, 0.01786241f, -0.02491671f, 0.00010600f, -0.04025686f, 0.00330228f, 0.00025545f, 0.00954018f, 
    -0.03254902f, 0.01197705f, -0.00155547f, -0.00377997f, 0.00452480f, 0.02500445f, -0.02630035f, 0.02917399f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.06560035f, 0.00430663f, -0.00359245f, 0.05344111f, -0.01178925f, 0.03614636f, -0.00284017f, 0.02696596f, 
    -0.03979102f, -0.00296694f, -0.00330680f, -0.01400958f, 0.00244571f, -0.03329105f, 0.03233312f, 0.00322373f, 
    -0.03043874f, 0.01458969f, 0.01968081f, 0.02376102f, -0.02502327f, 0.02818444f, -0.02779083f, -0.02226502f, 
    0.08774045f, 0.03589725f, 0.08304988f, -0.05240677f, 0.01980397f, 0.08794751f, 0.00410982f, -0.02540574f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.29494706f, 0.02295515f, -0.50566572f, -0.13202861f, -0.02707591f, 0.34618700f, 0.15486141f, -0.05031871f, 
    0.09043002f, 0.05571045f, -0.15660487f, 0.27916095f, -0.15445332f, 0.15486492f, -0.12174349f, 0.26203859f, 
    -0.16828543f, -0.24859574f, 0.10949257f, 0.00160287f, 0.26126274f, 0.06071930f, -0.16235186f, -0.00676260f, 
    -0.12878588f, 0.17646971f, -0.59700698f, 0.07941535f, 0.12492495f, -0.54600382f, -0.02748684f, -0.13142100f, 
    0.16155681f, 0.02737177f, -0.20154917f, 0.20170210f, -0.01240794f, -0.28337061f, -0.01649053f, -0.00626694f, 
    0.06998113f, 0.13233149f, 0.04703800f, -0.31172496f, -0.10229190f, -0.14359091f, -0.08773793f, 0.26915556f, 
    0.09293997f, -0.17399809f, 0.11333907f, 0.16044794f, -0.26359373f, 0.15283017f, 0.06919908f, 0.13612865f, 
    0.32468995f, 0.23830822f, -0.13879633f, -0.46422616f, 0.16104102f, 0.00375824f, 0.15202586f, -0.14715777f, 
    0.27425352f, 0.03561589f, 0.27868131f, 0.07918131f, -0.02563701f, 0.28650695f, 0.09846780f, -0.12053722f, 
    0.17114487f, -0.09970222f, 0.10446636f, -0.61260027f, 0.00390356f, 0.02470405f, 0.22826366f, 0.22355987f, 
    -0.10571846f, -0.16617596f, 0.14641485f, 0.35955241f, -0.02548519f, 0.11963872f, -0.00507922f, 0.16543135f, 
    -0.24384175f, -0.33485448f, -0.33764535f, 0.27667007f, 0.11708834f, -0.01554803f, -0.07447287f, 0.07920853f, 
    -0.04840663f, -0.08246896f, 0.12063618f, 0.23137374f, 0.07650478f, 0.04931121f, -0.06553040f, -0.14234111f, 
    0.06331472f, -0.06036507f, 0.08363379f, -0.19864969f, -0.13610089f, -0.01458305f, -0.43037024f, -0.47857210f, 
    0.05798970f, 0.09384303f, 0.16680473f, -0.65436959f, 0.41597795f, -0.18156195f, 0.05728821f, -0.09138086f, 
    -0.11048342f, 0.15900706f, 0.30471680f, 0.01264913f, 0.12204605f, -0.40271398f, 0.08702824f, 0.04062445f, 
    -0.08091959f, -0.05301178f, 0.20292273f, 0.25146243f, 0.06216580f, 0.32933539f, -0.07950250f, 0.10298217f, 
    0.12366024f, -0.10932922f, -0.06898934f, 0.39237237f, -0.13519613f, -0.08790765f, 0.18639411f, -0.50774038f, 
    0.07820505f, 0.01474580f, -0.00179912f, -0.36748803f, -0.08285825f, 0.08968225f, -0.00109343f, 0.03871392f, 
    0.18777470f, -0.29109901f, -0.14166197f, 0.21589348f, 0.00197881f, -0.13080013f, -0.16551192f, -0.02776906f, 
    0.23689236f, 0.12452757f, -0.36246353f, 0.26233536f, -0.11465762f, -0.87358439f, 0.12351803f, -0.05125606f, 
    0.08424278f, 0.10714936f, -0.00385038f, 0.28641933f, 0.12829675f, 0.13391729f, 0.32213125f, -0.37625059f, 
    0.16313399f, 0.25045845f, -0.12789224f, 0.01602717f, -0.38821918f, 0.09611686f, 0.14880203f, 0.12756482f, 
    -0.20777272f, 0.25936213f, -0.32482070f, 0.12643397f, -0.12584859f, -0.30978727f, 0.14027210f, 0.06776400f, 
    -0.06155280f, -0.15968533f, 0.40200588f, -0.71699834f, -0.13887408f, -0.08837304f, -0.16946617f, 0.13085419f, 
    0.04767119f, -0.10893158f, -0.15325251f, -0.07682028f, -0.14023145f, -0.09679618f, -0.17992231f, -0.09344473f, 
    0.03933370f, 0.41818184f, -0.01035052f, -0.13455679f, -0.25225770f, 0.04050826f, -0.13251324f, 0.00320583f, 
    0.11849301f, 0.13918310f, -0.39334232f, 0.24088128f, 0.10706500f, 0.32470715f, -0.07598872f, 0.01438689f, 
    0.22016102f, -0.04475373f, 0.17166270f, -0.21713868f, -0.07437579f, -0.07890160f, -0.14288713f, 0.05975771f, 
    0.11021508f, 0.15189394f, -0.06159269f, 0.35607281f, 0.11688504f, 0.14688486f, -0.45442533f, 0.06427214f, 
    0.12496550f, 0.29018855f, 0.02935504f, 0.37423608f, 0.20400955f, -0.13164143f, 0.00551853f, 0.13926546f, 
    -0.55545199f, -0.34588930f, 0.11664742f, 0.08255450f, -0.11915492f, -0.02056738f, -0.09089235f, 0.05206624f, 
    -0.47469276f, 0.06802236f, -0.06309141f, 0.33342892f, -0.12974904f, 0.20197992f, -0.01907689f, -0.01859280f, 
    -0.04063375f, -0.01497915f, -0.05480101f, -0.04316716f, -0.07433491f, -0.11407293f, 0.19021069f, 0.14133774f, 
    0.15941371f, 0.28837335f, 0.14937891f, -0.22985499f, -0.21199833f, -0.05225685f, -0.07916870f, 0.05910813f, 
    -0.58448207f, 0.21620522f, -0.42066327f, -0.22917216f, 0.07061680f, 0.42999303f, 0.05778393f, 0.03778989f, 
    -0.32200444f, -0.03107584f, -0.16501550f, -0.56136000f, -0.11279237f, -0.28864884f, -0.01816715f, -0.11052681f, 
    -0.14402571f, -0.10922196f, -0.13434601f, 0.20902553f, -0.15792628f, 0.12897803f, 0.25287127f, -0.35873961f, 
    0.01808926f, -0.42393330f, -0.01396637f, 0.55686218f, 0.28237811f, -0.02888700f, -0.12909381f, -0.11424731f, 
    0.14432950f, 0.04743850f, -0.20996056f, 0.00655838f, 0.16713858f, 0.08173871f, 0.16623451f, 0.08862676f, 
    -0.43568844f, -0.03753369f, 0.03126443f, 0.19606389f, 0.13559243f, 0.30333591f, -0.05083697f, 0.04537072f, 
    -0.08773229f, 0.09608924f, -0.05908848f, -0.11180861f, 0.06300764f, 0.14421433f, 0.03532401f, 0.24492842f, 
    0.09778704f, 0.12009998f, -0.12379508f, -0.05229180f, -0.05292024f, -0.14214607f, -0.07138524f, 0.03911395f, 
    0.08829241f, -0.34859160f, 0.40381432f, -0.37594140f, -0.08641896f, 0.29048768f, 0.09202578f, -0.08159792f, 
    -0.12567438f, 0.00389031f, -0.31363881f, -0.03232741f, -0.15398212f, -0.26269591f, -0.03601864f, -0.13888292f, 
    0.12740114f, -0.12248832f, -0.08116910f, -0.08458042f, 0.01217002f, -0.00932314f, 0.14431086f, -0.04632959f, 
    0.16416611f, -0.50959539f, -0.00952982f, -0.43063876f, -0.03978901f, -0.17747395f, -0.10464429f, 0.01167504f, 
    -0.10413447f, 0.19399828f, 0.32561615f, 0.46366340f, 0.12233211f, 0.30883214f, -0.07444827f, -0.09965445f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.17492990f, 0.18621030f, 0.03102207f, 0.14380580f, -0.08312619f, -0.03803804f, -0.03346633f, -0.07635020f, 
    -0.18473983f, 0.09595812f, -0.07384858f, -0.00128414f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
