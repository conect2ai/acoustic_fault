#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.89134908f, -0.25909117f, -0.29150173f, -0.48184252f, -0.41064981f, -0.01304084f, -0.02773757f, -0.20278075f, 
    -0.09843222f, -0.22004290f, -0.16807707f, -0.15434232f, 0.15220916f, 0.19061518f, 0.24600144f, 0.33788958f, 
    -0.34828690f, -0.45376194f, -0.05082218f, 0.01788855f, 0.19432062f, 0.06579347f, 0.30255756f, -0.31279325f, 
    0.18876041f, -0.05400378f, -0.69271427f, -0.59258997f, -0.62778866f, -0.33795857f, -0.02970592f, 0.92751932f, 
    0.35931274f, -0.18078311f, 0.45156986f, 0.03832014f, 0.12236624f, -0.27628583f, -0.24331948f, -0.37191540f, 
    -0.08177595f, 0.01951075f, -0.15526132f, -0.00049140f, -0.05268011f, -0.09057216f, 0.17933710f, -0.23200250f, 
    0.21359101f, 0.27491844f, -1.11766815f, 0.73631525f, -0.44818667f, 0.14573459f, -0.93668234f, 0.58813316f, 
    0.34023252f, -0.32341552f, 0.55178803f, 0.17744444f, -0.25233713f, -0.12823199f, -0.04917606f, 0.16241068f, 
    0.43086708f, 0.36521104f, 0.26716936f, 0.14753038f, -0.05830687f, 0.13478772f, 0.22196019f, -0.16008553f, 
    -0.22600275f, -0.11786330f, 0.27959573f, -0.45252582f, 0.51338691f, -0.58159876f, 0.47520742f, -0.52926159f, 
    0.18495551f, -0.50049406f, -0.74059129f, -0.16339739f, -0.49085915f, -0.12293575f, -0.08362939f, -0.03835512f, 
    -0.24342762f, -0.09775098f, -0.55764151f, -0.17068259f, -0.07005811f, -0.20120385f, -0.20587988f, 0.11102986f, 
    0.15879314f, 0.15366623f, -0.18685612f, -0.17660306f, 0.93498385f, 0.69321227f, 0.40505853f, -0.10360546f, 
    -0.87852061f, -0.33773491f, -0.51021600f, 0.04211671f, 0.02829833f, 0.11323630f, 0.29326221f, -0.15691245f, 
    -0.33136186f, 0.11295161f, -0.11026355f, -0.03070433f, 0.01293449f, -0.12877974f, -0.32920793f, -0.06691103f, 
    -0.29270765f, 0.36169109f, -0.24665268f, -0.02039601f, -0.29234201f, -1.06246924f, -0.23132108f, -0.11684374f, 
    0.32663140f, -0.55333984f, 0.48960963f, 0.50697625f, -0.00695405f, 0.08516037f, 0.13146530f, -0.27526286f, 
    0.10255281f, -0.03803192f, 0.13994415f, -0.06309828f, -0.42299643f, -0.33003572f, -0.38891050f, -0.14192149f, 
    -0.36862990f, 0.34260032f, 0.28194475f, 0.28393945f, 0.15900639f, 0.08458453f, 0.80604559f, 0.18108122f, 
    0.26773831f, 0.26158455f, 0.86624676f, -0.16600506f, -0.38207087f, 0.23952679f, 0.07732674f, 0.33621415f, 
    0.06115361f, 0.46284035f, 0.03470666f, 0.10429311f, 0.11962099f, -0.16267391f, 0.08927678f, -0.18716866f, 
    0.24525765f, -0.38769215f, 0.14774935f, 0.12243637f, -0.16861801f, -0.25371987f, 0.07777921f, 0.00605721f, 
    -0.10589873f, 0.48011443f, -0.73032826f, -0.53161645f, 0.42700183f, -0.68663633f, -0.26980191f, 0.04414954f, 
    0.15079634f, -0.26108754f, -0.31715989f, 0.04776057f, 0.01786784f, 0.13632202f, -0.16163562f, 0.33048463f, 
    0.34386164f, 0.27244768f, 0.33195123f, 0.03490487f, 0.31905529f, -0.30817980f, -0.28548899f, -0.26679757f, 
    -0.69035488f, -1.04982388f, -0.36629045f, 0.35318041f, -0.01769259f, -0.26597902f, 0.19991247f, 0.59174830f, 
    -0.22703548f, -0.33304560f, 0.35771528f, 0.10650134f, 0.23647095f, 0.25056601f, 0.13438535f, -0.28299308f, 
    0.03674667f, 0.07757857f, -0.29130539f, -0.08800635f, -0.02262530f, -0.21612749f, 0.02117745f, -0.01931524f, 
    -0.01875328f, 0.91213220f, 0.19076720f, 0.32396474f, 0.45741174f, 0.11287352f, 0.35207462f, 0.36098751f, 
    -0.26785001f, 0.36306423f, 0.38027230f, -0.08820937f, 0.26932815f, -0.30041063f, 0.26860860f, 0.24704698f, 
    0.30265731f, -0.24224684f, 0.36017603f, 0.14165197f, -0.06102253f, -0.57671154f, -0.15346113f, -0.14602239f, 
    0.30299672f, 0.08133847f, -0.91736972f, -0.37509421f, 0.60918647f, -0.15773571f, -0.39861190f, -0.16493165f, 
    -0.13354185f, 0.53878152f, -0.12946489f, 0.05372640f, -0.11578745f, 0.06785203f, 0.26465696f, 0.33916479f, 
    -0.38535738f, -0.18456875f, 0.13666375f, 0.01871460f, 0.26388663f, -0.02739822f, 0.08250148f, -0.06909182f, 
    0.15151319f, 0.31660631f, -0.02211495f, 0.32106283f, 0.95645380f, 0.75679576f, 0.74975538f, 0.25345215f, 
    0.32376203f, -0.09111230f, -0.89293498f, -0.20378482f, -0.37120149f, 0.33241427f, 0.05242476f, -0.02593619f, 
    0.24194853f, -0.27041101f, 0.12230538f, 0.27612370f, -0.02358748f, -0.01260158f, -0.13294519f, 0.08451046f, 
    -0.02268649f, -0.14471529f, -0.10221762f, 0.08432593f, 0.27854550f, 1.22948623f, 0.70903844f, 0.03430690f, 
    -0.32068738f, -1.01567817f, 0.59510922f, -0.22206908f, -0.15038472f, -0.24333541f, -0.10272674f, -0.01030926f, 
    -0.07749585f, -0.04988164f, 0.20282407f, -0.12408880f, -0.25923544f, 0.23068914f, 0.10276112f, -0.25076836f, 
    0.01596406f, 0.04613545f, -0.14974517f, 0.08955590f, 0.24955451f, -0.11205153f, -0.69661283f, 0.13143508f, 
    0.62471598f, 0.61856729f, -0.83999902f, 0.51293129f, 0.39470920f, -0.62573469f, 0.28405622f, 0.40809095f, 
    0.17209840f, -0.07254846f, -0.00684703f, 0.04331931f, -0.21547730f, -0.04795816f, -0.14380698f, 0.12532796f, 
    0.07376333f, 0.20182668f, -0.09771073f, 0.11019485f, -0.09553406f, -0.05985152f, 0.18300596f, 0.82323182f, 
    -0.49719810f, -0.57028639f, -0.69484085f, 0.54131520f, -0.33186287f, -0.39081171f, -0.27887434f, -0.49237430f, 
    0.35481009f, 0.16623862f, 0.47490469f, 0.46806610f, -0.01590954f, -0.24826981f, -0.26180327f, 0.11120283f, 
    0.23047374f, 0.19457245f, 0.14549357f, 0.21791893f, 0.01978145f, 0.21437146f, -0.05943516f, 0.12680487f, 
    0.23325114f, 0.08508884f, -0.13131905f, -0.49005368f, 0.71174949f, 0.53563356f, 0.21395369f, 0.48999631f, 
    0.43486568f, -0.22397405f, -0.39291081f, 0.01360936f, -0.42129922f, 0.17650117f, -0.37634048f, -0.15419044f, 
    0.02795486f, 0.23365475f, -0.19209100f, 0.24262951f, 0.25474483f, 0.21623221f, 0.02985811f, 0.25749645f, 
    -0.45953757f, -0.58835840f, -0.76605296f, -0.14248617f, 0.20797010f, -0.59376824f, -0.09394293f, 0.67945850f, 
    0.30621231f, 0.38993192f, -0.12593777f, -0.23496984f, 0.31782678f, -0.40942702f, -0.32854193f, 0.11645580f, 
    -0.15622325f, 0.07973182f, -0.33251876f, -0.26098505f, -0.32551029f, -0.09488793f, -0.22012021f, -0.01332365f, 
    0.18022799f, -0.63896406f, -0.99024421f, -0.59993887f, -0.13260105f, -0.08832212f, 0.23757069f, 0.06047447f, 
    -0.01387458f, 0.09980766f, 0.27590188f, -0.20336123f, 0.15298153f, -0.24128439f, 0.53221035f, -0.13568439f, 
    -0.24854167f, 0.21200994f, 0.14166892f, 0.25118849f, 0.11391030f, 0.14166838f, -0.00565438f, -0.17968009f, 
    -0.05127357f, 0.11087919f, 0.62782007f, -1.62154126f, 0.58007914f, 0.28421357f, 0.32976541f, 0.30453590f, 
    0.49494573f, 0.45670545f, 0.02501420f, 0.09852338f, -0.07842796f, 0.15656143f, -0.26719260f, 0.32149467f, 
    -0.11102062f, -0.02445563f, -0.13506803f, 0.01131354f, 0.11503817f, -0.11827478f, 0.01701570f, 0.07457505f, 
    0.04262025f, -0.09553475f, 0.04602461f, 0.56785995f, 0.06717394f, 0.70799917f, -0.05260800f, 0.13868575f, 
    0.29316771f, -0.67917907f, -0.55175096f, 0.21779515f, -0.12984839f, 0.35927519f, -0.12115200f, 0.20241994f, 
    0.19829796f, 0.24863756f, -0.16194190f, -0.39485008f, -0.30755115f, 0.07436507f, -0.27898476f, 0.44249737f, 
    0.08553153f, 0.09782224f, 0.31109121f, 0.25197753f, 0.58049196f, 0.94329524f, 0.06666067f, 0.25551137f, 
    0.75454748f, -0.24889544f, 0.32458454f, 0.28507829f, 0.20563722f, -0.08652722f, -0.42477146f, 0.11855756f, 
    -0.27545792f, -0.39903581f, 0.01452105f, 0.17444621f, -0.13822280f, 0.27412388f, 0.05245725f, -0.08064487f, 
    0.58422005f, -0.10470090f, -0.19148068f, 0.19566755f, 0.42670909f, 0.16450924f, -0.73552436f, 0.21361956f, 
    1.05566180f, -0.29724407f, -0.74492586f, 0.16251791f, 0.48830804f, -0.67729127f, 0.24110052f, 0.32389361f, 
    0.29611003f, 0.00762356f, -0.21091588f, 0.26399803f, -0.06671850f, 0.03814424f, 0.39751282f, 0.08232881f, 
    -0.20978437f, -0.25935301f, -0.24968024f, 0.14763747f, 0.28870413f, 0.28487313f, -0.52349412f, -0.87043363f, 
    -0.66153562f, 0.07791886f, 0.36575097f, -0.27449387f, 0.73544157f, 0.21735480f, -0.30336493f, -0.37337190f, 
    0.29800472f, 0.23492655f, -0.19935712f, 0.07428958f, 0.25686875f, -0.36028144f, 0.04569467f, -0.41417158f, 
    -0.34995151f, -0.14283186f, -0.05365296f, -0.03178180f, 0.21361576f, 0.08728732f, -0.12295743f, 0.68731076f, 
    0.52977794f, 0.39150918f, -0.65963715f, -0.32119015f, 0.33288860f, 0.36001655f, -0.25991943f, -0.69177735f, 
    0.06964214f, 0.17742638f, 0.38339847f, 0.09285302f, 0.26800856f, -0.10347424f, -0.00519850f, 0.07912974f, 
    0.02720037f, 0.25981644f, 0.13300149f, 0.18533142f, 0.15481575f, -0.03725413f, -0.04319496f, 0.46884546f, 
    1.09227538f, -0.17091483f, -0.49552831f, 0.08438271f, 0.43912444f, -0.35991448f, 0.03809081f, -0.04444868f, 
    0.55572081f, -0.60520530f, -0.52069890f, -0.35057488f, 0.18508169f, -0.15791295f, -0.12581691f, -0.08927488f, 
    -0.11956505f, 0.15035991f, -0.09846437f, -0.15962183f, 0.06479165f, 0.08312149f, 0.36390248f, 0.16090870f, 
    -0.05320539f, 0.07877598f, 0.50957018f, 0.07784507f, 0.13845526f, -0.09146269f, 0.71747988f, -0.77687263f, 
    -0.17388320f, -0.14250207f, -0.26779029f, 0.52224499f, 0.19753808f, 0.19873630f, 0.18165874f, -0.48630083f, 
    0.22596477f, 0.15153565f, 0.01297098f, -0.08078527f, 0.13045391f, -0.14976795f, -0.28234637f, 0.31936118f, 
    0.16569297f, -0.12405860f, 0.46003786f, 0.58794922f, 0.67920983f, 0.30553997f, 1.02566564f, 0.69344670f, 
    -0.14329688f, -0.31906906f, 0.23397112f, -0.28258687f, -0.00479535f, 0.14029834f, 0.02986157f, 0.20021619f, 
    -0.02553478f, 0.01949869f, 0.10619903f, 0.31359306f, -0.07440229f, 0.15428272f, -0.18551320f, 0.09450760f, 
    0.10419145f, -0.13596825f, -0.07652544f, -1.05626786f, 0.26663506f, 1.01541913f, -0.23127948f, -0.37415645f, 
    0.85077012f, -0.09125337f, -0.20031893f, 0.05347236f, -0.38680980f, 0.07856763f, 0.25869736f, 0.12996423f, 
    0.28147435f, 0.16331893f, -0.24293484f, 0.23503448f, 0.01350388f, -0.40408635f, 0.12430396f, 0.02563336f, 
    -0.02142212f, -0.17387170f, 0.18784295f, -0.15671031f, -0.53500891f, 0.59322482f, 0.30713892f, 0.10284875f, 
    0.44627282f, -0.73651803f, 0.47426924f, -0.24924143f, -0.82384288f, -0.36764663f, 0.09971208f, -0.34101272f, 
    0.01533680f, 0.21391080f, 0.13049202f, 0.25736377f, -0.23469876f, -0.12780502f, -0.00269418f, 0.06786791f, 
    -0.03423667f, 0.08578465f, -0.04718002f, -0.01203349f, 0.09549262f, -0.70593953f, 0.93912190f, 0.47296724f, 
    -0.67031175f, 0.30652189f, -0.42758340f, -0.47549373f, 0.10318493f, -0.17292555f, 0.20494713f, -0.08135825f, 
    0.06479596f, -0.15712793f, -0.19171020f, 0.13367555f, -0.15613654f, -0.11241310f, -0.36824474f, -0.19871390f, 
    -0.19806923f, -0.00402595f, 0.38173074f, -0.01857938f, 0.22968480f, -0.16695252f, 0.76038265f, 0.50733298f, 
    0.35542339f, 0.90667725f, 0.71351796f, 0.40878609f, 0.21245694f, 0.24551779f, 0.05584876f, 0.09313656f, 
    -0.32672551f, 0.28021958f, -0.04561365f, -0.23770063f, -0.24011482f, 0.14026436f, 0.00603650f, 0.29242897f, 
    0.25435930f, 0.28136563f, -0.14394768f, 0.06438999f, -0.15038086f, -0.35926384f, 0.33835387f, -0.00082166f, 
    0.78928530f, 0.52541453f, 0.10342527f, 0.06766719f, 0.16613925f, -0.34102869f, 0.40773645f, -0.48261449f, 
    0.39830643f, 0.09253091f, 0.11549560f, -0.04549508f, 0.07728799f, 0.32692525f, -0.04582562f, 0.30975321f, 
    0.15913184f, 0.09019306f, 0.27054828f, 0.32613209f, 0.09715636f, 0.11629058f, 0.31992489f, 0.07489193f, 
    0.90583086f, 0.61699152f, 0.29581016f, 0.48814577f, -0.39569598f, -0.12380514f, -0.12927406f, 0.12092336f, 
    0.30721691f, 0.64091307f, 0.14969707f, -0.13638046f, 0.02348512f, 0.01525663f, -0.67384171f, -0.12630028f, 
    0.10049445f, 0.11413278f, -0.26520327f, -0.22941007f, 0.26196012f, -0.11217224f, 0.05191218f, -0.07367470f, 
    -0.17573485f, -0.48480842f, 0.31548721f, 0.13047953f, 0.18566887f, -0.10675941f, -0.62590235f, -0.15898348f, 
    -0.36390489f, 0.21939430f, -0.25245157f, -0.16543978f, 0.11016306f, 0.23661369f, 0.27737778f, 0.15851946f, 
    0.04361914f, -0.22928321f, 0.56938523f, -0.37255609f, -0.34323123f, -0.25784120f, 0.10754632f, -0.22986811f, 
    -0.23063025f, 0.36574787f, -0.91586673f, -0.36060771f, -0.40489751f, 0.11997573f, -0.03791149f, 0.42227378f, 
    1.05635524f, -0.41098669f, 0.42276424f, -0.08146510f, -0.09630227f, -0.20939942f, 0.30141398f, -0.08756261f, 
    -0.04839285f, 0.14706472f, 0.23082875f, 0.11493081f, 0.13313237f, -0.34317368f, 0.12223492f, -0.31273556f, 
    -0.09769689f, -0.13815285f, 0.26329109f, 0.04330249f, 0.18343464f, 0.78714806f, 0.03550151f, -0.60438257f, 
    -0.10861941f, 0.45329937f, -0.60223240f, 0.12191486f, 0.68123430f, 0.22793041f, -0.04692325f, -0.12634414f, 
    -0.10455238f, -0.07722836f, 0.09285364f, -0.25312582f, -0.38866377f, 0.17541486f, 0.04388636f, -0.25728568f, 
    0.13572536f, 0.24281771f, 0.29903507f, -0.33718753f, -0.33034676f, -0.45081833f, -0.56873846f, -0.24026115f, 
    -0.51925480f, -0.45424101f, 0.87203819f, 0.54852140f, -0.64489394f, 0.01622928f, 0.17044683f, -0.26675424f, 
    -0.24297668f, -0.30802742f, 0.29638264f, -0.10389501f, 0.03340153f, -0.01287627f, 0.20738132f, -0.06652098f, 
    -0.07123492f, 0.04304927f, -0.09239914f, -0.00885954f, -0.10747926f, -0.55655372f, -0.13551992f, -0.23871706f, 
    -0.39509347f, 0.32509369f, 0.03290245f, -0.57833564f, -0.00030615f, -0.20257758f, -0.17494351f, 0.08762485f, 
    0.04675107f, 0.24470983f, 0.36210603f, 0.27217966f, 0.31811395f, 0.49303579f, -0.07042520f, 0.29964319f, 
    0.38408294f, -0.35228068f, -0.23805772f, -0.11014841f, 0.23694192f, 0.34580061f, 0.29493818f, 0.34098276f, 
    0.37564826f, -0.02744855f, 0.21243414f, -0.66717768f, -0.78784871f, -0.22230808f, -0.41554692f, 0.06334851f, 
    0.27109563f, 0.08081374f, 0.09672116f, 0.64356655f, -0.39754349f, 0.36206287f, -0.16645110f, 0.26063028f, 
    0.12544212f, 0.03062714f, -0.27365884f, 0.30195221f, 0.41606233f, -0.07960215f, -0.06267866f, -0.14619486f, 
    -0.35287890f, -0.39685559f, 0.43041098f, 0.82841825f, 0.38881510f, -0.69770867f, -0.68797886f, -0.38693532f, 
    -0.28488263f, -0.24543208f, 0.57205677f, -0.15364330f, 0.21309045f, 0.30558053f, 0.01879224f, -0.51020408f, 
    -0.02306377f, 0.22488248f, 0.12276600f, -0.12417098f, 0.07848342f, -0.09757703f, -0.14983213f, -0.13189755f, 
    0.96431303f, 0.48762971f, -0.77859598f, -0.57927507f, -0.36738431f, 0.01944851f, 0.10941412f, -0.35808745f, 
    -0.07890671f, 0.36857912f, 0.26923633f, -0.03013995f, 0.11158972f, 0.12764089f, -0.10745695f, 0.14907528f, 
    0.27460155f, -0.16501628f, -0.19682254f, 0.55010420f, 0.01361598f, 0.03791426f, 0.31614953f, 0.18335909f, 
    -0.14044543f, -0.57807279f, 0.65877658f, -0.50677425f, -0.60784638f, 0.27796733f, -0.44086936f, 0.62221336f, 
    0.62760079f, 0.09205008f, 0.47943458f, 0.01855362f, 0.12418801f, -0.34539726f, -0.52952075f, -0.20155901f, 
    0.14492702f, 0.01914255f, -0.37870023f, 0.27830034f, -0.17576346f, -0.11966133f, 0.23624544f, -0.02636540f, 
    -0.41952634f, -0.14448455f, -0.47459495f, -0.44156203f, 0.80232918f, 0.65973598f, -0.31358722f, -0.41846162f, 
    -0.25987312f, 0.60068333f, 0.29664314f, -0.39730039f, 0.01931675f, -0.22348379f, -0.30154270f, 0.17893994f, 
    -0.23450868f, 0.11334069f, 0.07076725f, 0.32271686f, 0.04961063f, 0.13801035f, 0.20872870f, 0.23127416f, 
    -0.11074177f, -0.00814343f, -0.30756062f, 0.00708351f, 0.22905949f, -0.47671193f, -0.63221419f, 0.30556720f, 
    -0.36422694f, -0.69276053f, -0.07092517f, 0.06057210f, -0.39798355f, 0.25641611f, 0.17887059f, -0.01042443f, 
    0.18475902f, -0.11327525f, 0.18530439f, -0.03746550f, -0.06969837f, 0.04479271f, 0.08554596f, 0.20922831f, 
    0.10606062f, 0.13282482f, 0.30487153f, 0.68765336f, 0.04991249f, -0.64255357f, -0.71075517f, -0.66127133f, 
    0.45202830f, 0.63427103f, -0.32964852f, 0.12028006f, 0.23712274f, 0.30823699f, -0.19949704f, 0.00117908f, 
    -0.03335399f, -0.32178038f, -0.04082112f, -0.03232324f, 0.06498187f, 0.27125254f, 0.20025504f, -0.31474486f, 
    0.02859194f, -0.15911621f, -0.10417084f, 0.43302751f, 0.33393928f, -0.02745327f, 0.63923877f, 0.88303459f, 
    0.03852429f, 0.19018707f, 0.55103332f, -0.05111098f, 0.27981883f, -0.08462355f, 0.21620357f, -0.43281603f, 
    -0.21492484f, -0.16450438f, -0.08360799f, -0.00898344f, -0.16649714f, 0.13367866f, -0.14488624f, -0.15869305f, 
    -0.36631888f, 0.08794807f, 0.04827147f, 0.17318624f, 0.30233538f, 0.03782760f, 0.05885228f, -0.12985572f, 
    0.37813824f, 0.76180583f, 0.58352751f, 0.26621553f, 0.31431007f, 0.50667429f, 0.46409187f, 0.47521046f, 
    -0.32798478f, 0.00193716f, -0.09543520f, 0.05138378f, 0.08895444f, -0.45670083f, -0.26707178f, 0.01984089f, 
    -0.12959264f, -0.23748118f, 0.11629459f, -0.50772089f, -0.42437005f, -0.21250613f, -0.37027550f, 0.70089537f, 
    0.29798332f, -0.17845713f, -0.71049869f, 0.37043744f, 0.02812443f, 0.16097106f, 0.56644857f, 0.45763955f, 
    0.45598882f, -0.09817296f, 0.33408290f, -0.18062054f, -0.10913447f, 0.03375370f, -0.24180646f, 0.18730231f, 
    0.06826671f, 0.18806800f, 0.14096496f, -0.48667225f, 0.32202134f, -0.31911764f, -0.21189433f, 0.08325243f, 
    -0.74599677f, -0.13546142f, -0.53423059f, -0.03437755f, -0.60700434f, 0.55135781f, -0.28792617f, -0.39727160f, 
    0.52646995f, 0.04012201f, -0.13178605f, -0.11362697f, -0.15983422f, -0.13674188f, -0.04313255f, -0.20914890f, 
    0.23164679f, -0.15611337f, 0.13543077f, -0.27642798f, 0.31879950f, 0.33307701f, 0.31348592f, 0.48027262f, 
    0.09687566f, 1.06323576f, 0.05289264f, -0.91793144f, -0.31213814f, 0.05807528f, 0.16531503f, -0.17609397f, 
    0.33510685f, 0.24092276f, 0.43350503f, -0.55459017f, 0.10360622f, 0.28856787f, -0.27973211f, -0.17893334f, 
    -0.07531743f, -0.40076464f, -0.24152467f, 0.17621624f, 0.41503298f, -0.15206185f, -0.03586239f, -0.06797267f, 
    0.00427681f, -0.11069413f, -0.28689936f, -0.02382505f, -0.14264765f, -0.59418422f, -0.33109736f, -0.62388057f, 
    -0.43864745f, -0.12460902f, 0.65485239f, -0.49655700f, -0.14909428f, 0.02292060f, -0.52072638f, 0.23976271f, 
    -0.31026658f, -0.49261183f, -0.16656733f, 0.00624886f, -0.01237768f, 0.09256057f, 0.59682810f, -0.30926532f, 
    -0.15364276f, -0.19764760f, -0.29585770f, 0.83256292f, -0.33710164f, 0.28293711f, -0.73899311f, -0.25131834f, 
    0.42463431f, -0.01076276f, 0.70452631f, 0.14187996f, -0.00026939f, 0.01970612f, 0.35285342f, -0.38221216f, 
    0.27445191f, 0.23012742f, 0.02419656f, -0.12943354f, -0.12961978f, 0.03704672f, 0.27406156f, -0.18714692f, 
    0.04310466f, -0.22989450f, -0.24249309f, 0.29825228f, 0.16940343f, 0.31471974f, -0.15089893f, 0.51647550f, 
    0.68129212f, -0.78557426f, -0.71295536f, 0.02325645f, -0.62638706f, 0.14797214f, 0.27058882f, 0.24476334f, 
    0.03495048f, 0.12067605f, -0.03582593f, 0.18771897f, 0.29996100f, 0.19997215f, -0.18570739f, 0.47078323f, 
    0.35150498f, -0.13203701f, -0.02274807f, -0.24863115f, -0.03855192f, -0.45864752f, 0.13480626f, -0.42459363f, 
    -0.65702242f, -0.36282119f, -0.50979489f, -0.22210836f, -0.06107884f, -0.35636875f, -0.40965015f, -0.52532524f, 
    -0.14329892f, -0.02586938f, -0.24167503f, -0.40640035f, 0.21758457f, -0.26290193f, 0.33993092f, -0.12829737f, 
    0.01986886f, 0.09480400f, 0.21815760f, 0.18467370f, 0.28757995f, 0.22212039f, 0.76293766f, 0.52610767f, 
    0.40328434f, 0.43363041f, 0.60200918f, -0.37702182f, -0.28461772f, 0.02203589f, -0.16696808f, 0.19941950f, 
    -0.40704215f, -0.45729408f, 0.29238528f, 0.05417690f, 0.33386213f, 0.23185001f, -0.20441891f, -0.08027469f, 
    0.20031247f, 0.25932303f, 0.57689971f, 0.20050187f, -0.04044627f, 0.12271218f, -0.21025422f, 0.59026378f, 
    -0.10537200f, -0.41750184f, -0.95985126f, -0.64995891f, 0.41488090f, 0.25825429f, 0.48003307f, 0.41058260f, 
    -0.17125021f, -0.24118586f, -0.28806230f, -0.46234050f, -0.00394480f, -0.19553821f, 0.07457288f, 0.21216868f, 
    0.07401656f, 0.13534869f, 0.00807896f, -0.12482460f, 0.02473573f, -0.02269835f, -0.24757358f, 0.04456163f, 
    -0.46786049f, -0.55937260f, -0.72969836f, -0.43402556f, -0.37188244f, -0.31603336f, -0.07950303f, 0.14379111f, 
    0.40345615f, 0.73369157f, 0.16073836f, 0.24207252f, 0.32504326f, 0.11044826f, 0.02584867f, 0.21057567f, 
    -0.19095276f, 0.52830005f, 0.36871940f, -0.03143132f, -0.26838359f, 0.19983377f, -0.32700065f, -0.08764921f, 
    0.00794900f, -0.52572650f, -0.55970132f, -0.17448661f, 0.44493777f, 0.53437060f, -0.21049967f, 0.39017734f, 
    0.38284755f, 0.03023008f, 0.19611771f, 0.18608996f, -0.30829012f, -0.38920119f, -0.09200879f, 0.31234190f, 
    0.24671982f, 0.40261322f, -0.21605304f, -0.11666776f, -0.17982149f, -0.33163664f, -0.39975917f, 0.21141507f, 
    -0.14079267f, -0.04059855f, 0.94894618f, 0.28439689f, -0.53375840f, 0.57227927f, -0.28139359f, 0.09976329f, 
    0.29556459f, -0.73922849f, -0.15376779f, 0.31095082f, 0.03465877f, 0.07289011f, -0.35391769f, -0.21140502f, 
    0.07048684f, 0.13046138f, -0.28197882f, -0.26391113f, -0.20535201f, -0.04246439f, 0.02591504f, 0.11002376f, 
    -0.07949116f, -0.01971466f, 0.38483304f, -0.11936773f, -0.53904098f, 0.38560817f, 0.54734606f, 0.55243033f, 
    0.77324432f, 0.38891950f, 0.44245380f, -0.25286469f, -0.38150820f, -0.00189339f, -0.44251436f, 0.17451540f, 
    0.04502196f, -0.34620944f, -0.18025781f, -0.29136041f, 0.14147435f, -0.32186076f, -0.05784594f, 0.02142433f, 
    0.50419772f, -0.22198729f, 0.24410708f, -0.12761416f, -0.24367726f, 0.09763911f, 0.30303550f, 0.39951202f, 
    0.13207747f, -0.63713580f, 0.38859731f, -0.78892374f, -0.24600489f, 0.03454784f, -0.18760446f, 0.48874927f, 
    -0.14510337f, 0.23536451f, 0.19637720f, -0.21260761f, -0.09210973f, 0.07231142f, -0.49888051f, -0.10800194f, 
    -0.15057929f, 0.41049248f, -0.05301374f, 0.15805346f, 0.11651694f, -1.19705594f, 1.09072936f, 0.06464908f, 
    -0.85103238f, 0.19798216f, 0.61962235f, 0.19795483f, 0.10888457f, 0.61211300f, 0.04676200f, -0.14860454f, 
    -0.08492860f, -0.30603015f, -0.22433072f, -0.28537518f, 0.19674847f, -0.13703057f, -0.22869375f, -0.01578386f, 
    0.22587743f, -0.35140023f, 0.02906787f, -0.09947312f, -0.01108815f, -0.08758300f, -0.54547507f, 0.37184820f, 
    0.03767808f, -0.67229128f, -0.19270359f, 0.82186162f, 0.51776814f, 0.22796904f, 0.56978244f, 0.26336974f, 
    0.38603628f, -0.41100991f, 0.21368475f, 0.05305989f, 0.10825621f, -0.29335108f, -0.27571678f, 0.04870069f, 
    -0.00216982f, -0.14382643f, -0.25515291f, -0.27725828f, -0.05672662f, -0.06929100f, -0.09149919f, -0.37567040f, 
    0.17994386f, 1.02416933f, 0.21837376f, -0.25931078f, -0.48309085f, 0.22729389f, -0.33057842f, -0.59416080f, 
    -0.06920545f, -0.24948792f, 0.39183092f, -0.29525438f, 0.33264068f, 0.14856209f, 0.10818591f, -0.10441910f, 
    0.04980738f, 0.19471306f, -0.00173845f, 0.01391059f, -0.16336460f, -0.12465689f, -0.08849656f, -0.03496151f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.05214108f, 0.12668410f, -0.07442111f, 0.18236579f, 0.19091314f, -0.07153635f, -0.03204775f, 0.10858243f, 
    0.05599226f, 0.05695856f, 0.22525974f, 0.21688171f, 0.29387435f, 0.06157545f, 0.13438793f, -0.00214839f, 
    -0.00627953f, 0.14212447f, 0.10628586f, -0.03278764f, 0.10953967f, 0.07288310f, 0.02063974f, 0.12411336f, 
    0.16825321f, -0.05974416f, 0.25706685f, 0.15690702f, 0.26629737f, 0.21569276f, 0.20609093f, 0.18621327f, 
    0.21528795f, 0.13008781f, 0.18811084f, -0.10939218f, 0.15581475f, 0.19611409f, 0.10997172f, 0.28094661f, 
    0.21720141f, 0.05443100f, 0.24016048f, 0.30667794f, 0.05222973f, 0.28672290f, 0.12095173f, 0.08706842f, 
    0.09520974f, -0.01030953f, 0.16286163f, 0.17027017f, 0.24016532f, 0.10068161f, 0.19729812f, 0.06166586f, 
    0.16661173f, 0.07584187f, 0.23908839f, 0.20237906f, -0.01156421f, -0.00304502f, 0.14783907f, -0.08364792f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.09779244f, -0.08192840f, -0.06753375f, -0.23205411f, -0.01802196f, 0.14140525f, -0.03111977f, 0.02749503f, 
    0.08726826f, 0.05930747f, -0.03146120f, -0.05434879f, -0.13390590f, 0.14672944f, 0.06092610f, -0.47703722f, 
    0.01733121f, 0.03536306f, 0.02546237f, 0.02674650f, -0.07578325f, 0.07242816f, -0.00570966f, 0.03014234f, 
    0.63836324f, 0.14289871f, -0.07664758f, -0.03972524f, -0.01702086f, -0.04134607f, 0.04161508f, 0.00284401f, 
    0.09238815f, 0.03488057f, -0.09553203f, 0.06814032f, -0.00478127f, 0.02662081f, -0.09645371f, 0.01862601f, 
    -0.01092378f, -0.01973805f, -0.02409334f, 0.01349115f, 0.01890543f, 0.03651816f, 0.01764809f, 0.03131776f, 
    -0.02523276f, 0.09052035f, -0.09531363f, -0.03579496f, -0.07900080f, -0.10199917f, -0.03262543f, 0.00618043f, 
    -0.09908168f, 0.00954907f, -0.05657750f, 0.01370115f, 0.18521833f, 0.14273098f, -0.01734063f, 0.04452555f, 
    0.05558908f, 0.00487972f, -0.03267890f, 0.09079506f, 0.03308250f, -0.02576376f, 0.10111730f, -0.06123959f, 
    0.25847670f, -0.16156124f, 0.00207490f, -0.10431807f, -0.15590085f, 0.07791862f, -0.05471724f, 0.04351881f, 
    -0.07318606f, 0.05667926f, 0.11120558f, 0.04461054f, -0.01024172f, -0.03146670f, 0.11643399f, -0.14679165f, 
    -0.03177289f, 0.03606604f, -0.00366579f, -0.08987352f, -0.19108944f, -0.05030546f, 0.08502389f, 0.06760381f, 
    -0.33535665f, 0.05041322f, -0.25052324f, 0.06178794f, 0.04603010f, 0.00802420f, -0.07781295f, 0.03400948f, 
    0.03075341f, 0.05668964f, -0.06239222f, 0.01912360f, 0.17408693f, -0.11389303f, -0.09462116f, 0.08155856f, 
    -0.17128615f, -0.03573422f, 0.04918001f, 0.10360256f, 0.12078679f, 0.02408381f, -0.00443493f, -0.10765277f, 
    -0.32683843f, 0.00049584f, -0.11277349f, 0.19815820f, -0.01142045f, 0.04508017f, -0.05292215f, -0.00999574f, 
    0.06648722f, 0.03741645f, -0.00457200f, -0.06620597f, 0.01671640f, 0.15260912f, -0.08934063f, -0.01019721f, 
    -0.17861015f, -0.11704928f, 0.02965670f, 0.11657798f, -0.04698042f, 0.03085824f, -0.04591165f, -0.02231481f, 
    -0.05032132f, 0.15531161f, 0.02047210f, -0.04592674f, -0.09449774f, 0.01074469f, -0.03408912f, -0.05563407f, 
    -0.10386613f, -0.01029165f, -0.02543022f, -0.12877341f, 0.03616399f, 0.07719795f, -0.05142001f, 0.18909097f, 
    -0.06912750f, 0.06261812f, -0.05706421f, -0.12231255f, -0.00067654f, -0.02858690f, -0.09073350f, 0.06094294f, 
    -0.33085284f, -0.02641019f, 0.10493249f, -0.11792482f, -0.18485112f, 0.07861324f, 0.05047308f, -0.09154774f, 
    -0.03168025f, -0.10411742f, -0.02940970f, 0.14633462f, 0.19093211f, 0.04390692f, -0.00774593f, -0.00219469f, 
    0.05634782f, 0.02100840f, -0.01854900f, -0.17366980f, 0.04711607f, 0.07899556f, -0.08894820f, 0.11930211f, 
    -0.13286689f, 0.23908678f, -0.11741930f, -0.01399672f, 0.06178313f, 0.06660314f, -0.10187847f, 0.02017912f, 
    -0.03580997f, 0.12727652f, 0.02746781f, 0.04015279f, -0.19929402f, -0.09166423f, -0.10522806f, -0.24123603f, 
    0.05936669f, -0.03223376f, -0.00757427f, 0.10840121f, 0.01476389f, -0.06289919f, -0.01493084f, 0.04938164f, 
    -0.03329254f, 0.00491784f, -0.03520932f, 0.16940264f, -0.12430525f, -0.08671783f, 0.05515127f, -0.01172077f, 
    -0.03185563f, 0.09048067f, -0.04312395f, -0.08531078f, 0.13631794f, -0.03684110f, 0.05444586f, -0.07451792f, 
    -0.08055922f, 0.01091761f, -0.07558388f, -0.11812106f, 0.01928422f, -0.05468001f, 0.03454349f, 0.00822106f, 
    0.08968466f, 0.10697655f, 0.07465496f, -0.17858939f, -0.14833704f, -0.05846519f, 0.03249812f, 0.00924443f, 
    -0.18872888f, 0.02830689f, -0.05194474f, -0.03283459f, 0.01322023f, -0.20135072f, -0.24571429f, 0.29374260f, 
    -0.02110439f, 0.03355237f, -0.03843163f, -0.01772093f, 0.12202418f, 0.11207602f, -0.04675545f, 0.03222616f, 
    -0.41942453f, 0.19655925f, -0.04620664f, 0.04216107f, 0.03138190f, -0.00978911f, -0.02102219f, -0.09740342f, 
    -0.04026246f, 0.01422499f, 0.07067635f, 0.02254209f, -0.24406615f, 0.24294542f, 0.16686893f, -0.25961477f, 
    -0.02642730f, 0.03922632f, 0.01631928f, 0.02301950f, -0.04874566f, -0.04038354f, -0.12330641f, 0.08045521f, 
    0.09064085f, 0.15225750f, -0.01771431f, 0.10903816f, 0.00958986f, 0.00674230f, -0.01007187f, -0.05258067f, 
    -0.01166562f, 0.01702451f, 0.00510016f, -0.11445093f, 0.00929080f, 0.03123913f, -0.07201588f, -0.00044180f, 
    -0.06189995f, 0.00030232f, 0.03978283f, -0.00663547f, 0.10611606f, 0.00069759f, -0.04618743f, -0.06440403f, 
    0.04087270f, -0.03449985f, 0.03474226f, -0.00791411f, -0.15069102f, 0.01332432f, 0.08374552f, 0.04847649f, 
    0.08997217f, 0.00774392f, -0.09614533f, 0.00962476f, -0.34455359f, 0.01491815f, 0.09671301f, 0.14522849f, 
    -0.02225346f, 0.00340863f, 0.12703057f, -0.14103658f, -0.01208086f, 0.05590390f, 0.07457215f, 0.00733965f, 
    -0.02279644f, 0.04409149f, 0.03864896f, 0.00386863f, -0.05759284f, -0.03014641f, 0.07679263f, -0.04848386f, 
    -0.02642566f, -0.11400726f, 0.06220475f, -0.07820897f, -0.20286900f, 0.10139585f, 0.05526461f, 0.01767784f, 
    0.01045011f, -0.03439746f, -0.09173200f, -0.09055457f, -0.02022983f, 0.00979180f, -0.02488211f, -0.00021400f, 
    0.12977658f, -0.06980395f, -0.07560221f, 0.14808351f, -0.14298834f, -0.01422316f, -0.00884617f, 0.01979530f, 
    0.09402119f, 0.01807367f, -0.08582350f, 0.01002221f, -0.22671480f, 0.12258011f, 0.03110653f, -0.05930451f, 
    -0.08258282f, 0.02945444f, 0.06677978f, -0.09697548f, -0.00834997f, -0.06854449f, -0.01204649f, 0.00964826f, 
    0.00372915f, -0.04143894f, -0.01301362f, 0.12324034f, -0.09931620f, -0.09855113f, -0.09171674f, 0.01523550f, 
    -0.00313440f, 0.12760580f, -0.04538128f, -0.05861182f, -0.23267461f, -0.07406145f, -0.09322613f, 0.05660971f, 
    0.00615522f, 0.00024106f, 0.04138359f, 0.00565566f, 0.05081834f, 0.07803493f, -0.13761990f, -0.04633790f, 
    0.26123086f, 0.19698982f, 0.10240889f, -0.08904637f, 0.00390285f, -0.00493468f, -0.05423816f, -0.01703832f, 
    0.05280157f, -0.01274946f, -0.14591393f, -0.00445774f, 0.18626058f, 0.01694543f, 0.08672293f, 0.13711515f, 
    -0.06108682f, 0.08309031f, -0.01880999f, 0.08811779f, -0.03145255f, 0.02559295f, 0.04453554f, -0.08644105f, 
    -0.25969154f, 0.16715205f, 0.15855269f, -0.14365715f, 0.02886998f, 0.04894712f, 0.03178693f, 0.00676301f, 
    0.02889509f, -0.11934294f, -0.00917184f, 0.05529984f, -0.16819754f, -0.15113364f, -0.00049287f, -0.05699365f, 
    0.02598090f, 0.01043451f, -0.10290666f, -0.00794529f, 0.09530025f, 0.03722279f, -0.03472193f, -0.04615806f, 
    0.06196983f, -0.02709047f, 0.09830509f, -0.10680534f, -0.06729566f, -0.10854430f, -0.08061605f, 0.13104834f, 
    0.01747071f, 0.09011016f, -0.00922158f, -0.08343863f, 0.01347450f, -0.10765010f, 0.15853474f, -0.01353246f, 
    0.01310563f, -0.01686340f, 0.04142421f, -0.17913544f, -0.14575188f, -0.12079423f, 0.06122404f, -0.06830940f, 
    -0.20874347f, -0.01826087f, 0.07535621f, -0.33581465f, -0.11503120f, 0.07192489f, 0.00275159f, 0.04119708f, 
    -0.10658410f, -0.04145180f, -0.00468774f, -0.00833306f, 0.11741795f, 0.11902279f, 0.11006689f, -0.34032694f, 
    0.04205231f, -0.09259020f, 0.12898941f, -0.09675016f, -0.02797236f, 0.03119410f, -0.08620153f, 0.11863904f, 
    -0.07618461f, 0.02360487f, -0.07450721f, 0.34261945f, -0.10241313f, 0.05707467f, 0.10576058f, -0.00343303f, 
    0.03021118f, -0.12995395f, 0.10130798f, -0.02610119f, -0.06457611f, -0.02143824f, 0.21054398f, -0.10317048f, 
    -0.00343036f, -0.00205766f, -0.02859377f, 0.05323374f, 0.11998121f, -0.04794526f, 0.03202320f, -0.09257136f, 
    0.17519824f, -0.00810141f, 0.02553766f, -0.13557385f, 0.12024589f, 0.11252271f, 0.02333424f, 0.15263426f, 
    -0.07823057f, 0.06455287f, -0.10133789f, 0.11956214f, -0.14102480f, 0.03799384f, 0.07819995f, 0.12902145f, 
    -0.18940109f, -0.09901035f, 0.02941936f, -0.04464810f, -0.01283586f, -0.09105353f, -0.05663637f, -0.00279099f, 
    -0.09432931f, 0.00866382f, -0.06703766f, 0.28585976f, -0.13637716f, 0.08966050f, 0.12883325f, 0.08848093f, 
    0.01446506f, -0.00909758f, -0.03583808f, 0.01512238f, 0.22282679f, -0.00637116f, -0.07070928f, -0.34566480f, 
    0.10457873f, 0.04041400f, 0.06763989f, 0.00141509f, -0.06177073f, -0.00288498f, 0.00424782f, 0.01675583f, 
    0.20176540f, 0.00753397f, -0.21262474f, -0.02034147f, 0.03326356f, -0.07041922f, -0.04137372f, 0.02018615f, 
    0.06194552f, -0.02421870f, -0.03778337f, -0.01852552f, 0.10110303f, -0.23682925f, -0.03397375f, -0.10035635f, 
    0.04945189f, -0.11016412f, 0.06749257f, 0.14474361f, -0.10839167f, 0.01743876f, 0.00039848f, 0.09105521f, 
    -0.27956408f, -0.01458045f, -0.18171002f, -0.04949501f, -0.00557546f, 0.04055108f, 0.02124477f, 0.01417807f, 
    -0.01045955f, -0.10808970f, 0.05019240f, -0.08945624f, 0.21407853f, -0.11882319f, 0.02342495f, -0.35250098f, 
    0.03004438f, -0.05752653f, -0.05570959f, 0.04978728f, 0.05497498f, 0.00991287f, 0.02172215f, 0.07834473f, 
    0.19353820f, -0.01515076f, 0.12584379f, 0.04619278f, -0.05961350f, 0.06781976f, 0.06613845f, -0.04207539f, 
    -0.00755146f, -0.08240147f, -0.07504017f, -0.06736970f, -0.23110960f, -0.10585123f, 0.03633224f, -0.04830396f, 
    -0.00267231f, 0.05215679f, 0.03797666f, 0.05430581f, -0.07298931f, 0.04997683f, 0.06975628f, -0.03288356f, 
    0.20692371f, 0.03969038f, -0.05285591f, -0.02733743f, -0.07369573f, 0.03950001f, -0.06771810f, -0.00802218f, 
    -0.04347961f, -0.00859997f, -0.06435826f, 0.02846648f, 0.18291767f, 0.04516652f, 0.01768323f, -0.36366710f, 
    -0.02378108f, 0.04704134f, 0.02312983f, -0.17736045f, -0.07782539f, 0.12762950f, 0.06905708f, -0.03843561f, 
    0.03952505f, -0.07021760f, -0.18101846f, -0.20294929f, 0.05988252f, -0.11155447f, 0.06845485f, -0.05015831f, 
    0.00281424f, -0.09775201f, -0.03034531f, -0.02371542f, -0.13761100f, 0.11426871f, 0.04517742f, 0.09786787f, 
    0.00709231f, 0.07043325f, 0.05947188f, -0.08013509f, 0.00741782f, 0.01433994f, -0.00136729f, -0.01873994f, 
    -0.01205688f, 0.05292375f, 0.03851278f, 0.14927019f, -0.19776291f, -0.03214761f, -0.01217635f, 0.11006641f, 
    -0.02482968f, 0.02804229f, 0.06955568f, 0.00584150f, -0.14171793f, 0.08055373f, -0.00272127f, 0.05394778f, 
    -0.07508274f, -0.00841283f, 0.00697701f, -0.11749841f, -0.06056630f, -0.09145898f, -0.09485715f, -0.04802452f, 
    -0.03852637f, 0.00653802f, -0.04321479f, 0.15212446f, 0.01699156f, -0.07301098f, -0.08486409f, -0.02121167f, 
    -0.04109676f, 0.08451562f, -0.04586555f, 0.10009018f, 0.35692763f, -0.05559002f, 0.15486734f, -0.13104828f, 
    -0.05077805f, -0.07616083f, 0.14331397f, -0.04250378f, -0.10309769f, -0.07943747f, -0.04538073f, -0.01324642f, 
    0.28039765f, -0.05163602f, 0.02433316f, -0.13086386f, -0.01184572f, 0.06594320f, -0.00720800f, -0.05605410f, 
    0.04980708f, -0.00696467f, 0.02744394f, 0.09875255f, -0.34656405f, 0.15841942f, 0.01946633f, 0.16025777f, 
    -0.04972777f, 0.08330420f, 0.09865880f, 0.04886407f, 0.04067057f, -0.00285516f, -0.00243649f, 0.02002171f, 
    -0.07164073f, 0.10125411f, 0.02297590f, 0.00214154f, 0.05718120f, -0.11658671f, 0.06806926f, 0.08544521f, 
    -0.05678588f, 0.10700609f, -0.06211393f, 0.05508390f, 0.13824794f, -0.20182583f, -0.07552809f, -0.15753385f, 
    0.00597355f, 0.00386367f, -0.05686926f, -0.04943972f, 0.10579892f, -0.07925268f, -0.03643708f, 0.05099748f, 
    -0.54607159f, -0.00396112f, -0.02446335f, -0.10242744f, -0.01782455f, -0.01980979f, 0.06458791f, 0.08259314f, 
    0.01453165f, 0.06081313f, -0.01339800f, -0.05657494f, -0.14901978f, -0.23765989f, -0.24285389f, -0.17045373f, 
    0.00257163f, -0.01244474f, -0.00043893f, -0.00038189f, 0.02994647f, -0.16048101f, 0.01056528f, -0.13610394f, 
    0.14609209f, -0.00867451f, -0.08557271f, -0.01035248f, -0.10384457f, -0.14224392f, 0.06891193f, 0.00576625f, 
    -0.05194902f, -0.03408706f, -0.01154594f, 0.10523360f, -0.21218881f, -0.00804926f, -0.27250895f, 0.03681847f, 
    0.06974105f, 0.09239035f, -0.09262019f, -0.00316282f, 0.03486075f, -0.04788110f, -0.17656600f, -0.04026437f, 
    0.03039691f, 0.06571446f, 0.12911718f, 0.29186046f, 0.01324582f, -0.08631314f, -0.06633962f, 0.10009321f, 
    0.05861618f, -0.08871026f, -0.05663757f, -0.06525909f, -0.13656175f, 0.03997407f, 0.03339288f, 0.11230645f, 
    -0.00429159f, 0.06097526f, 0.06645024f, -0.03442984f, 0.04390864f, 0.09256802f, 0.00061871f, 0.03454053f, 
    0.06642556f, 0.04892570f, -0.04521529f, 0.13775648f, -0.08105698f, 0.01173918f, -0.06984606f, 0.06292332f, 
    -0.00983824f, -0.25754178f, 0.06904799f, -0.02156527f, 0.28898126f, 0.04457489f, 0.11974274f, 0.02103323f, 
    0.04800714f, -0.00540676f, -0.13771240f, -0.10449650f, -0.06685647f, 0.00898641f, -0.10098494f, 0.12878214f, 
    -0.08133832f, 0.04158499f, -0.07760323f, 0.01569233f, -0.04908794f, -0.23357086f, 0.03569536f, 0.12137681f, 
    -0.11837048f, 0.01794997f, 0.00937843f, 0.07375576f, 0.13618509f, -0.18733251f, 0.12835310f, 0.15320687f, 
    -0.09287745f, -0.00026374f, 0.02776538f, -0.01859743f, 0.01415765f, 0.00003088f, 0.03747119f, -0.05517649f, 
    0.06194401f, 0.06790733f, -0.24694347f, -0.10142048f, -0.02663912f, -0.04224979f, 0.08299235f, 0.05540847f, 
    0.06253750f, -0.08854382f, 0.04138294f, 0.12790243f, -0.00307699f, -0.15678495f, -0.01204505f, 0.12100383f, 
    -0.11166538f, 0.01140709f, -0.07528426f, 0.03983384f, -0.01395671f, 0.04875599f, 0.05955787f, -0.00321732f, 
    -0.00348953f, -0.34707305f, -0.00518402f, -0.11850730f, 0.03850930f, 0.01499871f, 0.04653809f, 0.04686161f, 
    0.05451306f, 0.14379789f, 0.05439401f, -0.07758770f, -0.06227886f, 0.06030364f, 0.09812395f, 0.02084264f, 
    -0.01356173f, -0.12191009f, -0.08940180f, 0.01216117f, 0.09285923f, -0.03384043f, -0.05962772f, -0.08059121f, 
    0.22005993f, -0.09880839f, -0.03394312f, -0.15394899f, 0.08503813f, -0.03367390f, -0.06992355f, 0.00809150f, 
    -0.01661828f, -0.25026914f, -0.05386085f, -0.06290084f, 0.25262699f, -0.00808772f, -0.05969780f, 0.03334748f, 
    0.08866143f, -0.02837817f, 0.03112845f, 0.18747926f, 0.01360196f, 0.01189200f, 0.00567654f, 0.02002379f, 
    0.36505759f, -0.22341238f, 0.09548660f, 0.06044126f, 0.02563301f, 0.07355637f, 0.04820683f, -0.02724470f, 
    0.09647925f, -0.09032287f, 0.13253513f, -0.05982125f, -0.20352945f, -0.02500987f, 0.12100742f, 0.11532283f, 
    -0.07509858f, 0.04247288f, 0.06997058f, 0.07634951f, -0.01766986f, 0.01869333f, -0.07881568f, 0.09358596f, 
    0.16686180f, 0.17851856f, -0.04544710f, 0.27367899f, 0.04513253f, 0.08506358f, 0.01276000f, -0.00817232f, 
    0.10675595f, -0.05121368f, -0.04844603f, 0.07767746f, -0.32945350f, -0.01647990f, -0.03515745f, 0.23741519f, 
    -0.14559016f, 0.01159718f, -0.09212531f, -0.00205160f, -0.07258647f, -0.10193855f, 0.07041749f, 0.01896839f, 
    0.23564856f, -0.04703873f, -0.06246832f, 0.03946460f, -0.03497266f, 0.07721723f, -0.06092591f, -0.00589937f, 
    -0.05061303f, 0.01912266f, -0.06741945f, -0.13956393f, 0.14037181f, 0.13015027f, 0.02280016f, -0.08994045f, 
    -0.12690979f, -0.05521971f, -0.01036961f, -0.04492424f, 0.02013933f, 0.04876078f, 0.02724891f, -0.03603705f, 
    0.19826697f, -0.27540877f, 0.12131465f, 0.08114360f, -0.08659613f, 0.00150605f, 0.01301594f, 0.01445106f, 
    -0.10014485f, -0.02417198f, -0.07385080f, -0.01435650f, -0.12334846f, -0.06448754f, 0.10362794f, 0.04160298f, 
    0.05187724f, -0.03372771f, 0.04745411f, -0.10218849f, -0.02078835f, 0.15992993f, 0.03586223f, -0.06849761f, 
    0.14069024f, 0.00746930f, 0.08479524f, 0.13097310f, -0.13293006f, -0.02685349f, -0.02976966f, -0.01165431f, 
    -0.07486998f, 0.01042073f, 0.09713204f, -0.02174148f, -0.39567551f, 0.11038303f, 0.07375081f, 0.04359573f, 
    -0.09724250f, -0.08976360f, 0.02484043f, -0.03151264f, -0.04214032f, -0.05274551f, -0.01243821f, -0.09202175f, 
    -0.10757294f, 0.00651812f, -0.10049633f, -0.20398176f, -0.00261428f, 0.07521194f, 0.05121488f, -0.01424165f, 
    0.01668758f, 0.14626291f, -0.03397328f, 0.03255355f, 0.03575979f, 0.05747902f, -0.07891028f, -0.30055952f, 
    0.10966917f, 0.07050044f, 0.02785020f, -0.00565306f, -0.01836700f, 0.01440471f, -0.02892074f, -0.07778381f, 
    0.27852169f, 0.10011956f, 0.10781729f, 0.19550779f, 0.07132435f, 0.03066529f, -0.02052163f, -0.01857249f, 
    -0.01317634f, -0.09941967f, 0.05552835f, -0.00557460f, 0.19881859f, 0.08535680f, 0.10183362f, 0.19216982f, 
    -0.07751135f, -0.08535396f, -0.01848178f, -0.04611135f, 0.01943335f, 0.14758995f, 0.11341129f, 0.02651351f, 
    0.22873300f, 0.06090385f, 0.07764142f, 0.12966357f, -0.10990043f, -0.12247656f, -0.00020788f, 0.01088716f, 
    -0.00707322f, -0.22299595f, -0.03292769f, -0.00037648f, -0.02077201f, 0.00499708f, -0.05350298f, -0.09805292f, 
    0.08169799f, -0.02764233f, 0.00558211f, 0.05023417f, -0.09954475f, -0.14636256f, 0.12446002f, 0.10992346f, 
    -0.13640799f, -0.05683634f, -0.15890594f, 0.00800055f, 0.08829034f, 0.06125531f, -0.03864213f, 0.18857378f, 
    0.00496761f, 0.11240255f, 0.03998675f, 0.01513528f, -0.22612455f, -0.06358604f, -0.08235956f, 0.05239588f, 
    -0.02139810f, -0.17484005f, 0.02046769f, -0.14564466f, -0.02833208f, -0.02834189f, 0.04475033f, 0.05923356f, 
    0.36688411f, -0.00970478f, -0.23339520f, 0.00269584f, -0.13280647f, -0.04603763f, -0.11609426f, -0.04819934f, 
    -0.03111285f, 0.03144367f, -0.03155209f, 0.01970070f, 0.10102118f, 0.02566509f, 0.05012847f, -0.10136573f, 
    -0.00888884f, 0.07493863f, 0.09188578f, 0.13290748f, -0.05437004f, 0.09270900f, 0.05247178f, 0.06174399f, 
    -0.13156235f, -0.02874239f, -0.06116571f, -0.04367801f, 0.18306427f, 0.01939390f, 0.07381424f, -0.06168625f, 
    0.07617743f, -0.02770368f, -0.01012213f, 0.02737872f, 0.02919402f, -0.08915012f, -0.01918416f, -0.08516950f, 
    0.03275185f, -0.01729633f, -0.15521862f, 0.01642296f, -0.06080655f, 0.11161038f, -0.07725155f, 0.08343686f, 
    0.30499080f, -0.24766648f, 0.04766325f, -0.29860881f, -0.04847777f, -0.12287920f, 0.03211688f, -0.03110155f, 
    -0.09863771f, 0.05789472f, 0.06720292f, 0.05418932f, 0.03260343f, 0.16836189f, 0.00675360f, -0.20126690f, 
    0.08423220f, -0.06066545f, -0.04426604f, 0.05042952f, 0.15194947f, -0.08701479f, 0.03365615f, -0.01513286f, 
    -0.35283300f, 0.08676989f, -0.16271237f, 0.04658033f, 0.09436611f, -0.17614082f, -0.05184297f, -0.07117514f, 
    -0.08680279f, -0.01874235f, -0.09914170f, 0.00636932f, -0.08163071f, -0.21265951f, -0.08275088f, -0.24555428f, 
    0.04200093f, 0.01979422f, 0.03316064f, 0.07378117f, -0.05964015f, 0.11383440f, 0.04882462f, 0.06567997f, 
    0.06488778f, -0.11879833f, 0.08912230f, -0.29080638f, 0.00759455f, -0.04735477f, -0.04786723f, 0.01823992f, 
    0.13804740f, -0.08804166f, 0.10116426f, 0.12755470f, 0.17217067f, 0.14178632f, 0.05283633f, 0.12626749f, 
    -0.03295683f, -0.06324281f, 0.07476494f, -0.00365502f, -0.01336428f, 0.00140679f, 0.01754097f, -0.00429531f, 
    0.25959569f, 0.14523880f, -0.02909911f, 0.09033092f, 0.13013443f, 0.06130832f, -0.07771667f, 0.02758242f, 
    -0.04136492f, 0.04621901f, 0.11813930f, -0.10488082f, 0.21646219f, -0.09839702f, 0.12089281f, -0.07629434f, 
    0.05228909f, -0.06993607f, -0.06171597f, 0.05981115f, -0.06238491f, -0.05499184f, 0.13218072f, 0.06038762f, 
    -0.25724304f, 0.03090053f, -0.07893354f, -0.12289815f, 0.07902540f, -0.07975271f, -0.02628648f, 0.02278671f, 
    0.16684173f, 0.03388979f, -0.07461939f, 0.05782035f, 0.20769919f, -0.23424576f, 0.31621441f, -0.24664119f, 
    0.08284975f, -0.06418984f, -0.00393470f, -0.07081848f, -0.04726918f, -0.14431183f, 0.03770339f, 0.14530112f, 
    -0.20862994f, -0.02577345f, 0.01477068f, -0.12590919f, -0.05033688f, -0.05223189f, -0.07176144f, 0.20809782f, 
    0.07846034f, -0.19748849f, -0.08762758f, -0.05516996f, 0.12819208f, -0.04845690f, 0.08046615f, -0.11443081f, 
    0.05714168f, -0.09828171f, -0.06434352f, 0.00597782f, -0.21083143f, 0.02206226f, -0.00567984f, -0.08817534f, 
    -0.12369522f, -0.14068630f, -0.07661342f, -0.00646363f, 0.04405782f, -0.10970825f, -0.11988971f, 0.01238211f, 
    0.05075828f, 0.08879228f, 0.00006482f, 0.10522850f, -0.06026763f, -0.02854367f, -0.02454586f, -0.33818728f, 
    0.03744255f, 0.03753376f, 0.02510949f, 0.01165274f, 0.03188879f, -0.04316648f, 0.04222522f, 0.01385678f, 
    0.08624900f, 0.00142261f, 0.00527958f, 0.26553804f, -0.08937039f, -0.06163944f, 0.01607722f, 0.01784393f, 
    0.08289623f, 0.04682002f, -0.09056696f, 0.11097460f, 0.06499689f, -0.31884694f, 0.06800265f, -0.22371989f, 
    0.07738465f, -0.07046369f, -0.00270088f, 0.09601578f, -0.02559277f, 0.05990346f, 0.03416912f, -0.03218671f, 
    0.09191006f, -0.08691936f, 0.00603421f, -0.05341395f, 0.02587414f, -0.03771964f, 0.03494198f, 0.02040990f, 
    -0.04794564f, 0.03072059f, 0.01381719f, 0.09081373f, 0.12294897f, -0.02211189f, -0.05433469f, 0.02262873f, 
    -0.02872197f, 0.08921142f, -0.16374138f, 0.03717669f, 0.01252591f, 0.08153423f, -0.08593076f, -0.00344726f, 
    0.23614313f, -0.11182347f, -0.04874134f, -0.18032824f, -0.02393037f, -0.05921726f, 0.01763387f, 0.05995112f, 
    -0.17213769f, -0.07220025f, -0.11630170f, -0.03133289f, 0.09317939f, 0.08241586f, -0.02075966f, 0.13214661f, 
    0.00174263f, 0.09255985f, 0.00530388f, 0.03986743f, 0.02186337f, 0.12905888f, 0.01751131f, -0.05862415f, 
    0.09620669f, -0.01721644f, -0.09279314f, -0.09804048f, -0.08776747f, 0.14777912f, 0.03517685f, 0.03697732f, 
    0.02690976f, -0.11670113f, -0.02675317f, -0.16035914f, -0.49185789f, 0.00806244f, -0.08851039f, -0.26514456f, 
    0.00494950f, 0.12020649f, -0.06894481f, -0.15688893f, 0.17352483f, 0.09929991f, -0.01611229f, -0.05594343f, 
    -0.23761050f, 0.01849612f, 0.04718302f, -0.07475659f, 0.09680334f, 0.04081475f, -0.02279358f, -0.07457214f, 
    -0.05891192f, 0.03277270f, 0.01207794f, -0.03656619f, -0.20571576f, 0.06427553f, -0.20113377f, -0.06314602f, 
    -0.02521932f, 0.00227440f, -0.03774716f, -0.06944509f, -0.03439359f, 0.01728495f, -0.08143117f, -0.00626434f, 
    0.06737849f, 0.02785470f, -0.12390470f, -0.08536773f, -0.08725051f, -0.09763271f, -0.06997199f, -0.02743208f, 
    0.06240967f, -0.07927459f, -0.00742333f, -0.04410202f, 0.24774648f, 0.02820676f, 0.25851813f, 0.15519670f, 
    -0.10197925f, -0.09225681f, 0.03193627f, 0.05715054f, 0.01428073f, 0.06800238f, 0.01649338f, 0.02886394f, 
    0.24011546f, 0.16026491f, -0.06800535f, 0.04791946f, 0.05275090f, 0.04162182f, 0.05077233f, 0.03427864f, 
    -0.06144053f, -0.07772521f, -0.01242474f, -0.03258052f, -0.16307385f, -0.17196289f, -0.19729075f, -0.37933692f, 
    -0.00054358f, -0.01962787f, -0.06791443f, -0.13225156f, 0.01198215f, 0.04718897f, -0.02462894f, 0.03522832f, 
    -0.34145269f, -0.02219521f, 0.00897502f, -0.10932138f, -0.04505881f, 0.01673783f, -0.02027765f, 0.01686571f, 
    -0.06409837f, 0.03679815f, -0.04527847f, -0.07043438f, 0.31366834f, 0.00482722f, -0.02071045f, 0.02506438f, 
    -0.13916166f, -0.04446856f, -0.12291751f, -0.01976845f, 0.10730252f, 0.02648698f, 0.02215362f, 0.03719309f, 
    -0.08335148f, 0.13104106f, 0.03906707f, -0.05322523f, 0.02367626f, 0.06176494f, 0.04720694f, -0.01755735f, 
    0.00622291f, 0.01063772f, -0.01123949f, -0.05153758f, -0.36640701f, -0.03641713f, 0.06618006f, -0.24974665f, 
    -0.04541403f, 0.02744709f, -0.00110536f, -0.08681059f, -0.02235513f, -0.07149943f, -0.06683658f, -0.05004863f, 
    0.42674583f, -0.07632707f, -0.00014403f, 0.05289487f, -0.18221286f, -0.00598300f, -0.00053208f, -0.01011265f, 
    0.05487113f, -0.01001817f, -0.02007923f, -0.04818873f, 0.06395841f, -0.04725736f, -0.02468589f, -0.05512762f, 
    0.04926808f, 0.02655279f, 0.02690152f, 0.08358932f, -0.00056573f, -0.02515033f, 0.07633509f, -0.09128681f, 
    0.05463754f, 0.00339116f, -0.11881424f, -0.01361483f, -0.02638947f, 0.03513544f, -0.00316875f, 0.03986605f, 
    0.01968073f, -0.01875198f, 0.05251131f, -0.05297460f, 0.14357702f, -0.06627183f, -0.10702379f, 0.08028483f, 
    0.09062400f, 0.01046295f, 0.03621395f, -0.04319170f, 0.03380185f, 0.05303947f, -0.10640813f, -0.01407240f, 
    -0.03254487f, 0.07571495f, -0.25106406f, -0.13057965f, 0.01200024f, 0.05677128f, -0.03567275f, -0.05169607f, 
    0.00645380f, -0.04967240f, -0.02250630f, 0.01256495f, 0.42668825f, -0.06908541f, -0.08887680f, 0.06260184f, 
    0.04074017f, 0.05843012f, 0.02550902f, -0.08617467f, -0.05203818f, -0.07696344f, 0.03297139f, 0.03139633f, 
    -0.31379831f, 0.07828696f, -0.01351526f, -0.33866841f, 0.00106687f, 0.04128582f, 0.03447157f, -0.00596216f, 
    -0.07677867f, -0.03744802f, -0.06318366f, -0.05487843f, 0.15900679f, 0.10894342f, 0.07320844f, 0.06305062f, 
    -0.03010248f, 0.00790009f, 0.06757241f, -0.00734733f, -0.00767526f, 0.05396458f, 0.04237061f, 0.07172841f, 
    0.24826807f, -0.07240975f, -0.12812610f, 0.22737774f, -0.10988783f, -0.03974131f, 0.00716484f, -0.00086496f, 
    0.11413798f, 0.10926482f, -0.03575053f, -0.04149744f, 0.18226464f, -0.09986512f, 0.07944036f, 0.07348485f, 
    -0.14635749f, -0.07109845f, 0.01265607f, -0.02781276f, -0.01100414f, -0.04454137f, 0.05405966f, -0.01218862f, 
    -0.08049265f, -0.03546640f, -0.02689797f, -0.06468908f, -0.03487077f, 0.02284894f, -0.03190688f, 0.04832615f, 
    0.00768302f, 0.02399309f, -0.00518489f, 0.00532959f, -0.05649855f, 0.05574936f, -0.11604705f, -0.09927811f, 
    0.01629865f, 0.07608393f, -0.00532342f, -0.01629208f, 0.01649721f, -0.01900600f, -0.02915720f, -0.03674206f, 
    0.04200974f, -0.00624853f, -0.09798536f, -0.16283740f, 0.14549185f, 0.00255741f, 0.03505285f, -0.10746314f, 
    0.01463767f, -0.04636966f, 0.06229352f, 0.01011334f, 0.45259479f, -0.07481501f, -0.07408360f, -0.01015728f, 
    -0.05967760f, 0.02479070f, -0.00168048f, 0.08946362f, -0.00442573f, 0.01020660f, 0.03237690f, -0.12430345f, 
    0.37980062f, -0.05309188f, 0.06162107f, -0.08580326f, -0.12244926f, 0.00236044f, -0.08615050f, 0.03216530f, 
    0.11318034f, -0.04750735f, 0.06315707f, -0.04876118f, -0.19688641f, -0.01896157f, 0.05173253f, -0.19187050f, 
    0.02348975f, -0.00500702f, 0.01621773f, 0.01661445f, -0.01551287f, 0.03057364f, 0.00976332f, 0.00170161f, 
    -0.32301885f, 0.02009496f, -0.15901694f, -0.05727134f, 0.01192706f, -0.04026594f, 0.03358194f, 0.00646172f, 
    0.06231415f, 0.05301811f, -0.04781253f, 0.01763695f, -0.03758409f, 0.13727026f, -0.07542340f, 0.04380374f, 
    0.02540414f, 0.06360243f, 0.00601153f, 0.00615769f, -0.13710374f, 0.00187583f, -0.01169902f, -0.12913400f, 
    0.07948560f, -0.06660309f, -0.00433054f, 0.09439623f, 0.09883162f, -0.01482604f, -0.03372798f, -0.10760556f, 
    0.03211384f, -0.01224788f, -0.08058906f, 0.08083897f, 0.25292337f, 0.06875570f, -0.05312590f, -0.16270092f, 
    -0.10696091f, 0.08195519f, 0.04534113f, 0.03187784f, -0.02106158f, 0.00066353f, -0.09221864f, -0.02773520f, 
    0.12294694f, 0.07004835f, -0.22481784f, -0.05296598f, 0.07147616f, -0.01548880f, -0.07673351f, -0.07809350f, 
    0.02348280f, 0.02208121f, -0.08176063f, -0.00024896f, 0.27730769f, -0.20037384f, -0.18819208f, -0.08786336f, 
    -0.04367388f, 0.12127633f, 0.03528919f, 0.01039810f, -0.03592185f, -0.01080438f, 0.03755877f, -0.02184458f, 
    -0.06125927f, -0.01272731f, 0.07377096f, -0.00876151f, -0.00481999f, 0.03382532f, 0.01700492f, -0.04276627f, 
    -0.05356688f, 0.02837726f, -0.01380776f, 0.03594024f, 0.04912191f, 0.11754043f, -0.01963321f, -0.07317818f, 
    -0.10262962f, -0.01097840f, 0.03865208f, 0.06427775f, -0.08099298f, -0.07693366f, 0.03196809f, 0.02464580f, 
    0.06504784f, -0.00870902f, 0.01852812f, 0.00870394f, 0.05334966f, -0.00321827f, 0.03383811f, 0.02880121f, 
    -0.04642345f, 0.04284831f, -0.00881185f, -0.10148098f, 0.05586678f, -0.02693621f, -0.25309485f, -0.02853738f, 
    0.00737177f, -0.02624851f, -0.00452527f, -0.06209100f, -0.02155344f, 0.01698998f, -0.17350265f, -0.02055646f, 
    0.23350820f, 0.02425575f, 0.04428714f, 0.05474755f, -0.05450435f, -0.14863676f, -0.02206659f, 0.10601456f, 
    0.01834465f, -0.01491534f, -0.07454470f, -0.04549168f, 0.11786442f, -0.06795134f, 0.12915018f, -0.19798808f, 
    -0.13182774f, 0.10593863f, 0.04656452f, 0.09110928f, -0.08226193f, -0.09736054f, 0.03153893f, -0.09343365f, 
    0.22985543f, 0.09809011f, -0.04500632f, 0.15032624f, 0.01177945f, -0.07644093f, -0.00326721f, 0.06164618f, 
    -0.04169214f, 0.05059214f, 0.04396231f, -0.03393639f, -0.02272850f, 0.07738411f, -0.01310937f, -0.02433007f, 
    0.01782347f, -0.01832358f, -0.01767682f, 0.02327469f, -0.13228631f, -0.13233249f, 0.05771115f, -0.01968643f, 
    -0.17392667f, 0.06796163f, -0.19912294f, -0.01534173f, 0.04378088f, 0.08881154f, -0.04945963f, -0.10456735f, 
    -0.11630653f, 0.05472175f, -0.05947176f, -0.00568547f, -0.13445571f, -0.14112361f, 0.13071030f, -0.09122437f, 
    0.01888076f, -0.03730255f, 0.00812628f, -0.02212715f, -0.01860038f, -0.05186074f, 0.02276368f, -0.09935272f, 
    0.00203855f, -0.08690246f, 0.11001571f, -0.17390634f, -0.13701229f, -0.08076504f, 0.08600154f, -0.01630822f, 
    -0.07660138f, -0.01014178f, 0.04236585f, -0.07051173f, 0.15267967f, 0.04722005f, -0.06975771f, 0.10256300f, 
    -0.05744025f, 0.06391774f, 0.02322005f, -0.03004130f, -0.01932741f, -0.00690121f, 0.08306774f, 0.02845256f, 
    -0.08612799f, -0.01140711f, -0.10046105f, -0.04077697f, -0.21203402f, 0.08401124f, 0.03742449f, -0.03952674f, 
    -0.00752146f, 0.03487200f, 0.00122727f, -0.02210746f, -0.27661058f, -0.16825438f, -0.15901887f, -0.16461921f, 
    0.02708241f, -0.04509410f, -0.05060119f, -0.03547512f, -0.03672755f, -0.06553749f, 0.06531481f, 0.00359227f, 
    -0.25151750f, 0.04705413f, 0.15763636f, 0.17154112f, -0.09010418f, -0.06809772f, -0.01047124f, 0.00526108f, 
    -0.03406762f, 0.05378756f, -0.08566389f, 0.12491933f, 0.06178251f, 0.01287999f, -0.07963036f, -0.02111885f, 
    -0.01298538f, -0.00368111f, -0.06788401f, 0.02475915f, 0.00491595f, 0.08283143f, -0.02032404f, -0.02594251f, 
    -0.05252112f, -0.07531453f, -0.03833492f, -0.03153634f, -0.05762568f, 0.01547760f, -0.00521886f, 0.00510840f, 
    0.03725866f, 0.08204792f, 0.03608258f, -0.06433478f, -0.02423608f, 0.08450894f, 0.06928051f, 0.04342382f, 
    0.01452451f, -0.04013827f, 0.04922438f, 0.00919331f, -0.01084547f, -0.05923422f, -0.05307660f, -0.02618579f, 
    0.00008477f, -0.00114980f, -0.00940028f, 0.01117058f, -0.07436550f, -0.03016304f, -0.17414521f, -0.06228185f, 
    -0.04374703f, -0.01562424f, 0.03851734f, 0.11999509f, 0.04517990f, -0.02419123f, 0.01042236f, 0.06097538f, 
    -0.02514376f, 0.02885334f, 0.10182952f, 0.12683801f, -0.02469623f, 0.05667314f, -0.06193423f, 0.06597577f, 
    -0.30142915f, -0.08373685f, -0.05768200f, -0.03899004f, -0.03083916f, 0.01487773f, 0.02385256f, 0.01188004f, 
    0.03115014f, 0.02209770f, -0.03660327f, -0.01028210f, -0.25649166f, 0.12464377f, 0.04529338f, 0.01026008f, 
    -0.04730789f, -0.04911418f, 0.04607602f, 0.02675785f, -0.02858642f, -0.11023866f, 0.04266525f, -0.01019116f, 
    0.11582547f, -0.01233739f, -0.13678300f, 0.07082029f, 0.05766686f, 0.04339752f, 0.03365335f, -0.12342864f, 
    -0.07742872f, -0.06110604f, -0.06348391f, -0.00002138f, -0.30573288f, -0.05158975f, -0.25128746f, -0.10058966f, 
    -0.04310759f, 0.00522477f, -0.08684217f, -0.10295720f, 0.06220473f, 0.01079679f, 0.00338277f, 0.03901780f, 
    -0.18002224f, 0.04027658f, -0.04937986f, -0.05634508f, 0.05857536f, -0.03420767f, -0.06491102f, -0.11164741f, 
    0.06457746f, -0.06041125f, 0.02115642f, -0.02794734f, -0.29250097f, 0.08964017f, 0.03337537f, 0.14905882f, 
    0.01642346f, -0.09589365f, 0.02979036f, 0.04837280f, -0.04402476f, -0.02604287f, 0.05305406f, 0.01807226f, 
    0.07674859f, 0.06446587f, 0.09865201f, 0.19921833f, -0.09046907f, -0.09649731f, 0.03443462f, 0.05893369f, 
    0.03859239f, 0.03482556f, -0.09697674f, -0.05361422f, 0.14533119f, -0.11701645f, -0.02521478f, 0.03307157f, 
    -0.05528017f, 0.02706007f, -0.08594846f, 0.02658234f, 0.00941253f, -0.01687199f, 0.06234036f, 0.00645382f, 
    0.07893816f, -0.09405027f, 0.05557606f, -0.14993142f, 0.06008841f, 0.02511983f, -0.00781026f, 0.03570891f, 
    0.03706230f, 0.05277070f, 0.06234393f, -0.02838565f, -0.22820997f, -0.08330222f, 0.09949518f, -0.00660957f, 
    -0.00946425f, -0.06366094f, -0.07301848f, -0.02150743f, 0.05844212f, 0.02576188f, 0.02465935f, -0.06977271f, 
    0.23894712f, -0.02781730f, -0.18808456f, -0.12026145f, -0.07317910f, -0.04941619f, -0.05453696f, -0.02303743f, 
    0.04315250f, -0.02037244f, -0.05052916f, -0.05105706f, 0.33149397f, 0.13486055f, -0.11373565f, 0.08844964f, 
    0.06591053f, 0.07630716f, 0.08828960f, 0.01596739f, -0.21422720f, 0.13929968f, 0.00141201f, -0.11710139f, 
    0.22728083f, 0.15294924f, 0.00913578f, 0.09495536f, -0.02067414f, -0.04403065f, 0.04183915f, 0.04420728f, 
    -0.08975954f, 0.00788803f, 0.00514786f, 0.00509518f, 0.24360554f, 0.02077442f, -0.24303022f, -0.03138484f, 
    -0.02447509f, 0.05697844f, -0.01446100f, 0.08491009f, 0.02505087f, -0.04314509f, -0.16661566f, -0.04763239f, 
    0.06461376f, 0.09313625f, 0.05580026f, 0.03594394f, -0.03408998f, -0.08754343f, -0.00563368f, -0.01224261f, 
    -0.04455551f, 0.01717137f, 0.07780880f, -0.12678333f, -0.04965250f, -0.05599647f, -0.03049645f, -0.00475486f, 
    -0.07461911f, -0.06266489f, 0.09615708f, -0.01109796f, -0.11193375f, 0.00037833f, 0.00825645f, 0.00297456f, 
    -0.13960838f, 0.20741571f, -0.01278231f, -0.28797382f, 0.05523121f, 0.00294488f, 0.11165646f, 0.07044114f, 
    -0.03358911f, -0.06854153f, -0.01001055f, -0.00815003f, 0.30810332f, 0.14740701f, -0.01345434f, 0.10832612f, 
    0.04282753f, 0.09354337f, -0.03792289f, 0.05693103f, 0.00662334f, 0.03816988f, -0.01594061f, 0.02904347f, 
    0.11337266f, -0.27560133f, -0.21982484f, 0.03719814f, -0.10855053f, 0.08517449f, -0.00374434f, 0.14854306f, 
    0.03915590f, 0.04243714f, 0.02202300f, -0.06462522f, -0.01776323f, 0.14355907f, 0.07693832f, -0.07253949f, 
    -0.05232531f, 0.04309617f, -0.02885831f, 0.02009951f, -0.04679027f, -0.09507407f, 0.16601387f, 0.00841348f, 
    -0.14751430f, -0.17383619f, -0.11105140f, 0.09764384f, -0.06247646f, 0.11337274f, 0.06839332f, -0.17476936f, 
    0.02044165f, -0.03116546f, -0.06201946f, 0.05658553f, 0.03944933f, 0.01404133f, -0.01467106f, -0.05852532f, 
    0.00921264f, 0.12413603f, 0.01211709f, 0.07487950f, 0.02897594f, 0.11529499f, -0.00453237f, 0.13014963f, 
    0.24129324f, -0.00011519f, 0.00193977f, -0.05748289f, -0.06033309f, -0.01406958f, 0.01253296f, -0.07705042f, 
    -0.01226343f, 0.05717376f, 0.03047091f, 0.00002797f, -0.38827538f, -0.30967465f, -0.25917554f, 0.03038447f, 
    -0.08675371f, -0.04289472f, 0.05247943f, 0.07647593f, 0.02963745f, 0.00054300f, 0.06948418f, -0.00157347f, 
    0.06587585f, 0.07267766f, 0.12879373f, -0.15213926f, 0.04228310f, -0.04642889f, -0.03593897f, 0.02760652f, 
    0.00332046f, -0.08444224f, 0.03152656f, -0.00873119f, 0.23317561f, -0.36422384f, -0.16937712f, 0.25937340f, 
    0.00309018f, 0.09895547f, 0.09607723f, -0.00991867f, -0.04632157f, -0.01158661f, -0.04621119f, -0.06291714f, 
    -0.42306364f, 0.14230229f, -0.16386795f, -0.03190926f, -0.01189830f, 0.04442653f, 0.03151171f, 0.07533980f, 
    -0.16239034f, 0.04863732f, 0.06989423f, -0.04439234f, -0.43692046f, 0.03774412f, 0.37761185f, 0.01172543f, 
    -0.00580796f, 0.11645231f, -0.01125100f, -0.01516799f, -0.01181099f, 0.05268050f, -0.12349806f, -0.07562609f, 
    0.28378719f, 0.02086488f, 0.06220198f, 0.02496011f, -0.00233863f, -0.05315726f, -0.04260953f, 0.01239748f, 
    -0.06298184f, -0.08052719f, -0.05212884f, -0.00003976f, -0.58420509f, -0.12226963f, 0.04727430f, -0.24503720f, 
    0.06391219f, 0.08416988f, -0.00523343f, -0.02414964f, -0.06067972f, -0.02165751f, -0.02283732f, 0.00542191f, 
    0.20421925f, 0.00381775f, 0.03995409f, 0.01840118f, -0.05868375f, -0.08871715f, -0.06476773f, -0.09466759f, 
    -0.17353319f, 0.05641834f, 0.03523939f, 0.00493200f, 0.07495740f, -0.01405308f, -0.03049363f, -0.10256645f, 
    -0.17001344f, -0.16822319f, 0.05402033f, 0.01370547f, -0.02721517f, -0.09597418f, 0.10005367f, 0.03106923f, 
    0.00041653f, 0.08582494f, -0.03902330f, 0.02424627f, -0.02299030f, 0.06685784f, -0.10762651f, -0.01064031f, 
    -0.02824248f, 0.01397899f, -0.00741476f, 0.00900990f, 0.02222103f, -0.05498703f, -0.02465167f, 0.09632569f, 
    0.01103404f, 0.05087344f, 0.06382329f, -0.25390735f, 0.10729990f, 0.03134977f, 0.04166680f, -0.04442288f, 
    -0.19644915f, -0.46198991f, -0.18273170f, -0.15630363f, -0.06794368f, -0.03180627f, 0.02055629f, -0.00776007f, 
    -0.03434975f, -0.05294409f, 0.04224085f, 0.00020718f, -0.04788756f, -0.03961762f, 0.14874431f, -0.03760276f, 
    0.06939077f, -0.01160733f, 0.01375485f, 0.02291108f, -0.04539626f, -0.03664047f, -0.07799593f, -0.10281768f, 
    0.08017623f, 0.19078398f, 0.08784941f, 0.06492057f, -0.03358691f, 0.04369025f, -0.00144259f, 0.03543841f, 
    -0.05708658f, 0.00430836f, 0.03095735f, 0.05852108f, -0.04966256f, -0.05556029f, 0.08945235f, 0.04408049f, 
    -0.02894352f, -0.03689733f, 0.02168882f, 0.05915178f, -0.09990785f, -0.00327224f, 0.01073901f, -0.05703396f, 
    0.15406847f, 0.01257474f, 0.14036590f, -0.02412608f, 0.03677222f, 0.01674647f, -0.05723185f, 0.06934304f, 
    0.08307547f, 0.06115652f, -0.04242305f, -0.00353452f, 0.34681404f, 0.13814306f, -0.27432251f, 0.26121166f, 
    0.07712302f, -0.00323075f, 0.04038629f, 0.14686945f, -0.02709061f, 0.01103778f, -0.04985044f, -0.04076130f, 
    0.24574110f, -0.24529758f, -0.01565896f, 0.13014343f, -0.02904274f, 0.03339234f, -0.05618254f, -0.00110074f, 
    -0.04277144f, -0.10783899f, -0.00369320f, 0.01769281f, 0.13690902f, 0.07598452f, 0.07041747f, -0.13215138f, 
    0.06416608f, -0.06094662f, 0.02981890f, 0.16192688f, -0.00392593f, 0.05300638f, -0.09227918f, -0.01883778f, 
    -0.18945636f, 0.09364412f, 0.27080935f, 0.01898223f, 0.09808899f, -0.01556200f, 0.01807480f, 0.08646016f, 
    0.02650744f, -0.03579927f, 0.00261861f, -0.03491918f, 0.04205391f, 0.09036242f, 0.02655913f, 0.00801586f, 
    0.17227165f, 0.03019788f, -0.03616822f, 0.04541817f, -0.00835207f, 0.15811312f, 0.05741683f, 0.04070484f, 
    -0.28913102f, -0.29781434f, -0.14375657f, 0.06275071f, -0.08513328f, -0.07928530f, 0.01336160f, -0.03528424f, 
    0.03635858f, -0.00043612f, 0.05159095f, 0.04419767f, -0.28106064f, -0.35284775f, -0.12693509f, 0.13789794f, 
    -0.11363471f, 0.00920586f, 0.00333937f, -0.04053533f, 0.01486186f, -0.13675578f, -0.02833492f, 0.04913372f, 
    -0.03349411f, -0.36514023f, -0.39119333f, 0.02936711f, -0.14802681f, 0.07684992f, -0.08391626f, -0.09998097f, 
    0.00788560f, 0.05895922f, -0.14208347f, -0.02118119f, -0.02133032f, 0.13399781f, -0.06310686f, -0.07340451f, 
    -0.05814056f, -0.03803331f, 0.02297879f, 0.03810515f, 0.01311801f, -0.02940302f, 0.02982468f, 0.01555541f, 
    -0.15154612f, 0.07540364f, -0.10431007f, -0.01479590f, 0.00057812f, -0.01254640f, 0.06075869f, 0.00868124f, 
    -0.04131347f, -0.03351761f, -0.04214257f, -0.03403336f, -0.43175739f, 0.15046056f, -0.04449193f, 0.04949478f, 
    -0.01866063f, -0.03797371f, 0.02651249f, 0.04088805f, 0.07714285f, -0.10927486f, 0.04448127f, -0.00049451f, 
    -0.06609290f, -0.05978535f, 0.05549107f, -0.06124684f, -0.10375483f, 0.00735168f, 0.10471742f, -0.04154519f, 
    0.04863261f, 0.03928872f, -0.06561600f, 0.13519993f, -0.01391720f, -0.03191129f, -0.01381924f, 0.01431127f, 
    0.11393093f, -0.14440075f, 0.02049435f, 0.00096034f, 0.09479190f, -0.10351289f, -0.05062250f, 0.00123559f, 
    -0.06357412f, -0.12256273f, 0.09400820f, 0.22532664f, 0.03528860f, 0.16368957f, -0.01312509f, -0.02867972f, 
    0.01157951f, -0.03594976f, -0.02377945f, -0.09848626f, 0.17961429f, 0.07670970f, -0.02709653f, 0.22410850f, 
    0.01275528f, 0.07738324f, -0.08845784f, 0.01694193f, 0.03312560f, -0.10994997f, -0.02938647f, -0.07172566f, 
    0.03010247f, -0.08111733f, -0.04200700f, -0.03410584f, -0.13408345f, 0.05582932f, -0.03343717f, 0.07969909f, 
    -0.02402680f, -0.07116146f, -0.01457250f, 0.00783363f, -0.44329733f, 0.20487726f, -0.04495135f, -0.12195487f, 
    0.02695980f, 0.11983196f, -0.03023769f, 0.10533261f, 0.01660641f, 0.12701079f, -0.01367395f, 0.01790309f, 
    -0.06593789f, -0.00555345f, 0.11165418f, -0.04012322f, -0.05202530f, 0.04660783f, -0.00779189f, 0.09024081f, 
    0.02530326f, 0.03091710f, 0.02837880f, -0.02656477f, 0.14422175f, 0.09218314f, 0.09741029f, 0.05469197f, 
    -0.04109189f, -0.04262914f, 0.01681873f, -0.06908043f, 0.02129438f, 0.11314031f, -0.08807807f, -0.06465088f, 
    0.03758726f, 0.09679709f, -0.11808451f, -0.01938844f, -0.08324113f, -0.07165057f, 0.10418396f, -0.08740874f, 
    -0.06372467f, 0.05798387f, 0.00238300f, -0.00045324f, -0.30496228f, -0.36307761f, -0.16382504f, -0.03100701f, 
    -0.11630569f, 0.00741971f, 0.04232832f, 0.01182645f, 0.02303698f, -0.01250996f, 0.00165772f, 0.02533477f, 
    -0.27442798f, -0.16090116f, -0.08535220f, -0.15202640f, -0.09524491f, 0.09045658f, 0.00860217f, -0.08802424f, 
    0.11865245f, 0.05377328f, 0.00515364f, 0.03715625f, -0.19503528f, -0.13725927f, -0.18906972f, -0.19682336f, 
    -0.11149605f, -0.11690149f, -0.05012958f, -0.02630019f, -0.05747071f, 0.03158582f, -0.15876652f, 0.16878377f, 
    0.11088514f, 0.05980611f, 0.01849547f, -0.02874658f, -0.06806081f, -0.03674962f, 0.03316178f, 0.11292052f, 
    0.08651351f, -0.12956117f, 0.00287936f, 0.01762994f, 0.12152486f, 0.01250586f, 0.05261104f, 0.11541250f, 
    -0.08980384f, 0.07930071f, 0.01142472f, 0.06299593f, -0.08197422f, 0.05893716f, 0.00299710f, 0.02910728f, 
    0.09471849f, 0.22771844f, 0.15766889f, 0.06087394f, 0.03371964f, 0.03586532f, -0.08614349f, 0.00773339f, 
    -0.02473617f, 0.03575842f, 0.04586747f, -0.01975694f, 0.07600536f, -0.27415761f, -0.08010910f, 0.03644809f, 
    -0.06393665f, -0.08229898f, 0.01496114f, 0.12743732f, 0.02639714f, 0.07619980f, 0.05986777f, -0.01051644f, 
    0.05787213f, -0.07083336f, 0.12161513f, 0.24334168f, 0.09101211f, 0.11462847f, -0.01390490f, -0.03432297f, 
    0.01140633f, -0.07359449f, -0.05623065f, -0.10274189f, 0.08801776f, 0.06708035f, 0.00966833f, -0.03834292f, 
    -0.09881413f, -0.02803448f, 0.00882707f, 0.03220348f, 0.03381682f, -0.01031226f, 0.00931345f, 0.10429621f, 
    -0.10008719f, -0.32067180f, -0.03984375f, 0.06970741f, -0.03859212f, 0.05581584f, -0.02905358f, -0.10564521f, 
    -0.04698601f, -0.05337776f, -0.00566430f, 0.00396733f, -0.15165229f, -0.23314692f, 0.03275368f, -0.04272049f, 
    -0.15098803f, 0.09571506f, 0.02110137f, 0.04834465f, -0.00093269f, 0.10207836f, -0.03999176f, 0.04153044f, 
    -0.02805110f, -0.05539483f, -0.13609664f, -0.26970574f, -0.21698420f, -0.03563986f, -0.08012146f, 0.01606390f, 
    -0.00264181f, -0.11729100f, -0.03556083f, 0.02367788f, -0.14982182f, 0.06744736f, 0.08993966f, -0.01652559f, 
    0.04243838f, -0.01836945f, 0.01351691f, 0.00857202f, -0.02938035f, -0.06486349f, 0.03051774f, -0.09332060f, 
    0.10659615f, -0.15963237f, -0.10321379f, 0.02545905f, 0.00846960f, 0.04223924f, -0.04152938f, -0.02669877f, 
    0.03080106f, 0.00633306f, 0.04010633f, -0.01192112f, -0.12283841f, -0.09147953f, -0.01669324f, 0.11587314f, 
    -0.00398567f, -0.03543116f, 0.02606399f, 0.04244161f, 0.04232472f, 0.00576123f, -0.00972575f, -0.05031820f, 
    -0.22251962f, 0.22064576f, 0.04026496f, 0.13485269f, 0.09731703f, 0.01083039f, -0.04768858f, 0.01173582f, 
    -0.00881916f, -0.01249907f, -0.01956081f, 0.11844785f, 0.22344719f, 0.18756489f, 0.03362787f, -0.08086749f, 
    -0.09043747f, -0.01557943f, -0.03219368f, 0.22167748f, 0.03563425f, 0.03924514f, 0.03311933f, 0.00641494f, 
    -0.15507829f, 0.08427123f, 0.01662852f, -0.24292034f, -0.02805603f, -0.01297545f, -0.07417576f, -0.06226196f, 
    -0.00670758f, -0.09944469f, -0.01739769f, 0.09576578f, -0.26445609f, 0.33299720f, 0.09119118f, 0.17770834f, 
    0.05663340f, -0.00049429f, 0.09038924f, 0.05258003f, -0.02564435f, -0.15160163f, 0.02445806f, 0.07831459f, 
    0.03421531f, -0.04275435f, 0.05179581f, 0.00484089f, 0.04264113f, -0.12324156f, -0.06284019f, 0.08643448f, 
    0.00498145f, -0.13591406f, -0.06079996f, 0.04019183f, -0.68666852f, 0.00502367f, 0.18002495f, 0.19214790f, 
    0.11738854f, 0.04781781f, -0.03085944f, 0.05950027f, -0.05690018f, 0.03114204f, 0.03023014f, -0.04526320f, 
    -0.02350038f, -0.16924948f, 0.01588911f, -0.08773014f, 0.11844556f, -0.08831090f, 0.11724729f, 0.11085431f, 
    -0.03520595f, -0.00190369f, -0.02528246f, 0.02947059f, -0.03484086f, -0.04735162f, 0.14790151f, -0.17980134f, 
    0.08191626f, 0.05687668f, 0.02015829f, -0.06128963f, 0.03070114f, -0.09594452f, 0.02687144f, 0.10960716f, 
    -0.03673903f, -0.27615717f, 0.11573589f, -0.03929184f, -0.07928116f, 0.08849898f, 0.04768818f, -0.01044034f, 
    0.01973392f, 0.05550864f, 0.07845663f, 0.10207618f, -0.09028076f, -0.02667930f, -0.02970402f, -0.21085295f, 
    0.06963248f, 0.06164709f, 0.01807995f, 0.15805154f, -0.00725393f, 0.03522158f, -0.10276051f, -0.01483480f, 
    -0.11885288f, -0.43086824f, -0.02246880f, 0.05149441f, -0.09436758f, -0.08023781f, -0.02264319f, -0.00872014f, 
    0.04721393f, 0.02877885f, -0.02233367f, 0.01471002f, 0.20967062f, -0.00553153f, 0.03341238f, -0.10369931f, 
    -0.03911987f, 0.04249923f, 0.13268085f, -0.00635731f, -0.02880411f, 0.04828561f, 0.02936699f, 0.02945234f, 
    -0.55599755f, 0.03781561f, -0.10870921f, -0.13058187f, 0.09619787f, -0.02970872f, -0.02437046f, 0.04611617f, 
    -0.09860772f, 0.00161604f, -0.07973194f, 0.02435697f, -0.07244711f, 0.13244741f, -0.00678955f, -0.06865338f, 
    -0.01046885f, 0.02729096f, 0.02457464f, 0.13336030f, 0.04126040f, -0.08625919f, 0.02307378f, 0.05349043f, 
    0.19003130f, -0.02475116f, 0.05540721f, -0.11667109f, -0.00604188f, -0.00318646f, -0.06504907f, 0.04463933f, 
    0.01209395f, -0.12463164f, -0.04571976f, -0.05700942f, -0.24149361f, 0.10900799f, 0.13555969f, 0.06177967f, 
    -0.05399860f, 0.05315678f, 0.00557176f, 0.06686534f, 0.03359212f, 0.02135747f, -0.02736815f, -0.00964453f, 
    -0.33813974f, 0.02637177f, 0.25738987f, 0.01188457f, -0.00002003f, -0.04624335f, 0.10850220f, -0.07157677f, 
    0.11532442f, 0.00747351f, -0.09404149f, -0.04176214f, -0.49583253f, 0.02735551f, -0.02478244f, -0.00389807f, 
    -0.02805418f, -0.06849420f, 0.07144755f, -0.04228726f, -0.03816525f, -0.02346537f, -0.03234781f, -0.01963412f, 
    -0.13005701f, -0.03272577f, -0.09321535f, -0.06268663f, 0.06873812f, -0.01035507f, 0.04996122f, -0.10314196f, 
    -0.07048955f, -0.08757855f, 0.02201185f, 0.07908984f, -0.31512430f, 0.05399196f, 0.02201113f, 0.09200530f, 
    0.08049896f, -0.06196013f, -0.04144151f, -0.06487459f, -0.05578394f, 0.01406108f, -0.04466059f, -0.07857677f, 
    -0.08276504f, -0.03370659f, -0.08852395f, 0.19512056f, -0.01967204f, -0.08192106f, -0.03453242f, 0.09746883f, 
    -0.04416617f, 0.11888783f, 0.04501293f, 0.06979566f, -0.15985996f, 0.21441880f, -0.02155150f, 0.21161802f, 
    0.04469122f, -0.00690121f, 0.00209962f, 0.09481988f, 0.08121387f, 0.06023142f, 0.01107850f, -0.04882574f, 
    -0.63590091f, 0.33290240f, -0.04354158f, -0.16656198f, 0.09507985f, 0.00817102f, -0.07441900f, -0.04427923f, 
    0.07186576f, -0.00612302f, -0.06734891f, -0.13637380f, -0.15184547f, -0.03316693f, 0.06293932f, -0.00341870f, 
    0.10051559f, 0.00097225f, -0.09466852f, -0.11971460f, -0.00610050f, -0.17201798f, -0.03274041f, 0.02174107f, 
    0.25021616f, -0.12998267f, 0.13013367f, -0.00837853f, -0.20420679f, -0.16518351f, 0.13997960f, 0.03948309f, 
    0.03083305f, -0.04991375f, -0.07809527f, -0.05537215f, -0.27225268f, -0.17354544f, 0.06938739f, -0.14702547f, 
    -0.10615021f, -0.00043946f, 0.02010965f, 0.01311037f, -0.00838950f, 0.00233634f, -0.13093120f, -0.08232308f, 
    -0.30927795f, 0.05007275f, -0.02551232f, -0.13844796f, 0.04206024f, -0.10151649f, 0.08027086f, -0.05114393f, 
    0.00879577f, -0.06226913f, -0.03053856f, 0.09401198f, -0.23797899f, -0.14318839f, 0.08859225f, -0.17941593f, 
    0.09324888f, 0.02903459f, -0.07368933f, 0.00203420f, 0.11547483f, -0.05668954f, -0.06954964f, -0.15957387f, 
    0.33149353f, -0.02219575f, -0.02917508f, 0.06764395f, -0.03935434f, -0.04367316f, -0.04497642f, -0.02220406f, 
    -0.03672808f, -0.02812311f, 0.01006838f, 0.04974249f, -0.11358283f, 0.03693354f, 0.06365933f, -0.10760286f, 
    -0.19272575f, 0.04802896f, -0.06568176f, -0.05046583f, -0.10262797f, -0.00238704f, 0.05961658f, 0.00407128f, 
    -0.02788263f, 0.08063710f, -0.15196060f, -0.05136992f, 0.04714283f, -0.03256420f, 0.00599493f, 0.06429941f, 
    -0.05663626f, -0.07154068f, -0.04098714f, 0.04222196f, 0.23825699f, 0.22721764f, -0.18205249f, -0.44618919f, 
    0.04535954f, 0.00250136f, 0.01703736f, -0.09641635f, -0.03978942f, -0.03039325f, -0.05355431f, 0.04009400f, 
    -0.26416191f, 0.15789363f, 0.03628442f, 0.14440797f, 0.07814843f, -0.06973095f, 0.04470520f, -0.08322990f, 
    -0.00746608f, -0.02436638f, 0.01684893f, 0.02601127f, 0.25006837f, 0.04561476f, -0.04899573f, 0.18450312f, 
    -0.24837759f, -0.14279699f, 0.04048317f, -0.17873314f, 0.01425478f, 0.09810536f, 0.03276755f, 0.06065886f, 
    0.12522258f, 0.05467667f, -0.07840620f, -0.01603867f, -0.05166001f, -0.03824434f, 0.07654527f, 0.09200602f, 
    0.01093261f, -0.03646725f, 0.05231348f, -0.07765174f, 0.11435482f, -0.13890029f, -0.02995745f, 0.02303389f, 
    -0.06035288f, -0.03374287f, 0.00091938f, 0.01571471f, 0.05430136f, 0.04374004f, -0.01890317f, -0.05481224f, 
    -0.24944493f, -0.16608052f, 0.19585019f, -0.00197444f, -0.06778460f, 0.11350179f, 0.11150713f, 0.05821295f, 
    0.01714512f, -0.02466877f, 0.05353075f, 0.05472663f, 0.02560033f, -0.12916668f, 0.20910941f, 0.01433489f, 
    0.02236061f, 0.16053949f, 0.01606985f, -0.05946397f, 0.11873522f, -0.02383003f, -0.04747458f, 0.05833536f, 
    -0.32005507f, -0.03952536f, 0.06039556f, -0.10673091f, -0.09683961f, -0.07235442f, 0.09341242f, -0.03755160f, 
    0.13136093f, 0.09640653f, 0.02787767f, 0.00082784f, -0.29507944f, 0.10102793f, -0.14764561f, -0.20983352f, 
    0.06212722f, -0.04339509f, -0.24582762f, 0.08524261f, -0.08749066f, 0.04508941f, -0.02209033f, -0.04318575f, 
    -0.36451194f, -0.00824732f, 0.21126164f, 0.06698781f, 0.00963550f, 0.00950069f, 0.03354949f, 0.02732937f, 
    0.00748417f, 0.06079597f, 0.02630165f, 0.14735970f, 0.01959509f, 0.05071006f, 0.04177969f, 0.23153606f, 
    -0.02483020f, -0.07818442f, -0.02916179f, 0.05820575f, 0.07768901f, 0.02983646f, 0.07783162f, -0.09664783f, 
    -0.18467805f, -0.16005012f, 0.08021627f, 0.17133097f, -0.11119657f, -0.02961707f, -0.01750492f, -0.15515909f, 
    0.02863576f, 0.04246385f, -0.05354241f, -0.01354683f, -0.21702446f, 0.05380535f, 0.04193500f, 0.09409916f, 
    -0.03890370f, -0.03289568f, -0.02404195f, 0.08900782f, 0.09524646f, -0.16148216f, 0.06458902f, 0.08212961f, 
    0.16185538f, -0.16483817f, -0.06376467f, 0.14409314f, -0.08034232f, -0.02973130f, 0.12454872f, 0.02868116f, 
    -0.01358250f, -0.00099768f, -0.14668018f, -0.05192330f, 0.02122010f, -0.04249363f, 0.09076076f, 0.14382839f, 
    -0.10469640f, 0.05341225f, 0.02831288f, -0.12856130f, 0.00743706f, 0.02830939f, 0.07032501f, 0.02912509f, 
    0.02389577f, -0.04826809f, 0.01616349f, -0.13780057f, -0.02973181f, 0.14438796f, 0.02152332f, 0.05698474f, 
    -0.00463047f, -0.05333396f, -0.03913743f, 0.03672895f, 0.09033640f, -0.07633086f, -0.21578334f, -0.01838733f, 
    -0.02504789f, -0.06746158f, 0.04262569f, 0.02682656f, 0.00206067f, -0.05278934f, -0.02380259f, -0.13169228f, 
    -0.25888014f, -0.23258184f, -0.22335626f, 0.21347344f, 0.12323879f, -0.23635669f, -0.00883481f, -0.04414094f, 
    -0.17454529f, -0.04287968f, -0.07414049f, -0.07535841f, 0.18395230f, 0.12683558f, -0.01919641f, 0.01006826f, 
    0.07244371f, -0.03056216f, 0.00275270f, 0.04309082f, 0.00396775f, 0.07799851f, 0.03741195f, 0.10003313f, 
    -0.03657817f, -0.09059419f, -0.04815320f, 0.10670183f, -0.01775531f, 0.02100134f, 0.21988690f, 0.08010068f, 
    -0.06999257f, 0.02224070f, 0.08842848f, 0.03578477f, -0.15222947f, -0.16641340f, 0.06141008f, 0.00528195f, 
    -0.05773731f, 0.02551881f, -0.02976185f, -0.06773830f, -0.03271962f, -0.02301606f, -0.05327537f, -0.07446583f, 
    0.17122833f, -0.03746025f, -0.02239842f, -0.08448763f, 0.06992190f, 0.15990613f, -0.04074945f, 0.05530496f, 
    -0.15975541f, -0.04834763f, 0.03647926f, 0.01061943f, 0.01074363f, -0.15427306f, -0.22089811f, 0.15530358f, 
    0.01589249f, 0.06628320f, 0.08797798f, -0.07470246f, -0.07750022f, 0.07055667f, 0.11196450f, -0.11609697f, 
    0.18534032f, 0.07526991f, 0.04541391f, 0.04800801f, -0.04811021f, -0.05154756f, 0.02185767f, -0.00843930f, 
    0.00250808f, -0.05957104f, 0.04455365f, 0.07055725f, -0.22594021f, -0.08617596f, 0.14038000f, -0.03294171f, 
    0.03541508f, 0.10487635f, -0.04784553f, -0.14978199f, 0.04639731f, -0.05745177f, 0.04338438f, 0.00768693f, 
    -0.15139224f, -0.17535040f, 0.06736390f, 0.20345385f, -0.13814294f, 0.01073774f, 0.06257590f, -0.11232270f, 
    0.08667514f, 0.08075912f, -0.03545287f, -0.10324445f, 0.12274376f, 0.04528117f, 0.09538183f, 0.04859664f, 
    -0.01584806f, -0.15523529f, 0.07097521f, 0.01867415f, -0.01465487f, 0.03728231f, -0.02995775f, 0.13107084f, 
    0.14668618f, 0.02783196f, 0.07060594f, 0.18681796f, -0.03759241f, -0.02107753f, -0.06869748f, -0.07184196f, 
    0.06346896f, 0.02214592f, -0.02692483f, -0.08370670f, -0.26276386f, -0.08608498f, 0.19747357f, 0.17009673f, 
    -0.05538253f, -0.03988598f, 0.06289184f, -0.02494425f, -0.01348476f, -0.02661183f, 0.10879211f, 0.01640874f, 
    0.08048675f, 0.13905099f, 0.13177887f, 0.25411865f, 0.06630912f, 0.05669765f, 0.00496006f, 0.14391407f, 
    0.10317165f, 0.08434463f, 0.08602495f, 0.00818217f, -0.09727950f, -0.04026664f, -0.10160286f, 0.02772312f, 
    0.00797378f, -0.00585013f, 0.02177428f, 0.17323890f, 0.01363351f, 0.04705457f, 0.10101078f, 0.05004210f, 
    -0.06988812f, 0.17019154f, 0.04966636f, 0.05567122f, 0.03627979f, 0.06041297f, 0.00549073f, -0.03656533f, 
    0.01449084f, -0.08857882f, -0.02639241f, 0.02896627f, -0.00917007f, 0.17888510f, -0.20803675f, -0.17338961f, 
    0.02952661f, -0.07163868f, 0.06732374f, 0.01491020f, -0.05170399f, -0.01664766f, -0.00290528f, 0.01297443f, 
    -0.26476866f, 0.11984623f, 0.27723056f, 0.06275254f, -0.05955405f, 0.00645525f, -0.16622819f, -0.04573843f, 
    -0.02910491f, -0.03601209f, -0.02749142f, 0.05732884f, 0.37817785f, 0.22310898f, -0.17075047f, 0.01116143f, 
    0.01176877f, -0.03616668f, 0.04713429f, 0.12757103f, -0.00460758f, 0.05759802f, 0.06648823f, 0.08708599f, 
    0.04224905f, 0.15220374f, -0.03495838f, 0.12960991f, 0.02641333f, 0.04573870f, 0.12032093f, 0.01591628f, 
    0.02636158f, -0.03228312f, 0.09717274f, 0.08581278f, -0.07658024f, 0.01078061f, 0.11604100f, -0.09790204f, 
    -0.00788410f, 0.00476236f, -0.08209463f, 0.07524852f, 0.08704828f, 0.09211947f, 0.01740493f, 0.10219432f, 
    -0.52616000f, -0.18654336f, -0.08783320f, 0.13355634f, 0.07926716f, 0.12919833f, 0.08054852f, -0.03420076f, 
    -0.04319832f, 0.11441069f, 0.05228239f, 0.03736411f, 0.01663508f, -0.13487932f, -0.21103078f, -0.06753186f, 
    0.01259251f, -0.03692032f, -0.05583322f, 0.08797273f, 0.06218692f, 0.02801568f, -0.08157120f, 0.03274884f, 
    -0.26774669f, 0.05455690f, 0.06427427f, -0.04355897f, -0.00269758f, 0.18591455f, -0.18256503f, -0.25581011f, 
    0.11607025f, 0.02355231f, 0.16096547f, 0.03613380f, 0.00356723f, 0.16672656f, 0.26561269f, 0.12666020f, 
    -0.04027304f, 0.04624493f, 0.06780004f, 0.19828919f, -0.18574196f, 0.09061555f, -0.09979083f, -0.17464866f, 
    0.02139883f, 0.08904237f, -0.04403812f, 0.03583558f, 0.05506283f, 0.03498358f, -0.06481389f, 0.02819344f, 
    -0.04678511f, -0.01367542f, 0.00926064f, -0.02703166f, -0.53017974f, -0.06777739f, -0.22056834f, -0.09718879f, 
    -0.03225510f, -0.04458346f, 0.20548433f, 0.13272394f, -0.12739845f, 0.08466680f, 0.02470057f, -0.13736209f, 
    0.09767570f, 0.08258921f, 0.09200855f, -0.13703883f, 0.05775187f, -0.12074484f, 0.01307146f, -0.02270499f, 
    -0.03366275f, -0.06309696f, -0.03046011f, -0.04991775f, -0.15433587f, -0.18647203f, 0.01894194f, 0.06959792f, 
    -0.00996478f, -0.20124115f, -0.09350468f, -0.01022047f, 0.12102126f, -0.12769611f, 0.13910593f, -0.05383257f, 
    -0.53373992f, -0.23398642f, -0.18185300f, -0.16548145f, 0.16516198f, 0.06879019f, -0.00989725f, -0.02856431f, 
    -0.05647793f, 0.08398109f, 0.02167053f, 0.00701561f, -0.09580261f, 0.02920856f, 0.05579107f, -0.01075952f, 
    0.08730812f, 0.04942102f, 0.07168300f, -0.03911325f, -0.14874464f, 0.07118094f, 0.07960829f, -0.01909907f, 
    -0.10159137f, -0.24482033f, -0.18171871f, 0.06006445f, 0.06841908f, 0.02311286f, 0.04334020f, -0.03006253f, 
    0.06035566f, -0.00411085f, -0.02339095f, 0.02064661f, -0.00080776f, -0.02728323f, 0.11556394f, 0.10749439f, 
    0.06722025f, 0.03059486f, 0.02916590f, -0.05112222f, -0.02313785f, 0.01407126f, 0.00337774f, 0.20301634f, 
    0.07265323f, 0.04113272f, 0.05779358f, 0.18221156f, -0.03580716f, 0.02969948f, -0.13293120f, 0.05499666f, 
    0.06467123f, 0.01938220f, 0.13743301f, 0.01238378f, -0.01091573f, -0.00414120f, 0.03864157f, -0.38489100f, 
    0.07705687f, -0.07633147f, -0.01969406f, -0.00501159f, 0.02129020f, -0.04949840f, -0.01819224f, -0.00885214f, 
    -0.06669340f, 0.10801390f, 0.03277439f, 0.22860038f, -0.07973654f, -0.01527330f, 0.02074401f, 0.17706695f, 
    -0.02935945f, -0.06442485f, 0.10868944f, -0.08062474f, 0.23095882f, 0.00229953f, -0.11088697f, -0.05040278f, 
    -0.04510165f, 0.06412853f, 0.06020504f, 0.12103701f, -0.05516520f, -0.06947416f, 0.08427834f, -0.03767756f, 
    -0.19700930f, -0.03521032f, -0.09641424f, -0.35424355f, 0.06511959f, 0.21818532f, 0.09989940f, -0.15850936f, 
    -0.01556783f, -0.15038367f, -0.08329765f, -0.00365135f, -0.32898831f, 0.00512856f, -0.29378062f, 0.07634985f, 
    0.14331330f, 0.10879675f, 0.03156338f, -0.21118988f, 0.03538200f, 0.06369580f, -0.01550053f, -0.06574110f, 
    -0.59567958f, 0.33720407f, 0.09374209f, 0.02727844f, -0.04331086f, -0.08077613f, -0.12747431f, -0.05407318f, 
    -0.02070255f, -0.12928860f, -0.04773227f, 0.06279936f, 0.10369489f, 0.02896255f, 0.02574425f, 0.17060177f, 
    -0.00713590f, -0.03042299f, 0.10372135f, 0.16241813f, 0.00836155f, 0.03166998f, -0.06101711f, 0.01219922f, 
    -0.05068947f, -0.14589368f, 0.18814781f, -0.10840699f, 0.06664292f, 0.19823243f, -0.18466581f, -0.00233226f, 
    0.10390177f, 0.09725033f, 0.10703292f, 0.08142095f, 0.04081382f, 0.14551145f, 0.00760210f, -0.23183444f, 
    -0.00912390f, 0.05356409f, -0.01301920f, 0.10534535f, 0.06653599f, -0.18705110f, 0.04545408f, -0.03831737f, 
    -0.43203348f, -0.07059510f, 0.00048247f, -0.26409876f, 0.14944746f, 0.01141221f, 0.13035937f, 0.09945741f, 
    0.00498298f, 0.03759571f, -0.11910211f, 0.04822962f, -0.13747478f, -0.00804215f, 0.08226383f, 0.19517654f, 
    -0.06369854f, 0.04279720f, 0.09182138f, 0.09143852f, 0.01769192f, 0.08079225f, 0.08221355f, 0.04832682f, 
    0.02147272f, 0.00599402f, 0.01870067f, -0.17795356f, -0.01533773f, 0.00417376f, -0.00814270f, -0.02101795f, 
    0.13838692f, -0.10148989f, 0.07168934f, -0.06035439f, -0.20692968f, -0.18022011f, 0.08278694f, 0.14653221f, 
    0.03021004f, -0.05387353f, 0.05100305f, 0.05035181f, 0.09319390f, -0.22637218f, -0.04078198f, 0.22901802f, 
    0.00361702f, 0.03106611f, 0.11459843f, 0.09375196f, 0.03902075f, 0.03810626f, 0.07572036f, -0.00548911f, 
    0.01828775f, 0.06649832f, 0.07284540f, 0.10467375f, -0.34255457f, -0.35664481f, 0.14234921f, 0.17965035f, 
    -0.04702824f, 0.01884569f, -0.08430634f, -0.00353067f, 0.00595214f, 0.07472718f, 0.02686023f, 0.09563646f, 
    0.06523348f, -0.16087838f, 0.08975914f, 0.20988657f, -0.06293138f, -0.02602897f, -0.09716136f, 0.05628464f, 
    -0.00183249f, 0.04630106f, 0.03514373f, 0.11620408f, -0.27781254f, -0.05928924f, 0.08780944f, 0.27902687f, 
    -0.06781454f, -0.12631768f, 0.05480923f, 0.06257616f, 0.00125520f, -0.08207461f, -0.09801747f, -0.06777690f, 
    0.01784489f, 0.07284966f, 0.20136023f, -0.13712896f, -0.03864071f, 0.02886408f, 0.06318019f, -0.06885457f, 
    -0.03098724f, 0.09704349f, 0.05398124f, 0.16268587f, -0.08781777f, 0.02965355f, 0.03057321f, 0.02235525f, 
    0.08190126f, 0.07017222f, -0.03178042f, 0.05330864f, -0.00610793f, 0.04483041f, -0.03440847f, 0.04887573f, 
    0.15450311f, 0.05173853f, -0.04408598f, 0.01598187f, -0.01194033f, -0.07677934f, -0.07196794f, 0.04106389f, 
    0.06463256f, -0.10451739f, 0.06309808f, 0.03447048f, 0.06334961f, 0.13583586f, 0.10000671f, 0.20821278f, 
    -0.10010938f, -0.03176377f, -0.14619693f, -0.00266918f, -0.05213400f, -0.05115003f, 0.13520679f, -0.00181927f, 
    -0.35409722f, 0.11671338f, -0.02603483f, -0.10906705f, 0.01438845f, 0.13285927f, -0.04891660f, -0.26114494f, 
    0.10671757f, -0.18736129f, 0.10749205f, -0.02380274f, -0.02028177f, -0.17314017f, -0.18545449f, 0.04405576f, 
    0.06947674f, -0.02236942f, 0.11530674f, 0.05269012f, -0.00150936f, 0.08021420f, -0.20739993f, -0.03540855f, 
    -0.42814812f, -0.07192649f, -0.24537830f, -0.04953763f, 0.12810689f, -0.04889297f, 0.07504536f, 0.14360569f, 
    0.06163952f, 0.02212347f, -0.09980054f, -0.17263317f, -0.23713772f, -0.02384627f, 0.09004449f, 0.07617381f, 
    0.16280961f, -0.00968562f, -0.00760895f, -0.17799409f, -0.09539865f, 0.12219123f, 0.09453437f, 0.11691763f, 
    0.07408489f, 0.10860670f, 0.07249663f, 0.07971628f, -0.34676427f, -0.07504050f, -0.02839153f, 0.05803147f, 
    -0.01085884f, -0.24721059f, 0.19681633f, 0.21266337f, -0.03074769f, -0.07791323f, -0.04590743f, -0.18475786f, 
    -0.05014312f, 0.04048180f, 0.01539427f, -0.02921547f, -0.13311109f, 0.17384559f, 0.06477012f, 0.10449132f, 
    -0.01964418f, 0.03760821f, -0.06411814f, -0.03979659f, 0.06865544f, -0.04670490f, 0.03881482f, 0.02228855f, 
    0.11124556f, 0.01968048f, -0.15103824f, 0.03819932f, 0.04297538f, -0.23289277f, -0.02009179f, -0.09809445f, 
    -0.08799781f, 0.01130241f, -0.14419833f, -0.15439260f, 0.01926693f, -0.05825431f, -0.09403771f, -0.00691090f, 
    0.01719162f, -0.03191921f, -0.03027075f, -0.09000023f, 0.03699816f, -0.03696531f, 0.01666882f, 0.02940111f, 
    0.11903330f, 0.10161461f, 0.00699094f, -0.00453130f, -0.05876259f, 0.06000633f, 0.10282340f, 0.21999416f, 
    -0.03837156f, 0.07626654f, -0.02177669f, -0.01436700f, -0.07866011f, -0.09035141f, 0.03232072f, 0.20555514f, 
    0.03793225f, -0.00993239f, -0.15116765f, -0.02013882f, 0.11522887f, 0.18297604f, -0.04230753f, -0.04477219f, 
    0.25440478f, -0.11733778f, -0.02484534f, -0.17187555f, -0.13741089f, -0.05203088f, 0.09333244f, 0.08122912f, 
    0.06661258f, -0.01640477f, 0.09544305f, 0.03971949f, 0.08877087f, -0.02388371f, -0.05684870f, -0.18603876f, 
    0.03999543f, 0.19562612f, 0.23221871f, -0.19818579f, 0.05983445f, -0.05451796f, -0.16520426f, -0.02664739f, 
    -0.19427982f, -0.03134945f, -0.09654040f, -0.21457948f, 0.18928486f, 0.01694274f, 0.07576503f, -0.09711543f, 
    -0.08419849f, -0.03883095f, -0.10095493f, -0.06665993f, -0.02066325f, -0.05555765f, 0.05261455f, 0.04609618f, 
    -0.12081725f, -0.03789831f, -0.17845634f, 0.05456098f, 0.02902013f, 0.17402868f, 0.06532475f, -0.01613555f, 
    0.01913189f, 0.04303798f, -0.01156996f, -0.07463289f, 0.13569888f, 0.02109560f, -0.02003260f, -0.22612937f, 
    -0.07612956f, -0.04423330f, -0.20917045f, -0.09873781f, -0.08028159f, 0.01784972f, -0.01602503f, -0.12358181f, 
    0.14612161f, -0.14201210f, -0.04121450f, 0.23414128f, 0.05649194f, -0.12323613f, 0.05892165f, 0.08030100f, 
    -0.11165743f, 0.26080972f, -0.00291705f, 0.03001915f, -0.09380598f, 0.23983569f, -0.02156207f, 0.11082257f, 
    -0.09998055f, 0.07291609f, -0.02025625f, -0.10285903f, 0.01470689f, 0.00504378f, -0.15608260f, 0.06946211f, 
    0.02527358f, -0.01334231f, 0.04434230f, -0.05787055f, 0.00764597f, -0.02001222f, 0.04339129f, 0.01116500f, 
    -0.03651956f, -0.01612669f, -0.02435436f, 0.23165137f, 0.03958340f, -0.08159506f, -0.00159918f, 0.21186930f, 
    0.16287208f, 0.19693975f, 0.01921950f, 0.12996614f, 0.09963523f, -0.01285083f, 0.00990949f, -0.14997730f, 
    -0.00409561f, 0.00228523f, 0.10737561f, -0.16883560f, 0.04750315f, -0.06042226f, 0.04883881f, 0.03960483f, 
    -0.08356217f, 0.08164360f, 0.01661612f, -0.00580881f, 0.21212819f, 0.00588509f, -0.19596554f, 0.00762057f, 
    0.00419711f, -0.01705517f, -0.04621493f, -0.04966094f, 0.05193229f, 0.02849199f, -0.11469954f, 0.03160984f, 
    -0.20982867f, -0.11034584f, -0.12010124f, -0.02252527f, 0.05389812f, 0.05872303f, -0.06320368f, -0.02801886f, 
    0.09252427f, -0.03641870f, 0.14168108f, 0.00210921f, -0.07516829f, 0.18045484f, -0.09851768f, -0.23338300f, 
    0.02851797f, -0.01390126f, 0.15846230f, -0.22848363f, -0.01499431f, -0.01675390f, -0.17328417f, 0.07194690f, 
    -0.00889993f, -0.16039367f, 0.10800454f, -0.00749768f, -0.00201436f, 0.04186081f, -0.06144017f, -0.01199346f, 
    0.00637970f, 0.00481836f, -0.08250218f, -0.03257724f, -0.22406875f, -0.01419665f, 0.19611782f, -0.07976739f, 
    -0.00041288f, -0.02908240f, 0.04844768f, 0.07883842f, 0.07755823f, -0.04755034f, 0.05960969f, -0.10928915f, 
    0.03006769f, 0.02308758f, 0.13193324f, 0.01101591f, 0.03518885f, -0.04975363f, 0.02397048f, 0.07480726f, 
    -0.07671577f, 0.00893680f, -0.03590837f, 0.00905284f, 0.09873150f, -0.14603220f, 0.34077632f, 0.19094570f, 
    0.09736587f, -0.12677717f, -0.07087609f, -0.16413276f, -0.02172853f, -0.03182360f, -0.01058996f, -0.02265538f, 
    -0.06990635f, -0.04960235f, -0.06403322f, -0.07892034f, 0.00972157f, -0.16561693f, -0.01655429f, -0.03464960f, 
    0.01961314f, -0.09661192f, -0.03953996f, -0.13793631f, 0.18458359f, -0.12767154f, -0.03819487f, -0.08689091f, 
    0.01478996f, -0.03352207f, -0.09221105f, 0.01644942f, -0.16572315f, 0.05894529f, 0.05284751f, -0.03905431f, 
    0.18469697f, 0.00048148f, -0.05471722f, -0.29373854f, -0.06597704f, -0.01737891f, -0.07138467f, 0.04144299f, 
    -0.11818473f, -0.11048595f, 0.10422014f, -0.02403846f, 0.00721272f, -0.03055240f, -0.21127206f, -0.05824151f, 
    0.00470059f, 0.09551906f, 0.00334842f, -0.13690020f, -0.02359263f, -0.02817830f, 0.13710459f, 0.05670122f, 
    0.21409458f, -0.12032346f, 0.10746836f, 0.26862532f, -0.14829785f, -0.01581845f, -0.00889955f, 0.06414454f, 
    -0.08512190f, -0.07408305f, -0.02576716f, -0.14099003f, 0.10578568f, 0.16883242f, 0.10325094f, 0.17876446f, 
    0.02599112f, -0.04961623f, -0.05416631f, -0.05125988f, 0.04690653f, -0.00774157f, 0.00427196f, 0.15587157f, 
    -0.31062511f, 0.15831104f, -0.03870441f, 0.22452019f, 0.02161018f, -0.04202047f, -0.06894986f, 0.05048764f, 
    0.02723416f, 0.07451729f, -0.05450351f, -0.02606945f, 0.34401593f, -0.19033571f, 0.17467088f, -0.04900448f, 
    -0.09863487f, 0.07568511f, -0.01432267f, -0.24392125f, -0.04507623f, 0.15615751f, 0.11480638f, 0.05069206f, 
    0.17201017f, 0.20980948f, 0.17181447f, -0.16411631f, -0.09587638f, 0.03656760f, 0.00218967f, 0.10857469f, 
    0.00743780f, 0.07505231f, 0.04772331f, 0.06918132f, -0.03496680f, 0.05115882f, -0.09520523f, 0.27488738f, 
    0.07517628f, -0.10618506f, 0.10598129f, 0.00628080f, 0.01894416f, -0.00789359f, -0.04720039f, -0.11583670f, 
    0.00755082f, -0.02501495f, 0.08891074f, -0.15861644f, -0.07706407f, 0.06195662f, 0.20799699f, 0.00696907f, 
    0.09163730f, 0.02065367f, 0.00118189f, -0.00791678f, -0.13201675f, 0.11497856f, 0.18387981f, -0.03749090f, 
    -0.07893530f, -0.00162056f, 0.03191888f, 0.01123162f, 0.09950610f, 0.05016940f, -0.07702246f, -0.01972115f, 
    0.01650269f, -0.12656040f, -0.07934643f, 0.03604808f, -0.02859573f, 0.01475571f, -0.02521977f, 0.02348450f, 
    -0.01443066f, -0.00263421f, -0.07338098f, -0.00417451f, 0.11848531f, 0.14663048f, 0.05170414f, -0.19646229f, 
    -0.06799936f, -0.09317241f, 0.04572748f, 0.02880826f, 0.03223571f, -0.05962030f, 0.03604632f, -0.06607382f, 
    -0.09414505f, 0.09205592f, 0.09218495f, 0.03484066f, 0.11741141f, -0.13658375f, 0.12292412f, -0.00614214f, 
    0.02831662f, -0.01443259f, -0.14970611f, -0.01917885f, 0.47114047f, 0.07955843f, 0.11139747f, 0.00505105f, 
    -0.07540429f, 0.11251232f, 0.06654396f, 0.05894303f, 0.05107556f, 0.00083420f, 0.01157712f, -0.01236411f, 
    0.08896540f, -0.18029054f, -0.14300586f, 0.25620216f, 0.03778066f, 0.05305620f, -0.07455196f, 0.06362457f, 
    0.02496579f, -0.06912199f, -0.15130845f, 0.09257724f, 0.05435249f, 0.00117197f, -0.00877773f, 0.10664210f, 
    -0.04030524f, 0.05810479f, -0.02367205f, 0.00834788f, -0.01973944f, -0.06494718f, 0.04986246f, 0.00687480f, 
    -0.26107317f, -0.15142566f, 0.05797312f, -0.16299509f, 0.04275775f, -0.01760407f, -0.01989230f, -0.03747961f, 
    0.00119200f, -0.00792084f, 0.11965970f, 0.12673175f, -0.32437861f, 0.00692361f, -0.05398720f, -0.24063329f, 
    -0.08536176f, -0.02621225f, 0.03358921f, -0.03263396f, 0.01446400f, 0.10362683f, -0.04455177f, 0.07502644f, 
    0.45152485f, -0.27794728f, 0.04143218f, 0.09920168f, 0.04711439f, -0.05541725f, 0.08044530f, 0.00776533f, 
    -0.01868519f, 0.04966361f, 0.09570301f, -0.00756591f, -0.18647584f, 0.06013772f, -0.04761393f, -0.01664198f, 
    -0.01272512f, -0.04285745f, -0.05602509f, 0.06351914f, -0.05033391f, -0.06967585f, 0.16367640f, -0.04731179f, 
    -0.31488144f, 0.15590076f, 0.05394905f, -0.05804231f, -0.01906528f, -0.02764709f, 0.17848189f, 0.01758215f, 
    -0.05314249f, -0.13893163f, -0.03175700f, 0.02955586f, 0.22834317f, -0.06589279f, 0.10919552f, -0.18757527f, 
    -0.01153323f, -0.09153853f, -0.04907314f, 0.06805888f, 0.10859104f, 0.14494613f, -0.15097877f, -0.04911211f, 
    0.25099722f, 0.01980571f, -0.02659065f, 0.09905542f, -0.00730448f, 0.01242795f, -0.01896653f, -0.03366969f, 
    0.06370372f, -0.01362551f, 0.10616416f, 0.00181940f, 0.00538980f, -0.10621975f, -0.16362999f, 0.17563871f, 
    -0.00296390f, -0.00140911f, -0.09675049f, -0.07283575f, -0.02920785f, -0.13834295f, -0.08438957f, -0.09735688f, 
    -0.16689365f, 0.10212773f, -0.07102207f, -0.11569191f, 0.08070294f, 0.00885018f, 0.10947860f, -0.11623248f, 
    -0.06592129f, -0.03556569f, -0.01049112f, 0.07610629f, 0.20086375f, -0.10070402f, -0.04430026f, 0.07259621f, 
    -0.10692392f, 0.06799253f, 0.09153715f, -0.03601151f, -0.01618276f, -0.01607916f, -0.00853384f, -0.00821767f, 
    -0.03966584f, 0.11324193f, 0.12761571f, -0.13893205f, -0.12001095f, 0.00498406f, 0.00837541f, 0.03911807f, 
    0.04319881f, -0.00983485f, -0.03642447f, -0.06484536f, 0.28126431f, -0.32598469f, 0.04685545f, 0.05417078f, 
    0.03073343f, 0.08572176f, -0.06385876f, 0.16403592f, 0.05602169f, -0.01265662f, 0.06747226f, -0.07066891f, 
    0.06355581f, 0.06635231f, -0.01116982f, -0.10702623f, 0.06519553f, -0.05233137f, -0.02788841f, 0.07579768f, 
    -0.06400706f, 0.00198572f, -0.04087406f, -0.13785651f, -0.19354579f, 0.15179430f, -0.12035695f, -0.13888320f, 
    -0.03882453f, 0.00414320f, -0.00649744f, 0.05585413f, -0.09545349f, 0.01889563f, 0.10004208f, 0.12344159f, 
    -0.06814884f, 0.04495856f, 0.04614497f, -0.23589483f, -0.18719618f, -0.00665042f, 0.00319000f, 0.01278507f, 
    -0.00273275f, -0.09980504f, -0.07299723f, -0.13448411f, 0.04054897f, 0.07751880f, 0.05139394f, -0.06261156f, 
    0.12287974f, -0.05501019f, -0.03285505f, 0.09618039f, 0.04449041f, -0.01102838f, 0.03462592f, -0.19479170f, 
    -0.24780922f, 0.25431353f, 0.08370353f, 0.07842474f, -0.06243845f, -0.01334117f, 0.08406565f, 0.03224416f, 
    0.00136392f, 0.14382230f, 0.00550051f, 0.06514474f, 0.03221735f, 0.07985521f, 0.02284231f, -0.13563858f, 
    0.13775168f, 0.01310342f, 0.09079584f, 0.06425335f, 0.03338468f, 0.04830301f, -0.05352257f, -0.08301235f, 
    0.07448691f, -0.29258144f, -0.09555691f, -0.04186539f, -0.02072944f, 0.13859414f, 0.03626759f, -0.07835007f, 
    -0.00322901f, 0.13425899f, -0.09932712f, 0.04102585f, 0.05756874f, 0.12293280f, 0.11816198f, 0.09570888f, 
    0.01564944f, 0.06128154f, 0.00620259f, -0.07823121f, -0.03533667f, -0.08341235f, 0.07220018f, 0.00587145f, 
    -0.11949316f, -0.25550371f, -0.10331277f, -0.02998801f, 0.04033201f, 0.00289841f, -0.01391621f, -0.08808365f, 
    -0.06239541f, -0.06342488f, 0.10001833f, 0.02799620f, -0.06983760f, -0.02050690f, -0.07080604f, -0.05230749f, 
    -0.12614225f, -0.05932892f, -0.12128603f, -0.04515165f, 0.19638185f, -0.08267661f, -0.06252200f, -0.18252614f, 
    -0.00735922f, 0.16340265f, -0.06735427f, -0.06083442f, 0.03270791f, 0.02811794f, -0.07902587f, 0.05226634f, 
    -0.08115660f, -0.00693433f, -0.22487240f, -0.12302955f, 0.03395860f, 0.01998522f, -0.06095305f, -0.24295150f, 
    -0.06073508f, -0.03403519f, 0.04383545f, 0.02101140f, 0.11885676f, -0.15188029f, -0.04081630f, -0.13934292f, 
    -0.12963352f, 0.01801382f, -0.13718690f, 0.22652279f, 0.17157991f, 0.12375588f, -0.07933918f, 0.12079395f, 
    0.00259539f, -0.02225961f, 0.12963179f, -0.09921546f, -0.46871826f, -0.14999294f, -0.06340636f, 0.03991859f, 
    0.07741440f, 0.04112119f, 0.11852985f, 0.07006841f, 0.00776715f, -0.11588260f, 0.13360979f, 0.11064405f, 
    0.07593559f, -0.10567122f, 0.07681876f, -0.20972787f, 0.09604752f, 0.02654131f, 0.08322182f, -0.03104289f, 
    -0.11198223f, -0.07304178f, 0.02302854f, -0.03690526f, -0.07006720f, -0.08774474f, 0.01815105f, 0.03737281f, 
    0.04921801f, -0.04607042f, -0.05002538f, -0.07278157f, 0.10671328f, -0.08159132f, -0.09850071f, -0.17593749f, 
    -0.12067319f, -0.18620525f, -0.05693506f, -0.32211757f, -0.06469805f, -0.02738785f, -0.00751943f, -0.08820623f, 
    -0.15784124f, 0.07652685f, -0.00674131f, 0.08824939f, 0.07864752f, 0.12598674f, 0.01171199f, 0.08783925f, 
    0.02429908f, -0.05376568f, 0.00328236f, 0.09550220f, -0.04231455f, 0.05673863f, 0.01225356f, 0.06513173f, 
    0.14117558f, -0.10382340f, 0.14383350f, -0.05081080f, -0.13930331f, 0.07691531f, 0.05266215f, 0.06378166f, 
    0.04358017f, -0.02205942f, -0.00362671f, 0.09990395f, -0.48161227f, 0.00822177f, -0.04242012f, 0.15661897f, 
    0.02924095f, 0.10109155f, 0.01235852f, 0.11157494f, 0.06546260f, 0.04114581f, -0.00313035f, 0.02045139f, 
    0.08827029f, 0.15643489f, 0.14757025f, -0.12757218f, -0.15965393f, -0.05900532f, -0.00696451f, -0.14945635f, 
    -0.18111406f, 0.06682371f, -0.00150095f, -0.00518224f, -0.27924103f, -0.16050200f, 0.05855144f, -0.05929553f, 
    -0.09845451f, 0.10603478f, 0.11788926f, 0.07032295f, 0.09619822f, -0.08247520f, -0.02941214f, 0.06297755f, 
    -0.19331978f, 0.00091664f, -0.12986979f, -0.14146130f, 0.16031045f, -0.00151046f, -0.01415115f, -0.24650258f, 
    0.03758423f, -0.03306792f, 0.09692967f, 0.03702193f, -0.17490354f, -0.04425558f, -0.20284939f, 0.23212554f, 
    0.06345493f, -0.06871338f, 0.01095698f, -0.00157793f, -0.08301961f, -0.07567296f, 0.01286353f, -0.02482897f, 
    0.17066522f, 0.20128609f, 0.08765919f, -0.25381300f, -0.01745931f, 0.12282837f, -0.00683250f, -0.03995456f, 
    -0.10821576f, -0.11227137f, 0.04555861f, -0.04291615f, -0.09514830f, -0.00349193f, -0.17715810f, -0.03627687f, 
    -0.21832502f, -0.18030560f, -0.01966331f, -0.10576384f, -0.03166378f, -0.13951455f, -0.06675205f, -0.00790193f, 
    -0.14995787f, 0.18105249f, 0.10509726f, -0.34113586f, -0.04206147f, 0.07501866f, -0.02924300f, 0.02646629f, 
    -0.12988201f, -0.14154270f, 0.14396332f, -0.11345726f, -0.20225465f, -0.03535556f, -0.25454760f, 0.14551479f, 
    -0.00440225f, 0.00865154f, -0.06627900f, 0.03117780f, 0.10303082f, -0.05323591f, 0.00258829f, 0.09295583f, 
    -0.39915502f, -0.18656915f, -0.06549571f, -0.07407714f, 0.02099218f, 0.02893203f, 0.00171522f, -0.04282989f, 
    0.00706038f, -0.04798276f, -0.01542893f, 0.02150882f, 0.01526091f, -0.19111207f, 0.04240485f, -0.00350008f, 
    0.05432911f, -0.00280680f, 0.05406123f, 0.12840641f, 0.08953065f, 0.01691450f, 0.03696793f, -0.02097372f, 
    -0.05813693f, 0.08251918f, -0.06359604f, 0.14338958f, -0.00834260f, 0.07850695f, -0.07556168f, 0.10897183f, 
    0.00125034f, 0.01775186f, 0.05404147f, 0.00533133f, 0.20068051f, -0.40339223f, 0.00667474f, 0.00166802f, 
    0.05043641f, 0.04587771f, -0.02429228f, 0.07410119f, -0.00771390f, -0.00351727f, 0.07811298f, 0.11560892f, 
    0.08164112f, -0.01831553f, -0.07431543f, -0.18462422f, 0.15360714f, 0.05459100f, 0.12964706f, -0.06660058f, 
    -0.09459946f, 0.02263354f, 0.10269091f, 0.03900043f, -0.19111721f, -0.20577662f, -0.17995840f, 0.06720931f, 
    0.01361856f, 0.15292130f, 0.09593317f, -0.01640826f, 0.06215704f, 0.01008597f, -0.00683311f, 0.16104916f, 
    -0.03468818f, -0.23375969f, -0.16480887f, 0.15868104f, -0.08880908f, 0.10082543f, -0.13250211f, -0.00221597f, 
    -0.09572577f, 0.08072998f, 0.05065645f, 0.07668824f, 0.05374940f, 0.00537662f, -0.12427235f, -0.16000813f, 
    0.06227800f, 0.00423661f, 0.03125122f, -0.05643020f, 0.01802097f, 0.02343860f, 0.08235636f, -0.20144539f, 
    0.16278835f, 0.02481664f, 0.14806525f, 0.17697671f, 0.12453087f, 0.03438336f, -0.00303721f, -0.06078848f, 
    -0.00897383f, -0.06171061f, 0.00996942f, 0.01621900f, 0.08330423f, 0.19426885f, 0.24715108f, 0.11983881f, 
    0.04637638f, 0.04488272f, 0.11224572f, 0.00035652f, 0.00761068f, 0.05355274f, -0.05114474f, -0.06869937f, 
    -0.16217016f, 0.00024819f, -0.10105132f, 0.10075580f, 0.14374930f, -0.05557520f, 0.09433708f, -0.01088149f, 
    -0.03179436f, 0.02895028f, 0.05532932f, 0.04007366f, -0.03383832f, 0.00330036f, 0.04909447f, 0.13911621f, 
    -0.02215264f, -0.05854726f, 0.02390069f, -0.05015972f, -0.01676332f, -0.03518685f, -0.03636036f, 0.04735731f, 
    -0.11358278f, -0.07290139f, -0.07714047f, 0.02813926f, -0.03428148f, -0.00262358f, -0.02201510f, -0.02291966f, 
    -0.06399889f, 0.04040451f, 0.00532797f, -0.08266914f, 0.03154914f, 0.03450668f, 0.13045523f, 0.07343357f, 
    0.11786644f, 0.05996908f, 0.10605189f, 0.00007478f, -0.00638254f, 0.03532515f, -0.02179520f, 0.04520357f, 
    -0.22424524f, 0.00764635f, -0.16587497f, -0.07761562f, 0.07312821f, 0.07005432f, 0.03304595f, 0.03774256f, 
    -0.17529410f, -0.09223303f, 0.04369115f, -0.10408550f, 0.12261296f, 0.12199564f, -0.11705534f, 0.20242234f, 
    0.07631550f, -0.05808731f, 0.01911351f, -0.03073977f, -0.04340450f, -0.01325517f, 0.00695525f, -0.06491319f, 
    0.19344863f, -0.03432110f, 0.18496428f, 0.04750036f, 0.02483172f, -0.08370107f, -0.09631820f, -0.05508545f, 
    0.02155882f, 0.11914183f, -0.03179763f, 0.01899797f, -0.11930026f, 0.08957814f, -0.10338492f, -0.02457671f, 
    -0.04129882f, 0.01368037f, 0.01351170f, 0.02844616f, -0.07936566f, -0.03734610f, -0.09433502f, -0.13121022f, 
    0.10093398f, 0.02117451f, 0.06608984f, 0.17034996f, 0.12449361f, 0.01767413f, 0.02521993f, -0.05276324f, 
    -0.00330594f, 0.01237190f, -0.06460397f, -0.10042167f, -0.38500616f, -0.01374369f, -0.11138145f, 0.02917708f, 
    -0.03844396f, -0.04931586f, 0.01044158f, -0.05971843f, -0.05362392f, 0.03867376f, 0.03327508f, -0.01033452f, 
    0.14768739f, -0.37698856f, 0.07142953f, -0.00563110f, 0.07988133f, -0.03303084f, 0.00802280f, -0.04501753f, 
    -0.02643642f, -0.01529740f, -0.07703084f, 0.00604043f, 0.22842026f, -0.22076190f, -0.03445210f, -0.11010278f, 
    -0.03271690f, -0.01403434f, 0.02748816f, -0.11365913f, -0.03041408f, 0.02115920f, -0.03895416f, -0.03358451f, 
    -0.06872435f, 0.18441872f, 0.00145707f, 0.15451653f, -0.13329196f, -0.12603182f, 0.03065651f, 0.05387630f, 
    -0.07229774f, -0.00338572f, -0.04408613f, 0.01547681f, -0.04797313f, 0.01575109f, -0.06921806f, -0.08005573f, 
    -0.04876800f, -0.02397753f, 0.00412690f, 0.02482526f, 0.00028430f, -0.00652622f, 0.01452821f, 0.04769673f, 
    0.10018072f, -0.01587689f, 0.12734523f, 0.08752470f, 0.02610727f, -0.01426419f, 0.04463002f, 0.01587778f, 
    -0.01779823f, 0.08062862f, 0.01385871f, -0.03214630f, -0.03564194f, 0.13224801f, 0.10762279f, 0.15588219f, 
    0.13114725f, 0.03377384f, 0.07535399f, -0.05468402f, -0.07052470f, -0.01058144f, -0.03971651f, -0.02769350f, 
    0.04822897f, -0.13279589f, -0.00685073f, -0.03511793f, -0.07745513f, 0.02479119f, -0.02575030f, 0.02109252f, 
    -0.07406798f, 0.00172541f, -0.08260270f, 0.00039300f, -0.14370696f, 0.02529838f, -0.23791732f, -0.08036855f, 
    0.00703566f, -0.06895466f, -0.03632921f, -0.06446384f, -0.13393934f, -0.02243870f, -0.00331274f, -0.02772086f, 
    -0.14040959f, 0.02334100f, 0.00296632f, -0.16173090f, 0.05472956f, -0.12162316f, -0.02963528f, -0.06998073f, 
    -0.03243727f, 0.03065740f, -0.00970459f, -0.00690038f, 0.36981419f, 0.14039032f, 0.00894988f, -0.21748821f, 
    -0.11845035f, -0.00874521f, 0.05383935f, -0.03909921f, -0.07073396f, -0.02670531f, 0.01546488f, -0.01695758f, 
    0.11528000f, -0.11619159f, 0.13136742f, -0.05128776f, -0.03012952f, 0.01510299f, -0.06311962f, 0.03745724f, 
    -0.03020716f, 0.03964478f, -0.03994926f, 0.05662981f, -0.06422155f, -0.18306954f, -0.09544823f, -0.03943671f, 
    -0.08419168f, -0.07421996f, -0.01314879f, -0.09806152f, -0.02162339f, -0.05475659f, -0.05705005f, -0.02748071f, 
    0.12279727f, 0.00763751f, -0.03904556f, 0.00997909f, -0.03120849f, 0.01408028f, -0.05532542f, -0.02568837f, 
    -0.03002556f, 0.01072558f, -0.04977376f, -0.03215932f, -0.19278660f, -0.00880476f, 0.03029132f, 0.10386562f, 
    0.05326860f, -0.05739922f, -0.01075082f, -0.02129008f, -0.05248290f, 0.03880126f, -0.01501046f, -0.00309610f, 
    -0.16522050f, 0.12586747f, -0.10850500f, -0.09305382f, -0.01535317f, 0.01902016f, 0.01185358f, -0.06976091f, 
    -0.11057473f, 0.05554404f, -0.00565019f, -0.07048306f, 0.17004819f, 0.05607131f, 0.06851684f, 0.15680511f, 
    0.08811286f, 0.00185508f, 0.00290795f, 0.00364727f, -0.10491559f, 0.00937321f, -0.00680047f, -0.03799811f, 
    0.17315474f, -0.27992839f, 0.15107077f, 0.11198401f, -0.10325222f, -0.09335700f, -0.04415868f, -0.05212797f, 
    -0.02117533f, 0.03827155f, -0.02204940f, -0.07259268f, 0.09877910f, -0.20608610f, 0.03661609f, 0.07259963f, 
    0.04729954f, -0.09954757f, -0.02172641f, -0.07070621f, -0.10294997f, 0.03799017f, -0.01280497f, -0.06326823f, 
    -0.10648917f, 0.07202759f, -0.05545149f, -0.06808463f, -0.03107956f, -0.02892744f, -0.04431357f, -0.05962251f, 
    0.00398160f, 0.02221446f, 0.03152649f, -0.02528371f, -0.07632693f, -0.04010329f, -0.04374850f, -0.15506028f, 
    0.09586047f, -0.03373456f, 0.06710347f, -0.06282403f, -0.04635228f, -0.04083345f, -0.00428999f, -0.00654931f, 
    -0.26344031f, -0.00247384f, -0.04251575f, -0.29010838f, -0.02784337f, 0.01479610f, -0.06682531f, -0.05243975f, 
    -0.01576680f, -0.01245633f, -0.03047747f, -0.06817287f, 0.01635418f, -0.19780883f, 0.06992571f, -0.03559490f, 
    0.12520909f, -0.04006919f, 0.01302677f, -0.05775415f, -0.02891115f, 0.06539294f, -0.01625461f, 0.00689281f, 
    -0.08502012f, 0.06139157f, 0.10915300f, 0.01514242f, 0.04355946f, -0.00252199f, -0.02856933f, -0.02931886f, 
    -0.11094186f, -0.00945181f, 0.07384663f, 0.00516843f, 0.14615197f, 0.09107452f, -0.02771887f, -0.07539831f, 
    -0.04491445f, 0.05659687f, -0.09655962f, -0.06331946f, 0.09944999f, 0.05338843f, 0.02622686f, 0.04080747f, 
    0.20786998f, 0.14910111f, 0.21973428f, 0.06039739f, 0.04813911f, 0.04949325f, 0.01583426f, 0.00147412f, 
    -0.06045601f, 0.00497511f, -0.01355095f, -0.08309834f, -0.01999396f, 0.03430556f, 0.04715563f, 0.09225741f, 
    0.09681948f, 0.05668781f, -0.00334956f, 0.01187756f, 0.02845633f, -0.01705826f, -0.04311503f, -0.01584490f, 
    0.06758539f, -0.10486258f, -0.05618432f, 0.05415055f, -0.06766852f, -0.12653469f, -0.05100340f, -0.05127651f, 
    -0.08595680f, 0.04576759f, 0.00442070f, 0.01644836f, -0.18881755f, 0.05232180f, 0.02459436f, -0.06127259f, 
    -0.07132199f, -0.07411266f, -0.01038093f, -0.05332843f, 0.02576489f, -0.01535804f, -0.04535274f, -0.06317174f, 
    -0.24939610f, 0.12664850f, -0.03821529f, 0.05387043f, -0.07145078f, -0.00874078f, -0.11728778f, 0.00326669f, 
    0.10459720f, 0.01584415f, 0.01742388f, -0.12785211f, 0.04725626f, -0.03307299f, 0.14396967f, 0.11953685f, 
    0.05845694f, -0.01748582f, -0.06000070f, -0.13236833f, -0.02224647f, -0.02588471f, 0.01909827f, -0.08814150f, 
    0.15376569f, -0.11828291f, 0.04238040f, -0.03406859f, 0.05509268f, 0.04353415f, -0.03337013f, -0.13005784f, 
    -0.03011413f, 0.04645203f, 0.04149186f, -0.06959593f, -0.02479412f, 0.05007840f, -0.00283956f, 0.13019326f, 
    0.04347146f, -0.07951154f, -0.05759308f, -0.02238273f, -0.03694204f, -0.02952958f, 0.02248417f, -0.02493262f, 
    0.10938733f, 0.12861666f, 0.05603674f, 0.15861931f, 0.01602681f, 0.01293301f, 0.04953173f, -0.01302047f, 
    -0.06106272f, 0.01379379f, 0.01506560f, -0.07648082f, 0.02954721f, -0.11143274f, -0.10952683f, -0.13854426f, 
    -0.03631334f, 0.04055790f, -0.02743111f, -0.01222196f, -0.06458224f, 0.03794668f, -0.04825374f, 0.03432883f, 
    -0.11377088f, 0.01485878f, -0.12320203f, -0.18190908f, -0.02023629f, -0.04158706f, 0.00152713f, -0.17612636f, 
    -0.02029089f, -0.03490574f, -0.07209895f, -0.03411392f, -0.04778692f, -0.06977005f, -0.05447138f, 0.02410818f, 
    -0.02234444f, -0.00322331f, -0.02292010f, -0.05258165f, 0.05188092f, 0.02710866f, -0.04340847f, -0.09930186f, 
    0.00483756f, 0.12097308f, 0.10566477f, 0.19682276f, 0.08448100f, 0.03174264f, 0.09507159f, -0.02486970f, 
    -0.15038908f, -0.07766005f, 0.03110630f, -0.02932457f, 0.09471194f, 0.08987170f, -0.11903127f, -0.00238581f, 
    -0.07776277f, 0.02523122f, -0.05600039f, 0.04850272f, 0.02398651f, 0.10813195f, -0.05842834f, -0.11084667f, 
    0.08322804f, 0.05133408f, -0.00168639f, 0.10017329f, 0.00642624f, 0.04150071f, 0.01969323f, -0.07421660f, 
    -0.06936876f, -0.07925344f, -0.04369164f, -0.04786370f, -0.09010862f, -0.01050138f, -0.15371293f, 0.06179096f, 
    -0.08049053f, -0.04147198f, -0.01443208f, 0.02829346f, 0.08317702f, -0.08623065f, -0.00476756f, -0.01211703f, 
    -0.09072196f, -0.09681538f, -0.08629809f, -0.06917827f, -0.02796729f, -0.02721857f, -0.08248103f, -0.03580714f, 
    -0.03813050f, -0.06415424f, -0.01297400f, -0.05531071f, 0.15348683f, 0.08431502f, 0.09846925f, 0.17583935f, 
    0.11156701f, 0.00361642f, -0.07986339f, 0.01772366f, -0.04489850f, 0.00700018f, -0.07461477f, -0.07535646f, 
    -0.10562033f, -0.05122492f, -0.09741396f, -0.08965137f, -0.02267513f, 0.00642975f, -0.05909668f, -0.02429416f, 
    -0.02063973f, -0.08089422f, 0.04050725f, 0.01220841f, 0.11724086f, 0.17137301f, -0.09649391f, 0.08724128f, 
    0.05501758f, -0.01512522f, 0.05139389f, -0.00061751f, 0.05011397f, 0.00829664f, -0.03742558f, -0.01898589f, 
    0.00899867f, 0.17597346f, 0.03809321f, 0.05989865f, 0.07258967f, 0.00787449f, -0.00281857f, -0.11281151f, 
    -0.01241452f, -0.02941898f, -0.02252942f, -0.00645036f, 0.07167752f, -0.14424957f, 0.08489009f, -0.21687941f, 
    -0.02822728f, 0.02781936f, -0.01282423f, -0.06981090f, -0.08332570f, 0.04185095f, 0.07036067f, 0.01246251f, 
    -0.19642714f, 0.02668983f, -0.05529685f, 0.08202191f, -0.05167785f, -0.02422108f, 0.00253974f, 0.01054242f, 
    -0.06341788f, -0.02047599f, 0.04356294f, -0.01929874f, -0.08186519f, -0.13624778f, -0.07445237f, -0.10460316f, 
    -0.02531023f, 0.01852374f, -0.07797554f, -0.00655790f, -0.02500654f, -0.01110702f, -0.03356539f, -0.05459995f, 
    -0.06498136f, -0.25646833f, 0.11676964f, -0.00895152f, 0.02771408f, -0.11742312f, -0.01855345f, -0.08309344f, 
    -0.04470160f, 0.04548845f, -0.02841662f, 0.02704965f, -0.09078860f, 0.15962413f, 0.07746035f, 0.10533202f, 
    0.05112390f, 0.00575636f, 0.04645756f, -0.05345051f, 0.00218202f, -0.05935786f, 0.03824171f, -0.04741292f, 
    -0.09825289f, 0.06930103f, -0.02970401f, -0.01020860f, 0.03418593f, -0.02517694f, 0.03873284f, 0.01704996f, 
    0.06282805f, -0.04804762f, -0.02758028f, -0.00082301f, 0.19154784f, -0.10896008f, 0.14307787f, 0.07664791f, 
    0.09972868f, -0.11815775f, 0.10173064f, 0.03755671f, 0.02947210f, 0.00270301f, -0.03826651f, -0.01487449f, 
    -0.13247907f, -0.16324630f, 0.11268149f, -0.19026978f, 0.08271036f, 0.02549361f, -0.01645618f, -0.08934602f, 
    0.02318676f, 0.00717153f, -0.00366522f, -0.15725237f, 0.02933923f, 0.12663485f, -0.01969311f, 0.10768659f, 
    -0.10714402f, 0.01362893f, -0.05488084f, 0.03730744f, 0.03890327f, -0.09067263f, 0.00678139f, 0.10448633f, 
    0.04724853f, -0.03141630f, -0.01195800f, -0.03104914f, -0.07012811f, -0.07785051f, -0.16171312f, 0.01100952f, 
    -0.00231467f, 0.07221746f, -0.02321759f, 0.04909472f, -0.09762686f, -0.07214320f, -0.10452803f, -0.24565873f, 
    0.00228872f, -0.15533315f, -0.12146212f, 0.03342099f, 0.09976745f, 0.07700296f, -0.09416364f, -0.12286993f, 
    0.02719400f, -0.09692602f, -0.10631436f, -0.10697855f, 0.07444586f, -0.02084846f, -0.05297449f, -0.03500779f, 
    0.03205143f, -0.04555548f, -0.12482940f, -0.05731044f, 0.02372993f, -0.22929403f, 0.17696269f, 0.06562917f, 
    0.04205337f, -0.03224536f, -0.02205292f, 0.04090264f, -0.05737333f, -0.15602693f, -0.04131393f, -0.26390493f, 
    0.00361058f, -0.06073603f, -0.04598490f, 0.02266754f, 0.10284102f, -0.03191696f, 0.00438292f, -0.02856016f, 
    0.01567966f, 0.04585729f, 0.03120152f, 0.01828437f, -0.08220120f, -0.04614174f, -0.12304557f, -0.28295729f, 
    0.06922556f, -0.01925353f, -0.15397491f, 0.00772772f, -0.02654267f, 0.10005193f, 0.06703428f, -0.12095512f, 
    -0.13603781f, -0.12585454f, 0.15132926f, -0.14380988f, 0.00858759f, 0.04649114f, 0.04273862f, -0.02776291f, 
    -0.00813631f, 0.01961015f, 0.03268570f, 0.03686773f, 0.10573711f, 0.01991092f, 0.05199474f, 0.13294895f, 
    0.01703325f, -0.00156142f, -0.02236610f, -0.12860365f, -0.02044071f, -0.03347177f, 0.03877836f, -0.00720900f, 
    -0.04106134f, -0.11733299f, 0.16264567f, -0.05814137f, -0.07365386f, 0.06627426f, 0.10212414f, -0.12038901f, 
    -0.00333536f, -0.10241852f, 0.06411779f, 0.06200840f, 0.00660951f, -0.15850094f, -0.08483534f, 0.17788754f, 
    0.11916069f, -0.02062717f, -0.10897747f, 0.00180307f, 0.02838929f, -0.06062009f, 0.10451560f, 0.05991806f, 
    0.10220828f, -0.19565322f, -0.20736089f, 0.00902655f, 0.01695616f, 0.06472560f, -0.06895234f, -0.04007598f, 
    0.02019351f, 0.03270750f, 0.06339012f, 0.01041920f, 0.03434461f, 0.05753590f, -0.01351912f, 0.02844393f, 
    0.06394543f, -0.09068993f, 0.01530690f, 0.00039905f, 0.01447352f, 0.02775562f, 0.07522451f, 0.06126954f, 
    0.16831866f, 0.28969380f, -0.23272099f, -0.11617787f, -0.02442242f, -0.09837151f, 0.02904353f, -0.01368695f, 
    -0.00890360f, 0.01071945f, 0.10073484f, 0.04535583f, 0.17995134f, 0.08407845f, -0.12503962f, 0.03214382f, 
    -0.01748999f, 0.00563778f, 0.06467631f, 0.07200021f, -0.01503491f, -0.04050246f, -0.04698033f, -0.22940542f, 
    -0.19698203f, -0.06832814f, 0.23041147f, -0.09242234f, -0.08248464f, 0.02202198f, -0.03455525f, -0.04550416f, 
    -0.01005469f, -0.06137865f, 0.01010581f, -0.10489681f, -0.21484876f, -0.14174229f, 0.28615564f, -0.03551380f, 
    -0.08790495f, -0.01108640f, -0.13848716f, -0.05514730f, -0.02998096f, -0.06095479f, 0.00459991f, -0.04675448f, 
    -0.05262219f, -0.00624308f, 0.03736872f, 0.05755619f, -0.03894095f, -0.01045564f, -0.06131084f, -0.04052499f, 
    0.10504528f, -0.11406581f, 0.00692976f, 0.05065315f, -0.02387012f, 0.00782487f, -0.08905116f, -0.00322517f, 
    0.05746029f, 0.08286718f, 0.00225894f, -0.04416948f, 0.01470383f, 0.10654732f, 0.05243663f, -0.02243383f, 
    0.15504375f, -0.03960176f, -0.09918800f, 0.08186153f, 0.08483783f, -0.05682639f, -0.10894389f, 0.00083577f, 
    -0.08242592f, 0.01338664f, 0.11066693f, 0.04164642f, 0.18609986f, -0.12184582f, -0.01797485f, 0.00289035f, 
    0.08414362f, -0.09037989f, 0.04374695f, -0.11727030f, -0.01600249f, 0.04794161f, 0.03961542f, 0.11007484f, 
    -0.25522020f, 0.06357138f, -0.04389585f, -0.15670621f, -0.00590106f, -0.00356571f, 0.05114028f, -0.04542147f, 
    0.01346750f, 0.06132826f, -0.19270994f, 0.04675093f, 0.21877404f, 0.16194382f, -0.31862774f, 0.04546646f, 
    -0.01992673f, 0.03859857f, -0.01422719f, -0.10400406f, -0.00137205f, -0.00462101f, 0.06878286f, 0.07679159f, 
    -0.18461467f, -0.16573898f, 0.05267329f, -0.02119908f, -0.05124050f, -0.03919957f, 0.02142927f, -0.01026995f, 
    0.04486563f, -0.03329640f, 0.01877814f, -0.15205890f, 0.06619260f, 0.14186259f, 0.01713399f, -0.10381015f, 
    0.01275422f, -0.04585708f, -0.05907452f, -0.01886891f, 0.04694201f, 0.04860569f, -0.00314808f, 0.13016473f, 
    0.03312540f, -0.03680904f, 0.10836286f, 0.16931053f, 0.05178944f, 0.04437735f, -0.08080444f, -0.03849585f, 
    0.03552184f, 0.05889786f, 0.04925813f, 0.02080130f, 0.15686548f, -0.04976844f, 0.00349170f, -0.18039186f, 
    -0.01568921f, -0.11108877f, 0.06242386f, 0.05083999f, 0.00993753f, 0.02172334f, -0.03029806f, 0.07464334f, 
    -0.09934445f, -0.07135571f, -0.17464121f, 0.01642073f, -0.00851007f, -0.02737625f, -0.01244437f, -0.07991562f, 
    0.02363854f, 0.04316856f, 0.07473931f, 0.11500912f, -0.11832000f, -0.01898271f, 0.00941030f, -0.06524874f, 
    0.09632700f, -0.02323884f, -0.03153298f, -0.02708044f, 0.11834952f, -0.03778860f, -0.16625038f, -0.05595931f, 
    0.15579228f, 0.02507586f, 0.09250155f, 0.19349839f, 0.10628551f, -0.06016925f, -0.09394439f, -0.06341100f, 
    -0.02494819f, 0.09593357f, 0.06724141f, -0.01252579f, 0.11412239f, -0.00956140f, -0.01231591f, 0.00982753f, 
    0.02140917f, 0.00614561f, 0.02004042f, 0.00079700f, -0.01060860f, -0.00021476f, 0.01389394f, 0.02040567f, 
    0.07537302f, -0.07186325f, 0.00183516f, 0.06054600f, 0.09953596f, 0.00663310f, -0.10425680f, 0.02860256f, 
    0.02381016f, -0.06926791f, 0.05074593f, -0.05918264f, 0.04370880f, -0.13346019f, -0.02299461f, -0.08836395f, 
    -0.01718443f, 0.01934158f, -0.02202852f, 0.12370197f, 0.11874560f, 0.02589473f, 0.03630854f, 0.01903463f, 
    0.02437374f, -0.20777601f, 0.04411997f, 0.02658148f, -0.03399592f, 0.03507698f, -0.04707057f, -0.07005037f, 
    -0.01269225f, -0.08204626f, 0.00133480f, -0.03456190f, 0.22375248f, -0.06626590f, -0.24164006f, 0.02138028f, 
    0.01455044f, -0.11877473f, 0.14760873f, -0.07750017f, -0.02310151f, -0.09977944f, -0.08669743f, 0.00080749f, 
    -0.11498445f, -0.02387313f, -0.01706135f, -0.12906155f, -0.01957695f, -0.03646052f, 0.00904465f, -0.05400558f, 
    0.01277607f, 0.00067127f, -0.02892267f, -0.03758736f, -0.16486104f, -0.02837926f, -0.02107722f, -0.10483085f, 
    -0.04433133f, 0.02479945f, 0.05645089f, -0.04936140f, -0.00138532f, 0.02700306f, 0.04117035f, -0.01235572f, 
    -0.04828442f, -0.18931307f, -0.21540597f, -0.18345866f, 0.06611677f, 0.02713346f, 0.02402061f, 0.07075442f, 
    -0.05735983f, 0.00317916f, 0.06279785f, 0.00445766f, -0.15292779f, -0.03260855f, -0.09689821f, -0.02787073f, 
    -0.03939935f, -0.01138361f, 0.00511488f, 0.05635449f, 0.03304242f, 0.08010581f, -0.04207954f, -0.07185096f, 
    -0.05593469f, 0.22526823f, -0.11304830f, 0.06192366f, 0.00554090f, 0.01218467f, 0.00805809f, -0.07597186f, 
    0.04815234f, 0.02377977f, 0.01158451f, 0.08817054f, 0.11224551f, 0.18419175f, -0.00518892f, 0.18372644f, 
    -0.03473938f, -0.02080563f, 0.00132441f, -0.06117453f, -0.02786592f, 0.01548612f, -0.16967402f, -0.04597571f, 
    -0.01471749f, -0.13294512f, 0.08567507f, -0.01397392f, 0.01652740f, -0.05135098f, -0.03018321f, 0.05012272f, 
    -0.01637942f, 0.00262832f, -0.04960993f, 0.09468031f, -0.23877829f, 0.12848000f, 0.02618053f, -0.19687669f, 
    -0.06892032f, 0.09785422f, -0.07379907f, 0.03370972f, 0.03425369f, -0.10003043f, 0.04843344f, 0.13182473f, 
    -0.21404107f, 0.15686233f, 0.15617786f, 0.08626819f, -0.11820880f, 0.05648348f, 0.01834480f, 0.00391847f, 
    0.03161358f, 0.02081463f, 0.03077834f, -0.01500682f, 0.12340058f, -0.00133051f, -0.01126423f, 0.01331820f, 
    0.01779731f, 0.02582710f, -0.05067727f, -0.04631322f, 0.09406094f, -0.01769071f, -0.07245096f, -0.08264926f, 
    0.08173067f, -0.03232900f, 0.08089506f, 0.19519660f, -0.01274545f, -0.01527746f, -0.05134404f, -0.01185961f, 
    0.04807292f, -0.08998930f, -0.03711587f, -0.18817857f, 0.04157742f, 0.18248083f, -0.08087445f, 0.16895775f, 
    -0.06315569f, 0.05635157f, -0.16989923f, 0.03646131f, 0.00592727f, 0.06016128f, 0.01299372f, 0.03248592f, 
    -0.03051302f, -0.06742141f, 0.14427051f, -0.05756568f, 0.02533879f, 0.04050636f, 0.10931382f, 0.02364546f, 
    0.05351400f, -0.06891436f, -0.07178992f, -0.00830896f, -0.12801977f, 0.13480406f, -0.05078078f, 0.05790083f, 
    -0.10729598f, -0.11204316f, -0.11421492f, 0.02728532f, 0.05916786f, 0.10685395f, 0.03061642f, 0.01944672f, 
    -0.00190644f, -0.30222404f, -0.10739569f, -0.28745306f, -0.01861909f, -0.00231506f, -0.05578789f, 0.07462748f, 
    -0.04525712f, -0.04271646f, 0.00102069f, 0.03893999f, 0.13783322f, 0.14823309f, -0.09579028f, -0.00517794f, 
    -0.05365675f, 0.09621442f, -0.08456253f, -0.06065920f, 0.13521364f, 0.10377539f, -0.02324537f, 0.06543862f, 
    -0.12090923f, -0.05842190f, -0.21699336f, -0.06674891f, 0.00537859f, -0.07540267f, -0.01845765f, 0.07758789f, 
    0.06507555f, 0.12560177f, 0.01642558f, 0.03527924f, -0.19008738f, -0.02033036f, 0.00386832f, -0.37025836f, 
    -0.00252889f, -0.02157995f, 0.05626543f, 0.00066439f, 0.04297867f, -0.01091175f, 0.04187624f, -0.07841209f, 
    -0.05476755f, -0.10304128f, -0.03004539f, 0.08012126f, 0.04245012f, -0.02349428f, -0.01229704f, 0.05128303f, 
    0.06208035f, 0.04948086f, 0.00759086f, -0.08866660f, 0.05326092f, 0.30046797f, -0.11171867f, -0.02183347f, 
    -0.13858147f, 0.04192102f, -0.06973678f, -0.04491063f, 0.05923873f, -0.05498319f, -0.04453200f, -0.12046269f, 
    -0.00363765f, 0.14297828f, 0.13701384f, 0.12754965f, -0.03338919f, 0.04379293f, -0.21902572f, 0.05980283f, 
    0.02836899f, -0.03018485f, 0.02434698f, 0.00969963f, -0.11916298f, -0.03285019f, 0.12409738f, 0.12640870f, 
    -0.01508816f, -0.13442343f, 0.04079388f, -0.07210398f, -0.02975093f, 0.01294435f, -0.15468474f, 0.09698840f, 
    0.03473637f, 0.08003762f, -0.09299323f, -0.00359666f, 0.03385728f, 0.04726685f, 0.04315319f, -0.04484300f, 
    -0.00824098f, 0.00771162f, -0.03924317f, -0.04510399f, 0.10243634f, 0.11377241f, 0.06689312f, 0.07742121f, 
    -0.06128438f, -0.05085542f, -0.04714852f, -0.00572450f, 0.07883415f, -0.06635181f, -0.03855453f, -0.08668783f, 
    0.01941858f, -0.05642774f, -0.25976822f, 0.02510844f, 0.01794504f, 0.01034878f, -0.03678443f, -0.06858275f, 
    0.15659934f, 0.00069895f, 0.03794504f, 0.02449538f, -0.00435080f, 0.13766284f, -0.02347394f, 0.04792977f, 
    0.02673589f, -0.20719911f, -0.23240347f, -0.05766512f, 0.06520487f, -0.06944700f, -0.05107687f, 0.01343255f, 
    0.03366115f, 0.07621258f, 0.02544180f, 0.09428018f, -0.02834390f, -0.00247188f, -0.01168061f, 0.03091599f, 
    -0.05087705f, -0.02636964f, 0.06449428f, -0.11945705f, 0.00370253f, -0.19615649f, -0.25045761f, -0.09736095f, 
    -0.09216113f, -0.03196399f, 0.02653186f, -0.01243053f, 0.08400433f, 0.02046795f, 0.11169162f, 0.02261275f, 
    -0.11505389f, -0.18359824f, -0.08282305f, 0.30785543f, -0.00656726f, -0.03905730f, 0.03641132f, -0.10145769f, 
    0.04419233f, -0.02914572f, -0.03215550f, -0.03559215f, -0.11810508f, -0.26395085f, -0.04276527f, 0.04183832f, 
    0.01749073f, -0.04999923f, -0.03675047f, 0.04388135f, -0.06869645f, 0.13237740f, -0.00267261f, 0.02283225f, 
    -0.22138236f, -0.13129085f, 0.18653695f, 0.00413462f, 0.02611790f, -0.04294318f, 0.10661656f, -0.06380796f, 
    0.04890102f, -0.13796538f, -0.07917943f, 0.06964555f, -0.17509121f, -0.12119232f, -0.01270259f, 0.04637443f, 
    -0.04937613f, 0.13316078f, 0.05926732f, -0.01990392f, -0.06770405f, -0.02786223f, 0.08754190f, 0.01833588f, 
    0.25062466f, 0.10505334f, 0.23820695f, -0.04383751f, 0.08947171f, 0.06060620f, 0.11532391f, -0.08259068f, 
    0.01417737f, -0.11752261f, 0.04809375f, -0.07024383f, -0.12536158f, -0.05967641f, 0.04725659f, 0.17328563f, 
    0.08655705f, -0.09218927f, -0.06345526f, -0.16643350f, 0.03712005f, 0.03784913f, 0.05837615f, 0.15784486f, 
    -0.15685895f, 0.16306899f, -0.02047677f, -0.05953231f, 0.04170397f, 0.10651753f, 0.07175064f, -0.20820041f, 
    -0.03582117f, -0.03755771f, -0.02527645f, 0.01289116f, 0.12256079f, 0.06008296f, 0.08392552f, -0.33057642f, 
    -0.06268212f, 0.04597909f, -0.01699204f, 0.07952985f, -0.04984935f, -0.11634878f, -0.09715664f, 0.06276883f, 
    0.18891799f, -0.06211826f, -0.14045183f, 0.23386462f, -0.07329897f, 0.02570335f, -0.06439418f, -0.01985711f, 
    -0.02937990f, 0.02057188f, -0.00652103f, -0.02557077f, -0.17045160f, 0.15027718f, -0.04166456f, -0.08055121f, 
    0.04792685f, -0.05732473f, -0.19000053f, 0.06664961f, 0.04979833f, 0.11566424f, 0.04568348f, -0.04152073f, 
    0.19830820f, -0.13368268f, 0.00104787f, -0.11475748f, 0.09776952f, 0.08305014f, -0.00940266f, -0.04710577f, 
    -0.08354019f, 0.01365349f, -0.08071160f, 0.05634135f, -0.15426143f, 0.13013661f, -0.03941190f, -0.40663311f, 
    0.03907721f, 0.01547022f, -0.08191621f, 0.02777565f, -0.00339044f, 0.05148723f, -0.06399725f, -0.16176182f, 
    0.23247257f, -0.33735666f, 0.12067642f, -0.09454361f, 0.00966252f, 0.02796632f, -0.08295035f, -0.00055896f, 
    -0.11295194f, 0.03713117f, 0.01362722f, -0.01647588f, -0.14868009f, -0.10013980f, -0.00943935f, -0.15311864f, 
    0.11821705f, 0.00259845f, 0.08183288f, -0.03948057f, 0.08945923f, 0.04565262f, 0.05156854f, -0.04086548f, 
    -0.18859148f, 0.12427510f, 0.39157465f, -0.08405101f, 0.11143152f, 0.01938427f, -0.08057004f, -0.09292789f, 
    -0.03517408f, -0.00714429f, 0.04767196f, 0.00412447f, -0.05218977f, -0.02010788f, 0.21114422f, -0.06102689f, 
    0.11044046f, -0.08922634f, 0.04040000f, -0.08439002f, 0.06588282f, 0.07874240f, -0.10206004f, 0.12828109f, 
    0.11371643f, -0.20204152f, -0.03949307f, 0.09022280f, -0.05531796f, -0.03903542f, 0.04485781f, 0.12643853f, 
    -0.04851000f, 0.00041306f, 0.02491965f, -0.04495036f, 0.04884969f, -0.26689383f, 0.03842462f, -0.08074826f, 
    0.03393227f, 0.05425241f, -0.04564824f, -0.02125169f, -0.00408917f, 0.01021977f, -0.04765937f, 0.10964452f, 
    0.44675905f, -0.03374556f, -0.07682458f, -0.09852868f, 0.12353344f, -0.09261965f, 0.14427736f, -0.00662009f, 
    -0.03533097f, 0.05745370f, 0.06202354f, 0.19003503f, 0.13961476f, 0.08890045f, 0.02422233f, -0.23304446f, 
    0.01633518f, 0.04619829f, -0.02429642f, -0.12329615f, -0.05361550f, -0.01597150f, 0.04489009f, -0.03264036f, 
    -0.06210928f, -0.11339874f, 0.00654543f, 0.17596616f, -0.03326257f, -0.12402955f, -0.07605446f, -0.12855908f, 
    -0.10852312f, 0.04985628f, 0.01513179f, -0.12804037f, -0.16208664f, 0.04181220f, -0.02910812f, -0.00721855f, 
    0.06111425f, 0.00981897f, 0.01949251f, -0.06459819f, -0.03359867f, 0.03259026f, 0.14711381f, -0.02403040f, 
    -0.10984649f, -0.21383953f, -0.08548040f, 0.31709906f, -0.07376949f, 0.10434408f, -0.08158549f, 0.08199114f, 
    -0.03500807f, 0.01560656f, 0.09129044f, -0.03536645f, 0.07970954f, 0.12230080f, 0.08417547f, -0.00999811f, 
    0.07113802f, 0.05451560f, -0.02847584f, 0.03328801f, -0.08996201f, 0.01979552f, -0.08495326f, 0.02981052f, 
    -0.24811959f, 0.13835935f, -0.15473139f, 0.08749636f, -0.02917901f, -0.04083606f, -0.14733970f, 0.01932119f, 
    -0.01271505f, 0.00875469f, 0.04793903f, 0.04061147f, -0.02082537f, 0.16176961f, 0.01479204f, -0.27275822f, 
    -0.00503535f, -0.05983069f, -0.03339027f, 0.05213538f, 0.08146188f, -0.00557567f, 0.07171108f, -0.12370191f, 
    -0.14489965f, 0.23883368f, -0.20028660f, -0.36360207f, 0.04938104f, -0.00905555f, 0.00932539f, 0.06668729f, 
    -0.01139817f, -0.05486741f, -0.10521840f, -0.09827133f, 0.00409732f, 0.18102349f, -0.17166850f, -0.02116175f, 
    0.07536589f, -0.03014667f, -0.04934114f, 0.01649476f, 0.06046437f, -0.04202517f, 0.01840174f, 0.05603377f, 
    0.22007135f, -0.16635185f, -0.09892534f, -0.21053256f, -0.16247644f, -0.00589543f, 0.03758151f, 0.02373935f, 
    0.08190845f, -0.10829303f, -0.03011507f, -0.02611957f, 0.14128479f, -0.46538129f, 0.08349402f, -0.20959061f, 
    0.08246499f, 0.07428138f, 0.01736816f, -0.05512515f, -0.08806589f, -0.10032701f, 0.12353073f, 0.04375308f, 
    -0.16010252f, 0.16027835f, -0.15369309f, -0.02891722f, 0.12460889f, -0.02313175f, 0.09174372f, -0.00079948f, 
    0.03853067f, 0.06765765f, -0.07052183f, -0.03332612f, 0.00187265f, -0.14782506f, -0.00032633f, -0.15843116f, 
    -0.03995869f, 0.10122474f, -0.04650523f, -0.09911290f, -0.19724253f, -0.09185305f, -0.12716024f, 0.05196919f, 
    0.03092002f, 0.08889531f, 0.07017046f, -0.07185999f, 0.01790211f, 0.02062943f, 0.00759114f, -0.09903791f, 
    0.03506832f, 0.05036044f, -0.04676626f, -0.05170563f, -0.02292498f, -0.13655886f, 0.05540045f, 0.10030448f, 
    -0.14561582f, 0.00264761f, 0.01900210f, -0.03437587f, -0.08427691f, 0.04202949f, -0.05243717f, -0.04265603f, 
    0.04042677f, -0.19275388f, 0.13161014f, 0.17985128f, 0.13959612f, -0.12058112f, 0.01586905f, -0.02149520f, 
    -0.06912532f, 0.01885458f, -0.01174883f, 0.11556154f, 0.03105473f, 0.02803740f, 0.20270273f, -0.03903775f, 
    -0.00150698f, -0.03812958f, -0.02710931f, -0.01443759f, 0.12468322f, -0.08335058f, 0.00881962f, -0.06997526f, 
    -0.06759037f, -0.10337702f, -0.16646984f, 0.01328996f, 0.04392814f, 0.06717050f, -0.07167735f, 0.01134524f, 
    -0.01109116f, -0.00892286f, 0.03882958f, 0.01886731f, 0.18640599f, -0.14178412f, -0.17225051f, -0.01906971f, 
    -0.06737746f, -0.12366035f, 0.06124359f, -0.00510981f, -0.01209038f, -0.13439079f, -0.07099558f, -0.06195242f, 
    0.03779725f, -0.13413744f, 0.19067627f, -0.28781500f, -0.00829232f, 0.05117872f, 0.04448976f, -0.03451358f, 
    -0.00061050f, 0.08046394f, -0.11178794f, -0.01707873f, -0.11990035f, 0.22967862f, -0.19629988f, 0.11201853f, 
    0.01661940f, 0.04389744f, 0.07208523f, 0.04769656f, -0.01910834f, 0.05013911f, -0.01485997f, 0.03221226f, 
    -0.18727776f, 0.23611711f, 0.24320403f, 0.03876786f, 0.08724024f, 0.09156559f, -0.09547466f, -0.08149759f, 
    -0.02997616f, -0.05426100f, -0.06372475f, 0.03097106f, 0.29497436f, -0.56169021f, -0.07333336f, 0.14651068f, 
    0.08167604f, -0.04444132f, -0.04018329f, 0.11448284f, -0.09358733f, 0.09852579f, 0.05566402f, -0.07058296f, 
    0.34023109f, 0.03171872f, 0.04872027f, 0.17179754f, 0.02535299f, -0.10951272f, -0.03087969f, -0.02401622f, 
    0.04664003f, 0.03377014f, -0.02699754f, 0.03425203f, -0.00417945f, 0.01778113f, -0.00550629f, -0.08611820f, 
    -0.14203377f, 0.03692910f, -0.03827406f, 0.00043802f, -0.07686516f, 0.00229707f, -0.00059350f, -0.01846977f, 
    -0.09551489f, 0.20289347f, -0.07111852f, 0.08472440f, -0.04610483f, -0.00163880f, 0.11999850f, 0.02682654f, 
    0.08215570f, -0.02820573f, 0.07926243f, 0.07154505f, -0.04450601f, -0.06566431f, 0.06099596f, -0.14944898f, 
    0.08767381f, 0.10455176f, -0.04673553f, -0.09165084f, -0.07371109f, -0.02823210f, 0.03535201f, 0.06482823f, 
    -0.22571373f, 0.00180046f, -0.06476635f, -0.07740840f, 0.05681372f, -0.06520174f, -0.01136567f, -0.09774938f, 
    0.14775389f, -0.00834044f, -0.01415490f, 0.12365963f, 0.02526837f, 0.12326251f, -0.01047761f, 0.08408761f, 
    0.02990297f, 0.01598587f, 0.06863330f, 0.12938480f, -0.00259276f, 0.08324829f, -0.03888601f, -0.06999137f, 
    -0.40309358f, -0.16486323f, -0.04536010f, 0.07639493f, 0.05200116f, -0.07553484f, 0.02060093f, -0.12922925f, 
    -0.01248695f, -0.03432084f, 0.15315045f, 0.05923164f, -0.34749946f, 0.45962965f, 0.00658971f, 0.16434318f, 
    0.01278932f, -0.00683002f, -0.00019922f, 0.08923621f, 0.07738007f, 0.07113296f, 0.03430672f, 0.01012687f, 
    0.03029882f, -0.26349220f, -0.04124470f, -0.00271763f, -0.03847542f, 0.02910957f, 0.05589487f, 0.00379845f, 
    0.05835340f, 0.03224509f, -0.03743611f, -0.02795021f, 0.36176160f, 0.11407483f, 0.14443505f, 0.10960502f, 
    0.00929961f, 0.04792078f, 0.08069179f, 0.11146249f, 0.02782856f, 0.02872459f, -0.05544266f, 0.06456212f, 
    -0.08692813f, -0.02110533f, 0.07331894f, -0.25853729f, 0.01017937f, -0.02821580f, 0.04939645f, 0.04575171f, 
    0.13649434f, 0.01967414f, -0.01367541f, -0.03200101f, 0.05189758f, -0.24203408f, 0.01130919f, 0.03247178f, 
    0.07198237f, -0.01785414f, -0.03086999f, 0.04419988f, -0.08011764f, 0.03875127f, -0.02966794f, 0.06688919f, 
    -0.02356404f, -0.11943570f, -0.13213977f, -0.00597012f, 0.02804014f, 0.15691894f, 0.07677754f, -0.01093329f, 
    -0.04367368f, -0.01404999f, -0.05985713f, -0.00146895f, 0.02382440f, 0.16536283f, 0.14074659f, 0.07881806f, 
    0.04204949f, 0.02318011f, -0.05340338f, 0.12113501f, 0.01417599f, -0.04236729f, -0.02517326f, 0.05710339f, 
    -0.14074168f, -0.33963937f, -0.02871734f, -0.16104820f, -0.02645742f, 0.05715614f, -0.00825445f, 0.01633427f, 
    -0.09616042f, 0.02635831f, -0.13047898f, -0.07856476f, 0.14386155f, -0.05426868f, -0.15234832f, 0.00852291f, 
    0.00443685f, -0.06363056f, -0.00916274f, -0.15071861f, 0.04868050f, -0.08425432f, 0.16945969f, -0.06915873f, 
    -0.40999097f, 0.23640010f, 0.06022430f, -0.07594810f, -0.06618465f, -0.04926094f, 0.01770928f, -0.14320073f, 
    -0.00199384f, 0.03325163f, 0.06114815f, 0.02787418f, 0.19985178f, 0.14365138f, -0.27457148f, -0.02126795f, 
    0.06847375f, 0.08568045f, -0.03244692f, 0.04764958f, -0.09362157f, -0.03900260f, -0.11900511f, 0.11176813f, 
    -0.05805781f, -0.08853161f, 0.00853335f, -0.13012692f, -0.03923183f, 0.03550265f, 0.01174435f, 0.05962884f, 
    0.08848506f, -0.02122053f, -0.01142994f, 0.03702229f, -0.15219419f, -0.60877109f, -0.02224206f, 0.02289732f, 
    -0.07178012f, 0.01888064f, 0.07628582f, 0.11469235f, 0.00754298f, -0.05584301f, 0.15893902f, -0.07211466f, 
    -0.15561663f, -0.14210601f, 0.17781912f, -0.07483847f, 0.03485629f, -0.05555101f, 0.05209763f, 0.05199889f, 
    0.09147149f, 0.04463728f, 0.00436608f, 0.02746381f, -0.04884881f, -0.12235606f, 0.23351441f, -0.19342384f, 
    0.03243503f, -0.06581499f, -0.05325830f, 0.03834844f, 0.02730718f, -0.04777696f, -0.11246982f, 0.02536904f, 
    0.19294007f, -0.01315884f, -0.06040522f, -0.08030760f, -0.09241509f, 0.01651925f, 0.03855718f, -0.03996740f, 
    0.00876153f, 0.05154030f, -0.05870954f, 0.06927104f, 0.25609362f, 0.04045287f, -0.08917158f, -0.08549691f, 
    -0.11371899f, -0.03237230f, -0.03693382f, -0.11834694f, 0.05323256f, -0.05816809f, -0.05395554f, -0.13668056f, 
    0.08049992f, -0.00993606f, -0.11565026f, 0.11560578f, -0.12753516f, 0.07797523f, -0.08558437f, 0.05686098f, 
    -0.01347819f, 0.06727599f, 0.02847865f, 0.01307540f, 0.14675008f, 0.08399725f, 0.14930619f, 0.11356999f, 
    -0.00459371f, -0.03420210f, 0.03153226f, -0.00670864f, -0.01751412f, -0.01472472f, -0.05435361f, -0.00554896f, 
    -0.44428366f, -0.02812224f, 0.13347444f, 0.11039949f, 0.11968599f, -0.08140352f, 0.03798501f, -0.13969105f, 
    0.00928146f, -0.07265234f, -0.08261152f, 0.04694980f, 0.24724691f, 0.04273595f, -0.12851278f, 0.04347624f, 
    -0.19064000f, -0.14559685f, 0.08002415f, 0.08131741f, 0.05900586f, -0.00935852f, -0.03299604f, -0.14031531f, 
    -0.32843447f, -0.22326440f, -0.15016413f, -0.08145858f, 0.01226137f, -0.09469291f, -0.03488990f, 0.04540095f, 
    0.00470779f, -0.00818000f, 0.03871003f, 0.15277472f, -0.12745629f, -0.02424435f, -0.04617045f, 0.09880705f, 
    -0.04451371f, -0.02433879f, -0.00841825f, -0.11850679f, -0.04737292f, 0.11325383f, 0.03302630f, -0.11604809f, 
    0.11678672f, 0.06835806f, 0.02020072f, 0.02069387f, 0.01737636f, 0.01630739f, 0.05301894f, 0.01610410f, 
    -0.06853523f, -0.03962697f, -0.11171271f, -0.05063001f, -0.37154368f, -0.24816287f, -0.01503299f, 0.04764802f, 
    0.09820600f, 0.08461863f, -0.08237462f, -0.15758447f, 0.07225332f, 0.06193015f, 0.08218782f, 0.09196994f, 
    -0.03594014f, 0.09497330f, 0.04575349f, -0.00694637f, -0.02356704f, 0.00227537f, 0.08684391f, 0.06104873f, 
    0.04446510f, 0.10383876f, 0.10101838f, 0.02023035f, -0.39493352f, -0.13761181f, -0.08411676f, -0.22202624f, 
    0.06269898f, -0.06253773f, -0.08885185f, -0.01335341f, 0.03887456f, -0.06190158f, 0.02234055f, 0.00570770f, 
    -0.48780131f, -0.02554319f, 0.09877386f, -0.00857792f, 0.03917778f, 0.04510579f, -0.05747347f, -0.00059506f, 
    0.02683511f, -0.02278510f, -0.04846999f, 0.09223910f, 0.05167132f, 0.07130308f, -0.19111614f, -0.01913479f, 
    0.03566355f, -0.02623338f, -0.09088215f, 0.09366196f, -0.02221731f, 0.00297667f, -0.02437247f, 0.04485805f, 
    -0.03044188f, -0.06754334f, -0.09731251f, -0.04682235f, 0.01392304f, 0.04514129f, -0.01703533f, 0.04687708f, 
    0.14867403f, 0.17729463f, 0.06252673f, 0.01607771f, 0.05873457f, -0.06909792f, -0.21818386f, 0.00524365f, 
    -0.10152698f, -0.02260248f, 0.10590280f, 0.01417209f, 0.13007416f, 0.04112602f, 0.00469407f, -0.04750338f, 
    0.05972970f, 0.07955527f, 0.04432126f, -0.04766879f, 0.03993288f, -0.00978752f, 0.05359226f, 0.00645023f, 
    0.02689371f, -0.09293043f, -0.07200499f, -0.08174274f, 0.22464123f, 0.04009959f, -0.01039617f, 0.10496714f, 
    -0.07033602f, 0.04878761f, 0.00589646f, 0.12612748f, 0.08563177f, 0.04737987f, -0.10770368f, -0.01608090f, 
    0.03712412f, -0.09969375f, 0.06803509f, 0.07437286f, -0.10476968f, 0.00473618f, -0.00986993f, 0.01878170f, 
    -0.01639901f, -0.00476667f, 0.04829797f, -0.06246074f, -0.21845442f, 0.00341206f, 0.10665107f, -0.04535427f, 
    0.09741190f, 0.02740970f, 0.02873667f, 0.08446995f, 0.06050786f, 0.09164903f, -0.06481644f, -0.02066380f, 
    -0.28959441f, -0.23633710f, -0.10149854f, -0.04007975f, -0.03754592f, 0.16969737f, -0.11997139f, 0.02138611f, 
    0.04416745f, 0.17908509f, 0.00178336f, 0.15957713f, -0.22659260f, 0.00171361f, -0.05998330f, 0.05805985f, 
    0.09630300f, 0.12441345f, -0.02879190f, -0.05000062f, 0.00024494f, 0.08248799f, 0.07283084f, 0.19596124f, 
    0.17437786f, -0.05078565f, -0.00328332f, 0.13751686f, -0.10245385f, -0.05713967f, 0.03659347f, -0.01890267f, 
    -0.03537594f, -0.00140833f, -0.16235879f, -0.01159094f, -0.32157189f, -0.13270994f, -0.06167839f, 0.03153143f, 
    0.07966116f, -0.03002873f, -0.00545233f, 0.04526049f, 0.06639040f, 0.05309084f, 0.07450322f, 0.02671097f, 
    -0.28586936f, -0.24552155f, 0.24412949f, 0.06576334f, -0.04450953f, 0.08445457f, 0.10738826f, 0.08609837f, 
    -0.02757487f, 0.04943376f, 0.01077754f, -0.04012056f, -0.20896477f, -0.17480716f, 0.01486666f, -0.14908408f, 
    0.06815135f, -0.12589681f, 0.05394413f, -0.00315538f, -0.02549658f, 0.10625645f, 0.09380125f, 0.05277100f, 
    -0.50644618f, -0.28928992f, -0.14470609f, -0.31308165f, 0.05057637f, -0.04848951f, 0.01361793f, 0.04788162f, 
    -0.02390190f, 0.01070824f, 0.08782093f, 0.05368087f, -0.20626654f, 0.08575948f, -0.10850666f, 0.03640711f, 
    0.08457457f, -0.02493545f, 0.05068203f, -0.08299896f, 0.09379108f, 0.10173037f, 0.09289578f, -0.06291726f, 
    -0.02827523f, 0.17158046f, -0.13374430f, -0.11769658f, -0.00562009f, 0.13240795f, 0.01060656f, 0.00082184f, 
    0.02834003f, 0.05189889f, -0.00265006f, 0.04146083f, -0.16157450f, 0.29100847f, -0.03086742f, -0.00807188f, 
    0.01921571f, 0.10375459f, -0.04261841f, -0.03163251f, 0.17328045f, 0.00293103f, -0.14472024f, -0.02301626f, 
    -0.40640283f, -0.25455859f, -0.17063493f, -0.29733914f, -0.00531414f, 0.03106833f, -0.10183091f, -0.10157526f, 
    -0.00631100f, -0.05852513f, 0.01028737f, 0.02605421f, -0.28915849f, 0.13221994f, -0.09218757f, 0.00609988f, 
    0.12892699f, 0.05544907f, 0.05417014f, 0.00247155f, 0.05302016f, 0.17161116f, 0.10076097f, 0.10523812f, 
    -0.49448961f, -0.23741870f, -0.06605345f, -0.08503100f, 0.17594174f, -0.05367863f, 0.05163038f, -0.07118087f, 
    0.02929947f, -0.12030262f, 0.09703271f, 0.05922389f, 0.15404946f, 0.09947688f, -0.00837835f, 0.10497034f, 
    0.06537091f, 0.10186881f, -0.03243431f, 0.00833739f, 0.02479951f, 0.01828726f, 0.08656619f, -0.02125964f, 
    0.21712008f, 0.08633269f, -0.06576896f, 0.09425461f, -0.07033321f, -0.02814755f, -0.00276956f, 0.09052911f, 
    -0.00818669f, -0.02143770f, 0.04110700f, -0.00756958f, -0.18759170f, -0.17003055f, -0.02779946f, 0.16666980f, 
    0.05536867f, -0.02267817f, 0.03279283f, -0.08825263f, -0.00698376f, 0.09545261f, -0.12232446f, 0.12495996f, 
    0.25220415f, -0.01934170f, 0.00374135f, -0.06369510f, -0.08676437f, -0.06564508f, -0.02954908f, 0.00795177f, 
    -0.09278177f, 0.03254661f, -0.12041959f, -0.03710277f, 0.20730250f, 0.09756442f, -0.03256707f, -0.10759708f, 
    -0.03727747f, 0.09464792f, 0.06211068f, -0.01403033f, -0.02090190f, 0.11350732f, 0.04004242f, 0.09013526f, 
    0.25228930f, 0.20071916f, 0.10915392f, -0.13580161f, 0.15665485f, -0.05021335f, 0.07872172f, 0.07870982f, 
    0.00460962f, 0.00906561f, 0.11618511f, 0.03156897f, 0.34045082f, -0.00703107f, -0.00651803f, -0.00215249f, 
    0.04131161f, -0.02906273f, 0.05160729f, 0.02584180f, 0.00384429f, 0.07957888f, -0.04417447f, 0.03434833f, 
    -0.28299484f, -0.13292012f, -0.06392661f, 0.08904884f, 0.07433918f, 0.04873092f, 0.08816087f, -0.09946679f, 
    0.18092164f, 0.09032105f, 0.05435587f, 0.06178750f, 0.11244654f, 0.05173342f, -0.02006925f, -0.09506872f, 
    -0.03417745f, -0.06986005f, -0.02839952f, -0.07486967f, -0.08816882f, -0.12471581f, -0.18453051f, 0.07556967f, 
    -0.10104644f, 0.03446205f, -0.03934051f, -0.05324764f, 0.07496375f, -0.12703499f, -0.04779765f, 0.04355687f, 
    -0.02911943f, 0.05424583f, 0.00907228f, 0.09600072f, 0.21211645f, -0.02808854f, 0.04157022f, -0.03051740f, 
    0.12051326f, 0.13203305f, 0.03828588f, 0.01427648f, 0.06708225f, 0.09737308f, 0.07682393f, 0.09936321f, 
    0.13104907f, 0.03405589f, 0.07112990f, 0.02923747f, -0.05113273f, 0.09550095f, -0.01484928f, -0.02734798f, 
    0.05298239f, 0.04603846f, 0.03203616f, -0.08026852f, -0.35952166f, 0.06512710f, -0.07561070f, -0.08966246f, 
    0.09054964f, 0.01353371f, -0.05619219f, -0.01927305f, 0.07015685f, -0.09763870f, -0.01279402f, -0.01486556f, 
    0.01634332f, 0.03278872f, -0.12124801f, -0.07545726f, 0.11618721f, -0.14290059f, -0.11303543f, 0.02550317f, 
    -0.13200694f, -0.10579740f, -0.09832114f, -0.07329879f, -0.03256343f, -0.03468131f, -0.03726999f, 0.03536681f, 
    -0.02254110f, 0.04368719f, 0.06834649f, -0.04322158f, 0.07595102f, -0.01233796f, 0.07509172f, -0.06703751f, 
    0.07058232f, 0.01881761f, 0.01660399f, 0.14070399f, -0.05116689f, 0.00179223f, -0.00015603f, -0.10532197f, 
    0.12378248f, 0.09033333f, -0.00787303f, -0.02202353f, -0.36455950f, -0.42990777f, -0.03867648f, 0.02186197f, 
    -0.08003356f, 0.12227868f, 0.06173332f, -0.10518681f, 0.07765315f, -0.20728618f, -0.01258688f, 0.00656106f, 
    0.16803092f, -0.03462325f, 0.07160173f, -0.11805673f, 0.03990078f, -0.00196008f, -0.05311311f, 0.09960482f, 
    -0.02700022f, 0.00158573f, -0.13479854f, -0.08015626f, -0.04415892f, -0.05191166f, 0.08018795f, -0.10487034f, 
    0.00337908f, 0.06673770f, 0.04773566f, -0.06488665f, 0.09832323f, 0.08077034f, 0.03149167f, 0.09426973f, 
    0.14230086f, 0.16193311f, -0.07841525f, -0.10263031f, 0.02858977f, -0.06733868f, 0.02646862f, 0.05008269f, 
    -0.04923258f, 0.11925083f, 0.08955812f, 0.16798431f, 0.08735833f, 0.03221814f, 0.11972353f, 0.00556561f, 
    0.05868004f, 0.08359469f, -0.02599739f, -0.11606989f, 0.00705765f, 0.03939998f, 0.09967431f, -0.06257468f, 
    -0.32406193f, -0.04806135f, -0.04909264f, -0.13004521f, 0.03800518f, -0.07957111f, 0.06237346f, 0.10948780f, 
    0.03107535f, 0.13610040f, 0.03341046f, 0.08584960f, -0.05167356f, -0.10256252f, 0.10151582f, -0.13368042f, 
    -0.07703738f, 0.01649339f, 0.05174203f, -0.17980589f, 0.02676412f, 0.02356864f, -0.02971944f, -0.10488430f, 
    0.11876674f, 0.12362237f, 0.01237953f, -0.06824110f, 0.04958580f, 0.01893776f, -0.01879361f, -0.03866384f, 
    -0.05844036f, 0.00527826f, 0.12369366f, 0.05405185f, 0.00596814f, -0.04476453f, -0.11899755f, 0.09400935f, 
    -0.07350158f, -0.05684042f, -0.04885426f, -0.04097166f, -0.07355151f, -0.06173259f, -0.06418031f, 0.02378248f, 
    -0.27071306f, -0.21689589f, 0.05845641f, -0.01455165f, 0.13873044f, 0.00302597f, 0.06940030f, 0.00824649f, 
    0.16827644f, -0.00380630f, -0.01848981f, 0.02844409f, 0.16967724f, 0.06148904f, -0.06316624f, -0.12825075f, 
    0.04035285f, -0.08121201f, -0.04565138f, 0.08690739f, 0.02434078f, -0.02945266f, 0.06810454f, -0.00421993f, 
    0.00254907f, 0.05800794f, -0.09137414f, 0.03491762f, 0.05500530f, 0.01374203f, 0.02207397f, 0.05833193f, 
    0.08024663f, 0.00261543f, 0.02587409f, -0.06742927f, -0.22978507f, 0.04503937f, -0.02755940f, -0.15640199f, 
    -0.00756497f, -0.15371208f, -0.14408630f, -0.09689920f, -0.01236535f, -0.03253540f, -0.17577906f, -0.09197472f, 
    0.11067517f, -0.00401493f, -0.07254922f, -0.06238262f, -0.00969870f, -0.07311662f, 0.05602299f, -0.02118444f, 
    -0.00785321f, 0.03508148f, -0.06768049f, -0.17631578f, -0.20187099f, -0.04947617f, -0.04824761f, 0.04658800f, 
    -0.08634678f, -0.00198566f, -0.11277477f, -0.02986519f, 0.05062808f, 0.06639922f, 0.04983273f, -0.09468541f, 
    -0.04162668f, 0.12238055f, -0.00987063f, 0.01753017f, -0.02936795f, -0.04253760f, -0.05352252f, -0.05393242f, 
    0.04667686f, -0.06426974f, 0.08829372f, 0.05036659f, -0.06662795f, -0.00747855f, -0.13080767f, 0.11142701f, 
    -0.04404750f, 0.00353690f, 0.03393766f, -0.08368758f, -0.05110984f, -0.04415224f, 0.00177462f, -0.07761361f, 
    -0.03281187f, -0.08525017f, -0.12812684f, 0.04645036f, -0.05235197f, 0.02548218f, 0.03082807f, 0.04350740f, 
    -0.07628934f, -0.02076534f, -0.01398296f, 0.02445620f, 0.02987428f, -0.09566173f, -0.07678250f, -0.01484199f, 
    -0.01341051f, -0.03731473f, -0.08791158f, -0.11354353f, 0.07167391f, -0.01356214f, 0.09788483f, -0.06806310f, 
    0.33844537f, 0.17316511f, 0.00951101f, -0.19159374f, 0.04107928f, -0.01359302f, -0.10509223f, 0.00661296f, 
    0.08059903f, 0.08763298f, 0.03898156f, 0.07167974f, -0.27355349f, -0.06476357f, 0.02535853f, 0.00219090f, 
    -0.01607345f, 0.04063873f, -0.03964974f, -0.10634296f, 0.04425492f, -0.02989582f, -0.02478720f, 0.11042161f, 
    0.03904671f, 0.03184743f, -0.30134082f, -0.01787816f, 0.05317399f, -0.03993415f, 0.05842189f, 0.05526273f, 
    0.03057833f, -0.01503348f, 0.04830393f, -0.03332307f, 0.11563557f, 0.00386326f, -0.12618843f, 0.20250982f, 
    -0.04310742f, 0.06109742f, -0.10639036f, -0.04036853f, 0.04105029f, -0.07385385f, -0.04877489f, -0.05554430f, 
    -0.11861187f, 0.20682743f, 0.06789827f, -0.12598915f, -0.01432619f, -0.08194941f, -0.06102770f, -0.08245414f, 
    0.05885936f, 0.05808216f, 0.13501662f, -0.05255045f, 0.11234602f, -0.19693021f, -0.06158170f, -0.06092664f, 
    -0.02663321f, -0.00456915f, 0.06038101f, -0.00052202f, -0.11038510f, -0.05486692f, -0.15642589f, 0.03027522f, 
    -0.34722432f, 0.26309988f, 0.02122667f, 0.04857928f, -0.11576101f, 0.11334840f, -0.13827710f, 0.01088972f, 
    0.06666446f, 0.08392677f, -0.06312121f, -0.06974521f, 0.29066887f, -0.13344263f, -0.14191659f, -0.09500190f, 
    -0.01150242f, -0.00583728f, -0.02464145f, -0.07264513f, 0.01053128f, 0.02013437f, 0.07708947f, 0.05383744f, 
    0.43127584f, 0.15440744f, -0.14522882f, -0.00294637f, -0.09844400f, -0.09502734f, 0.03132112f, 0.02595497f, 
    -0.02169402f, 0.00530156f, 0.04804189f, 0.10631555f, -0.22782260f, 0.19486852f, -0.23872678f, 0.02144876f, 
    0.11456156f, -0.01674232f, 0.10805222f, 0.03502732f, 0.00352759f, -0.03920099f, 0.06393698f, 0.06765178f, 
    0.09945504f, -0.16852437f, -0.11594073f, 0.09220211f, 0.03273765f, 0.03284518f, -0.11104609f, 0.03671599f, 
    0.09113648f, -0.08749992f, -0.08067013f, -0.00845158f, -0.19527121f, -0.22513245f, -0.02801693f, -0.06020356f, 
    -0.06543130f, 0.04270396f, 0.01640639f, 0.03821951f, -0.06968708f, 0.01398335f, -0.04243130f, -0.08451328f, 
    -0.10659917f, 0.18449134f, -0.02961811f, -0.04939307f, -0.10647431f, -0.09051393f, 0.09811523f, -0.06448409f, 
    0.12905067f, 0.08234455f, 0.01379803f, -0.04752024f, 0.28842306f, 0.03071295f, 0.00916199f, -0.09063180f, 
    -0.13007203f, 0.05840717f, -0.03645421f, -0.14260194f, -0.02764877f, -0.06984401f, -0.02306950f, -0.03506394f, 
    -0.38897574f, -0.08488122f, -0.16932891f, -0.08846504f, -0.01983886f, -0.04079204f, 0.00193064f, 0.05838391f, 
    0.02531743f, 0.06236790f, -0.00999798f, 0.08439342f, 0.40534240f, -0.11937217f, -0.14664130f, 0.00727306f, 
    -0.03173058f, -0.11724731f, -0.03894314f, 0.07425251f, -0.01475647f, -0.01168234f, 0.00512614f, -0.04940761f, 
    -0.02584315f, 0.24681212f, -0.14343415f, 0.03050921f, 0.17213668f, 0.00669782f, 0.04389827f, 0.02227019f, 
    0.06064173f, -0.07299069f, -0.06133268f, -0.08195948f, -0.23835455f, 0.18137528f, -0.00657509f, 0.11874574f, 
    0.14712335f, -0.06253445f, 0.05248917f, -0.07057619f, -0.00013462f, 0.06218544f, -0.00558522f, 0.03483126f, 
    -0.11349877f, -0.00920869f, 0.07518993f, -0.13034369f, 0.02770972f, -0.11897559f, 0.11427160f, -0.05540701f, 
    -0.00111419f, -0.03929490f, 0.11673947f, -0.00465856f, 0.27933112f, -0.18357602f, -0.20774129f, 0.14283173f, 
    -0.07609260f, -0.02904100f, 0.02269420f, 0.01684104f, 0.00920577f, 0.08186590f, -0.03024052f, 0.00506842f, 
    -0.17766422f, 0.16878732f, 0.02364689f, -0.09123325f, 0.15954310f, -0.02421630f, -0.03087106f, 0.00146305f, 
    -0.00206123f, 0.09138483f, 0.05352941f, -0.03539654f, 0.14578572f, -0.18871246f, -0.07135521f, -0.00844235f, 
    0.04171348f, -0.04145009f, -0.10730617f, -0.01248903f, -0.02014777f, -0.00636831f, -0.05770678f, 0.03657226f, 
    0.17666186f, -0.16314939f, -0.13866653f, 0.23206444f, 0.05211405f, 0.04308045f, -0.02377308f, -0.01232174f, 
    0.03047429f, 0.00631104f, -0.01251694f, -0.10276794f, -0.10134681f, -0.17595555f, 0.01419971f, 0.18661386f, 
    -0.02278251f, 0.06664996f, -0.11886632f, -0.02287146f, 0.04552929f, -0.11838348f, 0.00133186f, 0.06569558f, 
    0.08564986f, -0.02998674f, -0.12032288f, 0.12447702f, 0.00425397f, 0.05435215f, -0.03958336f, 0.05191066f, 
    -0.00952962f, -0.03422528f, 0.12836787f, 0.01353362f, -0.00443678f, -0.07747717f, -0.04554409f, 0.15591854f, 
    -0.11813119f, 0.09417269f, -0.10786916f, 0.16671282f, 0.09685627f, 0.05229269f, 0.03711985f, 0.03901555f, 
    -0.09180688f, -0.16804834f, -0.10229164f, -0.23730730f, 0.04469224f, 0.05332014f, -0.00532496f, 0.01954638f, 
    0.05544687f, -0.05889917f, -0.03926649f, -0.05098880f, 0.16672578f, -0.06288567f, 0.03448223f, -0.06973133f, 
    -0.03137354f, -0.02489367f, -0.07031930f, 0.05585114f, 0.00976849f, -0.07271338f, -0.03493910f, -0.04449949f, 
    0.30151129f, 0.12794667f, -0.14985329f, -0.31639627f, 0.11687282f, 0.07923514f, -0.03943378f, 0.09197459f, 
    0.01071170f, 0.06289609f, 0.06688261f, -0.02256940f, -0.13830224f, 0.01516283f, 0.01184986f, -0.02602610f, 
    -0.11684418f, -0.13609023f, 0.07435764f, -0.02442268f, 0.06550351f, 0.05021341f, -0.01677125f, 0.00840188f, 
    0.12283529f, -0.00704619f, -0.01792265f, -0.00030973f, -0.01818051f, -0.02205012f, 0.00544261f, 0.00720233f, 
    -0.06326609f, -0.00041219f, -0.00565113f, 0.03278589f, 0.40585053f, -0.03744873f, 0.07860050f, 0.04792630f, 
    -0.00077377f, 0.08967265f, -0.11840031f, -0.01981178f, -0.06824549f, 0.03040859f, 0.08522047f, 0.07428568f, 
    -0.11991691f, -0.00977927f, -0.01619826f, 0.12870657f, -0.00297726f, 0.00586832f, 0.00942384f, -0.08350198f, 
    -0.06628620f, 0.03552470f, 0.03249705f, -0.06169387f, 0.11404350f, -0.03737490f, 0.05854238f, 0.07547972f, 
    -0.01571477f, 0.05059013f, -0.01091396f, 0.01434378f, -0.09954050f, -0.12491562f, -0.19883341f, -0.03306459f, 
    0.14168280f, 0.07200202f, -0.23841253f, 0.05145153f, 0.08152097f, -0.06492451f, 0.05770160f, 0.12480885f, 
    0.04104294f, -0.04042181f, -0.06523296f, 0.02478033f, 0.05409346f, -0.02166838f, 0.05290475f, 0.10686082f, 
    0.08791766f, -0.02609149f, 0.03100557f, 0.00704781f, 0.10849673f, -0.03570879f, -0.03495499f, 0.06795772f, 
    0.23619658f, 0.01876800f, -0.12226328f, 0.05410302f, 0.06858838f, -0.07962608f, -0.18073481f, -0.05417423f, 
    -0.05034918f, 0.02413134f, 0.01937724f, 0.07246220f, -0.37255010f, 0.12542033f, -0.05550004f, -0.01603767f, 
    0.00734010f, 0.06574059f, -0.00084812f, 0.09177252f, -0.08124410f, 0.01105890f, 0.05960834f, -0.15549269f, 
    -0.14571494f, 0.09527373f, 0.08225477f, -0.21497162f, 0.00768827f, 0.09815033f, -0.01376478f, -0.02324069f, 
    0.05980536f, -0.08908112f, -0.01844307f, -0.02958755f, 0.15680736f, 0.05448814f, -0.05358775f, 0.20063601f, 
    0.06144995f, -0.07277402f, 0.01197616f, -0.04292513f, -0.03908371f, 0.04317866f, -0.08483075f, -0.01879811f, 
    0.14258908f, -0.00617163f, 0.00795139f, 0.08582375f, -0.15195389f, -0.11657214f, -0.01084715f, 0.03315435f, 
    -0.07938159f, 0.06891996f, -0.07280573f, -0.07223436f, -0.06960599f, -0.13478504f, -0.02395779f, -0.20481697f, 
    -0.09374209f, -0.00508766f, -0.00505501f, 0.02787170f, 0.03983070f, -0.00035350f, -0.03534339f, -0.10131703f, 
    -0.15994222f, -0.17887649f, -0.12989812f, -0.32339412f, 0.01080706f, -0.08566179f, 0.04412706f, 0.07208905f, 
    0.00017144f, 0.01930323f, -0.02612247f, 0.19245744f, -0.20972225f, 0.04165930f, -0.03240587f, 0.10199043f, 
    0.03490692f, 0.00972540f, 0.11976022f, -0.04652278f, 0.08752266f, 0.03301625f, -0.00780384f, 0.00134580f, 
    0.12984614f, -0.07688958f, -0.02769348f, -0.11468054f, -0.12557729f, 0.05953117f, -0.14985466f, -0.04039011f, 
    -0.11525597f, 0.01396368f, 0.01323593f, -0.07393356f, -0.12208996f, 0.33094254f, -0.08370975f, 0.19231883f, 
    0.23042917f, -0.11049021f, -0.05197263f, -0.09676390f, 0.08158561f, 0.04199488f, -0.02591280f, 0.04983275f, 
    0.02363720f, 0.07398846f, 0.01277211f, -0.03248746f, -0.13743429f, 0.09630878f, -0.04963794f, -0.19500799f, 
    0.10262848f, -0.00049010f, -0.08954173f, 0.04927708f, -0.29509509f, -0.15190572f, 0.03115513f, -0.03244459f, 
    0.04137303f, -0.05246556f, 0.00783710f, 0.02722267f, 0.00586887f, -0.04570588f, 0.08636029f, -0.05014718f, 
    -0.09342121f, 0.14231786f, -0.15309747f, 0.04006412f, 0.15632851f, 0.06368342f, -0.01884596f, 0.11397605f, 
    -0.00861114f, -0.00170267f, 0.00657252f, -0.10293744f, -0.06021143f, 0.10383675f, -0.06732644f, 0.10618486f, 
    -0.15723102f, 0.00402669f, -0.07913966f, -0.08945756f, -0.00686565f, -0.07846879f, 0.02073158f, -0.01041372f, 
    0.05786533f, 0.20364489f, -0.09418667f, 0.01749430f, 0.09302379f, -0.09635098f, 0.01524886f, 0.03234972f, 
    0.07366941f, -0.07157920f, -0.02760041f, -0.03158963f, -0.02318913f, -0.11518793f, 0.01349896f, 0.04191210f, 
    0.04880947f, -0.01183241f, 0.04299637f, -0.04982735f, -0.14721011f, -0.01845274f, 0.00174145f, -0.08072809f, 
    0.14524741f, 0.12921336f, -0.02906203f, 0.01375828f, 0.04803492f, -0.01464818f, 0.07907389f, -0.11525204f, 
    0.02134668f, 0.08519898f, -0.14109913f, -0.01623397f, -0.08055834f, 0.11788616f, 0.08172005f, -0.19381663f, 
    -0.07501638f, -0.10244147f, -0.01411270f, 0.03178072f, -0.06293599f, 0.03367021f, -0.04205151f, 0.02906856f, 
    0.22119571f, -0.04139471f, -0.01140508f, 0.00287330f, 0.12115853f, 0.01043285f, -0.00731669f, -0.08941272f, 
    -0.02333734f, 0.03247161f, -0.00118826f, 0.01238487f, -0.15073100f, -0.26796269f, 0.10753476f, -0.00633741f, 
    -0.00897366f, 0.03647301f, 0.05781569f, -0.09230406f, 0.00987421f, 0.05057828f, -0.02489794f, 0.05210484f, 
    0.21520725f, -0.00077075f, -0.07081443f, 0.03709669f, -0.09649656f, -0.13839892f, 0.06168404f, 0.00856442f, 
    0.03569093f, 0.01791086f, 0.00851096f, 0.02862508f, -0.39651024f, 0.03581912f, -0.06570364f, 0.10698008f, 
    -0.04631139f, 0.12705892f, -0.09114682f, 0.08598955f, -0.04721972f, -0.10130536f, -0.05831838f, 0.02392979f, 
    -0.10035563f, -0.33725715f, 0.03849387f, 0.08268581f, -0.02161093f, 0.08604970f, -0.00242855f, 0.11807896f, 
    -0.00061197f, 0.01432216f, 0.00752641f, 0.02505846f, 0.25197995f, -0.04129884f, 0.05403735f, 0.15228963f, 
    -0.09378088f, 0.01281182f, -0.05561962f, 0.01465626f, 0.02285675f, -0.06785707f, 0.06091744f, 0.04839332f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.07738912f, 0.05275192f, -0.05550051f, -0.01222341f, 0.02950983f, 0.03533195f, -0.03166271f, -0.03135121f, 
    0.00356262f, 0.02637072f, 0.02658249f, 0.03777750f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
