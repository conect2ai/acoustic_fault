#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.19404995f, -0.67777640f, -0.54373777f, 0.71632844f, -0.60091913f, -0.27253503f, 0.26031497f, -0.13142323f, 
    -0.00975929f, -0.32185251f, 0.26278758f, -0.34344453f, -0.16169287f, -0.32810786f, 0.65776348f, -0.08298152f, 
    0.26479647f, 0.48141092f, -0.32857338f, -0.67662692f, -0.13049647f, -0.16548032f, -1.03259814f, -0.35698137f, 
    -0.15787923f, 0.71423352f, 0.16971742f, -1.21960318f, 0.79717231f, -0.01044106f, 0.34217978f, 0.32107234f, 
    0.43788889f, -0.12956296f, -0.10626545f, 0.40482488f, 0.22742152f, -0.97732145f, -0.57595479f, 0.40469843f, 
    0.32326320f, -0.29789263f, 0.68548191f, -0.35947093f, -0.28331786f, 0.62352848f, 0.68733984f, 0.59480208f, 
    -0.25948942f, 0.59926897f, -0.12255377f, -0.35434505f, -0.03785603f, 0.45958540f, -0.62198073f, -0.61343092f, 
    -0.36579815f, -0.52868980f, -0.54145676f, -0.58441883f, 0.11957525f, -0.17558913f, -0.44569740f, 0.78470904f, 
    0.12863179f, 0.59254891f, 0.17951076f, -0.78333086f, -0.55045831f, 0.01497623f, -0.24935931f, 0.05105997f, 
    -0.06253406f, 0.02646018f, 0.56902504f, -0.14451335f, 0.57262713f, -0.38255852f, 0.67171019f, -0.16475527f, 
    -0.44557473f, -0.93836069f, 0.27808419f, -0.48429379f, 0.45101169f, 0.59158546f, 0.17185210f, 0.25569278f, 
    -0.08111026f, -0.01627623f, 0.18548438f, -0.27532464f, 0.63410205f, -0.29445055f, -0.63941056f, -0.10245813f, 
    0.67899406f, 0.58781898f, 0.16778614f, 0.50629449f, 1.23817813f, -0.63416839f, -0.61962020f, 0.14564946f, 
    -0.17536998f, -0.04491748f, -0.19781263f, 0.25279498f, 0.14500573f, -0.51132876f, -1.07114732f, 0.31701148f, 
    0.82489526f, 0.45849815f, -0.26597038f, 0.08255888f, 0.13707303f, 0.65714306f, -1.01151836f, -0.06181806f, 
    0.14075451f, 0.67395920f, 0.63866943f, -0.49178672f, -0.52963251f, -0.30149972f, -1.04671621f, -0.48417237f, 
    0.33556390f, -0.13313548f, 0.72233087f, -0.48485833f, -0.25692496f, -0.18733360f, -0.30349514f, 0.82512039f, 
    0.43095270f, 0.18261270f, 0.14100941f, -0.04590733f, 0.05182097f, 0.27391317f, -0.15554543f, -0.46630675f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.16575499f, 0.17125836f, -0.11627119f, -0.15781085f, 0.25462660f, -0.21314858f, -0.32099327f, 0.05568664f, 
    0.22812614f, 0.08594909f, -0.18226472f, 0.12056866f, 0.03640843f, -0.06835006f, 0.03565129f, 0.11333947f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.15432352f, -0.11112656f, 0.22386478f, 0.20182370f, 0.23500983f, -0.03587526f, -0.14118728f, -0.16684194f, 
    0.05326701f, -0.05707496f, -0.02711223f, 0.04072752f, -0.09124568f, 0.15335615f, 0.04117279f, 0.14970456f, 
    0.00044416f, 0.12586617f, 0.05265262f, -0.10924809f, 0.19711097f, 0.19326524f, -0.14600205f, -0.03421324f, 
    0.18774742f, -0.06743532f, -0.14466067f, -0.02163828f, -0.04177455f, -0.23302984f, 0.10413785f, -0.01028511f, 
    -0.01299562f, -0.14743917f, 0.02869930f, -0.22751601f, -0.33848861f, -0.12005696f, -0.36505666f, -0.47554082f, 
    0.09072529f, -0.15283902f, 0.06424898f, 0.09438922f, 0.23175217f, 0.02596985f, 0.03329669f, 0.18478920f, 
    0.16223107f, 0.18304494f, -0.01297800f, 0.13235635f, -0.19514218f, -0.04284850f, -0.01336751f, 0.05648277f, 
    -0.02227932f, 0.08185582f, -0.24093165f, -0.19860864f, 0.06401178f, 0.00958448f, -0.24146639f, -0.10801881f, 
    -0.24866611f, 0.08548669f, 0.13902523f, -0.19498995f, -0.00286376f, -0.09803671f, -0.01809162f, -0.00070150f, 
    0.15707597f, 0.07035006f, -0.05862163f, -0.01677569f, -0.03761176f, -0.24420775f, -0.16612241f, -0.20728806f, 
    -0.20140299f, 0.05772609f, 0.30111051f, 0.19153136f, 0.23150346f, -0.09108005f, -0.02395966f, -0.16252683f, 
    0.07296373f, -0.11208853f, -0.01871949f, 0.08324666f, 0.09453475f, 0.11334018f, 0.04472444f, 0.02653946f, 
    0.02709605f, -0.03818644f, -0.03000278f, 0.02968720f, -0.01680598f, -0.11900757f, 0.08416013f, -0.48081255f, 
    0.14927638f, -0.02967833f, -0.02386975f, -0.05935287f, -0.01236124f, -0.05569290f, -0.03500665f, -0.04386003f, 
    0.12889424f, -0.10481380f, 0.23802620f, 0.12923895f, 0.03395320f, -0.03141672f, -0.13488410f, -0.23104434f, 
    -0.14712480f, -0.18932895f, -0.01172785f, 0.19974180f, 0.28786084f, -0.01019293f, 0.07205326f, -0.08640841f, 
    0.11055578f, 0.16043815f, -0.06306536f, 0.05446515f, 0.11182046f, 0.14898890f, -0.04470357f, 0.03345883f, 
    0.20544963f, 0.05453328f, 0.04577596f, 0.15900165f, -0.10467446f, 0.13689230f, 0.71118498f, 0.18127169f, 
    0.39529896f, 0.27204552f, 0.15946397f, 0.10856940f, -0.08671791f, -0.10127608f, -0.11291903f, -0.10931950f, 
    -0.09865651f, -0.06819113f, -0.06123034f, 0.03998129f, 0.04313713f, 0.10669611f, 0.07938818f, 0.13196705f, 
    0.04836881f, -0.13742699f, -0.09759371f, -0.15112334f, -0.32666025f, 0.07367729f, -0.30868125f, 0.09731753f, 
    -0.09484185f, 0.01936377f, 0.12652734f, -0.16563818f, 0.01409076f, -0.06300083f, -0.05855434f, 0.07756999f, 
    0.13520122f, -0.04113545f, -0.03994095f, 0.15088066f, 0.41548124f, -0.23359722f, 0.39209488f, -0.02480759f, 
    0.12518787f, 0.15734771f, -0.18059827f, -0.11340328f, 0.02641024f, -0.05357006f, -0.00687966f, -0.08223326f, 
    0.10966987f, -0.06577493f, -0.00255308f, 0.02087925f, -0.11952265f, -0.16766551f, -0.24229847f, -0.15853268f, 
    0.03779789f, -0.07235613f, -0.18897404f, 0.16104424f, 0.02735792f, -0.07850516f, 0.14107263f, 0.08817017f, 
    0.12903731f, -0.00687107f, 0.19884530f, 0.09475551f, -0.04096925f, -0.16961867f, -0.08299609f, -0.01957829f, 
    -0.33882177f, -0.19273141f, -0.51867390f, -0.41753137f, 0.09847150f, 0.04956586f, 0.40185106f, -0.08657990f, 
    0.39962533f, 0.15201299f, 0.14401823f, -0.11653805f, -0.13927148f, -0.19166602f, 0.04012119f, 0.00462891f, 
    0.09311776f, -0.23416850f, -0.10640556f, -0.08614736f, -0.03929949f, 0.02835950f, 0.02535381f, 0.01725502f, 
    -0.01175482f, 0.41425523f, 0.64889854f, -0.03197455f, 0.31204444f, -0.01932302f, -0.02577243f, -0.07148688f, 
    0.07172524f, -0.06749043f, 0.04248600f, -0.00999617f, -0.01897940f, 0.02644786f, 0.18360767f, -0.14496285f, 
    0.08941711f, -0.01446737f, -0.07862838f, -0.20833662f, -0.69099170f, 0.47303215f, 0.00203358f, -0.20324358f, 
    -0.09777062f, 0.15618959f, 0.05883487f, 0.16198027f, 0.15290514f, -0.01651658f, -0.12268176f, -0.07523713f, 
    -0.04980747f, 0.07948753f, 0.05135256f, 0.05985112f, 0.30218512f, 0.12845528f, 0.09787656f, 0.15644443f, 
    -0.12410305f, -0.07145932f, 0.10613789f, 0.20331371f, 0.39800018f, 0.02364314f, 0.09715633f, -0.00117676f, 
    -0.21055233f, 0.00314401f, -0.18593557f, 0.13652951f, 0.09149455f, 0.07416079f, 0.22281343f, -0.10095609f, 
    0.25927803f, 0.29487148f, 0.04962996f, 0.12725359f, -0.25325766f, -0.20545067f, -0.05288053f, -0.14207453f, 
    -0.19443046f, 0.02005710f, -0.22346845f, 0.09204337f, -0.10046235f, 0.01853049f, -0.02115877f, -0.04239833f, 
    -0.06589330f, -0.02887955f, -0.00446450f, 0.18767394f, 0.06903145f, -0.07446093f, -0.10577284f, 0.06144691f, 
    0.18947132f, 0.04106684f, -0.03925907f, 0.04228818f, 0.03209691f, -0.21386768f, 0.10396923f, -0.01458512f, 
    0.03614819f, 0.03097870f, 0.01999431f, -0.09114882f, 0.11041616f, -0.01382050f, 0.05242440f, 0.04826646f, 
    0.19038673f, -0.11226790f, -0.03912979f, 0.02932989f, -0.08263725f, -0.25575012f, 0.14788862f, 0.03063124f, 
    0.03992827f, 0.02586771f, -0.09708045f, -0.06999500f, -0.07345302f, -0.22291401f, 0.00659478f, 0.12069002f, 
    0.03561801f, 0.00498926f, -0.09878766f, -0.25485936f, -0.21893409f, -0.12166554f, -0.04975497f, -0.32058522f, 
    -0.00815825f, 0.24725309f, 0.18775125f, 0.07825736f, 0.24996574f, -0.16711828f, 0.06601533f, 0.07345951f, 
    0.15029129f, 0.24264097f, -0.16283259f, 0.10642139f, 0.11908153f, 0.04575410f, 0.02846167f, -0.06819237f, 
    -0.10548026f, -0.00701128f, -0.01477864f, -0.22525422f, -0.04444605f, -0.22916301f, 0.20072472f, -0.04522936f, 
    0.28014451f, -0.11377703f, -0.09158729f, 0.02545602f, -0.05123809f, -0.16329691f, -0.08813212f, 0.01916914f, 
    -0.07249164f, 0.07297668f, 0.23414141f, 0.12573282f, -0.01416540f, -0.21546109f, -0.20939371f, -0.16248921f, 
    0.06960664f, 0.03927357f, 0.00152270f, 0.16370860f, -0.09622942f, -0.04638190f, -0.02532787f, -0.07993238f, 
    0.11746226f, -0.00707177f, 0.07105196f, -0.10328743f, 0.04653956f, -0.06344073f, 0.07429378f, 0.02180645f, 
    0.05072968f, 0.08650283f, -0.09647993f, -0.00816274f, 0.03459239f, -0.45606151f, -0.38043055f, -0.16429801f, 
    -0.17145693f, 0.15062070f, 0.10603406f, 0.03234012f, -0.00050876f, -0.14195901f, 0.03979241f, 0.13205518f, 
    -0.02739928f, -0.08482890f, -0.01481839f, -0.04604111f, 0.07305141f, -0.00896547f, -0.13021474f, -0.03341837f, 
    0.04557351f, 0.17965619f, 0.06622490f, 0.06433591f, 0.25041768f, -0.15728320f, 0.11547595f, -0.06017141f, 
    0.06828155f, 0.28371710f, -0.03402943f, 0.01264542f, 0.02822128f, 0.16966344f, 0.09523354f, 0.07423342f, 
    0.05263218f, 0.05011075f, -0.03431728f, 0.23061143f, 0.11400011f, -0.19300427f, -0.30904424f, -0.21601497f, 
    -0.03568422f, 0.12979321f, 0.10070060f, 0.09512990f, 0.03069091f, 0.18908323f, -0.15907796f, -0.01000650f, 
    0.04614400f, 0.10278238f, 0.03356765f, 0.06871151f, -0.04549073f, -0.05605957f, 0.17231768f, 0.07833164f, 
    -0.27930000f, -0.42257345f, 0.05460194f, -0.34464300f, -0.00756224f, -0.16832450f, 0.09628960f, -0.04997306f, 
    -0.06145199f, 0.11621064f, -0.03324875f, 0.01177678f, -0.00761417f, 0.02449019f, 0.07826004f, 0.08013425f, 
    0.06150121f, -0.11424537f, 0.00173680f, 0.11182439f, 0.29734388f, -0.60864943f, 0.16483605f, 0.12867902f, 
    0.00354341f, -0.04961678f, -0.08382268f, -0.05567119f, -0.05162631f, -0.06534541f, -0.06125320f, -0.03815688f, 
    0.01761408f, -0.05774967f, 0.10735247f, 0.23289560f, 0.01990339f, -0.14223641f, -0.12229533f, -0.06122542f, 
    -0.06138076f, 0.21389015f, 0.28267792f, -0.31951669f, 0.10451614f, -0.05100738f, 0.02058683f, 0.08783694f, 
    0.03984025f, 0.03757150f, -0.02225805f, -0.03986950f, 0.12629782f, 0.17879707f, -0.03784239f, -0.12005879f, 
    -0.25067490f, -0.14961512f, 0.01302260f, 0.01094059f, -0.51028109f, -0.44443503f, -0.15154561f, -0.07773495f, 
    -0.57913113f, 0.23517497f, 0.10712721f, -0.06190245f, -0.00542497f, 0.09638724f, -0.01124000f, -0.04200198f, 
    0.05502143f, 0.09352046f, -0.04499242f, -0.19226778f, -0.00791704f, -0.05427320f, -0.14305487f, 0.03333994f, 
    0.50270241f, -0.29932883f, 0.15392819f, 0.18691477f, -0.18901962f, -0.06674612f, -0.17883372f, -0.00528565f, 
    0.11063717f, -0.09968019f, 0.23936947f, -0.01664507f, -0.10733539f, 0.00678651f, 0.02213104f, 0.04772825f, 
    0.14284013f, -0.04291255f, -0.06462915f, -0.12436181f, 0.12235552f, 0.02882898f, 0.27398047f, 0.29998586f, 
    -0.09797122f, 0.03160828f, -0.00317302f, 0.06063701f, 0.13373530f, -0.06811810f, 0.02116507f, -0.15368254f, 
    0.03723104f, 0.25128588f, -0.07547482f, 0.01991988f, 0.18970196f, -0.02131472f, -0.06300987f, 0.02324378f, 
    0.12975037f, -0.14454551f, 0.20086089f, 0.03735594f, 0.19500321f, 0.03994788f, -0.01671248f, 0.03207134f, 
    -0.02671611f, 0.20424233f, 0.13724883f, 0.01789007f, 0.11384666f, -0.08462095f, -0.02750086f, 0.10313996f, 
    0.02300685f, 0.10252104f, -0.01348408f, -0.00040105f, -0.07543151f, -0.56737542f, -0.44038641f, -0.09871755f, 
    0.03188826f, -0.06328207f, 0.09403045f, 0.16628668f, 0.03178904f, -0.10375412f, -0.02511047f, 0.13885134f, 
    -0.07511586f, 0.01495759f, 0.04935200f, 0.08102486f, 0.09821060f, -0.00445877f, 0.06494602f, 0.12886041f, 
    0.09378421f, 0.04280082f, 0.29693472f, 0.00965882f, -0.17423181f, 0.00080918f, 0.09065513f, 0.09914028f, 
    0.05160582f, 0.14539035f, 0.04249292f, -0.07502265f, -0.03261621f, 0.01568716f, 0.02273305f, 0.01509937f, 
    -0.01777643f, -0.00963404f, -0.07385181f, 0.02530438f, -0.12450052f, -0.03305532f, 0.03361609f, 0.03076808f, 
    -0.20372969f, -0.08899689f, 0.04086963f, -0.07355427f, 0.09156696f, 0.13994329f, 0.01766917f, -0.04519746f, 
    -0.01636623f, -0.05209710f, 0.00003087f, 0.11564046f, 0.10473685f, -0.08657847f, 0.00488646f, 0.23287782f, 
    0.13502461f, -0.03070804f, 0.45638061f, 0.12947582f, -0.04637839f, -0.06522878f, 0.03542811f, 0.03297084f, 
    -0.06924829f, 0.07391866f, 0.06141210f, -0.01932250f, 0.10623596f, 0.07098527f, 0.02254459f, -0.06258619f, 
    0.13476491f, -0.08599830f, -0.01162893f, 0.10527141f, -0.88946277f, 0.24865565f, -0.27951133f, 0.04693457f, 
    -0.19978273f, -0.13673392f, -0.07114018f, -0.12977888f, -0.01840662f, 0.03919073f, 0.26501167f, 0.00540233f, 
    -0.02836498f, 0.05518120f, 0.04404536f, 0.11390537f, -0.04280937f, 0.08022867f, 0.08533739f, 0.08316918f, 
    0.33343989f, -0.07013473f, 0.09389278f, -0.12365196f, -0.15620621f, -0.02897458f, 0.10637078f, 0.11183309f, 
    0.05363610f, 0.12828074f, 0.00701961f, -0.01651022f, 0.02751500f, 0.07443383f, -0.01194970f, -0.10898652f, 
    -0.03295361f, -0.09919121f, 0.12870240f, -0.17940822f, -0.20553155f, -0.23180725f, -0.36793461f, 0.24614017f, 
    -0.12352996f, -0.02208003f, -0.00671453f, -0.08959927f, -0.16013609f, 0.10692116f, 0.13939926f, -0.04259253f, 
    0.06883623f, 0.08196554f, 0.08343937f, 0.04547098f, -0.09394104f, 0.06848547f, -0.04991648f, 0.07320557f, 
    -0.03873406f, -0.02909197f, 0.30841425f, 0.19349913f, -0.14478163f, 0.00108034f, -0.03358100f, 0.16917811f, 
    -0.07173263f, 0.04760971f, 0.15086193f, 0.00108533f, 0.04176661f, 0.02301921f, 0.09714833f, -0.02053103f, 
    0.11967957f, -0.11840729f, 0.06479248f, 0.00537616f, 0.43627945f, -0.07479995f, -0.60350847f, -0.13905482f, 
    0.08252229f, -0.10897117f, -0.04784825f, -0.21248840f, -0.02096841f, -0.01424208f, 0.00734418f, 0.01275277f, 
    0.05694060f, -0.08807560f, -0.09021734f, 0.10763581f, 0.10641607f, -0.03955799f, -0.04217648f, 0.01271405f, 
    -0.03424807f, 0.12720498f, -0.34277460f, 0.20836125f, 0.07981779f, 0.07954305f, -0.11511057f, 0.00682246f, 
    0.00072989f, -0.08253797f, -0.02674184f, 0.00570585f, -0.16153876f, 0.01369291f, 0.15735021f, 0.08707464f, 
    0.08032613f, 0.02466077f, -0.08746182f, -0.12308335f, -0.65666723f, 0.53284389f, -0.33637270f, -0.13642719f, 
    -0.17089543f, -0.17229618f, -0.11131207f, -0.04523009f, -0.01638222f, 0.10841770f, 0.17373772f, 0.06657846f, 
    0.06120736f, 0.05842753f, -0.01274237f, -0.02440926f, 0.00219370f, 0.18343227f, -0.06489212f, -0.09811763f, 
    -0.07162840f, 0.04614286f, -0.08704024f, 0.22559434f, -0.04684899f, 0.15186031f, -0.07745921f, 0.00125184f, 
    -0.12312020f, 0.01105134f, -0.08629293f, -0.08578471f, 0.00398424f, 0.08775305f, 0.05661698f, 0.04089361f, 
    0.23370242f, 0.12588874f, 0.15184487f, -0.15979405f, 0.42280230f, 0.48433340f, -0.89713609f, -0.09953342f, 
    -0.15774818f, 0.04610785f, -0.09739244f, -0.10123678f, -0.14853121f, -0.01157050f, 0.09022646f, 0.00209244f, 
    0.22301072f, 0.02814776f, 0.13794401f, 0.18756178f, 0.01118258f, 0.12298819f, -0.03824098f, 0.04796754f, 
    -0.42757052f, -0.26636991f, -0.19234671f, -0.16525662f, -0.16208692f, -0.10988906f, -0.03347684f, -0.15135804f, 
    -0.13237268f, -0.02771539f, 0.00073668f, 0.08057216f, 0.02098777f, 0.05688654f, 0.08316474f, -0.02860642f, 
    -0.08590642f, 0.12384343f, -0.07191961f, 0.03042502f, 0.25892299f, -0.67723793f, -0.22771627f, -0.21749265f, 
    0.06534664f, -0.12931505f, -0.05737755f, -0.15952504f, -0.12204536f, -0.08768573f, 0.02404947f, 0.10275356f, 
    0.00115648f, -0.04820648f, 0.08824088f, 0.01768374f, -0.15754178f, -0.05665532f, 0.07302871f, 0.02322261f, 
    -0.31340000f, -0.11502636f, -0.03774488f, 0.20107304f, -0.14775969f, -0.07930552f, 0.00522482f, 0.00234433f, 
    0.10896461f, -0.00150884f, 0.01018037f, -0.10957126f, 0.03746141f, 0.06166800f, 0.08720516f, 0.03057155f, 
    -0.02149555f, 0.06175239f, 0.03867368f, 0.06000916f, 0.14179075f, -0.08005030f, -0.41045314f, -0.01049609f, 
    0.22426505f, -0.01216835f, -0.04766906f, -0.07002339f, -0.03475491f, -0.00342954f, -0.00124720f, -0.07784286f, 
    0.07148533f, -0.06890914f, 0.06107744f, 0.00946598f, 0.12042858f, -0.06109729f, -0.01899310f, -0.06131521f, 
    -0.16851933f, -0.19248804f, 0.27119556f, 0.13739014f, -0.17688271f, -0.05071669f, -0.13824435f, -0.17542972f, 
    0.12393044f, 0.06359583f, -0.02830286f, 0.03237394f, -0.11305337f, 0.10660482f, -0.02601642f, 0.07147574f, 
    0.02288208f, 0.07697254f, 0.07297205f, -0.06170863f, 0.08525864f, 0.45320234f, 0.06315895f, 0.01786733f, 
    0.07698264f, -0.03074108f, -0.03133390f, -0.11964000f, 0.22969374f, 0.03057116f, 0.07136784f, -0.00482379f, 
    -0.12035657f, -0.17576090f, -0.00874761f, -0.00099129f, -0.09081364f, -0.08868679f, -0.10058855f, -0.15924254f, 
    -0.02460843f, -0.39613265f, 0.34366962f, 0.07290216f, -0.14139016f, 0.01194585f, -0.15809901f, 0.08362491f, 
    -0.03749532f, 0.07161897f, 0.09606869f, -0.01493580f, -0.03562290f, -0.06157868f, 0.03855200f, 0.04411308f, 
    -0.05555415f, 0.01929292f, 0.20818697f, -0.04254027f, -0.06719413f, 0.12539732f, -0.08205534f, 0.08679727f, 
    -0.07766684f, -0.04621416f, 0.03097966f, -0.04373568f, 0.02854330f, 0.26687533f, 0.15358162f, 0.12206929f, 
    0.13143456f, 0.04851038f, -0.00966870f, -0.04331461f, -0.07820911f, -0.07665812f, -0.02209412f, 0.07561227f, 
    -0.25674364f, -0.01209882f, 0.49836501f, 0.22998022f, 0.01138789f, -0.07457329f, 0.02204167f, -0.13848686f, 
    0.05868959f, 0.10450294f, -0.11149871f, 0.08142862f, 0.11547500f, 0.01879028f, 0.01951891f, 0.00222821f, 
    0.04682989f, 0.12443977f, 0.13690355f, 0.01981083f, -0.24110813f, -0.12952222f, -0.04152813f, -0.27543262f, 
    -0.14052090f, 0.02546550f, 0.01698499f, 0.07884439f, 0.09887457f, 0.11038676f, -0.02509732f, -0.03990952f, 
    -0.09557767f, 0.01366542f, -0.02205179f, -0.06830548f, 0.05342115f, 0.00175864f, -0.06092400f, 0.00634142f, 
    -0.17548923f, -0.41046390f, -0.22495078f, 0.08991103f, -0.17732361f, 0.03287772f, -0.05977099f, -0.01076119f, 
    0.05273349f, 0.04498636f, -0.00824694f, 0.11203488f, 0.11153164f, -0.00430810f, -0.08172841f, 0.09314750f, 
    0.10045058f, 0.11330804f, 0.41814080f, 0.01338258f, 0.12541156f, -0.33057022f, 0.08738065f, 0.17547019f, 
    0.17489335f, 0.08132036f, 0.14094184f, 0.44034764f, 0.02904758f, -0.07078507f, -0.06913091f, -0.03294703f, 
    -0.17717208f, -0.05072455f, -0.09832648f, -0.00024123f, -0.00112771f, 0.15523392f, 0.03469288f, 0.09704047f, 
    -0.15951166f, -0.03382079f, -0.00822992f, -0.00297110f, -0.19656666f, -0.00467374f, -0.06148899f, 0.17764151f, 
    -0.04479713f, 0.06401122f, 0.16124709f, -0.07795205f, -0.04071296f, 0.01120244f, -0.12300241f, 0.03153701f, 
    0.21922411f, 0.01917495f, -0.07985510f, 0.18759058f, -0.08255769f, 0.21438086f, 0.28387707f, 0.01657556f, 
    0.12490313f, -0.04653229f, -0.02772940f, -0.10991859f, 0.07487165f, 0.25590324f, 0.02456291f, 0.00628961f, 
    0.11124050f, -0.01513523f, 0.02968273f, -0.06553984f, -0.17479655f, 0.09567174f, -0.13647418f, -0.05677251f, 
    0.12853706f, -0.12704484f, -0.15998027f, 0.15837243f, 0.04165390f, 0.00878587f, 0.04371852f, 0.13864239f, 
    -0.01597843f, -0.07389843f, 0.08523392f, 0.01781045f, -0.04769257f, -0.25540617f, -0.05246948f, 0.03771546f, 
    -0.13333151f, -0.06871379f, -0.20284432f, -0.14620908f, 0.32646042f, 0.25219986f, -0.23686273f, -0.05896257f, 
    0.17704307f, 0.05822075f, 0.06332514f, 0.29935223f, -0.05500880f, -0.11393591f, 0.02812055f, 0.05224562f, 
    -0.08925641f, -0.23698115f, 0.01706337f, -0.01657854f, -0.12672019f, 0.33154014f, -0.01919201f, -0.02720379f, 
    -0.60122657f, 0.54547149f, 0.41602907f, -0.14363649f, 0.37946624f, -0.16023517f, 0.01488488f, -0.23142356f, 
    0.17410690f, 0.14054680f, -0.11135542f, 0.07572045f, 0.10698625f, 0.14183195f, 0.06592812f, -0.10928423f, 
    -0.07774726f, 0.11192072f, -0.12170321f, 0.07324682f, -0.58552277f, 0.02407203f, -0.33735648f, -0.19539058f, 
    0.09489623f, -0.07352175f, -0.05712207f, -0.08764339f, -0.00094219f, 0.00223604f, -0.05190353f, 0.13522848f, 
    0.08930375f, 0.14753130f, 0.11477374f, 0.15655006f, 0.08750735f, 0.12587254f, 0.09049273f, 0.35915846f, 
    -0.23213688f, -0.21385220f, -0.09764864f, 0.38132992f, -0.05808881f, -0.00390228f, -0.00603323f, -0.10589542f, 
    -0.19031554f, 0.02625256f, -0.11889879f, -0.01326445f, 0.15137540f, 0.16221538f, 0.11990459f, 0.07198038f, 
    0.14875388f, 0.23601186f, 0.22373272f, 0.14725733f, -0.07419215f, -0.10979433f, -0.13740149f, -0.23464453f, 
    -0.29204339f, -0.02350295f, 0.07972299f, 0.09740216f, -0.01487381f, 0.15597323f, 0.00176917f, -0.04791376f, 
    -0.03293368f, -0.04420278f, -0.07122673f, 0.01721570f, 0.13250023f, -0.14845334f, -0.15883826f, 0.08737794f, 
    -0.03256411f, 0.00037732f, 0.01676786f, 0.03903674f, -0.05368639f, -0.00974113f, -0.05477478f, 0.00659094f, 
    -0.02453854f, 0.03237283f, -0.03244763f, -0.05747788f, -0.01439088f, -0.04928019f, 0.04261927f, -0.04635119f, 
    0.01413509f, 0.01311701f, 0.03036476f, -0.01962017f, 0.01056678f, -0.00341989f, 0.03611489f, -0.03321672f, 
    -0.02587637f, 0.00060960f, -0.03177006f, 0.03254194f, -0.02352921f, -0.05035576f, 0.00472305f, 0.03720750f, 
    -0.01357452f, -0.00910671f, 0.05820196f, -0.01649607f, -0.02584804f, 0.04287199f, -0.01806160f, -0.05128472f, 
    0.01877689f, -0.05491727f, -0.00250715f, 0.01811399f, 0.00131308f, -0.01143068f, -0.04929978f, 0.01113250f, 
    -0.04236227f, 0.01734548f, -0.04287035f, 0.00414226f, 0.01143303f, -0.01779525f, 0.03070793f, -0.05267621f, 
    0.03009108f, 0.01640144f, 0.02318366f, -0.01350198f, 0.02361718f, 0.03730164f, 0.02368897f, -0.05043058f, 
    0.01511739f, -0.03004842f, 0.05086191f, 0.03245959f, -0.00249833f, -0.02450611f, 0.04447790f, 0.02034906f, 
    -0.01030522f, 0.03656954f, 0.01247537f, 0.04750779f, 0.00601918f, -0.03064072f, -0.01875226f, -0.02066579f, 
    -0.00898293f, -0.02695898f, -0.00866507f, -0.03336818f, -0.02751055f, -0.02491724f, 0.03352141f, -0.01183761f, 
    0.01378272f, 0.03593822f, 0.04843970f, 0.03313089f, 0.02523218f, 0.00027432f, 0.02307927f, 0.03930523f, 
    -0.03006961f, -0.05939134f, 0.02051759f, -0.04716318f, 0.04418128f, -0.04520326f, -0.03695346f, 0.00469029f, 
    -0.03214865f, 0.04685285f, 0.04370868f, 0.03252272f, 0.02787944f, 0.03679829f, 0.00700595f, 0.02293831f, 
    -0.01527671f, -0.01518771f, -0.06051959f, 0.00676583f, -0.04081710f, -0.03406044f, -0.00221751f, 0.02467307f, 
    -0.01797201f, -0.00011514f, 0.00573194f, -0.01952640f, 0.02314077f, 0.03122719f, -0.05786568f, 0.04437474f, 
    -0.04292037f, -0.00245089f, -0.03515546f, -0.05163750f, -0.01584955f, -0.03447976f, -0.04591585f, -0.00063639f, 
    0.00718476f, 0.01796562f, -0.00725155f, -0.01283815f, 0.04550863f, -0.05833428f, -0.04500127f, -0.01037625f, 
    0.00180360f, -0.03666114f, -0.01851538f, -0.05943974f, 0.02383558f, -0.02231590f, -0.05207157f, 0.01919134f, 
    0.05419266f, -0.05198761f, -0.02870987f, -0.01698195f, -0.01144054f, 0.01760102f, -0.04642737f, -0.00497069f, 
    -0.02006493f, 0.01376498f, 0.01045041f, -0.02502845f, -0.02775041f, 0.02796826f, 0.00474339f, -0.03865209f, 
    0.03916012f, 0.01427839f, -0.02791422f, -0.01720099f, 0.01331376f, -0.06060059f, -0.05068942f, -0.05565976f, 
    -0.02260668f, -0.00664980f, -0.04848617f, -0.05710395f, 0.04358758f, -0.00976156f, 0.03535293f, -0.01867862f, 
    0.01165175f, 0.02171115f, -0.05654388f, 0.00833399f, 0.02496609f, 0.00661828f, 0.01808954f, 0.03362741f, 
    -0.00073499f, 0.01688763f, -0.05687158f, 0.02162575f, -0.03485528f, -0.05058030f, -0.00715465f, -0.02703637f, 
    -0.04727834f, -0.03698210f, -0.03118301f, -0.01351662f, -0.00669971f, 0.02011285f, 0.04055118f, -0.00739047f, 
    -0.05851626f, -0.06374837f, -0.05404390f, -0.02347099f, -0.01270061f, 0.01338468f, 0.01207941f, 0.00817956f, 
    -0.03443858f, 0.01619634f, -0.02509047f, -0.05405920f, -0.02772757f, 0.04916686f, -0.00380901f, -0.03119053f, 
    0.03352262f, -0.02770917f, -0.04917027f, -0.03044996f, -0.04621887f, 0.00646955f, 0.01799470f, -0.00688540f, 
    0.00709077f, -0.05793945f, -0.04951640f, -0.04606607f, 0.00634154f, 0.03234768f, 0.04163356f, -0.04002997f, 
    0.02446465f, -0.01342882f, 0.01971842f, 0.00592846f, -0.01070038f, -0.05349079f, -0.01323394f, 0.02800289f, 
    -0.02256523f, -0.04214354f, -0.05846274f, -0.03326268f, -0.04120168f, -0.00332367f, -0.01285076f, 0.00495324f, 
    -0.06174706f, 0.01025050f, -0.06395420f, 0.00625910f, 0.01039917f, -0.04655954f, -0.06078746f, 0.03324673f, 
    0.03655877f, -0.06350084f, 0.03282825f, -0.02089915f, 0.00291191f, 0.01181754f, 0.03448595f, 0.00976743f, 
    -0.01209795f, -0.03213517f, 0.02212742f, -0.03907574f, -0.02630677f, -0.05885324f, -0.00875961f, 0.04154446f, 
    -0.00870647f, -0.00448829f, -0.03958929f, -0.03779629f, 0.04585997f, 0.02698973f, -0.00552690f, 0.00473783f, 
    -0.04290678f, -0.03309855f, -0.05827662f, 0.01366676f, -0.01845822f, 0.02671348f, -0.05550398f, -0.01159399f, 
    -0.00761502f, 0.03857391f, 0.04295817f, 0.03492755f, 0.03117054f, -0.02411916f, 0.03564068f, -0.00781705f, 
    -0.05533045f, -0.04847357f, -0.05656255f, -0.01170739f, -0.04380028f, -0.01469438f, -0.03178742f, 0.01423675f, 
    -0.04986472f, 0.01024173f, 0.03584027f, -0.04878620f, -0.06052210f, 0.02190019f, 0.03654554f, 0.02756782f, 
    -0.06229281f, -0.18381870f, 0.33196306f, 0.08877702f, 0.14707081f, 0.00430568f, 0.00363978f, -0.01224283f, 
    0.09172084f, -0.07664517f, -0.04501935f, 0.07595865f, -0.02152069f, 0.05622552f, 0.04309963f, 0.05345817f, 
    -0.03890977f, 0.06137070f, 0.05486244f, -0.04572964f, -0.10096800f, -0.16045281f, -0.26007864f, -0.04947248f, 
    -0.03992338f, 0.11234381f, -0.10855974f, -0.10997597f, -0.32803220f, -0.13459451f, 0.09434753f, 0.12130933f, 
    -0.02300171f, 0.02410114f, -0.08638756f, -0.01879971f, -0.08268845f, -0.01161669f, -0.18789960f, 0.07167325f, 
    0.06043922f, -0.07940347f, 0.00578332f, 0.28632742f, 0.40885732f, 0.07010131f, -0.08532570f, 0.12740718f, 
    0.15754902f, 0.13020706f, -0.03274274f, 0.05182601f, -0.16516882f, -0.12791581f, -0.04105444f, 0.05810216f, 
    -0.06066477f, 0.07801957f, -0.24225400f, -0.04101742f, -0.08263964f, 0.13320817f, -0.44355586f, 0.18208924f, 
    -0.12125581f, 0.13224067f, 0.06397790f, -0.31654909f, -0.15742488f, -0.26846540f, -0.00836046f, -0.01398271f, 
    0.06816118f, -0.14123425f, -0.06609972f, -0.01077318f, -0.04877188f, -0.18078616f, 0.03793819f, -0.08182885f, 
    -0.12198967f, -0.02180000f, 0.26777431f, 0.09880462f, -0.10905991f, -0.03101181f, 0.07471154f, 0.05110135f, 
    0.07134348f, -0.05629228f, 0.05501883f, 0.00694020f, 0.12072146f, 0.15802941f, -0.04280178f, -0.07681806f, 
    -0.06245490f, 0.05436582f, 0.13616678f, -0.04924705f, -0.02252001f, 0.13614567f, 0.01500286f, -0.08248708f, 
    -0.02605735f, -0.03611430f, -0.05687424f, -0.08425318f, -0.12289625f, 0.00310788f, 0.05846424f, 0.00317816f, 
    -0.02850369f, -0.19740385f, -0.07105996f, 0.04952197f, 0.08656857f, 0.01950532f, -0.11116578f, -0.02855211f, 
    -0.02606825f, -0.12428053f, 0.20076822f, 0.42114097f, 0.20201549f, 0.00836852f, -0.17709661f, 0.00432885f, 
    0.17149785f, 0.13463737f, 0.09798729f, -0.04026008f, 0.09813967f, -0.05873753f, 0.03127502f, -0.01190551f, 
    0.02603659f, -0.04004995f, -0.16905434f, 0.04002241f, 0.06813176f, 0.33325922f, 0.41486508f, 0.14036947f, 
    -0.05204505f, -0.16924092f, -0.12386174f, -0.09032068f, -0.06355102f, 0.17921135f, -0.01304142f, -0.02385743f, 
    -0.10630406f, -0.09735235f, -0.15137807f, -0.01373200f, -0.13071373f, 0.17788909f, 0.11598574f, -0.15459724f, 
    -0.07269366f, 0.11424781f, -0.18462352f, 0.02094957f, -0.06818151f, -0.14817855f, 0.15207353f, -0.03635959f, 
    -0.08901686f, 0.00333869f, 0.17075835f, -0.07650269f, -0.15455626f, -0.17798173f, -0.25501943f, 0.11751384f, 
    0.16928145f, 0.10364690f, 0.20915258f, 0.01199053f, 0.00853490f, 0.08548293f, -0.38114926f, -0.00187248f, 
    -0.21489751f, 0.10880546f, 0.08351511f, -0.17157084f, -0.26112166f, -0.14163542f, -0.01119407f, -0.07670626f, 
    0.13581623f, 0.03949799f, -0.06448522f, 0.02609446f, -0.10887877f, -0.19257617f, 0.15013583f, -0.00977190f, 
    -0.35981891f, 0.02310946f, 0.00417518f, 0.25697494f, -0.11792943f, 0.07626234f, -0.07860935f, -0.13278453f, 
    -0.06514286f, -0.08912726f, 0.07511887f, 0.02306308f, -0.12685844f, -0.07957697f, -0.19731183f, 0.14253323f, 
    -0.07429038f, -0.10778652f, -0.18474157f, -0.19243971f, -0.18950829f, 0.24638888f, 0.32717168f, -0.21949488f, 
    0.13407674f, -0.09553709f, -0.08983003f, -0.41463104f, -0.07965849f, 0.11631153f, 0.01838288f, -0.04973530f, 
    -0.00925107f, -0.09792411f, -0.02012905f, -0.10617680f, 0.20034175f, -0.23942712f, 0.00764976f, -0.02201035f, 
    0.33784717f, 0.02195619f, -0.03949875f, 0.19352143f, -0.28298798f, 0.12262840f, -0.10677866f, 0.01196643f, 
    -0.10232199f, -0.15180357f, -0.05743295f, -0.12997960f, 0.07094173f, 0.00773202f, 0.11653878f, -0.00488748f, 
    -0.06152808f, 0.14994432f, -0.01702537f, 0.14468627f, 0.21978725f, 0.36179581f, -0.03491953f, 0.27468702f, 
    -0.22818738f, 0.13618779f, -0.03530437f, 0.09851509f, -0.02007664f, -0.08135264f, -0.31582272f, -0.02883008f, 
    0.05349262f, -0.07122917f, 0.06591127f, 0.07293792f, -0.13980156f, 0.09741397f, 0.04098466f, 0.15402061f, 
    -0.06697141f, 0.10684550f, -0.09623064f, 0.20319477f, 0.12318534f, 0.30976248f, 0.05879054f, -0.02355280f, 
    0.17120151f, 0.01498584f, 0.02903910f, 0.01161623f, -0.01720571f, -0.00995701f, 0.22574079f, -0.02735153f, 
    -0.00525226f, -0.02637400f, 0.04113531f, 0.11193801f, -0.00412833f, 0.09843224f, 0.04834207f, -0.00008024f, 
    0.07314308f, -0.15186284f, -0.10334256f, -0.05429748f, -0.04751909f, -0.05734975f, 0.00695854f, -0.05226688f, 
    -0.11472490f, -0.11515470f, -0.19785108f, -0.09246285f, 0.11383228f, 0.17780963f, 0.01944767f, -0.21340279f, 
    0.01623981f, -0.05528500f, 0.00243239f, -0.05141708f, -0.04216164f, -0.02664067f, -0.04222260f, -0.02553947f, 
    0.04825182f, 0.02760533f, 0.04141282f, -0.02105759f, -0.05830059f, 0.01498214f, -0.02781415f, -0.05808860f, 
    -0.04466940f, -0.04396720f, 0.02941604f, -0.01184397f, -0.05756957f, -0.05416924f, -0.00089681f, -0.05904390f, 
    -0.02857161f, -0.01464311f, -0.02058200f, 0.03041815f, -0.04368886f, -0.04226755f, -0.04739022f, -0.02577477f, 
    -0.04198601f, -0.04193261f, -0.03805101f, 0.03938766f, -0.02888713f, 0.03930468f, 0.01377723f, -0.00304799f, 
    -0.04180149f, -0.02111942f, -0.04682961f, 0.01691152f, -0.01464814f, 0.02940734f, 0.02596468f, -0.04998286f, 
    -0.00639385f, 0.02636098f, -0.00540595f, 0.03422792f, 0.04245993f, -0.02379260f, 0.00970468f, 0.03536774f, 
    -0.03030251f, 0.00450835f, 0.00286426f, 0.00452257f, -0.04130032f, -0.00398074f, 0.04531956f, -0.06595173f, 
    -0.01471945f, 0.01289738f, 0.01727701f, -0.04859941f, -0.06020099f, 0.01820239f, -0.03331174f, -0.05248411f, 
    -0.02793410f, -0.03166751f, -0.05006015f, -0.02802135f, -0.01244310f, 0.01423839f, 0.02946260f, 0.04265580f, 
    -0.04574293f, 0.01562416f, 0.02516212f, 0.03608221f, -0.03256300f, -0.04658642f, -0.06156753f, -0.06138229f, 
    -0.06375851f, 0.00862791f, 0.02400446f, -0.04572181f, -0.00373439f, 0.04293936f, 0.00454019f, 0.04423732f, 
    0.03907644f, -0.06716775f, -0.00310720f, -0.00469724f, -0.03818344f, 0.01167805f, 0.00374738f, -0.04821818f, 
    0.03554569f, -0.02985829f, 0.02850131f, 0.02614427f, -0.03302332f, -0.03588983f, 0.00956270f, -0.02635433f, 
    -0.05153111f, -0.04445537f, -0.01115555f, 0.04390312f, -0.02469627f, -0.05623646f, 0.04531654f, -0.00999540f, 
    0.01733916f, 0.04206365f, -0.00197856f, 0.00908279f, 0.03910616f, -0.04785924f, -0.04365155f, 0.01732061f, 
    0.01675100f, 0.03069129f, -0.04143362f, -0.03217949f, -0.01924406f, -0.00781215f, -0.06301164f, 0.00054127f, 
    -0.04875585f, 0.03255549f, 0.00433235f, 0.01706388f, 0.03153128f, -0.05875355f, 0.02605017f, -0.01484475f, 
    0.02589017f, 0.01424303f, -0.01592129f, -0.02627572f, -0.00037827f, -0.01747713f, 0.00151162f, -0.03647289f, 
    0.01349038f, 0.00656323f, 0.02307391f, -0.04681650f, 0.00110762f, -0.00906239f, -0.02108280f, 0.01692603f, 
    0.04427819f, -0.04803510f, -0.06274855f, 0.03234885f, 0.00496370f, 0.02580339f, -0.05378205f, -0.05184571f, 
    -0.02046713f, 0.00370677f, -0.03700688f, 0.00032803f, 0.01597967f, 0.04077675f, -0.03335825f, 0.00389303f, 
    -0.04999932f, -0.03870541f, -0.05636532f, 0.00202287f, 0.02414597f, 0.00818591f, -0.05061803f, 0.01189753f, 
    0.02664846f, -0.06164457f, 0.01939808f, -0.05719843f, -0.06694158f, -0.03401311f, -0.01023022f, 0.00056596f, 
    -0.04897178f, 0.03868554f, 0.00994454f, -0.04201759f, 0.03088342f, -0.03820726f, 0.01440144f, -0.05121174f, 
    0.02146427f, -0.02547458f, 0.02018343f, -0.03842232f, -0.05467656f, 0.04313754f, 0.01362357f, -0.01183881f, 
    -0.03051686f, -0.01659666f, 0.00041568f, -0.03198517f, -0.04575969f, -0.04997575f, 0.04876038f, -0.02247768f, 
    0.01680469f, 0.01397544f, -0.00256280f, 0.03053151f, -0.01273543f, -0.00642959f, 0.03951888f, 0.04120193f, 
    -0.05583923f, 0.04859031f, -0.01641775f, -0.02952217f, -0.05478258f, 0.04495048f, -0.04326212f, 0.04327152f, 
    0.03403907f, 0.04589116f, 0.00733395f, -0.04078539f, -0.03058510f, 0.01240994f, -0.01064169f, 0.00927785f, 
    -0.04871501f, 0.02956716f, -0.04510804f, -0.03998159f, 0.00662188f, -0.03014075f, -0.02081666f, -0.02322686f, 
    0.01461149f, -0.04598873f, 0.00593571f, 0.02598643f, 0.03893014f, -0.01221086f, -0.04283414f, 0.00868621f, 
    0.00791196f, -0.05110701f, -0.01089599f, -0.02128690f, -0.00938441f, -0.03741852f, -0.00014537f, -0.05857566f, 
    -0.01171807f, 0.04355645f, 0.00123548f, -0.04598518f, 0.01811326f, -0.00782360f, -0.00059130f, -0.06058172f, 
    0.00848996f, 0.04041778f, -0.00846216f, -0.02686021f, -0.06527054f, -0.03395372f, -0.04879341f, 0.00960048f, 
    0.02928726f, 0.01951525f, 0.03136237f, 0.03630066f, -0.05843469f, -0.02906677f, 0.02852998f, 0.02705543f, 
    0.02001423f, 0.00763819f, -0.00256625f, -0.02593186f, -0.02241218f, 0.03908587f, 0.01647977f, 0.01469711f, 
    0.03383643f, -0.00476197f, -0.00948737f, -0.06179284f, -0.04991645f, -0.00478499f, 0.00887620f, 0.03133095f, 
    0.02651978f, -0.03348007f, -0.05151405f, -0.00465949f, 0.00500413f, -0.03892795f, 0.04654094f, -0.00343098f, 
    -0.01170989f, 0.02277564f, 0.01796613f, 0.04045456f, 0.03377175f, -0.01626118f, -0.04417923f, 0.04385716f, 
    -0.06092220f, -0.03978935f, 0.05419892f, 0.06474392f, -0.09414379f, 0.02556849f, -0.10973909f, 0.01726164f, 
    0.00042353f, 0.12972561f, -0.06300712f, -0.01528506f, 0.02263568f, -0.05293423f, -0.00574577f, 0.09673837f, 
    0.10455310f, 0.14449690f, 0.05847249f, 0.10662565f, -0.12139054f, -0.17932814f, 0.16001780f, 0.00622418f, 
    -0.05177238f, 0.06954231f, 0.07532667f, 0.07284299f, 0.18805307f, 0.10504915f, -0.02459861f, 0.21266878f, 
    -0.06221101f, -0.10418730f, 0.05178902f, -0.14412306f, 0.00776840f, -0.02756814f, -0.12703766f, 0.02535598f, 
    0.11255503f, -0.21316792f, -0.10891882f, 0.11248334f, -0.11847531f, 0.06296938f, -0.25018567f, -0.21882294f, 
    -0.03743193f, -0.19654301f, -0.06325679f, 0.05674068f, -0.19593684f, -0.08912727f, 0.02103868f, -0.02761284f, 
    -0.07895124f, -0.01903452f, -0.09167688f, 0.02758100f, -0.35435909f, -0.11060197f, 0.02662809f, -0.06492727f, 
    0.07055479f, 0.01951016f, -0.01985819f, -0.12426237f, 0.07488573f, 0.10552391f, 0.23253389f, 0.16267373f, 
    -0.01048160f, 0.00799200f, 0.02233251f, -0.07342960f, -0.07430619f, -0.13246714f, 0.06776099f, -0.04039992f, 
    0.05838950f, -0.05147824f, 0.09458049f, 0.04192276f, -0.27823934f, 0.15021074f, 0.17218424f, 0.08683641f, 
    0.03555174f, 0.09917375f, -0.14466543f, -0.03769455f, 0.18827452f, 0.04951405f, -0.14830899f, 0.00197899f, 
    0.11388049f, 0.14196806f, 0.05550092f, 0.02675731f, 0.20033112f, 0.17372122f, 0.21651265f, 0.08977355f, 
    0.15268975f, -0.04043588f, -0.03640116f, 0.05009016f, 0.08882355f, 0.06504863f, -0.05321143f, 0.00863332f, 
    0.02575321f, 0.08569950f, 0.03392920f, 0.06123231f, 0.20259318f, -0.07632115f, -0.03216089f, -0.10965636f, 
    -0.10811704f, -0.20829760f, 0.00686572f, 0.02638306f, -0.16029833f, -0.12080743f, -0.28998882f, -0.11063375f, 
    -0.13557838f, -0.12479974f, -0.10364082f, -0.04964419f, -0.04302022f, -0.05640788f, 0.04793931f, 0.03498432f, 
    -0.04727643f, 0.13877258f, 0.01880317f, 0.05496301f, 0.71928650f, 0.43573478f, 0.40329269f, -0.01794715f, 
    -0.27267760f, -0.01941179f, -0.27414054f, -0.12390261f, -0.01795443f, -0.25036070f, -0.11826748f, -0.03029573f, 
    -0.02605673f, -0.06847662f, 0.03350270f, 0.06281137f, 0.10132714f, -0.02736060f, 0.15383002f, 0.00521895f, 
    0.17958102f, 0.43719971f, 0.01873621f, 0.29794830f, 0.20210733f, -0.01785744f, 0.10299563f, 0.10310880f, 
    0.02787450f, 0.12521751f, 0.07033367f, 0.10333877f, 0.09185088f, 0.14119478f, 0.10054364f, 0.16505970f, 
    0.21681283f, 0.22061396f, 0.25652671f, -0.11230651f, -0.40426421f, 0.03354171f, -0.14262579f, 0.02816503f, 
    -0.01611076f, -0.08279849f, 0.01180877f, -0.04883604f, 0.07187223f, 0.10704703f, 0.03027863f, 0.10440349f, 
    0.18306203f, 0.10792587f, -0.10281173f, -0.07388172f, -0.07992043f, -0.02268060f, 0.01211522f, -0.05394514f, 
    0.07146507f, 0.12944950f, 0.11005004f, 0.16893943f, -0.05498450f, -0.03173545f, -0.00325923f, -0.05376181f, 
    -0.02561603f, -0.11702845f, -0.08045326f, -0.03291067f, 0.02177792f, -0.10663649f, 0.02579501f, -0.09815061f, 
    -0.04826050f, -0.08076318f, -0.28764227f, -0.06175047f, 0.39167333f, 0.10947240f, 0.35452402f, 0.10724983f, 
    0.11683482f, 0.18398736f, -0.06908622f, -0.16944073f, 0.22427806f, -0.06585265f, -0.17423165f, 0.06391295f, 
    0.03611478f, 0.08866659f, 0.03988110f, 0.15579845f, 0.18508790f, 0.05030099f, 0.08043974f, 0.00958756f, 
    -0.15654267f, -0.30972201f, -0.02662853f, 0.11034638f, 0.02919582f, -0.00638433f, 0.01835154f, 0.01022068f, 
    0.05375713f, 0.05547127f, -0.01756019f, 0.00876231f, 0.15820439f, -0.04987305f, 0.05311926f, -0.00194841f, 
    -0.06213357f, -0.11717825f, -0.14339572f, 0.02383833f, 0.21540307f, -0.31011060f, 0.31268895f, 0.02066790f, 
    0.19001241f, -0.09348276f, -0.06637724f, -0.07728348f, -0.21540573f, -0.06385434f, -0.14579242f, -0.11843127f, 
    0.20133738f, -0.05083650f, -0.12090442f, 0.31631741f, -0.03615098f, 0.06038969f, -0.05663614f, 0.08847997f, 
    -0.34221035f, -0.24950634f, -0.27692232f, 0.21173960f, 0.09586472f, 0.16817868f, 0.09076045f, -0.06298043f, 
    -0.12255539f, -0.02295054f, 0.12618907f, -0.09838355f, 0.06267346f, 0.11304439f, 0.02742642f, 0.26401061f, 
    0.08368140f, 0.07682872f, -0.02022172f, 0.15305124f, 0.39176795f, 0.20375271f, 0.31817949f, 0.23105620f, 
    0.06926639f, -0.06606519f, -0.02574989f, -0.05989256f, 0.04659063f, 0.00544485f, -0.07641587f, -0.07199547f, 
    0.07701893f, 0.00783130f, 0.06218391f, -0.08500774f, 0.22858697f, 0.10833818f, -0.12912989f, -0.13959303f, 
    -0.21931796f, 0.05120111f, -0.25406241f, 0.35558236f, 0.36155957f, 0.20931807f, -0.15382592f, 0.01965887f, 
    -0.04406590f, 0.02391284f, 0.00132436f, 0.07267688f, -0.02837259f, 0.10977462f, -0.02631871f, 0.01461094f, 
    0.06511030f, -0.03561232f, -0.06289864f, 0.05075165f, 0.04992590f, -0.10777596f, -0.10978178f, 0.00743543f, 
    0.07930759f, -0.12793662f, 0.05334831f, 0.00399082f, 0.18346401f, -0.07791143f, 0.07548400f, -0.04297996f, 
    -0.14227495f, -0.12645209f, -0.00831881f, 0.03473690f, 0.19240727f, 0.05808658f, 0.16338661f, 0.10929431f, 
    -0.20989980f, -0.24873319f, -0.19634561f, 0.23197252f, 0.15620238f, 0.03113772f, 0.05347290f, -0.01479841f, 
    0.08368944f, -0.04583164f, -0.05633648f, -0.01923326f, -0.03626033f, 0.00214992f, 0.05282212f, 0.03930189f, 
    0.04500323f, 0.02982093f, -0.11408897f, 0.12980069f, -0.03578389f, -0.22524488f, -0.02222211f, -0.06944121f, 
    -0.10798692f, -0.02218600f, -0.07519496f, 0.05412095f, -0.02406157f, 0.04380120f, -0.00550773f, 0.00798074f, 
    0.10557508f, 0.00766035f, 0.04177637f, -0.05581055f, 0.01406970f, 0.06910626f, -0.00745508f, 0.08797739f, 
    -0.16100577f, 0.31116298f, 0.05649355f, 0.09903459f, 0.54320079f, -0.03241241f, 0.00241129f, -0.02226071f, 
    0.05575001f, 0.06251984f, -0.05072840f, -0.13648045f, 0.04107365f, -0.00586671f, 0.04143344f, 0.05444082f, 
    -0.03598846f, 0.03373130f, 0.00367903f, -0.03601476f, -0.26069823f, -0.11025910f, 0.03322381f, -0.05932966f, 
    -0.09576307f, -0.08619588f, -0.07515229f, -0.03723861f, 0.02023722f, 0.02739641f, -0.07961610f, -0.09481797f, 
    -0.03464470f, -0.08125031f, 0.06923225f, 0.10483390f, 0.10552727f, 0.02406595f, 0.06104599f, -0.07637749f, 
    -0.24926567f, -0.23699689f, -0.23296721f, 0.22827396f, 0.11249031f, -0.09320829f, -0.05932089f, -0.04692111f, 
    0.02956327f, -0.19911575f, -0.10532629f, 0.02482570f, -0.03327712f, 0.08873931f, 0.05103840f, 0.05436399f, 
    -0.02861144f, 0.01986398f, -0.15282790f, 0.01802844f, -0.24822839f, -0.26950112f, 0.02111930f, 0.08074486f, 
    0.07754932f, 0.10966168f, 0.02068826f, 0.16297594f, 0.04519897f, -0.01004342f, -0.07351107f, -0.07397585f, 
    -0.07021195f, -0.16649842f, 0.00493131f, -0.03441738f, -0.15019909f, -0.16031541f, -0.15448484f, -0.00508878f, 
    0.19033436f, -0.03844390f, -0.02319536f, -0.08044155f, -0.01608834f, 0.22118182f, -0.26828229f, 0.01581366f, 
    0.00423475f, 0.04641535f, -0.05841094f, 0.07134634f, -0.02177745f, 0.11128911f, 0.00486908f, -0.12460959f, 
    0.05474604f, 0.10528284f, -0.13159262f, 0.03521719f, -0.07237715f, -0.11968632f, 0.18600357f, -0.11917182f, 
    0.05321730f, -0.02227010f, -0.04433611f, 0.16245961f, 0.13483219f, 0.09718975f, 0.11870056f, 0.12549984f, 
    -0.03764075f, -0.07255393f, -0.00917443f, -0.09060909f, -0.01272829f, 0.15566036f, -0.01787555f, -0.03539241f, 
    0.25491995f, 0.07701955f, -0.11261977f, -0.10457489f, 0.07306563f, -0.09780719f, -0.06189825f, -0.10438724f, 
    -0.03444619f, -0.04466705f, 0.08089883f, -0.00180050f, -0.01715098f, -0.01739139f, 0.04331924f, -0.00925240f, 
    0.03147963f, 0.19758950f, 0.04081221f, 0.12879004f, 0.01622171f, -0.17829117f, -0.00929438f, 0.02505590f, 
    0.16372330f, 0.00352225f, 0.05564216f, 0.24066034f, 0.02218786f, -0.08172178f, -0.05115633f, 0.01261077f, 
    -0.01129463f, -0.09767284f, -0.05231912f, 0.08147636f, -0.14170255f, 0.07400957f, 0.10820901f, 0.00029104f, 
    -0.33647782f, 0.11782937f, 0.39750913f, -0.08099129f, 0.38496500f, -0.05422733f, 0.12175173f, -0.00068820f, 
    0.00153927f, 0.07351720f, 0.05087046f, 0.10508065f, 0.14935428f, 0.01164221f, 0.02019487f, -0.14830008f, 
    -0.10349149f, -0.04747390f, 0.07567389f, -0.13051105f, -0.35891819f, 0.27424815f, 0.26955438f, -0.22897696f, 
    0.25075832f, -0.02288626f, -0.07900101f, -0.28833827f, 0.02973527f, -0.03427045f, 0.17164263f, -0.08163591f, 
    0.01202828f, -0.09984662f, 0.08993191f, -0.16120137f, 0.02331045f, 0.08711156f, -0.08025879f, -0.31267688f, 
    -0.11454883f, 0.18545008f, 0.24748805f, 0.20675135f, 0.25347701f, 0.05930861f, 0.01400195f, -0.02457404f, 
    -0.06137601f, -0.02198859f, -0.01464103f, -0.01858289f, 0.07217351f, 0.02878654f, 0.15059435f, -0.08117329f, 
    -0.01243112f, 0.04494264f, -0.07278118f, -0.01591546f, -0.38361490f, -0.02408689f, -0.05028028f, -0.09865168f, 
    -0.03625857f, 0.08654650f, -0.06867760f, -0.02786607f, -0.08747516f, 0.04216432f, -0.07041418f, -0.04627498f, 
    -0.02613533f, -0.03499668f, 0.00778270f, 0.01075127f, -0.05196185f, -0.10149328f, -0.12057073f, 0.00983609f, 
    0.14137825f, 0.27051032f, -0.08833823f, -0.09896376f, 0.23767610f, 0.18558931f, 0.32946885f, 0.27379403f, 
    0.01519383f, 0.04780889f, 0.05938603f, -0.00947907f, -0.06387599f, -0.06817285f, 0.01227142f, 0.00117150f, 
    -0.06104506f, -0.08798650f, 0.11461526f, 0.23247026f, 0.25071084f, -0.19935143f, -0.16577701f, 0.06636534f, 
    -0.07385160f, 0.06187426f, 0.00749882f, 0.04393882f, -0.11105276f, 0.16787682f, 0.07204882f, 0.05375641f, 
    0.01121403f, 0.12631589f, -0.07944673f, 0.09239960f, 0.04324631f, 0.11157604f, 0.12922266f, 0.21143815f, 
    0.32638845f, 0.35960433f, 0.14127344f, 0.04444246f, 0.21277688f, 0.08757406f, 0.13560171f, 0.27503675f, 
    0.12192295f, 0.08951148f, 0.07919593f, -0.04933874f, 0.09297643f, -0.00682908f, -0.12186684f, -0.04422209f, 
    0.02470425f, -0.15032820f, 0.45846596f, 0.27996942f, 0.52475309f, 0.06128584f, -0.18845546f, -0.12969443f, 
    -0.20886554f, -0.05444705f, 0.02315680f, 0.03413596f, -0.04356337f, -0.11770859f, -0.05612237f, 0.07675860f, 
    0.12461080f, 0.08277297f, -0.01332222f, -0.09600927f, 0.06523301f, 0.14632508f, 0.06558559f, 0.03810718f, 
    0.23004074f, 0.18782699f, -0.22014295f, 0.02446323f, 0.23421066f, 0.19055432f, 0.21705672f, 0.35501459f, 
    -0.14506061f, 0.11442658f, 0.02205633f, -0.02763345f, -0.14502466f, 0.01909677f, 0.14429647f, -0.06578644f, 
    -0.02944403f, -0.01496229f, -0.03432984f, 0.16381636f, -0.21364629f, 0.06862905f, -0.13895333f, 0.19246466f, 
    -0.20960586f, 0.01826340f, -0.09447508f, -0.17267692f, -0.07200133f, -0.06088579f, 0.01374835f, -0.03399506f, 
    0.06463206f, -0.02372051f, -0.04928872f, 0.12955369f, 0.09934189f, 0.08429302f, 0.01703323f, -0.01475597f, 
    0.33200058f, 0.36172050f, 0.20226113f, 0.01227856f, 0.14716671f, 0.23494241f, 0.19902614f, 0.29966128f, 
    0.20084652f, 0.14151973f, 0.01978096f, -0.04743587f, -0.08228194f, -0.04032080f, -0.01908905f, 0.01271871f, 
    -0.11159276f, -0.07981877f, -0.04023349f, -0.15137266f, -0.53425545f, 0.07419766f, 0.08935553f, 0.11833327f, 
    0.11383169f, -0.09141961f, -0.10203098f, -0.19985181f, 0.11270826f, 0.16797724f, -0.00231260f, -0.05312221f, 
    -0.03878486f, -0.02563262f, 0.01885619f, 0.09593131f, -0.00919092f, 0.08246446f, -0.00714073f, -0.06793472f, 
    -0.20188341f, 0.01396021f, 0.19029754f, 0.09134564f, -0.08859760f, -0.02739472f, 0.05422607f, -0.01027882f, 
    0.02112707f, -0.20758854f, 0.05091796f, 0.01491151f, -0.06664478f, -0.02577655f, 0.08839919f, 0.01193510f, 
    -0.11561009f, -0.02716075f, -0.04776783f, -0.07009450f, 0.33641249f, 0.16282074f, -0.35857809f, -0.06785232f, 
    -0.12110593f, 0.02609232f, 0.12258448f, 0.07297549f, -0.08678708f, -0.02578056f, 0.14931437f, 0.08824501f, 
    0.10250376f, 0.11451960f, 0.03481522f, -0.10381114f, 0.03384266f, 0.14487955f, 0.02762816f, 0.05215411f, 
    -0.04354504f, 0.02051912f, 0.13401468f, -0.04344809f, -0.07119503f, 0.10497718f, 0.00925228f, 0.09303377f, 
    -0.05533879f, 0.01519406f, 0.00080687f, 0.16913433f, 0.00099957f, 0.07397468f, -0.09752592f, 0.02410768f, 
    0.09069809f, 0.11178605f, 0.29012707f, 0.21611795f, -0.39281818f, 0.14131024f, -0.04469580f, 0.25227201f, 
    -0.06053910f, -0.15632759f, 0.15137689f, 0.00663492f, -0.13676541f, 0.09342452f, 0.03271758f, -0.04629882f, 
    0.04638427f, -0.00080729f, 0.02906974f, 0.19273297f, 0.15850791f, 0.12271708f, -0.09238710f, 0.00491588f, 
    0.40048513f, -0.12494319f, -0.52429712f, 0.03636909f, -0.19019461f, 0.21928598f, 0.06469683f, 0.16788200f, 
    -0.14455301f, -0.00035126f, 0.09276581f, 0.13327178f, 0.00311057f, 0.08519188f, 0.05771921f, -0.02449905f, 
    -0.02233523f, 0.14329106f, 0.04828398f, 0.06816226f, 0.57318264f, 0.18617290f, -0.00406000f, 0.38545328f, 
    -0.04782409f, -0.01686287f, 0.06420372f, 0.08459882f, -0.02054593f, -0.11481769f, -0.05133405f, 0.25757805f, 
    -0.04414891f, 0.03919079f, 0.09223677f, -0.12613329f, -0.31138089f, -0.05985781f, 0.01743018f, -0.13233003f, 
    0.32460195f, 0.48231500f, 0.13740319f, -0.25922394f, -0.15049355f, 0.18013629f, 0.13027120f, 0.15200190f, 
    0.52226859f, 0.03899864f, -0.05467745f, 0.01061284f, -0.14313745f, 0.05718324f, 0.10204940f, -0.09567232f, 
    -0.10863323f, -0.02065095f, 0.11371665f, -0.03273317f, -0.30645323f, 0.03605424f, 0.00381825f, 0.07735639f, 
    0.08774452f, -0.01041345f, -0.01985584f, -0.11661985f, -0.10024910f, -0.06688309f, 0.07169402f, 0.05400360f, 
    -0.06427302f, 0.01128068f, 0.04781853f, 0.05047665f, -0.07739908f, 0.21156889f, 0.01797667f, -0.10574210f, 
    0.04247769f, -0.01870203f, 0.50633258f, -0.04442464f, -0.10420842f, -0.00869074f, 0.08289504f, 0.09229473f, 
    0.06276060f, -0.00415982f, 0.12242014f, -0.00970430f, -0.06788363f, 0.00866682f, 0.09717194f, 0.11033615f, 
    0.03188467f, 0.04179078f, -0.15458076f, -0.05870771f, 0.07361091f, 0.04114417f, -0.16675420f, 0.20592050f, 
    0.09134395f, -0.05382336f, -0.07014618f, -0.01808129f, -0.13271263f, 0.07907409f, -0.00456569f, 0.12547804f, 
    0.06867516f, -0.03198113f, 0.05139424f, 0.10204741f, 0.01112214f, -0.16599397f, -0.16333574f, 0.08224197f, 
    0.32834968f, 0.20522150f, 0.53299594f, 0.27695799f, 0.27637765f, -0.16334765f, 0.05961142f, 0.28941864f, 
    0.16254847f, 0.19255485f, 0.09670027f, 0.14237572f, -0.07322684f, -0.05782283f, 0.01891774f, 0.14847806f, 
    -0.06810819f, -0.06075025f, -0.01440164f, -0.13427302f, -0.33786583f, 0.03025155f, -0.49811596f, 0.19951317f, 
    0.15375271f, -0.07075685f, -0.06935050f, -0.35151353f, 0.02383787f, 0.04631698f, 0.01750802f, -0.09141078f, 
    0.16596186f, 0.08249529f, 0.12200232f, 0.06944091f, 0.03870028f, -0.14461389f, -0.07314118f, 0.02643768f, 
    0.22984782f, -0.08160937f, 0.29651824f, -0.09919872f, 0.06005384f, 0.02059376f, 0.10862311f, 0.24166234f, 
    0.16297114f, -0.04763488f, 0.05853990f, -0.06212865f, 0.07135253f, -0.01162815f, 0.05593111f, 0.01214154f, 
    -0.03451852f, -0.01180415f, -0.04624644f, -0.06200433f, -0.57341218f, -0.45971131f, -0.51480037f, -0.11356258f, 
    -0.00349745f, 0.23403136f, 0.17002237f, -0.13152029f, -0.19467525f, 0.11847841f, 0.14170229f, -0.00915227f, 
    0.14046128f, 0.01987899f, 0.12863442f, -0.03093684f, -0.08966357f, -0.03760555f, -0.06046853f, 0.06331745f, 
    -0.01798851f, -0.10404532f, 0.48947188f, 0.29431021f, 0.11795293f, 0.00486897f, 0.00555994f, 0.05724936f, 
    0.11919146f, 0.09562687f, 0.14223121f, -0.00502447f, 0.05132431f, 0.02213487f, -0.01388257f, 0.18438134f, 
    0.20808281f, -0.07548787f, -0.19933620f, 0.15532243f, -0.50154644f, -0.15846606f, 0.04418352f, -0.18661314f, 
    0.23414014f, 0.02836260f, 0.17784080f, -0.19384052f, -0.13014401f, 0.15190530f, 0.07891069f, -0.11249118f, 
    -0.00771178f, -0.13599394f, -0.09004823f, -0.02199280f, -0.05711134f, 0.05484668f, 0.03157574f, 0.11858725f, 
    -0.23802486f, -0.13195246f, -0.23929934f, -0.03980012f, -0.14535017f, 0.12710045f, 0.01285648f, -0.15662456f, 
    0.06791864f, 0.04424218f, 0.14751060f, -0.09960966f, -0.14753069f, 0.01276696f, -0.05624336f, 0.17127131f, 
    0.22997355f, -0.03640234f, 0.13477288f, 0.13025445f, -0.07444397f, 0.15804090f, -0.22316237f, -0.06388894f, 
    0.06937569f, -0.00914568f, -0.10484091f, -0.11817510f, -0.04283237f, 0.00808718f, 0.08201323f, 0.02027976f, 
    0.18799755f, 0.12751621f, 0.12123767f, 0.12905189f, 0.02082891f, -0.09267338f, -0.10145565f, -0.06615697f, 
    -0.00555105f, 0.32022527f, 0.29879597f, 0.08555373f, -0.02670865f, -0.01416876f, -0.15231653f, -0.14887279f, 
    -0.06752393f, 0.11551721f, -0.00172611f, -0.11023425f, -0.01510784f, -0.06265029f, 0.00030902f, 0.02078253f, 
    -0.11066066f, -0.09474111f, -0.06047468f, -0.08861675f, -0.35362852f, -0.07990646f, -0.49915096f, -0.27203155f, 
    -0.03448100f, 0.04690100f, -0.04355498f, -0.22186522f, -0.25408432f, 0.22854778f, 0.11015438f, -0.09904924f, 
    0.08720609f, -0.05043373f, 0.07422850f, -0.09947873f, -0.00608957f, -0.14472790f, 0.00804864f, 0.05781801f, 
    0.13586223f, 0.06911124f, 0.12419443f, 0.10607117f, 0.08881206f, -0.09408326f, -0.09273702f, 0.15430494f, 
    0.05591580f, -0.01079188f, 0.02906101f, -0.00756779f, 0.08449785f, 0.12381136f, 0.15452784f, 0.00454914f, 
    0.04091383f, 0.08378275f, -0.01372363f, 0.01825639f, 0.39224312f, 0.01292962f, 0.06338024f, -0.06955370f, 
    -0.09006601f, -0.03068884f, -0.02101443f, -0.03656217f, -0.07935685f, -0.04939950f, -0.04355285f, -0.00885499f, 
    0.05737126f, 0.01873718f, 0.07829149f, -0.00967895f, -0.06938476f, -0.03624657f, 0.18369679f, 0.35293478f, 
    -0.15349622f, -0.08026301f, 0.12404875f, 0.19194295f, 0.09671848f, -0.11816055f, -0.09908134f, -0.00566950f, 
    0.24824810f, 0.00951771f, 0.00872415f, -0.00909886f, -0.00138966f, -0.00307932f, 0.07921576f, 0.16536933f, 
    0.05299754f, -0.07027119f, -0.06677817f, 0.15828823f, -0.55925566f, -0.49488384f, -0.31268293f, -0.25148383f, 
    0.03966670f, 0.18512681f, 0.08842804f, 0.05767992f, -0.02947316f, 0.04287839f, 0.08929159f, -0.02335025f, 
    0.00720328f, -0.02639602f, 0.06101073f, -0.00203539f, 0.09995919f, 0.04932185f, 0.11218889f, 0.01866443f, 
    -0.09346478f, -0.25315762f, 0.33664104f, -0.18955688f, -0.14922060f, -0.02697447f, 0.05419623f, 0.11501888f, 
    0.23259214f, 0.00368769f, -0.01830636f, 0.00424924f, 0.10558810f, 0.00732827f, 0.08220164f, -0.11662778f, 
    -0.01725491f, 0.23151892f, 0.07862608f, 0.01008192f, 0.04453647f, 0.24797377f, -0.28555906f, 0.05214895f, 
    -0.09384032f, 0.12999471f, -0.05768190f, 0.05317621f, -0.20105159f, 0.02803140f, -0.00566013f, -0.08452698f, 
    0.15340099f, 0.17317238f, -0.01443610f, -0.03595088f, -0.12479576f, 0.06898952f, -0.12039797f, -0.17173350f, 
    -0.04670258f, -0.37930664f, -0.31226975f, -0.04791544f, -0.28225458f, 0.01652893f, -0.04295638f, -0.11923081f, 
    -0.07897612f, -0.05679230f, 0.12905413f, -0.01324574f, 0.03765921f, -0.02595324f, 0.06042540f, -0.00889690f, 
    0.06380305f, 0.07993375f, 0.05861934f, -0.02087094f, 0.22062662f, 0.43295729f, -0.17207707f, 0.05706951f, 
    -0.05194608f, -0.02039444f, 0.03144217f, -0.07220604f, -0.16041167f, -0.13997458f, 0.01509312f, -0.11171813f, 
    0.19326083f, 0.21974006f, -0.02873720f, 0.01089785f, -0.03205690f, -0.10729166f, 0.06719933f, -0.05892931f, 
    -0.08047357f, -0.46381253f, 0.20951462f, -0.25872451f, -0.03040586f, -0.01989122f, -0.04411334f, 0.26748461f, 
    0.09543008f, -0.01051797f, 0.04712385f, 0.04736878f, 0.00411180f, 0.15165499f, 0.04964400f, 0.02054240f, 
    0.07301805f, 0.03411867f, 0.11104355f, 0.05057896f, 0.09851540f, 0.27962241f, 0.03041896f, 0.02968707f, 
    0.05328188f, 0.02502367f, -0.01180550f, 0.01308136f, 0.01078897f, 0.01099676f, 0.05245452f, -0.08123823f, 
    0.04093614f, -0.03733609f, -0.07559198f, -0.20194912f, -0.00987037f, -0.00727945f, 0.00831749f, 0.00701065f, 
    0.11042536f, -0.09656867f, -0.01458722f, -0.12939569f, -0.16105917f, 0.09341665f, 0.03149628f, 0.04244220f, 
    0.08815736f, -0.06042799f, 0.00062224f, -0.07986539f, 0.01256318f, -0.12218550f, 0.05765152f, -0.06817871f, 
    0.01021083f, 0.12860581f, 0.12502499f, 0.04359138f, 0.00640000f, 0.05851871f, 0.25858012f, -0.14020263f, 
    0.04321748f, 0.07515974f, 0.13755326f, -0.07247463f, -0.22753799f, 0.03673903f, 0.09867537f, -0.03740183f, 
    0.01783222f, 0.07611541f, -0.02882334f, 0.18708237f, 0.13281873f, 0.25276837f, 0.10822847f, 0.01590778f, 
    0.22868045f, 0.24474615f, -0.01661307f, -0.08699623f, 0.05905310f, -0.08761550f, 0.17233600f, 0.02316731f, 
    0.12480774f, -0.02148905f, 0.11868739f, 0.09755614f, 0.01555199f, -0.02834305f, -0.11441354f, -0.00163613f, 
    -0.01923980f, -0.02358574f, 0.34039450f, -0.11896712f, 0.20144452f, 0.25975752f, 0.06251663f, -0.01644091f, 
    -0.02224451f, -0.04636136f, 0.05756045f, -0.13476713f, -0.13889039f, -0.14154203f, -0.05066774f, -0.14777665f, 
    0.06781708f, 0.25504345f, -0.03373400f, 0.03163146f, -0.05938676f, -0.10093410f, 0.08875200f, -0.04253044f, 
    -0.04297524f, -0.23102762f, -0.08988421f, 0.24222265f, 0.01537184f, 0.06014882f, -0.04204686f, -0.07739143f, 
    0.01466260f, -0.00128263f, 0.02516256f, -0.10456771f, 0.01736599f, 0.02684857f, -0.02667164f, -0.13656506f, 
    0.09235030f, -0.20829280f, -0.01956569f, -0.09153458f, -0.04193458f, 0.26932526f, 0.09699361f, -0.22944149f, 
    0.01409690f, -0.02444630f, -0.06466956f, -0.00257821f, 0.11342811f, 0.05035407f, 0.07611589f, 0.00911168f, 
    0.06056888f, 0.03057483f, -0.02443257f, 0.01564251f, -0.11633040f, -0.06875721f, 0.01967618f, 0.08193900f, 
    0.22386856f, 0.06700546f, -0.02391751f, 0.09785062f, -0.02342927f, -0.00762102f, -0.11022370f, 0.06819663f, 
    0.02269496f, -0.06693240f, -0.10424395f, -0.05922361f, 0.11714037f, 0.07386093f, -0.07311846f, -0.03967286f, 
    -0.00111579f, 0.04755083f, 0.03338967f, 0.10458325f, 0.16505583f, -0.06655663f, -0.03570367f, 0.32947600f, 
    0.21454230f, -0.07786972f, 0.06533808f, 0.25346476f, -0.18217815f, -0.00670511f, -0.07051838f, 0.06818365f, 
    0.13229416f, -0.09678898f, -0.01170278f, 0.12339883f, 0.03537296f, -0.06025606f, 0.11481857f, 0.32655805f, 
    0.21388926f, -0.12040089f, -0.39304623f, -0.35364908f, 0.03910068f, -0.07323757f, -0.04062315f, -0.21463324f, 
    0.10109031f, 0.09219355f, 0.06478383f, 0.02578875f, -0.05691963f, 0.08762725f, 0.08097605f, 0.10716020f, 
    0.05866226f, -0.07988967f, 0.16395885f, 0.10653315f, 0.16327897f, 0.15698166f, 0.22083020f, -0.07909369f, 
    0.06887898f, 0.02631031f, 0.08853413f, 0.03659338f, -0.03156626f, -0.07097639f, 0.00304626f, 0.00932220f, 
    0.03790932f, 0.02328419f, -0.09252781f, -0.02773118f, 0.01693755f, 0.07826519f, 0.23321332f, -0.00259045f, 
    -0.12450716f, -0.03743103f, -0.26286522f, 0.17954579f, 0.37395918f, 0.01719931f, -0.08457922f, 0.09706344f, 
    0.10942475f, 0.24223192f, -0.07863879f, 0.03178613f, 0.03320080f, -0.02712861f, -0.02472975f, 0.09233804f, 
    -0.02205523f, 0.11600554f, 0.13353828f, 0.08486647f, 0.05282093f, -0.12349631f, -0.07844950f, -0.11498239f, 
    0.03167078f, -0.01010397f, 0.12347214f, 0.01813525f, 0.07369479f, 0.02539206f, 0.06148030f, 0.02133578f, 
    -0.11184604f, -0.00929561f, 0.00996785f, 0.04330827f, 0.20058301f, 0.18864131f, 0.14813903f, 0.03787182f, 
    -0.15544660f, -0.20976512f, -0.38524550f, 0.19324394f, 0.04224466f, 0.18329571f, -0.06247111f, -0.07461289f, 
    0.09953694f, 0.02351281f, -0.07090274f, -0.01648243f, 0.02397725f, -0.03344319f, 0.05884864f, 0.05137802f, 
    0.01108814f, 0.10143839f, 0.09158661f, 0.11269213f, 0.28165954f, -0.08516026f, -0.07960837f, -0.25973672f, 
    -0.20225208f, -0.05647539f, 0.02785990f, 0.11265882f, 0.01117011f, 0.01622070f, -0.04209441f, 0.09099732f, 
    0.07238916f, 0.11731427f, 0.11581152f, -0.02756363f, 0.01282710f, 0.04948666f, 0.10865265f, 0.03737118f, 
    -0.17851597f, 0.15921278f, -0.06935301f, 0.24381158f, 0.29122886f, -0.03375082f, -0.05113986f, 0.13206561f, 
    0.11129459f, 0.21721956f, -0.06191402f, -0.09618369f, 0.07641347f, -0.11163585f, 0.02697217f, 0.08463009f, 
    -0.04405246f, 0.14421344f, -0.05832632f, 0.10166314f, -0.07718253f, 0.03672468f, 0.09496793f, -0.03496613f, 
    -0.31181172f, -0.12499151f, -0.04561675f, -0.03530049f, 0.12291053f, -0.12122790f, -0.14779699f, 0.00220156f, 
    -0.01286929f, -0.02965097f, -0.11163688f, 0.17319554f, 0.18496832f, 0.11132716f, 0.08453841f, 0.05994267f, 
    -0.09578083f, -0.07863157f, -0.30752108f, -0.01698134f, 0.05136932f, -0.09703173f, -0.16067187f, -0.05867874f, 
    0.06442295f, -0.15114240f, -0.02581051f, -0.01796321f, 0.03606081f, -0.09136418f, -0.00217386f, 0.05273296f, 
    -0.05457920f, 0.16328616f, 0.18948439f, 0.07633027f, -0.02265700f, -0.30110216f, 0.24892505f, -0.00035109f, 
    -0.32578135f, -0.06697626f, -0.25608593f, 0.04937961f, 0.13235141f, -0.06136062f, -0.03202428f, 0.01876541f, 
    -0.09672425f, -0.12991181f, 0.02936584f, 0.00573471f, -0.08732320f, 0.03982917f, 0.05454797f, 0.00539458f, 
    0.10053638f, 0.10025875f, 0.12470011f, -0.04500668f, -0.02286174f, -0.10561889f, 0.00247298f, 0.04093933f, 
    0.01105690f, -0.04953558f, -0.07809916f, 0.04766084f, 0.12011449f, -0.10244869f, 0.04967890f, -0.03472017f, 
    0.08378311f, 0.18467431f, 0.21182789f, 0.06787933f, 0.11439292f, -0.15745230f, -0.03089855f, -0.24552475f, 
    -0.09184713f, -0.02928210f, 0.02383481f, 0.16975062f, 0.08198020f, 0.05670552f, 0.08767729f, 0.07517383f, 
    0.07718373f, 0.00583220f, 0.04394402f, -0.06661981f, -0.00381372f, 0.05280932f, 0.11205021f, 0.01413498f, 
    0.17754887f, -0.15871206f, -0.12332777f, 0.13656677f, -0.10086107f, 0.03498507f, -0.03722831f, -0.02056850f, 
    -0.00202436f, -0.22257432f, 0.06713910f, 0.03680290f, 0.13353541f, 0.02766605f, 0.05611131f, -0.09955378f, 
    0.08785731f, 0.32750267f, 0.20759915f, 0.31168264f, -0.17793371f, 0.00024961f, 0.29073286f, 0.11030521f, 
    -0.06083874f, -0.11771385f, -0.06383673f, 0.11271109f, 0.26359853f, -0.20049232f, -0.13428536f, 0.04623785f, 
    0.02469529f, 0.01243871f, -0.01082933f, 0.07815630f, 0.03216163f, 0.10464534f, 0.10229003f, 0.18496867f, 
    -0.07991158f, 0.13646396f, 0.00381200f, 0.02020498f, 0.07895377f, -0.10380360f, 0.09317643f, 0.11099652f, 
    0.13930745f, 0.05664456f, 0.02087964f, 0.09878340f, 0.11607091f, 0.11266347f, 0.03960077f, -0.06927231f, 
    -0.03584820f, 0.05481231f, 0.04299995f, -0.05244987f, -0.36193722f, 0.40586707f, 0.21915174f, 0.20293319f, 
    0.04582241f, 0.01230451f, -0.02150692f, -0.07256708f, -0.09852998f, -0.11387686f, 0.08425029f, -0.03978223f, 
    0.05591223f, 0.04058120f, 0.11092923f, 0.02073012f, -0.13352895f, 0.08225247f, -0.07717223f, -0.24020259f, 
    0.12405442f, 0.23257647f, 0.06262903f, -0.02048421f, 0.15995871f, 0.22155492f, 0.04375611f, 0.00574666f, 
    0.01969597f, 0.09799823f, 0.05687948f, 0.02344115f, -0.00094497f, 0.11039437f, 0.01376316f, 0.19443801f, 
    0.04312136f, 0.09983035f, 0.06532001f, -0.06775665f, -0.19757207f, 0.04263613f, 0.18459311f, -0.04098587f, 
    -0.23307994f, -0.10554925f, -0.04927868f, -0.10908772f, -0.05766133f, -0.05119148f, -0.08528591f, -0.08486029f, 
    0.02238195f, -0.02696991f, -0.06790814f, -0.00291404f, 0.05336570f, 0.02686104f, -0.07011154f, 0.02219811f, 
    0.19307692f, 0.01501815f, 0.07638592f, -0.15688448f, -0.19936962f, -0.17671187f, 0.09401391f, 0.07734079f, 
    0.05305641f, -0.07510647f, -0.05093177f, -0.08939451f, 0.10739698f, -0.00876861f, 0.10021549f, -0.00707016f, 
    0.05928715f, -0.04805075f, 0.04168984f, 0.00189264f, -0.19774856f, -0.04909064f, 0.04086343f, -0.05070253f, 
    -0.15222961f, 0.05057220f, -0.09248796f, -0.03927056f, -0.17992717f, 0.01546580f, 0.03239097f, 0.14478999f, 
    0.09665886f, 0.10493632f, -0.10526212f, -0.10019551f, -0.13180320f, 0.01381205f, -0.03334665f, -0.05077525f, 
    -0.36767662f, 0.16831039f, 0.05619062f, -0.01187848f, 0.28051254f, -0.16082340f, 0.05078779f, 0.07635812f, 
    0.09274314f, 0.07259282f, -0.14107785f, -0.07857054f, 0.07809814f, 0.00551944f, -0.08132669f, 0.00585957f, 
    0.08072051f, -0.02454389f, -0.07450616f, -0.09104070f, 0.24596015f, 0.29568818f, -0.01123300f, 0.23488328f, 
    -0.00107331f, -0.06037586f, -0.03647717f, -0.08551731f, -0.21354339f, -0.11069214f, -0.09818434f, -0.02512907f, 
    0.00499552f, 0.00864506f, 0.13455153f, 0.15632927f, 0.02122439f, -0.05384191f, -0.06199133f, -0.14110936f, 
    0.25851738f, -0.16916600f, 0.07497438f, 0.01302122f, -0.33756310f, -0.04042853f, -0.10116205f, 0.03581332f, 
    0.04988898f, -0.00990503f, 0.04922787f, -0.04009770f, 0.03323623f, 0.06572931f, 0.04552057f, -0.04238081f, 
    0.03379710f, -0.11405561f, -0.03542578f, 0.07070545f, 0.12721244f, 0.14449236f, -0.03925113f, 0.03850022f, 
    0.08075897f, 0.00740709f, 0.02316694f, -0.03832457f, -0.10826083f, -0.01381703f, 0.18414883f, 0.15152110f, 
    -0.03850148f, 0.03288702f, -0.02440016f, 0.06022472f, -0.07370122f, 0.03158481f, 0.01298208f, 0.07187793f, 
    0.10439269f, 0.15557046f, 0.15638916f, 0.20673841f, 0.14335480f, -0.01652358f, -0.00998591f, -0.03887692f, 
    0.11152232f, 0.27488330f, 0.04197645f, -0.06812891f, -0.01625541f, -0.02849088f, 0.07403576f, -0.05923140f, 
    0.05287108f, -0.04429809f, -0.03601576f, 0.04057808f, 0.22416824f, 0.14442447f, -0.23635761f, 0.01255910f, 
    0.20917501f, 0.00231585f, -0.00570276f, -0.05319669f, -0.05886884f, 0.20150894f, -0.01422802f, 0.04682127f, 
    0.08064021f, 0.08222126f, -0.05271665f, 0.10260823f, 0.03040730f, -0.03605910f, -0.03271275f, -0.01061617f, 
    0.01260632f, -0.16520554f, 0.06083823f, -0.16703674f, 0.20890591f, -0.23169042f, 0.18260048f, -0.06646183f, 
    -0.02997003f, -0.02311853f, 0.02976853f, 0.03722785f, -0.03833762f, -0.08205601f, -0.09106180f, 0.09865547f, 
    -0.06277292f, -0.14307663f, -0.01265556f, -0.01674037f, 0.52249730f, -0.02891411f, 0.17279851f, 0.13656238f, 
    -0.20131379f, 0.01515115f, 0.02642963f, -0.11706099f, -0.18584287f, -0.15646315f, -0.03298569f, -0.14564162f, 
    -0.04937513f, 0.05775932f, 0.02307662f, 0.11913775f, 0.09007815f, -0.20198743f, 0.04685887f, 0.02872211f, 
    -0.29223856f, -0.12316254f, 0.02100456f, -0.06861967f, 0.03014686f, 0.14101490f, 0.04581751f, 0.06671035f, 
    0.11355027f, 0.14663544f, -0.05233822f, -0.04208532f, -0.08257040f, 0.09517127f, -0.07001784f, 0.05118104f, 
    0.05652072f, -0.04754568f, 0.15157215f, 0.01305538f, -0.40444702f, 0.20717457f, -0.06673229f, -0.15913171f, 
    -0.15807652f, -0.13189435f, -0.06418760f, -0.09891573f, -0.16521615f, 0.17318413f, 0.15036274f, 0.02298604f, 
    0.04102288f, 0.08585204f, 0.01125322f, -0.08882968f, 0.07962821f, -0.15185599f, -0.09342951f, -0.01274228f, 
    0.78652114f, -0.11651582f, 0.12818719f, 0.01983044f, -0.49670395f, 0.09765111f, -0.07968918f, -0.08106089f, 
    -0.02818445f, 0.00710072f, 0.00817783f, -0.12509610f, -0.08854406f, 0.02335616f, 0.01627390f, 0.04138934f, 
    0.15548280f, 0.03267033f, 0.06313136f, 0.06764895f, 0.44191462f, 0.12120905f, -0.05150393f, 0.27940264f, 
    -0.26651683f, 0.10062970f, -0.03494669f, 0.15303405f, 0.03549617f, 0.05753245f, 0.03475562f, 0.10280585f, 
    0.15912697f, 0.13714384f, -0.02583159f, -0.00746501f, 0.04601337f, -0.25666317f, -0.01381876f, 0.06952003f, 
    0.16788507f, -0.01578703f, 0.03334356f, -0.15959248f, 0.02422538f, -0.03262147f, 0.07771141f, -0.05636401f, 
    0.21408223f, 0.01278572f, 0.06832077f, -0.06657429f, -0.01174466f, -0.16383387f, -0.06344518f, -0.04284023f, 
    -0.01174714f, 0.01141874f, -0.05779792f, 0.03127907f, 0.21806905f, -0.00076148f, -0.11098306f, 0.06582041f, 
    0.20800497f, -0.02919892f, -0.00346961f, 0.17017134f, -0.03549951f, -0.07830825f, 0.02800230f, 0.10955894f, 
    0.03703374f, -0.00275051f, 0.04783457f, 0.11407827f, 0.03794012f, -0.00320549f, 0.17803611f, -0.06985012f, 
    0.06052514f, 0.07846978f, -0.09578495f, 0.08932257f, 0.30877057f, 0.05054212f, 0.06375146f, 0.10912509f, 
    -0.05000457f, -0.07527646f, -0.11413746f, -0.02713249f, 0.03116534f, -0.00119690f, 0.01137230f, 0.00459523f, 
    0.00120115f, 0.09995807f, 0.06960245f, 0.09233009f, 0.22246714f, -0.29667649f, -0.26255688f, -0.02131127f, 
    0.10272560f, 0.10844798f, -0.06950296f, 0.16092195f, -0.15526037f, -0.10980497f, 0.04547964f, -0.04288333f, 
    -0.04729511f, 0.07364269f, 0.11465971f, 0.01221235f, 0.01288132f, 0.21483873f, 0.01408687f, -0.01008691f, 
    0.23921102f, 0.17691371f, -0.27874109f, -0.02436567f, 0.21747340f, 0.15239714f, 0.04361582f, 0.10393166f, 
    0.09265507f, 0.09136169f, -0.01119490f, -0.01827123f, -0.03795073f, 0.03280571f, -0.01621614f, 0.01857390f, 
    -0.01465445f, 0.14202015f, -0.02819221f, 0.03255409f, 0.65648896f, -0.08800396f, -0.34479102f, -0.30209571f, 
    -0.30156559f, -0.09103134f, -0.02659076f, 0.02391877f, 0.02749192f, -0.20917760f, -0.16290195f, 0.05278976f, 
    0.07883336f, 0.01636179f, -0.02488694f, -0.05873821f, 0.05397332f, 0.01492772f, -0.01712371f, -0.08347169f, 
    -0.05743934f, 0.16264208f, -0.17157230f, 0.10106421f, 0.28842759f, -0.03506718f, 0.01017764f, 0.06732892f, 
    0.00493033f, -0.02787489f, -0.05415724f, -0.07069367f, -0.08510209f, 0.04756070f, 0.07129772f, 0.08526698f, 
    0.06276536f, -0.02564834f, 0.06861984f, 0.10774866f, -0.26209757f, 0.28886718f, 0.13136250f, 0.07119858f, 
    -0.25271979f, -0.14475371f, -0.20820548f, -0.22013098f, -0.04254200f, -0.20233531f, -0.08280387f, -0.02116837f, 
    -0.03121213f, -0.11412890f, -0.06168388f, 0.11053716f, 0.16479042f, -0.03341191f, -0.00386414f, -0.08138119f, 
    0.20925766f, 0.17574863f, -0.09526318f, -0.12333638f, 0.17764997f, 0.09394027f, 0.08741180f, -0.03182227f, 
    0.10729228f, -0.04102564f, -0.02030202f, -0.07135791f, -0.10055873f, -0.04496874f, -0.07255057f, 0.00913418f, 
    -0.05162689f, 0.08949460f, -0.14062046f, 0.05358776f, -0.43011072f, 0.33759898f, 0.53624046f, 0.05362973f, 
    -0.05739706f, -0.14885090f, -0.18750441f, -0.24895532f, 0.05051611f, 0.03239162f, 0.04814651f, -0.06061393f, 
    0.08712833f, -0.13333242f, 0.05981607f, 0.06841891f, -0.01066318f, 0.10994793f, 0.00627360f, -0.01701817f, 
    -0.02158192f, 0.07016441f, 0.07635184f, 0.00807604f, -0.19617201f, -0.17369099f, 0.08114146f, 0.11852364f, 
    0.01090124f, -0.06538559f, -0.07791746f, 0.03766153f, 0.08401790f, 0.01180561f, -0.03684596f, -0.04792508f, 
    0.00529716f, 0.08207213f, 0.08547502f, 0.05296400f, 0.41603485f, -0.21489172f, -0.24959251f, -0.21678168f, 
    -0.07207155f, -0.03247050f, 0.09835166f, 0.05003810f, 0.02294257f, -0.06037426f, -0.06390934f, -0.00158751f, 
    0.08490528f, 0.03471088f, 0.02428968f, -0.00561402f, 0.08856087f, -0.08035466f, 0.04501290f, 0.00052126f, 
    -0.12446957f, 0.00049775f, 0.08468152f, -0.00951219f, -0.17687561f, 0.03246279f, 0.09984272f, -0.16633357f, 
    0.00379108f, -0.04911252f, 0.09505988f, 0.06663230f, 0.09154597f, 0.07807630f, 0.00414784f, -0.01457332f, 
    0.06959089f, 0.16810749f, -0.00611688f, 0.21128844f, -0.56653082f, -0.00887724f, 0.49012950f, 0.20567673f, 
    0.12328716f, -0.27569196f, -0.00530119f, -0.27961794f, 0.15919307f, 0.02262620f, -0.07292488f, -0.01453708f, 
    0.05615808f, -0.06127941f, 0.00240462f, 0.06507463f, 0.07262391f, -0.04365220f, 0.11212796f, -0.05072331f, 
    0.23926309f, 0.01335514f, -0.01323687f, 0.14809905f, -0.00724588f, -0.00949682f, 0.10754569f, 0.30456096f, 
    0.12116914f, -0.03664520f, 0.07235528f, -0.06685866f, 0.03447100f, -0.03788149f, 0.07271753f, -0.01344325f, 
    0.07929654f, -0.02145907f, 0.19034326f, -0.04663450f, 0.02113941f, 0.37254769f, 0.18637329f, 0.29952943f, 
    -0.10069345f, 0.01468785f, -0.04430974f, 0.08078846f, -0.02381590f, 0.03866376f, 0.07447745f, 0.03904446f, 
    0.06995436f, 0.02381091f, 0.06366376f, -0.00511252f, 0.06885430f, 0.05078556f, -0.04765035f, -0.09478340f, 
    0.37976477f, 0.31355026f, 0.03589925f, -0.26110312f, 0.16084734f, 0.15701477f, 0.11620575f, 0.03816737f, 
    0.05433547f, 0.07267344f, 0.00832747f, -0.02608535f, -0.06676386f, -0.04472219f, 0.04761849f, 0.11156289f, 
    0.07745097f, 0.03035792f, 0.00024491f, 0.01003453f, -0.50098991f, 0.11656946f, 0.20087762f, 0.10809560f, 
    -0.11122977f, -0.17742524f, -0.15573584f, -0.25097194f, 0.00438300f, -0.12262795f, 0.02547466f, -0.03795186f, 
    -0.03378048f, 0.09611245f, -0.01219760f, 0.00558285f, -0.05663794f, 0.16052201f, 0.05413175f, -0.13971612f, 
    -0.04134452f, 0.00429046f, -0.03522396f, 0.01354829f, -0.02468286f, 0.01432990f, -0.04117024f, -0.03254243f, 
    -0.01233382f, -0.05956436f, 0.01141901f, 0.01475173f, 0.02644211f, -0.03078481f, -0.04012193f, -0.00430211f, 
    -0.01237202f, -0.00612900f, 0.01896078f, 0.00740042f, -0.03947810f, -0.01135556f, -0.01384235f, 0.04730084f, 
    0.00416161f, 0.02646499f, 0.00178813f, 0.02510331f, 0.00576290f, 0.05081694f, 0.00318917f, -0.04335302f, 
    -0.03529820f, 0.02841500f, 0.03593381f, -0.03231968f, -0.00796644f, 0.00125322f, -0.04931970f, 0.00619688f, 
    -0.04600137f, -0.00263270f, 0.03368453f, -0.02359692f, 0.00290056f, -0.06818799f, -0.05048172f, -0.04634114f, 
    0.04380934f, 0.02200293f, -0.01741958f, 0.02744067f, -0.04579498f, 0.04466055f, -0.06445851f, -0.01098556f, 
    0.01555136f, -0.04352257f, -0.02324753f, -0.02863040f, -0.01029499f, -0.03194599f, -0.02516388f, -0.00174280f, 
    -0.01331287f, -0.01264017f, -0.03540251f, -0.01347388f, 0.03707509f, -0.01049022f, -0.05004981f, 0.00131297f, 
    0.00218295f, -0.04807158f, -0.04176737f, 0.01583858f, 0.02766559f, -0.05312896f, -0.01274939f, -0.00549960f, 
    -0.01633368f, 0.03676344f, -0.00345536f, 0.02194037f, -0.05542709f, 0.01121744f, -0.01878573f, -0.04822242f, 
    0.01998541f, -0.03877140f, -0.04950435f, -0.04263525f, 0.01240849f, 0.00309735f, 0.01120541f, -0.01979255f, 
    -0.01515619f, -0.01299818f, 0.03514118f, 0.01894914f, 0.00294894f, -0.04568585f, 0.05024921f, -0.01369191f, 
    0.05405071f, -0.03893901f, -0.00403425f, -0.01679285f, -0.05019640f, 0.05165817f, 0.01523344f, -0.00823975f, 
    -0.02543747f, 0.02174808f, -0.02186828f, 0.00023901f, 0.02280124f, -0.02731928f, 0.00933743f, -0.03865985f, 
    -0.01959404f, 0.02465935f, -0.00158448f, 0.00920804f, 0.03751501f, 0.02671323f, -0.02222734f, 0.03681467f, 
    -0.05614664f, 0.04122320f, -0.00887574f, -0.06592609f, -0.03687876f, -0.01716069f, -0.03430223f, 0.00857653f, 
    -0.01622272f, -0.01508023f, 0.02087339f, 0.03489854f, 0.03141902f, -0.05618395f, -0.02562192f, 0.05611775f, 
    0.03670253f, -0.03991444f, -0.04514214f, 0.01095561f, 0.02663788f, -0.01470714f, -0.02550904f, 0.03770844f, 
    -0.04343189f, 0.03230470f, 0.02859612f, -0.04097037f, -0.05461620f, 0.02608539f, -0.05834644f, -0.02655844f, 
    -0.02004876f, -0.02457288f, -0.04718425f, -0.05873566f, 0.01731156f, 0.03481943f, 0.01067435f, 0.03752378f, 
    0.00239866f, -0.03488779f, -0.05636540f, 0.03294773f, 0.00242897f, 0.00692076f, 0.00303190f, 0.01056175f, 
    0.03875137f, 0.01752269f, -0.03494738f, 0.02510010f, -0.03455886f, 0.00807629f, 0.03770320f, 0.04345344f, 
    0.00258363f, -0.01683892f, 0.01059399f, -0.04226295f, -0.05371981f, 0.01121501f, -0.01228210f, 0.02712063f, 
    -0.02613178f, -0.03584109f, -0.05554419f, -0.04886917f, 0.04533691f, 0.01992902f, -0.02062347f, 0.00919458f, 
    0.02627459f, 0.01232434f, -0.02622054f, 0.00720312f, -0.05828400f, 0.05404243f, -0.03532491f, -0.01124511f, 
    -0.02995047f, 0.02326856f, -0.01717748f, -0.00541110f, 0.03579561f, 0.01525172f, -0.04581018f, -0.03969370f, 
    -0.02328186f, 0.00367005f, -0.02579787f, 0.00824345f, 0.05347752f, -0.00786441f, -0.03498454f, -0.01317140f, 
    -0.05369183f, -0.00475777f, -0.05062046f, 0.00389031f, 0.00144647f, -0.03929099f, 0.04178278f, -0.05699063f, 
    -0.00623837f, -0.06421690f, 0.04161401f, 0.01723183f, 0.04351287f, 0.02668493f, -0.04571240f, -0.02498350f, 
    -0.00085253f, 0.01927183f, -0.04892448f, -0.02185676f, 0.03200499f, 0.01329776f, 0.02217777f, 0.04358297f, 
    -0.04578886f, -0.05708477f, -0.02340767f, 0.03374596f, -0.03463572f, -0.04063539f, 0.00856785f, 0.00287352f, 
    0.02147083f, -0.00842571f, -0.02927933f, -0.02778122f, -0.06116874f, -0.00169356f, 0.01243041f, -0.04916197f, 
    -0.01315663f, -0.01686066f, -0.04720787f, -0.05699778f, -0.04788293f, 0.03271878f, -0.01659245f, -0.04791594f, 
    0.00627184f, -0.05470750f, -0.04487798f, 0.01187752f, 0.04016573f, 0.01949633f, -0.05711596f, -0.02556436f, 
    -0.05803730f, -0.04798192f, -0.03817791f, -0.02924491f, -0.04086379f, -0.00117526f, 0.03866015f, 0.02581286f, 
    -0.01379370f, -0.04605739f, -0.01986235f, -0.01159676f, -0.04880641f, -0.04487779f, 0.02499136f, -0.00776026f, 
    0.04448140f, -0.04139606f, 0.03755029f, -0.03256299f, -0.00277502f, 0.05261199f, -0.02575680f, 0.01833183f, 
    0.00259910f, -0.00359799f, 0.01038208f, -0.02905063f, 0.01030488f, 0.01454567f, 0.04327307f, -0.04624767f, 
    0.00413196f, -0.04278312f, -0.00885815f, 0.00413639f, -0.05762510f, 0.05013806f, -0.04001002f, 0.00672219f, 
    0.13783546f, 0.12391264f, 0.01571714f, 0.12671509f, -0.22785795f, -0.08771829f, 0.10018925f, 0.04183213f, 
    -0.06356145f, 0.12426715f, 0.08585355f, 0.04695802f, -0.03840150f, -0.06421393f, 0.03350042f, 0.08287607f, 
    0.00153044f, -0.18763030f, -0.08791184f, 0.03990356f, -0.10664152f, -0.35433695f, 0.27786297f, 0.04815321f, 
    -0.14285769f, -0.02033721f, 0.01256682f, -0.09897291f, 0.10867806f, -0.09424759f, -0.06014905f, 0.06345131f, 
    0.00080928f, -0.11691309f, -0.00315203f, -0.06869024f, 0.04051099f, -0.15331775f, 0.06439542f, 0.09354372f, 
    0.08559613f, 0.25289938f, 0.32769254f, 0.18880962f, 0.05109317f, -0.06262400f, 0.04961513f, 0.04992746f, 
    0.02803841f, -0.05547844f, -0.01521283f, 0.10088630f, 0.06392238f, 0.02079393f, -0.06545793f, 0.06697492f, 
    0.01486395f, -0.14594314f, 0.05039549f, 0.07306410f, -0.28451055f, -0.12779321f, 0.16466843f, 0.17986315f, 
    0.19548258f, -0.15875301f, -0.12436175f, -0.11432973f, 0.13749902f, 0.00621881f, 0.09847661f, 0.02701584f, 
    -0.13341969f, -0.05872206f, 0.10073970f, -0.05418750f, -0.06956271f, -0.11034589f, 0.00025601f, -0.07095868f, 
    0.22586998f, -0.01536448f, -0.03038349f, 0.25186950f, -0.28535256f, 0.03740098f, -0.02729816f, 0.00654127f, 
    0.07438504f, 0.10727875f, -0.01243325f, 0.00536791f, -0.06830866f, 0.10829213f, -0.07850484f, 0.05021683f, 
    0.02203716f, 0.00255233f, -0.09042379f, 0.05153055f, 0.23715445f, -0.06882185f, 0.08658712f, 0.15524052f, 
    0.12417123f, -0.01128134f, 0.10252917f, -0.08016182f, -0.02102534f, -0.12492544f, -0.01434522f, 0.01245927f, 
    -0.05555863f, -0.07777702f, -0.07265478f, -0.06647080f, -0.00838058f, 0.10941192f, -0.11775890f, -0.05210445f, 
    0.12512933f, 0.13354029f, 0.24288496f, 0.06439701f, -0.01000968f, -0.08365704f, -0.08632006f, 0.02826742f, 
    -0.07352211f, 0.07792627f, 0.06125742f, 0.12760970f, 0.04089870f, 0.09047145f, -0.01068710f, 0.14459899f, 
    0.05091678f, -0.15662414f, -0.00472142f, -0.06690625f, 0.47806188f, 0.41025713f, -0.16083813f, 0.23222770f, 
    -0.07306349f, 0.05474851f, -0.13480942f, -0.00389927f, 0.22399068f, 0.13677785f, -0.11623898f, 0.12860423f, 
    -0.03738713f, -0.04546627f, -0.11987752f, -0.07184515f, -0.05821089f, -0.15952542f, 0.11794181f, 0.16847280f, 
    -0.21720031f, 0.14008847f, 0.27652472f, 0.28861272f, 0.27914134f, -0.07509468f, -0.01960367f, 0.01227260f, 
    -0.04400193f, 0.01607298f, -0.03868530f, -0.01683056f, -0.15316643f, 0.06228100f, 0.05764785f, 0.16123688f, 
    0.02396715f, 0.00571617f, -0.07462580f, 0.00523259f, -0.12786229f, -0.00508409f, -0.19201444f, 0.15240830f, 
    -0.16465494f, -0.13170320f, -0.06042431f, -0.02624863f, 0.06593414f, -0.03920252f, -0.02283937f, -0.04738679f, 
    -0.04377912f, -0.01019236f, -0.04630113f, 0.03018723f, 0.04490231f, 0.09946440f, -0.03667062f, 0.04822261f, 
    -0.31804836f, 0.26523572f, 0.24999109f, 0.05171449f, -0.04846167f, 0.00719740f, -0.16538778f, 0.17845355f, 
    0.02068677f, -0.06021065f, -0.13445723f, 0.08841087f, 0.01916038f, -0.05864419f, -0.00415052f, 0.03640647f, 
    -0.14929630f, -0.04120763f, 0.05704170f, 0.03522764f, 0.28419513f, -0.00112706f, 0.05176297f, 0.21529821f, 
    -0.25016856f, 0.16092317f, 0.21809195f, -0.23429471f, -0.04255805f, 0.13743778f, -0.08807541f, 0.00318320f, 
    -0.02013511f, 0.08890419f, -0.05421262f, 0.08101060f, 0.05271761f, -0.04962748f, -0.05573209f, 0.06913721f, 
    -0.10085469f, -0.38925427f, -0.11872248f, 0.06837859f, -0.48708400f, -0.01165389f, -0.08063672f, -0.06991597f, 
    0.00848323f, -0.04534621f, 0.05791036f, -0.04408219f, -0.07460185f, -0.00033423f, 0.04246848f, 0.02979244f, 
    -0.00046120f, 0.06643754f, -0.15387802f, -0.01536020f, 0.10897666f, -0.50072896f, 0.17383923f, 0.16714007f, 
    -0.03795516f, -0.05453199f, 0.03778931f, -0.18676272f, 0.11397252f, -0.11367259f, 0.06840765f, -0.03947725f, 
    -0.00060471f, 0.07216921f, 0.06947388f, 0.02042442f, -0.11861146f, -0.00998177f, 0.05930532f, 0.01566185f, 
    -0.17552255f, -0.27337715f, 0.06694324f, 0.26708680f, -0.09319821f, -0.07695785f, -0.04252260f, 0.17406000f, 
    0.13899060f, -0.06604910f, 0.08444057f, 0.04978978f, -0.02300235f, 0.04790265f, 0.05606847f, 0.09638868f, 
    -0.00257025f, 0.05989577f, -0.04221118f, 0.00652163f, 0.42156458f, 0.02869922f, -0.07572354f, 0.27941832f, 
    0.31536856f, -0.04547147f, 0.03478866f, -0.04537297f, 0.01798749f, 0.01802276f, -0.15079960f, -0.02468855f, 
    0.01255911f, 0.03195197f, -0.08333001f, -0.02084064f, 0.02181914f, 0.09495834f, -0.06484736f, 0.00821162f, 
    -0.06083851f, 0.16363713f, -0.06591368f, 0.29803717f, -0.06711299f, 0.06012643f, -0.07663883f, -0.03168558f, 
    -0.05759646f, 0.11503105f, 0.01181618f, -0.00666943f, -0.07436348f, 0.06118932f, -0.03606740f, 0.15394607f, 
    -0.00100572f, -0.18844949f, -0.01455448f, 0.05746923f, -0.11911982f, -0.08675122f, 0.22520216f, -0.07975055f, 
    0.00303932f, -0.10966720f, 0.02444991f, -0.14264259f, 0.18905662f, -0.00636088f, 0.02107551f, 0.04894013f, 
    -0.01634387f, -0.08730391f, 0.03606879f, -0.01458636f, 0.11302587f, -0.10926919f, 0.12201835f, 0.15484498f, 
    -0.23337287f, 0.01998099f, 0.36936897f, 0.18382379f, 0.03337913f, -0.01479258f, 0.09250294f, 0.01714591f, 
    -0.04678100f, 0.04271781f, -0.04011210f, 0.04547741f, 0.05764995f, 0.02009978f, -0.04536872f, 0.10532192f, 
    0.06891169f, -0.05964004f, 0.11526611f, 0.08606598f, -0.33481845f, -0.28607893f, 0.23949960f, 0.00508830f, 
    0.09168377f, 0.00961627f, -0.11076783f, 0.01236613f, 0.04292237f, 0.11890170f, 0.06233001f, 0.01974726f, 
    -0.05871459f, -0.18385623f, -0.08082604f, -0.02296128f, -0.06192460f, 0.08356690f, -0.03498120f, 0.02594310f, 
    0.07396328f, 0.27336657f, 0.12005919f, 0.30230093f, -0.07118288f, 0.07206898f, 0.07807335f, -0.10585223f, 
    0.07270466f, 0.17172350f, 0.01214493f, 0.11494363f, -0.01918013f, 0.05100195f, -0.04099555f, 0.01963511f, 
    0.06176017f, 0.12240984f, 0.02631760f, -0.03676230f, 0.06502227f, -0.39123768f, -0.03162949f, -0.10808075f, 
    0.02328845f, 0.01167625f, 0.02828793f, -0.02971084f, -0.03956716f, -0.05353546f, -0.01049899f, -0.05411985f, 
    -0.05240068f, -0.03304625f, -0.02942595f, 0.01344905f, -0.07799052f, 0.03007324f, -0.02553717f, -0.09662307f, 
    -0.21727787f, 0.01719831f, 0.00994047f, 0.19559599f, -0.03833288f, -0.02414263f, -0.11595021f, -0.00595034f, 
    -0.10626249f, 0.03683589f, 0.03045221f, 0.11174955f, 0.09986268f, 0.07344127f, 0.01153295f, 0.03388656f, 
    0.07394227f, -0.22684628f, 0.02422133f, -0.05627405f, 0.06177959f, -0.12385026f, -0.29834852f, 0.21573789f, 
    0.03119640f, 0.12221794f, 0.06802510f, 0.19619597f, 0.11564402f, 0.00199670f, -0.14014965f, 0.06973682f, 
    -0.08451727f, 0.00771199f, 0.06038629f, -0.06535584f, -0.04478819f, -0.02751114f, 0.19518113f, 0.07701063f, 
    -0.14280067f, -0.05506333f, 0.12170156f, 0.11900345f, 0.00533437f, 0.07370452f, -0.25863242f, -0.05545946f, 
    -0.05093197f, -0.02598397f, -0.01153659f, -0.07843086f, -0.07362877f, 0.13431294f, 0.08865733f, -0.03951912f, 
    0.03417083f, 0.07016553f, -0.21983956f, 0.05661326f, -0.36151269f, 0.10289856f, 0.14826512f, 0.05068597f, 
    -0.05076438f, 0.05765160f, -0.03796951f, 0.00273092f, 0.00066492f, 0.13299184f, -0.03673977f, 0.16359581f, 
    0.01536628f, -0.03522141f, 0.09155290f, -0.05444715f, -0.06924543f, 0.14316659f, -0.10994348f, -0.04297971f, 
    0.00444588f, 0.16311651f, -0.07097284f, -0.16144520f, -0.01348173f, -0.00062761f, 0.01151301f, 0.25166827f, 
    -0.04659003f, -0.05796698f, -0.10595658f, -0.04172908f, -0.12048756f, 0.03469289f, -0.01534870f, 0.07826044f, 
    -0.04063103f, 0.03970024f, 0.02174815f, 0.03191332f, 0.40374672f, -0.27663261f, -0.09050483f, 0.17391598f, 
    0.01988341f, 0.03308329f, 0.08690333f, 0.08710252f, -0.15899748f, -0.08481193f, -0.08581942f, 0.01009740f, 
    -0.08663706f, 0.03454706f, 0.07355420f, 0.06953094f, -0.02934868f, 0.21527964f, -0.03742807f, -0.03753992f, 
    -0.42617700f, 0.16642681f, 0.10255215f, -0.15009169f, 0.01137942f, 0.07281204f, 0.00919966f, -0.16806293f, 
    -0.04664455f, -0.07593550f, -0.01230553f, 0.12348656f, 0.02423761f, 0.03292951f, 0.01485095f, 0.07016096f, 
    -0.03657063f, -0.03872262f, -0.10972859f, 0.00665317f, -0.19169441f, -0.06785851f, 0.00619887f, -0.13033909f, 
    -0.05542301f, -0.12203088f, -0.03510577f, -0.28031710f, 0.12055676f, -0.14862113f, 0.00509149f, 0.05308718f, 
    -0.11097077f, 0.12809134f, 0.09072741f, 0.05864083f, -0.05775210f, 0.00506762f, 0.09489489f, -0.06597423f, 
    -0.31430119f, -0.04987827f, 0.30334148f, 0.39702928f, 0.00049156f, -0.05195716f, -0.10910873f, 0.17650075f, 
    -0.05254956f, -0.10544561f, -0.01883601f, 0.09257905f, 0.12069193f, -0.00113293f, 0.00641523f, -0.04723489f, 
    -0.05849100f, 0.06499291f, -0.03108445f, 0.01323353f, 0.11959457f, -0.27912405f, -0.22123440f, -0.02022726f, 
    -0.01475421f, 0.03679507f, -0.03092604f, -0.06632715f, -0.09348629f, -0.01850462f, -0.10827631f, 0.01860747f, 
    0.01245587f, -0.04681904f, -0.00233282f, -0.01002024f, 0.07449131f, -0.14650480f, -0.15263447f, -0.06079621f, 
    0.12107150f, 0.02425333f, 0.12871513f, 0.22894363f, -0.15057062f, -0.15292339f, -0.21550159f, -0.00528873f, 
    0.00800692f, -0.17042992f, -0.11871328f, -0.03203153f, -0.01345394f, -0.05433539f, -0.02309553f, 0.04861237f, 
    0.07260936f, -0.14393929f, -0.11486634f, -0.14862446f, -0.14498046f, -0.08542495f, 0.34415343f, 0.04041765f, 
    0.24562459f, -0.05666890f, 0.11062602f, 0.07643133f, 0.22442816f, -0.13750191f, -0.07624227f, 0.07374074f, 
    0.07034123f, -0.05049247f, 0.17954607f, -0.12199388f, -0.08932959f, -0.03338174f, -0.14840348f, -0.04253292f, 
    -0.01994186f, 0.15719073f, 0.02618628f, 0.13188499f, -0.03013169f, 0.02195502f, 0.00018580f, -0.08157542f, 
    0.01031319f, 0.00751839f, -0.04172872f, 0.03266999f, -0.09001174f, -0.02101510f, -0.01004997f, 0.02681453f, 
    -0.12649743f, 0.02907669f, -0.28533235f, -0.29077530f, -0.27715009f, -0.27694225f, 0.20279886f, 0.01220439f, 
    0.22434399f, 0.03788844f, -0.00300968f, 0.08625785f, 0.18951035f, 0.07374050f, -0.15631230f, -0.04583717f, 
    -0.06921932f, -0.05759684f, 0.18710670f, 0.05319493f, -0.02130304f, -0.07930814f, -0.00263577f, -0.00393229f, 
    0.03863779f, 0.18021289f, 0.18347199f, 0.18271908f, -0.19170496f, -0.10074840f, -0.10388765f, -0.12582056f, 
    0.06021157f, -0.11724061f, -0.05698851f, 0.03844275f, 0.20121716f, 0.11763695f, -0.11566063f, 0.13234703f, 
    0.05715460f, -0.10052308f, -0.00189446f, -0.10716033f, 0.24578896f, -0.19202417f, 0.06841254f, -0.20835881f, 
    0.16669470f, 0.01720001f, -0.06990991f, 0.02645761f, 0.01097758f, 0.06672501f, 0.03117296f, 0.12943932f, 
    0.03300957f, -0.07779447f, 0.07676306f, -0.11882991f, -0.05018449f, -0.01251841f, 0.04422201f, -0.01034978f, 
    -0.07043765f, -0.06042517f, 0.01280438f, -0.06259987f, -0.05721763f, -0.24050170f, 0.06827368f, -0.27349433f, 
    -0.07384228f, -0.09989334f, -0.00124141f, 0.04498017f, 0.02883513f, -0.00318612f, -0.10609595f, 0.03154070f, 
    -0.05084814f, -0.13967967f, -0.11888697f, 0.16778858f, 0.31803700f, 0.23782121f, 0.08133239f, -0.09194816f, 
    0.04636145f, -0.03230530f, -0.11336684f, 0.12778683f, 0.13511790f, 0.00919043f, -0.09931839f, 0.00812809f, 
    0.10196529f, 0.11740406f, 0.02417983f, -0.04332475f, 0.00893875f, -0.08902442f, 0.22776437f, 0.23883834f, 
    -0.03750586f, -0.22216542f, -0.00351882f, 0.02183841f, 0.02141417f, 0.02887075f, -0.11231582f, 0.04918494f, 
    -0.00864272f, 0.23875242f, -0.02878355f, 0.04435840f, 0.05336953f, 0.10074343f, -0.10282700f, 0.15045647f, 
    0.08958410f, 0.12589517f, 0.04979599f, 0.13135400f, -0.08169059f, -0.34214467f, 0.30961210f, 0.16165161f, 
    0.12062055f, 0.06035117f, -0.04550019f, 0.03840510f, 0.17652392f, 0.16016550f, -0.23610798f, -0.09697908f, 
    -0.11601922f, -0.08126634f, -0.03902788f, 0.00971727f, -0.06091185f, -0.09076045f, -0.00165189f, -0.03570907f, 
    -0.16756342f, 0.13791555f, 0.05899691f, -0.08344405f, 0.07588889f, -0.11993613f, 0.06433354f, -0.02867642f, 
    0.14923690f, 0.08930913f, 0.06222367f, 0.06902345f, 0.11768427f, 0.11577661f, -0.01603058f, 0.00404398f, 
    -0.22184867f, -0.05330324f, -0.33147633f, -0.19505242f, 0.40910697f, -0.36517921f, 0.36188048f, -0.02549590f, 
    -0.05390798f, 0.16706964f, -0.10991014f, -0.11726760f, 0.11988017f, -0.01121102f, -0.02780683f, 0.07296477f, 
    0.00720419f, 0.08432529f, -0.02559371f, -0.02517460f, -0.02013945f, -0.13774376f, 0.18421803f, 0.05383145f, 
    -0.09212542f, 0.10086466f, 0.52698088f, 0.19813018f, 0.06422951f, -0.13988723f, 0.06036905f, -0.06616775f, 
    0.16228744f, 0.23756094f, 0.21104224f, -0.13506886f, 0.10914624f, -0.15460323f, 0.08927618f, -0.02844108f, 
    0.04449948f, -0.17132452f, 0.01304912f, -0.04922651f, -0.43671331f, -0.07641552f, 0.39364591f, -0.00860096f, 
    -0.12844938f, 0.06970587f, 0.06089219f, -0.01028064f, 0.07257628f, 0.12718914f, 0.06946778f, -0.19585334f, 
    0.14292334f, 0.09107812f, -0.08772069f, 0.10056700f, 0.29298052f, 0.15764166f, 0.13583392f, 0.13033858f, 
    0.05211040f, -0.33632931f, 0.26535076f, 0.35590494f, 0.38092673f, -0.08514006f, 0.03636888f, 0.16821468f, 
    -0.26404515f, 0.12519266f, -0.00466618f, 0.13040186f, 0.09531979f, 0.04712248f, -0.07999000f, 0.03073328f, 
    0.11600187f, 0.05648374f, -0.19977638f, 0.08319287f, 0.28097600f, -0.16405168f, -0.10464923f, -0.01550953f, 
    0.00399706f, -0.03356800f, -0.09959297f, -0.03465447f, 0.05741615f, 0.05874464f, -0.05022699f, 0.05966364f, 
    -0.06009059f, 0.06570615f, -0.06242377f, 0.07238860f, -0.10445588f, -0.04478494f, 0.09617728f, 0.13793059f, 
    -0.14829084f, 0.16440904f, -0.29745832f, 0.07109393f, 0.31721911f, 0.22480609f, 0.03617206f, 0.15894280f, 
    -0.09081313f, 0.14767136f, -0.00456160f, 0.01830823f, -0.06944826f, 0.07441450f, 0.01328189f, 0.04062174f, 
    0.02936749f, 0.02122298f, 0.06190237f, 0.14285752f, 0.01742075f, -0.27018127f, -0.15509434f, -0.09935724f, 
    -0.06925126f, -0.07959130f, 0.07384343f, 0.03042679f, 0.16696708f, 0.24137019f, 0.13125663f, -0.03452913f, 
    0.00346788f, -0.02190253f, -0.00050408f, 0.18016501f, 0.28370357f, 0.07333910f, 0.11596767f, 0.17563747f, 
    0.04901860f, -0.09560897f, -0.42645094f, 0.07251117f, -0.07445683f, 0.10925199f, 0.05782890f, -0.15831408f, 
    0.00160059f, -0.11879247f, 0.04198657f, -0.05880651f, -0.02723709f, 0.11645833f, 0.03608892f, -0.06453747f, 
    0.10423254f, 0.02006456f, 0.05164557f, 0.20088144f, -0.04701262f, -0.28524199f, 0.08650200f, -0.38510337f, 
    -0.19824772f, -0.05827917f, -0.05917139f, -0.02178351f, 0.00910128f, -0.06627426f, 0.02909065f, 0.02413722f, 
    0.09588997f, 0.04108978f, 0.04301257f, -0.03191000f, 0.07937633f, 0.10148780f, 0.06744068f, 0.11175510f, 
    -0.09448807f, 0.31175911f, -0.17329983f, -0.05771556f, 0.41922700f, 0.14334488f, 0.23500440f, 0.07944443f, 
    -0.02678489f, 0.09122123f, -0.02949632f, -0.07088473f, -0.06156148f, 0.07384063f, 0.04955578f, 0.03041905f, 
    0.07554160f, 0.10132992f, -0.03237722f, 0.04444719f, 0.06952455f, -0.00133924f, 0.16171841f, 0.11506997f, 
    -0.02867789f, -0.23559175f, -0.09451411f, -0.04038882f, -0.03562621f, -0.05441219f, -0.12560393f, -0.11772443f, 
    -0.00683582f, -0.04498632f, 0.03409915f, 0.02636895f, 0.15147947f, -0.05703056f, 0.01877518f, -0.04962143f, 
    -0.11990570f, -0.01002341f, -0.26020351f, -0.05995797f, -0.06015558f, -0.08868753f, -0.06414785f, -0.02191629f, 
    -0.12908374f, -0.26413706f, -0.06743635f, -0.02844400f, -0.07883036f, 0.09016751f, 0.07394143f, 0.07739612f, 
    -0.00840883f, 0.10021465f, -0.03096305f, -0.05645958f, -0.02191745f, -0.08217531f, 0.07168532f, 0.08061126f, 
    -0.18765135f, -0.02083248f, -0.13292062f, -0.24624139f, -0.02539887f, -0.15299867f, 0.03641148f, -0.06097620f, 
    0.01076831f, -0.01140991f, 0.12108947f, 0.00279021f, 0.04961828f, 0.00867439f, -0.09775004f, -0.06879441f, 
    0.28712079f, 0.35928890f, 0.10064085f, 0.17680630f, -0.03171587f, 0.18930398f, -0.13762891f, 0.04549283f, 
    0.11737774f, -0.02055274f, -0.00924403f, 0.11836376f, 0.09522934f, 0.10168338f, 0.12077940f, -0.07630528f, 
    0.07104228f, 0.31057695f, 0.12613502f, -0.10907809f, -0.36877176f, -0.05768543f, -0.20217146f, -0.29219121f, 
    -0.09827103f, -0.06479491f, 0.05377114f, 0.18165611f, 0.14941120f, 0.18468922f, 0.11077499f, 0.15653475f, 
    0.01123967f, 0.10764980f, 0.07689729f, -0.16154237f, 0.01102399f, 0.12771598f, 0.08317155f, 0.01109667f, 
    0.21519370f, 0.07624701f, -0.16200623f, -0.09789290f, -0.14033921f, 0.06461722f, -0.12538378f, -0.18364997f, 
    -0.10097643f, -0.07263214f, -0.02652976f, 0.01113835f, 0.04855841f, 0.07588881f, 0.06775963f, -0.07298005f, 
    0.15831238f, 0.25126112f, 0.13407630f, 0.22560233f, 0.24962513f, -0.23660666f, 0.13232811f, 0.16372003f, 
    0.16814165f, -0.14290516f, 0.17097543f, 0.04195478f, 0.04201626f, -0.16104978f, -0.13879462f, -0.03195262f, 
    0.07815746f, -0.03928161f, 0.04264314f, 0.09490283f, -0.02499716f, 0.11414342f, 0.14883985f, 0.03872525f, 
    -0.16378500f, -0.15032172f, -0.24505541f, -0.22714937f, 0.22828794f, -0.07376615f, 0.14608422f, -0.04671163f, 
    0.09395272f, 0.13299152f, -0.01866643f, 0.06594372f, 0.08174698f, 0.08844310f, 0.01215914f, -0.06926999f, 
    -0.08616973f, -0.09110251f, 0.04107353f, -0.11719060f, 0.21235316f, 0.21843123f, 0.27875414f, -0.18536931f, 
    0.26251900f, -0.16488509f, -0.06889470f, -0.26914281f, -0.09356532f, -0.05128704f, -0.00484065f, 0.02673561f, 
    0.05161988f, -0.05320924f, 0.00972293f, 0.07199370f, -0.05563004f, -0.06084369f, -0.17968923f, -0.18818948f, 
    -0.03564971f, 0.24484515f, 0.04987366f, -0.06907049f, 0.04171158f, 0.09160181f, 0.02821600f, 0.00732876f, 
    0.00843744f, -0.00138727f, 0.02373498f, 0.04581929f, 0.02888510f, 0.03778202f, 0.05656049f, -0.01377355f, 
    0.03080015f, 0.04781485f, -0.01917197f, -0.00556099f, -0.05557570f, 0.25501555f, 0.21210009f, 0.07844278f, 
    -0.04747537f, -0.04345774f, -0.08551603f, -0.25637674f, 0.02091178f, -0.12950657f, -0.08488890f, -0.08835119f, 
    -0.06733977f, -0.01590785f, 0.02366237f, -0.07593078f, -0.03179304f, 0.11681106f, -0.11981967f, -0.13543107f, 
    -0.02166382f, -0.00803828f, 0.04107302f, -0.00898104f, -0.00261416f, -0.01492798f, -0.01407173f, -0.02916953f, 
    0.01726913f, 0.00423512f, 0.01993845f, -0.05926140f, -0.05853331f, -0.02413223f, 0.00039273f, -0.01516481f, 
    -0.01169872f, -0.02320023f, -0.00186858f, -0.01915485f, -0.02863638f, -0.04093504f, 0.04576226f, -0.03296610f, 
    -0.04824379f, -0.04956717f, 0.00013938f, 0.01215238f, -0.00750477f, -0.05641973f, -0.05276761f, -0.03686807f, 
    -0.01530700f, -0.00913416f, 0.00266582f, 0.01901494f, 0.03047643f, -0.04740395f, -0.04375853f, -0.01782098f, 
    0.03191939f, -0.03717981f, 0.02889036f, -0.04875093f, -0.01041690f, 0.02113079f, -0.02996874f, -0.05700335f, 
    -0.00016964f, -0.03427386f, -0.01317143f, -0.02926352f, 0.02936986f, -0.02050326f, -0.03035803f, 0.00796150f, 
    -0.02161885f, 0.00131856f, -0.01089382f, 0.00396170f, 0.03457269f, -0.02564918f, 0.02426512f, 0.05324012f, 
    -0.03542347f, -0.00912067f, -0.01684465f, -0.00078883f, -0.01008999f, -0.03746242f, 0.00349834f, 0.01243205f, 
    0.03091185f, 0.02883258f, 0.04431235f, 0.01103809f, -0.04509996f, -0.05079629f, -0.00233501f, 0.01708174f, 
    0.05143252f, -0.05532713f, -0.01464977f, 0.04034993f, 0.02794322f, 0.02351046f, -0.05521321f, -0.06224748f, 
    -0.00306835f, 0.04861582f, 0.02980738f, -0.03822514f, 0.04786910f, 0.00490183f, 0.04852254f, -0.01722587f, 
    -0.01809511f, -0.02960935f, 0.01983070f, 0.00267415f, -0.02022188f, -0.02611572f, -0.01577532f, -0.05398355f, 
    -0.02076430f, -0.06006860f, -0.02313154f, -0.04329804f, 0.01850682f, 0.04045879f, -0.00381410f, 0.02794825f, 
    0.03723960f, -0.02609922f, -0.03642913f, 0.03036912f, -0.00655647f, -0.02492541f, 0.00272217f, 0.01036976f, 
    -0.01548078f, -0.03670169f, -0.03942435f, 0.05778065f, 0.06183593f, 0.01895400f, 0.01364198f, 0.03467771f, 
    -0.00181472f, 0.02711177f, -0.04548230f, 0.00502839f, 0.01515101f, 0.03645528f, -0.03886410f, 0.02437723f, 
    0.02862815f, -0.04224666f, -0.04934856f, 0.00169636f, 0.01330283f, -0.04456470f, 0.00835308f, 0.01330120f, 
    -0.05159801f, 0.03424817f, 0.01068270f, -0.02255439f, -0.01811557f, 0.02475833f, 0.01075686f, 0.02214346f, 
    -0.01620975f, -0.00244386f, -0.05022550f, -0.00386642f, 0.00402960f, 0.03645747f, -0.05113041f, -0.01668988f, 
    -0.06050087f, -0.03476765f, -0.03112695f, -0.01223858f, 0.00336681f, -0.04788246f, -0.05876864f, -0.01783497f, 
    -0.00595789f, 0.01425349f, 0.02701011f, -0.03093630f, 0.00677962f, 0.00823848f, -0.04554313f, 0.00667132f, 
    0.00243933f, 0.01680078f, 0.01578434f, 0.02610282f, 0.03911261f, 0.02770201f, 0.04153447f, -0.04360930f, 
    -0.02909605f, -0.03482645f, -0.01845526f, -0.04547300f, -0.00546593f, 0.00522378f, 0.00701251f, 0.04611935f, 
    -0.03964186f, 0.01079529f, 0.00599039f, -0.02103577f, -0.01670296f, -0.00057113f, -0.05727258f, 0.01591291f, 
    -0.00384227f, 0.03331785f, -0.00129428f, -0.00215263f, 0.02472955f, 0.00570263f, 0.02202274f, -0.04021443f, 
    -0.02062463f, 0.00588744f, -0.01937009f, -0.01996055f, 0.03989578f, -0.03168776f, -0.02383281f, 0.04594413f, 
    0.03533967f, -0.04519082f, -0.05662435f, 0.02047754f, 0.03447888f, 0.01645879f, -0.00703885f, -0.01995061f, 
    0.02142165f, 0.02751288f, 0.00288457f, 0.01319031f, -0.05304042f, -0.06037144f, 0.03972987f, -0.00989302f, 
    0.04123271f, -0.05052487f, 0.03064373f, -0.02112516f, -0.06142438f, -0.01412711f, -0.05213392f, -0.02494327f, 
    0.00120998f, 0.04268316f, -0.02713539f, -0.01644393f, -0.04974704f, -0.03641787f, -0.04429742f, -0.06093711f, 
    -0.02997238f, 0.00676876f, 0.04695730f, -0.02718645f, 0.00205196f, -0.02918458f, -0.05649457f, -0.00130804f, 
    0.04540047f, 0.04268830f, -0.03695665f, -0.04708313f, -0.01525556f, 0.03109971f, -0.04134053f, 0.04263543f, 
    0.02366836f, -0.02648977f, -0.01279887f, -0.01045304f, -0.00223223f, -0.02118387f, 0.04324012f, -0.00993744f, 
    -0.00545732f, 0.04209438f, 0.01256855f, -0.04734574f, -0.05142545f, -0.01822858f, 0.00049674f, -0.05042286f, 
    -0.00378309f, -0.01068642f, 0.02952430f, 0.02980840f, -0.02260612f, -0.04650446f, 0.01053546f, 0.03102393f, 
    -0.06447648f, -0.02526065f, -0.01136177f, 0.03869896f, 0.03378421f, 0.00541336f, -0.01786301f, -0.00564856f, 
    0.00605078f, -0.02581443f, 0.03499816f, -0.02489054f, 0.04238231f, 0.03046778f, -0.04857545f, 0.02614035f, 
    -0.00420219f, -0.00777664f, 0.04246534f, 0.04022291f, 0.00313383f, -0.01266167f, 0.02375350f, 0.03206932f, 
    -0.04555194f, -0.04598650f, -0.04064082f, -0.01340785f, -0.02490057f, 0.01959750f, -0.05125199f, -0.02537689f, 
    0.23069888f, 0.23254016f, 0.14287020f, -0.00959975f, -0.20951208f, 0.01629076f, 0.11685515f, 0.17541797f, 
    0.01624320f, -0.07933804f, 0.09424498f, -0.04803693f, -0.04600316f, -0.07853266f, -0.13072687f, 0.06855672f, 
    0.00924003f, 0.02888296f, 0.04104012f, 0.10982085f, 0.19401930f, -0.19124122f, 0.08395545f, 0.12517326f, 
    0.16813684f, 0.00269700f, 0.11872885f, 0.13832507f, -0.00042987f, 0.07839958f, -0.07582974f, -0.08384118f, 
    0.05624644f, 0.09460244f, 0.06564983f, -0.09649678f, 0.10846312f, -0.03253917f, -0.05045225f, 0.12995528f, 
    0.40253738f, 0.30215105f, 0.15110098f, 0.04460268f, -0.18525428f, -0.06706219f, 0.15567164f, -0.08857100f, 
    -0.06452022f, -0.08396176f, 0.11711961f, 0.08601687f, 0.06082764f, 0.03065343f, 0.02509933f, -0.05283684f, 
    0.01129184f, -0.13785960f, 0.30807868f, -0.04918688f, -0.28955519f, -0.36296290f, -0.01183267f, -0.15868035f, 
    0.35593191f, -0.01916824f, -0.12197446f, 0.02407464f, 0.21840060f, 0.08989698f, -0.06693369f, -0.04313744f, 
    -0.02826974f, 0.04726300f, 0.07128607f, -0.00024898f, 0.03209839f, -0.00761594f, -0.07542023f, -0.00817372f, 
    0.29302713f, 0.06542277f, -0.11303501f, -0.08904524f, -0.18234347f, -0.03460426f, 0.08679509f, 0.27758977f, 
    -0.00709988f, -0.10276855f, -0.01217216f, -0.08067578f, -0.22614004f, 0.02524532f, -0.06176009f, 0.06919225f, 
    0.04421221f, -0.02885463f, 0.04863162f, -0.02691595f, 0.00237083f, -0.29257447f, -0.04824149f, 0.09592357f, 
    0.14247032f, 0.11280279f, 0.11994417f, -0.15171073f, -0.02901364f, -0.03642885f, -0.12126528f, 0.03916635f, 
    0.08264671f, 0.04860346f, -0.03494389f, -0.13595925f, -0.15716642f, -0.04576340f, 0.01032004f, -0.02032116f, 
    0.26052690f, 0.16384439f, 0.29179460f, -0.19743630f, -0.11586877f, -0.01056219f, -0.00781555f, 0.07995122f, 
    -0.15992770f, -0.16829692f, 0.10972918f, -0.00715233f, -0.09736705f, -0.01601178f, -0.03613384f, 0.05723119f, 
    -0.02549101f, -0.07935780f, -0.16858931f, -0.02945415f, -0.20667496f, 0.40680021f, -0.13783729f, -0.29062331f, 
    -0.12581480f, 0.09471802f, -0.13720983f, -0.39417446f, 0.05137954f, -0.07912530f, -0.03575088f, 0.02241955f, 
    0.17255117f, -0.00727927f, -0.08864284f, 0.03244572f, 0.00034128f, -0.02419173f, 0.15414949f, 0.06039437f, 
    -0.31886443f, 0.14565116f, 0.11130354f, 0.13912290f, 0.02991171f, 0.06225644f, -0.08604155f, -0.13880314f, 
    0.12803411f, -0.05107063f, -0.05969976f, -0.04969645f, -0.07504043f, 0.21804257f, 0.15699922f, -0.11556154f, 
    -0.19886962f, -0.01783570f, 0.00232448f, 0.00598011f, -0.37754154f, 0.00972802f, -0.11553360f, 0.02557458f, 
    0.12092669f, -0.12205756f, 0.08197344f, 0.05652051f, 0.20119999f, -0.00059918f, 0.02040426f, 0.01578865f, 
    -0.04799501f, 0.02090013f, 0.01583286f, 0.07078422f, 0.15483937f, 0.02788326f, -0.06675122f, -0.00706182f, 
    0.01365727f, 0.35943493f, 0.31121761f, -0.07377546f, -0.07445467f, -0.20390345f, -0.14944239f, 0.06700196f, 
    0.09290328f, -0.01546053f, -0.02449521f, -0.00132970f, 0.17017671f, 0.05488639f, 0.07636136f, -0.09255137f, 
    -0.06803300f, -0.01360723f, 0.08007281f, 0.01688941f, 0.26046368f, -0.55027473f, -0.02916138f, 0.12709375f, 
    -0.18742134f, 0.15501049f, 0.19670339f, -0.26380944f, -0.01336321f, -0.00333975f, -0.19149671f, 0.00002814f, 
    0.12817308f, 0.10328688f, -0.04775738f, 0.19047914f, -0.09409392f, -0.14502257f, -0.05375447f, -0.01822929f, 
    -0.10751842f, -0.17785729f, -0.10347457f, 0.18592793f, 0.10694082f, 0.00800441f, 0.15265334f, 0.08436447f, 
    0.05435370f, 0.06895924f, 0.12298328f, 0.04541949f, -0.08146938f, -0.23029371f, -0.05797251f, 0.15991454f, 
    0.13665490f, -0.13495512f, 0.00439276f, 0.03596358f, 0.41363189f, -0.55135781f, 0.35832044f, 0.09518746f, 
    0.13350278f, -0.19692834f, -0.01424199f, 0.01730706f, -0.04734827f, -0.00450265f, 0.16742459f, -0.02592651f, 
    -0.02367139f, -0.03572944f, -0.03585728f, 0.11127774f, -0.01610182f, 0.05706875f, 0.03385459f, -0.11725871f, 
    0.04207054f, -0.24479498f, 0.19105473f, 0.05000640f, -0.05014558f, -0.12059979f, -0.06610300f, 0.23247688f, 
    0.30539700f, 0.07932782f, -0.00170182f, 0.16594388f, -0.13684326f, -0.06321584f, -0.10264467f, 0.01492159f, 
    -0.05343341f, -0.17397560f, -0.10840821f, -0.01956477f, -0.08225259f, -0.19980332f, -0.00261928f, -0.05384817f, 
    -0.11739450f, 0.09384497f, 0.06092678f, -0.14480251f, 0.08285458f, -0.02994408f, -0.07739475f, -0.07539256f, 
    0.07490800f, 0.10983953f, -0.04227870f, -0.02514101f, -0.10347459f, 0.15512529f, 0.06473875f, -0.05803982f, 
    -0.10574545f, 0.08573303f, 0.27735373f, 0.04839155f, -0.29856941f, 0.00851466f, 0.12237348f, -0.02730770f, 
    0.07344382f, 0.03326353f, 0.05593382f, 0.00979251f, -0.07468615f, 0.03703444f, 0.00248361f, -0.01196102f, 
    0.04893079f, -0.06316306f, -0.02164572f, 0.06004382f, -0.29613274f, 0.36484995f, 0.20882760f, 0.10829941f, 
    -0.04223498f, -0.06094918f, -0.09084821f, -0.08224522f, -0.02627613f, 0.08052172f, -0.03980598f, -0.03786078f, 
    0.13921520f, -0.02979495f, -0.16219081f, -0.01402206f, -0.07131504f, -0.10944272f, 0.00876673f, -0.07398662f, 
    -0.31403205f, -0.11608545f, 0.40119338f, 0.12276267f, -0.16829266f, -0.12024267f, 0.14341791f, 0.04154803f, 
    -0.01668491f, -0.03737595f, 0.00957952f, -0.01036832f, -0.03546492f, -0.05375424f, -0.09058811f, 0.02194257f, 
    0.10026510f, -0.08288474f, -0.02843660f, 0.12685989f, -0.50867474f, 0.14764430f, 0.19726025f, 0.49072343f, 
    0.08729459f, -0.00308471f, -0.00571016f, -0.13539432f, -0.12516199f, 0.04154044f, 0.26030263f, 0.06711053f, 
    0.01543347f, -0.03288698f, -0.12284308f, 0.00483727f, -0.01255304f, 0.09049365f, 0.01434149f, -0.01340995f, 
    0.08338473f, -0.01224690f, 0.42788449f, 0.09664480f, -0.23856711f, 0.02302726f, 0.06438492f, -0.02489448f, 
    0.18190646f, 0.11595617f, 0.05133068f, 0.09489337f, 0.00747950f, -0.00662183f, -0.00634294f, 0.04518727f, 
    -0.03259600f, 0.00401707f, 0.04964133f, 0.04640333f, -0.00501204f, -0.26999107f, -0.16056205f, -0.09561785f, 
    0.27962667f, 0.04417926f, 0.02303196f, 0.06397609f, -0.17866890f, 0.06399670f, 0.00704307f, -0.07291538f, 
    -0.05153633f, 0.03976302f, -0.02180038f, -0.02171549f, -0.12427679f, -0.00278451f, 0.05963236f, -0.02620136f, 
    -0.17865011f, 0.00010639f, 0.33626580f, 0.30765879f, -0.25390118f, 0.12767652f, -0.05547182f, 0.07862081f, 
    0.11360589f, 0.14289425f, 0.11373396f, 0.02472073f, 0.01086749f, 0.04964284f, 0.02253624f, 0.01368518f, 
    0.17822018f, -0.08786587f, -0.01088779f, -0.03625694f, -0.04237140f, -0.23738779f, -0.42955667f, 0.02126161f, 
    0.30898130f, 0.11068944f, 0.29610014f, 0.19418724f, 0.01194284f, 0.09540015f, -0.04085996f, -0.01885646f, 
    -0.15555038f, -0.01134943f, -0.14333977f, 0.02089555f, 0.03191608f, -0.04100339f, 0.05826268f, 0.02329870f, 
    0.07703658f, -0.10101026f, -0.02417256f, 0.03607274f, 0.28803226f, 0.20222594f, -0.07655672f, -0.03377238f, 
    0.01916828f, 0.09946875f, 0.11451389f, 0.00565191f, -0.16433409f, 0.02618497f, -0.03211312f, 0.07816014f, 
    0.03907061f, -0.05634522f, -0.10200621f, -0.07245973f, -0.20131443f, 0.36996832f, 0.42307037f, 0.26519185f, 
    0.09857965f, -0.06152913f, -0.16996740f, -0.07352510f, -0.09609044f, -0.07560781f, 0.14208131f, 0.09639268f, 
    0.07201336f, 0.13159361f, -0.02277382f, -0.05280719f, -0.08058784f, 0.10287333f, 0.00176761f, -0.08163576f, 
    -0.23343517f, -0.06711496f, -0.15687183f, 0.02572780f, 0.00612074f, 0.00071220f, 0.13894804f, 0.04849788f, 
    -0.15385561f, 0.04484706f, -0.06267145f, -0.09018913f, -0.26922944f, -0.05074594f, -0.11347716f, 0.02119854f, 
    -0.14264436f, -0.11205599f, 0.03479016f, -0.21697561f, 0.26337278f, 0.00885761f, -0.47429618f, -0.25839859f, 
    0.09483349f, 0.01258103f, -0.01988226f, 0.30612227f, -0.21850726f, 0.08542049f, 0.10755521f, -0.14045188f, 
    -0.14016610f, -0.04979933f, 0.01937875f, 0.14994808f, 0.05547708f, 0.09210202f, 0.05962022f, -0.07596885f, 
    0.06485513f, 0.27158263f, 0.44796687f, -0.14868678f, -0.09525481f, -0.02143762f, -0.17709574f, -0.09686881f, 
    -0.11530374f, -0.04384681f, 0.01921039f, 0.13160776f, 0.15149280f, 0.00256625f, -0.06270132f, 0.02454449f, 
    -0.04980858f, 0.17024496f, -0.07079481f, 0.04179455f, 0.30957124f, -0.16672978f, -0.12118940f, -0.02755069f, 
    0.13220839f, -0.09166816f, -0.05816144f, -0.19845289f, -0.04500607f, -0.18130711f, -0.02739378f, 0.25295869f, 
    0.10182740f, -0.14310148f, 0.02123982f, 0.19107039f, -0.01918660f, 0.10320926f, 0.26630631f, 0.34549999f, 
    -0.36693409f, -0.02821808f, 0.27169710f, 0.31965965f, -0.03247840f, -0.10372896f, -0.07063452f, -0.01568993f, 
    0.18097964f, -0.12754141f, 0.09284858f, -0.05408226f, 0.07327779f, -0.03418230f, 0.06729799f, 0.04390576f, 
    0.14445831f, 0.10563716f, 0.04563138f, 0.09791007f, 0.29122648f, -0.15522809f, -0.21440776f, -0.01877173f, 
    0.22979563f, 0.03512257f, 0.05161522f, 0.11491838f, -0.10142982f, 0.02438253f, -0.06498449f, 0.02919597f, 
    -0.00142906f, -0.08855142f, -0.04035327f, 0.08369284f, 0.07123351f, -0.03515499f, 0.05734498f, -0.01048124f, 
    -0.27662221f, 0.15088078f, -0.13474230f, 0.46575996f, 0.19982886f, 0.05438141f, -0.04652071f, 0.03999160f, 
    0.04404762f, -0.08393015f, -0.07852879f, 0.12440214f, 0.12462652f, -0.06036620f, -0.10186931f, 0.07078210f, 
    0.12502970f, -0.03532843f, 0.05679318f, 0.02632963f, -0.31633079f, -0.26116979f, -0.10702808f, 0.00325514f, 
    0.21461782f, 0.03603401f, 0.19100168f, 0.03568267f, 0.16427517f, -0.10186158f, 0.13350891f, 0.06519546f, 
    -0.03697642f, 0.03355576f, 0.01480436f, -0.14271283f, 0.12551725f, 0.09359600f, -0.04784796f, 0.08201747f, 
    -0.49339506f, -0.14477523f, -0.54599029f, 0.42257008f, 0.19527800f, -0.00778920f, 0.07318930f, -0.25392488f, 
    0.06250796f, -0.17939076f, -0.15573758f, 0.02551461f, 0.01610839f, 0.05758787f, -0.11643007f, 0.00087283f, 
    0.04964913f, 0.01965062f, -0.19328775f, 0.06038421f, -0.01376304f, -0.48724216f, 0.25331813f, -0.35702848f, 
    0.01798533f, 0.11139330f, 0.10183576f, 0.05630171f, -0.07740572f, -0.07547454f, -0.15726453f, 0.04949528f, 
    0.12685935f, 0.04647618f, 0.24823916f, 0.02285774f, 0.04530732f, -0.02139893f, -0.00178510f, 0.08876710f, 
    -0.24067953f, 0.34286377f, 0.26891196f, 0.24338138f, 0.28514522f, 0.07184871f, 0.01755562f, -0.04195213f, 
    0.15062132f, -0.00854443f, 0.14565475f, 0.00291471f, 0.11319216f, 0.02117828f, -0.01803195f, 0.14826891f, 
    -0.06299574f, 0.04484197f, 0.01082374f, 0.00078406f, 0.41014111f, -0.29075798f, 0.25610283f, -0.36236590f, 
    0.00925104f, -0.35626009f, -0.11942998f, -0.10916505f, 0.04774042f, -0.05816044f, -0.12639911f, -0.03493883f, 
    -0.04798990f, -0.20999354f, -0.06265327f, 0.07358589f, 0.09845645f, -0.06219076f, 0.06259745f, -0.12532416f, 
    -0.37260583f, -0.09110625f, -0.21866702f, 0.18435997f, 0.09418633f, -0.15092754f, -0.13898173f, -0.21062972f, 
    -0.00806658f, -0.28316173f, -0.15824248f, 0.09668110f, -0.02721100f, -0.00547910f, 0.04998102f, 0.01194483f, 
    -0.02609544f, 0.08052842f, -0.26596451f, 0.08499137f, -0.15160996f, -0.05488604f, 0.01680480f, -0.20731896f, 
    -0.34613526f, -0.09460342f, -0.18257727f, -0.24062444f, 0.01441314f, -0.07884032f, -0.07331026f, 0.06725699f, 
    0.00953585f, -0.00145474f, 0.07988204f, 0.02583921f, -0.08436503f, 0.03060658f, 0.07302825f, -0.00579623f, 
    0.56927383f, 0.07058784f, 0.05631850f, -0.12139066f, 0.12424479f, 0.11431265f, -0.12939425f, -0.02831477f, 
    0.00178780f, 0.18780389f, -0.06418639f, -0.01024204f, 0.13210513f, 0.00139816f, 0.10598572f, -0.05455071f, 
    0.10607186f, 0.17685990f, 0.27075747f, -0.09375439f, 0.01163742f, -0.43120083f, 0.37056842f, -0.14768480f, 
    0.05070088f, 0.24760981f, 0.08947076f, 0.12576039f, 0.04612849f, -0.01520051f, 0.07213023f, 0.04475553f, 
    0.00411875f, 0.16502255f, 0.18500330f, 0.04430714f, 0.02128036f, -0.03905477f, 0.15197910f, -0.01666793f, 
    -0.22113644f, 0.01589579f, -0.32084551f, -0.32850233f, -0.06328434f, -0.01232500f, -0.12963168f, -0.10525747f, 
    0.00452991f, 0.07670845f, -0.07670110f, -0.10840604f, 0.04167688f, 0.17125177f, -0.08701240f, -0.19696942f, 
    -0.03350565f, 0.10010564f, 0.06121396f, 0.02531263f, 0.18366808f, -0.60302794f, 0.37391385f, -0.14876314f, 
    -0.02704539f, -0.18551530f, -0.06582444f, -0.11174893f, 0.17005475f, -0.04736521f, -0.17357962f, -0.02877458f, 
    0.03513672f, 0.01441483f, -0.03509143f, 0.05021148f, -0.09725943f, -0.06112483f, 0.10304196f, 0.12723932f, 
    0.44747841f, 0.11769382f, 0.39707300f, -0.01428783f, 0.12507075f, 0.04398846f, -0.00237200f, -0.05118145f, 
    0.19522019f, 0.03469956f, 0.13679604f, -0.02480241f, 0.10341664f, -0.05017120f, 0.05912820f, -0.03168100f, 
    -0.06533955f, -0.15614213f, 0.09074024f, -0.16252767f, -0.02964236f, 0.62639403f, 0.36853695f, 0.19100983f, 
    -0.05493337f, -0.04220017f, 0.08325438f, -0.15792210f, -0.09695107f, -0.03783965f, -0.07266711f, -0.12213217f, 
    0.05925865f, -0.03891342f, -0.01875531f, 0.18351975f, 0.02535332f, 0.01093273f, -0.07298228f, -0.11835731f, 
    0.08983210f, 0.06845877f, 0.36550826f, 0.08722335f, 0.49420741f, 0.14139305f, 0.20005257f, 0.00316578f, 
    -0.05351484f, 0.15581478f, 0.08443360f, 0.15523285f, 0.13728993f, -0.06410921f, 0.02291652f, 0.09489356f, 
    -0.00925836f, -0.04089573f, -0.08775789f, -0.07091394f, 0.25957030f, 0.05752505f, 0.13243200f, -0.14159279f, 
    -0.20960712f, -0.19291277f, -0.19497141f, -0.17406864f, 0.00265220f, -0.09588362f, -0.01612181f, 0.02033902f, 
    -0.06105279f, -0.08269627f, -0.05954834f, 0.04432204f, -0.04568951f, -0.00895145f, 0.05430908f, -0.10135988f, 
    0.19707061f, 0.00262564f, 0.12505540f, 0.02101425f, 0.06918853f, 0.10910646f, 0.00658371f, -0.10395698f, 
    0.00493575f, 0.10800096f, -0.06769531f, 0.03759503f, -0.07257266f, 0.01168130f, -0.07398597f, 0.02540122f, 
    -0.12465032f, -0.01010174f, 0.15247472f, -0.00316061f, 0.33391607f, -0.06748904f, 0.00064979f, -0.09943759f, 
    -0.10224786f, 0.08689277f, -0.06393190f, -0.13965122f, -0.01825202f, -0.13452490f, -0.05229602f, -0.10683545f, 
    0.03503734f, -0.08964487f, 0.24781452f, -0.01470303f, -0.22323039f, -0.04126088f, -0.14899324f, -0.35234079f, 
    0.51211309f, 0.21058930f, 0.32266146f, -0.18847468f, 0.14321104f, 0.32717985f, -0.08767543f, 0.05228563f, 
    -0.05114057f, 0.14311340f, 0.17556269f, 0.09105664f, -0.12491266f, -0.01665619f, -0.02582937f, 0.02000233f, 
    -0.15408777f, 0.01099402f, 0.09038901f, -0.09043524f, 0.29454800f, 0.17935322f, -0.31558654f, -0.14247920f, 
    -0.05344210f, -0.15724024f, 0.13260904f, -0.10127794f, 0.37870270f, 0.08741774f, 0.00629137f, 0.04680946f, 
    -0.01954897f, -0.02480693f, -0.06312328f, -0.22439842f, 0.03215981f, -0.07771681f, -0.09888820f, -0.23199300f, 
    -0.08879917f, -0.08194453f, -0.33556491f, 0.19501877f, -0.00919946f, -0.02863747f, 0.17135400f, -0.02167890f, 
    -0.16810796f, 0.09576526f, -0.10059578f, 0.11001061f, 0.03380143f, 0.09693932f, 0.07022019f, -0.03585693f, 
    0.07318782f, -0.02686623f, 0.04765799f, 0.23147264f, -0.00173039f, 0.26471192f, 0.08570398f, 0.17126425f, 
    -0.14772645f, 0.17092444f, 0.08900181f, -0.07798643f, 0.16729273f, -0.00171119f, 0.06659853f, -0.07936439f, 
    -0.10288005f, -0.00868863f, -0.04483497f, -0.04806182f, 0.03467568f, -0.04700577f, -0.09335031f, -0.10514647f, 
    0.41233653f, 0.20574507f, 0.10433950f, -0.18115258f, 0.16954634f, 0.32481560f, 0.11633062f, 0.04392747f, 
    -0.06370790f, 0.10875139f, 0.07633904f, -0.05659119f, -0.01729711f, -0.13279459f, -0.08189556f, 0.03684396f, 
    -0.00791262f, -0.02645638f, 0.25728911f, 0.02322774f, 0.20712709f, 0.38234904f, 0.48619783f, 0.30859226f, 
    -0.07823189f, -0.11408669f, -0.02339922f, 0.12660807f, 0.05512843f, -0.01430001f, 0.00349547f, -0.01081655f, 
    -0.11061435f, -0.12129630f, -0.02467803f, -0.05311990f, 0.02119736f, -0.03940086f, 0.02527938f, 0.07097537f, 
    -0.49243000f, 0.09080533f, 0.13322999f, 0.26436761f, -0.23062412f, -0.30997732f, 0.20267430f, 0.20258644f, 
    -0.27400678f, -0.04340578f, 0.11307801f, -0.05711520f, -0.15564921f, 0.12864561f, -0.15446244f, 0.08724892f, 
    0.00830197f, 0.04236194f, -0.06012587f, 0.18112481f, 0.04353283f, 0.15408231f, -0.59259892f, -0.13564743f, 
    -0.02892886f, -0.16700129f, 0.08827747f, -0.12227469f, -0.10305887f, -0.06331676f, -0.03945630f, -0.10962043f, 
    0.01988438f, -0.04838879f, -0.13580191f, -0.14399847f, -0.00037018f, 0.02729624f, -0.08579478f, 0.11930187f, 
    -0.13209604f, 0.19110867f, 0.36907470f, 0.37115011f, -0.01805415f, -0.15253250f, 0.05486537f, -0.05388514f, 
    0.04755957f, -0.11829484f, -0.02123084f, 0.07347699f, -0.02727490f, -0.05678929f, -0.19009328f, 0.04317312f, 
    -0.17044646f, -0.16737543f, -0.50223047f, -0.19107753f, 0.22845288f, 0.25727490f, 0.45672622f, 0.44413397f, 
    -0.00786958f, -0.12272470f, 0.13196068f, -0.27764899f, 0.09756697f, 0.00099557f, 0.01598798f, 0.08429902f, 
    -0.13990156f, -0.06356309f, -0.09440618f, 0.10699467f, 0.12610853f, -0.05866167f, 0.00402619f, -0.03800606f, 
    -0.40668860f, 0.11038444f, -0.59559935f, 0.18441479f, -0.06808787f, -0.00571229f, 0.08770942f, -0.07000779f, 
    -0.03287367f, -0.15704241f, -0.12963775f, -0.04385758f, 0.03066405f, 0.09112643f, 0.22001457f, 0.06921629f, 
    0.00517936f, 0.11986560f, -0.00110113f, 0.18213706f, -0.29909533f, -0.27452996f, -0.34311163f, 0.15127960f, 
    -0.08724929f, 0.15865450f, -0.09520618f, 0.16063945f, 0.13232867f, -0.04635799f, -0.05375854f, 0.08295047f, 
    0.13421854f, 0.20955576f, -0.05173298f, -0.13938633f, 0.02422244f, 0.12107018f, 0.04945789f, 0.18332601f, 
    0.14523605f, 0.09451267f, -0.19382730f, 0.04805241f, -0.14413159f, 0.05515126f, 0.15472893f, 0.16681303f, 
    -0.05584645f, 0.07238392f, -0.10751835f, -0.01253416f, 0.02239560f, 0.27196637f, 0.08202535f, 0.08188067f, 
    0.19839752f, 0.15361460f, 0.14982831f, 0.33824363f, -0.08620284f, -0.01267605f, 0.22888850f, 0.23618942f, 
    -0.06493510f, -0.13472462f, 0.08217150f, -0.20329484f, -0.01777321f, 0.02610263f, -0.02053167f, -0.05461039f, 
    -0.17427883f, -0.04014291f, 0.03028668f, 0.03045275f, 0.10538799f, 0.06010196f, -0.05201137f, 0.05661185f, 
    -0.06756604f, -0.04345274f, -0.04096613f, 0.04627138f, -0.24426086f, -0.08781511f, -0.10467322f, -0.01328267f, 
    0.06288393f, 0.25986937f, 0.03959794f, 0.01976727f, -0.02556914f, -0.00985657f, 0.02502919f, 0.09419236f, 
    -0.03887934f, -0.02061336f, -0.01042588f, 0.00195371f, -0.10134508f, 0.10189476f, 0.20678730f, -0.07994131f, 
    -0.14282490f, 0.04793362f, 0.01209815f, -0.24012245f, 0.05208149f, 0.02425436f, 0.04929357f, 0.11892603f, 
    0.13851757f, -0.06069300f, 0.06103573f, -0.09618228f, -0.09031310f, -0.03367680f, -0.07314602f, -0.04097899f, 
    -0.18116720f, -0.28960055f, 0.08707411f, -0.06835854f, -0.18698946f, 0.05985974f, -0.21674658f, 0.04405085f, 
    -0.08043900f, 0.07621586f, -0.03931436f, 0.00312619f, 0.00637616f, -0.01192336f, -0.03346857f, 0.06673925f, 
    0.07707588f, -0.09995329f, -0.06668053f, -0.06311181f, -0.30684277f, 0.04820773f, 0.06509693f, 0.16924104f, 
    -0.04916147f, -0.12263322f, -0.00326731f, -0.03413008f, -0.08854998f, 0.05976269f, 0.12255487f, 0.16090448f, 
    -0.06414978f, -0.13624769f, 0.03003195f, 0.09591057f, -0.15217946f, 0.00012727f, 0.03622438f, -0.10952096f, 
    0.05857559f, -0.11650453f, 0.06513776f, 0.28085160f, -0.37418148f, 0.11821037f, 0.06541730f, -0.09227675f, 
    0.10317788f, 0.21135472f, 0.01750735f, 0.21509510f, 0.01462730f, 0.12810902f, -0.02868425f, 0.02964517f, 
    0.02822002f, 0.03454630f, -0.02262729f, -0.03003900f, 0.11984924f, 0.00234927f, 0.02422497f, -0.11094795f, 
    -0.04234899f, 0.01699861f, -0.11155590f, 0.01321014f, -0.03485718f, -0.08899760f, -0.04471148f, -0.03447082f, 
    -0.18219759f, 0.03667612f, -0.04908501f, 0.07872710f, 0.03967894f, 0.15425724f, 0.00255059f, -0.00046883f, 
    -0.19982399f, -0.12891212f, -0.26996475f, -0.06053664f, -0.23271729f, 0.05933307f, -0.22967409f, -0.04120361f, 
    0.04601097f, 0.24430400f, 0.04114616f, 0.04515733f, -0.00987473f, -0.06794631f, -0.04666124f, 0.04171692f, 
    0.03383969f, -0.06432109f, 0.24118875f, -0.00820445f, 0.43113115f, 0.12196057f, 0.00055893f, 0.15908737f, 
    -0.22887051f, -0.03658830f, -0.09072562f, 0.23164789f, 0.10912962f, 0.00244848f, -0.10285017f, -0.07533551f, 
    -0.17091843f, 0.01698191f, -0.14352778f, -0.08625937f, 0.03873736f, 0.04090350f, 0.17857052f, 0.14145705f, 
    -0.05298538f, 0.22662641f, 0.10023966f, 0.21885104f, 0.22497886f, -0.23563376f, 0.10312081f, 0.01954392f, 
    -0.04519187f, 0.02296272f, 0.02801000f, -0.13273568f, -0.03924921f, -0.05219878f, 0.00986844f, 0.14307982f, 
    0.02560329f, 0.15664341f, 0.10817817f, 0.02788227f, -0.15082398f, 0.22163431f, 0.07533566f, 0.07715883f, 
    -0.17235659f, -0.00855401f, -0.03944366f, -0.14359924f, -0.10223752f, -0.01815368f, 0.02139535f, 0.09823599f, 
    -0.00268532f, 0.10514051f, 0.02772425f, -0.04963712f, -0.05698926f, 0.08100144f, 0.03147557f, -0.00443803f, 
    -0.31183541f, -0.15853402f, -0.11203326f, 0.07877684f, -0.08732608f, 0.10729798f, -0.07846486f, 0.03526057f, 
    -0.00613505f, -0.11755929f, -0.16512351f, 0.02443421f, -0.17562364f, -0.07079601f, -0.03379881f, 0.20517923f, 
    -0.06646468f, -0.09205449f, -0.12935971f, -0.17352751f, 0.32900837f, 0.21080124f, 0.10732973f, 0.03177997f, 
    -0.16384269f, -0.00992751f, -0.03437049f, 0.02350826f, 0.06908096f, -0.00023209f, -0.02239871f, -0.06811760f, 
    -0.18271081f, -0.01473965f, -0.02423898f, -0.00012975f, 0.13625862f, 0.16695464f, 0.16867878f, 0.16583249f, 
    -0.16614066f, -0.03534194f, -0.03959075f, -0.05988018f, -0.31657541f, -0.05982399f, -0.11841507f, -0.23458557f, 
    0.07406002f, -0.06039570f, -0.06283256f, 0.06156743f, 0.11894575f, 0.15376690f, 0.04265338f, 0.02059196f, 
    -0.09779146f, 0.06790273f, -0.13741577f, 0.10328630f, -0.17732638f, -0.29608569f, -0.12643856f, 0.27601811f, 
    0.03834256f, -0.01306683f, -0.04321115f, -0.16574913f, -0.06016924f, -0.16263071f, -0.13330753f, 0.01980633f, 
    0.05107009f, 0.08284973f, 0.07907185f, 0.32493806f, 0.00103722f, 0.06092621f, 0.10157601f, 0.25803760f, 
    -0.19722876f, -0.19999003f, -0.17587793f, 0.29601929f, -0.24062750f, 0.13399047f, 0.01286156f, 0.02017882f, 
    -0.03606464f, -0.07261969f, 0.10541899f, 0.06835045f, 0.00605738f, 0.02394515f, 0.03106271f, 0.17293210f, 
    0.02460373f, 0.22283863f, 0.14344254f, 0.20114183f, 0.35003227f, -0.03258690f, 0.01446749f, 0.04932034f, 
    -0.00381095f, -0.18758596f, -0.03860705f, -0.06751608f, -0.07834995f, -0.02466535f, -0.12650205f, -0.03812426f, 
    -0.13839479f, -0.05137106f, 0.00646564f, -0.00935263f, 0.20358932f, 0.09542489f, -0.05862923f, 0.03771408f, 
    -0.13729420f, -0.06519932f, 0.21908087f, 0.04888828f, 0.19503570f, 0.19508761f, 0.05064493f, 0.06466158f, 
    0.01234717f, -0.00471332f, 0.11526643f, -0.02287552f, 0.03685626f, -0.00111140f, -0.04261315f, -0.09281889f, 
    -0.07079129f, 0.10783443f, 0.03429645f, -0.06350663f, 0.16662262f, -0.03232038f, -0.35098410f, -0.02971023f, 
    -0.00735089f, -0.07074305f, -0.03429884f, -0.01875598f, 0.03725040f, 0.01502287f, 0.01351356f, -0.11245356f, 
    -0.08614381f, -0.03205155f, 0.00807818f, 0.13387959f, 0.08149352f, -0.00486175f, -0.02182647f, 0.03107597f, 
    0.23291360f, -0.28576827f, 0.02238711f, 0.18085542f, -0.19444728f, 0.08139315f, 0.12496722f, -0.07546886f, 
    -0.11614184f, -0.08183944f, 0.21082671f, 0.01329334f, -0.07065832f, 0.05410111f, 0.01631078f, -0.06661667f, 
    -0.12541789f, -0.05657623f, 0.17673531f, 0.14944667f, 0.07205978f, 0.08152544f, -0.30334926f, -0.37288314f, 
    -0.13455240f, -0.06982126f, -0.04362411f, -0.13596153f, 0.01047771f, -0.02829305f, 0.10722823f, -0.05340724f, 
    0.10783066f, 0.09201007f, -0.01628066f, -0.06856935f, 0.01700727f, -0.02287132f, 0.06555133f, 0.21973948f, 
    -0.22074802f, -0.09658744f, -0.00272268f, -0.26455125f, 0.44317076f, -0.01675360f, 0.14857998f, 0.19755465f, 
    0.05087201f, -0.08732915f, -0.05259228f, 0.05223791f, -0.02699953f, -0.03707488f, -0.06499566f, 0.06088339f, 
    0.02031011f, 0.18723364f, 0.04602702f, -0.11136556f, 0.11338574f, 0.31975693f, 0.21100725f, 0.30907476f, 
    0.04013936f, -0.05139019f, 0.08667094f, 0.02199325f, -0.07786418f, 0.03258596f, -0.10255742f, -0.17255300f, 
    -0.00794622f, -0.07745583f, -0.08816834f, 0.00610790f, -0.00070306f, -0.09658565f, -0.01757288f, 0.00575689f, 
    0.08117694f, -0.09061947f, 0.05263963f, 0.10469715f, 0.03453381f, -0.02719041f, 0.03172094f, 0.02634096f, 
    -0.08478517f, -0.37126923f, -0.00059167f, -0.00456595f, -0.05780112f, 0.00563711f, 0.02687231f, -0.09937041f, 
    0.00460910f, 0.07777276f, -0.05049508f, -0.06461402f, -0.10934662f, -0.03196930f, 0.33761770f, -0.07586201f, 
    0.02026797f, 0.05309468f, 0.18489912f, -0.09434722f, -0.08213875f, -0.16690698f, 0.13286918f, -0.07023731f, 
    -0.06956258f, -0.10502955f, -0.08172423f, 0.02670107f, -0.02080952f, 0.11299767f, -0.04739460f, -0.05243886f, 
    0.39780024f, 0.44053179f, -0.08746602f, 0.08374241f, -0.15452982f, 0.20420434f, -0.14720733f, 0.00587021f, 
    0.08129092f, 0.02417077f, -0.04401869f, -0.09076404f, 0.00042168f, 0.02981865f, -0.03158347f, -0.13399720f, 
    0.08241405f, -0.02226873f, -0.01605501f, -0.18597938f, -0.33566952f, 0.05117868f, -0.27231929f, -0.33708146f, 
    -0.02500762f, -0.08022849f, -0.02627233f, 0.10073754f, 0.14798768f, 0.04613399f, 0.19892108f, 0.08415165f, 
    0.01201478f, 0.04691286f, 0.00657764f, -0.09515532f, -0.00139452f, -0.03352015f, 0.04425637f, -0.03516107f, 
    0.35973325f, -0.06751399f, -0.05644958f, 0.14787637f, 0.01411788f, -0.04491678f, -0.08638291f, -0.27054885f, 
    -0.09116799f, -0.00538282f, 0.01172092f, 0.13251869f, 0.14599830f, -0.09670704f, 0.11154679f, -0.17461435f, 
    0.10543565f, -0.05567697f, 0.10745313f, 0.05290174f, 0.37093648f, 0.05641299f, -0.12269448f, 0.17487097f, 
    0.32697725f, -0.03958217f, 0.13708963f, 0.06578059f, 0.21827571f, -0.04415783f, -0.03922335f, 0.00910039f, 
    0.03312622f, -0.12813343f, -0.02183041f, 0.09700656f, -0.08481622f, 0.12302089f, -0.01360348f, 0.00119926f, 
    -0.63601893f, -0.11647644f, -0.19892256f, -0.23053700f, 0.35030329f, -0.16339320f, 0.09108502f, 0.12835048f, 
    0.02528840f, 0.02799906f, -0.03028172f, 0.03484641f, 0.02560178f, 0.04173586f, 0.01253231f, -0.03390342f, 
    -0.19438407f, -0.01348915f, 0.07383871f, 0.02071494f, -0.09585555f, -0.06241128f, 0.10599823f, -0.38310236f, 
    0.42010823f, -0.18134588f, 0.01684320f, -0.07317290f, -0.15889511f, 0.07715756f, 0.08262613f, 0.05465322f, 
    -0.04556624f, -0.17875069f, 0.02778608f, -0.11119215f, -0.19666362f, 0.03002778f, 0.13326417f, 0.04020856f, 
    -0.11651281f, -0.08755466f, -0.12566134f, -0.18450619f, 0.08281291f, -0.11907734f, -0.10278090f, -0.08183859f, 
    -0.02647316f, -0.00461851f, -0.05177905f, 0.02245675f, -0.03970078f, 0.07022583f, 0.04486972f, 0.01261435f, 
    -0.06264426f, -0.05424701f, 0.18517824f, -0.03693228f, -0.06627728f, 0.34394628f, 0.40931869f, 0.02972522f, 
    -0.04097255f, 0.11492293f, 0.01771103f, -0.12300912f, -0.01050662f, -0.04567558f, -0.00922984f, -0.07811196f, 
    0.00681691f, -0.06011287f, -0.11559516f, -0.07234850f, -0.03905995f, 0.03972679f, -0.04701151f, 0.00261271f, 
    0.09581420f, -0.19284059f, -0.18739122f, -0.04448967f, -0.05889281f, 0.13016930f, -0.17100585f, -0.11990461f, 
    -0.35494989f, -0.16556840f, -0.03257298f, -0.02547190f, -0.01332105f, -0.04429468f, -0.06898059f, 0.05033388f, 
    -0.03551881f, 0.23382626f, -0.05608872f, 0.04263485f, -0.16964349f, -0.10774369f, 0.15796247f, -0.09899269f, 
    0.04306830f, -0.02524084f, 0.05223524f, 0.11499108f, 0.08151308f, 0.24408771f, 0.02258323f, 0.11615853f, 
    -0.11218398f, -0.07160413f, 0.00417590f, -0.04855885f, 0.04852486f, -0.04254663f, -0.07403356f, 0.15122856f, 
    0.26156673f, 0.32817930f, -0.05593850f, -0.03614170f, 0.19051953f, 0.14153445f, -0.07042950f, -0.03020271f, 
    0.05242806f, 0.25306845f, 0.04975576f, 0.01986267f, -0.10709362f, 0.01600590f, -0.01881050f, -0.10179185f, 
    -0.07246900f, 0.15750846f, -0.10728166f, 0.00252001f, -0.16344231f, -0.05999226f, 0.05092885f, -0.05964893f, 
    0.04056809f, -0.00495146f, -0.09465587f, -0.01226258f, 0.14032795f, 0.18738578f, -0.00595735f, -0.08914374f, 
    -0.28086308f, -0.29699507f, -0.02950473f, -0.04961480f, -0.02889916f, -0.16433164f, 0.01826490f, -0.13489412f, 
    0.31744957f, -0.10847004f, -0.16697629f, -0.06947909f, -0.36093554f, 0.08144987f, 0.09000812f, 0.04000539f, 
    -0.16641748f, -0.01984558f, -0.01468198f, -0.12908772f, 0.09581609f, -0.07081818f, -0.09135517f, 0.07773003f, 
    0.01895428f, 0.11491432f, -0.11941481f, -0.02137038f, 0.13205086f, -0.03630459f, 0.09238877f, 0.05855933f, 
    0.24279194f, 0.01212288f, 0.09419170f, 0.03821805f, -0.02914650f, 0.03833405f, 0.02747875f, 0.03087775f, 
    0.09276307f, 0.00970897f, 0.15910290f, 0.14715233f, 0.15839091f, -0.06095847f, -0.10070522f, -0.08695660f, 
    -0.02022910f, -0.12057208f, 0.13025521f, -0.14505848f, 0.06111059f, -0.08010109f, -0.19493587f, -0.24421334f, 
    -0.32963660f, -0.23079866f, -0.08152667f, -0.03240622f, 0.03545407f, 0.00161672f, -0.06827855f, 0.10313202f, 
    -0.11138611f, 0.10232650f, 0.00754312f, 0.20475805f, 0.46769398f, 0.32583916f, -0.07217182f, 0.26908988f, 
    0.13807246f, -0.07394768f, -0.08472760f, -0.02544979f, -0.01063887f, -0.16847987f, -0.00660001f, 0.07369938f, 
    0.05416850f, 0.01286514f, 0.13644156f, 0.13410698f, 0.12188662f, 0.10447884f, -0.06177791f, -0.04561312f, 
    0.04775500f, 0.10696758f, -0.01872775f, 0.17790900f, 0.02971665f, 0.12913468f, 0.10977291f, 0.02950405f, 
    -0.01009855f, -0.04764837f, 0.04487184f, 0.00154529f, 0.21850803f, 0.03569042f, 0.20457317f, 0.11856257f, 
    0.10809771f, 0.15016036f, -0.03174525f, -0.15644337f, -0.16658150f, 0.05679359f, -0.07765804f, -0.00225185f, 
    -0.08612856f, -0.08059390f, 0.08098330f, -0.06093795f, 0.14924225f, 0.25222397f, -0.04762669f, -0.03820917f, 
    -0.09454946f, -0.20938767f, -0.25867635f, -0.07165891f, -0.00471923f, -0.07139281f, 0.04557303f, 0.01540221f, 
    0.02327384f, 0.29238790f, 0.17552140f, -0.11529990f, 0.03629830f, 0.08123431f, 0.05720451f, 0.00237735f, 
    -0.02633639f, 0.12912573f, -0.03321484f, 0.11448643f, -0.03590466f, 0.06285521f, 0.07996821f, -0.01563718f, 
    -0.04189756f, -0.04326128f, -0.10425816f, -0.06451408f, 0.11276089f, -0.02409958f, 0.15593234f, 0.12277957f, 
    0.06568914f, 0.06333776f, -0.01053929f, -0.09766135f, 0.06671879f, -0.02363808f, -0.07971536f, 0.06921850f, 
    0.11925584f, 0.08612978f, 0.06192828f, 0.05011199f, 0.26262140f, -0.09868152f, 0.00891898f, -0.10871143f, 
    0.36773023f, 0.02550837f, -0.13033375f, -0.02650670f, -0.04690562f, -0.20076898f, 0.03456414f, 0.04898760f, 
    0.13153259f, 0.22135609f, -0.03927038f, -0.17808290f, -0.23276524f, -0.33971447f, 0.00556121f, 0.03422968f, 
    0.15293321f, -0.06285637f, -0.06637170f, 0.04246523f, 0.38504726f, 0.26430458f, 0.11985099f, -0.33775327f, 
    -0.08391894f, -0.02496947f, -0.09788626f, -0.14204600f, 0.04869020f, 0.15019843f, -0.05265440f, -0.23122182f, 
    0.06970950f, -0.18092701f, 0.09178327f, -0.03741038f, 0.16215074f, 0.03347826f, -0.28169188f, -0.14855078f, 
    -0.33129713f, 0.00287376f, -0.31058705f, 0.10159816f, -0.01874763f, -0.05657423f, -0.01760577f, 0.04479735f, 
    -0.26674390f, 0.00636459f, -0.02693539f, -0.07567427f, 0.07845001f, -0.00430013f, 0.09676141f, 0.02739027f, 
    0.02286182f, -0.08453703f, -0.15033501f, -0.00362753f, 0.07505453f, 0.04687366f, 0.04102089f, 0.21579914f, 
    0.18773602f, 0.05177865f, -0.05221193f, 0.02670541f, 0.04318492f, 0.02848404f, 0.04554605f, -0.03703747f, 
    0.06838536f, 0.06739286f, 0.09742828f, 0.10687955f, 0.10882955f, 0.09349278f, -0.02912877f, -0.02713876f, 
    -0.00847058f, -0.00672098f, 0.00850594f, -0.03416701f, 0.00203035f, -0.04800865f, 0.02176420f, -0.03207278f, 
    -0.05629963f, 0.03862933f, 0.03057946f, 0.02583721f, -0.02076137f, -0.05727912f, -0.02705151f, -0.02109499f, 
    -0.05844827f, 0.02550825f, 0.03222245f, -0.03885031f, 0.03161532f, 0.02436308f, -0.05969796f, -0.02439501f, 
    0.03661946f, -0.01579284f, 0.04399641f, 0.02276009f, -0.04609267f, -0.00247476f, 0.04948400f, 0.01552278f, 
    0.00943683f, 0.01623750f, -0.04820087f, -0.05643195f, 0.01296174f, 0.03667694f, -0.04257604f, -0.00714229f, 
    0.04129567f, 0.03547713f, -0.00695852f, 0.05740963f, -0.01944054f, -0.03118143f, 0.02276842f, 0.02613869f, 
    0.01498574f, -0.05177519f, 0.04218078f, 0.04100322f, 0.02064061f, 0.02076979f, 0.03630148f, 0.02651937f, 
    -0.01665962f, -0.02305033f, -0.04100841f, 0.00144165f, -0.04537367f, -0.02237731f, -0.04433034f, -0.00599835f, 
    -0.02163587f, 0.01618644f, -0.03293387f, -0.05239208f, -0.04077930f, -0.03301125f, 0.02756158f, 0.02841189f, 
    -0.05473205f, -0.04856707f, 0.05107517f, -0.03835272f, -0.01857123f, -0.01367578f, 0.03432677f, -0.02578560f, 
    0.02062005f, -0.05397959f, 0.01735311f, -0.02855166f, -0.03058428f, 0.02579944f, -0.04005405f, 0.01386749f, 
    0.01609848f, -0.01733403f, -0.01591777f, 0.03683345f, 0.02997229f, -0.05450360f, -0.00649534f, -0.02683541f, 
    0.04206141f, -0.03559351f, -0.02761595f, 0.00581644f, 0.01405142f, -0.05309174f, -0.00861361f, 0.00940523f, 
    -0.00864560f, -0.05961493f, -0.00225089f, -0.05181071f, 0.01914759f, -0.00583222f, 0.02291041f, 0.03814588f, 
    0.02590849f, 0.01343167f, 0.03577408f, -0.05443953f, -0.05104086f, 0.04187654f, -0.05741780f, -0.01279351f, 
    -0.03788773f, 0.01077945f, 0.03596812f, -0.02221277f, -0.03047792f, 0.02820913f, -0.02199975f, 0.03498929f, 
    -0.04256449f, 0.01854868f, -0.01326460f, -0.01965176f, -0.05403583f, 0.04941493f, -0.01354417f, -0.02935909f, 
    0.04609942f, 0.01780951f, -0.05895230f, 0.00802159f, 0.02914965f, -0.02973572f, 0.04015666f, -0.02394615f, 
    -0.01698271f, -0.03123777f, 0.04325465f, 0.01651840f, 0.03186257f, 0.04511944f, 0.01686685f, -0.04522051f, 
    -0.03573896f, -0.00222086f, -0.02637987f, 0.00798532f, -0.04597236f, 0.00747484f, -0.02958085f, 0.04383145f, 
    0.01595083f, -0.04728186f, 0.01483740f, 0.03070583f, -0.03883117f, 0.04017744f, -0.01842110f, -0.01241217f, 
    0.03333404f, 0.01814166f, -0.00805574f, -0.03409560f, -0.05546042f, 0.03938501f, -0.00938046f, -0.03856139f, 
    -0.01486126f, -0.01710964f, -0.01439504f, -0.05154499f, -0.04184693f, 0.04574630f, -0.03835302f, 0.00883438f, 
    0.01820497f, 0.05799390f, 0.00074535f, -0.02216580f, -0.01153510f, -0.02504093f, 0.05152022f, 0.05104557f, 
    -0.05977384f, -0.05035323f, 0.04371094f, -0.00062421f, -0.00159566f, -0.04908687f, -0.01531489f, 0.03661273f, 
    0.01117083f, 0.03465702f, 0.01155804f, 0.01422348f, -0.03670718f, -0.04773313f, -0.01826659f, -0.01501314f, 
    -0.01864100f, -0.02781001f, -0.05519492f, -0.00383696f, 0.02882830f, 0.02898979f, -0.04642280f, -0.02069682f, 
    -0.01026984f, 0.01160516f, 0.03712035f, 0.02399831f, -0.00486612f, 0.01103557f, 0.01703418f, -0.05551516f, 
    -0.01224576f, -0.00079523f, -0.02707379f, -0.00420482f, 0.05001730f, -0.02571779f, 0.01740552f, -0.03326610f, 
    -0.03475968f, -0.04819272f, -0.04936006f, -0.02481564f, -0.02747699f, 0.03864360f, 0.03490237f, 0.01670344f, 
    0.01661051f, 0.01483313f, 0.04795140f, 0.00841277f, -0.05207606f, 0.01990761f, 0.01496727f, 0.00222740f, 
    0.00223394f, 0.04701644f, -0.00753507f, 0.02550674f, -0.04844686f, 0.01138229f, -0.03415332f, 0.01237934f, 
    0.00750271f, -0.00825187f, 0.04432305f, -0.03078519f, -0.02984306f, 0.04256205f, -0.04909328f, -0.05407800f, 
    0.01443259f, 0.00370780f, 0.01177821f, -0.01995958f, -0.04965028f, 0.00842686f, 0.03635851f, -0.04976644f, 
    0.04800816f, -0.01020615f, 0.03516485f, 0.04255511f, -0.03361027f, -0.05189507f, -0.00258564f, 0.01818584f, 
    0.04189428f, -0.02392108f, 0.03858086f, -0.00238030f, -0.05350103f, 0.01128927f, -0.00358358f, -0.05758456f, 
    0.03028031f, -0.03450929f, -0.05794189f, -0.04990774f, 0.03709536f, 0.03071611f, -0.04584854f, -0.05137238f, 
    -0.05041842f, 0.03600245f, 0.02613955f, -0.05566965f, -0.04337049f, 0.01151641f, -0.03588170f, -0.04106655f, 
    -0.00355447f, -0.03420711f, -0.02125534f, -0.02563363f, -0.01198599f, -0.03681774f, 0.03111894f, -0.00303100f, 
    -0.04967981f, -0.05755959f, 0.00127657f, -0.04696433f, -0.02213859f, -0.05746175f, -0.02234786f, 0.00311146f, 
    -0.05255359f, -0.00280880f, -0.03698314f, 0.01600436f, -0.00195614f, -0.01011789f, -0.05918385f, 0.03752794f, 
    0.01355728f, -0.00873609f, 0.04256704f, -0.05735549f, 0.00654404f, 0.03648202f, -0.01303371f, 0.04160928f, 
    -0.03682391f, 0.03548134f, -0.01080389f, 0.03947729f, 0.02573860f, -0.00441404f, 0.00920337f, 0.01919493f, 
    0.02466718f, 0.01885976f, -0.01298989f, -0.05929846f, -0.00716529f, -0.00493644f, -0.02183456f, 0.03465886f, 
    0.01080057f, -0.06044929f, -0.01749440f, -0.03926049f, -0.02880141f, -0.05096282f, -0.01061417f, 0.02984795f, 
    -0.01883857f, -0.02068408f, 0.02713214f, -0.04556979f, 0.01324376f, -0.01031111f, -0.05096247f, -0.04895295f, 
    0.01270144f, -0.01031144f, -0.00533519f, 0.04027629f, -0.06135436f, -0.06172486f, -0.03151049f, -0.04349355f, 
    -0.03446780f, 0.04869370f, 0.04228029f, -0.05362329f, 0.02638494f, 0.04201166f, -0.03039559f, 0.02701587f, 
    -0.06108874f, -0.03510246f, -0.03896328f, 0.01609984f, -0.02577287f, -0.05281406f, 0.03592781f, -0.01498714f, 
    -0.01667123f, 0.02046577f, -0.06009566f, -0.02659718f, -0.01719025f, -0.01982786f, 0.00167031f, -0.04725937f, 
    -0.00574008f, -0.00348063f, 0.02761346f, -0.02149242f, -0.04169936f, -0.02988679f, 0.02710647f, -0.05075304f, 
    -0.04912365f, -0.03719371f, 0.00014475f, -0.04875644f, 0.04308113f, 0.00021786f, -0.01893782f, -0.00662721f, 
    -0.04592271f, 0.00682459f, -0.00209999f, 0.03653009f, -0.03656369f, -0.05899084f, 0.02321477f, -0.03671061f, 
    -0.02313780f, -0.04293013f, -0.05142465f, -0.05528972f, 0.04473378f, -0.00931033f, 0.03008251f, -0.01829929f, 
    0.02657104f, 0.02890763f, -0.04860147f, 0.04942209f, 0.02395422f, -0.02922399f, -0.01733328f, 0.00626036f, 
    0.02311041f, -0.05398417f, -0.02310745f, -0.04858205f, 0.03973749f, 0.03202930f, 0.01960657f, 0.00597110f, 
    -0.05234686f, -0.03087665f, -0.05984567f, 0.00205350f, -0.00722280f, -0.02277950f, 0.03588813f, 0.02074114f, 
    -0.00072727f, -0.00949168f, -0.01545413f, 0.02063760f, -0.03139427f, -0.01010345f, 0.01246107f, 0.04029967f, 
    -0.01886900f, 0.04698107f, 0.02992376f, 0.02822838f, -0.03401270f, 0.03630100f, -0.01371807f, -0.03097584f, 
    0.00651776f, -0.01202207f, -0.04947941f, -0.00769417f, -0.00112824f, 0.03561718f, -0.04384986f, -0.02533202f, 
    -0.05587133f, 0.02087759f, 0.03231765f, -0.04297697f, -0.00046139f, 0.00209595f, -0.00711776f, 0.01850026f, 
    -0.04688866f, -0.03180344f, -0.03096532f, 0.02106484f, 0.01925286f, -0.01351423f, -0.00716920f, -0.01751472f, 
    -0.03734310f, 0.02258440f, -0.01021987f, -0.05789890f, -0.05681272f, 0.03733453f, -0.05176670f, -0.03503227f, 
    -0.02738350f, -0.01337107f, -0.01664769f, -0.04897046f, -0.03747110f, -0.01889405f, 0.04750118f, -0.00728984f, 
    0.04958092f, -0.00965705f, 0.00581441f, -0.00651280f, 0.01484991f, -0.05407775f, -0.04520335f, -0.02930620f, 
    -0.06060741f, -0.04137437f, 0.02730599f, -0.05570460f, -0.03771260f, 0.01730579f, 0.03302786f, 0.04068251f, 
    0.00376044f, 0.01748937f, -0.02753540f, -0.00324459f, -0.03786159f, -0.00228846f, 0.02993060f, 0.04540378f, 
    0.04547126f, -0.02120040f, -0.03125208f, 0.04563550f, -0.01843792f, -0.03752824f, 0.03529042f, 0.03389971f, 
    -0.03368106f, -0.04546812f, 0.04444752f, -0.02529443f, 0.04243788f, -0.02961338f, 0.03645939f, -0.00067009f, 
    0.01171678f, 0.02443686f, -0.03393055f, -0.00403149f, -0.00927454f, 0.03915923f, 0.01908143f, 0.04649176f, 
    -0.03477464f, -0.01542307f, 0.03413401f, 0.01875556f, -0.00550336f, 0.03636957f, 0.01892434f, -0.01392996f, 
    0.01881838f, 0.00572845f, -0.04858546f, 0.00215933f, -0.02953656f, -0.05580381f, -0.05972826f, -0.00790808f, 
    -0.02654322f, -0.01990515f, -0.01958127f, -0.03438253f, -0.05959216f, 0.00372753f, -0.02268503f, 0.01137704f, 
    -0.05555211f, -0.03332432f, -0.02027274f, 0.01668641f, 0.02022432f, -0.04919927f, 0.05075704f, -0.00010496f, 
    0.04768004f, 0.04441907f, -0.05648251f, -0.05191366f, 0.04925366f, 0.02891888f, 0.02070204f, -0.04851064f, 
    -0.01409596f, -0.02184560f, 0.02584449f, -0.01327047f, -0.01086515f, -0.05099676f, 0.01180047f, -0.03910271f, 
    -0.05952020f, 0.04131750f, -0.00419028f, -0.05922839f, -0.00812873f, -0.05781471f, -0.05815018f, -0.00304417f, 
    -0.02530342f, 0.01490666f, -0.05868874f, 0.02749483f, -0.03105874f, -0.01832756f, 0.00941755f, -0.03634030f, 
    -0.04659784f, -0.00894633f, -0.02661599f, -0.00400109f, 0.00165555f, 0.01001863f, 0.01592531f, -0.02041366f, 
    0.00092149f, 0.03268080f, 0.01221143f, 0.03857732f, -0.01674520f, 0.00559512f, -0.03948755f, -0.05048241f, 
    -0.09071076f, -0.15519463f, -0.05687251f, -0.18017560f, -0.18692054f, 0.05085116f, 0.09592812f, 0.23718823f, 
    0.16435605f, 0.25489381f, 0.06380390f, -0.06675335f, 0.12021161f, -0.03842764f, 0.09549440f, 0.01474419f, 
    0.11133492f, 0.20462708f, -0.12833399f, 0.10909928f, -0.21675459f, 0.10563675f, -0.09599870f, -0.02281433f, 
    -0.12734646f, 0.03705781f, -0.07389555f, -0.05324541f, -0.06254634f, -0.08303893f, 0.04200940f, 0.12550257f, 
    0.00682343f, 0.11543389f, -0.04373144f, -0.08576415f, 0.02896725f, -0.07024097f, 0.09056961f, -0.05189253f, 
    -0.36917886f, -0.34033209f, -0.53750938f, 0.02659053f, -0.18436868f, -0.17399752f, -0.02354565f, -0.10065947f, 
    -0.04986387f, -0.08822256f, -0.11107124f, -0.03035808f, -0.05828084f, -0.03129521f, 0.07884379f, 0.05155035f, 
    0.16312359f, 0.05573332f, -0.05729473f, -0.05164396f, -0.29132313f, 0.11584462f, 0.06645694f, 0.21027377f, 
    -0.06176334f, -0.09914099f, -0.08371916f, -0.08034126f, -0.26838630f, -0.18775900f, 0.26305580f, 0.08936347f, 
    -0.03357617f, 0.13091582f, 0.03583389f, 0.12243491f, -0.07663306f, -0.09024950f, 0.03458446f, 0.06221078f, 
    0.15138434f, -0.28065816f, 0.32139936f, -0.12334123f, -0.05879418f, 0.10703593f, 0.13318649f, 0.15214899f, 
    0.26924926f, 0.21055034f, 0.18042526f, -0.05087796f, 0.13169038f, -0.17442034f, 0.05346217f, 0.10323095f, 
    0.11803264f, 0.20849535f, 0.01551114f, 0.07590335f, 0.02417624f, 0.17093410f, 0.07098962f, -0.02879357f, 
    0.00216036f, -0.11398792f, -0.14177775f, 0.01874112f, -0.07856254f, 0.00668055f, -0.12209553f, -0.08929534f, 
    -0.13865443f, -0.05271184f, -0.15445010f, 0.01652285f, 0.06977890f, -0.16398565f, 0.08757923f, 0.07376920f, 
    -0.20493124f, -0.18432759f, -0.18562932f, 0.03702854f, -0.30533758f, -0.08164320f, -0.16909519f, 0.08704675f, 
    0.01204416f, 0.03731366f, 0.05214852f, -0.01587394f, -0.00085034f, -0.03633898f, 0.14953491f, 0.04596040f, 
    0.04095307f, 0.26455858f, 0.12890051f, 0.12145664f, 0.47303122f, -0.24509749f, -0.33283827f, -0.16786194f, 
    -0.08275639f, 0.10972206f, 0.24511369f, -0.00375435f, -0.24868326f, -0.05731840f, 0.01072795f, -0.10677461f, 
    -0.06781496f, -0.03236410f, -0.06047636f, 0.15689294f, 0.07456822f, 0.06599812f, -0.14663099f, -0.16470474f, 
    0.47546136f, 0.08329564f, 0.00054010f, -0.03550721f, 0.33218971f, -0.02678567f, 0.13897347f, -0.11457419f, 
    0.13382246f, 0.07135581f, -0.08272001f, 0.03346161f, 0.17207010f, -0.09121319f, 0.07042611f, -0.01902020f, 
    0.12433535f, -0.01811174f, 0.30482256f, -0.03256918f, -0.14084841f, 0.07934633f, 0.21352153f, 0.02737539f, 
    -0.02736820f, -0.03711364f, -0.02612511f, -0.06574583f, -0.11996423f, -0.22193487f, 0.12537168f, 0.10655930f, 
    -0.02800660f, 0.18083292f, 0.14281237f, 0.00941790f, -0.03078423f, -0.09522942f, 0.03745651f, 0.07071024f, 
    0.07280441f, -0.19354351f, -0.28029186f, -0.03472160f, -0.00237448f, -0.02536359f, -0.14170724f, -0.06106423f, 
    0.02490047f, -0.04323043f, -0.10299863f, -0.17859726f, -0.16004834f, 0.05070664f, 0.04616736f, -0.06319033f, 
    0.10717006f, 0.01734927f, 0.30152258f, -0.05001006f, -0.10725989f, 0.24278370f, -0.18151058f, -0.32128599f, 
    -0.09024490f, 0.09358957f, -0.09956989f, 0.15373343f, -0.02241313f, 0.11084180f, -0.04648947f, -0.07116967f, 
    -0.06028203f, 0.00357855f, -0.03169889f, 0.01184115f, 0.06223644f, -0.08921064f, 0.05921203f, 0.11939395f, 
    0.22894657f, -0.04191563f, 0.26692373f, 0.07455547f, 0.06606333f, -0.12926072f, -0.16296972f, 0.00663314f, 
    -0.05196752f, -0.11636407f, 0.03214111f, 0.06519573f, 0.12590796f, 0.17146368f, -0.01464396f, 0.02982810f, 
    0.01044008f, -0.01331349f, 0.08751054f, 0.07634125f, 0.48673236f, 0.03747128f, 0.21206453f, 0.34741592f, 
    0.42974183f, -0.04015384f, -0.14036791f, -0.04999677f, -0.17038569f, -0.12667871f, 0.18397196f, 0.14350203f, 
    0.17905886f, 0.01678192f, 0.03750372f, 0.25000122f, 0.07799767f, -0.15092728f, 0.08814241f, 0.18976489f, 
    -0.02821808f, -0.12767281f, -0.17389506f, -0.19931878f, 0.04474872f, 0.07826971f, 0.08798240f, -0.24941435f, 
    0.14442748f, 0.01468788f, 0.20751131f, 0.03135191f, 0.15496074f, -0.05942448f, -0.14306107f, 0.19535738f, 
    0.09006941f, -0.07285824f, 0.12216993f, 0.06766952f, 0.28409126f, 0.13918492f, 0.08150939f, -0.13856021f, 
    0.03145717f, -0.13697940f, -0.01840268f, -0.03978281f, -0.17969453f, -0.01694598f, -0.15004262f, -0.06883504f, 
    -0.07593399f, -0.05112957f, -0.02071854f, -0.00332396f, 0.04894531f, -0.09687546f, 0.08151282f, 0.10629547f, 
    -0.03058384f, 0.03771723f, 0.22969133f, 0.04110640f, 0.05922778f, 0.15130074f, 0.17434254f, 0.02102682f, 
    0.07317284f, -0.21002366f, 0.07191151f, 0.02181137f, 0.01139221f, 0.02008085f, 0.00895631f, 0.06267820f, 
    -0.03693851f, 0.03963124f, 0.01875452f, -0.02558280f, -0.06742804f, -0.10984524f, -0.19439818f, 0.23927993f, 
    0.21881351f, -0.08277880f, -0.18172407f, 0.11602618f, -0.32047442f, 0.03992882f, 0.06607689f, 0.02519675f, 
    0.00757763f, 0.02908309f, 0.03998913f, 0.03389153f, -0.02751001f, -0.08328727f, -0.25044838f, 0.07786017f, 
    0.26523542f, 0.24680936f, 0.20799087f, -0.00956705f, 0.14317505f, 0.00566179f, 0.16690053f, 0.21171415f, 
    0.23926671f, 0.12842715f, 0.10437934f, -0.01265637f, -0.02045691f, 0.02032262f, -0.04990131f, 0.07650732f, 
    0.02304858f, 0.00203414f, -0.17590265f, 0.00725877f, -0.00428496f, -0.03965009f, -0.23082449f, 0.02440938f, 
    0.02469519f, -0.02984292f, -0.14541855f, -0.22625673f, -0.05184162f, -0.15702251f, -0.06473108f, -0.02858880f, 
    0.17000321f, 0.00165661f, -0.15664348f, 0.04801303f, 0.11727433f, 0.10540903f, -0.15157573f, 0.07938886f, 
    0.07448296f, 0.26520941f, 0.18710214f, -0.08025669f, 0.16988292f, -0.00904286f, -0.05028136f, 0.03743147f, 
    -0.01050973f, -0.06575289f, 0.03704704f, 0.00216767f, 0.06363983f, 0.07432444f, 0.15151072f, 0.08444169f, 
    0.01201104f, -0.18993415f, -0.00780643f, -0.03828366f, -0.45426619f, -0.46727681f, -0.36484313f, -0.12148376f, 
    0.24642712f, 0.09027000f, -0.18196200f, -0.18606789f, -0.22033206f, -0.08671527f, -0.03134205f, 0.05628671f, 
    0.04730053f, -0.11103050f, 0.07201509f, 0.03961660f, 0.00520959f, -0.05683569f, 0.00956653f, 0.05042411f, 
    0.00899275f, 0.07783914f, 0.31440189f, 0.13995625f, 0.11352979f, 0.09895589f, 0.09516240f, 0.15142401f, 
    0.18732032f, -0.01358790f, 0.02950524f, -0.06402212f, 0.08214852f, 0.08849911f, -0.06267529f, 0.05403275f, 
    0.05744953f, -0.00581751f, -0.24375883f, 0.04768033f, -0.72717029f, -0.16825092f, -0.08144724f, -0.08246251f, 
    0.15830334f, -0.02055806f, 0.06159756f, -0.29594144f, -0.07417998f, 0.10479884f, -0.04213985f, -0.15015011f, 
    0.06231955f, -0.19286659f, 0.04403668f, -0.06396978f, 0.01169189f, 0.07347043f, 0.12839074f, 0.05285753f, 
    -0.32074469f, -0.28126261f, -0.11044477f, -0.06654394f, -0.11669414f, 0.03738707f, 0.00815566f, -0.10336442f, 
    -0.13524342f, 0.00880297f, 0.13920726f, -0.03578190f, -0.24542932f, 0.08300261f, -0.09614347f, 0.14965893f, 
    0.11178609f, 0.02035709f, -0.06487206f, 0.12477893f, 0.04495036f, 0.00776944f, -0.05994852f, -0.10768361f, 
    0.11244509f, 0.07603348f, -0.16672447f, -0.06527178f, -0.08162902f, -0.17565548f, 0.04825321f, 0.08688406f, 
    0.16923800f, 0.04107114f, 0.06160481f, 0.18507427f, 0.11656927f, 0.06804418f, -0.13225684f, -0.10451042f, 
    -0.18628952f, 0.14046496f, 0.11691086f, -0.22156434f, -0.30102611f, -0.05434194f, 0.20534916f, -0.23593923f, 
    -0.05664461f, 0.15343104f, 0.11433032f, -0.11259680f, -0.04207680f, 0.04235603f, -0.09453681f, 0.06061018f, 
    -0.14929081f, -0.00870679f, -0.18999481f, -0.16552365f, -0.48507804f, -0.35408780f, -0.10327473f, -0.14835821f, 
    0.18526527f, 0.04361838f, 0.00657534f, -0.21972306f, -0.32545534f, 0.16431348f, 0.00329653f, -0.10002907f, 
    -0.01296993f, -0.07118525f, 0.09220840f, -0.03132727f, 0.13842781f, -0.09984039f, 0.08544069f, -0.03251101f, 
    0.43298158f, 0.35266492f, 0.05500921f, 0.19199575f, 0.03858994f, 0.04825264f, -0.10512652f, 0.17155652f, 
    -0.06069097f, -0.04178650f, 0.04496347f, 0.10242743f, 0.07573937f, -0.17982012f, 0.13668485f, 0.20105428f, 
    0.09382226f, 0.17742346f, 0.07400592f, -0.02577066f, 0.40460640f, 0.28802133f, 0.00518891f, 0.13181777f, 
    -0.22025751f, 0.00072573f, -0.06677932f, -0.02502915f, -0.03777225f, 0.02369763f, -0.00078601f, 0.12490503f, 
    -0.04733809f, -0.07445077f, 0.08549973f, -0.00234418f, 0.01979615f, 0.12052747f, 0.19165580f, 0.10663395f, 
    -0.04109699f, 0.29923722f, 0.34943312f, 0.06956778f, 0.13676144f, 0.09857001f, 0.10868245f, 0.05228762f, 
    0.25990206f, -0.00486239f, 0.05168675f, 0.00773578f, 0.01835386f, -0.05962304f, 0.13310969f, 0.05136273f, 
    0.10844021f, -0.04383567f, -0.08150446f, 0.12293208f, -0.63193166f, -0.29419485f, -0.34159112f, 0.07260676f, 
    0.20146953f, 0.01998888f, -0.10297888f, -0.04792203f, -0.14555091f, -0.04853579f, 0.11099657f, 0.00398440f, 
    -0.12364474f, 0.12950754f, 0.00100882f, 0.12742530f, -0.02244441f, 0.14610744f, 0.10985136f, -0.05527686f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.04121374f, -0.00585573f, 0.13008711f, -0.00286930f, 0.01217049f, 0.02066965f, -0.00762049f, 0.38240600f, 
    0.08489800f, -0.02466982f, 0.09442551f, 0.05526735f, 0.04523331f, 0.01255389f, -0.11143155f, 0.04245296f, 
    0.11616931f, 0.07329697f, 0.02494739f, 0.14831944f, -0.05038755f, -0.03658025f, 0.14990400f, 0.23111638f, 
    -0.21512544f, 0.15963891f, 0.05804130f, 0.10410495f, -0.02516573f, -0.03261574f, 0.23953038f, -0.05654901f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.12274436f, 0.08665540f, 0.64995539f, 0.19275270f, 0.08117883f, 0.17243735f, -0.06258806f, 0.02737878f, 
    -0.37784871f, 0.22362810f, 0.40764681f, -0.03984970f, -0.10750525f, 0.06739694f, 0.08961876f, -0.04710137f, 
    0.38006705f, -0.07325281f, -0.33818552f, -0.28988841f, -0.11176459f, -0.00410242f, 0.10580028f, -0.56307131f, 
    0.71850938f, 0.14917868f, -0.21469630f, 0.09548587f, -0.07547383f, -0.16455837f, -0.00996126f, 0.25020948f, 
    0.56067741f, 0.29832628f, -0.04289980f, 0.35945883f, -0.03364564f, 0.14097925f, 0.02027782f, 0.08944764f, 
    0.02829220f, -0.13881612f, 0.18957502f, 0.09522328f, 0.13629389f, 0.22196472f, -0.20359360f, 0.10043050f, 
    0.10767308f, -0.00582005f, 0.24759392f, -0.14222477f, 0.05486349f, -0.26857659f, 0.10087220f, 0.46590868f, 
    -0.47411054f, 0.03872191f, -0.10709068f, -0.05529945f, 0.02895446f, -0.16011760f, 0.10459711f, -0.13781689f, 
    -0.14245549f, 0.04302992f, 0.06577691f, -0.05795506f, -0.12259406f, -0.10412409f, -0.08393445f, -0.13046139f, 
    -0.04271967f, -0.15655436f, -0.07162137f, -0.00247921f, -0.22068092f, -0.03158391f, 0.03279930f, 0.04091951f, 
    -0.12607229f, -0.09561022f, 0.03666900f, -0.12989624f, 0.02101870f, -0.25962099f, 0.15395921f, -0.02907292f, 
    -0.15874220f, 0.05622622f, -0.19082174f, -0.00831320f, -0.08720759f, -0.11964700f, -0.00720749f, 0.16524640f, 
    -0.35099882f, 0.08086891f, 0.15458657f, -0.05217198f, -0.10445110f, 0.06054249f, -0.00567727f, 0.41468400f, 
    -0.22597593f, -0.13172024f, -0.88573158f, 0.14139530f, -0.05768194f, -0.18041849f, -0.17199782f, 0.14889653f, 
    -0.04400306f, -0.19839628f, 0.02433767f, 0.43056476f, -0.10920084f, -0.24589734f, -0.05709302f, 0.23145713f, 
    0.43927711f, 0.38106042f, 0.10944951f, 0.20140930f, -0.09921551f, 0.00457150f, 0.05115083f, -0.49213946f, 
    0.68612659f, -0.37236094f, -0.20694877f, 0.39624381f, 0.10845916f, 0.17043501f, -0.15359676f, 0.15227139f, 
    0.04876887f, -0.08433478f, 0.24360539f, 0.16153090f, -0.19287835f, -0.26071903f, 0.23525992f, -0.07335600f, 
    -0.42702976f, -0.06911706f, -0.01673788f, -0.11782619f, 0.06431355f, -0.20708106f, 0.23975477f, -0.16849908f, 
    0.60720521f, 0.07335713f, 0.14715360f, -0.40373841f, 0.05166762f, -0.14384057f, -0.16734724f, 0.28549841f, 
    -0.74394739f, -0.10830063f, 0.22412886f, -0.54692847f, -0.10573825f, 0.03196558f, 0.06351089f, 0.34650430f, 
    0.14329740f, 0.13051616f, 0.09829908f, 0.11118386f, 0.06859658f, -0.10380473f, 0.23436926f, -0.06903075f, 
    0.08276116f, -0.11452098f, 0.03479103f, 0.40424180f, -0.00918039f, 0.22982335f, -0.08985693f, 0.15242161f, 
    -0.34630200f, -0.21897459f, 0.03601543f, 0.06670462f, -0.04413843f, -0.12388866f, 0.17536223f, 0.16071899f, 
    -0.45489797f, -0.20927428f, 0.10803781f, -0.21553028f, -0.15527016f, 0.08796630f, -0.12775698f, -0.07660253f, 
    0.09429913f, 0.29465741f, -0.11000942f, -0.08338311f, 0.21274124f, -0.16169278f, 0.24663752f, 0.11113857f, 
    0.09962856f, 0.17454079f, -0.36906594f, 0.43116885f, -0.12779844f, -0.20068114f, -0.06385477f, -0.05042413f, 
    0.21214259f, 0.15848459f, 0.22968075f, 0.00256577f, 0.01055814f, -0.01646676f, -0.11344837f, 0.07402164f, 
    0.01094784f, -0.40182149f, 0.10781300f, 0.32584006f, -0.12821035f, 0.03939824f, 0.00114281f, 0.22160406f, 
    0.21107443f, 0.24416724f, 0.00131003f, -0.05512341f, 0.30682424f, -0.36892617f, 0.05142551f, -0.05199645f, 
    -0.14539480f, -0.07140859f, -0.15885575f, 0.24730290f, -0.15166084f, 0.04497000f, -0.21081191f, -0.10352521f, 
    0.21567100f, -0.13102861f, 0.20285438f, -0.11739735f, -0.14986667f, 0.03035400f, -0.01324403f, -0.10839464f, 
    -0.09332778f, 0.07138650f, 0.07029439f, 0.18181202f, 0.03717275f, 0.13728821f, -0.07950944f, 0.19713967f, 
    -0.22323325f, -0.26148933f, -0.30932701f, 0.11391073f, 0.22007141f, -0.08091736f, -0.31987372f, 0.06939235f, 
    0.22169839f, 0.15105398f, 0.32261664f, -0.18125513f, -0.09966641f, 0.04142327f, -0.00297160f, 0.04540673f, 
    0.53209102f, 0.35791972f, -0.33570805f, 0.05364817f, 0.04764586f, -0.16676009f, 0.21192990f, -0.31802452f, 
    0.25346509f, 0.32033634f, -0.42156145f, -0.25807649f, -0.16161904f, 0.22957303f, -0.15641041f, -0.06628353f, 
    0.07902021f, 0.33296230f, 0.10680719f, -0.24984597f, 0.12395871f, 0.06020873f, 0.25293010f, 0.07088870f, 
    -0.00876993f, 0.33168173f, 0.17814419f, -0.11129110f, -0.16046409f, 0.05292803f, 0.16181165f, 0.28691688f, 
    -0.07445485f, -0.12535913f, -0.38984597f, -0.01206262f, -0.00238853f, 0.11612745f, -0.30193326f, 0.26973623f, 
    -0.00695281f, 0.03924640f, 0.61084759f, 0.05081452f, -0.04480031f, -0.19605975f, -0.17639124f, -0.25442341f, 
    0.18250978f, 0.18002845f, 0.19494793f, 0.11048668f, -0.03993846f, 0.00678037f, 0.02334576f, -0.07677063f, 
    0.10972059f, -0.00511031f, 0.08706900f, -0.08821414f, 0.16793603f, 0.32439232f, 0.28230831f, -0.43678683f, 
    0.34313536f, -0.27292103f, 0.36560851f, 0.06284433f, 0.04839507f, 0.16558343f, -0.10848214f, -0.00608227f, 
    -0.23388670f, -0.64535570f, -0.01774251f, 0.21966685f, -0.06894398f, 0.00249729f, -0.00185593f, 0.20932619f, 
    0.01486026f, 0.06453658f, -0.32225874f, 0.05012446f, 0.32758075f, -0.55389768f, 0.30737820f, -0.15689787f, 
    0.26390272f, 0.12296247f, 0.07512060f, 0.30563295f, -0.04492202f, 0.04393999f, -0.37450969f, -0.04892719f, 
    0.54116160f, 0.25984794f, 0.30783290f, -0.20663026f, -0.01389975f, 0.14325683f, -0.10285881f, -0.38585669f, 
    -0.51157051f, 0.26482520f, 0.05305051f, -0.37327972f, 0.02469283f, -0.03881439f, 0.11088681f, 0.01852565f, 
    -0.09639511f, 0.36936525f, 0.01430666f, -0.38148341f, 0.06803307f, 0.18476380f, -0.02998407f, 0.15370595f, 
    0.25574240f, 0.15052429f, -0.07317711f, 0.19481944f, 0.08154736f, 0.12643114f, 0.18888745f, 0.28658986f, 
    -0.18913129f, 0.02423265f, -0.17147581f, -0.27341944f, 0.00489643f, 0.03914801f, -0.19573604f, 0.22481363f, 
    -0.40630478f, 0.20263866f, 0.41722769f, -0.26857540f, 0.12306043f, 0.18627560f, 0.09717049f, 0.43834513f, 
    -0.00856634f, -0.02259389f, 0.03848724f, -0.01201500f, -0.01420713f, 0.19158950f, 0.02679838f, -0.14676663f, 
    0.10189635f, -0.16376053f, -0.02520690f, -0.10868274f, -0.07199422f, 0.20724021f, 0.17319061f, 0.17313263f, 
    -0.43930775f, 0.22291563f, 0.04690142f, -0.03793969f, 0.08005262f, -0.08514890f, 0.16790235f, -0.15309834f, 
    -0.17627253f, 0.04344010f, -0.04524396f, 0.05367056f, 0.14993270f, -0.08380722f, -0.10798355f, -0.12562482f, 
    0.01653718f, 0.12244029f, -0.15627781f, -0.00787487f, -0.14063530f, -0.11613438f, -0.08504787f, 0.14942865f, 
    -0.02706662f, -0.09254110f, 0.04143161f, -0.04360826f, -0.07651476f, 0.00980954f, -0.01767229f, 0.11592927f, 
    -0.04292789f, -0.09514295f, -0.18566050f, -0.19556485f, 0.08371186f, -0.15841314f, 0.03048246f, -0.01036927f, 
    0.05332630f, 0.10072801f, 0.04472630f, 0.11685881f, -0.03508350f, 0.12806217f, 0.12709624f, 0.05104353f, 
    -0.08547911f, -0.16737004f, -0.24451552f, 0.04859404f, -0.04645815f, 0.01842565f, 0.15089034f, -0.08119917f, 
    -0.14287856f, -0.26306644f, -0.29636517f, -0.08303846f, 0.00759901f, -0.09230406f, -0.17933768f, -0.24829350f, 
    0.00981449f, 0.13102624f, 0.12205051f, -0.16032174f, -0.04272401f, -0.01645895f, -0.02418208f, 0.01228510f, 
    -0.17340480f, -0.26687279f, -0.31714556f, -0.09871107f, -0.11240367f, 0.10142148f, 0.12042196f, -0.05352104f, 
    -0.07426552f, 0.24751976f, -0.15074867f, 0.19904490f, 0.27716640f, -0.08353276f, 0.33580235f, -0.03562785f, 
    -0.31120864f, -0.23675649f, -0.22431836f, 0.21136010f, 0.04400852f, -0.07455979f, 0.13083901f, 0.34644601f, 
    -0.21267904f, 0.03907738f, 0.20927493f, -0.57272035f, 0.11306410f, 0.08637882f, 0.26755798f, 0.01641476f, 
    -0.24155243f, -0.18381198f, 0.45210817f, 0.18071413f, -0.11688368f, 0.13805318f, -0.14182113f, 0.20634104f, 
    0.21204305f, -0.18583435f, 0.05170779f, 0.04589524f, 0.24575165f, -0.11990914f, -0.06167680f, -0.12944651f, 
    0.20456490f, 0.20768601f, -0.04608154f, -0.05832924f, 0.12894894f, -0.10107920f, 0.21870740f, 0.18784581f, 
    -0.35449600f, 0.38792580f, -0.15790217f, -0.27595791f, 0.02124733f, -0.05381039f, 0.31789950f, 0.01715279f, 
    -0.23441266f, -0.07428186f, 0.68022680f, 0.11326006f, 0.03165953f, 0.04653345f, -0.10531648f, 0.22817671f, 
    -0.26865408f, 0.02521895f, 0.25463885f, -0.09176284f, -0.04838184f, -0.06204804f, -0.39447397f, 0.08877601f, 
    0.20314161f, 0.15662469f, -0.07864621f, 0.19634123f, 0.01485431f, 0.20048572f, 0.33630016f, 0.02337385f, 
    -0.18138060f, 0.09506272f, 0.14768372f, 0.07760005f, 0.12659562f, -0.02610468f, 0.31791559f, 0.02143151f, 
    0.07529761f, 0.01961004f, 0.15529791f, -0.07876239f, -0.11930709f, 0.27077249f, -0.18150195f, 0.11883544f, 
    -0.04356697f, 0.20907094f, 0.31423995f, -0.29980227f, -0.15336393f, -0.14047930f, -0.01282100f, 0.15077370f, 
    0.50391716f, 0.03664702f, 0.14485349f, 0.14621624f, 0.02353234f, 0.18654127f, 0.35238025f, 0.14879087f, 
    0.08625001f, 0.19162191f, -0.22999863f, -0.03311599f, -0.08024136f, -0.09024984f, -0.26337352f, 0.26476666f, 
    0.44902906f, -0.34781164f, 0.28364810f, 0.58153743f, -0.08091745f, 0.31318599f, 0.08604885f, -0.19234012f, 
    0.01762409f, -0.03488988f, -0.02536977f, 0.17037483f, 0.08558191f, -0.10811242f, -0.02490112f, 0.17097943f, 
    -0.29083493f, -0.05522740f, 0.02677351f, -0.11963926f, -0.16197026f, -0.10417789f, 0.16931787f, 0.17420955f, 
    0.13173568f, 0.05027511f, 0.38065961f, -0.06852727f, -0.02762347f, -0.16934386f, -0.21073428f, 0.04294647f, 
    0.14311774f, -0.16329117f, -0.00096901f, 0.45346615f, -0.15763558f, 0.15604366f, 0.15056305f, 0.26876780f, 
    -0.19713350f, -0.18547201f, -0.10153040f, 0.36671951f, -0.13097005f, -0.08194564f, -0.29178593f, -0.03893895f, 
    -0.21896027f, -0.19996358f, 0.06719102f, -0.07838877f, 0.09459437f, -0.18442875f, 0.39431286f, -0.19201390f, 
    -0.29094893f, 0.20336506f, 0.23233002f, -0.31480634f, 0.01526332f, -0.01135192f, 0.45612481f, -0.16991442f, 
    0.10738461f, 0.29123095f, -0.17096360f, 0.33458668f, 0.03335460f, -0.04803373f, 0.14353362f, -0.02520415f, 
    0.05109169f, 0.12067114f, -0.14711906f, -0.17377524f, 0.04781765f, -0.06349075f, 0.11445176f, 0.04000815f, 
    0.38226011f, 0.12177520f, 0.23778379f, -0.23854935f, -0.05165431f, -0.00207519f, 0.37095746f, -0.16512161f, 
    0.35435137f, 0.24429987f, -0.45525563f, -0.13628277f, 0.12410290f, -0.10269530f, -0.08885203f, 0.19711909f, 
    0.03010636f, -0.18940704f, -0.58131284f, -0.18086897f, -0.09244765f, 0.07526299f, -0.00932403f, 0.06131328f, 
    -0.09633722f, 0.11695233f, 0.05172359f, 0.25628567f, 0.26831597f, 0.12346768f, 0.21423765f, 0.18222387f, 
    -0.29612213f, -0.38943407f, 0.07444905f, 0.03113568f, -0.05018014f, 0.03522937f, -0.32737741f, 0.15656035f, 
    0.31054467f, -0.05249019f, -0.09888729f, -0.03493953f, 0.13222297f, 0.04290675f, -0.10908145f, 0.12644678f, 
    -0.22311120f, 0.22936632f, -0.45346436f, -0.25577417f, 0.04022805f, 0.22937156f, 0.02282226f, 0.00809933f, 
    -0.36446363f, 0.28261474f, -0.00225372f, 0.22274244f, 0.01069712f, 0.27760646f, 0.40421668f, -0.05726461f, 
    0.19403481f, -0.29759663f, -0.21341223f, -0.16109365f, -0.12422321f, 0.01616951f, -0.08079720f, 0.08762243f, 
    0.19389001f, 0.20976181f, -0.12674254f, -0.20225768f, -0.06054907f, -0.08334506f, 0.26204354f, -0.03415078f, 
    0.34946182f, -0.04234546f, -0.28833473f, 0.40633476f, 0.05845860f, -0.04366738f, 0.05086113f, -0.14403720f, 
    0.51109689f, 0.07937682f, -0.01797301f, -0.16821419f, 0.23959534f, -0.18107376f, 0.02316217f, 0.06546065f, 
    -0.41539299f, 0.16407719f, -0.23364785f, 0.25101557f, -0.07943752f, -0.36137432f, 0.30869275f, 0.36282662f, 
    -0.51941484f, -0.03986235f, -0.02228687f, -0.09569124f, -0.02013357f, -0.12689787f, 0.31829080f, 0.21377702f, 
    0.46971953f, 0.28495675f, -0.66541582f, -0.09684305f, 0.17032194f, -0.00285034f, 0.00336678f, -0.02577766f, 
    0.09729084f, -0.09033202f, -0.14939804f, -0.13742343f, 0.26091927f, -0.12689690f, 0.31750226f, 0.09562390f, 
    -0.21020216f, -0.12288816f, 0.13172284f, -0.01181817f, -0.01422080f, 0.05838167f, -0.20549759f, 0.32621983f, 
    -0.24313706f, 0.02460193f, 0.06844188f, 0.10067097f, 0.05517393f, 0.13626601f, 0.00754679f, 0.26685762f, 
    0.20926206f, -0.14698911f, -0.37730503f, 0.29496673f, 0.10942607f, -0.20685543f, -0.05500241f, 0.17306702f, 
    0.07848820f, -0.28948903f, -0.33369568f, -0.04647560f, 0.13542177f, -0.14587072f, -0.06549733f, 0.06936329f, 
    0.14244847f, 0.33975765f, 0.29735982f, 0.11495813f, -0.13478817f, 0.10740775f, 0.00743665f, 0.48344994f, 
    0.04985704f, 0.13731526f, -0.11930101f, -0.07917495f, -0.07343280f, 0.06107963f, -0.02650131f, -0.28154776f, 
    0.27013376f, 0.18727444f, -0.26583093f, -0.27852464f, 0.16351119f, 0.15279132f, 0.02007039f, 0.29590356f, 
    0.19349922f, -0.14188865f, 0.18827444f, -0.15031263f, -0.02636270f, -0.32963529f, 0.29512450f, 0.12652069f, 
    0.02135571f, 0.10512418f, 0.16573162f, 0.45229512f, -0.12384267f, 0.13864495f, -0.25268811f, 0.56212223f, 
    -0.25937095f, -0.19484568f, 0.23573816f, 0.13958916f, 0.07621326f, 0.15165864f, 0.03107341f, 0.10455647f, 
    0.47411522f, 0.31083506f, -0.44863790f, 0.12516969f, 0.00985892f, 0.23588105f, -0.00427368f, 0.14197753f, 
    0.10035220f, 0.13358225f, -0.00032332f, -0.21568005f, 0.30925605f, 0.04504950f, 0.36852252f, 0.03586012f, 
    0.01851291f, -0.14174339f, -0.09011743f, -0.04697310f, 0.14829333f, -0.40434915f, -0.50851852f, -0.17423205f, 
    0.52973497f, 0.00841326f, 0.00366371f, 0.05646095f, 0.05647225f, -0.11734509f, -0.04943290f, -0.16927706f, 
    0.39507577f, 0.23281583f, 0.51522696f, -0.18989736f, 0.11506055f, 0.36113369f, 0.11941582f, 0.04466991f, 
    -0.20723294f, 0.04543425f, 0.47746038f, 0.32071990f, -0.14399979f, 0.34539092f, 0.03541192f, -0.08893338f, 
    0.21116601f, -0.05754659f, -0.01744158f, -0.33758554f, -0.02134246f, -0.12912227f, 0.25057489f, -0.03777698f, 
    0.01864294f, -0.05057137f, 0.06709398f, 0.04013920f, -0.04901440f, -0.16513291f, -0.07602452f, 0.25515777f, 
    -0.04702536f, -0.17314409f, 0.12814763f, 0.03585060f, 0.03210834f, 0.17550024f, 0.15749401f, 0.10103086f, 
    0.14506237f, 0.19563954f, -0.04084135f, -0.06597684f, 0.17728682f, 0.29889318f, 0.01585387f, -0.14753847f, 
    -0.04765270f, 0.13731299f, -0.32966074f, 0.10636130f, -0.07005645f, -0.39764199f, 0.37192979f, 0.06128902f, 
    -0.39958051f, 0.16805232f, -0.28084293f, -0.25873923f, 0.04620774f, -0.15827903f, 0.17464630f, -0.03736111f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.05448790f, 0.33262330f, 0.10414501f, 0.28979126f, 0.03584524f, 0.10779443f, 0.06830088f, 0.18903394f, 
    0.16160886f, -0.02744191f, -0.11627860f, -0.14051768f, 0.15143019f, 0.19613001f, -0.16332234f, -0.17392914f, 
    0.16056564f, 0.21096507f, 0.09076048f, -0.04203202f, 0.05617630f, 0.11873592f, 0.01311898f, -0.06721382f, 
    0.03987106f, 0.03233404f, -0.08135784f, -0.06945578f, 0.21027559f, -0.08094998f, -0.02292565f, -0.03947591f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.22961088f, -0.44993258f, -0.09948209f, -0.68941414f, 0.00416567f, -0.06186725f, -0.07134898f, -0.42051709f, 
    0.03018803f, 0.17739205f, 0.17021132f, 0.04530027f, 0.14206864f, -0.25834006f, -0.11633330f, -0.06684753f, 
    -0.22088422f, -0.37425330f, -0.17514578f, 0.08990184f, -0.54172266f, 0.08482760f, 0.28233129f, 0.11578909f, 
    0.43353882f, -0.77403378f, 0.06409435f, 0.23518924f, -0.11362574f, -0.04264612f, -0.06825863f, -0.41419533f, 
    -0.24086073f, 0.20827143f, 0.07506480f, 0.46925595f, -0.84986663f, 0.27736056f, 0.13535830f, -0.45237517f, 
    -0.04242414f, 0.07634631f, -0.18398069f, -0.34725931f, 0.35710806f, 0.20194057f, -0.00884554f, -0.20932952f, 
    0.04535297f, 0.02358355f, 0.09053985f, 0.00795565f, -0.38873294f, 0.05934023f, -0.19158287f, 0.00619221f, 
    0.24124701f, -0.26418039f, -0.04079367f, -0.19761957f, 0.18899354f, -0.35366380f, 0.15026566f, 0.14710951f, 
    -0.73204952f, 0.22405984f, 0.06265534f, -1.01491046f, 0.37056321f, 0.00291869f, -0.68661004f, -0.14425258f, 
    -0.14730905f, -0.14877230f, -0.21695775f, -0.07656033f, -0.54707229f, -0.14374854f, 0.04332262f, -0.30604306f, 
    0.27615526f, 0.12155940f, -0.17089470f, 0.01291523f, 0.15408164f, 0.01278895f, -0.03306824f, 0.30822194f, 
    -0.06569606f, 0.20214643f, 0.32202846f, 0.25070995f, 0.24322276f, -0.48325038f, -0.13536838f, -0.09685075f, 
    -0.09720846f, 0.02581690f, 0.01211071f, -0.30378091f, 0.36047566f, -0.14877044f, 0.16198739f, 0.05727984f, 
    -0.29756334f, 0.09608416f, -0.24150917f, -0.04997675f, -0.18954362f, -0.54650956f, -0.17000951f, -0.13410763f, 
    0.00330486f, -0.33939719f, -0.60563952f, -0.05275968f, 0.11032642f, -0.45278403f, -0.10880271f, 0.37646070f, 
    0.03072902f, 0.17367004f, 0.26498708f, -0.35148495f, 0.19795191f, 0.47005698f, 0.06233715f, 0.01186859f, 
    0.17240898f, 0.31501350f, 0.03130120f, -0.07335098f, 0.05562139f, -0.45520130f, -0.22370516f, -0.20328927f, 
    -0.58972031f, -0.10585696f, 0.13979232f, 0.14779602f, -0.07870864f, -0.23641893f, 0.00849802f, -0.13028282f, 
    -0.92550236f, -0.00516156f, 0.07894796f, 0.14996336f, 0.11919771f, -0.58829117f, 0.20774211f, -0.35091579f, 
    -0.31365943f, -0.13668132f, 0.07671196f, -0.24769375f, 0.09780784f, 0.16573098f, 0.24175379f, -0.29411104f, 
    0.13440855f, -0.31719834f, 0.01807502f, -0.47726944f, 0.03758761f, 0.18869443f, 0.36752006f, 0.18105386f, 
    -0.09857678f, -0.15768042f, 0.12387553f, 0.31214869f, 0.18952081f, 0.01660892f, 0.09006472f, -0.19313413f, 
    -0.10011525f, 0.07240966f, 0.32203728f, 0.19224764f, 0.13379559f, -0.06469267f, -0.16923583f, -0.49164569f, 
    -0.31893408f, -0.09969600f, -0.42173153f, -0.19030175f, 0.07001092f, -0.37056407f, 0.05162903f, 0.17615834f, 
    -0.96512038f, 0.32156327f, -0.09718792f, -0.11581162f, 0.08040154f, -0.20866656f, -0.47473308f, 0.14743043f, 
    0.03370199f, -0.99479920f, -0.04479416f, 0.00639294f, -0.24827923f, -0.04464019f, 0.05814249f, -0.22108287f, 
    0.18081634f, 0.00636305f, 0.19195265f, -0.53530425f, 0.22260381f, 0.37571946f, -0.20936412f, -0.18991674f, 
    -0.72396737f, 0.28171256f, -0.13900162f, 0.20491828f, -0.19979674f, -0.48054340f, -0.23447075f, 0.08090986f, 
    -0.01738684f, -0.09660421f, -0.06792577f, -0.29460952f, 0.11665326f, -0.16681127f, 0.01929075f, 0.08028279f, 
    0.12177422f, -0.45704713f, 0.17087007f, 0.26250035f, -0.52714294f, -0.09196807f, 0.02603006f, 0.16231483f, 
    0.24310413f, -0.12151878f, -0.29969242f, -0.44552746f, 0.20708090f, 0.00960000f, -0.18900286f, 0.36793736f, 
    0.48791602f, -0.46290928f, -0.16853036f, -0.22931115f, -0.40652221f, 0.27358425f, 0.21899857f, 0.04687098f, 
    -0.23029998f, -0.32747653f, 0.02089056f, -0.01464017f, -0.36675870f, 0.34468201f, 0.29019424f, 0.30306557f, 
    -0.37979755f, -0.47524127f, -0.26999128f, 0.30363771f, -0.16569749f, 0.04601789f, 0.00226959f, 0.03574548f, 
    0.23374195f, 0.11290026f, -0.10827648f, -0.45301524f, -0.32081789f, -0.11087790f, -0.49363074f, 0.31374314f, 
    0.02284469f, 0.07564727f, 0.16630924f, -0.18104689f, 0.21188661f, 0.26801926f, -0.50006258f, -0.16511977f, 
    0.19141626f, 0.25417238f, 0.23013456f, -0.30615351f, -0.00844547f, -0.32379341f, -0.70335263f, -0.20431155f, 
    0.21426122f, -0.45523447f, -0.24470317f, -0.39923602f, -0.47838506f, 0.02174422f, -0.11376278f, 0.02894801f, 
    -0.09344722f, 0.31915936f, 0.19251955f, -0.15375109f, -0.09783943f, 0.20322216f, 0.19777067f, -0.28540927f, 
    -0.01558796f, 0.17526470f, -0.53842217f, -0.19647236f, -0.47592956f, 0.02735040f, 0.19718082f, 0.37046632f, 
    -0.50473565f, 0.12061372f, 0.05670867f, -0.41706792f, -0.55353636f, -0.23645639f, 0.33351356f, -0.14646269f, 
    -0.06401838f, 0.15556151f, -0.51163071f, 0.25704056f, 0.36792359f, -0.23178186f, -0.04685501f, -0.13270968f, 
    0.03281369f, 0.16298975f, -0.25792861f, 0.09858874f, -0.23126611f, -0.55600089f, 0.30025631f, -0.43166524f, 
    -0.12678948f, 0.40221789f, 0.04134707f, 0.35379028f, -0.12974994f, 0.12408942f, -0.65717936f, 0.33124110f, 
    -0.05339990f, 0.07303143f, -0.06920815f, 0.18047453f, -0.01412597f, -0.17127411f, -0.09767458f, 0.09833496f, 
    0.37452632f, -0.27925125f, -0.77203465f, 0.48430154f, -0.42833954f, 0.02968663f, -0.07846684f, 0.00141109f, 
    -0.16726851f, 0.15151301f, 0.01772123f, 0.12842591f, 0.07163158f, -0.12792893f, 0.08546544f, 0.05177175f, 
    -0.30430543f, -0.51137823f, -0.03807877f, 0.33173820f, 0.11578866f, 0.17136620f, -0.24446930f, -0.23531757f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.17976531f, 0.16962603f, 0.18554942f, -0.22436227f, 0.09190517f, -0.06769353f, 0.10604250f, -0.25210953f, 
    -0.03833881f, 0.08304685f, -0.01370180f, -0.11677370f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
