#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.70328939f, -0.86841345f, -1.21120691f, 0.04123087f, 1.27027822f, -0.52924961f, -0.37577415f, 0.32887164f, 
    0.03592264f, -0.28129047f, -1.39201736f, -0.14017779f, -0.99857897f, -0.88218671f, -0.17728694f, -0.49149099f, 
    -0.27362812f, 0.83582127f, -0.18598630f, -0.59858102f, -0.31017530f, 0.81346357f, -0.42977116f, 0.05944716f, 
    0.51082349f, 0.66994667f, -0.20776856f, 0.89674181f, 1.36074531f, 0.64215750f, -1.12164879f, -0.67419249f, 
    0.03570765f, -0.11237535f, -0.38236591f, -0.32265818f, -0.36248255f, 0.42584220f, -1.13007772f, -0.80403602f, 
    -0.89800090f, -1.32473230f, -0.32599777f, -0.62144023f, -0.21598466f, 1.04176736f, -0.55777013f, 0.18673041f, 
    0.12654875f, -0.04135147f, 0.05799910f, 0.37812266f, -0.10998616f, -0.05077641f, -1.67829800f, 1.64140368f, 
    0.08555620f, -0.58196515f, -0.44095376f, -0.25873670f, -0.15153766f, -0.00551009f, -0.21726631f, 0.30317488f, 
    -0.82585943f, -0.87886113f, 1.33421707f, 1.10444987f, -0.04403827f, -0.17746744f, -0.56935543f, -0.48979080f, 
    -0.27753887f, 1.35118580f, -1.38805842f, -0.84288472f, -0.60792696f, 0.52065867f, -0.25538197f, -0.55966663f, 
    0.97544706f, -1.52753747f, -1.34025574f, 0.43979806f, 0.89376265f, 0.61919326f, -0.89100403f, 0.05520014f, 
    -0.02236091f, 0.40362877f, -0.19205426f, 0.77018183f, -0.06417993f, -0.39295417f, 0.38105828f, 0.90687835f, 
    0.22489624f, -0.00925243f, 0.62211794f, -1.30085635f, -0.36306152f, 0.97976834f, -1.03978240f, -1.13100052f, 
    -1.00974178f, -0.34463429f, -0.83306533f, -0.75969058f, 0.00788726f, 0.02266047f, -0.38047907f, -1.03111219f, 
    -0.25013280f, -0.73077059f, 0.44028196f, 0.94338995f, 0.04802584f, 0.11014165f, -1.46010375f, -1.24982464f, 
    -0.99458385f, -0.70421165f, -0.11665846f, 0.55142492f, -0.56505960f, -0.60974246f, -1.61117744f, -0.50082445f, 
    -1.02312148f, 0.57156968f, 0.09423516f, 0.43153793f, 0.33097196f, 0.11009084f, 0.36519143f, 0.08467338f, 
    -0.62471020f, 0.64300615f, 0.40789425f, -1.00436652f, -0.95095730f, 0.27022874f, 0.78563392f, 0.57394654f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.57266086f, 0.23570763f, -0.07277891f, 0.48922411f, -0.33805743f, 0.76399863f, 0.69431520f, 0.21448508f, 
    0.09885990f, -0.17591909f, 0.52847672f, -0.34586203f, 0.10806950f, -0.15156457f, 0.84395659f, 0.19825582f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.11036368f, -0.00530437f, -0.60102344f, -0.00332920f, -0.23689479f, 0.18796784f, -0.09785522f, 0.00661361f, 
    -0.18197182f, 0.07880975f, -0.05258863f, -0.03436813f, -0.17578739f, -0.13095622f, -0.16221210f, -0.06218220f, 
    0.08531570f, -0.15825431f, -0.07034916f, 0.07140683f, 0.22751169f, 0.42115223f, 0.08134820f, -0.41564745f, 
    -0.04345359f, 0.17230347f, 0.09950095f, 0.19365327f, -0.41803235f, -0.08970204f, -0.06876028f, -0.04415066f, 
    -0.04340171f, 0.02763595f, -0.02618012f, 0.01925062f, -0.11952249f, -0.06648669f, 0.10429823f, -0.45142391f, 
    0.08321603f, 0.09341769f, -0.03731912f, 0.00504990f, 0.17320865f, 0.01385980f, 0.12152112f, 0.09399051f, 
    0.02320782f, 0.11292161f, -0.11880707f, 0.04175834f, 0.02233095f, 0.02369105f, -0.02896312f, 0.03130179f, 
    -0.03505362f, 0.06716830f, -0.09428649f, 0.07303579f, -0.81678581f, 0.33422810f, -0.06363954f, -0.09391101f, 
    -0.21673238f, 0.05376972f, -0.10802911f, -0.13782191f, 0.10462496f, 0.06430005f, 0.09728502f, 0.03706429f, 
    0.08827562f, 0.11928754f, 0.14615588f, 0.23212707f, 0.21992235f, 0.04681489f, 0.12135213f, -0.14231162f, 
    0.23137350f, 0.38815618f, 0.19377533f, -0.25208327f, -0.17315252f, 0.10695820f, 0.20094855f, 0.18187603f, 
    0.00831052f, 0.04852899f, 0.02675031f, -0.03255214f, 0.02268367f, -0.02262203f, -0.02260279f, -0.02498067f, 
    -0.01239802f, 0.00981177f, -0.06580576f, 0.01370795f, -0.19487187f, -0.12642315f, -0.11303458f, -0.06205380f, 
    -0.02859822f, -0.14529951f, -0.05085506f, -0.07889667f, 0.04893625f, 0.06824263f, -0.13123490f, 0.00862337f, 
    -0.00412267f, -0.01423683f, -0.06637669f, -0.23969643f, -0.25176466f, -0.24145533f, -0.15150774f, -0.00701003f, 
    -0.38603544f, 0.16912231f, -0.11951141f, -0.08385079f, -0.23022369f, -0.39705333f, -0.25630116f, -0.21765015f, 
    0.02157285f, -0.12041044f, 0.02197998f, -0.12079911f, -0.08616382f, -0.05719573f, -0.08508381f, -0.20793250f, 
    0.16005795f, -0.02322907f, -0.30739409f, -0.07118512f, 0.33763793f, -0.41602665f, -0.98188633f, 0.03656176f, 
    -0.23896195f, -0.05181573f, -0.02912113f, 0.04070056f, 0.00420252f, 0.01896107f, 0.01010387f, 0.04115501f, 
    -0.19184557f, -0.03492812f, -0.04827334f, -0.07305736f, 0.08457708f, 0.06762931f, -0.00108784f, 0.00021102f, 
    -0.06228635f, 0.22995089f, 0.34275532f, -0.11160107f, -0.39499107f, -0.07033288f, -0.00835592f, 0.10758950f, 
    -0.20632902f, -0.15182357f, -0.13585587f, -0.19652131f, 0.00117501f, 0.09395377f, 0.08771115f, 0.01980418f, 
    0.06815352f, 0.02941245f, -0.34866291f, -0.14912027f, 0.88643813f, 0.39319187f, -0.32525519f, -0.61226571f, 
    -0.03721984f, -0.09693715f, 0.11506648f, 0.24732013f, -0.03428022f, 0.01771338f, -0.07485515f, -0.11061504f, 
    -0.11496413f, 0.07096375f, 0.07006240f, 0.02489652f, 0.05464712f, 0.06545256f, 0.04959640f, -0.01579424f, 
    -0.04717361f, -0.02705939f, 0.07532600f, 0.02372258f, 0.06710052f, 0.02006936f, -0.10143155f, 0.01964193f, 
    0.09793664f, 0.07388378f, -0.38327700f, -0.26281381f, -0.41022551f, -0.24298911f, -0.15259273f, -0.07871252f, 
    -0.05174740f, 0.00635112f, 0.01886214f, -0.04279366f, 0.43052846f, 0.44230548f, 0.19107281f, -0.58353102f, 
    0.12054978f, 0.08827329f, 0.16267881f, 0.08255877f, 0.06205673f, 0.11755303f, 0.08095888f, -0.11448070f, 
    0.00818678f, -0.04806362f, -0.08531256f, 0.01547779f, -0.10235282f, -0.06472611f, 0.17061865f, -0.03917160f, 
    0.49478617f, 0.43900982f, -0.03178784f, -0.18159327f, -0.12258691f, -0.03095430f, 0.09237127f, -0.18080260f, 
    0.21623673f, 0.11121994f, 0.04808336f, 0.03781613f, 0.01181962f, 0.06254919f, 0.10904376f, -0.04719276f, 
    -0.10897365f, -0.05366188f, -0.15062913f, 0.09762707f, 0.43470073f, 0.28622803f, 0.05294666f, -0.48153418f, 
    -0.10871327f, 0.39570993f, 0.16303536f, 0.24805357f, -0.01390936f, 0.00795106f, 0.00573478f, -0.05083264f, 
    -0.02454779f, -0.10286367f, -0.03638916f, -0.02247119f, -0.07304154f, -0.00413122f, 0.09885639f, 0.37515640f, 
    0.29945719f, 0.14586031f, 0.04830629f, -0.18568762f, 0.03916857f, 0.13817738f, 0.16696429f, 0.11844699f, 
    -0.08678434f, -0.30345580f, -0.16076632f, -0.20629379f, -0.04013627f, 0.03866371f, 0.05455724f, 0.03496112f, 
    0.02906497f, -0.03209542f, -0.01647515f, 0.00678600f, 0.29933861f, 0.32042313f, 0.04552036f, -0.07031328f, 
    -0.01049057f, -0.19505951f, 0.16239618f, -0.01826265f, -0.23293574f, -0.04872891f, 0.19820854f, -0.08385884f, 
    -0.09763342f, -0.01408838f, 0.02342059f, 0.03284673f, 0.00298902f, -0.20189345f, -0.11414356f, -0.09732626f, 
    0.82022434f, -0.29786855f, -0.48671669f, -0.02414506f, -0.44601461f, 0.12469565f, 0.10930859f, 0.01016725f, 
    0.16355354f, 0.00940660f, 0.19934779f, -0.05830211f, 0.06770566f, -0.09891741f, 0.01341581f, 0.00777300f, 
    0.04902948f, -0.24356543f, 0.10142910f, 0.09222858f, -0.26549771f, 0.31424990f, -0.03659642f, 0.35233548f, 
    -0.03749575f, -0.09345038f, 0.17324214f, 0.09482965f, -0.00658041f, 0.15360242f, -0.00255660f, -0.07465462f, 
    0.09373290f, -0.00487943f, 0.06823198f, 0.04486384f, 0.03374878f, 0.02338756f, -0.21468274f, 0.23515432f, 
    0.06928138f, -0.07240433f, -0.30396849f, -0.09018657f, -0.17459381f, -0.13733873f, -0.08295272f, -0.00402532f, 
    0.06744677f, -0.03320284f, -0.13810112f, 0.27264696f, -0.03903695f, 0.08372191f, -0.07805970f, -0.16957147f, 
    0.01557423f, 0.08641678f, -0.06319600f, -0.04350130f, 0.57946348f, -0.04285713f, 0.11846504f, -0.05134948f, 
    -0.10583866f, -0.07043324f, -0.04784144f, -0.06686256f, -0.10665129f, 0.04846864f, -0.03063529f, 0.01432616f, 
    -0.05025142f, 0.04723366f, 0.01517078f, -0.09552975f, 0.02601730f, -0.19821106f, 0.19572112f, 0.04932748f, 
    -0.06835262f, 0.28822464f, -0.13981538f, 0.24531825f, -0.53533208f, 0.02761038f, -0.19683726f, -0.34277794f, 
    -0.38071409f, 0.10654537f, -0.08076706f, 0.03249581f, 0.03219545f, 0.06845777f, 0.09445326f, -0.07988832f, 
    0.06006214f, -0.00492770f, -0.21003731f, -0.11712712f, 0.35000393f, 0.27217534f, 0.14029936f, 0.13700460f, 
    0.18366608f, -0.03260138f, 0.13047458f, -0.07723530f, -0.00745808f, -0.00203216f, 0.03871080f, 0.04194758f, 
    0.10853852f, 0.20271204f, 0.00609212f, -0.11473406f, 0.08748204f, 0.16676970f, 0.15696509f, -0.02377385f, 
    -0.67495275f, -0.55720568f, -0.04744859f, -0.09326897f, -0.02807891f, 0.08697292f, 0.11568851f, -0.13160807f, 
    0.02140458f, 0.07834873f, -0.07647927f, 0.08873535f, 0.13500677f, 0.10063413f, 0.17473486f, -0.04080974f, 
    0.06111704f, -0.16836220f, -0.01805312f, -0.06285351f, 0.86114609f, -0.16545404f, 0.13315819f, 0.23185112f, 
    -0.29883030f, -0.05215011f, -0.10758855f, 0.00716576f, -0.00722351f, -0.19343072f, 0.18630622f, -0.20835094f, 
    0.05299522f, -0.36126471f, -0.13660049f, 0.16095003f, -0.12721173f, -0.23996364f, 0.06098384f, -0.01266271f, 
    -0.87107766f, -0.34411204f, 0.15660115f, 0.22630581f, -0.44785893f, 0.16306990f, 0.04494307f, -0.44513959f, 
    -0.28608033f, 0.09308599f, -0.13255179f, 0.12382008f, -0.02628719f, 0.13294978f, -0.16192310f, -0.10184836f, 
    -0.05737852f, -0.06864163f, -0.11785498f, 0.16334093f, 0.33063310f, -0.02296341f, 0.40438044f, 0.14925359f, 
    0.37834901f, 0.11692666f, 0.02692740f, 0.42666709f, 0.17482746f, -0.26812905f, 0.10362206f, -0.10887840f, 
    0.07604757f, -0.11323575f, -0.18242940f, 0.04361839f, -0.03392753f, 0.03915379f, -0.07981478f, -0.14922690f, 
    0.11628269f, -0.03817614f, 0.27249917f, 0.15352263f, 0.20819153f, -0.03844173f, -0.02735137f, 0.04404255f, 
    0.01412601f, -0.05383860f, 0.24560826f, 0.10797665f, -0.01242925f, 0.06840018f, -0.07311036f, -0.12800534f, 
    -0.12329619f, -0.08845621f, 0.02532142f, 0.03343881f, -0.14574338f, 0.13966861f, -0.33458787f, 0.04834737f, 
    0.23910990f, 0.19300146f, -0.17869225f, -0.09348734f, 0.19999838f, -0.13251588f, 0.02107692f, 0.07467493f, 
    0.10290184f, -0.06263765f, 0.14572614f, -0.14883465f, -0.08372684f, 0.13547969f, -0.41850883f, -0.43515849f, 
    -0.24958463f, -0.14225471f, -0.32728615f, -0.07983180f, -0.01537803f, -0.17921846f, 0.07531855f, -0.27915016f, 
    -0.03728149f, 0.00949545f, 0.00234723f, -0.00365627f, -0.09321310f, 0.17276505f, 0.11635329f, 0.00003390f, 
    0.02151526f, 0.01948658f, 0.23892415f, 0.11708348f, -0.11146729f, 0.63070172f, 0.22360107f, 0.27995169f, 
    0.20069566f, 0.15686257f, -0.25089598f, 0.09861214f, -0.21853705f, -0.01573388f, -0.00654192f, -0.07385327f, 
    -0.01627310f, 0.07447334f, 0.12363545f, 0.02285955f, 0.01724048f, 0.08380562f, -0.36361870f, -0.06369925f, 
    -0.42832184f, -0.08805668f, -0.22784014f, -0.08083796f, -0.19455864f, -0.02126915f, 0.10221791f, 0.20226875f, 
    0.03904101f, -0.09663384f, 0.01871094f, 0.04591940f, 0.04581368f, -0.05977740f, -0.05037879f, 0.04121105f, 
    0.04572926f, -0.03201875f, -0.04224143f, 0.01773906f, -0.46812361f, 0.08265506f, -0.17726643f, -0.16093521f, 
    0.01214187f, 0.22260591f, -0.13010354f, 0.12619807f, 0.29060513f, -0.01506661f, -0.11145272f, -0.04201974f, 
    0.00715994f, 0.03007371f, 0.01625948f, -0.10761774f, 0.01223983f, 0.09006779f, -0.08397186f, 0.04134139f, 
    -0.03389308f, 0.09555874f, 0.58364284f, -0.36230850f, 0.07191370f, -0.03920387f, -0.02084656f, 0.09797633f, 
    0.16678484f, -0.05899071f, 0.06802699f, -0.04345565f, 0.14125326f, -0.13196969f, 0.18779814f, -0.02132482f, 
    -0.10810080f, -0.23505516f, 0.18180543f, -0.10622732f, 0.26282987f, -0.41210490f, -0.36601824f, 0.30666050f, 
    -0.12993443f, -0.06752939f, 0.19489688f, 0.28912279f, -0.02364407f, 0.07573034f, 0.02706343f, 0.03240134f, 
    0.02191444f, -0.06857870f, 0.04971373f, -0.00307721f, 0.05089619f, -0.01936669f, -0.28423345f, -0.16537143f, 
    0.01193629f, -0.02649846f, 0.03634053f, 0.02279011f, 0.13570921f, 0.08372634f, -0.13774160f, -0.00095557f, 
    0.26078928f, -0.20897189f, -0.01317053f, -0.17275359f, -0.34254637f, 0.07092684f, -0.06902252f, 0.07997056f, 
    -0.16161364f, -0.04055142f, 0.09809812f, -0.05676405f, -0.83637100f, -0.67244613f, 0.33721262f, -0.35042068f, 
    -0.25135899f, 0.00030698f, 0.02450529f, -0.05765296f, 0.05315657f, 0.09432301f, -0.02037803f, 0.00957960f, 
    0.01587729f, 0.07326832f, -0.04153240f, 0.06911296f, 0.02055485f, 0.08254851f, -0.12531357f, -0.14418496f, 
    -0.67653775f, -1.32701302f, -0.07967193f, -0.09879586f, -0.46427584f, 0.02991541f, 0.01887457f, -0.03455004f, 
    0.04674159f, -0.21635096f, -0.03689871f, 0.00068568f, -0.02419513f, -0.10605101f, -0.11110486f, -0.13222113f, 
    0.01044270f, 0.03100374f, 0.19193810f, 0.12908183f, -0.24513802f, 0.17430301f, -0.01621762f, -0.05154377f, 
    0.00153392f, -0.06946902f, -0.08685920f, -0.07920857f, 0.02742333f, 0.05878108f, 0.14128360f, -0.06434249f, 
    -0.00339447f, 0.10076056f, -0.06759901f, -0.03414708f, -0.03642466f, 0.01226870f, 0.11073340f, -0.03936174f, 
    0.82111543f, -0.03508161f, 0.41901338f, 0.10764001f, 0.44094211f, 0.13755584f, -0.04208166f, -0.26049837f, 
    -0.09350052f, 0.08265477f, 0.02372005f, 0.03144389f, 0.04267738f, -0.06978709f, -0.05177041f, 0.18283215f, 
    -0.01636088f, -0.05801084f, 0.42879939f, 0.12572180f, -0.66047144f, -0.32730445f, 0.89588058f, -0.09140766f, 
    0.16505030f, 0.01738507f, -0.15916298f, -0.06842799f, -0.09008613f, -0.02290009f, 0.07394716f, 0.02143550f, 
    -0.11114790f, -0.18374577f, 0.12418615f, 0.14828585f, 0.11819245f, 0.14730579f, 0.15729009f, -0.13217470f, 
    0.26142457f, -0.71767163f, -0.62209308f, 0.19608349f, -0.05337292f, 0.04164620f, 0.11753445f, -0.05568155f, 
    -0.21308133f, -0.00646292f, -0.14072418f, -0.09921142f, 0.09862334f, -0.17775197f, 0.10957993f, 0.08081073f, 
    0.01968993f, -0.11044966f, -0.01077063f, -0.02703680f, 0.22245583f, -0.77142000f, 0.68857920f, 1.05446959f, 
    0.23781373f, 0.00273169f, -0.26140317f, -0.22372918f, 0.49078962f, -0.09290909f, 0.00727113f, -0.00261968f, 
    0.14540635f, -0.03677017f, -0.03118113f, 0.04294843f, -0.16234414f, -0.04626511f, -0.01640663f, -0.03439078f, 
    0.00720853f, -0.05867220f, -0.09294285f, -0.07517589f, 0.11196897f, 0.03059526f, 0.05505439f, 0.01895598f, 
    0.05925009f, 0.06530774f, -0.06326010f, -0.07154574f, -0.04545667f, -0.16210391f, 0.03373673f, 0.00764563f, 
    0.01257199f, -0.06946468f, -0.01864652f, -0.07589522f, -0.26136270f, -0.28510788f, -0.42755184f, 0.14298774f, 
    -0.23800932f, -0.24703236f, 0.09277432f, -0.28375098f, 0.16148688f, 0.03861203f, -0.09041601f, -0.02296592f, 
    0.01181061f, -0.10157005f, -0.09292170f, -0.12285610f, 0.00903728f, 0.10905450f, -0.26070422f, 0.18885507f, 
    -0.27023074f, -0.30525795f, -0.44024736f, -0.05106746f, -0.16012301f, 0.13213828f, 0.22970556f, -0.29755312f, 
    -0.05879124f, -0.49790004f, 0.03286397f, 0.00884216f, -0.07961519f, 0.07147537f, -0.03962465f, 0.07124674f, 
    -0.07530723f, -0.03702347f, -0.20136105f, -0.18508360f, -0.47093847f, 0.12761226f, 0.13398893f, 0.10062699f, 
    -0.35464048f, 0.20383547f, 0.10191982f, 0.18848439f, 0.15322621f, -0.05953934f, -0.04203859f, 0.06954546f, 
    0.08673219f, 0.09050535f, -0.04233824f, -0.09080366f, 0.04394242f, -0.08967749f, 0.00818313f, -0.12536511f, 
    -0.13014166f, 0.15983450f, 0.43559897f, 0.53523058f, 0.39476943f, 0.09403560f, 0.04960537f, 0.11302861f, 
    0.14181828f, -0.17464185f, 0.06728680f, 0.06340610f, 0.03109579f, 0.07434563f, 0.11225734f, -0.00200180f, 
    -0.06282606f, -0.00857675f, 0.03414370f, 0.00300802f, -0.10373209f, 0.02798626f, -0.07805323f, -0.03133145f, 
    -0.00179019f, 0.13404872f, -0.35302290f, -0.53732103f, -0.14866905f, 0.08594249f, 0.12877281f, -0.07010608f, 
    0.04562498f, -0.05136242f, -0.17609121f, -0.06213374f, -0.02973642f, -0.02047190f, 0.04239757f, -0.13178340f, 
    -0.05320824f, 0.47083429f, -0.18112673f, 0.11083005f, 0.21621977f, -0.01785729f, -0.13834018f, -0.01725562f, 
    -0.11766908f, -0.16794851f, -0.02434972f, 0.04427210f, -0.06230870f, -0.05646542f, -0.03823599f, 0.05271364f, 
    -0.14441966f, -0.05876016f, 0.07203567f, -0.19834381f, -0.13933288f, -0.04181372f, -0.64006990f, -0.08997108f, 
    0.22506455f, 0.11075959f, -0.18770234f, 0.03009707f, -0.01923097f, 0.11639860f, -0.12165555f, 0.19948421f, 
    -0.13730963f, 0.09227037f, -0.06190989f, -0.04738951f, -0.12123530f, 0.14335704f, -0.20120676f, -0.11411977f, 
    -0.41003692f, -0.21576776f, 0.11971614f, -0.16106686f, 0.22603829f, 0.23502062f, -0.07879896f, 0.06145978f, 
    0.17559476f, 0.01484755f, -0.20433344f, 0.11289127f, 0.05081517f, -0.11973645f, -0.08047339f, 0.00710463f, 
    0.06507524f, 0.28259143f, 0.06058721f, 0.02922911f, -0.55994201f, -0.60639244f, 1.16970193f, 0.08312105f, 
    0.21787912f, -0.35138446f, 0.07590284f, 0.18752225f, 0.28123721f, -0.15312855f, 0.22827518f, 0.02382523f, 
    0.04287193f, -0.06324102f, 0.19805995f, -0.09041447f, 0.03701004f, -0.03980951f, -0.00023008f, -0.02572009f, 
    0.19077769f, -0.34433493f, -0.41859815f, -0.05711485f, 0.45882589f, -0.04920364f, 0.22522697f, 0.12668552f, 
    -0.01687300f, -0.01027402f, -0.14956394f, 0.00176440f, -0.06765793f, -0.07221137f, 0.03831544f, 0.03424567f, 
    -0.13135082f, 0.08501758f, 0.15357736f, -0.12556653f, -1.68904173f, 0.07229909f, 0.14533192f, 0.51541799f, 
    -0.64479619f, 0.09427127f, -0.09892745f, -0.01608850f, -0.23426241f, -0.29005435f, -0.25767344f, 0.20427780f, 
    -0.07408118f, -0.03300988f, -0.13020943f, -0.01471073f, 0.12041581f, 0.15445986f, -0.15572213f, -0.33847880f, 
    0.54188412f, 0.24459340f, 0.11923402f, -0.54551893f, 0.38779315f, -0.09194278f, 0.17589346f, 0.10418040f, 
    -0.25750029f, -0.05346192f, -0.10045066f, -0.03013084f, -0.09394724f, -0.05202778f, 0.06254198f, -0.11579486f, 
    -0.04272887f, -0.10179228f, 0.16419993f, 0.10176515f, 0.05507654f, 1.01669073f, -0.17125660f, 0.09730221f, 
    0.03082241f, 0.33897057f, 0.23606151f, 0.01381738f, 0.08119132f, 0.32981241f, -0.31554437f, -0.14576106f, 
    0.07571754f, 0.01325154f, 0.15018307f, -0.12924419f, -0.07076636f, -0.10051533f, 0.04271888f, -0.00214992f, 
    0.13682587f, -0.12581876f, -0.23565607f, -0.06691044f, 0.49248067f, -0.11917226f, 0.07892340f, 0.11211004f, 
    -0.18621863f, -0.09600154f, 0.11527883f, 0.11185586f, 0.13154186f, 0.10443747f, -0.06058708f, 0.03767136f, 
    -0.07657994f, 0.07051751f, 0.05155545f, -0.36542928f, -0.65291995f, 0.80296367f, -0.30317336f, -0.14398311f, 
    0.45545870f, 0.45155290f, 0.07698623f, -0.07995193f, -0.05585676f, -0.17779507f, -0.29407614f, 0.09567467f, 
    -0.06005530f, 0.06062158f, 0.13524373f, -0.08577237f, -0.10142069f, 0.06699172f, 0.21800062f, 0.00045180f, 
    -0.39930013f, 0.03430850f, 0.00612254f, -0.00816424f, -0.93030351f, 0.01811029f, -0.22142847f, -0.11274605f, 
    -0.33654994f, -0.18875664f, -0.21173961f, 0.06584319f, 0.09071393f, -0.38242128f, -0.08311513f, 0.05594379f, 
    -0.00063096f, -0.02770612f, -0.22805427f, -0.11264492f, 0.22364633f, 0.06402282f, -0.06979915f, -0.08554857f, 
    0.40872917f, -0.03484336f, 0.17604481f, -0.07273065f, -0.03055809f, 0.12823452f, -0.19263852f, 0.11257385f, 
    -0.12500697f, -0.06472015f, -0.03425080f, 0.07427094f, -0.05842486f, 0.03017638f, -0.24440855f, 0.01827533f, 
    0.04595343f, -0.10992506f, -0.40585497f, -0.03334272f, 0.34714907f, 0.17608897f, 0.06711908f, 0.05659781f, 
    0.15522726f, 0.20669991f, 0.18485230f, -0.20895261f, 0.18300612f, -0.11251772f, 0.02437796f, 0.06289937f, 
    -0.04601041f, 0.00671170f, -0.09231031f, 0.09604582f, -0.16266935f, -0.18088940f, -0.17678332f, 0.08584043f, 
    0.35684258f, -0.07233576f, 0.03145427f, -0.11965741f, -0.12643480f, -0.12864357f, -0.02168023f, 0.02575961f, 
    0.09353104f, -0.04863562f, 0.07100032f, 0.10349669f, 0.03460765f, 0.16269559f, -0.14198273f, -0.01864287f, 
    0.18395501f, -0.31620046f, -0.22988991f, -0.05214621f, 0.46355715f, 0.20833229f, 0.01059099f, -0.18094894f, 
    -0.06562612f, -0.18521787f, -0.25298035f, 0.09127605f, 0.05089330f, 0.08939253f, 0.12518533f, -0.05933511f, 
    0.07033489f, 0.13322265f, 0.07366997f, 0.08118506f, -0.16772996f, -0.11590920f, -0.42584643f, 0.12271377f, 
    0.27717936f, 0.04494645f, 0.07699048f, 0.08012847f, 0.11018083f, 0.09427374f, 0.06957360f, -0.05162097f, 
    -0.39836890f, 0.04802229f, -0.09184576f, -0.05376216f, -0.22639892f, 0.44095036f, -0.26863724f, -0.33015275f, 
    -0.24135187f, -0.32262549f, 0.10384253f, 0.16892172f, 0.16980870f, -0.36990485f, -0.02537074f, -0.17504610f, 
    -0.22180176f, -0.17657360f, -0.11344943f, -0.09426392f, -0.07457575f, -0.03379926f, 0.06283752f, -0.17636935f, 
    -0.06060756f, 0.07618961f, -0.16084908f, -0.15280902f, 0.08706404f, 0.15864955f, 0.36153021f, 0.13988963f, 
    0.14255178f, -0.22895728f, -0.02003750f, -0.12187698f, 0.07346416f, -0.14921887f, -0.04265099f, -0.05462637f, 
    -0.00066910f, 0.06196121f, 0.04419858f, -0.15755659f, -0.05057639f, -0.08561203f, 0.02819942f, -0.21643850f, 
    0.24270515f, 0.08555157f, 0.08043471f, 0.18405060f, -0.00933422f, 0.01853431f, -0.05188450f, -0.04752095f, 
    0.01919902f, 0.00742393f, 0.27943558f, -0.14812103f, -0.32039902f, 0.02530228f, 0.11124364f, 0.23083326f, 
    0.07947188f, 0.03114152f, -0.05922722f, -0.03701212f, 0.12311069f, 0.41557947f, -0.47199297f, 0.21553114f, 
    0.29442969f, 0.05276073f, 0.07639123f, 0.08621474f, 0.10818694f, 0.15327460f, 0.15674885f, 0.02373855f, 
    0.08458147f, -0.00396557f, 0.02245539f, 0.10680983f, 0.08917730f, 0.15816775f, -0.01869952f, -0.00451497f, 
    0.06228390f, 0.20948255f, 0.42612824f, 0.23528378f, -0.06983913f, 0.04312577f, 0.18139844f, 0.02585615f, 
    0.21145329f, 0.36444205f, 0.05869660f, 0.04831022f, 0.00724127f, 0.06516358f, -0.02165343f, -0.03561849f, 
    0.13498095f, -0.07843507f, 0.15183616f, 0.26976591f, 0.08499044f, -0.21822208f, -0.02076750f, -0.24667168f, 
    -0.03797460f, 0.09186205f, -0.05340955f, 0.13818002f, 0.02146433f, -0.11651313f, 0.11271288f, 0.00652564f, 
    -0.16024101f, -0.16797604f, 0.10130113f, 0.01960061f, 0.06439672f, -0.29626754f, -0.12649278f, -0.02599967f, 
    0.42289978f, -0.19635464f, -0.27242333f, 0.46107474f, -0.07475890f, 0.10946985f, -0.09300075f, -0.11312515f, 
    -0.18773532f, -0.02094766f, 0.01345037f, -0.19164100f, -0.06876174f, -0.01607528f, -0.01200213f, -0.14715184f, 
    0.01179393f, -0.03306931f, -0.40191752f, -0.13863325f, -0.17197193f, -0.31787145f, 0.12361404f, -0.41539705f, 
    -0.21975967f, 0.05444191f, 0.19152600f, -0.10718863f, 0.13985424f, 0.20615941f, -0.03077181f, 0.09017782f, 
    -0.08362176f, 0.09330707f, -0.17837419f, -0.12869824f, 0.00321561f, -0.06988454f, -0.09277483f, 0.05769308f, 
    -0.01996633f, 0.15505187f, 0.17436296f, -0.11055841f, 0.03117544f, -0.11431869f, -0.03918011f, -0.24968919f, 
    0.07464813f, -0.25906691f, 0.01049816f, 0.00658816f, 0.00828554f, -0.18559903f, 0.00192399f, -0.17282188f, 
    -0.10576144f, -0.05409945f, -0.02227467f, -0.23179905f, 0.29544437f, -0.41744259f, 0.09802502f, 0.22938009f, 
    0.23056209f, -0.41089624f, -0.25620517f, -0.01760715f, -0.58038217f, 0.09325679f, -0.23813254f, 0.02373811f, 
    0.08833962f, 0.02468579f, 0.12335233f, -0.07097208f, -0.05899339f, 0.11742794f, -0.17611748f, -0.02043064f, 
    -0.01417642f, 0.09513641f, -0.15325703f, -0.14914662f, -0.06291264f, 0.04642981f, 0.07380075f, -0.03224846f, 
    -0.02019867f, 0.00914744f, 0.08852921f, -0.17901827f, -0.12587243f, -0.23283511f, 0.13879666f, 0.20638889f, 
    -0.06081659f, -0.10135231f, -0.07240880f, 0.04153383f, -0.21897759f, -0.10385729f, 0.10403273f, 0.22130187f, 
    -0.03113302f, 0.02737737f, 0.23306294f, 0.02089478f, -0.24278080f, -0.06129080f, -0.05103652f, -0.02317170f, 
    0.05779390f, 0.05359884f, -0.01032425f, 0.06770304f, 0.30827901f, -0.09117742f, 0.18230173f, 0.33006957f, 
    0.05453689f, 0.10565322f, 0.40076110f, 0.06771076f, 0.02566305f, -0.00271191f, -0.21314839f, 0.24522981f, 
    -0.27961284f, 0.29765308f, 0.19266123f, -0.06650365f, 0.01409507f, -0.16053265f, -0.00478337f, -0.06332187f, 
    -0.12805012f, -0.12708606f, -0.19488876f, -0.20401539f, -0.09295209f, -0.10687944f, 0.24795416f, -0.12851198f, 
    0.00960307f, -0.20962806f, 0.03626608f, -0.08085470f, -0.11893971f, -0.12631586f, 0.04491710f, 0.02677874f, 
    -0.07295388f, 0.00961738f, -0.04503874f, 0.04841340f, 0.09386343f, -0.22074702f, 0.12265362f, -0.07409033f, 
    0.03604913f, -0.08325100f, 0.15835580f, 0.08088329f, 0.02062615f, -0.30902883f, -0.12713557f, -0.22548021f, 
    0.05775242f, -0.02515326f, 0.10798530f, -0.05969158f, -0.15581897f, 0.02677993f, -0.01000652f, 0.06996042f, 
    0.01006897f, -0.03677849f, 0.03188721f, -0.03477379f, 0.04918669f, 0.14445093f, 0.27992275f, -0.10244943f, 
    -0.00247786f, 0.23974043f, 0.03372299f, 0.04826175f, 0.02588090f, 0.21591745f, -0.25026935f, 0.01569272f, 
    0.02766136f, 0.11880196f, 0.07185505f, 0.01471396f, -0.23247819f, -0.22803846f, -0.20452672f, -0.43478653f, 
    -0.26494828f, 0.23467828f, 0.04588475f, -0.23264121f, -0.12690966f, -0.00135532f, 0.01201894f, 0.06570800f, 
    -0.11165648f, 0.22726214f, -0.03578294f, 0.06833233f, 0.02796132f, 0.05998173f, -0.17749549f, 0.02141255f, 
    -0.16630778f, 0.22020416f, -0.04066544f, 0.08576861f, 0.33662963f, -0.24470614f, 0.36256036f, 0.01684468f, 
    -0.17543119f, 0.24688341f, 0.03961322f, -0.17319359f, 0.06827236f, -0.03035417f, 0.10261602f, 0.05214996f, 
    -0.06482459f, 0.01509855f, -0.04480194f, -0.01354452f, 0.01532176f, -0.10943594f, 0.05372830f, 0.34474525f, 
    0.08651982f, 0.12171087f, -0.17629449f, -0.26465869f, -0.04491860f, 0.11772402f, 0.10322551f, 0.01344671f, 
    -0.23701568f, -0.05722933f, 0.26874411f, -0.12184294f, 0.14516269f, -0.10402867f, -0.04700696f, 0.00664655f, 
    -0.04684784f, 0.10865103f, 0.08677965f, -0.01594397f, 0.03235561f, 0.04363174f, -0.55371898f, 0.24848230f, 
    0.15894148f, 0.24090219f, 0.00581932f, -0.08736497f, 0.03267982f, 0.03930419f, 0.03959012f, 0.00633608f, 
    -0.01919914f, 0.00678337f, -0.04577197f, -0.03534335f, -0.40092397f, 0.29742962f, -0.05559355f, -0.09715588f, 
    -0.08651908f, 0.07427234f, 0.39844820f, -0.02840404f, 0.02902192f, 0.05906830f, 0.03339450f, 0.16303493f, 
    0.08667450f, -0.24551161f, 0.05382536f, -0.00198340f, 0.08505787f, 0.05949207f, 0.04007307f, 0.09589738f, 
    0.10480156f, -0.08408801f, -0.28512168f, -0.17004144f, -0.01044200f, -0.26599604f, -0.29922006f, -0.07889166f, 
    0.14476965f, 0.23207857f, -0.08557475f, -0.06878796f, -0.09430514f, 0.13198511f, 0.04025573f, -0.22682211f, 
    0.02622708f, 0.00354586f, 0.10022470f, 0.11494237f, -0.07827455f, -0.02162549f, 0.00567226f, 0.07619245f, 
    -0.61741680f, 0.48451546f, 0.30666637f, 0.06476579f, -0.30869758f, -0.09973976f, 0.01745466f, 0.20002575f, 
    0.32231635f, -0.08130810f, -0.07149169f, 0.04521322f, -0.11520787f, -0.07395005f, -0.19654797f, 0.05298350f, 
    -0.11591755f, 0.07976771f, -0.03848822f, 0.06924272f, -0.29122251f, 0.24511804f, -0.61887091f, -0.49207968f, 
    -0.01138862f, -0.17112558f, -0.08557813f, 0.01597472f, -0.11696742f, -0.12105019f, -0.02156013f, 0.13737641f, 
    -0.19137815f, 0.02302188f, 0.14353237f, -0.21332714f, -0.09432388f, 0.03101599f, -0.10397712f, -0.20030276f, 
    0.63654834f, 0.35765141f, 0.10011436f, 0.21501827f, -0.06693949f, -0.05676947f, -0.06156886f, 0.09312731f, 
    0.03672287f, 0.41513848f, 0.08508971f, -0.12984425f, 0.15250024f, 0.09322887f, 0.15818495f, 0.19540259f, 
    0.07413188f, 0.02175725f, 0.02533575f, 0.23968412f, -0.80095387f, -0.32310691f, 0.01769175f, -0.47322223f, 
    -0.63698441f, -0.00623028f, 0.03444519f, -0.15826942f, 0.02888826f, 0.10765267f, 0.04742824f, 0.14891139f, 
    -0.19387852f, -0.01184477f, 0.18051361f, -0.02672891f, 0.04929142f, -0.04399793f, 0.05308292f, 0.24419107f, 
    -0.07887937f, -0.12328579f, -0.26580036f, 0.11726198f, 0.07400425f, 0.09946774f, -0.08896159f, -0.17644969f, 
    -0.05616515f, 0.08574146f, -0.07144929f, 0.11962480f, 0.23177376f, 0.17700522f, -0.12041046f, -0.00377962f, 
    0.15292107f, 0.25986126f, 0.07812865f, 0.04317391f, -0.10469396f, -0.12243289f, 0.58948666f, 0.20030078f, 
    -0.66449732f, -0.08001947f, -0.13969663f, 0.12635723f, 0.01720978f, -0.09263502f, 0.03394701f, 0.04704616f, 
    -0.02433747f, -0.06874636f, 0.02992584f, -0.01076809f, 0.10263841f, -0.13313654f, -0.34634537f, -0.19727527f, 
    0.09915643f, 0.19127128f, 0.22774440f, 0.00386167f, -0.11375791f, 0.31566834f, -0.08552008f, 0.03469119f, 
    0.00690801f, -0.14714161f, -0.19943488f, 0.00411434f, 0.00084810f, -0.07321628f, -0.04629713f, -0.01407950f, 
    0.07087015f, 0.10104334f, 0.04083356f, 0.03969439f, 0.32255098f, -0.16114715f, 0.08609878f, -0.09434692f, 
    -0.19357353f, -0.09178080f, 0.16034813f, -0.04369817f, 0.01707929f, 0.12280340f, 0.02239282f, 0.00546407f, 
    -0.01103288f, 0.03219010f, -0.01884611f, -0.07160617f, -0.01858466f, -0.05872988f, 0.03259097f, -0.17724510f, 
    -0.52948487f, 0.16539356f, -0.15802301f, -0.08907922f, -0.35162035f, -0.02090026f, 0.05220022f, -0.01268366f, 
    -0.05691927f, 0.14592075f, 0.11638445f, -0.03876494f, -0.05589913f, -0.07368124f, -0.13043071f, -0.07464900f, 
    0.04314686f, 0.07737858f, -0.09242947f, 0.06823061f, 0.31101400f, -0.14589417f, 0.19606072f, -0.14300263f, 
    -0.01444485f, -0.26276606f, 0.10318851f, -0.04902481f, -0.02283701f, -0.08647271f, 0.16334601f, -0.03787084f, 
    0.08581887f, -0.01619581f, 0.09628379f, 0.18453279f, 0.10160380f, -0.11012593f, 0.17753088f, 0.30973515f, 
    -0.53566587f, 0.68429559f, 0.43006706f, 0.45384783f, 0.64926779f, -0.03987779f, 0.14725366f, 0.06568434f, 
    0.14349081f, -0.17282411f, 0.15069465f, 0.14372626f, 0.10710876f, 0.10032772f, 0.06621059f, 0.13000588f, 
    0.01944993f, -0.02048817f, -0.01119830f, -0.07296658f, -0.68547285f, -0.21910878f, -0.77016169f, -0.13882540f, 
    -0.05635836f, 0.00742928f, 0.03296477f, 0.03390447f, 0.15544866f, -0.36938828f, 0.03229090f, 0.01081112f, 
    -0.07407901f, 0.06312491f, -0.03359021f, -0.00027857f, -0.05105135f, 0.11551998f, 0.13856280f, -0.00879135f, 
    -0.32655826f, 0.16456293f, 0.38321039f, 0.04546539f, -0.12769479f, -0.05603454f, -0.04177072f, -0.17345376f, 
    -0.24479876f, 0.01109913f, 0.08793622f, -0.24062966f, 0.12763548f, -0.09233920f, 0.11268974f, 0.03366658f, 
    0.02254031f, -0.18086804f, -0.16707528f, -0.06745198f, 0.18317145f, -0.43341917f, -0.70739484f, -0.56259793f, 
    0.13362861f, -0.01510340f, 0.12381280f, 0.22678135f, -0.03350595f, -0.04381505f, -0.10428981f, -0.08722653f, 
    -0.00686005f, -0.04421562f, -0.09925336f, -0.17145178f, -0.00571269f, -0.26868960f, 0.16285320f, 0.09264842f, 
    -0.46425796f, -0.47250718f, -0.97192681f, -0.37476593f, -0.01446109f, -0.23851477f, 0.02943153f, -0.18765786f, 
    0.25602275f, -0.69111180f, -0.05153036f, -0.09146439f, -0.03277884f, -0.01911822f, 0.11986745f, -0.02349888f, 
    -0.04225760f, 0.06712416f, 0.13212995f, 0.05506960f, 0.20479734f, 0.06510139f, -0.05907383f, -0.14771302f, 
    0.03289124f, 0.02718394f, 0.00322833f, 0.11693070f, 0.04709731f, 0.13467708f, -0.00834976f, -0.00000244f, 
    -0.07406538f, -0.12529880f, 0.07903124f, -0.07453921f, -0.09397693f, -0.16022275f, -0.10135581f, 0.06783908f, 
    -0.90471083f, -0.72948295f, -0.82055837f, 0.01294685f, 0.41951311f, -0.10900829f, 0.22863403f, -0.04815374f, 
    -0.04887770f, 0.11025661f, 0.11053865f, 0.03905798f, 0.12077168f, 0.05947439f, 0.06956326f, 0.03454821f, 
    0.11296503f, 0.06180961f, 0.29020742f, 0.02216590f, -0.13588504f, -0.09050725f, 0.21552798f, 0.09558863f, 
    0.32925695f, 0.05215226f, 0.00291498f, -0.02249777f, 0.11139404f, 0.01252598f, 0.12797482f, 0.15613331f, 
    0.18719907f, 0.23650549f, -0.06125106f, 0.14007539f, 0.10793966f, 0.19629750f, -0.01052704f, 0.06103928f, 
    0.08803825f, -0.11872799f, -1.41003525f, -0.47080657f, 0.37080571f, -0.08926524f, -0.04901690f, 0.13469994f, 
    0.27556324f, 0.02239741f, -0.01658650f, 0.04665903f, -0.07660329f, 0.10856305f, -0.04552897f, 0.01378971f, 
    0.07184975f, 0.07597987f, 0.12920254f, -0.10362582f, -0.65414995f, -0.28518254f, 0.80557573f, -0.07051679f, 
    -0.25437108f, -0.29559815f, -0.32357094f, -0.18460619f, -0.27294430f, 0.11013491f, -0.08503547f, 0.08914016f, 
    0.05112272f, -0.02702988f, -0.09189978f, 0.04997038f, 0.07011699f, -0.05079048f, -0.02593907f, 0.02422566f, 
    0.07877787f, -0.01367756f, -0.07569683f, -0.07667191f, 0.08519131f, -0.09284466f, -0.03652787f, 0.01108757f, 
    0.02426820f, 0.05305361f, -0.01364547f, 0.02240366f, 0.12740786f, -0.34621182f, -0.03837596f, -0.03093307f, 
    -0.06419887f, -0.24743994f, -0.02637938f, -0.10058252f, -0.82608575f, -0.78361303f, -0.89178586f, -0.48598948f, 
    0.53286958f, -0.27130181f, 0.10746757f, -0.14464416f, -0.22758409f, -0.30997050f, -0.05655111f, -0.12802069f, 
    -0.08549979f, 0.05749187f, 0.05149649f, -0.12519470f, 0.03422451f, -0.05563144f, 0.40310338f, 0.08046186f, 
    -0.15540542f, -0.32577616f, -0.10629953f, -0.16189381f, -0.04917740f, -0.23451574f, 0.14589491f, 0.06305880f, 
    -0.02048651f, -0.52933747f, 0.03419154f, -0.16478516f, -0.05907344f, -0.08506150f, 0.00708841f, -0.05490820f, 
    -0.04413091f, 0.09587900f, 0.13024804f, -0.27516681f, -1.01790738f, -0.94216353f, -1.18805480f, 0.18279137f, 
    -0.30830127f, -0.04186270f, 0.25837171f, -0.08261119f, -0.02442903f, -0.59284568f, 0.10036815f, -0.01287799f, 
    0.02315919f, -0.15348503f, -0.04320132f, 0.03729904f, 0.00051726f, 0.15148222f, 0.12910327f, -0.10157453f, 
    -1.12970340f, 0.73248047f, 0.80640918f, -0.00951867f, 0.25775802f, -0.29036957f, -0.14478804f, 0.02496992f, 
    -0.18132111f, 0.29367551f, -0.13662215f, 0.14725442f, -0.03248445f, 0.10585731f, 0.09200481f, -0.02783727f, 
    -0.02813859f, 0.01106826f, 0.07768716f, 0.01621943f, -0.01562889f, -0.27599871f, -0.09621894f, 0.06479848f, 
    0.12430274f, -0.11428499f, 0.07830732f, -0.05316067f, 0.11646604f, -0.35007173f, 0.20802915f, -0.11473282f, 
    -0.02283805f, -0.06153377f, 0.02686239f, -0.00263402f, -0.08881626f, 0.08615181f, 0.11544771f, -0.24718194f, 
    -0.51589459f, -0.67918384f, 0.66886622f, -0.12428243f, 0.05415717f, -0.17675523f, -0.16195954f, 0.01943913f, 
    -0.05192821f, -0.16065906f, 0.00341797f, 0.08172018f, 0.08109157f, 0.08024234f, -0.06096013f, -0.09419902f, 
    -0.01722876f, 0.05824055f, -0.04041389f, 0.02515865f, 0.09520718f, -0.75124496f, -0.19377379f, -0.10628623f, 
    0.18540701f, -0.06761137f, 0.06717008f, 0.10641665f, 0.07140978f, -0.02673867f, 0.01168135f, -0.00519531f, 
    0.01820647f, -0.09692106f, -0.07759978f, -0.02048524f, -0.04645189f, 0.04905319f, 0.08289561f, 0.07180151f, 
    0.08243948f, -0.01057258f, 0.18021348f, -0.26847047f, -0.04015901f, 0.11331406f, 0.17282030f, 0.07283757f, 
    0.10529777f, 0.05115227f, -0.06237308f, -0.09443143f, 0.10791277f, 0.06199284f, 0.08871147f, 0.04491619f, 
    -0.02807861f, -0.05814150f, 0.05070947f, -0.01693613f, -0.33104616f, 0.15828446f, 0.12058428f, -0.06040795f, 
    -0.31736979f, 0.01460548f, 0.18232077f, -0.02361243f, -0.10510813f, -0.08211059f, 0.06520557f, 0.10154566f, 
    0.05429625f, -0.00399038f, -0.01506501f, -0.03987397f, -0.01667978f, -0.24072313f, -0.08171703f, -0.04555278f, 
    -0.36050060f, -0.54052073f, -0.11294691f, 0.33823684f, -0.05400518f, 0.05148897f, 0.15880321f, 0.06833439f, 
    0.09706790f, 0.32669455f, 0.06417451f, -0.02612207f, -0.05002309f, -0.12281927f, -0.08538592f, -0.08220623f, 
    0.01756176f, -0.21188642f, 0.20756808f, -0.06768762f, 0.00381879f, 0.00712815f, 0.08746530f, -0.12740731f, 
    -0.05351869f, 0.00617918f, 0.06904779f, -0.08058442f, -0.06688622f, -0.09067971f, 0.11630658f, -0.00166623f, 
    -0.02937622f, -0.03804516f, -0.18177105f, -0.01228279f, -0.08130460f, -0.09418120f, 0.08254024f, -0.03116679f, 
    0.40530717f, -0.27239528f, -0.26360753f, 1.00336421f, -0.79538310f, -0.00117003f, 0.07399602f, -0.24438117f, 
    0.07543383f, 0.10959814f, -0.11611292f, 0.02260036f, 0.01883874f, 0.02613050f, -0.08929094f, -0.08395384f, 
    -0.01622988f, 0.05769563f, -0.15502073f, -0.06330210f, -0.00168309f, -0.46937293f, 0.00558709f, -0.17297541f, 
    0.37402543f, 0.02759547f, 0.02588921f, 0.24506414f, 0.18177570f, 0.05246225f, -0.07474668f, -0.04908627f, 
    -0.00766431f, 0.09034040f, -0.13569517f, -0.08365969f, 0.00831206f, -0.25051242f, 0.13490821f, 0.15377469f, 
    -0.48166728f, 0.44867763f, -0.81883520f, 0.48340487f, -0.06324104f, 0.14774382f, -0.05535213f, 0.10563173f, 
    -0.00641214f, -0.17116082f, 0.07878916f, -0.06141905f, 0.03550977f, -0.11515375f, -0.07521031f, 0.00043326f, 
    -0.15386364f, -0.03659639f, -0.35528952f, 0.04666463f, 1.15249038f, -0.66942561f, -0.19146083f, -1.30401337f, 
    -0.09558847f, 0.13069841f, 0.46042556f, -0.40368450f, 0.26351470f, -0.19590594f, 0.05104731f, 0.01392185f, 
    0.15090086f, -0.05455307f, 0.17315710f, -0.04829075f, -0.02284081f, -0.07866406f, 0.05691504f, 0.06110457f, 
    0.21040978f, 0.16750506f, -0.18810686f, -0.01035814f, -0.20014334f, 0.01148465f, 0.02165474f, 0.00784945f, 
    -0.11907984f, -0.11470799f, -0.34293914f, -0.48341396f, -0.29381311f, -0.00090468f, -0.24913074f, -0.00836316f, 
    -0.02900875f, 0.08650300f, -0.07521917f, 0.01334556f, 0.02690582f, -0.75031710f, 0.08997429f, 0.95208663f, 
    -0.07192830f, 0.09302941f, 0.05745691f, -0.27581951f, 0.22072756f, 0.34926006f, 0.10458896f, 0.00996217f, 
    -0.14866836f, -0.07992171f, 0.00149204f, 0.04797583f, 0.09551685f, -0.08059109f, 0.17419223f, 0.06247691f, 
    -0.52191001f, -0.38579112f, -0.64019376f, 0.48596552f, 0.16107860f, 0.10263199f, 0.09219869f, 0.15942593f, 
    0.04186414f, 0.19356839f, 0.15095794f, 0.05259367f, 0.13362925f, -0.04909045f, -0.00070651f, 0.10219400f, 
    0.09588902f, -0.12499739f, -0.37653950f, -0.12834275f, -0.86473465f, -0.95285738f, -0.94090253f, -0.06240801f, 
    -0.01667072f, 0.21652086f, -0.01884587f, 0.22240882f, 0.26800361f, 0.15678620f, -0.02874691f, 0.09832768f, 
    -0.07582736f, -0.10301954f, -0.06770912f, -0.11192472f, 0.01536938f, 0.03021204f, 0.06126130f, -0.26969942f, 
    1.20952809f, -0.62485313f, -0.53937948f, -0.37631273f, -0.26859313f, -0.01111513f, -0.06624481f, -0.14954011f, 
    -0.01279963f, -0.30889410f, -0.04925324f, -0.01041376f, 0.15033369f, 0.00508760f, 0.07509474f, -0.05079034f, 
    0.00096325f, -0.01703275f, 0.03292203f, -0.08027529f, -0.37246278f, -0.21928701f, 0.28976753f, 0.16892602f, 
    0.04182273f, 0.06835286f, 0.15121295f, 0.14462592f, 0.01119899f, 0.02995016f, -0.19264060f, -0.07493238f, 
    0.01508112f, 0.05008347f, 0.00587857f, 0.00919541f, 0.00333500f, -0.05652768f, -0.05518772f, -0.01499615f, 
    0.08664403f, -1.04572034f, 0.02978222f, 0.30741337f, 0.47536734f, 0.01163856f, 0.29450241f, 0.21570851f, 
    0.03478670f, -0.05270374f, 0.08471009f, -0.08799158f, 0.10792223f, 0.13229018f, 0.15778829f, 0.05310762f, 
    0.05704784f, -0.20942420f, -0.03448749f, -0.08394267f, 0.37751323f, -0.81038111f, -1.07967067f, 0.03563741f, 
    0.01600252f, 0.10011461f, -0.01030887f, 0.29025012f, -0.07089948f, -0.08485320f, -0.05486291f, -0.14110793f, 
    -0.01302962f, -0.03291937f, 0.01641862f, 0.00883630f, 0.05445673f, 0.04199868f, 0.17179708f, 0.03798491f, 
    -0.20022297f, -0.39839619f, -0.21544890f, -0.10059727f, -0.01701330f, -0.12589844f, -0.04988087f, -0.06339201f, 
    0.00372436f, 0.15246403f, -0.04111869f, 0.00380625f, 0.14040293f, -0.01443202f, 0.00523078f, -0.11710749f, 
    0.05962601f, 0.04820466f, 0.03738451f, 0.11332405f, -0.77701366f, 0.36314446f, 0.36866206f, 0.23131217f, 
    -0.19964962f, -0.05104375f, -0.18823119f, -0.19969150f, -0.05601587f, -0.23841704f, -0.14820661f, -0.12632588f, 
    -0.06348296f, -0.12406304f, -0.16282417f, -0.34903830f, -0.13358982f, -0.31835800f, -0.10162099f, -0.19846973f, 
    -0.03245302f, -0.34457794f, -0.28779742f, -0.33660632f, -0.15488246f, 0.11574727f, -0.41908187f, -0.00272913f, 
    -0.21415232f, -0.47243181f, -0.01584411f, 0.03054507f, 0.04129836f, -0.01191866f, 0.08352590f, 0.10360109f, 
    -0.01463825f, 0.11650744f, -0.25320813f, -0.15731677f, -0.02015422f, 0.06322873f, 0.04018645f, 0.00106392f, 
    -0.10574941f, -0.03734273f, -0.09702400f, -0.17243963f, 0.00111733f, 0.01289654f, -0.05654324f, -0.09363503f, 
    -0.03322436f, 0.03945098f, 0.07081816f, -0.04856791f, 0.12601233f, 0.12022654f, -0.06190952f, 0.11953786f, 
    1.24897861f, 0.13240002f, 0.12876971f, -0.29701012f, 0.00693744f, 0.12227567f, -0.05379961f, -0.10220470f, 
    0.08418954f, -0.32971078f, 0.05993265f, 0.07133467f, 0.14327340f, 0.06945003f, 0.10387164f, 0.05410137f, 
    -0.01284856f, -0.11453492f, -0.11973929f, -0.11416750f, -0.15957804f, -0.30071941f, 0.21328746f, 0.29983488f, 
    0.21467569f, -0.16440943f, -0.14418723f, -0.14226317f, -0.09758441f, -0.19121209f, 0.02464920f, -0.13840045f, 
    -0.06849844f, -0.01165937f, -0.07971273f, -0.02264435f, -0.15268354f, 0.01119627f, -0.18425457f, -0.12420294f, 
    0.40036768f, -0.52573335f, -0.44715506f, 0.01154360f, 0.40662354f, 0.13376223f, 0.25982663f, 0.17732932f, 
    0.23629975f, -0.10810412f, 0.08277402f, -0.11091875f, 0.01720175f, -0.04795455f, -0.03065788f, 0.03718459f, 
    0.02317154f, -0.02548926f, -0.00301338f, -0.07313222f, -0.19092907f, -0.46079093f, -1.88842118f, -0.45913258f, 
    -0.11021483f, -0.13445613f, 0.10469159f, 0.36399475f, 0.15011834f, 0.12983105f, 0.15220280f, -0.08305398f, 
    -0.03881634f, 0.08205947f, 0.07646629f, 0.04366950f, 0.08720645f, -0.00367251f, 0.00764291f, 0.05924669f, 
    -0.13220501f, -0.06807216f, -0.15463473f, -0.09408178f, -0.17290430f, -0.14105327f, 0.06709826f, -0.00459222f, 
    0.01522592f, -0.12184620f, 0.09608488f, 0.17118967f, 0.01982769f, 0.19135863f, 0.20351429f, 0.11390486f, 
    0.16939910f, 0.05232851f, 0.23649301f, -0.01421609f, 0.32680598f, 0.04865047f, -0.15891071f, -0.51171869f, 
    -0.09328248f, -0.13829030f, -0.48226252f, -0.31296274f, -0.21596558f, -0.35464942f, 0.04856627f, 0.07659138f, 
    0.06491407f, 0.07824983f, 0.03907080f, 0.07209893f, -0.02699938f, 0.05396170f, -0.18983668f, -0.53035808f, 
    0.12199050f, -0.20585456f, -0.21674784f, 0.27651632f, -0.04981825f, -0.22678716f, -0.08571929f, 0.02210181f, 
    0.07703833f, -0.22223285f, -0.07968652f, 0.13334209f, 0.00944406f, -0.04625557f, -0.08098657f, -0.14719553f, 
    0.11862915f, 0.17627507f, 0.16004671f, -0.01460105f, 0.33892751f, -0.86204499f, -1.14617860f, -0.55136204f, 
    0.31870496f, 0.05477847f, -0.16058019f, 0.16856889f, -0.10356075f, 0.09214105f, -0.01745332f, -0.05719076f, 
    -0.00984436f, 0.05966979f, 0.07538633f, 0.04101926f, -0.01147814f, 0.09776935f, -0.18611756f, 0.06612539f, 
    0.27445343f, -0.71100175f, -0.91334087f, -0.21770290f, 0.17049451f, 0.03307373f, 0.09356890f, 0.17569451f, 
    0.10576884f, 0.16841196f, 0.07844918f, 0.00488976f, -0.07896180f, -0.04517221f, -0.03833746f, -0.00597707f, 
    -0.00588122f, 0.03800399f, -0.08743788f, -0.00276424f, 0.55318433f, -0.21123773f, 0.02715701f, -0.01744026f, 
    -0.27907872f, -0.06366193f, -0.33810925f, -0.40207237f, -0.33958411f, -0.13308349f, -0.03084435f, 0.34526768f, 
    0.01872233f, -0.05900270f, 0.11391929f, 0.00107112f, 0.23539186f, 0.17349942f, 0.33365712f, 0.24212760f, 
    0.05388542f, -0.16897705f, 0.17087182f, -0.52027869f, -0.60959077f, -0.16743146f, -0.28758126f, -0.13300823f, 
    0.24282674f, 0.02567558f, -0.07466742f, 0.06398940f, 0.03570805f, 0.21893829f, -0.09015802f, 0.04215384f, 
    0.09900462f, 0.13688424f, 0.04970479f, 0.15820862f, -0.39852843f, -0.10109017f, 0.08106463f, 0.29870963f, 
    -0.45436534f, -0.09560440f, -0.39831248f, 0.12765586f, -0.16329584f, 0.15062574f, 0.01513937f, 0.01777450f, 
    0.01685026f, 0.02794099f, -0.05318800f, -0.04700620f, 0.04368053f, 0.13914250f, 0.00754563f, -0.12631094f, 
    0.03130962f, 0.06195851f, 0.51313668f, 0.01891996f, 0.14823820f, 0.09569045f, -0.15987931f, -0.31775096f, 
    -0.20804624f, -0.15774752f, -0.17457525f, 0.11699796f, 0.06641095f, -0.03397580f, 0.05996788f, 0.01861605f, 
    -0.14255713f, -0.25017759f, -0.06603516f, 0.02846072f, -0.19802618f, 0.01705914f, -1.26947320f, 0.17603625f, 
    0.16233565f, 0.00782832f, 0.06228290f, 0.37412217f, -0.04245329f, 0.04208196f, -0.00221336f, -0.04173344f, 
    -0.07864955f, 0.04266557f, -0.08631667f, 0.09887060f, 0.16263948f, -0.09549638f, 0.03506698f, 0.01826094f, 
    0.16128346f, -0.07075400f, -0.31238633f, 0.03940480f, -0.03814499f, 0.03040915f, -0.10073740f, -0.11038370f, 
    -0.24365743f, 0.39853117f, 0.06891003f, -0.00087173f, 0.01829567f, -0.01007006f, -0.05028171f, 0.06389719f, 
    -0.00834569f, 0.28211045f, 0.14040817f, -0.06664543f, 0.03522086f, -0.27305451f, -0.00640354f, -0.31024244f, 
    0.03193969f, 0.08215330f, 0.14644325f, -0.02508915f, -0.00763553f, -0.02586515f, 0.02789302f, 0.05222468f, 
    -0.00600963f, -0.07199971f, -0.15230483f, 0.15927151f, 0.06639894f, -0.05481731f, -0.14830293f, -0.09837210f, 
    -0.70817161f, 0.29760522f, -0.82452649f, 0.04470316f, -0.43012056f, -0.04409595f, -0.05542416f, -0.01058632f, 
    -0.33216658f, 0.12797599f, 0.13338611f, -0.06524848f, -0.04892683f, -0.07288413f, -0.04624907f, 0.23920669f, 
    -0.03967363f, 0.01387851f, 0.05969165f, -0.18179955f, 0.04904491f, -0.21672636f, 0.19481070f, 0.35055190f, 
    -0.02741969f, -0.14886566f, 0.04796606f, -0.40295544f, 0.19771729f, -0.23844410f, 0.02882615f, 0.04079635f, 
    0.23742290f, 0.03597323f, -0.02471416f, 0.11757146f, 0.15081185f, 0.07211966f, -0.05223086f, 0.31271657f, 
    -1.09672761f, 0.79390216f, -0.69051325f, -0.11477903f, -0.71742374f, 0.11210264f, -0.38824296f, -0.26761326f, 
    -0.45413560f, -0.05849274f, 0.02526615f, 0.05937933f, -0.19046126f, -0.05304252f, 0.16185026f, -0.17495543f, 
    -0.11238284f, 0.11814173f, 0.09943870f, -0.03813610f, -1.13581717f, 0.05716754f, -0.47399369f, 0.54389864f, 
    -0.80231625f, -0.39538994f, 0.31521291f, -0.64432180f, 0.02384295f, -0.25224814f, 0.14329600f, -0.14232188f, 
    -0.00625384f, 0.08604067f, 0.12498008f, 0.07417826f, 0.02522879f, -0.00286619f, -0.10416053f, -0.14691110f, 
    -0.37242618f, 0.31251258f, -0.21001218f, 0.13750972f, 0.00326477f, 0.02117376f, -0.03161822f, -0.07717513f, 
    -0.19989082f, -0.31517217f, 0.13218196f, 0.22003470f, -0.15326937f, 0.03449792f, 0.03439040f, 0.14425994f, 
    0.12385309f, -0.36886525f, 0.05840330f, 0.04887467f, -0.20665388f, -0.25599417f, -0.55600804f, 0.22926685f, 
    -0.62385845f, 0.09942017f, -0.12137734f, 0.15845564f, 0.09500490f, 0.22090895f, 0.07180548f, 0.08473732f, 
    0.06830204f, 0.06052553f, -0.04433546f, -0.02204423f, -0.00924191f, 0.00223421f, 0.43594548f, 0.14313777f, 
    0.14438206f, 0.35708547f, 0.49213141f, -0.40261588f, -0.23563762f, -0.02988859f, -0.24039026f, 0.18682374f, 
    0.22387038f, 0.18812162f, -0.04951757f, 0.04305848f, -0.04740267f, -0.16811465f, -0.14456055f, 0.05150567f, 
    -0.00611732f, -0.06683309f, -0.07825187f, -0.23015107f, -0.19260602f, -0.50889421f, 0.89155912f, 0.16762231f, 
    -0.98396367f, 0.09603885f, -0.48354727f, 0.04288496f, 0.35740337f, 0.52572477f, -0.08676318f, 0.03636601f, 
    -0.03138902f, -0.05849910f, -0.14191300f, -0.01594344f, 0.08792851f, 0.04822034f, 0.05762950f, 0.12309232f, 
    0.16430978f, 0.28867221f, 0.63933903f, 0.59821832f, -0.52183455f, 0.01923593f, -0.07010035f, -0.51516449f, 
    -0.14532354f, -0.07112438f, 0.18248256f, -0.14909679f, 0.18969969f, 0.12220738f, 0.12516165f, 0.07943922f, 
    -0.07526546f, 0.03302492f, 0.04011031f, -0.00044647f, 0.41592702f, -0.05388628f, -0.00770434f, 0.20679319f, 
    -0.33452439f, -0.04797748f, 0.01450147f, 0.11299287f, -0.07568000f, 0.02466043f, -0.03805884f, 0.08467051f, 
    -0.16849339f, -0.19699743f, -0.06042939f, 0.11561634f, -0.11737095f, -0.15283094f, -0.39731646f, -0.32223785f, 
    -0.40736738f, 0.37798753f, 0.42530626f, 0.20575897f, 0.18856113f, 0.29102480f, -0.08668122f, -0.11419965f, 
    -0.05644915f, 0.01865720f, -0.13593911f, -0.06293187f, -0.15639661f, -0.06946611f, 0.06706370f, -0.11990446f, 
    0.01630473f, 0.18802387f, -0.07973135f, 0.00403775f, -0.78136396f, 0.01758453f, 0.11516861f, 0.17202821f, 
    0.15602197f, -0.20718348f, 0.01854870f, -0.49604043f, 0.28824854f, -0.06652318f, -0.01384541f, -0.01059394f, 
    0.12931988f, 0.10077124f, 0.05947462f, -0.00698573f, 0.07818925f, -0.32476270f, 0.17949080f, -0.18893664f, 
    -0.15547809f, 0.10067927f, 0.03223432f, 0.35817319f, 0.09431733f, -0.13434838f, 0.10718369f, -0.21235630f, 
    -0.19088742f, -0.02599725f, -0.25016037f, -0.10864973f, -0.13801652f, -0.08831888f, -0.16964836f, 0.04409459f, 
    0.01762443f, -0.08706547f, 0.04156910f, 0.20236471f, -0.10908465f, -0.49228239f, -0.27002144f, -0.08588443f, 
    0.15939113f, -0.15976147f, -0.24775088f, 0.12693864f, -0.46380767f, -0.37936804f, -0.24075404f, 0.14779085f, 
    -0.07385443f, -0.03803379f, 0.00773532f, 0.04795874f, -0.30991328f, -0.17234629f, -0.11011340f, -0.15051207f, 
    -0.21793911f, -0.18331198f, -0.45432740f, -0.30061808f, 0.02250784f, -0.05301754f, -0.15268521f, 0.38477680f, 
    -0.12293866f, -0.14632168f, 0.00214994f, 0.16044590f, -0.03118432f, -0.07480244f, -0.16053700f, 0.07659530f, 
    -0.08425408f, -0.04713329f, -0.24758378f, -0.16772982f, -0.29406133f, -0.14232951f, -0.46974096f, 0.39306101f, 
    -0.20422885f, 0.01466560f, -0.10812283f, 0.13208057f, 0.42008042f, 0.15093687f, -0.27124459f, -0.03132168f, 
    -0.03451210f, -0.21472500f, 0.06844033f, -0.08555934f, -0.05437809f, 0.02759053f, 0.36890742f, 0.31462383f, 
    0.21750091f, -0.10445455f, 0.17872398f, -0.13419233f, 0.29742479f, -0.13786720f, 0.08093692f, 0.46644163f, 
    0.22760837f, 0.01363918f, -0.11812405f, 0.17430726f, -0.10717103f, -0.03463637f, 0.17311358f, 0.10692237f, 
    -0.15588282f, 0.08616409f, -0.18451528f, -0.19524996f, -0.02828605f, 0.21112420f, 0.06676342f, 0.09562602f, 
    -0.03350902f, 0.20151711f, -0.26977938f, -0.11644017f, -0.15206645f, -0.13446595f, -0.23169024f, 0.09662682f, 
    -0.13701202f, -0.15536264f, -0.14459780f, 0.00310316f, -0.04383016f, -0.06824005f, -0.12536414f, -0.20324838f, 
    -0.05609719f, -0.17918752f, 0.21863960f, 0.21154957f, 0.05267658f, -0.23070565f, 0.09954887f, 0.61618304f, 
    0.14330283f, -0.16838071f, -0.03018550f, -0.12907344f, -0.02011388f, 0.15948536f, 0.04390619f, -0.16692913f, 
    -0.08847698f, 0.18054873f, -0.06670794f, 0.17554541f, 0.12891676f, 0.33212250f, 0.05090128f, -0.36453316f, 
    0.14969015f, 0.33078617f, -0.18556392f, -0.04085074f, -0.07161752f, 0.08070412f, -0.32327977f, 0.17275280f, 
    0.04680600f, -0.05730826f, -0.01838733f, 0.01846298f, 0.11763236f, -0.14754680f, -0.03814274f, 0.03145429f, 
    0.21474683f, -0.93655002f, 0.37205032f, 0.01177598f, -0.59428382f, -0.28610298f, 0.02378639f, 0.27851939f, 
    -0.16631186f, -0.08080615f, -0.01575504f, -0.34575433f, 0.13082647f, 0.24318777f, 0.15988678f, -0.09225363f, 
    0.13698865f, 0.22166488f, 0.08899082f, 0.12531249f, -0.35973299f, 0.10202847f, -0.35778320f, -0.11565707f, 
    0.12818544f, 0.12646265f, -0.02571085f, 0.00663737f, -0.15163206f, 0.09161286f, -0.19918711f, 0.08357485f, 
    0.02692853f, 0.08652346f, 0.00209985f, 0.25153339f, -0.26394817f, -0.18720375f, -0.20079024f, -0.25387472f, 
    -0.72109830f, -0.19459710f, 0.24866049f, 0.00689711f, -0.11050255f, -0.05035603f, -0.18711723f, 0.11452858f, 
    0.04350021f, -0.20134450f, -0.27865407f, -0.02684172f, 0.21347837f, -0.02373667f, -0.19084892f, 0.20982234f, 
    0.19143637f, 0.12586069f, 0.20031066f, 0.46000278f, -0.56547332f, 0.20085347f, -1.08248854f, 0.30103973f, 
    0.06614173f, 0.01273923f, -0.27657101f, -0.31174639f, 0.02034905f, 0.10422797f, -0.00654886f, 0.06869002f, 
    -0.20166205f, -0.00162227f, 0.08384044f, 0.04030716f, -0.03341111f, -0.21265222f, -0.15523919f, -0.06777683f, 
    0.14536096f, 0.00428471f, -0.00851138f, 0.02854214f, 0.18664059f, 0.07212932f, 0.09688141f, -0.03563949f, 
    0.13708474f, 0.05774700f, -0.04699774f, 0.24169925f, -0.03349589f, -0.15697376f, -0.17573692f, 0.04870906f, 
    -0.03745610f, -0.08713153f, 0.17346789f, 0.08061700f, -0.86691517f, -0.22534154f, -0.37549713f, 0.06961944f, 
    -0.22495417f, 0.03895436f, 0.01670454f, 0.31273916f, -0.03821589f, 0.14035712f, 0.00786445f, 0.09944775f, 
    -0.00885939f, 0.19580480f, -0.03833609f, -0.02700123f, 0.18824448f, 0.18761942f, 0.21445008f, 0.50549781f, 
    -0.88794941f, 0.43747488f, -0.74970847f, 0.41008198f, -0.07639819f, 0.01468239f, 0.12903325f, 0.04234514f, 
    0.23983485f, -0.00620750f, -0.17027044f, 0.03201611f, -0.05321978f, -0.01935580f, 0.17425287f, 0.02266666f, 
    0.01679786f, 0.16242021f, -0.08806279f, 0.23145249f, 0.15785153f, -0.21626683f, 0.07781763f, -0.34647200f, 
    -0.23936282f, -0.06409963f, -0.43680999f, -0.21572411f, 0.02347488f, -0.15735109f, 0.00901130f, 0.01133866f, 
    0.09641863f, -0.06708267f, 0.06602669f, 0.18179964f, 0.05289228f, 0.01933292f, 0.00599892f, -0.05240485f, 
    -0.24597748f, -0.03267670f, -0.40211597f, 0.38560981f, 0.12840827f, -0.07646117f, -0.05380846f, 0.25994927f, 
    0.03985766f, 0.23838319f, -0.03866929f, -0.13422920f, -0.08598914f, -0.09213798f, -0.11362088f, -0.06504878f, 
    -0.10308404f, 0.04822602f, -0.11906200f, -0.51228458f, 0.82108885f, -0.04368210f, 0.70738596f, -0.05354501f, 
    -0.26338625f, -0.10743733f, 0.00603620f, -0.23491475f, 0.00201425f, 0.03283558f, -0.15042780f, -0.02389612f, 
    -0.05754293f, -0.12373059f, -0.10330460f, -0.07873643f, 0.06679114f, 0.00049919f, 0.08733940f, 0.18673791f, 
    -0.07462763f, -0.45977184f, -0.40903431f, -0.17815249f, 0.23957671f, -0.01896308f, -0.64885056f, -0.14713490f, 
    0.00011912f, -0.06813832f, 0.05239153f, 0.04831780f, 0.06563424f, -0.04093793f, -0.06004533f, 0.08706743f, 
    -0.03681637f, -0.16355222f, 0.16455373f, 0.02426235f, -0.02120654f, 0.19926645f, 0.26666468f, 0.35080868f, 
    -0.37207037f, -0.19524920f, 0.06086253f, 0.19925125f, 0.20975974f, -0.12760599f, -0.17260501f, -0.11759918f, 
    0.05089559f, -0.01799589f, -0.05606884f, 0.16959912f, -0.05877529f, -0.12190787f, -0.14913560f, -0.17693819f, 
    -0.11814822f, -0.46558198f, 0.20929347f, -0.11166511f, 0.15435918f, 0.11804360f, -0.23631471f, -0.16637547f, 
    0.07643456f, 0.09900334f, -0.02356026f, 0.17234306f, -0.01519920f, 0.19239660f, -0.01823750f, 0.05528725f, 
    0.17717670f, 0.18045300f, 0.01086334f, 0.25886905f, -1.09865546f, 0.56846684f, -0.57399243f, 0.34000498f, 
    -0.34711146f, 0.20283313f, 0.24114470f, 0.17123045f, -0.11295006f, 0.12456792f, -0.12192681f, 0.00370219f, 
    0.29648745f, 0.30266163f, 0.09311498f, 0.08004369f, 0.09989918f, -0.02724150f, 0.05838164f, 0.13759191f, 
    0.51283962f, -0.54155952f, 0.69632941f, -0.77788186f, 0.21468027f, 0.11267735f, -0.13326444f, -0.23916885f, 
    0.39335093f, -0.05357407f, 0.00640515f, 0.17496137f, -0.08025698f, -0.06514221f, 0.03247108f, -0.04718313f, 
    0.32548815f, 0.00386060f, 0.35413662f, -0.14395830f, -0.99059784f, -0.30833632f, -0.49727511f, 0.77150774f, 
    -0.74759704f, 0.21988307f, -0.05481101f, 0.12986515f, -0.29248098f, 0.18544573f, 0.00633869f, -0.16479254f, 
    -0.08920950f, 0.13352764f, -0.02390729f, -0.00384334f, -0.15658639f, 0.04088775f, 0.03862374f, -0.02478054f, 
    0.00214860f, -0.14581449f, 0.29318836f, -0.27525192f, 0.07344635f, 0.14067714f, 0.32738242f, -0.05425829f, 
    0.27081624f, -0.01997340f, -0.12993635f, 0.16120459f, 0.09022789f, 0.01749863f, 0.14454086f, -0.17169745f, 
    -0.14520282f, -0.07710751f, -0.28307408f, -0.10585786f, 0.05773479f, -0.54837799f, -0.21908107f, -0.04878158f, 
    0.10723072f, -0.13875991f, -0.44915208f, 0.27892578f, -0.16274187f, -0.33660063f, 0.06413091f, 0.03673548f, 
    0.10239443f, -0.12434258f, 0.00942155f, 0.09281810f, 0.06936871f, 0.04877885f, -0.08859961f, -0.06839178f, 
    0.02713762f, -0.39685386f, -0.23696400f, 0.43282926f, 0.34278283f, -0.39253777f, 0.11455715f, -0.04639867f, 
    -0.22129165f, -0.11926600f, 0.07198600f, 0.21868603f, 0.13830899f, -0.08447997f, 0.13431659f, -0.07319757f, 
    -0.22428553f, -0.02073310f, 0.05071132f, -0.07197013f, 0.13561851f, -0.25069010f, -0.17776054f, -0.03880573f, 
    -0.51440966f, -0.12140388f, -0.24081591f, -0.08116735f, 0.08908829f, -0.11498278f, -0.01615025f, 0.11943223f, 
    0.19602880f, -0.07191774f, -0.12205475f, 0.05896412f, -0.02337323f, 0.12442379f, 0.27186641f, -0.02826129f, 
    -0.34125707f, -0.24020368f, -0.18491544f, 0.21788426f, -0.40917164f, -0.04157735f, -0.14710741f, -0.08698501f, 
    -0.09679754f, 0.08710677f, 0.05356242f, -0.01832783f, -0.07188583f, -0.24376921f, -0.14335397f, -0.10431977f, 
    -0.05993405f, -0.08663170f, 0.02919544f, -0.06506544f, 0.03525263f, 0.38956505f, -0.05152162f, 0.47755262f, 
    -0.26938632f, -0.15566617f, -0.30478144f, 0.04152162f, -0.24157901f, -0.23343717f, -0.23883148f, 0.08531809f, 
    -0.14469068f, 0.00796747f, -0.04806009f, 0.05273697f, -0.26597083f, -0.04573849f, -0.08377881f, -0.13362516f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.37322390f, 0.25175104f, 0.08586228f, -0.17860502f, -0.19910599f, 0.05593598f, 0.07950026f, -0.17747684f, 
    0.05144964f, 0.06066890f, -0.02302082f, -0.01346705f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
