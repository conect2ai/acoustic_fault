#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.35663474f, 0.71920365f, 1.16928172f, 0.60457838f, 0.46452600f, 0.86776239f, -0.58425194f, -0.03075115f, 
    0.21911420f, 1.15027523f, 0.82290274f, 0.80784094f, 0.44825533f, -0.61002886f, -0.03655108f, -0.29860348f, 
    0.04004913f, 0.16983896f, -0.34504309f, 0.92001206f, -0.82910591f, -0.61568677f, -0.35269070f, -1.02151704f, 
    0.64521259f, -0.00207794f, -0.53184235f, 0.58430225f, -0.61387682f, -0.99865305f, 0.29051575f, -0.98637986f, 
    0.31403166f, -0.58666170f, 0.14266245f, 0.57106918f, -0.86430752f, 0.31088635f, -0.84671336f, -0.63840896f, 
    -0.27172300f, -0.77808082f, -0.31458837f, -0.17082977f, 0.55434656f, 0.56776530f, 0.87800676f, 1.18732977f, 
    -0.89368600f, 1.06806517f, -0.17606805f, 0.02279502f, 0.50289291f, -0.36800495f, 1.39500964f, -0.15497172f, 
    0.87017244f, -0.56375313f, -0.19446866f, 0.00655861f, 0.22766459f, 0.26846895f, -0.30286142f, -0.71812111f, 
    -0.17910516f, 0.55892819f, -0.83714044f, 0.09340488f, 0.63528258f, -0.01677580f, -0.86150914f, -0.21949783f, 
    1.24142158f, -0.32616201f, -0.89145380f, 0.44532681f, 0.48227009f, -0.86443079f, -0.06835005f, -0.11114562f, 
    0.49073470f, -0.93299001f, -0.88660097f, -0.89292192f, 0.19295463f, -0.54725111f, -0.76631969f, -0.22687222f, 
    -0.03155944f, -0.18240553f, 0.18858364f, 0.06928118f, 0.89893311f, -1.08024931f, -1.12096751f, -0.26982731f, 
    -0.32273290f, 0.28340873f, -0.16328622f, -0.92756379f, -1.09759927f, -0.82221383f, -0.25282797f, -0.17741247f, 
    0.78135568f, 0.04133643f, 0.01919380f, -0.16746829f, -0.02390768f, -0.35660520f, 0.08867814f, 0.82157415f, 
    1.06539464f, -0.92983085f, -0.11790603f, -0.39642841f, -0.39882156f, -1.09698403f, 0.82650357f, 0.85413730f, 
    0.71727765f, 0.71773189f, -0.84529650f, 0.14168632f, -0.09085322f, 0.51972562f, 0.96860206f, -1.08275580f, 
    -0.74300098f, 0.91978937f, 0.05918640f, -0.56821042f, -0.43334812f, -0.06809884f, -0.48402169f, 0.45674047f, 
    0.56753397f, -1.26810038f, -1.09880495f, 0.48553640f, 0.88982075f, -0.00086359f, -0.46444696f, 0.16937795f, 
    -0.48317659f, -1.16193640f, -0.56202799f, -0.31635666f, 0.52937579f, 0.47923240f, -0.64482021f, -0.17579842f, 
    -0.31741184f, 0.18808027f, -0.74775004f, -0.58339792f, -0.11997026f, -0.36436763f, -0.68610775f, 0.19039500f, 
    0.86017001f, 0.05536936f, 0.92433041f, 0.70435470f, -0.90781766f, -0.69806105f, 0.30341589f, -1.04543376f, 
    0.31566352f, 0.42912751f, 0.39044327f, 0.89284265f, 0.04870766f, -1.22460699f, 0.48491740f, -0.16618994f, 
    0.47278604f, -0.24847382f, -0.04756300f, 0.07875238f, 0.68777466f, 0.80092406f, 0.03950450f, -1.05011988f, 
    -0.99602264f, -0.45630360f, 0.34067661f, 0.06887228f, 0.37929991f, -0.96126854f, -1.16248989f, 0.35290167f, 
    0.67484146f, 0.48623842f, -0.36539036f, 0.01068709f, 0.10669480f, -0.35088298f, -1.15325546f, 0.97435880f, 
    -0.36025131f, 0.01707651f, 0.60001683f, -0.04054326f, -0.55746090f, 0.70632827f, 0.15492357f, -0.52680796f, 
    -1.09487593f, -0.76681596f, 0.42303303f, 1.08995116f, 0.52438992f, -0.22841626f, -0.06535252f, -0.18277776f, 
    0.03335360f, 1.45915985f, -0.13689417f, 0.63450992f, -0.61638200f, -0.71603054f, -0.28849730f, -0.42002863f, 
    -0.39732274f, 0.44707325f, -0.12313581f, -0.40514651f, 0.04382809f, 0.89721286f, 0.95707726f, 0.36146277f, 
    -0.29294613f, 0.64715958f, -0.33743757f, -1.23520446f, 0.69500321f, -1.18901932f, 0.78727549f, -0.61508292f, 
    0.29680762f, -0.25484288f, 0.08854220f, 0.18419126f, -1.47465491f, 0.38571817f, 0.75930125f, 0.12691653f, 
    0.73702204f, -0.19458558f, -0.22328059f, -0.47713837f, 0.98708808f, 1.12817800f, -0.32925472f, 0.65825695f, 
    0.59799528f, 0.57345861f, -0.15976705f, 0.26736319f, -0.22229460f, 0.88605046f, 1.29517031f, 0.40234819f, 
    -0.40591881f, 0.32091299f, 0.31750977f, -0.10165008f, -0.49327141f, -0.35710096f, -0.48302358f, 0.23026954f, 
    -1.18095374f, 0.51539284f, -0.93394965f, -0.52536416f, 0.28426838f, 0.26459438f, 0.46252880f, -0.80551594f, 
    -0.96576768f, 0.02416664f, 0.17732927f, 0.41096094f, 0.96089691f, 0.59348714f, 0.34350902f, 0.15922475f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.11395895f, 0.12021434f, 0.15931344f, 0.01253881f, 0.11917854f, 0.10464492f, 0.05455662f, 0.19522078f, 
    0.10330786f, 0.04822921f, -0.09354126f, 0.00273693f, -0.01245193f, -0.03870788f, -0.08360671f, -0.00098751f, 
    -0.13377285f, 0.24157752f, 0.18608645f, 0.11407435f, 0.10239632f, 0.05449559f, -0.19408563f, 0.18505046f, 
    -0.19618832f, 0.07296465f, 0.03525443f, 0.15369257f, 0.45741820f, 0.07651668f, -0.00042699f, 0.05464887f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.10506110f, 0.08564030f, 0.29942501f, 0.23928189f, 0.16790819f, -0.06328908f, 0.03628317f, 0.08462861f, 
    -0.01148764f, -0.03348899f, 0.07268035f, -0.07332921f, -0.01547832f, -0.10718472f, 0.04791460f, 0.06569079f, 
    -0.09853137f, -0.03779548f, 0.00071954f, 0.09822457f, 0.21738128f, -0.01235525f, 0.09312309f, -0.26932910f, 
    0.07320114f, -0.06598991f, -0.19465381f, -0.09951416f, 0.05021493f, 0.03605302f, -0.08935351f, -0.13049240f, 
    -0.13459192f, 0.04177826f, -0.06342184f, 0.10093629f, 0.06050635f, -0.02054828f, 0.03238446f, 0.07642081f, 
    -0.16353317f, -0.05079087f, 0.16284420f, 0.10636545f, 0.17497255f, -0.06601933f, -0.00481709f, 0.10156166f, 
    -0.04533677f, 0.10867444f, 0.08310787f, 0.09426261f, -0.08891895f, -0.00387259f, 0.02778932f, -0.01138574f, 
    -0.07335595f, 0.15506792f, 0.02482250f, -0.20838882f, 0.32778746f, -0.61163050f, 0.08306436f, 0.10613798f, 
    -0.24869066f, 0.12583308f, 0.10518909f, 0.11204173f, -0.08514988f, -0.24983396f, -0.10877125f, 0.14351512f, 
    -0.14447545f, 0.10540283f, 0.14627381f, 0.05228353f, -0.06561481f, 0.10154880f, -0.25227329f, -0.10936377f, 
    -0.11150123f, -0.18220538f, 0.02809592f, 0.00529497f, -0.07048987f, -0.00446654f, -0.11877259f, -0.01478516f, 
    0.00839198f, 0.08213675f, 0.12710607f, 0.02139813f, -0.08937722f, 0.03202884f, -0.07711975f, -0.08873410f, 
    -0.12912141f, 0.05366007f, -0.03599093f, -0.03839536f, 0.21030737f, 0.10533886f, -0.06221228f, -0.17206344f, 
    0.10253271f, -0.11365803f, -0.12915580f, -0.12635483f, 0.03518701f, -0.03086329f, 0.01649160f, 0.06520357f, 
    0.05063809f, -0.08876074f, 0.08197590f, -0.03210644f, 0.03321463f, -0.02214504f, -0.02276571f, -0.15241052f, 
    0.38766521f, 0.01761030f, -0.14493671f, -0.09119763f, -0.10436992f, -0.12276136f, -0.10365800f, -0.04302651f, 
    0.08961185f, -0.07549633f, -0.16195476f, 0.02411432f, -0.03510483f, 0.04420373f, 0.05968604f, -0.05819651f, 
    -0.06458166f, -0.01648448f, 0.03495574f, 0.04365977f, -0.27592367f, 0.11259938f, -0.07706100f, 0.10703517f, 
    0.11037075f, -0.17169079f, -0.08656492f, -0.08801310f, 0.04477862f, 0.02720304f, 0.05013715f, 0.04258943f, 
    -0.00755081f, -0.01224748f, 0.00332528f, 0.00407495f, -0.04615306f, -0.09794195f, 0.13120292f, 0.00377598f, 
    -0.09599293f, -0.15599726f, 0.14132948f, 0.08715677f, 0.29716328f, -0.11261385f, -0.13223773f, -0.02461307f, 
    0.15188012f, 0.01524081f, -0.06956676f, 0.09274784f, 0.01665817f, 0.05722771f, -0.15889560f, 0.02854463f, 
    -0.07632556f, -0.03724379f, -0.06292127f, -0.04217471f, -0.09665988f, -0.54397827f, -0.17867120f, 0.09829043f, 
    -0.15589622f, 0.16727182f, -0.15512317f, 0.02632618f, 0.01866203f, 0.01606942f, 0.00423563f, -0.15327775f, 
    -0.10684103f, 0.02403032f, 0.01431896f, 0.07096636f, -0.00810189f, 0.04144908f, 0.00656370f, 0.04994210f, 
    0.22050616f, -0.04008025f, -0.14806354f, 0.15364611f, 0.03443977f, 0.06054041f, -0.07043439f, -0.06432826f, 
    0.04354077f, 0.03983045f, -0.07467650f, -0.11660043f, -0.04339909f, -0.06221224f, 0.00508162f, -0.00079296f, 
    0.11219033f, -0.05471908f, 0.09860504f, 0.08326548f, -0.16493022f, 0.10230467f, -0.14378335f, -0.11772078f, 
    -0.39320466f, -0.02016884f, 0.08948062f, -0.17300881f, 0.04537335f, 0.08115304f, 0.05395379f, -0.00445923f, 
    -0.01368511f, 0.02610978f, -0.07829543f, 0.08883619f, -0.15828116f, 0.05622491f, 0.04178400f, 0.06737147f, 
    -0.03808172f, 0.21586359f, 0.30359587f, 0.07494157f, -0.12387112f, -0.06092532f, 0.05056493f, 0.01821648f, 
    0.03657321f, -0.11500458f, 0.00020980f, 0.06438233f, -0.09303913f, 0.10911950f, -0.03766699f, 0.09519417f, 
    -0.14578614f, 0.02129120f, -0.10339258f, 0.05182971f, 0.14201836f, -0.22206087f, 0.31485918f, -0.04991428f, 
    0.10746041f, -0.15242183f, -0.14249387f, 0.10322814f, -0.15689865f, -0.04091775f, 0.01220639f, 0.06008998f, 
    0.09211734f, 0.08957259f, -0.00139132f, -0.04398304f, -0.09566317f, 0.01016398f, -0.14088427f, 0.02208736f, 
    0.24290939f, -0.11459410f, 0.16749832f, 0.18182698f, 0.10253351f, 0.06117580f, -0.15572222f, 0.05903943f, 
    0.01711545f, -0.06592701f, -0.01145123f, 0.08528399f, 0.09306303f, -0.03156954f, 0.00780924f, 0.03499751f, 
    0.13070180f, 0.07298516f, -0.04907994f, 0.10738920f, -0.60713488f, 0.27037650f, 0.01012512f, -0.13679712f, 
    0.16275035f, -0.17859475f, -0.02348005f, -0.08201167f, -0.03390217f, -0.08608408f, -0.07512219f, -0.08685706f, 
    0.13360983f, 0.10474046f, 0.09317355f, -0.09263215f, -0.06607373f, -0.13990971f, -0.13029765f, -0.16068925f, 
    -0.08831430f, 0.10816555f, -0.20210470f, -0.15205722f, -0.44499388f, 0.03695034f, 0.03600091f, -0.04161941f, 
    0.01775623f, 0.00888981f, 0.08453746f, 0.04317779f, 0.07763571f, 0.00880366f, -0.07627431f, -0.06749549f, 
    -0.01918640f, 0.02127330f, -0.09618131f, 0.09766025f, -0.17469092f, -0.52694988f, 0.10634145f, 0.02754256f, 
    -0.07579266f, -0.08713127f, -0.12425418f, 0.15339471f, -0.09750195f, 0.01282213f, -0.01762330f, 0.10743754f, 
    0.00292735f, 0.01241682f, 0.05087933f, -0.00831039f, 0.02048584f, -0.01073489f, 0.08639355f, -0.00019403f, 
    -0.23410659f, -0.04419659f, 0.01809974f, -0.02338050f, 0.17175092f, -0.09519995f, 0.00839270f, -0.05524107f, 
    0.09384112f, 0.13276079f, 0.05822603f, -0.07935841f, 0.00445769f, -0.07231583f, -0.05360695f, -0.09686080f, 
    -0.09011116f, -0.06659955f, 0.00871263f, -0.07069502f, 0.25552237f, -0.00110165f, 0.01708222f, 0.00473409f, 
    0.09369331f, -0.07684761f, 0.01308657f, 0.07078473f, 0.09734162f, -0.12892093f, -0.04994045f, 0.05238300f, 
    0.01782457f, -0.02414038f, -0.01502480f, 0.09155123f, 0.00893500f, 0.08971950f, -0.15891165f, 0.06785768f, 
    0.11327944f, -0.06529422f, 0.15195493f, -0.14753570f, 0.10087234f, -0.03471240f, -0.00738095f, -0.17521152f, 
    0.00319129f, 0.05769481f, -0.01100457f, -0.08236752f, 0.04666199f, -0.04045504f, 0.00686111f, -0.02166261f, 
    -0.04722610f, 0.00588113f, 0.14780362f, -0.00011955f, -0.25458252f, 0.09158916f, 0.26424384f, 0.01600608f, 
    -0.37723058f, 0.09538342f, -0.07020763f, 0.04467592f, 0.10516743f, -0.02582961f, -0.10431418f, -0.06427265f, 
    -0.03630760f, -0.07962416f, -0.00934583f, -0.03664783f, -0.04274341f, -0.00597432f, 0.02752346f, -0.02032861f, 
    0.40670782f, 0.18550317f, 0.12752858f, -0.18601289f, 0.07231148f, 0.08691496f, 0.06440634f, 0.11922997f, 
    -0.05556653f, 0.03067851f, 0.02214675f, -0.21779485f, -0.09152801f, -0.06778052f, 0.01017684f, -0.16636834f, 
    0.00482312f, 0.11343227f, -0.01667719f, 0.01071322f, -0.00575918f, 0.25143629f, 0.04055162f, -0.21486984f, 
    -0.36237833f, 0.09187945f, 0.01134826f, -0.00168139f, 0.02114297f, -0.16746084f, 0.03129036f, 0.01108776f, 
    -0.05016688f, -0.03103248f, -0.06609352f, 0.02541936f, 0.05850970f, 0.02806042f, 0.00392519f, 0.03770911f, 
    0.10091108f, 0.07023081f, 0.14320502f, -0.01692198f, 0.28643394f, -0.20416337f, -0.15482169f, 0.04451273f, 
    -0.03220461f, 0.01525621f, -0.03162860f, 0.13694215f, -0.09893803f, 0.05661334f, -0.11625810f, 0.02209909f, 
    0.02477207f, 0.04644378f, -0.16060513f, -0.01106964f, -0.46857023f, 0.22929125f, -0.14638746f, -0.24905114f, 
    -0.05629729f, 0.09178121f, -0.00894275f, -0.03949596f, -0.13298965f, -0.02554357f, -0.09541995f, -0.12218141f, 
    -0.04524057f, 0.11925994f, 0.07120405f, 0.00870367f, 0.02017882f, -0.01372842f, -0.07407724f, 0.00450557f, 
    -0.00316575f, -0.47243094f, -0.05922249f, 0.17144489f, -0.50845456f, -0.10731851f, -0.05056572f, 0.08502436f, 
    0.14698410f, -0.04026983f, 0.02297834f, 0.01043286f, -0.11855487f, -0.05879321f, 0.06045232f, -0.02926342f, 
    -0.14570481f, -0.06077023f, -0.00498824f, 0.03494184f, 0.24035734f, 0.03933826f, 0.12086374f, -0.07847928f, 
    -0.42975208f, 0.03859152f, 0.14639561f, 0.10571878f, -0.00981568f, -0.03571881f, -0.05543514f, -0.02275916f, 
    -0.04252273f, -0.08739498f, -0.06050109f, 0.09461772f, 0.06125112f, 0.00823164f, 0.01587811f, 0.04166946f, 
    0.19968443f, -0.00238794f, -0.01333941f, -0.18091495f, 0.30743793f, -0.21009021f, -0.03740757f, -0.00319122f, 
    0.10143968f, -0.01773330f, -0.08314711f, 0.01142866f, -0.07476765f, -0.00564591f, -0.04112775f, 0.04091353f, 
    0.02956864f, -0.01787088f, -0.05231221f, 0.06615958f, 0.25532645f, 0.11426589f, 0.00353067f, -0.15046501f, 
    0.44471782f, -0.30159232f, -0.14419597f, -0.03604909f, 0.08330186f, -0.03994220f, -0.00216543f, 0.10555215f, 
    0.08410835f, -0.10039085f, 0.06964034f, 0.06421442f, 0.12975267f, -0.10591727f, 0.05099948f, 0.05343330f, 
    0.17617382f, -0.65976882f, -0.08546954f, 0.09212201f, 0.02276356f, -0.07712332f, -0.02723719f, 0.01805515f, 
    -0.05138855f, 0.09705294f, 0.03951695f, 0.04793026f, 0.01888282f, -0.02394089f, 0.05688312f, 0.14815830f, 
    -0.00735492f, 0.08121610f, -0.00675167f, -0.13189228f, -0.21921112f, 0.23464328f, 0.13082765f, -0.09731273f, 
    -0.26950791f, 0.02715004f, 0.08631250f, -0.11331518f, 0.01506128f, 0.02655200f, 0.04046740f, -0.01105045f, 
    -0.06450788f, 0.06986653f, -0.00087072f, -0.01000345f, -0.01487423f, -0.00116194f, 0.02674334f, 0.00055676f, 
    -0.16330764f, 0.18920699f, -0.14203121f, -0.02906114f, -0.02694223f, 0.00079024f, 0.11358130f, -0.00314359f, 
    -0.20896329f, 0.02538231f, -0.04770616f, 0.06894866f, 0.12351915f, -0.10795818f, 0.00746061f, 0.09396605f, 
    -0.16164696f, 0.13542052f, 0.05537727f, 0.01380456f, 0.21653067f, 0.14192209f, 0.15287827f, 0.09000897f, 
    0.25543138f, -0.14206398f, -0.08355881f, 0.06786378f, 0.02805955f, 0.04529548f, 0.06314871f, -0.05606391f, 
    0.09678577f, 0.03911044f, 0.07287277f, 0.09021611f, 0.02427086f, -0.07920252f, -0.01505909f, 0.02200399f, 
    -0.15474620f, -0.12887520f, -0.60834754f, -0.25711003f, -0.14800341f, 0.00349566f, -0.06032733f, 0.07157492f, 
    -0.02947276f, 0.03859172f, 0.09082036f, -0.10086921f, 0.20570731f, 0.03079810f, -0.01976619f, -0.06264110f, 
    -0.07124636f, -0.23109530f, -0.03334260f, 0.05370444f, -0.23844515f, -0.26840836f, 0.22827725f, -0.11110585f, 
    0.19762725f, -0.10292970f, -0.08993436f, 0.09349541f, -0.01126768f, -0.00789109f, 0.05394834f, -0.21740043f, 
    0.08975275f, -0.09206691f, -0.11775397f, -0.06522361f, -0.06286428f, -0.07157879f, 0.13097291f, -0.16624102f, 
    -0.04725600f, -0.04973872f, -0.05130063f, -0.29760611f, 0.10348339f, 0.08397439f, -0.00341914f, 0.10038209f, 
    0.04247804f, 0.08033059f, -0.14354308f, -0.12922573f, 0.07732654f, 0.05727567f, 0.11949017f, -0.01930884f, 
    0.10517507f, -0.05822180f, -0.04749236f, -0.32460484f, 0.14723264f, 0.33364043f, 0.05367424f, 0.16404597f, 
    0.39120984f, -0.04359260f, -0.05777701f, 0.02705893f, 0.07842080f, 0.06483009f, 0.10089260f, 0.01361524f, 
    -0.06263814f, 0.05483388f, -0.16008849f, -0.00769564f, 0.09645817f, 0.06178254f, -0.04633309f, 0.13310549f, 
    0.20225196f, 0.01572434f, 0.02386413f, 0.13940552f, -0.11280541f, 0.01375737f, -0.13756223f, -0.02931581f, 
    -0.00309755f, 0.08681740f, 0.07048886f, 0.08831774f, -0.03544953f, 0.01372624f, -0.15504847f, 0.11355845f, 
    -0.03022801f, 0.03036174f, -0.08620204f, 0.03898790f, -0.06762942f, 0.14607169f, -0.01543231f, -0.07566093f, 
    -0.27536419f, 0.04322341f, 0.12070084f, -0.15680748f, 0.06166451f, -0.01019954f, -0.03344288f, 0.02453975f, 
    -0.04472089f, -0.06550349f, -0.03497484f, -0.01555659f, -0.04532138f, 0.08669077f, -0.08329853f, 0.06379534f, 
    0.27898043f, -0.55818683f, 0.00370406f, -0.15901273f, -0.19209887f, 0.02865510f, -0.13282450f, -0.04720433f, 
    -0.03130460f, -0.00990985f, -0.04881145f, 0.10824710f, -0.07025379f, -0.09005276f, 0.09844864f, -0.08415540f, 
    -0.00766919f, -0.14114426f, 0.08036876f, -0.07981303f, 0.01023907f, 0.16670333f, -0.10045228f, -0.06391359f, 
    -0.12719180f, 0.22051629f, -0.03458158f, 0.10187455f, 0.11202844f, 0.13533017f, -0.04896585f, -0.07269687f, 
    0.11762247f, 0.07983173f, -0.08209224f, 0.02521223f, 0.10447923f, -0.27945200f, -0.17692533f, -0.17215945f, 
    -0.40184724f, -0.02503953f, -0.03554069f, 0.02887776f, -0.24654773f, 0.02231297f, 0.01477933f, -0.02236209f, 
    -0.04689042f, 0.04078493f, -0.07052949f, -0.06333318f, -0.10518830f, 0.02188451f, 0.08759206f, 0.02283058f, 
    -0.10965803f, -0.11748003f, -0.08968093f, 0.06876813f, 0.17062685f, 0.00095397f, -0.03535723f, 0.13967915f, 
    -0.25424117f, -0.09073012f, -0.11490223f, 0.07207429f, 0.10791112f, 0.12966467f, 0.10672933f, -0.08665100f, 
    0.03297168f, 0.07397254f, -0.10753556f, 0.03332828f, 0.15830895f, -0.14617831f, 0.02027186f, -0.05067424f, 
    -0.00875138f, -0.31225708f, -0.12710716f, -0.04623410f, 0.15081477f, -0.02881409f, -0.03390871f, -0.01149444f, 
    0.06600200f, 0.00092645f, -0.02909530f, 0.08870268f, 0.02442029f, -0.13234058f, 0.07043198f, -0.11199655f, 
    0.07258869f, -0.09269038f, 0.10521638f, 0.00514597f, -0.45857748f, -0.08360283f, 0.17769621f, -0.00353857f, 
    0.19517466f, -0.07857269f, 0.02094629f, 0.02021653f, -0.17677023f, 0.04653320f, -0.05379533f, -0.05158576f, 
    0.07715203f, -0.08411956f, -0.09679677f, 0.06793214f, -0.09756151f, 0.03572530f, 0.09577557f, -0.05761218f, 
    0.28340295f, -0.43792793f, -0.03555933f, -0.34075931f, -0.23277234f, 0.01669019f, 0.09208890f, -0.08573313f, 
    0.00204779f, -0.11383719f, -0.07533406f, -0.12703018f, -0.05040312f, -0.02275652f, -0.07611859f, -0.00485366f, 
    0.00871958f, -0.12082056f, 0.10535988f, 0.11550188f, 0.50322574f, -0.38181871f, 0.03076237f, -0.19758402f, 
    -0.05128448f, -0.07448298f, 0.02735740f, -0.17808403f, 0.18153882f, -0.08925395f, 0.02479698f, -0.03997929f, 
    -0.12864183f, 0.14129151f, 0.05306508f, 0.04142597f, -0.05447827f, 0.12347342f, 0.09751385f, 0.09931808f, 
    0.10600931f, -0.22838457f, -0.03530916f, -0.00044177f, -0.23365943f, -0.11442898f, -0.03426389f, -0.03285073f, 
    -0.00656917f, 0.03793911f, 0.07738040f, 0.00618357f, -0.00269909f, 0.02463670f, 0.01038519f, 0.05714631f, 
    0.00290160f, -0.02107495f, -0.02353131f, 0.01847525f, 0.14264378f, -0.10274564f, 0.05977469f, 0.00094834f, 
    -0.00807641f, 0.00749887f, 0.09790484f, -0.04456691f, 0.06038009f, 0.12723118f, -0.14946137f, -0.06590458f, 
    0.05193377f, 0.00066922f, -0.12664169f, 0.23820221f, 0.07389483f, 0.00252503f, -0.04217953f, 0.15027614f, 
    0.40499932f, -0.19748035f, -0.02670246f, -0.08257472f, -0.08892838f, -0.02474766f, -0.13097987f, 0.10861790f, 
    -0.03007722f, 0.05396242f, -0.04561247f, 0.09039967f, 0.02230046f, -0.00321793f, 0.15821356f, 0.08213702f, 
    -0.04137728f, -0.05632903f, -0.17599894f, 0.04217286f, 0.02775977f, -0.51387900f, 0.11129165f, -0.13247450f, 
    -0.09218335f, -0.02087353f, 0.02688258f, -0.06197171f, -0.07204371f, -0.03351675f, 0.03285406f, -0.00666098f, 
    -0.07162926f, 0.04412018f, -0.02328383f, -0.08932338f, 0.02634408f, 0.02378554f, -0.00602540f, -0.09134518f, 
    -0.04444802f, -0.10351766f, -0.13023026f, -0.06020995f, 0.02531788f, 0.07836671f, -0.08193979f, 0.18491745f, 
    0.03004507f, -0.08490341f, -0.10515928f, 0.03598854f, -0.07907826f, 0.12897910f, 0.02852092f, -0.02885695f, 
    -0.06072632f, -0.17539878f, -0.11348125f, -0.13951391f, 0.15573405f, -0.05521130f, -0.30070522f, 0.04628473f, 
    -0.31938189f, 0.00907415f, 0.01635540f, 0.04597871f, -0.02593052f, 0.07335322f, -0.07608996f, 0.01629867f, 
    -0.08424266f, 0.12568948f, 0.00125587f, 0.01976659f, 0.11239878f, 0.04861195f, -0.03486314f, 0.05593571f, 
    -0.70231760f, 0.23489746f, -0.12848160f, -0.25752586f, 0.10078835f, 0.05089891f, -0.01242584f, -0.03384911f, 
    -0.10897335f, 0.11932890f, 0.14128730f, 0.12771344f, 0.07309508f, -0.11034794f, -0.04327435f, -0.07446882f, 
    -0.10549980f, 0.01458863f, -0.04570438f, -0.00640833f, 0.23709866f, -0.12127037f, -0.23526551f, -0.01492394f, 
    -0.27563864f, -0.06721583f, 0.05322258f, -0.02671609f, 0.00052657f, 0.07328530f, 0.04717157f, 0.04142376f, 
    -0.04655583f, -0.03812241f, -0.03997808f, 0.09872390f, 0.07238157f, 0.02799913f, -0.06943364f, 0.00865670f, 
    0.03069170f, -0.25136822f, -0.17608504f, -0.30748144f, 0.31237769f, -0.04200968f, 0.00368618f, 0.08141700f, 
    -0.03175067f, -0.12340520f, -0.06386630f, -0.02570262f, 0.03900124f, -0.05226272f, -0.00423471f, -0.01913694f, 
    -0.12548009f, -0.08298064f, 0.12250917f, -0.04461963f, 0.36109626f, -0.06405414f, 0.05748630f, 0.01667824f, 
    -0.00108430f, -0.15971507f, 0.04573447f, -0.06825034f, -0.03580283f, 0.04850972f, 0.07693516f, 0.01568980f, 
    -0.05650538f, -0.00741448f, 0.12965788f, 0.05787181f, -0.02002767f, -0.01280332f, -0.01874594f, 0.18331882f, 
    -0.15416285f, -0.21381943f, -0.04482287f, 0.07739429f, -0.11713625f, 0.08169973f, -0.09075864f, -0.05429556f, 
    -0.02192556f, -0.01809024f, 0.13639133f, -0.02069594f, -0.06745608f, -0.00734888f, 0.04554738f, -0.04820655f, 
    -0.05111100f, -0.07958394f, -0.15693130f, -0.10229085f, 0.05995442f, -0.02895321f, -0.04837180f, 0.05801748f, 
    -0.17357028f, -0.04233189f, 0.13979807f, -0.00518784f, -0.04569074f, 0.13404292f, 0.23846626f, 0.05250229f, 
    0.04542977f, 0.03737292f, -0.00181556f, 0.02006240f, 0.17662102f, 0.03947271f, 0.06879777f, -0.01665837f, 
    0.24923874f, 0.09878113f, 0.21994543f, 0.07127448f, 0.16148588f, 0.01398546f, -0.04030298f, -0.02388699f, 
    -0.04897599f, 0.01976041f, -0.00350825f, 0.02362613f, -0.00503195f, 0.13726191f, -0.04446550f, -0.08055658f, 
    0.09990046f, 0.03380470f, 0.10172030f, -0.00697099f, 0.18674453f, 0.28501084f, 0.07531790f, 0.14441201f, 
    0.15723701f, -0.07510810f, 0.05718303f, 0.10529935f, 0.02212653f, -0.01496712f, -0.06462137f, -0.08745506f, 
    -0.16079798f, 0.14690611f, -0.08314468f, 0.07465166f, 0.04521685f, 0.09993964f, -0.08362246f, -0.11561738f, 
    -0.30967721f, 0.00917192f, -0.03987003f, -0.08724557f, 0.19208436f, 0.16484146f, -0.01630387f, 0.14548606f, 
    -0.00430939f, 0.03123132f, 0.09935644f, -0.02329283f, 0.07230762f, -0.11822060f, 0.01712688f, -0.05426497f, 
    0.00591618f, -0.17172280f, -0.00960688f, -0.04726000f, 0.14590906f, 0.08354265f, -0.20290110f, 0.06729306f, 
    -0.19591393f, -0.12302542f, 0.01617496f, 0.06477877f, 0.08172953f, 0.04819734f, -0.07293491f, -0.11464948f, 
    -0.05230499f, -0.05647676f, -0.05746636f, 0.14348559f, 0.16466454f, 0.02928994f, -0.04536479f, -0.00137592f, 
    0.41148490f, 0.05709139f, -0.15198225f, 0.01751665f, 0.02620053f, -0.19144762f, -0.08443176f, 0.07287665f, 
    0.06094280f, 0.06902077f, 0.01234593f, 0.09563031f, 0.00611398f, 0.06170564f, 0.08251277f, -0.03800891f, 
    -0.04297665f, -0.14547937f, 0.02224537f, -0.02111650f, -0.29696456f, 0.14165260f, 0.02533326f, -0.19532070f, 
    0.11372925f, 0.18929830f, 0.14239261f, 0.11405294f, 0.04708868f, -0.04186201f, -0.12375148f, 0.09079170f, 
    -0.05792788f, -0.02977340f, -0.00917179f, -0.04418048f, -0.09843373f, 0.00761066f, -0.16322008f, -0.03131448f, 
    -0.03145327f, -0.21736303f, -0.09630865f, -0.14354245f, -0.18122914f, 0.07178301f, 0.01548433f, 0.12995929f, 
    -0.10812282f, -0.01838569f, -0.14412467f, 0.02991942f, -0.00003309f, -0.07621831f, -0.06217088f, 0.02233372f, 
    -0.06018631f, 0.11112737f, 0.07602044f, -0.02038330f, -0.18812183f, -0.21089727f, 0.02637278f, -0.05982919f, 
    -0.30388692f, -0.03869795f, -0.10997485f, -0.04584924f, -0.02847084f, 0.11286915f, -0.15690905f, 0.01050633f, 
    -0.11506628f, 0.05041656f, -0.00958384f, 0.04510786f, 0.03895935f, 0.08487906f, -0.03365824f, -0.12043456f, 
    -0.32817030f, -0.25925657f, -0.07340464f, -0.25503910f, -0.20114776f, 0.05963235f, -0.04390302f, -0.08688858f, 
    -0.01872178f, -0.00362535f, 0.03776464f, 0.06660800f, -0.06089685f, -0.00651772f, 0.04250120f, -0.08293208f, 
    -0.02453933f, 0.05440600f, -0.02392318f, 0.00370113f, 0.01541050f, 0.20251912f, -0.16046424f, -0.13375998f, 
    0.07318718f, 0.07517413f, 0.08958003f, 0.11626092f, 0.00314286f, -0.09410315f, 0.06677855f, -0.05891854f, 
    -0.01085059f, -0.04374949f, 0.01012268f, 0.02421044f, 0.05943416f, -0.13182311f, -0.01919172f, -0.06760088f, 
    -0.38807186f, 0.29977331f, -0.01907792f, -0.21536571f, 0.19302346f, 0.04121070f, 0.07532138f, 0.04801467f, 
    0.04392319f, -0.11554684f, -0.05558889f, 0.02213551f, -0.03638208f, -0.04474547f, 0.00769982f, -0.00467834f, 
    0.07315994f, -0.01702796f, 0.08201209f, 0.05229818f, 0.11319032f, 0.08075596f, -0.25140724f, 0.03467331f, 
    -0.05514140f, -0.13029939f, -0.02922161f, 0.06484781f, -0.01921319f, 0.02701633f, 0.02144055f, 0.10422343f, 
    0.04239066f, 0.04625513f, -0.01940969f, -0.02420985f, -0.05202606f, -0.15500362f, -0.03978109f, -0.13193275f, 
    -0.10895952f, -0.36086589f, 0.11389755f, -0.23218168f, -0.19174552f, -0.05083738f, -0.17816898f, 0.00702847f, 
    0.03707321f, 0.03261632f, -0.05632735f, -0.01679106f, 0.01399485f, -0.02570946f, -0.05231439f, -0.00404867f, 
    -0.12338669f, 0.09522393f, 0.08584700f, 0.06100804f, -0.18645407f, -0.37019312f, -0.09063692f, -0.18693554f, 
    -0.19812708f, -0.16903527f, -0.08308306f, -0.15481646f, 0.03701757f, -0.09772592f, 0.00635673f, 0.01457520f, 
    0.01327702f, 0.06424697f, 0.03139510f, -0.06494446f, -0.00543657f, 0.07889581f, 0.02106644f, -0.04274598f, 
    -0.07553653f, 0.17814076f, -0.20204845f, -0.03161041f, -0.03645671f, 0.02645264f, 0.21500814f, 0.02674435f, 
    -0.01160113f, -0.11164048f, -0.01720383f, 0.04068088f, 0.00261934f, -0.05333024f, -0.07229777f, -0.01749989f, 
    0.10797574f, 0.03347488f, -0.07795073f, -0.10846748f, 0.34602237f, -0.10544760f, -0.00154667f, 0.19869527f, 
    0.06636813f, -0.12399440f, -0.03955128f, -0.12000724f, 0.00270714f, 0.01875809f, -0.01092875f, 0.00177112f, 
    0.08054153f, 0.03153620f, 0.01957430f, 0.04469019f, -0.07388503f, 0.03722523f, 0.06371797f, 0.02998774f, 
    0.26219022f, -0.37797824f, 0.15389350f, -0.07788684f, 0.14053656f, 0.12847438f, -0.05382892f, 0.01570934f, 
    0.01936975f, 0.06826813f, -0.02127887f, 0.01165893f, -0.02856426f, -0.03008463f, -0.06721143f, 0.05227531f, 
    -0.13595060f, -0.03606728f, -0.09411960f, -0.07912783f, 0.34975567f, 0.01926824f, -0.08331584f, -0.04697074f, 
    -0.19458948f, 0.02568319f, 0.08537109f, 0.00765099f, 0.00263619f, 0.03763724f, -0.00320490f, 0.06381774f, 
    0.05065984f, 0.03390070f, 0.06877270f, -0.00921794f, -0.11930816f, 0.00528988f, -0.01360890f, -0.09291782f, 
    -0.34959480f, -0.39461803f, 0.06993560f, -0.07209798f, -0.05621623f, -0.03396324f, -0.08097722f, -0.08760767f, 
    0.03221943f, 0.08656260f, 0.05020858f, 0.01970097f, -0.06656711f, 0.04256292f, -0.04542342f, 0.09003291f, 
    -0.04674582f, -0.02635504f, -0.02010997f, -0.07451440f, 0.16744907f, -0.02070624f, -0.33899900f, 0.16524102f, 
    -0.36326024f, 0.05516566f, 0.00166821f, 0.15264760f, 0.04668280f, 0.08455282f, -0.04813182f, 0.01672550f, 
    0.08200853f, -0.01768509f, -0.01390323f, -0.12186530f, -0.08680792f, -0.12343967f, -0.01941788f, 0.07495154f, 
    0.42393458f, 0.02106504f, -0.12951025f, 0.14388046f, 0.20195620f, -0.23999520f, -0.07706974f, -0.06487939f, 
    -0.01440482f, 0.00047286f, 0.09947642f, -0.01219386f, 0.00983194f, 0.11089099f, -0.06653750f, -0.09722587f, 
    -0.02856071f, -0.01822085f, -0.14422598f, 0.02326295f, -0.13170549f, -0.32649761f, 0.16097972f, -0.26461938f, 
    -0.11955138f, -0.06402797f, 0.09757804f, -0.02130190f, 0.01083378f, 0.01539406f, 0.07986592f, -0.01392873f, 
    0.11550631f, -0.21522970f, -0.00487931f, -0.04063851f, 0.03391134f, 0.06153279f, -0.03252073f, -0.14842489f, 
    0.16400898f, 0.16529937f, -0.01038967f, -0.26519534f, -0.17544983f, 0.05630425f, -0.02070014f, 0.06351949f, 
    -0.09546823f, 0.02819243f, -0.05713556f, -0.00866833f, 0.06086013f, -0.15189339f, 0.00121046f, 0.04403865f, 
    -0.00439111f, 0.04156083f, 0.10778254f, -0.02881910f, -0.03518508f, -0.05086643f, -0.03027849f, 0.19638069f, 
    -0.05423323f, 0.00793388f, -0.16865198f, 0.02816234f, 0.10492881f, 0.05709824f, -0.06940616f, -0.06683149f, 
    -0.09621569f, 0.07251613f, -0.04837562f, 0.02096874f, -0.00361446f, -0.02911532f, 0.05609930f, -0.03372118f, 
    -0.12103423f, 0.18399160f, -0.06168813f, -0.18826567f, -0.05022737f, 0.11656261f, 0.09114330f, 0.15334576f, 
    -0.11167869f, -0.01350890f, -0.06750318f, 0.05057719f, -0.06063146f, -0.20816219f, -0.08675979f, 0.01061965f, 
    0.06034244f, 0.16176043f, -0.05403252f, -0.05962978f, 0.41273367f, -0.32628444f, 0.12364604f, -0.04926352f, 
    0.11745987f, -0.11954305f, -0.05908033f, -0.04251186f, -0.03575830f, 0.03858331f, 0.07197426f, -0.08205058f, 
    -0.00420493f, -0.02551669f, 0.08838434f, 0.05403669f, -0.03018089f, 0.01310660f, 0.06533826f, -0.05880867f, 
    0.33574879f, -0.03590930f, 0.03972531f, -0.24797322f, -0.00412704f, -0.07761747f, -0.02980621f, -0.01753560f, 
    -0.03855208f, -0.06796011f, -0.12455102f, 0.09320391f, 0.01297081f, -0.10416300f, 0.04551524f, -0.07832533f, 
    0.05157166f, -0.03995915f, -0.03925609f, 0.04738667f, 0.29781601f, 0.00029642f, 0.20166868f, 0.11965083f, 
    0.28373522f, -0.13459250f, -0.11552724f, -0.15443212f, 0.09168226f, 0.03424644f, 0.08287723f, -0.08755341f, 
    -0.07701513f, 0.04647755f, 0.02058871f, -0.03530831f, -0.06219056f, 0.01584051f, -0.04151310f, -0.03691386f, 
    0.07791044f, -0.29435900f, -0.00537572f, -0.13654877f, -0.11675525f, 0.09965079f, 0.07304865f, 0.16091587f, 
    -0.10943365f, -0.04016206f, -0.11240437f, 0.02932570f, 0.02665280f, -0.03316606f, -0.11366959f, 0.01823313f, 
    0.02013808f, 0.08800907f, -0.18735452f, -0.01317662f, 0.16957968f, 0.13137016f, 0.14113811f, 0.12511328f, 
    0.01202612f, 0.00846824f, -0.16545257f, -0.01432224f, 0.07092497f, 0.14049758f, -0.05105850f, -0.08052702f, 
    0.03206721f, 0.06920286f, -0.04423334f, -0.04826671f, -0.11336732f, -0.01704936f, -0.02606398f, 0.00687765f, 
    0.60250562f, -0.09777018f, -0.14894396f, -0.07522577f, -0.20674254f, -0.24001315f, 0.05269779f, 0.05008349f, 
    0.07796043f, 0.06931943f, 0.00321757f, -0.07335526f, -0.01078105f, 0.01810226f, -0.01368496f, 0.05674798f, 
    -0.00594250f, -0.02071818f, 0.13475919f, -0.09118263f, -0.15098609f, 0.13633303f, 0.13724276f, 0.00658187f, 
    0.14096038f, -0.06396845f, -0.02808617f, -0.08919095f, 0.02193438f, 0.05291044f, 0.00319145f, -0.05831554f, 
    -0.00897000f, -0.14013848f, 0.11045112f, 0.02514479f, 0.00175238f, -0.09879283f, -0.02685131f, 0.01956094f, 
    0.21075954f, -0.14346389f, 0.04186395f, -0.11746402f, -0.01497581f, 0.13130726f, -0.10526013f, 0.10775390f, 
    0.06037993f, 0.06508561f, -0.06998605f, -0.02526032f, 0.14546877f, 0.05066945f, -0.06013912f, -0.04276630f, 
    -0.10861574f, 0.02068394f, -0.08011051f, -0.05657582f, -0.07489873f, -0.01220721f, -0.08176403f, -0.19111265f, 
    0.04168986f, 0.11699817f, -0.04097066f, 0.15130417f, 0.08368701f, -0.05886753f, -0.08217829f, 0.04862513f, 
    0.06508554f, -0.07415152f, -0.02207914f, -0.08183144f, 0.04537735f, 0.03699135f, -0.11920793f, -0.07120360f, 
    -0.29990453f, -0.04972389f, 0.03563360f, -0.25245303f, -0.19113196f, 0.13981380f, -0.16194275f, -0.11454067f, 
    -0.01360042f, 0.09888565f, -0.08593058f, 0.01088193f, -0.03981109f, -0.07080396f, 0.05494802f, 0.06090329f, 
    -0.05800856f, 0.06728344f, 0.05585150f, 0.07178064f, 0.24552657f, 0.05275754f, 0.21451536f, 0.02245514f, 
    0.18326813f, -0.14167298f, -0.00945083f, -0.06439369f, 0.01224907f, 0.04298230f, -0.02306522f, -0.08810867f, 
    -0.02906446f, -0.05342678f, -0.02486098f, 0.10650995f, -0.09506186f, -0.03241336f, 0.07515708f, -0.04534383f, 
    -0.47914574f, -0.10610444f, 0.05505241f, -0.22815643f, -0.20361613f, -0.07027091f, -0.02782907f, 0.00265583f, 
    0.04361172f, -0.06575932f, 0.07591911f, -0.11981820f, 0.01175391f, -0.05017202f, 0.03994330f, -0.01774378f, 
    0.02896095f, 0.00891722f, 0.00857491f, 0.02714014f, -0.21256478f, -0.83443278f, -0.54148895f, 0.12325852f, 
    -0.00884823f, -0.08991545f, -0.06423807f, 0.03509147f, -0.02167165f, -0.11365483f, 0.02179245f, -0.05742991f, 
    -0.07179873f, 0.00898142f, -0.09098048f, -0.04993853f, 0.01062223f, 0.10841822f, -0.09319385f, -0.00621476f, 
    0.32536480f, 0.35962823f, -0.01340609f, 0.08886135f, 0.07320853f, 0.10254462f, 0.05627801f, 0.05422044f, 
    0.01447918f, 0.05363235f, -0.06109298f, -0.07291768f, -0.01357092f, -0.18696918f, -0.09528363f, -0.06037268f, 
    0.08083069f, 0.08241377f, 0.06993859f, -0.00973069f, 0.25878981f, 0.22891894f, -0.13639769f, 0.16337481f, 
    -0.13051873f, -0.03328113f, 0.04459851f, -0.15888834f, -0.00972499f, -0.06181708f, -0.06311937f, 0.04851731f, 
    0.02881290f, -0.00230759f, 0.02083136f, 0.04879360f, 0.00589895f, 0.00351299f, 0.02463898f, 0.11118849f, 
    0.13844250f, 0.28123507f, 0.02393511f, 0.01113529f, -0.05485011f, -0.03318254f, -0.00951950f, 0.05759308f, 
    -0.07436427f, -0.00949851f, -0.11575597f, -0.01326726f, -0.00354778f, -0.01319488f, 0.05408092f, 0.05004044f, 
    -0.05591450f, 0.16072795f, 0.09605701f, 0.13131215f, -0.78005672f, 0.27990368f, -0.24180341f, -0.01125931f, 
    0.12442107f, -0.21398278f, 0.01319452f, -0.01024511f, 0.01506573f, -0.04980312f, -0.06573288f, -0.01470312f, 
    0.15163696f, -0.00668672f, 0.05654355f, -0.10214318f, -0.07630832f, -0.13768965f, 0.03993921f, 0.10600949f, 
    -0.34776318f, -0.16983658f, -0.21834579f, 0.03602111f, 0.11524151f, -0.01274761f, 0.06631160f, 0.09002935f, 
    0.04073045f, -0.02175598f, -0.05138618f, 0.01889714f, -0.03638931f, -0.06697559f, -0.02467550f, -0.05022065f, 
    -0.13817622f, -0.02589335f, 0.09912394f, -0.10066464f, -0.06372092f, 0.09502690f, 0.22795852f, 0.09060924f, 
    -0.01615030f, 0.05203039f, -0.10839676f, 0.00463952f, -0.02462640f, -0.00014861f, -0.10267016f, -0.02767217f, 
    -0.02134228f, -0.01328967f, 0.09999760f, 0.02886574f, 0.02852575f, -0.02977998f, 0.05541078f, -0.01891751f, 
    0.08173104f, 0.06689887f, 0.21590671f, 0.15326656f, -0.04534148f, -0.05964039f, 0.09225468f, 0.00130620f, 
    0.09762143f, 0.00435172f, -0.06980915f, -0.02604682f, -0.08245740f, -0.00959639f, -0.06725148f, -0.06550491f, 
    -0.01305508f, 0.03185328f, -0.05388842f, -0.06305008f, 0.13264702f, 0.10704854f, -0.11559211f, -0.06083014f, 
    0.00117531f, -0.11397500f, -0.16376546f, -0.09930669f, 0.01604056f, -0.03108357f, -0.02160564f, -0.01696374f, 
    -0.01899558f, -0.14031658f, 0.03229424f, -0.11609952f, -0.06236575f, 0.13854940f, -0.04501255f, -0.04657103f, 
    -0.06456644f, 0.17989208f, 0.13972990f, 0.29943043f, 0.30440283f, 0.11505324f, 0.14688836f, 0.11204825f, 
    -0.16060700f, 0.04459771f, -0.00060746f, 0.02716373f, -0.06086595f, -0.00119948f, -0.08608043f, 0.03582033f, 
    -0.03162004f, 0.05789194f, 0.01476067f, -0.07766338f, 0.16854955f, -0.09520442f, 0.05665817f, -0.06283865f, 
    -0.04592698f, -0.18427545f, -0.05459033f, -0.02213021f, -0.16888225f, -0.05171951f, -0.10474613f, -0.03583525f, 
    0.02504451f, -0.04291948f, 0.03340085f, -0.00163283f, 0.00831879f, 0.10577097f, 0.01612322f, 0.02900231f, 
    -0.00614308f, -0.09634847f, -0.08673979f, 0.22476345f, 0.00943217f, -0.04396714f, -0.10976654f, -0.00772729f, 
    0.01822671f, -0.04367747f, 0.00949958f, -0.03765459f, 0.06761084f, 0.05677518f, 0.05079878f, 0.02331860f, 
    0.00969164f, 0.01141325f, -0.02510204f, 0.04545737f, 0.36971349f, 0.08083306f, 0.14406337f, 0.06547466f, 
    -0.00990733f, 0.14210957f, -0.04791358f, -0.07329158f, 0.14324687f, -0.18780199f, 0.08206148f, 0.05512098f, 
    -0.13358246f, 0.02704850f, -0.06340934f, -0.09557855f, 0.04342304f, -0.14463431f, -0.00925918f, -0.05297725f, 
    -0.01597358f, 0.08999553f, 0.04612980f, 0.06267013f, -0.11674453f, -0.06611975f, 0.09279387f, -0.04107966f, 
    -0.00800810f, 0.03351130f, 0.03275736f, 0.09243720f, 0.05919214f, 0.05350238f, -0.00499442f, 0.03538821f, 
    -0.13304345f, 0.02973775f, -0.05561947f, -0.06739382f, 0.10175990f, -0.24704829f, -0.07084532f, 0.05427592f, 
    0.04744714f, -0.19026974f, 0.07117563f, 0.04531608f, -0.09969094f, 0.06655739f, -0.02713010f, 0.04652080f, 
    -0.06556098f, -0.08408618f, -0.07150963f, -0.06166728f, -0.04440464f, 0.01609364f, 0.10633507f, 0.01411896f, 
    -0.00205392f, -0.04031189f, -0.00297253f, 0.05736455f, -0.17594340f, -0.04668064f, -0.14270362f, 0.10692846f, 
    -0.03582687f, 0.04025768f, -0.19206429f, 0.02798655f, 0.01118438f, -0.05401465f, 0.10119940f, 0.01264282f, 
    -0.03999153f, 0.08841156f, 0.07480666f, 0.03918245f, 0.06139250f, 0.18239680f, -0.07571436f, 0.10947434f, 
    -0.05840710f, -0.04467147f, 0.02042470f, -0.10575354f, 0.10272185f, 0.00325863f, -0.03938210f, -0.01938181f, 
    -0.00224432f, -0.03500473f, -0.02301686f, 0.08397445f, -0.08093687f, -0.00249841f, -0.09292240f, -0.05678196f, 
    0.03777621f, -0.11183712f, 0.05599681f, -0.13596503f, 0.14643171f, -0.05623337f, 0.01334577f, 0.04442221f, 
    -0.03927738f, 0.04459564f, -0.06282789f, -0.04087178f, 0.02844784f, -0.11764403f, -0.02555893f, 0.00650405f, 
    -0.02185902f, 0.03499449f, 0.00903280f, -0.03684813f, 0.06620390f, 0.08772365f, -0.02123013f, 0.09684747f, 
    -0.12484520f, -0.03998280f, 0.01736747f, 0.05092892f, -0.01429079f, 0.02877474f, -0.02596866f, -0.04946255f, 
    -0.00555879f, 0.00717119f, 0.06105426f, -0.02980706f, -0.00669176f, -0.06093239f, 0.01334129f, 0.05466450f, 
    0.13621046f, -0.23997083f, 0.02637863f, 0.13825215f, 0.23385350f, 0.02615344f, 0.19248553f, 0.05596450f, 
    -0.02764416f, 0.02192448f, 0.05109671f, 0.01837794f, -0.01843583f, -0.12535444f, -0.09068648f, 0.07706752f, 
    0.01596395f, 0.11032367f, 0.01832568f, -0.11579360f, -0.06799277f, -0.06308492f, 0.03769178f, -0.05156914f, 
    0.00054494f, -0.05781045f, -0.15120158f, -0.17625616f, 0.06051197f, -0.02031642f, 0.05933987f, -0.02111566f, 
    0.05422413f, -0.05732982f, -0.01084191f, -0.13713320f, -0.02945458f, 0.01872657f, 0.12453935f, 0.05007676f, 
    0.21623380f, 0.42692485f, 0.01758745f, 0.04072667f, 0.05013668f, -0.08102370f, 0.07421721f, -0.04285019f, 
    0.18457228f, 0.04081830f, -0.12986293f, 0.04203253f, -0.16156375f, 0.13654426f, -0.00590434f, -0.01199671f, 
    -0.04930926f, -0.17983070f, 0.06798164f, 0.00101062f, -0.10293679f, -0.08782543f, -0.06691357f, -0.09415478f, 
    -0.10736375f, -0.00706891f, -0.20676045f, 0.11768046f, -0.00272403f, 0.06818744f, -0.12001636f, 0.05273597f, 
    0.06631581f, -0.03271283f, 0.03120173f, -0.04025870f, -0.02923114f, -0.00614247f, 0.06285304f, 0.05685779f, 
    0.57633275f, 0.15325284f, -0.33855891f, 0.11963728f, 0.10037588f, -0.06981343f, 0.03632041f, -0.02579769f, 
    0.03263841f, 0.13101107f, -0.05513827f, -0.00903019f, -0.01748159f, 0.14374070f, -0.04702933f, 0.02294169f, 
    0.11028415f, -0.05409316f, 0.11568152f, 0.00248604f, -0.10754987f, -0.27748603f, -0.11255502f, -0.06600746f, 
    -0.21755655f, -0.06312378f, -0.05223600f, 0.02644549f, -0.05359796f, -0.03676245f, -0.16271718f, 0.01293975f, 
    0.07172950f, 0.08701834f, 0.14321756f, 0.03616250f, -0.00564169f, 0.04984611f, -0.03475741f, 0.06332289f, 
    -0.35684270f, 0.32742646f, 0.15509564f, 0.18209885f, 0.12677464f, 0.06668446f, -0.04533798f, 0.04597237f, 
    0.04707739f, -0.07091966f, -0.05387291f, -0.08075773f, -0.02859458f, 0.02978142f, 0.04412570f, 0.03176090f, 
    -0.02038609f, 0.02064847f, 0.16770253f, 0.01583087f, 0.16657603f, -0.12370242f, -0.04902578f, -0.18156491f, 
    -0.20306534f, -0.01321673f, 0.03297871f, -0.08788063f, -0.03846725f, 0.02889507f, 0.01661498f, -0.02519973f, 
    0.04066309f, -0.12343308f, -0.01073103f, -0.01835345f, 0.04497960f, -0.00615868f, -0.03705496f, 0.04655443f, 
    -0.22121181f, -0.42458957f, -0.25635830f, -0.09954364f, -0.07226957f, -0.21073286f, -0.17629375f, -0.11377300f, 
    0.08988720f, 0.00690127f, -0.04025885f, -0.04453916f, 0.08815307f, 0.02000839f, 0.04612394f, -0.02253013f, 
    -0.12349406f, -0.09336685f, -0.00631520f, 0.10816106f, -0.48827749f, -0.49334660f, -0.33197227f, -0.19828735f, 
    0.05922592f, -0.11488215f, 0.03483692f, -0.08716431f, 0.02996517f, -0.02489202f, 0.01723674f, -0.06428161f, 
    0.04853888f, 0.11270312f, -0.00464920f, 0.06153965f, 0.03265885f, -0.12414798f, 0.02911250f, 0.09068733f, 
    0.35887668f, 0.26453254f, -0.21512376f, 0.03993168f, 0.00691198f, 0.04940741f, 0.04331453f, 0.00806507f, 
    0.08368993f, -0.03229427f, -0.04717377f, 0.02964760f, -0.05077253f, -0.03251666f, 0.06008649f, -0.04916155f, 
    -0.07970822f, 0.12745750f, -0.17567445f, 0.07898251f, 0.22065225f, -0.12826255f, 0.16317889f, -0.08728046f, 
    -0.13839151f, -0.02962428f, -0.09086049f, -0.12379184f, -0.20853694f, -0.05458290f, 0.02988855f, -0.01281836f, 
    0.03451009f, 0.07128717f, 0.00901774f, 0.01184799f, -0.03253836f, -0.10514535f, 0.01608234f, -0.00944753f, 
    0.29543859f, 0.18488406f, -0.36504075f, -0.02216360f, 0.08443550f, -0.06810755f, -0.11424369f, 0.15400635f, 
    0.19924006f, 0.04734711f, -0.11056616f, 0.01160834f, -0.03711739f, 0.02999745f, 0.00902118f, 0.02373769f, 
    0.09159563f, -0.06066440f, -0.05271836f, -0.05965929f, -0.15919815f, -0.04193910f, 0.20135169f, 0.06724827f, 
    -0.03142397f, -0.15913345f, -0.04290424f, -0.06435770f, 0.10049764f, 0.02436819f, 0.09580763f, 0.02236507f, 
    0.12725382f, 0.03406675f, -0.05519881f, -0.06628769f, 0.02604946f, -0.03430739f, 0.02404341f, -0.02239110f, 
    0.07265241f, 0.10247441f, 0.14997549f, -0.05662609f, -0.13449049f, -0.01773732f, -0.01841608f, -0.02302865f, 
    -0.17377359f, 0.05246845f, -0.04824934f, 0.02417837f, -0.01886213f, -0.04629194f, 0.05448582f, -0.04255196f, 
    0.01589761f, 0.12631838f, -0.10323994f, 0.11394326f, 0.08807579f, 0.06486358f, -0.33907491f, 0.14826992f, 
    -0.15792412f, -0.11039655f, -0.01139100f, -0.00831731f, -0.05946789f, 0.04357714f, 0.13475452f, 0.08208721f, 
    -0.04835981f, -0.08872151f, -0.01801049f, -0.06512246f, 0.00119577f, 0.08397306f, 0.07665689f, 0.01439158f, 
    0.07773378f, -0.06566557f, 0.30084145f, 0.08729747f, -0.20447832f, 0.10238431f, 0.17060010f, -0.11239526f, 
    0.02572959f, -0.04479882f, 0.15280405f, -0.07150301f, -0.00048297f, 0.00968275f, -0.00268586f, 0.00634319f, 
    0.01598606f, -0.16998732f, 0.02016135f, 0.04196342f, -0.52497119f, 0.11860229f, 0.20025392f, -0.03226093f, 
    0.01756695f, -0.12146244f, -0.06219328f, -0.01438525f, 0.03090118f, -0.04136645f, 0.14383011f, -0.01477919f, 
    -0.05592269f, -0.18238726f, -0.00611376f, 0.11065201f, -0.04938893f, -0.13281333f, 0.00655938f, -0.00760064f, 
    -0.16144037f, -0.19887456f, 0.15785566f, 0.03769886f, -0.02074542f, -0.00320906f, 0.01008576f, -0.01092279f, 
    -0.07081071f, 0.10202885f, 0.18250750f, 0.03114415f, -0.04630667f, -0.11793604f, 0.00926034f, 0.02933124f, 
    -0.09396392f, -0.03959749f, -0.04826191f, 0.05753433f, 0.04372295f, -0.09094554f, 0.04427484f, -0.03022024f, 
    0.12044936f, 0.02902705f, 0.13553572f, 0.05472563f, -0.02835646f, -0.00360557f, -0.02658665f, -0.11363520f, 
    0.06399567f, 0.12152689f, -0.01553307f, -0.22365265f, 0.05815691f, -0.11587147f, -0.06679672f, 0.02593225f, 
    0.08049965f, 0.13423817f, -0.16082723f, 0.05216295f, -0.34799901f, -0.02023130f, 0.08057838f, 0.05166638f, 
    -0.00295596f, -0.18918954f, -0.05180480f, -0.19100463f, -0.00274969f, 0.08954908f, -0.00276786f, 0.02565733f, 
    -0.04367930f, 0.07987903f, -0.00133377f, 0.07591046f, 0.05770160f, -0.06118624f, 0.00950104f, 0.06318688f, 
    0.15512474f, 0.01315780f, 0.13095935f, -0.04207781f, 0.19141443f, 0.04949943f, 0.11141360f, 0.01394626f, 
    0.03371315f, -0.01159449f, 0.07638495f, 0.11368325f, 0.01335083f, 0.05935851f, 0.17758167f, 0.15579045f, 
    -0.11541970f, -0.40424374f, 0.14484432f, 0.30548617f, 0.01495348f, -0.11874824f, 0.08568387f, 0.04572251f, 
    -0.06378581f, -0.05302424f, 0.05721306f, 0.13241242f, 0.00737791f, -0.02059757f, -0.01746291f, 0.01777423f, 
    -0.10760842f, 0.16619238f, 0.01824907f, 0.00112358f, -0.32860863f, -0.02281265f, -0.13309318f, 0.05640502f, 
    0.23691598f, 0.21693136f, 0.09434953f, 0.02059602f, 0.13535568f, 0.05110453f, 0.06827208f, 0.02323082f, 
    0.02357164f, -0.08766993f, -0.01609345f, -0.01761522f, 0.00261072f, 0.07686930f, 0.13702278f, -0.10213792f, 
    -0.24681789f, 0.17806746f, 0.02030725f, -0.08054291f, -0.08721353f, -0.04514716f, -0.02991305f, -0.12138361f, 
    -0.05076192f, -0.04550978f, -0.18720992f, 0.08692541f, 0.00656433f, 0.10250989f, 0.07823811f, -0.09804949f, 
    0.08678555f, 0.04701465f, -0.03177934f, -0.12878516f, -0.36131316f, 0.51670796f, -0.29637155f, -0.33887312f, 
    -0.07099319f, 0.04757636f, 0.13459432f, 0.01921887f, 0.00844450f, 0.00616129f, 0.00134139f, 0.05505912f, 
    -0.03159245f, 0.06559934f, 0.02571762f, -0.05683314f, 0.10078930f, -0.11201313f, -0.07487693f, 0.06810965f, 
    -0.33090883f, 0.24185219f, -0.02604015f, 0.20004730f, -0.22467397f, 0.02925233f, -0.12756597f, 0.03261266f, 
    0.03835920f, -0.19099440f, -0.02138647f, -0.06710573f, -0.03580602f, 0.11680416f, 0.07557518f, -0.05389405f, 
    -0.16968083f, 0.01105501f, -0.11223093f, 0.08550978f, 0.41956401f, -0.19976458f, -0.05750976f, -0.17761724f, 
    -0.07346439f, 0.02015450f, -0.16335163f, -0.00241374f, -0.16413453f, 0.06907414f, 0.04029250f, 0.01175451f, 
    -0.00383190f, -0.17531992f, 0.04519358f, 0.03889965f, -0.06612033f, -0.07808698f, 0.00603093f, -0.13275646f, 
    -0.74712777f, 0.08736823f, 0.04111518f, 0.20755179f, 0.31328338f, 0.13022530f, -0.11468620f, -0.08316974f, 
    0.12620082f, 0.04133809f, -0.12421374f, -0.05646154f, 0.07041574f, 0.03727011f, 0.01654841f, 0.01100706f, 
    0.13986365f, 0.05451578f, 0.08713576f, -0.13686718f, -0.13131480f, 0.19890593f, 0.06698717f, 0.15782322f, 
    -0.05729629f, 0.08900965f, -0.02061051f, -0.02945508f, 0.06379719f, -0.07371508f, 0.09284102f, 0.02042186f, 
    -0.02995692f, 0.04760041f, -0.03124352f, -0.18195677f, -0.11527158f, -0.01417506f, -0.12558052f, -0.06560521f, 
    -0.04785476f, -0.20256364f, -0.00901591f, 0.06833312f, -0.13622752f, 0.05280022f, 0.00399937f, 0.01785837f, 
    -0.10566597f, -0.18805987f, 0.04305858f, 0.02109567f, -0.03224679f, -0.01660343f, 0.03716751f, -0.14820534f, 
    0.03797292f, -0.11246179f, 0.02843608f, -0.08034712f, 0.21557231f, -0.09123650f, -0.37961695f, 0.11112714f, 
    -0.22815871f, -0.01503261f, -0.11585422f, 0.02556099f, -0.14540601f, 0.04526441f, -0.11797946f, 0.07454514f, 
    0.01383489f, -0.06622824f, -0.02304562f, 0.01196839f, 0.00517733f, 0.09445701f, -0.07972392f, -0.07360215f, 
    -0.21683432f, -0.43463174f, 0.04176287f, 0.30229589f, -0.05482596f, -0.15830263f, -0.03904703f, -0.00829434f, 
    -0.18898706f, -0.06790721f, 0.06205530f, 0.06810681f, -0.04483625f, -0.04861515f, 0.08100651f, -0.08467428f, 
    -0.05980642f, 0.06564290f, 0.02174082f, 0.05781141f, -0.02949116f, 0.13130784f, -0.16611820f, -0.20284413f, 
    0.09767203f, -0.04497424f, 0.01733106f, -0.11738163f, 0.10860999f, -0.06043551f, 0.02122705f, -0.02459588f, 
    -0.10009914f, 0.03151776f, -0.02157922f, 0.04867119f, -0.01330287f, -0.00797146f, 0.09484798f, 0.01594225f, 
    0.10476364f, 0.05280863f, 0.20338131f, -0.13483915f, -0.14623548f, 0.09272429f, -0.00903742f, 0.04181017f, 
    0.10212536f, 0.00252608f, -0.02477249f, -0.01525924f, -0.08401580f, 0.05902658f, 0.17561023f, -0.06371453f, 
    -0.01005147f, -0.05724780f, 0.11493170f, -0.08986687f, -0.80137891f, 0.03908840f, 0.05564884f, 0.17704520f, 
    0.21824504f, 0.10091040f, -0.00390545f, 0.08862513f, 0.03846944f, 0.13501769f, -0.01519752f, 0.03271775f, 
    0.08532665f, 0.01361313f, 0.04715461f, -0.01893522f, 0.07057348f, 0.13490368f, 0.09323428f, -0.07027997f, 
    0.15738565f, 0.11889955f, 0.08735895f, -0.02611330f, -0.02571306f, -0.04038606f, 0.05208398f, 0.02280733f, 
    0.00955253f, 0.05061453f, -0.06615452f, -0.10643979f, 0.04585188f, 0.02955231f, -0.03001446f, -0.06198098f, 
    0.07419193f, 0.04680735f, 0.01962653f, 0.13556518f, 0.16943999f, -0.16255045f, -0.07626522f, -0.06107636f, 
    0.07978456f, -0.11828843f, 0.06974217f, -0.00596258f, 0.01288380f, 0.10789343f, -0.05513800f, -0.05974875f, 
    0.06491114f, 0.17161149f, -0.04444543f, -0.04782637f, -0.12019739f, 0.03461751f, 0.00310909f, -0.18595208f, 
    -0.48671433f, -0.07872619f, -0.05710096f, -0.13324873f, -0.13449685f, 0.02109441f, 0.04834731f, -0.00529849f, 
    0.01522810f, 0.13186850f, -0.03804872f, -0.03773088f, -0.01191302f, 0.04742051f, -0.07437480f, 0.04304861f, 
    0.05647287f, -0.01392439f, 0.12501432f, -0.04587132f, -0.67383879f, -0.14246567f, -0.01681532f, 0.07617670f, 
    0.13162340f, 0.09713424f, -0.02139287f, -0.02196173f, 0.05484755f, -0.01958151f, -0.03692129f, -0.09905796f, 
    -0.01874182f, 0.03324310f, -0.02595536f, -0.05501587f, -0.02124597f, -0.07559547f, 0.00053835f, -0.02120342f, 
    0.01004788f, -0.29990175f, -0.01715282f, 0.09769816f, -0.05526815f, 0.03931844f, -0.03631373f, 0.08007675f, 
    0.03979007f, 0.13248621f, 0.02061982f, -0.05807652f, -0.03792328f, -0.04861129f, -0.00514589f, 0.09357624f, 
    0.03638328f, -0.06380820f, -0.01244236f, -0.11489996f, 0.12352809f, -0.04222458f, 0.20894699f, 0.05905669f, 
    -0.03675865f, -0.11564254f, -0.02416084f, 0.08028419f, 0.02310849f, 0.05818190f, 0.09927464f, -0.03622962f, 
    0.00288036f, -0.10241398f, -0.02364995f, 0.01407450f, 0.07168911f, 0.00833581f, 0.08327091f, 0.05965529f, 
    0.03683718f, -0.16491097f, 0.02755799f, -0.01044710f, -0.04080597f, 0.07199086f, 0.05107736f, 0.00627203f, 
    -0.02893419f, -0.03599798f, 0.02097751f, -0.08943413f, 0.07248620f, 0.00098948f, 0.16364981f, 0.00574014f, 
    -0.06087369f, 0.00468617f, -0.04347236f, 0.16115677f, -0.22180773f, 0.22120087f, -0.04456380f, -0.04441679f, 
    0.21365562f, 0.04974012f, 0.07931066f, -0.01495419f, -0.00818986f, 0.10630864f, -0.10290357f, 0.05582918f, 
    -0.02696876f, 0.07612886f, -0.02653283f, 0.03321691f, 0.01937395f, -0.13739055f, 0.04444306f, 0.01264295f, 
    -0.41839853f, -0.09937229f, 0.24678265f, 0.09117501f, -0.31462607f, 0.13141043f, 0.02967369f, -0.13345180f, 
    -0.01175064f, -0.07339747f, 0.05345567f, -0.06563404f, -0.03724043f, 0.01510916f, -0.14382017f, -0.03052190f, 
    0.05331899f, 0.13063374f, 0.14850862f, 0.07076308f, 0.07676397f, -0.02587719f, 0.11135658f, 0.22166266f, 
    0.08861247f, 0.10898148f, -0.02415280f, 0.12482774f, -0.05279087f, -0.05618891f, -0.02957086f, -0.00992560f, 
    0.02090399f, -0.00124937f, 0.07638537f, 0.06729012f, -0.01582211f, 0.14995992f, 0.05465959f, -0.00811873f, 
    0.11488870f, -0.13038872f, 0.27736780f, 0.26612985f, -0.00736432f, -0.06504437f, -0.08216414f, -0.07224671f, 
    0.08744496f, -0.00759885f, -0.03965634f, -0.10233891f, -0.05884202f, 0.16583407f, -0.02493083f, 0.05853461f, 
    0.03034471f, -0.19692658f, -0.12113855f, 0.01067744f, -0.13545725f, -0.25697392f, -0.06008196f, -0.19088762f, 
    0.00540882f, 0.08067878f, -0.02441111f, -0.10158346f, 0.14000957f, 0.21586339f, -0.06726559f, 0.09053583f, 
    0.18353702f, -0.14389305f, -0.13230370f, 0.09410651f, -0.13291186f, -0.07471463f, 0.09351251f, 0.19372432f, 
    -0.15428120f, -0.09839725f, -0.11135052f, 0.22403757f, -0.04977111f, -0.02045065f, 0.02227288f, 0.03233236f, 
    -0.07129676f, 0.05492041f, -0.00377892f, 0.08390846f, 0.12956847f, -0.00250650f, -0.13578354f, -0.05488983f, 
    -0.03189443f, -0.25050664f, -0.17602871f, 0.10818438f, -0.02196829f, -0.01821677f, -0.01047226f, 0.05037693f, 
    -0.25669473f, -0.10129505f, 0.09642549f, 0.09095880f, 0.01391523f, -0.02672533f, -0.03289306f, 0.01216003f, 
    0.03198180f, 0.02546158f, 0.14966354f, -0.18717401f, -0.06723705f, 0.11806067f, 0.03777587f, 0.03789193f, 
    -0.01443611f, 0.09720921f, 0.11000948f, 0.17063038f, 0.13483530f, -0.06172638f, -0.00839576f, 0.08702229f, 
    0.00500779f, 0.11272216f, -0.05044070f, -0.13929196f, 0.08120825f, -0.08578485f, 0.08394094f, 0.03543189f, 
    0.01550378f, 0.03586763f, -0.04008558f, -0.09181084f, 0.15997389f, 0.00382791f, -0.26360911f, -0.03532747f, 
    -0.08799084f, 0.03465950f, -0.09259437f, 0.01295224f, -0.03493949f, 0.12577824f, 0.02972282f, -0.03311905f, 
    0.01613248f, -0.15786834f, -0.01759355f, 0.03131805f, -0.06556690f, -0.00187874f, -0.13463017f, -0.09981441f, 
    -0.06151504f, 0.03036589f, 0.01431108f, 0.06721152f, 0.30865642f, -0.02259029f, -0.07245785f, 0.03106762f, 
    -0.00636943f, 0.05826189f, 0.11636321f, 0.01581156f, 0.11198487f, 0.01840787f, -0.00676723f, -0.12569462f, 
    0.15000096f, -0.28193441f, -0.02877256f, -0.01239182f, -0.35925138f, -0.03238376f, -0.17171374f, -0.09356194f, 
    -0.02218520f, 0.06524278f, 0.16176254f, 0.16356823f, -0.04774466f, 0.04096189f, -0.01296488f, 0.23162149f, 
    0.18615358f, -0.06978659f, 0.14270391f, -0.13348603f, 0.02258392f, -0.03668254f, -0.03869131f, -0.03392983f, 
    0.27265564f, 0.13128768f, -0.00076368f, -0.10377218f, 0.07624380f, -0.06646857f, -0.11580329f, -0.07525684f, 
    0.15325010f, 0.06949256f, -0.04461189f, -0.18989930f, 0.12041727f, 0.19541070f, 0.13446583f, -0.16619903f, 
    0.02427852f, 0.01994612f, -0.05582239f, -0.14292052f, -0.53817296f, -0.11130277f, -0.27375120f, -0.33433512f, 
    0.06045305f, 0.16935863f, 0.13985172f, 0.11829220f, 0.02327872f, -0.08589191f, -0.04283828f, 0.15754060f, 
    -0.23911139f, -0.00890046f, -0.04537649f, 0.03271771f, 0.03935373f, 0.00902186f, -0.13405113f, 0.04362698f, 
    -0.01983407f, 0.26789370f, -0.07998270f, 0.05279887f, 0.11200016f, -0.08715072f, 0.11700551f, 0.10814621f, 
    0.00147424f, -0.11151217f, 0.03759624f, -0.05850562f, -0.07415604f, -0.13365565f, -0.04331602f, -0.04199526f, 
    0.05604063f, -0.04946743f, 0.00855753f, 0.09137697f, -0.35528013f, -0.05992289f, 0.18040583f, 0.21015774f, 
    -0.39138952f, -0.03026146f, -0.03536936f, 0.00407393f, -0.02191572f, -0.03239818f, -0.03626839f, 0.06125585f, 
    0.03232201f, -0.04090109f, 0.11039271f, -0.01613167f, 0.03553174f, 0.02354895f, 0.05002851f, 0.02254050f, 
    -0.12648310f, -0.00276079f, -0.23581447f, -0.10278798f, 0.14032862f, 0.09651367f, 0.05685500f, -0.03268828f, 
    -0.12337212f, 0.02406331f, 0.14736143f, 0.03988891f, -0.02473048f, -0.04921306f, 0.02935505f, -0.05431106f, 
    0.05240069f, -0.02419043f, 0.09301312f, -0.15889925f, -0.22485772f, -0.04412717f, 0.15017536f, 0.01880847f, 
    0.11293250f, 0.00362812f, 0.02235169f, -0.06729673f, -0.11275581f, 0.14645439f, 0.08462729f, -0.04788736f, 
    -0.09697424f, 0.03023560f, -0.19051793f, -0.03078859f, 0.03044080f, 0.14099918f, 0.01702820f, -0.03379569f, 
    -0.21963803f, 0.33882752f, -0.51637530f, -0.19900443f, 0.04575397f, 0.07127676f, 0.19250919f, 0.10280059f, 
    0.03354577f, -0.08890095f, -0.02899698f, 0.00835335f, -0.21449773f, -0.10694882f, -0.06598712f, -0.09685947f, 
    -0.02419180f, 0.06524451f, 0.06200681f, -0.08887739f, -0.29289711f, -0.17473298f, -0.09793884f, 0.11647955f, 
    0.22320811f, -0.04412983f, -0.14831088f, 0.08079185f, 0.15425238f, 0.02759565f, 0.10316648f, 0.03959123f, 
    0.04952050f, 0.15048993f, 0.11211006f, 0.02722180f, 0.09539939f, -0.17934154f, 0.02676413f, -0.14359254f, 
    -0.05717222f, -0.00157071f, 0.15460105f, 0.16051103f, 0.20223457f, -0.09946839f, -0.06221646f, 0.05603560f, 
    -0.11064646f, 0.04440840f, -0.00224806f, -0.22236408f, -0.01030576f, 0.05206447f, 0.03550333f, -0.00318635f, 
    0.04242555f, -0.21907662f, -0.00833269f, 0.05211832f, 0.08733084f, 0.25828671f, 0.04774751f, -0.28348342f, 
    -0.00719129f, 0.04651941f, -0.02406825f, -0.09659556f, -0.08070674f, 0.02250549f, -0.01626971f, 0.12304310f, 
    0.04151015f, -0.04040674f, -0.07339475f, 0.04769956f, -0.01788282f, -0.08006951f, 0.15317027f, 0.06089740f, 
    0.13630578f, 0.03864450f, 0.06722303f, 0.24441198f, 0.14976542f, -0.14059789f, -0.05715217f, -0.02640992f, 
    0.08478009f, 0.07290041f, -0.06497274f, -0.20024350f, 0.03572448f, 0.20763437f, 0.13624446f, 0.10112664f, 
    0.05229477f, -0.08352830f, -0.04968407f, 0.06459446f, -0.46548614f, 0.11728368f, -0.29652348f, 0.02814382f, 
    -0.12118861f, 0.05375063f, 0.05795463f, 0.09846437f, -0.18504488f, 0.05046606f, 0.01018681f, 0.04702094f, 
    0.04465817f, -0.19824786f, 0.02563518f, 0.07224540f, 0.06125540f, -0.07932524f, 0.00492094f, -0.10977775f, 
    -0.42071593f, -0.42360297f, 0.02084577f, 0.11829225f, -0.06473508f, -0.01349353f, 0.14988104f, -0.06264266f, 
    0.01209220f, -0.09768554f, 0.01708754f, -0.10792550f, 0.01249698f, 0.05153905f, 0.01040128f, 0.00738601f, 
    -0.03977942f, -0.10932133f, -0.00589104f, -0.03844488f, -0.27377135f, 0.12791732f, -0.30010384f, -0.22229663f, 
    -0.03842618f, 0.03941164f, 0.06630907f, 0.04031331f, -0.06923836f, -0.19415893f, 0.03333888f, -0.00090336f, 
    -0.00211931f, -0.03551427f, 0.04098736f, 0.05906055f, 0.01831884f, -0.06537477f, 0.07868079f, 0.01225328f, 
    -0.20211719f, 0.02077085f, 0.11111332f, 0.25403279f, -0.34253296f, 0.03478272f, -0.11769927f, 0.06505731f, 
    -0.00241091f, 0.07339057f, -0.05284630f, 0.00564594f, 0.00237745f, -0.11968128f, 0.08425043f, -0.10602526f, 
    -0.18002574f, -0.12342564f, 0.09480862f, -0.09252492f, -0.19253047f, 0.28352237f, 0.08847716f, 0.01297378f, 
    -0.00584409f, -0.01141760f, -0.12033149f, 0.05230179f, 0.07249434f, -0.18659906f, -0.03637289f, 0.14791957f, 
    -0.05824231f, -0.12640683f, -0.00747811f, 0.08819752f, 0.05612556f, 0.07486635f, 0.05088767f, 0.04382973f, 
    -0.14174117f, 0.15605524f, -0.18326329f, -0.14885682f, 0.00818717f, 0.12377990f, 0.04148548f, -0.07274497f, 
    0.05358453f, -0.06617022f, 0.03543122f, 0.01774618f, -0.01533238f, 0.08433761f, 0.12625466f, -0.03073374f, 
    -0.02260855f, 0.03726449f, -0.21186383f, -0.02063393f, -0.43734470f, 0.18958089f, -0.20363751f, -0.04316724f, 
    -0.15913613f, -0.02535531f, -0.04858018f, 0.04297272f, -0.08082055f, -0.12751043f, 0.00806130f, 0.04149269f, 
    -0.04363549f, -0.04511903f, -0.06459258f, 0.06717576f, 0.01679344f, 0.02046916f, 0.06167838f, -0.03741291f, 
    0.18294924f, 0.22846055f, 0.12870869f, -0.02586561f, -0.05017914f, -0.00472842f, 0.12681533f, -0.06404125f, 
    -0.12318879f, 0.04613871f, 0.06996856f, 0.01662908f, -0.01828369f, 0.06080427f, 0.03125229f, 0.08377913f, 
    0.05145359f, 0.03043087f, 0.06040661f, 0.06869160f, 0.18571040f, -0.00495963f, 0.05786657f, 0.09309524f, 
    0.01538977f, -0.05813047f, 0.04525303f, -0.14266689f, -0.10381999f, 0.08231521f, 0.02544193f, 0.07235721f, 
    0.19794261f, 0.11015747f, 0.09491754f, -0.03600780f, -0.08360858f, 0.09807882f, 0.08146644f, 0.03278450f, 
    -0.34402341f, -0.05626927f, 0.03703537f, 0.00535855f, -0.10309181f, -0.24095368f, 0.03156305f, -0.01838732f, 
    -0.02549013f, 0.06662247f, -0.11552386f, 0.07698725f, -0.07442965f, 0.08042076f, -0.12986292f, -0.00860265f, 
    0.01718514f, -0.22705571f, -0.00249749f, 0.00208858f, -0.44215381f, -0.34992212f, -0.09278469f, -0.18451065f, 
    -0.16436359f, 0.16849947f, -0.07546277f, 0.09891208f, 0.05015088f, -0.13025689f, 0.11556665f, 0.03738486f, 
    -0.00520191f, -0.01550170f, -0.02498830f, 0.07264780f, -0.01492427f, 0.04323751f, 0.03670689f, 0.07283527f, 
    0.34419629f, -0.30044717f, -0.06235261f, 0.17745872f, 0.00176730f, -0.09191380f, -0.02125067f, 0.07554875f, 
    0.02193291f, 0.11141808f, -0.00448065f, 0.06424614f, -0.25493130f, -0.06091700f, 0.11099399f, -0.00465967f, 
    0.01586044f, -0.13993406f, -0.14776014f, -0.17461148f, -0.28779128f, 0.34493664f, -0.01838003f, 0.16339326f, 
    -0.28142494f, -0.14157163f, 0.01340094f, -0.01574956f, -0.00012277f, 0.13416441f, -0.03668899f, 0.02502890f, 
    -0.00075619f, -0.09829646f, 0.09709205f, -0.02208120f, 0.01801836f, -0.05375057f, -0.02104019f, 0.02881736f, 
    -0.13093801f, -0.02933604f, -0.10658923f, 0.18034941f, 0.02862983f, 0.05004704f, 0.02209475f, 0.03854607f, 
    -0.05771995f, 0.01957044f, -0.07313684f, 0.07265135f, -0.07413009f, 0.04950587f, -0.00264156f, -0.05859078f, 
    0.04773861f, 0.19210647f, 0.09426566f, -0.00554253f, 0.07220888f, -0.18766680f, 0.03340368f, -0.29519382f, 
    0.19106187f, -0.03990262f, 0.13690621f, 0.04185481f, -0.07068120f, 0.03193366f, 0.01024521f, -0.10830267f, 
    -0.13008705f, 0.02401083f, -0.09776486f, -0.06242745f, 0.04794505f, -0.00048821f, 0.13213554f, -0.11046419f, 
    -0.08682931f, 0.08976037f, 0.07049195f, -0.08808539f, 0.30183324f, -0.03189671f, -0.01453737f, 0.00590954f, 
    -0.10940639f, 0.02571934f, -0.16396327f, 0.00843934f, -0.18608063f, -0.01560332f, 0.02161770f, 0.05807450f, 
    -0.00656154f, 0.12136313f, 0.26800627f, -0.04320912f, -0.02976198f, 0.10103007f, 0.20712866f, 0.18731911f, 
    -0.34795943f, 0.12401163f, -0.10408100f, 0.03222586f, -0.05117174f, 0.04202534f, -0.16332912f, -0.01098039f, 
    0.08826320f, 0.04852488f, -0.03098076f, 0.11850490f, 0.04837598f, 0.02028149f, -0.04930096f, -0.15255998f, 
    0.02840159f, 0.24698666f, 0.13633326f, 0.05244647f, 0.04752197f, -0.06580324f, -0.03127865f, -0.09868640f, 
    0.01847583f, -0.06119929f, -0.09056310f, 0.08794937f, 0.01360192f, 0.06723006f, -0.02224131f, 0.05238243f, 
    0.08779059f, -0.12931012f, 0.04989298f, -0.00871739f, 0.10015933f, -0.32954356f, 0.11788559f, -0.27582261f, 
    -0.11337065f, 0.06476999f, -0.06447371f, 0.06534050f, -0.06867653f, -0.13369554f, -0.01626193f, -0.07275485f, 
    -0.05499262f, 0.05185666f, 0.02730191f, 0.06949479f, 0.03814032f, 0.01623208f, 0.17169739f, 0.09307129f, 
    -0.17031944f, -0.28318924f, -0.22061372f, 0.04226411f, 0.09859952f, -0.08408570f, 0.09079367f, 0.01376684f, 
    -0.13211046f, 0.04926284f, -0.03000090f, -0.05085928f, 0.03503178f, -0.01129347f, -0.12604736f, 0.09649202f, 
    0.02610926f, 0.12877943f, 0.02487440f, 0.07409021f, -0.20251302f, 0.03562985f, -0.05976170f, -0.38946247f, 
    0.16478492f, -0.09160654f, -0.06862921f, -0.21257791f, -0.13703793f, -0.15388431f, 0.03388185f, 0.04306860f, 
    -0.10015233f, -0.03734624f, 0.01669799f, 0.05511846f, 0.00952479f, 0.05402029f, -0.03065871f, 0.09134223f, 
    -0.01756544f, 0.24641462f, -0.04018795f, -0.37064195f, -0.27750590f, 0.07560162f, 0.04359429f, 0.20540701f, 
    0.02496159f, 0.06558055f, 0.01511594f, -0.01369948f, -0.18813963f, -0.02077467f, -0.10137242f, 0.02202928f, 
    -0.01050046f, -0.07151071f, 0.11355518f, 0.11569875f, -0.30467567f, -0.02603392f, -0.04742446f, -0.42186308f, 
    0.08832025f, -0.00661493f, -0.11503474f, -0.03016533f, 0.02215031f, 0.00019241f, -0.05452552f, -0.00393111f, 
    0.07201342f, 0.01499185f, 0.02512136f, -0.02617412f, -0.02486619f, -0.02446577f, 0.07837117f, 0.05165577f, 
    0.24028412f, -0.32144883f, -0.12210450f, -0.10793007f, 0.04847851f, 0.02587826f, 0.16397578f, -0.04076288f, 
    0.03966384f, 0.01891442f, -0.07798945f, -0.02301423f, 0.10053828f, 0.04708178f, 0.18363670f, 0.19350788f, 
    -0.03018685f, 0.07927790f, -0.21514165f, 0.17909409f, 0.44641685f, -0.22224022f, -0.03936227f, 0.12176032f, 
    0.20799790f, -0.01301412f, -0.01758164f, 0.01845576f, 0.12744491f, 0.01004893f, -0.02876956f, -0.03639789f, 
    -0.07231457f, -0.01281236f, -0.09201244f, -0.02107922f, 0.06144723f, -0.04679439f, -0.06620306f, -0.01989535f, 
    -0.06573293f, -0.31224486f, -0.23003300f, -0.35712266f, 0.35906205f, -0.12807854f, -0.06954502f, 0.04464997f, 
    0.06095770f, -0.06580825f, -0.04798167f, 0.03497715f, -0.08309136f, 0.01363136f, 0.07639142f, 0.02817881f, 
    0.03665853f, 0.12241028f, 0.00030050f, 0.17141680f, -0.62221825f, 0.21839853f, 0.05767136f, 0.27109179f, 
    0.10098220f, 0.15912756f, -0.08641572f, 0.13303208f, 0.05629440f, -0.16199552f, 0.00884942f, -0.01844545f, 
    0.07184555f, -0.00212996f, -0.15753749f, 0.09558822f, 0.01794937f, -0.18884826f, -0.10119146f, 0.12836519f, 
    0.03438498f, -0.37092045f, 0.01639660f, -0.53966016f, 0.23162700f, 0.02577191f, -0.09332915f, -0.12204330f, 
    0.02304353f, -0.02181169f, 0.03867471f, -0.01110655f, 0.12161636f, 0.07980645f, 0.01026622f, 0.09638266f, 
    0.00180586f, -0.03895018f, -0.03886109f, 0.07314654f, 0.08329786f, 0.07898390f, -0.10592033f, -0.16165115f, 
    -0.02148999f, -0.00547605f, 0.07005446f, 0.03464505f, -0.09910998f, 0.10947074f, -0.05845347f, -0.14323111f, 
    -0.07919369f, -0.09429553f, -0.00943739f, -0.15104173f, -0.04905641f, 0.24547237f, -0.12064631f, 0.02717150f, 
    -0.14780316f, 0.01878388f, -0.14480433f, 0.19543713f, -0.23345673f, 0.12930182f, 0.12680696f, 0.00408447f, 
    0.08090714f, 0.05491665f, -0.06734174f, 0.00675871f, -0.04433110f, 0.00655002f, -0.21903117f, 0.03134288f, 
    -0.00611699f, 0.15253045f, 0.06022509f, -0.06196943f, -0.06829999f, -0.15006568f, -0.16751650f, 0.02903471f, 
    0.16444650f, -0.04704835f, 0.02769686f, 0.08128635f, 0.05321373f, -0.01765443f, -0.03965439f, -0.01130171f, 
    -0.01005289f, 0.01351049f, -0.13857116f, 0.04051036f, -0.02796133f, -0.05368659f, 0.04460337f, -0.10464337f, 
    -0.13616385f, 0.20720655f, 0.06095407f, -0.09483416f, -0.29191920f, 0.04113232f, 0.07268388f, -0.01760939f, 
    -0.00995852f, 0.03846889f, -0.05424650f, 0.00060991f, -0.05897734f, -0.05827573f, -0.25738835f, 0.05211734f, 
    0.01192636f, 0.02748964f, -0.01956878f, -0.03198580f, 0.21522452f, -0.19364668f, -0.19564730f, -0.04655571f, 
    -0.03728553f, -0.01731013f, 0.14147063f, -0.05999607f, 0.06487378f, -0.09144595f, 0.02555891f, 0.08873926f, 
    0.08475918f, 0.00618692f, -0.03342304f, -0.02309361f, -0.02198210f, 0.00431840f, -0.13653269f, 0.11258233f, 
    0.11026540f, -0.07157369f, 0.08793962f, 0.11182912f, 0.19722761f, -0.15235496f, -0.05181869f, 0.14996849f, 
    0.02270872f, -0.04985967f, 0.02997811f, 0.11156546f, 0.04398660f, 0.09740840f, -0.14382793f, 0.12165477f, 
    0.01266970f, 0.16690774f, 0.01386066f, -0.02059924f, 0.13607173f, -0.41339406f, -0.02811345f, -0.22437355f, 
    0.04639236f, -0.03105285f, 0.03661983f, -0.10275947f, 0.00160502f, -0.09052118f, 0.01355954f, 0.03486170f, 
    0.05998795f, 0.13741632f, 0.03510650f, -0.03215010f, -0.02559800f, -0.07976639f, -0.10241604f, 0.01410576f, 
    -0.06448448f, 0.24122424f, -0.15550062f, 0.18513204f, -0.21439345f, -0.05401671f, 0.14842388f, 0.01076217f, 
    0.12301725f, -0.00304388f, 0.09815919f, 0.18191370f, 0.06532527f, -0.02110483f, -0.04207889f, -0.02975523f, 
    0.04007647f, 0.20432015f, -0.06775155f, 0.12732746f, -0.13673103f, -0.35628688f, 0.04121237f, 0.10704169f, 
    0.10789957f, 0.15049949f, -0.04153299f, -0.04927454f, -0.02219349f, 0.03505934f, 0.17703079f, -0.08041542f, 
    0.09579169f, 0.03659324f, -0.07823485f, -0.02833223f, 0.05678914f, -0.16093716f, -0.02193802f, -0.10799060f, 
    0.53198642f, 0.00629485f, -0.09362263f, -0.10778312f, -0.06625573f, -0.04926471f, 0.09578218f, 0.10694404f, 
    -0.02824034f, -0.06785988f, 0.06301092f, 0.07065536f, 0.14257823f, -0.10403005f, -0.03710563f, 0.00291043f, 
    -0.03212105f, 0.10418511f, 0.05284107f, 0.08352018f, 0.09232599f, -0.32248840f, 0.06022810f, -0.00715234f, 
    0.26217178f, 0.00690568f, 0.00112627f, 0.00196048f, 0.02202642f, -0.00358986f, -0.12281049f, 0.02609741f, 
    0.05735695f, 0.05474518f, 0.12733695f, -0.10084165f, -0.10825051f, 0.00064789f, -0.03202117f, 0.05142250f, 
    -0.33025315f, 0.10677426f, -0.12591365f, 0.10986631f, -0.09135526f, -0.12293296f, -0.02125113f, -0.02156726f, 
    0.12742215f, -0.00435730f, -0.05307404f, -0.05721045f, 0.06219322f, -0.04231229f, 0.01601785f, -0.10045198f, 
    -0.07157393f, -0.06074024f, -0.10391930f, -0.10245605f, -0.55514956f, 0.29608038f, 0.13680920f, 0.08104801f, 
    -0.39874789f, 0.00201510f, -0.22179775f, 0.01887658f, 0.09669216f, -0.03758018f, -0.00914486f, 0.00929628f, 
    -0.14891808f, 0.07465590f, -0.05003237f, 0.05607999f, -0.02626020f, -0.14853072f, 0.02959452f, -0.07248858f, 
    0.20523702f, -0.02748175f, -0.08258224f, 0.19506072f, 0.03788701f, -0.03953344f, 0.00122684f, -0.12680598f, 
    -0.07564364f, -0.05095539f, 0.06241487f, -0.18948038f, -0.20018649f, 0.00479373f, 0.08300086f, -0.09276909f, 
    -0.03951584f, 0.01363463f, -0.04211073f, 0.03297798f, 0.13110262f, -0.36278170f, -0.05413837f, 0.10859799f, 
    -0.09473552f, -0.02903613f, 0.05841642f, 0.00140012f, -0.01052415f, -0.05395000f, -0.01568313f, -0.02644116f, 
    -0.00759157f, 0.00841500f, 0.17137146f, -0.14011133f, 0.04473399f, 0.08880385f, -0.12142947f, -0.04621533f, 
    0.09666540f, -0.25102028f, -0.00299216f, -0.02103374f, -0.10568804f, 0.05896155f, -0.11870005f, -0.00926760f, 
    -0.11629587f, -0.02300410f, -0.00291833f, -0.02378312f, -0.12163217f, -0.02600764f, -0.09801950f, 0.03744088f, 
    0.04715066f, -0.06708167f, 0.01102722f, 0.03891023f, -0.17504369f, -0.06087428f, -0.26439413f, -0.23586236f, 
    -0.19220850f, 0.01697335f, -0.12946951f, -0.08898092f, -0.00362452f, -0.09379338f, -0.17550412f, 0.02003905f, 
    0.03787705f, -0.01802670f, -0.07084467f, -0.00887352f, -0.03676264f, -0.01100445f, 0.02699478f, 0.02807938f, 
    -0.36172059f, 0.03243893f, 0.01090725f, -0.05447412f, 0.21566744f, 0.01432898f, -0.18448433f, -0.17443028f, 
    -0.02659982f, -0.06240075f, 0.06528526f, -0.06847425f, -0.02694103f, -0.05659097f, -0.01679918f, 0.01435645f, 
    -0.07408655f, 0.07050584f, 0.00621297f, -0.02441372f, 0.21867140f, 0.18388881f, 0.11506487f, 0.02248046f, 
    0.17191045f, -0.06263624f, 0.17242137f, -0.10161684f, 0.09427132f, 0.00292406f, -0.08959267f, 0.04614387f, 
    -0.10660502f, 0.00015442f, -0.01814084f, -0.09635773f, 0.02226324f, 0.14165071f, -0.06109036f, -0.04241391f, 
    -0.03432710f, 0.05414491f, 0.06559803f, 0.02432440f, 0.13995644f, 0.12327728f, -0.03017913f, -0.06663756f, 
    0.05266274f, 0.01139597f, -0.00940858f, 0.06292772f, 0.02373424f, -0.10593605f, -0.02599638f, 0.06104192f, 
    -0.02434426f, 0.05906866f, 0.10313746f, -0.04541985f, 0.19570376f, -0.58558142f, -0.05791816f, -0.11944135f, 
    -0.26715791f, 0.04857401f, -0.00917569f, 0.00425530f, -0.01039550f, -0.12258394f, -0.00243146f, -0.05850665f, 
    -0.08752202f, 0.05697511f, 0.04580653f, 0.03673374f, 0.09862132f, -0.05519641f, 0.00855222f, -0.08750366f, 
    -0.07739794f, -0.06694835f, -0.29396278f, -0.02581975f, 0.00493520f, -0.14359580f, -0.10381329f, -0.00433831f, 
    -0.00374678f, -0.07308371f, -0.16741706f, -0.05537425f, 0.00632179f, 0.04589555f, -0.06326097f, -0.00412311f, 
    -0.02887874f, -0.02824875f, -0.02703908f, 0.02489918f, 0.24289964f, -0.19334356f, 0.07525206f, 0.01716883f, 
    0.13111700f, 0.03174433f, 0.05820268f, -0.05587971f, -0.06452991f, 0.02282299f, 0.00796509f, 0.04641559f, 
    -0.01066199f, 0.01291467f, -0.05028652f, -0.12108654f, -0.06359896f, -0.12438665f, -0.00680192f, -0.08733973f, 
    -0.15015991f, 0.18483171f, -0.07252426f, -0.04775192f, 0.10799447f, -0.04441734f, 0.03844035f, -0.10526563f, 
    -0.10775580f, -0.01737528f, -0.08167998f, 0.01174795f, -0.12886432f, -0.05304236f, -0.05162113f, -0.00635985f, 
    0.02129252f, 0.09206098f, 0.01539750f, -0.04319310f, -0.08625662f, 0.18328635f, 0.19710299f, 0.16345294f, 
    0.16888270f, 0.21613480f, 0.13988557f, -0.02066405f, -0.03851561f, -0.04480043f, -0.06439267f, -0.09456268f, 
    -0.05114115f, -0.03628838f, -0.12758262f, 0.07547840f, -0.00503444f, -0.00214371f, 0.00946905f, 0.05570681f, 
    0.12341741f, -0.10280839f, -0.23105441f, -0.07641730f, 0.13090597f, -0.12439013f, -0.19573277f, -0.10905349f, 
    -0.01214242f, -0.08910353f, -0.15363595f, 0.08090582f, 0.02534628f, -0.07875903f, -0.05765948f, -0.09598405f, 
    0.04338504f, -0.05444430f, 0.00221453f, -0.02205935f, 0.15609814f, 0.04065833f, 0.28944662f, 0.21091074f, 
    0.09882820f, 0.16519992f, 0.12894216f, 0.01025540f, -0.03358193f, -0.03711424f, -0.09011517f, 0.06452470f, 
    0.01800292f, -0.00106495f, -0.05901751f, -0.02333059f, 0.03106291f, -0.01629973f, 0.05525580f, -0.13616377f, 
    -0.06555078f, 0.28115559f, 0.16301765f, -0.08033465f, -0.01951040f, -0.03426361f, 0.04905107f, -0.03543894f, 
    -0.06748902f, 0.01084273f, 0.03135494f, 0.01487849f, -0.03025442f, 0.16205931f, -0.20709933f, -0.04841033f, 
    -0.06675114f, -0.07885768f, -0.05219334f, -0.03015420f, 0.03952964f, -0.12518927f, -0.07053126f, 0.01592058f, 
    -0.22809255f, 0.04495669f, -0.13139412f, -0.00159458f, 0.02661067f, 0.01334021f, -0.10951473f, 0.05047289f, 
    0.05046587f, -0.08397710f, -0.04852661f, 0.15354054f, 0.04713114f, 0.09126858f, 0.02761311f, 0.02351497f, 
    -0.10401187f, 0.06800897f, 0.10831946f, 0.11384282f, 0.17627825f, -0.13514796f, 0.16386852f, -0.03633743f, 
    -0.04655478f, 0.00750546f, -0.09626999f, 0.08082757f, -0.19011615f, -0.12905265f, -0.07862294f, -0.03995760f, 
    0.04110763f, 0.09700165f, -0.06154018f, 0.03097863f, 0.20023078f, 0.14802720f, 0.06288372f, -0.29487872f, 
    0.12358040f, 0.11037634f, 0.08023866f, 0.05978675f, -0.09083201f, 0.05791023f, -0.02292759f, 0.07474424f, 
    0.04823119f, -0.14861642f, 0.00010037f, -0.01299439f, 0.02324410f, -0.10283217f, -0.03692759f, 0.04435200f, 
    0.23046750f, 0.05276546f, 0.31365004f, 0.10221787f, 0.25177449f, 0.06805254f, 0.20814815f, 0.01227043f, 
    0.03341277f, 0.02209165f, 0.02039087f, 0.03037896f, -0.04708066f, 0.02111549f, -0.00860789f, -0.08340729f, 
    0.06443389f, 0.05570498f, 0.01879993f, -0.03237062f, 0.00153873f, 0.07377028f, -0.11313600f, -0.00050359f, 
    0.14155996f, -0.12453837f, 0.04140427f, -0.13542733f, -0.08069787f, -0.08610244f, -0.02394241f, -0.00943131f, 
    -0.08984330f, -0.05948062f, -0.02547190f, -0.14383551f, -0.06296397f, 0.07645712f, -0.12720363f, -0.10524882f, 
    -0.22726481f, -0.00342436f, -0.05756243f, -0.04801046f, 0.04425993f, -0.01583118f, -0.09259446f, -0.12104282f, 
    0.02545961f, -0.12551357f, 0.02406706f, -0.02040193f, 0.00615238f, -0.01240942f, -0.06622154f, -0.07081369f, 
    -0.07743195f, 0.04572298f, 0.01526126f, -0.08605941f, 0.03541017f, 0.13711564f, 0.00199874f, -0.02455298f, 
    0.13940462f, -0.05922661f, 0.09586512f, -0.02369329f, 0.01997835f, 0.07223614f, -0.09849139f, 0.02289707f, 
    -0.07907669f, -0.05300991f, 0.00820058f, 0.03918738f, -0.02760933f, 0.01891265f, -0.02357398f, -0.00639948f, 
    -0.25375780f, -0.03482856f, -0.16877942f, -0.08028486f, 0.08502755f, -0.03321252f, -0.07432754f, -0.23337731f, 
    0.00598378f, -0.05584104f, -0.09680507f, -0.05123096f, 0.08619945f, -0.03290033f, -0.08441222f, -0.11774509f, 
    -0.01799880f, 0.03257297f, -0.00441601f, 0.05933176f, -0.04158165f, 0.15754594f, 0.23015396f, 0.05899924f, 
    0.17343974f, 0.10359087f, 0.24733743f, 0.01459145f, -0.02721011f, -0.02718481f, -0.05204105f, -0.03248142f, 
    0.01481082f, -0.04173372f, -0.04419032f, -0.07025842f, -0.04477034f, -0.00777835f, -0.01280230f, 0.04916515f, 
    0.07489064f, -0.07322142f, 0.07319871f, -0.00034901f, -0.14806421f, 0.12556025f, -0.16975144f, -0.01807768f, 
    -0.00994212f, -0.01818872f, -0.04290397f, 0.23457709f, 0.03948434f, -0.16105613f, -0.16923335f, 0.07267080f, 
    0.17065682f, -0.02026371f, 0.10411665f, 0.03316894f, 0.07541452f, 0.06220324f, 0.24201824f, 0.08203147f, 
    0.13002710f, 0.06810952f, 0.14406547f, -0.01252981f, -0.00117826f, -0.01171807f, -0.03481061f, -0.03447503f, 
    -0.00417975f, 0.00134265f, -0.06096167f, -0.07496464f, 0.02538458f, -0.01286837f, 0.00048888f, -0.06181543f, 
    -0.09695436f, 0.21295559f, 0.03318799f, 0.17982742f, 0.04965273f, 0.06292331f, -0.13041306f, -0.07709317f, 
    0.03049281f, -0.04505669f, -0.01688468f, 0.05263927f, 0.06194660f, 0.05472604f, -0.14227024f, 0.02280286f, 
    -0.08131109f, -0.01278353f, -0.01580973f, -0.07304934f, -0.06018109f, -0.05219379f, 0.02519415f, -0.10700619f, 
    -0.15341841f, -0.03933225f, 0.05332261f, -0.10316014f, -0.07414445f, 0.03654872f, 0.03227521f, 0.03041605f, 
    -0.10842630f, -0.03850081f, -0.11421295f, -0.01349975f, 0.00397699f, 0.04001940f, -0.01524150f, 0.00733460f, 
    0.29671133f, 0.07216533f, 0.19855151f, -0.09895024f, 0.26101449f, -0.08786130f, 0.10943124f, -0.03216318f, 
    -0.08641668f, 0.03256653f, -0.06558178f, 0.05379503f, -0.10533426f, 0.01692545f, -0.03481856f, -0.02282041f, 
    0.04137208f, 0.08335903f, -0.02623771f, -0.00081447f, -0.03825684f, -0.04362076f, 0.03677063f, 0.08942756f, 
    0.13470383f, -0.08114687f, 0.02230654f, -0.08353100f, 0.06340607f, -0.01620392f, -0.04581945f, 0.04756981f, 
    0.01733719f, -0.03170650f, -0.01808737f, 0.00307562f, -0.12462045f, -0.04163308f, 0.00386683f, -0.01245688f, 
    -0.26469988f, 0.07368392f, 0.06320748f, -0.13973312f, -0.21022637f, -0.08017705f, -0.08469877f, 0.01466954f, 
    -0.08284583f, -0.11642030f, 0.07501952f, 0.05568562f, -0.01373696f, -0.06208923f, -0.06691250f, -0.01255569f, 
    0.00555181f, -0.05956272f, -0.06562679f, -0.02992060f, -0.23122619f, -0.45679450f, -0.11068046f, -0.30153325f, 
    -0.35451895f, -0.03958455f, -0.04678916f, -0.01462091f, -0.07277057f, -0.06597188f, -0.02417816f, 0.03662471f, 
    -0.03529983f, -0.04268676f, -0.02945494f, -0.01454078f, -0.00323628f, -0.01195756f, -0.02747300f, 0.02851008f, 
    -0.16022941f, 0.14328222f, 0.04253567f, 0.06632406f, 0.10674202f, 0.03289430f, -0.14439742f, -0.06253424f, 
    0.04174746f, 0.01881878f, -0.01324254f, 0.03089021f, -0.03243958f, -0.04500693f, -0.03430077f, 0.01844108f, 
    -0.02331948f, 0.17351393f, 0.06144883f, -0.08910993f, 0.12145038f, -0.09051256f, 0.14745332f, 0.07492365f, 
    0.10924418f, 0.09849997f, 0.05440003f, -0.05505916f, -0.03031811f, 0.00909686f, 0.02110868f, 0.03356718f, 
    -0.03271379f, 0.00683772f, 0.00421725f, -0.08433898f, -0.11644508f, 0.01821780f, 0.06510662f, -0.10185626f, 
    0.20242272f, 0.09443082f, 0.12714535f, 0.05471303f, 0.19985072f, -0.02893967f, -0.08228726f, -0.04861998f, 
    -0.09654541f, -0.02175939f, -0.10297694f, -0.00411717f, -0.02450112f, -0.15463790f, 0.01005993f, 0.06832330f, 
    -0.00803415f, 0.10568842f, 0.02895657f, 0.11880410f, 0.07922443f, 0.09758381f, -0.07128812f, 0.07108200f, 
    0.18141307f, 0.07916972f, 0.06595572f, -0.14403592f, -0.07876914f, -0.00015907f, 0.05583105f, 0.07244300f, 
    0.01795037f, -0.01821996f, 0.07123515f, -0.12375707f, 0.05925202f, 0.08586138f, 0.05492717f, -0.03350943f, 
    -0.18420209f, 0.09085796f, -0.30415720f, -0.19997308f, -0.08491432f, 0.12529235f, -0.05095454f, -0.12980628f, 
    0.02632949f, -0.03562742f, 0.05544274f, -0.00196968f, 0.04993567f, 0.02810897f, 0.01232535f, 0.11241048f, 
    -0.15615283f, -0.20630759f, -0.04465554f, -0.00592891f, -0.24693444f, 0.16660801f, 0.08019028f, -0.07412448f, 
    -0.26062164f, 0.00236596f, -0.03532622f, 0.00451889f, 0.03299372f, -0.19077414f, 0.14400107f, 0.05420030f, 
    0.10882396f, 0.05498330f, 0.06164058f, -0.05949222f, -0.00274506f, -0.19141850f, 0.06922587f, 0.12804072f, 
    -0.25097719f, 0.09693352f, -0.08600515f, -0.19063234f, -0.23943749f, -0.00332264f, -0.07758638f, -0.12470070f, 
    -0.08121879f, -0.02713371f, 0.05081733f, 0.04958142f, 0.07491155f, -0.01592738f, -0.01309788f, -0.11771181f, 
    -0.08169933f, -0.24295008f, -0.03945795f, 0.03316810f, 0.21459886f, -0.19483881f, -0.19674340f, 0.09618551f, 
    0.09495481f, 0.10638145f, 0.01914879f, -0.03375868f, -0.11400044f, -0.02010518f, -0.08233180f, 0.04123999f, 
    -0.01486355f, 0.09804896f, -0.02076082f, -0.02643397f, 0.04154643f, 0.06084221f, 0.08517990f, -0.08271820f, 
    -0.01043497f, -0.04538222f, -0.00563345f, -0.04818640f, 0.08232126f, 0.09019750f, 0.05637546f, -0.11624003f, 
    -0.06865526f, -0.07974839f, 0.10985192f, 0.01578409f, -0.00118049f, 0.07743192f, -0.09199395f, -0.04341707f, 
    0.10060707f, 0.08810706f, 0.03774135f, -0.11628787f, 0.04295741f, -0.15859319f, 0.19307366f, -0.06845450f, 
    0.04674533f, -0.00935991f, 0.02508358f, 0.03863307f, -0.00481718f, 0.04368363f, -0.10359534f, -0.01594092f, 
    -0.09373651f, -0.04503499f, -0.04806618f, -0.08913771f, -0.03369208f, 0.12731956f, -0.05226567f, -0.02781273f, 
    -0.00655336f, 0.20930240f, 0.05400855f, -0.00303734f, -0.18517169f, -0.11402638f, 0.06203920f, -0.02683260f, 
    -0.18039599f, 0.08491933f, 0.06375168f, -0.02980249f, 0.04860205f, -0.09000202f, -0.02531138f, -0.16678093f, 
    -0.00201475f, -0.25325096f, 0.06279139f, 0.03335003f, -0.24097221f, -0.14934130f, 0.29010674f, -0.22931597f, 
    -0.21841995f, -0.02908139f, 0.02051419f, -0.02648273f, -0.01537747f, -0.01819581f, -0.02409531f, 0.02204364f, 
    -0.10313425f, -0.04013287f, -0.05444975f, -0.15403943f, -0.06905590f, -0.15682617f, -0.21981609f, -0.15206094f, 
    -0.28129983f, -0.28193495f, 0.02222470f, -0.32993183f, 0.08405164f, 0.02732638f, -0.04005270f, -0.08413212f, 
    -0.03178605f, -0.01134016f, 0.13916428f, 0.08640995f, 0.11713528f, 0.02122544f, 0.02909755f, 0.08340937f, 
    0.09717074f, 0.12131114f, -0.07466049f, -0.05041761f, -0.41267309f, -0.15743402f, 0.20244175f, -0.06588843f, 
    0.09984337f, -0.08483829f, 0.03070455f, 0.05150662f, -0.07202951f, -0.07488251f, 0.03837764f, -0.02293952f, 
    -0.06124877f, 0.02526366f, 0.08767571f, -0.03661942f, 0.09910910f, 0.05984405f, -0.13170303f, 0.04279488f, 
    0.13898854f, -0.01837878f, -0.00264481f, -0.00017508f, -0.11464717f, -0.05684623f, -0.04062824f, -0.05296568f, 
    -0.07000745f, 0.10444239f, 0.06494857f, -0.10307315f, 0.03546201f, -0.03632352f, 0.15116481f, 0.03776214f, 
    -0.11324789f, -0.19679013f, 0.09610675f, -0.07526664f, 0.01771774f, 0.00009936f, -0.23292372f, -0.01107462f, 
    0.06530324f, 0.06950383f, -0.02978678f, -0.03909887f, 0.02803467f, -0.01477062f, 0.11981653f, -0.05493497f, 
    0.05653122f, -0.03092240f, 0.09169181f, 0.05891595f, 0.01943207f, -0.02185753f, 0.04081429f, 0.03269935f, 
    -0.00029296f, 0.24596530f, 0.27215499f, -0.06080265f, -0.08983311f, -0.06238614f, -0.01676072f, 0.06674116f, 
    -0.14202332f, -0.02730434f, 0.02724988f, 0.00754822f, 0.04258195f, -0.08748513f, 0.02241959f, -0.12438390f, 
    0.00967026f, -0.08883354f, 0.12211103f, -0.10399181f, -0.14972408f, 0.24281339f, -0.25667116f, -0.09777318f, 
    -0.06497756f, 0.04542993f, -0.02644549f, -0.09011774f, -0.06877010f, 0.07990115f, -0.02446377f, 0.07489730f, 
    -0.01801294f, 0.04067570f, 0.06222042f, -0.05243837f, -0.19532752f, 0.01991149f, -0.00299149f, -0.04226815f, 
    -0.19482411f, 0.05752861f, 0.14187413f, -0.05631322f, 0.02644200f, 0.04993135f, 0.00069869f, 0.10326490f, 
    -0.00766099f, 0.07818069f, 0.01231879f, 0.01659915f, -0.23805080f, -0.10613391f, -0.04213692f, -0.03372953f, 
    0.06210837f, 0.04944308f, 0.03458687f, -0.09710903f, 0.07337886f, 0.08451938f, 0.06090785f, -0.12547956f, 
    -0.15709747f, -0.13834472f, 0.01346842f, -0.01992201f, 0.03996235f, -0.10166136f, 0.07452977f, 0.08129037f, 
    0.05066714f, 0.08362050f, 0.01260804f, 0.01191976f, -0.01857727f, -0.23349880f, -0.06090563f, 0.07007911f, 
    -0.01323752f, 0.20779346f, -0.42008692f, -0.05686428f, -0.02092319f, 0.00552438f, 0.01921650f, -0.07258802f, 
    -0.11758532f, 0.03434622f, -0.02118804f, 0.03963318f, 0.05878809f, 0.03564456f, 0.03267624f, 0.00457770f, 
    -0.03391537f, -0.18238090f, 0.01084582f, 0.04257214f, -0.13165070f, 0.14173017f, 0.07789107f, -0.05845409f, 
    -0.05533588f, -0.12690401f, -0.00012349f, -0.06001287f, 0.02480734f, -0.05801198f, 0.12745567f, -0.05690086f, 
    -0.01425028f, -0.08481237f, 0.04324295f, -0.05998488f, -0.04013406f, -0.01256180f, 0.11747599f, -0.04218975f, 
    -0.03591917f, -0.16164796f, -0.27424186f, -0.26575261f, -0.10722218f, 0.04941406f, -0.02979062f, -0.00998283f, 
    0.02464746f, -0.03051933f, 0.12373102f, 0.00718335f, 0.05276705f, -0.03694818f, 0.04463883f, -0.01677366f, 
    0.08229097f, 0.04566943f, 0.07756690f, -0.01777079f, -0.18102989f, -0.24992235f, 0.26656494f, -0.00592025f, 
    0.03076721f, -0.18545288f, -0.13212317f, -0.01666044f, -0.05026033f, -0.00435898f, -0.02901034f, 0.04774284f, 
    -0.03458761f, 0.02720415f, 0.04315380f, -0.04459922f, -0.04230804f, -0.04418845f, 0.05421475f, -0.04059215f, 
    0.01861940f, 0.01810534f, -0.14739729f, 0.11160009f, -0.00254075f, 0.12803553f, -0.03314622f, -0.25163311f, 
    -0.18649724f, 0.03778734f, 0.06698482f, -0.02156108f, -0.04771894f, -0.00877470f, -0.09013677f, 0.06736241f, 
    0.00352737f, -0.07528161f, 0.09913401f, 0.07182521f, -0.07502390f, -0.01943391f, 0.14146273f, 0.06300162f, 
    0.14561480f, -0.14663205f, -0.05044161f, 0.07331531f, -0.09666800f, 0.02116346f, -0.03286652f, -0.09096576f, 
    -0.15117407f, -0.06809096f, 0.03937156f, 0.04983212f, -0.01853396f, -0.01315568f, 0.07756959f, 0.03163031f, 
    -0.17656484f, -0.09732719f, -0.05236129f, 0.12375179f, 0.00407221f, 0.10517325f, -0.11161637f, -0.24300055f, 
    0.06503376f, -0.07379971f, 0.06299848f, -0.00917155f, 0.08832300f, -0.02226755f, 0.19512482f, -0.14038712f, 
    0.04204279f, -0.00384789f, 0.16911897f, -0.11950662f, 0.13619319f, 0.08289304f, -0.02738601f, 0.05799944f, 
    0.15546112f, -0.05089675f, -0.06350826f, 0.03019154f, -0.07064122f, -0.00962334f, 0.08734135f, 0.01492379f, 
    0.00355245f, -0.06230326f, 0.05586380f, 0.01385063f, 0.08387432f, 0.04177909f, 0.03877372f, 0.04362352f, 
    -0.27266732f, -0.18597898f, -0.05608863f, -0.33216456f, -0.22034745f, 0.01373282f, 0.03043470f, 0.02097611f, 
    -0.16952889f, -0.03149728f, -0.06066617f, 0.03561873f, -0.08527884f, 0.09844042f, 0.04069419f, -0.01143552f, 
    -0.01515483f, -0.07644965f, -0.10291410f, 0.06053653f, -0.07547108f, 0.09870521f, 0.16881090f, 0.06423210f, 
    0.17488302f, -0.09435185f, -0.08691334f, -0.03072784f, -0.11093888f, -0.10364789f, -0.04847375f, 0.01621339f, 
    -0.04254538f, -0.00702664f, 0.00505581f, -0.04150078f, 0.05246593f, 0.08137043f, 0.03482599f, -0.07435395f, 
    0.28550357f, 0.20574754f, -0.09713244f, 0.13041160f, 0.07280292f, -0.03993499f, 0.05143965f, -0.14759362f, 
    -0.03370532f, -0.07527488f, -0.07049466f, 0.05455905f, -0.10527110f, -0.07038101f, 0.07031603f, -0.11001229f, 
    0.03053672f, -0.04067701f, 0.11170334f, -0.05379353f, 0.08980108f, -0.02311459f, -0.03457243f, 0.19077319f, 
    0.17974652f, 0.10162763f, 0.08047836f, -0.15062767f, -0.06590177f, -0.07465737f, 0.03086182f, 0.00241482f, 
    0.04334016f, -0.08189055f, 0.00492661f, -0.13000260f, -0.06795370f, 0.05693601f, 0.06867608f, -0.14142895f, 
    -0.22420910f, 0.14390820f, -0.02861997f, -0.11160946f, -0.24778445f, 0.04193445f, 0.02949324f, 0.00101143f, 
    0.09003819f, -0.12226329f, 0.07329223f, 0.16061532f, 0.09415558f, 0.02981262f, 0.00774058f, 0.07892667f, 
    -0.04084392f, -0.20153250f, 0.06360678f, 0.01333663f, -0.07352131f, -0.07610019f, 0.17180395f, 0.11070072f, 
    0.17363816f, -0.14900020f, 0.01330756f, 0.00549849f, -0.04196970f, -0.00775278f, 0.05447810f, -0.01181982f, 
    0.02723235f, 0.09555055f, -0.08077648f, 0.04606852f, 0.04504571f, 0.05307404f, 0.00211009f, 0.11393490f, 
    0.14915468f, -0.26133236f, 0.11892188f, -0.09579340f, 0.00704152f, 0.21258371f, 0.08007962f, -0.01762652f, 
    -0.10334819f, -0.02229141f, -0.02399531f, 0.02691788f, 0.15532635f, 0.18528853f, 0.00426775f, -0.02743577f, 
    -0.03532359f, -0.27497727f, -0.17501283f, -0.19640727f, 0.02387700f, 0.06733931f, 0.03610381f, -0.25567162f, 
    -0.37978959f, 0.00774483f, 0.17797938f, -0.06768915f, -0.10165472f, -0.02899010f, -0.01599483f, 0.00835575f, 
    -0.13170519f, -0.08953711f, -0.03254413f, -0.02998131f, 0.10602952f, -0.20367499f, -0.16399409f, -0.12924369f, 
    -0.23052181f, -0.11116411f, 0.14865170f, -0.20815469f, 0.12081976f, -0.12603390f, 0.00801023f, -0.06554785f, 
    0.19002408f, 0.02333524f, 0.00025633f, -0.00619951f, 0.06497449f, -0.11100350f, -0.08322344f, -0.01588930f, 
    0.05028679f, -0.00352815f, 0.06274208f, 0.00073488f, -0.38147879f, 0.14396514f, 0.04728114f, 0.15689392f, 
    0.02307048f, 0.03886481f, 0.02907179f, -0.07339107f, -0.11151355f, -0.11484192f, 0.02514402f, -0.07756728f, 
    -0.02066523f, 0.06503970f, 0.15327242f, 0.08585589f, 0.03714614f, -0.01602808f, -0.12308937f, 0.05894082f, 
    0.21460226f, -0.45196807f, -0.08591145f, 0.15599261f, -0.00020652f, -0.06355835f, -0.05621644f, 0.08238900f, 
    0.08682770f, -0.11494539f, 0.00140144f, -0.06130446f, -0.13724615f, -0.01558542f, 0.01112397f, 0.04527666f, 
    0.00536576f, 0.21697843f, 0.10153878f, 0.12156714f, 0.07072107f, -0.47251463f, 0.35538048f, -0.23570018f, 
    -0.20739903f, 0.13088714f, 0.08289330f, -0.10095575f, -0.03444471f, 0.04772181f, -0.02630552f, -0.03163194f, 
    0.01208948f, 0.00953616f, 0.00503169f, -0.08938765f, 0.05676680f, 0.04166602f, 0.08586484f, 0.04127832f, 
    0.16470556f, -0.17538193f, 0.09519095f, -0.07919226f, -0.56347346f, 0.12434549f, 0.15127127f, 0.12175523f, 
    -0.07490586f, -0.06264973f, -0.18907574f, -0.15453412f, -0.02156014f, -0.01213882f, 0.01418281f, -0.18522078f, 
    -0.00446621f, 0.10000839f, 0.08326842f, 0.05569746f, 0.13666753f, 0.02116043f, -0.09543479f, 0.17004509f, 
    -0.05589923f, -0.02740551f, -0.04792557f, 0.10396753f, 0.07549333f, 0.01721775f, 0.11616252f, 0.04973165f, 
    0.07039051f, -0.00400078f, -0.10520288f, 0.27600536f, 0.00971399f, 0.02973506f, 0.05641244f, 0.03314007f, 
    -0.43730846f, 0.39699298f, -0.00716110f, 0.01006409f, -0.03669447f, 0.18327661f, 0.02447858f, -0.05865778f, 
    0.11322254f, 0.04909616f, -0.12841880f, 0.03444968f, -0.04163589f, -0.07095564f, 0.16741288f, 0.14415951f, 
    0.02319066f, 0.19232409f, -0.16102566f, -0.00419652f, -0.15572767f, -0.26128477f, -0.10769214f, 0.30398270f, 
    0.06093591f, -0.05025329f, 0.10556471f, 0.00202886f, -0.17090406f, 0.06741414f, -0.05735637f, -0.01936493f, 
    -0.05954400f, 0.06920835f, -0.03539205f, 0.13702759f, -0.07520382f, -0.00031981f, 0.04764612f, -0.05412130f, 
    0.04876658f, -0.26769173f, 0.15189122f, -0.28742567f, -0.30527404f, -0.08857209f, -0.04723537f, 0.00273578f, 
    -0.09651456f, -0.02148317f, 0.02543887f, 0.12264322f, 0.12597606f, -0.14865243f, -0.03437664f, -0.00588779f, 
    0.15837710f, -0.05638183f, 0.07715343f, -0.01774180f, 0.19919761f, -0.11299684f, -0.17483380f, 0.17187509f, 
    -0.06100477f, -0.16426238f, 0.00580327f, -0.04876160f, 0.02509292f, -0.05577154f, -0.03629515f, -0.02749817f, 
    0.02001044f, -0.00225749f, 0.19997680f, -0.00523504f, -0.05764382f, 0.04528485f, -0.03220914f, 0.07730392f, 
    -0.46434000f, -0.03850458f, -0.19278468f, 0.05680912f, 0.11753368f, 0.18759097f, -0.09741211f, -0.11993492f, 
    -0.02804551f, 0.10472675f, 0.10399565f, -0.02893776f, -0.02989888f, -0.02983874f, -0.08366583f, 0.15972087f, 
    -0.00730901f, 0.03638379f, 0.03581858f, -0.11287641f, 0.04041710f, -0.11202784f, 0.04006815f, -0.39707336f, 
    0.19644281f, -0.07807923f, 0.03935378f, -0.08793431f, -0.04267631f, -0.00344224f, 0.04613944f, -0.09083536f, 
    -0.11735707f, 0.01044979f, -0.01015535f, 0.01225807f, -0.06865062f, 0.00549717f, -0.11164605f, -0.05987632f, 
    -0.02435117f, 0.37452856f, -0.13069156f, 0.18534361f, -0.12010849f, 0.16145039f, 0.09852189f, -0.01583638f, 
    0.15228422f, 0.26109064f, -0.14236574f, -0.03408416f, 0.05415322f, 0.02171846f, 0.08238853f, 0.19332509f, 
    0.03783005f, 0.00105645f, -0.11972938f, -0.13228339f, 0.06081599f, -0.20133564f, 0.17552602f, 0.08459615f, 
    -0.35540551f, -0.13471515f, -0.08491208f, -0.05571957f, 0.16025244f, 0.00762052f, -0.07579345f, -0.04479079f, 
    0.09509283f, 0.09550832f, 0.02149081f, 0.05677781f, 0.11324583f, 0.01790038f, 0.07044778f, -0.12340761f, 
    0.04811262f, -0.10921228f, -0.12545754f, 0.12112114f, -0.13944879f, 0.00160346f, 0.07604482f, 0.03728836f, 
    -0.04585995f, 0.14383750f, -0.03215380f, -0.08068816f, 0.04115495f, 0.04178975f, 0.09622316f, 0.13443318f, 
    -0.02790123f, -0.01783781f, -0.00919388f, 0.09524126f, 0.02451741f, 0.09221697f, -0.00969534f, -0.03229477f, 
    0.04806983f, 0.03845669f, 0.06666563f, -0.03503511f, -0.16313682f, -0.09307375f, 0.04084044f, 0.03741745f, 
    -0.06510367f, -0.08461178f, -0.05007354f, 0.02057256f, -0.07585584f, -0.07168467f, 0.18604197f, 0.06749861f, 
    -0.55238086f, 0.15433317f, 0.20787635f, -0.16745950f, -0.04625757f, -0.02526815f, -0.05281554f, -0.02092106f, 
    0.03994252f, -0.04774176f, -0.03974861f, 0.04878424f, -0.05471164f, 0.04674911f, -0.16738476f, 0.03100586f, 
    0.06620696f, 0.18669550f, 0.13262939f, 0.04346342f, -0.53090036f, 0.26309803f, 0.26834401f, 0.05696330f, 
    0.08412883f, -0.00629301f, -0.01816657f, -0.00919919f, 0.05546892f, -0.07819808f, 0.12856004f, -0.04170237f, 
    0.08567439f, 0.14738819f, 0.08666267f, -0.00136467f, -0.00061307f, 0.02572108f, -0.16667864f, 0.07352766f, 
    -0.09326517f, -0.08846594f, 0.15614340f, -0.25196800f, -0.35925913f, -0.10614979f, -0.00300103f, 0.09586083f, 
    0.03820414f, 0.06969783f, 0.02801421f, 0.00972233f, 0.02358088f, -0.12593201f, -0.04090415f, -0.13300349f, 
    -0.08096816f, 0.05905228f, 0.10784025f, -0.04367659f, -0.07981948f, -0.17649764f, -0.08072133f, 0.09855182f, 
    0.20021565f, 0.17417602f, -0.16084175f, 0.08799782f, -0.16836324f, 0.23699000f, -0.02748829f, -0.05268723f, 
    0.04448962f, 0.08610266f, -0.01268429f, -0.07884530f, -0.01331671f, 0.07002402f, 0.05263676f, -0.10920504f, 
    0.34563622f, -0.54433048f, 0.04606536f, 0.20690995f, -0.00302815f, 0.02838495f, -0.10515907f, 0.17291817f, 
    0.05998071f, 0.01390557f, -0.03675395f, -0.06198908f, 0.07177424f, -0.02663359f, -0.05656682f, 0.14129569f, 
    0.00084182f, -0.18796739f, -0.16446397f, 0.05579320f, -0.00615765f, -0.10982680f, -0.03257522f, 0.16336764f, 
    0.02890870f, 0.14053857f, 0.01150143f, -0.12619120f, -0.05773825f, 0.11337444f, 0.03310155f, -0.04092622f, 
    -0.12234416f, 0.00639665f, -0.04523968f, -0.03106149f, -0.14161138f, 0.02096636f, -0.00854342f, -0.02773038f, 
    -0.36664239f, -0.13771595f, 0.21108550f, -0.40155140f, -0.05233261f, -0.09818669f, 0.10167185f, -0.11192417f, 
    -0.10529137f, 0.10695022f, -0.13141650f, -0.13171308f, -0.05450845f, -0.01128185f, 0.13595261f, 0.08453309f, 
    0.07134018f, 0.04157035f, -0.23116367f, 0.05223275f, -0.13921279f, 0.00023432f, -0.08720726f, 0.23433784f, 
    -0.19212534f, 0.08949254f, 0.06262044f, -0.02035510f, 0.06995489f, -0.17121103f, -0.08164939f, 0.14721841f, 
    -0.04856225f, -0.09285133f, -0.03893191f, 0.00380320f, -0.02175231f, -0.11290444f, -0.01758986f, -0.00899554f, 
    -0.02592114f, -0.28958029f, 0.07089479f, 0.07305416f, 0.06030935f, -0.12293754f, 0.06202151f, -0.09271481f, 
    0.09051128f, 0.08010372f, -0.06654678f, 0.08838321f, 0.00824071f, 0.04234979f, 0.00290261f, -0.04789040f, 
    -0.01623641f, 0.05718683f, 0.07028665f, -0.01408139f, 0.74454647f, 0.04310583f, -0.26861069f, -0.14019313f, 
    0.11181824f, 0.12208264f, -0.03723435f, 0.04311211f, 0.03808645f, -0.00478107f, -0.06961647f, -0.07787590f, 
    0.11975459f, 0.17974713f, -0.04004697f, 0.09341102f, -0.02617547f, 0.00342860f, 0.00657753f, -0.00310482f, 
    -0.33943680f, 0.14718333f, 0.10772941f, 0.04653135f, -0.00193974f, 0.09143487f, 0.06531955f, 0.08540771f, 
    0.06233354f, -0.25945932f, 0.10011689f, 0.14773303f, -0.03116579f, 0.00226499f, 0.09979792f, 0.00631758f, 
    -0.02906159f, 0.05165986f, -0.06346339f, 0.12409128f, 0.08177856f, -0.26568109f, 0.07498726f, 0.03418006f, 
    -0.12423457f, 0.05117885f, 0.16282412f, 0.01518505f, -0.12106481f, 0.01812268f, -0.08904254f, 0.00523177f, 
    -0.02825662f, -0.16903765f, -0.00582820f, -0.07401045f, -0.06197231f, 0.03578560f, -0.28498384f, 0.03449447f, 
    -0.41190061f, -0.25820145f, 0.13312292f, 0.04491984f, -0.05639377f, 0.05873115f, 0.04900516f, 0.05083277f, 
    0.04059713f, -0.17003168f, -0.04812494f, -0.03487771f, 0.07240752f, -0.05752762f, -0.21600898f, -0.15972519f, 
    0.04503773f, 0.07015289f, 0.09254040f, -0.03656980f, 0.17672642f, -0.04441421f, -0.25201476f, 0.03761122f, 
    0.11714555f, 0.08896875f, -0.03418316f, -0.05778965f, -0.07352444f, -0.01116547f, 0.08869169f, 0.05655948f, 
    0.08853666f, -0.09222034f, 0.01694345f, -0.08501216f, -0.03304441f, -0.12767768f, 0.08179715f, 0.04605858f, 
    -0.32575217f, 0.07723863f, -0.24145025f, -0.08153926f, -0.00162345f, -0.00151273f, 0.07293850f, -0.14042398f, 
    -0.00325105f, 0.03660438f, 0.09729394f, 0.03823256f, 0.03933169f, -0.02140206f, 0.10149190f, -0.04469168f, 
    0.06928429f, 0.18334389f, 0.01459977f, 0.07154059f, -0.88102990f, -0.51168847f, -0.05655240f, -0.20993511f, 
    -0.16762623f, 0.12613165f, -0.01621188f, -0.09463493f, -0.17151545f, 0.06053810f, 0.05083539f, -0.02775045f, 
    -0.08571703f, 0.15537742f, 0.02364725f, 0.05807054f, -0.08162030f, 0.01084122f, 0.02331049f, -0.05726478f, 
    0.23513834f, 0.10704575f, 0.07431113f, 0.10954683f, 0.07963255f, 0.04237347f, 0.06164151f, 0.08320834f, 
    0.08441262f, -0.02005189f, 0.03896485f, 0.03829382f, 0.08657210f, 0.07061759f, 0.11335745f, 0.07789489f, 
    -0.10096230f, -0.21671936f, 0.00501906f, -0.08248979f, -0.05984798f, -0.20123173f, 0.03090720f, -0.05560618f, 
    0.20551918f, 0.01458146f, 0.00389204f, 0.16187876f, -0.06066914f, -0.02922743f, -0.03699327f, -0.00695096f, 
    -0.02745964f, -0.06291289f, 0.01680502f, 0.01756065f, -0.04278973f, -0.12902007f, 0.03145973f, 0.05435932f, 
    0.37052378f, 0.04847588f, -0.07292484f, 0.09786049f, 0.04875307f, -0.02596641f, -0.01441296f, -0.00425367f, 
    0.01061806f, 0.05651684f, 0.00868825f, 0.09414113f, 0.03253416f, -0.00476673f, -0.00416267f, -0.00564872f, 
    0.02605350f, -0.22917105f, -0.28119555f, -0.09705497f, -0.75157613f, -0.36737707f, -0.28523895f, -0.11684160f, 
    -0.21982476f, -0.00581380f, 0.13224633f, -0.09956153f, -0.06328212f, 0.05904951f, 0.00719491f, 0.01481134f, 
    -0.13324764f, 0.09618214f, -0.05895998f, 0.10645901f, 0.00333442f, 0.13855794f, -0.03667345f, 0.09726819f, 
    -0.58586109f, -0.25815204f, 0.03955054f, -0.07365768f, -0.29235017f, 0.06813082f, -0.01629371f, 0.01068931f, 
    -0.06096783f, 0.05723742f, 0.04800357f, 0.13356553f, 0.01950830f, 0.04819297f, 0.08511757f, 0.04375098f, 
    0.05758972f, 0.05612715f, -0.10263100f, 0.02659812f, -0.11209447f, 0.04335582f, -0.02299834f, 0.00237165f, 
    0.18542430f, -0.07671533f, 0.01550825f, -0.11266745f, 0.10599913f, 0.00236444f, 0.02204209f, 0.02206803f, 
    0.03550008f, 0.02143178f, -0.03535317f, 0.06539697f, 0.00902564f, 0.06319291f, -0.11460494f, 0.15416822f, 
    -0.22376961f, -0.09701580f, -0.05245338f, -0.02143672f, -0.13118763f, 0.03092052f, 0.08797079f, 0.05366632f, 
    0.07005166f, 0.06421956f, 0.17428252f, 0.05591802f, 0.00574930f, -0.03665604f, 0.11631789f, 0.00487227f, 
    0.03719374f, -0.09735225f, 0.10964753f, 0.03750904f, 0.29330048f, 0.09920047f, -0.02652335f, 0.09923229f, 
    -0.09373377f, 0.06385539f, -0.17398775f, 0.17429876f, -0.06569760f, 0.02147288f, -0.04038617f, -0.07912302f, 
    -0.03615674f, -0.00452646f, -0.12843668f, -0.00333532f, -0.15082175f, -0.25652358f, -0.16189080f, -0.18505977f, 
    0.16313593f, 0.20464863f, 0.18106532f, -0.09295101f, -0.20165475f, 0.13265264f, -0.09555293f, -0.04275094f, 
    0.06957692f, 0.02182218f, -0.05711217f, -0.01375918f, 0.01546510f, 0.06961951f, -0.01162041f, 0.05367848f, 
    0.05749992f, -0.09601250f, -0.14452624f, -0.05998581f, 0.12834409f, 0.01999997f, 0.02004744f, -0.12365234f, 
    -0.11230082f, 0.05631701f, -0.12099325f, -0.01729422f, 0.02641752f, 0.02836176f, -0.00767379f, 0.03942684f, 
    -0.09167919f, 0.01928806f, -0.13974045f, -0.06954512f, -0.00989394f, -0.14306155f, -0.16768368f, -0.01535045f, 
    0.12387825f, 0.09441853f, -0.22557427f, -0.00853534f, -0.23941834f, 0.00507063f, -0.03108931f, 0.03775126f, 
    0.00248840f, -0.06568212f, 0.07768553f, 0.02688728f, 0.02384482f, -0.08249360f, -0.12548606f, -0.09480433f, 
    -0.02476854f, -0.01678654f, 0.11144830f, -0.03245118f, -0.49228552f, 0.01751639f, -0.45235464f, -0.01499215f, 
    0.15054578f, 0.08786385f, -0.07133681f, -0.14193754f, -0.02467051f, 0.10824929f, 0.02399261f, -0.03803340f, 
    0.14292611f, -0.05655549f, 0.03943749f, -0.09908176f, -0.01825454f, 0.13558279f, 0.17183185f, 0.04874720f, 
    -0.15155019f, -0.03697211f, -0.05210418f, 0.07530382f, -0.16421075f, -0.09129487f, -0.03804946f, 0.03187740f, 
    0.05021323f, -0.00299012f, -0.04592555f, -0.05886257f, 0.06181350f, -0.08755004f, -0.12219657f, -0.10557608f, 
    -0.12205598f, -0.17507251f, 0.11032128f, -0.02066349f, -0.24769095f, -0.26777411f, 0.03412452f, 0.13541861f, 
    0.41506687f, 0.03352831f, 0.22961617f, -0.01592195f, -0.03424775f, -0.15500292f, -0.01498366f, 0.02090545f, 
    0.00510164f, 0.09747525f, 0.13343084f, -0.10119234f, 0.12069238f, 0.09130631f, -0.02822284f, 0.02558583f, 
    0.29995883f, -0.07563788f, -0.07868145f, -0.02515176f, -0.03640345f, -0.13639432f, -0.09102864f, -0.06769462f, 
    0.03950181f, -0.07525820f, 0.02851969f, -0.00192968f, -0.08546551f, -0.13973686f, -0.17577769f, -0.17228414f, 
    -0.09246765f, -0.14337334f, -0.19678779f, 0.03305617f, 0.23883852f, 0.03275891f, -0.07955485f, -0.11233064f, 
    -0.02605892f, 0.16329321f, 0.02741094f, -0.08103138f, 0.08255640f, 0.04397379f, 0.02671819f, -0.06540622f, 
    0.00056836f, 0.07357767f, -0.01391588f, 0.13256587f, 0.24179481f, -0.03649557f, 0.10906523f, 0.14725120f, 
    -0.14787067f, -0.18333600f, 0.12983696f, 0.14739871f, 0.04316782f, 0.08213414f, 0.11683027f, -0.03922280f, 
    0.03632586f, -0.01854015f, 0.12647356f, 0.12997398f, 0.03977558f, 0.01790135f, 0.09026695f, 0.01149036f, 
    0.04190709f, -0.01056744f, 0.03140073f, -0.01021594f, -0.09257037f, -0.13060047f, 0.01220805f, -0.01251222f, 
    0.17442602f, -0.00269632f, 0.06181927f, 0.02444326f, 0.05949880f, -0.03607754f, 0.07946745f, -0.02622565f, 
    -0.06403195f, -0.04441131f, -0.01717226f, 0.04634652f, -0.00035475f, -0.01790194f, 0.09469893f, 0.06824502f, 
    0.03036151f, 0.17831239f, 0.20184086f, 0.00952652f, 0.05279166f, 0.14433531f, 0.09821901f, -0.03530673f, 
    0.06448098f, -0.05432028f, -0.00343155f, 0.02990920f, 0.07240840f, 0.20227931f, 0.01167682f, 0.11075263f, 
    0.03645097f, -0.10624419f, -0.13789736f, -0.07151626f, 0.23984788f, 0.19682352f, -0.08164869f, 0.14813861f, 
    -0.06006840f, 0.02102107f, -0.08726076f, 0.00636288f, -0.00868844f, -0.04448603f, 0.10413932f, 0.00029547f, 
    -0.00491827f, -0.04075831f, -0.06330150f, 0.00786752f, -0.06629507f, 0.11207335f, -0.09199268f, -0.06231320f, 
    -0.18839683f, 0.02357632f, -0.29837060f, 0.08931708f, 0.05061604f, -0.05551273f, -0.06683942f, -0.19606657f, 
    -0.00439317f, 0.11988626f, -0.12365843f, 0.03252978f, 0.00692883f, -0.08858301f, 0.16575077f, 0.05215210f, 
    0.05355417f, 0.01257675f, 0.03547383f, 0.07781749f, 0.34438452f, 0.10113311f, -0.03692260f, 0.03554844f, 
    -0.04330155f, -0.19546522f, -0.08062103f, -0.05167723f, 0.00581862f, -0.08831298f, -0.01166865f, -0.00321979f, 
    -0.01054994f, -0.06601081f, -0.04974691f, -0.08674537f, -0.00608880f, -0.00884589f, -0.07996845f, 0.01664641f, 
    -0.72652209f, -0.16127266f, -0.05809292f, -0.11886851f, -0.16468230f, 0.10650166f, -0.06105013f, -0.07000078f, 
    -0.03517701f, -0.07741035f, 0.04879552f, 0.02313769f, -0.08863714f, -0.13680848f, 0.05253603f, -0.07550936f, 
    -0.23240176f, -0.13752477f, -0.10945791f, -0.05220510f, 0.15325911f, 0.01903474f, -0.07500024f, -0.06283908f, 
    0.10444282f, -0.10470765f, 0.04622727f, 0.01559137f, -0.01745009f, -0.07414895f, -0.02629710f, -0.05282130f, 
    -0.06211166f, -0.01504459f, 0.01407589f, 0.00019346f, 0.17267102f, 0.09074906f, 0.04979024f, 0.11322410f, 
    0.14921984f, 0.00308949f, 0.00148590f, 0.01245335f, -0.04240088f, -0.06893393f, 0.08952083f, 0.00669952f, 
    0.04119455f, 0.08076774f, 0.00217855f, 0.00233694f, -0.05851083f, -0.07441406f, 0.00306395f, 0.17706527f, 
    0.02465785f, -0.14013463f, -0.15396602f, 0.09575514f, 0.10899376f, 0.04562628f, 0.09369682f, 0.09571525f, 
    0.04707845f, -0.05628832f, -0.08209001f, -0.00337228f, 0.06810602f, 0.06742985f, 0.01859191f, 0.03964410f, 
    -0.01214760f, -0.10218523f, -0.00439555f, -0.07233386f, 0.01230486f, 0.13139482f, -0.00561216f, 0.03140244f, 
    -0.37840182f, -0.29882526f, -0.22264042f, -0.11754578f, -0.04328343f, 0.02926364f, 0.08971966f, -0.05740533f, 
    -0.04422697f, -0.05250737f, 0.09420170f, -0.06151379f, -0.09362650f, 0.04921908f, -0.00567181f, 0.05701671f, 
    0.10218279f, 0.06095985f, 0.11830816f, 0.05799522f, -0.62759691f, -0.16126585f, -0.17797479f, -0.09161102f, 
    -0.29742053f, 0.08696302f, 0.09063385f, -0.10445187f, -0.15400614f, -0.01778673f, 0.00259011f, -0.08137191f, 
    -0.08400193f, 0.08369596f, -0.00652363f, -0.07407531f, -0.08744568f, 0.06565957f, -0.04238329f, 0.03919944f, 
    0.29034844f, 0.06408186f, -0.00392021f, -0.03854269f, 0.09167293f, 0.00556987f, -0.05694968f, 0.16039278f, 
    0.02022784f, 0.01909907f, -0.02954747f, -0.01737755f, 0.09770536f, -0.01571630f, 0.04845789f, 0.00178358f, 
    0.18846144f, -0.15399311f, 0.09828974f, 0.16896372f, 0.10576806f, 0.10092245f, -0.09716215f, -0.06002811f, 
    -0.06316385f, -0.02535981f, -0.01176809f, -0.00809801f, 0.10506582f, -0.02565943f, -0.09244980f, -0.05806015f, 
    -0.07603429f, -0.00315980f, -0.01007614f, -0.08442870f, 0.19696414f, 0.14381933f, 0.02686372f, 0.07970656f, 
    -0.74103004f, 0.03382219f, -0.05356439f, -0.05837244f, 0.08059209f, -0.03276415f, 0.05260871f, -0.12768117f, 
    0.10549855f, 0.04670797f, -0.07779171f, -0.01457081f, 0.02164728f, 0.02111541f, -0.00526208f, -0.09281059f, 
    0.01933159f, -0.07902228f, -0.06751326f, 0.03566045f, 0.41362387f, -0.00438237f, -0.27496684f, -0.14069700f, 
    -0.20755626f, 0.05730730f, -0.00222900f, -0.08267616f, -0.00859179f, 0.04358729f, 0.07818372f, 0.06961156f, 
    0.05143974f, 0.02534037f, 0.05639840f, 0.01516398f, -0.00156588f, -0.04165454f, 0.02021288f, 0.08952620f, 
    0.21633232f, -0.07629618f, -0.12855493f, -0.00147705f, -0.04336391f, -0.21821059f, 0.06146922f, -0.08613975f, 
    0.01035292f, -0.02264774f, 0.05100778f, 0.07138688f, -0.05614562f, 0.05449354f, -0.00252855f, 0.04921968f, 
    -0.02405307f, -0.07764378f, 0.10111731f, -0.05248908f, 0.13137160f, 0.35162577f, -0.15694094f, 0.04478640f, 
    0.12239472f, 0.11906897f, -0.15323019f, -0.01491712f, 0.12527183f, -0.01045249f, 0.11714769f, 0.12108988f, 
    0.10010914f, 0.18110600f, 0.04428192f, -0.06492674f, 0.12777174f, 0.04634554f, -0.16013749f, -0.03106420f, 
    -0.12551716f, 0.05328026f, -0.15629297f, -0.14848162f, -0.04206788f, -0.25990856f, -0.06047428f, -0.02738797f, 
    0.02067817f, -0.13011263f, 0.05948991f, -0.02788402f, -0.09636594f, -0.00235918f, -0.09508752f, 0.03345627f, 
    0.06595990f, 0.09980346f, 0.05931782f, 0.02319405f, 0.69174910f, -0.06422741f, -0.25509238f, -0.00655332f, 
    -0.01888036f, -0.05555216f, -0.08835827f, 0.00786829f, 0.03816246f, 0.10860654f, 0.00134620f, 0.03319770f, 
    -0.02982653f, 0.06539037f, -0.05895176f, 0.06061997f, 0.00780441f, -0.05307882f, -0.05301348f, 0.00695504f, 
    0.19496661f, 0.19655497f, -0.17870991f, -0.23852527f, 0.30295363f, 0.11658543f, -0.10266300f, -0.01999695f, 
    0.09700630f, 0.03648875f, 0.10114560f, 0.01425494f, 0.03899128f, 0.01471175f, 0.00953716f, 0.07597993f, 
    0.00180427f, 0.00712316f, -0.04233424f, -0.03244714f, -0.53178942f, 0.15150133f, 0.05676294f, -0.03412781f, 
    0.22323360f, -0.01645382f, -0.08558119f, -0.03869333f, -0.00034974f, 0.05730534f, -0.06199382f, 0.01333608f, 
    -0.02578602f, -0.02659467f, 0.05524613f, -0.02567046f, 0.00540308f, -0.07661750f, -0.05589550f, -0.02377494f, 
    0.13376115f, -0.07299117f, -0.03371640f, -0.01627401f, 0.02893336f, 0.18846543f, -0.03254898f, -0.05887600f, 
    0.00571496f, 0.02424338f, 0.05013650f, -0.00289113f, -0.11087085f, 0.05274184f, 0.00314624f, 0.00201766f, 
    0.06148071f, 0.13879521f, -0.15838370f, -0.06383865f, 0.39176190f, 0.03844179f, -0.01654499f, -0.11454194f, 
    -0.02221096f, -0.29924378f, -0.13273677f, 0.02961754f, -0.06496147f, -0.14170469f, -0.00378792f, -0.11312900f, 
    -0.08088003f, 0.02889643f, -0.11675376f, 0.00252645f, -0.07701698f, 0.01920350f, 0.03485778f, 0.07941489f, 
    0.04642309f, 0.08543073f, -0.02397926f, -0.13662232f, 0.29264718f, -0.06554794f, -0.03163387f, 0.01447446f, 
    0.14633465f, -0.02195827f, 0.08447595f, 0.02099003f, -0.02578514f, 0.01139510f, -0.05848885f, 0.08625410f, 
    -0.20299433f, 0.03911795f, -0.01008165f, 0.24784489f, 0.00391014f, 0.20434065f, -0.06502615f, -0.09611617f, 
    -0.05697621f, -0.13254893f, -0.11804616f, -0.00430671f, -0.28168070f, -0.14613299f, 0.02569647f, -0.00668374f, 
    0.05166211f, -0.03936718f, -0.04697164f, 0.06875641f, -0.05274612f, -0.05784598f, 0.01375339f, -0.00786294f, 
    0.16085264f, -0.29987094f, 0.07190792f, 0.06876796f, -0.15125504f, -0.05091591f, 0.05857522f, 0.19760035f, 
    -0.07764355f, 0.15890449f, -0.10855688f, -0.01485064f, -0.06223374f, -0.01382428f, -0.07972946f, -0.00855693f, 
    -0.01283535f, -0.05454474f, -0.13952506f, -0.11403415f, 0.01757621f, -0.06180566f, -0.17055148f, 0.22637124f, 
    -0.08386952f, -0.04786860f, 0.19195862f, -0.03920549f, 0.00352858f, -0.01626678f, 0.02795181f, -0.11151173f, 
    -0.07065494f, 0.14161237f, 0.00695502f, 0.06320063f, -0.02104732f, -0.09374496f, -0.00278172f, -0.02659477f, 
    0.05610623f, -0.34406763f, -0.04004618f, 0.06178536f, -0.04419608f, -0.02359458f, -0.15368891f, 0.04951719f, 
    -0.02082146f, -0.01418594f, -0.04281198f, 0.03633208f, -0.02019476f, -0.01337027f, 0.00472375f, -0.14893737f, 
    0.11949251f, -0.01109248f, -0.03554466f, -0.04680783f, -0.45724720f, 0.44821796f, -0.07328621f, 0.05667387f, 
    -0.24345356f, 0.13614303f, 0.18129173f, -0.01579367f, 0.02414182f, -0.01517818f, 0.06848047f, 0.04319545f, 
    -0.04059689f, -0.03194879f, 0.11578722f, 0.02904849f, 0.12826708f, -0.02310421f, -0.03895127f, -0.04705213f, 
    -0.07739446f, 0.12388089f, 0.00249800f, 0.07914957f, -0.14852187f, -0.02143868f, -0.25367215f, -0.05161800f, 
    -0.04829656f, -0.20089497f, 0.05732705f, -0.02052836f, 0.09493741f, -0.10596493f, 0.04068075f, 0.09741911f, 
    -0.05700677f, -0.09262592f, 0.06619581f, 0.06962542f, -0.04472928f, -0.06523107f, -0.09299251f, -0.13727626f, 
    0.02642717f, 0.20812854f, -0.09000609f, 0.04464512f, 0.03227635f, 0.02536035f, 0.02075947f, -0.02628327f, 
    -0.11309937f, 0.06107933f, 0.03107321f, 0.03968016f, -0.08023118f, 0.02955084f, 0.02679581f, -0.01425705f, 
    0.18722643f, 0.05811222f, -0.05571887f, 0.08122399f, 0.03227058f, -0.01758779f, 0.10744931f, -0.08657885f, 
    -0.02205298f, -0.01339306f, 0.00718153f, 0.11022513f, -0.01147026f, 0.02080264f, 0.05608112f, -0.09281608f, 
    0.00631174f, 0.07773540f, -0.07826193f, 0.03715981f, -0.05709731f, 0.07364927f, -0.01732435f, 0.18284766f, 
    -0.01278474f, 0.15123314f, 0.03070562f, -0.01054049f, -0.02326437f, 0.05779485f, -0.00069018f, -0.01395214f, 
    0.05486742f, -0.00779019f, 0.06908383f, -0.11169180f, 0.01179150f, -0.02081317f, -0.00958216f, 0.05511510f, 
    0.31702033f, 0.22903536f, -0.25980106f, -0.00006821f, 0.21135020f, 0.08270555f, -0.00628888f, -0.09278425f, 
    0.05813910f, -0.07868250f, 0.07487651f, 0.12202592f, -0.02664182f, -0.01700165f, 0.04405118f, 0.03302412f, 
    -0.03667374f, 0.07426095f, -0.01451241f, 0.15354997f, -0.01439582f, -0.05535800f, 0.09178842f, -0.04356392f, 
    0.15972190f, -0.12162574f, 0.03198844f, 0.01749076f, 0.07303625f, -0.18788634f, -0.03714827f, -0.07663526f, 
    -0.00971212f, 0.08482297f, 0.03999586f, 0.06840191f, -0.05916481f, -0.01041653f, -0.12076001f, 0.08447758f, 
    -0.27509084f, 0.22036505f, -0.07546387f, 0.09547368f, -0.14924635f, -0.11108380f, 0.02203410f, 0.00989508f, 
    -0.01351585f, -0.19006887f, -0.05571314f, -0.03137759f, 0.14917456f, 0.02096862f, -0.08840689f, 0.00717622f, 
    -0.16891657f, 0.05556458f, -0.12696145f, -0.08197280f, -0.06544182f, -0.03050193f, 0.03180351f, -0.00696234f, 
    -0.07007957f, -0.02155415f, 0.00786978f, 0.06306273f, -0.03230628f, -0.06328589f, -0.04275426f, -0.07704919f, 
    0.03558681f, 0.05265879f, -0.00135655f, -0.08299772f, -0.04076753f, -0.06874737f, -0.08529585f, 0.03500741f, 
    0.20804159f, -0.15234771f, -0.23362389f, 0.04306515f, -0.14467078f, 0.13692825f, -0.01578347f, -0.08193720f, 
    -0.01312809f, -0.17036629f, 0.07998335f, -0.05192609f, -0.01285366f, 0.06139972f, -0.01225743f, 0.09166547f, 
    0.15320092f, -0.03960443f, -0.02222361f, -0.00062073f, -0.34565619f, -0.15622087f, -0.06391978f, 0.02192822f, 
    -0.02610520f, 0.22628199f, 0.07519939f, 0.04173908f, 0.02294092f, 0.15860082f, 0.02020651f, -0.06355030f, 
    0.01249563f, 0.01653498f, -0.10483040f, -0.13610828f, -0.08465825f, -0.04953472f, -0.01752246f, -0.18787731f, 
    -0.37667334f, 0.26449156f, -0.00781671f, 0.01463547f, 0.44495630f, 0.06303549f, -0.17679524f, 0.00371206f, 
    -0.05628119f, 0.01414693f, -0.08855079f, 0.02021377f, 0.10763956f, -0.03693946f, 0.00234536f, -0.05404358f, 
    0.04898391f, 0.11992832f, 0.07668051f, -0.03553706f, -0.33522689f, -0.07851693f, 0.02922451f, -0.10673991f, 
    0.00919413f, -0.00384160f, -0.07523642f, 0.01980195f, 0.06625137f, -0.01059156f, -0.13596976f, -0.07502331f, 
    0.07996882f, 0.03002125f, -0.01941093f, -0.05329877f, -0.13398728f, -0.02503761f, -0.12854221f, -0.00096611f, 
    -0.16883370f, -0.19855064f, -0.20578991f, -0.04876717f, -0.37727538f, 0.18585095f, 0.08221861f, 0.06828509f, 
    -0.03095177f, 0.06087215f, 0.05481689f, 0.01130491f, 0.03827650f, -0.03119446f, -0.02918738f, -0.09461960f, 
    -0.04421309f, 0.01054200f, -0.07999113f, -0.01036911f, 0.26137438f, 0.04350222f, -0.20186852f, -0.09782878f, 
    -0.36107585f, 0.04429431f, 0.03655906f, -0.01566183f, 0.04201920f, 0.04268498f, 0.04083209f, 0.01026610f, 
    -0.04463353f, -0.08662234f, 0.09171482f, -0.04523190f, -0.01672797f, -0.00558474f, -0.09348530f, 0.09358611f, 
    0.15403016f, 0.01988850f, 0.00229334f, 0.02102228f, 0.17165457f, -0.08129898f, 0.03375941f, -0.05128111f, 
    -0.04177807f, -0.01991565f, 0.00451948f, 0.11225120f, -0.05280015f, 0.02861454f, -0.12888016f, 0.12948565f, 
    -0.11359762f, 0.12319086f, -0.00515375f, -0.18830061f, -0.41518065f, 0.15456577f, -0.08498338f, -0.08944583f, 
    0.05788770f, -0.02704219f, 0.06907542f, 0.07550322f, -0.02135724f, 0.06403065f, 0.00301345f, 0.06245183f, 
    0.12071025f, -0.14340310f, 0.00634870f, -0.10962781f, -0.12195587f, -0.01643594f, -0.16627564f, -0.08386552f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.05569317f, 0.07560223f, -0.00296835f, -0.06183217f, 0.02484910f, 0.03706140f, -0.02082287f, -0.09511008f, 
    -0.01138784f, -0.03035595f, 0.05256955f, 0.04025838f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
