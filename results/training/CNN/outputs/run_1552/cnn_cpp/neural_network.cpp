#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.08719864f, 0.30274799f, 0.41741520f, -0.69990557f, 0.36071494f, 0.00397779f, -0.56140620f, -0.43303812f, 
    1.07932520f, 1.11705279f, 0.67766041f, -0.30374953f, -0.52098113f, -0.61313701f, -0.66979676f, -0.24162965f, 
    0.42680332f, 0.14368494f, -0.28033644f, 1.06157982f, -0.34241635f, -0.43880028f, -0.11189699f, 0.17494212f, 
    -0.12658493f, 0.93376803f, -0.64384890f, 1.02471173f, 0.51067632f, 0.99644798f, -0.69339234f, -0.28849220f, 
    -0.34838635f, 0.36264765f, 0.14900899f, 0.31109884f, 0.27651343f, -0.21178579f, 0.36813533f, -0.00015405f, 
    0.33745903f, -0.07297151f, -0.48232082f, 0.21510732f, 0.65755343f, 0.76736271f, -0.57824838f, -0.62568784f, 
    -0.65743101f, -0.78563648f, -0.64780384f, -0.62936842f, 0.28679982f, 0.53000802f, -1.05674601f, -0.08746325f, 
    1.02581775f, -0.22096087f, 0.56540728f, 0.80533469f, -0.02816152f, -0.48205236f, -0.40165800f, 0.65163183f, 
    0.64396560f, 0.31074041f, -0.25529051f, 0.43954635f, 0.34237504f, 0.62027639f, 0.15669984f, -0.00228444f, 
    -0.84862417f, -0.96854550f, -1.13953137f, 0.33478391f, 0.74201471f, 0.02767625f, 0.20010301f, 0.48399425f, 
    0.47501618f, 0.29328045f, 0.58884889f, -0.42626941f, -0.07661241f, -0.46589002f, 0.51482880f, 0.71299857f, 
    -0.74347401f, 0.10001261f, -0.38230655f, -0.53770113f, 0.91307849f, -0.36102444f, -0.26521498f, -0.18172929f, 
    0.35153961f, -0.59549582f, 0.90874285f, -0.58877343f, -0.60685003f, -0.19598797f, 0.47001156f, 0.89885813f, 
    -1.21070731f, -0.69646978f, -0.64373547f, -0.58171999f, -0.33611444f, -0.53653795f, 0.68499082f, 0.55823362f, 
    -0.45094225f, 0.82625860f, -0.40221256f, 0.39207491f, -0.37419829f, -1.54678261f, -1.25563705f, 0.89488566f, 
    -0.74574107f, -0.42584452f, 0.10315458f, 0.29690024f, -0.13314821f, -0.50217670f, -1.39144874f, -0.46717352f, 
    -0.04249134f, -0.07737959f, 0.63699484f, 1.35731363f, -0.04487879f, 0.15284441f, -0.16537152f, 0.20825520f, 
    1.04772854f, -0.91657716f, 0.33118558f, 0.05512396f, -0.08878946f, 0.35888159f, -0.15730765f, 0.47418225f, 
    -0.90004784f, -0.57914525f, 0.10630205f, 0.04348855f, -0.77130955f, -0.70688707f, -0.33863121f, 0.10081895f, 
    -0.18644996f, 0.26444274f, -0.88977963f, 0.84449410f, -0.16904418f, -0.20707829f, 0.46970674f, -0.05909028f, 
    0.16100648f, 0.28981498f, -0.55515248f, -0.54820508f, -0.18583527f, 0.81298321f, 0.12901242f, 0.81072658f, 
    0.65975833f, 0.36556745f, 0.33158946f, -0.41338357f, 0.02511430f, 0.04286036f, -0.49922618f, -1.06934357f, 
    -1.07931948f, 0.48532590f, 0.63599080f, 0.82198900f, 0.45629752f, 0.40320089f, -0.20709352f, -0.85953170f, 
    -0.73182505f, -0.61837113f, -0.35658270f, -0.70017719f, -0.56470233f, -1.16759753f, -0.92936581f, -0.49701536f, 
    0.45813832f, 0.40832704f, -0.20971374f, -0.30472571f, -0.53025484f, -0.37732056f, -0.49022311f, -0.02187643f, 
    0.38491595f, 0.43364480f, 0.47329479f, -0.87465107f, 0.58352405f, 0.62975293f, 0.04058885f, 0.16974726f, 
    0.22629443f, 0.43346635f, 0.50648701f, 0.10431166f, 0.61910051f, -0.03223740f, -0.63188279f, -0.41486582f, 
    -0.91825670f, 0.94014907f, -1.14312398f, 0.61448342f, -0.30784917f, 0.19350195f, 0.11006280f, 0.38394043f, 
    0.15623577f, 0.29568806f, -0.63555032f, -0.73257929f, 0.64533979f, -0.67562008f, 1.25467157f, -0.23884745f, 
    0.08565371f, -0.35958889f, -0.05413922f, 0.67352557f, 0.48897880f, -1.13766837f, -0.31129351f, 0.88768166f, 
    -0.02382415f, -0.57394618f, -0.48490399f, -0.00645364f, 0.37798569f, 0.75793654f, 0.94145715f, -0.77578235f, 
    -0.83072263f, -0.01394512f, -0.23706479f, -0.19277076f, 0.72274292f, 0.79794139f, 0.69790524f, 0.13969919f, 
    0.73782927f, -0.41780818f, 0.05437842f, -0.18097359f, -0.15672477f, 1.06871378f, -0.85560012f, -0.96714848f, 
    -0.52736056f, 0.34227541f, 1.02200615f, -0.13253979f, 0.08326134f, -0.13034526f, 0.76246369f, 0.10657693f, 
    0.15530401f, 0.55654746f, -0.89715850f, 0.34617284f, -0.25502115f, 0.01347982f, 0.39095312f, 0.78702056f, 
    -0.74659342f, -0.87760013f, 0.05967467f, -0.59456688f, -0.97874069f, -0.12532049f, -0.62306899f, -0.05913135f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.16733322f, 0.39812073f, 0.04734780f, 0.23336762f, 0.64708567f, 0.40661287f, 0.24006647f, 0.16988978f, 
    0.00920730f, 0.31983447f, -0.08011279f, 0.40248355f, -0.17047061f, 0.09176179f, 0.00949819f, -0.40105754f, 
    0.07373492f, 0.53492981f, 0.14438790f, 0.31192702f, -0.29921713f, -0.23490672f, 0.51079112f, 0.23420456f, 
    0.46077937f, 0.01441812f, -0.12077472f, 0.49963027f, -0.08659356f, 0.31941476f, 0.31206983f, -0.23018676f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.01295250f, -0.02734133f, -0.02589766f, -0.03894145f, -0.03379062f, -0.04174037f, 0.04397664f, -0.04923124f, 
    0.04951989f, -0.04859610f, 0.04005469f, -0.06473890f, 0.01689006f, 0.01850024f, 0.03896012f, -0.03131238f, 
    -0.04828703f, 0.03369427f, 0.03775868f, 0.04307098f, 0.01661428f, 0.00634987f, -0.01732854f, 0.03429423f, 
    0.00007557f, -0.04485005f, -0.02114481f, -0.02043422f, 0.00844208f, -0.02397757f, -0.01193506f, -0.00083336f, 
    -0.00068118f, -0.05903994f, 0.04128053f, -0.06619060f, 0.02072773f, 0.00609781f, -0.05520804f, -0.04978038f, 
    0.01386723f, -0.06590597f, 0.02504954f, 0.01296734f, 0.01846604f, -0.01528254f, -0.00761042f, -0.06798965f, 
    -0.04417392f, -0.01443162f, -0.05128054f, 0.05172788f, 0.04809067f, -0.03643559f, -0.05182823f, -0.01723789f, 
    -0.04319632f, 0.04820221f, -0.06599326f, -0.00166945f, -0.05507952f, 0.02656689f, -0.02830013f, 0.00603267f, 
    -0.01870940f, 0.04778790f, -0.03506596f, -0.01178213f, -0.04128290f, 0.04184758f, -0.03477826f, -0.04700906f, 
    -0.00309840f, -0.03681937f, 0.01747155f, 0.00535921f, 0.02819785f, -0.02823749f, -0.01312155f, 0.01921834f, 
    -0.00285612f, 0.01894812f, -0.02905620f, -0.05087236f, 0.00434430f, -0.04998408f, 0.02501956f, -0.00244398f, 
    0.00507190f, 0.01890299f, 0.00746030f, 0.03938907f, 0.01994259f, 0.02910850f, -0.02046186f, 0.01384088f, 
    0.01072049f, 0.03998767f, -0.02712376f, 0.00297161f, -0.06811389f, 0.04801662f, -0.00878123f, 0.01169412f, 
    -0.00065976f, 0.01351821f, -0.00092297f, -0.03621219f, -0.05120404f, -0.03378635f, -0.00256022f, -0.05031192f, 
    0.00200350f, -0.04001972f, -0.05429910f, -0.02477426f, -0.04399226f, 0.03426113f, -0.02234975f, 0.01948869f, 
    -0.00294662f, -0.03589541f, -0.03336381f, -0.03643332f, 0.01028739f, 0.01474421f, -0.01373954f, 0.02825697f, 
    0.01711738f, 0.01676144f, 0.03993673f, 0.01766894f, -0.01832585f, -0.00212620f, 0.00270419f, -0.05241920f, 
    0.04739078f, 0.03914572f, -0.03117285f, -0.03186430f, 0.00800417f, 0.02706390f, -0.00250913f, -0.04503704f, 
    -0.02981173f, 0.04452676f, 0.04180155f, 0.02873247f, 0.01294199f, -0.03987477f, 0.02910746f, -0.05770668f, 
    0.04290744f, 0.00397717f, 0.02592994f, -0.01974940f, 0.02465671f, 0.03360590f, 0.01521922f, -0.02545816f, 
    0.04582995f, -0.01440632f, 0.01217881f, 0.02793882f, 0.02339865f, -0.02255531f, 0.02612513f, -0.02692627f, 
    -0.00488491f, 0.00867194f, 0.00790234f, -0.05484416f, -0.03990762f, -0.06901082f, -0.03257073f, 0.02109798f, 
    -0.02171177f, -0.03624240f, -0.03243101f, -0.03342232f, 0.03205455f, 0.01366486f, 0.05260434f, -0.04376893f, 
    -0.04884204f, -0.02516035f, 0.02538488f, -0.00034545f, 0.05742342f, -0.06276303f, 0.00598838f, 0.03500143f, 
    -0.03338259f, -0.02362745f, -0.05984561f, -0.06272440f, 0.03476333f, 0.05582264f, 0.00553177f, 0.01875582f, 
    0.03457435f, -0.03056653f, 0.04688655f, 0.04941591f, 0.00587415f, -0.03237179f, -0.04569526f, 0.03483973f, 
    0.00186364f, -0.05515562f, 0.03153350f, -0.05584329f, -0.05785704f, -0.05748514f, -0.01890529f, -0.03006931f, 
    -0.02122936f, 0.02941279f, -0.04875394f, 0.03244175f, -0.03059561f, 0.02834656f, -0.06047164f, -0.03892216f, 
    -0.06333342f, -0.07000824f, -0.01874076f, -0.01468231f, 0.01802841f, -0.03491606f, -0.02024465f, 0.00543084f, 
    -0.00315377f, -0.02093418f, 0.04749699f, -0.03944451f, 0.03586489f, 0.02173501f, 0.04903608f, 0.04406873f, 
    -0.00600541f, -0.00313979f, -0.02060661f, -0.03961803f, 0.00217419f, -0.05006652f, 0.01340926f, 0.03862306f, 
    0.00259529f, 0.05140157f, 0.03101255f, 0.00842977f, -0.04484710f, 0.03068600f, -0.05807475f, 0.00766286f, 
    -0.06223975f, 0.01976893f, -0.00213503f, -0.02591118f, 0.04288082f, 0.00819001f, -0.06410618f, 0.01860082f, 
    -0.01023049f, -0.06345747f, -0.04136052f, -0.04624114f, -0.03207389f, 0.04977034f, -0.02576510f, 0.03387759f, 
    0.00485178f, -0.02642041f, -0.02808931f, -0.01298530f, 0.04499998f, -0.01829559f, 0.04204715f, -0.05304981f, 
    0.02170302f, -0.05998746f, -0.05207591f, 0.04294593f, -0.00207284f, -0.02272902f, 0.04050680f, 0.01415062f, 
    0.25629100f, -0.14151071f, 0.11541460f, -0.18606104f, 0.22848570f, -0.17244288f, 0.19914408f, 0.19835725f, 
    -0.02707054f, -0.00303070f, -0.22840394f, -0.14416684f, 0.00156867f, 0.07270346f, 0.13559331f, 0.08612499f, 
    0.14570908f, 0.26257434f, 0.03695309f, -0.05571738f, 0.10918389f, -0.10346949f, 0.08987489f, 0.06807867f, 
    -0.32666221f, -0.01726946f, -0.12258095f, -0.36940378f, -0.37595555f, -0.10028680f, -0.04987092f, -0.09992314f, 
    -0.01167043f, -0.27766547f, 0.14238919f, 0.29595253f, 0.00137052f, -0.15663923f, -0.05304502f, -0.12629934f, 
    -0.12071961f, 0.09563276f, 0.08960798f, 0.21126571f, 0.28249872f, 0.24952924f, -0.03788379f, 0.08457980f, 
    0.08435043f, 0.19822213f, 0.14646682f, 0.13791081f, 0.05305307f, -0.13158743f, -0.12574229f, -0.12797560f, 
    -0.17055900f, -0.02041298f, -0.07736819f, -0.05957790f, -0.29251790f, -0.27855387f, -0.21760595f, -0.23753054f, 
    -0.31558743f, -0.16725264f, -0.26144338f, -0.07938035f, 0.00633271f, -0.32031628f, 0.08059484f, -0.04216618f, 
    0.14881636f, 0.18771750f, 0.06405908f, -0.07290703f, -0.09789718f, -0.07648313f, 0.05163910f, 0.03203043f, 
    0.08783974f, 0.07229181f, -0.21503258f, 0.15293863f, 0.20422250f, -0.05746471f, -0.01263421f, 0.05692837f, 
    -0.22816876f, -0.07470311f, -0.25532731f, 0.13133053f, 0.32392460f, -0.13929634f, 0.08776449f, 0.00196493f, 
    0.09249796f, 0.15139978f, 0.00531436f, -0.30889112f, 0.11660437f, 0.27047345f, 0.09883078f, -0.01855610f, 
    0.12450556f, 0.05132471f, -0.07538948f, -0.09467952f, -0.20476481f, -0.19825189f, -0.10482230f, 0.16280544f, 
    -0.07742829f, 0.08312415f, -0.11968608f, -0.31304771f, -0.16811328f, -0.27465925f, -0.22078326f, 0.00024358f, 
    0.03549328f, 0.06464542f, 0.22630651f, -0.02509088f, 0.07119277f, -0.04222477f, 0.02138232f, 0.24314125f, 
    -0.18959728f, -0.01439784f, -0.20551242f, -0.06309463f, -0.09078265f, 0.02411451f, -0.04658962f, -0.09325290f, 
    -0.06451525f, -0.03132462f, 0.22361162f, -0.19471633f, 0.81126958f, -0.23258902f, -0.05043685f, -0.04323626f, 
    -0.19864894f, -0.13687940f, 0.07151846f, 0.11655061f, 0.10864525f, 0.20025416f, 0.11869589f, 0.01092940f, 
    -0.12738463f, 0.09775156f, -0.01342973f, -0.00349244f, -0.05397371f, 0.17958756f, 0.26935878f, 0.13298644f, 
    0.12831180f, 0.11782010f, 0.03606113f, -0.00921758f, -0.05534599f, 0.16237943f, -0.10353334f, 0.16239116f, 
    -0.00527837f, 0.10114255f, 0.06420078f, -0.28963000f, 0.08027516f, 0.19719025f, 0.13688029f, 0.03236838f, 
    0.00527159f, 0.17267169f, 0.14082780f, 0.25826716f, 0.21356204f, -0.17865263f, -0.17512462f, 0.22424495f, 
    0.18890530f, 0.08281473f, 0.57521671f, -0.26325050f, -0.64058095f, -0.51470417f, -0.06332976f, -0.09416952f, 
    0.01139896f, -0.05652815f, 0.05911016f, -0.06268659f, -0.19456723f, -0.00646953f, -0.05404652f, 0.06669863f, 
    0.11147799f, 0.17876644f, -0.06223763f, 0.19484715f, 0.08678377f, 0.27539188f, 0.28168902f, -0.13507563f, 
    -0.12432372f, -0.07107708f, -0.17382705f, -0.09575324f, 0.05170344f, 0.09924518f, -0.42658758f, -0.50306767f, 
    0.24137643f, 0.39970729f, 0.22815487f, 0.29096502f, 0.00993307f, -0.16547300f, 0.02910214f, 0.24498087f, 
    0.21932252f, -0.20795387f, -0.00476081f, -0.07640958f, 0.10034228f, -0.03897297f, -0.06569234f, -0.09905188f, 
    -0.01772832f, -0.20427987f, 0.13880861f, -0.26905599f, -0.04545069f, 0.04904656f, -0.00869648f, 0.05862220f, 
    -0.29871017f, -0.00485591f, 0.00328071f, 0.06082049f, -0.18232587f, -0.14173947f, 0.09736588f, -0.06119598f, 
    -0.00467116f, 0.11054584f, -0.04233667f, -0.21353446f, -0.15200613f, -0.05748351f, -0.04473196f, -0.10496394f, 
    -0.06773994f, -0.08369952f, 0.15236145f, -0.35208473f, -0.42357403f, 0.30631822f, -0.01792189f, 0.00172769f, 
    0.01002778f, 0.14671655f, -0.04458754f, -0.07859739f, 0.00198477f, -0.09472559f, -0.01850406f, -0.08968493f, 
    0.12145405f, -0.08875794f, -0.05169201f, -0.10461223f, 0.26284251f, -0.38578323f, 0.03524130f, -0.08836444f, 
    0.09461515f, -0.12615159f, 0.11617628f, -0.00046513f, 0.12482797f, 0.16261840f, -0.14696279f, 0.05747342f, 
    0.13754056f, -0.09572876f, -0.07772080f, 0.02387129f, -0.14647752f, 0.03685422f, -0.12963222f, -0.17767641f, 
    0.22587965f, 0.02403262f, -0.16425490f, -0.45975924f, 0.02918653f, -0.01645362f, -0.08033429f, 0.00460588f, 
    0.12924965f, 0.19235261f, 0.07409154f, 0.20298885f, 0.02756098f, 0.09466757f, 0.04198707f, 0.26370123f, 
    -0.02134577f, 0.15423863f, 0.12077893f, -0.15327293f, -0.12889205f, -0.08945655f, 0.10361362f, -0.10083246f, 
    -0.08878679f, 0.00720689f, 0.04932190f, 0.02829123f, 0.06991095f, 0.01448938f, -0.00753334f, 0.06082498f, 
    -0.09503680f, 0.04855216f, 0.17562148f, -0.02931234f, 0.18516685f, 0.23265299f, 0.20926376f, -0.04943386f, 
    0.08995102f, 0.23912407f, -0.04418247f, 0.08625345f, -0.03666417f, -0.09580014f, -0.17636488f, -0.53081030f, 
    0.24910516f, 0.23130579f, -0.06509034f, 0.13799514f, -0.09547977f, -0.08445083f, -0.34966534f, -0.15079540f, 
    0.00710301f, 0.07483298f, -0.00831024f, 0.02372275f, -0.01428081f, 0.07297241f, 0.17619134f, 0.12973796f, 
    -0.13579787f, 0.17724045f, 0.06803568f, -0.14972278f, -0.16069132f, -0.32839826f, 0.04351927f, 0.03135791f, 
    0.30734718f, 0.15207328f, 0.09284733f, -0.06628702f, -0.03543632f, 0.02569770f, -0.13686588f, 0.02648713f, 
    -0.10623454f, -0.02693708f, 0.10321458f, -0.73992330f, 0.08163176f, 0.09743310f, 0.02806035f, -0.17782140f, 
    0.07422767f, -0.11203405f, 0.34705415f, -0.25862834f, 0.09779630f, 0.29965186f, -0.08004650f, -0.07358929f, 
    -0.03637080f, 0.00392419f, -0.09508515f, -0.15079746f, 0.02551790f, -0.25317743f, 0.13046914f, 0.16822997f, 
    0.09943566f, -0.04143643f, -0.07918888f, -0.14862178f, -0.33503443f, -0.27543125f, 0.01203336f, 0.42578971f, 
    0.06862851f, -0.03324449f, 0.32731509f, -0.18964058f, -0.09208773f, -0.02741659f, -0.16402432f, 0.09201867f, 
    0.36930975f, 0.13020514f, -0.23202030f, 0.12370212f, 0.00626575f, -0.17210093f, 0.02928451f, 0.09850325f, 
    0.14075358f, 0.06264960f, -0.03957321f, 0.14191620f, 0.11349089f, 0.02283351f, 0.08811255f, 0.07094840f, 
    -0.27154356f, -0.01004088f, 0.23612803f, -0.02631587f, -0.07306354f, 0.04179646f, 0.00959521f, -0.09683273f, 
    -0.19461405f, 0.05513401f, -0.20735201f, 0.12135393f, 0.10304578f, 0.14125048f, 0.14148648f, 0.11719871f, 
    0.13329123f, 0.16185257f, 0.09548544f, 0.16591427f, 0.02640927f, 0.12691675f, -0.06442396f, -0.02083115f, 
    0.08775425f, 0.12000629f, 0.14795983f, 0.02749540f, -0.31935170f, 0.10690285f, 0.07489963f, 0.11507050f, 
    0.06348006f, 0.23861651f, 0.24242336f, -0.01413889f, 0.00757265f, 0.00193766f, 0.19000910f, 0.15492329f, 
    0.10060785f, -0.13051388f, 0.04503704f, 0.21957268f, 0.04913905f, -0.47450531f, 0.01817002f, 0.21716037f, 
    -0.08814002f, -0.15732341f, 0.02191336f, -0.07223495f, -0.01100991f, -0.22074448f, -0.06602146f, 0.05334065f, 
    0.01481063f, -0.01299240f, 0.09085217f, -0.02119712f, 0.22954297f, 0.18645002f, 0.16646603f, -0.08268122f, 
    -0.17989257f, 0.06723379f, -0.13876967f, -0.00776500f, 0.03752300f, -0.04694213f, -0.10989983f, -0.06494901f, 
    0.13197321f, 0.26400483f, 0.04096897f, 0.02318239f, -0.05473676f, -0.02165153f, 0.15946689f, 0.20504749f, 
    -0.02516614f, -0.49060279f, 0.30423054f, -0.28331617f, 0.06429360f, -0.14203355f, 0.02533411f, 0.09996928f, 
    -0.00427216f, -0.05067299f, -0.31668475f, -0.60367000f, 0.18083775f, 0.14879856f, -0.00360934f, -0.20630336f, 
    -0.17243384f, 0.17470683f, -0.03556462f, 0.10469548f, -0.26379395f, -0.15915078f, -0.03935789f, -0.11018818f, 
    -0.13264255f, 0.04570100f, -0.12858370f, -0.08139237f, -0.14558259f, -0.09023667f, 0.06988184f, 0.04421535f, 
    -0.09132839f, 0.01544644f, 0.15773463f, -0.07006814f, 0.01441652f, -0.15848683f, 0.09384349f, -0.21970125f, 
    0.19771552f, 0.26212060f, -0.00306189f, 0.16689776f, 0.02338594f, 0.02343878f, -0.01502529f, -0.17176558f, 
    -0.07241972f, -0.11136994f, 0.08603089f, -0.18669488f, 0.10292881f, -0.18445097f, 0.15134913f, -0.05295741f, 
    0.41914237f, -0.25625947f, -0.12204132f, -0.07491478f, -0.08956677f, -0.06165602f, 0.04385778f, -0.32834634f, 
    0.31722116f, -0.35385731f, -0.13903262f, -0.06919561f, -0.14444374f, -0.21186276f, -0.00222646f, 0.13836245f, 
    0.44941089f, -0.27239454f, 0.09030712f, 0.64079916f, -0.10145359f, -0.02789811f, 0.04177296f, 0.02692482f, 
    0.05761110f, 0.06362636f, 0.17784098f, -0.34849805f, 0.33835843f, -0.09697498f, -0.00031165f, -0.21009129f, 
    0.06147002f, -0.12114869f, -0.08788849f, -0.43964437f, -0.38822144f, -0.05538346f, -0.08409160f, -0.10522277f, 
    0.16451611f, -0.15665460f, 0.08361736f, 0.04859254f, 0.06291182f, -0.12211914f, 0.02790921f, 0.03251486f, 
    0.00316836f, 0.16348149f, 0.21377192f, 0.13718763f, 0.19955409f, 0.09547114f, -0.01666994f, 0.09755456f, 
    -0.06555638f, -0.09348121f, 0.04789155f, 0.15090868f, 0.20805506f, 0.18065944f, 0.45517868f, 0.07335423f, 
    -0.39499509f, 0.15995733f, -0.23104230f, -0.11513588f, 0.11388235f, -0.10282392f, -0.04857845f, -0.22561847f, 
    -0.35113752f, -0.08791246f, -0.19912818f, -0.36084735f, -0.22514658f, 0.12281509f, 0.22304484f, 0.18186450f, 
    -0.53284985f, -0.02943621f, 0.45025066f, 0.07793528f, 0.14820004f, 0.08378498f, 0.16205148f, 0.19832537f, 
    -0.12031239f, 0.23381807f, -0.03909825f, 0.02978897f, 0.04696995f, 0.03679359f, 0.06809448f, 0.22005937f, 
    0.02911305f, 0.08483724f, 0.13475037f, -0.40941826f, 0.07542060f, -0.16730264f, -0.08960277f, -0.06055329f, 
    -0.04641804f, 0.24898240f, 0.15740046f, -0.07721466f, 0.27344310f, 0.30363357f, -0.00841215f, 0.08310395f, 
    0.05645117f, 0.05852992f, 0.00946308f, -0.05342473f, -0.57486361f, -0.33207771f, -0.58946300f, -0.27309975f, 
    -0.49477121f, 0.03017339f, 0.01070871f, -0.22228262f, -0.10231759f, -0.14397062f, 0.10589208f, -0.30846360f, 
    0.02583590f, -0.06480683f, 0.02902337f, -0.14538047f, 0.15457366f, 0.04216339f, -0.21482882f, -0.11315097f, 
    -0.13291276f, 0.17549439f, 0.07861485f, -0.01816100f, -0.03405109f, 0.05426439f, -0.14104450f, 0.09377833f, 
    -0.95203000f, -0.40340713f, -0.41317844f, -0.40543443f, -0.11967394f, -0.09761301f, 0.19444856f, 0.12363727f, 
    -0.33396816f, 0.07082693f, 0.09151781f, 0.08544638f, -0.10928094f, 0.01418579f, -0.02790534f, 0.19788769f, 
    -0.07007092f, 0.30584839f, 0.20901179f, -0.42209557f, 0.17506665f, -0.02822906f, 0.10713952f, 0.23123173f, 
    0.18391961f, 0.10306227f, -0.23829126f, -0.04344032f, -0.06343921f, 0.14426127f, 0.10822917f, 0.06527301f, 
    0.05944046f, 0.17597710f, 0.08650512f, -0.16160472f, -0.35073176f, -0.10457220f, -0.09467950f, 0.10265777f, 
    0.14003640f, -0.07013552f, 0.04028654f, -0.02012269f, -0.12827298f, -0.52193218f, 0.01726082f, -0.34729195f, 
    0.01559182f, -0.01233383f, 0.06408358f, -0.00176047f, 0.04966829f, -0.42106873f, 0.17778017f, 0.18628512f, 
    -0.04657174f, -0.12447047f, -0.10130308f, 0.06169011f, 0.05238298f, -0.04085641f, 0.14191899f, -0.33994514f, 
    -0.04596785f, 0.06672584f, 0.22080885f, 0.13808481f, 0.23543780f, 0.26224434f, 0.25736094f, 0.00245711f, 
    -0.28801471f, -0.12772560f, 0.05388729f, -0.01484383f, -0.19224654f, 0.18081778f, 0.06615561f, -0.02623601f, 
    0.14627329f, -0.06751835f, -0.04806274f, 0.17933881f, 0.23737365f, 0.17278215f, 0.02757822f, 0.05639661f, 
    0.06277648f, 0.14427847f, 0.00412765f, 0.40694335f, 0.11288040f, 0.06048207f, 0.22045089f, -0.07722646f, 
    -0.04013638f, -0.00926182f, 0.14705390f, -0.65153474f, -0.27160880f, -0.47128245f, -0.28470224f, -0.10550784f, 
    0.01331025f, -0.28908515f, -0.08245817f, -0.20167032f, -0.06096049f, 0.48465377f, -0.07136419f, 0.10575151f, 
    -0.01951993f, 0.23405124f, 0.09303922f, 0.24456528f, -0.21880636f, -0.06229005f, 0.27657574f, -0.29908112f, 
    -0.14050734f, -0.44111219f, -0.25270450f, 0.06731930f, 0.13784391f, 0.54098940f, 0.08283843f, 0.50599372f, 
    -0.23886421f, -0.08265768f, 0.14438435f, -0.02732670f, -0.15437955f, 0.12794030f, -0.31606647f, 0.01217798f, 
    0.25037274f, 0.19664019f, -0.03912812f, -0.28177461f, 0.11594944f, 0.15212406f, 0.11236963f, -0.04721544f, 
    0.03342112f, -0.18192458f, -0.07971234f, -0.22909339f, -0.15387082f, 0.12897852f, 0.11972880f, -0.17512953f, 
    0.13262014f, 0.28631461f, 0.09412902f, -0.07989690f, -0.04049805f, -0.13754086f, 0.15594091f, 0.15954845f, 
    -0.13316853f, 0.24156907f, -0.55329758f, 0.19260189f, 0.14424062f, 0.02583173f, 0.04174959f, 0.07252955f, 
    0.02320575f, 0.09449144f, -0.11345029f, -0.07723934f, -0.00023137f, -0.02618883f, -0.03304719f, -0.01168350f, 
    0.09510087f, -0.13364366f, -0.03723929f, 0.00339607f, -0.31948891f, 0.01877451f, 0.13765597f, 0.01601247f, 
    -0.01066550f, 0.01345918f, 0.16681850f, -0.00464273f, 0.01458492f, 0.21388285f, 0.06971841f, -0.00234622f, 
    0.13092895f, 0.19021243f, 0.20410842f, 0.15960845f, -0.10152649f, 0.15227762f, -0.39308825f, -0.20935385f, 
    0.01578721f, 0.07949921f, 0.05339082f, 0.18814926f, 0.15950474f, 0.03563785f, -0.05114700f, 0.13577572f, 
    -0.01757012f, -0.08116612f, -0.25508460f, -0.04732646f, 0.09427951f, 0.02051402f, -0.06776610f, -0.02331227f, 
    -0.00772173f, 0.04482844f, 0.03255913f, 0.14574347f, -0.05601230f, -0.01870588f, 0.11113658f, 0.06667223f, 
    -0.21619308f, -0.05955785f, -0.18607666f, -0.18680106f, -0.11514236f, -0.11038758f, -0.04285752f, -0.03112504f, 
    -0.00320727f, 0.01419031f, 0.07625214f, 0.26109824f, 0.15109548f, 0.27459857f, 0.06633158f, 0.19512112f, 
    0.05509543f, -0.00142188f, -0.79049218f, 0.21260002f, -0.00568495f, 0.27457726f, 0.02592578f, -0.12606792f, 
    0.05771567f, 0.18222293f, 0.00036827f, -0.16242892f, -0.01825784f, -0.10860335f, 0.15854231f, 0.13482763f, 
    0.21263139f, -0.00878457f, -0.09485754f, 0.01856440f, 0.08801109f, 0.10551490f, -0.03574034f, -0.25925156f, 
    -0.07154632f, 0.02079639f, 0.44321051f, -0.07170665f, -0.11770377f, -0.44049990f, 0.01512516f, 0.24901696f, 
    0.02075530f, 0.23888995f, 0.31733358f, -0.10698237f, -0.11182607f, 0.05120283f, 0.02259916f, -0.09248306f, 
    -0.15780215f, -0.12810276f, -0.24475899f, -0.02257047f, 0.03955394f, 0.03912630f, -0.06108487f, 0.03229711f, 
    -0.09635442f, -0.09876767f, 0.03744946f, 0.29381794f, 0.15525885f, -0.38739821f, -0.16575871f, -0.22037025f, 
    -0.09803010f, -0.25844726f, -0.04286454f, 0.14759168f, 0.15886143f, 0.03028408f, 0.03612834f, -0.01270112f, 
    0.01543031f, -0.03047334f, 0.12363702f, 0.07785688f, 0.06897203f, 0.26759169f, 0.26220822f, 0.15616198f, 
    0.02770932f, 0.10691338f, 0.00760351f, 0.07760031f, -0.05006563f, -0.21755654f, -0.02597587f, -0.01073915f, 
    0.00581369f, 0.00798558f, -0.07020770f, 0.15817767f, 0.10994283f, -0.15113918f, -0.08907200f, -0.04496707f, 
    0.01601629f, 0.01250855f, 0.11668025f, 0.05058570f, -0.18595257f, -0.81729919f, -0.31395498f, 0.03464929f, 
    0.05907508f, 0.00440723f, -0.06838505f, -0.03733138f, -0.33775896f, -0.29234469f, -0.21763557f, -0.08947505f, 
    0.14054227f, 0.08044884f, 0.05144898f, -0.02279741f, 0.00072975f, 0.10629060f, 0.03328009f, 0.10893895f, 
    0.11475466f, 0.04411106f, 0.05774684f, -0.02795002f, -0.02213884f, 0.00729399f, 0.16306400f, -0.02354509f, 
    0.01774355f, -0.01807463f, -0.25030151f, -0.00303686f, -0.08483151f, 0.11543059f, 0.12425113f, 0.11155684f, 
    -0.06738191f, 0.15997870f, -0.26289439f, 0.03239142f, 0.01566242f, 0.00023322f, -0.05950681f, 0.22685522f, 
    -0.16845955f, 0.02817012f, -0.05320930f, -0.22253361f, -0.12378726f, -0.13621399f, 0.19941986f, 0.27207637f, 
    0.07670715f, -0.11617853f, -0.12483520f, -0.05615475f, 0.02285391f, -0.09196790f, -0.03005381f, -0.21987228f, 
    -0.23601879f, -0.08156379f, -0.16470246f, -0.16332036f, 0.06720765f, 0.37579951f, 0.03867176f, 0.22319365f, 
    -0.00966218f, 0.18552685f, 0.11395866f, 0.16245423f, -0.09068224f, 0.08557221f, 0.02185636f, -0.03816970f, 
    0.07832675f, -0.17187501f, 0.15409194f, 0.24087478f, 0.08940941f, 0.21783295f, 0.01323757f, -0.12057061f, 
    -0.19765039f, 0.16735241f, 0.17531969f, -0.04262257f, -0.06660227f, 0.04056157f, 0.05130384f, -0.09000944f, 
    0.09083842f, -0.01446476f, 0.03505811f, -0.01076539f, 0.30945650f, 0.21139717f, 0.14883423f, -0.30186188f, 
    -0.24855866f, -0.11326072f, 0.07194712f, 0.09552833f, 0.02151107f, 0.10141705f, 0.09526677f, -0.16338597f, 
    -0.00114502f, 0.03685630f, -0.04205097f, -0.05119365f, -0.03187966f, -0.04355557f, -0.01084671f, 0.03137322f, 
    0.00356052f, -0.02419749f, 0.05210273f, 0.00235735f, -0.01517985f, 0.00128713f, 0.00493374f, -0.00304640f, 
    -0.03422063f, -0.00055672f, 0.04527226f, -0.01016071f, 0.00090249f, 0.05701594f, -0.02867833f, -0.05520003f, 
    -0.01511540f, -0.05154577f, 0.01377045f, 0.04654952f, -0.02831288f, 0.02342980f, 0.01417412f, -0.05381150f, 
    0.00846812f, -0.01306440f, -0.05715420f, -0.00130116f, 0.01254346f, 0.02771762f, -0.00950168f, -0.00638613f, 
    -0.04875736f, -0.00499044f, -0.00952365f, 0.03554631f, 0.01708248f, 0.02435466f, 0.02186845f, 0.01152515f, 
    0.04334664f, 0.00694699f, 0.00131833f, -0.01228208f, 0.00130606f, -0.03799648f, -0.03963089f, -0.01938709f, 
    -0.02673139f, 0.03366030f, -0.00835260f, -0.01096311f, 0.00533063f, -0.05339251f, -0.00343587f, -0.03601469f, 
    -0.01011010f, 0.05252732f, -0.00106372f, -0.00736426f, -0.02192976f, -0.02657967f, -0.02336030f, -0.01481425f, 
    0.01802740f, -0.03172961f, 0.04275565f, 0.03118942f, 0.00531614f, -0.00301436f, 0.01799595f, -0.04157519f, 
    -0.03071282f, 0.05833948f, -0.03779779f, -0.05604280f, -0.02885746f, -0.05786170f, 0.01735049f, -0.00276555f, 
    -0.00236243f, 0.04083066f, -0.03911686f, 0.05430623f, -0.03907533f, 0.02345719f, -0.02170074f, 0.02484673f, 
    0.00434633f, -0.01027870f, -0.04858619f, -0.04271292f, -0.03939331f, -0.01938487f, -0.01433822f, -0.05718629f, 
    -0.02218923f, -0.05658878f, -0.02973918f, -0.03362004f, 0.01908314f, 0.05005493f, -0.05770145f, -0.01587356f, 
    -0.03293542f, 0.02926331f, -0.03766460f, 0.02179807f, 0.01546942f, -0.03991897f, 0.02855175f, 0.03554723f, 
    -0.00750597f, -0.03833696f, 0.04386697f, -0.02908232f, -0.02349075f, 0.03748659f, 0.01927504f, -0.03116550f, 
    -0.04282610f, 0.01839057f, 0.03706206f, -0.00798660f, -0.05352828f, -0.03906976f, 0.04088176f, 0.04855108f, 
    -0.03453412f, 0.01383585f, 0.01863540f, 0.00696500f, 0.02822381f, -0.01960351f, 0.04510637f, -0.00143469f, 
    0.03541175f, 0.03186392f, -0.02681602f, -0.01706522f, 0.00287069f, 0.00504135f, -0.02644146f, 0.03052308f, 
    -0.04709548f, 0.00178484f, -0.04803259f, -0.01063664f, -0.00093502f, 0.04109229f, -0.05377417f, 0.02204624f, 
    -0.04492939f, -0.02189549f, 0.01032325f, 0.02877544f, 0.02572021f, -0.04187221f, 0.00922029f, 0.03005361f, 
    0.02012166f, -0.02561342f, 0.02774158f, -0.03254780f, -0.02575281f, 0.01067209f, 0.03838244f, -0.00840720f, 
    -0.04117720f, 0.02967900f, -0.00600536f, 0.00140246f, 0.00505745f, -0.02060523f, -0.00985768f, -0.00092323f, 
    -0.04012978f, 0.01259783f, -0.00146269f, 0.03858174f, 0.05711560f, -0.03635700f, -0.05107807f, 0.02922809f, 
    -0.00217581f, 0.01035845f, 0.00924037f, 0.05020761f, 0.01575940f, -0.01667603f, -0.03010285f, 0.00940570f, 
    -0.01441092f, 0.02506088f, 0.01524901f, -0.03617072f, 0.00648138f, 0.01003578f, -0.04601049f, -0.00453027f, 
    0.04608222f, 0.05511505f, -0.04299458f, -0.03786466f, 0.01664129f, -0.00645722f, -0.03329109f, -0.05185851f, 
    0.02440095f, -0.01217511f, -0.05536264f, -0.05493999f, -0.04502496f, -0.01575204f, 0.02243389f, -0.03884527f, 
    0.01835353f, 0.00331663f, 0.00018460f, 0.02770265f, -0.05702580f, 0.03284419f, 0.02998394f, -0.01540642f, 
    0.00115841f, -0.05484497f, -0.00056777f, -0.04847708f, 0.04498535f, -0.03241332f, -0.01400290f, -0.05201956f, 
    -0.02949231f, 0.01013764f, -0.01960091f, 0.00692263f, -0.00038727f, -0.03218596f, -0.01370431f, -0.01002532f, 
    0.05107550f, 0.02563779f, -0.01623013f, 0.00207308f, -0.03346232f, -0.05469926f, -0.05178618f, -0.05050811f, 
    0.00927720f, -0.05313113f, -0.02140513f, 0.05311152f, -0.02982260f, -0.02095845f, -0.00001998f, -0.05648647f, 
    -0.05407285f, 0.01583345f, -0.05741427f, 0.05352044f, -0.05119332f, -0.02969688f, 0.05294336f, 0.02014858f, 
    -0.02172234f, 0.05128941f, -0.03012293f, 0.00517277f, -0.04252642f, 0.03577077f, 0.05627767f, -0.01674038f, 
    0.00773953f, -0.02616566f, -0.03418265f, -0.05074188f, -0.03171745f, 0.04726273f, -0.03877305f, 0.03840383f, 
    -0.23278421f, 0.19174941f, 0.13075708f, 0.09214430f, -0.04748957f, -0.12862688f, -0.47835639f, -0.14711326f, 
    0.10639729f, -0.03947143f, -0.17328937f, -0.01171329f, 0.06635709f, -0.06709732f, -0.07107310f, 0.02308322f, 
    0.15844890f, -0.02013771f, -0.16794901f, -0.08680838f, 0.16635139f, 0.03728176f, 0.10748327f, 0.12921999f, 
    -0.30406788f, 0.40944570f, -0.24730447f, -0.37125060f, 0.15875980f, 0.05487320f, 0.03224121f, 0.16247500f, 
    0.05690536f, -0.06691384f, 0.11762363f, -0.02282970f, -0.16111144f, -0.07043602f, -0.07178225f, 0.03537384f, 
    -0.03139684f, -0.00281255f, 0.18242936f, -0.05215442f, 0.15807320f, 0.11816633f, 0.28772146f, -0.10543931f, 
    -0.16202784f, -0.06143602f, 0.04586201f, 0.06864063f, 0.00391847f, -0.15407607f, -0.28324598f, 0.15885465f, 
    -0.36823040f, -0.24455450f, 0.03822363f, -0.20095986f, -0.13066699f, 0.08325253f, -0.24494903f, -0.08679177f, 
    0.09905900f, 0.09950794f, 0.03870653f, -0.11690642f, -0.04637336f, 0.09203529f, 0.16442589f, 0.04126586f, 
    0.11574332f, 0.06573471f, 0.19304301f, -0.31056988f, -0.07781664f, -0.11288682f, 0.10135418f, 0.07801834f, 
    0.06707167f, -0.33863494f, -0.11015788f, 0.26641268f, 0.07032047f, -0.08401743f, 0.12125000f, -0.12092733f, 
    0.02279426f, 0.07658464f, 0.10762484f, 0.21328126f, 0.46631351f, -0.01593627f, 0.29073143f, -0.05637156f, 
    -0.26313165f, -0.01158723f, -0.31857792f, -0.15299204f, 0.29450622f, 0.14913848f, 0.03287924f, -0.08273396f, 
    -0.11052079f, -0.11533960f, -0.03687432f, -0.12732013f, -0.01886988f, 0.26461178f, 0.32034913f, -0.25366613f, 
    0.22436610f, -0.24758321f, 0.07889616f, 0.18042551f, -0.03043791f, -0.24049598f, -0.14220798f, 0.21404992f, 
    -0.13383764f, -0.00016510f, -0.10290773f, -0.00480985f, -0.05101478f, 0.21274632f, -0.12735693f, 0.46832573f, 
    -0.30847958f, -0.21971416f, -0.19725764f, 0.01225607f, 0.09188921f, -0.03532974f, -0.00239510f, -0.08477453f, 
    0.10575696f, 0.19497180f, 0.31188822f, 0.12729229f, -0.02418504f, 0.02684626f, 0.19981647f, 0.15142813f, 
    -0.05590098f, 0.29139265f, 0.24287100f, -0.07569536f, -0.02108520f, -0.03055227f, -0.00693881f, -0.09271115f, 
    0.09993694f, -0.23487687f, -0.00539230f, 0.05279931f, -0.01571291f, 0.17953163f, 0.19835635f, 0.05091990f, 
    0.04015784f, 0.00508191f, 0.02637056f, 0.15294607f, 0.24993381f, -0.26887628f, 0.08158333f, -0.18220203f, 
    0.11611965f, 0.06136053f, 0.03038630f, 0.19080524f, 0.38986799f, 0.03146218f, 0.09838795f, -0.05601143f, 
    -0.07108136f, 0.18321280f, -0.05919093f, 0.06060587f, 0.51776248f, -0.26727206f, 0.27136716f, 0.10162664f, 
    -0.03575127f, 0.03480548f, 0.12986323f, 0.13968498f, 0.04452651f, -0.40227756f, 0.02471950f, 0.13721089f, 
    -0.02628433f, 0.01940643f, 0.00297446f, 0.00666100f, 0.04080312f, 0.11759046f, 0.02998571f, -0.01411964f, 
    0.00585826f, -0.14206187f, -0.12438753f, -0.10725065f, 0.17842768f, 0.01842774f, 0.00388500f, -0.08507104f, 
    0.13222070f, 0.07347047f, 0.02231024f, -0.17447466f, -0.12361237f, 0.06286009f, 0.10220375f, -0.11085416f, 
    0.17003600f, 0.16059576f, 0.20846215f, -0.11509846f, 0.17196098f, 0.17906098f, 0.09074254f, 0.03306210f, 
    -0.04647241f, -0.37976545f, 0.39906889f, 0.24581683f, 0.10745147f, -0.21141821f, -0.06103117f, -0.14940292f, 
    0.02921986f, 0.09946790f, 0.02220205f, 0.01312658f, 0.17948028f, 0.12250681f, -0.09889727f, -0.04038467f, 
    -0.08694337f, 0.06463054f, 0.16475356f, -0.28773347f, -0.03666430f, 0.04027548f, -0.02794445f, -0.05727550f, 
    -0.18050461f, 0.00363171f, -0.28745428f, -0.03581459f, 0.01967330f, 0.21851292f, 0.09702156f, 0.05363829f, 
    -0.11704635f, -0.13741133f, 0.02324557f, -0.02354824f, 0.09745961f, -0.55058700f, 0.15482262f, -0.50005335f, 
    0.17419857f, -0.29860276f, 0.07906575f, -0.23685561f, -0.13220067f, 0.05942562f, -0.22549960f, 0.00606134f, 
    0.18343252f, 0.07703537f, -0.05495777f, -0.01734482f, 0.02432676f, -0.00771502f, 0.03016904f, 0.24767545f, 
    0.24909529f, 0.06208616f, -0.07969746f, -0.05003919f, 0.22130734f, 0.11914054f, -0.17819658f, 0.16468954f, 
    0.21582849f, -0.01954439f, 0.05975001f, -0.18380663f, 0.02868603f, -0.14725754f, 0.04833846f, 0.04624201f, 
    -0.15717743f, -0.01920507f, -0.22777407f, -0.02248534f, 0.00660031f, 0.09657378f, -0.00380992f, 0.04446761f, 
    -0.09867197f, -0.00596073f, 0.36798695f, -0.60566002f, -0.10202873f, -0.15387098f, -0.21071303f, 0.10509364f, 
    -0.28274512f, -0.08294228f, -0.10293499f, 0.14904501f, -0.19855963f, -0.17069228f, -0.13709468f, 0.02785037f, 
    -0.09765649f, 0.14067002f, -0.17660171f, 0.17343198f, 0.27180693f, 0.23184314f, 0.05463569f, -0.13611063f, 
    0.28614658f, 0.15263295f, 0.05979855f, 0.02422427f, 0.04087163f, -0.33320701f, 0.11533985f, -0.31147274f, 
    -0.04989115f, 0.04203523f, 0.06219741f, -0.01289381f, -0.06935378f, -0.10168270f, -0.09882661f, 0.14129075f, 
    -0.06635588f, -0.16025092f, -0.06303597f, -0.04214013f, 0.09051789f, 0.01074768f, 0.15671463f, 0.09407771f, 
    -0.01137859f, 0.10662868f, -0.08878291f, -0.23005006f, -0.01398407f, 0.02349554f, -0.17942308f, 0.08148363f, 
    -0.46473008f, 0.23624925f, 0.55169410f, -0.39586857f, 0.27019143f, -0.03713007f, 0.08337489f, -0.00762027f, 
    0.06282277f, -0.00645590f, 0.01040899f, 0.17232661f, 0.00590506f, -0.32524946f, 0.02477015f, -0.13857046f, 
    0.00364783f, 0.13642967f, -0.37434986f, -0.09174412f, -0.50109583f, -0.20134491f, -0.10365926f, -0.03180598f, 
    -0.02832969f, 0.16319829f, 0.09075811f, -0.29470098f, -0.14498764f, 0.22129233f, 0.02423219f, 0.18759915f, 
    -0.00810456f, 0.01717177f, 0.23845299f, 0.21141304f, -0.03919450f, -0.08611072f, -0.02662837f, -0.23414156f, 
    -0.11067947f, -0.23910756f, -0.10514618f, 0.00571656f, -0.04285276f, -0.32072565f, -0.02197474f, 0.33883694f, 
    0.01093310f, 0.09171946f, 0.03060575f, 0.05214610f, 0.10589693f, -0.15441330f, -0.43904939f, 0.16214249f, 
    0.13115457f, -0.41417709f, -0.10376506f, 0.04237585f, 0.02486357f, 0.07101109f, 0.03255390f, 0.11191399f, 
    -0.20733772f, -0.19592850f, -0.09586194f, -0.35262027f, 0.07692257f, -0.07455204f, -0.32617572f, -0.10166530f, 
    -0.19461428f, -0.12400386f, 0.11625987f, -0.07230497f, -0.05966998f, -0.02084624f, 0.02421074f, -0.07845354f, 
    0.01698948f, 0.20968522f, 0.09892860f, -0.19277687f, 0.02680556f, 0.15326892f, 0.09864704f, 0.04001618f, 
    0.09422719f, -0.00454123f, -0.06307860f, 0.06485461f, -0.01868960f, -0.20325060f, -0.34353524f, 0.00991165f, 
    -0.06611675f, -0.03194167f, -0.00874259f, -0.54059112f, -0.45731008f, -0.20598583f, -0.10119794f, -0.01272407f, 
    -0.08781798f, -0.07066042f, -0.01445825f, -0.13696232f, -0.51733118f, -0.41021055f, -0.66745806f, -0.03638362f, 
    0.05982035f, -0.08825126f, -0.06598300f, 0.01204127f, 0.13261907f, -0.46438482f, 0.08869565f, 0.59654230f, 
    -0.13185444f, 0.05294225f, -0.07158562f, 0.08617985f, -0.00252067f, 0.09951013f, -0.04814705f, 0.07479402f, 
    0.16801158f, 0.01936885f, -0.17755195f, 0.08297167f, 0.02887827f, 0.13527538f, 0.03996235f, -0.08834729f, 
    0.16850841f, 0.06828141f, -0.00943352f, -0.13718857f, -0.11810700f, 0.24672967f, -0.22765382f, 0.09891599f, 
    0.39429158f, -0.20277978f, -0.09754706f, 0.17171043f, -0.01109837f, 0.25724143f, 0.13748243f, -0.14167047f, 
    0.08354613f, -0.24064913f, 0.29251122f, -0.04336245f, 0.08226690f, 0.21651185f, 0.10742003f, 0.04451061f, 
    -0.03731144f, 0.13381529f, -0.30118579f, -0.07392921f, -0.20489840f, -0.11680999f, -0.11530562f, 0.06952481f, 
    0.18803623f, 0.23257427f, -0.10508873f, -0.04743336f, -0.02128807f, 0.08022013f, 0.06081032f, 0.21287443f, 
    -0.09804203f, 0.12025983f, 0.41922298f, 0.20295668f, -0.04621697f, -0.00389062f, 0.07738963f, -0.04772546f, 
    -0.04042458f, -0.20565458f, 0.13147607f, -0.13429683f, 0.19135344f, 0.33259338f, 0.56233305f, 0.25222099f, 
    0.01094964f, 0.34793404f, -0.17403343f, 0.13593286f, 0.23467518f, 0.19021586f, 0.02131705f, 0.21056920f, 
    0.18408796f, -0.06336212f, -0.04038622f, -0.03574864f, 0.08313394f, 0.10123897f, 0.07860760f, -0.35630590f, 
    0.00773288f, -0.55164683f, -0.01174530f, 0.00483926f, -0.23826295f, -0.01100930f, 0.03863061f, 0.09083825f, 
    -0.02295327f, -0.18051848f, -0.38018632f, -0.13930675f, -0.18831772f, -0.03530182f, -0.27197671f, 0.31123450f, 
    0.02753502f, 0.02725805f, 0.29327127f, 0.39056623f, 0.07445164f, 0.18135552f, -0.09287095f, 0.11667348f, 
    -0.21441969f, -0.05104052f, 0.46170962f, 0.36659220f, -0.47202769f, 0.04266588f, 0.16022770f, -0.29442361f, 
    -0.35000733f, 0.07088637f, 0.34223241f, -0.44097367f, -0.34861407f, 0.09709658f, 0.00217472f, -0.08527757f, 
    -0.17398171f, -0.03218213f, -0.10354465f, -0.00701224f, -0.24984139f, -0.34324008f, -0.24606077f, -0.06559063f, 
    -0.08199552f, 0.13371815f, -0.02623102f, -0.03405592f, 0.06963885f, 0.04469395f, 0.20644192f, 0.35881892f, 
    0.24257475f, 0.18251856f, 0.00918950f, 0.15701586f, -0.29587516f, -0.15369295f, 0.58701307f, 0.13061562f, 
    -0.28907213f, 0.09570956f, -0.12553763f, 0.19682404f, 0.05556329f, -0.01888745f, 0.11735593f, -0.27676249f, 
    -0.05559268f, 0.00790573f, 0.15562993f, -0.10970062f, -0.16142970f, 0.13791135f, 0.04890458f, -0.10792206f, 
    -0.47910619f, 0.22450185f, 0.50464833f, 0.08787616f, 0.02321022f, -0.13312565f, -0.09678894f, 0.03178539f, 
    0.13637240f, 0.21606249f, 0.09591999f, -0.69581848f, -0.04397143f, -0.11954124f, 0.05818384f, 0.04012017f, 
    0.19294973f, 0.18658493f, 0.43541265f, -0.04183236f, -0.00856671f, 0.16588455f, 0.09536687f, -0.21793352f, 
    -0.19273195f, 0.11312156f, -0.11854690f, -0.04529623f, 0.16776676f, 0.29836434f, 0.05077905f, 0.06104552f, 
    -0.04053233f, -0.05111359f, 0.09533527f, -0.05909075f, -0.04335397f, -0.29686654f, -0.39939988f, 0.02634966f, 
    0.21382385f, -0.11027495f, -0.08851860f, 0.00375849f, 0.32350922f, -0.10188911f, 0.08584690f, 0.03775970f, 
    0.12196381f, -0.21165892f, -0.12053492f, 0.09475408f, 0.01730202f, -0.06103745f, -0.10853469f, 0.14043419f, 
    0.13985203f, 0.14539649f, 0.03460421f, 0.22218338f, 0.02178900f, 0.03603640f, 0.06143498f, 0.33968884f, 
    0.35483417f, -0.06815702f, -0.12904559f, 0.24621457f, -0.20458138f, 0.15524554f, 0.02610973f, -0.29693699f, 
    -0.14147644f, 0.01505023f, 0.26872110f, 0.02689559f, -0.02484731f, -0.11436129f, 0.06555352f, -0.09891651f, 
    0.20222335f, -0.18615156f, -0.20355070f, -0.34277123f, 0.08650115f, -0.10931262f, -0.00491736f, -0.13984853f, 
    0.20049036f, -0.14599401f, -0.14731967f, 0.03543408f, 0.31990036f, -0.04763813f, -0.00922216f, 0.21130680f, 
    -0.12637947f, -0.00735131f, 0.14657748f, 0.17360763f, -0.19018590f, 0.09350631f, 0.12927824f, 0.15294437f, 
    -0.02538350f, -0.01005004f, -0.28995660f, -0.20617791f, 0.11779782f, -0.12059229f, 0.45367256f, 0.23005414f, 
    0.06534422f, 0.01864930f, 0.23016311f, -0.06405877f, -0.21104288f, -0.30907953f, 0.01988653f, 0.37345818f, 
    0.06532598f, -0.06731801f, -0.04473308f, -0.07042435f, 0.15484144f, 0.13275866f, -0.07890659f, -0.21385550f, 
    -0.05713565f, -0.05286372f, 0.10429091f, -0.14176483f, -0.08125768f, -0.17719620f, -0.02067940f, -0.09399559f, 
    -0.16879134f, -0.10990360f, 0.26193124f, 0.18329947f, 0.06665686f, 0.09662978f, 0.20273648f, 0.18688089f, 
    0.25796098f, 0.14521228f, 0.10660687f, -0.17543928f, -0.09073556f, 0.05894700f, 0.03351308f, -0.06905630f, 
    -0.05890973f, -0.04130572f, 0.29886523f, 0.16556573f, 0.09375589f, 0.05318233f, 0.12004952f, -0.18028782f, 
    0.02938452f, 0.11267915f, 0.20930342f, -0.46354890f, -0.45637557f, 0.00658223f, -0.05318670f, 0.01204452f, 
    0.12830083f, 0.02047505f, -0.07716026f, -0.17101561f, -0.18355395f, 0.32475883f, 0.06458246f, 0.21579458f, 
    -0.05416628f, 0.01483754f, -0.12864166f, -0.05698537f, -0.49653664f, -0.50143623f, 0.18689317f, -0.05343275f, 
    -0.04680546f, -0.03249517f, -0.08025248f, -0.13348350f, 0.07565813f, -0.41576257f, 0.44759610f, -0.05898752f, 
    0.13597319f, -0.01443358f, 0.15217900f, -0.19284719f, 0.16818231f, -0.02854373f, -0.53646797f, -0.17650507f, 
    -0.31316873f, -0.17571986f, -0.23271170f, -0.18765305f, 0.14177901f, 0.24952537f, -0.08432708f, 0.22218004f, 
    0.19245972f, 0.33377561f, 0.04629822f, 0.09529987f, 0.00057195f, -0.02381995f, -0.31780770f, 0.17343894f, 
    -0.11402684f, -0.08406436f, -0.18095113f, 0.11249326f, 0.14121839f, -0.01746244f, -0.06192291f, 0.22620225f, 
    -0.29252157f, -0.66990554f, -0.08497629f, 0.09680884f, 0.07138459f, -0.04538433f, 0.21035522f, -0.00246181f, 
    -0.12465211f, 0.20182697f, 0.28619349f, 0.16393901f, 0.15693437f, 0.09612565f, -0.03643915f, -0.05137412f, 
    0.40550363f, -0.00511850f, 0.07105879f, -0.07010168f, -0.22707996f, 0.03763952f, 0.15555048f, 0.06725138f, 
    0.08173133f, 0.03835758f, 0.15622631f, 0.14771263f, 0.01074933f, 0.19249083f, 0.06434324f, 0.01111021f, 
    -0.03002765f, -0.10669866f, 0.14503242f, 0.02527101f, -0.00323146f, -0.54324603f, -0.13762967f, -0.21689810f, 
    0.04103041f, 0.11310381f, 0.10080030f, -0.03724091f, -0.08173046f, -0.24835616f, 0.10824302f, 0.22621778f, 
    0.24547039f, -0.20371501f, -0.03718247f, -0.54886109f, 0.01534534f, -0.13552150f, 0.17783460f, 0.13321564f, 
    -0.01274925f, 0.26217788f, -0.00140761f, 0.00994588f, -0.11709057f, 0.13037826f, -0.03961707f, 0.16258742f, 
    0.65407902f, -0.47587192f, -0.37991163f, -0.14422780f, 0.08565292f, 0.08358648f, 0.19775555f, -0.01955936f, 
    0.01319676f, 0.15322644f, 0.18979661f, 0.13645937f, -0.11917290f, 0.03811460f, -0.11986305f, -0.06416229f, 
    0.03177743f, -0.03136743f, 0.06035206f, 0.38293621f, -0.32102898f, 0.12483049f, 0.16630830f, 0.01575406f, 
    -0.06819030f, 0.53648102f, -0.20744556f, -0.22000569f, -0.59797376f, -0.16857518f, -0.05367693f, -0.04513099f, 
    -0.21452352f, -0.08106043f, 0.08346356f, 0.03801873f, 0.07457298f, 0.13014163f, 0.23809101f, -0.29516122f, 
    -0.07783474f, -0.43464732f, -0.13631535f, -0.03454159f, -0.15860160f, 0.98591012f, -0.08074755f, -0.23007014f, 
    0.03016588f, -0.13493690f, -0.05759071f, 0.06753085f, 0.04142309f, -0.40125206f, 0.38181904f, -0.00190457f, 
    -0.27866977f, -0.28083459f, -0.26189372f, -0.24952103f, 0.12417939f, -0.05544017f, -0.11267651f, 0.03425795f, 
    0.07866061f, 0.04689616f, -0.22356550f, -0.08931043f, -0.28548133f, -0.08300827f, 0.02240236f, 0.01842606f, 
    0.75997132f, 0.20790321f, 0.33062178f, -0.15253650f, -0.01569191f, -0.04243283f, 0.01734044f, 0.03277575f, 
    -0.08559157f, -0.01315086f, 0.08011349f, -0.02937915f, -0.06228563f, -0.22036192f, -0.16845414f, 0.16403234f, 
    0.18163279f, -0.00605982f, 0.31420076f, 0.04875528f, -0.03742659f, -0.26501524f, -0.19585696f, -0.14304926f, 
    0.08263057f, 0.03404707f, -0.04282093f, -0.30020553f, 0.15752472f, 0.52074283f, 0.28527319f, 0.12607376f, 
    0.08897357f, 0.00894718f, -0.03117033f, 0.38086060f, -0.38607904f, 0.02244233f, -0.07246308f, -0.08433411f, 
    0.00333760f, 0.01989653f, -0.17134844f, 0.10673279f, 0.13830051f, 1.21446562f, -0.01040712f, 0.21844654f, 
    -0.15004905f, -0.18315904f, -0.24430470f, 0.07636320f, -0.06140222f, -0.25040355f, 0.43346182f, 0.20571175f, 
    0.21961731f, -0.18421574f, -0.12314349f, 0.08616583f, 0.22998305f, -0.00663240f, 0.01237433f, 0.15202595f, 
    0.17176078f, 0.34023342f, -0.00017252f, 0.08266119f, -0.12179924f, -0.11193676f, -0.37479684f, -0.12190763f, 
    0.47108799f, -0.05229937f, -0.22367147f, -0.03178159f, 0.32616803f, 0.12913927f, 0.06541036f, 0.01879223f, 
    -0.03159095f, 0.14850864f, -0.51726454f, -0.58638513f, -0.02811581f, 0.02348397f, -0.18666570f, -0.18047145f, 
    0.08898448f, -0.20350888f, -0.25745502f, 0.16785541f, 0.27177131f, 0.11281490f, 0.25464606f, 0.02277814f, 
    -0.01974672f, 0.04212427f, 0.16437724f, 0.07514237f, -0.13623655f, 0.06496926f, 0.02074616f, 0.11122267f, 
    0.16136913f, -0.13557233f, -0.00503829f, 0.01913601f, 0.18038478f, -0.05899241f, 0.26781633f, 0.05570334f, 
    0.17118180f, 0.10055985f, -0.09759457f, -0.23608629f, -0.13124390f, 0.00905979f, -0.34525460f, -0.30728784f, 
    0.16044344f, -0.25006452f, -0.14667042f, -0.08476648f, -0.09588097f, -0.06521854f, -0.05599301f, -0.15594028f, 
    -0.03049455f, 0.11673729f, 0.05755758f, 0.14372487f, -0.04658581f, 0.01782276f, 0.06529975f, 0.08934344f, 
    0.10143824f, 0.27505848f, -0.11509835f, 0.06927464f, 0.11447282f, -0.29487392f, 0.04716189f, -0.21879862f, 
    -0.38942882f, 0.33255231f, 0.05868041f, -0.13327369f, -0.08632260f, 0.14428763f, -0.11615040f, -0.33101952f, 
    -0.03213579f, 0.01894606f, 0.37183017f, 0.13600010f, -0.21883161f, -0.12533185f, 0.03250158f, 0.10323907f, 
    -0.06950428f, -0.17658328f, -0.06350974f, 0.24059136f, -0.03066673f, -0.16276723f, 0.20303014f, -0.05275125f, 
    0.13084291f, 0.29395851f, 0.05535775f, 0.13853037f, 0.13471799f, -0.21038105f, -0.15376000f, -0.19016947f, 
    -0.05976086f, -0.02033006f, -0.03012596f, -0.32125083f, -0.12483460f, -0.09204401f, -0.03888700f, -0.11640448f, 
    0.09766621f, 0.04553477f, 0.07411513f, -0.21780743f, -0.18486099f, -0.20524335f, 0.32981518f, 0.38195279f, 
    -0.07698203f, -0.11464796f, -0.03247772f, -0.00948380f, -0.08060485f, -0.07817470f, -0.15868542f, -0.04420399f, 
    -0.08022236f, -0.18052855f, 0.11766811f, -0.10001267f, 0.06117361f, -0.01110863f, -0.17554501f, 0.01044235f, 
    0.06327779f, -0.16111521f, 0.04653506f, 0.14502390f, 0.01803876f, 0.08567372f, -0.05842200f, -0.09823112f, 
    0.20895800f, -0.04520388f, 0.47636899f, -0.00909400f, -0.00185255f, -0.24621335f, 0.10317755f, -0.10529501f, 
    0.11217766f, -0.28082830f, 0.18508522f, -0.03194269f, -0.18367210f, 0.19989519f, 0.19334441f, 0.12356316f, 
    0.11131679f, 0.13135995f, 0.09940057f, 0.38865352f, 0.20722918f, 0.06979107f, -0.01323466f, -0.18858388f, 
    0.00688356f, 0.18368617f, -0.16593200f, -0.17106234f, -0.08319255f, 0.31685650f, -0.03475438f, 0.09447575f, 
    -0.17449199f, -0.04130602f, 0.13675827f, 0.19968535f, 0.15011519f, -0.07061657f, 0.25343034f, 0.12856142f, 
    0.28041553f, -0.03190496f, -0.31248039f, -0.00999592f, 0.03061424f, -0.26679286f, 0.08933040f, 0.23320225f, 
    -0.18072122f, -0.03994113f, -0.02184614f, 0.11595661f, 0.09022073f, 0.10200379f, -0.33906707f, 0.18473400f, 
    -0.02560692f, -0.01202501f, 0.00877893f, -0.12898116f, 0.00345980f, -0.16799170f, -0.03384509f, -0.29753739f, 
    0.14280210f, 0.00942601f, -0.31170934f, -0.01264878f, 0.29810762f, 0.04232330f, 0.19131793f, -0.11240839f, 
    0.04545881f, 0.11302882f, 0.34532768f, -0.09197881f, 0.08712568f, 0.05268321f, 0.15209375f, -0.00149794f, 
    0.14005780f, -0.10050239f, -0.01132332f, -0.00178480f, -0.18411605f, 0.03764406f, 0.04456398f, 0.10785203f, 
    -0.04571848f, -0.09960662f, -0.05317841f, 0.15706718f, 0.09438954f, -0.01117611f, 0.09457245f, -0.24450472f, 
    0.14412886f, -0.30475920f, -0.25468096f, -0.04309424f, 0.01351431f, 0.02989791f, 0.08243037f, -0.17009905f, 
    -0.21388365f, -0.09775768f, -0.42365152f, -0.22678399f, 0.28922477f, 0.51350522f, 0.39657107f, 0.22735077f, 
    -0.01240740f, 0.09442935f, 0.07158657f, 0.02747910f, -0.05540428f, -0.00905052f, -0.12130224f, 0.13848814f, 
    -0.12545194f, 0.07149723f, 0.00696871f, -0.04351753f, 0.10617729f, 0.17793208f, 0.07302920f, -0.38815495f, 
    0.08831622f, 0.03217075f, 0.12037920f, -0.16474517f, 0.03481050f, 0.06849252f, -0.12841406f, -0.20011120f, 
    -0.02730635f, 0.09197705f, 0.04494800f, 0.13887726f, -0.00819006f, 0.18310927f, 0.06382083f, -0.06764597f, 
    0.00340940f, -0.08190792f, 0.11729059f, 0.09414186f, 0.08178242f, 0.13704373f, 0.01772205f, -0.07766717f, 
    0.02729906f, -0.32171085f, 0.23482332f, 0.03166897f, 0.13064386f, -0.13303213f, -0.10703804f, -0.16492060f, 
    0.23173094f, 0.37401885f, 0.00007099f, 0.26662615f, -0.18211840f, -0.19160964f, 0.08495667f, -0.05227171f, 
    0.07038388f, 0.08594190f, 0.12150571f, 0.25260648f, 0.04798595f, 0.39019617f, -0.21718296f, 0.07174790f, 
    0.02337893f, -0.11367776f, -0.12397359f, -0.02618308f, 0.09032802f, 0.08531262f, -0.19061927f, -0.03532282f, 
    -0.17317231f, 0.00311308f, 0.07636693f, 0.07722025f, -0.05710889f, -0.59193033f, -0.04278854f, -0.02117381f, 
    -0.07858665f, 0.06938407f, 0.12065786f, -0.00439346f, 0.26794499f, 0.10591938f, -0.14020009f, 0.02468805f, 
    0.00912146f, -0.07073603f, -0.14901267f, 0.04069220f, 0.08992231f, 0.01894623f, -0.06659616f, 0.27560934f, 
    0.19937253f, 0.54750377f, 0.17969431f, -0.16440856f, 0.01661262f, 0.01063052f, 0.00868911f, 0.05769701f, 
    0.04655873f, 0.07745516f, 0.37175971f, -0.04326755f, 0.16091353f, 0.08868586f, 0.16281523f, 0.01772775f, 
    0.27029577f, 0.29354164f, -0.06594223f, -0.04050576f, 0.02611684f, 0.26796487f, 0.09055238f, 0.02940113f, 
    0.04968267f, 0.06912435f, -0.48965073f, -0.07002769f, 0.08578054f, 0.12377910f, -0.00944691f, 0.18295269f, 
    0.05032936f, -0.09148067f, 0.12374773f, -0.06044780f, 0.04192407f, 0.00117559f, -0.14227811f, 0.24031386f, 
    0.11841044f, -0.10635620f, 0.09508733f, 0.12488244f, 0.17958243f, 0.00805507f, 0.14421278f, 0.11988097f, 
    0.21440020f, 0.17777826f, 0.13896994f, -0.04769200f, 0.31193998f, 0.31434336f, -0.18010037f, -0.15818346f, 
    0.10871115f, 0.06466520f, 0.02090267f, 0.07334035f, 0.13771817f, 0.26961267f, -0.31096655f, 0.01403963f, 
    -0.22180335f, 0.04912635f, 0.09062455f, 0.06758574f, 0.10655382f, 0.32860687f, -0.14732470f, -0.06620423f, 
    0.12399249f, 0.18831024f, 0.02655218f, -0.03640965f, 0.08871654f, -0.07756372f, -0.05506587f, 0.02744004f, 
    -0.13466778f, 0.22764392f, 0.34582040f, -0.00266547f, -0.08163917f, -0.19217186f, 0.08095572f, -0.12836143f, 
    -0.04426059f, 0.06696990f, -0.13270193f, 0.12693375f, -0.04885939f, 0.10592643f, 0.25569764f, 0.28326258f, 
    0.02727582f, 0.12290451f, -0.15376084f, -0.00402417f, 0.00289730f, -0.31506062f, -0.03590664f, 0.20384726f, 
    0.11848777f, -0.13071214f, 0.10406677f, 0.07997536f, 0.05274077f, -0.03639971f, 0.05397876f, 0.05321186f, 
    0.01179051f, 0.05407266f, 0.01478150f, -0.00387453f, -0.23771700f, -0.03080302f, -0.21380019f, -0.03973831f, 
    0.04842696f, 0.08768639f, -0.07559159f, -0.15401840f, -0.19772547f, -0.31019726f, 0.03731259f, 0.28523493f, 
    -0.29761580f, 0.11791015f, 0.20528346f, -0.07694195f, 0.11399662f, 0.00667057f, -0.61049795f, -0.40886912f, 
    0.08334398f, 0.03736251f, 0.25500107f, 0.11167273f, -0.09392829f, 0.09506208f, -0.13448405f, -0.04934653f, 
    -0.07806230f, -0.00275700f, 0.04261348f, 0.06420041f, 0.06778501f, -0.01365421f, -0.19462556f, -0.36007524f, 
    -0.07690181f, -0.17000978f, -0.10508714f, -0.08407810f, -0.09475697f, -0.01420519f, 0.05064597f, -0.04043168f, 
    0.07742848f, 0.19050680f, 0.16628759f, 0.22303556f, 0.18633488f, 0.15896817f, 0.20877203f, 0.12230207f, 
    -0.17129199f, 0.08590168f, 0.00251450f, 0.07894440f, 0.22343788f, -0.07767960f, -0.01907633f, 0.04384069f, 
    -0.16412726f, 0.15610275f, -0.07322953f, 0.10056796f, 0.11278025f, -0.75140190f, 0.05914798f, 0.25507355f, 
    -0.20575570f, 0.35360304f, 0.18597770f, -0.03131898f, -0.17385420f, -0.62852669f, -0.74230719f, -0.22888635f, 
    0.00727369f, 0.11405483f, -0.01991540f, 0.00460009f, -0.15647674f, -0.34127402f, -0.14729597f, 0.03144240f, 
    0.00729070f, -0.19138741f, -0.16923250f, -0.01448001f, -0.07184538f, -0.08707739f, 0.04584401f, 0.09283864f, 
    0.08586890f, 0.01172431f, 0.06455018f, -0.01982079f, 0.06391647f, 0.23294038f, -0.09075172f, -0.05967263f, 
    0.03510320f, -0.07279003f, -0.02024427f, -0.03278553f, 0.09793190f, 0.10603778f, 0.13205691f, -0.04029492f, 
    -0.34192342f, 0.47228026f, -0.09979219f, 0.20025794f, -0.10764087f, 0.05172644f, 0.02647504f, 0.13008936f, 
    -0.27079308f, 0.25592437f, -0.33589175f, 0.00590887f, -0.24036086f, -0.23635657f, -0.06559528f, -0.32386407f, 
    0.09593375f, -0.24499719f, -0.23609930f, -0.64940709f, -0.15507495f, -0.12204538f, 0.10503425f, -0.04233392f, 
    -0.12049205f, -0.17724375f, 0.01380868f, -0.00250634f, -0.37084717f, 0.42660722f, 0.28604734f, 0.06302658f, 
    0.05085160f, 0.06758568f, 0.00816164f, -0.07247721f, 0.04660180f, 0.00795244f, 0.19975942f, 0.00033820f, 
    0.09112966f, 0.04436770f, -0.01031707f, -0.01478327f, -0.11656032f, 0.35203031f, -0.23337585f, 0.29347780f, 
    0.23982449f, -0.03613605f, 0.17087142f, 0.16220088f, -0.10132955f, -0.09972690f, 0.10891525f, 0.08064875f, 
    0.18323317f, 0.14687127f, 0.07829218f, 0.13351136f, -0.04275408f, 0.02703686f, 0.00297307f, 0.00394510f, 
    -0.35517129f, -0.10699548f, -0.09891053f, -0.24041352f, 0.08710824f, -0.08314697f, 0.05283730f, -0.03962446f, 
    0.33962610f, 0.26915002f, 0.11389898f, 0.02397441f, -0.03311020f, -0.21275942f, 0.18564531f, 0.17422183f, 
    0.12898250f, 0.12817886f, -0.01556099f, 0.25027874f, 0.01255056f, 0.11437771f, 0.06978671f, -0.15554501f, 
    0.13367091f, 0.13123229f, 0.19245031f, 0.04704464f, 0.07678080f, 0.20272017f, 0.01770147f, -0.00676689f, 
    -0.06546285f, 0.03116084f, -0.06370313f, 0.10044584f, 0.10163906f, -0.05574232f, 0.04679752f, -0.03164520f, 
    -0.01717028f, -0.09420002f, 0.12859184f, 0.18618178f, 0.15889184f, 0.13107090f, -0.09087285f, 0.10124302f, 
    0.05604462f, -0.14479427f, 0.04821850f, 0.10892454f, -0.20816816f, -0.01108218f, -0.21795975f, 0.04373237f, 
    0.06646664f, -0.01777865f, 0.04667141f, 0.10002814f, 0.15082414f, -0.09691973f, -0.04911828f, 0.09324489f, 
    -0.17597738f, 0.13367555f, -0.06367150f, -0.08738007f, -0.04932622f, -0.09742934f, -0.03456746f, 0.05871537f, 
    0.07441594f, 0.09018787f, 0.03819279f, 0.08491764f, 0.02043283f, -0.11833553f, 0.03041836f, -0.07119165f, 
    -0.02243715f, -0.28080529f, -0.02822165f, -0.10910232f, 0.03806149f, 0.09458844f, -0.12607439f, 0.04174511f, 
    -0.07454024f, -0.02727229f, 0.09509287f, 0.29546839f, -0.11384745f, 0.05461743f, 0.23919362f, -0.09722355f, 
    0.03796035f, -0.17285542f, -0.42431992f, 0.09348331f, 0.15318955f, 0.31043568f, 0.05941477f, -0.01351210f, 
    0.06548662f, 0.11710338f, -0.05803811f, 0.02622670f, -0.10558297f, 0.16565742f, 0.02644708f, 0.05889916f, 
    0.15653971f, 0.04119558f, -0.11953676f, 0.00294939f, 0.06669441f, 0.08519549f, -0.08999794f, 0.16255561f, 
    0.04587756f, 0.06834085f, 0.03692182f, -0.13091566f, -0.19583663f, -0.36198181f, -0.16826081f, -0.11101837f, 
    0.19852513f, 0.21533899f, 0.08668748f, 0.06420670f, -0.11080042f, 0.04356536f, 0.12686624f, -0.00229414f, 
    -0.41938743f, 0.09485353f, -0.13655029f, 0.09229016f, -0.09607182f, -0.09178152f, -0.04704897f, 0.05157753f, 
    0.19241354f, 0.10296972f, 0.10450862f, 0.23478074f, 0.17854381f, -0.20794858f, -0.02087134f, -0.12316985f, 
    -0.19888613f, -0.08058426f, 0.18340880f, 0.19335186f, 0.10656434f, 0.01368372f, 0.15129839f, -0.02718859f, 
    0.13045590f, 0.06787132f, 0.06814796f, -0.04623915f, 0.08471682f, 0.08107232f, 0.19163021f, -0.07944633f, 
    -0.07375856f, -0.18835726f, -0.03110158f, 0.04641126f, -0.17914543f, 0.00094916f, 0.02949919f, 0.06388113f, 
    -0.08816949f, -0.02567557f, -0.05657505f, -0.06844836f, 0.03059900f, -0.08897506f, -0.12812674f, 0.04215707f, 
    -0.03371583f, 0.14404507f, 0.03125994f, 0.18694618f, 0.08687148f, -0.03681617f, -0.21927623f, 0.08657536f, 
    0.08145852f, 0.15655077f, 0.05681533f, -0.05622027f, -0.18291681f, -0.11194293f, -0.19174041f, -0.13412079f, 
    0.02075414f, 0.06115289f, 0.05591661f, 0.07569796f, 0.04976528f, 0.20700602f, 0.07679897f, 0.05082838f, 
    -0.05635984f, 0.04145436f, 0.09968899f, -0.08654973f, -0.01832194f, 0.06790917f, 0.03648119f, -0.05800913f, 
    0.02030084f, 0.04420523f, -0.10556681f, -0.00108910f, -0.03178130f, -0.06936938f, -0.08061124f, -0.13876204f, 
    -0.15711358f, 0.08650082f, 0.06732366f, 0.08830900f, -0.07700466f, 0.00580196f, 0.19143452f, -0.15682290f, 
    -0.08393978f, 0.14701647f, 0.03371513f, -0.11855167f, -0.03841415f, 0.00239215f, 0.08717927f, -0.11541814f, 
    -0.15789904f, 0.08826401f, -0.13797092f, -0.05278010f, 0.06825561f, 0.04995789f, -0.16479331f, -0.01125308f, 
    -0.06808995f, 0.01284944f, -0.26207682f, 0.02790071f, 0.16928415f, 0.11154398f, -0.13442937f, -0.02916586f, 
    0.03961340f, -0.18214494f, 0.12756711f, 0.16128215f, -0.01715714f, 0.03001293f, 0.01115627f, 0.06947668f, 
    -0.00689749f, -0.18630321f, -0.01961063f, 0.06930909f, -0.04190952f, 0.37081876f, -0.26496610f, 0.08026382f, 
    -0.18285809f, 0.17119674f, 0.16830637f, -0.22885117f, 0.00771883f, -0.16301681f, 0.09225436f, 0.10889149f, 
    0.18076260f, -0.08319185f, -0.04052762f, -0.04452588f, -0.01763441f, 0.05758034f, -0.03418832f, -0.16760585f, 
    -0.08959367f, 0.28952089f, 0.01408920f, 0.10257111f, 0.15769848f, 0.12265225f, -0.08302068f, -0.00129551f, 
    -0.04152969f, -0.64860368f, 0.09060613f, 0.01099844f, -0.03461996f, -0.09027062f, 0.07586183f, 0.19494618f, 
    -0.15360835f, 0.09129224f, 0.01820147f, -0.05436624f, 0.03241094f, -0.19476008f, 0.01722698f, -0.03243248f, 
    0.09095129f, 0.03775435f, -0.42468914f, -0.10576528f, -0.52368182f, -0.20930809f, -0.20325029f, -0.05137376f, 
    -0.19536752f, -0.06555707f, -0.16712621f, -0.21255296f, -0.47636971f, -0.01652655f, 0.13233170f, -0.11036517f, 
    -0.19678538f, -0.13655077f, 0.08206546f, 0.15520024f, -0.17210367f, -0.30949491f, -0.19645214f, 0.16148144f, 
    0.01409751f, -0.09355694f, -0.03892107f, 0.00942054f, -0.17493132f, 0.35336086f, 0.59246224f, 0.32203269f, 
    0.08209646f, -0.02891450f, -0.10380251f, -0.02330794f, -0.11826470f, 0.06594174f, -0.20071372f, -0.17006873f, 
    0.19331981f, 0.10064955f, -0.04432020f, -0.03863283f, -0.14285421f, -0.00555340f, 0.03063828f, -0.05319045f, 
    -0.05338402f, -0.21354328f, 0.12510635f, -0.13295901f, 0.02783822f, -0.06512865f, 0.09125207f, 0.22485790f, 
    0.18238695f, 0.19188032f, -0.30707094f, 0.31409833f, -0.01870788f, 0.16562863f, 0.03436132f, -0.00611815f, 
    0.04976199f, -0.07540770f, -0.18813026f, -0.40097651f, 0.01690383f, 0.05003094f, -0.11833764f, -0.17885616f, 
    -0.11812437f, 0.04634629f, 0.47657704f, 0.31512114f, 0.00157934f, 0.08360901f, 0.03409054f, -0.03752324f, 
    -0.05856120f, 0.22038585f, -0.02877991f, 0.18376642f, 0.20683175f, -0.04733128f, -0.05953288f, -0.08668894f, 
    0.23582903f, -0.07828546f, 0.11544617f, -0.08375338f, 0.12357887f, 0.15763669f, 0.31746700f, 0.05289977f, 
    -0.03039077f, 0.01849651f, 0.04041663f, -0.01867550f, 0.08383611f, 0.66986084f, 0.24310173f, 0.15323338f, 
    0.13284434f, -0.04797896f, -0.07256446f, 0.04108965f, 0.10926610f, -0.14494151f, -0.06846704f, -0.62346923f, 
    -0.09400962f, 0.17206378f, 0.01747066f, 0.15903366f, 0.14812286f, 0.02453106f, 0.20427194f, 0.30457234f, 
    0.23412351f, -0.61131048f, 0.08584639f, 0.06573533f, -0.07967655f, 0.18807696f, 0.04296740f, -0.32503650f, 
    0.45474851f, 0.23750922f, 0.14504896f, 0.04408415f, -0.22274889f, -0.08090460f, -0.01453369f, -0.01359045f, 
    -0.01319195f, 0.09982514f, -0.23577023f, -0.09600987f, -0.08268207f, 0.06045315f, 0.05591463f, -0.01824538f, 
    0.09003123f, -0.01826929f, -0.10241964f, -0.09973274f, -0.09453551f, 0.12032535f, 0.12035412f, 0.07543565f, 
    0.20202708f, 0.13511376f, 0.15049905f, 0.55015969f, 0.44599646f, 0.34032711f, -0.19472145f, -0.09674841f, 
    -0.14731011f, 0.04234264f, -0.04803197f, 0.16602512f, 0.09143473f, 0.43936417f, 0.37985227f, -0.01725667f, 
    -0.13031392f, 0.05078479f, -0.03875387f, -0.02268909f, -0.02607968f, 0.30238035f, 0.16118698f, -0.10394591f, 
    -0.02530541f, -0.04776231f, 0.01960613f, -0.08240350f, 0.00611916f, -0.04822886f, -0.10919657f, -0.03694061f, 
    -0.05987382f, 0.05086767f, 0.12556228f, 0.01910634f, 0.24211580f, -0.11664649f, 0.07464425f, 0.29311731f, 
    -0.34573865f, -0.11268579f, 0.11558109f, -0.03377384f, -0.09876317f, 0.11566082f, -0.11310006f, -0.08016850f, 
    -0.06032291f, 0.08974561f, -0.33843383f, -0.08542089f, -0.04900115f, -0.01094542f, 0.01876116f, 0.03506659f, 
    -0.12275161f, 0.20411891f, -0.11176275f, -0.23924303f, -0.08457445f, -0.04801407f, -0.14377761f, 0.05285754f, 
    0.09620075f, -0.02313804f, -0.53467697f, -0.42063665f, 0.14355052f, 0.12852912f, -0.43834722f, -0.20141706f, 
    0.04506733f, 0.09222645f, 0.04792656f, -0.10814894f, -0.19714512f, -0.32401362f, -0.14730637f, -0.11642706f, 
    0.11424164f, 0.07448576f, 0.13614783f, -0.07360157f, 0.03909499f, -0.35126892f, 0.06798968f, 0.19078851f, 
    0.08138739f, 0.01216421f, 0.22128743f, -0.01070566f, -0.04607743f, 0.14016956f, -0.22303227f, -0.49681103f, 
    -0.04631356f, -0.16520070f, 0.08277375f, 0.11062654f, 0.21781494f, -0.24130398f, 0.19982828f, 0.04326179f, 
    -0.34524152f, -0.17748281f, 0.26195231f, -0.21876967f, 0.12062904f, 0.07508531f, -0.13707229f, 0.49258593f, 
    0.40148577f, 0.01084439f, 0.11824495f, -0.03617117f, -0.08439438f, -0.00235670f, -0.00045570f, -0.03062171f, 
    0.10611971f, -0.12607387f, -0.43623081f, 0.00373476f, 0.04567587f, -0.03225478f, 0.01695348f, -0.02511024f, 
    0.13789463f, 0.28494167f, 0.14645362f, -0.01220083f, 0.02057030f, 0.03836670f, 0.30058664f, 0.06057177f, 
    0.07001964f, 0.08838566f, -0.18609323f, 0.03948200f, -0.32944325f, 0.11672027f, -0.17664631f, 0.40977576f, 
    -0.04314383f, 0.17065261f, 0.08154929f, 0.10159390f, 0.03207584f, -0.19706675f, 0.03991541f, -0.00164601f, 
    0.12164904f, 0.07131737f, 0.00502061f, -0.07464052f, 0.13504362f, -0.09773185f, -0.19782093f, 0.08199339f, 
    0.07675869f, 0.00491603f, 0.10490785f, -0.20760730f, -0.17860638f, -0.01347867f, 0.15253152f, 0.43423107f, 
    0.19729106f, 0.06206631f, -0.15908988f, -0.13824429f, -0.18422282f, 0.04876936f, 0.09699292f, 0.20598274f, 
    -0.14417666f, 0.12283748f, 0.07546660f, 0.11660505f, -0.05139526f, -0.04203317f, -0.20099033f, 0.13352892f, 
    0.04427747f, -0.08076926f, 0.10889837f, 0.08320373f, 0.05940418f, -0.02425561f, 0.05886440f, -0.07510296f, 
    -0.27261245f, -0.27054068f, -0.09935355f, 0.03741151f, -0.02519443f, -0.17070943f, 0.03803331f, 0.02730375f, 
    0.20512041f, 0.24226023f, 0.01222693f, -0.14671575f, 0.16268793f, -0.02213799f, -0.26377085f, 0.08522701f, 
    0.34939390f, 0.13441855f, 0.46154261f, -0.45758420f, -0.03067369f, 0.43843609f, 0.05815433f, -0.17953913f, 
    -0.16203983f, -0.26000780f, -0.03294395f, -0.21016431f, 0.02401017f, 0.09663611f, -0.19648847f, -0.15865070f, 
    -0.10673832f, -0.18083976f, 0.18544930f, 0.27784830f, 0.41923586f, 0.11575926f, -0.15777077f, 0.15978858f, 
    0.06121856f, 0.14455695f, 0.02688244f, -0.19266683f, -0.11758935f, 0.17013581f, -0.22374777f, -0.05119616f, 
    0.26913944f, -0.37255630f, 0.08540321f, 0.02256210f, 0.08485159f, 0.05547468f, 0.31807965f, 0.15556315f, 
    -0.50479394f, 0.07710192f, 0.08130595f, -0.02059818f, 0.09170432f, 0.24058989f, 0.10811648f, 0.01873401f, 
    0.07006673f, 0.07501373f, 0.07411856f, 0.01201386f, -0.05464192f, -0.18155430f, -0.08352999f, -0.04270506f, 
    -0.10395968f, -0.04661288f, 0.19761270f, 0.12273906f, -0.29831618f, -0.08154938f, -0.05328207f, 0.00878570f, 
    0.15584354f, 0.18435059f, -0.09624501f, -0.11924341f, 0.14945868f, 0.05811154f, -0.08247083f, -0.05162141f, 
    -0.30625764f, -0.48546705f, 0.12477312f, 0.05262371f, -0.09182651f, 0.07357458f, 0.06025673f, 0.05497714f, 
    0.11119352f, -0.39085299f, -0.12573105f, -0.01521825f, -0.05729268f, -0.00002006f, 0.04933413f, 0.13501059f, 
    -0.06929491f, 0.15630347f, -0.17363110f, -0.13560359f, 0.36186892f, 0.10430989f, 0.18943532f, 0.57013810f, 
    -0.23554088f, 0.08414308f, -0.01005410f, 0.15282606f, 0.09936672f, -0.29807699f, 0.05841308f, -0.18081275f, 
    0.09136457f, -0.09786281f, 0.18941286f, -0.12049568f, 0.12846108f, 0.22833946f, 0.05466186f, -0.01946453f, 
    0.10448281f, 0.08856633f, 0.13597459f, -0.09988678f, 0.12473267f, -0.12598735f, -0.02086035f, 0.01408986f, 
    -0.03580139f, -0.04389576f, 0.06206202f, 0.05890857f, 0.03090615f, 0.05631223f, 0.03231817f, -0.02009178f, 
    -0.18283154f, -0.04078162f, 0.00692359f, 0.10742174f, -0.05534144f, -0.03663801f, 0.26657242f, -0.65580231f, 
    -0.21170680f, -0.20874910f, -0.22031754f, 0.27327472f, 0.18617712f, 0.01563434f, 0.20865017f, -0.09949542f, 
    0.01986953f, 0.49203274f, 0.00078833f, -0.55633950f, -0.18191378f, -0.00792988f, -0.08823055f, -0.17973386f, 
    -0.09367784f, 0.23771806f, 0.08198196f, 0.07014510f, -0.15328513f, 0.04567535f, -0.02828353f, -0.02577437f, 
    0.16296297f, 0.04383473f, 0.20924319f, 0.06881525f, 0.21596007f, 0.03590854f, 0.06423336f, 0.05474456f, 
    -0.00597054f, 0.00631893f, -0.00669242f, 0.05773989f, 0.03275963f, -0.41000372f, -0.37822789f, -0.18556042f, 
    -0.05937372f, 0.04043446f, 0.00783853f, -0.20312698f, 0.13559242f, 0.22105256f, 0.04722694f, 0.07900362f, 
    -0.09759730f, 0.01705283f, -0.06500645f, 0.03210848f, 0.00437462f, -0.11419398f, -0.08364818f, 0.08693586f, 
    0.32793358f, 0.36484730f, 0.02854777f, -0.12951994f, -0.05963954f, 0.02494686f, 0.10322972f, 0.02372625f, 
    -0.62647432f, 0.10404219f, -0.34084603f, 0.10269818f, 0.11224936f, -0.05332721f, 0.03564044f, -0.03807826f, 
    0.03301130f, -0.11875282f, 0.25840127f, -0.09340194f, 0.11284979f, 0.08412290f, 0.20745680f, -0.04568816f, 
    0.01751566f, 0.06714636f, -0.48159847f, 0.33889386f, -0.30146301f, -0.01930512f, 0.28686386f, 0.07894597f, 
    0.28610799f, 0.17541741f, -0.14423013f, -0.02016674f, -0.05405011f, -0.53053910f, 0.20723905f, 0.08216715f, 
    0.27908185f, 0.01505518f, -0.10702927f, 0.09696529f, -0.29150996f, -0.11245360f, -0.13220055f, -0.07887301f, 
    0.00088823f, 0.13483977f, 0.37150043f, -0.02235973f, -0.04894597f, -0.17179020f, 0.47421923f, 0.37767377f, 
    0.01018136f, -0.05010404f, 0.11558762f, 0.04137436f, -0.05332175f, -0.02281756f, -0.32325825f, 0.28010994f, 
    -0.40073884f, -0.29107082f, -0.11227668f, -0.24893898f, -0.02008485f, 0.16153924f, 0.13613783f, -0.15841243f, 
    -0.05311124f, -0.18660337f, -0.05151789f, -0.04460248f, 0.02628303f, 0.15246211f, 0.08899477f, -0.02214226f, 
    0.28807712f, -0.15457720f, 0.30125865f, 0.08838644f, -0.15591830f, -0.31802955f, -0.13721423f, 0.00844896f, 
    0.08954507f, -0.22624712f, 0.09125008f, -0.34237051f, 0.21057548f, -0.06082897f, 0.01739077f, -0.21359247f, 
    0.21994638f, -0.35647765f, 0.01640348f, -0.00092995f, -0.18300286f, 0.02605662f, 0.35866082f, -0.05505399f, 
    -0.25448459f, 0.10548781f, -0.12421904f, 0.13926929f, -0.16145277f, -0.20500168f, -0.22346878f, -0.08342479f, 
    -0.24729806f, 0.16065675f, -0.01377111f, 0.06114786f, 0.14125550f, 0.37642282f, 0.01142688f, -0.09639417f, 
    0.00475863f, -0.31867331f, 0.15789422f, -0.00363960f, -0.13948634f, -0.25402004f, -0.07879804f, -0.04416507f, 
    0.28614724f, -0.29922742f, 0.05645902f, 0.08681419f, 0.05198198f, 0.04064219f, -0.27190104f, 0.54735243f, 
    0.24019299f, -0.00884441f, -0.39742434f, -0.34903881f, 0.05939555f, -0.00457735f, -0.00454845f, -0.26805910f, 
    0.00008722f, -0.12205957f, 0.02236105f, -0.06796647f, 0.06690107f, 0.03319706f, -0.20118044f, 0.06614594f, 
    -0.05846720f, -0.05478439f, 0.08385538f, -0.27577794f, -0.16096511f, -0.07869590f, 0.15199995f, -0.03859084f, 
    0.11478746f, -0.25129679f, -0.12844189f, -0.33177665f, 0.10023075f, 0.09797335f, 0.04909703f, 0.03747028f, 
    -0.02464657f, -0.00091575f, 0.06605821f, 0.07675198f, 0.17968746f, 0.01540611f, -0.19035637f, -0.30099696f, 
    0.08681067f, 0.12407555f, 0.09722728f, 0.39517099f, 0.38156599f, 0.42766619f, -0.06136229f, 0.02409302f, 
    -0.01083555f, 0.12693971f, 0.01845552f, 0.17125744f, 0.18695393f, -0.09565035f, -0.12646791f, 0.14320442f, 
    0.08240942f, 0.21176361f, -0.06875408f, 0.04332886f, 0.08359832f, 0.05525031f, -0.20816702f, -0.12621708f, 
    -0.12657879f, 0.13069451f, -0.06311571f, 0.07075652f, -0.08532474f, -0.06400009f, 0.11748666f, -0.13341483f, 
    0.05626491f, -0.14136317f, 0.13499193f, -0.30654696f, 0.10577510f, 0.11730853f, 0.07196656f, -0.07172868f, 
    0.11278969f, 0.00661614f, -0.23439318f, -0.02131927f, -0.04671868f, 0.13391739f, -0.02841043f, 0.18920183f, 
    -0.09233964f, -0.08016576f, 0.07740237f, -0.10712980f, 0.16066597f, -0.05412481f, 0.10912774f, 0.21639235f, 
    0.00217448f, 0.18970881f, 0.03430573f, 0.26851547f, 0.13315746f, -0.30363670f, 0.02584179f, 0.06978822f, 
    -0.01131135f, -0.15777862f, -0.43116966f, -0.23493499f, -0.44371131f, -0.07124241f, -0.05828893f, 0.10819261f, 
    0.09835604f, 0.13287693f, 0.20261273f, 0.06746932f, -0.34975100f, 0.34908742f, -0.13309672f, 0.19587699f, 
    -0.17436361f, 0.08298057f, 0.01967838f, 0.00946995f, -0.27894580f, -0.41119972f, -0.00437479f, -0.05678035f, 
    -0.02266952f, 0.10600138f, 0.07460144f, 0.18275154f, -0.00202029f, -0.22206269f, -0.27987239f, 0.17492832f, 
    0.21179163f, -0.40610942f, 0.00301968f, -0.09077068f, 0.07521420f, 0.06505476f, -0.23103520f, -0.27991673f, 
    -0.32967240f, 0.20514053f, -0.03464972f, 0.17252541f, 0.16153446f, -0.11421730f, 0.02823930f, 0.24026190f, 
    -0.16485651f, 0.06811258f, -0.36105424f, -0.12685108f, -0.00850097f, 0.09039862f, 0.02155066f, -0.04519454f, 
    -0.01422317f, 0.00457895f, 0.01078620f, -0.00963550f, 0.04997762f, -0.00028447f, -0.00732390f, -0.00241133f, 
    -0.00448513f, 0.04976049f, 0.03139815f, 0.00914419f, -0.06677281f, -0.03423939f, -0.03850722f, -0.00714235f, 
    0.00231750f, -0.02470278f, 0.03786156f, 0.01614016f, -0.03891157f, 0.05051079f, 0.01367875f, 0.01284266f, 
    -0.01960985f, 0.05396187f, 0.03361766f, -0.03856051f, -0.03243119f, 0.00472813f, 0.01234309f, 0.04864684f, 
    0.05392731f, -0.03626999f, 0.04527108f, 0.00131063f, -0.02767890f, -0.00414417f, 0.03284724f, -0.00743454f, 
    0.03960861f, -0.03308944f, 0.03832842f, -0.02141406f, -0.00139706f, 0.05644765f, 0.03633245f, -0.02431108f, 
    0.03888873f, -0.04800611f, 0.01213649f, -0.01779287f, 0.00713659f, 0.03185938f, -0.02842319f, -0.00218473f, 
    -0.04108984f, 0.05340756f, -0.03308146f, 0.03516399f, 0.04756663f, 0.03481233f, 0.01212769f, 0.03702689f, 
    -0.06602439f, -0.00558190f, -0.01620179f, -0.02194816f, -0.03658025f, -0.01888335f, -0.03167260f, -0.03006529f, 
    0.02855046f, 0.02762924f, 0.02705320f, -0.00863329f, 0.02747834f, -0.02221221f, -0.02579234f, 0.03332943f, 
    -0.01319387f, 0.00631633f, -0.04304100f, 0.02581590f, 0.01193773f, -0.02912712f, -0.01944388f, -0.02896559f, 
    -0.05593403f, 0.00080635f, 0.05075390f, 0.01282542f, -0.04171054f, -0.03079133f, -0.02792651f, -0.04703481f, 
    0.01599010f, -0.03017337f, 0.03432027f, -0.00360062f, 0.02151712f, 0.03291236f, 0.04459048f, -0.01274762f, 
    -0.06464330f, -0.01424826f, -0.05953182f, -0.01501548f, 0.04280397f, -0.00577226f, 0.00514659f, -0.01901098f, 
    -0.05071489f, -0.01902488f, 0.00293724f, -0.02527650f, -0.06157227f, -0.05324800f, 0.02900917f, -0.01453172f, 
    -0.00457094f, -0.04920821f, -0.03535381f, -0.00047895f, 0.04361162f, 0.01283725f, 0.00200607f, 0.01836212f, 
    -0.06851798f, -0.05122910f, -0.02659249f, 0.00017560f, 0.04875015f, -0.05318334f, -0.02515615f, -0.02989356f, 
    -0.05230568f, 0.00101724f, -0.00503663f, -0.02162188f, -0.05877897f, 0.04481914f, 0.01109176f, 0.01560742f, 
    -0.03205513f, -0.01861370f, -0.00793380f, -0.04177714f, -0.03481508f, 0.02044981f, -0.03360176f, 0.02999236f, 
    -0.01518871f, -0.02429378f, -0.02072552f, 0.04532992f, -0.04045740f, 0.00387315f, -0.05511215f, 0.04388805f, 
    0.01557670f, -0.06775057f, 0.00180438f, -0.03162036f, -0.03373225f, 0.03014164f, -0.02241646f, -0.02815627f, 
    0.00343602f, -0.05851271f, -0.04655061f, 0.03362980f, -0.06519366f, -0.03569605f, -0.05167022f, 0.01793943f, 
    0.05488200f, 0.02639458f, -0.02625748f, 0.03524497f, 0.00589139f, -0.01505592f, -0.00914517f, 0.04500043f, 
    -0.03473556f, 0.01161230f, -0.04271322f, -0.05045666f, 0.04747843f, 0.01977193f, -0.01933630f, 0.05805557f, 
    0.04598673f, 0.04959693f, 0.01664396f, -0.02603766f, -0.03178544f, -0.03222117f, 0.04051352f, 0.02271273f, 
    0.00198528f, -0.02537166f, 0.04373026f, 0.01283563f, 0.02210834f, 0.02316094f, 0.05255162f, -0.04037661f, 
    0.01717825f, -0.04242182f, 0.00075234f, -0.02857351f, -0.02624135f, -0.05730392f, 0.01386810f, -0.01023475f, 
    0.04700806f, 0.04511386f, -0.05690178f, 0.00518309f, -0.01626949f, 0.02343788f, 0.04262102f, -0.03595706f, 
    -0.06908903f, 0.04301735f, -0.04474498f, -0.01207963f, 0.04747596f, 0.01495217f, -0.02156414f, 0.00279209f, 
    0.01197507f, 0.00306864f, -0.03505918f, -0.00904318f, -0.02661991f, -0.03687173f, -0.00698491f, -0.04493452f, 
    -0.00883089f, -0.03461099f, 0.05591122f, -0.01410552f, -0.03011211f, 0.01317819f, -0.06373928f, -0.04867150f, 
    -0.03525857f, -0.01112040f, -0.03184569f, -0.05160647f, 0.03724819f, 0.00004000f, -0.03367859f, -0.02169427f, 
    0.03329161f, -0.03274858f, -0.02118402f, -0.02876144f, -0.02189920f, 0.01967163f, 0.00376759f, -0.06015793f, 
    -0.04288607f, -0.00178211f, -0.04960969f, -0.04898018f, -0.05188031f, -0.04737261f, -0.02739738f, -0.00168008f, 
    -0.06430626f, 0.05137604f, 0.02969268f, 0.02417454f, -0.05079604f, 0.04435386f, 0.03598147f, -0.03964705f, 
    0.01641099f, -0.00248346f, 0.02201033f, 0.02350738f, 0.03498290f, 0.02540390f, 0.00360769f, -0.00232186f, 
    0.41388229f, 0.12297161f, 0.52238196f, 0.16304041f, -0.01063196f, -0.01633823f, 0.22722428f, 0.13754289f, 
    -0.12338454f, 0.43624610f, 0.28728628f, 0.31233150f, -0.11990210f, 0.01458230f, -0.03686690f, -0.03846667f, 
    0.13050142f, 0.05427239f, 0.27421287f, -0.17263354f, -0.07309865f, 0.03167783f, 0.16472748f, -0.55284601f, 
    -0.01566539f, -0.03787980f, 0.09850511f, 0.69736546f, 0.45548019f, 0.20654257f, -0.11333676f, -0.15008733f, 
    -0.04947697f, 0.06593418f, 0.06161967f, 0.01787786f, 0.28421119f, 0.22117820f, 0.14478479f, -0.01691415f, 
    0.15806879f, 0.05287978f, 0.16186897f, 0.12924768f, -0.12593417f, 0.02354223f, -0.27448058f, -0.29411739f, 
    0.07439131f, 0.01762194f, 0.13707875f, 0.06862549f, 0.20034790f, 0.10444688f, 0.04291261f, -0.14779356f, 
    -0.21550635f, -0.18875547f, 0.08635436f, 0.06175598f, 0.01188187f, 0.01973239f, 0.26056391f, 0.26308393f, 
    0.31729954f, 0.09533227f, -0.16677977f, -0.09080631f, -0.15524517f, -0.06978250f, 0.07180998f, -0.01771269f, 
    -0.26449969f, -0.70825076f, -0.40388489f, -0.10669856f, 0.07296515f, -0.00906920f, -0.07407024f, -0.13824680f, 
    -0.16926253f, 0.15785915f, 0.13797612f, 0.13479264f, -0.09190851f, 0.01150562f, 0.08849252f, -0.14931658f, 
    0.16449846f, 0.04208238f, -0.20305839f, -0.54064989f, -0.09604573f, -0.04641869f, -0.12294827f, -0.01341380f, 
    0.15468794f, 0.18166600f, 0.14089517f, -0.35235432f, -0.28186116f, -0.42709816f, -0.11471244f, -0.03279783f, 
    0.26527542f, 0.12444767f, -0.18815896f, 0.09679480f, -0.22598307f, -0.21626645f, 0.20481689f, -0.04153938f, 
    0.00958202f, -0.03639093f, -0.02631366f, -0.19014421f, -0.20902872f, 0.23387970f, -0.71294773f, -0.34124827f, 
    0.05553493f, 0.11052439f, 0.36264300f, 0.06013295f, 0.05638836f, 0.08539735f, 0.12097128f, -0.46543178f, 
    -0.20282795f, -0.07063932f, 0.08481328f, -0.08661022f, -0.21783340f, -0.15652068f, -0.03781426f, 0.05861281f, 
    -0.06536109f, -0.12129808f, -0.21056990f, -0.12148455f, 0.08091066f, 0.19127116f, 0.16817978f, -0.24779090f, 
    0.32647425f, 0.03239265f, -0.26989183f, -0.13118994f, -0.32473597f, -0.08574066f, 0.13528505f, -0.03966534f, 
    0.04503598f, 0.16481203f, -0.13614357f, -0.19181465f, 0.05895230f, 0.13818760f, 0.24677375f, 0.14602107f, 
    0.11476853f, -0.08965998f, -0.10353986f, -0.24780314f, -0.23244795f, -0.05699412f, 0.13420941f, 0.05514920f, 
    0.23577206f, 0.15656526f, 0.02995036f, -0.46101770f, -0.27032682f, 0.16207404f, -0.09462181f, -0.17936565f, 
    -0.15068388f, 0.15074573f, 0.10787614f, 0.13237044f, 0.06552004f, -0.12172063f, 0.03845848f, -0.20712094f, 
    -0.30644628f, -0.10653985f, 0.01909944f, 0.01245929f, 0.04525223f, 0.20240438f, -0.46235374f, -0.81753033f, 
    -0.41609645f, -0.05285340f, 0.30230957f, 0.01055594f, -0.10391430f, -0.00095792f, -0.12720190f, -0.04366516f, 
    -0.05942198f, -0.09863107f, 0.24499619f, 0.00631892f, 0.36386135f, 0.05126325f, 0.17314762f, -0.00120606f, 
    -0.05965040f, 0.08423941f, -0.15462475f, -0.15349233f, -0.09922121f, -0.03409226f, -0.01427018f, 0.23783958f, 
    -0.46765700f, -0.54435128f, -0.28061181f, -0.03601527f, 0.05569872f, 0.04762509f, 0.16790897f, 0.14309987f, 
    -0.22990018f, -0.23668525f, -0.63268590f, 0.47483730f, -0.09569874f, -0.03244592f, -0.24384412f, -0.14416419f, 
    -0.23608355f, 0.01456802f, 0.63229334f, -0.15695012f, 0.64819378f, -0.14988703f, -0.20179756f, -0.16214554f, 
    -0.10380644f, -0.03934555f, 0.14277381f, 0.12980556f, 0.32865655f, 0.21163909f, -0.03560755f, -0.12558906f, 
    0.02496064f, 0.06820021f, 0.12552750f, 0.14463095f, 0.34196004f, 0.17781843f, 0.11604697f, -0.16963434f, 
    -0.12895687f, -0.13587920f, -0.02169948f, 0.06932025f, 0.11249365f, -0.03120692f, -0.82900935f, -0.09887887f, 
    0.13419233f, 0.21162985f, -0.03462439f, -0.02425338f, -0.06931648f, 0.10397156f, 0.24302572f, 0.18695964f, 
    0.17493679f, -0.03162819f, -0.06595761f, -0.05777704f, 0.03997805f, 0.17176247f, -0.02960815f, -0.34476373f, 
    -0.22736239f, -0.73960519f, -0.32494995f, 0.00400531f, 0.00133188f, 0.14772639f, -0.04591509f, 0.06239478f, 
    -0.05533509f, -0.04946971f, -0.04481626f, -0.06503884f, -0.05416191f, 0.00309999f, -0.03982960f, -0.06514714f, 
    0.03673232f, 0.04544785f, -0.01967788f, -0.02860587f, -0.02063499f, 0.01601961f, 0.03324370f, 0.04644775f, 
    -0.06238880f, 0.04594380f, -0.01259024f, 0.02550898f, 0.03647505f, 0.02631645f, 0.02963263f, -0.06089872f, 
    -0.00992398f, -0.06221140f, -0.02770177f, 0.00488660f, -0.02098341f, -0.01224534f, 0.03782190f, -0.04636846f, 
    0.01338567f, 0.03200756f, 0.01198470f, -0.03905918f, -0.06260690f, 0.00276059f, -0.04196722f, 0.03083264f, 
    -0.01929093f, -0.00118137f, -0.04940926f, 0.01782310f, -0.03658631f, -0.04503900f, -0.04264046f, 0.01635182f, 
    -0.05171558f, 0.05775991f, -0.03632151f, -0.00185183f, -0.05964341f, 0.04045928f, -0.01642154f, 0.00548359f, 
    0.00209935f, 0.05137941f, -0.01809738f, -0.02629044f, -0.05456612f, -0.04999035f, -0.03612118f, -0.03265470f, 
    -0.03939735f, -0.02867368f, -0.05079231f, -0.06388570f, -0.01662739f, 0.00467824f, -0.03501351f, 0.02905391f, 
    0.03330234f, -0.05689751f, -0.04171121f, -0.01380142f, 0.04851210f, -0.04320776f, 0.04745286f, 0.01055345f, 
    0.04527757f, -0.04330289f, 0.00739249f, -0.06514094f, 0.03324502f, -0.02534560f, -0.00223559f, -0.03907088f, 
    -0.04517826f, -0.03515735f, 0.01517920f, -0.03303165f, 0.02005367f, 0.02114687f, 0.03838344f, 0.04201145f, 
    -0.02278483f, -0.03825503f, 0.03446176f, 0.02792760f, -0.05440832f, 0.02403684f, -0.00889037f, 0.02136243f, 
    -0.05580989f, 0.02623931f, -0.06017468f, -0.00860301f, -0.01058013f, -0.02647306f, -0.04469059f, -0.01551643f, 
    0.03349771f, 0.00020343f, -0.04428591f, 0.00532311f, -0.00569839f, -0.03669138f, 0.02851300f, 0.00721642f, 
    -0.00343560f, -0.03613599f, -0.01248976f, 0.01897132f, 0.02694919f, 0.03631749f, -0.03001178f, 0.00463784f, 
    0.01574254f, -0.03478039f, -0.00113476f, -0.05363385f, -0.04551047f, 0.04416353f, -0.04714027f, 0.04047734f, 
    0.02150550f, -0.02036517f, -0.00512087f, 0.01762231f, 0.03670493f, -0.05829595f, 0.00347299f, -0.03608891f, 
    0.04152947f, -0.01843058f, 0.00139181f, 0.01576688f, 0.00802702f, -0.03965911f, -0.02735147f, 0.01869482f, 
    0.00602036f, 0.04921489f, 0.02514709f, 0.02301504f, 0.04524698f, 0.04713142f, 0.02945527f, -0.02262949f, 
    -0.04737331f, -0.04301450f, 0.04860039f, -0.05843102f, 0.03233694f, 0.01347178f, 0.01323849f, 0.04902005f, 
    -0.00682778f, -0.02546307f, 0.04451826f, 0.01538107f, -0.00260152f, -0.06349070f, 0.03609505f, 0.04002305f, 
    0.04698002f, 0.01972807f, 0.02461914f, 0.02333703f, 0.04082538f, -0.03141365f, -0.00640265f, -0.04102663f, 
    0.01908514f, 0.03031875f, -0.00921312f, -0.01498374f, -0.01017563f, 0.04652157f, -0.04775961f, -0.03967714f, 
    -0.04305191f, -0.03423367f, -0.03570954f, -0.06514387f, 0.04183406f, 0.03992868f, 0.01850924f, 0.01826427f, 
    -0.05729453f, -0.02620251f, -0.00357889f, -0.00294526f, -0.04505453f, 0.00031182f, -0.02406078f, 0.02000864f, 
    0.03320444f, -0.04392761f, 0.03253694f, -0.01530916f, 0.03994544f, -0.04538387f, 0.04853480f, 0.02690365f, 
    -0.06583249f, -0.03487170f, 0.00425486f, -0.02250177f, 0.00631658f, 0.00631194f, -0.00056383f, -0.01893221f, 
    -0.03912477f, -0.01406099f, -0.03279377f, -0.03243563f, 0.03708589f, -0.00900918f, -0.02974556f, -0.02627614f, 
    -0.06409995f, -0.03414957f, 0.04193021f, 0.05830879f, -0.05500823f, -0.03186823f, 0.05037450f, 0.04662800f, 
    0.00980707f, -0.04999185f, 0.01620953f, -0.05014605f, -0.02680093f, -0.06573579f, -0.03794393f, -0.05569201f, 
    -0.04642545f, -0.05471268f, 0.00847967f, -0.05802919f, 0.03136717f, -0.00561263f, 0.05223397f, -0.06486668f, 
    -0.02682014f, 0.02760473f, 0.01705217f, -0.06231366f, -0.05181170f, -0.06041500f, -0.06158484f, -0.01649891f, 
    -0.00821122f, -0.03248608f, -0.00500192f, -0.00943455f, -0.04453420f, -0.06116383f, -0.00574412f, -0.04124951f, 
    -0.00900579f, 0.02573102f, -0.02764196f, -0.04412050f, -0.05699770f, -0.01939956f, -0.01472337f, -0.04241661f, 
    -0.05535366f, -0.04337262f, -0.00921948f, -0.00038367f, 0.03382883f, -0.04522466f, -0.02563803f, -0.01283996f, 
    -0.04818625f, 0.02110533f, -0.01471002f, -0.03420326f, -0.03936049f, 0.01382612f, -0.02370442f, -0.06498115f, 
    0.03568195f, -0.00348762f, -0.05377050f, 0.03387307f, 0.01067308f, 0.02554443f, 0.03298166f, -0.00896691f, 
    -0.02749129f, -0.05580295f, -0.05323002f, -0.03962053f, 0.00422243f, -0.00653597f, 0.03775001f, 0.04830867f, 
    -0.05873566f, -0.00487723f, 0.04378055f, -0.00632361f, 0.00683203f, -0.04261968f, -0.04458136f, -0.00033705f, 
    -0.04133960f, -0.00278305f, 0.01248671f, 0.00885902f, -0.02109589f, -0.03654357f, -0.03510825f, 0.01880227f, 
    0.01666150f, -0.04990194f, -0.06359900f, 0.02750961f, 0.01665274f, 0.03104168f, -0.02292447f, 0.00526906f, 
    0.03998616f, -0.01056848f, 0.04871052f, 0.01376220f, -0.00494794f, -0.00904686f, 0.04632595f, 0.02952855f, 
    -0.00726857f, -0.03559081f, -0.01532810f, 0.00473815f, -0.02548905f, -0.03018657f, 0.01700225f, -0.02455681f, 
    0.01183719f, 0.00972731f, -0.03532083f, -0.05310725f, -0.06329133f, -0.03729409f, 0.03754470f, -0.03106867f, 
    0.04460703f, 0.00866067f, -0.04613109f, -0.02570448f, 0.04648510f, -0.02325166f, -0.02219746f, -0.01337088f, 
    0.04573420f, 0.02873973f, 0.02200682f, 0.01210932f, -0.01835835f, -0.05616067f, -0.04064794f, -0.03980662f, 
    -0.06070847f, -0.04846644f, 0.03586600f, -0.01804269f, -0.02360450f, -0.06021955f, 0.04303380f, -0.04477106f, 
    -0.01754469f, 0.05095845f, 0.01859241f, 0.01504881f, -0.02064445f, -0.04057878f, -0.03004781f, -0.05555941f, 
    0.01146490f, 0.04386836f, -0.05806836f, 0.03949754f, 0.02060964f, -0.06129301f, -0.04233598f, 0.01978622f, 
    0.04539833f, 0.01847035f, -0.01609883f, -0.05120878f, 0.00725433f, -0.04699234f, 0.04804143f, 0.04496332f, 
    -0.00613616f, 0.04470061f, 0.01954067f, -0.00193020f, -0.02770336f, -0.05024860f, -0.01847192f, 0.01768583f, 
    -0.02871302f, 0.04164406f, 0.02151553f, 0.03976746f, -0.02183187f, -0.06225665f, -0.06242744f, -0.00127850f, 
    -0.03034300f, 0.03404227f, -0.04737869f, 0.00555660f, -0.01837593f, 0.04145208f, 0.01020465f, -0.04301328f, 
    -0.05057821f, 0.03012920f, 0.01344731f, 0.04701715f, 0.02353969f, -0.03056325f, 0.02446593f, -0.05495659f, 
    -0.01214887f, 0.04796594f, 0.03224553f, -0.03463408f, -0.02281386f, 0.01644868f, 0.02442608f, -0.01065238f, 
    0.01512381f, 0.03872311f, -0.02441799f, 0.01666145f, -0.00335622f, -0.04264903f, -0.00519866f, 0.00392718f, 
    -0.01084980f, -0.06352865f, -0.06005563f, 0.02283317f, -0.00480630f, 0.02518021f, -0.01486565f, -0.05046604f, 
    0.04853877f, -0.06386552f, -0.04423340f, -0.00900005f, -0.03683203f, -0.04512670f, 0.00512827f, -0.06402516f, 
    -0.04436342f, -0.03808157f, 0.03736109f, 0.04584300f, -0.05600809f, -0.04404148f, -0.04791398f, 0.01752154f, 
    -0.01710801f, -0.01463897f, -0.04702560f, 0.00979874f, -0.01212748f, -0.05731379f, -0.03475627f, -0.02701034f, 
    0.02534655f, -0.01498752f, 0.02183343f, -0.06104101f, 0.03674662f, 0.03268043f, -0.06463745f, 0.02692423f, 
    0.03181368f, 0.03583469f, 0.03695640f, 0.03676505f, -0.00602567f, 0.00741379f, -0.04129196f, -0.01418005f, 
    0.01285291f, -0.03554097f, 0.00719226f, 0.01813027f, -0.05204866f, 0.04813933f, -0.06723849f, 0.04771097f, 
    -0.05943466f, -0.05278329f, -0.01224240f, -0.03081812f, -0.03976277f, 0.02189709f, -0.06331344f, 0.03231575f, 
    -0.04965363f, -0.03580323f, -0.00962188f, -0.04852971f, 0.00628056f, -0.05080540f, -0.04726445f, 0.00755688f, 
    0.00340641f, -0.06249231f, 0.00080110f, -0.01967711f, 0.04485913f, -0.02485544f, 0.02936204f, -0.01956446f, 
    0.02637150f, 0.03330896f, 0.03664573f, -0.04750488f, -0.01231738f, 0.00641391f, -0.02352005f, 0.00782343f, 
    -0.01056826f, -0.05314847f, 0.04433156f, -0.01664680f, -0.03380787f, -0.05100071f, -0.01921584f, -0.05512834f, 
    0.00934169f, 0.02607897f, -0.04456181f, -0.01665881f, -0.05511058f, 0.00229286f, -0.00687882f, 0.04646319f, 
    -0.03909661f, 0.01886513f, -0.00843471f, -0.06323467f, 0.00737037f, -0.02500675f, 0.03090920f, 0.00305699f, 
    -0.01140214f, -0.06153646f, -0.03461827f, -0.04258001f, -0.02161649f, 0.04661769f, -0.00440863f, -0.02369049f, 
    -0.31111038f, 0.12683420f, 0.14123544f, 0.06772303f, 0.03614779f, 0.18612336f, -0.00950647f, 0.21675289f, 
    -0.04923271f, -0.48682380f, -0.33067337f, 0.12998769f, -0.00886545f, 0.06316178f, -0.12461939f, 0.16250642f, 
    0.00821460f, 0.06534757f, -0.11311451f, 0.49955732f, 0.08312871f, -0.08767577f, 0.16260527f, 0.14665355f, 
    0.13198408f, 0.26357672f, 0.02490907f, -0.20632567f, -0.09729280f, 0.02097702f, -0.09810912f, -0.02023628f, 
    -0.14021531f, -0.05174473f, -0.00227453f, -0.21171366f, -0.10425703f, 0.11846067f, -0.02914190f, 0.16724455f, 
    -0.02150776f, -0.18969490f, 0.16894141f, -0.04735400f, 0.06045058f, 0.23887645f, -0.68703884f, -0.05339340f, 
    0.12509018f, 0.13968234f, 0.08351091f, 0.14974716f, -0.06181183f, 0.29249987f, 0.20383804f, 0.13221045f, 
    -0.09340880f, 0.02441003f, 0.00758022f, -0.02846433f, 0.18092868f, 0.08006869f, 0.10939058f, -0.15343162f, 
    0.05249027f, -0.03313509f, -0.26325798f, -0.04842214f, -0.19666380f, 0.07370750f, -0.12503250f, -0.18539388f, 
    0.20798281f, 0.25841835f, -0.34056708f, 0.09048859f, 0.18441370f, -0.14641145f, -0.01160163f, -0.00371057f, 
    -0.08023436f, -0.14899108f, 0.21422401f, 0.25887546f, 0.19227919f, -0.07911661f, 0.12969606f, 0.15827392f, 
    0.22865497f, -0.28797939f, 0.33932844f, 0.11937176f, 0.38468200f, -0.08671169f, -0.07970747f, 0.02738779f, 
    0.14678577f, 0.13488925f, 0.40114990f, -0.14481452f, 0.21957301f, -0.20393987f, -0.01197311f, -0.02391489f, 
    0.03661058f, 0.10600850f, -0.11757568f, 0.09187017f, 0.10503569f, -0.02152617f, 0.03837927f, 0.16880728f, 
    0.02196964f, -0.17657149f, 0.11034853f, 0.25863555f, -0.01108207f, 0.14512633f, -0.22264265f, 0.11634509f, 
    -0.15795065f, 0.05958837f, 0.09373567f, -0.05483304f, -0.07887987f, 0.15203592f, 0.24612388f, 0.02067918f, 
    -0.25492549f, -0.11748059f, 0.27448606f, 0.18454666f, 0.03724605f, 0.05448707f, 0.08102807f, -0.23056377f, 
    0.05407861f, -0.03164716f, -0.24584852f, -0.02822317f, -0.03144401f, 0.17351608f, 0.25298706f, -0.06027909f, 
    -0.10081630f, 0.07807802f, -0.13660526f, -0.02797857f, -0.06039280f, -0.00733602f, 0.06285230f, -0.09867338f, 
    0.01449013f, 0.23062195f, -0.01895621f, -0.08034593f, -0.12069992f, -0.14765757f, 0.03747469f, 0.27000046f, 
    -0.05676188f, 0.14236574f, 0.00644084f, 0.08944427f, -0.28177926f, 0.01584325f, 0.06723690f, -0.08197791f, 
    0.10058853f, 0.06540989f, 0.10889566f, -0.40334180f, -0.14327630f, 0.17402934f, -0.05752311f, -0.03577931f, 
    -0.04096824f, 0.15112108f, 0.08874131f, 0.19040780f, -0.33991089f, 0.01364643f, 0.15061249f, 0.02071628f, 
    0.02804983f, -0.07759564f, 0.14032201f, 0.10492969f, 0.19862226f, -0.22139706f, -0.37585050f, -0.76522428f, 
    -0.08602464f, -0.09267323f, -0.03873564f, -0.14011858f, -0.15827949f, -0.10650495f, -0.28347909f, 0.19347264f, 
    -0.03101469f, 0.09692330f, 0.09622303f, -0.12779064f, 0.09336873f, 0.06138063f, 0.15697896f, 0.06565341f, 
    0.17606840f, 0.07223321f, -0.06062973f, -0.26839876f, -0.25228944f, 0.06164825f, -0.00409009f, 0.11775001f, 
    0.04701005f, 0.24529704f, -0.09252041f, -0.04016767f, 0.15866224f, 0.16224267f, 0.16776450f, 0.13773188f, 
    0.06363302f, -0.06493837f, -0.10098777f, 0.06587309f, -0.09841299f, -0.00505145f, 0.21912804f, 0.21259637f, 
    0.11808815f, -0.01701232f, -0.04372853f, -0.11961944f, -0.20145172f, -0.07727893f, 0.12269537f, 0.01826655f, 
    -0.21906026f, 0.08353198f, 0.22138110f, -0.39237007f, 0.02516638f, -0.08785331f, 0.00220682f, -0.06898499f, 
    -0.09790925f, -0.07497792f, 0.19791146f, -0.16812076f, -0.24540386f, 0.14719972f, -0.04361618f, -0.03075558f, 
    -0.20150180f, -0.18581818f, -0.32637766f, 0.08612695f, -0.32251582f, 0.14046341f, -0.31667757f, -0.35557058f, 
    0.00381415f, 0.30894819f, 0.21055239f, 0.17974181f, -0.02613823f, 0.17582357f, -0.12947705f, 0.15362103f, 
    0.19496430f, -0.13024397f, -0.08354155f, 0.10825130f, -0.08823114f, -0.29463649f, -0.05376437f, 0.00370663f, 
    0.06368119f, -0.56104434f, -0.02257735f, 0.01662986f, -0.13701358f, -0.02698529f, -0.03920411f, 0.15585834f, 
    0.01067472f, -0.00540659f, 0.03040511f, -0.02487146f, 0.02982459f, -0.01838741f, 0.01147009f, 0.00223534f, 
    -0.02562371f, -0.05064430f, 0.00767243f, -0.02313896f, -0.01789200f, 0.03047031f, -0.03383820f, 0.02115574f, 
    0.03261404f, -0.04100077f, 0.05003875f, -0.05487853f, -0.02348361f, 0.02298603f, -0.04422750f, -0.05594590f, 
    -0.03639011f, 0.01167347f, -0.01665480f, -0.05676537f, -0.03603183f, -0.00271360f, 0.05031707f, -0.06702180f, 
    -0.01672555f, -0.02350966f, -0.02092179f, -0.02383723f, -0.05886330f, -0.02591916f, 0.00485914f, -0.04384149f, 
    -0.01247310f, 0.01339076f, -0.00550464f, -0.05769422f, 0.03600187f, 0.05724597f, -0.05451632f, -0.02266818f, 
    0.03969051f, -0.00789595f, 0.02517032f, 0.01303470f, -0.04361700f, -0.03133033f, 0.00886621f, -0.02163414f, 
    -0.03135802f, -0.01194057f, -0.01565442f, -0.05182570f, 0.04234761f, -0.06517535f, 0.04448793f, 0.04898343f, 
    -0.00719043f, 0.01345897f, -0.04225647f, -0.01599685f, 0.02430704f, 0.01976153f, 0.01286988f, 0.02888064f, 
    -0.04856529f, 0.04788556f, -0.02544914f, 0.01579112f, 0.02772324f, -0.05101118f, 0.01110998f, -0.05774062f, 
    -0.04040725f, 0.01109228f, -0.01872417f, 0.01443358f, -0.05512273f, 0.00360182f, -0.04072047f, -0.02076074f, 
    0.01721331f, -0.02125819f, 0.02221010f, -0.00422689f, -0.04861413f, 0.00053674f, 0.02114914f, 0.03126101f, 
    0.04963733f, -0.06587843f, 0.02826298f, 0.00310623f, -0.00809113f, -0.05010279f, 0.00353512f, -0.02011056f, 
    -0.00963792f, -0.05177153f, -0.04302403f, -0.02154466f, 0.03605723f, -0.00096842f, 0.00970973f, -0.03004441f, 
    0.02125047f, 0.02891524f, -0.04867459f, 0.04381594f, 0.00992198f, -0.00599925f, -0.00212670f, 0.00480966f, 
    -0.05175319f, -0.00643803f, -0.03546387f, 0.02853790f, -0.01154678f, 0.02491695f, -0.01936225f, -0.02107609f, 
    0.01585966f, 0.04773648f, -0.05756209f, -0.03020278f, -0.05937149f, 0.03648423f, -0.03007181f, -0.01315008f, 
    0.00983355f, 0.03250065f, 0.01098794f, 0.03658936f, 0.00319676f, -0.02919829f, -0.02925610f, -0.03923537f, 
    0.05394863f, -0.05728916f, -0.01358032f, -0.02130533f, 0.04267499f, 0.03175087f, -0.05456880f, -0.02614535f, 
    0.01060422f, -0.04725999f, 0.00184648f, 0.03879138f, -0.00343077f, 0.00214951f, -0.05924415f, 0.03133987f, 
    -0.01632121f, -0.02449056f, 0.01138122f, -0.01240994f, -0.04207406f, 0.03737346f, 0.04672070f, 0.00139095f, 
    -0.01056344f, -0.01984222f, -0.03113523f, 0.02216672f, 0.00575749f, -0.02831234f, 0.01067720f, -0.05834619f, 
    -0.05890857f, 0.04985860f, 0.01698335f, -0.03655838f, -0.04538834f, 0.06448776f, -0.05773384f, -0.00490335f, 
    0.04246666f, -0.02681661f, -0.01989510f, -0.03237510f, -0.05725687f, -0.04615678f, -0.01038684f, 0.04967007f, 
    -0.00001604f, -0.03856037f, 0.05143565f, 0.03777585f, -0.02138800f, 0.02188865f, 0.04477736f, -0.05279446f, 
    0.00316946f, 0.01604116f, 0.01010164f, -0.01621737f, 0.00270086f, -0.05187774f, -0.04824743f, -0.06180472f, 
    -0.06622985f, 0.01061307f, 0.00178676f, -0.03426021f, 0.02365401f, -0.00012899f, -0.01578332f, -0.06368974f, 
    -0.06443731f, -0.00544616f, -0.01826902f, -0.03890431f, -0.03674552f, -0.01461684f, -0.05378231f, -0.01600323f, 
    0.00980283f, -0.00004801f, -0.00542872f, -0.03249487f, 0.00528685f, -0.04484408f, 0.02554174f, -0.01674407f, 
    -0.00278157f, 0.06071166f, 0.00210824f, 0.05351013f, 0.00494199f, 0.00627939f, 0.04553298f, 0.02551547f, 
    0.02568152f, -0.05801870f, -0.02660635f, 0.02032946f, -0.02016479f, -0.00286753f, -0.03565944f, -0.04653446f, 
    0.01709993f, 0.02932312f, 0.00717503f, -0.01035691f, 0.03630775f, 0.01364461f, 0.00748154f, 0.04508029f, 
    -0.03578157f, -0.05862465f, 0.01012687f, 0.03114334f, 0.03991444f, -0.05477482f, -0.03391813f, -0.06293665f, 
    -0.04146006f, 0.04303076f, 0.02501894f, -0.00811772f, -0.00378982f, -0.00338258f, -0.00959989f, -0.00743543f, 
    0.01836492f, 0.01326783f, -0.03308390f, -0.02839334f, 0.00155874f, 0.04722185f, -0.02651917f, 0.05207075f, 
    -0.00059981f, -0.02816882f, 0.02911265f, -0.05734121f, -0.01149450f, 0.03162555f, 0.03034971f, -0.04253354f, 
    -0.06075160f, -0.41041571f, -0.23888902f, 0.18261991f, 0.09640398f, 0.04735621f, 0.01111124f, 0.29966694f, 
    -0.28469861f, 1.05245745f, -0.16670865f, -0.47289717f, 0.13301399f, 0.26173422f, 0.27454889f, 0.12627918f, 
    -0.00033031f, -0.17873333f, 0.11949206f, -0.16299419f, -0.16852012f, -0.10752021f, 0.05754279f, -0.00396443f, 
    0.17970447f, 0.22821783f, -0.10411736f, 0.50535083f, -0.60055423f, -0.33744127f, 0.05699857f, 0.17557353f, 
    0.20365795f, 0.06331369f, 0.12961568f, -0.40058893f, 0.11925382f, -0.05377928f, 0.07661410f, 0.13811676f, 
    0.12522043f, 0.02695815f, 0.08507620f, 0.14720927f, 0.01777694f, -0.49008083f, 0.50493073f, -1.73765767f, 
    0.12829594f, -0.11174211f, 0.03351831f, -0.04557802f, -0.06550077f, 0.03620525f, 0.06597981f, 0.31190723f, 
    0.21545592f, -0.38769445f, -0.11688927f, -0.08325630f, 0.08076893f, 0.11294691f, 0.26950762f, 0.31797153f, 
    -0.19046268f, 0.00652785f, 0.04752522f, -0.14209890f, 0.04390883f, 0.06135074f, 0.03994557f, -0.01853796f, 
    -0.49871349f, 0.38410535f, 0.45879167f, -0.31333768f, -0.00016369f, 0.01591413f, 0.02983352f, 0.08808959f, 
    -0.09801658f, 0.25605616f, 0.01253810f, 0.14104944f, 0.11005767f, 0.00273388f, 0.02028809f, 0.34970316f, 
    0.20561089f, 0.19856744f, 0.02617776f, -0.23770532f, 0.45681441f, 0.33623642f, -0.22346266f, -0.27575985f, 
    -0.01658194f, -0.11065724f, -0.30794296f, 0.04419450f, -0.92157114f, -0.37917700f, 0.00526310f, 0.13065150f, 
    0.05953659f, -0.21572159f, 0.10225819f, 0.05397612f, 0.02163602f, 0.11742715f, 0.09005841f, 0.01769366f, 
    0.24229492f, 0.09066314f, -0.14726685f, 0.14191093f, 0.00216328f, -0.72612906f, -0.78120971f, -0.30919641f, 
    -0.21668155f, -0.03420517f, -0.04571597f, 0.00613799f, -0.17385243f, 0.08613028f, -0.41071206f, -0.08781109f, 
    0.31075984f, -0.55868453f, -0.03685830f, -0.01362747f, 0.11692283f, 0.04198483f, 0.07524988f, 0.22788900f, 
    -0.06898133f, -0.18614566f, -0.31288463f, -0.23453158f, -0.22501473f, 0.04841196f, -0.24875468f, 0.01682451f, 
    -1.10231853f, -0.82263929f, -1.29053843f, -0.06373075f, -0.11607130f, -0.09119345f, -0.02371386f, 0.00675690f, 
    0.03529103f, 0.03921941f, 0.19785836f, 0.09594259f, 0.02683685f, 0.05120889f, 0.29640853f, 0.02968070f, 
    0.02019217f, -0.07725994f, -0.10051573f, 0.13252607f, 0.17458887f, -0.29104307f, -0.20193267f, -0.30417183f, 
    0.11942609f, 0.01764372f, -0.08414666f, -0.30819383f, -0.07420357f, 0.07104550f, 0.13601477f, 0.13142669f, 
    -0.07858197f, 0.01082633f, 0.01696148f, 0.05421462f, -0.35665277f, -0.80483389f, -0.77385396f, -0.07764770f, 
    -0.03475202f, 0.04024679f, -0.06081127f, 0.01895711f, 0.23883866f, 0.18527973f, -0.67993534f, -0.16969609f, 
    -0.08453343f, -0.04791691f, -0.04405326f, -0.03202785f, 0.05550971f, -0.17662758f, -0.00239372f, -0.06561700f, 
    0.14538698f, -0.06724270f, 0.04848270f, -0.10988189f, 0.30946124f, -0.02711129f, 0.04397761f, 0.02336302f, 
    0.15228137f, 0.14839870f, 0.22111496f, 0.18364686f, -0.05136177f, 0.09373380f, 0.18830793f, 0.34709999f, 
    -0.26548210f, 0.09975533f, 0.06296618f, -0.09042035f, 0.32003999f, 0.06739604f, 0.25584295f, 0.13852507f, 
    -0.11802272f, 0.12738672f, -0.24328600f, -0.16669875f, -0.09514759f, 0.04942505f, -0.30697334f, 0.04885394f, 
    -0.01001343f, -0.10476178f, -0.18440478f, -0.18299150f, -0.32605454f, -0.04993974f, 0.09057508f, 0.06311997f, 
    0.02169220f, 0.57854003f, 0.35328183f, -0.06702556f, -0.35450083f, 0.03621726f, 0.11317890f, 0.25495675f, 
    0.01743747f, 0.29689562f, -0.06726740f, 0.55782801f, 0.11391304f, -0.21894270f, 0.07815893f, 0.09300026f, 
    0.09810925f, -0.03602131f, -0.04713921f, -0.19883217f, 0.17231005f, 0.15587425f, 0.26938874f, -0.06372324f, 
    -0.60373539f, 0.19954307f, -0.29382199f, 0.23966441f, -0.23068064f, 0.03273475f, 0.24201362f, -0.03249058f, 
    0.25812247f, -0.08886537f, 0.22215718f, 0.02189518f, 0.06990077f, 0.20333523f, -0.18014212f, -0.23455355f, 
    0.27352497f, -1.15290427f, 0.00887359f, -0.06068226f, -0.17621185f, 0.02111941f, -0.07408825f, -0.04302923f, 
    -0.14631978f, 0.70861715f, 0.06385321f, -0.04033970f, 0.00726123f, -0.15093955f, -0.11199234f, -0.05751717f, 
    0.13246906f, -0.16987145f, 0.04870642f, 0.29224285f, -0.20194206f, -0.03068388f, -0.07802156f, 0.03087703f, 
    0.03330490f, 0.13803235f, -0.21666414f, 0.35282803f, 0.18230240f, -0.15878427f, 0.18280783f, 0.34163079f, 
    0.06293612f, -0.11864406f, 0.06563534f, -0.11665764f, 0.31125271f, -0.27790722f, -0.08431342f, 0.20208147f, 
    0.16250701f, 0.02930283f, 0.03543954f, -0.04877922f, 0.11669417f, 0.23370740f, -0.22280470f, -0.06324798f, 
    0.06327680f, 0.04969548f, 0.08243113f, -0.05046256f, 0.01936695f, 0.02951693f, -0.41070181f, 0.07737085f, 
    -0.39433464f, -0.07728893f, 0.12659542f, 0.12874082f, -0.12496553f, 0.13287283f, 0.06952413f, -0.05314047f, 
    -0.27530518f, 0.05520560f, 0.27793702f, 0.00704980f, -0.14299478f, -0.17491272f, 0.11997247f, -0.00825573f, 
    0.07400635f, -0.08846298f, -0.04252740f, -0.03023012f, -0.01782366f, -0.14882125f, 0.17513686f, -0.01777421f, 
    0.27817076f, 0.14850079f, 0.05864635f, -0.16258048f, -0.14990857f, -0.19604707f, 0.18163686f, -0.06528817f, 
    -0.01844360f, -0.47507966f, 0.01188922f, 0.17488685f, 0.08928310f, 0.01188066f, 0.02238816f, -0.19973746f, 
    -0.04075576f, -0.00425830f, -0.49850219f, 0.19297035f, -0.02706417f, -0.01698983f, 0.21613812f, -0.34223625f, 
    -0.14105140f, 0.17872348f, 0.02726624f, 0.25450090f, 0.08127943f, 0.36745924f, 0.02950930f, 0.11545814f, 
    -0.17479186f, 0.05439945f, -0.04861628f, 0.09063959f, -0.35977826f, 0.19819972f, -0.04327517f, 0.01502595f, 
    0.28808397f, -0.17556658f, -0.21675330f, -0.17021374f, -0.01735900f, 0.42630297f, 0.14566354f, -0.25941405f, 
    -0.13236402f, -0.09127787f, -0.04973663f, 0.01753231f, 0.11819062f, 0.02723169f, -0.09089885f, 0.40537781f, 
    -0.17534298f, -0.08843345f, -0.03037888f, -0.03702577f, 0.10774660f, -0.19977021f, 0.18715623f, -0.41462860f, 
    -0.08025049f, -0.05320440f, 0.11461905f, 0.28372395f, 0.27691886f, -0.27571365f, 0.03640654f, -0.09358356f, 
    0.41178682f, -0.28054297f, 0.31893513f, -0.09302875f, 0.05857191f, -0.37365264f, 0.03894120f, 0.03765510f, 
    -0.04815059f, -0.09643022f, 0.12992884f, -0.30693415f, 0.01081508f, 0.23548798f, 0.11174870f, -0.14140765f, 
    -0.06284429f, 0.00691171f, -0.08716296f, 0.19844966f, 0.16609536f, -0.00830893f, 0.14237495f, -0.04759528f, 
    0.19457759f, -0.13124979f, 0.02539532f, -0.14951366f, -0.36236730f, 0.05087897f, -0.05102563f, 0.02826085f, 
    -0.01262748f, 0.04287587f, -0.07027844f, -0.02099772f, -0.31013417f, -0.15917477f, 0.27489814f, -0.21041800f, 
    -0.10221005f, -0.26975402f, 0.01619428f, 0.03286284f, 0.02608978f, 0.45200756f, -0.14643344f, -0.20821741f, 
    -0.03048234f, 0.26483670f, 0.07325412f, -0.00662755f, 0.09298113f, 0.11257241f, -0.01446699f, 0.03231986f, 
    -0.03681916f, 0.01409928f, 0.01851850f, 0.01002284f, 0.10386947f, 0.02666437f, 0.07647663f, -0.41121891f, 
    -0.11386079f, -0.08344703f, 0.04873741f, 0.02246102f, -0.12182377f, 0.10619086f, -0.04812593f, 0.10136296f, 
    -0.33773008f, -0.13208120f, 0.01965257f, 0.06878421f, 0.14206667f, 0.26497132f, -0.05294116f, 0.02749134f, 
    -0.16929269f, -0.16649583f, 0.32854828f, -0.22879322f, 0.10720980f, -0.29416770f, 0.07252565f, 0.07285292f, 
    0.10245419f, 0.13066435f, -0.33416134f, 0.44752628f, -0.22523241f, -0.01213326f, -0.26552781f, 0.01499681f, 
    -0.10530117f, 0.04831010f, 0.07768933f, -0.06761485f, 0.15116273f, 0.32837906f, -0.11124319f, -0.07948723f, 
    -0.28588298f, 0.06809857f, 0.18852352f, -0.06124799f, -0.25125170f, 0.15684195f, -0.34124622f, -0.01150873f, 
    -0.11527947f, -0.09794077f, 0.07037754f, 0.17693140f, 0.12003930f, 0.22539985f, -0.03747893f, -0.15623683f, 
    0.23037289f, -0.22435954f, 0.32092157f, 0.19390257f, -0.19050999f, -0.09962108f, -0.11419589f, 0.09527010f, 
    0.08422852f, -0.18684089f, -0.11430662f, 0.15825118f, 0.14920762f, 0.23093574f, -0.08815211f, 0.16899197f, 
    -0.82717156f, -0.02329293f, -0.10988285f, 0.12706919f, 0.08165287f, 0.16961047f, -0.01630604f, 0.03991377f, 
    0.02740002f, 0.01983887f, 0.01073877f, -0.06072030f, -0.00916854f, 0.03489292f, -0.04140452f, -0.05242877f, 
    -0.05653774f, -0.05965651f, -0.02689968f, -0.03087989f, -0.04558473f, 0.04271522f, -0.00845124f, -0.01896078f, 
    -0.04563534f, -0.04124469f, 0.05567190f, -0.03975978f, -0.04810691f, -0.03763678f, 0.00242483f, 0.01956731f, 
    -0.04838318f, 0.01928425f, 0.01373781f, -0.02705625f, -0.06619463f, -0.06381387f, -0.01326944f, -0.03529715f, 
    0.04113317f, 0.03345061f, 0.01246811f, -0.06262109f, -0.03652680f, 0.02929227f, -0.00303803f, -0.03144301f, 
    -0.02505475f, -0.05301470f, -0.05129445f, 0.02836108f, 0.04594019f, 0.00503341f, 0.01723182f, -0.00626703f, 
    -0.02756003f, 0.03039301f, -0.06830252f, -0.03784114f, -0.05222675f, -0.00549003f, -0.03969204f, -0.02568311f, 
    -0.01781118f, -0.02887542f, 0.01820921f, 0.03581084f, 0.02560478f, -0.04009798f, -0.04127192f, -0.04468850f, 
    -0.03082901f, -0.01562843f, -0.05813975f, -0.02499345f, -0.04277178f, -0.04340178f, 0.00919986f, -0.06706814f, 
    -0.00637399f, 0.00558281f, -0.02871607f, 0.05851079f, -0.03553322f, -0.05282202f, 0.01638991f, -0.01854944f, 
    -0.06085956f, -0.01036792f, -0.01079851f, -0.06249497f, -0.02239869f, -0.02306850f, 0.03764141f, 0.04228394f, 
    0.00615911f, -0.04501664f, -0.04762823f, -0.00929037f, -0.01015245f, -0.01801882f, -0.04636024f, -0.01013920f, 
    -0.03086578f, 0.00952581f, 0.04132755f, -0.05195560f, -0.01676913f, -0.06055558f, -0.03035579f, -0.05529587f, 
    0.00474110f, 0.00548001f, 0.01861726f, -0.02487236f, -0.00109245f, 0.04304117f, 0.04216138f, 0.02175448f, 
    -0.02531635f, 0.00316146f, 0.04710947f, -0.01927298f, -0.03189677f, 0.02878044f, -0.03163889f, -0.02544143f, 
    0.00172232f, -0.00040573f, -0.03649405f, 0.03433324f, -0.01396247f, -0.04234513f, 0.02679361f, 0.00185605f, 
    -0.05338849f, -0.03804282f, -0.00872688f, -0.02440586f, 0.00244375f, 0.00117770f, 0.02776448f, -0.06688086f, 
    0.00213286f, 0.01978252f, 0.01754109f, -0.01746153f, -0.04834541f, 0.02068659f, 0.03251195f, -0.05643994f, 
    0.05174687f, -0.03948995f, -0.03181289f, -0.01332792f, -0.00094018f, 0.02234361f, -0.05224860f, 0.04680032f, 
    -0.05866802f, 0.01022820f, -0.03046951f, -0.04272195f, -0.02832623f, -0.03176372f, 0.00580338f, -0.04374301f, 
    -0.01770714f, -0.01958233f, -0.04364772f, -0.00506984f, 0.02222125f, 0.04289760f, -0.06699160f, -0.01482242f, 
    0.03366058f, -0.02855818f, -0.05049323f, 0.01774380f, -0.05070012f, 0.00612192f, -0.04905586f, -0.02689167f, 
    -0.03379262f, -0.01027322f, -0.02846121f, -0.02184261f, -0.01936255f, -0.00417876f, 0.01958463f, -0.00986638f, 
    0.00998842f, 0.04715408f, -0.05403756f, -0.00368869f, -0.02216206f, -0.03004468f, 0.05685558f, 0.03240050f, 
    0.01626479f, -0.05724771f, -0.04550730f, -0.00055552f, -0.02114121f, 0.02331084f, -0.01313083f, 0.00175717f, 
    -0.01148313f, -0.05842865f, 0.02894709f, -0.06322064f, -0.01475846f, 0.00671858f, -0.05868981f, -0.03131664f, 
    -0.06573849f, 0.03766663f, -0.00338484f, -0.06842916f, -0.00902430f, -0.06056963f, -0.00728297f, 0.02308442f, 
    -0.02382597f, -0.01377384f, -0.00733214f, -0.04506485f, -0.00259678f, 0.00195394f, 0.03606834f, 0.03363573f, 
    -0.00629481f, -0.04787127f, -0.06867335f, -0.02583219f, 0.00157444f, 0.01509797f, -0.06136804f, -0.01695705f, 
    0.01090882f, 0.00379587f, 0.00094019f, 0.03445554f, 0.01493637f, 0.02041892f, -0.05054558f, -0.02901879f, 
    -0.06217315f, -0.03463865f, 0.01989813f, 0.00617161f, 0.02475549f, -0.06628878f, 0.02129516f, 0.03179013f, 
    0.03938471f, -0.00331131f, -0.04937820f, -0.06314681f, -0.03100004f, -0.04646926f, -0.05028101f, -0.01018525f, 
    0.04180175f, 0.03602814f, -0.01311443f, 0.01005454f, 0.02158172f, -0.04909753f, 0.03874528f, -0.05225369f, 
    -0.06806425f, 0.01361983f, 0.01030521f, 0.01898892f, -0.06656543f, -0.04039522f, 0.01063708f, -0.03172581f, 
    0.02141564f, 0.03382412f, -0.00453994f, 0.02651487f, -0.02486083f, -0.05386447f, 0.02673481f, 0.02215984f, 
    0.01346742f, -0.00495513f, -0.04983137f, -0.04843994f, -0.06660312f, -0.01361750f, 0.02390048f, -0.05246711f, 
    0.08238937f, -0.16616900f, -0.00526595f, 0.15014511f, -0.13740592f, 0.19037561f, 0.01927424f, -0.13682634f, 
    -0.06926929f, 0.01262258f, -0.60389882f, -0.33346304f, -0.24950351f, -0.33846992f, -0.20106913f, -0.02664888f, 
    0.17055546f, -0.11265132f, -0.21195652f, -1.26612198f, -0.13807367f, -0.23717675f, 0.32528439f, -0.31868368f, 
    -0.35793704f, 0.09462800f, -0.25856835f, 0.42066017f, -0.28523758f, -0.44039801f, -0.15588722f, -0.31542453f, 
    -0.15554763f, 0.11282588f, 0.07315731f, -0.10502452f, -0.03924361f, 0.00506975f, -0.01710974f, 0.10192546f, 
    0.15226237f, 0.10039095f, 0.09101345f, 0.03124475f, 0.03570608f, 0.01892423f, 0.00236978f, 0.07328134f, 
    -0.07050097f, 0.06237087f, -0.25410005f, -0.00248125f, -0.02748213f, 0.01442215f, -1.11836588f, -0.73362261f, 
    -0.14441456f, -0.06798357f, -0.06521891f, -0.15635835f, 0.05183306f, 0.17356423f, 0.20097153f, 0.01534691f, 
    -0.29533583f, -0.06656630f, -0.02497959f, 0.24529466f, 0.05584119f, 0.16950732f, 0.01805435f, 0.32812023f, 
    0.31817752f, -0.15072359f, 0.25755927f, 0.07546192f, -0.05521375f, 0.19095768f, 0.00627844f, 0.03906183f, 
    0.02132311f, -0.68560463f, -0.31508085f, 0.31813377f, -0.30152452f, -0.07616413f, 0.24956577f, -0.08967187f, 
    0.00623329f, -0.16212068f, -0.49182063f, 0.68462723f, -0.27598357f, 0.02198562f, 0.29398942f, 0.23584710f, 
    -0.32687131f, -0.08977888f, 0.06162080f, 0.47117814f, -0.08484557f, 0.32382703f, 0.09827820f, 0.00318124f, 
    0.13984217f, 0.17804600f, 0.07715602f, 0.15010481f, -0.32930487f, -0.03016537f, -0.38077000f, -0.29555908f, 
    -0.17285785f, 0.13394387f, 0.17796579f, 0.01326692f, -0.05354885f, 0.02320647f, 0.08376922f, 0.01580678f, 
    -0.18332945f, -0.03393147f, 0.18674716f, 0.07365601f, 0.05955988f, -0.04569373f, -0.46835124f, -0.55366606f, 
    0.42678782f, -0.14679486f, 0.08943953f, 0.11498012f, 0.16207859f, 0.24470697f, 0.07637087f, -0.01970399f, 
    -0.34528092f, -0.52573043f, 0.29317215f, -0.23261201f, 0.05761262f, -0.09460135f, 0.34343824f, 0.31399333f, 
    0.20196734f, 0.21409136f, 0.11159198f, -0.05861551f, 0.16608603f, 0.17315322f, 0.11417446f, -0.07906702f, 
    0.12521055f, -0.50767553f, 0.02573341f, -0.59445399f, 0.00341078f, 0.32298505f, 0.16321301f, 0.09436526f, 
    0.13176775f, 0.07845198f, -0.25786749f, -0.54134840f, -0.41436481f, -0.00129983f, 0.14675288f, 0.12737937f, 
    0.12449636f, 0.04981581f, 0.03416580f, 0.13352776f, 0.33914849f, 0.31298029f, -0.21865666f, -0.02484659f, 
    -0.17579968f, -0.13971488f, -0.01324744f, 0.19275855f, -0.23394467f, 0.19010825f, 0.01885145f, 0.17730515f, 
    0.09198017f, -0.41014341f, -0.09490754f, -0.05523906f, 0.09300315f, 0.65054339f, 0.12021688f, 0.70089066f, 
    -0.00857772f, 0.08789451f, 0.23551674f, 0.17919511f, 0.12675376f, 0.02216836f, -0.14192054f, -0.22377533f, 
    0.03812944f, -0.09227207f, 0.02687541f, -0.13032766f, -0.24153994f, 0.19196616f, -0.16416921f, 0.14357974f, 
    -0.19976895f, -0.38069576f, 0.00983058f, -0.08324531f, -0.07990531f, 0.20110025f, -0.12068186f, 0.01562312f, 
    -0.31374669f, 0.00026672f, -0.34271431f, -0.07755981f, -0.05233285f, 0.01336213f, -0.16050655f, 0.07620676f, 
    -0.02167688f, 0.90802419f, 0.20609686f, 0.19530804f, -0.40975040f, -0.00635756f, 0.19593951f, 0.10936569f, 
    -0.02916030f, -0.01370826f, -0.94581175f, 0.03567674f, -0.01400037f, 0.11568166f, -0.05455152f, -0.32156232f, 
    0.06472692f, -0.04330435f, -0.02432568f, -0.26822099f, -0.26345727f, -0.63067591f, -0.00264125f, -0.21285586f, 
    -0.15163054f, 0.00499215f, 0.01514892f, -0.12951899f, -0.03203449f, -0.44274256f, -0.49561915f, 0.34923807f, 
    0.15906008f, -0.13429634f, 0.11080002f, 0.05398539f, -0.05857161f, 0.86947435f, -0.09594002f, 0.22065593f, 
    -0.21580759f, 0.09460554f, 0.03039294f, 0.17001234f, 0.03650424f, -0.23265338f, 0.35101002f, -0.11816999f, 
    -0.18861847f, -0.04461055f, 0.16585243f, -0.01568507f, 0.07137011f, 0.14440858f, -0.03507026f, 0.21601611f, 
    -0.05719952f, 0.29925010f, 0.01261479f, 0.07160086f, 0.09507327f, 0.09018676f, 0.00107252f, 0.00351597f, 
    0.05320884f, -0.00941302f, 0.32360038f, 0.06776638f, 0.22398098f, 0.08235111f, 0.15593213f, 0.06727899f, 
    0.13987806f, -0.45554465f, -0.32966411f, 0.02753435f, 0.00987472f, 0.04611270f, 0.11508192f, 0.10589261f, 
    0.14085776f, 0.01570716f, 0.43762878f, -0.09718476f, 0.31299111f, 0.29248363f, -0.12714098f, 0.17252281f, 
    -0.02745206f, -0.14739558f, 0.16255994f, -0.13591073f, 0.00180060f, -0.00464236f, -0.01319439f, 0.11392000f, 
    0.11184009f, -0.04325774f, 0.11410575f, -0.01470763f, -0.01272994f, 0.10216535f, 0.19053631f, -0.00929685f, 
    0.05542296f, -0.03090922f, -0.09227920f, 0.02432378f, 0.09861314f, -0.14372419f, -0.23742269f, -0.06942368f, 
    0.02829491f, 0.02518364f, -0.00425820f, 0.22430670f, 0.09017529f, 0.34059882f, 0.05371418f, 0.07090880f, 
    0.15782222f, 0.25542229f, -0.01312713f, -0.07896947f, -0.19780560f, -0.19223957f, -0.25742602f, -0.06569141f, 
    -0.09602168f, 0.14458090f, -0.03892424f, -0.04427234f, 0.12500986f, -0.33801556f, -0.10668056f, 0.08266032f, 
    0.05609468f, 0.00047503f, 0.01662279f, 0.01916667f, 0.07063672f, -0.10382963f, 0.00350203f, -0.08131351f, 
    -0.15110971f, 0.09420274f, 0.06805436f, 0.21126574f, 0.09203967f, -0.15127724f, 0.11348847f, -0.08756106f, 
    0.11463885f, 0.18742384f, 0.21214411f, 0.18828169f, 0.09875613f, 0.38679367f, 0.53715193f, -0.06397043f, 
    0.35574794f, 0.28797382f, 0.17947929f, -0.04312881f, 0.05860338f, 0.11926038f, -0.06341151f, 0.01668333f, 
    -0.20465432f, -0.07049000f, -0.25253174f, -0.16611087f, 0.04449996f, -0.02394720f, 0.04818086f, 0.14126314f, 
    -0.06929992f, 0.14522906f, 0.02224247f, -0.17529409f, 0.09080213f, 0.35128891f, 0.23436216f, -0.03737726f, 
    0.06127990f, -0.08741357f, -0.05760143f, 0.09131595f, 0.08709586f, -0.09401838f, 0.16521038f, -0.16691092f, 
    -0.11946175f, 0.16948947f, 0.09949566f, -0.20061326f, -0.11944510f, -0.10927968f, -0.07869220f, -0.09007048f, 
    -0.02531695f, 0.31143957f, 0.13465858f, -0.01257144f, 0.22516529f, -0.16581576f, 0.29893669f, 0.42155382f, 
    0.19970831f, 0.00400435f, -0.02899361f, -0.06628649f, -0.12670599f, 0.02453647f, 0.09509058f, -0.00629529f, 
    -0.05824048f, 0.10347355f, 0.15965137f, 0.18014114f, 0.04239960f, -0.00867071f, -0.05154715f, 0.09062406f, 
    0.18573484f, 0.07530593f, -0.03015219f, -0.08261801f, -0.06115977f, 0.03547345f, 0.15555955f, -0.02840307f, 
    -0.12957013f, -0.03500312f, 0.01565764f, -0.00795782f, -0.06765888f, -0.13275903f, 0.10148355f, -0.06584312f, 
    -0.01216125f, 0.14229813f, 0.28060666f, 0.22683564f, -0.14754267f, -0.25546819f, -0.28589129f, 0.02247196f, 
    0.07675714f, 0.03995405f, -0.12691785f, -0.12242723f, -0.27150285f, -0.01755517f, 0.06640599f, -0.06695048f, 
    -0.11512846f, -0.07726889f, -0.20580706f, -0.04214535f, -0.11274911f, -0.11599836f, 0.04886690f, 0.10130297f, 
    0.06851017f, 0.00841373f, 0.05869057f, 0.12998952f, -0.16106059f, 0.16781481f, 0.13081358f, -0.09578504f, 
    -0.15844947f, -0.03333954f, -0.03088349f, -0.06907512f, 0.01049781f, -0.04404482f, -0.10877109f, -0.13978496f, 
    0.24214943f, 0.03080809f, 0.27402827f, -0.09760759f, -0.13812433f, -0.08712890f, -0.01006059f, 0.01027049f, 
    0.36024061f, 0.33651400f, -0.11852449f, -0.10717360f, -0.08041295f, 0.09406293f, -0.20197156f, -0.25122726f, 
    -0.10338120f, 0.07226694f, -0.14318568f, -0.01890394f, 0.30460897f, -0.03814428f, -0.10366594f, 0.03443097f, 
    -0.26577809f, -0.17271921f, -0.13849542f, -0.38983569f, 0.06468698f, 0.02350738f, -0.01415733f, 0.01824077f, 
    0.09593995f, 0.00062034f, -0.04480825f, -0.11326241f, -0.22110496f, -0.18468040f, -0.08906699f, -0.07675338f, 
    -0.06255365f, -0.08160643f, -0.05555550f, -0.13454805f, -0.03574974f, 0.24507232f, -0.14983127f, 0.26914072f, 
    0.21405785f, 0.10531930f, -0.12636730f, -0.27221861f, -0.24034368f, 0.21150398f, -0.12364677f, -0.12433762f, 
    0.05764339f, 0.01154432f, -0.07092710f, -0.09011059f, -0.04429068f, 0.21632929f, 0.17484351f, -0.14335094f, 
    -0.10551757f, 0.02064655f, -0.02861558f, 0.08734938f, -0.02178179f, -0.02917007f, 0.02804007f, 0.15921389f, 
    0.02434159f, -0.01655006f, -0.04355894f, 0.02588386f, -0.03948365f, -0.01502146f, 0.00259177f, 0.05548548f, 
    -0.00380082f, 0.04215394f, -0.02049735f, -0.04342351f, 0.01259030f, -0.06561887f, -0.02818108f, 0.00018041f, 
    0.01451824f, -0.05091139f, 0.02020203f, 0.04337931f, 0.00100372f, 0.03818322f, 0.00388579f, -0.01931076f, 
    -0.04085298f, -0.03230906f, -0.02443834f, 0.00057841f, -0.02883352f, -0.04498927f, 0.01669645f, -0.03203474f, 
    -0.02024423f, 0.01571336f, -0.03086000f, 0.00025527f, 0.03824611f, -0.01218236f, -0.04441131f, 0.01706934f, 
    0.00678018f, 0.02639146f, -0.06566421f, -0.03192088f, -0.02592353f, -0.05020222f, 0.01966740f, -0.01278174f, 
    -0.01063874f, 0.02646874f, -0.05999526f, -0.05783399f, -0.02155150f, -0.01859226f, -0.06900673f, -0.03682253f, 
    -0.01647735f, -0.05062535f, 0.04763972f, -0.01755656f, -0.03444061f, 0.04926670f, -0.05122396f, 0.04020602f, 
    0.02752179f, 0.01580938f, 0.04408222f, -0.04038075f, -0.06126334f, 0.03911174f, -0.02815131f, 0.01444417f, 
    -0.04226858f, -0.07019283f, -0.02709575f, -0.04312356f, 0.01076555f, -0.05328331f, -0.01141895f, 0.03364458f, 
    -0.05907483f, 0.01293731f, -0.05229339f, -0.03428543f, -0.04428035f, -0.00287654f, 0.02977406f, -0.02333470f, 
    0.02933202f, 0.04249490f, 0.01906468f, 0.02134213f, 0.05339735f, -0.00202587f, -0.03003407f, -0.05514683f, 
    0.04760026f, 0.04751187f, -0.02946912f, 0.03190090f, 0.04396969f, 0.00170902f, -0.05904232f, 0.04729141f, 
    0.01888391f, 0.00768391f, -0.02359238f, 0.04272338f, -0.05545402f, 0.04901752f, 0.01295233f, 0.01127330f, 
    0.05955110f, -0.01013995f, 0.01204700f, 0.01530089f, 0.03497646f, -0.01795884f, -0.04097649f, -0.03397916f, 
    -0.00843456f, 0.02186877f, -0.00010429f, 0.02424770f, -0.01221563f, 0.01966927f, 0.02696136f, -0.06772717f, 
    -0.01609489f, 0.02780912f, 0.00558160f, -0.05303655f, 0.03595561f, 0.04119600f, 0.02236891f, -0.01975617f, 
    0.04019076f, -0.02566039f, -0.05435624f, 0.04336014f, 0.01573435f, 0.04010651f, 0.02176118f, 0.02352210f, 
    0.04533381f, -0.05097102f, 0.04944625f, -0.05236901f, 0.01031085f, 0.04260296f, -0.04229403f, -0.03163020f, 
    -0.03516269f, -0.00811534f, 0.01692114f, 0.00334066f, -0.02120131f, -0.04819283f, 0.00624483f, -0.00813420f, 
    -0.02053101f, -0.03595446f, -0.02605848f, -0.03516719f, 0.03866517f, 0.04526718f, 0.00222819f, 0.05109964f, 
    -0.04089633f, -0.07133057f, 0.01942120f, -0.06378588f, 0.02944689f, 0.01571387f, -0.00109170f, 0.04461749f, 
    0.03997803f, -0.05373473f, -0.03104997f, 0.04306834f, -0.03041060f, -0.03669762f, -0.01567275f, -0.04474649f, 
    -0.06074556f, 0.04298604f, 0.04696105f, 0.04641083f, 0.04794905f, -0.02808294f, 0.01743114f, -0.02567077f, 
    0.01740037f, 0.02809402f, -0.04301497f, -0.02176992f, -0.02977103f, 0.01101006f, -0.03779988f, 0.01864175f, 
    0.04665279f, -0.00394948f, -0.04476104f, -0.00227628f, 0.02415169f, 0.04246248f, 0.03071305f, -0.01712117f, 
    -0.00359837f, 0.02688405f, -0.06170860f, -0.01773661f, -0.04770629f, 0.03799341f, -0.03420171f, -0.04862334f, 
    -0.02799678f, -0.05642091f, -0.01760700f, -0.01007398f, -0.04767130f, 0.04652466f, -0.06685518f, 0.00162084f, 
    -0.06554373f, -0.06401587f, 0.01080990f, 0.03320698f, 0.02785957f, 0.01529854f, 0.03519087f, 0.00416248f, 
    -0.06245075f, -0.05536782f, 0.03099823f, 0.02021121f, -0.02605559f, 0.03528125f, -0.05690287f, 0.03365662f, 
    0.02526451f, 0.02549075f, 0.00213733f, -0.05786849f, 0.03376608f, 0.01332989f, 0.01448406f, -0.04464039f, 
    -0.05894436f, -0.01963334f, -0.04618280f, -0.04567992f, -0.00492085f, -0.02716606f, 0.01271430f, -0.04146513f, 
    0.04259893f, -0.06698713f, -0.05817884f, -0.01894257f, -0.04327062f, -0.01667873f, -0.05922644f, -0.06165387f, 
    0.04567068f, -0.06385024f, -0.04950897f, -0.01473095f, 0.03466596f, -0.02730925f, -0.01386336f, 0.01691203f, 
    0.01962836f, -0.03427168f, 0.00255594f, 0.02390219f, -0.05375815f, 0.01439193f, 0.04412573f, 0.03228710f, 
    0.05247343f, -0.05299792f, 0.00123151f, 0.03260913f, 0.04603975f, -0.01831922f, -0.02239074f, -0.04777122f, 
    -0.11629644f, 0.15466093f, -0.04963603f, 0.06715833f, 0.27366960f, -0.08269553f, 0.11764722f, -0.19577856f, 
    -0.18601023f, -0.03546555f, 0.30030018f, -0.02998244f, 0.05802220f, -0.28234929f, -0.00603565f, 0.11238927f, 
    0.10679629f, -0.07075642f, 0.00473214f, -0.15659003f, -0.02892781f, 0.03056035f, -0.03019956f, 0.12400188f, 
    0.14568771f, -0.29402229f, -0.08097427f, 0.00732989f, 0.27049387f, -0.01903879f, -0.00684149f, -0.00661875f, 
    0.07947475f, 0.14867927f, 0.13184860f, -0.08676211f, 0.06672574f, 0.02738013f, 0.02085531f, 0.09054688f, 
    0.05555115f, 0.12033913f, 0.20335633f, -0.23308077f, 0.08511915f, -0.01557535f, 0.08672585f, -0.03216231f, 
    0.27528533f, 0.20214619f, -0.09809367f, -0.07126235f, 0.09878413f, 0.03459274f, 0.57732671f, 0.05470964f, 
    -0.15274514f, 0.07428654f, 0.12563880f, -0.03808844f, 0.28078347f, -0.10000923f, 0.06344559f, 0.00155382f, 
    0.05995954f, 0.13132228f, 0.07021420f, 0.02219255f, -0.04072010f, 0.01958627f, -0.10806482f, -0.12279342f, 
    -0.02493892f, -0.25298420f, -0.06883124f, 0.02001312f, 0.02078154f, -0.03038964f, 0.11843120f, -0.39625669f, 
    0.05359464f, -0.10312204f, 0.01640510f, -0.18747179f, 0.07458681f, 0.28665069f, 0.05363181f, 0.15106757f, 
    0.23680270f, -0.35545367f, 0.44402114f, -0.15651996f, -0.18988872f, 0.12426941f, 0.27378565f, -0.20545441f, 
    -0.05574502f, -0.06751965f, -0.35496560f, 0.31527403f, -0.00366405f, -0.12366968f, 0.02216835f, -0.01191334f, 
    0.14049414f, 0.10455845f, 0.23471773f, 0.26428616f, 0.21900907f, -0.19139613f, -0.28166199f, 0.09819699f, 
    0.15598799f, 0.17091247f, 0.16113167f, 0.18574791f, -0.23700678f, 0.51833737f, 0.21701367f, -0.31634679f, 
    0.10759952f, 0.17727034f, 0.10868474f, 0.12938242f, 0.18482640f, 0.06223924f, 0.20356742f, -0.02823648f, 
    0.00788209f, -0.02595981f, 0.34473586f, 0.21462207f, 0.24003921f, -0.12293397f, 0.05754916f, -0.17771710f, 
    -0.15704186f, -0.15773036f, -0.02502637f, 0.11382069f, -0.10446811f, -0.07417691f, 0.09179297f, -0.19548088f, 
    0.27168956f, 0.12405429f, -0.30380687f, 0.01230546f, -0.03156740f, 0.21252435f, -0.09031036f, 0.15454189f, 
    0.02717154f, 0.09959672f, 0.03598253f, -0.07548078f, 0.02601198f, 0.06316455f, -0.07745650f, -0.01396265f, 
    0.14464745f, 0.02131910f, -0.03369423f, -0.05930032f, 0.04223029f, 0.12509528f, 0.06335035f, 0.06830036f, 
    -0.10298928f, -0.58133841f, -0.39423722f, 0.12312137f, -0.09891170f, -0.13595086f, 0.37528661f, 0.19925717f, 
    0.27851504f, -0.42248943f, -0.38241926f, -0.36898765f, -0.19949625f, 0.06329744f, 0.32643190f, -0.13678484f, 
    -0.00109820f, 0.02915863f, 0.06452351f, 0.12245517f, 0.08327538f, 0.23934920f, 0.10794684f, -0.22183907f, 
    0.04991179f, 0.00417861f, 0.31757107f, 0.07060042f, 0.06021523f, 0.17007367f, -0.02278175f, -0.11716317f, 
    -0.02882308f, 0.04071282f, -0.07469548f, 0.17557962f, -0.31636232f, -0.30027753f, -0.48365366f, 0.10452460f, 
    0.00425974f, -0.21866536f, -0.00877897f, 0.16578254f, 0.08743855f, 0.36303338f, 0.06850901f, -0.24437001f, 
    0.11762863f, -0.24690408f, -0.08412643f, 0.24642348f, 0.08014780f, -0.10984120f, 0.00273889f, -0.02175500f, 
    -0.02637796f, -0.16235293f, -0.16569045f, 0.11309257f, 0.20579921f, 0.19385064f, 0.37348479f, 0.19931570f, 
    0.41876790f, 0.09534885f, 0.05707323f, 0.33849299f, -0.18668225f, -0.01149436f, 0.17475678f, 0.05308998f, 
    0.18832518f, 0.10223981f, -0.02106727f, 0.38094324f, 0.27448314f, 0.15101457f, -0.11482602f, 0.01123657f, 
    0.24861394f, 0.15108469f, 0.25671205f, -0.04114248f, -0.13551201f, 0.02120136f, -0.20908010f, -0.04253929f, 
    0.08533913f, 0.13345078f, 0.10867525f, 0.14287305f, 0.01467383f, -0.28803566f, 0.17575069f, 0.17051247f, 
    0.14232472f, 0.04600313f, 0.04796044f, 0.19604674f, 0.02509755f, 0.20057267f, 0.03018597f, -0.05001684f, 
    -0.13937972f, -0.00149644f, 0.13578993f, 0.07289589f, 0.16863443f, 0.24407320f, 0.07506678f, 0.07197258f, 
    -0.15396430f, -0.11269772f, 0.08197099f, 0.23304629f, -0.01190098f, -0.15825377f, 0.22162397f, 0.07956710f, 
    -0.01709224f, 0.04421835f, -0.02443103f, -0.02988689f, -0.03886066f, 0.12439395f, 0.31428221f, 0.06414475f, 
    0.00806461f, -0.13289580f, -0.17443559f, -0.25192580f, -0.23127569f, 0.03165746f, -0.12101602f, 0.04891191f, 
    0.00631151f, 0.14845248f, -0.05115012f, -0.16328618f, 0.34683403f, 0.23145442f, -0.22692934f, -0.04869159f, 
    0.05718154f, -0.03822959f, -0.06003742f, -0.26026297f, -0.39089662f, -0.30776560f, 0.02218073f, -0.14150372f, 
    -0.10609015f, 0.01276166f, 0.06900873f, 0.26800525f, -0.04970247f, -0.20407826f, -0.07858150f, 0.05168143f, 
    -0.02333680f, 0.09643324f, 0.21471578f, -0.06170416f, -0.19512966f, 0.21891436f, 0.18536226f, -0.01478421f, 
    -0.08041829f, 0.46788174f, 0.04414319f, 0.26062173f, -0.10273462f, -0.03257146f, -0.44265690f, -0.42991427f, 
    0.21347041f, 0.03449799f, -0.04838014f, -0.13989960f, 0.03341710f, -0.16186869f, -0.05441199f, -0.21317542f, 
    -0.10325865f, -0.16223191f, 0.07557760f, -0.00219255f, 0.06269369f, -0.22503220f, 0.05227162f, 0.17300722f, 
    0.11542094f, -0.02374242f, -0.32324496f, 0.12226222f, 0.10192151f, 0.22487837f, -0.00279479f, 0.12047364f, 
    0.16908969f, -0.07600270f, 0.06824071f, -0.43897668f, -0.07130849f, 0.06778095f, 0.15590478f, 0.01250326f, 
    0.03609970f, -0.00081935f, -0.01902642f, 0.27793375f, -0.02751475f, -0.07091325f, 0.37006292f, 0.10514528f, 
    0.26343223f, 0.17045176f, 0.20251602f, 0.53095233f, 0.00630748f, 0.11935154f, 0.02730362f, 0.13158752f, 
    -0.06880635f, -0.00364065f, -0.01701983f, -0.41787907f, -0.37730682f, -0.22619312f, 0.00027907f, -0.00057945f, 
    -0.05504091f, -0.18453404f, 0.00681945f, -0.03867038f, -0.07267979f, 0.33167824f, -0.01795410f, 0.39826584f, 
    0.17203948f, 0.16213121f, 0.20124219f, 0.00914692f, 0.09783060f, -0.12399816f, -0.46232402f, -0.20586552f, 
    0.05177004f, 0.12453189f, -0.18746459f, -0.10142688f, 0.07996897f, -0.07293411f, -0.03291790f, 0.05907625f, 
    -0.13970663f, -0.24224153f, -0.07582381f, -0.15553951f, 0.21839401f, 0.06615134f, -0.03331930f, 0.01938508f, 
    0.38802916f, 0.24255084f, 0.09165872f, 0.02485385f, 0.27018461f, 0.12004327f, 0.07539596f, 0.03430653f, 
    -0.13312380f, 0.01104224f, 0.05166830f, -0.32814750f, 0.03617045f, 0.10143051f, 0.03073233f, 0.24317865f, 
    -0.03715835f, 0.03837368f, -0.08957081f, -0.23530363f, -0.30349779f, 0.06066464f, 0.05677279f, 0.05913734f, 
    -0.15937702f, 0.14221284f, 0.05870623f, 0.23363195f, 0.22212613f, 0.25545916f, -0.18460302f, 0.12543917f, 
    0.10440600f, 0.00232270f, 0.25054848f, 0.26197091f, -0.22368030f, 0.20890629f, -0.00953131f, -0.02130452f, 
    -0.13428788f, -0.09740164f, 0.04667483f, -0.06872249f, -0.11960369f, 0.49342123f, 0.12929191f, 0.33365130f, 
    0.24039930f, 0.11117471f, -0.01618217f, 0.00537212f, -0.09699148f, -0.18969896f, -0.17515962f, -0.01097243f, 
    0.05144975f, 0.06664232f, 0.06376332f, 0.12294897f, -0.15673929f, 0.14605890f, 0.14768454f, -0.14269729f, 
    -0.11628070f, -0.13964510f, -0.05504842f, 0.05026022f, -0.02325300f, 0.05933929f, -0.06339508f, -0.12775646f, 
    -0.10707386f, 0.15621115f, -0.16712682f, -0.03939715f, 0.09608881f, 0.04966072f, -0.01025677f, 0.08092553f, 
    -0.03616560f, 0.53537893f, 0.16448146f, -0.23075938f, -0.00412373f, 0.00619267f, -0.21268304f, -0.14481165f, 
    0.17372794f, -0.32956263f, -0.46807340f, -0.02057111f, 0.14612739f, 0.31090334f, -0.04110808f, -0.00477268f, 
    0.05156100f, 0.04422584f, 0.13576785f, -0.22309320f, -0.12122542f, -0.32081285f, -0.14360239f, -0.02304757f, 
    -0.10282271f, 0.03631509f, 0.05436958f, -0.03403699f, -0.28643537f, -0.17535853f, -0.13231587f, 0.08133817f, 
    0.00072300f, 0.02063632f, -0.01549584f, 0.09394583f, -0.09508022f, 0.55878347f, 0.08069298f, -0.05585781f, 
    -0.08104602f, -0.20208995f, 0.05127389f, -0.06464751f, -0.02945114f, -0.04475957f, -0.19603354f, 0.05310985f, 
    -0.27754861f, -0.02222458f, -0.07437833f, 0.04412523f, 0.02400453f, -0.06664152f, -0.03296468f, 0.13099903f, 
    0.20612270f, 0.26689810f, 0.00707271f, 0.21764782f, -0.01079423f, 0.10201883f, -0.05461211f, -0.30547234f, 
    0.03664573f, -0.05967392f, -0.01901373f, -0.03307804f, -0.03338595f, -0.02989838f, -0.07432034f, -0.06471158f, 
    -0.02452923f, -0.09753841f, -0.07098315f, -0.03894852f, -0.04850579f, -0.02526124f, -0.01605519f, -0.04643245f, 
    -0.00558966f, -0.09918449f, 0.00428365f, 0.00986645f, 0.00145131f, -0.01445102f, 0.01288494f, -0.02989629f, 
    -0.07574409f, 0.02968956f, -0.04887140f, 0.03820635f, -0.03153566f, -0.05832266f, -0.00501564f, 0.02136400f, 
    -0.05960420f, -0.00074747f, -0.03225857f, -0.04517766f, 0.01177526f, -0.07737537f, -0.08167422f, -0.04401857f, 
    0.02442782f, -0.07417103f, -0.03438589f, -0.00819864f, -0.06739160f, 0.00727254f, 0.00599092f, -0.09286151f, 
    -0.07071780f, -0.07486828f, -0.00195048f, -0.04353990f, 0.02338958f, -0.00228151f, -0.04767104f, -0.01107587f, 
    -0.01530523f, 0.02655494f, -0.00205594f, -0.05691050f, -0.04937138f, -0.10069200f, -0.00288877f, -0.04512316f, 
    0.04547856f, -0.04915919f, 0.01730781f, -0.04787011f, 0.01392172f, -0.00531466f, 0.01875843f, -0.00768360f, 
    -0.04908977f, 0.02201478f, -0.03124491f, -0.03509923f, 0.00673034f, -0.07269523f, 0.00577145f, 0.01991462f, 
    -0.04842434f, 0.01244312f, 0.02481682f, -0.03233426f, 0.01232254f, -0.03132053f, -0.06654220f, 0.03420570f, 
    -0.00963262f, -0.03071867f, -0.02550914f, -0.07668354f, -0.06947377f, 0.00083206f, -0.04651855f, -0.00178574f, 
    0.01395825f, -0.00595144f, -0.02781459f, 0.01490544f, 0.00311030f, -0.09134242f, -0.10669040f, -0.02576008f, 
    -0.10379341f, -0.00485613f, -0.02677038f, -0.05946988f, 0.02718280f, 0.01003120f, 0.03387157f, -0.01333095f, 
    0.02881294f, 0.03187305f, -0.02486739f, -0.07704653f, -0.05110105f, -0.00335245f, -0.03848683f, 0.01763410f, 
    0.00698160f, 0.00364007f, -0.06074790f, -0.04428697f, -0.00360609f, 0.01066377f, -0.02153285f, -0.03477325f, 
    -0.03258446f, -0.08971577f, -0.08704861f, -0.03051802f, 0.01196033f, 0.00165708f, -0.05080220f, 0.03441524f, 
    -0.05382538f, -0.00104021f, -0.06011164f, -0.06914944f, -0.03317142f, -0.04340613f, -0.04097494f, 0.01481320f, 
    -0.00410082f, -0.00373836f, 0.01103935f, -0.05953276f, -0.08990105f, -0.04364233f, 0.00689498f, 0.01253773f, 
    -0.01362753f, 0.00149581f, -0.01253985f, -0.02199488f, -0.00301850f, -0.03996519f, -0.08730279f, 0.02467282f, 
    -0.00315158f, -0.04129332f, -0.00098515f, 0.03227733f, 0.02417372f, -0.04574514f, -0.03227340f, 0.01484206f, 
    -0.07292998f, -0.01142857f, 0.03558506f, -0.04076581f, 0.01662967f, -0.04570048f, -0.07794999f, -0.06023115f, 
    -0.07142775f, -0.03561331f, 0.00856902f, -0.07562349f, -0.06993368f, -0.00210375f, -0.08325671f, 0.01813487f, 
    -0.08390851f, -0.01072862f, -0.01752326f, -0.09097827f, -0.00840230f, -0.04845061f, -0.03541896f, -0.06846375f, 
    -0.07925525f, -0.05943795f, -0.07877851f, -0.05102963f, -0.05120547f, -0.09770278f, -0.01043814f, -0.02471166f, 
    -0.01437468f, -0.03399909f, -0.03991389f, -0.08579026f, 0.00283281f, -0.06642689f, -0.05422102f, 0.04225213f, 
    0.02887483f, -0.03114868f, -0.03521048f, -0.04975468f, 0.03638669f, -0.07903049f, -0.05442740f, -0.05041233f, 
    -0.05626158f, -0.07708687f, -0.01308154f, -0.06833778f, -0.04657295f, -0.08867086f, -0.04033203f, -0.00854248f, 
    -0.02522011f, -0.05558008f, -0.01483764f, -0.02378643f, -0.04849573f, -0.05869329f, -0.05829924f, 0.00967973f, 
    -0.03070354f, -0.01580665f, -0.03125605f, -0.06326988f, -0.08282553f, -0.06981706f, -0.08051088f, -0.01610298f, 
    -0.03059836f, -0.06018300f, -0.03274794f, -0.08274065f, 0.00661720f, -0.06692547f, -0.02410918f, -0.03785626f, 
    -0.00901271f, -0.02598574f, -0.09340438f, -0.03356979f, -0.06743953f, -0.01106382f, 0.02523506f, -0.00609642f, 
    0.02733639f, -0.06082864f, -0.06400098f, -0.02648878f, -0.08760839f, -0.08368256f, -0.07267920f, 0.02315927f, 
    0.00914111f, -0.03108569f, -0.00409275f, 0.01455546f, -0.07258623f, -0.08071137f, -0.05644282f, -0.01575261f, 
    -0.02908012f, 0.01506302f, -0.05185782f, -0.00816701f, 0.02370715f, 0.01838654f, -0.05313274f, -0.02688984f, 
    -0.02270549f, -0.01452649f, -0.00749558f, 0.00806603f, -0.01583064f, -0.08570793f, 0.00300992f, -0.02801648f, 
    0.14896689f, -0.11524954f, 0.33258834f, 0.05580761f, 0.25537142f, -0.10019317f, -0.04804685f, 0.16928405f, 
    0.22098401f, -0.19812277f, -0.33845297f, -0.03944391f, -0.12510543f, 0.22501278f, 0.09038820f, 0.15053347f, 
    -0.08774286f, 0.04585597f, -0.28322315f, 0.05171639f, 0.34820610f, -0.51003087f, 0.21151401f, -0.01493826f, 
    -0.00895597f, 0.14163630f, 0.15032676f, -0.75437063f, -0.46234986f, 0.02551595f, -0.10828069f, 0.25855744f, 
    0.12107895f, -0.16787589f, -0.16002591f, -0.00918336f, -0.19066027f, -0.19988216f, 0.08008965f, 0.14334792f, 
    -0.04020946f, 0.01830361f, 0.06071167f, 0.16852047f, 0.10423778f, 0.12601009f, 0.42038411f, 0.40407276f, 
    -0.12909256f, -0.04862898f, 0.16379510f, 0.21693994f, 0.00074847f, -0.16707103f, -0.59713155f, -0.17591223f, 
    -0.15662637f, -0.06218821f, -0.07329270f, -0.06463718f, 0.15969753f, -0.05391198f, 0.02616062f, -0.07870905f, 
    -0.60290098f, -0.05465290f, 0.07422780f, 0.08568968f, -0.01177141f, -0.00039886f, 0.22790599f, 0.02274215f, 
    0.16090341f, -0.03914504f, -0.16198477f, 0.08793397f, 0.04812834f, 0.01379200f, -0.08430434f, 0.03989418f, 
    0.11733621f, -0.00746143f, -0.07849034f, -0.02532017f, 0.06199820f, -0.15324670f, 0.19063129f, -0.13886067f, 
    0.23886648f, -0.04349358f, 0.00514876f, 0.40571782f, 0.45732427f, 0.23255867f, 0.02447179f, -0.00710251f, 
    -0.11064728f, -0.13348004f, 0.00203138f, 0.11961796f, -0.00346819f, -0.07352655f, 0.13862322f, 0.06301934f, 
    -0.06232126f, 0.27456549f, 0.00481847f, 0.06028763f, -0.46961737f, -0.04119126f, 0.30351695f, -0.20656325f, 
    0.12549773f, -0.09504715f, 0.04450629f, 0.11721203f, 0.07616535f, 0.02324841f, 0.09200806f, 0.08820128f, 
    0.00301189f, -0.08728243f, 0.02528064f, -0.09699658f, -0.01532813f, 0.23544860f, -0.44629323f, -0.14523278f, 
    -0.03823595f, -0.05601253f, -0.15679699f, 0.01416959f, 0.15757537f, 0.12029632f, 0.10092124f, 0.45803997f, 
    0.13438644f, -0.82734197f, 0.01904151f, 0.12818599f, 0.32050490f, -0.10252366f, 0.11972386f, -0.09019966f, 
    0.07905857f, 0.29078996f, -0.03422870f, 0.03824986f, -0.01041787f, -0.10191073f, 0.02382479f, -0.01585641f, 
    0.17549740f, -0.65450132f, -0.14654572f, 0.21969236f, 0.15635560f, 0.12977828f, 0.20613453f, -0.06154481f, 
    0.20750448f, 0.12079820f, 0.08911075f, -0.35663050f, 0.12008034f, -0.08584247f, 0.09271490f, -0.16682950f, 
    -0.10327674f, -0.00455823f, 0.17353295f, 0.01941532f, 0.80015302f, 0.32362023f, -0.11627990f, -0.14599429f, 
    0.03762837f, 0.14666025f, -0.11501019f, 0.08027663f, 0.25363496f, 0.34963417f, 0.07513386f, -0.00626215f, 
    0.17072074f, 0.07482609f, -0.23003693f, -0.33997110f, -0.35705349f, 0.12073641f, -0.17845492f, -0.27907109f, 
    0.08523272f, 0.15939203f, -0.27801251f, 0.01984827f, -0.04790692f, 0.06092470f, -0.16212820f, -0.02328186f, 
    0.24506554f, -0.02739818f, -0.10364164f, 0.14021951f, -0.07299808f, 0.07943538f, 0.05564597f, 0.11194673f, 
    0.12789571f, -0.04935198f, -0.20939861f, -0.33371419f, -0.14992438f, 0.14737973f, -0.11316101f, -0.25065172f, 
    0.33375338f, 0.39006576f, -0.18671264f, -0.20155258f, 0.10566963f, 0.24705356f, -0.12767740f, 0.25218523f, 
    -0.02686048f, -0.46159944f, -0.19049887f, -0.03134768f, 0.14353941f, -0.08420567f, -0.25931191f, -0.07667214f, 
    0.06473619f, -0.04884580f, -0.50750673f, -0.11306042f, -0.04457676f, 0.07435431f, -0.15147819f, -0.08907688f, 
    -0.07098522f, -0.21174031f, -0.27848113f, -0.26989588f, -0.16671319f, -0.38417721f, -0.03810197f, -0.07094384f, 
    0.25984570f, 0.10146394f, -0.21680342f, -0.09528648f, -0.25853941f, 0.25648701f, 0.02320164f, -0.19585659f, 
    -0.36597282f, -0.46409392f, -0.12256645f, 0.04789951f, -0.01920184f, -0.28508061f, -0.57920265f, -0.02309794f, 
    0.12502508f, -0.08174700f, -0.00411533f, 0.19587386f, 0.11232048f, -0.12390018f, -0.20246263f, -0.11785643f, 
    0.29109985f, -0.44236690f, 0.07188280f, -0.00821252f, 0.07197522f, 0.07338239f, 0.20265791f, 0.13439152f, 
    0.41343203f, 0.07002858f, -0.07885616f, -0.14303531f, -0.11478369f, 0.00120962f, -0.12295463f, -0.02688205f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.00440859f, 0.18849742f, 0.19746836f, 0.39499572f, 0.32528305f, -0.03647846f, -0.00268881f, 0.15874523f, 
    0.03439865f, 0.10117006f, 0.01043839f, 0.39068151f, 0.11015148f, -0.12824853f, -0.08645496f, 0.03027412f, 
    -0.00766102f, 0.25061986f, -0.02168449f, 0.03359684f, 0.08767648f, -0.04506691f, 0.39832485f, -0.03051646f, 
    -0.06132165f, -0.11643153f, 0.04201474f, -0.06137349f, 0.10183951f, -0.04643423f, 0.00449665f, 0.08391551f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.03962968f, -0.26903090f, -0.24860878f, -1.06604159f, -0.33104056f, 0.02076019f, -0.12141613f, -0.01748621f, 
    -0.74011910f, 0.30294162f, -0.15925367f, -0.11624858f, -0.25961390f, 0.47876254f, -0.22918393f, 0.19112559f, 
    0.03467366f, -0.55030501f, -0.13940978f, -0.03054529f, 0.04853350f, 0.15135044f, 0.22333126f, 0.00534916f, 
    0.09248502f, 0.46882612f, -0.17993937f, 0.09475415f, 0.07764521f, 0.41285604f, 0.11587430f, 0.37297538f, 
    -0.10160448f, 0.27158701f, -0.19199446f, 0.19232318f, 0.18120921f, 0.06958502f, -0.11937065f, 0.25866184f, 
    -0.50435883f, 0.12041728f, -0.42258009f, 0.13166288f, 0.13096428f, 0.02691463f, -0.39868295f, -0.15186572f, 
    0.11743271f, 0.27102378f, -0.16557214f, -0.00324886f, -0.17415087f, -0.03323683f, 0.15264690f, -0.25845441f, 
    0.16336031f, 0.78987557f, 0.14712818f, -0.09839185f, -0.26969311f, 0.46672592f, 0.18462989f, 0.04253032f, 
    0.06652255f, 0.08536508f, 0.20967856f, 0.69593143f, -0.14392629f, 0.01592980f, -0.06502090f, 0.62286162f, 
    0.52162617f, 0.05485084f, -0.21634199f, 0.17701909f, -0.27991602f, -0.42237031f, -0.13044234f, -0.68750495f, 
    0.04556831f, -0.87365794f, -0.17038959f, -0.11223558f, -0.15845497f, 0.15872647f, -0.28727248f, -0.21939972f, 
    -0.14671840f, -0.35055193f, 0.01857357f, -0.14695229f, 0.28456867f, -0.27517051f, 0.12315334f, -0.83340448f, 
    0.02818984f, -0.40740392f, -0.72223610f, 0.62051970f, -0.40979955f, 0.17395134f, -0.48704118f, -1.13631499f, 
    0.42878267f, 0.42395222f, 0.24543406f, -0.48797286f, -0.25999048f, 0.04670430f, 0.11537291f, 0.26300943f, 
    -0.15797481f, -0.64194512f, 0.04771412f, 0.16055025f, -0.29513413f, 0.10962646f, 0.05946040f, 0.30467224f, 
    0.04975802f, -0.40746060f, 0.15470655f, -0.13203850f, 0.28785670f, 0.01938652f, 0.05238077f, -0.14625077f, 
    -0.14251757f, 0.03312058f, -0.00577042f, -0.40185377f, -0.15859571f, 0.02419389f, 0.67680615f, -0.25651440f, 
    0.22331674f, -0.05843002f, 0.22448730f, 0.06095070f, 0.08584335f, 0.13053253f, 0.05733785f, 0.25418612f, 
    -0.02649493f, 0.01059922f, 0.08401056f, -0.10978631f, -0.32131982f, 0.02484686f, 0.09644166f, -0.20039381f, 
    -0.12661737f, 0.15634102f, -0.54914486f, -0.08499197f, -0.10497730f, -0.04831241f, -0.06165699f, 0.27569333f, 
    0.02692904f, 0.43228421f, 0.22271663f, 0.12118652f, -0.17391315f, 0.06158588f, 0.05527045f, -0.48839235f, 
    0.05531108f, -0.06862013f, -0.13073823f, 0.26717496f, 0.10281494f, 0.31083700f, 0.34226364f, -0.49961397f, 
    -0.08627036f, -0.07627042f, 0.08558697f, -0.04980193f, 0.09723435f, -0.07618160f, -0.10544483f, -0.56501216f, 
    -0.11205262f, -0.13900460f, 0.18473269f, 0.13892446f, -0.33087200f, 0.11967167f, 0.14775179f, 0.35128155f, 
    0.06248806f, -0.05053319f, -0.17395984f, 0.17334083f, -0.00147084f, -0.00137363f, -0.37041640f, 0.34789336f, 
    -0.52019095f, -0.49450016f, 0.25753736f, 0.10948367f, -0.03287394f, -0.47400284f, 0.03504748f, -0.69975346f, 
    0.08023075f, -0.69457889f, -0.03781012f, -0.04010727f, 0.47337854f, 0.16489880f, 0.61503983f, 0.01572801f, 
    -0.05185080f, -0.48690391f, -0.27096236f, 0.12926157f, 0.19670713f, -0.79247296f, 0.03699545f, -0.39197293f, 
    0.03694533f, -0.50383878f, 0.07137230f, -0.64135462f, -0.08497740f, 0.15067378f, -0.04766885f, 0.12904823f, 
    0.56226254f, 0.36635706f, 0.26799089f, -0.41299134f, 0.20325720f, -0.12504196f, 0.08825657f, -0.12321579f, 
    0.01488325f, 0.30439940f, -0.00652463f, -0.12021351f, 0.17717107f, 0.01514845f, -0.17662233f, -0.02712916f, 
    0.04444775f, 0.05130898f, 0.12136537f, 0.15903436f, -0.21202524f, 0.01825236f, 0.06996306f, -0.48008099f, 
    -0.00215418f, 0.51562697f, 0.51021886f, 0.11992160f, -0.21540622f, -0.12363030f, -0.29438615f, -0.22680508f, 
    -0.54182041f, -0.17017478f, -0.93835580f, 0.18321274f, -0.04999955f, -0.16141675f, -0.36285123f, -0.01818408f, 
    -0.16690288f, 0.54417461f, 0.06099193f, 0.07158714f, 0.46435690f, 0.03953581f, -0.52916497f, 0.00932404f, 
    -0.07772100f, -0.62414968f, 0.35953921f, -0.14815626f, 0.00806559f, 0.17617391f, 0.11692382f, -0.96171004f, 
    0.11365895f, -0.38348585f, 0.40072772f, -0.57722145f, 0.37996253f, 0.06918293f, -0.32796213f, -0.04572097f, 
    -0.12285731f, -0.27577332f, 0.51342702f, 0.22499329f, 0.24476723f, -0.62996650f, 0.12290767f, 1.04650903f, 
    -0.12902613f, -0.41860029f, 0.02808911f, 0.07453145f, -0.34447554f, 0.04906756f, -0.08021508f, -0.36467227f, 
    -0.09379391f, 0.15272313f, -0.59049517f, 0.08051565f, 0.15162529f, 0.04339907f, 0.06419354f, -0.45198026f, 
    -0.11458004f, 0.36417583f, 0.12465969f, 0.20203216f, 0.01208839f, 0.01972034f, 0.53385061f, -0.39422527f, 
    -0.03925296f, -0.28958964f, -0.15197904f, 0.14752953f, 0.10542681f, -0.76794189f, -0.57158768f, 0.27019975f, 
    -0.14998484f, -0.80893821f, 0.02919203f, -0.15644534f, 0.51736677f, -0.15347975f, -0.06353060f, 0.76740015f, 
    -0.13661879f, -0.77992040f, 0.33693090f, 0.07447491f, -0.45468330f, -0.05170547f, 0.03152782f, 0.51324666f, 
    0.16013308f, -0.16653456f, -0.36333901f, 0.16481097f, 0.13647971f, -0.16498269f, 0.14577052f, 0.20285745f, 
    -0.45555919f, -0.89154053f, 0.42256489f, 0.14392458f, 0.29364634f, -0.17529117f, 0.05834170f, -0.54257536f, 
    0.01088669f, 0.55339068f, -0.07271967f, 0.05672448f, -0.38692853f, -0.01569296f, -0.41403723f, 0.85511512f, 
    -0.12653400f, 0.38078615f, 0.19845603f, 0.17387535f, -0.08892081f, -0.59323812f, -0.13582282f, -0.67421067f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.25322658f, 0.00483630f, 0.04692259f, -0.17744184f, -0.12121490f, 0.15199040f, 0.21639083f, -0.27566549f, 
    0.10655564f, 0.44430500f, -0.16000719f, -0.08168616f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
