#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.34392160f, -0.14170679f, 0.11458626f, -0.78048384f, -0.43201891f, 0.03543094f, 0.37034315f, -0.07682984f, 
    -0.36872965f, -0.13186355f, -0.24124722f, -0.79187387f, 0.05823017f, 0.28515163f, 0.55710244f, 0.47285894f, 
    0.47542995f, 0.58295429f, 0.61562824f, 0.82964939f, 0.47191948f, -0.74782562f, 0.10158323f, -0.33925381f, 
    0.04816892f, 0.05237053f, 0.07543616f, -0.79357451f, -0.68805194f, -0.45845947f, 0.29875714f, 0.98286968f, 
    0.30135220f, 0.17961816f, -0.18491098f, -0.00876107f, -0.64721638f, 0.11459816f, -0.90628046f, -0.24816030f, 
    0.24949187f, 0.43909681f, -0.28677914f, 0.00228095f, -0.16890205f, 0.68523246f, 0.00307405f, 0.03826489f, 
    0.69386739f, 0.71823782f, 0.06887948f, -0.48933497f, 0.31095293f, -0.28372601f, -0.77570516f, -0.57733989f, 
    -0.18702883f, -0.64766264f, -0.31275707f, -0.21256785f, 0.27751574f, 0.18456884f, -0.17647971f, 0.70356101f, 
    0.08880375f, 1.08551574f, 0.73135215f, -0.06880670f, -0.22450887f, 0.32441574f, 0.01175850f, -0.04415890f, 
    0.10080823f, 0.00574830f, 0.15958919f, -0.51120710f, -0.56892556f, -0.90602994f, -0.29839578f, -0.14456311f, 
    0.08530969f, 0.19636768f, 0.40667140f, 0.54078555f, 0.46879676f, 0.40488937f, 0.56526548f, -0.55050308f, 
    0.08521023f, 0.38976172f, 0.44988748f, 0.01013564f, 0.33555266f, 0.19496678f, -0.91350985f, 0.38140708f, 
    -0.51015985f, 0.15807666f, -0.17423373f, -0.48728934f, -0.26303029f, -0.06868134f, 0.57550907f, -0.51135278f, 
    -0.25316802f, -0.57255405f, -0.44742951f, -0.44107562f, 0.86309695f, -0.85503095f, -0.47291344f, -0.33110926f, 
    -0.04105528f, 0.09226898f, -0.04326121f, 0.09417069f, 0.03129340f, 0.23709536f, 0.86253053f, -0.71149480f, 
    0.45830694f, -0.14732903f, -0.08496136f, 0.06104763f, 0.10706547f, -0.03303186f, -0.58926183f, 0.54668081f, 
    0.54668617f, 0.28201079f, 0.43130809f, -0.05192694f, -0.62457955f, -0.37802336f, -0.38648993f, 0.64355695f, 
    -0.16502802f, -0.18350330f, -0.68291110f, -0.15139040f, -0.67381448f, -0.03147765f, 0.55922717f, 0.38521433f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.15779553f, 0.02715952f, 0.17339149f, 0.10792667f, 0.12940031f, -0.42774299f, 0.28111184f, 0.04181805f, 
    -0.06727602f, 0.11330865f, -0.15969853f, -0.37162814f, 0.01553011f, 0.05855396f, 0.03691676f, -0.16506879f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.10095491f, -0.05322345f, -0.14415784f, 0.07780477f, -0.04887766f, 0.14360814f, 0.13409704f, 0.10932517f, 
    0.10527916f, 0.12391494f, -0.18571219f, -0.18444203f, 0.20664813f, -0.04163008f, -0.12608890f, 0.12331862f, 
    0.05234401f, 0.04766637f, 0.03825963f, 0.17820273f, -0.04600863f, 0.06568129f, -0.17830931f, 0.31826565f, 
    -0.03036288f, -0.05012479f, 0.16454075f, 0.09884966f, -0.03263222f, -0.35033613f, 0.06645577f, 0.13120432f, 
    0.04927441f, 0.00804597f, -0.05062490f, -0.14111102f, 0.05429394f, 0.07114947f, -0.28362718f, 0.11385338f, 
    -0.00296985f, 0.01108687f, 0.05390042f, -0.05020265f, 0.04962328f, 0.14216085f, -0.23876031f, -0.04566151f, 
    -0.17193265f, 0.21506554f, -0.25067946f, 0.15698218f, 0.05312407f, -0.08672417f, -0.22975843f, -0.00680310f, 
    -0.13039613f, -0.01161953f, 0.05205134f, 0.07383695f, 0.04597067f, 0.02031778f, -0.09454352f, -0.20725976f, 
    -0.06079313f, 0.43946815f, -0.14211924f, 0.21352926f, -0.16673273f, 0.08308786f, -0.03454289f, 0.01157058f, 
    -0.05907815f, 0.04014527f, 0.07607475f, 0.25720695f, 0.02298501f, 0.26800239f, -0.00370376f, -0.09241046f, 
    0.25082541f, 0.20861551f, 0.19791931f, 0.06203929f, 0.03401913f, 0.05160392f, -0.04364954f, 0.04985972f, 
    0.17213881f, 0.14399920f, -0.01822073f, 0.20973276f, 0.17886363f, 0.07087807f, -0.12588717f, -0.04261663f, 
    0.14132112f, -0.13299632f, 0.15012935f, -0.13729097f, 0.25497428f, 0.05700792f, 0.07493569f, 0.19738749f, 
    -0.24993369f, 0.07913672f, 0.12023365f, -0.29749948f, -0.69155437f, -0.41949928f, -0.19520168f, -0.13815609f, 
    0.06812843f, 0.05874330f, -0.00052684f, -0.03924195f, -0.05001582f, -0.02367652f, -0.43207112f, -0.22817300f, 
    0.01006808f, -0.00783266f, 0.03041395f, -0.04858976f, -0.14132287f, 0.04665747f, -0.02339109f, 0.17496380f, 
    -0.18355680f, -0.00446521f, -0.05285366f, -0.10312247f, -0.04752046f, -0.00241943f, -0.09592562f, 0.09708833f, 
    -0.26247263f, -0.07300980f, -0.08703674f, 0.02541918f, 0.08921061f, -0.23144257f, -0.16393021f, 0.11234442f, 
    0.01326964f, 0.06770656f, 0.04330462f, 0.06695915f, -0.05087343f, 0.01398589f, 0.01168109f, -0.04092148f, 
    -0.09179671f, 0.00087458f, 0.03532525f, -0.08805081f, 0.06032682f, 0.01593128f, -0.05304042f, 0.02974352f, 
    0.01373072f, 0.03096846f, -0.07812300f, -0.08536229f, -0.07233397f, -0.05763717f, -0.03302509f, -0.00237090f, 
    -0.07555912f, 0.01240158f, -0.05774780f, -0.02355137f, -0.06374503f, -0.08816754f, 0.00055501f, 0.01757782f, 
    -0.00209079f, -0.01700906f, -0.01910893f, -0.03242751f, -0.03729830f, -0.08481184f, -0.01263300f, 0.03647660f, 
    -0.02796743f, -0.05715626f, -0.02139783f, 0.02830156f, -0.07877604f, 0.01239566f, -0.04003789f, -0.02993415f, 
    0.01414655f, -0.06171388f, 0.01425898f, 0.05141677f, -0.05206338f, -0.06935652f, 0.03301571f, -0.05761244f, 
    0.00851773f, 0.00356897f, 0.01947996f, -0.03566708f, -0.01829753f, -0.05607899f, 0.00164571f, 0.07012620f, 
    -0.02124579f, -0.00890072f, 0.05378522f, 0.03607989f, 0.05879654f, 0.04515333f, -0.01809153f, -0.01365721f, 
    -0.04588526f, -0.00650040f, 0.00659259f, 0.04676838f, -0.02720918f, 0.00683774f, -0.02627059f, -0.02000915f, 
    -0.07700606f, -0.08186679f, -0.06517035f, 0.05669859f, 0.05932245f, -0.05490527f, -0.02937070f, -0.04073661f, 
    -0.03738515f, -0.02156259f, -0.06102345f, -0.08502832f, -0.05159402f, 0.05487371f, 0.05584751f, -0.04249705f, 
    0.03699176f, 0.01048891f, -0.01967423f, -0.00990406f, -0.03267091f, -0.07593479f, -0.05857005f, -0.09343807f, 
    -0.05616793f, 0.04907362f, -0.04845397f, 0.06751324f, 0.06738508f, 0.04039157f, 0.01216899f, -0.02819083f, 
    -0.08132572f, -0.07005917f, -0.07585906f, -0.00570369f, -0.02952319f, -0.03748713f, 0.06481086f, -0.09129414f, 
    -0.09281798f, 0.00595241f, 0.00860795f, 0.02263431f, -0.03410393f, -0.01913073f, -0.02762946f, 0.02393149f, 
    -0.07619493f, 0.03029791f, 0.05906773f, -0.05900709f, -0.08533330f, -0.01846222f, -0.00594132f, 0.03799199f, 
    -0.07141948f, -0.07197723f, -0.06789198f, -0.02871232f, 0.00431120f, -0.02635885f, -0.08213142f, -0.05668332f, 
    -0.06582251f, -0.07144033f, 0.13775611f, -0.17132691f, 0.13891751f, -0.01842712f, -0.04819080f, 0.10753661f, 
    -0.01826519f, 0.09285124f, 0.30702162f, -0.16894916f, 0.36645946f, 0.00269536f, -0.01362727f, -0.00438084f, 
    0.08995379f, -0.04100275f, -0.10603590f, 0.21185426f, 0.44596359f, -0.05742436f, -0.11914671f, 0.06806623f, 
    -0.03920967f, 0.07705417f, 0.01221428f, -0.64261651f, -0.28331417f, -0.32166865f, 0.13639022f, 0.12679605f, 
    0.01655451f, 0.05597802f, 0.04313127f, -0.02672681f, -0.20738140f, -0.34913641f, 0.08328358f, -0.01375953f, 
    0.21291633f, 0.07861325f, -0.19335760f, -0.01949956f, 0.10831092f, -0.36258340f, 0.07508784f, -0.02027999f, 
    0.09636237f, -0.05458991f, -0.08230539f, 0.05655118f, 0.00214274f, -0.11495265f, -0.25988382f, -0.26646295f, 
    -0.03853285f, 0.25142246f, 0.15845951f, -0.09554905f, 0.19991916f, 0.04396557f, -0.04298733f, -0.06908479f, 
    0.14092544f, 0.20328404f, -0.07511505f, 0.03022971f, -0.08091664f, 0.06981140f, -0.10134929f, 0.19412270f, 
    0.14174888f, 0.03459964f, 0.23219891f, -0.05905028f, 0.15042980f, -0.01584943f, -0.02321644f, 0.06929606f, 
    0.10874052f, 0.14032191f, 0.01849593f, -0.02693149f, 0.00789971f, -0.07592309f, 0.08435446f, 0.12496620f, 
    0.01746932f, 0.10919487f, -0.07120071f, -0.06321871f, 0.13199204f, 0.22994936f, 0.04662098f, 0.12500884f, 
    0.10469911f, -0.00548572f, -0.00679621f, 0.03115314f, -0.15369341f, 0.16333500f, -0.04393173f, -0.08796114f, 
    -0.09668250f, 0.15367159f, 0.04474318f, 0.15031581f, -0.19553481f, -0.22105713f, -0.42815408f, -0.08036012f, 
    -0.01651204f, -0.08474018f, -0.02323708f, -0.12281843f, 0.09976006f, 0.08252257f, -0.26856172f, 0.10284822f, 
    -0.10035357f, 0.03954962f, 0.01210368f, -0.17450468f, -0.08061089f, -0.08760945f, 0.36847267f, 0.08664145f, 
    -0.15840140f, 0.05844850f, 0.01525790f, -0.00511157f, 0.00059082f, 0.03970199f, 0.01350902f, 0.10201728f, 
    0.03016637f, -0.29734486f, -0.04382990f, 0.07048424f, 0.09571535f, 0.06253895f, 0.05429434f, -0.14605874f, 
    0.21159256f, -0.13057761f, 0.13178784f, -0.39004797f, -0.07488040f, -0.03953452f, 0.04722286f, 0.13730021f, 
    0.18610145f, -0.56448001f, -0.08744469f, -0.01306503f, 0.11273229f, -0.01945431f, -0.08007322f, 0.22443055f, 
    -0.07186588f, 0.07232889f, -0.07757759f, -0.02191640f, 0.06037934f, -0.30766797f, -0.03442300f, -0.16862296f, 
    0.00810853f, -0.15923682f, 0.07423957f, 0.32318807f, 0.22353759f, -0.29993811f, 0.10585373f, 0.09129198f, 
    0.13789795f, -0.19950730f, -0.18372805f, -0.03413038f, 0.19563429f, -0.01140723f, -0.25443855f, 0.01141805f, 
    -0.04489355f, -0.05768402f, 0.10403988f, 0.10156430f, 0.03922011f, 0.26265451f, -0.06546658f, -0.03039752f, 
    -0.10647223f, -0.00798243f, 0.25303212f, 0.16467446f, 0.08883499f, -0.08736142f, -0.57485211f, -0.25066403f, 
    0.00361634f, 0.23090348f, -0.01720485f, -0.10891106f, 0.03801646f, 0.02420350f, 0.02121129f, 0.03806992f, 
    -0.02502890f, 0.14734925f, -0.13636070f, 0.24283516f, 0.04299038f, 0.02289742f, 0.07043108f, -0.09640001f, 
    -0.03855532f, 0.06320851f, 0.07176173f, -0.21014601f, 0.11716744f, -0.17578785f, 0.22775051f, 0.18866336f, 
    0.16863510f, -0.10367513f, 0.22944194f, 0.04955850f, 0.00927780f, 0.27960023f, -0.03347455f, 0.03929318f, 
    -0.00917132f, 0.00188272f, 0.07201916f, -0.20476584f, -0.01492346f, -0.23617528f, -0.15259172f, -0.06230009f, 
    -0.10440936f, 0.04862162f, -0.10104349f, -0.21349058f, 0.26629901f, -0.03965782f, 0.23488308f, 0.10897545f, 
    0.08741642f, 0.24161188f, -0.19886643f, 0.05553000f, 0.03169246f, -0.41879198f, -0.00836358f, -0.01667599f, 
    0.03388910f, -0.15489069f, -0.04667782f, -0.00965032f, -0.02445665f, -0.18077566f, -0.00013483f, 0.27111647f, 
    -0.12213791f, -0.07509400f, -0.08847949f, -0.00174653f, 0.03103588f, -0.17866988f, 0.26968157f, 0.42355171f, 
    0.35496739f, 0.00180992f, -0.13547032f, -0.02293746f, 0.15348156f, 0.02821903f, -0.19064398f, -0.02393091f, 
    0.23665009f, -0.01795702f, -0.15407644f, 0.00443498f, -0.02118070f, -0.25085449f, 0.01804489f, 0.10064912f, 
    -0.02398414f, 0.05251923f, -0.04273672f, 0.27520734f, -0.01422869f, -0.08476675f, 0.06025593f, -0.17755061f, 
    0.13703294f, 0.12759909f, 0.11964527f, -0.22535326f, -0.00983324f, -0.05113459f, 0.16801828f, -0.18467924f, 
    0.07705152f, -0.34193850f, 0.21790242f, 0.11080374f, 0.04244906f, 0.08933011f, 0.10360536f, 0.07526927f, 
    -0.03799727f, -0.02994458f, -0.00773123f, -0.26792482f, -0.13319018f, 0.11129409f, 0.05732456f, -0.20500055f, 
    0.16186170f, -0.17502081f, -0.10116380f, 0.06441815f, 0.09775499f, 0.01682617f, 0.02566802f, -0.23623133f, 
    0.00046844f, -0.00795732f, -0.00218300f, 0.08750215f, 0.11980510f, -0.44394809f, -0.14341854f, -0.10192788f, 
    0.05390942f, -0.10486773f, 0.18531552f, -0.16799180f, 0.05597265f, -0.11654140f, -0.18596354f, 0.22571835f, 
    0.13580836f, 0.04447988f, 0.03221399f, 0.09394501f, 0.09820253f, -0.09094296f, 0.07461391f, -0.02164692f, 
    0.18541351f, -0.15804760f, -0.08223605f, -0.07292589f, 0.22040787f, 0.01102143f, 0.14314440f, -0.18577446f, 
    0.00016738f, 0.18988481f, -0.07597878f, 0.04871524f, 0.14522311f, -0.12753464f, 0.07589959f, 0.00408317f, 
    0.01223393f, -0.33260688f, -0.13293116f, 0.09290247f, -0.08237380f, 0.12329365f, -0.09571615f, 0.03410824f, 
    0.18884274f, -0.19384494f, -0.11877318f, -0.24197780f, 0.30769494f, 0.00083137f, 0.28885469f, -0.13322289f, 
    0.01480273f, -0.00990633f, -0.06600251f, -0.13805525f, -0.35370556f, 0.02329857f, -0.25369880f, -0.20544837f, 
    0.30562904f, -0.10233825f, 0.16346331f, 0.08753187f, 0.23267549f, 0.41892335f, 0.19068301f, -0.14109987f, 
    0.13305479f, -0.14470722f, 0.02212194f, 0.14991711f, 0.06851287f, 0.41476870f, 0.00891012f, -0.03280827f, 
    -0.16727462f, 0.18963404f, 0.00133021f, 0.10027039f, -0.16739415f, -0.04783565f, 0.39040771f, 0.06567381f, 
    0.11091604f, 0.12567538f, -0.04672954f, 0.23072934f, 0.06613872f, 0.04050978f, -0.11006044f, 0.25917572f, 
    0.26391116f, -0.25293523f, 0.20664597f, -0.16024543f, -0.23020768f, 0.03510244f, 0.04809953f, 0.00581638f, 
    0.18152680f, -0.16864787f, -0.37367165f, -0.03620581f, -0.14965872f, 0.03876050f, 0.12165257f, 0.03200952f, 
    0.01159433f, 0.01371000f, -0.16136244f, 0.17590064f, 0.30484322f, 0.15628488f, -0.17428449f, -0.02627476f, 
    -0.03383436f, -0.08584476f, 0.12440541f, -0.11631429f, 0.02829285f, -0.14108467f, -0.13359743f, 0.17563364f, 
    0.00012375f, 0.14729986f, 0.05916006f, 0.10189439f, 0.31180248f, -0.05967827f, 0.18457022f, 0.01284483f, 
    -0.20650679f, -0.08643541f, 0.24190718f, 0.04832558f, -0.13409697f, 0.08660433f, 0.11783925f, -0.00256277f, 
    0.07849941f, 0.00487116f, 0.09543556f, -0.04915444f, -0.13087402f, -0.47491968f, 0.02973627f, -0.22512284f, 
    0.11752366f, -0.09224153f, -0.11571498f, 0.00467022f, 0.21836822f, -0.06171482f, 0.11830510f, 0.15732180f, 
    -0.00809966f, -0.13935007f, 0.01998617f, -0.12103821f, 0.15475456f, -0.03767018f, 0.02721392f, -0.42726228f, 
    -0.37071335f, -0.10307882f, 0.13164377f, 0.05209780f, 0.20392127f, 0.08731609f, -0.02124269f, 0.15787499f, 
    0.32787153f, 0.02119298f, 0.19198139f, -0.22491482f, 0.05503312f, -0.18641402f, 0.06947123f, 0.08110546f, 
    0.03387490f, -0.17241524f, 0.06743102f, -0.14323957f, 0.22099736f, 0.16900580f, 0.15487172f, 0.14652558f, 
    -0.11819506f, -0.00620879f, 0.01990434f, -0.29562461f, -0.02399152f, -0.05343118f, 0.10447501f, 0.04329366f, 
    -0.11137590f, 0.20049179f, -0.24982253f, -0.33692589f, 0.09754760f, 0.10527245f, 0.32906681f, 0.06660737f, 
    0.17228059f, -0.14265129f, 0.08227137f, -0.13357359f, -0.26548925f, -0.05267721f, -0.17766246f, -0.25885934f, 
    -0.07066598f, -0.08887053f, 0.05201080f, 0.11919229f, -0.10020451f, -0.03113158f, 0.21538435f, 0.17943244f, 
    0.11506142f, -0.08143998f, 0.05225131f, 0.00374193f, 0.01031648f, 0.12045099f, 0.11476339f, -0.00301363f, 
    0.01648310f, 0.06361700f, -0.18339026f, 0.14729252f, -0.17917518f, 0.04492550f, -0.02076815f, -0.06364666f, 
    -0.25877833f, 0.11496146f, -0.22144274f, -0.08817083f, -0.05490908f, -0.02980523f, -0.22695740f, 0.07680901f, 
    -0.26902056f, -0.06670323f, 0.01769277f, 0.02865765f, 0.15999116f, 0.15916044f, 0.07132662f, 0.16290623f, 
    0.11646079f, -0.03717143f, -0.16258700f, 0.14572577f, 0.11382929f, 0.05896381f, -0.17799196f, 0.07126980f, 
    0.07067417f, -0.00611927f, 0.27699825f, 0.01352636f, -0.04859236f, -0.07275509f, -0.14771883f, -0.03848207f, 
    0.02933191f, -0.03356649f, 0.11349129f, 0.32193929f, 0.17763700f, 0.17750394f, 0.13864987f, -0.11712276f, 
    0.06382662f, 0.15744404f, -0.17623910f, -0.03357498f, 0.11402800f, 0.08512330f, -0.28753561f, 0.18365330f, 
    -0.16968857f, -0.04072779f, 0.03600692f, 0.09094061f, -0.04784315f, 0.33158410f, -0.12211429f, -0.25173178f, 
    -0.26792914f, -0.19659880f, -0.00603693f, -0.06479087f, 0.11313462f, 0.03859224f, -0.50605690f, -0.21948650f, 
    0.19850808f, 0.05802413f, 0.10519513f, 0.24814762f, -0.01280226f, 0.09903169f, -0.01866101f, -0.00764458f, 
    0.29684737f, -0.02031274f, 0.10290591f, -0.04661950f, -0.13726692f, 0.10023344f, 0.11649429f, -0.04249246f, 
    -0.39604351f, -0.23723148f, -0.04145748f, 0.01090247f, 0.11639263f, -0.05583194f, 0.07989596f, 0.04053504f, 
    -0.06067646f, 0.20520368f, 0.03712942f, 0.01218125f, -0.08875127f, -0.18790981f, 0.09969661f, -0.05823804f, 
    0.34074181f, 0.10126897f, 0.21487640f, -0.09508539f, -0.00022139f, -0.08786263f, -0.07895622f, 0.20121302f, 
    0.19148237f, 0.02185383f, 0.10480634f, -0.12765971f, -0.25479233f, 0.10765576f, 0.31062165f, -0.23710331f, 
    -0.13275295f, 0.19303578f, -0.08872615f, -0.00620638f, -0.36274299f, -0.27182654f, -0.11556102f, 0.08313049f, 
    0.02767554f, 0.15659277f, -0.20906672f, 0.03940152f, 0.14962372f, -0.34250936f, -0.02798215f, -0.17629583f, 
    -0.34192383f, 0.08341203f, 0.17308459f, 0.19578683f, 0.03247689f, 0.04774492f, 0.12919937f, 0.00615226f, 
    0.24912699f, -0.13379021f, 0.00751117f, -0.26956663f, -0.05831140f, 0.02063333f, 0.13299574f, -0.11627972f, 
    -0.11590955f, 0.00776815f, 0.18160926f, -0.04485623f, 0.00206666f, -0.09646128f, 0.08427135f, -0.17135073f, 
    -0.09056124f, -0.30181691f, -0.16327149f, -0.30008176f, 0.24834093f, -0.04585357f, -0.02168877f, 0.11226469f, 
    0.02627990f, -0.00485141f, 0.18728328f, -0.16143872f, 0.15042841f, 0.22565047f, 0.08265727f, -0.02268603f, 
    -0.03239640f, -0.12706710f, -0.25786453f, -0.07127951f, -0.11125823f, -0.17195289f, -0.16885337f, -0.06073866f, 
    -0.10400621f, -0.02772851f, -0.02881048f, 0.32452539f, 0.48862794f, 0.09543959f, 0.24225996f, 0.05842825f, 
    -0.05458282f, 0.00568273f, -0.05055068f, 0.10147958f, 0.16904132f, 0.11870827f, 0.10227345f, 0.19598784f, 
    0.01258381f, 0.01954037f, -0.03340546f, 0.08230872f, 0.20819110f, -0.16829826f, -0.02439534f, 0.18007991f, 
    0.05995492f, 0.02116360f, -0.12788439f, 0.08860082f, 0.03890039f, -0.00769941f, -0.06453238f, -0.10315639f, 
    0.16986945f, 0.13413344f, -0.11672100f, -0.19289114f, -0.01291311f, -0.11074281f, -0.25016278f, 0.15588020f, 
    0.07971622f, -0.17372687f, 0.13063180f, 0.04837153f, -0.01240321f, -0.12799597f, -0.07261973f, 0.06037296f, 
    0.04049535f, -0.24239773f, -0.04780054f, -0.42511010f, 0.06969878f, -0.15846285f, 0.16820329f, -0.02265862f, 
    0.06287742f, 0.05171809f, -0.24960530f, -0.01392248f, -0.24246332f, 0.09898332f, -0.14987531f, 0.03957354f, 
    0.14674541f, -0.17437655f, 0.29315820f, -0.19268821f, 0.07163379f, -0.07258338f, 0.07888914f, 0.09611127f, 
    0.02132240f, -0.08898992f, -0.02651718f, 0.50644791f, 0.32471076f, 0.06643539f, 0.13072838f, 0.13585760f, 
    0.21319978f, -0.00733036f, 0.05938155f, -0.09908662f, 0.06271617f, 0.21150824f, -0.02718290f, -0.17473593f, 
    0.02915316f, -0.21391532f, -0.02219194f, 0.15439421f, 0.12169572f, 0.23663440f, 0.06726190f, 0.05975783f, 
    -0.21154663f, -0.06640276f, -0.00539856f, 0.03541819f, 0.08787317f, -0.11324260f, -0.10147060f, 0.13631538f, 
    0.12377541f, -0.05629412f, 0.10008351f, -0.16341524f, 0.01514766f, 0.15215664f, 0.06349912f, -0.11875169f, 
    -0.05920528f, -0.01514103f, -0.17489639f, -0.21382993f, 0.03706692f, -0.21794181f, -0.16896586f, -0.08820314f, 
    0.19964907f, 0.01478727f, 0.05869486f, 0.04736271f, 0.09130350f, 0.09773558f, 0.17246623f, 0.07691286f, 
    -0.02274514f, -0.18865199f, -0.00729385f, 0.16238107f, 0.03873385f, -0.04988066f, -0.02008687f, -0.07698505f, 
    0.11469831f, -0.24563955f, 0.67192090f, 0.27201185f, 0.07015138f, 0.12206615f, 0.13353436f, -0.16289006f, 
    -0.02117638f, -0.00440441f, 0.02804998f, -0.11428978f, -0.32874042f, -0.27273488f, 0.12566414f, 0.07550504f, 
    0.10452800f, -0.12595172f, -0.01210190f, -0.05976551f, -0.23971808f, -0.10409427f, 0.19975953f, -0.05538044f, 
    0.05621069f, 0.11844940f, -0.00721057f, 0.01186420f, -0.12641612f, -0.69916278f, -0.02760551f, -0.07794702f, 
    0.25396174f, 0.01279140f, 0.11853143f, -0.13712563f, -0.01917011f, 0.01181864f, -0.35932934f, 0.13519849f, 
    -0.20027399f, -0.09359793f, 0.09508036f, 0.05363986f, -0.03755314f, -0.08730988f, -0.09619019f, 0.36791217f, 
    0.13289246f, -0.04239300f, -0.04720804f, -0.03275729f, 0.12951420f, 0.12957294f, 0.02752429f, 0.13999069f, 
    0.02413860f, 0.19830041f, -0.46661949f, 0.15873662f, 0.02507288f, 0.20444392f, -0.01566480f, -0.01987297f, 
    0.01483058f, -0.02763198f, -0.00361064f, 0.16666970f, 0.17246650f, 0.10808800f, 0.08330131f, 0.07885860f, 
    -0.12356646f, 0.05595084f, 0.06245087f, 0.21218222f, -0.12555799f, -0.01796369f, -0.10964218f, 0.27871838f, 
    -0.01543461f, -0.09430243f, 0.11779772f, -0.17263064f, 0.07826479f, 0.09847911f, 0.10879533f, -0.03892658f, 
    -0.02081966f, 0.00538302f, 0.08328678f, 0.00422664f, 0.17670113f, -0.22621615f, -0.25520313f, 0.01882806f, 
    0.04654629f, -0.15703386f, -0.07599261f, 0.09656420f, 0.00473841f, 0.05750564f, -0.05274527f, 0.29927787f, 
    0.06218661f, -0.06052472f, -0.01744073f, 0.02002638f, -0.06102248f, 0.00311839f, -0.05350242f, -0.10858581f, 
    0.04374632f, -0.11382844f, 0.02852859f, -0.06307654f, -0.02423772f, -0.14219585f, 0.00853257f, 0.12293607f, 
    0.11853735f, -0.36992452f, 0.10966934f, -0.14886278f, -0.05091850f, 0.04377159f, -0.02056385f, -0.11829665f, 
    -0.00004373f, -0.20050256f, -0.13720724f, -0.03250121f, -0.05275920f, -0.14374198f, 0.04884325f, -0.01297375f, 
    0.13519825f, 0.31886601f, 0.02235240f, 0.30990669f, -0.04457699f, -0.04789625f, 0.01543764f, 0.10747853f, 
    -0.08428564f, -0.06224979f, 0.24072145f, 0.25442854f, -0.34549534f, -0.11519185f, -0.10967974f, 0.12410111f, 
    -0.02028850f, -0.07426768f, -0.10479895f, 0.43144745f, 0.15528105f, -0.08032309f, -0.33181351f, 0.10107781f, 
    -0.01045319f, 0.05593731f, 0.06116156f, 0.05019947f, 0.45020089f, 0.10224007f, -0.31468722f, -0.10929230f, 
    0.08475643f, -0.19177023f, 0.16162947f, 0.05542080f, 0.21831509f, 0.13317759f, -0.04778788f, 0.12541126f, 
    -0.06318551f, -0.08888093f, -0.08153982f, -0.06854652f, 0.09132759f, -0.05373916f, 0.16234052f, -0.36953530f, 
    -0.06084382f, 0.02751848f, -0.12636925f, 0.14091849f, -0.12951441f, -0.04336803f, -0.22614218f, -0.55649054f, 
    -0.08027861f, 0.17713536f, -0.01583067f, 0.25426903f, 0.01807641f, -0.23810756f, -0.01475251f, 0.05265572f, 
    -0.08428045f, -0.02078748f, -0.11539973f, 0.09717876f, 0.10713232f, 0.02260143f, 0.03774927f, 0.02246177f, 
    0.15859699f, -0.19977446f, 0.25309038f, 0.05068745f, 0.01135651f, -0.05108278f, -0.14992821f, 0.10240270f, 
    0.01163331f, 0.15779479f, -0.49430683f, 0.05099626f, -0.08347913f, 0.08729288f, -0.02678500f, 0.00769883f, 
    -0.04519455f, 0.00050219f, -0.13368618f, -0.18279366f, -0.04991132f, 0.03427562f, -0.13716543f, 0.23518705f, 
    0.11975234f, -0.11628118f, 0.04243853f, 0.06643026f, 0.05871220f, -0.20470586f, 0.04888294f, -0.02836094f, 
    0.09235638f, 0.00640563f, 0.11395362f, -0.09522755f, -0.08654560f, 0.26129627f, -0.33422422f, -0.03458386f, 
    -0.03192109f, -0.03796216f, -0.02873164f, -0.05957138f, 0.04062559f, 0.07372051f, 0.18906507f, 0.05051719f, 
    -0.22869201f, -0.08586399f, 0.09495860f, 0.04926364f, -0.08063176f, -0.00745072f, -0.09310289f, 0.25599611f, 
    0.08015905f, -0.02987371f, 0.10411639f, 0.01614293f, 0.16039076f, -0.05093464f, 0.09692539f, -0.17280743f, 
    0.23736027f, 0.28346837f, -0.16697864f, 0.19267567f, -0.04003404f, -0.15423560f, 0.20701645f, 0.09044909f, 
    0.18434834f, 0.03000592f, -0.20437045f, 0.08366989f, -0.14551429f, -0.06067061f, 0.09959517f, -0.02193751f, 
    0.05128452f, -0.04033601f, -0.09693774f, 0.18013626f, -0.35939413f, 0.16005051f, 0.07609034f, -0.14328986f, 
    -0.02798442f, -0.04126056f, 0.00825650f, -0.01397503f, 0.00964535f, 0.39554822f, -0.13231127f, -0.35196811f, 
    0.09998274f, -0.15590100f, 0.11990162f, 0.08606676f, -0.35440272f, -0.04606940f, 0.32551092f, -0.09649412f, 
    0.16266865f, 0.08119465f, -0.06248203f, -0.07899941f, 0.03004683f, 0.03329908f, -0.12853150f, -0.10086022f, 
    0.08915991f, 0.17530693f, 0.05567766f, -0.14485547f, 0.10890982f, -0.15425760f, -0.08568840f, 0.04731811f, 
    0.04680041f, 0.16995856f, 0.00090086f, -0.08246087f, -0.06151911f, 0.06806711f, -0.04290919f, 0.09868217f, 
    -0.20318760f, -0.32702386f, 0.06206959f, 0.07903516f, -0.00250634f, -0.15252693f, -0.04138218f, -0.15027614f, 
    0.19210094f, 0.27318653f, 0.02841328f, 0.06652848f, 0.00156027f, 0.01633666f, 0.04143093f, 0.12280191f, 
    -0.01688240f, -0.07745953f, 0.11894031f, -0.09474740f, 0.08166313f, 0.11659999f, 0.20674957f, -0.04196868f, 
    -0.05503219f, 0.12275870f, 0.04533024f, 0.03778745f, -0.25766563f, -0.26965740f, 0.18260826f, 0.12953313f, 
    0.00573674f, 0.03206637f, -0.12972181f, 0.11883090f, -0.42332712f, 0.03134384f, -0.11874513f, 0.05336473f, 
    0.16410634f, -0.27374604f, 0.06744082f, 0.07897479f, 0.11633322f, -0.07339417f, 0.21674067f, -0.02496967f, 
    -0.14323208f, 0.12274005f, -0.08334377f, 0.06555958f, -0.11651508f, 0.19179411f, 0.23877351f, -0.07759279f, 
    0.14574362f, 0.10566679f, -0.09214280f, -0.06223075f, 0.04816236f, 0.04984640f, -0.01951120f, 0.02801608f, 
    -0.30529875f, -0.02893869f, 0.00758698f, 0.02786620f, -0.04483519f, -0.25213453f, -0.07757919f, 0.18004419f, 
    0.07394926f, -0.23005410f, 0.11116242f, 0.13034442f, -0.38223842f, 0.11770392f, -0.07233135f, 0.03234748f, 
    -0.11717039f, 0.05011946f, 0.06903713f, 0.14126942f, -0.00320437f, -0.07482464f, 0.01553089f, 0.08949992f, 
    0.10987116f, 0.20986937f, 0.01064510f, -0.09296120f, 0.02359169f, -0.00379561f, 0.21835537f, 0.06671482f, 
    0.22109921f, 0.16363783f, -0.34229133f, -0.24113348f, 0.01185623f, 0.15704216f, -0.03361951f, 0.10936197f, 
    -0.07103174f, -0.02582687f, -0.00865708f, 0.32395396f, 0.22633025f, 0.07590947f, -0.04733546f, 0.00167838f, 
    -0.02013033f, 0.14604297f, 0.00401453f, 0.05660217f, 0.15481257f, -0.13477439f, 0.27787390f, 0.12386297f, 
    0.12906681f, 0.01417214f, 0.00494965f, 0.18319201f, 0.12671156f, -0.12413561f, -0.07465120f, -0.32577506f, 
    -0.04410193f, -0.00828086f, -0.08986419f, 0.11957148f, -0.03749747f, 0.00756682f, 0.10365278f, 0.32631722f, 
    -0.09450655f, -0.02657055f, -0.14031786f, -0.02671413f, 0.05590093f, -0.01526692f, -0.01299730f, -0.79896516f, 
    -0.03393042f, -0.23936361f, 0.17704797f, 0.07003021f, -0.12110919f, 0.10667591f, 0.13767780f, 0.14037877f, 
    0.09065879f, 0.22463690f, 0.28259614f, 0.03430736f, 0.08405051f, 0.07281952f, -0.24745187f, -0.06875149f, 
    -0.18228561f, -0.18749370f, -0.16092266f, 0.00825719f, 0.03972256f, 0.02392197f, 0.13808751f, 0.06929665f, 
    0.14673950f, 0.14624697f, -0.44893152f, -0.08277510f, 0.25293788f, 0.01068107f, -0.00800376f, 0.12769634f, 
    -0.25862113f, 0.02535437f, -0.04780163f, 0.14908747f, -0.10408906f, -0.19285090f, -0.07721397f, 0.14083491f, 
    0.00466429f, 0.07857138f, 0.01060278f, -0.08242647f, 0.03157680f, 0.08860415f, -0.07988219f, 0.21788600f, 
    -0.15442877f, -0.12388447f, 0.02686592f, 0.04735145f, -0.02229942f, 0.14465837f, -0.15629782f, -0.15270312f, 
    -0.03800618f, 0.10604015f, 0.00927796f, 0.15290701f, -0.05770452f, -0.12813506f, 0.06953125f, 0.00885177f, 
    -0.28853646f, -0.02346596f, 0.23303527f, -0.19258708f, -0.13854355f, 0.09008839f, -0.23678139f, -0.06475918f, 
    -0.01275570f, -0.06743905f, 0.11068879f, -0.15222827f, 0.12639365f, 0.01811622f, -0.24749973f, 0.13146926f, 
    -0.06620304f, -0.14168490f, -0.09568236f, -0.05818940f, -0.15394193f, -0.05234462f, 0.02198272f, 0.01335688f, 
    -0.18572809f, 0.17919096f, 0.14091563f, 0.07993712f, -0.13310352f, -0.15058613f, -0.30226192f, 0.04717543f, 
    0.11092700f, 0.06389815f, -0.47610778f, -0.20411316f, -0.03378332f, 0.12285231f, -0.03281897f, -0.00843960f, 
    0.05074924f, 0.04154280f, -0.06198939f, 0.20007229f, 0.04251860f, 0.09414177f, 0.12609684f, -0.23852378f, 
    0.13089551f, 0.05174166f, 0.20379694f, -0.00689895f, -0.23485717f, 0.19834970f, -0.04159888f, 0.20636652f, 
    0.11336520f, 0.17792301f, 0.12830879f, 0.10857396f, 0.17317820f, 0.18585667f, -0.09981433f, -0.18495351f, 
    0.02894607f, 0.06764232f, -0.05631401f, 0.03089710f, -0.06313435f, 0.16558132f, -0.04524739f, 0.07758416f, 
    0.16987252f, 0.09905932f, -0.08995549f, -0.10705649f, -0.07349680f, 0.03738821f, 0.10115507f, -0.38076508f, 
    -0.24672915f, 0.05641999f, -0.25662652f, -0.02446780f, 0.07303537f, -0.07426674f, 0.01717738f, 0.03740566f, 
    0.41032922f, -0.18477809f, 0.19586748f, 0.05782281f, 0.05837115f, -0.05940402f, 0.04575427f, -0.06760465f, 
    0.16755088f, 0.07063735f, -0.19360176f, -0.09251265f, -0.19995157f, -0.01951105f, 0.12309421f, 0.10687208f, 
    0.01674272f, -0.29044387f, 0.23674184f, -0.07334681f, 0.34525803f, -0.07715020f, 0.09149975f, 0.02300360f, 
    -0.01586198f, -0.08526049f, -0.35873348f, 0.36232126f, -0.03826274f, 0.28728166f, 0.09188857f, -0.15915702f, 
    -0.02301762f, -0.08156468f, 0.07367866f, -0.01651686f, 0.14402455f, 0.10839058f, 0.13905674f, 0.07838376f, 
    -0.00568075f, 0.03446722f, -0.16648133f, -0.12083564f, -0.03037722f, 0.13854094f, 0.42358109f, -0.36679101f, 
    0.05349412f, 0.07720073f, 0.09280632f, 0.00774324f, -0.14644724f, 0.12346064f, -0.06402162f, -0.07405718f, 
    0.02990908f, -0.30709127f, -0.11842237f, 0.12632644f, -0.01330033f, 0.07101603f, 0.22483020f, 0.02927526f, 
    -0.20499176f, 0.14530151f, -0.01209060f, 0.04007987f, -0.19172747f, -0.02866508f, 0.11609936f, 0.04716538f, 
    -0.49866655f, -0.13702776f, -0.31008205f, 0.01402761f, -0.02667107f, -0.11309194f, 0.08001436f, 0.00064879f, 
    -0.01064844f, 0.20758376f, 0.29273608f, 0.16764505f, -0.24620512f, 0.09606244f, 0.02837333f, -0.02255997f, 
    -0.02221319f, 0.14682494f, -0.18032551f, -0.02451917f, -0.13696806f, 0.12056459f, 0.03458173f, -0.00438864f, 
    0.05037188f, 0.01794831f, -0.03572190f, 0.17815340f, -0.05717307f, 0.50740695f, -0.08397903f, 0.03955487f, 
    0.00187749f, 0.04748187f, -0.10165402f, 0.01132465f, -0.07423671f, -0.04818339f, 0.11040136f, -0.12752797f, 
    0.11390364f, 0.00073888f, 0.00465143f, 0.09823328f, -0.08873932f, 0.27418029f, 0.06656045f, -0.02776782f, 
    -0.06298318f, -0.15586206f, -0.10303161f, 0.22953552f, 0.03184637f, 0.02461606f, -0.24588944f, -0.02332208f, 
    0.19514726f, 0.10738207f, 0.13234907f, 0.02797786f, 0.04371836f, 0.14164315f, -0.03299423f, 0.00612337f, 
    0.24218605f, 0.25139672f, 0.11222085f, -0.06438082f, -0.15099415f, 0.01951910f, -0.07925988f, 0.14954388f, 
    -0.32815915f, -0.08593240f, -0.32589027f, -0.08928248f, 0.09529590f, -0.02199216f, 0.02646804f, 0.10770386f, 
    0.14355049f, 0.24750490f, 0.00209525f, 0.21487349f, 0.18423103f, -0.03672126f, -0.08332340f, -0.04487307f, 
    0.13130672f, 0.18379556f, -0.12388764f, -0.06144122f, -0.13147050f, 0.06395993f, 0.14057927f, 0.02698739f, 
    0.10924961f, 0.06991387f, -0.02329267f, 0.42489991f, -0.54269975f, 0.04343313f, -0.14410464f, 0.14885156f, 
    -0.05519576f, -0.01357655f, 0.02478152f, 0.19007777f, -0.39835012f, 0.42548311f, 0.00344325f, -0.02352591f, 
    -0.03999445f, -0.02494131f, -0.04493833f, -0.00244255f, 0.00810152f, -0.33909351f, 0.14278910f, -0.60549992f, 
    0.09253582f, -0.19089161f, -0.06589421f, -0.10680321f, 0.04594797f, -0.07225431f, 0.06723159f, -0.28740975f, 
    -0.08599089f, 0.08449793f, -0.04309100f, 0.06363294f, 0.05141005f, -0.12536205f, -0.17960851f, 0.12329853f, 
    0.35007083f, -0.47182354f, 0.08260357f, 0.03497157f, -0.08585990f, -0.03967728f, -0.07495753f, -0.16706283f, 
    0.03905962f, -0.06884118f, -0.00026782f, 0.06011815f, -0.05772565f, 0.07331053f, -0.06040338f, -0.04741813f, 
    -0.07681634f, 0.01691793f, -0.07680932f, -0.08461786f, -0.07786067f, 0.02714794f, 0.04254846f, -0.00359441f, 
    -0.06222120f, -0.07068194f, -0.06239469f, 0.01421620f, -0.10861617f, 0.07719201f, -0.07388908f, 0.02701178f, 
    -0.12441069f, 0.02877507f, -0.05884116f, -0.12405110f, 0.00423469f, -0.01715370f, 0.03007684f, 0.02607887f, 
    0.01271722f, -0.09154431f, -0.04583874f, 0.06693944f, 0.01486003f, -0.08839729f, 0.03940404f, -0.10849355f, 
    -0.10403345f, -0.00421776f, -0.00137764f, -0.00341182f, 0.02938386f, 0.04818110f, -0.07053783f, -0.05764222f, 
    -0.03125955f, 0.05802273f, -0.05744320f, -0.01759588f, -0.03906466f, 0.04027536f, -0.04280501f, -0.03085525f, 
    -0.00602317f, 0.02764407f, -0.02921048f, 0.03660957f, -0.08505607f, -0.11606385f, -0.06679178f, -0.06987878f, 
    -0.09507918f, -0.07204573f, -0.04638512f, 0.02250247f, -0.05609386f, -0.01083722f, 0.02846764f, 0.00488890f, 
    -0.11541419f, -0.10890520f, 0.01343345f, -0.02081405f, -0.07206827f, 0.05993024f, -0.05060775f, -0.02863047f, 
    -0.00838788f, 0.03954290f, -0.06988186f, -0.05185768f, 0.05506908f, 0.00973715f, -0.08830354f, 0.06165852f, 
    -0.08513734f, 0.02096766f, -0.01594581f, -0.07824626f, -0.03042203f, -0.09128006f, 0.01578062f, -0.08499594f, 
    -0.02359598f, -0.05588715f, 0.00184992f, -0.07699654f, 0.07355846f, 0.02330614f, -0.00921983f, -0.02293740f, 
    0.04391839f, -0.10320266f, -0.01229715f, -0.07235441f, 0.03757742f, -0.09230323f, -0.03594004f, -0.02255861f, 
    0.05105746f, 0.04536643f, -0.09696820f, 0.02794285f, -0.03283362f, 0.00000492f, -0.02791967f, -0.08774089f, 
    0.00267965f, -0.01293054f, 0.01778788f, -0.00839614f, -0.07309721f, 0.01258045f, -0.05295807f, -0.01157546f, 
    0.01308205f, -0.07231809f, 0.00960715f, -0.10028020f, 0.03841430f, -0.02207426f, -0.07077551f, -0.11690279f, 
    -0.08156487f, -0.03150988f, 0.07821131f, 0.03415508f, -0.04989070f, -0.03617287f, -0.01604103f, -0.00405357f, 
    0.02802776f, 0.01404875f, 0.02392585f, -0.00698263f, -0.04240019f, -0.07937701f, 0.00593850f, -0.04557137f, 
    -0.01694750f, 0.02225625f, -0.03819850f, 0.00302247f, -0.04503324f, -0.06195381f, 0.04754492f, -0.07908288f, 
    -0.06848224f, -0.00725483f, 0.01004432f, -0.06054082f, -0.03621763f, 0.03331111f, 0.00604484f, 0.06432819f, 
    0.00959481f, -0.01455483f, -0.05155225f, 0.02974853f, -0.08267979f, -0.07339179f, 0.01575828f, 0.00540096f, 
    0.08981437f, -0.02015365f, 0.06956979f, -0.01890094f, -0.03015376f, -0.03461092f, 0.02488110f, -0.07062091f, 
    -0.06048726f, -0.01398052f, 0.01694201f, -0.07981096f, -0.03942289f, -0.02772976f, -0.10769967f, 0.05516629f, 
    -0.01777324f, -0.07372828f, 0.05392770f, 0.05848480f, -0.05781826f, 0.06275037f, -0.02871252f, 0.07311745f, 
    0.00316788f, 0.03016373f, 0.03903517f, -0.09984397f, -0.03427150f, 0.03520291f, -0.00051962f, -0.02144888f, 
    -0.06455403f, -0.09688193f, 0.03789447f, 0.05080000f, 0.01219975f, 0.07442129f, -0.07401396f, -0.07067850f, 
    -0.06527253f, -0.03495671f, -0.02433135f, 0.04205716f, -0.08583578f, 0.03813950f, 0.05573383f, -0.05549010f, 
    0.00571602f, -0.00018896f, -0.01196523f, -0.06502355f, -0.02278085f, 0.06516983f, 0.08093657f, -0.02169234f, 
    -0.06665988f, -0.04110142f, 0.03977548f, -0.00005865f, -0.02270619f, -0.01626849f, -0.03024153f, 0.02376997f, 
    -0.03457003f, -0.07203282f, -0.07068456f, -0.08855266f, -0.01671540f, -0.03931472f, 0.08173747f, -0.07543904f, 
    -0.02973079f, -0.00544335f, -0.07748714f, -0.05981260f, -0.04528030f, 0.00149764f, 0.05176600f, -0.00357508f, 
    0.00850201f, 0.05049073f, 0.05528333f, -0.08195993f, -0.01004433f, -0.02045904f, -0.01143418f, -0.04550837f, 
    -0.07287298f, -0.02482095f, -0.00755496f, 0.07874874f, 0.02308983f, -0.04579922f, 0.06724764f, 0.04270571f, 
    0.07595754f, -0.00300495f, -0.03308291f, -0.04337788f, -0.11006266f, -0.08769530f, -0.05259374f, -0.03299443f, 
    0.05434419f, 0.06405299f, -0.08925248f, -0.00746328f, -0.06481214f, -0.06896269f, -0.02197416f, -0.03975208f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.14461192f, -0.00388369f, 0.11641413f, 0.01355551f, 0.16128653f, 0.10874871f, 0.15199165f, -0.10780632f, 
    -0.09076703f, -0.00619874f, 0.09496322f, 0.07352031f, 0.00286966f, 0.05017369f, 0.01753655f, -0.04354206f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.37039676f, -0.12547573f, -0.22012174f, 0.22969314f, 0.47820270f, 0.04484572f, -0.30729109f, -0.17758125f, 
    0.40673825f, -0.04747677f, 0.43268093f, -0.01381816f, 0.01022732f, -0.02111583f, -0.02751813f, 0.24077153f, 
    0.05256108f, 0.09439991f, 0.36387372f, 0.18696338f, 0.33181289f, 0.05894695f, 0.14460589f, 0.42135403f, 
    -0.17697068f, -0.19919616f, 0.16326392f, -0.24522869f, -0.15186037f, -0.27152213f, 0.08866084f, -0.11182043f, 
    0.20975718f, -0.07807960f, 0.23535140f, 0.35059351f, -0.22002767f, -0.35600278f, 0.31501922f, 0.01078880f, 
    0.22010203f, -0.11168098f, -0.09829551f, 0.08509018f, -0.10474752f, 0.32577172f, -0.08727670f, -0.06027798f, 
    0.01238040f, 0.09036674f, -0.21358341f, 0.31204078f, -0.26799959f, -0.31663439f, 0.25622174f, -0.18639763f, 
    0.13963719f, 0.41427800f, 0.16771893f, 0.22884952f, -0.00893424f, 0.18297732f, 0.05917795f, -0.24169579f, 
    0.29284745f, 0.14219385f, -0.13203482f, 0.02424429f, -0.13455507f, -0.40982115f, -0.30102757f, 0.40198559f, 
    0.30674839f, 0.35686558f, 0.18980807f, -0.05921256f, 0.02694542f, -0.65071851f, 0.11572138f, 0.11500039f, 
    -0.34993824f, 0.04403654f, -0.10921533f, 0.51618981f, 0.14122988f, 0.39743263f, 0.13494776f, 0.04139171f, 
    0.56616127f, 0.07531830f, 0.03838596f, -0.31620276f, -0.22232106f, -0.28266138f, -0.06303505f, -0.16069476f, 
    -0.86920327f, 0.18775770f, 0.55451471f, 0.08024203f, -0.11097249f, -0.73552746f, 0.26822618f, -0.17712437f, 
    0.32197717f, 0.18500358f, 0.22303149f, 0.14398824f, -0.45248815f, 0.20436923f, 0.14387459f, -0.02390283f, 
    -0.50339991f, 0.17595026f, 0.51291525f, 0.47783577f, 0.11886922f, -0.01506019f, 0.02272943f, 0.40126204f, 
    0.18967339f, -0.12900101f, 0.46769983f, -0.33859277f, -0.03145913f, -0.22381532f, 0.07346967f, 0.12929335f, 
    -0.18120183f, -0.24085873f, -0.59328073f, 0.08923137f, 0.18773894f, -0.41224793f, 0.08682448f, -0.03073888f, 
    -0.26497516f, 0.47831848f, 0.27499828f, 0.51891172f, -0.11985923f, -0.10718741f, -0.22910011f, -0.23757257f, 
    0.19746771f, -0.23652841f, 0.36431453f, 0.06418905f, 0.30496916f, -0.32122380f, 0.41306159f, -0.30180901f, 
    0.09411445f, -0.52852601f, -0.34932938f, 0.11510041f, 0.35042661f, -0.42790017f, -0.17568929f, 0.05442125f, 
    -0.07197485f, -0.23494840f, 0.04243089f, 0.36661422f, 0.31304121f, -0.21109089f, 0.29412666f, 0.06424394f, 
    -0.29850516f, -0.09608170f, -0.24230540f, 0.36045098f, -0.23598452f, -0.06625827f, 0.12812792f, 0.01829249f, 
    -0.48553512f, -0.22839490f, -0.41917157f, 0.35068813f, 0.04390832f, 0.17149830f, -0.52243018f, 0.27846685f, 
    -0.15669423f, 0.21774973f, 0.15911905f, -0.08683457f, 0.55806327f, 0.34991336f, -0.08374452f, 0.16452548f, 
    0.02514072f, -0.17567910f, -0.28765398f, 0.59444302f, 0.35177276f, 0.45820662f, 0.09260418f, -0.17186296f, 
    0.62694722f, 0.12043493f, -0.24091026f, -0.32440519f, -0.30927312f, -0.29090339f, -0.19392160f, 0.26985842f, 
    -0.46632484f, -0.13605025f, -0.35013741f, -0.05415963f, -0.13829991f, 0.00792654f, 0.23772879f, -0.13809134f, 
    -0.10378721f, -0.41615134f, -0.07064401f, 0.25917819f, 0.45983389f, 0.06337123f, 0.04311129f, -0.04516220f, 
    -0.09670382f, 0.16811901f, 0.04057910f, -0.13080536f, -0.28848734f, 0.44372037f, -0.05709082f, -0.29474530f, 
    0.19084400f, 0.04577210f, -0.09624010f, -0.36957672f, 0.32800692f, -0.07757335f, -0.12972179f, 0.15729216f, 
    0.20033088f, 0.14117227f, -0.39514971f, -0.26766813f, -0.04937563f, -0.00590475f, 0.24312808f, -0.41335356f, 
    -0.43062916f, 0.43200219f, 0.05582287f, 0.43525767f, 0.13120510f, 0.31667805f, 0.18660896f, -0.13424645f, 
    -0.31753716f, -0.07968765f, -0.08164146f, 0.12086077f, 0.38014811f, 0.18528233f, -0.09017368f, -0.31646854f, 
    0.48632878f, 0.28644168f, 0.48005351f, -0.22588514f, -0.28341496f, -0.25657672f, -0.09905132f, -0.08533438f, 
    -0.22803175f, -0.13783431f, -0.48669910f, 0.01794471f, -0.05782650f, 0.30273399f, -0.03649265f, 0.18674402f, 
    0.26029310f, 0.46035814f, 0.15549138f, 0.23195855f, -0.20565182f, 0.23650864f, 0.17430283f, 0.04445041f, 
    0.25017267f, -0.03438019f, 0.08439093f, 0.06945535f, -0.38110417f, -0.05411164f, 0.27954018f, -0.14913937f, 
    0.13208771f, 0.37300864f, -0.46081305f, 0.26577553f, 0.11173092f, -0.25136077f, -0.00169512f, -0.03782356f, 
    0.50211138f, -0.07384691f, 0.12157320f, 0.24990071f, -0.04339324f, -0.44010442f, 0.38294256f, 0.51678926f, 
    -0.14848380f, -0.21442364f, -0.31918472f, -0.05704887f, 0.42391643f, 0.27424449f, 0.26809785f, 0.14588623f, 
    0.12764165f, -0.15538111f, 0.22694452f, -0.41639718f, 0.15658572f, -0.33352071f, 0.29871133f, -0.47123969f, 
    -0.04796610f, -0.46034071f, 0.06452644f, -0.24421178f, -0.13077751f, 0.52994627f, 0.00829874f, 0.04342012f, 
    0.30006561f, 0.07792599f, 0.37995097f, 0.29732195f, 0.01590711f, -0.49278417f, 0.30224276f, -0.12648346f, 
    0.06772155f, -0.36747420f, 0.17966087f, -0.30857432f, 0.00449044f, 0.38979888f, 0.17808689f, 0.11184324f, 
    0.19355248f, -0.02033094f, 0.04162456f, 0.32662514f, -0.16952804f, -0.15832697f, 0.27480093f, 0.15996937f, 
    -0.16524358f, 0.11701363f, -0.20813505f, -0.12552632f, 0.31843415f, -0.12237420f, 0.00569157f, -0.09152935f, 
    -0.12821350f, 0.13665712f, -0.42457291f, 0.15455526f, -0.23466428f, 0.54705185f, -0.05539268f, 0.17719537f, 
    0.31038758f, 0.06077690f, 0.35795307f, 0.14729060f, -0.19178101f, -0.13053989f, 0.09752645f, -0.19915634f, 
    0.00389240f, -0.21030110f, 0.37230021f, 0.31005177f, 0.42588741f, -0.05657029f, -0.21448608f, -0.28382170f, 
    0.27731180f, -0.48571873f, -0.11636963f, -0.06218882f, 0.13031553f, -0.19371362f, 0.16562063f, 0.10009833f, 
    -0.39162520f, 0.00361484f, 0.07848802f, 0.22050644f, 0.33365920f, 0.36420193f, 0.12485974f, -0.00673149f, 
    0.40621459f, -0.20238607f, 0.31677136f, -0.44731158f, 0.27469897f, -0.49070919f, -0.08432925f, -0.16794360f, 
    -0.27853677f, 0.03718673f, -0.25592205f, -0.33928427f, -0.07891019f, 0.54878163f, -0.11821942f, 0.19508255f, 
    0.04094714f, -0.08651038f, 0.66217011f, -0.18078157f, 0.33595061f, 0.09522604f, -0.05405657f, -0.16667420f, 
    -0.45808583f, 0.24773668f, 0.27824977f, 0.00088294f, 0.25728267f, 0.26387328f, -0.31039119f, 0.09842459f, 
    0.37367296f, 0.04640742f, 0.21008584f, 0.17390139f, -0.01999574f, -0.25322139f, 0.01876805f, 0.14742443f, 
    -0.21633972f, -0.18179208f, 0.02343401f, 0.05219937f, -0.07615748f, 0.23860033f, -0.04407972f, 0.46552873f, 
    -0.31096569f, -0.53353959f, 0.15392511f, 0.10546788f, 0.54444933f, 0.32444525f, 0.03409689f, -0.00205624f, 
    0.36162958f, -0.08591991f, -0.14458187f, -0.10468486f, -0.07066885f, -0.58268392f, 0.21038122f, 0.09976224f, 
    -0.48937789f, 0.40095860f, -0.00263413f, 0.36997887f, 0.01989145f, 0.40499276f, -0.21054614f, -0.14878060f, 
    -0.10327692f, -0.20459881f, 0.22206858f, -0.14566718f, 0.21433020f, 0.54218179f, -0.49206457f, -0.66698414f, 
    -0.11011721f, 0.27505153f, 0.29088375f, 0.17368211f, 0.10806800f, 0.01830699f, 0.13844992f, -0.00158099f, 
    -0.24873711f, 0.13549858f, -0.09900867f, 0.05999095f, 0.07685623f, 0.27261275f, 0.07139315f, 0.11303516f, 
    -0.52922112f, 0.00901653f, 0.11962111f, 0.49501556f, 0.63527763f, -0.04570530f, 0.16351378f, -0.05959637f, 
    -0.18041971f, -0.06836343f, -0.17085013f, 0.12949944f, -0.19661479f, -0.19343103f, -0.11829274f, 0.00820123f, 
    -0.01263161f, 0.20787159f, -0.24413380f, -0.06494062f, 0.13778016f, -0.20617053f, 0.12623510f, -0.06686601f, 
    0.13641301f, 0.19536409f, -0.08648844f, 0.08580936f, -0.12511227f, -0.10344972f, -0.09807264f, 0.16505161f, 
    -0.14860049f, 0.06277199f, 0.03695769f, -0.25966185f, -0.11607452f, -0.24830759f, 0.17463185f, 0.15969849f, 
    -0.00113606f, 0.09774366f, -0.26015523f, 0.06931943f, 0.33188239f, -0.07641403f, -0.39922935f, -0.19829775f, 
    0.06909454f, -0.42546019f, 0.22515602f, -0.01944017f, 0.57373291f, -0.33463195f, -0.14831126f, 0.15196940f, 
    0.27156958f, -0.10751469f, 0.30701488f, 0.15927720f, 0.39439249f, 0.28005743f, -0.28113309f, 0.30272079f, 
    0.25160250f, -0.23173682f, -0.24253780f, -0.24348705f, 0.04856055f, -0.18925908f, 0.18775813f, 0.19872083f, 
    -0.53854191f, 0.04583931f, -0.29654947f, 0.65643382f, 0.19093898f, -0.15743569f, -0.45182422f, 0.19856958f, 
    -0.21087876f, 0.18355089f, 0.03306243f, 0.01636817f, -0.20103604f, 0.03889698f, -0.20052788f, -0.17067724f, 
    -0.20448881f, 0.12372565f, 0.31034860f, 0.06317195f, 0.48384219f, 0.20174059f, -0.21914569f, 0.19884020f, 
    0.38157818f, -0.17221372f, -0.18331641f, -0.30434474f, -0.16050285f, 0.24595729f, -0.17051440f, -0.09256697f, 
    0.55326712f, 0.17781794f, -0.00525947f, 0.23257138f, 0.02236765f, -0.16698521f, 0.15561599f, -0.18422522f, 
    -0.27249908f, 0.18949932f, -0.45629585f, 0.33515421f, 0.07989848f, -0.38963732f, -0.05856521f, -0.21483320f, 
    -0.49291497f, -0.16075653f, 0.13114662f, 0.26688799f, 0.47211209f, 0.10598776f, 0.05350640f, -0.23564652f, 
    0.23733591f, 0.26944554f, 0.04351268f, -0.11899387f, -0.26486292f, -0.12203790f, 0.17505015f, 0.19101383f, 
    0.08634190f, -0.12772828f, 0.33534357f, 0.11572052f, -0.38643953f, 0.41964659f, -0.21494606f, 0.07221714f, 
    -0.20387122f, -0.09093182f, -0.40661749f, 0.25270340f, -0.11942130f, 0.04319825f, -0.12372357f, -0.12074524f, 
    0.16977888f, -0.02705142f, -0.05102438f, -0.22266039f, -0.09638534f, -0.02932101f, -0.23634815f, -0.09422895f, 
    -0.23082906f, -0.27942222f, 0.05232516f, 0.12683642f, -0.14534432f, -0.08435458f, -0.02598050f, 0.01884872f, 
    0.50489157f, -0.05705449f, -0.08107722f, 0.49646652f, -0.10843943f, -0.19169201f, 0.16817601f, -0.19440348f, 
    0.32238954f, -0.25498047f, -0.30809489f, 0.09822451f, 0.06668106f, -0.42712748f, 0.02002671f, 0.04886529f, 
    0.52501655f, -0.23018542f, -0.14042507f, 0.38147423f, -0.28432140f, -0.32747191f, 0.02994863f, 0.59628153f, 
    -0.13764955f, 0.20624889f, -0.28399801f, -0.02755235f, 0.43458894f, -0.12097638f, 0.12755716f, 0.18750849f, 
    -0.31103057f, 0.17093849f, -0.18974450f, -0.00835224f, -0.04577370f, 0.37822303f, 0.13039188f, -0.43767932f, 
    -0.24788895f, 0.18168339f, 0.17938735f, 0.42959666f, -0.25061110f, 0.32192242f, 0.12943605f, -0.19480863f, 
    0.06356926f, 0.05663309f, -0.05775454f, -0.28446355f, -0.01219685f, -0.19970170f, -0.18413895f, -0.21487837f, 
    0.05348125f, -0.02127932f, -0.03410701f, -0.17055921f, 0.04224990f, -0.11705891f, 0.21586815f, 0.05388886f, 
    -0.32393059f, -0.13566284f, -0.05519933f, -0.12153616f, -0.03901863f, 0.40261251f, 0.01679911f, 0.31086466f, 
    0.33544162f, 0.07633578f, 0.46606416f, -0.05717824f, -0.13741186f, 0.12735008f, -0.07533609f, 0.13743319f, 
    -0.28422898f, 0.17268339f, 0.12720510f, 0.21081372f, 0.22951624f, -0.31818321f, 0.28904533f, 0.17643821f, 
    -0.17512442f, 0.02791894f, 0.32838967f, -0.36265421f, 0.19761339f, -0.32055950f, 0.18733583f, -0.22783372f, 
    0.47853702f, -0.23000881f, 0.14770900f, -0.32964858f, 0.11009657f, -0.16941951f, 0.37308076f, -0.53849703f, 
    -0.01111729f, -0.60587585f, -0.03510566f, -0.19202542f, 0.04220520f, 0.19152957f, 0.14476027f, -0.06219632f, 
    -0.40722570f, -0.15433435f, 0.15880129f, -0.06162424f, 0.09542841f, -0.14660084f, -0.06532750f, -0.30421478f, 
    0.42455107f, -0.08191685f, 0.27556744f, -0.13878292f, -0.10124497f, 0.32667109f, 0.12495599f, -0.00073405f, 
    -0.36226517f, -0.18666738f, -0.07488281f, 0.39090246f, 0.00464658f, 0.13867925f, -0.38560921f, 0.46092078f, 
    -0.12388024f, 0.10350294f, -0.15807983f, 0.34095660f, 0.16261132f, -0.13026528f, -0.18597409f, 0.03455820f, 
    0.39732042f, 0.08420866f, 0.18617411f, 0.00539294f, 0.34395221f, -0.16056696f, 0.10846570f, 0.11238058f, 
    -0.09945694f, -0.38948056f, -0.47264817f, 0.35388067f, -0.11730780f, 0.09978468f, 0.06897832f, -0.14445414f, 
    0.49453166f, -0.12151837f, -0.29282942f, 0.12427541f, -0.22207564f, -0.30919874f, 0.12125440f, 0.14044690f, 
    0.03802159f, -0.18183322f, -0.22187912f, 0.44657147f, 0.50199634f, 0.50785303f, -0.20739143f, -0.18628123f, 
    0.38542718f, -0.10144377f, -0.11497568f, 0.27101836f, -0.18817261f, 0.13766403f, 0.25965875f, 0.69668067f, 
    0.05123910f, 0.21465106f, -0.22907712f, -0.37352097f, 0.17750010f, 0.09298795f, -0.21141152f, -0.16363759f, 
    0.00118512f, 0.23638991f, -0.20516720f, 0.15276612f, -0.32324490f, 0.23635286f, 0.38649085f, 0.30342120f, 
    -0.07002166f, -0.59147525f, -0.07283911f, 0.06166801f, -0.43242484f, 0.20942423f, 0.07031706f, -0.09302318f, 
    0.15232362f, 0.00520556f, -0.22168840f, -0.21543732f, 0.27509797f, -0.16785978f, 0.31482261f, 0.17285709f, 
    0.59807146f, -0.00583115f, 0.30495685f, -0.48495477f, -0.37066904f, 0.06251767f, -0.23108622f, 0.03817595f, 
    0.09133942f, -0.00757709f, 0.11125495f, 0.00999425f, -0.20941612f, -0.01420269f, 0.18804641f, -0.38655311f, 
    0.13875598f, 0.49341008f, -0.48115408f, 0.40420026f, -0.07938670f, -0.45511371f, 0.02590857f, -0.25520557f, 
    0.38536727f, -0.07175371f, 0.19395977f, -0.12351624f, 0.00846304f, -0.37104285f, 0.24951680f, -0.57239795f, 
    0.16318147f, -0.50832063f, -0.31204319f, -0.43661925f, -0.47148973f, 0.73219603f, 0.19540575f, -0.07084255f, 
    -0.26691586f, -0.07792313f, -0.56468368f, 0.32949635f, 0.22948809f, -0.29028597f, 0.38986531f, 0.43525940f, 
    0.02976008f, -0.20941499f, 0.03794413f, -0.19230329f, 0.13955954f, 0.30871770f, 0.11894397f, -0.20335060f, 
    0.31053352f, -0.10802295f, -0.41319585f, -0.12213902f, 0.29458266f, 0.43569762f, -0.20306313f, -0.42059255f, 
    0.21949476f, 0.46412683f, -0.24597134f, 0.29778010f, -0.12333238f, -0.18718556f, -0.14945765f, 0.17747970f, 
    -0.22998011f, 0.02835813f, 0.11497938f, 0.11347792f, 0.05006533f, -0.68369913f, -0.13988744f, -0.32874686f, 
    0.45327610f, -0.24329664f, -0.24474509f, 0.04006568f, 0.36910596f, 0.16984487f, -0.24008697f, 0.20131454f, 
    0.09159040f, -0.00147275f, 0.15778717f, -0.21079934f, -0.03826262f, 0.21678288f, -0.06969852f, -0.10359365f, 
    0.45980453f, -0.06470696f, -0.03468677f, 0.29262301f, -0.40735608f, 0.31673259f, 0.14150850f, -0.15464462f, 
    -0.23629883f, 0.18913653f, 0.22427499f, 0.11194089f, 0.03163898f, 0.29540691f, -0.11110087f, 0.03840343f, 
    0.22619165f, 0.06826229f, 0.39764893f, -0.36132276f, 0.16563489f, -0.23501715f, -0.23612732f, 0.15884006f, 
    -0.00256018f, 0.09534940f, 0.17441879f, 0.33816221f, -0.37174770f, 0.44531864f, -0.30991462f, 0.56116945f, 
    -0.34714380f, 0.27026364f, -0.07218114f, 0.23471172f, 0.20003150f, -0.35546967f, -0.01481850f, 0.16601214f, 
    -0.04143975f, 0.00714812f, -0.01433973f, 0.22927085f, 0.08834481f, 0.06590358f, -0.51139981f, 0.63338274f, 
    -0.05444849f, 0.19338872f, 0.06942853f, 0.14604354f, -0.02336608f, -0.20206280f, 0.12189210f, -0.21423352f, 
    0.41187838f, -0.24174228f, -0.42609563f, 0.08300070f, -0.05983552f, -0.21224077f, 0.05358763f, 0.23372823f, 
    0.18856141f, -0.36259246f, 0.30265251f, 0.07536747f, 0.36758974f, -0.74862063f, 0.10867205f, -0.05224054f, 
    0.24782993f, -0.06569356f, -0.05113894f, 0.07762631f, 0.08075861f, -0.47718945f, 0.27407780f, 0.20172369f, 
    -0.38760874f, 0.29277793f, 0.18621799f, 0.10441492f, -0.21225569f, -0.16222726f, -0.07222581f, -0.23467110f, 
    -0.43960094f, -0.05999315f, 0.01204418f, -0.09011313f, 0.58382368f, -0.30370477f, -0.26933956f, -0.26393995f, 
    0.31623209f, 0.54995745f, 0.11682599f, -0.06713338f, -0.23036453f, -0.44029763f, -0.07079817f, 0.13280042f, 
    0.13139160f, 0.02744236f, -0.22271599f, 0.03467276f, 0.15943791f, -0.30653131f, 0.51489252f, 0.30086952f, 
    -0.07914905f, -0.20233563f, -0.00655837f, -0.27934736f, -0.08298314f, 0.28705758f, 0.16727830f, 0.03631547f, 
    0.29550570f, 0.13102426f, -0.02084780f, -0.06367555f, 0.17195266f, -0.32383019f, 0.28428397f, -0.14690980f, 
    -0.20022087f, 0.06597712f, -0.20425019f, 0.04702420f, -0.47266448f, 0.36533377f, 0.15165636f, -0.23125717f, 
    0.01883678f, -0.24342291f, -0.03972285f, -0.32108435f, 0.43301848f, 0.22189485f, 0.16863593f, -0.47602573f, 
    -0.22826092f, 0.35939819f, -0.19147632f, 0.37699240f, -0.27943313f, 0.08161139f, -0.21358816f, 0.17572343f, 
    0.11091889f, 0.17611240f, 0.13213976f, 0.14832787f, 0.20923121f, -0.13005719f, 0.22777373f, -0.32721785f, 
    0.12871857f, -0.45427683f, -0.10797503f, 0.39823231f, -0.02530771f, -0.19688332f, 0.22975664f, 0.18775056f, 
    -0.34704262f, 0.07357019f, -0.21379788f, 0.33427116f, 0.43797883f, -0.11408681f, -0.09122951f, 0.02863018f, 
    -0.09410593f, -0.21483034f, 0.09837793f, 0.06314536f, 0.21108447f, -0.22620343f, -0.06678653f, -0.24816659f, 
    0.00929258f, -0.08597967f, -0.15599248f, 0.02083228f, -0.03932086f, -0.17409083f, -0.15809146f, 0.00833041f, 
    -0.22329912f, -0.20623928f, 0.22583114f, -0.20113504f, -0.03599509f, -0.18353462f, 0.18604523f, -0.15251955f, 
    -0.12675513f, -0.00256198f, 0.60469121f, 0.36116570f, -0.02321680f, 0.05351792f, 0.20994958f, 0.58958280f, 
    -0.26846674f, -0.20502079f, -0.36457279f, -0.14014708f, -0.17541333f, 0.07047519f, 0.14999957f, -0.12672810f, 
    -0.36334082f, -0.10696858f, -0.33788905f, 0.07709161f, 0.10867748f, -0.19419156f, 0.26247907f, 0.53324753f, 
    0.08024799f, -0.24708816f, -0.43545121f, -0.25603354f, 0.14789662f, -0.14890359f, 0.12947392f, 0.10809860f, 
    0.16330267f, -0.18364984f, -0.37570482f, 0.26500270f, 0.04978218f, 0.04404180f, 0.26534662f, -0.16437331f, 
    -0.09386121f, -0.17741904f, -0.16144368f, 0.24226968f, -0.08251121f, -0.03742928f, 0.15228008f, 0.05208364f, 
    -0.24440986f, -0.04044659f, -0.18978815f, -0.05610738f, 0.21032606f, 0.50491607f, -0.11946572f, -0.27027825f, 
    0.32224900f, 0.09247865f, 0.26643717f, 0.13090616f, 0.43700671f, -0.09264875f, -0.20664911f, 0.18626681f, 
    -0.39500567f, -0.08345851f, 0.25593805f, 0.25129908f, 0.36317971f, -0.39501083f, 0.10586809f, 0.28648990f, 
    -0.48632884f, -0.12926315f, 0.49873742f, -0.06508846f, -0.21584892f, 0.15108013f, -0.14759405f, -0.00362316f, 
    -0.59730053f, -0.20383500f, -0.48046958f, 0.05984596f, -0.23003356f, 0.33394653f, -0.05123346f, 0.35210884f, 
    0.23223139f, 0.21645820f, 0.37317005f, 0.18557352f, 0.19465317f, -0.12104568f, -0.02722668f, 0.26154822f, 
    -0.08865289f, -0.21123448f, 0.12132153f, -0.45257276f, 0.43872905f, 0.23066390f, -0.39002267f, 0.33007509f, 
    0.06838526f, -0.11972942f, 0.13441418f, 0.20590897f, -0.08584014f, -0.01329584f, -0.11735377f, 0.21476124f, 
    -0.15496874f, -0.09643501f, 0.09111492f, -0.34472626f, -0.17207094f, 0.22007698f, 0.31529921f, -0.18470664f, 
    0.16394359f, -0.20922294f, 0.17257579f, -0.41630173f, 0.33260944f, -0.03130254f, 0.10811694f, -0.05642239f, 
    -0.42596152f, -0.16735691f, 0.23058498f, 0.19984287f, 0.06905433f, -0.80355579f, -0.03138299f, -0.26159051f, 
    0.27572691f, 0.62713456f, -0.21656854f, -0.03161808f, -0.21999678f, 0.51179677f, -0.27618715f, -0.13755631f, 
    0.08410639f, 0.14202009f, 0.39374688f, 0.03000757f, 0.22701551f, -0.15819865f, -0.06278820f, -0.16253999f, 
    -0.02234047f, -0.67734909f, 0.16884279f, 0.04772589f, 0.27635854f, 0.15720513f, -0.07707765f, -0.12697978f, 
    0.08769071f, -0.07755288f, 0.64244229f, 0.21608596f, -0.17510106f, -0.13655506f, 0.01193596f, 0.65229738f, 
    -0.25137022f, -0.32217398f, 0.05088136f, -0.08748436f, 0.47540012f, 0.13279289f, 0.11063699f, -0.07074837f, 
    0.30835941f, 0.07171815f, -0.36017105f, 0.30698022f, 0.10877353f, -0.17017747f, 0.27860808f, 0.09203820f, 
    -0.22997089f, 0.29681551f, 0.01240978f, -0.21532232f, -0.40042213f, 0.41690320f, -0.15038653f, 0.00617362f, 
    -0.30904537f, 0.04092097f, 0.24936157f, -0.35294002f, -0.16257818f, 0.27562213f, 0.17894812f, 0.08552223f, 
    -0.30553111f, -0.07640725f, 0.41604775f, 0.34030533f, -0.42102477f, 0.50897688f, 0.00496393f, -0.11548266f, 
    -0.23389721f, -0.12884261f, 0.55301595f, -0.29500100f, 0.29533082f, -0.46697268f, 0.08999439f, 0.20485993f, 
    -0.20405468f, -0.05343810f, -0.06458717f, -0.13511330f, -0.14957394f, 0.38204923f, -0.17198941f, -0.25561032f, 
    0.07376800f, 0.16327989f, -0.00080930f, 0.20554443f, 0.17684746f, -0.18365891f, 0.05123475f, 0.36214057f, 
    -0.37277749f, -0.39313218f, 0.00369630f, 0.17976123f, 0.34070119f, 0.46104407f, -0.15668322f, 0.18003987f, 
    -0.29709816f, 0.13026026f, -0.52895105f, 0.43143600f, 0.35766450f, -0.23629963f, 0.41340393f, 0.49596992f, 
    -0.37647951f, 0.09562130f, 0.28022042f, -0.10723494f, -0.20233019f, -0.08677078f, -0.00486208f, 0.03850641f, 
    0.28230435f, 0.18045001f, -0.42105228f, 0.30288994f, 0.21053123f, 0.08425158f, -0.00849804f, 0.17060757f, 
    0.42360631f, -0.05632547f, -0.26014754f, -0.33863759f, -0.16934909f, 0.29085881f, -0.17274128f, 0.20541398f, 
    -0.52832216f, 0.20720911f, -0.42706284f, -0.65587246f, -0.00790998f, 0.09020191f, -0.04653236f, 0.46069920f, 
    -0.24279362f, 0.31277040f, 0.18995261f, 0.24437922f, 0.32410702f, 0.35394910f, 0.19968538f, 0.18095663f, 
    -0.19404316f, 0.14176315f, 0.43617177f, -0.04679436f, -0.17790484f, 0.26752821f, 0.11174520f, 0.01796422f, 
    -0.49316433f, -0.02801129f, -0.04331514f, 0.36856219f, -0.05427602f, -0.08515240f, -0.13558091f, -0.06993271f, 
    0.09801089f, 0.09535247f, 0.11176617f, -0.53383344f, 0.00099757f, 0.00680354f, 0.12707186f, -0.23201692f, 
    0.45938748f, 0.19397734f, 0.15949415f, 0.21883835f, -0.38310525f, -0.21734144f, 0.06944241f, 0.06140078f, 
    -0.00123359f, -0.07811274f, -0.33247182f, 0.33605102f, 0.28120252f, 0.42486802f, -0.26531559f, 0.24158908f, 
    -0.16078471f, 0.26420000f, -0.30544117f, 0.06812693f, 0.43033284f, -0.32439175f, -0.00864620f, 0.15502442f, 
    0.22918320f, 0.12711653f, -0.03477876f, 0.00511487f, -0.50479925f, 0.23206392f, 0.08178347f, 0.09866561f, 
    -0.10870522f, -0.16856466f, 0.20416178f, 0.27199617f, -0.34806302f, 0.19551139f, 0.24552390f, 0.18395534f, 
    0.18649195f, -0.03002525f, -0.17442898f, 0.33601952f, 0.16626981f, 0.01130053f, 0.16637963f, 0.26476276f, 
    0.27081648f, -0.53638512f, 0.23519590f, -0.32379314f, -0.00547613f, -0.46856865f, 0.06739290f, -0.14556134f, 
    -0.16246371f, -0.05911213f, 0.25357708f, 0.27444437f, 0.23441873f, 0.23607971f, 0.17354132f, -0.25285685f, 
    0.13110565f, -0.03968929f, -0.05894790f, -0.19857258f, 0.22339642f, -0.38318685f, -0.18066828f, 0.05726358f, 
    0.34900132f, -0.00892369f, -0.65160936f, -0.38165981f, 0.42843789f, 0.02215263f, 0.13791898f, -0.36391437f, 
    -0.06874208f, 0.47457910f, 0.10569730f, 0.24542440f, -0.04210260f, -0.10292015f, -0.10649306f, 0.10539421f, 
    -0.33866182f, 0.20959355f, -0.84536737f, -0.17127882f, 0.50873470f, 0.29930761f, -0.05383147f, 0.32193837f, 
    0.05791593f, 0.33551165f, -0.11150229f, 0.09409685f, -0.27100578f, 0.02401844f, 0.17291094f, 0.02210005f, 
    0.01190916f, 0.02945037f, -0.04672751f, -0.52459651f, 0.14077802f, 0.62244278f, -0.42604265f, -0.52141279f, 
    -0.08918195f, 0.17099157f, 0.48250341f, 0.38146016f, 0.36142024f, 0.19780442f, 0.12499668f, -0.04897250f, 
    -0.19223666f, -0.00838068f, 0.20906508f, -0.14889553f, -0.17446926f, -0.05791110f, 0.01006153f, -0.19591013f, 
    -0.16228330f, -0.08985406f, -0.14215103f, -0.09364989f, -0.12739626f, 0.05243483f, 0.23571813f, 0.10516447f, 
    0.39131671f, 0.12501352f, 0.04995818f, -0.07299434f, -0.16079628f, -0.05164010f, -0.10739537f, 0.41902003f, 
    -0.19096451f, 0.11018232f, -0.10384887f, -0.28014973f, 0.10184514f, 0.62902391f, 0.16558535f, -0.09595016f, 
    0.56656778f, 0.07979426f, 0.17166147f, 0.33114067f, 0.16497363f, -0.10038681f, -0.08016020f, -0.18601277f, 
    0.49192011f, -0.60006475f, -0.21961425f, -0.05067873f, -0.31489044f, -0.21520059f, -0.11823630f, 0.20334680f, 
    -0.06581764f, 0.23695529f, -0.22140969f, 0.21577828f, -0.20025298f, -0.33253369f, 0.25931635f, -0.27897611f, 
    -0.13343374f, 0.57075113f, 0.21604300f, 0.44032869f, 0.07961897f, -0.04384185f, -0.13393465f, 0.01712395f, 
    0.16470088f, -0.23721004f, 0.02775039f, 0.26771188f, -0.54403031f, 0.22197615f, 0.25305319f, 0.15886071f, 
    0.21091370f, -0.23668040f, -0.13694389f, 0.13335505f, -0.06836181f, 0.18190239f, -0.13571033f, 0.10202149f, 
    -0.39559972f, -0.03659515f, 0.14263150f, 0.12784655f, 0.31461528f, -0.22895081f, 0.17113428f, -0.43676627f, 
    0.19305570f, 0.14607973f, 0.26678479f, -0.04089832f, -0.05924337f, -0.05212635f, -0.06041407f, -0.10485365f, 
    0.36713013f, 0.11147469f, -0.11619437f, 0.48424959f, -0.22593263f, -0.04965697f, 0.16075006f, 0.48935255f, 
    0.39249820f, -0.00849299f, -0.33048502f, -0.25337350f, 0.40375191f, -0.12645878f, 0.24330214f, -0.05051045f, 
    0.00013060f, 0.20279074f, -0.10670304f, 0.54902101f, 0.08997916f, 0.29500976f, 0.41554818f, 0.25316292f, 
    0.46891761f, -0.49370044f, -0.24234262f, -0.25535691f, -0.15755655f, -0.18950762f, -0.00397932f, -0.03759561f, 
    -0.24705631f, 0.03016943f, -0.42870748f, -0.16562115f, -0.14642315f, 0.02109778f, 0.09796918f, 0.56835663f, 
    -0.20510730f, 0.22290632f, 0.29708755f, 0.04415127f, 0.45125946f, 0.09753878f, -0.16161500f, 0.19511651f, 
    0.37072462f, 0.20748371f, 0.13963138f, -0.35603762f, -0.11468324f, -0.14180511f, 0.26970959f, -0.35641444f, 
    0.45784709f, -0.31610596f, 0.08636606f, 0.36546287f, -0.19847466f, -0.18032938f, -0.13941351f, -0.21264057f, 
    0.02027635f, -0.05108335f, 0.39449218f, -0.34654862f, 0.13025606f, 0.09915497f, 0.04121345f, -0.26088753f, 
    0.35369149f, -0.14308104f, 0.09521720f, 0.01632154f, -0.13775159f, -0.42793968f, -0.10826973f, -0.14391713f, 
    -0.49637976f, 0.07593387f, -0.07540414f, 0.27543664f, -0.36960343f, -0.04330380f, -0.51323861f, 0.68647116f, 
    0.02390428f, 0.21769737f, 0.19892037f, 0.35769257f, 0.11236311f, 0.19495162f, 0.07416500f, 0.00504606f, 
    -0.49605718f, 0.12205961f, -0.08613227f, 0.20264602f, -0.01994192f, 0.04145162f, 0.25796503f, -0.00848084f, 
    0.05475214f, -0.37545204f, 0.57645971f, 0.12888554f, 0.16371587f, -0.26689181f, 0.24268791f, -0.24653377f, 
    0.32581720f, -0.01823375f, -0.31139117f, -0.53346014f, -0.08746615f, 0.53038710f, -0.11225217f, -0.37762016f, 
    0.14816330f, -0.16158649f, 0.12041842f, 0.34173593f, -0.12051936f, 0.52393711f, -0.02683152f, 0.18372189f, 
    0.46517158f, 0.01648326f, -0.33222318f, 0.04742815f, -0.15524879f, 0.14648916f, 0.36153579f, 0.25515100f, 
    -0.03793660f, 0.30696329f, -0.15489648f, -0.07377352f, -0.48709312f, 0.57009822f, -0.26295006f, 0.12158567f, 
    -0.15149254f, 0.16176999f, -0.07779050f, -0.17502144f, 0.01195806f, -0.15298307f, -0.16695994f, -0.02726474f, 
    -0.20571983f, -0.23710215f, -0.18054509f, 0.10123923f, -0.16701955f, 0.02295879f, 0.00950882f, -0.19964349f, 
    0.18499863f, 0.15791658f, -0.13489436f, 0.30607790f, 0.48645920f, 0.28422561f, -0.05837479f, -0.15895753f, 
    0.33216286f, 0.08791295f, -0.05563699f, -0.05892748f, -0.31684411f, -0.35965210f, -0.20577946f, -0.18533900f, 
    0.26452985f, -0.20753419f, 0.21830949f, 0.35172686f, 0.13850476f, -0.21316840f, 0.27844357f, 0.10913955f, 
    -0.59162444f, -0.14586344f, 0.11609928f, -0.36203283f, 0.31003502f, 0.30409923f, -0.18268587f, 0.03363239f, 
    -0.33032522f, 0.15880027f, -0.01373765f, 0.34681010f, 0.28728777f, 0.29287842f, -0.01166277f, 0.15118690f, 
    -0.15501593f, 0.23049730f, 0.27221099f, -0.14483555f, 0.08202211f, -0.21513507f, -0.24976800f, -0.06394373f, 
    -0.33623251f, 0.02320500f, -0.03321959f, 0.47455496f, 0.27095044f, 0.45074627f, -0.10173348f, 0.22102259f, 
    0.10515819f, 0.26580951f, 0.37119958f, -0.27456525f, -0.11795408f, -0.33918333f, -0.00494271f, -0.19132830f, 
    0.22312553f, 0.08513451f, -0.01698491f, 0.31013864f, 0.16204020f, -0.05623834f, 0.50707948f, 0.17130157f, 
    -0.09829258f, 0.16433756f, 0.08293866f, -0.27614659f, -0.40382102f, -0.49636018f, 0.07140810f, 0.23692553f, 
    -0.15421233f, -0.13731274f, 0.23704861f, 0.04333923f, 0.29923412f, 0.56385446f, -0.17304188f, 0.07703824f, 
    0.08680042f, -0.17177142f, 0.07150817f, -0.29170659f, 0.38018203f, -0.18818687f, 0.25737244f, -0.15939514f, 
    -0.10524015f, 0.18374571f, -0.11084434f, 0.02195048f, 0.06385709f, 0.28181240f, 0.15089557f, -0.41659942f, 
    0.09949507f, -0.15686058f, 0.53496122f, -0.60665250f, -0.01814518f, 0.02438421f, 0.17739642f, 0.04364710f, 
    0.26970568f, -0.14908500f, 0.04789941f, 0.18042091f, -0.17019098f, -0.23880471f, 0.18917485f, 0.07419550f, 
    -0.21910276f, 0.11972019f, -0.27101514f, 0.33996034f, 0.54958439f, 0.01034053f, 0.20062569f, 0.06022306f, 
    -0.52103966f, -0.08890426f, 0.01939786f, 0.20781958f, 0.30391839f, -0.19897667f, -0.23000370f, 0.20939474f, 
    0.44400439f, 0.14718963f, -0.29310405f, 0.01523962f, -0.08291777f, 0.06979272f, 0.22343798f, 0.08165862f, 
    0.33293122f, 0.09436118f, -0.43576118f, -0.01477280f, 0.14065316f, -0.10550890f, 0.00928511f, -0.24063277f, 
    0.42312455f, 0.50785273f, -0.13088430f, 0.34913787f, -0.10828458f, 0.01278389f, 0.11481586f, -0.09196719f, 
    0.23969635f, 0.23599133f, 0.07649025f, 0.28234261f, 0.16753748f, -0.19627318f, 0.11488756f, -0.67357069f, 
    0.23844175f, -0.21075268f, 0.20930117f, -0.15388091f, -0.28418505f, -0.45274711f, 0.12149534f, -0.24054360f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.19448633f, 0.05554847f, -0.00281419f, 0.05433015f, 0.29580432f, 0.24482305f, -0.15641202f, -0.06313547f, 
    0.16065323f, -0.12655652f, 0.02096137f, -0.25902072f, 0.37953568f, -0.11926166f, 0.16009068f, 0.19800714f, 
    0.13527927f, -0.38582683f, -0.09983810f, -0.12680365f, 0.31491739f, -0.21154466f, 0.30270895f, 0.02664144f, 
    0.38111341f, -0.31901923f, 0.05504389f, -0.17536637f, 0.48095340f, 0.31638131f, -0.22534756f, 0.24961480f, 
    -0.11218838f, -0.15785137f, 0.09873589f, 0.27117470f, -0.05088494f, 0.03362809f, 0.49379930f, -0.24554197f, 
    0.02739103f, 0.00634043f, 0.11548277f, 0.22657850f, 0.47965148f, 0.06135745f, -0.06269581f, -0.05213363f, 
    0.25588426f, 0.10412469f, -0.63063598f, 0.48309284f, -0.05875954f, -0.08122395f, 0.07142587f, 0.15058853f, 
    0.46620178f, 0.11719074f, -0.07380388f, 0.21134549f, -0.29936963f, 0.33137539f, -0.26018912f, -0.43303615f, 
    -0.28076461f, 0.00906160f, 0.47014165f, 0.17178085f, 0.31899482f, -0.07003725f, 0.19799551f, -0.03273499f, 
    0.37594134f, -0.02510646f, 0.31826371f, -0.07230716f, 0.48720863f, -0.32723662f, 0.15233675f, -0.14602387f, 
    -0.22742720f, 0.40144554f, 0.05896825f, 0.14904256f, 0.25596076f, 0.29792365f, 0.24517085f, -0.01725867f, 
    -0.53608382f, 0.02097101f, 0.32940754f, -0.02064694f, 0.24567223f, 0.48094788f, -0.07704312f, -0.24749885f, 
    0.19392996f, 0.39290112f, -0.13093561f, -0.18046263f, 0.20555565f, -0.12301546f, 0.17044465f, 0.16589950f, 
    0.19803408f, -0.69730073f, -0.21367547f, 0.17727579f, 0.01225751f, -0.21680981f, 0.06831509f, 0.72492748f, 
    -0.48165977f, 0.06938675f, 0.37177193f, -0.24254133f, 0.02189723f, 0.06866781f, -0.17034602f, -0.15948802f, 
    -0.11260149f, 0.44278398f, 0.26379436f, 0.11981300f, -0.13181522f, -0.30760133f, 0.07735924f, -0.28210908f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.05280627f, 0.10017542f, -0.03010662f, -0.03076162f, 0.23063950f, 0.09855124f, -0.74476743f, 0.01954935f, 
    -0.05996448f, -0.06802411f, 0.19110073f, -0.25225461f, 0.03262006f, 0.37300977f, 0.31815678f, 0.08292558f, 
    -0.16604835f, -0.01453641f, 0.21082807f, 0.04593286f, -0.70481420f, -0.15648431f, 0.27614081f, -0.00001303f, 
    -0.26153696f, 0.11815454f, -0.38741946f, -0.12369863f, 0.13901281f, -0.01068677f, 0.25103217f, 0.26492098f, 
    -0.08230973f, -0.05378991f, -0.08774062f, -0.08873119f, -0.68266678f, -0.19857430f, 0.23069160f, -0.08775921f, 
    -0.14117867f, 0.02123331f, 0.14436847f, 0.19185972f, 0.10090672f, 0.06589307f, -0.19281347f, 0.31577528f, 
    -0.56705159f, -0.25641355f, -0.54125494f, -0.04180824f, -0.04223216f, 0.23327750f, 0.79547155f, -0.17284395f, 
    0.14050184f, -1.21370876f, 0.36752728f, 0.04642068f, -0.10244925f, -0.38328409f, 0.02185824f, -0.15109909f, 
    -0.65954882f, 0.40523660f, 0.21363483f, -0.65038985f, 0.32745990f, -0.12726837f, 0.05231844f, -0.04469554f, 
    0.34337232f, 0.03328505f, 0.14308716f, 0.87883621f, 0.18231463f, -0.05167980f, 0.16700938f, -0.41315499f, 
    -0.64053231f, -0.14287910f, -0.28113422f, -0.08390619f, 0.04918090f, 0.21495157f, -0.08719428f, -0.05543005f, 
    0.11959688f, 0.47472149f, 0.16760699f, -1.12620056f, 0.09222463f, -0.72963476f, 0.20867760f, 0.10821694f, 
    0.29572150f, 0.18290997f, -0.12978792f, -0.24142705f, -0.33338317f, -0.01084486f, 0.11404618f, -0.46359372f, 
    0.12149706f, -0.06259663f, -0.07223075f, 0.18356641f, 0.14095262f, -0.08931276f, -0.90571791f, -0.26304320f, 
    -0.88871819f, 0.16057231f, -0.49597231f, 0.08575021f, 0.01771576f, -0.09683971f, 0.17413570f, 0.20647462f, 
    0.10385152f, 0.24544424f, 0.10048322f, 0.12304064f, 0.16233130f, -0.35388061f, -0.19199660f, -0.65303451f, 
    -0.86432993f, -0.04510387f, 0.19823582f, 0.20830585f, -0.07379397f, -0.17753506f, 0.01771757f, -0.27223572f, 
    -0.11058866f, 0.10025319f, 0.01623047f, 0.43841881f, -0.02288502f, -0.11683550f, -0.01831220f, 0.26814234f, 
    -0.43216294f, -0.14446488f, 0.33832011f, 0.32852215f, -0.25411204f, 0.19864263f, 0.23377068f, -0.62143219f, 
    -0.27853602f, -0.50201088f, 0.63217938f, -0.38185197f, -0.05829830f, 0.35752520f, -0.30434358f, -0.06046224f, 
    0.02835426f, -0.06234285f, 0.04367520f, -0.03787966f, 0.51596844f, -0.17458548f, 0.34775469f, -0.19314399f, 
    -0.61615628f, 0.00141981f, 0.09774298f, 0.35295013f, -0.14592029f, 0.01902272f, -0.33473349f, -0.21186827f, 
    0.09728236f, -0.10987883f, -0.34060833f, 0.10318440f, 0.19429064f, 0.22628427f, -0.70178688f, 0.06674567f, 
    0.13204794f, 0.07132376f, -0.09705783f, -0.12668516f, -0.13820648f, -0.10383105f, -0.18912385f, -0.39760178f, 
    -0.12757781f, -0.12429427f, 0.22847630f, -1.20032609f, 0.11506870f, 0.22360112f, 0.01759280f, 0.03208953f, 
    -0.33265725f, 0.05881131f, 0.03351632f, -0.70822358f, 0.07890497f, -0.32485282f, -0.25778717f, 0.05346034f, 
    -0.05598994f, -0.11644813f, 0.25297338f, -0.23451664f, 0.10350637f, 0.22543044f, -0.29678097f, -0.00387086f, 
    -0.06183907f, -0.13423184f, 0.22336799f, 0.71219575f, -0.05740257f, 0.05360813f, -0.24003324f, -0.66127032f, 
    -0.21183963f, -0.16227847f, 0.07972231f, -0.43888730f, -0.07213273f, 0.04227984f, 0.26334825f, 0.28446412f, 
    0.27039668f, -0.26058269f, -0.07121097f, 0.31147799f, -0.02309174f, 0.44778028f, 0.11330093f, -0.11159191f, 
    0.26597655f, -0.42301813f, -0.22913562f, 0.17205623f, -0.06811940f, -0.16097045f, 0.11473081f, -0.31932235f, 
    -0.27827144f, 0.28726339f, -0.28000826f, -0.06407870f, 0.23313668f, -0.15963654f, 0.19464256f, 0.17774890f, 
    0.10880203f, -0.04692679f, -0.03461410f, 0.20072508f, 0.35509890f, 0.21917497f, 0.42516690f, 0.21460474f, 
    0.36300090f, -0.69198692f, 0.01856298f, -0.79571259f, 0.08470718f, -0.19356619f, 0.23219447f, 0.11555572f, 
    0.35074517f, 0.24763326f, -0.17346133f, -0.50090390f, -0.12977365f, -0.17124666f, -0.27793467f, 0.06581903f, 
    -0.50071067f, -0.04920252f, -0.23093364f, 0.01392158f, -1.25664258f, 0.02569267f, -0.08420885f, -0.66075408f, 
    0.05165938f, 0.07830185f, -0.72012609f, -0.44455153f, -0.36358848f, -0.02403924f, -0.71403748f, 0.25100181f, 
    0.20789018f, 0.02867719f, -0.96907431f, -0.31884158f, 0.07699212f, 0.06623230f, 0.09200467f, 0.37899536f, 
    -0.28952694f, 0.11551301f, -0.73412657f, -0.42073417f, -0.68036067f, -0.03960554f, -0.16147180f, 0.20688200f, 
    -0.04638953f, -0.41156310f, 0.07499459f, 0.03435512f, -0.97627455f, 0.06047869f, 0.12475348f, -0.27086738f, 
    -0.63519317f, -0.50876808f, 0.19771238f, 0.59586763f, -0.01385983f, 0.15187699f, 0.12685293f, -0.36118203f, 
    -0.25453386f, 0.04464150f, -0.05157236f, -0.09626439f, -0.10360492f, -0.23159105f, 0.39761719f, 0.04626557f, 
    -0.09140946f, -0.23742290f, 0.42101660f, -0.75532269f, -0.60323203f, 0.22806488f, 0.10352674f, 0.21135797f, 
    -0.68729854f, 0.61882627f, 0.01160818f, -0.32238373f, -0.25565141f, 0.27126253f, -0.61524665f, -0.47860420f, 
    -0.21917535f, -0.25924018f, 0.44310859f, 0.31170243f, -0.13763660f, 0.05830357f, -0.28914985f, -0.61675417f, 
    0.26532137f, -0.00483983f, 0.20806660f, -0.38070902f, -0.19924685f, -0.18715428f, -0.29286620f, -0.04571138f, 
    -0.25566757f, -0.07400910f, -0.21580657f, 0.18106736f, -0.06195234f, -0.05551587f, -0.07885560f, 0.17806777f, 
    0.14852564f, 0.24017864f, -0.42491996f, -0.08616147f, -0.42666087f, 0.16696632f, 0.16455239f, -0.48698369f, 
    0.18724236f, -0.19109443f, -0.20321091f, -0.00837748f, -0.35604265f, -0.06675868f, -0.69974577f, -0.40733176f, 
    0.23497155f, 0.24439049f, 0.11838471f, 0.26390198f, -0.07881390f, -0.21843158f, 0.03541529f, 0.10934372f, 
    0.07014356f, 0.03164182f, 0.20806472f, -0.35158601f, -0.33131987f, 0.32818136f, -0.11532753f, -0.11980549f, 
    0.06978907f, 0.06502378f, 0.01783227f, 0.07990983f, -0.09965993f, 0.10163826f, 0.24837637f, 0.16288340f, 
    -0.07895407f, 0.03018444f, 0.19612360f, -0.05781154f, -0.49714711f, -0.25746650f, 0.07553185f, 0.11787835f, 
    -0.55774444f, 0.03106505f, 0.09101690f, -0.41840178f, 0.08399823f, -0.02468441f, -0.07558325f, 0.10167155f, 
    0.29782259f, -0.18911305f, 0.23316555f, -0.04866758f, 0.03593781f, -0.53256774f, 0.19305080f, -0.88367349f, 
    -0.02037690f, -0.20719081f, -0.04215983f, 0.29483923f, 0.02700805f, -0.25165549f, 0.03582581f, -0.44814107f, 
    0.18266393f, -0.10437234f, -0.10155885f, 0.39943153f, -0.29768828f, 0.03983517f, 0.19284102f, 0.11726889f, 
    0.19558449f, 0.02601883f, -0.71531183f, -0.70093024f, 0.02750143f, 0.24936377f, 0.01267674f, 0.01407537f, 
    0.15048081f, -0.49494413f, -1.42423368f, 0.13137598f, -0.34601322f, -0.11986174f, -0.11061902f, -0.27556813f, 
    0.25575814f, 0.13604070f, -0.66462326f, -0.22449630f, 0.02005871f, -0.27864578f, 0.21294931f, 0.18444872f, 
    -0.13516781f, -0.00947464f, 0.34055018f, 0.22910534f, 0.19877855f, 0.00877719f, -0.23918580f, -0.78708649f, 
    0.18098107f, 0.57428753f, 0.18290271f, -0.46015781f, -0.40047199f, -0.14275314f, -0.12578154f, -0.24773133f, 
    -0.11587292f, 0.00090593f, 0.07071840f, 0.18296024f, 0.06060141f, 0.11795112f, 0.30507529f, 0.18022119f, 
    0.03541176f, -0.68537712f, 0.01757545f, -0.26304516f, 0.09379203f, 0.14424196f, 0.21450213f, -0.82946599f, 
    0.02481761f, 0.22601680f, -0.22770108f, -0.40379131f, 0.01664370f, -0.12595749f, -0.00002139f, 0.18905427f, 
    -0.22323698f, 0.01845204f, 0.05607500f, -0.41908804f, -0.20400073f, -0.54114860f, -0.42948887f, -0.07666489f, 
    -0.06880074f, -0.44083470f, -0.41184002f, -0.05515906f, 0.28133994f, 0.04082406f, 0.03778559f, -0.34058213f, 
    0.18541718f, 0.00499660f, -0.10590477f, 0.12404873f, 0.17265294f, 0.01622600f, 0.20137130f, 0.13955016f, 
    -0.06807901f, 0.07170830f, -0.23305510f, 0.18085425f, 0.49631321f, 0.16880192f, 0.00584440f, 0.04715443f, 
    -0.19124903f, 0.02864626f, -0.49839610f, -0.18069732f, 0.08033379f, 0.05714586f, 0.01532896f, 0.11691449f, 
    0.10730550f, -0.01471793f, 0.03318502f, 0.18664803f, -0.36645117f, -0.10027280f, -0.16407950f, -0.05302667f, 
    -0.12985547f, 0.06659881f, -0.00087889f, -0.11897876f, -0.28166193f, -0.04650986f, 0.00239116f, 0.32301378f, 
    0.24856578f, -0.55528319f, 0.12946084f, 0.08981845f, 0.09699254f, 0.02591485f, 0.04353958f, -0.05932036f, 
    0.00226807f, -0.05188443f, 0.30119756f, 0.05393176f, -0.20846163f, -0.04760215f, 0.42188045f, -0.50719202f, 
    0.20731440f, 0.15564261f, 0.00066078f, 0.17282763f, 0.33913636f, 0.16320755f, 0.27361959f, 0.39160088f, 
    0.10948460f, 0.01743891f, -0.15643001f, -0.19008343f, 0.25535011f, -0.05146456f, -0.08106607f, -0.25419173f, 
    -0.17454484f, 0.10316035f, -0.14647786f, -0.47355691f, 0.14285880f, 0.08278979f, 0.10554203f, -0.47621560f, 
    -0.27741069f, -0.76225948f, 0.06478575f, -0.26517057f, -0.27691245f, -0.58138889f, -0.29684839f, 0.23962408f, 
    -0.18656653f, 0.09752137f, 0.03769386f, -0.11312193f, 0.00415773f, -0.10367890f, 0.16659845f, 0.13110930f, 
    0.05670216f, 0.06047168f, 0.22055328f, -0.14346334f, -0.13651264f, -0.11464233f, -0.57226378f, -0.77913338f, 
    -0.36890554f, 0.06358852f, 0.18858288f, -0.11809368f, 0.30704534f, 0.12478632f, -0.06340089f, -0.00430849f, 
    -0.21952669f, 0.12630744f, 0.22817525f, 0.15437569f, 0.14583255f, -0.69500840f, 0.19980015f, -0.46895853f, 
    -0.14179027f, 0.01691561f, 0.07660551f, 0.08630580f, 0.40138969f, 0.02869605f, 0.07144065f, 0.23824468f, 
    0.21485458f, -0.06901788f, -0.35467201f, -0.01172688f, -0.20376666f, -0.08350768f, -0.73535085f, -0.12118746f, 
    -0.08892660f, -0.01736746f, 0.34557807f, 0.07814351f, 0.06725588f, 0.03883189f, 0.22668386f, -0.06148361f, 
    0.49710116f, -0.07614188f, 0.18689416f, 0.14814091f, 0.00990345f, -0.02853011f, -0.20174260f, -0.18535663f, 
    0.29249445f, -0.15277985f, 0.36061549f, 0.27026692f, 0.00676673f, 0.05408869f, 0.21078737f, -0.04462875f, 
    -0.07084471f, 0.55674160f, -0.14550540f, -0.15365677f, -0.39214787f, 0.10075527f, -0.25989115f, 0.56244993f, 
    0.18805990f, 0.53790581f, 0.01643182f, 0.22220364f, 0.00848362f, 0.06467357f, -0.12073356f, 0.13638653f, 
    -0.25489807f, 0.06247799f, 0.18421541f, -0.57153457f, 0.06627190f, -0.27769303f, -0.10069274f, 0.19198661f, 
    -0.35265356f, 0.17943563f, -0.07206184f, 0.10392466f, 0.07284883f, -0.15937711f, -0.08648989f, -0.12841477f, 
    -0.02284532f, -0.43931767f, 0.01493240f, 0.48601186f, 0.01108472f, -0.07762162f, 0.16177346f, 0.07113750f, 
    0.22480658f, 0.02255643f, -0.59381032f, 0.00814520f, -0.91840863f, -0.07953300f, -0.21558051f, 0.45912838f, 
    -0.21984433f, 0.19239241f, -0.13410102f, 0.10351012f, 0.27871996f, 0.14309137f, 0.21305029f, 0.08446410f, 
    0.18350393f, -0.22887968f, 0.00833709f, -0.17961393f, 0.03060473f, 0.05017389f, -0.14067593f, -0.03954458f, 
    -0.03678587f, 0.05504885f, -0.11998210f, -0.03442740f, 0.08517085f, -0.00459333f, -0.08341108f, -0.44659075f, 
    0.18988197f, -0.02613604f, -0.02880822f, -0.18670329f, -0.76602930f, 0.31638399f, 0.15209047f, 0.14782760f, 
    -0.86163515f, 0.18347801f, 0.02901772f, -0.41647643f, 0.21205772f, 0.12881741f, -0.22450657f, -0.29133588f, 
    0.14565812f, -0.09534996f, 0.07483492f, -0.14758569f, -0.52193618f, -0.00554992f, -0.09276967f, -0.18140073f, 
    0.36479235f, 0.23367389f, -0.69416142f, 0.19463639f, -0.04554505f, -0.60359997f, -0.13159017f, -0.29353520f, 
    0.07766641f, 0.02167651f, 0.19790506f, 0.29566386f, -1.08543909f, 0.34345230f, -0.14258493f, 0.17213838f, 
    -0.45202705f, 0.02773995f, 0.13725705f, -0.11316431f, -0.65593791f, -0.05943608f, -0.11889980f, -0.12799785f, 
    -0.27120686f, 0.06388420f, -0.32521361f, 0.12376819f, -0.14014654f, -0.02661550f, -0.36243129f, 0.03653495f, 
    0.02783073f, -1.13945901f, -0.39260703f, 0.15173754f, 0.61053580f, 0.06125266f, 0.07609661f, -0.55617708f, 
    -0.33693948f, 0.13913496f, -0.66634041f, 0.21533883f, -0.34818017f, -0.10815322f, 0.03144007f, 0.10068022f, 
    -0.15538710f, 0.02969628f, 0.00537155f, -0.17485149f, -0.18124358f, 0.04678275f, -0.37909579f, -0.91938627f, 
    0.41999567f, -0.65637088f, 0.19973308f, 0.16088913f, -0.03067986f, -0.27909669f, -0.71929002f, 0.00172564f, 
    -0.05432602f, -0.93943042f, 0.23105097f, -0.10022017f, -0.15335552f, -0.02885059f, -0.11705533f, -0.63741261f, 
    0.08532642f, 0.13597268f, 0.08147113f, -0.00967443f, -0.00545883f, 0.00792971f, -0.15190852f, 0.47122726f, 
    -0.34859538f, 0.21762271f, 0.08593105f, 0.21284494f, 0.28081983f, -0.65352029f, 0.04336100f, 0.14565137f, 
    -0.80759490f, -0.17519553f, -0.16877545f, -0.19359097f, 0.02280501f, 0.22142482f, -0.29324383f, 0.04691533f, 
    0.01933053f, -0.11039754f, 0.20835966f, -0.37919065f, 0.00214616f, 0.31594241f, 0.04939754f, 0.30182189f, 
    -0.18575510f, -0.02363968f, 0.05449093f, -0.27184847f, -0.45945555f, -0.57003570f, -0.00352064f, 0.24084154f, 
    0.00294138f, -0.74657607f, -0.49115536f, 0.21732883f, -0.94143605f, 0.24173206f, -0.18718417f, -0.18619090f, 
    -0.82376677f, 0.05232910f, -0.17331550f, 0.13347092f, 0.12683509f, 0.44792917f, 0.03501402f, 0.06405525f, 
    -0.23839046f, 0.11817068f, 0.23853071f, 0.04698605f, 0.28643146f, -0.04817823f, -0.05681371f, 0.11301176f, 
    -0.09462173f, -0.06948559f, 0.12619968f, -0.11696135f, -0.54861969f, -0.29918563f, -0.45809183f, -0.86445904f, 
    0.00347067f, -0.06966101f, -0.24441032f, 0.13752921f, -0.27969256f, 0.07916623f, 0.20681006f, 0.19374458f, 
    0.09881482f, -0.25839114f, 0.15875785f, -0.54690999f, 0.05482799f, 0.20858569f, 0.01733449f, -0.14171399f, 
    -0.62704080f, 0.36949965f, 0.17334498f, -0.32172820f, -0.32373756f, -0.08259276f, 0.25845847f, 0.29610071f, 
    0.14610381f, 0.01153036f, -0.07562014f, -0.21806453f, 0.02418055f, -0.09093270f, -0.64639473f, -0.62025911f, 
    0.07484594f, -0.05953701f, 0.02864758f, -0.13277814f, -0.57556617f, 0.06684363f, 0.04559400f, 0.14667663f, 
    -0.00242292f, -0.20940730f, -0.42078108f, -0.02288477f, 0.35236090f, -0.46947142f, 0.07885560f, 0.03491629f, 
    0.23346376f, -0.00085367f, -0.40592009f, -0.02239187f, 0.05579308f, -0.83926952f, 0.10906986f, 0.14955606f, 
    0.07581485f, -0.31494528f, -0.12633255f, 0.05411021f, -0.02213170f, -0.04145335f, 0.26028869f, -0.24737385f, 
    -0.18821603f, 0.31404668f, -0.59090787f, 0.13029073f, -0.34969059f, 0.30083084f, -0.70232224f, -0.95518035f, 
    0.38936925f, 0.07798751f, -0.20512737f, 0.16083883f, 0.03775208f, -0.99138361f, 0.15581383f, 0.10487849f, 
    0.05498856f, -0.47987643f, 0.11948884f, -0.51824921f, 0.11635808f, -0.11620124f, -0.61182445f, -0.53367168f, 
    0.04973869f, -0.30089334f, 0.14316687f, 0.03435502f, -0.09122619f, -0.69794375f, 0.16955955f, -0.38682273f, 
    0.32929808f, -0.05621861f, 0.01337176f, -0.67106509f, -0.49348205f, 0.19254804f, -0.36597797f, 0.14933398f, 
    -0.43144023f, 0.12882322f, -0.18337189f, 0.25526631f, 0.38917455f, 0.21715340f, -0.26176551f, -0.16844904f, 
    0.01929519f, -0.66419494f, -0.47646683f, -0.12720488f, 0.00665124f, 0.24024093f, -0.21560884f, -0.06186739f, 
    0.05249559f, -0.06819304f, -0.77903128f, -0.20620267f, 0.27833998f, 0.14276077f, -0.23910137f, -0.32541755f, 
    0.17940140f, 0.08016945f, 0.09803510f, 0.03853724f, -0.05414860f, 0.08628359f, 0.05082049f, -0.40165392f, 
    0.17685759f, 0.20333932f, -0.34890041f, 0.21677849f, 0.49773481f, -0.00118528f, -0.37134546f, 0.04134904f, 
    -0.53087085f, 0.47764525f, 0.40362248f, -0.27757674f, 0.71640265f, 0.25076640f, -0.38062745f, 0.32056612f, 
    -0.07160573f, -0.08237702f, -0.41085544f, -0.37336710f, 0.17014657f, 0.20726737f, -0.09872320f, 0.08571281f, 
    -0.01644369f, 0.02305743f, 0.03114597f, 0.02478690f, 0.02253859f, -0.11088085f, 0.00844226f, -0.43594372f, 
    -0.15041332f, -0.30830765f, 0.23152082f, 0.08831318f, -0.02194225f, 0.18729848f, 0.33698744f, 0.29228991f, 
    0.47355157f, 0.09812262f, 0.12864712f, 0.09544363f, -0.09985394f, -0.25875324f, -0.36700204f, -0.06253904f, 
    -0.64283389f, -0.55136788f, 0.07384936f, 0.15848684f, 0.07872061f, 0.03146905f, 0.27425107f, 0.04031733f, 
    -0.03854735f, 0.15727504f, -0.10583371f, -0.21248208f, -0.35920173f, -0.02071248f, 0.10398266f, -0.40487424f, 
    -0.27571967f, -0.52020383f, 0.31126627f, 0.28976578f, 0.02673349f, -0.64437503f, 0.01116797f, -0.59726924f, 
    -0.74272680f, -1.06227064f, -0.39751238f, -0.00324536f, 0.03373531f, 0.32659253f, 0.02863937f, -0.80784124f, 
    0.16624404f, 0.01839989f, 0.06052446f, 0.01124534f, -0.48344404f, 0.27116704f, 0.33447146f, 0.31856513f, 
    -0.42552432f, 0.14744884f, -0.12434022f, 0.03220607f, 0.06983884f, -0.34210816f, -0.56852871f, -0.34650350f, 
    0.22367494f, -0.12263690f, -0.42547289f, -0.09547660f, 0.25852251f, 0.10489069f, -0.07798599f, 0.17745024f, 
    0.05602851f, 0.28351158f, 0.06739374f, 0.11675035f, 0.05280625f, -0.44792962f, -0.08893082f, 0.06038486f, 
    -0.12018307f, 0.02361402f, -0.80083567f, -0.04696147f, 0.01769846f, 0.02391341f, -0.38154721f, 0.08387035f, 
    0.01014839f, 0.07798742f, -0.33840162f, -0.41432786f, -0.20814337f, -0.07479855f, 0.12518445f, 0.14113455f, 
    0.31527248f, 0.18602905f, 0.24554658f, -0.16384956f, -0.18163671f, -0.06840920f, -0.28579500f, 0.20519137f, 
    -0.29131788f, 0.33796740f, 0.15567470f, -0.45734793f, -0.46581239f, -0.04471888f, 0.14886390f, 0.39078397f, 
    0.08877771f, -0.29117617f, -0.37736058f, -0.27177814f, 0.13740054f, -0.27565455f, -0.33426917f, 0.11574094f, 
    -0.26856747f, -0.07396826f, -0.02911976f, -0.19365424f, 0.05233655f, 0.06530721f, -0.00159605f, 0.49636000f, 
    -0.12602940f, 0.33095285f, -0.34764463f, 0.11480308f, 0.08392370f, -0.18998246f, -0.02152097f, -0.10107281f, 
    -0.06224260f, -0.03475378f, -0.13081032f, -0.18675734f, -0.15230156f, -0.07032392f, -0.23074837f, -0.01628735f, 
    0.26390973f, 0.10706794f, -0.68826759f, -0.46984985f, -0.06245027f, -0.03859260f, -0.48738495f, 0.03742866f, 
    0.11429809f, -0.07673258f, 0.19001539f, -0.02401959f, 0.19864807f, -0.09021201f, 0.10629678f, 0.12166382f, 
    0.71399456f, 0.25116679f, -0.80646104f, -0.63185543f, 0.06420978f, -0.07341658f, -0.01486431f, -0.01618989f, 
    0.07823243f, 0.10589942f, 0.05158611f, 0.53303301f, -0.15524137f, -0.02360766f, -0.34814599f, 0.70741194f, 
    -0.05633893f, -0.58106017f, -0.17173386f, 0.00365901f, 0.50540572f, -0.49095562f, 0.53738344f, -0.62457347f, 
    0.37318730f, -0.43428028f, -0.01049833f, -0.03602814f, -0.35740894f, 0.27898958f, 0.07628483f, 0.36549741f, 
    -0.04348302f, 0.05942822f, 0.35622111f, -0.67917567f, -0.02743714f, -0.58109611f, -0.27146795f, 0.18350908f, 
    -0.25653636f, -0.34528282f, 0.07739258f, 0.04556471f, 0.12677602f, 0.20533527f, 0.11211877f, 0.16730732f, 
    0.01059004f, -0.05194699f, 0.23266679f, -0.36545676f, 0.34265494f, -0.69484121f, 0.30254319f, -0.27130494f, 
    0.14029999f, 0.05235232f, -0.39011520f, -0.23478922f, 0.30527395f, -0.00099461f, -0.02605721f, -0.72791904f, 
    -0.52786893f, 0.03201471f, -0.37563691f, 0.00872826f, -0.03650457f, -0.43048495f, -0.23838915f, -0.29830244f, 
    0.36357388f, -0.41720033f, -0.53093284f, 0.29146200f, -0.55528045f, 0.22191554f, -0.22303954f, -0.49449158f, 
    -0.24926697f, 0.05775955f, 0.25137755f, -0.06847343f, -0.31589797f, -0.10823200f, 0.28216413f, 0.05804778f, 
    0.05930064f, 0.07870288f, -0.31307924f, -0.49217582f, 0.08921797f, 0.09884001f, -0.31230357f, 0.12781897f, 
    -0.00836478f, 0.26613110f, 0.20533219f, 0.07491211f, -0.35159290f, -0.20031726f, 0.18718271f, -0.13671276f, 
    -0.28244269f, -0.12682007f, -0.52883577f, 0.10230696f, 0.20339310f, 0.41901207f, -0.02639715f, -0.17191489f, 
    -0.27981138f, -0.07974593f, 0.24755302f, 0.03126590f, 0.35125113f, 0.01044538f, -0.01557651f, -0.57729059f, 
    0.35100651f, -0.89658189f, -0.05730299f, -0.51945269f, -1.05423725f, 0.00989036f, 0.40696096f, 0.25157502f, 
    -0.30242646f, 0.05128551f, 0.46608251f, -0.32305408f, -0.07679792f, -0.19360687f, -0.50993633f, -0.05781991f, 
    -0.22391790f, 0.12024641f, -0.01951282f, -0.13905098f, 0.01988621f, -0.55071259f, 0.16505691f, -0.17842807f, 
    0.26083302f, -0.00495211f, -0.34862641f, -0.29419103f, 0.46061668f, 0.34842497f, -1.49549973f, -0.10757745f, 
    -0.32617027f, -0.28359708f, -0.37837052f, -0.07787277f, 0.34203210f, -0.38640144f, 0.36536735f, -0.28224927f, 
    0.33639607f, 0.19263014f, -0.39536169f, -0.58515513f, -0.68918562f, -0.63748103f, -0.18693723f, 0.37168413f, 
    0.10106513f, 0.16165526f, 0.24311283f, 0.11799338f, -0.16594625f, -0.46578628f, 0.15327330f, -0.24536176f, 
    -0.06583080f, 0.07345759f, -0.21035387f, 0.23007880f, 0.23312327f, 0.13159764f, -0.33248228f, 0.03775423f, 
    -0.16815558f, 0.07373112f, -0.10669678f, -0.14202964f, 0.04497192f, 0.05244760f, 0.25687155f, -0.14366046f, 
    -0.99967021f, 0.07145236f, -0.49555376f, -0.16238002f, -0.43939212f, 0.07658998f, -0.47387153f, 0.12614709f, 
    -0.13603863f, -0.98029488f, -0.07459579f, 0.25317830f, 0.02052597f, 0.17155662f, 0.13963546f, -0.67083412f, 
    -0.05345817f, -0.12257054f, -0.33710819f, 0.38102722f, -0.26772270f, -0.15772036f, -0.02618666f, -0.09360494f, 
    0.09594814f, -0.08311953f, -0.17019160f, 0.42597151f, 0.02634235f, 0.17862007f, -0.39229497f, 0.13237342f, 
    0.09200890f, 0.09451502f, -0.58474737f, -0.24070071f, -0.46083051f, 0.07525606f, -0.02601995f, -0.97696096f, 
    -0.40813857f, -0.01216341f, 0.25281677f, -0.08128607f, -0.31731561f, 0.18903686f, 0.07027197f, 0.37575987f, 
    0.15511777f, 0.02754765f, 0.14769037f, 0.41785485f, 0.19551644f, 0.03834425f, -0.00045301f, -0.05646002f, 
    -0.41457430f, -0.11126096f, -0.12524228f, 0.13094430f, 0.03785608f, -0.19417502f, -0.06205533f, 0.22270729f, 
    -0.51340461f, -0.16643965f, 0.36454037f, 0.14473088f, 0.08583202f, 0.27726138f, -0.48005348f, 0.07193735f, 
    0.19290844f, 0.00000599f, 0.18408990f, 0.41873220f, -0.55232841f, 0.13476311f, 0.13073711f, -0.82060623f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.04464966f, 0.12188093f, -0.21401830f, -0.35599646f, 0.33697632f, 0.16083395f, 0.01668140f, -0.46666893f, 
    -0.15219884f, -0.11922242f, 0.28419155f, 0.08483697f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
