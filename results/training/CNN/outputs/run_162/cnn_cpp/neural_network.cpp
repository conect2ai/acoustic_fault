#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.51345408f, 0.57943940f, 0.79654169f, -0.69410896f, -0.83248085f, 0.15548903f, -0.41873950f, 0.28695706f, 
    -0.25541890f, 0.15445481f, 0.43094400f, 0.32408980f, -0.03697280f, 0.18192516f, 0.10442528f, 0.10428864f, 
    0.34739566f, -0.10531276f, -0.05728269f, -0.10137077f, -0.15320501f, 0.15194090f, 0.07785822f, -0.13767089f, 
    0.15875785f, 0.65276200f, 0.45008513f, -0.63104421f, -0.29669681f, -0.65347439f, 0.12349183f, -0.41326603f, 
    0.46131134f, -0.13052712f, 0.41038606f, -0.75647390f, 0.18583679f, -0.43452814f, -0.04888619f, -0.51899093f, 
    -0.39631841f, -0.33858612f, -0.42597765f, -0.14339262f, -0.20016380f, -0.21322422f, -0.10695884f, -0.36774424f, 
    0.29263929f, 0.26999840f, -0.15146326f, 0.09324620f, 0.49222884f, 0.85453480f, 0.51864672f, 0.62622249f, 
    -0.56670475f, -0.96186751f, -0.24657878f, -0.75476980f, -0.12856939f, 0.26245224f, -0.03849373f, 0.11423252f, 
    0.10223079f, -0.12614723f, -0.20855209f, 0.32783809f, 0.12057630f, 0.33355761f, 0.22854351f, 0.75109416f, 
    -0.52347660f, 0.00557915f, 0.29603568f, 0.29830009f, -0.78115618f, -0.98330522f, -0.88377899f, -0.56799948f, 
    -0.29435837f, 1.12832820f, 0.64482892f, -0.25138545f, 0.67569029f, 0.01047247f, -0.09165438f, 0.06008657f, 
    -0.36795357f, 0.07935253f, -0.10145649f, 0.27998030f, 0.12860242f, 0.19125152f, -0.06603718f, 0.02054037f, 
    0.01412607f, 0.04475010f, -0.06209442f, 0.22580795f, 0.76677972f, -0.41358984f, 0.29865447f, 0.79654127f, 
    -0.08165419f, 0.36947519f, 0.02984259f, -0.00947322f, -0.49526119f, 0.66370326f, -0.34088820f, -0.21433370f, 
    -0.11776598f, -0.22818862f, -0.38304967f, -0.75523716f, -0.11266080f, -0.09679183f, 0.09085785f, -0.49020761f, 
    0.32525921f, 0.20435329f, -0.17285763f, -0.16859198f, -0.16771370f, -1.70676351f, 0.82301360f, 0.21200538f, 
    -0.51009351f, -0.42715037f, 1.16600502f, 0.71579325f, -0.13424824f, 0.94435894f, 0.38050076f, 0.32890999f, 
    -0.30638507f, 0.00135510f, -0.17388818f, -0.56350440f, 0.12356541f, 0.02014234f, 0.11270794f, -0.02897814f, 
    -0.05537280f, -0.12502666f, -0.31451449f, -0.00733598f, 0.12266523f, 0.09880265f, 0.81799775f, -1.06094885f, 
    0.73482311f, 0.05475416f, -0.51661247f, 0.83512068f, 0.28452227f, 0.56352139f, 0.46587697f, 0.18560319f, 
    0.21925479f, -0.50980639f, -0.19920285f, 0.12390941f, -0.47571558f, 0.02228055f, -0.21051325f, -0.12480904f, 
    -0.17886384f, 0.22066922f, -0.07472246f, -0.06939723f, -0.04828776f, -0.17427289f, 0.24497019f, 0.76480991f, 
    -0.68818086f, -0.19195309f, 1.04281783f, 0.62753713f, -0.62843603f, 0.44453782f, 0.58134097f, 0.08094238f, 
    -0.08987977f, 0.02744362f, -0.04020178f, -0.01268728f, 0.01909580f, 0.07751796f, -0.02102103f, 0.20002970f, 
    0.08653600f, -0.19520655f, -0.47836682f, 0.33833340f, -0.05578331f, -0.25978711f, 0.04512993f, 0.42531490f, 
    -0.97856545f, -0.96162504f, -0.57926524f, 0.23062837f, -0.42253196f, 0.46079290f, 0.98735887f, 0.39163762f, 
    0.09956422f, -0.11595546f, -0.07226953f, -0.24236563f, 0.01761539f, 0.46639869f, 0.54106194f, -0.02160564f, 
    -0.25105208f, -0.56845713f, -0.25818387f, -0.10757879f, 0.01597802f, 0.06820516f, -0.01572827f, 0.25064585f, 
    0.13352142f, 1.11957896f, 0.78877121f, 0.62327623f, 0.81618059f, 0.80535573f, -0.36458540f, 0.37926346f, 
    0.15012136f, 0.23343508f, -0.03791185f, -0.02748557f, 0.00495300f, -0.00289358f, 0.44507492f, 0.24629305f, 
    0.09408765f, 0.22024603f, 0.25879142f, 0.25086343f, 0.61934739f, -0.30237862f, 0.16455764f, -0.06100690f, 
    0.30248943f, -0.09991980f, 0.48946375f, -0.75987685f, 0.38009486f, 1.13931394f, 0.73950791f, -0.94864041f, 
    -0.35248867f, 0.23821610f, -0.57389057f, 0.14908814f, 0.56166339f, 0.37280577f, -0.09215816f, 0.35842019f, 
    -0.23886998f, -0.16326939f, 0.15320505f, 0.17298868f, 0.35082525f, -0.21044825f, -0.21469820f, 0.23134460f, 
    0.11813846f, -0.21352755f, -0.15704063f, -0.31278896f, -1.16740155f, -0.46498659f, -0.02227131f, -0.02200397f, 
    -0.52438790f, 0.15919754f, -0.68004549f, 0.30909893f, 0.04234415f, 0.57395053f, 0.67111075f, -0.47075289f, 
    0.47570696f, -0.42382726f, -0.02807621f, 0.15494151f, -0.13998562f, 0.15349956f, 0.23216309f, 0.31935957f, 
    0.25415212f, -0.16332485f, 0.30748734f, 0.11746818f, 0.29486343f, 1.08071685f, 0.73361886f, 0.02778018f, 
    0.92093438f, 1.11744988f, 0.15943071f, -1.27756917f, 0.46424603f, -0.55453843f, 0.22471273f, 0.29807159f, 
    -0.14146741f, 0.23487234f, -0.41101474f, 0.03469072f, 0.34029713f, 0.29274312f, -0.12146340f, -0.12168840f, 
    0.01938061f, -0.06128922f, 0.14266990f, -0.00696158f, -0.12967783f, 0.09616795f, -0.48839229f, 0.67372072f, 
    1.12526679f, 0.85738581f, 0.65301621f, 0.47951546f, 0.48385838f, 0.21014886f, 0.18899693f, 0.03680046f, 
    0.38728130f, -0.26941073f, 0.35602018f, -0.21807177f, 0.30807129f, -0.08479550f, -0.28626367f, -0.10209442f, 
    -0.24975710f, 0.09101766f, 0.13698582f, -0.06859563f, -0.16489513f, -0.06680711f, -0.32825178f, -0.81105876f, 
    -0.56802875f, 0.00292280f, 0.08995526f, -0.63064158f, 0.48301652f, -0.39038154f, -0.61830717f, 0.75071502f, 
    -0.12626123f, 0.46777683f, 0.21861051f, 0.18409058f, 0.64130670f, -0.28232783f, 0.26725349f, 0.38485244f, 
    -0.21396868f, 0.10914705f, -0.41575289f, -0.28015146f, -0.20417587f, -0.20429619f, -0.22116129f, 0.99224025f, 
    0.77245164f, -0.88199419f, -0.66736364f, -1.03962028f, -0.65190500f, -0.31442374f, 0.54177803f, 0.46066716f, 
    -0.04504868f, -0.11491566f, 0.28287539f, 0.41310728f, 0.11474369f, -0.04270568f, 0.41548166f, -0.28275061f, 
    -0.04253053f, 0.02922047f, 0.07454968f, 0.05260717f, 0.35748273f, -0.06576781f, -0.06946873f, 0.12974876f, 
    -0.95955163f, -0.51350927f, 0.47132769f, 0.28550979f, -0.76975852f, -0.33195037f, -0.01195377f, 0.21150596f, 
    0.12827662f, -0.83152670f, -0.03280083f, -0.03327104f, -0.09605655f, 0.11216923f, 0.27762049f, 0.43244657f, 
    -0.17503428f, 0.06566894f, -0.24049918f, -0.21344022f, 0.18984409f, 0.42956018f, 0.22985943f, 0.25858787f, 
    0.49262330f, -0.36458671f, -0.94589919f, -0.57516736f, -0.18915808f, -0.31878573f, -0.61425900f, 0.62515974f, 
    0.57158816f, -0.02228242f, 0.05095982f, 0.13382858f, 0.12765558f, -0.23486088f, -0.13237062f, -0.22748460f, 
    -0.05283888f, -0.34127608f, -0.06769129f, -0.15307234f, -0.32925925f, -0.15985315f, -0.32843381f, 0.49105978f, 
    -0.28277206f, 0.28697658f, -0.12300694f, 0.45456025f, -0.59177125f, 0.32135716f, -0.03549112f, 0.15393074f, 
    -0.47456792f, -0.75992095f, -0.45892805f, -0.49916691f, -0.50088900f, -0.40615126f, -0.45326519f, -0.07408109f, 
    -0.48973894f, -0.53204626f, -0.09658302f, -0.28989443f, -0.19986728f, -0.34816024f, 0.06371516f, -0.56566536f, 
    -0.14182626f, -0.38783827f, -0.35796911f, -0.40352532f, 0.21153814f, 1.07323039f, -1.19646847f, -0.76006323f, 
    0.72351056f, -0.31527126f, 0.04242461f, -0.42146933f, -0.45197061f, 0.46902463f, 0.42186689f, -0.21212278f, 
    0.00048757f, -0.09930068f, -0.10417371f, 0.06021168f, -0.02535361f, 0.00281954f, -0.17423455f, 0.11696915f, 
    0.38186198f, 0.12972687f, 0.43658829f, 0.03658387f, -1.10886073f, -1.13818729f, -1.06465507f, 0.33328578f, 
    0.52217311f, -0.99533236f, 0.18763360f, 0.59420472f, -0.02757544f, 0.11198740f, 0.39499876f, -0.16519119f, 
    0.13029478f, -0.24258801f, 0.24167274f, 0.04111234f, 0.23802401f, 0.21267650f, -0.06289458f, -0.12242877f, 
    -0.03008111f, -0.09630281f, -0.21726912f, 0.05326211f, 0.04321962f, 1.44618642f, 0.66953897f, 0.31603569f, 
    0.64688259f, -0.49775568f, -0.92577994f, -0.27469486f, -0.80714780f, 0.48506099f, 0.03799332f, 0.07031694f, 
    -0.17511818f, 0.14976251f, 0.14947221f, -0.25727886f, -0.29815963f, -0.08688390f, -0.15572597f, -0.03635127f, 
    0.11860619f, 0.14177936f, 0.36425388f, 0.26134279f, 0.12038347f, 0.18841149f, -0.52344728f, -0.15244894f, 
    0.34000847f, -0.30824292f, -0.27548605f, -0.76749247f, 0.61473101f, -0.82991236f, -0.78502828f, -0.58380556f, 
    -0.49297649f, 0.46329287f, 0.48067293f, 0.17514621f, 0.22779772f, -0.56212771f, -0.38753721f, 0.27430791f, 
    -0.24425481f, -0.31769553f, 0.20210725f, 0.33255678f, 0.05692277f, 0.08027191f, 0.07234628f, -0.21097416f, 
    -0.11251295f, -0.36477700f, 0.20187181f, 0.89825267f, 0.63441199f, 0.97170466f, 0.61423248f, 0.51211345f, 
    0.63379717f, -0.35251883f, -0.29109016f, 0.03779631f, -0.23364307f, -0.02179436f, -0.09233003f, -0.04835565f, 
    0.28685918f, 0.08729013f, -0.24156611f, 0.62629092f, -0.50756025f, 0.31346619f, -0.35182554f, -0.17863639f, 
    -0.32184628f, -0.67829120f, -0.95055097f, -0.72443014f, -0.38800818f, 0.32013702f, -0.27522871f, 0.46377569f, 
    0.72242689f, 0.17534176f, -0.41114932f, -0.27463272f, -0.42350629f, -0.39702141f, -0.34032592f, 0.00284821f, 
    0.45140642f, 0.21274345f, -0.29739171f, 0.21157253f, -0.10729419f, -0.32677084f, 0.18461916f, 0.12860301f, 
    0.00272441f, -1.33904684f, 0.74447674f, 0.79532886f, -0.49646926f, -0.57253718f, 0.19829001f, -0.14689380f, 
    0.26730430f, 0.24700950f, -0.47910744f, -0.35580954f, 0.38719469f, -0.31784910f, 0.60698080f, -0.22096798f, 
    -0.49485502f, 0.04824566f, -0.57650352f, -0.50972342f, -0.63220721f, 0.26460546f, 0.26371238f, 0.07483847f, 
    0.00893427f, -0.24343002f, -0.91316068f, -0.70655882f, -0.42607969f, -0.43704185f, 0.81478399f, 0.70516878f, 
    -0.03916013f, -0.94706661f, 0.08018091f, -0.22977778f, 0.18192217f, 0.08259878f, -0.28096235f, 0.25838813f, 
    0.14541242f, 0.04628340f, -0.28563437f, -0.30089766f, -0.16005057f, 0.56074971f, 0.31745753f, 0.51360202f, 
    0.28234717f, -0.03030429f, -0.54643649f, -0.72511631f, -0.50244462f, 0.92428756f, 0.78334051f, -0.57196885f, 
    -0.34980229f, -0.78962797f, 0.39133453f, -0.52290356f, -0.49875823f, 0.15621771f, -0.11708333f, 0.05002542f, 
    0.37801495f, 0.06175070f, -0.13879608f, 0.21409336f, -0.25127819f, 0.01532759f, 0.26268068f, -0.33514634f, 
    -0.11347200f, 0.18757340f, -0.01495126f, 0.15298577f, 1.12718403f, 0.35226595f, 0.24993756f, 1.12694812f, 
    0.80742866f, 0.58888316f, -0.33185783f, -0.02514850f, 0.39679918f, 0.71230012f, -0.09930111f, -0.09468875f, 
    -0.13866900f, -0.36588043f, -0.23924863f, 0.16766186f, -0.20757993f, 0.28482276f, -0.20386684f, 0.35152453f, 
    0.09128734f, -0.31847286f, 0.19456565f, -0.15461686f, 0.15709905f, 0.00887487f, -0.17011401f, 0.73078305f, 
    0.57721972f, 0.20376807f, -0.71813756f, 0.12932551f, 0.49930695f, 0.45286712f, 0.05028528f, -0.34683511f, 
    -0.35748455f, -0.43109897f, -0.47137627f, -0.01882059f, -0.24332128f, -0.39635500f, -0.15565366f, -0.10872729f, 
    0.04432820f, -0.01467729f, 0.10353220f, -0.12049838f, 0.07044414f, -0.25200221f, 0.42087811f, 0.44339183f, 
    -0.71958286f, -0.85874861f, 0.17888941f, 0.78406632f, -0.69145966f, -0.61664474f, -0.91167605f, -0.41722813f, 
    -0.21559758f, 0.51751012f, 0.31607410f, 0.36125109f, 0.03127065f, 0.20178089f, 0.15039647f, 0.14714924f, 
    0.24422157f, 0.02944366f, 0.38293290f, -0.08491535f, 0.27648145f, -0.25870749f, 0.24407788f, 0.95253110f, 
    0.89426452f, 0.77982712f, 0.29176903f, 0.44928271f, -0.44877875f, -0.55791467f, 0.16040185f, 0.08373001f, 
    -0.12219866f, 0.38130084f, -0.29470000f, 0.03144449f, -0.06948850f, -0.61436039f, -0.35068631f, -0.34564137f, 
    0.10502430f, -0.24641596f, -0.53984243f, 0.13571504f, -0.14292276f, -0.02012404f, -0.17693210f, 0.21656193f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.18638253f, -0.04326947f, 0.07878251f, 0.29499659f, 0.06655088f, -0.23583208f, 0.20190243f, 0.08147454f, 
    0.16531947f, 0.24727137f, -0.00905318f, 0.36797288f, 0.21038786f, 0.33652228f, 0.10356487f, 0.05766034f, 
    0.32826766f, 0.02027187f, 0.12111982f, 0.23738088f, 0.07767312f, 0.12872717f, 0.32290527f, 0.09364286f, 
    -0.11894553f, -0.05035590f, 0.12260588f, 0.16131654f, -0.05073724f, 0.02113353f, 0.34073627f, 0.23334149f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.12705728f, -0.09392741f, 0.05383260f, -0.24090631f, -0.11450639f, -0.13350812f, 0.02429115f, 0.09239889f, 
    -0.03342697f, 0.06109382f, -0.06554719f, 0.00956005f, 0.03853160f, -0.12974897f, -0.15732695f, -0.25393590f, 
    -0.05179116f, -0.04897994f, -0.16623554f, -0.10831138f, -0.14622732f, -0.05136153f, -0.13412450f, 0.02731716f, 
    0.02918787f, 0.05214244f, 0.17005002f, 0.08643025f, -0.08563668f, -0.04381125f, 0.11282960f, -0.19021352f, 
    -0.05877062f, -0.12840730f, -0.20422448f, 0.08810590f, -0.46985406f, 0.17841031f, 0.00350025f, -0.64773965f, 
    0.07857077f, -0.09236705f, -0.02041631f, -0.08524399f, 0.00363979f, -0.13583514f, -0.03095531f, 0.00966621f, 
    0.13347216f, -0.12261334f, -0.06227123f, 0.25594661f, -0.00899154f, -0.03741834f, 0.11895929f, -0.07585366f, 
    -0.17864062f, 0.16900218f, -0.16107190f, 0.00032872f, 0.87773675f, 0.24444009f, 0.19028910f, -0.08189514f, 
    -0.08901919f, -0.01659384f, 0.11579337f, -0.02478410f, -0.01372855f, 0.00500034f, 0.06954917f, -0.15159738f, 
    0.15996407f, -0.06261588f, -0.06521031f, 0.13103087f, 0.03746821f, -0.02383502f, 0.11748774f, -0.02439356f, 
    -0.04589743f, 0.03671035f, -0.31579781f, 0.06309206f, -0.11173062f, 0.11327212f, -0.09356692f, 0.40388155f, 
    -0.02386061f, -0.03770553f, 0.16115685f, -0.07313674f, -0.12380864f, -0.07770336f, 0.02556941f, -0.04115134f, 
    0.14609282f, 0.14589711f, 0.01238903f, -0.25783566f, 0.00302044f, 0.07378813f, -0.03266404f, 0.03152646f, 
    0.03717164f, -0.04765570f, 0.01972749f, 0.01971601f, 0.27319252f, -0.08701643f, -0.12523812f, -0.00231742f, 
    -0.31422997f, 0.01106393f, -0.02783038f, 0.06430987f, 0.01439704f, -0.08809786f, -0.02548525f, -0.09564972f, 
    0.39367706f, -0.00384210f, -0.14939767f, 0.22103558f, -0.20925592f, 0.06494644f, 0.06003526f, -0.08778062f, 
    -0.05124011f, 0.07161453f, 0.03529335f, -0.00013705f, -0.35598910f, -0.23380598f, -0.17041372f, 0.13052891f, 
    -0.22936337f, -0.10921284f, -0.03410013f, 0.11560753f, 0.02868116f, 0.04762952f, -0.10493699f, -0.21743260f, 
    -0.17137618f, -0.04951885f, 0.02439715f, 0.03444039f, -0.25348470f, -0.05234529f, 0.04697659f, -0.02936671f, 
    0.13077193f, 0.08324984f, -0.16851555f, 0.02678212f, -0.17800501f, 0.02303199f, -0.08316109f, 0.29078633f, 
    -0.00852416f, 0.10643837f, 0.07739493f, -0.12847039f, -0.00170832f, 0.00147866f, 0.11524092f, -0.08606119f, 
    -0.30282491f, -0.23853338f, 0.02992045f, 0.05116751f, -0.00450101f, -0.24098128f, -0.10301014f, 0.03551044f, 
    0.02596572f, 0.06962916f, 0.05076477f, -0.02900155f, -0.35442382f, -0.04069348f, 0.02301065f, -0.27582240f, 
    -0.06702968f, -0.12760554f, -0.07985821f, -0.05971357f, -0.02211794f, -0.01518212f, 0.05782964f, 0.13318713f, 
    0.02647133f, 0.05734180f, -0.10291022f, 0.21673067f, 0.04293656f, 0.09039650f, -0.01643102f, 0.12838206f, 
    0.15025924f, 0.09087984f, -0.15058817f, -0.10641885f, -0.31237808f, 0.13552119f, -0.03473245f, -0.10779024f, 
    -0.08642678f, -0.00162682f, 0.17785266f, 0.03239425f, 0.15256809f, 0.20178972f, -0.01472852f, -0.08378713f, 
    -0.13179518f, -0.08326398f, 0.08070350f, -0.02750340f, 0.06630490f, -0.01629095f, 0.00396368f, -0.01179980f, 
    0.16867216f, -0.12954767f, 0.03537930f, 0.04299909f, -0.74907994f, 0.28471529f, 0.23643886f, -0.05150461f, 
    -0.14827736f, 0.21491526f, -0.03426966f, -0.20493105f, -0.03456408f, 0.16915071f, 0.11927189f, -0.05426587f, 
    -0.68365979f, 0.53218997f, -0.27722168f, 0.11704524f, -0.00822263f, 0.02687668f, -0.06964645f, 0.05786914f, 
    -0.04249559f, -0.03178979f, -0.08699816f, 0.09696898f, 0.08447775f, 0.02605651f, -0.20856141f, 0.26337123f, 
    -0.08962528f, -0.21226673f, -0.18352373f, 0.03612714f, 0.06355041f, -0.04223624f, -0.08033001f, 0.04361377f, 
    -0.36784205f, 0.00209023f, 0.05265571f, 0.10972408f, -0.00392017f, -0.02539359f, 0.04207129f, -0.01571727f, 
    -0.09359498f, 0.05416267f, -0.07014001f, -0.04814124f, -0.10389801f, 0.29832134f, 0.17068167f, 0.07112290f, 
    0.11077623f, 0.12230463f, -0.05975972f, 0.03944988f, 0.03834595f, 0.08202378f, -0.02201314f, 0.19840533f, 
    0.32487595f, 0.15700677f, -0.07787043f, -0.54492503f, 0.13022014f, 0.18057942f, 0.05899498f, 0.12991586f, 
    -0.24797930f, 0.07298685f, -0.06436832f, 0.03748101f, -0.23735133f, 0.14011982f, 0.05597245f, 0.19179282f, 
    0.09424178f, 0.03928396f, 0.06685890f, -0.05559831f, 0.09907628f, -0.04509186f, 0.13817686f, -0.00124835f, 
    -0.56732428f, -0.30452698f, 0.16176037f, -0.08802313f, 0.09827319f, 0.00804901f, 0.11288651f, -0.18671194f, 
    -0.05998706f, -0.14199695f, 0.18101884f, -0.00177061f, -0.38943210f, 0.12675008f, -0.34362802f, 0.50131249f, 
    0.10534655f, -0.01679258f, 0.06500109f, 0.00334436f, 0.05615204f, 0.00060456f, 0.09177384f, -0.05543988f, 
    0.29618478f, -0.19163728f, -0.00488116f, 0.48427472f, -0.27373350f, 0.16323613f, -0.00062964f, 0.12302507f, 
    0.01439783f, 0.13442652f, -0.17429167f, -0.15677206f, 0.12020715f, 0.00448239f, -0.00688053f, 0.29222649f, 
    -0.31011370f, 0.02719440f, 0.02056719f, -0.21639882f, 0.13395904f, -0.09128157f, 0.13497886f, 0.07519903f, 
    -0.07744725f, 0.02353345f, 0.25031403f, -0.42859966f, -0.14242248f, -0.04747929f, 0.16826615f, -0.03732087f, 
    -0.13464029f, -0.07236932f, -0.04215943f, -0.04734888f, 0.09912548f, 0.12314823f, 0.07361708f, -0.18672206f, 
    -0.25368246f, 0.08397679f, -0.04750398f, -0.05690302f, 0.08999709f, 0.05804520f, 0.10265364f, -0.15402587f, 
    0.32009000f, 0.11477419f, -0.06783839f, -0.20411989f, -0.06124135f, -0.09988028f, 0.02779930f, -0.04580363f, 
    -0.01310649f, -0.02305979f, 0.20052864f, -0.06506649f, 0.08610305f, -0.01368804f, 0.08902870f, -0.12932518f, 
    -0.00612461f, -0.00298016f, 0.12268090f, 0.03654689f, 0.04242532f, -0.04769147f, -0.07176328f, -0.19199842f, 
    0.11366370f, -0.08956662f, -0.11051727f, -0.07238528f, -0.06971532f, 0.09522935f, -0.01234723f, 0.02635311f, 
    -0.09351753f, 0.21331000f, 0.20499153f, -0.03712827f, 0.48306209f, -0.24830842f, -0.11636548f, -0.24551307f, 
    0.05751723f, 0.13201226f, 0.00711935f, 0.07591678f, 0.01380562f, -0.03520216f, 0.00024977f, -0.04203652f, 
    0.20945320f, 0.14134908f, 0.11845151f, 0.39360231f, -0.13825047f, 0.02000359f, 0.18323769f, 0.05324356f, 
    0.03590284f, -0.02123748f, 0.05448245f, -0.06894957f, -0.91944444f, -0.13362691f, -0.02581110f, -0.05748612f, 
    0.02609830f, 0.01889292f, -0.12347969f, -0.04928009f, 0.10297673f, 0.02218632f, 0.01072707f, 0.00367990f, 
    0.19894138f, 0.07841098f, 0.18897222f, 0.05196178f, 0.11550779f, -0.11153809f, -0.11749888f, -0.07601660f, 
    -0.01525139f, 0.02806895f, 0.14297359f, -0.12235828f, 0.00675637f, -0.17799564f, 0.02798137f, 0.13931216f, 
    -0.13850196f, 0.14104979f, -0.17616455f, 0.00348813f, 0.06960958f, 0.01077293f, 0.10128494f, -0.03400299f, 
    0.01043916f, 0.01122490f, -0.14998010f, 0.12529048f, -0.13970770f, 0.10783411f, -0.04762220f, -0.02065938f, 
    -0.11187828f, 0.06952122f, -0.25902513f, -0.02290170f, 0.33158022f, 0.06368273f, 0.06957736f, 0.25017208f, 
    0.06296443f, -0.07171125f, 0.00764051f, -0.02297252f, 0.09197155f, 0.01342392f, -0.03101431f, 0.12220746f, 
    -0.35534701f, -0.28037095f, 0.09357607f, 0.25517339f, 0.00967761f, -0.11985391f, -0.07815529f, 0.10443967f, 
    0.15820719f, -0.03227878f, 0.12180951f, -0.08429199f, 0.15211825f, -0.20695463f, -0.31311288f, 0.09712940f, 
    0.11671578f, 0.16124628f, -0.06117512f, 0.20241182f, 0.11595879f, -0.05351156f, 0.03758755f, 0.11791661f, 
    0.07324875f, -0.15783127f, 0.19470635f, 0.06063878f, -0.12077844f, 0.00329068f, -0.06044523f, -0.07505667f, 
    0.01254331f, -0.18357316f, 0.01244352f, -0.16571462f, 0.52548200f, 0.07025196f, -0.00057211f, 0.14455409f, 
    -0.07825176f, 0.07219122f, -0.00437639f, 0.08396342f, 0.07506089f, 0.01729171f, -0.11447912f, 0.01328789f, 
    0.10141298f, 0.04818868f, -0.05444773f, 0.11643717f, -0.12555028f, 0.07668824f, 0.02794475f, 0.10439836f, 
    -0.11823817f, 0.05081496f, 0.17454936f, -0.04502543f, 0.33393353f, -0.33795094f, -0.05275780f, -0.25015184f, 
    -0.03178054f, 0.02753922f, -0.13776225f, 0.26867312f, -0.13813816f, -0.05704582f, -0.16155848f, 0.07703248f, 
    -0.64395964f, 0.19635734f, -0.20583990f, 0.04519366f, -0.10904922f, -0.14014316f, 0.02702528f, 0.08884030f, 
    0.02038528f, -0.10133815f, -0.07029405f, 0.10963449f, 0.14619188f, -0.05940848f, -0.07365338f, 0.09332398f, 
    -0.08854020f, -0.11775738f, -0.18521033f, 0.09289509f, -0.09194858f, -0.24610333f, 0.05437102f, 0.11721392f, 
    -0.11236358f, -0.15384929f, -0.38085032f, -0.32749853f, 0.04766532f, 0.05029190f, -0.06579837f, 0.11779192f, 
    -0.07700029f, -0.12122083f, -0.23975745f, -0.19345136f, -0.35618481f, -0.19447924f, -0.29413909f, -0.08583124f, 
    0.00254831f, -0.01994858f, 0.00423388f, 0.03941853f, 0.08636802f, -0.08553331f, 0.04421502f, -0.19786613f, 
    0.47257411f, 0.00520083f, -0.09333962f, 0.06684748f, 0.09613968f, 0.02149875f, -0.11161558f, 0.04469921f, 
    -0.07499927f, -0.13134532f, 0.11834699f, 0.02945646f, 0.44891199f, -0.04783294f, -0.14747176f, 0.04813543f, 
    -0.08249324f, -0.05253814f, 0.15312546f, 0.07128374f, -0.08648886f, -0.01043699f, -0.03650827f, -0.04775141f, 
    -0.16885583f, 0.00183961f, -0.19506088f, -0.11550214f, -0.12432243f, 0.08031402f, -0.13089241f, 0.14673708f, 
    0.12746459f, -0.02977001f, -0.01497248f, -0.01337856f, 0.16590101f, -0.09454764f, -0.02590599f, 0.01884928f, 
    0.17094186f, -0.02750754f, -0.16319267f, 0.06807944f, 0.23049350f, 0.31492555f, 0.01530637f, -0.07543547f, 
    -0.00158561f, -0.17363052f, 0.02526595f, -0.37517953f, 0.05358546f, 0.01194976f, 0.04563211f, -0.01789316f, 
    0.32015118f, -0.09560953f, -0.02292493f, 0.03287909f, -0.41042078f, 0.21682073f, -0.34909618f, 0.02110562f, 
    -0.00160404f, 0.06467300f, 0.01745159f, -0.07358783f, 0.05042697f, -0.21532781f, -0.22124344f, -0.28146115f, 
    0.24808678f, 0.04706355f, -0.22803162f, -0.19483182f, -0.03222311f, -0.02737653f, -0.13411990f, -0.14283465f, 
    -0.14740454f, 0.13623770f, -0.17602333f, -0.20465825f, -0.44592249f, 0.31990451f, -0.14495714f, 0.01991883f, 
    0.09256671f, 0.01874385f, -0.08918409f, -0.20641874f, -0.11935405f, 0.05936638f, -0.00122696f, 0.01971766f, 
    0.38528910f, -0.02997726f, 0.21545337f, 0.21068732f, -0.07682367f, -0.04736449f, -0.01131900f, -0.02083838f, 
    -0.04077675f, -0.08129369f, -0.01366758f, 0.16201645f, -0.02511734f, 0.04452352f, 0.00442497f, 0.23761554f, 
    0.04505474f, -0.03299081f, -0.01544419f, -0.02834684f, -0.04123737f, 0.01265260f, -0.36162645f, -0.12603694f, 
    0.12830704f, -0.21502985f, 0.05428220f, -0.26438102f, -0.10084766f, -0.03385049f, 0.03791392f, -0.00388519f, 
    0.00749709f, 0.20382303f, 0.03251465f, 0.05669306f, 0.09403098f, 0.04069482f, 0.03103850f, 0.25283015f, 
    -0.02148069f, 0.01500177f, 0.09696540f, 0.04850947f, 0.02075515f, -0.09760331f, -0.07902791f, 0.13709450f, 
    -0.42707622f, 0.10898148f, -0.04960109f, -0.17761102f, 0.16623098f, -0.11178425f, 0.07599921f, 0.04253403f, 
    -0.05932178f, 0.00468373f, -0.00419990f, -0.04681886f, -0.04439769f, -0.07732850f, -0.04925419f, -0.12750299f, 
    -0.08127860f, -0.05927423f, -0.09953943f, 0.07421301f, -0.10192079f, 0.03419867f, -0.01593476f, 0.11514322f, 
    -0.14656474f, -0.28482169f, 0.11041884f, 0.11796527f, 0.08175044f, -0.11958387f, 0.04972684f, -0.12073308f, 
    0.00360709f, -0.05177083f, -0.12140470f, 0.09315909f, 0.34867808f, 0.18705842f, 0.07387920f, 0.34239200f, 
    -0.13035981f, -0.25713024f, 0.05151748f, 0.03637864f, -0.11689661f, -0.00248019f, 0.05281864f, 0.05794128f, 
    -0.34065053f, -0.03220589f, 0.00956430f, -0.32246628f, -0.03767994f, 0.02459846f, 0.02984628f, 0.00326711f, 
    0.02474996f, 0.21241628f, -0.00308108f, 0.09419581f, 0.53874987f, 0.01582160f, 0.11982600f, 0.03267159f, 
    0.05443291f, -0.09895975f, 0.00048695f, 0.07421383f, -0.14189120f, 0.11283403f, 0.04652907f, -0.12480848f, 
    -0.04901748f, 0.11076598f, 0.01786293f, 0.02316212f, -0.10240162f, 0.00269978f, 0.11546734f, 0.15716550f, 
    -0.08072902f, 0.01940767f, 0.10124107f, -0.11876138f, 0.38867941f, -0.05721794f, -0.04962857f, -0.03236824f, 
    0.22357503f, -0.09898596f, 0.07670660f, -0.00902382f, 0.00730786f, 0.01119885f, -0.09579009f, -0.03702141f, 
    0.26472303f, 0.12807386f, 0.09146339f, 0.13122353f, -0.14650747f, -0.18597245f, -0.10556403f, 0.03521086f, 
    0.14521436f, -0.08191615f, 0.00265204f, -0.09197633f, 0.06826041f, 0.02925952f, -0.06905540f, 0.10296181f, 
    0.13726959f, 0.05093288f, 0.03832042f, 0.00355174f, 0.02000711f, 0.01460415f, 0.02966112f, -0.01269069f, 
    0.18583085f, -0.00714294f, -0.07374667f, 0.03564817f, 0.00275236f, 0.20805368f, -0.01839794f, 0.11100266f, 
    -0.10589235f, -0.03812748f, -0.00283761f, 0.00882155f, 0.22232638f, -0.37329772f, 0.18701872f, -0.09062026f, 
    -0.14244348f, 0.02531070f, 0.01625222f, -0.06118668f, 0.02413166f, -0.11490856f, 0.09371015f, -0.08187488f, 
    0.37626842f, -0.29799181f, -0.06436952f, 0.23370755f, 0.14634314f, 0.05480596f, 0.01807218f, -0.23270684f, 
    -0.13030480f, -0.02437664f, -0.02448380f, 0.06491175f, -0.05606891f, -0.23078993f, 0.04331496f, -0.06971400f, 
    -0.00640222f, 0.03950996f, -0.08099453f, -0.06719600f, 0.06254488f, 0.07637489f, 0.00931512f, -0.13450095f, 
    0.55437040f, -0.25134465f, 0.01470930f, -0.03059317f, -0.08110934f, 0.04185449f, -0.05566423f, 0.06445599f, 
    0.07147579f, -0.09124037f, -0.03856455f, -0.18725005f, -0.19195260f, 0.23576058f, -0.09344021f, 0.14100096f, 
    0.00806879f, -0.07304841f, 0.14351235f, 0.02977648f, -0.00904574f, 0.04088535f, -0.00446461f, 0.01889155f, 
    0.05761161f, -0.26443663f, -0.38230586f, -0.25479889f, -0.17529665f, -0.06103925f, -0.03116557f, 0.00807959f, 
    0.02422061f, 0.00655211f, 0.07867195f, -0.03854556f, 0.21997926f, -0.03686335f, 0.01150435f, 0.24857475f, 
    -0.18749292f, -0.09503822f, -0.04930072f, -0.00647596f, -0.04991393f, 0.02027293f, 0.07381535f, -0.02175754f, 
    -0.23601523f, -0.18320052f, -0.15242325f, -0.42510867f, 0.04989134f, 0.06257742f, -0.08357801f, -0.08543687f, 
    -0.01144607f, 0.05145369f, -0.05810381f, -0.10821786f, -0.24608688f, -0.25642911f, -0.06181757f, -0.49435967f, 
    0.00847549f, 0.14819418f, 0.04179844f, 0.07247546f, -0.03073369f, -0.08364048f, -0.08721365f, -0.19876415f, 
    0.62298894f, -0.31561500f, -0.01681931f, 0.10172665f, -0.10207028f, 0.06625410f, -0.14281212f, -0.01183139f, 
    -0.02759575f, 0.10583925f, 0.11698008f, 0.03508770f, -0.06049315f, 0.14940725f, -0.20186223f, -0.14403112f, 
    0.02477800f, 0.03864237f, -0.00654223f, 0.01304395f, -0.05520081f, 0.09942804f, 0.08728739f, -0.03611686f, 
    0.22552052f, 0.10135432f, -0.19706734f, -0.32711923f, -0.16556837f, -0.07956123f, 0.05169204f, 0.06113631f, 
    0.09498315f, 0.09184824f, -0.14216204f, -0.06552857f, 0.13530706f, -0.05408257f, 0.05713092f, 0.13658181f, 
    -0.04687186f, 0.03500414f, 0.01872409f, -0.00550655f, 0.05526950f, -0.14564900f, -0.10140172f, 0.04648723f, 
    -0.20429756f, 0.06883709f, 0.13393174f, 0.40886045f, -0.14322010f, -0.19753300f, -0.07358368f, 0.16219983f, 
    -0.00164697f, 0.08158861f, 0.03043259f, 0.14053613f, 0.40618163f, 0.11622859f, -0.36578760f, -0.08443745f, 
    -0.22341961f, 0.07483778f, -0.11924533f, -0.07839035f, -0.12363736f, 0.00466877f, 0.03242650f, -0.03779026f, 
    0.11004891f, -0.29241803f, 0.10268375f, -0.14790265f, -0.16406241f, 0.15722148f, -0.00611746f, -0.04497491f, 
    0.01968448f, -0.11864591f, -0.00830357f, -0.06708954f, 0.05443439f, 0.04329133f, -0.59945059f, 0.00363456f, 
    0.04053775f, 0.09084789f, -0.18442060f, 0.04353826f, -0.02785522f, 0.02408072f, 0.00063334f, -0.21657951f, 
    0.12315004f, -0.04834126f, -0.06976271f, 0.05843281f, 0.03954226f, 0.07496428f, -0.02417478f, 0.02119660f, 
    0.00649656f, -0.00235168f, -0.02550772f, -0.14261495f, -0.16384481f, 0.13522926f, -0.29005218f, -0.09409996f, 
    0.05207335f, -0.03867977f, 0.05242297f, 0.01197938f, 0.09366746f, 0.02165084f, 0.12031727f, -0.04706466f, 
    -0.63273048f, -0.15616626f, 0.03680107f, -0.36677068f, 0.03240123f, -0.25369704f, 0.05048638f, 0.03946097f, 
    -0.13040319f, -0.12639031f, -0.21771628f, -0.05592031f, -0.13686860f, 0.08639561f, -0.31153530f, -0.07223596f, 
    0.12967956f, -0.01590757f, 0.05412526f, -0.09890153f, -0.07602215f, 0.10187555f, 0.00140035f, 0.03682778f, 
    -0.23268513f, -0.52098864f, -0.39724907f, 0.04091256f, -0.14067152f, -0.04332729f, 0.01872554f, 0.18893002f, 
    -0.03956043f, 0.05383873f, -0.14731073f, -0.08408296f, 0.08295763f, -0.24829133f, 0.07431234f, 0.23608652f, 
    -0.15629297f, -0.02878949f, 0.19436739f, 0.08240817f, -0.09587129f, 0.18019564f, -0.00255697f, 0.12221631f, 
    0.16463526f, -0.15845680f, 0.00895289f, 0.26788020f, 0.13039663f, -0.06801989f, 0.03965892f, 0.02765032f, 
    -0.04355172f, -0.11025728f, -0.09214235f, -0.18535173f, -0.11303362f, -0.19115636f, -0.03016028f, -0.03012756f, 
    -0.00116950f, -0.03348358f, -0.06108554f, -0.04510222f, -0.21179011f, -0.04891218f, -0.06739571f, 0.04754408f, 
    -0.06062205f, -0.38347924f, -0.08591087f, 0.17821291f, -0.02474182f, 0.19356038f, -0.02109539f, -0.11330386f, 
    -0.04480455f, -0.04963035f, 0.12420884f, 0.10394989f, 0.00776984f, 0.40703931f, -0.01421537f, -0.21771996f, 
    0.13831776f, -0.03476357f, -0.00973595f, 0.09486454f, 0.08795695f, -0.07977116f, 0.06487101f, -0.01323117f, 
    -0.20236312f, -0.13018759f, -0.21469560f, -0.18334962f, 0.00200537f, 0.02217101f, -0.11737230f, 0.03393722f, 
    0.01214048f, 0.08803365f, 0.13565601f, -0.18662612f, -0.21170665f, -0.03752560f, 0.11644111f, 0.09806515f, 
    -0.06316145f, 0.07240900f, 0.06340250f, -0.08998034f, -0.02036772f, -0.00259462f, -0.20072691f, -0.04927209f, 
    0.24637516f, -0.08931360f, -0.11562750f, -0.04556962f, -0.01760282f, -0.10562986f, 0.02266523f, -0.10359334f, 
    -0.09859271f, -0.08506815f, 0.09708811f, -0.07968111f, -0.79132086f, -0.54153877f, -0.07708368f, -0.07754362f, 
    -0.20949030f, 0.02547066f, 0.09642038f, -0.04412496f, -0.02015605f, -0.24806163f, 0.15616801f, 0.04995411f, 
    -0.32372534f, -0.06173776f, 0.37869537f, 0.35853767f, 0.01735289f, 0.28282729f, 0.05692802f, -0.10606127f, 
    -0.08934785f, -0.03448600f, 0.03337651f, -0.03827923f, 0.00954094f, 0.16362588f, 0.09959675f, 0.01539874f, 
    -0.13595679f, -0.13318226f, -0.02197517f, -0.10643338f, -0.17450166f, 0.03718963f, 0.11376619f, -0.00411381f, 
    0.83580393f, -0.21312200f, 0.00616045f, 0.16289543f, -0.07160659f, -0.05257110f, -0.07374106f, 0.04974882f, 
    -0.05818948f, 0.02528683f, 0.03892004f, -0.04669878f, -0.63602322f, -0.17986487f, -0.18115148f, -0.02397908f, 
    -0.15991324f, 0.09785106f, 0.04260107f, -0.13675934f, 0.04110402f, 0.04586280f, -0.04794386f, -0.05436259f, 
    -0.15917265f, 0.11103923f, 0.01001953f, 0.00027904f, 0.01105097f, 0.05752085f, -0.02395295f, 0.04185045f, 
    0.25155392f, 0.04096152f, -0.08595154f, 0.13449542f, 0.12988843f, -0.50281775f, -0.05545086f, 0.05683659f, 
    -0.12289575f, 0.23870969f, 0.00531058f, 0.07575212f, 0.04396486f, 0.03439904f, 0.00507792f, 0.12930524f, 
    0.10039338f, 0.24678713f, 0.06580007f, -0.12591843f, 0.05580000f, -0.08359124f, -0.05533660f, -0.02547866f, 
    0.00991618f, 0.01960192f, -0.01477324f, -0.02077815f, 0.15059966f, 0.03645283f, -0.00256474f, -0.05786173f, 
    -0.08883762f, 0.01121197f, 0.10702164f, -0.01484421f, -0.08189535f, 0.00818198f, -0.04857124f, -0.04001209f, 
    0.49760324f, -0.03488943f, 0.07823449f, 0.15745220f, 0.09383965f, 0.04861105f, -0.00972182f, 0.05027523f, 
    0.12504873f, -0.02656705f, -0.02768036f, 0.04656117f, 0.15625550f, 0.08611473f, 0.22606437f, 0.00839455f, 
    0.08590838f, 0.00087564f, 0.08501350f, 0.08253253f, 0.04238082f, -0.13494073f, -0.16518337f, -0.04352444f, 
    0.20005243f, -0.05712533f, 0.06565136f, 0.09022070f, -0.12162820f, -0.17739025f, 0.16986446f, -0.04243038f, 
    -0.15772951f, -0.04293144f, -0.12614593f, 0.04445086f, -0.14560145f, -0.50547326f, -0.33883399f, -0.03651688f, 
    0.03246840f, 0.00724363f, -0.08356301f, 0.06619762f, 0.07573838f, -0.00820517f, -0.04784829f, 0.02408265f, 
    0.02760393f, 0.33514893f, 0.24224856f, 0.03909156f, -0.01898292f, 0.00026246f, -0.08371914f, -0.04368281f, 
    0.01426203f, 0.16351403f, -0.07388136f, 0.18977867f, -0.32026508f, 0.11972188f, -0.22235176f, -0.24297170f, 
    -0.07050817f, -0.06865702f, 0.17687374f, 0.03927395f, -0.07890712f, 0.00282101f, -0.02508119f, -0.19989720f, 
    -0.05687877f, -0.01674580f, 0.00524897f, -0.19091728f, -0.13285179f, -0.09457133f, 0.01175459f, -0.03389294f, 
    -0.17995514f, -0.00045252f, -0.09447317f, 0.03775797f, -0.05537394f, 0.40214810f, 0.09197245f, -0.13809495f, 
    -0.11623244f, 0.11478393f, 0.02566999f, -0.00058886f, 0.00668032f, 0.26491433f, -0.00550519f, 0.06952961f, 
    0.24519575f, 0.12598881f, -0.03898025f, 0.14755917f, -0.06124293f, 0.02663437f, 0.04925236f, 0.13783087f, 
    -0.05841557f, -0.05088641f, 0.09959012f, -0.27434725f, 0.17427063f, -0.13171576f, 0.22978912f, 0.09220713f, 
    0.08420695f, -0.04474850f, 0.01423531f, -0.12974063f, -0.00249768f, -0.13413538f, 0.08652677f, 0.03453674f, 
    -0.21820675f, -0.09968473f, -0.36822349f, 0.17311005f, -0.01937609f, 0.04258685f, 0.07041144f, -0.10373122f, 
    0.03933796f, 0.06479201f, -0.04284949f, 0.05936266f, -0.21800223f, -0.00959735f, 0.08857179f, -0.00352041f, 
    0.06970087f, 0.00699055f, 0.00865524f, -0.03727366f, -0.05672748f, -0.00456843f, 0.08232298f, -0.05196324f, 
    0.33941004f, 0.06212094f, -0.05247353f, 0.03940957f, -0.01395686f, -0.01981980f, 0.07051868f, 0.09612338f, 
    -0.02751802f, -0.03869128f, -0.15288396f, -0.08677236f, 0.09122203f, -0.52761352f, -0.39446801f, 0.24402346f, 
    -0.01837794f, 0.04340284f, 0.06556467f, -0.03945405f, 0.03074666f, 0.06991641f, 0.00761694f, -0.05789542f, 
    -0.23591773f, -0.29411900f, 0.28450507f, -0.18956833f, -0.18032894f, 0.21508665f, -0.15402463f, -0.05836500f, 
    0.13163108f, 0.18246818f, 0.09437913f, 0.00228490f, -0.23583908f, -0.45439228f, -0.03173617f, 0.17505778f, 
    0.16748857f, 0.06855862f, 0.10857266f, 0.01227621f, -0.09898975f, -0.06727343f, 0.13224557f, 0.12229192f, 
    -0.19206470f, 0.31577167f, 0.18049382f, -0.03607882f, 0.10278141f, -0.11572870f, -0.14761281f, 0.10398294f, 
    0.14927806f, -0.26703474f, -0.13227931f, 0.09237445f, -0.58112532f, 0.04402078f, 0.27450889f, 0.26512796f, 
    -0.04868219f, 0.06241350f, 0.00294955f, -0.03631131f, 0.06651828f, 0.05223840f, 0.08012639f, 0.00737258f, 
    -0.22362845f, 0.20983048f, 0.20291786f, -0.06069521f, 0.08678509f, 0.12148636f, -0.15126072f, 0.02472128f, 
    -0.15484422f, -0.07532037f, 0.09388751f, 0.19942906f, 0.10556533f, 0.52825332f, -0.08667132f, 0.09805921f, 
    0.12877338f, -0.04430577f, 0.14713380f, -0.02847997f, -0.03270459f, 0.16675079f, 0.10754106f, 0.02590405f, 
    -0.56856179f, 0.13492508f, 0.12447270f, -0.10997382f, -0.03372930f, -0.00444767f, -0.22150172f, -0.08198881f, 
    0.03184856f, 0.01547921f, -0.03211960f, 0.03573327f, 0.11368181f, 0.08171951f, -0.17034581f, -0.15919977f, 
    -0.13911536f, -0.13247113f, 0.03756776f, -0.10137742f, -0.11174832f, 0.02725545f, -0.04081028f, 0.11872371f, 
    -0.65937632f, 0.05211629f, -0.11223984f, -0.07570641f, 0.13700493f, 0.07242635f, -0.11094566f, 0.10916783f, 
    -0.02507121f, -0.25979131f, 0.02762927f, 0.05878504f, 0.17801203f, 0.03948564f, -0.04066295f, 0.04025929f, 
    -0.13428620f, -0.00226229f, 0.05751360f, 0.08711072f, 0.01462185f, 0.16491950f, -0.02566998f, -0.16371974f, 
    -0.55957752f, -0.17171349f, 0.12147177f, -0.00245971f, 0.13075770f, 0.07240060f, -0.05751960f, -0.08434222f, 
    0.05366940f, 0.02604881f, -0.18007530f, -0.14802091f, -0.06981384f, 0.32175022f, 0.11513120f, 0.05700134f, 
    0.14686289f, -0.07480261f, -0.13904510f, 0.16580665f, -0.00037170f, 0.17523152f, -0.02067050f, -0.22398257f, 
    -0.12319058f, 0.24563378f, -0.05111584f, -0.20736298f, -0.17701937f, 0.09064406f, -0.01165272f, 0.19969212f, 
    -0.06611455f, 0.02110539f, -0.02403974f, 0.13593122f, -0.23426592f, 0.04759403f, -0.21192567f, -0.00124110f, 
    -0.02582899f, -0.00387043f, 0.10744666f, 0.15891479f, 0.04562095f, 0.11596590f, -0.02060701f, -0.16806461f, 
    -0.12688278f, 0.13505837f, 0.30074269f, 0.27242982f, 0.09238080f, 0.01457243f, -0.10414924f, 0.01888135f, 
    0.17256804f, -0.02283358f, -0.09056209f, 0.03440260f, 0.13433048f, -0.22845337f, -0.22275113f, 0.01869957f, 
    -0.24352409f, -0.19415481f, 0.10788884f, -0.15147226f, -0.07605927f, 0.06624860f, 0.06461482f, -0.02506913f, 
    0.07182273f, -0.18322589f, -0.08869012f, -0.33466113f, 0.01596957f, 0.09886038f, -0.09359118f, 0.00963110f, 
    -0.05281627f, -0.18502530f, -0.11958198f, -0.02406028f, -0.40459591f, 0.09340832f, 0.05036731f, 0.03830229f, 
    0.15031029f, 0.19224912f, 0.07826641f, 0.05532787f, -0.18117610f, -0.02182486f, -0.06099987f, 0.04920012f, 
    0.23082767f, 0.16718131f, 0.07128641f, 0.10535724f, -0.09558108f, 0.13473247f, 0.11562509f, 0.10149992f, 
    0.02729161f, 0.05502197f, 0.14814362f, 0.11782230f, 0.59678912f, 0.02862632f, 0.17653042f, -0.46578979f, 
    0.01507591f, -0.08354159f, -0.08559220f, -0.03028145f, -0.20186868f, -0.07944047f, -0.18516824f, 0.00757088f, 
    -0.15256870f, 0.03740459f, -0.27657941f, 0.08068822f, 0.05469032f, 0.01035121f, 0.02512173f, 0.11506339f, 
    0.10446762f, 0.00882364f, 0.01390409f, -0.02136649f, -0.20956720f, -0.17384538f, 0.28655121f, 0.33783722f, 
    -0.27580315f, -0.11977657f, 0.03486761f, -0.07380237f, 0.12365300f, -0.05248013f, 0.11989526f, -0.05236559f, 
    -0.48725265f, -0.09676547f, 0.29851303f, -0.03978977f, -0.05585453f, 0.02637568f, 0.02942989f, -0.09132224f, 
    0.02770289f, -0.10298165f, -0.05723735f, 0.05632602f, -0.11208790f, -0.20601143f, -0.11200735f, 0.08777338f, 
    -0.09413836f, 0.05795107f, 0.28489465f, -0.16750465f, -0.04436313f, -0.12963440f, 0.06778672f, -0.04047569f, 
    -0.24698991f, -0.40473434f, -0.16337959f, 0.44728661f, 0.05398511f, -0.10470008f, -0.09736160f, 0.14335763f, 
    0.04510390f, -0.01492465f, 0.20990640f, -0.01321698f, 0.62699240f, 0.06427003f, -0.15407144f, -0.42059883f, 
    -0.01447711f, 0.01805114f, 0.04696641f, -0.02702972f, -0.01853970f, -0.03123700f, -0.13991560f, 0.17785348f, 
    -0.25277480f, 0.24061367f, -0.14754836f, -0.26133516f, 0.08710567f, 0.04039110f, 0.00266999f, 0.14899601f, 
    0.01017895f, -0.09383833f, 0.11035606f, 0.04336901f, -0.08357642f, -0.17174992f, 0.17286837f, -0.13524942f, 
    -0.10471729f, 0.10174616f, -0.12056953f, -0.08018588f, -0.08419265f, -0.20187102f, -0.10014135f, -0.03845548f, 
    0.14118171f, -0.11679310f, -0.15818478f, -0.03963510f, 0.07587831f, -0.01002549f, 0.15035374f, -0.00444469f, 
    0.02458366f, -0.15173835f, 0.04256284f, 0.08016966f, 0.17456804f, 0.09256326f, 0.09482118f, 0.09671061f, 
    -0.03519992f, 0.11828157f, 0.11447406f, -0.02591767f, -0.07351031f, 0.13344719f, 0.12221789f, 0.12423043f, 
    -0.05178191f, -0.10046961f, 0.00836736f, 0.17993912f, -0.10106597f, 0.02804695f, 0.06569645f, 0.03591260f, 
    -0.08145431f, -0.07756034f, 0.00173768f, -0.07233870f, -0.02481696f, -0.06183014f, 0.19877642f, 0.10990735f, 
    -0.19208354f, -0.02681312f, -0.01113596f, 0.01894096f, 0.05151561f, -0.02310224f, -0.09011462f, -0.11136055f, 
    0.17894448f, 0.23011063f, -0.06514468f, 0.16084173f, -0.06057221f, -0.03125457f, 0.13367675f, 0.05281742f, 
    0.02751664f, -0.00801053f, -0.00876342f, -0.00375440f, 0.22392355f, 0.15907514f, -0.10593102f, -0.23611359f, 
    0.08937048f, 0.08841402f, -0.04803598f, 0.01028320f, -0.15123373f, -0.20962475f, -0.02647719f, -0.38195863f, 
    0.11471695f, -0.14167364f, 0.00560875f, 0.02111197f, -0.13580678f, 0.05239575f, -0.11023650f, 0.04252504f, 
    -0.17050388f, 0.21611054f, 0.17011298f, 0.11272369f, -0.41416064f, -0.13956390f, -0.36522329f, -0.07113123f, 
    0.04268490f, 0.08421919f, -0.01589515f, 0.02995771f, -0.00125743f, 0.04632061f, -0.13670269f, 0.07405948f, 
    -0.00321820f, -0.03422856f, 0.07669791f, -0.01253827f, 0.00431796f, -0.20516241f, -0.29630339f, 0.26864016f, 
    0.19928765f, -0.15139133f, -0.06584873f, -0.41378212f, -0.14836729f, -0.13450892f, 0.08547947f, 0.02799759f, 
    0.13505872f, -0.03017013f, -0.07306325f, -0.32643986f, 0.09856877f, -0.27076399f, -0.06312525f, 0.03813664f, 
    -0.21143924f, 0.10379268f, -0.20764749f, 0.09514110f, -0.05350447f, 0.04875769f, -0.04247805f, -0.18802436f, 
    -0.00417539f, -0.07767431f, -0.03262706f, 0.15592901f, -0.19862857f, 0.11045613f, 0.06192115f, -0.42946696f, 
    0.02782265f, 0.11533284f, -0.11235008f, 0.07843111f, 0.11161979f, -0.11198819f, -0.06439320f, -0.08841392f, 
    -0.71036983f, 0.03652217f, -0.36226273f, -0.28808963f, 0.14533110f, 0.03592329f, 0.32343340f, -0.02697781f, 
    0.05391200f, 0.13866910f, 0.04944403f, -0.12211984f, -0.02554432f, 0.04337417f, 0.16835564f, -0.01525350f, 
    0.05388948f, 0.02923009f, 0.09659782f, -0.09478828f, 0.01154570f, 0.10450359f, 0.22807558f, 0.18412195f, 
    0.07309108f, 0.10680103f, -0.02141290f, -0.14790899f, -0.13376527f, -0.07026009f, -0.07520282f, -0.01572020f, 
    0.09354697f, -0.13821511f, 0.05851286f, 0.11732958f, -0.25564858f, -0.21500702f, -0.11023338f, 0.02560755f, 
    -0.02134458f, -0.07720920f, 0.07607239f, -0.12383857f, -0.15070653f, 0.14986993f, 0.00485509f, 0.12747568f, 
    0.01113387f, -0.21630003f, 0.20121558f, 0.14551412f, 0.13154919f, 0.00512063f, 0.06530479f, 0.02529285f, 
    0.04565420f, -0.04542610f, 0.01537038f, 0.04700486f, -0.32963100f, 0.24877007f, 0.24809742f, -0.05630440f, 
    0.12474706f, -0.04786787f, 0.05880449f, -0.01966377f, 0.02816011f, -0.00444529f, -0.19279000f, 0.22238973f, 
    -0.36640766f, -0.07404383f, -0.11580596f, -0.14417619f, 0.08288010f, 0.03370971f, 0.06999761f, 0.00741852f, 
    -0.22925541f, -0.17481527f, 0.07575943f, 0.05272159f, 0.10043753f, 0.27844006f, 0.00624612f, -0.03502832f, 
    -0.04257127f, -0.04009548f, 0.05005376f, -0.24545163f, 0.05866351f, -0.10155539f, 0.08777234f, -0.05108665f, 
    0.11365982f, 0.08397827f, 0.06185174f, 0.27016664f, 0.00815793f, 0.01915437f, 0.06789964f, 0.12795702f, 
    0.24887797f, 0.05506021f, 0.05286255f, -0.00247681f, -0.34302413f, -0.12173096f, -0.24746470f, -0.12968850f, 
    0.03434488f, 0.00028925f, 0.05177040f, -0.13885587f, 0.24676995f, -0.06221845f, -0.14874111f, -0.01832340f, 
    0.07329017f, 0.25337937f, 0.27430740f, 0.15726846f, 0.00239789f, 0.03215416f, 0.16349135f, -0.07819867f, 
    -0.14426117f, 0.20204601f, 0.05413595f, -0.11876065f, -0.41835129f, -0.24740720f, 0.04569528f, 0.22024736f, 
    -0.17776473f, -0.14968602f, 0.00039055f, 0.14994480f, 0.24089247f, -0.08156029f, -0.06991838f, 0.12174138f, 
    -0.71898973f, -0.09472162f, -0.12276945f, -0.44615340f, 0.11950342f, 0.07832415f, -0.08434128f, -0.06717226f, 
    0.01738155f, 0.05345555f, -0.20510775f, 0.03838585f, -0.08218338f, -0.00446098f, 0.10894525f, 0.00762417f, 
    -0.03321175f, -0.03363985f, 0.01768614f, 0.02482284f, 0.01705676f, -0.21637157f, -0.08506682f, -0.08538812f, 
    0.10035024f, 0.08619162f, 0.18404177f, 0.34837717f, 0.07393654f, 0.07799268f, -0.03071544f, 0.08104275f, 
    -0.11688480f, 0.04889020f, 0.22842148f, -0.18385154f, 0.06906847f, 0.37694824f, 0.21480007f, -0.26344401f, 
    -0.11113637f, 0.07179696f, 0.02812955f, -0.06815106f, 0.23218293f, -0.20136619f, 0.14984035f, -0.32844257f, 
    0.21576841f, -0.02707010f, -0.13623999f, 0.00783138f, 0.03486997f, 0.07176676f, 0.07649166f, -0.18525340f, 
    0.04997703f, -0.06945267f, -0.11838987f, -0.03427368f, -0.37818599f, -0.29126298f, 0.21418297f, 0.22773658f, 
    -0.03907315f, -0.23603332f, -0.03573642f, 0.24506563f, -0.09506915f, 0.04985460f, -0.18918847f, -0.10878012f, 
    -0.24217749f, -0.32593098f, 0.07898171f, -0.02936716f, 0.03824179f, 0.02181667f, 0.02184124f, 0.11517601f, 
    -0.00591930f, 0.23367627f, -0.16183503f, 0.13613310f, 0.12651339f, -0.31456098f, 0.02907959f, -0.09691037f, 
    -0.09925683f, -0.05091950f, 0.11480981f, 0.06620438f, -0.02482228f, 0.09388764f, 0.08785893f, 0.07667688f, 
    0.09367660f, -0.08059486f, 0.06318136f, -0.21945551f, 0.13419841f, -0.04037606f, -0.03634442f, 0.08843451f, 
    0.19847572f, 0.00829907f, -0.00301173f, 0.10274426f, 0.03825373f, 0.25530002f, -0.02715498f, -0.10139448f, 
    -0.03296884f, -0.00160345f, 0.03726326f, 0.12990294f, 0.04301110f, 0.09860863f, -0.06983770f, -0.22212534f, 
    -0.31818914f, -0.00535894f, 0.21304615f, 0.32325724f, 0.02789239f, -0.06851131f, 0.00067275f, -0.02999511f, 
    0.15001570f, 0.16092180f, 0.24935383f, 0.10142729f, 0.06664188f, -0.06918433f, 0.02924198f, 0.31526244f, 
    0.04529916f, 0.05141218f, 0.02972892f, -0.01542945f, -0.13404362f, -0.33560285f, -0.06849661f, 0.08082963f, 
    -0.37488928f, 0.07003420f, -0.17005002f, 0.47484678f, -0.04897778f, 0.10305277f, -0.11727430f, -0.06107441f, 
    -0.00494466f, -0.05112715f, -0.17245911f, -0.15564309f, -0.22296640f, 0.22524852f, -0.00625736f, 0.19414237f, 
    -0.18817861f, 0.09380554f, 0.03184040f, -0.01446547f, 0.08694606f, 0.13381514f, -0.12954831f, 0.16593876f, 
    0.15408094f, -0.00889636f, -0.18379775f, -0.28700662f, 0.06148229f, 0.20610915f, 0.07304952f, -0.00902223f, 
    0.06875198f, -0.19291255f, -0.03390822f, -0.19586527f, -0.26998752f, -0.23020111f, -0.11562166f, -0.19880421f, 
    0.14628196f, -0.00858776f, -0.10557673f, -0.00033532f, -0.06125457f, -0.03215127f, 0.09418364f, 0.01763376f, 
    0.39470658f, -0.06872186f, 0.01927290f, -0.24298422f, -0.05967368f, 0.04722551f, 0.00567380f, -0.10577223f, 
    -0.06794015f, 0.10344090f, -0.01929450f, 0.24651863f, 0.18594536f, -0.59029996f, -0.15589459f, 0.14462732f, 
    -0.24376440f, 0.03799919f, 0.11614211f, 0.05023064f, 0.08524909f, 0.11599846f, -0.08615966f, 0.01193578f, 
    0.02521413f, -0.23114631f, -0.09698877f, 0.22647168f, -0.12951051f, 0.16610691f, 0.21283686f, 0.02341953f, 
    0.02432274f, -0.16235657f, 0.16690746f, 0.13849099f, 0.42812130f, -0.15828884f, 0.30895478f, -0.08262654f, 
    0.03291066f, 0.08180197f, 0.14744027f, 0.13317499f, 0.00924477f, 0.02883259f, 0.06730074f, -0.06997117f, 
    0.18118751f, -0.34817249f, 0.22079182f, -0.01091432f, -0.06000600f, 0.00855934f, -0.01830064f, -0.22383825f, 
    0.05783451f, -0.01472387f, 0.01620254f, 0.01154099f, -0.10492015f, 0.30142450f, 0.16825394f, -0.44278130f, 
    -0.02957869f, 0.05313532f, -0.08984750f, 0.01252268f, -0.09137893f, 0.05075622f, -0.28102240f, -0.12129740f, 
    0.61017394f, 0.19964358f, 0.16204937f, -0.31593099f, -0.03741109f, 0.09027445f, 0.15379819f, 0.04606057f, 
    -0.02684207f, 0.05203187f, -0.18459016f, 0.06222691f, 0.10300536f, 0.27243158f, -0.05615963f, -0.11655898f, 
    0.06001018f, -0.07706254f, -0.00975047f, -0.14765854f, -0.06105639f, -0.08361884f, 0.16370589f, -0.04082794f, 
    0.00645407f, 0.04366639f, -0.04721474f, -0.18205778f, 0.04723018f, 0.07749528f, 0.07267499f, -0.01918241f, 
    -0.01695411f, 0.17791317f, -0.15108004f, -0.00889739f, 0.32740515f, -0.30346712f, 0.15009007f, -0.02424385f, 
    -0.10912181f, 0.04257740f, 0.06132661f, 0.03437669f, -0.09510072f, -0.00898167f, 0.15294097f, -0.12700437f, 
    -0.15683927f, 0.05088620f, -0.00472510f, -0.02544505f, -0.07471152f, -0.06095636f, -0.04041828f, 0.07129955f, 
    -0.00417991f, 0.05055063f, -0.05476802f, 0.01491453f, -0.23517948f, -0.05323099f, -0.03232042f, 0.48324358f, 
    0.12753588f, 0.03451104f, 0.02818958f, 0.05720273f, 0.07155175f, -0.03940500f, 0.00240496f, 0.00713857f, 
    -0.09415095f, -0.10384939f, 0.18092290f, -0.35127291f, -0.05378239f, -0.09932645f, 0.02925540f, -0.21846421f, 
    -0.16519856f, 0.00101946f, 0.08217559f, -0.21219021f, 0.20562321f, -0.27607396f, -0.17866373f, -0.38653129f, 
    0.00511519f, -0.04585927f, 0.01809252f, -0.03220186f, -0.00585989f, -0.03180895f, 0.26037788f, 0.03733303f, 
    -0.01796516f, -0.06111749f, -0.06110226f, 0.16785333f, -0.01233913f, -0.12597108f, -0.00078233f, -0.00840517f, 
    -0.04799873f, 0.00515894f, -0.03458994f, 0.11809676f, -0.08734748f, -0.17194310f, -0.43513659f, 0.38915628f, 
    0.02381783f, 0.05755617f, 0.00896409f, -0.04573960f, -0.29249594f, 0.02586507f, -0.10943651f, 0.09156255f, 
    -0.26557890f, -0.17176309f, 0.01968655f, -0.09892283f, -0.04522142f, -0.04330671f, 0.14401694f, -0.00534896f, 
    0.10385650f, -0.05815069f, 0.09749872f, -0.06314300f, -0.47089556f, 0.22739579f, -0.02124911f, -0.18118221f, 
    0.02485780f, 0.10091864f, -0.01023022f, 0.03140505f, -0.13299640f, 0.14600849f, 0.11795297f, 0.08644694f, 
    0.11716966f, -0.30922008f, -0.24297915f, -0.12839341f, 0.11774091f, -0.04677080f, 0.04497750f, 0.03394414f, 
    0.03681866f, -0.06128005f, -0.01654964f, -0.00443211f, -0.22601968f, -0.34198341f, 0.10692788f, 0.01126551f, 
    0.07633820f, -0.06375535f, -0.08918801f, 0.26762605f, -0.07518145f, -0.05402858f, -0.13217051f, 0.32422259f, 
    -0.37667277f, 0.09914117f, -0.12851480f, -0.22777346f, -0.05282299f, -0.19849615f, -0.02666473f, -0.01692553f, 
    0.00591581f, 0.10914678f, 0.07694419f, 0.00209508f, 0.46529996f, -0.10027779f, -0.05912587f, 0.06347802f, 
    0.00753755f, 0.00061197f, -0.08897267f, 0.06610419f, -0.06164036f, 0.10301733f, 0.20679779f, 0.09237381f, 
    0.08684483f, 0.07267813f, 0.06321916f, -0.03948620f, 0.01635881f, 0.00637566f, -0.10863432f, -0.02072046f, 
    0.14019088f, -0.12802824f, -0.01892832f, 0.05959171f, -0.04440339f, -0.21736293f, 0.26343244f, -0.33801752f, 
    -0.06001418f, 0.04116007f, 0.21238062f, 0.04243184f, 0.14621861f, -0.16974692f, -0.10397355f, -0.06557715f, 
    -0.19259131f, 0.34373581f, 0.20241438f, -0.45937943f, -0.27865657f, 0.15246840f, 0.04044326f, 0.05616540f, 
    0.00546840f, -0.08941355f, 0.07467737f, 0.00576569f, 0.13658902f, -0.25358084f, 0.11055759f, -0.24762018f, 
    0.12892450f, -0.10917038f, -0.01017414f, 0.15182331f, -0.14927758f, -0.14747095f, 0.02768606f, 0.07216752f, 
    0.30767894f, -0.55517244f, -0.36012626f, 0.02986925f, 0.07819021f, 0.10523424f, -0.08995129f, -0.01192415f, 
    -0.08220948f, -0.24429587f, -0.04247567f, -0.12299523f, -0.18350714f, 0.37903181f, 0.08896231f, -0.25856647f, 
    0.04375288f, -0.03003227f, 0.05033667f, 0.13011342f, 0.09772978f, 0.21607977f, 0.13512869f, 0.14353459f, 
    -0.33895069f, -0.21345735f, -0.28167149f, -0.23026942f, 0.11695930f, -0.08433960f, -0.10077661f, 0.02445809f, 
    -0.15131050f, -0.02029114f, -0.05918555f, -0.00705774f, 0.11709297f, 0.04346309f, -0.02529621f, 0.04021891f, 
    -0.07066904f, 0.09448930f, 0.13247377f, 0.05933388f, -0.02307929f, 0.10748755f, 0.04416996f, -0.07939743f, 
    -0.48575437f, -0.00917835f, -0.08457638f, -0.11119366f, -0.09332193f, -0.09669269f, -0.00950939f, -0.18864016f, 
    -0.07417606f, -0.03738203f, 0.02886487f, 0.03897031f, 0.29461190f, 0.19722907f, 0.35019785f, 0.10961677f, 
    -0.05139424f, -0.00355359f, 0.05565846f, -0.06551463f, -0.08949319f, 0.01611614f, -0.05578689f, -0.04300471f, 
    -0.08062287f, -0.15121712f, -0.28384447f, -0.29518223f, -0.09666367f, -0.04911037f, -0.02286034f, -0.01212903f, 
    -0.02536170f, -0.03106041f, -0.13215666f, -0.06853142f, -0.33655524f, 0.22307549f, 0.14509660f, 0.04447009f, 
    0.13916993f, -0.24195509f, 0.19317217f, 0.08196304f, 0.03010169f, 0.07459962f, -0.00730104f, -0.11438651f, 
    -0.14177993f, 0.01914818f, -0.04802505f, -0.15401894f, -0.16157481f, -0.05106217f, -0.11407775f, 0.02804202f, 
    0.04131592f, -0.00585593f, -0.12211614f, -0.06551837f, 0.25752050f, 0.12466900f, 0.04316333f, -0.28618816f, 
    -0.13495499f, 0.00094973f, -0.04165886f, -0.13355771f, -0.03533178f, 0.00644272f, 0.07121339f, -0.02037617f, 
    -0.01426194f, 0.05401702f, 0.14718914f, 0.06262450f, -0.01975738f, 0.07899049f, -0.11113301f, 0.07013738f, 
    0.04622391f, 0.07147477f, -0.07150335f, 0.02285964f, -0.16387393f, -0.01210574f, -0.16686951f, -0.05186298f, 
    -0.00058585f, 0.03713562f, -0.05703249f, -0.02033051f, -0.12369055f, -0.03093017f, -0.03756118f, -0.12012057f, 
    0.48658547f, -0.01907320f, -0.32200804f, -0.12432247f, -0.06586159f, 0.03526955f, -0.01526500f, -0.10668854f, 
    -0.15631276f, -0.06941303f, -0.04670842f, 0.05033328f, 0.05141578f, 0.10746098f, 0.23183694f, 0.03431238f, 
    0.00565959f, 0.11752854f, 0.03309498f, -0.05531017f, -0.02935873f, 0.01048883f, -0.03778177f, 0.05452507f, 
    -0.45727003f, 0.25008067f, -0.15062474f, -0.09352187f, -0.08536635f, -0.01427007f, 0.02840845f, -0.04761031f, 
    -0.09697618f, 0.03719433f, 0.08721719f, -0.05580879f, -0.15591437f, -0.08867304f, 0.02155374f, -0.20800447f, 
    -0.01475832f, -0.01047804f, -0.03791622f, -0.16231434f, -0.13309705f, 0.04816768f, -0.02381822f, -0.06443574f, 
    0.24299870f, -0.03832608f, 0.13119999f, -0.06792989f, -0.09843265f, 0.07233686f, -0.05396057f, 0.04939120f, 
    -0.09291366f, -0.11185021f, -0.12491520f, 0.01376863f, 0.02925552f, 0.13876627f, -0.08251005f, -0.00916184f, 
    0.02742104f, 0.01489854f, -0.04954908f, 0.00649969f, -0.04048621f, -0.00397404f, 0.13948670f, -0.16859701f, 
    0.26260823f, -0.09675951f, 0.13396440f, 0.10595842f, 0.05468957f, 0.11061474f, 0.05006290f, -0.14000690f, 
    -0.18099563f, -0.07800687f, 0.04932624f, -0.08388860f, 0.38676989f, 0.07201543f, 0.28488982f, 0.02560788f, 
    0.16587149f, 0.14533131f, -0.02451074f, 0.05435456f, -0.13501020f, 0.02633998f, -0.09666862f, 0.01285287f, 
    0.01912676f, 0.19006495f, 0.04127171f, 0.26764625f, -0.12369952f, -0.07632986f, -0.05589244f, -0.14677848f, 
    -0.14665823f, 0.02434675f, -0.05239017f, -0.02666683f, 0.24054196f, 0.25581330f, 0.07874857f, 0.37259716f, 
    0.10314392f, 0.02664341f, 0.08579559f, -0.11930480f, -0.17658558f, -0.06756131f, -0.04641918f, -0.19414464f, 
    0.18351342f, -0.21164507f, 0.22012062f, -0.22060406f, 0.14934932f, 0.07829658f, -0.09578928f, 0.04403394f, 
    -0.12043710f, 0.11734790f, 0.01251796f, -0.02380219f, -0.10366572f, 0.06848312f, -0.26886287f, -0.08200375f, 
    -0.06655800f, -0.06404286f, -0.03927377f, -0.01096089f, -0.19681452f, 0.11441270f, 0.13801317f, -0.08591984f, 
    0.30955240f, -0.11239839f, 0.16881721f, 0.02582655f, -0.06210014f, 0.09451862f, -0.06989566f, -0.15448381f, 
    -0.05138424f, -0.00213657f, -0.07408744f, -0.17179854f, -0.16371796f, -0.02041407f, 0.03623430f, -0.01171280f, 
    -0.12064219f, 0.11535820f, -0.07339653f, -0.03620886f, -0.14156844f, 0.03463238f, 0.01986732f, 0.01571641f, 
    0.14401491f, 0.31330401f, 0.13378756f, 0.36764199f, 0.12758289f, 0.10379905f, -0.00601994f, 0.00878904f, 
    -0.09878343f, -0.00097938f, -0.07262116f, -0.14545284f, 0.15604906f, -0.23909271f, 0.06670257f, 0.17308754f, 
    0.17192109f, 0.00342078f, -0.02987344f, -0.16812313f, -0.18773411f, -0.01823164f, 0.00825526f, -0.09965710f, 
    -0.35071382f, 0.21211061f, 0.14684716f, 0.09287550f, 0.03777682f, 0.10862504f, -0.01625408f, -0.04700244f, 
    -0.08930010f, -0.01465054f, -0.02918795f, -0.06711544f, 0.34985581f, -0.08796445f, -0.07242057f, 0.20772512f, 
    -0.02707479f, -0.14140691f, -0.01367926f, -0.21377674f, -0.01723930f, 0.07176061f, -0.14782882f, -0.05407522f, 
    -0.17291664f, 0.23713540f, -0.13880338f, -0.31742314f, 0.00331037f, 0.02611851f, -0.01813795f, -0.06178479f, 
    -0.09852278f, -0.00159287f, -0.11557865f, -0.21206266f, 0.19266878f, -0.09156231f, -0.13624834f, -0.30851689f, 
    -0.05043050f, -0.01190016f, -0.05350807f, -0.11015382f, -0.06308728f, -0.00424274f, 0.04477811f, 0.02932117f, 
    0.02668741f, 0.26804855f, -0.05019146f, 0.22719105f, -0.04605482f, -0.09158814f, -0.20182718f, -0.00763895f, 
    0.09796099f, 0.03914975f, 0.01801948f, -0.04580354f, -0.23386860f, -0.10535019f, -0.18406232f, -0.09226665f, 
    0.09279381f, -0.09960297f, -0.05062060f, -0.09740648f, -0.19152021f, -0.03474927f, 0.11397800f, -0.05111980f, 
    0.36542138f, 0.40067661f, -0.38747156f, -0.27915102f, 0.04645367f, 0.11844011f, -0.14204459f, -0.07036781f, 
    0.14470720f, -0.05635010f, 0.02252114f, 0.23447637f, 0.05403032f, -0.09889894f, -0.26315549f, -0.26179671f, 
    0.07995328f, -0.03776773f, 0.02102540f, 0.03615796f, -0.00687609f, -0.14319868f, -0.12769873f, 0.03152730f, 
    -0.33036056f, -0.46405795f, -0.03465255f, 0.16124435f, -0.00728531f, -0.08498935f, -0.01742010f, 0.12195365f, 
    0.20383462f, 0.14386076f, 0.07805077f, 0.13460277f, -0.19357385f, 0.33516985f, -0.08924997f, -0.02672171f, 
    -0.25332865f, -0.00972801f, -0.08785687f, -0.03858000f, 0.01124611f, 0.14813216f, -0.10860934f, 0.00122601f, 
    0.07688356f, 0.01155842f, -0.11422591f, 0.06512167f, 0.00092282f, -0.08805858f, -0.08746346f, 0.09766577f, 
    0.23172501f, -0.00393434f, -0.07657443f, -0.33167693f, 0.10334778f, 0.00512092f, -0.03404879f, 0.14091872f, 
    -0.12150929f, -0.06287840f, -0.21873599f, 0.03434992f, 0.11248124f, -0.29000777f, 0.00521103f, 0.07378878f, 
    0.19718219f, 0.09379442f, 0.16479419f, 0.08798334f, -0.15959878f, -0.00314043f, -0.17932194f, -0.23341042f, 
    0.04226539f, 0.07244392f, 0.04230707f, -0.05492430f, 0.15072979f, -0.17714399f, 0.15028939f, -0.02309159f, 
    0.13595912f, 0.03225812f, -0.14328349f, 0.00999812f, 0.06595678f, -0.12951073f, -0.21470669f, 0.01415587f, 
    0.11003034f, -0.03850931f, 0.27869633f, 0.11862960f, 0.01140081f, -0.09448300f, 0.04033483f, 0.00403412f, 
    -0.13773620f, -0.04128570f, -0.13582261f, -0.27016854f, 0.10091174f, -0.15874840f, 0.04000927f, 0.31500515f, 
    0.20250322f, 0.04783985f, 0.00662866f, -0.04843027f, 0.03531356f, 0.01435969f, 0.04874973f, 0.11911054f, 
    -0.19464274f, -0.25935239f, -0.05952383f, -0.10201701f, 0.02519717f, -0.05430582f, -0.02669289f, -0.02589477f, 
    0.05661081f, -0.04272039f, 0.11562265f, 0.01002560f, -0.10315360f, -0.23099412f, 0.10973256f, -0.14226681f, 
    -0.00793708f, -0.01929690f, -0.12959632f, 0.08121435f, 0.03392794f, -0.06909651f, 0.09812745f, 0.20170426f, 
    0.19616282f, -0.16161333f, -0.02096624f, 0.16068403f, 0.15067847f, -0.03952191f, -0.13106455f, -0.04027789f, 
    0.09655504f, -0.08573220f, 0.03928340f, 0.12802172f, 0.10569931f, -0.13433397f, 0.20903715f, 0.19972017f, 
    -0.05215573f, -0.08584625f, -0.12654343f, -0.02927498f, -0.01419639f, -0.09851169f, -0.01823013f, -0.07488655f, 
    0.07308647f, 0.05000951f, -0.00741111f, -0.14678508f, -0.07780895f, 0.11552353f, -0.10549945f, -0.15599003f, 
    0.09139745f, 0.12911847f, 0.02794029f, 0.01377213f, -0.04167277f, 0.24628311f, -0.21981186f, -0.18311791f, 
    0.10799375f, -0.09308608f, -0.16597366f, 0.10895526f, 0.06935769f, 0.01777875f, 0.06564020f, 0.00540069f, 
    -0.15014969f, -0.41178596f, 0.21779501f, -0.30619675f, 0.05467619f, 0.15787172f, 0.01015961f, 0.01740483f, 
    0.06196352f, 0.09471218f, -0.06947436f, 0.17857906f, -0.13443117f, -0.23637381f, 0.11173127f, -0.13604280f, 
    -0.05907730f, -0.13059995f, 0.04028099f, -0.27422965f, -0.13311704f, -0.05317405f, -0.23697367f, 0.08096388f, 
    -0.06159971f, -0.29851559f, -0.36560908f, -0.25672364f, 0.00720750f, -0.17830159f, -0.34525609f, 0.07166348f, 
    0.05441942f, 0.09505554f, 0.16924436f, -0.53830868f, 0.35634068f, 0.25015038f, -0.07019586f, -0.27693379f, 
    0.02359048f, -0.13265336f, 0.21208541f, 0.00804469f, 0.02805129f, -0.16100200f, -0.03660642f, 0.19383262f, 
    -0.40456319f, -0.17116758f, 0.23177944f, -0.00961103f, -0.20126443f, -0.07170694f, -0.02932975f, -0.25759265f, 
    0.03064674f, 0.12022195f, -0.12420992f, 0.06379645f, 0.07459424f, -0.35248223f, -0.06162346f, -0.00467637f, 
    0.14706236f, -0.03313503f, 0.06834213f, -0.07828785f, 0.00162865f, -0.04699803f, -0.04852032f, -0.16210774f, 
    0.14706726f, 0.00795656f, -0.29272059f, -0.24056923f, -0.02115811f, 0.00847226f, 0.15577579f, -0.11139914f, 
    0.17208135f, -0.03993060f, 0.07461828f, -0.07288643f, 0.55435717f, 0.07901265f, 0.12266269f, 0.11532534f, 
    -0.11744832f, -0.13662425f, -0.08908871f, -0.10780862f, 0.01127968f, -0.02431185f, -0.12235530f, -0.30088428f, 
    -0.27454063f, 0.10950198f, 0.17668450f, 0.00179417f, -0.20098531f, 0.04484159f, 0.01455696f, -0.08558100f, 
    -0.01872835f, -0.08862387f, -0.14124379f, 0.09671657f, 0.15919136f, -0.01243636f, -0.00665404f, -0.38346705f, 
    0.05459508f, -0.06238748f, 0.04143099f, -0.00262280f, 0.22531936f, -0.04508794f, -0.17882648f, -0.08500838f, 
    -0.14039020f, 0.04464804f, 0.11862884f, 0.00423920f, -0.02440828f, -0.16638418f, -0.07983020f, 0.16326801f, 
    0.14121877f, -0.00876282f, -0.03434481f, 0.13100044f, -0.15666491f, -0.40045938f, 0.09531253f, -0.28818086f, 
    0.00144540f, -0.05915909f, 0.13817386f, -0.18136176f, 0.01706839f, 0.07657126f, -0.09631997f, 0.18028605f, 
    0.18122490f, -0.01615791f, 0.31616166f, 0.15716945f, 0.23063827f, -0.07266007f, -0.09068604f, -0.20067330f, 
    -0.01758004f, 0.10691132f, 0.01121508f, -0.04600858f, 0.02028323f, -0.21939041f, 0.16833065f, 0.08329452f, 
    0.09856920f, 0.00397669f, -0.08408625f, -0.02202933f, 0.01991006f, -0.00746659f, -0.23652786f, -0.27314776f, 
    -0.11717603f, 0.30524027f, -0.31308511f, -0.29840806f, -0.04045302f, 0.02354711f, -0.19695613f, 0.00872023f, 
    0.17576760f, 0.05192988f, 0.09852742f, -0.02753766f, -0.06958925f, -0.14233077f, 0.00847846f, 0.02846971f, 
    0.24917875f, 0.04534814f, -0.12061154f, 0.03175846f, -0.02995741f, -0.05502697f, 0.22400165f, -0.11484066f, 
    0.63518810f, 0.07039388f, 0.26459289f, -0.00395180f, 0.10515428f, 0.15953480f, 0.12830292f, -0.02592059f, 
    -0.16687118f, -0.07951308f, -0.04085384f, -0.12023088f, 0.00419191f, 0.20973660f, 0.24243957f, 0.00232799f, 
    0.07046262f, -0.23065376f, 0.01832281f, 0.02167583f, 0.07554009f, 0.22415610f, 0.07428829f, 0.16724259f, 
    -0.14832474f, 0.22247735f, -0.47590512f, -0.40429613f, -0.05160879f, -0.04643935f, 0.25525793f, -0.01900883f, 
    -0.08748001f, 0.09238616f, -0.22309749f, -0.12323295f, -0.25367534f, -0.40860268f, -0.09489086f, 0.17782773f, 
    0.07631407f, 0.03068288f, -0.02697414f, 0.07669325f, -0.08595262f, 0.05359966f, -0.02696231f, -0.04960709f, 
    -0.21778347f, 0.24101451f, -0.12462624f, -0.22503984f, 0.14456601f, 0.22373532f, 0.28379551f, -0.08320726f, 
    -0.19220173f, 0.01618122f, -0.08395180f, 0.13136488f, -0.42590937f, -0.60349143f, -0.06125428f, -0.04023550f, 
    -0.01346260f, -0.02656752f, 0.03890716f, 0.08400927f, -0.07890047f, -0.01457183f, 0.16229442f, -0.05682174f, 
    0.77520251f, 0.08019599f, 0.04949826f, 0.02527204f, 0.15782964f, 0.07935365f, 0.15219332f, 0.09485356f, 
    0.06759091f, 0.15850405f, -0.00721657f, -0.07488668f, -0.30207747f, 0.19140930f, -0.37898713f, 0.08732986f, 
    0.07349797f, -0.15749438f, 0.01184004f, -0.02612580f, -0.06483792f, 0.03964187f, 0.04399071f, 0.05973645f, 
    0.23200375f, 0.11807179f, 0.04365689f, 0.25813106f, 0.11180580f, -0.10164703f, -0.11323252f, 0.04133739f, 
    0.11248746f, 0.07244809f, 0.05463185f, -0.04359488f, -0.27622953f, -0.10045955f, -0.00592031f, -0.07341658f, 
    0.13758893f, 0.02360022f, 0.04522194f, -0.02735210f, 0.05722199f, -0.27281129f, -0.03275176f, -0.05424008f, 
    -0.12492236f, 0.18303744f, 0.08946332f, -0.30635884f, 0.05576338f, -0.19132872f, 0.17050697f, -0.03829807f, 
    0.09209599f, 0.04932035f, 0.08422195f, 0.02950797f, -0.08126923f, -0.25140047f, -0.18457890f, -0.02114474f, 
    0.13493076f, 0.20638697f, 0.01678810f, -0.17095283f, 0.10605358f, -0.00024586f, -0.17074756f, 0.02315954f, 
    -0.38209274f, 0.47549990f, -0.04756771f, -0.60973692f, 0.05328447f, -0.04642858f, -0.04663569f, -0.00379077f, 
    -0.15589850f, -0.11369786f, 0.10737248f, -0.18357264f, 0.13888249f, 0.32363260f, -0.24474514f, -0.31331035f, 
    0.31109291f, -0.06833284f, -0.08291966f, -0.08475872f, -0.01122812f, -0.02826591f, 0.11459059f, 0.14304844f, 
    -0.21916747f, -0.48347831f, 0.08778569f, -0.27776232f, 0.00640079f, 0.02618684f, 0.07676828f, -0.25051272f, 
    0.03590180f, 0.00889004f, 0.00240572f, -0.07104657f, 0.02081283f, -0.07706275f, 0.41196707f, -0.04588565f, 
    0.03619555f, 0.06400987f, 0.04532975f, -0.00472152f, 0.04344859f, -0.03937133f, -0.05407705f, -0.05123162f, 
    0.27111396f, -0.07301547f, -0.22305046f, 0.42540875f, -0.06113368f, -0.10166722f, 0.10512470f, -0.19764839f, 
    -0.15017188f, 0.08328504f, -0.11868402f, -0.00244610f, -0.11420385f, -0.18598427f, -0.23288399f, 0.16743046f, 
    -0.00530510f, 0.02800209f, 0.00627269f, 0.08660289f, 0.03538497f, 0.11469993f, 0.10765139f, -0.10590114f, 
    -0.38563585f, -0.18203887f, -0.04490596f, -0.16907629f, 0.00282537f, 0.00701410f, -0.07297146f, 0.06421380f, 
    -0.00914519f, -0.01650271f, 0.04141233f, 0.21461049f, 0.17360339f, 0.00495477f, 0.13750955f, -0.28773662f, 
    0.21957321f, -0.18822184f, 0.01534437f, -0.06162011f, 0.03960292f, 0.02206612f, 0.23192458f, 0.18022226f, 
    0.20930186f, -0.31008917f, -0.10142040f, 0.25944749f, -0.08680739f, 0.00737415f, 0.06058558f, -0.05049864f, 
    -0.13469253f, -0.09455912f, -0.00085332f, -0.13019159f, -0.26087967f, 0.16741471f, 0.24006326f, -0.20960341f, 
    -0.10587299f, 0.18592307f, 0.13781382f, -0.15955085f, -0.11286388f, -0.10042181f, -0.18506722f, 0.09273893f, 
    0.08968958f, -0.42404366f, -0.29776320f, -0.06580893f, -0.06590111f, -0.03586778f, 0.02735370f, 0.07822509f, 
    -0.16662519f, 0.07006579f, -0.11230794f, 0.16811867f, 0.03815863f, 0.07541930f, -0.15387635f, 0.21756253f, 
    0.14874022f, 0.11299410f, -0.07747965f, -0.14300378f, -0.20162292f, 0.07483497f, -0.08539703f, 0.06178686f, 
    -0.08667678f, -0.15132378f, 0.01663435f, -0.04410660f, 0.07712442f, 0.16404381f, -0.06110844f, 0.17528641f, 
    -0.14587423f, -0.01071491f, 0.15544145f, 0.14787307f, 0.04619211f, -0.26944026f, 0.25395054f, 0.13042790f, 
    0.07420298f, -0.04755234f, -0.04141097f, -0.14667813f, -0.00365006f, 0.13125812f, 0.13588500f, 0.23934796f, 
    -0.24348278f, -0.07141949f, -0.26689041f, 0.35219091f, 0.07926859f, 0.05726771f, -0.05781018f, -0.09810024f, 
    0.01685124f, -0.04289753f, 0.18286085f, -0.08536463f, 0.33220032f, 0.27862298f, -0.20967159f, -0.15118670f, 
    0.16021323f, -0.15020290f, -0.19458836f, 0.25179309f, 0.05672035f, 0.10280473f, 0.04307886f, 0.10097750f, 
    -0.51469511f, 0.45585847f, -0.15168740f, -0.02006529f, 0.10880678f, -0.08524629f, 0.00453618f, -0.04133863f, 
    -0.06414675f, 0.13348854f, -0.03501872f, -0.21257715f, 0.06433425f, -0.23078933f, 0.11317167f, -0.01074992f, 
    0.02081396f, 0.03080534f, -0.08061074f, 0.00600450f, 0.10689556f, -0.12519749f, 0.06729472f, 0.10781141f, 
    -0.43466383f, 0.21693833f, 0.02898602f, -0.05934411f, 0.03874380f, 0.13065921f, -0.18840989f, 0.02908579f, 
    -0.12736957f, -0.09433130f, -0.18936883f, 0.04440698f, -0.04363840f, -0.17597634f, 0.07909794f, -0.12101784f, 
    -0.12935096f, -0.11706853f, 0.00154068f, -0.03253169f, -0.02790951f, 0.06257880f, -0.01188544f, -0.00938814f, 
    -0.85786223f, -0.33341876f, 0.21350680f, 0.14605720f, 0.28851360f, -0.03263405f, 0.08772799f, -0.07399708f, 
    0.02664639f, -0.00966401f, 0.04906503f, 0.20778117f, -0.35371831f, 0.11376784f, -0.16783342f, 0.06080459f, 
    -0.00492081f, 0.15283149f, 0.05505110f, -0.03211294f, 0.26067215f, -0.46214041f, -0.28109643f, -0.28631258f, 
    0.11285493f, 0.15775602f, 0.00892369f, -0.12128246f, 0.02503831f, -0.00520864f, -0.03508286f, 0.18081374f, 
    -0.01222710f, 0.09275800f, 0.14923590f, 0.19516924f, 0.41191536f, -0.02835795f, -0.06203270f, -0.06858050f, 
    -0.16009957f, 0.07937687f, 0.09650717f, -0.02806934f, 0.06645068f, -0.00463397f, -0.06959525f, -0.11525551f, 
    -0.02293937f, -0.34411401f, 0.16915560f, 0.07704120f, -0.00365676f, -0.12919937f, 0.01577036f, -0.01534752f, 
    0.24272583f, -0.13778241f, -0.03487923f, -0.08544698f, 0.03804941f, 0.09786420f, -0.17168352f, -0.04270663f, 
    -0.14329484f, -0.01193233f, -0.04670586f, 0.03807417f, -0.05543818f, -0.21873011f, -0.11240929f, 0.04144246f, 
    -0.09477223f, -0.07379606f, 0.06421974f, 0.00121031f, -0.00269275f, 0.08369589f, 0.04958014f, -0.00350466f, 
    0.09603197f, -0.06580977f, -0.11485070f, 0.04906559f, -0.41877395f, -0.34547958f, -0.36303654f, 0.10147719f, 
    -0.01180419f, 0.03258377f, -0.11939003f, 0.17734666f, -0.01289466f, 0.08841635f, 0.13021676f, 0.05158638f, 
    0.50756562f, -0.05200721f, 0.00754004f, -0.04505992f, -0.25295746f, -0.11299060f, 0.04148274f, 0.21553165f, 
    -0.03181783f, 0.09536228f, -0.18393074f, 0.02237993f, -0.83626908f, -0.36481181f, -0.15394965f, -0.21822530f, 
    0.03609329f, -0.11321732f, -0.03852783f, -0.02830097f, 0.03226725f, 0.19841354f, 0.06748249f, 0.10286536f, 
    0.03167953f, 0.01904526f, -0.05864308f, -0.13189672f, 0.11068582f, -0.08922887f, -0.07954037f, 0.13072315f, 
    -0.01906380f, 0.05900611f, -0.08359118f, -0.00871098f, 0.31768534f, 0.04533169f, -0.05543619f, -0.00349348f, 
    0.08304469f, 0.04887499f, -0.00033051f, 0.14909208f, 0.17185105f, -0.04694183f, 0.07762564f, 0.13324626f, 
    -0.80873322f, -0.38528663f, -0.25810954f, -0.38408017f, 0.17567793f, -0.00678189f, 0.01143594f, 0.07278021f, 
    0.20641515f, -0.02138928f, 0.04338697f, -0.00525186f, -0.15929230f, 0.05741816f, -0.18086933f, -0.13267130f, 
    0.17766540f, -0.13361631f, -0.09416983f, 0.10650904f, 0.04025373f, -0.15198939f, -0.06884070f, -0.02239609f, 
    0.19222704f, 0.15846054f, -0.28937587f, 0.03257228f, 0.04250548f, -0.01417338f, -0.01014300f, -0.03254215f, 
    -0.09078763f, 0.02535137f, 0.00678778f, 0.07097071f, -0.38097277f, -0.18510911f, 0.36646962f, 0.02324642f, 
    0.09653103f, 0.08586537f, 0.03538736f, 0.05035766f, -0.08887676f, -0.06252310f, -0.02081306f, 0.05740681f, 
    0.19102520f, 0.09011389f, -0.07907067f, 0.06729890f, 0.08926473f, 0.11406239f, 0.12757984f, 0.05507784f, 
    -0.01569667f, 0.11758465f, 0.24621435f, 0.10592791f, 0.24461329f, -0.01277264f, 0.04780251f, -0.11210095f, 
    -0.02520389f, 0.02473966f, -0.05029393f, -0.06389516f, 0.13779639f, -0.11935933f, -0.07397678f, -0.16010429f, 
    -0.00483647f, 0.04009601f, 0.20174180f, 0.08415213f, 0.01578152f, -0.06979712f, 0.03980929f, 0.04787256f, 
    0.01575005f, -0.23091669f, -0.21020816f, -0.21284574f, -0.30566281f, 0.07746832f, -0.08373631f, -0.01881694f, 
    0.09631006f, 0.04897858f, -0.01997040f, 0.00914676f, 0.04106383f, 0.22659427f, 0.06828454f, 0.03306775f, 
    0.01634378f, -0.01660965f, -0.06363069f, 0.02524147f, 0.18466233f, -0.03288108f, -0.12612973f, 0.15290283f, 
    -0.06957413f, 0.02922526f, 0.01215957f, 0.09989928f, -0.49633086f, -0.31776085f, 0.40659624f, 0.02219933f, 
    0.18341281f, 0.05437970f, 0.09602131f, 0.01287640f, 0.15508062f, 0.08521045f, -0.05380102f, 0.08331674f, 
    0.18096033f, 0.03354111f, -0.13117294f, -0.00644097f, 0.10933221f, 0.07916763f, 0.10826936f, 0.05872010f, 
    0.15227082f, 0.07444607f, 0.01539602f, -0.21646504f, 0.16910508f, 0.05724399f, -0.27581459f, -0.08434036f, 
    0.05281919f, -0.07462814f, -0.02547836f, 0.01698270f, 0.02370558f, 0.05149584f, 0.08868968f, -0.00108748f, 
    0.06799898f, -0.13898119f, 0.04842242f, -0.12373983f, -0.23034181f, 0.03466836f, -0.00554647f, -0.10125273f, 
    0.08746419f, -0.05316710f, -0.13288513f, -0.20269577f, -0.47091734f, -0.03983652f, -0.02514428f, -0.09125691f, 
    0.14077602f, -0.07253081f, 0.14065200f, 0.01673418f, 0.07333583f, -0.04674843f, -0.05053513f, -0.21405780f, 
    0.42695147f, 0.15343817f, -0.10220081f, -0.01035878f, -0.03727379f, -0.19060618f, 0.15914863f, -0.03535958f, 
    0.16505143f, 0.06485842f, 0.05295610f, 0.24733476f, 0.22503333f, 0.32269210f, 0.13150859f, 0.06520244f, 
    0.03718164f, 0.07657801f, 0.15217677f, 0.01158209f, 0.01696670f, 0.18950358f, -0.02256625f, -0.02757181f, 
    -0.88459128f, -0.52220786f, -0.18573059f, -0.30716065f, -0.00896883f, -0.10493602f, -0.00768066f, -0.01837563f, 
    -0.05601430f, -0.06263472f, -0.00495715f, 0.10443594f, -0.46163961f, 0.04804941f, -0.15283367f, -0.21780638f, 
    -0.06281092f, -0.04699593f, -0.07636771f, -0.01440720f, -0.05959133f, 0.10106743f, -0.34314206f, -0.02173621f, 
    0.18290602f, -0.04676681f, -0.02813961f, -0.08270451f, 0.13857323f, 0.06723441f, -0.14775443f, 0.01360109f, 
    -0.04464184f, 0.05736294f, 0.11418942f, 0.02325442f, -0.44718924f, -0.13560025f, 0.05951693f, -0.29085496f, 
    0.07804208f, 0.11884923f, -0.04311168f, 0.04940925f, 0.01826223f, -0.10917640f, -0.00718404f, 0.05636868f, 
    0.34946522f, -0.07827735f, -0.07141915f, -0.19650836f, 0.11188113f, -0.23613197f, -0.06944501f, 0.00676494f, 
    0.04566517f, 0.04501613f, 0.02886553f, 0.05565560f, -0.17795159f, 0.25558946f, 0.04581946f, 0.09392803f, 
    0.17394444f, -0.14676781f, -0.24728452f, 0.05169373f, 0.24612239f, 0.14885548f, 0.24735513f, -0.00551675f, 
    0.16120946f, -0.24905039f, 0.15923686f, 0.20621009f, 0.05974349f, 0.06812948f, 0.01205726f, -0.06140935f, 
    0.15128347f, -0.18873778f, 0.03347753f, 0.03716409f, 0.02343143f, 0.20892921f, -0.11381364f, 0.21549530f, 
    0.11596426f, -0.04137546f, 0.18448704f, 0.00125072f, -0.09050018f, -0.01028440f, 0.06514175f, 0.00125310f, 
    -0.02307490f, -0.11671739f, 0.00709194f, -0.39165735f, 0.16682276f, -0.13195559f, 0.02893131f, 0.01762362f, 
    0.15723935f, 0.02970377f, -0.02334318f, -0.00120114f, -0.24169214f, -0.19222052f, 0.06865431f, -0.08630494f, 
    -0.07324654f, 0.22528021f, -0.17594102f, 0.14055876f, -0.13142475f, 0.01054579f, -0.19906063f, -0.01173941f, 
    -0.49974015f, -0.43720651f, 0.02713822f, -0.07947843f, 0.03562933f, -0.13256036f, 0.08259884f, 0.29695797f, 
    0.03938582f, -0.05936913f, -0.03727026f, -0.13716155f, -0.45557049f, 0.19711681f, 0.23141856f, -0.04153041f, 
    0.15469734f, -0.08459590f, 0.11090444f, -0.02711704f, -0.00661729f, -0.05701785f, -0.07605886f, 0.02838888f, 
    -0.19299150f, 0.01396695f, 0.02628712f, 0.08605531f, 0.16998366f, 0.02923967f, 0.00911924f, 0.02182060f, 
    -0.05932010f, 0.00935164f, 0.16257234f, 0.11793474f, -0.02157912f, -0.02264258f, -0.15144238f, 0.00380875f, 
    0.05393983f, 0.02079144f, -0.09989680f, 0.06242672f, 0.02389967f, -0.13526052f, -0.23479319f, -0.09072471f, 
    -0.29422569f, 0.27507693f, -0.39551190f, -0.16519657f, 0.19566265f, -0.05110785f, 0.01691490f, -0.03612242f, 
    -0.07833592f, 0.08259211f, -0.01461949f, 0.14786570f, -0.10768787f, 0.20500353f, -0.10274392f, -0.27641955f, 
    -0.04427662f, 0.01873974f, 0.01552673f, -0.09559917f, -0.05856200f, -0.07817424f, -0.16338222f, -0.16431196f, 
    0.15201204f, -0.12364236f, -0.09170869f, 0.39874786f, 0.00853891f, -0.01961308f, -0.04224332f, -0.04786528f, 
    0.05305609f, -0.04524516f, 0.01351409f, -0.00938085f, -0.01118187f, -0.21121280f, 0.06679858f, -0.26648107f, 
    -0.06167574f, 0.12320599f, -0.01365817f, 0.05644002f, -0.08257569f, 0.09415249f, 0.08914134f, 0.08590760f, 
    0.14794783f, 0.20199247f, -0.26563522f, 0.04515738f, 0.16041945f, -0.01738114f, 0.00916564f, -0.02548372f, 
    -0.02046569f, -0.04976862f, 0.00271301f, -0.10113531f, -0.15643550f, 0.45755297f, 0.01087695f, -0.09508288f, 
    0.17435265f, 0.18529622f, 0.00908812f, -0.15867646f, 0.05199814f, 0.15768160f, -0.05077052f, -0.15570378f, 
    -0.17104025f, 0.25451007f, 0.20990318f, -0.21557526f, -0.17376165f, -0.17653991f, -0.12749250f, -0.01752058f, 
    -0.01528968f, 0.00540193f, 0.14166631f, -0.12448678f, -0.39272854f, 0.34480304f, -0.06592087f, -0.02969699f, 
    0.10374770f, -0.17251690f, -0.07127112f, 0.01684827f, -0.02024904f, 0.10470357f, -0.01450786f, -0.11191887f, 
    -0.19487110f, -0.12049483f, -0.11194675f, -0.30731472f, 0.05307404f, 0.04248079f, 0.02279625f, -0.26422641f, 
    0.01660136f, -0.03606570f, 0.18332759f, 0.09589432f, -0.07225475f, -0.35227630f, -0.10600074f, 0.12442039f, 
    -0.15646710f, 0.10964648f, -0.03926577f, 0.02856585f, 0.12795778f, 0.10238709f, -0.00480725f, -0.14014769f, 
    -0.15561654f, 0.29328170f, 0.09593480f, -0.13100623f, -0.19487016f, -0.14395337f, -0.01087500f, -0.20782979f, 
    0.04084725f, 0.03098354f, -0.10957507f, -0.12890607f, 0.61695617f, 0.38353595f, -0.13200927f, -0.35199538f, 
    0.18507417f, 0.05439328f, -0.14183742f, 0.05364818f, 0.00710573f, -0.04046457f, -0.01586162f, 0.09111258f, 
    0.06580555f, 0.10567880f, -0.20230286f, 0.16922788f, -0.04377798f, -0.03645549f, -0.06486008f, -0.11039069f, 
    0.04008799f, 0.00103518f, 0.20684567f, 0.11715716f, -0.26299578f, -0.34722796f, -0.04667752f, -0.11470626f, 
    0.08586541f, -0.01051207f, 0.15895529f, -0.02191787f, -0.18771915f, -0.20068066f, 0.02144597f, 0.03604932f, 
    0.17958371f, 0.05389722f, -0.08516941f, -0.00913302f, -0.11370943f, -0.18857470f, -0.13251162f, -0.05211670f, 
    -0.15583822f, 0.01261133f, 0.09395012f, -0.05575080f, -0.47457027f, 0.00776455f, 0.21713129f, -0.00062252f, 
    -0.21285820f, 0.06570116f, 0.03049977f, -0.11912758f, -0.05882010f, -0.07644784f, 0.13208300f, 0.16673274f, 
    0.31546906f, -0.00473277f, 0.08428779f, 0.42240897f, 0.01077322f, -0.13517494f, 0.14750248f, 0.24199072f, 
    -0.08238824f, -0.11070840f, -0.01690886f, -0.02401073f, -0.20066901f, 0.06530841f, 0.01765360f, 0.02999467f, 
    -0.07046467f, -0.00935541f, -0.02757754f, 0.03866459f, -0.04305831f, -0.05813169f, 0.05900627f, 0.01379810f, 
    -0.04020249f, -0.28410813f, -0.05134584f, -0.40555328f, 0.12840605f, 0.03169217f, 0.02715550f, 0.08842590f, 
    -0.12829547f, -0.12104180f, 0.05380697f, -0.06680664f, -0.17468606f, 0.16185547f, -0.17696971f, -0.39804801f, 
    -0.00893927f, -0.09482547f, -0.00506870f, 0.11388935f, 0.02931424f, -0.09449094f, 0.01886992f, 0.10921591f, 
    0.07921927f, -0.08508315f, -0.19300130f, 0.30220628f, 0.28246990f, 0.07372753f, -0.03792443f, -0.04486408f, 
    0.02694652f, -0.02450071f, -0.08192044f, 0.13930704f, 0.55268198f, 0.29922101f, -0.24394074f, -0.31827825f, 
    -0.03217378f, -0.00989845f, -0.00880433f, 0.01408119f, 0.05952338f, 0.10758221f, -0.00685803f, -0.09468252f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.09218358f, 0.03133075f, -0.05762370f, 0.01640764f, -0.00865095f, 0.04230304f, -0.01979724f, -0.05276092f, 
    0.00574117f, -0.01239537f, 0.07677131f, 0.00254675f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
