#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.56280416f, 0.50975704f, -0.02775462f, -1.02408075f, 0.92428279f, -0.01622473f, 0.36339450f, -0.34477049f, 
    -0.12183023f, -0.54359680f, -0.19229288f, 0.72140783f, -0.46200919f, -0.23050119f, -0.42041618f, 0.20119718f, 
    0.47715321f, 0.25201717f, -0.49185225f, -0.00120042f, 0.12092663f, 0.69106781f, 0.92773533f, 0.64832830f, 
    -0.47222763f, 0.56863683f, -0.06517139f, 0.03863195f, -0.27509454f, 1.36406481f, 0.09698188f, 0.28543973f, 
    0.95414227f, 0.14958392f, -0.01546627f, 0.27319312f, 0.64985603f, 0.93894249f, 0.32614881f, -0.07437031f, 
    -0.61588317f, -0.24480504f, -0.18306553f, -0.00699850f, 0.13350193f, 0.11204508f, -0.01557968f, -0.05863637f, 
    0.17447752f, 0.97975707f, -0.79120874f, 0.35018390f, 0.12244495f, 0.50061560f, -0.61202419f, -0.39002159f, 
    -0.62334818f, -0.39864412f, -0.39855209f, -0.47897378f, 0.05676580f, -0.35695803f, -0.18930249f, 0.89800775f, 
    -0.44492871f, -0.26144221f, 0.07118290f, -0.48990971f, -0.00665765f, -0.18075071f, 0.06286767f, -0.33406952f, 
    0.33860877f, 0.73025769f, -0.32614982f, -0.27871129f, 0.05098622f, 0.65625197f, -0.13673854f, -0.51309824f, 
    -0.31189704f, 0.18127497f, -0.21933948f, 0.41411558f, 0.48096475f, -0.54002488f, -0.29682094f, 0.48993111f, 
    0.45442718f, 0.45484054f, -0.19670865f, -0.01156320f, -0.05624987f, -0.11799808f, -0.91250044f, -0.51376504f, 
    0.03863995f, 0.29924342f, -0.11943505f, -0.48220983f, -0.79891068f, -0.88412380f, 0.26974797f, 0.62489921f, 
    -0.05539684f, 0.16267174f, 0.20513777f, -0.14948462f, -0.39389247f, -0.57552713f, 0.05762415f, 0.34866887f, 
    0.30268970f, -0.39298093f, -0.52624476f, -0.42755294f, -0.50014120f, 1.16935325f, -0.53248841f, -0.10953622f, 
    -0.35901567f, 0.15770970f, -0.16474336f, -0.22582370f, 0.31954107f, 0.18697491f, 0.24068794f, 0.44784203f, 
    0.19041604f, -0.18072043f, 0.29376644f, 0.82717788f, -0.85823703f, -0.39079419f, 0.16833182f, -0.18802296f, 
    -0.47447273f, -0.27000272f, -0.39947775f, -0.73302442f, -0.35068965f, -0.11971758f, 0.62288249f, 0.40065187f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.03654684f, 0.02627996f, 0.03427447f, 0.27846259f, 0.38385436f, -0.14739802f, -0.41295391f, 0.29775882f, 
    -0.15276825f, 0.34285703f, 0.49235991f, 0.72643030f, -0.23602463f, 0.36074299f, -0.14511892f, -0.22308384f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.07885858f, -0.04365547f, -0.03601861f, 0.06046143f, -0.04117363f, 0.01039530f, 0.01906947f, 0.04597727f, 
    0.03566702f, -0.07651640f, -0.09213786f, 0.04130803f, -0.01749819f, -0.00405896f, 0.03808746f, -0.04832188f, 
    0.02233478f, -0.00567958f, -0.02783320f, -0.04257748f, 0.04525946f, -0.07940602f, -0.03504351f, 0.04761722f, 
    -0.02457802f, -0.08641135f, 0.04925911f, 0.05643811f, -0.03116336f, -0.05678298f, 0.04039459f, 0.06890879f, 
    0.03635079f, 0.05511301f, 0.04089130f, 0.02578340f, -0.10319296f, 0.01611204f, -0.01038699f, -0.01044573f, 
    0.05670842f, -0.08698871f, -0.09444544f, 0.06289356f, -0.04555789f, 0.04639861f, 0.06550860f, -0.04889089f, 
    0.03343853f, -0.04907857f, -0.06008606f, -0.02870261f, -0.01424326f, -0.05744402f, -0.04142705f, 0.07349462f, 
    0.03574388f, -0.06034301f, -0.05966553f, 0.05722093f, -0.08615541f, 0.06718352f, 0.00045589f, -0.03710517f, 
    -0.02614376f, -0.08122675f, -0.03191097f, -0.08824019f, 0.02381441f, -0.08783323f, -0.09346222f, -0.01094338f, 
    -0.03713486f, -0.05427353f, -0.02434271f, -0.01058091f, -0.09764410f, -0.03953517f, 0.04761340f, -0.06084619f, 
    -0.01318411f, 0.01955266f, 0.01176753f, -0.09155645f, -0.02681623f, -0.00365146f, -0.07254598f, -0.09400124f, 
    0.00821030f, 0.05807095f, -0.00077627f, -0.03923775f, -0.01969706f, 0.05280027f, -0.00322882f, 0.02063658f, 
    -0.00141128f, 0.06003928f, 0.03213793f, 0.03027013f, -0.07711498f, 0.06002716f, 0.01778604f, -0.06770503f, 
    0.05345622f, -0.03350910f, -0.08761241f, 0.05795750f, -0.03927153f, -0.06477404f, -0.03829945f, 0.00312124f, 
    -0.02735614f, -0.01169694f, 0.05380711f, 0.03992378f, -0.04937348f, -0.06368741f, 0.01136968f, -0.08117503f, 
    -0.03607637f, 0.01524299f, -0.06097879f, 0.01202895f, 0.00558037f, -0.10294313f, -0.06176551f, -0.07928223f, 
    0.04453865f, 0.00175438f, 0.03177601f, 0.01396949f, 0.05893129f, -0.06821864f, -0.00425850f, 0.06981028f, 
    -0.02607177f, 0.02799822f, -0.09254193f, 0.00047153f, 0.05559331f, -0.06182905f, -0.02995329f, 0.00407582f, 
    -0.20259157f, -0.01473780f, 0.28161255f, -0.02721525f, 0.11247644f, 0.27491906f, 0.02398449f, -0.12212119f, 
    -0.16642922f, 0.28577599f, 0.15539674f, -0.27489895f, 0.08485244f, 0.10046704f, 0.03717867f, 0.04826642f, 
    0.02647971f, 0.11802739f, 0.35242188f, 0.11942892f, 0.41538981f, -0.01825040f, -0.02815324f, -0.19810003f, 
    -0.11278392f, -0.14951056f, -0.17685233f, 0.18032035f, 0.37088639f, 0.19211347f, -0.32666382f, -0.07817889f, 
    -0.32689503f, -0.04795134f, 0.05577785f, 0.00499935f, 0.15005891f, 0.01301674f, 0.30583498f, 0.04193595f, 
    0.07789195f, 0.11196652f, -0.04429650f, -0.07443592f, 0.29761076f, 0.23619226f, 0.27057606f, 0.02676046f, 
    -0.09138496f, -0.37773341f, -0.07575367f, 0.27680498f, 0.02693742f, -0.02074506f, 0.35183313f, 0.38434350f, 
    -0.02232215f, -0.04458738f, -0.16861653f, 0.00128803f, 0.02578440f, 0.04996029f, 0.17090923f, 0.01897466f, 
    -0.20663100f, -0.47589242f, 0.04560031f, 0.05188980f, -0.00237456f, 0.07719138f, 0.07893837f, -0.09755517f, 
    -0.31775901f, -0.04953765f, 0.08992939f, 0.11057004f, 0.05366278f, -0.15105233f, -0.18106760f, -0.04457387f, 
    -0.27709728f, -0.08940500f, 0.02062613f, 0.21540812f, -0.07038562f, -0.00241022f, 0.00860027f, 0.23513892f, 
    0.33529776f, 0.13466659f, 0.18015386f, 0.18246096f, 0.04896842f, -0.08304279f, 0.16667762f, 0.08642679f, 
    0.08829185f, 0.04440643f, -0.08104801f, 0.12961297f, -0.33007154f, -0.56402409f, -0.14828311f, -0.17544562f, 
    -0.16388965f, -0.00576185f, -0.12257613f, -0.05844771f, -0.04429646f, -0.44276923f, -0.46392119f, -0.04033088f, 
    -0.08796688f, -0.00132976f, -0.01767898f, -0.19738092f, -0.13062297f, 0.16876704f, 0.17744842f, 0.08302632f, 
    0.16806500f, 0.11114781f, -0.11612764f, 0.00736462f, -0.02149928f, -0.04813113f, 0.09175806f, 0.17223898f, 
    0.33895910f, 0.07860311f, 0.09072917f, -0.07618801f, 0.02304842f, 0.02512204f, 0.32300824f, 0.17694546f, 
    0.37564909f, 0.16446653f, -0.00203508f, -0.01817512f, 0.09010452f, -0.01307845f, 0.04127029f, 0.18081243f, 
    0.01851153f, -0.08580639f, -0.04110839f, 0.04598507f, 0.03890640f, 0.05144890f, -0.01139441f, -0.05788544f, 
    -0.07458057f, -0.06029036f, 0.03737815f, -0.00894740f, -0.07860473f, -0.09494068f, 0.01815988f, -0.03987050f, 
    -0.04025885f, -0.07353534f, -0.03454996f, -0.07964432f, 0.00076572f, -0.00561783f, -0.03359444f, -0.09249967f, 
    -0.07865918f, 0.00125871f, -0.06444167f, -0.06890740f, -0.02468764f, -0.01459459f, -0.05760846f, -0.07734609f, 
    -0.04250449f, -0.03999710f, -0.05263048f, 0.06747867f, -0.01834448f, -0.00532310f, -0.02876114f, -0.04468966f, 
    -0.07395326f, 0.06592108f, -0.06186443f, -0.00512683f, -0.06262105f, -0.06668462f, -0.06673512f, -0.05251035f, 
    -0.09408704f, 0.02088981f, 0.02911158f, -0.04384727f, 0.01726543f, 0.05721193f, 0.05287018f, -0.09047904f, 
    -0.01886460f, 0.00825568f, -0.08457144f, -0.04156366f, 0.01616815f, -0.00654013f, -0.02122033f, -0.03307816f, 
    -0.01183356f, -0.06282736f, -0.03460680f, 0.06808619f, 0.05961397f, 0.01709687f, 0.01209257f, 0.05941110f, 
    -0.07739085f, -0.03394421f, -0.05118040f, -0.05854397f, 0.01695507f, -0.04867102f, 0.04771276f, -0.00914287f, 
    -0.04643095f, 0.00377078f, 0.04326982f, -0.02135509f, -0.03627479f, -0.05858236f, 0.00563343f, 0.04411854f, 
    -0.03498165f, 0.06475966f, -0.08657365f, 0.05552432f, -0.06392118f, -0.03129599f, -0.00011222f, 0.01463200f, 
    -0.00480380f, -0.00092902f, -0.00494638f, 0.03655403f, 0.02282147f, -0.05180376f, -0.05309835f, -0.08670066f, 
    -0.08481689f, 0.00992282f, -0.03496098f, -0.09161341f, -0.07761621f, 0.06913459f, -0.00369492f, -0.07906068f, 
    0.05935000f, -0.00080538f, 0.01445384f, -0.05747805f, -0.05385974f, -0.04413766f, -0.01685620f, -0.04775070f, 
    -0.02077563f, -0.05179696f, -0.00154177f, 0.04725564f, 0.05099827f, -0.08167139f, -0.03025698f, 0.06895476f, 
    0.02967720f, 0.00629340f, -0.00177901f, -0.03965531f, -0.06879053f, 0.00460081f, -0.05872535f, -0.04531011f, 
    -0.01581454f, -0.03605235f, -0.01398270f, -0.02536074f, -0.09522133f, -0.08276175f, -0.01481335f, 0.02356037f, 
    -0.64786398f, -0.33070430f, 0.26424065f, -0.09617426f, 0.08828139f, -0.05920457f, -0.11840124f, 0.37141663f, 
    0.00765422f, 0.14943779f, 0.15127452f, 0.19806133f, -0.00627130f, 0.04064157f, 0.06627297f, 0.00952497f, 
    0.29156637f, 0.05109772f, -0.13496484f, -0.50463128f, -0.13886453f, 0.12020893f, -0.11113740f, -0.16312088f, 
    -0.06481225f, -0.06039966f, 0.13448034f, -0.29967067f, -0.34538299f, -0.05115946f, 0.00572017f, 0.02395935f, 
    -0.13113077f, 0.00489445f, 0.04330821f, -0.06795517f, -0.42655441f, -0.28727144f, -0.17636941f, -0.03117508f, 
    0.02641136f, 0.02844369f, -0.06072760f, 0.07049651f, 0.10487680f, 0.11188287f, 0.05492335f, 0.29850656f, 
    -0.13586839f, -0.13181834f, 0.17999539f, -0.17490305f, 0.17847437f, 0.21050273f, 0.25103706f, 0.32262689f, 
    0.28012836f, -0.03609751f, 0.29792485f, -0.13401529f, -0.08986354f, -0.05208900f, -0.31622878f, 0.20563316f, 
    -0.24564914f, -0.10949465f, 0.19584879f, 0.18823922f, 0.03823568f, 0.11146293f, 0.06203211f, -0.24287987f, 
    -0.12779625f, 0.07785792f, 0.05497373f, 0.30605996f, 0.15372443f, -0.07723329f, -0.05913841f, -0.16136861f, 
    -0.25564900f, 0.01222986f, -0.03566140f, 0.16807826f, -0.00230825f, 0.13175403f, -0.06715421f, 0.10078108f, 
    0.07968973f, 0.25179452f, -0.08505552f, 0.03273420f, 0.12586519f, -0.12436386f, 0.12720761f, -0.08478482f, 
    -0.06639527f, 0.04487050f, 0.12049328f, 0.39203992f, -0.09791812f, -0.26041454f, 0.02935802f, 0.11273448f, 
    0.05872850f, -0.06034317f, 0.02002996f, -0.04390514f, 0.56997925f, 0.25656351f, 0.17211165f, -0.02649327f, 
    0.07284886f, 0.05913131f, 0.10308670f, -0.00445326f, -0.19261056f, 0.07451779f, -0.16301347f, -0.30449897f, 
    -0.03357527f, 0.04338671f, 0.06069103f, -0.00472399f, 0.14802481f, 0.02288139f, -0.05493698f, -0.11001348f, 
    -0.18651226f, 0.15428680f, 0.19093649f, -0.08064593f, 0.21208745f, 0.09146298f, 0.08588857f, -0.09441887f, 
    0.03753630f, 0.39864212f, 0.09734230f, 0.00701333f, -0.12390389f, 0.14752567f, -0.01523013f, 0.01219710f, 
    0.03680870f, 0.32050440f, 0.03746850f, 0.14982015f, 0.00394707f, -0.13874751f, -0.12577118f, -0.01647313f, 
    -0.19841038f, 0.30728418f, -0.20038433f, -0.01731978f, 0.06207144f, 0.05914265f, -0.17728494f, 0.17356594f, 
    0.12097279f, 0.20191097f, -0.07739031f, 0.06465990f, -0.00664101f, 0.27185637f, 0.18594514f, -0.05761577f, 
    -0.06918572f, -0.11696105f, 0.06124171f, -0.07872793f, -0.02193991f, -0.14167236f, 0.09111290f, 0.15582202f, 
    0.06828733f, 0.06987990f, -0.26358283f, 0.08053973f, -0.23341905f, -0.11032204f, 0.16095051f, 0.04170949f, 
    -0.01829332f, 0.05140171f, -0.04520540f, 0.17545222f, -0.11514927f, 0.09841697f, -0.11044972f, -0.21163340f, 
    0.10153730f, 0.01730765f, 0.11470079f, 0.06430836f, 0.39115921f, 0.20710033f, -0.32207146f, -0.18718511f, 
    -0.00198728f, -0.18362594f, 0.03112270f, 0.10918356f, 0.20357375f, 0.13014211f, 0.11666143f, -0.03228126f, 
    0.10291083f, 0.04775772f, -0.07103451f, 0.04656199f, 0.14978182f, 0.05500367f, -0.00481451f, 0.16529053f, 
    -0.19494478f, -0.12087858f, -0.18381728f, 0.01139079f, 0.16492833f, 0.02134194f, -0.32643828f, -0.16833696f, 
    -0.40773544f, -0.16361672f, 0.10369366f, -0.08347049f, 0.02453307f, -0.08347217f, -0.17509991f, 0.22939524f, 
    0.30988124f, 0.27933416f, -0.03194860f, -0.01476455f, -0.05533332f, 0.18796086f, 0.02534199f, 0.11738262f, 
    0.17957313f, 0.23410080f, 0.02863477f, -0.00750198f, 0.25473300f, 0.05469938f, -0.01136299f, 0.19045007f, 
    0.12745018f, 0.01464255f, -0.20456275f, -0.09540433f, -0.18658000f, -0.17238706f, 0.25854948f, 0.14141545f, 
    -0.04297318f, -0.08064078f, -0.13969372f, 0.04359489f, -0.35294801f, 0.20238309f, -0.02434323f, 0.09209952f, 
    -0.07180303f, 0.10736094f, 0.30154037f, -0.02193970f, -0.04090419f, 0.28599644f, -0.06149304f, 0.21081460f, 
    -0.21939862f, -0.16309813f, 0.29842874f, 0.00900547f, -0.10846489f, -0.08537766f, 0.03273049f, -0.14445533f, 
    -0.50126064f, -0.04780011f, 0.11562359f, 0.08054405f, 0.04213772f, 0.15886156f, 0.15135197f, 0.05408721f, 
    0.02911951f, -0.08093682f, -0.05083913f, -0.06721633f, 0.00442869f, -0.02431476f, 0.00642225f, 0.02737510f, 
    0.01156618f, -0.01696451f, -0.05841800f, -0.07256781f, -0.00695381f, 0.03597585f, 0.00706804f, -0.01841471f, 
    -0.09182017f, -0.04636213f, 0.00598797f, -0.08247591f, 0.00072245f, -0.00451059f, -0.08910280f, -0.08921323f, 
    0.00250828f, 0.06584611f, -0.08049569f, -0.06965850f, 0.05414413f, 0.00248114f, -0.00237316f, 0.01937408f, 
    0.04770067f, 0.06376554f, -0.03769673f, -0.05657942f, 0.03512554f, 0.04491358f, 0.03400309f, -0.07947359f, 
    -0.07000864f, -0.02762850f, -0.03497579f, 0.01202424f, -0.03605063f, 0.05147339f, -0.06263845f, -0.06906719f, 
    0.00113309f, -0.07068760f, 0.00519991f, -0.05572741f, 0.07402072f, -0.03962246f, 0.02203911f, -0.05947743f, 
    0.01942292f, 0.04201225f, -0.01980970f, -0.01417110f, -0.00332565f, -0.08884818f, 0.03805090f, 0.01746282f, 
    0.05500976f, -0.01141884f, -0.06449862f, -0.04983947f, 0.01332262f, 0.07114532f, -0.08393665f, -0.07596846f, 
    -0.00916259f, 0.05468873f, -0.08762064f, 0.04616398f, 0.02209950f, -0.09841801f, -0.04106537f, -0.08194713f, 
    0.01024795f, -0.06786961f, -0.03650463f, -0.07184059f, -0.04920020f, 0.06228926f, 0.03239457f, 0.02000596f, 
    -0.04580726f, 0.00127017f, -0.02406602f, 0.01898861f, -0.03741699f, -0.08212803f, -0.05498007f, -0.04689899f, 
    0.00120263f, -0.05054692f, -0.00616809f, -0.05885847f, -0.04105180f, -0.07637567f, 0.00830952f, -0.01313870f, 
    0.04922941f, 0.02066045f, 0.06491649f, -0.01009758f, -0.00448566f, 0.04354117f, -0.06722643f, -0.02306616f, 
    0.04138245f, -0.00628123f, 0.04164454f, -0.07312847f, 0.04513060f, 0.05557023f, 0.02724396f, -0.05149332f, 
    0.04982528f, -0.08140836f, -0.01038045f, -0.05393127f, 0.01635755f, 0.06461809f, -0.03250705f, -0.03865185f, 
    0.05346452f, -0.04446242f, -0.00013073f, 0.02054523f, -0.05594682f, 0.01485245f, 0.04926292f, -0.01228657f, 
    -0.06948456f, -0.05416325f, -0.06757229f, -0.00576580f, 0.05636679f, -0.00773234f, 0.00253310f, 0.05055479f, 
    -0.58608913f, -0.22827248f, -0.00532879f, -0.03945303f, -0.16964151f, -0.01666776f, 0.15974088f, 0.13678461f, 
    0.05320010f, 0.14469029f, 0.29519469f, 0.34215018f, -0.20910867f, -0.10530891f, -0.09663180f, -0.02481413f, 
    0.06038758f, -0.11144893f, 0.15261073f, -0.31474346f, -0.41275266f, -0.22085111f, -0.12719075f, 0.13697676f, 
    0.08076175f, 0.04236828f, 0.31921533f, 0.03666621f, -0.56834841f, -0.74482298f, 0.10339457f, -0.18818162f, 
    -0.04455059f, 0.12107366f, 0.05231058f, 0.13158934f, -0.03288537f, -0.02829323f, -0.06431274f, 0.05313120f, 
    0.14336447f, -0.04189523f, 0.11057358f, 0.04325906f, -0.05905129f, -0.01911706f, -0.63032150f, -0.08176115f, 
    -0.02439662f, -0.04034811f, 0.20461035f, 0.17372614f, -0.05850314f, -0.02749422f, 0.15258873f, 0.08698042f, 
    0.19945891f, 0.18538076f, -0.00602556f, 0.16016968f, 0.15383281f, -0.23161374f, 0.05227865f, -0.09752484f, 
    0.25125843f, -0.25451919f, 0.10317411f, 0.01177355f, 0.07498211f, 0.05149317f, 0.08933799f, 0.03741242f, 
    -0.26296556f, 0.45670503f, -0.68157899f, 0.13022794f, 0.10891918f, -0.01952206f, 0.03865935f, 0.08317985f, 
    -0.05880189f, 0.20469908f, -0.09977431f, -0.14875771f, -0.15828502f, 0.04166498f, -0.06159631f, 0.03081130f, 
    -0.08976643f, -0.07369466f, -0.00979877f, 0.03880192f, 0.09247093f, -0.26348934f, 0.01704695f, -0.17321549f, 
    -0.07975180f, -0.03863735f, 0.09402115f, 0.24550033f, 0.04417417f, -0.10782746f, 0.11419448f, 0.05039354f, 
    0.19447818f, 0.19118562f, 0.04925289f, 0.13021424f, 0.17228788f, -0.11617883f, 0.18983333f, 0.10869317f, 
    0.00169158f, 0.03563092f, 0.12783973f, -0.01332660f, 0.07064854f, -0.17976052f, 0.31320134f, -0.39786935f, 
    -0.03770989f, 0.07036316f, 0.01914996f, 0.14359817f, 0.09694791f, -0.03978410f, 0.21214586f, -0.15902704f, 
    -0.35151902f, 0.29252413f, -0.11967121f, -0.04324320f, 0.06608389f, -0.04338654f, -0.09369618f, 0.28683105f, 
    0.30786130f, 0.44994125f, -0.07629239f, 0.07787082f, -0.08398774f, -0.09080233f, -0.17188424f, 0.11399330f, 
    0.05703130f, -0.16192047f, 0.10412693f, 0.12594022f, -0.02897368f, 0.11824255f, 0.07756215f, -0.16046183f, 
    0.32898492f, -0.04380374f, 0.03769807f, 0.17971990f, 0.05522834f, 0.10047016f, 0.11404080f, -0.05132790f, 
    0.23470435f, -0.10190353f, -0.13403068f, -0.04501184f, -0.10023664f, 0.19242267f, 0.15633482f, 0.05942008f, 
    0.01370228f, 0.06187098f, -0.14167184f, 0.06027661f, -0.31855792f, 0.18367288f, -0.00791163f, -0.03852096f, 
    0.02020710f, -0.13569137f, -0.08427149f, -0.00617743f, 0.15003724f, -0.27773741f, 0.16561869f, 0.02482843f, 
    0.04522002f, 0.19669180f, 0.13053311f, 0.09744143f, -0.07695548f, -0.03107007f, -0.04310801f, -0.11755313f, 
    0.02848991f, 0.21812095f, 0.09926588f, -0.12954050f, 0.02852631f, 0.28102714f, 0.02856638f, -0.09153450f, 
    -0.01660233f, 0.08958686f, -0.24322499f, 0.05142254f, -0.18547899f, 0.03747861f, -0.15752609f, 0.07669783f, 
    0.38042578f, -0.03005125f, 0.32474497f, 0.15930872f, -0.11424502f, 0.05851515f, -0.04160676f, 0.33985484f, 
    0.09357742f, -0.38328055f, -0.30567163f, -0.07971388f, -0.19844681f, -0.03073794f, -0.16687487f, -0.07947751f, 
    -0.27063668f, -0.26233175f, 0.15808503f, 0.09023850f, -0.12478387f, 0.01460173f, -0.02767783f, 0.08672477f, 
    0.32139701f, 0.11000760f, 0.03831693f, 0.00258927f, -0.18745044f, 0.12967090f, 0.11650349f, 0.18825097f, 
    0.07077973f, 0.17466842f, -0.06506421f, 0.15850730f, 0.24958780f, 0.12928259f, 0.00620917f, 0.06595444f, 
    0.03782767f, -0.00198642f, -0.18632318f, 0.13967757f, -0.11739069f, 0.02145750f, -0.17437731f, 0.14096327f, 
    -0.09455345f, -0.04964877f, -0.33560213f, -0.03548326f, -0.19117199f, 0.26148891f, 0.24210508f, -0.02201988f, 
    0.27948612f, 0.12378472f, 0.07040279f, 0.30677700f, 0.13246851f, 0.23046806f, 0.18869534f, -0.20692188f, 
    -0.12430944f, -0.16578779f, 0.06122842f, -0.19648856f, 0.11914352f, 0.10133166f, -0.24389046f, -0.13909382f, 
    -0.12256466f, -0.23810229f, -0.07868790f, 0.02824189f, -0.12983632f, -0.03000658f, -0.02275389f, 0.10088230f, 
    0.08441214f, 0.24201761f, -0.07537112f, -0.04336872f, -0.27187183f, 0.01198233f, 0.16873351f, 0.23754703f, 
    -0.02557750f, 0.49454927f, -0.08716453f, 0.25935251f, -0.10811619f, 0.20843613f, 0.00540635f, -0.08618622f, 
    -0.27264044f, 0.12147455f, 0.16983591f, -0.05347365f, 0.12182659f, -0.28162169f, -0.15064643f, -0.13443364f, 
    0.15690370f, -0.01167118f, 0.25359696f, -0.09940317f, 0.06654283f, 0.02406484f, -0.42761108f, -0.22691335f, 
    -0.08860053f, -0.01326656f, 0.22313756f, 0.05931717f, -0.29079959f, 0.62606794f, -0.13085292f, -0.10403306f, 
    0.04251304f, -0.06422311f, -0.06259237f, 0.12018692f, -0.05295400f, 0.14030111f, -0.20983115f, 0.03390940f, 
    -0.09159750f, -0.36572298f, -0.63075781f, -0.19678496f, 0.09523286f, 0.02024392f, -0.25980264f, -0.15677539f, 
    0.52631491f, 0.00111637f, -0.41573998f, -0.12472508f, -0.04617995f, -0.06252988f, 0.05196300f, -0.17670384f, 
    0.37000671f, 0.44327632f, 0.12782474f, 0.24629274f, 0.10640272f, 0.31932288f, -0.26392478f, -0.05476903f, 
    -0.00566386f, -0.32997036f, -0.26225621f, 0.41478136f, -0.21048908f, -0.01480923f, -0.06244027f, -0.01333345f, 
    -0.17635876f, 0.12429129f, -0.29696244f, -0.21559453f, 0.15842429f, -0.10336219f, 0.23857155f, 0.08388522f, 
    -0.00252226f, 0.11742016f, 0.19352089f, 0.31227621f, 0.51041234f, 0.02457216f, 0.11699650f, 0.22330834f, 
    0.15776858f, -0.16311227f, 0.01841522f, -0.16780743f, 0.12122419f, 0.76688844f, 0.08830904f, 0.16615348f, 
    -0.07778298f, 0.02983825f, 0.14246784f, 0.21664722f, 0.03209752f, 0.21358071f, -0.14796329f, -0.10911281f, 
    -0.05864624f, -0.11163341f, 0.33848312f, -0.00774983f, -0.12017538f, -0.33579066f, 0.03424202f, 0.45411214f, 
    0.10656486f, 0.15945639f, 0.27275226f, 0.16369525f, 0.06818064f, 0.06635009f, -0.29370752f, -0.13323368f, 
    -0.24202468f, -0.09865177f, -0.14260367f, 0.06057893f, -0.10239317f, 0.26664540f, 0.05728263f, 0.09677252f, 
    -0.23563617f, 0.47552937f, -0.02286511f, -0.08576506f, 0.13699053f, 0.07131476f, -0.29708445f, -0.04286854f, 
    -0.67839092f, -0.02308837f, 0.13764188f, -0.25226989f, -0.00580160f, -0.01342509f, 0.03014684f, -0.12012430f, 
    0.05532428f, 0.13598470f, 0.05819023f, -0.03091444f, -0.08860486f, -0.03364090f, 0.05866754f, -0.05956025f, 
    0.05687313f, -0.03686028f, 0.29691976f, 0.43647671f, 0.16619286f, -0.25967366f, -0.13611796f, -0.19369882f, 
    0.16568509f, 0.03961576f, 0.05403162f, -0.22134195f, 0.26020324f, -0.11083329f, -0.16389886f, 0.01108026f, 
    0.11837117f, 0.05821643f, 0.10139715f, -0.04184174f, 0.13184367f, -0.18807518f, -0.32239684f, 0.11048942f, 
    0.00646399f, -0.04769107f, 0.05628209f, 0.04771708f, -0.15352565f, -0.04066045f, 0.39864388f, 0.35385463f, 
    -0.22785297f, 0.03903832f, -0.23469999f, 0.16903365f, 0.29036862f, 0.04031924f, -0.04249040f, 0.06735777f, 
    0.28422970f, -0.07862662f, -0.15166056f, -0.17003149f, 0.11188332f, -0.04327101f, 0.06788296f, -0.07047779f, 
    -0.07513394f, -0.25089079f, 0.02530830f, 0.03081347f, 0.21450734f, 0.12955067f, 0.10085668f, -0.08587878f, 
    -0.11069813f, -0.28727680f, -0.25252831f, 0.06121529f, -0.14411917f, -0.23125513f, 0.09422734f, 0.12182976f, 
    0.23121136f, 0.03821260f, -0.33820516f, 0.10385141f, 0.10954934f, 0.09223523f, 0.05798127f, 0.16441751f, 
    -0.20655566f, -0.06251916f, 0.06222926f, 0.18076801f, 0.27013537f, 0.00380472f, 0.16811338f, -0.04120424f, 
    0.05044644f, 0.09991990f, 0.07978729f, 0.23070455f, -0.24329811f, 0.21306664f, 0.16659136f, 0.00872313f, 
    -0.05990001f, -0.00310784f, 0.16172852f, 0.02784676f, -0.33316994f, -0.09755768f, -0.06243283f, -0.15388855f, 
    -0.08768615f, -0.04972477f, 0.08670300f, 0.03074019f, -0.01516895f, -0.41896912f, -0.13358402f, -0.12178142f, 
    -0.05995305f, -0.04482082f, 0.16634189f, -0.04457537f, 0.05850913f, -0.23069298f, -0.01894608f, -0.17999797f, 
    -0.07046063f, 0.02325469f, -0.28725424f, -0.10646467f, 0.11051834f, 0.03485221f, 0.20635892f, -0.17376877f, 
    0.21751046f, 0.13635856f, -0.18556474f, -0.22490235f, -0.21547323f, 0.17327458f, -0.03091509f, -0.00641500f, 
    -0.02412522f, -0.04758418f, 0.04238784f, -0.02515328f, 0.04506424f, 0.04956888f, 0.07535854f, 0.01390280f, 
    -0.00540995f, 0.02764867f, 0.03561780f, -0.03615582f, -0.00074145f, 0.04966016f, -0.08164816f, 0.06707771f, 
    -0.02431337f, -0.01710555f, 0.02813500f, 0.04754533f, -0.02811616f, 0.04413877f, -0.04017115f, -0.07767358f, 
    -0.02292305f, -0.08412287f, -0.06388466f, 0.05152223f, -0.07409282f, -0.05783471f, -0.00481321f, -0.05174837f, 
    0.01881994f, -0.00876098f, 0.00717061f, 0.02494089f, -0.06200292f, -0.07339460f, 0.07036328f, 0.04315730f, 
    0.01575381f, -0.00325083f, 0.02074381f, -0.02474153f, -0.03716909f, -0.05940882f, 0.06301721f, 0.06623134f, 
    0.05060138f, 0.02647502f, -0.00043306f, -0.04744754f, -0.00075141f, -0.03717893f, -0.01294825f, -0.07870165f, 
    0.03469076f, 0.05772508f, 0.01274784f, 0.02856624f, -0.02987813f, -0.03668877f, 0.03676027f, -0.07636581f, 
    -0.01920760f, -0.02639314f, 0.02618819f, -0.08896157f, 0.00874368f, -0.08849858f, 0.02106866f, -0.02798295f, 
    -0.02342791f, -0.06470578f, 0.04073440f, 0.01411888f, 0.05114646f, 0.02852674f, -0.04111192f, -0.00748842f, 
    0.04141772f, -0.07619862f, -0.02513970f, -0.08457711f, 0.05844629f, 0.04398830f, 0.01261778f, -0.03362921f, 
    -0.07640265f, -0.02791146f, 0.06991879f, -0.04902443f, 0.02583501f, 0.02697723f, -0.07315608f, 0.07138108f, 
    0.02927273f, -0.05261300f, -0.06513423f, -0.07933298f, 0.01896723f, -0.07443690f, -0.09050965f, -0.08638623f, 
    0.01945815f, -0.08276663f, 0.02365088f, -0.08065650f, 0.03921553f, 0.03635743f, 0.06199890f, -0.06552894f, 
    -0.04807499f, 0.06380924f, 0.00472517f, 0.02632786f, -0.00348102f, 0.00551601f, 0.00646702f, 0.01250581f, 
    -0.04117836f, -0.03763185f, -0.02115264f, 0.00965707f, 0.06746972f, 0.05973861f, 0.05688974f, -0.06414472f, 
    -0.01880179f, -0.02932464f, -0.08865196f, -0.01442951f, -0.00795876f, 0.02142695f, -0.01533534f, 0.01726606f, 
    -0.05943789f, -0.08903506f, -0.02321766f, -0.01690028f, -0.08146978f, -0.06870097f, 0.05524606f, 0.05251882f, 
    0.29895881f, 0.37424368f, 0.09467439f, 0.04708489f, 0.21127467f, 0.20966685f, 0.03991740f, 0.01357548f, 
    0.13243154f, -0.10470428f, -0.28989950f, -0.03766789f, 0.04410194f, 0.16355148f, 0.10493469f, 0.03382482f, 
    -0.16692761f, -0.13623637f, 0.28500158f, 0.05961851f, -0.01645582f, -0.05987597f, 0.04384608f, 0.37070653f, 
    -0.22948453f, 0.06142914f, 0.01325458f, 0.24096210f, -0.24352601f, -0.06810140f, -0.08843701f, 0.12274493f, 
    -0.07196760f, 0.17987418f, -0.12370612f, -0.24490768f, 0.43386731f, 0.07435613f, 0.36829448f, -0.21339226f, 
    0.02298109f, -0.16730218f, 0.03760779f, 0.06433295f, -0.09838331f, -0.06265830f, 0.14580250f, -0.08143264f, 
    -0.03049308f, 0.01404983f, 0.07864301f, -0.13647270f, 0.04866714f, -0.11531524f, 0.64367938f, -0.16762483f, 
    -0.07542734f, 0.25481868f, -0.13790652f, -0.06008109f, -0.11574902f, -0.10758812f, 0.20063540f, -0.11076325f, 
    0.09631469f, 0.08018340f, 0.19892280f, 0.16643728f, 0.25152364f, 0.04257044f, -0.01093790f, 0.19559830f, 
    -0.02825370f, 0.05452981f, 0.12754528f, -0.00413810f, 0.09087788f, -0.36474147f, 0.29328540f, 0.39025685f, 
    0.17753626f, 0.13119115f, 0.00522957f, -0.11547538f, -0.00742579f, -0.01618825f, -0.10179113f, 0.06838749f, 
    -0.19428463f, -0.27808052f, 0.08934857f, 0.23877381f, 0.15551287f, 0.05522403f, 0.08563922f, -0.04205116f, 
    -0.07532209f, -0.14838654f, -0.06216584f, 0.03095104f, -0.28604630f, -0.13486138f, 0.03898174f, 0.08171102f, 
    0.15383993f, -0.03561779f, 0.07003920f, 0.22776125f, 0.10685431f, 0.06653555f, -0.13025175f, -0.15334834f, 
    0.05905370f, 0.00170607f, -0.21029632f, 0.33526444f, 0.34133193f, -0.39923042f, 0.19881372f, 0.28245878f, 
    0.21380608f, 0.15857759f, 0.04302328f, -0.06412905f, 0.01462271f, -0.27216202f, -0.03193789f, -0.27979702f, 
    0.09244485f, 0.02659978f, 0.16858147f, 0.03795783f, 0.13747121f, 0.01585185f, -0.08096027f, -0.02286991f, 
    -0.00988363f, -0.01504529f, 0.17717820f, 0.00710703f, -0.14468150f, 0.09527006f, 0.13891965f, -0.25287679f, 
    0.06585224f, -0.02774974f, -0.06589900f, -0.02848211f, 0.01402937f, 0.06345480f, -0.01900853f, -0.00487672f, 
    0.00083887f, -0.07503106f, -0.07704493f, -0.06259204f, -0.01183645f, 0.04617256f, -0.05602966f, 0.01234997f, 
    -0.06242790f, -0.03581237f, 0.06873053f, 0.03817663f, 0.00685207f, -0.06436967f, 0.01373871f, -0.02449255f, 
    -0.06247450f, -0.07369771f, -0.03495738f, 0.04882100f, -0.08098052f, 0.00209361f, 0.04539369f, 0.01622769f, 
    0.00238579f, 0.00433533f, -0.03504372f, -0.02521840f, 0.06396767f, -0.03119141f, 0.03839051f, -0.00554678f, 
    0.04522458f, 0.02193982f, 0.06925430f, -0.02400596f, -0.00495393f, -0.07489583f, -0.05173308f, -0.08495747f, 
    -0.04532157f, 0.03234382f, 0.05332832f, -0.05748449f, -0.00063416f, 0.01260857f, -0.08001065f, 0.04648244f, 
    0.07437696f, 0.04465489f, -0.05962855f, 0.06935769f, -0.06040252f, -0.06831687f, 0.04185123f, -0.06513558f, 
    -0.01958712f, -0.08576793f, 0.02809713f, -0.00270994f, -0.08495658f, -0.04641186f, 0.03906965f, -0.02016961f, 
    -0.07839195f, -0.01636965f, -0.07623453f, 0.02415366f, -0.04856383f, 0.00008317f, 0.02934194f, 0.05231247f, 
    -0.01110238f, 0.05652132f, -0.05095966f, 0.04277683f, -0.01893675f, 0.03403021f, 0.02047895f, 0.02687912f, 
    -0.07102765f, -0.08812844f, -0.08382747f, -0.06642672f, 0.01174933f, -0.01131672f, -0.05781591f, 0.04592117f, 
    0.00144743f, -0.07812745f, 0.05965524f, -0.01226938f, -0.08043944f, 0.02621987f, -0.01580324f, -0.08556091f, 
    -0.07493569f, -0.02008741f, -0.01778501f, -0.07868385f, 0.04434634f, -0.04919426f, -0.02184706f, 0.08325937f, 
    -0.05399027f, 0.05138308f, 0.04119067f, 0.01671313f, -0.07492956f, -0.08006491f, 0.01942872f, -0.01077884f, 
    0.03352147f, -0.00821205f, -0.02298845f, -0.06085584f, -0.05790025f, 0.07313843f, -0.03362905f, 0.00435369f, 
    0.06166272f, -0.06038542f, -0.07545488f, -0.04304779f, -0.06916137f, -0.08600673f, 0.05312986f, 0.03438251f, 
    0.02787267f, 0.01846015f, -0.02883175f, -0.02730821f, -0.05254754f, 0.03788611f, -0.04145878f, -0.00878587f, 
    -0.65651691f, -0.45618737f, -0.46229255f, -0.03959048f, -0.19701315f, -0.08453169f, 0.05712272f, 0.07411509f, 
    0.25437135f, -0.25332782f, -0.51260710f, -0.42450747f, -0.21188737f, 0.12335258f, -0.09752650f, 0.08309002f, 
    -0.06282863f, -0.00048385f, -0.04784349f, 0.11540235f, 0.16523844f, -0.10732035f, -0.11952088f, -0.14082998f, 
    -0.09586673f, -0.07599068f, 0.17334865f, 0.28991893f, 0.17484905f, -0.08006544f, 0.21536143f, 0.00284554f, 
    0.20244488f, 0.16919944f, 0.05443134f, 0.05322115f, 0.16045688f, -0.10839949f, -0.01286471f, -0.03141288f, 
    0.24020006f, 0.30175707f, 0.09328362f, 0.01651657f, 0.02119303f, -0.36427340f, -0.54256725f, 0.18023682f, 
    -0.01955935f, -0.11644532f, -0.23855634f, -0.00149571f, -0.07470129f, 0.01609269f, -0.32146415f, -0.27349678f, 
    0.15830162f, 0.12177831f, -0.08549932f, -0.19022495f, -0.04828027f, 0.10109103f, 0.13213757f, -0.00596873f, 
    0.04538821f, -0.04015894f, 0.08094181f, 0.10997403f, -0.04883233f, -0.04253825f, -0.19927470f, 0.10466903f, 
    -0.06835821f, -0.15496705f, -0.11593017f, -0.06380840f, -0.05928224f, -0.12079436f, 0.15945673f, 0.12010932f, 
    0.08938815f, 0.16462792f, -0.04759120f, 0.05780562f, 0.01783762f, 0.03599531f, 0.05270424f, 0.18093382f, 
    -0.03175239f, -0.03896150f, -0.09890740f, -0.38828832f, -0.58429593f, 0.16365013f, -0.07240418f, -0.24117690f, 
    0.24305479f, 0.06562731f, 0.14014883f, -0.26107651f, 0.21661638f, 0.59047526f, -0.00266377f, 0.03952962f, 
    0.14664973f, 0.07731318f, 0.07943898f, 0.20351273f, 0.09320877f, -0.13716090f, 0.00913468f, -0.17887129f, 
    -0.04230313f, 0.04711758f, 0.01075033f, 0.05886650f, 0.17002469f, 0.33538538f, 0.36277264f, -0.58570582f, 
    0.19717827f, 0.04380277f, 0.12008729f, -0.09137563f, 0.02449434f, -0.15048598f, -0.27322230f, 0.19390157f, 
    0.09373166f, -0.15206978f, -0.10618274f, -0.13825426f, -0.01545375f, -0.07445280f, 0.31374645f, -0.20157871f, 
    0.04819126f, -0.50701463f, 0.05385172f, -0.05837763f, -0.41687599f, -0.10702530f, -0.07794592f, -0.11319988f, 
    -0.01451393f, 0.41659847f, -0.27856135f, 0.06330520f, -0.09545217f, -0.17757742f, 0.03506652f, 0.29821059f, 
    -0.16041259f, -0.43395823f, 0.28808555f, 0.05229582f, 0.00889997f, 0.02664044f, 0.12709452f, -0.05232983f, 
    -0.18830438f, 0.19005886f, 0.11760187f, 0.31472355f, -0.07454529f, 0.15107480f, -0.07494925f, -0.08610233f, 
    0.07551139f, 0.12859656f, -0.03744391f, 0.02765706f, 0.58211547f, 0.25232190f, -0.03165537f, -0.07071356f, 
    -0.02238336f, -0.23848090f, -0.01033040f, -0.05709621f, 0.36904973f, -0.05653297f, -0.03364844f, 0.10874554f, 
    0.13972831f, -0.22451474f, -0.15461239f, 0.12739092f, -0.03607708f, 0.18926094f, 0.23314516f, 0.01418037f, 
    0.06301734f, -0.02518850f, 0.11078116f, -0.05560521f, -0.05203220f, -0.15828069f, -0.20140295f, -0.10793274f, 
    0.38139501f, 0.08052691f, 0.01437220f, -0.01545426f, -0.02787462f, 0.04439619f, 0.27074692f, 0.32372200f, 
    -0.28058106f, 0.50962985f, 0.10548177f, 0.10841662f, 0.22189476f, 0.03822786f, -0.17260349f, -0.03128782f, 
    0.10832496f, 0.04948742f, 0.05335815f, -0.20060676f, -0.09224388f, -0.15048459f, -0.00067086f, 0.05165137f, 
    -0.35859755f, -0.07364275f, 0.35055372f, -0.02563468f, 0.04543729f, 0.10832953f, 0.11047453f, -0.16752213f, 
    -0.05200965f, 0.01599406f, -0.20950517f, -0.04756516f, -0.08786942f, 0.04388605f, 0.02719808f, -0.08601334f, 
    0.11197590f, -0.05623704f, 0.09548866f, -0.16017903f, -0.16011231f, -0.17189968f, -0.04510127f, -0.01954878f, 
    0.13633698f, 0.00024819f, 0.06740951f, -0.05694092f, 0.04330526f, 0.02188717f, -0.00894519f, 0.02183590f, 
    -0.23836158f, 0.17581056f, 0.04666708f, 0.04326437f, -0.12665656f, 0.26028097f, 0.03337416f, 0.53175896f, 
    -0.11082664f, -0.08152521f, 0.33881497f, -0.11835553f, -0.10307072f, 0.16849037f, -0.06221686f, 0.10031192f, 
    0.16402340f, -0.03976722f, -0.51991695f, 0.06975509f, 0.02049120f, 0.05699899f, -0.04564083f, 0.03060502f, 
    0.00352849f, 0.02731648f, 0.16903667f, 0.06312565f, -0.15145792f, -0.10279354f, -0.02799329f, 0.05896620f, 
    -0.50330883f, -0.09322219f, 0.38632408f, 0.14170498f, -0.20624517f, -0.09230749f, -0.07525105f, 0.00546802f, 
    -0.01661260f, -0.58016318f, -0.58291495f, 0.19414505f, 0.07130039f, 0.30991727f, -0.17612714f, 0.09542125f, 
    0.14350513f, -0.03361247f, 0.10086706f, -0.02326630f, 0.05975183f, 0.12709481f, -0.03706808f, -0.09933172f, 
    -0.23429543f, -0.04536344f, 0.14996210f, -0.05063755f, 0.40317312f, 0.05002855f, -0.03980581f, -0.03923884f, 
    -0.18303792f, 0.07843641f, 0.03504375f, -0.09706286f, 0.24443309f, 0.39373425f, -0.18709555f, 0.00912413f, 
    -0.15561961f, -0.10910396f, 0.24777730f, 0.01994282f, 0.19394188f, -0.13427167f, 0.00569393f, 0.43173957f, 
    0.17337528f, -0.03553127f, -0.14448020f, 0.38667774f, -0.03358283f, 0.03675419f, -0.01123172f, 0.07318380f, 
    -0.15647446f, -0.41319016f, 0.10502468f, -0.10810024f, 0.11326481f, -0.00754272f, -0.23192018f, 0.04334754f, 
    -0.20607173f, 0.57057124f, -0.01121765f, -0.08328898f, 0.38425004f, -0.02438791f, -0.02503528f, -0.09178931f, 
    -0.22472218f, -0.00535635f, -0.02430820f, 0.12053394f, -0.35113993f, 0.20515014f, 0.01349761f, -0.19381867f, 
    0.18049850f, 0.01902046f, -0.19271831f, -0.02829549f, 0.12293772f, 0.12211677f, -0.11537485f, 0.00253506f, 
    -0.02845758f, -0.04115599f, -0.32599860f, -0.07637215f, 0.22731227f, -0.14588508f, -0.21946989f, -0.23365456f, 
    -0.04194675f, 0.06360953f, -0.03210431f, 0.07560576f, -0.56395435f, -0.17215869f, 0.21539025f, -0.04661126f, 
    0.08030845f, 0.10766935f, 0.09543142f, -0.03340703f, 0.01513149f, -0.15630046f, -0.20917025f, 0.09003051f, 
    0.15893100f, -0.04935947f, -0.15509894f, 0.04548235f, 0.19435230f, 0.49235660f, -0.25112271f, 0.24612747f, 
    -0.30214396f, 0.07507034f, 0.59965384f, -0.11986142f, -0.02014740f, -0.11941481f, -0.23195642f, 0.12418257f, 
    -0.21524586f, 0.01074242f, -0.16240561f, 0.03301874f, 0.19801904f, -0.01104467f, 0.15556598f, -0.13842058f, 
    0.04842932f, 0.12483890f, -0.20637280f, -0.07610094f, -0.06074101f, 0.08734094f, -0.03161821f, 0.04862047f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.03690409f, -0.04969703f, -0.03766720f, 0.02981011f, 0.27432558f, -0.06171078f, -0.02120180f, 0.27738705f, 
    0.28746757f, 0.14491364f, 0.03075047f, -0.03233601f, 0.04608104f, 0.34727430f, 0.03706886f, 0.05030674f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.10536049f, 0.16745512f, 0.03909189f, 0.38864762f, -0.14520055f, -0.25656617f, -0.25242907f, 0.04082448f, 
    0.06381665f, -0.33950278f, 0.20639145f, -0.17422640f, 0.03175640f, -0.05367697f, 0.42061266f, 0.35960397f, 
    -0.08369887f, -0.44100481f, 0.18303049f, -0.16931461f, 0.32394820f, -0.18808703f, -0.49653953f, -0.11210269f, 
    0.46608132f, -0.23407564f, 0.05805809f, 0.16794053f, -0.11602943f, 0.48233840f, 0.16161373f, -0.03684637f, 
    -0.01158953f, 0.43998945f, -0.13278505f, -0.00766700f, 0.32223567f, -0.08739624f, -0.05837365f, 0.28805333f, 
    0.01625018f, -0.48738322f, 0.03465101f, 0.35933232f, 0.19588041f, 0.01329321f, -0.34907043f, -0.55003726f, 
    -0.09871826f, 0.15005824f, 0.10966212f, -0.22991911f, -0.05171824f, 0.10367635f, -0.21106291f, -0.08274952f, 
    -0.07976839f, -0.21878690f, 0.08855581f, -0.23145050f, 0.15491706f, -0.16691366f, -0.13735092f, -0.24902812f, 
    0.13813832f, 0.23946330f, 0.22880679f, -0.08857547f, -0.19579633f, -0.22567300f, 0.56752980f, 0.03392154f, 
    -0.33177194f, 0.06554848f, 0.20508167f, 0.33374056f, 0.15692538f, 0.00788684f, 0.23128976f, 0.30975941f, 
    -0.06489582f, 0.28731281f, 0.15979314f, -0.01286184f, 0.34864211f, -0.03571146f, -0.00179780f, 0.07590900f, 
    0.03827413f, -0.57266617f, 0.15210930f, 0.19998002f, 0.12480268f, -0.79980636f, -0.07072382f, 0.60966259f, 
    -0.02638260f, -0.22689995f, -0.09049180f, -0.18262160f, -0.21219802f, -0.10616109f, -0.06912383f, 0.02672677f, 
    -0.04773793f, 0.15225667f, -0.17546546f, -0.09204003f, 0.07507154f, 0.07042859f, 0.06112524f, 0.01137248f, 
    -0.06186090f, -0.42800677f, 0.17828219f, -0.26082751f, 0.01577091f, 0.25044432f, -0.13710006f, 0.20582956f, 
    0.18310274f, -0.23034221f, -0.12980983f, 0.16753998f, -0.17758009f, 0.45975909f, 0.35311723f, 0.46876746f, 
    -0.00646864f, -0.29480660f, -0.22521415f, 0.23427953f, -0.10636920f, -0.04094754f, 0.61726117f, 0.24391545f, 
    0.56830233f, 0.10665817f, -0.21758778f, -0.19392535f, -0.08840448f, -0.14037894f, -0.20644541f, -0.48428792f, 
    -0.20331162f, 0.33526853f, 0.18161292f, 0.46792305f, 0.05202851f, 0.08112049f, 0.21615444f, 0.26507324f, 
    -0.32264346f, -0.15482719f, 0.14024663f, -0.37953839f, 0.10967807f, 0.22468188f, 0.22159493f, 0.04408936f, 
    -0.10611314f, -0.05900776f, -0.21913871f, -0.08145417f, -0.37091783f, -0.21046588f, 0.47063816f, -0.15910220f, 
    0.13759317f, 0.53473222f, -0.14691499f, 0.39932108f, 0.08742887f, -0.17318830f, 0.26514378f, 0.24900313f, 
    -0.18400146f, 0.12138626f, -0.09556848f, -0.41032979f, 0.21971449f, 0.18169789f, -0.81888908f, -0.22198234f, 
    -0.66866452f, 0.18896870f, 0.10370075f, 0.09664459f, 0.00682503f, -0.09991695f, 0.24033870f, 0.03768692f, 
    -0.07981384f, 0.05018464f, 0.18338206f, 0.12395066f, 0.00176147f, 0.02625191f, -0.15160656f, -0.04952049f, 
    -0.11932009f, -0.22565919f, 0.18319365f, -0.19611543f, 0.01988131f, 0.08635196f, -0.24107996f, 0.02257806f, 
    0.13517036f, 0.22750495f, -0.03589243f, 0.27730021f, 0.25230840f, -0.10181296f, 0.00478832f, 0.21871252f, 
    0.20085660f, -0.04300677f, 0.05622641f, -0.63460553f, -0.19837539f, -0.23355909f, 0.04785249f, 0.13813157f, 
    -0.17893100f, -0.14902757f, -0.08612528f, -0.01252204f, 0.07081468f, -0.04095823f, -0.19614202f, 0.00708140f, 
    -0.12634303f, -0.03997050f, 0.14319360f, 0.06053666f, 0.14055574f, -0.16685277f, 0.01272813f, -0.08962263f, 
    0.25232106f, 0.24796592f, -0.03285456f, 0.27839768f, -0.14777906f, -0.04638578f, -0.24751373f, -0.14252934f, 
    0.04045898f, 0.73138881f, -0.01620501f, -0.09713540f, 0.15094329f, 0.16569811f, 0.47419080f, -0.43259123f, 
    -0.23497467f, -0.13305479f, 0.14390796f, -0.36002421f, -0.29134580f, -0.06928146f, 0.81587291f, 0.33660501f, 
    -0.15506223f, -0.20480432f, -0.08843684f, 0.35810646f, 0.09986794f, 0.38431463f, 0.17331445f, 0.33361882f, 
    0.22829734f, -0.16124836f, 0.19230914f, 0.02988864f, 0.26741952f, 0.10903022f, -0.51853061f, 0.31433716f, 
    0.17000552f, 0.07607281f, 0.01089930f, 0.10617860f, -0.20491502f, -0.51100177f, 0.05928728f, 0.72462672f, 
    0.02467833f, -0.20365553f, -0.02232251f, 0.60823774f, 0.46786657f, -0.13288054f, 0.12266523f, -0.08122053f, 
    0.08439953f, 0.50717461f, -0.05262481f, -0.41553435f, -0.18471415f, -0.09953017f, 0.07250273f, -0.20981325f, 
    -0.22540486f, 0.29971310f, 0.09280484f, 0.48127046f, -0.24188431f, 0.13430914f, 0.45573613f, 0.14410037f, 
    0.22543955f, -0.46320492f, 0.03144121f, -0.25654808f, -0.20614818f, -0.22399652f, -0.35835153f, -0.44289935f, 
    0.06419697f, -0.22197099f, 0.14695719f, 0.08086830f, -0.13520442f, 0.09033247f, -0.13537633f, -0.09492308f, 
    -0.07791942f, 0.13474524f, 0.18476170f, -0.00500669f, 0.04167813f, 0.00252204f, 0.09166922f, -0.14368640f, 
    -0.02019945f, 0.06498843f, 0.20503931f, -0.26265004f, 0.37038520f, -0.10303781f, -0.17858192f, 0.37774241f, 
    0.08328889f, -0.33439943f, 0.08197359f, 0.11096069f, 0.19996646f, 0.56691372f, -0.40800813f, -0.30832094f, 
    -0.20258617f, 0.13043803f, 0.23587435f, -0.21352461f, -0.15679476f, 0.06274208f, -0.10219690f, -0.18443948f, 
    0.11271456f, 0.06311724f, -0.03513855f, -0.10803184f, -0.24581403f, -0.19006911f, -0.12663022f, -0.13780981f, 
    -0.14814395f, 0.22905864f, 0.10878131f, -0.74463886f, -0.34865862f, -0.00847968f, -0.38994882f, 0.28015685f, 
    -0.20419696f, -0.54822731f, -0.04759669f, 0.12387364f, -0.00720739f, 0.27024856f, -0.10791264f, 0.27152860f, 
    0.16243215f, -1.01073384f, -0.16846894f, -0.40237507f, 0.04047871f, 0.21610850f, 0.11460621f, 0.21770032f, 
    0.43464434f, 0.18237002f, -0.02498655f, 0.23063542f, -0.17566383f, 0.62794048f, -0.12458516f, -0.36172998f, 
    -0.00558257f, 0.05453146f, -0.06410086f, -0.24001828f, -0.17495036f, 0.07127088f, -0.14099991f, 0.00760657f, 
    0.17403871f, -0.03544009f, -0.04735494f, -0.11169344f, -0.14852676f, -0.03926036f, -0.16318727f, 0.00144762f, 
    -0.07476830f, 0.16358353f, -0.20433855f, 0.30071217f, 0.38895741f, 0.12795487f, -0.31919363f, 0.05854030f, 
    -0.43217874f, 0.58540082f, 0.02242423f, -0.15822162f, 0.21328923f, 0.10005302f, 0.22325908f, -0.11772805f, 
    -0.18619026f, -0.41600803f, 0.10635436f, 0.23636048f, 0.53956324f, 0.01437318f, -0.22238518f, 0.40497333f, 
    0.15663050f, -0.28915367f, 0.16314554f, -0.41450861f, -0.24300706f, -0.19901523f, 0.09911049f, -0.04010781f, 
    -0.22063856f, 0.23359324f, -0.19032842f, 0.36108965f, 0.02658623f, -0.04588694f, 0.47033027f, 0.02755354f, 
    0.38134226f, 0.56805050f, 0.20252766f, 0.06116154f, 0.23883644f, -0.35854730f, -0.14470933f, -0.40566668f, 
    -0.09711084f, 0.44207358f, -0.19075564f, -0.28524953f, -0.02401372f, 0.24495810f, -0.19668509f, -0.07533760f, 
    0.19716765f, 0.55413371f, 0.06501839f, 0.37898159f, -0.02727169f, -0.30827847f, 0.08135548f, -0.31690741f, 
    -0.20853509f, -0.40056476f, 0.16122097f, -0.22049466f, -0.14505358f, -0.16617535f, -0.20322445f, 0.05432987f, 
    0.52317452f, 0.39811826f, 0.07025816f, 0.33826560f, 0.23134872f, 0.13335918f, 0.21416147f, 0.13173446f, 
    -0.18844937f, -0.25144452f, -0.05060928f, 0.41037345f, -0.11308885f, -0.21256867f, 0.11207429f, -0.19357133f, 
    0.08419202f, -0.41761175f, 0.05678740f, 0.42002985f, 0.02425382f, 0.09095854f, -0.21059594f, -0.29232603f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.15504912f, 0.35180685f, 0.04075880f, -0.16658512f, -0.16018401f, -0.35026163f, -0.21335126f, 0.23602812f, 
    0.22650072f, -0.10634599f, -0.06357932f, -0.00481189f, -0.13767192f, 0.21865416f, -0.13743167f, -0.06804238f, 
    0.29590636f, -0.06839671f, -0.09995158f, -0.30183917f, -0.04052752f, 0.32132122f, 0.14810783f, 0.33120590f, 
    0.31607628f, -0.17770821f, -0.39909545f, 0.42338216f, 0.27001828f, -0.18735875f, 0.09741899f, -0.32566687f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.63303655f, -0.09956728f, -0.04698558f, 0.10674267f, 0.23218648f, 0.25848764f, -0.15873107f, -0.04831842f, 
    0.32759029f, -0.56041181f, 0.54047006f, -0.20618285f, 0.07227822f, -0.33036095f, -0.17625675f, -0.34743530f, 
    0.04818298f, 0.01312828f, -0.06780235f, 0.07591870f, -0.01073074f, -0.18795942f, 0.07532333f, -0.59518605f, 
    0.24634199f, -0.09115586f, -0.40902025f, -0.26345879f, 0.25585514f, 0.26400861f, 0.24655512f, 0.21989962f, 
    -0.16720368f, 0.49468395f, 0.24751817f, 0.05874175f, -0.35021859f, -0.02720359f, 0.03131546f, 0.12810300f, 
    -0.09556726f, -0.21371470f, -0.11532527f, 0.12877133f, 0.07954749f, -0.08425690f, -0.14834137f, 0.08854239f, 
    -0.30050084f, -0.15688320f, 0.21389076f, -0.13815640f, 0.06999200f, 0.49373206f, -0.05468947f, 0.13136202f, 
    0.38887092f, -0.10361136f, 0.09449972f, 0.37609652f, -0.10015302f, 0.03257187f, 0.25162378f, -0.05588559f, 
    0.14280467f, 0.28952259f, -0.45181757f, 0.06648992f, -0.32551736f, -0.26373789f, -0.11725017f, 0.01905855f, 
    0.27418566f, -0.12547871f, 0.07788903f, -0.09974448f, -0.10133577f, 0.34008253f, -0.14286478f, 0.12862761f, 
    -0.54222625f, 0.01860720f, 0.34112412f, 0.15744644f, -0.15294255f, -0.53114367f, -0.02128311f, -0.14997220f, 
    0.05217819f, 0.00522062f, 0.06649596f, 0.28334200f, 0.14283131f, -0.24884567f, 0.04527514f, -0.12080471f, 
    0.04547158f, 0.44286111f, -0.25804323f, 0.14544766f, -0.08239175f, 0.48028770f, -0.09027138f, 0.22631840f, 
    0.03442672f, -0.56745440f, 0.00107808f, -0.41046789f, -0.14042872f, -0.14817330f, 0.14118126f, -0.49256048f, 
    0.24304424f, 0.08241951f, -0.47249624f, 0.36568558f, -0.14424479f, 0.03907369f, 0.11111401f, -0.27647910f, 
    0.43644160f, -0.02678167f, -0.12812062f, -0.15714234f, -0.19387381f, 0.07009733f, 0.25790206f, 0.22145970f, 
    0.30099243f, -0.10545562f, -0.39844286f, -0.09296063f, -0.12018398f, 0.26214731f, 0.08128576f, 0.04792495f, 
    0.04682766f, 0.05888458f, 0.39074287f, -0.15768538f, -0.05420380f, 0.38976294f, 0.08888499f, -0.20388563f, 
    -0.07266483f, 0.25367302f, 0.32160029f, 0.12482098f, -0.16655871f, -0.21807021f, -0.04753869f, 0.61388618f, 
    -0.23858564f, -0.00406055f, -0.18895482f, 0.24020432f, 0.28586340f, 0.10128644f, 0.07403417f, 0.01227835f, 
    0.21043767f, 0.65567720f, 0.06943616f, -0.07782974f, -0.40029636f, -0.24578843f, 0.02573286f, 0.33674189f, 
    0.19033368f, -0.10997898f, -0.36121133f, -0.09949857f, 0.04840427f, 0.22675702f, 0.19389622f, 0.11259329f, 
    -0.15122800f, 0.05133453f, 0.11713278f, 0.08127135f, -0.09640991f, 0.49952665f, 0.17512578f, 0.58214772f, 
    0.28410602f, -0.06894107f, -0.25738823f, 0.72514445f, -0.10569130f, -0.21944965f, 0.20127620f, -0.28102735f, 
    -0.16732948f, 0.47035173f, -0.48992819f, 0.07931436f, -0.41838351f, -0.34908387f, -0.11433569f, 0.39904004f, 
    0.09468263f, -0.94311851f, 0.07440971f, 0.33262643f, -0.07918352f, -0.36191818f, -0.13465782f, -0.40450755f, 
    0.20430587f, 0.51747376f, -0.19514735f, 0.15803842f, -0.01275511f, 0.03024344f, 0.08625757f, -0.05311884f, 
    0.77014065f, 0.15569293f, -0.25733554f, 0.30311671f, -0.02327623f, -0.49616653f, 0.56442750f, 0.22305200f, 
    0.00795043f, 0.26605305f, -0.04878919f, -0.04853553f, 0.04930105f, 0.02436677f, -0.06444736f, 0.26219705f, 
    -0.43927309f, -0.03125608f, 0.61135411f, -0.00676394f, 0.15130748f, 0.16594215f, -0.04232969f, -0.14567319f, 
    0.61751521f, 0.26851144f, -0.74146932f, -0.68891126f, 0.12013326f, 0.20795041f, -0.06459468f, -0.15129085f, 
    -0.21264330f, 0.08303485f, -0.31866619f, -0.31033194f, -0.18400982f, -0.08671122f, 0.18069416f, -0.78321898f, 
    -0.27197912f, 0.42133778f, 0.80054063f, -0.04107571f, -0.09892423f, -0.24303396f, 0.12744044f, 0.11666711f, 
    0.11663050f, -0.25175828f, -0.40793478f, 0.36642277f, 0.07897457f, 0.09154623f, -0.07962469f, -0.07534058f, 
    0.06910606f, -0.26853019f, 0.18999635f, -0.14624839f, 0.06945708f, 0.66497010f, -0.16621280f, 0.14905554f, 
    0.28819981f, -0.13625552f, 0.06738359f, 0.20365027f, 0.11820806f, 0.14717358f, -0.04761793f, -0.19386296f, 
    -0.54605144f, -0.21492945f, 0.14542210f, -0.16191645f, 0.26419756f, 0.02142564f, 0.10346664f, -0.14974406f, 
    0.15182111f, -0.24434565f, 0.46326938f, -0.62835968f, 0.17255859f, -0.00938075f, 0.13438947f, 0.04078941f, 
    0.37582389f, -0.05369753f, -0.04260608f, -0.07578091f, -0.06941437f, -0.26532003f, -0.17584276f, -0.45087054f, 
    0.15489756f, 0.11951390f, 0.29331928f, -0.58711559f, 0.44944566f, 0.12371944f, 0.21926874f, 0.23646553f, 
    -0.06276729f, -0.19986190f, -0.13053775f, -0.03370292f, -0.12764207f, -0.06655015f, -0.03058138f, 0.09142563f, 
    -0.10259818f, 0.04632193f, -0.23215675f, -0.22583061f, -0.06749097f, -0.08977936f, -0.17104554f, 0.06177382f, 
    0.03610070f, -0.15375318f, 0.04276469f, -0.01772642f, -0.01140237f, 0.12282231f, 0.16592689f, -0.10182931f, 
    -0.17440052f, 0.15779603f, 0.02673141f, 0.07067216f, -0.14835882f, 0.08418199f, -0.10980155f, 0.00607821f, 
    -0.44645727f, 0.19776094f, 0.13882247f, 0.08867419f, -0.03254336f, -0.72326475f, 0.16256085f, 0.01655077f, 
    0.36293525f, -0.58917439f, 0.26546139f, -0.10204500f, -0.03909009f, -0.22395390f, 0.07301147f, 0.13283913f, 
    0.21648450f, -0.50069958f, -0.02595514f, -0.07325445f, 0.16454758f, 0.27195916f, -0.09044027f, 0.45947239f, 
    0.46850923f, 0.11129337f, 0.10811479f, -0.24240784f, 0.18908849f, 0.26645759f, 0.21138562f, 0.29110488f, 
    0.13529037f, 0.06069528f, 0.24490917f, -0.02434790f, -0.34431598f, 0.10319350f, 0.08703258f, -0.04961026f, 
    -0.03409795f, -0.04727343f, -0.07638258f, -0.26569822f, -0.01589899f, 0.15268166f, -0.13160609f, 0.05401377f, 
    0.01844609f, 0.19662318f, 0.02138280f, 0.03626772f, -0.15760374f, 0.12631920f, -0.10114622f, 0.08880125f, 
    -0.32596755f, 0.11819662f, -0.37831050f, 0.41791803f, 0.33508676f, 0.04164600f, -0.01529976f, -0.08742402f, 
    0.13724250f, -0.00779152f, 0.01635191f, 0.15441208f, -0.22425273f, 0.13344297f, -0.12428225f, -0.03846770f, 
    0.11318955f, -0.39009219f, 0.20139346f, -0.37985849f, -0.00850506f, -0.00931696f, 0.11850558f, 0.05413590f, 
    -0.17962585f, 0.32633016f, 0.02242193f, 0.10647463f, -0.02187731f, -0.17583483f, 0.05299684f, 0.12902714f, 
    -0.27737567f, -0.09000061f, -0.03529305f, 0.03485934f, 0.35393149f, 0.50423229f, 0.18823208f, -0.07073252f, 
    -0.04395222f, -0.12540904f, 0.24191347f, 0.01571565f, -0.36174244f, 0.35618868f, 0.11030588f, 0.11809088f, 
    0.27050710f, 0.00383484f, -0.33612651f, 0.02491738f, -0.00191018f, 0.46460199f, -0.04232255f, -0.56590825f, 
    0.06667308f, 0.22302680f, 0.48607191f, 0.24456492f, -0.17398120f, 0.01397677f, -0.14733265f, 0.05680629f, 
    -0.02509321f, 0.09368332f, -0.59752506f, 0.76005214f, 0.35249910f, -0.24411710f, -0.00702284f, -0.21469425f, 
    0.00234857f, -0.03779609f, -0.12050171f, -0.00133842f, 0.14570782f, 0.12178519f, 0.10836861f, 0.05772446f, 
    -0.03019470f, 0.05721188f, 0.02906036f, 0.02303552f, 0.15155335f, 0.29421994f, -0.07656699f, -0.30617687f, 
    0.20350559f, 0.18939434f, 0.31358138f, -0.23247413f, 0.08271184f, -0.23396561f, 0.02237715f, 0.42097589f, 
    -0.02028771f, -0.01591033f, -0.89474434f, 0.37817258f, 0.16429602f, -0.10205816f, -0.04675160f, -0.22749938f, 
    -0.01691041f, 0.14131385f, -0.09246862f, -0.14772518f, 0.12281007f, -0.28391263f, -0.12512746f, -0.10754120f, 
    0.01241177f, 0.03276710f, -0.11035641f, 0.11720347f, -0.01506507f, 0.10820063f, 0.14321451f, -0.03364181f, 
    0.13544449f, -0.15169197f, 0.03222278f, -0.03508982f, -0.10865045f, -0.07111780f, -0.09417325f, 0.14390025f, 
    -0.04493261f, 0.01585524f, 0.00592638f, -0.26316732f, -0.13036531f, 0.00980823f, 0.02046660f, -0.01979773f, 
    -0.68458533f, -0.02229929f, 0.49877185f, -0.11821888f, -0.63938570f, -0.46404523f, -0.00748624f, -0.25958890f, 
    0.41492769f, -0.39250425f, -0.40292910f, 0.11830905f, 0.08822591f, 0.00516373f, -0.11413464f, -0.73670769f, 
    -0.13718802f, 0.04672145f, 0.03966806f, 0.40425965f, 0.15028295f, 0.48362175f, 0.03214502f, -0.37450260f, 
    0.41796574f, -0.13491033f, -0.59015554f, 0.48611772f, 0.06682328f, -0.50116748f, 0.02088720f, 0.31341186f, 
    -0.01152111f, 0.07970913f, 0.23552042f, 0.14487845f, -0.10716534f, -0.22846523f, -0.03103137f, -0.27585000f, 
    0.28090367f, -0.16093200f, 0.04489683f, -0.18778908f, -0.11282707f, 0.23345250f, 0.05187378f, 0.08155100f, 
    -0.28623676f, -0.04323707f, 0.26696411f, 0.47958311f, -0.06458481f, 0.12175656f, -0.00259391f, 0.04746679f, 
    -0.17880350f, -0.06571237f, -0.14333318f, 0.34175006f, 0.54019630f, 0.22203888f, 0.30232233f, 0.08007687f, 
    0.37504688f, -0.48663011f, -0.13673528f, 0.07817768f, 0.22265425f, -0.48275483f, 0.01288775f, -0.17721806f, 
    0.19432394f, 0.22247872f, -0.00828664f, 0.04670086f, -0.15435682f, -0.04430337f, -0.08151048f, -0.00586030f, 
    0.02998878f, -0.30945227f, 0.13583942f, 0.41572204f, -0.04095576f, -0.54593241f, -0.14291817f, -0.11657177f, 
    -0.12926623f, 0.14990151f, -1.00069726f, -0.15739053f, 0.00567148f, -0.93719172f, -0.09648475f, 0.60314697f, 
    0.01163202f, 0.17920199f, -0.08823530f, -0.05909165f, 0.19635417f, 0.46475360f, -0.15219304f, 0.39844969f, 
    0.00899726f, -0.08821894f, 0.27925450f, -0.24912994f, 0.13046631f, -0.16878787f, -0.13415390f, -0.07021679f, 
    0.31979996f, 0.23258631f, -0.14572041f, -0.26303285f, 0.10882216f, -0.14405249f, 0.14296006f, 0.02040833f, 
    0.37003863f, -0.02488986f, 0.18507583f, 0.01280149f, -0.07995620f, -0.11636864f, 0.22043426f, -0.33907261f, 
    0.03081555f, -0.00476740f, -0.05114006f, 0.00184801f, 0.00302281f, -0.38565627f, -0.15529963f, 0.33882686f, 
    -0.38422778f, 0.11699963f, -0.00595347f, 0.15982135f, 0.11411434f, -0.14322899f, -0.04455062f, -0.10913480f, 
    0.33822036f, 0.15181324f, -0.35455865f, -0.31322587f, -0.09243421f, 0.53597909f, -0.06409037f, 0.55015463f, 
    0.24076417f, 0.03751674f, -0.11962119f, 0.17722201f, -0.12634990f, -0.10834121f, 0.08274822f, 0.21815851f, 
    -0.11827223f, 0.23545916f, -0.35463592f, 0.03242075f, -0.39929342f, -0.38867927f, -0.06707372f, -0.09795076f, 
    0.28788713f, -0.13733153f, 0.25093827f, 0.15615731f, -0.03584874f, 0.08146942f, -0.11044101f, 0.46257940f, 
    -0.16282175f, 0.32615125f, 0.29063779f, -0.04940002f, 0.01749128f, -0.32002860f, 0.06433229f, -0.52089173f, 
    0.22334671f, -0.04209265f, -0.22139156f, 0.27549675f, 0.17198265f, 0.15443194f, 0.18005359f, -0.12010761f, 
    -0.30903214f, -0.32115400f, 0.20768763f, -0.14873117f, 0.12096453f, 0.13244498f, 0.09658013f, -0.56224114f, 
    0.41435382f, 0.30489197f, 0.13503864f, 0.16237763f, 0.11220431f, 0.13522014f, 0.05784263f, -0.44141537f, 
    -0.12064633f, -0.33633211f, 0.43018627f, 0.70685983f, 0.15611464f, -0.34510213f, -0.09294798f, -0.05793478f, 
    -0.22743401f, 0.10206641f, -0.02267153f, 0.32127443f, 0.16879466f, -0.39625242f, -0.25335792f, 0.37481228f, 
    -0.63764286f, 0.25313517f, 0.03033169f, 0.12702586f, 0.08134285f, -0.26050866f, 0.15681961f, 0.22390041f, 
    0.12300183f, -0.95272076f, 0.37970349f, -0.14518972f, -0.12585662f, -0.80555797f, -0.08899970f, -0.07457519f, 
    0.20362975f, -0.26385492f, -0.25795239f, -0.14792620f, -0.13976952f, -0.07219010f, 0.02322982f, 0.50994468f, 
    0.46996275f, 0.03050620f, 0.09842237f, -0.52355927f, 0.13313162f, 0.27951914f, 0.29228163f, 0.55324513f, 
    0.15411954f, -0.33919671f, 0.18710604f, -0.01771179f, 0.05597455f, 0.01880141f, -0.14749365f, -0.15853634f, 
    0.12979701f, 0.24552909f, 0.08391929f, 0.12059945f, 0.15096959f, 0.17939952f, 0.12590140f, -0.10138103f, 
    0.40089515f, -0.39582512f, -0.01392579f, 0.36823452f, 0.02424299f, 0.06010823f, -0.02569478f, 0.07946358f, 
    -0.10930135f, 0.13374175f, -0.43835148f, -0.06912734f, 0.33319804f, -0.02343961f, -0.01334133f, 0.21821482f, 
    -0.53366679f, 0.07295121f, 0.60402197f, 0.01530584f, -0.41888127f, 0.26875371f, 0.06939363f, -0.21422583f, 
    0.13140394f, -0.06915066f, -0.38016728f, 0.67830569f, 0.05135459f, -0.00903570f, 0.08748926f, -0.83493173f, 
    -0.07806326f, 0.25510207f, 0.19703071f, 0.04115901f, 0.09767739f, 0.60570884f, -0.12142682f, 0.48469517f, 
    -0.04122710f, -0.02817586f, 0.21055439f, 0.37670729f, 0.13071127f, -0.20054770f, 0.01593378f, -0.16009732f, 
    0.17706670f, -0.25617266f, 0.11697744f, 0.14662081f, 0.32383099f, 0.18625273f, 0.04982186f, -0.12695256f, 
    0.16494799f, 0.18988514f, 0.31876671f, 0.02959416f, -0.00330341f, -0.08286544f, 0.03804900f, -0.09679444f, 
    -0.00744442f, -0.05696062f, 0.01381250f, 0.33823666f, -0.07620574f, -0.41070151f, 0.01889612f, -0.08123609f, 
    -0.35401973f, -0.09368374f, -0.28047493f, -0.29250661f, 0.23850854f, 0.14031813f, -0.00424931f, 0.05299745f, 
    -0.09739269f, 0.02335725f, -0.70814794f, 0.05063324f, 0.27365044f, -0.49860847f, 0.09634662f, 0.17103960f, 
    -0.03068195f, 0.03139704f, 0.34491894f, -0.05393967f, -0.13426249f, -0.07197553f, -0.02149270f, 0.17067231f, 
    0.45611051f, -0.15760879f, 0.22025394f, -0.13482988f, -0.15627934f, -0.44309527f, -0.07537194f, 0.02033519f, 
    0.29026467f, -0.03077080f, -0.10959311f, 0.16138195f, -0.01295625f, -0.11217402f, 0.12851775f, -0.43005025f, 
    0.03967671f, 0.09851882f, 0.04428536f, 0.03950216f, -0.05292587f, 0.68000180f, -0.02960740f, -0.09386826f, 
    -0.16942427f, -0.47766566f, 0.22017846f, -1.13086998f, 0.14522107f, 0.06540641f, 0.08083967f, -0.33631396f, 
    -0.18509686f, 0.77947587f, 0.16327956f, 0.03112163f, -0.11734485f, -0.40944231f, -0.12915324f, 0.53111511f, 
    -0.17596595f, -0.14749913f, -0.03590097f, -0.02363942f, 0.02704400f, 0.15412991f, 0.25214389f, -0.13218415f, 
    0.03666420f, -0.07096741f, 0.08036753f, 0.12643839f, 0.06860086f, -0.10776860f, 0.04221424f, -0.05954958f, 
    -0.15389040f, -0.01635437f, 0.02555610f, -0.17578427f, -0.14957368f, -0.15865490f, 0.09768815f, -0.03599250f, 
    -0.09562827f, -0.05921837f, -0.06297176f, -0.08091061f, 0.11826958f, -0.05123116f, -0.08190700f, -0.03052104f, 
    -0.14774619f, 0.15114591f, -0.14833471f, -0.09400307f, -0.09697054f, -0.03199949f, -0.00378991f, 0.02596979f, 
    -0.30514285f, -0.07752515f, 0.49556908f, -0.01096667f, 0.34877127f, 0.17957236f, -0.13069952f, 0.02795968f, 
    -0.14147653f, 0.08184985f, -0.20443170f, 0.27983502f, -0.10799495f, 0.00521376f, 0.10014222f, -0.62475967f, 
    0.50111109f, 0.09538506f, -0.03175320f, 0.03743283f, 0.14463288f, 0.39466089f, -0.11900274f, 0.38104945f, 
    -0.13245466f, 0.13819730f, -0.38257939f, 0.05819998f, 0.08339003f, -0.14826381f, -0.09613638f, -0.12740760f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.00310201f, 0.09353127f, 0.13239896f, -0.15764830f, 0.41136861f, 0.32910812f, 0.25563776f, 0.75782955f, 
    0.31432563f, 0.06144532f, -0.05437479f, 0.27834150f, 0.46917391f, 0.08555207f, 0.32642481f, 0.20115967f, 
    -0.16669151f, 0.20761810f, 0.29022276f, -0.46920210f, -0.15979439f, 0.48157367f, 0.19301617f, 0.12959141f, 
    0.16068475f, 0.14962164f, -0.10884488f, 0.02921964f, 0.22947931f, -0.02294653f, -0.07345045f, -0.17017651f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.19328405f, -0.60814518f, -0.25183940f, -0.83933282f, 0.03414199f, -0.98059034f, -1.17709410f, -0.78082377f, 
    -0.17189206f, 0.26391861f, -0.20099971f, 0.10577811f, -0.03332705f, 0.04365885f, 0.03392733f, -0.13583912f, 
    -0.15327673f, -0.07453213f, 0.14002839f, 0.80471820f, -0.57425195f, -1.23377073f, 0.11735155f, 0.19797048f, 
    0.04008079f, 0.23766465f, -0.20540331f, 0.24719045f, -0.33640450f, 0.12438440f, -0.17165680f, -0.04264229f, 
    -0.38786134f, -0.17285450f, 0.30839807f, -0.30475995f, 0.06070573f, 0.20750113f, -0.25826815f, 0.45845848f, 
    0.01527863f, -0.34482804f, -0.10499828f, -0.66955382f, 0.18982249f, -0.20637420f, 0.25740141f, 0.12892671f, 
    -0.13508339f, 0.30967405f, 0.07092900f, -1.08765137f, -0.26826593f, 0.43081400f, -0.00416446f, 0.41978008f, 
    -1.31170273f, 0.22702391f, 0.05178046f, 0.07294958f, -0.07081394f, -0.34306982f, 0.07339958f, -0.09033917f, 
    -0.18738376f, 0.18234055f, -0.28285635f, -0.05598582f, -0.54201299f, 0.27877146f, 0.42746681f, -0.44207400f, 
    0.24168597f, -0.20283796f, -0.22021794f, 0.19891249f, -0.09264678f, -0.47153163f, -0.21910267f, -0.53534096f, 
    0.02795034f, 0.74323231f, -0.06214837f, -0.05988624f, -0.18064670f, -0.05971848f, 0.12851484f, -1.32649767f, 
    0.25046319f, 0.18204966f, 0.38662353f, -0.10352321f, -0.13725157f, -0.40892327f, 0.01076256f, -0.35950062f, 
    0.03515847f, -0.09549377f, -0.14539585f, 0.47786310f, -0.04561296f, -0.20620370f, 0.09014171f, -0.49866277f, 
    0.07536667f, 0.16454744f, -0.04163437f, 0.16996197f, 0.22006400f, 0.31466103f, -0.02229095f, -0.45369554f, 
    -0.55371922f, 0.01939786f, 0.23514506f, 0.12163933f, -0.17857639f, -1.01100743f, -0.08558849f, 0.00753464f, 
    0.19090392f, 0.06178977f, -0.09743021f, -0.07233734f, -0.69588488f, 0.13019395f, 0.00536588f, -0.09079307f, 
    0.17549683f, -0.43477768f, 0.21210809f, -0.28792441f, 0.08681592f, -0.52706003f, -0.10081252f, -1.07230592f, 
    -0.17201775f, 0.33910695f, -0.14816658f, 0.22003463f, -0.05546944f, -0.07937471f, -0.08859068f, -0.05352492f, 
    -0.07610254f, -0.06148158f, -0.00199043f, -0.52273941f, 0.04857894f, -0.19291522f, 0.21557404f, 0.04092766f, 
    0.29451218f, 0.12553373f, -0.47708949f, 0.05647865f, 0.27329272f, -0.06122754f, -0.06539275f, -0.12737583f, 
    0.02096594f, 0.06695634f, -0.05771009f, -0.57541573f, -0.13830625f, 0.07634741f, -0.28847927f, -0.01209711f, 
    0.17339517f, -0.09049415f, -0.01192118f, -0.13253726f, 0.07053572f, 0.11241715f, 0.16247900f, 0.09966502f, 
    -0.07887659f, 0.15679441f, 0.08771771f, 0.43225408f, 0.04297937f, -0.46041480f, 0.19958985f, -0.07644412f, 
    -0.80288672f, 0.16132934f, 0.30686045f, -0.10043641f, 0.30594829f, -0.20295513f, 0.14959367f, 0.36744249f, 
    0.04201246f, 0.36295238f, -0.41853008f, 0.22668485f, -1.06735134f, 0.34498757f, 0.46834806f, 0.32086530f, 
    0.14309628f, -0.25292033f, -0.18218876f, 0.17160146f, -0.56610692f, -0.90983617f, -1.28172219f, -0.68843317f, 
    -0.30100569f, -0.48998058f, -1.21521592f, -0.07386390f, 0.00810831f, 0.17547597f, -0.95491236f, -0.18662594f, 
    0.31801879f, 0.02631186f, -0.26696575f, -0.07741046f, 0.15414490f, -0.51070011f, -0.14690123f, 0.16472097f, 
    0.61718410f, -0.24841133f, -0.75157821f, 0.21486364f, 0.03381252f, -0.80001265f, 0.16641672f, 0.05848875f, 
    -1.35101879f, 0.43643221f, -0.06770621f, -0.73376209f, -0.32323962f, 0.26204175f, -0.14818771f, -0.14323339f, 
    -0.06103156f, -0.41559213f, -0.73227578f, -0.00884281f, 0.22654733f, -0.52061760f, -1.54299319f, -0.68529600f, 
    0.42660329f, -0.17569192f, -1.37543416f, 0.21657485f, -0.35435504f, 0.50778741f, 0.02311936f, -0.36904007f, 
    -0.78791797f, 0.13414000f, -0.43032929f, -0.60985881f, -0.10086343f, 0.11453778f, -0.44687599f, -0.13149953f, 
    0.32784995f, -0.35679552f, -0.10382193f, -0.41743070f, 0.23435098f, 0.00238703f, 0.30215153f, 0.16404897f, 
    0.22573195f, -0.17822811f, -0.05109848f, -0.11172759f, -0.06747536f, 0.23634605f, -0.34492162f, -1.12194121f, 
    -0.27462974f, -0.46540722f, 0.63551915f, -0.60577792f, -0.22383505f, 0.28979558f, 0.03607159f, 0.41218174f, 
    0.11587074f, 0.15421955f, -0.13324699f, -0.22592324f, 0.05233410f, 0.09864553f, -0.00196966f, 0.04861822f, 
    0.04797544f, 0.35782471f, -0.30413043f, 0.50054282f, -0.37632743f, 0.08920688f, -0.34228334f, -0.25908381f, 
    -0.41304153f, -0.60276169f, -0.06905323f, -0.11840209f, 0.12703539f, -0.28707182f, -0.16825713f, -0.64713746f, 
    0.53432155f, -0.57001132f, -0.91948497f, -0.39413977f, 0.36213621f, -0.52792501f, 0.02224407f, -0.51325572f, 
    -0.46412241f, 0.28762713f, 0.61474109f, -0.68634927f, 0.24688134f, 0.29648852f, 0.28530464f, -0.71370870f, 
    -0.02289935f, -0.85964614f, -0.16273825f, -0.86128139f, 0.11453253f, 0.27741495f, 0.03708788f, -0.00681224f, 
    -0.14739747f, -0.30537376f, 0.03967085f, -0.38511020f, -0.10188818f, -0.33141369f, 0.48843163f, -0.42925796f, 
    -0.64619696f, -0.70969713f, -0.36639628f, -0.77888036f, 0.03009217f, 0.36136562f, 0.09766144f, -0.99649161f, 
    -0.11920688f, -0.18711329f, -0.25260860f, 0.35010564f, -0.21840037f, 0.07801112f, 0.53573757f, 0.21769686f, 
    -0.33001664f, -0.46855333f, -0.24437767f, -0.53753483f, -0.18711351f, -0.13066950f, 0.05163791f, 0.23864941f, 
    -0.30926821f, -0.27118456f, -0.60589874f, -0.05733426f, 0.23537695f, 0.13132919f, -0.30358616f, -0.20256433f, 
    -0.29481748f, -0.53862101f, -0.00049541f, -0.24833830f, 0.22061116f, 0.38383362f, -0.16389576f, -0.02545932f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.20585355f, 0.64620107f, 0.11471304f, -0.12690569f, -0.08053672f, -0.46498579f, -0.14692873f, -0.12672451f, 
    0.04029818f, 0.11720919f, -0.19408414f, -0.32014924f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
