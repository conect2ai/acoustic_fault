#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.16660511f, -0.83379632f, -0.29437506f, 0.59388018f, 0.55124569f, 0.29107463f, 0.13229159f, 0.08290461f, 
    0.19389272f, 0.32482567f, 0.28436315f, 0.24616143f, 0.03370316f, 0.13070603f, 0.04517518f, 0.00722972f, 
    -0.03056516f, -0.18131438f, -0.24323525f, -0.34040117f, -0.36093354f, -0.23395370f, 0.04261962f, -0.13491909f, 
    -0.34921980f, 0.64553916f, 0.28026652f, -0.27246350f, 0.01628741f, -0.55430633f, 0.14148343f, -0.27428073f, 
    0.17143591f, 0.20655693f, -0.09353440f, 0.15067028f, 0.13350996f, 0.06804502f, -0.03916971f, -0.10181582f, 
    0.19517903f, 0.31178471f, -0.26435131f, -0.17692536f, 0.10812684f, 0.11787891f, 0.11826410f, -0.21249786f, 
    -0.38245615f, 0.47588247f, 0.85520220f, 0.63086563f, -0.09659649f, 0.04332263f, -0.15960459f, -0.19380583f, 
    0.12787743f, 0.17440796f, -0.12722236f, 0.06954241f, -0.12057026f, 0.12419124f, -0.12295620f, -0.33575329f, 
    0.20576863f, 0.07385689f, -0.15257561f, -0.14229421f, 0.08092941f, -0.25746113f, -0.24204756f, 0.08386618f, 
    -0.21465394f, -0.29508471f, -0.34723887f, -0.89021134f, 0.92884749f, -0.34496140f, -0.98684818f, -0.21019390f, 
    -0.16806076f, 0.30665883f, 0.36086309f, 0.59218687f, 0.13990383f, -0.21112643f, -0.06612834f, 0.15214418f, 
    -0.28705630f, -0.17289895f, 0.48571283f, 0.32801020f, -0.05474959f, 0.11079658f, 0.01939515f, 0.05924198f, 
    0.29615983f, -0.13727972f, -0.07875137f, -0.31467530f, -0.74386108f, -0.07879436f, -0.50646466f, 0.48197490f, 
    0.75131124f, -0.51921171f, -0.33106300f, 0.54306275f, 0.55311590f, -0.23444995f, -0.40164000f, -0.44048890f, 
    -0.30571309f, 0.39401990f, 0.15107156f, 0.35151541f, 0.07202794f, -0.12982517f, -0.03131095f, 0.15887088f, 
    -0.29208210f, -0.12893291f, 0.21077491f, -0.23257238f, -0.14130780f, 0.76663244f, 0.61064821f, 0.39021266f, 
    -0.16904336f, -0.10376034f, 0.08175436f, 0.06520794f, 0.21897157f, 0.51723152f, 0.02785347f, -0.10538814f, 
    -0.27203187f, -0.30040303f, 0.10850410f, -0.20611329f, -0.20398949f, -0.03180342f, -0.16992581f, -0.35047373f, 
    -0.05638845f, -0.08071416f, -0.29839507f, 0.02635110f, 0.01131297f, 0.09266977f, 0.06409039f, 0.40723473f, 
    0.27684844f, 0.96323991f, 0.70279193f, -0.58093208f, -0.63780594f, -0.73942560f, -0.54989725f, -0.28746161f, 
    -0.18806177f, -0.19197267f, 0.31862545f, 0.00728343f, -0.12278304f, 0.18966170f, 0.34291142f, 0.25698897f, 
    0.00442917f, 0.00123285f, -0.30711028f, 0.14640880f, -0.00513820f, 0.03374158f, -0.24344011f, -0.60176301f, 
    0.13713147f, -0.20557912f, 0.21742849f, -0.39510390f, -0.72224367f, -0.61605424f, -0.03025432f, -0.11421841f, 
    0.46771818f, 0.63752413f, 0.29972476f, 0.10584527f, 0.05685863f, 0.50789428f, 0.10309039f, -0.20665182f, 
    -0.27692577f, -0.74912125f, -0.49502274f, 0.00117341f, 0.33188912f, 0.00732993f, 0.05552802f, 0.06359145f, 
    -1.17186534f, -0.79397160f, -0.37454814f, -0.17267258f, -0.02910416f, 0.73535311f, -0.46582597f, -0.67850935f, 
    -0.68315047f, -0.69827205f, -0.31633502f, -0.20588636f, -0.44680512f, 0.00647529f, -0.48005316f, 0.15580313f, 
    -0.25986367f, -0.49014124f, 0.11823026f, -0.40919065f, -0.18156214f, 0.48029450f, 0.03067238f, -0.11281388f, 
    0.28941193f, -0.94799107f, -0.47080672f, -0.80776745f, -0.43586591f, 0.90095085f, 0.28319678f, 0.21631190f, 
    0.87928563f, 0.15525441f, -0.14336754f, -0.32696202f, -0.29984131f, 0.00765726f, -0.27737311f, -0.01569272f, 
    -0.21119969f, -0.39119789f, -0.22119491f, 0.09207367f, -0.24930045f, 0.35290033f, 0.10487067f, 0.13232207f, 
    -0.13234340f, 0.07972080f, -0.52694875f, 0.67014593f, 0.49741465f, -0.81375432f, -0.45577455f, -0.17559054f, 
    0.36699229f, 0.44574043f, 0.09282145f, -0.35501829f, -0.36243102f, -0.02352844f, 0.14102601f, -0.32386586f, 
    -0.16714361f, 0.48954949f, -0.38154399f, -0.67568827f, -0.57124013f, -0.69053090f, -0.38534364f, 0.02639226f, 
    0.05445559f, -0.24897869f, -0.10065990f, 0.20171940f, 0.38817719f, 0.15055667f, 0.13010873f, -0.73469293f, 
    -0.65076047f, -0.47256061f, 0.24787952f, 0.49707437f, -0.03224472f, -0.03418261f, 0.07123902f, 0.29463780f, 
    -0.10053933f, -0.17442602f, -0.16125154f, 0.26314259f, 0.23618731f, -0.17862995f, -0.16830327f, -0.51245797f, 
    -0.35622102f, -0.63350141f, -0.64020330f, -0.55806237f, 1.37674546f, -1.08549547f, -0.09348573f, -0.36628649f, 
    -0.08820806f, 0.22767223f, -0.19190487f, -0.13190128f, 0.27165067f, 0.26051152f, -0.26488879f, 0.41508150f, 
    0.10871959f, -0.41643578f, 0.13909702f, -0.00569727f, 0.13035296f, -0.08170275f, 0.22337922f, -0.41071230f, 
    -0.00855323f, -0.24245305f, 0.07886900f, 0.05716093f, 0.10540377f, -0.77613699f, -0.87090898f, -0.86275816f, 
    -0.68907303f, -0.97637212f, 0.97140932f, -0.11563767f, -0.46703547f, -0.04583604f, 0.80393398f, -0.38370180f, 
    -0.43228802f, -0.03324012f, 0.41360226f, 0.22263439f, 0.02490742f, -0.13194752f, -0.12802184f, 0.03824757f, 
    -0.28420672f, -0.37310383f, 0.06404531f, 0.14621167f, -0.16369283f, -0.17955278f, -0.14629981f, -0.15932097f, 
    0.30301744f, -0.33506230f, -0.60471153f, -0.96167570f, -0.89768064f, -1.05300319f, -0.73824739f, -0.74724227f, 
    0.92235661f, -0.01518540f, 0.08635123f, 0.53785044f, -0.11514640f, -0.28496069f, 0.12873413f, 0.05999679f, 
    -0.28978813f, -0.64330769f, -0.01937386f, -0.14671411f, -0.21824650f, -0.11976939f, 0.04129644f, 0.61063123f, 
    -0.00996347f, 0.50927848f, -1.21027982f, -1.02889812f, -0.44563842f, 0.14451285f, 0.17285419f, 0.49253413f, 
    0.37920460f, -0.28988039f, 0.07897774f, 0.29210472f, -0.10177905f, 0.29842412f, -0.22174379f, 0.33209267f, 
    -0.14001681f, -0.29750925f, -0.01281319f, -0.01619642f, -0.06900512f, -0.01131727f, -0.21812724f, -0.10406395f, 
    0.79339969f, -0.88093680f, -0.38500327f, 0.28500178f, 0.49581024f, 0.65787739f, 1.04074836f, -0.39868769f, 
    -0.86559927f, -0.26199764f, -0.21773005f, -0.13882779f, -0.06800134f, -0.35047576f, 0.04463736f, 0.23414305f, 
    0.08331499f, 0.31749398f, 0.25717545f, -0.02615542f, -0.05655710f, -0.22066702f, -0.20415965f, -0.21458334f, 
    -0.04226076f, -0.50874370f, -0.63011110f, -0.45124307f, -0.13009730f, -0.79808044f, -0.54969990f, -0.06481716f, 
    -0.39169562f, -0.65616375f, -0.47788754f, -0.01694759f, -0.09833980f, -0.37228203f, -0.32260659f, -0.31617796f, 
    0.05996680f, 0.22289817f, 0.02941492f, 0.12480175f, 0.25674468f, -0.08155874f, -0.08929182f, -0.03137124f, 
    0.22953449f, -0.16245927f, 0.28853869f, 0.26044640f, -0.61938852f, -0.25082138f, -0.07129036f, 0.87706727f, 
    -0.39851373f, -0.03655429f, 0.03030776f, -0.24987665f, 0.05797295f, 0.59026062f, -0.23191543f, 0.21487144f, 
    -0.15122105f, -0.24513569f, -0.30971339f, -0.04960324f, -0.03602173f, -0.01456507f, -0.31981248f, 0.22272345f, 
    0.32997558f, 0.17129731f, -0.05366310f, 0.67512226f, -0.50941557f, -0.97967732f, -0.88277966f, -0.66160095f, 
    0.85447097f, 0.37748635f, 0.50804865f, 0.22898650f, -0.07013446f, 0.01686633f, 0.22483200f, 0.09929832f, 
    -0.19114012f, -0.03395697f, -0.21972668f, 0.01443170f, 0.08242348f, -0.05375377f, 0.18691078f, 0.19261441f, 
    -0.01670474f, -0.36436000f, 0.24472560f, 0.03643258f, -0.86758900f, -0.27821204f, 0.05954232f, -0.03166155f, 
    -0.06520648f, 0.39051935f, 0.49840805f, -0.25020236f, -0.25689939f, 0.19991365f, -0.13796133f, -0.71171016f, 
    -0.36692780f, 0.02604567f, -0.28703353f, 0.07164099f, 0.06393583f, -0.36036900f, -0.36316943f, -0.45992592f, 
    -0.18823962f, -0.44677359f, -0.19439158f, -0.20295157f, -0.69954288f, 0.00689050f, 0.31561187f, 0.15974374f, 
    0.11929590f, 0.22061333f, -0.37269944f, -0.53161401f, 0.32865769f, -0.05023451f, 0.50694698f, -0.18824379f, 
    0.11002479f, 0.07802787f, 0.05091492f, 0.06632122f, -0.18572846f, 0.01868734f, -0.14935108f, -0.20549414f, 
    0.20270969f, -0.28755471f, -0.13918982f, 0.30043703f, 0.01075179f, 0.11787330f, -0.68184888f, 0.20334454f, 
    0.37224829f, -0.44829509f, -0.63172364f, -0.00655902f, -0.10559705f, 0.17871606f, 0.44221213f, 0.22204830f, 
    0.11016892f, 0.08840885f, 0.52380073f, -0.37377545f, -0.27348435f, -0.06479446f, -0.44023332f, 0.01500215f, 
    -0.36271849f, 0.07742944f, 0.05902541f, 0.35502297f, 0.07102259f, -0.08765737f, 0.85139900f, -0.07859543f, 
    -1.17086697f, 0.03359146f, 0.00681183f, -0.54044390f, -0.72198474f, -0.23752120f, 0.18750352f, 0.04925448f, 
    -0.31927320f, -0.67667180f, -0.61441249f, 0.27246788f, 0.23607303f, 0.05227933f, -0.32052320f, -0.32137117f, 
    -0.13651502f, 0.34792709f, -0.28612354f, 0.09944662f, -0.21779171f, -0.19920702f, -0.28888124f, 0.05330681f, 
    -0.64428002f, -0.42174593f, 0.47043487f, 0.58140314f, 0.28829816f, -0.86454958f, -0.77297133f, 0.62353623f, 
    0.11995634f, 0.33128372f, -0.25035146f, 0.15442516f, -0.20660231f, 0.37249759f, 0.02469939f, -0.13311401f, 
    -0.16535243f, -0.12635799f, 0.12168574f, 0.20502104f, 0.04998975f, -0.00018154f, -0.12693855f, 0.04453018f, 
    0.14107075f, -0.03780310f, 0.26418436f, 0.36569026f, 0.15866061f, 0.21997035f, 0.26921380f, 0.24291873f, 
    0.23808955f, 0.32197580f, 0.17551777f, 0.13149144f, -0.04168279f, 0.01994082f, 0.30321091f, -0.18517193f, 
    0.20038058f, 0.12810545f, 0.01616045f, 0.08465377f, 0.08147021f, -0.04340789f, 0.17802340f, -0.20691361f, 
    -0.13193777f, -0.05213513f, -0.92430001f, -0.79996932f, -0.65562612f, -0.01476476f, 0.36642590f, -0.07881781f, 
    -0.78272820f, -0.80801952f, -0.45792449f, 0.18786456f, 0.13413997f, 0.14754395f, 0.07510442f, -0.17685612f, 
    -0.19572856f, 0.20080973f, 0.00090757f, 0.25102305f, 0.39449376f, 0.57322639f, 0.14782806f, -0.09857451f, 
    -0.23862477f, -0.19553432f, 0.09680288f, 0.23006856f, 0.11257070f, -0.34679273f, -0.00051127f, 0.02240979f, 
    0.19127271f, -0.60947752f, 0.23403016f, 0.60485321f, 0.26064697f, -0.08064145f, -0.03771095f, -0.06590256f, 
    0.30233032f, -0.26149690f, -0.42229003f, 0.26982334f, 0.27819824f, -0.20693082f, -0.13347457f, -0.02360043f, 
    0.25513294f, 0.25450107f, 0.20478083f, -0.21154909f, 0.03092384f, -0.43905312f, -0.76500428f, -0.91423798f, 
    -0.53504384f, -0.35327026f, -0.39069545f, -0.09964709f, -0.15786627f, 0.26427463f, 0.43094784f, 0.71603853f, 
    0.30044955f, 0.05501330f, -0.22538215f, -0.21720797f, 0.08229561f, -0.14172395f, -0.56023151f, -0.19792792f, 
    -0.53501189f, -0.11243905f, -0.10185915f, -0.10865542f, -0.34507191f, -0.05391210f, 0.17594589f, 0.65456986f, 
    -0.39454511f, -0.47399807f, -0.69240373f, -0.40310264f, -0.49922407f, -0.20779923f, -0.01362340f, -0.00274693f, 
    -0.43727463f, -0.46108004f, 0.83833706f, -0.56349397f, 0.10572086f, -0.05020482f, -0.00661597f, -0.12326716f, 
    -0.06795230f, 0.28505504f, 0.48877272f, 0.28077120f, -0.06186287f, -0.08791251f, -1.78221679f, 0.63154107f, 
    0.53330082f, -0.38049364f, 0.34777790f, 0.22358017f, 0.18895754f, -0.42142990f, 0.45326033f, -0.00007461f, 
    0.16449179f, -0.01638794f, 0.15989406f, -0.19461042f, -0.54025942f, 0.01274359f, 0.12061656f, -0.12583865f, 
    -0.17307250f, -0.14993583f, -0.25302747f, 0.07071430f, -0.28541547f, -0.06926254f, -0.50032705f, -0.76902103f, 
    -0.41686326f, -0.29785243f, -0.22446457f, -0.28809205f, 0.24816281f, -0.23147559f, 0.16601889f, 0.66503513f, 
    -0.16549242f, 0.50195646f, 0.16025715f, 0.09299669f, 0.24940826f, 0.32700244f, 0.15504274f, -0.16672222f, 
    0.20694360f, -0.06254330f, -0.04469537f, 0.17822930f, -0.00730855f, 0.25476503f, -0.14250320f, -0.17716390f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.04244234f, 0.53676420f, 0.38255230f, 0.23874797f, 0.34731913f, 0.25784138f, 0.20034942f, 0.52473772f, 
    0.32106519f, 0.15770616f, 0.22532865f, 0.06225923f, 0.34661254f, -0.19453104f, -0.03653637f, 0.37502110f, 
    0.18903680f, -0.42394483f, 0.36396098f, 0.41150486f, 0.16248980f, 0.43038002f, 0.16937949f, 0.24333404f, 
    0.34979069f, -0.06821375f, 0.09716104f, 0.44528109f, 0.06009897f, 0.24844094f, 0.29688320f, 0.17324772f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.11348672f, 0.09483851f, 0.04252865f, 0.05767376f, 0.02590857f, 0.10992253f, 0.04391371f, 0.03879604f, 
    0.02197698f, 0.02980499f, 0.01771653f, 0.03758126f, -0.04568162f, -0.17742352f, -0.09626956f, -0.00188723f, 
    -0.12120586f, -0.02000610f, -0.06716480f, -0.07064095f, -0.39967942f, -0.16381095f, -0.20823967f, -0.27943072f, 
    -0.77912098f, -0.48262471f, -0.26599863f, 0.08068296f, 0.00097369f, -0.00396476f, -0.00398595f, -0.03736306f, 
    -0.10206363f, -0.03638436f, -0.01969593f, -0.05559759f, -0.38105437f, -0.18871413f, 0.04582981f, 0.05919810f, 
    -0.09298261f, 0.20987120f, 0.00068448f, -0.05607570f, 0.01017765f, 0.07097970f, -0.01637019f, -0.03299751f, 
    0.04910532f, -0.10814987f, 0.30353892f, -0.19961102f, -0.06675988f, -0.01433392f, 0.07318733f, -0.04076567f, 
    -0.09053826f, -0.01536354f, -0.08945899f, -0.12887619f, -0.05474872f, -0.65836143f, -0.27982485f, -0.01934297f, 
    0.09193203f, 0.03515369f, -0.00195124f, 0.09035193f, -0.01231705f, 0.00797183f, 0.00451040f, -0.01789062f, 
    -0.08648571f, 0.15697540f, 0.13930662f, -0.09908691f, 0.02144990f, -0.24463841f, -0.14189933f, -0.00075994f, 
    -0.04679457f, 0.02812627f, 0.02726552f, 0.03235620f, 0.11561447f, 0.07960677f, 0.19176215f, -0.30841163f, 
    -0.13759024f, -0.00965937f, -0.02964250f, -0.21381369f, -0.05814191f, -0.07081186f, -0.18232755f, -0.10580473f, 
    0.45613676f, 0.22357108f, -0.20306402f, -0.24662535f, -0.04551193f, 0.07582895f, 0.13898933f, 0.02138710f, 
    -0.03842689f, -0.11992331f, -0.10145298f, -0.03962180f, 0.31457698f, -0.01231205f, -0.13579804f, -0.03503457f, 
    0.07560325f, 0.12284783f, 0.12378086f, -0.26874518f, -0.10535458f, -0.08447661f, -0.00266184f, 0.01495987f, 
    -0.42014617f, -0.36561710f, 0.06861240f, -0.04892727f, -0.05065597f, -0.04765741f, -0.12268154f, 0.10107119f, 
    -0.08052001f, -0.08519714f, 0.02580887f, 0.06112739f, -0.19947816f, -0.05672161f, 0.14691554f, -0.01913586f, 
    0.02106059f, -0.12994456f, -0.11964687f, 0.01909179f, -0.13627376f, -0.03007379f, 0.05670710f, 0.19894746f, 
    -0.45421600f, -0.04247405f, -0.24414897f, 0.17780839f, -0.09238034f, 0.00050266f, -0.01427390f, -0.27181607f, 
    -0.01324196f, -0.20404871f, -0.07537231f, 0.11162603f, 0.38158807f, 0.09029871f, -0.07072043f, -0.26490781f, 
    0.10509448f, 0.17374623f, -0.00507268f, -0.23231843f, -0.02811390f, 0.00618747f, 0.07175203f, 0.04780766f, 
    0.31259084f, 0.25830498f, -0.15226264f, -0.38402399f, 0.08817410f, 0.12896334f, -0.02378813f, 0.13249594f, 
    0.02608025f, 0.05372997f, -0.01290641f, -0.03849281f, -0.05001124f, -0.64050114f, 0.17777076f, 0.06877628f, 
    -0.07589453f, 0.04799148f, -0.20124236f, -0.02245501f, -0.09479264f, -0.33967918f, -0.08648537f, 0.00081287f, 
    0.30754235f, -0.22357248f, -0.33500049f, 0.03474420f, 0.02579240f, -0.25065166f, 0.14191933f, -0.22300355f, 
    -0.10158741f, 0.05414998f, -0.02644923f, 0.07231158f, 0.44622856f, 0.20797862f, 0.01980942f, -0.14749904f, 
    0.28818604f, 0.21118034f, 0.13260362f, 0.14546032f, -0.01249116f, 0.03890877f, 0.08069970f, -0.01078179f, 
    0.08893494f, -0.36284500f, -0.92272264f, 0.07959302f, -0.00700033f, -0.03946279f, -0.06452312f, 0.06247169f, 
    -0.30933326f, -0.11220081f, -0.28278500f, -0.18544583f, 0.21455255f, -0.25860769f, -0.33673182f, -0.00001620f, 
    0.10410478f, 0.18478847f, -0.21865615f, 0.04600298f, -0.08485782f, -0.01219746f, 0.00407089f, -0.03627288f, 
    0.30771413f, 0.04741201f, -0.07141080f, -0.03339437f, -0.02181078f, -0.01768481f, -0.17084405f, 0.00876296f, 
    0.00333111f, 0.03578102f, -0.01067181f, 0.10156057f, -0.52952343f, -0.09847883f, -0.05460310f, -0.13581672f, 
    0.01434593f, 0.04541020f, -0.01045689f, -0.00637719f, 0.00860103f, -0.00793402f, -0.05025982f, -0.07197283f, 
    0.06055769f, -0.12010183f, 0.23837724f, -0.19014753f, -0.07898484f, 0.00488655f, -0.03095859f, -0.16710597f, 
    0.07728422f, -0.26102588f, 0.11331671f, -0.11056267f, 0.26128075f, 0.12093759f, 0.17329592f, -0.13835455f, 
    0.09022789f, -0.01373243f, 0.07335213f, -0.09053428f, -0.14715673f, -0.14813857f, -0.08173404f, -0.05737850f, 
    -0.22072831f, 0.22765237f, 0.58081597f, -0.53376770f, -0.22736761f, 0.01105316f, 0.03482576f, -0.09328796f, 
    -0.02776404f, -0.09136952f, -0.05623348f, -0.05636245f, 0.00826538f, -0.01159501f, 0.03328096f, 0.06400300f, 
    0.03221154f, 0.05176442f, 0.08284377f, 0.06751412f, -0.22815835f, -0.14363444f, -0.18678497f, -0.10316164f, 
    0.63131899f, 0.42410439f, -0.07092057f, -0.17553939f, 0.16122979f, 0.09304454f, 0.14101046f, -0.18144874f, 
    0.06675012f, 0.00588208f, 0.05551080f, 0.02542660f, -0.13290513f, -0.16679193f, -0.10722792f, 0.03896132f, 
    -0.05838354f, 0.05323379f, -0.03620301f, -0.00709037f, -0.10315241f, -0.06192904f, -0.10342625f, -0.23530467f, 
    0.31033504f, 0.12551929f, -0.17235051f, -0.09275673f, 0.12793444f, 0.04357376f, -0.08027705f, -0.17382061f, 
    -0.13614327f, 0.12575480f, -0.07292581f, 0.17038664f, 0.03420301f, 0.06302880f, -0.02027521f, -0.38213381f, 
    -0.01169084f, 0.03535692f, -0.05001020f, -0.12860985f, -0.02724628f, -0.13160153f, -0.00392438f, -0.04574821f, 
    -0.18683791f, 0.33917788f, -0.07512431f, -0.22447447f, -0.14382848f, 0.09166601f, 0.10860337f, 0.12971814f, 
    0.12981081f, 0.25959554f, -0.02807860f, -0.07566184f, 0.20590818f, 0.01254520f, 0.04545970f, 0.01277711f, 
    0.09536022f, 0.12785564f, 0.01929249f, -0.02696120f, 0.02333456f, 0.05960039f, -0.05732675f, 0.08566733f, 
    0.00689499f, -0.08975269f, -0.09664597f, -0.01086573f, -0.05874842f, 0.01641369f, 0.05145639f, 0.03793285f, 
    -0.19191250f, -0.01951296f, -0.00411647f, -0.07652757f, 0.13958275f, 0.00449278f, 0.07600383f, -0.05817895f, 
    -0.03025737f, 0.01994516f, 0.04786236f, -0.09137003f, 0.06593752f, 0.16411111f, -0.05288623f, -0.02252475f, 
    0.23594631f, 0.01169872f, 0.16059124f, -0.03959301f, 0.05667114f, -0.02326848f, -0.03251471f, -0.06539060f, 
    -0.03335639f, 0.03923826f, -0.02515311f, -0.05747055f, -0.39004251f, -0.14600533f, 0.15335338f, -0.02803073f, 
    0.06011984f, -0.00260323f, -0.11633839f, -0.21426484f, -0.10411405f, -0.06341382f, -0.18859060f, 0.01285585f, 
    -0.84123224f, 0.10534810f, 0.02146954f, 0.20236249f, 0.14296585f, 0.02306644f, 0.08396567f, 0.05243392f, 
    0.07544606f, 0.01771093f, 0.04993673f, -0.07433771f, 0.58104372f, 0.63083476f, 0.40380535f, 0.23578528f, 
    -0.07236526f, -0.06406592f, 0.06508829f, -0.07270876f, 0.03584266f, 0.01971867f, -0.01033321f, -0.00188278f, 
    -0.15533410f, 0.23900367f, -0.26028058f, -0.22659430f, -0.01211096f, -0.07868403f, 0.25921103f, -0.06842360f, 
    -0.06886234f, 0.05723530f, -0.01431050f, 0.01735498f, -0.87667167f, -0.30061325f, -0.20933126f, -0.30854908f, 
    0.07569381f, 0.13294296f, -0.07703808f, 0.15641798f, 0.04244909f, -0.09047449f, 0.08578635f, 0.09991121f, 
    0.13079661f, 0.14354819f, 0.26020062f, 0.39128184f, 0.13388661f, -0.04997192f, 0.18496169f, 0.13191645f, 
    0.07062358f, 0.03817577f, 0.00793351f, -0.07294440f, -0.37272552f, 0.06736613f, -0.07511295f, 0.04813990f, 
    -0.02970409f, 0.02486715f, 0.07508291f, 0.02228194f, 0.01665038f, 0.02823544f, -0.14907348f, -0.20455328f, 
    -0.16722733f, -0.41938940f, 0.12126480f, -0.03587170f, 0.01210660f, 0.02249002f, 0.07950051f, 0.05116392f, 
    -0.00987964f, -0.14180653f, -0.32111388f, -0.34548861f, -0.18749492f, -0.09195568f, 0.13871455f, -0.21359529f, 
    0.06068684f, 0.03581114f, 0.03391521f, 0.02876390f, -0.12645458f, -0.26597911f, -0.20184048f, 0.19293654f, 
    0.63304764f, 0.08736682f, -0.11957874f, -0.19036701f, 0.04154999f, 0.05813772f, 0.03563646f, -0.10736469f, 
    0.02017437f, 0.33651406f, 0.10598274f, -0.07667945f, 0.38367140f, 0.22163662f, 0.25769731f, 0.21784580f, 
    0.13924496f, 0.23395619f, -0.12749699f, -0.21158850f, -0.07939506f, -0.01391185f, 0.16874619f, -0.38453430f, 
    -0.19258517f, -0.12226400f, -0.06715429f, -0.48062161f, -0.21425210f, -0.31664234f, -0.02375433f, 0.21250366f, 
    -0.01657675f, -0.01590047f, -0.01254960f, 0.13159363f, 0.15780175f, -0.47748464f, 0.09749218f, -0.29092166f, 
    0.07437718f, 0.16819213f, -0.20402472f, 0.06470754f, 0.07426159f, 0.38627276f, 0.01691161f, -0.07284895f, 
    0.54189616f, -0.19718336f, -0.15949298f, 0.06318932f, 0.07013839f, -0.01442695f, -0.06281072f, -0.06332153f, 
    0.22293559f, -0.20252912f, 0.05899465f, 0.11200321f, 0.23710088f, 0.14142485f, 0.23389913f, -0.12359405f, 
    -0.03798861f, -0.07489325f, -0.16990696f, -0.24019849f, -0.04280178f, 0.00261022f, -0.14620046f, -0.03675691f, 
    0.14234355f, 0.04561742f, -0.24161738f, -0.01150601f, -0.03148964f, -0.14065804f, 0.11005662f, 0.14971246f, 
    -0.04163775f, 0.31924120f, -0.16341630f, 0.05668638f, 0.66125172f, -0.22865376f, -0.25119773f, -0.15176494f, 
    0.09929761f, 0.06920474f, 0.10657570f, -0.17604601f, 0.01624487f, 0.00648138f, -0.03794824f, -0.03239111f, 
    0.50327641f, -0.14937335f, 0.13363062f, -0.00013321f, 0.11956022f, 0.00156445f, -0.07100580f, 0.04956999f, 
    -0.16818827f, 0.00492437f, -0.25213104f, -0.24156666f, 0.02560548f, 0.11054099f, 0.13525759f, 0.00673208f, 
    0.05280714f, 0.04548632f, -0.01100114f, -0.04984520f, 0.09832724f, -0.01195393f, -0.05143827f, 0.05672863f, 
    -0.12383728f, 0.14498176f, 0.01018802f, -0.12707868f, 0.05725369f, 0.21627632f, -0.12803698f, -0.04564855f, 
    -0.15127823f, 0.13977790f, 0.10281237f, 0.04154050f, -0.36438912f, 0.19339214f, 0.22896174f, -0.04406868f, 
    0.14444853f, 0.18131182f, 0.07068529f, -0.28361061f, 0.07436177f, -0.12910393f, 0.05736290f, -0.17862928f, 
    -0.60838097f, 0.28685260f, -0.15265343f, -0.12037706f, 0.06273559f, 0.06953003f, 0.11292218f, 0.08854096f, 
    0.03531088f, -0.03415066f, -0.02060053f, -0.04204834f, 0.06916318f, 0.02608655f, 0.07074930f, 0.12644954f, 
    -0.06420939f, -0.05104793f, -0.07719339f, -0.00260318f, 0.11202022f, 0.08911196f, 0.05198791f, 0.01209763f, 
    -0.07864745f, 0.20157517f, -0.07953323f, 0.26831043f, -0.11792482f, -0.08916461f, -0.07687087f, -0.19178753f, 
    -0.01404013f, -0.13519031f, -0.01061152f, 0.03723732f, -0.09631645f, 0.09875238f, 0.13752593f, 0.00464992f, 
    0.00626992f, -0.03212707f, 0.03358447f, 0.04122135f, -0.03644511f, 0.04433497f, 0.07522102f, 0.07716849f, 
    0.00300041f, -0.12834845f, -0.15012217f, 0.00167223f, 0.08817728f, 0.07536507f, -0.05558512f, 0.15499331f, 
    0.30984470f, -0.30088887f, -0.01696677f, 0.05787789f, 0.24726696f, -0.27264723f, -0.14365432f, -0.02006183f, 
    0.04879557f, -0.13039280f, -0.14828046f, 0.42502633f, -0.04105727f, -0.09301694f, 0.09100037f, 0.01027897f, 
    -0.04346173f, -0.09351204f, -0.35760441f, 0.22949095f, -0.06414022f, -0.07926553f, -0.02400448f, 0.00449117f, 
    -0.43028823f, -0.21843652f, -0.38096809f, -0.14609562f, -0.39489919f, -0.22748958f, -0.13302888f, -0.12208181f, 
    -0.04348604f, 0.15651649f, 0.01450968f, 0.17458732f, -0.25316483f, 0.02734993f, 0.17792909f, -0.07408313f, 
    0.05522337f, -0.14053804f, 0.06561108f, 0.08777105f, 0.02422746f, -0.02520204f, 0.06782786f, 0.02651052f, 
    -0.16486444f, -0.02896802f, -0.05465476f, 0.01294488f, -0.16672106f, 0.06652674f, 0.01058174f, -0.02219223f, 
    -0.06550752f, 0.03626847f, -0.01607216f, 0.00584734f, 0.04077339f, -0.03758607f, -0.22208971f, 0.21736698f, 
    -0.15619275f, -0.17896752f, 0.09877843f, -0.09452744f, 0.03117061f, -0.05208279f, -0.11893707f, -0.00245633f, 
    0.06190497f, 0.00311448f, -0.12085516f, 0.10478926f, 0.32388166f, 0.23380905f, 0.01855715f, 0.26210979f, 
    0.08169726f, -0.08019611f, 0.23929213f, -0.01813890f, -0.01015702f, -0.04252484f, -0.01912953f, 0.08018891f, 
    0.13230531f, -0.10279295f, -0.26604414f, 0.18968607f, 0.10996755f, 0.03106919f, 0.10813655f, 0.04758081f, 
    0.10146108f, 0.18136472f, 0.07981487f, 0.08788733f, -0.47748476f, -0.31879202f, 0.07922517f, -0.45047891f, 
    -0.02444653f, -0.00252211f, 0.00362584f, -0.00730034f, 0.02572460f, -0.06502131f, -0.06677156f, -0.03121700f, 
    -0.38503972f, 0.13440353f, 0.00116081f, -0.07650086f, -0.31973794f, -0.16386242f, -0.14927706f, -0.01983916f, 
    -0.03546075f, -0.09199990f, 0.04102145f, -0.00220581f, 0.00781188f, -0.26057121f, -0.37223414f, 0.16087343f, 
    0.05809137f, 0.02735494f, -0.08113151f, -0.24161880f, 0.02868118f, -0.00413792f, -0.29885685f, 0.14439541f, 
    -0.37751311f, -0.10304417f, 0.33353922f, 0.14333098f, 0.06243525f, -0.18939264f, -0.04553213f, 0.13990702f, 
    0.05582205f, -0.08362258f, 0.00884409f, 0.05767030f, -0.15873513f, 0.17615288f, 0.27999598f, 0.41006982f, 
    -0.07544209f, -0.03661312f, 0.12417328f, -0.06260769f, 0.13463636f, -0.09029658f, -0.09285693f, -0.22376497f, 
    0.44488835f, 0.05355397f, -0.00461582f, -0.22906718f, 0.01211901f, -0.03023192f, 0.00805518f, -0.09276311f, 
    0.02202836f, 0.08474988f, -0.14699888f, 0.10033104f, -0.04065330f, 0.11258848f, -0.11631168f, 0.03894386f, 
    0.00123354f, 0.03220163f, -0.04821797f, -0.17397632f, 0.18160789f, 0.06835215f, 0.19296204f, 0.09127164f, 
    -0.31443697f, 0.38103265f, -0.06959624f, 0.03836541f, -0.06799089f, 0.17814860f, -0.11692692f, -0.16001250f, 
    0.05889860f, 0.03056626f, 0.06466387f, 0.01685868f, 0.07088677f, 0.16961126f, 0.90128618f, 0.60205364f, 
    0.02653281f, 0.05759346f, 0.13896725f, 0.05231191f, 0.00931303f, -0.06849187f, 0.04351172f, 0.03715532f, 
    -0.86358559f, -0.81743217f, -0.18131441f, -0.56117296f, 0.29141060f, 0.03826960f, -0.28549168f, -0.07048945f, 
    -0.01480071f, -0.03875173f, 0.08890051f, 0.06095104f, -0.14312279f, 0.48590857f, 0.05825331f, 0.09766250f, 
    -0.08201248f, 0.08874485f, 0.03949160f, -0.41109356f, 0.02142081f, 0.18163556f, -0.26712510f, 0.03608394f, 
    -0.08066199f, -0.16993475f, 0.07812079f, -0.22265087f, 0.02760074f, -0.00266984f, -0.20875545f, -0.03153216f, 
    0.07411487f, -0.03149087f, -0.13965888f, -0.14573848f, -1.05819905f, -0.33756208f, -0.17062162f, -0.54252326f, 
    -0.13588640f, -0.08526646f, 0.15809974f, -0.24759480f, -0.05144289f, 0.02555164f, 0.00791571f, -0.00020066f, 
    -0.17837790f, 0.08948899f, -0.21699119f, -0.01056335f, 0.00754256f, -0.09553567f, 0.05298599f, -0.05571404f, 
    0.07095905f, -0.15805645f, -0.33149546f, 0.03217642f, -0.15224306f, 0.50342822f, 0.35401079f, 0.15036671f, 
    -0.12608846f, -0.09562986f, 0.14405076f, 0.05632712f, 0.06139015f, 0.00858208f, -0.07396690f, -0.02948181f, 
    -0.07772896f, -0.25501496f, 0.43508241f, 0.06085705f, -0.03744662f, -0.07216612f, 0.09694963f, 0.00859363f, 
    0.11094896f, 0.03695212f, 0.06934670f, -0.03178608f, -0.27521065f, -0.05355351f, -0.01079858f, 0.12178102f, 
    -0.10554022f, 0.00682359f, -0.00262745f, -0.02698170f, 0.02177174f, 0.04725356f, -0.00548928f, 0.00874516f, 
    0.16115801f, 0.13157071f, -0.30418062f, -0.00066122f, 0.23599389f, 0.14929552f, -0.33621171f, 0.00967789f, 
    -0.16269362f, -0.17309587f, 0.00492754f, 0.01119216f, 0.03021569f, -0.12245177f, 0.14037924f, 0.16413097f, 
    -0.17725144f, 0.13463002f, -0.16886930f, -0.05315749f, -0.04204336f, -0.01051553f, 0.08016393f, -0.22339904f, 
    0.04651043f, 0.22829962f, -0.59271234f, 0.24190708f, -0.04988791f, 0.14997764f, -0.10304436f, 0.08992460f, 
    -0.00103864f, -0.00755269f, -0.00502183f, -0.03748587f, -0.12365802f, -0.09232886f, -0.09361003f, -0.05456106f, 
    0.02390808f, -0.03366483f, -0.00857236f, 0.03459449f, 0.03100770f, -0.00598151f, 0.13403809f, 0.05475304f, 
    -0.13106494f, -0.38056579f, -0.16255327f, 0.21337447f, 0.10675584f, 0.04336790f, -0.17080261f, 0.28305128f, 
    0.07002378f, 0.02749561f, -0.02583849f, -0.05824950f, -0.18748932f, 0.05686655f, 0.00148411f, 0.04375558f, 
    -0.07335149f, 0.04234168f, 0.01680221f, -0.02028630f, 0.07736421f, -0.10192695f, 0.02667960f, 0.00765798f, 
    0.16005543f, 0.07725483f, -0.09376465f, 0.17006496f, -0.11212727f, 0.03168589f, 0.13480291f, -0.22930938f, 
    0.02561199f, -0.05992435f, -0.08274461f, 0.10270499f, -0.21769421f, -0.47682002f, -0.12383331f, -0.34452313f, 
    0.09672986f, -0.08050351f, -0.16289449f, 0.04260745f, 0.06925888f, -0.16267301f, 0.03812731f, 0.05488463f, 
    0.29490942f, -0.04556946f, -0.30450419f, 0.22575440f, 0.00203036f, -0.00758212f, -0.00001884f, 0.00213246f, 
    -0.03405776f, 0.00300444f, 0.12644565f, 0.23792794f, 0.06643151f, 0.17853524f, 0.05585620f, 0.13609365f, 
    -0.01391127f, -0.02906089f, 0.05393436f, 0.06007567f, -0.07173462f, 0.17878050f, 0.05060331f, 0.14265545f, 
    -0.46687409f, 0.15568928f, -0.32826915f, -0.59152961f, 0.36706164f, 0.10295349f, 0.24492005f, -0.10037280f, 
    -0.24804327f, -0.06899464f, -0.12365501f, -0.07189108f, -0.59417695f, -0.42667925f, -0.02195965f, -0.02232911f, 
    -0.06838260f, 0.15276746f, -0.22912739f, -0.19625236f, -0.18892819f, 0.02924705f, -0.11425767f, -0.13487643f, 
    -0.64910126f, -0.26260322f, 0.22124103f, -0.06343642f, -0.11686309f, -0.06074487f, -0.39815843f, 0.06504283f, 
    -0.04113654f, 0.27412769f, -0.09811427f, 0.02903423f, 1.26245189f, -0.09183487f, 0.05422320f, 0.31334454f, 
    0.05999120f, -0.01041956f, 0.00958474f, -0.13918473f, -0.30789912f, -0.16055813f, -0.00925936f, 0.23728380f, 
    0.62853950f, 0.33687046f, -0.64558190f, -0.53790945f, -0.22470057f, -0.11962323f, -0.16513085f, 0.06989622f, 
    -0.15345381f, -0.12586093f, 0.14509557f, -0.02203195f, -0.61406779f, -0.32434270f, 0.05292274f, -0.06038512f, 
    -0.01530800f, 0.01894504f, -0.02394317f, -0.04495063f, -0.11821156f, 0.13100483f, 0.14389819f, -0.03226027f, 
    0.12884103f, 0.29481453f, 0.14847252f, 0.35239494f, -0.26443779f, -0.08003289f, 0.00449248f, 0.15687145f, 
    0.06005378f, 0.19598413f, -0.08289068f, 0.17307867f, 0.19292390f, -0.01238354f, -0.00519217f, -0.12165423f, 
    0.17700467f, -0.14876662f, -0.00803636f, 0.09538922f, 0.05612805f, 0.04362761f, 0.01118589f, -0.13317192f, 
    -0.12833607f, 0.00974634f, -0.13523576f, 0.12937990f, 0.09042416f, 0.00118604f, -0.10630362f, -0.03131267f, 
    -0.11779007f, -0.06926876f, 0.08524826f, -0.01219143f, 0.46592268f, 0.38764450f, -0.27827799f, -0.10116968f, 
    0.26983029f, 0.08457020f, 0.02415882f, 0.00508255f, -0.06183676f, 0.02011630f, 0.14256863f, 0.03827197f, 
    0.55914456f, -0.03558455f, 0.23872851f, 0.26483697f, -0.14809930f, -0.04462991f, -0.25587657f, -0.08303159f, 
    -0.16087836f, -0.15833150f, 0.13588977f, 0.12403055f, 0.03527005f, -0.34619159f, 0.02665257f, 0.07694069f, 
    -0.18138580f, -0.02628054f, 0.00560244f, 0.13285147f, 0.08466208f, 0.12887856f, -0.15379135f, -0.01664491f, 
    -1.23129356f, 0.03866139f, -0.13582899f, 0.06699074f, -0.25743413f, -0.01989148f, 0.25806299f, -0.33073080f, 
    -0.06570698f, -0.00351437f, 0.02402233f, 0.07671259f, -0.15161778f, -0.35138956f, 0.03978464f, 0.24723396f, 
    -0.00996529f, 0.14002359f, -0.02497558f, -0.02497140f, -0.01800132f, 0.03136019f, 0.08149155f, 0.15377432f, 
    0.05345748f, -0.12387525f, 0.08462653f, 0.23538211f, 0.06590402f, 0.20020378f, -0.00760895f, 0.20965289f, 
    0.01542928f, 0.04076828f, -0.04689717f, -0.05739632f, 0.31300679f, 0.00098197f, 0.24562927f, 0.34346169f, 
    -0.21078292f, -0.09363065f, -0.11079398f, 0.04187433f, 0.04111062f, -0.12017871f, -0.28184351f, 0.12916431f, 
    -0.18742168f, 1.06642795f, -0.64806229f, 0.54920954f, 0.07372890f, -0.12596238f, 0.06617501f, -0.14684759f, 
    -0.18387319f, 0.02303573f, -0.01733158f, 0.01982518f, -0.15441127f, -0.10378244f, -0.03950439f, 0.27486834f, 
    -0.00647979f, -0.07990978f, 0.02259290f, -0.10434309f, 0.03096743f, 0.11771259f, -0.11169644f, 0.06343850f, 
    -0.42664948f, -0.29536423f, -0.07669851f, 0.02350996f, -0.02155478f, 0.02712031f, -0.25870171f, -0.11378459f, 
    0.01129354f, -0.06549083f, 0.19537221f, -0.18735689f, -0.34897810f, 0.07757043f, 0.02881070f, 0.47521055f, 
    0.13957994f, 0.10502619f, 0.06349332f, -0.05403404f, -0.08651537f, 0.06137730f, 0.02078638f, 0.13431807f, 
    -0.00276203f, 0.23710343f, -0.00472562f, 0.08797892f, 0.06943011f, 0.08958156f, -0.00364963f, -0.10056189f, 
    -0.11395581f, -0.04794597f, 0.04772233f, -0.01808450f, 0.03263633f, -0.08896243f, -0.15429245f, -0.67463505f, 
    -0.13110206f, -0.07827529f, -0.14649433f, -0.09448060f, 0.08350943f, -0.01994244f, -0.11554556f, 0.07243516f, 
    0.36460266f, -0.09215534f, 0.07007919f, 0.27162084f, 0.05156453f, -0.05808236f, -0.20887455f, -0.00947562f, 
    0.01631736f, 0.35699612f, 0.00582570f, -0.14008187f, -0.17726271f, -0.08216859f, -0.07411225f, 0.13361983f, 
    -0.08808829f, -0.01093767f, -0.19796120f, 0.05728503f, -0.09350823f, 0.08781260f, 0.18552645f, -0.08495511f, 
    0.01132635f, 0.37095317f, -0.45306876f, -0.86800635f, -0.01110468f, -0.17023288f, -0.14717272f, -0.15581642f, 
    0.06388117f, -0.02204383f, -0.13872702f, -0.00490473f, -0.33214936f, -0.26070559f, 0.02736692f, -0.21178839f, 
    -0.05913504f, 0.21253540f, 0.05928740f, -0.11467290f, 0.00947102f, -0.09965558f, 0.11775669f, -0.22498554f, 
    -0.17276163f, -0.02630888f, -0.36084041f, 0.08085556f, 0.08405104f, 0.04420419f, -0.10387141f, -0.14188793f, 
    -0.07762330f, -0.02122169f, -0.05241112f, 0.08544517f, 0.01713348f, -0.45352352f, 0.11994272f, -0.46504337f, 
    -0.11571434f, -0.03699829f, -0.11804275f, -0.14459243f, -0.18782887f, 0.04026418f, -0.24223197f, -0.01203189f, 
    -0.13701566f, -0.20207588f, -0.07054231f, 0.22359310f, 0.12348242f, -0.08232493f, 0.20462014f, -0.00504893f, 
    0.04766619f, 0.13388532f, 0.01849562f, 0.15131529f, 0.09900898f, -0.02678107f, 0.12713523f, 0.23881038f, 
    -0.12687422f, 0.10977035f, -0.04482865f, -0.04125077f, -0.01583536f, 0.02755235f, -0.00184959f, 0.00322459f, 
    0.61785746f, 0.07468253f, -0.01691157f, -0.40199047f, 0.21090965f, 0.06644668f, -0.13211718f, -0.17880742f, 
    -0.12143116f, -0.02759887f, 0.06439659f, 0.07447259f, 0.14930035f, -0.16232361f, -0.09098829f, 0.10151652f, 
    0.03880096f, 0.20736592f, 0.04965190f, 0.08590131f, -0.12072412f, 0.05867600f, -0.00830300f, -0.08851222f, 
    0.05337068f, -0.09104585f, -0.02579077f, -0.02286637f, 0.01244204f, -0.03443691f, 0.04177805f, -0.01122113f, 
    0.00734414f, 0.09036276f, 0.06894553f, 0.10501156f, -0.03117731f, -0.03709181f, -0.05052898f, -0.05738499f, 
    0.04226212f, 0.01744767f, -0.05480894f, 0.02775604f, 0.06070863f, 0.00945831f, -0.07966177f, -0.24553819f, 
    0.02127952f, 0.11186918f, -0.24040747f, -0.01709165f, 0.04784580f, 0.03328946f, 0.11312550f, -0.14456156f, 
    0.19190879f, 0.05326607f, 0.19662297f, 0.16711025f, -0.09145827f, -0.25413185f, -0.02133607f, -0.08072063f, 
    -0.12398978f, -0.32820037f, -0.12041335f, 0.22375056f, 0.14243969f, 0.02476889f, 0.06852547f, -0.11531523f, 
    -0.49422744f, -0.24736351f, 0.02540278f, -0.10380573f, -0.07150697f, 0.05017535f, -0.28639299f, 0.00812890f, 
    -0.19501127f, -0.08764157f, -0.13840990f, 0.10606932f, -0.27460712f, -0.65997070f, -0.79096895f, -0.19772421f, 
    0.07355411f, 0.02615093f, -0.04297485f, 0.06268895f, 0.01240286f, 0.00029601f, -0.04947342f, -0.02080311f, 
    0.30629846f, -0.03858607f, 0.31811365f, 0.37496254f, 0.02299904f, 0.23057590f, 0.01809054f, 0.12185039f, 
    0.10610011f, -0.08790018f, 0.02586935f, 0.02098704f, 0.10614702f, 0.19369136f, 0.28872043f, 0.27896881f, 
    0.00884235f, 0.04256731f, -0.06300323f, -0.04631289f, -0.15001585f, -0.09548718f, -0.09429905f, -0.01236738f, 
    0.00591419f, -0.24151999f, 0.09535055f, 0.05762530f, -0.03226336f, -0.06127660f, -0.12916017f, -0.08405277f, 
    0.04143004f, -0.01946240f, -0.03755872f, 0.02071965f, -0.33123556f, -0.41340545f, 0.17094882f, 0.03712261f, 
    -0.13017067f, 0.01475268f, -0.39324728f, 0.16430832f, -0.02733727f, -0.12906289f, -0.40079054f, -0.12906113f, 
    -0.02183657f, -0.10002831f, -0.13001984f, 0.14100687f, 0.01247577f, -0.13077557f, 0.01827104f, -0.10912810f, 
    0.07633321f, -0.21774919f, 0.07761315f, -0.07237142f, 0.10104599f, 0.00601724f, 0.01419121f, 0.02366212f, 
    0.04730456f, 0.06202426f, -0.00128994f, -0.19795229f, 0.09186669f, -0.01677449f, 0.21042566f, 0.27102667f, 
    0.36307636f, -0.23969238f, -0.18670072f, -0.35317135f, 0.06799409f, -0.03159266f, -0.07563252f, 0.02312332f, 
    0.01870311f, -0.11275298f, -0.29652575f, -0.14054930f, 0.00745630f, 0.35541430f, 0.06428484f, 0.19302419f, 
    -0.24262814f, -0.13600163f, 0.05924254f, -0.02407808f, -0.04191493f, -0.03934374f, 0.02137220f, 0.12985145f, 
    0.11813476f, 0.31811202f, 0.28548035f, 0.35777336f, 0.11597795f, 0.01820329f, -0.00173625f, 0.11108615f, 
    0.05068903f, 0.07616920f, -0.01469327f, -0.09211604f, -0.71059275f, -0.00512927f, -0.14528649f, -0.09017412f, 
    0.04581319f, -0.11091483f, -0.18471017f, -0.04579428f, -0.22495027f, -0.07713130f, 0.03214468f, -0.02672121f, 
    0.01969503f, -0.17704064f, 0.27943221f, -0.13801388f, 0.05462236f, 0.29365978f, -0.14243150f, 0.09206918f, 
    -0.15076344f, 0.04656075f, 0.01633969f, 0.00904149f, -0.03454797f, 0.10258417f, 0.03745935f, 0.12651448f, 
    -0.00443210f, -0.02782621f, 0.13696782f, 0.23184909f, -0.00335631f, 0.06526632f, 0.04995992f, 0.01867040f, 
    0.02175266f, 0.19954893f, -0.17209917f, 0.04770059f, -0.01615019f, 0.03780410f, -0.02395016f, -0.10727542f, 
    0.02229011f, -0.37690961f, -0.09878941f, 0.01155407f, -0.10221436f, 0.07291065f, 0.16980018f, 0.02770481f, 
    -0.05035185f, -0.12113290f, -0.15237027f, -0.11202945f, -0.05803955f, -0.07931026f, -0.06612766f, 0.06166670f, 
    -0.14353369f, -0.13185588f, -0.01808807f, -0.07627767f, -0.04452537f, -0.06754846f, 0.11226939f, -0.08205085f, 
    0.11578281f, 0.07691472f, 0.08664070f, 0.20475613f, -0.26133364f, -0.23941870f, -0.19854853f, -0.02757937f, 
    -0.07026929f, 0.04223410f, -0.01056667f, 0.01975118f, -0.04613061f, -0.01799043f, -0.03089440f, 0.03060767f, 
    0.16159475f, 0.14302905f, -0.08598009f, 0.00151108f, -0.13944864f, -0.12665723f, 0.03333823f, -0.06427304f, 
    0.01056178f, -0.30422384f, -0.09704371f, -0.14950761f, -0.18702002f, 0.02572316f, -0.06348836f, -0.11411332f, 
    -0.30199447f, 0.06837102f, 0.09530899f, -0.10348350f, 0.01343257f, 0.06714403f, -0.03931769f, 0.17269984f, 
    -0.24927393f, -0.37756875f, 0.05765252f, -0.27296782f, -0.26585934f, -0.10371327f, -0.15659858f, -0.02089261f, 
    0.02238553f, -0.14450885f, -0.01022102f, 0.10657693f, 0.14307721f, 0.03244437f, 0.05051468f, 0.04542492f, 
    0.17141299f, 0.12056678f, 0.02965534f, 0.12657192f, 0.06760311f, 0.04652169f, -0.05706416f, 0.08826844f, 
    -0.00188389f, -0.11450367f, 0.30837938f, 0.21734691f, -0.17607041f, -0.07950645f, -0.19726600f, -0.00759523f, 
    -0.00849146f, -0.00626606f, -0.02352350f, 0.02514677f, -0.00036564f, 0.04541954f, -0.04446315f, 0.04406251f, 
    0.04480870f, -0.08423660f, 0.06465118f, 0.03908897f, -0.00394213f, -0.26831618f, -0.15591247f, -0.14904469f, 
    0.19649455f, 0.18943739f, 0.18594988f, 0.25954387f, 0.05356054f, -0.03306582f, -0.02092020f, -0.22132073f, 
    0.20322534f, 0.04229954f, 0.18097904f, 0.07461003f, 0.01678877f, 0.13864858f, -0.03485352f, 0.19628057f, 
    -0.01045957f, 0.15139431f, -0.01865417f, -0.14784068f, 0.03051501f, -0.06348944f, -0.12946001f, -0.08967933f, 
    0.14608732f, -0.47961631f, -0.23204280f, 0.13188933f, -0.00476489f, -0.23519789f, 0.09571393f, -0.18062462f, 
    0.11813147f, 0.03905831f, 0.14231294f, 0.14732784f, 0.05888061f, 0.09464682f, 0.12634791f, 0.03138810f, 
    0.01914793f, -0.06779876f, -0.01366764f, 0.00819231f, 0.21028669f, -0.08275145f, -0.07261732f, 0.05689432f, 
    0.00525486f, -0.03015976f, 0.07856480f, 0.02260850f, 0.04222676f, -0.05581536f, -0.00740163f, -0.01063638f, 
    0.16714448f, -0.13174921f, -0.05770639f, 0.14363571f, 0.14050478f, -0.14120969f, -0.16130522f, 0.05884254f, 
    0.17891894f, 0.02703136f, -0.00064253f, 0.11763612f, 0.12883474f, -0.04358464f, 0.15298100f, 0.30859458f, 
    0.19985493f, -0.05577830f, -0.22640178f, 0.13502094f, 0.01824799f, 0.01762073f, 0.09885669f, 0.11922914f, 
    0.06381048f, -0.06885743f, -0.00348232f, -0.29731488f, -0.31002259f, 0.19187345f, -0.35312688f, -0.09645370f, 
    0.27055442f, -0.02654967f, 0.03372468f, 0.09374058f, -0.04408677f, -0.02247076f, 0.11821616f, 0.01661156f, 
    0.11459459f, -0.20556915f, 0.23121899f, -0.04186358f, -0.08394020f, -0.01135167f, -0.06317438f, -0.08836050f, 
    0.03610322f, -0.06650959f, -0.14501250f, -0.16590363f, -0.05254165f, -0.20944202f, -0.17543153f, 0.17322756f, 
    0.07045113f, 0.07244939f, -0.00691693f, 0.01975569f, 0.02492295f, -0.09059939f, 0.05620227f, 0.16686477f, 
    -0.08829848f, -0.34275204f, 0.17824937f, -0.02197253f, -0.06899258f, -0.09115954f, 0.09023557f, 0.11310576f, 
    0.06749487f, -0.05017157f, 0.05908398f, -0.08210427f, 0.14848292f, 0.21781757f, 0.16699080f, 0.13487928f, 
    -0.08666462f, -0.02418473f, 0.11945140f, 0.18144551f, 0.01500367f, 0.16034213f, -0.15332338f, -0.13009213f, 
    -0.07659329f, 0.25408384f, 0.16369537f, -0.33108377f, 0.08218978f, 0.21495293f, 0.16598031f, -0.04654567f, 
    0.04752832f, 0.06015715f, -0.02892638f, 0.09907515f, -0.28483683f, 0.16660315f, -0.02737952f, -0.19717559f, 
    -0.11471424f, -0.10323634f, 0.00658300f, -0.06761190f, 0.08808705f, 0.12877889f, 0.03942157f, 0.13604487f, 
    0.01850950f, 0.28118163f, -0.41710901f, -0.03894372f, 0.04648953f, -0.00453905f, -0.01102401f, 0.03848061f, 
    0.14749677f, 0.02666740f, -0.17636223f, 0.02831704f, 0.15845999f, -0.10384122f, -0.18975694f, 0.16025837f, 
    -0.03466192f, -0.02595950f, -0.07247673f, 0.10116313f, -0.16500181f, -0.35759035f, 0.03527173f, -0.76791227f, 
    0.11562476f, -0.12829059f, 0.23079178f, 0.07310097f, 0.01105511f, -0.04426197f, -0.19277540f, 0.13787067f, 
    0.22650427f, -0.09978403f, 0.14105979f, 0.00832613f, -0.35996735f, -0.33797747f, -0.12439027f, -0.59868944f, 
    0.10155017f, -0.12290516f, -0.10321528f, 0.09137366f, 0.04863198f, -0.12344135f, -0.19090916f, -0.05306370f, 
    0.28389171f, 0.14994487f, 0.13705856f, 0.11089344f, 0.03340751f, 0.17645575f, -0.06804440f, -0.35218123f, 
    -0.04608315f, -0.04620235f, -0.02785805f, -0.03252779f, 0.24558705f, -0.04328990f, -0.40389243f, 0.11084405f, 
    0.05081807f, -0.12354412f, 0.15892710f, 0.07296885f, 0.13879240f, -0.25332451f, 0.18246008f, -0.19600877f, 
    -0.13370924f, 0.19152147f, -0.04452113f, -0.59249628f, -0.21694137f, -0.19078960f, -0.03320941f, -0.03907511f, 
    -0.02130125f, 0.04130512f, -0.22668937f, -0.23369914f, 0.03632353f, 0.13198811f, 0.00278108f, 0.08363303f, 
    0.03557131f, 0.21442927f, 0.01193275f, 0.05349654f, -0.00444104f, 0.02536097f, 0.11694953f, 0.01383866f, 
    -0.01826762f, -0.04902172f, 0.11715834f, -0.28497189f, 0.03035247f, 0.12004665f, -0.00586079f, -0.18664615f, 
    0.24199076f, -0.01442166f, 0.29570091f, -0.17019227f, -0.46515682f, -0.28161871f, -0.30548280f, -0.36042264f, 
    -0.05244215f, 0.03865360f, -0.20479798f, 0.00973923f, 0.13500167f, -0.07314458f, 0.08835388f, -0.00733585f, 
    -0.34759152f, 0.22363293f, -0.03223831f, -0.07022373f, -0.02664492f, 0.03437100f, -0.03316320f, -0.00349306f, 
    0.08365148f, -0.26752076f, -0.39561155f, -0.31098157f, -0.20784743f, -0.15676136f, 0.04599586f, 0.28805572f, 
    -0.01993206f, -0.08581952f, -0.00058439f, 0.01427228f, -0.02117453f, 0.05561046f, -0.01995345f, 0.00558972f, 
    -0.35880134f, -0.30141199f, -0.21745715f, 0.23670778f, 0.08443549f, -0.01290817f, 0.16335732f, -0.03371646f, 
    0.17818426f, -0.04239316f, -0.05333339f, 0.21059017f, 0.48420548f, 0.09001335f, 0.08010914f, 0.17995869f, 
    0.20346612f, -0.12384520f, -0.23788111f, 0.17495987f, 0.03001491f, 0.08754869f, -0.01167409f, 0.11295647f, 
    0.07006846f, -0.74726653f, 0.48789147f, 0.49706671f, 0.17131236f, -0.06135106f, 0.09488706f, 0.02988659f, 
    -0.06832285f, 0.09838976f, -0.14280568f, -0.07573068f, -0.03129369f, -0.09187774f, -0.02242917f, -0.01406876f, 
    0.10348018f, -0.02908132f, -0.10139272f, -0.11967795f, -0.07051145f, -0.08324841f, 0.02834688f, -0.01706974f, 
    -0.14315571f, -0.03093529f, 0.26413548f, -0.31993228f, 0.10368177f, 0.21722969f, 0.12540966f, 0.25804803f, 
    -0.00037588f, 0.16039681f, 0.08294599f, 0.06219929f, 0.15099214f, -0.12215674f, -0.20252286f, -0.06780344f, 
    0.00404792f, 0.20800777f, -0.23322816f, -0.05684559f, 0.09059510f, 0.14152429f, 0.13725384f, 0.13030641f, 
    0.11591659f, 0.10040665f, 0.07632042f, -0.26635745f, -0.00112933f, 0.00997381f, 0.00542924f, -0.05919928f, 
    -0.29685235f, -0.23745055f, 0.01948418f, -0.18965021f, 0.03938780f, 0.16082349f, 0.24470893f, 0.03155009f, 
    0.10315090f, -0.04538405f, 0.22950947f, 0.13929045f, -0.00411390f, 0.27321821f, 0.04919242f, 0.07937002f, 
    -1.11040103f, 0.12794332f, 0.47492415f, 0.00015988f, 0.02065184f, 0.06364288f, -0.08150167f, 0.08627072f, 
    0.18063377f, -0.18472120f, 0.03718971f, -0.07767147f, 0.07017958f, -0.01263263f, -0.08972879f, -0.07760747f, 
    -0.08052914f, -0.20406307f, -0.02225085f, -0.10941537f, 0.07478914f, -0.09700406f, -0.09715743f, -0.07668769f, 
    -0.24241015f, 0.11585632f, 0.14241512f, -0.05711789f, -0.03265765f, -0.02930591f, -0.05722422f, 0.13097890f, 
    0.11046977f, 0.09959187f, 0.04345869f, -0.05747776f, 0.30375385f, 0.17170757f, -0.01994172f, -0.16212498f, 
    0.05788627f, -0.01114729f, 0.10267072f, 0.00914851f, 0.20473537f, 0.00733133f, 0.08984458f, -0.16446386f, 
    0.23568371f, 0.03713990f, -0.12567854f, -0.06447457f, 0.02413178f, -0.06617173f, 0.06725324f, 0.08237448f, 
    -0.00291877f, -0.06305543f, 0.01787544f, -0.00987669f, 0.21478648f, 0.06921314f, 0.17869146f, 0.05306580f, 
    -0.17875962f, 0.19179039f, 0.01162975f, 0.28641188f, 0.08444752f, 0.12038065f, 0.00827316f, -0.12102070f, 
    -0.02181503f, 0.19106032f, -0.14813726f, -0.02968797f, -0.08358692f, 0.04221029f, -0.03132179f, 0.26398802f, 
    0.06931528f, -0.08654068f, 0.12715037f, -0.03771331f, -0.23911378f, 0.04388248f, -0.00376901f, -0.12331781f, 
    0.00386225f, -0.01586923f, -0.02068443f, -0.03114115f, -0.04817012f, -0.04096111f, 0.01009378f, -0.07024527f, 
    -0.45201120f, -0.57025468f, -0.56817585f, 0.14239620f, -0.09607053f, 0.12963331f, -0.00212885f, -0.06545454f, 
    -0.01350018f, 0.05123546f, -0.05824949f, 0.03769109f, 0.12774214f, 0.06178803f, -0.17872095f, -0.15895982f, 
    -0.11816182f, -0.08413313f, -0.17049186f, 0.08760777f, -0.03075693f, -0.08881623f, 0.20981959f, -0.20481229f, 
    -0.22538517f, -0.90472084f, -0.10854054f, -0.01142403f, -0.06529655f, -0.43823481f, -0.14428189f, -0.30439895f, 
    -0.07010116f, 0.09138896f, -0.03595942f, -0.07943188f, -0.15869932f, 0.01875519f, 0.22438602f, -0.19673347f, 
    -0.05314775f, -0.01667076f, 0.00309508f, 0.07866353f, -0.02775199f, 0.24751283f, 0.14230189f, 0.21148111f, 
    0.08466495f, -0.09609324f, 0.29924554f, -0.55586016f, -0.00060711f, -0.05604315f, 0.02778894f, -0.10042826f, 
    0.01269465f, 0.32841507f, 0.15911105f, 0.15576319f, 0.16710976f, 0.06421167f, -0.08927278f, -0.09038246f, 
    -0.10272820f, 0.08336086f, 0.08909133f, 0.04544565f, 0.11630690f, 0.33535329f, -0.00868857f, 0.09137549f, 
    0.16594212f, 0.24171361f, -0.20187655f, -0.05323531f, 0.10964639f, -0.04770034f, 0.28465176f, 0.30879116f, 
    0.05773778f, 0.02265630f, 0.08222643f, 0.00134213f, -0.67989564f, 0.06869233f, -0.13091931f, -0.18322018f, 
    0.05530905f, -0.10483552f, 0.02116606f, 0.25388226f, 0.02680626f, 0.06849378f, 0.08886857f, 0.17352372f, 
    -0.71145248f, -1.24494791f, -0.37375385f, -0.48204756f, -0.03184338f, -0.25976241f, -0.08323523f, -0.40456301f, 
    -0.05517889f, -0.08892903f, -0.03259595f, -0.05398414f, 0.99957097f, 0.32542336f, -0.26629266f, 0.16856571f, 
    0.05332363f, -0.02784180f, 0.07941321f, 0.14182638f, 0.07813834f, -0.00137735f, -0.06838751f, 0.08353833f, 
    -0.33488238f, -0.29601076f, 0.01423599f, 0.18647175f, 0.11591200f, 0.02391152f, 0.13664976f, -0.00134164f, 
    0.02632381f, 0.14039782f, 0.14002112f, 0.00777693f, -0.44644099f, -0.64648187f, -0.64612961f, -0.17280437f, 
    -0.38675055f, -0.08415979f, -0.00624872f, -0.26233584f, 0.06024513f, 0.02531006f, 0.01811674f, -0.06759070f, 
    -0.13413757f, 0.25847569f, 0.28143311f, 0.14448628f, 0.07614620f, -0.04383859f, -0.10967132f, 0.00576367f, 
    0.08815429f, -0.07302012f, -0.18471520f, 0.21310969f, -0.00421367f, 0.67305177f, 0.09845266f, 0.13815950f, 
    0.01285862f, -0.03287341f, -0.00833606f, -0.09757385f, 0.03609608f, 0.01787916f, -0.05669035f, 0.03792335f, 
    -0.04951336f, -0.24167573f, 0.02714815f, -0.25836176f, -0.06884925f, 0.08252834f, 0.11878880f, -0.00833404f, 
    0.06128325f, 0.18356794f, 0.08352184f, 0.33367753f, -0.03269919f, -0.01997541f, -0.05669339f, 0.15142247f, 
    -0.06655312f, 0.01422160f, 0.01690611f, 0.18570249f, -0.04788390f, -0.09584884f, 0.04448412f, -0.09942114f, 
    -0.14310057f, -0.10315046f, 0.27339241f, 0.35621822f, -0.09575733f, -0.48074690f, 0.18617189f, -0.07442624f, 
    -0.00870090f, -0.08792683f, -0.21388681f, -0.03540027f, -0.60506642f, -0.36427999f, -0.88507789f, -0.31861985f, 
    -0.14142348f, -0.08850126f, 0.15221339f, -0.38893995f, 0.01893783f, -0.00796568f, -0.05124028f, 0.24687333f, 
    -0.08293152f, -0.07606220f, -0.58685970f, 0.17004058f, -0.05564423f, -0.10294238f, -0.07224228f, 0.04574629f, 
    -0.08298074f, -0.02188569f, 0.03348077f, 0.15566804f, 0.05754699f, -0.08383346f, -0.12908582f, -0.04690588f, 
    -0.01097507f, 0.07835355f, -0.02848554f, 0.00967053f, -0.16184255f, -0.19536372f, -0.14913411f, -0.20647684f, 
    -0.68262398f, -0.46286550f, -0.05891386f, 0.03925984f, -0.29564252f, -0.04328282f, 0.07633886f, -0.08871426f, 
    0.00649361f, 0.07528927f, 0.01745611f, -0.02688335f, -0.01222385f, 0.11968240f, -0.20181969f, -0.00655421f, 
    -0.05815766f, -0.07297797f, -0.13127045f, 0.05637589f, -0.08275937f, 0.01711112f, -0.11155848f, -0.03841320f, 
    -0.32722518f, 0.32141349f, 0.18279523f, -0.07439191f, -0.10132420f, -0.04424679f, -0.13050099f, 0.07282428f, 
    -0.09656668f, 0.12225939f, -0.07841101f, -0.07574282f, -0.36041707f, -0.49516875f, -0.50179070f, -0.44054082f, 
    -0.16829912f, -0.12505543f, -0.16300076f, -0.22467555f, 0.03369961f, -0.02733503f, -0.05803500f, -0.03616303f, 
    -0.15870801f, -0.24378297f, 0.47628507f, -0.26845056f, -0.06470728f, 0.02952855f, 0.06290285f, 0.07468961f, 
    0.39449897f, 0.42879304f, 0.31070435f, -0.04462810f, -0.15192175f, 0.19937068f, 0.10553163f, 0.07433818f, 
    -0.12885296f, 0.13378990f, -0.25900137f, -0.28116462f, -0.11671803f, -0.00440255f, 0.01796944f, 0.07558338f, 
    0.26554936f, -0.04731707f, -0.01883888f, -0.14651912f, -0.01693076f, 0.09356960f, -0.00521619f, -0.02197968f, 
    0.19046926f, -0.02713866f, -0.04507945f, -0.16148883f, 0.06192306f, -0.03632635f, -0.02885909f, -0.05275428f, 
    0.00042030f, -0.06056003f, 0.03100159f, -0.02450350f, -0.16915682f, -0.03682323f, -0.09941781f, -0.05081388f, 
    0.00345895f, 0.12500444f, 0.08358308f, 0.01696751f, -0.03806899f, -0.04004988f, -0.03621904f, -0.08556991f, 
    0.06434820f, -0.01695973f, 0.07454462f, 0.03407066f, 0.16114803f, 0.13650309f, -0.09177857f, 0.05749724f, 
    -0.17033501f, -0.06365317f, 0.07612804f, -0.29049239f, 0.02427338f, -0.14972542f, -0.08328565f, -0.01780871f, 
    0.53699404f, -0.17955510f, -0.05474244f, 0.03006896f, -0.05757100f, -0.05169053f, -0.05766959f, -0.41999730f, 
    -0.14329919f, 0.12027902f, -0.06926590f, -0.10861700f, -0.08766480f, 0.03665238f, 0.04832393f, -0.07184490f, 
    -0.00139571f, 0.02315008f, 0.03586569f, 0.00086895f, 0.04371005f, 0.02296166f, 0.08153183f, -0.12345901f, 
    0.00294796f, -0.12595534f, -0.00844106f, -0.06025239f, -0.01694518f, -0.06952614f, -0.06229377f, -0.07329650f, 
    -0.00880432f, 0.03310240f, 0.08664283f, 0.02981526f, 0.06023115f, -0.92265177f, -0.21503901f, 0.53857541f, 
    0.11920375f, -0.00994210f, 0.05634246f, -0.07681169f, -0.17135502f, -0.05671221f, 0.13492669f, -0.06274825f, 
    -0.21737917f, -0.41606623f, 0.36142552f, -0.26541081f, -0.07918054f, -0.08852430f, -0.08708450f, 0.15748435f, 
    0.01723425f, -0.00755666f, -0.01136245f, -0.04808329f, 0.68642431f, -0.08197493f, -0.79335821f, -0.46794850f, 
    0.15181291f, 0.10102717f, 0.08572720f, 0.09574864f, 0.07122251f, -0.08125789f, 0.03482587f, -0.05210922f, 
    -0.47053081f, 0.39205140f, -0.29132161f, 0.48626557f, 0.00637857f, 0.14508998f, -0.08898293f, -0.04595243f, 
    -0.03851965f, 0.05515456f, -0.04634997f, 0.02535744f, 0.03394517f, 0.03267813f, -0.00288279f, 0.12332898f, 
    -0.05874579f, 0.04751753f, 0.01980938f, -0.02278265f, 0.15452994f, 0.09404802f, -0.11213800f, 0.03496346f, 
    -0.29197341f, -0.08052804f, 0.28915867f, -0.12301640f, -0.04828188f, 0.00006321f, 0.07407285f, 0.02300559f, 
    -0.12320840f, -0.01252512f, 0.01111146f, -0.10149850f, 0.36896950f, -0.58139247f, -0.37751958f, -0.70021665f, 
    -0.13754986f, 0.05415253f, -0.04643262f, 0.03355161f, 0.00665965f, 0.04120598f, 0.07229842f, -0.06785661f, 
    -0.69951576f, -0.43953496f, -0.03946361f, 0.73359215f, -0.03631449f, 0.10611618f, 0.02392261f, 0.12147782f, 
    -0.02048094f, -0.00659157f, -0.07921004f, -0.07264341f, -0.63457263f, -0.19112405f, -0.26794147f, 0.11586116f, 
    -0.19646639f, 0.20478617f, 0.03444153f, -0.05972584f, 0.04893587f, -0.05770106f, 0.06314231f, -0.22746503f, 
    0.00510215f, 0.06255969f, 0.35666648f, 0.15219024f, 0.10402643f, -0.16712701f, 0.16441481f, -0.06078469f, 
    -0.13558364f, -0.01250792f, 0.12049478f, 0.05598507f, -0.25373617f, -0.20668358f, -0.33362541f, -0.29502648f, 
    0.06967528f, -0.13791999f, 0.07579534f, 0.22832789f, 0.03893925f, -0.08847876f, -0.05642542f, -0.00831288f, 
    0.03123990f, 0.16413195f, 0.21614958f, -0.11366649f, -0.08372451f, -0.00627029f, 0.10450479f, -0.03118183f, 
    -0.07237890f, -0.21659474f, 0.12527500f, -0.01868854f, -0.08687110f, -0.13998432f, -0.07796215f, -0.03949941f, 
    -0.06872181f, -0.07637446f, -0.00897508f, -0.12002608f, -0.02453577f, -0.00655889f, 0.01414375f, 0.02342745f, 
    0.22641531f, -0.31892177f, -0.30545375f, -0.01143156f, -0.06542991f, -0.15084158f, -0.10877746f, 0.05607311f, 
    0.14504199f, 0.20118670f, 0.09805202f, 0.06318815f, 0.03923291f, -0.11425873f, 0.00039718f, -0.13435265f, 
    -0.02325629f, -0.09035935f, -0.03294571f, -0.07713609f, 0.09222378f, 0.04404408f, -0.01984571f, -0.16960923f, 
    0.17882791f, 0.03290565f, -0.05223688f, 0.07832937f, -0.09493246f, 0.29380560f, -0.03229723f, 0.05964740f, 
    0.06062307f, 0.06066898f, 0.04223479f, 0.02623194f, -0.71703953f, -0.29215780f, -0.19591740f, 0.14898269f, 
    0.06555457f, -0.04138638f, 0.14186879f, -0.01034063f, -0.06166968f, 0.01223591f, -0.02811965f, -0.12385336f, 
    0.45104644f, 0.03453920f, -0.13976461f, -0.04900922f, -0.01223115f, -0.11139384f, 0.03391651f, -0.23350997f, 
    -0.04358640f, 0.14277184f, -0.07481027f, -0.04066210f, 0.15235861f, 0.14279686f, 0.07988646f, -0.04966186f, 
    -0.08170781f, 0.05647498f, -0.01690440f, -0.05361655f, -0.21892884f, -0.18862638f, -0.03204259f, -0.01239155f, 
    0.38900575f, -0.49415904f, 0.18952912f, -0.23464595f, -0.07213670f, 0.02397013f, -0.01513347f, 0.16108724f, 
    -0.02160735f, -0.07133339f, 0.01431666f, 0.05933756f, 0.08448404f, -0.05159968f, 0.02765579f, -0.07704206f, 
    0.02149470f, -0.03173497f, 0.06822895f, -0.10365145f, -0.00784244f, -0.14390002f, 0.03749891f, -0.13568632f, 
    -0.37531731f, -0.57249832f, -0.28946435f, -0.04006617f, -0.16489777f, -0.05307761f, 0.04685505f, 0.12238435f, 
    -0.00249495f, -0.07272830f, 0.20666794f, -0.02454876f, -0.41309610f, -0.08089644f, 0.00272714f, 0.33001706f, 
    -0.15322739f, 0.18877900f, -0.16513470f, -0.14515384f, 0.04630606f, 0.04549967f, -0.11785338f, -0.01672707f, 
    0.69795001f, 0.18796326f, -0.01680556f, -0.28975421f, -0.03426514f, 0.02341970f, -0.09948573f, -0.03311946f, 
    -0.04858625f, -0.06080530f, -0.05874271f, -0.15066864f, 0.35245788f, -0.19392519f, -0.20200525f, -0.08077227f, 
    0.08243678f, 0.02213180f, -0.07659647f, -0.05555986f, 0.07117357f, -0.04887965f, 0.03486251f, 0.11610732f, 
    -0.14518160f, -0.16734648f, -0.20861781f, -0.24990389f, -0.03606280f, -0.04202528f, 0.03163749f, 0.00423173f, 
    0.00236916f, -0.08280002f, -0.07980177f, -0.08168314f, -0.30954266f, 0.12312734f, 0.06574252f, 0.13098842f, 
    0.01885081f, -0.01385782f, -0.04683329f, -0.02288078f, 0.04167263f, 0.06507541f, 0.16072924f, 0.11761547f, 
    -0.54727578f, 0.08884069f, 0.15475482f, -0.08111986f, -0.05912578f, 0.04153917f, -0.09715904f, -0.08159366f, 
    -0.35702890f, -0.24753231f, -0.29643989f, -0.19594973f, -0.15765198f, -0.02281882f, -0.13928919f, -0.02385404f, 
    -0.10180483f, 0.20332092f, -0.05687221f, 0.09945907f, -0.11492402f, 0.08895525f, 0.09028285f, -0.10913816f, 
    0.40207630f, -0.05443541f, -0.25587687f, -0.39091599f, 0.25933948f, 0.10641757f, 0.19519542f, -0.03656103f, 
    0.08670698f, -0.09311610f, 0.17638139f, 0.04169418f, -0.64717549f, 0.28322557f, 0.13579363f, -0.08409638f, 
    0.01753370f, -0.00230691f, -0.07233424f, 0.06888025f, -0.05047058f, -0.07191966f, 0.06845149f, 0.08783413f, 
    -0.03270660f, 0.23349020f, 0.13587816f, 0.06145781f, 0.10369166f, -0.06308811f, -0.11469305f, -0.41665754f, 
    0.04858214f, 0.10425356f, -0.10781016f, -0.08121530f, 0.42260122f, -0.25553516f, -0.59656125f, -0.24200080f, 
    0.16386840f, 0.02563413f, -0.04077625f, 0.14107755f, 0.15463549f, 0.25277594f, 0.12952797f, 0.14245521f, 
    0.43924668f, -0.29767096f, -0.50802892f, -0.41241404f, -0.11311659f, -0.13141079f, 0.10488646f, -0.03122332f, 
    0.02312262f, 0.10063785f, -0.03912720f, 0.15258540f, 0.09334642f, -0.74390095f, -0.80012608f, -0.33185962f, 
    -0.23361860f, -0.07481755f, 0.16249390f, 0.03388494f, 0.01382716f, 0.10186027f, 0.14107352f, 0.13527340f, 
    -0.14832096f, 0.22796728f, -0.10689971f, -0.03242552f, 0.12978655f, 0.05842941f, -0.07929487f, 0.16314763f, 
    0.04086366f, 0.24026106f, -0.21024697f, -0.28385684f, -0.18974486f, 0.08213327f, -0.07704850f, 0.12448914f, 
    0.06379540f, 0.05704790f, 0.00111677f, 0.06298427f, -0.34189951f, -0.14292698f, -0.21848798f, -0.35919544f, 
    0.32733336f, -0.17092878f, 0.03413810f, 0.17571881f, 0.11734385f, 0.07370007f, -0.10346978f, 0.05618304f, 
    0.17681134f, -0.11133066f, -0.20697662f, 0.16959529f, -0.34437484f, -0.58422267f, -0.61287332f, -0.08742677f, 
    0.13250718f, 0.24631065f, 0.22748637f, 0.02280339f, -0.19969486f, -0.08845902f, -0.09514664f, -0.08765032f, 
    0.02595063f, -0.04590698f, -0.24120729f, -0.31127682f, 0.03785509f, -0.15831031f, 0.09165651f, 0.07108888f, 
    0.07832871f, 0.06257134f, 0.09053613f, 0.02907656f, -0.56467938f, 0.38706288f, -0.01212054f, 0.37361887f, 
    0.15817253f, 0.16213426f, -0.19558871f, 0.03218502f, 0.00770772f, 0.11589438f, -0.00040598f, -0.04938478f, 
    -0.05343062f, -0.17717235f, 0.01938801f, 0.17396374f, -0.10698647f, 0.08557427f, -0.08663561f, -0.25498518f, 
    -0.07509179f, -0.26591927f, 0.03421402f, 0.00701773f, 0.05447456f, -0.27168357f, -0.54350257f, -0.13815171f, 
    0.01558159f, 0.01713289f, -0.10884673f, -0.29629135f, -0.01628061f, -0.09093373f, -0.03283883f, -0.03708963f, 
    -0.32731470f, -0.36660689f, 0.12821883f, 0.08731279f, -0.06329734f, 0.11835943f, 0.09497191f, 0.03990870f, 
    0.03955179f, 0.22405209f, -0.03822701f, 0.14849882f, -0.42913446f, -0.45949876f, -0.05308989f, 0.23970817f, 
    -0.00633463f, 0.07412717f, 0.19752051f, 0.12700348f, 0.03126922f, 0.03593577f, 0.11026226f, -0.00487140f, 
    0.03276007f, 0.01631114f, 0.01269654f, -0.13506708f, 0.00921855f, -0.00458861f, 0.05549878f, 0.11831351f, 
    -0.02188449f, -0.21177179f, -0.18778265f, -0.60356027f, 0.28828627f, 0.23743123f, -0.02583760f, -0.04790207f, 
    0.05129205f, -0.06474151f, -0.04985020f, -0.01347235f, 0.13132046f, -0.05558084f, 0.02478064f, 0.10835604f, 
    -0.15429512f, 0.01466755f, -0.35002184f, 0.24077193f, 0.21438989f, -0.04207477f, 0.11184669f, 0.00636540f, 
    0.06151790f, 0.15663487f, 0.08399221f, 0.19789512f, 0.41483822f, -0.20411786f, -0.35605705f, 0.14340454f, 
    0.01529242f, 0.11209964f, 0.13071407f, 0.14961280f, 0.03455679f, 0.00923537f, -0.04366172f, -0.02015223f, 
    0.77455336f, 0.12336335f, -0.31574786f, -0.14270717f, 0.11567049f, -0.00890816f, 0.12588279f, 0.02862591f, 
    0.13019264f, -0.02519811f, 0.21761322f, 0.04974473f, -0.21755283f, -0.01472510f, -0.06645072f, -0.17627823f, 
    -0.10250229f, -0.03406096f, -0.01677236f, 0.06983456f, 0.00781615f, 0.05689038f, -0.02148174f, 0.08117825f, 
    0.22450104f, -0.13515911f, -0.58770853f, -0.17588215f, 0.05868720f, -0.01324949f, 0.17036100f, -0.02958518f, 
    -0.07962716f, -0.00185355f, -0.08141070f, -0.06324165f, -0.25364131f, 0.12070694f, 0.04942442f, -0.06108656f, 
    0.05708776f, -0.02174578f, 0.09288278f, -0.01976140f, 0.15301040f, 0.16627948f, -0.05135745f, 0.24692686f, 
    -0.24263111f, -0.37477851f, -0.23496501f, 0.03789568f, 0.03197560f, 0.14766370f, 0.06622598f, 0.06065319f, 
    -0.30730423f, -0.27039060f, -0.34265262f, -0.25913802f, -0.20158564f, -0.26719216f, 0.11392180f, 0.12884296f, 
    0.19069135f, 0.00898213f, 0.04752967f, 0.23674995f, -0.18846320f, 0.15658802f, 0.15248361f, 0.09038708f, 
    0.39899880f, 0.15722157f, -0.30407235f, -0.38735819f, 0.07301049f, 0.05414384f, 0.04335368f, 0.07711968f, 
    0.06295480f, 0.16733299f, -0.18120237f, -0.05601458f, -0.11779448f, -0.33186382f, -0.17389491f, -0.25860783f, 
    0.05715137f, 0.03965992f, 0.08775025f, 0.11662415f, -0.05241646f, 0.05604937f, -0.16958237f, -0.14687760f, 
    0.18942972f, 0.05614973f, 0.35000318f, 0.44668713f, -0.05964597f, -0.06082657f, -0.21503231f, -0.17403592f, 
    0.02509412f, -0.00962595f, 0.10889314f, -0.09163421f, -0.20651130f, 0.09093901f, -0.05947510f, -0.08446941f, 
    -0.01103547f, -0.09622447f, 0.12480025f, 0.09893509f, -0.07107192f, 0.04744825f, 0.00616241f, -0.20618603f, 
    -0.05812871f, -0.15077688f, -0.10007519f, -0.16695362f, 0.04213271f, 0.18840271f, 0.07812255f, -0.02349146f, 
    0.08742575f, -0.12681532f, 0.04553315f, 0.17113690f, -0.42558807f, 0.20819825f, 0.00999888f, -0.03591664f, 
    -0.06329027f, -0.17585930f, -0.02577315f, -0.32674888f, 0.10506690f, 0.06516618f, 0.00415547f, -0.05056880f, 
    -0.37074885f, 0.13602145f, -0.01827238f, 0.39196992f, 0.23475118f, -0.18160439f, -0.00388147f, -0.04011322f, 
    0.04561859f, 0.05181542f, 0.12035321f, 0.12708117f, -0.06506164f, 0.04520395f, -0.42457640f, 0.14475036f, 
    0.05537875f, -0.02390357f, 0.10295701f, -0.07477545f, 0.01978086f, 0.01435455f, 0.08066089f, -0.11067341f, 
    0.15428719f, -0.67532092f, -0.36525854f, -0.05056583f, 0.38578540f, 0.23709017f, 0.03850245f, 0.11951411f, 
    -0.03605189f, -0.00858451f, -0.05823752f, -0.03299037f, 0.26721546f, 0.13042343f, 0.18422949f, 0.11709559f, 
    0.04035023f, -0.19814351f, -0.01144889f, -0.18168199f, 0.14452872f, -0.00905447f, -0.12222020f, -0.07996111f, 
    -0.27414072f, -0.08742899f, -0.08847643f, -0.12246395f, -0.23606201f, 0.21721028f, -0.12339403f, 0.07312365f, 
    0.09188443f, -0.00475599f, 0.05110627f, -0.08024607f, -0.01546354f, 0.15347078f, 0.28099638f, 0.61810815f, 
    0.22040592f, -0.23591748f, -0.15944415f, -0.05596140f, -0.12444253f, -0.08396871f, -0.02214609f, 0.11761588f, 
    -0.77609056f, 0.27189487f, -0.18962100f, 0.20430361f, 0.03264521f, 0.01467251f, -0.01935766f, 0.10609824f, 
    0.05024352f, 0.08379531f, 0.09115814f, -0.10185783f, 0.01765461f, 0.12912111f, -0.04990736f, 0.04793530f, 
    0.00021826f, 0.00110034f, 0.06409568f, -0.06760640f, 0.09174863f, 0.21961893f, 0.09262270f, 0.17853968f, 
    0.09685630f, -0.38386172f, 0.52192211f, -0.44593796f, 0.04448973f, -0.20171775f, -0.12833308f, -0.19997279f, 
    -0.19413182f, -0.02513775f, -0.18283175f, 0.08716632f, 0.27202818f, -0.35038677f, -0.23685361f, -0.33462304f, 
    -0.50143284f, -0.04815724f, -0.14559774f, -0.07541272f, 0.11894245f, 0.03797382f, 0.06986381f, 0.02934106f, 
    -0.03311808f, 0.24118100f, -0.46587211f, -0.13591187f, -0.20396571f, 0.02402626f, 0.23118997f, 0.21900897f, 
    -0.04890972f, 0.15690371f, -0.05944584f, -0.18449743f, -0.26046070f, 0.41952768f, 0.07084715f, -0.64546573f, 
    -0.17784712f, -0.21590929f, -0.00966744f, -0.26991096f, -0.02085659f, -0.09339819f, 0.18799655f, 0.03995436f, 
    0.11617494f, -0.58432484f, 0.11328601f, -0.42612338f, 0.03067451f, 0.10386635f, -0.00558643f, 0.19192995f, 
    0.11039628f, 0.15819545f, 0.01493264f, 0.10504153f, -0.27229220f, 0.10298910f, 0.40276697f, -0.02700683f, 
    0.02547642f, -0.21236089f, -0.05355449f, 0.23762135f, 0.05586894f, 0.00217896f, 0.14685731f, -0.00776943f, 
    0.23190048f, 0.00576072f, 0.09163226f, -0.53669280f, 0.15452166f, -0.16875115f, -0.08140178f, -0.02275549f, 
    0.03518409f, -0.00922394f, -0.02947337f, -0.04370431f, 0.25285643f, -0.00870452f, 0.40835166f, -0.61459678f, 
    0.09269951f, -0.17897788f, -0.16825005f, -0.02874525f, -0.12512374f, -0.06692708f, 0.11499529f, 0.07572165f, 
    -0.33684647f, -0.00052525f, -0.27202445f, 0.23462336f, 0.04900793f, 0.12171839f, -0.08315893f, 0.02115290f, 
    0.05102762f, -0.00733970f, 0.18550991f, 0.10391361f, -0.02114822f, -0.19852409f, -0.13867109f, 0.03471544f, 
    0.18777797f, 0.14362410f, 0.16311400f, -0.12325262f, 0.01585980f, -0.09516166f, 0.07014095f, -0.08140311f, 
    -0.13897799f, 0.29682016f, -0.13914435f, -0.23874080f, -0.20600472f, -0.18723579f, -0.11421841f, 0.00507382f, 
    0.03445695f, -0.04801809f, -0.21398602f, -0.13742512f, -0.04578255f, 0.14556280f, -0.25136065f, 0.15793535f, 
    0.05405618f, -0.19116056f, 0.11763112f, 0.05690547f, 0.06591956f, 0.06786942f, 0.10942491f, -0.01658588f, 
    -0.34467000f, -0.36698717f, -0.33686128f, 0.39954829f, 0.10022329f, 0.18904927f, 0.12911023f, -0.01119677f, 
    -0.00639625f, -0.01789194f, 0.07567209f, -0.07639959f, -0.11423295f, -0.01578551f, -0.04859762f, 0.24719489f, 
    0.13340074f, 0.19005530f, 0.14611700f, 0.00160308f, 0.20959455f, 0.09767256f, 0.05421954f, 0.01985565f, 
    -0.45518002f, -0.30404422f, 0.34204561f, -0.18854983f, -0.16636156f, -0.16757540f, -0.00521258f, -0.15338813f, 
    0.06058358f, -0.00737709f, 0.02967608f, 0.00041770f, 0.12403537f, -0.21899322f, -0.09685761f, 0.08254455f, 
    0.05130432f, -0.15157723f, 0.16708244f, -0.13529836f, 0.18701078f, -0.16117139f, -0.21739626f, -0.08957729f, 
    -0.13844964f, 0.16144422f, 0.52558285f, -0.41025281f, -0.00954127f, -0.17462395f, -0.03632107f, -0.05351681f, 
    0.02022984f, 0.10346834f, 0.06903908f, 0.10860752f, 0.02752928f, 0.43883270f, -0.91868961f, 0.01684302f, 
    -0.08754355f, 0.01525601f, 0.16214216f, -0.06567974f, -0.00053378f, -0.05599653f, -0.10777014f, 0.05264794f, 
    -0.56595421f, -0.02208203f, -0.11115917f, 0.53378505f, -0.04418250f, 0.04319816f, -0.17714310f, -0.18001282f, 
    -0.04225586f, -0.13185740f, -0.03401868f, 0.02930859f, 0.06106883f, 0.10277767f, 0.32404280f, 0.07934257f, 
    0.02089465f, -0.17106882f, -0.15991658f, -0.16207805f, 0.09767160f, 0.04870493f, 0.12332547f, 0.11668265f, 
    -0.42277718f, 0.21954030f, -0.11083653f, -0.35886407f, 0.07613961f, 0.09105086f, -0.09790423f, 0.08854344f, 
    -0.06682989f, -0.09023540f, -0.15992488f, -0.09910649f, -0.09043734f, 0.00093257f, -0.10117865f, 0.13645440f, 
    -0.13891460f, 0.05896110f, 0.12646416f, -0.05268377f, -0.05300188f, -0.02393223f, 0.21965930f, 0.08350387f, 
    -0.10259665f, 0.15384406f, 0.10170316f, -0.05919139f, -0.13510507f, -0.16338065f, -0.03715859f, 0.04791595f, 
    -0.24735847f, -0.10503802f, -0.23353225f, -0.18179637f, 0.37682304f, -0.20740268f, 0.14058346f, -0.01457021f, 
    -0.28380141f, 0.01576973f, 0.07047144f, 0.04507108f, -0.10049030f, 0.29127002f, -0.19278339f, -0.15855700f, 
    -0.20780253f, 0.29967427f, 0.03450244f, -0.33717978f, -0.08773809f, 0.12340683f, -0.05157590f, 0.16119087f, 
    -0.11556091f, 0.03256808f, -0.17994297f, -0.17558837f, 0.08901726f, -0.10968010f, -0.27682975f, -0.18876058f, 
    -0.25057861f, -0.02331117f, 0.01158706f, -0.06830497f, -0.03178709f, -0.02438486f, -0.06696594f, 0.05431652f, 
    -0.25204358f, -0.35471603f, -0.27237853f, -0.17165767f, 0.02723826f, 0.15740965f, -0.06315956f, -0.31763634f, 
    -0.02825196f, -0.02458019f, 0.03813762f, -0.16619147f, -0.26822791f, -0.10855333f, 0.16892250f, -0.06848001f, 
    0.00849942f, 0.05250793f, 0.08954142f, -0.16956677f, -0.22103827f, -0.01578557f, 0.11819921f, 0.15088977f, 
    -0.08724089f, 0.25733975f, -0.46652898f, 0.30893648f, -0.07996894f, 0.07727473f, 0.04956809f, 0.21101850f, 
    -0.03565058f, 0.22142561f, 0.05163741f, 0.05029282f, 0.13486265f, -0.08620280f, 0.22517765f, -0.02396245f, 
    -0.07547054f, 0.11313605f, -0.09581003f, 0.05682304f, 0.16119264f, 0.13428403f, 0.03322955f, -0.09789810f, 
    0.57138211f, -0.44642168f, 0.34693760f, -0.22089814f, 0.10485709f, 0.03293773f, 0.11142608f, 0.13520530f, 
    -0.17121011f, -0.45391816f, -0.56051534f, -0.19807371f, 0.02462490f, 0.16780064f, 0.09791972f, -0.14908819f, 
    -0.10013857f, -0.04652308f, 0.01223195f, 0.01739165f, -0.07136922f, 0.08076204f, -0.40411973f, -0.20204735f, 
    -0.57688260f, 0.42184159f, -0.25141764f, 0.24537718f, -0.06812448f, -0.14354262f, 0.17259409f, 0.46756390f, 
    -0.27490586f, -0.02953160f, -0.03809868f, -0.01503289f, -0.23847540f, 0.26558244f, -0.59293902f, 0.14511441f, 
    0.19100146f, -0.32131404f, 0.12599160f, 0.06160747f, -0.06999872f, 0.06852083f, -0.19995613f, -0.21337202f, 
    -0.14450784f, 0.00377376f, -0.32701963f, 0.06260549f, -0.28650573f, -0.14161448f, 0.16399276f, -0.36485732f, 
    0.10189414f, 0.16606377f, -0.00244052f, 0.00576205f, -0.10432054f, -0.05528769f, 0.27344599f, 0.32485065f, 
    -0.19411032f, -0.16830388f, 0.05879483f, 0.25588158f, -0.20808269f, 0.02068232f, 0.06858294f, 0.02715518f, 
    -0.27126738f, 0.20639637f, 0.23121974f, 0.04332140f, 0.11842687f, 0.03759620f, -0.32069829f, 0.02616724f, 
    -0.07735364f, -0.34283793f, -0.03346004f, 0.04935245f, -0.26161849f, -0.33074439f, -0.20476501f, 0.21789351f, 
    -0.10261820f, 0.10319288f, -0.37129000f, 0.12588887f, 0.06756233f, 0.13931273f, 0.05705883f, -0.06171014f, 
    0.27297315f, 0.18361920f, 0.45843285f, 0.39867553f, -0.06187346f, 0.13173722f, 0.13153437f, -0.01936420f, 
    -0.03990082f, 0.23572877f, 0.25225306f, 0.10869049f, 0.05049337f, 0.11633930f, 0.04577286f, 0.24466570f, 
    -0.07257286f, -0.04672622f, 0.06450740f, 0.10915446f, -0.10236604f, 0.07448369f, -0.08651727f, -0.31097928f, 
    -0.00062478f, 0.04418007f, -0.01370920f, -0.11280775f, 0.15091541f, -0.02529708f, -0.07176142f, 0.08748086f, 
    -0.06389339f, -0.14739914f, -0.19185382f, -0.44844744f, -0.31975430f, 0.21868610f, 0.25313133f, -0.29254892f, 
    -0.17446893f, -0.08474260f, 0.22506934f, -0.03663764f, -0.05907678f, 0.21291760f, 0.20489857f, 0.04029467f, 
    0.35237342f, 0.06562751f, 0.63112140f, -0.23557809f, -0.28357744f, 0.09181923f, 0.08315807f, 0.04300552f, 
    0.17606637f, -0.27839366f, 0.48360705f, 0.17917703f, -0.19127999f, 0.11253548f, 0.08700203f, 0.08559455f, 
    -0.14434575f, -0.09201805f, -0.10674495f, 0.20169953f, 0.21295419f, 0.11336927f, -0.02856845f, -0.19530883f, 
    -0.82494986f, 0.40727755f, 0.52565372f, -0.03974963f, -0.18911706f, -0.01082066f, -0.06529416f, 0.07251971f, 
    -0.00493669f, 0.12566461f, 0.13406517f, -0.07766572f, -0.16904177f, -0.12777732f, -0.36712283f, -0.42074859f, 
    -0.17718060f, -0.35921279f, 0.01063918f, -0.19143298f, -0.01368789f, 0.15513338f, -0.02658959f, -0.04563383f, 
    -0.52328050f, -0.03914211f, -0.54070044f, -0.08048708f, 0.22097811f, -0.02535288f, 0.07734615f, 0.05264949f, 
    -0.10559146f, -0.00742461f, 0.21883121f, -0.11219494f, -0.07104054f, 0.27221936f, -0.24154508f, 0.21618420f, 
    -0.16085146f, -0.07865641f, 0.20138358f, -0.10539000f, -0.00603010f, 0.19696756f, 0.17021516f, 0.20890857f, 
    -0.33660045f, 0.01979367f, 0.11741165f, -0.09809145f, 0.02535205f, -0.01265659f, -0.09989334f, 0.12663716f, 
    -0.04129748f, -0.29806137f, -0.46267450f, -0.28241122f, 0.01145463f, 0.35457578f, -0.01364898f, 0.08391125f, 
    -0.05182328f, -0.06679399f, 0.01883432f, 0.07530883f, -0.03946777f, 0.19961421f, -0.10052337f, 0.25367326f, 
    0.58807003f, 0.43345183f, 0.27312085f, -0.20200050f, 0.02670537f, 0.02048653f, 0.18612039f, -0.03238099f, 
    -0.18123826f, -0.29863492f, -0.43738967f, -0.39395979f, 0.05957634f, 0.28013852f, -0.23367089f, -0.01736819f, 
    0.05623088f, -0.00388803f, 0.12897582f, 0.18256204f, -0.04834887f, -0.11242121f, 0.08125515f, 0.10823912f, 
    -0.38438213f, 0.04346083f, -0.47777534f, 0.15192865f, 0.08836237f, -0.05128606f, 0.00486331f, -0.09599734f, 
    0.02063557f, 0.12431099f, 0.17302288f, 0.05945040f, 0.16705407f, -0.18817215f, 0.17938854f, 0.06878715f, 
    -0.03688904f, 0.05814563f, 0.09324465f, 0.17649241f, -0.02294693f, -0.06830031f, 0.04934233f, -0.13298981f, 
    0.26561999f, 0.25886983f, 0.01509584f, 0.19286671f, -0.10061617f, 0.04615012f, -0.07982633f, 0.18655910f, 
    -0.07739235f, 0.12124714f, 0.09498303f, 0.00474761f, 0.10644799f, -0.23737429f, 0.13412303f, -0.33783647f, 
    0.04335311f, 0.13264745f, -0.17922023f, 0.10511970f, 0.00837262f, 0.02487384f, 0.07807948f, 0.06224912f, 
    0.33366540f, -0.02480955f, 0.11149918f, -0.02305313f, 0.07506219f, 0.15504371f, 0.13150267f, 0.07669573f, 
    0.15625712f, 0.08224132f, 0.12293883f, 0.14189652f, 0.44939786f, -0.35680470f, 0.28171721f, -0.02853116f, 
    0.00599131f, -0.04922416f, -0.04285898f, 0.09002263f, -0.17807540f, 0.00884664f, -0.04652451f, -0.12607554f, 
    0.52920711f, 0.37596217f, 0.29153520f, -0.23611559f, -0.01499075f, -0.06279647f, -0.13332506f, 0.05972623f, 
    -0.12436217f, 0.04849995f, -0.00597385f, -0.11951684f, -0.09544887f, 0.15563348f, -0.38523284f, -0.13310935f, 
    0.04668671f, -0.03474539f, 0.20258142f, 0.13675204f, -0.08951451f, -0.04080217f, 0.10224823f, -0.01348911f, 
    -0.39763841f, -0.49573502f, 0.06046383f, 0.22483984f, -0.16594151f, -0.00245582f, -0.27276722f, -0.24783516f, 
    -0.01062940f, -0.19296621f, 0.00832006f, 0.01091031f, -0.51297218f, -0.33814660f, 0.21797104f, -0.23820075f, 
    0.20808727f, -0.05465454f, -0.19560541f, -0.11820475f, -0.10887575f, -0.11735419f, 0.14750598f, -0.05658772f, 
    -0.12085336f, -0.21650615f, 0.17659821f, -0.78770888f, 0.05397288f, 0.05837264f, -0.06928113f, 0.05221537f, 
    -0.00650316f, 0.22553118f, 0.26479587f, 0.16552186f, 0.23081405f, -0.10998113f, 0.06432609f, -0.05619740f, 
    0.16285574f, -0.06832641f, -0.02765649f, 0.15945521f, -0.04793436f, 0.21531068f, 0.12758376f, -0.07162745f, 
    -0.33994952f, -0.01591105f, -0.17880149f, 0.61737800f, 0.09458791f, 0.04149375f, 0.04736476f, 0.06639733f, 
    -0.23242705f, -0.02370163f, 0.08093310f, -0.21724802f, 0.05625314f, 0.70137745f, -0.19103917f, 0.02496907f, 
    -0.09203895f, -0.20398037f, 0.11392963f, 0.15067577f, -0.00598023f, 0.04802228f, -0.01111643f, 0.05545288f, 
    -0.16522126f, -0.49636027f, 0.20852183f, 0.17634219f, -0.12282884f, -0.25726843f, 0.06358691f, -0.24631724f, 
    0.00345900f, -0.02909849f, -0.01824895f, -0.03557637f, -0.19575213f, -0.33682275f, 0.25351775f, -0.31308264f, 
    0.06841499f, 0.07504976f, 0.41108015f, -0.12229095f, -0.00690589f, 0.14902304f, 0.08018723f, 0.09781882f, 
    -0.80563980f, 0.56601119f, -0.40814266f, 0.24404505f, -0.07122863f, 0.15080710f, 0.18321133f, 0.22979841f, 
    -0.21210429f, 0.04606629f, -0.03979432f, 0.07876817f, 0.09801202f, 0.04669072f, -0.20451599f, -0.25295806f, 
    -0.23683967f, -0.00032609f, -0.12247548f, 0.00088514f, 0.00870241f, -0.02303340f, -0.02103021f, -0.04439886f, 
    0.13676359f, -0.04987509f, -0.00404147f, 0.15438908f, -0.13750032f, 0.19885623f, -0.04321240f, 0.24383759f, 
    -0.19338168f, -0.02032806f, -0.03622725f, -0.03090841f, -0.49475726f, -0.09905522f, 0.07683852f, -0.15069461f, 
    -0.19677021f, 0.04642826f, 0.09714287f, 0.12808706f, -0.22747295f, 0.05898319f, -0.13155520f, -0.23590018f, 
    -0.42562696f, 0.39532310f, -0.35004419f, 0.12844722f, 0.06717084f, 0.07633799f, -0.01631195f, -0.05854785f, 
    -0.09985834f, -0.00725658f, 0.19916962f, 0.17284897f, 0.53449982f, 0.07710994f, 0.17938884f, -0.17394182f, 
    0.01935884f, 0.25721666f, -0.21673284f, 0.07146743f, -0.14157131f, 0.15545964f, -0.04959501f, -0.07283778f, 
    -0.00999684f, -0.37648943f, 0.11935189f, -0.24346358f, 0.13874011f, 0.07839786f, 0.03483605f, 0.11287728f, 
    -0.24748598f, 0.00417276f, -0.19999085f, -0.55463696f, 0.24003392f, -0.54788762f, 0.02639303f, -0.09545447f, 
    0.02835372f, -0.14139703f, 0.17582607f, 0.03686620f, 0.07766829f, 0.10053687f, 0.04097649f, 0.10061938f, 
    0.20060776f, -0.05859443f, 0.35256189f, 0.05224414f, 0.24205637f, 0.07403847f, 0.02223743f, 0.10818409f, 
    -0.08064711f, -0.07034618f, 0.09462476f, 0.06348304f, -0.02519754f, -0.09297653f, -0.00158677f, -0.18673496f, 
    -0.01525841f, -0.01109986f, 0.05453711f, 0.08411963f, 0.12239828f, 0.00887872f, 0.01325369f, -0.09326667f, 
    -0.00292397f, 0.03947153f, -0.16009422f, 0.07757805f, 0.01106334f, -0.38155642f, 0.18084930f, -0.07866224f, 
    -0.02661390f, 0.01479606f, 0.04730826f, -0.14727010f, 0.18070726f, -0.28996032f, 0.18062297f, 0.29617134f, 
    -0.10145212f, 0.07758876f, 0.04206726f, 0.03240443f, -0.06862972f, -0.11598255f, 0.09441233f, -0.14475772f, 
    -0.45296612f, -0.31406471f, -0.42680517f, -0.36039853f, -0.04124356f, -0.01338767f, -0.03428639f, -0.06476369f, 
    -0.06133257f, 0.23183276f, 0.05055472f, -0.01143184f, 0.06013195f, -0.28921300f, 0.77712470f, 0.09039958f, 
    0.06888602f, -0.18872474f, 0.12314530f, -0.29367211f, 0.08126061f, -0.07582924f, -0.04222664f, -0.11537137f, 
    -0.43344644f, -0.39922702f, -0.02232517f, -0.15282167f, 0.06801736f, 0.02220760f, 0.05960719f, -0.08594651f, 
    -0.07779494f, 0.05671840f, 0.13622020f, -0.08554802f, -0.04018455f, -0.24528059f, 0.27733892f, 0.13661014f, 
    -0.01649215f, -0.08102621f, 0.08367570f, -0.27008086f, -0.00114789f, -0.04051839f, -0.05172260f, -0.19450222f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.19626966f, 0.20034204f, 0.12765814f, -0.17460902f, -0.11711845f, 0.10384691f, 0.03481632f, -0.18658322f, 
    0.03013783f, -0.04310424f, 0.08399728f, -0.04227257f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
