#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.21749157f, 0.15040070f, 0.33875367f, 0.18890056f, 0.16679648f, 0.12384111f, -0.51842028f, -1.26182079f, 
    -0.91157889f, -0.59684014f, 1.08239782f, 0.19101052f, -0.73266405f, -0.86683935f, -0.82250011f, 0.46640775f, 
    0.29818094f, 0.98667997f, 1.32776833f, 0.11840934f, 0.95146841f, -0.60734719f, 0.46991989f, 0.16680433f, 
    0.50343740f, 0.74392176f, 0.06304384f, -1.54407692f, -0.41733074f, -0.43473694f, -0.36748368f, -0.33729386f, 
    -0.73027200f, -0.48729795f, 0.99655718f, -0.52961880f, 0.99353898f, -0.22876592f, -0.08158503f, 0.76028508f, 
    0.68613929f, 0.85354376f, -0.25241247f, 0.78589672f, -0.33504269f, -1.27373469f, -0.25587082f, -1.43689013f, 
    -0.19135301f, -0.64153290f, 0.60228461f, 0.57349062f, 0.02113971f, -0.13131036f, 0.45832545f, 0.00546831f, 
    0.24942587f, 0.08230144f, 0.64201111f, 0.47482127f, -0.24064338f, -0.70737958f, 1.35198855f, -0.32643864f, 
    -0.78794402f, 0.35611126f, -0.93098319f, -0.36568758f, -0.83181292f, 0.33367118f, -0.74489331f, -0.78318208f, 
    -0.04202366f, -0.17489360f, -0.14290598f, 0.35745218f, -0.59437609f, -0.72410995f, 0.49123162f, -0.56069601f, 
    0.50723165f, -1.55790401f, -0.86455780f, 0.46508178f, 1.18562818f, 0.37470704f, -0.06442112f, 0.19883886f, 
    0.02022135f, 0.44592631f, -1.39325774f, -0.36477783f, 1.59761214f, -0.68504733f, -0.38092485f, 0.90151674f, 
    0.28019056f, 0.21412954f, -0.17050643f, -1.17482853f, -0.61761773f, -0.74411768f, 0.53410745f, 0.75109023f, 
    -0.00466117f, -0.67134458f, -0.93868756f, -0.53388345f, 1.69701135f, 0.03529400f, -0.65210080f, -0.50408036f, 
    0.09127794f, -0.35403517f, -0.33784971f, 0.22394854f, -0.00432959f, -0.42896441f, 0.44856676f, 0.93138558f, 
    -0.54573977f, 0.00837618f, 0.69345951f, -0.50911397f, -0.71333957f, 0.19973554f, -0.29464647f, 0.30365682f, 
    0.45128146f, -0.50987613f, -1.96181810f, -1.37555206f, 0.01075866f, 0.04601742f, -0.16119079f, -0.13434680f, 
    -0.09487352f, -0.99371159f, -1.11531043f, -1.02758563f, -0.29725227f, -0.46716684f, -0.94340521f, -0.48890844f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.26535943f, 0.11000469f, 0.64257848f, -0.26663849f, 0.55410039f, 1.19266307f, 0.36668229f, 0.62957114f, 
    1.23724794f, 0.18240511f, -0.09942964f, 0.24385312f, 0.26365763f, 0.27826405f, -0.10447389f, -0.61947173f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.22131413f, 0.15432470f, 0.13236280f, -0.21933380f, -0.12179904f, -0.08700953f, 0.01543264f, -0.10207649f, 
    0.19462167f, 0.01467999f, -0.38464704f, 0.09234159f, -0.01055251f, -0.28121969f, -0.06229290f, 0.17723104f, 
    0.18173791f, 0.14613403f, 0.68938994f, 0.46613526f, 0.08887196f, -0.34101433f, 0.03078611f, -0.20135765f, 
    0.07953066f, 0.13899402f, 0.11932593f, 0.33354619f, 0.19577713f, -0.09472875f, 0.00978124f, -0.09741493f, 
    -0.33619687f, 0.10125009f, -0.06695876f, -0.09190951f, -0.04061495f, 0.00314499f, -0.08780392f, -0.06264017f, 
    0.02838860f, -0.12286013f, -0.01385089f, 0.09970252f, 0.02707317f, -0.00326891f, -0.47715855f, -0.05099990f, 
    -0.00592356f, 0.04016836f, -0.08064717f, 0.21761343f, 0.03502403f, 0.14694296f, 0.24410094f, 0.18496661f, 
    0.21564139f, 0.05503337f, -0.03683083f, -0.29725346f, 0.11231676f, -0.04163200f, 0.11400896f, 0.22087856f, 
    -0.06002339f, -0.28797024f, -0.09341244f, 0.02389674f, 0.23163596f, 0.08697739f, -0.05554378f, 0.15239619f, 
    -0.36454672f, 0.00472405f, 0.13245770f, 0.16832043f, -0.06376676f, -0.06283023f, 0.16839172f, 0.21381082f, 
    0.21137141f, -0.43300021f, -0.81407988f, -0.93692839f, -0.27073359f, 0.06821105f, 0.05648422f, 0.11095735f, 
    -0.18775058f, 0.14166310f, -0.14521587f, -0.98792559f, -0.55698240f, 0.12315910f, 0.21044886f, 0.40425488f, 
    0.06405831f, 0.09050355f, -0.00256045f, 0.31053755f, -0.16256306f, -0.53934830f, -0.09318218f, 0.07942491f, 
    0.07204627f, -0.00687548f, -0.11093890f, -0.05254078f, 0.67975897f, 0.05578081f, -0.05758754f, -0.16518621f, 
    0.17990108f, 0.04962765f, -0.07423546f, -0.06747561f, -0.19018097f, 0.03349681f, 0.05842652f, 0.59767145f, 
    0.02769524f, -0.04321583f, -0.21713914f, -0.02215614f, 0.04075327f, 0.11926413f, 0.15727933f, 0.40471560f, 
    0.26851451f, -0.18649180f, -0.10174903f, -0.07678588f, -0.06232113f, 0.02965652f, 0.08144345f, 0.08309809f, 
    0.33831087f, -0.30285618f, -0.24987772f, -0.42516220f, -0.05990799f, 0.17079026f, -0.00228393f, 0.06425774f, 
    0.16553807f, 0.23416637f, 0.13923605f, -0.14270233f, 0.01835318f, 0.02041445f, 0.13624169f, 0.36634722f, 
    0.06347595f, 0.14721082f, -0.35107473f, -0.21114147f, 0.06592011f, -0.19763783f, -0.35213539f, 0.03555717f, 
    0.06679130f, -0.09023195f, -0.10054772f, 0.01430399f, 0.02912562f, 0.12310412f, -0.22470728f, -0.06665356f, 
    0.05897334f, -0.15774813f, 0.15805456f, -0.12801133f, -0.23288201f, -0.15745151f, 0.31131271f, -0.02915824f, 
    -0.12647353f, -0.02185923f, -0.08372970f, -0.00732870f, -0.19857250f, 0.14988403f, 0.19770025f, 0.01013350f, 
    -0.09659314f, -0.13371974f, -0.08157624f, 0.07465148f, 0.35247526f, -0.20593855f, -0.20558591f, 0.24022807f, 
    0.17361018f, 0.24134533f, 0.07955724f, -0.09223204f, -0.05575486f, 0.22820610f, 0.02853501f, 0.13117693f, 
    0.03260090f, 0.04272011f, 0.01189800f, -0.01402127f, -0.09130588f, 0.11703687f, 0.30193022f, -0.30781341f, 
    0.05336589f, 0.45690364f, 0.00520746f, -0.05981713f, -0.03287243f, -0.02743133f, 0.19453812f, 0.22045520f, 
    -0.03268592f, 0.08971513f, 0.15242438f, 0.20084301f, 0.27062863f, -0.03916049f, 0.39576554f, 0.13374661f, 
    0.19621342f, -0.23580085f, -0.39525568f, -0.09437135f, -0.24211371f, -0.02214289f, 0.00596642f, -0.03402282f, 
    0.15598528f, 0.04035798f, 1.23308492f, -0.23009680f, -1.11440420f, -0.20437907f, -0.45832291f, -0.24007265f, 
    0.14205588f, -0.04894601f, 0.00128749f, -0.44548374f, 0.23586294f, -0.01888990f, -0.03034048f, 0.05496405f, 
    0.19928773f, -0.11426935f, -0.06833447f, 0.07602920f, 0.03975658f, 0.05500520f, -0.25746775f, -0.17453945f, 
    -0.11210977f, -0.04573025f, 0.04919603f, 0.16734248f, -0.17177710f, 0.24868399f, 0.16592939f, 0.06355222f, 
    0.00344040f, -0.02018815f, -0.02822351f, -0.18534179f, -0.02455906f, 0.07332550f, -0.03056255f, 0.07730035f, 
    0.78925776f, 0.06512561f, -0.11087205f, -0.28654778f, -0.20413457f, 0.04260398f, -0.28590605f, -0.09117802f, 
    -0.27889022f, -0.15513819f, 0.10690071f, -0.07009150f, 0.00919746f, -0.02704601f, 0.07229359f, -0.04809409f, 
    -0.21697654f, 0.04697865f, -0.08941107f, -0.03244160f, 0.05885658f, 0.09423940f, 0.00273008f, 0.21523035f, 
    0.65875041f, -0.19008711f, -1.02603531f, -0.43603253f, -0.11264241f, 0.07678048f, -0.09560674f, 0.18534119f, 
    -0.21166055f, -0.14681359f, 0.32586423f, -0.07945435f, -0.21280769f, -0.00346266f, 0.05766479f, -0.02105602f, 
    -0.15564796f, -0.00248858f, -0.09754075f, -0.90953332f, -0.25072458f, 0.55278796f, 0.06779683f, -0.02437920f, 
    -0.09691339f, 0.02591012f, -0.07369185f, 0.11509685f, -0.29329431f, 0.26288322f, -0.07729492f, -0.28908953f, 
    0.15470377f, 0.06760354f, 0.18373947f, 0.29491171f, 0.37172744f, -0.33623365f, 0.60252553f, 0.79042596f, 
    -0.01620011f, 0.20534386f, 0.27057216f, 0.18686140f, 0.12404811f, 0.13013186f, 0.05898241f, 0.09005588f, 
    -0.11601565f, -0.04613310f, -0.18887062f, 0.06293687f, 0.36689496f, 0.30364984f, 0.16678429f, -0.27067947f, 
    -0.80688173f, -0.79296374f, 0.11634520f, 0.17175119f, 0.11978095f, -0.08152708f, -0.06466658f, -0.08650085f, 
    0.30066183f, 0.19737636f, 0.47773612f, 0.16140652f, 0.18938805f, 0.00625317f, 0.67018920f, 0.23357885f, 
    0.41233557f, -0.93524921f, 0.49156663f, 0.90777183f, -0.02596582f, -0.09118880f, -0.05681581f, 0.13985297f, 
    -0.05605027f, 0.12093998f, -0.20910996f, -0.32504246f, -0.48044541f, -0.35755351f, -0.24611276f, -0.28991809f, 
    0.22424050f, -0.19545601f, 0.12980217f, 0.01688972f, -0.03857345f, 0.02293304f, -0.06840660f, -0.20321114f, 
    0.24410959f, 0.16362908f, 0.21367840f, 0.45861658f, 0.89267987f, 0.15740231f, -0.78164214f, 0.05809665f, 
    0.19062065f, -0.04942985f, 0.20888332f, -0.26049650f, 0.06866404f, -0.12801574f, 0.14795391f, 0.01747615f, 
    0.00510209f, 0.17228998f, 0.02274643f, -0.12051322f, 0.23053053f, 0.27421185f, -0.87881535f, -0.85596365f, 
    -1.46006334f, 0.03245349f, -0.06051885f, -0.29830089f, 0.27302727f, -0.27547276f, 0.16811879f, -0.01860091f, 
    -0.59055555f, -0.51730072f, -0.15819767f, -0.16909158f, -0.07011319f, 0.03864458f, -0.17586650f, -0.06281175f, 
    -0.13124861f, -0.30375111f, -0.07363866f, -0.01170393f, -0.00378143f, 0.34556013f, 0.06700195f, -0.43130580f, 
    -0.73912930f, 0.00061790f, 0.02683217f, 0.40906867f, 0.25124100f, 0.15361784f, 0.10734642f, 0.14336616f, 
    0.28707063f, 0.23343043f, -0.45234591f, -0.40611961f, -0.12765720f, 0.08858032f, -0.16348691f, 0.24201307f, 
    -0.14422728f, 0.16238205f, 0.04324848f, -0.47570777f, -0.06790601f, 0.33309767f, -0.10985021f, -0.02000265f, 
    -0.07182092f, 0.02001490f, 0.08800524f, -0.21973154f, -0.08658956f, -0.26581347f, -0.21543208f, 0.11115392f, 
    -0.03855441f, 0.08211253f, -0.04182340f, -0.07415733f, -0.21862477f, -0.02295844f, 0.45053896f, 0.14153124f, 
    -0.18854259f, -0.08875852f, -0.01358932f, 0.13014786f, -0.03433416f, -0.08554382f, -0.21799542f, -0.15514141f, 
    -0.05416340f, -0.57906425f, -0.04473258f, -0.30556598f, 0.29386812f, 0.07568694f, 0.24869068f, -0.15456650f, 
    0.17252226f, 0.11123361f, 0.11613102f, 0.15718701f, 0.27305761f, 0.17849645f, 0.02313233f, -0.45640093f, 
    0.32053205f, 0.43841136f, 0.40922365f, 0.17319298f, 0.27425209f, -0.15113276f, 0.19517921f, 0.28472823f, 
    0.09931123f, -0.04802861f, 0.20439312f, 0.14763348f, 0.22646987f, 0.07983508f, -0.02768485f, 0.14362949f, 
    0.06899955f, 0.08109604f, -0.33970886f, -0.10739353f, 0.28854612f, -0.00108471f, -0.02595202f, 0.13330741f, 
    -0.02902509f, 0.10223927f, 0.09751385f, -0.55714262f, 0.08813281f, 0.18932590f, 0.14395298f, -0.33057442f, 
    -0.33777362f, -0.14162648f, -0.42462042f, -0.12984924f, 0.21577610f, -0.87499821f, -0.66871995f, 0.02054386f, 
    0.26051891f, -0.04539408f, -0.26120850f, 0.31352824f, 0.13968658f, -0.08285803f, -0.22073554f, 0.01474070f, 
    -0.07897564f, 0.02042877f, 0.00954520f, 0.00588487f, -0.08522949f, 0.04977925f, -0.14906101f, -0.17274779f, 
    -0.01718857f, 0.02576252f, 0.02419294f, 0.15091975f, 0.08572836f, 0.18769807f, -0.24776131f, -0.09365118f, 
    0.01665534f, 0.01267959f, 0.03427121f, 0.09860495f, 0.05656317f, 0.02770414f, 0.07743683f, -0.31271824f, 
    -0.15939629f, 0.00456851f, -0.06880169f, -0.14887683f, -0.27893689f, -0.17975558f, -0.20329231f, 0.14522250f, 
    0.06754522f, -0.49353719f, -0.86363047f, 0.51772720f, 0.01795010f, 0.23340344f, 0.12364791f, 0.05960064f, 
    -0.07806451f, 0.22103652f, 0.20169307f, -0.35901719f, 0.05595740f, -0.00396483f, 0.07860073f, -0.13401984f, 
    0.39870331f, 0.05006962f, 0.16301095f, 0.85111284f, 0.04851722f, 0.49892753f, 0.10817628f, -0.09966187f, 
    -0.06909557f, 0.10995519f, -0.18865618f, 0.21850401f, 0.17093872f, 0.16580845f, 0.04911902f, 0.11251220f, 
    0.09494464f, -0.04032584f, 0.09474327f, -0.26748535f, 0.03767258f, 0.39503881f, -0.09357630f, -1.21781528f, 
    -0.00586110f, 0.16522190f, -0.00509192f, -0.01486243f, 0.20078728f, -0.12983975f, 0.09073635f, 0.13430917f, 
    -0.08343680f, 0.08256742f, 0.03576626f, 0.08303813f, 0.07827431f, -0.07091644f, -0.18153280f, -0.12567395f, 
    -0.23438850f, -0.37740240f, -0.02102786f, 0.02012276f, 0.04582293f, 0.22530665f, 0.06757222f, -0.17673336f, 
    -0.13336115f, 0.30877307f, 0.42685735f, 0.07219749f, 0.08226357f, 0.19074109f, 0.12450103f, 0.29668143f, 
    -0.07621849f, 0.09952013f, 0.34109601f, -0.65608543f, -0.25986639f, 0.10707369f, -0.02261188f, 0.15901726f, 
    -0.00523428f, -0.00209193f, -0.07508579f, -0.13665371f, -0.25090212f, 0.03182196f, -0.13559954f, -0.13344179f, 
    -0.09025467f, 0.20277147f, 0.05102208f, 0.04025389f, -0.16118129f, -0.19901526f, 0.02083997f, 0.15035778f, 
    -0.03041171f, 0.04386645f, 0.03701113f, -0.02540492f, 0.00884001f, -0.30895698f, -0.13321567f, 0.07442306f, 
    -0.28042811f, 0.21919712f, 0.09207893f, 0.12099915f, 0.22294787f, 0.08872302f, -0.08607198f, -0.34704447f, 
    -0.03229443f, -0.03063214f, -0.35833743f, 0.08752415f, -0.07912846f, 0.18446125f, -0.28549001f, -0.46512440f, 
    0.26628181f, 0.05263167f, 0.01722619f, -0.04743272f, -0.08063109f, -0.15156034f, 0.08280481f, -0.00560289f, 
    -0.49441841f, -0.75564820f, 0.05620694f, -0.10576516f, 0.10818814f, -0.03297086f, 0.08700703f, -0.11188995f, 
    -0.29053098f, -0.12985700f, 0.09072869f, -0.01817253f, 0.02807973f, 0.03055790f, -0.40268606f, -0.05802077f, 
    -0.26225936f, 0.22630043f, 0.12439947f, -0.03706409f, -0.09078017f, 0.11709346f, -0.02884665f, 0.15436988f, 
    0.34294683f, 0.12132625f, -0.24220958f, 0.15141842f, 0.08530971f, -0.24592067f, 0.17156738f, 0.05317485f, 
    0.22021699f, 0.11334015f, 0.10952647f, 0.75785100f, 0.22119644f, -0.32657179f, 0.03815758f, 0.07880654f, 
    -0.12696742f, 0.17527133f, -0.01243173f, 0.18992899f, 0.03647069f, 0.04874571f, 0.23269245f, -0.16591895f, 
    -0.13933277f, -0.39009401f, -0.06497863f, -0.19686188f, -0.01031122f, 0.08275469f, 0.03051573f, -0.15738645f, 
    -0.06018064f, -0.27279294f, 0.02634730f, -0.05520622f, 0.00976514f, -0.03639643f, 0.00342910f, 0.15604354f, 
    0.20571359f, -0.09181879f, -0.10559624f, -0.14783064f, 0.23490380f, -0.17588563f, 0.16558574f, 0.23012395f, 
    0.08688470f, -0.25527334f, 0.03083637f, -0.07231190f, 0.03853396f, -0.07315474f, -0.10641973f, 0.10629036f, 
    0.05494920f, 0.02594407f, -0.18782237f, 0.08831833f, -0.05159556f, 0.05502358f, -0.02453514f, 0.08133531f, 
    0.19115192f, 0.53399152f, -0.39326543f, -0.56723803f, -0.22942452f, 0.11666322f, -0.36683971f, 0.11439571f, 
    0.05296562f, 0.03561943f, 1.02073228f, 0.48610881f, -0.34925947f, -0.29717767f, 0.17749375f, -0.14707275f, 
    0.04789166f, -0.00420880f, -0.21429212f, 0.43145406f, -0.20396104f, -0.05256261f, 0.05604134f, -0.18809517f, 
    -0.03041757f, -0.07067791f, -0.00733852f, -0.26291841f, -0.52227426f, -0.70197624f, 0.52664113f, -0.26268730f, 
    -0.06843629f, 0.05269966f, 0.03893067f, -0.17014812f, 0.20294064f, -0.21350458f, -0.04196550f, -0.01978784f, 
    -0.04053656f, 0.01861357f, 0.10834448f, 0.04714990f, 0.00043214f, 0.17487334f, 0.31276006f, 0.24211630f, 
    -0.15781762f, -0.02554538f, -0.08922050f, 0.18594724f, -0.05312990f, 0.12259342f, -0.19783038f, 0.31499082f, 
    0.36468625f, -0.27002636f, 0.11661003f, -0.17098825f, -0.02861008f, -0.10494548f, 0.04751991f, -0.24675295f, 
    0.19500440f, -0.24501450f, -0.01383857f, -0.02866782f, -0.08641848f, 0.03263906f, -0.06138448f, -0.28810337f, 
    0.01223034f, -0.32798624f, 0.73736751f, -0.44130510f, -0.18254429f, 0.08278762f, -0.18166876f, 0.08159233f, 
    -0.04862990f, -0.09962871f, -0.01551191f, -0.02316374f, -0.07265217f, 0.06458389f, 0.17432082f, 0.35558385f, 
    0.17844856f, 0.18253674f, -0.02806361f, -0.21871957f, 0.39335451f, -0.01144332f, 0.10512403f, 0.11545663f, 
    0.41001639f, 0.12101920f, 0.09372722f, 0.02120274f, 0.06675972f, 0.21622428f, 0.33723962f, -0.11536573f, 
    -0.24113522f, -0.14770694f, 0.26510710f, 0.27360159f, 0.13042173f, -0.26609462f, 0.12740660f, 0.72555292f, 
    0.27013683f, -0.03502287f, 0.23309878f, 0.18569872f, -0.08293884f, 0.03780010f, -0.00283661f, 0.26844639f, 
    0.16417424f, 0.08050423f, -0.23332183f, 0.03232855f, 0.08511092f, 0.02433041f, 0.31242913f, 0.01714816f, 
    -0.43693036f, 0.37146619f, 0.17239152f, -0.28633478f, -0.03001992f, 0.11368359f, 0.09120683f, 0.03928733f, 
    0.38789785f, 0.28958315f, 0.44781008f, -0.25280565f, 0.11042553f, -0.10998502f, 0.18659978f, 0.06934159f, 
    0.16807885f, -0.28905797f, -0.08911228f, -0.24028237f, -0.29565763f, 0.02193418f, -0.81460178f, -0.08598544f, 
    -0.27223289f, -0.09276415f, -0.76255870f, 0.22582404f, -0.17327043f, -0.37412548f, -0.02704661f, -0.19106235f, 
    -0.00847871f, 0.02705425f, -0.02995233f, 0.05536771f, -0.04082359f, -0.12524177f, -0.14560954f, -0.17272139f, 
    -0.15939739f, -0.04673208f, -0.03225810f, 0.34187666f, -0.00280122f, -0.10550711f, 0.47658747f, -0.25455758f, 
    -0.15584660f, 0.48315004f, 0.00106798f, 0.18022422f, -0.13798240f, -0.89913744f, 0.17391361f, -0.36232328f, 
    0.05728702f, -0.16925718f, 0.15393616f, -0.13717176f, -0.15422153f, 0.21401954f, 0.23595789f, 0.09946167f, 
    -0.42036095f, -0.11770751f, 0.00226744f, -0.18243006f, 0.01716505f, 0.07920238f, 0.12593815f, -0.01579863f, 
    -0.74939883f, 0.16325539f, -0.06729474f, 0.01362737f, -0.06001999f, -0.01457046f, 0.19776393f, 0.03675518f, 
    0.17937127f, 0.20173457f, 0.20820014f, 0.14595850f, 0.02870833f, -0.16923529f, 0.41780728f, 0.72808182f, 
    0.33635280f, 0.17630954f, -0.09335104f, 0.18216680f, 0.24445489f, 0.00284081f, 0.08017273f, -0.24710251f, 
    -0.15182723f, -0.59931028f, 0.30667302f, 0.22209555f, 0.01644300f, -0.03838891f, 0.00186864f, 0.04719258f, 
    -0.08007397f, -0.26708630f, 0.01345314f, -0.18263043f, -0.47432670f, -0.69411629f, 0.11921659f, -0.11774368f, 
    -0.06569628f, -0.03701235f, -0.20890599f, -0.14958203f, 0.03022330f, 0.14026906f, 0.01520327f, -0.06599152f, 
    0.04548626f, 0.04527095f, 0.33581424f, -0.07547915f, 0.04590380f, -0.08469462f, -0.28251082f, -0.12760627f, 
    0.13674721f, 0.12640643f, 0.04572266f, -0.13495493f, 0.21201570f, 0.04828086f, 0.22466508f, 0.06772976f, 
    -0.02935942f, -0.03532099f, 0.13575536f, 0.05131565f, 0.13117005f, 0.01187828f, -0.18613482f, -0.35268024f, 
    -0.47530529f, 0.22897588f, 0.07064420f, -0.06957281f, 0.18404278f, 0.23428936f, -0.14988615f, 0.56633437f, 
    -0.54371095f, 0.26081756f, 0.32036054f, 0.25640067f, 0.22947530f, 0.16810559f, -0.04814220f, -0.13430956f, 
    -0.63167161f, 0.00459542f, -0.11327271f, -0.09232131f, 0.13702106f, 0.17602594f, 0.36432886f, 0.06774413f, 
    0.09841062f, 0.08857094f, 0.28652179f, 0.40046829f, 0.32209054f, 0.06863843f, 0.55889136f, 0.27008724f, 
    -0.04604012f, 0.08655656f, -0.05801194f, -0.16933282f, -0.43410403f, -0.26956981f, -0.22112364f, -0.11721894f, 
    0.22734843f, 0.10597392f, 0.14912489f, 0.76272577f, 0.01686149f, 0.49295473f, 0.42933735f, 0.06063469f, 
    0.19937946f, 0.21761200f, 0.09228594f, 0.32240108f, -0.01626248f, 0.09897781f, 0.15788220f, 0.12756190f, 
    0.20006344f, 0.09912085f, 0.01481932f, 0.26296124f, 0.07272860f, -0.34725785f, 0.22503130f, 0.65167868f, 
    0.40946344f, 0.18627462f, -0.04012105f, 0.00894331f, -0.01403029f, -0.27612245f, 0.02922460f, -0.28795880f, 
    -0.32210299f, -0.22102265f, -0.11340132f, 0.14080638f, -0.04834359f, -0.16226234f, -0.25180632f, 0.33320111f, 
    -0.27166265f, 0.07730700f, -0.08711364f, -0.18912649f, 0.05749907f, -0.19768709f, 0.08786625f, -0.05765439f, 
    -0.07653489f, -0.68306762f, -0.02930267f, -0.22348906f, -0.18379824f, -0.25571889f, 0.07492670f, 0.05124335f, 
    0.05521581f, 0.00751491f, 0.08690193f, 0.26499811f, 0.37243253f, -0.16188040f, -0.12062243f, -0.11526094f, 
    -0.08649716f, 0.20809440f, 0.35421941f, -0.27136779f, 0.03355060f, 0.88438827f, -0.02461408f, -0.09342840f, 
    -0.01560083f, 0.07020019f, -0.00388007f, 0.27888718f, 0.05573561f, -0.18033241f, 0.12610213f, -0.17585440f, 
    -0.14678505f, -0.11790533f, -0.00559548f, 0.00481504f, 0.20371652f, -0.04063922f, 0.43109930f, 0.10709267f, 
    -0.21246053f, 0.18905939f, 0.41753495f, 0.08056009f, 0.19229896f, 0.17771843f, -0.13089572f, -0.04576674f, 
    -0.09264114f, -0.10545600f, 0.09801757f, 0.10130558f, 0.17188707f, 0.13889462f, 0.09129313f, 0.00845128f, 
    0.24043059f, 0.02603458f, -0.01728888f, 0.06624921f, -0.00197634f, -0.09642147f, 0.07904188f, 0.05233638f, 
    -0.07559624f, 0.42649508f, 0.60231006f, 0.19005509f, -0.02502608f, 0.17735639f, 0.29313684f, 0.20877583f, 
    0.51332486f, -0.56137598f, -0.11978617f, -0.03796438f, -0.01727024f, -0.08282494f, -0.03380795f, -0.02644026f, 
    0.03328660f, -0.16325444f, 0.26462653f, 0.10668004f, -0.18709889f, -0.12163743f, 0.02974080f, 0.16209544f, 
    -0.12700912f, 0.21980105f, 0.03556614f, -0.32357997f, 0.29017475f, 0.15814990f, -0.02754754f, 0.22200942f, 
    -0.14691786f, 0.09100255f, -0.03696077f, -0.06221381f, 0.30249473f, -0.04404436f, 0.60755593f, -0.12268729f, 
    0.06780622f, 0.10925265f, -0.13566546f, 0.21910112f, 0.05736933f, -0.14802246f, 0.09644751f, -0.18965343f, 
    -0.10951982f, 0.06720894f, -0.34923428f, 0.11864089f, -0.02610861f, -0.07470203f, -1.09257114f, -0.71478331f, 
    -0.15950501f, -0.04207895f, -0.30891097f, -0.58284569f, -0.11545361f, 0.01790988f, 0.00380207f, -0.24425776f, 
    -0.02626341f, -0.54868901f, -0.04809934f, -0.05984706f, -0.25801662f, -0.07994951f, -0.09649660f, -0.08719043f, 
    -0.06902720f, -0.11407224f, -0.19603162f, 0.11409261f, 0.12027636f, 0.04162271f, -0.10195968f, -0.58702320f, 
    -0.48506629f, -0.02113341f, -0.04279132f, 0.52024376f, -0.09338418f, 0.11330874f, 0.25158039f, 0.11606241f, 
    0.08155514f, 0.30539185f, -0.46148425f, -0.13365005f, 0.13159987f, -0.23404340f, 0.34537953f, 0.15705308f, 
    0.08767149f, 0.12093264f, 0.20527595f, 0.53584814f, 0.15442720f, 0.75154567f, 0.12130767f, 0.27233747f, 
    -0.07695156f, -0.02469368f, 0.03367222f, 0.24893177f, -0.09677467f, -0.23944728f, 0.11026186f, -0.00775190f, 
    -0.10199761f, 0.06532104f, -0.01232738f, -0.14126562f, -0.09940492f, 0.34385034f, -0.05561929f, 0.55865288f, 
    -0.10566281f, -0.21916047f, 0.11059780f, 0.00398767f, 0.03187671f, -0.07064124f, -0.10842988f, -0.26792714f, 
    0.26951438f, -0.23674758f, -0.02051945f, -0.15192848f, 0.11115979f, -0.13834602f, 0.47359541f, -0.07960805f, 
    0.17227370f, -0.03110283f, 0.11583688f, -0.11844957f, -0.11612985f, -0.09355068f, -0.07459341f, -0.16291563f, 
    -0.02456045f, -0.05226791f, -0.02731317f, -0.03148098f, -0.06577262f, -0.00434164f, 0.06409671f, 0.01944469f, 
    0.13895220f, 0.78536898f, 0.15910974f, 0.27243724f, 0.04618206f, 0.14337128f, 0.04519905f, -0.07322683f, 
    0.08604947f, -0.20353247f, 0.06112599f, 0.88253033f, 0.51826769f, -0.12594542f, -0.36200449f, 0.09118116f, 
    0.12332187f, 0.21306056f, -0.02102589f, 0.14235969f, 0.15783839f, 0.07417880f, 0.17821868f, 0.18916252f, 
    -0.21212919f, -0.05221061f, -0.09999234f, -0.14717796f, -0.46553534f, -0.44110641f, 0.57295960f, -0.24140359f, 
    0.19832654f, 0.11330505f, -0.51777786f, -0.01436614f, 0.00226308f, -0.06583788f, -0.14395122f, 0.09223185f, 
    -0.03860259f, -0.04112742f, 0.07110910f, 0.21398135f, 0.13060082f, -0.49528900f, -0.58091933f, -0.06506789f, 
    -0.14162938f, 0.06354350f, 0.18172514f, 0.19601120f, -0.21356001f, -0.02984841f, -0.04598088f, 0.04638953f, 
    0.07081651f, 0.16230159f, 0.28984225f, 0.06339361f, -0.02168725f, -0.13212731f, 0.08758569f, -0.18526287f, 
    0.20307702f, 0.01885938f, -0.07249511f, 0.10441644f, 0.22316761f, 0.25996256f, 0.09834718f, 0.39781463f, 
    0.13028860f, 0.71354711f, 0.32098126f, 0.42382717f, -0.26521936f, -0.09886424f, 0.08633637f, -0.24590170f, 
    -0.25333259f, -0.18915819f, -0.25665689f, -0.64317608f, -0.78240806f, 0.11009118f, -0.00663380f, -0.21208976f, 
    0.17769860f, -0.08177882f, 0.02353580f, 0.21001384f, -0.37429011f, 0.19697504f, 0.44137818f, 0.01087537f, 
    -0.10451373f, 0.16361988f, -0.26436469f, 0.07867136f, -0.03792146f, -0.36551830f, -0.81082648f, 0.12169808f, 
    0.02339704f, 0.27037480f, 0.08402881f, 0.06179463f, 0.16721117f, -0.07032395f, 0.16645670f, 0.04845627f, 
    0.13856858f, 0.26272503f, -0.00812077f, 0.02268975f, 0.11537146f, 0.05490433f, -0.02272190f, -0.82607871f, 
    -0.49735749f, 0.23114358f, 0.13942401f, 0.05666730f, -0.06200163f, 0.04909351f, -0.01338880f, 0.01234578f, 
    0.34174067f, 0.36908278f, -0.20349789f, 0.01024633f, 0.01598347f, 0.16636755f, -0.04845145f, -0.10645221f, 
    0.41331056f, 0.37508747f, 0.08884522f, -0.13754639f, 0.05532566f, -0.16804105f, -0.04347825f, -0.03668350f, 
    -0.28298885f, -0.45054030f, -0.22393343f, 0.40850398f, 0.26655644f, 0.19548619f, -0.09453489f, 0.11215906f, 
    -0.00737888f, 0.11327063f, 0.47376546f, -0.24449357f, -0.78082865f, 0.09295116f, -0.06257814f, -0.36026761f, 
    -0.16695175f, 0.21648967f, 0.10341293f, 0.11354628f, -0.34506571f, -0.02279262f, 0.04133316f, 0.08727618f, 
    0.06513243f, 0.10076106f, 0.15798479f, 0.23697786f, -0.77242589f, -0.24338523f, -0.71220362f, -0.26392040f, 
    -0.09701019f, -0.24619618f, 0.30504474f, -0.04935322f, -0.11307901f, 0.08863635f, -0.04837576f, -0.76952940f, 
    0.40663102f, 0.02339959f, -0.06174331f, 0.15805402f, 0.18762209f, -0.01112625f, 0.25397021f, 0.15918849f, 
    0.76019549f, -0.20349507f, -0.00343111f, 0.06854745f, -0.26422897f, -0.13941424f, -0.12332481f, 0.14542641f, 
    0.22139037f, 0.13163425f, 0.27660495f, -0.00967762f, 0.04765314f, -0.01602899f, -0.03677318f, -0.23049207f, 
    0.46476054f, -0.20378645f, 0.18954985f, -0.00026051f, -0.06981257f, 0.05632336f, 0.06451306f, -0.09498075f, 
    0.04846274f, -0.12837435f, -0.42611766f, -0.06466120f, -0.17523251f, 0.00049068f, -0.25355655f, -0.09127633f, 
    0.01504220f, -0.04792148f, 0.09554259f, -0.05231192f, -0.02642382f, 0.14179383f, -0.00521787f, -0.04725133f, 
    0.07761924f, 0.10715848f, 0.02185079f, 0.14211819f, 0.45484343f, 0.34914064f, -0.31990451f, 0.25322756f, 
    -0.22980560f, -0.07186263f, 0.12496184f, -0.07782884f, 0.57023233f, 0.23880453f, 0.16087429f, -0.14102240f, 
    -0.14366607f, -0.32341453f, 0.19928081f, 0.23237008f, 0.17578386f, -0.08553048f, 0.39889148f, 0.11660768f, 
    -0.05855048f, -0.01870286f, 0.08660503f, -0.10821843f, 0.03895124f, 0.00705268f, -0.00902322f, 0.06001387f, 
    0.48820674f, -0.23202124f, 0.09889133f, -0.18035151f, 0.11798463f, -0.04280693f, 0.21754242f, 0.55983895f, 
    0.16097386f, -0.09174428f, 0.13839795f, -0.00969331f, 0.08908343f, -0.02980046f, 0.00751505f, -0.02461271f, 
    0.08147202f, 0.17595600f, 0.02815886f, 0.00046917f, 0.05549803f, 0.07781812f, -0.01949902f, 0.04919535f, 
    0.00989335f, 0.36011204f, -0.18531774f, -0.33662736f, -0.17666815f, -0.39539203f, 0.22296306f, 0.13023965f, 
    0.26256973f, 0.04918641f, -0.36422148f, -0.94073373f, 0.00749979f, -0.43478888f, -0.04602114f, -0.25341544f, 
    0.01522431f, 0.04452878f, 0.09536461f, 0.45492953f, -0.05398511f, 0.28344369f, -0.08098387f, -0.13691850f, 
    0.24598125f, 0.31284282f, 0.04648531f, -0.15784046f, 0.22833297f, -0.79788202f, -1.52624679f, 0.01151106f, 
    -0.04820278f, 0.10672431f, 0.12091691f, -0.11668788f, -0.33221444f, -0.90041864f, -0.29823753f, 0.06520678f, 
    0.15106812f, 0.10497828f, -0.18610922f, 0.12063067f, 0.09572311f, 0.11817358f, -0.10402798f, -0.29121065f, 
    -0.22478604f, -0.37613109f, -0.25440344f, -0.69991201f, 0.00639133f, -0.08491325f, 0.32579178f, 0.41723856f, 
    0.59977424f, 0.58641100f, 0.04009006f, -0.10769194f, -0.02536128f, 0.08806150f, -0.08650383f, 0.07553995f, 
    -0.10408135f, -0.13964739f, -0.17710984f, -0.04916803f, -0.15374237f, 0.21771103f, -0.28718770f, -0.21802394f, 
    -0.57300854f, -0.14281927f, 0.03069854f, 0.24708915f, 0.07469588f, 0.14247377f, 0.16257457f, 0.22620170f, 
    0.43484339f, 0.20609045f, -0.06244150f, -0.21739350f, -0.02775582f, 0.05851946f, 0.04622265f, 0.19861344f, 
    0.04680152f, 0.25081813f, 0.20996602f, -0.23786813f, -0.37039220f, -0.05162355f, -0.03030896f, -0.30301344f, 
    -0.07551640f, 0.10641330f, 0.16293226f, 0.11007490f, 0.00081565f, -0.16189592f, -0.31410626f, 0.19509301f, 
    0.32393774f, 0.08999491f, -0.03960839f, -0.24460053f, -0.01296798f, 0.26436403f, 0.18396504f, -0.18010698f, 
    0.05948363f, -0.04682899f, 0.05059027f, 0.03862129f, 0.06778862f, 0.10397589f, 0.09782808f, -0.16866957f, 
    -0.12524313f, -0.04703699f, -0.02169489f, 0.05311601f, 0.26282918f, -0.01937922f, 0.03648146f, 0.08800266f, 
    0.34102485f, 0.09051306f, 0.08289296f, 0.11707141f, 0.14904840f, 0.01364968f, 0.14495601f, -0.13401613f, 
    0.22579154f, 0.42640671f, -0.25664732f, 0.16029942f, 0.15124534f, 0.09410085f, 0.27275068f, 0.33156952f, 
    0.48219141f, 0.06380006f, 0.12547410f, -0.12313410f, 0.37208480f, -0.01386891f, 0.20329523f, 0.00544994f, 
    -0.03546948f, -0.03631490f, 0.47756740f, 0.14971787f, 0.04243054f, 0.24103959f, -0.13430753f, 0.08985276f, 
    0.04963219f, 0.23137407f, -0.04583466f, -0.05854307f, -0.16220841f, 0.19750358f, -0.03224566f, -0.07759378f, 
    -0.05762912f, -0.22576424f, -0.48667553f, -0.09883856f, 0.03723241f, 0.51750237f, -0.04389419f, 0.27306443f, 
    0.21452476f, 0.17857227f, 0.04165632f, -0.20086679f, 0.23830332f, 0.04877515f, -0.24128072f, 0.04996103f, 
    -0.07388902f, 0.05752540f, -0.14487271f, -0.19298229f, -0.00453047f, -0.26420650f, -0.01908758f, -0.38535756f, 
    -0.22215010f, 0.11562318f, 0.01179702f, 0.21014325f, 0.05902543f, -0.06035112f, -0.29905936f, 0.17445260f, 
    -0.20592511f, 0.09148262f, 0.16428578f, 0.00492818f, -0.02029145f, 0.04799597f, 0.09700006f, -0.23191784f, 
    0.02685366f, -0.04402120f, -0.08977958f, 0.07285842f, -0.12819940f, -0.33828938f, 0.07301515f, -0.47265172f, 
    -0.02023681f, -0.26155570f, -0.30298981f, -0.45094252f, -0.23159122f, -0.25805542f, -0.10632073f, 0.18961489f, 
    0.35786960f, 0.24509455f, 0.01926282f, -0.01145183f, 0.17392147f, 0.03960040f, -0.15880531f, 0.02469382f, 
    0.01883793f, 0.07568521f, 0.18953696f, -0.06738765f, -0.27975884f, 0.30414420f, -0.16086477f, -0.24914323f, 
    0.04427511f, -0.28032300f, -0.16358049f, -0.04276120f, -0.01261574f, -0.00976126f, -0.03339799f, -0.12620556f, 
    -0.22593498f, 0.06516908f, 0.16267096f, 0.09801476f, 0.13912109f, 0.46288630f, 0.42884767f, 0.29759407f, 
    -0.02109683f, -0.11715145f, 0.07452089f, 0.31872246f, 0.03138318f, -0.14711894f, -0.12350372f, 0.12141938f, 
    0.07876866f, -0.06574962f, -0.15208420f, 0.14510673f, 0.09406213f, 0.13761847f, -0.00407234f, 0.01188936f, 
    0.10935365f, 0.31022292f, -0.03314224f, -0.06052707f, -0.08263576f, 0.10496382f, -0.04232024f, 0.31375879f, 
    -0.02686092f, -0.17709868f, -0.05981356f, -0.03238769f, -0.30686733f, -0.06572369f, 0.10524563f, -0.04784684f, 
    0.20636456f, 0.07178072f, 0.14345193f, 0.25015244f, -0.04746309f, -0.20529473f, -0.06055533f, 0.19500080f, 
    0.19334988f, 0.09895091f, 0.25099093f, -0.33867940f, 0.00818017f, -0.45570764f, 0.18535720f, -0.21874523f, 
    -0.25107399f, -0.10793062f, 0.08821711f, -0.55707383f, -0.08623517f, 0.24719951f, -0.02577435f, 0.02799048f, 
    -0.28111207f, -0.05313139f, 0.27153412f, 0.18022102f, -0.08951779f, -0.16643362f, 0.06846832f, 0.20021661f, 
    -0.14422806f, -0.11171521f, 0.09352709f, -0.30581006f, -0.25627166f, 0.08831881f, 0.00729637f, -0.00843790f, 
    0.00607709f, -0.01559059f, -0.00461571f, -0.71358567f, -0.10046161f, -0.52588832f, -0.12631860f, 0.07880155f, 
    0.28915432f, -0.11045826f, -0.20059045f, -0.02788012f, -0.13140750f, -0.31127417f, -0.18687631f, 0.00462718f, 
    0.03773941f, 0.22727250f, -0.23117398f, -0.19921345f, -0.04961431f, 0.35094774f, -0.01458305f, 0.17033231f, 
    0.16818339f, -0.00631107f, 0.14080578f, 0.18747060f, 0.11014872f, 0.07258020f, -0.03769229f, 0.06883813f, 
    0.25348884f, -0.69564968f, -0.07984076f, 0.41933063f, 0.53846240f, 0.22037314f, -0.08889459f, -0.24821636f, 
    0.01207896f, -0.11840291f, 0.21475719f, 0.06217152f, 0.28104243f, 0.06865811f, -0.09607907f, -0.14238505f, 
    -0.09861488f, 0.12045293f, 0.01046233f, 0.26673761f, 0.35281536f, -0.90264070f, -0.07198690f, 0.04983306f, 
    -0.14875372f, -0.13572040f, -0.05573783f, -0.08227354f, 0.51651078f, 0.12062306f, 0.20212133f, -0.12124865f, 
    -0.35497949f, -0.37152302f, -0.22524634f, -0.14464208f, -0.03568385f, -0.16096409f, 0.44440615f, -0.79135972f, 
    -0.00397828f, 0.07525777f, 0.00588035f, 0.07631883f, -0.05590418f, 0.27311352f, 0.05354908f, 0.00017957f, 
    0.04095494f, -0.00489642f, 0.00069245f, -0.27410576f, -0.31482208f, 0.17873718f, -0.03023178f, -0.89112628f, 
    -0.47287181f, -0.42648831f, 0.02455460f, 0.02518489f, -0.00311867f, -0.02585630f, 0.01626602f, -0.11590956f, 
    -0.53139192f, 0.14099115f, -0.30392760f, 0.22462389f, 0.23355551f, 0.06791864f, 0.06480011f, 0.01457571f, 
    0.10746953f, 0.43930769f, -0.12243908f, -0.23473607f, -0.45956683f, -0.29335281f, -0.18627705f, 0.11737082f, 
    -0.20633194f, -0.12988529f, 0.13634707f, -0.21516812f, 0.51875174f, -0.17310262f, 0.08841004f, -0.16842422f, 
    0.10766905f, -0.18410903f, 0.05431529f, -1.18594003f, -0.01952892f, -0.16126885f, -0.18955976f, -0.07220470f, 
    0.05335319f, -0.00871101f, 0.18186772f, -0.11075339f, 0.44798273f, 0.46063507f, 0.11955125f, -0.19772631f, 
    -0.20975094f, 0.45893413f, 0.25273567f, 0.18237688f, -0.09355762f, 0.14032188f, 0.18001869f, 0.17523754f, 
    0.26309326f, 0.15165626f, -0.17964168f, 0.26114336f, 0.17143598f, 0.38650680f, -0.01847858f, 0.23965538f, 
    0.54402131f, 0.04737244f, -0.09586804f, -0.10032319f, -0.19560334f, -0.05616145f, -0.05969352f, -0.28644180f, 
    -0.59307420f, 0.36601031f, -0.02676041f, -0.03106486f, 0.13866155f, -0.19935223f, 0.11241379f, 0.04792598f, 
    -0.04732696f, -0.07697164f, -0.09164379f, -0.05450017f, -0.06225625f, 0.00605827f, -0.04486671f, 0.00746487f, 
    0.03243804f, -0.03161190f, -0.06492732f, -0.08985652f, -0.08565949f, -0.05402257f, -0.07441997f, -0.05288143f, 
    0.00793988f, 0.02901039f, -0.06501190f, 0.02046957f, -0.05478651f, -0.08655886f, -0.03142793f, 0.01923220f, 
    0.00222353f, -0.01947301f, 0.06513301f, 0.00833320f, -0.08410891f, -0.07599100f, 0.02083140f, -0.05340241f, 
    -0.07952246f, -0.01545053f, -0.03500468f, 0.03079932f, -0.09146614f, 0.04392501f, -0.06045780f, -0.05931779f, 
    0.01006193f, -0.08367981f, -0.10274614f, -0.01194726f, -0.04899085f, 0.04532132f, 0.00229441f, 0.02051380f, 
    -0.03696825f, 0.04704256f, 0.01744407f, -0.07450899f, -0.05675323f, -0.01043046f, -0.01106473f, -0.02493960f, 
    -0.10044030f, 0.03968934f, 0.05602659f, 0.02576305f, 0.03581095f, -0.01064833f, -0.03132366f, -0.08063299f, 
    0.02295508f, -0.00656654f, -0.03458970f, -0.01016345f, -0.00038489f, -0.08204895f, 0.02202854f, -0.01377713f, 
    -0.06409770f, -0.00573999f, 0.05711000f, -0.07936867f, -0.07739376f, -0.01073310f, -0.09769899f, -0.11310691f, 
    0.02628271f, -0.11272519f, -0.09541129f, -0.03747372f, -0.01685427f, 0.03424406f, -0.06203356f, -0.07257009f, 
    -0.05201002f, -0.01065546f, -0.02252763f, -0.04409480f, 0.01218764f, 0.05329350f, 0.05666874f, -0.09322884f, 
    0.01905685f, 0.01845967f, 0.01884397f, -0.06669737f, 0.02002106f, 0.02019728f, -0.07034487f, 0.02575656f, 
    0.05186030f, -0.09574784f, -0.07232495f, -0.03716550f, 0.03269207f, 0.06315196f, -0.02226550f, -0.08963841f, 
    -0.01634106f, -0.08594815f, -0.07945151f, -0.00718437f, -0.01735567f, 0.00008574f, 0.01212933f, 0.04532903f, 
    -0.01906282f, -0.03106073f, 0.03145505f, 0.02950625f, 0.02707365f, 0.01348865f, -0.00548859f, 0.03445136f, 
    -0.01653386f, 0.06784187f, -0.03400928f, -0.04528616f, 0.03136531f, -0.03308399f, -0.01441063f, -0.00389522f, 
    -0.03935191f, -0.01781867f, 0.00590546f, -0.00594174f, -0.00604681f, 0.04047709f, -0.06570257f, -0.03849927f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.28008893f, 0.38496852f, 0.77896672f, 0.39022091f, 0.33977118f, -0.10061677f, 0.21926807f, -0.03822515f, 
    0.49361971f, -0.36694637f, -0.17511193f, 0.28514019f, 0.24744233f, -0.00480230f, 0.16956660f, -0.08716267f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.17983472f, -1.08215761f, 0.01739671f, -0.58736837f, -0.26042402f, 0.86387634f, -0.44737801f, -0.20320384f, 
    -0.56135017f, 0.57393128f, 0.15359879f, 0.68829131f, -0.28707448f, -0.46078694f, 0.18787852f, 0.14852235f, 
    0.10966440f, -0.48528579f, -0.15206215f, 0.46211699f, 0.41978195f, -0.36790201f, -0.43294749f, -0.36866647f, 
    0.22462562f, 0.09835737f, -0.10039478f, 0.60414308f, 0.37303516f, -0.55894697f, 0.61000174f, 0.00963848f, 
    -1.62113142f, 0.67757934f, 0.28716949f, -0.06420907f, -0.84402227f, -0.18591823f, -0.71657562f, 0.26417616f, 
    0.73752844f, -0.34063694f, -0.18547243f, -0.34084836f, -0.01552164f, 0.43550044f, -0.13845390f, -0.07277020f, 
    -0.48793966f, 0.39408073f, -0.59354097f, -0.55595535f, 0.57856315f, 0.68930602f, 0.03319740f, -0.01732954f, 
    -0.41966301f, 0.24907163f, 0.63096368f, -0.74084997f, 0.13582154f, 0.15711327f, -1.10332394f, 0.09412452f, 
    -0.10510924f, -0.53591263f, -0.23004012f, 0.36473283f, -0.25627133f, -0.39085513f, 0.27659637f, 0.17815156f, 
    -0.54722345f, 0.05233047f, 0.50194883f, 0.33446363f, -0.38395131f, 0.31782863f, 0.28305447f, -0.18876055f, 
    0.12050030f, 0.08994463f, -0.13806690f, 0.26753968f, -0.84176326f, -0.12618689f, -0.14052382f, -0.31160882f, 
    0.04221641f, -0.11601288f, 0.15869915f, 0.12920864f, 0.61647230f, 0.27944237f, 0.38856536f, 0.13234220f, 
    -0.60845643f, -0.00513093f, 0.94825798f, -0.74915504f, 0.35902151f, -0.80230498f, -0.16283858f, 0.21744008f, 
    0.20083463f, -0.61804885f, -0.56700134f, -0.24849133f, -0.44427943f, -0.36563668f, -0.32177714f, -0.00777592f, 
    0.30356643f, -0.01007305f, -0.53003496f, -0.55989832f, 0.84339321f, 0.50357336f, -0.71210307f, 0.38304546f, 
    -0.11841650f, 0.17758738f, -0.00082433f, -0.25212622f, -0.30353171f, 0.12916604f, -0.01534972f, 0.02090932f, 
    0.85099572f, 0.61395496f, -0.17836694f, 0.74775189f, 0.38389164f, 0.41595873f, -0.36073917f, -0.24834037f, 
    -0.30874851f, -0.21111330f, -0.77402443f, -0.59321630f, 0.43469393f, 0.18367030f, -0.65174627f, 0.18055746f, 
    -0.48329139f, 0.13352230f, 0.26087433f, 0.11349499f, -0.83917147f, -0.31266031f, 0.87447172f, 0.43526658f, 
    -0.63492697f, -0.90452641f, -0.21458554f, 0.45340797f, -0.17698818f, -0.47489232f, -0.23621842f, 0.10223586f, 
    -1.02007186f, -0.12924936f, -0.14334533f, 0.16293989f, -0.43021363f, 0.11500635f, 0.51581943f, -0.36222124f, 
    0.71363401f, 0.63574505f, -0.68504721f, -0.29606232f, 0.05313776f, -0.88774431f, -0.45010874f, -0.07611939f, 
    0.75073963f, 0.04721738f, -0.26703668f, -0.66827828f, -0.53276962f, -0.53153622f, 0.37707916f, 0.19918093f, 
    0.70169222f, -0.03733070f, -0.34065816f, -0.79116309f, -0.05674728f, 0.12789473f, -0.60282934f, 0.23703358f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.37572211f, 0.20506346f, 0.32677308f, 0.40848163f, -0.20081368f, -0.27587208f, -0.13963756f, -0.50134003f, 
    0.06589073f, 0.34365660f, -0.19002031f, 0.11956684f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
