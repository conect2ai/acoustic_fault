#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.49743405f, -0.03003798f, -0.67964482f, 0.14597353f, 0.54567289f, 0.15957090f, 0.18624416f, 0.17741188f, 
    -0.11202036f, 0.39668173f, -0.45406434f, -0.18710887f, -0.00103358f, 0.26209977f, -0.52896547f, -0.43035254f, 
    0.38103753f, 0.47429803f, 0.55888557f, 0.37645596f, -0.53275025f, -0.30992675f, 0.00709261f, -0.40102258f, 
    0.02320480f, -0.62489188f, -0.51475513f, -1.11320651f, 0.86438674f, -0.10807605f, -0.22157229f, 0.45684835f, 
    0.55656856f, -0.31161097f, -0.08229976f, -0.04249081f, 0.04214864f, 0.32012358f, 0.08243326f, -0.53612417f, 
    -0.33997157f, 0.59385878f, 0.41746446f, -0.03427647f, -0.33349496f, 0.18592855f, 0.54259551f, -0.37038508f, 
    -0.35649210f, -0.04097131f, -0.76933551f, 0.46001002f, 0.13617270f, -0.04015708f, -0.12765886f, -0.99773002f, 
    0.40255120f, 0.22230573f, 0.20287868f, 0.12693965f, -0.03896260f, -0.49032286f, -0.54135638f, 0.57873356f, 
    -0.13861999f, 0.27944782f, -0.55124676f, -0.03215597f, 0.20380615f, -0.04493428f, -0.31938905f, 0.09339558f, 
    0.07018878f, 0.67009628f, -0.66596574f, -0.69252688f, -0.67694724f, -0.38607693f, -0.46781468f, -0.38047972f, 
    -0.56822681f, -0.47629288f, 0.02339675f, 0.56623799f, 0.05923944f, 0.20320033f, -0.42004383f, 0.01553496f, 
    0.12796555f, 0.07550960f, 0.18213199f, -0.74506360f, -0.26667297f, -0.20166157f, -0.34906304f, 0.59261280f, 
    -0.40784332f, -0.12034693f, 0.38364136f, -1.08776736f, -0.85062772f, -0.85139745f, 0.43761933f, 0.22685228f, 
    -0.12907948f, -0.11451089f, -0.64316326f, -0.24737625f, 0.59688681f, 0.44562554f, -0.04206092f, 0.13307510f, 
    -0.31141934f, 0.05944893f, 0.18774803f, -0.27140546f, 0.03545433f, 0.14881738f, 0.72076422f, -0.59464777f, 
    -0.20882550f, 0.07563649f, -0.06313086f, -0.18248817f, -0.01444808f, 0.30206218f, -0.85280102f, 0.45396820f, 
    0.33795288f, -0.08208343f, 0.79458678f, -0.53154367f, -0.31933087f, 0.47960165f, -0.20922709f, 0.49064484f, 
    -0.63953143f, 0.14991826f, -0.18248668f, 0.25751603f, -0.43203807f, 0.19355446f, -0.19958363f, 0.23331782f, 
    -0.07770604f, -0.94091964f, 0.48672396f, 0.57943940f, 0.92930710f, -0.22112550f, -0.24526559f, -0.55070168f, 
    -0.21824321f, 1.09307826f, -1.02223039f, -0.99709338f, 0.30893302f, 0.37404260f, 0.46381077f, -0.38131797f, 
    -0.22456130f, 0.36703959f, -0.09854525f, 0.73749524f, 0.09500466f, -0.73749876f, -0.34324530f, 0.19248073f, 
    -0.05693495f, 0.32139555f, 0.42672685f, -0.75877506f, 0.09927997f, 0.41333887f, 0.74138260f, -0.55172765f, 
    -0.50193995f, -0.32118228f, -0.30066639f, -0.43022108f, 0.10691414f, -0.53264964f, 0.41109416f, -0.13514908f, 
    -0.17203180f, 0.35605493f, -0.13428368f, -0.26453403f, 0.50415593f, -0.26846585f, 0.32863113f, 0.25530973f, 
    0.06205063f, 0.17592202f, -0.33545193f, -0.28269240f, -0.17466407f, 0.50922972f, -0.75158828f, 0.09634696f, 
    0.17066996f, -0.42219812f, -0.10620014f, 0.11613784f, -0.19421822f, 0.49811134f, -0.11259229f, -0.01914679f, 
    0.37340286f, 0.23581325f, -0.01470567f, -0.34358367f, 0.39939821f, -0.00706238f, -0.04984409f, 0.07784066f, 
    -0.22834040f, -0.25180736f, 0.13265060f, 0.08696305f, -0.16549349f, -0.27035269f, -0.52064496f, -0.40730217f, 
    -0.47049704f, -0.02461332f, -0.33960879f, -0.50416088f, -0.40609309f, 0.01549039f, 0.06423454f, 0.21178676f, 
    0.51435393f, 0.17221636f, -0.81213486f, 0.34194863f, -0.21294300f, 0.35403544f, -0.57715017f, 0.19242300f, 
    0.09955851f, -0.47092804f, 0.59044045f, -0.69077879f, -0.53893250f, -0.07628307f, -0.12686646f, 0.29954684f, 
    -0.60044932f, -0.09382995f, 0.08559575f, 0.30417106f, -0.78112727f, -0.70150232f, 0.81678206f, -0.37593445f, 
    -0.27838942f, 0.57667851f, -0.33364737f, 0.23402405f, 0.18271285f, -0.72640210f, -0.62564880f, 0.06086846f, 
    0.54334527f, 0.32928076f, 0.13876316f, 0.14969172f, 0.11451907f, -0.24120720f, 0.28357852f, -0.56592327f, 
    0.41279992f, -0.08218446f, 0.59099168f, -0.45292556f, -0.39976302f, 0.14077491f, 0.26615399f, -0.72254652f, 
    0.58219975f, 0.36715886f, 0.49392939f, -0.24564223f, 0.03034629f, -0.21902396f, -0.00218320f, -0.27572319f, 
    1.00092661f, -0.01823573f, -0.03780794f, -0.49502635f, -0.77667600f, -1.03118157f, -0.27075154f, -0.19350743f, 
    -0.00283480f, 0.98721695f, -0.86505127f, -0.77037889f, 0.65751070f, -0.00694244f, 0.07873975f, -0.26063406f, 
    0.13746729f, -0.11757918f, 0.19617625f, 0.55352831f, 0.56829166f, -0.48269030f, -0.12540568f, -0.39937672f, 
    -0.49680689f, -0.12141209f, -0.22934489f, -0.35509193f, 0.85389161f, 0.51590627f, -0.78540754f, -0.56188995f, 
    0.58115202f, -0.19839175f, 0.25675872f, -0.05306885f, -1.42840350f, 0.07693371f, 1.13434637f, -0.87040180f, 
    -0.51166183f, -0.02224805f, 0.64656776f, -0.31101465f, -0.22145380f, -1.02144313f, 0.20558035f, 0.28135470f, 
    -0.14265180f, -0.47279388f, 1.02639151f, -0.37813440f, -0.52826130f, 0.26122230f, -0.03107950f, 0.26399589f, 
    0.27376562f, -0.28890750f, 0.28309822f, 0.36428574f, -0.06602061f, 0.22540861f, -0.05230840f, 0.95099795f, 
    -0.77051651f, -1.00493681f, 0.15441930f, 0.40998331f, -0.26851672f, -0.23264872f, 0.55846334f, -0.49945045f, 
    -0.67085534f, -0.59145719f, -0.06422564f, 0.46778339f, 0.30664635f, 0.31651056f, 0.25554007f, 0.16640186f, 
    -0.19148165f, 0.82574272f, 0.39141420f, -0.93496531f, -0.18687175f, -0.17785701f, 0.17079937f, 0.16272262f, 
    0.06158380f, -0.20977546f, 0.18290277f, -0.45455486f, 0.21363831f, 0.31089398f, 0.21452896f, 0.31224111f, 
    -0.34148973f, -0.01696870f, 0.27644324f, 0.36701879f, 0.47735888f, 0.47871098f, -0.16557236f, -0.44959033f, 
    -0.26982826f, 0.61099899f, -0.10875935f, -0.34798753f, -0.59496772f, 0.39171883f, -0.39752209f, 0.49613068f, 
    -0.12578999f, -0.55937415f, 0.36535081f, 0.14822522f, -0.02230078f, -0.49700332f, 0.84836918f, 0.17877351f, 
    -0.45545098f, -0.05526659f, 0.10108748f, -0.00979647f, 0.03382124f, -0.06381940f, 0.93168110f, -0.55546224f, 
    -0.51056182f, 0.57454711f, -0.29762751f, -0.81629694f, -0.42418465f, -0.40914854f, 0.03743907f, -1.15517247f, 
    -0.11069001f, -0.71469867f, -0.46094689f, 0.40122908f, 0.70422864f, 0.29322916f, -0.06308819f, -0.20685017f, 
    -0.27771524f, -0.33505806f, -0.38030651f, -0.62430555f, -0.35589984f, -0.57015693f, -0.21779722f, -0.50053370f, 
    -0.72875148f, -0.93677419f, 0.06207780f, 0.52211308f, -0.44668236f, 0.55619889f, 0.07436276f, 0.15090570f, 
    -0.10027670f, 0.04421092f, -0.49137241f, -0.60694790f, -0.30463162f, -0.41077480f, -0.64567542f, -0.44096652f, 
    0.34710711f, 0.14772204f, 0.30731550f, 0.59156036f, -0.55215043f, -0.23826164f, 0.57299060f, -0.45144871f, 
    0.41873848f, -0.40293258f, 0.56050718f, -0.32529527f, -0.48030081f, 0.05559955f, 0.43060815f, -0.07702042f, 
    0.28964832f, -0.78821617f, -0.09672068f, 0.31227949f, 0.48348576f, -0.18417741f, 0.06744803f, 0.14365843f, 
    -0.44740880f, 0.34975445f, 0.31984338f, -0.10600168f, -0.40058565f, 0.41663778f, -0.61207712f, -0.69784164f, 
    -0.29017827f, 0.39685494f, 0.14467262f, 0.04342618f, -0.07901771f, 0.01711692f, 0.61221850f, 0.28803661f, 
    -0.60223216f, -0.57872987f, -0.75108671f, -0.61107117f, -0.49054909f, 0.46670017f, 0.17752023f, 0.16072619f, 
    0.43882442f, 0.40493616f, -0.17348906f, 0.05181751f, 0.13219260f, 0.21952632f, -0.27294558f, 0.05650740f, 
    0.36475736f, -0.47321635f, -0.47472540f, -0.21414620f, 0.60127968f, -0.01564401f, 0.09210730f, 0.17287919f, 
    -0.16278343f, 0.27759436f, 0.45066592f, 0.28814647f, 0.18409309f, 0.01451345f, -0.10234409f, -0.11260958f, 
    0.53967756f, -0.34336898f, -0.25451186f, 0.42642015f, 0.27340418f, 0.20754367f, -0.34923315f, 0.15762565f, 
    0.23791900f, 0.14713702f, -0.10065088f, 0.09901050f, -0.58773905f, 0.50514388f, -0.29459980f, -0.64595217f, 
    -0.11036217f, -0.61888129f, -0.38882619f, -0.16373478f, -0.39420033f, -0.71004999f, 0.76572227f, 0.81009686f, 
    -0.17891675f, -0.57025385f, -0.15085162f, 0.17866527f, -0.10795505f, 0.01352803f, -0.60544771f, -0.39090434f, 
    -0.35951144f, -0.37185401f, -0.46885693f, -0.58822685f, 0.39061508f, -0.32560173f, -0.34607652f, 0.43522280f, 
    0.63030118f, -0.64557576f, 0.02174716f, -0.04794354f, -0.29946014f, -0.21121460f, 0.34888589f, -0.03158368f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.01073578f, 0.14270552f, -0.20372681f, 0.19394530f, 0.06049864f, -0.05082693f, -0.14603294f, 0.10904428f, 
    -0.22327977f, -0.01836991f, 0.20197780f, -0.10081016f, -0.05867705f, 0.20937695f, 0.12240519f, -0.01814654f, 
    0.00790003f, 0.12359542f, 0.10093327f, -0.12613496f, 0.21447186f, 0.10017552f, 0.20653437f, -0.09459765f, 
    -0.04195910f, -0.17421563f, 0.17890303f, -0.11842822f, 0.04907735f, 0.11873791f, 0.07771575f, 0.02035362f, 
    -0.06065487f, 0.15128477f, -0.01281503f, 0.23303045f, -0.07605794f, -0.01441011f, 0.13182355f, 0.18233348f, 
    -0.13924997f, 0.14169784f, -0.03132656f, -0.00820793f, 0.20042904f, 0.16159134f, -0.08345849f, 0.02460845f, 
    -0.19799352f, 0.08534396f, 0.03602936f, 0.02608960f, -0.07463595f, 0.05782968f, 0.05399928f, 0.07044601f, 
    -0.33105785f, -0.06190492f, 0.02540993f, -0.23000093f, -0.29366615f, 0.06631391f, -0.13686873f, 0.24417236f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.10837661f, -0.01035455f, -0.17010462f, 0.09330129f, 0.05613052f, 0.07343566f, 0.06916233f, 0.07705848f, 
    0.02701890f, 0.02765692f, -0.05404893f, -0.02636153f, -0.11210223f, 0.07212569f, 0.01387875f, 0.00909907f, 
    0.07399011f, -0.05745267f, -0.01154372f, -0.01304835f, 0.04654957f, 0.16427468f, -0.05571384f, 0.02678680f, 
    -0.04118685f, 0.03211776f, 0.03859037f, -0.07177176f, -0.19725451f, -0.06831880f, -0.01011881f, -0.10254682f, 
    -0.04404526f, -0.05117090f, 0.01161087f, -0.11730248f, -0.01700886f, -0.05199691f, -0.09585107f, -0.02237949f, 
    0.01864491f, 0.18530923f, 0.35270143f, -0.12151061f, -0.13366687f, -0.10294408f, -0.09979994f, -0.07131216f, 
    0.01124795f, 0.02532350f, -0.00063460f, -0.03795022f, 0.03977302f, 0.00391321f, 0.02112266f, 0.07842524f, 
    0.02165779f, 0.13114566f, 0.15206915f, 0.17366312f, -0.47282299f, -0.22192465f, 0.18622775f, 0.04028228f, 
    -0.01690529f, -0.03036689f, 0.02745642f, 0.04222534f, 0.03750787f, -0.00982997f, -0.11163986f, 0.06275889f, 
    0.00852791f, 0.02123483f, -0.01982904f, -0.02856020f, -0.02299555f, 0.00075937f, -0.15011768f, -0.02837053f, 
    -0.17561623f, 0.11435427f, 0.14887001f, -0.05560194f, -0.09170148f, -0.02980807f, -0.02243191f, -0.21098293f, 
    -0.05129292f, -0.05567379f, -0.01272652f, 0.00763512f, -0.07204854f, 0.02485256f, 0.04816215f, -0.07506908f, 
    0.00470657f, -0.01600328f, -0.05675298f, -0.04355624f, 0.16825634f, 0.09884533f, -0.15127006f, 0.01586296f, 
    -0.02882805f, -0.05529896f, 0.03660972f, -0.11598717f, -0.02810671f, 0.02527251f, 0.00758787f, 0.06281179f, 
    0.07297480f, -0.05475219f, -0.12192271f, 0.00100698f, -0.03274728f, -0.13281381f, -0.07916681f, -0.13913022f, 
    0.43056631f, -0.13898034f, 0.08070680f, -0.34826595f, 0.07931960f, 0.03814097f, -0.00768126f, 0.16892894f, 
    -0.03846490f, 0.02577885f, 0.05599465f, 0.08418089f, -0.02471802f, 0.11534467f, -0.00425296f, -0.00061079f, 
    0.03383053f, 0.14714015f, -0.01055095f, 0.05770910f, -0.38950986f, 0.01815633f, 0.32491148f, -0.25143397f, 
    -0.03018325f, -0.01440014f, -0.05174037f, -0.03180332f, -0.01262907f, 0.01935873f, 0.05043396f, -0.02067304f, 
    0.02039512f, 0.00845179f, 0.03745030f, 0.07877884f, 0.08980940f, -0.12467465f, 0.02015472f, -0.06435741f, 
    -0.02074036f, 0.28367066f, 0.14685875f, -0.16666313f, -0.20817702f, -0.02164793f, 0.03605436f, 0.00584796f, 
    -0.03531855f, 0.07578461f, -0.04571456f, -0.08661471f, -0.05364963f, 0.05110676f, 0.01182648f, -0.04101988f, 
    0.00951213f, 0.03744804f, 0.10251494f, 0.14195350f, 0.11797434f, 0.01278622f, -0.04850976f, -0.05097817f, 
    -0.00302583f, -0.14901751f, 0.01400731f, 0.04017003f, 0.04535036f, -0.01719341f, 0.01396946f, -0.05138873f, 
    -0.21922508f, -0.06907093f, -0.15993789f, 0.03169607f, -0.03763863f, -0.01283317f, 0.03492735f, -0.05027179f, 
    0.14198001f, 0.11809057f, -0.01547606f, -0.09772912f, -0.05996987f, 0.01137478f, 0.05672164f, 0.11463822f, 
    -0.17163453f, -0.12794279f, -0.02650711f, -0.03930433f, 0.03291648f, 0.02247698f, 0.00760625f, 0.01351666f, 
    0.01924796f, -0.02133702f, -0.00888387f, -0.11873168f, 0.35252324f, 0.11537617f, -0.07560124f, -0.20720699f, 
    -0.04945429f, 0.16010666f, 0.17432806f, 0.23191494f, 0.06936496f, 0.05102234f, 0.07003410f, 0.03255391f, 
    -0.00652365f, 0.03365148f, 0.02803548f, 0.01894453f, 0.04990486f, 0.01757850f, 0.05457357f, 0.00282300f, 
    -0.22959915f, -0.09054198f, -0.15568282f, -0.05470377f, -0.00006843f, 0.02865483f, 0.02218615f, 0.00595425f, 
    0.03863825f, 0.06840470f, 0.01484878f, 0.07538322f, -0.00238982f, 0.02106404f, 0.06650181f, 0.02264988f, 
    0.04726394f, -0.20772700f, 0.04712424f, -0.06082045f, -0.22958288f, -0.20467940f, -0.16596629f, 0.12419271f, 
    -0.22177827f, 0.02729732f, -0.09626038f, -0.06193094f, -0.05584285f, 0.06084358f, -0.00703952f, -0.03238486f, 
    -0.12057226f, 0.01619530f, 0.07294670f, -0.12800248f, -0.01947580f, -0.11547916f, -0.06208813f, -0.13488157f, 
    -0.22840653f, -0.07963251f, 0.00965743f, -0.16744670f, -0.05766130f, -0.18577659f, -0.04057083f, 0.05845045f, 
    0.15350397f, 0.05292726f, -0.24803023f, -0.04354092f, -0.15042925f, -0.14050482f, -0.28821400f, -0.20511456f, 
    -0.01700671f, 0.02963817f, -0.01705177f, 0.07486083f, -0.02287433f, 0.07290389f, -0.02268718f, -0.05893084f, 
    0.02244404f, -0.08418298f, -0.02064009f, 0.01689158f, -0.10092963f, 0.02294262f, -0.08719150f, 0.09776515f, 
    -0.10009905f, 0.01310080f, -0.04627797f, -0.04345921f, -0.03617903f, -0.09596672f, -0.16570830f, 0.02513688f, 
    0.66543585f, -0.31441352f, -0.44051915f, -0.19013236f, -0.22003697f, 0.01122637f, -0.05118500f, 0.12435314f, 
    0.00104054f, 0.07791768f, 0.10245980f, 0.12964819f, -0.02200637f, 0.14000113f, 0.00109191f, -0.05291925f, 
    0.04267096f, 0.11064123f, 0.00705429f, 0.08848273f, 0.11198934f, 0.03656287f, -0.28553513f, 0.14159593f, 
    0.00827089f, 0.10061736f, -0.00902724f, 0.01202342f, -0.12988964f, -0.09049644f, 0.03128162f, -0.03227349f, 
    -0.11425510f, -0.08889086f, 0.04222005f, 0.04353674f, 0.13803619f, -0.01781637f, 0.03549016f, 0.02078453f, 
    -0.05840087f, -0.07225224f, 0.13142224f, 0.01477061f, -0.12213870f, -0.24107163f, -0.21422261f, 0.02126977f, 
    0.00671621f, 0.01911137f, 0.05108978f, 0.07736696f, -0.01760930f, 0.03737007f, -0.02390770f, -0.02102912f, 
    -0.00232444f, -0.00719110f, -0.07257222f, -0.07830840f, 0.19717054f, 0.25091764f, -0.15631077f, -0.24377595f, 
    0.06010794f, -0.15562063f, -0.08316845f, -0.11793391f, -0.04228521f, 0.03297021f, 0.03785816f, 0.00070206f, 
    -0.01924721f, -0.00655694f, 0.03068276f, -0.04991400f, -0.08593687f, 0.04340243f, 0.04975933f, 0.13806956f, 
    -0.27721381f, -0.12712246f, 0.15184781f, -0.12576422f, 0.05831468f, -0.05292130f, -0.03538425f, -0.03199835f, 
    -0.05544843f, -0.13493399f, 0.03953825f, -0.10370006f, -0.00470037f, -0.05681003f, -0.17809758f, -0.10914329f, 
    -0.02429043f, 0.01332963f, -0.05183295f, -0.20259874f, -0.31703058f, -0.21220756f, -0.10395932f, 0.07772864f, 
    -0.06793281f, 0.04717546f, -0.07854613f, -0.08907171f, 0.08321605f, 0.02569975f, 0.01922871f, 0.02434107f, 
    -0.01989827f, 0.06139766f, -0.00231721f, -0.23833373f, -0.17599587f, 0.01840518f, -0.02478425f, -0.07847928f, 
    0.08435921f, 0.07063673f, 0.06639404f, -0.15868150f, -0.09580639f, -0.01325551f, 0.10738885f, 0.04705471f, 
    0.08759816f, -0.05617653f, -0.02825683f, -0.00277696f, -0.01089604f, -0.00213256f, -0.01984788f, -0.02123732f, 
    -0.04165626f, -0.01782741f, -0.03706842f, 0.02254536f, -0.04791443f, -0.03410271f, 0.05056059f, 0.08912384f, 
    0.07213464f, 0.02314088f, -0.01439904f, -0.00178226f, 0.05721276f, -0.00921665f, 0.02613067f, 0.09417641f, 
    -0.01576637f, 0.05407364f, 0.03344309f, -0.10932378f, -0.08604559f, -0.05963208f, -0.01131716f, -0.03202458f, 
    0.18693317f, 0.17122003f, 0.07489456f, -0.16833936f, -0.00647718f, -0.04199215f, -0.10226722f, -0.07456697f, 
    -0.14625856f, -0.06738995f, -0.03828115f, -0.00558768f, -0.01036412f, -0.01330583f, -0.00277575f, -0.02431089f, 
    -0.19970000f, 0.06407238f, 0.04833946f, 0.08482730f, 0.27970922f, 0.24405318f, -0.00859764f, -0.05346409f, 
    0.04722831f, 0.05521065f, 0.04557045f, 0.05633259f, -0.01322572f, -0.15157123f, -0.03687979f, -0.02332803f, 
    -0.01214014f, 0.03499672f, 0.06052097f, -0.01408866f, -0.07286160f, -0.05179111f, 0.01015243f, -0.02086852f, 
    0.06636049f, 0.06540227f, 0.01158964f, -0.30139056f, 0.06300784f, -0.08527778f, 0.04330324f, -0.03137356f, 
    0.04802195f, -0.05826950f, -0.00202872f, -0.00609526f, 0.01878828f, -0.08146824f, -0.02516674f, -0.07425620f, 
    -0.04618600f, 0.04754088f, -0.06286773f, -0.10930493f, 0.25817165f, 0.21960294f, -0.07554670f, -0.24643409f, 
    -0.10326911f, 0.04601315f, -0.01044174f, 0.14061660f, -0.05340351f, 0.04521909f, 0.00013799f, -0.01783293f, 
    -0.01391813f, 0.00625543f, -0.01723217f, 0.01342099f, -0.05601612f, -0.01468975f, -0.01228600f, -0.03512958f, 
    0.20725076f, 0.16114101f, 0.22120191f, -0.26208624f, -0.00507753f, -0.06949378f, 0.04567570f, 0.07678612f, 
    -0.01331825f, -0.08629695f, -0.04768874f, -0.08241579f, -0.05993182f, -0.02286742f, -0.05851028f, 0.02479736f, 
    -0.01073416f, 0.03496325f, 0.04539062f, -0.13142690f, 0.14255621f, 0.02880353f, -0.22659655f, -0.03801429f, 
    0.05820038f, 0.06688456f, 0.06880605f, 0.11690731f, 0.03182849f, 0.03348739f, -0.02959733f, -0.00826517f, 
    -0.02729731f, 0.06780184f, -0.01312075f, -0.00412670f, 0.06151537f, 0.01668271f, -0.02800238f, 0.00499058f, 
    -0.06944791f, -0.07593296f, 0.11339716f, 0.06937702f, -0.01199479f, -0.03867804f, -0.15103313f, 0.02888458f, 
    -0.10867476f, 0.03824560f, -0.06467602f, -0.04352808f, -0.00286012f, -0.11449819f, -0.00807619f, -0.24395418f, 
    -0.00750224f, -0.13618265f, -0.10029481f, 0.05230606f, -0.40981370f, 0.31883332f, -0.11884058f, -0.27346507f, 
    0.12246338f, -0.06723420f, -0.02293080f, 0.05298942f, 0.10377169f, 0.02617031f, -0.03359525f, 0.05059702f, 
    0.00446982f, -0.08093471f, 0.05230726f, -0.01082550f, 0.04618312f, 0.00703481f, 0.00633415f, 0.11434127f, 
    0.02807800f, 0.26886627f, -0.04110365f, -0.26633462f, -0.13645078f, 0.05359622f, 0.01306385f, -0.02419224f, 
    -0.05466407f, -0.05414866f, 0.02120735f, -0.02071304f, 0.08108936f, 0.01763113f, 0.00538542f, -0.01624338f, 
    0.01947789f, 0.03937525f, -0.09276452f, 0.10598091f, 0.03107711f, -0.22755733f, -0.61580706f, 0.07548220f, 
    0.03547997f, 0.06706889f, -0.02998605f, 0.02103145f, -0.18127619f, -0.03770911f, -0.02112265f, -0.01606752f, 
    -0.13239364f, -0.18817098f, -0.01980645f, 0.02122438f, 0.07223744f, -0.01953151f, -0.05376662f, 0.06388380f, 
    -0.35719332f, 0.32742482f, 0.00283189f, 0.09157945f, 0.00672699f, 0.03455725f, -0.03960207f, -0.07249627f, 
    0.03847940f, 0.04686841f, 0.01887433f, 0.01063655f, 0.05135747f, 0.04645215f, 0.00113766f, 0.10292712f, 
    0.08048403f, -0.04125073f, 0.04509168f, 0.01752237f, -0.51270264f, 0.12004010f, 0.27998352f, -0.08509374f, 
    -0.16697462f, -0.10514794f, -0.11356392f, -0.10574652f, 0.04718878f, -0.10075741f, 0.07231659f, 0.04540562f, 
    -0.01642189f, 0.09406412f, 0.01781964f, -0.04269300f, 0.02162522f, 0.00257041f, -0.16043411f, -0.01190452f, 
    0.07627821f, 0.23835312f, 0.52204853f, -0.40154615f, 0.12251389f, -0.03399771f, 0.16594972f, -0.14278549f, 
    0.17711371f, -0.01276144f, 0.02521341f, -0.05397831f, -0.09358033f, -0.07746506f, -0.02487678f, -0.02688431f, 
    0.04404317f, -0.01722792f, 0.02555265f, 0.07833990f, -0.09090795f, 0.14402649f, 0.32168406f, -0.21262279f, 
    0.09607784f, -0.14562391f, 0.02895058f, -0.03378462f, 0.11513080f, -0.09449393f, 0.01959959f, 0.03047899f, 
    0.06919689f, -0.04019453f, -0.04521317f, -0.01247108f, -0.02863786f, 0.01403799f, -0.14535430f, -0.14936778f, 
    -0.05753962f, -0.06340841f, 0.01012878f, 0.05956215f, 0.05307837f, -0.02796303f, 0.05798487f, 0.00034991f, 
    0.03010621f, -0.00605692f, -0.06172134f, 0.01578142f, 0.01045802f, -0.03063446f, 0.00042414f, -0.01479037f, 
    -0.14378987f, -0.00343203f, -0.02090132f, -0.03416254f, 0.01747500f, 0.00654554f, -0.33798152f, 0.03252682f, 
    -0.07547648f, 0.11107879f, -0.08242568f, 0.00419690f, 0.01571326f, 0.10076139f, -0.01851159f, -0.01053634f, 
    -0.10832617f, -0.10772943f, -0.16966994f, -0.00683177f, -0.00584043f, -0.00520242f, -0.02041616f, 0.14031501f, 
    0.08233370f, 0.08303209f, -0.08013280f, 0.03840964f, 0.07023168f, 0.06392355f, 0.07458010f, 0.07368679f, 
    0.04221394f, 0.05824434f, -0.10910622f, -0.05360434f, -0.04258818f, 0.04978729f, -0.00738587f, 0.01532075f, 
    0.02425696f, 0.04735188f, 0.00812506f, 0.00223554f, -0.46594226f, 0.01234457f, -0.96651852f, 0.06932940f, 
    -0.57987893f, -0.11244394f, -0.02926691f, -0.17791024f, 0.10206261f, 0.01646647f, -0.02074879f, 0.00575662f, 
    -0.07304295f, 0.03969539f, 0.06517191f, -0.14287108f, -0.11900840f, -0.02153281f, 0.00861248f, -0.04880996f, 
    0.00373706f, -0.01054220f, -0.00771321f, 0.03832786f, 0.03638373f, -0.02463040f, 0.02347294f, 0.01405068f, 
    0.04498350f, 0.05439071f, -0.02373671f, -0.13943160f, -0.06180181f, -0.08660012f, -0.09918111f, -0.01159840f, 
    0.08742726f, 0.02619847f, -0.04665976f, -0.01580616f, -0.23992334f, 0.03568084f, 0.00965957f, -0.08662675f, 
    -0.04341860f, 0.05628668f, 0.01298298f, 0.00209280f, -0.00773532f, -0.01519926f, 0.01119519f, 0.03146239f, 
    0.05761767f, 0.05750922f, 0.04308932f, 0.07090718f, 0.05292778f, -0.03456227f, -0.07185162f, -0.01748583f, 
    0.14184199f, 0.10317177f, -0.08148532f, -0.02837855f, -0.00694695f, -0.08943567f, 0.06017495f, -0.05160987f, 
    -0.06061789f, -0.14843234f, -0.05666548f, -0.21227844f, -0.03732754f, -0.04853088f, -0.02030615f, -0.08859115f, 
    -0.01109542f, -0.05056252f, -0.03239089f, -0.07671928f, -0.50710064f, -0.11982888f, 0.14994380f, 0.10274543f, 
    -0.12829915f, -0.07034810f, -0.09400350f, -0.04737983f, 0.02482654f, -0.01989483f, 0.07869472f, 0.06407185f, 
    -0.03430035f, 0.03379916f, 0.04396901f, -0.13183893f, 0.09990118f, 0.01667493f, -0.16640787f, 0.04238028f, 
    0.08902085f, 0.02556442f, -0.13905843f, 0.02186775f, 0.03057723f, -0.00384072f, -0.15842618f, 0.04100570f, 
    -0.07075312f, -0.06828315f, -0.05803986f, -0.06196264f, 0.04654240f, 0.04341492f, -0.03637677f, 0.05230418f, 
    -0.01521613f, 0.09291568f, -0.12269416f, 0.01051609f, 0.31324953f, 0.09690468f, 0.03419533f, -0.14164075f, 
    -0.10376526f, 0.13107549f, 0.11744100f, 0.16979827f, 0.13331421f, -0.16546267f, -0.01876500f, 0.05692759f, 
    -0.04044429f, 0.10252147f, 0.11227373f, 0.08646572f, 0.05247004f, -0.01150102f, -0.04001460f, -0.02389949f, 
    0.22205561f, 0.17755511f, 0.18726437f, -0.25075993f, -0.03257381f, 0.14611121f, 0.17430863f, 0.14592363f, 
    0.00714970f, 0.07386769f, -0.00934491f, -0.05345681f, 0.00959945f, -0.10820846f, -0.15058613f, -0.06092994f, 
    -0.13896209f, 0.00661301f, 0.08981584f, 0.11199151f, -0.06791458f, -0.10290508f, 0.16012231f, -0.04494549f, 
    0.01859327f, -0.12080231f, 0.00700605f, 0.09670058f, 0.11573429f, -0.06280956f, -0.19037063f, -0.02595492f, 
    -0.10988469f, 0.07544880f, 0.01669197f, -0.09938221f, -0.04797626f, -0.04340974f, -0.01565966f, -0.01879084f, 
    0.27891704f, 0.29628104f, 0.04316647f, -0.40360934f, -0.10750538f, 0.05890836f, -0.00254777f, 0.05340673f, 
    0.02629726f, 0.04262657f, 0.00775835f, -0.01588699f, 0.01391993f, 0.03127304f, 0.02693679f, -0.00315711f, 
    -0.06913601f, 0.03744189f, -0.04297507f, -0.09032931f, -0.16098441f, -0.38124534f, -0.22045015f, -0.04060428f, 
    0.15345480f, -0.04983743f, -0.02345306f, 0.02890922f, -0.13912715f, 0.04988315f, -0.08671461f, 0.04632117f, 
    0.03452903f, -0.10809907f, -0.06254098f, 0.04323388f, -0.01125537f, -0.01866108f, -0.02938740f, -0.03610770f, 
    0.12533692f, 0.10936403f, -0.00881826f, 0.06646087f, -0.02099128f, -0.04744821f, 0.03886035f, 0.04365632f, 
    0.01194985f, 0.01587522f, 0.13635753f, -0.04653704f, -0.02869770f, -0.02183839f, -0.06990502f, -0.02068531f, 
    -0.06072065f, -0.04485001f, 0.00515084f, -0.02566063f, -0.48187229f, -0.24337433f, 0.20977266f, 0.07007333f, 
    0.05581641f, 0.02108025f, -0.01224655f, -0.03827282f, 0.04089369f, 0.00599772f, -0.10308525f, -0.02567302f, 
    0.01347629f, -0.07173792f, -0.00155821f, -0.07361496f, -0.04987186f, -0.01648118f, -0.06999991f, -0.15955387f, 
    0.33788693f, 0.19782047f, -0.08311646f, -0.10276686f, 0.10618895f, 0.12744407f, 0.09047028f, 0.12704852f, 
    -0.17087825f, -0.11830119f, -0.07594245f, -0.04688866f, -0.03777965f, 0.03382215f, 0.04467719f, -0.02029887f, 
    0.04181133f, 0.05388190f, 0.04028661f, 0.00766199f, 0.29715133f, 0.28753012f, -0.02514263f, -0.29624087f, 
    -0.12102801f, -0.03018660f, -0.01107066f, -0.05687997f, 0.01433975f, -0.06262962f, 0.04583149f, 0.00390501f, 
    0.02706723f, 0.01203243f, 0.02302969f, -0.01095593f, -0.04166441f, -0.01743738f, 0.04343092f, 0.01901944f, 
    -0.03008599f, -0.07457929f, 0.00565635f, 0.06690507f, 0.07131331f, 0.08412173f, 0.02443712f, -0.00958759f, 
    0.06514227f, 0.04433880f, 0.05112566f, -0.08026084f, -0.01411726f, 0.03977552f, 0.03021894f, -0.07987062f, 
    -0.11097063f, -0.18896475f, 0.04330273f, -0.07403977f, 0.19615000f, 0.07267712f, -0.07462519f, -0.03762566f, 
    0.13115941f, 0.06387840f, 0.05983570f, 0.03223460f, 0.02277353f, -0.06161194f, 0.01739785f, 0.10986436f, 
    -0.07277920f, -0.03460199f, 0.07300811f, 0.00129582f, 0.07869313f, 0.03548808f, 0.03895623f, -0.02554970f, 
    -0.28077719f, -0.31746167f, -0.07106197f, 0.02617405f, -0.02707328f, 0.03375265f, 0.01358506f, -0.01305622f, 
    0.05472640f, 0.05500918f, 0.01352608f, 0.04914618f, 0.04412096f, 0.02771721f, 0.05237067f, -0.02311377f, 
    -0.06870252f, -0.05229085f, 0.03047614f, -0.01669464f, -0.00711596f, -0.02227306f, -0.00533642f, 0.05208614f, 
    0.02569147f, 0.00113333f, 0.07915017f, -0.01362161f, 0.03043678f, 0.08002530f, 0.03233485f, 0.05229927f, 
    -0.00432614f, 0.03108785f, 0.10323950f, 0.01491727f, -0.07902971f, -0.11654300f, -0.00781132f, -0.07028276f, 
    0.12450985f, 0.20896307f, 0.09322572f, -0.11605231f, -0.10751703f, 0.01927108f, 0.09507567f, 0.03807871f, 
    0.02660306f, 0.03198739f, -0.02480008f, -0.01649020f, 0.02266825f, -0.03373359f, -0.03998310f, -0.16898534f, 
    -0.07203934f, -0.06339730f, -0.06901309f, 0.12962109f, -0.46731034f, 0.36939976f, 0.05479333f, -0.25416982f, 
    0.08771112f, -0.10290685f, -0.09518348f, -0.14718592f, -0.03631404f, -0.17876294f, 0.07269893f, 0.04177235f, 
    0.01531886f, 0.06674521f, 0.01297640f, -0.07078328f, 0.08986239f, 0.04904877f, -0.13818084f, -0.02942436f, 
    0.25478154f, 0.19814837f, 0.07763315f, -0.26613596f, -0.06394410f, 0.14349434f, 0.18389221f, 0.07424153f, 
    -0.01362082f, 0.04563177f, 0.00187662f, 0.00517981f, -0.00401144f, -0.05033641f, -0.00907974f, -0.05149117f, 
    -0.02862295f, -0.05351487f, -0.01854401f, 0.03161438f, -0.24398264f, -0.19563834f, -0.57643896f, 0.12780687f, 
    -0.24409764f, 0.03614480f, -0.07998020f, -0.08511379f, -0.00939471f, 0.01502393f, -0.05593804f, -0.00672529f, 
    -0.07584277f, -0.06108776f, 0.02472323f, -0.15759411f, 0.01129363f, -0.16469257f, -0.00177886f, -0.05279423f, 
    0.03256476f, -0.20434238f, -0.08381385f, -0.00877260f, -0.09534721f, -0.03940390f, -0.01466300f, 0.04854439f, 
    0.01195147f, 0.01100905f, 0.02134551f, -0.01219908f, -0.02249625f, -0.03226367f, -0.03766445f, -0.03246481f, 
    -0.02339606f, -0.07453866f, 0.01987931f, 0.02617717f, 0.06196647f, -0.07813308f, -0.07304151f, -0.01860377f, 
    -0.07439109f, 0.04714803f, 0.07153340f, 0.10915458f, 0.01949641f, 0.05204195f, 0.01237084f, 0.05794303f, 
    0.05303511f, 0.11338988f, 0.01458242f, -0.04041838f, 0.07731259f, -0.03525195f, 0.06120383f, 0.08997890f, 
    -0.06972748f, 0.00411500f, -0.09707894f, -0.39985016f, -0.34027848f, 0.04125943f, -0.05820349f, -0.07676908f, 
    -0.01856273f, -0.03391260f, -0.03729790f, -0.03830887f, 0.02253642f, -0.02025235f, 0.03821054f, 0.04436585f, 
    -0.16081829f, -0.23486859f, -0.10006458f, -0.14317015f, -0.30738834f, -0.39392385f, 0.13338558f, 0.02138900f, 
    0.06590989f, -0.01446627f, 0.01229737f, 0.06783324f, -0.09930513f, 0.00608176f, 0.04932548f, 0.01464355f, 
    -0.13973083f, 0.02130296f, 0.12649435f, 0.13047265f, -0.02934469f, -0.06998020f, 0.11924960f, 0.02107175f, 
    -0.09034660f, -0.03922908f, 0.20461507f, 0.05478752f, 0.04420931f, 0.11309636f, 0.10715141f, 0.13892218f, 
    -0.03320013f, -0.03844353f, 0.06553427f, -0.03455555f, -0.02748895f, 0.07690078f, 0.00333267f, 0.11231605f, 
    -0.04444766f, 0.02096466f, 0.09130510f, -0.12013602f, -0.13750495f, -0.11269300f, 0.00479343f, 0.01899892f, 
    -0.20305599f, -0.05549681f, -0.02183761f, -0.22415677f, 0.00904315f, 0.02318343f, 0.04257424f, -0.05183881f, 
    -0.04949474f, 0.18925044f, 0.09107278f, 0.01667070f, -0.00797010f, 0.03979002f, 0.10770413f, 0.05618755f, 
    -0.09517241f, 0.00221349f, 0.05994665f, -0.06686374f, 0.03541783f, -0.03739937f, -0.04080589f, -0.04151262f, 
    -0.03893727f, 0.02348512f, 0.06610028f, -0.02893220f, 0.04980858f, -0.03760058f, -0.13442020f, 0.08903833f, 
    -0.03773410f, -0.29526430f, 0.06309314f, -0.25133291f, 0.23576421f, 0.28257564f, 0.00801220f, 0.10983762f, 
    0.03532241f, -0.01780739f, 0.01649416f, -0.00942170f, -0.09961791f, 0.00518087f, -0.00892955f, 0.03206359f, 
    0.05764318f, 0.00647404f, 0.00848020f, -0.03611943f, -0.03406344f, 0.08577816f, 0.02352289f, -0.01563095f, 
    -0.23002653f, 0.08549953f, -0.16615017f, -0.14320365f, -0.37934005f, 0.06661471f, 0.01600226f, -0.15074793f, 
    -0.08437546f, 0.03447068f, -0.06581687f, 0.01042969f, -0.00092402f, 0.03688603f, 0.04280666f, -0.14352228f, 
    -0.02463672f, -0.04705819f, -0.17034239f, -0.25979364f, 0.05651705f, 0.09607351f, 0.07441667f, -0.01306775f, 
    0.13411303f, 0.03058000f, 0.01611021f, -0.03626005f, 0.09887506f, 0.04053400f, -0.04985465f, -0.00293547f, 
    0.12544623f, 0.07790695f, 0.05074246f, -0.16215388f, -0.02869683f, 0.11310221f, 0.04999907f, -0.11098266f, 
    -0.12130443f, 0.15098797f, -0.11965020f, 0.07386513f, -0.11904600f, -0.04170142f, 0.08315212f, 0.03725203f, 
    -0.00728443f, 0.14070173f, -0.01343895f, -0.06417336f, 0.06811874f, -0.00560048f, -0.04737125f, 0.05800531f, 
    0.12268665f, -0.00963827f, -0.04810503f, 0.08883173f, 0.32758477f, 0.18517992f, 0.28882489f, 0.03279974f, 
    -0.04180619f, 0.08986114f, -0.08488259f, 0.04720396f, 0.06150156f, -0.13683727f, 0.06279828f, -0.01820377f, 
    -0.01590708f, -0.07636689f, 0.02482192f, 0.11468976f, -0.00172930f, -0.09824815f, -0.02542244f, 0.05428058f, 
    0.12975693f, 0.22946547f, 0.13697195f, 0.09948067f, 0.17485221f, -0.03211553f, -0.00943289f, 0.03324683f, 
    -0.01195288f, 0.01215734f, -0.00233958f, -0.02490901f, 0.03941317f, 0.01330422f, -0.00001824f, 0.04144175f, 
    0.02135484f, 0.02617636f, 0.07435913f, 0.02696110f, -0.05474279f, -0.04727503f, 0.08703651f, 0.05987329f, 
    0.01200363f, 0.02315205f, 0.01423794f, -0.00476918f, 0.03837800f, -0.01103295f, -0.04777706f, 0.04353498f, 
    0.05836096f, 0.11158349f, -0.05553490f, -0.04724025f, 0.02121045f, -0.05580917f, 0.02828395f, 0.05915678f, 
    0.09569789f, -0.23778489f, 0.14941396f, -0.05930272f, 0.18603005f, -0.16402490f, 0.19082607f, -0.09744651f, 
    0.08980430f, 0.08024696f, 0.16838229f, 0.00397305f, -0.03127256f, 0.03198147f, 0.07963231f, -0.06233959f, 
    -0.00415658f, -0.01358117f, 0.08098669f, -0.15191503f, -0.04173110f, 0.09363967f, -0.10319794f, -0.04051509f, 
    0.01659738f, -0.13065830f, 0.07725859f, 0.04150245f, -0.02810849f, 0.04148942f, -0.10382462f, -0.03911424f, 
    0.28875685f, 0.04651185f, -0.00279978f, -0.01352741f, -0.09274307f, 0.11607241f, 0.03909032f, -0.08489313f, 
    0.31566361f, -0.46500066f, 0.32782093f, 0.19867696f, 0.24032031f, -0.02318821f, 0.00568280f, 0.04972500f, 
    -0.01411414f, 0.01913366f, 0.13730945f, -0.04939101f, 0.19527213f, -0.12086523f, -0.18938901f, 0.15184614f, 
    -0.14440982f, -0.10035504f, -0.07804629f, -0.24123117f, 1.06502664f, -0.08441260f, 0.22802928f, 0.17402023f, 
    -0.42998695f, -0.01384736f, 0.08230512f, 0.07803017f, -0.06249739f, -0.07914022f, 0.09050612f, -0.27397788f, 
    0.04168136f, -0.13088284f, -0.14374970f, 0.08618134f, 0.01187862f, -0.05744433f, -0.02905027f, 0.02960211f, 
    0.00883605f, -0.06614616f, 0.09148046f, -0.06521623f, -0.00971546f, 0.13173701f, 0.05056952f, -0.08722150f, 
    0.00301183f, 0.06221420f, 0.01803280f, -0.05658136f, 0.08900126f, 0.14836220f, 0.06413952f, -0.05907948f, 
    0.02047913f, -0.09264456f, 0.09927254f, 0.08968265f, -0.15772900f, 0.09902754f, -0.14999804f, 0.06151307f, 
    0.00320552f, 0.15774207f, -0.06324361f, 0.03407992f, 0.03628239f, -0.04687842f, 0.08647662f, 0.04175328f, 
    0.10599426f, -0.05628039f, 0.11800932f, -0.17770962f, -0.14813004f, -0.03714931f, -0.20444699f, -0.24754868f, 
    -0.29838970f, 0.14734930f, 0.01619012f, 0.14582825f, 0.02786737f, -0.08155998f, 0.05441917f, 0.10814615f, 
    -0.08397768f, 0.05909633f, 0.03877591f, -0.05024511f, 0.04217365f, 0.03200152f, -0.07210116f, 0.04568475f, 
    0.15763901f, 0.13494566f, -0.01779793f, 0.03426769f, 0.14929266f, 0.04866860f, 0.04343357f, 0.09148692f, 
    0.17940080f, 0.02564502f, 0.00436863f, 0.02775787f, -0.00364172f, -0.05638042f, -0.03932729f, 0.02969008f, 
    0.08375829f, -0.05046526f, -0.01100829f, 0.03253440f, 0.13912462f, 0.06956109f, -0.05293470f, 0.04088476f, 
    -0.38273114f, -0.03402352f, -0.14508100f, -0.04196950f, 0.06758260f, -0.03556250f, 0.06784508f, -0.09152585f, 
    0.08108339f, -0.03660632f, -0.02329824f, 0.02670160f, -0.04445924f, 0.02295864f, -0.01449496f, -0.00619171f, 
    0.01836633f, -0.03204265f, 0.05253510f, -0.02108569f, 0.17484054f, 0.17104438f, 0.10460699f, 0.07919113f, 
    0.09488961f, 0.00300934f, 0.00272395f, 0.03195555f, -0.02208176f, -0.00496044f, 0.06924975f, 0.00831947f, 
    0.02012540f, 0.03855821f, -0.02345467f, -0.05231360f, 0.03318564f, 0.00420645f, 0.02119577f, -0.00531008f, 
    -0.00151820f, 0.07163981f, 0.03958192f, 0.01552187f, 0.01474123f, 0.12220819f, 0.00395887f, 0.05373888f, 
    0.09832746f, 0.05016704f, 0.02516055f, -0.02209019f, 0.02428756f, -0.02529374f, 0.04060181f, -0.08855683f, 
    -0.18726584f, -0.24115609f, -0.04022805f, -0.03536997f, -0.18332328f, -0.13455386f, -0.18415369f, 0.01078233f, 
    0.01582269f, 0.00677019f, 0.17697091f, 0.08831587f, -0.18593824f, -0.04039738f, 0.05084953f, 0.10782672f, 
    -0.05141240f, 0.07531651f, 0.02745074f, -0.00164729f, 0.01333543f, -0.04710259f, 0.02136549f, 0.06527977f, 
    -0.54777408f, -0.04269703f, -0.07265008f, 0.01082618f, 0.07577790f, 0.07242457f, -0.00612436f, 0.09652329f, 
    -0.09715208f, -0.06854157f, -0.10557050f, 0.06005725f, 0.00775295f, -0.01599381f, 0.02559498f, 0.05395070f, 
    0.08386447f, 0.03648320f, -0.16640246f, 0.01435241f, 0.06223230f, 0.04243521f, 0.06235186f, 0.08224273f, 
    0.05363055f, -0.06165403f, 0.11972152f, 0.05570646f, 0.08879795f, -0.02643960f, -0.01659037f, -0.01073340f, 
    0.04304567f, 0.01028637f, -0.06130889f, -0.03881633f, 0.05141317f, -0.10885385f, -0.02821153f, 0.00532004f, 
    -0.53587532f, 0.11529870f, -0.08147991f, -0.01358562f, -0.03025706f, -0.10228846f, -0.02547019f, 0.04353669f, 
    0.02919924f, 0.11106173f, 0.01807315f, 0.05196113f, -0.01306178f, 0.05904762f, -0.09070399f, -0.05121481f, 
    0.08253612f, 0.00224221f, -0.02826183f, 0.01776939f, 0.15541001f, -0.11458196f, -0.09959130f, -0.05715811f, 
    -0.08164143f, -0.03237334f, -0.00730998f, 0.00986450f, 0.08599204f, 0.08620042f, -0.02627581f, -0.01464950f, 
    0.05718878f, 0.00205793f, -0.04247773f, -0.03193420f, -0.02499299f, -0.04997632f, -0.00593587f, -0.00127870f, 
    0.13876869f, 0.09825553f, 0.07866476f, 0.00754429f, 0.13456751f, -0.04971973f, 0.11722466f, 0.08418386f, 
    -0.05462654f, 0.06829536f, -0.01853961f, 0.05788622f, 0.17666759f, 0.05093174f, -0.13098443f, -0.00058085f, 
    0.06130548f, 0.00574884f, -0.08424988f, -0.09292645f, -0.15844299f, -0.00410903f, -0.03296023f, 0.16264974f, 
    0.12055968f, 0.02383386f, 0.00037469f, 0.00349050f, 0.02390854f, -0.01758002f, 0.05761100f, 0.03063649f, 
    0.04657712f, 0.00693256f, 0.11598397f, -0.09154656f, -0.07578801f, 0.04954378f, 0.04498821f, -0.23027901f, 
    -0.04241863f, -0.11833341f, -0.47437602f, -0.28892192f, -0.64425540f, -0.21475925f, -0.34030265f, -0.18038790f, 
    -0.11611718f, 0.05835509f, -0.02803184f, -0.02564406f, 0.00069167f, 0.01206992f, 0.00121316f, 0.08721245f, 
    0.06364683f, -0.33449990f, -0.07306734f, -0.00899525f, 0.94590998f, 0.13326494f, -0.29351938f, -0.01673782f, 
    -0.23132661f, -0.04302496f, 0.00121993f, -0.00771417f, -0.01676061f, -0.00166089f, 0.10259411f, -0.04989970f, 
    0.04268526f, -0.07796608f, -0.01920077f, 0.05530981f, 0.01420463f, -0.08415405f, -0.00708410f, 0.12271954f, 
    0.38703948f, -0.10797394f, -0.11876664f, -0.20296153f, -0.08774716f, -0.00877601f, -0.07729913f, -0.04587838f, 
    -0.04301240f, -0.07327821f, 0.00315333f, 0.02675364f, 0.04792671f, -0.00987219f, 0.03060222f, -0.06609230f, 
    -0.07845626f, -0.20904975f, 0.01194867f, -0.02453570f, 0.13234849f, -0.17934413f, 0.32391909f, -0.05625282f, 
    0.02248538f, 0.15142097f, -0.03022530f, -0.03405463f, 0.02369430f, -0.02132062f, 0.03111231f, -0.01222631f, 
    0.02386193f, 0.01704681f, -0.00021588f, -0.06541352f, 0.25774178f, -0.02172234f, 0.08769767f, -0.02674755f, 
    -0.78470075f, -0.18395747f, -0.46801671f, -0.33340991f, 0.39163092f, 0.04715602f, -0.10909341f, -0.15864454f, 
    0.08590453f, -0.04879710f, 0.00729667f, 0.07970261f, 0.00752738f, -0.04619274f, -0.02548374f, -0.00058289f, 
    -0.03789070f, 0.15350088f, -0.16602224f, -0.19036567f, -1.37175047f, -0.19271398f, -0.09578086f, -0.08330389f, 
    -0.03425731f, 0.07706141f, -0.05653539f, 0.09304585f, -0.14249472f, -0.14332777f, 0.02656466f, 0.05925463f, 
    -0.07403527f, -0.17595823f, 0.15810181f, 0.30399883f, -0.04484637f, 0.07855994f, -0.07652131f, -0.10885195f, 
    0.14561696f, 0.07914259f, 0.15235901f, 0.09218513f, 0.10982376f, 0.02432537f, 0.02491016f, -0.00540750f, 
    -0.03498552f, 0.03654764f, 0.10222430f, -0.01989074f, 0.00514133f, 0.00774289f, 0.04967128f, -0.13375731f, 
    0.02561881f, -0.04303928f, 0.00416493f, 0.01093862f, 0.63065541f, 0.05185461f, -0.23123489f, 0.00622005f, 
    -0.19845593f, -0.19086297f, 0.10568409f, -0.05355460f, -0.02451540f, 0.13769504f, 0.09474748f, 0.06462627f, 
    -0.06907137f, 0.02381728f, 0.10921933f, -0.01077823f, -0.04440694f, -0.12564921f, 0.01245287f, 0.15253480f, 
    0.10085171f, -0.08031555f, -0.09975541f, 0.00480992f, -0.09950213f, -0.05565300f, -0.02538401f, 0.01988292f, 
    0.02864242f, 0.01574883f, -0.06040115f, 0.03171665f, 0.02848281f, -0.02393225f, -0.06882949f, -0.02062904f, 
    -0.01219904f, -0.01498637f, 0.01462199f, -0.01508745f, 0.08849999f, 0.09624729f, 0.35424733f, 0.14366625f, 
    -0.32976678f, 0.04674962f, 0.00171384f, 0.00747451f, -0.06382902f, 0.03169282f, 0.00220439f, -0.02847312f, 
    -0.01850198f, 0.08452375f, -0.02700678f, 0.08614600f, -0.13358283f, 0.07144339f, 0.12596892f, -0.02936493f, 
    0.20588881f, 0.02875940f, 0.12541981f, 0.07410371f, 0.02785225f, 0.00615327f, -0.01324032f, 0.01969888f, 
    -0.01769091f, 0.00420659f, 0.01922365f, -0.00169772f, 0.00476623f, -0.01053151f, -0.06040585f, -0.02324803f, 
    -0.00936498f, -0.06732817f, -0.02804231f, 0.01528716f, 0.21648370f, 0.16754311f, 0.23501438f, 0.01654563f, 
    0.08390531f, 0.06073777f, -0.07431378f, -0.12808637f, 0.02399290f, -0.07162555f, 0.00710191f, -0.03317498f, 
    -0.00990731f, 0.01530387f, 0.06383069f, 0.05728608f, -0.04133578f, -0.07168183f, 0.08806122f, -0.15718566f, 
    -0.10585598f, -0.00584791f, -0.07383325f, 0.00638753f, -0.02184097f, 0.04437229f, -0.00038836f, -0.00505899f, 
    0.12133105f, -0.05624168f, -0.11317641f, 0.05066738f, 0.02394695f, 0.03284688f, 0.00215652f, -0.00184364f, 
    0.02679623f, 0.06408077f, 0.04668330f, 0.01350980f, 0.09099215f, -0.16793223f, 0.18543921f, -0.03169502f, 
    0.03344121f, 0.00649480f, 0.02921399f, -0.05478054f, 0.04333036f, 0.04819938f, 0.06063127f, -0.00175674f, 
    0.02201780f, 0.00896215f, 0.05138684f, 0.00272562f, 0.13187382f, -0.07793399f, 0.07315707f, -0.00312439f, 
    0.29716569f, 0.00897218f, -0.24268062f, 0.03125855f, -0.34450850f, 0.14964211f, -0.06348590f, -0.08247768f, 
    -0.02952467f, -0.16521925f, 0.07529469f, 0.02575861f, 0.08414049f, 0.01883064f, 0.02323612f, -0.04256848f, 
    0.02440815f, -0.22459662f, -0.02648873f, 0.03585759f, -0.43267557f, -0.12391129f, 0.03500865f, 0.02256378f, 
    -0.03926953f, 0.19864193f, -0.13906389f, 0.02363998f, -0.47566167f, 0.03230643f, -0.06739479f, -0.01524263f, 
    -0.10830159f, -0.01782299f, -0.09178298f, 0.04578738f, 0.01355702f, 0.01498408f, 0.00061803f, 0.06915864f, 
    0.18024485f, 0.18890253f, 0.11603810f, 0.01693039f, 0.15060258f, 0.12039572f, -0.05876691f, 0.02030525f, 
    0.02496845f, 0.12588724f, 0.00908909f, 0.00584474f, 0.03323536f, -0.00367022f, 0.12681192f, -0.04447408f, 
    -0.01546386f, 0.16555066f, -0.17045905f, -0.02279158f, -0.00504424f, -0.25148022f, -0.10144500f, -0.07215087f, 
    0.06527997f, 0.03294645f, -0.01495263f, -0.00133362f, 0.01850876f, 0.04641397f, -0.05470449f, 0.03240418f, 
    -0.05690819f, -0.03812486f, -0.11601371f, 0.08044819f, 0.02418427f, 0.04781738f, 0.03570011f, 0.01062992f, 
    -0.23987789f, 0.09442864f, -0.00301028f, 0.24300785f, 0.15728793f, 0.01572502f, 0.08615488f, 0.05231825f, 
    0.02345127f, -0.00789626f, -0.02920899f, -0.06107023f, 0.04204848f, -0.00769436f, 0.00893788f, -0.03159300f, 
    0.01016997f, 0.00184105f, -0.09305277f, 0.08862829f, 0.83996505f, 0.22111815f, -0.21363389f, -0.12991217f, 
    -0.00942586f, -0.11358134f, 0.03493711f, -0.01047871f, 0.10598563f, 0.01412553f, -0.02011905f, 0.07669283f, 
    -0.17226274f, 0.02503386f, -0.00883608f, -0.09628739f, 0.09482136f, 0.05785754f, 0.01392079f, 0.10735985f, 
    -0.03468435f, 0.06283413f, 0.04810869f, -0.04577861f, 0.05708177f, 0.07470511f, 0.01112164f, 0.01429914f, 
    0.06758060f, 0.06459378f, -0.06108619f, -0.00222151f, 0.02712076f, 0.06056298f, -0.04842705f, -0.12085749f, 
    0.00416668f, 0.01523962f, -0.00936653f, -0.04985858f, -0.03900149f, -0.07729083f, 0.11274420f, 0.08948832f, 
    0.03408201f, -0.03965218f, -0.04741570f, 0.11939086f, 0.02018367f, -0.01798612f, -0.00596537f, -0.01499197f, 
    -0.01511655f, -0.06365970f, 0.02022325f, 0.05724761f, 0.01620627f, 0.04373628f, 0.01309913f, -0.00188406f, 
    -0.18950389f, -0.11233097f, 0.01504222f, 0.00241513f, -0.07041916f, 0.07512926f, 0.10520033f, 0.23907138f, 
    0.12203225f, -0.29228139f, -0.00092634f, -0.16250210f, 0.07473954f, -0.00494092f, -0.04682134f, 0.02192860f, 
    0.01808169f, 0.01661824f, -0.02165487f, -0.00161824f, -0.22692133f, 0.04981295f, -0.03524402f, 0.14365205f, 
    0.08236056f, 0.02622088f, -0.01698327f, -0.01519497f, -0.05704571f, 0.05923272f, 0.04797984f, -0.01715057f, 
    0.01924322f, 0.09157541f, 0.02499209f, -0.02169375f, -0.03122614f, 0.01330962f, -0.07144132f, 0.05785984f, 
    0.17858036f, 0.15493453f, 0.11775357f, 0.09164143f, 0.15087490f, -0.00566736f, -0.01050984f, 0.01330009f, 
    -0.00486358f, -0.00816394f, 0.01441175f, 0.06558717f, 0.06641965f, 0.02330249f, -0.04422833f, -0.04639812f, 
    -0.02850548f, -0.13135193f, -0.00858316f, -0.02362031f, 0.06222631f, -0.09984096f, -0.09385706f, -0.08528081f, 
    -0.00926248f, -0.05614739f, -0.02746273f, 0.02760740f, 0.04239170f, -0.13395140f, 0.01167872f, -0.06340998f, 
    0.02318358f, -0.05975588f, -0.04131219f, -0.02041932f, -0.02061315f, -0.01402955f, -0.00136550f, 0.01668390f, 
    0.21282879f, 0.23650832f, 0.16338080f, 0.09876653f, 0.13865902f, -0.01481201f, -0.00176475f, -0.00583631f, 
    -0.02557047f, -0.03138682f, -0.01028470f, -0.00689516f, 0.04736448f, 0.02456164f, 0.03789790f, 0.08087049f, 
    0.00581454f, 0.06347892f, 0.13004476f, -0.08095934f, 0.19763660f, 0.12836832f, 0.13571705f, 0.09387563f, 
    0.10360896f, 0.02911515f, 0.03091216f, 0.02075335f, -0.00632436f, -0.04375941f, 0.00097512f, 0.02999794f, 
    0.03893766f, 0.03202591f, -0.01427275f, -0.01375496f, 0.06124490f, -0.05961896f, 0.00386042f, -0.01289330f, 
    -0.07921424f, 0.05178848f, -0.03288115f, 0.00421189f, -0.09949844f, 0.08098740f, 0.06267884f, -0.33775014f, 
    -0.07892972f, 0.06439099f, 0.02864663f, 0.02390636f, 0.01282845f, 0.00998283f, 0.02262996f, -0.10002828f, 
    -0.00727443f, -0.08011498f, -0.33726516f, -0.25620568f, -0.24404338f, -0.27716064f, 0.00906990f, -0.11800422f, 
    0.14476511f, 0.07707786f, -0.29343751f, -0.19461574f, 0.17188691f, -0.05860145f, -0.01155332f, -0.04896726f, 
    0.06036415f, 0.00713582f, 0.05254453f, -0.05759469f, 0.06425468f, 0.04114616f, 0.07733433f, 0.08851930f, 
    0.07252415f, 0.20100957f, 0.05519845f, 0.10285009f, 0.15369870f, 0.06467890f, -0.08767478f, 0.01650550f, 
    -0.09632277f, 0.06574971f, -0.01885070f, -0.02218774f, -0.01620257f, 0.00433355f, 0.06351913f, 0.00152068f, 
    0.02117319f, 0.10777894f, -0.20689012f, 0.03781443f, 0.02096087f, 0.03018203f, 0.02363173f, 0.05506695f, 
    -0.05832916f, 0.01773201f, -0.10689652f, -0.02661213f, 0.05281088f, -0.01942270f, 0.00628273f, 0.03588335f, 
    -0.00342905f, 0.04482735f, -0.02435458f, -0.10494383f, 0.07400814f, -0.00838744f, 0.13401815f, 0.07227159f, 
    0.02271375f, 0.05176765f, 0.31273279f, 0.02662740f, 0.13815957f, -0.00327828f, -0.00453520f, 0.04962447f, 
    0.03487179f, -0.23091105f, 0.03538508f, -0.08874573f, -0.08254082f, -0.00787379f, 0.11159801f, 0.02499491f, 
    -0.05280922f, -0.03365825f, 0.03217349f, -0.05754664f, 0.01002973f, -0.01142295f, -0.06964689f, -0.01484094f, 
    -0.00078597f, 0.01365234f, -0.05265697f, -0.03623679f, 0.01013437f, -0.16246323f, 0.02042370f, 0.04317401f, 
    0.02497143f, -0.00201032f, 0.01866244f, 0.02254897f, 0.01091979f, -0.09216592f, 0.13990283f, -0.12051249f, 
    -0.06891602f, -0.28230312f, 0.32308272f, -0.02694310f, -0.27526715f, -0.05475825f, -0.01205922f, -0.01679127f, 
    -0.01486966f, 0.05026417f, -0.00066168f, -0.01885635f, -0.00083355f, -0.00748915f, -0.01348161f, 0.10538630f, 
    0.01821768f, 0.08009506f, 0.13550295f, 0.12945721f, 0.03862192f, -0.10471269f, -0.09448598f, 0.02239061f, 
    0.07629428f, -0.06036257f, -0.04402666f, -0.05649959f, -0.04435967f, -0.01015441f, 0.07485054f, -0.02142968f, 
    -0.07186394f, -0.00152449f, 0.08936328f, 0.09742428f, 0.10243821f, 0.02135605f, 0.06726312f, 0.06838322f, 
    -0.04029843f, -0.06399242f, -0.07202093f, -0.03130065f, -0.07470225f, 0.01913991f, 0.06647891f, 0.08215826f, 
    -0.06555686f, 0.03708332f, 0.09977736f, 0.02604515f, -0.07655240f, 0.05197595f, -0.07482203f, 0.06786616f, 
    0.02808148f, 0.09464258f, -0.00842549f, -0.15694736f, -0.05216418f, -0.17735028f, 0.15278165f, -0.21064188f, 
    -0.04260248f, 0.06408500f, -0.01889640f, -0.29135299f, -0.00077238f, -0.00964559f, 0.03380062f, -0.02423791f, 
    0.04732321f, 0.03084325f, -0.09410401f, 0.06981533f, -0.02950766f, -0.22954075f, -0.06413086f, -0.08106373f, 
    -0.24058104f, 0.01919039f, 0.45705345f, 0.22387926f, 0.18541886f, -0.04426980f, -0.06557990f, -0.13380063f, 
    -0.02808759f, -0.00111016f, 0.01602054f, -0.01623282f, 0.07369262f, -0.00356228f, 0.03870954f, 0.00087927f, 
    0.18137959f, 0.15698658f, -0.07538398f, 0.00859314f, -0.34484139f, -0.06930028f, -0.13153858f, 0.08650856f, 
    -0.10619817f, 0.02359592f, 0.01320663f, -0.00306575f, -0.04514501f, 0.05521451f, 0.03272444f, -0.02203072f, 
    0.01445513f, 0.01899483f, -0.00694248f, 0.05747739f, 0.05642591f, 0.08948284f, -0.04576972f, -0.00664980f, 
    -0.06449562f, -0.67639613f, 0.23230317f, -0.02261030f, -0.20219947f, -0.02419548f, -0.06784683f, -0.23720556f, 
    -0.03407528f, -0.08084759f, -0.06690244f, -0.04340250f, 0.01754165f, 0.01134462f, -0.01337923f, -0.13656701f, 
    -0.14053059f, -0.09619946f, 0.11925239f, 0.16075413f, 0.26459402f, 0.05856897f, 0.01402489f, -0.01577275f, 
    0.08472706f, 0.07281365f, -0.18914241f, -0.03195269f, 0.03241524f, 0.11213557f, -0.02735196f, -0.08004824f, 
    0.08154771f, -0.05828321f, -0.09850008f, 0.04860458f, 0.01658642f, 0.00230279f, -0.01032723f, 0.02938386f, 
    0.22777303f, 0.11798902f, -0.01351060f, 0.19923417f, 0.18905009f, -0.09887490f, 0.04093011f, 0.08695202f, 
    -0.17914206f, 0.09166211f, 0.01312968f, 0.00433165f, 0.04849852f, -0.05031802f, 0.08337808f, -0.05543203f, 
    -0.03730274f, -0.06184929f, -0.01401423f, -0.07261418f, -0.20477650f, -0.06131909f, 0.53723508f, 0.40022928f, 
    0.24836756f, -0.04398620f, -0.10496347f, -0.03884502f, 0.15359275f, -0.03009515f, 0.03608371f, 0.01609227f, 
    0.02684446f, -0.05836868f, 0.02060237f, -0.02304355f, 0.00243813f, 0.00940125f, -0.01784902f, -0.02498228f, 
    -0.31531683f, -0.14761379f, 0.04689053f, -0.22560742f, -0.12278433f, -0.02446684f, -0.00564213f, -0.06016049f, 
    0.03191168f, 0.03456449f, -0.00298170f, 0.02748355f, -0.05108132f, 0.04620436f, -0.06709566f, -0.02194961f, 
    -0.17483993f, -0.05096681f, 0.05289644f, -0.04268565f, 0.05078067f, -0.10756169f, 0.09581094f, -0.08265931f, 
    0.07103760f, 0.00350332f, -0.11740350f, -0.05335095f, -0.04902374f, -0.02166197f, -0.07315044f, -0.04223284f, 
    -0.01392039f, -0.03959738f, 0.03145425f, 0.08007335f, -0.07200669f, -0.08119462f, 0.08907736f, -0.05716000f, 
    0.34187236f, -0.11050341f, -0.20646580f, -0.17483337f, 0.15023726f, 0.07272544f, -0.00586885f, 0.02262660f, 
    -0.00055297f, 0.04172815f, -0.18568233f, 0.04343255f, 0.12088456f, -0.05880027f, -0.03977573f, 0.06243929f, 
    -0.12762408f, -0.05204897f, 0.09334543f, -0.01951589f, -0.08083560f, -0.00741265f, -0.03658823f, -0.00081690f, 
    0.00001113f, -0.00230919f, 0.00209033f, -0.10503106f, -0.03413837f, -0.00377445f, 0.04562099f, -0.19592130f, 
    0.05981648f, 0.02303517f, 0.00184103f, 0.00266316f, 0.03464001f, -0.12597406f, 0.04645705f, -0.00210142f, 
    -0.15803207f, -0.07136596f, 0.26212430f, 0.02282487f, 0.15856439f, 0.03476329f, -0.02275417f, -0.11366162f, 
    -0.00806482f, -0.04445655f, 0.04571160f, -0.01589204f, 0.05550747f, -0.15182902f, 0.14506611f, 0.09859369f, 
    0.11399094f, 0.03183535f, 0.00595668f, -0.05004800f, -0.24955899f, 0.40711871f, 0.44165194f, 0.20763341f, 
    -0.04257789f, -0.14855187f, -0.04855835f, 0.01352522f, -0.12863660f, 0.10693847f, 0.03872307f, 0.06456771f, 
    0.08144227f, -0.14981796f, 0.01514267f, -0.04995652f, 0.04275841f, 0.02958360f, 0.11000432f, -0.12950306f, 
    -0.11685557f, -0.09639942f, 0.01393992f, -0.04767771f, 0.08448111f, -0.09005260f, -0.06380000f, -0.28142735f, 
    -0.12356424f, -0.01052942f, 0.03282719f, -0.03209886f, -0.01322775f, -0.00061942f, -0.02490006f, 0.04822724f, 
    -0.07226463f, -0.06007841f, -0.03841330f, -0.02960763f, -0.08819775f, 0.05917562f, -0.07308587f, 0.15431567f, 
    0.08962328f, 0.06532674f, 0.00743285f, -0.10487065f, 0.12107270f, -0.01763928f, -0.03780952f, 0.05108407f, 
    -0.00780463f, -0.07521447f, 0.02180810f, -0.01986581f, 0.14792806f, 0.08594643f, 0.01826663f, 0.12969516f, 
    0.21763307f, 0.11879732f, -0.17282525f, 0.04247623f, 0.12961748f, -0.07730342f, -0.00152007f, -0.05584062f, 
    -0.10550437f, -0.02838969f, -0.05276028f, 0.09756215f, 0.08495622f, -0.07901996f, 0.00482492f, -0.02070198f, 
    -0.05374956f, 0.05385977f, -0.08101134f, -0.01240985f, 0.02587373f, 0.07034182f, -0.01285794f, -0.12178309f, 
    0.11610166f, 0.04227586f, -0.02418187f, -0.02693586f, 0.00331184f, 0.05221622f, 0.01389749f, 0.04547408f, 
    0.07437552f, -0.12615143f, 0.04807077f, 0.02545235f, 0.02167226f, -0.00096425f, 0.04510828f, 0.04009603f, 
    0.24404325f, -0.01003009f, -0.21589220f, 0.12479954f, -0.06969368f, -0.02646689f, 0.08933412f, 0.08283294f, 
    0.04174835f, 0.08825091f, -0.01677043f, 0.01297021f, -0.01367337f, 0.02855359f, -0.03792588f, 0.04783855f, 
    0.00735649f, 0.03569810f, -0.07002597f, 0.13092245f, -0.18055198f, -0.17644238f, -0.04065444f, -0.12018899f, 
    0.05033103f, -0.03091382f, -0.02432113f, -0.02102990f, -0.00594141f, 0.03802417f, 0.00097380f, -0.01645756f, 
    -0.04614532f, -0.00323192f, -0.03068357f, -0.11943443f, -0.10555169f, 0.04123421f, 0.02755789f, -0.01823276f, 
    -0.13298069f, 0.02209782f, -0.00650747f, 0.23209178f, 0.04917731f, 0.01010245f, -0.03898006f, -0.03301840f, 
    0.01468634f, -0.04797691f, 0.02117418f, -0.01096060f, -0.01487103f, -0.05243862f, -0.00993488f, 0.10862403f, 
    0.11693788f, 0.17094959f, 0.06583095f, 0.08554783f, -0.01709325f, 0.00953950f, -0.07775902f, 0.04371494f, 
    0.06462697f, -0.05594615f, -0.07121199f, -0.08889702f, 0.02376440f, -0.14980592f, 0.01674141f, 0.08351866f, 
    -0.01347062f, 0.01113878f, 0.02025397f, 0.04588257f, -0.00315712f, -0.01997660f, -0.04798842f, -0.06804752f, 
    0.05566679f, -0.07109997f, -0.18417728f, 0.35528994f, 0.07975581f, 0.07200084f, -0.00920916f, 0.03441234f, 
    -0.04609329f, 0.00694511f, -0.03988266f, 0.06312135f, 0.03128664f, -0.00867285f, 0.04715534f, -0.02564043f, 
    -0.01949417f, -0.02382426f, 0.02531077f, -0.03533126f, 0.11318082f, -0.39158601f, 0.03252950f, 0.19526938f, 
    -0.10522009f, 0.03362031f, 0.03045826f, -0.05194094f, 0.16568956f, -0.03684271f, 0.04955504f, -0.00537030f, 
    0.00868814f, 0.01490493f, 0.01200793f, 0.01623818f, 0.06251299f, -0.02769268f, -0.00502132f, 0.00295244f, 
    0.53408247f, 0.14463635f, -0.34807721f, 0.20054352f, 0.11191685f, -0.10354779f, 0.10374695f, -0.05258682f, 
    -0.07937960f, 0.11448395f, -0.02632631f, 0.00819198f, -0.00013131f, 0.02978061f, -0.03187550f, 0.03256624f, 
    -0.03422599f, -0.03732899f, -0.15998404f, 0.13348790f, 0.04611944f, -0.10750680f, 0.30394953f, 0.08190382f, 
    0.21029823f, 0.00798359f, -0.04063228f, 0.01595871f, 0.09445151f, -0.13655716f, 0.04855889f, 0.03269297f, 
    -0.05812510f, 0.01001145f, 0.00948406f, 0.04860562f, -0.03584879f, 0.00637490f, -0.02880938f, -0.00406177f, 
    0.10319933f, 0.11432094f, -0.08470329f, -0.15653162f, -0.00788686f, 0.01299285f, 0.01434474f, -0.04091194f, 
    0.01412418f, 0.04614974f, -0.01860314f, -0.02563001f, 0.17109796f, -0.02182541f, 0.06285337f, 0.05731761f, 
    -0.02875908f, -0.04857861f, 0.10181337f, 0.03277220f, 0.02462439f, -0.01001845f, -0.13530877f, -0.10257699f, 
    0.12378247f, 0.08536355f, 0.01223358f, -0.03699282f, 0.06104914f, 0.00223288f, 0.00751558f, 0.02409718f, 
    -0.00617810f, 0.01552283f, 0.01139133f, -0.04018110f, 0.11210177f, 0.07749075f, 0.07124152f, 0.12678009f, 
    -1.13759434f, 0.03543008f, 0.33621484f, -0.07022520f, -0.17794894f, 0.05505988f, -0.00885601f, -0.28649017f, 
    -0.18767321f, -0.07835411f, 0.04458429f, -0.00825003f, -0.01365697f, -0.03347473f, -0.04046668f, -0.02687239f, 
    -0.04426240f, 0.06095392f, -0.04736901f, 0.03171838f, -0.29254124f, 0.30010730f, 0.36330107f, -0.03931550f, 
    -0.08334995f, -0.04952399f, -0.02870749f, -0.06707960f, -0.03238168f, 0.12469303f, 0.03109563f, 0.06609686f, 
    -0.09862896f, -0.00441670f, -0.06897371f, 0.04395708f, 0.05264091f, 0.13829607f, 0.13375565f, -0.06852750f, 
    -0.42130962f, -0.06255364f, 0.33754906f, -0.37559786f, 0.09666296f, -0.01717184f, -0.02369706f, -0.00833263f, 
    0.09093309f, -0.00008478f, 0.01125888f, -0.02541498f, -0.02248827f, -0.02109858f, -0.00308746f, 0.01910536f, 
    0.06360850f, 0.05885760f, 0.03427352f, -0.05757336f, -0.15821397f, -0.17232741f, 0.04214875f, -0.15848000f, 
    0.07876877f, -0.10338387f, 0.06962320f, -0.00527920f, -0.01244534f, 0.05529159f, 0.02791476f, -0.00813906f, 
    -0.03964255f, 0.02022498f, -0.00735033f, -0.02701948f, -0.04933381f, 0.05776561f, 0.02313385f, -0.06741868f, 
    0.39340296f, -0.00845282f, -0.83724689f, -0.07805569f, -0.02553890f, 0.11281070f, 0.04835975f, -0.02934973f, 
    0.10403159f, 0.11161306f, -0.04643768f, -0.02667310f, -0.01000137f, 0.04549538f, -0.18471687f, 0.01120868f, 
    0.02480626f, 0.02984958f, -0.19458936f, 0.01204322f, -0.09973226f, -0.07669352f, -0.65545225f, 0.19581471f, 
    0.08892164f, -0.04353683f, -0.02939434f, -0.06742842f, -0.12556693f, -0.01724389f, -0.04083027f, -0.05481349f, 
    0.05628433f, -0.15112130f, -0.08204682f, -0.07315563f, 0.09454337f, 0.08115284f, -0.14011212f, 0.08313304f, 
    0.02666059f, -0.03842102f, -0.05650092f, -0.06851425f, 0.07071093f, -0.05339850f, -0.05804963f, -0.02522363f, 
    0.04107011f, 0.01802828f, 0.01102376f, -0.02712017f, -0.11805426f, 0.04472271f, -0.02684679f, 0.04420700f, 
    -0.01505459f, 0.06308294f, 0.03699839f, 0.00099887f, -0.23006308f, 0.22369820f, 0.27434856f, -0.11901949f, 
    0.00848646f, 0.00187056f, -0.03990633f, -0.11776421f, 0.06376915f, 0.10030300f, -0.01517719f, 0.03201420f, 
    -0.08071177f, 0.04986711f, 0.06780402f, 0.04412382f, 0.00115692f, -0.13604596f, 0.13965566f, -0.02370861f, 
    -0.04503763f, -0.12886196f, 0.25863078f, 0.05619429f, 0.16627774f, 0.00380259f, -0.01956287f, 0.02805271f, 
    0.07421005f, -0.14498009f, -0.06410660f, -0.02437016f, -0.12059110f, -0.02829766f, 0.01457781f, -0.00075750f, 
    -0.00425631f, -0.01101182f, 0.02412819f, -0.03253819f, -0.66371316f, 0.32474241f, 0.21853562f, 0.13608481f, 
    -0.43597043f, -0.00010133f, -0.05744290f, -0.10774823f, -0.11097246f, 0.16151199f, -0.05006467f, 0.02494699f, 
    -0.05841454f, 0.08879829f, 0.03081996f, 0.10673302f, 0.00739155f, 0.02790225f, 0.00038239f, -0.08624990f, 
    0.02778520f, -0.07741793f, -0.06433856f, -0.00226052f, 0.04057565f, -0.03933253f, 0.00089446f, 0.03251578f, 
    0.00626833f, -0.01210436f, -0.03659904f, 0.01531843f, -0.00875064f, -0.04598206f, 0.00940857f, -0.00214291f, 
    -0.02553856f, 0.02774922f, 0.06151358f, -0.03563006f, -0.30126205f, -0.17311645f, 0.10809792f, -0.37000194f, 
    -0.21191892f, -0.04317017f, 0.04895995f, 0.01031821f, 0.04684459f, 0.08041874f, 0.02542014f, -0.01573428f, 
    -0.02796014f, 0.05419054f, -0.08079470f, -0.01106739f, -0.03006245f, -0.05681236f, -0.03934658f, -0.00755223f, 
    0.23981473f, -0.08251248f, 0.04963100f, 0.05004635f, 0.04454893f, 0.10274650f, -0.05110453f, -0.10675946f, 
    0.09403721f, -0.05006624f, -0.00975611f, 0.08774618f, 0.00852186f, 0.04371410f, -0.02841786f, 0.00256975f, 
    -0.00907712f, -0.15059622f, 0.07409157f, 0.00521686f, 0.04666673f, -0.06548428f, 0.16490287f, -0.18220165f, 
    0.10629227f, 0.05117085f, 0.00066617f, -0.07463443f, -0.01951658f, 0.03316605f, 0.01956183f, -0.03345627f, 
    0.01597322f, 0.02492905f, -0.00311787f, 0.07004872f, -0.02934235f, -0.12522809f, 0.06798340f, 0.03525462f, 
    -0.45199114f, 0.37669647f, -0.10977886f, 0.06319539f, -0.40002304f, 0.01916882f, -0.15787716f, -0.07496814f, 
    -0.06759728f, 0.03703327f, -0.04382234f, 0.05029434f, -0.01024755f, -0.12543868f, 0.00517482f, 0.00934802f, 
    0.06946837f, 0.07158108f, 0.18921410f, 0.10798731f, -0.31897607f, 0.48675641f, 0.27145526f, -0.03543343f, 
    0.36725065f, -0.23189934f, -0.01199520f, -0.09157494f, 0.08104298f, 0.08205871f, 0.01249561f, 0.01754144f, 
    0.02749452f, 0.02931118f, 0.09503383f, 0.07295544f, -0.02751938f, 0.01787067f, -0.00045567f, 0.07438620f, 
    -0.42311126f, -0.62307245f, -0.19542766f, 0.02495576f, -0.43260339f, 0.04856212f, 0.06066403f, 0.02014776f, 
    0.01747218f, -0.01640490f, 0.00425121f, -0.01744987f, -0.02291382f, 0.01989080f, -0.06413278f, -0.09537799f, 
    -0.04984893f, -0.05969214f, -0.03906478f, 0.11510278f, 0.30853963f, -0.04013389f, -0.08001476f, -0.05195735f, 
    0.14435431f, 0.04778061f, 0.04987707f, -0.05078197f, -0.00790872f, 0.04932255f, 0.01651108f, -0.00265956f, 
    0.06999251f, 0.05741281f, -0.00849207f, 0.08455700f, -0.05270379f, -0.01639869f, 0.01782617f, 0.06842168f, 
    -0.29751402f, -0.27224174f, -0.28144577f, 0.02702313f, -0.28467771f, 0.07418662f, 0.03749411f, 0.03250044f, 
    0.03729283f, -0.03210767f, 0.05238344f, 0.05718298f, 0.05748230f, 0.01730865f, -0.03171353f, -0.00146091f, 
    0.02699145f, -0.00338301f, -0.07761782f, -0.03427903f, -0.21348552f, 0.13464092f, -0.07580858f, 0.06040502f, 
    -0.02535076f, -0.06239489f, -0.06867748f, -0.06396465f, -0.01306065f, 0.08185875f, 0.04850399f, 0.11356460f, 
    -0.26850408f, 0.07068477f, 0.05500911f, 0.12388198f, -0.06987358f, 0.06697821f, 0.08302121f, -0.02925920f, 
    0.20498365f, -0.07883178f, -0.01708421f, 0.05628188f, 0.05212627f, 0.11274374f, -0.15708184f, -0.04615645f, 
    -0.03883594f, 0.17919207f, -0.17448296f, -0.11148985f, 0.06300669f, -0.01073084f, -0.01478285f, 0.03214742f, 
    -0.02745677f, -0.08311515f, -0.01210521f, -0.10395333f, 0.09737832f, -0.04713219f, -0.20002960f, -0.00673755f, 
    0.05713689f, 0.04996489f, -0.01331061f, 0.03776584f, -0.04679313f, -0.04176903f, -0.02932414f, 0.03049550f, 
    0.03648890f, -0.11374640f, 0.08496257f, 0.06305695f, 0.03307236f, 0.00394344f, 0.11331997f, 0.03932829f, 
    0.06809796f, -0.06669888f, 0.32153621f, 0.31726849f, 0.09463615f, -0.02531816f, -0.03806714f, 0.06552749f, 
    0.02689965f, -0.05215986f, 0.07133001f, 0.03909475f, 0.08548704f, 0.01349648f, 0.06252833f, -0.03766483f, 
    -0.01946975f, 0.01019631f, -0.00821784f, -0.02189324f, -0.34625903f, -0.07802930f, -0.30347848f, -0.01534342f, 
    -0.20900965f, 0.10234644f, 0.14013426f, -0.03108129f, -0.00469702f, -0.14179899f, -0.00734635f, 0.02575980f, 
    0.00976443f, 0.01207395f, 0.00564199f, 0.01993134f, 0.03543246f, -0.05187635f, -0.06936084f, -0.06595559f, 
    -0.15422411f, -0.13875428f, -0.05280237f, -0.08359777f, -0.06203721f, -0.04507286f, -0.06264270f, -0.02398738f, 
    -0.04032416f, 0.03883462f, -0.10201782f, -0.05928733f, -0.05727531f, -0.07213610f, -0.03711199f, -0.09661563f, 
    -0.07960548f, -0.05793316f, 0.02877956f, -0.00472387f, -0.07923037f, -0.10504351f, 0.21725634f, 0.17678985f, 
    0.07196190f, 0.00602459f, -0.05272347f, 0.02871878f, 0.09990299f, -0.18738118f, 0.01302867f, 0.00405041f, 
    0.04412365f, -0.02983128f, 0.00723332f, -0.01222766f, -0.06218945f, -0.00675023f, 0.04157645f, -0.00518330f, 
    -0.26658958f, -0.13727297f, 0.00996326f, -0.36448085f, -0.26588780f, 0.02729080f, 0.01324072f, 0.02818154f, 
    0.01925693f, 0.01065260f, 0.05772671f, 0.02106927f, -0.05378686f, 0.04054558f, -0.06452366f, -0.04175405f, 
    0.03134862f, -0.06631301f, 0.04496551f, -0.05193204f, -0.27144098f, -0.20116837f, -0.04513863f, -0.04005777f, 
    -0.06735267f, -0.00482624f, -0.04637888f, 0.00577687f, -0.04589866f, 0.02430567f, 0.00290299f, -0.03792113f, 
    -0.03128617f, 0.00287785f, -0.06059438f, -0.12158070f, -0.14697851f, 0.01930997f, 0.01197442f, -0.02396406f, 
    -0.40339676f, -0.82857716f, -0.16684318f, -0.19359550f, -0.10141993f, -0.00597526f, -0.09893114f, -0.09092218f, 
    0.03704339f, -0.05816272f, -0.01890206f, -0.01451747f, -0.01902465f, -0.04856706f, -0.00677805f, -0.04675475f, 
    -0.06304374f, -0.14729586f, 0.11526737f, 0.22034632f, 0.03799193f, -0.03557867f, 0.02658942f, -0.35468587f, 
    0.07403327f, 0.04437125f, -0.03923278f, -0.22582714f, -0.08600342f, 0.06209681f, -0.01405699f, -0.01834264f, 
    0.01775800f, -0.03885260f, -0.01876454f, 0.04264992f, -0.04941763f, -0.09513664f, 0.04021196f, 0.00333019f, 
    -0.37186608f, -0.24842398f, -0.06928820f, 0.05636873f, -0.28821418f, 0.00805551f, 0.05579140f, -0.02079386f, 
    0.12355952f, -0.00265189f, -0.01328824f, -0.00218680f, 0.03218482f, 0.03554675f, -0.03244361f, -0.01554944f, 
    0.00470880f, 0.00347007f, -0.15576687f, 0.03868721f, -0.04864183f, -0.09634253f, 0.18447199f, -0.24822937f, 
    0.01147619f, -0.03042938f, -0.08877626f, -0.11535447f, 0.00689226f, 0.02106418f, -0.01049758f, 0.00423588f, 
    -0.00970464f, 0.02632839f, 0.00026095f, 0.11112000f, -0.08595672f, -0.10441221f, 0.01833641f, 0.04484350f, 
    0.15502241f, -0.03915089f, -0.20625506f, 0.09659845f, 0.11903109f, 0.21939702f, -0.01849860f, 0.11630811f, 
    -0.20699887f, -0.02148543f, -0.09161003f, -0.02227294f, 0.01841089f, -0.06745890f, -0.07259778f, -0.04723247f, 
    -0.01770861f, -0.05318599f, 0.03266832f, 0.01283658f, -0.16671370f, -0.01813073f, -0.15140541f, 0.00745858f, 
    0.04235568f, 0.01245180f, -0.12293653f, 0.16298397f, 0.06384041f, 0.07750369f, -0.05315000f, -0.02739565f, 
    -0.12317032f, -0.00081195f, -0.08886577f, 0.01147026f, -0.05178313f, 0.04635751f, -0.11518997f, -0.08535971f, 
    -0.15156254f, -0.23735470f, -0.14602827f, 0.17365021f, 0.35136858f, -0.07787018f, 0.05419917f, -0.02535547f, 
    0.09671744f, 0.01301698f, 0.00099465f, -0.05094509f, 0.03381206f, -0.15799074f, 0.02631450f, 0.04893250f, 
    0.10504743f, -0.08388766f, 0.21022868f, 0.00611403f, 0.77084464f, 0.22320950f, -0.10173348f, 0.05242537f, 
    -0.17879131f, 0.14449073f, 0.02916974f, 0.10527924f, -0.07931965f, -0.10668394f, -0.14156578f, -0.08890322f, 
    0.07075333f, 0.04449923f, -0.05173652f, 0.01707993f, 0.00641060f, -0.08967002f, 0.04160958f, 0.03466128f, 
    0.08702002f, -0.20277438f, -0.03226398f, -0.13102058f, -0.13461572f, 0.01613760f, 0.01236885f, -0.07545535f, 
    0.02286734f, -0.04870776f, -0.01723733f, 0.03248550f, -0.11873131f, -0.08158857f, 0.03894725f, -0.09368438f, 
    -0.13035525f, 0.07492886f, -0.15138780f, -0.09724817f, -0.13117656f, 0.06982614f, 0.06604165f, 0.05482244f, 
    0.28572857f, -0.06871542f, 0.11434671f, 0.00706553f, 0.14193709f, 0.01236813f, 0.05262956f, -0.08160430f, 
    0.02204251f, -0.04187256f, -0.09012119f, 0.05848675f, 0.09260134f, -0.08085597f, 0.10691754f, 0.00715485f, 
    -0.72138357f, 0.48823801f, -0.07937670f, -0.21381909f, 0.13254973f, 0.06218781f, 0.21885847f, 0.01940564f, 
    0.02635037f, 0.11087579f, -0.15492521f, 0.06892713f, 0.06266676f, 0.06493517f, 0.07877524f, 0.02761681f, 
    0.09526991f, 0.14774306f, -0.08639820f, 0.00106656f, -0.32308245f, -0.16762997f, -0.02556287f, 0.09509145f, 
    -0.03093472f, -0.02772678f, -0.04830495f, -0.15003830f, -0.02481204f, -0.11435679f, 0.01716313f, 0.09906716f, 
    0.04063433f, -0.00687902f, -0.05316162f, -0.06812697f, -0.03058445f, -0.04050044f, 0.10948268f, -0.13519679f, 
    0.07091148f, -0.24043599f, 0.11957104f, 0.03824656f, 0.33399186f, -0.03637654f, 0.12547334f, -0.01673427f, 
    0.10787994f, -0.03470677f, -0.02912807f, 0.00847396f, -0.05543378f, -0.05670555f, 0.03719568f, 0.05462683f, 
    -0.03992862f, 0.07608032f, 0.02576240f, -0.04608080f, -0.01807150f, 0.52258593f, 0.06758408f, -0.18994814f, 
    0.28537378f, 0.00899181f, -0.02847158f, -0.09860900f, -0.08636196f, -0.05516374f, -0.03304889f, -0.03759217f, 
    -0.08324689f, -0.00810517f, -0.01382656f, -0.05415455f, -0.01948083f, 0.02037216f, -0.09535696f, 0.04619217f, 
    -0.13201699f, 0.06188721f, -0.17772423f, -0.03622325f, 0.20554760f, -0.08912238f, -0.04546378f, -0.11969010f, 
    0.01991408f, -0.05117277f, 0.03364439f, 0.05356409f, -0.10870767f, -0.09270789f, 0.09360614f, -0.01998067f, 
    0.02089312f, 0.03856711f, -0.12601832f, -0.06226623f, -0.02758820f, 0.04277062f, -0.08725163f, 0.05059189f, 
    0.30550089f, 0.09097639f, 0.02811457f, -0.06265757f, -0.02731465f, -0.07058173f, -0.07209492f, 0.07183778f, 
    0.04908669f, 0.10820354f, 0.11951974f, -0.04111810f, 0.00859534f, 0.10389427f, -0.02053989f, 0.07852374f, 
    -0.73048854f, -0.24755763f, -0.22633712f, -0.21421471f, -0.10070293f, -0.07530293f, 0.02114066f, -0.18959476f, 
    0.06877514f, -0.01197104f, 0.06833715f, 0.04850128f, 0.07207692f, 0.04769696f, -0.03862299f, 0.03629823f, 
    0.08149572f, 0.16056512f, -0.13128354f, -0.14835972f, -0.33311000f, 0.06023164f, 0.24805947f, 0.08598519f, 
    0.20254700f, -0.03619478f, -0.02049892f, -0.08253831f, -0.06820389f, -0.01697899f, 0.02929567f, -0.06461307f, 
    -0.02862069f, -0.06476406f, -0.04433970f, -0.01843937f, -0.03585503f, 0.09713666f, 0.00899801f, -0.19410889f, 
    0.53739911f, 0.77332526f, -0.27718681f, -0.33192524f, -0.25564671f, 0.04335024f, -0.04950174f, -0.06274090f, 
    -0.34086567f, 0.13995959f, -0.24341688f, -0.24140941f, -0.02825253f, 0.03886754f, 0.08595732f, -0.11223659f, 
    0.14159843f, -0.08892606f, 0.06722841f, 0.03928630f, -0.47264272f, 0.14466941f, -0.29724994f, 0.22371206f, 
    -0.23528329f, 0.14740478f, -0.01931128f, 0.14104047f, 0.02226029f, -0.08693664f, 0.00858657f, -0.03453191f, 
    0.10967269f, -0.16382466f, -0.15887219f, 0.25452146f, 0.14900516f, 0.17487130f, 0.15082847f, -0.24360920f, 
    -0.87285447f, 0.77550542f, -0.17558637f, -0.14824401f, -0.17192242f, 0.28049353f, 0.15714592f, 0.05503093f, 
    0.01766190f, 0.12641710f, -0.02384770f, -0.09615902f, 0.01836661f, -0.12499800f, -0.04093977f, -0.06192504f, 
    0.05215601f, -0.05837628f, 0.16545564f, -0.00050091f, -0.18133332f, 0.58113396f, -0.02683774f, 0.26531649f, 
    0.34161383f, 0.18822709f, 0.02732424f, -0.08691327f, -0.05697286f, -0.01498910f, -0.04805412f, 0.00706670f, 
    -0.11533191f, -0.09330521f, 0.01887505f, -0.01196925f, -0.02173678f, -0.01970083f, 0.01041114f, -0.10412545f, 
    0.13744754f, 0.16536176f, 0.26156777f, -0.10849926f, 0.18890198f, -0.04822776f, -0.00329355f, -0.06691350f, 
    0.00309550f, 0.01398944f, 0.03983021f, 0.04641135f, -0.00212114f, -0.09431738f, 0.17787971f, 0.01341726f, 
    -0.05251095f, -0.07287995f, -0.07592902f, -0.14157560f, 0.05896514f, 0.20595874f, 0.14726427f, -0.04401422f, 
    0.18592550f, -0.09065232f, 0.11704929f, -0.06207867f, 0.01178184f, 0.03587981f, -0.18468179f, 0.10298780f, 
    -0.07815805f, -0.03136010f, 0.04651003f, -0.02177965f, -0.13106221f, 0.09057821f, 0.07659579f, -0.01007263f, 
    -0.21371551f, 0.12950946f, -0.20485264f, -0.13944155f, -0.19318262f, -0.06685153f, -0.02400915f, -0.17552596f, 
    -0.02223406f, -0.08625010f, -0.03232021f, -0.04026249f, -0.03232558f, -0.22585510f, 0.04623356f, 0.16319315f, 
    0.09866545f, -0.07413469f, -0.24941213f, -0.20632030f, 0.03730957f, 0.03908822f, 0.13040283f, -0.31658572f, 
    -0.13859645f, -0.06699920f, -0.08020643f, -0.01587241f, -0.15190351f, 0.05596115f, 0.05827563f, -0.01744355f, 
    0.02725856f, -0.03086991f, 0.08497660f, -0.01365979f, -0.05911706f, 0.01349118f, 0.00121706f, -0.08418308f, 
    0.16659792f, 0.06345358f, -0.18654473f, -0.18845764f, 0.13681719f, 0.04275366f, -0.06993529f, 0.01419801f, 
    -0.04011841f, -0.07392958f, -0.03602504f, -0.05341357f, -0.05597868f, 0.08664959f, 0.06687718f, 0.02124278f, 
    0.01929313f, 0.10392924f, -0.04905848f, 0.11776371f, -0.43570432f, -0.16119553f, -0.17987956f, -0.06091780f, 
    -0.39161196f, -0.10333608f, 0.00798431f, -0.04416806f, 0.07393492f, -0.08259962f, 0.10003602f, 0.06611944f, 
    0.00988912f, -0.05982007f, 0.03470957f, 0.07887144f, 0.01187547f, 0.20994711f, -0.13915192f, -0.21553178f, 
    -0.03307947f, 0.05034361f, -0.02245709f, 0.00979765f, -0.00433203f, -0.09250081f, 0.05508731f, 0.01041218f, 
    0.06737733f, 0.00389812f, -0.08653679f, 0.00215775f, 0.00681499f, -0.02771994f, 0.06055206f, 0.09342346f, 
    0.03015271f, 0.05927696f, 0.00779243f, -0.01485487f, -0.07688055f, -0.05606373f, -0.22736463f, 0.11735173f, 
    0.21750885f, 0.10311229f, 0.05939724f, 0.17217654f, 0.04149565f, 0.11926549f, 0.10845555f, 0.08620293f, 
    0.01528831f, -0.01835343f, -0.00206845f, 0.16711175f, -0.03429646f, 0.07387712f, 0.10514548f, 0.10955312f, 
    0.09485073f, -0.07637148f, -0.13805158f, -0.08927802f, 0.12419908f, -0.03375418f, 0.03695427f, -0.12129234f, 
    -0.09833804f, -0.18744881f, -0.04363273f, 0.02937984f, 0.01455683f, -0.01240662f, -0.04055030f, -0.07906459f, 
    -0.04819142f, 0.11083464f, 0.11711825f, -0.18680470f, -0.11019154f, 0.01597743f, -0.14529000f, -0.12482734f, 
    0.12328736f, 0.12316468f, -0.01455699f, 0.00648305f, 0.07371508f, 0.07835375f, -0.03220165f, 0.14797384f, 
    -0.05203860f, 0.13192326f, -0.05241615f, 0.03952330f, -0.04814478f, 0.07607732f, 0.02491713f, 0.07358946f, 
    -0.12285671f, 0.21192366f, -0.17937155f, -0.26839241f, 0.14599843f, 0.09180514f, -0.00430495f, -0.17044622f, 
    -0.03634311f, -0.16095696f, -0.11845690f, 0.05299145f, -0.14362116f, 0.05935900f, 0.07915153f, 0.09372909f, 
    0.01596604f, 0.00886288f, -0.18071355f, 0.05523359f, -0.37325177f, 0.34318179f, -0.03067756f, -0.08945251f, 
    0.14101453f, 0.23807135f, 0.03104659f, -0.01688577f, -0.02520532f, -0.14844245f, -0.22407252f, -0.01491794f, 
    -0.05423112f, -0.03377337f, 0.02361113f, -0.04551266f, -0.02221686f, -0.11959935f, 0.10367569f, -0.00122074f, 
    -0.50951451f, 0.29184374f, -0.22924584f, 0.04699406f, -0.40334707f, 0.04325916f, -0.26007962f, 0.14745940f, 
    -0.03927538f, -0.06387900f, 0.04895258f, -0.08361869f, -0.17308234f, -0.00815562f, -0.02150296f, 0.10546218f, 
    -0.06740319f, 0.04918737f, -0.14823145f, -0.11075074f, 0.42334330f, 0.48301035f, 0.27694696f, -0.24348566f, 
    -0.01878473f, 0.04625044f, 0.14589864f, 0.02488611f, -0.03857728f, 0.04073834f, -0.04281528f, 0.02475720f, 
    0.02109125f, 0.00796913f, 0.00301357f, 0.00682193f, -0.07911132f, -0.00917826f, 0.10777763f, -0.01661725f, 
    -0.23865268f, -0.16250460f, -0.04815637f, 0.22767247f, 0.36509717f, -0.06472055f, 0.05072508f, 0.22030608f, 
    0.10563660f, 0.03132239f, 0.05407410f, 0.05649151f, -0.00400230f, -0.02103767f, 0.04796407f, -0.16739091f, 
    0.00975492f, 0.04243245f, 0.10663533f, -0.11467737f, -0.25316176f, 0.30325961f, 0.24738526f, 0.09655902f, 
    0.33541194f, 0.07668556f, 0.04393470f, 0.02686349f, -0.07434323f, -0.01707480f, -0.05643957f, -0.02710755f, 
    0.04158212f, 0.10878123f, 0.00428455f, 0.02081987f, 0.01798621f, 0.04403530f, 0.00625180f, -0.01510299f, 
    0.03360469f, -0.18739362f, 0.41540751f, -0.15745936f, 0.13491091f, -0.25544915f, -0.03137553f, 0.09861930f, 
    0.06939493f, 0.09839151f, 0.11553751f, -0.04030456f, 0.12231837f, 0.09890562f, 0.13155431f, 0.03158356f, 
    0.01986053f, 0.00978930f, -0.03872147f, -0.03005767f, 0.16285120f, 0.20309441f, 0.28110310f, -0.44627213f, 
    0.11673930f, -0.17708455f, -0.05779229f, 0.02091317f, -0.02019495f, -0.06582318f, 0.04165829f, 0.01157420f, 
    -0.05249567f, -0.05581027f, 0.13509126f, 0.01623617f, -0.13739584f, 0.06730685f, 0.02829631f, -0.05432914f, 
    0.40465268f, 0.18314640f, 0.07100513f, -0.41007915f, 0.21473181f, 0.11006725f, 0.11361826f, -0.10087758f, 
    -0.00319026f, -0.08240157f, -0.07069591f, -0.01439701f, -0.01759784f, -0.05502549f, -0.02094594f, -0.08764437f, 
    -0.04647130f, -0.07004824f, 0.16897057f, 0.00382976f, 0.63777381f, 0.28592685f, -0.21438457f, -0.24572003f, 
    -0.02287640f, 0.07423398f, 0.05894082f, -0.05730050f, 0.14589944f, -0.21628188f, -0.00227819f, 0.07601678f, 
    0.00131134f, 0.03874026f, -0.05444180f, 0.03057403f, 0.05216572f, 0.01887517f, -0.01629487f, -0.14776076f, 
    -0.25995371f, -0.05691273f, -0.02380043f, -0.10285418f, -0.34084272f, -0.01836507f, -0.13633616f, -0.03367633f, 
    -0.12094115f, -0.06143413f, -0.02166434f, -0.00190384f, -0.01884483f, 0.00567224f, -0.03225235f, 0.07797886f, 
    -0.02098056f, -0.08266553f, -0.03700161f, -0.06024946f, -0.12651131f, 0.05979440f, -0.09567636f, 0.25944042f, 
    0.22216760f, -0.06462748f, -0.14011517f, 0.09409293f, -0.09634260f, -0.04210862f, -0.03498580f, 0.06985653f, 
    0.17954308f, 0.02185843f, -0.08765116f, 0.06118529f, 0.01424072f, -0.01019616f, 0.02099144f, -0.02151429f, 
    -0.20310926f, 0.38776979f, -0.06711539f, -0.04682926f, 0.22532970f, 0.35755810f, 0.08355082f, 0.03451424f, 
    -0.00278381f, -0.09975776f, -0.21953347f, 0.07305735f, -0.00743032f, -0.04013664f, 0.03451138f, 0.02942258f, 
    -0.06519020f, -0.09455111f, 0.12873335f, -0.01177487f, -0.13400118f, 0.04866444f, 0.28229779f, 0.57699311f, 
    0.56298792f, -0.09597629f, -0.12572283f, -0.09319930f, -0.05041341f, -0.28920141f, -0.04493540f, 0.06513342f, 
    0.03136112f, 0.06746912f, -0.07868945f, 0.01142868f, 0.07241789f, 0.15179764f, 0.02640748f, 0.02655343f, 
    -0.15546539f, 0.11815064f, -0.09846608f, -0.22696383f, -0.24199812f, 0.31118178f, 0.13701670f, 0.07767779f, 
    0.05451795f, -0.02560366f, -0.15062642f, -0.11593474f, -0.04048881f, -0.06296294f, -0.01977923f, -0.07661477f, 
    0.01547919f, -0.13473760f, -0.11534707f, -0.16527747f, -0.09257668f, -0.37471452f, 0.17447115f, 0.00410894f, 
    0.18423265f, -0.11335444f, 0.07891974f, -0.03162276f, 0.07165629f, -0.06542478f, 0.11553597f, 0.04354093f, 
    -0.13625275f, 0.07959761f, 0.07810666f, -0.05391882f, 0.03697534f, 0.00207927f, -0.09026007f, -0.03163659f, 
    -0.10960196f, -0.06553509f, -0.17817560f, -0.01124460f, 0.11580402f, 0.05771753f, 0.08689048f, -0.00952657f, 
    -0.03626185f, -0.05135106f, -0.09157850f, -0.04862113f, 0.01412461f, 0.02748805f, -0.10986669f, -0.03008948f, 
    -0.06095124f, -0.03970722f, 0.10072496f, 0.04175332f, 0.14773796f, 0.16659272f, 0.36584926f, -0.45506534f, 
    0.18964280f, -0.14755197f, -0.09830002f, -0.05274907f, -0.01826199f, -0.13019398f, -0.01496551f, -0.06035300f, 
    -0.01760810f, -0.02857580f, 0.06802284f, -0.02430115f, -0.12000436f, -0.10885035f, 0.12623426f, -0.02769396f, 
    -0.26988965f, 0.00809941f, -0.23958255f, 0.25210267f, 0.10631630f, -0.08714829f, -0.00140615f, 0.05197394f, 
    -0.00900174f, 0.05080803f, -0.00245502f, 0.02230668f, -0.09605718f, -0.08132434f, 0.02095938f, -0.04008441f, 
    0.01582020f, -0.09019314f, 0.06130973f, -0.02541555f, 0.46397778f, -0.07724062f, -0.15206923f, -0.12790036f, 
    0.25455463f, 0.17907777f, 0.00665976f, 0.16169184f, -0.12840652f, -0.27013886f, -0.18519036f, 0.03562892f, 
    0.05345315f, -0.00424243f, 0.04287165f, -0.09561813f, 0.04296733f, 0.05304477f, 0.09395346f, 0.08489154f, 
    0.02081792f, -0.07126354f, -0.16878170f, 0.03939085f, 0.15283594f, -0.07535344f, 0.06938092f, -0.05957656f, 
    0.03662586f, 0.05872667f, -0.07873074f, -0.02210512f, 0.00809406f, -0.07408958f, -0.01529203f, 0.05893573f, 
    0.02788527f, 0.05727008f, -0.03288019f, -0.03471745f, 0.40411273f, 0.34574011f, 0.16857149f, -0.40600035f, 
    -0.06570563f, 0.10721561f, -0.00799275f, -0.08935910f, -0.08146735f, -0.16803947f, -0.01445393f, -0.00472401f, 
    0.06917203f, -0.10442538f, 0.03061425f, 0.02532269f, 0.10690671f, -0.12752059f, 0.08035620f, 0.09671406f, 
    0.02148073f, -0.07264342f, -0.23678923f, 0.02223380f, 0.16451812f, 0.07988321f, -0.01561569f, -0.01274689f, 
    0.10518360f, 0.06278325f, -0.00973028f, 0.01938637f, -0.01235419f, -0.00381944f, -0.05116561f, 0.04433696f, 
    -0.05865633f, 0.16495717f, -0.08397441f, 0.06681998f, -0.33041158f, 0.06887835f, 0.08602303f, -0.09554913f, 
    0.07511975f, 0.02846390f, 0.14082430f, 0.22255599f, 0.06427731f, -0.19481108f, -0.02223435f, -0.01593651f, 
    0.01512329f, 0.04858482f, -0.06390077f, -0.02549814f, 0.08794212f, 0.19317770f, -0.06571410f, -0.03596808f, 
    0.06615353f, 0.18400851f, -0.09532828f, -0.34146214f, 0.15828225f, 0.10758663f, -0.07551822f, 0.06249099f, 
    0.10972253f, 0.09635998f, -0.08462292f, 0.00088714f, -0.13811734f, 0.05382495f, -0.10267960f, -0.02383015f, 
    -0.02428495f, 0.04652504f, -0.09619879f, 0.01178716f, 0.45814618f, 0.22130768f, -0.09970316f, -0.05622084f, 
    -0.45852774f, 0.09627077f, -0.02621200f, -0.09397289f, 0.04912701f, -0.02148630f, 0.04214654f, -0.00686507f, 
    0.10598527f, -0.14210384f, -0.04168618f, -0.02479875f, -0.03154085f, -0.24055979f, 0.06463558f, 0.02933581f, 
    -0.41270521f, 0.11961826f, -0.19118516f, -0.09174120f, 0.33028424f, 0.20151056f, 0.08501733f, -0.05584319f, 
    0.01679582f, 0.00383560f, -0.11972587f, 0.01879700f, -0.03052793f, 0.05237920f, 0.04611113f, -0.07763843f, 
    0.04466573f, 0.10756712f, 0.05556894f, -0.04490253f, -0.01738749f, -0.01388158f, -0.15937382f, 0.09146532f, 
    0.15028501f, 0.05346135f, 0.01908190f, 0.09577651f, 0.11121801f, 0.12696224f, 0.03746659f, -0.02169077f, 
    0.04935191f, -0.03373678f, -0.04800543f, 0.02131822f, -0.07596553f, 0.01059017f, -0.01408148f, -0.00868225f, 
    -0.28575355f, -0.38047493f, -0.28542179f, -0.05814788f, -0.19433418f, 0.03545688f, 0.00336254f, -0.09868164f, 
    0.02980957f, 0.05500824f, 0.01389392f, 0.03622777f, -0.00757374f, 0.01954008f, 0.03298736f, 0.04471596f, 
    0.04858996f, 0.16784507f, -0.19324130f, -0.17549889f, -0.51951271f, 0.30716151f, -0.10845524f, -0.24710108f, 
    0.26985458f, 0.34097737f, 0.18045421f, -0.06296668f, 0.05234503f, -0.11866707f, -0.18759480f, 0.01587931f, 
    -0.00023480f, -0.02671321f, 0.02483533f, -0.12226029f, 0.04406305f, 0.13871774f, 0.12966090f, -0.10700615f, 
    -0.38748020f, -0.12791823f, -0.03647420f, -0.03570462f, 0.03633143f, -0.16608626f, -0.00004568f, -0.18301518f, 
    0.05165108f, -0.14851157f, 0.06441007f, 0.10411329f, -0.03125190f, 0.02713530f, -0.04006775f, -0.10095433f, 
    0.06304497f, 0.03334191f, 0.00622121f, -0.03841520f, -0.63268912f, -0.23173828f, -0.28830320f, -0.11738544f, 
    -0.45593929f, -0.05393870f, -0.12626332f, -0.18304050f, 0.08329485f, -0.25723141f, 0.04402544f, 0.05405445f, 
    0.08176133f, -0.02334480f, -0.09705346f, -0.01032054f, 0.02970465f, -0.10268521f, 0.06045111f, -0.08501016f, 
    0.21841913f, -0.06054711f, -0.04627868f, -0.10906036f, 0.23323354f, -0.01969872f, 0.11887429f, 0.05038323f, 
    -0.00381948f, 0.11713682f, -0.15280554f, -0.02005743f, -0.00240371f, -0.00850290f, -0.03058987f, 0.10453174f, 
    0.10647633f, -0.00548502f, 0.09293123f, -0.06297015f, 0.21618076f, 0.28217125f, 0.61005962f, -0.29658541f, 
    0.45029265f, -0.12353535f, 0.12392364f, 0.05418646f, -0.03706948f, -0.04444874f, 0.08542100f, 0.02779892f, 
    -0.10083024f, 0.01733319f, 0.03991525f, 0.01300566f, -0.10537905f, 0.01004504f, 0.00659735f, -0.00830261f, 
    -0.01196267f, -0.10305306f, -0.06025888f, -0.04924657f, 0.16691712f, -0.03052696f, 0.02469150f, -0.05393088f, 
    0.08500941f, -0.02091871f, 0.01596305f, -0.05322387f, 0.02639661f, -0.04573613f, -0.02687490f, -0.00638432f, 
    -0.06563500f, 0.03117583f, -0.00968419f, 0.02349703f, -0.25997224f, 0.03263442f, 0.37515518f, 0.14620668f, 
    0.25159302f, -0.00012511f, -0.05924369f, -0.14075516f, -0.08549177f, -0.07448890f, 0.03934469f, -0.07579782f, 
    -0.02414897f, 0.02943532f, -0.05102594f, 0.02516215f, 0.01530458f, 0.06351624f, -0.06159006f, -0.04736943f, 
    0.06125819f, 0.05922695f, 0.09325049f, 0.05963047f, 0.04622614f, -0.06315971f, -0.03109163f, -0.02204013f, 
    0.03691962f, 0.13840486f, 0.07653701f, -0.04237715f, -0.00070801f, -0.06437162f, -0.03768045f, 0.05031150f, 
    0.02689295f, 0.08794453f, 0.00532575f, 0.00894829f, 0.16557671f, 0.00314310f, 0.09483527f, -0.07307620f, 
    -0.02963897f, 0.13103895f, -0.10298621f, 0.01117104f, 0.00310172f, 0.01873450f, 0.00641094f, -0.01612689f, 
    0.02355383f, 0.00026375f, 0.05372005f, 0.04671759f, -0.09750594f, 0.06788999f, -0.12247105f, -0.21431515f, 
    -0.10433450f, 0.23033401f, -0.14915794f, 0.00841352f, -0.17442407f, 0.11299004f, -0.09244416f, -0.00356421f, 
    0.02612498f, 0.14076166f, 0.04445270f, 0.02875828f, 0.02426692f, 0.06049348f, -0.03642483f, -0.01683662f, 
    0.15994096f, 0.16165723f, 0.00774100f, 0.19090688f, 0.17990106f, -0.36807954f, -0.01886935f, -0.21730228f, 
    -0.13211863f, 0.14097674f, -0.01052608f, -0.03893140f, 0.10912947f, 0.04358507f, -0.00406743f, -0.02325430f, 
    0.07855111f, -0.12529819f, 0.03899964f, -0.02043289f, -0.09705672f, 0.00325874f, -0.13845715f, 0.07403128f, 
    -0.13121158f, -0.16610965f, 0.01583328f, -0.10757139f, -0.01296586f, -0.12381648f, -0.12324551f, 0.03495955f, 
    0.16038115f, -0.01476670f, 0.08473448f, -0.04574120f, 0.12302708f, -0.01715990f, -0.00560091f, -0.04480610f, 
    -0.01831287f, -0.07650130f, -0.10219006f, 0.05389634f, -0.00801123f, 0.04075166f, -0.08393887f, 0.03648409f, 
    -0.00250585f, 0.11306884f, -0.07437339f, 0.13041568f, -0.07009815f, 0.17176843f, -0.01600248f, 0.00682860f, 
    0.05050519f, -0.02593120f, 0.01307835f, -0.06833798f, -0.04216846f, -0.16660865f, -0.14664584f, -0.16683118f, 
    -0.22562383f, -0.15665802f, -0.19352128f, -0.17980608f, -0.02427013f, -0.06486309f, 0.02741177f, -0.05885509f, 
    0.03390830f, 0.00725872f, -0.02059689f, 0.06363167f, -0.09112739f, -0.15421893f, -0.17838851f, -0.06428728f, 
    -0.02051405f, 0.01590946f, 0.17030130f, 0.36551037f, -0.03701559f, -0.07288759f, -0.01589402f, -0.10952299f, 
    -0.01691676f, -0.06222395f, 0.04376956f, 0.01025370f, 0.09867972f, 0.02604908f, 0.03848071f, -0.01258035f, 
    -0.01354147f, 0.00564454f, 0.03748754f, -0.02959589f, 0.10112400f, 0.05606240f, -0.08898924f, 0.00899816f, 
    0.00617953f, 0.12148511f, 0.00524788f, 0.18114623f, 0.13844615f, 0.08397043f, 0.13773808f, -0.05167866f, 
    0.18404669f, 0.14692603f, 0.03072793f, -0.00064801f, 0.06028597f, 0.02869765f, 0.00496215f, 0.04469972f, 
    0.09172384f, 0.03314751f, 0.06177771f, 0.23324852f, -0.18001086f, -0.03058850f, -0.06862495f, 0.08524761f, 
    -0.08429866f, 0.05913967f, -0.07013666f, -0.03964315f, -0.09779358f, 0.00364954f, -0.06697042f, -0.01949704f, 
    -0.04449184f, 0.07352848f, 0.03899407f, 0.01505883f, -0.04950221f, -0.07085676f, -0.08227326f, 0.00444536f, 
    -0.04347646f, -0.09511090f, 0.16241840f, 0.05205963f, 0.06557902f, -0.10312498f, 0.02051725f, -0.09050626f, 
    0.00091847f, -0.15455973f, -0.01600365f, -0.04556909f, 0.00030009f, 0.03468733f, -0.01597997f, -0.11276034f, 
    -0.11186580f, -0.05503434f, -0.00895358f, -0.03712611f, -0.06516925f, -0.05316271f, 0.15536325f, 0.18496117f, 
    0.13913852f, -0.14619149f, 0.04444811f, -0.10135833f, -0.22593465f, -0.12319443f, -0.02297032f, 0.05142265f, 
    -0.00474647f, 0.00182919f, -0.01071202f, -0.02409828f, 0.03303799f, -0.00107839f, 0.03870723f, -0.03933864f, 
    -0.04391071f, -0.03071185f, -0.03127974f, 0.06355322f, 0.07455099f, 0.06829122f, 0.06968670f, 0.02824832f, 
    0.04710856f, 0.05210113f, 0.06550788f, 0.00658385f, 0.03612232f, -0.03243881f, 0.08061294f, -0.08276436f, 
    -0.01173236f, -0.03104540f, -0.03486326f, 0.01626064f, 0.00816169f, -0.03454147f, -0.06422739f, -0.09108819f, 
    -0.02118952f, -0.00093845f, 0.03272531f, -0.04043733f, 0.02573177f, -0.00870512f, 0.07022354f, -0.00704481f, 
    0.09681730f, -0.15730733f, -0.02366852f, -0.03250714f, -0.12231271f, 0.00007885f, -0.05979875f, -0.02179756f, 
    0.12252625f, -0.77990282f, -0.04502686f, 0.30803481f, -0.20565085f, 0.14363749f, -0.13164622f, 0.08127996f, 
    -0.11852541f, 0.01701845f, 0.03549951f, -0.09479990f, 0.03447744f, -0.15942743f, 0.01839070f, -0.05591130f, 
    -0.12025107f, 0.01915164f, -0.35567260f, 0.05102576f, 0.12764609f, -0.04967634f, 0.03552226f, 0.03201275f, 
    0.06132809f, 0.04782889f, -0.02021012f, 0.04264705f, -0.05782244f, 0.02598844f, -0.07893680f, 0.11081681f, 
    -0.12712035f, 0.03291401f, 0.10148785f, -0.07739272f, -0.08643787f, -0.09457905f, -0.19941029f, -0.17019781f, 
    -0.30803916f, -0.29313356f, 0.03363876f, -0.22874020f, -0.09175356f, 0.01091133f, 0.06655979f, 0.03734576f, 
    0.04274138f, 0.06374142f, -0.17170659f, 0.10138191f, -0.01785777f, -0.08053784f, -0.12418184f, -0.14191863f, 
    -0.08456655f, 0.02109840f, 0.07258401f, 0.11368456f, -0.39064756f, -0.45903063f, 0.13060704f, -0.26953161f, 
    -0.08703544f, -0.16276541f, -0.07237158f, -0.14006317f, -0.02874370f, -0.08583377f, -0.15884882f, -0.11846901f, 
    0.00376674f, 0.24881412f, -0.05500779f, -0.09628785f, 0.02476180f, -0.08635963f, -0.06809020f, -0.05323461f, 
    -0.06871662f, 0.05273626f, -0.03785592f, 0.07389306f, 0.10902505f, 0.03882163f, 0.15441367f, -0.04591607f, 
    0.00045233f, 0.01626842f, 0.06949940f, -0.03913883f, -0.03633940f, -0.10659709f, 0.00951232f, -0.11085450f, 
    -0.07145509f, -0.05297084f, -0.01422021f, -0.10221729f, 0.06431219f, -0.29856169f, 0.05069024f, 0.03686721f, 
    -0.11954149f, 0.07217076f, -0.14320579f, 0.16581310f, -0.17560962f, -0.10835566f, -0.04927386f, 0.00575257f, 
    -0.04113779f, 0.02386721f, -0.13383892f, -0.01132665f, 0.16799106f, 0.09079726f, 0.05918625f, 0.15119372f, 
    -0.20314935f, -0.14126591f, -0.04262273f, -0.14375851f, -0.00587826f, -0.11479213f, 0.04785412f, 0.06759179f, 
    0.04413419f, -0.07648767f, -0.12328672f, -0.10201198f, -0.05594166f, 0.05577771f, 0.03608304f, -0.33172128f, 
    -0.18850864f, -0.04379715f, 0.09060499f, -0.06669014f, -0.00881561f, -0.00478645f, -0.08601504f, -0.04780132f, 
    -0.07040130f, 0.00861050f, 0.06693522f, 0.03712017f, 0.01159842f, -0.00584731f, 0.11494239f, 0.00197503f, 
    -0.10075208f, 0.00220845f, 0.03151564f, -0.00956681f, -0.07543471f, -0.01912860f, -0.05742434f, -0.12439851f, 
    0.01537661f, 0.07998952f, 0.17027387f, 0.20827606f, 0.09717070f, -0.10646634f, -0.10564891f, 0.00583958f, 
    -0.12321299f, 0.05017634f, 0.11050440f, -0.03243943f, 0.04694286f, -0.05526190f, 0.00621276f, -0.05134919f, 
    -0.04422356f, 0.02605864f, -0.06561022f, -0.10193568f, 0.03593044f, 0.02239015f, -0.07264462f, -0.05365036f, 
    0.01867066f, 0.05079591f, 0.05284811f, 0.03680847f, 0.05558246f, -0.00078694f, 0.07442809f, -0.03294928f, 
    0.01746095f, 0.02795291f, 0.08313417f, 0.00008016f, -0.06942448f, 0.02071271f, 0.02659884f, 0.01446399f, 
    -0.07214233f, -0.03065141f, 0.00750240f, -0.02238484f, 0.04422865f, -0.09174009f, -0.01007138f, 0.05318074f, 
    -0.08227035f, -0.05018973f, 0.01936617f, 0.01214926f, -0.02415972f, 0.04296512f, -0.06783870f, -0.02747298f, 
    0.22115837f, 0.11263902f, 0.11669935f, 0.20582432f, 0.13101630f, 0.11856094f, 0.19010539f, 0.15053704f, 
    0.01940595f, -0.00514107f, -0.04530624f, -0.06954888f, -0.06644833f, 0.10780922f, 0.14263055f, 0.01732517f, 
    0.06122895f, 0.00976911f, 0.02079807f, 0.02805377f, -0.04518659f, 0.02142280f, -0.03171672f, -0.08785182f, 
    0.09386077f, 0.08464816f, 0.05737239f, 0.08804590f, -0.11968023f, -0.08658313f, -0.11737128f, -0.06945843f, 
    -0.01043004f, -0.12244138f, 0.13244550f, -0.04404660f, 0.00107272f, 0.01129551f, 0.07712431f, -0.00562555f, 
    0.02876064f, -0.07143407f, -0.00488958f, 0.01909116f, 0.06864466f, 0.08781661f, 0.08968790f, 0.29278567f, 
    0.15923189f, -0.12823649f, -0.04685459f, -0.04848191f, -0.16618572f, -0.01732045f, 0.03613210f, 0.01764455f, 
    -0.00355065f, 0.03775819f, 0.09585120f, -0.00442103f, -0.00088749f, 0.06504373f, -0.06155675f, -0.09862421f, 
    -0.05447330f, -0.10923065f, 0.06958281f, 0.08852181f, 0.07443726f, -0.24615705f, -0.07404560f, 0.02842073f, 
    -0.13466905f, -0.10398613f, -0.02464342f, 0.01675588f, 0.04896772f, -0.03883496f, 0.00198514f, -0.05442945f, 
    -0.18599214f, 0.00689792f, 0.00536274f, 0.03725623f, 0.17801680f, -0.19608925f, 0.13932906f, 0.08073280f, 
    0.04347815f, -0.12939775f, -0.05678306f, 0.00637383f, -0.12076796f, 0.11646651f, 0.07038424f, -0.00868584f, 
    -0.03806353f, -0.07043957f, -0.07459554f, 0.09570593f, 0.01352269f, 0.04571323f, -0.01728884f, 0.02677872f, 
    -0.05161069f, -0.23912863f, -0.02908268f, -0.07490198f, -0.02795876f, 0.03273365f, -0.02306581f, -0.02032053f, 
    0.04929243f, -0.09908048f, 0.02208362f, 0.01804115f, -0.13652407f, -0.01274574f, 0.01021180f, -0.02400192f, 
    -0.15164283f, 0.06655497f, -0.01551697f, -0.15819339f, 0.54374921f, -0.88323563f, -0.36227128f, 0.11327147f, 
    -0.40022555f, 0.08632678f, -0.04823179f, 0.03713052f, -0.04089814f, 0.01701298f, 0.01099062f, -0.03693030f, 
    -0.06395884f, 0.04042952f, -0.01890314f, -0.05165759f, 0.02313983f, -0.04495285f, -0.08846730f, 0.13797688f, 
    0.28653872f, 0.15713450f, 0.37058416f, 0.14279935f, 0.20295869f, 0.16456532f, 0.27958679f, 0.12496623f, 
    0.07116381f, 0.31210795f, -0.01136257f, 0.00162110f, -0.02644947f, 0.01025598f, -0.04938514f, -0.02112326f, 
    -0.02597195f, -0.15669137f, 0.06441636f, 0.09898165f, -0.13225180f, -0.21505235f, 0.11648259f, -0.02547440f, 
    -0.11706639f, -0.06276734f, 0.04065491f, -0.11072168f, -0.02092924f, -0.05067542f, -0.00919998f, -0.06112938f, 
    -0.14327160f, 0.13451143f, 0.05871329f, -0.06499843f, -0.01582063f, -0.12213097f, -0.04443014f, -0.08263157f, 
    0.28260350f, 0.13271147f, -0.30443490f, 0.29062510f, 0.18896449f, 0.03952981f, 0.08554351f, 0.08164798f, 
    0.12075519f, 0.15977407f, 0.11267871f, 0.04194785f, 0.01897752f, -0.00752192f, 0.03783806f, 0.10705592f, 
    0.09962135f, 0.14287640f, 0.05025199f, 0.11049508f, 0.14385864f, -0.23765272f, -0.33824259f, 0.19836284f, 
    0.21023431f, -0.02996073f, 0.01966336f, -0.01293832f, 0.10888661f, -0.00091097f, 0.06056631f, -0.05496521f, 
    0.02122076f, 0.00810264f, 0.03718888f, -0.10332947f, -0.01755079f, -0.02361190f, -0.12248909f, -0.11667924f, 
    -0.16411874f, 0.06771623f, -0.10351235f, 0.42968050f, -0.17408209f, -0.16607590f, 0.02186637f, 0.01440030f, 
    -0.26080954f, -0.01336854f, 0.03213817f, -0.03890675f, 0.01886606f, 0.09795025f, -0.03836875f, 0.10982481f, 
    0.00896953f, -0.15218043f, -0.10806724f, -0.08741560f, -0.13665941f, -0.44271353f, -0.03441971f, -0.02219315f, 
    -0.11838263f, -0.05950956f, -0.06125826f, -0.02546721f, 0.05073439f, 0.04025292f, -0.00089564f, 0.03330226f, 
    0.01790092f, -0.00209843f, 0.09290683f, -0.22563748f, -0.08041136f, -0.14566326f, 0.06370625f, 0.07993650f, 
    -0.01326434f, -0.03674222f, -0.12040462f, -0.02249411f, -0.02824584f, 0.09810625f, 0.01448518f, -0.00398734f, 
    0.02877817f, 0.03690151f, 0.06001364f, -0.02134598f, -0.01171717f, -0.01018981f, 0.07036965f, 0.01856554f, 
    -0.09495793f, -0.02671920f, -0.00109938f, 0.04825234f, -0.04349535f, -0.08244101f, 0.17466728f, -0.01190600f, 
    -0.00766936f, -0.08074410f, -0.04909014f, -0.00666673f, -0.17926919f, -0.13027242f, -0.01351679f, -0.10874271f, 
    -0.07636289f, 0.02831388f, 0.00874363f, -0.00221207f, 0.02609446f, -0.06817026f, -0.06782784f, -0.16021623f, 
    0.12360965f, 0.00752998f, 0.13590220f, 0.11614621f, 0.06098280f, -0.02953626f, -0.03835259f, -0.01283610f, 
    -0.01593098f, 0.15655001f, 0.10758689f, 0.01063757f, -0.05857149f, -0.10679654f, -0.07837672f, 0.09122873f, 
    0.04153043f, 0.02442495f, 0.01560922f, 0.00010151f, -0.29763445f, -0.35938010f, 0.08379609f, -0.45195368f, 
    -0.00301860f, -0.01087604f, -0.24211793f, 0.00476316f, -0.12357399f, -0.08273153f, 0.03594777f, -0.06139873f, 
    0.13721068f, -0.11263251f, -0.06186431f, -0.06342214f, 0.03385509f, 0.02162012f, -0.16027218f, -0.03377071f, 
    0.05950817f, 0.05428881f, -0.02332297f, -0.00943997f, -0.03347455f, -0.01030564f, -0.00716491f, 0.04488702f, 
    0.04502867f, 0.07500703f, -0.00776498f, -0.00748536f, -0.12293939f, -0.05330409f, -0.08033069f, -0.03178712f, 
    -0.01335082f, 0.00897756f, 0.02420375f, -0.02956768f, -0.05393572f, -0.14091213f, -0.04458106f, 0.16795516f, 
    0.09206662f, -0.02052681f, 0.01745984f, 0.07887257f, 0.04513763f, 0.06855001f, 0.00515805f, -0.01653610f, 
    0.00151803f, -0.00018030f, 0.02973823f, -0.08139455f, 0.00221868f, -0.11256626f, -0.03370744f, 0.03076921f, 
    0.03935078f, 0.15459517f, -0.06648857f, 0.03613650f, -0.07706224f, 0.03215154f, -0.17802934f, -0.04238402f, 
    -0.13330045f, 0.10164256f, 0.03783730f, 0.00707205f, -0.02923336f, 0.04851618f, 0.02315024f, 0.07617708f, 
    -0.00412892f, -0.03354579f, -0.14141896f, -0.00121206f, 0.26877576f, -0.08657037f, -0.28992638f, 0.18948786f, 
    0.05866063f, 0.05492516f, 0.07178539f, -0.00177499f, -0.03460327f, -0.07297669f, 0.11488626f, -0.05827278f, 
    0.02667173f, 0.01244019f, 0.03288695f, 0.00391032f, 0.04663406f, -0.00000425f, -0.15503576f, -0.07463861f, 
    0.11124296f, 0.05978321f, 0.44355062f, -0.27038154f, 0.09240901f, 0.08945793f, 0.16105084f, -0.07619327f, 
    -0.02370452f, -0.05846560f, 0.02241192f, -0.03251977f, -0.01239562f, 0.03735960f, -0.03017967f, -0.11878480f, 
    0.02827793f, -0.11486490f, -0.07751717f, 0.04084207f, -0.15420008f, 0.01676852f, 0.21162114f, 0.11115611f, 
    0.12193228f, -0.19347468f, -0.04207277f, -0.19671498f, 0.03617102f, 0.13963374f, 0.11535665f, 0.06699760f, 
    -0.12664972f, -0.05816144f, -0.04630965f, 0.00060974f, 0.00244165f, 0.00228734f, 0.03028831f, -0.00563821f, 
    -0.10844664f, 0.04667704f, 0.08775295f, 0.13367620f, 0.11795203f, -0.07251730f, 0.09702452f, -0.06491615f, 
    -0.05438127f, 0.07589886f, 0.06163274f, 0.05660398f, -0.00933574f, 0.09621030f, 0.05419764f, 0.07449732f, 
    0.11990284f, -0.13925022f, 0.02847810f, 0.17760710f, -0.17051134f, -0.19512489f, -0.06466677f, 0.11823375f, 
    -0.06676454f, -0.04495709f, -0.09100718f, 0.03619940f, -0.10909785f, -0.02828119f, 0.07366838f, -0.03121712f, 
    -0.00560242f, -0.00683506f, 0.01885939f, 0.03140730f, -0.03368461f, -0.05369601f, -0.09985982f, -0.02947341f, 
    0.14827821f, 0.16196015f, 0.23233758f, 0.24246913f, 0.21349990f, -0.16728631f, -0.11783457f, -0.04672216f, 
    -0.02112991f, 0.04247773f, 0.06366855f, 0.07393260f, -0.01200456f, 0.04322537f, 0.04708768f, 0.04469489f, 
    -0.01822677f, -0.06342144f, -0.00941053f, -0.10606558f, -0.09338737f, -0.12453523f, 0.19044635f, 0.06445164f, 
    -0.27266577f, -0.04135020f, 0.01223705f, -0.00385647f, -0.02055820f, 0.05350740f, 0.09123415f, -0.08307551f, 
    -0.13171366f, -0.06238725f, 0.11673677f, -0.09030063f, 0.01823728f, -0.00116473f, -0.11895236f, -0.07574282f, 
    -0.07365435f, 0.11256428f, 0.03098441f, 0.06955542f, -0.04518811f, 0.08686626f, -0.02541013f, -0.12553848f, 
    -0.04251801f, 0.07508398f, 0.02149219f, -0.00997779f, -0.04499086f, 0.02249654f, 0.08428781f, 0.01460537f, 
    -0.16482949f, -0.00517877f, -0.16334555f, -0.15522629f, -0.11167416f, 0.01595889f, -0.01821804f, -0.15353280f, 
    -0.14650781f, 0.06514101f, 0.00624162f, -0.04111998f, 0.08793627f, -0.00982874f, -0.00465619f, -0.13412978f, 
    -0.05459033f, -0.12703376f, 0.12934746f, 0.00105480f, -0.04277565f, 0.02986918f, -0.06420038f, -0.14979137f, 
    0.22546233f, -0.03138802f, 0.11592392f, 0.11542977f, 0.01006068f, -0.24052586f, -0.15167916f, -0.06347520f, 
    -0.03876834f, 0.00058397f, 0.03640976f, -0.05257308f, 0.02345054f, 0.04043219f, 0.07278042f, 0.02918711f, 
    -0.02076999f, 0.00828067f, -0.02845964f, -0.03692400f, 0.11713684f, 0.08351714f, 0.31391007f, 0.15371269f, 
    0.19885243f, -0.01360796f, -0.08521713f, 0.01767164f, -0.02736570f, 0.10191525f, 0.06675473f, 0.04809063f, 
    0.01684812f, -0.00142072f, 0.00808168f, 0.00058627f, -0.03068169f, -0.06421973f, -0.07794052f, -0.27971750f, 
    0.03195352f, -0.00627668f, -0.02859661f, -0.02499580f, 0.00711291f, 0.07226599f, 0.04422341f, 0.03344102f, 
    -0.03289252f, 0.04928808f, 0.10462318f, 0.12800331f, 0.07398210f, -0.07259527f, 0.06086367f, 0.13528106f, 
    0.05141699f, 0.05168873f, -0.04959577f, 0.03024280f, 0.20391950f, 0.06587955f, 0.11151697f, 0.15481211f, 
    -0.01928722f, -0.07497062f, -0.06163960f, 0.02148144f, -0.03571030f, 0.11667412f, 0.13650139f, -0.02086420f, 
    -0.04233695f, -0.02126811f, 0.02102631f, 0.04933368f, 0.05257592f, -0.01164593f, -0.02703651f, -0.05717751f, 
    -0.03392789f, -0.07629206f, 0.02412386f, 0.06329839f, 0.04360347f, 0.05620908f, -0.00785996f, 0.04747194f, 
    0.06173638f, 0.06557658f, 0.07252160f, -0.00734565f, 0.01623395f, -0.01344539f, 0.01417700f, 0.04377891f, 
    0.01925442f, -0.16928092f, -0.06025985f, 0.02046285f, 0.00668826f, -0.04563643f, 0.00060209f, -0.00731012f, 
    0.03872892f, 0.04853380f, 0.05607384f, 0.01984228f, 0.04532397f, 0.06515785f, 0.10289598f, 0.02368649f, 
    0.01647534f, 0.02578590f, 0.08612011f, -0.00195063f, -0.09526686f, -0.03049051f, -0.07676411f, 0.03074253f, 
    0.07952823f, 0.00726893f, 0.06191895f, 0.22905287f, 0.11011740f, 0.02324319f, 0.05610158f, 0.00739296f, 
    0.11204591f, 0.05923554f, 0.06249390f, -0.01726202f, -0.01728136f, -0.03351760f, 0.01204861f, 0.08675478f, 
    0.07750880f, 0.08226926f, 0.07970753f, 0.15310320f, 0.19369289f, -0.14447342f, -0.36926708f, 0.44726348f, 
    -0.02739142f, 0.04343054f, 0.13699086f, -0.08781253f, -0.24768046f, -0.04227030f, 0.04275099f, -0.00293513f, 
    -0.02503523f, 0.02956727f, 0.03774948f, 0.03452501f, -0.06389169f, -0.05714398f, -0.09515680f, -0.12892447f, 
    -0.00151457f, 0.06044808f, 0.14469938f, 0.16219805f, 0.04012373f, -0.07657135f, -0.02416329f, -0.12660632f, 
    -0.07241023f, 0.05900749f, 0.04621972f, 0.05654093f, 0.00816785f, 0.07591283f, 0.03731223f, 0.03605372f, 
    0.03447567f, -0.05843483f, 0.00969466f, 0.00169219f, -0.04091296f, 0.02148853f, -0.10473182f, -0.05590498f, 
    0.05894440f, -0.01093361f, -0.01366700f, 0.00045655f, -0.03108114f, 0.05000873f, 0.01113629f, 0.02674954f, 
    0.07361963f, -0.04817420f, -0.00482867f, 0.07671103f, -0.06412577f, 0.03633625f, -0.05609420f, -0.00131451f, 
    -0.30283472f, 0.19458243f, -0.28487128f, -0.13197806f, -0.02994056f, 0.08054615f, 0.01656369f, 0.03101278f, 
    0.02783549f, -0.00338375f, 0.07133497f, 0.05989139f, -0.01287101f, 0.08725539f, 0.00251707f, -0.05010768f, 
    0.01060057f, 0.16939722f, -0.03004627f, 0.00178109f, 0.04914524f, -0.01921507f, 0.09559312f, 0.04726259f, 
    0.10262195f, -0.10392973f, 0.02986082f, -0.12054190f, -0.02493829f, 0.02854559f, 0.05489561f, 0.01570354f, 
    0.00997149f, -0.08784244f, -0.04920916f, 0.12609848f, -0.03556661f, 0.02718831f, 0.03197549f, 0.14242677f, 
    0.39857975f, 0.08317110f, -0.12520584f, 0.04317483f, 0.12378287f, 0.02482631f, 0.07754484f, -0.02218963f, 
    -0.05308238f, -0.06921457f, 0.07955737f, 0.09411757f, -0.03614761f, 0.03332125f, 0.04889672f, -0.22027095f, 
    -0.09221176f, -0.18892978f, -0.05375039f, -0.21680546f, -0.36780161f, 0.64801931f, -0.25881985f, 0.16959976f, 
    0.07451998f, 0.00394110f, 0.00657177f, -0.08815553f, 0.04360710f, -0.00764282f, 0.10728036f, -0.04120785f, 
    -0.02368305f, 0.03250433f, -0.14255235f, -0.12673597f, 0.05217820f, 0.15845490f, -0.02278421f, -0.16816555f, 
    0.05653450f, 0.04381838f, -0.17280737f, 0.12595752f, 0.05158309f, -0.00110714f, -0.26818687f, -0.16721147f, 
    -0.11613938f, 0.21430747f, -0.07449686f, 0.06972145f, 0.01904974f, -0.00522406f, 0.00147800f, -0.11727817f, 
    -0.03449937f, 0.01502576f, 0.01955371f, 0.11509124f, 0.08857134f, 0.21239361f, 0.11510842f, -0.30739301f, 
    0.21761072f, 0.10150246f, -0.14660910f, 0.08077499f, -0.06981140f, -0.20430019f, -0.13673568f, -0.03313890f, 
    -0.14981291f, -0.09308445f, -0.01019080f, 0.03853123f, 0.06194132f, 0.16525018f, -0.01869615f, 0.00569996f, 
    0.32283911f, -0.04497580f, -0.07336072f, -0.03105165f, -0.24393338f, 0.00465471f, 0.05854579f, 0.08676890f, 
    -0.04535296f, -0.10185488f, -0.07015735f, -0.05445978f, -0.13411218f, -0.07076843f, 0.23651420f, -0.26999384f, 
    -0.29201758f, -0.00336348f, -0.17299734f, -0.31330028f, 0.18832183f, -0.15622063f, 0.01019795f, 0.04605988f, 
    0.05341208f, 0.09155527f, 0.01502084f, 0.02642497f, -0.00355639f, 0.06363686f, 0.06102832f, 0.01245374f, 
    -0.02717257f, 0.00977929f, 0.01924424f, -0.06859080f, -0.11219355f, -0.00000710f, -0.01436987f, 0.08732140f, 
    0.37637389f, 0.10228424f, 0.15666860f, 0.07053714f, 0.04342349f, -0.01583700f, -0.07260011f, 0.09064764f, 
    -0.06581282f, 0.07662044f, 0.09326383f, 0.06072045f, 0.07364562f, -0.03843719f, -0.03008108f, 0.07190361f, 
    -0.04751397f, -0.04908924f, -0.19787334f, -0.26819009f, -0.10531783f, -0.25943157f, 0.09118672f, 0.00614626f, 
    -0.17031376f, 0.01871649f, -0.02530813f, -0.02417095f, 0.03945671f, -0.02404125f, 0.17874068f, -0.03310164f, 
    -0.00469290f, -0.02523461f, 0.12665236f, 0.07214361f, 0.02398811f, -0.03628419f, 0.02353861f, 0.17045243f, 
    0.15127100f, -0.12599637f, 0.12419615f, -0.02795588f, -0.14105546f, 0.24777788f, -0.05389554f, -0.08420379f, 
    0.06327880f, 0.13326639f, 0.01284530f, 0.09052096f, -0.01913657f, 0.05313124f, 0.00835115f, 0.04009381f, 
    0.01296455f, -0.02557373f, 0.06692965f, 0.14217921f, -0.38663819f, 0.01311344f, -0.19244875f, -0.18131274f, 
    -0.14984947f, -0.03757479f, -0.02406666f, 0.07612460f, -0.05546517f, 0.14744592f, -0.01288205f, -0.07061855f, 
    -0.03650099f, 0.04081003f, -0.00838270f, -0.09138680f, -0.04430355f, 0.03691648f, 0.02535828f, -0.00869172f, 
    0.21193942f, -0.14069414f, -0.09792161f, -0.04915718f, 0.17603819f, 0.08902272f, 0.06592819f, -0.02628774f, 
    -0.03421960f, 0.01893407f, 0.05847377f, -0.01989179f, -0.01777698f, -0.03053461f, -0.02649990f, -0.04571775f, 
    -0.00087531f, -0.01082069f, -0.05975340f, -0.03234904f, 0.30765751f, 0.12491836f, -0.29378295f, 0.02143848f, 
    0.12817791f, -0.07529911f, 0.08741701f, 0.06242193f, -0.12741335f, 0.10371527f, 0.00726611f, -0.04915843f, 
    0.02163692f, -0.01492449f, 0.01139837f, 0.14958616f, 0.05230493f, -0.00204087f, 0.03377822f, 0.07354212f, 
    -0.50710672f, 0.37313285f, -0.08483615f, 0.10799621f, -0.13808928f, 0.17585772f, -0.39896730f, -0.00876241f, 
    0.10182157f, -0.17789558f, 0.07455825f, 0.05255124f, 0.02770193f, 0.17093468f, -0.12796621f, 0.16917065f, 
    0.01492837f, 0.08989730f, 0.08682082f, 0.02523237f, 0.14412887f, -0.14056017f, 0.06884411f, -0.11089140f, 
    0.02397375f, 0.04943773f, -0.08270798f, -0.04475769f, -0.01914760f, 0.03783437f, 0.13514508f, -0.08966062f, 
    -0.12503025f, -0.03617728f, -0.02321031f, 0.00736200f, 0.14420925f, 0.00359679f, 0.05271717f, 0.20676917f, 
    0.12391087f, 0.23709862f, -0.33133957f, -0.27669337f, -0.17279626f, -0.01754114f, -0.05872679f, 0.03921003f, 
    -0.04972323f, -0.07938316f, -0.09635610f, 0.04624338f, -0.33468232f, 0.04973368f, 0.25156671f, -0.11350991f, 
    -0.08373600f, 0.07661997f, -0.01809526f, 0.01044849f, -0.32337323f, -0.10879076f, -0.35882342f, -0.35652801f, 
    0.03094005f, 0.07128463f, -0.07101651f, -0.08481275f, -0.09336042f, 0.13450406f, 0.02601399f, 0.22745532f, 
    -0.02417677f, -0.14504595f, 0.07401139f, -0.05433168f, -0.09927265f, 0.08727840f, 0.00216274f, 0.16744173f, 
    -0.02825273f, 0.02809049f, -0.07823368f, 0.22706102f, -0.04117765f, -0.04064658f, -0.06383825f, 0.06685952f, 
    0.00898958f, 0.06384131f, -0.12628578f, 0.06743139f, -0.04106049f, -0.08902920f, -0.07221061f, 0.09809773f, 
    0.02053848f, 0.19153683f, -0.16671908f, 0.01413906f, -0.24571897f, -0.04070187f, 0.25558075f, -0.07882845f, 
    -0.09036058f, -0.05435332f, 0.03483241f, -0.02154102f, 0.06008346f, 0.00650465f, 0.03327041f, -0.00593875f, 
    0.02465460f, 0.07934380f, -0.12663652f, 0.10977093f, -0.04333281f, -0.09577331f, -0.07876301f, -0.02899758f, 
    0.36754477f, -0.21848305f, 0.09038230f, 0.02546573f, -0.08208672f, 0.12957729f, -0.09106269f, -0.07136162f, 
    0.04394822f, 0.13369146f, 0.05694444f, 0.13832399f, -0.00376868f, 0.06377152f, 0.10391413f, 0.14751136f, 
    -0.05258608f, -0.09089772f, -0.00506541f, 0.28861660f, -0.08772209f, -0.04757170f, -0.12161251f, 0.14171305f, 
    0.08017723f, -0.02087391f, -0.03521679f, -0.02685498f, 0.02690359f, -0.00289401f, 0.01442352f, -0.05780977f, 
    0.01970141f, 0.03228159f, 0.03454791f, 0.03224536f, 0.01920549f, -0.18936136f, 0.11705391f, 0.18004756f, 
    0.06358977f, -0.00794637f, 0.16744214f, 0.11322097f, -0.13477027f, 0.04352766f, 0.03501749f, -0.01196143f, 
    -0.00822760f, -0.05610938f, -0.01767763f, 0.05921528f, -0.00015331f, 0.02543860f, 0.03931331f, 0.04905347f, 
    0.02250299f, 0.00310648f, -0.03660676f, 0.13089699f, -0.21247154f, -0.08517469f, -0.06983916f, 0.08272913f, 
    -0.01523073f, 0.03484524f, 0.01858424f, -0.10111079f, -0.08462060f, 0.12673788f, -0.11000552f, -0.04997566f, 
    0.03103371f, 0.00697135f, -0.03123456f, 0.07868001f, -0.02341245f, -0.00002832f, 0.00287583f, 0.01098630f, 
    0.07412423f, -0.00989769f, 0.14263855f, -0.01522248f, -0.04502715f, 0.05457712f, -0.03674368f, -0.08549809f, 
    -0.05440868f, 0.00614256f, -0.03227980f, 0.04746616f, 0.05308629f, -0.01799853f, 0.02603660f, -0.07641646f, 
    -0.00625176f, -0.20297177f, -0.26651260f, -0.28351709f, 0.10671899f, -0.09584682f, 0.03111292f, -0.01802471f, 
    -0.16757911f, 0.01042567f, -0.00579831f, 0.04715168f, 0.07922691f, 0.03730214f, -0.15324742f, -0.18838225f, 
    -0.01735748f, -0.03295052f, -0.07203858f, -0.03187595f, 0.07431778f, 0.05212137f, 0.01114601f, 0.05360119f, 
    0.00996399f, 0.11205062f, 0.10550233f, 0.00270166f, -0.11162045f, 0.02862094f, -0.00178040f, -0.06324597f, 
    0.10981877f, 0.14915353f, 0.05508276f, -0.02682049f, 0.01211145f, 0.07236059f, 0.02102892f, 0.05419958f, 
    -0.05273904f, -0.02572424f, 0.17418575f, 0.16230799f, -0.16319323f, -0.04320250f, 0.14049967f, -0.06726049f, 
    -0.13231547f, 0.06702688f, -0.05210514f, -0.13694951f, 0.10937336f, 0.01420276f, 0.02180347f, 0.00485742f, 
    -0.01419481f, -0.03007768f, -0.00430909f, -0.00821870f, 0.00385435f, 0.06821497f, 0.10076427f, 0.18939090f, 
    0.04519277f, -0.30508479f, 0.05670080f, 0.10487967f, -0.26131505f, 0.25211474f, 0.01619982f, -0.11881769f, 
    0.07917125f, 0.08054807f, 0.05701635f, -0.01432071f, 0.01190998f, -0.06403993f, 0.11663771f, 0.08098309f, 
    0.00298467f, 0.04369174f, 0.09759497f, 0.11056668f, -0.27811462f, -0.01223411f, -0.20081928f, -0.16914855f, 
    -0.10370053f, 0.03440644f, 0.05167319f, -0.01743273f, -0.03447510f, -0.13775940f, 0.07514396f, -0.00393657f, 
    -0.00233982f, -0.00156954f, 0.05959352f, -0.00470329f, 0.01209225f, 0.05007406f, -0.02325576f, -0.00142427f, 
    0.11603478f, -0.29718328f, -0.14160119f, 0.05601385f, 0.10302397f, 0.01222311f, -0.03343898f, -0.19686447f, 
    0.04745344f, 0.00804621f, 0.12060538f, 0.03794889f, 0.03336427f, -0.03530927f, 0.19374634f, 0.05372021f, 
    -0.00271488f, 0.09641984f, 0.13658226f, 0.19377214f, -0.49379060f, 0.14855547f, 0.25187969f, 0.00001150f, 
    0.03227683f, 0.01015308f, -0.00438293f, -0.07716540f, 0.00804402f, 0.00140827f, -0.00358698f, -0.05830450f, 
    -0.03592044f, 0.05352759f, -0.10500134f, 0.03858129f, -0.00981470f, -0.03754145f, -0.02809965f, -0.01668629f, 
    0.12885353f, 0.14006011f, 0.12412050f, -0.03603057f, 0.01865048f, -0.13066019f, 0.13753434f, 0.04591256f, 
    0.05174314f, 0.03356194f, 0.03721081f, 0.02082100f, -0.01925322f, -0.07406247f, -0.01948070f, -0.09691671f, 
    0.02385022f, 0.12922344f, -0.02643063f, 0.05564902f, -0.34831548f, -0.01342744f, 0.05841434f, -0.37064123f, 
    0.05340148f, -0.04698965f, 0.02522010f, -0.04448259f, -0.03238696f, -0.02303397f, 0.01698239f, 0.05587323f, 
    -0.04152235f, -0.14949207f, 0.00419433f, -0.01022134f, -0.10382786f, 0.00572218f, 0.05138610f, -0.07806032f, 
    -0.41715384f, -0.13316275f, 0.02487880f, 0.24003710f, -0.08316491f, 0.07543198f, 0.04979056f, -0.00219426f, 
    0.02774412f, 0.02080671f, -0.04039564f, 0.04278572f, 0.01414491f, 0.01571332f, 0.01001131f, -0.15339088f, 
    -0.08880665f, 0.14026871f, -0.01401435f, -0.07430135f, -0.54969424f, -0.13850988f, -0.14871997f, 0.31749731f, 
    -0.14160390f, -0.02504164f, -0.05634160f, -0.06333864f, -0.06753168f, 0.18018222f, -0.11093163f, 0.08783045f, 
    -0.02706941f, -0.02330551f, -0.01898818f, 0.02180694f, -0.22156110f, 0.06663880f, -0.05764508f, 0.02452517f, 
    0.14479169f, -0.11315179f, 0.43149397f, 0.23803045f, -0.60739398f, 0.07652636f, -0.10047673f, 0.13657467f, 
    -0.01594871f, -0.02227798f, 0.02735498f, 0.02452298f, -0.03945171f, 0.00827100f, 0.11855757f, -0.03013258f, 
    -0.03745695f, 0.01612383f, -0.00264372f, 0.04540325f, -0.03875050f, 0.10213689f, 0.01805345f, 0.04065079f, 
    -0.15130362f, -0.01771242f, 0.07043149f, -0.05156201f, -0.03953089f, 0.12286270f, -0.00592872f, -0.06207961f, 
    -0.03741084f, 0.04088247f, -0.15963940f, -0.16476659f, -0.01248134f, 0.04211372f, 0.02757256f, 0.12561493f, 
    -0.10164978f, -0.12027682f, -0.21212670f, 0.09017830f, 0.06018353f, 0.05023340f, -0.08936113f, -0.07695945f, 
    0.02098923f, 0.00394745f, -0.06384586f, 0.07555995f, 0.06156067f, 0.11927155f, -0.01171910f, 0.05447252f, 
    0.07866886f, 0.10997217f, 0.03753029f, -0.03479544f, -0.19127262f, 0.01894302f, -0.00951805f, -0.35568640f, 
    0.02097667f, 0.11879054f, 0.04096634f, 0.07226418f, 0.00441397f, -0.14939946f, 0.02253444f, -0.02347165f, 
    0.05478016f, -0.03039608f, -0.06672670f, -0.03818708f, -0.01143004f, 0.14308228f, 0.00924587f, -0.08088262f, 
    -0.19388457f, -0.06020668f, -0.31804559f, -0.12828514f, -0.08808024f, 0.08360780f, 0.03052625f, -0.05890667f, 
    -0.02138784f, -0.10596681f, 0.13794944f, -0.00278122f, -0.00886382f, -0.01745333f, -0.00768847f, -0.02352138f, 
    0.00810450f, 0.05621258f, -0.01403557f, 0.00234280f, 0.67226726f, -0.10640510f, -0.43987519f, -0.45752633f, 
    0.28237993f, 0.04142576f, 0.20337015f, -0.01478778f, -0.10034320f, 0.10772404f, 0.06377295f, 0.04795286f, 
    -0.02250981f, -0.03279819f, -0.08547226f, -0.05171214f, 0.18519029f, -0.16136435f, 0.05709378f, 0.02102145f, 
    -0.08156744f, -0.17141537f, -0.10020050f, -0.05071118f, 0.01976034f, 0.00335561f, -0.03799761f, -0.10925882f, 
    -0.02590830f, 0.01632853f, 0.02628148f, 0.12030108f, 0.02986685f, 0.04668150f, 0.16294467f, -0.00429590f, 
    -0.04583803f, 0.10799910f, 0.08783512f, 0.10156938f, -0.09908821f, 0.11494776f, -0.22678277f, -0.04362518f, 
    0.00491718f, 0.17875753f, -0.09826591f, -0.06355533f, 0.02023484f, 0.08813505f, -0.02854176f, 0.03815191f, 
    0.03715064f, 0.02193137f, 0.00025794f, 0.09752911f, -0.09635082f, 0.15270273f, -0.07444576f, 0.01731956f, 
    -0.17990384f, 0.13318136f, 0.16931295f, -0.21604723f, 0.03490428f, 0.02681006f, 0.03712627f, 0.05046375f, 
    0.00668874f, -0.03852909f, 0.17893890f, -0.00673076f, 0.00228575f, -0.04686439f, 0.02348052f, 0.05747256f, 
    0.00688141f, 0.05709576f, 0.12623343f, 0.07885331f, -0.62963456f, 0.19293694f, -0.11541793f, 0.24495806f, 
    -0.01608895f, 0.13199513f, -0.17230912f, 0.00874567f, 0.03179079f, 0.09237458f, -0.13621622f, 0.11371286f, 
    -0.02413369f, -0.04298399f, -0.03036694f, 0.04980292f, -0.11176194f, 0.21722412f, -0.01685294f, -0.01721451f, 
    0.00051250f, 0.20078056f, 0.12041175f, -0.13828734f, 0.07059775f, -0.05915604f, 0.09082608f, -0.04647836f, 
    -0.08799013f, 0.23265553f, 0.01003523f, -0.01415246f, -0.07362708f, -0.00641388f, 0.02863224f, -0.03182442f, 
    -0.13217588f, -0.11490683f, 0.04826588f, 0.03577425f, -0.30897942f, 0.18366770f, -0.37430805f, 0.16031799f, 
    -0.18586507f, -0.13101469f, 0.05029339f, 0.12121242f, 0.11544956f, 0.08712769f, 0.07192603f, -0.06040445f, 
    0.00272062f, 0.05991652f, 0.01284357f, -0.07734923f, 0.03188474f, 0.04734172f, -0.07700699f, -0.10166267f, 
    -0.02526239f, -0.02975138f, 0.18298694f, 0.12165745f, -0.12898420f, -0.02715335f, -0.10369311f, 0.02952274f, 
    0.03879392f, -0.11974577f, 0.03287649f, 0.04991938f, 0.01059267f, 0.02064965f, -0.01158089f, 0.04888083f, 
    -0.00048714f, -0.22516336f, -0.14189862f, -0.32839087f, -0.26714179f, 0.13958898f, -0.02057413f, 0.20162149f, 
    -0.12815540f, 0.06597733f, -0.01068932f, -0.04746937f, 0.12106600f, -0.04594164f, 0.08057559f, 0.00567886f, 
    -0.11030463f, 0.10462151f, 0.14073282f, -0.00178947f, 0.06038192f, 0.03479024f, -0.00922969f, 0.02032584f, 
    0.14331849f, -0.05485623f, 0.18634859f, -0.10695601f, -0.21118113f, 0.13419151f, 0.12920992f, 0.01575374f, 
    -0.07481123f, -0.10307167f, 0.02265253f, -0.00767710f, 0.00699728f, -0.00799570f, 0.02218980f, 0.01452371f, 
    0.08966155f, 0.00379615f, 0.15266614f, 0.19324537f, -0.49648353f, -0.09520320f, 0.03282874f, -0.03698892f, 
    0.08187725f, 0.08302560f, 0.01950932f, -0.08929066f, -0.08823086f, -0.10091970f, 0.10489814f, -0.06302307f, 
    0.27490059f, -0.02331310f, 0.02475036f, 0.10888901f, -0.08941560f, -0.16365683f, 0.21780704f, -0.10157330f, 
    0.00864756f, -0.18300676f, 0.07600248f, 0.03321457f, 0.01419523f, -0.07820337f, -0.08806414f, -0.02208805f, 
    0.09147156f, -0.22367647f, 0.15073980f, 0.00387964f, 0.09640852f, -0.07185969f, 0.08977938f, 0.09219194f, 
    0.07452468f, 0.01691642f, 0.12996735f, 0.26492953f, 0.04825545f, -0.31784859f, -0.05246409f, -0.02861230f, 
    0.20240362f, -0.08418782f, -0.06216338f, -0.06916653f, -0.12457576f, 0.06381626f, 0.04806926f, 0.12795915f, 
    -0.01442660f, 0.24951290f, -0.08361614f, -0.00790364f, 0.00184047f, 0.06148531f, 0.01493675f, 0.17018229f, 
    -0.30501044f, -0.07831174f, -0.06539529f, -0.19617406f, -0.18468191f, 0.03333198f, -0.05898306f, -0.16780682f, 
    -0.00518798f, 0.26431403f, 0.12156993f, 0.15733182f, -0.04214581f, -0.02657868f, -0.05648616f, -0.03653596f, 
    -0.02034581f, 0.04547194f, 0.02591671f, 0.10733036f, 0.15176412f, -0.07435191f, 0.18174794f, -0.05690714f, 
    -0.16443449f, 0.09676424f, 0.08850283f, -0.05287725f, -0.00876157f, -0.01911724f, -0.05997392f, 0.04220716f, 
    0.02426756f, -0.05118418f, -0.03897187f, 0.00323199f, 0.05576127f, 0.00810249f, 0.04409656f, 0.16929594f, 
    0.07883308f, -0.13511007f, -0.07248096f, 0.04474968f, 0.02435466f, 0.04057559f, 0.08923703f, -0.02679578f, 
    -0.07804658f, 0.05419081f, -0.01440900f, -0.11624619f, -0.04143048f, 0.08126921f, 0.14817317f, -0.01687226f, 
    -0.01525715f, 0.07746228f, -0.04595138f, 0.08642749f, -0.28334531f, -0.03272988f, -0.20701694f, -0.13553016f, 
    -0.11799419f, 0.02560126f, 0.03005250f, -0.07066498f, -0.05087063f, 0.09843195f, 0.07419703f, 0.03428081f, 
    -0.04369214f, 0.09276249f, -0.05817962f, -0.02912943f, -0.04390633f, 0.01905448f, 0.04989581f, 0.04051645f, 
    0.09631693f, -0.04216958f, -0.24956870f, -0.16422865f, 0.10867863f, 0.14832100f, -0.02252021f, 0.00728592f, 
    -0.02200119f, 0.00307983f, 0.00885451f, -0.00769930f, 0.01467756f, 0.01223640f, 0.02779461f, 0.00573750f, 
    -0.06733427f, 0.08658772f, -0.14250286f, 0.00786624f, -0.09843881f, -0.11282987f, -0.10999639f, 0.04295470f, 
    0.07108735f, 0.08006227f, -0.05680044f, -0.00628076f, -0.02381459f, 0.05395945f, -0.01058753f, -0.02929548f, 
    -0.01314991f, 0.01709940f, 0.00296899f, 0.06347422f, 0.03275789f, 0.18639196f, -0.06533641f, 0.00489831f, 
    -0.12890160f, 0.13642077f, 0.26620704f, 0.12908043f, -0.10846659f, 0.06134808f, -0.14041990f, 0.17251068f, 
    0.04854262f, -0.03770438f, 0.01262887f, 0.00097742f, 0.03258244f, 0.00416555f, 0.06546121f, 0.10907814f, 
    -0.01167632f, -0.07489206f, -0.16780327f, -0.18655759f, -0.49898362f, -0.18960848f, 0.23082386f, 0.05801022f, 
    -0.43972024f, 0.11954553f, 0.04408135f, 0.04338151f, 0.07137857f, 0.14676708f, -0.04717911f, 0.05108098f, 
    -0.02006765f, -0.08324824f, -0.01337277f, 0.17147394f, -0.05809260f, 0.02112797f, -0.07363537f, -0.06456828f, 
    -0.01415255f, -0.03609551f, 0.14479758f, 0.06267793f, -0.11171127f, 0.05690236f, 0.09617139f, 0.11769284f, 
    0.05851879f, -0.09499611f, 0.04161000f, -0.00796094f, 0.04080708f, 0.03769073f, 0.02352546f, -0.00202741f, 
    0.01077043f, -0.07270981f, 0.07980080f, -0.06223963f, 0.39191353f, 0.14435589f, -0.20835988f, -0.06489797f, 
    0.15200163f, -0.07984440f, 0.12531437f, 0.02736564f, -0.14688450f, 0.01971898f, 0.05596761f, -0.01978368f, 
    -0.01125483f, 0.04549052f, -0.03062636f, 0.13620093f, -0.03894680f, -0.06831867f, -0.07842021f, -0.07450769f, 
    -0.31765589f, 0.15998185f, 0.25462481f, 0.01703862f, 0.12802280f, -0.07392147f, -0.00540296f, -0.07537852f, 
    -0.02978570f, 0.04388445f, -0.06486335f, -0.00711926f, 0.01435790f, -0.01445722f, 0.07764535f, 0.00529315f, 
    -0.04195319f, -0.05187591f, -0.04291285f, -0.01008173f, -0.13514198f, 0.12107909f, -0.05879056f, 0.11845734f, 
    -0.02887535f, 0.04901835f, -0.03009063f, -0.07821571f, 0.00638863f, -0.14002286f, -0.05651702f, 0.00411639f, 
    -0.08555196f, -0.00854199f, 0.06162911f, -0.03862558f, 0.02043077f, 0.07627697f, -0.19250973f, -0.07892103f, 
    -0.40860015f, -0.31184238f, -0.34454513f, 0.01675108f, -0.28487092f, 0.10372587f, 0.05970402f, 0.11595319f, 
    0.04221325f, -0.08529238f, 0.03982214f, 0.00491788f, 0.03091787f, 0.02664815f, 0.03288556f, 0.03076535f, 
    0.00291642f, 0.04351100f, 0.04014016f, 0.02066748f, -0.05613889f, 0.08391445f, 0.03888598f, -0.08525535f, 
    0.15461715f, -0.01930263f, 0.04449131f, 0.00727143f, -0.01487689f, 0.14111422f, 0.02758714f, 0.08354987f, 
    0.13253422f, 0.06517923f, 0.07754737f, -0.01494673f, 0.09752141f, -0.05332470f, -0.02174901f, 0.05194720f, 
    0.19267723f, 0.11998272f, -0.21756248f, -0.07267238f, -0.08419394f, 0.04339096f, 0.01130065f, 0.04701051f, 
    0.12745890f, 0.08516544f, 0.04107472f, 0.06206354f, 0.10178571f, -0.16542199f, -0.03249243f, 0.05377790f, 
    0.05607892f, -0.15296599f, 0.07773508f, 0.00592623f, 0.11418571f, -0.13902940f, -0.22318672f, -0.05579909f, 
    0.01494604f, 0.04767065f, 0.08490470f, 0.15179256f, 0.06937972f, -0.33399385f, 0.05487580f, 0.03315910f, 
    -0.10855546f, -0.07784595f, 0.04864182f, 0.04572171f, 0.02702971f, 0.15924940f, -0.09464348f, -0.09628397f, 
    -0.01237929f, 0.05781794f, -0.18126823f, -0.10159845f, 0.29426283f, 0.02676263f, 0.03021049f, -0.07786039f, 
    0.04732707f, 0.13275489f, -0.02854373f, 0.04561583f, 0.08424681f, -0.01398863f, -0.10986947f, 0.00920596f, 
    0.10851063f, 0.03728562f, 0.18363601f, 0.03211619f, 0.07263030f, 0.00043194f, -0.21604115f, -0.18162490f, 
    0.01466069f, -0.04348725f, 0.04427433f, 0.13799100f, 0.01291559f, 0.05376578f, -0.02359634f, 0.00178182f, 
    0.02184453f, 0.03558098f, 0.03374638f, 0.02274048f, 0.08738944f, 0.01351066f, 0.01432487f, 0.10731235f, 
    -0.44903600f, -0.31811032f, -0.55079716f, -0.26408547f, -0.15068844f, -0.18697658f, 0.01948837f, -0.04650445f, 
    0.05595957f, -0.29749084f, 0.00388628f, -0.03787530f, 0.04392104f, 0.00668291f, 0.06261735f, -0.00646086f, 
    0.00273334f, 0.07599198f, 0.10156476f, 0.00208731f, -0.11447831f, -0.22218929f, 0.06973369f, -0.00033631f, 
    0.09329209f, -0.03032658f, 0.07441995f, -0.06734349f, -0.05062096f, -0.04217551f, 0.17519817f, -0.00786918f, 
    -0.03258262f, 0.02912792f, -0.04762792f, 0.01434217f, -0.00906559f, 0.00657378f, 0.04404416f, -0.05971928f, 
    -0.13190313f, 0.43179253f, -0.32942566f, -0.13253307f, 0.28661585f, -0.07947568f, -0.05629157f, -0.02113353f, 
    0.15003338f, 0.06096758f, -0.00810116f, -0.00547361f, 0.01135390f, 0.04998852f, -0.04833098f, 0.00433437f, 
    -0.00671129f, 0.01522836f, 0.10162291f, -0.02800266f, -0.45768431f, -0.40205109f, 0.04395035f, -0.23081745f, 
    0.28538173f, -0.11248913f, -0.15396377f, -0.07623444f, -0.13372047f, 0.02099745f, -0.03557773f, -0.02565456f, 
    0.00394090f, 0.02650292f, -0.03914175f, -0.01602766f, 0.01232221f, -0.00021587f, 0.06241089f, 0.01823430f, 
    0.19604459f, -0.00811416f, -0.00817249f, -0.06166937f, 0.07785796f, 0.04256154f, 0.03713545f, 0.08845335f, 
    -0.04099810f, 0.01815588f, -0.01380320f, -0.02539835f, -0.04585853f, -0.03525381f, 0.02307296f, -0.03958569f, 
    -0.06167851f, -0.11805200f, -0.02749108f, 0.06007677f, 0.13985047f, 0.07554221f, -0.05435269f, -0.01395825f, 
    0.04048948f, -0.03014218f, 0.00435841f, 0.14258775f, 0.07366545f, -0.05129876f, 0.04684686f, 0.02243576f, 
    -0.06994668f, -0.10652805f, -0.03432776f, -0.10700582f, -0.04274796f, 0.05994477f, -0.12650257f, 0.06271888f, 
    -0.11809903f, -0.13107458f, 0.27329889f, 0.10000266f, 0.01486954f, 0.03599765f, 0.03666350f, 0.05549279f, 
    -0.01028449f, 0.01773616f, 0.07126117f, 0.03617273f, -0.02471873f, -0.04511880f, -0.08016717f, 0.02378418f, 
    -0.02663870f, 0.03127316f, -0.03788573f, 0.05991263f, 0.01385998f, 0.11068842f, -0.00280321f, 0.04012615f, 
    0.03942465f, 0.05252722f, -0.01210735f, -0.04719289f, 0.03451946f, 0.03421272f, 0.02501426f, 0.01516325f, 
    -0.22021337f, 0.00297249f, 0.04628682f, 0.01252310f, -0.03847670f, 0.02936570f, -0.19564548f, -0.13492393f, 
    -0.09982167f, -0.00812404f, 0.01584105f, -0.03595951f, 0.17013134f, 0.03358818f, 0.03516859f, -0.08847816f, 
    0.02699687f, 0.09849022f, -0.00298964f, 0.02636014f, 0.07297955f, 0.14763732f, -0.10833719f, 0.01314852f, 
    0.07000223f, -0.01008109f, 0.04032250f, 0.17029327f, -0.44093239f, 0.68987662f, -0.19044346f, -0.16173916f, 
    0.47005758f, -0.06518546f, 0.03408055f, -0.09001167f, 0.13167286f, -0.03286534f, 0.16250455f, 0.09245271f, 
    0.06225640f, -0.00912702f, -0.04252804f, 0.07814073f, -0.00189585f, -0.00941525f, -0.00747382f, 0.02133553f, 
    0.09859211f, -0.14700039f, -0.35694808f, -0.19200790f, 0.15209782f, -0.05192899f, 0.05792554f, 0.19674067f, 
    0.10362163f, -0.00339142f, -0.01642989f, -0.00712476f, -0.05871792f, -0.06573684f, 0.07706695f, -0.01570287f, 
    -0.01156378f, -0.00548734f, 0.07247589f, 0.01896093f, 0.12999682f, -0.19326580f, -0.17684606f, 0.07138277f, 
    -0.17049909f, -0.04548578f, 0.07713207f, -0.07403975f, 0.01848169f, 0.04010582f, -0.03055001f, -0.00591911f, 
    0.00735116f, 0.08223051f, -0.02801958f, 0.01047896f, 0.04971952f, 0.12362188f, 0.05409153f, 0.07080548f, 
    0.02028353f, 0.13593651f, -0.09320400f, 0.05535227f, 0.05802982f, 0.03369378f, 0.07337196f, -0.01206388f, 
    0.20393236f, 0.03872407f, -0.04831965f, -0.01011964f, -0.09882352f, 0.10551175f, 0.04741242f, 0.00561050f, 
    0.05131336f, -0.09632888f, 0.10390325f, 0.02666412f, 0.03629918f, -0.08016231f, -0.05201800f, -0.01738861f, 
    -0.00792943f, -0.03938708f, 0.06478878f, 0.09032303f, 0.00462223f, 0.00334826f, 0.03676152f, -0.05772707f, 
    -0.03057146f, 0.05585855f, -0.03612877f, 0.05407699f, -0.06038470f, -0.02632623f, 0.04384680f, 0.04577180f, 
    -0.43212250f, -0.25043508f, 0.06683009f, 0.09163999f, 0.20923312f, 0.00215072f, 0.02795275f, 0.10683007f, 
    -0.12826122f, 0.01758026f, 0.04323667f, 0.01882462f, 0.01097607f, -0.01944158f, 0.01377972f, 0.01718053f, 
    0.01892261f, 0.01724905f, 0.09070197f, -0.01873678f, 0.08876906f, 0.05861116f, -0.10627493f, 0.00774615f, 
    0.12246546f, -0.01579215f, 0.05930983f, 0.04138097f, -0.03232100f, 0.06444950f, -0.09123083f, -0.05991853f, 
    -0.09394960f, -0.08114445f, -0.03469615f, -0.09961761f, -0.15056038f, -0.20042165f, 0.01127343f, 0.03036128f, 
    -0.00474901f, -0.20580396f, -0.19365868f, -0.08165650f, -0.06827827f, -0.00538740f, 0.02414541f, -0.00436326f, 
    0.01501277f, 0.02280856f, -0.04902994f, -0.02728668f, -0.00128264f, 0.04659010f, 0.01468293f, 0.03010565f, 
    0.06003585f, 0.09365746f, 0.09149820f, -0.02504784f, -0.23761947f, 0.15280664f, 0.03806289f, -0.18283598f, 
    -0.06921266f, -0.29091603f, -0.12322295f, -0.18323119f, -0.00431596f, -0.08916106f, 0.03339158f, -0.01155467f, 
    -0.03711222f, -0.05305059f, 0.03830839f, -0.01914537f, -0.05383356f, 0.01235583f, 0.00286390f, -0.06977419f, 
    -0.02766939f, 0.04357859f, 0.08720271f, 0.14855197f, 0.08074001f, -0.01230512f, -0.10644597f, 0.01487025f, 
    -0.03302156f, -0.00862047f, 0.00063350f, 0.02260070f, 0.02434877f, 0.15301089f, 0.00299818f, -0.02608449f, 
    0.03327163f, -0.05090569f, 0.00047133f, -0.01402864f, -0.46893647f, -0.25145742f, 0.12578785f, -0.15986475f, 
    -0.17154297f, -0.04641538f, -0.05731260f, -0.00609073f, -0.13339908f, -0.09409843f, 0.03268161f, 0.06425857f, 
    -0.03076921f, 0.00292058f, 0.01468839f, -0.02758803f, 0.01149401f, 0.07890236f, 0.00757352f, -0.05056221f, 
    -0.11729038f, -0.19566114f, -0.17550287f, 0.00292558f, 0.11471935f, 0.01929849f, -0.01385010f, -0.01679722f, 
    -0.06695890f, 0.11074214f, -0.00046783f, 0.00880293f, 0.08095521f, 0.06659932f, 0.02012781f, 0.01488479f, 
    -0.00257441f, -0.05204465f, 0.14850767f, -0.01197520f, -0.18762161f, 0.07262890f, 0.28047132f, 0.07963406f, 
    0.11693264f, -0.06295633f, -0.04344320f, -0.03677112f, -0.12944688f, 0.16573800f, -0.09459083f, 0.07803044f, 
    0.01726796f, -0.00003512f, 0.03619129f, 0.00373291f, 0.02511561f, -0.01838741f, -0.02731187f, -0.00353668f, 
    0.01969814f, -0.10500193f, 0.02159150f, 0.10376944f, -0.00211138f, 0.04854687f, 0.06795733f, -0.02987153f, 
    0.03475583f, 0.03305996f, 0.07117718f, -0.08974742f, -0.07029738f, 0.02097792f, 0.01907894f, 0.00981304f, 
    -0.00461413f, -0.04377654f, -0.00897937f, -0.03056656f, -0.02900179f, 0.05513000f, -0.03359508f, 0.09301470f, 
    -0.14476277f, 0.01501296f, 0.01508973f, -0.07210817f, -0.02089231f, 0.06131986f, 0.05793056f, 0.01843229f, 
    0.00684958f, -0.02364872f, -0.08858686f, 0.05701693f, 0.03560778f, 0.04029623f, 0.04713437f, 0.07879209f, 
    0.05974710f, -0.76743966f, -0.84567201f, -0.11814231f, 0.11313993f, -0.15860958f, 0.09193964f, 0.09417008f, 
    -0.14797367f, -0.59324998f, 0.04335149f, 0.00802336f, -0.07497831f, 0.02058526f, 0.11761446f, -0.03590738f, 
    0.03526451f, 0.16784222f, -0.02170771f, 0.03717827f, -0.19699426f, 0.32896450f, -0.00505425f, 0.00532553f, 
    0.18375950f, 0.02403620f, 0.06797562f, 0.05299078f, 0.03540649f, -0.04904387f, 0.02296537f, 0.08933701f, 
    0.19686332f, 0.02052280f, 0.11521951f, 0.03416476f, 0.02886596f, 0.06947789f, -0.08160585f, 0.02696891f, 
    -0.42002153f, -0.51338643f, -0.41781765f, -0.13640423f, 0.14072631f, -0.03215553f, 0.11457107f, 0.12354893f, 
    -0.01191588f, -0.00017623f, -0.05980039f, -0.06518512f, -0.00802256f, -0.01056685f, 0.03099458f, 0.04995114f, 
    0.03220209f, -0.04534447f, -0.03260419f, 0.02450016f, 0.04097606f, -0.17490396f, -0.50831228f, -0.21550100f, 
    0.16033189f, 0.01904435f, 0.09022952f, 0.17923597f, 0.04928821f, 0.07979886f, -0.03389394f, -0.00383980f, 
    0.00643927f, -0.08243088f, 0.03946942f, 0.00518118f, -0.07729044f, -0.17732309f, 0.13102022f, 0.07226869f, 
    -1.04921949f, -0.75487304f, -0.68497008f, -0.18825620f, 0.42419833f, -0.08898599f, -0.07033908f, 0.06567349f, 
    -0.25959760f, -0.12997554f, -0.00333441f, -0.02180413f, 0.06036784f, -0.04237731f, 0.08366767f, -0.03238047f, 
    0.01519469f, -0.05993939f, 0.13889380f, -0.00737893f, 0.17727941f, 0.10846614f, -0.29444060f, -0.07528657f, 
    0.12513278f, -0.13921352f, 0.04128900f, 0.02396129f, 0.01207801f, 0.15827900f, -0.07918333f, 0.08835834f, 
    0.07867759f, 0.16296196f, 0.05393355f, 0.00808083f, 0.06785061f, -0.11764392f, 0.18035585f, -0.03615659f, 
    0.07459340f, 0.02599358f, -0.05574165f, -0.06327967f, 0.02153388f, 0.00446342f, 0.00600963f, -0.00400541f, 
    0.00633289f, 0.09662176f, -0.05334950f, -0.05465933f, -0.04714446f, -0.08361907f, -0.03807429f, -0.06999791f, 
    0.00463550f, -0.14775477f, -0.03389784f, 0.04689901f, -0.21502125f, 0.35368285f, 0.10074624f, 0.20157194f, 
    0.01594883f, 0.08711924f, 0.19617125f, 0.02843095f, -0.09659661f, -0.22517577f, 0.07364453f, 0.05409614f, 
    0.07428657f, -0.03550402f, 0.05433426f, 0.05008512f, 0.00882680f, 0.05182574f, -0.04476472f, -0.06686283f, 
    -0.25341940f, 0.10343421f, 0.28093022f, 0.00346683f, 0.09992489f, -0.08771747f, -0.05185068f, -0.08713936f, 
    -0.13388650f, 0.07302096f, -0.15642951f, -0.07983661f, -0.02649357f, 0.01968512f, 0.05403465f, -0.00524040f, 
    0.01578017f, -0.04413337f, -0.02223803f, -0.03307523f, 0.58603585f, 0.29549283f, -0.33681995f, -0.30867735f, 
    -0.21904965f, 0.08949305f, 0.01356148f, 0.14525339f, 0.16433559f, -0.18751408f, 0.07747393f, 0.03078951f, 
    0.03259515f, -0.14014716f, 0.09370681f, 0.00695869f, 0.02865537f, -0.10339127f, 0.00548228f, 0.04788157f, 
    -0.07013801f, 0.07574333f, 0.03713686f, -0.09685369f, 0.01902255f, 0.00270341f, 0.02799113f, -0.02055302f, 
    0.06221672f, 0.11090765f, 0.00487649f, 0.03402758f, 0.03364966f, 0.05937248f, 0.09272788f, -0.01627743f, 
    -0.04550976f, -0.05446757f, -0.10664776f, 0.04673748f, 0.13647029f, -0.19387205f, -0.25996381f, -0.09969888f, 
    0.04297661f, 0.05938614f, 0.07006693f, 0.08591727f, -0.02891699f, 0.01879785f, -0.00785042f, -0.00494898f, 
    0.02072711f, -0.06709535f, 0.03865391f, -0.02075356f, 0.02036529f, -0.03481140f, 0.07736363f, 0.05507940f, 
    -0.27837473f, -0.10860842f, 0.21199612f, 0.03875086f, -0.10651497f, -0.01929050f, -0.18288709f, 0.02442402f, 
    -0.01956258f, -0.01053489f, 0.03351502f, -0.03942253f, -0.01473093f, -0.00338801f, 0.01529992f, 0.00573860f, 
    0.02360735f, 0.04913184f, -0.12879854f, -0.05325935f, -0.04357163f, -0.17267351f, -0.26910692f, -0.10176819f, 
    0.15837659f, -0.04259191f, 0.08874760f, 0.10738401f, -0.00315525f, 0.03426886f, 0.01144265f, -0.00191734f, 
    -0.00338128f, -0.03290868f, 0.02712203f, -0.01133218f, -0.15942396f, -0.09497329f, 0.07201715f, -0.00521155f, 
    -0.29235619f, -0.42811486f, -0.14502394f, 0.05747635f, -0.27113071f, -0.00395279f, 0.03416646f, -0.06325613f, 
    -0.05020724f, -0.39018646f, 0.03095875f, 0.01311248f, -0.02238475f, 0.09280314f, 0.07353963f, -0.01517040f, 
    0.02998130f, 0.18029971f, -0.06810643f, -0.03177740f, -0.73254949f, -0.33939141f, -0.05039144f, -0.01252280f, 
    0.19249091f, -0.35139239f, -0.07684591f, 0.02733562f, 0.04740719f, 0.24197869f, 0.08986477f, 0.01433075f, 
    0.15287335f, -0.15144658f, 0.03897570f, -0.04143050f, 0.01151581f, -0.08656725f, 0.12784119f, -0.07324737f, 
    -0.28074270f, -0.33657166f, -0.56426901f, -0.22037187f, -0.05523438f, -0.21134996f, -0.04963399f, -0.11789109f, 
    -0.13925427f, -0.26213104f, -0.01025721f, -0.02622071f, -0.01302564f, -0.00918703f, 0.06833013f, -0.05249078f, 
    -0.03153297f, 0.06842491f, 0.09966760f, 0.05127534f, -0.17864254f, -0.05744791f, 0.14912438f, -0.02143445f, 
    0.09623599f, -0.12601055f, 0.02843872f, 0.03143654f, -0.09511533f, 0.12337375f, 0.05969266f, 0.06653856f, 
    0.13473734f, 0.01578496f, 0.05928603f, -0.07764267f, 0.03711721f, -0.01367004f, 0.04476111f, -0.03137572f, 
    -0.64291602f, -0.39056054f, -0.19441457f, -0.32645851f, -0.20675397f, -0.28526038f, -0.08439685f, -0.16197185f, 
    -0.09673047f, -0.24670695f, -0.01364519f, -0.00961096f, -0.03026592f, -0.01951844f, 0.04939011f, -0.00876671f, 
    0.02779559f, 0.07315530f, 0.10157903f, -0.14250392f, -0.07631011f, 0.10802256f, 0.01877733f, 0.04098559f, 
    0.10541677f, 0.06031230f, 0.03750889f, 0.09467781f, 0.02403914f, 0.04127329f, 0.02143486f, 0.05045691f, 
    0.18873103f, 0.08604405f, -0.01236980f, 0.01456900f, 0.07067960f, 0.02966442f, -0.13235684f, -0.02216930f, 
    -0.17014123f, -0.21679619f, 0.05587652f, 0.01760328f, 0.07166436f, -0.01207710f, -0.00307318f, -0.03779862f, 
    -0.04477768f, -0.14065309f, 0.12585580f, -0.07516307f, -0.10815206f, 0.06260684f, 0.05248651f, -0.00987752f, 
    0.01204683f, -0.01695509f, 0.03468563f, -0.00824518f, 0.02672677f, 0.11926901f, -0.04361299f, -0.01028001f, 
    0.04954221f, -0.08820238f, 0.07334677f, 0.04904997f, -0.03214782f, 0.20846015f, 0.04812836f, 0.04206857f, 
    0.04549085f, 0.02167750f, 0.02596638f, 0.01366622f, 0.11250532f, -0.03125509f, 0.01228179f, 0.01203847f, 
    -0.47721851f, 0.52390110f, 0.41388339f, -0.11988009f, 0.08374456f, -0.02590213f, -0.04360426f, -0.01292920f, 
    -0.07903706f, 0.17032346f, 0.00386982f, 0.06945692f, -0.07820505f, 0.14382733f, 0.00403215f, 0.00264247f, 
    -0.06208665f, -0.03182042f, -0.00456931f, -0.00730060f, -0.27628887f, -0.19139419f, -0.45495090f, -0.28379852f, 
    -0.10938203f, -0.16977940f, 0.04883593f, -0.13461339f, -0.08262040f, -0.26325431f, 0.06437135f, -0.07038559f, 
    -0.05433591f, -0.02932003f, 0.01716330f, 0.00472229f, 0.00181682f, 0.08947903f, 0.03792408f, -0.03225665f, 
    0.11833221f, 0.09034872f, 0.00350167f, -0.13861607f, 0.01802485f, -0.06815293f, -0.09326144f, 0.04058417f, 
    0.00321952f, 0.02633863f, -0.12883423f, -0.13362716f, -0.16723496f, -0.13688685f, -0.09939830f, -0.07314894f, 
    -0.15348686f, -0.15120226f, -0.14137675f, 0.00218784f, -0.32197931f, 0.29478031f, 0.36229119f, -0.03831667f, 
    0.14777054f, -0.08023767f, -0.06944109f, -0.06824420f, -0.02652136f, 0.20378144f, -0.01435238f, -0.01158355f, 
    -0.00378443f, 0.16973449f, 0.05508813f, -0.00300257f, -0.00843649f, -0.04916811f, -0.06449840f, -0.00643199f, 
    0.11398405f, 0.03058225f, -0.09472531f, -0.08123225f, -0.02306467f, 0.07549793f, 0.03795914f, 0.07734038f, 
    -0.02285963f, 0.02825603f, -0.05474837f, 0.03445974f, -0.00779953f, -0.05317137f, 0.02231749f, -0.04940381f, 
    -0.02800740f, -0.03560857f, -0.01361550f, 0.07434098f, 0.19417155f, 0.01167210f, -0.20638701f, -0.14715652f, 
    0.01405481f, -0.06030483f, -0.07118578f, 0.10844136f, -0.05773988f, 0.07165864f, -0.03402259f, -0.03514280f, 
    -0.05606537f, -0.13067476f, -0.01548852f, -0.12052538f, -0.04792342f, -0.23211671f, -0.04291159f, 0.02962446f, 
    -0.39469275f, -0.31086394f, -0.50965673f, -0.20783482f, 0.23215754f, -0.14415760f, 0.03752733f, -0.18290591f, 
    -0.04781640f, -0.22699296f, -0.01679330f, -0.01149365f, -0.00208604f, 0.04549786f, 0.09145531f, -0.03403597f, 
    -0.03435992f, 0.12228051f, 0.12943541f, 0.09301576f, -0.31563091f, -0.77495199f, -0.65777951f, 0.04734542f, 
    0.29923460f, -0.05560229f, 0.27267584f, -0.03898978f, 0.04029411f, -0.04135027f, -0.02514937f, -0.00250336f, 
    0.00698843f, 0.01301495f, 0.02833223f, 0.00682763f, -0.02672965f, -0.05999202f, 0.18389402f, -0.06700425f, 
    -0.40036297f, -0.51006275f, -0.53495270f, -0.20214050f, -0.14165738f, -0.18410619f, -0.08874127f, -0.09683748f, 
    -0.10857212f, -0.28221947f, -0.04492712f, 0.00985576f, -0.00865830f, -0.05298886f, 0.00574925f, 0.03279260f, 
    0.00535765f, 0.04100422f, 0.13121986f, 0.03315552f, 0.19543903f, 0.01491496f, 0.01004220f, -0.03607674f, 
    -0.08785575f, 0.05645778f, 0.04915198f, 0.10993116f, 0.06763806f, -0.13322434f, 0.03896235f, -0.01416092f, 
    -0.07122139f, -0.04520865f, 0.02886377f, -0.03693866f, 0.00121061f, 0.10863307f, -0.11993599f, 0.02955482f, 
    0.26437938f, 0.04908792f, -0.13039136f, -0.10186179f, -0.09780906f, 0.03594636f, -0.03272902f, -0.05404222f, 
    -0.07036264f, -0.00598593f, -0.03187812f, -0.00536377f, 0.02820638f, 0.02812053f, 0.04231223f, 0.04283133f, 
    -0.00908238f, 0.04042291f, -0.00340053f, -0.01568476f, -0.38928843f, -0.14466533f, 0.18781936f, -0.13013873f, 
    0.10303292f, -0.14872229f, 0.15494622f, 0.04766866f, 0.03140971f, 0.02039057f, -0.04546741f, 0.02262008f, 
    0.03170573f, -0.01365678f, -0.01527388f, 0.02279029f, -0.03802413f, 0.00272592f, -0.12906641f, 0.02532838f, 
    -0.12161721f, 0.07232357f, 0.28147891f, 0.11100072f, 0.17274082f, -0.00135595f, 0.04094136f, -0.00672247f, 
    -0.04208063f, -0.02005148f, 0.01975710f, -0.05852859f, 0.04802653f, -0.00539586f, -0.02665171f, 0.09592034f, 
    0.12726380f, 0.10490988f, -0.04602958f, -0.12351573f, 0.29387012f, 0.25804749f, -0.24189085f, 0.05203729f, 
    -0.40546724f, -0.04337312f, 0.01423099f, 0.03331519f, -0.08383268f, -0.06332663f, -0.10861272f, -0.08007374f, 
    -0.01306787f, -0.02682302f, -0.11129738f, -0.00444184f, -0.04333619f, 0.00507325f, -0.08399200f, 0.00870197f, 
    0.01867494f, 0.04613687f, 0.02004829f, 0.02048663f, -0.01213422f, -0.01100469f, 0.17167632f, -0.10633627f, 
    -0.04674410f, -0.01936498f, 0.03511899f, 0.01682281f, 0.01383097f, -0.04195834f, 0.03925785f, -0.16736530f, 
    0.12372303f, 0.03966559f, -0.02030997f, -0.00379394f, -0.09742288f, -0.14077613f, 0.05997062f, 0.15956740f, 
    -0.01116429f, 0.04477070f, 0.00770427f, -0.05646875f, 0.12742022f, 0.13852575f, 0.03230954f, -0.03761023f, 
    0.06518854f, -0.04777265f, -0.02708411f, -0.01057494f, -0.02577597f, -0.09033743f, 0.03992039f, 0.02619156f, 
    0.05370020f, -0.66834390f, 0.00282227f, -0.27153963f, 0.00063085f, 0.01129473f, -0.06536634f, 0.03786283f, 
    0.02920718f, 0.05096963f, 0.00455498f, 0.05463160f, 0.01793532f, 0.12319478f, -0.00999316f, 0.03752942f, 
    0.02473621f, -0.17510933f, 0.16751172f, 0.06711548f, -0.07156233f, 0.05921192f, 0.00957324f, -0.00882033f, 
    -0.08461490f, 0.01423880f, 0.02686386f, -0.01153325f, -0.08679332f, 0.00699568f, 0.01697580f, 0.03702036f, 
    0.01765130f, -0.01617086f, -0.04034917f, 0.05920815f, 0.08224255f, -0.09112182f, -0.10492340f, 0.10716689f, 
    -0.26979414f, -0.06997865f, -0.14029810f, 0.33869904f, 0.12294270f, 0.17156552f, 0.01692512f, 0.16707768f, 
    -0.02306692f, 0.14963727f, 0.00788376f, -0.09131603f, -0.03105773f, -0.02475972f, -0.05940616f, 0.12880424f, 
    0.13151613f, -0.03311614f, 0.08779271f, 0.06693356f, 0.02754043f, 0.01058232f, -0.10855260f, -0.06973955f, 
    -0.07947128f, -0.00479084f, 0.01539321f, 0.08172217f, -0.01042788f, -0.07596615f, -0.09540209f, 0.04038897f, 
    0.00581689f, -0.08160313f, -0.05073323f, 0.03128965f, -0.04811719f, 0.00281991f, -0.08388031f, 0.00014449f, 
    -0.31670561f, -0.33057052f, -0.30415893f, -0.27578029f, -0.11780956f, 0.02457215f, 0.01157704f, 0.14014564f, 
    0.03430544f, -0.07224540f, -0.02596577f, 0.03839271f, -0.00397650f, -0.03347198f, -0.05312794f, -0.01246955f, 
    -0.06851717f, 0.08878595f, -0.07478733f, -0.00100635f, 0.35201201f, -0.56065923f, -0.42323428f, -0.44060931f, 
    -0.44861016f, -0.01153672f, -0.07950843f, -0.08999910f, 0.31673032f, 0.05799033f, 0.02001703f, 0.03605252f, 
    0.00152992f, -0.01676625f, 0.03430976f, -0.04973779f, 0.01495808f, -0.07357193f, 0.01418180f, 0.00237628f, 
    0.00394079f, 0.09246919f, 0.09746087f, 0.01932963f, -0.00847926f, -0.00502209f, -0.01778470f, -0.01303594f, 
    -0.00972658f, -0.04537927f, 0.04684269f, 0.01950764f, 0.04181076f, 0.00297230f, 0.01588147f, 0.04489734f, 
    -0.08646949f, -0.08640818f, 0.05298659f, 0.03657926f, -0.04752900f, 0.09347979f, 0.00796169f, 0.07158772f, 
    -0.03557018f, 0.00724640f, -0.03215568f, 0.06486046f, -0.04266653f, -0.00313085f, 0.06262889f, -0.06531689f, 
    0.04096191f, -0.03246688f, -0.02213553f, -0.02544647f, -0.16887419f, 0.03951468f, -0.09023312f, 0.03685365f, 
    0.22616833f, 0.19802587f, -0.09873303f, -0.04715938f, -0.15446582f, 0.05851576f, -0.06230174f, 0.04630843f, 
    -0.11578120f, -0.00723002f, -0.12098708f, -0.02759784f, 0.07197686f, -0.21972150f, -0.05023410f, -0.05528431f, 
    0.00067339f, -0.00555097f, -0.12064648f, 0.00167791f, -0.02877295f, -0.08419288f, 0.11294788f, -0.03170654f, 
    0.09336022f, 0.03811175f, -0.00095208f, 0.03853749f, 0.03297239f, -0.02402866f, 0.08525149f, -0.03088498f, 
    -0.09387217f, 0.05316867f, 0.05004064f, 0.01043223f, 0.00026977f, -0.04235673f, 0.06567778f, 0.01704520f, 
    0.19069652f, -0.16819263f, -0.05381783f, -0.05166210f, -0.01856419f, 0.02235096f, -0.00427224f, 0.04318459f, 
    0.04110712f, 0.01642093f, -0.03618719f, 0.05109058f, 0.01339560f, 0.01702774f, -0.03672075f, 0.01466699f, 
    0.11067487f, -0.18624735f, 0.11701233f, 0.19801354f, -0.46637595f, -0.57918185f, -0.12159065f, 0.02094810f, 
    0.00112787f, 0.04773927f, -0.02047126f, 0.28536794f, -0.10251470f, 0.01235709f, -0.10550879f, 0.13793607f, 
    0.00647123f, 0.07143917f, 0.14041151f, -0.00368185f, -0.01001327f, 0.06290702f, -0.02287124f, 0.03695293f, 
    -0.04173372f, -0.00584983f, -0.20284870f, 0.05886811f, -0.23040749f, 0.03355626f, -0.05508768f, 0.08252806f, 
    -0.04296934f, -0.01955146f, 0.03606564f, -0.00697113f, 0.02148087f, 0.00546510f, -0.01542448f, 0.01477673f, 
    -0.01223013f, 0.03852506f, -0.03476818f, 0.00655208f, 0.29195514f, -0.24495189f, 0.34447870f, -0.05427200f, 
    -0.04769407f, -0.18843758f, 0.01164858f, -0.18066007f, 0.14198045f, 0.08020531f, -0.02759083f, -0.04643081f, 
    -0.02709140f, -0.04524058f, -0.03990487f, 0.04867188f, 0.08355118f, -0.04110265f, 0.04697916f, -0.00120972f, 
    0.05772424f, -0.07625385f, -0.18086372f, -0.00452331f, 0.03287506f, 0.01441989f, 0.10695216f, -0.12279233f, 
    -0.11295171f, -0.03258303f, -0.00875587f, 0.05058304f, -0.01270410f, -0.08110639f, -0.08865660f, -0.02661696f, 
    0.01029982f, 0.04327826f, -0.13616580f, -0.06473032f, 0.05401727f, 0.15298325f, -0.04782653f, -0.07350317f, 
    -0.09732438f, -0.01886012f, -0.01210191f, 0.00136294f, -0.02365199f, 0.01218210f, -0.00454276f, 0.04989382f, 
    0.00857457f, -0.04691889f, -0.05645675f, -0.06542234f, 0.01379974f, 0.04033436f, -0.03026170f, 0.00320162f, 
    0.16440111f, -0.38325131f, -0.26190621f, 0.14413197f, -0.10410763f, 0.01777306f, -0.03964761f, 0.04876612f, 
    -0.03355405f, -0.00231853f, 0.02044069f, -0.03925278f, 0.05491441f, -0.07713147f, -0.02389208f, 0.01605441f, 
    -0.02872191f, -0.00942051f, -0.05294231f, -0.06359646f, 0.02842682f, 0.08097640f, -0.02352267f, -0.00836647f, 
    -0.06183814f, -0.02860996f, 0.02805400f, -0.04799738f, -0.02687863f, -0.02711468f, 0.00820769f, 0.00389671f, 
    0.02638525f, -0.02610319f, 0.02230627f, -0.13037503f, -0.07452146f, 0.04862984f, 0.00844618f, 0.01168174f, 
    -0.09843357f, -0.26694572f, 0.04441277f, 0.04110720f, 0.06153370f, -0.03335393f, -0.01632202f, -0.16412248f, 
    0.02707537f, 0.02479580f, -0.04208330f, -0.04573970f, -0.05902945f, 0.00186108f, -0.03437078f, 0.01007729f, 
    0.03578677f, 0.02573875f, 0.08561050f, 0.01518288f, -0.08138938f, -0.28653774f, -0.23046671f, -0.09956104f, 
    -0.08006279f, 0.07663456f, -0.06552507f, 0.08299361f, 0.14158435f, 0.08294751f, -0.02654867f, 0.05016683f, 
    0.10517299f, 0.01676575f, 0.03392432f, -0.00080332f, -0.00701501f, -0.00509184f, -0.08881602f, -0.09043350f, 
    0.33502114f, -0.32374650f, -0.07003712f, -0.41356850f, -0.33143827f, 0.08179870f, 0.06298720f, -0.03762019f, 
    -0.02657488f, -0.15579011f, 0.01403547f, -0.05846255f, 0.05697411f, -0.01578317f, -0.04967041f, -0.04638826f, 
    0.03337953f, -0.03744021f, -0.12147510f, 0.00097119f, 0.31396770f, -0.26374060f, -0.11743253f, -0.27203470f, 
    -0.09563781f, 0.11956383f, 0.00332781f, 0.03275430f, 0.12087590f, 0.02734458f, 0.00355330f, 0.03025488f, 
    0.03890926f, -0.04315457f, -0.00507900f, 0.05315446f, -0.05232910f, -0.03543570f, -0.06271864f, -0.01183591f, 
    0.36169887f, -0.12384206f, -0.18731695f, 0.08372621f, -0.00398178f, 0.05796194f, 0.03817539f, -0.03046856f, 
    0.02367615f, -0.11046240f, 0.11075012f, 0.01467440f, 0.07915800f, -0.08096677f, -0.09824457f, -0.00686413f, 
    -0.08606190f, 0.00647378f, -0.02041728f, -0.11459649f, 0.22930962f, 0.08239907f, -0.06390678f, -0.19962038f, 
    -0.17842126f, -0.05454951f, -0.04019315f, -0.08435381f, 0.08039106f, -0.02311684f, 0.04649943f, -0.02075800f, 
    0.01265642f, -0.00641586f, 0.13124725f, -0.01869809f, 0.02494372f, -0.02037996f, 0.07601701f, 0.00708923f, 
    0.01162932f, 0.11381707f, 0.09514905f, -0.05962851f, 0.05235498f, -0.02676397f, 0.03793375f, -0.00320005f, 
    -0.09186708f, -0.05125105f, -0.02730393f, 0.05048975f, -0.02622784f, -0.04708603f, -0.08539511f, -0.06639376f, 
    -0.04015805f, -0.01209867f, -0.04810432f, 0.00495523f, 0.08068707f, 0.07176480f, 0.03248164f, -0.09552750f, 
    -0.15584715f, 0.00171426f, 0.07640330f, -0.00485228f, 0.02367926f, -0.04650045f, -0.05751270f, 0.02736433f, 
    0.02841869f, -0.08679907f, -0.01284181f, 0.03744508f, 0.06544740f, 0.05820194f, -0.11673827f, -0.03267885f, 
    -0.87831664f, -0.61297011f, 0.34560511f, 0.20512059f, 0.19431707f, 0.19934846f, 0.10879109f, -0.02677033f, 
    0.04538895f, 0.08737601f, 0.06462934f, -0.02989159f, -0.00238530f, 0.01816850f, -0.07936326f, 0.09449314f, 
    -0.03212854f, 0.02791052f, -0.05093163f, -0.09242240f, -0.14422801f, -0.35212070f, 0.14801139f, -0.00624367f, 
    0.13559960f, 0.04191019f, -0.07244853f, 0.19565204f, 0.01662733f, 0.00428709f, -0.14965749f, 0.04623136f, 
    -0.00959934f, 0.06075554f, -0.03031167f, -0.07213303f, -0.02626916f, -0.06040408f, 0.01853071f, 0.04036639f, 
    0.03120006f, 0.30251023f, -0.21397525f, -0.00788104f, -0.14463039f, 0.02542124f, 0.05339065f, -0.00883200f, 
    -0.03783936f, 0.02711190f, 0.05021925f, 0.00387764f, 0.02202216f, -0.00064407f, -0.03997043f, 0.06490547f, 
    0.04438585f, -0.04081746f, -0.02396529f, -0.01087486f, -0.01454638f, 0.21783778f, -0.29054111f, 0.07338633f, 
    -0.21080416f, 0.00804468f, 0.03697207f, -0.09420553f, -0.11539353f, -0.10869552f, 0.00256213f, 0.03753057f, 
    0.00341160f, -0.01106643f, -0.00662753f, 0.01081697f, 0.00523811f, 0.06246840f, -0.04348530f, 0.05598663f, 
    0.17666754f, -0.57116282f, 0.26979893f, 0.73828179f, -0.17946467f, -0.10420731f, 0.19253878f, 0.21685956f, 
    0.09808905f, 0.10089485f, -0.04198698f, 0.01053912f, -0.04789631f, -0.05858920f, -0.03394108f, -0.10724358f, 
    0.10667803f, -0.10543547f, 0.01842517f, 0.15473762f, 0.28442091f, 0.16971026f, -0.32739174f, 0.11352624f, 
    -0.14879678f, 0.07550490f, 0.16123712f, -0.03762166f, -0.05735727f, -0.00847474f, -0.04010984f, -0.04174992f, 
    0.04724904f, 0.17211951f, -0.04020887f, -0.07168652f, 0.00129266f, 0.04332491f, -0.00305040f, 0.01626821f, 
    0.03713403f, 0.13363498f, 0.03846899f, 0.04578989f, -0.10942414f, -0.04018235f, 0.02073533f, 0.01137081f, 
    -0.06667522f, -0.06584442f, -0.02723186f, -0.00482700f, -0.01611275f, -0.04473766f, -0.02504273f, -0.04966227f, 
    -0.05618177f, 0.06329050f, -0.00640868f, 0.00220435f, -0.34199265f, -0.47201008f, 0.12358575f, -0.15793733f, 
    0.19645482f, 0.08634944f, -0.19136544f, 0.12592161f, -0.01436043f, -0.03363653f, -0.12791611f, 0.04417889f, 
    0.09853592f, 0.02784373f, 0.00299629f, 0.01154664f, -0.03212992f, 0.02624610f, -0.01282475f, -0.00626378f, 
    0.21154611f, 0.10724325f, -0.08089577f, -0.08589361f, -0.09114801f, 0.00899653f, 0.00343516f, -0.07203376f, 
    0.03192832f, -0.01229476f, 0.07664575f, -0.01393499f, 0.00663772f, 0.02215525f, 0.06941687f, -0.00154116f, 
    0.00286125f, -0.00952729f, 0.04662609f, 0.01348494f, -0.23317219f, 0.21217591f, -0.05600851f, -0.08767900f, 
    0.19651425f, -0.00629070f, 0.03738998f, -0.02055923f, -0.01372460f, 0.06752922f, 0.06909904f, 0.03655860f, 
    0.01786209f, 0.04451850f, 0.08125342f, 0.18493952f, -0.03695612f, -0.03727037f, -0.04833729f, 0.04436937f, 
    0.05680700f, 0.10595039f, -0.07544515f, 0.00840964f, -0.06883624f, 0.00668882f, 0.04493613f, -0.02839869f, 
    -0.03615638f, -0.07436008f, -0.08603285f, -0.01383289f, -0.09836412f, -0.11667843f, -0.04947785f, -0.02176685f, 
    0.01261855f, 0.00724433f, -0.00125773f, -0.00305949f, -0.05951357f, 0.03993359f, 0.09062567f, 0.06660967f, 
    -0.01065648f, -0.06557392f, 0.04101152f, -0.08714695f, 0.02822254f, -0.01311067f, 0.02461873f, -0.01268342f, 
    0.02887305f, -0.01502314f, -0.02348190f, -0.14703043f, 0.05038469f, -0.07979958f, 0.08349767f, 0.08740669f, 
    0.34076005f, -0.10573820f, 0.07878168f, -0.09004357f, -0.04633351f, -0.05237160f, 0.11668413f, 0.01672746f, 
    -0.02312967f, 0.02197877f, 0.04075488f, -0.07723151f, 0.03066913f, 0.00820572f, 0.01305177f, -0.05808629f, 
    -0.00296101f, -0.01831730f, -0.00100376f, -0.04634197f, 0.13823581f, 0.11922140f, -0.01162551f, 0.08527733f, 
    -0.19516501f, -0.04938053f, 0.07973800f, -0.02994854f, -0.09187176f, -0.11452518f, -0.03861086f, -0.00227205f, 
    0.04760906f, -0.04551037f, -0.01299157f, -0.12481049f, -0.03881054f, 0.08888536f, -0.07395347f, -0.01966839f, 
    0.08538216f, -0.58672696f, 0.57194239f, -0.21973376f, 0.31244916f, 0.12076250f, -0.12524495f, 0.09913336f, 
    0.12826854f, 0.03213188f, -0.03290427f, 0.01446977f, -0.03178865f, 0.02239692f, -0.11690056f, 0.17280176f, 
    -0.04883099f, 0.14348407f, -0.06736506f, -0.10579559f, 0.65825999f, -0.48407912f, -0.77193594f, -0.41527763f, 
    -0.27465877f, 0.00875864f, -0.18954770f, 0.02484690f, 0.15308626f, -0.01566442f, -0.03334230f, 0.04543016f, 
    0.03496554f, 0.00645933f, -0.04678291f, 0.00265841f, -0.02042183f, 0.01101098f, -0.04182088f, -0.07006900f, 
    -0.22725956f, -0.22626318f, -0.19567706f, 0.15003079f, -0.01648528f, 0.03945978f, 0.06761589f, -0.00334525f, 
    0.06553334f, 0.15964147f, 0.01793188f, -0.03865876f, -0.11391766f, -0.08461654f, -0.08676487f, 0.00221314f, 
    0.07310495f, -0.04579552f, 0.13459505f, -0.04460990f, 0.22521067f, 0.29632810f, -0.18222517f, -0.08778630f, 
    -0.33753952f, 0.02326493f, -0.03481877f, 0.04997722f, -0.08255444f, -0.08149090f, -0.07204788f, 0.01334570f, 
    0.03407350f, -0.00965452f, -0.12645866f, -0.02138121f, 0.01040003f, -0.01061194f, -0.04546614f, -0.03966413f, 
    0.18473320f, -0.39200360f, -0.08903773f, 0.11457787f, -0.00645291f, -0.00487680f, 0.20758227f, 0.03824442f, 
    0.05570115f, 0.04683690f, -0.04526713f, -0.03481247f, -0.02221078f, -0.00516974f, -0.01415349f, 0.01972231f, 
    0.03343879f, -0.01965160f, -0.00017509f, -0.03077937f, -0.03483158f, -0.16600381f, 0.16007183f, -0.13788085f, 
    -0.00354070f, 0.00071859f, -0.02543727f, 0.04685653f, -0.01834746f, -0.00534842f, -0.09309978f, -0.04005662f, 
    0.03940621f, -0.06843789f, -0.00252342f, -0.02945685f, -0.03520836f, -0.03644743f, -0.00017197f, 0.04616469f, 
    0.01435938f, 0.02698288f, -0.07249352f, -0.02219909f, -0.04681494f, 0.00004713f, 0.09971966f, 0.15529214f, 
    -0.08048300f, -0.04372231f, -0.07480432f, -0.01067604f, 0.09721722f, -0.00656575f, -0.00157517f, 0.01797286f, 
    -0.02108435f, -0.00437879f, -0.07478328f, -0.01468845f, 0.06514554f, 0.20795724f, -0.19839582f, 0.03837825f, 
    -0.26787469f, -0.00946945f, 0.05167115f, 0.05610827f, -0.09654688f, -0.02049455f, -0.13165461f, -0.07313065f, 
    0.03755289f, 0.01243816f, -0.07321926f, -0.04888152f, -0.05681533f, 0.04482282f, -0.11927851f, 0.01686789f, 
    0.58784860f, -0.58405989f, -0.21167541f, -0.39072913f, -0.19342941f, 0.01477004f, -0.06906466f, -0.20530470f, 
    0.14078578f, -0.23955467f, 0.01813468f, 0.06717143f, 0.03490469f, -0.03979614f, 0.04578811f, -0.02729972f, 
    0.00364143f, -0.02775028f, 0.01027822f, -0.00283077f, -0.51868725f, -0.38189971f, -0.25131053f, 0.24563049f, 
    0.10369621f, -0.06533056f, 0.11656051f, 0.07106840f, -0.00726854f, 0.02484638f, -0.01212483f, -0.01634692f, 
    -0.03235609f, 0.00156148f, 0.01915371f, 0.01858357f, 0.00337242f, -0.05982739f, 0.01625909f, -0.03765508f, 
    -0.00615480f, 0.09918415f, -0.00482132f, 0.09312771f, -0.04707209f, -0.02777846f, -0.01847981f, -0.00322703f, 
    0.00789778f, -0.01592425f, 0.07321527f, -0.01139540f, 0.07303040f, 0.02686423f, -0.00313761f, -0.06234457f, 
    -0.05744478f, 0.08766446f, 0.02663036f, 0.01664512f, 0.24414267f, -0.01871647f, -0.11684132f, -0.14240962f, 
    -0.05876430f, -0.01701649f, 0.03397172f, -0.07132956f, 0.03337936f, -0.06015891f, 0.04531470f, -0.00277341f, 
    0.05467520f, 0.03581977f, 0.04662617f, -0.00803293f, 0.01946735f, -0.00618482f, 0.04879499f, -0.00869525f, 
    0.00963571f, 0.02101396f, 0.17061637f, -0.02900915f, 0.01178738f, -0.03960614f, 0.01059252f, -0.02569907f, 
    0.00368874f, -0.00623822f, 0.05861202f, -0.02338676f, 0.01079859f, -0.01168563f, -0.05510677f, -0.06877156f, 
    -0.04477403f, -0.07017227f, 0.08786859f, -0.01021941f, 0.04529198f, 0.06627519f, 0.01607726f, 0.04845199f, 
    -0.11553684f, 0.00210591f, -0.02455195f, -0.05165055f, -0.03178363f, -0.02909654f, 0.02085008f, 0.04209226f, 
    0.05730009f, -0.02688034f, 0.00751023f, -0.14113994f, -0.09323361f, 0.07489855f, 0.03523666f, 0.00256977f, 
    -0.15406062f, -0.15215734f, -0.39092347f, 0.35449985f, -0.14661226f, 0.04592672f, -0.01336497f, 0.06307223f, 
    -0.07949910f, 0.21173418f, 0.00517392f, -0.06790147f, -0.08434686f, -0.09516917f, -0.09349570f, 0.02317801f, 
    0.03387015f, -0.00904549f, 0.04948366f, 0.10973126f, -0.00939546f, 0.11086596f, -0.16379505f, 0.22143650f, 
    -0.30140761f, -0.18156910f, 0.13801442f, 0.07495790f, 0.04846290f, 0.00146831f, -0.03310055f, 0.06266488f, 
    0.03465761f, -0.01110409f, -0.02105114f, -0.09256419f, 0.06345101f, 0.06183621f, -0.00558339f, 0.02596997f, 
    0.07963641f, -0.24681868f, -0.15222453f, 0.06531700f, -0.09804861f, -0.03955735f, 0.15024617f, -0.00482195f, 
    0.18400067f, 0.12366758f, -0.03185174f, -0.06631073f, -0.08870227f, -0.12178615f, -0.01508241f, -0.07725811f, 
    0.01693015f, -0.09985195f, 0.14467837f, -0.15172896f, -0.10945255f, 0.09592826f, 0.07102215f, -0.03086417f, 
    -0.02345464f, 0.01124993f, -0.05736548f, 0.03832896f, 0.02760647f, 0.01123916f, 0.00271638f, -0.00423923f, 
    -0.00082254f, -0.00904422f, -0.05418679f, 0.03112385f, -0.14383782f, -0.01961702f, -0.07618278f, 0.05419200f, 
    -0.10766404f, -0.21095499f, -0.07306411f, -0.07336016f, -0.02530561f, -0.05934307f, 0.07850421f, 0.05539151f, 
    0.02627281f, 0.00340874f, 0.02414492f, 0.06048485f, 0.08106958f, -0.04713497f, -0.04370730f, -0.00245348f, 
    0.03052123f, 0.01508820f, 0.06565456f, 0.02436164f, 0.20356730f, -0.27905369f, -0.07730586f, 0.06849331f, 
    0.01456796f, 0.02602835f, 0.05018630f, -0.05852010f, -0.02765000f, 0.05392402f, 0.05229240f, -0.01037997f, 
    -0.05447138f, 0.00608137f, -0.00988820f, 0.01777078f, 0.17063096f, 0.04190570f, 0.19232342f, 0.09229697f, 
    -0.43607146f, -0.13070147f, 0.19075824f, 0.02283328f, 0.07482757f, 0.04072214f, -0.05493813f, -0.02131323f, 
    -0.02784784f, -0.03829145f, -0.02679629f, -0.01778740f, 0.01050337f, -0.07861747f, -0.00715531f, -0.15197559f, 
    -0.19199497f, -0.11171135f, -0.15834790f, -0.15353535f, 0.19795257f, -0.00953226f, 0.01946170f, -0.06453042f, 
    -0.16633207f, -0.04528451f, 0.08443367f, -0.06486411f, 0.06546221f, 0.00700883f, 0.06769764f, 0.08731932f, 
    0.09570972f, 0.00595014f, 0.05444831f, 0.00398599f, -0.02022943f, -0.09378572f, 0.03159481f, 0.01451029f, 
    0.18279769f, 0.17047447f, 0.00210914f, -0.03798576f, -0.06367511f, 0.03069692f, 0.05923701f, 0.06788893f, 
    0.04043724f, -0.11507348f, -0.01042085f, 0.03340096f, 0.06823167f, 0.01878497f, 0.00856210f, 0.03198208f, 
    0.03352921f, 0.04411529f, 0.07832340f, 0.02000409f, -0.16135769f, -0.11668717f, -0.05202163f, 0.01908008f, 
    0.01410519f, 0.01136680f, -0.10359770f, 0.03305909f, -0.07527048f, -0.20108825f, -0.03198715f, 0.08818025f, 
    0.08618568f, 0.00288014f, 0.04358904f, -0.08167065f, 0.04247602f, 0.17273864f, 0.23957343f, 0.11963703f, 
    0.40929547f, 0.08251751f, -0.11900690f, -0.13248360f, 0.01585337f, -0.01230583f, -0.04632676f, -0.08598241f, 
    0.05826750f, 0.01217807f, -0.01076656f, -0.01999513f, -0.03177519f, 0.05796009f, 0.02974089f, -0.01389024f, 
    0.05456834f, 0.12633978f, -0.25137487f, -0.31968006f, -0.00220096f, 0.14650416f, 0.14941862f, 0.05979232f, 
    -0.03559711f, 0.04478043f, -0.08726754f, -0.08332372f, -0.02553641f, -0.03064472f, -0.01418883f, -0.00786071f, 
    0.01978358f, -0.07086763f, -0.04848924f, -0.06180670f, -0.06774917f, 0.02843625f, -0.10708815f, -0.06965096f, 
    -0.07983160f, -0.18667790f, 0.04327281f, -0.10400935f, -0.18118320f, 0.06115833f, -0.00603025f, -0.04402608f, 
    0.00370074f, -0.17582239f, 0.04446884f, 0.01804847f, 0.02939845f, 0.00094510f, 0.02135428f, 0.05565549f, 
    0.01917363f, -0.08395283f, -0.05292021f, -0.25062770f, 0.04869817f, -0.00028469f, -0.02327663f, -0.06419469f, 
    -0.17029400f, -0.07454886f, -0.04605589f, -0.04174326f, 0.00887146f, -0.03897085f, -0.00947577f, 0.08719790f, 
    0.07066102f, -0.01216317f, 0.07795312f, -0.00734404f, 0.09807961f, 0.04476839f, 0.08369060f, 0.01136513f, 
    0.28951731f, -0.39885429f, -0.37262478f, 0.02527924f, 0.17071700f, 0.11401671f, 0.21405233f, 0.16189101f, 
    0.09988995f, 0.00980496f, 0.03762718f, -0.03813732f, 0.01464644f, 0.02371241f, 0.01235149f, 0.01494200f, 
    0.00667957f, 0.00135659f, 0.06659015f, -0.00501818f, -0.13436738f, -0.33214971f, -0.61370456f, -0.41984007f, 
    0.05668140f, 0.02022726f, 0.06224768f, 0.22839941f, 0.08533164f, -0.03493432f, -0.05082911f, -0.05475580f, 
    -0.06780249f, 0.01252496f, -0.01598930f, 0.04010347f, -0.06584582f, -0.00881649f, -0.08450778f, -0.01865357f, 
    -0.38494733f, 0.00593932f, 0.05529702f, 0.05550595f, -0.08347769f, -0.04696047f, -0.05111163f, -0.04753006f, 
    -0.02520680f, -0.03234782f, 0.00244900f, -0.02102381f, -0.00777798f, -0.05391534f, -0.04069534f, -0.05727735f, 
    0.02532524f, 0.08758577f, -0.00126773f, -0.00042959f, -0.19298041f, -0.04473678f, 0.07534403f, 0.01760986f, 
    -0.02601851f, -0.05181605f, 0.08040452f, 0.01528598f, 0.07408386f, 0.02360328f, -0.00985449f, 0.05672985f, 
    0.05392327f, 0.02170710f, 0.03810415f, 0.04391013f, 0.11032873f, 0.02170160f, 0.12794730f, 0.07488881f, 
    0.06117488f, 0.15847267f, -0.01935482f, 0.00965300f, -0.29585868f, 0.00944789f, 0.10101355f, 0.12039457f, 
    0.06884657f, -0.13773523f, 0.04317480f, 0.16172856f, -0.06145189f, 0.09601470f, 0.10167791f, -0.05851904f, 
    0.01358952f, -0.02952380f, 0.04017986f, 0.02349807f, 0.25122651f, -0.13247684f, -0.07378567f, 0.01541491f, 
    -0.03033086f, -0.00512544f, -0.03283168f, -0.08731388f, -0.12317728f, 0.05280448f, 0.09835826f, 0.06759204f, 
    0.06498187f, -0.00525340f, 0.02279391f, -0.00143209f, 0.10972701f, 0.07464570f, 0.04036615f, 0.18640305f, 
    0.18498752f, -0.07760648f, 0.09787650f, 0.09961498f, -0.15869875f, -0.11634672f, -0.04683404f, -0.09973199f, 
    0.02944490f, -0.02432669f, 0.04347952f, -0.08139864f, -0.00651351f, -0.08259330f, 0.07081889f, -0.10191089f, 
    -0.13248906f, 0.02873586f, -0.17707351f, -0.19618554f, -0.24381988f, -0.97498220f, -0.04916121f, 0.04574543f, 
    0.37742400f, 0.01380964f, 0.21019264f, 0.06184993f, -0.12573479f, 0.01742073f, 0.07218744f, 0.05066378f, 
    -0.03200770f, 0.22187994f, -0.02520817f, -0.01529366f, -0.04533133f, 0.01460854f, -0.01770101f, -0.07985583f, 
    0.19849616f, 0.07633863f, -0.00102803f, -0.00652050f, -0.11950462f, -0.01060154f, -0.04898486f, -0.04994076f, 
    -0.04398042f, -0.10536022f, -0.01670361f, 0.05145803f, 0.08735211f, 0.02746911f, 0.01209871f, 0.04612742f, 
    0.07883590f, 0.12619615f, 0.16634427f, 0.13004605f, 0.15847938f, 0.18969542f, 0.01837503f, -0.21015178f, 
    -0.00869253f, 0.12499713f, -0.18675308f, 0.11437359f, 0.11855964f, 0.01088542f, 0.02147923f, 0.04468821f, 
    -0.01804723f, 0.00228600f, 0.02241717f, 0.04023744f, -0.03076006f, -0.10091305f, -0.15448686f, -0.28318715f, 
    0.31389809f, 0.03069627f, -0.04405725f, 0.02109176f, -0.05275626f, 0.11836995f, 0.07468868f, 0.04520665f, 
    -0.02975162f, 0.04208620f, 0.00743125f, 0.07639313f, -0.01854573f, 0.05715271f, -0.05434064f, 0.02472882f, 
    -0.03175510f, 0.07593802f, 0.08617065f, 0.03440879f, -0.05361608f, 0.06764176f, 0.01075539f, 0.06755614f, 
    -0.18617544f, -0.06277911f, 0.02129274f, -0.01023142f, 0.01088959f, -0.03973999f, -0.00439599f, -0.01519373f, 
    -0.07848616f, 0.03163883f, 0.00363694f, 0.14759563f, -0.00325215f, -0.00271903f, -0.01389606f, 0.10499001f, 
    0.16897702f, 0.07397983f, -0.19827245f, -0.14164737f, -0.06693290f, 0.14084113f, 0.06731167f, 0.07097658f, 
    0.03409147f, 0.06233204f, 0.08546643f, 0.02706014f, -0.00860821f, -0.00787623f, 0.04220298f, 0.05330517f, 
    0.03671489f, 0.01158635f, 0.04468213f, -0.00262470f, -0.04685387f, 0.06806933f, 0.01654303f, -0.03247640f, 
    -0.12859197f, -0.02250053f, -0.06479078f, -0.00123375f, 0.02254898f, -0.04371878f, -0.07268396f, 0.00316078f, 
    -0.04844538f, -0.03438091f, 0.00752603f, 0.05434768f, 0.07807730f, -0.01552051f, 0.05270904f, 0.04993170f, 
    0.14222434f, 0.10502338f, 0.02758039f, -0.04283330f, -0.04973418f, 0.08602946f, -0.03617484f, 0.03927120f, 
    0.06353411f, -0.00840429f, 0.06290741f, 0.02912114f, -0.04715722f, -0.01113887f, 0.04732805f, -0.01455296f, 
    -0.03527029f, -0.08286821f, -0.12866151f, -0.38002104f, -0.14039420f, -0.20663147f, -0.24322960f, -0.08657876f, 
    0.04722134f, -0.16798016f, -0.01499546f, -0.00848753f, -0.00360476f, 0.01891453f, -0.01710956f, -0.05178064f, 
    -0.08153582f, -0.08140676f, -0.07376256f, -0.01261080f, 0.10532320f, 0.05478818f, 0.15054977f, 0.04648355f, 
    0.24184056f, 0.02402611f, -0.27252513f, -0.05959857f, 0.11280145f, 0.07508176f, 0.07543965f, 0.14162019f, 
    0.00936782f, 0.16392972f, -0.03590149f, 0.11450958f, -0.04532437f, -0.02133563f, -0.02055404f, 0.05027803f, 
    0.00156349f, -0.01340498f, -0.05856890f, 0.09861143f, -0.05809439f, -0.20634928f, -0.45456955f, -0.11682942f, 
    -0.02512077f, 0.03524701f, 0.04842455f, 0.13337454f, 0.01795709f, -0.00100669f, -0.02279621f, 0.00322794f, 
    -0.04150580f, -0.00270566f, 0.02870824f, 0.03952152f, 0.05501333f, -0.01148518f, 0.06223236f, 0.02497930f, 
    0.18523271f, 0.06337167f, -0.32527661f, -0.11415428f, -0.11585769f, 0.10824064f, 0.04555558f, 0.09958740f, 
    0.12804799f, 0.05698052f, 0.05986998f, 0.03891212f, -0.05160000f, -0.04701533f, 0.00061956f, 0.03880325f, 
    0.06247468f, -0.04502606f, 0.05004316f, -0.01981916f, -0.11955632f, -0.19066516f, -0.28523111f, -0.06922957f, 
    0.01389963f, -0.00475443f, 0.02472454f, 0.09737264f, 0.05375118f, 0.06077742f, 0.11074024f, 0.00112440f, 
    0.03284785f, 0.00275783f, 0.01434016f, -0.04444963f, 0.02280490f, -0.00043135f, 0.03332818f, 0.01246594f, 
    0.25250688f, -0.02609087f, 0.01861965f, 0.12530185f, -0.08981270f, -0.09790926f, 0.08549003f, -0.03405176f, 
    -0.01947721f, 0.07032807f, 0.01040671f, -0.03755345f, -0.02701315f, 0.01256894f, 0.07038938f, 0.11393481f, 
    0.13214631f, 0.00667596f, 0.02985213f, 0.02211104f, 0.20580657f, 0.11228323f, 0.02941639f, -0.06477381f, 
    -0.00875182f, 0.03492209f, -0.15491237f, -0.04804697f, 0.00600653f, -0.06374241f, -0.03481715f, -0.01470138f, 
    -0.07605761f, 0.00600905f, -0.01389025f, -0.11288771f, -0.15255956f, -0.16755594f, -0.10298682f, -0.06396194f, 
    0.33556831f, -0.36460742f, 0.07508326f, -0.00941057f, -0.26836991f, 0.07563543f, -0.05456692f, -0.15565780f, 
    -0.26140565f, -0.07233778f, -0.01330643f, -0.02490792f, 0.03168884f, -0.04177272f, 0.03587292f, 0.04051746f, 
    0.00625738f, -0.00623861f, -0.20001999f, -0.23996018f, -0.10933881f, -0.54391986f, 0.07136992f, 0.13984261f, 
    0.19417457f, -0.02079816f, 0.00824341f, 0.07476253f, -0.03978711f, 0.05749409f, 0.07139041f, -0.00805132f, 
    0.03299879f, 0.05208050f, 0.03730929f, -0.06687760f, 0.01969476f, -0.02173697f, -0.04614638f, -0.00001414f, 
    -0.46392867f, 0.16260174f, 0.24489543f, 0.05212767f, -0.29038030f, -0.12436387f, -0.14112738f, -0.21996106f, 
    -0.08487352f, -0.15038259f, -0.04111183f, -0.00819088f, -0.03169843f, -0.08553641f, -0.05404518f, -0.06101263f, 
    -0.04936185f, -0.16145054f, -0.17800885f, -0.21562660f, 0.36773288f, 0.25308275f, 0.11298792f, 0.04075245f, 
    -0.12837622f, 0.05278870f, -0.02291120f, -0.04424226f, 0.00807378f, -0.16060689f, 0.00474547f, -0.00319509f, 
    0.00954472f, -0.03175946f, -0.02144841f, 0.05385042f, -0.02215077f, -0.04160156f, 0.05633006f, -0.02649016f, 
    0.48655477f, 0.09384702f, -0.37032029f, -0.36838305f, -0.07220712f, 0.11682824f, -0.04885999f, 0.01648825f, 
    0.02080088f, -0.07269440f, 0.07106316f, 0.10507116f, 0.12628843f, 0.08801854f, 0.03296789f, 0.03147423f, 
    0.00698006f, 0.05617075f, 0.17247914f, -0.02962172f, 0.48490709f, -0.00228430f, -0.18719287f, 0.08523758f, 
    -0.04565782f, 0.10849003f, -0.03747513f, 0.06722328f, 0.17877145f, 0.05398235f, -0.03182035f, 0.04205414f, 
    0.02277374f, 0.01140524f, 0.03546772f, 0.04533905f, -0.05042137f, -0.14152676f, 0.04482521f, -0.16084234f, 
    -0.06161093f, 0.07678447f, 0.05427998f, -0.06647472f, -0.14314370f, -0.07726794f, -0.00297520f, -0.03358363f, 
    -0.02997025f, -0.01676866f, -0.04941846f, 0.00770268f, 0.06992951f, 0.06251695f, 0.02952891f, 0.04615981f, 
    0.09379048f, 0.01380334f, 0.04399442f, 0.00995837f, -0.11555379f, -0.57370609f, -0.05098004f, 0.12782523f, 
    0.29397491f, -0.02913730f, 0.14456065f, 0.06939054f, 0.02922364f, 0.10696507f, 0.02614884f, -0.06587379f, 
    -0.00347120f, 0.08039086f, 0.00608832f, -0.00811675f, 0.03150741f, -0.11887779f, 0.03095245f, 0.01096290f, 
    -0.17405434f, -0.21474792f, -0.13965946f, -0.16582714f, -0.07001201f, -0.03546929f, 0.01594416f, 0.07972432f, 
    0.05275601f, 0.05454883f, 0.12822019f, 0.04252425f, 0.05591480f, -0.01670913f, -0.00536824f, -0.00164778f, 
    0.04217454f, 0.05330446f, 0.02825109f, 0.05017298f, -0.77796173f, -0.29895684f, 0.13656685f, 0.10389473f, 
    0.29952514f, -0.00038018f, -0.02858556f, -0.02814098f, -0.03811820f, -0.02687287f, 0.06365610f, -0.09035447f, 
    0.06576133f, -0.00106376f, -0.03458892f, -0.13873485f, -0.07022859f, -0.02816319f, -0.01148576f, 0.06605497f, 
    -0.08620025f, -0.10450926f, -0.04996647f, -0.02594572f, -0.11050028f, -0.02460871f, 0.04006534f, 0.01761578f, 
    0.00265646f, 0.04850513f, 0.05425905f, 0.01398879f, 0.04194672f, 0.07218462f, 0.04489638f, -0.00413018f, 
    0.02203833f, 0.03665414f, 0.06358124f, 0.06920962f, -0.13066339f, 0.12602560f, 0.00546367f, 0.00191712f, 
    -0.13023013f, 0.04928999f, -0.13875520f, 0.03137140f, 0.03639127f, -0.14665963f, -0.05749703f, 0.02131495f, 
    -0.02255210f, -0.05090334f, 0.02440565f, -0.13382134f, 0.06474950f, 0.14510384f, 0.09134854f, -0.03407390f, 
    0.00374394f, -0.12208802f, -0.19511937f, -0.10810621f, 0.07565226f, 0.05082593f, -0.08912250f, 0.14294298f, 
    0.09193772f, 0.07356258f, -0.06745804f, 0.02956579f, 0.04770767f, 0.00329097f, 0.04380699f, -0.04684519f, 
    0.04299255f, 0.13660486f, 0.00889764f, 0.07830886f, 0.40307987f, 0.14614639f, 0.05056175f, -0.05179339f, 
    -0.10491854f, 0.01809157f, -0.00546611f, -0.02087900f, -0.00864145f, -0.15438494f, -0.01153683f, 0.05227543f, 
    0.03632672f, -0.00789337f, 0.02417512f, 0.03794599f, 0.01463785f, -0.01297717f, 0.05282449f, 0.04442733f, 
    0.18770263f, -0.47232389f, -0.13059436f, 0.04824897f, 0.00599781f, -0.03682115f, 0.06708191f, 0.07701681f, 
    -0.01574251f, 0.01835520f, 0.09734525f, 0.00473745f, 0.04460406f, -0.02326710f, 0.00745048f, 0.10530666f, 
    -0.19008261f, -0.07691018f, -0.07010854f, -0.05623682f, -0.13815035f, -0.79729462f, -0.94413209f, -0.49980712f, 
    0.02305154f, -0.09812009f, 0.35793149f, 0.09027909f, 0.22846963f, 0.06266891f, -0.02741042f, -0.06152527f, 
    -0.01417749f, 0.00879454f, -0.05405285f, 0.03471352f, -0.06058636f, -0.01665447f, -0.06631178f, -0.01314706f, 
    0.08621424f, -0.15425387f, -0.31116349f, -0.27667645f, -0.10160859f, -0.11189981f, -0.14241233f, -0.03328846f, 
    -0.10548490f, -0.25526622f, 0.01375904f, -0.02281255f, 0.01408886f, 0.09331357f, 0.07089927f, 0.06419041f, 
    0.02815765f, 0.08898290f, -0.01496535f, -0.25299948f, 0.05817455f, -0.02013460f, -0.21579824f, -0.14989033f, 
    -0.11067203f, -0.09879807f, 0.08311518f, 0.01214634f, 0.10756013f, -0.00262901f, 0.12254407f, 0.02964025f, 
    0.06880182f, -0.06874544f, 0.11245298f, -0.01917305f, -0.03215031f, 0.00691838f, 0.04810971f, 0.04569058f, 
    -0.02686230f, -0.41490713f, -0.40524033f, -0.26487312f, -0.02745009f, 0.01162090f, -0.03779111f, -0.06329246f, 
    0.06424410f, 0.07885168f, -0.03678066f, 0.00484444f, 0.01224879f, 0.00628628f, 0.00996903f, 0.01133165f, 
    0.02943976f, 0.04509557f, 0.03448087f, 0.11932638f, -0.01457684f, -0.11715725f, -0.07217456f, 0.12504567f, 
    0.06203191f, 0.00465010f, -0.06575674f, 0.08187395f, -0.00077207f, 0.13019416f, 0.11120695f, 0.04967177f, 
    0.02312336f, 0.06331749f, 0.01697456f, -0.04875537f, 0.04137996f, -0.05762036f, -0.05399688f, -0.00235593f, 
    0.01715125f, -0.08006922f, -0.09833115f, -0.00909259f, -0.20810607f, -0.17952637f, 0.00586387f, -0.07279791f, 
    -0.05632558f, -0.00632338f, 0.04860237f, 0.07855600f, -0.05938937f, -0.01692447f, 0.07374199f, 0.01701079f, 
    0.17132431f, 0.10686439f, 0.14017421f, 0.12679021f, 0.07863513f, 0.03196408f, -0.02178296f, -0.07985168f, 
    -0.09891819f, -0.06146475f, 0.12195700f, -0.00022296f, 0.12792704f, 0.07666060f, 0.04932085f, 0.00464719f, 
    -0.01594093f, 0.03506214f, 0.05386094f, 0.09674203f, 0.03201701f, 0.00981706f, 0.11981246f, -0.06907881f, 
    0.01052567f, -0.49040383f, -0.52589279f, -0.12503579f, 0.10081435f, 0.01164690f, 0.02525102f, 0.18429160f, 
    0.00877054f, 0.15562113f, 0.03548288f, -0.03799563f, -0.07330455f, -0.01362523f, -0.07175113f, 0.01084146f, 
    0.03811008f, 0.01121968f, 0.04498099f, -0.00438759f, 0.26184952f, -0.28776824f, -0.24079759f, -0.12761189f, 
    0.04030684f, -0.00478549f, -0.10414591f, -0.07742761f, 0.02732463f, 0.09030297f, -0.03578240f, 0.00113733f, 
    0.06854718f, 0.00993592f, -0.01821572f, -0.01959859f, 0.06599823f, 0.08927948f, 0.07673148f, 0.13823235f, 
    -0.27744904f, -0.12985408f, 0.02174321f, -0.06883918f, -0.17181951f, -0.06530759f, 0.02526342f, -0.05063491f, 
    -0.01322556f, -0.00487575f, -0.07859142f, -0.06075614f, 0.03239026f, 0.06706161f, 0.00574223f, 0.09658459f, 
    0.05304973f, 0.08439839f, 0.09986041f, 0.03792265f, -0.11584058f, -0.27703062f, -0.25866938f, -0.11168371f, 
    -0.03399456f, -0.01033149f, -0.00861720f, 0.06029562f, 0.00943153f, 0.08272538f, 0.04851775f, 0.04086997f, 
    -0.03507845f, 0.00686288f, -0.08358662f, 0.02149746f, 0.02669938f, 0.03317175f, -0.00005991f, 0.05774261f, 
    -0.29070762f, 0.11067534f, 0.05880421f, 0.01798104f, -0.06207037f, 0.02177345f, -0.11379592f, -0.00846311f, 
    0.00558085f, -0.08272702f, -0.06454722f, -0.03022272f, 0.02825609f, -0.07427321f, -0.01687478f, -0.06469297f, 
    0.04488534f, 0.10234927f, 0.02839596f, 0.00744576f, -0.23168328f, 0.08036151f, -0.01153397f, -0.04599831f, 
    -0.15613653f, -0.00458749f, -0.01697882f, -0.03947341f, 0.01241065f, -0.05123945f, -0.08321376f, -0.06653793f, 
    0.03346697f, -0.01638559f, -0.00473724f, -0.01263741f, 0.08255607f, 0.11309003f, 0.03980888f, -0.00641501f, 
    0.09065396f, -0.08922350f, -0.13185310f, -0.32957733f, -0.25194767f, -0.04600450f, -0.09860702f, -0.04878324f, 
    -0.00219700f, -0.30629265f, 0.06446960f, 0.01248976f, 0.00967343f, 0.03854807f, 0.03629917f, 0.09035397f, 
    0.05821736f, 0.04797976f, -0.02379978f, -0.11763252f, 0.57574862f, 0.14998063f, 0.06703971f, -0.14426593f, 
    -0.22958854f, 0.09967492f, -0.28048798f, -0.09574845f, -0.03080160f, -0.13120125f, -0.01134269f, 0.06094954f, 
    0.01155671f, -0.06507383f, 0.01618681f, -0.08898506f, -0.00318881f, -0.08768760f, 0.09649030f, -0.05578512f, 
    -0.03252846f, -0.19598511f, -0.37900913f, -0.31140950f, -0.11500835f, 0.06667954f, -0.15194759f, 0.04372973f, 
    -0.02801031f, -0.11452930f, -0.00150362f, -0.01667060f, -0.01877542f, 0.05741099f, 0.04450513f, 0.01471209f, 
    0.02274168f, 0.05380214f, 0.00909515f, 0.02933441f, -0.36620021f, -0.15559930f, 0.12060304f, 0.02859861f, 
    -0.04171237f, -0.02450381f, 0.00437964f, -0.00146419f, 0.03862081f, -0.01045547f, -0.02009988f, -0.00123143f, 
    0.03673030f, -0.00670797f, -0.00537079f, -0.04459435f, 0.05346309f, -0.01863137f, 0.08913999f, 0.01093953f, 
    0.16704114f, 0.14877087f, 0.26669940f, 0.22693770f, -0.13924301f, 0.08390581f, -0.07549944f, -0.14712062f, 
    -0.18495567f, -0.12071984f, 0.00076533f, 0.08577301f, 0.10822116f, 0.08225951f, 0.00401790f, 0.05814109f, 
    0.01618141f, -0.05851988f, -0.02494845f, 0.06075447f, -0.04007408f, -0.01834373f, 0.12026285f, -0.20245765f, 
    -0.01943194f, -0.09536520f, 0.00518207f, 0.03695381f, -0.08020110f, 0.07340802f, 0.01107329f, -0.01192642f, 
    0.01510038f, 0.05645844f, 0.01551395f, -0.04866575f, -0.02647546f, 0.00294036f, -0.05955243f, 0.03586059f, 
    0.09808061f, -0.64492804f, -0.43263757f, -0.16621213f, 0.25229791f, -0.01633362f, 0.04494653f, 0.13482228f, 
    0.05352769f, 0.14564703f, -0.02980256f, 0.04418955f, -0.01774217f, -0.05021203f, 0.00355441f, -0.02916850f, 
    0.15903340f, 0.18554397f, -0.00228603f, 0.09999236f, -0.32354155f, 0.18183446f, -0.07210611f, 0.37047729f, 
    0.10464382f, 0.00218120f, -0.12626415f, -0.00020265f, -0.09700824f, 0.00466280f, 0.08143342f, 0.00319668f, 
    0.04874836f, -0.05197163f, -0.08647166f, 0.05206105f, -0.02487635f, -0.00533073f, 0.05985116f, 0.06573214f, 
    -0.22931762f, 0.01922030f, -0.29055315f, 0.03259642f, 0.12978832f, -0.09578952f, 0.15893261f, 0.17092809f, 
    -0.04838948f, -0.03257503f, -0.06247551f, 0.04185293f, -0.01215016f, 0.00044982f, 0.00275316f, 0.01569215f, 
    0.12515207f, -0.04830632f, 0.05628926f, 0.12958118f, 0.15552197f, 0.28212145f, -0.18892880f, -0.12829554f, 
    0.01443275f, -0.17998530f, 0.14703614f, 0.12483047f, -0.01733476f, 0.28905734f, -0.04484260f, 0.02545390f, 
    -0.00844359f, -0.07111140f, -0.04452780f, -0.01895343f, 0.02291867f, -0.06491430f, -0.08177979f, -0.03865043f, 
    -0.01103694f, -0.00011888f, 0.07056013f, 0.52982813f, -0.25590655f, 0.03912713f, 0.01071658f, -0.15099917f, 
    0.10450034f, -0.13166586f, 0.06807189f, -0.07277464f, 0.11240915f, -0.06983719f, 0.08903996f, 0.16867255f, 
    0.15861280f, -0.03555072f, 0.05166777f, 0.25030822f, -0.15188955f, -0.10466224f, -0.50745362f, -0.00668585f, 
    0.16234094f, 0.14651993f, 0.03153351f, 0.07347784f, 0.04259023f, -0.02035624f, 0.01935775f, -0.00290461f, 
    0.02288292f, 0.05173600f, 0.03474196f, 0.01454253f, -0.00924322f, -0.04323456f, 0.06218608f, 0.00671169f, 
    -0.03059712f, -0.13056791f, -0.37632674f, 0.01037175f, 0.01934898f, 0.09794711f, -0.08554845f, 0.08456621f, 
    -0.04428040f, 0.16958968f, -0.00913896f, 0.07813101f, -0.00447165f, 0.03904996f, 0.02134544f, -0.02930068f, 
    0.02876176f, 0.20547566f, 0.04069211f, 0.24290879f, -0.13451993f, -0.10394238f, -0.09394392f, 0.08554542f, 
    0.07767177f, -0.05440538f, 0.14174797f, -0.08086196f, -0.01276876f, -0.03737135f, -0.13810177f, -0.02677520f, 
    -0.03528219f, -0.05861006f, 0.03711220f, 0.03372177f, -0.03598109f, -0.05770532f, -0.06393705f, -0.04524174f, 
    -0.06251200f, -0.19440481f, 0.01379282f, 0.11728074f, -0.37009555f, -0.02492030f, -0.23482361f, -0.01150603f, 
    -0.08215752f, -0.11496440f, -0.03454785f, 0.02545691f, -0.03274852f, 0.04266302f, 0.08482786f, -0.05812141f, 
    0.01622749f, 0.04662523f, 0.00167800f, 0.03293489f, 0.08133490f, 0.02124249f, 0.11961068f, 0.30749437f, 
    -0.73760754f, -0.05746104f, 0.01522862f, -0.14762993f, 0.10987987f, 0.04368974f, 0.09502585f, -0.03278967f, 
    0.03608565f, 0.08616150f, 0.03055923f, 0.07095357f, 0.04909420f, 0.07233007f, 0.03257302f, 0.05279081f, 
    -0.05236272f, -0.11217979f, -0.42417249f, -0.01820709f, -0.06068404f, 0.05217873f, 0.07049955f, 0.21608506f, 
    0.00184179f, 0.04937487f, -0.00570124f, 0.01423861f, -0.06055185f, -0.02342244f, -0.00759226f, 0.02505850f, 
    0.08256748f, 0.03274067f, -0.01515594f, 0.02067938f, -0.25051910f, 0.32349867f, -0.09905091f, -0.21482779f, 
    -0.13142955f, 0.04387009f, -0.05724043f, 0.03500703f, -0.04965093f, 0.07661071f, 0.03480426f, 0.01968489f, 
    -0.03684029f, 0.15122055f, 0.08717211f, 0.00089813f, 0.09812583f, -0.03145872f, 0.02495276f, -0.03793751f, 
    -0.59626842f, -0.05823482f, -0.03417997f, -0.10257462f, 0.16244592f, -0.15832618f, 0.18380101f, -0.32192335f, 
    0.06025704f, 0.10168768f, 0.08034253f, -0.08109616f, -0.09334615f, -0.01820923f, 0.10345279f, 0.18117037f, 
    0.09029096f, -0.06854537f, -0.06926586f, -0.02351042f, 0.03493376f, -0.10313285f, 0.10019354f, -0.21778230f, 
    -0.07435742f, 0.05241507f, 0.06401193f, 0.00964541f, -0.00646352f, -0.01840859f, 0.14910367f, -0.06602985f, 
    0.01171911f, -0.03178059f, 0.00129712f, -0.00998026f, 0.02927967f, -0.16187909f, -0.08084567f, -0.01643747f, 
    -0.03960670f, -0.02704122f, 0.10183092f, 0.28476769f, 0.05022397f, -0.06345906f, 0.08439678f, -0.21155372f, 
    0.14645661f, -0.09187663f, 0.10136073f, -0.10329236f, 0.15628710f, -0.04492980f, -0.03871549f, 0.07197760f, 
    0.18685371f, 0.02033799f, 0.00951285f, 0.14676870f, 0.04999716f, -0.32600060f, 0.15784319f, -0.28370869f, 
    -0.62422234f, 0.03845609f, -0.29682422f, 0.05806681f, 0.05923281f, -0.10814390f, -0.10473809f, 0.07452365f, 
    -0.07949710f, 0.13472910f, -0.04738235f, 0.02999354f, -0.01790198f, 0.05825997f, -0.07962778f, 0.06119858f, 
    -0.24309880f, 0.38452414f, -0.33759889f, 0.05520557f, -0.09277760f, 0.02151087f, 0.04656699f, 0.11070926f, 
    0.01468540f, 0.05920512f, 0.05807874f, -0.04322496f, -0.05896116f, -0.06575713f, -0.12191018f, 0.07308818f, 
    0.05591296f, -0.08165904f, 0.04020103f, -0.09529237f, -0.30655214f, -0.28606737f, -0.10191695f, 0.09462471f, 
    0.02878732f, -0.08540533f, 0.14376622f, 0.08574750f, -0.03848316f, 0.20664275f, 0.05144724f, -0.03566234f, 
    0.01597623f, 0.05868936f, 0.01149045f, 0.02597904f, 0.02601150f, -0.09891968f, 0.12823243f, 0.09362647f, 
    -0.04072525f, 0.05798621f, -0.12033678f, 0.05164656f, -0.05357367f, 0.09367089f, -0.11291036f, 0.09705815f, 
    -0.06071012f, -0.02737832f, 0.01896880f, 0.01449636f, -0.03803028f, -0.02674977f, 0.07959118f, -0.13159451f, 
    0.12262407f, -0.00529718f, -0.04737904f, 0.02250445f, -0.21507233f, -0.04356002f, -0.03810554f, 0.02363615f, 
    -0.02567424f, 0.04423514f, 0.03976545f, 0.07156710f, -0.02818880f, 0.10708130f, -0.04258795f, -0.08054817f, 
    -0.07077525f, 0.02933705f, -0.00639800f, 0.00257722f, -0.04151236f, 0.06118411f, -0.07303954f, -0.01207396f, 
    -0.33405867f, 0.00704617f, -0.07862840f, -0.07806183f, -0.17462641f, 0.08896437f, -0.27348199f, 0.03220913f, 
    -0.00727012f, 0.07285961f, 0.01075727f, -0.03351398f, -0.01201323f, 0.03512161f, -0.03829163f, 0.03537028f, 
    0.00673914f, 0.07209686f, 0.07656109f, -0.07274733f, -0.24627322f, -0.03595703f, -0.30980313f, 0.10744771f, 
    -0.06709123f, 0.03259193f, 0.10434192f, 0.16116233f, -0.08221228f, -0.06937412f, -0.00496355f, -0.00174129f, 
    0.01892571f, 0.01701218f, -0.01079894f, 0.03216206f, 0.18242496f, 0.05236747f, -0.02676357f, 0.07480802f, 
    0.00046495f, -0.04245253f, -0.08821435f, 0.10579401f, -0.03157756f, 0.05830106f, 0.06035363f, 0.03342076f, 
    0.11377794f, 0.09334330f, 0.06046417f, -0.00237855f, 0.07433111f, 0.05749814f, 0.03693807f, 0.00506515f, 
    0.10793470f, 0.08013970f, 0.19039971f, 0.21361080f, -0.11595372f, 0.09762958f, 0.29585329f, -0.03786138f, 
    -0.16716844f, 0.07939051f, -0.17804490f, -0.10497911f, 0.00405632f, 0.08640115f, -0.03139804f, 0.01852835f, 
    0.11121056f, -0.01861854f, -0.01324949f, -0.01098482f, -0.01785446f, -0.06547464f, -0.02035289f, -0.07766048f, 
    -0.12516744f, 0.03442323f, -0.16721357f, 0.01365985f, -0.27418986f, -0.15845925f, 0.04797718f, -0.10002484f, 
    -0.13646117f, 0.14240496f, 0.08170480f, -0.01631131f, -0.07345869f, -0.01472669f, 0.03199595f, -0.06180106f, 
    0.00390329f, 0.03361746f, 0.00858433f, -0.16252680f, -0.26527917f, -0.10097864f, -0.13128357f, -0.00624796f, 
    -0.14060356f, -0.14334197f, 0.01685002f, -0.10156834f, 0.05641584f, 0.06830506f, 0.00104660f, -0.07756312f, 
    0.02439742f, 0.05599840f, 0.00340466f, 0.01808519f, 0.00321732f, 0.01720787f, -0.00562670f, -0.07325901f, 
    -0.51197118f, 0.23649928f, -0.29989755f, 0.24830981f, -0.12395220f, 0.02663409f, -0.07331236f, 0.01772687f, 
    -0.07491369f, -0.08402355f, 0.02838533f, -0.03527579f, -0.05159851f, 0.04317242f, 0.03613178f, -0.04440479f, 
    0.00532790f, -0.02415320f, 0.05529108f, -0.03019680f, 0.06995922f, 0.20422550f, 0.19928212f, 0.39129451f, 
    -0.03400758f, 0.00117286f, 0.02617831f, -0.25682154f, -0.02444131f, -0.19658209f, 0.12103181f, 0.00948866f, 
    0.09323675f, 0.10285904f, 0.08419798f, 0.07358605f, 0.03949202f, -0.06523073f, 0.03135892f, 0.05132942f, 
    -0.16951680f, -0.23527433f, 0.00172767f, -0.22604987f, 0.09064887f, 0.09117497f, 0.05125277f, -0.12169042f, 
    -0.06334813f, -0.08532961f, 0.00175389f, 0.07810151f, -0.06822263f, 0.06623438f, -0.05613359f, -0.08658765f, 
    0.01270124f, -0.02522017f, -0.14278328f, 0.02805953f, -0.25752553f, -0.11561096f, -0.12806115f, 0.03639565f, 
    0.17248614f, -0.00855237f, 0.09868837f, 0.11262751f, -0.11632855f, 0.08627301f, 0.01720933f, -0.12831326f, 
    0.12250225f, 0.05326493f, -0.04615325f, 0.13180417f, 0.08715644f, -0.02315900f, 0.08064336f, 0.11639079f, 
    0.63660669f, -0.09829780f, -0.43684086f, 0.07833663f, 0.00469282f, 0.16444595f, -0.00822139f, 0.15957434f, 
    0.03185726f, 0.17165312f, -0.01993495f, 0.04655835f, -0.04183789f, -0.04540447f, -0.00150090f, 0.02396565f, 
    0.01302353f, 0.11342628f, 0.07325435f, -0.01295805f, 0.03326918f, -0.33860645f, 0.26010147f, -0.22826952f, 
    -0.20026971f, -0.00662752f, -0.19816627f, -0.02346261f, 0.16083585f, -0.04060828f, 0.00592002f, -0.00336693f, 
    0.03651350f, 0.10282500f, -0.02350282f, 0.06551098f, 0.09545156f, 0.04798292f, -0.02327310f, 0.03978289f, 
    -0.12946498f, -0.00381122f, -0.43626666f, 0.00941215f, 0.09069647f, 0.15494759f, 0.12789974f, 0.11791103f, 
    0.05574711f, 0.11393748f, 0.04491129f, -0.00793068f, -0.01668945f, 0.04668427f, -0.06249488f, 0.03573531f, 
    -0.00103281f, 0.08210450f, -0.04676764f, 0.08526108f, -0.32085872f, 0.30367786f, -0.71013403f, 0.20538941f, 
    -0.00832052f, 0.06558417f, 0.04836946f, 0.14420998f, -0.09891801f, -0.01455898f, 0.02697238f, -0.04220701f, 
    -0.01191826f, 0.03128221f, -0.04018144f, 0.04302254f, 0.08548704f, -0.01582629f, 0.05026412f, 0.03055497f, 
    -0.21204111f, -0.06047380f, -0.50467622f, 0.08624227f, -0.47934929f, 0.00960195f, -0.15100296f, -0.10041047f, 
    -0.08153334f, 0.08936250f, -0.04422055f, -0.03686281f, 0.02283947f, -0.02285690f, -0.04865165f, -0.02023748f, 
    -0.03843823f, -0.09973061f, 0.13804901f, 0.03192227f, -0.44566450f, 0.22626300f, -0.44374427f, 0.35429740f, 
    -0.20038602f, 0.04243380f, -0.19444722f, 0.06634225f, -0.03607200f, 0.06852369f, 0.09797569f, -0.00503359f, 
    0.00975178f, 0.01558990f, -0.05090075f, -0.07698668f, 0.01035776f, 0.00522067f, 0.02531871f, 0.14534479f, 
    -0.23345560f, 0.02979534f, -0.09404471f, 0.06417622f, 0.13182317f, -0.00641290f, 0.14649916f, 0.09627656f, 
    -0.01043447f, -0.07315201f, 0.00702958f, 0.09042514f, 0.00948798f, -0.06088622f, -0.01800023f, 0.05082801f, 
    -0.00909648f, 0.00898181f, 0.02202975f, 0.03250511f, 0.08878078f, -0.28079927f, 0.36337656f, -0.56696540f, 
    -0.43631196f, -0.08980673f, -0.28098422f, -0.07755808f, 0.23463279f, 0.08243187f, -0.08178332f, 0.12712534f, 
    0.01320871f, 0.06797976f, -0.01593018f, -0.01619866f, 0.06989907f, 0.01579657f, -0.11902928f, 0.10373278f, 
    0.09932492f, 0.20342357f, 0.26902744f, 0.38255784f, -0.06352904f, 0.02136497f, -0.05437570f, -0.23648573f, 
    -0.06935082f, -0.28363657f, 0.11657450f, 0.04897974f, 0.07354226f, 0.05949666f, 0.06042230f, 0.08571763f, 
    -0.01139024f, -0.00481451f, -0.02549944f, 0.04959902f, -0.33644295f, 0.08785199f, 0.14342530f, -0.34812573f, 
    -0.17531891f, -0.18894987f, -0.05478320f, 0.04429741f, 0.03611197f, 0.10479750f, -0.08216529f, 0.04706546f, 
    -0.05791256f, -0.15144646f, 0.04684495f, 0.07809669f, 0.10345229f, -0.04097682f, -0.11623588f, -0.02248901f, 
    -0.00307935f, 0.07116123f, 0.16042233f, 0.11249158f, 0.16968562f, -0.03670941f, -0.05584591f, -0.06245921f, 
    -0.07669657f, -0.17846465f, 0.04242969f, -0.00248232f, -0.03833319f, 0.00459203f, -0.18284687f, 0.05768501f, 
    0.03553404f, -0.04720364f, -0.10847100f, 0.01431189f, 0.05672951f, -0.09936253f, -0.53257900f, 0.11049327f, 
    0.01050480f, -0.09679250f, 0.15775178f, 0.21324813f, 0.04637244f, 0.14507397f, 0.04061921f, -0.05165025f, 
    -0.10919122f, 0.02557160f, -0.09134339f, -0.02622444f, 0.03796732f, -0.03450814f, -0.02359316f, 0.00217874f, 
    -0.00716260f, -0.02599285f, 0.07062829f, 0.04132480f, 0.02680728f, -0.11112926f, 0.14349264f, -0.09944286f, 
    -0.13956282f, 0.03246087f, 0.03077154f, 0.07096128f, 0.09484700f, -0.00423915f, 0.03034057f, 0.09197600f, 
    -0.00280532f, -0.06985725f, -0.07646154f, -0.03923297f, -0.34808373f, 0.21228941f, -0.66327560f, 0.19491369f, 
    -0.00595395f, -0.06749836f, 0.05739387f, 0.02779896f, -0.10085805f, 0.05064252f, 0.00319410f, -0.01437143f, 
    0.00154381f, 0.02418435f, -0.01304073f, 0.01238623f, 0.12575747f, -0.03940809f, 0.04066799f, -0.00162026f, 
    0.32743225f, -0.73593640f, -0.21915445f, -0.19201232f, -0.03252017f, -0.12250856f, 0.00791962f, 0.06575083f, 
    0.13566342f, 0.20050414f, -0.01177083f, -0.00346777f, -0.00539006f, -0.02572556f, 0.02893719f, -0.10191982f, 
    0.03276999f, 0.13511698f, -0.03187667f, -0.00908638f, -0.28464529f, 0.01001994f, 0.40327021f, 0.55058128f, 
    -0.86956310f, 0.37434116f, -0.34316716f, -0.13971916f, -0.21478240f, -0.18157837f, 0.02406020f, -0.04649976f, 
    0.02083804f, 0.06860580f, 0.02896715f, 0.00947650f, -0.00488160f, -0.03106899f, 0.01441650f, 0.07194286f, 
    -0.06137769f, -0.15183254f, 0.11373062f, 0.12680660f, -0.12314545f, 0.01602021f, -0.18692023f, 0.06840272f, 
    0.11268612f, 0.19402286f, 0.01750605f, 0.05436583f, 0.08513328f, 0.04800187f, -0.00235691f, -0.03777244f, 
    0.07790434f, 0.15179746f, 0.14168465f, 0.14555429f, -0.43574861f, 0.16311610f, -0.02194005f, 0.38099611f, 
    -0.02376933f, 0.10222340f, 0.02368039f, -0.20606394f, 0.02912045f, -0.23280311f, 0.03656071f, -0.11112824f, 
    0.05184364f, -0.08696268f, 0.08596987f, 0.11260983f, -0.05560399f, -0.09389555f, 0.02016961f, -0.02827213f, 
    -0.04132390f, -0.02680329f, 0.21024664f, 0.08483427f, -0.23075192f, -0.00583851f, -0.17260602f, 0.14891362f, 
    0.16826324f, 0.17225936f, 0.00647183f, -0.02271187f, 0.02993340f, 0.02064670f, -0.00280568f, 0.01966283f, 
    -0.01225543f, 0.02855211f, -0.03152047f, -0.17570651f, 0.11927454f, 0.09747720f, 0.04437734f, -0.22558227f, 
    0.04416877f, 0.10068608f, -0.24509269f, -0.04400061f, -0.02259653f, -0.18601917f, 0.01509205f, 0.00964086f, 
    -0.07365455f, -0.05996183f, -0.00614147f, 0.06727067f, -0.00898011f, -0.05412187f, -0.06238186f, 0.14919826f, 
    -0.01740048f, -0.03982987f, -0.15261267f, 0.02471543f, 0.06018356f, -0.11096735f, 0.15304017f, -0.10300208f, 
    0.01362169f, -0.00343934f, -0.12701394f, -0.02885914f, -0.01824836f, -0.06082860f, 0.06834357f, 0.08423579f, 
    -0.05567676f, -0.04007992f, -0.15598717f, -0.12705782f, -0.10491789f, 0.19003257f, -0.05436126f, 0.19370274f, 
    0.04980002f, 0.10956130f, -0.26845402f, -0.05089057f, 0.05908936f, -0.17621207f, 0.01612052f, 0.13210940f, 
    -0.01683031f, -0.03845400f, 0.01642933f, -0.04956104f, -0.07485060f, -0.06550764f, 0.02329230f, 0.08090332f, 
    0.09283429f, 0.05196000f, -0.09988631f, 0.28868517f, -0.13083245f, -0.17330159f, -0.02201555f, -0.38857993f, 
    -0.05536186f, -0.06544060f, 0.03487850f, -0.01999093f, 0.02751180f, 0.06843989f, 0.04367264f, 0.04189161f, 
    0.06894364f, 0.03112035f, 0.02067165f, -0.06067314f, 0.11428172f, 0.16862489f, 0.39010736f, -0.12856476f, 
    -0.26927930f, -0.02524348f, -0.16357018f, 0.11749206f, 0.12733474f, 0.17746763f, -0.07987029f, 0.04940885f, 
    0.05466980f, -0.04629655f, -0.06316783f, 0.04185246f, -0.02678076f, 0.00185630f, -0.05933775f, -0.19377021f, 
    -0.40426648f, 0.08640845f, -0.10996290f, -0.15392086f, -0.11732987f, 0.06157312f, -0.08644440f, -0.00029321f, 
    -0.01642682f, 0.00618574f, 0.05665204f, 0.01321545f, -0.07404386f, 0.05074512f, 0.04301438f, -0.05314850f, 
    -0.08791442f, 0.01260443f, 0.00158237f, 0.05658070f, 0.27211481f, 0.10990631f, 0.07673490f, 0.25478113f, 
    -0.12428261f, -0.07257234f, -0.02319799f, -0.21771771f, -0.11662919f, -0.14877786f, 0.02562951f, -0.01230498f, 
    0.11696123f, 0.07868461f, 0.04473180f, 0.04625760f, -0.00507612f, 0.01425482f, -0.02379089f, -0.04327711f, 
    -0.00322753f, -0.28538093f, -0.39583972f, -0.02967874f, 0.11610074f, -0.07830396f, 0.10955130f, 0.19321023f, 
    0.02432371f, 0.10126650f, -0.02563059f, -0.01355710f, -0.07381011f, -0.05258797f, -0.04465794f, 0.04950334f, 
    0.06181097f, 0.06776623f, -0.04286757f, -0.03756416f, -0.37326783f, 0.03734897f, -0.23025881f, -0.12806475f, 
    0.13684297f, 0.00628331f, 0.11610112f, 0.15309955f, 0.02861193f, -0.08736382f, 0.02763730f, -0.02337863f, 
    -0.01861762f, 0.03423136f, -0.04514194f, 0.06908059f, -0.02755987f, -0.13643782f, 0.05024609f, -0.01660496f, 
    -0.47086650f, -0.13213636f, -0.33572674f, -0.05206170f, -0.11560751f, 0.09685370f, -0.12985186f, -0.02174685f, 
    -0.11634935f, 0.12802541f, 0.07456715f, 0.03395199f, 0.05698762f, 0.09089725f, -0.04154216f, 0.00715951f, 
    0.01296495f, 0.14173181f, 0.11889593f, 0.02176430f, -0.00109930f, 0.11878696f, -0.75413841f, 0.17406651f, 
    -0.25703299f, -0.10050935f, 0.07268909f, 0.16510639f, -0.09388617f, 0.14896159f, -0.02170519f, -0.05620649f, 
    -0.04786862f, -0.01621350f, -0.03977370f, -0.03421361f, -0.01906900f, -0.02025909f, 0.03210618f, -0.04568832f, 
    -0.10114649f, -0.19295442f, 0.31823242f, 0.09678038f, -0.31263906f, 0.07031909f, -0.13333920f, 0.05918964f, 
    0.06344630f, 0.29016885f, 0.05315386f, 0.02320130f, 0.02151298f, 0.00713967f, -0.02405647f, 0.01983117f, 
    0.01364947f, 0.05957520f, 0.07505348f, 0.00240948f, -0.03165168f, 0.18198220f, -0.12277912f, -0.19764161f, 
    0.00798730f, 0.00785686f, 0.09649490f, 0.05899995f, 0.05054168f, 0.17099825f, 0.02452977f, -0.00101141f, 
    -0.05394090f, -0.02900214f, 0.04669627f, 0.02618607f, 0.07934964f, -0.00170444f, -0.00675316f, -0.04501698f, 
    0.21597341f, -0.17313722f, 0.09388681f, -0.04172745f, -0.08625234f, -0.07340015f, -0.02646787f, -0.10898323f, 
    0.05256333f, -0.07863312f, -0.03522232f, 0.03878100f, -0.09778112f, -0.00762607f, -0.09258764f, -0.08436510f, 
    -0.02519242f, 0.04594684f, -0.03745533f, -0.03048549f, -0.23397231f, 0.11298656f, -0.00625627f, 0.04488292f, 
    -0.00054626f, 0.02603532f, -0.00074262f, -0.05497163f, 0.11153241f, 0.08152231f, -0.08097614f, 0.02529220f, 
    -0.01076009f, -0.01435757f, -0.01280893f, 0.01309820f, 0.14587170f, -0.03387233f, 0.13040206f, 0.12911844f, 
    0.01353790f, -0.04758165f, 0.06660224f, 0.23111761f, 0.03900965f, -0.02769674f, -0.00881810f, 0.16948190f, 
    -0.26112860f, -0.08916092f, 0.03686357f, 0.05331355f, -0.03111498f, 0.08496045f, -0.00904989f, 0.01162908f, 
    -0.15222339f, -0.05712652f, -0.43892103f, -0.15841098f, 0.38589272f, -0.19140391f, 0.18477853f, -0.20116806f, 
    -0.09794919f, -0.03451376f, 0.04113790f, 0.06598330f, 0.06702571f, 0.00312146f, -0.03701884f, 0.07350807f, 
    -0.08449454f, 0.01372711f, -0.18437275f, 0.01239086f, 0.00830683f, 0.05481701f, -0.02595291f, -0.13469610f, 
    -0.16075142f, -0.11394607f, 0.04784705f, -0.10682455f, 0.08602940f, 0.05341234f, -0.05185835f, 0.02957236f, 
    0.02466347f, -0.10110296f, -0.15169698f, -0.06858899f, 0.00980641f, 0.06265997f, 0.12633343f, 0.14078374f, 
    -0.09262495f, 0.09401409f, -0.06585705f, 0.02717672f, -0.11159387f, -0.13309531f, -0.03631983f, 0.12421463f, 
    -0.06246299f, 0.00384939f, 0.03738832f, 0.30362654f, -0.14235547f, -0.12020353f, 0.03571974f, -0.00180271f, 
    0.06784175f, 0.08097084f, -0.04134515f, 0.05422077f, 0.02073132f, 0.25483456f, -0.02848167f, 0.16932210f, 
    -0.30702242f, 0.12556310f, -0.23856130f, 0.08241797f, -0.02778391f, 0.07142915f, -0.02729083f, 0.10323578f, 
    0.14141595f, 0.01372768f, -0.09622194f, -0.07383666f, 0.01792035f, -0.11941557f, -0.14695370f, 0.01306312f, 
    -0.28402528f, -0.08606786f, -0.09154585f, -0.14513654f, -0.16660717f, -0.06403577f, -0.10255750f, -0.02168842f, 
    0.04501087f, -0.14729035f, -0.02277965f, 0.00755452f, 0.13550705f, -0.07433142f, -0.20281339f, 0.04489955f, 
    -0.01503032f, -0.00803308f, 0.00353267f, 0.11978580f, -0.07666869f, -0.01815882f, 0.01685753f, -0.07726153f, 
    -0.12322932f, -0.15652466f, -0.29262665f, -0.11753141f, 0.00979017f, -0.06646336f, 0.04001810f, 0.29083753f, 
    -0.15151714f, -0.13396186f, 0.01937369f, 0.09488405f, -0.00960456f, 0.06618580f, -0.04720522f, 0.03387135f, 
    -0.08606382f, 0.02102336f, -0.37512055f, -0.30560422f, 0.11751601f, -0.04513394f, 0.15006164f, -0.02548377f, 
    -0.06638040f, 0.03364982f, -0.01029358f, 0.11891896f, -0.04821689f, -0.05133735f, 0.05439955f, -0.03198470f, 
    0.02847005f, 0.09977547f, 0.02045077f, -0.02524541f, 0.03829187f, 0.00477979f, -0.04573571f, 0.05316250f, 
    -0.34969729f, 0.10601970f, 0.09392391f, 0.08704918f, 0.04544169f, 0.04065755f, 0.05834601f, -0.10779095f, 
    0.12623449f, 0.05767307f, 0.09944341f, -0.01482129f, -0.03202774f, 0.03167871f, -0.02382466f, 0.12264480f, 
    0.10117041f, -0.02329929f, 0.05957326f, -0.05599168f, -0.18350551f, 0.01120240f, -0.36977825f, 0.00911830f, 
    0.07419078f, 0.02713662f, -0.03917969f, -0.03646890f, 0.00337559f, 0.13027295f, -0.10874321f, 0.11011445f, 
    0.03805888f, -0.14003991f, -0.13828902f, 0.00796886f, 0.00206842f, 0.02317712f, 0.02771111f, -0.06923182f, 
    -0.08248969f, -0.18151979f, -0.34973541f, 0.11709257f, -0.11981077f, -0.14441974f, -0.12273378f, -0.04118362f, 
    -0.15669173f, -0.04219889f, -0.08041612f, 0.01195062f, -0.13070601f, 0.00298972f, 0.02721667f, 0.05884203f, 
    -0.07428459f, 0.03704360f, -0.05458068f, 0.00804401f, 0.00978306f, -0.10929103f, 0.00258576f, 0.00135604f, 
    -0.15159810f, -0.02699292f, 0.06517747f, 0.23500803f, -0.07420351f, -0.04861295f, -0.02411604f, -0.10653512f, 
    -0.03208617f, 0.04943099f, -0.02032476f, -0.04096698f, 0.02041942f, 0.17103727f, 0.01869660f, 0.10894818f, 
    0.45705324f, -0.15488908f, 0.43553182f, 0.03372469f, -0.02391171f, -0.02531153f, -0.13544117f, 0.06636628f, 
    0.11363160f, -0.18736194f, 0.04336849f, 0.00625836f, 0.10286257f, 0.02453650f, 0.02428701f, 0.04319946f, 
    0.05874921f, 0.07661463f, 0.00889577f, -0.01335294f, -0.34054273f, 0.15941441f, 0.07893625f, 0.22333440f, 
    -0.07980775f, 0.00328755f, 0.07304326f, -0.05163123f, 0.29288021f, 0.08173158f, -0.17968176f, 0.04321392f, 
    0.10156421f, 0.01067134f, -0.03624605f, 0.00076155f, 0.00806350f, 0.06911884f, 0.19962202f, 0.21889231f, 
    -0.09487686f, 0.16878645f, 0.30763018f, -0.10364244f, 0.00765873f, 0.08738253f, -0.04464890f, 0.03174541f, 
    0.10457356f, -0.10830049f, -0.19358945f, 0.01371467f, -0.11497185f, 0.02097725f, -0.05400445f, -0.17098211f, 
    -0.09804130f, -0.03882353f, -0.16669598f, -0.34910861f, -0.43335372f, 0.33727518f, -0.33598423f, 0.05828547f, 
    -0.00216435f, 0.03635046f, -0.06303430f, -0.01034859f, 0.21254374f, 0.03512645f, 0.10863629f, -0.05454599f, 
    -0.00081336f, 0.05142616f, 0.01977843f, 0.01726198f, -0.04525973f, -0.11929914f, 0.19434702f, -0.14036335f, 
    -0.30748907f, -0.44168523f, 0.10704986f, -0.11062600f, -0.11210857f, 0.00614449f, -0.01698320f, 0.15024987f, 
    0.00081157f, -0.06527744f, -0.13727465f, 0.00379744f, 0.00986867f, 0.06143165f, -0.02210968f, -0.00249084f, 
    0.11459866f, 0.14959110f, 0.11814733f, 0.03071278f, 0.04269352f, -0.01061226f, -0.32587913f, 0.16090290f, 
    0.07530261f, -0.03194169f, 0.08421456f, 0.07494388f, -0.19666988f, -0.09172991f, -0.09633406f, -0.00655602f, 
    0.00916667f, 0.05347167f, 0.06962357f, -0.00024347f, -0.12112710f, -0.27636918f, 0.04861136f, -0.13278660f, 
    -0.16885595f, -0.11287356f, 0.18898813f, 0.11397505f, 0.06610530f, -0.09729886f, -0.09212567f, -0.01534595f, 
    0.26787668f, 0.00097228f, 0.03888895f, -0.05678999f, 0.01108877f, 0.03440510f, -0.01374186f, 0.13467918f, 
    0.02911105f, 0.02811443f, 0.27207717f, 0.02384753f, 0.17515482f, -0.29280981f, 0.14131117f, -0.06921663f, 
    -0.08401249f, -0.03123633f, -0.04097306f, 0.01296133f, -0.04037453f, -0.08610732f, 0.02787241f, -0.01511338f, 
    -0.02979386f, 0.10039154f, -0.04207673f, -0.03741251f, 0.05844606f, 0.00177873f, -0.00984254f, -0.06955262f, 
    0.02798571f, 0.10670384f, 0.17140286f, 0.03121201f, 0.09035507f, -0.11712932f, 0.01205570f, -0.07885639f, 
    0.12785988f, -0.07265427f, -0.11663745f, 0.09242605f, 0.03202650f, -0.06714278f, 0.02407103f, 0.07193308f, 
    0.08440135f, -0.02125796f, 0.16064975f, -0.00408167f, -0.17248261f, -0.29809603f, 0.02098285f, 0.05915907f, 
    -0.21137027f, -0.09911091f, -0.20414737f, -0.01305199f, -0.11746716f, 0.00160230f, -0.06105970f, -0.04283473f, 
    -0.04232804f, 0.03420954f, -0.02701909f, 0.06469942f, -0.01199576f, -0.00634708f, -0.00919712f, 0.02115096f, 
    -0.09072503f, -0.04045347f, -0.26739338f, 0.02864787f, 0.07135612f, -0.07149612f, 0.08299071f, 0.04172868f, 
    -0.07769241f, -0.02166134f, -0.00110005f, -0.00364120f, 0.03950721f, 0.07380103f, 0.00024897f, 0.05557017f, 
    -0.05603403f, -0.19122283f, -0.11096717f, -0.15344958f, -0.26775959f, -0.11827890f, 0.01549020f, -0.07465259f, 
    -0.09161873f, -0.08324520f, 0.08491179f, -0.08938792f, 0.12096713f, 0.00297876f, -0.00299280f, -0.04535308f, 
    -0.02714169f, -0.07050140f, -0.06055743f, 0.06846509f, 0.05831710f, -0.00248527f, 0.09289219f, 0.22347824f, 
    0.09605619f, -0.04239916f, 0.18006243f, 0.15500779f, 0.23870520f, 0.03394850f, 0.05724866f, 0.20887074f, 
    0.00242080f, 0.05642127f, -0.13156413f, 0.06438753f, -0.02816057f, -0.10379978f, 0.02243796f, 0.11793225f, 
    0.00709128f, -0.04919922f, 0.13244042f, 0.05078755f, -0.10361693f, 0.04089228f, 0.11269816f, 0.06453686f, 
    0.16157873f, -0.08411013f, 0.01763271f, -0.04049046f, -0.04095321f, -0.00573035f, -0.11449276f, 0.05520199f, 
    0.03880867f, -0.00034958f, -0.00256610f, 0.02734639f, 0.04155857f, 0.01724048f, 0.06420338f, 0.01102757f, 
    0.03983464f, 0.15508436f, 0.23270062f, 0.12106457f, 0.06659050f, -0.05521695f, -0.09550935f, 0.05539677f, 
    0.10603080f, -0.00344365f, -0.05056233f, 0.00413421f, 0.03740296f, -0.00768666f, -0.03642887f, 0.05324602f, 
    0.10314992f, 0.01161036f, 0.05474141f, -0.07482784f, 0.14846122f, 0.13713337f, -0.02491075f, -0.05884609f, 
    -0.05055177f, 0.02456349f, 0.00148541f, -0.03900612f, -0.05874960f, -0.01250120f, -0.10796846f, 0.05015492f, 
    0.00009832f, -0.07501697f, -0.04929043f, -0.06207813f, -0.07714851f, -0.04322726f, 0.05169427f, -0.04424419f, 
    -0.29910985f, 0.08740590f, 0.24501607f, 0.08074058f, -0.13634214f, 0.01986980f, -0.06321139f, -0.03853399f, 
    0.19393165f, 0.02555982f, -0.13248555f, 0.07570033f, -0.07648358f, 0.06750496f, 0.04133894f, -0.09179389f, 
    0.14687473f, 0.07902132f, 0.10451141f, 0.09603705f, 0.32093492f, -0.11875398f, 0.15062954f, 0.26192468f, 
    -0.00121590f, -0.10977612f, 0.04477217f, 0.02235351f, -0.13342413f, -0.08723642f, 0.01517533f, -0.04720548f, 
    -0.00683719f, 0.00788936f, 0.04217301f, -0.02597706f, -0.10243052f, -0.16802277f, 0.01688313f, -0.17379265f, 
    -0.29362828f, -0.10965308f, -0.42684025f, -0.04205758f, -0.08456392f, 0.05262800f, -0.12011708f, -0.16160397f, 
    0.19818519f, -0.01138975f, -0.06489781f, 0.11235157f, -0.00485667f, 0.02149279f, -0.10393472f, 0.10985767f, 
    -0.07670457f, -0.14662766f, -0.02936711f, 0.00147122f, -0.21530187f, 0.30929637f, -0.24410850f, 0.19133987f, 
    0.19314738f, 0.04753741f, -0.00083990f, -0.05126124f, 0.06769381f, 0.08174162f, -0.09777302f, 0.01287112f, 
    0.03974650f, -0.00679789f, -0.03664691f, -0.05740026f, -0.02340248f, -0.25824142f, 0.03666125f, -0.05247705f, 
    0.01108508f, -0.53250635f, 0.14631976f, 0.16887356f, 0.11684519f, -0.22310409f, -0.05664908f, -0.02365468f, 
    -0.31042197f, -0.23809128f, -0.03396652f, -0.01434640f, -0.04256408f, -0.04263711f, -0.06379099f, 0.04367273f, 
    -0.22213288f, -0.16265586f, -0.07544137f, -0.06559235f, -0.19203892f, -0.44138065f, 0.11311316f, -0.08771930f, 
    -0.00571244f, -0.04339440f, -0.10386360f, 0.09966783f, -0.02094813f, -0.06523088f, -0.14391571f, 0.01814581f, 
    0.03907212f, 0.01137069f, 0.02157862f, 0.07558429f, -0.08748151f, 0.06319868f, 0.02403889f, -0.04436158f, 
    -0.09677584f, 0.04926944f, 0.02839132f, -0.24358821f, 0.13551751f, -0.10538434f, -0.00223376f, 0.12860096f, 
    -0.06635025f, 0.01929787f, -0.14814749f, 0.00091690f, -0.09154645f, 0.18827054f, 0.14912330f, 0.10622073f, 
    -0.04131159f, 0.03219260f, -0.08636118f, 0.01598490f, 0.31198665f, -0.10247807f, 0.35324743f, 0.10883521f, 
    0.11822400f, -0.14014482f, -0.01449363f, -0.03534666f, 0.09579227f, 0.07810275f, -0.03253787f, 0.03050336f, 
    -0.16457802f, -0.03960096f, -0.07431865f, 0.17668441f, -0.20461498f, 0.06087701f, 0.02778348f, -0.09253058f, 
    -0.03199925f, -0.29172021f, 0.06951749f, -0.21276958f, -0.17569616f, -0.04953503f, -0.10827718f, 0.01916800f, 
    -0.02770814f, -0.12534031f, 0.01221692f, 0.00862492f, 0.01202844f, -0.05777377f, -0.00716626f, 0.07195278f, 
    0.05118592f, 0.01010012f, 0.02533850f, -0.10849243f, -0.08887135f, 0.19505921f, 0.18254606f, 0.18511100f, 
    0.04400543f, 0.09610054f, 0.00362361f, -0.09732627f, -0.02491546f, 0.12104739f, -0.07166503f, -0.01703735f, 
    0.01965695f, 0.01604035f, -0.04758603f, -0.05221020f, -0.02587833f, 0.11851027f, -0.05323901f, -0.02732164f, 
    0.14910683f, 0.04368140f, -0.09938280f, -0.06581998f, -0.09373152f, -0.02851376f, -0.01731749f, -0.09271465f, 
    -0.11726970f, -0.01119123f, -0.09087987f, 0.08468033f, -0.05663481f, -0.08180699f, -0.06472852f, -0.04609174f, 
    -0.08502976f, -0.05474053f, 0.02752585f, -0.03506602f, 0.02250661f, -0.09061369f, -0.00216175f, 0.21991153f, 
    0.00997427f, 0.13115075f, 0.00286049f, 0.22146522f, -0.00205496f, -0.04698495f, -0.04002422f, 0.07614022f, 
    0.00879400f, 0.09959053f, 0.10246550f, -0.06885582f, -0.22049217f, 0.10376554f, -0.13265532f, 0.06937016f, 
    -0.19432218f, -0.11425950f, 0.08894122f, -0.04928358f, -0.15077601f, 0.00558281f, -0.11465900f, -0.13172136f, 
    0.05300424f, -0.04082348f, -0.00287644f, -0.01808608f, 0.01217103f, 0.09280592f, -0.06061589f, -0.07299903f, 
    0.02075955f, -0.00016381f, 0.12483726f, -0.04610492f, -0.11064421f, -0.20162626f, -0.28623396f, -0.00951481f, 
    0.04775344f, -0.00028970f, -0.09355225f, 0.04066749f, -0.23779051f, -0.05037672f, -0.08402053f, 0.03109200f, 
    -0.08835512f, 0.01791439f, 0.00062049f, 0.06107860f, -0.16517253f, -0.04907596f, -0.05800766f, 0.07125569f, 
    0.11156841f, 0.00887024f, -0.00899073f, 0.05725671f, 0.10053969f, -0.06484123f, 0.02932218f, 0.22059272f, 
    0.06284047f, 0.00220467f, -0.04564330f, 0.06027441f, 0.03148757f, 0.04180087f, 0.04234614f, -0.01010441f, 
    0.04537323f, 0.08076639f, 0.00490744f, 0.06979509f, 0.06497464f, -0.31624201f, 0.07314106f, -0.09701097f, 
    -0.03941858f, -0.15281139f, -0.01278067f, 0.13719964f, -0.00744558f, 0.01897859f, -0.09009194f, 0.01824322f, 
    -0.05835687f, 0.05611048f, 0.01111439f, -0.01475087f, -0.03501249f, 0.05769721f, -0.02304119f, 0.03109344f, 
    -0.24065346f, 0.11033592f, -0.41905260f, 0.16152167f, 0.12853357f, 0.00975101f, 0.01256621f, 0.06409262f, 
    0.22806250f, 0.12600717f, -0.00967651f, -0.00311931f, -0.11592461f, -0.01710463f, 0.00844986f, -0.06856208f, 
    0.14430608f, -0.57985568f, -0.03124130f, -0.11966842f, 0.12961672f, -0.22219892f, 0.14637339f, -0.06991168f, 
    -0.03568634f, -0.13992046f, -0.01236965f, -0.11160886f, 0.19957502f, -0.13041361f, 0.03836877f, -0.10235732f, 
    -0.17267683f, -0.16208491f, -0.09205247f, -0.04033975f, -0.01268547f, 0.06541377f, -0.01097892f, -0.07556569f, 
    -0.22645171f, -0.01757387f, -0.41268295f, 0.02142688f, -0.05246930f, -0.01751621f, -0.04530635f, -0.03948191f, 
    -0.10221010f, -0.06089136f, 0.00176146f, 0.07716808f, -0.02315045f, 0.02349784f, -0.02167140f, 0.05977372f, 
    -0.02166974f, -0.11040061f, -0.07595572f, -0.19616254f, 0.30040577f, -0.02402266f, 0.25897563f, -0.00317580f, 
    0.05111504f, -0.06079007f, -0.04755091f, 0.02267969f, -0.01227150f, 0.00153722f, -0.09349472f, -0.02472649f, 
    -0.05962403f, 0.05700854f, -0.01637514f, -0.08912692f, -0.01660234f, 0.03005222f, 0.00342487f, 0.02890084f, 
    -0.39702347f, -0.06202200f, -0.13924117f, -0.00257066f, 0.16658114f, -0.07388437f, -0.02168919f, -0.00674448f, 
    -0.05419029f, -0.01309483f, -0.07395542f, 0.07913310f, 0.04163356f, 0.05515733f, 0.06063003f, 0.04728203f, 
    -0.01349338f, -0.11488657f, 0.09581144f, 0.14858711f, -0.31539512f, 0.17202567f, 0.07783552f, 0.27193788f, 
    0.03710063f, -0.02682394f, -0.03584049f, -0.07367477f, -0.02296080f, 0.06170485f, -0.12637885f, 0.03907204f, 
    0.12877825f, -0.07537942f, -0.04460109f, -0.06953986f, 0.05191786f, -0.05991915f, 0.01088290f, 0.07622875f, 
    -0.02201997f, -0.18663424f, 0.12703066f, -0.11027867f, -0.13083291f, 0.02307651f, 0.09037417f, 0.02178307f, 
    -0.04939271f, -0.06169855f, 0.02020890f, 0.10005727f, 0.00258048f, 0.07510970f, -0.00770427f, -0.01178885f, 
    0.13170177f, 0.02031198f, 0.07798262f, 0.13030079f, 0.05621479f, -0.28264654f, 0.19023797f, -0.07050981f, 
    -0.06134157f, -0.07114506f, -0.08088262f, -0.06867977f, 0.00708217f, -0.09012295f, -0.00475838f, 0.03416766f, 
    -0.06136798f, 0.10817797f, -0.00176521f, -0.05194232f, 0.06974979f, -0.05193135f, -0.01019812f, -0.03133420f, 
    0.00186477f, 0.03617146f, 0.04671888f, 0.00045428f, 0.02530368f, 0.08881750f, 0.01669933f, -0.04373088f, 
    0.00609165f, 0.06833182f, -0.14578266f, 0.08860312f, 0.00596971f, -0.08813772f, -0.11094122f, 0.08967805f, 
    0.00273582f, -0.13411248f, 0.08131056f, 0.00244723f, -0.31330615f, -0.03431076f, -0.34355751f, 0.10154606f, 
    0.07692001f, -0.05054129f, -0.03177674f, -0.00727061f, 0.03677768f, -0.07153242f, -0.12524517f, 0.09160661f, 
    0.04464182f, 0.08263557f, 0.01582314f, 0.03687831f, -0.02323354f, -0.01576991f, 0.04964515f, 0.20348024f, 
    -0.17857723f, -0.26358381f, -0.33622700f, -0.21411654f, -0.30587766f, -0.04593113f, -0.09744292f, -0.07603799f, 
    -0.04145197f, -0.02381610f, -0.10294484f, -0.01143314f, 0.01275829f, 0.02004769f, -0.16418241f, 0.05473474f, 
    0.01208739f, 0.08327825f, 0.07496072f, -0.14001030f, 0.08418632f, 0.05062449f, -0.00240814f, 0.17001951f, 
    0.06541611f, 0.04695681f, 0.03390834f, -0.08582866f, -0.20678256f, 0.04778701f, -0.18877666f, 0.09839971f, 
    -0.04411832f, -0.04095773f, -0.04568302f, 0.03748077f, -0.06288327f, -0.12706941f, 0.05462733f, 0.08434236f, 
    -0.01612863f, -0.13459352f, -0.28586787f, 0.21441962f, 0.03273696f, -0.08469477f, -0.12676828f, -0.05841395f, 
    -0.16131945f, -0.02170159f, -0.10289238f, 0.01409546f, -0.11312301f, 0.06317531f, 0.08076008f, 0.01694581f, 
    -0.11111686f, -0.00847212f, -0.12039791f, 0.04866987f, -0.21756470f, -0.36759180f, -0.24965546f, -0.18583575f, 
    -0.21463549f, -0.13341919f, -0.18993543f, -0.06020007f, -0.03687465f, -0.18030266f, -0.22019929f, 0.06464832f, 
    -0.09485403f, -0.01735964f, -0.00001597f, 0.08757909f, 0.02415372f, 0.07170158f, 0.00222474f, -0.08327909f, 
    -0.14364542f, -0.16254641f, -0.05599911f, -0.00870808f, 0.01853658f, -0.19312793f, 0.10677305f, 0.28175950f, 
    0.10350943f, -0.10527174f, 0.04485352f, 0.08589358f, 0.05067219f, 0.02687976f, -0.07726482f, 0.10524384f, 
    -0.08392329f, -0.00601614f, -0.08230484f, -0.24295434f, -0.15490109f, -0.27833858f, -0.09166700f, -0.10861823f, 
    0.15493281f, -0.10648868f, -0.00569667f, 0.09698474f, -0.32192984f, 0.01694180f, -0.05194085f, 0.00142496f, 
    -0.02133682f, 0.04968823f, 0.03015822f, 0.01418294f, -0.20270954f, -0.03723382f, -0.08165460f, -0.00060227f, 
    -0.30748442f, -0.03587502f, -0.47219005f, 0.00059138f, 0.06847095f, -0.01900659f, -0.03701000f, -0.03615550f, 
    -0.04527481f, 0.06397344f, -0.04785893f, 0.05742305f, -0.01663775f, 0.08061571f, -0.01587957f, 0.06057890f, 
    -0.05657271f, -0.05564864f, 0.00117309f, -0.06500345f, 0.02443394f, -0.05203000f, 0.19482860f, -0.03064896f, 
    -0.08879548f, 0.08027170f, 0.02215641f, 0.16711991f, -0.05686027f, -0.02481585f, -0.05333127f, -0.05898549f, 
    0.05147688f, -0.01170762f, -0.02421368f, -0.13772628f, 0.03797105f, 0.20824689f, 0.01427263f, 0.07825767f, 
    -0.28664887f, 0.00616466f, -0.23509519f, 0.05622787f, -0.08875834f, -0.01253811f, 0.06523079f, -0.08319412f, 
    0.07135213f, 0.03719394f, -0.02202137f, -0.01651565f, 0.11001849f, -0.03367508f, -0.06610356f, -0.00857905f, 
    -0.06799109f, -0.06972106f, -0.02419296f, 0.01810896f, -0.06652959f, 0.10367721f, -0.01954721f, 0.19654083f, 
    0.09909263f, -0.13451056f, -0.09284396f, -0.04335455f, 0.05081459f, -0.07091544f, 0.00196722f, 0.00395300f, 
    -0.04500849f, -0.02863883f, 0.03131137f, -0.00180399f, -0.15960933f, 0.07063242f, -0.03173728f, -0.13966750f, 
    0.07438812f, -0.19061404f, -0.07389361f, 0.16361639f, 0.07896567f, -0.04709328f, 0.00359259f, -0.06680773f, 
    -0.06109696f, -0.02922719f, -0.01770223f, 0.06165531f, 0.05145345f, -0.03007660f, 0.03880328f, 0.08330823f, 
    -0.12468890f, -0.07083724f, 0.01355427f, -0.08159405f, -0.05653121f, -0.19794632f, 0.05582236f, -0.18612778f, 
    0.15988751f, 0.08809553f, 0.16752547f, -0.04359691f, 0.09219603f, 0.04542834f, -0.06520253f, 0.01062878f, 
    -0.00818232f, 0.03133633f, 0.04351749f, -0.04634175f, -0.01089071f, 0.02402322f, -0.00652121f, 0.06221690f, 
    0.21404544f, -0.02576138f, 0.19351166f, 0.11679031f, 0.17275827f, -0.04420697f, 0.05845987f, -0.05043294f, 
    0.11307015f, -0.09789795f, 0.01372660f, -0.10899512f, 0.01641736f, -0.00904784f, 0.00381007f, 0.04469988f, 
    -0.01054865f, 0.01412852f, 0.06325120f, -0.03867056f, 0.14252122f, 0.11886981f, 0.07764336f, 0.28479120f, 
    0.07547016f, -0.18405665f, 0.00719044f, -0.13794875f, -0.04632343f, 0.03066793f, -0.05027523f, 0.04355365f, 
    0.01016387f, -0.02073562f, 0.05046605f, 0.04248181f, -0.06530864f, -0.13515939f, -0.04681356f, 0.02642835f, 
    -0.16312905f, -0.17203483f, -0.21477352f, 0.22440428f, -0.18303354f, 0.20081592f, 0.10939425f, 0.07084169f, 
    -0.21456149f, 0.01812350f, 0.08542557f, -0.01524871f, 0.10494700f, 0.28998268f, 0.05717031f, 0.03670132f, 
    -0.09482113f, 0.21016149f, -0.06667148f, 0.07169566f, 0.23638572f, -0.08473218f, 0.18793595f, 0.04790421f, 
    0.01942861f, -0.05247482f, -0.04356384f, -0.03713746f, 0.07441670f, -0.18581167f, -0.06673216f, -0.05721745f, 
    0.00236730f, -0.08697451f, -0.08856709f, 0.13031748f, -0.01832577f, -0.02842601f, 0.08359265f, -0.00159914f, 
    0.13311963f, -0.37321657f, -0.08447000f, -0.13315859f, 0.16508515f, -0.08815829f, -0.20976010f, -0.15081996f, 
    0.06887913f, -0.17578939f, 0.04069131f, 0.07477766f, 0.04383355f, -0.01944251f, 0.00224597f, 0.10270463f, 
    0.00539575f, -0.04833057f, 0.13157108f, 0.03750164f, -0.19582316f, 0.07577404f, -0.10301509f, 0.04479245f, 
    -0.05228759f, 0.04275644f, 0.04467894f, 0.08763029f, -0.18340351f, 0.09645417f, -0.09412471f, 0.04385386f, 
    -0.02476356f, -0.00447074f, -0.05674821f, 0.00388540f, 0.02832955f, -0.01984807f, -0.03465761f, 0.02057020f, 
    0.06254391f, -0.15641926f, 0.35996905f, -0.16272411f, -0.29868698f, -0.04898943f, -0.01420741f, -0.15629366f, 
    0.03264969f, -0.06226240f, 0.02918535f, 0.00029333f, 0.03163106f, 0.00775471f, 0.11048160f, 0.04385110f, 
    0.03524750f, -0.01698501f, 0.04378178f, -0.06218367f, -0.16750413f, -0.16575293f, -0.20301785f, -0.15981801f, 
    -0.48909509f, -0.09995012f, 0.00058831f, -0.01480402f, -0.13614386f, -0.05275451f, 0.01193080f, 0.01774937f, 
    0.09553917f, 0.07874437f, -0.01238378f, 0.00637617f, 0.04997145f, 0.06107099f, 0.02666443f, 0.02235370f, 
    0.24213584f, -0.04793589f, 0.16929655f, 0.04016406f, -0.32033050f, -0.08470953f, 0.02816365f, -0.07717129f, 
    0.04403143f, -0.00862255f, -0.04274372f, -0.02137555f, 0.02851721f, -0.03598204f, -0.06136682f, 0.04087835f, 
    0.13933058f, 0.05817250f, -0.02024433f, -0.03073890f, 0.23494247f, -0.14651336f, 0.23328961f, 0.04207866f, 
    0.08457351f, 0.09395022f, 0.10091168f, -0.15244539f, 0.18969712f, 0.07585175f, 0.00045493f, 0.10798168f, 
    -0.06690767f, 0.03877402f, 0.03013624f, -0.03831200f, 0.10536569f, -0.01339372f, 0.02209911f, -0.08057386f, 
    -0.31148443f, 0.01948378f, -0.33349946f, 0.15164171f, 0.36265787f, -0.03624459f, 0.23417178f, 0.10146458f, 
    -0.17484963f, 0.18934108f, 0.01591053f, 0.12283049f, 0.06959587f, 0.13135841f, 0.11612964f, -0.06179798f, 
    0.05520460f, 0.10319921f, 0.05677802f, 0.02705129f, -0.19777432f, 0.08065017f, -0.06493467f, 0.23597807f, 
    -0.08340536f, -0.08469304f, -0.05852472f, 0.03651048f, 0.06276774f, -0.12281960f, -0.02132475f, 0.00025243f, 
    -0.08800109f, -0.03175639f, -0.00968251f, 0.06680337f, -0.18307011f, -0.09767286f, 0.02873282f, -0.09802791f, 
    -0.62126690f, 0.09136931f, -0.48141155f, 0.17208163f, -0.01282212f, 0.16094045f, 0.05893924f, 0.11587049f, 
    -0.18018116f, -0.02813344f, 0.02659078f, -0.14992166f, 0.04971012f, 0.24790283f, 0.05789834f, 0.08849443f, 
    -0.05687352f, 0.08335797f, 0.07449741f, 0.03924898f, -0.58120829f, -0.20563295f, -0.13129875f, 0.12059313f, 
    -0.39179417f, -0.06262684f, 0.17995533f, -0.10767999f, 0.19365148f, -0.02194418f, -0.24393474f, -0.07749341f, 
    0.00594363f, -0.01175538f, 0.12324896f, 0.05218844f, -0.04060996f, 0.10135666f, -0.06083600f, 0.00664016f, 
    0.34432793f, 0.01376902f, 0.31940109f, -0.11534502f, 0.14034748f, 0.13967028f, 0.08163392f, -0.14966378f, 
    0.06911919f, -0.10250758f, -0.06066489f, 0.07514608f, -0.00338115f, 0.10816575f, 0.00250553f, -0.10795174f, 
    0.00281649f, -0.07498859f, -0.16887090f, 0.06361031f, -0.16106699f, -0.23048355f, -0.08297495f, 0.17039357f, 
    -0.01071301f, 0.09413549f, -0.03275910f, 0.09360393f, -0.03562236f, 0.01416110f, 0.05699188f, 0.09971941f, 
    -0.00668840f, 0.06941473f, 0.06165243f, 0.09640127f, 0.06759305f, 0.12381606f, 0.03830606f, -0.06481903f, 
    0.10491425f, -0.01976411f, 0.16511132f, -0.08611941f, 0.06061411f, 0.06332727f, 0.07195113f, 0.12879518f, 
    0.03531966f, -0.03457337f, 0.01190531f, 0.03180884f, 0.06073949f, 0.07188874f, 0.06703449f, 0.05452108f, 
    -0.00632592f, -0.11774045f, 0.04600914f, -0.16412023f, 0.03861178f, 0.02493611f, 0.10059004f, -0.09587137f, 
    0.04721446f, 0.08919209f, 0.01825247f, 0.00533138f, 0.03304758f, 0.03856836f, -0.07950906f, 0.08591113f, 
    -0.08439855f, 0.04266582f, -0.00797234f, -0.12700532f, 0.07912733f, 0.08378435f, 0.13974577f, -0.12344490f, 
    0.10415699f, -0.28038120f, 0.00268105f, -0.21648237f, 0.07489061f, 0.03748763f, -0.05067485f, -0.11674593f, 
    0.00510801f, 0.01321117f, 0.05061447f, 0.00835220f, -0.01257697f, 0.03079282f, 0.00821113f, 0.02745666f, 
    0.07480555f, 0.02863914f, 0.00309242f, 0.03071070f, 0.20322357f, -0.10200625f, 0.11193186f, -0.16029429f, 
    -0.07176422f, 0.04677247f, 0.04333059f, -0.04052985f, 0.17016162f, -0.00494614f, -0.01375597f, 0.02617319f, 
    -0.00925450f, -0.07768963f, -0.12463373f, 0.08886248f, 0.05121412f, -0.03742216f, -0.07786491f, -0.00963836f, 
    -0.10662718f, -0.17382346f, -0.10034813f, 0.04421362f, -0.05167032f, 0.03857919f, 0.04379462f, 0.08555437f, 
    -0.01453076f, 0.02485087f, 0.02937713f, 0.06209103f, 0.05446119f, 0.02247040f, 0.00242657f, 0.09441022f, 
    0.06792855f, 0.07438208f, 0.00080541f, 0.00955256f, -0.00160810f, -0.24577475f, -0.12664838f, 0.12141534f, 
    0.14990942f, 0.09116162f, -0.04219832f, -0.07691622f, -0.00442814f, -0.10495101f, -0.03407263f, 0.01252719f, 
    -0.04094314f, -0.10366129f, -0.02826859f, -0.03815287f, -0.09471696f, -0.00425469f, -0.12397366f, -0.20655335f, 
    0.05632843f, -0.09115904f, 0.16567685f, -0.11679728f, 0.04046217f, 0.04023663f, -0.06388144f, -0.05956394f, 
    0.13197802f, 0.02694158f, 0.07103106f, -0.03632866f, -0.04467882f, 0.00498442f, -0.07776978f, 0.01203736f, 
    -0.02428625f, -0.02851534f, 0.07047202f, -0.07097208f, -0.09969744f, -0.08182420f, -0.22763726f, 0.18225048f, 
    -0.16538256f, -0.03619104f, -0.10459791f, -0.08305327f, -0.16104399f, -0.01042851f, 0.08369407f, 0.02198375f, 
    0.01271862f, -0.04755942f, -0.04454702f, 0.02487713f, -0.05497860f, 0.00998601f, -0.04992232f, 0.00568402f, 
    0.00548445f, -0.42751420f, 0.31382558f, -0.14253603f, 0.10395787f, 0.06373805f, 0.07804924f, 0.08036071f, 
    0.04108291f, -0.03159089f, -0.02679279f, 0.06032869f, 0.07451453f, 0.05588503f, 0.03933859f, -0.04779663f, 
    0.08861808f, 0.05979339f, -0.04776249f, -0.03273832f, -0.31906578f, -0.02002884f, -0.24784231f, 0.06121860f, 
    -0.27407482f, 0.12881559f, 0.05069342f, 0.04841507f, -0.08702177f, 0.12816644f, -0.10556957f, -0.07338502f, 
    0.06846929f, 0.04015058f, -0.07305712f, -0.03611699f, -0.03632763f, -0.04483793f, -0.03583474f, 0.02388234f, 
    -0.14789632f, 0.23628034f, -0.16815947f, 0.13439555f, -0.03190106f, 0.06900565f, 0.01656717f, 0.20301181f, 
    0.06819765f, -0.08795328f, -0.02287053f, -0.08712994f, -0.08200479f, 0.06891723f, -0.01545099f, 0.07861132f, 
    -0.10932470f, -0.00949569f, 0.02388329f, -0.05765809f, -0.21303733f, -0.20995317f, 0.01489415f, -0.10367929f, 
    0.08043516f, 0.02657016f, 0.05514472f, 0.09039256f, 0.00024744f, 0.06328309f, -0.11848120f, 0.08120702f, 
    -0.09892660f, 0.06168908f, 0.11018511f, 0.10978471f, 0.14128187f, 0.04730848f, 0.03004009f, -0.00722311f, 
    0.33848169f, -0.06995689f, 0.30813372f, 0.19401042f, -0.06770698f, -0.02032633f, -0.27354234f, -0.15691675f, 
    0.04759014f, -0.31497627f, -0.06059048f, 0.05024116f, 0.03866113f, 0.02773755f, 0.03036587f, 0.01326632f, 
    -0.02573031f, 0.06000420f, 0.22900884f, -0.04004209f, -0.53270859f, -0.07959856f, -0.30753419f, 0.28791237f, 
    -0.15472758f, 0.06974864f, 0.07827148f, 0.00465870f, 0.14041348f, 0.05973788f, -0.15006016f, -0.05196615f, 
    -0.05708551f, 0.12823033f, -0.05571857f, 0.04776205f, 0.01837628f, 0.15344338f, -0.01067330f, -0.01260297f, 
    0.39966077f, -0.14131249f, 0.24692664f, -0.01139868f, -0.08622570f, -0.00438978f, -0.06292196f, 0.01607013f, 
    -0.04586897f, -0.00241233f, -0.03199195f, 0.03229087f, -0.01175843f, -0.08295169f, -0.01778403f, -0.08242835f, 
    0.08888274f, 0.00962888f, 0.06517489f, 0.02338872f, 0.39494854f, -0.04032379f, 0.30105531f, -0.13203493f, 
    0.07398038f, 0.06430818f, 0.06271384f, -0.11964575f, 0.14215873f, -0.00654226f, -0.07144326f, 0.01272362f, 
    -0.04902931f, 0.03866953f, -0.08803791f, 0.04006740f, 0.05448382f, 0.04608162f, -0.13950385f, 0.09507113f, 
    -0.08594267f, -0.46535814f, -0.05591085f, -0.00214494f, 0.31956160f, -0.12203115f, -0.19499977f, 0.00218029f, 
    0.03461848f, 0.06972971f, 0.06884047f, -0.04745527f, 0.07512560f, -0.06002543f, -0.04043401f, 0.06547298f, 
    0.07507918f, 0.04759852f, 0.10281093f, 0.04156188f, 0.17788342f, -0.43439528f, 0.48335347f, -0.36522090f, 
    0.24212058f, 0.13093819f, 0.15371300f, 0.07006543f, 0.09858260f, -0.02432076f, 0.07612375f, -0.07158232f, 
    0.07265462f, 0.06657951f, 0.10384399f, -0.02977720f, 0.12447216f, 0.00048856f, 0.02208689f, -0.00442326f, 
    0.07877526f, -0.01389473f, 0.03013096f, -0.02692843f, 0.05558690f, -0.00803463f, 0.12516147f, 0.06913234f, 
    0.07051375f, 0.02437658f, -0.11461297f, 0.02014746f, 0.02085456f, -0.02296137f, -0.06619073f, 0.05701813f, 
    0.07349370f, -0.04705883f, -0.10982608f, -0.07437993f, -0.41639924f, -0.00586421f, -0.51406592f, 0.42945951f, 
    0.09631690f, 0.05616998f, 0.14677788f, -0.02213213f, 0.22636962f, 0.04539663f, -0.08053306f, -0.06358289f, 
    -0.02605596f, 0.05972904f, 0.08121103f, 0.02598204f, 0.00739460f, 0.13802454f, -0.04260914f, 0.06160654f, 
    -0.31111866f, -0.13339603f, -0.26529875f, 0.00701464f, -0.15562686f, 0.04366523f, -0.00240994f, 0.05654224f, 
    -0.01418511f, 0.13782050f, -0.07399927f, -0.04141973f, 0.08697799f, 0.04777009f, -0.08265039f, -0.03995688f, 
    -0.07448582f, -0.09444428f, -0.03986257f, -0.05744050f, 0.27026159f, -0.43604442f, -0.01745785f, 0.44901836f, 
    0.15331809f, -0.03427768f, 0.08413952f, -0.04194281f, 0.23138580f, -0.13510965f, -0.16242288f, -0.06638329f, 
    -0.00226993f, 0.07791395f, -0.04043386f, -0.08215706f, -0.02811297f, 0.19529316f, 0.11606326f, 0.01941771f, 
    -0.21042830f, 0.00851019f, -0.10917594f, -0.03844912f, -0.07923400f, 0.02161323f, 0.05920810f, 0.10780501f, 
    0.07028954f, 0.01752372f, 0.02145960f, -0.05729634f, 0.07187095f, -0.04775061f, 0.07467987f, 0.04652701f, 
    -0.04435971f, -0.12006233f, -0.11307174f, -0.12998928f, 0.26659170f, 0.18577923f, 0.29839122f, 0.15922381f, 
    -0.20520444f, -0.15161023f, -0.03488282f, -0.02283156f, -0.07147728f, -0.06551597f, -0.04092081f, -0.06432217f, 
    0.02035970f, -0.03165828f, -0.02162449f, 0.03838801f, 0.03608596f, 0.05087070f, -0.02532092f, 0.10160620f, 
    -0.23773211f, 0.05810494f, -0.07279126f, 0.26603246f, 0.13733044f, -0.07332541f, 0.04531983f, -0.04249061f, 
    -0.04130452f, 0.10202625f, -0.08949666f, 0.04729908f, -0.10408667f, -0.02003537f, -0.08715156f, 0.08722450f, 
    -0.07791948f, -0.03147045f, -0.02340755f, -0.06473190f, 0.16060933f, -0.00112039f, 0.23751906f, -0.13119769f, 
    0.07043503f, 0.02799037f, -0.01146668f, -0.00620006f, 0.10006394f, 0.11998843f, -0.02457072f, 0.00258836f, 
    -0.00960258f, 0.01806316f, -0.06292567f, 0.09164406f, 0.08234440f, -0.03808609f, -0.04147765f, 0.08803433f, 
    -0.59479576f, -0.29553494f, 0.10947756f, 0.23341791f, -0.08498828f, -0.06774271f, 0.02563748f, 0.09709410f, 
    0.05037877f, -0.02481125f, -0.06785572f, 0.05331357f, 0.09060527f, 0.02224589f, 0.02718302f, 0.22501366f, 
    0.05555933f, 0.23451783f, 0.09459000f, -0.10393110f, 0.05474343f, -0.30297074f, 0.01480021f, -0.20122445f, 
    -0.21674415f, 0.06045274f, 0.13542806f, -0.16650289f, 0.05141006f, -0.07620490f, -0.03517109f, 0.00277088f, 
    0.02634246f, 0.04020022f, 0.00367041f, -0.01464914f, 0.04890367f, 0.03167006f, 0.08131455f, 0.02409074f, 
    -0.00629923f, -0.27778131f, -0.33421472f, -0.31379026f, 0.04552998f, -0.09117445f, -0.08128616f, 0.06754001f, 
    0.00925866f, -0.06043480f, 0.02105330f, 0.03766372f, 0.03961141f, -0.02255899f, -0.00917362f, 0.10207464f, 
    -0.02979255f, -0.00031637f, 0.05217043f, 0.02239206f, -0.16002272f, -0.10661080f, -0.19449055f, 0.09555687f, 
    0.30111358f, 0.07732766f, 0.13954036f, 0.10237291f, -0.05462722f, 0.17041808f, 0.01351010f, -0.00749315f, 
    -0.00117000f, -0.02710071f, -0.15065402f, -0.03977743f, 0.08798294f, 0.02776650f, 0.07771021f, 0.00810219f, 
    0.02215922f, -0.22055690f, -0.13522395f, -0.01835444f, -0.11588833f, -0.04911862f, -0.30920777f, -0.07826422f, 
    -0.19448805f, -0.07966121f, 0.02833833f, 0.02852153f, -0.03920706f, -0.03429455f, -0.09168182f, 0.05070701f, 
    -0.00685242f, 0.00165657f, -0.03352784f, -0.16681769f, -0.20648402f, -0.05213930f, -0.02204227f, 0.22733118f, 
    -0.15763497f, 0.11296288f, -0.00431354f, -0.00914138f, 0.08334073f, 0.04668183f, -0.08994640f, -0.15458401f, 
    -0.11359739f, 0.08785540f, 0.05000902f, 0.02328117f, -0.04025804f, 0.11026559f, 0.01918195f, -0.08191998f, 
    -0.18687426f, 0.07908630f, -0.07646850f, 0.16058283f, 0.00254618f, 0.00373726f, 0.02633155f, 0.03464220f, 
    -0.22142930f, 0.01821235f, -0.05782460f, 0.14452608f, -0.00849770f, 0.01175805f, -0.12073421f, -0.11006357f, 
    -0.14047483f, 0.00651220f, -0.12787910f, -0.10886551f, 0.12683085f, -0.05061444f, 0.07126797f, 0.05701166f, 
    0.18070781f, 0.10948543f, 0.15992460f, -0.00292630f, 0.07167052f, -0.10041235f, -0.00015943f, -0.11648620f, 
    0.00371071f, 0.00711542f, -0.05892147f, -0.04834542f, -0.01506781f, -0.02056768f, -0.04265504f, -0.03541669f, 
    -0.15947114f, -0.05449173f, -0.10695172f, 0.10018210f, -0.21574838f, 0.00315913f, -0.07989246f, -0.03039682f, 
    -0.04162296f, 0.03350518f, -0.05603167f, -0.09319384f, -0.03933107f, -0.11421389f, -0.05945917f, -0.02075586f, 
    -0.09442390f, -0.08030982f, -0.07048968f, -0.03138898f, -0.07027978f, -0.27466619f, -0.10558814f, 0.06798290f, 
    0.02376530f, -0.16582771f, -0.21805586f, 0.03054393f, -0.03472729f, -0.14080167f, -0.02726265f, 0.01161505f, 
    -0.00723424f, -0.04412770f, -0.01028760f, 0.01412776f, -0.00459263f, 0.05777575f, 0.06901030f, -0.11948050f, 
    0.22034608f, -0.15294084f, 0.13570295f, -0.05788306f, 0.06100537f, -0.01500690f, 0.14105654f, -0.07938690f, 
    0.12783608f, 0.03499673f, -0.06954118f, 0.10388812f, 0.00982324f, -0.04503308f, -0.02825984f, -0.02401185f, 
    0.08348712f, 0.06826071f, -0.09058991f, -0.14363939f, -0.27856535f, -0.12176138f, -0.10908614f, 0.23886712f, 
    -0.17700347f, -0.00246648f, -0.04346378f, 0.02444983f, -0.00885618f, 0.12740436f, -0.08321009f, -0.08929375f, 
    0.03907281f, -0.10743012f, -0.05051677f, -0.01132599f, -0.09596163f, -0.10777848f, -0.03533090f, -0.13632402f, 
    0.14436890f, 0.00808733f, 0.14042661f, 0.19416429f, -0.27442831f, -0.13810897f, -0.10018709f, -0.04809345f, 
    -0.01148520f, 0.01510949f, -0.00787044f, -0.11939602f, 0.04513352f, -0.07411028f, -0.02969755f, 0.02343420f, 
    0.09252775f, 0.06003526f, 0.06580540f, -0.02972109f, 0.23880853f, -0.00377783f, 0.20441031f, -0.00523736f, 
    -0.05952440f, -0.07408946f, 0.06108072f, -0.09218324f, 0.06155799f, -0.08706369f, -0.08846576f, -0.02613601f, 
    -0.02519888f, -0.07605598f, -0.08137981f, 0.07508714f, 0.00224311f, -0.02084277f, -0.03488952f, -0.00707333f, 
    -0.11405717f, -0.36394554f, -0.41071281f, -0.22368795f, 0.05485800f, -0.15535994f, -0.15555115f, 0.05413723f, 
    0.01389796f, -0.10800764f, 0.04504721f, 0.08151785f, 0.05006835f, -0.02756443f, -0.00511482f, 0.05851695f, 
    -0.01175061f, -0.08388961f, 0.03925122f, 0.02002273f, 0.27982062f, 0.21376042f, 0.35701424f, -0.14546758f, 
    -0.06148403f, 0.05816954f, -0.13275929f, 0.17238221f, 0.08712782f, 0.11687689f, 0.00307319f, -0.00159648f, 
    -0.02858912f, -0.03905425f, -0.08511768f, 0.05423184f, 0.10809725f, 0.01549269f, -0.06309429f, 0.11144502f, 
    0.04447033f, -0.19606741f, -0.15726399f, -0.05102265f, 0.01546411f, -0.12674525f, -0.13795646f, -0.00829006f, 
    -0.07050264f, -0.07428062f, 0.00643885f, 0.04097247f, 0.05413407f, -0.04594988f, -0.03092517f, 0.06365214f, 
    -0.05539297f, -0.01928028f, 0.05184270f, -0.00465809f, 0.19875950f, -0.12467530f, 0.10053165f, 0.24313651f, 
    0.15633982f, 0.06045774f, 0.08452564f, -0.09716446f, 0.12945163f, 0.10118184f, -0.03913886f, 0.02949058f, 
    -0.00175454f, 0.08439136f, 0.06980142f, -0.03287041f, 0.03657352f, 0.02503996f, 0.05476046f, -0.02890001f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.15748477f, 0.08221135f, 0.01322710f, -0.08300223f, -0.02287727f, 0.05148149f, 0.00568102f, -0.06380976f, 
    0.07053936f, 0.05783093f, -0.00419791f, 0.02407620f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 5120);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
