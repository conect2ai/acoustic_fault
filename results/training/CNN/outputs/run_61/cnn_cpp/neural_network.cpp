#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.10580147f, -0.68297857f, -0.44098440f, 0.41085881f, 0.50584072f, -0.08961046f, 0.65307677f, 0.57923919f, 
    0.29242414f, 0.51658541f, -0.00076939f, 0.04356497f, -0.14939059f, 0.09834365f, -0.26869071f, -0.36766398f, 
    0.01259247f, -0.21783207f, 0.08265255f, -0.14611736f, 0.26332229f, 0.04887190f, -0.01529209f, -0.08112272f, 
    0.16729423f, -0.83753031f, -0.61165982f, 0.10221809f, 0.68239504f, -0.45995620f, 0.31156838f, 0.67305022f, 
    0.21395005f, -0.41958034f, -0.41761488f, -0.31317827f, 0.04089467f, -0.32375816f, 0.04301625f, -0.21612555f, 
    -0.42374763f, 0.04039622f, -0.11495650f, -0.11937265f, -0.46081471f, 0.29678088f, -0.08995437f, 0.06788545f, 
    -0.09088545f, -0.20628658f, -0.51550835f, -0.04776179f, 0.03094137f, 0.72053289f, 0.38035220f, -0.92656869f, 
    -0.81257439f, -0.75486887f, 0.00219658f, -0.11544372f, 0.37175485f, 0.21625872f, 0.34229705f, -0.22532324f, 
    -0.30692056f, 0.14395301f, -0.09549899f, -0.19862446f, -0.16549943f, -0.07727908f, 0.01236191f, 0.02470360f, 
    0.14414951f, -0.17525263f, -0.06068215f, -1.10056090f, 1.03654575f, 0.75934279f, -0.68768746f, -0.05119767f, 
    -0.04193098f, 0.45537442f, -0.26861668f, 0.29212224f, -0.21995538f, -0.19631013f, 0.00327780f, -0.15243550f, 
    -0.18286958f, 0.15026827f, -0.05294044f, -0.02188727f, -0.09553126f, -0.29808289f, -0.30244488f, 0.23685645f, 
    0.20688398f, 0.09295505f, 0.16503815f, 0.07937319f, -0.03363709f, 0.87046260f, 0.21047363f, 0.17799826f, 
    0.54638141f, 0.97648656f, -0.74928606f, -0.88424724f, -0.10998190f, -0.24860273f, 0.43196687f, -0.19158441f, 
    -0.00975564f, 0.00669542f, -0.17627078f, 0.11262795f, -0.01672377f, 0.14857930f, -0.16540486f, 0.03550489f, 
    0.07207601f, -0.10106137f, 0.10132090f, -0.00360895f, -0.09552344f, -0.65168697f, -0.39707533f, -0.47041449f, 
    -0.26319295f, -0.17419125f, 0.61496717f, -0.29930660f, -0.31735933f, 0.46718770f, -0.26603335f, -0.30472255f, 
    0.03505284f, 0.58967894f, 0.42754707f, -0.32150212f, -0.09696515f, -0.15530469f, -0.15904811f, -0.27966702f, 
    0.02658034f, -0.20858310f, 0.04619493f, -0.01897215f, -0.22858477f, -0.30732089f, -1.02113998f, 0.64822698f, 
    0.05739064f, -0.56748384f, -0.70899200f, 0.26895833f, 0.22290398f, -0.43390313f, -0.05106612f, 0.39795068f, 
    -0.40325090f, -0.12845349f, 0.23169658f, 0.23081146f, 0.49744362f, 0.08956913f, -0.01287114f, -0.21455094f, 
    0.29335696f, 0.39042732f, 0.03252112f, -0.08051623f, 0.12750390f, 0.23205149f, 0.16536851f, -0.12316345f, 
    -0.76887155f, 0.89338452f, 0.75375742f, -0.01758346f, 0.22297044f, 0.51820862f, -0.10453155f, 0.17142889f, 
    -0.13967547f, 0.06542850f, -0.18140049f, 0.18980083f, 0.22384733f, -0.00491110f, 0.07771848f, 0.18549643f, 
    -0.23122321f, -0.03144068f, -0.00024213f, -0.26945335f, 0.10961355f, -0.28733352f, 0.06522057f, -0.10768129f, 
    -0.35336691f, -0.86095834f, -0.62028199f, -0.00081364f, -0.30210611f, -0.52997679f, -0.37115788f, -0.30522928f, 
    -0.39061144f, 0.20878653f, -0.11852072f, 0.27706099f, 0.33424321f, -0.00359459f, -0.10192676f, 0.29533914f, 
    -0.24877743f, -0.08398047f, -0.05417466f, -0.33139944f, -0.07346303f, -0.14268380f, 0.18665856f, -0.12554787f, 
    -0.06971692f, -0.42604801f, -0.30424258f, -0.32287690f, -0.54752076f, -0.53238916f, 0.11481783f, -0.52807546f, 
    -0.15604717f, 0.04159485f, 0.20580153f, 0.22168854f, -0.21703070f, 0.14529753f, -0.15346934f, -0.08387434f, 
    -0.01877685f, 0.08044256f, -0.08023359f, 0.15781516f, -0.02216748f, -0.07328756f, 0.22914180f, 0.36553332f, 
    0.60902798f, 0.23091614f, 0.10642321f, 0.44891632f, -0.19577619f, 0.47258985f, 0.58436346f, 0.21732733f, 
    0.19311574f, 0.66601050f, 0.24285196f, 0.53968149f, -0.08406676f, -0.18929836f, 0.08363672f, -0.09335670f, 
    0.19317022f, -0.14443897f, -0.28294247f, 0.06207041f, -0.10471364f, -0.35164124f, -0.03279876f, -0.10141759f, 
    0.00766900f, 0.37078488f, -0.17094581f, -0.04025982f, -0.51043409f, -0.68121225f, -0.92092818f, -0.07315491f, 
    0.21673086f, -0.38468531f, -0.01954730f, 0.23978163f, -0.02213478f, -0.59904402f, -0.22850335f, -0.05112647f, 
    -0.15829110f, -0.25229543f, 0.16860485f, -0.10209678f, 0.18486036f, 0.31176308f, 0.26337799f, 0.04805748f, 
    0.12481270f, -0.18494305f, -0.09531161f, 0.13051264f, -0.20731415f, 0.47663629f, 1.04307854f, 0.75798941f, 
    -0.56013465f, -0.72315925f, -0.37535685f, -0.42691433f, -0.28776237f, -0.43173280f, 0.24637532f, 0.11059682f, 
    -0.25490347f, -0.00217094f, -0.01056561f, -0.19477937f, -0.07923461f, 0.11319874f, -0.04035663f, -0.04254225f, 
    -0.09228464f, 0.09343225f, 0.23373491f, 0.32522270f, -0.15770680f, -0.07787059f, 0.27515844f, -0.19263883f, 
    -0.48149657f, 0.33817291f, -0.07306840f, -0.90085447f, -0.68664598f, -0.71477115f, -0.52985007f, 0.00366397f, 
    0.10814140f, 0.40283465f, 0.20143409f, 0.11019217f, 0.15182567f, -0.29197782f, -0.26994571f, 0.02888443f, 
    0.16062510f, -0.27083731f, 0.18578474f, 0.12390395f, 0.08789003f, 0.18235129f, 0.64094335f, 0.35576469f, 
    -0.21546188f, -0.87759054f, -0.31104150f, 0.48075813f, -0.10024725f, -0.27238020f, -0.46486795f, -0.72616565f, 
    -0.35214224f, 0.16096243f, -0.24294628f, 0.16636609f, -0.20579295f, -0.08328428f, -0.08290955f, -0.47920221f, 
    -0.37840110f, 0.05344301f, 0.17452189f, -0.17842171f, 0.13590173f, -0.05485742f, -0.22971283f, 0.00501551f, 
    0.48096105f, -0.86541784f, -0.81762516f, 0.20119374f, -0.76858765f, 0.56842148f, 0.87226379f, 0.00549120f, 
    -0.02790539f, -0.28615388f, 0.15273641f, 0.45477509f, -0.37331289f, 0.09828313f, -0.01523077f, -0.26697123f, 
    0.02968644f, -0.20168209f, -0.46559334f, 0.25898689f, 0.12704839f, 0.07722590f, 0.24382660f, 0.03464837f, 
    -0.16800912f, 0.41308865f, 0.28002831f, -0.20264173f, -0.38297266f, 0.38750461f, 0.09816005f, 0.06021984f, 
    0.04842401f, -0.12763362f, 0.28470165f, 0.42268717f, 0.18955737f, 0.22718188f, 0.36305735f, -0.07140259f, 
    -0.21682632f, 0.36235824f, 0.01904438f, 0.19920492f, 0.27063292f, 0.22547653f, -0.29239321f, 0.29667181f, 
    0.11815996f, -0.68966824f, -0.51125592f, -0.43826297f, -0.45441166f, -0.46722746f, 0.68461770f, 1.12734151f, 
    -0.29586738f, 0.22322662f, 0.75963974f, -0.01654361f, -0.12226644f, -0.15838172f, -0.34035927f, -0.03930159f, 
    -0.17758818f, 0.03533438f, -0.03220663f, 0.01058027f, -0.24756666f, -0.22034882f, -0.16896494f, -0.04516794f, 
    -0.05015440f, 0.10380125f, -0.41757110f, 0.23062102f, -0.66967922f, -0.16082816f, -0.13044503f, 0.35710964f, 
    -0.06263117f, 0.47867557f, 0.58860695f, 0.15766715f, -0.46268067f, -0.03053330f, 0.19387014f, -0.41968259f, 
    -0.70042974f, -0.25897947f, 0.11785248f, 0.27185324f, 0.34964532f, -0.10597997f, -0.10214529f, -0.15682156f, 
    -0.23909904f, -0.29372326f, 0.10632626f, 0.77067995f, 0.37978184f, 0.64874941f, 0.54681826f, 0.71181828f, 
    -0.24700886f, 0.16303633f, -0.39765471f, -0.54049575f, 0.15150528f, -0.15955172f, 0.56737703f, 0.12845477f, 
    0.27498507f, 0.22042321f, 0.32511708f, -0.01520265f, -0.18599398f, -0.09073155f, 0.04113308f, 0.19534664f, 
    -0.04129757f, 0.13679108f, 0.20447005f, -0.04432463f, -0.11591580f, -0.17018147f, 0.06365502f, -0.17893884f, 
    -0.42727402f, -0.48211947f, -0.77340925f, 0.09097663f, -0.06933445f, 0.05938463f, -0.27302247f, -0.27235112f, 
    -0.25037405f, -0.21784134f, 0.17009763f, 0.21514079f, -0.31302103f, -0.30072570f, -0.22161849f, 0.14885923f, 
    0.37765729f, 0.23635037f, 0.14187168f, 0.18270461f, 0.03106530f, 0.31373990f, -0.94612837f, -0.80628490f, 
    0.61928833f, 0.35242662f, 0.68185550f, 0.09945578f, -0.41610757f, 0.61302000f, -0.17685707f, -0.20609984f, 
    0.18726827f, -0.14125425f, 0.48078147f, -0.10049041f, 0.22410232f, 0.10480372f, 0.19045989f, 0.18117565f, 
    0.14393309f, -0.05574870f, -0.19209395f, -0.21762937f, -0.05571564f, -0.07929021f, 1.03895223f, 0.57722330f, 
    0.18844917f, -0.39072898f, 0.30460000f, 0.16101208f, 0.41969988f, 0.15697105f, 0.40570498f, 0.30513507f, 
    -0.19548389f, 0.02998372f, -0.27512062f, -0.13778655f, 0.16632760f, 0.26259908f, 0.32822827f, 0.00597533f, 
    -0.02875874f, 0.14775302f, -0.10887247f, 0.23395757f, 0.24720913f, -0.10489038f, 0.03420928f, 0.14969878f, 
    0.40796804f, 0.11866792f, -0.64215595f, -0.42852950f, -0.08458959f, -0.25867584f, -0.64979309f, -0.75677186f, 
    -0.11814111f, 0.22143634f, 0.51696795f, 0.17396463f, -0.13856398f, -0.25678378f, 0.37064445f, -0.27361685f, 
    0.44578061f, 0.11835060f, 0.10482702f, 0.22771092f, 0.07981806f, 0.19113608f, -0.07238800f, 0.31323773f, 
    1.06346428f, 0.57516658f, 0.67945546f, -0.23676710f, -0.03271369f, -0.03813186f, -0.41413027f, 0.06755731f, 
    0.41436738f, 0.26617536f, -0.07260835f, 0.12188473f, 0.09169575f, 0.23501621f, -0.31689227f, 0.11716814f, 
    0.09457918f, 0.01256764f, -0.27589062f, 0.07304417f, -0.39081764f, -0.06934286f, -0.14792296f, -0.27434519f, 
    -0.18505935f, 0.39592025f, -0.78640270f, -0.13884676f, -0.32532921f, 0.40899599f, 0.31441039f, -0.46627021f, 
    0.53068918f, 0.08899841f, 0.10493609f, -0.10972337f, -0.45413810f, -0.31828129f, -0.13419969f, -0.62195319f, 
    0.28719521f, 0.17934263f, 0.35436338f, 0.38332006f, -0.40920293f, 0.06816418f, -0.13538547f, 0.01841411f, 
    0.13905789f, 0.21343586f, 0.41056755f, 0.24465029f, 0.26431814f, 0.95491493f, 0.83359373f, 0.82892883f, 
    0.43952128f, -0.85354888f, 0.20763487f, -0.30398569f, -0.22199444f, 0.10258553f, -0.32800868f, 0.26847866f, 
    -0.60946864f, -0.06078520f, 0.02665005f, 0.15750805f, -0.06821392f, -0.28098142f, 0.14473899f, 0.13398562f, 
    -0.30279705f, -0.17025273f, 0.21795693f, -0.21385875f, 0.92216718f, 0.61446649f, 0.52411550f, 0.62103713f, 
    0.31072000f, -0.21423911f, 0.25182542f, -0.24417681f, -0.02175257f, -0.62710059f, -0.44814062f, 0.03694986f, 
    0.31123725f, 0.19451019f, 0.05609384f, 0.33261597f, -0.20757134f, 0.22193418f, 0.26847243f, 0.06155279f, 
    -0.17821003f, -0.18669926f, -0.07335626f, -0.11106919f, 0.70782804f, 0.51994050f, 0.34626135f, 0.53264683f, 
    0.58719987f, -0.07969262f, 0.26910564f, -0.31518677f, 0.20292793f, 0.09908362f, 0.19656260f, -0.05597195f, 
    -0.23992026f, -0.28470105f, -0.08822901f, -0.29325718f, -0.19718419f, 0.06649590f, 0.08738556f, 0.26445064f, 
    -0.05631916f, 0.46250188f, 0.44543439f, 0.12254153f, 0.31628036f, 0.23722404f, -0.58921164f, -0.68488467f, 
    -0.59615356f, 0.35645232f, 0.20717587f, -0.00359181f, -0.38299879f, 0.30062830f, -0.03834916f, 0.01549730f, 
    -0.35762230f, 0.30015260f, -0.03237125f, 0.00414659f, -0.19616514f, 0.31893867f, -0.33448738f, -0.59060919f, 
    -0.23516355f, 0.04744719f, 0.04083769f, 0.27392834f, 0.32909146f, -0.16106015f, 0.80152673f, 0.33176124f, 
    0.17596294f, 0.61572629f, 0.20838976f, 0.05410973f, 0.25786674f, -0.27242303f, -0.08149669f, 0.18673123f, 
    0.18615854f, 0.15179421f, 0.42745566f, 0.21794198f, -0.52121282f, -0.22531334f, -0.11463915f, 0.28299531f, 
    -0.22101769f, -0.36348009f, 0.01596387f, -0.41322181f, 0.15510197f, 0.25364783f, -0.16456962f, 0.66172975f, 
    0.26203591f, -0.75866222f, -0.94269204f, -0.53189057f, 0.59153980f, 0.27353877f, 0.62006706f, 0.50961876f, 
    0.26529235f, 0.14381607f, -0.14654870f, -0.26163024f, -0.22759630f, 0.05792442f, -0.06260113f, -0.19285709f, 
    -0.02643868f, 0.10752973f, 0.25510341f, 0.17986679f, -0.10022337f, -0.14744803f, -0.01571620f, -0.11640503f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.14861861f, 0.07688484f, 0.18033999f, -0.09854780f, -0.03121947f, -0.03121067f, -0.00998965f, 0.25739264f, 
    0.09553067f, 0.08076729f, -0.07420467f, 0.02342222f, 0.03171887f, 0.23014466f, -0.14014328f, 0.11651710f, 
    0.18013164f, 0.07439001f, -0.03352541f, 0.02204792f, -0.02531910f, -0.03920279f, 0.04537856f, 0.21563962f, 
    0.03290215f, 0.06963219f, 0.18961538f, 0.05780514f, 0.06524518f, 0.05434551f, 0.24073759f, 0.23877095f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.26980826f, 0.07882794f, 0.10941860f, -0.07308375f, 0.07109635f, 0.01011206f, 0.12354971f, -0.11179210f, 
    -0.09328388f, 0.06127413f, 0.15525812f, 0.03596120f, 0.27217424f, -0.05407023f, 0.11949427f, -0.06404894f, 
    0.21938302f, 0.09798426f, 0.03354213f, 0.12417822f, 0.04324909f, 0.15372884f, 0.17468786f, 0.28419200f, 
    0.02289249f, 0.24761805f, 0.29422262f, 0.22741941f, -0.01688107f, 0.16796650f, 0.05663029f, -0.00321816f, 
    0.09603078f, 0.05012891f, -0.07262388f, 0.03347505f, 0.41541642f, -0.01515824f, 0.24066444f, 0.10352179f, 
    0.03557095f, -0.11348134f, 0.03509627f, 0.00622566f, -0.09661552f, 0.07191776f, 0.06229133f, 0.09286735f, 
    0.05301484f, 0.30341044f, -0.02779748f, -0.18607682f, -0.05110147f, 0.15917532f, 0.00454321f, 0.13982177f, 
    -0.06853931f, -0.08456089f, 0.02890549f, 0.08692205f, -0.18515211f, -0.11346821f, -0.06158559f, 0.00583871f, 
    -0.03867323f, 0.15567130f, -0.06433906f, 0.16670117f, 0.16475211f, 0.01306616f, -0.15925485f, 0.10703705f, 
    0.24901222f, -0.17744115f, 0.14823754f, -0.08055534f, 0.00399944f, -0.01795348f, 0.10383367f, 0.10283463f, 
    -0.08542327f, -0.16163252f, -0.11672346f, 0.05756310f, 0.10857320f, 0.06937978f, -0.04948042f, -0.04501440f, 
    0.01320827f, 0.10080352f, 0.03453415f, 0.14899836f, 0.13099548f, 0.05998095f, -0.02402480f, 0.14173794f, 
    -0.08764374f, -0.06744699f, -0.03166008f, -0.01694103f, 0.03882422f, 0.08112609f, 0.08975495f, 0.06636605f, 
    0.09198187f, 0.20949696f, 0.10467702f, -0.04745751f, 0.01499401f, -0.11382673f, -0.18126728f, -0.11797120f, 
    -0.15327480f, 0.20585671f, -0.06832346f, 0.08217279f, -0.06101207f, -0.03307598f, 0.00637808f, -0.07401815f, 
    -0.18338506f, -0.10280610f, 0.03503586f, -0.11452413f, -0.07143944f, 0.10281767f, 0.12449604f, -0.01589297f, 
    0.04370885f, 0.09951751f, 0.19394322f, 0.10826702f, -0.22165351f, -0.21968426f, -0.02438295f, 0.07191400f, 
    -0.10282459f, -0.09859901f, 0.17869760f, 0.06615236f, 0.02287035f, -0.00558271f, -0.00376191f, 0.06356787f, 
    -0.17348406f, 0.06113303f, 0.21454048f, -0.18129273f, 0.10345811f, 0.09779951f, 0.02871086f, 0.17932862f, 
    0.10347088f, -0.05409360f, 0.03375246f, 0.02197643f, 0.11759192f, 0.17516252f, 0.18836018f, 0.02036956f, 
    -0.02411419f, 0.08703801f, -0.08233482f, 0.05970946f, 0.07346221f, -0.10370941f, 0.07105207f, 0.08843552f, 
    0.01783986f, -0.01759531f, 0.07691387f, 0.34297132f, 0.15312994f, 0.16954720f, -0.09517040f, 0.20368613f, 
    0.08036557f, 0.01837065f, 0.29968587f, 0.22491373f, 0.02154607f, -0.41060013f, 0.03184900f, 0.17874084f, 
    -0.00589438f, -0.12829024f, 0.17471351f, 0.09542394f, 0.05520249f, 0.18212147f, 0.00175864f, -0.00688855f, 
    -0.11036373f, 0.02634999f, 0.15437137f, -0.01532560f, 0.20872964f, 0.03973682f, 0.03212220f, -0.13864794f, 
    -0.03222854f, 0.03572347f, -0.08148693f, -0.05772799f, -0.53639996f, -0.17405486f, -0.10738467f, 0.00353262f, 
    0.09303170f, 0.12560426f, 0.01835076f, -0.02690451f, 0.13305013f, 0.19135559f, 0.03479195f, 0.19292317f, 
    -0.07085455f, -0.25972971f, 0.03993209f, 0.09299248f, -0.05929564f, 0.01799571f, 0.12068883f, 0.06093793f, 
    -0.04827068f, 0.27520552f, -0.01668114f, 0.16365063f, -0.47819003f, 0.16044261f, 0.13352790f, -0.12058049f, 
    0.13414562f, 0.11422663f, -0.13622275f, -0.01718952f, -0.08917212f, 0.09174776f, 0.06914704f, -0.01944421f, 
    0.14768927f, -0.16572031f, 0.12143567f, -0.00898325f, 0.05623639f, -0.02698486f, 0.13101283f, -0.03143824f, 
    -0.03529219f, 0.02633834f, 0.16920094f, -0.02837027f, -0.26833388f, 0.29662639f, -0.14067604f, 0.10061080f, 
    0.05722707f, 0.09672120f, 0.16366343f, 0.08841521f, 0.17874266f, -0.05313258f, 0.06633355f, -0.05010905f, 
    -0.49449584f, 0.07015604f, -0.01291102f, 0.03904321f, 0.09296820f, 0.03402050f, -0.15068741f, 0.06826570f, 
    0.15450777f, 0.01595988f, 0.07891835f, -0.01492811f, -0.18899332f, -0.05690166f, 0.14347315f, 0.15146437f, 
    0.09732930f, 0.15357663f, 0.01272765f, 0.05783722f, -0.04492290f, 0.07649825f, -0.12534346f, -0.00316730f, 
    -0.22051254f, -0.09739117f, 0.14549159f, 0.20443751f, -0.07413501f, 0.24317479f, 0.21548526f, 0.08895970f, 
    0.11966895f, 0.16728312f, -0.02075311f, 0.05838355f, 0.36697429f, -0.09567966f, -0.10627020f, -0.01866419f, 
    0.10009035f, -0.08870600f, 0.08822814f, -0.12326328f, -0.08439046f, 0.07923479f, 0.12230832f, 0.05194400f, 
    -0.07011850f, 0.47585207f, -0.25918993f, -0.07190575f, 0.21331561f, -0.04615081f, 0.00800243f, 0.08288878f, 
    -0.01366322f, 0.19030261f, -0.01762218f, 0.09152322f, 0.13445191f, 0.03905629f, -0.08175471f, -0.05369735f, 
    -0.03405665f, 0.09273622f, 0.03680825f, 0.06195074f, 0.10811067f, 0.09585331f, -0.03469828f, 0.02580843f, 
    -0.39519787f, 0.17867172f, 0.04610388f, -0.26176870f, 0.12222382f, -0.13539428f, -0.15210357f, 0.04824032f, 
    0.03984645f, -0.11852056f, -0.01922729f, -0.05010180f, -0.06074662f, 0.14570554f, -0.20268139f, 0.09848753f, 
    -0.02187411f, -0.01172217f, -0.04646564f, 0.10662184f, 0.00238755f, 0.04741909f, 0.18402471f, 0.02178419f, 
    -0.18435949f, 0.10272720f, 0.06324431f, -0.11930182f, -0.06766435f, 0.07441973f, 0.01990019f, 0.08715296f, 
    0.03929809f, 0.28699324f, -0.12807064f, 0.12070727f, -0.38428321f, 0.01554570f, 0.04526179f, 0.17556013f, 
    -0.01290008f, 0.10495723f, 0.10944817f, 0.07511732f, 0.09856216f, 0.02202935f, 0.12525874f, 0.05812461f, 
    0.22689348f, -0.10131817f, -0.00184104f, -0.05992976f, -0.14600681f, 0.01678177f, -0.05619498f, -0.08976132f, 
    0.06131864f, 0.05432300f, -0.03156226f, 0.00638860f, 0.38593915f, 0.18497112f, 0.16209769f, 0.22545323f, 
    -0.14859281f, -0.07150868f, 0.13268086f, 0.17715830f, 0.05558860f, 0.01402252f, -0.15326996f, -0.01795996f, 
    0.46556491f, 0.22764876f, 0.04684638f, 0.17758822f, 0.10612118f, -0.03317494f, 0.08615239f, 0.05518863f, 
    -0.23442541f, -0.07317776f, 0.08736009f, -0.04438533f, -0.11076048f, -0.05568979f, 0.14335853f, -0.05992578f, 
    0.00793654f, 0.07454609f, -0.02371996f, 0.03197596f, -0.00645820f, 0.00769367f, 0.01214763f, -0.00654425f, 
    0.04562475f, 0.14833803f, -0.38359287f, -0.09441263f, 0.02230151f, 0.05940275f, -0.07652189f, 0.11413001f, 
    -0.08722304f, -0.00243025f, 0.08160286f, -0.09297320f, 0.26275852f, 0.22996007f, 0.00672370f, 0.12830791f, 
    -0.04532250f, -0.00485839f, 0.15873893f, 0.09897757f, -0.02912256f, -0.14388809f, -0.01512906f, -0.14268424f, 
    0.08244576f, 0.09960869f, 0.09967273f, 0.04610064f, 0.11130836f, -0.10136177f, 0.01635511f, 0.00512176f, 
    0.05806014f, -0.01365371f, 0.10906752f, 0.12389885f, -0.15428485f, -0.28736502f, -0.01051718f, 0.00661988f, 
    -0.00476183f, 0.03186496f, -0.10742393f, -0.06733902f, 0.07305096f, -0.07967047f, -0.00993706f, -0.09353409f, 
    0.37854341f, 0.18392858f, 0.10291388f, 0.09949797f, -0.00297207f, -0.03423398f, -0.03837179f, 0.04209861f, 
    -0.16788226f, -0.06983141f, 0.06582218f, 0.02507237f, 0.13728890f, 0.12046015f, 0.11245013f, 0.05062587f, 
    0.04904664f, -0.07512796f, -0.04812454f, -0.06256290f, 0.06289040f, -0.01212405f, -0.12893291f, 0.00491631f, 
    -0.37869748f, -0.02089623f, -0.10855545f, -0.13978627f, 0.07259931f, 0.03364928f, -0.16676262f, -0.07805247f, 
    0.13686407f, -0.12807460f, -0.06415671f, -0.03414305f, 0.24684851f, 0.23707119f, 0.12111540f, -0.15311730f, 
    0.01124740f, 0.09140263f, 0.00474241f, -0.01736343f, -0.02824117f, 0.05360054f, 0.05974432f, -0.01922499f, 
    -0.37013614f, 0.07247090f, -0.05558438f, 0.10453700f, 0.03760930f, -0.07181222f, -0.03566537f, 0.08098350f, 
    -0.08438484f, 0.01309850f, 0.04748946f, -0.11317505f, 0.46163070f, 0.18422009f, 0.12290466f, 0.10474902f, 
    0.04042254f, -0.01853076f, -0.01749219f, -0.07266695f, -0.07605664f, 0.05179759f, -0.04267050f, -0.05871028f, 
    0.15093289f, -0.06485564f, -0.14061868f, 0.04482200f, -0.10236384f, -0.07691821f, 0.05137702f, 0.04871478f, 
    0.03911296f, 0.13042197f, -0.03390034f, -0.16667160f, 0.32311001f, -0.17650598f, 0.12478100f, 0.23549519f, 
    -0.03104665f, 0.18193647f, -0.03980052f, 0.04009806f, -0.01300541f, 0.14940085f, -0.08880303f, 0.04110729f, 
    -0.04074425f, 0.00145743f, -0.08408768f, -0.03083789f, 0.00907883f, -0.13238302f, -0.09250749f, 0.03336332f, 
    0.12875967f, 0.15614878f, -0.04884348f, 0.13686882f, 0.28830978f, 0.36735797f, -0.19198884f, 0.00761694f, 
    -0.09969758f, 0.03001298f, 0.11278701f, -0.02978882f, 0.00971518f, -0.05956318f, 0.10631537f, -0.00944352f, 
    0.25957733f, 0.25998992f, 0.03570440f, -0.05258003f, -0.11230064f, -0.02635471f, 0.11183760f, -0.00348539f, 
    0.08020148f, 0.04138236f, 0.00529867f, 0.05233806f, -0.42284060f, -0.34472337f, -0.04648887f, -0.13574766f, 
    0.08837543f, 0.08829198f, 0.02870777f, -0.07351462f, -0.04819992f, -0.07721186f, -0.12457779f, 0.01442447f, 
    0.12922494f, 0.11952919f, 0.07073225f, 0.07995915f, 0.08720315f, -0.06634786f, -0.01631373f, -0.08177629f, 
    -0.03065175f, 0.08955278f, 0.11001799f, -0.04310716f, 0.24311724f, 0.06975823f, -0.02611375f, -0.00980933f, 
    0.07311971f, -0.04486634f, 0.10052915f, -0.04952095f, -0.04881369f, -0.00678267f, 0.03033714f, 0.04215680f, 
    -0.46215257f, -0.26995164f, -0.24391684f, -0.00534678f, -0.09254140f, 0.02119457f, 0.02795218f, -0.16895656f, 
    -0.04585276f, -0.00099120f, -0.04900778f, -0.03184988f, 0.10211490f, 0.24800032f, -0.01193941f, 0.00314714f, 
    0.04605205f, -0.04642088f, -0.03406317f, 0.02729850f, -0.06496259f, -0.01350722f, -0.03863348f, -0.02939963f, 
    -0.41294342f, -0.27719623f, -0.17995512f, 0.11151910f, 0.11600444f, -0.10464688f, 0.02425626f, -0.07442635f, 
    -0.08569408f, -0.04891843f, -0.05316167f, 0.04911140f, 0.13996747f, 0.18358161f, 0.23550873f, 0.05093736f, 
    -0.16639148f, 0.10124985f, -0.04699300f, 0.08013368f, 0.18819159f, 0.06193558f, 0.10150847f, 0.00426516f, 
    -0.19191107f, -0.24885663f, -0.19677313f, -0.00126479f, 0.06077640f, 0.01862658f, 0.06137185f, -0.00101355f, 
    -0.00648674f, -0.09167866f, 0.10538169f, -0.08652525f, -0.34436798f, -0.40168789f, -0.07954613f, -0.01750224f, 
    -0.00069498f, -0.08351240f, -0.01935894f, -0.04392254f, 0.09274578f, -0.13234857f, 0.03467129f, 0.04927147f, 
    -0.57206112f, -0.16037977f, -0.29637000f, -0.06544977f, -0.08501693f, 0.04090755f, -0.01810557f, -0.04815811f, 
    0.14120844f, 0.08780251f, 0.12998644f, 0.14014985f, 0.16334015f, 0.23167865f, -0.03381749f, 0.15403637f, 
    -0.16935861f, 0.03925817f, -0.00731096f, -0.00271768f, 0.01725291f, 0.06897967f, 0.04262555f, 0.09207807f, 
    -0.45516378f, -0.29787362f, -0.07892458f, -0.09203208f, 0.14106765f, -0.12787858f, 0.00945195f, -0.02662304f, 
    0.08549630f, -0.04555628f, -0.02891873f, -0.09610566f, 0.25178653f, 0.05134548f, 0.00968242f, -0.04425551f, 
    -0.12223640f, 0.13490449f, -0.02747844f, 0.06274933f, 0.03228406f, -0.01657091f, -0.01294451f, -0.07574032f, 
    0.37184530f, -0.27529764f, 0.08220273f, 0.12579034f, -0.15922527f, -0.01357876f, 0.17770047f, 0.06174060f, 
    0.18153387f, -0.10487469f, 0.19318834f, 0.09549548f, 0.19045375f, -0.28580004f, -0.00936434f, -0.27089760f, 
    -0.20718026f, -0.03250501f, 0.00160221f, 0.00030788f, 0.03220842f, 0.04096489f, -0.04636681f, 0.08066201f, 
    0.19764473f, 0.06074339f, -0.06357931f, -0.11073969f, 0.21489586f, 0.02267855f, 0.10152880f, -0.07835244f, 
    0.01356048f, 0.01504359f, 0.07506604f, -0.03224414f, -0.06393072f, 0.23418361f, -0.53673184f, -0.06315704f, 
    -0.03795684f, 0.01076575f, 0.03246159f, -0.03907131f, 0.06226497f, 0.09842534f, -0.13639824f, 0.01954432f, 
    0.00986394f, -0.01791192f, -0.02223101f, 0.23596072f, 0.21126796f, 0.12245425f, -0.02573494f, 0.00355082f, 
    0.05543853f, -0.00694224f, -0.04281478f, 0.10891406f, 0.32666349f, 0.42513791f, -0.13736022f, -0.06080151f, 
    -0.06823455f, -0.01360340f, 0.15214144f, -0.01551597f, -0.04079645f, 0.11513906f, -0.02547100f, 0.01024524f, 
    -0.19843534f, 0.13295320f, -0.18103361f, 0.29436952f, 0.02523400f, 0.10634010f, -0.00667394f, -0.06531631f, 
    -0.03075867f, 0.26264083f, 0.07725789f, -0.19771445f, -0.01811896f, -0.00216683f, 0.03441721f, -0.16650032f, 
    0.04342690f, 0.01578319f, -0.01454845f, -0.02046016f, 0.00671685f, -0.00878123f, 0.00825448f, -0.13471264f, 
    0.54668474f, 0.36150149f, 0.03505792f, -0.06859306f, -0.00864076f, 0.01491130f, -0.03510362f, 0.04522215f, 
    0.09440618f, -0.05214339f, 0.03643395f, 0.07998141f, 0.19084865f, 0.15726408f, 0.22179542f, 0.13753225f, 
    0.07147116f, -0.08624694f, -0.05416453f, -0.13999349f, 0.13498971f, 0.05700763f, 0.08457485f, 0.05634690f, 
    0.12681848f, -0.10706088f, -0.09075124f, 0.22160226f, 0.04453583f, -0.14575796f, -0.00059401f, 0.11502665f, 
    -0.03849375f, -0.02170260f, -0.13424575f, 0.10019785f, -0.15168042f, 0.13848165f, -0.03516463f, 0.41022235f, 
    -0.12984124f, 0.00741455f, -0.04303167f, -0.04321022f, 0.04248387f, -0.04671447f, 0.03158196f, -0.08436891f, 
    -0.14039643f, -0.27732044f, 0.19825014f, -0.31377581f, -0.04906606f, -0.02680107f, 0.11769678f, -0.01770005f, 
    0.06467311f, 0.04934414f, 0.05578222f, 0.07602660f, 0.17202054f, 0.13262749f, -0.04395452f, -0.05703735f, 
    0.08594182f, 0.07059037f, 0.06459635f, 0.00257551f, 0.02939469f, 0.03316464f, 0.09098242f, -0.06544460f, 
    0.16262123f, -0.20789592f, -0.10475526f, 0.01206470f, -0.10895086f, -0.05259923f, 0.25964129f, -0.03070573f, 
    -0.08579092f, 0.03276319f, -0.11683858f, -0.00352357f, 0.23579603f, 0.19648671f, 0.00286665f, 0.14512251f, 
    -0.04043450f, 0.10921662f, 0.02262445f, -0.06110059f, -0.00759521f, -0.20852751f, 0.01090789f, -0.02191089f, 
    0.01750708f, -0.09719073f, -0.14743675f, 0.07490405f, 0.04944756f, -0.04106078f, -0.11718306f, 0.19232821f, 
    0.06389165f, 0.04893921f, 0.05904667f, -0.02634726f, 0.01768041f, 0.01092062f, -0.05110243f, 0.24651988f, 
    -0.20255879f, -0.07963965f, 0.02451620f, 0.03205165f, -0.14887126f, -0.07306044f, 0.02430960f, 0.04055141f, 
    -0.35551068f, 0.04467382f, -0.05539889f, 0.08257762f, -0.11225590f, -0.01365877f, 0.03346422f, -0.01591626f, 
    0.08617090f, 0.01373610f, 0.04294295f, 0.05531471f, -0.09257870f, -0.01113538f, 0.19420034f, 0.22219451f, 
    -0.00243457f, -0.01503466f, 0.06268992f, -0.13001518f, 0.14117657f, 0.09530141f, -0.09121585f, -0.02077765f, 
    -0.09113290f, 0.07713073f, 0.09206515f, -0.07091664f, -0.02842922f, -0.05888446f, -0.07030217f, 0.05854164f, 
    0.04646941f, 0.04002163f, -0.00640284f, -0.03041810f, 0.19368027f, -0.30076656f, 0.05752122f, -0.19230728f, 
    -0.04158948f, -0.07602340f, -0.03159407f, 0.16848782f, -0.05746551f, 0.02564150f, -0.00664052f, -0.08483589f, 
    -0.16705662f, -0.17419308f, 0.10210301f, 0.13051723f, 0.08358386f, -0.05973958f, 0.11529498f, -0.03684125f, 
    0.00415029f, -0.07416408f, -0.03702387f, -0.02016547f, 0.30568644f, -0.03815096f, -0.31653997f, 0.11538282f, 
    -0.00331795f, 0.02545880f, -0.03013578f, 0.03841400f, 0.18269801f, 0.02089432f, -0.00137494f, 0.02878136f, 
    -0.34966141f, -0.02454960f, -0.09326853f, 0.23236424f, 0.13118720f, -0.01186188f, -0.04731688f, -0.09893243f, 
    -0.17582257f, -0.01923384f, 0.01609754f, 0.01537285f, -0.51265144f, 0.01674066f, 0.00143341f, -0.04174780f, 
    -0.04997912f, -0.08727790f, 0.02831372f, 0.08259246f, -0.09427088f, -0.03722709f, -0.13060041f, 0.11339010f, 
    0.50207293f, -0.33807611f, 0.12061451f, -0.16740955f, -0.05310004f, 0.15773796f, 0.00220311f, 0.07929697f, 
    0.11864208f, -0.10202539f, 0.27104083f, 0.03061641f, -0.02921460f, 0.09006618f, 0.08378172f, 0.01507869f, 
    -0.00080551f, -0.04872183f, -0.04796623f, -0.04129893f, -0.03918188f, -0.01391855f, 0.17703448f, -0.10308149f, 
    0.17476308f, 0.08645169f, 0.10536161f, 0.11522978f, -0.02807133f, 0.14288233f, 0.12698692f, 0.07078250f, 
    0.17444038f, 0.11503354f, 0.26520064f, 0.12351386f, 0.22728150f, -0.10954586f, -0.16214484f, -0.06413808f, 
    -0.00262220f, -0.18953417f, 0.03923893f, 0.01268313f, -0.04476589f, -0.08864924f, -0.10968231f, 0.09743983f, 
    0.23891042f, -0.05147263f, 0.13807191f, 0.03055796f, 0.04529819f, 0.05665275f, -0.01559340f, 0.01098352f, 
    -0.01414244f, -0.10996845f, 0.01703713f, 0.04938647f, -0.07596964f, -0.20459816f, -0.06422982f, 0.26957193f, 
    0.05823562f, 0.08648692f, -0.07187844f, -0.08656812f, 0.09697237f, -0.00594763f, 0.00620891f, 0.02148179f, 
    -0.16771664f, 0.23040485f, -0.06494398f, -0.09277408f, 0.09640385f, 0.03084372f, -0.21225809f, 0.17228685f, 
    0.03210182f, -0.04279481f, -0.17871165f, -0.07863668f, -0.26521876f, 0.18831067f, 0.03304893f, 0.19093886f, 
    0.09174358f, -0.18627991f, 0.09415928f, 0.10962941f, -0.08612157f, -0.15193763f, -0.20800444f, -0.23738542f, 
    0.17347451f, -0.08763601f, 0.08911678f, -0.10861512f, -0.00533471f, -0.20842227f, 0.02655851f, 0.22843155f, 
    -0.02273100f, 0.02977951f, 0.02928757f, 0.17468239f, -0.56538653f, -0.01680291f, 0.36455268f, 0.17161205f, 
    0.03914699f, 0.03907758f, -0.02989583f, 0.08460977f, 0.14866182f, -0.02348760f, 0.06739182f, -0.09513122f, 
    -0.34960341f, -0.27731186f, 0.03414926f, 0.04515103f, -0.05232016f, -0.11939988f, -0.05163126f, 0.09974650f, 
    0.15691343f, 0.09764243f, 0.05284774f, 0.02573285f, -0.19839969f, -0.35964438f, 0.06096754f, -0.06882709f, 
    0.03338170f, -0.04477479f, 0.08364693f, -0.05705132f, -0.13861232f, -0.09969521f, 0.19909444f, -0.09843203f, 
    -0.11211393f, -0.13458246f, -0.03054512f, 0.00487926f, -0.14118659f, -0.06080358f, 0.01983442f, -0.07855108f, 
    0.09086598f, 0.09051212f, 0.12453161f, 0.05606695f, -0.16784558f, 0.06177809f, 0.17570098f, 0.26926130f, 
    0.02861357f, -0.07780800f, -0.08070121f, -0.07466701f, -0.07154383f, -0.04099087f, 0.05290687f, 0.04287410f, 
    -0.22406991f, -0.04625827f, 0.02751240f, 0.03037661f, 0.18343033f, 0.02127832f, 0.18068975f, -0.04334065f, 
    -0.00325657f, -0.11792526f, 0.08693556f, -0.00409110f, -0.09585869f, 0.03583376f, 0.04168004f, 0.07132053f, 
    0.17171633f, -0.03139678f, 0.22713397f, -0.07241834f, 0.05703703f, -0.04193188f, 0.06889513f, -0.04890813f, 
    0.09616198f, 0.10588939f, 0.05025269f, 0.00811237f, -0.05282790f, 0.01663292f, -0.04901465f, -0.07152803f, 
    -0.04902684f, -0.10338204f, 0.01452202f, -0.10181464f, 0.24120201f, 0.02493176f, 0.06389431f, -0.31773302f, 
    0.10665484f, 0.08570047f, -0.19097671f, 0.00862352f, 0.10713364f, -0.01470459f, 0.08340536f, -0.12238067f, 
    0.16188930f, 0.15713456f, 0.07057221f, 0.26532382f, 0.11260196f, -0.05862490f, 0.04198905f, 0.05063557f, 
    -0.02251606f, 0.05470388f, 0.02979865f, 0.08799257f, 0.13138796f, -0.10090255f, -0.11175773f, 0.16521393f, 
    -0.05928743f, 0.04165829f, -0.04280535f, -0.03850373f, -0.02874507f, -0.02585381f, 0.04905850f, 0.19377577f, 
    -0.16318266f, 0.21232679f, 0.11951289f, -0.05053772f, -0.07668423f, -0.03837980f, -0.15144391f, -0.11024950f, 
    0.16044086f, -0.01617908f, -0.13828416f, -0.08212298f, -0.24810611f, 0.05986141f, -0.01689116f, -0.14923839f, 
    -0.02201037f, 0.13757509f, -0.04640964f, 0.05170641f, 0.10710807f, 0.03495936f, 0.03659370f, 0.16645925f, 
    0.08355249f, -0.10896550f, -0.15770400f, 0.12002003f, -0.12481142f, 0.04003288f, -0.02774909f, 0.01589654f, 
    0.09842048f, 0.18520133f, 0.19186316f, 0.18055117f, 0.12414892f, 0.14787652f, -0.05128737f, -0.11377814f, 
    -0.02299621f, 0.07929851f, 0.06331445f, -0.02583586f, 0.12275296f, -0.08390323f, 0.03072055f, -0.02161446f, 
    0.20694761f, 0.02192033f, 0.02626019f, -0.21620391f, 0.18338160f, 0.06290910f, -0.12224089f, -0.08981732f, 
    0.18212280f, -0.21085319f, 0.12116449f, -0.15093769f, 0.21333101f, -0.11480066f, -0.11180537f, 0.05630692f, 
    -0.11973903f, -0.10517439f, 0.06191511f, 0.05816822f, -0.03726102f, 0.01261287f, 0.02044366f, 0.24077342f, 
    -0.03112689f, -0.00540992f, 0.08414074f, 0.04665265f, 0.07821042f, 0.21783544f, 0.08760512f, -0.05162104f, 
    0.09120737f, 0.08509700f, -0.16028222f, 0.01428045f, -0.12367207f, 0.17762485f, 0.04452484f, 0.14877386f, 
    -0.01121328f, -0.10698843f, 0.10455942f, -0.17825928f, -0.02247567f, 0.04326462f, 0.11436895f, 0.19383816f, 
    0.31602445f, 0.03546732f, -0.08683274f, -0.08958758f, -0.08028835f, 0.07125547f, 0.06714512f, -0.10879990f, 
    0.02889976f, 0.06666213f, 0.03908109f, 0.09783059f, 0.13201804f, 0.17223670f, 0.00657155f, -0.05864005f, 
    -0.10528376f, -0.06567787f, -0.02461741f, -0.00185522f, -0.09155434f, -0.04245021f, 0.20291655f, 0.13005899f, 
    0.24681683f, -0.01475248f, 0.11773334f, -0.01565140f, 0.06243832f, -0.13691431f, -0.24154083f, -0.09958907f, 
    0.05694189f, -0.08749067f, 0.04457904f, 0.05197313f, 0.08355979f, 0.13928750f, 0.14583999f, 0.06642596f, 
    0.09507724f, 0.14346737f, 0.01466401f, 0.11573925f, 0.27543369f, -0.09031344f, 0.08777786f, -0.12229940f, 
    -0.18037950f, 0.02869035f, 0.12169523f, 0.14660782f, -0.06645802f, -0.06827341f, -0.03344871f, -0.00105410f, 
    0.11770289f, -0.05790224f, 0.09514180f, 0.07283805f, -0.28103694f, -0.02314527f, 0.14273861f, -0.04422639f, 
    0.14299688f, -0.19516236f, -0.15250203f, -0.02232399f, 0.01649339f, 0.03571856f, 0.10311778f, -0.06001600f, 
    0.04878898f, -0.13904238f, -0.11935865f, 0.13310415f, 0.02040805f, 0.08881242f, 0.06906109f, 0.00827387f, 
    0.05849743f, 0.16748124f, -0.08631191f, 0.05932534f, 0.01593403f, 0.09372132f, 0.15190457f, 0.00647504f, 
    -0.02371022f, 0.07329935f, 0.06056283f, 0.10576295f, 0.09086454f, -0.02004959f, -0.05318189f, -0.01008579f, 
    -0.01120261f, -0.14551444f, -0.04923924f, 0.16169494f, 0.05095590f, -0.14210837f, 0.14905243f, -0.02029297f, 
    0.06554335f, -0.21406847f, 0.19904836f, -0.00789114f, 0.34487045f, 0.03570375f, -0.15251574f, -0.28887457f, 
    0.02105697f, -0.00600777f, -0.03352692f, -0.03019940f, 0.15141056f, 0.10567013f, -0.13418412f, 0.10798670f, 
    0.03102522f, 0.06629656f, 0.03660144f, -0.27331877f, -0.04038075f, 0.05311023f, -0.00666178f, 0.11856890f, 
    0.01902347f, 0.09206221f, 0.03306646f, 0.09317110f, 0.09497882f, 0.07111488f, 0.18639390f, -0.06573019f, 
    0.05549615f, 0.04117056f, 0.00938497f, 0.00314726f, 0.15184955f, 0.09667113f, 0.10202742f, 0.00894872f, 
    0.17925707f, 0.02683000f, -0.20407632f, -0.03109771f, 0.06036343f, 0.06357904f, -0.06885883f, -0.09164997f, 
    -0.10773976f, -0.05917580f, 0.06907000f, -0.03383457f, 0.13404059f, -0.05143642f, 0.16366297f, 0.27875257f, 
    0.02717144f, 0.06188599f, -0.01868829f, 0.02642325f, -0.05677328f, 0.05724973f, -0.04773638f, 0.04511970f, 
    0.45585781f, -0.13791485f, -0.14062341f, 0.26679024f, -0.14792320f, -0.04888664f, 0.25870967f, -0.02164585f, 
    0.02629881f, 0.17809893f, -0.07915471f, 0.04005244f, 0.45227557f, 0.01809496f, 0.01973078f, 0.02941498f, 
    -0.06102849f, 0.03389380f, 0.03483414f, -0.06354637f, 0.03489734f, 0.10128652f, -0.08366445f, 0.02460921f, 
    0.23458497f, 0.32732442f, -0.00758165f, 0.09866945f, -0.08242634f, 0.17639127f, -0.08049628f, 0.00482443f, 
    0.00164936f, -0.12229176f, 0.05988463f, -0.04526174f, 0.22339931f, -0.16224828f, 0.07219204f, 0.17683698f, 
    -0.11360727f, 0.01599847f, 0.12066311f, -0.07076418f, 0.04845416f, 0.01219178f, -0.05288207f, -0.09353585f, 
    0.04405748f, 0.00933886f, -0.14468637f, -0.04747773f, -0.05192007f, -0.05220229f, -0.19205134f, 0.03274546f, 
    0.13787958f, 0.08615570f, 0.07518378f, 0.11776406f, 0.05266361f, 0.05082036f, -0.03296530f, -0.03400144f, 
    -0.10643067f, 0.02902817f, -0.09278984f, -0.05243840f, -0.13250615f, 0.07891635f, -0.03094824f, -0.11788940f, 
    -0.27080795f, 0.09524339f, 0.18084888f, -0.27866301f, -0.09282082f, -0.00244554f, 0.05216966f, -0.02501347f, 
    0.00056237f, -0.03934909f, -0.05986480f, 0.04878298f, 0.26599342f, 0.15883690f, -0.04429752f, -0.12466284f, 
    -0.00938405f, -0.01294490f, 0.00760759f, -0.13242351f, -0.13574688f, 0.01914513f, -0.01380910f, 0.02982984f, 
    0.32037824f, 0.08509434f, -0.19818567f, 0.15670767f, 0.15759535f, 0.01554051f, 0.15524802f, 0.00527424f, 
    0.01287379f, 0.01858495f, -0.03255359f, 0.03069108f, 0.07174580f, -0.10806987f, 0.10045423f, 0.05519737f, 
    0.02089605f, -0.08231944f, -0.00895801f, -0.01614687f, -0.11214941f, -0.00141762f, -0.00162354f, -0.03651261f, 
    0.11150895f, -0.02132420f, -0.17325698f, 0.07397060f, -0.05664109f, 0.07054682f, 0.10308261f, -0.00246673f, 
    -0.02652192f, -0.05644667f, -0.10283004f, 0.05043397f, -0.58384687f, 0.15921356f, 0.06814275f, 0.10016209f, 
    0.16951010f, -0.12681963f, -0.09027734f, -0.13872057f, -0.04206341f, 0.00853852f, 0.09337730f, 0.04740337f, 
    -0.05958693f, 0.00171246f, 0.05442683f, 0.20932525f, -0.12329502f, 0.03848627f, 0.08917776f, 0.12634794f, 
    -0.03621535f, -0.03459622f, -0.07278447f, -0.08776949f, 0.57731670f, 0.01722910f, -0.05858657f, -0.11563507f, 
    -0.07255850f, 0.17943433f, -0.04966483f, 0.06346244f, -0.02239744f, 0.04767533f, -0.08907042f, 0.02710493f, 
    0.05461187f, 0.37453121f, -0.08042800f, -0.03763572f, 0.13712858f, -0.03358332f, 0.13262221f, -0.03019698f, 
    0.04983843f, 0.03558807f, -0.17470723f, 0.08493616f, 0.46820140f, -0.08598228f, 0.02897666f, -0.16407616f, 
    -0.16924746f, -0.00046238f, 0.03505406f, 0.03768557f, -0.01399951f, -0.04886101f, 0.01716839f, -0.05609934f, 
    -0.22029665f, 0.13811138f, -0.10777226f, 0.05142401f, 0.07827592f, -0.04624560f, -0.09261903f, 0.01079189f, 
    -0.03817655f, -0.04170344f, 0.13505004f, 0.08590610f, -0.04271766f, -0.26696035f, 0.12742059f, -0.14544146f, 
    0.02699604f, 0.08037263f, -0.03400796f, -0.00183623f, 0.08651651f, -0.00446948f, -0.07763228f, -0.11772439f, 
    -0.24435306f, 0.06740649f, 0.11967635f, 0.05687660f, -0.08849630f, 0.11580839f, 0.03531514f, 0.04013690f, 
    -0.04461619f, 0.07643500f, 0.02060082f, 0.01557809f, 0.02920092f, -0.08473910f, -0.10141524f, 0.30047694f, 
    0.02115300f, 0.01081852f, 0.01308927f, -0.09900528f, -0.02723583f, -0.14198883f, -0.08133228f, -0.04514910f, 
    0.04220811f, 0.38253412f, -0.05027128f, 0.02210800f, -0.09489615f, -0.17073525f, 0.13589670f, 0.04445307f, 
    -0.03012103f, 0.01244050f, 0.07280800f, -0.10015552f, -0.04802592f, -0.03633701f, 0.23903413f, -0.08742054f, 
    -0.12029679f, 0.15014762f, 0.00976075f, 0.14148103f, -0.08118764f, -0.03328894f, 0.02845295f, 0.03159894f, 
    0.02333603f, -0.36833882f, 0.09945990f, 0.03816017f, -0.03488955f, 0.06999081f, 0.06344969f, -0.08433559f, 
    -0.01067695f, -0.03155293f, 0.00690415f, -0.05635018f, -0.10744663f, 0.05343975f, 0.24609780f, -0.09203458f, 
    -0.06827853f, -0.02197593f, 0.14752032f, 0.03293675f, 0.11466004f, -0.09616789f, -0.00732183f, -0.09488746f, 
    0.14360264f, 0.07959387f, -0.08006527f, -0.04894393f, -0.08116058f, -0.00661386f, -0.09195060f, 0.08531950f, 
    0.00266345f, 0.02457834f, 0.09959890f, 0.00148571f, 0.16544668f, -0.00742396f, 0.22752324f, -0.13944252f, 
    -0.12876116f, 0.05228190f, 0.10069370f, -0.06762813f, -0.13188528f, 0.20177652f, 0.12731889f, -0.06404396f, 
    0.05027437f, 0.08285532f, -0.09050622f, -0.03687311f, -0.06691666f, 0.05854902f, -0.05259593f, -0.05082855f, 
    0.01611780f, 0.27092433f, 0.03769418f, 0.05772521f, 0.00312370f, -0.11242803f, -0.26381639f, -0.11670084f, 
    0.10069499f, -0.02315532f, 0.07471654f, -0.06945202f, -0.03871511f, 0.05869839f, 0.12099785f, -0.03375081f, 
    -0.03470483f, -0.01243413f, 0.13576017f, 0.24242644f, -0.05337843f, 0.02240573f, 0.20934986f, -0.08223292f, 
    -0.02161730f, 0.01830649f, 0.07996749f, 0.08878282f, 0.11035252f, -0.18811700f, 0.19335681f, -0.12327756f, 
    -0.02724678f, 0.03415845f, 0.04701477f, -0.05028247f, 0.03434872f, 0.28677604f, 0.07466692f, 0.26985168f, 
    -0.44492224f, -0.11414845f, -0.07868569f, 0.01059806f, 0.00325399f, 0.08434696f, -0.06419855f, -0.06298617f, 
    0.07340647f, 0.14372677f, -0.02097776f, -0.12380879f, 0.51140821f, 0.33275658f, -0.10934252f, -0.14993735f, 
    -0.00569590f, 0.05282269f, 0.10789099f, -0.10311084f, 0.06880091f, 0.06300367f, -0.14333953f, 0.09916872f, 
    0.14038332f, 0.23374404f, 0.03010875f, 0.14165050f, 0.01647246f, -0.06981755f, -0.06894165f, 0.02664958f, 
    0.04617396f, -0.03155753f, 0.14092062f, -0.01385231f, 0.39029419f, 0.27605861f, 0.12572879f, 0.01816077f, 
    0.16503106f, 0.05560792f, 0.02513330f, -0.02036777f, 0.07976855f, 0.07289009f, 0.02067304f, 0.10701892f, 
    0.36473116f, 0.22782235f, -0.10933279f, 0.04535984f, 0.04471944f, -0.01384017f, -0.06062299f, 0.07229541f, 
    -0.00598882f, -0.03651293f, -0.11431565f, -0.05101062f, -0.05441022f, -0.14502750f, -0.05545535f, -0.05019047f, 
    0.09886411f, -0.08291841f, 0.13072531f, 0.04818809f, -0.06416817f, 0.00913277f, -0.10595355f, -0.01410164f, 
    0.10319089f, 0.12059560f, 0.20222291f, -0.01611227f, 0.06110965f, -0.01081024f, -0.02167788f, -0.01172154f, 
    0.05263191f, 0.09395357f, -0.08254927f, 0.05852159f, 0.29822770f, 0.25276306f, 0.01493144f, -0.16651897f, 
    -0.12487561f, 0.04546349f, 0.07188634f, 0.03060039f, -0.09830770f, 0.03270898f, 0.02543889f, 0.04700504f, 
    -0.05541860f, -0.12992220f, -0.08235260f, 0.29047453f, -0.09344591f, -0.06152978f, 0.01264716f, 0.17259888f, 
    0.05520040f, 0.15478121f, -0.06017963f, -0.03806269f, -0.01856455f, 0.26863953f, 0.05143911f, 0.17650987f, 
    -0.12959914f, -0.08401567f, 0.18926471f, -0.04451348f, 0.00506793f, -0.01367331f, 0.02164236f, 0.02210894f, 
    -0.06138045f, -0.40196380f, 0.16334876f, -0.07410416f, 0.14151761f, -0.14085717f, 0.01930472f, -0.05688075f, 
    0.07392129f, -0.08655874f, -0.02451677f, -0.10742521f, -0.06802549f, 0.00355777f, 0.00718825f, 0.01014050f, 
    -0.03387247f, -0.03289173f, -0.10565220f, 0.20931034f, 0.22731726f, 0.02392444f, 0.01591327f, -0.11123543f, 
    0.30811200f, 0.14604653f, -0.20495564f, -0.16512360f, 0.01078778f, 0.08815147f, 0.14527972f, 0.10886541f, 
    -0.16276282f, -0.02377745f, 0.07011060f, 0.14061864f, 0.07170501f, 0.19594440f, -0.01593489f, 0.01127608f, 
    -0.08364394f, -0.05784476f, 0.01963605f, -0.18715379f, -0.19235282f, 0.02156021f, 0.02898338f, -0.00742245f, 
    0.24107024f, 0.07169114f, -0.01721516f, -0.00475934f, 0.09900747f, -0.04870860f, -0.04380381f, -0.07055974f, 
    -0.09212639f, -0.09512048f, -0.07025708f, -0.08156583f, -0.04958127f, 0.27097142f, 0.24042033f, 0.25728217f, 
    0.00813034f, -0.03639473f, 0.00734934f, 0.04960863f, -0.16680539f, 0.13340010f, -0.05508674f, 0.17438617f, 
    -0.06334341f, 0.02494588f, -0.09483717f, 0.15335575f, -0.13948624f, -0.10697515f, 0.14800273f, 0.09936012f, 
    0.04859181f, 0.12652074f, 0.07567096f, 0.20934024f, -0.14588556f, -0.12168995f, -0.10787839f, 0.30092064f, 
    -0.05122900f, -0.08414642f, -0.13497292f, -0.05300007f, 0.07732686f, 0.08919410f, 0.02052711f, -0.10805152f, 
    0.17230910f, -0.04102702f, 0.08057000f, 0.01359209f, -0.11800756f, 0.01097511f, -0.00383553f, 0.05856832f, 
    0.06220788f, -0.07296084f, 0.11787739f, 0.01857177f, 0.42801645f, 0.01075689f, 0.27974534f, 0.10066406f, 
    -0.10601229f, -0.05165356f, 0.08078481f, 0.03756572f, -0.03573542f, -0.03797620f, -0.07921936f, -0.07627139f, 
    -0.24396425f, -0.06119668f, -0.11896265f, 0.08588388f, -0.09477109f, 0.03708884f, -0.06232909f, 0.06693649f, 
    0.00633996f, -0.07806537f, 0.04090932f, -0.02298578f, 0.21275319f, 0.08187076f, -0.09794112f, 0.14120573f, 
    0.06414385f, 0.12166915f, 0.10533535f, -0.04122822f, 0.08547779f, -0.03704685f, -0.12058284f, -0.09429020f, 
    -0.01297458f, -0.11278155f, -0.28358325f, -0.09431091f, -0.06633782f, 0.07129655f, -0.01638621f, 0.21896458f, 
    0.06070081f, 0.17735609f, -0.00464470f, -0.02760811f, -0.12071490f, 0.06839051f, -0.03920662f, -0.01195956f, 
    -0.00242478f, -0.15128246f, 0.00318634f, -0.10585062f, -0.22814645f, 0.09481495f, 0.03104554f, -0.03513985f, 
    0.28019372f, -0.04859872f, -0.02131498f, 0.19545692f, -0.27569449f, -0.00606115f, 0.01152916f, -0.02671887f, 
    -0.05610409f, 0.05757276f, 0.06016800f, -0.00185804f, 0.12620267f, -0.05306672f, 0.01686172f, 0.24038850f, 
    -0.17798722f, 0.05658766f, -0.00317892f, 0.17656434f, 0.01344003f, -0.11535066f, -0.01131110f, -0.03966283f, 
    0.11069868f, 0.06282669f, -0.02480928f, 0.20797922f, 0.10170137f, 0.03080628f, -0.11257764f, 0.02368452f, 
    -0.04793308f, -0.09851038f, -0.02386006f, -0.00900876f, 0.09414217f, 0.15139022f, 0.03476851f, -0.08400010f, 
    0.06123977f, -0.14266774f, 0.06457418f, -0.05390143f, -0.23538490f, 0.10123330f, 0.16395131f, 0.02917585f, 
    0.14266129f, -0.07460529f, -0.17842631f, 0.13429895f, -0.03876576f, 0.03128013f, -0.15534475f, 0.03773338f, 
    -0.05025473f, 0.13007843f, -0.04647193f, -0.02559943f, -0.34628016f, 0.16601442f, 0.00632105f, 0.17966439f, 
    0.07196967f, 0.22265798f, -0.01385506f, -0.10023547f, -0.07194257f, -0.05071400f, 0.07785025f, 0.07583071f, 
    -0.01920672f, 0.00867320f, -0.01994824f, -0.02850475f, -0.01959921f, -0.04517484f, -0.04114297f, 0.01338519f, 
    -0.03511984f, -0.02823973f, -0.04274238f, -0.04264276f, -0.00482276f, -0.02826510f, -0.00155924f, -0.03280996f, 
    0.03188661f, 0.03169718f, -0.01664667f, 0.03696743f, -0.00082274f, 0.02629877f, -0.05035109f, -0.01624168f, 
    -0.03590289f, 0.01613364f, 0.03275728f, 0.00765609f, 0.00704852f, -0.00737962f, 0.00081273f, -0.01700675f, 
    0.00773954f, -0.05170138f, 0.03519334f, -0.05402913f, -0.02131095f, 0.01179836f, -0.05306876f, -0.03291423f, 
    0.03044761f, -0.02982859f, 0.00448159f, 0.03011041f, -0.02772373f, -0.02125680f, 0.02367682f, -0.05487053f, 
    0.03161157f, -0.03439438f, 0.01942821f, -0.01804598f, 0.02035017f, -0.02658526f, 0.04203637f, 0.03576300f, 
    -0.03311558f, -0.01660911f, -0.03821532f, 0.02269282f, 0.02021105f, 0.01793624f, 0.01844967f, -0.03705401f, 
    0.00798985f, -0.01457295f, 0.03815037f, -0.05847969f, -0.00566846f, 0.01746051f, 0.05137198f, -0.05467824f, 
    -0.05787592f, 0.00913745f, -0.02781834f, -0.02218064f, 0.01949051f, -0.02037577f, 0.04029500f, -0.03213464f, 
    0.03473527f, 0.03477035f, -0.02466403f, -0.01930597f, -0.01391165f, 0.04474492f, 0.03579810f, -0.02823807f, 
    -0.05799587f, -0.00181750f, -0.03945761f, -0.04984658f, -0.04123499f, 0.02366170f, 0.02141387f, -0.03648744f, 
    0.00638733f, 0.01805128f, -0.01497609f, -0.04064931f, 0.00592811f, 0.04004209f, 0.03487641f, 0.01221919f, 
    0.04130661f, -0.02450601f, -0.03062216f, 0.02206429f, -0.01083899f, -0.05368110f, -0.02050191f, 0.02422040f, 
    -0.01973793f, -0.05123064f, 0.04144089f, -0.05564331f, 0.00956371f, 0.01873990f, -0.01118796f, 0.02373547f, 
    0.04225428f, 0.01945622f, 0.02521391f, -0.00557474f, -0.04922076f, 0.01665942f, -0.03165947f, -0.00726094f, 
    -0.01097098f, 0.00894774f, 0.00118745f, 0.02076107f, -0.06352664f, -0.02934782f, -0.00885670f, -0.05468871f, 
    0.01919968f, -0.02487168f, -0.04103953f, 0.00746855f, -0.01826450f, -0.00467400f, 0.02445499f, 0.00379511f, 
    -0.04515108f, 0.00395469f, -0.04777841f, 0.02438345f, -0.03198425f, -0.00854883f, -0.02964182f, 0.02681975f, 
    -0.01330172f, -0.01069841f, -0.03672413f, 0.03492637f, -0.01855617f, -0.01673172f, 0.00771261f, 0.02353344f, 
    0.00054931f, -0.03728723f, -0.00241145f, 0.03618769f, 0.00375257f, -0.04632597f, -0.05109970f, 0.02914455f, 
    -0.00177286f, -0.04289329f, 0.01511593f, 0.00603026f, 0.01677415f, -0.03979092f, -0.00790400f, -0.02160922f, 
    0.01768270f, -0.01683760f, 0.00132933f, -0.00822711f, -0.02853306f, 0.02961946f, 0.00644390f, -0.01407743f, 
    0.03812218f, -0.03894887f, -0.00393845f, -0.00964895f, 0.00688442f, -0.02230729f, -0.00230843f, 0.00618625f, 
    0.02588353f, -0.05782083f, -0.00288954f, 0.01930542f, -0.04567431f, -0.05180404f, 0.02527547f, 0.03748075f, 
    -0.00302737f, 0.04048390f, -0.02984886f, -0.03831378f, 0.00273211f, -0.01919898f, -0.00650834f, -0.02247989f, 
    0.02193974f, -0.01940656f, 0.00407473f, -0.01054165f, 0.01762906f, -0.00986556f, -0.02190697f, -0.00210663f, 
    0.01679264f, -0.03342882f, 0.03627513f, -0.05210402f, -0.05410096f, -0.04543226f, -0.03430642f, -0.05600028f, 
    -0.05397948f, 0.00768770f, 0.01411299f, -0.01663761f, 0.04051139f, -0.04891802f, 0.01130062f, -0.00642337f, 
    -0.01611031f, 0.01516490f, -0.03545048f, -0.04365822f, -0.05155760f, -0.00852291f, -0.02704700f, 0.04776755f, 
    -0.02735732f, -0.03408826f, -0.01114470f, 0.03566169f, 0.04038916f, -0.04575621f, 0.04782575f, 0.02954209f, 
    -0.02689511f, 0.01126111f, 0.03452940f, -0.02027573f, -0.00771298f, 0.03181442f, 0.03026802f, -0.04591904f, 
    -0.01540620f, -0.03027720f, 0.01190891f, 0.00463965f, -0.05506415f, 0.01479956f, 0.00326333f, -0.04856476f, 
    0.01191034f, 0.00206053f, -0.04338359f, 0.01590544f, 0.03079027f, -0.01703308f, -0.05138108f, -0.05901814f, 
    0.01335439f, 0.02122798f, -0.05116113f, 0.03729795f, -0.02771754f, -0.00845480f, -0.03883533f, -0.04108807f, 
    0.02560321f, 0.04050291f, 0.00586539f, -0.04532595f, -0.06079090f, 0.04596868f, 0.05479712f, -0.00986561f, 
    0.01907279f, -0.02691896f, 0.04101872f, -0.02891648f, 0.01941224f, -0.00112099f, 0.00414453f, 0.01690128f, 
    0.00421356f, 0.01462790f, -0.00821712f, -0.03275217f, -0.02637325f, 0.03406394f, 0.01779601f, -0.02694638f, 
    0.02777749f, -0.00582891f, -0.02242607f, -0.05869135f, -0.00728771f, -0.01580664f, -0.00261738f, -0.03257455f, 
    0.02856694f, -0.00141468f, 0.01862129f, 0.01874194f, 0.02531893f, 0.00975520f, -0.04725830f, 0.00774478f, 
    0.01020764f, -0.01298638f, 0.04446274f, -0.00797252f, -0.02807494f, 0.00475956f, 0.02175758f, -0.02648097f, 
    -0.04703174f, -0.02522157f, 0.03985537f, 0.01583355f, -0.02358306f, -0.01760982f, -0.02412966f, -0.00582290f, 
    0.02626415f, -0.02385876f, -0.02427443f, -0.03319326f, 0.02792709f, -0.04691570f, 0.03504160f, -0.00585983f, 
    0.02123861f, 0.02803043f, -0.06259822f, 0.00945953f, 0.00599110f, 0.01327951f, -0.04053969f, -0.04078614f, 
    -0.02160132f, -0.01260853f, -0.00540722f, -0.04881619f, -0.04490566f, 0.02194385f, -0.00090391f, -0.05875831f, 
    -0.02459545f, 0.03376561f, 0.02198902f, -0.05328656f, -0.02452176f, 0.02224966f, -0.00290407f, -0.01982134f, 
    0.01361683f, -0.05665556f, -0.00291926f, -0.02122457f, 0.02732319f, 0.02803002f, 0.00562602f, -0.03704750f, 
    0.02706951f, -0.02688053f, 0.02837541f, 0.03386961f, 0.04176210f, -0.04036076f, -0.03602421f, 0.02258677f, 
    0.02063094f, -0.05550611f, 0.03803755f, -0.03455121f, -0.00129544f, -0.04163053f, -0.02524749f, 0.03144453f, 
    -0.01954076f, -0.00890565f, 0.02430519f, -0.04709958f, 0.04177035f, -0.02670389f, -0.00150997f, -0.00266723f, 
    0.02240433f, -0.04867134f, -0.03255470f, -0.01323727f, -0.04469752f, -0.04679086f, 0.00953833f, -0.00479226f, 
    -0.03082822f, -0.03078205f, -0.03357969f, -0.01645944f, 0.04098561f, -0.01010976f, -0.00599633f, 0.02497956f, 
    0.03217656f, 0.03091220f, -0.01081217f, -0.05703762f, -0.02082742f, 0.00919891f, -0.02526265f, 0.02406446f, 
    -0.02757792f, -0.03544952f, 0.02426031f, 0.02620592f, -0.00032759f, -0.03017460f, 0.03599306f, -0.01584962f, 
    -0.04104631f, 0.01100211f, 0.01043630f, 0.03309792f, -0.01226659f, -0.01319594f, -0.01225487f, -0.04814173f, 
    -0.02351596f, 0.01927893f, -0.04790600f, -0.01661948f, 0.02043426f, -0.04471907f, -0.01044438f, -0.02697552f, 
    -0.05359304f, 0.00290903f, 0.01102580f, -0.00641654f, 0.01688541f, -0.02033392f, 0.00593327f, -0.01174984f, 
    0.04121377f, -0.00406875f, -0.01853838f, -0.01583128f, 0.03890654f, 0.00415114f, 0.00956867f, -0.00042061f, 
    -0.01908181f, -0.03597610f, 0.02069397f, -0.05346467f, 0.03638870f, -0.00003290f, 0.03389009f, 0.00054269f, 
    0.00066384f, 0.02583770f, -0.01360575f, 0.04097940f, 0.02412182f, -0.00683243f, -0.03307829f, -0.04725683f, 
    -0.04611801f, -0.00156346f, -0.04460328f, 0.00223456f, 0.00959196f, 0.01672324f, 0.02345907f, -0.05260367f, 
    0.02682741f, 0.01494078f, 0.03465306f, 0.00180721f, -0.00089297f, 0.01219525f, 0.03887444f, 0.02295018f, 
    0.01463353f, 0.02880957f, 0.01998161f, -0.02560221f, 0.01604062f, 0.03472216f, -0.01075940f, -0.05865474f, 
    0.02706057f, -0.04480199f, 0.01588764f, 0.02833424f, -0.03424632f, -0.01580977f, -0.00569663f, 0.04173364f, 
    0.00803228f, 0.00749589f, -0.01862971f, -0.03682725f, 0.01101924f, -0.05348518f, -0.03827091f, 0.03994652f, 
    -0.04997624f, -0.04554258f, 0.02843717f, -0.01720947f, -0.05396099f, -0.01876877f, 0.02527649f, -0.05016581f, 
    -0.05349538f, -0.00397275f, -0.04144600f, -0.00156105f, 0.04101819f, -0.04007211f, 0.02064831f, -0.01671732f, 
    -0.01425325f, -0.00481356f, 0.02919384f, -0.01137233f, -0.05679350f, 0.01946998f, -0.04705964f, -0.04296190f, 
    0.00555671f, -0.02495343f, -0.01765688f, 0.04081179f, 0.04225942f, -0.04661019f, -0.04163739f, 0.03715151f, 
    0.00920634f, 0.02997853f, -0.00317327f, -0.04401233f, 0.04109679f, -0.03705603f, 0.04152306f, 0.03173118f, 
    -0.03545092f, -0.02970415f, 0.03847125f, 0.03417944f, -0.00559560f, -0.02255876f, 0.02502602f, -0.02744738f, 
    -0.04461794f, -0.01684685f, 0.00715066f, 0.01094481f, -0.04361638f, 0.01571480f, 0.00444769f, 0.02079190f, 
    -0.04183380f, 0.03191633f, -0.02574594f, 0.03940264f, 0.04056309f, 0.03330778f, -0.02792090f, -0.04491759f, 
    -0.02746812f, 0.00677759f, -0.02098256f, 0.03923881f, 0.03555506f, -0.00094054f, -0.00626045f, -0.02493530f, 
    -0.01504700f, -0.04274996f, -0.00426383f, -0.01838480f, -0.03790742f, -0.05055421f, 0.01766247f, 0.04311760f, 
    0.02334277f, 0.00659897f, -0.05409456f, -0.01778291f, -0.02327863f, -0.03033363f, 0.03603204f, -0.01241435f, 
    0.02502603f, 0.02706529f, -0.05878760f, -0.01776804f, 0.01229087f, -0.04952763f, -0.02006367f, 0.03157507f, 
    -0.03281961f, -0.00103907f, -0.01222204f, 0.01721407f, -0.04004633f, 0.00801423f, -0.05353677f, -0.02131586f, 
    0.02438724f, -0.04303121f, 0.01797356f, -0.01823519f, 0.04216495f, 0.02646801f, 0.00422802f, -0.01613562f, 
    0.02760453f, -0.00251979f, -0.04121881f, 0.03722290f, 0.02920574f, -0.05298376f, -0.04158049f, 0.01277076f, 
    0.01158920f, 0.02753113f, 0.00186657f, 0.03365250f, -0.03185873f, 0.04046643f, 0.02831001f, 0.02258669f, 
    -0.04134737f, 0.00424929f, 0.04295827f, -0.03489815f, 0.00523840f, -0.05288708f, -0.05406674f, -0.01786116f, 
    -0.01409824f, 0.04070834f, 0.01482350f, -0.04484284f, -0.05279217f, -0.04353522f, 0.02937617f, 0.02451503f, 
    -0.04460690f, -0.03767151f, -0.00224195f, 0.00953912f, 0.01734308f, -0.04855393f, -0.00735383f, -0.02927933f, 
    -0.05329515f, 0.04241670f, -0.03708022f, -0.04148422f, 0.01199395f, -0.00020379f, -0.00064891f, -0.02349357f, 
    -0.03136173f, -0.03565993f, -0.00716539f, 0.03628307f, 0.02343652f, 0.01571806f, 0.03848629f, 0.02722637f, 
    -0.05328070f, -0.01757885f, 0.01860425f, 0.04269603f, -0.02570276f, -0.03653326f, -0.03330292f, -0.03867381f, 
    -0.04940580f, -0.01321052f, 0.00722641f, -0.02249825f, -0.04986433f, 0.00069196f, 0.00437809f, -0.05629246f, 
    0.01105482f, 0.01497829f, 0.03050606f, 0.01063273f, 0.01244760f, -0.05086610f, -0.03049413f, -0.05727235f, 
    -0.02645858f, -0.05641620f, 0.03107952f, -0.05498760f, 0.03681898f, 0.03487978f, -0.03987351f, 0.02698300f, 
    0.02139152f, -0.05959760f, 0.01210229f, -0.03524078f, -0.00504422f, 0.04001965f, -0.02997006f, -0.00238960f, 
    -0.02988373f, 0.02712316f, -0.00185098f, 0.04211142f, -0.04663148f, -0.00707704f, 0.04443794f, 0.04150574f, 
    -0.00265863f, -0.04118789f, 0.00357269f, 0.00154574f, -0.00206563f, 0.00819275f, -0.03295766f, -0.04200708f, 
    -0.03880292f, -0.05016368f, 0.03929707f, -0.03045001f, -0.00318150f, -0.00967747f, -0.01015225f, 0.04191665f, 
    -0.02385849f, 0.02705083f, -0.01336856f, -0.00428426f, -0.02235776f, -0.04098335f, 0.03657722f, 0.03154636f, 
    -0.02560662f, 0.03612936f, -0.03197356f, -0.03157194f, -0.04691159f, -0.03884872f, -0.04397554f, -0.00545100f, 
    -0.02079550f, 0.00410704f, 0.01307502f, -0.05397425f, -0.03702720f, -0.01996862f, 0.00048576f, -0.01731447f, 
    -0.01207370f, -0.02380814f, -0.04367570f, -0.03624780f, -0.03494066f, -0.02426604f, -0.02573860f, -0.00241680f, 
    0.00174123f, -0.05679535f, -0.01980241f, -0.03345894f, -0.01135377f, -0.01356763f, 0.00353063f, -0.04380582f, 
    0.02178723f, -0.02739721f, -0.00658920f, -0.00326060f, 0.01648217f, -0.04837259f, 0.00965249f, -0.04586933f, 
    -0.02155385f, -0.05597487f, 0.00564954f, -0.00349499f, 0.01668161f, -0.06003283f, -0.00021356f, -0.04981804f, 
    -0.05228936f, 0.02693247f, -0.00550133f, -0.02022092f, -0.03278849f, 0.00608789f, 0.00368952f, 0.03713498f, 
    0.01380374f, 0.02739955f, -0.04737120f, -0.02794351f, -0.00395048f, 0.01560266f, -0.00239568f, 0.04198674f, 
    -0.00113148f, 0.02915344f, 0.03859900f, -0.01294031f, -0.05557185f, 0.00046067f, -0.02814450f, -0.02260789f, 
    -0.05881819f, -0.04602808f, 0.01443406f, -0.02790124f, -0.04971004f, -0.02886175f, 0.01161524f, -0.01725799f, 
    -0.02091510f, -0.01918462f, -0.03677147f, -0.02594240f, -0.04625295f, 0.03990373f, 0.02383664f, 0.01999104f, 
    -0.04480242f, -0.04220995f, 0.01571091f, -0.01506513f, -0.03863527f, 0.00525793f, -0.01404438f, -0.00377756f, 
    -0.04704613f, -0.05548562f, 0.04196605f, -0.01436992f, -0.03645628f, -0.03720586f, -0.01237959f, 0.00009933f, 
    0.00594113f, -0.00781125f, -0.05090424f, 0.01919871f, 0.00574835f, 0.03803251f, -0.00728635f, -0.01686668f, 
    -0.01466972f, 0.04216528f, 0.03587895f, 0.01629405f, -0.04636330f, 0.02270854f, 0.01730415f, 0.00286051f, 
    0.01227655f, 0.00536740f, -0.00427833f, 0.04005289f, 0.00268963f, -0.01033740f, -0.00147702f, 0.00032347f, 
    -0.04790304f, -0.00291967f, -0.03659665f, -0.02188914f, -0.04803316f, -0.05308092f, 0.01551129f, 0.02308233f, 
    0.02655770f, -0.04747660f, 0.00413613f, 0.01729049f, 0.03541652f, 0.01198538f, 0.02205221f, 0.03254375f, 
    -0.03101761f, -0.03273356f, -0.01480484f, 0.02444369f, -0.03190578f, 0.02774131f, -0.05007964f, 0.04479865f, 
    0.00083978f, -0.01003326f, -0.00407907f, -0.00197747f, 0.03879280f, -0.02828648f, -0.05519478f, -0.00541376f, 
    -0.04247271f, -0.02191328f, -0.05898539f, -0.01670039f, 0.03939598f, -0.03827591f, -0.05394325f, -0.02272997f, 
    0.00903617f, -0.02120497f, -0.00973282f, -0.05855281f, 0.03813536f, -0.00519633f, 0.01113400f, 0.03029498f, 
    0.03016847f, 0.02963717f, -0.00393134f, 0.01141367f, -0.00262491f, -0.00539715f, -0.05203055f, -0.05514734f, 
    0.01116329f, -0.05364363f, -0.05454391f, -0.01361496f, -0.04934233f, 0.00656346f, -0.01411246f, 0.01702253f, 
    0.00059931f, -0.01284119f, -0.00310383f, 0.02529961f, -0.04223790f, 0.01330542f, -0.02087325f, 0.01789193f, 
    -0.03163540f, -0.00190278f, 0.04316300f, 0.03909913f, -0.00627796f, 0.01058082f, -0.05583396f, 0.03113665f, 
    0.02720802f, -0.01611015f, -0.01318693f, 0.01780216f, -0.01761973f, -0.00217171f, 0.01058625f, 0.03251256f, 
    -0.02211054f, -0.00569298f, -0.00482679f, 0.01856764f, -0.04345028f, 0.01050382f, 0.00276240f, -0.01403446f, 
    -0.05348130f, -0.00777291f, -0.05482790f, -0.00916934f, -0.02988369f, -0.01168730f, -0.02939992f, 0.01346126f, 
    -0.03933765f, -0.04934712f, 0.00568971f, -0.01527017f, -0.03698727f, -0.03124310f, -0.05256202f, -0.03733207f, 
    -0.00563791f, -0.00439622f, 0.01499591f, -0.03502436f, 0.01744698f, -0.01655271f, -0.02143646f, -0.02826319f, 
    -0.01434575f, -0.00171292f, -0.03940077f, -0.00360819f, 0.03475293f, 0.03302292f, 0.00034853f, -0.04244677f, 
    -0.00579113f, 0.00272853f, -0.01970828f, -0.00546276f, 0.01513713f, -0.04201220f, -0.00768207f, 0.00834231f, 
    -0.04335659f, -0.04087336f, 0.02826765f, -0.02172363f, -0.04891007f, -0.00388541f, -0.02625959f, 0.02767016f, 
    0.00676112f, -0.02462767f, 0.03473024f, 0.00959540f, -0.03644652f, 0.01138089f, 0.02272586f, 0.04278039f, 
    -0.05647755f, 0.03413902f, -0.00459691f, -0.00626185f, -0.05666174f, 0.00631561f, -0.04593902f, -0.01174901f, 
    -0.02252829f, 0.03218513f, -0.00330941f, -0.04252753f, 0.04131842f, -0.01828634f, 0.00983733f, -0.00865334f, 
    0.02326403f, 0.01989652f, -0.00793616f, 0.01515334f, -0.03309686f, -0.02078783f, 0.03522564f, 0.02606458f, 
    0.02287852f, 0.01128590f, -0.05260301f, 0.03462292f, 0.02977256f, -0.00022245f, 0.03457037f, -0.03809208f, 
    0.02761305f, -0.01362372f, -0.02080122f, 0.03122283f, -0.05493510f, 0.03941012f, 0.00260588f, -0.00799326f, 
    -0.01769064f, 0.00974703f, 0.00343212f, -0.01360498f, -0.00379750f, 0.01593057f, 0.03928113f, -0.05897753f, 
    0.00239157f, -0.04151537f, 0.03059431f, 0.03704596f, -0.03109959f, -0.00647228f, 0.04293868f, -0.02473442f, 
    0.02948465f, -0.04386393f, -0.02543676f, -0.04318593f, -0.04391404f, -0.05485437f, 0.00589684f, -0.04599698f, 
    0.01538841f, 0.04287684f, 0.03942790f, 0.03719538f, -0.05112887f, -0.03297428f, 0.03102900f, -0.02087115f, 
    0.00324985f, 0.04111784f, -0.00412340f, -0.05669388f, 0.00554872f, 0.03475484f, 0.03072849f, 0.00446216f, 
    -0.02765227f, -0.01787719f, -0.03736968f, -0.03173430f, -0.03658163f, -0.02241208f, 0.00975691f, -0.02266449f, 
    -0.03176942f, -0.04614799f, 0.03495073f, 0.02553258f, -0.02011370f, -0.04238044f, 0.02603177f, -0.00209353f, 
    0.00268771f, 0.02341902f, 0.00559825f, 0.00821154f, -0.04055577f, 0.03154158f, -0.03739477f, 0.03166163f, 
    0.02068632f, 0.01341776f, 0.04164676f, -0.03624340f, 0.03013383f, -0.04380792f, -0.01925029f, -0.04261110f, 
    -0.04506493f, 0.03213729f, -0.05255262f, 0.03769339f, -0.00688793f, -0.02171871f, -0.02624467f, -0.04393736f, 
    -0.03593579f, -0.04962175f, -0.04661833f, 0.03931986f, 0.03705573f, 0.01416714f, -0.00690849f, 0.04035747f, 
    -0.00473266f, 0.03806792f, -0.02170972f, 0.02485596f, -0.02775686f, -0.05837667f, 0.04123621f, 0.01947875f, 
    -0.05817633f, -0.05259321f, -0.03970572f, -0.05883112f, -0.04352051f, -0.02631303f, 0.03576112f, 0.02936810f, 
    -0.00948139f, -0.02937893f, -0.00229608f, 0.02155859f, -0.00302873f, 0.02738186f, -0.03468871f, -0.03370106f, 
    0.02548245f, -0.02506791f, -0.02888830f, 0.02481109f, -0.04768072f, -0.00091370f, 0.03309701f, -0.02550203f, 
    -0.00917304f, -0.02735355f, 0.03923875f, -0.05064487f, -0.00572235f, 0.01605201f, 0.01421601f, -0.01026976f, 
    0.00050238f, 0.02216830f, 0.01795952f, -0.00820556f, -0.03495143f, 0.03652572f, -0.02343040f, 0.00392220f, 
    -0.03742494f, -0.03895827f, -0.02328266f, 0.02433469f, -0.02696027f, -0.05544174f, -0.03700691f, 0.02778681f, 
    0.03367867f, 0.02129011f, 0.01450908f, -0.04472812f, -0.02655978f, -0.02409855f, -0.01362715f, 0.03859266f, 
    -0.00540560f, -0.01598845f, -0.00389092f, 0.02034044f, -0.05566895f, -0.04744859f, -0.00995289f, -0.01657520f, 
    -0.01128721f, -0.04015886f, -0.04423662f, 0.04175027f, 0.00991089f, 0.02960953f, 0.01190677f, -0.02315447f, 
    0.00141096f, -0.05593824f, -0.04156729f, -0.03552225f, 0.00394460f, -0.04619860f, 0.00497499f, -0.01424108f, 
    -0.01098243f, -0.05703712f, -0.00096791f, -0.01876176f, 0.01118814f, -0.04677145f, -0.01984260f, -0.04714570f, 
    -0.02681616f, -0.01738803f, -0.04479490f, -0.04070966f, 0.00357955f, 0.03427957f, 0.02005122f, 0.02493920f, 
    0.00849412f, -0.00679897f, 0.04220463f, -0.04904216f, -0.02483866f, -0.04650768f, 0.03571786f, 0.00325952f, 
    0.03615692f, 0.01139028f, -0.01905916f, -0.00965580f, -0.01488942f, -0.00239043f, 0.03174319f, 0.03007782f, 
    0.03162701f, -0.01785049f, 0.03017103f, 0.01597022f, 0.01598517f, -0.01307675f, 0.01891864f, 0.02572109f, 
    -0.01730887f, 0.01302628f, 0.02234907f, -0.03621891f, 0.03543530f, 0.03380512f, -0.02516666f, -0.00514279f, 
    -0.02314847f, -0.02117011f, 0.01551119f, 0.04036982f, -0.05150916f, -0.01089318f, -0.03006683f, -0.01398794f, 
    -0.03355426f, 0.00376692f, 0.01550134f, -0.03972598f, 0.02528792f, 0.01966128f, -0.02053113f, -0.00718742f, 
    -0.03236553f, 0.02430621f, -0.04526501f, 0.03853805f, -0.04825421f, 0.01615554f, 0.03431592f, -0.03380231f, 
    -0.05189673f, 0.03977285f, 0.03656131f, -0.02076236f, 0.02961522f, -0.03484976f, -0.00477660f, 0.00027615f, 
    0.00348191f, -0.02947490f, -0.02407005f, 0.02515996f, -0.03905545f, 0.01234469f, -0.00889094f, 0.01208531f, 
    0.00173571f, 0.03554618f, -0.03533901f, -0.03670910f, -0.03558981f, 0.01658682f, -0.04654552f, 0.01318816f, 
    -0.01959635f, -0.04374551f, -0.00381572f, -0.02855986f, 0.04524053f, -0.02659522f, 0.00271928f, 0.03307611f, 
    0.01910762f, -0.04362573f, -0.04784632f, -0.00762998f, 0.01773650f, 0.03015649f, 0.01721171f, -0.04434665f, 
    -0.01024876f, -0.03458868f, -0.03257549f, 0.03302061f, -0.00808121f, 0.00498062f, -0.00950478f, -0.02680608f, 
    -0.02705484f, 0.02221022f, -0.05022261f, -0.03554675f, 0.01168540f, 0.01358088f, 0.00733111f, -0.01726929f, 
    0.01304844f, -0.04716853f, -0.03224492f, -0.05849177f, -0.03958289f, 0.01793590f, 0.02538843f, 0.01658262f, 
    -0.00088716f, 0.02865233f, 0.03512617f, 0.02922852f, -0.05239022f, 0.01987085f, 0.03427531f, -0.02256060f, 
    0.03337435f, -0.00674963f, -0.00120640f, -0.02067934f, 0.02780479f, 0.03467916f, -0.00100806f, 0.03230007f, 
    -0.04906115f, -0.04260007f, -0.04177182f, -0.01994859f, -0.00640026f, -0.02675623f, 0.02646197f, -0.03155521f, 
    0.01949162f, -0.02744277f, -0.04391609f, -0.01396212f, -0.01966725f, 0.02493853f, -0.05872686f, 0.00662574f, 
    -0.00351597f, -0.04029800f, -0.04227552f, -0.04400899f, -0.01475346f, -0.05045892f, -0.01919455f, -0.00272361f, 
    0.02568897f, 0.03417398f, 0.02087309f, 0.02078543f, 0.01660188f, 0.02244895f, -0.02217472f, 0.00404774f, 
    -0.05707761f, -0.03377294f, -0.04661314f, -0.03703843f, 0.03794586f, 0.01430916f, 0.02406206f, -0.02449245f, 
    0.00199454f, 0.01253409f, 0.01250247f, -0.00331818f, -0.00349188f, -0.00398561f, -0.04311411f, 0.02782291f, 
    0.01929416f, -0.04341754f, -0.02027904f, -0.03959748f, -0.00472490f, -0.03069894f, 0.04140108f, -0.05129711f, 
    0.01568180f, -0.02690579f, 0.01042736f, -0.01105137f, -0.02474255f, -0.04578005f, 0.03913717f, -0.02850878f, 
    -0.00258005f, 0.00454684f, 0.03115651f, -0.03906208f, 0.03454890f, -0.01615136f, -0.00835851f, 0.04028774f, 
    -0.01454834f, -0.01747474f, 0.02980988f, -0.01839336f, -0.01842688f, -0.05429680f, -0.01416976f, -0.03700796f, 
    0.00494606f, -0.04219193f, 0.00040310f, -0.01027154f, 0.00459721f, -0.05502069f, 0.02732440f, 0.00271070f, 
    -0.05828862f, 0.01377520f, -0.02084260f, 0.02533305f, 0.01020477f, -0.04184274f, -0.03005920f, 0.02760912f, 
    -0.02255637f, -0.04877862f, 0.03664597f, 0.02608229f, -0.00820134f, -0.04277673f, -0.04819772f, 0.02842590f, 
    -0.04440904f, -0.04829181f, -0.01661104f, 0.03155038f, -0.00436710f, 0.00022372f, -0.05608957f, -0.01099133f, 
    0.02175838f, 0.00762864f, -0.01415559f, -0.02552307f, 0.03375356f, 0.00994969f, -0.02444838f, -0.05295590f, 
    0.03785588f, 0.02503138f, -0.01749042f, 0.01601115f, 0.01438790f, -0.02327777f, 0.00515372f, 0.04266429f, 
    -0.12970893f, -0.08997588f, 0.09674536f, 0.07170289f, 0.17430349f, -0.00887878f, -0.01773262f, 0.08506483f, 
    0.06088706f, 0.05751195f, -0.00784785f, 0.07747757f, 0.02386364f, -0.09370599f, 0.03812636f, 0.16860452f, 
    0.09090764f, 0.04360985f, -0.10225707f, -0.08485559f, 0.02546184f, 0.01336045f, 0.02495149f, 0.13937506f, 
    -0.23642385f, -0.00302420f, 0.02165867f, -0.23627487f, -0.04433103f, -0.01451543f, 0.02111611f, 0.17624199f, 
    0.04084965f, -0.11652727f, -0.02942446f, 0.07958641f, -0.22575811f, -0.41137400f, 0.31532356f, 0.16078863f, 
    -0.05146182f, 0.05862238f, -0.05980198f, 0.01635559f, -0.09678255f, 0.06171207f, 0.13403329f, 0.06266694f, 
    0.09313620f, -0.17694154f, -0.07560682f, -0.07116657f, -0.11091051f, -0.06919021f, 0.02484273f, 0.02957151f, 
    0.12679939f, 0.13576522f, 0.01527474f, 0.02230271f, -0.04932088f, -0.37028605f, 0.26138413f, -0.09449296f, 
    0.01021824f, -0.01582667f, 0.03938214f, 0.00274465f, 0.07534785f, 0.03804347f, -0.00749662f, 0.07439296f, 
    -0.11537917f, -0.14820392f, 0.20697784f, 0.02382644f, -0.09411875f, 0.21461073f, 0.07554465f, -0.02019258f, 
    0.00187763f, -0.13842984f, 0.02005299f, -0.09493995f, 0.33225918f, -0.11075167f, 0.14622456f, 0.00786996f, 
    0.09833796f, -0.10600045f, -0.03751101f, -0.04698385f, -0.00207227f, 0.08430272f, 0.07190809f, 0.08864934f, 
    -0.48886266f, 0.14285326f, -0.11598196f, -0.10859316f, 0.09458546f, 0.02855260f, 0.09572110f, -0.04499409f, 
    0.02567407f, 0.06156192f, 0.14638987f, 0.02615128f, -0.06289995f, 0.03768055f, -0.05938911f, -0.21082760f, 
    -0.09898748f, -0.03281459f, -0.01748375f, 0.04132553f, -0.07907508f, -0.09385299f, -0.06105555f, 0.06514487f, 
    -0.09513173f, 0.06480911f, 0.11963450f, -0.07557518f, 0.04621279f, -0.01011788f, 0.02755794f, -0.02673352f, 
    0.05127062f, 0.05035969f, 0.04712383f, 0.08103314f, 0.02862209f, 0.03802044f, 0.05213865f, -0.25529221f, 
    0.10052702f, 0.00929104f, -0.03654303f, 0.06885134f, 0.03126075f, 0.02266119f, 0.02856939f, -0.06996925f, 
    0.50397670f, 0.09773209f, 0.00669190f, -0.16928951f, 0.08664630f, -0.04237606f, 0.00483715f, 0.06360015f, 
    0.07459474f, 0.05995940f, 0.05396676f, 0.16608502f, -0.09638400f, 0.00370037f, -0.13908961f, -0.07602870f, 
    -0.00385339f, 0.00438567f, 0.07025338f, 0.08098023f, 0.04379650f, 0.02412140f, -0.03485059f, 0.07600547f, 
    0.27952978f, 0.07212106f, -0.14430651f, 0.22485097f, 0.01359116f, 0.11886033f, -0.16984549f, 0.00390129f, 
    0.17454600f, 0.02922739f, 0.04746514f, 0.24217565f, -0.39567664f, 0.04708486f, -0.09209174f, -0.08558698f, 
    0.29821298f, -0.01111521f, -0.11933249f, 0.18646756f, 0.09275806f, -0.03966814f, 0.00148157f, 0.09981375f, 
    0.08101785f, -0.14163421f, 0.02065730f, 0.28920138f, 0.05699611f, 0.01004321f, 0.02026545f, -0.01170770f, 
    -0.06541813f, -0.04718814f, 0.02394100f, -0.06475272f, -0.11492308f, -0.41823345f, -0.31201085f, -0.21057189f, 
    0.05064017f, 0.14589366f, -0.04347813f, -0.08944639f, 0.05838066f, 0.02647873f, -0.03497581f, 0.04244151f, 
    -0.12695074f, -0.18077758f, 0.04578071f, -0.06927915f, 0.08178334f, -0.02642987f, -0.10513152f, 0.08953432f, 
    0.04851864f, -0.16243988f, 0.07705738f, 0.05515628f, 0.29195148f, 0.24983625f, -0.12747139f, -0.08601946f, 
    -0.04172632f, 0.00935149f, -0.02376973f, 0.02555051f, -0.12835303f, -0.10885221f, -0.02030819f, 0.01038831f, 
    -0.29939303f, 0.20960143f, 0.12920697f, -0.34100512f, 0.08424125f, -0.06852414f, 0.04105247f, 0.11096987f, 
    -0.02173990f, -0.09502599f, 0.04523491f, -0.09104889f, -0.07092185f, -0.13504872f, 0.00455656f, -0.09406158f, 
    0.07157871f, 0.12418123f, 0.03464395f, 0.04273686f, 0.03162106f, 0.07445735f, -0.03904567f, 0.04180388f, 
    0.07559533f, 0.40889403f, -0.05829420f, 0.26117954f, -0.03412460f, 0.05676971f, -0.08154317f, 0.00815205f, 
    -0.00071135f, 0.17249690f, 0.05256647f, -0.11972108f, 0.09124629f, 0.09091397f, -0.27678901f, -0.05297408f, 
    0.02793999f, 0.04095004f, 0.01473284f, -0.07456498f, -0.05293272f, 0.02777096f, 0.03313169f, 0.00184174f, 
    0.41441333f, 0.31178063f, 0.13455874f, 0.04526627f, -0.01891195f, -0.01886354f, -0.07465299f, -0.01570379f, 
    0.16331476f, 0.00343430f, -0.01064836f, 0.01630865f, 0.42733419f, 0.11949365f, 0.02124004f, -0.15432592f, 
    -0.06425309f, 0.10451681f, 0.20860089f, 0.07995160f, -0.02553417f, -0.13176353f, 0.13267787f, -0.02272525f, 
    -0.05717922f, 0.08073018f, 0.08861733f, 0.00761151f, 0.09147638f, 0.05041377f, -0.08742888f, 0.05500235f, 
    0.11702861f, -0.08006866f, -0.01666289f, 0.07359684f, 0.15408659f, -0.03230282f, 0.14599504f, -0.16879016f, 
    -0.08025486f, -0.02721281f, -0.02710447f, 0.05923189f, 0.09352709f, -0.02071734f, -0.13505840f, -0.09328119f, 
    0.12748861f, 0.01361699f, -0.04904516f, -0.01040738f, 0.01340842f, 0.03606203f, 0.00892174f, 0.05451971f, 
    -0.05660821f, -0.06932116f, -0.11585483f, -0.07471273f, 0.03348513f, 0.04286543f, 0.07341342f, -0.12161282f, 
    0.11628226f, 0.09569025f, 0.01910006f, -0.10493787f, 0.02090217f, 0.13956849f, 0.12419313f, 0.11308796f, 
    0.12785333f, 0.15814720f, 0.08132279f, 0.07655855f, 0.03754323f, -0.04322973f, -0.02619495f, -0.00164525f, 
    0.10146437f, 0.12826890f, 0.11173496f, 0.02725583f, 0.06806552f, -0.02646480f, -0.05598329f, -0.05491736f, 
    0.08289845f, 0.02446820f, 0.01361323f, 0.20245454f, 0.06957530f, 0.08352564f, -0.02216024f, 0.03951655f, 
    0.30991992f, 0.05606912f, 0.17475757f, 0.01815472f, -0.05824466f, 0.16102017f, -0.18537986f, 0.11032584f, 
    0.04365192f, 0.00565390f, 0.08755999f, 0.08129527f, -0.04627283f, -0.07697744f, -0.05067395f, 0.03503566f, 
    0.08114373f, -0.00471942f, -0.06381103f, 0.06153745f, -0.00970028f, -0.02082533f, 0.03245171f, -0.07357018f, 
    0.00558023f, -0.25824070f, 0.01804435f, 0.06402466f, 0.09051316f, -0.10181852f, -0.16765383f, -0.07705422f, 
    -0.04869869f, -0.02436994f, 0.03602871f, 0.11284511f, -0.26842672f, -0.09917444f, -0.07761379f, 0.10339357f, 
    0.07465561f, -0.01510503f, 0.05368555f, -0.03568868f, -0.11768803f, 0.03274853f, -0.07475293f, -0.01910741f, 
    -0.12533545f, 0.03851311f, 0.16543083f, -0.06944743f, -0.17802930f, -0.10610317f, 0.09233765f, -0.07903703f, 
    -0.00078959f, 0.05723760f, -0.08724962f, 0.07857187f, -0.25768882f, 0.02541126f, 0.12355631f, -0.10297637f, 
    -0.12983136f, 0.04102319f, 0.08067557f, -0.09693065f, -0.08304361f, 0.09077384f, -0.09324790f, -0.00799957f, 
    -0.06317523f, -0.00026733f, 0.13842401f, -0.04018716f, 0.06137201f, 0.01409126f, 0.24671625f, -0.04496700f, 
    0.03368625f, 0.03763637f, 0.14967041f, -0.19582434f, 0.24212603f, -0.00102935f, 0.01714523f, 0.15649524f, 
    -0.16505565f, 0.05027743f, 0.06835830f, -0.08449207f, 0.03621567f, -0.08383771f, 0.03253733f, -0.20594415f, 
    -0.16905607f, -0.08580672f, 0.17367162f, 0.05779219f, -0.03298176f, 0.04448163f, -0.10484041f, 0.14345710f, 
    -0.07958809f, -0.01819998f, 0.12599178f, 0.11222499f, -0.14032575f, -0.01677367f, 0.03757545f, 0.02897646f, 
    0.17194107f, 0.07582652f, 0.13218646f, 0.12458312f, 0.03962854f, -0.05954781f, -0.00300401f, 0.00974135f, 
    0.32322150f, 0.18659145f, 0.27405176f, 0.11040514f, -0.07275190f, 0.15450424f, -0.06046052f, -0.16405576f, 
    -0.06297170f, -0.00509191f, 0.02541272f, 0.15077099f, 0.00311089f, -0.07342033f, 0.11688832f, -0.19338667f, 
    0.20329523f, 0.07610065f, 0.15852067f, 0.23809078f, 0.01180723f, 0.06921867f, 0.06761177f, 0.05248256f, 
    -0.10034744f, -0.06942420f, -0.06394599f, -0.07860815f, 0.00808105f, -0.05365663f, 0.15077183f, 0.01781415f, 
    0.03251371f, 0.09284940f, 0.03706449f, 0.07010794f, -0.29364085f, -0.11109530f, 0.25001201f, -0.19153479f, 
    -0.09060472f, -0.08216242f, 0.04170984f, -0.04760437f, -0.07590099f, -0.00333594f, 0.04013178f, 0.00998590f, 
    0.13202965f, -0.15287128f, 0.06399988f, -0.02391175f, -0.18778497f, 0.01866993f, 0.14111656f, -0.02692562f, 
    -0.03236674f, 0.01244637f, -0.10661966f, -0.04302813f, -0.14648753f, -0.07492121f, 0.04613167f, -0.22527842f, 
    0.11536026f, -0.15251720f, -0.17363106f, -0.02069038f, 0.09083939f, -0.22281796f, -0.02124767f, 0.10653820f, 
    -0.09365865f, 0.03442603f, -0.07926136f, 0.06150227f, -0.07276567f, -0.07107773f, 0.12794149f, -0.03345351f, 
    0.00283996f, 0.03235175f, -0.04621290f, -0.04949525f, 0.20786145f, 0.04156274f, -0.10035799f, -0.16255935f, 
    -0.03579852f, -0.05153675f, -0.00910142f, 0.02579389f, 0.04308361f, 0.04379792f, -0.01306995f, 0.12050922f, 
    0.08430314f, 0.11147805f, -0.04257110f, -0.01107571f, 0.19808982f, -0.14327873f, -0.09296183f, -0.06689792f, 
    0.08322749f, -0.01092911f, -0.00207384f, 0.04061759f, 0.30784723f, 0.17356551f, 0.38739473f, -0.11818291f, 
    -0.18057488f, 0.02068000f, 0.02165301f, 0.01082915f, 0.01215054f, -0.03866763f, 0.08401195f, -0.01792328f, 
    -0.31957078f, -0.18891361f, -0.04626663f, -0.02924084f, 0.12000722f, -0.09708969f, 0.08498122f, 0.10210793f, 
    -0.05479492f, -0.05436809f, 0.12544048f, -0.10614717f, -0.22162929f, -0.12217166f, -0.20720708f, -0.25386924f, 
    0.01838082f, 0.21000008f, -0.11811803f, -0.01719203f, 0.10331681f, -0.03104227f, -0.01429541f, -0.11542815f, 
    0.29575279f, 0.09065128f, 0.32310998f, 0.10253821f, -0.10527554f, 0.05633646f, 0.03077456f, -0.02790511f, 
    0.03630858f, -0.01603945f, -0.00299213f, 0.05385175f, -0.19450770f, 0.04636957f, -0.05201066f, -0.18296459f, 
    -0.03772187f, 0.12745258f, 0.07218983f, 0.00347185f, -0.01495109f, 0.00039878f, 0.04796338f, -0.06594936f, 
    0.01092369f, 0.40503824f, 0.14484791f, 0.15351026f, 0.00737580f, -0.06729058f, 0.13723049f, -0.03337046f, 
    -0.12243122f, -0.05001866f, 0.13665542f, -0.03740879f, 0.01473695f, -0.11459337f, 0.28843409f, -0.19846433f, 
    0.03845931f, 0.20663349f, -0.03827960f, 0.21922398f, 0.09809504f, -0.05539054f, -0.00783807f, 0.17501168f, 
    0.12019280f, -0.16016625f, 0.19140989f, 0.10413025f, -0.04145069f, 0.07770779f, -0.05048515f, 0.02821435f, 
    0.06966171f, -0.08463345f, 0.08948777f, -0.05677531f, 0.28061596f, 0.39944124f, 0.19902626f, 0.14485939f, 
    -0.02154175f, 0.06358284f, 0.18303844f, -0.06394947f, 0.08879437f, 0.14606668f, 0.06210825f, -0.09193553f, 
    0.03419920f, 0.20702724f, 0.26539487f, 0.27678925f, -0.20171064f, -0.03889664f, 0.04174075f, 0.04989324f, 
    -0.00687138f, 0.12278259f, 0.04634701f, -0.00705347f, -0.02063262f, -0.06522360f, 0.03790148f, -0.34405878f, 
    0.08110154f, 0.14416973f, 0.09673402f, -0.18142156f, -0.05239614f, 0.04702320f, -0.07688390f, 0.01766942f, 
    0.18811750f, 0.22008806f, 0.14958109f, 0.14175896f, -0.21569514f, 0.01198117f, 0.00578140f, 0.06926473f, 
    -0.03184880f, -0.03073461f, 0.08605988f, -0.04641824f, 0.26513463f, -0.10371865f, -0.18621847f, -0.15897079f, 
    -0.04213022f, -0.14010678f, -0.01039436f, -0.05439577f, 0.07009903f, -0.04186225f, 0.06934478f, 0.04450711f, 
    -0.01187019f, 0.12013784f, -0.10229289f, 0.09402994f, 0.09456618f, 0.04047740f, 0.10902417f, -0.04095795f, 
    -0.02425123f, 0.08058111f, 0.08233175f, 0.10690194f, 0.06200169f, 0.28597376f, -0.06375073f, 0.04486058f, 
    0.13579054f, 0.18299089f, 0.00558087f, 0.10256612f, 0.05425872f, 0.04095319f, 0.17732337f, 0.05592019f, 
    0.22352095f, 0.12575187f, 0.29254848f, 0.35595107f, -0.06347560f, 0.11211064f, -0.09426107f, -0.11623441f, 
    0.03684913f, 0.07543457f, -0.01345642f, -0.04501129f, 0.15598440f, 0.27889642f, -0.16262986f, -0.24947639f, 
    -0.01095512f, -0.09722751f, 0.11817899f, -0.02322158f, -0.07330119f, -0.06421929f, -0.04299826f, 0.11438762f, 
    -0.17833886f, 0.36278376f, 0.23894463f, -0.40713254f, -0.07858744f, 0.01164648f, 0.01586831f, -0.03590286f, 
    -0.14890264f, -0.12239172f, 0.00601482f, -0.01162175f, -0.09028153f, 0.09228794f, -0.12721123f, 0.02293690f, 
    0.08409374f, 0.02073533f, -0.02422603f, 0.13427281f, 0.05146685f, -0.05344166f, -0.22681411f, 0.07494370f, 
    0.26782045f, -0.12502849f, -0.05910744f, -0.06618729f, 0.15540238f, -0.05494042f, -0.02712422f, 0.17524485f, 
    -0.02755152f, -0.07552119f, -0.23242532f, 0.14757137f, -0.08417763f, 0.19543226f, -0.16672327f, 0.11770983f, 
    -0.09076046f, 0.12514749f, 0.14287613f, 0.10414287f, 0.15316167f, -0.04002525f, -0.10365332f, -0.03471332f, 
    0.09145267f, -0.23744883f, 0.01265334f, 0.16043061f, 0.01413225f, 0.10999382f, 0.04841869f, 0.10287827f, 
    -0.04330826f, 0.21117818f, -0.18083213f, -0.05330104f, 0.09112415f, -0.27478975f, -0.09750775f, -0.15846172f, 
    0.03112741f, 0.11235263f, -0.04670630f, 0.09394686f, -0.04911074f, 0.13394950f, -0.03945103f, 0.00283348f, 
    0.09781614f, -0.09512643f, -0.00418413f, 0.25639838f, 0.03676291f, 0.15746839f, 0.05878397f, 0.12489085f, 
    0.05317308f, 0.19685507f, 0.08837601f, 0.21511456f, -0.14313591f, -0.38875327f, -0.06234451f, 0.04266166f, 
    0.05685231f, -0.01869008f, 0.28910884f, -0.04587702f, -0.03181522f, 0.04959419f, 0.00343597f, 0.18005091f, 
    -0.30017442f, 0.38603675f, 0.01685456f, 0.10406639f, -0.14535740f, 0.16059831f, -0.08433028f, -0.03651545f, 
    0.03615605f, 0.00988223f, -0.06489982f, 0.00356962f, -0.04230841f, 0.04982511f, 0.30826515f, -0.19736457f, 
    0.06283294f, 0.04259175f, 0.09354845f, 0.04188242f, -0.07936973f, -0.06333035f, 0.00401214f, 0.03409872f, 
    -0.38933259f, 0.07545399f, 0.33756897f, -0.33588609f, 0.08299023f, 0.05898115f, 0.11993757f, -0.00267368f, 
    -0.16042446f, -0.01968054f, 0.14798561f, 0.01795366f, 0.20556280f, -0.15620801f, -0.00730716f, -0.21566604f, 
    -0.09775621f, -0.22208948f, 0.09865425f, -0.05487549f, 0.03335391f, 0.07470696f, 0.01827738f, 0.07116482f, 
    -0.23777264f, 0.01896386f, 0.05079182f, -0.27242610f, 0.06706011f, 0.02146427f, 0.03298536f, -0.08206207f, 
    0.09194282f, -0.07747098f, -0.08939224f, -0.00871446f, 0.20516291f, 0.01941312f, 0.26270553f, -0.10051725f, 
    0.02449632f, 0.00299612f, 0.08433795f, 0.09695819f, 0.07147406f, 0.15918729f, 0.02858578f, 0.12066737f, 
    0.04834691f, -0.02289808f, -0.14392702f, 0.02921763f, 0.00544966f, 0.05194774f, 0.17513259f, 0.14447537f, 
    -0.06764515f, 0.22515486f, -0.13265549f, 0.08385483f, -0.16860713f, 0.03989837f, 0.12508722f, -0.04796672f, 
    0.01261187f, -0.05611121f, -0.06836145f, 0.12122826f, 0.05574847f, 0.11607976f, 0.04057076f, -0.11856732f, 
    0.14358035f, -0.26869595f, -0.14382762f, 0.16817923f, -0.09132447f, 0.14617342f, 0.06676907f, -0.09471513f, 
    0.03882010f, -0.03251678f, 0.15840812f, 0.16815253f, -0.08301593f, 0.19224992f, -0.18678860f, 0.19985445f, 
    0.11617629f, 0.04884807f, 0.03005055f, 0.06377853f, 0.14578679f, -0.11977565f, -0.01545522f, -0.07073148f, 
    -0.07652806f, -0.28171629f, 0.22556345f, -0.21100020f, -0.04250252f, -0.07729200f, -0.00830803f, 0.13018399f, 
    0.13283128f, -0.02551063f, 0.02340318f, -0.06170919f, -0.39329535f, -0.00849036f, 0.43475071f, -0.20293209f, 
    0.09902006f, 0.18396315f, 0.07675906f, 0.09078813f, 0.05033345f, -0.00131806f, -0.04794355f, 0.01962814f, 
    -0.29203725f, -0.19580075f, 0.07315465f, -0.13521388f, -0.14715514f, 0.05553862f, 0.15710574f, 0.04456539f, 
    0.03325715f, 0.13469429f, -0.00213259f, -0.01552730f, 0.02987103f, -0.08629352f, -0.03681487f, 0.18287905f, 
    0.28043655f, -0.09220374f, -0.09208900f, 0.02267409f, -0.01910046f, 0.23448472f, 0.03654691f, -0.01506533f, 
    -0.04710677f, 0.29623550f, -0.16155666f, 0.00767381f, 0.02672850f, -0.14520963f, 0.08195470f, 0.09024250f, 
    -0.13531570f, 0.20155774f, -0.14394088f, 0.00157194f, 0.01576969f, 0.27277723f, -0.27855808f, 0.05786094f, 
    0.04990482f, 0.12719752f, 0.04348942f, 0.02571552f, -0.03096694f, -0.02136060f, -0.09440107f, 0.03980045f, 
    -0.00103360f, 0.11252586f, 0.23493797f, 0.00642356f, -0.08784829f, -0.14803457f, -0.07928015f, 0.07931306f, 
    0.02158022f, 0.06105769f, -0.06467108f, 0.06066119f, -0.15409376f, -0.17698666f, -0.05587775f, 0.01043817f, 
    0.05962681f, 0.07959444f, -0.04208479f, 0.12045971f, -0.07530504f, -0.04701370f, 0.04643414f, -0.03725899f, 
    0.02544659f, -0.03485572f, 0.02355697f, -0.06002112f, -0.20013589f, 0.05862982f, 0.05911415f, 0.02274654f, 
    -0.02757906f, 0.28836241f, -0.22997659f, 0.01393452f, -0.03224026f, -0.14967403f, 0.17661025f, -0.06325319f, 
    0.00997170f, 0.00498081f, 0.19807413f, -0.03734289f, -0.05567867f, -0.06335595f, 0.07593882f, 0.08952525f, 
    0.34800097f, -0.16379535f, 0.04068843f, 0.25234258f, 0.08750109f, -0.00461683f, -0.05941163f, 0.00029771f, 
    0.05237338f, 0.07961492f, -0.04591515f, 0.12301655f, 0.56901312f, -0.18651812f, 0.02540141f, 0.49224362f, 
    -0.07574859f, -0.03159345f, 0.06801163f, -0.10974970f, -0.02196283f, -0.08292609f, -0.13424708f, 0.07771999f, 
    0.09051159f, -0.06731691f, -0.09322501f, -0.11528001f, -0.02495518f, -0.06213716f, -0.03633888f, 0.07634077f, 
    -0.08346146f, -0.04546697f, 0.01488960f, -0.08082107f, -0.06236944f, -0.41651183f, -0.03952620f, -0.34349674f, 
    0.21046574f, 0.03356596f, 0.08168956f, -0.00179193f, -0.04274882f, -0.21261443f, 0.06139185f, 0.08902524f, 
    -0.51266241f, 0.17547333f, 0.10327319f, -0.56086558f, 0.06500226f, -0.05750850f, -0.07619970f, 0.05390340f, 
    0.11475840f, -0.01444965f, 0.12695171f, -0.08359398f, -0.06332376f, 0.25162446f, 0.27950335f, -0.02052462f, 
    0.11220158f, -0.22047392f, 0.10747450f, -0.00737452f, -0.02522070f, 0.00475888f, 0.07615370f, -0.16071197f, 
    0.18816043f, -0.01385124f, -0.07411224f, -0.04742359f, 0.18461746f, -0.01123130f, 0.07262100f, 0.00919406f, 
    0.08172625f, 0.00928221f, 0.02705511f, -0.06145542f, 0.42971256f, -0.00380843f, -0.05431601f, 0.04611165f, 
    -0.05647774f, 0.00829951f, -0.03527847f, -0.09576043f, 0.03874908f, 0.01504317f, 0.01581505f, 0.05150865f, 
    -0.08640851f, -0.01650783f, 0.12512125f, -0.11755507f, -0.02741108f, 0.10728627f, 0.13470493f, 0.00575181f, 
    -0.25693223f, -0.03884254f, -0.16419850f, -0.13549700f, -0.11771940f, 0.15231229f, 0.18923783f, -0.04738838f, 
    0.07754085f, -0.10912242f, 0.19064656f, 0.02748107f, -0.03880646f, 0.01588530f, 0.04717573f, 0.11518835f, 
    0.17630316f, 0.25842041f, -0.08609898f, 0.09092276f, 0.07475104f, 0.08014500f, -0.18269318f, 0.04927059f, 
    0.10204942f, 0.13610303f, -0.12577611f, 0.02547801f, -0.08725452f, 0.21259570f, 0.19872844f, -0.15660793f, 
    0.11090858f, 0.15630564f, -0.07542913f, 0.08433954f, 0.04347412f, 0.01367354f, 0.04424056f, 0.05810052f, 
    -0.10198224f, 0.24217969f, -0.01808145f, -0.07744288f, 0.08846987f, -0.07863902f, 0.01408397f, -0.12479106f, 
    -0.00807609f, 0.04484278f, 0.10043222f, -0.03036832f, -0.00500689f, 0.08063602f, -0.10068663f, -0.33217305f, 
    0.07703467f, -0.01428869f, 0.02995878f, -0.05328692f, 0.07741842f, 0.06993722f, -0.03980060f, -0.10177153f, 
    -0.15737140f, 0.13616711f, -0.11336979f, -0.13683966f, 0.05292111f, -0.00406222f, -0.17037046f, 0.04084560f, 
    -0.04902298f, 0.03562736f, -0.11264517f, -0.01997283f, 0.49839863f, -0.08619148f, 0.10979308f, 0.11969101f, 
    0.03394702f, 0.04839936f, -0.13596593f, 0.18035401f, -0.02811169f, 0.05112895f, -0.01658677f, 0.02498711f, 
    0.16046384f, 0.08004205f, -0.00658435f, -0.05853012f, 0.01956958f, -0.05905697f, 0.11960991f, -0.10166481f, 
    -0.09268132f, -0.01046876f, -0.03900045f, 0.04034275f, 0.33361161f, 0.11164627f, 0.17602499f, -0.05980311f, 
    0.03142483f, -0.05962839f, -0.00875883f, -0.04090871f, 0.11994550f, 0.10040863f, 0.04634044f, 0.05005332f, 
    0.12188198f, -0.01103824f, 0.06328116f, 0.00547091f, 0.05328468f, -0.04095856f, 0.02689037f, -0.00782032f, 
    0.02604004f, -0.01912996f, -0.00567103f, -0.02277380f, -0.09910213f, 0.16870561f, -0.26361951f, -0.24333020f, 
    0.02920802f, 0.13711144f, 0.03926465f, 0.04612226f, 0.10186113f, -0.01338450f, 0.09370353f, -0.13040017f, 
    -0.14037810f, 0.10587823f, -0.06364216f, -0.04691200f, 0.06898279f, 0.01567596f, 0.05948882f, 0.05755330f, 
    -0.03511480f, -0.05674136f, 0.00213889f, 0.00220648f, 0.11875921f, 0.01500666f, 0.16212232f, 0.15548907f, 
    -0.03126290f, 0.06846839f, 0.04702615f, 0.08360142f, -0.01670362f, 0.07317789f, -0.07708021f, 0.06075142f, 
    -0.07916309f, 0.25645497f, -0.05158798f, 0.19497302f, 0.07307278f, 0.02751519f, -0.10108375f, 0.04046589f, 
    -0.01529923f, 0.00640552f, 0.08621676f, -0.00347175f, 0.03856565f, 0.14994107f, -0.01810927f, -0.20946351f, 
    0.07162844f, 0.01208519f, -0.00077632f, -0.01326967f, 0.00769071f, 0.14839578f, 0.04503841f, -0.04107348f, 
    -0.07176593f, -0.05602413f, 0.23750104f, -0.20753926f, 0.22822125f, 0.03743963f, -0.10029309f, -0.01188288f, 
    -0.01250038f, -0.02002148f, 0.05485110f, 0.02704997f, 0.21684797f, 0.11107755f, 0.08378350f, 0.00710408f, 
    0.03132517f, -0.02361886f, 0.07718531f, 0.01340745f, 0.11372243f, 0.01487431f, 0.19821402f, 0.00402018f, 
    -0.49803290f, 0.37445420f, 0.05685263f, 0.08674792f, 0.08166347f, 0.02000363f, -0.06286500f, 0.05348474f, 
    -0.00080725f, -0.06713758f, 0.04484665f, -0.09273771f, -0.01523588f, 0.02964286f, -0.28592792f, -0.10503791f, 
    0.09198549f, 0.03379627f, -0.03755266f, -0.00844223f, 0.01885681f, -0.02880936f, -0.12873007f, 0.03838317f, 
    -0.18748537f, 0.12077624f, -0.02239047f, -0.02202728f, -0.05243414f, 0.06750824f, 0.08785341f, -0.14922100f, 
    -0.19385180f, -0.00183268f, -0.13420030f, 0.12331641f, -0.30837288f, 0.18237825f, 0.20221663f, 0.08368272f, 
    0.09786093f, 0.06481724f, -0.13565139f, -0.02074059f, 0.05409185f, -0.03852478f, 0.05798334f, 0.05339005f, 
    -0.26267189f, 0.20932540f, 0.07818544f, -0.06484007f, 0.04801656f, -0.00558251f, -0.02796111f, 0.06362626f, 
    -0.04330726f, 0.04048765f, 0.07679892f, -0.15186620f, -0.04461662f, 0.21175334f, 0.21238087f, -0.11694364f, 
    -0.09504865f, -0.06966316f, 0.04752312f, 0.22616746f, 0.02334335f, 0.04534410f, -0.02516272f, -0.04366163f, 
    -0.05254134f, 0.02715637f, 0.01122848f, 0.01503632f, -0.02099949f, -0.01048453f, -0.02807181f, -0.00717987f, 
    -0.01699826f, 0.00519525f, -0.00881712f, -0.01066407f, -0.02050185f, 0.00470693f, 0.01992756f, -0.01834183f, 
    0.02979260f, -0.01435190f, -0.04455015f, 0.01345067f, -0.02217010f, -0.04824121f, 0.02255413f, -0.00747504f, 
    0.03511353f, 0.02834389f, -0.02159895f, -0.01352451f, 0.03048553f, 0.00254977f, -0.04010874f, -0.04190896f, 
    0.00125931f, -0.04049373f, -0.03510055f, 0.00790568f, 0.03582562f, -0.04116749f, -0.02660324f, -0.02127129f, 
    -0.03999789f, 0.03701474f, 0.01759269f, 0.01985306f, 0.01254152f, 0.00940467f, -0.02778450f, -0.03508944f, 
    0.03352285f, -0.04606742f, -0.03055197f, -0.04021979f, -0.02171478f, 0.02523388f, -0.00623433f, 0.02710443f, 
    -0.05252775f, 0.00988936f, -0.00756847f, -0.01525886f, -0.02980360f, 0.02010171f, 0.02953716f, 0.01815125f, 
    -0.00165223f, 0.00975927f, 0.02753265f, -0.00171011f, 0.01697055f, -0.02196330f, -0.00276976f, 0.03635333f, 
    0.03451689f, 0.02446290f, 0.00826474f, 0.02904201f, -0.00599420f, 0.02407519f, -0.01090715f, -0.04492616f, 
    -0.01492412f, 0.00878135f, 0.00729854f, 0.02534428f, -0.01729467f, -0.02667240f, -0.02276733f, -0.04867395f, 
    0.03090115f, -0.01199032f, -0.00347978f, -0.03256151f, 0.03585102f, 0.02772030f, -0.05130254f, -0.01634674f, 
    -0.02632412f, -0.04833421f, -0.01632714f, 0.04177304f, -0.04705148f, -0.03075056f, -0.03503992f, 0.03530319f, 
    0.00363465f, -0.01758808f, 0.04220907f, 0.01136995f, -0.00367974f, -0.00865638f, -0.02888997f, 0.02693368f, 
    -0.02744139f, 0.01214064f, 0.04377250f, 0.00022779f, -0.03849458f, 0.03116298f, -0.05072666f, -0.04659665f, 
    -0.02133154f, -0.03840642f, 0.02300310f, 0.02683328f, -0.05066324f, -0.03371696f, -0.02857821f, -0.01759298f, 
    -0.00528775f, 0.01628546f, -0.01671899f, 0.02648296f, -0.04606046f, -0.03750278f, -0.04567324f, -0.04138153f, 
    -0.04415341f, -0.04602886f, 0.01568129f, -0.02066308f, -0.05292214f, -0.02171698f, 0.01905605f, 0.00726011f, 
    -0.03142386f, 0.03667610f, 0.04796721f, 0.00899030f, -0.03666320f, -0.03885660f, 0.00880695f, 0.01074595f, 
    0.00456716f, 0.01975921f, -0.05659138f, 0.00498703f, -0.05310240f, -0.05451214f, 0.00786057f, -0.03331888f, 
    -0.01822913f, -0.03081100f, 0.03032442f, 0.01934932f, -0.02565757f, -0.03015563f, -0.04920471f, -0.03268135f, 
    0.01042413f, -0.04545794f, -0.03843579f, -0.02316321f, 0.01035385f, -0.00017140f, 0.00419544f, 0.01770882f, 
    0.04449231f, -0.03618396f, -0.00276847f, 0.02711014f, -0.03306329f, 0.01910458f, 0.01046353f, 0.02228575f, 
    0.01067611f, -0.01716419f, 0.02409701f, 0.04319278f, -0.05229088f, -0.01495485f, -0.01288713f, -0.04833717f, 
    -0.00066747f, -0.00269572f, -0.02582249f, 0.01614393f, -0.03934545f, -0.01629720f, -0.00564533f, -0.00737130f, 
    0.02746159f, -0.02594316f, 0.02390532f, -0.00317473f, -0.00228832f, 0.00513915f, 0.01453543f, -0.03139832f, 
    -0.03312992f, 0.02855004f, -0.04123205f, -0.03466959f, 0.01133638f, 0.02411723f, 0.01135549f, 0.01817178f, 
    -0.03992562f, 0.01712607f, -0.02889706f, 0.02043201f, -0.02362349f, 0.04854260f, -0.00681477f, 0.00052022f, 
    -0.03944637f, 0.01900816f, 0.02668199f, -0.05630465f, -0.03601957f, 0.02657935f, -0.01454981f, -0.04438533f, 
    0.01596197f, 0.02644725f, -0.02156155f, -0.01266567f, -0.04484288f, 0.01252179f, 0.01896820f, 0.01053628f, 
    0.00011907f, -0.05337925f, 0.02830949f, 0.00803334f, -0.01441419f, 0.00176489f, 0.00192659f, 0.04296075f, 
    -0.03537317f, -0.02398655f, 0.00690293f, -0.00490488f, -0.03149062f, -0.00158930f, -0.00775956f, -0.01576369f, 
    0.03759673f, 0.02555492f, 0.01931622f, -0.05192503f, -0.02640675f, -0.01510476f, -0.02878092f, 0.00409168f, 
    -0.04597773f, 0.03436092f, -0.02704982f, 0.01919425f, -0.01869522f, -0.04124699f, -0.03693255f, 0.03791447f, 
    0.02876117f, 0.01002894f, 0.03490929f, -0.04128395f, 0.01578975f, 0.02174686f, 0.03509007f, -0.04650386f, 
    0.03841425f, -0.04844872f, 0.04007450f, 0.02615991f, -0.03014448f, 0.04245920f, -0.00270793f, -0.03992667f, 
    -0.05675475f, -0.04278158f, 0.02452005f, 0.05012941f, -0.03497597f, -0.03922114f, -0.02678453f, -0.03526163f, 
    -0.00148897f, 0.01278164f, 0.01533069f, -0.05592740f, -0.03041232f, 0.02953453f, -0.05636554f, -0.01118775f, 
    -0.04188990f, 0.04002319f, 0.03988277f, 0.01979595f, -0.00858551f, -0.00953371f, 0.03281466f, 0.00173425f, 
    -0.00939961f, 0.03139700f, 0.01974089f, 0.00201705f, -0.00449622f, 0.01851249f, 0.04010134f, -0.05516602f, 
    -0.00656429f, 0.00643122f, -0.00920009f, -0.00990808f, -0.01109484f, -0.00334274f, 0.00715100f, 0.04408288f, 
    0.00824253f, 0.02168884f, -0.00451964f, 0.01328728f, -0.05450259f, 0.03702361f, -0.01210351f, -0.00328941f, 
    0.01611011f, 0.03898215f, 0.01876356f, -0.01213534f, -0.00440536f, 0.01690982f, -0.00690131f, -0.02469710f, 
    0.00121147f, -0.03393187f, 0.01090552f, -0.00677524f, 0.02935722f, 0.00139652f, -0.00741576f, -0.04639581f, 
    0.03496320f, -0.05090160f, 0.02102231f, 0.01139654f, 0.00109503f, -0.03285125f, -0.02104742f, -0.02795092f, 
    0.04481907f, -0.04322140f, -0.03347523f, -0.04674015f, -0.03955413f, 0.05021852f, -0.04240353f, -0.03605803f, 
    0.02435455f, -0.04230026f, 0.00121833f, -0.00853502f, -0.01180268f, -0.02735303f, -0.01193921f, -0.02822211f, 
    -0.02378765f, 0.04780763f, -0.05109971f, -0.02689808f, -0.01579200f, 0.01943195f, 0.04158010f, 0.02215660f, 
    -0.14126435f, 0.07876655f, -0.05273217f, -0.08140383f, 0.07239136f, 0.06484229f, -0.05940270f, 0.01219043f, 
    0.02805709f, -0.11386709f, -0.00323009f, -0.07323976f, -0.45524171f, 0.13594629f, -0.21923716f, 0.12710407f, 
    0.03530956f, 0.01262893f, -0.00287564f, 0.07819850f, -0.13338272f, -0.10022520f, -0.09880582f, -0.11023280f, 
    -0.17202613f, -0.30313507f, 0.10573238f, 0.00578353f, -0.00061745f, -0.09436858f, 0.03083548f, 0.04124869f, 
    0.08902030f, -0.09196676f, 0.01148860f, 0.09932125f, -0.12052217f, -0.06604425f, -0.17133996f, 0.16115128f, 
    -0.03684178f, -0.13629469f, -0.01650883f, -0.08748830f, 0.07533610f, -0.07428270f, 0.07414300f, -0.01494253f, 
    -0.47492182f, -0.04615952f, 0.18790348f, -0.07893746f, -0.09092755f, 0.06353860f, -0.00893581f, 0.02126619f, 
    -0.15414952f, -0.02185401f, -0.04160414f, 0.05479473f, -0.39056748f, 0.12636235f, -0.06026670f, 0.13599512f, 
    0.00077648f, 0.08354433f, 0.07473490f, -0.00093249f, -0.09543710f, -0.05955234f, 0.02190033f, -0.00958102f, 
    -0.32839730f, -0.23193166f, 0.16940558f, 0.05719863f, 0.13945341f, -0.20669523f, 0.11435543f, -0.14142369f, 
    0.05363346f, 0.09996153f, 0.02051234f, 0.03349330f, -0.22735764f, 0.33999288f, -0.04168975f, -0.09782428f, 
    0.02807260f, 0.02663227f, -0.14045446f, -0.03753783f, -0.06502850f, 0.00966055f, -0.03372754f, -0.03414236f, 
    0.02897579f, 0.02418972f, 0.29553103f, 0.23613353f, 0.02147202f, 0.18293038f, 0.03020253f, 0.05792982f, 
    -0.03701852f, -0.13477801f, -0.01230368f, -0.02253251f, -0.03841153f, -0.09374679f, 0.09457523f, 0.36834177f, 
    0.31581926f, -0.00668207f, 0.03930311f, 0.17307231f, 0.18813415f, -0.08455622f, -0.01870048f, 0.04167592f, 
    0.30158669f, 0.01371952f, 0.03220320f, 0.04688149f, 0.15298624f, 0.07906639f, 0.02715407f, -0.11310860f, 
    -0.11506470f, -0.05305984f, 0.08438633f, 0.05194441f, 0.23568279f, -0.04989101f, 0.09023952f, 0.25096896f, 
    0.30587861f, 0.06575863f, 0.00854317f, 0.10517117f, 0.12135082f, 0.03647199f, 0.03619312f, 0.04990344f, 
    0.08322965f, -0.15934764f, -0.02126482f, 0.13555473f, -0.24477792f, 0.06466896f, -0.02064843f, -0.02626778f, 
    0.01742489f, 0.07678957f, 0.08382840f, 0.06753390f, -0.23531637f, -0.05798343f, 0.04388412f, 0.18855301f, 
    -0.14575936f, -0.06023662f, 0.06017577f, -0.06169506f, -0.11360924f, 0.00028660f, 0.09031469f, 0.11608136f, 
    0.00915788f, 0.12358736f, 0.25451007f, 0.03976763f, -0.07974147f, -0.06979405f, -0.00872285f, -0.01671940f, 
    0.05379568f, 0.13420439f, 0.08199555f, -0.12168529f, 0.47371167f, -0.07185788f, 0.00431983f, -0.10865144f, 
    -0.00721629f, 0.15185350f, -0.02162556f, 0.04368600f, 0.14250302f, -0.11443356f, -0.03169864f, -0.06887422f, 
    -0.11530718f, 0.07414658f, -0.03929645f, -0.06958557f, 0.02973323f, -0.06452600f, -0.14115708f, 0.00802880f, 
    0.03186510f, 0.02494662f, 0.01214864f, 0.06526274f, -0.39720705f, 0.08973051f, 0.04413453f, 0.16961166f, 
    0.12101247f, -0.09716915f, 0.07658058f, 0.02218781f, 0.05523391f, 0.01171022f, 0.06343378f, -0.08818105f, 
    0.16030325f, -0.10833924f, 0.12725534f, -0.02438443f, 0.12508927f, 0.12373062f, -0.19496469f, -0.04543143f, 
    -0.02686197f, 0.01775191f, 0.09891362f, -0.19134228f, -0.00311249f, 0.21078230f, 0.17438625f, 0.00500335f, 
    -0.00368215f, -0.04369474f, 0.07654783f, 0.04809500f, -0.00645133f, 0.04296474f, -0.09579997f, 0.15664227f, 
    0.20433252f, 0.03733149f, 0.01649519f, 0.09858050f, 0.06613564f, 0.11003090f, 0.03742348f, -0.01671897f, 
    -0.00024734f, 0.01189016f, -0.14650789f, -0.08554064f, 0.04385731f, 0.18747562f, -0.23018704f, -0.07466307f, 
    0.12292499f, 0.02530506f, -0.04572905f, -0.10019805f, -0.08953994f, 0.03322228f, 0.10972661f, 0.06778848f, 
    0.64353389f, -0.04237031f, 0.15313938f, -0.16543868f, 0.01637389f, -0.04484767f, -0.00356813f, -0.07793846f, 
    0.04327203f, -0.02863134f, -0.07297833f, 0.06591903f, -0.05479505f, -0.06435528f, 0.03485803f, -0.04108493f, 
    -0.13117392f, -0.10656630f, -0.02420498f, 0.06866518f, -0.04287328f, 0.09252273f, 0.16498901f, 0.14093839f, 
    0.33334249f, -0.03262759f, 0.10945874f, -0.02877274f, -0.00862625f, 0.06794287f, -0.04117753f, -0.17027211f, 
    -0.06900095f, -0.07703601f, 0.00844201f, -0.02621000f, -0.00414738f, -0.01269601f, -0.04646452f, 0.10974431f, 
    0.16687877f, 0.09973553f, -0.07126634f, 0.01025700f, 0.08806973f, -0.06758483f, -0.11862909f, 0.00165866f, 
    -0.03925327f, 0.31799445f, 0.02745819f, -0.18449751f, -0.04179879f, -0.01655675f, -0.00867838f, 0.01649493f, 
    0.01431419f, 0.02160005f, -0.06670085f, -0.06026219f, 0.17753808f, 0.14322147f, 0.05938211f, 0.14425239f, 
    -0.03155406f, 0.12052201f, 0.04060930f, -0.16395237f, -0.06946567f, 0.21044752f, 0.03366775f, 0.12691914f, 
    0.15934123f, -0.01838234f, 0.19499606f, 0.06361664f, -0.17633222f, -0.02649513f, 0.05658472f, -0.02497217f, 
    0.00106279f, -0.07262033f, -0.03571613f, -0.02117951f, -0.09097435f, -0.13531454f, -0.11403379f, 0.04030729f, 
    0.18511444f, 0.14513414f, 0.00466213f, 0.08352507f, 0.18705367f, -0.22857213f, -0.15012148f, 0.05352860f, 
    0.07465672f, 0.13394721f, 0.08690158f, -0.06256658f, -0.04157625f, -0.05401792f, 0.06879905f, -0.00431801f, 
    -0.00964900f, -0.32332000f, -0.06445989f, -0.06329139f, 0.33748356f, 0.01669055f, 0.01788750f, -0.05006897f, 
    0.04898736f, -0.05104177f, -0.06736126f, 0.00036249f, 0.08246715f, 0.05425174f, -0.02181423f, 0.03155620f, 
    -0.06450436f, 0.03680277f, -0.16236316f, -0.01518159f, 0.07755977f, -0.07159746f, 0.15744695f, -0.07344293f, 
    -0.00272965f, 0.07542455f, 0.04332227f, 0.10076258f, 0.01028540f, 0.20067064f, 0.15121256f, 0.27669758f, 
    -0.07568650f, 0.14159200f, -0.00690196f, -0.03554817f, 0.12759249f, 0.11753408f, 0.17577393f, 0.04148057f, 
    0.08650648f, -0.00434952f, -0.27260554f, 0.03494584f, -0.08665795f, 0.12073759f, -0.06183811f, 0.00638805f, 
    0.01047247f, 0.04276264f, 0.15621968f, -0.14696708f, 0.44694534f, 0.03177132f, -0.00431250f, -0.03247671f, 
    -0.13358718f, 0.16958630f, 0.05914255f, 0.04897568f, 0.01372387f, -0.02177868f, 0.06622161f, 0.08750285f, 
    0.39453474f, 0.03156675f, 0.00467458f, 0.04695152f, 0.02353418f, -0.13220437f, 0.03999564f, -0.06553081f, 
    -0.10223553f, -0.07225654f, 0.02408955f, -0.16602029f, 0.40323824f, 0.16468145f, -0.11605896f, 0.17485425f, 
    0.10313036f, -0.04583272f, -0.06949613f, 0.04513305f, 0.14023721f, 0.02452543f, -0.01457042f, 0.02683353f, 
    0.28987530f, 0.24635565f, -0.08296347f, -0.02937958f, 0.06451113f, 0.03773911f, -0.21556629f, 0.17395066f, 
    0.04526104f, -0.17516115f, -0.13526729f, 0.19696087f, 0.03135740f, 0.05924169f, 0.00951070f, -0.02796793f, 
    0.04952345f, -0.01545181f, 0.08034469f, 0.02043612f, 0.03945711f, 0.12132592f, -0.11435439f, 0.05004579f, 
    0.18033463f, -0.00174949f, -0.20227161f, 0.00879981f, -0.12503965f, -0.06388155f, -0.07491709f, -0.02951926f, 
    0.00424696f, 0.15658891f, -0.27604896f, -0.05684286f, 0.07382043f, 0.03932957f, 0.04467799f, -0.06213908f, 
    -0.12347939f, -0.10420437f, -0.24576126f, -0.05548067f, -0.06605055f, 0.20887765f, 0.08463058f, -0.05672403f, 
    -0.22491165f, -0.03231435f, -0.10836388f, -0.17207637f, 0.09221596f, -0.07049178f, -0.04460743f, 0.10439867f, 
    0.07630556f, 0.04324831f, 0.05616536f, 0.06249651f, 0.21265039f, 0.15472789f, -0.00416879f, 0.19285475f, 
    -0.07889675f, -0.06135264f, -0.01440756f, -0.23788165f, -0.16341753f, 0.01158529f, -0.10422116f, 0.08727611f, 
    0.19168276f, 0.31055480f, -0.27837855f, 0.27769232f, -0.05532735f, 0.18097091f, -0.07970213f, -0.13131700f, 
    -0.09450401f, -0.03720975f, 0.03477013f, -0.06463203f, -0.03659895f, -0.06990993f, -0.05638950f, 0.08393893f, 
    0.18223152f, -0.07944265f, 0.07310776f, 0.11447112f, 0.04942907f, -0.01808103f, -0.11404356f, -0.11039057f, 
    -0.22623345f, 0.09436803f, 0.09564892f, -0.22124197f, 0.16535711f, -0.00693541f, 0.03738997f, 0.01502936f, 
    -0.10686118f, -0.06399121f, 0.09935097f, 0.09691751f, 0.10153944f, 0.10215013f, -0.01524892f, 0.11817192f, 
    0.09623682f, -0.00071533f, 0.06624896f, -0.05374211f, -0.13817818f, 0.19392855f, 0.11419898f, -0.01624412f, 
    -0.01094401f, 0.11101506f, 0.24179874f, -0.09407165f, -0.05567925f, 0.05657094f, 0.04247152f, 0.01335330f, 
    -0.03823172f, -0.13438644f, -0.13144909f, -0.04727066f, 0.51756769f, 0.13705972f, 0.39487100f, -0.03338654f, 
    0.07324637f, -0.01213678f, 0.04555188f, 0.21561497f, 0.07144348f, 0.07685478f, 0.04162578f, -0.08908993f, 
    0.14818868f, 0.19563285f, -0.05253493f, -0.00343147f, -0.10577369f, 0.08281907f, 0.18855160f, 0.17397229f, 
    -0.04059755f, 0.13356413f, -0.16568896f, -0.02668713f, 0.25500554f, -0.15815119f, -0.32290253f, -0.05657072f, 
    0.06578160f, 0.01838551f, -0.03820814f, -0.03236674f, 0.03087823f, 0.04559800f, -0.09531002f, -0.03027302f, 
    0.24867843f, 0.28270003f, -0.12240501f, 0.15766485f, -0.11482226f, 0.00601139f, -0.13557479f, -0.07068665f, 
    -0.00045643f, -0.03692788f, 0.03580305f, 0.29010683f, 0.27464485f, -0.01015817f, 0.13287197f, 0.17338902f, 
    0.07058556f, -0.12275835f, 0.07989640f, 0.05111369f, -0.06919895f, 0.05073462f, -0.08404033f, -0.03618459f, 
    -0.14221518f, -0.03287978f, -0.10683464f, -0.21429937f, 0.17028312f, -0.05198698f, 0.10650346f, 0.09041610f, 
    -0.09257823f, -0.02801219f, 0.05566056f, -0.06905964f, 0.04242988f, -0.05983898f, 0.29746315f, 0.21707456f, 
    0.04380731f, -0.02328759f, -0.06270342f, 0.01702394f, 0.00201164f, -0.02880850f, -0.13213190f, -0.05171226f, 
    0.22275890f, 0.00932625f, -0.16816208f, -0.28614393f, -0.01685740f, 0.01042279f, 0.08018203f, 0.06093332f, 
    0.09089325f, 0.09118274f, 0.03683735f, -0.02777699f, 0.03711846f, 0.02455118f, -0.10966925f, 0.29297835f, 
    0.00226606f, -0.11399272f, -0.02960021f, -0.05396139f, -0.12538376f, 0.21426289f, -0.08680469f, -0.16715592f, 
    -0.17759861f, 0.02967464f, -0.03789043f, 0.09931933f, -0.03862735f, -0.10383929f, -0.00555662f, -0.12728594f, 
    -0.13711905f, 0.21265911f, -0.19218215f, -0.06318476f, -0.06138244f, -0.22102860f, -0.21773265f, -0.01011099f, 
    -0.10532206f, 0.01040860f, 0.01540285f, -0.03330362f, -0.02975454f, -0.16413955f, -0.08903705f, 0.11504500f, 
    0.15439670f, -0.07324900f, -0.18205194f, -0.08166750f, -0.00585466f, -0.12146791f, -0.09455400f, -0.00983116f, 
    -0.06600484f, -0.09938862f, 0.05701914f, -0.02190235f, 0.11106864f, 0.03705644f, 0.11018582f, 0.27069899f, 
    0.04812662f, -0.03990034f, -0.09379808f, 0.02355348f, -0.02808998f, 0.04684225f, 0.20926695f, -0.00769665f, 
    -0.08421349f, 0.03068926f, -0.23337467f, -0.18329369f, 0.07511225f, 0.05969256f, -0.12512295f, -0.11991626f, 
    -0.06426647f, 0.19057399f, -0.13133474f, 0.00296461f, -0.08595894f, -0.02634165f, 0.25415424f, -0.04469175f, 
    0.03608098f, 0.00332174f, 0.13368022f, 0.04399437f, -0.19125859f, 0.01987696f, 0.02398913f, 0.00788396f, 
    -0.16955431f, 0.08630303f, -0.02288266f, 0.02675741f, 0.07406323f, -0.07505798f, 0.15655509f, 0.21529067f, 
    0.08674411f, -0.13369206f, 0.02535100f, 0.04974087f, -0.21240781f, -0.00929178f, 0.06656413f, -0.32595956f, 
    0.06379022f, 0.06937294f, 0.05828778f, 0.10157690f, 0.06399861f, 0.01230735f, -0.06642572f, -0.08169069f, 
    0.23787564f, 0.18397425f, 0.16200621f, -0.04890112f, -0.00143944f, 0.07900210f, 0.05008722f, 0.11134996f, 
    0.11983961f, 0.00809462f, 0.12280989f, 0.03932772f, 0.05958530f, 0.25266165f, -0.32436335f, 0.07336453f, 
    -0.15915546f, 0.05483278f, -0.02942805f, -0.02032948f, 0.07790837f, 0.02373553f, -0.06383190f, 0.09044185f, 
    -0.17265345f, -0.24196893f, 0.00054442f, 0.07129907f, 0.11872267f, -0.00178166f, -0.03106198f, -0.09918208f, 
    0.12585804f, -0.02286339f, 0.01767851f, 0.04037281f, 0.12879042f, -0.11818613f, -0.06579532f, -0.08010227f, 
    0.07867036f, 0.11569729f, 0.06052225f, -0.04029275f, -0.01234115f, 0.01397176f, -0.03764537f, 0.13018090f, 
    0.18469766f, -0.09077685f, -0.22324331f, 0.17310959f, -0.11842655f, 0.18111572f, -0.17626479f, -0.02802574f, 
    -0.03974323f, 0.06220343f, -0.02222553f, 0.04873553f, -0.18282148f, 0.07178812f, 0.05605024f, 0.00380292f, 
    0.19667929f, 0.00161142f, -0.06958482f, 0.03267640f, -0.00717977f, 0.10218991f, -0.03790500f, 0.03606483f, 
    0.00526319f, 0.05058968f, -0.15216199f, 0.00179744f, 0.18391307f, -0.01893807f, 0.12580355f, -0.01391033f, 
    0.11445798f, 0.09666158f, 0.04485111f, 0.10301837f, 0.05490292f, -0.03974550f, 0.08752032f, 0.03025929f, 
    0.06531470f, 0.13903710f, -0.08726520f, -0.16447124f, 0.02275755f, 0.16035683f, 0.07395513f, -0.01782570f, 
    0.02543930f, -0.24666691f, -0.02821002f, 0.16153046f, 0.05876144f, -0.08074106f, 0.11144498f, 0.14813967f, 
    -0.03307407f, -0.03405430f, -0.04047797f, -0.07290047f, 0.03516089f, -0.01125999f, -0.12760147f, 0.27438539f, 
    -0.07611058f, -0.00778117f, -0.03443397f, -0.12858449f, -0.00594325f, -0.12722462f, 0.08150936f, -0.02633200f, 
    0.35775459f, 0.22983606f, 0.22536846f, -0.14496921f, -0.06679236f, -0.00163206f, 0.00594439f, -0.01859112f, 
    0.03968412f, 0.01725599f, -0.16013280f, 0.08613946f, 0.08523938f, 0.05431240f, -0.12304697f, 0.07129194f, 
    0.10410972f, 0.03948239f, 0.12090203f, 0.00568501f, -0.06245313f, -0.19560191f, 0.03241264f, 0.12169701f, 
    -0.27472562f, 0.08444156f, 0.19317156f, -0.07557870f, 0.06084276f, 0.04384640f, 0.11455715f, -0.09995580f, 
    0.06943749f, -0.08412774f, 0.03025475f, -0.00987762f, -0.25348410f, 0.27993563f, -0.15555370f, 0.12652859f, 
    -0.18102726f, 0.03147101f, 0.11464814f, -0.12340884f, 0.06902325f, -0.05744366f, 0.09577047f, -0.00302923f, 
    0.08227744f, -0.12777522f, -0.11286290f, 0.08123057f, 0.05797550f, 0.07278969f, -0.01650481f, 0.04356800f, 
    0.09590932f, 0.14297780f, 0.11847924f, 0.07653654f, 0.38363490f, -0.06260738f, 0.15852997f, 0.19582003f, 
    -0.04403774f, -0.02177315f, 0.10910439f, 0.10157944f, -0.13853322f, -0.01864747f, -0.04474944f, -0.06320829f, 
    -0.06779990f, -0.00741902f, 0.01074558f, 0.00897927f, -0.05402246f, 0.14631380f, 0.00609913f, -0.01038158f, 
    0.03897662f, 0.00821437f, -0.05386264f, 0.00735257f, 0.31286582f, -0.03200418f, -0.16359779f, -0.00234452f, 
    0.00493108f, -0.14603245f, 0.06917859f, 0.00367281f, 0.00559316f, 0.07508395f, 0.03474777f, 0.06409340f, 
    0.00420022f, 0.05920096f, -0.02619589f, -0.00265685f, -0.15296923f, 0.23557469f, -0.01405420f, 0.02704287f, 
    0.14648767f, -0.02077698f, -0.01762126f, 0.07202213f, -0.21176602f, -0.04437026f, 0.10974985f, 0.05736081f, 
    -0.05507570f, -0.13879468f, 0.09886982f, 0.06176476f, 0.06487481f, -0.12030362f, -0.07117977f, 0.05497628f, 
    0.05984322f, -0.21158129f, 0.03717369f, 0.05182075f, 0.00857352f, 0.01686243f, 0.21124706f, -0.00865867f, 
    0.10277680f, 0.05322274f, 0.13463446f, 0.00433109f, 0.12560569f, -0.08796159f, -0.01493181f, -0.08251521f, 
    -0.07427286f, 0.00606902f, 0.06619472f, 0.07873531f, -0.00378895f, -0.06645636f, 0.08989013f, -0.00593282f, 
    -0.13229269f, -0.00823979f, 0.01801254f, -0.08231040f, -0.00098874f, -0.01900441f, -0.12118614f, -0.04942278f, 
    0.07788514f, 0.08913625f, 0.03667083f, 0.03164183f, -0.31676772f, 0.08767065f, -0.10686812f, 0.12175373f, 
    0.10049682f, -0.08071656f, -0.00568169f, 0.16304591f, -0.12057271f, -0.00574429f, -0.05731745f, -0.13520698f, 
    0.03547508f, -0.12164858f, -0.02815868f, -0.16405383f, 0.03409772f, -0.07533526f, 0.02594648f, 0.00749802f, 
    0.05188558f, 0.08527979f, 0.05409800f, 0.05710562f, -0.35187265f, 0.04477808f, 0.02403661f, -0.12351891f, 
    0.06489059f, -0.02931841f, -0.12950280f, 0.13872589f, -0.08409756f, 0.00049450f, 0.09068375f, -0.08242609f, 
    0.25441867f, -0.01900603f, -0.02476202f, -0.02681985f, 0.23671331f, 0.06406758f, 0.07900758f, 0.07100420f, 
    0.22649631f, 0.11182103f, 0.01535653f, -0.01983199f, -0.01352293f, -0.14883830f, 0.01402960f, -0.01131603f, 
    0.00040549f, -0.08891797f, 0.08297174f, 0.10555480f, -0.00158136f, -0.01024053f, 0.03483408f, 0.00913373f, 
    0.22738120f, -0.04886736f, -0.05887802f, -0.08060848f, 0.03552688f, 0.04848827f, 0.06863040f, 0.01584589f, 
    -0.05181603f, 0.03065022f, 0.06340042f, 0.05210239f, 0.13512290f, -0.09239181f, -0.03997272f, 0.28168321f, 
    0.14177197f, -0.02415353f, 0.08138324f, -0.19262481f, 0.11192112f, 0.07171123f, -0.03692123f, -0.00598520f, 
    -0.27844498f, 0.14668068f, 0.04695575f, -0.34445506f, -0.00894729f, 0.02295397f, -0.02582758f, 0.01914973f, 
    -0.09081864f, 0.04233331f, 0.00081946f, -0.20099193f, -0.08558936f, 0.11762726f, 0.31664255f, -0.31779060f, 
    0.18866827f, -0.04154818f, 0.09428944f, 0.12211597f, -0.02883283f, -0.02111242f, -0.09851047f, -0.17630379f, 
    0.18714800f, 0.08125106f, 0.18854794f, 0.11287490f, -0.02608837f, 0.01298306f, -0.03385162f, 0.04332153f, 
    0.07689456f, 0.03107056f, 0.09005436f, 0.12500064f, 0.24143124f, 0.09886923f, 0.25231275f, 0.51315558f, 
    0.09280833f, -0.08913803f, -0.11605041f, 0.05327164f, 0.00040755f, 0.06161200f, 0.00190792f, -0.08042760f, 
    -0.19375926f, 0.02821693f, -0.07508617f, 0.28631914f, -0.01644294f, 0.03903513f, 0.08756379f, 0.03658258f, 
    -0.02225041f, 0.06674002f, -0.02612607f, 0.01472026f, -0.06882264f, -0.03862363f, -0.06669357f, 0.10951982f, 
    0.09548634f, 0.14721090f, -0.00753837f, -0.01911114f, -0.00335445f, -0.01836695f, 0.09097617f, 0.01250896f, 
    0.32186586f, 0.00744952f, -0.05843436f, 0.12677705f, 0.06214870f, -0.06188356f, 0.07759489f, -0.05505874f, 
    -0.00663957f, 0.01798361f, 0.11700394f, 0.03268841f, -0.31722346f, 0.10037480f, 0.09249833f, -0.11272011f, 
    0.16021141f, 0.00098427f, -0.08203750f, -0.00008867f, -0.02063957f, 0.06037695f, -0.08717126f, 0.09413344f, 
    0.08976306f, -0.09550753f, 0.06748880f, 0.13828559f, 0.12633993f, 0.05154251f, -0.06821453f, -0.18343210f, 
    0.18385589f, 0.10564795f, 0.16682927f, 0.08811941f, -0.02968560f, 0.05863519f, -0.08615800f, 0.36459211f, 
    0.17496479f, 0.14883898f, 0.02035571f, -0.07884701f, -0.01475337f, -0.05674851f, 0.00217110f, -0.09757695f, 
    -0.10670453f, -0.02607380f, -0.04252011f, -0.29352856f, -0.04213049f, -0.02437566f, 0.04941965f, -0.07143809f, 
    -0.08673159f, -0.20379785f, 0.08604181f, -0.31837222f, 0.21610676f, 0.06170928f, -0.18683425f, 0.32541358f, 
    0.02716498f, 0.12199857f, -0.10216730f, -0.10580988f, 0.06920937f, -0.02568355f, 0.01966902f, -0.14064540f, 
    0.10398900f, -0.12779637f, 0.27808011f, 0.12840363f, 0.03861970f, -0.00531297f, 0.07065517f, 0.09161529f, 
    0.02938266f, 0.03063227f, -0.08083577f, 0.02546638f, 0.25852388f, 0.05225207f, -0.05983085f, 0.45508072f, 
    -0.08654799f, -0.02013548f, -0.18660505f, -0.02721551f, -0.10863279f, -0.08268302f, 0.16369772f, 0.18523858f, 
    -0.08407535f, 0.19032061f, 0.10584979f, 0.35722789f, -0.02311535f, 0.01066008f, -0.21717124f, 0.10150687f, 
    0.33816093f, -0.05838883f, 0.04709870f, -0.11701992f, -0.16241331f, -0.16032027f, 0.08716524f, 0.38005057f, 
    -0.22612277f, 0.02814422f, 0.15623499f, -0.00594009f, 0.05601605f, 0.11606887f, 0.12954794f, 0.00122906f, 
    0.02265953f, 0.07967931f, -0.05496527f, 0.05207380f, 0.05415140f, 0.08173737f, 0.07335121f, 0.02831687f, 
    0.11308675f, 0.13655652f, 0.13507131f, 0.14472839f, -0.30402860f, 0.35376593f, 0.01648644f, 0.23460893f, 
    0.03654825f, 0.14914139f, 0.10972929f, -0.07806170f, 0.00700523f, -0.12138384f, 0.06228537f, -0.08384249f, 
    0.30842021f, 0.18613836f, 0.16329572f, 0.05209582f, -0.08649513f, 0.01251107f, 0.00018762f, -0.09844954f, 
    -0.09794722f, 0.10627472f, 0.11047761f, -0.06040955f, -0.32355002f, -0.23857839f, 0.05296913f, 0.05341956f, 
    0.08205219f, -0.08952728f, 0.05885805f, 0.00235380f, -0.09916466f, 0.08007718f, 0.07045721f, 0.18723001f, 
    0.26362991f, -0.08991624f, 0.16357684f, 0.30953947f, 0.08826218f, 0.19348943f, 0.04135891f, -0.06826019f, 
    -0.00151752f, 0.19072483f, 0.02716907f, -0.05027849f, -0.34041035f, 0.36427441f, 0.17998168f, -0.11123201f, 
    -0.09527776f, -0.14199097f, 0.06968182f, -0.20487213f, 0.03310215f, -0.02575268f, 0.12479814f, -0.06214855f, 
    -0.20024274f, -0.09239873f, -0.01480547f, -0.06101173f, 0.00702554f, 0.11726250f, 0.05052470f, -0.07076767f, 
    0.15234804f, -0.00642757f, 0.04922450f, 0.22713186f, 0.07848878f, -0.05396063f, 0.10332152f, 0.31000504f, 
    -0.13878939f, -0.13215345f, -0.10402428f, -0.00543758f, 0.00765925f, -0.11084316f, 0.00252758f, 0.13842560f, 
    -0.13207440f, -0.15861040f, 0.03182004f, 0.10372265f, -0.02847423f, 0.12805472f, 0.04434270f, -0.03765588f, 
    -0.01730391f, 0.03116976f, -0.00171515f, 0.06409977f, -0.04417308f, 0.04391533f, -0.03386516f, 0.06875362f, 
    0.05136811f, 0.03881950f, -0.04960112f, -0.02228692f, -0.01561886f, 0.00413608f, 0.00993366f, -0.03085410f, 
    -0.24687995f, 0.15759397f, -0.03961905f, -0.15868430f, 0.10270466f, -0.06536111f, 0.06478530f, -0.02299429f, 
    0.05401559f, 0.06368309f, 0.00663430f, 0.05606265f, -0.36200839f, 0.01227549f, 0.27538851f, 0.04235224f, 
    0.06439598f, -0.00891350f, -0.02644717f, -0.00818430f, -0.04021077f, 0.13290554f, 0.25885090f, 0.03031975f, 
    -0.31681436f, -0.01216984f, -0.15701017f, -0.21331736f, 0.22378129f, 0.06972072f, -0.06590986f, -0.00449289f, 
    0.14665547f, 0.06494387f, -0.06984838f, -0.00491808f, -0.08290218f, 0.18040942f, -0.06375621f, 0.26028371f, 
    -0.13849877f, 0.04314581f, 0.14324987f, 0.18623537f, 0.05213559f, -0.01011846f, -0.04727765f, -0.11236587f, 
    -0.12756826f, -0.18686807f, -0.08297461f, -0.14434321f, 0.04917799f, 0.05491946f, 0.08912452f, -0.04015666f, 
    -0.05445461f, -0.10427226f, 0.03552678f, -0.01363619f, -0.07060805f, 0.26276180f, -0.26776692f, 0.10221381f, 
    0.02285095f, 0.03895836f, -0.06016517f, -0.20449047f, 0.12323362f, 0.11738565f, -0.06421715f, -0.00362545f, 
    0.16357990f, -0.00930847f, 0.03639484f, 0.00860759f, -0.02572091f, 0.07325482f, -0.17800514f, 0.06117465f, 
    0.03675913f, -0.06126348f, -0.07892725f, -0.00543304f, 0.07550067f, 0.04277539f, -0.02334010f, -0.21763255f, 
    0.05779394f, -0.00871042f, -0.05309466f, 0.12165453f, 0.13678469f, -0.06645525f, 0.02106217f, -0.12614360f, 
    0.27666351f, 0.15937433f, 0.09281880f, -0.06358811f, 0.07438453f, -0.05492365f, -0.01913267f, 0.01146248f, 
    -0.07588695f, 0.04253748f, 0.00907544f, 0.06064729f, -0.11665636f, -0.05409928f, 0.12877686f, 0.07668104f, 
    0.04222837f, 0.07406581f, 0.00456613f, 0.02812784f, -0.07138281f, 0.06180356f, -0.02460692f, -0.07054389f, 
    0.28205499f, -0.10290524f, 0.09097760f, 0.14103912f, 0.10024046f, -0.04152915f, 0.08410899f, -0.05118316f, 
    0.15253288f, 0.16269800f, -0.14739977f, 0.09049746f, -0.22546448f, -0.25607148f, 0.14814383f, -0.12393031f, 
    -0.06120346f, 0.09790824f, -0.02562758f, -0.01998732f, -0.12103742f, 0.06175323f, 0.02823000f, -0.03830703f, 
    0.11951429f, 0.08284754f, 0.07752083f, -0.31851622f, 0.06707858f, 0.18498525f, 0.09775553f, -0.04989275f, 
    -0.16553281f, -0.10397153f, 0.16274236f, -0.07751996f, 0.23639520f, -0.23736846f, 0.02054106f, 0.20172992f, 
    -0.05523010f, 0.05301505f, -0.02214474f, 0.02883158f, 0.03488820f, 0.00370175f, 0.10577824f, -0.12003976f, 
    -0.14574686f, -0.17550112f, -0.13732736f, -0.06799786f, -0.01296451f, -0.01412630f, -0.10591719f, 0.05253578f, 
    0.09943261f, 0.05733556f, 0.24620508f, 0.09620956f, -0.16291329f, -0.11931829f, 0.12610909f, -0.13382377f, 
    0.07183064f, 0.00661611f, 0.04696076f, 0.00694478f, -0.03595577f, -0.10860509f, 0.06732569f, 0.09032633f, 
    0.09851936f, 0.07253522f, 0.14411376f, -0.10610394f, -0.07712163f, -0.02070539f, -0.01080858f, -0.09410884f, 
    -0.02002589f, -0.11725916f, 0.06194570f, -0.10692206f, -0.21375386f, -0.12747014f, 0.11505759f, -0.20901582f, 
    0.14399175f, 0.10311302f, -0.05823118f, 0.05102243f, 0.06557410f, -0.01824473f, 0.04482052f, -0.00566984f, 
    0.08200689f, 0.21746336f, -0.08943134f, 0.04207901f, 0.13815837f, -0.01837071f, 0.06206575f, 0.09333705f, 
    -0.01011816f, 0.10499279f, -0.05968270f, 0.08650282f, -0.10263196f, 0.08144499f, 0.04901824f, -0.11859195f, 
    0.07604942f, 0.11447845f, 0.01751160f, 0.02692147f, -0.03264767f, 0.02711640f, 0.08443592f, -0.00375058f, 
    0.10617582f, 0.04856204f, -0.05318171f, 0.02286603f, -0.02066214f, -0.00383088f, 0.04187978f, -0.04361570f, 
    0.18830505f, 0.02660919f, -0.15263328f, -0.13176410f, -0.28811699f, 0.31623495f, -0.13396221f, -0.00826694f, 
    0.19609648f, -0.12629332f, -0.05991901f, 0.03552570f, 0.06167594f, -0.02278988f, -0.01709001f, 0.11189590f, 
    0.07760568f, -0.06086707f, -0.01996558f, 0.01984301f, -0.13042043f, -0.04368429f, 0.10296630f, 0.06957813f, 
    0.02552429f, 0.03829611f, 0.02152021f, 0.05259747f, 0.44642502f, -0.15726383f, -0.11329203f, -0.16564828f, 
    0.00489029f, 0.03295379f, 0.00358010f, -0.04446555f, 0.00150181f, -0.08291975f, 0.01380859f, 0.07054561f, 
    0.01482849f, 0.12465059f, 0.00365971f, 0.04680442f, 0.17175502f, 0.00621196f, -0.08331399f, -0.07984876f, 
    -0.08968140f, -0.16042341f, -0.02699520f, 0.02880564f, 0.17997810f, 0.03002362f, 0.06054180f, -0.10758229f, 
    0.00611271f, 0.10276233f, 0.10298464f, -0.07501430f, -0.03653337f, -0.11976907f, 0.02046820f, 0.01034443f, 
    -0.18006143f, -0.09968079f, 0.00438163f, 0.00449187f, 0.10623222f, 0.05967287f, 0.17965314f, 0.11871360f, 
    0.03559758f, 0.15005814f, -0.04834809f, -0.03050007f, -0.44113353f, -0.22521150f, 0.12726393f, -0.06595550f, 
    -0.06756966f, 0.05717825f, -0.10384674f, -0.02776479f, 0.07747643f, -0.01914684f, 0.00899742f, 0.08996235f, 
    0.28105983f, 0.10182720f, 0.10112084f, -0.02539952f, -0.05853999f, -0.01647876f, 0.02526778f, -0.02947110f, 
    0.01762686f, 0.03541464f, -0.02933994f, 0.11005685f, -0.24265517f, 0.11381426f, 0.00874489f, -0.24025500f, 
    0.03826503f, 0.01153541f, 0.02787185f, -0.00516021f, -0.06033152f, -0.11656612f, 0.04248924f, 0.11616329f, 
    -0.08204784f, 0.32539371f, 0.01719973f, 0.18629313f, 0.07232204f, -0.06352844f, 0.05262960f, -0.04044114f, 
    -0.01656482f, -0.03205542f, 0.05859850f, -0.03044199f, -0.10344636f, -0.01868945f, 0.13564616f, -0.02553098f, 
    -0.08396148f, 0.21729048f, 0.04195703f, 0.13861269f, 0.08268452f, -0.22644259f, -0.00592266f, 0.12524271f, 
    0.01024406f, -0.41083762f, 0.19903833f, 0.14954618f, 0.12690452f, -0.00448994f, -0.02409754f, 0.00881133f, 
    0.13320008f, -0.08578214f, 0.10730123f, 0.11615584f, -0.09959468f, 0.02755821f, 0.26256299f, 0.09817800f, 
    0.17927764f, -0.07187670f, -0.03577325f, -0.07848297f, 0.00500057f, 0.02819951f, 0.00899508f, -0.02635429f, 
    0.02073583f, -0.00842850f, 0.05421576f, 0.00913146f, 0.08653551f, -0.00511599f, -0.02829385f, 0.03211969f, 
    0.07256587f, 0.14941712f, 0.01971254f, 0.06859700f, -0.15867914f, -0.05073120f, 0.19192840f, -0.10467604f, 
    -0.11045898f, 0.12185510f, -0.03507406f, -0.08498131f, 0.07380035f, 0.02949134f, -0.05933414f, 0.01950145f, 
    0.14286843f, 0.05380212f, 0.11658719f, 0.16531552f, -0.01492412f, -0.00088503f, 0.08594812f, 0.04951660f, 
    0.08842781f, 0.10013001f, 0.14395465f, -0.02327903f, 0.16100389f, 0.20562652f, -0.20386571f, 0.04466612f, 
    -0.01750144f, -0.09143308f, -0.00934489f, 0.02134745f, -0.04149430f, 0.00087644f, 0.07502020f, 0.05061264f, 
    0.24031827f, -0.10257410f, -0.15784116f, -0.06242549f, 0.08270082f, 0.03970114f, -0.01112553f, 0.12734854f, 
    0.16552819f, -0.04901155f, 0.12230558f, 0.07904240f, -0.01586684f, 0.10272361f, -0.24367893f, 0.36410880f, 
    -0.12112750f, -0.09816009f, -0.02793860f, -0.02527065f, -0.05622040f, -0.11467064f, -0.06301645f, -0.04908903f, 
    0.30718926f, 0.06011717f, -0.04710758f, -0.04193186f, 0.11648520f, -0.09459484f, 0.19415794f, 0.11185396f, 
    -0.10495150f, -0.08902965f, 0.08890712f, 0.17964157f, -0.90701574f, 0.03158965f, -0.21873091f, 0.04126661f, 
    -0.07085446f, 0.00818358f, 0.04247191f, 0.04956247f, 0.02578445f, -0.03928987f, 0.08830000f, -0.01651957f, 
    0.07372316f, -0.29931629f, -0.15077724f, -0.13005167f, -0.02549710f, 0.05941011f, 0.04859219f, 0.10924818f, 
    -0.01227280f, -0.00780458f, -0.01341170f, 0.03345691f, 0.23702559f, 0.06765652f, -0.14082512f, 0.05572311f, 
    -0.08872707f, -0.14870329f, 0.13291848f, -0.05660548f, -0.14683335f, -0.03904116f, -0.05219737f, -0.01552316f, 
    -0.74545795f, -0.16198334f, -0.00818785f, 0.36799368f, -0.10352362f, -0.00660418f, -0.06983576f, -0.02269534f, 
    0.10005644f, 0.20649886f, 0.06129166f, 0.00024301f, -0.07577957f, 0.10005157f, 0.07884586f, -0.00657980f, 
    0.09995148f, 0.06854777f, 0.00716238f, 0.01842947f, 0.04142751f, 0.03801128f, 0.20441529f, 0.06013074f, 
    0.15635805f, 0.33870751f, -0.04008776f, 0.07112832f, -0.03684417f, 0.09604044f, 0.14889967f, 0.02076825f, 
    -0.14068198f, -0.15732393f, -0.03520776f, 0.05157646f, 0.11665256f, -0.10958711f, -0.03821399f, 0.09725595f, 
    0.05216682f, -0.13344863f, 0.07477000f, 0.05658874f, 0.19943193f, 0.03877925f, -0.06984976f, 0.00580322f, 
    0.03798350f, 0.04080674f, 0.02637308f, 0.03940914f, 0.11783610f, 0.02618422f, -0.01837787f, 0.00197450f, 
    0.08016496f, 0.05712378f, -0.16544606f, 0.27897602f, 0.30767766f, -0.00663117f, 0.05821395f, -0.21291657f, 
    0.02022583f, -0.04643709f, -0.05955692f, -0.08081523f, -0.05579666f, 0.15187937f, 0.09207006f, 0.02715616f, 
    -0.18290235f, 0.32464716f, -0.02308314f, 0.02026253f, -0.00122616f, 0.07764720f, 0.08587030f, -0.01327737f, 
    -0.01434467f, 0.07294640f, 0.16456161f, 0.12485097f, 0.36630538f, -0.17671917f, 0.11442614f, 0.05022459f, 
    0.20109273f, 0.04861848f, 0.18914413f, 0.01436254f, 0.06441087f, 0.15106034f, -0.03977270f, 0.10204071f, 
    -0.14568514f, -0.39655393f, 0.02328250f, 0.08138189f, -0.06883473f, -0.06604423f, 0.15622444f, -0.07074451f, 
    -0.09604838f, -0.02202890f, -0.07391176f, -0.01556559f, -0.01114677f, -0.09784609f, 0.17715414f, -0.26490387f, 
    0.04934628f, 0.22779049f, -0.07703118f, 0.16510944f, 0.14807950f, -0.12929074f, -0.04080172f, -0.06078562f, 
    -0.17236856f, -0.10646643f, 0.00733060f, 0.15938739f, -0.07295949f, 0.00380269f, -0.14196347f, 0.12456495f, 
    0.14779463f, 0.10159715f, 0.09676545f, -0.05384753f, -0.10748065f, -0.08317781f, -0.31313822f, -0.12114526f, 
    -0.12977850f, -0.11971569f, 0.05081703f, -0.08483808f, 0.10043100f, 0.01039633f, -0.00286278f, -0.09221765f, 
    -0.21532963f, -0.18974778f, -0.00940147f, -0.22341923f, 0.10474166f, 0.01395317f, -0.12274507f, 0.00301973f, 
    0.25877348f, -0.13344626f, -0.07533110f, -0.05938194f, 0.07216975f, 0.12064014f, 0.14902328f, -0.11234582f, 
    -0.07092371f, -0.05918048f, 0.07215942f, 0.06300420f, 0.13214360f, 0.07329816f, -0.05947656f, 0.11538284f, 
    -0.11956167f, 0.26750785f, -0.03961540f, -0.09648247f, 0.03509114f, -0.02860966f, -0.10007528f, -0.06054991f, 
    0.03986436f, 0.01782715f, -0.00553712f, 0.09088361f, 0.51976448f, -0.20661524f, -0.37640712f, 0.03005161f, 
    0.25887293f, 0.02852973f, -0.05557631f, 0.13592042f, 0.00617167f, 0.09539194f, 0.05800301f, 0.01169628f, 
    -0.00158171f, -0.16713957f, 0.12975653f, 0.09632757f, -0.11531651f, -0.07588135f, 0.02702844f, 0.05304183f, 
    -0.02752851f, -0.01169708f, -0.02939123f, -0.05773316f, 0.31275320f, -0.09256515f, -0.15981416f, -0.00943467f, 
    0.09510279f, 0.04865091f, -0.00650423f, 0.01688870f, 0.07787474f, 0.08829915f, 0.10362208f, 0.04933977f, 
    -0.00107022f, -0.11389700f, 0.09833898f, 0.06142898f, 0.08287983f, -0.12256311f, -0.05275958f, -0.12199733f, 
    0.10967365f, -0.12377934f, 0.01128094f, 0.07413094f, 0.03872585f, -0.01615801f, 0.03361314f, -0.11448867f, 
    0.04495768f, 0.11917020f, 0.03771645f, 0.12949947f, 0.10365395f, 0.01094541f, -0.03591483f, -0.01344006f, 
    0.06750926f, -0.02700420f, 0.01673237f, -0.12102018f, -0.03644401f, 0.08292751f, -0.00499297f, 0.12478340f, 
    -0.00411625f, -0.14431918f, 0.20529918f, -0.01737483f, -0.09548963f, 0.04209945f, -0.13752984f, -0.19854060f, 
    -0.05115866f, 0.03403796f, -0.00621009f, -0.05646408f, 0.06777092f, 0.00528646f, 0.02796467f, -0.01709974f, 
    0.09567504f, -0.08383571f, 0.08423973f, 0.05998319f, -0.20719397f, 0.05838222f, 0.18996061f, 0.05491822f, 
    0.10364349f, 0.02971761f, 0.10904987f, 0.08777893f, 0.42408624f, -0.18047120f, -0.07955554f, -0.11053519f, 
    0.08220713f, -0.09151448f, 0.10698244f, -0.03565467f, 0.09073573f, -0.03214997f, -0.01507112f, 0.09629124f, 
    -0.00159877f, 0.02335436f, 0.06245655f, 0.03520127f, 0.00917851f, -0.07156996f, 0.06821018f, -0.00239602f, 
    0.14143454f, -0.14364305f, 0.08266531f, 0.15043329f, 0.16212104f, -0.55773783f, 0.10151523f, -0.26237330f, 
    0.08569650f, -0.07638092f, 0.04280355f, 0.06769440f, 0.06228688f, 0.07987744f, -0.05317787f, 0.07074748f, 
    0.00095590f, 0.00912912f, -0.05645085f, 0.00571266f, 0.03101919f, -0.01528768f, 0.03572266f, -0.00998107f, 
    0.00246709f, -0.02192604f, 0.00150163f, -0.01976055f, 0.02626702f, 0.02097590f, -0.02850635f, 0.00059458f, 
    -0.02251097f, 0.02402594f, 0.00261781f, -0.00866991f, -0.03253061f, 0.00616230f, -0.02273213f, -0.00527362f, 
    0.01869464f, -0.03189735f, 0.00342070f, -0.04390493f, -0.00306949f, -0.03851974f, 0.00985765f, -0.02037382f, 
    -0.04333947f, -0.01674043f, -0.03178312f, -0.02082642f, -0.05825038f, 0.02552664f, 0.03851306f, -0.00206017f, 
    -0.03837176f, -0.02279308f, -0.02088640f, 0.02759090f, -0.05991231f, -0.01783707f, -0.02221088f, -0.04546436f, 
    0.03391061f, -0.01584988f, 0.02665609f, -0.01514297f, 0.00407640f, -0.04492788f, 0.02719219f, 0.02665025f, 
    -0.01365047f, 0.03564746f, 0.01833546f, 0.01066371f, 0.04038581f, 0.02902265f, -0.00747418f, 0.01652266f, 
    -0.04016165f, -0.01205749f, 0.04101997f, 0.03887860f, -0.01383887f, -0.03780825f, 0.02264598f, 0.03229782f, 
    -0.05791242f, -0.03581728f, -0.03696614f, -0.04518891f, -0.00045034f, 0.04229325f, 0.02748156f, 0.00337275f, 
    -0.00509657f, -0.05441356f, 0.02482270f, -0.06165932f, 0.03647532f, -0.03088638f, -0.02987614f, -0.01662260f, 
    -0.00381666f, -0.00568051f, -0.00006129f, 0.02942080f, -0.00029565f, -0.05928223f, -0.06329150f, 0.00140341f, 
    -0.00475843f, -0.02453479f, -0.02501707f, 0.01421472f, -0.05348247f, -0.05675448f, -0.03717615f, -0.01966651f, 
    -0.06264851f, 0.01296790f, 0.00837900f, 0.03164366f, -0.03092846f, 0.03877552f, -0.03902913f, -0.04606781f, 
    -0.04419078f, 0.03056923f, 0.01321794f, -0.02705240f, 0.00486297f, -0.01945505f, -0.04143283f, 0.00000449f, 
    -0.02344887f, 0.02804361f, -0.04373382f, 0.03987842f, -0.01145410f, -0.00679268f, 0.02129654f, -0.03997092f, 
    0.03339557f, 0.02708175f, 0.02135333f, -0.05896192f, -0.01085372f, -0.00731549f, 0.04134682f, 0.00543346f, 
    0.00864466f, -0.03232000f, -0.02934758f, -0.01948328f, -0.04252856f, -0.01729669f, -0.01291118f, 0.03873884f, 
    0.03417897f, -0.03503262f, 0.03396546f, 0.00679885f, -0.02174247f, 0.02396780f, -0.04104125f, -0.01865012f, 
    -0.03609449f, -0.02233500f, 0.03189925f, 0.03520840f, 0.02748717f, 0.03343975f, -0.04520096f, 0.00538287f, 
    0.00940853f, -0.05717078f, 0.03567086f, -0.01717349f, -0.04202863f, 0.03498692f, 0.04603419f, -0.05380411f, 
    0.01338915f, -0.01761492f, -0.00434965f, -0.02307615f, -0.04155855f, -0.00116345f, 0.04077035f, 0.03028366f, 
    -0.00242109f, -0.02721423f, 0.04880352f, -0.04668429f, -0.04920626f, 0.01339530f, -0.05136800f, -0.02467228f, 
    -0.02477921f, -0.02660583f, -0.01158203f, -0.01195509f, -0.05954920f, 0.00993564f, 0.02177578f, -0.02192639f, 
    0.00993374f, -0.02075192f, 0.01170705f, 0.02824858f, 0.03682148f, 0.01076290f, -0.04576482f, -0.02094853f, 
    -0.05886929f, -0.05597195f, -0.05053506f, 0.02403938f, 0.01919334f, -0.02652824f, 0.00246166f, -0.03359497f, 
    -0.01501683f, -0.00295625f, 0.01491854f, -0.00707793f, -0.02722616f, 0.04549581f, 0.03567495f, 0.02970987f, 
    -0.00067040f, -0.01013447f, -0.05243181f, -0.02823921f, 0.00541510f, 0.03340962f, 0.02826765f, -0.03066355f, 
    -0.05404306f, 0.00060481f, -0.01030132f, -0.02846033f, -0.03400169f, -0.04783978f, -0.04016006f, 0.03692818f, 
    0.03736807f, -0.01496517f, -0.04328755f, -0.01408242f, 0.04313591f, -0.04992848f, -0.03906224f, -0.00206080f, 
    -0.00703293f, -0.03611616f, 0.00646266f, -0.00029789f, -0.03398209f, 0.02020880f, -0.03217826f, -0.04650531f, 
    -0.02621378f, -0.06141967f, 0.00611913f, 0.00985947f, -0.00051308f, -0.03218528f, 0.04116824f, -0.02339092f, 
    -0.02684249f, -0.02300515f, -0.02045157f, -0.00924438f, 0.00918299f, -0.05101980f, 0.03502826f, -0.00766955f, 
    -0.04921495f, 0.02902952f, 0.02489376f, -0.03855053f, 0.01870132f, 0.01840714f, -0.02192546f, -0.03518932f, 
    -0.02821819f, 0.03780912f, 0.04320527f, 0.01665260f, -0.00914012f, -0.05873316f, -0.03105530f, -0.00592296f, 
    -0.05223781f, 0.00379527f, -0.02239288f, 0.03540305f, 0.03265472f, 0.01449248f, -0.04249654f, 0.00555716f, 
    -0.03562522f, 0.02437471f, -0.00320035f, -0.03111441f, -0.01930806f, 0.02331579f, -0.01054667f, 0.03930179f, 
    0.03302456f, -0.04007663f, -0.03181599f, -0.01703800f, 0.02370148f, -0.04870098f, -0.02044135f, 0.01575114f, 
    -0.05669948f, 0.00851212f, 0.04619753f, -0.03005012f, -0.03602026f, 0.03241308f, -0.03780834f, -0.03089091f, 
    -0.01781014f, 0.03591745f, -0.05009277f, 0.01997065f, 0.00252315f, 0.01536417f, 0.03087628f, 0.03730952f, 
    0.00137301f, -0.01568148f, 0.02995504f, 0.03095330f, -0.00356894f, 0.02486810f, -0.05199760f, -0.04458212f, 
    0.02509954f, 0.02484973f, 0.01153786f, 0.00971593f, 0.01553090f, 0.03281938f, -0.02137648f, -0.02586293f, 
    -0.00370439f, 0.00005706f, -0.00635959f, -0.00197316f, -0.01397586f, -0.03539176f, -0.00422858f, 0.03618895f, 
    -0.01893306f, -0.06193677f, -0.04016155f, -0.02846640f, -0.02092356f, 0.04258920f, -0.04643280f, -0.05291981f, 
    -0.01470216f, 0.04416119f, 0.00769960f, -0.05457910f, 0.03751002f, 0.02400009f, -0.02860164f, 0.01121283f, 
    -0.00947549f, -0.03588704f, -0.05100584f, -0.04572725f, -0.06177203f, 0.02086086f, -0.04013660f, -0.05079509f, 
    -0.02885224f, -0.03237168f, 0.03172993f, -0.00704032f, 0.02960194f, -0.00745043f, -0.05045145f, -0.00996251f, 
    0.00285190f, -0.03787807f, -0.00996607f, 0.02025006f, 0.00114713f, 0.01217029f, -0.01566140f, -0.03649805f, 
    -0.02545375f, -0.02604629f, -0.04568152f, 0.00243648f, -0.05155429f, 0.00878193f, -0.01005431f, 0.03227576f, 
    0.03326426f, -0.03975241f, -0.05716962f, -0.04468814f, 0.02675291f, -0.01045362f, -0.02542210f, 0.03728981f, 
    -0.02032087f, -0.01864078f, -0.03382633f, 0.03643989f, -0.02498242f, -0.01910539f, -0.05318267f, -0.03861582f, 
    0.01236171f, 0.01023365f, -0.00295261f, -0.01682098f, 0.01491720f, 0.01238474f, -0.05534364f, 0.01130845f, 
    -0.04587485f, 0.00668893f, 0.03204058f, -0.05246018f, -0.05645876f, 0.02314562f, 0.03384677f, -0.00481511f, 
    0.01230115f, 0.03989494f, 0.02053241f, 0.00608933f, 0.02659376f, -0.00266009f, -0.02429073f, -0.01330606f, 
    0.03622101f, 0.03276984f, 0.00270087f, 0.02270588f, -0.00380277f, -0.02688564f, -0.06331302f, -0.03649247f, 
    -0.01180961f, -0.03639048f, 0.00520976f, -0.04671159f, -0.01122698f, -0.02022012f, -0.04281887f, -0.01133539f, 
    0.01271999f, -0.02264388f, 0.01610005f, -0.00504250f, -0.02673408f, -0.00043202f, -0.01505813f, 0.03957642f, 
    0.00489613f, -0.05852675f, -0.04982542f, -0.00743623f, -0.03117410f, 0.02123440f, -0.05404583f, 0.01138151f, 
    -0.04017912f, -0.01727676f, -0.05975593f, -0.00374813f, -0.00294243f, 0.02500634f, -0.03276602f, -0.02357688f, 
    0.00526419f, -0.03938234f, 0.02477165f, 0.01770450f, 0.00011905f, -0.02934548f, 0.00283326f, 0.03406402f, 
    -0.00164286f, 0.02500861f, 0.02583991f, -0.01614708f, 0.02341602f, 0.00097956f, 0.00021611f, 0.02223585f, 
    0.03016523f, -0.04407561f, 0.03697187f, 0.03485086f, 0.01875531f, -0.05136865f, -0.04610265f, -0.03770927f, 
    -0.06205522f, 0.02878883f, -0.03427650f, -0.00939743f, -0.02985764f, 0.00324116f, -0.01902571f, 0.04015619f, 
    -0.02717085f, -0.01954976f, 0.03923047f, 0.02016796f, -0.00877154f, -0.03134397f, -0.01323284f, 0.02172048f, 
    0.02956368f, -0.05327937f, -0.02799193f, 0.03480896f, -0.03712109f, -0.02607761f, 0.02334466f, -0.00381370f, 
    0.04260761f, 0.01272011f, -0.03724708f, 0.00829207f, 0.03213082f, -0.01030497f, -0.02074677f, 0.03795147f, 
    0.03059284f, 0.03505208f, -0.01424195f, -0.05654331f, -0.04288818f, 0.01042400f, -0.01178681f, 0.00442351f, 
    0.01716669f, 0.00979732f, -0.01246500f, -0.04007288f, 0.01294323f, 0.03384637f, -0.03864736f, -0.03292056f, 
    -0.05048448f, 0.01438558f, 0.01317665f, 0.02780310f, -0.02085748f, -0.04494195f, 0.01497670f, 0.03620758f, 
    0.04206770f, 0.05350338f, 0.01736133f, -0.04911833f, 0.03969581f, -0.01142958f, -0.04331379f, 0.01133636f, 
    0.01044816f, 0.02196220f, 0.01916418f, 0.01502479f, -0.02853605f, 0.01626370f, -0.05167919f, 0.05033563f, 
    0.03320078f, 0.03979796f, -0.00000198f, 0.02261235f, -0.04673445f, 0.03776258f, -0.01942376f, 0.02278234f, 
    0.01648809f, 0.01584006f, 0.01292247f, 0.04026441f, 0.04080192f, -0.05361945f, -0.03753119f, -0.02839091f, 
    -0.02323722f, -0.03812212f, 0.02579568f, -0.03748787f, 0.04267750f, 0.03791201f, -0.03518340f, 0.00412102f, 
    0.02565332f, 0.02690209f, -0.00152104f, 0.01553553f, -0.04644497f, 0.00041429f, -0.00580940f, -0.04419445f, 
    -0.00172810f, 0.01357611f, -0.04117180f, 0.03404710f, -0.02013691f, -0.04282549f, 0.04224966f, 0.00645341f, 
    0.00024790f, -0.02645036f, -0.02564630f, -0.05477214f, -0.02026766f, -0.04512636f, -0.03083648f, -0.02982195f, 
    -0.05549027f, 0.03086162f, -0.01055599f, 0.03430875f, 0.02945623f, -0.03827925f, 0.04184898f, -0.03769272f, 
    -0.00443501f, 0.03968185f, 0.02057916f, 0.03862716f, -0.04956064f, 0.02643602f, -0.04350815f, 0.03205457f, 
    -0.00723991f, -0.05174679f, 0.01532642f, -0.02750209f, 0.02421183f, -0.05573143f, -0.04418514f, -0.06074537f, 
    -0.03916757f, 0.02825853f, 0.02010309f, 0.01671754f, -0.01675420f, 0.00967356f, 0.01539886f, 0.01306873f, 
    -0.04888367f, -0.04288286f, -0.00050994f, 0.02466038f, 0.04270370f, -0.05047831f, 0.00801741f, -0.00128732f, 
    -0.03800606f, 0.01516169f, -0.00238103f, 0.01300636f, 0.01172017f, 0.03266118f, 0.03242564f, 0.01628350f, 
    -0.05224790f, 0.01808668f, 0.00030028f, -0.02689764f, -0.03383911f, 0.02285450f, -0.02725771f, -0.02265728f, 
    -0.01318194f, -0.01371328f, -0.00340465f, -0.04004819f, -0.01506406f, 0.00057787f, -0.03397973f, -0.00622792f, 
    -0.01971359f, -0.02904206f, -0.02550909f, -0.03726978f, 0.03698031f, 0.00864262f, 0.03106736f, -0.05039895f, 
    0.01201721f, -0.03710172f, -0.00333281f, 0.01506319f, -0.01470078f, -0.02191949f, -0.05975720f, -0.02587841f, 
    0.02579898f, 0.03012954f, -0.02750106f, -0.02739150f, -0.00265565f, -0.01333927f, -0.04169618f, -0.01883982f, 
    0.00029578f, 0.02627363f, -0.00265727f, -0.05759790f, -0.04460698f, 0.03759672f, 0.01260216f, 0.03556219f, 
    -0.05155503f, 0.03144321f, -0.03104361f, -0.04777175f, -0.01390243f, 0.00017165f, -0.03015035f, -0.02009925f, 
    -0.00479487f, -0.01784784f, 0.04285581f, 0.02218409f, 0.03218270f, 0.03661454f, -0.00189009f, 0.02537137f, 
    -0.04603134f, -0.03967300f, -0.03679023f, -0.05055253f, 0.01576725f, -0.02878073f, -0.03942795f, 0.01122732f, 
    0.04307498f, 0.01387459f, 0.01048538f, -0.02988119f, -0.01859979f, 0.01606847f, 0.00621706f, 0.05366728f, 
    0.03047513f, 0.03302984f, -0.00177957f, -0.04787188f, 0.03013637f, -0.03512664f, -0.01973371f, 0.03323813f, 
    -0.05698350f, 0.00403500f, -0.03020426f, -0.04716628f, -0.05409526f, -0.04787097f, 0.01899246f, 0.03589908f, 
    -0.04026988f, -0.01302549f, 0.00136020f, 0.02993265f, -0.00100834f, -0.00446159f, -0.01161243f, 0.00581976f, 
    0.25014722f, -0.26001859f, 0.05907537f, 0.21727791f, 0.17850392f, -0.01725042f, 0.12449322f, 0.02500863f, 
    0.18191661f, -0.00899437f, 0.01035343f, 0.10997041f, 0.33598879f, -0.33132452f, 0.00437464f, 0.24459776f, 
    -0.22427917f, 0.08591954f, -0.08436254f, -0.21671213f, 0.04096293f, -0.01809319f, -0.02598572f, 0.11352021f, 
    -0.20306638f, -0.03363793f, -0.23841152f, -0.35206082f, -0.03647972f, -0.02508552f, 0.06523772f, 0.10327128f, 
    0.00964787f, -0.10381536f, 0.12985978f, -0.08318423f, 0.06597659f, -0.55232757f, -0.15308218f, -0.16444427f, 
    -0.03342069f, 0.16206382f, 0.00760602f, 0.01032147f, -0.06358597f, -0.03848839f, 0.13808143f, 0.15165205f, 
    -0.09783676f, -0.16412883f, 0.00007314f, -0.17363413f, 0.22728431f, 0.06610796f, -0.04114977f, 0.02873566f, 
    0.02520573f, -0.02651238f, 0.11737856f, 0.02834265f, -0.04445304f, 0.08262695f, 0.24096744f, -0.02131513f, 
    0.02089029f, -0.07748336f, 0.00615171f, -0.05476877f, 0.03877730f, 0.07957704f, -0.00211084f, -0.00134691f, 
    -0.19767024f, -0.02269086f, -0.04002505f, -0.00828012f, 0.07205638f, 0.15761492f, -0.06826935f, -0.04549990f, 
    -0.02327141f, -0.04760609f, 0.00748720f, -0.07032908f, 0.43027943f, 0.13019246f, 0.10155428f, -0.23176692f, 
    0.12343236f, 0.01227119f, -0.04754951f, -0.01062107f, 0.04353135f, 0.18518944f, 0.14291526f, 0.18652131f, 
    -0.15337038f, 0.14192817f, -0.22793645f, -0.16627496f, -0.11918814f, 0.04662310f, 0.09855817f, -0.03701717f, 
    0.02120575f, -0.03846990f, -0.05994338f, -0.06257483f, -0.21928418f, 0.07877998f, 0.24614951f, 0.01282664f, 
    -0.09407040f, -0.15667652f, -0.17846170f, -0.05212686f, 0.10544237f, 0.09579779f, 0.11498578f, 0.15179604f, 
    0.04144754f, 0.08059351f, -0.12893599f, 0.04905107f, 0.20899419f, -0.06866729f, -0.05855044f, 0.18584174f, 
    0.08759839f, 0.04674505f, -0.03623609f, 0.01416121f, -0.22531727f, 0.23506290f, -0.01430740f, 0.17517307f, 
    -0.00361540f, 0.07667132f, -0.14824504f, -0.08219422f, 0.07427096f, 0.00783983f, -0.10923912f, -0.09435873f, 
    0.37453046f, 0.08071464f, -0.12738788f, -0.25806376f, 0.03642764f, 0.12625709f, -0.09160081f, -0.13739385f, 
    0.01729101f, -0.07142106f, 0.07939293f, -0.00165038f, -0.15757394f, 0.00693127f, -0.43355581f, -0.18118900f, 
    0.18069500f, 0.01971992f, 0.12429565f, -0.04640735f, 0.06128564f, 0.16064119f, -0.07581852f, -0.08858233f, 
    -0.10661065f, -0.06640658f, -0.12897016f, -0.05190268f, 0.12560126f, 0.07014119f, -0.05619429f, -0.04457705f, 
    0.05404497f, 0.01006087f, -0.05393896f, 0.13874295f, 0.38459376f, 0.22023045f, 0.01197265f, 0.21731877f, 
    0.05773686f, 0.14454788f, -0.00601020f, 0.13169998f, -0.10784434f, -0.01238751f, 0.01823365f, -0.00039653f, 
    0.28228435f, 0.02719430f, 0.09175587f, 0.11688200f, 0.06028131f, 0.04429137f, -0.01364819f, 0.06931473f, 
    -0.04109406f, -0.12752876f, 0.00944706f, 0.00659466f, 0.24731629f, -0.27234378f, 0.01235052f, 0.11292832f, 
    -0.04285473f, -0.08069141f, 0.02115370f, -0.00399192f, -0.01613644f, 0.03339485f, 0.04250009f, -0.14075702f, 
    -0.16773291f, -0.06408749f, 0.02282595f, 0.19440511f, -0.13285181f, 0.01416040f, 0.04098958f, 0.04857072f, 
    0.01944999f, -0.01726880f, 0.01174833f, -0.05645917f, 0.21012345f, 0.24412441f, -0.28015903f, -0.11599256f, 
    0.11830600f, 0.10121341f, 0.16929212f, -0.08674996f, 0.05321099f, 0.01268872f, -0.02218132f, -0.06090938f, 
    -0.23878759f, 0.32220837f, -0.11631065f, -0.23599401f, -0.04121887f, -0.04010214f, -0.04568342f, 0.10664762f, 
    0.06389851f, -0.01829758f, -0.03844258f, 0.05609396f, 0.07673921f, -0.17042239f, 0.17950641f, 0.02613532f, 
    -0.05692605f, 0.03315907f, -0.00203044f, 0.24910484f, -0.11691064f, 0.15721045f, -0.15861815f, 0.13581997f, 
    0.14904575f, 0.34167400f, -0.12127254f, 0.24555932f, 0.30756983f, 0.01007202f, 0.07013049f, -0.01835600f, 
    -0.05112358f, 0.03019119f, 0.05265825f, -0.13981631f, 0.21396585f, -0.09535313f, -0.18821667f, -0.22781950f, 
    0.04266855f, -0.08912142f, -0.01548110f, -0.05751949f, 0.04401798f, 0.19545433f, 0.10536285f, -0.03218069f, 
    0.10675716f, 0.17127208f, 0.12552398f, -0.00698388f, 0.27117831f, 0.08825103f, -0.02544892f, 0.00372266f, 
    0.05003762f, -0.00847016f, 0.00503566f, -0.04989579f, 0.05147686f, 0.12975736f, -0.24711215f, 0.13477309f, 
    -0.08463733f, -0.08071125f, 0.13104154f, -0.06193639f, -0.00489226f, -0.08207465f, 0.06063597f, -0.01887816f, 
    -0.12188917f, 0.10654035f, 0.07030645f, -0.17706741f, 0.19877170f, 0.08239198f, -0.09781084f, -0.03227423f, 
    0.13534780f, 0.00461882f, -0.01355681f, -0.08154114f, 0.03665525f, -0.20242901f, -0.09585989f, -0.23378831f, 
    0.09057368f, 0.05289683f, -0.04549137f, -0.01077321f, 0.00425439f, -0.03000938f, -0.10348736f, -0.00314659f, 
    0.16176187f, 0.09742980f, -0.10214072f, -0.11337338f, 0.21700059f, 0.06195050f, 0.14794287f, -0.12992951f, 
    0.00179925f, -0.14317958f, 0.07499322f, 0.06579006f, -0.17899162f, 0.03274487f, 0.07552069f, 0.16944736f, 
    0.10501674f, 0.02143125f, -0.10060442f, -0.09735721f, 0.16217868f, -0.04351708f, -0.00579478f, 0.09512354f, 
    -0.06991483f, 0.29471198f, 0.09684700f, -0.14044510f, 0.24259259f, 0.13829274f, -0.02485094f, -0.02596029f, 
    -0.07365692f, 0.05906874f, 0.00971791f, -0.05715419f, -0.06354525f, 0.27634779f, 0.27426144f, 0.25814676f, 
    -0.01012978f, -0.09806608f, 0.07916838f, 0.28228888f, -0.01907071f, 0.07858772f, 0.01753674f, 0.01642817f, 
    0.03925471f, 0.00988987f, -0.01214682f, -0.02996854f, -0.01828093f, 0.01450485f, 0.00399738f, -0.04207833f, 
    0.02060577f, -0.00716683f, -0.03622007f, 0.03710000f, 0.04837948f, -0.05292186f, 0.00770769f, 0.00062395f, 
    0.01838777f, 0.03069258f, 0.03375991f, -0.01297751f, -0.00543702f, -0.00604245f, 0.03142741f, -0.01019210f, 
    0.04381623f, -0.03298425f, -0.04324875f, 0.02469555f, 0.00161342f, 0.03057852f, 0.04658296f, 0.00625318f, 
    -0.01881716f, -0.04350822f, -0.04997781f, 0.00316217f, -0.03942590f, -0.04898641f, 0.00364458f, -0.04051920f, 
    -0.03428639f, -0.04853763f, -0.03863888f, -0.03868394f, -0.04695664f, -0.00231758f, 0.02804003f, -0.03195464f, 
    0.00799866f, -0.01672250f, 0.01678502f, -0.04208712f, 0.04400045f, 0.03374722f, -0.04327399f, -0.00736247f, 
    -0.01941562f, -0.03272942f, -0.04467559f, -0.03945263f, -0.04077078f, -0.04948185f, -0.05159718f, 0.01462500f, 
    -0.00716133f, -0.04497974f, -0.01868120f, -0.01499342f, -0.00337668f, 0.02780865f, -0.01084892f, -0.05211202f, 
    -0.05548027f, -0.02326975f, -0.03222658f, -0.04516633f, -0.00841918f, 0.01036411f, -0.01752520f, -0.03525959f, 
    -0.03178171f, -0.03371261f, 0.01786632f, -0.01203625f, 0.00589266f, -0.00264718f, -0.01099646f, -0.00963763f, 
    -0.02781618f, -0.01214328f, -0.00357340f, 0.03118149f, 0.03887790f, -0.05198170f, -0.01544176f, 0.00801377f, 
    0.04542208f, -0.03347311f, -0.02509157f, 0.02228110f, -0.01578662f, -0.03665606f, 0.00111572f, -0.00616907f, 
    0.01153967f, -0.01191838f, -0.03373336f, -0.04329228f, -0.01834505f, 0.01955604f, 0.00351089f, -0.00515029f, 
    0.01025541f, -0.03091902f, 0.04046084f, -0.02025831f, -0.05301169f, 0.04372731f, -0.00006434f, -0.03315768f, 
    -0.02555284f, -0.04072479f, -0.03359250f, -0.04821116f, -0.02131279f, -0.02046176f, -0.04295210f, 0.04693411f, 
    -0.02530980f, -0.02502738f, -0.04439177f, -0.01135235f, -0.02904003f, -0.00865459f, -0.01987654f, 0.04712088f, 
    -0.00538298f, -0.01869210f, 0.01725701f, -0.02169219f, 0.03711242f, -0.00600923f, 0.04290961f, 0.01555952f, 
    0.03429688f, 0.03061162f, 0.00309243f, -0.04287092f, -0.02635667f, 0.01992603f, 0.02783350f, 0.04502877f, 
    -0.04828977f, 0.02742517f, 0.02000961f, 0.01210885f, -0.03708531f, 0.03037209f, 0.01390769f, -0.02853924f, 
    0.01797217f, -0.03008037f, -0.03937402f, 0.02223341f, -0.00678945f, 0.03062536f, 0.03867233f, -0.00783868f, 
    -0.05275611f, 0.02434976f, -0.02993601f, -0.02912899f, -0.04831676f, -0.01847226f, 0.00730794f, -0.04264052f, 
    0.02552947f, -0.02478572f, -0.04534491f, -0.03217348f, -0.03468278f, 0.00324827f, -0.01126253f, 0.01002481f, 
    -0.04027154f, -0.01746566f, 0.04054962f, 0.04431824f, 0.04822300f, 0.01153097f, 0.02830322f, 0.00121239f, 
    -0.03608390f, 0.03197756f, 0.00363799f, -0.04401026f, 0.00195001f, 0.03411938f, -0.00230050f, 0.01536016f, 
    -0.01685945f, -0.04410273f, -0.03357019f, 0.02981138f, -0.01962340f, -0.03973227f, -0.04787216f, -0.00266167f, 
    0.02461310f, 0.00510107f, -0.00045979f, -0.00237379f, -0.04330732f, 0.02269567f, -0.05068225f, -0.03795652f, 
    -0.03831421f, 0.03699400f, 0.02576547f, -0.05155331f, -0.02280584f, -0.01597506f, 0.02239875f, 0.02439834f, 
    -0.04366016f, -0.00733432f, 0.00580051f, -0.02935449f, 0.01705124f, 0.03288869f, -0.04633014f, -0.05092439f, 
    -0.01542302f, 0.03427463f, 0.00202164f, -0.00531119f, 0.01703867f, -0.04363894f, 0.01981157f, 0.04000884f, 
    -0.02398879f, 0.04625977f, 0.00533099f, 0.02307372f, -0.04042415f, 0.02621699f, -0.00869278f, 0.02307294f, 
    0.01450702f, -0.00052687f, -0.02731122f, 0.02736577f, -0.02595118f, -0.02526275f, -0.04300284f, -0.01750820f, 
    0.00174390f, 0.04052805f, 0.01517288f, -0.01037410f, 0.01505842f, -0.05238886f, 0.01010606f, 0.01139730f, 
    -0.04366647f, -0.03302052f, 0.03370717f, 0.01408808f, 0.02543570f, 0.03094880f, -0.01948590f, 0.01050982f, 
    -0.03571803f, -0.02112784f, -0.03742632f, -0.00361402f, -0.00490255f, 0.03548487f, -0.01735796f, -0.04508829f, 
    -0.01703216f, -0.01319029f, 0.01211440f, -0.05470648f, -0.04805440f, 0.03786931f, -0.04298618f, 0.01947828f, 
    -0.04291403f, -0.03570437f, -0.01116355f, -0.01868317f, -0.00742259f, -0.00516604f, 0.00661816f, 0.00069663f, 
    0.02196230f, -0.01129792f, -0.01916030f, 0.00173260f, -0.05414955f, -0.02652858f, -0.03475543f, -0.04902945f, 
    0.01823531f, 0.03849434f, 0.04145751f, -0.04232121f, 0.00978307f, 0.02200884f, -0.04041781f, -0.01118923f, 
    -0.02632849f, -0.02077052f, 0.00030988f, 0.03261833f, -0.02562111f, -0.00239746f, 0.02672005f, -0.02567952f, 
    0.03143239f, 0.03857863f, -0.04159948f, 0.03667309f, -0.01961255f, -0.01298673f, 0.04065236f, -0.02210481f, 
    -0.03354498f, 0.02278248f, 0.01319486f, -0.05363213f, 0.00347246f, 0.00739780f, 0.03891018f, 0.00452831f, 
    0.02367832f, 0.00306579f, -0.05136583f, -0.00129042f, 0.04265665f, 0.00260539f, 0.04054818f, -0.05523240f, 
    -0.00315825f, -0.02757999f, -0.00833412f, 0.03752995f, -0.04289517f, -0.00600955f, -0.02482278f, 0.00539706f, 
    0.04746943f, -0.02436457f, -0.04661984f, -0.00442805f, -0.02415154f, 0.02797334f, -0.04204095f, -0.01161084f, 
    0.03085442f, 0.00318181f, -0.02735880f, -0.02062511f, -0.02282832f, 0.00020719f, 0.00811837f, 0.03342719f, 
    -0.03138086f, -0.04551454f, -0.02519735f, 0.01331478f, 0.03325105f, 0.03509538f, 0.03271687f, 0.00842483f, 
    0.02602338f, 0.03966471f, -0.04846484f, -0.04212103f, -0.02406128f, 0.02953150f, -0.00515848f, -0.00778683f, 
    0.03856098f, 0.01825086f, -0.02161263f, -0.01137524f, 0.00629654f, -0.02061426f, -0.00762866f, -0.00980149f, 
    -0.00262040f, -0.00318706f, -0.03883006f, -0.02625111f, -0.01017291f, -0.02272149f, -0.04330978f, 0.00909896f, 
    0.00549432f, 0.03875277f, -0.04036786f, -0.02416231f, 0.00793347f, 0.04301213f, -0.05103057f, -0.02457079f, 
    0.01686259f, 0.02785456f, -0.06075921f, 0.00791572f, -0.05631099f, -0.01063777f, 0.01206301f, 0.00538621f, 
    0.02936312f, 0.04145835f, -0.00735299f, -0.00864308f, 0.00970826f, -0.03102849f, -0.01291519f, -0.04255208f, 
    -0.01741496f, -0.03555029f, -0.05149118f, -0.02889904f, -0.00458040f, -0.00206237f, 0.04730286f, -0.02781680f, 
    -0.01872167f, 0.02337185f, -0.04995373f, 0.01915098f, -0.01075131f, -0.02695666f, 0.02916530f, -0.01107418f, 
    -0.03227924f, -0.02214455f, -0.05395843f, 0.03811439f, 0.00815664f, 0.05088872f, -0.03469680f, -0.01781498f, 
    -0.02828453f, -0.00725754f, -0.00084411f, -0.03073379f, 0.02964516f, 0.01075791f, -0.02577526f, 0.02494685f, 
    0.03756677f, 0.01155782f, -0.03895322f, 0.01289310f, 0.02102827f, 0.02180284f, -0.03067971f, 0.00324879f, 
    -0.02723239f, 0.02191730f, -0.04813085f, 0.04306236f, -0.00980800f, 0.02039720f, -0.05233685f, -0.01052629f, 
    -0.05767278f, 0.03279583f, 0.02180202f, 0.00526683f, 0.02457125f, -0.02559691f, -0.02881073f, -0.03650669f, 
    0.00555832f, -0.01897326f, 0.00341032f, -0.03616683f, -0.00835134f, -0.05921913f, 0.01682090f, 0.03228486f, 
    0.02739566f, -0.05808439f, -0.05875555f, -0.00246691f, 0.01946308f, 0.01130931f, -0.05231239f, 0.01506450f, 
    0.00043762f, 0.00984199f, -0.01557209f, 0.02401055f, -0.03260611f, 0.01464342f, 0.04174171f, -0.02088643f, 
    -0.02943669f, -0.00492429f, -0.00723844f, 0.02982629f, -0.03875181f, -0.00344093f, -0.01028756f, 0.02688453f, 
    -0.02896484f, -0.03076787f, -0.03264635f, 0.01668864f, 0.00511613f, -0.03806433f, -0.02986982f, -0.05595527f, 
    0.02911010f, 0.00026486f, -0.04919465f, -0.04124251f, 0.00706264f, 0.03392203f, -0.01607141f, -0.03920938f, 
    -0.00384340f, 0.04298812f, -0.03345242f, 0.03733995f, 0.01054352f, 0.01697417f, 0.00379643f, -0.04996723f, 
    0.01936500f, -0.06073963f, -0.03799763f, 0.03064656f, -0.04794710f, -0.03753944f, -0.05700155f, -0.05177427f, 
    0.01709261f, -0.04870500f, 0.04005511f, 0.02613857f, -0.05766463f, 0.04227038f, -0.04135702f, 0.00183588f, 
    0.03279095f, -0.04561085f, -0.03842968f, 0.01821117f, 0.03570427f, 0.03989834f, 0.01385495f, 0.04104016f, 
    -0.03371826f, 0.02565822f, 0.02741385f, -0.01793184f, -0.00559060f, 0.02809705f, -0.05525611f, -0.04269900f, 
    -0.02979038f, -0.00479724f, -0.01713472f, -0.05484845f, -0.02992743f, -0.03924157f, -0.01654545f, 0.00690018f, 
    -0.01136320f, -0.02165542f, -0.01378532f, -0.00446045f, -0.01139300f, 0.03113355f, -0.01431857f, -0.00949911f, 
    -0.02504988f, 0.04392917f, -0.02421816f, -0.04840930f, -0.02241145f, 0.01216532f, 0.00404378f, -0.03412865f, 
    0.03088427f, 0.02616695f, -0.04753081f, -0.03183166f, -0.01192117f, 0.03377116f, 0.00475998f, 0.04585811f, 
    0.00068062f, 0.00789208f, -0.04746646f, -0.00407997f, -0.01932547f, -0.03022832f, -0.01035618f, 0.03137694f, 
    -0.01488611f, -0.05454774f, -0.00953978f, 0.02666162f, 0.04222694f, 0.00668516f, 0.01984756f, 0.02959116f, 
    0.02576406f, 0.02444979f, -0.01784622f, 0.02298246f, 0.01360842f, -0.00102889f, 0.02104992f, -0.00996268f, 
    0.01020764f, -0.06257346f, 0.02879463f, -0.05487981f, -0.01292348f, -0.03631579f, 0.02079834f, -0.03267695f, 
    0.01129175f, 0.03562896f, 0.01184658f, 0.01956281f, 0.01786725f, -0.00831196f, -0.01316898f, -0.01647277f, 
    0.03218486f, -0.00871228f, -0.01681950f, -0.03309729f, -0.03165564f, -0.05879737f, -0.04596569f, -0.05515712f, 
    0.02888614f, -0.00506542f, -0.03270778f, -0.03926730f, 0.01142658f, 0.02326123f, 0.03422587f, -0.05759669f, 
    -0.02167088f, -0.04687429f, -0.04000913f, -0.04581781f, -0.05246617f, -0.01093870f, -0.02054500f, -0.05872465f, 
    -0.01017660f, 0.02922232f, 0.02436114f, -0.02371554f, 0.01648101f, -0.05485373f, -0.04497717f, -0.02699000f, 
    -0.05767736f, -0.02302632f, -0.04115374f, -0.03161262f, -0.02418661f, -0.02277860f, -0.00867580f, -0.05122594f, 
    -0.01525561f, 0.03897113f, 0.03285327f, -0.00442184f, -0.01139615f, -0.00584740f, 0.00105269f, 0.03159634f, 
    -0.05501613f, 0.03285615f, -0.00801747f, 0.02547951f, -0.01322495f, -0.01838221f, 0.02144765f, 0.01703913f, 
    -0.05031303f, 0.01864532f, 0.00034084f, 0.03685784f, -0.02288384f, -0.03351895f, 0.03992003f, -0.04400672f, 
    -0.00948950f, -0.01868202f, 0.00145311f, -0.02237784f, -0.00085969f, -0.02171245f, 0.00124375f, 0.02639656f, 
    -0.00580473f, -0.05975591f, -0.05034981f, 0.02967888f, 0.03082796f, 0.01911979f, 0.01428972f, 0.02372097f, 
    -0.01005157f, -0.02280629f, -0.01346302f, 0.00346023f, 0.02064717f, -0.02200866f, 0.01632981f, -0.00621614f, 
    0.00067281f, -0.01765417f, -0.01444626f, -0.01602895f, -0.04953336f, -0.03770715f, 0.02470762f, -0.02587651f, 
    -0.02973550f, 0.01193899f, -0.01615379f, 0.00679523f, 0.04079468f, 0.03502889f, -0.05633958f, -0.02197219f, 
    -0.04734662f, -0.01299521f, -0.01837287f, -0.05647600f, -0.05694084f, -0.03671762f, -0.01494040f, 0.04200716f, 
    0.03583587f, 0.01370228f, 0.03135837f, 0.03482093f, -0.04728805f, 0.03736648f, -0.04058845f, -0.04313745f, 
    -0.00314260f, 0.01457419f, 0.02654339f, -0.03088848f, 0.01588632f, 0.01883355f, -0.00387298f, 0.00562023f, 
    0.02574238f, -0.05179637f, 0.02282421f, -0.03353174f, -0.01875282f, 0.02243136f, -0.00487932f, -0.02691921f, 
    0.03070289f, -0.00952241f, 0.04539431f, -0.02509821f, -0.00314169f, -0.02779895f, -0.00773591f, -0.05326242f, 
    0.01210851f, 0.04560389f, -0.03788166f, -0.03261764f, -0.05338575f, -0.02759423f, -0.04064011f, 0.03792966f, 
    -0.00748301f, 0.03340225f, -0.03128942f, -0.00283495f, 0.03533818f, -0.02636916f, -0.02369266f, -0.04746585f, 
    0.03210803f, -0.03016454f, 0.03108418f, -0.03086811f, 0.03826728f, -0.00221035f, 0.03584354f, 0.01549579f, 
    -0.05452229f, 0.01739816f, 0.02008862f, -0.01043649f, 0.02786801f, -0.01106948f, -0.02502469f, -0.05284509f, 
    0.02650485f, 0.03042150f, -0.00604750f, -0.05439547f, -0.02587648f, 0.03932172f, -0.04255455f, -0.05390584f, 
    -0.00107353f, 0.01275423f, 0.01148394f, 0.04305136f, 0.01156427f, 0.02898829f, -0.00848663f, -0.03418304f, 
    -0.03494486f, -0.04678314f, -0.00069687f, 0.03704935f, -0.00466545f, 0.04229550f, 0.02201147f, 0.03789635f, 
    0.01940599f, 0.03015541f, -0.04147693f, 0.00545031f, 0.01294301f, 0.00861361f, 0.00580494f, 0.03294497f, 
    0.02492290f, -0.00459799f, -0.00745942f, 0.04212053f, -0.00769329f, -0.02315879f, -0.01293357f, 0.03775905f, 
    -0.04655742f, 0.03453887f, -0.05237519f, 0.02285457f, -0.04811700f, -0.04109334f, -0.02310629f, -0.02085755f, 
    -0.05276968f, 0.04563834f, 0.03006873f, 0.02708222f, 0.02169280f, 0.01341707f, 0.04310520f, -0.02545873f, 
    0.00456779f, -0.01034947f, -0.05017257f, -0.02236486f, -0.03775478f, 0.01076805f, -0.05006452f, -0.04702821f, 
    -0.01031712f, -0.00628512f, -0.01869287f, -0.05373120f, -0.04641799f, -0.00065320f, 0.03101030f, 0.02614598f, 
    -0.00464001f, 0.02724289f, -0.03079728f, -0.00326845f, -0.03288028f, -0.00261434f, -0.00625980f, 0.02741641f, 
    -0.00236493f, 0.04333364f, -0.00497043f, -0.02047797f, -0.03996651f, -0.05699242f, -0.04107949f, 0.00528635f, 
    -0.05688772f, 0.04067897f, 0.04533532f, -0.05414841f, -0.03446027f, -0.03414880f, -0.02239547f, -0.03246420f, 
    0.01223806f, -0.04453476f, 0.00802776f, 0.03730746f, -0.00045109f, 0.00533257f, 0.01879013f, -0.01969223f, 
    -0.03038797f, -0.05482317f, -0.01098301f, 0.04104197f, 0.02189326f, -0.02018436f, 0.00918597f, 0.01435002f, 
    0.02230324f, -0.00807994f, 0.04262655f, -0.02869217f, 0.01696136f, -0.01444384f, -0.01842873f, -0.00191443f, 
    -0.03413981f, 0.03115800f, -0.04455825f, 0.02601604f, -0.01837750f, -0.00278077f, -0.00700670f, 0.00652823f, 
    -0.04083975f, -0.02685788f, -0.01371411f, -0.00523988f, -0.01931785f, -0.00939132f, 0.02832378f, -0.05162308f, 
    -0.02745070f, -0.01851252f, -0.04536149f, -0.05236986f, -0.00192248f, -0.03676019f, 0.03209678f, 0.02310146f, 
    -0.04144527f, 0.02220208f, -0.04359113f, -0.03163451f, -0.04209315f, 0.01355557f, -0.02915236f, 0.02326372f, 
    0.04176868f, 0.01916292f, -0.03110201f, -0.01312649f, 0.03663665f, 0.04153197f, -0.02502763f, -0.04463867f, 
    0.04399220f, 0.04465404f, -0.00187232f, -0.05406877f, 0.01138433f, 0.01967478f, -0.00719439f, -0.04012273f, 
    -0.00560926f, 0.00668237f, -0.05434838f, 0.00122953f, -0.00815564f, 0.04392444f, 0.00275960f, 0.00819323f, 
    -0.02147343f, -0.04587651f, 0.00428870f, -0.02265101f, 0.01517204f, 0.02526610f, 0.04510564f, 0.02527090f, 
    0.02395003f, -0.04654485f, 0.03393397f, 0.02720453f, 0.01230873f, 0.04050146f, -0.00268825f, -0.03747550f, 
    0.02901038f, -0.00920126f, -0.01158323f, -0.05684736f, 0.00085640f, -0.04154772f, 0.03179224f, 0.03175960f, 
    0.00587709f, -0.03030202f, -0.00173242f, -0.01768607f, -0.05246150f, 0.00741272f, -0.01124498f, -0.00556628f, 
    -0.05389387f, -0.03919172f, 0.03015075f, 0.03964803f, -0.04228850f, 0.02152779f, -0.04186344f, -0.04168268f, 
    0.03451172f, 0.00009697f, -0.00931950f, 0.02016213f, 0.01764917f, -0.04165288f, 0.00552137f, 0.01953491f, 
    -0.04075316f, 0.01911979f, -0.05203972f, 0.04018098f, -0.01840300f, -0.03640012f, -0.01547080f, 0.00289963f, 
    0.01155967f, 0.03029544f, -0.00184850f, -0.05090890f, -0.00138046f, 0.01592207f, 0.00914942f, -0.02457856f, 
    -0.01826924f, -0.00610964f, -0.01939652f, 0.00491944f, 0.04468081f, 0.00186759f, -0.02082804f, -0.05100179f, 
    -0.03098475f, 0.00932202f, 0.04358391f, 0.00974053f, -0.01184775f, -0.03642885f, -0.00037950f, -0.00665454f, 
    -0.00655591f, -0.00760353f, -0.03732797f, 0.02839667f, -0.03771453f, 0.01483436f, -0.05454822f, 0.03085884f, 
    0.02504276f, -0.02491684f, -0.01146260f, -0.04095040f, -0.00919579f, -0.05517621f, 0.00662848f, -0.02674389f, 
    -0.01213213f, -0.02748857f, 0.02978463f, 0.00635706f, 0.01516596f, -0.04594412f, 0.01517006f, 0.03649461f, 
    -0.02847618f, 0.00380363f, 0.04071992f, -0.04253935f, 0.03881587f, -0.04477109f, 0.04266893f, -0.04884086f, 
    -0.02013687f, 0.01859687f, -0.03007088f, -0.04330155f, -0.04020109f, -0.02982004f, -0.00246964f, -0.00105995f, 
    -0.04416379f, 0.01034956f, -0.03243773f, 0.04799302f, 0.02743752f, -0.05524420f, 0.01266742f, -0.01211789f, 
    -0.03524120f, -0.00766470f, 0.04436145f, -0.04658172f, -0.05227611f, 0.02937548f, -0.03833132f, -0.01859887f, 
    0.03776524f, -0.05312661f, -0.02512760f, 0.03250543f, 0.01650809f, 0.02587569f, -0.03245778f, 0.01728499f, 
    -0.00441712f, -0.03103675f, -0.01778888f, 0.02423482f, 0.03151753f, -0.02213267f, -0.04613375f, -0.00962310f, 
    -0.01931055f, -0.02605918f, 0.02912052f, -0.00299103f, -0.05266500f, 0.01510080f, 0.00506363f, -0.00300778f, 
    -0.03905511f, 0.00952562f, 0.00604802f, 0.03300264f, -0.05162458f, 0.00279165f, 0.02846631f, -0.00091547f, 
    -0.01564891f, 0.03783627f, -0.01029925f, -0.03529776f, 0.01713213f, 0.01037807f, 0.01386907f, -0.03827172f, 
    -0.00839983f, -0.01510174f, 0.00736329f, 0.01101343f, 0.00794768f, -0.00198515f, -0.04667615f, 0.00698374f, 
    0.04123709f, -0.00488252f, 0.03951479f, 0.01563697f, 0.01944190f, 0.01191630f, 0.03041691f, 0.00818679f, 
    0.01808314f, -0.01530079f, 0.03360980f, -0.02691381f, -0.04456825f, -0.03250401f, -0.00308735f, -0.03380334f, 
    -0.03850570f, -0.00462711f, 0.03594700f, -0.06293679f, 0.04080571f, -0.05442898f, -0.02012302f, 0.02235878f, 
    0.00443734f, -0.02840755f, -0.04063144f, 0.03260703f, 0.01081648f, 0.02031888f, -0.00670305f, -0.04841715f, 
    -0.01228097f, -0.00393164f, 0.02616405f, 0.03627967f, 0.00069822f, -0.01437304f, 0.03179099f, -0.00876524f, 
    -0.03188909f, 0.00964375f, -0.02014469f, 0.00079100f, 0.02006309f, -0.00261219f, -0.02539697f, 0.00795872f, 
    -0.00771871f, -0.03619923f, -0.02117999f, -0.04349864f, 0.03214361f, 0.04576870f, 0.03865188f, 0.03196214f, 
    0.00826269f, 0.02416937f, -0.04387473f, -0.05524994f, 0.02938286f, 0.00096681f, 0.01975100f, 0.01019037f, 
    -0.03026183f, 0.01896432f, -0.05635759f, -0.02572695f, -0.00990947f, -0.01214741f, -0.03954387f, 0.03903966f, 
    0.02809133f, 0.00912971f, -0.03170877f, -0.04770886f, -0.02343119f, 0.00348405f, 0.03929207f, 0.02929688f, 
    -0.01657531f, 0.02311519f, 0.01659267f, -0.05716149f, -0.02871650f, 0.00132737f, -0.01794380f, -0.05248510f, 
    -0.02311228f, 0.01252619f, 0.02351242f, 0.00882564f, 0.00807157f, 0.02349390f, -0.01818516f, -0.03534804f, 
    -0.03455130f, -0.01378932f, -0.03704003f, -0.00168077f, -0.00916009f, -0.04060535f, -0.05774008f, 0.03017769f, 
    -0.04227926f, -0.03452805f, -0.02020013f, 0.00175672f, -0.01925669f, -0.05313295f, -0.05302725f, 0.00293751f, 
    0.04219812f, -0.02988924f, -0.01516907f, 0.00536735f, -0.01494750f, -0.03342631f, 0.03857308f, -0.05313800f, 
    -0.01655206f, -0.04070176f, 0.00038792f, 0.01876098f, -0.04530777f, -0.00024171f, 0.02287794f, -0.02274978f, 
    -0.03230551f, -0.03444145f, -0.00514568f, -0.05715706f, 0.00406430f, 0.02079929f, -0.04442568f, -0.03350032f, 
    0.02432446f, -0.00640082f, -0.04286636f, 0.02038962f, -0.02690841f, -0.04056127f, 0.00658320f, -0.03594207f, 
    -0.01918951f, -0.03424155f, -0.00191043f, 0.02804620f, -0.05518505f, -0.01052269f, -0.04609839f, -0.04370551f, 
    -0.00483931f, -0.04263202f, -0.05593189f, 0.01563548f, 0.00750763f, 0.00319671f, 0.01607222f, -0.03277595f, 
    0.02729976f, -0.00566879f, -0.00710894f, 0.01773790f, -0.04855286f, -0.03174201f, 0.00025144f, 0.02260307f, 
    -0.02994792f, 0.02357128f, 0.00290915f, 0.01899575f, 0.01692992f, 0.03310524f, -0.01090848f, -0.01745373f, 
    0.01797169f, 0.02365682f, -0.05469302f, 0.03801051f, 0.01476331f, -0.00335266f, -0.03750362f, 0.03382205f, 
    0.00067112f, 0.00882389f, 0.01363831f, 0.03035786f, -0.05470303f, 0.01274266f, 0.00539804f, -0.00114321f, 
    -0.04356030f, 0.02124724f, -0.03401247f, -0.01273337f, -0.02986474f, -0.00836334f, 0.01066176f, -0.01422936f, 
    0.01385508f, -0.01920057f, -0.05165271f, 0.03660721f, 0.01682636f, -0.01910137f, 0.02398626f, -0.00506200f, 
    0.00814861f, -0.01889455f, -0.03929082f, 0.02020432f, 0.00451406f, 0.04285514f, -0.03953185f, 0.02796303f, 
    -0.00780016f, -0.02512870f, 0.03542455f, -0.04344424f, 0.00800515f, -0.02772804f, 0.03595158f, 0.00521976f, 
    -0.00121714f, 0.02628959f, -0.00530567f, 0.03476468f, -0.00252945f, 0.03294592f, -0.05516861f, 0.02919277f, 
    -0.04431092f, 0.03915216f, 0.01125101f, 0.00788204f, -0.03906963f, -0.02183370f, -0.04200334f, -0.02159238f, 
    0.01335893f, 0.02696696f, -0.04209289f, 0.01555998f, 0.02109454f, -0.01972993f, 0.01418207f, -0.01375755f, 
    0.02137856f, -0.00035890f, -0.02127012f, 0.01122258f, 0.00715017f, -0.05918502f, -0.01901531f, -0.00059868f, 
    0.01663753f, -0.03669562f, -0.04199470f, 0.04619934f, -0.00101564f, -0.01766473f, 0.00685240f, -0.02251039f, 
    -0.01951639f, -0.00549079f, 0.03051276f, 0.02587970f, -0.05294416f, 0.00630174f, 0.00073778f, -0.04020137f, 
    0.01715144f, -0.03805319f, -0.00024063f, 0.01709312f, -0.00696349f, -0.01400019f, 0.03216644f, 0.03205362f, 
    0.03267384f, -0.05132769f, -0.01691733f, 0.03893943f, 0.01519784f, -0.02056784f, -0.00305494f, 0.02136367f, 
    -0.02003539f, -0.02930526f, -0.04112537f, 0.00791618f, -0.00799472f, -0.02362615f, 0.01357738f, 0.03227656f, 
    -0.03175139f, 0.00300137f, -0.03818128f, -0.05271878f, -0.01039950f, 0.03393750f, -0.01871786f, -0.04306126f, 
    -0.03403301f, 0.01047110f, 0.02871324f, -0.03467669f, 0.02905208f, -0.04950012f, -0.05426810f, -0.03118495f, 
    -0.02429609f, 0.00463915f, -0.05525116f, 0.04013999f, 0.02541886f, 0.03467140f, 0.04568893f, -0.04626402f, 
    -0.01804978f, -0.01835621f, -0.05767017f, -0.02494410f, 0.02120614f, -0.04915794f, -0.00619670f, 0.00595561f, 
    0.03977125f, -0.01647632f, 0.00366267f, -0.02790842f, 0.02144559f, 0.02490997f, 0.00244470f, 0.01264395f, 
    0.04410311f, -0.03470238f, 0.00361799f, 0.02574132f, -0.03133903f, -0.01818631f, -0.02522149f, 0.02336627f, 
    -0.01958680f, -0.01705549f, 0.02288909f, -0.00369235f, -0.04956380f, -0.02084764f, -0.03161759f, 0.00425196f, 
    -0.01346918f, -0.02370824f, -0.00351740f, 0.03000066f, -0.00083034f, -0.00305617f, -0.01354610f, 0.02581528f, 
    0.13609146f, 0.22347330f, -0.13879208f, 0.27911553f, 0.02461061f, 0.05607679f, 0.03051248f, 0.00941650f, 
    0.01731493f, -0.04465567f, -0.14075036f, 0.01126349f, -0.45414305f, 0.30778596f, -0.26948941f, 0.06118275f, 
    -0.10730347f, -0.06719626f, 0.05021992f, 0.16627404f, -0.06101665f, -0.04028657f, -0.07536402f, -0.12340479f, 
    -0.01839028f, -0.16974699f, 0.09444613f, 0.17043990f, 0.13639542f, -0.06067980f, 0.06593980f, 0.05219895f, 
    -0.00055735f, 0.11639065f, -0.16880248f, -0.00662653f, -0.38018775f, 0.48553833f, -0.09788390f, -0.35099667f, 
    -0.07421151f, 0.05671225f, 0.18751597f, 0.07744970f, 0.22143647f, -0.05877834f, -0.00931085f, -0.15205157f, 
    0.24295594f, 0.03038183f, 0.14788535f, 0.27268228f, 0.05145438f, -0.02505642f, -0.05086969f, 0.01362796f, 
    0.15050724f, 0.08541418f, 0.00084340f, -0.01560647f, 0.05940579f, -0.03365846f, -0.03848671f, -0.04898760f, 
    0.02648009f, -0.13962798f, -0.04052871f, 0.01458968f, -0.12070090f, -0.07937706f, 0.25958699f, -0.19430263f, 
    -0.17384084f, 0.14431298f, 0.05609457f, -0.30083233f, -0.03419396f, -0.07001380f, -0.06306180f, -0.03805287f, 
    0.06118155f, 0.16804415f, 0.02020691f, 0.07425172f, -0.45198712f, -0.08259359f, 0.04268342f, 0.30967513f, 
    -0.03045232f, -0.00428212f, 0.04802833f, -0.01217186f, -0.03532318f, -0.01534010f, 0.05933290f, -0.12290920f, 
    0.09929242f, -0.04977662f, 0.08000264f, 0.07926507f, -0.05865701f, -0.11034022f, 0.03268432f, 0.09833319f, 
    -0.10534849f, -0.13101593f, 0.04184775f, 0.01039139f, 0.19594520f, -0.10025689f, 0.13321470f, -0.11741104f, 
    0.03162185f, -0.06131330f, 0.25092456f, 0.14798233f, 0.10791962f, -0.10850569f, 0.12051362f, 0.12895983f, 
    0.26456013f, 0.09121079f, -0.02555518f, 0.30929235f, -0.03387081f, 0.06052614f, 0.01727369f, 0.01889972f, 
    0.04474344f, 0.00993723f, 0.03092819f, -0.00188999f, 0.01672975f, -0.11446968f, 0.15492167f, -0.35827529f, 
    0.06548259f, -0.03356951f, -0.02110171f, 0.06819265f, 0.05304416f, 0.07339518f, 0.14377500f, 0.12642276f, 
    -0.46157584f, -0.09675575f, -0.15951176f, 0.44543609f, -0.01141917f, -0.01705737f, -0.01767928f, -0.02313255f, 
    0.05281896f, -0.00253408f, -0.01032327f, 0.01646522f, 0.02111795f, -0.00045416f, 0.19158314f, -0.17790532f, 
    -0.06667614f, 0.07852215f, 0.10254326f, 0.01183377f, 0.11557577f, 0.11207461f, 0.01847930f, 0.00831066f, 
    0.20483281f, 0.04888827f, 0.19439475f, -0.49675637f, -0.10865925f, -0.11908652f, 0.17649223f, -0.01488981f, 
    -0.13079530f, 0.03518191f, -0.15774423f, -0.19676739f, 0.17322703f, 0.32174230f, -0.13746175f, -0.47784150f, 
    0.03914671f, -0.03912991f, 0.00459716f, -0.12006531f, -0.00613872f, -0.01152460f, -0.02491534f, 0.05649787f, 
    -0.05450150f, 0.04038877f, 0.01717282f, -0.20233552f, -0.11969579f, -0.05072776f, -0.04673558f, 0.06585783f, 
    0.08536246f, 0.03064090f, 0.11801259f, 0.10191822f, 0.29091415f, 0.16987661f, 0.19111359f, -0.17448601f, 
    -0.09684909f, -0.03915106f, -0.02254020f, 0.05562104f, -0.04048223f, -0.13038889f, 0.03495031f, 0.07377794f, 
    -0.03171609f, 0.07193676f, -0.09547470f, -0.13468814f, 0.08907727f, 0.02568205f, -0.08990531f, 0.02271135f, 
    0.00293283f, -0.22501086f, 0.04080516f, -0.17385638f, 0.03961046f, -0.23802388f, 0.08632980f, 0.35743815f, 
    -0.05813561f, 0.03045417f, 0.03928088f, 0.00108489f, 0.14949568f, -0.01152050f, -0.08029868f, 0.04640528f, 
    0.07399672f, -0.18105136f, -0.01028395f, 0.04868789f, -0.02331909f, 0.06927004f, 0.07607537f, 0.06335053f, 
    0.00733198f, 0.03348469f, -0.15699957f, 0.21752512f, 0.43265229f, -0.00418026f, -0.06109487f, 0.29104504f, 
    0.18457171f, -0.11815357f, -0.04569562f, -0.04782300f, 0.00414254f, 0.06737694f, 0.14332262f, 0.14295688f, 
    0.62657118f, -0.28942722f, -0.07086556f, -0.19362852f, -0.18021101f, -0.06579946f, 0.07577827f, -0.00415001f, 
    0.03234375f, -0.05336626f, -0.10564701f, 0.09932614f, -0.08934522f, 0.18857251f, 0.17805655f, -0.35784593f, 
    0.15597329f, 0.08644155f, 0.17019421f, 0.12053014f, 0.11714030f, -0.06638196f, 0.14366814f, 0.15935647f, 
    0.26448101f, -0.16594972f, -0.22994241f, -0.02482565f, 0.00645462f, -0.17347556f, -0.11914301f, 0.07021558f, 
    0.02911828f, -0.00103012f, 0.05543704f, 0.03745336f, -0.26085305f, 0.08292550f, 0.11719318f, 0.15030235f, 
    -0.03592712f, 0.11372708f, -0.04845823f, 0.08594413f, 0.27716413f, 0.01650386f, -0.06088493f, -0.06287468f, 
    0.38589534f, -0.37899888f, 0.21706356f, 0.50273156f, -0.20553322f, -0.01098192f, 0.01649102f, 0.06668844f, 
    -0.00680364f, 0.02818939f, 0.03731036f, 0.04321782f, 0.09276768f, -0.09796254f, 0.01123641f, 0.44557232f, 
    0.03105722f, -0.06241389f, 0.03789602f, -0.03233028f, -0.06548659f, -0.01235260f, 0.06592595f, 0.10639570f, 
    0.29551142f, -0.24207716f, 0.09841743f, 0.49480513f, -0.11731398f, 0.10044072f, 0.06533956f, 0.07360651f, 
    0.02454087f, 0.17201565f, 0.04251435f, 0.09946410f, 0.18150137f, -0.06849156f, 0.16906415f, -0.18082270f, 
    0.00000544f, 0.02493859f, 0.03628737f, -0.01843784f, -0.00965803f, -0.06460073f, -0.04105442f, 0.06476389f, 
    0.25218248f, -0.23165727f, -0.10060177f, 0.41357994f, 0.00001219f, -0.04400591f, 0.04659251f, -0.05707522f, 
    0.06599306f, -0.25438750f, 0.02615142f, 0.04505230f, 0.47891468f, -0.09372784f, 0.09120105f, -0.27798679f, 
    -0.05763681f, 0.10544237f, -0.04087397f, -0.09695185f, -0.04012911f, -0.02105493f, -0.00712678f, 0.06385843f, 
    0.02518402f, 0.02054601f, -0.00401249f, -0.02828628f, -0.01232157f, 0.02280041f, -0.05670544f, 0.00340649f, 
    0.04076120f, -0.05408539f, -0.01890261f, -0.03254456f, 0.03843758f, 0.01187284f, 0.01497188f, 0.03554384f, 
    -0.00991612f, -0.01966443f, -0.04689377f, 0.02002534f, 0.03575929f, -0.04708119f, -0.03297809f, -0.03179324f, 
    0.04400402f, 0.01467780f, -0.05392303f, 0.03135638f, 0.01277091f, -0.04033442f, -0.03103009f, -0.03073777f, 
    -0.04711252f, -0.02836293f, -0.05246442f, -0.01059503f, -0.00950158f, -0.02994013f, -0.04278180f, 0.00397066f, 
    0.02213577f, 0.00743617f, 0.01345870f, -0.00941831f, 0.03151805f, -0.03526002f, -0.02527283f, 0.00478600f, 
    0.01300669f, 0.00533485f, -0.02308433f, -0.02194108f, -0.02050276f, -0.03172639f, -0.00205574f, 0.00139115f, 
    0.00099915f, -0.04212789f, 0.04227843f, -0.01569541f, -0.00067747f, -0.01282577f, -0.04301379f, -0.02478213f, 
    -0.01110570f, 0.00438147f, -0.04671697f, 0.02678648f, -0.01546305f, 0.01041154f, -0.05358545f, 0.03756836f, 
    -0.04599982f, -0.02442451f, 0.04211202f, 0.02187349f, 0.02427747f, -0.05601663f, 0.00064043f, 0.02064376f, 
    -0.02344866f, 0.01728074f, -0.00764212f, 0.03660825f, -0.01382305f, 0.02737347f, 0.02214433f, -0.00774641f, 
    -0.04627948f, -0.03506004f, -0.02918709f, 0.00431031f, 0.00275667f, 0.03985286f, -0.04143746f, 0.01758406f, 
    0.01409355f, -0.04012425f, -0.00670765f, -0.00736038f, -0.00471586f, -0.04401077f, -0.04431460f, -0.01070695f, 
    0.00145088f, -0.02799539f, -0.04010012f, -0.04993397f, -0.03673826f, 0.03984128f, 0.01772987f, 0.04251259f, 
    -0.02859838f, 0.00181765f, 0.00292015f, 0.00458234f, 0.01943914f, -0.01563486f, -0.01126515f, -0.01151382f, 
    -0.00284794f, 0.03896557f, -0.01732137f, -0.00674268f, -0.00229410f, 0.03804903f, -0.03267719f, -0.01437919f, 
    0.01061427f, -0.04992444f, 0.02201146f, 0.04524105f, 0.04432432f, -0.02510474f, 0.03418522f, 0.01341400f, 
    0.02482909f, 0.03822852f, -0.05311371f, -0.00851724f, 0.03273956f, -0.00639533f, 0.03359410f, -0.00071413f, 
    -0.00738041f, -0.01595162f, 0.01033509f, 0.02984876f, -0.00349268f, -0.02216797f, -0.00461055f, -0.04312238f, 
    -0.00559021f, -0.05217263f, -0.03532292f, 0.02314541f, 0.03616520f, -0.03526605f, -0.04670949f, -0.02535864f, 
    -0.05036117f, -0.02545160f, -0.05387992f, 0.00482723f, -0.03854418f, 0.03807025f, -0.03635233f, 0.01784485f, 
    -0.02557332f, -0.04191745f, -0.03704967f, 0.02176958f, -0.01076953f, 0.02454260f, -0.05482168f, -0.03366193f, 
    0.00816237f, 0.02865737f, 0.03914623f, 0.02306272f, -0.01668634f, -0.04681259f, -0.04516055f, -0.03477306f, 
    -0.03324866f, -0.03723792f, -0.00549106f, 0.04464814f, -0.02312216f, 0.01307964f, 0.04017464f, -0.02953193f, 
    -0.01328193f, -0.04335107f, -0.03220245f, 0.01974133f, 0.03400973f, -0.05543711f, -0.05448924f, 0.01603967f, 
    -0.04298856f, 0.03197687f, -0.02826371f, 0.03868676f, 0.00139885f, -0.05452535f, 0.02027842f, 0.03217332f, 
    -0.05567664f, 0.03952441f, -0.05495868f, 0.02150944f, -0.04124410f, -0.00414649f, 0.01710321f, -0.02563692f, 
    -0.00599240f, 0.03642037f, -0.05762241f, -0.00999494f, 0.00978849f, 0.00256955f, -0.03340421f, -0.05546129f, 
    -0.01686162f, -0.00889447f, -0.00536342f, -0.00749011f, -0.00544545f, 0.03012823f, 0.00120028f, 0.01805643f, 
    -0.04806391f, 0.00691483f, 0.00729037f, 0.00603572f, -0.01278748f, -0.03764849f, 0.01141515f, -0.00204028f, 
    0.02238776f, -0.03334117f, 0.01104134f, 0.01210442f, 0.02812787f, 0.02923270f, 0.04300826f, -0.01821537f, 
    0.01934269f, -0.05649168f, 0.00964243f, -0.03825030f, 0.02532806f, 0.02137439f, -0.02021251f, -0.04764475f, 
    0.01233300f, 0.03609684f, 0.01813227f, -0.00995245f, -0.01403750f, 0.03815324f, -0.04479830f, -0.01150224f, 
    -0.04938489f, 0.00944981f, -0.00213175f, 0.03210261f, -0.04637527f, 0.02760606f, -0.02872828f, -0.03456677f, 
    0.01284193f, -0.04821685f, -0.05598295f, 0.00731265f, 0.03112677f, -0.00011340f, -0.03159492f, -0.01302778f, 
    -0.00306384f, -0.04694965f, 0.01374549f, 0.03086030f, -0.04006072f, -0.05018266f, 0.02374014f, 0.02809552f, 
    -0.04047529f, -0.04908465f, 0.03602679f, -0.00402530f, -0.01100507f, 0.01235806f, -0.02957881f, -0.02928041f, 
    0.02398718f, -0.03123052f, -0.01783878f, 0.03392075f, -0.00197210f, -0.04459621f, -0.04779880f, -0.03293901f, 
    0.02621997f, -0.00748612f, -0.02644475f, 0.03373235f, -0.03810137f, 0.03359208f, -0.02182764f, 0.02995977f, 
    -0.00298796f, -0.01168257f, -0.00949165f, -0.00026027f, 0.00768371f, -0.00599645f, 0.02567283f, -0.05185282f, 
    -0.03764323f, 0.02473961f, -0.04865241f, 0.04109616f, 0.00354077f, 0.00170031f, 0.03204291f, 0.01657130f, 
    -0.00330428f, 0.03755098f, -0.02838947f, -0.01036944f, 0.01456249f, 0.03215095f, -0.05033254f, 0.01437837f, 
    -0.02078575f, 0.01370362f, -0.00564811f, -0.04875588f, -0.03193712f, 0.00763356f, -0.04758313f, -0.00714943f, 
    0.00323390f, -0.03178572f, 0.02206034f, 0.03203019f, -0.04349426f, 0.01045638f, 0.01075238f, 0.01631029f, 
    0.03376147f, -0.00365689f, 0.01606987f, 0.01388582f, 0.04014668f, 0.02405650f, 0.00930979f, -0.00443404f, 
    0.00990581f, -0.05511442f, -0.04413540f, -0.04436619f, 0.01074615f, 0.01177927f, -0.02613775f, -0.01388181f, 
    -0.02355368f, 0.01806900f, -0.04507577f, 0.02771273f, -0.01401569f, -0.03318458f, -0.05263048f, -0.00845207f, 
    -0.04209470f, -0.04490013f, -0.04974895f, -0.01361956f, -0.05312091f, 0.00463684f, -0.00905890f, -0.05549153f, 
    -0.35414556f, 0.11595320f, 0.04960991f, -0.14214644f, 0.10493983f, 0.07930139f, 0.08898687f, -0.11206758f, 
    0.03955087f, 0.02578538f, 0.14489722f, -0.04487886f, -0.44684556f, 0.15870021f, 0.02079111f, 0.15700696f, 
    0.15180592f, 0.02922641f, -0.05158927f, -0.10943811f, -0.09819189f, 0.07734182f, 0.14174250f, 0.15366329f, 
    -0.47446594f, -0.27110726f, 0.03041094f, 0.14359820f, -0.02852820f, 0.01183218f, 0.08059891f, -0.03955619f, 
    0.06863110f, -0.03378820f, -0.02662271f, 0.03855336f, 0.09601234f, 0.02644809f, 0.15692228f, 0.27004460f, 
    -0.14638764f, -0.11388612f, -0.02303993f, -0.05406847f, 0.00718456f, 0.08009601f, 0.01774719f, -0.00139006f, 
    0.20819634f, 0.02671292f, -0.03050621f, 0.07869968f, -0.24226207f, 0.01751812f, -0.05783780f, -0.00732900f, 
    -0.23261815f, -0.04027271f, -0.02421528f, -0.10568811f, 0.14797823f, 0.04393287f, -0.07883102f, 0.10527641f, 
    0.03113325f, 0.09279803f, 0.00360218f, 0.01242712f, 0.15647894f, -0.01431135f, -0.08288195f, 0.16367768f, 
    -0.24206726f, -0.09889021f, 0.22697204f, 0.21964726f, -0.09305508f, -0.10535347f, 0.00094537f, -0.00130995f, 
    0.08871821f, -0.06359362f, -0.12012312f, 0.11749893f, -0.25192618f, 0.23738271f, -0.02622477f, -0.20878184f, 
    0.04606264f, -0.01318519f, 0.04118853f, -0.00127344f, 0.06192739f, 0.03788849f, 0.00512732f, 0.03360258f, 
    -0.14184350f, 0.23524773f, 0.20324452f, 0.22540407f, 0.12502898f, 0.05183965f, 0.07538117f, 0.07998855f, 
    -0.06099549f, 0.03895429f, -0.05923456f, 0.02321136f, 0.28354198f, 0.01945868f, -0.14502457f, 0.08480053f, 
    0.13141529f, 0.09354540f, -0.03200007f, 0.17478018f, 0.01655632f, -0.06837747f, -0.17011426f, -0.04410910f, 
    -0.04335816f, -0.14540587f, 0.00041000f, 0.01105231f, 0.01372978f, 0.05770298f, 0.11382626f, 0.03886983f, 
    -0.06118389f, 0.06551579f, 0.06620960f, 0.13686305f, 0.41181782f, 0.02725277f, 0.00314370f, 0.05715215f, 
    0.03637003f, -0.19890684f, 0.22030620f, 0.09291995f, -0.01885074f, 0.00558194f, -0.00684345f, 0.11021341f, 
    0.16530377f, -0.30722016f, 0.09151965f, 0.06602290f, -0.09212108f, 0.09238075f, -0.00169867f, 0.02836701f, 
    -0.02097482f, -0.04269466f, 0.00455227f, -0.02732076f, -0.16676696f, -0.13218315f, 0.17276232f, 0.40610090f, 
    -0.11988046f, -0.11339652f, 0.01225559f, 0.08722708f, 0.06735341f, 0.04659320f, -0.03522317f, 0.07142040f, 
    0.40473172f, 0.06932748f, 0.07465027f, 0.18960322f, -0.00411181f, 0.02734267f, -0.01271584f, 0.06753787f, 
    -0.04753108f, 0.03752781f, 0.24456848f, 0.18373525f, -0.02702590f, -0.22998402f, 0.09760644f, -0.24586026f, 
    0.01922529f, -0.00581782f, 0.00858190f, 0.06275176f, 0.02018262f, 0.01002367f, -0.02834661f, -0.06585880f, 
    -0.11677151f, -0.02073860f, 0.08839449f, -0.02381916f, 0.08313811f, -0.01817670f, -0.09625916f, -0.08204224f, 
    0.00896809f, -0.12903532f, -0.01645479f, -0.14534508f, -0.60793233f, -0.04692554f, -0.12129712f, 0.01947036f, 
    0.17052774f, 0.14937036f, 0.00858961f, 0.02461987f, -0.08236292f, 0.04486963f, -0.04889885f, 0.06338943f, 
    0.04894495f, -0.15858270f, 0.03536334f, -0.13923472f, 0.03989694f, 0.00375330f, -0.02244266f, 0.13864826f, 
    0.00625287f, 0.10868832f, 0.01542100f, -0.00529339f, 0.05481999f, 0.20340253f, 0.22476797f, 0.19207014f, 
    0.00347612f, -0.06197375f, -0.02421868f, -0.01075580f, -0.00332606f, 0.08315061f, -0.03667725f, 0.08815318f, 
    0.20711502f, 0.10789753f, 0.13800512f, 0.01482480f, -0.06351266f, -0.09183037f, -0.04434706f, 0.01681516f, 
    -0.05864488f, -0.14903875f, 0.11175354f, -0.01140286f, 0.44152519f, 0.19774568f, -0.27689904f, 0.01448161f, 
    0.18472189f, 0.08713569f, 0.07822676f, 0.00956306f, 0.04056771f, 0.04346208f, 0.06578902f, -0.05736594f, 
    0.23059081f, 0.07990438f, 0.00153993f, -0.01334894f, 0.01824974f, -0.01059516f, -0.06116445f, 0.03856348f, 
    0.02815639f, 0.05531857f, -0.02004088f, -0.09941002f, 0.14464979f, -0.12996098f, 0.03569834f, 0.22200546f, 
    0.01448048f, 0.05633225f, 0.04000479f, 0.04800018f, 0.03008707f, 0.03894865f, -0.02958306f, -0.03144734f, 
    0.46463126f, -0.00848062f, -0.06215839f, -0.01380584f, -0.16374813f, -0.04763320f, 0.04408114f, 0.08077180f, 
    0.16845274f, -0.00467784f, 0.04161047f, -0.02740366f, 0.37791312f, 0.02878988f, -0.09269890f, -0.11211377f, 
    0.10391872f, -0.07918437f, 0.05045791f, -0.13151956f, -0.05937616f, 0.11067994f, -0.07493737f, -0.03292765f, 
    0.16440094f, 0.36087441f, -0.09588850f, -0.00933353f, -0.09729708f, 0.03034067f, 0.07791573f, -0.01056123f, 
    -0.13532840f, 0.15338548f, -0.15275119f, -0.00357842f, 0.41915512f, 0.06080089f, 0.04726196f, 0.08015793f, 
    -0.19016191f, 0.12789947f, 0.05724671f, 0.02849325f, 0.06373938f, 0.04578821f, 0.02374463f, 0.04104739f, 
    0.16298087f, 0.05287839f, 0.13707602f, 0.07722428f, -0.16719684f, -0.11423034f, 0.02429585f, 0.02995760f, 
    -0.06705723f, -0.24776138f, -0.08938207f, -0.21300507f, 0.28695694f, -0.03878555f, -0.21848530f, -0.03288172f, 
    0.15369366f, 0.01640193f, 0.05083418f, 0.08375082f, -0.01203368f, 0.05280456f, 0.05425957f, 0.06970653f, 
    0.11630380f, 0.04544609f, -0.08801095f, -0.03956145f, -0.01982652f, -0.10925498f, -0.01750668f, 0.01944909f, 
    0.05709572f, -0.05987338f, -0.11243307f, 0.06211495f, 0.03089908f, -0.20111911f, 0.00116439f, -0.12096725f, 
    0.12811705f, 0.07700681f, -0.01547000f, 0.01202016f, -0.01064179f, 0.04275296f, 0.01803854f, 0.09572181f, 
    0.23897232f, -0.11593559f, 0.02949593f, -0.03380707f, -0.03466642f, -0.03902382f, 0.02243797f, -0.09028050f, 
    0.14795859f, -0.12088872f, 0.10971093f, 0.04632997f, -0.21833611f, 0.10699998f, -0.19752362f, -0.15102054f, 
    -0.08747569f, 0.07590845f, -0.15278514f, 0.08674695f, 0.07043159f, -0.04749800f, 0.06982243f, -0.05113485f, 
    0.18966864f, 0.17457804f, 0.03270452f, -0.00531139f, 0.14303291f, -0.01227870f, 0.06724393f, 0.02195472f, 
    -0.04719295f, 0.00998802f, 0.01788489f, 0.04401586f, -0.17936286f, 0.00133267f, -0.11319840f, 0.04634826f, 
    -0.05400179f, 0.09476204f, -0.03787196f, 0.14407985f, 0.02997647f, 0.12180828f, 0.14715219f, -0.08835736f, 
    0.68144691f, -0.10606615f, -0.14400402f, 0.33903474f, 0.07495809f, 0.18709151f, 0.04803434f, -0.06477741f, 
    -0.08538892f, 0.10959902f, -0.09978446f, 0.01814165f, -0.13359141f, -0.00999081f, -0.08394971f, 0.01313522f, 
    -0.13551129f, 0.03831293f, -0.04354439f, 0.09848709f, -0.06762489f, 0.11527396f, 0.00984911f, -0.05914763f, 
    -0.48797402f, 0.11767136f, 0.09857129f, -0.27907911f, -0.01924026f, 0.02106299f, 0.02820558f, 0.03126854f, 
    -0.12351710f, 0.03326364f, 0.15464981f, -0.01698756f, -0.01860002f, -0.08029336f, 0.12809749f, 0.01514575f, 
    -0.01759114f, 0.16623797f, -0.09170292f, 0.07999884f, 0.04783154f, 0.12434880f, 0.19239065f, 0.00267824f, 
    0.07289328f, -0.05336018f, -0.14300346f, -0.05625214f, -0.17681701f, -0.10541826f, -0.16308706f, 0.04883288f, 
    0.13575268f, -0.01478234f, 0.14933242f, 0.12013486f, 0.02865463f, -0.14524975f, 0.10015056f, -0.02518870f, 
    -0.09946568f, -0.13753480f, -0.10798970f, 0.04391306f, 0.13997181f, -0.14972493f, -0.00813465f, 0.13946038f, 
    0.10090314f, 0.04731379f, 0.06936865f, -0.17862946f, 0.14493844f, -0.07268446f, 0.03289428f, -0.08934047f, 
    0.01577709f, -0.04384498f, 0.08298080f, 0.08159991f, -0.16951109f, -0.12014750f, -0.02695141f, 0.02218263f, 
    -0.03079864f, 0.03238666f, -0.08479076f, 0.11061198f, 0.06071810f, 0.01228299f, -0.05390935f, -0.02967333f, 
    -0.12689413f, 0.02759204f, -0.30585349f, 0.11685913f, -0.07455733f, 0.17291550f, 0.02624498f, 0.13894773f, 
    -0.00931817f, -0.01135876f, 0.03311095f, 0.10402068f, -0.06003301f, 0.14156786f, 0.02791898f, 0.03709005f, 
    0.02468920f, 0.08585014f, 0.05863522f, -0.07105198f, 0.03577667f, 0.14265732f, -0.02701653f, 0.01525280f, 
    0.20374510f, -0.22531249f, 0.04842141f, 0.04144435f, 0.10340020f, -0.00358514f, 0.16255541f, 0.02597304f, 
    0.12381829f, 0.06969607f, -0.04217383f, -0.11930460f, 0.02826667f, 0.24775921f, -0.03268815f, 0.00220474f, 
    0.21429706f, -0.02016945f, 0.01971387f, 0.02097032f, -0.03079749f, 0.06246349f, -0.05291651f, -0.00647382f, 
    -0.04429842f, 0.03304863f, 0.12133002f, -0.03448786f, -0.07077385f, -0.03597974f, -0.06007228f, 0.13679780f, 
    0.05993634f, -0.12444965f, 0.02144831f, 0.07083362f, 0.00909041f, -0.26888296f, -0.20590042f, -0.09885774f, 
    -0.03095672f, -0.00592904f, -0.09440340f, -0.00610717f, 0.00324380f, -0.10107575f, 0.11738006f, -0.12362863f, 
    -0.26833063f, 0.02571691f, -0.04090008f, 0.09480391f, -0.09289353f, 0.09698208f, -0.07679030f, -0.00609743f, 
    -0.10293544f, -0.14228547f, -0.10031833f, 0.01559238f, 0.05397085f, 0.01768117f, 0.28017911f, 0.06233682f, 
    0.09615006f, 0.16306126f, 0.05232067f, -0.03786238f, 0.01057003f, -0.04522990f, -0.12936391f, 0.07542681f, 
    -0.07274923f, -0.00639019f, 0.09820230f, -0.02662162f, 0.07382076f, -0.19666538f, 0.02836402f, 0.02363894f, 
    0.01253769f, 0.03639045f, -0.11018810f, -0.06699791f, -0.01599592f, -0.22139506f, -0.13790339f, -0.18792565f, 
    0.15607224f, 0.07021240f, -0.14337078f, 0.03263776f, -0.07676622f, 0.15859556f, 0.03625083f, -0.00261300f, 
    0.27762339f, 0.01539322f, -0.02755655f, -0.12227664f, 0.19248824f, 0.00087887f, 0.05406106f, -0.08329056f, 
    -0.06094925f, -0.01599131f, -0.09320996f, 0.03756287f, -0.18828715f, 0.05374544f, -0.04893289f, -0.02276351f, 
    0.10156921f, -0.00316872f, -0.04373714f, 0.04343298f, 0.05115210f, 0.05796331f, 0.01495040f, 0.14531219f, 
    0.11316419f, 0.12540443f, -0.09157924f, 0.30232894f, 0.08149295f, -0.03461679f, 0.13832042f, -0.09421893f, 
    -0.04373600f, -0.03614307f, -0.03970088f, 0.05516566f, -0.16115369f, 0.00969756f, -0.00658329f, 0.00242426f, 
    -0.14032912f, 0.06852601f, 0.08007297f, 0.05056738f, 0.11353613f, -0.11059308f, -0.23570654f, 0.06614906f, 
    0.46272698f, -0.54981965f, 0.11997831f, -0.05058844f, 0.22564031f, 0.10445873f, -0.01709672f, 0.00899145f, 
    0.09217326f, 0.00619609f, 0.04055184f, 0.10480692f, 0.25677031f, -0.22587764f, 0.11979445f, 0.19305679f, 
    0.05185825f, 0.03595018f, 0.03955220f, -0.11354973f, 0.00727371f, -0.09471437f, 0.06028379f, 0.11495900f, 
    0.13111232f, -0.06026688f, 0.04736758f, -0.04639688f, 0.01427917f, 0.03714891f, 0.04339290f, -0.01561172f, 
    0.06584717f, -0.01710205f, 0.28446859f, 0.05116631f, 0.16894731f, -0.16482511f, 0.01930268f, 0.03638360f, 
    -0.02247458f, -0.03653724f, -0.07535021f, -0.10588239f, 0.17060581f, -0.06607968f, 0.00048977f, 0.08260273f, 
    0.13198793f, -0.02967820f, 0.16051929f, 0.05772445f, 0.08156593f, 0.03779181f, 0.02205003f, -0.00122365f, 
    0.06140540f, -0.06480012f, -0.02317439f, 0.16812183f, 0.08408961f, -0.04380775f, 0.15946366f, 0.10945754f, 
    0.02185720f, 0.01406743f, -0.01702383f, 0.14607030f, -0.02290766f, -0.11139587f, 0.02111470f, -0.02051446f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.09926013f, 0.00442044f, 0.04060519f, -0.00097789f, -0.03477838f, -0.07329606f, -0.03651608f, -0.02261985f, 
    0.00882905f, -0.01142110f, 0.04736210f, 0.01190795f, -0.02087193f, -0.01567223f, 0.03830860f, 0.07752237f, 
    -0.01880774f, 0.04505079f, 0.07302096f, 0.01993483f, 0.10083580f, -0.01057972f, -0.01571050f, 0.05737159f, 
    0.03336245f, 0.03304020f, 0.03661237f, -0.05040078f, 0.00798746f, 0.02527283f, 0.00988298f, 0.09260877f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.17546968f, -0.97447890f, -0.56956083f, 0.29108027f, 0.34216210f, 0.00584299f, -0.15482362f, -0.02338415f, 
    0.16227889f, -0.01976069f, 0.01707377f, 0.22504365f, 0.31193513f, -0.03392756f, 0.16721663f, -0.16689824f, 
    0.19726938f, 0.01973890f, -0.22395921f, 0.16888034f, -0.26835579f, -0.06648087f, -0.04045295f, -0.49614254f, 
    0.07357518f, 0.03038224f, -0.02413372f, 0.15602458f, 0.37477678f, 0.02562256f, -0.04996052f, -0.23819070f, 
    -0.32029063f, 0.21851334f, 0.21700427f, -0.10487781f, -0.13500580f, -0.08479276f, 0.10407919f, -0.12366298f, 
    -0.07157873f, -0.15763053f, 0.05142892f, 0.29997471f, -0.05586699f, 0.02856639f, -0.02758243f, 0.29968548f, 
    -0.22205764f, -0.22973254f, -0.57021332f, 0.02864273f, 0.40600327f, -0.11144778f, -0.13682491f, 0.05012834f, 
    -0.04063349f, -0.15121298f, -0.09760693f, 0.13006151f, 0.36910778f, 0.12068297f, 0.17563961f, 0.15880041f, 
    -0.18738058f, -0.08673678f, 0.26005664f, -0.64800721f, 0.15057074f, -0.03043330f, -0.04702006f, -0.14490549f, 
    0.08225627f, 0.11213280f, -0.20357253f, -0.00121155f, 0.19551830f, 0.08256111f, -0.13740279f, -0.10850924f, 
    0.33372506f, 0.20569131f, -0.28873301f, 0.24513245f, -0.63583690f, -0.12541601f, 0.09503238f, 0.35478395f, 
    0.10839082f, 0.06966184f, -0.06966010f, -0.01220042f, -0.00752615f, -0.05254236f, -0.57148439f, 0.24569243f, 
    0.15821709f, 0.36846232f, 0.04538117f, -0.29892248f, 0.07910451f, 0.27718344f, 0.07288472f, 0.14178008f, 
    0.06789151f, -0.10258318f, -0.23353279f, -0.41010508f, -0.05739905f, -0.38729304f, -0.14034522f, -0.55774266f, 
    0.13097395f, -0.41516295f, 0.11475102f, -0.03831992f, -0.10763501f, -0.00809505f, -0.14247009f, -0.50052255f, 
    0.09245390f, -0.04740455f, 0.05676777f, 0.15719622f, 0.28912956f, 0.11785068f, 0.04865401f, 0.26608220f, 
    0.17761026f, -0.44160464f, 0.19934185f, -0.29214415f, -0.49691921f, 0.28719917f, 0.07389794f, 0.14025284f, 
    -0.03150421f, -0.08946847f, -0.15216801f, -0.08852754f, 0.28563437f, -0.26958334f, -0.10172854f, 0.25913176f, 
    -0.17778973f, 0.14436132f, 0.07832041f, -0.19254617f, -0.27751940f, -0.07543261f, 0.10923548f, -0.20302136f, 
    -0.06595391f, -0.11716165f, -0.12208857f, 0.09785303f, -0.02886569f, 0.02654915f, 0.27549028f, -0.10128870f, 
    -0.05422597f, 0.01489907f, -0.18987513f, 0.36206234f, 0.10988178f, -0.62225729f, 0.09253744f, 0.14107643f, 
    0.08538757f, -0.10624613f, 0.15123892f, 0.20517056f, -0.22938809f, -0.47500029f, -0.12526783f, 0.39818278f, 
    -0.43447411f, 0.07104218f, 0.41845623f, 0.27342144f, -0.04723757f, 0.02150583f, 0.05257763f, -0.15379079f, 
    0.08377306f, -0.17143987f, -0.05347193f, 0.04185666f, -0.19209793f, 0.14792493f, 0.08683132f, 0.19840294f, 
    0.22479056f, -0.10622419f, 0.24488422f, -0.49146649f, 0.44104707f, 0.14933144f, -0.16030350f, -0.17079526f, 
    0.00190336f, 0.01911534f, 0.30770493f, 0.32375789f, -0.06011755f, -0.05019267f, -0.07595430f, -0.54280108f, 
    -0.36832437f, -0.03211837f, -0.16978729f, 0.15167305f, -0.06288756f, 0.14091219f, 0.14892501f, 0.04764283f, 
    0.04035360f, -0.17999780f, 0.04924607f, 0.01125449f, -0.84135783f, -0.03492057f, -0.01263066f, -0.03468825f, 
    -0.20310819f, 0.30001703f, 0.03410671f, -0.14668629f, 0.16663863f, 0.24962862f, -0.14345814f, -0.15103032f, 
    0.07245006f, 0.14865391f, -0.29387176f, 0.10296463f, -0.19443010f, 0.27772373f, 0.03975473f, 0.22653639f, 
    0.21875337f, -0.34510675f, 0.32488066f, -0.44298962f, -0.29899836f, 0.03807381f, 0.04578273f, 0.10397982f, 
    -0.15339315f, 0.09871677f, -0.10502826f, -0.17850673f, -0.51903248f, 0.05998896f, 0.12535706f, -0.49792099f, 
    -0.37923872f, -0.11193284f, 0.16188130f, 0.36968789f, -0.26868460f, 0.26852411f, 0.16522878f, 0.11870899f, 
    0.13403311f, 0.04568740f, 0.19505593f, 0.08214873f, -0.54699630f, 0.27817929f, 0.04165125f, -0.12204418f, 
    -0.51991427f, 0.02916153f, -0.13011533f, 0.28405267f, -0.53709835f, -0.08101089f, 0.05579310f, 0.26846343f, 
    -0.02279612f, 0.16108060f, 0.16781826f, 0.06230254f, 0.30043173f, 0.15646829f, -0.46714181f, -0.03118396f, 
    0.33284968f, -0.05283481f, -0.70170218f, -0.10453442f, -0.54675573f, -0.17002790f, 0.15086065f, 0.15043809f, 
    0.11002640f, -0.13017659f, 0.26674640f, -0.33125418f, 0.17851412f, 0.52460772f, 0.01921671f, 0.05650717f, 
    0.16926883f, -0.21375656f, -0.18792133f, -0.11881647f, -0.19778842f, 0.04526370f, -0.10914022f, 0.46314207f, 
    -0.12219860f, 0.08352216f, -0.12299218f, -0.07029581f, -0.60340273f, 0.12572071f, 0.14058584f, -0.15514301f, 
    -0.18384983f, 0.46005416f, 0.32819989f, 0.30435339f, -0.25624609f, -0.32203287f, 0.13641550f, -0.15377294f, 
    -0.03373312f, -0.03440028f, -0.29984048f, -0.35806140f, 0.11500758f, 0.23666944f, 0.00154862f, -0.09696315f, 
    -0.09198033f, 0.30711046f, 0.14791127f, -0.13528886f, 0.50250781f, -0.09957220f, 0.08054695f, 0.04841466f, 
    0.15940353f, 0.08423755f, 0.07488001f, -0.00942034f, -0.07306647f, 0.08314423f, -0.50163805f, -0.19027379f, 
    -0.31044960f, -0.46268344f, 0.17544559f, 0.02636115f, 0.34847534f, 0.27626604f, -0.15036021f, -0.10048508f, 
    -0.03389042f, -0.07238565f, 0.20077509f, -0.60541755f, -0.39453909f, -0.50109017f, -0.09456340f, -0.27153328f, 
    0.41090995f, 0.37016818f, -0.06411427f, -0.17385088f, 0.14319240f, -0.11317228f, -0.14126657f, 0.28871709f, 
    -0.12443570f, -0.14472857f, -0.12384873f, -0.10401452f, -0.14424692f, 0.03990319f, 0.25846705f, 0.00699768f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.05287923f, -0.15458027f, -0.05774986f, -0.02294364f, 0.18283869f, 0.00868603f, -0.02534883f, -0.08717536f, 
    -0.11369030f, 0.18455353f, 0.15755637f, -0.07650744f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
