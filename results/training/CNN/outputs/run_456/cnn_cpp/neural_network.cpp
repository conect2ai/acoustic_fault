#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.16877723f, -0.55001163f, -0.75807720f, -0.37308857f, -0.57532239f, 0.96954620f, 1.15044951f, -0.00096337f, 
    0.50498110f, 0.47894731f, 0.03201140f, -0.33418915f, -0.33270872f, -0.19347604f, -0.03792092f, -0.15789290f, 
    -0.01014252f, 0.17537178f, 0.36817083f, -0.06842526f, -0.18796228f, 0.00622520f, -0.07109401f, -0.11665703f, 
    0.15255259f, -0.88350654f, -0.58076233f, -0.39742374f, -0.60284418f, -0.75707579f, -0.24883826f, -0.30767936f, 
    0.05344723f, -0.24256088f, -0.54552907f, -0.08914315f, 0.26122668f, -0.41004139f, 0.16430192f, -0.05995194f, 
    0.50038511f, 0.32030657f, -0.26359558f, 0.13296975f, 0.27759996f, -0.13721739f, -0.02621832f, 0.46626988f, 
    0.06082965f, 0.32476720f, -1.41866434f, 0.97842079f, 0.11876960f, -0.77436268f, -0.78531343f, 0.44897848f, 
    0.51563120f, -0.20578931f, 0.54382426f, 0.47322375f, -0.32755005f, 0.04292174f, -0.43153760f, -0.06513414f, 
    -0.25499272f, 0.05621117f, 0.24956144f, -0.04731262f, 0.16886702f, -0.09967855f, 0.09509139f, 0.08734196f, 
    0.24599859f, 0.10071288f, 0.13063648f, -1.67328477f, 0.21128707f, 0.78023636f, -0.21253194f, -0.45892867f, 
    0.69507104f, 0.33789912f, 0.06006029f, -0.05655394f, -0.62750381f, -0.09470899f, -0.15171522f, -0.06877395f, 
    0.12412493f, 0.38410640f, -0.12582414f, 0.00979659f, 0.10719872f, -0.22034612f, 0.04539504f, 0.04165281f, 
    0.25574964f, 0.24737893f, 0.09735490f, 0.11345208f, 1.05366349f, 0.78527516f, 0.71366578f, -0.60880947f, 
    -0.74206746f, 0.19877011f, -0.52978790f, -0.14291875f, -0.54511988f, 0.40465721f, 0.19579765f, 0.49460214f, 
    0.27549630f, 0.16986077f, 0.16215073f, -0.13601637f, 0.28300786f, 0.31070891f, -0.02842179f, -0.20939149f, 
    0.16522680f, 0.23477404f, 0.16444573f, 0.21334551f, 0.40889576f, 1.13458133f, 0.67097831f, 0.54216039f, 
    -0.11699989f, 0.21820278f, 0.60847008f, -0.16196139f, 0.33124042f, 0.14477631f, 0.38800308f, 0.06139389f, 
    0.29930377f, -0.20349087f, -0.16688822f, -0.76434922f, -0.04787954f, -0.28480932f, -0.19629258f, -0.13155650f, 
    -0.46546316f, -0.02012755f, -0.16152325f, -0.04143267f, -0.14130527f, -0.25484985f, -0.95171607f, 0.64773339f, 
    -0.86353850f, -0.50837290f, 0.87891096f, -0.59835917f, 0.85162848f, 0.80605990f, 0.13139829f, 0.51931578f, 
    0.04186400f, -0.10315265f, 0.02939456f, -0.55428123f, 0.06844891f, 0.28659239f, -0.06586821f, -0.05662583f, 
    0.43019283f, -0.17726389f, -0.27109483f, -0.03221640f, -0.00942297f, -0.09007756f, -0.12919459f, -0.31454703f, 
    -1.07312965f, -0.12637445f, 0.56551939f, 0.45962176f, -0.64328402f, -0.39531299f, 0.31321490f, 0.26844966f, 
    -0.49249738f, -0.17213735f, -0.15176861f, -0.17791779f, 0.62080598f, -0.01255148f, 0.29093367f, 0.00887882f, 
    0.32728338f, -0.13652809f, -0.24023297f, -0.23865150f, -0.54566824f, -0.49977085f, -0.37793779f, 0.05800963f, 
    1.18394125f, 0.62583548f, 1.06317461f, -0.44752344f, 0.10219409f, -0.09427781f, 0.00878858f, -0.09587253f, 
    0.17969805f, 0.54858989f, -0.18753240f, -0.27516139f, -0.25221038f, -0.17943099f, 0.19090414f, 0.35730618f, 
    0.45813072f, 0.10521865f, 0.10820416f, 0.03095629f, 0.21010362f, 0.05223148f, -0.12075596f, -0.14626972f, 
    0.13281651f, 1.20750570f, -0.33212087f, -0.98748267f, -0.31014141f, 0.89309561f, 0.32559732f, 0.12053467f, 
    -0.11962034f, 0.41927019f, 0.68566477f, -0.21383438f, 0.25807431f, -0.02973898f, -0.00080390f, 0.41508228f, 
    -0.22965516f, -0.13701116f, -0.15857050f, -0.14024423f, -0.14570779f, -0.01955826f, 0.06158999f, 0.23642461f, 
    0.04539659f, -0.11018694f, -0.04406654f, 0.52013856f, -0.76123774f, -0.98587477f, -0.06738092f, -0.46182770f, 
    -0.70176411f, -0.73807919f, -0.48482037f, -0.46189463f, -0.65366328f, 0.40465295f, 0.15488154f, 0.19806717f, 
    0.25981879f, -0.38290319f, 0.18055633f, -0.11129281f, 0.30555916f, 0.57692999f, 0.40962180f, -0.01021803f, 
    0.05986457f, -0.20994747f, 0.23575626f, -0.26639503f, 0.07841150f, 0.39762402f, -0.17577465f, 0.64780533f, 
    -0.93530494f, -1.21896052f, -0.23898952f, -0.59907198f, -0.17934068f, 0.00706163f, 0.03434937f, -0.08644934f, 
    -0.13010949f, 0.02763624f, 0.42217284f, -0.16060248f, -0.30251098f, -0.29639709f, 0.23077197f, 0.32216558f, 
    -0.07159082f, -0.00734848f, 0.19902523f, -0.10022629f, 0.90548384f, 0.61316985f, 1.34570968f, 0.53479165f, 
    -0.36996192f, -1.20349073f, -0.13232328f, -0.49813792f, -0.12285435f, -0.59464449f, 0.13927135f, -0.18209495f, 
    -0.27751637f, 0.16057822f, 0.20949928f, -0.35294777f, -0.33834729f, 0.07453933f, 0.04294129f, 0.07677723f, 
    -0.38361639f, 0.00048905f, -0.05107125f, -0.16683400f, -0.08166400f, -0.54367673f, -0.87087178f, 0.25719649f, 
    0.68260801f, 0.36329302f, -1.07905006f, -0.01488857f, -0.52907151f, -0.31772977f, 0.08617910f, 0.74099857f, 
    0.54828060f, 0.29941198f, 0.25269651f, 0.07692064f, 0.15321398f, 0.22101189f, 0.01581093f, 0.50006801f, 
    0.01031125f, 0.04959915f, 0.02728202f, 0.07532381f, 0.21965584f, 0.33963370f, -0.19888462f, -0.44036955f, 
    -0.70569360f, -0.44105604f, 0.20967101f, -0.64624828f, -0.79963028f, 0.08882260f, 0.15137745f, 0.14241435f, 
    -0.30491012f, -0.32930055f, 0.52528983f, -0.36436528f, -0.66802949f, 0.27795112f, -0.52572149f, -0.20603877f, 
    -0.40651244f, 0.01535627f, -0.46090272f, 0.08951099f, 0.09448554f, 0.00059932f, -0.21367846f, -0.94311380f, 
    -1.25964034f, -0.58211118f, -0.02098966f, 0.15890868f, -0.52415407f, 1.02431226f, 0.71128500f, -0.45091707f, 
    0.59547001f, 0.02782895f, 0.27689421f, 0.47366092f, -0.17100726f, 0.22789524f, -0.44412822f, -0.13328777f, 
    -0.07328927f, -0.03516031f, -0.15392783f, 0.20931089f, 0.01765724f, -0.05638209f, -0.06782670f, 0.13928407f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.34668225f, 0.15294917f, -0.05294602f, 0.30930170f, 0.30946544f, 0.19994912f, 0.14416689f, 0.39505357f, 
    0.34754384f, 0.15033215f, 0.37366325f, 0.39484990f, 0.32449350f, 0.21581393f, 0.15297920f, 0.25435936f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.50564092f, 0.02450243f, -0.03957744f, 0.25782749f, -0.04121184f, 0.12279049f, 0.13303787f, -0.19583598f, 
    0.01303294f, 0.04785863f, 0.11089798f, 0.03358644f, 0.42243585f, 0.00779458f, -0.06395435f, 0.51875049f, 
    0.06356235f, -0.05466074f, -0.07733077f, 0.13953301f, -0.16320935f, 0.11941246f, 0.01741581f, 0.12952602f, 
    -0.37929732f, -0.10105539f, 0.28500557f, -0.03896741f, -0.16493621f, 0.01927519f, 0.13975306f, 0.05900340f, 
    -0.02879393f, 0.22636139f, 0.06530002f, 0.16838101f, 0.37243143f, 0.12561390f, -0.10306069f, 0.07053035f, 
    0.01279746f, 0.03931103f, -0.00333882f, 0.04089839f, -0.07391638f, -0.23348136f, -0.03368612f, 0.14094304f, 
    0.04204309f, -0.43541446f, -0.02384544f, 0.37808496f, 0.16356176f, -0.10890117f, -0.01763379f, 0.08496843f, 
    -0.00318387f, 0.25420445f, -0.11864282f, -0.15127863f, -0.23058015f, -0.09140192f, -0.19360885f, 0.13740122f, 
    -0.18172739f, 0.10954046f, 0.00190272f, 0.04108709f, 0.09649649f, -0.03994741f, 0.07754748f, 0.18023808f, 
    -0.06765548f, -0.32618046f, -0.10897177f, 0.19242474f, 0.15934856f, -0.05004822f, 0.08220261f, 0.12186307f, 
    0.10402000f, 0.00737931f, -0.03951511f, -0.14301293f, 0.24224602f, 0.23054998f, 0.22089161f, -0.01729497f, 
    0.08893766f, -0.05236693f, 0.23404042f, 0.12114682f, 0.00994076f, -0.01215021f, -0.02405037f, 0.02866729f, 
    -0.36087683f, -0.01188555f, 0.13180305f, 0.16444810f, 0.05232992f, 0.25471950f, 0.02146755f, 0.03073414f, 
    -0.15369096f, -0.08431669f, -0.00283786f, -0.09603224f, -0.14991048f, 0.01203040f, -0.09530933f, 0.16029552f, 
    0.12637208f, 0.01789184f, -0.24612205f, -0.21761708f, 0.04506942f, -0.05610121f, -0.03401967f, -0.03921402f, 
    0.44632795f, -0.03817776f, 0.07824998f, 0.57339936f, -0.08335669f, 0.05956408f, -0.02722220f, 0.14501281f, 
    0.09880494f, -0.02940984f, 0.02728400f, 0.07283472f, 0.02125980f, 0.01517142f, 0.14441453f, 0.35310334f, 
    0.02132873f, 0.14040405f, 0.08654095f, -0.12164126f, -0.09016736f, -0.01540792f, 0.00706537f, -0.05864886f, 
    -0.06900596f, 0.11333323f, 0.28660578f, -0.19796024f, 0.12123245f, -0.07438022f, 0.21054642f, 0.07420979f, 
    0.17588674f, -0.20873420f, 0.04915762f, 0.15865032f, -0.57690525f, 0.14848106f, -0.00918918f, 0.09617065f, 
    0.14449099f, 0.13750763f, -0.06460006f, -0.07537785f, 0.06135209f, 0.04861142f, -0.01268897f, -0.36303747f, 
    0.40475681f, 0.37144464f, -0.08113349f, 0.42578745f, -0.01913946f, -0.01131449f, 0.23700394f, 0.09497006f, 
    -0.07622181f, 0.22945309f, -0.16321176f, 0.06624217f, 0.05917940f, -0.08429337f, 0.05425755f, -0.21710826f, 
    -0.10752640f, 0.00695940f, 0.20532602f, -0.13617745f, -0.18960209f, 0.07321482f, -0.20106646f, 0.14936483f, 
    -0.10094263f, -0.13799721f, 0.44742370f, 0.16127490f, 0.01873127f, -0.00845522f, 0.12471364f, 0.12656532f, 
    0.00653995f, 0.06748442f, 0.03246181f, -0.12034275f, 0.09682901f, 0.14939706f, 0.10412230f, -0.22830243f, 
    -0.02367338f, -0.01202454f, -0.11749918f, -0.02762306f, -0.03227209f, -0.06434851f, 0.12086015f, -0.21298328f, 
    0.11931404f, 0.06305098f, -0.08871622f, 0.00655526f, -0.00535359f, 0.02984500f, 0.10350633f, 0.07886200f, 
    -0.08571482f, 0.15658112f, 0.01247362f, -0.09755953f, -0.10698010f, -0.00999569f, -0.13418067f, -0.31879619f, 
    0.03808441f, -0.05037580f, -0.08124971f, -0.10870337f, -0.06150728f, 0.09775387f, 0.00557764f, -0.00825127f, 
    0.36473328f, -0.20649120f, 0.09289241f, -0.27920035f, -0.13860378f, -0.06163433f, -0.17465307f, -0.10200592f, 
    0.12749647f, 0.12921627f, 0.07595125f, 0.09232637f, 0.46219063f, 0.14396547f, 0.04488461f, -0.11933880f, 
    0.25104901f, -0.08829542f, 0.07208225f, 0.04074674f, 0.00300783f, 0.15917078f, 0.18897238f, 0.00518786f, 
    0.37816495f, 0.28309479f, -0.03483858f, 0.13830800f, -0.05688493f, -0.04489677f, 0.00072883f, -0.02794164f, 
    0.01559502f, 0.08133685f, 0.04766798f, -0.04374354f, -0.12427146f, 0.05672118f, 0.08601762f, -0.01441713f, 
    -0.09757774f, 0.14668193f, -0.06010162f, 0.20432979f, -0.06865995f, -0.00893639f, 0.06096144f, 0.20048521f, 
    0.53444147f, 0.05654617f, -0.12398796f, -0.21286850f, -0.15130837f, -0.18501592f, 0.12046043f, 0.02016634f, 
    0.01974087f, -0.01482131f, -0.07787357f, -0.06776092f, 0.07967728f, 0.03420544f, -0.06724231f, 0.21768971f, 
    0.33131012f, 0.13952303f, 0.14731382f, 0.11397114f, -0.00972838f, 0.08590361f, -0.15617631f, -0.06114196f, 
    -0.16146055f, 0.29475880f, -0.11925776f, -0.08071910f, -0.03982890f, -0.05842502f, -0.07622077f, -0.04987970f, 
    0.11898886f, 0.10298667f, -0.01728240f, -0.15361856f, -0.30557230f, -0.06873175f, -0.03365977f, -0.08351569f, 
    -0.08449747f, -0.06278032f, -0.16783999f, 0.03861031f, 0.22163531f, 0.10683931f, 0.05234838f, -0.01076741f, 
    0.51610947f, -0.24674647f, -0.10654325f, 0.22369692f, 0.01666970f, -0.12037309f, -0.29500797f, -0.11263815f, 
    0.28513294f, 0.01386544f, 0.06717875f, 0.03604966f, -0.43423533f, 0.01950469f, -0.19582754f, 0.01327469f, 
    -0.03667523f, -0.20250238f, -0.04873669f, 0.11956946f, -0.10329957f, 0.12497547f, -0.06524158f, 0.09221516f, 
    -0.31352401f, 0.22523502f, -0.27419436f, -0.21105209f, 0.06314600f, -0.16835357f, 0.11741903f, 0.11588440f, 
    0.10409199f, 0.13023156f, 0.14987390f, 0.02871176f, -0.32793075f, 0.27123863f, 0.22140655f, 0.23919669f, 
    0.04805762f, 0.07780955f, 0.06006961f, -0.11596508f, 0.02783958f, -0.02931247f, -0.03670533f, -0.04992386f, 
    0.26247787f, -0.29187322f, -0.41059881f, -0.01001242f, -0.08864465f, 0.04005712f, -0.09720918f, -0.11892029f, 
    -0.01054487f, -0.01309446f, -0.05779020f, -0.04530676f, -0.15644391f, 0.03503192f, -0.15445831f, -0.16694613f, 
    -0.14612401f, -0.09719005f, -0.07197287f, -0.32539535f, 0.24822477f, 0.21813966f, -0.02338628f, 0.00784173f, 
    -0.08868995f, -0.04417249f, -0.17995918f, 0.05755215f, 0.03855483f, 0.02026981f, -0.06645445f, 0.01286066f, 
    0.10228360f, 0.02796022f, -0.03538512f, -0.14606839f, -0.45437869f, -0.30366898f, 0.16483285f, 0.11740113f, 
    -0.10774706f, 0.01968297f, 0.08004063f, -0.07066382f, 0.01881707f, 0.26412952f, 0.04047666f, -0.05310066f, 
    0.32863685f, 0.24574032f, -0.26647002f, 0.33992565f, 0.01767364f, -0.05479300f, 0.18766110f, 0.16115963f, 
    0.12781005f, -0.03315445f, 0.15334016f, 0.08647290f, 0.19075052f, 0.00258665f, 0.16889155f, 0.34442174f, 
    0.00819475f, -0.11385711f, -0.18310626f, 0.11425357f, 0.14318179f, -0.06894254f, -0.06555069f, 0.11577701f, 
    -0.62632078f, 0.55347478f, 0.17320253f, -0.13816902f, -0.01654512f, -0.06307571f, 0.17582390f, -0.12150525f, 
    0.05810912f, 0.03155582f, -0.11720300f, 0.16755585f, -0.36601707f, 0.13503131f, 0.10637245f, -0.48030847f, 
    0.15289035f, 0.13157222f, -0.08878115f, -0.03888306f, 0.01287629f, -0.04547213f, 0.27898183f, -0.09680829f, 
    0.40355867f, 0.38736391f, -0.14359584f, 0.28861877f, 0.02201265f, -0.18340291f, -0.06776416f, 0.10298322f, 
    0.24903798f, 0.25837010f, 0.00680863f, 0.02279872f, 0.27379313f, -0.14298569f, 0.19821163f, -0.13688283f, 
    0.10979881f, -0.01869529f, 0.08944304f, 0.02046194f, 0.11716115f, -0.10244600f, -0.12031266f, 0.00165893f, 
    -0.03216591f, 0.00236564f, -0.19487251f, 0.29005241f, -0.03940910f, -0.06980088f, -0.08730910f, -0.11300062f, 
    0.01519999f, 0.02543774f, 0.32430577f, 0.05889173f, -0.21571106f, 0.20393081f, -0.09004378f, 0.07940098f, 
    -0.09006809f, -0.09888656f, -0.05067642f, 0.10760377f, -0.11371986f, 0.03479407f, -0.09343559f, 0.14145905f, 
    0.46003559f, 0.20237374f, -0.05679665f, 0.42026988f, 0.04093273f, -0.06158591f, 0.12890130f, 0.09898146f, 
    -0.06159323f, 0.09110343f, 0.19045702f, 0.02493295f, -0.12027276f, 0.17991352f, -0.01116053f, -0.03708889f, 
    0.08627048f, 0.07356577f, 0.04488577f, 0.04897643f, -0.02413403f, 0.03518520f, 0.04000217f, 0.11096772f, 
    -0.11011370f, 0.16171449f, -0.12452821f, -0.31705770f, 0.10063434f, -0.11863823f, 0.05503400f, -0.22715349f, 
    0.06461895f, -0.22002998f, -0.01850106f, 0.10526811f, -0.48626068f, 0.26274022f, -0.23892456f, -0.04268214f, 
    0.19515339f, 0.06997225f, 0.11618414f, 0.01231424f, -0.02932415f, -0.24539495f, 0.18879355f, -0.03594927f, 
    -0.04347116f, 0.01289592f, 0.05444551f, -0.05932494f, -0.07626294f, -0.05419311f, 0.02434812f, -0.03257414f, 
    -0.08095016f, 0.06573072f, -0.05850049f, -0.05539878f, 0.00136789f, -0.02396227f, -0.03379532f, 0.06067336f, 
    -0.04023995f, 0.06354532f, -0.04617247f, 0.00855782f, 0.05376925f, -0.05006204f, 0.06578990f, -0.05421618f, 
    0.02363198f, -0.07701696f, -0.03417376f, -0.02625124f, 0.02744175f, -0.01624463f, 0.02797793f, -0.07172981f, 
    -0.00344053f, 0.03498339f, -0.05220512f, 0.05190169f, 0.03628682f, 0.00905108f, 0.02970328f, -0.02039961f, 
    -0.07386220f, -0.05166314f, -0.06240382f, 0.04900726f, 0.05103228f, 0.01097061f, 0.05750322f, -0.04960435f, 
    -0.04225378f, -0.06945848f, -0.07372543f, 0.02968914f, 0.01571115f, 0.03577311f, 0.01291369f, -0.03931488f, 
    -0.06733717f, 0.06415658f, 0.03634348f, 0.06393713f, 0.04602384f, -0.00653757f, 0.03371535f, 0.04731077f, 
    0.04015706f, -0.00433577f, -0.03153023f, 0.00640416f, -0.00512277f, 0.04685464f, -0.04483557f, 0.06935664f, 
    -0.02289347f, -0.03715872f, -0.04260929f, 0.05324973f, -0.06676558f, -0.03488160f, 0.04998193f, -0.07305436f, 
    -0.04642840f, -0.06147762f, -0.01907331f, -0.00850535f, 0.05859592f, 0.05750124f, -0.07120493f, 0.01086402f, 
    -0.04009042f, 0.04100966f, -0.06901321f, 0.01536168f, -0.06930085f, -0.05590129f, 0.01271135f, -0.04422961f, 
    0.01791696f, 0.05063556f, -0.03427075f, -0.06583872f, -0.00608399f, 0.01175389f, 0.04997976f, -0.03451607f, 
    0.03140742f, -0.03991719f, 0.04680445f, -0.06704141f, -0.03239544f, 0.02408116f, 0.01447345f, 0.01101179f, 
    -0.03967413f, 0.05865465f, -0.06710898f, 0.00999801f, -0.07045922f, 0.03032891f, -0.05026127f, 0.02722170f, 
    -0.03696425f, -0.07134169f, 0.05170021f, -0.03365498f, -0.02449539f, -0.00154771f, -0.02371540f, -0.02324918f, 
    -0.01133772f, 0.02829218f, -0.07861306f, 0.02391476f, -0.05963603f, -0.00734530f, 0.02822067f, 0.03528983f, 
    -0.03833904f, 0.05487289f, -0.07492244f, 0.01621581f, 0.01660526f, -0.07387245f, 0.02911855f, 0.02587244f, 
    -0.03000856f, 0.05158078f, 0.03796658f, -0.07517901f, 0.00407747f, -0.00855819f, -0.02154942f, -0.02361482f, 
    -0.03851767f, 0.04217302f, -0.03566135f, 0.06357882f, 0.05237100f, -0.07021374f, 0.01354092f, 0.04070353f, 
    -0.00213857f, -0.06986497f, -0.03299888f, -0.08096997f, -0.07692946f, -0.06518977f, -0.01133886f, -0.06176612f, 
    0.00158703f, -0.01263234f, 0.04711043f, -0.03640173f, -0.02155321f, 0.05684107f, -0.03731335f, 0.05698443f, 
    -0.04912270f, -0.07231165f, -0.07978979f, 0.02500686f, -0.01679728f, -0.04699010f, 0.05251374f, -0.03000494f, 
    0.01972653f, 0.02825092f, -0.01318651f, -0.01138985f, 0.02840131f, -0.00902797f, -0.00389834f, -0.07505689f, 
    0.36032265f, 0.09445172f, 0.13164283f, -0.23369090f, 0.16372365f, 0.08537908f, 0.16273254f, 0.17939183f, 
    0.12608629f, -0.03993123f, -0.09612568f, -0.15995903f, 0.13198175f, 0.21546787f, 0.20719291f, 0.02764825f, 
    0.22694287f, 0.29735428f, 0.18830243f, 0.05851429f, -0.13158034f, -0.09602474f, -0.12129751f, -0.08986042f, 
    -0.41457537f, 0.02174818f, -0.12097494f, -0.10667507f, 0.25112659f, -0.07141394f, -0.03853573f, 0.03928396f, 
    0.10577027f, 0.01715916f, 0.03996638f, -0.03682375f, -0.35066369f, 0.06801231f, 0.14601007f, 0.24811344f, 
    0.15185541f, 0.05189390f, 0.03662458f, 0.09494162f, 0.01093922f, 0.10873573f, -0.04901615f, 0.10237132f, 
    -0.06049979f, 0.24755698f, 0.14981522f, -0.40117818f, 0.06266118f, -0.03780073f, 0.08637080f, -0.02487643f, 
    -0.09943057f, -0.00559925f, 0.11306487f, 0.17434801f, 0.34918702f, 0.08742577f, 0.09830649f, -0.24149120f, 
    0.06840517f, 0.06750230f, -0.12840073f, -0.11217213f, -0.01158350f, -0.13659151f, -0.10972354f, -0.18811733f, 
    0.75565815f, -0.00448320f, 0.21736105f, -0.12022658f, 0.16223778f, 0.06265510f, -0.22524711f, 0.05230810f, 
    0.06749376f, 0.05946463f, 0.09054607f, -0.14487243f, 0.02318078f, -0.11462151f, -0.14177059f, 0.17148021f, 
    -0.09185721f, 0.02776181f, -0.02349210f, -0.05043552f, -0.08131934f, 0.05471317f, -0.01110528f, 0.08618239f, 
    0.21440810f, -0.30593735f, -0.08304602f, -0.15743318f, 0.05901900f, 0.04176440f, -0.13982937f, -0.09612004f, 
    0.04097976f, -0.04937803f, -0.07673997f, 0.13608596f, 0.13040623f, 0.04780071f, -0.00062665f, 0.12905529f, 
    -0.12324861f, -0.09903251f, 0.01779977f, 0.06286167f, -0.00962276f, -0.01526190f, -0.07738169f, -0.04932274f, 
    -0.04558245f, 0.08196899f, 0.08846017f, -0.41297069f, -0.02254927f, 0.01711317f, -0.12858865f, 0.02081324f, 
    -0.19590881f, 0.26902756f, -0.05214996f, -0.11413151f, 0.10288247f, -0.15408343f, 0.11060400f, -0.28846964f, 
    -0.01622164f, -0.11178828f, -0.20786500f, -0.05656000f, -0.05148439f, -0.04652475f, 0.07779863f, 0.15401958f, 
    0.13972828f, -0.30436465f, -0.21859339f, 0.15788077f, -0.16229104f, 0.05208812f, -0.12169335f, -0.04492968f, 
    -0.08142101f, -0.09638362f, 0.00140795f, 0.06451948f, 0.31477067f, -0.03179741f, -0.01550387f, -0.15179706f, 
    -0.03703063f, 0.00000919f, -0.09678968f, 0.00039402f, 0.02716241f, 0.08639054f, 0.18201064f, 0.15778026f, 
    0.06003501f, -0.16283765f, 0.19372380f, -0.05487195f, 0.18604754f, -0.02124261f, -0.06732045f, 0.01208258f, 
    -0.20566137f, -0.12799059f, 0.03405032f, -0.10575774f, 0.69211489f, 0.04784429f, 0.06182586f, 0.08197513f, 
    -0.01978309f, 0.10959941f, 0.05975911f, 0.03554729f, -0.05660661f, 0.00647197f, -0.00440875f, -0.15305533f, 
    -0.03395769f, 0.06205988f, -0.01170057f, -0.04389169f, -0.06108173f, -0.02987572f, 0.05290070f, -0.07280321f, 
    0.04020495f, 0.03797515f, -0.05641108f, -0.07087676f, -0.07016627f, -0.07162695f, -0.04392828f, 0.06531129f, 
    0.00885532f, -0.02897744f, 0.03674773f, 0.05601674f, -0.01729118f, 0.05510946f, 0.01407968f, -0.02459215f, 
    -0.04496824f, 0.05030626f, -0.05419920f, -0.07406029f, 0.03812003f, 0.03628206f, -0.02452048f, -0.04866182f, 
    -0.02735578f, -0.05019918f, 0.05119484f, -0.00611974f, -0.06979845f, -0.01177103f, 0.04815575f, -0.01260329f, 
    -0.04686598f, -0.03942117f, -0.05807425f, -0.02909171f, -0.05304802f, -0.03861230f, 0.05741097f, -0.03920532f, 
    -0.00273204f, -0.07347118f, 0.01528649f, -0.03072797f, 0.06606369f, 0.05185154f, 0.03368165f, -0.04660671f, 
    -0.02531487f, 0.01975704f, -0.07113612f, 0.05941323f, 0.01207974f, 0.02366935f, 0.02374404f, -0.05526317f, 
    0.02381285f, -0.06968332f, -0.05050561f, -0.07524379f, -0.02019884f, 0.06461257f, 0.06574467f, -0.04180134f, 
    -0.07325689f, -0.06373161f, 0.00564802f, 0.03487568f, 0.01623985f, -0.07666805f, -0.05002683f, 0.00209034f, 
    -0.07381653f, 0.02155198f, -0.00895586f, -0.00083746f, 0.03698815f, -0.05734360f, -0.05369687f, -0.03758303f, 
    -0.00178259f, 0.06170223f, -0.07134265f, 0.02910884f, 0.03167270f, 0.06286984f, -0.04259605f, -0.02198791f, 
    -0.06397332f, -0.00858998f, -0.07723501f, -0.05580778f, 0.05606846f, 0.00311848f, 0.01478525f, -0.00305511f, 
    0.02649079f, -0.04122315f, -0.06538028f, 0.03599710f, 0.02373031f, 0.00182924f, -0.03897963f, 0.06348096f, 
    0.00460467f, 0.02146668f, -0.06843318f, 0.06176269f, 0.06225459f, 0.00077914f, -0.02387035f, -0.04804615f, 
    -0.06977269f, -0.01282680f, 0.05310304f, 0.04635955f, 0.02437016f, -0.00324283f, 0.01224207f, 0.02044397f, 
    -0.02568824f, -0.04147641f, 0.01775358f, -0.07057986f, 0.05221320f, -0.07274921f, 0.03228098f, 0.02156895f, 
    0.01779479f, 0.01275528f, -0.05488953f, -0.07317638f, 0.03265754f, -0.02331252f, 0.02878795f, 0.01192671f, 
    0.03686417f, 0.01166610f, -0.06085311f, -0.03589970f, -0.05408140f, -0.02560079f, -0.03126585f, 0.02106362f, 
    -0.04897608f, -0.02279669f, -0.06812824f, -0.03246372f, -0.05449631f, -0.04688121f, -0.01845493f, -0.00437206f, 
    0.03578036f, 0.04200197f, -0.03858319f, 0.01097197f, -0.05709945f, -0.05122339f, -0.06831196f, 0.01305972f, 
    -0.05710547f, 0.00635607f, -0.03988555f, 0.01131047f, -0.00258083f, -0.03458910f, 0.02508714f, -0.01920278f, 
    -0.01444580f, 0.01371936f, 0.04955310f, 0.01421465f, 0.06470867f, 0.03860248f, 0.01065023f, -0.03280841f, 
    -0.03263149f, 0.03508247f, 0.04126798f, -0.04589427f, 0.00849596f, 0.01633610f, -0.06785899f, -0.03198070f, 
    -0.07730893f, -0.05770960f, 0.00891117f, -0.07411499f, 0.05614978f, 0.04454547f, -0.04060844f, 0.01201152f, 
    -0.04909198f, -0.04882637f, -0.01013600f, -0.04634378f, -0.00494286f, -0.05473711f, -0.03959760f, 0.01301769f, 
    0.00127244f, -0.03766219f, 0.05124006f, -0.00351013f, -0.00629033f, 0.04959761f, 0.04772308f, 0.01407043f, 
    0.06238296f, -0.01862418f, -0.05434250f, 0.05133793f, 0.06355571f, -0.04020735f, 0.02633518f, 0.02724047f, 
    0.03043575f, -0.03141795f, -0.00396843f, -0.06935419f, -0.03217104f, -0.00807723f, 0.02323527f, -0.06447729f, 
    -0.05854830f, -0.02067734f, -0.07487040f, 0.05346577f, 0.05255785f, -0.06085291f, 0.02948481f, 0.04245696f, 
    0.06258207f, 0.00219926f, -0.00485980f, -0.05149520f, 0.03566459f, -0.04122164f, -0.06003175f, -0.00445606f, 
    -0.00498956f, -0.00661533f, -0.03455821f, -0.02931602f, -0.05458002f, 0.05382268f, -0.02613789f, 0.04774629f, 
    -0.02512310f, 0.04621218f, 0.01597961f, -0.00085891f, -0.05046596f, -0.02105941f, 0.02086455f, -0.06950285f, 
    0.01786136f, 0.02744304f, 0.00424164f, 0.02126257f, -0.00866879f, -0.03646130f, -0.00047109f, 0.03268835f, 
    0.01534297f, -0.07062474f, -0.00582219f, -0.00936378f, -0.06511976f, 0.04367242f, 0.04361629f, -0.07501603f, 
    -0.00512267f, -0.03107048f, 0.00158974f, -0.05017985f, -0.03594207f, -0.06113897f, -0.07603393f, 0.06267533f, 
    0.02312750f, 0.02043937f, 0.00501279f, 0.00847722f, -0.05002796f, 0.01165032f, -0.03991035f, 0.06238263f, 
    -0.02513298f, -0.03209399f, -0.07594215f, -0.07766769f, 0.00028213f, -0.02257264f, -0.05428654f, 0.01669254f, 
    -0.01645850f, -0.01237306f, 0.06943170f, -0.05687055f, -0.07146559f, -0.00874336f, -0.07789090f, -0.05126608f, 
    -0.04475323f, -0.03293999f, -0.03124862f, 0.00589229f, -0.02900233f, -0.04275041f, -0.01239503f, 0.01621118f, 
    0.03836727f, -0.01847596f, -0.00849987f, 0.01371327f, -0.05050438f, -0.03015016f, -0.04548661f, -0.03868443f, 
    -0.05409199f, -0.05263712f, 0.00276716f, -0.02770094f, -0.05206475f, -0.01373495f, 0.02079295f, 0.00648403f, 
    -0.03040349f, -0.03104863f, 0.05730683f, -0.04159939f, -0.06387818f, -0.02904201f, 0.02132072f, 0.03759342f, 
    -0.00886243f, 0.06142023f, -0.04201402f, 0.06267519f, -0.06286703f, -0.00756172f, -0.05105370f, -0.03399661f, 
    -0.06820107f, -0.01594781f, -0.05729014f, 0.02181604f, -0.04543804f, 0.05563748f, 0.05418142f, 0.01564898f, 
    0.00931146f, 0.05221188f, 0.02681689f, -0.07823451f, 0.01821014f, 0.05705511f, -0.02437021f, 0.00768999f, 
    0.01869370f, 0.03449986f, -0.03937351f, -0.02218424f, -0.05177666f, -0.01792997f, 0.02754840f, 0.05231785f, 
    -0.03812372f, -0.04226760f, -0.01950587f, 0.06414126f, -0.05155490f, 0.02950775f, -0.06091895f, 0.00234067f, 
    -0.02855868f, 0.01258303f, -0.06742050f, -0.05468438f, -0.04951974f, 0.00906871f, -0.03349280f, 0.06016244f, 
    -0.00840310f, 0.02166457f, 0.04668237f, 0.03001847f, 0.02183854f, -0.05858741f, -0.05640948f, -0.02952325f, 
    -0.03938472f, -0.05307378f, -0.01884169f, -0.06945875f, 0.01552849f, 0.04467624f, -0.06536529f, -0.03474072f, 
    0.00271274f, -0.06268256f, -0.04464445f, -0.03713122f, -0.02533525f, 0.06771344f, -0.03738853f, -0.06906401f, 
    -0.07139066f, -0.05563400f, 0.04463792f, -0.00110741f, -0.05584797f, -0.07213722f, -0.02618031f, 0.01188030f, 
    -0.05708873f, -0.06988569f, -0.05700211f, 0.01313804f, -0.02613910f, 0.02155930f, 0.02728132f, -0.04500993f, 
    0.03873395f, 0.03619725f, -0.01127355f, -0.03425780f, 0.02791865f, 0.04938741f, 0.05837881f, 0.05660303f, 
    -0.01141227f, 0.00336079f, 0.05935265f, 0.04784504f, 0.05024647f, -0.06709275f, -0.06897349f, 0.02602572f, 
    0.04877345f, -0.01598183f, -0.03447441f, 0.01787728f, -0.01831535f, -0.04234357f, 0.05407516f, -0.02803171f, 
    0.05361927f, -0.04349929f, -0.03877102f, -0.05690763f, 0.00038630f, -0.03668750f, -0.01319002f, -0.05230979f, 
    -0.04342538f, -0.05095054f, 0.04848336f, 0.00552531f, 0.01005877f, -0.01372914f, -0.03599045f, 0.02396947f, 
    0.00303557f, 0.01949494f, 0.01814425f, 0.05188381f, -0.01295910f, 0.04354985f, 0.05578444f, -0.01126505f, 
    -0.02505624f, -0.07907882f, -0.06404945f, 0.02271018f, -0.03085416f, -0.02630314f, -0.06719019f, -0.06138813f, 
    0.01521325f, -0.05183595f, -0.01118296f, 0.04041182f, -0.04130467f, -0.01670617f, -0.05809953f, -0.02543943f, 
    -0.01553323f, -0.00823399f, -0.00452650f, 0.00777099f, -0.00442116f, -0.00877369f, 0.01287566f, -0.06834382f, 
    -0.06342893f, -0.06078349f, -0.01039248f, 0.01830243f, -0.02757137f, -0.06775489f, -0.01905785f, 0.02738145f, 
    0.04973307f, -0.04647047f, 0.00924220f, 0.00407416f, 0.01298088f, -0.02512941f, 0.04495183f, -0.00951382f, 
    -0.06009337f, -0.05881063f, 0.04250298f, 0.03930906f, 0.05331222f, 0.02791318f, -0.00926224f, -0.02392808f, 
    0.06119070f, 0.01864894f, -0.02917228f, -0.05410114f, -0.03144577f, 0.00434720f, 0.04331374f, -0.01194316f, 
    -0.00458582f, 0.05583555f, -0.06088898f, -0.02939094f, 0.03596201f, -0.05780961f, 0.05656449f, 0.06145817f, 
    -0.00863043f, -0.07694618f, 0.05669901f, 0.04080210f, 0.04535260f, -0.07156444f, 0.04947821f, -0.07488955f, 
    0.05299215f, -0.04546101f, -0.02110960f, -0.06936997f, -0.01409467f, 0.02724223f, -0.04482495f, 0.01679753f, 
    0.01569435f, -0.00977054f, -0.02300747f, -0.02383363f, -0.00483651f, 0.02532370f, 0.00589081f, -0.06559131f, 
    -0.02308167f, 0.02202193f, -0.00234947f, 0.05470604f, -0.01561973f, 0.00816272f, 0.04682165f, -0.03554243f, 
    -0.18186183f, 0.03566382f, -0.02233541f, -0.16028871f, 0.21803722f, 0.04286214f, -0.26521966f, -0.00854694f, 
    0.05095738f, -0.00708829f, 0.08544161f, 0.13039257f, -0.42584717f, -0.02732198f, -0.34327784f, -0.13304864f, 
    0.03981017f, -0.11341617f, 0.01531366f, 0.10551813f, 0.11130552f, -0.17335129f, -0.03424679f, -0.06296833f, 
    0.25312588f, -0.40509126f, 0.23859829f, -0.17192057f, 0.09499054f, 0.05354124f, -0.08655293f, 0.04384576f, 
    0.07855821f, -0.25612170f, -0.00367156f, 0.13842180f, -0.15115964f, -0.12347891f, 0.26834667f, 0.24609080f, 
    0.05282814f, 0.03714957f, 0.17124322f, 0.11340051f, 0.01318612f, -0.01544739f, 0.10757463f, 0.02065746f, 
    0.60125691f, 0.43993860f, -0.07516709f, -0.07134050f, -0.17734525f, -0.04304998f, 0.00082947f, -0.06134426f, 
    -0.30962220f, -0.09340631f, 0.01654969f, 0.06624544f, 0.31975880f, 0.46037480f, -0.00256225f, 0.35000741f, 
    -0.01562433f, -0.04228139f, 0.02114237f, 0.08592877f, 0.03768294f, 0.32262999f, 0.15675968f, -0.18417016f, 
    0.15420195f, -0.06538704f, -0.03762785f, -0.10129031f, 0.04918738f, 0.00955833f, 0.01655874f, 0.03709251f, 
    0.03945987f, 0.00304765f, 0.13357371f, 0.01208306f, -0.03715026f, 0.03643065f, 0.05876565f, 0.22440225f, 
    -0.05120125f, -0.11523097f, 0.22233985f, -0.09977062f, 0.29825166f, 0.05784873f, 0.13493790f, 0.19406761f, 
    0.47303274f, 0.32180414f, 0.10795978f, 0.24368283f, 0.09902488f, -0.03157073f, 0.04219888f, 0.23979843f, 
    0.02064417f, 0.04363775f, 0.00565803f, -0.30848590f, 0.13286573f, 0.72221684f, 0.29312623f, 0.09746747f, 
    0.11131931f, 0.12756984f, -0.26966205f, 0.00231784f, 0.10870092f, 0.16967110f, 0.28621465f, -0.01380259f, 
    -0.35553360f, -0.11922026f, 0.01685197f, -0.27967256f, -0.07240300f, -0.00660994f, 0.11230846f, 0.06640144f, 
    0.08758076f, -0.15901802f, -0.09143883f, 0.00881858f, -0.18729287f, -0.11844514f, 0.12872991f, -0.17577134f, 
    -0.08973597f, 0.03332813f, 0.07060248f, 0.02550418f, 0.00028841f, 0.07883427f, -0.02599745f, -0.10358684f, 
    0.32131383f, 0.01470857f, -0.10988561f, 0.02237071f, -0.13278840f, -0.01637878f, -0.05089719f, 0.13550957f, 
    -0.00706880f, -0.04526501f, 0.12889406f, -0.12223358f, -0.44648978f, 0.01143095f, 0.08223969f, 0.10620493f, 
    -0.08615294f, -0.17630106f, 0.01252020f, -0.08005237f, 0.13761514f, 0.03304052f, -0.00166308f, -0.07299007f, 
    -0.12949747f, 0.02088663f, 0.18541119f, -0.17218721f, -0.20188349f, 0.26095310f, -0.13986211f, 0.19892639f, 
    0.01176514f, 0.03074624f, 0.20993756f, -0.03778330f, -0.36610025f, -0.12165312f, -0.00811458f, 0.01496551f, 
    0.25462884f, -0.07175785f, -0.05458277f, -0.07411363f, 0.06987759f, 0.21465644f, 0.05286109f, 0.10576541f, 
    0.43414164f, -0.28209651f, -0.13429365f, -0.30202436f, 0.02958466f, 0.07192187f, 0.18133007f, -0.04818031f, 
    0.07199557f, 0.00693612f, -0.09844750f, 0.03607290f, 0.22852157f, 0.34373477f, 0.04919597f, -0.04939877f, 
    -0.33528358f, 0.06536558f, 0.00398123f, -0.22309318f, 0.18218850f, 0.14975253f, 0.08263854f, -0.16474843f, 
    -0.28024355f, -0.14873385f, -0.17143133f, -0.07198642f, -0.18262437f, -0.01115824f, -0.07783645f, -0.00780380f, 
    -0.03762884f, 0.14527310f, -0.03270964f, -0.00386962f, -0.30370376f, -0.07579925f, 0.08108492f, 0.60047472f, 
    -0.00653642f, 0.15872765f, 0.02181520f, -0.04693077f, -0.13795158f, 0.05907338f, 0.31645364f, -0.03211378f, 
    0.18407261f, 0.23037599f, 0.06564403f, -0.21072450f, 0.23521295f, -0.24076618f, -0.15003200f, 0.10027159f, 
    -0.02672781f, 0.18651617f, -0.01323512f, 0.08609193f, 0.08834147f, 0.06204771f, -0.04760227f, -0.39766476f, 
    0.04976174f, 0.05288020f, -0.16216594f, -0.13820177f, 0.15465707f, -0.11369050f, 0.21510114f, -0.05389947f, 
    0.07504830f, -0.01869118f, -0.00311953f, -0.00353457f, 0.25022879f, 0.00161615f, 0.07864667f, 0.09121180f, 
    -0.06498846f, -0.13133669f, -0.03903690f, -0.12294224f, 0.06604692f, 0.20487000f, -0.08062118f, -0.08329236f, 
    -0.10196016f, 0.03380588f, 0.07458410f, 0.23366213f, -0.05380209f, -0.03147205f, -0.02305203f, -0.16249256f, 
    0.25760439f, 0.04798543f, -0.05823142f, -0.09150862f, -0.12361148f, -0.13140863f, 0.02335138f, 0.08821303f, 
    -0.17994131f, 0.01614301f, -0.14579661f, -0.07760969f, -0.02383219f, -0.30861095f, 0.04687020f, 0.18592261f, 
    0.21685947f, 0.04923263f, 0.15642330f, 0.12088974f, 0.04999553f, 0.04558888f, -0.07933566f, -0.05011748f, 
    0.03756894f, 0.03117850f, -0.07728822f, 0.12414213f, -0.05661355f, 0.29623577f, -0.04881037f, 0.09368573f, 
    -0.10707720f, -0.01912489f, -0.11327320f, -0.22111236f, -0.18419641f, 0.28509504f, -0.07705156f, -0.36870146f, 
    0.00530133f, 0.10380328f, -0.11305916f, 0.32850650f, 0.08039448f, 0.00763881f, -0.02812429f, 0.04248594f, 
    0.53660399f, 0.15938874f, 0.03964636f, -0.12015592f, 0.13839282f, -0.29066679f, -0.18175627f, 0.01633641f, 
    0.06367281f, 0.01470041f, -0.09416362f, 0.14138697f, 0.29316956f, 0.25166988f, -0.42933783f, 0.07004950f, 
    0.03303803f, -0.11719844f, 0.11485188f, 0.18346332f, -0.03327924f, 0.07783800f, -0.16940176f, -0.03106280f, 
    0.05200208f, 0.01656274f, 0.00258888f, -0.33911094f, 0.08085305f, -0.26994124f, 0.15404727f, -0.01056470f, 
    0.04703641f, -0.08932577f, -0.05075318f, 0.11773633f, 0.22663181f, 0.16289255f, -0.19639325f, 0.05326524f, 
    0.06487302f, 0.14905345f, 0.06589375f, -0.01348438f, -0.02398563f, -0.09318183f, 0.11412128f, -0.06400352f, 
    -0.05178590f, -0.05526130f, 0.00839415f, -0.05149341f, -0.03644012f, 0.02422715f, -0.04737267f, -0.00540523f, 
    -0.05090632f, -0.07641262f, -0.05238597f, -0.03736704f, 0.03247960f, 0.05649572f, 0.02900099f, 0.06225486f, 
    -0.03816365f, 0.01534666f, -0.02202925f, 0.04564302f, 0.01789591f, 0.00754828f, 0.04099309f, -0.07050551f, 
    0.05583582f, -0.04052775f, -0.06852645f, -0.03393807f, -0.02963161f, -0.06559623f, 0.04495811f, 0.02630009f, 
    0.03819045f, -0.07213779f, -0.06672398f, -0.03972783f, -0.03820819f, -0.03586841f, -0.02615163f, -0.01993740f, 
    -0.00347898f, 0.01088172f, -0.04151169f, 0.04489845f, 0.02730471f, -0.03041722f, -0.00561794f, -0.04094913f, 
    -0.01451403f, -0.01310627f, 0.04256139f, 0.02466048f, -0.02254478f, 0.04769408f, 0.04451690f, 0.02336669f, 
    0.02048993f, -0.04914972f, -0.03454465f, -0.00181823f, 0.04160310f, -0.06935854f, 0.00563789f, 0.02355172f, 
    0.01778329f, -0.05080040f, -0.04765130f, 0.00396363f, 0.01957865f, 0.06006882f, -0.02182628f, -0.06686230f, 
    0.05554375f, 0.03519463f, -0.06254999f, 0.00465211f, 0.06236999f, -0.01654808f, 0.00827616f, -0.06032204f, 
    -0.00911610f, -0.00653747f, -0.06159653f, -0.04824603f, -0.01192014f, -0.07437916f, -0.02884106f, -0.02246343f, 
    -0.01854712f, -0.02971001f, 0.03136790f, -0.00939316f, -0.06285723f, -0.07076241f, -0.05662465f, -0.03072562f, 
    -0.01869838f, -0.03243590f, 0.04965933f, 0.03300878f, -0.02690786f, -0.06987650f, 0.05503286f, 0.04188946f, 
    -0.04495515f, -0.01276516f, -0.02668862f, -0.04902790f, 0.03424910f, -0.01581462f, 0.00834212f, 0.01858736f, 
    -0.00048094f, -0.01750693f, -0.01617626f, -0.03426848f, 0.05671887f, 0.06316360f, 0.01050956f, 0.05463086f, 
    0.06148531f, -0.05301400f, 0.00613429f, 0.06540610f, -0.02571489f, 0.01660758f, 0.01779034f, 0.02112764f, 
    0.00124500f, 0.00842762f, 0.05877774f, 0.03844765f, -0.07344773f, -0.07084052f, 0.05328654f, -0.05656543f, 
    -0.01213054f, -0.07817268f, 0.03499807f, 0.01163066f, -0.02999993f, -0.00504536f, -0.03310029f, -0.07722116f, 
    0.02762196f, 0.02812169f, -0.01820917f, 0.00328318f, 0.04433845f, 0.00023276f, 0.05727199f, -0.04122365f, 
    -0.02313482f, 0.04381571f, -0.07672991f, -0.04479433f, -0.03211608f, 0.05117043f, 0.06385023f, -0.06926887f, 
    0.06297381f, -0.03398589f, -0.00114211f, -0.05664800f, 0.02139970f, -0.01333424f, -0.02343006f, 0.00636758f, 
    -0.00096364f, -0.05711984f, 0.01061751f, -0.05980269f, 0.01572870f, 0.02067640f, -0.02355315f, -0.01338373f, 
    0.04015930f, 0.02492635f, 0.04162658f, -0.02766302f, 0.03198425f, -0.07150139f, 0.02365339f, -0.01296583f, 
    0.01508922f, 0.03781084f, 0.03373854f, -0.01554723f, -0.01357796f, -0.07469112f, 0.04912601f, 0.02456400f, 
    -0.04568877f, -0.35326043f, 0.12196181f, 0.20369339f, 0.30021971f, -0.07331894f, 0.16920169f, 0.22352581f, 
    -0.00287143f, -0.20539738f, -0.00098316f, -0.13578230f, -0.03234579f, -0.03059632f, 0.05968454f, 0.04666847f, 
    -0.04837497f, -0.13602471f, -0.12801543f, 0.13585654f, -0.08888477f, 0.14491653f, 0.00656290f, 0.10799445f, 
    -0.47913042f, -0.42736617f, -0.03831982f, -0.34498265f, -0.12088151f, 0.06822912f, -0.22817120f, 0.06811102f, 
    -0.10073533f, 0.20831503f, -0.11988264f, 0.03549639f, -0.31491548f, 0.00943590f, -0.19784455f, -0.01667720f, 
    -0.03617199f, 0.10129111f, -0.06625823f, -0.04654023f, -0.12387660f, -0.11282805f, 0.02043382f, 0.09520384f, 
    0.16340603f, -0.07707746f, 0.50560999f, -0.08461122f, -0.19751015f, 0.10336702f, 0.19788757f, -0.08761024f, 
    0.12778047f, 0.08353150f, 0.04835398f, 0.05209284f, 0.07768582f, -0.09611499f, 0.10816581f, -0.15916523f, 
    0.17047197f, 0.29805145f, 0.07255361f, -0.02753493f, 0.20275250f, -0.04013587f, 0.14505431f, 0.10526828f, 
    0.64637005f, -0.27788940f, -0.31664595f, -0.13451925f, 0.03356022f, 0.13403833f, 0.14883241f, 0.21718636f, 
    0.08057217f, 0.03341975f, 0.18008059f, -0.10448796f, 0.22117241f, 0.19640675f, -0.28404844f, 0.22333516f, 
    -0.06583443f, -0.05873730f, -0.03221668f, 0.29258296f, 0.00955477f, 0.02182635f, 0.06718771f, 0.16026099f, 
    0.22308859f, -0.07449119f, 0.44149953f, -0.02621162f, 0.01522329f, 0.26497602f, 0.04456964f, -0.04626437f, 
    -0.04554180f, 0.02428951f, -0.06365494f, -0.03283615f, 0.18988398f, -0.10460531f, -0.11137183f, -0.05275710f, 
    0.31555659f, -0.09027800f, 0.02007245f, 0.06348120f, 0.10243855f, -0.11807089f, -0.05668349f, 0.07700981f, 
    -0.08795311f, 0.03067859f, 0.27105519f, 0.14285521f, 0.09282593f, 0.02761953f, 0.07207118f, 0.09058377f, 
    -0.05512822f, 0.18242769f, -0.00067081f, -0.03519069f, 0.12347803f, 0.01818229f, 0.17721663f, 0.16964468f, 
    -0.16561060f, 0.10385083f, 0.08925387f, -0.03710470f, 0.10655974f, 0.01537665f, -0.03076981f, 0.17858139f, 
    -0.08808403f, 0.31797060f, 0.30602843f, -0.23285252f, -0.07277615f, 0.05724925f, -0.14837104f, 0.02027701f, 
    0.17157638f, -0.08239730f, -0.00053770f, 0.18973669f, -0.03738977f, -0.01138165f, -0.15716697f, 0.23272003f, 
    0.21177426f, -0.07821811f, 0.03070482f, 0.20840240f, 0.02268438f, 0.13615003f, 0.07733186f, -0.10353149f, 
    -0.00612947f, -0.11675315f, -0.34257576f, 0.16263299f, -0.07536318f, 0.04831778f, 0.15380006f, -0.00270995f, 
    0.01057219f, 0.25328615f, -0.14464214f, 0.07282454f, -0.24021898f, -0.02325069f, -0.23247129f, 0.22580971f, 
    0.04298399f, -0.10411076f, 0.14455973f, -0.00882250f, -0.11907259f, -0.09668786f, 0.00810711f, -0.17527790f, 
    0.21253543f, -0.22870868f, 0.05401987f, -0.39846361f, 0.05221355f, 0.03311458f, 0.15022446f, 0.16937973f, 
    0.07586548f, -0.08736023f, 0.00171895f, 0.11984527f, -0.47459239f, -0.07326718f, -0.38378522f, 0.00741499f, 
    -0.00839458f, 0.06665158f, -0.12555920f, -0.04199078f, 0.19230567f, -0.04262936f, -0.16592826f, -0.26773581f, 
    0.72760099f, -0.11485281f, -0.08763762f, -0.07265789f, -0.02349119f, 0.22704303f, 0.04882550f, 0.10670033f, 
    -0.19144771f, 0.08107584f, -0.05400431f, 0.17524423f, 0.43497851f, 0.04072824f, 0.09832737f, 0.07835279f, 
    0.25366879f, 0.11625748f, 0.00605965f, 0.02242635f, -0.08709242f, -0.03060984f, 0.02850708f, -0.00850656f, 
    -0.31940988f, 0.16110243f, 0.26694974f, 0.00400024f, -0.11033662f, -0.18475619f, -0.10132194f, 0.04953299f, 
    -0.17811289f, 0.10322761f, -0.06897754f, -0.04814963f, 0.00107081f, 0.43171445f, 0.43779370f, 0.01675570f, 
    -0.11050940f, -0.01377715f, 0.00405915f, 0.09775310f, -0.11290292f, 0.12851270f, 0.11244924f, 0.12591733f, 
    -0.10611442f, 0.01442646f, 0.01005048f, -0.17735329f, 0.20146073f, 0.16172189f, -0.02538436f, 0.12740101f, 
    -0.04671385f, 0.00012550f, -0.03169071f, -0.13253351f, 0.08372844f, -0.05351323f, 0.08303402f, -0.00673450f, 
    -0.02431748f, 0.04900712f, 0.04916489f, 0.10191616f, 0.01484680f, 0.09266023f, 0.07483746f, -0.02176968f, 
    -0.13645956f, 0.34832871f, 0.23619439f, 0.30669639f, -0.08197668f, -0.09655979f, 0.09855471f, 0.00172090f, 
    0.06186397f, -0.07172899f, 0.03057055f, -0.12409870f, 0.07762102f, -0.38841176f, 0.28347874f, -0.32534063f, 
    0.21197876f, 0.15737979f, 0.03177623f, 0.00801630f, -0.09558399f, 0.13742250f, 0.06494880f, 0.03538693f, 
    -0.46400619f, -0.10700337f, -0.13641739f, -0.15592383f, 0.06867486f, 0.03782005f, -0.02591795f, -0.15022483f, 
    0.21893977f, -0.30724359f, -0.03336466f, 0.02577773f, 0.02293824f, 0.15516105f, 0.03779889f, -0.11545069f, 
    0.13028654f, 0.04972650f, -0.07879429f, -0.06121438f, 0.03158175f, -0.23921277f, 0.26982754f, -0.09930667f, 
    0.21997297f, 0.31260362f, 0.26125127f, 0.22348122f, -0.13860941f, -0.23505867f, -0.13977484f, -0.08852243f, 
    -0.06607718f, -0.05382081f, -0.12588632f, 0.07612089f, 0.20040673f, -0.20083095f, 0.01206540f, 0.21714886f, 
    -0.13047740f, 0.03205771f, -0.05806113f, -0.10341382f, -0.09740745f, 0.22450934f, -0.03161431f, -0.19583346f, 
    -0.25933924f, -0.43228072f, -0.01954917f, -0.34833136f, 0.14474332f, 0.09821190f, -0.09486993f, 0.11614342f, 
    -0.07335108f, 0.08799905f, -0.04573225f, 0.08501492f, 0.01094835f, -0.26042798f, -0.34542838f, -0.25070944f, 
    0.03899756f, 0.09941011f, -0.02592597f, 0.20235969f, 0.07753149f, -0.03486204f, 0.03553682f, 0.12495540f, 
    -0.14280011f, -0.34850511f, 0.09138700f, -0.12184076f, 0.08418190f, -0.06485707f, 0.22994970f, 0.05802598f, 
    0.08191351f, -0.05671935f, 0.06628826f, 0.00362271f, -0.02336406f, 0.02629136f, -0.20549998f, -0.01135224f, 
    -0.12738815f, -0.29189771f, -0.28750589f, 0.18820751f, -0.13100775f, -0.16783121f, 0.04589900f, -0.19405040f, 
    0.51175696f, 0.04950837f, 0.23248100f, -0.26577070f, -0.07410388f, 0.32366714f, -0.06476437f, 0.08053309f, 
    0.01465142f, -0.13944270f, -0.12804963f, 0.24200405f, 0.47108895f, 0.19987321f, -0.01869576f, 0.01902293f, 
    0.01803987f, 0.11911438f, 0.01309689f, 0.06689644f, 0.00101787f, -0.18829261f, 0.05783478f, 0.20129271f, 
    0.32026824f, -0.21332346f, 0.05801753f, -0.06025338f, -0.10194306f, -0.16562800f, -0.12651196f, -0.26146579f, 
    -0.21858411f, 0.11235896f, -0.27609238f, 0.05539408f, 0.06631114f, -0.05240745f, -0.32189327f, -0.23688893f, 
    -0.00063786f, 0.09571551f, 0.10110337f, -0.02557350f, 0.12605570f, 0.46574101f, 0.19619164f, 0.05051597f, 
    -0.08164197f, 0.13485706f, -0.35199773f, -0.06897755f, 0.05676372f, -0.12949142f, 0.01682370f, 0.21142164f, 
    -0.05790440f, -0.06197175f, -0.05073249f, -0.10436414f, 0.20683573f, -0.01087614f, 0.13300295f, 0.23576841f, 
    -0.09502657f, -0.11313633f, 0.45127681f, 0.24893905f, 0.21923028f, -0.00945454f, 0.08175438f, 0.06817540f, 
    0.14611489f, 0.02156732f, -0.05123820f, 0.00024228f, -0.12058167f, 0.06703276f, 0.05616922f, -0.11796606f, 
    -0.18653069f, -0.01488628f, 0.02274548f, -0.09748417f, 0.09266809f, 0.43744883f, 0.01897062f, 0.00194562f, 
    0.32771835f, 0.07644722f, -0.07724057f, -0.03323944f, -0.09421658f, 0.13186905f, 0.22283369f, -0.01480537f, 
    -0.17721245f, 0.17669828f, 0.00098270f, 0.28248712f, -0.16047622f, -0.03378889f, 0.09508234f, -0.08368257f, 
    0.03532566f, -0.20285089f, -0.26790744f, 0.14930499f, 0.11552056f, 0.03561841f, -0.00934450f, 0.33362970f, 
    0.11414786f, 0.16296974f, -0.01897817f, -0.12260223f, 0.08826148f, -0.06117202f, 0.15757707f, -0.17095147f, 
    0.35635287f, 0.38625431f, -0.15386324f, -0.17155407f, -0.04451358f, 0.09272252f, -0.19868445f, -0.03609688f, 
    0.05596224f, -0.15397988f, 0.18386212f, -0.03525771f, -0.19261543f, 0.28523764f, -0.04115440f, 0.13828859f, 
    0.07491975f, -0.30543709f, -0.17201079f, -0.22010274f, -0.18519452f, -0.00691912f, -0.23634778f, -0.31784362f, 
    0.06006771f, 0.20705095f, -0.05528051f, 0.21099548f, -0.20400523f, 0.09458438f, -0.15629242f, 0.17449151f, 
    0.01430564f, 0.47760993f, 0.21704715f, 0.21769212f, 0.11262541f, 0.00631335f, -0.16141920f, -0.03019652f, 
    0.04962211f, -0.17026369f, -0.00514194f, -0.08935592f, -0.02574282f, 0.11934014f, -0.09618459f, 0.13233587f, 
    -0.24158999f, 0.17542289f, -0.26162481f, -0.23399003f, 0.08582612f, 0.00786364f, -0.03380125f, -0.03937339f, 
    -0.02006661f, 0.04569428f, -0.08887408f, 0.06274535f, -0.53495145f, -0.13563855f, -0.29552382f, 0.18629861f, 
    0.17553313f, 0.08720987f, -0.03392444f, -0.17701338f, -0.00515400f, -0.04182377f, -0.01625578f, 0.20610644f, 
    -0.13389939f, -0.66336763f, -0.09988285f, -0.01028405f, 0.08190379f, -0.03876977f, -0.14205863f, -0.09363493f, 
    -0.05952764f, -0.15758027f, -0.01378989f, 0.11136553f, -0.24013913f, -0.21817304f, 0.16174474f, 0.53308702f, 
    0.03965564f, 0.11750633f, 0.13060822f, -0.07219978f, -0.02985034f, 0.04626259f, 0.02949809f, -0.05832414f, 
    -0.09702189f, 0.35608980f, 0.10104885f, 0.25201878f, -0.10833449f, -0.03307647f, 0.02926240f, 0.13803077f, 
    -0.00091515f, -0.03438332f, 0.01588928f, 0.01802816f, -0.05984183f, 0.30328292f, 0.31902066f, 0.27801618f, 
    -0.09014849f, 0.06991661f, 0.07155315f, 0.13107820f, 0.09177127f, 0.03583304f, -0.08487704f, 0.08636702f, 
    0.21655598f, -0.66620022f, -0.07519680f, -0.03481671f, 0.01958864f, -0.00359670f, 0.02470437f, 0.08563424f, 
    -0.21765293f, -0.03662271f, 0.19870891f, 0.07486581f, -0.01309893f, 0.11684109f, -0.28522322f, 0.04439596f, 
    0.11086345f, -0.12840874f, -0.06474280f, -0.13185439f, 0.04076474f, 0.14598414f, 0.21395999f, 0.07798420f, 
    0.07065195f, 0.23036481f, 0.59848100f, 0.24476616f, 0.13749538f, 0.20288043f, -0.06581493f, 0.09902912f, 
    0.10938105f, 0.17862999f, 0.06109185f, 0.06966446f, -0.23632094f, 0.21380077f, 0.05937471f, -0.20081063f, 
    -0.01693038f, -0.14273092f, 0.03724704f, -0.22108269f, 0.22646050f, -0.09641091f, 0.01797557f, 0.02357648f, 
    -0.04289839f, -0.23562969f, 0.13295521f, 0.11111618f, -0.01964079f, -0.01435910f, -0.02696095f, -0.01729960f, 
    -0.05340393f, 0.08508448f, 0.12340978f, 0.14457971f, 0.12473200f, 0.00523899f, 0.12306173f, -0.17658596f, 
    -0.15531510f, 0.05151730f, 0.07325348f, 0.08963466f, -0.09137730f, -0.05434759f, 0.13742030f, 0.20228915f, 
    -0.13999908f, 0.21074986f, 0.51057220f, -0.11664236f, -0.21129325f, -0.03980693f, 0.06033705f, 0.08970746f, 
    -0.11537628f, 0.08615648f, 0.10967974f, 0.09947401f, -0.02309151f, 0.02360025f, 0.18528810f, -0.18714361f, 
    0.16842057f, 0.05111591f, 0.07732015f, -0.05875754f, 0.13604349f, 0.02609218f, 0.25494415f, 0.10342659f, 
    0.01726583f, -0.32227862f, 0.05745095f, 0.04038238f, 0.12916018f, 0.19218846f, 0.12017839f, 0.02481251f, 
    -0.00315581f, -0.04089018f, 0.04937178f, -0.00512470f, -0.61718148f, -0.31116006f, -0.32479519f, -0.21462427f, 
    0.11684652f, 0.09168195f, 0.06691948f, 0.08075869f, -0.09808736f, 0.04709065f, 0.13081273f, -0.13235708f, 
    0.60035479f, -0.00060138f, -0.15412627f, -0.08762108f, -0.20932814f, -0.11480019f, 0.07901131f, -0.00133451f, 
    0.18738832f, 0.04904439f, -0.02285125f, 0.14813687f, -0.19875029f, -0.19669920f, 0.14804928f, -0.49545202f, 
    -0.21975835f, -0.03134324f, 0.05193273f, -0.09685489f, 0.06513931f, -0.00021757f, 0.07808170f, -0.06974214f, 
    0.63427800f, 0.38000712f, -0.19097410f, -0.00898657f, 0.01932009f, 0.10887179f, -0.06772351f, 0.00502892f, 
    0.00251003f, -0.11521927f, -0.05070889f, -0.16863587f, -0.00380228f, 0.10610142f, -0.02093851f, -0.02630349f, 
    -0.16793779f, 0.04518133f, 0.06597155f, 0.13671885f, 0.10567215f, 0.19662398f, 0.17234334f, -0.06653805f, 
    -0.34299442f, 0.16778831f, -0.03251434f, -0.04256292f, 0.01963081f, 0.14503901f, 0.07892632f, 0.00541257f, 
    0.05131688f, -0.11117637f, -0.04293185f, 0.08174022f, -0.30362344f, -0.37726474f, -0.09164366f, -0.10680174f, 
    0.13003129f, -0.04049859f, -0.07407003f, -0.00319167f, -0.05560179f, -0.05929933f, -0.05378199f, -0.05902848f, 
    -0.37584454f, 0.36473405f, 0.11194257f, -0.13957678f, -0.21207252f, 0.08164310f, 0.00323637f, -0.12704226f, 
    -0.05289016f, 0.06909630f, -0.03167776f, 0.20534153f, -0.12070385f, -0.05585393f, 0.03305292f, 0.11503471f, 
    0.18719576f, 0.01244205f, -0.05878603f, 0.13107230f, 0.08985896f, 0.14156444f, -0.03322446f, -0.16613658f, 
    -0.40437478f, -0.16297287f, -0.09481269f, 0.00062834f, 0.18714184f, -0.15103632f, -0.00759927f, -0.14145848f, 
    0.08672291f, 0.14117002f, 0.07491057f, 0.32743514f, 0.02647306f, -0.33189070f, 0.12235630f, -0.24889529f, 
    -0.11404807f, 0.05018983f, 0.36736786f, 0.02930895f, 0.02366328f, 0.04079218f, 0.20593242f, 0.13313401f, 
    0.15617293f, 0.03030245f, 0.07867099f, -0.13914877f, 0.07191122f, 0.23630632f, 0.07764779f, -0.06699757f, 
    -0.08710767f, 0.10125098f, 0.08995918f, 0.16604729f, 0.26189053f, 0.26134071f, 0.02064589f, 0.06376751f, 
    0.24075994f, 0.02917107f, 0.02555057f, 0.21885018f, -0.05382934f, -0.06297220f, 0.09889960f, 0.11610860f, 
    -0.37016550f, 0.21513771f, -0.08685623f, 0.07669377f, 0.08362699f, 0.14289667f, 0.04320468f, 0.04877177f, 
    -0.18520078f, 0.16877773f, -0.04486547f, -0.06529146f, 0.68148875f, 0.02149858f, 0.07312613f, 0.18504524f, 
    0.01327538f, 0.01738357f, 0.18714273f, 0.07371305f, -0.14624344f, -0.01792141f, 0.04853136f, 0.16373451f, 
    -0.03931879f, -0.12314274f, 0.18703750f, -0.09409399f, -0.04469535f, -0.02348140f, -0.16680813f, -0.13580407f, 
    0.10571171f, -0.05040368f, 0.12078473f, -0.03473233f, -0.04381924f, 0.17768046f, -0.12659429f, 0.17434883f, 
    -0.04115337f, 0.05083891f, -0.19998102f, 0.14356166f, 0.07265992f, 0.02354974f, 0.06983650f, 0.01748814f, 
    -0.35686961f, 0.39472064f, 0.05204023f, -0.12782696f, -0.08027606f, 0.21014160f, 0.15627438f, -0.03618313f, 
    0.21895753f, -0.07273126f, 0.12115759f, 0.02306937f, 0.13382392f, -0.00778347f, 0.07459920f, 0.36016881f, 
    0.28901443f, 0.10664820f, -0.19126305f, -0.02236945f, -0.07437707f, -0.02702447f, 0.03047385f, -0.19895560f, 
    1.30155015f, -0.03459421f, 0.03633792f, 0.19204970f, 0.36087230f, 0.21954022f, 0.18316245f, 0.00922247f, 
    -0.13461313f, -0.04364861f, 0.07928135f, 0.25953129f, 0.53191835f, 0.10751040f, 0.18824914f, 0.04208991f, 
    0.29103935f, -0.01837962f, -0.02313195f, 0.08878329f, -0.07794924f, -0.01257158f, 0.04027000f, 0.00210477f, 
    -0.41362098f, -0.08957490f, 0.08072426f, -0.11620006f, 0.03623094f, -0.04415281f, -0.13749078f, -0.27446374f, 
    -0.12257621f, -0.13479830f, -0.23676743f, -0.10676381f, -0.14778319f, 0.04860732f, 0.11555046f, -0.04863821f, 
    0.04269015f, 0.20261161f, -0.12357578f, -0.06002392f, 0.08045656f, 0.18872067f, -0.01477570f, 0.03759205f, 
    -0.00360187f, -0.02607509f, 0.16220775f, 0.31190482f, -0.11380172f, -0.17666779f, 0.17161979f, -0.07097584f, 
    0.02684855f, -0.10475155f, -0.04952010f, -0.04985859f, 0.17076737f, -0.05367908f, -0.02861715f, -0.00442387f, 
    0.03259037f, -0.17812741f, 0.16600533f, -0.07602821f, 0.02842773f, 0.09658633f, 0.00914792f, 0.15366162f, 
    0.08851674f, 0.05542725f, 0.16979350f, -0.20507267f, 0.07099918f, -0.01989100f, 0.01960340f, -0.24048553f, 
    0.01289399f, 0.13340490f, 0.16377240f, 0.04609353f, -0.14380139f, 0.10162232f, -0.19854383f, -0.11976893f, 
    -0.04905749f, 0.02378221f, 0.17053424f, -0.34870178f, -0.02247423f, 0.02186803f, -0.00500017f, -0.16528070f, 
    -0.05389777f, -0.20899847f, -0.05897461f, 0.23171599f, -0.02316715f, -0.16152300f, 0.02521705f, -0.10916894f, 
    0.07711738f, -0.26561272f, 0.04556927f, 0.22097416f, 0.04679000f, -0.14061522f, -0.22705001f, 0.28786498f, 
    -0.02721073f, 0.06383805f, 0.02806778f, -0.14471163f, 0.03867825f, -0.07322080f, 0.22465219f, -0.04122080f, 
    0.17206720f, 0.05854701f, 0.12997149f, 0.04077521f, -0.22097769f, 0.00362339f, -0.06884225f, -0.06896671f, 
    -0.11562666f, -0.14941835f, 0.13469647f, -0.05250175f, -0.00871462f, -0.39450586f, 0.16323067f, -0.16425504f, 
    0.05058547f, -0.33749473f, -0.09153198f, -0.23861754f, -0.07337999f, 0.11697089f, -0.10767008f, -0.09495184f, 
    -0.01865544f, -0.10152667f, 0.06906972f, 0.27398422f, 0.00047978f, 0.22990237f, -0.11351329f, 0.21554436f, 
    0.06233136f, 0.30002731f, 0.25786361f, 0.03143368f, -0.41023690f, -0.00215564f, 0.16871163f, -0.14986962f, 
    -0.01397628f, 0.16548185f, -0.09386482f, -0.12223737f, 0.03436970f, 0.07325749f, 0.02856854f, 0.18216453f, 
    0.32335725f, -0.19206481f, -0.39636073f, -0.36023340f, -0.15762699f, 0.05207959f, -0.10931788f, -0.06858057f, 
    0.01843928f, 0.01624547f, -0.02144394f, -0.02702787f, -0.26374415f, -0.09578587f, 0.09578809f, -0.28316200f, 
    -0.09061648f, 0.11272204f, 0.19555947f, -0.04766752f, 0.16295204f, 0.18177789f, -0.16407587f, 0.02026131f, 
    -0.18623175f, 0.19792376f, -0.27726364f, -0.05723321f, -0.10179979f, -0.10826361f, -0.02311542f, 0.03862221f, 
    0.04069356f, -0.00952099f, -0.13279371f, -0.16150276f, -0.28625268f, -0.22305609f, 0.15715140f, -0.09199548f, 
    0.00641176f, 0.03070003f, 0.08987865f, 0.08281249f, 0.11616255f, 0.23760782f, 0.04466834f, -0.00422798f, 
    0.23923896f, 0.06649967f, -0.33127782f, 0.34374151f, 0.09003469f, -0.06395056f, 0.04779932f, 0.10731782f, 
    0.22657757f, -0.03017676f, 0.09862759f, 0.16061939f, -0.01368919f, -0.09190853f, -0.15598774f, 0.08147185f, 
    0.07765409f, -0.08575208f, -0.20113695f, 0.01779100f, 0.10635216f, -0.00618051f, 0.03956116f, 0.05991364f, 
    -0.55963641f, 0.66379321f, 0.17599732f, -0.08334979f, 0.00632131f, -0.05843462f, 0.15305018f, -0.11849742f, 
    0.00596732f, 0.10281230f, -0.12482996f, 0.04081655f, -0.32712942f, -0.10764628f, 0.44079825f, 0.00812497f, 
    0.12867065f, 0.10853326f, 0.08183517f, 0.06676123f, -0.04526900f, -0.12327813f, 0.27379832f, -0.06978452f, 
    -0.10649315f, 0.24134995f, -0.28186870f, 0.30710572f, 0.02268658f, 0.00877043f, 0.06648973f, -0.23154703f, 
    0.20527223f, 0.09167878f, -0.00846040f, 0.11557412f, 0.08648406f, -0.19650841f, 0.25632593f, -0.15695477f, 
    -0.00188819f, 0.10420803f, 0.13362513f, -0.09500545f, 0.02320451f, 0.02611579f, -0.00967801f, -0.00833890f, 
    0.26615611f, -0.08213720f, 0.00973532f, -0.03375507f, -0.15269791f, 0.30985811f, -0.04619872f, -0.18158814f, 
    0.12764058f, 0.09556091f, 0.22176389f, -0.00917664f, 0.09350701f, 0.19563390f, 0.16676797f, 0.01554357f, 
    0.12576643f, 0.02924184f, 0.03746787f, 0.07176596f, -0.02901301f, 0.06328849f, -0.10244232f, 0.16951765f, 
    -0.00398596f, 0.05088326f, -0.17966658f, 0.33669472f, 0.13658416f, 0.11803259f, 0.04864939f, -0.00722778f, 
    -0.04894800f, 0.15201409f, 0.00256238f, 0.10400626f, -0.03113139f, 0.14654145f, 0.05617349f, 0.12390801f, 
    0.20127346f, 0.04936722f, -0.01198079f, 0.00426600f, -0.11439569f, 0.06398390f, -0.02813832f, 0.13084191f, 
    -0.11229987f, 0.07857813f, 0.25331977f, -0.26196954f, -0.03423243f, -0.16508850f, 0.04902948f, -0.03476609f, 
    -0.03566597f, -0.29949394f, -0.00377417f, 0.17994317f, 0.04997963f, 0.09092283f, -0.05831998f, -0.16095044f, 
    0.06687810f, 0.11854599f, 0.18565194f, -0.04937934f, -0.00624526f, -0.05154411f, 0.15954256f, -0.00490340f, 
    -0.13891283f, -0.05126169f, 0.30785489f, 0.18429269f, -0.12324900f, 0.03235761f, 0.17971028f, -0.09929927f, 
    0.04566510f, 0.11469469f, 0.07623772f, 0.11397468f, 0.26169211f, 0.03601472f, -0.04033783f, 0.04341970f, 
    -0.21185710f, -0.19730806f, -0.24504435f, -0.00775388f, -0.06117724f, -0.07314633f, 0.18237963f, -0.06889061f, 
    0.31542519f, 0.07505646f, 0.03549989f, 0.32595551f, -0.25999150f, 0.01060769f, 0.10636566f, -0.04076928f, 
    -0.10991711f, 0.05130979f, 0.09905989f, 0.06002949f, 0.75692606f, 0.09113596f, -0.30490738f, -0.02544342f, 
    -0.04093942f, -0.00047574f, -0.11471418f, 0.07094230f, 0.04133051f, -0.14209372f, 0.11561631f, -0.09159882f, 
    -0.12132273f, -0.20610875f, 0.00111239f, 0.17432669f, 0.22944380f, 0.03085862f, -0.22687136f, -0.09528206f, 
    0.02582175f, 0.15412544f, -0.22691430f, -0.00324716f, -0.57250947f, -0.10918904f, -0.16381478f, -0.28962764f, 
    0.00906730f, -0.05428728f, 0.19062303f, 0.07386917f, 0.07522058f, 0.16268760f, 0.14261806f, 0.13005720f, 
    -0.41326129f, -0.33527076f, -0.17472957f, 0.40704152f, 0.06565502f, 0.00640212f, 0.10855084f, 0.11985017f, 
    -0.10130601f, -0.10429031f, -0.05217535f, -0.07908551f, 0.28954399f, 0.05302603f, 0.21383435f, -0.20462070f, 
    -0.13047490f, -0.00539542f, 0.05730297f, 0.20127083f, 0.02635546f, 0.02243051f, -0.33065760f, -0.02031968f, 
    -0.42623615f, 0.13413854f, -0.14685601f, -0.12023996f, 0.00101998f, 0.15729226f, 0.15409060f, 0.02802768f, 
    -0.14598994f, -0.18656057f, 0.12063894f, -0.09141963f, -0.56374472f, -0.11968946f, -0.11121707f, 0.20713423f, 
    0.15790868f, 0.17517945f, 0.10813244f, 0.11492906f, 0.00794486f, 0.17257644f, -0.00338595f, 0.06130582f, 
    0.20048171f, 0.22530442f, -0.23549172f, 0.27250800f, -0.05772194f, 0.08036602f, 0.01061737f, 0.09950569f, 
    0.17450102f, -0.14060330f, -0.15815423f, 0.04515524f, 0.07440421f, 0.21630473f, -0.14939179f, -0.00528437f, 
    0.10801810f, 0.26380289f, 0.17869385f, 0.11096191f, 0.20820877f, -0.02009789f, 0.14539649f, -0.05680295f, 
    -0.02914300f, 0.20777419f, 0.16888495f, -0.45629710f, 0.13669904f, -0.00938957f, 0.04534825f, -0.05447827f, 
    0.08771127f, -0.02387947f, -0.13869524f, -0.08675994f, 0.02127672f, 0.16140702f, -0.10814616f, 0.09743742f, 
    -0.00997347f, 0.03093049f, 0.08663025f, 0.01162698f, -0.07985397f, -0.08024936f, -0.13296129f, -0.14029039f, 
    -0.07371542f, 0.28965649f, 0.01520489f, 0.20469125f, -0.17582583f, -0.09365818f, 0.07247877f, 0.16532530f, 
    0.11690088f, 0.35983214f, -0.00660585f, 0.17626277f, 0.13111503f, 0.05594476f, 0.25650477f, -0.00635299f, 
    -0.13199230f, -0.11634038f, -0.08012071f, -0.08502055f, -0.03592515f, 0.12085330f, -0.12422910f, 0.24338038f, 
    0.26854005f, 0.12073637f, 0.29286253f, 0.21564452f, -0.00122867f, 0.04606723f, 0.27370721f, 0.10997181f, 
    -0.00401810f, -0.05582834f, -0.02101773f, -0.15872777f, -0.16672426f, -0.29189029f, -0.24719909f, -0.60648799f, 
    0.10428751f, 0.09414914f, 0.14871269f, 0.02316067f, 0.10814186f, 0.07285663f, -0.04689835f, 0.04084461f, 
    0.56073475f, 0.11610962f, -0.18078560f, 0.16086167f, -0.21067011f, 0.02534015f, 0.09229841f, -0.00732022f, 
    0.01755127f, 0.05407533f, -0.00140826f, -0.06556736f, -0.07516956f, 0.18468852f, -0.27855018f, -0.74556154f, 
    -0.08439615f, -0.10899135f, 0.04233307f, -0.18505548f, -0.08252847f, 0.12465671f, 0.01610043f, 0.14460978f, 
    -0.05721768f, -0.07466578f, -0.16098286f, -0.18970312f, 0.05439324f, 0.07176979f, -0.08708558f, -0.05167668f, 
    0.24626501f, -0.05312935f, 0.02134481f, 0.27231824f, 0.16653985f, 0.14550455f, 0.04075792f, 0.14079112f, 
    0.28339523f, 0.10361458f, -0.06547299f, 0.07447153f, -0.03818888f, 0.05799333f, 0.10511072f, -0.02478536f, 
    0.53417510f, 0.56592369f, -0.11047570f, 0.22558381f, -0.16403216f, -0.01966670f, 0.09363626f, 0.03929525f, 
    0.00833317f, 0.03746429f, 0.15905647f, 0.04580560f, -0.10560669f, -0.26140204f, -0.07677144f, -0.00471869f, 
    -0.01126292f, -0.06153996f, -0.13472764f, 0.06302956f, -0.08005422f, 0.05459648f, -0.10628427f, 0.05461684f, 
    0.01619324f, -0.00226409f, -0.07767652f, 0.10877471f, 0.13533001f, 0.10366427f, 0.12231930f, 0.02255412f, 
    0.03100318f, -0.01879887f, -0.01951581f, 0.00535076f, 0.36450389f, -0.01659378f, 0.29903844f, 0.09996283f, 
    0.01255596f, 0.03005318f, 0.20507257f, 0.14179096f, 0.07817557f, -0.02026778f, -0.21505706f, 0.16465792f, 
    -0.34656379f, -0.07782295f, -0.48268270f, -0.77376068f, 0.03424550f, -0.02831241f, -0.01479336f, -0.13428903f, 
    0.15182750f, -0.04027955f, 0.15062757f, -0.09210229f, -0.03243033f, -0.36592704f, 0.07958341f, -0.12633726f, 
    0.05242393f, -0.19111165f, -0.04294970f, -0.11118576f, 0.01331722f, -0.05521076f, -0.23264067f, 0.01626820f, 
    -0.35959402f, -0.27026361f, -0.29419106f, 0.35977718f, 0.26022521f, 0.00972238f, -0.05603305f, -0.10105441f, 
    -0.00159008f, -0.16408028f, 0.04038106f, 0.09965472f, 0.01755432f, -0.27957749f, 0.08507589f, -0.06629530f, 
    -0.12392376f, -0.12096778f, 0.01739915f, 0.14911540f, -0.02276485f, -0.12115503f, -0.03451798f, 0.06368575f, 
    -0.29950097f, -0.27899519f, -0.13066334f, -0.52822059f, 0.22199260f, 0.00753467f, 0.05725262f, 0.05549223f, 
    -0.01728966f, -0.00867459f, 0.05002254f, -0.02551257f, 0.36864284f, 0.36147690f, 0.03331674f, 0.22834760f, 
    -0.06553008f, 0.00050592f, 0.18347919f, 0.21116550f, 0.06972197f, 0.08676229f, 0.03226842f, 0.01425524f, 
    0.08603200f, -0.00653903f, 0.10283439f, 0.05512516f, -0.05908305f, 0.08758789f, 0.04648831f, 0.05699294f, 
    0.06165722f, 0.00906972f, 0.05832199f, 0.07362455f, 0.00174957f, -0.29231131f, 0.18919113f, -0.30633414f, 
    0.07042634f, 0.13486382f, 0.11714393f, 0.14326422f, -0.09728687f, -0.00111678f, -0.10209700f, 0.10283756f, 
    0.15977700f, 0.06870663f, -0.07900839f, -0.18858498f, -0.20864840f, -0.09389094f, 0.07409097f, 0.06755961f, 
    0.06157507f, 0.08296259f, -0.07162807f, 0.04833414f, 0.38106167f, 0.08375732f, -0.22466007f, -0.64161545f, 
    0.19342276f, -0.01760018f, -0.02291024f, 0.04236388f, 0.09911310f, 0.11381397f, -0.18270460f, -0.01851496f, 
    -0.16441314f, -0.18532331f, -0.04121754f, 0.11755433f, -0.02979202f, 0.18294498f, -0.11982358f, -0.15468900f, 
    0.17911565f, 0.13475318f, 0.01150798f, 0.06546237f, -0.12511295f, 0.17537652f, -0.17113507f, -0.03458527f, 
    -0.07601813f, 0.20609848f, -0.05937231f, -0.01778942f, -0.09434120f, 0.01743830f, -0.01862515f, 0.17920072f, 
    0.06984171f, 0.11213471f, -0.22421658f, 0.12367829f, -0.07619745f, 0.13204993f, 0.07609174f, 0.03852415f, 
    0.05555567f, -0.05136454f, 0.13542385f, 0.11597011f, -0.12641339f, -0.26393446f, 0.18099339f, 0.44794056f, 
    0.06081920f, -0.00289560f, 0.01980238f, 0.22832516f, -0.13429271f, 0.04052022f, 0.05061068f, -0.03453051f, 
    -0.48665202f, -0.08533458f, -0.12426741f, 0.20108262f, -0.04384108f, 0.17777348f, -0.06345728f, -0.23924796f, 
    0.05381621f, -0.04287047f, 0.03926503f, -0.13061115f, -0.03638949f, -0.10417829f, 0.14275166f, 0.01913891f, 
    -0.00616111f, 0.05327879f, -0.10023096f, -0.01122469f, -0.08634711f, -0.02056593f, -0.07699548f, 0.21593973f, 
    0.11631794f, 0.03446190f, 0.10822584f, -0.54062825f, -0.01344300f, 0.22950454f, 0.12007251f, 0.16346855f, 
    0.22265185f, 0.07982916f, 0.03173538f, -0.01590942f, 0.23883705f, 0.11250512f, 0.26061130f, -0.30094805f, 
    0.15714593f, -0.08595153f, 0.03014673f, -0.13175088f, 0.17030197f, 0.07972535f, 0.16088246f, 0.10349632f, 
    -0.72087026f, -0.13671815f, 0.21294248f, -0.14891319f, 0.22440773f, 0.00943142f, -0.08310150f, -0.24787927f, 
    0.11137668f, 0.02953333f, -0.14143310f, 0.14531741f, -0.03520500f, -0.19941351f, 0.18752120f, 0.15184335f, 
    -0.05178828f, 0.09473643f, 0.00839905f, 0.08646338f, 0.04918882f, -0.00301692f, 0.08450796f, -0.07000834f, 
    -0.12846625f, -0.10783983f, 0.14470634f, 0.08489595f, -0.08385531f, 0.03758909f, -0.04464746f, 0.24424633f, 
    -0.10735231f, -0.09719042f, 0.00178932f, -0.05678689f, 0.41376022f, -0.15008828f, 0.09636102f, 0.06729507f, 
    -0.11459575f, 0.11096039f, -0.05189013f, 0.18756190f, 0.04526754f, 0.15246159f, -0.10091082f, 0.09318620f, 
    -0.23517168f, 0.16807629f, 0.19007155f, 0.15232542f, -0.07646277f, -0.03269489f, 0.14164741f, 0.01976116f, 
    -0.01657164f, 0.09915004f, 0.01642086f, 0.09953988f, 0.36576775f, -0.04326955f, 0.37745222f, 0.11279816f, 
    0.18469743f, 0.27819136f, 0.23619373f, 0.18550435f, -0.00100569f, 0.25320771f, -0.10070831f, 0.14161001f, 
    0.45318070f, 0.29998285f, -0.00703829f, 0.20749927f, 0.28674504f, -0.02018296f, 0.13484293f, -0.13339227f, 
    0.13251218f, 0.21092893f, -0.05730489f, 0.00088963f, 0.09371080f, 0.26068303f, 0.07926621f, -0.25016835f, 
    0.09716593f, -0.02680752f, 0.02999825f, -0.02828869f, 0.02760508f, 0.00825307f, -0.16163717f, -0.06362724f, 
    -0.75648773f, -0.25959337f, 0.32073504f, -0.30035871f, -0.01304787f, 0.18430486f, -0.00313417f, 0.01175588f, 
    0.01041780f, -0.00910894f, 0.13864996f, -0.06532748f, -0.20615914f, -0.15840770f, 0.38925815f, 0.03644003f, 
    -0.14383797f, 0.08914026f, 0.13062961f, 0.18876632f, -0.13343497f, -0.17576914f, -0.11646414f, 0.08172892f, 
    -0.05988071f, 0.19273038f, 0.40115586f, -0.13743138f, -0.03036450f, 0.19004244f, 0.06291194f, -0.15489437f, 
    0.05775177f, 0.10872082f, -0.17573558f, 0.17606117f, -0.09215932f, 0.19175749f, -0.21408221f, 0.24214676f, 
    0.23661023f, 0.10366473f, -0.15517893f, -0.07472915f, 0.04261997f, -0.05778793f, -0.12262319f, -0.01843152f, 
    -0.14963789f, -0.07919140f, 0.09101301f, -0.18160969f, -0.11048259f, -0.15974072f, 0.02483848f, 0.08020066f, 
    0.01634336f, 0.09944696f, -0.03630745f, 0.13571759f, 0.20120910f, -0.65473545f, 0.02786661f, -0.30620137f, 
    -0.18439987f, -0.08700087f, 0.05313759f, 0.05172510f, -0.22067048f, -0.13917014f, -0.17119682f, -0.02212494f, 
    0.13696440f, -0.13180046f, 0.31203589f, -0.09567194f, 0.03655681f, -0.00653281f, 0.18522063f, 0.16404916f, 
    -0.17471229f, -0.14835198f, 0.23334444f, 0.05060425f, 0.09750165f, -0.09364337f, 0.08351970f, 0.22636317f, 
    0.05201057f, -0.01911616f, -0.11332396f, -0.18508314f, -0.05700086f, -0.08093037f, 0.13341212f, 0.03459290f, 
    -0.10999873f, -0.04267494f, 0.23295125f, 0.27747586f, -0.13806695f, -0.08628189f, 0.16524246f, 0.01632478f, 
    -0.02103019f, 0.10918541f, -0.10928389f, -0.05892311f, 0.30754656f, -0.52369714f, 0.14145671f, 0.19647169f, 
    -0.05827490f, 0.14334664f, -0.01774160f, 0.22849095f, 0.11839639f, -0.02163785f, -0.11297306f, -0.01710844f, 
    0.11709718f, -0.14069721f, 0.15238045f, 0.17717364f, 0.22245450f, -0.01125778f, -0.12362190f, -0.02848544f, 
    -0.06072314f, -0.05080412f, -0.05891984f, -0.12428421f, -0.18608788f, 0.16538909f, 0.00893640f, -0.11284178f, 
    -0.01395821f, 0.07666049f, -0.02786770f, 0.25333852f, 0.04255554f, -0.04404552f, -0.14697410f, -0.00789312f, 
    0.00319561f, -0.00057790f, 0.03562711f, -0.03482238f, 0.01214637f, -0.00546404f, 0.03017907f, 0.01736229f, 
    0.01261647f, 0.03075609f, 0.03821633f, -0.07992838f, 0.03761268f, -0.04250486f, -0.03929463f, 0.02839026f, 
    -0.03799443f, -0.02927856f, 0.05469097f, 0.07078258f, -0.05116139f, -0.04639049f, -0.06765722f, -0.01140468f, 
    -0.05819188f, 0.06100603f, -0.00819039f, 0.04688164f, 0.04740504f, 0.02652053f, 0.05419627f, -0.04865015f, 
    0.00519063f, -0.04084931f, 0.04483882f, -0.06984118f, -0.06975092f, 0.05111200f, 0.01261125f, -0.06512236f, 
    -0.06606196f, -0.00018469f, -0.03661005f, -0.03199208f, -0.03901821f, -0.07179842f, -0.03429953f, 0.01335435f, 
    0.03772492f, -0.06536248f, 0.02467470f, -0.03267354f, 0.05300882f, 0.01582187f, 0.03883505f, 0.02402426f, 
    -0.04213765f, -0.06436354f, 0.04166250f, 0.01791989f, 0.05791818f, 0.05187684f, 0.07026447f, 0.02469734f, 
    0.02637361f, -0.07492108f, -0.03312856f, -0.02190400f, -0.02787567f, -0.07173100f, 0.00161526f, -0.05110713f, 
    -0.02840680f, -0.01104999f, 0.01489047f, 0.03043516f, 0.00810346f, 0.01990628f, -0.02140450f, -0.04472963f, 
    0.04131567f, -0.05079324f, -0.06124372f, 0.00313859f, -0.04517571f, -0.01084765f, 0.04130154f, 0.03037807f, 
    0.00413711f, -0.01400403f, 0.03185087f, -0.04301950f, -0.01116111f, -0.02325430f, -0.00932586f, 0.01851517f, 
    -0.02148763f, 0.00354105f, 0.03409135f, 0.02845598f, -0.02164693f, -0.05933235f, -0.00418727f, 0.04854162f, 
    0.02983401f, -0.03837764f, 0.01701943f, -0.05403043f, 0.01315189f, -0.06734077f, 0.02332600f, 0.03486242f, 
    0.04921352f, -0.02189973f, 0.02220721f, -0.02985921f, -0.03957839f, -0.05830218f, -0.06486688f, -0.04467265f, 
    0.05019509f, -0.02128874f, 0.04055091f, -0.02072189f, -0.04522705f, -0.06732044f, -0.00926915f, 0.02150452f, 
    0.03736703f, 0.02857112f, 0.06493874f, -0.00842524f, -0.06488657f, -0.02440492f, -0.02770876f, -0.07590567f, 
    0.06975964f, -0.03603473f, 0.04057541f, 0.02668539f, -0.02646980f, -0.00720642f, -0.05241892f, -0.01457689f, 
    -0.06689867f, -0.05842576f, -0.01851956f, 0.01732502f, -0.07283220f, -0.00693826f, 0.00577296f, -0.04491915f, 
    -0.07847170f, 0.03230447f, 0.02932054f, 0.04325682f, 0.06244481f, -0.03164961f, -0.05550073f, -0.06178699f, 
    0.02519693f, 0.01043042f, -0.06864087f, 0.01373970f, -0.04605571f, -0.02221572f, 0.01732552f, 0.02590288f, 
    0.01817359f, 0.01217437f, -0.01955945f, -0.05653307f, 0.05838539f, -0.02524672f, 0.05755038f, -0.03396402f, 
    -0.05912029f, -0.04902309f, 0.02515567f, 0.00882027f, 0.03348132f, -0.06485378f, 0.02077019f, 0.04459899f, 
    -0.05117383f, -0.02513975f, -0.06091826f, -0.05550515f, 0.05685342f, 0.01385642f, -0.00589777f, 0.04494358f, 
    0.27126169f, 0.01087234f, 0.25465411f, -0.01338321f, 0.13098386f, -0.02188099f, -0.08517095f, 0.21058093f, 
    -0.03073686f, 0.11083237f, -0.01113826f, 0.04601743f, -0.23095343f, 0.09261892f, -0.03423104f, -0.12837151f, 
    -0.00996919f, 0.03380983f, -0.03837830f, 0.09855811f, -0.09916229f, -0.10705858f, 0.07512341f, 0.10156606f, 
    -0.34884846f, -0.14038090f, -0.15545909f, 0.04681607f, -0.08019037f, -0.10518409f, -0.02385770f, 0.02748957f, 
    -0.08649963f, 0.18066689f, 0.05263807f, 0.14584970f, 0.22629951f, -0.08491612f, -0.05966088f, -0.07737048f, 
    0.19482620f, -0.05278819f, -0.09842593f, -0.05827877f, 0.10253266f, -0.04631390f, -0.14645366f, 0.04498043f, 
    0.19294502f, 0.28294691f, 0.22685377f, -0.08976159f, -0.08393463f, -0.00176889f, -0.00771011f, 0.02715183f, 
    -0.07275826f, 0.00256448f, 0.14613339f, 0.02271800f, 0.37434700f, 0.58055568f, 0.20179589f, 0.17013378f, 
    0.01706454f, 0.08177072f, 0.17966773f, 0.06391220f, 0.00837742f, 0.05124269f, 0.18161024f, 0.23525017f, 
    0.39430973f, -0.13721342f, -0.00378840f, 0.02838426f, 0.31218636f, 0.11637764f, -0.01257562f, 0.17832281f, 
    0.07335696f, 0.07244046f, 0.13072434f, 0.01049086f, 0.03883767f, -0.20478301f, -0.18464482f, 0.16588369f, 
    -0.03599093f, 0.04228916f, -0.05930354f, 0.09051719f, -0.10615642f, 0.02531085f, 0.08942967f, 0.04900349f, 
    0.14366412f, 0.18648936f, 0.15220240f, 0.37476689f, -0.05925372f, 0.05250148f, 0.14291658f, 0.01094523f, 
    0.03845134f, -0.19033979f, -0.05065145f, -0.35791910f, 0.18320714f, 0.10377760f, 0.40538150f, -0.01556855f, 
    -0.10398649f, 0.06974653f, -0.27133501f, 0.14374442f, -0.02494426f, 0.01954249f, -0.17696945f, 0.15071264f, 
    -0.34743035f, -0.05034865f, 0.02792701f, -0.72763169f, -0.02247311f, -0.05562344f, 0.13165443f, -0.04430054f, 
    -0.07838632f, 0.00887319f, 0.05319234f, -0.13074721f, -0.15196989f, -0.06281747f, 0.20593630f, -0.69821060f, 
    -0.00180082f, -0.03199390f, -0.03145901f, -0.16510487f, -0.05175960f, 0.00347881f, 0.26630518f, 0.01972141f, 
    -0.10935844f, -0.01357726f, -0.07941702f, -0.19568157f, 0.05012805f, -0.04929188f, 0.00155614f, -0.01181891f, 
    0.14690284f, 0.05575775f, -0.05492397f, 0.21377443f, 0.06065359f, -0.28456461f, -0.14350717f, -0.01094044f, 
    -0.15091756f, 0.10100432f, -0.16688396f, -0.05021243f, 0.07295477f, -0.14406092f, 0.04375961f, -0.15578306f, 
    -0.29500699f, -0.25455871f, 0.07591406f, -0.28439319f, -0.02387545f, 0.10335415f, -0.00721670f, 0.13055596f, 
    -0.13981242f, -0.05126843f, -0.10606755f, 0.16738997f, 0.86595833f, -0.21480756f, 0.12618245f, 0.14204292f, 
    -0.08637054f, 0.06219634f, -0.02909061f, -0.00336697f, 0.10305407f, -0.01134470f, 0.00992303f, 0.08233325f, 
    0.04361606f, 0.38308665f, -0.07650001f, 0.30992407f, 0.02976844f, 0.14231199f, -0.09158070f, 0.10424827f, 
    -0.02605032f, 0.04276985f, -0.13379008f, 0.00417202f, -0.03412679f, -0.02919385f, -0.08881111f, 0.49008495f, 
    0.14356098f, -0.16484027f, -0.00746790f, -0.25903240f, 0.05923009f, -0.04138690f, -0.07889918f, 0.12881003f, 
    0.00489202f, -0.33976287f, -0.23934045f, 0.45712364f, 0.04151067f, 0.00976410f, 0.07490197f, -0.21514125f, 
    -0.03891423f, -0.09073389f, 0.13429883f, -0.03143879f, 0.16408555f, -0.36144602f, 0.04241125f, 0.20550492f, 
    -0.07966992f, 0.08271980f, 0.04248743f, -0.17489350f, 0.04073142f, -0.03608290f, -0.02149749f, -0.03138943f, 
    0.20714407f, 0.30103397f, -0.20466244f, 0.18215890f, 0.00014938f, 0.03661141f, 0.15566275f, -0.04023309f, 
    0.14520583f, -0.07587172f, 0.11929613f, 0.09440218f, 0.01802542f, 0.13567594f, -0.06814865f, 0.03452312f, 
    0.15464053f, -0.07712276f, -0.06943671f, -0.14438802f, 0.05837915f, -0.01753870f, -0.07797874f, 0.11547387f, 
    0.15606101f, -0.47742596f, -0.21050654f, 0.48476213f, 0.05403790f, -0.15557611f, 0.00349938f, -0.08686840f, 
    -0.05689103f, 0.02765060f, 0.16991270f, 0.09987226f, 0.12616082f, -0.14904788f, -0.34189013f, -0.34600988f, 
    0.04510812f, -0.11280652f, -0.21272887f, -0.06105285f, -0.00345574f, 0.10412960f, 0.10623436f, -0.02271576f, 
    0.07168760f, 0.13262983f, 0.22552194f, 0.10585515f, 0.21384628f, 0.17769489f, -0.09577095f, -0.11186638f, 
    0.01612443f, 0.11692268f, 0.24314156f, 0.08912454f, -0.40182582f, 0.18146116f, -0.18599974f, 0.01814971f, 
    -0.06783904f, -0.18754385f, 0.20550756f, 0.05951799f, 0.33728835f, -0.15306242f, -0.03998184f, 0.11527523f, 
    0.04045863f, 0.07891796f, -0.20873390f, 0.38568848f, 0.18941796f, -0.18198067f, -0.26898924f, -0.19574557f, 
    0.00260448f, 0.14375138f, 0.03201584f, -0.01983803f, 0.05715684f, 0.01298173f, -0.22173359f, -0.11838321f, 
    -0.06042253f, -0.03169542f, 0.07208558f, 0.14048460f, 0.10583325f, 0.06132646f, 0.04491301f, 0.14143273f, 
    -0.07254588f, -0.02970473f, 0.32204172f, -0.26973286f, 0.19420797f, 0.10920271f, -0.02593480f, -0.10556047f, 
    -0.21603493f, 0.10416010f, 0.12880833f, 0.03617982f, 0.43326849f, 0.09312951f, 0.16272677f, -0.48245504f, 
    -0.00491491f, 0.13785294f, 0.04785074f, -0.13549240f, 0.14979687f, -0.04275966f, 0.18609643f, 0.30748588f, 
    -0.28560546f, -0.00999025f, -0.16722140f, 0.14625613f, 0.07132643f, 0.14608082f, 0.12847994f, -0.09202436f, 
    0.06583274f, 0.10717242f, 0.21382074f, -0.10345180f, -0.12967086f, -0.14751208f, -0.00129597f, 0.02999646f, 
    -0.01457945f, 0.19200887f, 0.02047158f, 0.02224806f, 0.01202013f, 0.00843344f, 0.15550515f, -0.06046188f, 
    -0.08799131f, -0.32131752f, -0.42751032f, 0.07177952f, -0.07185879f, -0.06757561f, 0.04317190f, -0.13070850f, 
    -0.08389512f, -0.00719591f, -0.00888597f, 0.02277656f, 0.25506857f, -0.02258121f, 0.00490321f, 0.15051557f, 
    -0.10856232f, -0.02728923f, 0.01252533f, 0.07702916f, 0.08865888f, 0.26360622f, -0.02669174f, 0.12272103f, 
    -0.60152149f, 0.04279596f, 0.11731765f, -0.23162086f, 0.02198979f, 0.09229327f, -0.09835285f, 0.04923207f, 
    0.12859559f, 0.16560943f, -0.02871349f, 0.07043738f, -0.24681771f, 0.02678743f, 0.17650379f, 0.18436928f, 
    -0.02604712f, 0.04981529f, -0.01904214f, -0.02504187f, 0.04314255f, -0.09761341f, 0.03803618f, 0.10326306f, 
    0.04865700f, -0.18644576f, 0.02595977f, 0.26173854f, 0.04423273f, -0.13094586f, 0.15823941f, 0.14087759f, 
    0.12529577f, 0.09158441f, 0.06220651f, -0.20872156f, -0.02675584f, -0.10114803f, 0.12304466f, 0.26852459f, 
    -0.17283924f, 0.02633830f, -0.03120407f, 0.08702013f, 0.07366475f, -0.22058900f, 0.04274962f, 0.08462523f, 
    -0.42653537f, 0.15767840f, 0.15181892f, -0.25675476f, 0.11529907f, 0.07700790f, 0.15540491f, 0.15327744f, 
    0.19933823f, 0.04760470f, -0.09490640f, 0.00260744f, -0.06439479f, 0.34221882f, 0.10467807f, -0.06514040f, 
    0.20560499f, 0.08558573f, 0.03893282f, 0.02031391f, 0.05694229f, -0.10867705f, 0.26858833f, 0.02687527f, 
    0.00173552f, 0.10830444f, 0.07745843f, 0.25470647f, -0.00307161f, -0.04697997f, -0.01706534f, 0.12648277f, 
    0.00661259f, 0.08334135f, -0.06997513f, -0.04299799f, 0.37675667f, -0.27073345f, 0.08626317f, -0.10854639f, 
    0.03963885f, -0.07228144f, -0.07154647f, -0.13212514f, 0.01795462f, -0.12758908f, -0.15711422f, -0.09945613f, 
    0.18866861f, -0.18343242f, 0.20023118f, 0.56688750f, -0.05158514f, 0.06389508f, 0.10267449f, 0.07137960f, 
    -0.12535247f, 0.02039968f, 0.12525667f, 0.19739072f, 0.07234409f, 0.23664664f, 0.01088655f, 0.50775492f, 
    0.07484039f, 0.14918782f, 0.06756058f, -0.14650586f, -0.19981176f, -0.00936013f, 0.04618236f, 0.06450586f, 
    0.24667683f, 0.40522724f, 0.13706404f, 0.46060887f, -0.02395051f, 0.01513122f, 0.19334495f, 0.06471100f, 
    -0.03586821f, -0.01547231f, 0.12959762f, 0.11902826f, -0.23425587f, 0.10757390f, 0.05970389f, 0.19220707f, 
    0.11600540f, 0.15190184f, -0.00841981f, 0.03925617f, -0.00482374f, 0.00298913f, -0.07334393f, -0.13109779f, 
    0.47880691f, 0.18452303f, -0.15037248f, 0.02841754f, 0.19905873f, 0.02190704f, 0.11930346f, -0.16476496f, 
    0.02061098f, -0.02297720f, -0.20943643f, 0.18815942f, -0.08362856f, 0.12591250f, -0.29830301f, -0.17797202f, 
    0.08541882f, 0.06458851f, 0.25046742f, 0.02611406f, -0.13187836f, -0.15191084f, 0.03165441f, 0.00591913f, 
    -0.02223505f, 0.02648511f, -0.07269118f, 0.05800858f, -0.01164064f, 0.02543462f, 0.00110231f, 0.00867185f, 
    0.02701043f, -0.02623493f, 0.02161206f, -0.07066835f, -0.01615125f, 0.03404626f, 0.01792357f, -0.05015080f, 
    -0.03187285f, -0.03084440f, 0.03553300f, 0.05772598f, -0.07646519f, 0.01470917f, -0.01389292f, -0.01034817f, 
    0.00249321f, 0.03815104f, -0.07113729f, -0.06457772f, -0.01220986f, 0.03452840f, -0.03209242f, -0.04293949f, 
    -0.04413950f, -0.06378242f, -0.05261540f, 0.06755809f, 0.06981921f, -0.05793763f, 0.03341014f, -0.04955776f, 
    -0.02312899f, -0.05599014f, 0.01326733f, -0.07065159f, -0.00961385f, -0.05827430f, 0.04311371f, -0.01567155f, 
    -0.01345773f, -0.02000652f, -0.04928744f, -0.03100347f, -0.05518764f, -0.07445318f, 0.04950725f, -0.06850923f, 
    -0.05043732f, 0.03319013f, -0.02082070f, -0.06768671f, 0.02854507f, 0.00890650f, 0.00140983f, -0.07449584f, 
    0.03078724f, -0.06642112f, 0.00806725f, -0.01732964f, -0.03471563f, 0.01075150f, 0.03889688f, -0.04443111f, 
    0.05523795f, -0.02583676f, 0.00587394f, 0.03192113f, 0.00031004f, 0.02064859f, 0.03706623f, -0.05139926f, 
    0.00623767f, -0.00222156f, 0.03022573f, -0.06006694f, -0.05870586f, -0.07329711f, -0.07084043f, -0.05728067f, 
    -0.06854757f, -0.07618635f, 0.03536001f, -0.05538005f, 0.04254461f, -0.04784042f, -0.02254521f, -0.07229728f, 
    0.04905600f, 0.05989078f, -0.04570033f, -0.07277939f, -0.00168128f, 0.00060264f, 0.04325240f, 0.01401290f, 
    -0.03989711f, 0.04067965f, -0.01495287f, -0.05132481f, -0.06756914f, 0.03697723f, -0.01413309f, 0.00086750f, 
    -0.05595250f, -0.00999519f, 0.03938123f, 0.00016250f, 0.06047753f, -0.03731436f, -0.02417194f, -0.07423071f, 
    -0.01211757f, 0.03720953f, 0.02418872f, 0.02593340f, -0.05945089f, 0.04109742f, 0.03877677f, 0.06257047f, 
    0.05530214f, -0.05284138f, -0.03405366f, -0.02447302f, -0.07199763f, -0.05701112f, -0.04221430f, 0.02751100f, 
    0.02876739f, -0.04109234f, -0.06448422f, 0.04711401f, -0.05511686f, -0.07162122f, -0.00870687f, -0.01823337f, 
    -0.00177084f, 0.03982825f, -0.04132067f, -0.01770724f, -0.05345210f, 0.04577473f, 0.04898869f, 0.03232239f, 
    -0.02629344f, 0.04559230f, 0.01737472f, 0.03465727f, 0.06457533f, -0.00582144f, 0.01356934f, 0.05159834f, 
    -0.02348598f, 0.00360975f, -0.00044622f, -0.04825585f, 0.00133472f, -0.04362539f, 0.03758733f, 0.05522899f, 
    0.03867910f, 0.01994800f, 0.01007589f, 0.04993658f, 0.02929416f, 0.06166387f, -0.07179583f, -0.03906213f, 
    0.02085160f, 0.03283158f, 0.03267646f, -0.06771999f, -0.00502161f, -0.02005374f, -0.03406729f, -0.07746349f, 
    0.01634612f, -0.07108801f, -0.05897268f, 0.05188278f, -0.02119084f, -0.00927275f, -0.07673281f, 0.03345492f, 
    -0.50976342f, 0.51640886f, -0.06484610f, 0.06381851f, 0.02900418f, 0.21912338f, 0.21697424f, 0.01203602f, 
    0.06189879f, -0.06279261f, 0.06314529f, -0.00933967f, 0.30038974f, -0.03693476f, 0.16326383f, 0.18969017f, 
    0.45165092f, 0.14290616f, 0.31951243f, 0.05012138f, 0.01048759f, -0.13105683f, -0.10099239f, 0.09549155f, 
    -0.05184934f, -0.08422121f, 0.31333908f, 0.00502910f, 0.11249984f, 0.01829807f, 0.10681104f, 0.08268904f, 
    0.16623648f, -0.14955617f, -0.00398922f, -0.00329288f, 0.04214935f, 0.10077414f, 0.06653742f, -0.07897090f, 
    0.00932990f, 0.02766796f, 0.14681111f, -0.00715329f, -0.06715479f, -0.01579504f, -0.08478048f, 0.05711011f, 
    -0.01157636f, -0.31678590f, -0.07243548f, -0.13764443f, 0.05720530f, -0.05492792f, 0.03469739f, -0.04483028f, 
    0.11088435f, -0.04943286f, 0.13725635f, 0.09508410f, 0.03557773f, -0.19948883f, -0.16595544f, -0.12916954f, 
    0.03345435f, 0.13098830f, -0.14160983f, -0.03143187f, -0.09878466f, -0.01015013f, -0.18412079f, -0.11447957f, 
    0.39049613f, 0.06484378f, 0.09054909f, 0.19277190f, -0.22602992f, -0.22729158f, -0.14604484f, 0.02299101f, 
    0.02641059f, 0.06571527f, 0.13528436f, -0.03314996f, -0.03802365f, -0.01178232f, 0.19502221f, 0.19464307f, 
    0.04283606f, -0.14870983f, 0.10213861f, -0.11276339f, 0.01355121f, 0.00304631f, 0.05437008f, 0.07177670f, 
    0.05235330f, -0.21982527f, -0.05767874f, -0.19678628f, 0.03440790f, 0.10900640f, -0.20705809f, -0.08112905f, 
    -0.00063956f, 0.14255621f, 0.11977946f, 0.21044505f, -0.01130710f, 0.40359914f, -0.39694968f, 0.31875646f, 
    0.03080020f, -0.04369507f, 0.06402456f, -0.04835221f, -0.04743484f, 0.05729552f, 0.01191055f, -0.16159478f, 
    0.34197614f, 0.21463861f, 0.06900728f, 0.24291554f, -0.10864950f, 0.03907380f, -0.09984300f, -0.03769324f, 
    0.19793156f, 0.06761952f, -0.05323535f, -0.01348432f, 0.00686693f, -0.39594033f, 0.29612842f, 0.36648363f, 
    -0.20519650f, -0.22827218f, -0.01253553f, 0.07902806f, 0.17354316f, 0.12765001f, -0.16463226f, 0.09150920f, 
    -0.02256528f, -0.47048834f, 0.14295436f, 0.14500105f, -0.12683885f, -0.07429369f, 0.03660613f, -0.15235242f, 
    0.02432777f, -0.07138107f, 0.29206237f, 0.01342033f, -0.53985190f, 0.04901219f, 0.27044144f, -0.26031867f, 
    0.15355781f, -0.14970301f, -0.00054271f, -0.06133324f, 0.08404711f, 0.16533008f, 0.05881227f, 0.18315047f, 
    0.19949253f, 0.19887282f, -0.03701589f, 0.44246504f, 0.06281638f, 0.00291687f, 0.09946742f, 0.09926885f, 
    -0.03910872f, -0.04135155f, 0.10521406f, -0.12926869f, -0.47560948f, 0.05316576f, 0.13684314f, -0.23317824f, 
    0.16000438f, -0.06798176f, 0.18973409f, 0.04227382f, -0.05185083f, 0.23474199f, -0.03254827f, -0.05011787f, 
    -0.00942828f, -0.07823683f, 0.01264223f, 0.02676158f, 0.04190823f, 0.04075129f, 0.02569670f, 0.05108856f, 
    0.03266373f, 0.00204709f, 0.03135625f, -0.02344147f, -0.02539495f, -0.05301388f, -0.02587864f, -0.07402937f, 
    0.03106070f, -0.02075506f, 0.01737349f, -0.05801883f, -0.08447366f, 0.00267736f, -0.05729893f, 0.04710481f, 
    0.05417405f, 0.01932400f, 0.03962307f, 0.00291112f, -0.00860667f, 0.00497635f, 0.00018670f, -0.01639031f, 
    -0.05948581f, -0.05882267f, 0.04605797f, -0.04526041f, 0.01594543f, -0.02886569f, 0.01751574f, 0.03065950f, 
    0.03891337f, -0.00551242f, -0.02626355f, 0.01091989f, -0.04134894f, -0.05515888f, -0.06136994f, 0.04156001f, 
    -0.06497899f, -0.02409047f, 0.00372232f, -0.04663932f, 0.02116228f, 0.02528976f, 0.00227434f, -0.04529921f, 
    0.03929894f, 0.02971977f, -0.00503400f, 0.05713935f, -0.02699380f, -0.04591388f, 0.02871761f, 0.05349552f, 
    -0.05724755f, -0.04058973f, -0.06861847f, -0.02976264f, -0.07047232f, -0.04059548f, 0.02947534f, -0.04922634f, 
    0.02549359f, 0.04176231f, -0.04984567f, -0.00594788f, -0.07532203f, -0.05297828f, 0.02190791f, 0.00510482f, 
    -0.06248958f, -0.06376354f, 0.04436855f, 0.03020328f, 0.01358180f, 0.04937054f, -0.00002761f, -0.07004842f, 
    -0.06687618f, -0.02035719f, 0.06177891f, 0.02726109f, 0.00977543f, 0.00664878f, -0.00493263f, -0.02799648f, 
    0.03136635f, -0.03600157f, -0.03672164f, -0.05403720f, -0.06406973f, 0.03957462f, -0.01047973f, 0.01370787f, 
    0.02542790f, -0.00109460f, 0.05107059f, -0.02164147f, -0.06406996f, 0.03117540f, -0.06607753f, -0.06707736f, 
    0.06255550f, -0.05617450f, -0.00336511f, 0.02518988f, -0.02719382f, 0.02427041f, 0.03050063f, -0.01607088f, 
    0.02767263f, -0.02050459f, 0.02046273f, -0.03790945f, 0.03938913f, -0.06130387f, 0.00315316f, 0.00978473f, 
    -0.02228896f, 0.04459458f, 0.04990995f, -0.07445890f, -0.05905055f, 0.05946785f, 0.03333583f, -0.04015788f, 
    -0.03958043f, 0.00203610f, -0.02039808f, -0.07983518f, 0.05153521f, 0.01732250f, 0.04622326f, 0.03850896f, 
    0.01788718f, -0.07734110f, 0.02314819f, 0.03979886f, -0.06847452f, -0.08189340f, -0.06205347f, -0.01127813f, 
    0.05987446f, -0.05667700f, 0.02547285f, -0.05730809f, -0.00958556f, -0.01608087f, -0.05425600f, -0.01901534f, 
    0.00561274f, 0.03263106f, -0.02377805f, 0.02699077f, -0.02436937f, -0.03353440f, 0.02702564f, 0.01024587f, 
    -0.05933963f, -0.05297670f, 0.03979971f, 0.00308110f, -0.00060622f, -0.04074917f, -0.04366244f, -0.02340931f, 
    -0.05035684f, 0.02940577f, 0.04282412f, -0.02341813f, -0.06767717f, -0.08044692f, 0.02495597f, -0.01764444f, 
    -0.08172658f, -0.04515376f, -0.02696641f, -0.01417368f, 0.05750756f, -0.02802637f, 0.02761734f, -0.07553516f, 
    0.23896027f, 0.04397960f, 0.05676397f, -0.09369215f, -0.05996060f, 0.02399214f, -0.03180485f, 0.03833836f, 
    0.14402027f, 0.11217622f, -0.03097166f, -0.09860750f, 0.16442354f, 0.12522554f, 0.06551761f, 0.11485790f, 
    0.02013737f, -0.09687405f, -0.13893002f, 0.07103845f, -0.07969996f, -0.18612619f, 0.06374153f, -0.08906029f, 
    -0.35395849f, 0.15597716f, 0.03653344f, 0.02418794f, -0.16222659f, -0.00701172f, 0.04929231f, 0.01380012f, 
    -0.08700355f, -0.05874023f, 0.09774628f, 0.07382791f, 0.51877666f, -0.02805695f, -0.03480170f, 0.09898446f, 
    -0.05782378f, -0.01167051f, -0.05394867f, 0.14409232f, 0.14128700f, -0.07563976f, -0.07549729f, 0.08055276f, 
    0.21816507f, -0.09070386f, -0.26408252f, 0.16917039f, 0.18038824f, -0.03269700f, -0.04563136f, -0.07034762f, 
    -0.02345531f, 0.18044557f, 0.01961340f, 0.08825400f, -0.16359542f, 0.19942731f, -0.56490457f, -0.10445519f, 
    0.05959631f, -0.16550502f, 0.04714514f, -0.20559523f, -0.08343247f, 0.16109930f, 0.10975008f, 0.10998889f, 
    0.09921173f, -0.31987914f, -0.15101133f, 0.24301344f, 0.19424260f, -0.18778379f, -0.18929432f, 0.11577864f, 
    -0.08087003f, -0.04373029f, 0.02888174f, -0.08466075f, 0.32308161f, -0.23606575f, 0.44159719f, -0.20904946f, 
    -0.14985967f, 0.11889233f, 0.09431826f, 0.06658543f, -0.15125898f, -0.02241959f, -0.12936038f, 0.00422663f, 
    -0.46141481f, -0.15530351f, -0.31079137f, 0.21638773f, 0.05540745f, 0.24142960f, 0.13361259f, -0.14670634f, 
    -0.16930336f, -0.25211328f, 0.04711108f, -0.08076290f, -0.44229907f, 0.39206961f, -0.03358212f, 0.24374518f, 
    -0.01257737f, 0.06515907f, -0.12366236f, -0.05144138f, 0.17700768f, 0.06978592f, 0.09000120f, -0.00573343f, 
    0.18370582f, 0.28522044f, -0.26965550f, -0.03120742f, -0.03556862f, -0.00988755f, -0.06536905f, 0.02052707f, 
    0.16541287f, 0.13802767f, -0.14946219f, -0.02648648f, 0.05024961f, 0.04820104f, -0.11748840f, -0.12461424f, 
    0.23062913f, 0.21429811f, 0.02618762f, 0.02411942f, 0.07749519f, 0.08757205f, 0.05833895f, -0.11944978f, 
    -0.00390446f, 0.06670497f, -0.26782188f, -0.39650100f, 0.26139998f, 0.09311356f, -0.07605249f, 0.04428246f, 
    -0.05976602f, 0.03862983f, -0.01316844f, 0.14420439f, 0.09132528f, 0.39782205f, -0.08843952f, -0.22654817f, 
    -0.00987157f, 0.10284051f, -0.03720832f, -0.18348430f, 0.03183627f, -0.03529893f, 0.06855047f, -0.08372135f, 
    0.03469781f, 0.31373164f, 0.19126719f, 0.14013577f, -0.11709834f, 0.04610510f, 0.03914782f, 0.13691372f, 
    -0.00889572f, 0.10056182f, 0.00618794f, 0.13819215f, 1.19599986f, -0.18732476f, 0.22204240f, 0.16402419f, 
    -0.07917790f, 0.00983186f, -0.02965859f, -0.15921418f, -0.03909508f, 0.14166476f, -0.02990359f, 0.13121678f, 
    0.56752348f, -0.01857141f, -0.11240271f, -0.36017075f, 0.03398540f, -0.13336086f, 0.06643970f, 0.27495092f, 
    -0.03252823f, -0.17271221f, -0.07403245f, -0.09728821f, -0.22131468f, 0.03330200f, 0.12667114f, -0.19019867f, 
    0.08709271f, 0.03461476f, 0.13130997f, 0.15857933f, 0.07380912f, -0.00529373f, -0.00372103f, -0.08500874f, 
    -0.29339337f, 0.31094605f, 0.02372226f, -0.24128431f, 0.26453418f, 0.13379607f, -0.19554947f, 0.19396789f, 
    0.15067117f, -0.10739430f, 0.01597079f, -0.02301660f, -0.60224944f, 0.04038471f, 0.38929108f, 0.11762019f, 
    -0.16088192f, 0.04972979f, 0.04727171f, 0.15008357f, 0.03182421f, 0.12638576f, 0.05074904f, 0.15951425f, 
    0.03684016f, 0.15551589f, 0.16220236f, -0.21782005f, -0.06868507f, -0.06211154f, 0.17769332f, 0.07404102f, 
    -0.02443563f, -0.01688686f, 0.16412728f, 0.01023296f, 0.42175314f, -0.11160102f, 0.05730238f, -0.13786462f, 
    0.15460901f, -0.11385612f, -0.05968124f, -0.14400895f, -0.05276775f, -0.01382994f, -0.08048233f, -0.18749847f, 
    0.35875180f, 0.46926650f, 0.17502286f, -0.29701102f, -0.08009949f, 0.01733462f, -0.21002273f, 0.08344454f, 
    0.01930179f, 0.13361380f, -0.03752206f, -0.06737060f, -0.10129678f, -0.13797560f, -0.09116510f, 0.15440689f, 
    -0.02821553f, 0.12612624f, 0.00736208f, -0.04041029f, 0.00434203f, -0.03854799f, 0.22820507f, 0.06132946f, 
    0.44902140f, -0.20793457f, -0.00230904f, -0.02339366f, 0.00399141f, -0.12879229f, -0.04157610f, 0.03828044f, 
    0.16217999f, 0.02414970f, -0.05571966f, 0.26231655f, 0.58263677f, 0.08538789f, 0.04203393f, -0.17124841f, 
    -0.01935758f, 0.01629395f, 0.05436011f, -0.05418278f, 0.05038521f, 0.03221089f, 0.08648960f, -0.08795633f, 
    -0.28359613f, -0.02980703f, 0.14018023f, -0.07685636f, 0.06614880f, -0.07143015f, 0.01069101f, -0.11015351f, 
    -0.22773869f, 0.29722536f, 0.01368994f, 0.04590750f, 0.04640826f, -0.21994622f, -0.03998522f, 0.42136636f, 
    0.01685007f, -0.04372480f, -0.11465975f, -0.10911593f, -0.12062652f, 0.02095100f, -0.10509835f, 0.11822245f, 
    0.29175678f, -0.00248651f, -0.34194326f, 0.42116114f, -0.12973128f, 0.16966510f, 0.00829285f, 0.06401536f, 
    -0.02424091f, -0.00317108f, 0.11391649f, -0.07749119f, 0.36168671f, -0.03265834f, 0.07375227f, 0.02015264f, 
    -0.04127044f, -0.05747679f, -0.08201397f, 0.01366157f, -0.11364687f, -0.05118691f, 0.02090439f, 0.15976726f, 
    -0.04939681f, -0.01601341f, 0.03218319f, -0.01155779f, 0.21447253f, 0.09463720f, -0.08539694f, -0.27804473f, 
    -0.09440409f, -0.01374856f, 0.16093390f, -0.07954927f, 0.32973686f, 0.17930819f, -0.09121419f, 0.19301312f, 
    0.01321641f, -0.01711127f, 0.03033032f, 0.07463188f, 0.00848753f, -0.12417985f, 0.04227418f, -0.14715475f, 
    -0.02254558f, -0.00979046f, 0.06935973f, -0.03113778f, -0.02022151f, 0.04492992f, -0.06931386f, -0.01689484f, 
    -0.04588106f, -0.07142114f, -0.08128724f, 0.00220855f, -0.02194066f, -0.05104794f, -0.07396045f, -0.01524923f, 
    -0.04140041f, -0.04154487f, 0.05008421f, -0.05424179f, -0.05010774f, -0.01836384f, -0.03562325f, 0.02798707f, 
    -0.00202075f, 0.04959786f, -0.04185282f, -0.02869997f, -0.08025374f, -0.05598274f, -0.05230488f, -0.00133009f, 
    -0.07518189f, -0.00345989f, -0.01556393f, -0.00115849f, 0.03318650f, -0.07648216f, -0.06138228f, -0.01125995f, 
    -0.01108323f, 0.04327114f, -0.07267732f, -0.07067255f, 0.03805735f, 0.01569818f, 0.02323134f, -0.09167080f, 
    0.04550474f, 0.05737172f, 0.01037742f, 0.01062497f, -0.00369404f, -0.02132304f, -0.01296109f, -0.07576263f, 
    -0.00090598f, 0.02420797f, 0.03295853f, -0.07928762f, -0.03284784f, 0.05029538f, -0.01063198f, -0.07257475f, 
    0.08497541f, -0.06033609f, -0.02862953f, -0.08251818f, -0.02950773f, -0.00088674f, 0.06379709f, 0.01583985f, 
    -0.07021238f, -0.03139339f, 0.00384994f, 0.05072783f, -0.01415139f, 0.02878009f, -0.04992158f, -0.05374328f, 
    -0.01990390f, -0.06385642f, 0.03779488f, -0.02160192f, -0.00392935f, -0.09028782f, -0.08235998f, 0.03861066f, 
    -0.00946616f, -0.01448254f, -0.08496363f, -0.02537226f, 0.04609755f, 0.05061474f, 0.01616105f, -0.05730838f, 
    0.02881011f, -0.02380704f, -0.03757763f, 0.03892097f, 0.02440746f, -0.00420203f, 0.07066284f, -0.04676773f, 
    0.02033501f, -0.07641081f, -0.07090458f, -0.03106830f, -0.06707610f, -0.03166197f, -0.02938895f, -0.03399706f, 
    0.04334858f, -0.09252277f, -0.08644612f, -0.04225173f, -0.04421147f, 0.01521461f, -0.07664256f, -0.01544884f, 
    -0.02345953f, 0.00945330f, -0.05699863f, 0.00925523f, 0.03434666f, 0.00819199f, -0.04398695f, 0.00483924f, 
    0.05694207f, -0.05613328f, 0.00182485f, 0.04883797f, 0.03870311f, -0.01469752f, 0.03199613f, -0.07077628f, 
    -0.02747613f, 0.07712083f, 0.01731765f, 0.05151911f, 0.04155441f, 0.04395987f, 0.05399821f, 0.01007099f, 
    -0.09554224f, 0.01147704f, 0.06233786f, -0.04765759f, 0.07025857f, 0.00536392f, -0.02149307f, 0.02660108f, 
    0.03562030f, 0.03761469f, -0.06001581f, 0.02652533f, -0.03184233f, -0.01016473f, -0.06301831f, -0.03211862f, 
    0.00196775f, -0.02521481f, -0.02343019f, -0.02945242f, -0.06730589f, 0.02303853f, -0.07787903f, -0.08905116f, 
    0.01157475f, -0.07768235f, 0.00540910f, -0.04145384f, 0.03201557f, 0.06179089f, 0.05074364f, -0.05042351f, 
    0.03436349f, -0.00295325f, 0.03960956f, -0.06727995f, -0.00749876f, -0.00796276f, 0.00059768f, -0.03679641f, 
    -0.02770573f, -0.01563432f, -0.08001828f, 0.01934829f, 0.00423312f, 0.04262136f, 0.01048960f, 0.02674062f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.10167430f, -0.00965120f, 0.08051851f, 0.05661255f, -0.06223965f, -0.04081064f, -0.06030596f, -0.01804578f, 
    -0.05176026f, 0.12799475f, -0.06315682f, 0.21476823f, -0.08460558f, -0.03600941f, 0.04074597f, -0.02256434f, 
    -0.04553658f, 0.17255025f, 0.01646888f, 0.09073666f, 0.04503150f, -0.07714555f, -0.02797732f, -0.07059310f, 
    0.05291271f, 0.13536812f, 0.04916013f, 0.05433043f, -0.07035318f, -0.00646375f, -0.05082276f, 0.04017161f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.47713387f, 0.15121110f, 0.03161222f, 0.15973227f, 0.05389418f, 0.00853543f, 0.07445664f, -0.01781522f, 
    0.21645455f, 0.20266299f, -0.03039615f, -0.22983468f, 0.45368969f, 0.24636745f, -0.13103786f, 0.35221654f, 
    0.48125425f, -0.02347391f, -0.24961084f, 0.05287721f, -0.08723838f, 0.23690480f, -0.03139638f, -0.16393909f, 
    -0.85694700f, -0.10026872f, -0.14909805f, -0.06213941f, 0.04978740f, -0.81752151f, 0.23277000f, -0.12540351f, 
    -0.10855839f, 0.07628873f, 0.10210677f, -0.06951269f, 0.33668822f, -0.12053542f, -0.02873787f, 0.09333556f, 
    -0.07072724f, 0.21469837f, 0.12875885f, 0.16082111f, 0.19690257f, -0.59323537f, -0.00516687f, -0.22367197f, 
    -1.26437747f, 0.15354247f, -0.62963992f, 0.20123072f, 0.11929363f, 0.07752001f, 0.17807145f, 0.42056313f, 
    -0.38235343f, 0.24741527f, -0.09302153f, -0.23619571f, -0.13501164f, -0.07057492f, 0.30165952f, -0.10497237f, 
    -0.44366542f, 0.03413210f, -0.39911371f, -0.11739419f, 0.02418262f, 0.09958141f, 0.02926031f, 0.14006053f, 
    -0.23793513f, -0.40681657f, -0.03092590f, 0.06953669f, 0.31940421f, 0.35596189f, -0.47273695f, 0.35777253f, 
    0.12144680f, -0.69153392f, 0.23297635f, 0.26019621f, 0.19564749f, 0.11488369f, -0.13680147f, 0.28816530f, 
    0.21089937f, -0.30455476f, 0.12111401f, -0.81657964f, 0.08507702f, 0.24424052f, 0.22731006f, 0.12548722f, 
    0.26609066f, -0.63066190f, -0.09129292f, -0.00944951f, -0.45194608f, -0.16355063f, -0.00765385f, -0.05905151f, 
    -0.14123724f, -0.57704526f, -0.01951269f, -0.23426956f, -0.65195054f, 0.66334975f, -0.99296331f, 0.17312297f, 
    -0.24545881f, 0.35562736f, 0.14066134f, -0.91691488f, 0.25518405f, -0.18672056f, 0.11636727f, -0.65605867f, 
    -0.60323852f, 0.32125524f, -0.15030451f, 0.12491301f, 0.11703055f, 0.46156895f, 0.12610872f, -0.00823190f, 
    0.19120972f, 0.27793449f, -0.10196728f, -0.07118057f, -0.62530345f, 0.16199839f, 0.04855379f, 0.06474930f, 
    -0.16671461f, -0.60571712f, -0.14053160f, 0.22535549f, -0.21910354f, 0.01968809f, -0.12354120f, -0.24738498f, 
    0.38009244f, -0.30289775f, 0.16901469f, 0.52504408f, 0.20049392f, 0.32307237f, -0.06520573f, -0.31181929f, 
    -0.02919434f, 0.08851241f, 0.02682250f, 0.33332771f, 0.07636933f, -0.58436358f, -0.42964327f, 0.14334923f, 
    -0.20785864f, -0.37882355f, 0.34019342f, -0.05787376f, -0.15479387f, 0.07889693f, -0.07458983f, -0.10101898f, 
    0.06034606f, -0.17712860f, -0.04709915f, 0.01611330f, -0.23286274f, -0.67773038f, 0.53116566f, 0.09915602f, 
    0.00196779f, 0.01381120f, -0.67146122f, -0.34141421f, -0.34391335f, 0.03204878f, 0.00759849f, -0.26328102f, 
    0.52188587f, 0.21089707f, 0.14527333f, 0.03963556f, -0.07440083f, -0.53606236f, 0.27304992f, -0.06546368f, 
    0.07047427f, -0.41358796f, 0.17398542f, -0.04541092f, -0.77701241f, 0.16671692f, -0.17462847f, 0.15731551f, 
    0.03827709f, 0.13101661f, -0.01477004f, -0.27594385f, 0.63932592f, -0.07149636f, 0.24334434f, 0.00829094f, 
    0.01001146f, 0.12377036f, 0.41280982f, -0.63684452f, 0.17923537f, -0.09835269f, -0.05991348f, 0.24752882f, 
    0.26124659f, 0.06434350f, -0.03725785f, -0.61803102f, 0.06034775f, 0.23243062f, -0.71708536f, 0.08189883f, 
    0.19957073f, -0.04833449f, -0.43459356f, -0.01184703f, 0.29391244f, -0.02930184f, -0.13525245f, 0.10343508f, 
    -0.48808470f, -0.02207148f, -0.09203117f, -0.82269347f, -0.30448508f, -0.18758711f, -0.66910779f, -0.39504996f, 
    0.56482619f, -0.51038128f, 0.31536308f, -0.19899410f, -0.32731026f, 0.25548357f, -0.01463208f, -0.07409965f, 
    0.21743922f, -0.01638588f, 0.04699451f, 0.40365267f, -0.16866681f, 0.43192163f, 0.00286709f, -0.04348818f, 
    -0.54635686f, 0.41399956f, 0.13248783f, 0.08073197f, 0.13776907f, -0.06563756f, -0.15077148f, 0.01274686f, 
    0.13746370f, -0.34016335f, 0.10869709f, -0.46899149f, -0.72977352f, -0.63025767f, -0.28130117f, -0.01631483f, 
    -0.14805670f, 0.41611591f, -0.30758432f, 0.39198983f, 0.33729160f, -0.48082799f, -0.06499453f, 0.10508348f, 
    0.39891279f, -0.53752297f, 0.14695726f, 0.32748172f, 0.01246983f, 0.25667179f, 0.03908946f, -0.02979154f, 
    0.11983992f, -0.02341561f, -0.60385972f, -0.01321335f, 0.14594290f, -0.11612542f, 0.15900241f, -0.17827785f, 
    0.34043875f, -0.07543434f, -0.10182335f, 0.36152333f, -0.19175242f, 0.31847313f, 0.45560762f, -0.60800683f, 
    -0.07486998f, -0.88700718f, 0.01581370f, -0.58731878f, -0.00661351f, -0.46202156f, 0.14863206f, 0.24554835f, 
    0.25489661f, -0.22484599f, -0.02248539f, 0.24004906f, 0.03396711f, 0.28340593f, -0.13217680f, -0.04348604f, 
    0.03333884f, -0.57818633f, -0.28840068f, 0.12793891f, 0.12028553f, 0.15903045f, 0.09639896f, -0.00098033f, 
    -1.04012513f, 0.34920284f, -0.15047450f, 0.22892529f, -1.04253471f, -0.64005870f, -0.03638590f, 0.51130909f, 
    -0.49047962f, 0.14991085f, 0.30496907f, 0.16546036f, 0.41405073f, 0.13840130f, 0.09603014f, -0.35258302f, 
    0.28893003f, 0.01697752f, -0.15890414f, 0.00538487f, -0.05073951f, 0.19731799f, -0.13078335f, -0.04656706f, 
    0.01505058f, 0.52730852f, 0.39595962f, -0.05509363f, -0.31042150f, 0.16126689f, -0.10133310f, 0.15781938f, 
    -0.10304982f, 0.65822250f, -0.11610404f, 0.23886251f, -0.70158869f, 0.38160843f, -0.50503856f, -0.18775578f, 
    -0.36141169f, 0.06826561f, 0.19243824f, -0.38362128f, -0.67410958f, -0.50479627f, 0.06679846f, -0.51015639f, 
    0.06242797f, 0.23702122f, -0.03458455f, -0.12079576f, 0.15483797f, 0.08423897f, 0.12538223f, -0.13017994f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.22532234f, 0.03126628f, 0.10383534f, -0.00546387f, 0.06268267f, 0.19924821f, -0.16583534f, -0.11966313f, 
    -0.17576919f, -0.12189146f, 0.28692517f, -0.03639489f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
