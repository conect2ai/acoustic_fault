#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.63468266f, 0.95811898f, -0.04542429f, 0.59224552f, 0.35338235f, 0.38403043f, 0.17823701f, 0.24059799f, 
    0.07494368f, -1.30890036f, 1.02264142f, -0.99293047f, -0.11551005f, 0.32957977f, -0.39886919f, 0.01460741f, 
    0.17179543f, -0.06825797f, 0.15034707f, 0.63793236f, 0.12939645f, 0.26061115f, -0.12381677f, 0.46464360f, 
    -0.24878755f, -0.11199573f, -0.20245744f, -1.05117691f, -0.92858869f, -0.49522582f, 0.43244117f, -0.29184833f, 
    -0.21110404f, -0.00930141f, 0.12173997f, 0.58246565f, 0.39217591f, -0.77035916f, -0.26527184f, -0.78031522f, 
    -0.84821010f, -0.85876733f, -0.05070949f, -0.40175694f, -0.12011343f, 0.47611043f, 0.12392949f, -1.07251871f, 
    0.12746160f, 0.69299752f, -0.23165905f, -0.02998617f, -0.26520741f, -0.07886288f, 0.04749944f, 0.14141946f, 
    -0.30668101f, -0.11097339f, -0.44437507f, -0.71026874f, 0.27239633f, 0.63503307f, 0.69751596f, -0.88795233f, 
    -0.97125334f, -0.74166375f, 0.69582766f, 0.72627991f, 0.20850165f, -0.09696425f, -0.26761124f, -0.38378647f, 
    0.41322038f, 0.93694413f, -0.44413176f, -0.41110498f, 0.16271003f, -0.04363026f, 0.14058703f, 0.16181895f, 
    0.27099004f, 0.67564601f, 0.72368723f, 0.24816987f, -0.52678180f, 0.29730690f, -0.28895479f, -0.02375426f, 
    0.02910090f, -0.20991372f, 0.75707906f, -0.77752125f, 0.85346788f, -0.72822756f, -0.06063201f, -0.16727555f, 
    -0.10390046f, 0.20833400f, 0.49846217f, 1.05677843f, -1.27893806f, -0.49759883f, 0.24802305f, -0.18014221f, 
    0.22323820f, 0.30150732f, 0.14085756f, 0.41570404f, 0.12552154f, 0.41077060f, 0.40052900f, 0.46886641f, 
    -0.30532381f, -0.74522167f, -0.03271322f, -0.11174646f, -0.04891143f, -0.32603869f, -0.00945205f, 0.70635390f, 
    -0.40840033f, -0.44804284f, 0.65929198f, 0.61329192f, -0.16004975f, -0.43259284f, -0.48257905f, -0.78196150f, 
    1.19490743f, -0.13419862f, -0.20393616f, -0.20119643f, 0.16393943f, 0.47380605f, -0.01801368f, 1.01566863f, 
    -1.02710903f, -0.43681526f, 0.35386974f, 0.07444905f, 0.04464857f, 0.12199377f, 0.57666647f, -0.46065310f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.33753517f, 0.58826947f, -0.08371697f, 0.05755330f, 0.36453244f, -0.03783108f, -0.16921128f, -0.12978844f, 
    0.91277403f, 0.37684599f, 0.09851135f, -0.17099628f, 0.38650268f, 0.03563737f, -0.28446525f, 0.10471316f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.03169793f, -0.00105266f, -0.06027258f, -0.00064541f, -0.03897708f, -0.00980383f, -0.02393403f, 0.03862672f, 
    -0.00760038f, -0.08654117f, 0.04470326f, -0.00770155f, 0.04575546f, -0.05173406f, -0.02820355f, -0.08443478f, 
    -0.08241405f, -0.03611182f, -0.01281224f, -0.03252649f, 0.01100775f, -0.05509044f, 0.00364817f, 0.06395381f, 
    -0.07804336f, 0.02095457f, -0.04680208f, 0.02606933f, 0.06427655f, -0.06928185f, -0.03905875f, 0.03308898f, 
    -0.03462423f, -0.04403733f, 0.01534566f, -0.07112966f, -0.04989412f, 0.06449103f, -0.03882638f, 0.04949801f, 
    -0.00240638f, -0.03563301f, 0.01482861f, -0.08170146f, 0.03226974f, -0.07263351f, -0.04119413f, -0.06801393f, 
    0.05657613f, 0.03064670f, 0.05986376f, -0.05306560f, 0.03409532f, -0.03149145f, -0.00214739f, -0.04306885f, 
    0.02315565f, -0.02793809f, -0.06031977f, -0.01937697f, 0.01319820f, 0.01599174f, 0.03990838f, -0.06696721f, 
    -0.00089361f, 0.02155945f, -0.00826458f, -0.08378775f, 0.02455331f, -0.06294421f, -0.03848848f, -0.07694361f, 
    0.00469447f, -0.06147241f, 0.04194198f, -0.04293861f, -0.01327672f, -0.06310111f, -0.06097560f, 0.03882470f, 
    -0.00865446f, -0.09220069f, -0.06267530f, -0.07421637f, 0.03289479f, -0.06612580f, -0.02106401f, 0.04513230f, 
    -0.04737012f, 0.07297685f, -0.01818489f, -0.08159620f, -0.01088413f, 0.06369940f, 0.01814043f, 0.05198901f, 
    0.05881928f, -0.01307643f, 0.02642305f, -0.05876392f, 0.05533610f, -0.02815787f, 0.02444588f, -0.06581921f, 
    0.01922557f, 0.04695629f, -0.07758611f, -0.02241487f, 0.01739235f, 0.01630750f, 0.01645415f, -0.00855216f, 
    0.00489231f, 0.02563619f, -0.06946936f, -0.04674581f, -0.06893326f, -0.07293912f, -0.05337296f, 0.00017501f, 
    -0.02012105f, 0.06120834f, 0.07065323f, 0.00255719f, 0.04353943f, -0.03788434f, -0.01112274f, 0.02090625f, 
    -0.07360474f, -0.07359441f, 0.01435166f, 0.07756562f, 0.00076996f, 0.06132216f, 0.07332498f, 0.03872850f, 
    -0.02996776f, 0.02958701f, 0.01569663f, -0.04692864f, -0.08813889f, 0.04466286f, 0.05977971f, 0.03823249f, 
    0.06392030f, 0.03080814f, -0.59924072f, -0.26030791f, -0.26341772f, -0.02893368f, 0.22236730f, 0.19177133f, 
    0.16182379f, -0.49282509f, 0.22082792f, -0.11030555f, -0.16742377f, 0.25638857f, 0.44453400f, 0.15564878f, 
    0.19462873f, -0.04197384f, 0.37278295f, 0.02388595f, 0.36353785f, -0.43093190f, -0.07100224f, -0.30876917f, 
    0.10150474f, -0.11843324f, -0.11729944f, 0.15112478f, 0.39076939f, 0.32311329f, 0.08483986f, -0.24020517f, 
    -0.06470487f, 0.00647785f, -0.08582921f, 0.13236183f, 0.39116111f, 0.35244620f, 0.44450238f, -0.08111505f, 
    0.27139407f, -0.01911429f, 0.21134531f, -0.18243885f, 0.09276982f, -0.58186972f, 0.02183431f, -1.07348597f, 
    -0.10234308f, -0.06262638f, -0.00115797f, 0.13005432f, -0.02327901f, -0.05254417f, 0.52714753f, 0.51111758f, 
    0.15664004f, -0.18594438f, -0.06373540f, -0.08690342f, 0.06470369f, 0.08469418f, 0.23695399f, 0.20321049f, 
    -0.20456326f, 0.10383995f, -0.11787650f, -0.29423410f, -0.03396084f, -0.02941111f, -0.04857626f, 0.14628930f, 
    0.41757941f, -0.37443754f, -0.84889466f, -0.08157934f, 0.12465133f, 0.09191149f, 0.17010494f, 0.03693991f, 
    0.24408142f, 0.03490286f, -0.50302380f, -0.09374070f, 0.10229037f, 0.01633403f, -0.08752317f, 0.18089829f, 
    -0.04517024f, -0.00067631f, -0.33267689f, -0.32674742f, -0.27280968f, -0.15357099f, -0.02104062f, -0.03327651f, 
    -0.06525510f, -0.09930839f, -0.08393616f, -0.29306179f, -0.13801478f, -0.76796526f, -0.20961133f, 0.09629718f, 
    -0.05782900f, 0.07473798f, -0.17165910f, -0.08913029f, -0.31594747f, -0.18978271f, -0.30359450f, -0.04846549f, 
    -0.15845782f, -0.15971635f, 0.12788196f, 0.09595390f, 0.03335211f, -0.55991739f, -0.37536794f, 0.33952260f, 
    -0.22690617f, 0.00955690f, -0.31051600f, 0.06013116f, 0.07439402f, 0.07207553f, -0.09012466f, -0.07605627f, 
    0.40122706f, -0.13069418f, 0.34412780f, 0.22359270f, 0.09145814f, -0.05556247f, 0.04091426f, -0.17403385f, 
    -0.07881781f, -0.26153648f, 0.17032780f, 0.18827066f, 0.05252305f, -0.01500195f, 0.01636530f, -0.07067712f, 
    0.27666226f, -0.15561372f, -0.24071634f, 0.00376951f, -0.40348566f, 0.15550004f, 0.14613715f, 0.26603633f, 
    0.07575079f, 0.49541315f, 0.17165682f, 0.24817388f, 0.07549957f, -0.02783097f, 0.27346170f, 0.06879134f, 
    0.04132515f, 0.09109581f, -0.09339344f, -0.18151569f, -0.02069002f, -0.12313667f, -0.17699994f, 0.02614030f, 
    0.04192556f, -0.11121918f, -0.05128360f, -0.60719204f, 0.23886050f, 0.31312311f, 0.10048088f, -0.12704103f, 
    0.02050201f, -0.05429054f, -0.00193247f, 0.27171621f, -0.16969857f, 0.05754845f, 0.22914983f, -0.11861873f, 
    -0.17729954f, -0.12187604f, 0.00282426f, 0.05408705f, -0.01400933f, 0.24931076f, -0.23784670f, 0.09532482f, 
    -0.11768164f, -0.06465348f, -0.26414594f, 0.11065959f, 0.07823934f, -0.00151858f, -0.52064914f, -0.06552141f, 
    -0.07124067f, -0.12109239f, -0.08956441f, -0.18355294f, 0.15052859f, 0.03082491f, 0.36589557f, -0.65393257f, 
    0.26158494f, 0.34940946f, -0.07579333f, -0.09459379f, -0.02283114f, -0.04312149f, 0.03214747f, 0.05056771f, 
    0.27857569f, -0.24160534f, -0.13797262f, 0.14814191f, 0.01613848f, 0.21633947f, 0.15253179f, 0.13168691f, 
    0.07017106f, 0.13105996f, -0.09109235f, 0.23096354f, -0.03642977f, 0.00245134f, 0.03927168f, -0.03374616f, 
    -0.14691614f, 0.13874549f, -0.12329268f, -0.64539158f, -0.41237566f, -0.00020626f, -0.17302249f, 0.33222377f, 
    0.01460895f, -0.13303924f, 0.07506578f, -0.29086965f, 0.10905206f, -0.23460782f, 0.07139543f, -0.19071260f, 
    -0.02668675f, 0.11508039f, -0.34332278f, 0.02767490f, -0.05828062f, -0.41845575f, 0.22785902f, 0.12303585f, 
    0.08904073f, -0.18593496f, 0.25146315f, 0.16076024f, 0.05606945f, 0.13912450f, -0.30476910f, -0.26901156f, 
    -0.28615585f, -0.12161794f, -0.01299460f, -0.05577309f, 0.08157804f, 0.10324623f, -0.13801563f, -0.44152531f, 
    -0.57053185f, -0.01259433f, -0.24911068f, 0.10858676f, -0.03851980f, 0.02755169f, -0.09265614f, -0.21028897f, 
    0.37027660f, 0.50559086f, -0.10131476f, -0.09304955f, 0.08127563f, -0.26224375f, -0.10789015f, 0.10596967f, 
    0.14285545f, -0.04087532f, -0.09923790f, -0.39633483f, -0.32178971f, -0.00424771f, 0.08859041f, 0.12436330f, 
    0.09092876f, 0.15899235f, 0.19582562f, 0.14262567f, -0.10947466f, 0.09159198f, -0.14911984f, 0.03901083f, 
    0.08019948f, -0.00239535f, -0.02070675f, 0.20346217f, -0.04403657f, 0.02338414f, 0.07129179f, -0.01006080f, 
    -0.09659048f, 0.26958621f, 0.21030951f, 0.30549061f, -0.12662934f, 0.36436042f, 0.32723948f, 0.22998370f, 
    0.02054094f, 0.00918171f, -0.21549888f, -0.00139980f, 0.47692665f, 0.36755452f, 0.62210542f, 0.08695124f, 
    -0.03700849f, 0.06968074f, -0.06454742f, -0.17618462f, -0.05037375f, -0.19060193f, 0.09243111f, 0.41160360f, 
    -0.04175892f, -0.21411160f, -0.30817324f, 0.04646637f, 0.31041437f, 0.04288205f, 0.51909626f, 0.31816629f, 
    0.16514458f, -0.10252307f, 0.10084490f, 0.17067914f, 0.09376708f, -0.41704041f, -0.06420892f, 0.22648183f, 
    -0.23146321f, 0.57171124f, 0.28978607f, 0.28052875f, -0.00446028f, 0.02786681f, 0.18161921f, -0.01420674f, 
    -0.18388954f, 0.15679203f, -0.08571500f, -0.14304833f, -0.23713855f, -0.04953513f, -0.08165810f, 0.15716462f, 
    -0.24682392f, -0.10999612f, -0.00353965f, 0.08613063f, -0.07921082f, 0.00661631f, -0.00838754f, 0.06834055f, 
    -0.20638858f, -0.08102308f, -0.37708369f, 0.24793370f, 0.38314143f, -0.12316347f, -0.00650823f, -0.12339100f, 
    0.30918443f, 0.00335263f, 0.12567426f, 0.05704805f, 0.17766868f, 0.13233170f, -0.12512113f, -0.02232916f, 
    0.17137302f, 0.04643745f, -0.02995767f, -0.13181658f, 0.08630259f, -0.23030324f, -0.13128220f, -0.09601323f, 
    0.02379753f, -0.03458937f, 0.04722239f, -0.17098922f, -0.21446809f, -0.04141350f, 0.11793686f, -0.22757678f, 
    -0.23559907f, -0.18552244f, -0.13983546f, -0.01053817f, -0.17788498f, -0.09910061f, 0.38926974f, 0.52556920f, 
    0.07771628f, 0.22269067f, 0.34479824f, -0.24399939f, 0.18497957f, 0.07249477f, -0.26271299f, -0.26613328f, 
    0.00228636f, 0.18237112f, 0.12089790f, 0.36964038f, -0.21730293f, 0.17916217f, -0.04736652f, 0.26912490f, 
    0.00280974f, -0.20442669f, 0.17572457f, -0.16575815f, -0.02650593f, -0.04670253f, 0.00668385f, -0.04056083f, 
    -0.19216144f, 0.09117322f, 0.16153729f, -0.16422641f, 0.04319960f, 0.08557905f, 0.31203857f, -0.00439926f, 
    0.08576526f, 0.07825262f, -0.09282196f, -0.10052999f, 0.14266492f, -0.03034668f, 0.02850293f, 0.01351801f, 
    -0.08372422f, -0.27483755f, -0.32944074f, -0.07396919f, -0.04956213f, -0.05845821f, 0.08662368f, -0.19976760f, 
    -0.00718317f, 0.16008419f, 0.20496853f, 0.31029332f, 0.25962526f, 0.37783769f, -0.08831117f, 0.07675805f, 
    -0.04579971f, 0.14764692f, -0.21072122f, 0.02041140f, -0.12890296f, 0.08993625f, -0.13033706f, -0.24300815f, 
    -0.18675880f, 0.18312857f, 0.17006774f, 0.05615203f, -0.15224916f, -0.18816683f, -0.09406558f, 0.22506279f, 
    -0.06774446f, -0.15488596f, 0.02067882f, 0.00118154f, 0.24778438f, -0.03511860f, 0.41091985f, 0.07537740f, 
    -0.26193401f, -0.69682723f, 0.02426443f, 0.00843041f, -0.14902908f, -0.04416189f, -0.13332278f, 0.03554242f, 
    -0.26001361f, -0.03552481f, 0.15722670f, 0.07200550f, -0.08379713f, -0.01081411f, 0.05425994f, 0.13969460f, 
    0.34888494f, -0.36098620f, -0.10064410f, 0.16991027f, -0.02791696f, -0.02836971f, 0.23295875f, 0.00065750f, 
    0.04974652f, 0.05449650f, 0.26469499f, 0.27624577f, -0.12416178f, 0.16256595f, 0.03361200f, -0.04777513f, 
    0.10597663f, -0.05187979f, -0.07698283f, 0.32231343f, 0.19136921f, -0.32537058f, 0.04291873f, -0.03746971f, 
    -0.01718353f, 0.01712016f, 0.06109630f, -0.09384175f, -0.44835758f, -0.14915389f, 0.02372610f, -0.18126799f, 
    0.03794590f, 0.21301429f, 0.03350484f, -0.05114011f, -0.09578077f, 0.01882695f, 0.09735664f, 0.03659418f, 
    0.04096119f, -0.20610130f, -0.05869315f, -0.13472496f, 0.08386026f, 0.08060452f, 0.09041193f, -0.00379768f, 
    -0.32105061f, -0.09548800f, -0.19365408f, 0.11510985f, -0.06746624f, 0.06299288f, -0.06552035f, 0.36546716f, 
    -0.19370569f, -0.29900154f, -0.13004389f, 0.02026318f, -0.06213834f, 0.04508410f, -0.00124206f, 0.12202208f, 
    0.11254255f, -0.08133595f, 0.02897664f, -0.51116556f, -0.33160868f, -0.18669787f, 0.08182544f, 0.13904487f, 
    0.12094410f, -0.36558336f, 0.26782131f, -0.18577696f, 0.26134086f, -0.19739459f, 0.00290757f, -0.10659096f, 
    -0.01780081f, 0.00477308f, -0.37402448f, -0.10745989f, 0.10013740f, -0.18760268f, -0.14240707f, -0.02697380f, 
    -0.06027829f, 0.04240689f, 0.18385704f, -0.38479567f, 0.25551718f, 0.43078452f, 0.11112900f, -0.05376520f, 
    0.13072480f, -0.09518239f, 0.03090660f, 0.10300087f, 0.05924082f, -0.35932043f, -0.08372484f, -0.06366072f, 
    -0.13055281f, -0.09487885f, 0.12783752f, 0.08360852f, 0.04409949f, 0.28642124f, -0.17023095f, -0.68523908f, 
    -0.06589397f, 0.19530390f, 0.19825889f, 0.09728023f, 0.19843975f, -0.27806330f, -0.29947814f, -0.41858679f, 
    0.04433926f, -0.19340959f, -0.34452873f, -0.21540128f, 0.09756582f, -0.06771190f, -0.07653168f, -0.06853843f, 
    0.36025053f, 0.40497234f, -0.12752970f, -0.20344922f, -0.10234790f, 0.09683555f, -0.11732151f, 0.05115897f, 
    0.03036539f, 0.16924998f, -0.13138452f, 0.08645527f, 0.08462643f, 0.31327632f, 0.23023947f, 0.08612581f, 
    0.10619416f, -0.10620684f, -0.03789915f, -0.02525915f, 0.14054947f, 0.09098869f, 0.04192475f, 0.22313942f, 
    -0.09079070f, 0.15151496f, 0.09530657f, -0.33994016f, -0.49292552f, 0.24018024f, 0.05292904f, 0.09236778f, 
    0.12895676f, -0.06521957f, -0.16169590f, 0.55352294f, 0.38680425f, -0.22622845f, 0.16449924f, 0.14603677f, 
    -0.00627594f, -0.10815052f, 0.09509015f, 0.07245384f, -0.36568359f, 0.03413815f, 0.24521993f, 0.12035243f, 
    0.02479509f, 0.11466688f, 0.17411935f, 0.00431758f, 0.04379161f, 0.03192532f, -0.26260549f, -0.48089191f, 
    0.14409336f, -0.08045444f, -0.07630190f, -0.04352501f, 0.19489974f, -0.10538049f, -0.27339163f, -0.23906384f, 
    -0.53515404f, -0.18973082f, -0.31200099f, 0.00501602f, 0.04687288f, -0.11722743f, -0.01239751f, 0.56181437f, 
    -0.06054020f, -0.53929156f, -0.09729650f, -0.11953632f, -0.09922121f, 0.07626387f, 0.06843784f, 0.13305461f, 
    -0.02544437f, -0.05922536f, -0.00921183f, -0.07117730f, 0.03631791f, 0.02539457f, -0.08273765f, 0.06899411f, 
    -0.05198481f, -0.02975987f, 0.05659007f, 0.06898830f, 0.06838661f, -0.03722146f, -0.04474213f, 0.03145591f, 
    -0.08253077f, -0.05460782f, -0.01697152f, 0.02667681f, -0.04962331f, 0.00324861f, -0.08343525f, 0.02231806f, 
    -0.02088274f, 0.00692884f, -0.08662423f, -0.03093245f, -0.00347875f, -0.04107215f, -0.07522566f, -0.03892222f, 
    0.02214086f, -0.08233025f, 0.02328977f, 0.02756660f, -0.06253874f, -0.06954981f, -0.05305391f, -0.00124333f, 
    0.00471105f, 0.05781594f, 0.05396317f, -0.02707218f, -0.01733324f, -0.02872075f, -0.03185113f, 0.05541181f, 
    0.01645461f, 0.07526145f, -0.02640255f, -0.05511561f, -0.08480912f, 0.06624709f, 0.07715523f, -0.06510992f, 
    0.03637111f, -0.08487129f, 0.07152559f, 0.04505431f, -0.08529683f, 0.00724322f, -0.01803045f, -0.04332596f, 
    -0.03654334f, 0.00549153f, -0.01860848f, -0.08886672f, -0.02045181f, 0.01448518f, -0.01090481f, 0.02144565f, 
    0.00475830f, 0.01204593f, -0.06237138f, -0.05079861f, -0.08922645f, -0.06756916f, 0.01156939f, 0.06092402f, 
    -0.04740722f, -0.04925786f, -0.00459368f, -0.00735764f, 0.01494807f, -0.07892608f, -0.05170000f, -0.07805669f, 
    -0.07814007f, 0.01087720f, -0.02332936f, -0.04373766f, -0.07919071f, 0.06724586f, -0.04824720f, -0.05392424f, 
    0.05441388f, 0.01962356f, -0.00092910f, -0.03209906f, -0.04745108f, -0.01191540f, 0.00058867f, 0.04224879f, 
    0.03862258f, -0.04100011f, -0.01236797f, 0.03248525f, 0.01284649f, 0.06499986f, 0.01790852f, 0.00758936f, 
    0.02370846f, 0.03402888f, 0.07156319f, 0.05411006f, 0.02149820f, -0.06873199f, 0.02516628f, -0.04834056f, 
    -0.05052473f, -0.04021620f, 0.00698568f, 0.03007658f, -0.05654751f, -0.06353597f, -0.00156638f, 0.03751020f, 
    0.06645945f, -0.03070645f, 0.07507110f, 0.03922261f, 0.03684048f, -0.06611729f, 0.00366234f, 0.04128153f, 
    -0.02347025f, 0.05157619f, -0.03534370f, -0.00720819f, -0.06496568f, -0.07505437f, 0.03889056f, -0.03850384f, 
    -0.19490390f, 0.07304516f, -0.13623433f, 0.24949771f, 0.10227199f, 0.19736403f, -0.03451513f, 0.49454084f, 
    0.11704967f, -0.04609808f, 0.43800029f, 0.87951463f, -0.17534521f, -0.09438780f, -0.23165481f, -0.12425286f, 
    0.14812818f, 0.03245473f, -0.11104393f, -0.28635398f, -0.37864566f, -0.05728256f, -0.17836887f, -0.00329099f, 
    -0.11941913f, -0.27575114f, -0.34676170f, -0.28132173f, 0.11929424f, 0.11164803f, 0.06200785f, -0.09903583f, 
    -0.00133952f, 0.13792799f, -0.06547166f, 0.08947896f, -0.38280812f, -0.04106550f, -0.09705535f, 0.15739159f, 
    0.19429144f, 0.26241609f, -0.08832697f, -0.08447710f, -0.20187272f, 0.09943759f, 0.13139810f, -0.12190875f, 
    -0.04622277f, -0.10445003f, 0.09730866f, -0.23354574f, -0.05181681f, -0.09756100f, -0.22189459f, -0.18339242f, 
    -0.41364315f, -0.28162292f, -0.24516198f, -0.02743129f, 0.31398472f, 0.37703303f, 0.14812146f, -0.39100790f, 
    0.10363188f, -0.06422908f, 0.30234918f, 0.03995726f, -0.18824564f, -0.22718617f, -0.22055270f, -0.50060165f, 
    -0.01598305f, -0.13296090f, -0.07097383f, 0.12561285f, 0.06554350f, -0.03768817f, 0.09258038f, 0.14435412f, 
    0.14773782f, -0.06812714f, -0.29146540f, 0.07464480f, -0.14669003f, 0.04569120f, 0.09011757f, -0.02262528f, 
    0.00364676f, -0.18569773f, -0.08538399f, 0.10500600f, 0.28383076f, 0.14798725f, 0.08560948f, 0.03880465f, 
    0.06595252f, 0.15792480f, 0.28763062f, -0.22879887f, 0.03317298f, 0.47382674f, -0.05050599f, -0.05466613f, 
    -0.03265129f, 0.15638562f, -0.26357746f, 0.14020616f, -0.14461946f, -0.01185117f, 0.01277959f, 0.03872484f, 
    0.05486577f, 0.14712706f, -0.12160057f, -0.08717041f, -0.02486968f, 0.05667561f, 0.33117265f, 0.40531605f, 
    0.16389038f, 0.17536490f, 0.05199904f, -0.04601516f, 0.14315179f, -0.13519865f, 0.39064890f, 0.55879408f, 
    0.08444312f, 0.05704310f, 0.10511889f, 0.26259488f, -0.05365281f, 0.28393075f, -0.05421294f, -0.08790302f, 
    0.15227658f, 0.27522063f, 0.14230230f, 0.32700187f, -0.09387960f, -0.19263142f, -0.33940706f, -0.19840935f, 
    -0.25612727f, -0.09629270f, -0.17820983f, -0.20461394f, -0.14830412f, 0.04507456f, 0.07424966f, -0.02628850f, 
    -0.09158024f, -0.72662669f, -0.24337716f, -0.11563343f, 0.29607403f, 0.14500989f, 0.10386718f, 0.18926242f, 
    -0.05164048f, 0.00380963f, -0.05735479f, 0.12141652f, -0.01617788f, -0.18344654f, -0.18998663f, -0.14321335f, 
    0.00069430f, -0.15343100f, 0.06638820f, -0.22126551f, 0.21264133f, 0.56980884f, -0.09891362f, 0.16379957f, 
    -0.15881962f, 0.04129252f, -0.07235825f, -0.10284868f, -0.49343738f, -0.17702311f, -0.63991940f, 0.06453269f, 
    0.12965514f, -0.08357204f, 0.04202487f, -0.07221682f, 0.09243666f, -0.41644049f, -0.14555369f, 0.19858776f, 
    0.20465535f, 0.16698159f, -0.14754334f, 0.06881535f, 0.21756905f, 0.09070402f, -0.15135860f, -0.08284068f, 
    -0.61267596f, 0.01567469f, -0.21674277f, -0.11312682f, 0.00306894f, -0.04039391f, 0.22961895f, -0.52881211f, 
    -0.51125371f, 0.11740057f, -0.24458063f, 0.25039327f, -0.03042968f, -0.01705999f, -0.07509754f, 0.12107846f, 
    0.42493120f, 0.04211434f, 0.00410246f, 0.06726635f, 0.06046475f, 0.38597602f, 0.14025204f, 0.03339267f, 
    -0.02705134f, 0.39211640f, -0.16315354f, 0.22684999f, -0.00221513f, -0.03696898f, 0.19137888f, -0.05732857f, 
    0.08513442f, 0.19895636f, 0.86281163f, 0.09619632f, -0.21961534f, -0.00540001f, -0.13599250f, 0.13186567f, 
    -0.14787421f, 0.14683498f, -0.18026112f, -0.20811294f, 0.38909921f, -0.66747510f, -0.15427478f, -0.27323601f, 
    -0.15598303f, 0.13419034f, -0.03602119f, -0.08883206f, -0.29653689f, -0.19453138f, -0.01582493f, 0.03889985f, 
    0.20702456f, 0.00359823f, 0.39868477f, 0.13921107f, 0.34021577f, 0.12469727f, 0.01547839f, -0.45920730f, 
    -0.24191210f, 0.14812812f, 0.16071256f, 0.01720869f, 0.16546893f, 0.17291883f, -0.63816798f, -0.49535304f, 
    -0.11332966f, -0.25845310f, -0.05840253f, -0.03991413f, 0.06894241f, -0.07592762f, -0.12162698f, -0.18501446f, 
    0.00317771f, -0.12425663f, 0.08103178f, 0.17061958f, 0.25160602f, 0.02849632f, 0.10586674f, 0.17471920f, 
    0.27641100f, -0.19091153f, 0.14821589f, 0.09046125f, 0.14181505f, 0.16976932f, -0.07277818f, -0.06190799f, 
    -0.15426005f, 0.44701448f, -0.13221583f, 0.40084937f, 0.15005437f, 0.03799140f, 0.15036352f, 0.06820901f, 
    0.09085459f, 0.41324401f, -0.12077118f, -0.36975726f, -0.05010529f, -0.12761410f, -0.07629433f, 0.05196976f, 
    0.22017787f, 0.15439369f, 0.02978328f, -0.08738832f, -0.03425526f, -0.28317663f, 0.04762871f, -0.22116871f, 
    -0.02816886f, 0.05203155f, 0.30515927f, -0.09479572f, 0.20503467f, 0.31823888f, 0.31554264f, 0.07320061f, 
    -0.03370854f, -0.00237000f, -0.09471855f, 0.05743118f, 0.21345299f, 0.43715334f, 0.02685848f, 0.05746190f, 
    0.05842903f, 0.09784990f, -0.02125476f, 0.05251371f, 0.11561341f, 0.08571305f, -0.27882767f, -0.01389111f, 
    -0.24998175f, 0.09058993f, 0.20676824f, -0.17821015f, -0.05386939f, -0.56084090f, -0.26245144f, -0.11931438f, 
    -0.14645433f, -0.22132012f, 0.04498119f, 0.01892366f, 0.06320771f, -0.08050074f, 0.09860739f, 0.13362391f, 
    -0.01010227f, -0.11807528f, 0.08649361f, -0.06648160f, 0.00404645f, -0.03394995f, 0.03729703f, -0.02781779f, 
    -0.11722047f, -0.01090339f, -0.07657990f, 0.33842069f, -0.04035373f, -0.12356609f, 0.04857451f, 0.01328422f, 
    -0.01208258f, -0.07272342f, -0.27333334f, 0.00610503f, 0.04393341f, -0.05675986f, -0.16049291f, -0.09518049f, 
    -0.03439020f, -0.08092527f, -0.00881638f, -0.11873266f, 0.18318026f, 0.25529107f, -0.20672145f, -0.10616989f, 
    -0.11730050f, 0.15816149f, -0.17534223f, -0.21353006f, 0.38888919f, -0.19836926f, 0.16759536f, -0.09126117f, 
    -0.00151587f, -0.10618864f, 0.05747737f, 0.05828598f, -0.02415284f, 0.21651334f, 0.11507665f, -0.07949340f, 
    0.06862050f, -0.05143125f, 0.05891097f, 0.24463123f, 0.34483722f, -0.00505741f, -0.29979610f, 0.06870306f, 
    -0.09695866f, 0.11594433f, -0.07213558f, 0.09078006f, -0.28883773f, -0.13705581f, -0.08089337f, -0.18178533f, 
    0.31862289f, 0.44776389f, 0.16841511f, -0.07189512f, 0.21289530f, -0.13918303f, 0.26500297f, 0.29217577f, 
    0.01490169f, 0.06629106f, 0.01623974f, 0.06523488f, 0.02242457f, 0.06082188f, 0.01557756f, 0.00428194f, 
    0.02132616f, -0.00824123f, -0.02419931f, 0.05083410f, 0.04824118f, -0.06264730f, -0.08591361f, -0.00342788f, 
    -0.04277643f, -0.02700988f, -0.00400884f, -0.03651067f, -0.05029647f, -0.08715781f, 0.02339588f, 0.01999291f, 
    -0.01350505f, -0.04446555f, -0.07122181f, -0.06292623f, 0.03202958f, -0.06967279f, -0.00477351f, 0.01656688f, 
    0.02051349f, 0.02750999f, 0.00562132f, 0.07062689f, -0.00048760f, -0.00127562f, 0.04386311f, 0.00745268f, 
    0.04398738f, -0.00921954f, -0.00719738f, -0.07786254f, -0.04505085f, 0.00500806f, 0.01122712f, 0.03897315f, 
    -0.00374755f, 0.02893950f, 0.06632900f, 0.03805453f, 0.07132901f, 0.06426952f, 0.06434036f, -0.05169121f, 
    0.03173230f, -0.08151768f, -0.09493737f, 0.02641070f, -0.06246738f, -0.04197409f, 0.04064012f, 0.01815001f, 
    0.02451520f, 0.02310602f, -0.01524088f, -0.04415543f, 0.05604734f, -0.06429110f, -0.05570896f, -0.06046989f, 
    0.03530077f, -0.06092624f, -0.08484495f, 0.02743842f, 0.06341282f, 0.03928635f, 0.03881101f, 0.03987445f, 
    -0.07709509f, -0.02077484f, 0.02624740f, 0.04809239f, -0.05332430f, 0.01118091f, -0.08023825f, 0.02233201f, 
    0.02695488f, -0.05848474f, -0.06792599f, 0.06148907f, -0.02956156f, -0.02055202f, -0.04272517f, 0.01997766f, 
    0.00375943f, -0.00665854f, -0.08553692f, -0.02092580f, -0.04032303f, 0.00524627f, 0.01240825f, -0.05366186f, 
    -0.07631668f, 0.02180303f, -0.05680658f, -0.08891410f, -0.04812735f, 0.04756216f, -0.06424862f, -0.02149849f, 
    0.05374561f, 0.07787795f, -0.09255970f, -0.07926367f, -0.01294268f, -0.01853306f, 0.00416426f, -0.08230785f, 
    -0.02800249f, -0.05426338f, -0.06740240f, -0.00323211f, -0.06565154f, -0.06024143f, -0.04752714f, 0.04866497f, 
    0.03819811f, 0.00875953f, 0.02852033f, -0.08547653f, 0.03633818f, -0.04989472f, 0.02041698f, -0.06869001f, 
    -0.04934093f, -0.04943379f, -0.00106575f, 0.06296769f, 0.04291326f, -0.07759987f, 0.03799185f, -0.00231315f, 
    -0.36621433f, -0.24312401f, -0.07211052f, 0.11841435f, -0.05508099f, 0.17274506f, 0.10526557f, -0.08616857f, 
    -0.22264972f, -0.03604497f, -0.04442270f, -0.11928610f, 0.03804926f, 0.02455791f, -0.02205392f, 0.00424656f, 
    0.23361982f, 0.10410289f, -0.32321283f, 0.09308206f, 0.28651214f, -0.06182282f, -0.25626382f, -0.01007140f, 
    0.11555556f, -0.07091478f, 0.27572790f, -0.34371334f, -0.21579164f, -0.17173149f, -0.02945257f, 0.18734328f, 
    0.03215329f, 0.10725145f, -0.10149653f, -0.07892901f, -0.03970255f, -0.16325814f, 0.02711299f, 0.03967332f, 
    0.00115493f, 0.12238915f, 0.07442188f, 0.07253370f, 0.14052162f, 0.15916336f, -0.16905917f, 0.22045930f, 
    0.07306026f, 0.30114320f, -0.04267685f, -0.00281124f, 0.15733218f, 0.07109670f, -0.31091407f, -0.09477949f, 
    -0.16184342f, 0.07431336f, 0.02497877f, -0.22676243f, 0.00231010f, 0.10260803f, -0.39956763f, -0.15944342f, 
    -0.61607361f, -0.11513743f, 0.03231474f, -0.15323265f, 0.01367369f, -0.11364198f, 0.05080814f, 0.23273578f, 
    0.32260102f, 0.41591650f, 0.03827745f, -0.03473395f, 0.20465827f, 0.03536849f, 0.10487499f, 0.07621066f, 
    -0.07267883f, 0.41856688f, 0.44768623f, 0.23655353f, 0.12626763f, 0.10527807f, -0.19225587f, 0.08545091f, 
    0.06057757f, -0.20246255f, 0.53673714f, 0.01084447f, 0.14605495f, -0.05401751f, -0.00671073f, -0.04470137f, 
    0.04151409f, 0.06483286f, -0.28702629f, -0.02015123f, -0.27061284f, 0.07625249f, -0.10818458f, 0.02828430f, 
    0.17637721f, -0.26060581f, -0.01373625f, -0.26665708f, 0.38881949f, 0.50549477f, 0.26717114f, 0.25652781f, 
    0.17516482f, -0.21899945f, 0.01764509f, 0.05192690f, 0.03648799f, 0.08922762f, 0.17611337f, 0.15842780f, 
    0.06159968f, -0.05310316f, 0.39778250f, -0.01025451f, -0.01563041f, 0.14059077f, -0.32472318f, -0.31399855f, 
    -0.02949530f, -0.25822887f, 0.30793408f, -0.31862786f, -0.28254241f, -0.26486659f, -0.20884955f, -0.11333773f, 
    -0.33060139f, 0.60684419f, -0.03221700f, 0.10534205f, 0.49760231f, 0.17544585f, -0.12742767f, 0.12273696f, 
    0.05457119f, -0.08043326f, 0.00072033f, 0.06245058f, -0.07522541f, -0.04300955f, 0.05324964f, -0.01855765f, 
    -0.01168424f, 0.00024854f, -0.05551048f, 0.04728643f, 0.00759133f, 0.05834425f, -0.07646736f, -0.03562349f, 
    -0.02394014f, -0.07625706f, 0.00901997f, 0.05147431f, 0.02824210f, -0.04197627f, -0.07515560f, 0.06726390f, 
    -0.04833981f, 0.04111072f, 0.00521955f, -0.03317428f, 0.02345266f, 0.05776366f, 0.02400675f, 0.03248408f, 
    -0.04762860f, -0.03711567f, -0.07136224f, 0.03439903f, 0.03540727f, 0.04616826f, 0.00610001f, -0.05121686f, 
    0.00290619f, 0.02939177f, -0.04692252f, -0.08915818f, -0.07685277f, 0.01964870f, -0.05675631f, -0.01807198f, 
    -0.05656108f, -0.01888173f, -0.01617249f, -0.03852317f, -0.02144393f, 0.04113350f, 0.04076762f, -0.04281433f, 
    -0.07419283f, -0.06550906f, -0.04289540f, 0.02625246f, 0.01856991f, -0.02287328f, 0.01933040f, -0.02959414f, 
    0.02060974f, 0.00211990f, -0.03546413f, -0.03934543f, -0.05028422f, 0.00253942f, -0.00465433f, -0.01235396f, 
    -0.07742474f, -0.07500097f, 0.04958795f, 0.01207835f, -0.00977722f, -0.02678278f, 0.02574895f, -0.08066583f, 
    -0.07225906f, -0.06826977f, 0.01206956f, -0.07591204f, -0.09444790f, 0.04798380f, -0.00576253f, -0.00936160f, 
    0.01959158f, -0.01149778f, -0.06639457f, -0.04783057f, -0.02310009f, 0.00156711f, 0.07313643f, 0.03461913f, 
    0.01633938f, -0.04496624f, -0.00121984f, 0.00787368f, -0.05838873f, -0.07516020f, -0.05339206f, 0.03460893f, 
    -0.05128408f, 0.00841313f, -0.05981476f, -0.06100736f, -0.01710906f, -0.02376431f, 0.03435180f, -0.06253608f, 
    -0.03966191f, 0.03339680f, -0.07212742f, -0.03318964f, 0.04237390f, 0.02045293f, -0.02063796f, -0.02057549f, 
    -0.06263518f, -0.01685105f, 0.02490327f, -0.07024876f, -0.08668049f, -0.01819041f, -0.06331012f, -0.03355157f, 
    0.03856831f, 0.07762397f, -0.02555278f, -0.04068706f, 0.06207939f, 0.06943548f, -0.08087535f, -0.02659311f, 
    0.04083341f, 0.02240806f, 0.07331111f, -0.01231513f, 0.03798733f, 0.00930990f, 0.07194142f, -0.00259913f, 
    0.38737661f, 0.43994707f, -0.13328527f, -0.24446771f, -0.27161250f, -0.10844740f, -0.01665069f, -0.16436531f, 
    -0.20619759f, 0.53198421f, -0.01228252f, -0.24717461f, -0.06005496f, 0.18868792f, 0.18240228f, 0.22256289f, 
    0.06230777f, -0.06940036f, 0.06819867f, 0.37902987f, 0.08807345f, 0.11458036f, -0.14478636f, 0.06634866f, 
    0.18065083f, 0.03871854f, -0.16782789f, 0.54149354f, -0.16061550f, -0.33334145f, -0.06440821f, 0.14658296f, 
    -0.12197177f, -0.01508811f, -0.06697064f, -0.01895493f, -0.68904644f, -0.25586930f, -0.06390972f, -0.21978670f, 
    -0.01223018f, 0.05072262f, 0.05543387f, -0.00453222f, -0.05349438f, -0.04129148f, -0.13692184f, 0.31469199f, 
    0.09626591f, -0.29738230f, 0.02230946f, -0.06660807f, 0.12432577f, -0.26611370f, -0.14654614f, -0.36106259f, 
    0.34549031f, -0.14056252f, 0.07857976f, -0.02428345f, -0.01065990f, 0.10036299f, 0.33877799f, 0.44156024f, 
    -0.76867777f, -0.98576909f, -0.18042529f, -0.26835635f, -0.19364804f, -0.07247617f, -0.07014190f, -0.17032190f, 
    -0.00165387f, 0.24215132f, 0.03119010f, 0.14097278f, -0.09226428f, 0.16040035f, 0.01886606f, 0.20639229f, 
    -0.04107614f, -0.08131801f, 0.15158664f, 0.18850458f, 0.12287056f, -0.01653228f, -0.08671143f, 0.07528292f, 
    0.04548176f, -0.02659585f, -0.28596112f, 0.11116581f, 0.16590698f, -0.06790759f, -0.12973124f, 0.16557974f, 
    0.05934751f, 0.05807583f, 0.03881047f, 0.34094995f, -0.60120785f, -0.52023989f, -0.07328462f, 0.07983992f, 
    0.23441172f, 0.10994090f, 0.00303599f, -0.00612281f, 0.23452385f, 0.21190536f, 0.11646108f, -0.16848566f, 
    0.04702669f, -0.35373577f, -0.00183083f, 0.03765773f, 0.25132921f, -0.33489531f, 0.09473006f, 0.31618994f, 
    -0.27635258f, 0.10015715f, -0.28793585f, -0.04712989f, 0.08723337f, -0.09921636f, -0.31050232f, -0.14687587f, 
    0.13496175f, 0.01057412f, 0.10613059f, -0.03877515f, -0.10283075f, 0.19500715f, -0.17674841f, 0.48076445f, 
    -0.55456293f, 0.30324662f, 0.05765909f, -0.03803995f, 0.35687354f, 0.08818488f, 0.10131013f, 0.09365768f, 
    0.19262190f, 0.14782232f, -0.03736052f, -0.04252084f, -0.11476428f, 0.11815499f, -0.14532350f, 0.06030387f, 
    -0.04607359f, 0.21394767f, 0.02248472f, 0.32157150f, 0.09301165f, 0.21556613f, 0.30536735f, 0.13377175f, 
    -0.03036222f, -0.01066698f, -0.56103605f, -0.29546878f, -0.33118957f, 0.08126973f, -0.15462354f, -0.02484649f, 
    0.10202499f, -0.22297882f, 0.02739339f, 0.27426255f, 0.19180544f, 0.33240721f, 0.10873496f, 0.18786167f, 
    0.18299997f, -0.04083539f, 0.22566962f, 0.12650546f, 0.15245016f, 0.16162865f, 0.20292835f, -0.09123915f, 
    0.18459561f, -0.10600189f, 0.08639885f, 0.01917293f, 0.01724284f, -0.46235210f, 0.09783840f, 0.16353212f, 
    -0.27709898f, -0.12826334f, 0.06114828f, 0.04107469f, 0.00806898f, 0.11196861f, -0.21812816f, -0.02244744f, 
    0.22946647f, 0.01278789f, -0.10208607f, 0.01004246f, 0.08418875f, -0.00946211f, 0.33399510f, 0.19786474f, 
    0.23273605f, 0.41754866f, 0.01718754f, 0.11352092f, -0.06062433f, -0.02826145f, -0.06161347f, -0.17926735f, 
    -0.65210217f, -0.32078069f, 0.08834741f, -0.13214828f, 0.07412853f, 0.18535079f, 0.03378780f, 0.05006135f, 
    0.15551293f, -0.88128942f, -0.33394301f, 0.05072063f, -0.17681821f, -0.22716074f, 0.10525293f, -0.02296161f, 
    0.09765104f, -0.05886610f, 0.33328256f, 0.05787862f, -0.47932678f, -0.15047218f, 0.23963487f, -0.16629897f, 
    -0.03776608f, 0.12848487f, 0.08871500f, 0.40595400f, -0.68791264f, -0.36373788f, 0.19343494f, 0.00083454f, 
    0.00436915f, 0.00295102f, 0.11713322f, -0.07014345f, -0.27377239f, 0.03164559f, -0.17810802f, -0.23747377f, 
    -0.15379360f, 0.14636901f, -0.20649894f, 0.20036887f, 0.10267374f, -0.12547025f, 0.02451899f, -0.00901710f, 
    0.17079304f, -0.25282663f, -0.08561232f, 0.23300304f, -0.06909113f, 0.15766324f, 0.51599073f, -0.19069816f, 
    0.05326319f, -0.15168157f, 0.15271157f, -0.13969287f, 0.09057360f, -0.05459879f, -0.07827447f, 0.16459391f, 
    -0.31176370f, -0.01165236f, -0.29910031f, -0.11199202f, -0.05394252f, 0.15213001f, 0.03271179f, 0.04804633f, 
    -0.02863646f, -0.03864274f, 0.03585004f, 0.06936672f, -0.07243098f, 0.01524407f, 0.00304312f, 0.05860844f, 
    -0.04536752f, 0.07995572f, -0.08605876f, 0.06236906f, -0.06187820f, 0.04360934f, -0.04405165f, -0.07060274f, 
    -0.01611248f, -0.06042923f, 0.03268717f, 0.03400022f, -0.05476396f, 0.00633513f, -0.05788621f, 0.03764322f, 
    -0.00314742f, 0.04467883f, -0.02369891f, -0.02293417f, -0.00768857f, 0.05031099f, 0.02210433f, 0.00670153f, 
    0.07099116f, -0.01364320f, -0.01551756f, 0.00747957f, -0.02384337f, -0.05999658f, -0.06830139f, 0.00994334f, 
    -0.04203016f, 0.01180224f, 0.00008699f, 0.05345353f, 0.00234483f, 0.07299620f, 0.02430394f, -0.02847484f, 
    -0.06359412f, 0.03643106f, -0.05498999f, -0.08277099f, -0.07462741f, 0.00035647f, -0.06585074f, -0.02197184f, 
    0.00718622f, -0.03059438f, -0.06057221f, -0.06176393f, 0.03069799f, -0.01450236f, -0.06088803f, -0.06674794f, 
    -0.08350584f, 0.04587870f, 0.05543364f, 0.02010909f, -0.05060536f, -0.06831051f, 0.00541333f, 0.05393008f, 
    0.00148355f, 0.02043901f, -0.09610430f, -0.01696103f, -0.07864849f, -0.08300277f, 0.03462234f, -0.01610810f, 
    -0.06619210f, -0.02655520f, 0.03986001f, -0.03834914f, 0.06013716f, 0.02106296f, 0.00780797f, -0.08913684f, 
    -0.00831802f, -0.00274982f, -0.06477971f, -0.02506643f, -0.08579148f, -0.05260430f, -0.05851893f, 0.03871132f, 
    0.03981785f, -0.04678234f, -0.07599851f, -0.03819634f, -0.00134464f, -0.02913943f, -0.09686419f, -0.01493953f, 
    -0.02306152f, -0.00270636f, -0.09430066f, 0.01535803f, 0.03075369f, -0.05889820f, 0.05032885f, -0.01491197f, 
    -0.06718251f, 0.06916760f, -0.04383678f, -0.01209557f, -0.04278582f, -0.09167320f, 0.09382805f, -0.00077399f, 
    -0.06122830f, -0.04458994f, -0.00224522f, -0.06754451f, 0.06018586f, -0.05621930f, -0.01982247f, -0.04225881f, 
    0.00144738f, -0.03698339f, 0.05791287f, 0.04905007f, 0.02975988f, 0.01309972f, -0.00434481f, -0.06671210f, 
    -0.03319858f, 0.04449188f, -0.07807728f, -0.02190394f, 0.06689837f, -0.06970238f, 0.00486856f, 0.02644485f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.03541781f, 0.29895705f, 0.31390050f, -0.24519113f, 0.26911867f, 0.56956434f, -0.04064320f, 0.07685702f, 
    0.55832106f, 0.12068552f, -0.07016219f, 0.33797097f, 0.02246571f, 0.05093304f, 0.09785491f, 0.04692960f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.18390517f, 0.03950891f, -0.31306630f, 0.53696805f, 0.26447207f, 0.04674958f, -0.17901683f, 0.55357301f, 
    -0.93390727f, -0.13534115f, -0.14011434f, -0.68464601f, 0.00119624f, -0.31800810f, 0.92950898f, -0.09058632f, 
    -0.14016786f, -0.02450018f, 0.41442531f, -0.32126880f, -0.53928620f, 0.21204068f, -0.19019367f, -0.36464778f, 
    -0.17693478f, 0.41618612f, 0.20349333f, 0.54965734f, -0.10904992f, -0.45560440f, -0.08876058f, 0.15672313f, 
    -0.22560351f, 0.07252669f, -0.15891685f, 0.15845147f, 0.62653512f, 0.85217893f, -0.22811864f, -0.02681762f, 
    0.46051684f, -0.10884522f, 0.08131495f, -0.19862540f, 0.18352005f, -0.36565843f, 0.37536556f, -0.09676977f, 
    0.17137586f, -0.35908750f, -0.08340795f, 0.08040282f, -0.08718968f, 0.14068455f, -0.06041298f, -0.31884345f, 
    0.31152248f, 0.49229598f, 0.07589561f, 0.25788507f, 0.18547577f, -0.30964863f, -0.17911336f, -0.19043759f, 
    0.19287741f, 0.18076842f, -0.19594622f, -0.16378596f, 0.07948295f, 0.18607807f, -0.13802087f, -0.12253812f, 
    0.22891793f, -0.30620587f, 0.05225182f, 0.66312510f, 0.08783137f, 0.09486271f, 0.42532599f, -0.16313171f, 
    0.11098583f, -0.60780180f, 0.86979538f, 0.27482882f, -0.22275597f, -0.01814901f, -0.18431203f, 0.22420849f, 
    -0.05772373f, 0.39317498f, -0.12003079f, -0.51720673f, -0.20501447f, 0.29104948f, -0.02867795f, 0.16376978f, 
    -0.23765767f, -0.01553884f, 0.04804681f, -0.08603717f, -0.44612548f, 0.18270096f, -0.03327775f, -0.09359604f, 
    0.57495129f, -0.42176783f, -0.18869153f, 0.34350464f, -0.06211084f, 0.06832077f, 0.56977713f, 0.00399005f, 
    0.00545490f, -0.25099146f, 0.48546925f, 0.20419773f, 0.01625651f, 0.69401008f, 0.16373080f, -0.24238044f, 
    0.12228452f, 0.40921515f, 0.05217332f, -0.05490374f, -0.00559911f, -0.59285146f, -0.34399080f, -0.06741107f, 
    0.18140697f, 0.76790965f, -0.12509529f, 0.67554200f, -0.20241714f, 0.31651470f, 0.22548118f, -0.44440281f, 
    -0.47712079f, 0.16436204f, 0.21551581f, 0.09261058f, -0.17203972f, 0.51961893f, -0.15091057f, -0.01165569f, 
    -0.24384077f, -0.64296913f, 0.55209172f, 0.29132068f, -0.23687516f, -0.46048731f, 0.19300450f, -0.18391924f, 
    -0.05427988f, 0.36326334f, 0.14296925f, 0.12643114f, 0.06441400f, -0.04080044f, -0.05211277f, 0.15383379f, 
    -0.01594066f, -0.40435743f, 0.10903930f, 0.18065700f, -0.27507946f, 0.22687693f, -0.23873307f, -0.48367321f, 
    0.60893351f, 0.00792153f, 0.08934265f, -0.07834214f, 0.14402923f, -0.04781894f, -0.57650512f, -0.24028791f, 
    -0.01490105f, -0.67373651f, 0.54164380f, 0.00729775f, -0.09960806f, -0.22761765f, -0.15902609f, 0.19578001f, 
    0.28788492f, -0.07088947f, 0.14100178f, -0.25843862f, -0.21398625f, 0.36682102f, 0.57965285f, 0.00341259f, 
    -0.23047742f, 0.67088163f, -0.21156752f, 0.26566252f, 0.21332546f, -0.21912259f, 0.22020474f, -0.95934784f, 
    -0.32896480f, 0.33151996f, -0.01177471f, 0.43768546f, -0.15773393f, -0.15352648f, 0.01452723f, -0.20547083f, 
    0.12685293f, 0.04270143f, 0.43112889f, -0.00638621f, 0.15360184f, -1.53402746f, 0.11164859f, 0.48071828f, 
    0.19956891f, 0.10771514f, -0.18080740f, 0.02565133f, 0.06617641f, 0.30297688f, 0.43676478f, -0.03804636f, 
    -0.16765134f, -0.46782452f, 0.20164350f, -0.39177972f, 0.25584221f, 0.67459142f, 0.06711372f, 0.15443201f, 
    0.32328972f, -0.11714120f, 0.06686045f, 0.22104143f, -0.01005471f, -0.02649003f, 0.59739643f, -0.01786484f, 
    0.23739415f, -0.67641366f, 0.46324977f, 0.00137853f, 0.25340948f, -0.67578042f, -0.03739064f, 0.05582667f, 
    0.44857773f, 0.23876588f, 0.14313680f, -0.13529392f, -0.17374843f, 0.37295449f, 0.14011252f, -0.07275229f, 
    -0.17990813f, 0.12545450f, 0.35440168f, 0.14438409f, -0.69598579f, -0.30056551f, 0.02758053f, -0.24342328f, 
    0.13947140f, 0.37494975f, 0.12790340f, 0.40185368f, -0.07706383f, -0.77075624f, -0.08651605f, -0.06392763f, 
    0.17864707f, 0.56515235f, 0.11175802f, 0.21342398f, 0.43527496f, 0.20992962f, 0.22881009f, 0.33909270f, 
    -0.24419978f, 0.38402095f, 0.23565076f, -0.30908388f, -0.05589378f, -0.03866968f, -0.21697578f, 0.08832337f, 
    0.10777271f, -1.03889239f, 0.21683276f, 0.03338844f, -0.02703869f, 0.34089348f, -0.03367860f, 0.33371845f, 
    0.31394511f, -0.36341870f, -0.14144917f, 0.07702899f, -0.00727996f, 0.31288770f, -0.14990859f, -0.14956906f, 
    0.00370079f, -0.35037753f, -0.18353836f, -0.23502930f, -0.26695606f, -0.64522111f, 0.12648542f, 0.05974850f, 
    0.60670519f, 0.17203905f, -0.13903515f, 0.53876632f, 0.13842060f, 0.22445148f, -0.25543013f, 0.03426183f, 
    0.10111451f, -0.73440641f, 0.27330390f, 0.05678530f, 0.35292709f, 0.41092446f, 0.00616886f, -0.22697784f, 
    0.56642169f, 0.29641843f, 0.13849033f, -0.24097200f, 0.14998493f, 0.19545722f, -0.49223626f, -0.14617378f, 
    -0.24014013f, 0.18381485f, 0.17641798f, -0.23380050f, -0.05587015f, 0.08867169f, -0.16633922f, -0.03714527f, 
    -0.06612417f, -0.02002814f, 0.02967467f, -0.02077270f, -0.19611070f, -0.06631447f, -0.16617489f, 0.00042980f, 
    0.01989216f, 0.74703687f, 0.30726790f, -0.03539191f, 0.41643772f, -0.55180359f, -0.03758251f, 0.65167040f, 
    0.21472320f, -0.21947671f, 0.12240325f, -0.10691466f, 0.19063608f, 0.06760722f, 0.34132332f, -0.11915984f, 
    -0.06420369f, -0.26238143f, 0.92860842f, 0.01971961f, -0.27485287f, -0.49315906f, -0.24665329f, 0.21273300f, 
    -0.28748387f, 0.26574808f, -0.03081047f, 0.40856162f, -0.14815159f, 0.22536464f, 0.03001730f, -0.22132103f, 
    0.00623390f, 0.01610793f, -0.35961074f, 0.45535454f, -0.24548854f, 0.18096189f, 0.04688835f, -0.64379436f, 
    0.46275237f, -0.07469640f, -0.17120239f, 0.46517044f, -0.03554875f, 0.31299320f, -0.70861858f, -0.01426863f, 
    -0.02461258f, -0.20469958f, -0.07724715f, 0.29643071f, 0.00000254f, -0.75155103f, 0.15747234f, -0.22133705f, 
    0.52828991f, 0.18528810f, -0.19678365f, 0.11657331f, 0.22966620f, 0.38556996f, -0.35808560f, -0.05578226f, 
    0.23466742f, -0.18719874f, 0.50993824f, -0.10509389f, 0.14702094f, -0.23732534f, 0.21445507f, 0.32302007f, 
    0.54343182f, 0.43865982f, 0.20229283f, 0.26692411f, -0.15037444f, -0.74944836f, -0.52797526f, 0.22285995f, 
    -0.24834132f, -0.13489808f, -0.08196518f, -0.13450757f, 0.07963038f, -0.11951166f, -0.02709734f, -0.05412709f, 
    -0.04659701f, 0.07573172f, -0.18352376f, -0.19875117f, 0.24483457f, -0.02314607f, -0.24108878f, -0.02733013f, 
    -0.20240276f, -0.62554723f, -0.03352788f, -0.22562858f, 0.67082840f, -0.06857287f, 0.21731283f, -0.09749065f, 
    0.49203464f, -0.37517050f, -0.21225630f, 0.38926077f, -0.11717416f, -0.11340708f, 0.46609920f, 0.01583192f, 
    0.04516569f, -1.03686583f, 0.14508738f, -0.63296276f, 0.38469750f, -0.33959407f, -0.04219687f, -0.09796477f, 
    0.05669511f, 0.04664197f, 0.02376644f, 0.04076933f, -0.23344639f, 0.30556986f, -1.16615975f, -0.21355766f, 
    0.17454194f, -0.36097240f, 0.55890667f, 0.15181509f, -0.36433831f, 0.40736958f, -0.03284146f, -0.14924347f, 
    0.38510066f, 0.34744519f, 0.14483632f, -0.13969404f, -0.04986892f, -0.41583702f, -0.42538449f, -0.25265014f, 
    0.01807323f, 0.89886063f, 0.36305228f, -0.25932157f, 0.07631006f, 0.66266394f, -0.12941112f, 0.48353133f, 
    0.45067900f, -0.17102645f, 0.00168378f, 0.42750487f, -0.24455224f, -0.64651251f, -0.34557784f, -0.08251232f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.23687555f, 0.70832676f, 0.79638171f, 0.62233335f, 0.10257046f, 0.04900208f, -0.04412501f, 0.45825231f, 
    0.35288706f, 0.15300006f, 0.14446685f, 0.24805249f, 0.32744101f, -0.39813510f, 0.70785689f, -0.09680685f, 
    -0.20539723f, 0.11777865f, 0.28471112f, -0.05703837f, -0.31451246f, -0.24171765f, 0.09861878f, 0.24143307f, 
    0.08502474f, -0.13348518f, 0.49918863f, 0.00148804f, -0.21411778f, 0.19696397f, 0.17605382f, 0.52340907f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.43346703f, 0.81554610f, 0.23849134f, -0.28791755f, 0.13177642f, -1.00613260f, -0.14554748f, -1.02335775f, 
    0.37277406f, -1.52622259f, 0.02319955f, -0.55600762f, 0.35271758f, 0.11919934f, 0.15399130f, -0.26653051f, 
    -0.64322025f, 0.27089903f, 0.39929700f, -0.31912690f, 0.10580830f, 0.11624047f, 0.05962855f, -0.82951158f, 
    0.16272835f, -0.61342496f, 0.27738279f, -0.04924427f, -0.32988942f, 0.25091472f, -0.06166473f, -0.26703984f, 
    0.49690598f, -0.26228729f, 0.49969947f, -0.35483754f, 0.24719855f, -0.19397764f, 0.38177606f, -0.00982377f, 
    -0.25876662f, -0.62738907f, 0.17124477f, 0.25071976f, -0.33113748f, -0.12549087f, 0.29118311f, -0.03357621f, 
    -1.06972623f, -0.09158579f, -0.07582611f, 0.28199232f, 0.00333177f, -0.12235655f, 0.12966375f, -0.19430678f, 
    0.22210592f, 0.51424313f, -0.63985407f, 0.10321730f, -0.06043488f, 0.77224302f, -0.15083902f, 0.09722460f, 
    -0.50035018f, 0.46767816f, 0.14255872f, 0.18104407f, -0.05848268f, 0.46475917f, 0.07905938f, 0.43787491f, 
    -0.01739416f, 0.14579581f, -1.43660879f, 0.23634019f, -0.47096339f, -0.89958656f, 0.42277139f, -0.04021010f, 
    0.29164803f, -0.03747181f, 0.10925531f, -0.85621029f, 0.40130919f, -0.17413200f, -0.45050445f, 0.08243848f, 
    -0.45247930f, -1.54204810f, 0.05027767f, -0.15452187f, -0.10860433f, 0.52700865f, 0.34532109f, -0.24742936f, 
    0.17100738f, 0.32202852f, 0.26755765f, 0.30858508f, -0.31722093f, 0.33633468f, -0.82229358f, 0.05690889f, 
    0.26350087f, 0.45129842f, -0.33436462f, 0.04351415f, 0.46111616f, -0.15879522f, 0.04405387f, 0.33673322f, 
    -0.25438797f, 0.03029328f, 0.67618066f, 0.10615017f, -0.90433264f, 0.12473880f, -0.25419506f, -0.03604636f, 
    -1.28374684f, -0.46957693f, 0.03951442f, 0.13693984f, -0.32384282f, -0.25614983f, -0.51922542f, -1.10836530f, 
    0.04001360f, -0.80998701f, -0.26561674f, -0.39911163f, 0.33637270f, -0.22572482f, 0.27581069f, -0.24757454f, 
    0.39221528f, -0.05523595f, -0.28610349f, -0.37731656f, 0.42956397f, 0.02502996f, -0.60870540f, -0.66143745f, 
    0.58200610f, 0.16485339f, 0.48504683f, -0.15499507f, 0.31419975f, -0.01921183f, -0.15940829f, 0.27643239f, 
    -0.08582623f, -0.61683547f, -1.08072674f, 0.06643719f, 0.38110808f, 0.18995999f, -0.08619914f, 0.22746898f, 
    -0.00561945f, -1.13072360f, 0.27654123f, -0.29271418f, -0.27988124f, -0.04519739f, -0.75680184f, 0.12791668f, 
    0.08282366f, -0.63234288f, 0.09579403f, -0.33336776f, -0.05861881f, -0.12475811f, -0.30154598f, -0.15214740f, 
    -0.65089065f, 0.42753270f, -0.45590690f, -0.06580944f, -0.19363937f, -0.03146271f, 0.29680705f, -0.13858005f, 
    0.24922563f, 0.41074535f, 0.34724057f, -0.12592353f, -0.36790669f, 0.01007741f, -0.27326441f, 0.72557157f, 
    -0.92389375f, -0.07970096f, 0.07124244f, 0.16909416f, -0.29367429f, 0.05141221f, -0.05547754f, 0.36689907f, 
    -0.59032202f, -0.04265326f, 0.71381503f, -0.18847890f, -0.60182947f, -0.87183356f, -0.05246026f, 0.19219208f, 
    0.06641618f, -0.12436141f, 0.28928864f, -0.03960773f, 0.48592997f, 0.12552050f, -0.56712759f, -0.38699117f, 
    0.06739411f, 0.09849686f, 0.50344038f, 0.00074065f, -0.04708876f, -0.90541595f, 0.44573253f, 0.19933756f, 
    -0.85858434f, -0.07233421f, -1.03155291f, -0.20650618f, -0.13372429f, 0.60743338f, 0.38452688f, -1.36952996f, 
    0.48337072f, 0.20606042f, 0.17356899f, 0.47805843f, -0.14020336f, -0.02577615f, -0.12754232f, 0.24045996f, 
    -0.65527648f, -0.44813180f, 0.04390801f, -0.20955729f, 0.22334239f, -0.10595924f, -0.14885432f, 0.15179540f, 
    0.29970786f, 0.18631946f, -0.88612819f, -0.14845005f, -0.60336930f, -0.60337055f, -0.24047439f, -0.59478509f, 
    -0.27203256f, -0.28183797f, 0.25030702f, -0.11527857f, 0.36703378f, -0.30433959f, 0.57474667f, -0.55651736f, 
    -0.72314757f, -0.27668914f, -0.39008152f, 0.16918848f, -0.21428111f, 0.32017192f, 0.31485230f, 0.18696508f, 
    -1.44554663f, -0.25199738f, 0.06612047f, -0.14976162f, 0.04373581f, -0.16635579f, 0.11624411f, 0.08238672f, 
    -0.33204398f, -0.36681682f, 0.13801105f, -0.00227688f, 1.04997528f, -0.75064325f, -0.64243257f, 0.17062007f, 
    -0.70492303f, 0.55921811f, 0.06475812f, 0.27194011f, 0.20482945f, -0.49958515f, -0.08851782f, 0.24208851f, 
    0.32031792f, -0.08648152f, 0.22666064f, -0.57447916f, 0.35656276f, -1.00485396f, -0.00210653f, -0.56194049f, 
    0.04851682f, -0.23747137f, 0.13319314f, -0.29393059f, -0.15548296f, 0.08025268f, -0.18634266f, -0.01956536f, 
    0.15951706f, -0.55835003f, 0.22632384f, -0.16493623f, -0.53020924f, 1.07301164f, 0.08532894f, 0.31978440f, 
    -0.08977667f, -0.81820595f, -0.57053083f, -0.65420109f, -0.38443527f, 0.51730859f, -0.87775058f, -0.31182742f, 
    -0.27999368f, 0.32595503f, -0.40483549f, 0.30638093f, -0.57474977f, 0.72226948f, -0.20920303f, 0.61222517f, 
    -0.76511073f, 0.11641858f, -0.25083762f, -0.67868227f, 0.34816611f, -0.08609386f, 0.26658049f, 0.48812178f, 
    -0.69209498f, -0.02953502f, 0.13708125f, -0.01158118f, -0.47351420f, -0.51002532f, 0.36913767f, -0.36965168f, 
    -0.54244632f, 0.42577234f, -0.58770567f, 0.18450421f, -0.01759582f, -0.06581545f, -0.07614837f, -0.21598801f, 
    -0.53418398f, 0.31882873f, -0.49739540f, -0.06592879f, -0.24508499f, 0.38382775f, -0.17133139f, 0.07758327f, 
    0.27686334f, -0.29228339f, -0.16225827f, 0.47260863f, 0.06669322f, 0.03833662f, -0.13601437f, 0.33143604f, 
    -0.18445566f, -0.04274424f, 0.31279603f, 0.07060750f, -0.08796554f, -0.07458042f, 0.03357797f, 0.01520709f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.31700233f, 0.17724268f, -0.03247844f, 0.04221955f, -0.25405559f, 0.30896875f, -0.57234293f, -0.25831577f, 
    -0.13424011f, 0.11803508f, -0.28743541f, 0.04680242f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
