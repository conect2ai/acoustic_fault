#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.87763119f, 0.21435864f, -0.38906226f, 0.36264524f, -0.42882377f, 0.53352076f, 0.55364496f, -0.77059120f, 
    -0.04628060f, -1.31438923f, -1.13753688f, -0.60045034f, 0.68938679f, 1.32661414f, -0.44925252f, -0.42116067f, 
    -0.31372282f, 0.20437762f, -0.02671050f, 0.44455525f, 0.99566275f, -0.75898683f, -0.46385512f, -0.21029907f, 
    -0.59977061f, 0.96799332f, -0.62104934f, 0.38284644f, 0.23502369f, 0.82198405f, 0.32644221f, 0.14910360f, 
    -0.02630495f, -0.25420603f, -0.36924985f, -0.00027615f, 0.98489606f, 0.14012603f, 0.40249637f, -0.01838848f, 
    -0.33918542f, -0.61554492f, 0.24205725f, -0.57536685f, 0.84797484f, -1.12975240f, 0.08974012f, -0.39250648f, 
    0.22035930f, 0.09726151f, -0.78210145f, -0.41379774f, -0.58155328f, -0.48121744f, -1.08166432f, -0.50468558f, 
    -0.29314604f, -0.63916808f, -0.48726374f, -0.77976608f, -0.53478098f, -0.75047868f, -0.37291098f, 0.31965768f, 
    0.42598251f, -0.05204153f, 0.02620544f, 0.53386468f, -0.32066891f, 0.46656814f, 0.48834404f, 0.48350510f, 
    0.27072051f, -0.19146073f, -1.17791247f, -0.02901497f, -0.08599401f, -0.19820458f, 0.51448715f, 0.53579885f, 
    0.72399521f, -0.85995716f, -0.19982989f, 0.84540915f, 0.43983838f, 0.92301536f, 0.61104238f, 0.04360826f, 
    0.14027973f, 0.09623584f, 0.02820203f, 0.16635036f, 0.58542293f, -0.56319892f, -0.04233881f, -0.16640669f, 
    -0.13975950f, 0.18775792f, 0.87144685f, 0.82428819f, 0.82127416f, 0.42520902f, -0.71201384f, -0.95987988f, 
    -0.99258614f, -0.13584824f, -0.42766702f, -0.52973026f, -0.39898747f, 0.38889316f, 0.33368629f, 0.55519563f, 
    0.37012783f, -0.84779906f, -0.12969546f, -0.05685493f, -0.22835314f, 0.65811330f, 0.44633189f, 0.43341729f, 
    0.21286461f, 0.12444789f, 0.09843027f, 0.36715063f, -0.18724605f, -0.10480944f, 0.13420393f, 1.11735439f, 
    -0.22521479f, -0.21040379f, 0.30288550f, 0.46695179f, 0.09809850f, -0.27542394f, 0.63462919f, 0.15772317f, 
    0.63370413f, -0.38773355f, -0.28287011f, -0.01287652f, 0.23645422f, -0.49600175f, -0.85236728f, -0.59622079f, 
    0.16402732f, -0.06527143f, -0.58387756f, -0.75234097f, -0.79633766f, -0.36604103f, -0.29082471f, 0.84426403f, 
    0.65989852f, -0.41001850f, -1.00030446f, -0.09758033f, 0.74885267f, 0.53055757f, 0.98421264f, -0.32018170f, 
    -0.89403665f, -0.45725167f, -0.37212509f, 0.48193493f, 0.19554999f, -0.30959386f, -0.96020025f, -0.84446239f, 
    -0.01938380f, 0.13121703f, 0.49175057f, 1.01995170f, 0.88784838f, -1.11688387f, -0.07843246f, 0.18280320f, 
    -0.20111205f, -0.40948969f, 0.37139183f, 0.15441114f, -1.11388695f, -1.12675202f, -0.26598343f, -0.04062673f, 
    -0.43701473f, -0.06689918f, 0.32990876f, -0.33748493f, -0.46862322f, -0.85721344f, 0.20779091f, 0.98796999f, 
    0.95199764f, -0.40312457f, -0.63990545f, -0.25250447f, -0.46297792f, -0.21802230f, 0.14704786f, 0.19443353f, 
    -0.27361700f, -0.35259435f, 1.29564798f, -1.07175577f, 0.10881218f, 0.21662480f, 0.19284274f, -0.33453551f, 
    -0.88754737f, -0.17267522f, -0.34027067f, -0.09854475f, -1.23437309f, -0.00757981f, 0.33668846f, 0.37647441f, 
    0.49029487f, -0.67973000f, -0.82668155f, -0.97683740f, -0.98190612f, -0.63134879f, 0.43112931f, -0.61131841f, 
    0.66734219f, -1.12344611f, -0.76186347f, 0.85089314f, -0.48072106f, 0.43045366f, -0.21318319f, 0.63815224f, 
    0.78932762f, -0.09716574f, -0.87385833f, 0.39671877f, 0.67147297f, -0.91134846f, -0.91817552f, 1.58042848f, 
    -0.11564363f, -0.10953996f, -0.05196832f, -1.00983179f, 0.30068469f, -0.63643694f, 0.67426807f, 0.86472166f, 
    0.24508847f, -0.08640750f, 1.02412701f, -0.37602311f, 0.42319292f, 0.48267433f, 0.48951113f, 0.16300130f, 
    0.30454966f, 0.42509350f, 0.05879432f, 0.00063041f, 0.52241725f, 0.54020458f, 0.01767396f, 0.08116394f, 
    0.00940463f, 0.02150038f, 0.40684199f, 0.26657540f, 0.70503157f, -0.88948786f, -0.42874393f, 1.13631809f, 
    -0.41273645f, -0.32896239f, -0.32444170f, -0.68673468f, 0.75373483f, 0.46270567f, 0.44701189f, -0.04378372f, 
    -0.22616158f, 0.50029486f, -0.33037937f, -0.02111274f, -0.39461684f, -0.51108217f, -0.60871065f, -0.15994731f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.25100684f, 0.10028585f, -0.17979497f, 0.38042384f, 0.17529498f, 0.63061970f, -0.26779947f, 0.50650954f, 
    0.52930450f, 0.55246544f, 0.03523641f, 0.43461570f, 0.44482929f, -0.34863710f, 0.46261123f, 0.09513806f, 
    -0.24953009f, -0.06934026f, 0.34373155f, 0.54566985f, 0.26387328f, -0.09190860f, 0.39799348f, -0.25712264f, 
    -0.12039042f, -0.19179934f, 0.14775014f, -0.01830717f, -0.08281502f, 0.50190413f, -0.06225369f, 0.54584503f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.05408110f, -0.22058097f, -0.01729702f, -0.12914442f, -0.15950631f, 0.13798998f, -0.14203735f, -0.11514596f, 
    -0.10782088f, -0.17203543f, 0.05044675f, 0.52325636f, 0.06374288f, 0.09501337f, -0.09325458f, 0.04407908f, 
    0.19451913f, 0.05736952f, -0.39948946f, -0.50012106f, 0.55483258f, 0.15523174f, -0.16115367f, 0.15605853f, 
    0.05400259f, 0.00198010f, -0.03401925f, 0.04449508f, -0.22542387f, -0.05646267f, -0.24948305f, -0.16975148f, 
    0.21295673f, 0.11186132f, 0.00106740f, -0.18095343f, -0.00678736f, -0.20370233f, -0.12080155f, -0.21857451f, 
    0.00745161f, -0.20439288f, -0.17236829f, -0.06201563f, 0.17813985f, -0.19269568f, 0.12499336f, 0.25165254f, 
    0.12547237f, -0.02805201f, 0.15399417f, 0.23439030f, -0.00816512f, -0.20533442f, -0.21613708f, 0.16662084f, 
    0.26959962f, 0.00426235f, -0.03759403f, 0.08708828f, 0.10618863f, 0.13061579f, -0.03736461f, -0.26133302f, 
    -0.16149524f, 0.11444984f, -0.08231936f, -0.09256872f, -0.08408264f, 0.17601816f, 0.12562220f, 0.22377060f, 
    -0.03019308f, -0.18638696f, -0.05256537f, 0.08010697f, 0.12226310f, 0.08844224f, -0.07726901f, -0.11500391f, 
    0.29698476f, 0.20238499f, -0.07537843f, 0.28339815f, -0.09545354f, -0.04285333f, 0.34772220f, 0.09227207f, 
    0.22560368f, 0.02902032f, -0.44579601f, -0.21127264f, 0.16684449f, 0.08405132f, 0.04665059f, -0.15786545f, 
    -0.12040328f, -0.09025361f, -0.00631607f, 0.24336684f, -0.05624141f, -0.32194185f, -0.00700272f, 0.03856756f, 
    -0.02154090f, 0.02695526f, 0.17273650f, 0.13726893f, -0.13755293f, -0.44163319f, 0.25879174f, 0.15777577f, 
    -0.07636082f, -0.07333731f, 0.33213252f, -0.02118546f, -0.14647071f, -0.18048124f, -0.03250458f, -0.04790227f, 
    -0.06232277f, -0.22062160f, -0.01898816f, -0.12916544f, -0.13477421f, -0.14081250f, -0.13891855f, -0.15177408f, 
    0.07484921f, -0.00815555f, -0.00040418f, 0.19499306f, 0.08816206f, -0.00644878f, 0.10742886f, 0.00890840f, 
    0.10311036f, -0.00313643f, 0.03428481f, 0.14561979f, 0.12118451f, 0.34775051f, -0.00069532f, -0.44544113f, 
    -0.19153634f, 0.02322789f, 0.10389975f, 0.03960910f, 0.08528421f, -0.10403539f, 0.01345141f, 0.06914508f, 
    -0.11287352f, -0.36514607f, -0.34175485f, 0.16447149f, -0.28424340f, -0.19654118f, -0.16561939f, 0.26801196f, 
    -0.01214760f, -0.29453573f, -0.10491239f, -0.22224388f, 0.06151987f, -0.00345898f, -0.02269126f, -0.05672216f, 
    0.09262073f, 0.20105672f, 0.08461370f, -0.24935499f, -0.42039931f, -0.56782007f, 0.03768088f, 0.17679165f, 
    -0.13451867f, 0.10079022f, 0.03932396f, 0.16988866f, -0.10682682f, 0.07007749f, 0.01315464f, 0.03305368f, 
    -0.02808195f, 0.05345480f, -0.01112789f, 0.10440864f, -0.06125462f, -0.20934147f, -0.68058115f, -0.27057877f, 
    0.05434104f, 0.05525977f, 0.08154133f, 0.18376738f, -0.21613625f, -0.19882502f, -0.40850684f, -0.23440368f, 
    0.46973303f, -0.00006183f, 0.02448745f, -0.14575388f, 0.17137095f, -0.04252135f, 0.10251492f, -0.30170795f, 
    0.20423551f, 0.17220122f, -0.13090114f, -0.03482576f, -0.13966782f, -0.04552390f, 0.01846135f, 0.14229293f, 
    -0.03415415f, 0.18998492f, 0.37029907f, -0.08626012f, 0.04633183f, 0.11911794f, -0.06934524f, 0.04399976f, 
    0.00844258f, -0.06182586f, -0.11724699f, -0.05890850f, 0.11308639f, 0.10526504f, 0.08035587f, -0.13102266f, 
    0.09731051f, 0.01163618f, -0.97936267f, -0.35465941f, 0.47372493f, -0.06781413f, -0.02099011f, -0.13112800f, 
    -0.07910362f, 0.21090238f, 0.15492454f, 0.18171431f, -0.05347601f, 0.42495820f, -0.31221372f, 0.03654331f, 
    -0.08625888f, 0.11054162f, 0.13312931f, 0.02479394f, -0.14706516f, -0.00803189f, 0.10459518f, -0.17484373f, 
    -0.27095258f, -0.26244402f, 0.14486931f, 0.06442101f, 0.08363355f, -0.15130104f, -0.01323832f, 0.36897588f, 
    -0.05309340f, 0.08501403f, -0.18998389f, -0.13902164f, -0.21919869f, 0.25470933f, -0.35455894f, -0.08810211f, 
    -0.27235720f, -0.19755329f, -0.01032008f, 0.20837644f, 0.18499078f, 0.07367769f, 0.12225824f, 0.15541950f, 
    0.00624500f, 0.24309945f, 0.04282762f, 0.20686445f, 0.08262334f, -0.00679756f, 0.10691503f, -0.24800785f, 
    -0.05905227f, 0.20504044f, 0.35928741f, -0.06531847f, -0.16674289f, 0.06371417f, 0.18230833f, -0.17388518f, 
    0.16934295f, -0.08472338f, 0.31667039f, 0.27095428f, -0.05917895f, -0.29622617f, -0.01571829f, -0.18819010f, 
    0.09548791f, 0.01202745f, 0.12207460f, -0.51430845f, 0.19461104f, -0.11881043f, 0.22777069f, 0.03053434f, 
    0.01027766f, -0.03175115f, -0.00313422f, -0.03988446f, 0.00085512f, 0.03675927f, 0.01828331f, 0.15106387f, 
    0.05901659f, 0.19471583f, 0.10451958f, 0.07099785f, 0.40238634f, 0.34229925f, -0.20207098f, -0.07279804f, 
    -0.01202292f, 0.02828314f, -0.08953187f, 0.01754359f, 0.09242621f, -0.06263766f, -0.07225454f, -0.02375494f, 
    0.20406739f, 0.21810752f, -0.01199127f, 0.00637119f, 0.22940217f, 0.19995999f, -0.37890723f, -0.07433636f, 
    -0.01873176f, 0.02474037f, 0.29079020f, -0.15139891f, -0.04504027f, 0.10628667f, 0.06279082f, 0.01086434f, 
    -0.01676841f, 0.02317400f, 0.09248493f, 0.11747414f, 0.02232752f, -0.07604958f, -0.02997867f, -0.01795119f, 
    -0.09048185f, 0.19964087f, -0.01157312f, 0.16360618f, 0.01756470f, 0.05646292f, 0.00942648f, -0.18172823f, 
    -0.19942719f, -0.03419586f, -0.00435749f, 0.05287335f, 0.18624252f, 0.07754038f, 0.10469143f, -0.12187806f, 
    0.17394412f, -0.04891370f, 0.24686167f, -0.03763030f, -0.23373736f, 0.12207005f, 0.14275685f, -0.02542236f, 
    -0.14699404f, -0.01117185f, -0.04043597f, 0.03467194f, -0.54364181f, -0.17137469f, -0.11250746f, 0.03635743f, 
    0.23454338f, 0.06908427f, -0.09720761f, 0.06747966f, 0.24877942f, 0.13411005f, 0.13834286f, 0.15449169f, 
    0.13524435f, 0.03129325f, 0.19861381f, 0.35802880f, 0.24637823f, 0.19514588f, -0.04703955f, 0.11630904f, 
    -0.16468117f, -0.09868053f, -0.09341541f, 0.04341256f, -0.11677006f, 0.11946377f, 0.07096639f, 0.07278464f, 
    0.10125973f, 0.01290783f, -0.13794449f, 0.17343293f, 0.04057244f, 0.07790642f, -0.11251074f, -0.11634360f, 
    0.04059863f, -0.08892250f, 0.05247801f, -0.09528726f, 0.05356061f, -0.04941020f, -0.02201509f, 0.22002947f, 
    0.02556321f, -0.31164843f, -0.42367479f, 0.15417671f, 0.10323075f, -0.09094892f, -0.04706076f, -0.29348639f, 
    -0.17360768f, -0.35349828f, 0.23673996f, -0.00116786f, 0.06925467f, 0.02128938f, -0.11212429f, 0.06885091f, 
    0.00771614f, 0.13543516f, 0.00539617f, -0.51024544f, -0.29304653f, -0.07115965f, -0.02900864f, 0.09416658f, 
    -0.04546194f, -0.14852941f, -0.05945401f, 0.32422131f, -0.08288144f, 0.08445261f, 0.12902798f, 0.14637637f, 
    -0.00440276f, -0.04770850f, 0.22878158f, -0.11021889f, -0.31337517f, -0.17053241f, 0.01254565f, -0.16950908f, 
    0.08859416f, 0.04025041f, 0.02394244f, 0.00212044f, 0.04710144f, -0.16068403f, -0.10132045f, 0.13137475f, 
    0.13167493f, 0.25592297f, -0.10068850f, 0.08452494f, 0.19056627f, 0.10643379f, 0.00351472f, -0.14370400f, 
    0.26429397f, 0.22465429f, 0.03542431f, 0.14665382f, 0.16717523f, 0.07109442f, 0.11371132f, -0.05450113f, 
    -0.18391572f, -0.22945020f, -0.11957292f, -0.22558147f, -0.19430865f, -0.01691905f, -0.05697345f, -0.12131908f, 
    -0.80044371f, -0.04423446f, -0.10083836f, 0.06236534f, -0.18002743f, -0.08187508f, 0.08387684f, -0.07879599f, 
    -0.05068591f, -0.51422161f, -0.13241218f, 0.09138858f, -0.12422687f, 0.09222192f, 0.12559129f, -0.12195389f, 
    -0.15158078f, -0.03681880f, 0.14876062f, 0.60717094f, -0.13701627f, 0.03688665f, -0.03724475f, 0.55686009f, 
    0.07418598f, 0.07922036f, -0.14039783f, -0.39911178f, -0.12449421f, 0.21763800f, 0.08200842f, -0.39097431f, 
    0.03412339f, -0.21828613f, -0.17633237f, 0.07610286f, 0.20452803f, 0.04196723f, -0.04145835f, 0.01674458f, 
    0.02225311f, 0.02012830f, 0.01314714f, 0.07472599f, -0.07914808f, 0.25095621f, 0.10001995f, 0.26250467f, 
    -0.01647767f, 0.06977561f, 0.33492926f, 0.07186456f, 0.00365381f, 0.00423580f, -0.12820281f, -0.19600773f, 
    -0.06133955f, 0.11822505f, 0.14820294f, 0.06479962f, -0.15049557f, -0.41372535f, -0.20395125f, -0.07868645f, 
    0.07322045f, 0.10135039f, 0.15307987f, 0.34289664f, 0.18428153f, 0.11253198f, 0.14760323f, 0.16722845f, 
    0.22266015f, 0.18322670f, 0.11770365f, -0.05517277f, -0.09356079f, -0.20675050f, 0.05240771f, 0.19898590f, 
    -0.07708979f, 0.57626289f, -0.15507866f, -0.87361217f, 0.02311571f, -0.00004260f, -0.00224132f, 0.08701750f, 
    -0.07851837f, -0.00064734f, -0.23272799f, 0.02172441f, -0.24620342f, 0.00917052f, -0.04832941f, -0.01460273f, 
    0.11246888f, -0.02087119f, -0.09527384f, 0.07915812f, 0.13059781f, -0.06511097f, -0.02068154f, 0.09105043f, 
    -0.10908253f, 0.03486997f, 0.02171541f, 0.17126660f, 0.08564947f, -0.11329460f, 0.12524541f, 0.01536741f, 
    0.18093303f, -0.06517876f, -0.02228916f, -0.12242682f, -0.03909351f, 0.06563587f, -0.61431623f, -0.16110690f, 
    -0.05799266f, -0.08082419f, 0.04598999f, 0.07239587f, -0.05843103f, 0.08479271f, 0.12179412f, -0.35725674f, 
    -0.34479272f, -0.03951950f, -0.08488310f, -0.19187063f, 0.07904313f, 0.17045622f, 0.39861754f, 0.02833453f, 
    0.04325190f, 0.07061324f, 0.09365895f, 0.03148282f, 0.14151172f, 0.19021410f, 0.04866590f, 0.06346081f, 
    0.25890788f, -0.12655464f, -0.23660183f, 0.04115556f, 0.04879173f, 0.14779742f, 0.12375887f, -0.07532673f, 
    0.04708445f, 0.21997724f, 0.18597281f, -0.02773847f, -0.25504252f, -0.12712803f, -0.28291410f, 0.14889328f, 
    -0.02421817f, -0.06646422f, -0.66873455f, -0.43250859f, -0.09399596f, -0.05009672f, 0.06910793f, 0.27183363f, 
    0.21785118f, 0.13793258f, 0.03137479f, -0.29308602f, -0.23993613f, -0.08351383f, -0.01984484f, 0.17398046f, 
    0.09284286f, 0.08120246f, 0.01677879f, 0.02638034f, 0.04961639f, 0.05695635f, 0.20696232f, 0.00564096f, 
    0.11310568f, 0.07947856f, -0.04558895f, -0.15150936f, 0.21048909f, 0.08103151f, -0.11746897f, -0.05589153f, 
    -0.00250619f, 0.00523760f, -0.28294241f, 0.11571112f, -0.01625534f, 0.03742081f, 0.05603860f, 0.11034533f, 
    -0.03104095f, 0.02674133f, -0.03475471f, 0.11203679f, 0.21578516f, -0.03500778f, -0.05717198f, -0.04553673f, 
    0.10592477f, 0.03270263f, -0.07830613f, 0.06345320f, 0.17022651f, -0.00201008f, 0.32528144f, 0.15801124f, 
    -0.25564665f, -0.50931931f, -0.67363107f, -0.00948515f, -0.02590963f, -0.00018387f, 0.08549444f, -0.20705844f, 
    -0.02024989f, 0.09659843f, 0.02466599f, -0.12690029f, -0.31068009f, 0.10276385f, -0.11737446f, -0.03074247f, 
    0.10778319f, 0.19022264f, -1.25580645f, -0.41411275f, 0.22872706f, -0.01925143f, 0.13930722f, 0.16383140f, 
    0.01125585f, -0.19450358f, -0.01049509f, -0.04152435f, 0.17793982f, -0.03839399f, 0.07010452f, -0.12642267f, 
    0.35505486f, 0.05059427f, -0.07295383f, -0.00515502f, 0.76136434f, 0.20390670f, -0.90755564f, -0.06737974f, 
    -0.06390984f, -0.21230023f, -0.07779746f, 0.01002147f, -0.15777965f, 0.04726092f, -0.10084473f, -0.09132069f, 
    -0.17381459f, 0.12921543f, -0.22788396f, 0.07361779f, -0.01163905f, 0.10518219f, -0.18015130f, 0.30876759f, 
    0.72683775f, 0.09278266f, 0.03446536f, 0.25207627f, 0.28340459f, 0.11172602f, 0.03638313f, -0.04842610f, 
    0.35689104f, -0.48233739f, -0.07026967f, -0.11590303f, 0.04393993f, 0.01431786f, -0.17442913f, -0.09955739f, 
    -0.67865980f, -0.63047600f, -0.40637073f, -0.12956706f, -0.05849862f, -0.02343055f, 0.04725439f, -0.11678559f, 
    -0.07245778f, 0.02648099f, 0.40905258f, -0.10233553f, 0.03159450f, -0.04274483f, 0.03479781f, 0.11817186f, 
    0.09543769f, -0.08627317f, -0.09735307f, -0.68956143f, -0.12194504f, 0.01711423f, 0.25635281f, -0.07438783f, 
    0.09052177f, 0.17074788f, -0.06708866f, 0.29912695f, 0.27560484f, 0.10548259f, -0.26559514f, 0.05639109f, 
    -0.09154838f, 0.13884337f, -0.05497587f, 0.12548903f, 0.00495072f, -0.02047059f, -0.14281252f, -0.08215398f, 
    -0.10999706f, -0.12473677f, 0.16577938f, -0.13410471f, -0.05362999f, 0.29643750f, -0.00172808f, 0.21273407f, 
    0.00334003f, -0.15569209f, -0.07401361f, 0.08880880f, 0.09597683f, -0.06919899f, 0.00215425f, -0.17045966f, 
    0.19972563f, -0.00149606f, 0.26900136f, 0.23490083f, -0.05540712f, 0.03581990f, 0.05114801f, -0.01391140f, 
    0.01770363f, -0.18111075f, -0.00548566f, 0.10005657f, -0.06357583f, -0.04154249f, 0.14578371f, 0.19595085f, 
    -0.29570770f, -0.00478106f, -0.09094227f, -0.05807668f, 0.06303629f, 0.04611718f, -0.12725952f, 0.15805908f, 
    0.02478641f, 0.41552755f, 0.38022655f, 0.06648690f, 0.16026725f, 0.03815043f, 0.07287844f, -0.03015871f, 
    0.08593307f, -0.12748902f, -0.36487138f, -0.12240565f, -0.20261717f, -0.46418697f, -0.34143278f, -0.02667002f, 
    0.04875011f, 0.13450833f, 0.17863791f, -0.41144961f, -0.40396670f, -0.25843614f, 0.08579423f, -0.01014705f, 
    -0.04516307f, 0.00495336f, -0.01874655f, 0.02186638f, -0.21714160f, 0.02436807f, -0.12843160f, -0.27382603f, 
    -0.25038207f, -0.15509386f, 0.07581805f, 0.10371954f, -0.00384228f, 0.39580384f, 0.32034642f, 0.09420672f, 
    -0.06300841f, 0.22505568f, -0.14267051f, 0.00888085f, -0.07428045f, -0.36711279f, 0.35001659f, 0.32917616f, 
    0.01583445f, -0.17168172f, 0.15771718f, 0.05885029f, 0.07711542f, 0.01976910f, -0.23360351f, -0.07168360f, 
    -0.11357942f, -0.01264522f, -0.03070084f, -0.02558709f, 0.15543911f, -0.13970269f, -0.02905889f, 0.07653338f, 
    0.01386781f, -0.11817710f, 0.06340212f, 0.12554815f, 0.17379218f, 0.04189268f, 0.09540185f, -0.00836005f, 
    0.09987657f, -0.33710638f, -0.17009762f, -0.07851554f, 0.03244993f, 0.03370479f, 0.02584434f, -0.06955024f, 
    0.02470695f, -0.04021730f, 0.05951616f, 0.12277566f, -0.08538572f, -0.21343905f, 0.14689019f, -0.03849082f, 
    0.11590929f, 0.19149834f, 0.02794842f, -0.65485555f, -0.12633976f, -0.17395398f, -0.35072064f, -0.57323742f, 
    -0.21621160f, -0.00286696f, 0.01511522f, 0.09787685f, -0.15953618f, 0.26309428f, -0.16159764f, 0.05355341f, 
    0.00087937f, -0.19896534f, -0.10127015f, 0.01546941f, -0.05943576f, -0.21528853f, -0.09069154f, 0.05966002f, 
    0.05450764f, 0.01257351f, 0.12535091f, -0.02855341f, 0.16190208f, 0.14376867f, -0.21900019f, -0.08341385f, 
    -0.12713122f, -0.02995124f, -0.06925926f, 0.14859147f, -0.01107701f, 0.01115040f, -0.08415275f, -0.06435528f, 
    0.23199965f, 0.18549855f, 0.06939542f, -0.01781999f, -0.11831430f, 0.06876217f, -0.06171977f, -0.05855545f, 
    0.07993321f, 0.00134402f, 0.20178975f, 0.12949146f, -0.26762769f, 0.00240100f, 0.15362516f, -0.01676426f, 
    0.19919486f, 0.13176163f, 0.25263295f, 0.27938646f, 0.05271599f, -0.04759110f, 0.05306799f, -0.08259399f, 
    0.09313001f, -0.41179910f, -0.16650777f, -0.07395170f, 0.03394427f, -0.32908788f, -0.05696302f, -0.06607632f, 
    -0.04365596f, 0.07360167f, 0.16648898f, -0.50858718f, -0.38705891f, -0.21338893f, -0.16022557f, -0.13926196f, 
    -0.11583597f, 0.00011913f, 0.02343792f, -0.09157729f, 0.47447643f, 0.32617655f, -0.01023920f, -0.06201683f, 
    0.10866019f, 0.00289149f, 0.03912754f, 0.01873550f, -0.10992341f, 0.27982321f, 0.27172369f, -0.06459245f, 
    -0.11749066f, 0.08265337f, -0.08292967f, 0.04758410f, 0.10098170f, -0.15621017f, -0.28309354f, -0.21410243f, 
    -0.12483028f, -0.09167977f, -0.05214188f, -0.02624104f, -0.29992351f, -0.06402126f, 0.01881475f, 0.37659186f, 
    0.12101538f, 0.13834545f, 0.12523073f, 0.09346846f, 0.01009790f, 0.13417527f, 0.02071458f, 0.10002621f, 
    0.09439621f, 0.04916901f, 0.21652316f, -0.23864082f, -0.04031068f, -0.35328895f, -0.00858526f, -0.02836340f, 
    0.02227558f, -0.02277933f, 0.16009665f, -0.17059785f, 0.07857444f, 0.32305083f, 0.16086023f, 0.15514742f, 
    0.07364277f, 0.15366685f, -0.75194460f, 0.43827209f, 0.20609103f, -0.29577640f, 0.14755356f, -0.04060766f, 
    0.27662608f, 0.05902725f, 0.00096665f, -0.43594947f, -0.31272206f, -0.08635186f, 0.21519102f, 0.08064827f, 
    -0.00615074f, -0.21565409f, 0.00025329f, 0.04368417f, -0.06442175f, -0.08494168f, -0.04681893f, -0.00424596f, 
    0.03728233f, 0.12417462f, 0.06285269f, 0.11292671f, 0.22854489f, -0.22376281f, -0.17763555f, 0.09174816f, 
    0.00117044f, -0.07325184f, -0.06252167f, -0.06220729f, -0.01583380f, 0.20146684f, -0.04799527f, 0.11370840f, 
    0.11443703f, 0.00015042f, 0.11108232f, 0.17033784f, -0.10282547f, 0.15656663f, 0.13667166f, -0.01479731f, 
    -0.10119104f, -0.12152705f, -0.11272741f, -0.07129829f, -0.12948333f, 0.02057543f, -0.03753336f, -0.12777418f, 
    0.03444514f, 0.03555260f, -0.04477332f, 0.03223341f, 0.05132668f, 0.00392786f, 0.01536711f, 0.00291119f, 
    0.01562820f, -0.03496598f, -0.02842551f, 0.01367878f, -0.01348741f, -0.06819089f, 0.01966553f, 0.02871354f, 
    0.02370102f, 0.01741867f, -0.06425390f, -0.03990857f, 0.04630016f, 0.03473749f, -0.06311192f, 0.01062902f, 
    -0.05730512f, 0.03391742f, -0.01780727f, 0.00132943f, -0.05333057f, 0.04450110f, -0.02381126f, -0.02380494f, 
    0.04637468f, -0.05500731f, 0.00678090f, 0.03812176f, -0.06516240f, -0.03544395f, -0.02612934f, -0.00407956f, 
    -0.02358386f, 0.01681196f, 0.03781615f, 0.03403073f, 0.04017107f, 0.00696723f, 0.04475909f, 0.00669599f, 
    0.01918928f, -0.02223724f, 0.04248457f, -0.03481691f, 0.02344851f, 0.03818652f, 0.03461774f, -0.02362864f, 
    0.00961213f, 0.03901727f, 0.03039412f, -0.07188561f, -0.00849363f, -0.02070343f, -0.00932382f, -0.00478965f, 
    -0.05459249f, -0.04893440f, 0.00638137f, -0.03509275f, 0.02098263f, -0.01958550f, -0.01360108f, -0.06036099f, 
    -0.04622317f, -0.05385714f, -0.01608147f, -0.01825266f, 0.03517154f, 0.03818229f, 0.03819128f, -0.05514904f, 
    -0.01908533f, -0.02162492f, -0.05972784f, -0.05897813f, -0.03493205f, 0.03031586f, 0.02591930f, -0.03804991f, 
    -0.06525477f, -0.05931719f, -0.02142817f, -0.01218689f, -0.03014535f, 0.03507946f, 0.03448290f, -0.05610549f, 
    -0.05053334f, 0.00787426f, -0.01266102f, -0.05031382f, -0.05783278f, -0.04895451f, 0.04163143f, -0.02748936f, 
    0.03959824f, -0.04264913f, 0.02313014f, 0.03821722f, -0.00937365f, -0.06317937f, 0.02617140f, 0.02434005f, 
    0.01099488f, -0.03680095f, 0.00158825f, -0.05049737f, 0.02997282f, 0.00059203f, 0.01839470f, -0.03904299f, 
    -0.00850346f, -0.01080730f, -0.01991508f, -0.00368836f, 0.03595407f, -0.03479747f, -0.03662680f, -0.00540240f, 
    -0.00211529f, 0.03101861f, 0.03263969f, 0.03915986f, -0.07222439f, -0.01618807f, 0.04605735f, -0.01399474f, 
    0.03400918f, 0.02617662f, -0.07132181f, 0.00301162f, -0.04428681f, 0.03343586f, -0.06727295f, -0.02382234f, 
    0.04086028f, -0.03507701f, 0.01761167f, -0.03512166f, -0.05326042f, 0.01287426f, 0.00311545f, 0.02280243f, 
    -0.06385490f, 0.00311131f, 0.00973409f, -0.05462389f, -0.01310856f, 0.01888330f, -0.03543764f, 0.01605720f, 
    -0.00790329f, -0.00644989f, 0.00800224f, 0.03732625f, 0.02997197f, -0.00440802f, -0.06373577f, 0.00992042f, 
    0.03921815f, -0.06493782f, 0.04117811f, -0.05113815f, -0.00798737f, -0.04280381f, 0.00029708f, -0.04092505f, 
    -0.04533790f, -0.05556492f, -0.05149456f, 0.02407021f, 0.00343386f, -0.01381028f, -0.00162275f, 0.01933908f, 
    0.02805949f, -0.04761641f, -0.03686806f, 0.00973410f, 0.01549617f, -0.04104248f, -0.03973171f, 0.01303643f, 
    0.03066445f, -0.06069496f, -0.03223659f, -0.05874757f, -0.04818811f, -0.05234335f, -0.03151402f, -0.04294337f, 
    -0.04804876f, 0.01691830f, 0.01623847f, -0.05418175f, 0.01154963f, -0.00312977f, 0.01877389f, 0.00354277f, 
    0.02556600f, -0.04060258f, 0.00054869f, -0.01096619f, -0.06684326f, -0.05086025f, 0.01533008f, 0.02095281f, 
    0.03796276f, 0.03240431f, -0.00683671f, -0.06007003f, -0.00137364f, -0.03189374f, 0.00830868f, -0.00816065f, 
    -0.06374884f, 0.04331380f, -0.01406527f, -0.04895798f, 0.01694220f, -0.02428575f, 0.02399643f, 0.00106105f, 
    -0.04228082f, 0.02650441f, 0.01921910f, 0.04152099f, -0.00716079f, -0.06158609f, 0.02573357f, -0.04199607f, 
    -0.02053088f, -0.02429988f, -0.03345926f, 0.03714146f, -0.04665232f, 0.02860431f, -0.01883177f, -0.02450787f, 
    -0.04862674f, -0.01612908f, -0.05296937f, -0.05418871f, -0.02816238f, 0.04954338f, -0.04462773f, 0.05564353f, 
    0.04845647f, -0.02374932f, -0.04718558f, 0.02531225f, -0.01096485f, 0.03611823f, 0.01296344f, 0.02783252f, 
    0.01680922f, -0.05574907f, -0.04462448f, -0.01083589f, 0.00296362f, 0.01497230f, -0.03645009f, -0.03076687f, 
    -0.06397577f, 0.02038919f, 0.00191852f, -0.04669711f, -0.00638498f, -0.02270051f, -0.05706958f, -0.03216048f, 
    -0.00201459f, 0.01534622f, -0.03780574f, 0.03254949f, 0.04461876f, 0.04864636f, -0.04089285f, -0.02778662f, 
    -0.07151481f, 0.02804095f, -0.16933858f, 0.05864010f, 0.10151956f, -0.19307226f, 0.06261309f, 0.14843681f, 
    -0.06546437f, -0.48350534f, -0.17171858f, -0.14726394f, 0.13089046f, 0.25759324f, 0.34368226f, -0.30174419f, 
    -0.04399730f, -0.04971769f, 0.32725394f, -0.03066479f, 0.36859545f, -0.03334056f, -0.13315688f, -0.15804763f, 
    0.07616920f, 0.00445207f, 0.00127581f, -0.00473370f, 0.14617541f, -0.06406582f, 0.05325222f, -0.07981057f, 
    -0.09667971f, 0.00588885f, 0.08962167f, -0.05875920f, -0.16632904f, 0.04608881f, -0.29136541f, 0.27404889f, 
    0.04978345f, -0.24050194f, -0.05245794f, 0.07402989f, 0.07741430f, 0.00601107f, 0.04217251f, 0.08907754f, 
    0.01641309f, 0.07679970f, 0.10344376f, -0.14582321f, 0.02965841f, 0.21039337f, 0.06784566f, 0.10984372f, 
    0.20665747f, 0.01999062f, 0.03132603f, 0.11215752f, 0.00447897f, 0.03979836f, 0.15129414f, -0.07049134f, 
    0.00702213f, -0.17005953f, -0.20724443f, -0.10327032f, -0.24200691f, -0.12418021f, 0.04495746f, -0.09055496f, 
    -0.22325008f, -0.10163306f, -0.20555836f, 0.07504081f, -0.03865995f, -0.17661078f, 0.11979255f, 0.05455047f, 
    -0.00413061f, 0.22938721f, 0.04841375f, -0.27228782f, 0.09285019f, 0.13014695f, 0.14943199f, 0.09720689f, 
    -0.20252703f, -0.05151692f, 0.12483832f, -0.37599289f, -0.29851168f, 0.05775033f, -0.01792682f, -0.06428162f, 
    -0.00593624f, 0.16525118f, -0.04618364f, 0.02702578f, -0.11784895f, 0.37602574f, 0.08093649f, 0.06868522f, 
    0.01002442f, -0.12682189f, 0.09359677f, 0.10043275f, 0.05363305f, 0.18850562f, 0.02646796f, -0.05686600f, 
    0.05610878f, 0.07429299f, 0.04126104f, 0.19387315f, 0.02265050f, -0.06063615f, 0.15036513f, -0.17047103f, 
    -0.25936377f, -0.11967552f, -0.25520754f, -0.20418273f, 0.10447767f, -0.05417802f, -0.01104479f, 0.05973475f, 
    -0.13563295f, 0.04365490f, -0.15094928f, -0.25308791f, 0.12995602f, 0.02639399f, 0.01190205f, 0.26200002f, 
    0.05161503f, 0.18113443f, -0.19897889f, 0.06557713f, -0.04190432f, 0.16718765f, 0.16425478f, 0.16959874f, 
    -0.27858758f, -0.14145713f, 0.27553377f, -0.08109343f, 0.07424694f, 0.02451878f, 0.08688550f, 0.09240650f, 
    0.04624728f, -0.22953737f, 0.02798981f, -0.26587257f, 0.19267924f, 0.41862208f, 0.38238642f, -0.04242272f, 
    0.03016625f, -0.05696104f, 0.02988055f, 0.17776386f, 0.28295794f, 0.14763142f, -0.16136357f, -0.11158120f, 
    0.00439740f, 0.09659481f, 0.01753983f, 0.06108295f, 0.00184079f, 0.45793781f, -0.13974904f, 0.05020678f, 
    -0.11687095f, -0.11409345f, 0.13337764f, -0.02802938f, -0.24189347f, 0.02274573f, 0.04067596f, -0.01009039f, 
    0.03843876f, 0.15035290f, -0.09591123f, 0.07709850f, 0.06124438f, -0.04307984f, 0.46969154f, 0.35135522f, 
    0.09935317f, -0.17758168f, 0.08892747f, 0.13791543f, 0.16942081f, 0.06651610f, -0.07212672f, 0.00876107f, 
    0.02003098f, -0.01748790f, 0.17676753f, -0.05873305f, 0.22091790f, 0.06280211f, -0.11697014f, 0.03178632f, 
    -0.06876692f, 0.03714576f, 0.23199977f, 0.03542319f, 0.07109259f, 0.04651859f, 0.19149703f, 0.04381510f, 
    0.01473894f, -0.12504421f, 0.09412607f, 0.05390792f, 0.00468246f, -0.02129593f, 0.15859149f, 0.14970057f, 
    0.17922676f, 0.05141266f, -0.29621449f, -0.47236183f, 0.02022715f, 0.00186690f, -0.13626453f, 0.14543910f, 
    -0.07073801f, -0.18872465f, 0.84599686f, -0.17293037f, -0.15332745f, 0.01408086f, 0.02465102f, -0.12529355f, 
    0.16886802f, -0.04356074f, -0.07918528f, 0.17150335f, -0.13457005f, -0.17096686f, 0.12438805f, 0.26409611f, 
    0.06896971f, -0.03643868f, -0.04403044f, -0.00381144f, 0.11250555f, -0.00126282f, -0.12331966f, -0.18970329f, 
    -0.19731382f, -0.24937403f, 0.08830633f, 0.07679920f, 0.04793369f, -0.23540989f, 0.09709942f, -0.19978294f, 
    -0.17806531f, -0.06417960f, -0.24494770f, 0.20661700f, 0.11683277f, 0.13940877f, -0.24856184f, -0.21759281f, 
    -0.42049429f, 0.01136092f, -0.12357203f, -0.30068216f, -0.03715184f, -0.00348594f, -0.07501610f, 0.02781831f, 
    0.17689501f, 0.33317634f, -0.00375136f, -0.17115907f, -0.07340939f, 0.06625423f, 0.25186205f, 0.16749117f, 
    -0.39085019f, -0.05213327f, 0.01201003f, -0.01649079f, -0.17511991f, -0.26909548f, -0.17708607f, -0.19034705f, 
    -0.10472026f, 0.32882375f, -0.13746649f, 0.73141140f, 0.02759006f, 0.01596347f, -0.30736253f, -0.09358115f, 
    0.13569863f, 0.07992176f, -0.23674971f, -0.03771494f, 0.70099795f, 0.13533685f, 0.08271466f, -0.21770085f, 
    -0.25807396f, 0.03080120f, 0.14790617f, -0.22482361f, -0.37124765f, -0.12212218f, -0.02421232f, -0.14826846f, 
    0.00631617f, -0.01228689f, -0.06797315f, -0.07022268f, -0.37518471f, -0.45213673f, 0.62228012f, -0.06368972f, 
    0.16671658f, -0.22181965f, -0.08744292f, 0.05078727f, 0.21083686f, 0.13895345f, -0.14655064f, 0.19397138f, 
    0.03311033f, -0.05917864f, -0.05309232f, 0.16188489f, 0.01596283f, 0.00387505f, 0.35296291f, 0.12160522f, 
    0.18130355f, 0.03840354f, -0.03080261f, -0.01560186f, 0.01629145f, 0.02380040f, 0.08390348f, -0.07927220f, 
    -0.13567342f, -0.09244269f, -0.13080551f, -0.06513884f, -0.13308145f, 0.01834832f, -0.00573244f, 0.10676007f, 
    0.19053775f, 0.12357263f, 0.00061575f, -0.05609877f, -0.00657801f, -0.08867018f, 0.17268951f, -0.02407330f, 
    0.17872851f, 0.18901074f, -0.14151247f, 0.07476669f, -0.21629858f, 0.03985641f, -0.01349812f, -0.14927368f, 
    0.03306032f, -0.12679027f, 0.03876442f, 0.00962168f, -0.05117695f, 0.02803002f, -0.04953798f, -0.17474763f, 
    -0.21848990f, -0.08077801f, 0.01105072f, -0.20551279f, 0.06082371f, 0.26326284f, 0.03203029f, 0.12742466f, 
    -0.04374916f, -0.16036446f, -0.29647046f, 0.05230598f, 0.17510265f, -0.43261266f, 0.24749319f, -0.08707329f, 
    0.11920469f, -0.25544581f, 0.18133277f, -0.16535753f, -0.17392975f, -0.23738131f, -0.34838408f, -0.05098048f, 
    0.41860646f, 0.07722130f, -0.21594730f, -0.07338960f, -0.20543320f, -0.00496742f, 0.06166703f, -0.19388402f, 
    -0.29264730f, -0.00392807f, -0.04893360f, -0.00512172f, -0.07075719f, 0.21286166f, -0.05190597f, 0.05645045f, 
    0.07900301f, -0.10861979f, 0.17482871f, 0.11193094f, 0.21529739f, 0.15201387f, -0.00539569f, -0.10137282f, 
    0.09897638f, 0.42912114f, 0.28689235f, 0.32365662f, 0.03204225f, -0.04407078f, -0.00336151f, 0.01999117f, 
    0.11708684f, -0.10605419f, -0.25413674f, -0.01184024f, -0.06124406f, -0.14206797f, -0.09177905f, -0.16547114f, 
    0.06501189f, 0.23301488f, 0.01914058f, 0.15075088f, 0.17765936f, -0.01631509f, 0.18779591f, 0.04312309f, 
    -0.11652312f, -0.17809165f, 0.01983823f, -0.94009858f, 0.16898789f, -0.41433585f, 0.17316099f, -0.19690190f, 
    -0.11389360f, -0.00612099f, 0.30442098f, 0.14519918f, 0.25765967f, -0.03828065f, -0.01547834f, 0.06081016f, 
    -0.08409716f, -0.05528046f, 0.05098854f, -0.00759465f, 0.12256315f, 0.37822574f, -0.10977049f, -0.27872050f, 
    0.06971908f, 0.11611018f, -0.09163622f, 0.10050003f, -0.05508356f, -0.16070443f, -0.38533491f, -0.60999775f, 
    0.78945863f, -0.26567420f, -0.07635508f, -0.26470512f, 0.00080881f, 0.21223848f, 0.04230166f, 0.15030706f, 
    0.31487066f, 0.51069796f, 0.04344157f, -0.01785312f, -0.05353452f, -0.03859066f, 0.06888677f, 0.20380174f, 
    0.09646256f, 0.46574992f, 0.63138443f, 0.01669052f, 0.05713378f, 0.07706268f, -0.03387537f, -0.07932424f, 
    0.06014898f, 0.54988837f, 0.27384168f, 0.28233966f, -0.12277181f, 0.11005051f, -0.08195872f, 0.14488783f, 
    0.25448182f, -0.01834875f, 0.46119344f, -0.21766880f, 0.06718977f, -0.09373267f, -0.27025247f, -0.31500599f, 
    -0.31344318f, 0.23092912f, 0.11063433f, 0.13759668f, -0.07975185f, 0.40044004f, -0.17709038f, -0.00542822f, 
    -0.08011825f, -0.02236145f, 0.07143846f, 0.20511496f, 0.26940107f, -0.05804023f, -0.11063614f, -0.01816270f, 
    -0.16645464f, -0.10351723f, 0.09012165f, 0.09375300f, 0.06424895f, -0.28504434f, 0.02140140f, -0.16483785f, 
    -0.08764205f, 0.01608521f, -0.31685135f, 0.01469633f, 0.13946879f, 0.13797608f, 0.53635633f, 0.20612483f, 
    -0.08550026f, 0.00502608f, 0.22084409f, -0.05498572f, -0.01915576f, 0.12657726f, 0.13852707f, 0.03762880f, 
    -0.03696837f, -0.08347828f, 0.03450952f, 0.02971609f, 0.11799137f, 0.03626651f, -0.10519341f, -0.18329132f, 
    -0.02679976f, 0.01406259f, 0.04293951f, -0.01876255f, 0.02579106f, 0.03277878f, 0.02658535f, 0.01862104f, 
    -0.00725878f, 0.01764812f, -0.05313127f, -0.02985648f, 0.02647610f, -0.04933196f, -0.00161577f, -0.04457987f, 
    -0.02553402f, -0.05328485f, 0.00568328f, 0.02166482f, 0.04858971f, 0.04274656f, -0.02636279f, 0.05036598f, 
    -0.02357910f, 0.03011762f, -0.05835178f, -0.00778071f, 0.01082812f, -0.02556432f, 0.03370705f, 0.02048879f, 
    -0.02481663f, -0.01406407f, -0.02017956f, -0.02802742f, -0.02630763f, 0.00945537f, 0.02453609f, 0.02315776f, 
    0.02693750f, 0.02366847f, -0.05363639f, -0.00295126f, 0.00650030f, 0.04087536f, -0.02190681f, 0.01660100f, 
    0.01657571f, -0.00923175f, 0.02912967f, -0.03810203f, -0.05413753f, -0.03781628f, -0.06441218f, -0.00901340f, 
    -0.04636965f, 0.04166061f, -0.04833243f, -0.04515822f, 0.01856378f, -0.00525761f, 0.03849620f, 0.03697835f, 
    0.03115710f, 0.04185294f, -0.05547773f, -0.04654959f, -0.02986452f, 0.02604566f, -0.05505976f, -0.04861658f, 
    0.03413852f, 0.03957358f, 0.03676667f, -0.04189687f, 0.03047866f, 0.04390211f, 0.00040270f, 0.02111865f, 
    0.04652199f, 0.00443574f, -0.02917081f, 0.01242968f, -0.04999539f, -0.05886829f, 0.03184051f, -0.02439873f, 
    0.00738516f, -0.03466863f, 0.01520210f, -0.04911280f, 0.03916870f, -0.00340071f, 0.03074829f, 0.04055630f, 
    -0.00041077f, 0.04127865f, 0.01898269f, 0.02197171f, 0.03206503f, -0.05228647f, -0.01002646f, -0.03867731f, 
    -0.05183560f, -0.05332178f, -0.04741995f, -0.02210893f, -0.05787672f, -0.02636729f, 0.02434079f, -0.04481579f, 
    0.00599616f, -0.05278790f, 0.04215346f, -0.05675112f, -0.01309387f, 0.00967501f, -0.03188492f, 0.02370482f, 
    0.00595777f, -0.04796421f, 0.00433905f, -0.04236934f, -0.04506354f, -0.03156951f, -0.05962184f, -0.02511784f, 
    -0.04620257f, -0.05175835f, 0.00364248f, 0.02598801f, 0.02903335f, -0.03153607f, 0.04848338f, -0.01914012f, 
    -0.03957060f, 0.04257919f, -0.04547383f, 0.04585322f, -0.01948952f, -0.05475903f, -0.00315072f, 0.03800664f, 
    0.02075139f, -0.06483228f, -0.03639625f, -0.00658875f, -0.05893414f, -0.05554248f, 0.04038736f, 0.02280324f, 
    0.04997452f, -0.00368049f, -0.01333058f, -0.02718699f, -0.03028871f, 0.05213446f, 0.04241238f, -0.04100815f, 
    -0.04004025f, -0.02529082f, 0.01264875f, -0.05753185f, 0.01793674f, -0.06101157f, -0.05573682f, 0.04790187f, 
    0.02280068f, 0.05754935f, 0.04313385f, -0.04133021f, 0.01194479f, -0.02741984f, 0.03766835f, -0.02255444f, 
    -0.01104273f, 0.03566618f, -0.06375178f, 0.04574668f, -0.04504379f, 0.02722131f, -0.06253034f, -0.03576874f, 
    0.00526828f, 0.05541556f, -0.02403387f, -0.05744931f, 0.04017556f, 0.05007870f, 0.00516816f, 0.03889398f, 
    -0.04278323f, -0.03908146f, 0.01611999f, -0.03973088f, -0.04345426f, -0.03172369f, 0.01277286f, 0.05016812f, 
    -0.03319700f, -0.03305884f, 0.00691580f, -0.04230917f, -0.00217216f, 0.04481313f, 0.01809924f, 0.01889810f, 
    0.04104016f, -0.02194795f, -0.05257806f, -0.04091031f, 0.01653773f, 0.03500512f, -0.03289222f, -0.03598494f, 
    -0.05188406f, -0.00457791f, -0.03429736f, 0.00552773f, -0.01670888f, -0.01279644f, -0.00876114f, -0.03262363f, 
    -0.04594639f, -0.04061361f, 0.03670332f, 0.03968634f, 0.02829557f, -0.05372183f, -0.06181387f, -0.01476336f, 
    -0.05047108f, -0.04024913f, -0.05175952f, -0.03153531f, 0.01771577f, -0.02205159f, -0.03792240f, -0.00970045f, 
    -0.01599928f, -0.05721282f, 0.03164707f, -0.04650733f, 0.00501113f, 0.00652544f, -0.04046437f, 0.01434870f, 
    0.03789979f, 0.04640781f, -0.03795046f, -0.01573504f, -0.02182302f, -0.05735330f, -0.00021729f, -0.01299220f, 
    0.00928834f, -0.04165285f, -0.03001722f, 0.03622878f, -0.00406207f, -0.05645109f, 0.02820814f, -0.02238731f, 
    0.02469692f, 0.01036191f, -0.01096240f, 0.01679084f, -0.02049780f, 0.03654251f, -0.04790527f, -0.00729841f, 
    0.02762052f, -0.02312294f, -0.03728915f, 0.05270153f, -0.05438980f, 0.02091770f, -0.02789499f, 0.03562485f, 
    -0.02191465f, -0.02465827f, 0.00165408f, -0.04941689f, 0.02782909f, -0.05350451f, -0.02103517f, 0.03668175f, 
    0.09082718f, 0.15218441f, 0.05708357f, -0.01699543f, 0.07799916f, -0.14031644f, -0.20004356f, 0.00171667f, 
    -0.03446809f, 0.47931609f, 0.13376658f, -0.49637398f, 0.13319878f, 0.04578114f, -0.05562741f, -0.13813192f, 
    -0.02351635f, -0.00244638f, 0.00336827f, -0.09710842f, -0.00121520f, -0.04007892f, 0.11568363f, 0.19071396f, 
    -0.18588299f, 0.34785166f, 0.15319724f, 0.05873911f, -0.04721417f, -0.01959848f, 0.07602448f, 0.07234953f, 
    0.02463052f, -0.15895630f, -0.22173335f, -0.32132542f, 0.14649507f, 0.06426570f, -0.01035501f, 0.04395941f, 
    -0.02684562f, 0.03451934f, -0.22706084f, -0.14896573f, -0.24412967f, 0.03946922f, 0.09718151f, -0.01124305f, 
    0.02801759f, 0.13129292f, 0.07272451f, -0.02255049f, -0.20766243f, -0.19178869f, 0.44878122f, 0.36445004f, 
    0.17258753f, 0.10011500f, 0.13569501f, 0.08493419f, 0.21707296f, -0.06625234f, -0.00858060f, -0.01541722f, 
    0.11229464f, 0.12701358f, -0.04703590f, -0.01074049f, 0.01620593f, -0.00438525f, 0.18028286f, 0.11232195f, 
    -0.02333244f, 0.07244794f, 0.02190582f, -0.20103662f, 0.02905436f, -0.05382208f, 0.05048873f, 0.04316993f, 
    0.12829143f, 0.05388579f, -0.04041668f, 0.08703844f, 0.22832347f, -0.02645744f, -0.04199155f, -0.07664144f, 
    -0.06411160f, -0.03079157f, 0.12167262f, -0.15661795f, 0.28681475f, -0.03255062f, 0.20811424f, 0.00784139f, 
    0.09208504f, -0.04617267f, 0.16947073f, -0.04677554f, 0.09788674f, -0.46527922f, -0.04185558f, 0.07740949f, 
    0.05510511f, -0.00113302f, 0.10317373f, -0.21925290f, -0.26074138f, -0.08663447f, -0.00052958f, 0.17809962f, 
    -0.00982297f, 0.11283990f, -0.17760000f, -0.11122208f, -0.38813815f, 0.28854036f, 0.18039890f, 0.09586461f, 
    0.09785300f, 0.05564035f, 0.03529833f, -0.10989884f, -0.15681556f, -0.44374996f, 0.15174605f, 0.12537979f, 
    0.03634327f, 0.01340986f, 0.03106354f, 0.05837233f, -0.00721951f, -0.32084280f, 0.13438931f, 0.06128946f, 
    0.06660673f, 0.06546781f, -0.04564111f, 0.03932699f, 0.14771454f, -0.22709630f, -0.21998356f, -0.13801187f, 
    0.23487747f, 0.02281521f, 0.05677047f, 0.11179084f, 0.35445806f, 0.04044108f, 0.15103902f, 0.07821078f, 
    0.07413463f, 0.13793950f, -0.13825351f, -0.14386600f, 0.22977689f, 0.18287794f, -0.07537016f, -0.34547001f, 
    -0.38909051f, -0.36780491f, 0.00328526f, 0.00676543f, 0.09643124f, -0.03272486f, 0.00057925f, 0.00425538f, 
    0.07860626f, 0.07899415f, 0.03185140f, -0.03851138f, 0.17920634f, 0.13952810f, -0.12449093f, 0.24777532f, 
    0.03821152f, 0.10674360f, -0.48552874f, 0.09324377f, 0.33652213f, 0.33849895f, 0.01122835f, 0.15159072f, 
    0.00279821f, 0.02939102f, 0.12031122f, 0.04132454f, -0.04294498f, -0.22726978f, -0.06566663f, -0.09545566f, 
    0.09728246f, 0.00935782f, 0.06998745f, -0.36227974f, -0.25278765f, -0.36114645f, -0.07376268f, 0.38843465f, 
    0.21427585f, 0.04598270f, -0.05008113f, 0.09312443f, -0.04592168f, 0.06171131f, 0.04726470f, 0.35578704f, 
    0.49558583f, -0.06131072f, -0.03449585f, -0.04622044f, 0.13644926f, 0.12128397f, 0.01590439f, 0.02692487f, 
    0.10432737f, 0.36064866f, 0.26271290f, 0.08582795f, -0.01511644f, 0.12094695f, 0.08041667f, -0.00762851f, 
    -0.04028451f, -0.10274071f, 0.22246553f, 0.19811454f, 0.27416962f, -0.23824029f, 0.15480596f, -0.02573883f, 
    0.14002070f, -0.00876678f, -0.69861042f, 0.16362166f, 0.41294599f, 0.06899702f, -0.24674229f, 0.13410151f, 
    -0.03729243f, -0.42879555f, 0.08360806f, 0.17539626f, 0.05608765f, -0.16853170f, 0.11610015f, 0.03357483f, 
    0.32644862f, 0.01228629f, 0.15396418f, -0.00846359f, 0.24656542f, 0.18929087f, 0.02266434f, -0.05600452f, 
    -0.19316271f, -0.01727360f, -0.05380053f, -0.24460691f, -0.12015414f, 0.13236909f, 0.10853967f, 0.01846619f, 
    -0.00200658f, 0.01330212f, -0.13058007f, -0.34594297f, 0.03203743f, -0.05411716f, -0.19785412f, 0.20363744f, 
    0.12696144f, -0.25940213f, 0.15601332f, 0.17065433f, 0.04938070f, 0.20818044f, 0.11131497f, 0.15437505f, 
    -0.05288129f, -0.17427941f, 0.02305362f, -0.10177181f, 0.03588681f, -0.42886108f, -0.10004114f, -0.25139531f, 
    0.02063328f, -0.02255282f, -0.05965927f, -0.02613924f, -0.04670969f, -0.02720513f, -0.02955050f, 0.02731050f, 
    -0.06572676f, -0.09156846f, -0.04014092f, -0.01765324f, -0.01318263f, -0.00893515f, -0.00642249f, -0.04187305f, 
    0.01403202f, -0.01775950f, 0.02446175f, 0.00949294f, -0.01845663f, -0.05681681f, -0.02595641f, -0.03809794f, 
    0.06809864f, 0.01091718f, -0.07311559f, -0.07021892f, 0.03117895f, -0.03228146f, 0.04423226f, -0.06777392f, 
    -0.06130851f, -0.08155603f, -0.05548343f, -0.06810764f, -0.01828310f, -0.06636095f, -0.05487322f, -0.04103201f, 
    -0.04720988f, -0.01147437f, -0.04329215f, -0.02455703f, -0.00817856f, -0.00252271f, 0.02324802f, -0.07001147f, 
    0.02812609f, 0.02374991f, -0.03448877f, -0.01999947f, 0.02443301f, -0.02524111f, -0.00365769f, 0.00918724f, 
    -0.05744265f, 0.00004104f, 0.00838754f, -0.05817686f, 0.00933103f, -0.03822706f, -0.00411982f, 0.00955865f, 
    -0.04812723f, -0.04080914f, -0.08667290f, 0.01553204f, 0.01515072f, -0.01709955f, -0.08282316f, -0.06557047f, 
    0.00352323f, 0.02016250f, 0.01537132f, -0.09363274f, 0.00352002f, -0.08286567f, 0.02243413f, -0.01493612f, 
    -0.01453898f, 0.00859982f, -0.08395009f, -0.04036942f, -0.04807166f, -0.00700073f, -0.04216126f, 0.03037908f, 
    -0.08697775f, -0.00252293f, 0.03778495f, -0.04089847f, -0.07562850f, -0.05785507f, -0.03315773f, 0.00930480f, 
    -0.03640476f, -0.00607569f, 0.01243832f, -0.01885576f, 0.02533076f, -0.02128438f, 0.01128783f, 0.02944773f, 
    -0.05614562f, -0.05231397f, -0.02540668f, -0.05597505f, -0.06180365f, 0.00477700f, -0.02998528f, -0.07339726f, 
    -0.03904271f, -0.02152902f, -0.05984811f, -0.02023468f, 0.01561594f, 0.02173407f, -0.00116187f, -0.07115766f, 
    -0.02975451f, -0.01309288f, -0.06569301f, 0.01647689f, 0.01695914f, 0.04088240f, 0.01019244f, 0.01481036f, 
    -0.04144092f, 0.01431519f, -0.06760281f, 0.01454321f, -0.07399058f, -0.05959331f, -0.04197083f, -0.01723250f, 
    -0.01193259f, 0.04173188f, 0.01598981f, -0.04168834f, -0.06561030f, -0.05545321f, -0.00453602f, 0.00980916f, 
    -0.02218061f, -0.06796709f, -0.03340311f, -0.00983929f, -0.06524841f, 0.01105004f, 0.07555753f, 0.03026399f, 
    -0.01592512f, 0.03478357f, -0.01053527f, 0.00679328f, -0.07154857f, 0.03394926f, -0.00224231f, -0.04227922f, 
    0.01205023f, -0.04242310f, 0.02588164f, -0.01051392f, -0.03817333f, 0.02985960f, 0.02425574f, -0.01059254f, 
    0.00620657f, -0.01003508f, -0.05160623f, -0.01605276f, -0.00725984f, 0.02704616f, -0.03628973f, -0.06007455f, 
    0.00267478f, -0.05205889f, -0.01033863f, -0.07686782f, -0.07150873f, -0.04441737f, 0.02263401f, -0.02114130f, 
    0.00677788f, -0.04479192f, 0.06041969f, 0.03317730f, -0.06804547f, -0.00959517f, -0.03930787f, 0.00083407f, 
    0.00259165f, -0.03800141f, -0.03798673f, -0.05324277f, -0.08498607f, -0.00722437f, -0.04299786f, 0.02276953f, 
    0.02611436f, -0.05920625f, -0.05477867f, 0.01127750f, 0.01597538f, -0.06960378f, -0.08861802f, -0.02685638f, 
    -0.05050023f, -0.06309105f, 0.00754550f, -0.08111873f, -0.01231218f, 0.00314436f, 0.02324176f, 0.00029606f, 
    0.00870945f, 0.00441108f, -0.00821269f, -0.01238571f, -0.05169638f, -0.03212085f, 0.03482246f, 0.01718154f, 
    -0.05127615f, -0.09816793f, 0.02197834f, 0.03510114f, -0.02476187f, -0.02127912f, -0.02169155f, -0.00075147f, 
    0.02660483f, -0.00236937f, 0.02102400f, -0.03089377f, 0.01530572f, 0.03893729f, 0.03302146f, -0.08001769f, 
    0.03647996f, -0.08016860f, -0.05484988f, -0.09001370f, 0.01214127f, -0.04690041f, -0.04974768f, 0.01627631f, 
    0.02894508f, 0.00779942f, 0.04934525f, -0.01523634f, -0.00170235f, -0.00606019f, -0.04319138f, -0.02817257f, 
    -0.00500194f, -0.04458430f, -0.01304179f, -0.01702470f, 0.02945887f, -0.01321385f, 0.00336543f, -0.05197078f, 
    -0.02975068f, -0.00777015f, -0.06388794f, -0.04448359f, -0.03064173f, -0.04859227f, -0.00104054f, -0.00175122f, 
    0.00258804f, -0.08233970f, -0.05836528f, -0.00471125f, -0.05103147f, -0.01037272f, -0.01266050f, 0.01979326f, 
    -0.00239679f, 0.00698099f, -0.01268925f, 0.01278843f, 0.02720359f, 0.03320916f, 0.00186700f, -0.00750758f, 
    -0.02042106f, -0.06448364f, 0.16994274f, 0.09911221f, 0.06083463f, 0.03249091f, 0.01053544f, 0.02184200f, 
    0.09228392f, -0.34033316f, 0.03692521f, 0.13866353f, -0.01388068f, 0.18078722f, -0.03485741f, -0.08570988f, 
    -0.23277749f, -0.20109555f, -0.07005762f, -0.64198583f, 0.44388053f, 0.11669747f, 0.21657228f, 0.35802612f, 
    -0.06982137f, 0.01729576f, 0.02491212f, -0.17176537f, 0.00811242f, 0.20629527f, -0.01226602f, 0.00917191f, 
    -0.05680592f, 0.12541670f, 0.03939345f, -0.06619943f, 0.05856624f, 0.00866263f, 0.19451998f, 0.04061932f, 
    0.36138710f, -0.05512861f, 0.07792890f, 0.17713925f, 0.19823325f, -0.05386288f, 0.09950601f, 0.35081300f, 
    -0.04474891f, 0.15930746f, -0.01811792f, -0.05607356f, -0.14586276f, -0.15400845f, -0.03855602f, -0.08775729f, 
    -0.02466331f, 0.00567185f, -0.01799353f, -0.17467089f, 0.04969722f, -0.05296130f, 0.15007573f, -0.03029445f, 
    0.00059180f, 0.04385275f, 0.08429280f, 0.10477791f, 0.07715131f, 0.01179390f, 0.34034798f, 0.01118695f, 
    -0.11715106f, 0.00179469f, -0.00754232f, -0.06143431f, 0.00209811f, -0.09030379f, 0.17629316f, 0.14849509f, 
    -0.06286017f, -0.00653918f, -0.16655819f, -0.09554625f, 0.19053110f, 0.15542309f, 0.12081056f, 0.06100801f, 
    0.15013425f, 0.15907294f, 0.13082296f, 0.09461085f, 0.09067953f, -0.14496832f, 0.26284117f, -0.15031375f, 
    0.16746762f, 0.09756405f, 0.19918796f, -0.38067201f, -0.22034791f, -0.04049573f, 0.15200113f, 0.02012919f, 
    -0.07630792f, 0.01574405f, 0.04439487f, -0.08102425f, -0.24238464f, 0.06861418f, 0.27441856f, 0.23507337f, 
    0.06305873f, 0.03724044f, 0.07949691f, 0.08593088f, -0.00439371f, -0.05349953f, -0.09955767f, 0.01773797f, 
    0.04996109f, 0.01025742f, -0.01389170f, -0.11324872f, -0.00302285f, -0.03624936f, -0.00537340f, 0.04210354f, 
    0.18469313f, 0.02252546f, 0.06589375f, 0.12848751f, -0.08270474f, 0.18900768f, 0.09386043f, -0.22237197f, 
    -0.05337716f, -0.03601984f, -0.05483305f, -0.18013702f, -0.14616938f, 0.10048410f, -0.08242725f, -0.20341675f, 
    -0.15936427f, -0.29272312f, -0.11817603f, 0.21689484f, -0.01468122f, -0.05861739f, 0.28728476f, 0.02857120f, 
    0.13855578f, -0.13340265f, -0.20212004f, -0.27891731f, 0.07393172f, 0.00818782f, -0.21148105f, -0.48867613f, 
    -0.46346122f, -0.62786579f, 0.04651673f, -0.14076938f, -0.10046841f, 0.29693857f, 0.15270072f, 0.01148337f, 
    0.20252797f, 0.30362886f, 0.27011299f, 0.10579655f, 0.08151805f, 0.00808720f, 0.21834964f, 0.27189153f, 
    0.03211397f, -0.03930699f, 0.08001897f, 0.15862395f, 0.00459095f, -0.14577685f, -0.18778244f, -0.11640494f, 
    -0.10032177f, 0.00863197f, -0.07436001f, 0.05181307f, -0.04909343f, -0.13104460f, 0.11265475f, 0.10509047f, 
    0.06863018f, -0.05140886f, -0.10116957f, -0.01402840f, -0.15348519f, -0.31283632f, -0.04667784f, -0.02870996f, 
    0.16572990f, 0.11461633f, -0.02817562f, 0.19753233f, 0.15645447f, 0.34160724f, 0.31224263f, -0.18571992f, 
    -0.23622756f, -0.11154039f, -0.05818701f, -0.11411416f, -0.26541439f, 0.05265969f, 0.10370837f, 0.09692901f, 
    -0.13175695f, -0.13527094f, -0.08056944f, -0.04184565f, 0.07955915f, -0.05648950f, 0.14256085f, 0.10388396f, 
    0.11755731f, 0.20444591f, 0.03077141f, -0.00816880f, -0.20384276f, 0.12199040f, 0.14471729f, -0.50239187f, 
    0.26476753f, 0.01879899f, 0.33295321f, -0.00240183f, 0.41697457f, 0.19299103f, -0.11266710f, -0.00216589f, 
    0.07072181f, 0.22037791f, 0.08761753f, -0.23979147f, -0.21751270f, -0.03192335f, 0.20466144f, 0.25353923f, 
    0.14153348f, -0.05993853f, -0.01234945f, -0.00159329f, 0.03129883f, -0.08446979f, 0.09432110f, 0.04912613f, 
    0.05596199f, 0.00587741f, -0.11093220f, 0.02331556f, -0.01406015f, 0.14229901f, 0.00100839f, 0.14208274f, 
    0.07668647f, 0.03324985f, 0.17005001f, -0.15492652f, 0.00857096f, 0.38084525f, -0.18458746f, 0.10731505f, 
    -0.00413644f, -0.00834487f, -0.07158010f, 0.08128631f, 0.17598355f, 0.20861492f, 0.08115099f, -0.01403267f, 
    0.19004980f, 0.15278170f, -0.05697596f, -0.08310204f, -0.10543413f, 0.12121712f, -0.03500491f, -0.11947168f, 
    -0.10757829f, 0.05795097f, 0.10013540f, 0.08050099f, -0.00884485f, 0.00016680f, -0.00484624f, 0.09370685f, 
    -0.29395533f, 0.03024098f, -0.14080149f, -0.28971064f, -0.15230687f, -0.22188887f, -0.11657900f, 0.04349544f, 
    0.05537304f, 0.04334896f, 0.12528974f, 0.29050440f, -0.07196975f, -0.01965319f, -0.04790003f, -0.05708995f, 
    0.05061819f, 0.08952533f, 0.11797771f, -0.27670282f, 0.02326370f, 0.06482272f, 0.01830204f, 0.01706691f, 
    0.05951630f, -0.07478896f, -0.07110160f, 0.04572611f, -0.01735717f, 0.02354933f, 0.14326441f, 0.01777524f, 
    0.01049608f, -0.00280428f, 0.06805642f, 0.34779423f, 0.15166734f, 0.39908966f, 0.05381573f, -0.24868058f, 
    0.02304139f, -0.14404123f, 0.01267504f, -0.13550282f, -0.03329994f, -0.27054316f, 0.32964274f, 0.07968387f, 
    -0.29855758f, 0.05185694f, -0.03547377f, 0.00994258f, -0.10417092f, 0.02862167f, -0.11247593f, 0.02891268f, 
    0.02389407f, -0.01935698f, 0.12564361f, -0.11481322f, 0.04723800f, 0.08882576f, 0.08251145f, 0.15641043f, 
    -0.02484408f, -0.08265069f, -0.11371367f, -0.01567485f, -0.03707349f, 0.08155498f, 0.20333365f, 0.07501743f, 
    0.14004436f, -0.00989289f, -0.03379245f, 0.11130147f, 0.06053148f, 0.05846592f, -0.11597395f, 0.01145082f, 
    -0.05581357f, -0.04466024f, 0.00657187f, -0.12743770f, 0.00021324f, -0.06348673f, 0.08678066f, 0.20424736f, 
    0.16744378f, 0.13115358f, 0.45407709f, -0.11113324f, 0.06420521f, -0.10986819f, -0.13966745f, -0.10129968f, 
    -0.03409952f, 0.03455065f, 0.03106104f, -0.06930052f, 0.06733948f, 0.03060859f, 0.13898323f, 0.04694547f, 
    0.11175124f, 0.15434101f, -0.08230024f, 0.10832050f, -0.02315061f, -0.07931877f, -0.00786345f, 0.09021871f, 
    0.01718633f, 0.03277939f, -0.03067308f, -0.01833393f, -0.01422568f, -0.18081015f, 0.00352441f, 0.07822641f, 
    0.11928883f, -0.00727740f, 0.11148244f, -0.03502937f, -0.13585556f, 0.06733529f, -0.11632050f, -0.26650956f, 
    -0.05716211f, -0.09511673f, -0.10603927f, 0.03586242f, -0.01874280f, -0.32162610f, -0.08582195f, -0.08620398f, 
    0.34531567f, -0.16767949f, -0.31025735f, -0.09125765f, 0.11479329f, 0.01818861f, 0.12345751f, 0.03457363f, 
    0.26820332f, -0.24414840f, -0.31039104f, 0.02997755f, 0.03507934f, 0.08282251f, -0.19232535f, -0.08472443f, 
    -0.24486186f, -0.42653957f, 0.18150058f, -0.11557246f, -0.10622171f, -0.15852542f, 0.19922727f, 0.22119254f, 
    0.02760801f, 0.11750041f, 0.23264651f, -0.23101054f, 0.10554504f, 0.17878726f, -0.00426049f, 0.33660498f, 
    -0.01287560f, 0.14649545f, 0.02010266f, 0.11102518f, 0.15841030f, 0.14091727f, -0.43810779f, 0.03244073f, 
    -0.02791436f, 0.02993525f, 0.00590919f, 0.05423971f, -0.17029247f, 0.17615436f, -0.10282069f, -0.22956696f, 
    -0.05372807f, -0.04137720f, 0.08998810f, -0.20876648f, -0.02701891f, -0.12668681f, -0.09571305f, 0.26947847f, 
    -0.03358679f, 0.06695512f, 0.12540767f, -0.11372861f, 0.24177401f, 0.18920600f, 0.08677643f, 0.36965284f, 
    0.14068916f, -0.42940551f, -0.10348702f, 0.00046994f, -0.02056688f, 0.09470619f, 0.01173315f, 0.11204025f, 
    0.49501577f, 0.06951158f, -0.23315611f, 0.02226463f, 0.02650683f, -0.03846739f, 0.00155314f, 0.09775670f, 
    -0.01264722f, -0.05322796f, 0.08043882f, -0.06498770f, -0.02877633f, -0.09287398f, -0.14684497f, -0.04573026f, 
    0.07688191f, 0.08543698f, 0.30570766f, 0.51558268f, -0.05162012f, 0.01968742f, -0.01952924f, -0.05842374f, 
    0.20953837f, 0.09335374f, -0.06100491f, -0.16345939f, 0.02877024f, 0.10612115f, 0.07768718f, 0.13819531f, 
    -0.25697103f, -0.06657917f, 0.01292073f, 0.01360395f, -0.03948293f, 0.02244050f, 0.09584721f, 0.10960239f, 
    -0.00476054f, -0.05895690f, -0.14210781f, -0.11124179f, -0.00347790f, 0.06936889f, 0.12026800f, 0.15942702f, 
    0.08146038f, -0.00267134f, 0.00773212f, 0.00235634f, 0.02142033f, -0.03202511f, -0.04871465f, 0.15000999f, 
    0.03145692f, -0.09415642f, 0.04010288f, 0.18050776f, 0.07701933f, 0.13141537f, 0.11813472f, -0.03306977f, 
    0.09379999f, -0.27499557f, 0.11466755f, -0.01343840f, -0.04856170f, -0.22352695f, 0.04447115f, -0.00347060f, 
    0.04717287f, -0.06025314f, -0.20886873f, 0.04490547f, -0.08899082f, -0.12910230f, 0.12787694f, 0.13011943f, 
    0.02835515f, -0.64799601f, 0.26306608f, 0.27561414f, -0.08445237f, -0.01323953f, -0.23405679f, 0.03205964f, 
    0.03536315f, 0.06806368f, -0.18595245f, -0.32318363f, -0.35459864f, -0.04751398f, 0.04582004f, -0.26289159f, 
    -0.24911447f, 0.05679980f, -0.12958547f, -0.18306865f, -0.04008744f, 0.02716212f, 0.05645258f, -0.09194575f, 
    -0.03720153f, 0.00755098f, -0.02339683f, 0.13122746f, -0.15561102f, -0.42769569f, 0.09897225f, 0.09459890f, 
    0.03127129f, -0.03695784f, 0.07228930f, -0.30463380f, -0.07853562f, -0.21244848f, 0.04003245f, -0.02289779f, 
    0.00374940f, 0.08183328f, 0.09689058f, 0.12425952f, 0.09403290f, -0.02352308f, -0.32591420f, 0.11087028f, 
    -0.00240806f, -0.00721088f, -0.03685015f, 0.06237640f, 0.19174547f, 0.11526522f, -0.09124391f, -0.01512998f, 
    -0.04349349f, -0.08647784f, -0.00816346f, 0.05967971f, 0.32472336f, 0.22564891f, 0.17118324f, 0.02330953f, 
    0.15275726f, 0.18064855f, 0.00927969f, -0.01502995f, -0.25987250f, 0.12413798f, 0.13549720f, 0.15742640f, 
    0.19275810f, 0.00593384f, 0.20349704f, 0.11803915f, 0.00859473f, 0.07613970f, 0.16784367f, 0.08156295f, 
    0.14890230f, 0.20789403f, 0.01297561f, -0.47275200f, -0.36910179f, -0.12659104f, 0.07223001f, -0.09790739f, 
    -0.09015190f, -0.05271347f, -0.04890701f, 0.49604163f, -0.24795602f, 0.15594546f, 0.14286561f, 0.17029561f, 
    -0.09386895f, 0.09600230f, 0.17923325f, 0.13204801f, -0.37352496f, -0.19488977f, 0.23959693f, 0.03921349f, 
    0.01020073f, -0.04530816f, 0.20704365f, -0.06911118f, -0.00793303f, -0.14485933f, -0.05974775f, -0.08404126f, 
    -0.09285585f, -0.14519306f, -0.22786471f, 0.28473982f, -0.10848442f, 0.02349038f, 0.04821412f, -0.04773369f, 
    0.03742996f, 0.01591677f, 0.00297423f, 0.11420152f, 0.09421545f, 0.10444325f, 0.06349855f, 0.17093471f, 
    -0.24697500f, -0.21185857f, 0.01716128f, -0.06063388f, 0.00111873f, 0.19753437f, 0.15826169f, 0.11922852f, 
    -0.00171246f, 0.17412926f, 0.06886245f, -0.33156079f, -0.21742548f, -0.15609643f, -0.03663227f, 0.07817486f, 
    -0.07068004f, -0.14135726f, 0.01929099f, -0.02308156f, -0.23078625f, -0.17808229f, -0.25305489f, -0.04582493f, 
    0.10070798f, -0.01834072f, 0.22529130f, -0.08527189f, -0.09363838f, 0.17994907f, 0.11268233f, -0.07124876f, 
    0.20636868f, 0.03352456f, -0.05305664f, 0.11923314f, -0.15695603f, -0.28653246f, 0.06209034f, -0.01418842f, 
    0.13062635f, -0.00178187f, 0.22110569f, 0.09169389f, -0.15749943f, -0.00674505f, 0.28557101f, 0.07649353f, 
    0.09124098f, -0.00401910f, 0.02011853f, -0.07994498f, 0.08592242f, -0.62579805f, -0.29601526f, 0.05637223f, 
    0.04406900f, 0.00046154f, -0.16797970f, 0.00747161f, -0.17039981f, -0.03147157f, -0.23088719f, -0.01519557f, 
    -0.05432533f, 0.20691332f, 0.00551920f, 0.19167250f, 0.12039910f, 0.15067016f, -0.04334278f, -0.29166076f, 
    0.20435308f, 0.14062411f, -0.05064154f, -0.14283726f, -0.22956893f, 0.03194848f, -0.05393254f, 0.05517548f, 
    0.12491332f, 0.33235657f, 0.05023252f, 0.06986328f, -0.12857457f, -0.09076677f, 0.03627151f, -0.04923693f, 
    -0.03898588f, -0.23129658f, -0.45905462f, -0.06328312f, -0.10166252f, -0.13456613f, -0.11045213f, 0.02933360f, 
    0.12170266f, -0.12854631f, -0.15180984f, -0.52521056f, -0.67284352f, -0.22922792f, -0.01079262f, 0.21796480f, 
    -0.06965013f, 0.02690258f, 0.11127036f, -0.11047263f, 0.36195484f, 0.50368708f, -0.08750122f, -0.05735540f, 
    -0.27861080f, 0.11362436f, 0.17703958f, 0.20243125f, -0.07981416f, 0.02571724f, 0.13369513f, -0.09179251f, 
    -0.13383351f, 0.02534264f, 0.10726438f, -0.09150986f, -0.03109893f, -0.12087478f, 0.00990738f, -0.13714787f, 
    -0.03731637f, -0.03375589f, 0.08168460f, 0.42651364f, 0.06407820f, 0.10154201f, 0.03241439f, -0.23872018f, 
    -0.55023867f, -0.09950868f, -0.14346294f, -0.07790529f, 0.12327761f, 0.12461711f, -0.13636525f, 0.01571568f, 
    0.21725379f, 0.01567662f, 0.28815520f, 0.09163395f, 0.12199091f, -0.01474305f, 0.00834015f, 0.07650927f, 
    -0.06189455f, -0.09034304f, -0.19029507f, 0.01303273f, -0.42286253f, -0.19861364f, 0.25721207f, 0.09842327f, 
    0.10122269f, -0.20874405f, 0.19216064f, 0.12398811f, 0.02554270f, -0.04166356f, -0.18207322f, -0.07220108f, 
    -0.05498305f, -0.00647965f, -0.04295855f, -0.29954970f, 0.18806751f, -0.08397520f, 0.17254618f, 0.05533984f, 
    -0.01548107f, 0.02541235f, 0.24653356f, -0.13385504f, 0.05905503f, 0.06213858f, -0.01442123f, 0.13110183f, 
    0.04615862f, -0.03057946f, 0.10324530f, -0.27058980f, -0.32640788f, 0.03976280f, 0.01256071f, -0.17914529f, 
    0.16241364f, 0.01704676f, 0.21351954f, 0.31818515f, -0.14611082f, 0.02883930f, 0.15959720f, 0.17939384f, 
    0.09514566f, 0.06135718f, 0.10955644f, 0.05786895f, -0.02109709f, -0.15120523f, -0.20772037f, 0.06170956f, 
    0.10355386f, 0.04345219f, 0.03209967f, 0.13327172f, 0.15624872f, 0.06787074f, -0.40036640f, -0.16765131f, 
    -0.12511334f, -0.19737589f, -0.14679697f, 0.14662702f, -0.15387237f, 0.16889146f, 0.06297132f, 0.18440428f, 
    -0.18959455f, 0.07270876f, 0.46794996f, -0.04447754f, 0.17548415f, -0.02094465f, 0.09328175f, 0.13846636f, 
    0.22638361f, 0.07943223f, -0.12327789f, -0.28100234f, 0.14586215f, -0.01720346f, 0.08821155f, -0.08793817f, 
    0.08569714f, 0.06374208f, -0.08158123f, -0.21570751f, -0.08010904f, -0.21733890f, -0.00822531f, -0.01945137f, 
    0.17395678f, 0.24765371f, -0.14600311f, -0.28500679f, -0.15107416f, 0.27167138f, -0.03329176f, 0.16133150f, 
    0.11335812f, -0.08084197f, -0.25394964f, 0.08562460f, 0.31565991f, 0.28972739f, 0.17176136f, 0.27071258f, 
    -0.07836144f, 0.00856793f, 0.20203564f, -0.07808208f, 0.08754449f, -0.21253206f, -0.19721837f, -0.15425444f, 
    -0.11468701f, -0.25540113f, -0.00841445f, -0.02572824f, 0.11535696f, -0.33846551f, -0.25666475f, -0.37654817f, 
    -0.14583051f, -0.07389230f, 0.19671866f, -0.21572487f, -0.01496055f, 0.31937113f, 0.07065792f, 0.24756201f, 
    -0.08646346f, -0.07141998f, 0.04718217f, 0.09312113f, 0.07777274f, 0.07690645f, -0.15022583f, -0.19475070f, 
    -0.00387959f, 0.03671629f, 0.42667499f, -0.04453271f, -0.05073863f, -0.00399258f, 0.11551705f, 0.03740405f, 
    -0.03199803f, -0.18528965f, 0.18395956f, -0.22271106f, -0.22110237f, -0.17362845f, -0.23379953f, -0.16958629f, 
    -0.29641259f, -0.05563559f, 0.05521899f, 0.16796690f, 0.40466869f, 0.11613973f, -0.00949718f, 0.18322957f, 
    0.01130068f, 0.12065211f, 0.07858212f, 0.13891082f, -0.23248301f, -0.02688983f, -0.26473430f, -0.03597147f, 
    -0.18588416f, 0.11304519f, -0.10035462f, 0.30323362f, -0.28359106f, 0.02154669f, -0.24019769f, 0.08724875f, 
    0.07314315f, 0.13428546f, -0.03077150f, 0.03588354f, 0.06439193f, 0.16942878f, 0.29918933f, 0.21183954f, 
    -0.04421802f, 0.02068549f, -0.13319609f, -0.01652369f, -0.23783350f, -0.09891773f, -0.05015423f, -0.34343103f, 
    0.10410967f, 0.10769811f, 0.23188967f, -0.07155087f, 0.06300686f, -0.02935047f, 0.21719375f, -0.14888164f, 
    -0.11971963f, 0.27932465f, 0.16999874f, 0.12331512f, 0.16480698f, 0.01664653f, 0.11173873f, 0.19895910f, 
    -0.01712756f, -0.08731709f, 0.30216008f, 0.00895489f, 0.07229817f, 0.11540087f, 0.11220308f, -0.13662693f, 
    0.00879376f, 0.11206138f, -0.05427703f, -0.32423320f, 0.01385775f, -0.24762323f, 0.06111577f, -0.20193094f, 
    0.10794201f, 0.06127887f, 0.67689729f, -0.14926244f, -0.75901091f, -0.24103750f, -0.00748084f, -0.12719889f, 
    -0.06943782f, 0.01909563f, -0.21699941f, 0.04533270f, -0.01449331f, 0.09419744f, 0.05248960f, -0.05124833f, 
    0.03293211f, 0.00989740f, 0.14539279f, 0.04296042f, -0.23421292f, -0.23375510f, -0.18204726f, -0.30677810f, 
    -0.13497458f, -0.14338411f, 0.10801274f, 0.11551599f, -0.13263647f, -0.24271761f, -0.23662116f, -0.20854820f, 
    -0.03576755f, 0.04698082f, 0.21128045f, -0.06484874f, 0.14172901f, 0.16815028f, 0.06899249f, 0.17323105f, 
    0.12022512f, -0.05517327f, -0.17680439f, -0.04555238f, -0.01134905f, 0.02812420f, 0.13300116f, 0.09838809f, 
    0.09863847f, 0.15776636f, -0.05453810f, 0.20180742f, 0.18772931f, 0.22347295f, 0.11474210f, -0.33250856f, 
    0.08591647f, -0.04472250f, -0.00775833f, 0.03591214f, 0.08851162f, 0.05782127f, 0.04792707f, -0.08581036f, 
    -0.15077658f, 0.04878748f, 0.19656372f, 0.10486719f, 0.19362399f, -0.35782051f, -0.04467325f, -0.00223713f, 
    0.06121055f, 0.02481432f, -0.11495119f, -0.55676132f, 0.38789520f, 0.02846422f, 0.07042016f, -0.15898098f, 
    -0.08642378f, -0.02237424f, -0.12808812f, 0.09048308f, 0.25816095f, 0.20522244f, 0.06485328f, 0.09787855f, 
    0.01422812f, 0.04759188f, 0.15104827f, 0.06333227f, 0.03573636f, -0.04153545f, -0.08655587f, 0.04232730f, 
    0.02339851f, 0.12514909f, -0.06991115f, 0.02756473f, -0.10271895f, 0.00012714f, -0.18709362f, -0.33257148f, 
    0.20161167f, 0.05542043f, 0.17784302f, -0.07690500f, -0.06072008f, -0.13922715f, -0.02165715f, -0.05753247f, 
    -0.28751257f, -0.00097443f, -0.09125288f, 0.18942863f, -0.08379304f, 0.12961836f, -0.00153765f, 0.14894013f, 
    0.13013092f, -0.06385034f, 0.03377226f, 0.01927953f, 0.06517253f, -0.03516513f, -0.05811009f, -0.06557136f, 
    0.39015529f, 0.20889668f, -0.31570810f, -0.03448342f, 0.07181008f, 0.17056547f, 0.03878478f, 0.02051874f, 
    0.12360260f, 0.26818058f, 0.14920507f, 0.43853793f, -0.19432558f, -0.13567311f, 0.04839664f, 0.07752088f, 
    -0.01185176f, -0.01274895f, 0.03300830f, -0.20784418f, -0.06721678f, 0.02067453f, -0.01841022f, -0.05910053f, 
    -0.21784817f, -0.01454754f, -0.16862248f, 0.29268739f, -0.11074317f, 0.47811636f, 0.15046953f, 0.09265723f, 
    0.15666370f, 0.07823157f, -0.03396431f, 0.15918398f, -0.11046065f, 0.21028174f, 0.04039883f, 0.14988984f, 
    -0.04320810f, 0.00796953f, 0.17949058f, 0.02691833f, 0.03087397f, 0.16375944f, 0.05104945f, 0.12942816f, 
    0.12251437f, 0.03581625f, -0.08370092f, -0.05552078f, -0.01384536f, -0.12826416f, 0.04045301f, 0.06850555f, 
    0.11709686f, -0.00366979f, 0.05602165f, -0.15589593f, 0.02079099f, -0.01646162f, -0.02526049f, 0.29919481f, 
    -0.27818468f, -0.06222290f, -0.08950477f, -0.01977781f, -0.01708075f, 0.14123668f, 0.06623670f, 0.18182552f, 
    0.35489202f, 0.26088265f, -0.23544613f, -0.07653422f, -0.16763197f, -0.12428253f, 0.04511359f, -0.07573330f, 
    0.12446973f, 0.12956809f, 0.36183792f, 0.60372263f, -0.06030119f, -0.20456742f, -0.14910093f, 0.13107479f, 
    0.10738194f, 0.07621334f, 0.19153395f, -0.34461164f, -0.09202162f, 0.08742874f, 0.05267643f, -0.11875756f, 
    -0.12806632f, 0.06178261f, 0.03312393f, 0.36322629f, -0.11502399f, -0.50168163f, -0.07192312f, 0.13873409f, 
    -0.05287882f, 0.13083260f, -0.04837620f, -0.14037600f, 0.07608705f, 0.54844397f, 0.34359279f, 0.19885966f, 
    -0.08142146f, 0.05550027f, 0.02733818f, 0.03969181f, -0.07263473f, -0.43334851f, 0.12748723f, 0.01917165f, 
    0.15648152f, -0.14909321f, -0.08251330f, -0.04103869f, -0.00418836f, -0.04045175f, 0.12798145f, -0.04742580f, 
    -0.48992932f, 0.18144681f, 0.05868380f, 0.09745087f, -0.07723480f, -0.06321944f, -0.09147324f, -0.50169599f, 
    0.21904401f, -0.38288909f, -0.16395803f, -0.17534389f, -0.12772635f, -0.11687525f, 0.05185726f, 0.07207112f, 
    0.34543136f, 0.10059616f, -0.46077490f, -0.42156166f, -0.00814634f, -0.17741352f, 0.06591588f, -0.00764103f, 
    0.06093380f, -0.14793128f, 0.06857189f, 0.00744906f, -0.20480226f, -0.21975009f, -0.03168570f, -0.15790007f, 
    -0.12420715f, -0.28644100f, -1.37062252f, -0.47835833f, -0.05692279f, -0.10400230f, -0.15056171f, -0.22221994f, 
    0.20183404f, -0.12026454f, 0.04145706f, 0.10021956f, 0.12822218f, 0.01208067f, -0.20626359f, -0.39889473f, 
    -0.15503357f, 0.06826694f, 0.05924077f, -0.11114612f, 0.05517297f, 0.03078308f, 0.11271743f, 0.02253206f, 
    0.06924351f, -0.12064422f, 0.00843022f, -0.00896998f, -0.03305790f, 0.04418018f, 0.19978023f, 0.08452521f, 
    0.16818653f, -0.01643739f, -0.03068865f, 0.09071212f, 0.17752665f, -0.05626389f, 0.00064565f, -0.14503273f, 
    -0.11353064f, 0.01208969f, -0.00824392f, -0.12197398f, -0.08700894f, -0.14962041f, -0.04098418f, -0.01056247f, 
    0.03966933f, -0.08040769f, 0.20717750f, 0.15102535f, 0.15377450f, 0.06691351f, -0.07238053f, 0.06008948f, 
    -0.05486328f, 0.32074592f, 0.03953544f, -0.20055495f, 0.09737951f, -0.17032018f, -0.02153227f, -0.06111264f, 
    0.06658377f, -0.11002925f, -0.58154660f, -0.88977456f, -0.25783381f, -0.22805917f, 0.00007218f, -0.03493263f, 
    0.03517817f, -0.13960721f, 0.41413420f, 0.39450431f, 0.36766246f, -0.05903976f, -0.42799294f, -0.24425328f, 
    0.06950030f, 0.09725951f, 0.00684959f, 0.10960399f, 0.10868235f, 0.29850078f, -0.07451911f, -0.02133355f, 
    -0.16413112f, -0.00212601f, 0.01479073f, 0.16194658f, 0.13341565f, 0.35722023f, 0.11406969f, -0.08019722f, 
    -0.26660106f, -0.26780161f, 0.02101923f, -0.06671124f, 0.09329212f, -0.08277152f, -0.20892432f, -0.63952279f, 
    0.13303514f, 0.09943821f, 0.10623799f, 0.11208621f, -0.00391861f, -0.09195703f, 0.38361022f, -0.25654081f, 
    -0.76143563f, 0.06149910f, 0.06748351f, 0.29518327f, 0.20442855f, 0.03285096f, -0.00706821f, 0.08397072f, 
    0.19525981f, 0.08454624f, 0.10333857f, 0.14395081f, 0.00914625f, 0.09776926f, -0.02640047f, -0.06261699f, 
    -0.39623931f, -0.27346426f, -0.10630950f, 0.07078974f, 0.12087458f, 0.14256369f, -0.01232288f, 0.04551337f, 
    0.00340408f, 0.23591694f, -0.12628594f, -0.34629127f, 0.06184470f, -0.01768660f, 0.03097277f, 0.16289261f, 
    0.02886417f, -0.07752845f, 0.32304466f, 0.06476451f, 0.07482729f, 0.04199829f, 0.02048998f, -0.18696053f, 
    0.04233266f, -0.03254849f, 0.14616151f, 0.33904696f, 0.52293843f, 0.41623187f, -0.24776077f, -0.08948944f, 
    -0.13785309f, -0.00020511f, 0.11211200f, -0.07038514f, -0.40920991f, 0.11978724f, -0.17033975f, 0.04699096f, 
    0.00439710f, 0.06552351f, 0.06652245f, -0.01096427f, -0.05855621f, 0.16759057f, 0.37857851f, 0.10411742f, 
    -0.15694723f, -0.12662189f, -0.07211368f, 0.03372982f, -0.01114190f, 0.07040357f, 0.33865052f, 0.17405127f, 
    0.07055407f, 0.08496512f, 0.05414855f, -0.00551503f, 0.03085386f, -0.04002328f, -0.17029986f, -0.08410825f, 
    0.09218094f, 0.30488500f, 0.00593498f, 0.05302014f, -0.10486217f, 0.02367650f, 0.00912121f, 0.14960374f, 
    -0.40957564f, -0.22992623f, 0.08688094f, -0.19539461f, 0.08158042f, -0.04850723f, 0.00489884f, 0.15152185f, 
    0.06028841f, -0.28155819f, -0.52676594f, -0.44838044f, -0.17273124f, -0.09157984f, -0.28162235f, -0.03085513f, 
    -0.15813613f, -0.06021086f, -0.08021221f, 0.42787763f, 0.14539911f, 0.02700601f, 0.13124987f, -0.01508262f, 
    0.07852083f, 0.06708289f, -0.01571744f, -0.05537959f, 0.19273697f, 0.22380863f, -0.01540647f, 0.17424387f, 
    0.16890068f, 0.07411946f, 0.21795233f, 0.04978315f, 0.22533973f, -0.66514391f, -0.57636255f, 0.03580945f, 
    -0.07540625f, 0.33349189f, 0.07045591f, -0.05674217f, -0.12191553f, -0.47629127f, 0.26096117f, -0.30214804f, 
    -0.04142663f, -0.20102242f, 0.08276204f, 0.09111565f, 0.08883744f, 0.03674043f, -0.03455593f, 0.33996671f, 
    0.11442330f, 0.13418804f, 0.15731189f, -0.14547850f, 0.13077676f, -0.13908939f, -0.10428464f, -0.32935524f, 
    -0.32292882f, -0.03573504f, -0.17508410f, 0.04246651f, 0.09332463f, -0.02893981f, -0.07251608f, 0.04366243f, 
    -0.29148081f, -0.41046503f, -0.06617512f, -0.30659416f, 0.03385329f, -0.08758738f, 0.06371549f, 0.01692889f, 
    0.08224541f, -0.11001947f, -0.69466335f, -0.35595158f, -0.17196241f, -0.05808238f, 0.13872840f, 0.11767343f, 
    0.00679042f, 0.01323167f, -0.03020937f, -0.23893234f, 0.36529958f, 0.22140318f, -0.03619393f, -0.02128182f, 
    -0.07473191f, -0.08527867f, 0.22497867f, 0.00948884f, -0.35316613f, -0.63537157f, -0.07780590f, -0.04115991f, 
    -0.19679539f, 0.20744006f, 0.07782162f, 0.11962166f, 0.30228871f, 0.27248955f, 0.09254383f, 0.07126997f, 
    -0.03423720f, 0.00407994f, -0.05008270f, -0.01037341f, 0.14041470f, 0.02049899f, 0.44919857f, 0.04521260f, 
    0.02684024f, 0.09169702f, -0.18749677f, -0.03286018f, -0.04478168f, 0.19081165f, -0.11364034f, -0.13039269f, 
    0.07001465f, -0.14463650f, 0.09891701f, -0.09290612f, 0.15082310f, 0.16145158f, -0.08937797f, 0.23789808f, 
    0.09762560f, 0.20416586f, 0.16782703f, -0.00730438f, -0.10706327f, 0.05171705f, -0.03176288f, 0.02564204f, 
    0.00236452f, -0.02066563f, -0.04747676f, 0.04162008f, 0.04446963f, 0.03773511f, -0.00090175f, -0.01379400f, 
    -0.03994077f, 0.00120984f, 0.03017085f, -0.03875000f, 0.03605978f, 0.00183636f, 0.03306082f, -0.00036197f, 
    0.02936246f, -0.00902491f, 0.00932647f, -0.03043634f, -0.05589239f, -0.05809013f, 0.04473690f, -0.00204688f, 
    0.02282612f, 0.00422337f, -0.01149165f, 0.00889914f, -0.03309031f, 0.02581554f, 0.01304736f, -0.04886013f, 
    -0.02932614f, -0.06596467f, 0.01288720f, 0.03387888f, -0.07318549f, -0.03767586f, -0.06461431f, 0.00011695f, 
    0.02378821f, -0.02944765f, -0.06117741f, 0.04463504f, -0.04961275f, -0.05724167f, 0.04518932f, -0.02701844f, 
    0.04140395f, 0.03345330f, -0.03887341f, -0.00729535f, -0.04918129f, 0.03402346f, -0.06027580f, -0.00113927f, 
    0.00072950f, 0.02997768f, -0.00624641f, -0.00482832f, -0.02847882f, -0.06022720f, 0.02867884f, -0.06622808f, 
    0.03399313f, 0.01258090f, -0.01180955f, -0.02760572f, -0.03834106f, -0.04405663f, -0.01793144f, -0.03020691f, 
    -0.04701575f, -0.01445962f, -0.02651658f, -0.06255578f, -0.05984092f, 0.04393147f, 0.01305738f, -0.01356200f, 
    0.04742289f, -0.03542331f, -0.06063799f, -0.02726625f, 0.00191387f, 0.05581871f, 0.04740656f, 0.03640688f, 
    -0.01262940f, 0.01956684f, -0.04077362f, -0.03780631f, 0.02738995f, -0.04296999f, -0.03822380f, -0.07340223f, 
    0.03236115f, 0.03335508f, -0.00648323f, 0.01923914f, 0.02355915f, 0.00786467f, -0.00296687f, 0.01798590f, 
    0.05204622f, 0.03295077f, -0.04599565f, -0.03470463f, -0.00413711f, -0.00686353f, 0.03090257f, 0.03370234f, 
    0.04609783f, -0.02612531f, 0.00379541f, 0.01194787f, 0.04516903f, 0.01800618f, -0.04277341f, -0.06651770f, 
    -0.05569962f, 0.00974561f, 0.02622940f, -0.00687015f, 0.06255551f, 0.02687607f, 0.02167588f, -0.00590495f, 
    0.00936651f, -0.01191977f, -0.02153834f, 0.01033866f, 0.04048109f, -0.04902587f, 0.01751354f, 0.02997490f, 
    0.00738510f, 0.05449893f, 0.00022483f, 0.01875208f, -0.02466801f, -0.03947207f, 0.04662137f, -0.06502015f, 
    -0.00236219f, 0.02250738f, 0.00489836f, 0.05842848f, -0.04022326f, -0.05823452f, -0.00541481f, -0.01251715f, 
    -0.01041730f, 0.05265215f, 0.03626711f, 0.00815626f, -0.06527110f, 0.02537449f, -0.02942058f, 0.03062112f, 
    -0.02614204f, 0.01905241f, -0.05597330f, 0.01774115f, -0.02500262f, -0.04786194f, -0.00216103f, 0.04355149f, 
    0.00421828f, 0.02737716f, 0.00836367f, 0.04040230f, 0.01706241f, -0.01714197f, 0.04086033f, -0.01094757f, 
    -0.00148475f, 0.00028244f, -0.04956768f, -0.01529220f, -0.03749309f, 0.02320282f, -0.05767353f, 0.00697136f, 
    0.01658400f, -0.05915225f, -0.01731801f, -0.01172458f, -0.05842553f, -0.00787133f, -0.02742361f, -0.04706532f, 
    -0.03781999f, 0.04492598f, -0.04453158f, -0.00607605f, -0.04496161f, -0.06524616f, -0.00282687f, -0.03106931f, 
    -0.01017772f, -0.00389526f, 0.02478002f, -0.06403763f, 0.02391122f, -0.00915436f, 0.00760906f, -0.03772475f, 
    -0.06091535f, 0.01112590f, -0.04603132f, 0.01980837f, 0.01571968f, 0.02305695f, 0.01304152f, -0.03151535f, 
    -0.01526300f, -0.04918335f, 0.03698678f, 0.01798815f, -0.02679063f, -0.00069442f, -0.04277170f, 0.02846392f, 
    -0.04337185f, 0.04656707f, -0.01903170f, -0.01005107f, 0.05126187f, -0.02465355f, -0.00786783f, 0.04142305f, 
    0.05388991f, -0.01235508f, 0.04101248f, -0.03869974f, -0.02925565f, -0.05297734f, 0.03537303f, 0.02684589f, 
    0.05355146f, 0.05190951f, -0.01648356f, -0.05920295f, -0.05629168f, -0.02995900f, -0.00562616f, -0.00513309f, 
    -0.05149829f, 0.02395631f, -0.00594952f, -0.05272512f, -0.00298424f, -0.01722343f, 0.00767949f, -0.07045066f, 
    0.02830191f, 0.00460216f, 0.01759568f, 0.05073404f, 0.03570493f, -0.04326770f, 0.00744670f, 0.03707280f, 
    0.00207959f, -0.05264555f, -0.04770252f, -0.04794830f, -0.00262434f, 0.03030820f, -0.01364264f, 0.01177877f, 
    -0.00749013f, -0.05394916f, -0.03871733f, -0.00720246f, -0.04937931f, -0.01812197f, -0.02096182f, -0.00245462f, 
    -0.00351497f, -0.05276130f, -0.04233199f, -0.05240042f, -0.01936279f, 0.04736597f, -0.01851494f, -0.00828216f, 
    -0.04584172f, 0.00839178f, -0.00564800f, -0.00806250f, 0.01619108f, -0.01624584f, -0.04842419f, -0.04010842f, 
    -0.05484500f, -0.00741016f, -0.01517126f, 0.00460359f, -0.04133052f, 0.04084783f, 0.00266574f, -0.04230491f, 
    0.03498400f, -0.05114436f, 0.01613063f, 0.02249343f, 0.02000784f, -0.04223051f, 0.01421676f, -0.03148776f, 
    0.00015426f, 0.00628958f, -0.02477710f, -0.00880079f, 0.03776307f, -0.05750049f, 0.02561476f, -0.01159033f, 
    0.00839904f, -0.00820809f, -0.01500649f, 0.01459210f, -0.04740306f, -0.04342197f, 0.03967169f, -0.03527004f, 
    0.03230338f, 0.03896871f, -0.04612761f, 0.02364560f, 0.05291891f, -0.01653804f, 0.00760256f, -0.05544849f, 
    -0.03843054f, 0.02692925f, -0.01023821f, -0.05900189f, 0.03055013f, -0.02039796f, 0.03388989f, -0.01505406f, 
    0.03786498f, -0.04137768f, 0.02467864f, -0.05660379f, -0.01228426f, -0.05753206f, 0.03668146f, -0.01887784f, 
    -0.05154614f, 0.03500153f, -0.05918389f, 0.00869190f, -0.04629975f, -0.03543159f, 0.03147664f, -0.01104712f, 
    0.04445640f, -0.00517338f, -0.00108652f, -0.00229058f, 0.01860541f, -0.04914314f, -0.01749214f, -0.05915114f, 
    -0.03431910f, 0.04382211f, -0.02008572f, -0.03039788f, -0.02777533f, -0.01738339f, -0.00300542f, -0.01503097f, 
    -0.01736714f, 0.04272978f, -0.05644565f, 0.02834639f, 0.00000837f, -0.00844179f, 0.03791637f, -0.00334923f, 
    -0.06157717f, -0.04251753f, 0.01409153f, 0.03821283f, -0.03704062f, -0.06630916f, -0.03483992f, 0.01325054f, 
    0.02762378f, -0.02201840f, -0.05856087f, -0.00871553f, -0.06065812f, 0.00785273f, 0.03096132f, -0.02238425f, 
    -0.03671665f, 0.01373425f, 0.04508381f, -0.00407619f, 0.04722676f, -0.00967969f, -0.04007627f, 0.00408346f, 
    0.03096801f, -0.01193468f, 0.01191250f, -0.05198997f, -0.04669473f, 0.03808508f, -0.01429443f, 0.03286724f, 
    -0.06135166f, 0.02525924f, 0.00820400f, -0.02802037f, 0.04728492f, -0.06372692f, -0.02336443f, -0.04434979f, 
    -0.02967002f, 0.00539233f, 0.04491098f, -0.06673351f, -0.02293692f, 0.03959524f, 0.00299261f, 0.04470824f, 
    -0.01241266f, -0.01699212f, -0.06277516f, 0.05068183f, 0.03640950f, -0.03569536f, -0.03300363f, -0.00813220f, 
    -0.00439751f, -0.01736062f, -0.01601826f, 0.00121468f, 0.04144562f, -0.02088450f, 0.03039118f, -0.02591411f, 
    -0.01574687f, -0.02370477f, -0.00947289f, -0.03746884f, -0.00801037f, 0.01202612f, -0.03003309f, 0.01105657f, 
    -0.00333994f, -0.03541866f, 0.03007092f, 0.04420470f, -0.05515748f, -0.03182852f, -0.01851630f, -0.05891043f, 
    0.00784085f, 0.00351174f, 0.00880237f, -0.03418206f, -0.03640385f, -0.00735870f, 0.00804136f, 0.01505989f, 
    -0.06819675f, 0.04408504f, -0.06188286f, 0.01694324f, -0.04227052f, 0.00519447f, 0.00040588f, 0.03498869f, 
    -0.04131673f, 0.00699323f, -0.00057624f, 0.03392735f, -0.02266215f, 0.04192609f, -0.03059714f, -0.00152384f, 
    -0.00501171f, -0.05362150f, -0.00513907f, -0.06091524f, 0.02265031f, -0.03692873f, 0.03569209f, 0.03102181f, 
    -0.03791864f, -0.01956147f, -0.01022563f, -0.05522446f, -0.02654374f, 0.00150132f, -0.02953594f, -0.04601672f, 
    0.01187846f, 0.03318221f, 0.03354028f, 0.03042990f, -0.05118082f, 0.00906084f, -0.05576806f, 0.03060162f, 
    -0.02416682f, -0.05797951f, -0.00242524f, -0.06031731f, 0.02651107f, -0.04748026f, -0.06913001f, 0.00284844f, 
    -0.06196354f, -0.04550063f, -0.01494005f, -0.00901514f, -0.02108489f, -0.00308720f, -0.02177099f, -0.03632522f, 
    -0.03384054f, -0.05543806f, 0.02009167f, -0.06822725f, -0.01533572f, -0.06870765f, -0.01654093f, 0.03270767f, 
    0.02123345f, 0.03224321f, 0.04639833f, 0.05215139f, 0.03601923f, -0.02649070f, -0.05869795f, -0.05621199f, 
    0.03113586f, -0.03120395f, -0.05246932f, -0.03449031f, -0.02044303f, -0.03837920f, 0.00647913f, -0.05832272f, 
    -0.05586553f, 0.02835663f, -0.00676730f, -0.03413009f, -0.00028617f, 0.04472600f, 0.01820863f, 0.03686073f, 
    -0.05943382f, -0.05438094f, -0.01135621f, -0.01587761f, -0.02730610f, -0.06396396f, 0.01445717f, -0.07033294f, 
    -0.06844789f, 0.02949392f, 0.00839996f, -0.02713778f, 0.03473074f, -0.03071299f, 0.02889766f, -0.02239912f, 
    0.19672029f, 0.02430675f, -0.42098647f, 0.02509570f, 0.20202659f, -0.15902781f, 0.17538178f, 0.02451708f, 
    -0.21728830f, 0.05189626f, -0.37708884f, -0.46138042f, 0.02778934f, -0.24102576f, 0.08027328f, 0.05110863f, 
    -0.05115827f, -0.02641055f, -0.56779021f, -0.27078816f, 0.26455051f, -0.14254557f, 0.09544624f, -0.12800789f, 
    -0.01990609f, -0.04564573f, -0.10756752f, 0.05992655f, -0.16665269f, -0.20579605f, 0.00780006f, -0.29065794f, 
    -0.22975980f, -0.04827303f, -0.08343004f, -0.24367370f, -0.43950689f, -0.57773983f, 0.05038036f, -0.09589273f, 
    0.09012320f, 0.02814425f, 0.00311936f, -0.26790649f, -0.09618639f, -0.17957328f, 0.16600622f, 0.05521792f, 
    0.02502610f, -0.08712601f, 0.19848996f, 0.07409691f, -0.17811646f, -0.03004765f, 0.05427760f, 0.24654122f, 
    0.25728875f, -0.07486502f, 0.03374553f, 0.21839298f, 0.27205759f, 0.06713211f, 0.02493582f, -0.11717305f, 
    -0.26159817f, -0.30438817f, 0.11291219f, -0.01403603f, -0.06981292f, 0.20912656f, 0.19096048f, 0.22672468f, 
    0.43650407f, 0.17412435f, -0.17428997f, -0.04295664f, -0.01367718f, 0.05999577f, -0.19666311f, 0.07591148f, 
    0.07966230f, -0.36765808f, -0.09189950f, -0.20551859f, -0.19655091f, -0.38879952f, -0.07154742f, 0.19913661f, 
    0.13702029f, 0.01940740f, -0.43742555f, -0.27688679f, 0.16477352f, -0.14749731f, 0.07013437f, -0.19750182f, 
    0.13545141f, 0.24818331f, -0.09763362f, 0.13709907f, 0.31329182f, 0.15506369f, 0.02459290f, 0.10649715f, 
    -0.12215924f, 0.12959695f, -0.08301271f, 0.06817985f, -0.60309029f, -0.28170341f, -0.23284543f, 0.01438586f, 
    -0.31526539f, 0.01449175f, 0.08001255f, 0.01251382f, -0.04708869f, 0.07465045f, 0.02342113f, 0.34170616f, 
    0.12803420f, 0.09371027f, 0.20431106f, 0.21759993f, -0.00269193f, 0.05243526f, 0.25923970f, -0.32407969f, 
    -0.52819234f, -0.10096060f, 0.08061578f, -0.14154246f, -0.06935612f, 0.11604850f, -0.19645773f, 0.11520994f, 
    0.20145515f, 0.11345869f, 0.07265887f, -0.17258488f, 0.04272717f, -0.00975671f, 0.17590570f, 0.08751284f, 
    0.59616441f, 0.59173572f, 0.39482537f, -0.24295449f, 0.11566196f, -0.36511031f, 0.07812390f, 0.27298209f, 
    0.16393980f, 0.34333214f, -1.00554299f, -0.71209925f, -0.17444983f, -0.21517533f, 0.05139798f, -0.10820700f, 
    0.12286588f, 0.00007225f, 0.01147222f, 0.00384499f, 0.14831226f, -0.00060170f, 0.01091108f, -0.12282250f, 
    -0.11435157f, 0.05670230f, -0.15495774f, 0.00873388f, -0.37764016f, -1.33695567f, 0.20898625f, 0.02614637f, 
    0.14205267f, 0.08408672f, 0.03103999f, 0.01094636f, 0.25292566f, 0.06148969f, 0.07907283f, -0.00134271f, 
    0.14284840f, 0.19536455f, 0.06637718f, -0.06198507f, 0.02461155f, -0.55718791f, 0.10289076f, -0.31718034f, 
    -0.20343338f, -0.05654922f, 0.07918360f, 0.22662555f, 0.10108816f, -0.18313099f, -0.81331843f, -0.11479864f, 
    0.22510839f, -0.03018597f, -0.11165956f, -0.21412079f, 0.18479262f, 0.17256476f, 0.02826799f, 0.50712347f, 
    0.53555393f, 0.53724784f, -0.26919588f, 0.18704836f, -0.07024546f, 0.01051187f, 0.01548709f, 0.26552451f, 
    0.48406956f, 0.32260519f, 0.26351160f, -0.12729692f, -0.05296021f, -0.18514055f, 0.18095618f, -0.01367432f, 
    0.04201427f, 0.36170280f, 0.18558013f, 0.41835716f, 0.13325554f, -0.00407438f, 0.13646020f, 0.09867800f, 
    -0.05422388f, 0.12179875f, -0.87281662f, -0.05813022f, 0.16089728f, -0.01716852f, 0.00989974f, -0.32224154f, 
    0.05236358f, 0.11824705f, -0.42552882f, 0.09663989f, -0.03335688f, -0.74111634f, -0.12077110f, -0.06886622f, 
    -0.14847526f, 0.28466013f, 0.04547392f, 0.22026171f, 0.10784119f, -0.17738642f, 0.02623462f, 0.03133839f, 
    0.14763731f, 0.08001520f, 0.02880027f, 0.00480769f, 0.03598733f, -0.36098486f, -0.14546509f, -0.07461071f, 
    0.04229815f, -0.07101905f, -0.20626742f, 0.13175769f, 0.04778274f, -0.05153261f, 0.19460866f, 0.01561815f, 
    -0.21106768f, -0.10485065f, -0.05174765f, 0.21962756f, -0.02441806f, 0.37831548f, -0.13317303f, 0.17211428f, 
    0.09613978f, 0.08788107f, -0.00582777f, -0.06298658f, 0.04261791f, -0.01759377f, 0.05548273f, -0.24587758f, 
    0.18301830f, 0.20925803f, 0.27076975f, -0.16579990f, -0.17589664f, -0.29199246f, 0.12976545f, 0.22950558f, 
    0.16558409f, -0.84301788f, 0.11725058f, 0.91894615f, 0.11044363f, 0.05146147f, 0.13171066f, -0.02560732f, 
    0.06053316f, 0.01460513f, -0.28841120f, -0.32343748f, -0.02116764f, 0.02629164f, 0.00010119f, -0.05207342f, 
    -0.24204324f, -0.16241962f, 0.13916703f, 0.15440848f, 0.03699268f, 0.10594320f, 0.00185327f, 0.03283770f, 
    -0.08781752f, 0.19734202f, -0.17148006f, 0.11149104f, 0.16806400f, 0.07708798f, 0.15497002f, -0.02418942f, 
    0.02050097f, -0.02250082f, 0.09737489f, -0.20338705f, 0.28132698f, -0.53416038f, -0.03966120f, 0.31416085f, 
    0.06336679f, 0.03074303f, 0.05748939f, -0.07411382f, 0.15912503f, 0.20091522f, -0.54719096f, -0.40954831f, 
    -0.25732705f, -0.07214532f, -0.04527215f, -0.17830513f, -0.07745413f, -0.21675310f, 0.00683318f, 0.11170246f, 
    -0.09248465f, -0.00588294f, 0.09997882f, -0.03121092f, -0.14333174f, -0.12760824f, 0.10516930f, 0.04657165f, 
    0.05528648f, 0.08209354f, -0.03043753f, -0.13679394f, -0.03856187f, -0.07649790f, 0.08259498f, 0.03173950f, 
    -0.02169671f, 0.14039791f, 0.11808081f, -0.19274153f, -0.04767581f, 0.09755903f, 0.04844955f, 0.15475816f, 
    0.04789361f, 0.20095092f, -0.04862192f, -0.25126690f, -0.15468870f, -0.03427950f, -0.05601300f, -0.05418415f, 
    0.14990573f, -0.01344072f, 0.19142184f, -0.47901946f, -0.31955022f, 0.09737381f, 0.07691080f, 0.12973794f, 
    0.05007957f, 0.10540801f, -0.11453237f, -0.02265096f, 0.07035528f, -0.11950523f, 0.18303300f, 0.14979416f, 
    0.08161661f, -0.05444303f, 0.14591496f, 0.21921816f, 0.20720926f, -0.00993922f, -0.06747872f, 0.03165452f, 
    -0.24685057f, -0.34002608f, -0.30516437f, -0.23755269f, -0.28330389f, 0.06056788f, 0.11935516f, -0.22108036f, 
    -0.09686418f, -0.01327559f, -0.16160655f, -0.00860964f, 0.05453845f, 0.21084471f, -0.06376032f, 0.01840539f, 
    0.00393280f, -0.01990202f, 0.09275966f, 0.03199267f, 0.04338969f, 0.08961455f, 0.11786558f, 0.01139848f, 
    -0.39802757f, -0.59253103f, -0.71031004f, -0.14623794f, -0.07665344f, -0.12918974f, 0.07506909f, -0.12831999f, 
    -0.00103670f, -0.15583639f, 0.01654663f, 0.14402299f, -0.19933176f, 0.16221417f, 0.13397960f, 0.04953413f, 
    0.07477712f, 0.20657912f, -0.19109157f, -0.43206191f, 0.31027010f, 0.06422808f, -0.10327551f, -0.15165254f, 
    0.17246376f, 0.01849086f, 0.14656281f, 0.52739054f, 0.25530943f, 0.16632921f, 0.10858003f, -0.07869872f, 
    0.03295633f, 0.04566666f, 0.14330059f, -0.03713775f, -0.51103806f, 0.20119816f, 0.61658782f, 0.01112101f, 
    -0.11526081f, -0.01603894f, -0.18645245f, -0.06712777f, -0.02566018f, 0.03869403f, 0.12157371f, 0.17138550f, 
    0.10044426f, 0.02561448f, -0.06946176f, 0.36908484f, 0.01768572f, -0.04530204f, 0.05132820f, -0.20730010f, 
    0.40496358f, 0.26218578f, 0.09725400f, -0.04074203f, -0.06298500f, 0.01347333f, 0.08579151f, -0.30338591f, 
    -0.33560741f, 0.08916334f, -0.04539699f, -0.04947028f, -0.16752955f, -0.01273828f, -0.13365224f, 0.03281180f, 
    -0.38567072f, 0.10074105f, -0.39697793f, -0.06974401f, -0.03584767f, -0.04370643f, 0.05959937f, -0.01770507f, 
    0.23886746f, -0.16315745f, -0.21666624f, 0.16897975f, -0.15649590f, -0.04562776f, 0.03748956f, 0.10382940f, 
    0.14031823f, -0.00531790f, -0.28912553f, 0.11108107f, -0.15511812f, -0.01470761f, 0.25389391f, 0.09992073f, 
    0.36546999f, 0.17712408f, 0.05043926f, 0.03873419f, -0.06069534f, 0.32352945f, -0.42548496f, -0.27052209f, 
    0.17736925f, 0.05495078f, 0.07552815f, 0.06964735f, 0.08509246f, -0.03599941f, -0.12815826f, -0.27332854f, 
    -0.22682497f, -0.19722532f, -0.04087875f, 0.08585960f, -0.06280289f, 0.25303513f, 0.06369115f, 0.02957854f, 
    0.08168866f, -0.03592917f, 0.04891128f, 0.15836948f, 0.02789554f, 0.21822487f, 0.15563793f, -0.33571488f, 
    -0.16114740f, -0.03206587f, -0.16407451f, -0.27420336f, -0.10236081f, 0.10955512f, 0.04773673f, 0.04250691f, 
    -0.17440429f, -0.13479882f, 0.03869503f, 0.16334479f, 0.09496112f, 0.05510627f, 0.08553199f, 0.16739690f, 
    -0.18390976f, -0.11123580f, -0.12350141f, 0.06481745f, 0.07171137f, 0.11379596f, 0.07354504f, 0.25172117f, 
    0.03213814f, -0.05854625f, -0.04511508f, -0.09062617f, -0.22841857f, -0.07350467f, -0.12394623f, 0.16102566f, 
    0.24851879f, 0.21647477f, 0.00635424f, -0.11861672f, -0.45597684f, 0.18644235f, -0.19788529f, 0.21407710f, 
    0.15610197f, 0.04165616f, 0.19172567f, -0.09109885f, -0.21550769f, -0.28355682f, 0.19346151f, 0.17763852f, 
    0.03624679f, 0.06445400f, 0.03411302f, 0.12669775f, 0.08526793f, -0.00054276f, -0.00210559f, 0.10373462f, 
    0.12319329f, 0.25912529f, 0.11779028f, 0.02446579f, -0.18265131f, -0.15525380f, 0.05889920f, -0.11963505f, 
    -0.12188988f, -0.00630518f, 0.00651198f, 0.09314039f, 0.06417656f, 0.25426006f, -0.08227782f, 0.16531633f, 
    -0.06283331f, -0.04749554f, 0.09074194f, 0.10141635f, -0.07796820f, 0.03414886f, 0.14317279f, -0.00242224f, 
    0.02324250f, 0.00557578f, 0.05751976f, 0.04837047f, 0.11899958f, -0.07334644f, -0.44169959f, -0.50344199f, 
    0.13864212f, 0.09256362f, 0.09461014f, 0.15133314f, 0.01779234f, -0.25787729f, -0.20418115f, -0.43522123f, 
    -0.12369806f, -0.02964614f, -0.03627479f, 0.18218349f, 0.07805359f, 0.09869665f, 0.08215663f, -0.18111053f, 
    -0.26593494f, -0.21767931f, -0.03682249f, 0.14277802f, -0.20877270f, -0.18852186f, -0.06978321f, 0.18606351f, 
    -0.06078401f, -0.33505538f, -0.24761443f, -0.30059174f, 0.04163849f, -0.01192133f, 0.25853634f, 0.14777611f, 
    0.03506058f, 0.13946043f, 0.08175553f, 0.05886579f, -0.04465058f, -0.14641841f, -0.31834745f, 0.06971835f, 
    0.01184858f, 0.04510684f, 0.01608255f, -0.06775305f, 0.14932744f, -0.09988008f, -0.05854792f, -0.13876395f, 
    0.08215976f, 0.11806018f, 0.12787394f, 0.12584861f, 0.20759715f, 0.10902612f, 0.02143927f, -0.01839074f, 
    -0.19636297f, 0.09947131f, 0.01048478f, 0.10899362f, 0.11719132f, 0.04122073f, -0.07251481f, -0.18700615f, 
    -0.00292027f, -0.28089762f, 0.13821045f, 0.10999838f, 0.15918523f, 0.07034862f, 0.14302111f, 0.09698361f, 
    -0.05386318f, 0.01246527f, -0.03110863f, 0.32704261f, 0.28603804f, 0.03526830f, -0.32182550f, -0.33237422f, 
    0.06822100f, 0.02677815f, -0.10799289f, -0.14663540f, 0.04847942f, 0.17734900f, 0.16307272f, 0.02523160f, 
    0.19497544f, 0.43393728f, -0.05865069f, -0.08744556f, -0.25538909f, 0.11648674f, -0.16064321f, -0.06453162f, 
    -0.06763425f, -0.14356482f, -0.17076704f, -0.18045828f, -0.03652552f, 0.08799073f, 0.04222877f, 0.13313849f, 
    -0.09994058f, 0.34498823f, -0.06458376f, -0.08560979f, -0.00616568f, -0.01653389f, -0.04924745f, 0.07804487f, 
    0.32827067f, 0.15228239f, -0.04229887f, 0.09285919f, 0.06607948f, -0.10953902f, -0.07945586f, 0.21555951f, 
    -0.02627233f, 0.20259611f, 0.02135686f, 0.02722006f, 0.14144284f, 0.12257753f, 0.11590564f, 0.05699885f, 
    -0.05777302f, -0.03638559f, -0.01142343f, 0.14947620f, -0.19262956f, -0.27928051f, -0.22510454f, 0.02187560f, 
    -0.06285943f, -0.52925938f, 0.34586975f, 0.30363503f, -0.01264853f, -0.03093088f, -0.00075553f, 0.03072697f, 
    0.00541300f, -0.10459591f, -0.14037737f, 0.42951626f, 0.27752081f, 0.11865173f, -0.15805238f, -0.02328549f, 
    -0.03538015f, 0.26453933f, 0.17064366f, 0.09922422f, 0.45586592f, 0.14338598f, -0.21179013f, 0.06041842f, 
    -0.27865329f, -0.23275152f, -0.31158686f, 0.14091827f, -0.27882725f, -0.10725500f, -0.14837660f, -0.00029683f, 
    -0.13246191f, 0.29536778f, 0.35088137f, 0.06720704f, -0.03437291f, 0.11089060f, -0.02580033f, 0.14527212f, 
    0.13491006f, 0.05520948f, -0.11842493f, -0.18438974f, 0.01487044f, -0.03698418f, -0.06932677f, 0.09219802f, 
    0.19049208f, 0.13856298f, 0.02184660f, -0.02149097f, -0.08487970f, -0.04467586f, 0.04149023f, -0.18062621f, 
    0.09624628f, 0.01891695f, 0.02497878f, 0.17385072f, -0.18881285f, -0.00789956f, 0.05444781f, 0.05731433f, 
    -0.00451451f, 0.22169727f, -0.17751959f, -0.09942217f, -0.10773388f, -0.48288310f, -0.33100840f, -0.26741961f, 
    -0.00021076f, -0.20501037f, -0.10030172f, 0.01533768f, 0.04403597f, -0.05535671f, 0.11327772f, 0.15943706f, 
    0.29494563f, 0.07431389f, -0.29135597f, 0.10989535f, 0.09014246f, -0.08757064f, 0.11231873f, 0.35602245f, 
    0.17474210f, -0.28500780f, -0.01532487f, 0.22797339f, 0.24795513f, 0.19624215f, 0.20039621f, 0.18035387f, 
    -0.00307602f, -0.03135022f, -0.26252607f, -0.46115354f, -0.23028539f, -0.27254120f, -0.04374701f, -0.20483983f, 
    -0.05312184f, -0.15121318f, 0.19427182f, -0.21925521f, -0.17598218f, -0.04858222f, 0.28060248f, 0.05166305f, 
    -0.06564341f, 0.02088063f, 0.09954564f, -0.05112850f, -0.26095900f, 0.06628280f, -0.38233715f, 0.02590838f, 
    0.14860663f, 0.21618707f, 0.00409985f, 0.00438130f, 0.08052593f, 0.07704467f, 0.36094508f, 0.16846979f, 
    0.17405725f, 0.11031064f, 0.19302559f, 0.10714068f, 0.21409440f, 0.03334991f, -0.06923022f, 0.05442327f, 
    0.10249522f, 0.01847789f, -0.02906758f, 0.12768471f, -0.00322303f, 0.00385188f, -0.12276884f, -0.03433970f, 
    -0.20468229f, -0.24425933f, 0.25185376f, -0.01109400f, 0.16397198f, -0.12377233f, -0.07146057f, -0.05406690f, 
    0.03011113f, 0.26277176f, 0.18382849f, -0.01524743f, 0.02921938f, 0.13875531f, -0.07483516f, 0.08703826f, 
    -0.23696189f, -0.10744221f, -0.07764933f, -0.01925065f, 0.17853747f, -0.02392312f, -0.14798826f, 0.12886308f, 
    0.15661721f, 0.13494660f, 0.01254513f, -0.40316746f, -0.31690818f, -0.17918476f, -0.03204439f, -0.10307450f, 
    -0.30058345f, 0.07474893f, -0.21784398f, -0.20821542f, -0.25561175f, 0.03422910f, -0.01104609f, -0.15344815f, 
    -0.01167485f, -0.04679431f, -0.06119474f, -0.04580564f, 0.01383319f, 0.33368960f, 0.10803539f, 0.05293082f, 
    0.19493634f, 0.30922216f, 0.00758732f, 0.04541363f, 0.22870256f, -0.57721055f, -0.61057609f, 0.09156896f, 
    0.26499715f, 0.06966387f, 0.23465350f, 0.04098721f, -0.08417237f, 0.10727552f, -0.09552154f, -0.41621539f, 
    -0.50983912f, -0.11385826f, 0.11339983f, 0.19946925f, 0.13661796f, 0.18979576f, -0.13778877f, 0.30904245f, 
    0.19701064f, 0.04413170f, 0.29605111f, -0.00129580f, -0.06252567f, -0.02037064f, 0.14535081f, -0.14741749f, 
    0.09846070f, 0.22285739f, 0.13601136f, -0.13639134f, -0.14054222f, -0.09849919f, 0.03451603f, -0.21905373f, 
    -0.49821880f, -0.19761766f, 0.05081774f, 0.03653564f, 0.24922085f, -0.03156268f, -0.17642941f, 0.23752674f, 
    0.37751132f, 0.16757180f, 0.15109335f, -0.14117008f, 0.13677385f, -0.21148786f, -0.04978644f, -0.14266559f, 
    -0.20762211f, 0.08517470f, -0.11394442f, 0.49523982f, 0.14105695f, -0.23209958f, 0.14078316f, -0.04348296f, 
    0.05365367f, 0.03612289f, -0.06740224f, -0.03944504f, -0.01860568f, 0.05229365f, 0.17334327f, 0.11715513f, 
    0.00355870f, 0.11876279f, 0.12070093f, -0.15016283f, -0.06509025f, -0.11923874f, 0.55181456f, 0.24437773f, 
    -0.16887282f, -0.11536381f, 0.44436157f, 0.07907905f, 0.24541962f, 0.05886264f, -0.18703014f, -0.11354636f, 
    -0.32419059f, -0.07080863f, 0.13349141f, 0.41961047f, 0.08799139f, -0.14544043f, -0.07904030f, -0.24931628f, 
    -0.14136630f, 0.20130251f, -0.03302491f, 0.15438956f, 0.08268689f, 0.11962838f, -0.25332838f, -0.30422509f, 
    0.10200230f, 0.33823943f, -0.03289402f, -0.03954818f, 0.26770759f, -0.05570968f, 0.04323621f, -0.11786911f, 
    -0.38511810f, 0.36096057f, -0.12065099f, 0.06043650f, -0.14844516f, -0.17202628f, -0.15780327f, 0.11669118f, 
    -0.10724038f, 0.09673395f, 0.07441074f, 0.08599525f, -0.38882864f, 0.04491802f, 0.03386709f, -0.21898368f, 
    0.20279083f, 0.21066503f, -0.14319213f, -0.54627967f, -0.20902887f, -0.38090211f, 0.04805485f, -0.17813072f, 
    -0.21498762f, 0.02711012f, -0.03709127f, 0.31359392f, -0.49591854f, -0.53133798f, -0.15819776f, -0.06767254f, 
    0.19780059f, 0.11082345f, 0.01008775f, 0.10792476f, -0.16687831f, 0.16774280f, -0.14285479f, -0.13760285f, 
    0.30441728f, 0.12620981f, -0.17515430f, -0.06551208f, 0.03405275f, 0.26640421f, 0.22954521f, -0.05502691f, 
    -0.19217907f, -0.10330961f, -0.15913908f, -0.03710064f, -0.36891094f, -0.37171632f, -0.40337220f, 0.14715813f, 
    0.11869730f, 0.06791206f, 0.03581828f, 0.13508764f, -0.02919687f, 0.12462757f, 0.01106219f, -0.14189643f, 
    0.05814144f, 0.22778270f, -0.24675193f, -0.07146849f, 0.11967039f, 0.24253914f, -0.11262350f, 0.25962800f, 
    -0.18924130f, 0.44610712f, 0.25294870f, 0.18384792f, -0.05590273f, 0.07834698f, 0.15749371f, 0.07296591f, 
    -0.03022150f, 0.07504792f, 0.08953228f, -0.09408041f, -0.95314699f, 0.31743339f, -0.61029088f, 0.15750781f, 
    0.14661694f, 0.01937102f, 0.04300657f, -0.37092033f, -0.37132534f, -0.62525529f, 0.00033345f, 0.11022699f, 
    -0.01921651f, -0.03069830f, 0.04021835f, 0.03797486f, 0.01700018f, 0.18479915f, -0.60876626f, -0.29661357f, 
    -0.28602412f, -0.24805273f, 0.06582492f, 0.16276214f, 0.06386063f, 0.15636407f, 0.19663484f, 0.01731214f, 
    0.01920862f, 0.14434364f, 0.00121566f, 0.09564466f, -0.01082101f, -0.20120747f, 0.22146507f, 0.17376851f, 
    0.01895600f, -0.02558763f, 0.16868834f, -0.09877060f, 0.00797756f, -0.02435035f, -0.30442989f, -0.02422924f, 
    -0.15053988f, -0.01894658f, 0.05102457f, -0.03308485f, 0.16834657f, 0.08482698f, 0.00429776f, 0.06502761f, 
    0.08221684f, -0.19994359f, -0.02701309f, 0.17358637f, 0.17173521f, 0.00781004f, 0.16334827f, 0.12829317f, 
    0.31469777f, -0.25263649f, -0.30316412f, -0.11693249f, -0.00212218f, 0.10943508f, -0.07623280f, 0.01151246f, 
    0.08526167f, -0.02359607f, 0.18301214f, 0.01822376f, -0.22140503f, -0.19817819f, -0.03690369f, -0.08027061f, 
    0.13015704f, 0.22690041f, -0.01073996f, -0.39541569f, 0.05445677f, -0.19303133f, 0.03419360f, -0.54529601f, 
    0.02888647f, 0.01581913f, -0.01344040f, 0.16853012f, 0.07914398f, 0.21214348f, 0.05659995f, -0.08307955f, 
    -0.13591795f, -0.06856190f, 0.13450184f, -0.04371834f, -0.08882092f, -0.08325078f, -0.06689479f, -0.19509572f, 
    -0.01279797f, 0.09055407f, 0.08816419f, -0.01304057f, 0.13657629f, 0.01967601f, -0.24189913f, -0.17782234f, 
    -0.20279975f, -0.18892941f, -0.35028282f, 0.06712748f, 0.09242430f, -0.01991171f, -0.25083482f, -0.18000598f, 
    0.26381028f, 0.40204832f, 0.07999390f, 0.05175344f, 0.09474834f, -0.00929142f, -0.02770406f, -0.07687018f, 
    0.11304754f, -0.02352253f, 0.08421275f, 0.13687600f, -0.31476694f, -0.03429926f, -0.19241492f, 0.07247378f, 
    0.26707536f, 0.24143758f, 0.39778864f, 0.57735175f, -0.24933872f, 0.07947286f, 0.10309157f, 0.17550851f, 
    0.19981296f, -0.16959353f, -0.13266471f, 0.12582061f, -0.01615963f, -0.23976967f, -0.25840417f, 0.13696718f, 
    -0.06306821f, 0.12703331f, 0.12992942f, -0.51019764f, -0.56430763f, -0.25516471f, 0.03671456f, -0.05973370f, 
    0.02535444f, 0.09045674f, -0.14762861f, -0.09429863f, 0.37900519f, 0.20941985f, 0.10702104f, -0.00965728f, 
    0.11918219f, 0.15805376f, 0.11355952f, 0.04394441f, -0.17913112f, 0.42161277f, 0.13099605f, -0.05657913f, 
    -0.14202768f, 0.02481513f, -0.02731955f, -0.00766146f, 0.16180356f, -0.12579888f, -0.36263731f, -0.49742895f, 
    -0.53734839f, 0.12494262f, 0.00869942f, 0.19562602f, -0.11070709f, -0.08992030f, -0.15129098f, 0.34210205f, 
    0.06445030f, -0.10107549f, -0.03537514f, 0.17428963f, 0.23323707f, -0.08199721f, 0.05562662f, 0.08034132f, 
    0.19291535f, 0.02590780f, -0.13454627f, -0.25127172f, 0.02939718f, -0.42236739f, 0.00491369f, 0.09894904f, 
    0.03709854f, 0.28008384f, -0.01987882f, -0.30874130f, 0.08369988f, 0.20603792f, -0.01484119f, 0.07098907f, 
    -0.06104502f, 0.20744251f, -0.51446182f, 0.43785486f, -0.36387286f, 0.07678465f, 0.26163617f, -0.11639164f, 
    0.06624553f, 0.12455390f, -0.24372229f, -0.34207365f, -0.58730316f, -0.25690460f, 0.13926983f, 0.04925419f, 
    -0.00802495f, 0.04394779f, -0.05100131f, -0.15289445f, -0.04325790f, -0.06009474f, -0.20981583f, -0.09863753f, 
    -0.17573364f, 0.03595123f, 0.20677593f, -0.05111284f, 0.00790768f, 0.06249358f, -0.05250724f, 0.00850828f, 
    0.15518998f, 0.02566284f, -0.12701544f, -0.20083496f, -0.11309019f, 0.04106756f, -0.10861098f, 0.14197038f, 
    0.15675551f, -0.11070982f, -0.24634650f, 0.08112644f, -0.05814509f, 0.21882014f, 0.19036697f, -0.09802175f, 
    -0.09378518f, -0.26005313f, -0.03613234f, 0.08352274f, -0.03965775f, 0.06462490f, -0.02824922f, -0.13920183f, 
    0.12525104f, -0.28157708f, 0.07250416f, 0.03513252f, -0.15952012f, 0.11342819f, -0.00694463f, -0.05980438f, 
    0.14322604f, 0.14890191f, -0.19335367f, -0.49397591f, -0.06842882f, 0.00820268f, -0.25020662f, -0.01718683f, 
    0.01543398f, 0.03264881f, -0.61210346f, -0.40823525f, -0.07630097f, -0.08048063f, 0.13771139f, -0.12640001f, 
    -0.00811040f, 0.07341380f, 0.05809560f, -0.26767012f, -0.04570868f, 0.26718935f, -0.00689844f, 0.04058264f, 
    0.05757330f, 0.05355929f, 0.04753423f, 0.06894797f, 0.52010381f, -0.26860848f, 0.11104482f, 0.01142007f, 
    -0.01988511f, 0.10753117f, 0.11889135f, -0.09325248f, -0.10968603f, -0.06967148f, 0.07911282f, -0.20070371f, 
    -0.09083366f, 0.19989464f, 0.18465306f, 0.12861753f, 0.08578186f, 0.09599397f, 0.07424606f, 0.36418435f, 
    0.28413668f, -0.19072267f, -0.17241870f, 0.11356706f, 0.13200203f, 0.20931230f, 0.04741680f, 0.17388923f, 
    0.06910723f, -0.01357877f, 0.03814202f, 0.09409171f, 0.00610424f, 0.19889712f, 0.24882081f, -0.06965120f, 
    0.07814740f, 0.24847071f, 0.08797311f, 0.11557823f, 0.21808644f, 0.01261532f, -0.12454618f, 0.14775093f, 
    0.07360949f, -0.23955032f, 0.25184369f, -0.05295986f, -0.04033545f, -0.07029448f, -0.20293112f, 0.09650821f, 
    -0.00260422f, 0.08851024f, -0.11670955f, -0.08954185f, -0.45276794f, 0.01957726f, 0.11288550f, -0.03396153f, 
    0.07878181f, -0.06281235f, -0.08604145f, 0.66419983f, -0.44601798f, -0.52922595f, 0.15704377f, 0.16516934f, 
    0.00819190f, 0.10650174f, 0.09470778f, -0.03158559f, -0.75344455f, 0.04489617f, 0.36631855f, -0.08985599f, 
    0.12494851f, 0.00903772f, 0.20272726f, 0.11748645f, 0.20218097f, 0.08030218f, -0.09718143f, -0.08522593f, 
    -0.09606653f, -0.23269387f, -0.12596977f, -0.03348585f, -0.09393817f, -0.05947513f, -0.11765533f, 0.15214106f, 
    -0.09967588f, 0.07592531f, 0.03246790f, -0.03069829f, -0.05218941f, 0.09371436f, -0.03995325f, 0.16045092f, 
    -0.00910890f, -0.17772199f, -0.00027964f, 0.02154698f, 0.02855276f, 0.00549797f, 0.00834848f, 0.13391650f, 
    -0.05901790f, 0.22443488f, -0.01407138f, -0.09401764f, 0.00549157f, -0.04423658f, -0.13114491f, -0.06384721f, 
    0.13253123f, 0.21941198f, 0.17735137f, 0.00585342f, -0.14118317f, -0.23102954f, -0.16809805f, 0.19409262f, 
    -0.08973202f, 0.17030829f, 0.06877423f, 0.12311837f, -0.83115858f, -0.05449931f, 0.16585264f, 0.12484942f, 
    0.10285693f, 0.06458943f, 0.10747048f, 0.62738961f, 0.15962961f, -0.02410052f, 0.07397293f, 0.00979762f, 
    0.14042567f, 0.08871032f, 0.09781189f, -0.00592358f, -0.04680742f, -0.59981430f, 0.20356229f, 0.11930225f, 
    0.06174013f, 0.00739246f, 0.13894959f, -0.04678551f, -0.03691416f, -1.36061430f, -0.30300483f, 0.06977105f, 
    -0.15473750f, 0.18972746f, 0.00897525f, 0.10455911f, -0.01444973f, -0.01253605f, 0.03549621f, 0.03505438f, 
    0.29198667f, 0.12805963f, 0.13587546f, 0.00372083f, 0.13311802f, 0.05070399f, -0.09680519f, -0.16481286f, 
    -0.48911873f, 0.29480523f, -0.18379946f, -0.18083240f, -0.13231526f, -0.03646358f, -0.04223737f, 0.03259612f, 
    0.14636859f, 0.34146735f, 0.28779581f, -0.22600500f, -0.50279474f, 0.06426771f, 0.03430796f, -0.12265571f, 
    0.04133720f, -0.74860865f, -0.39638948f, -0.04628346f, -0.15626290f, -0.16509975f, 0.14150122f, -0.02611341f, 
    -0.05805956f, -0.10153281f, -1.28559291f, -0.16353595f, -0.44672236f, -0.11939868f, -0.05216613f, -0.00277861f, 
    0.29739463f, -0.06658778f, 0.16196600f, -0.16006489f, 0.14773329f, -0.16290326f, -0.04707639f, -0.27515888f, 
    -0.22434393f, -0.17764704f, 0.08416907f, -0.01054116f, -0.01684741f, -0.05125430f, -0.09992129f, 0.00118856f, 
    -0.09327915f, -0.10170378f, -0.00387173f, 0.04347920f, -0.18942288f, 0.13832912f, 0.02656998f, 0.12313970f, 
    0.02861668f, 0.02104943f, -0.08057340f, -0.19885723f, 0.29990846f, 0.30579185f, -0.36162469f, 0.08826688f, 
    -0.35880867f, 0.04109677f, 0.15076241f, 0.18622807f, 0.11363222f, 0.03337530f, 0.04165868f, -0.04138928f, 
    -0.03084480f, 0.07673582f, 0.21666309f, 0.22058813f, 0.26619110f, 0.08867672f, 0.06510773f, 0.01910140f, 
    -0.00206881f, -0.02406369f, 0.04362997f, 0.02493630f, 0.00394590f, -0.06908160f, -0.06671789f, 0.01176804f, 
    0.03805056f, 0.04559075f, -0.00734142f, -0.05987100f, -0.02651100f, -0.01720003f, -0.00701584f, -0.03788872f, 
    -0.01456044f, 0.02447540f, 0.00589002f, -0.00942183f, 0.01084864f, 0.01585998f, -0.00173816f, 0.04554220f, 
    -0.04512708f, -0.02316568f, 0.02266923f, -0.00414920f, -0.02730438f, -0.05921771f, -0.03137811f, -0.03762160f, 
    0.03051128f, -0.02504794f, 0.00525384f, -0.05957328f, -0.01611339f, -0.06670818f, 0.03825334f, 0.00245039f, 
    -0.06622252f, 0.02260130f, -0.00367341f, 0.00852934f, 0.00609937f, -0.01042367f, 0.04042805f, -0.05580534f, 
    -0.00477911f, 0.02125115f, 0.04943447f, -0.02577000f, 0.04633429f, -0.03812997f, 0.01326642f, -0.04579682f, 
    -0.00512057f, -0.01539983f, -0.04028739f, 0.00403093f, -0.01484714f, -0.00005380f, -0.03622377f, 0.03798828f, 
    -0.00688139f, -0.06026040f, 0.04477742f, 0.02075721f, 0.01944307f, -0.02867864f, 0.00185317f, 0.02232285f, 
    -0.04725712f, 0.00459840f, -0.05756001f, 0.02290425f, 0.02208406f, 0.00550912f, -0.03579989f, -0.04092861f, 
    0.04762058f, 0.04216203f, 0.00732040f, -0.04871662f, 0.02044213f, 0.03279623f, 0.03384657f, -0.00883979f, 
    -0.05615234f, 0.03617206f, 0.02825701f, -0.05003162f, -0.04281373f, -0.01306140f, 0.04546950f, 0.00933643f, 
    0.00155116f, 0.05097319f, -0.01520860f, -0.00774316f, -0.02370142f, -0.02233218f, -0.00164812f, -0.03241852f, 
    0.05163482f, 0.04320441f, -0.02892671f, -0.05291895f, -0.06501152f, -0.03981729f, 0.02191486f, 0.04892352f, 
    -0.04093388f, 0.03098187f, 0.03562942f, -0.02916636f, -0.00748871f, 0.00208033f, -0.04794757f, 0.00494215f, 
    0.04616136f, 0.01322928f, -0.01129857f, -0.00937943f, -0.01680913f, -0.05070508f, -0.06031780f, -0.06453234f, 
    0.04112850f, 0.02695832f, 0.00738695f, -0.01300731f, 0.00007261f, -0.03369030f, -0.05011409f, 0.02328318f, 
    -0.00174981f, -0.01694256f, 0.02103436f, -0.02905822f, -0.00438756f, -0.05110985f, -0.00214617f, 0.01000199f, 
    0.01345323f, -0.02767847f, 0.01909238f, 0.00353004f, -0.04409202f, -0.04857726f, 0.01320983f, 0.01195004f, 
    0.00166549f, 0.02805445f, -0.00075405f, 0.04730597f, 0.05165303f, 0.01617963f, 0.00976747f, -0.05645167f, 
    -0.00740837f, -0.04606966f, 0.04681730f, 0.03234558f, -0.00286661f, -0.00512131f, -0.04594053f, -0.00313479f, 
    0.02614013f, -0.00563709f, -0.04955854f, -0.01362148f, 0.00386758f, -0.03774213f, -0.03089261f, 0.01081120f, 
    -0.00043914f, -0.02408001f, -0.03556843f, -0.01489635f, 0.04091490f, -0.02404191f, -0.06173995f, 0.02198184f, 
    -0.05853861f, -0.05188490f, -0.05749997f, 0.02890992f, -0.05346146f, -0.03749371f, -0.06586204f, 0.02032324f, 
    0.01345782f, -0.03633300f, 0.03174816f, -0.03564059f, 0.04046904f, -0.00908548f, -0.01835082f, -0.01305668f, 
    -0.06711715f, -0.02163056f, 0.04183137f, -0.01284809f, -0.02524327f, -0.05548057f, -0.01242165f, 0.04093230f, 
    -0.05156414f, -0.03302982f, -0.01771456f, -0.02728055f, 0.00575551f, -0.04651546f, 0.03963799f, 0.01328109f, 
    -0.05631519f, 0.00081798f, 0.04472954f, -0.00594652f, -0.00777365f, -0.05919163f, 0.04350949f, 0.03470741f, 
    -0.04859049f, -0.05668421f, 0.02892024f, 0.03135765f, 0.02829858f, 0.04254677f, -0.02033524f, 0.04897743f, 
    0.01494177f, 0.00342207f, -0.03480793f, 0.04193086f, 0.04225234f, -0.01123723f, 0.04640451f, 0.04995100f, 
    -0.00382254f, -0.04827974f, 0.01601510f, 0.01050544f, 0.00827587f, 0.00952530f, -0.04829721f, -0.01923727f, 
    0.03396789f, -0.05874197f, -0.00620751f, 0.02059881f, -0.04519032f, 0.00495619f, 0.05041070f, -0.00721674f, 
    -0.01955651f, -0.06024221f, -0.05202031f, -0.05393965f, -0.03156996f, 0.04820389f, 0.00480171f, 0.01305293f, 
    0.00372648f, 0.02405434f, 0.05595714f, -0.02564116f, -0.02463381f, 0.00251905f, 0.01754072f, -0.06027430f, 
    0.03127332f, 0.01860671f, -0.00943059f, 0.02741612f, 0.00096634f, 0.00743697f, -0.02645744f, -0.03037767f, 
    0.00564823f, -0.04232668f, 0.04158682f, 0.03033857f, 0.04970649f, -0.00583059f, -0.04990236f, 0.02833910f, 
    0.03918818f, -0.02849955f, -0.04327933f, 0.03527263f, 0.01793173f, -0.05873162f, -0.03946958f, -0.06807376f, 
    -0.07163860f, -0.02039108f, 0.04103790f, -0.05098546f, -0.00839327f, -0.00987223f, -0.06658398f, -0.05165419f, 
    -0.03382593f, -0.03586851f, 0.03830536f, -0.04976640f, -0.02568087f, -0.03925673f, -0.04120982f, 0.00097455f, 
    -0.07111878f, 0.04564027f, 0.02436695f, 0.01547278f, 0.00448474f, -0.02284067f, -0.07047890f, -0.01483321f, 
    0.03294667f, -0.06555045f, -0.06441861f, -0.00484385f, -0.01506090f, -0.06387392f, 0.02021284f, -0.00201652f, 
    -0.01740794f, -0.07493288f, -0.03626131f, 0.03626415f, -0.02480241f, -0.06820884f, -0.01295770f, -0.01645440f, 
    0.03621409f, -0.06864364f, -0.02189165f, 0.01773236f, -0.05102115f, -0.02722163f, -0.02403101f, 0.03762113f, 
    -0.04583631f, 0.02019816f, -0.03291319f, 0.02472863f, -0.02928403f, 0.02645948f, -0.02531716f, 0.02665317f, 
    -0.07230917f, 0.01899005f, -0.05002043f, -0.05731560f, 0.03918268f, -0.05445567f, -0.00740695f, -0.00254591f, 
    0.03275729f, -0.03847686f, -0.05036031f, -0.02570288f, -0.00440653f, -0.01704659f, -0.04186868f, -0.07481400f, 
    -0.02449578f, -0.05058465f, -0.03773193f, -0.00492030f, -0.00134420f, -0.01791107f, -0.00638730f, -0.04737625f, 
    -0.04400805f, 0.00767929f, -0.02426621f, -0.00803939f, -0.07267465f, 0.00865252f, 0.02551468f, -0.05874049f, 
    0.03210621f, -0.02692866f, 0.00752734f, -0.03549242f, 0.01387943f, -0.06582752f, -0.03108327f, -0.07712186f, 
    -0.01893543f, -0.07148983f, -0.04572296f, -0.03172232f, -0.06629486f, -0.02413642f, 0.04000233f, 0.03928922f, 
    -0.03768399f, -0.02400712f, -0.06480877f, -0.03707849f, -0.04133501f, 0.01301288f, -0.06164488f, -0.01433037f, 
    -0.01142981f, 0.03014304f, -0.03599877f, -0.06214330f, -0.05901843f, -0.00082341f, -0.03787160f, -0.06957348f, 
    0.00571589f, -0.01748740f, 0.03269782f, -0.07849640f, 0.01472198f, -0.07003380f, -0.02581724f, -0.05360003f, 
    -0.03289902f, 0.01722851f, -0.03199597f, -0.01476087f, -0.03855405f, -0.05982674f, 0.03283425f, 0.04744494f, 
    -0.05242432f, 0.04197215f, -0.03257533f, -0.03977353f, -0.00205296f, -0.05701936f, -0.07179328f, -0.07105751f, 
    -0.08083361f, -0.04564728f, 0.01833932f, -0.00853328f, 0.00814510f, -0.03433786f, -0.01996171f, 0.02431525f, 
    0.00693183f, -0.07111000f, -0.04307093f, 0.01999960f, 0.04711250f, 0.03004868f, 0.02946678f, -0.02784471f, 
    -0.01993621f, -0.07498501f, -0.05289995f, -0.04030205f, -0.03143740f, -0.00894467f, -0.00649390f, 0.00889876f, 
    -0.03893077f, 0.00711811f, 0.03314015f, -0.02107472f, 0.03947595f, 0.04266408f, -0.01045623f, -0.04757194f, 
    -0.00712970f, -0.01981697f, -0.00971739f, 0.03412544f, -0.01326895f, 0.00438848f, -0.03424834f, -0.05930425f, 
    0.00935484f, -0.06534772f, 0.00778772f, 0.00892937f, -0.04829999f, -0.06728457f, -0.06617104f, 0.02961493f, 
    -0.06771152f, 0.02081300f, -0.02378547f, 0.04247572f, 0.00469261f, -0.02817813f, 0.04088588f, -0.01689751f, 
    0.01650250f, -0.03591233f, -0.05956500f, -0.04542535f, 0.00943626f, -0.07619287f, 0.02731350f, -0.04216672f, 
    0.03749375f, -0.06692306f, -0.02919076f, -0.07508186f, -0.04393300f, -0.01401103f, -0.05480420f, -0.03813930f, 
    -0.00339382f, -0.01324373f, 0.01559649f, 0.01318661f, -0.00872312f, -0.06562112f, -0.02442147f, -0.04503530f, 
    0.03181305f, 0.00147846f, -0.04269284f, -0.01079778f, -0.04509555f, 0.03477706f, -0.06813585f, -0.04964442f, 
    -0.06777645f, 0.04081807f, -0.05560999f, 0.02447478f, -0.04597557f, 0.01290542f, 0.04376474f, 0.04007481f, 
    -0.01893628f, -0.05024784f, 0.00611557f, -0.01497832f, 0.02030128f, -0.07088655f, -0.05296541f, -0.01496030f, 
    -0.04549664f, -0.07330488f, -0.05556636f, -0.03928310f, -0.01963210f, -0.06292020f, 0.01803675f, 0.00813817f, 
    -0.01046125f, -0.06594574f, 0.03411146f, -0.06541397f, -0.04132468f, -0.04830465f, 0.00553165f, -0.06510989f, 
    -0.05496579f, -0.00480203f, -0.06857926f, -0.01309252f, 0.00123963f, -0.04520940f, -0.07777050f, -0.04372447f, 
    -0.05453534f, 0.00960268f, 0.00878745f, 0.00670352f, 0.02979041f, -0.05076355f, -0.05044855f, -0.02994963f, 
    -0.07062783f, -0.40345418f, -0.07827965f, -0.20678598f, 0.11979316f, 0.14839000f, 0.15201220f, -0.22166985f, 
    0.24543929f, -0.08628570f, -0.10978498f, 0.18157044f, 0.04424917f, -0.28412554f, 0.08104893f, -0.01538448f, 
    -0.20043416f, 0.12067576f, -0.47376910f, -0.63176382f, -0.04732041f, 0.21069264f, -0.14809719f, 0.30340022f, 
    -0.05577518f, -0.02439866f, 0.04711374f, -0.28724054f, -0.10701831f, 0.15731850f, -0.06253605f, -0.11574366f, 
    0.12953383f, 0.04238382f, 0.10120827f, -0.10882286f, -0.08691523f, -0.16670491f, 0.13007432f, 0.07114737f, 
    0.00477352f, -0.20397435f, -0.05095905f, 0.04645574f, 0.12293220f, -0.20518097f, -0.02385466f, 0.18484633f, 
    -0.10823661f, -0.01984930f, -0.01432128f, -0.05157559f, 0.07431248f, -0.09390885f, -0.42271733f, -0.34944364f, 
    -0.07233521f, 0.06293057f, 0.08968180f, -0.05621457f, 0.08229388f, -0.03097124f, -0.06939054f, 0.00247388f, 
    0.03347857f, -0.02016083f, 0.04450283f, 0.09218678f, -0.03785004f, 0.17150865f, 0.13938449f, 0.07285724f, 
    0.03420078f, 0.05814321f, 0.12289421f, -0.05955746f, -0.05210070f, -0.01863099f, 0.04180746f, 0.19340879f, 
    0.15152298f, -0.00272610f, 0.00385941f, 0.05224456f, 0.28970420f, -0.01282538f, 0.07671801f, 0.10865908f, 
    0.13980408f, 0.04838454f, 0.06344333f, -0.00469856f, 0.02588743f, 0.01016436f, -0.04826975f, 0.03700463f, 
    0.14276734f, -0.09094570f, 0.33754084f, 0.09758606f, -0.26722836f, 0.04980961f, 0.16005239f, -0.01793630f, 
    -0.06942488f, 0.09560601f, 0.14956118f, 0.05044350f, -0.45131972f, -0.06132003f, 0.23825952f, 0.06551463f, 
    -0.06160299f, 0.08874902f, 0.18344048f, 0.10119607f, -0.37589681f, -0.52789420f, -0.39531964f, 0.00266529f, 
    -0.21949950f, -0.05018435f, -0.06843606f, 0.15464196f, 0.06997799f, -0.06747769f, 0.04445780f, -0.08945142f, 
    0.29740658f, 0.04386921f, -0.00009932f, -0.13950516f, -0.07155748f, 0.06800946f, 0.12837206f, -0.02465018f, 
    -0.41212514f, -0.00992489f, -0.03386528f, -0.14544243f, 0.04893416f, -0.02325236f, 0.02690305f, -0.04704696f, 
    -0.04195199f, -0.23682822f, 0.06630721f, -0.06187662f, 0.16233067f, 0.07358802f, 0.04048980f, 0.10629571f, 
    0.14689167f, 0.10696302f, -0.16998143f, -0.06897246f, -0.26935768f, -0.21595621f, 0.16425698f, -0.30238986f, 
    -0.36905006f, -0.33733481f, 0.21165068f, -0.03716533f, 0.10716501f, 0.38046417f, 0.04318735f, 0.03009617f, 
    0.20724721f, 0.11681745f, 0.32819447f, 0.10983969f, -0.17044526f, -0.07474776f, 0.14845765f, 0.11474264f, 
    0.12469209f, 0.06675779f, 0.11035983f, 0.13185853f, -0.26416141f, -0.10275492f, 0.23197229f, -0.12205630f, 
    0.00402869f, 0.08852147f, -0.02251190f, 0.00953478f, -0.09607498f, -0.60256344f, -0.33473489f, 0.35400769f, 
    -0.03127838f, 0.02495506f, 0.04730698f, 0.11968493f, -0.04936269f, -0.12040785f, 0.12416568f, -0.13014744f, 
    -0.16408668f, 0.33469748f, 0.00641353f, -0.06022479f, 0.14364544f, 0.11501564f, 0.20963658f, -0.01946035f, 
    -0.34124035f, 0.05703802f, -0.18287085f, -0.06624535f, -0.03225164f, 0.01980007f, -0.01618381f, 0.15634476f, 
    0.07822219f, 0.08121911f, -0.28801450f, -0.07478127f, 0.11350414f, 0.14381890f, 0.06687970f, 0.19979806f, 
    0.01992399f, -0.07468181f, -0.19887353f, -0.01288830f, 0.39383346f, -0.04494289f, 0.07983814f, -0.04765461f, 
    -0.20546673f, 0.00169523f, 0.18980373f, -0.21110241f, 0.68418849f, 0.43381348f, 0.26164380f, -0.02700670f, 
    0.00232265f, -0.00857588f, 0.16513711f, -0.02997482f, 0.11385689f, -0.40373066f, 0.39154553f, 0.05045698f, 
    -0.02879367f, -0.03170759f, 0.01568234f, 0.09774170f, -0.20427275f, -0.08002018f, 0.17334346f, 0.00718205f, 
    -0.05055002f, -0.10091779f, -0.07405704f, 0.11638352f, -0.00019052f, -0.04340037f, -0.12081449f, -0.01464780f, 
    -0.01553334f, 0.13897027f, 0.05679694f, 0.23570731f, -0.04257347f, 0.01872360f, -0.16929324f, -0.10470085f, 
    -0.00906178f, 0.02319577f, -0.18117958f, -0.09974368f, 0.32276821f, 0.36274281f, -0.01060794f, -0.04084191f, 
    -0.30037448f, 0.03763098f, 0.13148834f, 0.01901098f, 0.10761142f, -0.07577046f, 0.12363752f, -0.09222589f, 
    -0.04377801f, 0.00823899f, 0.03042394f, 0.01621679f, 0.01326164f, -0.02633307f, 0.00285919f, 0.04897819f, 
    -0.02061615f, 0.00987637f, 0.03346692f, -0.01219903f, 0.00688989f, 0.02596679f, -0.06134870f, 0.03071718f, 
    0.01997928f, 0.00316378f, -0.04064287f, -0.07127931f, -0.00769796f, -0.05310148f, 0.00050897f, -0.03826954f, 
    -0.01461567f, 0.02681415f, -0.05636793f, 0.01061857f, -0.04254638f, 0.00650150f, -0.03528668f, -0.04957631f, 
    -0.01882638f, -0.05975660f, 0.00094064f, -0.02611171f, 0.01657539f, -0.03631072f, -0.05803391f, -0.00204674f, 
    0.04665471f, 0.00655980f, 0.02801399f, 0.01527867f, 0.00996163f, 0.02738048f, -0.01941150f, -0.03716465f, 
    -0.04523502f, -0.00871808f, -0.02769496f, 0.02589131f, 0.02844068f, -0.01228683f, -0.04481521f, 0.01648946f, 
    0.05598897f, 0.04544456f, -0.03377987f, -0.03893232f, -0.01586340f, -0.01466048f, -0.02084349f, -0.05950572f, 
    0.02935194f, -0.01665477f, 0.03799951f, -0.00974327f, -0.02646065f, -0.03448175f, 0.03610155f, 0.03517013f, 
    -0.01194146f, 0.04929366f, -0.02769071f, 0.03319826f, -0.04419630f, -0.02060647f, 0.00627810f, -0.02246225f, 
    -0.00322275f, 0.02411523f, -0.00499653f, -0.02253750f, 0.03693240f, -0.02044007f, 0.00267743f, 0.00300868f, 
    -0.00857282f, -0.00851441f, -0.05215615f, -0.02458275f, -0.02393321f, -0.05571271f, 0.05031225f, -0.01821164f, 
    -0.05691209f, 0.04181243f, -0.04042527f, 0.02591944f, 0.00332290f, 0.02113049f, 0.04475719f, 0.02221337f, 
    -0.00537825f, 0.03374993f, -0.06059330f, 0.01450810f, -0.00974170f, 0.03969522f, 0.02676758f, -0.03915147f, 
    -0.06537580f, -0.03676540f, 0.03017366f, 0.03668547f, -0.04339320f, -0.03881107f, -0.00491224f, 0.05627001f, 
    0.03889915f, 0.03100194f, -0.04390611f, -0.01677733f, 0.03347149f, -0.00598553f, 0.04962752f, 0.00585856f, 
    0.01425386f, 0.00885669f, 0.05831381f, 0.05383734f, 0.02656749f, -0.05386313f, 0.00438886f, -0.06451827f, 
    -0.06511660f, -0.07605959f, -0.02538030f, -0.05300873f, 0.02817981f, -0.00271601f, -0.00165243f, -0.02633103f, 
    0.03564542f, 0.03224618f, 0.01245515f, 0.04061612f, 0.03031240f, 0.01690773f, -0.04525251f, -0.00490002f, 
    -0.01175696f, 0.01541197f, -0.01828432f, 0.04876397f, 0.02490361f, 0.01441648f, -0.02698501f, 0.04742382f, 
    -0.02449711f, -0.03457197f, -0.06484209f, 0.02860655f, 0.01955518f, -0.01428436f, -0.04445994f, -0.05200307f, 
    -0.02649071f, -0.01906530f, -0.01805585f, 0.00035311f, -0.03264586f, -0.01960128f, -0.04791885f, -0.03522391f, 
    0.00694593f, 0.01338631f, -0.03005361f, -0.02702319f, -0.05146226f, -0.00056728f, -0.05361287f, -0.04132814f, 
    -0.02063363f, 0.01862212f, -0.06727084f, -0.04900576f, -0.01756029f, 0.00345211f, 0.02143010f, 0.03107046f, 
    0.01920150f, -0.05817615f, 0.02775386f, -0.04245843f, -0.06373806f, -0.02762523f, -0.04121691f, -0.01731934f, 
    -0.02942964f, -0.02772072f, 0.05157697f, -0.05319367f, 0.01464337f, 0.03174389f, -0.04411064f, -0.03683996f, 
    0.02695624f, -0.00701490f, 0.03589343f, -0.00211259f, -0.03650235f, -0.04122026f, -0.01212993f, -0.04039034f, 
    0.06300127f, 0.04100230f, -0.02224035f, -0.01336088f, 0.03536679f, -0.06360235f, 0.01279479f, 0.02511012f, 
    -0.04066513f, 0.03201659f, -0.04427364f, 0.04344975f, -0.01794641f, -0.06411361f, 0.03204538f, -0.06119547f, 
    0.04131867f, 0.01307145f, -0.04207941f, -0.04978688f, -0.00423890f, -0.05086370f, -0.01330234f, -0.02903106f, 
    0.01941427f, 0.00153642f, -0.02747815f, -0.00488202f, 0.00980080f, 0.01326902f, -0.01820987f, -0.04535764f, 
    0.02459739f, 0.00400806f, 0.03956569f, 0.04506995f, 0.01694038f, 0.00017200f, 0.01859610f, 0.00449788f, 
    -0.00313590f, 0.02569201f, 0.02980064f, -0.03724794f, -0.05642989f, -0.02930224f, 0.01671168f, 0.02454040f, 
    -0.00343335f, -0.05395203f, -0.02460713f, -0.01951184f, 0.00873984f, -0.03354986f, -0.05167424f, -0.05415639f, 
    -0.03581922f, -0.01994603f, 0.01510939f, 0.04496643f, -0.00378571f, 0.03699517f, 0.02692405f, -0.01890040f, 
    -0.01498483f, 0.04690166f, -0.03456747f, -0.05364646f, -0.01009235f, 0.00876145f, 0.03592292f, 0.05107545f, 
    -0.40158311f, -0.04039555f, 0.20310508f, -0.03827476f, -0.08730742f, 0.01896297f, 0.14833750f, 0.03512001f, 
    0.01539063f, -0.14077288f, -0.32277301f, 0.18818250f, -0.05859984f, -0.00904084f, -0.07701271f, 0.00154106f, 
    0.15284783f, 0.32155216f, 0.14990023f, 0.71822864f, -0.09673036f, -0.43339819f, 0.03174737f, 0.13856488f, 
    0.11577364f, 0.07868588f, -0.04284644f, -0.07682668f, 0.11756629f, -0.14441834f, -0.07819068f, -0.03859407f, 
    0.03206769f, 0.11560406f, 0.02643411f, -0.09048299f, -0.07093561f, 0.25171405f, 0.25974736f, -0.18364879f, 
    0.04341592f, -0.02113403f, 0.03860054f, 0.20501077f, -0.15421270f, 0.18356037f, -0.30889273f, -0.01401769f, 
    0.10225095f, -0.15403080f, -0.21234974f, -0.05299428f, -0.03375200f, 0.24165016f, 0.27990285f, -0.00101729f, 
    0.14176492f, 0.04612849f, -0.04501766f, -0.15831259f, -0.05851451f, -0.13071689f, 0.20765918f, -0.11300032f, 
    0.09140033f, -0.02343332f, 0.03183370f, -0.00408408f, -0.01661316f, -0.32292169f, -0.03104535f, -0.24443859f, 
    -0.16533716f, 0.02372761f, 0.09102109f, 0.13521247f, 0.04163178f, -0.14389569f, -0.01788616f, -0.18899256f, 
    -0.07788018f, -0.08278950f, 0.18751223f, -0.13429219f, -0.05729842f, 0.10989891f, -0.11005762f, -0.26292142f, 
    -0.04523267f, -0.20510675f, -0.04490291f, 0.36782306f, -0.13466121f, -0.05934015f, -0.01958312f, 0.03453486f, 
    -0.00044757f, -0.09668157f, -0.17517734f, 0.08618199f, 0.39838612f, 0.34768978f, -0.24395522f, 0.09768184f, 
    0.20931444f, 0.10238537f, 0.03946527f, -0.03072217f, 0.09493451f, -0.06530338f, -0.32444224f, -0.13413306f, 
    0.01984352f, -0.24967338f, 0.05778351f, -0.12673377f, -0.07888407f, 0.01618354f, 0.14379673f, 0.00381140f, 
    -0.07939114f, -0.01603287f, 0.07675294f, 0.07047436f, 0.10144051f, 0.06400774f, -0.17720412f, 0.18683799f, 
    0.03739344f, 0.01668206f, 0.00536328f, 0.03853313f, 0.01143951f, 0.15190575f, -0.23580296f, -0.08629303f, 
    -0.23007683f, -0.14525983f, 0.16046855f, 0.11101986f, 0.19005838f, -0.01770336f, 0.06264456f, -0.08830346f, 
    -0.10784045f, 0.20796096f, 0.20528044f, 0.00919569f, 0.18318011f, 0.09086418f, 0.00859775f, -0.25473729f, 
    -0.19276892f, -0.19199391f, -0.03142088f, -0.19521302f, 0.13485570f, 0.17675340f, 0.24045031f, 0.04930356f, 
    0.13296045f, -0.11395881f, 0.14471301f, 0.33094621f, -0.14188674f, 0.05257568f, -0.20122375f, -0.05435183f, 
    -0.13769057f, -0.05718222f, -0.24691598f, -0.39166808f, 0.24706455f, 0.17698739f, -0.23511893f, -0.06462826f, 
    0.09455138f, 0.08190335f, 0.13438818f, -0.06938476f, 0.25924763f, -0.31662270f, 0.07294867f, 0.12683313f, 
    -0.03293594f, -0.07230356f, 0.05055932f, -0.17921507f, 0.16134496f, 0.38802654f, 0.18640804f, -0.16157506f, 
    0.03178421f, 0.03900792f, -0.13890991f, 0.09498105f, -0.09113630f, 0.12282178f, -0.11064331f, 0.14702389f, 
    0.16790043f, -0.16649747f, 0.03605029f, 0.06021889f, -0.33739901f, 0.12160914f, -0.07494877f, 0.22511406f, 
    -0.14894778f, 0.35840267f, 0.14907993f, -0.00729675f, 0.30496418f, 0.01414268f, 0.00038409f, -0.04467785f, 
    0.25736725f, -0.05476795f, 0.52216208f, 0.07667571f, 0.02324861f, -0.03263358f, -0.15222445f, -0.10506975f, 
    0.06438082f, 0.03752037f, 0.07615971f, 0.04197297f, 0.09990031f, 0.28861895f, -0.25354290f, 0.08370631f, 
    0.00086555f, -0.24930148f, 0.33515039f, 0.40263462f, -0.56396002f, -0.19833596f, -0.14310235f, 0.11685944f, 
    -0.11157952f, -0.10522708f, -0.07691143f, -0.12421827f, -0.00780988f, 0.32935607f, -0.05394708f, 0.16827857f, 
    -0.17034347f, 0.09086354f, -0.03849457f, 0.18370916f, 0.05370874f, 0.04274737f, 0.04452486f, -0.02697311f, 
    0.00038533f, 0.06211026f, 0.07445073f, 0.20343174f, -0.07584383f, -0.22291516f, 0.11281241f, -0.01737225f, 
    -0.04538663f, -0.02573963f, -0.06486914f, -0.03489231f, 0.05424671f, -0.17076968f, -0.07939545f, 0.24727191f, 
    -0.10398695f, 0.20216316f, 0.06742095f, -0.19716601f, 0.00273617f, 0.02160108f, -0.15559165f, 0.23381396f, 
    0.11504140f, 0.02537276f, 0.03141172f, -0.01441944f, 0.06341319f, 0.06203115f, -0.09903776f, -0.00048335f, 
    -0.05884326f, 0.01234482f, 0.02344729f, -0.05746651f, -0.04739641f, -0.00422264f, -0.00154454f, 0.05326403f, 
    -0.03722331f, 0.02222130f, 0.04073406f, -0.04393775f, 0.01467451f, -0.01933241f, -0.06233360f, -0.02013989f, 
    -0.07196258f, 0.01037723f, -0.00817085f, -0.01931671f, 0.05048026f, 0.02707651f, -0.00334272f, -0.00816151f, 
    -0.04970502f, -0.00791564f, -0.00354655f, 0.02870768f, -0.04213941f, 0.00306047f, -0.00172169f, -0.05247437f, 
    -0.03381089f, 0.05007510f, -0.02254941f, -0.06955817f, 0.04163967f, -0.00578205f, -0.04712974f, -0.02196440f, 
    0.04532716f, 0.03816218f, 0.02692269f, 0.03130986f, -0.02223780f, -0.01914680f, -0.02651045f, -0.02301791f, 
    -0.06659626f, -0.04522802f, -0.02130087f, -0.03480238f, -0.02409648f, 0.01365792f, -0.04533324f, -0.02169158f, 
    0.03603273f, -0.05252787f, -0.04038214f, -0.01211093f, 0.03078879f, -0.00537316f, -0.01841993f, -0.03619245f, 
    0.04238409f, -0.00105773f, 0.01064974f, -0.03479824f, 0.05009209f, -0.02827026f, -0.02319988f, -0.04318704f, 
    -0.01190823f, -0.03025649f, 0.00532624f, 0.01723080f, -0.02676415f, 0.03468766f, 0.03946480f, -0.00301206f, 
    -0.05338382f, -0.03733893f, -0.04046996f, -0.00933892f, 0.01392983f, 0.01464638f, -0.03010960f, -0.03253721f, 
    0.02139722f, 0.00634662f, 0.05187910f, 0.00495259f, -0.02463109f, 0.03131076f, -0.01059990f, -0.05565000f, 
    -0.02245020f, 0.05251699f, -0.01532755f, 0.01312529f, -0.05862709f, 0.03213511f, -0.01179555f, -0.04960994f, 
    0.05334521f, -0.06679302f, -0.02234995f, 0.03623349f, -0.02657428f, -0.00418662f, -0.01392844f, 0.04128413f, 
    -0.01866533f, -0.01538748f, -0.05537754f, -0.05057633f, -0.04763918f, -0.04734149f, 0.04902323f, -0.01898884f, 
    -0.01228577f, 0.00750759f, -0.00102185f, 0.03386369f, -0.05873078f, -0.05365813f, 0.01344324f, -0.00775925f, 
    0.04206538f, -0.06567813f, -0.05882243f, 0.04447507f, 0.02091977f, -0.03879805f, -0.03564372f, -0.06381659f, 
    -0.05770651f, -0.03736666f, -0.00241962f, 0.02415088f, 0.01287521f, 0.01849203f, -0.05544621f, 0.00513841f, 
    0.00315787f, 0.01075678f, -0.00101908f, 0.02351878f, -0.01759875f, -0.03811083f, -0.06738477f, 0.01040842f, 
    0.02158219f, -0.05094479f, -0.05430404f, -0.03558980f, 0.03582210f, 0.02541288f, 0.01047420f, 0.05175468f, 
    0.02331298f, -0.02515540f, -0.04178971f, 0.03466444f, 0.03419071f, 0.01701760f, 0.04883550f, 0.04654482f, 
    0.02857599f, -0.01029975f, 0.01659621f, -0.00570168f, -0.05596706f, 0.03530150f, -0.02432926f, 0.01778325f, 
    -0.03779637f, -0.02978321f, 0.02147583f, 0.02802651f, -0.03489330f, 0.04055459f, -0.03027503f, 0.01681851f, 
    -0.01678283f, 0.00920323f, -0.04302855f, -0.01658912f, -0.00649524f, -0.05975458f, -0.04572868f, 0.01089514f, 
    0.01254779f, 0.02740297f, 0.02206608f, -0.04050243f, -0.01683603f, 0.00279944f, -0.06046336f, -0.06517086f, 
    0.01414070f, 0.02490659f, -0.04031382f, 0.04356118f, -0.01969773f, 0.02964053f, 0.02727457f, -0.03096619f, 
    -0.05183006f, 0.03462614f, -0.05128270f, 0.04212431f, 0.03715005f, -0.02067152f, 0.03118034f, -0.06727969f, 
    -0.04566387f, 0.04246553f, 0.01716388f, -0.00121153f, 0.02439884f, 0.03377757f, 0.00370560f, -0.02640711f, 
    0.02765405f, -0.02773230f, 0.02515224f, -0.00647510f, 0.03164762f, -0.05238604f, -0.04492475f, 0.00570567f, 
    -0.00988444f, -0.00803405f, -0.05416293f, -0.05437101f, 0.04743579f, -0.00979227f, -0.01855726f, 0.04356837f, 
    -0.06915222f, -0.06319505f, -0.02979992f, 0.02436618f, 0.01566476f, -0.05562227f, 0.00980496f, -0.01235295f, 
    -0.03947537f, 0.05717964f, 0.05257252f, -0.00969520f, 0.04771437f, -0.04229704f, 0.02950936f, -0.01732281f, 
    0.06020420f, -0.03999360f, 0.02558011f, 0.05017925f, 0.06199495f, -0.03544404f, 0.02915590f, 0.03001249f, 
    0.03756129f, -0.04902447f, -0.04677632f, 0.02936604f, -0.01999679f, 0.02971564f, 0.04585795f, 0.04274131f, 
    0.05214645f, -0.00310657f, -0.01759676f, 0.04791576f, 0.01645217f, -0.04514678f, -0.05909695f, -0.00496900f, 
    0.01179071f, 0.03240559f, -0.05867844f, 0.00526691f, -0.04711080f, -0.02890073f, 0.03402389f, -0.01087905f, 
    0.33577001f, -0.01369573f, 0.15560032f, -0.40602750f, -0.16721751f, 0.02517460f, -0.23656781f, 0.05480165f, 
    0.24284957f, -0.42809427f, -0.26361510f, -0.32489330f, 0.01103277f, 0.07494482f, -0.11582291f, -0.06102388f, 
    -0.32826272f, -0.13348614f, 0.04537001f, -0.41556072f, 0.05861745f, -0.02321347f, -0.03556896f, -0.00880081f, 
    -0.02065758f, 0.19014829f, -0.02172222f, 0.38520887f, 0.00335720f, 0.04682063f, 0.02724875f, 0.10006321f, 
    0.09691411f, 0.10790190f, -0.00361429f, -0.00701228f, 0.37961805f, 0.26090533f, 0.43931597f, -0.17867322f, 
    -0.07333072f, -0.16026950f, -0.23473266f, 0.11878121f, 0.13586955f, -0.04898398f, -0.05431936f, -0.09598400f, 
    0.02913442f, -0.05644433f, 0.03541337f, 0.13362175f, 0.17396216f, 0.07934790f, 0.31390095f, 0.10095076f, 
    -0.01854663f, -0.06757515f, -0.21148685f, -0.10048773f, 0.06098646f, 0.08187433f, 0.06388585f, 0.13598807f, 
    0.16222054f, 0.04903952f, -0.06040490f, 0.10199694f, -0.02119805f, 0.21794133f, 0.17220616f, 0.04354770f, 
    -0.06702065f, -0.22324893f, 0.00539864f, 0.06674354f, 0.09457639f, 0.10539611f, 0.06937026f, 0.06414895f, 
    -0.04758632f, -0.10974284f, -0.18340857f, -0.18445393f, -0.04112553f, 0.18661100f, 0.04452181f, -0.05414504f, 
    0.04857606f, 0.13656442f, 0.23947422f, 0.23559476f, 0.40621436f, 0.00078204f, 0.13852599f, 0.03855078f, 
    -0.02661223f, 0.17917573f, -0.09354376f, 0.76971424f, -0.06071771f, 0.12323897f, -0.04006272f, -0.10159635f, 
    -0.07281089f, -0.02223919f, 0.03915638f, 0.10229708f, -0.20892796f, -0.16910967f, -0.26265165f, 0.10532682f, 
    0.07870443f, -0.08773119f, 0.13972442f, 0.06780732f, -0.10682156f, 0.52750194f, 0.31492838f, 0.36637622f, 
    -0.14561674f, -0.08034295f, -0.06192677f, -0.23250626f, -0.12422801f, 0.19198239f, 0.43539038f, -0.16688254f, 
    0.23837321f, -0.07670795f, 0.07757692f, -0.44389343f, -0.04143056f, 0.13994721f, -0.02047057f, 0.17466535f, 
    -0.18538207f, -0.09028036f, -0.01522832f, 0.03778369f, -0.19594641f, 0.06245645f, -0.11068422f, 0.01383486f, 
    -0.03458935f, -0.15145651f, -0.19072658f, -0.02438278f, 0.15093414f, -0.18173246f, 0.11782333f, 0.05751534f, 
    -0.01479412f, -0.13485259f, 0.07982189f, -0.03628768f, -0.28473762f, -0.03858710f, -0.17465682f, -0.03757922f, 
    -0.31979743f, 0.18336236f, 0.18619452f, 0.07637617f, 0.36536554f, 0.00382829f, 0.05876810f, -0.19321290f, 
    -0.01897470f, 0.19010550f, 0.01309476f, 0.71443224f, -0.12040270f, -0.08811442f, -0.11838463f, 0.10583656f, 
    0.06928134f, -0.04940604f, 0.07169293f, -0.10492194f, 0.42002705f, 0.25270668f, 0.16694833f, -0.07772203f, 
    -0.09370489f, -0.06101286f, 0.08158107f, 0.01847132f, 0.01614299f, -0.45644683f, -0.43536535f, -0.07051459f, 
    0.10384289f, 0.09823150f, -0.00073143f, 0.03635535f, 0.01845188f, -0.10081527f, -0.08653484f, -0.21587960f, 
    -0.37773913f, -0.25653234f, 0.08812983f, -0.01599726f, -0.04550748f, -0.14457108f, -0.08201444f, 0.19511589f, 
    0.12634222f, -0.01603151f, 0.00506628f, -0.00091483f, -0.15940817f, -0.00340355f, -0.21544068f, 0.19404212f, 
    0.01129249f, 0.05050985f, -0.07912800f, -0.02082205f, -0.08707664f, -0.09239487f, 0.08239385f, 0.13176785f, 
    0.06211045f, 0.18927504f, -0.34818888f, -0.43635467f, 0.08789233f, 0.15324463f, 0.07725818f, 0.00327878f, 
    0.02241771f, 0.04762492f, -0.42117387f, -0.50135732f, 0.79838455f, -0.03952885f, -0.13937601f, -0.40541410f, 
    0.00014359f, -0.00839568f, 0.01570541f, -0.06885992f, -0.08112880f, -0.60526842f, -0.08373737f, 0.02303911f, 
    -0.06206737f, 0.10427510f, -0.10353149f, -0.02952826f, 0.40624261f, 0.16326347f, 0.29508188f, -0.15642264f, 
    -0.00297636f, -0.06518977f, -0.04586445f, 0.15011548f, 0.04600765f, 0.12737478f, 0.02316461f, -0.11215705f, 
    -0.24116325f, -0.02165481f, -0.05698201f, -0.08948497f, -0.02582155f, 0.27059007f, -0.03636660f, -0.25719386f, 
    -0.06195952f, -0.12050642f, -0.09940360f, -0.10764508f, 0.11019331f, 0.11707602f, -0.20706774f, 0.11464148f, 
    -0.23722006f, -0.09764771f, 0.06371631f, -0.13528746f, 0.19557822f, 0.10123423f, 0.12517475f, 0.01557676f, 
    0.03621942f, 0.30095771f, 0.12903984f, 0.15451762f, -0.08548164f, 0.02637148f, -0.02391573f, -0.03797973f, 
    -0.10005303f, -0.10570946f, -0.06260015f, -0.00738601f, -0.19153056f, 0.00837332f, 0.02681263f, 0.18523963f, 
    -0.05257968f, -0.14511722f, 0.16397174f, 0.14227714f, -0.19188219f, 0.04528217f, -0.15327458f, -0.36672184f, 
    0.12197012f, -0.09931486f, 0.00872945f, -0.01841167f, 0.04201508f, 0.03330088f, -0.12521763f, -0.08433431f, 
    0.02806750f, 0.05397598f, 0.00439999f, 0.10293130f, -0.07033874f, -0.07323606f, -0.06948670f, -0.03050132f, 
    -0.18384278f, 0.08868760f, 0.02605920f, 0.06529655f, -0.06402697f, 0.11143904f, -0.02325682f, 0.01777642f, 
    0.16159748f, -0.00511338f, 0.21682623f, 0.23811096f, 0.15490940f, 0.05283360f, 0.03325678f, -0.34523389f, 
    -0.17218512f, -0.12191927f, -0.29162300f, 0.01123633f, 0.15890184f, 0.07183266f, 0.11614711f, -0.04711072f, 
    -0.09953941f, -0.00938128f, -0.02923850f, -0.09951610f, 0.03005908f, 0.31891078f, -0.13018249f, 0.20193495f, 
    -0.14804706f, -0.28008479f, -0.47942957f, 0.13953190f, 0.06006801f, 0.16786776f, 0.08932413f, -0.03265701f, 
    0.01856665f, -0.12696095f, -0.20619644f, 0.00098186f, -0.21895400f, 0.09192010f, 0.05977610f, 0.08049289f, 
    0.09800610f, -0.00806361f, 0.02269206f, -0.07367965f, -0.09114096f, 0.02126102f, -0.04929760f, 0.13700870f, 
    0.15394601f, 0.22329633f, 0.07197644f, -0.02177200f, 0.09712749f, -0.15613352f, -0.08648276f, 0.06482708f, 
    -0.00493877f, 0.08553072f, 0.14255546f, 0.05553126f, -0.00600161f, 0.13249637f, 0.11934771f, -0.00999026f, 
    0.24198197f, 0.10270579f, 0.15966919f, 0.20843470f, 0.05380411f, 0.02282124f, -0.07909217f, -0.09094036f, 
    -0.19139612f, -0.18866223f, -0.26598924f, -0.13406242f, 0.00869712f, -0.04927817f, 0.04989612f, 0.02908303f, 
    0.15703692f, -0.09134660f, -0.19543706f, 0.06919155f, 0.09721642f, -0.00631335f, -0.00677165f, -0.11764647f, 
    0.18985099f, 0.01898756f, 0.04002668f, -0.22919650f, -0.02250309f, 0.05849537f, 0.01946686f, 0.05487213f, 
    0.38248563f, -0.55401939f, -0.61774337f, 0.08555106f, -0.08631293f, -0.18920468f, -0.31234321f, 0.08783054f, 
    -0.03410392f, -0.37646383f, -0.03343076f, -0.11736145f, -0.39879182f, -0.08278697f, -0.03601088f, 0.30018431f, 
    -0.12258939f, -0.33787519f, 0.06671876f, -0.00564510f, -0.25333795f, 0.08379894f, 0.15234120f, 0.21877141f, 
    0.03018132f, 0.06024900f, 0.19772044f, -0.05697791f, -0.18215996f, -0.26685441f, 0.04709233f, -0.01820808f, 
    -0.04351950f, -0.05671076f, 0.05042534f, 0.26158971f, -0.05039950f, -0.18435775f, -0.55651885f, -0.28020522f, 
    0.06474850f, 0.05671929f, 0.09880374f, 0.01237283f, 0.03101141f, 0.09172016f, -0.13305089f, -0.17510492f, 
    -0.06139704f, -0.22140604f, -0.08716995f, 0.23758107f, 0.09625933f, 0.01584545f, -0.29039273f, -0.21748893f, 
    -0.03939583f, 0.13470320f, -0.05420063f, 0.04150945f, 0.44837099f, 0.03320596f, 0.20591652f, 0.24809410f, 
    -0.36125073f, -0.29331297f, -0.04093731f, -0.23953895f, -0.22088568f, -0.16797879f, -0.08440594f, 0.11056636f, 
    0.29057276f, -0.50125062f, -0.75398564f, 0.05004331f, 0.01564996f, -0.03852646f, -0.05722519f, 0.08518544f, 
    0.06657771f, -0.32613140f, -0.21234407f, -0.38750756f, -0.11364725f, 0.03611321f, 0.13003738f, -0.05419612f, 
    -0.30184072f, 0.09231384f, 0.39696375f, 0.13098745f, -0.18258856f, 0.06053891f, -0.06325861f, 0.34051993f, 
    -0.07260537f, 0.07595216f, 0.05745837f, -0.47978801f, -0.09889714f, 0.00211631f, -0.08327117f, 0.06489819f, 
    0.18964668f, 0.28754002f, -0.24441575f, -0.03556407f, -0.02344824f, 0.05360943f, 0.10990752f, -0.32751647f, 
    -0.26197034f, -0.12894830f, 0.06334265f, -0.07807261f, -0.05134657f, -0.00138750f, 0.25944653f, 0.16216153f, 
    0.10680653f, -0.02127341f, -0.07446759f, -0.12796132f, 0.22237027f, 0.26914877f, -0.05730426f, -0.34755033f, 
    -0.23216808f, -0.14441893f, 0.03153501f, 0.00127988f, 0.11126315f, -0.30926001f, 0.04074964f, 0.18460348f, 
    0.18837260f, -0.11793557f, 0.05326687f, -0.07583816f, 0.08907671f, 0.12514161f, 0.21979673f, 0.23456624f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.14421450f, 0.26280609f, 0.15028688f, -0.21025559f, 0.03546345f, 0.03879731f, -0.10318384f, -0.06098140f, 
    -0.08803826f, -0.07820128f, 0.21274187f, 0.00640447f, 0.33024114f, 0.20201096f, 0.30398583f, 0.12543516f, 
    0.00599239f, -0.05379139f, -0.10649431f, 0.20630702f, -0.06219225f, 0.17603679f, -0.02142220f, 0.39603561f, 
    -0.04718565f, -0.04084398f, 0.16380966f, -0.02217842f, -0.10270441f, -0.06188795f, 0.03309491f, 0.28819796f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.17048232f, -0.22548099f, 0.01983376f, 0.52476126f, -0.15692003f, -0.44263244f, 0.04764859f, 0.09014028f, 
    0.29278830f, 0.03158315f, -0.29128739f, 0.32536891f, -0.53742510f, -0.70042932f, 0.23578243f, -0.44825357f, 
    -0.03349100f, -0.12684423f, 0.51372039f, 0.09908025f, 0.20870170f, -0.08964057f, 0.44961968f, -0.44206816f, 
    -0.01312618f, -0.01040236f, -0.39383936f, 0.15724020f, -0.06810746f, 0.08484794f, 0.03939701f, 0.08960071f, 
    0.09577811f, 0.14052233f, 0.18882281f, 0.57343858f, 0.08000323f, -0.42985576f, -0.20210204f, -0.13834476f, 
    0.04299542f, -0.06217167f, 0.12370200f, 0.09177204f, -0.38711399f, 0.11887562f, 0.13079588f, 0.21979684f, 
    -0.14191063f, 0.12393761f, -0.28088203f, -0.12505034f, -0.36722559f, 0.34073767f, 0.75335729f, 0.17669448f, 
    -0.15823282f, -0.07652809f, -0.16086088f, 0.14577664f, -0.35887644f, 0.02169872f, 0.05777329f, 0.31371903f, 
    0.07041980f, 0.03231793f, -0.17721066f, -0.33424929f, -0.04684363f, -0.06566303f, -0.18069308f, -0.04769776f, 
    -0.34006470f, 0.08168308f, 0.17744963f, -0.23712544f, 0.30270731f, 0.23820788f, 0.10255974f, -0.80517429f, 
    0.13761947f, 0.07631315f, -0.96429169f, 0.59045976f, 0.31576276f, 0.62252730f, -0.15887463f, -0.83781642f, 
    -0.16253699f, 0.11930886f, -0.01501291f, 0.10467990f, -0.20183212f, -0.05910625f, -0.22865371f, 0.03113165f, 
    -0.88721704f, -0.12743929f, 0.09423164f, 0.14196646f, 0.17177483f, 0.33013171f, 0.14418897f, -0.15258220f, 
    -0.26985341f, 0.11345047f, -0.03789534f, 0.21263351f, -0.49013048f, 0.60012138f, 0.13695885f, -0.41289887f, 
    -0.10753780f, -0.03657165f, -0.39511827f, -0.87339395f, 0.17300092f, 0.19869305f, 0.00513885f, -0.62308413f, 
    -0.13127601f, 0.01202782f, -0.31824228f, -0.02604909f, 0.50663394f, 0.02811604f, -0.89882439f, -0.05237544f, 
    0.21240903f, 0.07651670f, 0.04399118f, -0.16303307f, -0.11481263f, -0.35215867f, 0.52903396f, -0.17037576f, 
    0.00050926f, 0.09203712f, -0.24122132f, -0.42761320f, 0.34899804f, -0.04829175f, 0.34086397f, -0.16872071f, 
    -0.13090786f, -0.11726207f, 0.30009782f, -0.34324232f, 0.19104575f, -0.19452302f, -0.24615772f, -0.04046419f, 
    0.09272183f, 0.09789201f, -0.37376091f, -0.09493832f, 0.24052940f, 0.13918394f, 0.21491560f, -0.88865453f, 
    0.00035494f, -0.48028195f, -0.23619105f, -0.04372559f, 0.02456557f, -0.20967662f, -0.31602305f, 0.11601156f, 
    0.30762336f, -0.00375791f, 0.24266630f, 0.00056726f, 0.13040692f, 0.16246553f, 0.04172098f, 0.00737837f, 
    0.15763786f, -0.11403725f, 0.48883083f, 0.05364388f, 0.03309684f, 0.29205617f, -0.43262014f, 0.14680707f, 
    0.16330974f, 0.00282237f, 0.23977132f, 0.12091084f, -0.10953241f, -0.11174719f, 0.14790478f, -0.25595292f, 
    -0.54390723f, 0.45714995f, 0.37296930f, -0.42801759f, -0.10881918f, 0.33696201f, -0.78054953f, -0.14161007f, 
    -0.39442408f, -0.13267452f, -0.12293074f, -0.16067450f, 0.42174664f, -0.11779007f, -0.10847014f, -0.65275681f, 
    -0.12701833f, 0.00454739f, -0.44939759f, 0.50196797f, 0.03245763f, -0.83144617f, -0.64325547f, 0.38080892f, 
    0.08372739f, 0.05761744f, -0.30256790f, 0.00674497f, 0.24217385f, 0.02573311f, -0.41409197f, 0.14905339f, 
    -0.26452079f, -0.17227866f, 0.53254664f, -0.32026476f, 0.04120417f, 0.32787561f, 0.30712387f, -0.17267607f, 
    0.03885180f, -0.11060121f, -0.13967445f, -0.06051874f, -0.27066445f, -0.52160770f, -0.47791320f, 0.46667689f, 
    -0.13441655f, -0.12624663f, -0.25163001f, 0.19182290f, 0.09097870f, -0.04149256f, 0.19800012f, -0.23838252f, 
    -0.09355942f, -0.11885846f, -0.09928584f, -0.09959137f, -0.06959233f, -0.14140223f, 0.16528332f, -0.64190125f, 
    -0.13799819f, -0.28908437f, -0.12607190f, -0.27264741f, 0.15000550f, 0.12972504f, -0.37167868f, 0.08655193f, 
    0.13171245f, 0.13134362f, 0.23678768f, 0.43164536f, 0.16285248f, 0.26254135f, -0.42464650f, 0.49477839f, 
    0.03592895f, 0.10479247f, -0.50424588f, -0.31908399f, -0.25082430f, -0.88116902f, 0.30449712f, -0.42475480f, 
    0.04649765f, 0.07943082f, 0.36165524f, -0.06229166f, -0.12568119f, -0.05174559f, -0.37430125f, 0.72352844f, 
    -0.10486144f, -0.18955095f, -0.20584247f, -0.91307288f, -0.10121481f, 0.11369104f, -0.45301083f, -0.07472932f, 
    -0.41483602f, -0.09114893f, -0.31654620f, -0.18478324f, 0.64659029f, -0.16653231f, 0.67367822f, 0.09447834f, 
    0.02296265f, -0.05411638f, 0.01817738f, -0.50532728f, 0.27523395f, -0.04769102f, -0.16764370f, 0.84206307f, 
    -0.09240606f, 0.13466743f, 0.34898090f, 0.15751006f, 0.33557129f, -0.12187179f, -0.32445630f, -0.74889487f, 
    0.75058317f, -0.12865172f, 0.10132108f, 0.05881824f, -0.03308111f, -0.27068913f, 0.44901118f, -0.16823186f, 
    0.08653391f, 0.03784736f, 0.38755086f, 0.33158669f, -0.18398207f, 0.18225706f, -0.44001371f, -0.42624742f, 
    -0.17062433f, 0.10471821f, -0.86443520f, -0.04453338f, -0.42084476f, -0.52048033f, -0.69381934f, 0.37858513f, 
    0.10549469f, -0.08805270f, -0.08445341f, 0.00831083f, 0.04371589f, -0.11432285f, -0.80437857f, -0.29731682f, 
    -0.50764751f, 0.46015283f, -0.81552494f, -0.04561863f, -0.07125110f, 0.28089416f, -0.30738345f, -0.01313207f, 
    -0.51779890f, 0.07916614f, 0.20773953f, -0.36456969f, -0.49444443f, -0.01446455f, -0.38437858f, -0.05377334f, 
    0.14073853f, 0.06246089f, -0.43811306f, 0.05048582f, 0.03991782f, -0.31057587f, -0.54643756f, -0.01026054f, 
    0.01289004f, -0.14941847f, 0.28268766f, -0.07820164f, 0.03332204f, 0.15083128f, 0.87471551f, -0.20097645f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.30082577f, 0.08294368f, 0.13374577f, 0.11634618f, -0.18839264f, -0.24184883f, 0.02778405f, -0.21724209f, 
    0.10422495f, 0.20077486f, 0.10755755f, 0.00571092f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
