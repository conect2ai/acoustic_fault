#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.21036027f, -0.32175153f, 0.25705531f, -0.34849313f, 0.48196766f, -0.50371730f, -0.03767716f, 0.04528438f, 
    0.10267937f, 0.18783745f, -0.19225544f, -0.48756343f, 0.03643056f, 0.43162492f, -0.23713644f, -0.31028023f, 
    0.24256772f, 0.09265683f, 0.57371092f, 0.11850625f, 0.12314488f, 0.63654751f, 0.23398291f, 0.23827937f, 
    0.23850438f, 0.07590770f, -0.19171333f, -0.50346988f, -0.40481961f, -0.45926458f, -0.02840605f, 0.46781439f, 
    0.55970240f, -0.08896288f, -0.08386035f, 0.20359035f, 0.40050694f, -0.28815052f, 0.44670457f, -0.19028887f, 
    0.15276511f, -0.08917229f, -0.47232798f, 0.12016756f, 0.12270673f, 0.36314970f, -0.46892613f, -0.04802985f, 
    -0.62403423f, -0.05031847f, 0.10243484f, -0.00356272f, 0.03517893f, 0.06093672f, -0.42181587f, 0.21450423f, 
    -0.36017299f, 0.00760525f, 0.53554165f, -0.55066794f, 0.20045641f, -0.19771665f, -0.29090983f, -0.18600969f, 
    0.44906214f, -0.19473855f, 0.02655333f, 0.52659196f, 0.31296983f, -0.05465994f, -0.13290609f, -0.08626808f, 
    0.22893529f, 0.52193260f, -0.08857715f, -0.33997050f, 0.27372232f, -0.44524696f, 0.14177354f, 0.08472091f, 
    0.06765106f, 0.56403071f, 0.55798370f, 0.49953568f, -0.50737619f, -0.29655692f, -0.32237074f, 0.03212508f, 
    -0.00109409f, 0.14652699f, -0.66664386f, -0.01280515f, 0.07385470f, 0.37233537f, 0.40423316f, 0.29631606f, 
    0.18338670f, -0.20946622f, -0.07030848f, 0.52701551f, 0.51341283f, 0.54280049f, 0.40311271f, 0.29309112f, 
    0.24899571f, -0.14423750f, 0.42258921f, 0.13423666f, 0.76708233f, -0.40943834f, -0.40724948f, 0.14811641f, 
    -0.23826520f, -0.24611625f, 0.13955729f, -0.16794239f, 0.22674111f, -0.49313587f, 0.37683466f, 0.17366019f, 
    -0.19896829f, 0.00058829f, 0.31428710f, 0.29192236f, 0.05102266f, -0.27796069f, 0.19992910f, 0.48772174f, 
    -0.34483436f, 0.25362262f, -0.41076767f, -0.04920498f, 0.08835869f, 0.24834208f, 0.32641605f, -0.59033597f, 
    -0.49669325f, -0.65268320f, 0.11950464f, -0.20991851f, 0.13857679f, -0.13381304f, -0.07270793f, -0.26256633f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.31044537f, -0.16042998f, -0.65940934f, -0.00349661f, 0.22937627f, -0.20667006f, 0.15571007f, -0.33460081f, 
    0.05117412f, 0.15068236f, -0.06190358f, 0.43289074f, -0.39888856f, -0.21273296f, -0.16455279f, -0.39623737f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.07342366f, 0.02929826f, -0.02327966f, -0.06905622f, -0.05060575f, 0.00441184f, -0.00821084f, -0.08310857f, 
    -0.02115023f, 0.05560499f, 0.06254811f, -0.08446828f, 0.03933151f, 0.07053667f, 0.06827230f, -0.02829111f, 
    -0.03377597f, 0.06068388f, 0.04948431f, 0.05021700f, -0.04645186f, -0.08684413f, -0.01786146f, 0.06499220f, 
    -0.00102330f, 0.02722968f, -0.01209268f, -0.07205661f, -0.07666668f, -0.05502886f, -0.01476351f, -0.04497330f, 
    -0.02857940f, -0.03619805f, -0.03359734f, -0.05205890f, -0.03325779f, -0.08360055f, 0.02986112f, -0.05011793f, 
    0.03358718f, 0.03066220f, 0.05444263f, 0.01893074f, -0.05796487f, -0.02400976f, 0.07759366f, -0.06434758f, 
    -0.02273338f, -0.06477449f, -0.05692510f, -0.05889960f, -0.07942767f, 0.03391157f, 0.02124199f, -0.04847212f, 
    0.05857266f, 0.03414963f, 0.01345263f, 0.06081933f, -0.02435448f, 0.02003776f, -0.08446511f, 0.01313715f, 
    -0.00860470f, 0.03020679f, -0.04937750f, 0.02138457f, -0.04837620f, -0.05022525f, -0.08641328f, -0.05149748f, 
    0.01694456f, -0.08516374f, 0.04848860f, -0.07876978f, 0.00457915f, -0.01285579f, -0.08180920f, 0.07572506f, 
    0.00994925f, -0.02765194f, 0.01624304f, -0.08032338f, 0.02565978f, -0.07815778f, -0.08751945f, 0.02085666f, 
    -0.05192367f, 0.06140041f, 0.00180997f, 0.01625721f, 0.05485855f, -0.01420830f, -0.06899111f, 0.05733396f, 
    -0.06335127f, -0.04758624f, 0.04385348f, -0.08592663f, -0.00626785f, -0.01251605f, -0.05344137f, 0.06017622f, 
    -0.01289795f, 0.01254288f, -0.05725065f, -0.05032961f, -0.04411190f, -0.07796769f, -0.08117635f, -0.08892616f, 
    0.04037690f, 0.06042111f, -0.00830446f, -0.06191178f, -0.04142592f, -0.05905811f, 0.07068270f, 0.04924766f, 
    -0.03459509f, 0.07271380f, -0.08576703f, 0.06532946f, -0.00352499f, 0.07814990f, 0.02203849f, 0.03252516f, 
    0.07367554f, 0.04694044f, -0.06665529f, 0.07064608f, -0.01753169f, -0.04014710f, 0.00277118f, -0.01808914f, 
    -0.08717585f, -0.07198323f, 0.00401114f, 0.02195170f, -0.01116787f, 0.03516314f, 0.01637760f, 0.04716411f, 
    0.12920511f, -0.06502780f, 0.23788197f, 0.06170618f, 0.09006561f, -0.00627290f, -0.02566835f, 0.05683513f, 
    0.04125308f, -0.22767441f, -0.04981026f, 0.17848612f, -0.02772953f, 0.04028047f, 0.09073861f, 0.18501779f, 
    0.02413440f, -0.11543185f, -0.26044747f, 0.01636114f, -0.10350896f, 0.15188091f, -0.02159845f, 0.00323442f, 
    0.02579189f, 0.00285422f, -0.09139489f, 0.32875574f, -0.02115219f, 0.16382223f, 0.00125903f, 0.02881446f, 
    0.09104991f, -0.01644238f, 0.02403024f, 0.12435531f, 0.04431273f, -0.18499438f, -0.19173795f, -0.11204199f, 
    0.00347936f, -0.06074528f, -0.07585777f, -0.08517640f, -0.06424055f, 0.18087855f, 0.07521707f, -0.04127855f, 
    -0.02024590f, -0.13837889f, -0.05630387f, -0.01750608f, 0.02015404f, -0.04069997f, -0.05312463f, 0.22476736f, 
    0.00053143f, 0.00152475f, -0.09066471f, 0.08192068f, -0.13826647f, -0.03712432f, -0.08406089f, -0.10588310f, 
    0.11109103f, -0.05293479f, 0.12043113f, 0.01180536f, 0.03162988f, 0.06218978f, -0.09226590f, -0.01855311f, 
    -0.32777640f, 0.01131872f, -0.08143505f, 0.11341567f, -0.13325563f, -0.12066674f, -0.07943585f, -0.02727375f, 
    0.13222814f, -0.03420185f, -0.08254347f, -0.26394725f, -0.23227003f, -0.04243075f, -0.08041456f, -0.08203650f, 
    0.06170117f, -0.05230901f, 0.05911491f, 0.11552506f, 0.02889845f, 0.12517399f, 0.15351284f, 0.17187925f, 
    0.15052499f, 0.08922490f, 0.03122433f, 0.21109158f, 0.11392777f, 0.06999030f, -0.05458917f, -0.03096760f, 
    0.02475187f, -0.00215551f, -0.00497959f, -0.11957823f, 0.21871272f, 0.17496729f, -0.16696824f, -0.15603057f, 
    -0.19886389f, -0.12650384f, -0.05289062f, 0.09703896f, -0.09647094f, 0.01649332f, -0.02633206f, -0.08021913f, 
    0.00127838f, 0.09047750f, 0.02428269f, -0.10994142f, -0.15553534f, -0.21349269f, 0.02095210f, 0.20887811f, 
    0.18248117f, -0.01454950f, 0.07504911f, -0.14793234f, 0.05971326f, 0.07464700f, 0.09754380f, 0.17070627f, 
    0.11139689f, 0.50301874f, 0.28935510f, 0.08410776f, 0.00451691f, -0.01877308f, 0.04628452f, 0.08401436f, 
    0.15258683f, -0.14013068f, -0.17389062f, 0.03955572f, 0.01681932f, -0.01566057f, -0.02083007f, -0.26138255f, 
    -0.08045823f, -0.07943688f, -0.07790062f, 0.03166540f, -0.13350016f, -0.04583802f, 0.13361408f, -0.03526074f, 
    0.00574425f, -0.18320727f, 0.13896090f, 0.05757145f, 0.15419875f, 0.09405512f, -0.11674215f, 0.04280837f, 
    0.05443328f, -0.04847794f, -0.06527529f, 0.23755552f, 0.17843649f, -0.00643187f, 0.02049723f, -0.05637984f, 
    0.19435696f, 0.05454209f, -0.10240067f, 0.12881757f, -0.33865857f, 0.20052554f, 0.03424588f, 0.18630983f, 
    0.10148427f, -0.05532409f, -0.01222611f, 0.14434743f, 0.00079987f, 0.44366267f, -0.21699320f, -0.13328460f, 
    -0.01996166f, -0.01291334f, 0.01824093f, -0.11985784f, 0.13421981f, -0.07915226f, 0.12876831f, -0.01149967f, 
    -0.05796060f, 0.02362820f, -0.04102252f, -0.04749238f, 0.03019311f, -0.00394669f, 0.08698495f, -0.06513228f, 
    0.29680741f, -0.00519435f, 0.07400476f, -0.08534836f, -0.12491457f, -0.09813533f, -0.03172326f, 0.07122840f, 
    -0.03625208f, 0.04246084f, 0.06657164f, 0.11717036f, 0.14710356f, -0.05032847f, -0.03628869f, -0.17605186f, 
    0.04625709f, -0.37293604f, 0.21400082f, -0.26514262f, 0.09072983f, -0.05283893f, 0.13635860f, -0.08429276f, 
    -0.01209460f, -0.01245758f, 0.46020228f, 0.19353800f, 0.01213233f, -0.01083186f, -0.00149398f, 0.06814802f, 
    0.01719323f, 0.04391369f, -0.08515309f, -0.01318561f, -0.00837491f, 0.09003138f, -0.10308372f, 0.00370576f, 
    -0.09545343f, 0.06508511f, 0.23521072f, -0.03196723f, -0.14059831f, 0.01567061f, -0.29457656f, -0.15309727f, 
    -0.05626941f, -0.01362908f, -0.01748861f, 0.01542382f, 0.06359430f, -0.00034702f, -0.02322518f, -0.21399674f, 
    0.06961019f, 0.10571614f, 0.11026252f, -0.19273877f, 0.02468266f, 0.14418131f, -0.39202341f, 0.00750337f, 
    -0.08800229f, -0.06580132f, 0.01290245f, 0.00744904f, -0.18952043f, -0.01253411f, -0.07852309f, 0.07099602f, 
    0.31959671f, 0.25685924f, -0.09863562f, -0.11919701f, -0.18450394f, 0.17186353f, -0.06172549f, 0.17200783f, 
    -0.15311222f, -0.01035171f, -0.15235759f, 0.10220452f, -0.09843630f, 0.21069890f, 0.05019008f, 0.03496740f, 
    -0.16747572f, -0.09328955f, -0.01320402f, 0.10871971f, 0.03319313f, -0.12880579f, 0.02219274f, -0.05185148f, 
    -0.03538615f, 0.04504950f, -0.35142979f, 0.06663180f, 0.06375211f, 0.01367809f, 0.05573291f, 0.02459272f, 
    -0.00986127f, -0.00697199f, -0.14853534f, -0.23537657f, -0.24338776f, -0.24857195f, 0.10816784f, 0.10582847f, 
    -0.00779283f, -0.02354894f, -0.08335898f, -0.05085254f, -0.02633838f, 0.14530875f, -0.02010098f, 0.16213641f, 
    0.10977246f, -0.09422405f, -0.06948559f, -0.06304202f, 0.19385597f, -0.03672241f, 0.01716153f, -0.17155921f, 
    -0.22215296f, -0.00288197f, 0.04213969f, 0.12839252f, 0.07860483f, -0.02019118f, -0.31673211f, -0.08624331f, 
    -0.06417144f, -0.03075274f, 0.15866682f, 0.00878157f, 0.06440884f, 0.03593907f, 0.01193571f, -0.13310911f, 
    -0.12149598f, 0.08905720f, -0.16154985f, 0.03922161f, -0.17200699f, 0.00273468f, -0.04590498f, -0.02064630f, 
    0.05518732f, 0.08783321f, 0.17684904f, -0.00645087f, -0.07829863f, 0.02825461f, -0.06362976f, 0.03827436f, 
    -0.10341377f, 0.03257124f, 0.25397396f, 0.19724762f, 0.00360313f, 0.02255623f, 0.04511631f, 0.07301864f, 
    0.02522525f, 0.13489583f, 0.14063865f, -0.28360632f, -0.32281470f, -0.00654610f, 0.00516728f, -0.04192354f, 
    0.09768161f, -0.14550447f, 0.09140083f, 0.07860223f, 0.18483379f, 0.27767256f, 0.08298744f, 0.01797864f, 
    -0.03377438f, 0.13956021f, 0.00111818f, -0.00677297f, -0.09965187f, -0.29053232f, -0.33541104f, 0.03642208f, 
    0.07795845f, -0.15802620f, 0.06139627f, -0.18127461f, -0.09030649f, -0.01372530f, -0.02350944f, -0.30435884f, 
    -0.02166955f, 0.06334539f, -0.06223868f, 0.05639877f, 0.01835266f, 0.08932889f, -0.13052711f, -0.14107810f, 
    0.06333208f, -0.06008565f, 0.08873127f, -0.11126893f, -0.03856352f, -0.08162387f, 0.02020312f, -0.25315523f, 
    0.15109101f, -0.05184760f, 0.15572639f, -0.02216977f, 0.13985570f, 0.08168116f, 0.08209040f, 0.03638168f, 
    -0.02628427f, 0.17565508f, -0.06169297f, 0.15851425f, 0.10954542f, 0.06879368f, -0.15353419f, -0.05714448f, 
    -0.19334848f, -0.01624358f, 0.02631846f, -0.06068804f, 0.04841077f, 0.00870928f, -0.09121666f, -0.01590405f, 
    0.05678297f, -0.10516594f, -0.32339782f, -0.01695448f, 0.06088561f, 0.17110611f, 0.23856004f, 0.26548356f, 
    0.00741857f, 0.03095394f, 0.01163671f, -0.19776788f, -0.00488616f, -0.05472815f, 0.02713882f, 0.20053110f, 
    -0.07095109f, -0.02249375f, 0.00655839f, -0.01770911f, -0.42165756f, -0.03281455f, 0.17760065f, -0.00691227f, 
    -0.01178867f, 0.06965332f, 0.10681202f, -0.05717031f, -0.05788104f, -0.04367912f, 0.09975553f, -0.06416685f, 
    0.02254701f, -0.06520225f, 0.09696040f, -0.04693463f, 0.09317417f, -0.01635156f, 0.02151796f, -0.24908084f, 
    0.00009449f, -0.18610436f, -0.16531935f, 0.01419899f, -0.00366515f, 0.01875016f, 0.00612863f, -0.15575798f, 
    -0.18007626f, 0.09223284f, 0.01665411f, 0.08344778f, 0.05401619f, -0.06875639f, -0.17481717f, -0.05657864f, 
    0.39184356f, 0.02588294f, -0.18065032f, -0.08774303f, 0.03526236f, -0.02562372f, -0.05489800f, -0.06140682f, 
    0.13448605f, 0.45791331f, 0.19190516f, -0.18468620f, 0.05694108f, -0.09519590f, 0.01571053f, -0.01135526f, 
    -0.02548309f, 0.13555659f, -0.29821393f, -0.06545801f, 0.13509962f, -0.01512599f, -0.11710573f, -0.01057998f, 
    0.01634699f, 0.07610309f, 0.04679757f, 0.26824072f, 0.06157743f, 0.06940841f, 0.02198332f, 0.04333685f, 
    0.03155935f, 0.02970166f, -0.08565851f, -0.04712822f, -0.01035468f, -0.14490469f, -0.10098975f, 0.18583938f, 
    -0.21861602f, -0.09776019f, 0.05865221f, -0.05485584f, -0.13719739f, 0.08463938f, 0.11521115f, -0.02110910f, 
    -0.05879529f, -0.10805389f, -0.08658588f, -0.00539231f, 0.22829209f, 0.09518992f, 0.16728181f, -0.01341470f, 
    0.04001100f, 0.20751274f, 0.15155707f, -0.16775271f, -0.07956008f, 0.01429407f, -0.03666914f, 0.14412329f, 
    0.17081565f, -0.07389713f, -0.14078254f, -0.02591275f, 0.07845556f, 0.04473251f, 0.04569012f, 0.06152619f, 
    -0.03773987f, 0.06742359f, -0.00959085f, -0.06422241f, -0.03689897f, -0.02795467f, 0.05162987f, -0.04745976f, 
    -0.06397685f, 0.03487914f, 0.04213943f, -0.08835726f, -0.03403952f, 0.04002841f, 0.07221712f, 0.00171034f, 
    -0.05059106f, -0.08790300f, -0.02866132f, -0.06424945f, -0.02323888f, -0.02654933f, 0.04727775f, 0.01079086f, 
    -0.05855719f, 0.02265868f, -0.01016626f, -0.04959119f, -0.00677235f, -0.00606148f, -0.04798450f, -0.03670261f, 
    0.04203979f, 0.05778754f, -0.02813582f, -0.06313267f, -0.07605677f, 0.01031107f, -0.08877409f, -0.01671304f, 
    0.01581347f, -0.07375359f, -0.04155678f, -0.08190092f, 0.04359185f, -0.09078296f, 0.04546860f, -0.00375933f, 
    -0.03294881f, -0.07838221f, -0.08954228f, 0.00392823f, 0.06550052f, 0.01881899f, -0.03956582f, 0.00611624f, 
    0.05747193f, -0.07052137f, -0.03038050f, 0.02010056f, 0.01949583f, -0.01346784f, -0.02365971f, 0.01918719f, 
    0.03240065f, 0.06524085f, -0.00874187f, 0.06262556f, -0.03116250f, -0.00710834f, -0.02628264f, -0.08135895f, 
    -0.03519380f, 0.05986138f, 0.05545618f, -0.08374102f, -0.01216613f, 0.06129679f, -0.07153249f, 0.02025574f, 
    -0.06241726f, -0.05227976f, -0.08626851f, 0.02863751f, 0.02350646f, -0.02551969f, -0.07099244f, -0.03466200f, 
    0.02318729f, -0.06422561f, 0.03529285f, -0.01336311f, 0.04257300f, -0.00171636f, -0.07343074f, 0.02736033f, 
    -0.03886937f, 0.00554193f, -0.05268362f, -0.00759056f, -0.07098950f, -0.03442959f, 0.06324226f, -0.00340877f, 
    -0.08749008f, 0.01806504f, -0.03978254f, -0.07599859f, 0.01188448f, 0.01281175f, -0.00544636f, -0.08669677f, 
    -0.06944105f, 0.04443919f, -0.02417545f, 0.06261623f, 0.02947781f, 0.07110225f, -0.03683983f, 0.01700860f, 
    -0.09284925f, -0.06545651f, -0.02193194f, -0.04611077f, 0.05732309f, -0.00910451f, 0.00534260f, 0.02299070f, 
    -0.00033437f, 0.03272534f, 0.04144319f, 0.01234596f, 0.04922035f, -0.04250881f, 0.05524647f, 0.07088947f, 
    -0.04105004f, 0.06616987f, 0.04614800f, 0.01970142f, 0.02631195f, -0.05396792f, 0.05480944f, -0.05210771f, 
    -0.11120462f, -0.27356750f, 0.13481262f, 0.06551938f, 0.12544505f, 0.02459579f, -0.07448060f, -0.04413861f, 
    -0.05394933f, -0.22588697f, 0.03715879f, -0.20636196f, -0.01574497f, 0.13233387f, 0.00515895f, -0.22596177f, 
    0.07181182f, -0.07720169f, -0.08978356f, -0.28711328f, -0.24974951f, -0.27548215f, 0.02682722f, 0.06002839f, 
    0.24861862f, 0.08726483f, -0.20463204f, 0.08354561f, -0.17039473f, -0.27923506f, 0.20085792f, -0.02579170f, 
    0.17633379f, 0.04537485f, -0.00229554f, 0.04754406f, -0.01947483f, -0.10617408f, -0.00027554f, -0.03446454f, 
    0.09404664f, -0.03175978f, -0.08640074f, 0.12612188f, -0.00490996f, 0.14053553f, 0.06682313f, -0.14435308f, 
    -0.09673738f, 0.20193361f, -0.13963228f, -0.00312100f, 0.12563774f, 0.06218966f, 0.17167149f, -0.11013483f, 
    -0.10316460f, 0.09535466f, -0.00554875f, 0.04278175f, -0.00364592f, -0.09866316f, 0.15211159f, 0.47407058f, 
    0.15710858f, 0.10759244f, -0.02091080f, -0.15518592f, -0.17274311f, -0.11141472f, 0.02215202f, -0.10002009f, 
    0.28597721f, 0.08140079f, -0.02230611f, -0.00399718f, 0.02408788f, 0.04281798f, -0.04082738f, -0.06876093f, 
    0.05884054f, 0.29057464f, 0.19139425f, 0.03277567f, -0.05501554f, -0.10943071f, -0.01302993f, -0.01769132f, 
    0.03994310f, 0.11022398f, 0.11292109f, 0.00557764f, 0.24340062f, 0.05067201f, 0.05468702f, -0.02806133f, 
    -0.00869780f, -0.14029258f, -0.13348196f, 0.11096270f, 0.31413460f, 0.19809422f, -0.12192663f, -0.02171015f, 
    -0.03902774f, 0.00756460f, 0.01829669f, -0.10176282f, -0.14568821f, -0.14005397f, 0.07228302f, 0.07475736f, 
    0.09093612f, -0.00887156f, -0.04185707f, 0.01982600f, 0.06536344f, -0.34637117f, -0.18653794f, 0.09864065f, 
    -0.17694664f, -0.05174692f, 0.08822121f, -0.09037478f, 0.14596543f, -0.13210712f, -0.23646094f, 0.04471811f, 
    0.04918932f, -0.00461443f, -0.08769032f, -0.07163428f, -0.11857235f, 0.01569803f, -0.02033651f, -0.27810353f, 
    0.22682069f, -0.31579536f, -0.09068222f, -0.01098207f, -0.02665930f, 0.10791095f, -0.00862768f, -0.10056086f, 
    -0.04817566f, 0.02557212f, 0.15544686f, -0.16194940f, 0.07104480f, 0.06431460f, -0.12377351f, -0.06862962f, 
    -0.13276663f, 0.22189341f, 0.03102759f, 0.00872402f, -0.22625139f, -0.20862423f, -0.07066804f, 0.00682131f, 
    0.10680041f, 0.12172358f, -0.48585653f, -0.18691470f, -0.19284754f, 0.07116713f, 0.01256371f, -0.03865248f, 
    -0.05163500f, -0.02686393f, 0.10663068f, 0.17168109f, 0.11927734f, 0.04219607f, -0.09128218f, 0.00757468f, 
    -0.09593212f, 0.04141269f, 0.20667939f, 0.02242874f, -0.04366114f, -0.10616979f, 0.00400045f, 0.13750353f, 
    0.16938779f, 0.08527931f, 0.23086672f, -0.05015524f, 0.13347113f, -0.03552251f, -0.05663440f, 0.12156469f, 
    -0.11554793f, 0.03821060f, -0.26287636f, 0.06917168f, 0.11774113f, -0.04554061f, 0.20713611f, 0.03137293f, 
    -0.01964416f, -0.02898654f, 0.08830406f, 0.17631094f, 0.09048358f, 0.13009641f, -0.06073477f, -0.00309251f, 
    -0.03590224f, -0.03064871f, -0.18753399f, -0.00951707f, -0.24070318f, -0.01297114f, -0.04582497f, -0.17866912f, 
    -0.21063252f, -0.12261556f, 0.05125027f, 0.03056938f, -0.03516499f, -0.02737808f, -0.09527028f, 0.04731892f, 
    0.18326309f, -0.05857983f, -0.14625371f, 0.14627935f, 0.26829630f, 0.13156636f, 0.08260199f, -0.09455278f, 
    -0.11937054f, -0.06438704f, 0.21142852f, 0.06493364f, -0.11862685f, 0.10472660f, -0.08947131f, 0.05783728f, 
    -0.13397293f, -0.07226534f, -0.01306863f, -0.65894526f, -0.20159613f, -0.13644665f, 0.04723992f, 0.12211878f, 
    0.08914734f, 0.16322257f, 0.01859459f, 0.04553089f, 0.01222871f, -0.07471978f, 0.01036540f, -0.00502890f, 
    0.01967433f, 0.00139418f, -0.00201030f, 0.08971737f, -0.10329517f, -0.18335719f, 0.01186734f, -0.09513208f, 
    0.10407041f, 0.15715647f, 0.00525804f, 0.12592202f, -0.15879005f, -0.10448233f, 0.21257246f, -0.09744095f, 
    -0.22204638f, -0.03027457f, -0.02447077f, 0.05181815f, 0.03063954f, 0.05924422f, -0.01461668f, 0.10475773f, 
    0.00459860f, 0.03386582f, -0.12340825f, -0.10043170f, 0.06520059f, -0.06491375f, 0.10664503f, -0.03887170f, 
    -0.03538432f, -0.03186342f, -0.07709544f, 0.06323491f, -0.06124160f, -0.06875985f, -0.03019384f, 0.04248741f, 
    -0.00159326f, -0.05610596f, 0.01812085f, -0.08405053f, -0.04573993f, -0.02198735f, -0.05576912f, -0.05720575f, 
    0.03902720f, -0.02597169f, -0.03147201f, 0.07955639f, -0.06338248f, 0.02176467f, 0.01324505f, 0.03119031f, 
    -0.07761048f, 0.01302488f, 0.04308232f, 0.05386959f, 0.02611310f, 0.06470032f, 0.02166158f, -0.06815612f, 
    -0.05159241f, 0.04963936f, 0.02133999f, 0.02880424f, -0.07343658f, 0.00930439f, -0.08985788f, -0.06962240f, 
    -0.01454519f, -0.04086948f, -0.03610022f, 0.05109456f, -0.07877546f, 0.01690588f, -0.04930973f, 0.02884877f, 
    0.05734777f, 0.02093457f, -0.08698267f, -0.04337560f, -0.00757300f, 0.06625924f, -0.04816386f, -0.08321994f, 
    -0.04882669f, -0.00447021f, -0.00378789f, 0.05504620f, 0.02500214f, -0.01051612f, -0.00472660f, 0.06562119f, 
    -0.06652556f, -0.06455658f, 0.02045163f, -0.08477418f, -0.05986867f, 0.07704873f, 0.06198387f, -0.04778884f, 
    0.03975491f, 0.05259191f, -0.06529192f, 0.00936077f, -0.01693591f, -0.06787475f, -0.02520382f, -0.08072517f, 
    0.05811087f, 0.01227999f, -0.03280383f, 0.03715400f, 0.06094283f, -0.04220202f, -0.02323430f, -0.03824857f, 
    -0.00083064f, -0.07285084f, 0.04389986f, -0.08932371f, -0.04309401f, 0.02479454f, 0.00533665f, -0.02111969f, 
    0.02965617f, -0.01556136f, 0.06567890f, -0.06283786f, 0.01333461f, -0.07761283f, -0.03622371f, -0.00390843f, 
    0.02041148f, 0.00953864f, -0.03291268f, 0.01793077f, -0.00297130f, 0.02877196f, 0.03470802f, 0.07072655f, 
    -0.06243153f, 0.00862443f, -0.06183778f, -0.00007821f, 0.03891272f, 0.06505154f, 0.01576386f, -0.05268521f, 
    0.06075669f, 0.04008802f, -0.01190153f, -0.05710255f, -0.03574101f, -0.02909326f, -0.00700812f, 0.05172452f, 
    0.01728432f, 0.02661231f, -0.05568995f, -0.03936993f, -0.00331073f, -0.06549552f, 0.03442301f, -0.02388753f, 
    -0.08102053f, -0.01902918f, 0.02317045f, 0.00274283f, 0.01043789f, -0.08500339f, -0.02832834f, -0.00152018f, 
    -0.10719683f, -0.12333950f, -0.01396100f, -0.09197124f, 0.08741473f, 0.00779571f, 0.08485176f, -0.14784305f, 
    -0.03052305f, -0.24506475f, 0.10089392f, -0.40414864f, 0.06559420f, -0.07279766f, 0.20990413f, 0.05078832f, 
    -0.03449576f, 0.04484962f, -0.12524486f, 0.04975966f, 0.15739103f, -0.11655356f, -0.16227336f, -0.36341268f, 
    0.05019350f, 0.13125721f, 0.13602751f, 0.10014274f, 0.01786149f, -0.03164846f, -0.03588413f, 0.12074608f, 
    -0.13092525f, 0.03760681f, -0.06217690f, 0.00499221f, -0.01598378f, 0.04524226f, 0.15854673f, -0.06785613f, 
    0.25524685f, 0.16196804f, -0.05733892f, -0.07639690f, -0.01296760f, -0.36018834f, -0.08028790f, 0.17141153f, 
    0.16435640f, 0.02804933f, 0.13756087f, -0.00365239f, -0.04784603f, -0.12062210f, -0.04494520f, -0.30885831f, 
    -0.14400317f, -0.00446794f, 0.03436446f, 0.10134296f, 0.06615259f, -0.00542988f, -0.07008860f, 0.25004256f, 
    0.16916320f, -0.24944851f, -0.07585282f, -0.24139825f, -0.17462538f, 0.02708546f, -0.10805483f, 0.07730781f, 
    0.00290432f, 0.07566018f, 0.02602254f, -0.00854709f, -0.01870821f, 0.02037168f, 0.01165640f, -0.06434111f, 
    0.04053050f, -0.00068568f, -0.14802772f, -0.14706266f, 0.07631185f, 0.09604771f, 0.11256386f, -0.09477900f, 
    0.03089174f, 0.11437307f, -0.01220675f, -0.00863499f, -0.07023374f, 0.02572923f, -0.03228143f, -0.15764566f, 
    0.11765376f, -0.09001088f, 0.05708951f, 0.12317457f, 0.10724842f, 0.07258835f, 0.08902585f, 0.00477780f, 
    -0.16661441f, 0.07632221f, 0.24432868f, 0.13239869f, -0.46591586f, -0.18180278f, 0.08968847f, 0.11108550f, 
    0.15613703f, -0.11214849f, 0.10727523f, -0.21339566f, -0.14040282f, -0.02958420f, -0.04298168f, -0.13088124f, 
    0.09425963f, -0.14037034f, -0.13513649f, 0.09286217f, 0.02913039f, -0.05588056f, -0.03330484f, -0.05878997f, 
    -0.26711124f, 0.06339040f, 0.16629151f, -0.09810643f, 0.12235641f, 0.09550381f, 0.11610107f, 0.02747604f, 
    0.25191221f, -0.01278720f, 0.11773891f, -0.12252935f, 0.07668506f, 0.09392855f, -0.01183437f, -0.09949169f, 
    -0.05157017f, 0.13645621f, 0.07992961f, 0.10979717f, -0.00615710f, -0.03538115f, -0.12380904f, -0.05760852f, 
    -0.08137970f, 0.09522698f, 0.07947212f, 0.03475978f, -0.18862928f, -0.00611845f, -0.11390726f, 0.02977877f, 
    -0.01982029f, -0.21046612f, 0.00720200f, 0.05320382f, 0.06134640f, -0.05627161f, -0.13629879f, -0.21879180f, 
    0.01478589f, 0.14970379f, 0.11590666f, 0.12545596f, 0.21586967f, 0.05978719f, -0.01349031f, 0.08030514f, 
    0.00835418f, 0.00025596f, 0.09535598f, 0.05977249f, -0.00207652f, 0.04234331f, -0.05127489f, -0.11994523f, 
    -0.04418678f, 0.04847417f, -0.01310867f, -0.08967367f, 0.10011908f, -0.14069735f, 0.14208640f, -0.21025704f, 
    -0.00305061f, -0.02856844f, -0.15382187f, -0.02942642f, -0.04810927f, 0.03197427f, 0.16507095f, 0.17459346f, 
    0.07437520f, -0.02988427f, 0.08621967f, 0.06121889f, -0.03376868f, -0.06325928f, -0.08882601f, -0.05024511f, 
    -0.18498309f, 0.03857358f, 0.14372537f, 0.00294646f, -0.01224733f, 0.03264270f, -0.04919620f, 0.02014616f, 
    -0.24714959f, -0.23872828f, -0.10334731f, -0.14136228f, 0.10223405f, 0.01782847f, -0.14998809f, -0.08744249f, 
    0.08289209f, -0.24481501f, -0.43914598f, 0.04649635f, -0.01878246f, -0.03874192f, 0.12795481f, -0.02854575f, 
    -0.08413886f, -0.02413729f, -0.17055854f, 0.14202735f, 0.08045644f, 0.13595109f, 0.16950244f, 0.03167635f, 
    0.12304692f, 0.09094517f, 0.10215499f, -0.07858267f, 0.23827505f, 0.10796821f, 0.01311801f, -0.01871418f, 
    -0.05854513f, 0.14316188f, 0.05362592f, 0.09238541f, 0.55671161f, 0.06012369f, -0.21781918f, -0.00597463f, 
    -0.04426306f, 0.06301156f, 0.02496544f, -0.01838505f, 0.01273780f, -0.07807262f, -0.26264840f, -0.00266146f, 
    0.16323699f, 0.01188408f, -0.11386272f, -0.11246989f, -0.10577770f, 0.05083683f, 0.30237135f, -0.15895681f, 
    -0.06502201f, 0.02059321f, -0.06786696f, -0.06040792f, -0.02977328f, -0.14902022f, -0.11443164f, 0.20134431f, 
    0.50282156f, -0.04272113f, -0.02767404f, 0.00436955f, 0.03676198f, 0.07068371f, 0.03610314f, 0.10627221f, 
    -0.21974300f, 0.19919813f, -0.06491132f, -0.01998307f, -0.31708819f, -0.02197785f, 0.03121525f, -0.16274107f, 
    0.11235010f, 0.04001705f, -0.04801529f, 0.08970577f, 0.15640427f, -0.16402437f, -0.21912698f, 0.00179029f, 
    -0.04306691f, -0.06661128f, -0.11739877f, -0.26458174f, -0.72096664f, 0.04598703f, 0.12903799f, 0.09632996f, 
    -0.19124979f, -0.04311588f, -0.43973735f, -0.14713340f, 0.02183595f, 0.16534916f, 0.15200965f, -0.03596612f, 
    0.11255110f, -0.16678566f, -0.03647356f, 0.03988083f, 0.14908755f, 0.13034008f, -0.16934969f, -0.02585556f, 
    0.09630793f, 0.13847686f, 0.13962539f, 0.01640314f, 0.02693647f, -0.14727446f, -0.03543574f, -0.09223372f, 
    0.10875978f, 0.00133304f, 0.03004823f, 0.10159123f, 0.07702643f, -0.07099821f, 0.19201541f, 0.17628135f, 
    0.05241476f, 0.02541954f, -0.05902886f, -0.04499282f, -0.08008321f, 0.15849049f, 0.17638288f, -0.40817654f, 
    -0.01249459f, 0.06501640f, -0.13401568f, 0.01896306f, 0.21807490f, -0.04261012f, -0.04838993f, 0.06723817f, 
    0.10027705f, 0.13000451f, 0.17675537f, -0.07080045f, -0.04937861f, -0.05403513f, 0.02344360f, 0.07954412f, 
    -0.00738568f, 0.14764379f, -0.04750828f, -0.05851522f, 0.01192719f, 0.02778322f, -0.14661601f, 0.14222574f, 
    0.12743714f, -0.08862814f, -0.17077829f, 0.12307445f, -0.13214749f, 0.05955327f, 0.14451014f, 0.12186018f, 
    -0.09179935f, 0.03658576f, -0.08436774f, 0.02162661f, -0.10700879f, -0.25057763f, 0.02048867f, 0.20424080f, 
    0.12931652f, 0.05790180f, 0.01125312f, -0.08390141f, 0.22918545f, 0.06260519f, -0.02842028f, -0.07893322f, 
    0.14858812f, 0.04844734f, 0.11888454f, 0.03000317f, -0.07175621f, 0.02482768f, 0.06757175f, -0.12492765f, 
    -0.11895864f, 0.12558113f, -0.05413987f, -0.13361309f, 0.08695129f, -0.05606128f, -0.01497280f, -0.01493304f, 
    0.04811106f, -0.02089203f, -0.05864535f, -0.05236004f, 0.15043363f, 0.02758027f, -0.09918884f, -0.06340456f, 
    -0.14711112f, 0.08641079f, -0.00068120f, -0.12066218f, -0.00519918f, -0.09131681f, -0.04423308f, 0.27550951f, 
    0.06862587f, -0.03470185f, 0.02567418f, 0.03140402f, -0.00975371f, -0.02904276f, -0.06292085f, 0.02680185f, 
    -0.00608092f, -0.07254183f, 0.00035640f, -0.05094003f, -0.05163445f, -0.06210167f, -0.02185727f, -0.08924264f, 
    -0.06231344f, -0.04581295f, -0.08554576f, -0.03405202f, -0.07419723f, -0.04618952f, 0.06859537f, 0.06354548f, 
    -0.04098289f, -0.05329972f, -0.02403052f, -0.00297908f, -0.06333511f, -0.03232675f, -0.01754417f, 0.02855455f, 
    0.04232965f, -0.08491675f, -0.09109018f, -0.04696668f, 0.03177816f, -0.02017063f, 0.04131786f, -0.00909417f, 
    -0.06570358f, 0.03158903f, -0.09368023f, -0.00836721f, 0.04178000f, 0.05828462f, 0.05812215f, -0.05473831f, 
    -0.03781100f, -0.04548709f, -0.03464140f, 0.05035768f, 0.06835787f, -0.07539694f, -0.05337819f, -0.01875252f, 
    0.06225840f, 0.02877871f, -0.03895994f, -0.02611057f, 0.05308648f, -0.08622734f, -0.02189577f, 0.01502689f, 
    0.01674672f, -0.04681838f, -0.00909248f, 0.04456979f, -0.01440057f, -0.03786596f, -0.08291510f, -0.01098141f, 
    -0.06768867f, -0.01799540f, -0.07793596f, -0.01332044f, 0.04283996f, -0.01214510f, -0.00736485f, 0.05771028f, 
    -0.02797166f, 0.04162985f, 0.02419919f, -0.03553542f, -0.08249754f, 0.04916584f, 0.00274823f, 0.02391975f, 
    -0.00300105f, 0.05865016f, -0.08501373f, 0.06072949f, 0.02178872f, -0.02536079f, 0.04156603f, -0.03917832f, 
    -0.02289207f, -0.02119440f, -0.03562026f, 0.02958538f, 0.02820542f, -0.07581563f, 0.02892746f, -0.03871660f, 
    -0.05017079f, -0.04498051f, -0.03075834f, -0.07815287f, 0.00021454f, -0.03763289f, -0.05794771f, 0.06789720f, 
    0.01544882f, 0.01474526f, -0.01256797f, 0.06800740f, 0.01053457f, -0.08977686f, -0.07305966f, -0.09185501f, 
    -0.03963141f, 0.05601641f, 0.02542800f, 0.04551258f, 0.02722547f, -0.07061923f, 0.03989492f, -0.00420945f, 
    0.04308335f, -0.04974252f, -0.09373669f, 0.00343034f, 0.02836280f, -0.02642115f, -0.07308901f, -0.03325774f, 
    -0.00594846f, -0.01457365f, -0.06804016f, -0.01900074f, 0.01407944f, -0.02938770f, -0.01492743f, 0.04243679f, 
    0.02148463f, -0.02284745f, -0.02947524f, 0.04361038f, -0.04675997f, -0.02557388f, 0.00397526f, 0.05108336f, 
    0.01345019f, 0.04331311f, 0.01519666f, 0.01756866f, 0.05499070f, 0.01561781f, -0.02804990f, 0.07521141f, 
    -0.01827885f, 0.06062694f, 0.00010169f, -0.04092476f, -0.01987647f, 0.05623214f, 0.07208664f, -0.02070228f, 
    -0.03978753f, 0.03810047f, -0.01361620f, -0.04901442f, 0.04085144f, -0.01815164f, -0.02951125f, -0.04553782f, 
    -0.05582929f, -0.07206151f, -0.02778601f, -0.04044455f, 0.02400651f, 0.04656408f, -0.02839837f, -0.05679549f, 
    0.02914402f, -0.00312925f, -0.08456157f, -0.00623079f, -0.07336760f, -0.07502919f, 0.05503065f, 0.00403432f, 
    0.03621509f, -0.03891341f, 0.05035133f, -0.02634416f, 0.06791691f, 0.04237955f, -0.05482047f, 0.05835969f, 
    -0.01229939f, -0.02713940f, -0.04416358f, -0.01727112f, 0.04860275f, -0.07269152f, 0.04687803f, -0.02189822f, 
    0.00356506f, 0.03669754f, 0.03253972f, 0.01252001f, -0.00732679f, 0.06609906f, 0.01973411f, 0.03850165f, 
    0.01432214f, 0.02315529f, -0.05032069f, -0.04223870f, -0.08372942f, -0.01827016f, -0.05545288f, -0.02102484f, 
    -0.02955632f, -0.03800479f, -0.08555413f, -0.08595571f, 0.05730025f, -0.01499175f, -0.01224239f, 0.07673698f, 
    -0.06847240f, -0.03035282f, -0.06005130f, -0.05070208f, -0.07184348f, -0.06398785f, 0.06165632f, -0.08067422f, 
    -0.07494845f, -0.08822939f, 0.04298005f, -0.07648379f, 0.05173317f, 0.02481610f, 0.01192647f, -0.08263569f, 
    0.06520682f, 0.01364303f, -0.04720701f, 0.05827683f, -0.04978076f, -0.03960436f, 0.04282978f, 0.01711291f, 
    -0.02467063f, -0.06587573f, 0.01158208f, -0.07116709f, -0.04537218f, -0.00014457f, 0.06335746f, -0.05093886f, 
    -0.03142602f, -0.04248446f, -0.08338987f, 0.07446548f, 0.03379664f, -0.05744396f, 0.07354289f, -0.06852671f, 
    0.03421040f, -0.08969082f, 0.00054398f, 0.04352611f, -0.08043126f, -0.05673864f, -0.05014002f, -0.08272423f, 
    -0.03047099f, -0.02069989f, 0.04684830f, 0.04874746f, -0.06227430f, -0.06946547f, 0.00475354f, 0.03299878f, 
    -0.36399946f, -0.19086409f, -0.07245215f, -0.07799512f, 0.07114239f, 0.03243545f, 0.16338684f, -0.03564499f, 
    -0.11084154f, -0.02224184f, -0.38388288f, -0.09395447f, -0.02544859f, -0.07431026f, -0.00009233f, -0.11292585f, 
    0.04662754f, 0.07031158f, -0.03189619f, -0.56575751f, 0.03926233f, -0.04640657f, 0.03298291f, -0.08016986f, 
    -0.01360458f, -0.01840521f, -0.08141486f, 0.13265528f, 0.25095087f, -0.20201549f, -0.01853690f, -0.07580935f, 
    0.09325608f, 0.02391068f, 0.01562414f, 0.01527272f, 0.13731216f, -0.00807931f, -0.12678894f, 0.07237280f, 
    0.09869745f, -0.05252687f, 0.11504896f, -0.00786071f, 0.01941288f, 0.02662167f, -0.62404370f, -0.05961366f, 
    -0.01570024f, -0.19749090f, 0.04370358f, 0.03494012f, -0.03097416f, 0.08425525f, 0.12679324f, -0.20611629f, 
    -0.21490376f, 0.05544823f, 0.12064195f, 0.06351941f, 0.04712125f, -0.07732917f, -0.05868181f, 0.25925902f, 
    -0.15969545f, 0.07296038f, 0.07903230f, 0.14759691f, -0.12299170f, 0.10837647f, -0.04082697f, -0.01583354f, 
    0.18265763f, -0.01763625f, -0.19752382f, -0.09902956f, -0.03952285f, 0.07647030f, 0.04199350f, 0.11519984f, 
    0.05993066f, 0.00709215f, -0.24186333f, 0.07593808f, 0.05674987f, -0.17669281f, 0.02990099f, -0.05971275f, 
    -0.04279412f, 0.06059949f, -0.11377802f, 0.47477400f, 0.05326442f, -0.01700968f, 0.04711297f, -0.11164470f, 
    -0.01571645f, 0.07348908f, -0.02919738f, -0.05825762f, 0.30568880f, 0.05251301f, 0.00731525f, -0.03993573f, 
    0.01932449f, -0.05115211f, -0.06912484f, 0.06393740f, 0.05067024f, 0.06725443f, 0.05076496f, -0.08880617f, 
    0.00854089f, -0.08587801f, -0.04247526f, 0.05876030f, 0.04177073f, -0.02110875f, 0.05904803f, -0.30431774f, 
    -0.15888670f, 0.00322207f, 0.16753283f, -0.06444152f, 0.07928448f, -0.02259620f, -0.10440707f, -0.17721260f, 
    0.06765646f, -0.01133214f, 0.06443077f, -0.08175619f, -0.00703411f, -0.06618948f, -0.01860330f, 0.08050171f, 
    0.34027854f, -0.05413521f, 0.13089149f, -0.05597426f, 0.01561718f, 0.00991891f, 0.06326159f, 0.05721016f, 
    -0.14817218f, -0.21811515f, -0.14639232f, 0.13858579f, -0.03637149f, 0.01342789f, 0.04760252f, -0.03898047f, 
    0.02210837f, 0.14240158f, 0.09901438f, 0.12757111f, -0.16186514f, -0.06600754f, -0.16164364f, 0.01648272f, 
    0.08408315f, -0.17334971f, 0.18869197f, 0.11175148f, -0.10277811f, 0.03260014f, -0.04232085f, 0.11905236f, 
    0.05048975f, -0.12958203f, 0.02489705f, 0.09396450f, 0.02587357f, 0.49855024f, -0.18588646f, 0.03647970f, 
    0.11030746f, -0.15735935f, 0.06152791f, 0.00976681f, 0.02794180f, 0.03086886f, -0.04217481f, 0.13281831f, 
    0.05722571f, 0.04727579f, 0.00800064f, -0.07266957f, 0.05947426f, 0.26779079f, 0.02758590f, -0.18200363f, 
    0.11314692f, 0.05401197f, 0.03171753f, -0.00194793f, 0.05193062f, 0.07013814f, -0.23343912f, -0.34493071f, 
    -0.23766667f, 0.05245496f, -0.01346300f, 0.03696454f, 0.03712295f, 0.01540968f, 0.08340069f, -0.06635606f, 
    0.08040579f, -0.00045181f, -0.06679933f, 0.03523161f, -0.02719534f, -0.04119121f, 0.05973373f, 0.00810382f, 
    0.17363310f, 0.08828589f, -0.42315924f, 0.16381957f, 0.02928330f, 0.08378650f, -0.03290299f, -0.07228728f, 
    -0.06981447f, 0.02761021f, -0.00154919f, -0.16683863f, 0.20879871f, 0.04900437f, -0.04833586f, 0.11334566f, 
    -0.03517229f, 0.00816761f, 0.08729702f, -0.10963421f, 0.15777060f, -0.12346719f, -0.14809269f, -0.04683349f, 
    -0.04176418f, -0.01986599f, 0.10743270f, 0.17341948f, 0.00224188f, 0.03056734f, 0.10952874f, 0.02805936f, 
    -0.04488470f, 0.03606088f, 0.04333495f, -0.03105485f, 0.07529045f, -0.01111547f, 0.04276828f, -0.12304182f, 
    -0.02751070f, -0.05690374f, -0.11953425f, -0.12946866f, -0.08219256f, -0.02608146f, -0.07010170f, -0.17765632f, 
    -0.06749139f, 0.19577059f, -0.01683928f, -0.00405930f, -0.06880613f, 0.02771430f, -0.08462758f, 0.36896464f, 
    -0.26126459f, -0.02931437f, -0.08986712f, -0.05192099f, -0.17525963f, -0.03082291f, 0.05450599f, -0.29413792f, 
    -0.26255831f, 0.23451367f, -0.12698182f, 0.07025599f, -0.07185060f, 0.05330716f, 0.06149740f, -0.00169740f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.04302632f, -0.12438072f, 0.01858776f, 0.04064341f, -0.10243016f, 0.02687775f, 0.11349522f, 0.13890965f, 
    -0.07816335f, 0.06127606f, -0.04025424f, 0.06704472f, -0.02298771f, 0.01647854f, -0.00035194f, 0.13176334f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.23486300f, -0.07173595f, 0.27082565f, 0.13987043f, -0.21130957f, -0.10258660f, -0.38156915f, 0.32364899f, 
    0.05569987f, -0.66792625f, -0.14013554f, 0.27840480f, 0.16645780f, 0.20428257f, 0.08400275f, 0.19349453f, 
    0.02207153f, -0.30016783f, 0.06447896f, 0.35344756f, 0.18363243f, -0.05532232f, -0.11096709f, -0.33487779f, 
    -0.16898133f, 0.12695573f, -0.09232703f, 0.30150047f, 0.04199008f, 0.23291306f, 0.04999151f, 0.03910122f, 
    0.01947829f, 0.51758921f, 0.05624342f, -0.63505876f, -0.01199836f, -0.14569353f, 0.38948137f, -0.20047508f, 
    0.05815134f, -0.18948501f, -0.23062909f, 0.12325299f, 0.04526998f, -0.11011393f, -0.13510792f, 0.06413879f, 
    0.23785643f, 0.20565407f, -0.25201219f, 0.44561449f, -0.39636171f, 0.10967352f, 0.32737195f, -0.00677868f, 
    0.22757566f, -0.31541735f, -0.07528195f, -0.17576244f, 0.18081546f, 0.13760656f, 0.08504441f, 0.13372174f, 
    0.04442124f, 0.27957186f, 0.16524048f, 0.03378766f, 0.33531627f, -0.07395796f, 0.27992764f, 0.11387459f, 
    0.13029580f, -0.05491729f, -0.14376999f, -0.01497991f, -0.05838947f, 0.09444728f, -0.29695842f, -0.42254677f, 
    -0.01725044f, 0.06497505f, 0.38200983f, 0.36134073f, -0.43243772f, -0.03056252f, 0.10846866f, 0.11397762f, 
    0.09292500f, 0.09033319f, -0.27253273f, -0.10336379f, -0.08172097f, -0.14615889f, 0.02172222f, 0.02336779f, 
    -0.15127604f, 0.09544045f, 0.28533876f, -0.37043649f, -0.15884733f, 0.14800997f, 0.27664921f, -0.44855392f, 
    -0.11585996f, 0.18131788f, -0.03066950f, 0.07538963f, 0.10366824f, -0.01119876f, 0.00634836f, 0.25502011f, 
    -0.11590531f, -0.20589305f, -0.22441018f, 0.19214226f, 0.31223550f, 0.17469390f, 0.10341169f, -0.00301503f, 
    -0.23588142f, 0.23145752f, -0.24666466f, 0.05577152f, -0.23518261f, -0.14444244f, -0.01961625f, 0.04619314f, 
    0.20657071f, -0.31356907f, -0.26118422f, -0.28537843f, 0.40977025f, -0.06290363f, -0.12530246f, 0.44291970f, 
    -0.16928580f, -0.14062957f, 0.24577752f, -0.08528899f, -0.02399717f, 0.16859049f, 0.17013852f, 0.23007521f, 
    -0.04841784f, 0.38904035f, 0.06471902f, -0.33959991f, 0.00041986f, -0.21358468f, 0.03807374f, 0.02982274f, 
    -0.07524136f, -0.27094954f, -0.21727201f, 0.29237050f, -0.06989588f, 0.19640291f, -0.10784121f, 0.21473989f, 
    0.04428319f, 0.00116386f, -0.27785689f, -0.00404625f, 0.28551412f, 0.10881764f, 0.16976193f, 0.20320863f, 
    0.07261557f, -0.55036169f, 0.17825736f, 0.36648974f, -0.08879603f, 0.24634492f, -0.06297767f, -0.13127804f, 
    -0.18926361f, -0.28886297f, 0.41204384f, 0.08664360f, 0.00405543f, -0.15472326f, -0.19615909f, 0.41279951f, 
    -0.14016652f, -0.09992568f, -0.03730175f, -0.20573743f, -0.04701782f, 0.02744728f, -0.25221840f, 0.16612506f, 
    -0.06627500f, -0.01473508f, -0.01372765f, 0.27867588f, 0.25353816f, 0.21628346f, 0.03068788f, 0.01910948f, 
    -0.23871109f, 0.08055513f, -0.07169686f, -0.04914642f, 0.19271402f, 0.03384551f, -0.09439994f, -0.42108124f, 
    -0.03953379f, 0.34813046f, -0.02730688f, -0.35284019f, 0.06918634f, -0.05781953f, 0.03039054f, -0.07102913f, 
    -0.01136484f, -0.05828189f, -0.09391642f, 0.34956652f, 0.12103930f, 0.21746030f, -0.46815503f, 0.20705715f, 
    -0.21453074f, -0.18442343f, -0.04158501f, -0.15470897f, 0.12761033f, 0.05481985f, -0.29985055f, 0.25809547f, 
    -0.06579728f, 0.19510414f, 0.28301540f, -0.11539036f, 0.16591333f, -0.19003408f, 0.17021215f, 0.04580189f, 
    0.10994934f, 0.19173396f, -0.06526614f, 0.01043105f, 0.26956758f, -0.13357426f, -0.41046730f, -0.00994244f, 
    -0.03499873f, -0.02173241f, 0.10702319f, 0.26570350f, 0.19573618f, 0.22043806f, 0.06884903f, 0.06426035f, 
    0.14768542f, 0.28933412f, 0.41949883f, -0.00507440f, 0.10393915f, 0.20896839f, 0.08754390f, -0.18073574f, 
    0.08362934f, -0.04892258f, -0.35434225f, 0.10310464f, -0.21673189f, 0.07618132f, -0.21636266f, -0.13700376f, 
    0.10785609f, -0.05484949f, -0.06523336f, -0.05271246f, -0.44130948f, 0.15253820f, -0.14427388f, 0.28728619f, 
    -0.19369082f, -0.38779712f, 0.05670182f, 0.36506748f, -0.19542402f, 0.06434608f, 0.03391455f, 0.22854905f, 
    0.25415599f, 0.22222184f, -0.25624147f, -0.15511860f, -0.19472201f, 0.22721265f, 0.28902724f, -0.14929453f, 
    0.23271097f, 0.26923984f, 0.15936883f, 0.00698663f, -0.07622074f, -0.16586602f, 0.07609551f, 0.35572067f, 
    -0.04867559f, 0.31150359f, -0.14201611f, 0.16251519f, 0.29470897f, -0.00875173f, -0.26862168f, -0.11937111f, 
    0.04167884f, -0.04089758f, 0.03751016f, 0.32742596f, 0.09041291f, -0.04911221f, -0.23364763f, 0.17220746f, 
    0.24027348f, 0.18983594f, -0.31658027f, 0.35561717f, -0.29689607f, -0.03231225f, 0.12335499f, -0.06281230f, 
    -0.24846904f, 0.27634495f, 0.07303953f, 0.11704842f, -0.01745418f, 0.06038671f, -0.10085474f, -0.19610450f, 
    -0.11398089f, 0.10797339f, -0.14617218f, 0.10404930f, -0.03033719f, 0.04406351f, -0.06183553f, 0.02945380f, 
    0.19984543f, -0.01254351f, -0.23973967f, -0.08004206f, -0.19066188f, -0.21183142f, -0.22320865f, -0.15477136f, 
    -0.09836993f, -0.16775581f, -0.23139185f, 0.02704507f, -0.04604656f, -0.10400259f, -0.07896790f, -0.17526615f, 
    -0.12646574f, 0.00272936f, -0.05261248f, -0.20206144f, -0.17726770f, 0.02208424f, -0.18905157f, -0.09454614f, 
    0.01101683f, 0.13995595f, 0.17113303f, 0.30729821f, -0.03235164f, 0.05329386f, -0.25890779f, -0.47188911f, 
    -0.20458300f, -0.13187249f, 0.03965692f, 0.06064626f, 0.14244854f, 0.13380057f, 0.05810102f, 0.27456135f, 
    0.18288353f, 0.02223473f, 0.35141808f, 0.44686428f, 0.13638386f, 0.03703111f, -0.11181715f, -0.05842679f, 
    -0.00584927f, -0.32965115f, -0.19408621f, -0.03222036f, 0.02796695f, -0.01804659f, 0.17169334f, -0.15512754f, 
    0.21342130f, 0.02355285f, -0.28406185f, -0.25307700f, 0.20771812f, 0.15982643f, -0.07487526f, -0.39029318f, 
    0.20363076f, 0.21718553f, -0.12656802f, 0.08844538f, 0.00431472f, -0.16664289f, 0.56075674f, 0.18198575f, 
    0.04406458f, 0.16607817f, -0.08707054f, -0.02669363f, -0.02330097f, -0.10776585f, -0.14812508f, 0.21585335f, 
    0.03527272f, 0.19926602f, 0.29747003f, -0.11482712f, 0.14559464f, -0.06587891f, 0.43561250f, 0.30274349f, 
    0.08930495f, -0.05607745f, -0.16723044f, 0.11970715f, 0.05261616f, 0.10528160f, -0.25895298f, 0.41024867f, 
    0.22523144f, -0.01571937f, -0.04473044f, -0.03469559f, -0.01183829f, -0.05697003f, 0.11670258f, 0.36482003f, 
    -0.23736162f, 0.18923476f, 0.10350716f, -0.31582990f, 0.33415794f, -0.02603300f, -0.01659775f, 0.32502097f, 
    0.22989728f, 0.06987635f, -0.23050286f, -0.06953350f, -0.07985129f, -0.24493596f, -0.35810745f, 0.39236447f, 
    -0.11874753f, 0.33991143f, 0.04726679f, -0.55734360f, -0.23005204f, -0.11519828f, -0.18767181f, 0.16249147f, 
    0.16628930f, 0.18604711f, 0.41839272f, -0.06447048f, 0.21924314f, 0.24956918f, -0.17438644f, 0.03832589f, 
    -0.22078982f, -0.24267283f, 0.23611255f, 0.03768184f, -0.38647008f, 0.07757473f, 0.34552726f, 0.43122244f, 
    -0.02443975f, -0.11503521f, -0.23879316f, -0.07375826f, 0.11393308f, 0.06011862f, 0.23522192f, -0.19408345f, 
    0.23682326f, 0.52005136f, -0.01082407f, 0.27565548f, -0.42677975f, -0.17923692f, 0.03704673f, -0.18505715f, 
    0.20825702f, -0.09225364f, 0.23467799f, 0.07822204f, -0.09559593f, 0.07969746f, -0.03448918f, -0.10676108f, 
    0.10179335f, 0.17552850f, 0.01501954f, -0.04959435f, 0.42535844f, 0.15442540f, 0.04658281f, 0.16550976f, 
    -0.22197193f, -0.25047359f, -0.01776047f, 0.00742487f, -0.02843791f, 0.08650750f, -0.12437205f, -0.26416770f, 
    0.00171609f, -0.08350461f, -0.27566233f, -0.05676296f, -0.28780732f, -0.09369855f, -0.21505329f, 0.25192574f, 
    -0.21042860f, -0.16936699f, 0.28496480f, 0.39606029f, -0.23489237f, 0.13627899f, 0.07448324f, 0.36882105f, 
    0.21277775f, -0.15890445f, -0.04323312f, 0.26068252f, -0.35767081f, 0.08922296f, 0.04023745f, 0.18401614f, 
    0.20611094f, 0.47527424f, -0.11820379f, 0.20228653f, 0.06066458f, 0.20277490f, -0.28986502f, -0.43921536f, 
    -0.00955912f, 0.39363694f, 0.16008168f, -0.11622640f, 0.07604634f, -0.22841963f, 0.06782184f, 0.07617515f, 
    0.07853482f, 0.25681576f, -0.12740548f, -0.29372370f, 0.22923139f, -0.17139669f, 0.02556060f, 0.34144643f, 
    -0.15320912f, -0.34137237f, -0.27358988f, 0.03202566f, 0.01145212f, -0.08498138f, 0.12664889f, -0.57924050f, 
    -0.09712377f, 0.08357723f, 0.19459334f, 0.06650088f, -0.07612231f, -0.07504845f, -0.28500178f, 0.59210289f, 
    -0.19584556f, 0.06104559f, 0.30663678f, 0.04204942f, 0.25677720f, 0.05657369f, 0.37042609f, -0.33897120f, 
    -0.06238659f, 0.07560115f, -0.03975816f, -0.33334917f, -0.06961324f, 0.05108627f, 0.12210485f, -0.21908300f, 
    0.04692198f, 0.07589505f, 0.18081179f, 0.27119255f, -0.36468101f, -0.03147281f, 0.11895598f, -0.35593328f, 
    0.10966878f, -0.03996874f, -0.15503787f, 0.16757271f, 0.16941155f, -0.17052302f, -0.26139683f, 0.05813226f, 
    -0.15210220f, -0.43866765f, -0.02024939f, 0.15120912f, -0.06540751f, -0.02649184f, -0.01564115f, -0.31338924f, 
    0.16820629f, 0.34571072f, -0.35546172f, -0.01163702f, -0.00259329f, -0.09477858f, 0.60512877f, 0.23588377f, 
    -0.06057341f, -0.12359972f, -0.17934828f, -0.09539793f, 0.34392613f, -0.12849095f, 0.39736027f, 0.41364411f, 
    -0.11418170f, -0.11716289f, 0.37236971f, -0.28108454f, 0.08729342f, 0.02049038f, 0.08622016f, -0.09732150f, 
    0.10457925f, 0.41128725f, -0.08728292f, 0.01232866f, -0.16093048f, -0.14611313f, -0.04425036f, 0.32113752f, 
    0.04870632f, 0.23754106f, 0.13465160f, 0.21092860f, -0.05104876f, 0.00349309f, -0.28298146f, -0.32011771f, 
    0.18519609f, 0.09045383f, -0.41547343f, 0.44377789f, -0.29459220f, -0.08815409f, 0.30296403f, 0.22007932f, 
    0.07927106f, 0.07972585f, -0.19513233f, -0.20299305f, -0.18454567f, -0.00914097f, -0.58413106f, 0.06842042f, 
    -0.22559026f, -0.20672251f, 0.45086718f, -0.45360950f, 0.39444995f, 0.01153072f, 0.15649645f, 0.39240387f, 
    0.19486932f, -0.09144613f, -0.45075437f, -0.22061370f, 0.22021270f, -0.22110847f, -0.13045013f, 0.36199284f, 
    0.05520251f, -0.40309855f, 0.28403375f, -0.23296498f, 0.59993529f, 0.18119553f, 0.10031897f, -0.33771837f, 
    0.00446071f, -0.13412368f, 0.00485881f, 0.34263745f, -0.04427427f, 0.11813930f, 0.23069565f, 0.03398782f, 
    -0.15241575f, 0.00130735f, 0.10029270f, -0.35274488f, 0.00033140f, -0.18825413f, -0.52903676f, 0.26951510f, 
    -0.13372442f, -0.38118386f, 0.06106637f, 0.34504765f, -0.21182178f, 0.21553560f, -0.18083404f, -0.04711911f, 
    -0.24623744f, 0.18549052f, -0.01373888f, -0.24204791f, 0.44340774f, 0.23092180f, -0.21710810f, 0.35417238f, 
    0.03252015f, -0.17973839f, -0.26577768f, 0.06689016f, -0.17447448f, -0.17942993f, -0.13569859f, 0.32122046f, 
    -0.21904179f, -0.10018080f, 0.01419417f, -0.23243633f, 0.00181987f, -0.03027662f, -0.14373560f, 0.31233260f, 
    0.03745162f, 0.33453035f, 0.25714388f, -0.21534730f, 0.23217739f, 0.14496383f, 0.41806573f, 0.32645249f, 
    0.16537374f, -0.25587174f, -0.03478020f, 0.09451101f, -0.22823770f, 0.03790614f, -0.05982446f, -0.18709938f, 
    0.11349258f, -0.20919606f, -0.04320894f, -0.07520849f, -0.20820716f, -0.14780056f, -0.09968057f, -0.14052169f, 
    0.14898230f, 0.08785985f, -0.08703900f, 0.17651658f, -0.26431456f, 0.21531107f, -0.24096912f, 0.00490162f, 
    -0.04356019f, 0.27684799f, 0.17855954f, -0.12627986f, -0.14695081f, 0.04553367f, 0.08479482f, 0.31518546f, 
    -0.07183379f, -0.35695854f, -0.10484760f, 0.16309896f, 0.52231145f, -0.07538769f, -0.26177371f, 0.30455035f, 
    -0.18932635f, -0.09144516f, -0.07514467f, 0.21202415f, -0.09332219f, 0.16008002f, 0.44490433f, -0.09257527f, 
    0.08342842f, -0.04695800f, 0.06414636f, 0.21655527f, -0.48063532f, 0.01581161f, 0.33883354f, 0.11311788f, 
    -0.16745406f, 0.21312916f, -0.24714401f, -0.13439496f, 0.03888086f, 0.18352285f, -0.17246687f, 0.12969247f, 
    -0.08599120f, -0.14135897f, 0.23211534f, -0.28265148f, 0.17435732f, -0.18854874f, 0.20320275f, 0.06868377f, 
    -0.16910829f, 0.23979211f, -0.24901018f, 0.00634155f, 0.04605438f, 0.09800213f, 0.03654261f, 0.09480940f, 
    -0.10779479f, -0.08897457f, -0.15747178f, -0.23437411f, -0.18046048f, -0.05706513f, -0.19622941f, 0.13366623f, 
    0.23001233f, -0.01691721f, -0.19191697f, -0.03518094f, -0.06837752f, 0.07097444f, -0.01007360f, 0.06509605f, 
    0.15897885f, -0.19188009f, -0.29685584f, 0.14818120f, 0.14085002f, 0.20680176f, 0.15024553f, -0.06811582f, 
    0.23940884f, -0.05033989f, 0.51340222f, -0.11230959f, 0.15873441f, 0.13880393f, 0.00541161f, 0.21188349f, 
    -0.10832522f, 0.20610064f, 0.21954466f, -0.17789254f, 0.08939578f, 0.24757949f, 0.10638582f, 0.04170408f, 
    -0.00413161f, -0.08187769f, 0.13016024f, 0.22099862f, 0.00335997f, 0.05169851f, -0.24208172f, -0.37489060f, 
    -0.00316185f, 0.07390579f, -0.01289710f, -0.21972530f, 0.39041233f, 0.01863096f, -0.41034812f, 0.38984746f, 
    0.06645251f, -0.15872492f, -0.01909961f, 0.21637151f, -0.03474020f, 0.08199166f, 0.03124138f, 0.00008817f, 
    0.21430913f, 0.03891971f, 0.20055743f, 0.20742644f, 0.12299407f, 0.13682872f, 0.22472173f, -0.05539874f, 
    -0.00616396f, -0.16102053f, -0.31423527f, 0.04821264f, -0.14144774f, 0.14558576f, 0.15480809f, -0.24617098f, 
    -0.03131115f, -0.12367218f, -0.19466430f, -0.15782923f, 0.26636997f, 0.15718022f, 0.19921683f, -0.25436702f, 
    0.07432032f, -0.23692155f, 0.34590092f, -0.23497124f, 0.01576021f, -0.05440828f, -0.47341269f, -0.26783416f, 
    -0.14761683f, 0.33910736f, 0.13532409f, 0.14262459f, 0.26692119f, 0.07141011f, -0.07676777f, 0.05886960f, 
    -0.19534853f, -0.04122988f, 0.05960241f, 0.21105619f, -0.22337610f, 0.06919372f, -0.37361166f, -0.37462568f, 
    0.06306141f, -0.40676501f, 0.18871027f, -0.27644798f, -0.07304383f, -0.08443002f, 0.21011092f, -0.31317633f, 
    0.21437897f, 0.28527761f, -0.02020890f, 0.21833208f, -0.00783813f, 0.19952202f, -0.09377678f, 0.46866190f, 
    0.18877716f, 0.26626000f, -0.36159396f, -0.34866232f, -0.06216028f, 0.21991952f, 0.10660101f, 0.22240895f, 
    -0.10423800f, 0.30189887f, -0.03706392f, 0.11174014f, 0.15023570f, 0.12902941f, 0.44387960f, 0.10892841f, 
    -0.08597401f, -0.26662672f, -0.27700806f, 0.15201902f, 0.17777975f, 0.12757421f, 0.13045065f, 0.27903751f, 
    -0.22000651f, 0.41618198f, -0.16700050f, 0.10796262f, -0.05097373f, 0.20908041f, 0.51335901f, -0.26567602f, 
    -0.15209305f, -0.25307760f, 0.38429445f, -0.21452002f, -0.30953100f, 0.17625727f, 0.17502256f, -0.26492268f, 
    -0.04675770f, 0.11705190f, -0.19111308f, 0.13431010f, 0.14471649f, 0.16373774f, 0.32808018f, 0.28429705f, 
    0.17133084f, 0.19494614f, -0.06199130f, -0.58344758f, 0.01524073f, 0.07222885f, -0.04454740f, 0.01665961f, 
    0.01163718f, 0.47209141f, -0.00854262f, 0.17208025f, 0.05683354f, 0.11252883f, 0.01972883f, -0.82547373f, 
    -0.14384319f, -0.07728709f, -0.06025657f, -0.05229287f, 0.15017255f, 0.12649499f, -0.29357475f, 0.38004950f, 
    -0.10940862f, -0.07114270f, 0.27388012f, 0.09859693f, 0.13597038f, -0.22060731f, 0.17435870f, 0.35364279f, 
    0.21610405f, -0.11159475f, -0.27978826f, 0.25679472f, -0.01928601f, -0.19457406f, 0.39258170f, -0.13924395f, 
    0.19484589f, 0.28174502f, 0.23317127f, -0.17741212f, -0.13007253f, 0.03885582f, 0.56827277f, -0.35611957f, 
    -0.08808771f, 0.14774752f, 0.30188867f, -0.43826461f, 0.45923060f, -0.05751342f, -0.33121282f, -0.01765238f, 
    -0.11474140f, 0.22781201f, 0.00265032f, -0.13353218f, -0.12311935f, -0.17614649f, 0.12351012f, 0.15081573f, 
    -0.10691349f, 0.00526643f, -0.20391580f, -0.34084785f, -0.46336851f, -0.14700203f, 0.10436743f, 0.18761858f, 
    -0.22363114f, -0.09404855f, -0.00455403f, 0.25427112f, -0.24010131f, 0.00863133f, 0.45593616f, 0.19645597f, 
    0.13812536f, 0.14060517f, -0.02373668f, 0.02493964f, 0.34469333f, -0.06662181f, -0.14998640f, -0.32799968f, 
    0.06464013f, 0.07359982f, -0.65193313f, 0.11318598f, 0.00473472f, -0.17139694f, -0.14922075f, 0.01021195f, 
    -0.02706972f, 0.45191330f, -0.42277545f, -0.56929493f, 0.11548150f, -0.20523646f, 0.33509466f, 0.03020034f, 
    0.22906186f, -0.04936594f, 0.12287945f, 0.10131783f, -0.17492881f, -0.14913192f, 0.18370540f, 0.04622696f, 
    0.07705975f, 0.08872239f, 0.29957956f, 0.42312431f, -0.05946416f, 0.21882789f, -0.07268389f, -0.07157104f, 
    0.14244094f, 0.04178223f, -0.19628824f, -0.06029487f, -0.19668843f, -0.10580487f, 0.28018284f, -0.39640954f, 
    -0.02533248f, -0.08731474f, 0.24292235f, 0.03796378f, 0.41822001f, -0.11541153f, 0.32168841f, 0.10122076f, 
    -0.08704124f, -0.20993352f, -0.51554030f, -0.23846568f, 0.04728034f, 0.22859092f, 0.17452991f, 0.33664221f, 
    -0.19960505f, 0.42247501f, -0.02507189f, -0.00364590f, 0.25455490f, -0.20721474f, 0.04810533f, 0.01583554f, 
    0.15215749f, -0.34021765f, 0.17619199f, -0.05229824f, 0.08145744f, 0.12455583f, 0.20790112f, 0.04769057f, 
    0.11605809f, -0.22463518f, -0.19914082f, -0.08591455f, -0.19277881f, 0.07258002f, 0.16109547f, 0.12801889f, 
    0.16015601f, 0.36275411f, 0.25163993f, 0.04523403f, 0.05789918f, -0.23153789f, 0.41796288f, 0.28956997f, 
    0.14073637f, -0.06033917f, -0.15594751f, 0.25389597f, 0.09088961f, 0.03199423f, 0.25423095f, -0.25090358f, 
    -0.21587515f, 0.35244235f, 0.23344806f, -0.05513804f, -0.24242371f, -0.22684741f, 0.11897675f, -0.24024038f, 
    -0.02178195f, -0.18292914f, -0.35971352f, 0.44119209f, -0.14226277f, -0.05383033f, -0.25055763f, 0.10327033f, 
    0.09314629f, 0.15883522f, -0.04574472f, 0.32702714f, -0.02981231f, -0.15348424f, 0.24179147f, 0.08564020f, 
    -0.12732919f, -0.10517599f, 0.12682106f, -0.60908037f, -0.34605730f, -0.09386493f, -0.19099689f, 0.20143941f, 
    0.05017975f, 0.17537884f, 0.10848325f, 0.09983869f, 0.17925812f, -0.17282389f, 0.48294833f, -0.02139057f, 
    0.20395955f, 0.00099500f, 0.27056769f, -0.28754404f, -0.22345227f, -0.23358445f, 0.01366943f, 0.12677552f, 
    -0.14389630f, 0.32381770f, -0.14586145f, -0.11143491f, 0.01336384f, -0.04236494f, 0.44442540f, 0.26843721f, 
    0.16094778f, 0.28599492f, 0.20147221f, 0.06555939f, -0.42258191f, 0.24525581f, -0.03325012f, 0.03873587f, 
    0.23406839f, 0.33363843f, 0.10631905f, -0.19975384f, -0.05660878f, 0.17370835f, 0.42103684f, -0.39119524f, 
    0.14229517f, 0.34005550f, 0.19737564f, -0.23031414f, -0.35917592f, 0.06475252f, 0.37272638f, -0.24219120f, 
    -0.12867320f, -0.00717312f, -0.38985029f, 0.08671586f, 0.12738743f, -0.01277703f, 0.42630470f, -0.22455306f, 
    0.00787792f, -0.13491593f, 0.17812265f, -0.19739589f, -0.01012707f, -0.05274147f, -0.03593989f, -0.01432092f, 
    0.25478348f, -0.57341409f, 0.28570694f, 0.22422068f, -0.02346733f, -0.08875014f, 0.87278026f, -0.32535937f, 
    -0.20333901f, 0.28883481f, 0.26597068f, -0.24843654f, -0.00737246f, 0.18620221f, -0.06358327f, 0.33806536f, 
    0.02355793f, 0.33494708f, -0.07663451f, -0.09322149f, 0.04076397f, -0.02086854f, 0.19845919f, -0.04235320f, 
    -0.07454824f, 0.42478374f, -0.02916456f, 0.05186911f, -0.43169123f, -0.24354006f, -0.36112371f, 0.19273436f, 
    -0.19303441f, -0.23598124f, -0.16003071f, 0.13913243f, -0.23244980f, -0.02045694f, -0.21458672f, 0.35196033f, 
    0.22998804f, 0.18889464f, 0.25779167f, -0.20737517f, -0.40593195f, -0.02504059f, 0.19404390f, -0.36958140f, 
    -0.21063961f, -0.03833508f, -0.10800701f, 0.36375734f, 0.23465662f, 0.06816369f, -0.15885951f, 0.28692397f, 
    0.18876261f, 0.48745868f, -0.00111109f, -0.39767715f, -0.40412199f, 0.11397102f, 0.34273535f, 0.09449079f, 
    -0.00469884f, -0.34572366f, 0.04674783f, -0.11469004f, -0.19125497f, 0.17647813f, 0.13016926f, -0.22949450f, 
    0.17298976f, 0.14657559f, -0.43360695f, 0.22637515f, -0.22932054f, -0.23360220f, 0.35923341f, -0.43023312f, 
    0.17893147f, 0.22491288f, -0.67453951f, 0.39950499f, -0.17588925f, 0.18561956f, -0.75784373f, -0.00585532f, 
    0.23089027f, 0.03322951f, -0.33169326f, -0.44108069f, 0.43876886f, -0.01436105f, -0.15852174f, -0.00195359f, 
    -0.18529648f, 0.04372201f, 0.02347153f, 0.33527383f, 0.09010458f, 0.08768079f, -0.02567645f, -0.41257536f, 
    0.08963402f, 0.12392181f, 0.31292552f, 0.28768161f, -0.22860135f, 0.18888627f, 0.23389511f, 0.02512599f, 
    0.22566734f, 0.05268041f, -0.30158702f, -0.26836237f, 0.16178362f, 0.07777844f, 0.50828159f, 0.15030129f, 
    0.10298639f, -0.19851284f, 0.30675906f, -0.26981467f, 0.05546731f, -0.15052618f, 0.32248065f, 0.10336622f, 
    0.23554060f, 0.12123480f, -0.42925557f, 0.07475179f, 0.22997914f, 0.16541876f, -0.23157085f, 0.24303360f, 
    0.06368822f, 0.32995728f, -0.41093472f, 0.16022649f, 0.01034800f, -0.04684073f, -0.40592632f, -0.24795540f, 
    0.22988099f, 0.52803880f, 0.09836825f, 0.05506147f, 0.19063407f, 0.08601379f, 0.11287434f, -0.22889495f, 
    0.07898173f, -0.11750701f, -0.03361945f, -0.11928625f, -0.11791877f, 0.19167925f, -0.16477895f, -0.54588181f, 
    -0.19737244f, 0.20892969f, 0.28880340f, -0.11913813f, 0.13243465f, -0.18332407f, 0.28244355f, 0.43607134f, 
    -0.21245658f, -0.09171718f, -0.06774072f, 0.23170966f, -0.17783682f, -0.16723473f, -0.05814560f, -0.45716652f, 
    -0.08811449f, 0.07751793f, 0.34476456f, -0.28345191f, 0.15136492f, -0.02830604f, 0.25406253f, 0.36381087f, 
    -0.06620365f, -0.28172219f, -0.28006229f, -0.35345915f, 0.51808721f, 0.09224708f, 0.11990168f, -0.15229394f, 
    0.13372386f, -0.44133022f, 0.10669561f, 0.40175974f, -0.00950503f, 0.19063407f, 0.62412959f, -0.02984487f, 
    0.22876027f, -0.16808219f, -0.24067502f, -0.10258209f, 0.08902878f, 0.08222920f, 0.45046726f, -0.08339550f, 
    -0.01277560f, -0.42453200f, 0.12212636f, 0.14121059f, -0.03000748f, 0.08635058f, -0.29648820f, 0.38218555f, 
    -0.12361241f, -0.18251403f, -0.10393529f, -0.22464851f, 0.39873075f, -0.11514574f, -0.05785018f, 0.34641331f, 
    -0.12807055f, 0.45435610f, -0.21654522f, -0.12714912f, -0.24703871f, 0.05142648f, 0.03423043f, 0.38333696f, 
    0.16669662f, -0.03594954f, 0.18147166f, 0.12092598f, -0.49529341f, -0.19914547f, 0.02736292f, 0.26234868f, 
    0.18191874f, 0.18455358f, -0.24665709f, -0.22523402f, -0.17850323f, -0.25514951f, 0.21351445f, 0.37539110f, 
    0.23888369f, 0.08392955f, 0.02353978f, 0.04981603f, -0.08493295f, -0.21553279f, 0.13814242f, -0.06906246f, 
    0.11495773f, -0.45243984f, 0.05387018f, 0.29091117f, -0.12102032f, 0.09090042f, -0.27698156f, -0.03671356f, 
    -0.06060985f, -0.28000915f, -0.02370290f, -0.07106971f, -0.23057997f, 0.10737713f, -0.10932835f, 0.41829705f, 
    -0.05153378f, 0.34430683f, 0.17755669f, -0.01025447f, -0.05096709f, 0.03653916f, -0.00869776f, -0.40487665f, 
    -0.10290772f, 0.03558967f, -0.24272087f, -0.07755873f, -0.12333924f, 0.05795479f, -0.21112460f, -0.22330713f, 
    0.11924452f, 0.02380526f, 0.12601468f, -0.11436686f, -0.05408666f, -0.04675016f, -0.07233962f, -0.22427946f, 
    -0.15139660f, -0.38153163f, 0.38324499f, -0.00801432f, -0.23870970f, -0.12666155f, 0.34250036f, 0.17195690f, 
    0.12391278f, -0.10191743f, -0.12911440f, 0.04618898f, -0.21771669f, -0.19676982f, -0.33756670f, 0.11693832f, 
    -0.16293305f, 0.49655792f, 0.06803180f, 0.29220933f, 0.16965716f, -0.18337235f, -0.00540046f, -0.32182971f, 
    0.03763700f, -0.15225624f, -0.27806738f, 0.30994678f, 0.12846816f, 0.11386189f, -0.26595941f, 0.37419489f, 
    0.11674541f, 0.30365872f, 0.17803624f, 0.25526997f, 0.28792563f, 0.16699870f, -0.02723137f, -0.05671218f, 
    -0.00430850f, -0.12621568f, -0.16054875f, -0.02211092f, 0.10575800f, 0.21244290f, -0.21232815f, -0.19450942f, 
    0.00481952f, -0.17383039f, -0.36598989f, -0.09266244f, 0.42752019f, -0.19508751f, -0.09219249f, 0.13158025f, 
    0.22386214f, 0.32190788f, -0.07771764f, -0.08402911f, 0.08552828f, -0.15398197f, 0.32442927f, 0.39639816f, 
    0.15796646f, 0.00722723f, 0.09308539f, -0.00019942f, 0.08042008f, -0.19677006f, 0.11506149f, 0.11737831f, 
    -0.03184910f, -0.42460105f, 0.14894210f, 0.15147193f, -0.10972427f, 0.04088316f, 0.03035223f, -0.15087192f, 
    0.12944551f, -0.04018458f, -0.33295730f, -0.27411929f, -0.24763122f, -0.10354338f, 0.23849916f, -0.47717249f, 
    0.11755589f, 0.17879115f, 0.08647525f, 0.34520301f, -0.04299987f, -0.07881606f, 0.16358049f, 0.24375081f, 
    0.02717644f, 0.35364223f, -0.23830166f, 0.44514447f, 0.03421413f, 0.10743799f, 0.10736012f, -0.13555637f, 
    -0.10931603f, -0.09727865f, 0.15969750f, 0.14712480f, -0.12591118f, -0.01119506f, -0.09627537f, -0.10756750f, 
    0.21881071f, -0.27995455f, 0.00930536f, 0.37084568f, 0.30717650f, 0.08004516f, -0.43679541f, 0.16134313f, 
    -0.18478131f, 0.54998952f, -0.02292538f, -0.42625675f, 0.22666737f, -0.12447903f, -0.63490242f, 0.20136377f, 
    -0.11951154f, 0.42961156f, 0.21496871f, 0.00958638f, -0.47592375f, 0.17679703f, -0.03356714f, -0.00616659f, 
    0.21934775f, 0.27340454f, -0.04532725f, -0.07016122f, -0.09831905f, -0.19375047f, 0.57000744f, -0.23150387f, 
    -0.22533387f, -0.16064453f, 0.32167208f, -0.37958431f, -0.19387111f, 0.16931286f, -0.05729093f, -0.22103791f, 
    0.03550147f, 0.40469092f, -0.11111591f, 0.24759668f, 0.15396929f, 0.04752005f, 0.06585503f, 0.27732614f, 
    -0.03186989f, -0.05117580f, 0.36034200f, -0.07134905f, 0.09204137f, 0.11058813f, 0.46518365f, 0.13764997f, 
    0.03550449f, -0.18554637f, -0.21223398f, -0.21385320f, 0.02030523f, -0.21745080f, 0.00261297f, -0.28720289f, 
    0.15577614f, -0.22168837f, -0.25759691f, 0.20198223f, 0.17439377f, 0.22299041f, -0.31119540f, 0.40181971f, 
    0.01913613f, 0.32471585f, -0.28852153f, 0.37777728f, 0.12176153f, 0.17035435f, -0.02763527f, 0.09218501f, 
    0.08061084f, 0.37305966f, 0.21860515f, -0.03223930f, 0.29912931f, 0.13596711f, -0.14325568f, -0.04016619f, 
    -0.01888570f, -0.11834019f, -0.03498871f, -0.32725564f, 0.16718554f, 0.22396654f, -0.19461393f, 0.23153776f, 
    0.23891237f, 0.00781284f, -0.15831479f, 0.36023703f, -0.04278269f, -0.03400252f, 0.34799439f, -0.09499096f, 
    0.07246815f, 0.15832099f, 0.26934868f, -0.06742613f, -0.16923618f, 0.18187267f, 0.29449272f, -0.32973182f, 
    0.04908159f, 0.15197749f, 0.16181725f, 0.15924329f, -0.00448844f, -0.21897116f, -0.24070756f, -0.55908585f, 
    -0.09056971f, 0.03170087f, 0.31003559f, -0.26508313f, -0.16946962f, -0.23585805f, -0.10360378f, 0.49526945f, 
    -0.13648660f, 0.14282066f, -0.13230340f, 0.30529234f, -0.01556474f, -0.04825900f, 0.09423009f, 0.34409353f, 
    -0.17843269f, 0.02895101f, -0.28761730f, -0.07039532f, 0.24752876f, -0.17678614f, -0.74608296f, -0.17489888f, 
    0.05212283f, -0.11720511f, 0.37943813f, 0.05939888f, 0.27568966f, -0.10496191f, 0.01192882f, 0.02325633f, 
    -0.15598522f, -0.10879343f, -0.30364892f, 0.18148340f, 0.24130309f, -0.07914699f, 0.00040125f, -0.04963627f, 
    -0.12709562f, 0.05574232f, -0.09650993f, 0.41726527f, 0.12602790f, 0.23851134f, 0.16021121f, -0.10137662f, 
    0.16475049f, -0.28447643f, -0.13138603f, 0.25369516f, 0.08855513f, 0.10595094f, 0.04718516f, -0.18489003f, 
    0.18952851f, -0.42370969f, 0.05716994f, 0.21601741f, 0.33508241f, -0.00943254f, -0.24986827f, 0.12617207f, 
    0.15329358f, 0.01071969f, 0.11395096f, 0.12120565f, 0.11484631f, -0.20017828f, -0.24764536f, 0.19356683f, 
    0.00380394f, -0.20467860f, 0.05213340f, -0.18946616f, -0.04137014f, 0.04341391f, -0.22910896f, -0.04567014f, 
    -0.21959540f, 0.12505145f, -0.13175142f, -0.14443824f, 0.05767098f, -0.00902051f, -0.11269403f, -0.15417509f, 
    -0.02354610f, 0.26248020f, 0.00154401f, -0.12999140f, 0.30642012f, -0.11719936f, -0.22864014f, -0.13365115f, 
    -0.12266493f, -0.07860184f, 0.40921339f, 0.04912599f, 0.16569087f, -0.08693093f, 0.06265292f, 0.13817663f, 
    -0.08962306f, -0.30865470f, -0.38032597f, -0.06096635f, -0.48641163f, -0.19832046f, 0.31845981f, 0.31995195f, 
    -0.21144605f, 0.10135860f, 0.36511686f, 0.12714815f, -0.05726987f, -0.06303818f, 0.11516433f, -0.02701085f, 
    -0.19062048f, 0.33230135f, 0.24404126f, -0.30165234f, 0.24959800f, -0.11873989f, -0.26038846f, 0.32789952f, 
    0.24647368f, -0.20137322f, -0.13587731f, 0.03670219f, 0.02948257f, -0.24575797f, 0.15237391f, -0.08734643f, 
    0.00870099f, -0.21230948f, 0.15794975f, -0.32305863f, -0.43990549f, 0.17930874f, 0.24443708f, 0.20974271f, 
    0.13197576f, 0.26277703f, 0.12549825f, -0.14532205f, -0.08289835f, 0.07941363f, 0.55464041f, 0.18969066f, 
    0.12136626f, 0.04915262f, 0.04831795f, 0.45920575f, -0.04311582f, -0.04136069f, -0.10178944f, -0.14360309f, 
    -0.15251529f, 0.00165012f, 0.10739604f, 0.21293852f, -0.07638684f, -0.11486325f, 0.26103938f, -0.31338111f, 
    -0.06851070f, -0.27525505f, -0.11906835f, 0.01325518f, 0.24822085f, -0.25440052f, 0.32817677f, -0.38648206f, 
    0.19817474f, 0.09218556f, -0.10411147f, 0.31952316f, -0.17077114f, 0.18281031f, -0.08698877f, -0.04328388f, 
    -0.18353122f, -0.00027741f, 0.03422608f, 0.05410605f, -0.39054701f, -0.21490373f, -0.09761096f, -0.16111340f, 
    -0.06189435f, -0.40794384f, 0.05944222f, 0.37898928f, -0.06384339f, -0.08195063f, 0.05564331f, 0.22042240f, 
    0.14726853f, 0.18373747f, -0.23473421f, -0.07173037f, -0.27289727f, -0.09411192f, -0.12679005f, -0.16904227f, 
    0.00411102f, 0.07394520f, -0.18684973f, -0.08724219f, -0.04760119f, -0.22471803f, -0.11499459f, -0.26880193f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.39214343f, 0.16584095f, 0.10528053f, 0.29331917f, 0.06095776f, 0.44677845f, 0.10050379f, 0.29246435f, 
    -0.00506016f, 0.24118972f, 0.03651925f, -0.03931141f, 0.34178892f, 0.15286820f, 0.27873343f, -0.36731952f, 
    0.38328502f, 0.43417910f, -0.31625953f, 0.05372198f, 0.02320555f, -0.19271627f, -0.12474042f, 0.07371149f, 
    0.42023379f, 0.31374919f, -0.47029796f, 0.13772519f, -0.33458179f, -0.20856500f, 0.07435276f, -0.20603561f, 
    0.08054314f, 0.20172542f, 0.33024964f, -0.41291988f, 0.03524167f, -0.00918876f, 0.40408602f, 0.47783169f, 
    0.12353996f, -0.15127997f, 0.40123957f, 0.09648676f, -0.07377189f, 0.34667701f, 0.30806026f, 0.07473331f, 
    0.11691031f, -0.11118604f, -0.26893795f, 0.30666277f, 0.12254908f, 0.03311668f, 0.10885864f, 0.24797331f, 
    0.02940089f, 0.31884876f, -0.01996105f, 0.02615988f, -0.05859369f, -0.10440475f, 0.27130523f, 0.02202493f, 
    0.14341560f, -0.29630560f, -0.30434144f, 0.02340157f, 0.33811799f, -0.20092955f, 0.10992643f, 0.20958920f, 
    -0.16540378f, -0.50059336f, -0.19641630f, 0.15682311f, 0.14576080f, 0.12896816f, -0.08467510f, 0.02174416f, 
    0.02184943f, -0.17497645f, -0.33373633f, 0.22050339f, 0.09922642f, 0.21643187f, 0.05594273f, 0.22112083f, 
    -0.11876155f, 0.29901543f, -0.36660627f, 0.43726772f, 0.13566443f, 0.08738247f, 0.44394588f, 0.13495277f, 
    0.04372872f, 0.42868397f, 0.38723409f, -0.17099354f, 0.48588839f, -0.18045066f, 0.29903221f, 0.11097782f, 
    0.07007916f, 0.58112746f, -0.17426366f, -0.01139482f, -0.16747268f, 0.35016939f, 0.29019192f, -0.24297041f, 
    -0.30133528f, 0.15654315f, -0.21225992f, 0.37107867f, 0.16252834f, 0.34912315f, 0.46887594f, -0.09146772f, 
    -0.49067104f, -0.09365396f, 0.01715359f, -0.05788978f, 0.06751946f, 0.28927761f, 0.24963249f, 0.03031020f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.02364340f, 0.01672112f, 0.27097961f, 0.14032984f, 0.14298064f, 0.07376932f, 0.19050108f, 0.09159882f, 
    0.04601200f, 0.00872111f, -0.25984752f, 0.59600395f, 0.00967120f, -0.08098271f, 0.04783978f, -0.20385869f, 
    0.16656731f, -0.29066679f, 0.11088403f, -0.00865118f, -0.06744052f, 0.07780329f, -0.07202974f, 0.13807780f, 
    0.24611349f, -0.15838310f, 0.14157356f, 0.13602364f, 0.28469232f, 0.05690586f, 0.00303922f, -0.03717801f, 
    0.01256382f, -0.30297351f, -0.26243341f, 0.37730038f, -0.35862809f, 0.22084004f, 0.00158901f, -0.38413149f, 
    0.18977864f, -0.31007686f, -0.12017196f, 0.55963373f, 0.10442194f, -0.22171190f, 0.08701735f, 0.09351570f, 
    0.04533584f, 0.06937196f, -0.06024554f, 0.10195146f, 0.06960161f, -0.01541033f, 0.21711519f, -0.16651031f, 
    -0.21335426f, 0.12711537f, 0.32693031f, -0.00248781f, 0.07690591f, -0.23246787f, -0.21476816f, 0.16762313f, 
    0.08282853f, -0.04890047f, 0.10416839f, 0.18996920f, -0.12725067f, -0.08157589f, -0.15524492f, 0.03956944f, 
    0.53998822f, -0.02381933f, -0.12550291f, -0.05164327f, -0.07099213f, 0.07993006f, 0.14401536f, -0.23567455f, 
    0.00245398f, -0.75864738f, 0.04398452f, 0.27390698f, 0.04828582f, -0.20776722f, -0.03302308f, -0.41781202f, 
    0.30938476f, 0.14396201f, -0.09679338f, -0.13179761f, 0.12767759f, -0.52670109f, 0.21928406f, 0.12760343f, 
    0.22013396f, -0.23301902f, -0.35811129f, -0.00921483f, 0.22045580f, 0.11272830f, 0.20826952f, 0.02401918f, 
    -0.19073489f, -0.25773185f, 0.00907019f, -0.39021358f, -0.08481568f, 0.00102242f, 0.19297510f, -0.24367583f, 
    0.43433931f, 0.06416874f, 0.11210185f, -0.09909987f, 0.12401637f, -0.02983914f, 0.05491741f, -0.04089174f, 
    -0.10731559f, -0.05805104f, -0.09292041f, 0.05993652f, -0.15532696f, -0.05458386f, -0.28163409f, -0.00511740f, 
    0.15866861f, -0.54678524f, 0.11698242f, -0.04511192f, -0.19005595f, -0.40434200f, -0.11910407f, -0.53759903f, 
    0.03355687f, 0.15931560f, 0.10211448f, 0.15655647f, -0.22803961f, 0.07561244f, 0.00328451f, -0.01631891f, 
    -0.39580631f, 0.29884627f, 0.13803449f, 0.06324863f, -0.07803533f, 0.06836735f, -0.03446847f, -0.04850670f, 
    -0.11061720f, -0.02341302f, 0.15262713f, 0.00550056f, -0.02406017f, 0.32445237f, 0.04458925f, 0.17923175f, 
    0.07402351f, 0.30970874f, -0.41780177f, -0.08893771f, 0.19857362f, -0.14462449f, -0.10747846f, 0.03498552f, 
    0.21162640f, -0.04236591f, -0.53201050f, -0.14445966f, -0.37323061f, 0.17995372f, -0.05812199f, -0.00336545f, 
    -0.03431407f, -0.03266260f, -0.32122707f, -0.29305795f, -0.24486323f, -0.08661801f, 0.26843271f, 0.08550379f, 
    -0.02690934f, -0.28431842f, 0.33417636f, -0.04851263f, -0.34189475f, 0.05933666f, -0.60491514f, 0.27796662f, 
    -0.18453877f, 0.08152723f, 0.03457246f, -0.06130680f, 0.24627183f, -0.13614024f, 0.27411824f, -0.10862873f, 
    -0.27726868f, 0.29460740f, 0.10309914f, -0.26427329f, -0.26328212f, 0.15842311f, -0.18108602f, 0.11886287f, 
    0.11818813f, 0.41088822f, -0.10277384f, 0.38253704f, 0.03128152f, 0.31180641f, 0.36402053f, -0.29236042f, 
    -0.30873716f, -0.32142651f, 0.01246772f, 0.12717170f, 0.23455396f, -0.09684235f, 0.41172415f, -0.45278692f, 
    -0.46092224f, 0.23878634f, -0.02353762f, -0.04207733f, -0.14283799f, -0.02653258f, -0.21771747f, -0.36371464f, 
    0.11468314f, 0.29170409f, 0.05974678f, 0.57307392f, 0.08570341f, -0.24474937f, -0.16793402f, -0.51739162f, 
    0.03401408f, -0.01731021f, 0.25227010f, -0.33423445f, -0.34219843f, -0.28008729f, -0.15939920f, -0.07414926f, 
    0.24785994f, 0.22974761f, 0.07193570f, 0.02284417f, -0.18458658f, -0.50731963f, 0.39466476f, -0.06210122f, 
    -0.08040709f, -0.05231091f, 0.02785172f, 0.02829682f, -0.03417850f, 0.03905648f, 0.04683085f, 0.04536270f, 
    -0.24906740f, 0.03054551f, 0.11143617f, -0.19079031f, 0.08801107f, -0.05250761f, 0.04881940f, -0.02461941f, 
    -0.05390497f, 0.23468474f, 0.15860553f, -0.07798284f, 0.17415464f, 0.07687298f, -0.08056370f, 0.22359830f, 
    0.10001910f, 0.24881263f, 0.19003165f, -0.04984734f, -0.29104501f, 0.30999950f, 0.18635578f, 0.33657286f, 
    -0.10347019f, 0.20101246f, 0.15252860f, 0.00792215f, 0.31918836f, 0.04540440f, 0.13555656f, 0.39579627f, 
    0.02612551f, 0.17503414f, 0.02046784f, -0.29624340f, -0.15821931f, -0.14766553f, -0.22936495f, 0.04027418f, 
    0.03112021f, 0.23929729f, -0.42264092f, 0.02069320f, -0.04567181f, -0.05189151f, 0.30406478f, 0.03684808f, 
    -0.13635607f, 0.09662318f, -0.35227773f, -0.01268124f, -0.08437010f, 0.18309417f, 0.04664458f, 0.09935752f, 
    -0.24692911f, 0.05532419f, 0.16013050f, -0.23374833f, 0.26535201f, -0.31972051f, 0.24759786f, 0.12763132f, 
    -0.08337734f, 0.36983600f, 0.25810614f, 0.17909175f, 0.17055789f, 0.04091685f, 0.07915647f, 0.32622677f, 
    0.20067416f, -0.04982776f, 0.05294314f, 0.12432078f, 0.01248420f, 0.07717940f, -0.07623887f, -0.35015649f, 
    0.05770454f, -0.13533375f, -0.27085814f, 0.29423302f, 0.32903063f, 0.07455927f, 0.07418077f, -0.21835053f, 
    0.12719871f, -0.10221270f, 0.16511996f, -0.00472957f, -0.05320357f, -0.01038020f, -0.00629852f, 0.12421469f, 
    0.09015381f, 0.60868251f, 0.23086445f, 0.32058588f, 0.34417403f, -0.11047899f, -0.08099908f, -0.06683598f, 
    0.09436635f, 0.29503542f, 0.33451748f, -0.08174162f, -0.01475250f, 0.02523276f, -0.08012095f, 0.06391624f, 
    0.14866772f, 0.38891929f, 0.04032535f, 0.13763857f, 0.27025795f, 0.06859364f, 0.06217406f, -0.00203208f, 
    0.03951991f, -0.04418005f, -0.03613812f, -0.01986183f, 0.02679300f, 0.05929503f, -0.01753248f, -0.02140537f, 
    0.04341862f, 0.06723633f, 0.06665818f, -0.11604681f, -0.10103561f, -0.11512776f, -0.00933558f, -0.00085414f, 
    0.00295776f, -0.01508774f, -0.07087457f, 0.01764897f, 0.04329605f, 0.04965656f, -0.04231173f, 0.04804884f, 
    0.04262774f, -0.07918690f, 0.03576728f, -0.00063183f, 0.01212546f, 0.04824594f, -0.07543844f, 0.04209602f, 
    -0.09497602f, 0.00146176f, -0.09441727f, -0.00492654f, -0.04267015f, 0.06435433f, 0.06247229f, -0.08275397f, 
    -0.05936276f, -0.03147831f, 0.07618108f, 0.05824381f, 0.06796578f, 0.04614294f, 0.06022543f, -0.08403532f, 
    0.03491881f, -0.06030396f, -0.05633038f, 0.06070693f, 0.05669359f, -0.02307508f, 0.04719857f, 0.00812954f, 
    -0.01656309f, 0.00364759f, -0.07350101f, -0.03376031f, -0.03901980f, 0.05374672f, -0.01872031f, -0.07897881f, 
    0.00528912f, -0.08047242f, 0.01243071f, -0.04483275f, 0.06674471f, -0.02335574f, 0.02624378f, -0.04517169f, 
    0.04894312f, -0.07538769f, -0.10604911f, -0.08188741f, -0.07869906f, -0.03793214f, 0.01561010f, -0.02746765f, 
    -0.08251142f, 0.04796590f, 0.02896841f, -0.06399037f, -0.09940219f, -0.04922126f, -0.06170728f, -0.05700536f, 
    0.01010294f, -0.09035786f, -0.00698094f, 0.01301058f, 0.06078085f, -0.04894596f, -0.06451850f, -0.05679959f, 
    -0.00890037f, -0.09054653f, 0.05335947f, -0.06458325f, 0.04479362f, -0.06752444f, -0.03341315f, -0.01663905f, 
    0.02585690f, -0.09568175f, -0.08585493f, -0.01398792f, 0.04705152f, -0.09457723f, 0.05324981f, 0.05206050f, 
    0.02323859f, 0.00496205f, -0.01519176f, -0.05878391f, -0.03390678f, -0.01943991f, -0.09914508f, -0.00980321f, 
    -0.06905458f, -0.00553116f, -0.03691657f, -0.09546229f, -0.11954235f, -0.09062210f, 0.04473802f, 0.01788048f, 
    0.02099454f, -0.00691894f, 0.03857500f, -0.09146527f, -0.00812807f, -0.09836551f, 0.04602866f, -0.08381779f, 
    -0.08878782f, -0.02104710f, 0.00277988f, 0.00004351f, 0.01603571f, 0.06067994f, 0.05370595f, -0.09404992f, 
    0.03895500f, -0.06355868f, -0.04070169f, -0.08327007f, -0.09628514f, -0.07209293f, 0.04971953f, -0.01194013f, 
    -0.10245740f, -0.09215248f, 0.03060316f, -0.07523727f, -0.07971991f, -0.08575403f, 0.06951831f, -0.01451988f, 
    -0.10143796f, -0.01394338f, -0.01333238f, 0.01955762f, 0.06575111f, -0.07027548f, 0.03094062f, 0.06751233f, 
    0.00999104f, -0.09296127f, -0.05140707f, -0.10094811f, 0.03860093f, 0.06676393f, -0.05560685f, -0.01282111f, 
    -0.07811169f, 0.03160800f, 0.04979895f, -0.01409111f, 0.03904774f, 0.08051110f, -0.02060172f, -0.05750474f, 
    -0.07826056f, -0.01306224f, 0.04671762f, -0.05989927f, -0.01519551f, 0.00156147f, 0.04990790f, 0.00926713f, 
    0.03931075f, 0.02023986f, -0.09652965f, 0.01934484f, -0.08787184f, -0.03866923f, -0.03735426f, -0.00864010f, 
    0.02198818f, 0.03332083f, -0.07227986f, 0.00258917f, -0.07547548f, 0.06532681f, -0.01686086f, 0.01914816f, 
    0.06295321f, 0.05785881f, -0.07491913f, -0.02219709f, 0.05292913f, -0.10478900f, -0.07118608f, 0.00778025f, 
    -0.06255878f, -0.07862312f, -0.08147474f, -0.05993220f, 0.04795319f, 0.02875221f, -0.08232890f, 0.07087404f, 
    -0.09193668f, -0.08837087f, -0.08553418f, 0.06236408f, -0.06556355f, -0.05948611f, -0.06144176f, -0.04783336f, 
    0.00243530f, 0.04770963f, 0.06862827f, -0.00079486f, -0.01218463f, -0.04117828f, 0.01833136f, -0.07741758f, 
    -0.07968620f, -0.08794864f, -0.03918741f, -0.05692615f, 0.06591524f, -0.05555334f, -0.01243999f, 0.05989267f, 
    0.03478855f, -0.02912027f, 0.01525026f, -0.09603146f, 0.06223423f, -0.08979273f, -0.05138049f, -0.08153085f, 
    -0.08964694f, 0.02466601f, -0.07458316f, -0.01753318f, -0.01613129f, 0.06539585f, -0.08924236f, -0.02438338f, 
    0.01688362f, 0.00210600f, -0.05175120f, 0.06190111f, -0.01280232f, 0.08149817f, -0.05864382f, 0.01486048f, 
    -0.07800810f, -0.04948324f, 0.05951218f, -0.03596060f, -0.07794345f, -0.08419885f, 0.07060326f, -0.02872720f, 
    0.06496959f, -0.09512603f, -0.05533472f, -0.00937485f, 0.05516508f, 0.06454754f, -0.00925151f, -0.02910208f, 
    -0.00501963f, 0.06717064f, -0.09338082f, -0.05506641f, -0.07278997f, 0.04145131f, -0.02660611f, 0.00087803f, 
    -0.02611868f, 0.00520842f, 0.05437039f, -0.05545833f, -0.01601300f, -0.01329888f, -0.03121028f, -0.01693847f, 
    0.00927521f, -0.03059304f, -0.01556918f, -0.00027787f, 0.01182314f, -0.01433845f, 0.07003038f, -0.08463349f, 
    0.01669012f, -0.04261550f, 0.06115082f, 0.00995482f, -0.04192375f, -0.04107458f, -0.00636938f, -0.00983064f, 
    -0.06306200f, -0.03112029f, 0.01971556f, 0.06793520f, -0.04488938f, -0.06249369f, -0.05643432f, -0.04744979f, 
    -0.04576264f, 0.04216436f, -0.03034688f, -0.05457396f, 0.04975392f, -0.00668397f, -0.05224999f, -0.08721540f, 
    0.02999294f, -0.05542558f, -0.08356652f, 0.08408100f, 0.06416145f, -0.01470010f, -0.04150573f, -0.07792712f, 
    -0.03118438f, 0.00434478f, -0.03838168f, 0.01611619f, -0.03740366f, -0.00644866f, -0.06601825f, 0.01877727f, 
    -0.06160406f, 0.02121348f, 0.05021998f, -0.05365070f, 0.00116008f, -0.03209749f, 0.04115080f, -0.00856390f, 
    0.04626212f, -0.08511440f, 0.06814561f, -0.03316759f, -0.03055047f, -0.00248718f, -0.03796199f, 0.07921084f, 
    0.04019848f, -0.04720040f, 0.04191567f, -0.00834083f, -0.05277047f, -0.03807807f, -0.07889940f, 0.08109345f, 
    0.02957165f, -0.02250426f, -0.02571350f, 0.04113913f, -0.04816951f, -0.09173744f, -0.03109758f, 0.00888045f, 
    0.03328263f, -0.02240793f, -0.03581618f, -0.03149319f, -0.09148813f, 0.04125301f, -0.02886075f, -0.12041242f, 
    -0.08405956f, 0.01257702f, 0.02487798f, 0.03087960f, 0.00828812f, 0.04299857f, 0.05872469f, -0.06332860f, 
    0.03019732f, -0.00457533f, -0.04853752f, -0.11503740f, -0.08855996f, -0.04542537f, -0.01516410f, -0.06545531f, 
    -0.01139608f, -0.08545360f, 0.00176568f, -0.11754781f, -0.02754981f, 0.00306050f, -0.11591951f, 0.00382574f, 
    0.03097073f, -0.02102029f, 0.02009512f, 0.05392537f, -0.08811267f, 0.05281101f, 0.04125278f, -0.08246689f, 
    -0.09765696f, -0.08867787f, -0.07603963f, -0.09698645f, -0.00685729f, -0.06652598f, -0.07801675f, -0.05976236f, 
    -0.05690795f, 0.00563356f, 0.06268515f, -0.00375213f, -0.08309928f, 0.03562203f, -0.04177284f, -0.10313550f, 
    -0.09483646f, -0.08603279f, -0.07459453f, -0.00898322f, -0.00070363f, 0.08402507f, -0.03501926f, -0.02379655f, 
    -0.07801845f, 0.02766486f, -0.09733941f, 0.01511913f, 0.02273683f, -0.01646982f, 0.05224842f, -0.10601697f, 
    0.02930679f, 0.04317667f, 0.03437950f, 0.01304298f, 0.02212732f, 0.01365636f, -0.06029192f, -0.04326421f, 
    0.09051181f, 0.07999515f, 0.01689747f, 0.04529867f, -0.07182995f, -0.01712980f, -0.09798878f, 0.03723658f, 
    0.03312255f, -0.02093908f, -0.04565630f, 0.01803218f, 0.03640578f, -0.08363275f, -0.08389425f, -0.06160724f, 
    0.11010103f, 0.00046444f, -0.08366846f, 0.05944518f, 0.00967404f, -0.09167244f, -0.07548789f, -0.00720480f, 
    -0.06366269f, -0.08977751f, 0.06428204f, 0.05645206f, 0.06404096f, -0.05178882f, -0.12377050f, -0.02637088f, 
    -0.04578782f, -0.00714953f, -0.09498664f, 0.02518662f, -0.01662394f, -0.11007792f, -0.02424240f, 0.07572623f, 
    0.08835352f, -0.01762261f, 0.12002327f, 0.09065314f, -0.00256516f, 0.01502579f, -0.00784806f, 0.05346666f, 
    -0.05519549f, -0.05959415f, 0.11999634f, -0.17408176f, -0.01064936f, -0.24011204f, -0.16485877f, 0.16339022f, 
    0.38150504f, 0.04969526f, -0.00665011f, 0.08157413f, -0.06162015f, 0.05790756f, 0.16894765f, 0.06153129f, 
    -0.19860448f, -0.06986587f, 0.03848924f, 0.02450564f, -0.23994535f, 0.06271968f, -0.08152235f, -0.42863795f, 
    -0.24585344f, 0.15943371f, 0.00722552f, 0.25396362f, 0.22310287f, 0.15646482f, -0.44893062f, -0.43181196f, 
    0.08052076f, 0.04512904f, 0.03653030f, 0.13490999f, 0.25168023f, -0.02880028f, -0.34706602f, 0.10083642f, 
    0.17874859f, -0.00390923f, -0.00126941f, 0.16598518f, 0.06549187f, 0.35004538f, 0.23521847f, 0.13271110f, 
    0.00495989f, -0.08096925f, 0.54407060f, -0.12673907f, 0.11377747f, -0.01429888f, 0.06305481f, -0.01784656f, 
    0.19906905f, 0.00837442f, -0.37939224f, -0.10213227f, 0.05041456f, 0.10602318f, 0.17562929f, -0.31912151f, 
    0.46105704f, 0.10551091f, 0.09714401f, 0.10966809f, -0.10095669f, -0.01592914f, 0.04036245f, -0.28517151f, 
    0.09979481f, -0.09070784f, 0.15070802f, -0.04925319f, 0.15110001f, -0.09642962f, 0.01567520f, -0.12360031f, 
    -0.45631114f, -0.04245339f, 0.06230883f, 0.18477011f, -0.26034489f, 0.04014288f, -0.37114051f, 0.58962476f, 
    -0.21376613f, -0.02368725f, 0.10403243f, -0.30090693f, -0.03823683f, 0.57469362f, 0.02651883f, 0.40682164f, 
    -0.11434792f, -0.07966640f, -0.01095120f, -0.05242992f, -0.29645443f, -0.25394571f, -0.02517481f, 0.19256288f, 
    -0.11791883f, -0.18888187f, -0.12030154f, 0.19820723f, -0.13013519f, 0.02225375f, -0.03969601f, 0.43426913f, 
    0.17768531f, -0.16347608f, -0.10523356f, 0.15881082f, -0.03177136f, -0.11292438f, 0.06308678f, 0.02010846f, 
    0.19463862f, -0.21434996f, 0.20843370f, -0.04131920f, -0.29108664f, 0.01765466f, -0.20776357f, 0.03304578f, 
    0.15250207f, 0.03777571f, -0.05653528f, -0.38395879f, -0.10444324f, -0.16710749f, -0.07657467f, -0.01600227f, 
    0.24037817f, -0.06898256f, 0.07962291f, -0.00681696f, -0.04103836f, -0.18949048f, 0.20968966f, 0.08786761f, 
    -0.34702930f, 0.10887001f, 0.01811540f, 0.04451722f, 0.05815451f, 0.07945267f, -0.02544261f, -0.00213083f, 
    -0.06623302f, 0.04654256f, 0.09726954f, 0.17369793f, 0.00514807f, 0.14426656f, 0.04336431f, -0.16619723f, 
    -0.03411280f, 0.18686673f, 0.05426728f, 0.01838018f, 0.46202841f, -0.17054069f, -0.19398558f, -0.39278108f, 
    0.07460505f, -0.00257217f, -0.19975922f, 0.11306112f, 0.22175251f, 0.40096322f, -0.07002746f, 0.20868754f, 
    -0.01548979f, 0.06688077f, 0.54810637f, -0.13573952f, 0.04825106f, -0.01299736f, 0.27725101f, -0.09533395f, 
    0.17024548f, -0.08702190f, 0.44262218f, -0.02000461f, 0.11156321f, 0.00947171f, 0.12896489f, -0.20744199f, 
    0.27359411f, 0.22846130f, 0.19586687f, 0.24363327f, 0.02515349f, 0.25137115f, -0.11666607f, -0.14873700f, 
    -0.01170499f, -0.05943904f, 0.27659976f, 0.04377846f, 0.18430239f, 0.13139647f, -0.04384359f, 0.09846927f, 
    -0.33471581f, 0.39584789f, -0.07899233f, -0.33503497f, -0.13973193f, -0.24782854f, -0.81679976f, 0.19551826f, 
    -0.07884586f, -0.03605871f, 0.41631526f, 0.21462904f, 0.22689930f, 0.33290240f, -0.08484582f, 0.22114025f, 
    -0.11611935f, -0.04231827f, 0.20520732f, 0.03138595f, -0.13117106f, -0.32155055f, -0.31846821f, 0.19120944f, 
    0.00118069f, 0.01972885f, -0.04795967f, -0.27183998f, -0.05967972f, 0.08075830f, -0.29030925f, 0.29208636f, 
    -0.19612493f, 0.04447377f, 0.14621107f, -0.06447730f, 0.02483176f, -0.08099066f, 0.09533005f, -0.09762806f, 
    0.13458715f, 0.32582486f, 0.04723043f, 0.13039777f, 0.02198423f, 0.00928590f, 0.24418825f, 0.01124846f, 
    -0.01528170f, -0.14552924f, 0.23149489f, -0.18802565f, -0.26476136f, -0.33710244f, 0.17214543f, -0.03204885f, 
    0.35027185f, 0.16117087f, 0.05240199f, -0.12890472f, -0.22311758f, 0.13911186f, 0.01368000f, -0.06764574f, 
    -0.37715414f, 0.18481411f, 0.13985223f, -0.04389645f, -0.10902947f, -0.00668435f, -0.07747006f, -0.25982195f, 
    -0.63331169f, -0.07534520f, -0.05619736f, -0.00405442f, -0.02585027f, 0.09890790f, -0.33579227f, -0.04440221f, 
    -0.16690131f, 0.35146126f, -0.27361283f, -0.27178755f, 0.37079316f, -0.28216153f, -0.11421817f, -0.17389548f, 
    0.15156788f, -0.11906726f, -0.22724777f, 0.00497423f, 0.07580949f, 0.04316007f, 0.08088089f, 0.04375559f, 
    -0.03473501f, 0.00875818f, -0.13512318f, -0.19828907f, -0.12559336f, -0.06412205f, 0.21977220f, -0.01736653f, 
    0.02964647f, -0.49708346f, 0.47556478f, -0.10481020f, 0.18322867f, 0.04294280f, -0.23073374f, 0.13920254f, 
    0.06470206f, 0.10015951f, -0.11132269f, -0.00133833f, 0.19195256f, 0.08688761f, 0.22005075f, -0.45262679f, 
    -0.52910185f, -0.14013991f, 0.21470666f, 0.01511836f, -0.12515128f, 0.20195906f, -0.04147743f, -0.63055158f, 
    0.24065419f, -0.01618557f, -0.39719832f, -0.08504525f, 0.10749333f, 0.10416247f, 0.05460948f, 0.24555053f, 
    -0.51210517f, -0.08795716f, 0.14884779f, 0.29859984f, 0.08255649f, 0.31230280f, 0.43240362f, -0.01124110f, 
    -0.12369767f, 0.04982578f, 0.01029247f, -0.00508355f, -0.05966161f, -0.06038762f, -0.52256382f, 0.13303107f, 
    0.00420385f, 0.32570034f, -0.02169796f, 0.06835657f, -0.47139680f, 0.01995149f, -0.34446079f, -0.02034250f, 
    -0.23906888f, -0.11513932f, 0.02995521f, -0.32759547f, -0.29882327f, -0.21182926f, 0.01847740f, -0.01062174f, 
    0.15021811f, 0.15783463f, -0.27980116f, 0.06900970f, -0.26764533f, 0.11365615f, 0.14154156f, 0.04393739f, 
    -0.02113832f, -0.03369606f, 0.07017712f, 0.03054519f, 0.00960115f, 0.06006958f, 0.03042740f, 0.01652564f, 
    -0.07144021f, 0.01988075f, -0.07258716f, -0.06788783f, 0.04943584f, 0.00284911f, -0.01993237f, 0.01809939f, 
    -0.08160454f, 0.02832459f, 0.03310946f, -0.05442751f, -0.10019177f, 0.03674686f, -0.07176425f, 0.03225876f, 
    -0.03782020f, -0.01946941f, 0.03745740f, 0.00281602f, -0.06201262f, 0.06381072f, -0.00387007f, -0.02558684f, 
    -0.02413857f, -0.01210983f, -0.02880094f, -0.01308523f, 0.03662349f, -0.02109640f, -0.07248244f, 0.07469152f, 
    -0.08429102f, -0.03523386f, -0.08365727f, -0.02718248f, 0.07409871f, -0.02038588f, -0.05258835f, 0.04632819f, 
    -0.04088573f, -0.09633074f, 0.08741698f, 0.01112693f, 0.03018506f, 0.05812287f, 0.02609687f, -0.04857338f, 
    0.05197192f, -0.01225521f, 0.06018655f, 0.02733567f, 0.01992913f, 0.01210344f, 0.01388079f, -0.03116382f, 
    -0.01977720f, -0.08967076f, -0.07553502f, 0.02351282f, -0.07755882f, 0.02797891f, 0.05317952f, 0.06813823f, 
    -0.05574941f, -0.05024779f, -0.03162018f, 0.04107545f, 0.07294483f, 0.02386494f, -0.03865664f, -0.08587928f, 
    0.05821392f, 0.00831086f, -0.08922864f, -0.04811206f, -0.07057894f, -0.01507697f, 0.08593258f, 0.07093458f, 
    0.01960799f, -0.01236516f, 0.05624275f, -0.07829538f, 0.01941945f, -0.00380466f, -0.05045391f, 0.04763607f, 
    -0.02832749f, 0.03631802f, -0.08093075f, -0.05853045f, -0.04730548f, 0.04843802f, -0.04451365f, -0.08900215f, 
    0.05115176f, -0.05875131f, 0.02447542f, -0.01262721f, -0.06826282f, -0.00853566f, 0.06887326f, 0.04841266f, 
    0.03536024f, -0.01724355f, 0.08318546f, 0.05107403f, -0.03960026f, 0.06258585f, -0.09662671f, -0.05279906f, 
    0.03165758f, 0.01153883f, 0.00268559f, -0.08206828f, -0.09732439f, -0.03401823f, 0.08121689f, -0.04032018f, 
    -0.01669838f, 0.08065831f, -0.03474458f, 0.07943035f, 0.13337499f, -0.03593749f, 0.04343500f, 0.05792213f, 
    0.02058118f, 0.04206419f, 0.15420149f, -0.37148955f, 0.02601471f, -0.02078584f, -0.15978345f, 0.03844368f, 
    0.18707244f, -0.07760516f, 0.12569191f, 0.12553416f, 0.06140029f, -0.05067550f, 0.02456749f, -0.06063305f, 
    0.07378694f, 0.01196707f, -0.04143209f, -0.14219783f, -0.01294513f, -0.23197213f, -0.09117613f, 0.08506138f, 
    0.13443811f, 0.03582939f, 0.03604247f, -0.15999162f, 0.28596354f, -0.09688648f, 0.20447366f, 0.03508917f, 
    0.02308670f, 0.03822727f, 0.28757972f, -0.07216081f, 0.45919272f, -0.27677986f, 0.08266938f, -0.05878766f, 
    -0.05559184f, -0.25065163f, -0.08040538f, 0.08211261f, -0.00718865f, 0.03141595f, 0.06895097f, 0.12408462f, 
    0.02451587f, 0.20194434f, 0.29907206f, 0.10320982f, -0.01589226f, -0.00608433f, 0.11567271f, -0.06182099f, 
    -0.48712975f, -0.08460400f, -0.09802164f, -0.04413491f, -0.06814142f, -0.01844935f, 0.02863869f, -0.11619787f, 
    -0.28463286f, 0.45219749f, -0.00827927f, -0.00524928f, 0.01596536f, -0.22358860f, -0.07473833f, 0.02214336f, 
    -0.12146955f, 0.33237889f, -0.12818258f, -0.30339471f, 0.15291324f, 0.13364227f, 0.80497855f, -0.38744593f, 
    -0.22171551f, 0.17855911f, -0.56500238f, -0.11286849f, -0.07424893f, 0.47683093f, 0.25760573f, -0.08039354f, 
    -0.14054744f, 0.26451185f, -0.21000126f, -0.03028546f, 0.04732695f, 0.42961556f, 0.14605233f, -0.02134826f, 
    0.16925545f, 0.06373307f, 0.13341442f, -0.45331019f, -0.09623569f, 0.01199244f, 0.04092038f, -0.23502713f, 
    -0.01496272f, 0.09912362f, -0.20729862f, 0.13106039f, 0.18850733f, 0.26727858f, 0.03352435f, -0.04284148f, 
    0.11190379f, 0.02994119f, 0.12262693f, 0.00719036f, 0.19851835f, 0.37603346f, -0.02924492f, 0.03530863f, 
    -0.06139839f, -0.00112612f, -0.09085091f, -0.00667295f, -0.08998126f, 0.04923884f, 0.00190947f, -0.03199658f, 
    0.02739899f, -0.04089099f, -0.00939283f, 0.01781836f, -0.07977774f, -0.07821505f, 0.02942439f, 0.00102255f, 
    0.03748429f, -0.01647573f, -0.05451208f, 0.04652347f, -0.11760624f, 0.00490286f, 0.04605702f, -0.10716613f, 
    -0.11189760f, 0.07069895f, -0.08394990f, -0.07587071f, 0.03831977f, 0.03542358f, 0.01886519f, -0.04096052f, 
    -0.08493103f, 0.03228795f, -0.02893967f, -0.04660941f, -0.08227962f, -0.10464329f, -0.03062817f, -0.08429145f, 
    0.01904743f, -0.07909256f, 0.02497619f, 0.02145825f, -0.07845689f, 0.04411194f, -0.04257836f, -0.10051382f, 
    0.01631806f, -0.11259581f, 0.05576618f, 0.00428373f, 0.05606702f, -0.04518360f, -0.06459840f, -0.10315131f, 
    -0.07424784f, -0.11685949f, 0.04904338f, 0.04362071f, 0.04076047f, -0.04794601f, -0.00484076f, 0.01940704f, 
    -0.06980228f, -0.04188250f, 0.00258279f, 0.00732207f, 0.00929761f, 0.03297052f, -0.04453138f, -0.09168108f, 
    -0.02386883f, -0.04968267f, 0.00086705f, 0.01086885f, -0.08265290f, -0.01240286f, 0.02730118f, -0.02916894f, 
    -0.06438801f, 0.05369285f, -0.06843725f, -0.03074554f, -0.09540689f, 0.03056463f, -0.02589531f, -0.00839628f, 
    0.00297091f, 0.01695788f, 0.04503388f, 0.03297896f, -0.08814055f, 0.05500192f, -0.03282083f, -0.06784202f, 
    0.00467468f, -0.08476695f, 0.03010528f, -0.02542589f, -0.06856410f, 0.00765559f, 0.05060042f, -0.06974093f, 
    -0.11683489f, 0.06802402f, -0.01912437f, -0.01733041f, -0.06883065f, -0.02208645f, 0.04925570f, -0.04515267f, 
    0.03866665f, 0.03059550f, -0.05293333f, 0.00593964f, -0.05678996f, -0.02626390f, 0.02729197f, -0.01175876f, 
    -0.04361697f, -0.00458886f, -0.10344390f, -0.10808796f, -0.04304491f, -0.09665047f, 0.05725339f, 0.01355476f, 
    0.05858019f, -0.06648569f, -0.07740013f, -0.07505374f, -0.05449273f, -0.00476883f, -0.03973382f, -0.04239150f, 
    -0.03034773f, -0.03407773f, -0.01046881f, 0.05803293f, -0.06897978f, 0.05297238f, -0.05722075f, 0.01734926f, 
    0.06503858f, -0.05724645f, 0.02698110f, 0.06339780f, -0.00597574f, 0.01024508f, 0.03288059f, -0.04313324f, 
    -0.06941419f, -0.06674216f, -0.09885193f, -0.05563440f, -0.08939632f, 0.05919663f, 0.06961071f, 0.01166647f, 
    -0.03922575f, 0.03389338f, -0.04180418f, -0.01380307f, 0.04269433f, 0.06118157f, -0.03073652f, -0.05768498f, 
    -0.00637450f, 0.07686645f, 0.05837608f, -0.08679510f, 0.05152876f, -0.09045993f, -0.00413398f, -0.00457485f, 
    0.00718529f, 0.04311059f, -0.06237390f, -0.09267537f, -0.05295781f, 0.03825345f, 0.05056574f, 0.07067540f, 
    -0.02782986f, 0.00167275f, -0.00692056f, -0.01692788f, -0.01189892f, -0.03685541f, 0.02974306f, -0.01222951f, 
    -0.00924003f, 0.06733732f, -0.05805774f, 0.05837234f, 0.00844251f, 0.01104542f, 0.07478535f, 0.06544252f, 
    -0.06879124f, -0.04589223f, -0.07255341f, -0.08806480f, -0.06374100f, -0.07773564f, -0.04979182f, -0.07479621f, 
    0.07615514f, -0.05164754f, -0.04787712f, 0.00407390f, 0.01096838f, -0.08258107f, 0.08399890f, -0.10560936f, 
    -0.01645840f, -0.07519870f, 0.02794040f, 0.02269720f, -0.02773917f, -0.05648514f, -0.05615105f, 0.00812706f, 
    -0.02736134f, 0.05625319f, 0.05512544f, 0.06156168f, -0.01555044f, -0.10074650f, -0.03111992f, 0.05835928f, 
    -0.00701356f, 0.04594637f, -0.03704491f, 0.07628071f, -0.05102883f, -0.00769476f, 0.02559528f, -0.07437643f, 
    -0.10873686f, -0.11428376f, 0.03686184f, -0.05064356f, 0.05555283f, -0.01030586f, -0.06339753f, 0.07822873f, 
    -0.10002214f, 0.02519733f, 0.05080601f, 0.05385288f, -0.00961445f, -0.04508311f, 0.04288294f, -0.05608683f, 
    0.16700678f, 0.07451025f, -0.23824209f, 0.17790389f, 0.02290795f, -0.10854556f, 0.01692689f, 0.30909237f, 
    0.26570168f, -0.13539764f, 0.13978876f, 0.05430833f, -0.05233451f, -0.10551023f, -0.06245640f, 0.16604613f, 
    0.04428532f, -0.02409230f, 0.10196834f, 0.10496555f, 0.08788572f, -0.06044761f, 0.02352348f, 0.08399299f, 
    -0.01676611f, 0.17343473f, -0.07331612f, 0.30016342f, 0.12928393f, 0.03311484f, 0.17178221f, -0.30922782f, 
    -0.13326967f, 0.11284772f, 0.03437042f, 0.09220596f, -0.25056604f, -0.07067635f, -0.00378613f, 0.19956622f, 
    0.17558080f, -0.00019681f, 0.43602782f, 0.14639120f, 0.05586182f, 0.06607036f, 0.07158715f, 0.03667182f, 
    0.05704675f, -0.01841920f, 0.68054187f, 0.09363314f, 0.12979904f, 0.06745536f, -0.05434836f, -0.05965764f, 
    0.02389400f, 0.03979900f, 0.24262103f, -0.14779091f, 0.12701020f, 0.10810734f, 0.23991731f, -0.20294349f, 
    0.39497477f, 0.14549509f, -0.06732403f, -0.02863144f, -0.03813848f, 0.47589219f, 0.00580819f, -0.15230836f, 
    0.35114697f, -0.19167669f, 0.11288531f, -0.04271159f, 0.27295649f, -0.06778017f, 0.04993591f, -0.25840494f, 
    -0.26206845f, -0.02964924f, -0.04498801f, -0.14746839f, -0.09748761f, -0.15204971f, 0.50512785f, 0.43006387f, 
    0.12871112f, 0.21021201f, -0.31779486f, -0.14785129f, 0.16372824f, 0.40750039f, 0.14187731f, 0.42903799f, 
    0.16033922f, -0.19261013f, 0.05869322f, 0.01720493f, 0.11587948f, 0.06296399f, -0.04385608f, 0.35906550f, 
    0.05540235f, -0.29358095f, 0.01786997f, -0.44092000f, -0.38544860f, -0.12376120f, -0.01632640f, 0.64638644f, 
    -0.15994410f, -0.02953166f, -0.23474406f, 0.25584611f, 0.11365995f, 0.16398618f, 0.24506760f, -0.01688397f, 
    -0.04438249f, 0.22251858f, -0.11728345f, 0.05867549f, -0.02353716f, 0.16983256f, -0.10228364f, 0.02680800f, 
    -0.07428837f, 0.22476599f, 0.15261166f, 0.06363665f, 0.22761980f, 0.18101731f, 0.11863066f, 0.05016813f, 
    -0.22629230f, 0.14936824f, 0.21728522f, -0.20335901f, 0.11779847f, -0.00268366f, -0.13153695f, -0.00219580f, 
    0.40187880f, -0.14929119f, -0.22810234f, -0.04517013f, 0.03191260f, 0.01349265f, -0.05381668f, 0.10745343f, 
    0.39140716f, 0.06684071f, -0.12853362f, -0.18451595f, -0.13277629f, -0.53415281f, -0.04840821f, -0.05290636f, 
    0.11093732f, -0.11852945f, 0.12844774f, -0.12920709f, -0.87942386f, 0.06434394f, 0.20888510f, -0.02795459f, 
    -0.06212382f, -0.10914186f, -0.22385110f, 0.14704481f, 0.59985059f, 0.10342988f, -0.07180134f, -0.15272781f, 
    0.02341824f, -0.04228750f, 0.26267558f, 0.01979470f, 0.15136686f, 0.07201115f, -0.22290118f, 0.07948067f, 
    -0.00186083f, 0.34737796f, 0.50625134f, 0.15796475f, 0.05186456f, 0.00943674f, 0.30020225f, 0.16398686f, 
    0.23788296f, -0.16451231f, 0.24808022f, 0.16675563f, -0.00989957f, 0.05566208f, -0.00552990f, 0.38836128f, 
    0.18938544f, -0.18781722f, -0.16645576f, 0.20291401f, 0.01525921f, 0.15414700f, 0.05389572f, 0.01745730f, 
    0.20125553f, -0.15269263f, -0.13621905f, -0.41327062f, 0.14937632f, 0.00338013f, -0.65111244f, -0.07953049f, 
    0.05321011f, 0.18989123f, -0.17582951f, -0.07568443f, 0.06706019f, 0.52100855f, -0.01382994f, -0.08434718f, 
    -0.06530963f, 0.14306666f, -0.08090501f, 0.07173718f, 0.21411858f, 0.04033865f, 0.29959801f, -0.16135618f, 
    0.14225468f, -0.40283546f, 0.10808934f, -0.48574474f, 0.15094401f, 0.16300683f, 0.18194138f, 0.03499105f, 
    -0.25689495f, 0.22489507f, -0.30429709f, 0.02663934f, 0.35783309f, 0.43201235f, 0.03180343f, -0.00723956f, 
    -0.16733792f, 0.03730806f, -0.12977032f, -0.05095387f, 0.35873151f, 0.22640359f, 0.07359867f, 0.02409104f, 
    0.53308225f, -0.06111423f, -0.00128781f, 0.12790886f, -0.05859179f, 0.00454630f, 0.04157510f, 0.12156717f, 
    0.25072214f, 0.22590993f, 0.22626559f, -0.02217732f, -0.00363339f, 0.21228878f, 0.14646468f, -0.06445206f, 
    0.07355236f, 0.37601870f, -0.08058985f, 0.13169582f, 0.06238488f, -0.02441648f, 0.01383602f, -0.02950707f, 
    0.13965206f, -0.02480520f, -0.11935315f, 0.12185311f, 0.08498121f, -0.55937827f, 0.04578488f, -0.18450893f, 
    0.02715997f, 0.25712430f, 0.01844638f, -0.28054324f, 0.02298033f, -0.08923141f, 0.04287536f, -0.31549028f, 
    0.07671702f, 0.01569297f, 0.05859568f, 0.20264824f, 0.15907127f, 0.14796558f, 0.30723572f, 0.04385206f, 
    -0.00615750f, -0.22412349f, 0.28949001f, -0.00941820f, 0.03704483f, -0.05401323f, -0.04229601f, 0.09391482f, 
    0.20832600f, 0.10827973f, 0.19322541f, -0.00162795f, -0.13485134f, -0.08539522f, -0.00539758f, -0.21213993f, 
    -0.85228127f, 0.09972044f, -0.21017170f, -0.09048774f, 0.13451979f, 0.30129400f, -0.07578991f, -0.02686315f, 
    -0.05417068f, -0.24486610f, -0.04836165f, -0.16601831f, 0.16420384f, -0.36400929f, -0.03898795f, -0.08272631f, 
    -0.17677619f, 0.41996858f, -0.20570439f, 0.29049739f, 0.01345106f, -0.02164784f, 0.78682321f, -0.29666841f, 
    -0.29331997f, 0.17226914f, -0.40676919f, -0.44977263f, -0.39879760f, 0.10319832f, 0.22088748f, -0.05571803f, 
    0.04676143f, 0.31586155f, -0.08882488f, -0.08591421f, 0.13105139f, 0.16123198f, 0.08078078f, -0.02452099f, 
    0.11514487f, 0.17158757f, 0.01053350f, -0.35528341f, -0.28469166f, -0.18258032f, 0.07088777f, 0.29377028f, 
    -0.47525537f, 0.00265039f, -0.46513930f, -0.01540730f, 0.15816478f, 0.20167188f, 0.10846981f, 0.08364289f, 
    -0.08250761f, 0.09270384f, 0.12753099f, 0.03499274f, 0.11296933f, 0.09495103f, 0.52356076f, 0.01625299f, 
    0.05408904f, 0.10711003f, 0.14967448f, -0.22522891f, 0.02880261f, 0.04971966f, 0.09109655f, 0.05196080f, 
    0.21011566f, 0.04134513f, -0.11003970f, 0.27721676f, 0.07297254f, 0.10253683f, -0.04486503f, 0.02592339f, 
    0.10726427f, -0.17467856f, -0.03185862f, -0.04661841f, -0.07644254f, -0.00112273f, -0.08030440f, -0.07352633f, 
    0.03104160f, -0.33991590f, -0.01092920f, 0.00882634f, 0.18214029f, 0.07287087f, -0.04811269f, -0.28744960f, 
    0.09206942f, -0.11539344f, -0.06714625f, 0.07522221f, -0.32509506f, 0.14716382f, 0.09555673f, -0.30446127f, 
    0.10509349f, -0.10791818f, -0.40704662f, 0.33189109f, 0.16258061f, 0.37117904f, 0.09029652f, -0.00166381f, 
    0.04189808f, -0.03974690f, 0.18747328f, 0.03862304f, 0.06917707f, 0.02635298f, -0.01546563f, -0.06646334f, 
    0.05144863f, 0.13940644f, -0.07989462f, 0.01325919f, 0.23458579f, -0.04932804f, -0.10258646f, 0.15847515f, 
    0.67559808f, 0.17186372f, 0.25907919f, 0.10941011f, -0.01010024f, 0.35134768f, -0.22192834f, -0.05101307f, 
    0.32372871f, -0.27287790f, 0.04330166f, -0.02879292f, 0.03536768f, 0.14439303f, 0.12142377f, -0.17535764f, 
    0.04009564f, -0.32169837f, 0.07714090f, 0.09843099f, 0.06736889f, -0.19257855f, -0.28498417f, 0.39097813f, 
    0.19678949f, 0.08970206f, 0.15327030f, -0.21450421f, -0.11412255f, -0.36192176f, -0.05493292f, 0.19474672f, 
    0.12974954f, -0.18638869f, -0.22721840f, 0.08163267f, 0.12501742f, 0.02181240f, -0.03025177f, 0.02795862f, 
    -0.14649527f, -0.24373737f, -0.04121670f, -0.43856359f, -0.20682526f, 0.17903087f, 0.00572576f, 0.12335397f, 
    0.05119739f, -0.17803316f, -0.14923602f, -0.07185548f, 0.04430291f, -0.07885476f, 0.13524203f, -0.04879304f, 
    -0.10212596f, -0.10343105f, -0.05661651f, 0.03353269f, -0.14359541f, 0.01189782f, -0.15435077f, -0.05669760f, 
    -0.03632756f, -0.13525724f, -0.02126707f, -0.01085671f, 0.02218487f, -0.01414059f, -0.10475469f, -0.14145520f, 
    -0.02347984f, 0.05906511f, -0.00832045f, -0.07732515f, -0.04668806f, -0.06819352f, 0.00274480f, -0.07461676f, 
    0.02254780f, 0.08414184f, -0.08271988f, 0.02095409f, 0.00347228f, -0.00612633f, 0.04250511f, 0.01714352f, 
    -0.08095808f, -0.08497958f, -0.03714943f, 0.02016426f, -0.01544897f, -0.00288824f, 0.03757005f, 0.00938366f, 
    0.00500530f, 0.00928356f, -0.12410935f, -0.13391876f, -0.04171587f, -0.09974600f, -0.12967652f, -0.04195644f, 
    -0.01732812f, -0.04768481f, -0.10797396f, -0.01990728f, -0.08507087f, 0.00688266f, -0.05282988f, -0.08653886f, 
    -0.05746863f, -0.02247960f, -0.09835102f, -0.08347124f, -0.04472492f, 0.01792967f, -0.13900799f, -0.04370014f, 
    -0.06351433f, -0.01623459f, -0.01104800f, -0.01108821f, -0.10190419f, -0.01627985f, -0.05526141f, 0.08714733f, 
    -0.06575528f, 0.00454166f, -0.05657200f, -0.11855514f, 0.03075214f, 0.07985581f, 0.07033899f, 0.03843222f, 
    -0.08085489f, -0.07528338f, 0.04372314f, -0.02909720f, -0.05145764f, 0.06572944f, -0.04008720f, 0.00413119f, 
    -0.02430285f, 0.08198084f, 0.00060068f, -0.10242665f, 0.01739819f, 0.04067827f, -0.13409768f, -0.09134511f, 
    0.00945686f, -0.07919357f, 0.02990700f, 0.00562925f, 0.01410182f, 0.01336732f, -0.03419840f, -0.05831438f, 
    -0.10093445f, -0.02209673f, -0.09961504f, 0.06528494f, -0.05289206f, -0.03650142f, -0.11502109f, -0.04785318f, 
    -0.06979816f, -0.01054979f, 0.00560043f, 0.00303775f, -0.00386418f, 0.00941296f, 0.02719194f, -0.07344092f, 
    0.03268090f, -0.11999156f, -0.15178555f, -0.00436025f, 0.01057520f, -0.12581122f, -0.12687631f, 0.00285723f, 
    0.04363884f, 0.07069427f, -0.05385562f, -0.06519733f, -0.06158808f, -0.04441544f, -0.03720245f, 0.00408663f, 
    -0.35563055f, 0.02222928f, 0.28623340f, -0.08907302f, 0.24056557f, 0.12906443f, 0.06905969f, 0.00392233f, 
    -0.44025466f, 0.28143948f, -0.13491568f, 0.27944443f, 0.10190875f, 0.07929209f, -0.24199726f, -0.09522831f, 
    0.15990417f, -0.21513331f, 0.06886158f, -0.07840646f, -0.11903866f, 0.03347981f, 0.08577160f, 0.11633591f, 
    0.10822084f, 0.03718448f, 0.00000761f, -0.29151490f, 0.16409017f, 0.03035070f, 0.10982020f, -0.00550275f, 
    0.06086110f, -0.38589621f, -0.18039982f, 0.27878109f, -0.66528952f, 0.26819173f, 0.11409622f, 0.00266759f, 
    -0.05053334f, -0.17868197f, -0.47470143f, 0.24774654f, 0.20289287f, -0.25438336f, -0.06322409f, -0.09446740f, 
    0.04835899f, -0.13528070f, -0.16187091f, 0.08133563f, 0.07676055f, -0.07280824f, -0.28779057f, 0.04283005f, 
    -0.17029180f, 0.17998788f, 0.07833616f, 0.02633142f, 0.10135319f, -0.03158467f, -0.22609399f, 0.27318037f, 
    0.66623133f, -0.23367333f, -0.01162614f, 0.17054625f, 0.11096126f, 0.12091673f, 0.17661218f, 0.13825852f, 
    0.43178228f, 0.09656607f, -0.11359275f, 0.00859129f, -0.39546812f, 0.27657768f, 0.09967468f, 0.05900528f, 
    0.45553443f, 0.03569733f, 0.06881189f, -0.06536467f, 0.07210770f, 0.41632357f, 0.08370680f, -0.05573750f, 
    0.26509768f, 0.14674327f, -0.07458733f, -0.16178669f, -0.26010159f, -0.06130446f, 0.10006086f, -0.09885710f, 
    -0.01196764f, 0.04526639f, -0.26175928f, 0.06985626f, 0.04833723f, 0.21538438f, 0.18653777f, -0.17470212f, 
    0.03797194f, -0.08954601f, -0.02211379f, 0.06891421f, 0.06161578f, 0.08536725f, 0.37880149f, -0.35635039f, 
    0.25578040f, -0.02636067f, 0.00958933f, -0.11510124f, 0.12967481f, -0.02870306f, -0.18934847f, 0.06092189f, 
    -0.04827145f, -0.09246228f, 0.01456326f, 0.06151030f, -0.13399568f, -0.05033248f, -0.11882969f, 0.01091189f, 
    0.04059228f, 0.00027335f, 0.35069305f, -0.03717552f, -0.11658920f, 0.16821977f, 0.07236195f, -0.12360483f, 
    -0.17026767f, 0.25741208f, -0.26531351f, 0.28298536f, -0.13661849f, 0.10378230f, -0.00596677f, 0.00110036f, 
    0.00687150f, 0.15086842f, 0.11535822f, -0.16575682f, -0.06318123f, 0.04542759f, -0.06959593f, 0.15532255f, 
    0.08861099f, 0.13809669f, 0.12107495f, -0.02485659f, 0.15277460f, 0.05134828f, 0.22115022f, 0.15531525f, 
    -0.04229797f, 0.07073710f, -0.11948176f, 0.20214076f, -0.32218358f, 0.10727143f, -0.01070819f, -0.08885443f, 
    -0.18086693f, -0.19021212f, -0.58873248f, 0.18860047f, -0.03816958f, 0.31806394f, -0.00011277f, 0.13009000f, 
    0.08128406f, 0.19584902f, 0.12483715f, 0.08278284f, 0.06253854f, 0.06205821f, -0.13937402f, -0.15891701f, 
    0.02618431f, 0.04924216f, 0.04314883f, -0.10880139f, 0.04871330f, 0.22063172f, -0.00507141f, 0.35937363f, 
    0.68533701f, 0.10708115f, 0.22700396f, 0.12242077f, 0.21497276f, -0.16482981f, 0.11162040f, 0.04541289f, 
    0.32479280f, -0.22510168f, 0.22860600f, -0.09756397f, -0.03084044f, 0.32758856f, 0.34728220f, 0.09544405f, 
    0.20491633f, -0.30203098f, 0.15896754f, 0.08329821f, 0.13834146f, -0.10653420f, -0.52239889f, 0.20453650f, 
    0.19868004f, -0.00157545f, 0.11202849f, 0.22890253f, 0.22061427f, -0.33331639f, -0.21743804f, -0.00657668f, 
    0.28446606f, -0.27465254f, 0.02044492f, -0.06411397f, 0.04461615f, 0.04135650f, -0.06191747f, -0.11255293f, 
    -0.04973032f, 0.02500670f, -0.07717979f, -0.12905625f, 0.24156527f, 0.01865495f, -0.01739760f, 0.01865699f, 
    -0.06011678f, -0.08924518f, 0.10107446f, -0.36730778f, 0.02454204f, -0.26114914f, -0.14900936f, 0.04834732f, 
    -0.13234067f, 0.09474709f, -0.00856936f, 0.21182750f, 0.03906238f, -0.14804329f, 0.04261903f, 0.10803963f, 
    0.14504308f, -0.00290514f, 0.19111891f, 0.11365732f, -0.25138837f, 0.16506985f, 0.23192829f, -0.06994557f, 
    -0.01290113f, 0.10203022f, -0.39112735f, 0.19158198f, -0.22252411f, -0.05584080f, 0.06139824f, -0.06951044f, 
    0.10946922f, 0.21364225f, 0.17706203f, -0.11449915f, -0.05822204f, -0.00467199f, 0.02326157f, 0.15476337f, 
    -0.01643194f, 0.10798341f, 0.11293956f, 0.22100773f, -0.00425781f, -0.22734034f, 0.23157224f, 0.01432294f, 
    -0.16511360f, 0.14772871f, -0.10033484f, 0.21158282f, -0.12365325f, 0.02660775f, 0.14722909f, -0.01538997f, 
    -0.21209326f, -0.32888356f, -0.58545691f, 0.24371898f, 0.01831638f, -0.04128164f, 0.01164531f, 0.22493865f, 
    -0.09186789f, 0.19876362f, 0.11875159f, 0.11506644f, 0.16317560f, 0.04376392f, -0.03479442f, -0.16732635f, 
    -0.14218953f, 0.02834253f, -0.06673996f, -0.15785459f, 0.32281944f, -0.00142963f, 0.06468428f, 0.41674373f, 
    -0.22369246f, 0.14983256f, 0.09864843f, 0.13345098f, 0.29165074f, -0.17128918f, -0.11086302f, 0.08786110f, 
    0.22976261f, -0.08050168f, 0.30463451f, -0.16459467f, 0.06559944f, 0.31509155f, 0.47371322f, 0.02873039f, 
    0.28652477f, -0.32581246f, -0.02361828f, -0.00730282f, 0.18253425f, -0.39463028f, -0.59265244f, -0.18197282f, 
    0.45962030f, 0.25170034f, -0.20668523f, 0.62650836f, 0.30060843f, -0.18982579f, 0.05276773f, 0.07985396f, 
    0.46673056f, -0.16433246f, 0.01249149f, -0.08825489f, 0.18956707f, 0.14185688f, -0.26825327f, 0.15927599f, 
    -0.05602407f, 0.26099417f, -0.31216347f, -0.52085716f, 0.37710017f, 0.21994273f, 0.00520170f, -0.01817099f, 
    -0.21353354f, -0.17935695f, 0.45371637f, -0.46311080f, 0.03868122f, -0.14884536f, -0.03315844f, -0.03493744f, 
    -0.34485728f, 0.07107513f, -0.03818948f, 0.34772450f, -0.09054380f, -0.05787795f, 0.07378390f, 0.09064046f, 
    -0.25007170f, 0.05279873f, 0.29960778f, 0.20913234f, 0.09137779f, 0.20874010f, 0.16438860f, -0.06229141f, 
    -0.40840748f, 0.19307008f, 0.11898604f, -0.23443514f, 0.14442649f, 0.11900394f, -0.23497723f, -0.36851424f, 
    0.36729297f, 0.01908422f, -0.12477089f, -0.07081301f, -0.06695227f, 0.05231353f, -0.04927123f, 0.03786977f, 
    0.30870408f, 0.10243558f, -0.15122545f, -0.37334836f, -0.30715862f, -0.33134043f, 0.09583144f, 0.13111453f, 
    0.10258289f, -0.00137692f, 0.30324650f, -0.15488468f, -0.43809256f, 0.09262916f, 0.19071455f, 0.37787598f, 
    -0.13035397f, 0.00613784f, 0.01828932f, 0.01237573f, 0.13528985f, 0.02961253f, -0.15982138f, -0.06617529f, 
    0.04822909f, -0.09852915f, -0.43775252f, 0.05992788f, 0.04787205f, 0.02665466f, -0.13221897f, 0.20454645f, 
    -0.39682212f, 0.13823444f, 0.04379357f, 0.13995878f, 0.14088441f, 0.05818823f, 0.12983511f, 0.23990974f, 
    0.09155127f, -0.36877322f, 0.03285767f, -0.00037288f, 0.24220109f, -0.05856606f, 0.32778654f, 0.34428427f, 
    0.05081746f, -0.27691245f, -0.14615783f, 0.14739613f, -0.08720589f, 0.35294026f, 0.00939057f, 0.07038235f, 
    0.40688196f, -0.05037457f, -0.06759398f, -0.38231742f, 0.15966018f, 0.48400387f, -0.08791702f, -0.21576484f, 
    0.07812800f, 0.06198920f, -0.40687647f, 0.19563752f, -0.02184035f, 0.16638598f, 0.13353851f, -0.24717668f, 
    -0.06963887f, 0.32272780f, 0.11835806f, -0.00011305f, 0.18088005f, -0.00792918f, 0.15817130f, -0.13032804f, 
    0.14943923f, 0.13803770f, 0.14261591f, 0.41661161f, 0.14949073f, 0.18015298f, 0.19288357f, -0.44911292f, 
    -0.07604016f, 0.22449997f, -0.18726607f, 0.16191317f, 0.09154259f, 0.28381255f, 0.01207548f, 0.02534281f, 
    -0.40871397f, 0.07695083f, -0.18406011f, -0.04107516f, 0.19322193f, 0.11227081f, 0.04386325f, 0.06480159f, 
    0.34508821f, 0.00518252f, 0.04596057f, -0.24728766f, -0.04767787f, 0.02197476f, 0.07389969f, 0.03315392f, 
    0.10343362f, -0.04645366f, -0.15638007f, 0.15607573f, 0.06438678f, 0.08387854f, 0.24450010f, 0.02869975f, 
    -0.15752104f, 0.30312970f, 0.03284823f, 0.15981638f, 0.14708939f, 0.09839667f, -0.02014902f, 0.14090773f, 
    -0.09418684f, 0.05924277f, 0.08328294f, 0.09112246f, -0.09671813f, -0.04295542f, 0.02772603f, 0.16797185f, 
    -0.03139844f, 0.20200220f, 0.05211222f, -0.08929279f, 0.54465866f, 0.00900810f, -0.01041130f, -0.64045167f, 
    -0.09932673f, 0.11067408f, -0.36304793f, -0.00040920f, 0.12333126f, 0.35990152f, 0.07868362f, 0.22230259f, 
    -0.07409602f, 0.22103861f, 0.26991174f, -0.05769878f, 0.02009842f, 0.02983463f, 0.22948316f, 0.00829863f, 
    0.06691027f, -0.21224234f, 0.28369921f, 0.12699832f, -0.02039732f, -0.15283456f, -0.04691093f, -0.20572619f, 
    0.15805739f, 0.24808374f, 0.22312246f, 0.11658397f, -0.02704188f, -0.20705904f, -0.10999884f, 0.11738912f, 
    -0.14465341f, -0.32585317f, 0.11064764f, -0.01423451f, 0.28466460f, -0.14567493f, -0.03443890f, 0.17469907f, 
    -0.29848728f, -0.13566260f, -0.06822585f, 0.06043320f, -0.01916958f, -0.22025718f, -0.74867409f, 0.00539125f, 
    -0.21064346f, -0.10054548f, 0.82232076f, 0.15889920f, 0.16315952f, -0.10679735f, -0.14419073f, 0.02130798f, 
    0.13067742f, 0.03320862f, 0.13157441f, -0.07685006f, 0.02314960f, -0.07220005f, -0.10221089f, 0.13858686f, 
    0.03254678f, -0.08869972f, -0.08097593f, -0.09174961f, 0.01167933f, 0.12140416f, -0.31923443f, 0.26816410f, 
    -0.34550938f, 0.06196031f, 0.20554318f, -0.23434108f, -0.01629344f, -0.13218385f, 0.10077032f, -0.06670802f, 
    0.14120205f, 0.08198532f, 0.00577782f, 0.00860126f, 0.10908473f, -0.05065272f, 0.18248236f, 0.02006646f, 
    -0.52523381f, 0.09990138f, 0.10856511f, 0.12319645f, 0.15738079f, 0.15966095f, 0.05359986f, 0.00669452f, 
    -0.44256037f, -0.11762171f, -0.05947873f, 0.03293195f, 0.10192383f, -0.12523763f, -0.13865703f, -0.20365988f, 
    0.16328573f, -0.24281044f, -0.07546212f, -0.15057762f, 0.11034192f, 0.09282640f, 0.00503110f, 0.11981340f, 
    0.23092303f, 0.12227497f, -0.10435762f, -0.19303896f, -0.24457654f, 0.42576569f, 0.13036737f, 0.01440875f, 
    -0.09448183f, -0.14787039f, 0.19619054f, -0.07189916f, -0.44865817f, 0.05802292f, 0.07090604f, 0.57191342f, 
    0.10471015f, 0.03615529f, 0.02528802f, -0.25593486f, -0.09227174f, -0.00969101f, -0.14668876f, -0.08166666f, 
    -0.00413572f, -0.01816933f, -0.09869164f, 0.06844009f, -0.01584487f, -0.04985428f, -0.12782817f, -0.08798154f, 
    -0.26938072f, 0.15575089f, -0.10403775f, 0.09121093f, -0.06627746f, 0.00871899f, 0.17289987f, 0.19530191f, 
    0.31144789f, -0.21374831f, 0.07700142f, -0.06495707f, 0.00184715f, -0.19252275f, 0.10250424f, 0.15802543f, 
    0.07206341f, 0.20930173f, -0.15085873f, 0.10400973f, 0.01478452f, 0.19663179f, 0.10302968f, 0.17686206f, 
    0.37447488f, -0.19639489f, 0.12863328f, 0.16140375f, -0.03430317f, 0.48839679f, -0.26108173f, -0.29810318f, 
    0.09714120f, -0.09845337f, -0.39090210f, 0.14338718f, 0.05886386f, 0.25495142f, -0.16018052f, -0.16486429f, 
    0.03170069f, -0.10744736f, 0.08535169f, -0.06940024f, -0.09108577f, -0.12648815f, 0.12974565f, -0.04906259f, 
    -0.09233598f, 0.07800708f, 0.01681640f, 0.37946349f, 0.37130523f, 0.06676778f, 0.12202248f, -0.07396340f, 
    0.22354652f, 0.22750902f, 0.02992776f, 0.02221511f, 0.09892605f, 0.13931404f, -0.02307757f, 0.01771197f, 
    -0.02800501f, -0.12110157f, -0.01489628f, -0.06075686f, 0.13924545f, 0.07420848f, -0.38228944f, -0.03529229f, 
    -0.03744014f, -0.04926747f, 0.02306298f, 0.00846564f, 0.02789921f, -0.05816176f, 0.02493532f, -0.08557598f, 
    -0.01598606f, 0.00548894f, -0.04448315f, -0.03110843f, 0.06211234f, 0.01921560f, 0.03074188f, 0.01600560f, 
    -0.04909528f, 0.06767505f, -0.10231230f, 0.05309279f, 0.06235161f, -0.04673992f, -0.05293747f, -0.09969312f, 
    -0.06468331f, -0.08539348f, -0.09713158f, -0.04763523f, -0.07708812f, 0.02390358f, 0.02893838f, -0.03598218f, 
    -0.02890316f, -0.03025907f, -0.06807644f, -0.04837209f, -0.05196457f, -0.11196338f, -0.08308476f, 0.06190529f, 
    -0.07443491f, 0.02213794f, 0.02711746f, -0.04813553f, -0.02100094f, 0.05483294f, -0.09507015f, 0.03025601f, 
    0.04135207f, 0.00503430f, -0.02146497f, -0.11830290f, -0.06009888f, 0.07488137f, -0.09327641f, -0.09496219f, 
    -0.04991524f, -0.08371604f, -0.07759704f, -0.03938398f, -0.08257538f, -0.09229009f, -0.04402193f, 0.03648090f, 
    -0.02296864f, -0.02818798f, -0.10729974f, -0.06425670f, -0.08680156f, -0.00072185f, -0.03459907f, -0.09061585f, 
    0.04269545f, -0.03739626f, 0.07411502f, -0.04093699f, -0.04939558f, 0.04273539f, 0.03569970f, -0.08895455f, 
    -0.04388081f, -0.04063050f, -0.00745465f, -0.06780528f, 0.04742062f, -0.03639260f, -0.03508297f, -0.07471630f, 
    -0.07645062f, -0.09206903f, -0.00384712f, -0.07848406f, -0.01187136f, 0.03442254f, -0.12321693f, -0.07302834f, 
    -0.08187751f, -0.00930485f, 0.04555479f, -0.08722535f, -0.08828367f, 0.04718207f, -0.06526306f, -0.03284328f, 
    0.05803454f, 0.04772642f, -0.01285534f, -0.03355240f, -0.08036746f, -0.09595014f, -0.07735773f, 0.07998742f, 
    0.01636999f, 0.05505276f, 0.07842364f, 0.05610513f, -0.01994507f, 0.06196654f, 0.02720536f, -0.00844846f, 
    0.03550764f, -0.02136259f, -0.07921687f, 0.04820883f, 0.01427396f, -0.10461578f, 0.02780728f, -0.01107149f, 
    0.14020431f, 0.16788939f, -0.42381772f, 0.15290302f, -0.02037578f, 0.10055985f, -0.00932950f, 0.11878110f, 
    -0.06453651f, -0.34518564f, 0.09886396f, -0.21338685f, 0.13267620f, -0.23994213f, -0.03035886f, 0.16250484f, 
    0.12170709f, -0.18470415f, 0.12981065f, 0.22363125f, 0.13545862f, 0.00104699f, 0.07712183f, 0.08254798f, 
    0.08698066f, -0.14880963f, -0.01190095f, -0.03388643f, -0.10373274f, -0.34783259f, -0.16273850f, 0.17884055f, 
    -0.03086894f, 0.13349652f, 0.24762318f, -0.03427108f, 0.52921212f, 0.07485643f, 0.09970023f, 0.04906883f, 
    -0.04769063f, -0.02750157f, 0.46100917f, 0.01547058f, 0.30041867f, -0.35944796f, -0.12816244f, 0.00337062f, 
    0.05871435f, 0.11441299f, 0.06827959f, 0.13905652f, 0.08877346f, -0.04380919f, 0.21862786f, 0.02545650f, 
    -0.02596971f, 0.07180109f, 0.37133732f, 0.06529965f, 0.27780437f, -0.04140544f, 0.09779081f, 0.07807072f, 
    0.00324704f, 0.06349605f, -0.09556451f, -0.06566829f, -0.10936676f, -0.11368544f, -0.33512649f, 0.04374131f, 
    -0.00859018f, 0.23310618f, 0.00181301f, 0.23900807f, 0.11587321f, -0.28775972f, 0.04334910f, 0.05019471f, 
    -0.29896891f, 0.22355121f, -0.14458273f, -0.31045157f, 0.05644996f, -0.47851902f, 0.51643270f, -0.14042965f, 
    -0.12418776f, 0.15742749f, -0.32063526f, 0.03894331f, 0.22192024f, 0.19504268f, 0.00706046f, 0.02240737f, 
    -0.02157599f, 0.09009688f, 0.01006941f, -0.01589938f, 0.13779503f, 0.21827404f, 0.10341692f, -0.11366062f, 
    -0.04700015f, -0.06915118f, 0.14475952f, -0.52264822f, -0.14553238f, 0.08784299f, -0.09514778f, 0.03605584f, 
    0.05368086f, 0.08385651f, 0.10948124f, 0.18537520f, 0.10512722f, 0.24122107f, 0.08258876f, 0.03858916f, 
    0.28415349f, 0.10125006f, -0.05071010f, -0.04363841f, 0.19156946f, 0.34278390f, 0.05072828f, 0.05319037f, 
    -0.19720961f, 0.08784130f, -0.11511118f, 0.02951236f, 0.07074786f, 0.06147528f, -0.09044896f, 0.11685342f, 
    0.07045729f, -0.15550460f, 0.07030803f, -0.02484258f, 0.15889239f, 0.00696945f, 0.15328564f, 0.04120858f, 
    -0.14477170f, -0.01760839f, 0.06339441f, 0.00088886f, 0.09861160f, -0.03248150f, -0.01780725f, -0.03109452f, 
    0.04563236f, 0.16077210f, 0.09904714f, 0.10531430f, -0.21265446f, 0.29895872f, 0.08526222f, -0.08960760f, 
    0.03085166f, 0.16951516f, 0.22008757f, -0.07258941f, -0.07509349f, 0.04203517f, 0.02913902f, 0.43608087f, 
    0.33349785f, 0.12602332f, 0.21960002f, -0.09420164f, 0.02524714f, 0.10024443f, -0.03283360f, 0.07594659f, 
    0.01584442f, -0.08116899f, -0.04602230f, -0.07299052f, -0.03298811f, -0.02386024f, 0.26013529f, 0.02050842f, 
    -0.03494378f, 0.03703042f, -0.42616919f, -0.00400797f, -0.09498461f, 0.28727940f, 0.32878137f, 0.06758265f, 
    -0.43962207f, -0.03391039f, 0.25649738f, -0.19108427f, 0.10364963f, -0.12261505f, 0.15163736f, 0.18320405f, 
    -0.04304902f, 0.21937844f, 0.22671565f, 0.22904702f, 0.06882914f, 0.06531940f, -0.14745547f, 0.12388878f, 
    0.24570751f, 0.19412445f, 0.12020308f, -0.04473476f, -0.01451284f, 0.20362942f, -0.39478695f, -0.00932736f, 
    0.01519393f, 0.03500100f, -0.05890323f, -0.00620614f, -0.03596111f, 0.45574537f, 0.02124539f, 0.00401503f, 
    -0.09953916f, -0.04178031f, 0.28953296f, -0.03948640f, -0.02627437f, 0.04355234f, -0.04100275f, 0.25864568f, 
    0.10555442f, 0.25467488f, 0.06489372f, 0.48773780f, 0.15120526f, -0.13492964f, 0.07333875f, 0.13927133f, 
    -0.02205927f, 0.28877071f, -0.06979167f, 0.05962681f, -0.08215579f, 0.09679846f, 0.11528834f, 0.04001144f, 
    0.09756588f, 0.27082136f, 0.02892237f, -0.01092604f, 0.28508845f, 0.10870874f, -0.05711986f, -0.00807359f, 
    -0.00996376f, -0.04177554f, -0.07224363f, -0.03189675f, -0.06228432f, 0.03596080f, -0.08941825f, -0.09716327f, 
    -0.01293208f, -0.02948240f, 0.06809294f, 0.08114468f, -0.01131644f, 0.02287963f, -0.02842014f, -0.07373621f, 
    -0.02974373f, 0.08313438f, 0.01005446f, -0.06951369f, 0.05440810f, 0.00378790f, 0.04807176f, -0.08677159f, 
    -0.05737122f, 0.03139889f, 0.05099541f, 0.04796666f, -0.07524961f, -0.02750498f, -0.06868561f, -0.04652965f, 
    -0.04972243f, 0.02313984f, -0.07735837f, -0.05916540f, 0.03487419f, -0.13413140f, 0.03592972f, -0.02753952f, 
    -0.00542595f, 0.00234244f, -0.07943723f, -0.04346092f, 0.01171571f, 0.07520935f, -0.01707713f, -0.03252968f, 
    0.05546569f, -0.05537419f, -0.09358018f, -0.01631985f, -0.00894052f, 0.01851140f, -0.07090360f, 0.03587370f, 
    -0.06523123f, 0.02271730f, -0.01856210f, 0.05548941f, -0.01151951f, -0.07666179f, -0.02832430f, -0.03701267f, 
    -0.11071780f, -0.04083654f, -0.07601148f, 0.04988043f, 0.06309385f, -0.05306679f, -0.05113864f, -0.09898679f, 
    -0.06591238f, 0.05373634f, 0.07579005f, -0.06185280f, 0.06233309f, 0.05235877f, -0.02168518f, -0.02142702f, 
    0.02109436f, -0.04581154f, -0.05813820f, -0.01466359f, -0.09860466f, -0.08003940f, -0.00924882f, 0.07318343f, 
    -0.00172175f, -0.05591374f, 0.00414106f, 0.05299312f, -0.11715620f, -0.02853948f, -0.07985274f, 0.02409512f, 
    -0.07558661f, 0.01874770f, 0.08376076f, 0.03450397f, -0.00108081f, -0.05395894f, -0.09840945f, -0.07762430f, 
    -0.00569226f, 0.06096010f, -0.06970150f, -0.01113905f, -0.10273757f, 0.02497886f, -0.11027002f, -0.04996984f, 
    0.04472718f, -0.03494786f, 0.00633170f, -0.02037188f, 0.00203261f, -0.08531556f, -0.03734025f, -0.08121525f, 
    0.02480455f, -0.06542796f, 0.03976845f, -0.05774669f, -0.04851758f, -0.05425771f, 0.00332262f, -0.05270898f, 
    0.05988638f, 0.15799730f, -0.07290823f, 0.13078335f, 0.22244015f, -0.00858103f, 0.13047719f, -0.02393722f, 
    -0.12451340f, -0.06741965f, 0.30114284f, -0.34601334f, 0.15027264f, 0.01854051f, -0.00208466f, -0.11613858f, 
    0.18073025f, -0.09595899f, -0.08187293f, 0.14994298f, 0.03714458f, 0.02133873f, 0.05693837f, -0.04088267f, 
    0.19706769f, 0.04597431f, -0.25803947f, -0.25961643f, -0.14593937f, -0.29738921f, -0.27232265f, 0.04384018f, 
    0.16988656f, -0.05340545f, 0.02047518f, -0.17753142f, -0.19143350f, 0.00614021f, 0.15545408f, 0.09388900f, 
    0.05627489f, 0.04110196f, 0.23333471f, -0.08559785f, 0.22454938f, -0.20212781f, 0.02406196f, -0.12113678f, 
    0.07976732f, -0.29293478f, -0.03273388f, -0.08828744f, 0.06366604f, 0.06704954f, -0.06255253f, 0.26175362f, 
    -0.06969865f, 0.02785677f, 0.11495661f, 0.04439277f, -0.01715959f, -0.13143569f, 0.00294646f, -0.02691012f, 
    -0.46352467f, -0.13429330f, -0.05433279f, -0.08924963f, -0.07148093f, -0.48908314f, 0.19402674f, 0.19196013f, 
    -0.15603952f, -0.04768838f, -0.19947962f, 0.03706606f, -0.02976042f, -0.09046084f, -0.07985977f, -0.05885661f, 
    -0.07762133f, 0.05901698f, -0.06658395f, -0.39685336f, -0.01954852f, 0.07807911f, -0.32309565f, -0.21348649f, 
    -0.10493449f, -0.02897253f, -0.07469588f, 0.08452478f, -0.07992855f, 0.41649127f, 0.12377147f, -0.13456146f, 
    -0.24882746f, 0.34303954f, 0.03457922f, 0.01720462f, 0.12791730f, -0.02552919f, 0.21220492f, 0.01022997f, 
    0.26845810f, -0.00351256f, 0.14049332f, 0.02027832f, 0.04358036f, 0.17343915f, 0.02836138f, -0.28519976f, 
    -0.19236909f, 0.13070518f, -0.25574717f, 0.18708700f, 0.07794023f, 0.30850670f, -0.00888929f, 0.07229803f, 
    -0.01561169f, -0.13623038f, 0.11605968f, -0.09191535f, 0.22709185f, 0.15091878f, 0.01204655f, -0.06255539f, 
    -0.18660185f, 0.17768237f, -0.63051981f, 0.43761075f, 0.09053865f, 0.16043480f, 0.04617049f, 0.19610567f, 
    -0.44490880f, -0.59414601f, -0.04074448f, -0.53280419f, 0.25306576f, -0.45276499f, -0.33415291f, -0.16129577f, 
    0.10486637f, -0.30956236f, -0.03969410f, 0.12677087f, 0.38698205f, 0.15965736f, 0.05276696f, -0.10497556f, 
    0.22512388f, -0.12610085f, -0.27194819f, -0.08691467f, -0.37234655f, -0.15899546f, -0.10933957f, 0.24961805f, 
    -0.02259540f, -0.07713564f, 0.30919981f, -0.10256057f, 0.01803093f, 0.06382378f, 0.32403019f, 0.48670030f, 
    -0.11153810f, 0.06392564f, 0.64459813f, -0.02495970f, -0.05366625f, -0.25720495f, -0.29691634f, -0.37513807f, 
    -0.04968536f, -0.02578432f, -0.41460541f, 0.19592915f, -0.02553103f, -0.03607560f, 0.11586108f, 0.05307296f, 
    -0.50045460f, 0.17386544f, -0.18180619f, -0.00093400f, 0.06455857f, -0.11746836f, 0.21190052f, 0.11862064f, 
    -0.14362837f, -0.62233466f, 0.06061925f, -0.46388346f, -0.38140196f, -0.39026922f, -0.51492769f, 0.17573790f, 
    0.02288914f, -0.02352753f, -0.04770786f, 0.28505948f, 0.26815575f, -0.22314341f, -0.27978566f, 0.09468286f, 
    0.01081346f, -0.68218589f, -0.27839065f, -0.32356074f, 0.08762440f, -0.20517983f, -0.27417308f, -0.24451196f, 
    0.14179572f, 0.04788829f, 0.17165580f, 0.01894737f, 0.06351201f, -0.25457734f, 0.11577337f, 0.01541757f, 
    0.16892825f, -0.01366160f, 0.04915539f, -0.02302194f, 0.05752968f, 0.01138185f, 0.26909280f, 0.06240972f, 
    -0.06321758f, -0.12979142f, 0.24409090f, -0.28992712f, -0.08908182f, 0.00932866f, 0.16466163f, -0.06174831f, 
    -0.35035512f, 0.30363470f, -0.46414191f, 0.45575273f, 0.10248940f, 0.36331403f, 0.01340559f, -0.06433692f, 
    -0.39610434f, -0.01670557f, -0.30649623f, -0.31868240f, 0.22007595f, 0.19358122f, -0.19624302f, 0.08947058f, 
    0.16456145f, 0.00813229f, 0.17390800f, 0.24040149f, 0.08960078f, -0.01869652f, -0.04517637f, -0.04082366f, 
    -0.00911354f, 0.25317466f, 0.02562178f, 0.07325745f, 0.05232856f, 0.30616462f, -0.08654715f, -0.03884939f, 
    0.10122167f, 0.27892861f, -0.06509349f, 0.04718144f, -0.00845723f, 0.00629518f, 0.00346771f, 0.00228882f, 
    0.06368084f, -0.03783188f, 0.04288974f, 0.06528120f, -0.08428231f, -0.23585148f, 0.14488934f, 0.13871740f, 
    0.06167560f, -0.01523733f, -0.03336947f, -0.13292052f, -0.08938874f, 0.02660012f, -0.00439179f, -0.47475967f, 
    -0.11937912f, 0.08607005f, -0.13057320f, 0.09079705f, -0.02034195f, 0.08497237f, 0.08985342f, 0.01361724f, 
    0.06558194f, -0.08047496f, 0.13428462f, 0.06797951f, -0.01399805f, 0.04777381f, -0.12459297f, 0.19477788f, 
    0.06379702f, 0.09208572f, 0.31845635f, 0.09121260f, -0.00808124f, 0.07258926f, -0.10655640f, -0.04114033f, 
    0.06557820f, -0.07404368f, -0.08772108f, -0.01773908f, 0.02958558f, -0.26403576f, 0.18547671f, 0.18561740f, 
    -0.04545872f, -0.12517108f, -0.06481008f, -0.03807529f, -0.07134590f, 0.02676716f, -0.09653895f, 0.02940417f, 
    0.00510731f, -0.14277631f, 0.00277883f, 0.50091505f, -0.02213652f, 0.11350716f, 0.16838408f, 0.04869097f, 
    -0.02348755f, -0.10094532f, 0.19794342f, -0.25705245f, -0.22550623f, -0.10753626f, -0.16292125f, -0.25060895f, 
    0.10820732f, 0.18177028f, -0.02019028f, -0.07664652f, 0.13653959f, 0.04054400f, 0.18283556f, -0.06683343f, 
    0.07181703f, -0.05944602f, 0.07615591f, 0.30649075f, -0.01534064f, -0.03662423f, 0.20766294f, 0.13515007f, 
    -0.29530981f, -0.02002078f, -0.12946175f, -0.16632521f, 0.06330153f, 0.10744862f, 0.05530984f, 0.03344796f, 
    -0.26147699f, -0.12433139f, 0.06499721f, 0.03415021f, 0.14333037f, -0.05140213f, 0.20647712f, 0.02624177f, 
    -0.11295883f, 0.02359248f, -0.23277821f, 0.27635944f, 0.17808738f, 0.30583861f, -0.01199786f, 0.07363950f, 
    0.10131117f, -0.61154360f, -0.17423868f, 0.69108498f, 0.18542156f, -0.73349303f, -0.02663629f, -0.27380136f, 
    0.04568056f, -0.57371306f, -0.20032112f, -0.48288700f, -0.04171217f, 0.08122586f, 0.04941034f, -0.13319367f, 
    0.22450100f, -0.14705206f, -0.15682432f, 0.10228230f, 0.12922683f, 0.05087951f, 0.39334086f, -0.42432943f, 
    -0.09771051f, -0.49508801f, 0.20521085f, 0.20152916f, -0.50948697f, 0.18965918f, 0.11257648f, 0.45850980f, 
    0.34606493f, -0.22864933f, 0.78065264f, 0.48387018f, -0.18479626f, -0.47644070f, -0.09367301f, 0.01381306f, 
    -0.06382388f, -0.12377705f, -0.07402305f, 0.28823930f, 0.15156052f, 0.10050033f, -0.09985020f, -0.23213917f, 
    -0.42227694f, 0.22299360f, 0.09676549f, -0.08813098f, 0.14294355f, -0.42147481f, 0.13146996f, 0.24134617f, 
    -0.12101099f, -0.29197454f, 0.14529322f, -0.02921689f, -0.51228464f, -0.01727856f, -0.50391442f, 0.11373927f, 
    0.47607943f, -0.34947568f, -0.09109726f, 0.15327083f, -0.06910888f, -0.05887168f, 0.01128477f, 0.05836353f, 
    0.06972144f, -0.29227036f, -0.00860527f, -0.46183845f, -0.17285284f, -0.05960449f, 0.25195262f, -0.74267977f, 
    0.25191602f, 0.21801715f, 0.14620605f, 0.10516756f, 0.13212088f, -0.36173341f, 0.18308754f, 0.16750842f, 
    0.41241011f, -0.34099922f, 0.07123014f, 0.04420745f, 0.31785834f, -0.09575299f, 0.09919950f, 0.09382163f, 
    -0.13544060f, -0.33932894f, -0.19336028f, -0.25195149f, -0.14267309f, -0.04462705f, 0.50940114f, -0.10739581f, 
    0.14755844f, 0.11793213f, -0.20182855f, 0.44911778f, 0.15311523f, 0.06364153f, 0.14175645f, -0.02113696f, 
    -0.30861521f, 0.12271593f, -0.36951277f, 0.14737864f, -0.24456525f, 0.07414501f, -0.57197666f, -0.07027428f, 
    -0.01547189f, 0.00195829f, -0.08226611f, -0.05803975f, 0.02143888f, 0.06932592f, -0.08360889f, 0.06229058f, 
    -0.00256378f, -0.01451948f, 0.05690617f, -0.09226535f, 0.02105884f, -0.07947052f, -0.06055551f, -0.03960489f, 
    -0.02087105f, -0.07993061f, -0.03060323f, 0.00377034f, 0.02661907f, 0.08567679f, 0.03192530f, 0.01310268f, 
    -0.06551207f, 0.04894142f, -0.03711950f, -0.02477462f, -0.05696149f, -0.02529363f, 0.00839651f, -0.01220889f, 
    0.06598065f, -0.00131090f, -0.07701802f, 0.05823493f, -0.06156814f, 0.05384511f, -0.03122724f, -0.07614274f, 
    -0.03590846f, -0.01139808f, -0.02642260f, -0.02695853f, -0.02873816f, 0.03678318f, -0.05942709f, -0.03620661f, 
    0.03883861f, -0.02931974f, -0.02854055f, -0.08956257f, -0.01682870f, 0.01621649f, -0.07433778f, -0.08062410f, 
    -0.01830939f, 0.01699774f, 0.05071806f, -0.00730450f, -0.05204774f, -0.00564915f, 0.07646077f, -0.04608718f, 
    0.06391154f, -0.07790880f, 0.05421036f, -0.10171087f, 0.06908715f, 0.02682493f, -0.01426074f, -0.06365713f, 
    -0.07731621f, -0.03605992f, -0.08333480f, 0.00018364f, -0.00658328f, 0.03002776f, -0.06144235f, 0.06944916f, 
    -0.03148425f, 0.06407677f, -0.04343111f, 0.00163347f, 0.03660309f, 0.02148696f, 0.01131546f, 0.03469496f, 
    -0.03742340f, -0.00217958f, 0.03128089f, 0.04454784f, 0.02769495f, -0.09907513f, -0.06521883f, 0.05507638f, 
    -0.05582653f, -0.00181646f, 0.04257398f, 0.03691607f, 0.02262067f, -0.01303870f, 0.05515385f, 0.07083496f, 
    0.03066378f, 0.07229524f, -0.06505736f, -0.02898622f, -0.04316799f, 0.02458392f, 0.02774597f, 0.06926739f, 
    -0.05875847f, 0.02478099f, -0.08333169f, -0.07759657f, 0.02955211f, -0.07440363f, -0.00364282f, -0.03243420f, 
    0.05670222f, 0.02831300f, 0.03840049f, 0.05390936f, -0.08841847f, -0.09531020f, -0.03716204f, 0.02645246f, 
    0.29293212f, 0.05452657f, -0.11671574f, -0.16722555f, 0.03187865f, 0.02604910f, -0.18645060f, 0.16156335f, 
    0.27396011f, 0.03171212f, 0.04670195f, 0.41784149f, 0.20014685f, 0.03145607f, 0.19377121f, 0.05892475f, 
    0.05865449f, -0.03850504f, -0.20598035f, 0.09261011f, -0.03629266f, 0.02915455f, -0.07040334f, -0.08461722f, 
    0.03982664f, -0.12297793f, -0.04117002f, 0.34816134f, 0.17235270f, -0.13215713f, 0.09575988f, -0.48264557f, 
    0.17199628f, 0.02572850f, 0.08486155f, -0.00908113f, -0.36079547f, -0.00109835f, -0.11615878f, -0.71030569f, 
    0.13037899f, -0.02340560f, -0.03933958f, 0.24818331f, 0.06800945f, 0.25069410f, 0.14457087f, 0.12649180f, 
    0.01764335f, 0.04741433f, 0.51966202f, 0.02802400f, -0.02533859f, 0.04822087f, -0.10187091f, 0.02901436f, 
    0.03182276f, 0.01649136f, 0.22719455f, 0.03162365f, -0.00072597f, -0.17208245f, 0.15763217f, -0.51456726f, 
    0.22482939f, 0.20621689f, -0.00570499f, 0.14673600f, -0.09490986f, 0.59031367f, -0.14727859f, -0.02115935f, 
    0.40640581f, -0.45997989f, -0.06137322f, -0.02300942f, 0.08484636f, 0.02069605f, -0.07447054f, -0.16166744f, 
    -0.64320856f, -0.23597229f, 0.05895611f, 0.08410100f, -0.12589736f, -0.19699767f, 0.26276401f, 0.30735686f, 
    0.00954605f, 0.14949933f, 0.73398191f, -0.60876423f, -0.41311893f, -0.04966182f, 0.10148887f, 0.31428578f, 
    0.10460553f, -0.07671174f, 0.18302634f, 0.08571661f, 0.18676142f, -0.19576859f, 0.10722008f, 0.15310507f, 
    0.01595424f, -0.56247729f, -0.08047416f, 0.08429506f, -0.56783164f, -0.15671563f, 0.13986525f, 0.47562101f, 
    -0.26556531f, -0.13234651f, -0.53355366f, 0.21050653f, 0.14802182f, -0.04022174f, 0.30216613f, -0.00205724f, 
    -0.37537190f, 0.06578382f, 0.03354276f, -0.00164696f, -0.14866288f, 0.03703099f, -0.02468197f, -0.04736215f, 
    -0.10997717f, 0.23361269f, -0.10074014f, -0.03206321f, 0.03202278f, 0.07454763f, -0.00540020f, 0.15135808f, 
    0.09304484f, -0.14362460f, -0.07243776f, -0.20674299f, 0.09817833f, -0.00486570f, 0.02243186f, 0.20789573f, 
    0.08895902f, -0.30493030f, -0.15201475f, 0.15067482f, -0.08928236f, 0.03042582f, 0.01854837f, -0.01667666f, 
    0.01280140f, -0.00901798f, -0.05497985f, 0.14637317f, 0.07196127f, 0.13347748f, -0.04229709f, -0.27565688f, 
    0.00439891f, -0.15004909f, 0.11747433f, 0.08407965f, -0.42096525f, 0.01146207f, -0.05118212f, 0.15523760f, 
    0.03520142f, -0.03598890f, -0.01031310f, 0.10529021f, 0.23165239f, 0.27743903f, 0.01831993f, 0.02670085f, 
    -0.04900049f, 0.06583339f, 0.50248414f, -0.00130700f, 0.13561937f, 0.00186790f, 0.01165891f, -0.09959862f, 
    0.07130208f, 0.17251830f, -0.13506100f, -0.04811124f, 0.14437982f, -0.22131479f, 0.19583832f, -0.06336804f, 
    0.74810410f, 0.09898726f, 0.19863342f, 0.16679238f, -0.17382394f, 0.24753961f, -0.28396794f, -0.07051549f, 
    0.04114908f, -0.19381514f, 0.09828151f, -0.01774682f, 0.24544500f, 0.11730088f, 0.07687064f, -0.08781639f, 
    -0.22036965f, -0.09556176f, -0.04289633f, -0.06952839f, 0.01406741f, -0.19659020f, -0.57295632f, 0.54393363f, 
    0.02789677f, 0.11786053f, -0.22124200f, -0.05678638f, 0.13693017f, 0.18687125f, -0.00456030f, 0.21374504f, 
    0.00127580f, -0.21988688f, -0.07428083f, -0.01351174f, -0.06213619f, -0.14889465f, -0.05865725f, 0.16702247f, 
    -0.08448659f, -0.37829295f, -0.03561496f, -0.50896132f, -0.02414647f, 0.09763601f, -0.01688223f, 0.28024063f, 
    -0.13877541f, 0.04878131f, -0.05737811f, 0.00403709f, 0.21806219f, 0.09058966f, 0.10467331f, -0.07895476f, 
    0.04452274f, -0.09127159f, 0.02004011f, -0.03095320f, 0.09429234f, 0.14860325f, -0.22533308f, -0.03383676f, 
    0.07582872f, -0.05036995f, -0.06330305f, -0.06967679f, -0.00876310f, -0.04411977f, 0.00509617f, -0.02630295f, 
    -0.04518957f, -0.09925911f, -0.04647340f, -0.02998830f, 0.00864142f, 0.05258633f, -0.08303785f, -0.03716023f, 
    -0.06121550f, -0.05294536f, -0.04547019f, -0.06631869f, -0.04688562f, -0.07241086f, -0.08203717f, -0.02152308f, 
    -0.00267170f, 0.00978851f, 0.05541942f, -0.05293965f, -0.04999191f, -0.01812705f, -0.08695395f, -0.00576009f, 
    -0.03793456f, -0.04770045f, 0.00876815f, 0.00739201f, -0.00068493f, 0.02528925f, -0.08926059f, -0.07917510f, 
    -0.00235845f, 0.03916482f, -0.05897489f, -0.05807463f, -0.07357275f, -0.08431736f, -0.10976170f, -0.01524900f, 
    -0.08344698f, -0.00488201f, 0.02896003f, 0.00359648f, 0.02620690f, 0.08446223f, -0.04567233f, -0.09674814f, 
    -0.07886707f, -0.02794983f, 0.04664365f, -0.07670886f, 0.05024728f, 0.03811490f, -0.11289074f, 0.04824521f, 
    0.08563222f, 0.02458221f, -0.00843872f, -0.04426099f, -0.07988912f, 0.07755352f, 0.02461260f, -0.04532581f, 
    -0.07640180f, -0.06440186f, 0.03023647f, -0.07910475f, -0.04723376f, 0.02925136f, -0.00643436f, -0.07885160f, 
    -0.04549939f, 0.00341204f, 0.03885839f, -0.08689878f, 0.00454951f, -0.04505932f, 0.08168106f, -0.06064864f, 
    -0.01548372f, -0.06130576f, 0.05803578f, -0.01829731f, -0.09835006f, -0.03578274f, -0.00535360f, -0.07980940f, 
    -0.02134166f, 0.02734572f, -0.00089086f, -0.02338288f, -0.06716342f, -0.02528705f, 0.04224392f, -0.04598032f, 
    -0.02919097f, 0.05203665f, -0.11773118f, -0.03087075f, -0.01511623f, -0.07732732f, 0.04848220f, -0.01436287f, 
    -0.02947449f, 0.04704970f, -0.09144764f, 0.00257462f, -0.01637203f, -0.05088885f, -0.05572730f, 0.08112692f, 
    -0.04294191f, 0.04389289f, -0.00161727f, -0.08928030f, 0.00671074f, -0.01657777f, -0.05587131f, -0.06787638f, 
    0.35017395f, -0.11576161f, -0.13051192f, 0.10576297f, -0.09513952f, 0.03258993f, 0.09476073f, 0.05995626f, 
    0.33349594f, -0.08106940f, -0.05744451f, 0.03968017f, -0.08541675f, -0.04593469f, 0.18546370f, 0.12333550f, 
    -0.18790251f, 0.27322596f, 0.17617217f, -0.06076063f, 0.03624168f, 0.04410764f, 0.00158218f, -0.04842663f, 
    -0.13948543f, -0.03991977f, 0.13230515f, 0.20486051f, 0.01778893f, 0.02568531f, 0.18343982f, -0.16154154f, 
    -0.09241027f, 0.15026727f, 0.00846718f, -0.00565890f, 0.41819409f, -0.22639441f, -0.03194749f, -0.22026095f, 
    0.05026088f, -0.08177630f, -0.01604396f, 0.15358859f, -0.00100858f, 0.08515332f, 0.15920231f, 0.18141533f, 
    -0.04266036f, 0.13864239f, 0.18030348f, 0.04956588f, 0.08692367f, 0.06743082f, 0.14612330f, 0.03493040f, 
    0.10307869f, -0.08586548f, -0.09260924f, -0.05281130f, 0.01106395f, -0.03992458f, 0.07847182f, -0.22427914f, 
    -0.03949761f, 0.17713505f, 0.04871863f, 0.09920945f, 0.08664902f, 0.22021654f, -0.09005657f, -0.22346699f, 
    0.00621114f, -0.20295107f, 0.28691843f, 0.01388678f, 0.15563169f, 0.13729337f, 0.08182711f, -0.09177019f, 
    -0.15274763f, 0.27591297f, 0.03606981f, -0.01727931f, 0.09242852f, -0.18155232f, 0.23256969f, -0.05618552f, 
    -0.00490753f, 0.12472115f, 0.31201950f, 0.25335214f, 0.02750562f, -0.01526797f, 0.08379728f, 0.33759940f, 
    0.17737103f, -0.05315664f, 0.18198098f, -0.01640304f, 0.16485803f, -0.17215079f, -0.21928601f, 0.08542039f, 
    0.03648417f, 0.09137414f, -0.09646533f, -0.29906714f, -0.06643584f, 0.04554988f, -0.18546394f, 0.23066059f, 
    -0.17582074f, -0.11659756f, -0.01654837f, -0.11220603f, -0.04271155f, -0.03706273f, 0.18899345f, -0.00851875f, 
    -0.08719490f, 0.26743209f, -0.05268546f, 0.28820172f, -0.05078075f, -0.00218784f, 0.30213368f, -0.01260871f, 
    -0.08701785f, 0.07248386f, -0.15191387f, -0.07107270f, 0.09381728f, 0.05137235f, -0.00211847f, 0.11506478f, 
    0.25597021f, -0.16728421f, 0.13333327f, 0.10660785f, 0.13355006f, -0.11258030f, 0.21734476f, -0.06750215f, 
    -0.06989377f, 0.04109952f, 0.06187657f, 0.08726674f, 0.09842108f, 0.00267877f, -0.07048038f, -0.13005711f, 
    -0.05112052f, 0.11973894f, 0.04795549f, 0.01383669f, -0.13818109f, 0.14978096f, 0.04070889f, -0.07765248f, 
    0.09946819f, 0.10991241f, 0.23342410f, -0.16817260f, 0.09895431f, -0.02053365f, 0.04470798f, 0.40924501f, 
    0.20966955f, 0.13826074f, 0.36100897f, 0.06220814f, -0.08251297f, 0.06759983f, 0.12841691f, -0.02597963f, 
    -0.00213436f, -0.14946286f, -0.10601227f, 0.05458183f, 0.00384093f, -0.04911295f, 0.19644368f, 0.00074892f, 
    0.06986842f, 0.08914421f, -0.33072323f, 0.11432484f, 0.01030303f, 0.07565620f, 0.20540616f, -0.10530074f, 
    -0.30525607f, -0.11764314f, 0.05904942f, -0.06428327f, -0.04117651f, -0.21345653f, 0.16212747f, 0.08338995f, 
    -0.13548383f, -0.08424421f, 0.12960587f, 0.08254532f, -0.01517611f, 0.18154766f, -0.09368452f, 0.12383479f, 
    0.00763449f, 0.01458910f, -0.04848585f, -0.08042358f, -0.02752463f, 0.10102964f, -0.36914518f, 0.07272708f, 
    0.05469905f, -0.02012381f, 0.10074759f, 0.09988104f, -0.10335432f, 0.31718063f, 0.19054319f, 0.29723111f, 
    -0.09676979f, 0.07345358f, 0.37311918f, -0.04322639f, 0.11279253f, -0.19454764f, -0.01384973f, 0.17984350f, 
    0.02433326f, 0.11478986f, -0.00085753f, 0.60563016f, -0.18341173f, 0.01431380f, -0.05217505f, 0.04897589f, 
    -0.07047421f, 0.15593934f, -0.10627919f, 0.20197606f, -0.01480183f, 0.02946080f, 0.21289213f, 0.10043009f, 
    -0.23335601f, -0.01567435f, 0.12713854f, -0.10361005f, 0.12040120f, 0.09363355f, -0.09379698f, 0.04847466f, 
    -0.13677108f, -0.01157693f, -0.43118784f, 0.10979500f, -0.02291828f, 0.12382639f, 0.01333236f, 0.17602842f, 
    -0.04724929f, -0.25876576f, -0.14134653f, 0.19700389f, 0.07095512f, -0.27395898f, 0.26929715f, -0.12789339f, 
    -0.03696171f, -0.01091741f, -0.23853077f, -0.18181676f, 0.06395224f, 0.05787882f, 0.08632226f, -0.05082152f, 
    0.17084838f, -0.00779601f, -0.03081954f, 0.01068374f, -0.16899151f, 0.31845072f, 0.37607083f, -0.03718169f, 
    -0.02027367f, -0.08595545f, 0.25202799f, -0.05683053f, -0.33873415f, 0.04869015f, -0.01550705f, 0.58323282f, 
    0.14186908f, 0.05201552f, 0.27243623f, 0.00908330f, -0.20822249f, 0.14635707f, -0.04587721f, 0.13811792f, 
    0.08210506f, -0.06078702f, 0.04719242f, 0.01059276f, 0.04919987f, -0.06044863f, -0.00136461f, 0.10252887f, 
    0.11476497f, 0.13367951f, -0.07008643f, 0.09363922f, -0.09063119f, 0.04254121f, 0.31087068f, 0.11517558f, 
    -0.03300830f, -0.08989582f, 0.09299921f, 0.09938813f, -0.09509108f, 0.21014777f, -0.13206539f, 0.13434494f, 
    0.18537469f, -0.04218093f, 0.00725904f, 0.01642629f, 0.13398777f, 0.27511448f, 0.12825581f, 0.13658904f, 
    0.15938868f, -0.00792883f, 0.06243324f, -0.09508585f, -0.02740910f, -0.16471384f, -0.26416215f, 0.10497022f, 
    0.17489764f, 0.15764266f, -0.21971162f, 0.16988932f, -0.06825352f, -0.32919452f, -0.19100858f, 0.02643113f, 
    0.12043868f, -0.19243683f, 0.45418867f, -0.03349288f, 0.13859698f, -0.23539004f, -0.04360260f, 0.08698984f, 
    0.01645830f, -0.13146171f, -0.20085000f, -0.04469244f, -0.02521172f, 0.03617303f, 0.10336255f, 0.23424846f, 
    -0.04659024f, 0.07725953f, -0.02642192f, 0.05812224f, 0.14424159f, 0.06149268f, 0.09277758f, 0.07953108f, 
    -0.11795844f, 0.15934649f, 0.15025546f, 0.11108974f, 0.16846463f, -0.05903394f, -0.29750675f, -0.01059537f, 
    -0.01677790f, 0.07059427f, 0.39726385f, 0.03697171f, 0.19572669f, 0.03546997f, 0.05467581f, 0.10041869f, 
    -0.15417421f, 0.20166554f, 0.08353787f, 0.18902516f, 0.02976545f, 0.13799125f, -0.37484235f, 0.07380154f, 
    0.26109666f, -0.12712978f, -0.06105522f, -0.04132032f, -0.05353791f, -0.01440659f, 0.08143470f, 0.08321641f, 
    0.28359339f, 0.03354005f, -0.13033187f, -0.25533918f, 0.37266338f, -0.59257698f, 0.01517561f, -0.19980060f, 
    0.20444496f, -0.22496030f, -0.17343791f, 0.29533216f, -0.87255293f, 0.20351736f, 0.06804956f, 0.04956683f, 
    -0.09312820f, -0.25399229f, 0.02916836f, 0.39058793f, 0.33758628f, -0.16586377f, 0.10160623f, -0.27432173f, 
    -0.05884921f, -0.07385868f, 0.47581980f, -0.05650597f, 0.13816328f, 0.03851272f, -0.36044565f, 0.09462526f, 
    0.02186098f, 0.26218697f, 0.06530256f, 0.18019520f, 0.10514818f, -0.05040875f, -0.07879137f, 0.08205643f, 
    0.15632647f, -0.10385779f, -0.11116696f, 0.13334022f, -0.00147116f, 0.49425516f, 0.18270552f, 0.14159285f, 
    0.37593180f, -0.04700759f, -0.35413221f, -0.18560968f, -0.14359072f, -0.06149282f, 0.10190909f, -0.22077361f, 
    0.32862040f, 0.06195458f, 0.09000915f, -0.40453008f, 0.05182465f, 0.25110644f, 0.59885907f, 0.10708355f, 
    0.21736436f, 0.17310579f, -0.00838202f, -0.42970344f, -0.12950698f, 0.51719791f, 0.08592939f, -0.11095790f, 
    0.08294344f, 0.16055411f, -0.38896510f, -0.00207510f, 0.04345739f, 0.35051614f, 0.18884023f, 0.01991897f, 
    0.10186473f, -0.24421312f, -0.00088621f, -0.04290949f, -0.35368317f, -0.14119847f, 0.28518596f, 0.01379156f, 
    0.23621044f, -0.08417330f, 0.00608337f, 0.11501523f, 0.39101580f, 0.17777054f, -0.10322506f, 0.04572484f, 
    -0.20272371f, -0.18879372f, 0.04261809f, -0.10911452f, -0.11445793f, 0.15590490f, -0.14877819f, -0.04673826f, 
    -0.06208162f, 0.17222829f, -0.24333015f, 0.15704490f, -0.04491992f, 0.11222193f, 0.08859663f, 0.10653162f, 
    -0.00147941f, -0.22511020f, 0.03532114f, -0.20888276f, -0.04936322f, -0.18732584f, -0.03799360f, 0.13378006f, 
    0.02669417f, 0.05087050f, 0.15672910f, -0.03391056f, 0.18048447f, -0.08833031f, -0.05669094f, 0.18204437f, 
    0.12410888f, -0.03209351f, -0.00353448f, -0.14250946f, -0.02696607f, 0.07530678f, -0.01618532f, 0.08241010f, 
    -0.03503419f, 0.05128151f, 0.07899942f, -0.04553471f, -0.03563554f, 0.00486911f, 0.07613929f, 0.77072930f, 
    0.06316400f, 0.03828232f, 0.51017922f, -0.19328910f, 0.11498088f, -0.52452123f, -0.11709490f, -0.03517831f, 
    -0.04007937f, -0.03996714f, -0.37322310f, 0.02905916f, 0.04323265f, 0.06286909f, 0.19654252f, -0.08856011f, 
    -0.08787365f, 0.05114155f, 0.02551391f, -0.04086572f, 0.16659012f, -0.02418193f, 0.03855753f, 0.27482912f, 
    -0.36635548f, -0.03758477f, -0.09523702f, -0.06975340f, 0.08895465f, -0.08775455f, -0.11755753f, -0.03250564f, 
    -0.01576055f, 0.35275775f, 0.10404414f, 0.09091401f, 0.15108646f, -0.10314430f, -0.05532162f, 0.01418096f, 
    0.03840748f, 0.12537538f, -0.02311419f, -0.26933590f, 0.03348359f, -0.25076109f, 0.74886489f, -0.13217457f, 
    0.10644654f, 0.12269277f, -1.09609091f, 0.19457516f, 0.13830695f, 0.23637837f, 0.16377731f, -0.09051380f, 
    0.04400416f, 0.03580642f, 0.03304322f, -0.07352988f, 0.12080456f, 0.20461462f, -0.05670050f, 0.04263709f, 
    0.04054084f, 0.13195042f, 0.14105804f, -0.40086362f, -0.19134638f, 0.00705942f, -0.04714080f, -0.18926650f, 
    0.24529234f, 0.18940715f, 0.08298966f, 0.19602923f, 0.15209393f, 0.21785222f, 0.12099501f, -0.00337820f, 
    0.19336492f, 0.23571728f, -0.19245286f, 0.06158284f, 0.17510489f, 0.30058399f, 0.02582028f, -0.05641624f, 
    0.15227816f, -0.07120863f, 0.13942581f, 0.13079943f, 0.21945210f, 0.24427660f, 0.21697414f, -0.25229865f, 
    -0.10366683f, 0.12258057f, 0.14701870f, 0.03678945f, 0.06028304f, 0.29618552f, -0.05332502f, -0.17838514f, 
    0.25817510f, 0.15095484f, -0.18416588f, 0.09142536f, 0.02839643f, -0.00846077f, 0.03760327f, -0.01013337f, 
    0.02792387f, -0.44892967f, -0.11236617f, -0.08917890f, -0.03372803f, 0.02731809f, 0.05270071f, 0.24160320f, 
    0.06347912f, -0.22122714f, 0.19477189f, -0.02655723f, 0.75107104f, 0.06663074f, 0.20230499f, -0.00847807f, 
    -0.01421868f, 0.16494584f, -0.00802153f, -0.18624942f, -0.24789308f, 0.20315133f, 0.11544664f, -0.01414564f, 
    0.03141575f, -0.02163488f, -0.61257213f, 0.17819394f, -0.02771530f, 0.07448500f, -0.13313715f, 0.20861247f, 
    -0.00919507f, 0.05516607f, -0.02864396f, 0.21783213f, 0.01605778f, -0.24865675f, -0.21170984f, 0.37070122f, 
    -0.06953692f, -0.20209850f, -0.15581273f, 0.07509487f, -0.07645418f, -0.12177798f, -0.12877436f, 0.17346330f, 
    -0.26430434f, -0.03389151f, -0.12542966f, -0.06305476f, -0.17168935f, -0.11754671f, -0.05506147f, 0.11519580f, 
    -0.06674282f, -0.27039367f, 0.06156083f, 0.45340902f, 0.17774202f, 0.17086987f, -0.56876963f, -0.08910759f, 
    0.00511558f, -0.00901216f, -0.14191635f, 0.30648199f, 0.04959467f, -0.71873623f, 0.10990528f, -0.22458959f, 
    0.20558576f, 0.38147068f, 0.23153315f, 0.03718705f, 0.13441285f, 0.07764575f, 0.20836864f, -0.46766326f, 
    0.12507260f, -0.04220548f, 0.02158874f, 0.02788420f, 0.11893456f, 0.29329330f, 0.19616158f, -0.62335557f, 
    0.00819175f, -0.06906855f, -0.10353503f, 0.13893661f, 0.04110332f, 0.07502843f, 0.09034640f, 0.02443893f, 
    -0.11872518f, -0.19382314f, 0.11070968f, 0.03594557f, 0.05053034f, -0.07542878f, 0.21529719f, -0.05888149f, 
    0.35200271f, 0.03421720f, -0.08032404f, 0.35679328f, 0.09224329f, 0.13618930f, -0.10945451f, 0.02224536f, 
    -0.30691260f, 0.08100925f, 0.01147948f, -0.27828676f, 0.08495209f, 0.07571115f, -0.18078411f, 0.23230831f, 
    0.27410057f, 0.08019879f, 0.00004169f, 0.29951376f, 0.11819922f, 0.08655341f, 0.08373953f, 0.14605278f, 
    0.12251194f, -0.00122077f, 0.00460160f, 0.12569830f, 0.16141628f, 0.01606754f, 0.04189690f, 0.21171793f, 
    0.12154663f, 0.04809268f, -0.01238394f, 0.14666383f, -0.26094279f, -0.18570456f, 0.04992944f, 0.07424182f, 
    -0.28585938f, 0.16207531f, 0.14218740f, 0.09353731f, 0.07413740f, -0.21779588f, 0.14499356f, -0.09410264f, 
    0.06454046f, 0.20107123f, 0.33693337f, 0.02618073f, -0.00696059f, -0.02953748f, -0.35656714f, 0.07997243f, 
    0.17100143f, 0.09634243f, -0.10487255f, 0.17260046f, -0.08068402f, 0.02904474f, -0.02264702f, 0.13623510f, 
    0.21262549f, 0.03891816f, -0.17361920f, 0.15921311f, -0.12630847f, 0.16310251f, -0.21821880f, 0.07277328f, 
    0.11091918f, 0.27656588f, -0.28780502f, -0.13352120f, 0.18355811f, -0.15884662f, -0.04825392f, -0.02223630f, 
    -0.01211434f, 0.13787331f, 0.04345896f, 0.16653836f, 0.00875342f, -0.18179408f, 0.43002036f, -0.26477411f, 
    0.03867687f, -0.01311079f, -0.04677366f, -0.31278390f, -0.10872722f, -0.22379416f, -0.31193283f, -0.13734810f, 
    0.16802570f, 0.07018118f, -0.28995219f, 0.08282371f, -0.10310443f, 0.46777681f, 0.21875928f, -0.19859645f, 
    0.07473964f, -0.47459617f, 0.21946228f, -0.65285695f, 0.25141603f, -0.04487347f, -0.08847695f, 0.28977081f, 
    0.13959822f, -0.15293264f, -0.03728606f, 0.01864806f, 0.04276049f, 0.14385214f, -0.03528640f, 0.00777037f, 
    0.26255074f, -0.28050146f, 0.12742820f, -0.10455044f, 0.12125754f, -0.00899469f, 0.05866307f, -0.09934239f, 
    0.16434100f, 0.14471486f, -0.10716451f, 0.07739762f, -0.18328628f, 0.18388180f, -0.11338346f, 0.02546475f, 
    -0.12838094f, -0.02257394f, -0.27108514f, 0.33720711f, -0.11753569f, -0.08671213f, 0.05423810f, 0.07717050f, 
    -0.03366836f, 0.04038218f, -0.04390986f, -0.00795558f, -0.00710261f, 0.01152684f, 0.01093586f, 0.10136906f, 
    0.09582035f, 0.01403509f, 0.14844750f, 0.23642670f, 0.09546714f, 0.05845626f, 0.16585971f, 0.12186313f, 
    -0.14519928f, 0.06414033f, 0.07625864f, 0.16732335f, -0.51402140f, -0.32327288f, 0.02671140f, 0.15796024f, 
    -0.25469568f, -0.16728745f, -0.42440441f, 0.02515273f, -0.19700949f, 0.11217052f, 0.09313214f, 0.15431625f, 
    -0.07200629f, 0.32413107f, 0.47155878f, 0.14754507f, 0.04107391f, -0.07411262f, -0.35202950f, -0.14855199f, 
    -0.01410711f, 0.06101704f, -0.10567459f, -0.17956787f, 0.07488977f, 0.16626441f, 0.15757647f, 0.38521609f, 
    0.27355736f, 0.11349200f, 0.12267810f, -0.03695776f, 0.19296844f, -0.68396688f, -0.30145943f, 0.25159734f, 
    0.22674172f, -0.34238058f, 0.11684413f, -0.28811288f, 0.28923476f, 0.22804444f, 0.28952238f, 0.03860975f, 
    0.11066694f, -0.19041885f, 0.17186248f, 0.14193331f, -0.08088904f, -0.21918167f, -0.67995936f, 0.17854442f, 
    0.45557019f, -0.01524163f, -0.35167488f, 0.03972078f, 0.10712445f, -0.71722680f, -0.51473403f, 0.03430694f, 
    0.36187932f, -0.40277752f, -0.03887137f, -0.04594475f, 0.03811850f, -0.04202997f, 0.01711318f, 0.12968040f, 
    -0.08347110f, -0.27241382f, -0.04476558f, -0.08398389f, 0.29050347f, 0.13008311f, -0.22846688f, 0.43864301f, 
    -0.33340365f, -0.08393046f, -0.05732092f, -0.28130481f, 0.02709299f, -0.09757404f, 0.04543355f, 0.05580388f, 
    -0.37604359f, -0.09525769f, 0.09267844f, 0.10820650f, 0.18731837f, -0.24766788f, 0.00192497f, 0.04929304f, 
    0.03970719f, 0.07727236f, 0.32645416f, 0.06653785f, 0.10193972f, 0.23561515f, 0.09033024f, 0.01407242f, 
    -0.20588581f, 0.11322151f, -0.08054062f, 0.26563057f, 0.08495936f, 0.08584444f, -0.12509428f, 0.01058695f, 
    0.35837024f, 0.05396258f, -0.13254739f, -0.12635206f, -0.25561106f, 0.08283790f, 0.06679580f, 0.06791956f, 
    0.15905991f, 0.12336741f, -0.08439678f, -0.14497250f, 0.15693551f, -0.06583485f, 0.36259040f, -0.32442150f, 
    -0.03090547f, -0.00193869f, 0.07877851f, 0.15404052f, -0.80187142f, 0.15930483f, 0.13379450f, 0.01301626f, 
    0.00158874f, -0.06267904f, -0.22003579f, 0.33285135f, 0.17280751f, 0.05965973f, 0.08633033f, -0.06058480f, 
    -0.02292345f, -0.16257690f, 0.05553277f, 0.08107805f, 0.14116217f, -0.04049313f, -0.23024689f, 0.04246595f, 
    -0.03011137f, 0.08873104f, -0.11149092f, -0.08486979f, 0.10529861f, 0.09821095f, 0.02633498f, 0.17498291f, 
    0.16110639f, -0.04694786f, -0.00269937f, 0.10317411f, 0.34032512f, 0.14036749f, 0.06314246f, 0.06872400f, 
    0.37207830f, -0.06745292f, -0.14541371f, -0.14932880f, -0.00642265f, 0.28032458f, 0.12352584f, -0.08486365f, 
    0.11112085f, -0.23551802f, 0.05604888f, -0.05550571f, 0.17311467f, 0.16642050f, 0.37611815f, 0.17944184f, 
    0.28853849f, 0.31350207f, -0.49997070f, 0.05031727f, -0.02928849f, 0.15837651f, -0.01215855f, -0.05184867f, 
    0.14415352f, 0.06309301f, 0.02037528f, -0.02298328f, 0.23321497f, -0.03190260f, 0.00356562f, -0.07838601f, 
    0.07159192f, 0.05395098f, -0.15624663f, -0.30205429f, -0.06566209f, 0.20906535f, 0.30293894f, -0.08849181f, 
    0.09404241f, -0.12219759f, -0.04699963f, 0.18187310f, 0.29346874f, -0.00845662f, 0.00340857f, -0.01107839f, 
    -0.30229342f, 0.10355831f, -0.07967237f, 0.15133797f, -0.04419972f, 0.05632884f, -0.11282459f, 0.07104816f, 
    -0.05148817f, -0.10073182f, 0.07813057f, -0.00923836f, -0.06952414f, -0.03598871f, -0.04202858f, -0.07060634f, 
    -0.00437820f, 0.01570068f, -0.12112348f, 0.04271182f, -0.08587575f, 0.06094338f, 0.01487618f, -0.02932262f, 
    -0.14819744f, -0.03980607f, -0.06620749f, -0.04084672f, 0.01305601f, 0.01795922f, 0.02100466f, 0.02538092f, 
    -0.08509415f, -0.03107327f, -0.02779094f, -0.06576850f, 0.08124635f, -0.03361914f, -0.09157597f, -0.07078619f, 
    -0.05783859f, -0.03670774f, -0.09622648f, -0.01946518f, 0.05424583f, -0.07866133f, -0.03072085f, -0.04952398f, 
    0.04882572f, 0.00651930f, -0.06196377f, 0.08398486f, 0.01136160f, -0.08644887f, -0.08995266f, 0.03799006f, 
    -0.08762719f, -0.01994634f, -0.01325420f, -0.04829261f, -0.12021002f, -0.07603221f, -0.08820694f, -0.01720497f, 
    0.03178942f, -0.02451584f, -0.03070898f, -0.13414703f, -0.01664308f, -0.08470430f, -0.09232918f, 0.01757917f, 
    0.02421767f, -0.00112749f, 0.05234558f, 0.06244919f, -0.05853841f, 0.08167036f, 0.02094907f, 0.02679561f, 
    -0.05057275f, 0.00453665f, 0.04464635f, -0.05719102f, -0.10692820f, 0.05405243f, -0.01407147f, -0.03443269f, 
    -0.01222415f, 0.08487165f, -0.01783879f, -0.07967460f, -0.05762194f, -0.05259001f, 0.00449190f, 0.02253854f, 
    0.04103725f, -0.11042129f, 0.07737625f, -0.03065505f, 0.01577065f, 0.07328036f, -0.15350728f, -0.02555967f, 
    -0.12558873f, -0.01506222f, -0.01490116f, 0.03103215f, -0.15859105f, -0.00555680f, -0.03127906f, -0.03574410f, 
    -0.09517640f, -0.04780264f, -0.10381957f, 0.03099292f, 0.07565373f, -0.02824343f, -0.09244353f, 0.00331079f, 
    0.09890321f, 0.05894207f, -0.00954144f, -0.06158425f, -0.05685647f, -0.04404746f, -0.12300934f, -0.07005624f, 
    0.08121852f, -0.08047773f, -0.01069616f, -0.00456220f, -0.08145894f, -0.08113962f, -0.04450177f, 0.07954873f, 
    0.05197927f, -0.21960990f, 0.07839087f, -0.73298085f, -0.19627523f, -0.41207248f, -0.01173655f, -0.20565559f, 
    0.17357470f, 0.16548912f, 0.04530973f, 0.14242031f, -0.10209830f, 0.23528518f, 0.39278114f, 0.16451633f, 
    -0.14454372f, 0.35803902f, -0.03655007f, -0.00996840f, -0.53096372f, 0.01640604f, 0.02446551f, 0.02781890f, 
    -0.13215974f, 0.03756442f, 0.17827708f, 0.04492447f, -0.00355994f, 0.31258842f, -0.19799194f, -0.17367718f, 
    -0.03901108f, 0.34549433f, 0.07720625f, -0.23507899f, 0.03550265f, -0.18279035f, -0.34489092f, 0.28250310f, 
    0.00766716f, 0.08499867f, -0.72883272f, -0.15234692f, 0.09354746f, 0.52356899f, 0.07641639f, 0.15449777f, 
    -0.05441571f, -0.28130376f, 0.30913097f, -0.58288568f, -0.00572374f, 0.00678853f, 0.03157194f, 0.04883531f, 
    0.20605427f, -0.26504007f, -0.41136998f, -0.04179774f, -0.06759617f, 0.11976665f, -0.21040450f, 0.41168869f, 
    0.07991658f, 0.30291927f, -0.32126901f, 0.29455912f, 0.22642860f, 0.20118742f, 0.16058484f, -0.03809230f, 
    -0.29644853f, 0.07216206f, 0.04185185f, -0.40038103f, -0.04026673f, 0.48352197f, 0.06548530f, -0.05675452f, 
    -0.09317972f, 0.59455138f, 0.05115237f, 0.16458333f, 0.02396244f, -0.03394070f, -0.38124707f, 0.22553988f, 
    -0.32940677f, -0.13860115f, -0.41866180f, 0.29766843f, -0.06183711f, 0.35905123f, -0.11155361f, 0.02303322f, 
    -0.57848388f, 0.13416572f, 0.28135377f, -0.06263433f, -0.11979263f, -0.27564031f, -0.24309406f, -0.10050534f, 
    0.02247246f, 0.30100459f, -0.31553617f, 0.54408401f, -0.01211969f, 0.17833924f, -0.19800758f, 0.14487042f, 
    0.05533586f, -0.32433093f, 0.11051935f, -0.31291088f, -0.08468167f, -0.25969663f, 0.06596343f, -0.03143360f, 
    0.26966175f, 0.02048898f, 0.14713947f, 0.16412951f, -0.18460788f, -0.20010616f, 0.33030388f, 0.08150611f, 
    0.40435648f, 0.06580979f, -0.37596777f, 0.37684268f, 0.07884685f, 0.19220686f, -0.11120116f, 0.02571886f, 
    -0.09660015f, 0.06896824f, 0.26745087f, -0.21687850f, 0.08629923f, 0.06770530f, 0.05075847f, -0.24828053f, 
    0.20280872f, 0.35998437f, -0.23188889f, 0.26739809f, 0.19373082f, 0.04574820f, 0.03861225f, 0.04280804f, 
    0.33675578f, -0.31293571f, -0.08687101f, 0.14577170f, -0.32756954f, -0.20807719f, 0.02390836f, 0.15909179f, 
    0.04374378f, 0.32558554f, 0.27419296f, -0.42572966f, 0.53834212f, -0.11068758f, 0.28346637f, 0.15108341f, 
    -0.04505691f, 0.29316610f, 0.53320426f, -0.35096028f, -0.33212772f, 0.14003940f, 0.13735572f, -0.16089141f, 
    0.09035978f, -0.03145304f, -0.64160448f, 0.13194652f, -0.13122226f, -0.00662934f, 0.02222806f, 0.29292607f, 
    0.03454307f, 0.04113133f, 0.25425568f, 0.24360888f, -0.12153389f, -0.27182254f, -0.07272276f, -0.21938466f, 
    -0.79830915f, -0.08755521f, -0.30047137f, -0.44967294f, -0.06176970f, -0.26019669f, -0.22255360f, 0.29906428f, 
    -0.46710253f, -0.04940065f, -0.26265588f, -0.06301241f, 0.11671623f, 0.07962550f, -0.33917016f, 0.02120530f, 
    -0.26255736f, 0.36513382f, -0.10074664f, 0.40037641f, 0.12237498f, 0.01466957f, 0.48422536f, -0.25635290f, 
    -0.13493052f, -0.03322719f, -0.53343970f, 0.06085203f, 0.04389587f, -0.37926531f, 0.03530453f, -0.43412179f, 
    0.14473745f, 0.42872125f, 0.35466743f, -0.07102516f, 0.12402429f, 0.09212119f, 0.22253641f, -0.27368623f, 
    0.18351947f, 0.17693004f, 0.12519181f, 0.05324772f, -0.06793417f, 0.05352659f, -0.02579532f, -0.05482648f, 
    -0.32263190f, 0.11861854f, -0.22936530f, 0.28508121f, 0.00175903f, 0.30109519f, 0.22684938f, 0.03485868f, 
    -0.24143009f, 0.01019041f, 0.06091062f, -0.10953114f, 0.17012025f, 0.01089987f, 0.49269080f, 0.04860075f, 
    -0.49374664f, 0.08315016f, 0.36606514f, -0.16434765f, 0.08596125f, -0.07636059f, 0.14821504f, 0.00703252f, 
    -0.09545974f, 0.03308233f, 0.10491899f, -0.04404556f, -0.00025982f, 0.09009115f, -0.10744177f, 0.05470657f, 
    0.00474789f, -0.30416340f, 0.23346888f, 0.13021299f, -0.04356047f, -0.02161065f, 0.04447425f, 0.13955815f, 
    -0.02839372f, 0.08051793f, 0.18758513f, -0.12862670f, 0.09241518f, 0.16801548f, -0.43357831f, 0.21587266f, 
    0.01829691f, -0.01644120f, -0.27677691f, 0.29263148f, 0.06519473f, 0.34713402f, 0.00279496f, -0.17941028f, 
    -0.01817124f, 0.05735027f, -0.15607777f, -0.01420246f, 0.43694338f, -0.20896704f, 0.03595262f, 0.01714970f, 
    0.08394103f, 0.14662939f, 0.08238482f, -0.15839763f, -0.02795302f, 0.01397988f, 0.18871978f, -0.05396118f, 
    -0.03721428f, 0.02581092f, 0.22671767f, 0.13574974f, 0.06145701f, 0.09009997f, -0.01532697f, -0.01272126f, 
    0.03965550f, -0.01247528f, 0.05822765f, 0.09025633f, -0.11324151f, 0.33018398f, 0.28796685f, 0.03887977f, 
    0.08323298f, 0.39698809f, -0.03528898f, 0.27431026f, -0.20100071f, -0.01948390f, -0.10516655f, 0.12591742f, 
    0.11992335f, -0.09958730f, 0.13600577f, -0.09315643f, -0.00610595f, 0.23359601f, -0.31097770f, -0.03226344f, 
    0.00264453f, -0.03546206f, -0.35723272f, 0.08806325f, 0.28160435f, 0.62998676f, 0.07694092f, -0.04097715f, 
    -0.24851924f, -0.00181248f, -0.32421863f, -0.05355056f, -0.30439588f, 0.09375314f, 0.08422067f, 0.12809758f, 
    0.02896428f, 0.04995289f, 0.14697474f, 0.36439949f, 0.12753400f, -0.04571723f, 0.01205277f, -0.42097947f, 
    0.61630464f, 0.06459390f, 0.17960651f, -0.02101117f, 0.05298626f, 0.00291162f, 0.00093254f, 0.01829707f, 
    0.18387069f, -0.17372362f, 0.04532259f, -0.01716132f, 0.15309726f, 0.33655471f, -0.31479031f, -0.00752422f, 
    0.29998273f, -0.22775844f, -0.26821792f, 0.07566868f, 0.10409038f, 0.15252894f, -0.14242813f, 0.09460051f, 
    0.36081278f, 0.03446244f, -0.04079784f, 0.38504499f, 0.07963449f, -0.01991261f, 0.16441657f, -0.23420577f, 
    -0.15360583f, 0.22223032f, -0.00367972f, -0.03739846f, -0.00484360f, 0.01255066f, 0.03431945f, -0.02771117f, 
    0.08384199f, 0.12214302f, 0.17729038f, 0.33292738f, 0.28153726f, -0.26783857f, 0.17323516f, -0.20060876f, 
    0.00703641f, -0.03907828f, 0.03739567f, 0.02794291f, -0.33148137f, 0.04737317f, -0.17242742f, -0.28086108f, 
    0.25241607f, 0.07056571f, -0.08050846f, 0.09306160f, -0.50460339f, 0.00541512f, 0.31411919f, 0.26131254f, 
    0.02409993f, 0.07545039f, 0.10551769f, 0.16853823f, 0.04422013f, 0.06624784f, -0.03425135f, -0.03638100f, 
    0.18758102f, 0.02848766f, 0.04845452f, 0.02230641f, -0.40661570f, 0.10610499f, 0.17100555f, -0.67139447f, 
    -0.18607381f, 0.08913045f, 0.00996944f, -0.20215534f, 0.11983111f, 0.27206475f, 0.01851774f, -0.02822772f, 
    0.03036062f, -0.32003710f, 0.05599304f, -0.09647043f, -0.06194127f, -0.04958658f, 0.19249342f, 0.01139443f, 
    -0.17528164f, 0.19729662f, 0.23151122f, 0.22572716f, -0.06968749f, -0.04683019f, -0.26997948f, 0.00327412f, 
    0.26354471f, 0.09187698f, 0.53618473f, -0.50723130f, -0.11790588f, -0.10981211f, -0.06233314f, 0.31842244f, 
    0.35864666f, -0.10878319f, 0.16879262f, 0.06058777f, 0.05173432f, -0.09306875f, 0.09396349f, 0.26588559f, 
    -0.00461528f, -0.08527402f, -0.12714417f, 0.23737691f, -0.01246383f, -0.32733622f, 0.18674096f, 0.33045575f, 
    -0.23310255f, 0.01120637f, -0.32960239f, 0.13861805f, -0.03935038f, -0.23846728f, 0.09444000f, -0.04895643f, 
    -0.32344592f, 0.11036444f, 0.12994951f, 0.30550990f, -0.13178979f, -0.31971148f, 0.03376896f, 0.06650615f, 
    0.04827663f, 0.01334149f, 0.15218581f, -0.01534148f, 0.20137461f, 0.08544654f, -0.01454568f, 0.02892016f, 
    -0.09044135f, 0.17036009f, 0.31864104f, -0.02160051f, 0.16159470f, 0.09631550f, -0.09552306f, -0.28374216f, 
    0.06233817f, 0.11210470f, -0.01989486f, 0.00049309f, -0.00123870f, 0.10368122f, 0.03652801f, -0.15825722f, 
    0.13612595f, -0.05480678f, -0.11740161f, -0.18587048f, -0.08218443f, -0.32808870f, -0.09308255f, 0.13877079f, 
    0.06883766f, 0.06186763f, 0.00172673f, -0.21234527f, -0.10653294f, 0.08974364f, 0.11471392f, -0.22756955f, 
    0.06383644f, 0.06693006f, 0.05136907f, 0.08686291f, 0.21164839f, -0.04384897f, 0.07853284f, -0.06730922f, 
    0.01198946f, -0.30116355f, -0.02884431f, 0.06411622f, 0.06131450f, 0.02479406f, 0.07321899f, 0.23305924f, 
    -0.06515830f, -0.00907349f, 0.40692306f, 0.18664980f, 0.04943207f, -0.07660351f, -0.05807490f, 0.05985980f, 
    -0.40235183f, -0.11599389f, 0.02679837f, -0.17890827f, -0.07969736f, -0.20853291f, 0.14308707f, 0.05953463f, 
    0.00268666f, 0.01110038f, -0.15772848f, 0.03536433f, -0.16574478f, -0.19110820f, -0.20644145f, 0.02602206f, 
    0.08220978f, 0.25904962f, 0.04228853f, -0.11247571f, 0.06032887f, 0.35485053f, 0.35393265f, -0.26428357f, 
    -0.06744925f, -0.03120966f, 0.10042302f, -0.19213061f, -0.20387311f, 0.20248425f, 0.24948464f, -0.19946089f, 
    -0.23881446f, 0.36163977f, -0.08745290f, 0.02895733f, 0.15521036f, 0.12325059f, 0.11274745f, -0.05810343f, 
    0.14125155f, 0.10163499f, 0.16523004f, 0.44143257f, -0.11810290f, -0.14483051f, 0.16674235f, -0.09220161f, 
    -0.15193084f, 0.14659329f, -0.18090919f, 0.15473449f, 0.03361798f, 0.26129267f, 0.09979756f, -0.01735072f, 
    -0.09316996f, -0.05899859f, -0.01764167f, -0.16743423f, 0.07085393f, 0.14825542f, 0.18389243f, 0.06109383f, 
    0.07942305f, -0.08364826f, 0.01717919f, -0.06771603f, 0.00983945f, 0.05119778f, 0.03647019f, -0.02808306f, 
    -0.06293241f, 0.00623590f, -0.06265345f, -0.04270564f, 0.04880914f, -0.04593889f, -0.05794895f, -0.04512174f, 
    -0.05595057f, -0.09968966f, 0.03635019f, 0.07588837f, -0.07893056f, 0.03489143f, 0.02532074f, 0.00231082f, 
    -0.02624660f, -0.01707278f, -0.07584178f, 0.01413201f, 0.06176255f, -0.01308512f, 0.04813015f, 0.01435196f, 
    -0.02815705f, 0.03583810f, 0.03907962f, 0.04651525f, -0.02694740f, 0.07754320f, -0.05739667f, -0.07879760f, 
    0.03066372f, 0.03973114f, -0.03492255f, -0.08349495f, -0.03073317f, -0.03116296f, 0.05834030f, -0.01267620f, 
    0.06073340f, 0.04237842f, 0.07798600f, 0.03991193f, 0.06056427f, 0.05247563f, 0.03713453f, -0.02243004f, 
    0.01655841f, -0.04869734f, 0.07521479f, -0.08472659f, -0.09368302f, -0.02272814f, 0.00031611f, -0.08811615f, 
    -0.05714240f, 0.03328517f, -0.04077056f, 0.02721428f, 0.04750585f, -0.01152814f, 0.00573498f, -0.06754364f, 
    0.05061471f, 0.03635401f, -0.06632444f, 0.05104768f, -0.07936378f, 0.06093062f, -0.08517797f, -0.02903561f, 
    -0.04900020f, -0.08666950f, 0.04554708f, -0.06735025f, -0.02876171f, 0.05435157f, 0.06544267f, -0.04805480f, 
    -0.01766193f, -0.09346502f, 0.04988029f, 0.01014187f, -0.09128526f, 0.04924089f, 0.04837745f, 0.05872320f, 
    0.01940589f, 0.05587665f, -0.02689540f, 0.03086386f, 0.00394891f, -0.02138379f, -0.06142371f, -0.02346138f, 
    -0.05723311f, -0.05626454f, -0.01099627f, -0.04568010f, -0.03789357f, -0.00370759f, -0.04951378f, -0.06836782f, 
    -0.06887775f, -0.03550542f, -0.03347103f, -0.04214680f, 0.01050864f, -0.04822983f, -0.00849263f, 0.08790077f, 
    -0.06256049f, -0.04766473f, 0.04602936f, 0.04935119f, -0.07373374f, 0.00478001f, -0.00925424f, -0.04147095f, 
    -0.07350549f, 0.08886474f, 0.12186465f, -0.01324014f, -0.20365039f, -0.03042288f, 0.31190118f, 0.19706061f, 
    -0.24663348f, 0.10588948f, -0.33591878f, -0.35871863f, -0.15321814f, -0.04075422f, -0.09998932f, 0.17630297f, 
    0.21717927f, -0.16636099f, 0.13198310f, 0.21355659f, 0.05360186f, -0.04225623f, 0.04900520f, 0.40061107f, 
    -0.20040596f, 0.32183790f, -0.12152524f, 0.09660055f, 0.03755700f, -0.07154047f, -0.37293515f, 0.02552442f, 
    -0.34084165f, -0.04303764f, 0.03924041f, 0.24123944f, 1.18059373f, -0.01578160f, 0.18315797f, 0.57632118f, 
    -0.52312356f, -0.21938531f, 0.38559720f, -0.05255195f, 0.14240034f, -0.19608599f, -0.01362274f, 0.11063725f, 
    0.08797137f, 0.26031673f, -0.32595617f, 0.06798458f, 0.14350992f, 0.03583654f, -0.02679267f, -0.08803457f, 
    0.02098396f, -0.13093577f, -0.37228277f, -0.12422886f, 0.28173456f, -0.30252564f, -0.23247308f, 0.31261414f, 
    -0.23539495f, -0.11379875f, -0.57238406f, 0.34463722f, 0.03448524f, 0.00857679f, -0.21228850f, -0.37434804f, 
    -0.05768726f, -0.04170743f, 0.07949247f, 0.03721942f, 0.12760311f, -0.15849575f, 0.27174136f, 0.06921489f, 
    0.06600088f, 0.17723656f, -0.09435070f, -0.01878846f, 0.29324576f, -0.39663526f, 0.60778737f, 0.14762825f, 
    -0.04295925f, 0.17919205f, -0.10535759f, 0.68712449f, 0.42037845f, 0.31575483f, 0.23000357f, 0.19716464f, 
    0.26103529f, 0.17553529f, -0.51355428f, -0.01230786f, 0.01442886f, 0.35271630f, -0.10402550f, 0.22231555f, 
    -0.39279890f, 0.60544527f, -0.25741059f, 0.39712226f, 0.06058247f, 0.45410499f, -0.39408043f, -0.01780576f, 
    0.17752799f, -0.26155943f, 0.72623169f, -0.00284541f, -0.01576545f, -0.10321462f, 0.14021318f, -0.00844849f, 
    0.33093670f, -0.57783920f, 0.09198496f, 0.06679051f, -0.22653200f, 0.34950861f, 0.34471446f, -0.06290699f, 
    0.00512262f, -0.02769243f, -0.05542078f, -0.09533408f, -0.10166962f, -0.08591008f, 0.07083649f, -0.01865773f, 
    0.01050022f, -0.10087349f, -0.03976139f, -0.03671162f, 0.05655826f, 0.06278501f, -0.00250711f, 0.04412991f, 
    -0.07180143f, 0.02610218f, 0.04412954f, -0.10126702f, 0.00512090f, 0.03836650f, -0.01584593f, -0.08006059f, 
    -0.03275298f, -0.09705947f, 0.03718031f, -0.07115288f, 0.04160111f, -0.01632369f, -0.09815849f, -0.10764937f, 
    0.03198916f, -0.00259821f, 0.00453962f, 0.04636738f, -0.02925268f, -0.09778886f, -0.01529926f, -0.03295822f, 
    0.01133369f, -0.12785757f, 0.02324040f, 0.04084726f, 0.06703149f, -0.05681818f, -0.08752166f, -0.10930680f, 
    -0.04244224f, 0.05962026f, 0.04821277f, 0.01963318f, -0.01470205f, -0.00840472f, -0.05461664f, -0.10225115f, 
    -0.01413150f, 0.07523378f, 0.05334952f, -0.05178015f, -0.07342115f, 0.04567970f, -0.05069919f, -0.06859967f, 
    -0.00933059f, 0.06761924f, -0.04907393f, -0.12976386f, -0.09642131f, 0.03147053f, -0.00510927f, 0.03175259f, 
    0.03359829f, 0.03964223f, -0.01050554f, -0.05924878f, 0.01853507f, 0.05680507f, 0.04377200f, -0.06334729f, 
    0.03150411f, 0.00152695f, -0.00087252f, -0.05502911f, -0.01330460f, -0.02971517f, -0.02626186f, 0.03763647f, 
    0.04675476f, 0.01382677f, 0.01573891f, -0.00580593f, 0.03072640f, -0.03134258f, -0.01039485f, -0.00048031f, 
    0.06496587f, 0.06475566f, -0.03068597f, 0.05303660f, -0.09378580f, -0.08080148f, -0.11870167f, -0.06780839f, 
    -0.11104384f, -0.08799987f, 0.03386578f, 0.07203756f, -0.02670347f, -0.01345710f, -0.08500217f, 0.04411492f, 
    0.00459299f, 0.00411150f, 0.02368170f, 0.05053179f, 0.06946794f, -0.01514574f, -0.00620584f, 0.05603034f, 
    0.02990548f, -0.01123825f, 0.02835568f, 0.01791636f, -0.07473831f, 0.02338078f, -0.10324930f, 0.02725796f, 
    0.15195338f, -0.16487150f, 0.28890127f, 0.03489926f, 0.00952547f, 0.07918045f, 0.12442277f, 0.02674377f, 
    -0.21592136f, 0.40588820f, -0.16867460f, -0.16568056f, -0.03432230f, 0.25485387f, 0.04119808f, -0.03602683f, 
    -0.02923688f, 0.22083355f, 0.14668718f, 0.04900002f, -0.04232091f, -0.02322163f, -0.07615674f, -0.03750611f, 
    -0.12898615f, 0.39143938f, -0.02767691f, -0.00327784f, 0.20777555f, 0.12229265f, 0.00446787f, 0.07075150f, 
    -0.09715438f, 0.12016895f, -0.16836904f, 0.04942119f, 0.14794379f, -0.19549094f, 0.11776499f, 0.18999676f, 
    -0.13335718f, -0.01287155f, -0.14076819f, -0.16292696f, -0.15542869f, 0.11540683f, 0.21636155f, 0.08674770f, 
    -0.05416044f, 0.17227420f, -0.03082808f, 0.06548474f, 0.02282148f, -0.03461460f, -0.37560540f, 0.01246646f, 
    0.00529852f, 0.01121001f, -0.03704539f, -0.07318995f, -0.05213461f, 0.17411780f, -0.00761514f, -0.05843648f, 
    0.53203720f, 0.06765026f, -0.16111630f, 0.13981998f, 0.32063961f, 0.36340857f, 0.19394606f, -0.04967179f, 
    -0.07608353f, -0.12517415f, 0.10252953f, -0.04226015f, 0.02350421f, -0.01903916f, 0.11394793f, 0.11217479f, 
    0.37469396f, -0.14106581f, 0.11594619f, 0.61209798f, 0.11532611f, 0.32159302f, 0.27355674f, 0.02898345f, 
    -0.03706886f, -0.02365132f, 0.30847242f, -0.06106427f, -0.21269874f, -0.11068814f, 0.01084703f, 0.08382310f, 
    0.06932297f, 0.07341756f, -0.11298078f, -0.06978522f, -0.13678855f, 0.21404251f, -0.10165523f, 0.16919345f, 
    -0.06416055f, 0.50675374f, 0.02449246f, 0.19748424f, 0.40865576f, 0.06601383f, -0.01145003f, 0.28708768f, 
    -0.15540777f, -0.07895254f, -0.41634306f, -0.24252965f, -0.00729235f, -0.13313618f, -0.28882360f, -0.03788633f, 
    -0.05500551f, -0.20146912f, 0.09124614f, 0.09652778f, -0.15176560f, 0.04358557f, 0.27056783f, 0.11036351f, 
    -0.01611640f, -0.16642283f, 0.29605541f, -0.02912101f, 0.09511449f, 0.11243992f, 0.10632554f, -0.20419978f, 
    -0.39116636f, 0.14644335f, 0.09638253f, -0.45847735f, -0.01073348f, 0.20663676f, -0.22955741f, -0.25974101f, 
    0.08223511f, 0.04865257f, 0.05441502f, -0.14510624f, -0.04546271f, 0.00559988f, -0.05234499f, -0.39880580f, 
    -0.15649512f, 0.13047567f, -0.14376083f, -0.40581483f, -0.06767509f, -0.02031579f, 0.18879844f, 0.00003443f, 
    0.10941405f, -0.12318594f, 0.18920299f, -0.19045112f, -0.14577979f, 0.11640103f, 0.02640013f, -0.00986586f, 
    -0.03076894f, 0.10088216f, -0.05296534f, -0.28001398f, -0.10483877f, 0.11829643f, -0.09590919f, -0.16290185f, 
    0.04076171f, -0.54654056f, -0.34316811f, 0.01348525f, -0.09520356f, -0.00456891f, -0.07214822f, 0.03127976f, 
    -0.06818243f, 0.07947631f, -0.31971863f, -0.01351413f, -0.16127327f, 0.20802525f, -0.02356160f, 0.08410750f, 
    0.40223542f, -0.39063770f, 0.23404656f, -0.15070365f, 0.15283276f, 0.05638971f, 0.32225886f, -0.02739840f, 
    -0.23526959f, -0.03182455f, -0.08610324f, -0.08106560f, -0.25113514f, 0.05583961f, 0.03940601f, 0.04819775f, 
    0.40983513f, 0.10110202f, -0.01094546f, -0.01236758f, 0.00589597f, 0.42415333f, -0.46331361f, 0.37112045f, 
    0.08604334f, -0.06812609f, -0.02514211f, -0.02117878f, -0.01703682f, -0.05579466f, 0.11006276f, -0.38738391f, 
    -0.20146964f, 0.11414082f, 0.04908703f, -0.08515253f, 0.06652717f, -0.16583812f, -0.05217069f, -0.21406627f, 
    0.01201140f, 0.17344873f, 0.05498159f, -0.36526310f, 0.13395526f, 0.01515942f, 0.19654492f, -0.56466502f, 
    -0.45733935f, 0.07480085f, -0.47396833f, 0.12557834f, -0.10699222f, 0.09022553f, -0.29924682f, -0.06299104f, 
    -0.26096722f, 0.18034142f, 0.04445453f, 0.08757646f, 0.06372263f, -0.03881629f, 0.02338260f, 0.03520472f, 
    -0.06341711f, 0.05125590f, -0.09240158f, 0.01923588f, 0.05023237f, -0.06471686f, -0.03460145f, -0.00926586f, 
    -0.09170108f, -0.11378326f, -0.01071876f, -0.10000387f, 0.02150160f, -0.02700831f, -0.05161781f, -0.05533678f, 
    -0.01104094f, -0.02574300f, -0.00462057f, -0.11844926f, -0.06463706f, 0.08794171f, 0.04584352f, -0.07664905f, 
    0.01439647f, -0.03931486f, -0.06462057f, 0.04038650f, -0.07234012f, 0.01442187f, 0.04026569f, 0.07388700f, 
    -0.06378261f, 0.01157430f, 0.01054301f, -0.10294773f, 0.02544524f, -0.06375600f, 0.04397407f, -0.02027835f, 
    -0.00650105f, -0.01878530f, -0.06076763f, -0.02346125f, 0.01415325f, -0.05143410f, -0.02529497f, 0.00837796f, 
    0.00844445f, 0.02467689f, 0.01895385f, -0.07166518f, 0.02668450f, 0.04308809f, 0.00326941f, -0.08560301f, 
    0.02861360f, 0.02367585f, 0.00742916f, -0.05827238f, -0.10256617f, -0.11209458f, -0.10074066f, -0.08133986f, 
    -0.02747912f, -0.03103812f, 0.06643719f, -0.10411898f, -0.04157685f, 0.06330477f, 0.00084664f, -0.04573087f, 
    0.02816977f, -0.06607384f, 0.01655699f, -0.07069548f, -0.05007338f, 0.05064120f, -0.06360925f, 0.00120242f, 
    0.03379281f, 0.08756480f, -0.07100460f, 0.03910377f, -0.09991665f, -0.01114608f, 0.03235074f, 0.02325807f, 
    -0.02981958f, -0.00978102f, 0.02281959f, -0.00042448f, 0.04993213f, -0.10005032f, 0.04675267f, 0.01968545f, 
    -0.01415750f, -0.04719967f, 0.03560550f, -0.08753450f, -0.00116753f, -0.03644715f, 0.03766643f, 0.03864276f, 
    -0.09418369f, -0.08750576f, -0.09034745f, -0.04984456f, -0.04298465f, -0.00417547f, -0.07204303f, 0.02053721f, 
    0.01707739f, -0.08901561f, -0.06640110f, -0.07360331f, -0.07956137f, 0.02192558f, 0.01813815f, -0.06354967f, 
    -0.01848706f, 0.00739203f, -0.06656697f, -0.10680671f, -0.06184675f, -0.07733850f, -0.06927472f, 0.04293749f, 
    -0.03170385f, -0.05994240f, -0.08875242f, 0.04538051f, 0.05462494f, -0.00058829f, 0.06749396f, 0.03938575f, 
    -0.03177573f, -0.03588004f, 0.02917886f, -0.03070449f, -0.09253257f, -0.00033137f, 0.00585170f, -0.07095590f, 
    -0.03047253f, -0.05258219f, -0.10196517f, -0.01743898f, 0.00025271f, -0.04764948f, -0.07151297f, -0.00186464f, 
    -0.03185475f, -0.02423766f, 0.01417668f, -0.06830222f, 0.01347281f, -0.07777096f, -0.04545406f, 0.04405620f, 
    0.01264284f, -0.08851486f, -0.02749093f, -0.09436371f, 0.04830663f, -0.09049950f, -0.03370119f, -0.02744504f, 
    0.01726655f, 0.00270784f, 0.04962808f, 0.00038773f, -0.06875451f, -0.06096511f, -0.01103189f, 0.05862857f, 
    -0.06576339f, -0.05003701f, -0.05719808f, 0.05033588f, -0.08733606f, 0.03093411f, -0.03213730f, -0.08103644f, 
    -0.02084043f, 0.01033414f, -0.00821505f, 0.03579729f, 0.07130957f, -0.05768720f, -0.08963586f, 0.06715490f, 
    0.08002069f, 0.03820767f, 0.05395548f, -0.05336579f, -0.08815742f, 0.06819951f, -0.00777553f, -0.05799482f, 
    0.04270420f, -0.03686015f, -0.06194039f, -0.10522754f, 0.02955372f, -0.07371674f, 0.05943390f, -0.10069806f, 
    -0.08964325f, -0.02644871f, 0.01529106f, 0.02854307f, -0.06072135f, 0.04402999f, 0.07596662f, 0.02090611f, 
    0.00197916f, -0.09524480f, -0.08528686f, 0.03195587f, -0.08144797f, -0.05384314f, -0.09301231f, 0.04694019f, 
    0.01862364f, 0.02643569f, -0.03363563f, 0.00638392f, -0.01094721f, 0.00057602f, 0.04388569f, -0.00663462f, 
    -0.09121890f, 0.01128509f, -0.02996144f, -0.05982701f, -0.00824273f, -0.01902380f, 0.01836669f, 0.07149865f, 
    0.03667704f, 0.00308426f, 0.04033390f, 0.00574736f, -0.03120138f, -0.04493628f, 0.00982023f, -0.04047228f, 
    0.01552967f, -0.02856807f, -0.07160401f, 0.06042795f, 0.05926617f, 0.03107148f, 0.05217730f, 0.08550730f, 
    -0.06169771f, -0.06775112f, 0.04078422f, -0.05479719f, -0.09373799f, -0.05867123f, 0.03545804f, -0.05428203f, 
    -0.04082002f, -0.04006810f, -0.07843708f, -0.08062990f, -0.08094267f, -0.09297139f, -0.01759928f, -0.09519148f, 
    0.05594869f, 0.03482822f, 0.06553582f, -0.05235767f, -0.00603735f, 0.01941686f, 0.02623687f, -0.04583998f, 
    -0.00511518f, -0.00706587f, -0.11337251f, 0.03426205f, 0.01791543f, 0.05649682f, 0.05740112f, -0.07553234f, 
    -0.04759117f, -0.08522414f, 0.03267088f, -0.02591410f, 0.06850320f, 0.06224816f, 0.06503426f, -0.02969040f, 
    0.02963202f, -0.09215698f, 0.03967040f, -0.07114002f, 0.01688884f, 0.03137369f, -0.09600736f, 0.04190699f, 
    -0.01348968f, -0.01196919f, 0.02015266f, -0.10365243f, -0.07293244f, 0.03414071f, -0.03078158f, 0.00187808f, 
    -0.00085361f, -0.00453305f, -0.05120460f, 0.02284227f, 0.03697560f, -0.07049801f, -0.02196598f, 0.03473129f, 
    0.02870065f, -0.02501732f, 0.05274187f, 0.02895030f, 0.02680810f, -0.06594113f, -0.02667974f, 0.06448103f, 
    0.05901683f, 0.07017786f, -0.07945841f, 0.03965675f, -0.10417435f, -0.10859920f, -0.03475450f, -0.06686612f, 
    -0.08647528f, 0.06849718f, -0.01617577f, 0.07597980f, -0.04981583f, -0.07525295f, 0.08202025f, -0.02944305f, 
    -0.01490608f, 0.03132629f, -0.02654274f, -0.01758635f, 0.01273378f, -0.00800297f, -0.04663039f, 0.01419214f, 
    -0.06988356f, -0.06054442f, 0.05097105f, 0.05199529f, 0.00231289f, -0.02343159f, -0.02339765f, 0.01710141f, 
    -0.04520851f, -0.08098388f, 0.06389602f, -0.00542077f, 0.04340242f, 0.00530247f, -0.10685483f, 0.06631552f, 
    -0.08759440f, -0.01092641f, 0.01662556f, -0.02279851f, -0.04273342f, -0.08336846f, 0.03245508f, 0.01170497f, 
    -0.05930488f, -0.03815399f, 0.01215131f, -0.06764305f, -0.00881383f, -0.02381299f, 0.08209309f, -0.04199526f, 
    0.06879825f, 0.00832058f, 0.09163862f, -0.03043099f, -0.04885155f, 0.19579004f, 0.02103341f, 0.02771399f, 
    -0.32599446f, 0.06031905f, 0.10521458f, -0.13721840f, 0.04278548f, 0.04341963f, -0.02901315f, -0.06087311f, 
    0.12291691f, 0.22472754f, 0.07940345f, -0.11976667f, 0.05780641f, -0.05274430f, 0.02527701f, 0.14845155f, 
    0.02777373f, 0.04199426f, -0.04230912f, -0.28613943f, -0.17318138f, -0.06136309f, 0.19901827f, -0.00268260f, 
    -0.04799901f, 0.13271914f, 0.24626756f, -0.16315822f, -0.36422196f, 0.13814357f, 0.13582848f, 0.40978304f, 
    0.02993385f, -0.02647491f, -0.04593056f, -0.07213431f, 0.06663541f, -0.25390914f, -0.08345436f, 0.03768866f, 
    -0.07192542f, -0.02641168f, -0.47853521f, 0.03952250f, 0.10699119f, -0.02654271f, -0.04235712f, 0.06201969f, 
    -0.09123751f, 0.14500283f, 0.03717725f, -0.02610014f, -0.02157108f, 0.10121562f, -0.00337531f, 0.13930507f, 
    -0.44947049f, -0.12487059f, 0.05254147f, -0.09235281f, 0.41296303f, 0.01716517f, 0.19597921f, 0.13994923f, 
    0.02663231f, -0.05636792f, 0.01426437f, 0.02601621f, 0.02427200f, 0.21718207f, 0.04275317f, 0.07419338f, 
    0.24600554f, 0.26358861f, -0.10817963f, -0.21290545f, 0.24088609f, 0.12734507f, 0.85973012f, -0.24222475f, 
    0.05035917f, 0.13442980f, -0.40523639f, 0.16834955f, 0.05286897f, 0.06349019f, 0.25476077f, -0.14895381f, 
    0.04559710f, 0.22995396f, 0.16459043f, -0.05154409f, 0.27374035f, 0.08836786f, -0.02090025f, -0.14250608f, 
    0.07588240f, 0.43318146f, 0.00709482f, 0.20767288f, -0.00697864f, 0.12624958f, 0.24349844f, -0.27486229f, 
    -0.07606044f, 0.10441115f, 0.16981958f, 0.14449213f, 0.11049126f, 0.08130818f, -0.06775355f, 0.03882143f, 
    -0.14510319f, 0.34010780f, -0.10682987f, 0.19508240f, 0.15063596f, 0.09568967f, 0.13490038f, -0.00831505f, 
    -0.00076105f, -0.06669638f, 0.15049611f, 0.07267188f, -0.06395845f, -0.03895180f, -0.03594908f, -0.15997013f, 
    -0.22676295f, 0.24753521f, 0.07035361f, -0.03999089f, -0.00180165f, 0.22902822f, 0.12540437f, 0.19392534f, 
    -0.03106605f, 0.03409369f, -0.06907157f, 0.16801813f, 0.06148142f, -0.05633380f, -0.05554669f, 0.31322801f, 
    0.06019958f, 0.08832428f, 0.17133091f, 0.01394906f, 0.12244661f, 0.35605347f, -0.29144460f, 0.31804481f, 
    0.09051811f, 0.13647036f, -0.38802162f, 0.11571709f, -0.24894720f, -0.08991721f, -0.01971002f, 0.45124140f, 
    -0.03451483f, 0.18418331f, 0.12707408f, -0.18927413f, -0.16526094f, 0.22507136f, 0.16926590f, 0.00019335f, 
    0.07697002f, 0.26263782f, -0.07501823f, -0.24775980f, -0.15754960f, -0.07183838f, 0.03261579f, 0.11029527f, 
    0.14594547f, -0.02823068f, 0.41198832f, 0.05771922f, -0.24207778f, 0.06552871f, -0.36415976f, 0.09401581f, 
    0.12624796f, 0.05864540f, -0.40559971f, 0.23544729f, -0.08540941f, -0.51537776f, 0.08044227f, 0.11625160f, 
    -0.11110421f, 0.26024500f, -0.17442924f, -0.08751307f, -0.15211548f, 0.14940743f, -0.00970613f, 0.21864943f, 
    -0.02962162f, 0.12423237f, 0.09339295f, 0.31120548f, 0.04616503f, 0.07893445f, -0.34265119f, -0.00847679f, 
    0.04103975f, -0.35295051f, -0.49230489f, 0.13866317f, 0.29843578f, -0.08521477f, -0.28014851f, -0.23915915f, 
    -0.12949508f, 0.08510658f, -0.11737627f, -0.01326995f, -0.56367296f, 0.19206303f, 0.12757802f, -0.15946497f, 
    -0.02057822f, -0.14417182f, 0.28674740f, 0.16243626f, 0.24280049f, -0.04233316f, -0.42898244f, -0.37695196f, 
    0.41726971f, 0.00929011f, 0.31363854f, -0.24862304f, -0.09277511f, 0.06654623f, -0.13508992f, 0.00428952f, 
    0.35442024f, -0.43531406f, 0.25869894f, -0.08478462f, 0.18192081f, -0.32770491f, 0.11198574f, 0.04234644f, 
    -0.00732317f, 0.04969873f, -0.07109819f, -0.12926769f, -0.03819733f, -0.05758027f, 0.00703998f, -0.08955815f, 
    0.02411690f, -0.04300671f, -0.05016842f, 0.01504355f, -0.02611872f, -0.08335827f, -0.02704773f, -0.04988671f, 
    -0.04719841f, -0.07964169f, 0.01355437f, -0.07907514f, -0.00220972f, -0.02007002f, -0.05317611f, -0.08007638f, 
    0.00204632f, -0.13649218f, -0.04310006f, 0.04786989f, 0.00418388f, -0.05293568f, -0.02863404f, -0.10678373f, 
    0.08974569f, -0.05949273f, -0.00117477f, -0.09468615f, 0.00163438f, -0.04390342f, -0.12376879f, 0.01712881f, 
    -0.04285932f, 0.04057277f, 0.00736827f, -0.00652889f, 0.03101256f, 0.01196415f, -0.00967574f, 0.03445693f, 
    -0.03003941f, -0.05189744f, 0.09777965f, -0.08707951f, 0.04169574f, 0.05014595f, 0.02480660f, -0.07745702f, 
    0.08859394f, 0.02193849f, -0.03057443f, 0.05367243f, -0.08621429f, -0.09956840f, -0.07041559f, 0.07576017f, 
    0.04053552f, 0.11249906f, -0.05000966f, -0.08825333f, -0.01537303f, -0.00103055f, -0.09721144f, -0.06434105f, 
    0.04326984f, 0.02702576f, -0.01237793f, -0.03489419f, -0.06207317f, -0.04660166f, -0.03315215f, -0.13058925f, 
    0.03641612f, 0.06248857f, 0.09213172f, 0.04987312f, -0.05447117f, -0.08235621f, -0.04210965f, -0.03893043f, 
    0.02332354f, -0.00334420f, -0.03511472f, -0.13667540f, -0.02662201f, -0.03379063f, -0.11550732f, 0.00609947f, 
    0.05840335f, -0.06818915f, 0.01701057f, 0.04386519f, -0.07918494f, -0.06566598f, -0.03482322f, -0.08645224f, 
    -0.03643858f, -0.00994621f, -0.07554021f, 0.02359921f, -0.06773565f, 0.04018684f, -0.09019067f, -0.00979752f, 
    0.01025765f, 0.01051488f, -0.07766329f, -0.02360422f, 0.07061614f, -0.07096889f, -0.00460363f, 0.03342090f, 
    -0.00105798f, -0.05044327f, 0.03895186f, 0.00792004f, -0.05859894f, -0.06039399f, 0.06046718f, -0.04468675f, 
    -0.12546915f, -0.20479400f, 0.10063037f, -0.06966306f, 0.26524141f, -0.04093742f, 0.04961114f, -0.21202369f, 
    0.08270798f, 0.12098134f, -0.00832479f, 0.08525076f, -0.01327241f, 0.24542762f, 0.07149154f, 0.12692921f, 
    0.12327947f, -0.11858305f, 0.08811537f, 0.19992585f, 0.02207742f, -0.06599209f, -0.08359353f, -0.08200149f, 
    -0.02914658f, -0.18311945f, 0.19206153f, 0.04330008f, 0.27773407f, 0.24023949f, -0.13633326f, 0.24458447f, 
    0.26778278f, -0.07301098f, -0.25943294f, 0.29084116f, -0.20276488f, 0.06540124f, -0.02601755f, -0.65312147f, 
    -0.06672633f, 0.33415708f, 0.31948799f, -0.18180397f, -0.31233561f, -0.16866092f, 0.13348082f, 0.07469428f, 
    0.07691818f, 0.05875331f, -0.46240529f, -0.15957108f, -0.00434043f, -0.00029957f, -0.03671957f, 0.19687569f, 
    0.21885790f, 0.04928522f, 0.19653329f, 0.15172096f, -0.25695580f, 0.02248350f, -0.33310258f, -0.12495548f, 
    -0.01387524f, 0.11508577f, -0.40961847f, 0.07787349f, -0.09044217f, -0.45250678f, 0.17656358f, 0.14316845f, 
    -0.28821295f, 0.16304910f, -0.09316871f, 0.05727523f, -0.28148311f, -0.06353876f, 0.00561195f, 0.13077877f, 
    -0.08673812f, -0.11607951f, 0.23982759f, 0.31702849f, -0.00498457f, 0.09771344f, -0.27609172f, -0.13037516f, 
    -0.10200890f, -0.06379161f, -0.56230497f, -0.13969097f, -0.07194380f, -0.50073063f, -0.24815337f, -0.12957814f, 
    -0.18586293f, -0.03244701f, -0.10908138f, 0.04618452f, -0.26291585f, 0.12209230f, 0.18274577f, -0.28593007f, 
    0.01330904f, -0.15405715f, 0.13713694f, -0.32133931f, 0.26184666f, -0.03448528f, -0.15862156f, -0.09126467f, 
    0.38201606f, -0.13382509f, 0.04775222f, -0.03545618f, -0.09881917f, -0.09464014f, -0.04572643f, 0.00107068f, 
    0.16162832f, -0.23678072f, 0.13031907f, -0.03030382f, 0.08091134f, -0.40878898f, -0.07317298f, -0.00672763f, 
    -0.08145808f, -0.07564121f, -0.06902041f, -0.01845589f, 0.00879456f, -0.05107849f, -0.09594653f, -0.08113217f, 
    -0.08766847f, 0.00081233f, 0.03016591f, 0.08451118f, -0.10588616f, -0.04062932f, 0.04366256f, -0.01092007f, 
    -0.09633389f, -0.08761876f, -0.12338965f, -0.01382074f, 0.03487894f, 0.05830286f, 0.04797649f, -0.01682818f, 
    -0.10275083f, -0.09113092f, 0.03403467f, -0.14468087f, -0.01971170f, -0.06288362f, 0.03017646f, -0.08429606f, 
    -0.07742687f, -0.01975366f, -0.06753086f, -0.05790333f, 0.08599906f, -0.11064176f, -0.07158601f, -0.01673196f, 
    -0.07470702f, -0.02263916f, -0.09221135f, -0.03129104f, -0.04515710f, -0.11261822f, 0.01066391f, 0.02376217f, 
    -0.06927644f, -0.09352142f, 0.04976141f, -0.07141332f, -0.06197788f, -0.01515198f, -0.01049791f, -0.10952786f, 
    0.00346338f, -0.01631237f, 0.08162463f, -0.09345802f, 0.02659746f, 0.01147209f, 0.00969424f, 0.13971983f, 
    -0.00612619f, -0.03749538f, 0.07033952f, -0.05472617f, 0.05534019f, -0.11620999f, -0.11210697f, -0.07731067f, 
    0.08702786f, -0.07371697f, -0.00052097f, -0.02081054f, 0.04672932f, -0.01726814f, -0.04528574f, 0.05637257f, 
    -0.02847317f, -0.07694715f, -0.06147080f, -0.00194277f, -0.12138326f, -0.00521438f, -0.08415323f, -0.00169193f, 
    -0.04834659f, -0.09565324f, 0.00819538f, -0.07432982f, 0.05127181f, 0.02733237f, -0.04853018f, 0.05205126f, 
    -0.03184661f, -0.09388376f, -0.09730849f, 0.04243068f, -0.05503432f, -0.11878844f, -0.12565269f, -0.06562120f, 
    -0.05412606f, 0.06884060f, -0.03399874f, 0.09289546f, -0.05471484f, 0.01653147f, -0.01161843f, -0.03788831f, 
    -0.02020958f, -0.01805823f, -0.00860339f, -0.05294002f, 0.02988785f, -0.06351472f, -0.03382803f, -0.00395310f, 
    0.02788196f, -0.03730293f, -0.04902140f, -0.03243320f, -0.10171916f, 0.01497587f, -0.04202271f, -0.04140297f, 
    0.14941631f, 0.17731337f, 0.21201311f, 0.01981016f, -0.04872772f, 0.05649136f, 0.19471429f, 0.06530956f, 
    -0.19109188f, 0.26024336f, -0.07537604f, -0.34417856f, -0.10708962f, 0.20205759f, -0.28359222f, 0.27855623f, 
    0.32972357f, -0.05719763f, 0.13951613f, 0.19509907f, 0.05779926f, -0.15931103f, 0.02399788f, 0.15706992f, 
    -0.16521409f, 0.06407627f, -0.27130032f, -0.00027188f, 0.25434381f, -0.63305908f, -0.05783817f, -0.08172837f, 
    -0.06179379f, -0.03068914f, 0.18568221f, 0.01144726f, 0.65137595f, -0.16445944f, 0.29487088f, 0.26809695f, 
    -0.50314933f, -0.09364273f, 0.34354007f, 0.20787384f, 0.26562065f, -0.16077322f, 0.14246918f, -0.19891474f, 
    0.01560320f, -0.08166929f, 0.05896583f, 0.10086317f, 0.08004972f, 0.02952375f, -0.45752770f, 0.10384551f, 
    0.12096395f, 0.12206767f, 0.10468245f, 0.08543110f, 0.26563480f, -0.11361212f, -0.11363532f, 0.42520973f, 
    -0.20229426f, -0.01859874f, -0.87429881f, 0.24440563f, -0.05564753f, 0.10614524f, -0.19936240f, -0.36642599f, 
    -0.02392094f, -0.32523015f, -0.08750243f, -0.25051954f, 0.18738019f, -0.43262041f, 0.08352476f, -0.34857494f, 
    0.28992867f, -0.13342185f, -0.14941995f, -0.18761083f, 0.27793449f, -0.57316393f, 0.83779025f, 0.13704419f, 
    -0.21017100f, 0.31942049f, -0.26635528f, 0.11392994f, -0.13634422f, 0.06392436f, 0.07866711f, 0.09858765f, 
    0.14955232f, 0.31882370f, -0.48859656f, 0.01746011f, 0.20778702f, 0.42022505f, -0.04547864f, -0.04110001f, 
    -0.05438207f, 0.42440924f, -0.05195009f, -0.10661702f, -0.21418320f, 0.35471788f, 0.00039801f, 0.13056602f, 
    -0.19192576f, -0.35806155f, 0.08295801f, 0.10253386f, 0.19874786f, 0.19001336f, 0.12481458f, -0.00010608f, 
    0.05910500f, -0.28118241f, 0.05228249f, 0.03598254f, -0.25882393f, 0.41492650f, 0.18331623f, -0.05513573f, 
    0.06489765f, -0.07202809f, 0.03784343f, -0.04989624f, 0.01119593f, 0.05678752f, -0.01468997f, -0.07326309f, 
    0.04485226f, -0.05469683f, -0.08093483f, 0.01597643f, -0.01347837f, -0.00063842f, 0.05699178f, -0.05402711f, 
    -0.04609134f, -0.02998108f, -0.02982557f, -0.06770768f, 0.05890032f, 0.07975674f, -0.05069784f, -0.06599753f, 
    -0.03615927f, 0.06486879f, -0.04934166f, 0.02541803f, -0.01675436f, -0.01445252f, -0.08727372f, -0.00907028f, 
    -0.02122962f, 0.06677666f, -0.03096861f, 0.02083575f, 0.00218137f, -0.02515045f, -0.00154164f, -0.08816931f, 
    -0.06444003f, -0.07787950f, -0.07224671f, 0.07142913f, -0.08111652f, -0.01813932f, 0.01167212f, -0.06074321f, 
    -0.03008812f, -0.09058505f, 0.05023611f, 0.04280817f, -0.08355655f, 0.02901061f, -0.09812552f, -0.02131413f, 
    -0.00186560f, -0.06306563f, -0.08727277f, -0.03891741f, -0.09843714f, 0.03013822f, 0.04228542f, -0.07204700f, 
    -0.07312793f, -0.00267816f, -0.05740317f, -0.02621448f, 0.06699638f, -0.07810559f, 0.01749119f, 0.04249888f, 
    0.07524579f, 0.04682984f, -0.04537888f, 0.01224057f, 0.05403349f, 0.02143650f, -0.02188870f, -0.06204884f, 
    -0.06098659f, 0.00100203f, -0.09965184f, -0.01983963f, -0.02978024f, -0.06250150f, -0.05683594f, 0.06980740f, 
    -0.05197980f, -0.05512888f, -0.01488744f, -0.06073121f, -0.01178392f, -0.07044237f, -0.05763778f, -0.08136693f, 
    0.02901673f, -0.04283888f, 0.07969739f, -0.07518070f, 0.00199787f, 0.00740693f, 0.03579202f, 0.06755635f, 
    0.02902686f, -0.06774191f, 0.02503554f, -0.03184205f, 0.06691522f, 0.06285600f, -0.08212321f, -0.06253009f, 
    0.04028442f, 0.04651959f, -0.00841160f, -0.06703705f, -0.03193731f, 0.06142078f, 0.01072544f, -0.00634105f, 
    0.02130650f, 0.06486225f, -0.03788854f, -0.02346064f, -0.02967013f, -0.09488714f, -0.11917839f, 0.07507075f, 
    0.04073507f, -0.09036029f, 0.05352609f, -0.09815952f, -0.10894164f, 0.00054495f, -0.05708938f, 0.01570189f, 
    0.02337290f, -0.01096955f, -0.04099891f, -0.08379222f, -0.00875516f, 0.03600712f, -0.04531913f, 0.02423614f, 
    -0.11337899f, -0.01163998f, 0.04906527f, -0.04365246f, -0.11603084f, -0.06894228f, -0.07805637f, -0.00657570f, 
    -0.09955239f, -0.09972239f, -0.09231357f, 0.00885030f, -0.11306813f, 0.06293441f, -0.03133294f, -0.07243092f, 
    -0.02764780f, -0.12306787f, 0.03015994f, -0.08851682f, -0.02671606f, -0.02065411f, -0.07216516f, -0.10558856f, 
    -0.02906317f, -0.09524255f, -0.03758358f, 0.02084878f, 0.05255678f, 0.06821916f, -0.07189530f, -0.07691634f, 
    0.05787794f, 0.01289964f, 0.06040150f, -0.07024899f, -0.09904949f, 0.07604767f, 0.05302284f, -0.05419083f, 
    -0.02369186f, 0.04320790f, -0.06381385f, 0.00556380f, -0.01493115f, -0.01898117f, 0.05718778f, -0.06170449f, 
    0.06272531f, 0.01494518f, 0.04145273f, -0.00006874f, 0.01548158f, 0.04764404f, -0.01906568f, -0.02660424f, 
    -0.00801263f, -0.03456711f, 0.02181517f, -0.02624059f, -0.09620668f, -0.06180976f, 0.01830853f, -0.10492852f, 
    -0.03811731f, 0.00465406f, 0.03465974f, 0.03461562f, 0.01802358f, 0.00139038f, -0.03886352f, -0.02264499f, 
    -0.10463309f, -0.05074349f, -0.05441893f, -0.04158960f, 0.06596048f, -0.04130499f, -0.07597508f, -0.09580910f, 
    -0.05194727f, -0.07247592f, -0.01614486f, 0.03760551f, -0.03752501f, -0.05266314f, 0.02222679f, -0.11581556f, 
    -0.07804946f, -0.00787860f, 0.03543632f, 0.03893091f, -0.07740811f, -0.12686649f, -0.03604314f, -0.03026520f, 
    -0.11038231f, 0.04457886f, -0.08243841f, 0.01226375f, -0.06600288f, -0.11600332f, 0.03303394f, 0.04041542f, 
    -0.06707118f, -0.04093868f, -0.11856815f, -0.10041539f, 0.06182608f, 0.01830951f, -0.01864293f, -0.08335371f, 
    0.01186890f, 0.05572595f, -0.00154028f, -0.07326521f, -0.00085662f, 0.12966603f, 0.05340006f, -0.02698742f, 
    -0.16874765f, -0.04994142f, -0.21975707f, -0.07610980f, 0.03900407f, -0.08875620f, 0.15200277f, 0.08278452f, 
    0.12706728f, -0.14444488f, -0.20570034f, -0.14659272f, -0.09553026f, 0.03550450f, -0.02506129f, -0.04013878f, 
    0.05120738f, 0.13206850f, 0.00018023f, -0.01599394f, -0.11088912f, 0.11920421f, 0.14894579f, -0.02338616f, 
    -0.06213475f, -0.03165977f, 0.06098966f, 0.02911438f, -0.33860883f, 0.10112625f, -0.01054301f, 0.33361569f, 
    -0.01046421f, -0.10532961f, -0.32173386f, 0.13884634f, 0.03349512f, 0.26870105f, 0.07095429f, 0.06004356f, 
    0.06254499f, -0.01950301f, -0.22739460f, 0.08508447f, 0.12852153f, 0.00318071f, -0.19179831f, 0.07201035f, 
    -0.02796634f, 0.11111765f, 0.05797004f, -0.04134899f, 0.19872065f, -0.00602744f, 0.12763803f, 0.32880822f, 
    0.04877027f, -0.02397152f, 0.03255332f, 0.20333244f, 0.07093816f, -0.36952230f, 0.05326584f, 0.18101892f, 
    -0.02830539f, -0.04920054f, 0.10749193f, -0.05984039f, -0.10128392f, 0.18750097f, 0.21513981f, 0.00524156f, 
    0.17895618f, -0.08577931f, 0.05851074f, 0.02238490f, 0.13931327f, 0.02961961f, -0.71256453f, 0.23427071f, 
    0.15959895f, 0.26102483f, -0.30868462f, 0.53786606f, 0.24865071f, -0.26375684f, -0.06234226f, 0.10207481f, 
    0.15176439f, -0.19092208f, 0.02011803f, -0.02073229f, 0.03255343f, -0.26177010f, -0.01786178f, 0.00184874f, 
    -0.05853462f, 0.12263895f, -0.17329845f, -0.39283580f, 0.22876044f, 0.33126298f, 0.09647308f, -0.22157264f, 
    -0.01029405f, -0.00557120f, 0.09216999f, -0.07079612f, 0.10472921f, -0.11376221f, 0.04680354f, 0.00526891f, 
    -0.04719055f, -0.17164193f, 0.10767367f, 0.04469882f, -0.00573035f, 0.07608259f, -0.21358931f, 0.08188078f, 
    -0.18038583f, -0.24998790f, 0.38504094f, -0.07609392f, -0.07489254f, -0.05994449f, 0.07883395f, 0.06002957f, 
    0.37634727f, 0.17334640f, 0.11044949f, 0.09938005f, -0.17181553f, 0.19690070f, 0.00227013f, -0.06685500f, 
    -0.03057478f, 0.23530005f, 0.43146864f, -0.09250148f, 0.10568417f, 0.02789363f, 0.08147926f, -0.38213995f, 
    -0.39665419f, 0.12740882f, 0.20150632f, 0.06777290f, 0.31110469f, 0.03787830f, -0.01260227f, -0.11341110f, 
    -0.02745361f, 0.13628273f, -0.10108881f, 0.17946075f, -0.76600283f, -0.15681484f, -0.13527614f, -0.12426092f, 
    0.19450194f, 0.04393141f, 0.05049251f, 0.23080252f, -0.57302409f, -0.07198706f, 0.12426648f, 0.20013432f, 
    -0.06379244f, 0.06173770f, -0.23543885f, 0.05143382f, 0.06793581f, 0.06449673f, -0.04487039f, 0.02121051f, 
    0.02667052f, -0.16007861f, -0.46487346f, -0.05664818f, -0.08414595f, 0.34319243f, 0.00558341f, -0.21498545f, 
    0.40165135f, 0.12024499f, 0.02179552f, -0.19415520f, 0.27826405f, 0.14243078f, 0.39846388f, -0.49271113f, 
    -0.06330767f, 0.03698102f, 0.23229685f, 0.05936692f, -0.07541989f, 0.17034188f, 0.08041894f, -0.26830307f, 
    0.35445812f, -0.06909433f, 0.10692016f, 0.26824933f, 0.02384895f, 0.27528110f, 0.64915031f, 0.42074716f, 
    -0.05499229f, 0.02250705f, 0.41382495f, -0.36516044f, -0.19936641f, 0.02276726f, 0.14344077f, 0.22814168f, 
    0.11392813f, 0.08173937f, -0.00250172f, -0.06356037f, -0.04501159f, -0.02205963f, -0.21256599f, 0.17144828f, 
    0.05952999f, 0.36067480f, -0.05058243f, 0.48694912f, -0.03024742f, 0.00517088f, 0.12546219f, 0.03104247f, 
    -0.19720057f, 0.05741703f, -0.35070845f, 0.10996438f, -0.23317577f, -0.13376613f, -0.22076938f, -0.07019065f, 
    -0.19635269f, 0.32244918f, -0.00398039f, 0.17465086f, -0.33595312f, -0.01744719f, -0.06917216f, -0.04706993f, 
    -0.00368342f, -0.13770929f, 0.03626625f, -0.25434428f, 0.10295143f, -0.33885670f, -0.30681011f, 0.00869840f, 
    0.34849823f, -0.09940025f, 0.29706335f, 0.00832812f, 0.16959585f, 0.04089121f, 0.12161028f, 0.12181289f, 
    -0.17797607f, 0.01464659f, -0.27849782f, 0.02844679f, 0.12942882f, 0.11093969f, 0.01313017f, -0.32354489f, 
    -0.12886271f, 0.16111352f, -0.00187135f, 0.13457581f, -0.22258125f, 0.08381542f, -0.13551399f, -0.23910771f, 
    0.08865653f, 0.11393213f, 0.15263380f, -0.36597288f, 0.32612431f, -0.17720139f, -0.31314251f, -0.07076115f, 
    0.22188793f, 0.03813475f, -0.02463476f, -0.24237502f, 0.07509874f, 0.48263749f, 0.14341989f, 0.00838381f, 
    -0.04877085f, -0.15362404f, 0.50784719f, -0.18289167f, -0.11721366f, -0.01188127f, 0.08296990f, -0.01203882f, 
    0.17856696f, -0.04735439f, -0.35417965f, 0.12110249f, -0.31931114f, 0.04882145f, 0.12431179f, -0.44929644f, 
    0.05410285f, 0.14741446f, 0.02767275f, 0.19116917f, -0.08539658f, 0.14503726f, 0.07280035f, -0.04431623f, 
    -0.29789540f, -0.07635856f, 0.01935619f, 0.05488065f, 0.22158955f, -0.10184870f, -0.21476583f, -0.09046607f, 
    -0.41764328f, 0.19297504f, -0.02450426f, 0.01269335f, -0.20406410f, -0.03822978f, -0.28192914f, 0.47209394f, 
    -0.51350832f, -0.43187445f, 0.77736783f, -0.30083266f, -0.12218148f, 0.41043612f, -0.13176322f, 0.03254914f, 
    -0.51142734f, 0.15194033f, 0.09688561f, -0.05716265f, -0.23936839f, -0.26977283f, 0.08910079f, 0.19946985f, 
    0.06416446f, -0.18025319f, 0.10969853f, 0.37845916f, -0.11888438f, -0.17793226f, -0.12529129f, 0.33597973f, 
    -0.16943350f, 0.01526541f, -0.17379959f, -0.02069418f, -0.13126324f, -0.04365480f, 0.10561943f, 0.10620676f, 
    0.25648934f, 0.03946431f, 0.17818946f, -0.21473180f, 0.10419016f, -0.13633128f, -0.00230181f, 0.02928247f, 
    0.00699452f, -0.27319914f, 0.10383018f, -0.09554928f, 0.19938965f, -0.01096899f, 0.21178086f, -0.46426252f, 
    0.02816096f, 0.18945049f, -0.00844462f, 0.23073633f, 0.06158992f, 0.06260328f, -0.05233790f, 0.15711710f, 
    0.23672989f, -0.19297388f, -0.00492335f, 0.06273701f, -0.28771421f, -0.11323949f, 0.00370510f, 0.06894946f, 
    0.17932984f, -0.51784742f, 0.19167462f, -0.02404428f, 0.36401388f, 0.13970475f, -0.06839046f, 0.21252717f, 
    0.10325286f, -0.17134540f, -0.75796247f, 0.40175137f, 0.01366410f, 0.31702784f, -0.02437482f, -0.61457139f, 
    0.00908936f, 0.08574141f, 0.01623410f, -0.06091185f, -0.23007247f, -0.06524044f, 0.03535900f, 0.06171472f, 
    0.05907084f, 0.08024064f, -0.24573189f, -0.13291201f, -0.07847314f, 0.03185922f, -0.23179896f, 0.04754373f, 
    0.14590861f, 0.02807968f, -0.16872963f, 0.03141480f, -0.00487079f, -0.09708170f, -0.53304893f, -0.07191849f, 
    -0.00066550f, 0.09871645f, -0.10958340f, 0.21025266f, -0.19340022f, -0.25000557f, -0.00475499f, 0.08874656f, 
    -0.04117124f, 0.27402395f, -0.40319920f, -0.11532500f, -0.92709506f, -0.08953905f, 0.12038240f, 0.09829918f, 
    0.21436027f, 0.13183407f, 0.18540913f, 0.30061224f, 0.06282625f, 0.19072908f, -0.31336075f, -0.31418237f, 
    0.06660852f, -0.13654439f, -0.81105161f, -0.19289216f, 0.07653793f, -0.67053497f, -0.56282580f, -0.22354329f, 
    -0.09214409f, -0.05540854f, -0.33151868f, -0.06277755f, -0.27301311f, 0.24431090f, 0.19702767f, -0.53368759f, 
    0.12060975f, -0.58217496f, 0.02755479f, -0.21548617f, 0.28250274f, -0.09762433f, 0.22256820f, -0.43454453f, 
    0.62905079f, -0.14453660f, 0.13749620f, -0.20836748f, 0.03103820f, -0.22314146f, -0.22518116f, 0.00080434f, 
    0.23391879f, -0.75302625f, 0.22551376f, -0.14075208f, -0.08636963f, -0.32745951f, -0.18502589f, 0.01078876f, 
    -0.05835427f, -0.07124819f, 0.06690136f, 0.06142823f, 0.03269273f, 0.04877516f, 0.05434399f, -0.03143525f, 
    -0.00622012f, -0.01624302f, -0.00998140f, 0.04832412f, -0.03613542f, -0.05649190f, 0.02885717f, 0.03637605f, 
    0.02043249f, -0.08563310f, -0.02181452f, -0.02183087f, -0.03438708f, -0.01102210f, -0.05317144f, -0.00692162f, 
    0.01807244f, -0.03238218f, 0.04323487f, 0.00601074f, -0.10257012f, 0.02799965f, 0.05930761f, 0.05258667f, 
    -0.10535615f, 0.05922638f, 0.03789746f, 0.02584897f, 0.02411036f, -0.07830529f, 0.01298677f, 0.05956399f, 
    -0.02084075f, -0.00998173f, 0.05441565f, 0.03648001f, -0.06457045f, 0.02662103f, -0.08907878f, -0.02025765f, 
    0.07205093f, 0.02910618f, -0.00221971f, 0.05245575f, -0.06514841f, -0.07618551f, -0.02839682f, -0.03700102f, 
    -0.00034987f, 0.00906304f, -0.04140074f, -0.09932989f, 0.06467336f, 0.00838028f, -0.00692353f, 0.06087220f, 
    0.04320731f, 0.02219271f, 0.06805552f, 0.01775199f, -0.07920867f, -0.03087834f, -0.06172245f, 0.02622485f, 
    -0.07304595f, -0.01357178f, -0.03786603f, -0.07888779f, 0.01068988f, -0.05034447f, 0.04312100f, -0.05766598f, 
    -0.03418617f, -0.07350565f, -0.00860822f, -0.02798448f, -0.06295364f, 0.01170880f, 0.03075782f, 0.06596990f, 
    -0.08322888f, -0.07904916f, 0.02408455f, 0.03697696f, 0.02725562f, -0.01939519f, -0.09862739f, -0.01495340f, 
    -0.07008899f, -0.00357149f, -0.01608621f, 0.06700250f, -0.10859955f, 0.02716480f, 0.03143362f, -0.01370245f, 
    -0.06146270f, -0.03625990f, -0.09553304f, -0.08670874f, 0.03016900f, -0.06024558f, 0.01421165f, 0.02640029f, 
    -0.05525157f, -0.06788170f, -0.04015244f, 0.06011001f, -0.04009568f, 0.03615012f, -0.08465309f, 0.05656216f, 
    -0.08755720f, -0.06929611f, -0.02349210f, -0.00428330f, -0.05565396f, 0.00671246f, -0.09709790f, 0.07782727f, 
    -0.41303068f, -0.08680870f, 0.35711688f, -0.05101226f, 0.23994091f, 0.04194396f, 0.16073467f, -0.06893273f, 
    -0.22636512f, 0.20843963f, -0.05724577f, -0.27694198f, 0.00459473f, 0.23589478f, -0.11900162f, -0.07374508f, 
    0.23936403f, -0.28114924f, 0.01646829f, -0.03502918f, -0.06568997f, 0.06930060f, -0.03815870f, -0.21768889f, 
    -0.01897090f, 0.14651608f, -0.02900049f, -0.32351872f, 0.10792769f, 0.22376208f, -0.04981110f, 0.05258295f, 
    0.16415536f, -0.38674122f, -0.01418757f, 0.20983429f, -0.13353647f, 0.15939958f, -0.04451061f, 0.04365392f, 
    0.05227247f, 0.08498410f, -0.40305829f, -0.07341346f, 0.16174182f, 0.16532432f, -0.06082289f, 0.05346638f, 
    0.02330556f, -0.27201849f, -0.15811409f, 0.06519306f, 0.00786324f, -0.00323921f, -0.29810604f, 0.26282838f, 
    0.01155651f, 0.09245315f, -0.35876462f, 0.06785247f, 0.16903602f, 0.10269734f, 0.06399903f, 0.27277291f, 
    0.70036942f, -0.14834531f, 0.20457083f, 0.34580481f, 0.01984381f, 0.34553617f, 0.27281547f, -0.09197733f, 
    0.04573825f, 0.26760879f, -0.05609354f, -0.03657352f, -0.34718242f, 0.18419747f, 0.11556640f, 0.21829958f, 
    0.53362876f, -0.03200550f, 0.36392733f, -0.03667258f, 0.16838519f, 0.40327525f, -0.60817879f, 0.44354177f, 
    0.01483960f, 0.03273365f, -0.03734429f, -0.04492436f, -0.21596366f, 0.11898425f, -0.11395839f, -0.04788256f, 
    -0.21928898f, -0.07719026f, -0.18799753f, -0.01347943f, -0.05731615f, -0.02911472f, 0.08305378f, -0.12547402f, 
    0.13585925f, 0.02590789f, -0.06085265f, -0.53124982f, 0.40895769f, 0.17510454f, 0.27524456f, -0.37924072f, 
    0.30089352f, 0.11243348f, -0.23191017f, -0.24245763f, 0.05807999f, -0.03362680f, -0.33743691f, 0.00068372f, 
    0.09086016f, -0.01833174f, 0.19809656f, 0.00605760f, -0.05930849f, 0.19265774f, -0.19546306f, -0.00269031f, 
    0.05847993f, -0.03604781f, 0.01465756f, 0.07774597f, 0.00900826f, 0.02763538f, 0.03021236f, 0.06360784f, 
    0.01169800f, -0.03787293f, 0.00375399f, -0.06201236f, 0.00546151f, -0.07038958f, -0.01692743f, 0.01041595f, 
    -0.08701450f, 0.05425450f, -0.08539282f, -0.10847641f, 0.00854125f, -0.04093312f, -0.03888430f, -0.08334938f, 
    -0.03589066f, -0.06761242f, -0.03316093f, 0.02890647f, 0.02436451f, 0.01273406f, 0.01164149f, 0.05062030f, 
    -0.10413401f, -0.04924579f, -0.06816618f, -0.08214880f, -0.06177365f, 0.05752440f, -0.07246101f, -0.05700424f, 
    0.02713476f, 0.03327269f, -0.05858028f, 0.05470343f, 0.00556764f, -0.02581674f, 0.05332853f, 0.01434732f, 
    -0.00177379f, -0.04094806f, 0.03540239f, -0.06687874f, 0.06905975f, -0.05517985f, 0.02816100f, -0.08149445f, 
    -0.06212371f, -0.07016178f, -0.03543906f, -0.03335521f, -0.09031390f, -0.03572032f, -0.08675624f, 0.00647458f, 
    -0.02417883f, -0.08395404f, 0.01412834f, -0.03466403f, 0.03008738f, -0.05598717f, 0.00839643f, 0.02709732f, 
    0.05261406f, -0.03824395f, 0.00521110f, 0.07071252f, 0.00514601f, -0.00878185f, -0.02245036f, -0.05551422f, 
    0.03394972f, -0.04343699f, -0.01549407f, -0.00563100f, -0.02217467f, 0.07081217f, 0.04233470f, -0.02074902f, 
    -0.00220340f, 0.04844103f, -0.05744771f, -0.00319133f, 0.06391428f, -0.07975578f, -0.07723869f, -0.08112828f, 
    -0.08260677f, 0.00067191f, 0.00917450f, 0.07406157f, -0.00406824f, 0.05397355f, -0.00101321f, -0.07440158f, 
    -0.03671828f, -0.05642503f, -0.06488740f, 0.05171710f, 0.03218114f, -0.08972151f, -0.06807255f, -0.08226126f, 
    0.01215269f, -0.07738982f, 0.05192183f, -0.00083127f, 0.02098094f, -0.04055821f, 0.02802406f, -0.00961716f, 
    -0.00491597f, -0.03721663f, 0.03651877f, 0.06449527f, -0.04206465f, -0.03918294f, -0.10300215f, 0.08728100f, 
    -0.06718948f, -0.04385835f, 0.24242041f, -0.24362987f, 0.07579064f, -0.00558478f, -0.05279804f, -0.08008268f, 
    0.24163722f, 0.25840116f, -0.03434312f, -0.10865287f, 0.00305588f, 0.20902444f, 0.10338263f, 0.00374929f, 
    0.05762007f, -0.01002701f, 0.01252834f, 0.06381735f, -0.13966379f, 0.02642408f, 0.08184412f, -0.32297218f, 
    -0.12758601f, 0.23783776f, 0.21506870f, 0.04547581f, 0.26158237f, -0.15019128f, 0.00597564f, -0.04589539f, 
    0.08546453f, -0.03741118f, 0.03005797f, 0.10665795f, -0.50734484f, 0.06542366f, -0.14368999f, 0.00765081f, 
    0.27589554f, 0.11581830f, -0.09560899f, -0.04096843f, -0.27531987f, -0.00587580f, 0.21474846f, 0.14818025f, 
    -0.08790834f, 0.04202128f, 0.29303566f, 0.04889575f, 0.07965686f, -0.06297919f, -0.25359967f, 0.07403704f, 
    0.24563646f, 0.05163335f, -0.49341163f, 0.08429364f, -0.24107154f, 0.23833141f, 0.22696915f, -0.38688281f, 
    0.26417363f, 0.11427563f, 0.12770121f, 0.10901477f, 0.07557997f, 0.23083434f, 0.20424964f, -0.11579661f, 
    -0.25208583f, -0.06034408f, 0.06140283f, 0.05631102f, -0.16672930f, -0.04566755f, 0.13065302f, 0.26088861f, 
    0.30297157f, 0.23768663f, 0.32303181f, 0.38498524f, 0.01955741f, 0.27540466f, -0.15340644f, 0.37232444f, 
    0.03648876f, 0.00598870f, 0.21026292f, -0.54637468f, -0.57665455f, 0.18166013f, -0.25188059f, 0.21447957f, 
    0.13437992f, -0.12163196f, 0.01912037f, -0.06135244f, -0.15582828f, -0.09981057f, -0.06308072f, 0.14460269f, 
    -0.02455214f, 0.03710300f, -0.01755621f, 0.30079949f, 0.32091597f, 0.03177238f, 0.09109019f, 0.16537392f, 
    -0.27361888f, 0.07234080f, -0.60663992f, 0.01514650f, 0.01796165f, -0.08873800f, -0.09653164f, 0.01976556f, 
    -0.13657308f, -0.14447342f, 0.23379931f, 0.09746124f, -0.10326434f, -0.10721719f, -0.18010356f, -0.04691260f, 
    0.02046207f, -0.05181749f, -0.09165235f, -0.01103992f, 0.00712215f, 0.04981096f, -0.06666693f, -0.01932322f, 
    -0.07148834f, 0.01059204f, -0.05125063f, -0.05942312f, -0.02990908f, -0.07125130f, -0.01138239f, -0.09283029f, 
    -0.07931177f, -0.08902494f, -0.00737464f, -0.08471048f, -0.05295410f, -0.07072897f, -0.01550215f, 0.00770203f, 
    -0.08014919f, -0.00198824f, 0.07206307f, -0.03969656f, -0.04424246f, -0.07612664f, -0.06040196f, -0.02265347f, 
    0.02689518f, 0.05280162f, -0.08324460f, -0.04748403f, -0.06120846f, 0.05911923f, 0.05317429f, 0.02645965f, 
    0.03747900f, -0.06737493f, -0.09213314f, -0.04993528f, -0.08275051f, -0.01917361f, -0.05492065f, -0.07430847f, 
    0.08517951f, -0.00579254f, -0.01230755f, -0.07637198f, 0.02803056f, 0.03519576f, -0.05858473f, 0.03018042f, 
    0.01587264f, 0.01212905f, -0.03156833f, 0.03415348f, 0.00909959f, 0.03907589f, 0.00235134f, -0.03772729f, 
    -0.04659508f, -0.05480224f, 0.06524178f, 0.08672228f, -0.09421330f, -0.02696491f, 0.02703032f, 0.04892268f, 
    0.03848219f, 0.00635273f, 0.01093843f, 0.03897540f, 0.06080421f, 0.00160744f, 0.03709298f, 0.01642912f, 
    -0.08499844f, 0.05352923f, -0.06775708f, 0.03942775f, -0.08950780f, -0.09558312f, -0.04807864f, 0.03160085f, 
    -0.06736722f, 0.02346699f, -0.00429373f, -0.08461975f, -0.03025380f, 0.03330461f, -0.05466318f, 0.07134047f, 
    -0.08395330f, -0.06153636f, -0.08830214f, 0.05260112f, -0.01220621f, -0.05662688f, -0.01952749f, -0.09488881f, 
    0.03521361f, 0.00500634f, 0.07842430f, 0.04941457f, -0.07408725f, -0.08302134f, 0.06685601f, -0.03632104f, 
    0.08461387f, 0.01843889f, -0.06281763f, -0.00433606f, -0.09091704f, -0.06351005f, -0.03661702f, 0.00432299f, 
    0.00348051f, -0.06683062f, -0.04143354f, -0.00265586f, -0.05064745f, -0.09567454f, -0.04277963f, 0.02750190f, 
    0.01782298f, -0.13102724f, 0.39904681f, -0.27083835f, -0.13209915f, -0.02776721f, -0.04313171f, -0.00752696f, 
    0.17465736f, 0.22199322f, -0.04315333f, 0.08027938f, -0.07777693f, 0.11419041f, 0.02095591f, 0.03125410f, 
    -0.26621267f, 0.18653002f, 0.28785145f, 0.00539858f, 0.01025500f, 0.00676159f, -0.08682358f, 0.06016632f, 
    -0.08827440f, 0.21641278f, 0.16575181f, -0.03070449f, 0.02958613f, -0.16120088f, 0.09923075f, -0.05628951f, 
    -0.07296431f, 0.11740663f, -0.15018411f, 0.09721726f, 0.33140156f, 0.04572405f, -0.13709462f, -0.20645963f, 
    0.18037412f, -0.00546330f, -0.37236804f, -0.08375321f, 0.06315713f, -0.04578877f, 0.05102812f, 0.18080707f, 
    -0.06970486f, 0.20410138f, 0.05736673f, -0.08047289f, -0.02372542f, -0.02715243f, 0.19095826f, 0.02945100f, 
    -0.02239912f, -0.09468061f, -0.22363108f, -0.05118096f, 0.08277283f, 0.18741234f, 0.02369463f, -0.00142640f, 
    0.02914672f, 0.13947001f, 0.17129932f, -0.02458767f, 0.20092085f, 0.26588151f, 0.27041304f, -0.14123616f, 
    0.09852019f, 0.03437964f, 0.29116333f, 0.07987184f, -0.02063436f, -0.04401893f, 0.15819693f, 0.14865573f, 
    0.15515384f, 0.14863768f, 0.15842731f, -0.13466893f, 0.04647277f, 0.17227262f, 0.07720134f, 0.14108159f, 
    -0.00222051f, -0.02331518f, 0.39110607f, -0.12915765f, -0.01422655f, 0.35090068f, 0.12397589f, 0.15277921f, 
    0.07744582f, -0.08445346f, 0.01991864f, -0.01522270f, -0.06429654f, 0.01242750f, -0.09526683f, 0.17769933f, 
    0.05740381f, 0.41185495f, 0.04112601f, 0.06037641f, 0.18032084f, -0.12158184f, -0.05759293f, 0.16891666f, 
    -0.05488711f, 0.13561022f, 0.09851152f, -0.26360148f, -0.07290407f, -0.11839367f, -0.02637744f, 0.04452167f, 
    -0.00764772f, 0.26689258f, -0.07996110f, 0.11386517f, -0.04614138f, -0.04968698f, 0.18371895f, 0.05521901f, 
    0.14568953f, 0.01800371f, 0.04190547f, 0.13391244f, 0.07019995f, 0.01679485f, 0.02529283f, -0.05413236f, 
    -0.09388333f, 0.14577281f, 0.17431059f, -0.34034184f, 0.04436115f, 0.22572242f, -0.09090862f, -0.03666899f, 
    0.22907428f, 0.10680693f, 0.04707098f, 0.19082190f, 0.02952518f, 0.04653893f, 0.04322333f, -0.08959296f, 
    0.12432382f, 0.06593101f, -0.01634243f, -0.14434668f, 0.01189011f, -0.39691663f, -0.14388454f, 0.14539999f, 
    0.08883089f, -0.04569924f, -0.03921416f, 0.01890547f, 0.16565131f, -0.00962486f, 0.25355896f, -0.11316086f, 
    -0.00556164f, 0.10680877f, 0.05178727f, -0.10742389f, 0.01708612f, -0.13543311f, 0.10057203f, -0.06242979f, 
    -0.04232003f, 0.02638341f, -0.12263265f, 0.03505531f, 0.04854761f, 0.07960927f, -0.07453895f, 0.28987899f, 
    0.01314941f, -0.02091648f, 0.27049896f, 0.11646858f, 0.07517434f, 0.01131190f, -0.07240704f, 0.02913313f, 
    -0.40038699f, -0.05487271f, -0.13687591f, -0.03777242f, -0.17545000f, -0.28806657f, 0.16833283f, 0.13545562f, 
    -0.23040678f, 0.21683006f, -0.06765202f, -0.01235528f, -0.09630706f, -0.36649472f, -0.16920008f, -0.03411562f, 
    -0.04865784f, 0.12936707f, -0.00792042f, 0.24967048f, 0.15784208f, 0.12893479f, 0.30308667f, -0.17517552f, 
    -0.19844729f, -0.06092388f, 0.16533557f, -0.12929784f, -0.17725357f, -0.08114166f, 0.03769042f, -0.19728920f, 
    -0.10545668f, 0.38178924f, -0.18809614f, 0.01442052f, 0.20691624f, 0.27068803f, 0.25998154f, -0.10757880f, 
    0.13005540f, 0.02647645f, 0.18746871f, 0.22576973f, -0.01492054f, 0.03825322f, 0.03968351f, 0.02599146f, 
    -0.24037501f, 0.07224107f, -0.13407934f, -0.03300135f, 0.05448392f, 0.14838462f, 0.06975313f, -0.08422083f, 
    0.07672335f, -0.27473527f, 0.11335065f, -0.12111405f, 0.09472651f, 0.09111156f, 0.18561289f, -0.05039954f, 
    0.51028651f, 0.08036903f, -0.10509197f, 0.08155279f, 0.07259412f, -0.09872314f, -0.03618713f, 0.16718821f, 
    0.41024229f, 0.24582756f, 0.32168096f, 0.08384559f, 0.10848592f, 0.14774282f, 0.15514177f, -0.09108777f, 
    0.16538942f, 0.41049522f, -0.21432430f, 0.20042551f, -0.11632592f, -0.00163516f, -0.03426747f, -0.02608014f, 
    0.25509533f, -0.15015748f, -0.14030015f, 0.20769709f, 0.10035437f, -0.38964149f, -0.23637772f, -0.19109525f, 
    0.22266729f, 0.30037794f, -0.12768458f, -0.15050118f, -0.41438067f, -0.00793080f, 0.13336688f, -0.58798218f, 
    0.08124021f, -0.09426583f, -0.03491878f, 0.41295588f, 0.34022599f, 0.17626987f, 0.38817033f, -0.09396619f, 
    0.01880021f, -0.32595491f, 0.40605506f, 0.05534847f, 0.01679194f, 0.00082404f, -0.00575623f, 0.10911226f, 
    0.27180380f, 0.05164258f, 0.41638115f, 0.06164286f, -0.11456408f, -0.31880665f, -0.09239317f, -0.38448384f, 
    -0.82387197f, 0.28591749f, -0.20684618f, 0.10724185f, -0.08393493f, 0.46690047f, -0.17258687f, -0.01505047f, 
    0.12503955f, -0.33909452f, -0.23223281f, -0.19616640f, 0.11063301f, -0.28429222f, -0.16868554f, -0.24539441f, 
    -0.44116706f, 0.09022605f, -0.16524853f, 0.14591631f, -0.04622319f, -0.33011362f, 0.68761748f, -0.24346127f, 
    -0.24473868f, 0.12755878f, -0.28859419f, -0.29981726f, -0.40862295f, 0.12944037f, 0.24066687f, 0.03642973f, 
    -0.06885830f, 0.46000481f, -0.10627235f, -0.04181181f, 0.13228853f, 0.25093454f, 0.10446354f, -0.14273898f, 
    0.21405275f, -0.26097500f, -0.08088557f, -0.67474484f, -0.45482385f, -0.17208913f, 0.05305037f, 0.21731262f, 
    -0.24342109f, -0.14501721f, -0.42871985f, 0.08717870f, 0.29460201f, 0.18639265f, 0.19200455f, 0.02175805f, 
    -0.18173653f, -0.18365023f, 0.07410131f, -0.04282456f, 0.03587035f, 0.15319349f, 0.34487072f, 0.05387428f, 
    0.03814429f, 0.00950076f, 0.01296336f, 0.02341082f, -0.11371299f, 0.01057984f, -0.01959288f, -0.07304726f, 
    0.01292602f, 0.00589092f, 0.01009896f, 0.02614142f, -0.13123205f, -0.09019354f, 0.00338202f, -0.11570188f, 
    -0.05707486f, 0.07509495f, -0.02195260f, -0.09674915f, -0.07245666f, -0.02946992f, -0.01098304f, -0.02939502f, 
    -0.04696414f, 0.04469555f, -0.11341252f, -0.03294283f, 0.05637371f, 0.03759127f, -0.10834420f, -0.06138188f, 
    -0.00715198f, -0.05527933f, 0.02051931f, -0.06662199f, 0.05539887f, -0.13233422f, -0.10118830f, -0.03577915f, 
    -0.05790152f, -0.00277718f, -0.11309163f, -0.10713350f, -0.04264587f, -0.03366048f, 0.01830587f, -0.07453175f, 
    0.08242726f, -0.06262565f, -0.05578922f, 0.04585630f, -0.10491355f, -0.04001198f, -0.03549425f, -0.08855253f, 
    -0.00596581f, -0.11270798f, -0.02974555f, -0.11296491f, 0.02299805f, -0.07826588f, 0.01695264f, 0.04357737f, 
    -0.07040397f, -0.02124098f, -0.00091601f, -0.05559336f, 0.03976129f, 0.02801617f, -0.05050801f, -0.02435620f, 
    0.00332630f, 0.00128022f, -0.00483871f, 0.03858826f, -0.00424553f, -0.03856855f, 0.02543866f, 0.05362676f, 
    -0.04705119f, 0.01804667f, 0.02889524f, -0.03960029f, -0.06345233f, 0.01921700f, -0.10722538f, 0.04069210f, 
    -0.06085210f, 0.04565562f, 0.04145286f, 0.05297766f, -0.08685464f, 0.03106060f, -0.08840877f, -0.06279211f, 
    -0.02881641f, -0.05559680f, -0.05555083f, 0.06676791f, -0.09061701f, 0.03736238f, -0.08745591f, 0.03004352f, 
    -0.01362161f, -0.03032495f, 0.02644267f, 0.02171956f, -0.01442840f, -0.02803962f, 0.01615158f, 0.05126175f, 
    0.02005294f, 0.02950034f, 0.03714469f, -0.00864627f, -0.00328353f, -0.11303575f, -0.08692147f, 0.01191728f, 
    -0.02509865f, 0.03088080f, 0.00943218f, -0.05468484f, -0.05576656f, 0.02520602f, 0.01483172f, -0.06662205f, 
    -0.05790609f, -0.09505236f, -0.08627709f, 0.01671641f, -0.01955129f, 0.01104413f, -0.07924409f, -0.05792974f, 
    0.01142252f, 0.03429559f, -0.10034201f, -0.10208199f, -0.04757213f, 0.02315196f, -0.06446599f, -0.06037745f, 
    -0.01737198f, -0.06324717f, -0.09856024f, -0.05413702f, 0.03243727f, -0.02342036f, -0.01571448f, -0.02177170f, 
    0.02273256f, -0.09460372f, 0.04104495f, 0.01672098f, 0.01316651f, -0.03597593f, 0.06604682f, -0.01954647f, 
    -0.00561785f, -0.07644966f, -0.08777610f, -0.11791982f, -0.06594339f, -0.08034454f, 0.00203342f, 0.02578723f, 
    0.03595568f, -0.05569198f, 0.04638193f, 0.00934353f, -0.05795769f, 0.04073852f, -0.08957715f, -0.07377204f, 
    -0.00993744f, -0.04692219f, -0.06841977f, -0.09654649f, -0.10624426f, -0.07750037f, -0.03067487f, -0.04236956f, 
    0.04474660f, -0.05637679f, 0.04630695f, -0.07362384f, -0.05548217f, 0.01063548f, 0.02508374f, -0.02627308f, 
    0.04579207f, -0.02901471f, -0.00738920f, -0.04096555f, 0.01855889f, 0.07852191f, -0.07725967f, -0.00098866f, 
    -0.00125641f, -0.06819505f, -0.03267730f, -0.05739282f, -0.04229140f, -0.08734699f, 0.02494038f, 0.04961417f, 
    0.03532102f, -0.00479903f, -0.05334907f, 0.03564566f, -0.04396049f, 0.05063499f, -0.06194263f, -0.02383611f, 
    -0.09825267f, 0.04751972f, -0.04122825f, -0.04208437f, 0.01241638f, 0.03721473f, -0.09769767f, 0.00951916f, 
    -0.00321587f, 0.00764984f, -0.06737856f, -0.04427342f, -0.11323820f, -0.02133115f, 0.06168657f, 0.01147309f, 
    -0.03882532f, 0.05574980f, 0.00069166f, 0.01301215f, -0.08583604f, -0.00906158f, -0.06098834f, -0.00542872f, 
    0.05614550f, -0.08677862f, -0.03290454f, -0.08730019f, -0.05245463f, 0.02759369f, -0.00610696f, -0.07390364f, 
    -0.06153590f, -0.01911685f, 0.03273570f, 0.01538006f, -0.02092762f, -0.00868098f, 0.02181155f, -0.01145838f, 
    0.09866264f, -0.05078282f, -0.13231160f, -0.24015917f, -0.10909554f, -0.27854609f, -0.05762449f, 0.04110134f, 
    0.46238017f, -0.09985226f, 0.23577183f, 0.15895428f, -0.00338706f, 0.03935474f, -0.02244778f, -0.05499413f, 
    -0.33475903f, 0.25489533f, 0.17444555f, 0.01428125f, -0.09446607f, 0.08012938f, 0.02369128f, -0.20298666f, 
    -0.31427106f, 0.00072484f, 0.02837847f, 0.13747643f, 0.16666329f, -0.04539754f, -0.10570139f, -0.47453621f, 
    0.06499199f, 0.22828735f, 0.15660259f, 0.00255421f, 0.58598381f, -0.05520958f, -0.22307803f, -0.14576101f, 
    0.14024357f, -0.00394325f, -0.07508456f, 0.30670762f, 0.21911906f, 0.44030285f, -0.04641504f, 0.04660100f, 
    -0.04775457f, -0.24699400f, 0.49588928f, -0.03092580f, 0.04069015f, 0.03807581f, 0.20613301f, -0.03871541f, 
    0.12282962f, 0.01135113f, 0.51745617f, -0.06506608f, 0.11174948f, 0.09514032f, 0.03481266f, 0.00155121f, 
    0.30515358f, 0.25743812f, 0.17469314f, 0.08568170f, 0.26385069f, -0.07244396f, 0.00380269f, -0.37455562f, 
    0.16636612f, -0.01313241f, 0.10806420f, -0.06808215f, 0.05371159f, -0.03533689f, -0.01164099f, -0.22436325f, 
    -0.75486231f, 0.18210039f, -0.06216215f, -0.18648030f, -0.17597175f, -0.09979501f, -0.20051529f, 0.44118384f, 
    -0.19969758f, -0.01879903f, 0.13952479f, 0.06342390f, 0.05000915f, 0.63080078f, 0.16496423f, 0.22095567f, 
    -0.27054712f, -0.01108941f, 0.12745780f, -0.06173800f, -0.09302557f, -0.25521678f, -0.34796801f, 0.22732171f, 
    -0.02460521f, 0.03704084f, -0.19028993f, -0.17590292f, -0.42078730f, -0.04966537f, -0.10799910f, 0.25600845f, 
    0.22076170f, -0.08490776f, -0.00372554f, 0.17353237f, -0.00500884f, -0.17118157f, 0.15320651f, 0.01366051f, 
    0.14911216f, 0.15507446f, 0.07356529f, 0.02377728f, -0.22455074f, 0.07439682f, 0.16282779f, -0.04322484f, 
    -0.08158899f, 0.06546158f, 0.01617148f, -0.08134318f, 0.04184005f, -0.06626829f, 0.00593415f, 0.06120123f, 
    -0.06584541f, -0.02674191f, -0.09893311f, -0.00918250f, -0.06114008f, -0.03441457f, -0.00943443f, 0.03341211f, 
    0.06082935f, -0.06489123f, -0.05094647f, 0.02603590f, 0.00802524f, -0.04753179f, 0.02059090f, 0.01684051f, 
    -0.06381148f, -0.05947622f, -0.03555282f, 0.00161508f, -0.03051389f, -0.03420176f, -0.06409808f, -0.06097861f, 
    0.01454023f, -0.08784293f, -0.07707642f, -0.01836228f, -0.01637139f, 0.04876105f, 0.04771840f, -0.10332236f, 
    -0.01605323f, 0.05148397f, -0.02365816f, 0.00410543f, -0.03005434f, 0.00664879f, 0.02492210f, 0.05443448f, 
    0.02542528f, -0.01579664f, -0.10083656f, 0.04975884f, 0.05882691f, -0.02290254f, 0.07814337f, 0.01689903f, 
    -0.03409630f, -0.08137864f, 0.03418681f, 0.01881511f, -0.08558000f, -0.03855604f, -0.01464646f, 0.04236080f, 
    0.00927307f, -0.04857922f, -0.04795451f, -0.06849259f, -0.01362946f, 0.06085699f, -0.04250307f, 0.03916205f, 
    -0.03524930f, 0.01834403f, -0.02900261f, -0.08724502f, 0.05082257f, -0.06840406f, -0.06620411f, -0.06382363f, 
    0.06532792f, -0.02187244f, -0.07573792f, -0.00796770f, -0.07669850f, 0.06262647f, 0.01165074f, -0.03377882f, 
    0.06102555f, 0.06520970f, -0.06821851f, 0.01534153f, 0.00119655f, -0.01374444f, -0.05116580f, -0.04138589f, 
    -0.03791659f, -0.01961916f, -0.02764037f, -0.03066924f, -0.04588395f, -0.02751669f, 0.04250607f, 0.01933876f, 
    -0.00008769f, -0.05573966f, 0.04685166f, 0.00416177f, -0.08341135f, 0.01714079f, 0.01887371f, 0.02275390f, 
    -0.00170460f, 0.04372702f, -0.01799588f, -0.03904924f, -0.00474020f, -0.06193690f, -0.07494553f, 0.03295557f, 
    -0.09950133f, 0.07214046f, 0.04832380f, -0.01320793f, 0.04992174f, -0.02881466f, -0.03309728f, -0.02053282f, 
    0.12007526f, 0.15268187f, -0.36538765f, 0.40824360f, 0.10592292f, 0.17053849f, 0.00084196f, 0.20327686f, 
    -0.05359747f, -0.11919761f, 0.06088084f, -0.34491563f, 0.18778554f, -0.01945632f, -0.29766500f, -0.04021519f, 
    0.21060573f, 0.01929104f, -0.08942432f, 0.02880438f, 0.12087709f, -0.03128114f, -0.06663528f, 0.04271780f, 
    0.20268996f, -0.25557536f, -0.29178494f, 0.11044592f, 0.06052658f, -0.22188780f, 0.11110735f, -0.00170062f, 
    0.12745570f, 0.08304495f, 0.33164445f, -0.15322402f, -0.32626426f, 0.01426238f, 0.13738638f, 0.38407317f, 
    0.02246103f, 0.12314929f, 0.61321008f, 0.16149560f, -0.02718394f, -0.21673270f, 0.11060557f, -0.26254955f, 
    0.05597050f, -0.25215107f, -0.24927543f, 0.15846536f, 0.19142471f, -0.05655935f, -0.05933842f, 0.13052274f, 
    0.01700567f, 0.24987873f, -0.09031393f, 0.07878546f, 0.01075617f, -0.13419446f, 0.17287754f, -0.02119746f, 
    -0.02339382f, -0.12385898f, -0.18351440f, -0.37411335f, -0.07455903f, -0.03702461f, -0.14656699f, 0.14532435f, 
    0.08827690f, 0.01743077f, -0.15371133f, 0.02522413f, 0.09635158f, -0.21305935f, -0.12639923f, -0.20658140f, 
    -0.21338347f, -0.10267894f, -0.21477908f, -0.20710625f, 0.07537770f, -0.16131441f, 0.82510388f, -0.21737617f, 
    0.03187910f, 0.21945380f, -0.45719337f, -0.34112850f, 0.16663577f, -0.14822626f, 0.24286263f, 0.02478510f, 
    -0.04506003f, 0.06570519f, 0.00854101f, 0.08192680f, 0.24606273f, 0.19079281f, 0.25104266f, 0.03933281f, 
    0.05310282f, -0.14495203f, 0.15525070f, -0.60431004f, -0.30567878f, -0.06637915f, 0.20912588f, -0.02453684f, 
    -0.08521578f, 0.05022632f, -0.34710526f, 0.61660904f, 0.12013828f, 0.37699392f, 0.02447912f, 0.03074781f, 
    -0.29896727f, 0.11498693f, -0.01412268f, -0.14652711f, 0.06417183f, 0.29238796f, -0.02780500f, 0.07789031f, 
    0.61017656f, 0.00893908f, -0.15289281f, -0.01431963f, -0.11965571f, 0.23779760f, -0.24768302f, -0.12829281f, 
    0.07058890f, 0.31212938f, 0.00164962f, 0.48066258f, -0.10430081f, 0.28073946f, 0.18070450f, 0.05336826f, 
    0.05981320f, 0.48583335f, -0.42738527f, 0.18658282f, -0.07108104f, -0.02450539f, -0.00644657f, -0.01198637f, 
    0.28927973f, -0.07888628f, 0.04444477f, 0.50602549f, 0.14210847f, 0.21739061f, 0.08005918f, 0.06918360f, 
    0.04689524f, 0.18248247f, 0.04357241f, -0.24195671f, 0.26454085f, -0.32885689f, 0.01037612f, 0.25710177f, 
    -0.27912486f, 0.16454473f, -0.15128449f, -0.12933400f, -0.62747037f, 0.30895233f, 0.34302109f, 0.05066526f, 
    0.03465481f, 0.16357152f, 0.03833977f, 0.03986657f, -0.17663835f, 0.07272079f, -0.38168865f, -0.03387058f, 
    0.31362173f, -0.07329680f, -0.00493788f, 0.07229748f, -0.35308295f, 0.08377744f, -0.04672352f, -0.26856226f, 
    -0.29552224f, 0.15590638f, -0.69301724f, -0.16326147f, 0.11625607f, -0.24883556f, -0.13119334f, 0.24093556f, 
    -0.15454142f, -0.13478990f, -0.12757543f, -0.46195403f, 0.21298544f, -0.45330548f, -0.07670318f, 0.19783890f, 
    -0.55599463f, 0.00501990f, 0.01274333f, 0.88936597f, 0.07264903f, -0.25916985f, -0.18700226f, -0.38258684f, 
    -0.00537666f, -0.06648584f, -0.02637446f, -0.08053094f, 0.03557001f, -0.80724972f, -0.32641819f, -0.08015328f, 
    0.33973926f, 0.08082887f, 0.02252013f, 0.02806173f, -0.06875810f, 0.05908764f, 0.03974430f, -0.09698551f, 
    0.06211361f, -0.10175188f, 0.01293671f, 0.12786418f, 0.18300670f, -0.17646687f, -0.19912323f, 0.41545808f, 
    -0.34182674f, -0.26115873f, -0.09282231f, 0.20479886f, 0.08342133f, 0.06894387f, 0.10800261f, -0.02324979f, 
    -0.18646644f, -0.28372914f, 0.14357956f, -0.08493360f, -0.01512924f, -0.44943160f, 0.28563619f, -0.02040459f, 
    -0.02852800f, 0.09045792f, -0.44846863f, -0.01874496f, -0.04724393f, 0.09667055f, 0.02998655f, 0.09767378f, 
    0.00333270f, -0.30839485f, -0.01041207f, -0.25407749f, 0.03202624f, -0.33244616f, 0.13849047f, 0.15885492f, 
    0.00479507f, -0.16283920f, -0.26697734f, -0.07459539f, 0.13158251f, -0.04493148f, -0.07446992f, -0.08314396f, 
    0.12016321f, 0.23958255f, -0.03642413f, 0.14818224f, -0.43755081f, 0.20654643f, 0.19601746f, 0.04326165f, 
    -0.04580236f, -0.05627154f, 0.19658384f, -0.11027184f, -0.25966847f, -0.06852241f, -0.01137833f, 0.54643553f, 
    0.03432326f, 0.04405665f, 0.04211965f, -0.19041866f, 0.04964242f, 0.26066497f, -0.05117070f, 0.17212293f, 
    0.05425930f, 0.02026429f, 0.16384560f, 0.03677408f, 0.02736078f, 0.05641024f, -0.09355854f, 0.12353335f, 
    0.18711373f, 0.05389670f, -0.18653750f, 0.02397826f, -0.08481260f, 0.12523635f, 0.37222493f, 0.03414929f, 
    0.05440474f, -0.07823559f, 0.13692349f, 0.19268246f, -0.03432934f, -0.30541050f, -0.13759863f, 0.15985423f, 
    -0.25889221f, -0.19237305f, 0.15837522f, 0.20645292f, 0.21425068f, 0.13688512f, 0.13517798f, 0.11821967f, 
    0.08317674f, -0.11968300f, 0.18068819f, 0.03149694f, 0.00657087f, -0.16904365f, -0.93280846f, 0.25697285f, 
    0.07184828f, 0.04559555f, 0.13350894f, 0.45007494f, 0.04717768f, -0.15876307f, -0.48595381f, 0.17046545f, 
    0.05950487f, -0.21807705f, 0.29469329f, 0.05813483f, -0.03162286f, -0.40135872f, 0.12193602f, 0.18025987f, 
    -0.04535937f, -0.16436821f, 0.02061574f, -0.20164317f, 0.17038363f, 0.28260872f, 0.03365228f, 0.24793474f, 
    -0.13380539f, 0.09666844f, 0.00510566f, 0.07557210f, 0.06373310f, 0.12238757f, -0.03792614f, 0.00047235f, 
    -0.03878289f, 0.06425397f, 0.15579067f, 0.09636791f, 0.14885122f, 0.01389800f, -0.13958383f, 0.06929353f, 
    0.43886191f, -0.08958164f, 0.04615474f, 0.11479003f, -0.08113673f, 0.25584373f, 0.06396105f, 0.08532026f, 
    0.05000559f, 0.28125748f, -0.21347496f, 0.26307017f, 0.01932436f, 0.09216475f, 0.05988433f, -0.05725637f, 
    0.21818709f, 0.19373736f, -0.04926073f, 0.12049266f, -0.02612170f, -0.05422162f, -0.03201839f, 0.06980154f, 
    0.02112994f, -0.14571683f, -0.08023585f, 0.22595035f, 0.05796288f, -0.14517140f, 0.00143463f, 0.04337212f, 
    -0.22058082f, 0.03370998f, 0.17233843f, 0.07096227f, 0.49550527f, -0.11798252f, 0.18011053f, 0.13046743f, 
    -0.37157640f, 0.07523131f, 0.27284312f, 0.12282411f, -0.36299220f, 0.23947938f, 0.26207045f, -0.06269306f, 
    0.04385593f, 0.26519063f, -0.35390395f, 0.23441377f, -0.02436990f, -0.02652778f, -0.31757313f, -0.06394134f, 
    0.02442296f, 0.06396297f, 0.05079107f, -0.04744150f, 0.02477021f, -0.20138669f, -0.18282728f, -0.02068813f, 
    -0.16804841f, -0.08815510f, -0.41513085f, -0.00806267f, -0.03707165f, -0.15300110f, -0.27764297f, 0.05663167f, 
    -0.07898368f, -0.40560755f, -0.15836757f, -0.31693634f, 0.12283375f, -0.06047809f, 0.15412576f, 0.15033118f, 
    -0.11962366f, -0.07845706f, 0.01935379f, 0.40311041f, 0.14430635f, -0.12087369f, 0.30190694f, -0.24823505f, 
    0.05320350f, 0.07510396f, 0.28374827f, 0.13742411f, 0.03628774f, -0.83024782f, -0.11985780f, 0.20371915f, 
    0.34979686f, 0.09718194f, 0.17831017f, -0.05806075f, 0.14369959f, 0.09480101f, 0.12965114f, 0.01136180f, 
    -0.15497403f, 0.07185023f, -0.10519733f, 0.42819703f, 0.17576991f, 0.08237374f, -0.16662911f, 0.23266126f, 
    -0.14217469f, -0.35949785f, 0.20369206f, 0.22462592f, 0.00644092f, -0.02739884f, 0.08425733f, -0.04270934f, 
    -0.37910578f, -0.40489274f, 0.18012914f, -0.09230676f, -0.17818686f, -0.15505567f, 0.23989408f, 0.07788183f, 
    -0.03141157f, -0.12175901f, -0.01999591f, -0.03365849f, 0.01227405f, -0.03475478f, -0.06333490f, -0.04231687f, 
    -0.07833562f, 0.01752339f, -0.11156347f, 0.00172667f, -0.08650377f, 0.04418927f, -0.04163816f, -0.02994861f, 
    -0.09149035f, 0.00630779f, -0.03579162f, -0.06960319f, -0.05969776f, -0.08108551f, 0.05880485f, 0.01022330f, 
    -0.06733805f, 0.01031572f, -0.10526225f, 0.04299777f, -0.06329867f, -0.04617325f, 0.05354615f, -0.07594094f, 
    -0.05202300f, -0.10963304f, 0.02742036f, -0.00815566f, -0.01389290f, -0.07944247f, 0.00301416f, -0.04030120f, 
    -0.06309368f, -0.00197999f, 0.00343332f, 0.00792137f, 0.04165307f, -0.04615726f, -0.06742911f, -0.09145411f, 
    -0.01824488f, 0.01562256f, -0.02718351f, 0.02333919f, -0.06485195f, -0.08722400f, -0.05000819f, 0.02398534f, 
    0.04290766f, -0.06973214f, -0.02200762f, -0.10357206f, -0.05406440f, -0.05954850f, -0.08564115f, -0.00432382f, 
    0.02646804f, -0.08248307f, 0.12031339f, -0.11915165f, 0.02228744f, -0.07058942f, 0.04541107f, -0.02374798f, 
    0.06559558f, -0.11192194f, 0.05620134f, -0.00556244f, -0.03771378f, -0.00157674f, -0.05611109f, -0.10744701f, 
    0.05979327f, 0.01526921f, 0.03496492f, -0.07726874f, 0.01197938f, -0.02474714f, 0.04733874f, -0.02927906f, 
    -0.06669642f, 0.01483759f, 0.10125656f, -0.11516042f, 0.10157882f, 0.01006992f, -0.06744365f, -0.03172428f, 
    -0.00816541f, -0.11956140f, -0.04325580f, 0.02023185f, -0.05084077f, 0.00006229f, -0.09796780f, -0.09965979f, 
    -0.07994907f, -0.02965225f, 0.03464889f, -0.06315339f, -0.02214267f, -0.11054419f, -0.02834327f, -0.04966568f, 
    -0.05021080f, 0.00974878f, -0.00247656f, -0.04552328f, -0.07244508f, -0.11584070f, -0.05423403f, 0.04294642f, 
    -0.07964429f, 0.11289784f, -0.00666069f, -0.07986895f, 0.02493280f, -0.03199487f, -0.01267223f, 0.00636406f, 
    0.19354934f, -0.27201703f, -0.17475274f, -0.28578529f, 0.07089260f, -0.02295475f, -0.07341129f, -0.21397382f, 
    0.11000314f, 0.08159884f, 0.13277377f, 0.36868817f, 0.09202779f, 0.24976490f, 0.24230962f, -0.10208543f, 
    0.02061450f, 0.11337457f, -0.36483586f, 0.09343684f, 0.02042734f, 0.00700566f, -0.01714004f, -0.56655520f, 
    0.05689450f, -0.02655130f, -0.06370887f, 0.14205989f, 0.10308314f, 0.32783359f, 0.02470030f, -0.02682592f, 
    0.28464484f, 0.17710750f, -0.01227481f, -0.19377889f, -0.94689429f, 0.10713010f, -0.36891899f, -0.55383015f, 
    0.15381780f, 0.17154674f, 0.09690698f, 0.02186540f, -0.24259245f, 0.45081460f, 0.25630522f, 0.10198666f, 
    0.04261150f, -0.37228698f, 0.07566295f, -0.01391907f, -0.02476492f, -0.04300839f, -0.00951483f, 0.25872079f, 
    0.31186640f, 0.00701921f, -0.22993852f, 0.17089657f, -0.37259179f, 0.09067456f, -0.04620408f, -0.33020091f, 
    0.52899504f, 0.10129193f, -0.57818478f, 0.18208461f, 0.05485158f, -0.30955455f, 0.04132522f, 0.04905045f, 
    -0.06166054f, -0.18227577f, -0.15349780f, -0.09143347f, 0.00167701f, -0.08598768f, -0.09767667f, -0.02145708f, 
    -0.47531888f, 0.03588627f, 0.19013621f, 0.45247161f, -0.12559366f, -0.02376776f, -0.04907698f, 0.35362673f, 
    -0.30695617f, -0.15837096f, -0.10659397f, -0.45532700f, -0.58437181f, -0.38979602f, -0.26608679f, 0.22912729f, 
    -0.14774475f, 0.10361283f, 0.24652839f, 0.05133757f, -0.06607826f, -0.38933578f, 0.06665104f, -0.02733807f, 
    0.10346572f, -0.35142040f, -0.04769298f, -0.03918429f, -0.05561118f, 0.03419698f, -0.01764914f, 0.09297058f, 
    -0.14888296f, -0.10039162f, -0.76604551f, 0.01779700f, -0.04571389f, -0.11438354f, 0.22861637f, 0.06655261f, 
    0.11373578f, -0.13860442f, 0.25886697f, -0.17490707f, -0.16178964f, -0.32091665f, 0.08796494f, -0.00452955f, 
    -0.02544757f, -0.03683946f, -0.08475090f, 0.01023853f, 0.01751811f, -0.00369073f, 0.01945310f, 0.03459196f, 
    -0.06956720f, 0.01776881f, 0.01574665f, 0.04911005f, -0.05211154f, -0.04859039f, 0.02993688f, -0.03164548f, 
    0.07354969f, 0.01760147f, -0.06578255f, -0.02862715f, 0.03595027f, -0.08505799f, 0.08457645f, -0.00324463f, 
    0.03243420f, -0.05215921f, 0.00487150f, -0.08848758f, -0.05310082f, -0.00506041f, -0.00890047f, 0.00428337f, 
    0.06575771f, -0.05524475f, 0.07165014f, -0.09329949f, 0.06725444f, -0.00391556f, 0.04935565f, -0.07725802f, 
    0.00957539f, 0.02308986f, -0.04177451f, 0.05670201f, -0.08331703f, 0.01817661f, 0.06759345f, 0.02783252f, 
    -0.03210387f, -0.10468846f, -0.07103333f, 0.01758429f, -0.10650356f, -0.08730498f, -0.05735983f, -0.03073290f, 
    0.08427582f, -0.00783128f, 0.08258475f, -0.02069859f, 0.00449224f, -0.04435868f, 0.02633191f, -0.07518462f, 
    0.04884190f, 0.04369552f, -0.06773685f, 0.04462742f, 0.01511883f, -0.01142759f, -0.06718986f, -0.04907823f, 
    0.04744713f, -0.05767659f, 0.01456471f, -0.05173304f, -0.00272825f, -0.01195164f, 0.03812482f, -0.09094926f, 
    0.00217523f, -0.02612337f, 0.01712183f, -0.05753307f, -0.10817970f, -0.06678215f, -0.07017393f, 0.08454221f, 
    0.07092611f, -0.08726756f, 0.05810073f, -0.03018723f, -0.08195790f, -0.10009525f, -0.07592946f, 0.00674606f, 
    0.05322503f, -0.05233455f, -0.02798710f, -0.08104150f, 0.06782322f, -0.09490483f, 0.03538891f, 0.04289881f, 
    -0.06493933f, -0.04412284f, -0.08174906f, -0.06657303f, 0.01409562f, -0.00644374f, 0.03482908f, 0.10620522f, 
    0.02463076f, -0.10524568f, 0.02843895f, -0.02701964f, -0.06906891f, -0.01753484f, -0.05189039f, 0.03156618f, 
    -0.09629869f, -0.07125974f, -0.04331424f, -0.07691111f, 0.01637513f, -0.07578429f, 0.05258966f, 0.05458924f, 
    -0.42834854f, 0.21668638f, -0.07646944f, 0.04560616f, -0.06918617f, -0.08552627f, 0.01092171f, 0.20922187f, 
    0.41348946f, -0.25556356f, -0.29489005f, -0.14818078f, 0.10008205f, -0.17502372f, 0.11374895f, 0.06330830f, 
    -0.20278867f, -0.27070087f, 0.24363090f, 0.03221469f, 0.25668657f, -0.10749581f, 0.04250491f, 0.13122819f, 
    -0.14751323f, 0.28153273f, 0.24547970f, 0.02676954f, -0.16465887f, 0.23312162f, -0.50697094f, 0.22396113f, 
    -0.09548632f, 0.00769272f, 0.09048251f, 0.13099162f, 0.07069432f, 0.08705560f, 0.14690779f, 0.12741034f, 
    -0.05808730f, -0.13889062f, -0.20958723f, -0.09555767f, 0.06294062f, 0.04274826f, -0.25857472f, 0.17254898f, 
    0.02150702f, 0.32312998f, 0.25641313f, 0.06888481f, -0.00086672f, -0.01168470f, 0.21326478f, -0.25141171f, 
    -0.13530666f, 0.00267901f, -0.38241646f, -0.06915726f, 0.06765944f, 0.19016422f, 0.13805130f, 0.10090552f, 
    0.22159171f, 0.04304570f, 0.36071414f, 0.20100541f, 0.04940134f, -0.64051360f, -0.07108263f, 0.19028446f, 
    -0.01993325f, 0.10228191f, 0.18442029f, 0.18490705f, 0.20470548f, -0.11760923f, 0.17578942f, 0.18096119f, 
    0.03119924f, -0.52682197f, 0.09942660f, -0.19493422f, -0.04622566f, -0.61350268f, -0.75432837f, 0.01267473f, 
    0.09824364f, -0.01392861f, 0.61434072f, 0.41080344f, 0.39909431f, 0.18927072f, -0.03722626f, 0.16262762f, 
    -0.01905365f, -0.46059212f, -0.27425268f, 0.04833549f, -0.14293686f, -0.01605969f, -0.06921399f, 0.22273833f, 
    -0.27552265f, 0.31249124f, 0.12996604f, -0.39982048f, 0.35506457f, 0.05712347f, -0.53548104f, 0.10217237f, 
    0.27492458f, 0.17217627f, 0.24725911f, -0.47291639f, -0.19919397f, -0.13915734f, 0.12097527f, 0.00747042f, 
    0.38884768f, -0.18173410f, -0.27867183f, -0.00300206f, 0.09156653f, 0.10632315f, -0.17021097f, 0.02582251f, 
    0.02953898f, -0.06037582f, 0.05736476f, 0.04521986f, -0.06801273f, -0.06127774f, -0.00443656f, -0.04362581f, 
    -0.03397087f, -0.11491469f, -0.00151271f, -0.10827445f, -0.10361424f, -0.10236272f, -0.07741988f, -0.08712734f, 
    -0.03505134f, -0.05470492f, 0.06604858f, -0.11123244f, -0.00745826f, 0.00473764f, -0.08211076f, -0.02297269f, 
    0.00686187f, -0.01235296f, -0.04006657f, -0.06380924f, -0.08968522f, -0.08896022f, 0.03752492f, 0.05219268f, 
    0.02859351f, -0.09663608f, -0.07564591f, -0.03712409f, 0.06580276f, -0.09648244f, 0.03358060f, 0.07233991f, 
    0.00880926f, -0.03431528f, 0.08106902f, -0.05905380f, -0.02411022f, -0.03626498f, 0.03224468f, 0.01142698f, 
    -0.03140525f, 0.00306559f, -0.06713365f, -0.05938191f, 0.00940739f, -0.03413102f, -0.06807858f, -0.02726345f, 
    -0.06646135f, -0.01406104f, 0.07711761f, 0.01033747f, -0.06144297f, -0.09820532f, -0.07563447f, 0.03148475f, 
    0.08834265f, 0.04906337f, 0.06637439f, -0.11505197f, 0.06574788f, 0.08562524f, -0.00142554f, 0.04206644f, 
    0.00282846f, -0.01612642f, 0.07105538f, 0.03870428f, -0.04048977f, 0.02299879f, 0.05246080f, 0.01213498f, 
    -0.00394932f, 0.01304929f, 0.05859360f, 0.04287453f, 0.04345770f, -0.07628018f, -0.02971336f, 0.07349089f, 
    0.01391476f, -0.06111823f, 0.00348159f, 0.01408192f, 0.03428803f, -0.02081114f, -0.00135603f, 0.07976796f, 
    -0.06738406f, -0.08669820f, -0.00997909f, 0.03807022f, -0.03200177f, -0.07171889f, 0.04293973f, 0.01886059f, 
    0.03745095f, -0.04324756f, -0.01626155f, 0.02159257f, 0.01349743f, -0.07802925f, 0.05242204f, -0.08567858f, 
    0.05579202f, -0.06247003f, -0.07349413f, 0.05686956f, 0.01569038f, -0.02611591f, -0.09582774f, 0.00054896f, 
    -0.08039244f, -0.04502889f, -0.04231643f, 0.04142793f, -0.00337426f, 0.04734115f, -0.08587052f, 0.00671143f, 
    0.11826864f, -0.04850925f, -0.17839468f, 0.27495942f, 0.14936613f, -0.04447910f, -0.00692515f, -0.03760208f, 
    0.01866998f, -0.06943633f, 0.26803809f, -0.37373930f, 0.02538793f, 0.07891830f, -0.20156762f, -0.06322576f, 
    0.19535887f, 0.10645434f, 0.07994804f, 0.15911458f, 0.12905596f, 0.13307922f, -0.01985593f, -0.04231823f, 
    0.14032909f, -0.15236193f, -0.02678173f, -0.12544696f, -0.00808074f, -0.00962256f, -0.11332991f, 0.26353231f, 
    0.09511030f, 0.02812091f, 0.13152868f, -0.07984584f, -0.20879300f, -0.07583792f, 0.26930863f, -0.06191129f, 
    -0.08128407f, 0.05551264f, 0.37047362f, 0.07511319f, 0.16615327f, -0.08007541f, 0.06396430f, -0.20857260f, 
    0.05009650f, -0.13924621f, -0.06189304f, 0.01144872f, 0.00410183f, 0.03039257f, 0.14730489f, 0.14381334f, 
    0.01253480f, 0.06259634f, 0.35383141f, 0.17242433f, -0.04612862f, -0.02513666f, -0.02401513f, 0.04970270f, 
    -0.58593637f, -0.00450212f, -0.17453697f, -0.15614328f, -0.12086540f, -0.47085196f, 0.06795809f, 0.03199852f, 
    -0.07980401f, 0.29022181f, -0.04565008f, 0.12783857f, -0.06206902f, -0.09656259f, -0.18682356f, -0.01994372f, 
    -0.16419148f, 0.28444907f, -0.04686712f, 0.06183505f, 0.17194712f, 0.00720838f, -0.03910556f, -0.32611766f, 
    -0.23441024f, 0.04645990f, -0.20794649f, -0.07360228f, 0.01519087f, 0.09169982f, 0.14068756f, -0.28832713f, 
    -0.17097433f, 0.22675149f, -0.11621542f, -0.07424121f, 0.11061543f, 0.35167614f, 0.12280775f, -0.19990028f, 
    0.23972405f, -0.09278429f, 0.28215271f, -0.29215911f, -0.06617641f, -0.05671627f, 0.11001027f, -0.09645538f, 
    0.01691653f, 0.17292368f, 0.00535675f, 0.16521083f, 0.08585780f, 0.33437520f, 0.03296388f, -0.07997657f, 
    0.08899067f, 0.01229414f, 0.02228620f, -0.16325369f, 0.21902828f, 0.16337062f, 0.22426252f, 0.00805266f, 
    0.03572669f, 0.01640111f, 0.03854990f, -0.31608912f, 0.03203660f, 0.05929773f, 0.03380834f, 0.11657275f, 
    0.34107301f, 0.07324948f, -0.07301981f, 0.40589905f, 0.08389381f, 0.03614394f, 0.27219850f, -0.05831212f, 
    0.10936971f, -0.03778670f, -0.24298546f, -0.04381696f, -0.50974107f, 0.01532824f, 0.05852566f, -0.19031419f, 
    0.02661338f, 0.01590806f, 0.02868412f, 0.16007020f, 0.28165609f, 0.19365954f, -0.34569085f, -0.49143198f, 
    -0.06528645f, -0.00164318f, 0.01444993f, 0.11837172f, -0.07604055f, 0.07064201f, -0.14512655f, -0.04164752f, 
    -0.09195530f, -0.19020659f, -0.10522681f, 0.45545706f, 0.22108249f, 0.34362519f, 0.27975881f, 0.12489160f, 
    -0.06193460f, -0.02185726f, 0.40787056f, 0.05237031f, 0.10983610f, -0.06650341f, -0.20415702f, 0.01770310f, 
    0.10964777f, 0.01414595f, -0.06094716f, -0.07494085f, 0.10780349f, -0.17343748f, 0.06646314f, -0.03530552f, 
    0.23429006f, 0.06818417f, -0.22866513f, 0.39350694f, 0.05270149f, -0.27532613f, 0.02838729f, -0.13063891f, 
    0.17467292f, -0.27150324f, -0.06239711f, -0.15513642f, -0.11582164f, 0.26346251f, 0.22310971f, -0.03141598f, 
    -0.30418020f, -0.04926774f, 0.08260186f, -0.06821419f, -0.07484154f, -0.21582198f, -0.51434469f, 0.56721926f, 
    0.04635210f, 0.22496180f, -0.00552840f, -0.16070637f, -0.30484894f, 0.15717374f, 0.12265319f, 0.53934473f, 
    0.08294151f, 0.06562522f, 0.12746923f, -0.07280537f, 0.16668428f, -0.33812672f, 0.01431501f, 0.16566086f, 
    -0.14478600f, -0.27084270f, -0.63148934f, 0.18784279f, -0.34328341f, 0.18208629f, 0.12314466f, 0.13946708f, 
    0.32405931f, -0.36952615f, -0.11925574f, 0.05817031f, 0.21797432f, -0.20471822f, 0.25889891f, 0.11053482f, 
    -0.07627495f, -0.30759743f, 0.14176361f, 0.07218035f, -0.25770739f, -0.04810316f, -0.01861478f, 0.06814008f, 
    -0.03081040f, 0.04375007f, -0.01780481f, -0.00294981f, -0.02238147f, -0.02524856f, -0.08181445f, 0.01336547f, 
    -0.08001112f, 0.09744794f, 0.02194386f, -0.12874685f, -0.05475715f, -0.01981980f, -0.09552675f, 0.06584595f, 
    -0.09081766f, -0.04000966f, -0.00832569f, -0.02368037f, 0.02317293f, 0.05165920f, -0.02731537f, 0.01605024f, 
    -0.00270664f, 0.04044126f, -0.09810837f, -0.06710267f, -0.00139368f, -0.05599208f, 0.03952724f, -0.05192716f, 
    -0.02051962f, -0.06507064f, -0.09350836f, -0.09993243f, 0.05654420f, -0.08498549f, -0.05863444f, 0.06015879f, 
    -0.03130825f, -0.07164397f, 0.06052893f, -0.01631360f, -0.05648775f, -0.02425199f, -0.07947084f, 0.01258334f, 
    -0.04063904f, -0.07810532f, 0.02794637f, -0.09745973f, -0.05726582f, 0.08344775f, -0.01229164f, -0.08897131f, 
    0.03563140f, -0.10490675f, 0.07106625f, -0.06732208f, -0.08130192f, -0.11360195f, 0.05821214f, -0.02677488f, 
    -0.07708625f, 0.07296409f, 0.05375668f, -0.04299926f, -0.06722845f, -0.01796713f, -0.06670619f, -0.10449597f, 
    -0.09643829f, 0.02160120f, -0.09599051f, 0.05086724f, -0.00742741f, 0.01577264f, -0.01423774f, 0.04836848f, 
    -0.06144203f, 0.01180612f, -0.12823658f, -0.07651510f, -0.01405377f, 0.03817442f, -0.05103607f, -0.02744674f, 
    -0.07861075f, -0.09416581f, -0.01985787f, 0.00591683f, 0.06832007f, -0.08435590f, -0.09289387f, -0.07765201f, 
    -0.03576311f, 0.01137133f, 0.01735991f, 0.06027741f, -0.00388897f, -0.03436963f, -0.02411689f, -0.02401731f, 
    -0.07377762f, -0.08216927f, -0.07752895f, -0.03094315f, -0.07314719f, 0.00091756f, -0.09035425f, 0.01279886f, 
    -0.11501692f, -0.10020982f, -0.09203696f, -0.01772711f, -0.11261286f, -0.08708888f, -0.00566430f, 0.05880567f, 
    -0.00611631f, 0.01950888f, -0.01783738f, -0.08531762f, -0.05822115f, -0.08870022f, -0.04309830f, -0.02670250f, 
    -0.07348026f, 0.04567936f, -0.08078895f, -0.05177040f, -0.04147866f, -0.01143087f, -0.08280630f, 0.04850528f, 
    0.03916049f, 0.02626154f, -0.05095947f, 0.02197539f, -0.10295896f, 0.00044576f, 0.02890799f, 0.02801311f, 
    -0.06046118f, -0.01866397f, -0.07667387f, 0.02220502f, -0.05717574f, 0.00432945f, 0.02136944f, -0.07944553f, 
    -0.04344146f, -0.01757861f, 0.00262827f, 0.05337155f, -0.01831342f, -0.02814120f, -0.00214022f, 0.01996643f, 
    -0.03616896f, -0.01024505f, 0.06044201f, 0.07715612f, -0.01655651f, 0.04893534f, 0.01085100f, -0.05290407f, 
    -0.01014820f, -0.06397271f, -0.07584893f, -0.07475246f, -0.04781307f, -0.03042976f, -0.03869519f, -0.11261443f, 
    -0.03658336f, 0.00890094f, -0.01143290f, 0.04130275f, -0.05682795f, -0.02655062f, 0.01589830f, 0.03548079f, 
    -0.09592810f, -0.00462108f, 0.02144729f, -0.08874872f, 0.03922213f, -0.00270992f, -0.05542014f, -0.04650329f, 
    -0.02170369f, 0.06651747f, 0.05833881f, -0.06579377f, 0.00287355f, -0.05993919f, -0.07760172f, 0.06039777f, 
    -0.03951057f, 0.06721003f, 0.01259131f, 0.00504441f, -0.00662439f, 0.05022077f, -0.04000448f, -0.09008552f, 
    0.01340635f, -0.06042779f, -0.00678472f, -0.02406523f, -0.01443673f, 0.00527074f, -0.03269934f, -0.06610198f, 
    0.05667564f, -0.02542451f, 0.05763711f, 0.03906544f, -0.04222884f, 0.02169091f, -0.02570988f, 0.08497448f, 
    -0.05554120f, 0.02127220f, -0.00088882f, -0.00782703f, -0.02458488f, 0.00969785f, -0.06060817f, -0.09307145f, 
    -0.05160870f, -0.08628903f, -0.08172487f, -0.07697970f, 0.02097792f, -0.00007222f, 0.00180824f, 0.07175361f, 
    0.01101621f, 0.02331674f, -0.03981450f, -0.08829533f, 0.06156697f, 0.05797539f, -0.02556909f, -0.03479994f, 
    -0.01830504f, 0.02462258f, -0.04556395f, 0.04618877f, 0.08018108f, 0.04279950f, 0.01806169f, -0.02694534f, 
    -0.05311731f, -0.06546617f, -0.07573318f, 0.00176091f, -0.05480952f, -0.07673774f, -0.04550706f, 0.00181676f, 
    -0.07890835f, -0.06241449f, 0.00493438f, -0.08403876f, -0.02782601f, -0.07523861f, 0.06707083f, 0.00040897f, 
    -0.05540894f, 0.02574341f, 0.05883288f, -0.05490181f, 0.02940966f, 0.02794794f, -0.06370750f, 0.02218359f, 
    0.01378740f, -0.02910906f, 0.00373560f, 0.05459290f, 0.04875305f, 0.06858989f, -0.02028465f, -0.05762975f, 
    0.00028797f, -0.09782169f, -0.08687989f, -0.06662438f, 0.03343788f, 0.02627272f, 0.06462955f, -0.06617128f, 
    0.01827249f, -0.06042376f, 0.01683932f, 0.00910146f, 0.08624902f, 0.04382374f, -0.02051034f, 0.03751750f, 
    -0.08475509f, 0.06831369f, -0.00873493f, -0.07888971f, 0.01852485f, -0.00887925f, -0.08520036f, 0.03657987f, 
    -0.09211646f, 0.02265673f, -0.06458618f, 0.03270803f, -0.05025288f, -0.01174083f, -0.04612252f, 0.07528919f, 
    0.00478184f, 0.07024999f, 0.06722148f, -0.00791496f, 0.03319706f, -0.05952318f, -0.07718933f, -0.07677893f, 
    0.00123319f, -0.03695215f, -0.07552440f, -0.02582060f, -0.00072246f, -0.06029000f, 0.03431092f, -0.04772528f, 
    -0.06838948f, -0.10002142f, -0.00844301f, 0.00484748f, -0.03149904f, -0.02952952f, -0.02830826f, -0.05989107f, 
    0.03062459f, 0.00164425f, -0.07420548f, -0.01022662f, -0.07106171f, 0.01206698f, 0.04569975f, -0.00528270f, 
    0.06566074f, 0.01981258f, 0.05279398f, -0.02731051f, -0.01137425f, -0.04703504f, -0.08157476f, -0.08632794f, 
    0.03095267f, -0.03735036f, 0.03760427f, -0.03057103f, -0.05692066f, -0.08126589f, -0.00553400f, -0.03074137f, 
    -0.01775955f, -0.00715626f, 0.02735344f, 0.00304147f, 0.02396874f, 0.06473554f, -0.08385222f, 0.00747834f, 
    -0.02643958f, -0.01708307f, 0.01500103f, -0.00695998f, 0.05832776f, 0.04558241f, -0.02695754f, 0.07955049f, 
    0.18009700f, 0.25906962f, 0.11796280f, 0.16701604f, -0.08410414f, 0.13849671f, 0.17560253f, 0.13830909f, 
    -0.04900268f, 0.05149028f, -0.07330982f, -0.00857636f, 0.11390751f, -0.08399253f, 0.06110993f, 0.14914028f, 
    0.14435227f, -0.03264297f, -0.09492838f, 0.00830508f, -0.04157260f, -0.04729661f, 0.01811787f, 0.21481963f, 
    0.21325324f, 0.06700391f, -0.09195990f, 0.08635432f, -0.11684201f, -0.19351932f, 0.12626325f, -0.21757159f, 
    -0.12116658f, 0.18946640f, 0.17440845f, 0.12812559f, -0.21758626f, -0.08301365f, 0.06237612f, -0.01110216f, 
    -0.21270891f, -0.21451308f, 0.07115780f, 0.02584280f, 0.24330355f, -0.17084579f, 0.05816309f, -0.03500934f, 
    0.03725339f, 0.00435090f, 0.08958279f, 0.06572032f, 0.05340417f, 0.00999646f, -0.07213095f, -0.02907144f, 
    0.04103721f, 0.07227141f, -0.07955626f, -0.03502684f, 0.21893197f, 0.05695074f, 0.13964689f, 0.03678703f, 
    0.23128405f, -0.02744784f, -0.16765119f, 0.12736872f, 0.23603936f, 0.09080482f, -0.08204701f, 0.03906078f, 
    0.19512713f, -0.24117830f, 0.01645066f, -0.01368389f, 0.24334472f, 0.09087684f, 0.05941312f, -0.22027397f, 
    -0.09835092f, -0.27585191f, -0.22202437f, -0.14067532f, 0.17249724f, -0.29006770f, 0.45559344f, -0.07712581f, 
    -0.01040312f, 0.15378633f, -0.68726546f, 0.19830762f, 0.01823398f, -0.10428848f, -0.03077161f, 0.08770226f, 
    0.14711307f, 0.03970735f, 0.00537178f, 0.04684013f, 0.16912058f, 0.18708014f, 0.02789716f, -0.10418569f, 
    -0.08528185f, -0.06845840f, -0.12113564f, -0.72352040f, -0.29051083f, 0.22150007f, 0.05870207f, 0.10137609f, 
    -0.24422608f, -0.11702131f, 0.08056342f, 0.06572823f, 0.08824486f, 0.20906951f, 0.18833938f, -0.04437771f, 
    -0.00761392f, 0.08447349f, -0.12509564f, 0.20910247f, -0.05411340f, 0.18601644f, 0.07278326f, -0.09291230f, 
    -0.05537975f, -0.02777710f, 0.07079208f, 0.03862549f, -0.07860366f, -0.06872318f, 0.09682482f, 0.10893286f, 
    0.17197329f, 0.06131494f, -0.03750191f, 0.13329332f, -0.19039303f, 0.02093057f, 0.13121687f, 0.00382047f, 
    -0.03077549f, 0.08597723f, 0.16724353f, -0.09862190f, -0.05886443f, -0.08821771f, 0.08477093f, -0.10432280f, 
    -0.15323934f, 0.32872370f, -0.01220390f, 0.11189112f, 0.18118930f, 0.04793928f, 0.19405268f, -0.20715685f, 
    -0.13165416f, 0.27535486f, 0.13206492f, 0.07390933f, 0.23827803f, -0.21693806f, 0.04841102f, 0.45633587f, 
    0.16243149f, -0.01599338f, 0.40644693f, 0.01323738f, -0.29527721f, -0.18187101f, 0.14159684f, 0.23135151f, 
    0.05584636f, 0.04626103f, -0.49609843f, 0.12172888f, 0.02173072f, -0.01283898f, 0.17553404f, -0.05347903f, 
    -0.10245625f, -0.02654858f, -0.38499498f, -0.07258019f, -0.13856748f, 0.24590871f, 0.11874861f, -0.18993163f, 
    -0.24289781f, 0.00445659f, -0.25285625f, -0.20558798f, 0.32507592f, 0.14013885f, 0.22673965f, -0.35867235f, 
    0.02516253f, 0.04276139f, 0.25429368f, 0.07220843f, 0.02363211f, 0.21482195f, 0.18170168f, -0.08659307f, 
    -0.10763412f, 0.21592599f, 0.04121660f, -0.07528707f, 0.09612526f, 0.16615224f, 0.79685611f, -0.06041505f, 
    -0.00139193f, 0.17790624f, -0.21007156f, 0.04679465f, 0.10366268f, 0.16291130f, 0.36419648f, 0.26178816f, 
    0.12144459f, 0.04816675f, 0.39371586f, -0.00820986f, 0.08466965f, -0.23131184f, -0.20802167f, 0.31623894f, 
    0.09485234f, 0.52012426f, -0.13962695f, 0.63068348f, -0.12650202f, 0.02010865f, 0.02043624f, -0.02869756f, 
    -0.04468427f, 0.01558155f, -0.02222035f, 0.18212779f, -0.13102907f, -0.05184973f, 0.05527513f, -0.05974756f, 
    -0.05404476f, 0.33462527f, -0.03707080f, 0.21877678f, -0.15672113f, 0.04127890f, -0.02086007f, -0.05719229f, 
    0.03202366f, 0.12665319f, 0.25749284f, -0.03065544f, -0.05877919f, -0.25256753f, 0.04631535f, 0.09219870f, 
    0.16836898f, 0.21044721f, 0.24603100f, -0.25655603f, -0.06481576f, 0.07714488f, -0.00148271f, 0.08319954f, 
    0.04180751f, 0.19616149f, 0.07481501f, 0.05300898f, -0.01729380f, 0.02014314f, -0.04627343f, -0.07758065f, 
    -0.08281702f, 0.11514138f, -0.01446381f, 0.07755708f, -0.00782610f, -0.28510407f, -0.23351283f, -0.19682559f, 
    0.10532420f, 0.30072942f, -0.17733213f, -0.09083606f, 0.72690111f, -0.25750127f, 0.00227585f, -0.21550906f, 
    0.09802053f, -0.07491145f, 0.01809057f, 0.00898645f, 0.45116830f, -0.05279921f, 0.12789439f, 0.02845242f, 
    0.03941429f, -0.13256210f, 0.06690639f, -0.19021901f, 0.09735874f, 0.06364686f, 0.11515635f, -0.04451753f, 
    0.06528072f, -0.09519500f, -0.24413191f, 0.00090004f, 0.15483572f, -0.05549608f, -0.07468995f, -0.27559793f, 
    -0.46616971f, 0.13174668f, -0.32591799f, -0.02189164f, 0.15231176f, 0.37031251f, 0.08315833f, -0.65673178f, 
    -0.09430806f, 0.01356416f, 0.06492642f, -0.07197750f, 0.05247099f, -0.10729872f, 0.08688305f, -0.20300531f, 
    -0.24265543f, 0.16542195f, -0.04167317f, -0.40413970f, 0.12561584f, 0.20613982f, 0.73777336f, -0.04603311f, 
    -0.45624205f, 0.08830020f, -0.00788394f, 0.13665240f, 0.09786741f, 0.63114673f, 0.44239706f, 0.13826589f, 
    -0.06777094f, 0.30773845f, -0.27447015f, -0.08816853f, 0.09823667f, 0.11326388f, -0.10981251f, 0.11338844f, 
    0.13986471f, 0.44172591f, -0.01323848f, -0.42566276f, -0.35359472f, 0.13926937f, -0.01700991f, -0.28594390f, 
    -0.09553722f, -0.11824490f, 0.08545434f, -0.05623897f, 0.04243254f, 0.16925704f, 0.05786388f, 0.05142500f, 
    -0.09256331f, 0.14813964f, -0.04856412f, 0.00821496f, -0.19651550f, 0.29212031f, 0.24204277f, 0.04427036f, 
    0.28438881f, 0.10415608f, 0.31280997f, -0.05676720f, -0.18208459f, 0.04348964f, 0.09055670f, -0.04607778f, 
    -0.24239574f, 0.24429297f, -0.18176624f, 0.33956996f, -0.02919367f, 0.29126152f, -0.03976455f, 0.06211513f, 
    -0.13553837f, 0.51186436f, 0.23306940f, 0.03030053f, 0.22821073f, 0.05868212f, 0.04797415f, 0.27718750f, 
    -0.04598619f, 0.20708176f, 0.07810842f, 0.06228472f, 0.02343972f, 0.00512327f, 0.04911534f, 0.29112238f, 
    -0.14400741f, 0.23933986f, 0.00928716f, 0.03322011f, 0.56488562f, -0.07666646f, 0.07179858f, -0.29611179f, 
    -0.24325576f, 0.00612255f, -0.32799304f, -0.06883933f, -0.10018088f, -0.03982029f, -0.21610291f, 0.12077802f, 
    0.01126861f, 0.28453842f, -0.27970329f, 0.00136001f, -0.05581566f, 0.04095196f, 0.18848205f, 0.04991291f, 
    -0.12781872f, -0.15115780f, -0.00602641f, -0.08650527f, 0.21912636f, 0.13160621f, -0.24662851f, 0.16057284f, 
    0.01107476f, 0.15263574f, -0.09515313f, -0.14589772f, 0.27037686f, 0.21631189f, 0.08589102f, 0.00197053f, 
    0.09525082f, 0.06357103f, 0.10981703f, 0.00977753f, 0.10573529f, -0.10760525f, 0.02044320f, 0.11512450f, 
    0.13882475f, -0.06524246f, -0.01328322f, 0.32410243f, 0.15267326f, 0.07378013f, 0.67275047f, -0.27319029f, 
    -0.01462479f, -0.08654942f, 0.47924560f, 0.21217208f, 0.20081872f, -0.25322583f, 0.14749715f, -0.20285928f, 
    0.15787044f, 0.06671835f, -0.13654976f, -0.07894298f, -0.00259902f, 0.21693680f, -0.16282800f, 0.07957138f, 
    -0.01941256f, 0.59439033f, 0.05308901f, 0.42873323f, 0.16117471f, 0.06592163f, -0.18437859f, -0.03606453f, 
    0.10106781f, -0.06331927f, 0.37250370f, -0.28942785f, -0.17257191f, -0.16393320f, -0.02812266f, -0.05477566f, 
    0.03390279f, 0.07291962f, -0.03636748f, 0.16698317f, 0.01230651f, -0.08023717f, 0.53988433f, 0.09000818f, 
    0.36691701f, 0.19922461f, -0.02746166f, 0.15087518f, -0.07563929f, 0.35870075f, 0.04702494f, -0.04586220f, 
    -0.24893698f, 0.29511538f, -0.13052505f, 0.11598793f, 0.04658636f, 0.04326295f, -0.09967209f, 0.09861185f, 
    0.19381985f, 0.24351121f, -0.16062145f, -0.00592077f, -0.03419092f, -0.06572039f, 0.05962759f, 0.18915242f, 
    0.23600955f, -0.03191772f, -0.09463955f, 0.03066675f, 0.03183612f, -0.24940781f, 0.44127852f, -0.01344491f, 
    -0.10021186f, 0.17002761f, 0.17112751f, -0.07738078f, -0.53403884f, -0.08249468f, 0.17090841f, 0.38687211f, 
    -0.18321660f, -0.08446679f, 0.02517831f, 0.09124073f, 0.02148298f, -0.02012375f, 0.12183561f, -0.05175109f, 
    -0.04561904f, 0.07790926f, 0.05149748f, 0.13814192f, 0.02407430f, -0.01039245f, -0.42505759f, -0.04422744f, 
    0.11072289f, 0.16708291f, -0.13488378f, -0.07242139f, 0.08783693f, -0.01539615f, 0.18918885f, 0.37394202f, 
    -0.18433066f, -0.04520329f, -0.12494104f, -0.00183649f, 0.33823904f, -0.05366808f, -0.26569033f, 0.23541634f, 
    0.14502952f, -0.19629547f, -0.05730655f, -0.21351823f, 0.28170246f, 0.23150253f, 0.30475757f, 0.07143919f, 
    0.02445955f, 0.05619980f, -0.02892754f, 0.22799198f, 0.20720230f, -0.20382018f, 0.67046291f, -0.30484363f, 
    0.26889911f, 0.24397220f, -0.58572280f, 0.21156345f, 0.08478010f, -0.29022309f, -0.04548681f, -0.05260810f, 
    0.28831214f, 0.08776877f, 0.08583310f, -0.01359475f, 0.24261470f, 0.13533331f, 0.04610284f, 0.05364013f, 
    0.06649176f, 0.09527010f, -0.17000124f, -0.57437003f, 0.12713338f, 0.20539695f, 0.23368628f, 0.18983293f, 
    -0.18709286f, -0.15730296f, -0.01997872f, 0.04326821f, 0.26729029f, 0.07820061f, 0.08878180f, -0.01187755f, 
    -0.30001035f, 0.02453532f, 0.11408740f, 0.24458361f, 0.05548441f, 0.02955271f, 0.18920757f, 0.05158963f, 
    -0.25740746f, 0.00700150f, 0.03876945f, 0.00746242f, 0.00660610f, 0.06153087f, 0.10135573f, 0.02866255f, 
    -0.12006490f, 0.00678136f, -0.03336819f, -0.06262390f, -0.04832030f, 0.05477150f, 0.10530967f, -0.02721724f, 
    -0.12564030f, 0.20985289f, 0.37660643f, -0.06654746f, 0.28126317f, -0.09617171f, 0.01482382f, 0.26881984f, 
    -0.19431961f, 0.21037573f, 0.27257732f, -0.02507976f, -0.05593874f, 0.30598500f, 0.09498082f, 0.21584544f, 
    -0.08638359f, 0.22733402f, 0.11662812f, 0.01863630f, 0.45818469f, 0.13087897f, 0.13011512f, 0.33287004f, 
    0.16994242f, 0.06603577f, 0.11984529f, -0.27226907f, -0.11024252f, -0.15303585f, -0.06740556f, 0.17317776f, 
    -0.04258776f, 0.15500952f, -0.40958795f, 0.02134623f, 0.07289974f, 0.06510099f, 0.47679910f, -0.17232448f, 
    -0.08369289f, -0.10258644f, -0.43859962f, -0.11494242f, 0.01697570f, 0.28277180f, 0.09782080f, 0.17172943f, 
    -0.33622563f, 0.13092911f, 0.14624582f, -0.23906854f, 0.30787304f, -0.14998479f, 0.28323427f, 0.03037579f, 
    0.10133669f, 0.36709502f, 0.32630128f, 0.18183641f, 0.19389781f, 0.06269592f, 0.07128626f, 0.20737457f, 
    0.30582103f, 0.12060270f, 0.14509204f, 0.11570204f, 0.09017785f, 0.18361685f, 0.04661398f, -0.22517180f, 
    0.08676405f, -0.06759243f, -0.34214926f, 0.25702065f, 0.38502672f, 0.09424707f, 0.26373869f, -0.00898589f, 
    0.03108713f, -0.22261408f, 0.11150770f, -0.06128769f, -0.05193424f, 0.00635243f, -0.19308989f, 0.14732020f, 
    -0.01681478f, 0.64721125f, 0.13262320f, 0.39306471f, 0.32852361f, -0.00133303f, -0.12872979f, -0.24883789f, 
    0.46610239f, 0.26073110f, 0.33418384f, -0.17046694f, -0.21776725f, 0.05237954f, -0.13595544f, 0.08027932f, 
    0.18763790f, 0.40135244f, -0.03643024f, 0.17797332f, 0.18281199f, 0.03911615f, 0.00593014f, -0.03175093f, 
    0.02314210f, -0.01969091f, -0.01851618f, -0.08689259f, 0.05739941f, -0.08453806f, -0.00043393f, -0.05734169f, 
    -0.07573613f, -0.09122375f, 0.01548483f, -0.03405372f, -0.03074709f, -0.03058571f, 0.05596401f, 0.02185608f, 
    -0.03304845f, -0.02101566f, -0.05560429f, 0.02163562f, -0.00051044f, -0.02105383f, 0.06978637f, 0.05957485f, 
    0.07045178f, 0.05032587f, -0.07943572f, 0.04973399f, 0.06798362f, 0.04247404f, -0.03818944f, -0.03703920f, 
    -0.07045854f, -0.03670228f, 0.06536284f, -0.09528544f, 0.01557094f, -0.04874958f, -0.09167243f, -0.04415980f, 
    -0.02238116f, -0.02448542f, 0.00851092f, 0.00450946f, 0.04019871f, 0.05094465f, -0.08790395f, 0.02598390f, 
    -0.03241935f, 0.04778609f, -0.10631458f, 0.00653317f, -0.10035831f, 0.05877929f, -0.00900442f, -0.01030322f, 
    0.06545778f, -0.04124875f, -0.01705602f, -0.01659153f, 0.05653236f, 0.06544918f, -0.05985286f, 0.02398226f, 
    -0.00515272f, 0.00488296f, 0.00494311f, -0.08540654f, -0.10194375f, -0.07537965f, 0.03370608f, -0.02423331f, 
    -0.05020788f, 0.04579059f, -0.07371125f, -0.03235639f, 0.05270635f, -0.02259346f, -0.06771392f, -0.06865502f, 
    0.04713904f, -0.00683359f, 0.03249716f, -0.09341509f, -0.04865770f, 0.01237292f, 0.04471182f, 0.04671280f, 
    -0.06885161f, 0.02412260f, 0.00394624f, -0.00913196f, -0.07396331f, -0.07909310f, 0.01190340f, -0.01188118f, 
    0.00659958f, -0.05694921f, -0.09628062f, 0.03384282f, -0.00619375f, 0.05043818f, 0.05682065f, -0.01280559f, 
    -0.02433642f, -0.00128045f, 0.01395143f, -0.08040094f, -0.03034260f, 0.01765880f, -0.01741244f, -0.01192163f, 
    0.00589131f, 0.00904353f, -0.01969271f, 0.05085059f, 0.01041219f, -0.04679945f, 0.04637145f, 0.03609599f, 
    -0.05385650f, -0.08463416f, 0.04248022f, -0.06493610f, 0.06807338f, 0.01101559f, -0.06778739f, 0.07865072f, 
    0.08849194f, -0.22626200f, 0.30099872f, 0.05006500f, 0.06460100f, -0.04325255f, -0.06402086f, -0.26461354f, 
    -0.15588874f, 0.20689499f, 0.31461942f, -0.28855154f, 0.12951371f, 0.22064398f, 0.06967736f, -0.06126464f, 
    0.12591287f, 0.19372998f, -0.27052116f, 0.18089978f, 0.05240548f, -0.00352478f, -0.00713699f, -0.47566804f, 
    0.01379261f, -0.15304928f, -0.06062085f, -0.11132255f, -0.28065524f, 0.27834764f, 0.09561478f, 0.01590620f, 
    0.23726495f, 0.15487395f, 0.38367689f, -0.37958604f, -0.27246875f, -0.11563357f, -0.29654133f, -0.65602756f, 
    -0.02017393f, 0.16136529f, 0.18854184f, -0.65267652f, -0.13989644f, 0.40476841f, 0.16768424f, -0.15771523f, 
    -0.00842357f, -0.35061657f, -0.26916832f, -0.11799058f, -0.27110240f, -0.08195145f, -0.26934111f, 0.11541665f, 
    0.21524867f, 0.07633524f, -0.33684021f, 0.11889248f, -0.41510314f, 0.16084795f, 0.27137622f, 0.15391800f, 
    0.44023803f, -0.08276220f, -0.13127042f, 0.13230602f, 0.23156936f, 0.00364385f, 0.21197528f, 0.04692483f, 
    -0.55760652f, 0.06518914f, -0.27021015f, -0.01158116f, 0.05948320f, -0.15415394f, -0.34942815f, 0.03181930f, 
    -0.07149967f, -0.02471753f, 0.02074332f, 0.27375427f, -0.01130265f, 0.21749556f, -0.38018438f, 0.25118631f, 
    -0.45319229f, -0.54801160f, -0.24189225f, -0.01683954f, -0.71438956f, -0.20767629f, -0.22644554f, -0.51578498f, 
    -0.61484402f, 0.21203797f, 0.21326551f, 0.07086178f, -0.27138054f, -0.23827153f, 0.09501097f, -0.63585967f, 
    0.06443886f, -0.26262107f, 0.04837573f, -0.01296146f, 0.01533184f, -0.00673448f, 0.14697228f, -0.01309333f, 
    -0.15892404f, 0.04452673f, -0.48531008f, 0.25653884f, -0.10162287f, 0.19636801f, -0.16755749f, 0.01770793f, 
    -0.00687644f, -0.06802837f, 0.18472454f, -0.28250322f, 0.04009172f, -0.14761743f, -0.00160471f, 0.02496877f, 
    -0.15067464f, 0.14589100f, 0.18633492f, 0.00237059f, 0.06558160f, -0.20209844f, -0.01519048f, 0.05467329f, 
    0.10398804f, 0.08584236f, 0.28263283f, -0.48959625f, 0.15327953f, 0.00837184f, 0.02069137f, -0.09105957f, 
    0.09003974f, -0.03545855f, 0.09475928f, -0.00155661f, 0.11732121f, 0.05305275f, 0.01600430f, -0.26285946f, 
    -0.01257834f, 0.25595471f, -0.01460237f, -0.27666140f, -0.09294368f, -0.46473950f, -0.23445719f, -0.03517828f, 
    0.15763117f, -0.07903830f, 0.12377915f, -0.24160638f, -0.15243240f, -0.01751751f, 0.00826627f, -0.19957565f, 
    0.09567539f, -0.04407901f, -0.46990073f, -0.13585214f, 0.38049307f, 0.02608631f, 0.04110822f, 0.02750512f, 
    0.02798656f, -0.14921115f, 0.24208488f, -0.04572614f, 0.02200812f, -0.10122398f, 0.07394485f, 0.16306141f, 
    -0.02182119f, 0.13089418f, -0.09572203f, 0.15552948f, -0.02461143f, 0.05750170f, 0.27754056f, -0.35425094f, 
    -0.21009970f, -0.04351118f, 0.23870897f, 0.07786883f, -0.06997363f, -0.01785163f, 0.14369473f, 0.00949612f, 
    -0.20410337f, -0.17507942f, 0.05464999f, 0.24070986f, -0.05477894f, 0.06380744f, -0.10439610f, 0.08681577f, 
    0.06208451f, 0.13797079f, -0.03604860f, -0.45657125f, 0.06279828f, 0.15680291f, -0.50170732f, 0.07240991f, 
    -0.36127675f, -0.00238209f, 0.58720046f, 0.06549171f, -0.20520723f, 0.67443228f, 0.14089645f, 0.00057170f, 
    -0.41289878f, 0.26409790f, 0.05638589f, 0.05412982f, 0.06471772f, 0.03767282f, 0.07518730f, -0.00436158f, 
    0.13194422f, 0.10821957f, 0.14110750f, 0.24993019f, -0.07568385f, 0.10468729f, -0.01418475f, 0.02437651f, 
    -0.31299889f, 0.16464360f, -0.27181619f, -0.01476961f, 0.09479140f, 0.24820071f, 0.00688725f, -0.00142780f, 
    -0.09877974f, -0.00883286f, -0.05996804f, 0.00675092f, 0.11375752f, 0.25292283f, 0.03805010f, 0.07888661f, 
    0.15337136f, 0.02582094f, -0.01230372f, -0.11863724f, 0.14031465f, 0.20679228f, 0.07344088f, -0.05276814f, 
    -0.04254096f, 0.23626897f, -0.06025603f, 0.11535112f, 0.01474217f, 0.11674793f, 0.18679859f, 0.00174271f, 
    0.22821808f, 0.00216604f, -0.22123192f, 0.14114654f, -0.02147152f, 0.07433888f, -0.03293146f, -0.13092904f, 
    0.18905626f, 0.08399321f, -0.07588788f, -0.07662989f, -0.11480233f, -0.33497733f, 0.02611043f, 0.04301023f, 
    0.12526299f, -0.13010143f, 0.10455095f, -0.09622034f, -0.40897518f, 0.01409422f, 0.03100498f, 0.04111434f, 
    -0.20622377f, -0.02136735f, -0.50864989f, 0.08136165f, 0.11494600f, 0.27199039f, 0.15071847f, -0.03659568f, 
    0.05121253f, -0.06203910f, 0.16606334f, 0.00942935f, 0.11676472f, -0.04980829f, -0.24959143f, 0.22994362f, 
    0.06700603f, 0.09070579f, 0.22216652f, 0.20149066f, 0.01866759f, 0.02004549f, 0.13782847f, 0.03878059f, 
    0.13940804f, 0.03778657f, -0.16411602f, 0.25100225f, 0.05728900f, -0.13311142f, 0.05992210f, 0.28239301f, 
    -0.18966849f, -0.40315250f, -0.08929764f, -0.11655958f, -0.08296353f, 0.08279849f, 0.14055859f, 0.21403353f, 
    0.04938188f, 0.06664842f, 0.23002258f, 0.05436371f, 0.00945935f, 0.22136797f, -0.52734315f, 0.10629364f, 
    -0.02878667f, -0.04996131f, 0.53475684f, -0.08269598f, -0.27556962f, -0.02831528f, -0.35561842f, -0.04725179f, 
    0.13638425f, 0.20346832f, 0.12353751f, 0.05742969f, 0.05641854f, -0.01165392f, 0.10439463f, 0.01499728f, 
    0.12528098f, -0.17716278f, -0.13915055f, 0.33396366f, 0.28271151f, 0.20691590f, 0.16941106f, 0.16202877f, 
    -0.39457548f, 0.01327327f, -0.32599944f, -0.10022481f, 0.13480970f, 0.01833989f, 0.07919306f, -0.01035421f, 
    -0.11872250f, -0.26302847f, 0.19917879f, -0.02411861f, 0.05394642f, -0.11892211f, 0.04536442f, -0.01673396f, 
    -0.01998146f, -0.04811474f, -0.08187629f, 0.05336679f, 0.06506950f, -0.08821491f, -0.01474090f, 0.01774458f, 
    -0.09280405f, 0.01889037f, 0.04417910f, -0.01716676f, -0.05376574f, 0.00979855f, -0.04109191f, -0.02672901f, 
    -0.00717242f, -0.03639162f, 0.00532466f, -0.06294522f, 0.08293296f, -0.03876706f, -0.02348436f, -0.04152412f, 
    0.04293127f, 0.05485662f, -0.01108734f, -0.00182336f, 0.03555360f, 0.05192585f, -0.08643392f, 0.01302870f, 
    -0.06993446f, -0.00117954f, -0.08725389f, -0.07181919f, 0.01438095f, -0.03626959f, 0.05579798f, -0.09068289f, 
    -0.00449506f, 0.01592040f, 0.02993731f, 0.02221891f, -0.06971014f, -0.05222879f, -0.00178507f, -0.00162913f, 
    0.04996055f, 0.05778208f, -0.07375850f, 0.00295094f, 0.08230606f, -0.08020964f, -0.00860087f, 0.05369215f, 
    -0.06164008f, -0.05172372f, -0.03557829f, -0.09163709f, -0.02760183f, -0.04491964f, -0.06254568f, -0.01578697f, 
    -0.03794076f, -0.07367902f, -0.02649672f, -0.02762413f, 0.06266185f, -0.08375303f, 0.00010461f, -0.07187584f, 
    -0.02318412f, -0.08817213f, -0.07508982f, 0.08122939f, -0.08218967f, 0.04697754f, -0.02886271f, -0.08487813f, 
    -0.04130643f, -0.07239796f, -0.08362027f, -0.02027364f, -0.01035810f, 0.00049147f, -0.00096873f, -0.07110100f, 
    -0.02257213f, 0.06009170f, 0.06863151f, -0.01854192f, -0.03776523f, 0.01838861f, -0.05159844f, 0.05896940f, 
    -0.07340090f, -0.00860977f, 0.01374087f, 0.06189647f, 0.01055568f, 0.01927730f, -0.04814838f, -0.05372265f, 
    0.02898042f, -0.01197629f, -0.06150811f, -0.02855369f, 0.03745141f, -0.00338839f, 0.06047339f, -0.03974961f, 
    -0.01116917f, -0.03304462f, -0.01718125f, 0.03535751f, 0.01720293f, -0.03612786f, -0.00074267f, 0.08132443f, 
    -0.01592552f, 0.00210527f, 0.05631663f, 0.07435830f, 0.07672358f, 0.08509698f, -0.07192419f, 0.07915512f, 
    -0.08999069f, -0.02941001f, -0.08653565f, -0.15370797f, 0.21622489f, -0.00716128f, 0.07562079f, -0.27541840f, 
    0.28145969f, -0.05628122f, 0.07748447f, 0.11261900f, 0.08427051f, 0.18250398f, 0.15482503f, 0.26115662f, 
    0.03456914f, -0.22832373f, 0.13371906f, 0.17314260f, -0.05688970f, -0.05573454f, 0.01869205f, -0.02399057f, 
    -0.01474900f, -0.34737286f, 0.32646698f, 0.06528848f, 0.49443057f, 0.10065020f, -0.05585771f, 0.08324841f, 
    0.15617348f, -0.12936617f, -0.00395626f, 0.29179549f, -0.32660314f, 0.04541716f, -0.26635596f, -0.13278364f, 
    0.18941553f, 0.24355665f, 0.14350545f, -0.17425528f, -0.16419218f, -0.28621146f, 0.03765141f, 0.12138905f, 
    0.03558859f, -0.02015784f, -0.12749715f, -0.04342303f, 0.09088189f, 0.00365187f, -0.09324714f, 0.11030468f, 
    0.11742721f, -0.06420743f, -0.55251187f, 0.22859038f, -0.07083030f, 0.19730413f, 0.04321654f, -0.12360261f, 
    -0.17624788f, 0.20148666f, -0.01863617f, 0.29357246f, -0.15367441f, -0.11918124f, 0.01540576f, 0.03203307f, 
    -0.46056393f, 0.17647791f, 0.11180170f, -0.04132881f, -0.19837666f, 0.01304153f, 0.26925105f, 0.16680728f, 
    0.11365005f, 0.12176747f, 0.34666881f, 0.09888696f, 0.12526806f, 0.00575571f, -0.72292399f, -0.41329849f, 
    -0.03392847f, -0.12163429f, -0.80521870f, 0.12065468f, -0.23075284f, -0.37880436f, -0.35758764f, -0.06818129f, 
    -0.10040960f, -0.11604237f, -0.05581744f, 0.06791600f, -0.12262225f, 0.01953176f, 0.10010257f, -0.08816141f, 
    0.16055194f, -0.45590338f, 0.11793122f, -0.37073976f, 0.24662697f, 0.02429721f, 0.04388629f, -0.10825775f, 
    0.32208547f, -0.00028300f, 0.05973605f, 0.04861606f, 0.07662920f, -0.14310473f, -0.17868094f, 0.04102760f, 
    0.20795789f, 0.04851954f, 0.23777102f, 0.13029788f, 0.08432749f, -0.25560600f, -0.28550068f, -0.07759003f, 
    0.30724895f, 0.16191724f, -0.01415673f, -0.41598615f, 0.06351312f, -0.12583970f, 0.01074584f, -0.26963985f, 
    0.04428444f, 0.06535343f, 0.10801964f, 0.00368068f, 0.05436019f, 0.12829123f, 0.04524055f, 0.24022704f, 
    0.18387128f, -0.11484479f, -0.28738964f, 0.21607794f, -0.33645597f, -0.00235472f, -0.03547767f, 0.07517111f, 
    0.28480396f, 0.01983337f, 0.18103494f, 0.04921295f, 0.08005798f, 0.04993426f, -0.13478872f, -0.01572442f, 
    0.18965966f, -0.03447477f, -0.23074456f, -0.09353567f, -0.15081643f, -0.06641472f, -0.17069335f, 0.19354649f, 
    -0.03852453f, 0.11392896f, -0.26068914f, -0.34553015f, 0.13096786f, -0.03982391f, 0.17144856f, 0.06457453f, 
    0.03019444f, -0.12470397f, 0.29716039f, -0.31524229f, 0.06273216f, 0.05426549f, -0.21120593f, 0.05765674f, 
    0.30289653f, 0.13940813f, -0.40466073f, 0.13824058f, -0.25999105f, 0.02407074f, -0.09126784f, 0.01590766f, 
    -0.10642231f, 0.09630938f, -0.24409977f, 0.26271927f, -0.12407986f, 0.08781885f, 0.04710108f, 0.13579570f, 
    -0.43507966f, 0.37059420f, -0.04649154f, -0.10546014f, 0.19268022f, 0.11082836f, -0.05223874f, 0.02053452f, 
    -0.15947606f, 0.49820921f, 0.18185024f, 0.20105873f, 0.01948927f, -0.14437024f, -0.01096096f, -0.37977287f, 
    -0.18906191f, -0.06260875f, 0.02991259f, 0.11540802f, -0.31942919f, 0.09660021f, -0.37893409f, -0.20327102f, 
    -0.37861758f, -0.00639779f, -0.10800032f, 0.06684099f, -0.13517743f, 0.13060386f, 0.12388422f, -0.10287202f, 
    0.09947585f, -0.07357990f, -0.02773407f, -0.46282253f, 0.27735391f, -0.06203265f, -0.01391362f, -0.01568957f, 
    0.16792938f, -0.13844424f, -0.06736007f, -0.01366579f, 0.28972435f, -0.00523867f, 0.10635717f, 0.04437328f, 
    0.42811033f, -0.21917586f, 0.33761960f, 0.04566549f, 0.15934354f, -0.12385368f, 0.04538640f, 0.05455565f, 
    -0.05506823f, -0.10434752f, 0.34374532f, -0.12276047f, 0.14653370f, 0.10464408f, 0.12509936f, -0.44430029f, 
    -0.17693391f, 0.25054833f, -0.07599620f, 0.27155343f, -0.05995407f, 0.25878325f, -0.02447885f, -0.18297160f, 
    0.18611346f, 0.02009989f, -0.10195954f, -0.29399678f, -0.04825292f, 0.04513535f, -0.05401517f, -0.19467573f, 
    -0.03336506f, -0.19909763f, -0.03843316f, -0.17314136f, 0.36573255f, 0.36146960f, 0.23274459f, 0.04891102f, 
    0.08046461f, -0.09160932f, 0.20667653f, 0.06474388f, -0.14349368f, 0.14813715f, -0.03098750f, -0.06771704f, 
    0.02745224f, 0.20814662f, -0.44204786f, 0.19702566f, -0.13822149f, 0.13280088f, 0.01361161f, 0.03647128f, 
    0.05391750f, -0.13970914f, -0.41507909f, 0.11691096f, 0.12261008f, 0.03878565f, -0.49436957f, 0.17707825f, 
    0.02552244f, 0.05263884f, 0.25166085f, 0.00237680f, 0.04291321f, -0.06272884f, -0.06545237f, 0.30482507f, 
    0.47320911f, -0.19181262f, 0.12647295f, 0.19802204f, 0.15371653f, 0.09422474f, 0.23400997f, 0.07997523f, 
    -0.00787534f, -0.10820334f, 0.00635253f, -0.03391928f, -0.38446048f, 0.17222595f, 0.24938683f, 0.20077278f, 
    0.47426945f, 0.03690600f, 0.39502436f, 0.09170344f, 0.12500976f, 0.38868111f, -0.06967176f, 0.36479092f, 
    0.23137462f, -0.02679949f, -0.37639743f, 0.08568299f, -0.11334776f, -0.51406223f, -0.28024724f, -0.01903638f, 
    0.25247657f, 0.05734096f, 0.15783960f, -0.08330972f, 0.05527810f, -0.22798637f, -0.08798718f, -0.39953771f, 
    0.07430611f, -0.10323139f, -0.17499821f, -0.15133786f, 0.45824489f, 0.32072634f, 0.13098404f, -0.28870216f, 
    -0.03492095f, -0.11781348f, -0.18499124f, 0.11249755f, 0.07410197f, -0.15954842f, -0.18968599f, 0.10233054f, 
    -0.32455778f, -0.04185142f, 0.23517849f, 0.13960998f, -0.12571265f, -0.24076508f, 0.09932930f, 0.08814450f, 
    0.12990201f, -0.12919365f, 0.03500590f, -0.13609396f, -0.04160346f, -0.02483971f, 0.02107048f, -0.23919116f, 
    0.30092540f, 0.16658470f, 0.01735565f, 0.33509877f, -0.15852119f, 0.08422568f, 0.23383217f, 0.15564957f, 
    -0.07651961f, 0.14559709f, 0.00025711f, 0.09905221f, -0.64523345f, 0.01840764f, 0.01614422f, 0.33125579f, 
    0.15967588f, 0.19955038f, 0.17865691f, 0.35361794f, 0.23727389f, 0.34224761f, 0.00125562f, 0.03195533f, 
    0.06445079f, 0.19289647f, -0.53747016f, 0.11837927f, 0.18017964f, -0.07051777f, -0.35692918f, 0.32398659f, 
    0.01568412f, -0.05924959f, -0.23800889f, -0.00763933f, -0.39683679f, 0.02282496f, 0.39912680f, 0.30021402f, 
    -0.04518233f, 0.13268334f, 0.05319832f, -0.35413468f, -0.02691549f, 0.07583957f, -0.13214768f, -0.09996498f, 
    0.16238245f, -0.10168281f, -0.49334776f, 0.01386489f, -0.35417649f, 0.11463574f, -0.31093320f, -0.24855517f, 
    -0.38081935f, 0.28089345f, -0.47938162f, 0.38834190f, 0.18760887f, 0.26872393f, 0.17585991f, -0.02080897f, 
    -0.07340268f, 0.42640686f, -0.00011849f, -0.35890117f, -0.17426337f, 0.22712527f, 0.11049828f, -0.11354718f, 
    -0.16549368f, 0.42764986f, 0.17065951f, 0.33448106f, -0.03246601f, 0.15952675f, -0.78015232f, -0.40158400f, 
    0.00224890f, -0.16832356f, -0.88151085f, 0.21744703f, 0.13194503f, -0.12211416f, -0.34274036f, 0.17287439f, 
    -0.08894106f, -0.05410501f, -0.10657039f, -0.02388423f, -0.33343720f, -0.01701116f, 0.09486855f, 0.02846242f, 
    0.11178005f, -0.38711831f, -0.14802334f, 0.24144408f, 0.07546052f, -0.11414330f, -0.14146003f, 0.12914617f, 
    0.50409371f, -0.28841650f, 0.27990499f, -0.07808010f, 0.04809120f, -0.05815159f, -0.03016156f, -0.02518599f, 
    0.31536108f, -0.20244621f, 0.28415167f, -0.06083561f, -0.04765170f, -0.64108157f, -0.03682045f, 0.03424150f, 
    0.03309521f, 0.02068155f, 0.01731277f, -0.02325543f, 0.00714358f, -0.03579362f, 0.06042890f, -0.08202649f, 
    -0.07963509f, -0.05677098f, 0.00224856f, -0.10222368f, -0.05243472f, 0.00754041f, -0.02845360f, -0.07734177f, 
    -0.08034024f, -0.00318570f, 0.01922297f, 0.03956858f, -0.02349353f, 0.04321792f, 0.00117656f, 0.00945465f, 
    -0.08277338f, 0.02522996f, -0.03759139f, -0.01322598f, -0.06335019f, 0.04654358f, -0.03144096f, 0.04256557f, 
    0.01844676f, -0.08463547f, -0.00820749f, -0.09352423f, -0.04085237f, 0.00610070f, -0.05267464f, -0.07078377f, 
    -0.08525568f, -0.06874142f, -0.08881209f, -0.07128330f, 0.05780706f, 0.07512878f, 0.00196500f, 0.02101843f, 
    0.05822051f, 0.07970812f, 0.02883338f, -0.10875184f, -0.07506606f, 0.03978652f, -0.00730032f, -0.03208768f, 
    0.01678613f, -0.06297945f, 0.03942452f, -0.03947088f, -0.10029648f, 0.04117538f, -0.02316170f, -0.11253990f, 
    0.10927157f, 0.03042387f, -0.07038754f, -0.02086847f, -0.04690471f, 0.08794898f, 0.05492724f, -0.06595648f, 
    -0.09962898f, 0.05656680f, -0.04599428f, 0.08527225f, -0.09719022f, -0.05069938f, -0.00977976f, -0.09506995f, 
    0.03555256f, -0.01697830f, 0.04102548f, 0.04881431f, 0.01401025f, 0.07309873f, -0.07115442f, 0.05977050f, 
    -0.01218706f, -0.05873779f, -0.00706778f, 0.02353410f, -0.07677869f, 0.06689974f, -0.03639982f, -0.00873838f, 
    0.01345058f, -0.02042219f, 0.07821330f, -0.04316814f, -0.00061152f, -0.09177015f, 0.01357135f, 0.06362052f, 
    -0.02098198f, -0.03766707f, 0.00053019f, -0.00383742f, -0.03934566f, -0.06393989f, -0.06250260f, 0.03754338f, 
    0.06108106f, -0.06974705f, -0.03535374f, -0.08572609f, -0.07592400f, 0.04471172f, -0.09868255f, -0.01152770f, 
    0.00175001f, -0.01340444f, -0.00205703f, 0.00800104f, -0.04784667f, -0.08342452f, -0.07621930f, 0.04523385f, 
    0.06287187f, 0.07570522f, -0.00677501f, 0.24290065f, 0.00811643f, 0.08130687f, 0.04111622f, -0.09839793f, 
    -0.15109895f, -0.03563043f, 0.24038731f, -0.03179941f, 0.16463478f, 0.02097301f, -0.00286563f, -0.25884193f, 
    0.06487158f, 0.16589978f, -0.14862792f, 0.09608000f, 0.08826447f, 0.03453147f, -0.06302544f, 0.09857225f, 
    0.24718910f, 0.02226324f, -0.08558890f, -0.08290870f, -0.34108734f, -0.06039814f, 0.07642871f, 0.15696128f, 
    0.11494868f, 0.09007319f, 0.09978789f, -0.32085082f, -0.29111859f, -0.02882652f, 0.30917850f, 0.00402866f, 
    -0.03033899f, 0.09053189f, 0.15305066f, -0.22153968f, -0.20210133f, 0.19979379f, -0.15072706f, -0.15433662f, 
    -0.05950847f, -0.00753122f, -0.18115449f, 0.16358776f, -0.07259984f, -0.04512123f, -0.07351712f, 0.06744426f, 
    0.00182789f, 0.00497994f, 0.30411714f, 0.15374120f, -0.13226347f, 0.09937910f, 0.08108412f, 0.01724937f, 
    -0.36497226f, -0.18394873f, -0.02442502f, -0.10096589f, 0.10890497f, -0.36931294f, 0.06870922f, 0.36188272f, 
    -0.24787724f, -0.00866149f, -0.17042023f, 0.08694229f, -0.00132818f, 0.24652830f, -0.10630653f, 0.19182032f, 
    0.21444480f, 0.12624823f, 0.01704739f, 0.28002170f, 0.00091337f, 0.05515045f, -0.16377109f, -0.24352251f, 
    0.01637321f, -0.18405895f, 0.31331730f, 0.10762640f, 0.01184899f, -0.07733292f, -0.15306845f, -0.26702148f, 
    -0.02346495f, 0.27876443f, 0.25346917f, 0.02914931f, 0.16549893f, 0.03579752f, 0.12236205f, -0.17504384f, 
    0.17408970f, 0.19487812f, 0.26555073f, 0.23174736f, 0.14200075f, -0.03150569f, 0.06740947f, 0.00205625f, 
    -0.13967182f, 0.12882823f, -0.05522256f, 0.10380991f, 0.01556221f, 0.27780056f, -0.05054355f, 0.04055457f, 
    -0.07527723f, -0.03055184f, 0.00241191f, -0.12376159f, 0.23344266f, -0.06220473f, 0.15095986f, -0.02804413f, 
    -0.11605313f, -0.12774374f, 0.11514551f, -0.07429936f, 0.03005532f, 0.16737217f, -0.10851569f, 0.05919681f, 
    0.12007857f, -0.12882754f, -0.15601128f, 0.18719558f, 0.08030410f, -0.11967006f, 0.21950503f, -0.11446863f, 
    -0.10378817f, -0.08380417f, -0.16669422f, -0.25185102f, 0.02914759f, -0.00627202f, -0.04687325f, -0.17663343f, 
    -0.01400214f, 0.12663022f, 0.06616453f, -0.05129656f, -0.06838603f, 0.37317887f, 0.16509207f, -0.18242811f, 
    0.00618897f, -0.17396386f, 0.18911129f, -0.12668677f, -0.54712856f, 0.06167750f, -0.04065127f, 0.29137096f, 
    0.12529272f, -0.09982305f, 0.02472036f, 0.13178384f, -0.33763051f, 0.25692940f, -0.06865612f, 0.17124020f, 
    -0.06755483f, 0.12715416f, -0.13223547f, 0.07127526f, 0.07362214f, 0.08544762f, -0.06868585f, -0.05647101f, 
    0.06302001f, 0.05763091f, -0.26264447f, -0.04350806f, 0.00774615f, 0.01655953f, 0.25434396f, 0.03058463f, 
    0.42776000f, -0.09118216f, 0.29083750f, -0.01539628f, 0.01754248f, -0.29159424f, 0.19736853f, 0.06272619f, 
    0.17222480f, -0.20570260f, 0.11879192f, 0.05186460f, -0.08128143f, 0.40532291f, 0.22580498f, 0.26924747f, 
    0.39601958f, 0.07698534f, 0.06937748f, -0.15838145f, -0.12149367f, 0.36155048f, -0.12727961f, 0.20878370f, 
    0.30648074f, 0.13237818f, -0.17840959f, 0.13933899f, 0.12217468f, -0.24609883f, -0.37475774f, 0.20949127f, 
    0.20976941f, -0.32095763f, 0.37207916f, 0.07699009f, 0.15796320f, -0.53092211f, -0.12399851f, 0.00467844f, 
    -0.08285785f, -0.01786406f, -0.15586723f, 0.15181638f, 0.25781736f, 0.08504605f, 0.22529569f, 0.06729043f, 
    -0.18516067f, 0.01610871f, -0.13202278f, 0.23718186f, -0.01789981f, -0.08863176f, -0.05007289f, -0.06536458f, 
    -0.13581589f, 0.02385098f, 0.17402385f, 0.07172818f, -0.11701751f, -0.32145768f, -0.15777045f, 0.00938280f, 
    0.35203183f, 0.14066748f, 0.16094245f, 0.23316526f, 0.00464041f, 0.04175302f, -0.00070243f, -0.08830514f, 
    -0.06096705f, 0.23681271f, 0.21152468f, -0.02729208f, 0.02490189f, 0.28191337f, -0.16998351f, 0.16923362f, 
    0.23902312f, 0.18202221f, 0.06612305f, 0.24546395f, 0.01583034f, -0.01770614f, -0.00251685f, 0.15263490f, 
    0.16800179f, 0.00115728f, -0.03535949f, -0.11799000f, 0.18597379f, -0.26180404f, -0.23044237f, 0.29480311f, 
    0.00430041f, 0.07805075f, -0.23797825f, 0.15009506f, -0.08938846f, -0.06027765f, 0.18303578f, -0.02968398f, 
    -0.19048487f, 0.03968145f, 0.01158215f, -0.12736014f, 0.09383602f, -0.15797538f, 0.15590163f, -0.12668271f, 
    -0.04588342f, 0.03138675f, 0.03030888f, -0.04659975f, 0.06240710f, -0.08941303f, -0.08951046f, 0.06529464f, 
    0.03971719f, 0.05145337f, 0.31839681f, 0.19359580f, 0.05730741f, 0.00550031f, -0.26814991f, -0.03881097f, 
    -0.29244703f, 0.06047846f, -0.33456102f, -0.02192553f, -0.02888796f, 0.17522652f, 0.09298239f, -0.00741483f, 
    -0.12029902f, 0.40177381f, -0.09038943f, -0.17013235f, -0.02592421f, -0.44438210f, -0.06088573f, -0.00872657f, 
    -0.07237896f, 0.21906817f, 0.04803098f, 0.20413899f, 0.19626223f, -0.15284958f, 0.92825425f, -0.11084842f, 
    -0.02081540f, -0.04845407f, 0.05152361f, -0.14622010f, 0.03175238f, 0.06353556f, -0.03573315f, -0.23396294f, 
    0.01008585f, 0.38799283f, -0.61963385f, 0.03346879f, 0.04567176f, 0.50911641f, 0.17832114f, -0.06836668f, 
    0.15850596f, 0.04092174f, 0.15689786f, 0.07188817f, -0.09956771f, 0.04454001f, -0.11666833f, 0.02083179f, 
    0.02283329f, -0.13332382f, 0.07661682f, -0.00012990f, 0.14617710f, 0.24218924f, 0.04597174f, 0.04980178f, 
    0.14992118f, -0.37010822f, 0.09345432f, -0.16628718f, 0.14669473f, 0.13403140f, 0.37051991f, -0.02903585f, 
    0.50746191f, 0.00187673f, 0.16096976f, 0.26204354f, -0.02187871f, 0.15172014f, 0.13495755f, -0.05225008f, 
    -0.16000979f, 0.40939701f, -0.09646506f, 0.28793669f, -0.06313883f, 0.36526337f, -0.02009798f, 0.05383494f, 
    0.22854476f, 0.35282725f, -0.05175101f, 0.18897572f, -0.02062587f, -0.06864256f, -0.04193414f, 0.00805346f, 
    0.02875910f, -0.00760242f, 0.05728083f, 0.18866061f, 0.26403221f, -0.29745233f, 0.07294970f, 0.19646610f, 
    0.11377264f, 0.07959003f, -0.17474960f, 0.07538711f, -0.03608667f, -0.07032933f, 0.24995019f, -0.28797239f, 
    -0.26066199f, 0.09605125f, -0.04383361f, 0.07778353f, -0.14715086f, 0.21293548f, 0.19472413f, 0.03062527f, 
    0.07221181f, -0.03956094f, 0.05146967f, 0.16663729f, -0.10362251f, -0.00473869f, -0.34892163f, 0.10358684f, 
    0.05271673f, 0.11316004f, 0.02821152f, 0.11366352f, 0.08503300f, -0.06579771f, -0.10045239f, 0.13704115f, 
    0.24651043f, 0.09959888f, -0.21585307f, 0.10837924f, 0.05506781f, 0.25536901f, -0.06153899f, 0.15703933f, 
    0.16031389f, -0.12457848f, -0.05972345f, -0.20726953f, -0.08077770f, -0.22305994f, 0.05936227f, 0.12625095f, 
    -0.04438885f, -0.03497079f, 0.01196530f, 0.68920255f, 0.22859214f, -0.04887539f, 0.41604879f, -0.10254265f, 
    0.13608220f, 0.04342944f, 0.47110999f, -0.34347355f, -0.17651412f, -0.53625667f, -0.06506180f, -0.03346106f, 
    0.13978632f, 0.18163845f, -0.16904280f, 0.00907123f, 0.04664873f, 0.25033709f, 0.15096487f, -0.07922948f, 
    0.08515280f, -0.04445599f, 0.11363959f, -0.06047051f, 0.05213694f, 0.07686771f, 0.06649683f, 0.24649291f, 
    -0.09348936f, -0.20087180f, -0.07574010f, -0.04747794f, 0.10468126f, -0.01347498f, 0.00095018f, 0.04079205f, 
    -0.21288161f, -0.34215939f, 0.09009683f, -0.06057811f, -0.11812717f, -0.12719195f, 0.38885602f, 0.02999744f, 
    0.08205266f, -0.08819669f, -0.08043047f, -0.04294881f, 0.01249664f, -0.02490862f, 0.01283962f, -0.01382012f, 
    -0.06630817f, -0.01520847f, 0.04649793f, 0.03798807f, 0.05444497f, -0.01037740f, -0.03512362f, 0.03258321f, 
    -0.04941108f, -0.03429663f, -0.08498321f, -0.04323758f, 0.05538653f, -0.03044743f, -0.03247450f, 0.04409340f, 
    -0.01667206f, -0.06595147f, 0.06888337f, 0.06727817f, 0.06290358f, -0.06708130f, 0.00805127f, 0.02334972f, 
    -0.08116381f, -0.03530011f, -0.06374073f, -0.08239727f, 0.03853111f, -0.05163325f, 0.06713698f, 0.00112796f, 
    -0.07821597f, 0.04805077f, -0.03321136f, -0.05929806f, 0.08711114f, 0.02556092f, 0.02739150f, 0.03639740f, 
    0.01008843f, 0.05474081f, -0.05504042f, -0.07462365f, 0.04149884f, 0.00437625f, 0.02282487f, 0.08498775f, 
    -0.07306551f, -0.04324147f, 0.01924494f, -0.06372774f, -0.07761659f, 0.02298121f, -0.01084280f, -0.02804974f, 
    0.05731433f, 0.03528156f, 0.07261391f, -0.08354671f, 0.06408072f, 0.03203232f, 0.02699440f, -0.08543898f, 
    0.08727083f, -0.06355386f, -0.07779065f, -0.05805120f, -0.03029070f, -0.01815334f, -0.02833245f, 0.02609208f, 
    -0.03585640f, -0.00850170f, 0.01463906f, -0.05297472f, -0.07383490f, 0.00000681f, 0.02633377f, -0.04513658f, 
    -0.08510204f, -0.02143913f, 0.01297410f, -0.02430986f, -0.06129500f, 0.08343098f, -0.04357197f, 0.02661335f, 
    -0.00518928f, -0.04873337f, -0.06994728f, -0.01055263f, 0.01859977f, 0.02754123f, -0.08161714f, 0.06740512f, 
    0.01246770f, -0.07682193f, 0.00255403f, -0.03948558f, -0.04700641f, 0.05651608f, 0.04450289f, -0.05524943f, 
    -0.00148132f, -0.05548560f, 0.07193020f, -0.05188128f, -0.01308021f, 0.08246582f, 0.00246141f, 0.02457915f, 
    -0.02824295f, -0.08247467f, -0.03905130f, -0.04883099f, 0.06606321f, 0.02212602f, -0.03477888f, -0.04277718f, 
    -0.23135282f, 0.11022307f, -0.11025455f, 0.13922215f, 0.06452776f, 0.08132950f, -0.10878041f, 0.05889740f, 
    -0.15066725f, -0.08211914f, 0.21823403f, -0.16911002f, 0.06940214f, -0.09121082f, 0.03799267f, -0.01654508f, 
    0.01416493f, 0.11064076f, 0.20084915f, -0.03159355f, 0.15909816f, -0.00088268f, -0.01506453f, 0.17999706f, 
    0.11772005f, 0.03844098f, 0.13682196f, -0.16047466f, -0.18711917f, 0.34488794f, 0.18508492f, 0.14793167f, 
    -0.04838305f, 0.27393124f, 0.12547067f, -0.00306417f, -0.32300895f, 0.14682524f, 0.07268152f, 0.10954832f, 
    0.03263705f, 0.00542165f, 0.14366212f, -0.07351357f, 0.11761774f, -0.07447084f, -0.21313368f, 0.00311658f, 
    -0.08429745f, 0.17433333f, -0.26919341f, 0.07131864f, -0.00136014f, 0.07509241f, 0.30170670f, 0.01609329f, 
    -0.22678338f, 0.08703452f, 0.17184542f, -0.05516468f, 0.10427437f, 0.16906564f, 0.11047192f, 0.17302255f, 
    -0.22963318f, 0.06994444f, 0.28235799f, -0.20634052f, 0.30218399f, -0.06408043f, 0.07964144f, 0.10134551f, 
    0.07938202f, 0.32204023f, 0.14404392f, 0.23091386f, 0.11289370f, 0.28813753f, -0.05229869f, 0.05223186f, 
    0.14812185f, -0.02564969f, -0.05223755f, -0.38895151f, 0.09328968f, 0.15807296f, -0.24002552f, -0.25285175f, 
    0.10164507f, 0.06750572f, -0.55378449f, 0.33873871f, 0.19026969f, 0.25325254f, 0.14729996f, -0.13133810f, 
    -0.16425224f, 0.10307097f, 0.07000957f, -0.03142432f, 0.02906401f, -0.07214508f, 0.03309571f, -0.03762608f, 
    0.12174644f, 0.16549776f, 0.23603757f, -0.19148840f, 0.03744969f, -0.08812863f, 0.01055943f, -0.22837253f, 
    0.13786633f, 0.29632184f, 0.43354201f, 0.04934648f, -0.10544863f, 0.14971708f, -0.09797043f, -0.01361265f, 
    0.12964493f, 0.43578401f, -0.25095421f, 0.08924321f, 0.21933417f, 0.19725931f, 0.13084054f, 0.11864723f, 
    0.33242732f, 0.01010483f, -0.05280546f, 0.04603300f, 0.14504251f, -0.08160629f, -0.24695577f, 0.03630676f, 
    0.23837310f, 0.10887060f, 0.14695907f, 0.09690708f, 0.16733672f, 0.30413929f, 0.15499091f, 0.07647839f, 
    -0.00345794f, 0.33578122f, -0.14053433f, 0.19885547f, 0.03606640f, 0.10648029f, -0.04435130f, -0.06616315f, 
    -0.04454676f, -0.05910610f, 0.03022215f, 0.25832200f, 0.17484950f, -0.23442793f, -0.05174597f, 0.02873173f, 
    0.20810276f, 0.24061950f, -0.02358819f, -0.15422803f, -0.13605064f, -0.08379942f, -0.02347866f, -0.58061051f, 
    0.15452528f, 0.25819653f, 0.07603096f, 0.12785354f, -0.07306486f, 0.19234438f, 0.17205536f, 0.09615786f, 
    -0.06798377f, -0.00770121f, 0.33660254f, 0.00618199f, 0.02986768f, 0.02446804f, 0.14107445f, 0.03795410f, 
    0.13270094f, -0.11398706f, 0.41400862f, 0.14181708f, -0.15988457f, -0.04796344f, 0.02345471f, -0.46881923f, 
    0.06800833f, 0.15395093f, 0.03396461f, -0.00016399f, -0.11579595f, 0.22651613f, 0.04302495f, -0.01240530f, 
    0.01116928f, -0.18919988f, 0.03160279f, 0.05333838f, 0.05238138f, -0.39733824f, -0.19307482f, -0.06524114f, 
    -0.43495291f, -0.09042659f, 0.05603950f, 0.40363279f, -0.03864661f, -0.03385549f, 0.37337655f, 0.11011533f, 
    -0.07486217f, -0.03572622f, 0.34893453f, -0.64327502f, -0.30990419f, -0.02862815f, -0.08745004f, 0.12039607f, 
    -0.05272499f, 0.17789368f, 0.16686881f, 0.03475323f, -0.08241816f, 0.14548738f, 0.10515071f, 0.10976233f, 
    -0.02927075f, -0.04208304f, 0.16323583f, 0.25741440f, -0.26889148f, -0.15449753f, -0.10228115f, 0.62298000f, 
    -0.32672173f, -0.01855560f, -0.50147593f, 0.05930987f, 0.03312100f, 0.09833592f, 0.11875520f, 0.03183315f, 
    -0.04980923f, -0.01851543f, 0.04489640f, -0.08478637f, 0.00694283f, -0.04208895f, 0.34105510f, -0.01112222f, 
    0.02234428f, 0.11968880f, 0.06509697f, 0.02654050f, 0.11493347f, 0.08339304f, -0.09150839f, 0.00378990f, 
    0.06385394f, -0.06487432f, 0.19366175f, 0.26427019f, 0.16776592f, -0.02113490f, 0.18766329f, -0.20351817f, 
    0.16754277f, -0.13671169f, -0.27363211f, -0.11962235f, 0.03316018f, 0.03066419f, 0.02975946f, -0.28448835f, 
    0.08052367f, -0.11903303f, -0.06817846f, 0.00657059f, 0.08152360f, 0.09380620f, -0.06079874f, -0.07641554f, 
    0.17818214f, -0.15210657f, 0.22298011f, -0.11247998f, -0.03385881f, 0.11149244f, -0.06238155f, -0.18727839f, 
    0.01453594f, 0.00908961f, 0.13784675f, 0.33575177f, 0.01731294f, 0.24347427f, 0.03226521f, 0.00687577f, 
    0.07601544f, -0.18510994f, 0.13633257f, 0.08165891f, 0.07513509f, 0.04892640f, -0.05450869f, 0.19117184f, 
    0.06819630f, 0.06714308f, 0.38333344f, 0.09124606f, 0.04131768f, -0.16357833f, 0.03353119f, -0.15277272f, 
    -0.26704273f, -0.04258432f, -0.02670314f, 0.13072677f, -0.29612315f, -0.36536136f, 0.06289876f, 0.14717320f, 
    0.06309240f, -0.26731533f, -0.16679929f, 0.07129397f, -0.11024484f, 0.04202065f, -0.08110293f, 0.03252121f, 
    -0.18542497f, -0.08875762f, 0.10312569f, -0.09063627f, -0.12132450f, 0.21068069f, -0.34460434f, 0.18684776f, 
    -0.12636296f, 0.04734975f, 0.08209539f, -0.16237269f, -0.27179670f, -0.10245150f, -0.09705089f, 0.04498136f, 
    -0.03356148f, 0.15810774f, 0.32036525f, -0.05942117f, 0.14863624f, -0.26436615f, 0.13803041f, -0.03244869f, 
    0.02663146f, -0.28938851f, -0.10755207f, 0.39864528f, -0.21118933f, 0.13943982f, 0.19793281f, -0.04122864f, 
    -0.21598761f, 0.07666238f, -0.19632356f, 0.23964995f, 0.14791030f, 0.01332349f, 0.18823357f, 0.01854678f, 
    -0.29750180f, -0.12605846f, 0.11102151f, -0.19958109f, 0.09330530f, -0.01836306f, -0.14763269f, -0.00114699f, 
    -0.09825930f, 0.01701387f, -0.00722579f, 0.03735406f, 0.00393945f, -0.09735157f, -0.08935536f, 0.00210555f, 
    -0.01693996f, -0.00196093f, -0.08235229f, 0.04489617f, -0.09388284f, -0.09041067f, -0.02465357f, -0.06814601f, 
    -0.03987600f, 0.01455781f, -0.06957190f, 0.00888055f, -0.00863719f, 0.01150768f, 0.03035922f, -0.01397561f, 
    -0.00997345f, 0.03320839f, 0.00993878f, 0.05883201f, -0.03648144f, -0.05365053f, 0.02515923f, 0.07088546f, 
    0.04004465f, -0.10316509f, 0.06093479f, -0.05981476f, -0.05744997f, -0.02539643f, 0.03941875f, 0.02718631f, 
    -0.03949756f, 0.00042486f, -0.06873394f, 0.03963246f, 0.03180747f, -0.11005708f, 0.01849044f, 0.01793022f, 
    -0.08068578f, -0.05579600f, -0.11054283f, -0.06304558f, -0.11155845f, 0.07954922f, -0.06292343f, -0.09028982f, 
    0.02065476f, -0.07025475f, 0.02000286f, -0.10129435f, -0.01229298f, -0.09557041f, -0.09332220f, -0.00455194f, 
    0.08418992f, 0.00322751f, -0.01012492f, -0.09449212f, -0.00574982f, -0.07463577f, -0.10553446f, -0.09826723f, 
    -0.03086372f, 0.01190187f, 0.04478381f, 0.03779238f, -0.03101279f, 0.03482119f, -0.04641047f, 0.00257997f, 
    -0.03166270f, 0.00968186f, 0.06151687f, -0.04257936f, -0.06330150f, -0.05947601f, -0.01503431f, 0.06723059f, 
    -0.05980519f, 0.00105337f, 0.07116342f, -0.05747791f, -0.10789103f, -0.01772213f, -0.05211594f, 0.01388970f, 
    0.01948368f, 0.05273886f, -0.10968062f, 0.03141049f, -0.09726484f, -0.06705309f, -0.10611729f, 0.00048184f, 
    -0.01378748f, -0.07681634f, 0.05292033f, -0.05713094f, -0.07561760f, 0.03533400f, 0.00376645f, -0.00800409f, 
    0.03470581f, -0.06393217f, 0.02632170f, 0.00307982f, -0.01462248f, -0.00686825f, -0.02562315f, -0.00156204f, 
    -0.05614346f, -0.02974889f, -0.03495651f, -0.01408650f, -0.03349610f, 0.01250448f, 0.07974663f, 0.06516440f, 
    0.49774599f, 0.04709068f, 0.05318912f, -0.11960268f, 0.11833020f, 0.03317899f, 0.00340722f, -0.10197100f, 
    0.34729269f, 0.18492542f, 0.10771086f, 0.38407636f, 0.07833830f, 0.18811101f, 0.13988708f, -0.04053554f, 
    0.07843679f, 0.16130002f, -0.20450191f, 0.06528062f, -0.22181229f, 0.02710713f, 0.06493366f, -0.10995378f, 
    0.24594823f, -0.32481509f, -0.13878292f, 0.11466881f, 0.09230559f, -0.30239427f, 0.04172479f, -0.26792824f, 
    0.22529447f, 0.17563710f, -0.15075502f, -0.14772309f, -0.30282369f, 0.10042669f, -0.07969758f, -1.06030869f, 
    0.00886447f, -0.16207099f, -0.41523305f, 0.48976770f, 0.31227720f, 0.36591989f, 0.29742751f, 0.11394329f, 
    -0.03815522f, -0.21758437f, 0.52212310f, -0.09853623f, -0.01876262f, -0.03419239f, -0.01506380f, 0.20139916f, 
    0.14360562f, 0.03195393f, 0.51524884f, 0.09319359f, 0.06532968f, -0.10995262f, -0.00062285f, -0.16956754f, 
    -0.36767384f, 0.12263591f, -0.07035343f, 0.23282897f, -0.10507642f, -0.08477037f, -0.00900584f, -0.03706810f, 
    0.28662997f, -0.45387173f, -0.07105190f, -0.19761084f, -0.15016185f, -0.03317305f, -0.09346938f, -0.20260628f, 
    -0.36635807f, -0.06307409f, -0.02855739f, 0.14025280f, -0.00362338f, -0.07046997f, -0.32122666f, -0.03904589f, 
    -0.17774357f, 0.15766484f, -0.20564906f, -0.13542913f, -0.29583824f, 0.02662160f, 0.06610123f, 0.08429895f, 
    0.10366338f, 0.22609070f, 0.11307943f, 0.01312753f, 0.21201666f, -0.01547704f, 0.16827299f, -0.02418272f, 
    0.19739968f, -0.40532798f, -0.07653936f, 0.00027775f, -0.47953960f, -0.03456945f, 0.23543692f, 0.23512155f, 
    -0.39120069f, -0.12788916f, -0.18490064f, -0.01745470f, 0.23622417f, 0.04605135f, 0.30785269f, -0.07287720f, 
    -0.22413497f, -0.13830349f, 0.00740589f, -0.05985489f, -0.14264029f, -0.08721794f, 0.20079832f, 0.04130028f, 
    0.17708719f, -0.18004555f, -0.20170957f, 0.13425948f, 0.03656008f, 0.27101675f, -0.08166017f, -0.06784678f, 
    0.04815792f, 0.06773204f, 0.04568999f, 0.21743913f, 0.16967332f, 0.08942849f, 0.09224672f, -0.08999071f, 
    -0.05909770f, 0.14014852f, 0.09783544f, -0.04807853f, 0.18632273f, -0.00655168f, 0.07113793f, 0.03569802f, 
    0.05258784f, -0.20030722f, 0.22316623f, 0.20358337f, 0.15659226f, -0.08495338f, 0.34311426f, 0.20638782f, 
    -0.00181942f, 0.13747017f, 0.13549432f, 0.12832412f, 0.44499856f, -0.01414945f, -0.05798274f, -0.27976584f, 
    0.02156494f, 0.29292259f, 0.09744886f, -0.22188517f, -0.45901084f, -0.37662968f, 0.08503349f, 0.21668239f, 
    0.04401944f, 0.12069687f, -0.33719465f, 0.13553171f, 0.08770942f, 0.00996041f, 0.00417010f, 0.06879337f, 
    -0.00526060f, -0.00668450f, -0.31167719f, 0.09941713f, -0.15566190f, 0.16213340f, 0.03438157f, -0.36616465f, 
    -0.08418889f, 0.01972919f, -0.17576857f, -0.18036616f, 0.08737041f, -0.28108931f, 0.08808521f, 0.08404868f, 
    -0.18520658f, 0.05126952f, 0.17217429f, 0.14554939f, 0.00355830f, -0.29320195f, 0.02101317f, 0.16339396f, 
    -0.14422241f, -0.08437005f, 0.24577600f, 0.29711109f, 0.05190037f, -0.16894408f, 0.05104072f, -0.32379577f, 
    -0.00086719f, -0.04844302f, -0.19580565f, -0.22893748f, -0.02543779f, -0.61129624f, -0.28969172f, -0.06494045f, 
    0.28479302f, 0.11167303f, 0.14142899f, 0.00612926f, 0.02455858f, 0.07359108f, 0.14584726f, -0.11173958f, 
    0.09409921f, 0.23620413f, 0.20757404f, -0.13666219f, 0.28918016f, -0.22497240f, 0.11504612f, -0.04975123f, 
    0.04544533f, 0.02823951f, -0.05697712f, 0.23799592f, -0.12869228f, 0.02905231f, 0.01836201f, 0.04539398f, 
    -0.17602880f, 0.23257506f, 0.10006570f, 0.15606581f, 0.14938213f, -0.30351067f, 0.04547597f, 0.02856158f, 
    -0.20092407f, 0.13132580f, 0.13898258f, -0.08330334f, 0.06064484f, -0.04231110f, 0.10614390f, -0.00173054f, 
    0.10954457f, -0.05603438f, -0.06239834f, -0.12535858f, 0.02596620f, -0.00139207f, 0.07810757f, 0.06819320f, 
    0.18812968f, -0.27748933f, -0.02139852f, 0.11041208f, -0.19267282f, 0.01401831f, 0.02734496f, -0.03597728f, 
    0.11182393f, 0.21724992f, -0.06983120f, 0.03054869f, 0.09063294f, 0.10592823f, -0.10178053f, -0.11281103f, 
    0.12685633f, -0.03954640f, 0.00177605f, 0.14044449f, -0.11880911f, 0.15426272f, 0.01555592f, 0.27429041f, 
    0.03054982f, -0.11015349f, 0.07756568f, 0.14162646f, 0.17809115f, 0.10129600f, 0.12181171f, 0.12689276f, 
    -0.05942288f, -0.07018661f, -0.02754642f, -0.07821196f, 0.08197576f, -0.05707051f, -0.04923293f, 0.02410806f, 
    0.02277803f, 0.16372789f, -0.26462299f, -0.02458881f, 0.15447789f, -0.10042827f, 0.19524862f, -0.07774461f, 
    0.28108522f, -0.06242765f, 0.04016451f, 0.27349338f, -0.08543057f, 0.08767524f, 0.08234660f, 0.05876603f, 
    -0.01257145f, -0.11290433f, -0.02354578f, 0.11438005f, -0.07908031f, 0.18064018f, 0.15451746f, -0.01019463f, 
    -0.01260273f, -0.16398576f, 0.02860262f, -0.24639441f, 0.09087655f, 0.27645370f, -0.67645603f, 0.51900315f, 
    0.05953044f, 0.10957301f, -0.32617316f, 0.20663747f, 0.13643022f, 0.32461905f, 0.01688608f, 0.27395949f, 
    -0.07384922f, -0.07863887f, 0.02001378f, -0.08297585f, 0.04700593f, -0.29023963f, 0.05840387f, 0.21689969f, 
    -0.00851197f, -0.19417357f, -0.05910405f, -0.07369791f, 0.05218230f, 0.36666897f, 0.21505179f, -0.03128631f, 
    0.01899468f, -0.06004895f, -0.10188349f, 0.13572162f, 0.18771859f, 0.11123922f, 0.08725750f, 0.00108253f, 
    0.02950151f, -0.12593783f, 0.02040486f, 0.01509430f, -0.14283831f, 0.11868783f, -0.35274625f, -0.06185359f, 
    -0.04820222f, 0.04188683f, -0.02847702f, -0.02142726f, -0.05648473f, -0.02249379f, 0.06863952f, -0.04589870f, 
    0.00305344f, 0.06309830f, -0.05335437f, -0.01432843f, -0.04690639f, 0.01497187f, 0.05023410f, -0.09497330f, 
    -0.01587567f, -0.07617231f, 0.06275538f, -0.05619892f, 0.03526899f, 0.07075725f, -0.00759852f, -0.03169004f, 
    0.04818527f, -0.03012916f, -0.01074966f, -0.00189792f, -0.06046352f, -0.01431984f, 0.05621027f, 0.03211366f, 
    -0.08232883f, -0.07131471f, 0.00733373f, 0.05755027f, 0.02806726f, -0.09864344f, -0.08223756f, 0.02706574f, 
    0.05667829f, 0.03004051f, 0.00442118f, -0.00086809f, 0.06199067f, -0.06553588f, 0.02155820f, 0.03118062f, 
    0.01380176f, 0.05508139f, -0.08731013f, -0.09248444f, -0.08992214f, -0.05240105f, -0.10198260f, -0.05009706f, 
    0.03779756f, -0.09464338f, -0.08538189f, 0.02770163f, -0.08832460f, 0.04251884f, -0.09522369f, -0.03267651f, 
    0.01508704f, -0.03943162f, 0.06689089f, -0.00227537f, -0.07922127f, 0.06901000f, -0.00295794f, 0.01532504f, 
    -0.02081847f, -0.04887151f, -0.07755233f, -0.10097443f, 0.01326863f, 0.03736922f, -0.01571964f, -0.09653959f, 
    -0.01096542f, -0.10095272f, 0.06070465f, -0.03218203f, -0.07571360f, -0.08102386f, 0.01613911f, 0.05994708f, 
    0.03796832f, -0.02411519f, 0.06677587f, 0.02425728f, 0.02010270f, -0.05587471f, -0.06666501f, -0.04129230f, 
    -0.05119370f, 0.07292691f, -0.08051006f, 0.00221072f, -0.03628683f, -0.09378861f, -0.02486761f, 0.03189003f, 
    -0.05895575f, -0.04967503f, 0.06613406f, 0.07619252f, -0.02866528f, -0.06454619f, 0.02345210f, 0.07901993f, 
    0.05728628f, 0.00491052f, 0.02858808f, -0.00722156f, 0.00756637f, 0.06957799f, 0.05375824f, 0.08127122f, 
    -0.08107676f, -0.01364972f, -0.02818307f, -0.05136538f, -0.00121933f, -0.00986882f, -0.01469288f, 0.06031201f, 
    -0.07913753f, -0.14696829f, 0.08191517f, 0.05601830f, 0.11907933f, -0.09201655f, 0.03100979f, 0.07122852f, 
    0.05292996f, 0.11656845f, -0.07698952f, -0.00344451f, -0.05696859f, 0.19326036f, 0.06187855f, -0.01021067f, 
    0.01026591f, 0.02838975f, 0.04192415f, 0.02695078f, -0.08837701f, 0.06573444f, -0.07890040f, -0.15462959f, 
    0.01220890f, 0.17487475f, 0.14854890f, 0.07277069f, 0.15707932f, -0.21932353f, -0.05088974f, 0.03524359f, 
    0.12367138f, 0.02873206f, -0.06807351f, 0.04593891f, -0.40036157f, 0.07838730f, -0.13406217f, -0.30064976f, 
    0.16961443f, 0.02901000f, -0.36525443f, -0.03544046f, -0.17203997f, -0.07884938f, 0.19187780f, 0.07966270f, 
    -0.08389448f, 0.04974719f, 0.04056542f, -0.08436087f, 0.05164326f, -0.02066768f, -0.06955816f, -0.03337122f, 
    0.04115337f, 0.01526293f, -0.19576265f, 0.09972381f, -0.04931355f, 0.20310687f, 0.16028216f, -0.27392465f, 
    0.05493744f, 0.04972869f, -0.03426575f, 0.06736192f, 0.11645890f, 0.19658849f, 0.13450579f, 0.01983642f, 
    -0.20904015f, -0.03702205f, 0.08314355f, -0.03434904f, 0.00686241f, -0.09872972f, 0.04278446f, 0.21963473f, 
    0.08477180f, -0.06869052f, 0.24189517f, 0.37643436f, 0.05297305f, 0.19231005f, -0.16810279f, 0.31074527f, 
    -0.03343299f, -0.03077011f, 0.54903132f, -0.29287690f, -0.25667989f, 0.22016504f, -0.13034983f, 0.03912820f, 
    0.13557847f, 0.14013465f, 0.00915715f, -0.02931315f, -0.11543486f, -0.06131939f, 0.02667170f, 0.05788972f, 
    -0.07174243f, 0.18118601f, -0.00301497f, 0.34492299f, 0.12852602f, -0.00596089f, -0.00852434f, 0.16180490f, 
    -0.08375083f, 0.05423557f, -0.42725226f, -0.09068411f, -0.03251050f, -0.11727699f, -0.07376456f, 0.05637398f, 
    -0.08427877f, -0.03544697f, 0.01755368f, 0.06460293f, 0.05556532f, -0.09636722f, 0.06811984f, 0.09327631f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.01016598f, -0.11244550f, 0.06982767f, -0.00002960f, -0.02047575f, -0.04047925f, 0.00679071f, -0.04768235f, 
    0.04978115f, 0.10228001f, -0.05216356f, 0.15567730f, -0.06964496f, -0.05467350f, 0.13239099f, 0.14115651f, 
    0.22573324f, -0.10431115f, -0.08363315f, -0.00491691f, -0.11989076f, -0.01989529f, 0.27002847f, 0.11731829f, 
    0.09875597f, -0.02305934f, 0.14384334f, 0.08356456f, -0.06786567f, 0.29589602f, 0.30136988f, 0.01079123f, 
    0.05972871f, -0.05378007f, -0.04857701f, -0.05515642f, 0.07064001f, 0.20202899f, 0.11806826f, 0.08126383f, 
    -0.00571153f, 0.18178900f, 0.05857401f, -0.05041580f, -0.19977206f, 0.04546656f, -0.10924468f, -0.00927161f, 
    0.36632285f, -0.13317989f, -0.00511911f, 0.16268890f, -0.08206193f, 0.24603002f, 0.00541373f, 0.06976332f, 
    0.02138017f, 0.06166514f, -0.09045983f, -0.03417325f, 0.18810815f, -0.04342696f, -0.00433560f, -0.06933368f, 
    -0.00892414f, 0.09980785f, 0.01088480f, 0.05598717f, 0.18843102f, 0.02613006f, 0.02317961f, -0.28560340f, 
    0.00186250f, -0.16400678f, -0.09079526f, -0.00809286f, 0.07524325f, -0.05169617f, 0.17612268f, 0.27894172f, 
    0.04085900f, -0.08737769f, -0.19793461f, -0.03594600f, 0.24966317f, 0.06069196f, 0.26368809f, 0.25157917f, 
    0.00234850f, 0.13536379f, -0.07164229f, -0.01456898f, -0.08554228f, 0.19404148f, 0.13168050f, -0.01097032f, 
    0.05950228f, 0.06013592f, 0.04313916f, 0.20977430f, 0.14463158f, -0.11696842f, 0.24116644f, -0.00266962f, 
    -0.02640710f, 0.15134013f, 0.17248805f, 0.21263625f, -0.03527406f, -0.16981845f, -0.07994016f, -0.06630652f, 
    0.00421421f, 0.05934894f, 0.20261402f, 0.03757924f, -0.05554171f, 0.03763077f, -0.02578797f, 0.11254875f, 
    0.02591807f, 0.07239655f, 0.06469361f, 0.10376246f, 0.01878782f, 0.14395332f, -0.07742231f, 0.05328602f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.04819292f, -0.44718793f, 0.17115875f, -0.05546433f, -0.00125251f, 0.04250883f, -0.00465250f, -0.02901547f, 
    -0.18044606f, 0.19018969f, -0.05831993f, 0.00339426f, -0.02328637f, 0.06955338f, -0.31577790f, 0.00679499f, 
    -0.10817809f, -0.08555940f, 0.03047671f, 0.32066634f, 0.24175869f, 0.07232515f, 0.24050030f, 0.02971147f, 
    0.24214813f, -0.08126224f, -0.35020739f, 0.08485791f, 0.03821588f, 0.05477751f, -0.59151298f, 0.14912683f, 
    -0.45194986f, 0.07205945f, -0.10765901f, -0.32315916f, -0.02769034f, -0.13960597f, 0.04771642f, -0.07261702f, 
    0.20766160f, -0.10423578f, -0.14662930f, -0.40225634f, 0.28865725f, 0.09215370f, -0.02180236f, -0.30240512f, 
    -0.08322877f, 0.28759509f, -0.07588313f, 0.19419545f, 0.00988041f, -0.22561651f, 0.00369267f, 0.25062287f, 
    0.31321129f, -0.02501942f, -0.04531545f, -0.04661258f, 0.16961917f, -0.66479415f, -0.03641467f, -0.51775706f, 
    0.01449302f, -0.28024605f, 0.05059640f, 0.01718968f, 0.05797654f, 0.29160017f, 0.14004700f, -0.49297485f, 
    0.03453089f, 0.33370781f, 0.05534265f, 0.11361351f, 0.06591693f, 0.15490516f, 0.09275677f, -0.12398300f, 
    -0.05288753f, 0.04680063f, -0.36012864f, -0.05880100f, -0.21972981f, -0.03955999f, -0.14188425f, -0.04348248f, 
    0.06729952f, -0.49178386f, -0.11275889f, -0.20268638f, -0.00703214f, -0.04941637f, 0.10804414f, -0.01264680f, 
    0.02235197f, -0.06070929f, -0.16467546f, 0.10134055f, 0.11546852f, 0.25635085f, -0.04214948f, 0.15826565f, 
    0.03902195f, -0.23086925f, 0.12158624f, 0.10855612f, -0.07716013f, -0.39799649f, -0.77663291f, 0.27874735f, 
    -0.80234140f, -0.03115750f, 0.10365818f, 0.16242737f, 0.01147913f, -0.02067972f, 0.02457198f, 0.08083940f, 
    0.01501031f, 0.11000443f, 0.01708561f, 0.03044362f, -0.12323418f, 0.00924817f, 0.02731951f, 0.12504104f, 
    -0.05331230f, 0.40900791f, 0.19426996f, -0.06168902f, 0.02142313f, -0.02515878f, -0.01427530f, -0.28483158f, 
    0.11380771f, 0.11854344f, 0.02307201f, -0.03340574f, -0.01893432f, 0.00257369f, 0.20269063f, 0.22335516f, 
    -0.28209019f, -0.04206866f, -0.04482951f, 0.06199209f, 0.07777490f, 0.11466183f, 0.05886523f, 0.01639993f, 
    0.15483288f, -0.05011725f, 0.00021584f, 0.11816221f, -0.05036542f, -0.03469313f, 0.08402533f, -0.15737881f, 
    0.17906392f, 0.06791798f, -0.23859678f, 0.11926407f, -0.08535471f, -0.01936177f, 0.00557179f, 0.20222788f, 
    0.08704825f, 0.16179880f, -0.51471746f, 0.11530920f, 0.01401453f, 0.15386933f, 0.01598798f, 0.43501768f, 
    -0.65642297f, -0.00988876f, -0.19096446f, -0.16669187f, 0.05713588f, -0.17720993f, 0.01237443f, 0.01467425f, 
    -0.00448286f, -0.00088784f, -0.05233883f, -0.02030034f, 0.12328894f, 0.21652272f, 0.07346267f, 0.30680826f, 
    -0.03368395f, -0.12754120f, 0.07467648f, -0.01189209f, 0.12512022f, -0.11059012f, -0.35136887f, 0.27348748f, 
    0.02126424f, -0.05991986f, -0.00174439f, -0.18103056f, 0.07177897f, 0.01357102f, -0.18286501f, -0.54522032f, 
    -0.03144124f, -0.05558712f, -0.21806778f, -0.01063939f, -0.01943480f, -0.56445420f, 0.21623199f, -0.37129700f, 
    -0.06916186f, -0.36870664f, 0.02216100f, 0.07796033f, -0.06021532f, -0.09720540f, -0.50227064f, -0.01542607f, 
    0.05323092f, -0.03718267f, 0.08613965f, 0.06807323f, -0.02435829f, -0.15282249f, 0.19802439f, 0.17889664f, 
    0.00816701f, -1.01300395f, -0.10839464f, -0.16848278f, 0.04465856f, 0.04690485f, 0.14031279f, -0.25134498f, 
    0.13887733f, -0.03092382f, -0.04034482f, 0.17640419f, -0.07606266f, -0.21659504f, 0.00653587f, 0.18507236f, 
    -0.25359333f, -0.24354850f, -0.02111376f, -0.23137072f, -0.12628447f, 0.03906688f, -0.05313409f, -0.20872484f, 
    0.29541197f, -0.35227299f, -0.53612077f, -0.01351713f, 0.06507054f, -0.06849824f, -0.08124256f, -0.19559652f, 
    -0.24883476f, -0.01935420f, 0.04351577f, -0.03155868f, -0.08039618f, -0.02085100f, -0.12739478f, 0.10518554f, 
    -0.17411400f, 0.19257884f, -0.01461280f, 0.38794109f, 0.16182597f, 0.20452301f, -0.07133705f, -0.02891063f, 
    -0.33095846f, -0.01117626f, -0.03790633f, -0.67078245f, 0.01759949f, -0.11242568f, -0.55438066f, -0.13515355f, 
    0.25207567f, 0.07061102f, 0.07539991f, -0.02421700f, 0.01818804f, -0.05599280f, -0.52277517f, -0.16015001f, 
    0.36326954f, -0.00781672f, 0.27038243f, 0.16689862f, 0.15581156f, 0.20596765f, -0.04502576f, -0.33265865f, 
    -0.66103101f, -0.04702472f, -0.15234749f, -0.08540262f, -0.05004055f, 0.18818969f, 0.05019674f, -0.12062829f, 
    -0.32708910f, -0.00139369f, -0.02168325f, 0.01918407f, 0.03907371f, -0.37473017f, 0.01637743f, -0.31197092f, 
    0.02259666f, 0.30129465f, 0.04848522f, -0.00835629f, 0.12892529f, -0.19786176f, -0.11769589f, -0.08418986f, 
    0.07848264f, 0.11006396f, 0.02879381f, -0.34738740f, -0.03703234f, -0.17923984f, -0.07572018f, 0.08544765f, 
    0.07539693f, 0.06234615f, -0.73771447f, 0.06621909f, -0.01428825f, -0.11905438f, -0.08970676f, 0.24762681f, 
    -0.09484468f, -0.07418661f, 0.02132457f, -0.24525896f, 0.00002417f, -0.09852383f, 0.17716914f, 0.08474188f, 
    -0.03225196f, -0.07571714f, 0.09505763f, -0.06687464f, -0.10865202f, 0.00092123f, 0.17777263f, -0.40709117f, 
    0.01046116f, -0.63135517f, -0.26787257f, 0.07253207f, -0.07797097f, -0.24274474f, -0.04304852f, 0.27940512f, 
    -0.62666720f, -0.08137148f, -0.56429440f, -0.17191210f, 0.05927112f, 0.16562234f, -0.08672581f, -0.20760708f, 
    -0.32030037f, 0.06782532f, -0.09158658f, 0.11928213f, -0.57569534f, 0.06950736f, -0.04508360f, -0.39573780f, 
    0.15360168f, 0.39394253f, -0.00920065f, -0.06060532f, 0.05647393f, -0.08068640f, 0.07085470f, 0.08487172f, 
    0.09317715f, -0.20543706f, -0.03232598f, -0.29067752f, 0.01007268f, 0.07058749f, 0.04542002f, -0.51051956f, 
    0.21478449f, -0.07441517f, -0.05906095f, -0.18108134f, -0.07069067f, -0.88877064f, -0.19240989f, 0.11121186f, 
    -0.34399647f, 0.09615253f, -0.28207681f, 0.14628311f, -0.02418456f, -0.17138630f, -0.21480589f, 0.02282874f, 
    0.47917476f, 0.05984082f, 0.21909429f, -0.10307347f, 0.06340537f, 0.11317227f, 0.17447643f, 0.12165038f, 
    -0.29276624f, -0.50877589f, -0.11584345f, -0.32136562f, -0.24596311f, -0.30832830f, -0.01124420f, 0.23893090f, 
    0.07211135f, -0.39806223f, 0.24743019f, 0.09444106f, -0.05566605f, -0.77202302f, -0.06333580f, -0.01775735f, 
    0.37780344f, -0.03722738f, 0.01574442f, -0.04618663f, -0.10093864f, -0.01328891f, 0.09100712f, -0.04697274f, 
    -0.03777950f, -0.68373626f, -0.07470960f, 0.08700522f, -0.32074803f, 0.22446528f, 0.20880759f, -0.79489428f, 
    -0.01310213f, -0.36751556f, -0.07686258f, 0.16161144f, 0.01122126f, 0.11762123f, -0.02508308f, 0.17771876f, 
    0.00686841f, -0.06701893f, 0.07412469f, 0.00197141f, -0.41348660f, 0.09812611f, 0.01846991f, 0.01157327f, 
    0.00358593f, 0.17670146f, 0.00624897f, -0.16304879f, 0.01095889f, -0.11254290f, 0.00071725f, -0.05993606f, 
    -0.05483120f, 0.00012279f, -0.60291803f, 0.13164122f, -0.02081882f, 0.06875462f, -0.45636225f, 0.02563141f, 
    -0.05094722f, -0.10727966f, -0.00110355f, -0.10394672f, -0.03414396f, -0.13788740f, 0.10432121f, -0.30612341f, 
    0.01649480f, 0.01108111f, 0.10527418f, 0.14301395f, -0.06407076f, 0.01134287f, -0.00488771f, -0.13879773f, 
    0.22158551f, 0.12478634f, 0.06745546f, 0.14484552f, 0.01338516f, -0.25752828f, -0.04711175f, 0.09966516f, 
    -0.18332174f, -0.47607553f, 0.08253644f, 0.06441382f, -0.00715961f, 0.06767280f, 0.00344033f, -0.32643428f, 
    -0.08582652f, 0.11501601f, 0.00498362f, 0.03767323f, 0.02041283f, 0.05892779f, -0.24205497f, 0.02434640f, 
    0.21513833f, -0.09320303f, 0.09728611f, -0.33841726f, 0.14544889f, 0.33272287f, -0.06695308f, 0.18270133f, 
    -0.07786662f, -0.05376134f, 0.01220637f, -0.09136393f, 0.00112813f, 0.11887711f, -0.13431937f, 0.13299002f, 
    -0.94068748f, 0.03097996f, -0.23097816f, -0.22525734f, -0.09785510f, -0.00465525f, -0.05619430f, 0.09634668f, 
    -0.30633447f, -0.09370029f, 0.23374638f, 0.18310854f, 0.30366877f, -0.10674166f, 0.02465779f, -0.23661619f, 
    0.21322274f, -0.21487014f, -0.11478529f, 0.04401300f, -0.02714933f, 0.15611611f, 0.05938549f, 0.05253827f, 
    -0.46152747f, 0.07078687f, 0.04731564f, -0.00536477f, 0.00842554f, 0.03601188f, 0.00525733f, 0.03138676f, 
    -0.03546445f, 0.15005697f, 0.06431735f, -0.00533358f, 0.06004097f, -0.64302975f, -0.03044204f, -0.32066029f, 
    -0.07032368f, -0.14386593f, 0.02298368f, -0.14998309f, -0.04697212f, -0.08773614f, 0.15366945f, 0.24563415f, 
    0.06780872f, -0.00386012f, -0.29612535f, 0.06144941f, -0.07410994f, 0.31282184f, 0.28144071f, 0.28136441f, 
    0.01738730f, 0.04922273f, -0.01528907f, 0.18035899f, 0.04304487f, 0.14455295f, -0.12701756f, -0.03079974f, 
    -0.00046508f, 0.06105747f, -0.00127689f, -0.19612277f, -0.05998237f, 0.08489206f, 0.15015176f, -0.01627916f, 
    -0.08153310f, 0.02443331f, 0.02075395f, 0.19077019f, 0.03187902f, -0.14435315f, 0.07290750f, -0.40985793f, 
    -0.54068577f, 0.04338291f, 0.17200746f, -0.57053351f, 0.06846203f, 0.12460094f, -0.00036633f, -0.07219010f, 
    0.08744049f, 0.09831522f, -0.03054940f, 0.23267950f, 0.17935565f, -0.17723331f, 0.00776015f, 0.01612240f, 
    -0.16700745f, 0.21034797f, 0.05134507f, -0.02720093f, -0.03375617f, -0.02799294f, -0.02516301f, 0.24245571f, 
    -0.18788695f, -0.08644643f, -0.07113524f, 0.14374799f, 0.03516190f, 0.07245164f, -0.05709527f, 0.08766124f, 
    -0.59997565f, -0.23878509f, -0.02127890f, -0.05251530f, -0.37652627f, -0.11797550f, 0.15097311f, -0.39781910f, 
    0.15154824f, -0.00143324f, 0.08095084f, 0.10603760f, 0.00190894f, 0.20436418f, 0.45676762f, -0.15429410f, 
    0.18942004f, 0.05178468f, -0.54007667f, 0.06942384f, 0.03886125f, -0.15740180f, 0.16989458f, 0.10674907f, 
    -0.16034397f, 0.08428021f, 0.26625949f, -0.23116422f, -0.16185537f, -0.04947332f, 0.02008645f, 0.29268622f, 
    0.26341215f, 0.12198681f, -0.26305056f, 0.03334008f, -0.05950511f, 0.26914173f, -0.00908818f, -0.37339514f, 
    0.17474689f, -0.02267803f, -0.04981185f, 0.02447343f, 0.00733422f, -0.05155344f, -0.00321333f, 0.02064786f, 
    -0.00956667f, -0.07920411f, -0.01851694f, 0.07259496f, 0.09925263f, -0.06652381f, 0.16359225f, 0.10000800f, 
    0.06662820f, 0.05994991f, -0.07849666f, 0.02332952f, -0.00894677f, -0.27368617f, 0.01063664f, -0.87040740f, 
    -0.03093193f, -0.07680906f, 0.21297640f, -0.02787117f, 0.21168296f, -0.63284695f, 0.16243775f, 0.18607305f, 
    -0.11575890f, -0.16112560f, 0.00860397f, 0.06889643f, -0.08097242f, 0.12559922f, 0.35884026f, 0.02187667f, 
    -0.03157296f, 0.00700834f, -0.15441614f, 0.10725141f, 0.02337782f, -0.48513433f, -0.10355689f, 0.03654793f, 
    0.02365354f, 0.40920013f, 0.07768214f, 0.03049266f, -0.09497135f, 0.33243555f, 0.21385328f, 0.23010862f, 
    0.32991028f, -0.07457431f, 0.08432879f, -0.00633446f, -0.27151644f, -0.42330089f, 0.01359020f, 0.03128319f, 
    -0.34305054f, 0.16741180f, -0.08743227f, -0.63111818f, -0.12617992f, 0.17662561f, -0.01955583f, -0.07114208f, 
    0.26022789f, 0.25508574f, -0.13218383f, 0.01694018f, 0.00156026f, 0.06691696f, -0.02273694f, -0.16899218f, 
    0.06820434f, 0.40940589f, -0.04375538f, 0.14954947f, 0.05870156f, 0.03369070f, 0.15371141f, 0.18718450f, 
    0.03779024f, 0.10070218f, -0.06173917f, 0.01974686f, -0.20232934f, -0.31633240f, 0.12015975f, -0.12533823f, 
    -0.04038497f, 0.03359509f, 0.21269155f, -0.06026300f, 0.00132522f, 0.13816473f, 0.22773927f, 0.10530666f, 
    0.31174764f, 0.03602221f, 0.18026604f, 0.03926135f, 0.04182950f, -0.05298092f, -0.00109952f, -0.02397611f, 
    0.21742663f, 0.06205360f, -0.11296739f, 0.20595475f, -0.44351181f, 0.04354247f, -0.05134271f, 0.15319809f, 
    0.17684487f, 0.10728703f, -0.19651611f, 0.16236959f, 0.06554014f, -0.80289882f, 0.05207894f, -0.41085762f, 
    -0.15063535f, 0.06993341f, 0.02121351f, -0.04709595f, 0.01004353f, 0.40487134f, -0.00992469f, 0.07453980f, 
    -0.11038490f, -0.19301432f, -0.08262135f, 0.04179648f, -0.25968772f, -0.09153996f, 0.01272287f, -0.13992284f, 
    0.04808107f, -0.54851115f, 0.03624335f, -0.25653443f, 0.07862286f, -0.24207060f, 0.05354003f, 0.20683163f, 
    0.05317954f, 0.05709624f, 0.24830870f, -0.00483590f, 0.24390674f, -0.97768456f, -0.18111785f, -0.44689065f, 
    0.03036559f, -0.40149015f, -0.00799437f, -0.25471866f, 0.05562566f, 0.24765207f, 0.17483538f, -0.07830133f, 
    -0.08019698f, 0.05338076f, 0.04388593f, -0.04506430f, -0.02436723f, -0.27883691f, -0.01796309f, -0.17113908f, 
    -0.00635333f, -0.19467631f, 0.03114484f, -0.07261220f, -0.00284259f, -0.36998969f, -0.36197269f, -0.56442010f, 
    -0.36242402f, 0.01451104f, 0.10780654f, -0.35064098f, 0.09189262f, -0.09351871f, 0.03470212f, 0.09335319f, 
    0.14426708f, 0.15009272f, 0.08206140f, 0.20971438f, -0.23128662f, -0.12574261f, 0.00921421f, -0.11819309f, 
    0.20912759f, 0.10333993f, 0.05442618f, -0.07248973f, 0.00962938f, 0.01129494f, 0.03134217f, 0.05089071f, 
    -0.34136441f, -0.11114333f, -0.01938526f, -0.08031136f, -0.07943197f, -0.02702732f, -0.60390276f, -0.27354684f, 
    -0.32353076f, -0.02114718f, -0.02944631f, 0.09832773f, 0.06875682f, 0.07419381f, -0.16678688f, -0.19655086f, 
    0.19157921f, -0.02849121f, 0.08404017f, -0.06525344f, -0.01247270f, -0.18072832f, -0.23318343f, 0.02488010f, 
    -0.14889139f, -0.03139357f, -0.39587319f, -0.14640826f, -0.05486454f, -0.43901452f, -0.22490832f, -0.16042081f, 
    -0.35181063f, 0.11691716f, 0.19235234f, 0.08560009f, -0.01855556f, -0.64781988f, -0.02753815f, 0.05723081f, 
    -0.17100272f, 0.16734011f, -0.07124302f, -0.07066997f, -0.06653944f, 0.05150001f, 0.01745810f, 0.14333791f, 
    -0.12451798f, -0.00417429f, -0.02728476f, -0.05801691f, -0.36058593f, 0.24716021f, -0.00530657f, 0.26007000f, 
    0.05676723f, -0.10214893f, 0.01400606f, 0.05084103f, -0.22435799f, 0.06730504f, 0.09940546f, 0.31772432f, 
    -0.01441720f, 0.16166683f, -0.05936942f, 0.03781736f, 0.02035886f, -0.10018326f, -0.00938618f, -0.47191006f, 
    -0.01476300f, 0.01628509f, -0.14018159f, -0.04972039f, -0.68102449f, 0.09480588f, -0.46703702f, -0.42555898f, 
    -0.06844801f, 0.20843458f, 0.03954572f, -0.11427846f, -0.01354945f, 0.02107884f, -0.40305826f, 0.00270944f, 
    0.06218876f, 0.02072545f, -0.18191591f, -0.55334675f, -0.58201820f, 0.12724656f, -0.33205250f, 0.09974330f, 
    -0.00156255f, 0.38884535f, -0.60524863f, -0.08103648f, 0.06996819f, 0.17689930f, 0.09046321f, 0.11252343f, 
    0.13548589f, 0.05967302f, -0.00069358f, -0.22134911f, 0.02038845f, 0.07746010f, -0.00824469f, -0.09353114f, 
    0.02233155f, -0.09256938f, 0.06916012f, -0.35979369f, 0.19925894f, -0.37967345f, 0.02351582f, 0.04119084f, 
    0.12415116f, -0.19539762f, 0.13870782f, 0.06244964f, -0.08764482f, -0.01399656f, 0.03923727f, 0.03746032f, 
    0.34948263f, 0.25102597f, -0.10049949f, -0.08015119f, 0.04101906f, -0.00515910f, -0.09236744f, -0.62685084f, 
    -0.24826133f, 0.04395351f, -0.06864290f, 0.02722226f, 0.12284950f, 0.21866407f, -0.88279188f, 0.26956365f, 
    -0.25817859f, -0.05576593f, 0.05269271f, -0.07464971f, -0.00795354f, -0.72551727f, -0.51811105f, -0.33672988f, 
    -0.47585228f, 0.02643894f, -0.14425188f, 0.00147532f, -0.02687403f, 0.14450188f, -0.07105610f, -0.11697065f, 
    -0.18226612f, 0.00039552f, -0.35871682f, -0.36768696f, -0.26813841f, 0.00214493f, 0.07027671f, 0.03356131f, 
    -0.54150993f, 0.21451287f, -0.10603725f, -0.72066522f, -0.00175950f, 0.20796216f, 0.07093128f, -0.18106940f, 
    -0.14988160f, 0.05153436f, 0.02629886f, -0.02054617f, -0.02651413f, -0.08515026f, -0.03993862f, -0.12292688f, 
    0.07835927f, 0.19485089f, -0.06558714f, -0.00568002f, 0.12147477f, -0.14637612f, 0.11291391f, -0.01054070f, 
    0.04036216f, -0.11620441f, 0.02040895f, -0.19932476f, 0.07709439f, 0.24195971f, -0.68608177f, -0.24145162f, 
    0.09195250f, -0.01206672f, 0.28201154f, 0.01766914f, -0.32942358f, -0.26294327f, 0.00288761f, -0.14446552f, 
    -0.08945736f, 0.18849255f, -0.00962065f, 0.33807415f, -0.07859429f, -0.67916316f, 0.07032634f, 0.07899079f, 
    -0.05751707f, 0.00721893f, 0.02053132f, 0.09849573f, 0.27331844f, 0.31008288f, -0.21562368f, 0.29300490f, 
    -0.03430504f, -0.43605462f, -0.16107388f, -0.61896360f, -0.04570685f, -0.04829901f, -0.33634162f, 0.02412926f, 
    -0.11076517f, 0.06350972f, -0.28449842f, -0.09395833f, -0.66207826f, -0.44897935f, 0.05369611f, 0.16849303f, 
    -0.15638150f, -0.52697670f, 0.07851215f, -0.28582051f, 0.04250671f, -0.01360002f, -0.02799263f, -0.03389486f, 
    -0.54160035f, -0.24336407f, 0.06636808f, -0.00726147f, -0.09834377f, 0.00178055f, -0.02893159f, -0.25822023f, 
    -0.16087319f, -0.69139147f, -0.05417126f, 0.19201085f, 0.05646434f, 0.00844365f, 0.12921102f, -0.14491159f, 
    0.15363063f, -0.44743675f, -0.09308231f, -0.21698718f, -0.30286905f, -0.23833407f, -0.07388836f, -0.25620469f, 
    -0.27351877f, -0.08323538f, 0.19837052f, -0.05934205f, -0.06892796f, 0.03265021f, -0.13873005f, 0.01146184f, 
    0.06038771f, 0.05991679f, -0.16338070f, -0.28824732f, -0.05575801f, 0.07373001f, -0.02944497f, -0.01932202f, 
    0.06405415f, 0.20272173f, -0.11234102f, 0.14880441f, -0.72446382f, -0.00815267f, -0.05653315f, -0.64428365f, 
    0.14801103f, -0.12885723f, 0.22499503f, 0.03843540f, 0.00318090f, 0.34148270f, 0.05585448f, -0.02334055f, 
    -0.04743302f, -0.02633883f, 0.07762050f, -0.02818741f, 0.15212093f, -0.11052482f, -0.02531290f, 0.15896355f, 
    -0.08421730f, 0.34253770f, 0.03316106f, -0.01988175f, -0.12109572f, 0.35965836f, -0.57302743f, 0.39285967f, 
    -0.05034692f, -0.29358929f, 0.04749852f, 0.16780065f, -0.03908854f, 0.01273901f, 0.07851480f, 0.01604092f, 
    -0.08517387f, -0.06708291f, -0.32555711f, 0.02582748f, 0.16675450f, 0.01324458f, -0.21873805f, -0.00713004f, 
    -0.01424427f, -0.20544380f, -0.02813263f, -0.61643308f, 0.05102589f, 0.06561111f, -0.44160628f, -0.01627266f, 
    -0.00190381f, -0.09065672f, -0.01483512f, 0.34170550f, 0.18929890f, 0.11297577f, 0.14812194f, 0.09033781f, 
    0.07293493f, -0.55409497f, -0.05426075f, -0.09774141f, -0.00672809f, 0.26925531f, 0.14659302f, -0.05477306f, 
    0.24745832f, 0.05694177f, -0.05560597f, -0.02372311f, 0.19316578f, 0.03855474f, -0.00409998f, -0.04313966f, 
    0.07346334f, -0.12532124f, -0.02566451f, -0.16207615f, 0.34087569f, -0.12494361f, -0.00004739f, 0.08368756f, 
    0.07544463f, -0.38763553f, -0.32850325f, 0.06093832f, -0.00556809f, -0.07273081f, -0.02595162f, 0.22839981f, 
    0.04184613f, 0.15482505f, -0.05578800f, -0.63983774f, 0.00626216f, -0.07915904f, 0.23061663f, -0.32420877f, 
    -0.06264888f, 0.14357513f, -0.03019882f, -0.06384144f, 0.19186345f, 0.19235869f, -0.62318838f, 0.03193196f, 
    -0.23953354f, 0.00791981f, -0.45928103f, -0.11950159f, -0.03344912f, -0.16818702f, 0.12917045f, 0.05655520f, 
    0.09992960f, -0.04739813f, 0.31088087f, 0.21810080f, 0.00911071f, 0.11676145f, 0.05198738f, 0.09968056f, 
    -0.38720837f, -0.37098053f, 0.12091017f, -0.10179313f, 0.39783791f, 0.00981741f, 0.05959789f, 0.04923479f, 
    -0.02725261f, -0.47105876f, 0.18414690f, -0.17693457f, -0.06579225f, -0.40264419f, -0.03359866f, 0.03439253f, 
    -0.49933031f, -0.02672807f, 0.05361811f, -0.04639882f, -0.33766010f, -0.08419004f, -0.03153131f, -0.02405008f, 
    -0.05029710f, -0.82751453f, 0.02912488f, 0.02872419f, 0.07389853f, 0.08643534f, 0.09815210f, -0.05617724f, 
    -0.04132194f, 0.10634182f, -0.08220557f, 0.13445799f, 0.06355994f, -0.08252981f, -0.12347277f, -0.05416205f, 
    -0.04495488f, -0.10277638f, 0.02973648f, 0.02269811f, -0.12242462f, 0.10338373f, 0.15905756f, 0.24851415f, 
    -0.10095741f, 0.24323300f, 0.07281540f, 0.01433117f, -0.04697420f, -0.29986241f, 0.29546410f, -0.06838753f, 
    0.00719875f, -0.07479490f, -0.15914677f, 0.04799769f, -0.26793751f, -0.21674226f, 0.08571609f, -0.31137675f, 
    0.04783790f, 0.25282887f, -0.19297871f, 0.08294411f, -0.04242499f, -0.24451703f, -0.07596166f, 0.30336213f, 
    0.04328607f, 0.01774477f, -0.07030284f, 0.20286463f, -0.22912556f, 0.08883563f, 0.07232993f, -0.48847914f, 
    0.08479602f, 0.13054858f, -0.08490566f, 0.17075144f, -0.10900536f, 0.13972619f, 0.01660550f, 0.03958778f, 
    -0.42619464f, -0.28654471f, -0.21738151f, 0.04881606f, -0.04109981f, -0.03975075f, 0.03370780f, 0.30167946f, 
    0.11797780f, -0.11324804f, -0.05519447f, 0.11915088f, -0.08847755f, -0.09244491f, 0.17145766f, 0.23784713f, 
    0.19090302f, 0.08514812f, -0.04790426f, -0.10710067f, 0.02138548f, -0.32440567f, -0.06041968f, 0.13311023f, 
    0.11170822f, -0.07707334f, 0.08670867f, -0.08060525f, -0.12600520f, 0.07861231f, 0.03750410f, -0.00840578f, 
    -0.68867922f, -0.00218677f, 0.09608050f, 0.19828922f, -0.04061005f, -0.01906324f, -0.06797812f, -0.42978463f, 
    0.11744516f, -0.16443773f, -0.25478667f, 0.12349132f, -0.10249817f, -0.11467365f, 0.07314900f, -0.06908208f, 
    -0.51617384f, 0.13876450f, -0.03433191f, 0.00507526f, 0.06067457f, -0.03690962f, -0.07693169f, 0.07267980f, 
    0.10678094f, 0.00106940f, 0.06335687f, -0.05439790f, -0.23747125f, -0.19230254f, 0.05575852f, -0.22056955f, 
    -0.03089100f, -0.03717739f, 0.06634587f, 0.01672937f, -0.15409714f, -0.14484996f, 0.24596009f, 0.09454852f, 
    -0.06186515f, 0.22860113f, 0.01538867f, 0.20198776f, 0.05733569f, 0.11573336f, 0.06659663f, 0.28116271f, 
    0.02246124f, 0.04002521f, 0.12922892f, 0.06286427f, -0.10020846f, 0.12439217f, -0.06004845f, -0.12062570f, 
    -0.01316000f, -0.14371459f, -0.01719864f, 0.18414427f, -0.10823971f, -0.06885400f, 0.07044669f, -0.01197223f, 
    0.03403015f, 0.04910558f, -0.04625779f, -0.20900695f, 0.21124642f, -0.13195074f, -0.25689122f, -0.20503056f, 
    -0.00845594f, 0.11914659f, 0.25589833f, 0.15915579f, 0.02799968f, -0.07504185f, 0.07248784f, -0.27929136f, 
    -0.07686604f, 0.06117710f, -0.17312260f, -0.25622278f, 0.09369206f, 0.05317434f, 0.04983872f, -0.20862255f, 
    0.08794391f, 0.02307834f, -0.01949613f, 0.11657495f, -0.42592189f, 0.08549500f, 0.05872253f, 0.12408848f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.01867548f, 0.08243768f, -0.15153684f, -0.04239967f, 0.22192508f, 0.02855776f, -0.03828540f, -0.38977408f, 
    -0.04669445f, 0.08952626f, 0.00118534f, 0.01925682f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
