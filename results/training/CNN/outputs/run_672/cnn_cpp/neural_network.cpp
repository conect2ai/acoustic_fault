#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.30566239f, -0.25457841f, -0.91323262f, -0.96521765f, -0.01009932f, -0.28001115f, -0.36788115f, 0.53516352f, 
    0.50884640f, -0.15342629f, -0.79519767f, -0.14330237f, 0.08669004f, -0.15732116f, -0.79868263f, -0.54110694f, 
    0.06724866f, 0.15142226f, 0.08276901f, -0.06795888f, 0.13559665f, 0.16071156f, -0.05307066f, 0.07606887f, 
    0.02453136f, -0.97118425f, 0.43495432f, -0.11418288f, -0.54233623f, 0.09327055f, -0.92317885f, -0.17640647f, 
    0.55781984f, -0.02633507f, -1.01912081f, 0.16108020f, 0.29723001f, -0.14974385f, 0.21360424f, 0.25709879f, 
    -0.13326485f, -0.10222405f, -0.53276694f, -0.23519248f, 0.08681014f, 0.23372591f, -0.28909394f, 0.30159467f, 
    -0.19240399f, 0.07657123f, 1.11701894f, 0.73509890f, -0.52044070f, -0.41245458f, -0.58097917f, 0.67445594f, 
    0.72178692f, 0.31706610f, 0.54930460f, 0.47829375f, 0.32786751f, 0.03328491f, -0.37273583f, -0.18647294f, 
    -0.08802512f, 0.23505257f, -0.30836636f, -0.61330903f, -0.00412489f, 0.37596217f, -0.19736733f, -0.28388199f, 
    0.11291306f, 0.01687921f, -0.01202357f, 1.13449466f, 0.06801938f, -0.87659341f, 0.84162724f, 0.94044727f, 
    0.52874309f, 0.38962659f, 0.30782038f, 0.74649990f, -0.04793576f, -0.53451604f, -0.17688523f, 0.07609820f, 
    0.25612998f, 0.36330050f, 0.08149258f, -0.11324217f, 0.16686316f, 0.19173902f, 0.12851816f, 0.41854843f, 
    0.05431789f, -0.02469967f, -0.15094665f, -0.03192889f, 1.02687979f, 0.56136727f, 0.72194493f, 0.55679345f, 
    -0.47871551f, -0.26470938f, -0.21490015f, 0.24609232f, 0.33659500f, 0.86348182f, -0.37758914f, -0.08160009f, 
    0.10545243f, 0.45127836f, -0.51353800f, -0.23385452f, -0.24444997f, 0.14568056f, -0.12502396f, 0.13246159f, 
    0.34092826f, -0.16852438f, 0.06082323f, 0.00547395f, 0.09048133f, 0.67365915f, 0.54690558f, 0.69361293f, 
    1.03555405f, 0.62508816f, -0.12683240f, 0.11501184f, 0.44619960f, 0.36327523f, -0.46947777f, -0.24548368f, 
    -0.41594690f, -0.44771311f, 0.09494848f, -0.05769547f, -0.49699003f, -0.16206615f, 0.09340181f, -0.13474563f, 
    -0.04524375f, -0.23425961f, -0.26382914f, -0.23628674f, 0.39534539f, 0.14267625f, 0.54043502f, 0.88665158f, 
    0.13883580f, 0.06200681f, 0.81900823f, -0.01652255f, -0.03799455f, 0.59250933f, 0.35333633f, 0.46953180f, 
    -0.00394685f, -0.40071192f, 0.25492463f, -0.40714341f, 0.03083727f, 0.39712259f, -0.07680077f, 0.05953687f, 
    -0.49874231f, -0.25030097f, -0.14397375f, -0.28298020f, 0.29336149f, -0.23484039f, 0.09070934f, -0.53268677f, 
    -0.94407231f, -0.08213613f, 0.73544079f, -0.23798966f, -1.15140796f, 0.03463544f, -0.21774834f, -0.59859359f, 
    -0.26203424f, 0.39636892f, 0.68944037f, 0.22304988f, 0.41891652f, 0.16810866f, -0.07607527f, 0.18856719f, 
    0.46248278f, 0.11421957f, -0.02957988f, 0.29553279f, -0.04644994f, -0.07999822f, 0.45709524f, 0.07869714f, 
    -0.47228810f, -0.52424353f, -0.64996737f, -0.65556401f, 0.00409468f, -0.12165585f, -0.28548646f, 0.20301412f, 
    -0.26033196f, 0.40414247f, 0.42642051f, -0.20972897f, 0.58104777f, 0.54793423f, 0.32914978f, 0.32600236f, 
    0.39071646f, -0.00114917f, 0.58216798f, 0.41249371f, 0.16522320f, 0.03275192f, 0.19726729f, -0.37415665f, 
    0.41214585f, -0.35206297f, -0.32224718f, -0.61826241f, -0.62359565f, -0.53130758f, 0.78192163f, 0.87806582f, 
    0.08984565f, 0.57342207f, 0.53261220f, -0.19324394f, -0.33106455f, 0.03781959f, -0.00052672f, -0.27003822f, 
    -0.35079774f, 0.04554429f, 0.34944347f, 0.12279861f, 0.06625577f, 0.03192127f, 0.00611006f, -0.11237682f, 
    -0.34703663f, 0.52830374f, -0.25187254f, -0.57257855f, -0.90353858f, -0.79942423f, -0.42734727f, -0.75528681f, 
    0.02347426f, 0.32657859f, -0.22461587f, 0.02457835f, 0.48509103f, -0.17826945f, -0.18978384f, -0.43942618f, 
    -0.09505490f, 0.36489469f, 0.09070562f, -0.13091421f, -0.03612622f, -0.21246895f, -0.15186717f, -0.09779815f, 
    0.03935864f, -0.06508630f, 0.45063594f, 1.37943566f, 0.26403213f, 0.72738785f, 0.72527683f, 0.17195192f, 
    0.42210650f, 0.18291079f, -0.70515591f, -0.42049360f, -0.48375541f, 0.18364234f, 0.51116025f, 0.32786393f, 
    0.23130859f, -0.65598267f, 0.33725098f, 0.16672800f, 0.39470813f, 0.02855996f, 0.35188276f, -0.34806561f, 
    0.21655267f, 0.03691735f, -0.09813462f, 0.03247160f, 0.52991992f, 1.32595801f, 1.03180742f, 0.40364993f, 
    -0.23195077f, -0.74567932f, 0.34016103f, -0.74106312f, -0.74995518f, -0.07057226f, 0.43359986f, 0.20852444f, 
    -0.18150839f, 0.28422728f, 0.26199540f, 0.17317964f, -0.20206732f, 0.07635773f, 0.11286456f, -0.25947914f, 
    0.17336389f, 0.34580192f, 0.15328781f, 0.04301244f, 0.20470636f, -0.72303635f, -1.67099905f, -0.74753916f, 
    0.60411525f, 0.28878659f, -0.62534398f, 1.03936481f, 0.83438694f, -0.22620979f, -0.14322354f, 0.25553137f, 
    -0.15139639f, -0.17211519f, 0.16628641f, 0.01541614f, -0.20973714f, -0.04553539f, -0.20872326f, -0.16683149f, 
    -0.20888302f, -0.03449944f, 0.01720445f, 0.13457009f, 0.11264490f, 0.03707765f, -1.04894090f, -0.49453646f, 
    -0.61772811f, -0.41777915f, -0.49523437f, 0.34670448f, 0.04746270f, -0.50690597f, 0.48288876f, 0.74326783f, 
    0.08973916f, -0.02611103f, -0.23652065f, -0.50851214f, -0.11430428f, 0.07385098f, 0.35088223f, -0.00133024f, 
    -0.17317809f, 0.00411785f, -0.53559184f, -0.18893471f, -0.25601298f, 0.18987997f, -0.14239480f, -0.38986537f, 
    -0.94467294f, -0.87353307f, -0.31218958f, 0.87019497f, 0.53909010f, -0.02751086f, -0.77052337f, -0.21892637f, 
    -0.06210326f, 0.33004135f, 0.35425806f, -0.22630258f, 0.24611194f, -0.24009006f, -0.06925639f, -0.32750988f, 
    -0.34025398f, -0.06424728f, 0.00844392f, 0.30996498f, -0.08596944f, -0.03765514f, -0.14775822f, -0.13440885f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.03036705f, 0.28492397f, 0.28054106f, 0.18421464f, 0.34037560f, 0.18588737f, 0.23115729f, 0.49794108f, 
    0.37737170f, -0.00584278f, 0.22982202f, -0.13290408f, 0.25201872f, 0.38306803f, -0.10564095f, 0.50480098f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.06150144f, -0.02500892f, 0.03789621f, -0.02849619f, 0.01017186f, 0.03028908f, 0.06882901f, 0.04290891f, 
    0.04689661f, -0.03007757f, -0.01389646f, 0.02581294f, -0.01750166f, -0.05503871f, -0.06093964f, -0.06046452f, 
    0.01536559f, -0.04822162f, -0.04515049f, 0.04887105f, -0.04938825f, 0.03701811f, -0.07296076f, 0.01632247f, 
    0.06299140f, 0.03145768f, 0.00171678f, -0.01961555f, -0.01679334f, -0.03432404f, -0.06482680f, -0.01959356f, 
    0.02962020f, -0.01983496f, 0.01549612f, 0.00902674f, -0.01407092f, -0.05057616f, -0.05377368f, 0.02430807f, 
    -0.01467555f, 0.03002176f, -0.06087706f, -0.00530207f, -0.06480049f, 0.02258709f, -0.08840317f, 0.02024066f, 
    -0.00786400f, 0.02421371f, -0.07544898f, -0.05255291f, -0.06848599f, -0.05627922f, -0.02639759f, 0.01796783f, 
    0.01471008f, 0.05163231f, -0.04978774f, -0.07295071f, 0.05395882f, 0.01847970f, -0.05797244f, -0.05849576f, 
    -0.06298089f, -0.05508444f, -0.04633285f, 0.05696892f, 0.00411456f, 0.00471528f, -0.03343981f, 0.04687686f, 
    -0.00316739f, -0.00089988f, -0.03438951f, -0.05374150f, -0.05891422f, 0.01262824f, -0.07241578f, 0.01976426f, 
    -0.05528455f, -0.02333356f, -0.03698606f, -0.04968552f, -0.07812537f, -0.06631511f, 0.03877742f, 0.04663134f, 
    -0.02026888f, -0.04956765f, -0.06591785f, -0.00134328f, -0.07852183f, 0.05243204f, 0.05097405f, -0.04557268f, 
    0.01436496f, 0.00970523f, -0.00862959f, -0.02030201f, 0.02019349f, -0.06597944f, -0.00924405f, -0.01769488f, 
    -0.05956244f, 0.03037028f, -0.03846020f, 0.04846609f, -0.04637372f, -0.06671194f, -0.06785557f, 0.03528573f, 
    -0.05274526f, 0.05397005f, 0.05440592f, -0.00686311f, -0.00749052f, -0.01234089f, 0.02142463f, -0.03855107f, 
    -0.03411628f, -0.01929654f, -0.06848688f, -0.01031075f, -0.04155933f, 0.02268417f, -0.04033764f, 0.00969521f, 
    -0.02990361f, 0.02896874f, -0.03384007f, -0.05486723f, -0.05230605f, -0.04711090f, 0.00256087f, 0.01072922f, 
    -0.07267715f, -0.04099866f, -0.03946603f, -0.06870216f, -0.04208867f, 0.02631722f, -0.03790211f, -0.09000863f, 
    0.00174114f, -0.00997531f, 0.02159614f, -0.04319036f, -0.01073602f, -0.03847424f, 0.00185616f, 0.03357779f, 
    -0.03409780f, 0.01702016f, 0.00597646f, -0.03206968f, -0.01313554f, 0.04221224f, -0.07322464f, 0.05441461f, 
    -0.08250498f, 0.00616402f, -0.06033521f, -0.05544547f, 0.02413529f, -0.04217649f, -0.01110086f, -0.02893577f, 
    -0.05493429f, -0.05742234f, -0.01856949f, -0.07954004f, 0.03251377f, -0.00476399f, 0.00305361f, 0.00707953f, 
    -0.00745082f, -0.05117699f, 0.04281502f, -0.06742039f, 0.01033787f, -0.01602070f, 0.04162122f, 0.02545132f, 
    0.04716273f, -0.06841174f, 0.03699945f, -0.01320266f, -0.01405233f, 0.05439057f, -0.03966526f, -0.03504029f, 
    -0.51080942f, 0.38415661f, -0.01353034f, 0.01332663f, -0.05376520f, 0.02902492f, -0.07269401f, -0.00442087f, 
    0.31365040f, 0.15789732f, -0.03335969f, -0.11562549f, -0.25799283f, -0.05860927f, 0.25295967f, 0.04200185f, 
    0.11462379f, 0.21449150f, 0.03619274f, 0.09689179f, 0.25816807f, 0.26055980f, -0.00864250f, 0.10227386f, 
    0.04920164f, 0.04098665f, 0.00818155f, 0.05800601f, 0.05078490f, -0.06323761f, -0.07177459f, -0.07413887f, 
    0.21797021f, 0.03972561f, -0.11754442f, 0.03586502f, -0.44757348f, 0.07113520f, 0.32244492f, 0.03204311f, 
    0.18088147f, -0.06968155f, -0.14140715f, 0.17897950f, -0.00520014f, -0.02446649f, -0.00216027f, -0.07307886f, 
    0.50968975f, 0.21478757f, -0.03444504f, -0.10166499f, 0.16077244f, -0.05133928f, -0.03981237f, 0.02149647f, 
    -0.02746946f, 0.01436801f, 0.06836661f, 0.07218555f, -0.13238168f, -0.24716115f, 0.20549023f, -0.23362717f, 
    -0.05985698f, -0.04685265f, -0.15017571f, 0.03189972f, -0.13406441f, -0.00871585f, -0.18981801f, 0.05650032f, 
    -0.23709571f, 0.21889286f, 0.02192102f, 0.00567151f, 0.36318216f, 0.17315944f, -0.17718625f, -0.02520259f, 
    0.10315893f, -0.09990706f, 0.09004736f, 0.07280843f, 0.21695112f, 0.22836483f, -0.17048258f, -0.31164253f, 
    0.05894404f, 0.02830836f, 0.19523504f, 0.10703745f, 0.05018709f, -0.02482677f, 0.28976211f, 0.01666867f, 
    -0.22553755f, 0.06807104f, 0.02158976f, -0.25168326f, -0.11289578f, -0.09234957f, -0.13869449f, -0.00384525f, 
    -0.09479168f, 0.01766923f, 0.02981009f, 0.09815469f, 0.32619685f, -0.20669714f, -0.01271981f, -0.17232327f, 
    -0.22071539f, 0.24530177f, -0.12567145f, 0.09109938f, -0.08584942f, -0.07281443f, -0.16290198f, 0.07038721f, 
    -0.29971501f, 0.21710637f, -0.03580887f, -0.06892560f, -0.00506867f, -0.14293696f, -0.24337922f, -0.09743257f, 
    0.08152198f, 0.03303884f, 0.03513112f, 0.11802822f, -0.05749454f, -0.17226711f, -0.08473160f, 0.04262872f, 
    0.21901478f, -0.05490823f, 0.03970102f, -0.28455791f, -0.00969028f, -0.09560802f, 0.13846821f, 0.16685084f, 
    0.83042228f, 0.08021624f, -0.22260579f, 0.06342943f, 0.20625880f, -0.07864054f, -0.06728557f, 0.06779503f, 
    -0.12538546f, -0.05274773f, 0.21685287f, 0.22383155f, 0.38182008f, -0.10039675f, 0.22635956f, -0.08432683f, 
    0.20563486f, -0.13481997f, 0.02498322f, -0.07659698f, 0.03543089f, 0.04980838f, 0.21269751f, -0.07123661f, 
    -0.35560024f, -0.14713714f, 0.05955390f, -0.34075063f, -0.09627700f, 0.04497363f, 0.23069339f, -0.14350225f, 
    -0.02986669f, 0.08238493f, -0.25244969f, -0.04347458f, 0.27540892f, -0.03205505f, 0.07324177f, 0.26698482f, 
    -0.01769596f, 0.07238278f, -0.04961929f, -0.03345398f, 0.07462248f, 0.09017199f, -0.02534005f, 0.15072781f, 
    -0.33133608f, 0.00071775f, -0.00617961f, 0.24606329f, -0.20283371f, 0.02958600f, 0.16466287f, 0.06216156f, 
    -0.00444406f, 0.07981890f, 0.02361047f, 0.29920286f, 0.02856647f, 0.12918876f, -0.25524127f, -0.02390732f, 
    -0.04314306f, 0.24093319f, 0.12081650f, 0.12270793f, 0.13208853f, 0.17361534f, 0.25129488f, 0.13876270f, 
    -0.20754433f, 0.26924834f, 0.08181719f, 0.20506054f, 0.05894708f, 0.18270183f, 0.07235043f, 0.36708665f, 
    0.15437117f, 0.04144191f, 0.23648973f, -0.08110533f, -0.46878269f, 0.06137640f, -0.27949432f, 0.08082127f, 
    0.34639138f, 0.16852032f, 0.28401452f, 0.19436936f, 0.02612039f, -0.20607494f, 0.02560103f, 0.16495721f, 
    -0.51817274f, -0.07750147f, 0.09208012f, 0.31543389f, 0.10804787f, 0.21537223f, 0.03768392f, -0.09529625f, 
    0.02311123f, 0.24804102f, -0.17496265f, 0.22312716f, -0.21811339f, 0.12181143f, -0.04766510f, -0.28806981f, 
    0.03139962f, -0.03222485f, -0.05597403f, 0.05367816f, 0.09606605f, -0.04520205f, 0.09107559f, -0.15700786f, 
    -0.27689549f, -0.03656667f, -0.01375157f, -0.19055399f, -0.24693102f, -0.00135760f, 0.15995969f, 0.15305261f, 
    0.06658309f, 0.10426629f, 0.22711742f, 0.01140990f, 0.11718050f, -0.01549805f, -0.06790954f, 0.07741499f, 
    0.06092555f, 0.16827486f, 0.24419358f, -0.07182089f, -0.01206556f, 0.10796536f, -0.04324718f, -0.01071654f, 
    0.01663138f, -0.19004382f, -0.09763265f, -0.10540956f, -0.22494313f, 0.01908444f, 0.32735693f, 0.11130761f, 
    -0.03506382f, -0.01343850f, -0.19279157f, 0.02164263f, 0.18470912f, -0.03618494f, 0.07444508f, -0.06808116f, 
    -0.01051077f, -0.25324067f, -0.03172119f, -0.02340207f, -0.16748382f, 0.05561341f, -0.18827589f, 0.19524692f, 
    -0.43130130f, -0.39626285f, -0.35822666f, -0.23849028f, -0.12595145f, -0.09959791f, 0.07114845f, -0.08092590f, 
    0.03051779f, 0.18301816f, 0.16243327f, -0.05591996f, -0.31595626f, 0.49144807f, -0.08356534f, -0.56913894f, 
    0.06564967f, 0.03275215f, -0.06298315f, 0.19954504f, 0.00288255f, 0.25321561f, -0.15796016f, -0.10892785f, 
    -0.47193438f, 0.54330814f, 0.22734004f, -0.24799947f, 0.22528462f, 0.29771274f, -0.10303124f, -0.06612669f, 
    -0.09225146f, 0.00605285f, -0.05778162f, -0.02371115f, 0.12037043f, -0.05838516f, -0.14720336f, 0.43845379f, 
    -0.19346155f, 0.02301739f, 0.05211350f, 0.21717608f, 0.16401783f, -0.09226584f, 0.14329319f, 0.00964967f, 
    0.19177923f, -0.40144968f, -0.11684019f, -0.05865366f, -0.13665213f, -0.11591914f, 0.01396621f, 0.15596916f, 
    0.03201917f, 0.09095438f, 0.24430986f, 0.29467696f, -0.02069814f, 0.13652669f, -0.02695986f, 0.00701240f, 
    0.14399296f, -0.05161538f, 0.06034664f, 0.13986649f, 0.32103759f, 0.00697253f, 0.31602681f, -0.05292112f, 
    0.05845511f, -0.05508579f, 0.03449402f, 0.05220388f, -0.05732826f, -0.00432528f, -0.05914139f, -0.05503764f, 
    0.05320268f, -0.01438326f, 0.04185932f, -0.04694564f, 0.03306412f, -0.07594415f, -0.06803888f, 0.05840179f, 
    -0.04691516f, 0.02151221f, 0.02643046f, 0.00574093f, -0.00421677f, -0.04763752f, -0.05684894f, -0.07455512f, 
    0.00881758f, 0.01026049f, 0.04726084f, -0.00997481f, -0.06762527f, -0.07433633f, -0.02676846f, -0.03619491f, 
    0.01472751f, -0.06909440f, 0.04833966f, 0.05120553f, -0.07312200f, 0.01418473f, 0.03035062f, -0.03161896f, 
    -0.06931408f, -0.01818990f, -0.01314379f, -0.05625981f, -0.03868332f, -0.00981853f, -0.01212559f, -0.01841195f, 
    -0.04116457f, -0.06393111f, -0.04480705f, 0.05671736f, -0.01910982f, 0.05114153f, 0.04079657f, 0.00066804f, 
    0.06266939f, -0.04716745f, 0.04774988f, -0.00352373f, -0.04842549f, 0.06270565f, 0.02273334f, -0.00841836f, 
    -0.03760505f, 0.03419438f, 0.01454872f, -0.05172580f, -0.01731404f, -0.00372697f, -0.01731327f, 0.00443361f, 
    0.01305477f, -0.07913129f, -0.05842962f, 0.00105803f, 0.04670746f, -0.03566375f, 0.03035362f, -0.04006020f, 
    0.00161453f, -0.04705594f, 0.01500922f, 0.00301995f, -0.07712895f, -0.05962175f, 0.06116462f, -0.00972954f, 
    -0.06568151f, 0.00597106f, 0.00413923f, 0.00301067f, 0.01205537f, -0.07415241f, 0.05179054f, 0.00956435f, 
    0.03216365f, -0.07290938f, -0.07887415f, 0.02022647f, -0.05414825f, 0.05050528f, -0.07723523f, 0.00253321f, 
    0.04489071f, -0.05143030f, -0.03835810f, -0.07455609f, -0.03094587f, 0.00988916f, -0.01216596f, -0.07008468f, 
    0.05672199f, -0.07377347f, 0.05038002f, -0.01295515f, -0.00720329f, 0.04899460f, -0.04605273f, 0.04190318f, 
    0.00147463f, -0.03222506f, -0.02773954f, 0.03159643f, -0.02638457f, 0.04432753f, 0.03088128f, -0.03663504f, 
    -0.03374935f, -0.05199262f, 0.00521173f, -0.00606621f, 0.00810388f, 0.01447003f, -0.01180612f, 0.01686783f, 
    0.01503819f, -0.06689093f, 0.02056340f, 0.05565427f, -0.06398694f, 0.02149421f, -0.04126125f, -0.05955783f, 
    -0.06746448f, 0.03080619f, 0.06035333f, 0.04875523f, 0.02661071f, -0.08027653f, 0.04026087f, -0.01877756f, 
    0.00912253f, -0.06093506f, -0.00614255f, 0.01938657f, -0.00606878f, -0.03755737f, -0.01203232f, -0.03887729f, 
    0.03491491f, 0.04589986f, 0.02298489f, 0.04295766f, -0.06746008f, -0.04605854f, -0.07549383f, -0.00464132f, 
    -0.02525663f, 0.00837835f, -0.02770630f, -0.00234798f, -0.07233051f, -0.07355095f, -0.06971999f, -0.07214021f, 
    -0.02455993f, 0.05640683f, -0.04871318f, 0.01253217f, 0.00503715f, 0.04316670f, -0.00646767f, 0.04475736f, 
    -0.05702414f, -0.04023534f, -0.00668703f, 0.05231334f, -0.07126695f, 0.01778039f, -0.00187827f, 0.03835247f, 
    -0.33660474f, -0.09109348f, 0.03061158f, -0.18359788f, 0.07419110f, -0.13258906f, -0.12604548f, 0.06245569f, 
    0.11903492f, -0.23087226f, -0.13811290f, 0.01006997f, 0.06397903f, -0.19003752f, -0.31109586f, -0.18276200f, 
    0.23654029f, 0.11543919f, -0.04183133f, -0.01923583f, 0.06384169f, 0.14001682f, -0.12827779f, 0.00942252f, 
    0.30394885f, 0.05132404f, 0.25728482f, 0.11537595f, -0.06021770f, -0.13966824f, 0.01983204f, -0.03903659f, 
    0.02605726f, -0.16200730f, -0.02542195f, 0.10886534f, -0.24106456f, -0.06654921f, 0.03468449f, 0.21683563f, 
    -0.03656690f, -0.19395830f, -0.25416088f, 0.16415913f, -0.00273943f, 0.10204795f, -0.11938506f, 0.02823578f, 
    0.24265267f, 0.26095924f, 0.29008561f, -0.03352622f, 0.08583651f, -0.02447711f, 0.18224764f, 0.11552308f, 
    -0.00029910f, -0.14048457f, 0.07236633f, -0.03342395f, -0.03188057f, 0.15151644f, 0.00283737f, 0.14234093f, 
    0.26422289f, 0.07505810f, -0.00256413f, 0.03151192f, -0.07169117f, 0.12500916f, -0.10936654f, 0.11996523f, 
    0.14556055f, 0.06113809f, 0.03051835f, -0.01182003f, 0.29383752f, 0.07073479f, -0.09210707f, -0.06579007f, 
    -0.03606842f, -0.02163410f, -0.06311204f, 0.02837265f, 0.20202416f, -0.20066530f, -0.52753586f, -0.09295473f, 
    -0.14917481f, 0.12909158f, 0.05991233f, -0.02159515f, 0.04229143f, -0.11850818f, 0.06885452f, 0.02287295f, 
    0.07482414f, 0.11919155f, 0.13926366f, -0.08713719f, -0.04694222f, 0.08936839f, 0.08882880f, -0.00558976f, 
    -0.29553345f, -0.01800316f, 0.01009756f, 0.11393604f, 0.18271792f, -0.16193052f, 0.10034598f, 0.07625988f, 
    -0.06011010f, 0.05541266f, -0.11232539f, 0.26985216f, 0.07430020f, -0.03094318f, 0.06542377f, -0.11849289f, 
    0.12414692f, 0.08632922f, -0.05637431f, 0.08971149f, -0.01050543f, 0.05174472f, -0.13904446f, 0.14395790f, 
    0.02100516f, -0.00172903f, 0.09178909f, 0.09933559f, 0.20922014f, 0.07739316f, 0.08543056f, -0.49396354f, 
    0.24007590f, 0.05845786f, 0.07830636f, -0.33272970f, -0.00599149f, 0.02484639f, 0.14357509f, -0.21241339f, 
    0.45864445f, 0.07809576f, -0.14997834f, -0.23344536f, 0.35816994f, 0.10459040f, 0.01748643f, 0.04378743f, 
    0.06832969f, 0.03502862f, 0.03213211f, 0.21633953f, 0.60225117f, -0.40979156f, 0.02718564f, 0.15675582f, 
    -0.20145485f, 0.08000721f, -0.11884513f, 0.00173217f, 0.06964222f, 0.08065628f, 0.14095600f, 0.05577385f, 
    -0.25903532f, -0.32246751f, 0.17198917f, -0.00942675f, 0.01479679f, 0.06353209f, 0.01941657f, -0.21853240f, 
    0.16188465f, 0.09952959f, 0.03685971f, 0.03855769f, 0.33752522f, -0.10548001f, 0.02464368f, -0.14533554f, 
    0.03785395f, -0.13653587f, -0.24978852f, -0.05209354f, 0.09563887f, 0.05696758f, -0.20258573f, 0.03926269f, 
    0.36081305f, -0.09340813f, -0.03856789f, -0.19548301f, -0.01879293f, 0.15999128f, -0.22734612f, -0.01422135f, 
    -0.11302123f, -0.18271992f, 0.15498206f, -0.15053129f, -0.07859209f, 0.13568690f, 0.11911848f, 0.01548800f, 
    0.00150745f, -0.10255162f, -0.06176412f, 0.13736297f, 0.03129146f, 0.00376029f, -0.14832811f, -0.08307922f, 
    0.12127832f, -0.02391874f, 0.13723810f, -0.32106805f, 0.03914200f, 0.05270917f, -0.03404760f, -0.22501642f, 
    -0.18718803f, 0.05278740f, -0.25105911f, 0.12838043f, 0.35888883f, 0.08293507f, -0.22466509f, 0.19387127f, 
    0.00824806f, -0.06516575f, -0.11413005f, -0.12916906f, 0.05676979f, 0.34638736f, 0.14184119f, 0.10617264f, 
    0.29889691f, -0.08341981f, 0.03583428f, -0.00618540f, 0.24497013f, -0.08830846f, -0.00901973f, 0.07613477f, 
    -0.02390737f, -0.16433686f, 0.08336468f, -0.01962507f, 0.13244867f, -0.06476595f, -0.23426870f, 0.34251547f, 
    -0.10663181f, 0.18792044f, -0.10409904f, -0.02813984f, -0.17849123f, -0.08928373f, 0.11134863f, -0.06541099f, 
    0.52689832f, -0.23241910f, -0.02670172f, -0.12490100f, -0.08943822f, 0.00072417f, -0.07237647f, 0.09092857f, 
    -0.03632055f, -0.06679189f, -0.06946404f, 0.03485914f, -0.42595083f, -0.12126207f, 0.02922148f, 0.39081466f, 
    0.04076046f, -0.15777998f, -0.06398073f, -0.06938526f, -0.05043063f, -0.05512476f, 0.11639405f, 0.02106969f, 
    0.43835285f, -0.15728526f, -0.07523423f, 0.08398274f, 0.05844574f, 0.06170995f, -0.18799269f, 0.08340865f, 
    -0.00146369f, 0.28612378f, 0.11159789f, 0.03157223f, -0.16799240f, -0.05736742f, 0.03697714f, -0.00810980f, 
    0.24234895f, -0.03187203f, -0.13664562f, 0.11309335f, 0.09159883f, 0.05075460f, -0.06642204f, 0.03517049f, 
    0.13067995f, -0.02885626f, 0.19056480f, 0.09278716f, 0.06121301f, 0.05613329f, 0.20120378f, 0.20695733f, 
    -0.09369458f, 0.13060813f, -0.09503070f, 0.09667329f, 0.32568109f, -0.04656225f, 0.02850316f, 0.10481546f, 
    0.05212058f, -0.03946222f, 0.10140520f, 0.15127611f, 0.12592661f, 0.05465741f, 0.04078303f, 0.18230197f, 
    -0.08877253f, -0.14887601f, 0.21026187f, 0.08344063f, -0.21928896f, -0.12458773f, -0.09074974f, -0.01180321f, 
    0.10565811f, -0.01169943f, -0.02237080f, 0.00965542f, -0.89539772f, 0.49168605f, -0.22020039f, -0.02669490f, 
    0.03672929f, -0.10028850f, -0.18754950f, 0.17250480f, -0.04324494f, 0.15469564f, -0.15185115f, 0.07257760f, 
    0.18550237f, 0.16407610f, -0.17615056f, 0.24720432f, 0.12245497f, 0.11813914f, 0.02404907f, 0.04960047f, 
    0.04375962f, 0.04111712f, 0.08320495f, -0.08198001f, 0.03162188f, -0.02435352f, -0.05855186f, 0.07264336f, 
    0.02346605f, 0.07318107f, 0.22313459f, 0.15443008f, -0.05763997f, 0.12418765f, 0.07582270f, 0.02184089f, 
    0.02881795f, -0.05196237f, 0.15033673f, 0.15128718f, 0.09118113f, 0.11773033f, 0.07794698f, 0.10181957f, 
    0.18364429f, 0.03716721f, 0.14027666f, -0.21336748f, 0.25307855f, -0.10238225f, 0.09125093f, -0.06549027f, 
    0.09267819f, 0.00593749f, -0.11865690f, -0.00148098f, -0.04484738f, -0.00638670f, -0.16532949f, 0.19295371f, 
    -0.03938857f, 0.12215190f, -0.16524345f, 0.00916674f, -0.04514858f, 0.17831168f, -0.01195086f, -0.23404145f, 
    0.01666461f, -0.12870437f, -0.17120886f, 0.11844981f, 0.15509395f, -0.23380654f, 0.11877405f, -0.05841931f, 
    -0.22868837f, -0.02459001f, 0.00490487f, -0.02994377f, 0.01572571f, 0.17106782f, 0.04170780f, 0.08827308f, 
    -0.40204588f, -0.31033009f, 0.08717515f, -0.02095247f, 0.02426472f, -0.06748285f, -0.20391054f, 0.00129012f, 
    0.12630630f, 0.03429219f, 0.21729276f, -0.01389539f, -0.18919010f, -0.14028540f, -0.01384269f, -0.10401066f, 
    0.00844914f, 0.10354533f, -0.17097561f, -0.06752644f, 0.03235895f, 0.01700907f, 0.10303962f, -0.05642446f, 
    -0.13983601f, 0.13597327f, -0.05612704f, 0.01350614f, 0.27603352f, -0.10637549f, -0.15371549f, -0.20527723f, 
    -0.06849690f, -0.16547421f, -0.09562313f, 0.04104517f, 0.45664814f, 0.03546636f, 0.20409295f, -0.23991665f, 
    -0.09037785f, -0.10485765f, -0.03890495f, 0.03851408f, 0.05135677f, 0.07852688f, 0.22372599f, 0.15643911f, 
    -0.13279517f, 0.23361705f, 0.05746590f, 0.08508757f, 0.09461024f, -0.00570706f, -0.01196021f, -0.08158933f, 
    0.10031591f, 0.09709290f, 0.15220618f, 0.23471841f, 0.29851103f, 0.29665220f, 0.04985621f, 0.13620675f, 
    -0.24539982f, 0.16758782f, 0.07318588f, 0.10311809f, 0.02266514f, 0.03606541f, 0.05275455f, -0.06241783f, 
    -0.04749788f, 0.22814359f, 0.37250838f, -0.21520096f, 0.22870477f, 0.19591080f, 0.03515110f, -0.16212149f, 
    0.12573400f, -0.15624040f, -0.11487805f, -0.05965969f, -0.56901884f, -0.32473424f, 0.16571742f, 0.09317621f, 
    -0.01047124f, -0.02464448f, -0.01844896f, -0.28007531f, 0.11729532f, 0.07259615f, 0.27456164f, 0.17362809f, 
    -0.29577217f, -0.16836005f, -0.03381961f, 0.11092015f, 0.27230436f, -0.04570479f, 0.06513461f, 0.15889814f, 
    0.12952805f, 0.16369420f, 0.14329106f, 0.24187647f, 0.11567685f, -0.12284998f, 0.14183688f, -0.30266428f, 
    -0.03967020f, 0.08626417f, -0.03542685f, 0.03286250f, 0.07909350f, 0.06585383f, -0.18932346f, -0.05933658f, 
    -0.30356213f, 0.37034765f, 0.12751974f, 0.29962519f, -0.04305854f, -0.04522662f, 0.02180145f, -0.22700426f, 
    0.09301434f, -0.00474205f, -0.12712932f, -0.02402079f, -0.08287689f, 0.15566400f, 0.18723908f, -0.07542861f, 
    0.01286949f, -0.07436845f, -0.11298954f, 0.15869652f, 0.08489876f, -0.08873471f, -0.04602352f, 0.17045122f, 
    0.01694344f, 0.01791947f, -0.01516690f, 0.03496591f, 0.00269264f, -0.05598408f, -0.03948246f, 0.00525935f, 
    -0.06532592f, 0.00671346f, 0.07435992f, -0.06348588f, -0.01670265f, -0.06443721f, 0.04811477f, -0.06574370f, 
    0.03175709f, -0.06899587f, 0.06974147f, 0.03453740f, 0.03953923f, -0.05192022f, -0.05680333f, 0.04144514f, 
    0.05260432f, -0.02675351f, -0.03731985f, 0.01498388f, 0.03090901f, -0.06532273f, -0.02112480f, 0.01877943f, 
    -0.00655823f, 0.03934598f, -0.06209032f, -0.02324560f, -0.02506741f, -0.04314867f, 0.03815643f, 0.05857764f, 
    0.03758386f, -0.01747727f, 0.03873216f, 0.05634556f, 0.00847234f, -0.05927530f, 0.03136693f, -0.07804537f, 
    -0.06242179f, 0.05936931f, -0.03447511f, -0.03252244f, -0.01944986f, 0.02227778f, -0.03062338f, -0.00593776f, 
    0.04848737f, -0.00280861f, 0.02689289f, 0.04370971f, -0.07131016f, -0.06586417f, -0.05276056f, -0.01563602f, 
    -0.00424255f, -0.00536031f, -0.06207521f, 0.04716703f, -0.00261789f, -0.01325830f, 0.04235091f, -0.02404924f, 
    0.00565988f, 0.03083208f, 0.06987885f, -0.05388768f, -0.06084602f, -0.06769215f, -0.05584852f, -0.07647476f, 
    0.04620076f, -0.00603369f, -0.02056088f, 0.00125394f, -0.04069965f, -0.06351956f, -0.04109126f, 0.06935266f, 
    -0.05655634f, -0.06039320f, -0.06086383f, 0.05862122f, 0.04596128f, 0.03659532f, -0.01291759f, 0.05291219f, 
    -0.03157103f, -0.01378399f, -0.06201306f, -0.06773212f, 0.00463881f, -0.00593743f, -0.00669718f, -0.02085228f, 
    0.00388417f, 0.01997614f, -0.06015439f, 0.02233463f, -0.07588199f, 0.04052534f, -0.03369927f, 0.06236208f, 
    -0.06701542f, -0.06429122f, -0.00295555f, -0.02993095f, -0.00939280f, 0.03121721f, 0.05474945f, -0.06620014f, 
    -0.00413756f, 0.06289062f, -0.00035711f, -0.05189763f, 0.01746710f, -0.02441503f, -0.05402166f, -0.01433609f, 
    0.03519095f, -0.06974248f, -0.03327814f, -0.06631375f, 0.05190904f, -0.00191788f, -0.04082278f, -0.04873022f, 
    0.00501126f, -0.00232122f, -0.05324086f, -0.06404670f, -0.02511810f, 0.03307988f, -0.02712183f, -0.00152121f, 
    0.00407152f, 0.02503223f, -0.00757971f, -0.03161860f, -0.06330213f, 0.02491222f, -0.06074763f, 0.04124932f, 
    0.05711488f, 0.00812039f, -0.07576498f, -0.03306622f, 0.03153881f, 0.03304754f, -0.06505040f, 0.05127436f, 
    0.04126723f, 0.05132060f, -0.05376060f, -0.00739749f, -0.01635942f, 0.01877685f, -0.02362435f, -0.04966181f, 
    0.04548917f, -0.03500873f, -0.04245275f, 0.02340021f, 0.00531996f, 0.02909664f, 0.03080850f, -0.01946545f, 
    -0.00755213f, -0.04291962f, 0.00411492f, 0.07162017f, -0.01951024f, -0.00039318f, 0.02927249f, -0.01981362f, 
    0.00200233f, -0.00192844f, -0.03251554f, -0.01785647f, 0.05318163f, -0.02789453f, -0.06072825f, -0.00827206f, 
    -0.07797693f, -0.07239628f, 0.03950979f, -0.01650968f, 0.00270276f, 0.04081011f, -0.00986774f, -0.04928298f, 
    0.00576902f, -0.03409858f, -0.01067278f, -0.02595760f, -0.01764291f, -0.02537228f, -0.06641977f, -0.02570017f, 
    -0.03143944f, 0.04771905f, 0.01537270f, 0.05551079f, -0.08326809f, 0.05749334f, -0.01764810f, 0.00617381f, 
    -0.04553007f, -0.07655961f, -0.06676642f, 0.05591728f, -0.00279855f, -0.07099316f, 0.06036014f, -0.04036929f, 
    0.04658416f, -0.04181745f, -0.01853599f, -0.06920479f, 0.00993156f, -0.06393746f, -0.00963063f, -0.02557793f, 
    -0.04455578f, -0.05718509f, 0.04579314f, 0.02412888f, -0.01548839f, 0.00046116f, -0.07359502f, 0.06029608f, 
    -0.05004584f, 0.02984287f, 0.04566517f, -0.05082722f, -0.01286088f, 0.05367072f, 0.03764135f, 0.03790645f, 
    -0.06936637f, 0.00063010f, -0.03903989f, -0.06377584f, -0.00702240f, -0.04282078f, -0.04083921f, -0.03786220f, 
    -0.04741291f, -0.03290723f, -0.01411959f, -0.02546613f, 0.05470171f, -0.07019610f, -0.06239441f, 0.06270126f, 
    0.03808150f, -0.00114456f, -0.01161101f, -0.02935094f, 0.04764872f, 0.05428474f, -0.05819361f, 0.00415509f, 
    -0.04962675f, -0.02896705f, 0.00894148f, -0.04825173f, 0.04710923f, 0.02166401f, -0.02369264f, 0.02696662f, 
    0.05862487f, -0.00278286f, -0.04398666f, -0.03944535f, 0.02640863f, -0.01671823f, -0.02765699f, -0.07729668f, 
    0.05601205f, -0.05649637f, 0.03406924f, -0.05248939f, -0.07478399f, 0.04533087f, -0.05099762f, 0.03113943f, 
    0.00718305f, -0.04910326f, 0.02331472f, -0.00432661f, -0.04262478f, -0.02859346f, 0.05468461f, -0.08182486f, 
    -0.06841428f, -0.05461848f, -0.06336162f, -0.01312282f, -0.01318925f, -0.07371120f, -0.03335444f, -0.05290485f, 
    0.00519803f, -0.02830607f, -0.01842497f, -0.00396280f, 0.01671759f, 0.00549624f, -0.06826889f, 0.05139745f, 
    -0.03624517f, 0.00837355f, -0.00042155f, -0.04256811f, 0.02679398f, 0.03862462f, 0.03024027f, 0.03016835f, 
    0.02657714f, -0.03812616f, 0.04232417f, 0.01646319f, -0.06878585f, 0.05410565f, 0.00467549f, 0.03292715f, 
    0.02735198f, -0.01124417f, -0.07216945f, -0.06606188f, 0.02549915f, 0.00892301f, -0.03251614f, 0.00305044f, 
    -0.04554030f, 0.03567420f, 0.01833474f, 0.01282953f, 0.05187772f, -0.05722053f, 0.05550482f, -0.00835848f, 
    0.03292675f, 0.05124627f, -0.06912035f, -0.01373399f, -0.02964057f, 0.04811222f, 0.04094629f, -0.06413783f, 
    0.00683263f, 0.05208874f, -0.06018874f, -0.03358958f, 0.01605066f, 0.01928395f, -0.06375094f, -0.04636681f, 
    0.00628460f, -0.00791939f, 0.02361629f, -0.01051559f, -0.02009285f, 0.06128996f, -0.02215330f, -0.05429518f, 
    0.02785561f, -0.05271213f, 0.05315098f, -0.02402791f, -0.06427216f, -0.06457545f, 0.04727237f, 0.03892508f, 
    0.03368769f, -0.00224849f, 0.00096853f, -0.01097366f, -0.04031389f, -0.03527868f, 0.04813809f, -0.04026101f, 
    -0.03692810f, 0.01287711f, -0.02404175f, -0.06762861f, -0.01296786f, -0.04647508f, -0.00074734f, 0.00589572f, 
    0.04385467f, 0.00452524f, -0.05556628f, 0.05816048f, -0.05157823f, 0.05775065f, -0.00626147f, -0.03647532f, 
    0.03890711f, 0.03419962f, 0.04079429f, 0.00132717f, 0.01793698f, 0.03602191f, -0.02044539f, -0.00421740f, 
    -0.04118165f, 0.05503795f, -0.03500334f, -0.01900904f, 0.03147270f, -0.00615673f, -0.02093261f, -0.04751300f, 
    0.03814158f, 0.03486725f, -0.01407583f, -0.00699788f, 0.03196958f, -0.00228205f, -0.02798079f, 0.02961275f, 
    0.01282176f, 0.00710072f, -0.01131919f, 0.03136311f, 0.05240147f, -0.07413842f, -0.06337912f, 0.04679398f, 
    -0.08185949f, -0.06401797f, 0.04690782f, -0.04094702f, 0.04008628f, -0.00983837f, -0.01196855f, -0.07930132f, 
    0.03920048f, 0.02430540f, -0.05287106f, -0.06090676f, 0.05153227f, 0.06008724f, 0.05182207f, -0.02301404f, 
    0.01686344f, -0.02780491f, 0.00004609f, -0.06189173f, -0.07240220f, -0.05664726f, -0.06701128f, 0.05595028f, 
    0.00218531f, -0.02825279f, 0.00326224f, 0.04576611f, 0.05682927f, -0.04045176f, -0.01003771f, -0.05271316f, 
    -0.03244751f, 0.01392509f, 0.00947842f, -0.00947021f, -0.06824891f, -0.00944383f, 0.04561692f, 0.02581845f, 
    -0.00194445f, -0.06473498f, -0.00897821f, -0.05748317f, 0.02549715f, -0.05864421f, 0.00560909f, -0.05985923f, 
    -0.00725767f, -0.03171544f, 0.01108869f, 0.02634285f, -0.06823088f, 0.00638213f, -0.03152792f, 0.00159285f, 
    0.04499156f, -0.08643322f, 0.01264830f, 0.02574316f, -0.01760699f, -0.05224968f, -0.04024581f, -0.06926838f, 
    -0.07376750f, -0.04455053f, -0.01677022f, -0.00610872f, -0.04701880f, 0.00866128f, 0.00280477f, 0.02817841f, 
    -0.05666644f, -0.07718952f, -0.06879160f, 0.01600099f, -0.00409744f, 0.06015181f, 0.01093277f, 0.01249828f, 
    0.00265590f, -0.07492092f, -0.07791363f, -0.03049422f, 0.05759597f, 0.05163040f, -0.07214845f, 0.01099586f, 
    -0.00973815f, -0.02399068f, 0.02246604f, -0.07329403f, 0.04585736f, 0.02849927f, -0.00962483f, -0.07090391f, 
    0.02260111f, -0.03951955f, -0.01195781f, -0.01024358f, -0.06575536f, 0.00329222f, -0.03400072f, -0.04552294f, 
    0.06380448f, 0.00461544f, -0.02462503f, -0.01652251f, 0.01690395f, 0.01266922f, -0.03820348f, 0.05751684f, 
    -0.00664411f, -0.02796672f, 0.06068287f, -0.01412616f, 0.00790010f, -0.03911497f, -0.04046313f, -0.01337024f, 
    -0.02538464f, 0.00280376f, 0.01695497f, -0.01205075f, 0.01677034f, -0.06181188f, -0.06041666f, -0.00564387f, 
    0.01318811f, 0.01687874f, 0.00659239f, 0.00473563f, -0.00013074f, 0.00382413f, -0.05084017f, 0.00750729f, 
    0.28671134f, 0.15051886f, 0.13291262f, 0.14859907f, 0.03550161f, 0.10689571f, 0.16152216f, 0.02540514f, 
    -0.03549705f, 0.31081983f, 0.18485166f, 0.03011364f, 0.16250362f, 0.03283094f, 0.12780179f, 0.26673308f, 
    0.01971732f, -0.00732156f, 0.08352987f, -0.12522173f, 0.00765573f, -0.12837392f, 0.24810757f, 0.00250094f, 
    -0.59109837f, 0.10526624f, -0.17374077f, 0.09429960f, 0.07679911f, 0.30624261f, 0.09205137f, 0.04092329f, 
    0.22580358f, 0.10280725f, 0.06196013f, -0.08045860f, 0.11691619f, 0.01707223f, -0.08843253f, -0.11129956f, 
    -0.01361892f, 0.12264559f, 0.31178480f, -0.21814062f, -0.03969046f, -0.11969349f, 0.11006317f, -0.04277721f, 
    -0.47603607f, -0.11322773f, 0.19143754f, -0.25488260f, -0.09379887f, -0.00865388f, -0.06934447f, -0.13669561f, 
    0.03990241f, 0.09541899f, -0.05843971f, 0.13614471f, 0.25742504f, -0.05711196f, 0.17849375f, -0.41124618f, 
    -0.01936045f, 0.01425637f, -0.08204401f, -0.20100202f, 0.18732454f, -0.00645240f, 0.01003331f, 0.04357859f, 
    -0.10150937f, 0.01779590f, -0.11857886f, -0.11397570f, -0.39132798f, -0.19684428f, 0.01795049f, 0.09198168f, 
    0.01109153f, -0.03207381f, 0.10548999f, 0.05096041f, -0.12058797f, 0.15966855f, 0.36653185f, -0.00056673f, 
    0.27355653f, 0.17464748f, 0.00003821f, -0.11918492f, 0.04936929f, 0.09330595f, -0.04026853f, -0.13231039f, 
    0.03468130f, -0.06940526f, -0.03276518f, 0.21325487f, 0.07642616f, -0.05013795f, 0.15532684f, 0.09810541f, 
    0.28750214f, -0.07973756f, -0.10016543f, -0.22277679f, -0.15249945f, 0.23827276f, 0.03999790f, 0.17255929f, 
    0.15750572f, -0.01281404f, 0.24888916f, -0.14841744f, 0.03910263f, 0.13694118f, 0.06012434f, 0.11548246f, 
    -0.03894742f, 0.10668605f, 0.19613154f, -0.05904701f, 0.29844931f, 0.01717785f, 0.30465055f, -0.00173375f, 
    0.09103257f, 0.09047232f, 0.08447938f, -0.06028038f, -0.31164455f, 0.02822349f, -0.02544626f, -0.16380396f, 
    -0.10636897f, 0.00519725f, -0.04991407f, 0.13727441f, 0.03188341f, -0.00639026f, -0.19229829f, 0.02838547f, 
    -0.26055914f, -0.38610664f, 0.35827270f, 0.03063613f, -0.07441340f, -0.17731863f, -0.03251633f, -0.12949397f, 
    0.07746003f, 0.03680085f, -0.10091981f, -0.04856530f, -0.44879666f, 0.29124388f, 0.12086762f, -0.18700062f, 
    0.15225261f, 0.12237938f, 0.04220404f, 0.22092928f, 0.03372164f, 0.05705888f, -0.06527364f, 0.09039730f, 
    0.06104747f, 0.27866432f, -0.10555311f, 0.07871530f, 0.08373296f, 0.09476744f, -0.01547998f, 0.25693294f, 
    0.02894138f, 0.01246176f, 0.14041820f, 0.15346247f, -0.46511799f, 0.31920439f, -0.03287404f, 0.11160433f, 
    0.11154655f, -0.00717966f, 0.21961600f, 0.04703788f, 0.10229439f, 0.00654319f, 0.11592543f, 0.11173858f, 
    0.16968930f, 0.37304610f, -0.20766346f, 0.58249378f, -0.11240734f, -0.04705618f, -0.13795321f, -0.08512823f, 
    -0.08923036f, 0.11201025f, 0.09787708f, 0.04349129f, 0.32309097f, -0.20843965f, -0.04454572f, 0.20872895f, 
    0.05467754f, -0.05527684f, 0.00045266f, -0.09856571f, -0.00999562f, -0.11369323f, 0.21977177f, 0.03635656f, 
    -0.40138781f, 0.10003471f, 0.21721277f, 0.12211332f, 0.22577891f, 0.02939166f, 0.07124941f, 0.10405832f, 
    0.22695598f, -0.05042963f, 0.22241329f, -0.21492542f, -0.26999575f, 0.26837876f, 0.06674968f, -0.21883716f, 
    0.37213528f, 0.03072794f, 0.35648167f, -0.26871189f, 0.01447212f, -0.17529769f, 0.04126283f, 0.27609640f, 
    -0.19852185f, 0.08625226f, 0.23564808f, -0.35724664f, 0.17490681f, 0.36008829f, 0.07144891f, 0.01184452f, 
    -0.08058834f, 0.12843461f, -0.09849261f, 0.13131177f, -0.13441215f, -0.14257286f, -0.05475114f, -0.64030588f, 
    0.21179976f, -0.06002304f, -0.17037281f, -0.07967988f, 0.01659962f, 0.03294649f, -0.02867724f, 0.06908014f, 
    0.04068528f, -0.32384598f, -0.38410011f, -0.07846708f, -0.12371374f, -0.19429834f, -0.03984578f, 0.10302552f, 
    0.04989714f, -0.08660337f, 0.10795724f, 0.08426917f, 0.10817715f, 0.17472780f, 0.22706881f, -0.06296892f, 
    0.10557911f, 0.17435575f, 0.05064695f, -0.17673476f, 0.08090574f, -0.05629720f, -0.14995295f, -0.08072003f, 
    0.16638428f, -0.03645881f, -0.00405047f, 0.28100431f, 0.00854680f, -0.11790682f, -0.04927933f, -0.02635348f, 
    -0.02324654f, -0.01049084f, -0.11398144f, -0.08402432f, -0.17099287f, 0.02526147f, 0.22990258f, 0.26660576f, 
    0.01197871f, 0.05391043f, 0.07650743f, -0.05899598f, -0.10524110f, -0.07671164f, 0.00902469f, 0.09619974f, 
    0.16459835f, 0.05188369f, 0.09033450f, 0.13750263f, 0.04279323f, 0.04007093f, 0.02392034f, -0.07727339f, 
    -0.13598752f, 0.22220914f, 0.12502293f, -0.03250133f, -0.23898557f, 0.29795736f, -0.06490134f, -0.31542134f, 
    0.19026896f, 0.10015483f, 0.09409932f, 0.08396970f, -0.00409478f, 0.00536414f, -0.13096926f, 0.12317770f, 
    0.37409797f, -0.31867385f, 0.28855515f, -0.06874956f, 0.00509836f, -0.05542956f, -0.20844811f, -0.07347240f, 
    -0.00232353f, -0.06492563f, 0.06842096f, -0.08937409f, -0.24426512f, 0.13877128f, -0.06541611f, -0.01265612f, 
    0.22626084f, -0.00509906f, -0.05831242f, 0.04519675f, 0.01033050f, 0.08993291f, 0.05635215f, 0.07486269f, 
    0.08039173f, -0.04814804f, 0.00062973f, 0.12406202f, 0.07293507f, 0.09092392f, 0.12688714f, 0.28857023f, 
    -0.16465940f, 0.14005803f, -0.08477566f, -0.04569332f, -0.22738591f, 0.08938356f, -0.12933226f, 0.13792853f, 
    0.16297062f, 0.02753448f, 0.43430203f, 0.00576702f, 0.10904956f, 0.16618136f, 0.04612394f, 0.06613921f, 
    -0.31584603f, 0.47439185f, -0.17835756f, -0.03598054f, -0.10155717f, 0.10477588f, 0.00133303f, -0.33755299f, 
    0.18528225f, -0.04005411f, -0.07435171f, -0.23926885f, -0.23058744f, 0.22799729f, 0.00732565f, -0.29424369f, 
    0.10774060f, 0.28050086f, 0.21048278f, -0.00057695f, 0.00960083f, -0.04141885f, -0.13880046f, 0.01046031f, 
    -0.03513075f, -0.29113227f, 0.25733188f, -0.03223194f, 0.00261326f, -0.04774016f, 0.13730560f, 0.09813061f, 
    -0.00101227f, 0.02618255f, -0.09010604f, -0.05278955f, -0.31838828f, -0.29054770f, 0.07935612f, 0.23194234f, 
    0.12434795f, -0.04191974f, -0.03001009f, 0.10909078f, 0.03968722f, 0.21081176f, 0.07656317f, 0.22005861f, 
    0.22348869f, 0.09869722f, -0.25855383f, -0.07844249f, 0.11461900f, -0.01930019f, -0.15908936f, 0.16399749f, 
    0.11647409f, -0.01750792f, 0.04529282f, -0.10721245f, 0.02002168f, 0.16518445f, -0.22434627f, -0.41910467f, 
    0.02368082f, 0.07517038f, -0.07710107f, -0.00314931f, -0.10685565f, 0.07241583f, -0.18036452f, -0.21303605f, 
    0.11679621f, -0.09271778f, -0.03651939f, -0.25110897f, 0.09408092f, -0.04886187f, 0.07471333f, 0.18684737f, 
    0.09610227f, 0.06271364f, 0.03817387f, 0.10415184f, 0.13846537f, -0.02810154f, -0.26046827f, -0.06251635f, 
    0.07033971f, 0.09659480f, -0.03013106f, 0.00817645f, -0.00379328f, -0.02473166f, 0.11862219f, 0.02571122f, 
    0.12160824f, 0.22180870f, 0.06150396f, 0.17114392f, -0.05728636f, 0.08228548f, 0.17746297f, 0.10457753f, 
    -0.10753268f, 0.21729863f, 0.11552778f, 0.02641672f, 0.47217160f, 0.01028705f, 0.09178275f, 0.14249574f, 
    -0.10805694f, -0.01792664f, 0.11802490f, 0.16546781f, -0.00913161f, -0.02013013f, -0.06597012f, -0.05519572f, 
    -0.38416305f, 0.19152430f, 0.02992201f, -0.09139229f, -0.02337299f, -0.14174753f, -0.00143541f, -0.18106891f, 
    -0.00794211f, 0.09307437f, 0.07956091f, -0.02951779f, -0.07584749f, -0.36861885f, -0.02510871f, 0.03752619f, 
    0.08763574f, -0.34395495f, -0.08396702f, -0.02834906f, 0.16058335f, 0.08914044f, -0.08989296f, -0.01392858f, 
    0.71409911f, 0.18812425f, -0.30617815f, 0.07481008f, 0.02206974f, 0.12412016f, 0.15317544f, -0.00445810f, 
    -0.04408560f, -0.01115604f, 0.00072719f, 0.11585547f, -0.19921704f, 0.07802276f, -0.09853794f, 0.01615467f, 
    -0.01080420f, -0.06962906f, -0.09154833f, 0.08208526f, 0.11001438f, 0.05086493f, -0.00159670f, 0.04486459f, 
    0.46224019f, -0.07337178f, 0.12530066f, 0.00415279f, -0.15977956f, -0.22915396f, 0.12259153f, -0.14368609f, 
    -0.09526987f, -0.03409814f, -0.31727171f, -0.10052188f, 0.35929433f, -0.20946382f, 0.34627283f, 0.10480311f, 
    -0.00082496f, -0.07984488f, 0.18664688f, 0.03649637f, 0.14398098f, -0.08178963f, -0.01342498f, 0.06122452f, 
    -0.08354716f, -0.04061861f, 0.03797488f, -0.18771887f, 0.09278214f, 0.11327299f, 0.33291173f, 0.06577168f, 
    0.08066048f, 0.10330742f, 0.04088572f, 0.14223808f, -0.47856313f, 0.28884211f, 0.29557374f, 0.11231641f, 
    -0.08034997f, -0.10114893f, 0.09963730f, -0.03325687f, 0.05957730f, 0.01822991f, 0.08682487f, 0.10459927f, 
    0.08321257f, -0.14167526f, -0.41228479f, 0.15132040f, 0.03242362f, 0.03881557f, 0.01416247f, 0.00350554f, 
    -0.08218194f, 0.10390721f, -0.06068274f, 0.12825169f, 0.36171478f, -0.03123424f, -0.00014795f, -0.12360965f, 
    -0.07072638f, 0.10109165f, 0.02718368f, -0.01838630f, 0.03063777f, -0.17457767f, 0.10654560f, -0.13047992f, 
    -0.07530708f, -0.19116239f, -0.25783861f, 0.29929349f, -0.07226741f, -0.16848095f, -0.19467114f, 0.02969945f, 
    0.01545228f, 0.22055712f, 0.09426683f, -0.00341541f, 0.33528072f, 0.16962865f, 0.29577753f, 0.18718800f, 
    -0.19560109f, -0.05718271f, 0.16458544f, -0.04066712f, 0.03326938f, -0.11910617f, 0.24354686f, -0.02749056f, 
    -0.11261257f, 0.34812343f, 0.22001554f, 0.14171948f, -0.22542377f, 0.01554738f, 0.09046810f, 0.02941582f, 
    -0.01955245f, 0.17581357f, 0.17618790f, -0.12634395f, -0.22610617f, 0.01075324f, 0.32278642f, 0.05553086f, 
    0.15514551f, -0.16123945f, 0.02334156f, 0.08117530f, -0.05983083f, 0.04415222f, 0.00323265f, 0.03095062f, 
    -0.30346996f, -0.14732799f, 0.00579331f, -0.00515595f, 0.03754796f, 0.03952150f, 0.06164438f, 0.06057969f, 
    0.28512138f, -0.08167500f, 0.12224495f, -0.08646514f, -0.07873509f, 0.01693256f, -0.11694192f, -0.22452383f, 
    -0.02126587f, -0.11623883f, -0.03209504f, -0.19164328f, -0.02511461f, 0.07296073f, -0.01914845f, 0.19094948f, 
    -0.47820842f, -0.11062331f, -0.12830423f, -0.28170091f, 0.08461227f, 0.04943493f, 0.15632083f, 0.03426003f, 
    0.13132481f, -0.07345214f, -0.02909009f, 0.04020568f, 0.26379377f, -0.09194432f, 0.09376015f, 0.47147760f, 
    -0.08998637f, 0.10390279f, -0.01010391f, 0.12401909f, 0.12920476f, 0.02873096f, 0.05496304f, 0.04974175f, 
    -0.30125439f, 0.25073317f, 0.18198396f, 0.28589633f, -0.14558271f, 0.01095074f, 0.13843237f, 0.11565877f, 
    0.06057142f, 0.02438787f, 0.00790370f, -0.09764270f, -0.88340271f, 0.48017865f, 0.01204033f, -0.16034742f, 
    0.18677354f, 0.04344218f, 0.23417823f, -0.03331776f, 0.07985042f, -0.17042387f, 0.06828871f, 0.02197154f, 
    0.17682883f, -0.02464550f, -0.06563727f, -0.08589217f, -0.04733108f, 0.04150733f, -0.19658376f, 0.00816530f, 
    0.04388300f, 0.07133693f, -0.02755925f, 0.15378337f, -0.35198855f, 0.05640079f, 0.02122585f, -0.13805646f, 
    -0.04678564f, 0.03147560f, -0.03445864f, 0.14202479f, -0.02686815f, 0.02304953f, 0.27575442f, 0.15900181f, 
    -0.16940123f, 0.11489611f, -0.22527371f, -0.14239310f, -0.07821177f, -0.07619336f, 0.20875901f, -0.05691633f, 
    -0.00054945f, 0.02380676f, 0.01135013f, 0.17205997f, -0.51450324f, 0.32424119f, 0.13286236f, -0.11250805f, 
    0.05177584f, -0.04079094f, 0.01368726f, 0.00387305f, -0.03633866f, -0.10818585f, 0.04875083f, -0.17785335f, 
    0.26429081f, -0.34720626f, -0.06738991f, 0.05049387f, 0.13084282f, -0.16291377f, 0.07031850f, 0.11401282f, 
    -0.25265270f, -0.00850685f, -0.06770511f, -0.00366834f, 0.58138633f, -0.39996102f, 0.02776498f, 0.00111198f, 
    -0.00279120f, -0.08817982f, -0.06280366f, -0.09551123f, -0.01815116f, -0.04118564f, 0.04224581f, -0.03143652f, 
    0.44686559f, 0.04454784f, -0.35467532f, -0.03047762f, -0.18080571f, -0.03900430f, -0.05285734f, 0.19805951f, 
    -0.18657760f, 0.05590066f, -0.01793821f, -0.18053299f, 0.48347777f, 0.18418814f, -0.03061709f, 0.40638193f, 
    0.02163043f, 0.03021225f, 0.10998783f, 0.13873890f, 0.09655266f, -0.05044042f, 0.16526894f, 0.07280038f, 
    0.44637659f, -0.08015514f, -0.12415256f, 0.25394279f, -0.14043252f, -0.01723693f, 0.15315643f, 0.11970791f, 
    -0.00494719f, 0.28081679f, 0.00884063f, -0.09318438f, -0.25380334f, 0.13447027f, 0.10947572f, 0.14700203f, 
    0.09027193f, -0.16260919f, -0.04962174f, 0.14378580f, -0.00788141f, 0.00274671f, -0.03901123f, -0.10537811f, 
    0.16392824f, 0.08694644f, -0.13839278f, 0.21278381f, -0.01335913f, 0.13273220f, 0.07608247f, 0.12763764f, 
    0.14999971f, 0.00705334f, 0.02126848f, -0.14047709f, -0.24442281f, -0.15988685f, -0.01578688f, 0.07798629f, 
    0.03791809f, -0.12675720f, 0.05154385f, -0.14828838f, 0.05011784f, -0.07176226f, 0.07182897f, -0.05206209f, 
    -0.04896059f, 0.06598692f, -0.03325364f, 0.11659393f, -0.12724972f, -0.06747171f, 0.12546693f, -0.05358547f, 
    0.01658465f, 0.01307399f, 0.09344195f, 0.11204797f, 0.65748435f, -0.14936113f, 0.04905593f, 0.57021582f, 
    0.14793015f, 0.05241548f, -0.08690659f, 0.15861280f, 0.02737591f, -0.15314719f, -0.10038499f, 0.04684407f, 
    0.34656298f, 0.14861000f, -0.18584551f, 0.21276784f, -0.25371388f, 0.00577329f, 0.20457360f, -0.01814796f, 
    0.09344962f, -0.01296371f, -0.11779474f, -0.23438194f, -0.55802631f, 0.38098764f, -0.11906636f, -0.05441793f, 
    0.09900142f, -0.04064225f, 0.24446481f, -0.02854871f, 0.02259216f, -0.04226414f, 0.02790356f, 0.07230197f, 
    0.56917191f, -0.00952735f, 0.13680252f, 0.03051482f, 0.07089016f, -0.10560981f, -0.09554525f, 0.23297398f, 
    0.01343686f, 0.03774713f, -0.08295244f, -0.00191977f, 0.06179536f, -0.32028511f, 0.04962660f, 0.05562179f, 
    -0.10927287f, 0.09631595f, 0.16367425f, 0.13978393f, -0.13674885f, 0.05909117f, 0.10978929f, -0.07348606f, 
    0.04101960f, 0.07440373f, 0.00195439f, 0.00390824f, 0.05472302f, 0.00706543f, -0.06466319f, -0.03297801f, 
    -0.01980874f, -0.06797513f, -0.00062283f, 0.06366149f, -0.00652209f, 0.04124335f, 0.07047842f, -0.05476621f, 
    -0.08180442f, -0.04045111f, -0.07437252f, -0.04816844f, -0.06292028f, 0.06023604f, -0.03579248f, 0.07095025f, 
    0.00009489f, -0.00185384f, 0.05604508f, 0.02717517f, 0.04717812f, 0.04808620f, -0.04610069f, -0.02770995f, 
    -0.01443395f, 0.00422943f, 0.00415799f, -0.00813835f, -0.03630671f, -0.03662601f, 0.05064476f, -0.05143996f, 
    0.06216405f, -0.06625857f, 0.00920579f, -0.00895392f, -0.05234946f, -0.02044781f, -0.06722502f, 0.03308850f, 
    0.06524140f, -0.00851192f, -0.00961312f, -0.06829194f, -0.05279072f, 0.02894519f, -0.00778738f, -0.04452752f, 
    0.05423009f, 0.04738248f, -0.04769932f, -0.01272001f, -0.03611917f, -0.05871952f, -0.02348543f, -0.05945983f, 
    -0.03320431f, -0.02565375f, 0.02075927f, -0.05255739f, 0.04752563f, -0.05798797f, -0.06827160f, 0.00078599f, 
    -0.04275339f, 0.03156928f, 0.02428831f, -0.03665652f, 0.04027532f, 0.01655250f, 0.06722161f, -0.01514720f, 
    -0.00832094f, -0.01530194f, -0.06295696f, -0.04177729f, 0.02566493f, 0.05871025f, -0.01374345f, 0.01198193f, 
    0.06089079f, -0.06996513f, -0.01242159f, -0.06197366f, -0.07083438f, -0.01395307f, -0.06256028f, 0.04112889f, 
    -0.04956439f, -0.04426560f, -0.03090892f, 0.01855160f, -0.06498861f, -0.02024315f, -0.04298054f, -0.07611617f, 
    0.03231106f, -0.06306794f, -0.04357893f, -0.03611563f, 0.02558782f, -0.00994876f, 0.06688176f, 0.00775163f, 
    0.05010799f, -0.01749469f, 0.06135992f, 0.03493628f, 0.00631987f, -0.05139018f, 0.04223803f, 0.06276374f, 
    0.00324920f, 0.01432684f, -0.01516112f, 0.01700287f, -0.04983243f, -0.00147664f, -0.07952689f, 0.02371970f, 
    0.02926985f, 0.00532707f, -0.04494056f, -0.08002867f, -0.04709632f, 0.03276756f, -0.06946374f, 0.02223397f, 
    -0.06864510f, 0.01994159f, -0.02531384f, -0.06782623f, -0.02493140f, 0.03318075f, 0.06261812f, 0.04189417f, 
    -0.00871497f, -0.05525487f, 0.03935529f, -0.03560602f, -0.04112495f, 0.00549711f, -0.04948418f, -0.00466831f, 
    0.01450992f, 0.03588512f, -0.04204175f, 0.02192778f, 0.06992687f, 0.00161469f, -0.05289739f, 0.05397791f, 
    -0.06737857f, -0.06931511f, -0.03020669f, 0.04399673f, 0.03357355f, -0.00060049f, 0.02272895f, -0.03859966f, 
    -0.03144260f, -0.00344065f, -0.02976200f, -0.05690727f, 0.03499611f, -0.02920164f, 0.00067855f, 0.02639281f, 
    -0.06511736f, -0.05702265f, -0.07035116f, -0.00938104f, -0.04561055f, -0.06515874f, -0.06003947f, -0.00383878f, 
    0.03343960f, 0.02426688f, 0.03366240f, -0.02226868f, 0.01712898f, -0.01217270f, 0.03275336f, 0.04030015f, 
    -0.00398444f, 0.53382713f, 0.07715869f, 0.21964593f, -0.06021100f, -0.12824528f, -0.04329537f, 0.14418873f, 
    0.01523315f, 0.31713283f, -0.02953155f, 0.30076531f, 0.12894922f, -0.30757311f, -0.03380377f, 0.10769153f, 
    -0.27619261f, -0.04989833f, -0.02308924f, -0.18558878f, 0.07698875f, 0.02017022f, 0.36572972f, 0.04979416f, 
    -0.17425764f, 0.56288469f, -0.14716183f, 0.23061195f, -0.03371897f, -0.13166197f, -0.15860619f, 0.17894851f, 
    0.30214942f, 0.10093793f, 0.13234456f, -0.04960692f, -0.06514104f, 0.56197411f, 0.10535156f, -0.06600597f, 
    0.03349343f, 0.16774958f, 0.25242794f, -0.14213198f, -0.13364631f, -0.33942747f, -0.16715187f, -0.22214988f, 
    0.05406949f, 0.25011432f, 0.13121325f, -0.20940185f, -0.11207095f, 0.11122453f, -0.03389085f, -0.12686633f, 
    -0.16177848f, 0.22252555f, 0.02934341f, 0.08534383f, 0.30821505f, -0.14802955f, 0.28261942f, -0.04424353f, 
    0.15625739f, -0.07824867f, 0.06082221f, -0.03014109f, 0.17938156f, 0.01517724f, 0.06862684f, 0.02458478f, 
    -0.12138978f, 0.23454696f, 0.10410365f, 0.10803032f, 0.03632911f, 0.01142402f, 0.00609402f, -0.07766318f, 
    -0.00483408f, 0.13133080f, 0.42147407f, -0.18322513f, 0.19351001f, -0.16466254f, 0.16419578f, -0.23317333f, 
    0.06251017f, -0.00621440f, 0.22177902f, -0.14558657f, 0.11685139f, 0.06078972f, -0.18013498f, -0.09849502f, 
    -0.19693191f, -0.17945389f, 0.09893280f, 0.04335255f, -0.12578420f, 0.00013617f, -0.10114940f, -0.11368815f, 
    0.18010825f, -0.42256096f, -0.13969043f, -0.28040147f, -0.07910605f, 0.23118405f, 0.24975313f, 0.31917521f, 
    0.04311063f, 0.23024134f, -0.01348717f, -0.18804181f, -0.07532775f, -0.00157098f, -0.11237197f, -0.07951085f, 
    -0.01236034f, 0.08844861f, 0.11432608f, 0.14483000f, 0.05766050f, -0.03411561f, -0.10402977f, -0.11525422f, 
    -0.02843281f, -0.06280471f, -0.06916380f, -0.13876662f, 0.19302222f, 0.66796947f, -0.28223050f, -0.02485044f, 
    0.01186562f, 0.06670842f, 0.06377214f, 0.10986550f, -0.17388909f, -0.00698376f, -0.08463715f, -0.08669506f, 
    0.55145645f, -0.23363994f, -0.16558358f, -0.09937545f, 0.08624191f, -0.10576475f, -0.08721991f, -0.11823887f, 
    -0.20456904f, -0.05201344f, 0.00914442f, -0.04676783f, 0.16731489f, -0.09208862f, 0.33726668f, -0.25493991f, 
    0.02323517f, -0.02453769f, 0.13599576f, -0.20730315f, 0.07077102f, -0.01822286f, 0.12900701f, 0.05869420f, 
    -0.12617655f, -0.18681660f, 0.17812914f, -0.03267253f, -0.06816150f, 0.44055483f, -0.03449028f, 0.29933378f, 
    0.06260709f, 0.22278734f, 0.04882047f, -0.04926779f, -0.63791281f, 0.05004813f, 0.03102545f, 0.13801235f, 
    -0.08172137f, 0.09781378f, -0.17075676f, -0.16209459f, 0.05075645f, 0.11919178f, 0.06055662f, 0.02669686f, 
    -0.06620019f, -0.14657311f, 0.01556529f, -0.11498554f, 0.06700255f, 0.00507681f, -0.08743034f, 0.08227415f, 
    0.05817087f, -0.12002121f, -0.06478211f, -0.09812687f, -0.31393981f, -0.29816636f, -0.13570572f, 0.52106839f, 
    0.06990034f, -0.03664204f, -0.04770792f, 0.13213275f, -0.02044286f, 0.23764953f, 0.01488219f, 0.01750492f, 
    0.06220216f, -0.10593244f, -0.01172551f, -0.20015524f, 0.07478171f, -0.01461423f, 0.04385643f, -0.14354393f, 
    0.05415821f, 0.03381619f, -0.15519014f, 0.02713654f, -0.31946728f, 0.25348037f, 0.05900248f, -0.09694128f, 
    0.17531270f, -0.07521901f, -0.12185770f, 0.12653017f, 0.01240868f, -0.01950079f, -0.05075623f, 0.12736292f, 
    0.29562190f, 0.35789785f, 0.38734600f, 0.07545357f, 0.13877368f, -0.07756818f, 0.04970612f, 0.22327161f, 
    0.02313288f, -0.02585742f, 0.18063444f, -0.06023973f, 0.07861549f, 0.16384831f, 0.27946660f, 0.10354424f, 
    0.07492525f, 0.03605345f, -0.14644174f, -0.12147686f, -0.12887430f, 0.10481941f, -0.18724276f, 0.18439187f, 
    0.01887518f, 0.07460801f, 0.45597044f, -0.25036135f, 0.20300068f, 0.10929927f, 0.15159301f, -0.15870570f, 
    0.09025877f, 0.01749359f, 0.10937806f, 0.03018916f, -0.15329769f, 0.11658709f, -0.26464152f, 0.12501274f, 
    0.10342635f, -0.08816135f, 0.17776072f, 0.07775911f, 0.06289363f, -0.03618783f, 0.12941536f, 0.14504798f, 
    -0.32453594f, -0.25951198f, 0.03903520f, -0.12529102f, 0.25644463f, 0.11246691f, -0.20884195f, -0.04008799f, 
    0.07277320f, 0.02458908f, -0.04471048f, -0.15969171f, -0.04999923f, -0.45717177f, -0.35470667f, -0.18690203f, 
    0.19104566f, 0.19221899f, -0.17440635f, 0.03757965f, -0.15256236f, -0.24556568f, -0.10201623f, 0.02526711f, 
    -0.57133746f, -0.06445630f, -0.23590706f, 0.20460780f, 0.08615947f, 0.07408669f, 0.02230893f, 0.08961571f, 
    0.04142005f, -0.09054208f, -0.05927624f, 0.05385072f, 0.23425002f, 0.20994501f, 0.15931569f, 0.04776750f, 
    0.10176367f, 0.12231152f, 0.11418008f, -0.23457141f, 0.12858710f, -0.05510818f, 0.26896340f, 0.19034845f, 
    0.64755297f, 0.27424544f, 0.38989729f, 0.32569245f, -0.14198382f, -0.12876280f, -0.17905886f, 0.04019178f, 
    0.07933255f, 0.17959985f, 0.05874109f, 0.14296153f, -0.76728076f, 0.26030785f, -0.15379201f, -0.13858983f, 
    0.40374738f, -0.06486905f, -0.02470442f, 0.06824623f, -0.03182643f, 0.02080044f, 0.10237490f, -0.08723451f, 
    -0.47399831f, -0.32467717f, -0.18678175f, -0.26601005f, 0.26715451f, 0.14725855f, 0.11149678f, -0.22568817f, 
    -0.02769490f, 0.23390508f, -0.04606954f, -0.17278209f, 0.00868282f, -0.10232330f, 0.06731194f, -0.22372784f, 
    0.25604373f, 0.11181946f, 0.22827737f, 0.03217966f, 0.04008264f, 0.02226963f, 0.01303636f, 0.31006825f, 
    -0.05528288f, 0.05475800f, 0.10451730f, -0.04533961f, -0.19517234f, -0.14626455f, -0.03421025f, 0.15905385f, 
    -0.16772671f, 0.06137118f, -0.02420342f, 0.24197859f, 0.23814128f, 0.29266903f, 0.12187868f, -0.41890451f, 
    -0.01401409f, 0.13729958f, 0.10084232f, 0.02305002f, 0.07410964f, 0.00681525f, 0.20210560f, -0.13961948f, 
    -0.03136593f, 0.29869550f, 0.37623492f, -0.02143615f, 0.05262384f, -0.07248266f, 0.01996404f, 0.22353929f, 
    0.00772434f, 0.00452493f, 0.12834443f, 0.02722665f, 0.18376249f, 0.03024564f, -0.32895166f, 0.27934492f, 
    0.03296623f, -0.06942546f, 0.13995866f, -0.20459351f, 0.01506748f, 0.00701133f, 0.01114303f, -0.03378939f, 
    0.04738579f, -0.22025819f, -0.17109819f, -0.02418860f, -0.04850603f, 0.26370665f, 0.30743963f, -0.12262625f, 
    0.02213806f, 0.08246243f, 0.02799755f, -0.00180850f, 0.25023982f, -0.15370497f, -0.08792018f, 0.34270880f, 
    0.12237277f, -0.06156166f, 0.04711410f, -0.05108349f, 0.02727954f, 0.03592880f, 0.30770814f, 0.08761716f, 
    0.25531206f, -0.33162937f, -0.40344808f, 0.16625693f, -0.23139831f, -0.06318370f, -0.17676722f, 0.06155365f, 
    -0.02305882f, 0.16741921f, 0.02577023f, -0.01567906f, -0.56234491f, -0.04733497f, 0.19899192f, 0.00446052f, 
    0.11719837f, 0.11541059f, 0.06920567f, -0.17182049f, 0.08542679f, 0.01369360f, -0.25189948f, -0.04133121f, 
    0.54653388f, 0.03030190f, 0.00393642f, -0.20684330f, -0.09493037f, -0.00791105f, 0.19080530f, 0.14458840f, 
    -0.11856745f, -0.05986925f, -0.03351355f, -0.09078429f, -0.44133160f, 0.01999601f, 0.35306096f, 0.22961907f, 
    0.01807808f, -0.08387139f, 0.17113091f, 0.03185567f, 0.05140970f, 0.02373111f, 0.08261351f, -0.16028661f, 
    0.41618228f, 0.01840624f, 0.03153893f, 0.07822628f, -0.07308218f, -0.13557668f, 0.00300564f, 0.09929312f, 
    -0.13954516f, 0.23820838f, 0.20455259f, 0.04203096f, 0.27965105f, 0.16628432f, -0.17320816f, -0.01291955f, 
    0.09912731f, 0.05411634f, -0.06910989f, 0.13406532f, -0.08203104f, 0.04095348f, -0.18947767f, -0.18742952f, 
    -0.37710389f, -0.31567863f, 0.02708402f, -0.01719764f, -0.03585582f, 0.10055103f, -0.00931398f, -0.20186912f, 
    0.05542799f, -0.08424571f, -0.07481354f, -0.18176430f, 0.21280731f, -0.16326271f, 0.03936082f, 0.48739648f, 
    -0.16159798f, -0.05973174f, 0.08133452f, 0.00490607f, -0.01951328f, 0.05066999f, 0.11160169f, 0.11297502f, 
    -0.19670907f, -0.13612625f, 0.06154991f, 0.10366599f, 0.06647218f, 0.05351168f, 0.01140525f, 0.37988818f, 
    0.07207212f, -0.13425782f, 0.26021910f, 0.17278056f, 0.05990019f, 0.35334641f, -0.29072362f, 0.27252141f, 
    -0.02577960f, -0.03333909f, 0.02462185f, -0.02356978f, 0.06724724f, 0.00789959f, -0.03070114f, -0.24964297f, 
    -0.03171629f, 0.02863402f, 0.03688912f, 0.01593271f, -0.06150967f, 0.05808459f, -0.06113709f, -0.00054808f, 
    -0.02038918f, 0.03871505f, -0.03852783f, -0.03467630f, 0.00464152f, 0.00791433f, 0.03869392f, -0.02824043f, 
    0.04695923f, -0.02092160f, -0.07262708f, 0.03440798f, 0.04448056f, -0.01068853f, -0.02343340f, 0.04423050f, 
    -0.04010521f, -0.02589787f, -0.01363893f, -0.05447916f, -0.00688005f, -0.00169723f, -0.05321614f, -0.03863453f, 
    0.05722839f, 0.04646478f, 0.00847979f, 0.02644436f, -0.01592661f, 0.01066783f, 0.04996020f, -0.04128575f, 
    -0.03468146f, -0.06265305f, -0.07034602f, -0.03571678f, 0.05531177f, -0.05499705f, -0.00938741f, -0.02841652f, 
    -0.00993070f, 0.01608845f, -0.05057238f, -0.01534235f, -0.05034002f, 0.05329553f, -0.02795193f, 0.03930821f, 
    0.05381181f, -0.07258528f, 0.01400947f, -0.01520560f, 0.02451980f, -0.04263785f, -0.05429480f, 0.00102682f, 
    -0.02415860f, -0.01656923f, 0.03187210f, -0.01272564f, 0.05290750f, -0.04309734f, -0.01920157f, -0.05821875f, 
    -0.04915679f, 0.00747573f, -0.01126526f, 0.03390176f, 0.00135464f, 0.01761969f, -0.04352653f, 0.02058546f, 
    0.04893621f, -0.04776270f, -0.04934898f, 0.02905593f, -0.04002152f, -0.05781088f, 0.04396164f, -0.04882461f, 
    -0.05905754f, -0.06674337f, 0.06198400f, -0.06567498f, -0.00432165f, -0.04769447f, -0.04727757f, -0.02110297f, 
    -0.06637353f, -0.01649831f, -0.05487523f, 0.01115824f, 0.03019114f, 0.04900031f, -0.03743075f, -0.01568585f, 
    -0.07770729f, 0.04333131f, -0.00495245f, -0.07207804f, -0.05272847f, -0.02067734f, 0.02892833f, 0.05787323f, 
    0.04274723f, 0.03322870f, -0.02490795f, -0.05194211f, 0.03068779f, 0.05777698f, -0.06737199f, 0.02377695f, 
    0.01330051f, -0.02340716f, 0.00143904f, -0.03607289f, 0.03952263f, 0.01949536f, 0.05108236f, 0.03003530f, 
    -0.03070490f, 0.01842135f, -0.05704576f, -0.06952699f, 0.05344401f, -0.07315827f, -0.07141651f, -0.06624046f, 
    -0.06411599f, 0.02900894f, -0.02566172f, -0.07982831f, -0.04918103f, 0.05594467f, 0.01917021f, -0.00665388f, 
    0.05260405f, 0.06424358f, -0.01105654f, -0.06525666f, -0.01384350f, 0.02892074f, 0.02355798f, -0.01604773f, 
    0.01905482f, -0.07134919f, -0.06514890f, -0.03048977f, 0.05348822f, -0.02277998f, -0.07563941f, -0.04336825f, 
    -0.06221491f, 0.03024055f, -0.05065272f, -0.06376287f, 0.03086932f, 0.05612476f, -0.04291809f, -0.06594747f, 
    0.01997688f, 0.00912746f, -0.04640817f, -0.04315542f, 0.04013242f, -0.04596544f, 0.05926180f, 0.06039491f, 
    0.00747324f, -0.06232558f, 0.00679789f, -0.06911981f, -0.01210274f, -0.04456346f, -0.03407494f, 0.04404736f, 
    0.01077309f, 0.04426048f, 0.00327453f, 0.00563267f, 0.04358164f, -0.02074500f, 0.01078421f, -0.03431332f, 
    -0.00337840f, 0.02639884f, -0.00425404f, 0.04160766f, -0.05018947f, 0.03394873f, -0.06998449f, 0.05935142f, 
    -0.03685378f, 0.04023112f, 0.03964475f, -0.06330500f, 0.04058477f, 0.02088635f, 0.02711578f, 0.01087458f, 
    0.00225815f, -0.03061832f, 0.06840984f, -0.05703949f, -0.03175364f, -0.00945331f, 0.03924339f, -0.06080004f, 
    0.03229276f, 0.06253465f, -0.07161139f, -0.05178292f, -0.06591640f, -0.06972567f, -0.03699088f, -0.02428577f, 
    0.05195868f, -0.00161290f, -0.01196268f, 0.02367870f, -0.06212574f, 0.05014246f, 0.02450795f, -0.06250217f, 
    -0.02365195f, -0.07111838f, -0.04115497f, -0.04931881f, 0.02617128f, 0.00861361f, 0.05246914f, -0.02132087f, 
    -0.03364033f, -0.04680237f, -0.01320724f, -0.02912441f, -0.02855553f, 0.06334118f, 0.04568695f, -0.02546004f, 
    0.05325472f, -0.04618412f, 0.04320762f, -0.03212247f, -0.02774506f, -0.02861685f, -0.04557450f, -0.00724454f, 
    0.00623570f, 0.02495199f, -0.01236023f, -0.02988190f, 0.00166967f, -0.02678744f, 0.03164317f, 0.06014413f, 
    0.02987094f, 0.00240196f, 0.04188473f, 0.04456659f, -0.01912629f, 0.02008837f, -0.04212198f, 0.04536427f, 
    -0.05045433f, -0.00251708f, -0.00356929f, -0.04848340f, -0.02177241f, -0.05121034f, 0.00487904f, 0.02635668f, 
    -0.04496651f, 0.03903389f, -0.00951212f, -0.03483989f, -0.04990932f, -0.00787684f, 0.04451989f, -0.06701756f, 
    -0.01557271f, -0.07063624f, -0.00585959f, 0.02306516f, -0.00914163f, 0.04921486f, -0.06880655f, -0.05527458f, 
    0.03323715f, -0.01841596f, -0.03845003f, -0.03579284f, 0.00442797f, -0.04919073f, -0.06878944f, 0.00615987f, 
    -0.04531009f, 0.01517615f, 0.05688214f, -0.07144317f, -0.06762493f, -0.03927220f, -0.01887478f, -0.06238304f, 
    -0.03089371f, 0.00761000f, 0.00359507f, -0.04296088f, 0.03790737f, -0.07892065f, -0.06093807f, -0.02696478f, 
    0.06271897f, -0.04773813f, 0.02457369f, 0.05821102f, 0.00166730f, -0.01135720f, 0.03937960f, -0.04180933f, 
    0.01778493f, -0.03697721f, -0.00792983f, 0.05081666f, 0.04876250f, -0.05842461f, 0.03424011f, 0.05765429f, 
    -0.05934797f, -0.06189143f, -0.03112257f, 0.04454170f, 0.00162853f, 0.02289514f, -0.05523966f, 0.00775426f, 
    -0.03817188f, 0.04080489f, -0.06130824f, -0.07048073f, -0.04778164f, 0.00704956f, 0.05196570f, -0.02112518f, 
    0.00408040f, -0.05013449f, -0.01544061f, -0.02296226f, 0.03990916f, 0.03876050f, -0.02021794f, -0.06809975f, 
    0.04033180f, -0.04800543f, -0.07630210f, 0.03054384f, 0.04964033f, 0.02829898f, -0.05291011f, -0.01461447f, 
    -0.02345634f, -0.07711926f, 0.01139199f, 0.05879107f, -0.06159451f, 0.03294543f, 0.01088991f, -0.03634429f, 
    0.05008151f, 0.06053348f, -0.04137285f, -0.02364935f, -0.01344664f, -0.04330463f, 0.05460565f, 0.00187454f, 
    0.01662963f, 0.13939479f, 0.09860058f, -0.31623164f, 0.01089566f, -0.07771039f, 0.35346904f, -0.06744565f, 
    0.04299033f, -0.01750797f, 0.04666775f, 0.10309319f, -0.17872198f, 0.58119810f, -0.34032315f, -0.13408594f, 
    0.13529396f, -0.00381402f, 0.01414442f, 0.03365144f, -0.00988255f, -0.07803514f, 0.04977280f, -0.20821510f, 
    0.21679802f, -0.37773326f, 0.12251904f, -0.31522259f, -0.03394873f, 0.05442228f, 0.31002358f, 0.14089908f, 
    -0.07910248f, -0.02885370f, 0.18104146f, 0.00827139f, 0.08882421f, -0.25387266f, -0.22851573f, 0.40042675f, 
    -0.36533704f, 0.12359387f, 0.15459223f, -0.05950045f, -0.14029340f, 0.06390184f, -0.00906751f, 0.04047316f, 
    0.01195457f, -0.05360358f, -0.39286450f, 0.24019124f, -0.23001556f, -0.11642470f, 0.02716857f, -0.07317875f, 
    -0.00373501f, 0.11420947f, -0.05401209f, -0.07555759f, 0.13887337f, 0.36688399f, -0.47074121f, 0.24975856f, 
    -0.20415269f, -0.11124005f, 0.11080845f, -0.06279640f, 0.10326683f, -0.03954324f, 0.04456411f, -0.06276857f, 
    0.07722655f, 0.00269081f, 0.22360234f, -0.09850360f, -0.04764261f, 0.09453673f, -0.16180643f, 0.08734672f, 
    0.06174036f, 0.14618832f, -0.01261081f, -0.01086871f, 0.23112425f, -0.39174670f, -0.35068211f, 0.15036076f, 
    -0.04455078f, 0.09223786f, 0.06100338f, -0.06840661f, -0.04102658f, 0.15738370f, 0.04125204f, 0.06628407f, 
    0.27587843f, 0.15497230f, -0.08631541f, -0.41259155f, 0.01548087f, 0.04131250f, 0.26712039f, 0.12302438f, 
    -0.03080257f, 0.01367380f, -0.19044285f, -0.09536399f, 0.57044637f, 0.13292940f, -0.04876679f, -0.28396139f, 
    0.05512003f, -0.12404303f, 0.29976711f, 0.31118944f, 0.12273002f, -0.05095507f, -0.06469417f, 0.07809462f, 
    0.14639574f, 0.36415577f, 0.06578969f, -0.23713088f, -0.07474793f, -0.22254695f, 0.03008896f, -0.07368369f, 
    0.09245342f, -0.01209509f, 0.12208337f, -0.16051279f, -0.02818788f, 0.20327209f, 0.17256318f, 0.12589839f, 
    -0.48694116f, -0.36641654f, -0.17719002f, -0.13073973f, 0.15655805f, 0.08142855f, -0.31261024f, -0.10581059f, 
    -0.12647186f, 0.44633898f, -0.01016437f, -0.00393335f, -0.14169434f, 0.03254567f, 0.15554214f, 0.01648247f, 
    -0.02244823f, 0.09707368f, 0.02339276f, 0.00963781f, 0.90425545f, -0.09401814f, -0.34595647f, 0.33489940f, 
    -0.15697500f, -0.03486452f, -0.07955243f, 0.07486932f, -0.02203085f, -0.01777383f, -0.08452384f, 0.12967846f, 
    0.69898766f, -0.18545742f, 0.03244813f, 0.08760152f, -0.04027689f, -0.02987464f, -0.00176333f, -0.01610210f, 
    0.07342137f, 0.05364092f, 0.11162538f, 0.06621899f, 0.22778247f, -0.37824976f, 0.40185222f, -0.08856227f, 
    -0.04273690f, -0.26776516f, -0.12344694f, 0.19157375f, 0.12558109f, -0.18251297f, -0.09391529f, -0.17559236f, 
    -0.05531056f, 0.01672198f, -0.05200447f, 0.01068242f, -0.05432633f, -0.00443562f, 0.02690822f, 0.03565275f, 
    -0.06789183f, 0.04434133f, -0.05254805f, -0.05400236f, -0.00816939f, -0.06570513f, 0.05416929f, -0.02303393f, 
    -0.05673201f, 0.00851069f, 0.00579961f, -0.06203737f, 0.01282425f, -0.03108992f, -0.06785484f, 0.05436747f, 
    -0.07728382f, 0.05717025f, 0.01760436f, 0.05566390f, 0.03716758f, -0.06033777f, -0.05903033f, 0.00486034f, 
    0.03652902f, 0.03447938f, -0.00534687f, -0.07393075f, -0.01783371f, -0.04471631f, 0.03002864f, 0.01203219f, 
    -0.02237359f, -0.05725439f, -0.01087327f, 0.00927989f, -0.05068914f, -0.04726917f, -0.04452634f, 0.06012127f, 
    -0.00942572f, -0.02576475f, 0.04862560f, -0.07897116f, -0.00070545f, 0.01291157f, -0.01492727f, -0.05917880f, 
    -0.04737006f, -0.01554835f, 0.06432794f, -0.02292052f, -0.03104594f, 0.06384391f, 0.00778180f, -0.06654287f, 
    -0.03444447f, 0.01084328f, -0.04660374f, 0.05318276f, 0.02161733f, -0.06967679f, 0.02954755f, 0.04041861f, 
    -0.05144773f, 0.00201585f, 0.07000074f, 0.02423313f, 0.04082192f, 0.00395568f, 0.01859194f, -0.02653741f, 
    -0.02303444f, 0.01986779f, -0.05124285f, -0.06578974f, -0.05718978f, 0.00340790f, 0.01486529f, -0.05287867f, 
    0.00357390f, -0.05295873f, -0.06313123f, 0.05979658f, -0.06739979f, -0.04775234f, -0.07379581f, 0.00445262f, 
    -0.04844205f, 0.00499351f, -0.00225427f, -0.02495671f, -0.00189838f, -0.05767941f, 0.05860529f, 0.04119628f, 
    -0.01789412f, -0.03541950f, -0.02914662f, 0.05147864f, -0.02424233f, 0.00743500f, -0.02468276f, -0.03184894f, 
    0.00760307f, -0.00204003f, -0.00099605f, -0.03219848f, 0.00587165f, -0.07052065f, -0.00561472f, -0.06279498f, 
    0.05029205f, 0.07599641f, 0.05203919f, 0.01133287f, 0.04669349f, -0.03489755f, 0.00439680f, -0.03965898f, 
    -0.05045266f, -0.00888867f, -0.03756691f, -0.04293214f, -0.06821387f, 0.06771868f, -0.00982583f, -0.03232717f, 
    -0.03840030f, 0.05954506f, -0.01828184f, 0.01099500f, -0.06204027f, -0.05132633f, 0.03809791f, 0.02873836f, 
    -0.05824742f, 0.00175105f, -0.01465965f, 0.05550270f, -0.06495318f, -0.06502072f, 0.02449254f, 0.04987094f, 
    0.02260971f, -0.06006189f, -0.01027618f, 0.05326257f, 0.00609282f, 0.00085684f, 0.03867890f, -0.04314836f, 
    0.00941326f, 0.06442314f, -0.01477043f, 0.06122929f, -0.00234577f, -0.03050900f, -0.00942788f, -0.01067550f, 
    -0.02104601f, 0.01502530f, 0.00520138f, -0.01779736f, -0.03137960f, 0.07830181f, 0.02534059f, -0.05905090f, 
    -0.08000503f, -0.06485179f, -0.05853267f, 0.03125066f, -0.02182261f, 0.04545213f, 0.06923733f, -0.02495502f, 
    -0.06311277f, 0.06470543f, -0.00562483f, -0.07469563f, -0.05877296f, -0.05435083f, 0.04514359f, 0.02872452f, 
    0.13131030f, -0.17777175f, 0.24308980f, 0.03824956f, -0.03966414f, -0.25462681f, 0.19874352f, -0.15795398f, 
    0.00307238f, -0.04514180f, 0.05976255f, 0.01689021f, 0.09810886f, 0.12217682f, 0.27232200f, 0.12152758f, 
    0.05573545f, 0.07315647f, 0.05774468f, 0.01164221f, -0.05941379f, -0.05931748f, -0.02863253f, -0.00612082f, 
    -0.21062303f, -0.46263415f, -0.05696968f, -0.03988314f, 0.15508743f, 0.09711657f, 0.17856726f, 0.08889174f, 
    0.03409569f, -0.05148843f, 0.20124736f, 0.10275168f, -0.10936483f, -0.37537071f, 0.10531175f, -0.15488814f, 
    -0.03707233f, 0.07061841f, 0.06526835f, 0.00568838f, 0.13985063f, -0.10421957f, -0.02984712f, -0.07740463f, 
    -0.12210734f, 0.06537520f, 0.10532169f, -0.17489420f, -0.06310973f, 0.10266483f, 0.11001478f, 0.10233817f, 
    0.14176230f, -0.19567390f, 0.00722449f, 0.12651016f, -0.00532912f, -0.03956408f, 0.26966429f, -0.61237299f, 
    0.02750573f, -0.07705354f, 0.14031127f, 0.17438154f, -0.00720430f, 0.10473897f, -0.00625667f, 0.07184000f, 
    -0.35911161f, 0.10808214f, -0.10489318f, 0.09767058f, 0.06389544f, 0.13974719f, 0.07986188f, 0.10644016f, 
    0.03743001f, -0.05270713f, -0.15508980f, 0.21370205f, -0.29302084f, 0.41161674f, 0.07501431f, 0.07259813f, 
    0.10799044f, 0.21429136f, 0.09964249f, -0.04784434f, -0.00826305f, 0.02838694f, -0.05031537f, 0.00998199f, 
    0.14884076f, 0.24779159f, -0.09572494f, -0.21198094f, 0.05635901f, 0.16387658f, 0.24339078f, 0.04094983f, 
    0.01843864f, -0.03365983f, -0.17765746f, -0.08390357f, -0.18157786f, -0.29667819f, -0.26352581f, -0.14911908f, 
    -0.16099234f, -0.11106750f, 0.28077468f, -0.01920654f, 0.05169880f, 0.01810185f, 0.10716359f, -0.15098295f, 
    0.50716174f, 0.21299060f, 0.18710358f, 0.03760714f, 0.02142309f, -0.07243148f, -0.01557801f, -0.01871732f, 
    0.09359026f, 0.04612763f, 0.29127792f, -0.07847280f, -0.05434952f, -0.38061315f, 0.09060410f, -0.07255430f, 
    0.03632624f, 0.04726752f, -0.09763013f, -0.08206153f, 0.12685293f, -0.23686022f, -0.00040546f, -0.08023089f, 
    -0.12861185f, -0.17001051f, 0.17583947f, -0.02827472f, 0.22958738f, 0.14369337f, 0.02273899f, 0.15515049f, 
    0.20970516f, -0.02448644f, -0.02197722f, -0.01012624f, 0.74206281f, -0.30663070f, 0.12003998f, 0.24504998f, 
    0.04104876f, 0.00991206f, 0.08844178f, 0.11609349f, 0.01670489f, 0.08024655f, 0.10950100f, 0.11130326f, 
    -0.30613562f, 0.25600809f, -0.19235964f, -0.05477492f, -0.07115676f, -0.13367978f, 0.06672793f, -0.05553108f, 
    0.03453062f, -0.13189989f, 0.20939447f, 0.13066538f, 0.72764617f, 0.40622988f, -0.37956357f, 0.15463956f, 
    0.10108705f, -0.16335760f, 0.14878055f, -0.07726896f, 0.00931449f, -0.03443141f, -0.13441458f, -0.06661131f, 
    -0.05089188f, 0.00298888f, 0.04251838f, 0.03924255f, -0.03081922f, -0.03288065f, -0.08356369f, 0.02091802f, 
    0.05937634f, 0.00520401f, -0.01318452f, 0.04773802f, 0.02572926f, 0.04842826f, 0.03278798f, -0.03057564f, 
    -0.06085192f, -0.01902660f, -0.06321435f, -0.02068508f, -0.04046832f, -0.01282166f, -0.04082294f, 0.00390425f, 
    -0.00456981f, -0.07485193f, -0.06060716f, -0.03023946f, -0.06071468f, 0.03926834f, -0.07488184f, -0.04518939f, 
    0.04285579f, -0.00596287f, -0.06334496f, 0.04162781f, -0.04539438f, -0.04251894f, -0.03973284f, -0.00609900f, 
    0.03860469f, 0.03159995f, 0.00511537f, -0.06542970f, 0.04242105f, -0.01492904f, -0.03823564f, -0.02489355f, 
    0.03635525f, -0.00158739f, 0.03808972f, 0.02881769f, 0.01527988f, 0.04367603f, -0.00953844f, -0.01625383f, 
    -0.06725454f, 0.06172759f, 0.06004083f, 0.04857405f, -0.02993426f, 0.02975881f, 0.02062059f, 0.02338460f, 
    -0.00878798f, -0.02386061f, -0.01072269f, -0.00376821f, 0.04790930f, -0.03845794f, 0.03945690f, -0.00447749f, 
    -0.01517165f, -0.04541367f, -0.04590966f, -0.04618245f, -0.07551664f, 0.04084618f, -0.05030958f, -0.06628577f, 
    0.02912157f, 0.05790734f, -0.00223146f, -0.07907023f, -0.06416575f, 0.01055775f, 0.06419408f, -0.06309181f, 
    0.02173795f, 0.02203307f, 0.04172878f, -0.04631647f, 0.03536593f, -0.01633504f, 0.03502235f, -0.05831594f, 
    -0.01372838f, 0.05088421f, -0.02913553f, -0.02660982f, 0.04954582f, 0.00855156f, -0.05115856f, 0.00982995f, 
    0.06281689f, -0.02422242f, -0.03188905f, 0.04707934f, -0.00415529f, -0.06893121f, -0.01849248f, -0.04726302f, 
    -0.01483096f, -0.02235045f, 0.00616070f, -0.01887553f, -0.04504295f, 0.02101693f, -0.01805752f, -0.05899675f, 
    0.02972319f, -0.03208968f, -0.00012972f, -0.04766297f, 0.05730510f, 0.03086477f, -0.01724575f, 0.02665052f, 
    0.00823484f, -0.05395582f, -0.04473471f, 0.01040979f, -0.04798868f, -0.03362698f, 0.01168486f, -0.02445772f, 
    -0.04349647f, -0.01554311f, 0.01059449f, -0.05262020f, -0.02513237f, -0.07403374f, -0.00804375f, -0.04946893f, 
    -0.03368364f, -0.04500865f, 0.01893813f, -0.06828689f, -0.00502004f, -0.07494316f, 0.03508628f, -0.04934527f, 
    0.00873067f, 0.00604209f, 0.02878361f, 0.00931833f, -0.08072693f, -0.04932128f, 0.02304246f, -0.00460295f, 
    0.05364218f, 0.04083452f, -0.06059653f, -0.00341210f, -0.06796701f, 0.03783077f, 0.04031285f, -0.03089298f, 
    -0.05146717f, -0.08006034f, -0.04692711f, -0.01820424f, 0.04949535f, 0.04445994f, -0.05813167f, -0.03440531f, 
    0.01188361f, -0.06472315f, 0.00769208f, -0.00207514f, -0.01082004f, -0.01495008f, 0.03364431f, -0.03514733f, 
    -0.00852844f, -0.07518255f, -0.01273837f, -0.03241824f, -0.00787234f, -0.04392618f, -0.05346684f, -0.03090766f, 
    0.36628184f, 0.20543489f, 0.22909898f, -0.32831177f, 0.08183073f, -0.07994820f, 0.05276728f, -0.06829483f, 
    -0.06880291f, 0.13285288f, -0.04321593f, 0.06723445f, -0.30227852f, 0.01976156f, 0.00121782f, 0.39703485f, 
    -0.06045402f, 0.01949346f, 0.00805989f, 0.07012998f, 0.10157546f, 0.03329322f, 0.02423376f, -0.16939101f, 
    -0.06706633f, -0.02038824f, 0.12294380f, -0.09682844f, -0.00888246f, -0.01346111f, 0.04496443f, 0.17121407f, 
    0.11526636f, 0.15955342f, 0.04996367f, -0.02569513f, -0.35886011f, 0.31174845f, -0.07448004f, 0.13385026f, 
    0.12456968f, 0.13956572f, -0.06550559f, -0.00114624f, -0.02784861f, 0.05518629f, 0.07262702f, -0.10765982f, 
    0.29940492f, 0.21629840f, -0.14335424f, 0.15011162f, 0.08094141f, -0.09083622f, 0.09467814f, -0.05185447f, 
    0.07534040f, -0.08819126f, -0.19697627f, 0.08260347f, -0.08314422f, 0.03208510f, 0.18507402f, 0.13995028f, 
    -0.19749118f, -0.03525954f, 0.14402759f, 0.05153263f, -0.02692885f, -0.08109201f, -0.12421899f, -0.03185742f, 
    -0.16214059f, 0.16909997f, 0.38727713f, -0.19596747f, -0.19513595f, 0.28693658f, 0.04344727f, 0.11680814f, 
    0.14017314f, -0.00286124f, 0.22043610f, 0.00682736f, -0.37080556f, 0.13964182f, -0.13344373f, 0.23324899f, 
    0.00993473f, 0.08716971f, 0.15349455f, 0.09544559f, 0.03604899f, -0.02338050f, -0.03227412f, -0.10701845f, 
    -0.13177308f, -0.16543987f, -0.07231898f, -0.45747668f, 0.18713306f, 0.06265619f, 0.05202127f, 0.07148869f, 
    -0.00222725f, -0.02205118f, -0.04626858f, -0.14022224f, 0.02616719f, -0.01344013f, -0.28227368f, -0.43930906f, 
    0.29375046f, -0.03428064f, -0.10042176f, -0.00035362f, 0.12164376f, 0.01620718f, -0.20381135f, 0.11493684f, 
    0.01260115f, -0.13330534f, -0.15566733f, 0.09314406f, -0.20249039f, -0.29044238f, -0.06626096f, 0.10332078f, 
    0.06319240f, 0.05745845f, 0.06734531f, -0.00985951f, 0.41137329f, 0.09371094f, -0.13944660f, -0.00938274f, 
    -0.19120571f, 0.01198491f, 0.01847026f, 0.12810636f, 0.05915979f, -0.07227936f, -0.21270628f, -0.12672846f, 
    0.26496661f, 0.20187792f, 0.07997228f, -0.07069079f, -0.10473938f, 0.14257394f, -0.02869055f, 0.01043024f, 
    -0.05348260f, -0.09316032f, -0.10444734f, -0.10576382f, 0.14956827f, 0.00132170f, 0.06520899f, 0.26066700f, 
    0.00285914f, 0.07515381f, -0.04222740f, -0.01611374f, -0.08686832f, 0.06889907f, 0.11605501f, 0.06737626f, 
    0.02206538f, -0.06668298f, -0.33062837f, -0.35457218f, 0.13391712f, 0.10359735f, 0.08052348f, -0.06235171f, 
    -0.13085885f, -0.05760859f, 0.18252012f, 0.07989354f, 0.20865332f, 0.08571649f, -0.18348210f, 0.21380794f, 
    -0.01223933f, -0.00983756f, -0.07543071f, -0.12914567f, 0.02721403f, 0.00949818f, 0.01519161f, -0.12527746f, 
    -0.44045672f, -0.50434226f, -0.04860148f, -0.13022576f, -0.02926962f, -0.20437229f, 0.17457990f, 0.13775940f, 
    0.06560891f, -0.16893341f, -0.02260769f, 0.01326599f, -0.06500220f, 0.16530992f, -0.04059133f, -0.42055821f, 
    0.16130792f, 0.05327987f, 0.00265046f, -0.14359502f, -0.15173310f, -0.14792144f, -0.10750138f, 0.11349296f, 
    0.21066745f, -0.33760554f, -0.10379511f, 0.28754479f, -0.08692005f, -0.05147256f, -0.03397258f, -0.16827565f, 
    -0.31341508f, -0.09122649f, 0.09146582f, 0.15933107f, 0.51009661f, -0.64004689f, 0.20179430f, -0.03673263f, 
    -0.19555625f, -0.09841114f, -0.07174929f, 0.09257702f, 0.10650769f, -0.01846029f, -0.17201334f, -0.17425025f, 
    0.00933485f, -0.01167282f, 0.06476241f, 0.08625037f, -0.24698040f, -0.01597053f, 0.00873646f, 0.20811294f, 
    -0.12570740f, -0.06560303f, 0.08202860f, -0.06284434f, 0.37615356f, 0.31796050f, 0.29541415f, 0.21356322f, 
    0.15965892f, 0.06336045f, 0.03540730f, 0.15832438f, 0.04931979f, 0.24704067f, 0.15264359f, 0.12876922f, 
    0.20969562f, 0.36920705f, -0.04130401f, 0.35008228f, 0.24027684f, -0.04849244f, 0.10024276f, 0.03264573f, 
    -0.06739247f, 0.15932733f, -0.23004840f, 0.06124509f, 0.00939547f, -0.02979978f, -0.07929818f, -0.18047529f, 
    -0.04437440f, 0.06080068f, -0.02780372f, 0.02635217f, -0.01529949f, -0.01672304f, 0.09913344f, 0.11856716f, 
    0.10450266f, 0.32553434f, 0.08349790f, 0.22266382f, -0.11118967f, 0.13535629f, 0.05251601f, 0.02524724f, 
    -0.06834817f, -0.03992838f, -0.00296268f, -0.05793355f, -0.33042914f, -0.21881489f, -0.00861264f, 0.17339790f, 
    -0.20142698f, -0.05237605f, 0.13398577f, -0.03384743f, 0.04555299f, 0.00161814f, 0.23973884f, -0.18558218f, 
    0.14861861f, 0.28959730f, 0.01597763f, -0.04664683f, 0.20463642f, 0.08194965f, 0.00182508f, 0.00796957f, 
    0.00730484f, -0.13336824f, 0.12146397f, 0.06873295f, 0.21019387f, -0.20462480f, 0.42944351f, 0.18237348f, 
    0.05760153f, 0.10066535f, -0.07462024f, -0.20185256f, 0.02971662f, -0.27074695f, 0.13349988f, -0.13998702f, 
    -0.09129316f, 0.07468353f, -0.04985145f, 0.09417526f, 0.14182177f, -0.11416981f, 0.22900791f, -0.03907790f, 
    0.32906455f, 0.14348085f, 0.06033945f, 0.11430557f, 0.30551904f, -0.30601770f, -0.07831437f, -0.17755561f, 
    0.01086132f, 0.02999184f, 0.16362865f, -0.08684575f, 0.10266183f, -0.06171474f, 0.08642191f, 0.07858095f, 
    -0.08998609f, -0.06714325f, 0.29115537f, 0.24337968f, -0.00330610f, -0.08443071f, -0.14801610f, 0.00037651f, 
    0.14457008f, 0.07722926f, -0.01589842f, 0.11556550f, 0.25802273f, -0.07593770f, -0.00473888f, -0.33472797f, 
    -0.03180069f, 0.00329241f, -0.15742280f, 0.05588000f, -0.10710456f, -0.03297899f, -0.15724739f, 0.07485801f, 
    0.30755636f, -0.24578536f, 0.06040736f, -0.08781467f, 0.08427485f, 0.11510813f, 0.03422545f, 0.12660021f, 
    -0.19902575f, -0.12877327f, -0.01735973f, 0.14151569f, 0.21378130f, -0.39702371f, -0.43145889f, 0.19661188f, 
    0.05538778f, -0.17976229f, 0.00954319f, -0.09004914f, -0.21969938f, -0.11065263f, -0.10891884f, -0.13215438f, 
    0.29667699f, 0.20662908f, 0.26295516f, -0.22286025f, -0.00759836f, -0.07618314f, -0.04893950f, -0.06005089f, 
    -0.07924132f, 0.02967830f, -0.05196767f, 0.13271184f, 0.02326017f, 0.44167134f, -0.11401577f, 0.00690751f, 
    -0.04346658f, -0.03482639f, -0.10856660f, 0.04518734f, 0.06985028f, 0.12458996f, -0.06481180f, 0.15451063f, 
    0.11309835f, 0.48668870f, 0.12898907f, 0.03335898f, -0.03643007f, -0.09113215f, 0.13949913f, 0.00667572f, 
    -0.03979502f, -0.09579270f, -0.06369671f, -0.04985820f, -0.06927269f, 0.32982492f, -0.16030313f, 0.47076273f, 
    -0.06948217f, 0.10052423f, 0.04958124f, 0.03917914f, -0.03902827f, 0.03147809f, -0.06588688f, 0.08478163f, 
    0.26787645f, -0.13525279f, 0.16318968f, -0.08013503f, -0.10472508f, 0.03759527f, 0.20496719f, 0.04018713f, 
    -0.04521731f, -0.12063736f, -0.01382859f, 0.06451309f, 0.22445188f, -0.27106658f, -0.16560157f, 0.36968076f, 
    -0.18605240f, 0.00259246f, -0.16661772f, 0.09304284f, 0.01813270f, 0.00543112f, -0.12645482f, -0.13090241f, 
    -0.08502710f, -0.29268929f, 0.08436929f, 0.16669685f, 0.14378807f, -0.10082538f, -0.10710635f, 0.03480715f, 
    -0.07338794f, 0.04483339f, -0.07111002f, -0.01121234f, -0.02871993f, 0.10668401f, 0.07841919f, 0.06822640f, 
    0.36011440f, -0.19895764f, -0.09259073f, 0.10866706f, 0.20706838f, 0.04030893f, 0.20593743f, 0.13257428f, 
    0.19756059f, -0.13789247f, 0.02467436f, 0.48295584f, -0.10033890f, 0.08670738f, 0.18860182f, 0.10157294f, 
    0.10534307f, -0.03344145f, -0.00298058f, 0.00249924f, 0.08553095f, 0.45397547f, 0.12740602f, -0.24315333f, 
    -0.06129432f, -0.00032611f, 0.27057165f, 0.15077271f, -0.12999459f, 0.11044145f, 0.06728651f, -0.04717625f, 
    -0.19941014f, 0.03390716f, 0.30718070f, -0.21710196f, -0.19164740f, 0.03724956f, 0.01214761f, -0.14428943f, 
    -0.12790075f, -0.06447259f, -0.13988997f, -0.01524342f, 0.22523715f, -0.04287997f, -0.10642207f, 0.00123776f, 
    -0.14858408f, 0.08502862f, -0.15451626f, 0.14725237f, 0.04834103f, 0.03147664f, -0.03544482f, -0.00688052f, 
    0.24779370f, -0.02499101f, 0.02372230f, 0.20113195f, 0.10284218f, 0.10918300f, -0.03462489f, 0.03754078f, 
    0.03025849f, 0.17052157f, 0.21760477f, -0.21849249f, -0.25689960f, -0.34165329f, -0.01958484f, -0.10260332f, 
    -0.07416173f, -0.06935441f, -0.05209827f, 0.06537975f, -0.02646119f, 0.06360052f, -0.06987581f, -0.14555250f, 
    0.21123192f, -0.21697347f, 0.16967100f, -0.19034992f, 0.10149837f, 0.21073084f, -0.06280998f, 0.20092069f, 
    -0.04561266f, -0.14158002f, -0.19525005f, -0.26628292f, 0.18046464f, 0.10575989f, 0.11819913f, -0.08265467f, 
    0.17989057f, -0.07277706f, -0.12365751f, 0.23209220f, 0.06646606f, 0.19190703f, -0.24805899f, 0.01601322f, 
    0.68259269f, 0.07588518f, 0.16979577f, -0.39394125f, -0.09439779f, -0.04470747f, -0.14615795f, -0.21903291f, 
    -0.17541076f, 0.05010027f, -0.26118723f, 0.27877855f, 0.36864653f, 0.03451934f, 0.13155380f, 0.07378760f, 
    -0.07812111f, -0.18905708f, -0.25003690f, -0.05954451f, 0.11494719f, 0.48000291f, 0.06703108f, 0.08089533f, 
    0.33653611f, -0.34701476f, -0.33188316f, 0.00183103f, -0.01506571f, -0.08619577f, 0.01634736f, -0.02518587f, 
    -0.01669726f, -0.08770253f, 0.23907310f, 0.04310206f, -0.23745860f, -0.20098354f, -0.24730015f, 0.57611912f, 
    -0.14172019f, 0.16937305f, -0.09036479f, -0.11903710f, -0.12735331f, -0.09553461f, 0.13541503f, -0.08467793f, 
    0.43049389f, -0.15625972f, -0.01196158f, 0.10381754f, 0.24211161f, 0.10953093f, -0.26037061f, -0.22573878f, 
    0.02135345f, -0.13395356f, -0.27151108f, 0.08398825f, 0.25464809f, -0.11563236f, 0.00342704f, -0.00456924f, 
    -0.01430433f, -0.14930625f, -0.09844419f, 0.24221852f, 0.15321499f, 0.14866847f, 0.37161022f, 0.27509326f, 
    -0.08920085f, 0.05425886f, 0.12104218f, -0.26594943f, 0.08536788f, -0.07932299f, -0.31284589f, -0.05612829f, 
    -0.07597759f, 0.24499510f, 0.25910738f, 0.36107257f, 0.28589019f, 0.13070059f, 0.08457270f, -0.09377104f, 
    0.04704754f, 0.13530903f, -0.09987342f, 0.23621269f, 0.03346363f, -0.12820552f, 0.01153962f, -0.04706764f, 
    0.23919725f, 0.00609614f, 0.43115473f, -0.02135133f, 0.07030739f, 0.04878630f, 0.04811108f, 0.11292603f, 
    0.00534771f, 0.02470715f, -0.36981153f, 0.16555819f, -0.09763476f, -0.47230956f, 0.10675780f, 0.53655910f, 
    -0.04433863f, 0.06745107f, 0.11329708f, -0.01094457f, -0.02598418f, 0.08452468f, 0.27826136f, 0.34706461f, 
    -0.15902203f, -0.07533698f, -0.33499134f, 0.21533147f, -0.09835812f, 0.03089406f, 0.08377307f, 0.01537856f, 
    0.02247400f, -0.05422254f, 0.15856764f, 0.15273525f, 0.00260157f, 0.11838361f, 0.01693127f, -0.04268138f, 
    0.12581053f, -0.00239465f, -0.02967926f, 0.07289089f, -0.00984906f, 0.15406130f, -0.28905901f, -0.08468005f, 
    -0.05238872f, 0.35121393f, 0.04366545f, 0.16348960f, 0.14049101f, -0.00365792f, 0.05801141f, -0.24802545f, 
    0.22100237f, -0.14948124f, -0.08863318f, -0.21566941f, 0.22630814f, -0.17799093f, 0.12953980f, -0.10053809f, 
    -0.04730951f, 0.14437091f, -0.09438170f, 0.08730166f, -0.22349620f, 0.05133938f, -0.01421875f, 0.05810591f, 
    -0.03661706f, 0.01196286f, 0.04546957f, -0.03991720f, -0.01127227f, 0.03493039f, 0.05876014f, -0.03423931f, 
    0.03518137f, 0.00656049f, 0.04318208f, 0.00944013f, -0.04207687f, 0.01721549f, 0.01686420f, -0.04438625f, 
    -0.07496935f, 0.05033669f, 0.01220887f, -0.02171028f, -0.03501409f, 0.02058676f, -0.00414295f, 0.02803559f, 
    -0.05822196f, 0.03156412f, 0.02278254f, -0.00480717f, 0.05617344f, 0.04645291f, -0.01046453f, -0.06209044f, 
    -0.02523083f, 0.01709308f, -0.01093652f, 0.01186608f, -0.02844812f, 0.03400771f, -0.01286871f, 0.01265667f, 
    -0.00531671f, -0.00825700f, -0.01783083f, 0.04488322f, 0.02904999f, -0.03872920f, 0.02182555f, -0.01550836f, 
    -0.03774310f, -0.04916977f, 0.00358379f, 0.04722032f, -0.05237249f, -0.07162537f, -0.03205586f, -0.03259161f, 
    0.02362727f, 0.07087012f, 0.01171809f, 0.00030775f, -0.01940061f, 0.02097882f, 0.01305112f, 0.04355625f, 
    -0.04877066f, 0.00063625f, 0.04705217f, -0.00605652f, -0.06551409f, 0.02611868f, 0.00555557f, -0.02357890f, 
    -0.00447179f, 0.01476382f, -0.07642662f, 0.02283276f, 0.05506432f, 0.02656461f, 0.00786095f, -0.01067325f, 
    -0.00708976f, -0.02735023f, 0.02229256f, -0.06633850f, -0.06795194f, -0.07887542f, -0.03240748f, 0.01395335f, 
    -0.04628266f, -0.01611859f, -0.06710756f, -0.03169695f, -0.07252656f, 0.00629607f, -0.07599013f, -0.00862414f, 
    -0.04199494f, -0.06279268f, 0.05260500f, 0.05859531f, 0.03302165f, -0.06478772f, 0.04752501f, -0.02457650f, 
    -0.06668826f, -0.01883779f, 0.03622174f, -0.00470723f, 0.01376247f, -0.01611600f, -0.01769235f, -0.03524978f, 
    -0.06429460f, -0.04864338f, -0.04611223f, -0.04017985f, -0.07628115f, -0.06111274f, -0.04504955f, -0.03227001f, 
    -0.04879151f, 0.01886461f, 0.02902413f, -0.05433051f, 0.02230496f, 0.02581581f, -0.05039194f, -0.05039476f, 
    -0.05980265f, -0.05000095f, -0.07727324f, -0.02293883f, 0.00920814f, 0.05421418f, 0.04937676f, 0.01404551f, 
    -0.02236445f, -0.05351823f, -0.07732298f, -0.00981661f, -0.07516407f, 0.06640791f, -0.01942624f, -0.03618180f, 
    -0.06708757f, 0.06257918f, 0.00540018f, -0.07524271f, -0.00692300f, 0.01686406f, 0.05215042f, 0.03127121f, 
    -0.01841427f, -0.07910107f, -0.05432753f, 0.02700013f, -0.03551778f, 0.01237336f, -0.07406915f, 0.02497504f, 
    0.02100008f, 0.01788831f, -0.06565745f, 0.00697012f, -0.06768002f, 0.03396599f, -0.03743254f, -0.00503049f, 
    -0.01779067f, 0.00361779f, 0.04301722f, 0.06022437f, -0.03049221f, -0.05700968f, 0.02586415f, 0.04397010f, 
    -0.04007273f, 0.00470881f, 0.05703275f, 0.03065320f, 0.02987812f, -0.04557129f, 0.02712938f, -0.05750251f, 
    0.00922461f, 0.03225877f, 0.02349148f, -0.06900010f, -0.02545232f, -0.06442304f, -0.05267174f, -0.07467825f, 
    0.00261300f, -0.52848029f, 0.01476964f, 0.05094207f, 0.01929215f, -0.00673351f, -0.15586685f, 0.20100389f, 
    -0.02884842f, -0.33664045f, 0.08002920f, -0.04506842f, 0.10111248f, -0.32380539f, -0.15807381f, 0.19844088f, 
    0.11043804f, -0.10385725f, -0.04985457f, 0.20074217f, -0.08904305f, 0.03993377f, 0.04504257f, 0.10960919f, 
    0.12073269f, 0.08854141f, -0.00649213f, -0.04627069f, 0.07706866f, 0.12780759f, -0.01449350f, -0.23314106f, 
    -0.09592457f, -0.05705174f, 0.00599446f, 0.09707866f, 0.10422564f, 0.17146975f, -0.06726209f, -0.08445731f, 
    -0.07386628f, -0.05435422f, -0.05233132f, -0.10403515f, 0.22373605f, 0.00901537f, 0.02579732f, 0.18799958f, 
    -0.08697620f, 0.02716770f, 0.40724516f, 0.16313522f, -0.06890187f, 0.04172205f, 0.18723078f, -0.07939263f, 
    0.03050459f, -0.15816180f, 0.10716833f, -0.01400786f, -0.05064281f, 0.10176936f, -0.07933971f, 0.35860938f, 
    -0.12022959f, 0.12955536f, 0.07543059f, -0.12953411f, -0.03686437f, 0.03624380f, 0.06845026f, 0.05412949f, 
    0.19800356f, -0.05870742f, -0.02266079f, 0.08568840f, -0.05425167f, 0.02495040f, 0.11665996f, -0.09548409f, 
    -0.00719237f, -0.07879597f, -0.13641801f, 0.05857182f, -0.53270531f, -0.12977415f, 0.09128582f, 0.24703528f, 
    -0.00577746f, 0.05292043f, -0.09750604f, 0.06004710f, 0.07364367f, 0.05839891f, 0.10337749f, 0.21319030f, 
    -0.13173185f, -0.24328277f, 0.00977129f, 0.04030815f, 0.09383135f, -0.04952499f, -0.10338315f, 0.05750033f, 
    -0.01539556f, 0.10824261f, 0.12075595f, 0.07956537f, -0.35295263f, -0.26532549f, -0.08730893f, 0.03776042f, 
    0.00856646f, -0.12501538f, -0.09969211f, -0.01764313f, 0.01098447f, -0.01324567f, 0.15073153f, -0.00084314f, 
    -0.00105541f, -0.35011548f, -0.10716607f, 0.16367401f, 0.03999056f, 0.22957015f, 0.13428482f, 0.24282397f, 
    0.03350244f, 0.00379027f, -0.12336827f, 0.16232736f, 0.07014263f, 0.37201071f, 0.30350929f, -0.09659786f, 
    0.00051020f, -0.06982620f, 0.01425462f, 0.01548319f, 0.12343417f, 0.01085362f, 0.23548478f, 0.20479515f, 
    -0.38621876f, -0.01573174f, 0.46571058f, 0.00731378f, -0.17838888f, -0.02556565f, -0.05980037f, 0.05325966f, 
    0.11076393f, 0.11661407f, 0.17247173f, 0.03787689f, -0.56933033f, 0.02331421f, -0.36119685f, -0.05904729f, 
    -0.01214397f, 0.01350585f, 0.00413643f, 0.07457744f, -0.02709258f, 0.05278206f, -0.11491434f, 0.07630228f, 
    -0.35182181f, -0.03714714f, 0.00888842f, 0.12262021f, 0.24062605f, -0.09824744f, -0.07630937f, 0.00023536f, 
    0.13332362f, 0.12073498f, 0.14043368f, -0.00240585f, 0.04869676f, 0.10356131f, -0.25488067f, -0.23056142f, 
    0.27999642f, 0.14717165f, 0.09893812f, 0.05470230f, -0.10608383f, 0.09805009f, 0.00409698f, 0.08257908f, 
    0.18191621f, -0.19816183f, -0.13023037f, 0.39805979f, -0.07938950f, 0.18023375f, 0.15712228f, 0.17216156f, 
    -0.08011373f, 0.28665450f, -0.06458519f, 0.19572090f, 0.18663384f, -0.14076027f, -0.02798387f, 0.24198756f, 
    0.06704661f, 0.01864312f, 0.06486296f, 0.03879904f, -0.03771835f, 0.10666621f, -0.04002696f, 0.06216394f, 
    0.19008407f, 0.00444545f, -0.13689327f, -0.22761144f, 0.10451664f, 0.08013649f, -0.05677139f, 0.19175309f, 
    0.09817173f, 0.04255835f, 0.09753318f, -0.16244672f, 0.05017260f, 0.28278410f, 0.25419778f, -0.72296852f, 
    0.14934427f, -0.09408602f, 0.02213828f, 0.00379274f, 0.10004790f, -0.19024821f, -0.10785449f, -0.14265341f, 
    -0.02979125f, 0.11448675f, -0.06827290f, -0.22328979f, -0.23843390f, 0.12578180f, 0.09739049f, 0.01024253f, 
    -0.09364703f, 0.08967752f, -0.03090403f, 0.09580176f, -0.29005632f, 0.05818454f, 0.12014356f, -0.17205377f, 
    -0.15446377f, -0.04283857f, 0.06409919f, -0.10588881f, 0.05354496f, 0.06479519f, 0.19913261f, 0.06564852f, 
    -0.05119979f, 0.09726435f, -0.06921198f, 0.05928135f, -0.09176356f, -0.01799915f, 0.25047907f, -0.25013277f, 
    -0.02661647f, 0.00296251f, -0.07262667f, 0.26437688f, 0.52042204f, 0.18210463f, 0.17456472f, -0.14719497f, 
    -0.00812637f, -0.03731783f, -0.13482620f, 0.12049072f, 0.00108656f, 0.03297500f, -0.04342491f, -0.12006494f, 
    -0.39524990f, 0.01491749f, -0.12910588f, 0.11036363f, 0.06437599f, -0.19518685f, -0.10703305f, -0.01716218f, 
    0.21850519f, 0.01052205f, -0.09786492f, 0.03296896f, 0.05107388f, 0.08612172f, -0.05730021f, 0.03976318f, 
    -0.14877816f, -0.22343722f, -0.01082099f, 0.07857783f, -0.05715494f, 0.05523129f, 0.04986658f, 0.03156347f, 
    0.06005039f, -0.35047159f, -0.04120888f, 0.21319570f, 0.06258861f, 0.07906284f, 0.15536630f, -0.01519757f, 
    0.08492711f, 0.06483242f, -0.06224315f, 0.07607963f, -0.35909882f, -0.01487456f, 0.24192974f, 0.39649737f, 
    -0.11832464f, 0.25911742f, 0.05465844f, 0.02733370f, -0.20447679f, 0.01996516f, -0.06878196f, 0.07299001f, 
    -0.03851923f, 0.14768593f, -0.00717771f, 0.11545170f, 0.00449116f, 0.05254379f, -0.07760894f, -0.07863248f, 
    -0.15047842f, -0.09232981f, -0.08661407f, -0.38420117f, 0.35951167f, 0.10173833f, -0.00469840f, -0.07856049f, 
    0.07901033f, 0.06435984f, 0.12437072f, -0.06805537f, -0.00664868f, 0.11513504f, 0.03545080f, -0.09814999f, 
    0.06590025f, 0.04772363f, 0.03615125f, -0.03229490f, -0.03095666f, 0.08628897f, 0.00051191f, 0.11753744f, 
    -0.04183648f, 0.13774568f, 0.01259135f, -0.16602506f, 0.03535672f, -0.33390173f, -0.13550815f, 0.01353867f, 
    0.12487342f, 0.11527880f, 0.15509832f, 0.13443327f, -0.14451009f, 0.00376363f, 0.18960585f, 0.10343829f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.07365558f, 0.07205562f, 0.10372776f, -0.02333742f, 0.04959708f, -0.05382582f, 0.07560810f, -0.04490571f, 
    0.01199884f, 0.01391058f, 0.00337211f, -0.00251308f, 0.00547918f, -0.07741945f, -0.09651791f, -0.04825948f, 
    -0.17924528f, 0.10461967f, -0.04236986f, -0.07428820f, 0.04648188f, -0.09288388f, 0.04774190f, 0.30136865f, 
    0.00182309f, -0.01928967f, 0.18118733f, -0.16378598f, 0.03800608f, 0.03639043f, 0.13193578f, 0.09214567f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.05008036f, -0.25604242f, 0.16317818f, 0.12738404f, -0.37769681f, 0.44118738f, -0.20259817f, 0.02834984f, 
    0.07372782f, -0.08352787f, -0.04814091f, -0.48035398f, 0.14263269f, 0.44760960f, 0.24429052f, -0.03383384f, 
    -0.07036185f, 0.00274869f, -0.20285407f, -0.09793677f, 0.01765775f, 0.76595742f, -0.09137442f, -0.64062113f, 
    -0.18237457f, 0.41368452f, -0.49957293f, 0.12586603f, 0.05995016f, -0.01244005f, -0.16911131f, -0.38884124f, 
    -0.11673367f, -0.13224711f, -0.31410769f, 0.02405602f, 0.34042811f, 0.25595322f, -0.13675101f, -0.08302314f, 
    -0.11717042f, 0.10871322f, -0.63624477f, -0.73114216f, -0.14030424f, -0.12765098f, 0.15405959f, 0.07554138f, 
    -0.39911896f, 0.22973819f, 0.11755549f, -0.14561339f, 0.00362619f, 0.28003788f, 0.02050419f, 0.24251267f, 
    0.09554698f, 0.19743147f, 0.44271460f, 0.21155861f, 0.19553323f, -0.03879622f, 0.27928048f, -0.44565576f, 
    -0.15144667f, 0.07045706f, 0.28271267f, -0.16152063f, 0.30351678f, -0.79822803f, -0.08485103f, -0.17127782f, 
    -0.05834733f, -0.09611815f, -0.69494623f, -0.01302609f, 0.24037589f, -0.41348332f, 0.12230169f, 0.05294337f, 
    0.12695210f, -0.43520045f, -0.06488411f, 0.13128012f, -0.11292180f, 0.54597884f, 0.14761004f, -0.41821945f, 
    0.15929513f, -0.38238752f, 0.18655677f, 0.27881923f, 0.06090065f, -0.03028815f, -0.44027939f, 0.47135675f, 
    -0.16337092f, -0.01348180f, 0.10520766f, 0.00089674f, -0.83559138f, -0.09069399f, -0.05338294f, 0.11123828f, 
    -0.15526402f, -0.02380551f, 0.08849143f, -0.09878352f, -0.39574549f, 0.28465843f, 0.11811129f, -0.09707599f, 
    -0.08364496f, -1.07502401f, 0.48076540f, 0.01679352f, -0.03055190f, -0.00977624f, 0.07738315f, 0.38973546f, 
    -0.18076745f, 0.25748762f, -0.10952188f, -0.93698561f, 0.09762105f, -0.11005899f, -0.38288912f, 0.26866102f, 
    0.11539640f, -0.91324264f, 0.13479510f, -0.15083419f, -0.36152190f, 0.33864391f, -0.05771978f, -0.01876213f, 
    0.16407478f, -0.16944307f, 0.36872184f, 0.22772077f, -0.41958785f, 0.23057307f, 0.23237564f, -0.09945688f, 
    -0.03735275f, -0.13554576f, 0.25763953f, 0.11139166f, -0.07843544f, -0.50845379f, -0.13792853f, -0.15376420f, 
    0.00980915f, -0.52381319f, 0.31657213f, 0.10640042f, -0.33427244f, -0.15713313f, 0.35822231f, -0.16774343f, 
    -0.00434328f, 0.10598789f, -0.20967978f, 0.12912728f, -0.14859146f, 0.28775212f, 0.06112174f, 0.12314507f, 
    -0.06782523f, -0.04336470f, -0.13965952f, -0.06108281f, -0.16175619f, 0.20538349f, 0.04680961f, 0.01496510f, 
    -0.14291552f, 0.38993186f, -0.93958145f, -0.00233282f, -0.11968317f, -0.89929962f, 0.13877264f, -0.26843140f, 
    0.14545503f, -0.05385180f, -0.14153555f, 0.21656621f, 0.28086054f, -0.07377031f, 0.39921376f, 0.39708629f, 
    -0.13972221f, 0.21737461f, 0.34507111f, 0.04229491f, 0.12921113f, -0.96457130f, -0.01861797f, -0.10509343f, 
    -0.15484130f, -0.11846019f, 0.01478651f, -0.21674381f, -0.20150389f, 0.28102887f, -0.20250788f, 0.00395662f, 
    0.34827131f, 0.15389982f, -0.50943601f, -0.09250319f, 0.03487332f, -0.01054974f, 0.05905640f, 0.34427294f, 
    0.00723947f, 0.22892395f, 0.27386233f, -0.13977157f, -0.85997587f, -0.11655430f, -0.15572898f, -0.04644926f, 
    0.10707324f, -0.19960772f, -0.73714352f, -0.09093471f, -0.22394125f, -0.12635262f, 0.33024931f, 0.01458625f, 
    0.10655403f, 0.10721199f, 0.37556472f, 0.27503496f, -0.37479368f, -0.49855512f, -0.52565926f, 0.08086748f, 
    0.54585844f, -0.34330097f, -0.11708586f, -0.14844809f, -0.03728659f, -0.10193805f, 0.07962777f, 0.10081574f, 
    0.02950699f, -0.12768920f, -0.27563506f, 0.21096759f, 0.08488263f, -0.00734243f, -0.42585814f, 0.20034988f, 
    0.08561622f, 0.46826446f, -0.30325347f, 0.00533781f, 0.34134373f, 0.00556536f, 0.35348529f, 0.06057717f, 
    0.14903043f, -0.04522623f, -0.42487103f, -0.49815440f, 0.00004092f, 0.12095508f, 0.00102443f, -0.17618276f, 
    0.30149874f, -0.02724241f, 0.11561824f, -0.12276420f, -0.06337566f, -0.47960848f, -0.16884454f, -0.62073165f, 
    0.13259239f, -0.81079543f, 0.40609396f, -0.49534184f, 0.38562807f, -0.11153697f, -0.21524891f, -0.57269561f, 
    -0.07277390f, 0.03910011f, 0.38562328f, -0.13757940f, 0.20518190f, 0.04958251f, -0.36205342f, 0.03837853f, 
    0.03803768f, 0.04850908f, -0.00915672f, 0.36779284f, -0.41294321f, -0.53770429f, -0.50725091f, 0.01534526f, 
    0.35176432f, 0.05274122f, 0.45862210f, 0.09545162f, 0.06038135f, -0.43393543f, 0.09631980f, -0.13654080f, 
    0.07279368f, 0.35974368f, -0.86212921f, 0.23425350f, -0.35727242f, 0.06087943f, 0.22737248f, -0.25067198f, 
    -0.11636144f, 0.12820299f, 0.39958742f, 0.12130591f, 0.14523309f, 0.00586883f, 0.47230718f, -0.06835963f, 
    0.13058713f, 0.10442133f, 0.00750718f, -0.00211108f, 0.40523592f, -0.52522200f, -0.82781243f, 0.08681811f, 
    -1.12332416f, -0.62337887f, -0.25534847f, -0.08139479f, -0.11650249f, 0.16871923f, 0.11758856f, 0.43028480f, 
    -0.10243024f, -0.37252387f, -0.04310259f, -0.58876252f, 0.15697451f, 0.07031065f, -0.11433340f, -0.13910156f, 
    -0.16712163f, 0.43988487f, -0.27068651f, 0.11541569f, -0.00694058f, 0.11749294f, -0.35408607f, -0.10249983f, 
    0.06917533f, -0.07299442f, -0.03537197f, 0.39714816f, 0.66736901f, -0.23345351f, 0.45741788f, 0.06925450f, 
    -0.02949188f, 0.10364445f, -0.14866924f, -0.12378223f, -0.07394321f, -0.29539168f, -0.01062885f, 0.18117526f, 
    0.05940741f, 0.07666377f, -0.02631780f, -0.78059202f, -0.46231583f, -0.11686992f, -0.88794047f, -0.34488630f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.30186829f, -0.10954800f, -0.15041411f, 0.16305453f, -0.17929842f, 0.10417385f, -0.08207875f, -0.22021851f, 
    0.02558069f, -0.07651333f, 0.21145250f, 0.08492148f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
