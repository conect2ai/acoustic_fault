#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.35361016f, -0.59491140f, -0.06963580f, 0.53050768f, -0.56897509f, 0.47438467f, -0.99234396f, -0.99733073f, 
    -0.29669628f, 0.87563229f, 0.00646756f, 0.49174079f, -0.04866508f, 0.07563163f, -0.16950056f, -0.12085882f, 
    -0.12581703f, -0.26936108f, -0.15544139f, 0.24140739f, -0.01904847f, -0.16665243f, -0.07287969f, -0.11209885f, 
    -0.12440285f, -0.49685070f, 0.10431128f, -0.07186069f, 0.37841311f, 0.33214676f, 0.31116888f, 0.10314653f, 
    0.29644439f, 0.52767229f, 0.20063373f, 0.37869182f, 0.17678408f, -0.09578913f, 0.03432705f, -0.22645898f, 
    0.26068243f, 0.23053838f, 0.14648892f, -0.07485513f, -0.35729617f, 0.11467467f, 0.23028162f, 0.02325024f, 
    0.05244171f, -0.24556737f, -0.19136633f, -0.32194686f, -0.50960398f, -0.50646895f, 0.26885599f, -0.06912554f, 
    0.43541926f, -0.38507724f, -0.24821094f, -0.06758609f, -0.02333801f, -0.51184118f, -0.14884883f, -0.00042497f, 
    -0.37332314f, 0.00635340f, -0.23139805f, 0.11179592f, 0.23125353f, 0.19053307f, -0.05088482f, 0.38349447f, 
    0.18636297f, 0.20419036f, 0.17497489f, 1.28392422f, -0.86360097f, -0.60335559f, -0.15700088f, -0.57677627f, 
    0.59806567f, 0.22007230f, 0.65398407f, 0.04239179f, -0.20997199f, -0.10097338f, -0.02747141f, 0.39425495f, 
    -0.30374137f, 0.15955792f, -0.12151705f, 0.08549023f, 0.37288690f, -0.49768415f, -0.05443431f, 0.17903025f, 
    -0.20338450f, -0.06586748f, 0.31518671f, -0.10719629f, -1.35138488f, -0.45208520f, -0.43159100f, -0.93861479f, 
    -0.97691107f, 0.26829034f, 0.47175881f, 0.37598324f, 0.23987742f, 0.34888250f, -0.05900929f, -0.16662520f, 
    -0.03994461f, -0.35471982f, 0.00465108f, -0.10452825f, 0.27236471f, -0.31074950f, -0.10408904f, 0.08048674f, 
    -0.16939767f, -0.01457609f, -0.09188729f, 0.04829567f, 0.24150622f, -0.15795213f, -0.22710508f, 0.49774849f, 
    1.14260042f, -0.20705737f, -0.12751478f, -0.74161309f, -0.50605255f, -0.18024623f, 0.01929468f, -0.39178708f, 
    -0.32990262f, -0.09320129f, 0.33911955f, 0.70769691f, 0.05666706f, -0.16358413f, 0.21426016f, -0.05594490f, 
    0.29087955f, -0.10073062f, 0.04088492f, -0.06951702f, 0.02718941f, -0.46524307f, -0.43021250f, 0.02624910f, 
    0.29806149f, 0.37759626f, 0.37267819f, 0.13785236f, -0.43624610f, 0.25041112f, 0.43691313f, 0.03142752f, 
    -0.16569625f, -0.29512835f, -0.14210647f, 0.59131140f, -0.30792356f, -0.21802968f, -0.14993690f, 0.08080262f, 
    0.29445049f, -0.19444694f, -0.30868986f, -0.26957968f, -0.18927671f, 0.04181912f, 0.21207766f, 0.59711421f, 
    0.34325463f, -0.56057906f, 0.17833650f, -0.09812930f, 0.00092743f, -0.00786813f, -0.16973425f, -0.15208924f, 
    0.48306674f, -0.18883528f, 0.06753333f, -0.51129800f, -0.36062425f, -0.03521682f, -0.24411803f, 0.14910877f, 
    -0.05330306f, 0.02479392f, -0.47645155f, -0.76268756f, -0.45402238f, -0.47923294f, -0.89679706f, -0.75171340f, 
    0.19535317f, 0.74134606f, 0.48542523f, -0.38576913f, -0.65737706f, -0.68988580f, -0.25185186f, -0.10851499f, 
    -0.16490372f, -0.05122042f, 0.38067609f, 0.08577570f, 0.47253385f, 0.03043340f, -0.07347958f, -0.07818117f, 
    -0.15081617f, 0.11505912f, 0.32479328f, -0.57846075f, -0.01258194f, 0.23773076f, 0.07448912f, -0.00260675f, 
    0.32952982f, -1.02515209f, -0.77297455f, -0.77506334f, -0.16876255f, 0.16781919f, -0.22626488f, 0.72287023f, 
    0.12951259f, 0.52600843f, 0.37131116f, 0.04570756f, 0.76292396f, -0.02257043f, -0.06177973f, -0.12853839f, 
    -0.19043289f, -0.08264102f, -0.07433717f, -0.34928730f, -0.55340189f, 0.14522859f, 0.02749709f, 0.19588727f, 
    -0.22334327f, 0.67885780f, -0.79249477f, 0.25283119f, -0.49102652f, -0.79872322f, -0.29269952f, 0.05970184f, 
    0.05735644f, -0.11578586f, -0.04133077f, -0.07491018f, -0.20269592f, 0.52360839f, -0.05135969f, -0.43734613f, 
    -0.17673399f, 0.40267801f, 0.15432571f, 0.15254445f, 0.23101750f, 0.20709473f, 0.17659296f, 0.09483647f, 
    -0.15363304f, -0.30984199f, -0.22588006f, 0.18739645f, -1.53521764f, -0.94760001f, 0.87182224f, 1.01440310f, 
    0.98499662f, 0.76524884f, 0.32531792f, -0.32049888f, -0.17354234f, -0.43322158f, -0.24077782f, -0.04265242f, 
    -0.49594733f, 0.17648493f, -0.11240819f, -0.04994716f, -0.05242670f, -0.05769196f, -0.14646947f, 0.28679055f, 
    -0.24856849f, -0.14835741f, 0.02400845f, 0.07227124f, 0.68723708f, -0.34608409f, -0.69231761f, -0.31542712f, 
    -0.17071027f, 0.70938057f, 0.35127658f, -0.28452349f, -0.73645562f, 0.62025762f, 0.02399340f, 0.37150744f, 
    -0.45571762f, -0.29772696f, 0.53379208f, -0.04489275f, 0.05735974f, 0.31608003f, -0.08306859f, -0.20572135f, 
    0.10991881f, -0.41501841f, 0.01995745f, 0.20189269f, 0.12381845f, -0.01395083f, -0.71795237f, 0.06164635f, 
    0.16743055f, 0.34510398f, -0.63383377f, -0.27894729f, 0.40710223f, -0.36965644f, 0.51107347f, -0.19906306f, 
    0.37838539f, -0.32045248f, 0.14115728f, -0.15781362f, -0.44519514f, -0.00813143f, 0.28669104f, 0.25275478f, 
    0.04014577f, -0.29989743f, -0.45765358f, -0.44126654f, 0.22176516f, 0.41048425f, -0.24793071f, -0.32261258f, 
    -0.49365962f, -0.00401328f, -0.33089507f, 0.42844903f, -0.29386765f, -0.44687217f, 0.08805496f, -0.46806580f, 
    0.04854483f, 0.46341535f, -0.30756560f, 0.16870439f, -0.29677105f, -0.33805716f, 0.03444821f, -0.22971579f, 
    -0.14564718f, -0.25780398f, 0.27042422f, 0.43125650f, 0.37669337f, 0.46817243f, 0.27600929f, -0.86925137f, 
    -0.59997076f, -0.06737213f, -0.37777510f, -0.30612913f, 0.13269204f, -0.60446054f, -1.07689583f, -0.96317059f, 
    -0.28106269f, -0.31356549f, -0.31333077f, -0.31535122f, -0.48467815f, -0.53632945f, -0.16934466f, -0.20888326f, 
    -0.10298881f, -0.04467400f, -0.17045847f, -0.09627723f, -0.14416838f, -0.01373082f, -0.11582965f, 0.10558801f, 
    -0.97950059f, 0.34232345f, -0.11630813f, -1.03302348f, -0.53773832f, -0.09555349f, -0.01712641f, -0.14267042f, 
    0.15541112f, 0.45702404f, -0.34605715f, -0.42673317f, -0.18315874f, -0.13852009f, -0.25303537f, 0.25809544f, 
    0.36618367f, 0.16864693f, 0.23705494f, -0.15805218f, -0.09536824f, -0.02803449f, -0.29775032f, -0.30654317f, 
    -0.52421594f, 0.67817944f, -0.54903787f, -0.52586597f, -0.38918152f, -0.30314043f, 0.57163870f, -0.53054208f, 
    -0.01341273f, 0.32357833f, 0.32229605f, -0.01071343f, 0.05606605f, -0.00717016f, 0.07428356f, 0.20775881f, 
    0.17732508f, -0.15564555f, 0.23970419f, 0.09908082f, -0.44517398f, 0.15020141f, -0.01305792f, -0.13184720f, 
    -0.17772697f, 0.44122395f, 0.98127604f, 0.63725555f, -0.82069528f, -0.41772354f, -0.87688571f, -0.11622719f, 
    -0.08621262f, 0.03606971f, 0.43335491f, 0.39049602f, 0.22844185f, -0.08841733f, -0.07261146f, 0.15946510f, 
    -0.27482790f, -0.25406757f, 0.10592547f, 0.11498144f, 0.18657449f, -0.27005434f, 0.14601167f, -0.01052065f, 
    0.17437892f, 0.08355892f, -0.10724140f, 0.29986626f, 0.71229637f, 0.41649133f, -0.38683927f, -0.83747613f, 
    -0.27295688f, -0.50639111f, -0.06177827f, -0.13202223f, -0.35449570f, 0.14382187f, -0.21178769f, 0.37527442f, 
    -0.01372109f, 0.27340314f, 0.30645606f, 0.14808887f, 0.21102864f, -0.27320096f, -0.27149001f, -0.16901381f, 
    0.29769203f, -0.08424035f, 0.00969114f, -0.02414365f, 0.62336403f, 0.79437822f, 0.74173713f, -0.10624120f, 
    0.38012123f, -0.49262387f, -0.27709290f, -0.28835559f, 0.02048193f, 0.18730685f, 0.12708379f, -0.12955309f, 
    0.14679520f, -0.16111557f, -0.30760682f, -0.15208498f, -0.18826686f, 0.04493249f, 0.10909114f, -0.03904246f, 
    -0.10944935f, 0.36178353f, -0.06337842f, 0.00341070f, -0.32144654f, 0.33201894f, -0.19157511f, -0.66188675f, 
    -0.65524065f, -0.33267334f, -0.05188587f, 0.03569478f, 0.22840819f, 0.33374724f, 0.35416788f, 0.00331792f, 
    -0.16201103f, -0.26115716f, -0.19468516f, 0.28556514f, -0.51328415f, -0.34628212f, 0.08005325f, 0.31433788f, 
    -0.37362552f, 0.13162544f, 0.10125349f, -0.16700009f, 0.30870020f, 0.58187181f, -1.09571564f, 0.39064491f, 
    0.31720451f, -0.13207132f, 0.25016770f, -0.32946098f, -0.42159608f, 0.16429609f, 0.42665944f, -0.19124761f, 
    -0.25602943f, -0.23228054f, -0.32728174f, 0.06485489f, 0.39512458f, 0.45614961f, -0.35507697f, -0.37255749f, 
    -0.13138796f, 0.36556008f, -0.21106122f, -0.25095037f, -0.10414528f, 0.08355897f, -0.47543633f, -0.47865260f, 
    -0.69309974f, -0.56726992f, -0.47630280f, -0.49534923f, -0.63466555f, -0.89913356f, -0.63864142f, -0.80994517f, 
    -1.04266274f, 0.51401585f, 0.34215894f, 0.28017887f, 0.15595210f, 0.17124532f, -0.10144324f, -0.26554015f, 
    -0.09930167f, -0.14757912f, -0.27636650f, -0.35859591f, -0.34445867f, 0.25897259f, -0.07147849f, -0.20560054f, 
    -0.50527507f, 0.05838915f, 0.17179053f, -0.06845666f, 0.18204653f, 0.61357069f, 0.20182616f, -0.04341093f, 
    0.19205418f, -0.08217392f, -0.04994471f, 0.05572037f, 0.11238101f, -0.03774442f, 0.12639745f, -0.14776298f, 
    -0.22557922f, 0.13531610f, -0.01595578f, -0.08647520f, -0.18958189f, 0.27106243f, 0.06725458f, 0.05448314f, 
    -0.07582369f, 0.40927413f, 0.54904050f, 0.09702976f, -0.46414006f, -0.80375499f, -0.03537671f, 0.30318063f, 
    0.41804931f, -0.40106466f, -0.13634218f, 0.02695838f, 0.24600896f, -0.27299210f, 0.24883269f, -0.20234551f, 
    -0.04155858f, 0.12919304f, -0.63868558f, -0.10527899f, 0.42307097f, 0.23591194f, -0.04681921f, -0.25167978f, 
    -0.08403813f, 0.38884667f, -0.50432730f, 0.39422050f, 0.03524324f, 1.03803766f, -0.08331138f, -0.69043207f, 
    -1.04142082f, -0.94396126f, -0.17517242f, -0.37421152f, 0.20616059f, -0.59413666f, -0.25818080f, 0.21305779f, 
    -0.70341337f, 0.00795198f, 0.28278616f, 0.02771487f, -0.51457101f, -0.22524500f, -0.20540006f, -0.03139935f, 
    -0.07224266f, -0.05812063f, 0.12654823f, 0.37957892f, -0.29945871f, 0.32876098f, -0.09328783f, 0.01350508f, 
    -0.11992101f, 0.13353547f, 0.31553587f, 0.21491256f, -0.14421235f, -0.04321665f, -0.02972572f, 0.12278745f, 
    -0.02005005f, -0.40581676f, -0.06518599f, -0.22848006f, 0.05163728f, -0.11805828f, 0.10368615f, 0.38206106f, 
    0.43854624f, 0.00344794f, -0.31632945f, 0.07644215f, 0.50765610f, 0.46881166f, 0.62368107f, 0.08735148f, 
    -0.82474333f, 0.12923926f, -0.35753477f, -0.32522720f, 0.09508497f, -0.30064878f, 0.33914456f, -0.15522812f, 
    -0.09186515f, -0.51607984f, 0.36116663f, -0.18518791f, 0.32624328f, -0.20120731f, -0.03779073f, -0.17002317f, 
    -0.20117530f, 0.23638821f, -0.02991325f, -0.05175227f, 0.11795287f, -1.31138313f, -0.41180789f, 0.50960273f, 
    0.46579036f, 0.41199321f, -0.72107321f, -0.65125901f, -0.16177587f, 0.78511590f, 0.15533590f, -0.13695444f, 
    -0.06490080f, -0.02409686f, 0.39606252f, -0.02885736f, -0.06013367f, 0.16928425f, -0.15416969f, -0.39909694f, 
    -0.27249995f, 0.31542388f, -0.03622096f, 0.13541789f, 0.27208596f, 0.03676856f, 0.24140276f, 0.47779387f, 
    0.13918224f, 0.03430036f, 0.19880441f, 0.20008057f, -0.15528448f, -0.36478952f, -0.13117166f, 0.19749133f, 
    0.02589010f, -0.18846665f, -0.15140843f, -0.05226237f, 0.15456080f, -0.08080988f, -0.04763361f, 0.20924135f, 
    0.16307335f, -0.19787546f, -0.19376762f, -0.05534573f, 0.25844017f, -0.40994540f, -0.32520872f, -0.54619759f, 
    -0.80794388f, -0.95561832f, -0.60130262f, -0.54005301f, 0.36154678f, 0.12744811f, 0.33989707f, 0.00191542f, 
    0.27638888f, 0.39473301f, 0.45417127f, 0.44327888f, -0.08980273f, -0.06843973f, -0.12940530f, -0.16896851f, 
    -0.15114559f, -0.02341944f, -0.04374147f, -0.31135762f, 0.01795667f, -0.24141824f, -0.14858299f, -0.22554362f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.18382023f, -0.10277329f, 0.11112583f, 0.34539330f, 0.08856896f, 0.17743309f, 0.19838089f, -0.11145028f, 
    0.21554792f, 0.37410519f, -0.08553021f, 0.39915776f, 0.44885513f, 0.32136419f, 0.12118987f, -0.16763596f, 
    -0.35820079f, 0.37012210f, 0.48713270f, 0.42422891f, 0.24679929f, 0.23972690f, 0.39374077f, -0.04606400f, 
    -0.14421430f, 0.30439502f, 0.02005048f, 0.12297956f, 0.26941350f, 0.30647773f, 0.07494967f, 0.00785777f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.57639152f, 0.15523100f, 0.15730621f, -0.45772344f, 0.06327865f, -0.01284869f, 0.01073747f, -0.17263991f, 
    -0.06583225f, -0.07500531f, 0.02447217f, -0.06509489f, 0.06200320f, 0.07476928f, 0.06091120f, 0.10800597f, 
    -0.01029818f, 0.07491368f, 0.06305432f, 0.04776690f, -0.37493506f, -0.22773439f, -0.04383574f, -0.14561971f, 
    0.29715535f, 0.15999831f, -0.11412491f, -0.11546371f, 0.09338786f, 0.16128612f, 0.04611678f, 0.15181036f, 
    0.00761387f, 0.05442116f, -0.05089713f, -0.03666893f, -0.02607634f, -0.55335093f, -0.52721864f, 0.04239762f, 
    0.02131027f, 0.02386130f, -0.18348832f, -0.19613719f, -0.02755362f, -0.15290639f, -0.16743471f, -0.07752854f, 
    0.23892717f, 0.04864796f, -0.00763707f, -0.23067839f, 0.08108416f, 0.19591877f, 0.09693030f, -0.02055820f, 
    -0.02655291f, -0.05765511f, -0.05011464f, -0.06653023f, -0.13797446f, 0.00246881f, 0.25282583f, -0.29263732f, 
    0.03849925f, -0.04026430f, -0.17809142f, -0.04681082f, -0.00319733f, -0.04162356f, 0.01980975f, 0.08325157f, 
    -0.19989872f, -0.05656418f, 0.21869746f, -0.19125958f, 0.00619437f, 0.01949786f, 0.09257623f, 0.08162815f, 
    0.11066748f, -0.02857428f, -0.06153021f, -0.09162617f, -0.31403321f, 0.09952991f, 0.02552784f, 0.02790515f, 
    0.04139508f, -0.00241440f, -0.12074915f, -0.04236765f, -0.29299864f, 0.04374998f, -0.07632949f, 0.13805079f, 
    0.12875441f, -0.23359098f, -0.03141713f, 0.00777308f, -0.03627168f, -0.06011434f, 0.02682981f, -0.17254457f, 
    -0.00846640f, -0.03470089f, -0.04148658f, -0.02049854f, -0.07292662f, 0.19569565f, 0.01892333f, -0.14305983f, 
    0.06531195f, 0.09532669f, 0.11854928f, -0.18246102f, -0.20880903f, -0.12685420f, -0.19651341f, -0.06418524f, 
    0.15355009f, 0.38917273f, -0.01953746f, 0.02031538f, -0.03248019f, 0.31793028f, 0.05106553f, -0.12403189f, 
    0.08144307f, 0.08304816f, 0.18084762f, 0.06039077f, 0.59069371f, -0.36848626f, -0.57966918f, 0.07194850f, 
    -0.03908537f, 0.02946328f, 0.15220396f, -0.00369784f, -0.02306856f, 0.02983036f, 0.04040332f, -0.03673733f, 
    0.03596508f, 0.07798114f, -0.44593805f, 0.07073905f, -0.02574682f, 0.05089412f, -0.34606001f, -0.35562748f, 
    -0.27865216f, -0.10414918f, -0.10698198f, -0.03107767f, 0.08506158f, 0.13931526f, 0.11419079f, -0.09750713f, 
    -0.03478483f, -0.01276901f, -0.00743494f, -0.00442194f, -0.16913335f, -0.01254003f, 0.03571881f, -0.06768979f, 
    0.23968013f, 0.10446057f, -0.16030718f, -0.15667452f, 0.10111883f, 0.17564768f, -0.10774910f, -0.13286898f, 
    -0.08926759f, -0.19781668f, -0.07949659f, 0.01328723f, 0.55565739f, 0.35962522f, -0.23243135f, -0.28167453f, 
    0.13904922f, 0.09572835f, 0.06510500f, 0.07407225f, -0.06080812f, -0.05344784f, -0.11091415f, -0.13690847f, 
    -0.00491415f, 0.24422994f, 0.11905063f, 0.00253875f, 0.02517697f, 0.40331003f, 0.03877555f, 0.10184485f, 
    0.05481735f, 0.07778870f, 0.01431023f, -0.01300310f, -0.08372711f, -0.10264255f, -0.09787253f, -0.05331922f, 
    -0.04024340f, 0.03273857f, 0.10009695f, -0.20527083f, -0.14171781f, 0.01781688f, 0.00507663f, 0.09038597f, 
    -0.42273927f, -0.58819771f, -0.43727139f, 0.14562555f, -0.05786142f, -0.06404503f, -0.00602758f, -0.10205868f, 
    -0.08364920f, -0.19794886f, -0.24368379f, -0.08310667f, 0.14125463f, -0.29378983f, 0.01836128f, 0.00032743f, 
    -0.20714040f, -0.00711965f, 0.01828326f, -0.14009364f, 0.03249611f, 0.01568993f, 0.02169358f, 0.02330569f, 
    -0.78811586f, -0.53378940f, -0.24489613f, 0.31633911f, 0.07646498f, 0.03021665f, 0.07012251f, 0.01211283f, 
    0.00504316f, -0.02509317f, 0.04572525f, 0.09433014f, -0.06457414f, -0.04579487f, -0.10194824f, 0.01460060f, 
    0.18492526f, 0.03111810f, -0.30049884f, -0.14501439f, 0.04194807f, -0.21457507f, -0.08825497f, -0.02548875f, 
    -0.39228114f, 0.04835305f, 0.27175915f, -0.06365836f, -0.19016731f, -0.11579269f, 0.01298936f, 0.02842540f, 
    -0.02989777f, -0.04507340f, -0.02891658f, -0.09064505f, 0.41657963f, 0.25721955f, -0.12906992f, -0.25087669f, 
    -0.03385355f, -0.03810271f, 0.00169344f, 0.16170606f, -0.11233463f, -0.04474326f, -0.00048173f, -0.02995998f, 
    0.02776678f, 0.01208678f, 0.00435563f, 0.10739177f, 0.05909269f, 0.04265227f, 0.05168344f, 0.06525248f, 
    -0.21684612f, -0.05418096f, -0.10162158f, 0.10725971f, -0.33286607f, -0.33051518f, -0.03654444f, 0.22053149f, 
    -0.13191265f, 0.04988194f, -0.16249858f, 0.01362963f, -0.19038436f, -0.01945925f, -0.16296926f, -0.26629943f, 
    0.25672615f, 0.33368278f, 0.12848379f, -0.33565205f, 0.10914727f, -0.00265933f, -0.12374894f, -0.02987053f, 
    -0.06995661f, -0.02585755f, -0.07546139f, 0.01806287f, -0.24917457f, -0.10922033f, -0.08922068f, 0.16225736f, 
    -0.00919969f, 0.02229398f, 0.03724008f, 0.09338316f, 0.00383718f, 0.02026421f, 0.11279396f, 0.04926499f, 
    -0.00933366f, -0.55464464f, -0.23746894f, -0.43569323f, -0.03072535f, 0.08862159f, 0.01205490f, -0.00794393f, 
    -0.02380339f, -0.03074388f, 0.07865981f, 0.02491252f, 0.22180305f, 0.37925288f, 0.61736643f, -0.69471359f, 
    0.13688979f, 0.08103742f, 0.04117593f, 0.19225442f, -0.00784340f, -0.08879339f, -0.29683694f, -0.15742494f, 
    -0.25034794f, -0.05133249f, 0.05684241f, 0.08916996f, 0.10156355f, 0.05745994f, 0.08693337f, -0.03734153f, 
    -0.03330376f, -0.07451931f, 0.06491861f, 0.03746265f, 0.36932939f, 0.12274405f, -0.08956115f, 0.00377355f, 
    0.16149640f, 0.13620608f, 0.03763537f, -0.22189032f, 0.00357085f, 0.06519385f, -0.05276738f, 0.18129301f, 
    -0.06471673f, 0.22411120f, -0.22031410f, 0.19777437f, -0.11910495f, 0.03387168f, -0.14536045f, 0.20250447f, 
    -0.04434050f, -0.11680438f, -0.00430100f, -0.06002642f, 0.03185332f, 0.00895500f, 0.13495368f, 0.12748669f, 
    -0.02886653f, -0.05173832f, 0.02323975f, 0.04147081f, -0.04487962f, -0.05249832f, 0.00497582f, 0.16780767f, 
    0.16726568f, 0.23849536f, 0.15702964f, -0.11170961f, -0.05990315f, -0.06307776f, 0.24682251f, -0.01845456f, 
    -0.03635316f, -0.04123819f, 0.02642473f, -0.13058643f, 1.08869433f, -0.16836852f, 0.17906807f, -0.22294591f, 
    -0.05814958f, -0.06918807f, 0.13921931f, -0.07902407f, 0.03846341f, 0.12062306f, 0.12024485f, -0.10011956f, 
    0.19459940f, 0.18444900f, -0.19382122f, -0.11703943f, 0.14818399f, 0.12856358f, -0.21335822f, -0.41517773f, 
    -0.00532629f, 0.05180338f, -0.15682110f, -0.09266261f, -0.21805610f, 0.14423604f, -0.06389981f, -0.22096127f, 
    -0.12804511f, -0.21366146f, -0.09430815f, 0.21202752f, -0.13140814f, 0.07865611f, 0.24268556f, -0.05295558f, 
    -0.13767715f, 0.28873029f, 0.11399383f, -0.05331334f, -0.00669956f, -0.02308977f, -0.04176388f, -0.07775237f, 
    0.20360488f, 0.01895631f, 0.10733157f, 0.04905886f, 0.07390223f, 0.11214431f, 0.07005159f, -0.07514568f, 
    -0.06406209f, 0.03377416f, -0.11489423f, 0.01356465f, -0.45546034f, -0.47175810f, -0.18247247f, -0.19858065f, 
    0.02594011f, -0.24406685f, 0.19642162f, -0.22512197f, -0.08758769f, 0.14734042f, -0.17406395f, 0.19940738f, 
    -0.04223544f, -0.14069343f, 0.05397646f, 0.08545756f, -0.55631101f, -0.30233553f, -0.51305360f, -0.51065356f, 
    -0.16015843f, 0.13308734f, 0.01330774f, 0.02194865f, 0.04360939f, 0.15967166f, -0.19497447f, 0.04426375f, 
    -0.12810610f, 0.14412700f, 0.07310637f, 0.06260318f, -0.21306856f, -0.03748361f, -0.33874127f, -0.33144051f, 
    -0.12521411f, -0.16605672f, -0.09700923f, -0.03950682f, 0.37498137f, -0.35483602f, 0.19894491f, 0.25479868f, 
    -0.01289540f, 0.01546609f, -0.02453187f, 0.04823713f, 0.24805486f, -0.12584595f, 0.00409831f, 0.10701079f, 
    0.49484503f, -0.10639934f, -0.11755557f, -0.05924067f, -0.05863930f, 0.00880023f, -0.12030683f, -0.05942697f, 
    0.17862238f, -0.05564128f, -0.11992022f, 0.06107109f, -0.26977345f, 0.23825452f, -0.13111761f, -0.19058910f, 
    -0.07079425f, 0.14935356f, 0.00116676f, -0.03220611f, 0.33374998f, -0.28729451f, 0.02282035f, 0.16551207f, 
    0.03221394f, 0.08994643f, 0.02485443f, 0.27904010f, 0.09652687f, 0.03878589f, 0.14075147f, 0.31041491f, 
    -0.08828101f, -0.05109277f, 0.04009098f, 0.06207843f, 0.37133095f, 0.20371465f, 0.19733562f, 0.31726307f, 
    0.06456088f, 0.07263906f, -0.00080286f, -0.02876113f, 0.06723239f, 0.02991751f, 0.04884159f, 0.11285325f, 
    -0.06256300f, 0.18279935f, 0.28601006f, 0.16570380f, 0.26586512f, 0.10547531f, -0.63239950f, -0.24739783f, 
    -0.05234724f, -0.04411566f, -0.14516297f, 0.03450105f, 0.35359320f, 0.02912773f, -0.10064542f, -0.24087591f, 
    0.02897662f, 0.13524722f, -0.02605306f, -0.21545462f, -0.12290277f, 0.07520942f, 0.00983307f, -0.16198519f, 
    0.06780366f, -0.08029951f, 0.38797480f, -0.23796037f, 0.05469543f, -0.06496373f, -0.01066763f, 0.09031627f, 
    -0.04653252f, 0.00084793f, 0.08134127f, -0.08616137f, 0.00945820f, -0.15794721f, 0.07059027f, -0.19928919f, 
    -0.04095986f, -0.02440796f, -0.00292371f, -0.05655572f, -0.17436640f, 0.16016540f, -0.08084189f, 0.05205650f, 
    0.43803012f, 0.24842161f, 0.13096090f, 0.11603726f, -0.06604216f, -0.06041134f, -0.02588004f, 0.01661395f, 
    0.00303119f, 0.03632543f, 0.01726517f, -0.02266253f, -0.07523713f, 0.31845498f, 0.08595086f, -0.11025597f, 
    0.08952384f, 0.18559255f, -0.01032730f, 0.03139516f, 0.03694322f, 0.03974871f, -0.02865486f, -0.24038252f, 
    -0.29288712f, -0.05263278f, 0.07465787f, -0.04563960f, 0.12283187f, 0.08988982f, -0.09886032f, 0.15066727f, 
    -0.13614118f, 0.21499114f, 0.04316499f, -0.40976414f, -0.17615131f, 0.02926401f, 0.26037154f, 0.13025832f, 
    -0.01774940f, 0.08345890f, 0.08376554f, 0.03615884f, 0.00736046f, 0.03360940f, 0.00964662f, 0.03909599f, 
    -0.00119841f, 0.02968471f, 0.09288601f, 0.08925969f, 0.03959041f, -0.02614713f, -0.02286524f, 0.05634303f, 
    -0.16625699f, 0.02960558f, 0.06722505f, -0.04487014f, 0.39194122f, -0.11595304f, -0.12487701f, -0.03102042f, 
    0.07906696f, -0.08246661f, 0.16595605f, 0.00055309f, 0.14362416f, -0.02243038f, -0.02269368f, 0.04718243f, 
    -0.61360639f, -0.14538461f, -0.65124470f, -0.50129914f, 0.05955334f, -0.37011334f, -0.00764239f, -0.18422419f, 
    -0.03992809f, 0.07239094f, 0.00507063f, 0.00667026f, 0.20411894f, 0.06622218f, 0.12372781f, 0.12421328f, 
    -0.07685661f, 0.03061935f, -0.12338990f, 0.01224941f, -0.07889205f, 0.02756101f, -0.02500708f, 0.08546496f, 
    0.43306693f, -0.01955342f, 0.21466225f, -0.06566568f, -0.03977269f, 0.00313420f, -0.05447082f, -0.05730625f, 
    -0.02281164f, -0.00198419f, -0.10953955f, -0.01419177f, -1.10390186f, 0.00110603f, -0.11869980f, -0.08242142f, 
    0.07216747f, -0.10373801f, 0.20754690f, 0.15099056f, 0.07224110f, -0.09494148f, 0.11572396f, 0.00607075f, 
    0.04106283f, 0.15347053f, 0.10171837f, 0.18134397f, 0.01268009f, -0.03656542f, -0.02610233f, 0.03142165f, 
    0.03551783f, 0.10539157f, 0.16154052f, -0.03946899f, -0.02793390f, -0.16541865f, -0.22122860f, -0.03736006f, 
    0.01746547f, 0.14195228f, -0.06670256f, -0.08312345f, -0.06247788f, -0.03952783f, 0.02636329f, -0.09037778f, 
    0.58771276f, -0.48598999f, 0.17766634f, 0.71425241f, 0.03406034f, -0.15417245f, -0.22074370f, 0.12245301f, 
    -0.02470415f, 0.06683940f, -0.04252526f, 0.07222468f, -0.10375685f, -0.11837772f, -0.04065580f, 0.02212100f, 
    -0.00569002f, 0.02354212f, 0.08300273f, 0.09024496f, -0.18119355f, -0.15304936f, 0.12229154f, 0.05507678f, 
    -0.19911394f, -0.04135694f, 0.22059715f, 0.03751551f, 0.15748589f, 0.10128108f, 0.18218073f, 0.24451083f, 
    -0.00522715f, -0.04635557f, -0.02584257f, -0.14658546f, -0.42932823f, 0.46509156f, 0.32704508f, 0.02080621f, 
    -0.09634400f, 0.03499665f, 0.07982702f, -0.19005013f, 0.06564541f, 0.14164892f, 0.03387911f, -0.12452181f, 
    0.14065103f, 0.80920053f, 0.55876601f, 0.43636402f, -0.21733260f, 0.04846402f, -0.01559311f, -0.00822533f, 
    0.07167668f, 0.03514065f, -0.02801774f, 0.05954506f, -0.23043750f, 0.15048023f, -0.11306536f, 0.01292360f, 
    0.03404830f, -0.37363002f, -0.17110707f, 0.02431278f, -0.08580645f, -0.00701116f, -0.02554608f, 0.05884772f, 
    -0.24853204f, 0.04323170f, -0.47991759f, -0.05431655f, 0.00759900f, -0.00850722f, 0.03244863f, 0.08791874f, 
    -0.12494174f, -0.02775394f, 0.11432187f, -0.20175119f, -0.04781786f, -0.05178254f, 0.00956420f, -0.06595382f, 
    0.02223961f, -0.06617780f, -0.01200839f, -0.11901641f, 0.14398186f, 0.18842956f, -0.04540822f, 0.28955400f, 
    -0.18517716f, -0.44694832f, 0.02597574f, -0.00670142f, 0.07606620f, 0.02640220f, -0.33739626f, -0.13782071f, 
    0.05537639f, -0.13847323f, 0.10513351f, -0.01093530f, 0.17461370f, 0.10461789f, 0.12299231f, -0.18699996f, 
    0.00465364f, 0.17795037f, -0.04622368f, 0.00103597f, -0.20814265f, 0.01187332f, -0.13163833f, 0.12396851f, 
    0.04128617f, -0.01350282f, -0.08142575f, 0.17675340f, 0.16653095f, -0.05705968f, 0.15877229f, 0.07433543f, 
    0.05160032f, 0.03250449f, 0.00049139f, 0.05527367f, 0.05563869f, 0.11372180f, 0.24799851f, 0.16714740f, 
    -0.00754968f, -0.00344178f, 0.01440262f, 0.03388859f, 0.17596944f, 0.10350298f, 0.06251628f, -0.03939378f, 
    0.00114271f, -0.10624921f, 0.34650466f, -0.18555541f, 0.09606525f, 0.02111132f, -0.17303185f, -0.03690970f, 
    0.01371441f, 0.10665996f, -0.07296152f, 0.11514266f, 0.12941419f, -0.00158185f, -0.03392814f, -0.01150207f, 
    -0.10910835f, -0.00442585f, -0.01194234f, -0.04556850f, -0.12264472f, 0.19953725f, 0.07165741f, 0.04093056f, 
    -0.37127849f, -0.17666692f, -0.28659114f, -0.32795358f, -0.02902181f, -0.02894700f, 0.07486986f, 0.03774609f, 
    -0.06340522f, -0.17834710f, -0.12834883f, -0.08104831f, -0.82459766f, -0.37494066f, -0.07061348f, -0.27118552f, 
    0.11858459f, 0.03305755f, -0.09168445f, 0.14617389f, -0.03969045f, 0.02804869f, -0.06471484f, -0.07432662f, 
    0.22599475f, -0.00122864f, -0.10849942f, 0.31523639f, 0.09727545f, -0.02306510f, 0.05933870f, -0.17479853f, 
    0.08251762f, -0.02891138f, -0.01077747f, 0.03150465f, -0.24654576f, 0.34537956f, 0.06610169f, 0.07515198f, 
    0.06384026f, 0.16249064f, -0.13200872f, 0.14640649f, -0.10626872f, 0.07510480f, 0.11106143f, 0.16036910f, 
    -0.12635002f, 0.54392374f, 0.12761559f, 0.00262494f, 0.02792552f, 0.13471344f, -0.10432748f, -0.03198212f, 
    -0.02622443f, -0.07426153f, 0.06673735f, 0.17630662f, -0.13889530f, -0.14495577f, 0.12321088f, 0.02326645f, 
    0.15484542f, -0.05202586f, -0.23349887f, -0.25810280f, 0.04050038f, 0.00278889f, 0.01291380f, 0.04726947f, 
    -0.40396383f, -0.21336797f, 0.47830629f, -0.36959410f, -0.02107314f, -0.01317958f, -0.03128865f, 0.10088228f, 
    0.07346875f, -0.06796842f, 0.09345219f, 0.05741749f, -0.23623817f, 0.23058875f, 0.18475010f, 0.07563764f, 
    -0.00892859f, 0.22059248f, -0.11658939f, 0.04737097f, -0.12736402f, 0.00877434f, -0.11279246f, -0.16656570f, 
    0.17489500f, 0.01755298f, -0.26889062f, 0.20625010f, 0.00337936f, 0.09010139f, 0.13099697f, -0.09663866f, 
    -0.08059051f, 0.12764280f, -0.02479749f, 0.09159151f, -1.02818954f, -0.39256170f, -0.18394358f, -0.27796367f, 
    0.13327463f, 0.04471615f, 0.09848161f, -0.23298594f, 0.01579429f, 0.03691872f, -0.01579049f, -0.08449604f, 
    -0.15262914f, -0.01055730f, -0.09283776f, 0.00734450f, 0.08995073f, 0.01693008f, 0.00048489f, 0.10841155f, 
    -0.39716345f, -0.05890637f, 0.18438095f, -0.10927843f, 0.14254493f, 0.00832571f, -0.08297402f, -0.37212914f, 
    -0.04535021f, -0.12618841f, -0.14110582f, 0.16768718f, 0.05791255f, 0.02163057f, -0.29502612f, -0.00432459f, 
    -0.72440875f, -0.00841960f, 0.12939239f, -0.18468298f, -0.13865796f, -0.20028365f, -0.14691192f, 0.07585639f, 
    -0.03468323f, -0.00807688f, 0.01703455f, -0.02043021f, 0.06739674f, 0.07659490f, -0.36380491f, -0.25938457f, 
    0.04548040f, 0.07272071f, -0.11197806f, 0.11219373f, -0.04227620f, -0.07284068f, 0.01989341f, -0.04725629f, 
    -0.73130989f, -0.05323452f, 0.31087700f, -0.86453658f, -0.00525648f, -0.01500061f, -0.09356812f, 0.07899475f, 
    0.03997009f, 0.07600119f, -0.08174165f, 0.10999804f, 0.10578603f, -0.33144379f, -0.51178902f, 0.30577064f, 
    -0.23922715f, -0.15900432f, -0.09896535f, -0.03495005f, -0.05079423f, -0.07698211f, -0.03397461f, 0.04158549f, 
    -0.02476492f, -0.04251413f, 0.17500228f, -0.12473208f, 0.01012000f, -0.03940456f, 0.03526672f, 0.02252542f, 
    0.02162240f, -0.04711578f, 0.04406842f, 0.01397646f, -0.00726617f, 0.28424042f, 0.18049833f, 0.29762283f, 
    -0.14987271f, -0.06007215f, 0.04289163f, -0.03739054f, -0.03870304f, -0.04379184f, 0.03750031f, -0.01038769f, 
    -0.21806966f, 0.06086757f, -0.25588292f, 0.00424366f, 0.13314830f, 0.05145024f, -0.07118590f, 0.08500031f, 
    -0.10784277f, 0.13447836f, -0.12546632f, 0.16995424f, -0.02031977f, -0.07896908f, 0.06687840f, -0.24814790f, 
    0.09342322f, 0.23848505f, 0.19079976f, -0.04716012f, -0.29515162f, -0.01910106f, -0.25003776f, -0.15136199f, 
    -0.08144083f, 0.04182261f, -0.29653534f, 0.06357124f, 0.07319993f, -0.10038367f, -0.11953080f, -0.04242250f, 
    0.10010380f, -0.08269439f, 0.00762347f, -0.10772640f, -0.64502358f, 0.45901176f, 0.25439024f, 0.19209675f, 
    0.05403146f, 0.09454186f, 0.24394725f, -0.01905543f, -0.11310634f, 0.05558752f, -0.05753065f, -0.05770663f, 
    0.31775722f, -0.11273196f, 0.08891168f, 0.21285905f, 0.18329687f, -0.02106885f, -0.02279877f, 0.10516472f, 
    -0.09552655f, 0.01757150f, 0.03270918f, 0.11425846f, 0.22222441f, 0.32931447f, 0.07912305f, 0.46011510f, 
    -0.12184811f, -0.12248628f, -0.03502936f, -0.17538598f, 0.08760872f, 0.03580409f, -0.00579022f, 0.08500984f, 
    0.07576332f, 0.14033367f, -0.31979582f, -0.52121216f, -0.12872767f, -0.01635496f, -0.09025848f, -0.06570994f, 
    -0.31490278f, 0.02084003f, 0.18798919f, -0.17421576f, -0.04155063f, -0.04886985f, -0.20070477f, 0.17260358f, 
    -0.23498765f, 0.07469989f, -0.15027902f, 0.09397789f, 0.19567385f, 0.27526996f, -0.09421048f, 0.02656473f, 
    0.18796754f, 0.06346214f, 0.08600061f, 0.00488042f, -0.01294376f, 0.17179914f, -0.30566907f, -0.05352428f, 
    0.03455980f, 0.05881482f, 0.15958987f, -0.24338254f, 0.12789047f, 0.07539765f, -0.17970215f, 0.02143982f, 
    0.20626499f, -0.12310302f, 0.04594276f, -0.02529795f, -0.02591684f, 0.24819976f, -0.13412260f, 0.11415023f, 
    0.38752398f, -0.21532258f, -0.14450477f, 0.25523791f, -0.03521998f, -0.07046255f, 0.05294878f, -0.09620335f, 
    -0.01612806f, -0.02951309f, -0.04309843f, 0.23644163f, -0.17802240f, 1.32870066f, -0.36135674f, -0.48867050f, 
    0.41920358f, 0.02367612f, 0.10699296f, -0.03644872f, -0.33290055f, -0.07032824f, 0.05660949f, 0.00891688f, 
    -0.49075434f, -0.45370910f, -0.11955946f, 0.16590473f, -0.06244303f, -0.26964504f, 0.27602652f, -0.33687350f, 
    0.11411012f, -0.03146671f, 0.00459535f, -0.13274536f, -0.31742054f, -0.01212057f, -0.21553224f, -0.13193588f, 
    -0.10274136f, -0.18156807f, 0.08446098f, -0.28624848f, 0.02992146f, -0.09607167f, -0.30706546f, -0.16388433f, 
    0.04705864f, -0.09274139f, 0.10037055f, 0.22062615f, 0.05707711f, -0.03385406f, 0.01800107f, -0.08863120f, 
    -0.04155463f, 0.20011838f, 0.03911609f, 0.03404962f, -0.19107758f, -0.08935381f, -0.04867474f, 0.23693290f, 
    0.05412663f, 0.08947346f, 0.04184999f, 0.07906242f, -0.13203220f, -0.07060632f, -0.13169815f, -0.01001925f, 
    0.62261945f, -0.31113642f, 0.13975690f, 0.25074229f, 0.02821678f, -0.04819320f, 0.07227354f, -0.08150670f, 
    -0.04988879f, 0.01110851f, 0.11207024f, 0.28654948f, -0.46324760f, -0.18356623f, 0.00351550f, 0.09200094f, 
    -0.02115496f, 0.02290932f, -0.25077978f, -0.03563737f, -0.13518582f, -0.08322820f, 0.05556391f, -0.22855201f, 
    -0.45292202f, -0.07715207f, -0.10052708f, 0.48874179f, -0.29608411f, 0.17937681f, -0.20171911f, -0.18657404f, 
    -0.11226118f, 0.04942596f, -0.02308286f, 0.15615994f, 0.15269960f, -0.09946593f, 0.37734553f, -0.04978584f, 
    -0.06801038f, -0.04770609f, 0.00388190f, 0.05279939f, 0.02789685f, -0.04924832f, -0.12395718f, -0.15997435f, 
    -0.59831524f, -0.07889847f, 0.26258898f, -0.22951329f, -0.15891710f, -0.18730049f, -0.29612282f, -0.04860082f, 
    0.01314487f, 0.01919673f, 0.08845524f, 0.00683422f, 0.13168122f, 0.06661346f, 0.02179988f, 0.45754179f, 
    0.01557041f, -0.10322808f, 0.17304020f, -0.14410385f, -0.01006918f, 0.06863752f, 0.20806077f, 0.12576191f, 
    0.56027675f, 0.18915199f, -0.18397057f, -0.60726255f, -0.13958253f, -0.04666281f, 0.00781167f, -0.07979438f, 
    -0.12763812f, -0.14529371f, -0.00333722f, -0.06430059f, 0.00081531f, -0.26653841f, -0.06953379f, 0.14759359f, 
    0.12594017f, 0.15673138f, 0.04141721f, 0.14907840f, 0.02085090f, -0.01501559f, 0.08586180f, -0.07231329f, 
    -0.24331796f, 0.29867855f, -0.06704927f, -0.61747259f, 0.26689634f, 0.13314262f, -0.15242785f, -0.03882391f, 
    -0.05962823f, -0.11451562f, -0.10283573f, -0.09246109f, -0.47800690f, 0.21318412f, -0.07889914f, 0.19802296f, 
    0.12888113f, 0.03890164f, -0.20394462f, 0.09356330f, -0.17496689f, -0.02214561f, 0.06985386f, 0.02536630f, 
    0.04434667f, 0.01222147f, 0.08586501f, 0.16860953f, -0.02414414f, 0.05336916f, -0.00109038f, 0.00870533f, 
    -0.01371445f, 0.05541143f, 0.03632800f, 0.10755356f, -0.20616351f, -0.24662867f, 0.00953591f, -0.11004113f, 
    0.23887312f, 0.29485086f, -0.21224052f, -0.18757054f, 0.05322375f, 0.11281058f, 0.17262678f, -0.25328368f, 
    -0.22643024f, -0.48053938f, 0.50360143f, 0.15703744f, -0.20828876f, -0.15468428f, -0.17959526f, -0.03451375f, 
    -0.12383962f, 0.15234900f, -0.42063141f, 0.02900162f, 0.29586020f, 0.16185385f, -0.04049059f, -0.69487005f, 
    -0.18144298f, -0.16574000f, -0.14646143f, -0.05119478f, -0.09039901f, 0.06779964f, -0.20006602f, 0.01821332f, 
    -0.49528244f, 0.05376786f, 0.03106780f, -0.30998877f, -0.04462685f, 0.12491909f, -0.32842290f, -0.06451036f, 
    0.19234645f, 0.09830308f, 0.02233111f, 0.14250770f, -0.29232612f, -0.17518176f, -0.06331226f, 0.31197131f, 
    0.19189349f, 0.04407617f, 0.10467333f, 0.07609309f, -0.00334129f, 0.15873854f, -0.02931780f, -0.01082653f, 
    0.04101089f, 0.21275048f, 0.04391886f, 0.12369721f, -0.07218001f, -0.03857454f, 0.17789885f, -0.27888918f, 
    -0.06238967f, 0.08751046f, -0.02541547f, 0.08562816f, 0.15074459f, 0.05936768f, -0.05400101f, -0.08085452f, 
    0.12504473f, 0.05869472f, 0.05792775f, 0.15585247f, 0.22424397f, 0.05550190f, -0.12756774f, -0.16630051f, 
    -0.12431816f, -0.04812175f, 0.10687865f, 0.17565170f, -0.03656426f, -0.01390053f, -0.39838827f, -0.18922468f, 
    0.05333207f, -0.05233205f, 0.03083721f, 0.08681823f, 0.00264855f, -0.12394127f, -0.03869150f, -0.08875058f, 
    -0.05920006f, -0.26028293f, 0.04952664f, 0.01824781f, -0.18213947f, -0.05193704f, -0.07028235f, 0.24798541f, 
    -0.04748408f, -0.00404286f, 0.09406231f, 0.14076480f, -0.05112398f, -0.10102381f, 0.12783860f, -0.13014041f, 
    0.01747256f, 0.02290075f, 0.00365891f, 0.00312883f, 0.04975423f, -0.06764606f, 0.01849061f, 0.17161629f, 
    -0.06113854f, 0.23538207f, -0.12199728f, 0.03701399f, 0.04766514f, -0.06401314f, -0.19664434f, 0.08909614f, 
    -0.59820265f, -0.51890737f, 0.08839653f, 0.02864541f, 0.00142681f, 0.01956242f, 0.05924706f, 0.06201591f, 
    -0.14385584f, -0.02400305f, -0.11949011f, 0.10174954f, 0.09638568f, -0.02082429f, -0.09670146f, -0.00513821f, 
    0.04241192f, -0.04287056f, 0.01830997f, -0.14472240f, 0.15040818f, 0.17858544f, 0.20333613f, 0.40241158f, 
    -0.11225852f, 0.22281289f, 0.14478487f, 0.21290785f, -0.08849470f, -0.02999561f, 0.19359016f, -0.08594513f, 
    0.00001262f, 0.04560041f, -0.09920506f, -0.21622773f, 0.43005446f, 0.09434789f, 0.08351529f, 0.20828918f, 
    -0.06811113f, 0.00530428f, -0.11091244f, 0.05633534f, 0.06581488f, -0.30529237f, 0.00484475f, -0.22579762f, 
    0.12334324f, -0.22807379f, 0.09441453f, 0.16859926f, -0.01123425f, -0.39035219f, -0.17706826f, 0.04139293f, 
    0.08554550f, 0.01660494f, 0.05588958f, -0.08609784f, -0.10476884f, -1.13727748f, 0.08575593f, -0.33510235f, 
    0.02010331f, 0.24843490f, -0.09884983f, 0.02131305f, 0.01459413f, 0.00296003f, -0.19421652f, 0.06745486f, 
    0.08657251f, 0.10143179f, -0.33572119f, 0.14238283f, -0.03093210f, 0.04703903f, -0.03092553f, -0.22965562f, 
    -0.18362871f, -0.10231711f, 0.08440109f, -0.00136589f, -0.38118774f, -0.21713534f, 0.05035418f, -0.03586111f, 
    -0.13229586f, -0.00358912f, -0.23031615f, -0.00126809f, -0.19086988f, -0.00251044f, -0.09121471f, -0.39796373f, 
    0.29638112f, 0.04480590f, 0.07086546f, 0.20181608f, 0.02561970f, 0.11908026f, 0.03339133f, -0.20082416f, 
    0.13219705f, -0.05571410f, -0.13020368f, -0.02674895f, -0.10722875f, -0.08462802f, 0.02214739f, 0.04968359f, 
    0.02570122f, 0.00805684f, -0.00456034f, -0.00687433f, -0.03309757f, -0.01621973f, 0.01613229f, -0.00633074f, 
    -0.08951225f, -0.10494122f, -0.04328841f, 0.13684422f, -0.10871106f, -0.04097170f, -0.03352906f, -0.05992301f, 
    0.05025127f, -0.01160032f, 0.09155028f, 0.22233120f, -0.08177026f, 0.02949959f, -0.09263459f, 0.09676530f, 
    -0.14236747f, -0.05253742f, -0.12762988f, 0.03687301f, -0.05695132f, -0.02040143f, -0.09547554f, 0.07658476f, 
    -0.30382305f, 0.11436648f, -0.34668237f, 0.01154691f, 0.10127356f, -0.03406183f, -0.22733855f, 0.00208960f, 
    -0.02814356f, -0.20321530f, -0.06898912f, 0.01874038f, 0.02373096f, 0.26600227f, -0.04946801f, 0.15298028f, 
    -0.10569527f, 0.09577665f, -0.17532276f, 0.01902713f, 0.09967913f, -0.05161666f, 0.04545908f, -0.20592374f, 
    0.18235667f, 0.00958917f, -0.07576105f, 0.25649449f, -0.00685783f, 0.09751314f, 0.13912086f, 0.02301616f, 
    0.16249566f, -0.00560399f, 0.00275722f, -0.05491522f, -0.17869642f, 0.04597770f, 0.04547333f, 0.03063127f, 
    -0.18548489f, -0.13656943f, -0.14624986f, 0.13426068f, 0.04011723f, 0.01789311f, -0.11986618f, -0.01340797f, 
    -0.18861140f, -0.26838842f, -0.08996945f, 0.11055951f, -0.19388583f, -0.02278103f, -0.15293565f, -0.19455419f, 
    -0.02299647f, -0.18064000f, -0.22081687f, 0.19571191f, 0.18568675f, 0.25059405f, 0.31670505f, 0.24881637f, 
    -0.13538522f, -0.12340853f, -0.03138404f, 0.18653369f, 0.02560225f, 0.05812270f, -0.00708177f, 0.05467487f, 
    0.19966552f, 0.00324080f, -0.01535200f, -0.03724222f, 0.02457539f, -0.01627497f, 0.03406399f, 0.07729767f, 
    -0.09670109f, -0.12485099f, -0.14330776f, -0.09673540f, 0.01074591f, 0.04090596f, 0.04201054f, -0.26356608f, 
    0.05290475f, 0.06154367f, -0.32837737f, -0.09815533f, -0.14708120f, -0.02966153f, -0.08563752f, -0.25069684f, 
    0.13196819f, -0.14365791f, 0.31160572f, 0.29214305f, -0.00475690f, 0.19775371f, 0.00157095f, 0.16067798f, 
    0.03201256f, -0.07102199f, 0.01687226f, -0.08567224f, 0.17182292f, 0.10052870f, 0.06874529f, -0.09071045f, 
    0.08690763f, 0.02670983f, 0.15739331f, 0.04378914f, 0.09538913f, -0.13895540f, -0.12340305f, -0.05605267f, 
    -0.18411876f, 0.36594093f, -0.02855755f, 0.20623952f, 0.13030548f, 0.00543627f, 0.03607263f, -0.05113216f, 
    0.04013439f, 0.01742083f, 0.04814407f, -0.14683448f, -0.11399498f, -0.21107490f, -0.01644632f, 0.20658624f, 
    -0.23107757f, 0.19061098f, -0.15196918f, -0.14065373f, -0.04074998f, -0.02681123f, 0.04347755f, 0.00392195f, 
    0.06218616f, -0.12357485f, -0.17569576f, 0.19379194f, 0.09155621f, -0.05951273f, 0.08549827f, -0.07168071f, 
    -0.01667188f, -0.02563673f, -0.03744388f, 0.06152840f, 0.15421756f, 0.05659565f, 0.16372402f, 0.09426191f, 
    0.07357045f, -0.07726354f, 0.00811096f, -0.00664477f, 0.19038239f, 0.03459490f, 0.02179412f, 0.09501050f, 
    -0.26635379f, -0.17796992f, 0.38619357f, 0.05207799f, -0.03204446f, 0.11365843f, -0.10239965f, 0.05829970f, 
    0.19197959f, -0.06336024f, -0.05559579f, -0.13431931f, -0.13131939f, -0.00484462f, -0.08486237f, -0.04562045f, 
    0.04242187f, -0.12794144f, -0.04437998f, -0.11738863f, -0.04376937f, -0.08476837f, 0.21258897f, 0.03444189f, 
    -0.13650766f, 0.05700602f, -0.04311630f, -0.12614699f, 0.13034660f, 0.03923010f, 0.15844046f, -0.13497235f, 
    0.14866321f, 0.08823030f, -0.01116373f, 0.15419607f, -0.34659874f, -0.37609637f, -0.52193689f, -0.15987119f, 
    0.10507479f, 0.12204890f, -0.20535636f, 0.05585810f, 0.23466006f, -0.11468378f, 0.11010255f, -0.33701101f, 
    -0.42400804f, -0.07174063f, -0.36315459f, -0.12218070f, 0.04555199f, -0.06289447f, -0.07981737f, 0.12835124f, 
    0.01382069f, -0.02220211f, -0.07827147f, 0.02687420f, 0.01789296f, -0.45494094f, 0.15577914f, 0.18032238f, 
    0.07443030f, -0.03041193f, 0.11400282f, -0.06347350f, -0.05410745f, 0.11323886f, -0.09766018f, -0.14473638f, 
    -0.15819803f, -0.39247587f, 0.24512042f, 0.24632759f, -0.02050243f, 0.02604049f, -0.04032670f, 0.03011012f, 
    -0.03362917f, 0.00282283f, 0.04922780f, 0.19382490f, 0.24753334f, -0.18223697f, -0.05409557f, -0.16212209f, 
    0.04936528f, -0.03267265f, 0.09070462f, 0.09889397f, -0.02688328f, -0.56489712f, -0.22732197f, -0.60100985f, 
    -0.13344963f, 0.15164091f, -0.29346082f, 0.10930341f, 0.15269765f, -0.06225304f, 0.07245225f, -0.00372921f, 
    -0.06207938f, 0.05854158f, -0.11233144f, -0.03568645f, -0.32674176f, -0.21767081f, 0.19682875f, 0.05544715f, 
    0.02791962f, -0.06023674f, 0.11551142f, 0.12040848f, 0.31496781f, -0.23918018f, 0.21141060f, 0.16888571f, 
    -0.25310940f, 0.31596881f, -0.10560471f, -0.30820119f, 0.30550349f, 0.04008332f, 0.00081652f, 0.36905971f, 
    -0.04104149f, -0.06303997f, 0.01942426f, 0.03119056f, -0.32211667f, 0.20785251f, 0.12384593f, -0.27525017f, 
    -0.14575738f, -0.11194871f, 0.04128388f, 0.05687892f, -0.17659406f, 0.05346362f, -0.23107925f, -0.22705534f, 
    -0.42277944f, 0.18342599f, -0.00977027f, -0.34200746f, 0.06237991f, 0.10784748f, 0.11466001f, 0.30972999f, 
    0.19685674f, 0.09595142f, -0.02716025f, -0.08205193f, 0.38838258f, -0.21034725f, 0.13645561f, 0.29961812f, 
    0.13646489f, -0.12548786f, 0.01269849f, 0.12721850f, -0.11499214f, 0.04675939f, 0.02027384f, 0.23223123f, 
    -0.03641091f, 0.08113430f, 0.10988519f, -0.29611585f, -0.08442513f, 0.04140095f, 0.05349989f, -0.30948445f, 
    0.18319444f, 0.13196139f, 0.08943767f, -0.07961027f, 0.02122452f, 0.25709087f, 0.30454394f, -0.21717383f, 
    0.09805886f, 0.03034380f, 0.03377755f, -0.02805061f, 0.04284592f, 0.02593121f, 0.05542891f, 0.07251875f, 
    -0.55641919f, 0.10925469f, 0.04753016f, -0.35955596f, -0.03971826f, -0.24793731f, 0.01121926f, 0.19159444f, 
    -0.17652591f, -0.13538267f, -0.06923524f, -0.25668195f, -0.20561208f, -0.18758802f, 0.01626081f, 0.02203984f, 
    0.06641442f, 0.05691951f, 0.14209671f, 0.15798447f, 0.25086418f, -0.15909533f, 0.06879998f, 0.20370676f, 
    0.78163445f, -0.12883930f, -0.34558043f, -0.14588770f, 0.00300191f, -0.03632049f, -0.10850590f, -0.04080356f, 
    0.13929000f, 0.02368247f, 0.06447386f, -0.10798258f, -0.09140983f, 0.15198800f, -0.28302354f, 0.00357729f, 
    0.10932812f, 0.07991610f, 0.20065531f, 0.18097380f, 0.05855487f, -0.15035127f, 0.10596459f, 0.03128294f, 
    -0.54118812f, -0.13996357f, -0.21580848f, 0.07638125f, 0.07818707f, -0.07560806f, -0.00601003f, 0.03139095f, 
    -0.01432641f, -0.06797910f, -0.03723753f, 0.02287773f, -0.03075939f, -0.30834013f, 0.04072262f, -0.17893830f, 
    -0.15584075f, 0.08170953f, -0.16466734f, -0.10728899f, 0.21485402f, 0.09986598f, 0.01009096f, 0.20553245f, 
    -0.41778767f, 0.05663131f, 0.12702818f, 0.20840195f, 0.07105178f, -0.25372413f, -0.00255226f, 0.12774451f, 
    0.07491773f, -0.10129236f, -0.06595305f, 0.12179050f, 0.19530949f, 0.29855490f, 0.04863057f, -0.06370796f, 
    0.14715862f, 0.11552326f, -0.03986369f, -0.43850365f, -0.01526436f, -0.06613328f, -0.02038064f, 0.03830266f, 
    -0.06287736f, -0.13737541f, -0.06182282f, 0.04765415f, -0.08347057f, 0.03005102f, -0.06135556f, -0.08064582f, 
    0.42868900f, 0.02358843f, 0.01335545f, 0.18193467f, -0.03175138f, -0.23628214f, -0.36860770f, 0.36581653f, 
    0.04088502f, 0.02793006f, -0.15448716f, -0.08893202f, 0.12261306f, 0.01635537f, -0.01336387f, 0.13915135f, 
    0.33060059f, 0.10287780f, 0.31401846f, 0.07187948f, 0.01074159f, 0.22276726f, -0.00893368f, 0.10216096f, 
    0.14279664f, 0.01591244f, 0.04301248f, -0.00312427f, -0.11511578f, -0.28893438f, -0.08735949f, 0.22762077f, 
    0.03987977f, -0.08229753f, 0.01468327f, -0.08797711f, 0.05311047f, 0.11032591f, 0.00724494f, 0.13918804f, 
    0.04660020f, -0.07093415f, -0.81936878f, 0.23546985f, 0.16140027f, -0.04690593f, 0.07988746f, 0.10693216f, 
    0.14726476f, 0.00043304f, 0.19049989f, 0.10652748f, 0.03429728f, -0.28932589f, 0.36848623f, 0.12944865f, 
    -0.00127449f, 0.03042761f, -0.02056656f, 0.12470490f, 0.06332223f, 0.08934817f, -0.04258361f, 0.03721699f, 
    -0.16117981f, -0.14557810f, -0.07562117f, -0.15283357f, 0.01369316f, 0.04039751f, 0.05341570f, 0.08057686f, 
    0.04031429f, 0.06008650f, -0.13630335f, -0.02841385f, -0.13845836f, -0.18562429f, -0.20265442f, -0.18840648f, 
    0.03011351f, 0.07582802f, -0.01903974f, 0.06564108f, -0.03233475f, -0.12595002f, -0.04126459f, -0.15070073f, 
    -1.07181680f, -1.46785748f, -0.38784412f, 0.74735463f, 0.00469327f, 0.00508020f, 0.22811835f, -0.18966861f, 
    -0.03191557f, 0.10649780f, 0.04916907f, -0.01518297f, -0.08891921f, -0.05755127f, 0.05389044f, -0.04905744f, 
    -0.00411741f, 0.04404088f, -0.13483553f, 0.01478438f, -0.04075862f, -0.03899262f, -0.11211574f, -0.42772081f, 
    -0.10723037f, -0.46512219f, -0.06913903f, 0.08444811f, -0.15285118f, -0.18867238f, -0.27223793f, 0.19795066f, 
    -0.04016130f, -0.05311914f, -0.06500404f, -0.06226877f, 0.08669171f, 0.58678257f, -0.25137761f, 0.11584743f, 
    0.00933017f, -0.00006116f, 0.00268118f, 0.15906920f, -0.00031174f, 0.03355453f, 0.06972995f, 0.19534405f, 
    -0.76069242f, 0.12080953f, 0.44422472f, 0.45233542f, -0.16681042f, -0.25702375f, 0.19982956f, -0.09955374f, 
    -0.00747289f, 0.05134514f, 0.10408656f, 0.02058489f, -0.23472099f, -0.43949524f, -0.32884532f, 0.56144869f, 
    -0.06503924f, 0.41947824f, 0.31665328f, -0.10179435f, 0.01686273f, -0.17072296f, -0.00908974f, 0.07860888f, 
    0.12768099f, 0.16119473f, 0.00601672f, -0.02358110f, 0.06020977f, 0.02618331f, -0.01976893f, 0.08752056f, 
    -0.20074864f, -0.06228745f, -0.07692273f, 0.12028763f, 0.02881687f, 0.03903496f, -0.11610106f, 0.02344089f, 
    0.03186116f, -0.00494665f, 0.11993176f, 0.08719829f, 0.05852452f, 0.24876375f, 0.21117717f, 0.14303087f, 
    0.36971706f, -0.44234437f, -0.38267094f, -0.27525896f, -0.08191860f, -0.12256600f, 0.18236084f, -0.16045496f, 
    -0.03309039f, 0.09326892f, -0.14695013f, -0.06933102f, -0.34524632f, 0.17913823f, 0.53201497f, 0.12472519f, 
    -0.10763884f, -0.14233482f, 0.09582170f, 0.05544112f, -0.01834927f, 0.27752200f, 0.06391788f, -0.00759143f, 
    -0.14242560f, -0.33461928f, -0.07417339f, 0.03816618f, -0.00940475f, 0.08276330f, 0.06160796f, -0.09918924f, 
    0.07746721f, 0.06410292f, 0.00079908f, -0.04053766f, -0.08680726f, -0.02822519f, 0.11329284f, 0.11751991f, 
    0.06147983f, -0.07126410f, -0.00540408f, 0.03775034f, 0.08346126f, 0.04432761f, 0.16238834f, 0.16543593f, 
    0.21625437f, -0.02342963f, 0.07695085f, 0.12213075f, 0.15311748f, -0.10848028f, 0.04774891f, 0.03449901f, 
    -0.09490103f, -0.00022160f, 0.23919907f, -0.04455224f, -0.01613754f, 0.15113823f, -0.00151230f, 0.25994858f, 
    -0.13726784f, -0.17068596f, 0.26987770f, 0.23565520f, 0.02157708f, 0.10858805f, -0.03535894f, 0.21569367f, 
    -0.49706367f, -0.24011561f, 0.07172991f, -0.26056972f, -0.08866206f, -0.42649478f, -0.22635192f, -0.07824238f, 
    -0.07174804f, -0.05442189f, -0.00931446f, -0.11934939f, -0.42847988f, -0.79012150f, -0.64409840f, -0.14536302f, 
    -0.09201343f, -0.25379273f, -0.02924017f, -0.30319375f, -0.03919211f, 0.04177136f, -0.02728681f, -0.06582505f, 
    -0.16691546f, -0.63067186f, -0.36346900f, -0.31727841f, -0.18763806f, 0.07207139f, 0.21996523f, 0.23825461f, 
    0.05237754f, 0.11656016f, 0.01080641f, -0.09371794f, 0.18109591f, 0.27036154f, 0.01759490f, 0.05722136f, 
    0.18384294f, -0.15419573f, 0.17655814f, 0.13445598f, 0.10671753f, 0.05883303f, -0.07888721f, 0.01358589f, 
    0.54908907f, 0.12062635f, -0.26465166f, 0.26576847f, 0.01666917f, -0.11021641f, 0.14900333f, 0.05052858f, 
    0.20818827f, 0.10177287f, -0.09840033f, -0.24220404f, 0.33501157f, -0.19995603f, -0.10625731f, -0.13917857f, 
    -0.06769588f, -0.00013263f, 0.09268237f, -0.08501671f, 0.17836602f, -0.01409858f, 0.03546714f, -0.02405918f, 
    -0.01088920f, -0.28783566f, -0.27172267f, -0.23012105f, 0.02820097f, 0.11921237f, 0.07209701f, -0.00482777f, 
    -0.09574942f, 0.03896704f, -0.02246294f, -0.00108836f, 0.12504162f, 0.20879899f, -0.24394117f, 0.43238986f, 
    -0.05779124f, -0.39098218f, 0.19479993f, 0.06699400f, 0.04606810f, -0.03605529f, -0.00698263f, -0.02321847f, 
    -0.05122110f, -0.03902044f, -0.06801895f, 0.11726333f, -0.09138516f, 0.09235508f, 0.02468957f, 0.14030677f, 
    0.12170202f, -0.06518384f, 0.28883639f, -0.07627692f, -0.86304581f, -0.95208603f, -0.49481025f, -0.09340072f, 
    -0.24330956f, -0.14229199f, -0.26575041f, -0.48040241f, -0.03160399f, 0.02086408f, 0.01930477f, 0.02324745f, 
    -0.16914852f, -0.05761735f, 0.11451424f, -0.07854567f, -0.02204823f, -0.02201709f, -0.02265996f, 0.04210189f, 
    0.01787418f, -0.09860381f, -0.08530048f, 0.13547051f, 0.33338329f, 0.15482239f, 0.17380649f, -0.00572422f, 
    0.01391217f, -0.15629785f, 0.08610760f, -0.13250497f, 0.06342767f, -0.12016284f, 0.04721875f, -0.12167162f, 
    -0.61898452f, -1.04228389f, -0.88749272f, -0.27555588f, -0.10200875f, 0.04115013f, 0.20379251f, -0.15579650f, 
    0.00398701f, -0.01281036f, 0.01831872f, 0.10263386f, -0.12722118f, 0.06163556f, -0.22236475f, -0.19601932f, 
    0.05446321f, 0.03229453f, -0.00797824f, -0.06367503f, 0.03933703f, -0.01373609f, -0.02350057f, 0.00154599f, 
    0.38186786f, -0.45265612f, -0.16337167f, -0.42113483f, -0.02502766f, 0.08756007f, 0.06005184f, -0.08850799f, 
    0.02651294f, 0.00540223f, 0.08881157f, -0.07259755f, -0.03488033f, -0.35091910f, -0.34992290f, -0.08101988f, 
    -0.20891042f, -0.16512187f, -0.19240770f, 0.03165537f, -0.06476187f, -0.00923012f, 0.04264786f, -0.10352600f, 
    -0.01872512f, -0.08215541f, -0.12376684f, 0.10794635f, -0.05070800f, 0.13455741f, -0.03424093f, 0.12291750f, 
    -0.07273843f, -0.04482610f, -0.04547638f, 0.00542789f, -0.42327151f, 0.59233874f, 0.34699389f, -0.06179626f, 
    -0.10378641f, 0.02778062f, -0.11245688f, -0.07965809f, -0.05726158f, 0.00586920f, -0.09748873f, 0.12156542f, 
    0.69175279f, -1.11189568f, 1.04717195f, -0.13389224f, -0.15821186f, 0.03006164f, -0.21379945f, 0.12177005f, 
    0.12044840f, 0.04639578f, 0.01025134f, -0.00743310f, 0.20514891f, 0.09958486f, 0.04664990f, -0.16482638f, 
    -0.02487398f, -0.01365886f, -0.02815828f, -0.10764182f, -0.15999226f, -0.21208288f, -0.27078959f, -0.10376786f, 
    -0.43230346f, -0.50005555f, 0.26952425f, -0.23111087f, -0.02246270f, -0.26971447f, -0.02565926f, 0.16854540f, 
    0.04940636f, 0.01100712f, -0.02440554f, -0.00322478f, -0.05838998f, -0.09885215f, -0.29553699f, 0.04585240f, 
    -0.03469792f, 0.08670164f, 0.04771024f, -0.00486740f, -0.26860124f, 0.04421520f, -0.10148009f, 0.05857235f, 
    0.15508194f, -0.80232406f, -0.59352756f, -0.60236764f, -0.07821565f, -0.07919826f, -0.09969925f, 0.13862765f, 
    0.09222431f, 0.08905708f, -0.01267513f, 0.01576276f, 0.15144239f, -0.24523471f, 0.06980600f, -0.07479683f, 
    -0.08308381f, 0.08225226f, 0.02524001f, -0.07808562f, 0.05151701f, 0.04315170f, -0.04103394f, 0.02760568f, 
    0.28147158f, 0.09953611f, 0.05995088f, -0.22381534f, 0.02487010f, 0.05787928f, -0.00371221f, -0.03972263f, 
    -0.07333662f, 0.09713427f, -0.03044187f, -0.19829647f, 0.03112382f, -0.15882453f, 0.22082742f, -0.04050968f, 
    0.00800509f, -0.03598636f, -0.00265449f, -0.10092438f, 0.08976288f, 0.03905315f, 0.16412568f, 0.12729247f, 
    -0.48570555f, 0.00920111f, -0.05453814f, 0.40057385f, -0.18245578f, 0.03526755f, -0.19605568f, 0.07029580f, 
    0.06096648f, -0.08365861f, 0.06184127f, 0.05611105f, 0.86040115f, -0.38861877f, -0.70656735f, -0.56312197f, 
    -0.01042510f, -0.13011928f, -0.01983828f, -0.07833793f, -0.01225093f, -0.03024847f, 0.21340735f, -0.13944773f, 
    -0.20736682f, -0.20997444f, -0.17819671f, -0.11392340f, 0.27752164f, 0.08885273f, 0.22927621f, 0.02879476f, 
    0.11640619f, -0.05450802f, -0.01269868f, 0.04892190f, 0.23696913f, -0.20051010f, 0.00512274f, -0.41788626f, 
    0.10804749f, -0.07070664f, 0.12547304f, 0.02101094f, -0.05705053f, 0.09839437f, -0.00201060f, -0.27488497f, 
    -0.16603050f, -0.04495245f, 0.34204599f, -0.11078498f, -0.20747232f, -0.06986012f, -0.00898596f, 0.03912505f, 
    -0.04298819f, 0.05366496f, -0.01333947f, -0.13495131f, 0.11052174f, 0.03353684f, -0.17638853f, -0.20211256f, 
    -0.05119376f, -0.06934875f, -0.16070709f, 0.03160719f, -0.28653502f, 0.12958859f, -0.00156835f, -0.03674020f, 
    -0.10439324f, -0.27663144f, 0.42191812f, 0.02230708f, -0.01064977f, 0.02303403f, 0.11671603f, 0.17437726f, 
    -0.02473063f, 0.05804577f, 0.06287552f, 0.02978974f, -0.43415606f, -0.63102853f, 0.51330084f, -0.09989140f, 
    -0.10887609f, -0.02418859f, -0.24696964f, 0.26528370f, -0.03630395f, -0.05804237f, -0.08533344f, -0.07342421f, 
    -0.21667211f, -0.20836958f, -0.32960457f, -0.13837780f, 0.09051546f, 0.36404049f, 0.20501801f, 0.06025710f, 
    0.03651543f, -0.10758074f, -0.10513795f, 0.12568434f, 0.04825135f, -0.17045373f, 0.14461188f, -0.19691847f, 
    -0.21944322f, 0.02117183f, -0.00775763f, -0.05002655f, 0.08374248f, 0.03804724f, -0.11210077f, -0.01122182f, 
    -0.28295293f, -0.16854733f, 0.16061024f, -0.06511194f, -0.12206106f, 0.01942151f, 0.10946479f, -0.03601835f, 
    -0.04641225f, -0.00494816f, 0.00933721f, -0.11181792f, -0.29306424f, 0.21304239f, -0.11487134f, 0.17460582f, 
    -0.15282328f, -0.04521365f, -0.04137465f, -0.04580919f, -0.02352538f, -0.00954989f, 0.03093345f, -0.01590769f, 
    0.03952755f, -0.03483162f, 0.05024757f, -0.10471553f, 0.00026156f, -0.02833270f, -0.09453854f, -0.05233369f, 
    0.13509451f, 0.01636834f, 0.07021017f, -0.05914159f, -0.16468969f, -0.47305429f, -0.55566210f, -0.46766779f, 
    -0.09222035f, 0.23415154f, 0.15962549f, 0.00850558f, 0.01466076f, 0.10636046f, -0.01522538f, -0.00429935f, 
    0.37055188f, 0.05873455f, -0.29087126f, 0.01325917f, 0.00759603f, -0.03272168f, -0.19184370f, -0.13773735f, 
    -0.15752836f, -0.01645375f, -0.12138264f, 0.07914494f, -0.53838307f, -0.40364146f, -0.12569286f, 0.31378290f, 
    0.00526914f, -0.00145935f, -0.02285696f, 0.13446486f, -0.00800153f, -0.11953304f, 0.02946363f, -0.04467639f, 
    0.20428483f, 0.04166179f, -0.01311174f, -0.14875011f, -0.03095614f, 0.02591127f, 0.01227463f, -0.00871433f, 
    0.02061847f, -0.14706506f, -0.01926553f, -0.08701421f, -0.11620891f, 0.18899646f, -0.23837875f, 0.13784160f, 
    -0.03753547f, 0.06926458f, 0.15134948f, -0.02233375f, -0.21416153f, 0.08296255f, -0.02389521f, -0.16265318f, 
    -0.21062317f, -0.76271099f, 0.35923421f, 0.20792547f, -0.11944717f, -0.05358026f, -0.00272497f, -0.00112763f, 
    -0.00356978f, 0.01489983f, 0.00197624f, -0.01136532f, 0.11385002f, 0.05256825f, -0.02602305f, 0.01631572f, 
    0.07519081f, -0.01074896f, 0.02775427f, 0.00997305f, 0.05820278f, 0.08587004f, -0.05156797f, -0.01451903f, 
    -0.03507086f, 0.16499634f, 0.04781451f, -0.09685857f, -0.06813025f, 0.02463583f, -0.04376226f, 0.03739941f, 
    -0.01854274f, 0.04391543f, 0.11884798f, -0.04109143f, 0.66846412f, -0.33775952f, 0.09580439f, 0.35627660f, 
    -0.03541525f, 0.14372964f, 0.06503999f, -0.21525104f, -0.06058916f, 0.11527027f, -0.07084151f, -0.05053670f, 
    0.12915964f, 0.04156992f, 0.08947507f, -0.08881579f, -0.00351910f, -0.01230050f, -0.11217380f, -0.00912917f, 
    0.10843170f, -0.08121542f, 0.10333267f, -0.00687937f, 0.38251108f, -0.90644264f, -0.32759181f, -0.25463220f, 
    -0.07038791f, -0.04590566f, 0.06762036f, 0.28404537f, 0.24887194f, 0.05496348f, 0.02313532f, 0.16519284f, 
    0.07741272f, -0.25840127f, -0.61118394f, -0.35385659f, 0.29193643f, -0.17559080f, 0.27348769f, 0.01519116f, 
    -0.08045501f, -0.08761968f, -0.03121632f, -0.07319753f, -0.05729135f, -0.05872691f, -0.14983721f, -0.17928591f, 
    -0.03004853f, 0.03891021f, 0.07292780f, 0.01741862f, 0.12869060f, 0.13540770f, 0.07310743f, 0.17468645f, 
    0.15009843f, -0.39455822f, 0.02690353f, -0.05067522f, -0.07942882f, -0.00469111f, -0.13497019f, -0.03823078f, 
    -0.03315511f, 0.06113680f, 0.11813969f, 0.19820376f, -0.41827542f, -0.28002381f, 0.16799015f, 0.18074511f, 
    0.10731250f, 0.05072752f, 0.10437270f, -0.03809718f, 0.22549522f, 0.13176914f, -0.16293733f, 0.14210849f, 
    -0.34107766f, -0.69339621f, -0.45636752f, 0.32591230f, -0.06818373f, 0.19378334f, 0.17537288f, 0.16548930f, 
    -0.03594471f, -0.01909949f, 0.08704188f, -0.01640043f, 0.03051068f, -0.05137554f, 0.18213518f, -0.10993113f, 
    0.05627141f, 0.05098481f, 0.06779289f, -0.20183052f, -0.12592474f, -0.05107369f, -0.01873288f, -0.11845916f, 
    0.29563257f, 0.17989503f, -0.12662415f, -0.33796290f, -0.01542785f, -0.09858559f, -0.02619329f, 0.02537986f, 
    0.00277086f, -0.07469622f, 0.11196876f, -0.03157434f, -0.30340204f, 0.11139898f, 0.13319509f, 0.07901600f, 
    0.00640982f, -0.01213834f, 0.02166688f, -0.11209403f, -0.14714614f, 0.16577910f, -0.38105595f, -0.40014634f, 
    -0.09523812f, -0.05689385f, -0.19616568f, 0.15130286f, 0.17111023f, 0.04507866f, -0.04381638f, 0.16174588f, 
    0.07706834f, 0.17786245f, 0.22014782f, 0.05572009f, -0.29927894f, -0.20064849f, -0.44313562f, -0.06645948f, 
    -0.00772572f, 0.11787049f, 0.09341898f, 0.06152259f, 0.11560144f, 0.03101738f, -0.07883400f, -0.01930507f, 
    -0.09790379f, -0.19929904f, -0.13056085f, 0.17015079f, -0.18866727f, 0.21138600f, -0.00028386f, 0.01502049f, 
    -0.09662974f, -0.03389538f, -0.17863213f, -0.14450651f, 0.14421326f, -0.10712389f, -0.28493989f, -0.29968339f, 
    -0.25218424f, -0.16901058f, -0.01554446f, -0.11759684f, 0.01229383f, -0.04896078f, 0.11370870f, -0.01578440f, 
    -0.13232870f, -0.33314088f, 0.16095136f, 0.06185835f, -0.02629041f, 0.08306316f, 0.10220779f, 0.03695753f, 
    0.04691932f, -0.16771486f, 0.11933558f, 0.00737509f, 0.44312313f, 0.04276015f, -0.33011106f, 0.18390550f, 
    0.03468860f, -0.02340624f, 0.07351395f, -0.11728995f, 0.33147264f, -0.10652063f, 0.31567127f, 0.11281271f, 
    -0.35319799f, -0.40343863f, -0.27443996f, 0.02324117f, -0.06780399f, -0.14069350f, -0.11490467f, -0.02903010f, 
    0.04897495f, 0.11910292f, 0.09895391f, 0.14089881f, 0.04854714f, -0.20402709f, -0.30491945f, -0.41579375f, 
    -0.16081278f, -0.20430344f, -0.00577722f, -0.44072694f, 0.01241086f, 0.06344468f, 0.05120699f, 0.07561609f, 
    -0.13361201f, -0.39211079f, -0.11267405f, 0.07786045f, 0.02348410f, 0.26925272f, -0.08419582f, 0.03626890f, 
    -0.13013500f, -0.04914104f, -0.20408952f, -0.33385950f, 0.01850619f, -0.23327880f, -0.04183831f, 0.05026291f, 
    0.22528465f, 0.06117301f, 0.11035266f, 0.05595268f, 0.16920823f, 0.03656923f, -0.04432828f, 0.07434661f, 
    -0.66031170f, 0.14389709f, -0.02570357f, 0.24706942f, 0.12895529f, 0.11302666f, 0.00165661f, 0.03079318f, 
    -0.07358018f, 0.06343150f, -0.00799485f, 0.22713836f, -0.39662847f, -0.09375117f, 0.09397272f, 0.17736416f, 
    0.21414132f, -0.00425494f, -0.05402117f, 0.04158725f, -0.05870593f, 0.07654618f, 0.05572642f, -0.02643873f, 
    -0.21663080f, 0.27286276f, 0.08439003f, -0.00600243f, 0.01040194f, -0.14361741f, -0.08422906f, -0.07749952f, 
    -0.12518770f, 0.01782221f, -0.00051182f, 0.06060341f, -0.11671250f, -0.13276950f, -0.02313968f, 0.24661553f, 
    0.14281879f, 0.04012668f, 0.14421254f, 0.05601105f, 0.07051130f, -0.00904007f, 0.11356245f, 0.14900707f, 
    0.32465136f, 0.09655492f, 0.06441126f, -0.03398069f, 0.20091461f, 0.09657375f, -0.01566758f, 0.12037656f, 
    -0.06493983f, -0.04067493f, 0.15339303f, -0.15109047f, -0.18148281f, -0.63095683f, -0.50871575f, -0.27512467f, 
    -0.08336455f, -0.00160448f, 0.12643874f, -0.07404710f, 0.07320801f, 0.06971821f, 0.01161560f, 0.04203229f, 
    -0.08400978f, -0.11781558f, -0.09927843f, -0.13418496f, -0.11086966f, -0.05204050f, 0.00359053f, 0.07470603f, 
    0.12809132f, 0.25208750f, 0.07396584f, 0.16145618f, -0.49581081f, -0.00035573f, 0.25989407f, 0.12011701f, 
    -0.08136483f, 0.09448736f, -0.02315103f, 0.21250348f, -0.12314508f, -0.08348276f, 0.33012259f, 0.03616048f, 
    0.57112497f, 0.20357779f, 0.23514107f, -0.22703801f, 0.20665242f, -0.16609554f, -0.06624070f, -0.36158761f, 
    -0.00730108f, 0.08291455f, -0.01905720f, 0.05388178f, -0.14522924f, 0.15993661f, 0.12152904f, -0.01110694f, 
    -0.10662486f, -0.15858151f, -0.12876721f, -0.04359384f, -0.02346714f, 0.07197510f, 0.04888546f, 0.13273871f, 
    -0.55342621f, -0.09987978f, 0.03903371f, 0.16578348f, 0.06281061f, -0.13247781f, -0.16930790f, 0.08618999f, 
    -0.02425569f, 0.02033709f, -0.01916071f, -0.02775605f, 0.61399591f, 0.03759372f, -0.45757934f, -0.54088736f, 
    0.23811328f, -0.11209921f, -0.03038899f, 0.03701514f, 0.10133594f, 0.08856488f, 0.23082745f, 0.22383100f, 
    -0.28391352f, 0.08910082f, 0.10244709f, -0.17892678f, -0.04906347f, -0.04399161f, -0.10066463f, 0.00691107f, 
    -0.09635783f, -0.05786458f, -0.08312003f, -0.05069109f, -0.12441045f, -0.15609095f, -0.32758248f, 0.03602085f, 
    -0.07172993f, 0.15086596f, 0.07833416f, 0.17384143f, -0.20656092f, -0.13224852f, -0.14946750f, -0.25624478f, 
    -0.35735500f, -0.43962148f, 0.10826981f, -0.62083811f, -0.57373393f, -0.05568067f, -0.03281051f, -0.11433446f, 
    0.00559397f, -0.01351351f, -0.00548683f, 0.07211268f, -0.00295946f, -0.01412625f, 0.13216472f, 0.36291084f, 
    0.11231929f, 0.04982613f, -0.05573627f, -0.04875869f, 0.30213246f, 0.10277397f, -0.02007963f, -0.14302486f, 
    -0.08918200f, -0.27023128f, -0.01662863f, -0.28821772f, -0.03853934f, 0.12441963f, -0.02355780f, 0.12507018f, 
    0.00123618f, -0.08892176f, 0.06010562f, -0.03251593f, 0.15829754f, -0.18423767f, 0.30384934f, -0.22263597f, 
    0.18538190f, -0.10229430f, -0.14099237f, -0.15709028f, -0.06421275f, -0.11721084f, -0.02786990f, 0.15044196f, 
    -0.00192486f, 0.01088004f, -0.09314267f, -0.29537293f, -0.12476049f, -0.13903286f, 0.01443478f, 0.10623570f, 
    0.07732677f, -0.00105540f, 0.13533171f, 0.07700431f, 0.54673576f, -0.24202539f, -0.26897129f, -0.48170173f, 
    0.10232143f, 0.08870279f, 0.02474316f, 0.11685711f, 0.08080895f, -0.05794389f, -0.03572405f, -0.03351884f, 
    -0.21952544f, -0.31443322f, -0.06688446f, 0.28962690f, 0.04516639f, 0.04639640f, 0.06546232f, -0.12312543f, 
    -0.04767662f, -0.05493230f, -0.06844193f, -0.00964278f, 0.14801064f, -0.35821277f, 0.14477476f, -0.10123862f, 
    -0.00472592f, 0.05870121f, 0.07730825f, 0.05719584f, 0.17004414f, 0.14892216f, 0.27594745f, 0.18052623f, 
    -0.04083052f, 0.77280098f, -0.48310870f, -0.15399535f, -0.16124108f, -0.14546588f, 0.13587862f, 0.14455776f, 
    0.16971178f, -0.10396352f, -0.08707953f, 0.00848395f, 0.20030065f, 0.23405708f, 0.33681685f, 0.19730270f, 
    0.18121165f, -0.29461232f, -0.26922917f, -0.09528781f, -0.21097086f, 0.02625770f, 0.01299977f, -0.01093978f, 
    -0.30659193f, 0.11137721f, 0.39037004f, -0.65371215f, -0.09136344f, 0.08027395f, 0.05887814f, -0.15216047f, 
    0.09021474f, 0.08513675f, 0.02654723f, 0.06687474f, 0.03327958f, -0.38939419f, 0.30110303f, 0.23659833f, 
    0.00143734f, -0.05589259f, -0.13099003f, 0.08663790f, -0.07299794f, 0.04757165f, 0.07323222f, 0.01620685f, 
    0.42669490f, -0.40318850f, 0.39792880f, -0.51959950f, -0.08961490f, -0.08959704f, -0.12660554f, 0.10702892f, 
    -0.05220710f, 0.01696385f, -0.05352820f, 0.08260554f, 0.02375651f, -0.39177793f, -0.03714876f, -0.08516166f, 
    0.11340301f, 0.05650786f, 0.03740724f, -0.01923480f, -0.19613911f, -0.02398638f, 0.05243818f, -0.02356891f, 
    0.18544821f, -0.08268277f, -0.06647731f, -0.22177358f, -0.04887184f, -0.04408486f, -0.06888229f, 0.29612795f, 
    -0.09404761f, -0.02115907f, -0.07137711f, -0.03721533f, -0.24098794f, -0.18318629f, 0.27740052f, -0.14799707f, 
    -0.29945081f, 0.06178524f, -0.10534949f, 0.21097197f, 0.04776139f, 0.08512288f, -0.00373556f, 0.00559680f, 
    -0.01931860f, 0.21115692f, -0.01942709f, -0.02504475f, 0.04202340f, 0.02126086f, 0.09890782f, -0.26174694f, 
    0.17632890f, 0.09744444f, 0.07308115f, 0.05532827f, 0.43110719f, 0.01902338f, 0.42615753f, -0.28997704f, 
    -0.00803179f, -0.39304519f, -0.12947929f, -0.24881124f, 0.03988662f, 0.03147269f, -0.17418882f, 0.03397980f, 
    -0.30276617f, 0.29539615f, 0.44243485f, -0.62072176f, 0.00180239f, -0.09327864f, 0.08097075f, -0.26664028f, 
    0.01689399f, 0.12560402f, -0.13718010f, 0.11630888f, -0.00402207f, 0.64276111f, -0.59199417f, -0.05901201f, 
    -0.05352608f, -0.01162969f, 0.03275244f, 0.02980416f, 0.05532858f, -0.00753125f, -0.06823473f, -0.10828964f, 
    -0.18549456f, -0.34921199f, -0.55018359f, 0.17326955f, 0.12320191f, 0.13745828f, 0.17554505f, 0.02090744f, 
    0.05333521f, -0.09274766f, -0.03929787f, -0.04550389f, 0.39574537f, -0.10087988f, 0.30422467f, -0.44475320f, 
    0.18606611f, -0.40570709f, 0.08290263f, -0.05954726f, -0.21462803f, -0.01841084f, 0.04423650f, -0.00762321f, 
    -0.28334594f, 0.22330996f, -0.14305998f, 0.17722911f, 0.14900289f, 0.06554756f, -0.18943940f, -0.13767396f, 
    0.13707460f, -0.02721941f, 0.14820129f, 0.13673598f, -0.06990522f, 0.07771831f, 0.12490966f, -0.21845610f, 
    -0.07419451f, -0.10667673f, 0.12401184f, 0.42246422f, -0.03106362f, 0.07734852f, 0.07879351f, 0.00729676f, 
    -0.04958810f, -0.02137347f, 0.15454830f, 0.20060527f, -0.02133902f, 0.03067016f, -0.17744012f, -0.06280380f, 
    0.02267134f, -0.12103579f, 0.12388919f, 0.05275805f, -0.57856703f, 0.34183490f, -0.29135418f, -0.43628362f, 
    -0.00687848f, -0.01471657f, 0.24667999f, 0.03124311f, 0.15786760f, -0.02516591f, -0.01461297f, 0.01123073f, 
    0.01011214f, -0.33056825f, -0.87169331f, 0.26802945f, 0.12752211f, 0.10073846f, 0.17814501f, -0.03677240f, 
    -0.01787324f, 0.04409494f, -0.01301129f, -0.11896665f, -0.11555639f, -0.20838936f, -0.11225872f, 0.15128426f, 
    0.13462493f, 0.03181269f, 0.04541477f, 0.02922652f, 0.13850796f, 0.02399354f, -0.09825257f, -0.10604762f, 
    -0.04217478f, -0.27890915f, -0.60068762f, 0.15865830f, -0.14114346f, 0.15481207f, -0.04969599f, 0.11092233f, 
    0.02435415f, -0.04703065f, -0.10481063f, 0.07377607f, -0.39555335f, 0.20346473f, -0.43243641f, 0.40169206f, 
    0.06851982f, -0.04778653f, -0.10311167f, 0.02029932f, 0.03737960f, -0.19380873f, -0.06741008f, -0.08934283f, 
    0.15701690f, -0.47454637f, -0.10060649f, -0.06802388f, -0.00698395f, 0.09470282f, 0.04370360f, -0.10473290f, 
    -0.05877633f, -0.17411694f, 0.11554860f, -0.11578745f, 0.12934411f, 0.26521543f, 0.65552503f, -0.14110668f, 
    -0.04569050f, -0.22945593f, -0.25191751f, -0.30967841f, -0.02858417f, 0.04842055f, 0.10336784f, 0.12776214f, 
    -0.55100185f, 0.20099773f, -0.15037037f, -0.08647564f, -0.01042716f, 0.31865713f, 0.12870923f, 0.18894574f, 
    -0.15656163f, 0.16403879f, -0.02826960f, 0.02352034f, -0.29405239f, 0.11232446f, -0.42195830f, -0.29090238f, 
    -0.03247311f, 0.00807605f, -0.04975295f, -0.23918775f, 0.05196014f, 0.05299466f, 0.03571227f, 0.02900691f, 
    -0.06710053f, -0.06459787f, 0.10004018f, 0.14992587f, -0.11811275f, 0.03738502f, 0.10012287f, -0.01041840f, 
    -0.02755327f, 0.25494483f, -0.01719645f, 0.05786660f, -0.28507248f, 0.42308304f, -0.01296348f, 0.36268356f, 
    0.07644013f, 0.20060422f, -0.38211998f, 0.39304766f, 0.00614161f, -0.13337533f, 0.05837138f, 0.15280014f, 
    0.27690342f, -0.39379272f, 0.34650293f, -0.14125854f, -0.07416288f, 0.09073645f, -0.01984049f, -0.01334652f, 
    -0.08173755f, 0.17598666f, 0.01996463f, -0.41663626f, -0.49637142f, 0.04586588f, -0.20209222f, -0.20520858f, 
    -0.19381687f, 0.16760460f, -0.02218143f, -0.16989763f, -0.02095836f, -0.02662249f, -0.11285420f, -0.05854192f, 
    -0.25726348f, 0.47738859f, -0.05300570f, 0.03971130f, -0.19458076f, -0.00689987f, 0.06292436f, -0.17146419f, 
    0.25602528f, -0.02321261f, -0.14055388f, -0.08411401f, -0.24628225f, 0.47181201f, 0.00935015f, -0.05604650f, 
    0.00099260f, 0.04100911f, -0.03609970f, -0.09115274f, -0.15545613f, -0.33316574f, -0.21330084f, -0.42164305f, 
    -0.01537949f, -0.52198642f, 0.21992922f, 0.00456594f, -0.09690186f, 0.05541318f, 0.17061597f, -0.16732678f, 
    0.00643420f, 0.26635224f, 0.08333773f, 0.16876429f, 0.03107867f, 0.14544286f, 0.29713991f, -0.12866333f, 
    -0.06001704f, -0.12502699f, 0.06231387f, -0.00958052f, -0.03782781f, -0.19646288f, 0.09836937f, 0.03569655f, 
    0.18584996f, -0.48283008f, 0.18874802f, -0.07395554f, 0.02925196f, -0.14086759f, -0.06125063f, 0.02896498f, 
    -0.25727645f, 0.02056867f, 0.00128595f, -0.03542666f, -0.65001851f, 0.33289319f, -0.29100180f, 0.23725101f, 
    -0.01156315f, 0.07761803f, -0.04631209f, 0.04851206f, 0.11902469f, -0.20468886f, -0.00329740f, 0.07018837f, 
    -0.07234806f, 0.48084512f, 0.31473747f, 0.36679727f, -0.02596468f, -0.05874478f, -0.01913453f, -0.02089084f, 
    -0.19938831f, 0.16780496f, 0.08282913f, -0.12026188f, -0.57047319f, 0.19827639f, 0.58990872f, 0.12930018f, 
    0.10922378f, 0.04012041f, -0.43282160f, -0.09590056f, 0.07769498f, -0.13554506f, 0.06122943f, -0.27480093f, 
    -0.10021735f, 0.29009476f, 0.21059150f, 0.13277739f, -0.08182391f, 0.04872854f, 0.09041729f, -0.08766703f, 
    0.00708848f, 0.22877604f, 0.36381379f, 0.24864432f, -0.10206901f, -0.42737576f, -0.38783079f, 0.11087849f, 
    0.00471743f, -0.06615411f, 0.11043391f, 0.05089935f, 0.11473357f, -0.00844698f, 0.01377766f, -0.00960444f, 
    0.13026230f, -0.06330634f, -0.17593077f, -0.06951652f, 0.05015605f, -0.34217438f, -0.21788716f, -0.02944415f, 
    -0.03204626f, 0.04441893f, -0.31289765f, -0.41375074f, -0.21798135f, 0.12991279f, -0.38345450f, 0.38730991f, 
    -0.02619698f, 0.03426254f, 0.02325636f, -0.06391534f, 0.12341455f, -0.14883430f, 0.05953740f, -0.01461694f, 
    -0.00254032f, 0.18387847f, -0.20535743f, 0.16154060f, -0.28324127f, -0.09781682f, 0.24284521f, 0.04860044f, 
    -0.02036960f, 0.02081187f, -0.14215206f, 0.05156985f, -0.07861620f, -0.52412879f, 0.18882367f, 0.24073924f, 
    0.02293411f, -0.05707995f, 0.01696562f, -0.20646219f, -0.16912912f, -0.04163440f, -0.09872525f, 0.26527137f, 
    -0.15878062f, -0.06410976f, -0.65306938f, -0.16481340f, -0.37140870f, -0.10261051f, 0.05703715f, 0.11210246f, 
    -0.21361755f, 0.20080045f, -0.01026780f, 0.10897644f, 0.14339285f, 0.11705150f, -0.06393150f, -0.01615593f, 
    -0.13129273f, 0.07754511f, 0.18193915f, 0.02301519f, 0.34453368f, -0.03034026f, 0.04870027f, 0.01644426f, 
    0.22593072f, -0.10520676f, 0.12775068f, -0.28807390f, -0.25410506f, 0.18456987f, 0.09949323f, 0.15446542f, 
    -0.01359590f, 0.11420494f, -0.39967233f, -0.19600879f, -0.22388701f, -0.23288892f, -0.26841372f, 0.15980455f, 
    -0.02233860f, -0.05509398f, -0.05062273f, 0.07260180f, 0.09222227f, 0.17906763f, -0.09776741f, -0.06407538f, 
    0.26736632f, -0.12643656f, -0.15012723f, -0.12305325f, -0.02886478f, -0.02440768f, 0.25224909f, -0.05920586f, 
    -0.13913292f, 0.18721330f, -0.03878970f, -0.03714577f, 0.18946582f, -0.13606773f, 0.49785060f, 0.04411047f, 
    -0.12511916f, 0.11986605f, 0.27156508f, 0.03714182f, 0.09456888f, 0.02001619f, 0.10066822f, -0.06675241f, 
    -0.22700755f, 0.40328225f, -0.63608372f, 0.08637678f, -0.03846709f, 0.32701355f, 0.34167218f, -0.07810883f, 
    -0.10065567f, 0.17104246f, -0.18015319f, -0.00215183f, -0.41038299f, 0.22994678f, -0.09546089f, -0.27660972f, 
    -0.34205931f, -0.32929865f, 0.13029712f, 0.22059590f, 0.12127624f, -0.07980086f, 0.09811741f, 0.17325746f, 
    -0.04970947f, -0.07414751f, 0.23016645f, 0.03060781f, -0.09451686f, -0.01384069f, 0.11561090f, -0.09025218f, 
    -0.18740541f, 0.12696816f, 0.06050523f, 0.05420308f, -0.58313179f, 0.44327301f, -0.17033923f, -0.05641508f, 
    -0.08980957f, 0.05955093f, 0.11785363f, -0.01440870f, -0.08389264f, 0.11523612f, -0.07374834f, 0.06894416f, 
    -0.20395738f, -0.00403509f, -0.35819355f, 0.00736468f, -0.39460868f, -0.15563226f, 0.14065242f, -0.20609902f, 
    -0.01490472f, 0.00068909f, -0.29076096f, -0.00104441f, -0.11353798f, -0.15453655f, 0.06749782f, 0.01914788f, 
    0.04413996f, -0.04347762f, -0.16917588f, 0.03138899f, -0.03460271f, -0.13997845f, -0.31193233f, -0.32005367f, 
    -0.13637519f, -0.10232702f, -0.57433939f, 0.33908561f, 0.14170960f, -0.50296301f, 0.12847316f, -0.14390901f, 
    0.09107095f, 0.07670949f, -0.01314723f, 0.10873105f, -0.31597593f, 0.00028095f, -0.07161614f, 0.05525171f, 
    -0.05138155f, 0.04024907f, -0.00795081f, 0.09772085f, 0.07140248f, 0.09410322f, 0.14396839f, -0.09525140f, 
    0.02353022f, 0.22061257f, -0.15036958f, 0.14293435f, 0.12605603f, 0.02611987f, -0.12762712f, -0.09133898f, 
    -0.03074566f, -0.00992097f, -0.10278194f, -0.09491061f, -0.49488091f, -0.23044860f, 0.24852589f, 0.09515458f, 
    -0.12255232f, -0.16269033f, 0.07269513f, 0.28409725f, -0.21353275f, -0.06502660f, -0.04518096f, -0.20344031f, 
    -0.19026998f, 0.13292570f, 0.00531880f, -0.61445117f, -0.05469555f, -0.05507233f, 0.04001440f, 0.05238767f, 
    -0.08548864f, -0.02882781f, -0.02028961f, 0.00447742f, 0.20379214f, 0.49214643f, 0.15397820f, -0.03612407f, 
    0.24366175f, -0.31071356f, 0.11196120f, 0.15679988f, 0.17088738f, 0.00676144f, 0.15772976f, 0.04128003f, 
    0.18270814f, -0.44608852f, -0.00032578f, 0.31254488f, 0.09060010f, -0.12892500f, 0.00434884f, -0.01851471f, 
    0.02837430f, 0.21040988f, -0.12924199f, 0.10870776f, -0.13887136f, 0.24159177f, -0.07323206f, 0.15685083f, 
    -0.00378406f, 0.01458122f, 0.09551938f, 0.20707914f, 0.15397143f, 0.21275257f, 0.10600484f, 0.01781559f, 
    0.23798536f, -0.10236136f, 0.47171357f, -0.14419208f, 0.20101213f, 0.04170014f, 0.13722526f, 0.02526348f, 
    -0.23313771f, -0.00240433f, -0.01129484f, 0.01438677f, -0.40583247f, -0.00785103f, -0.39437428f, 0.41514269f, 
    0.19718097f, -0.00159372f, -0.06993061f, 0.08367139f, -0.15510732f, 0.22450535f, 0.00826922f, -0.16931944f, 
    -0.04468129f, 0.17087923f, 0.11467514f, -0.11559826f, -0.01377917f, 0.03567362f, 0.10317907f, -0.09013242f, 
    0.09165783f, 0.09446374f, 0.00036772f, 0.01397978f, -1.05769444f, 0.03846827f, -0.50011593f, 0.34936479f, 
    0.10541909f, 0.13852961f, 0.09414303f, 0.02590299f, -0.11892153f, -0.02308539f, 0.16307855f, 0.11726399f, 
    -0.53505546f, 0.49994811f, -0.34750724f, 0.38799310f, 0.02213765f, -0.06960077f, 0.13346988f, 0.19087808f, 
    -0.14821959f, 0.03173804f, -0.16333304f, 0.16134085f, -0.03419011f, -0.07940485f, 0.24276990f, -0.11374692f, 
    0.14291961f, 0.03111460f, 0.05823857f, 0.05502536f, -0.13720208f, 0.27710190f, -0.10254301f, 0.11655996f, 
    -0.28483942f, -0.09233592f, -0.11834173f, 0.05196518f, -0.00850979f, -0.07755702f, -0.23902212f, -0.00346505f, 
    0.03096795f, -0.11139600f, -0.31287360f, -0.18255697f, -0.11500535f, -0.32864553f, -0.43438333f, 0.10416610f, 
    -0.26482335f, -0.19834609f, 0.05381088f, -0.31041014f, -0.02187886f, 0.01146119f, -0.06022283f, -0.03447762f, 
    0.14442873f, 0.23010339f, -0.20398030f, -0.41543406f, -0.15972206f, -0.11096290f, 0.29179373f, 0.03782275f, 
    0.00056333f, 0.11327783f, 0.15856972f, 0.04787388f, -0.23591590f, 0.03003241f, 0.28148887f, 0.31972557f, 
    -0.09750063f, 0.01849037f, -0.00597096f, 0.13403918f, -0.06451274f, -0.04691271f, 0.01366301f, -0.24927936f, 
    0.20067996f, -0.43020865f, 0.39174712f, 0.11005042f, 0.06142297f, 0.11800903f, 0.00210200f, 0.27393153f, 
    -0.18922536f, 0.02569577f, 0.15512162f, -0.08203013f, 0.31994849f, 0.09274565f, 0.37563282f, -0.21585366f, 
    0.08458431f, 0.12859006f, 0.00623881f, -0.10769931f, -0.02873316f, -0.00196145f, -0.02204715f, 0.03348783f, 
    0.53433341f, 0.23897855f, 0.42309621f, -0.17400879f, -0.10926536f, 0.09775566f, -0.00421423f, 0.08661123f, 
    -0.17295939f, -0.11241335f, -0.13774660f, -0.13563597f, -0.09366731f, -0.18410356f, -0.12105256f, -0.32485682f, 
    0.19692501f, -0.11465683f, -0.04822404f, 0.05640032f, -0.38327041f, -0.10231222f, -0.10750546f, -0.05186836f, 
    0.21704929f, -0.37074280f, 0.28878096f, -0.23108800f, 0.12149750f, -0.06811666f, 0.17447849f, -0.01678551f, 
    0.22232282f, 0.06572019f, 0.25836897f, 0.17862374f, -0.32994974f, -0.47185194f, 0.10109984f, -0.07861702f, 
    -0.24376424f, -0.17586975f, -0.15023197f, -0.21509780f, 0.01834808f, 0.02760474f, -0.05213610f, -0.03640188f, 
    -0.26220763f, 0.04528672f, -0.15096214f, 0.08163966f, -0.07704430f, 0.03719503f, 0.04952054f, -0.06345239f, 
    -0.00449169f, -0.06843331f, -0.01722154f, -0.20598671f, 0.09444881f, -0.40286872f, 0.44980198f, -0.23833016f, 
    -0.04651073f, 0.09472056f, -0.00492779f, 0.06363516f, -0.14134040f, 0.01504641f, 0.00520223f, 0.17879795f, 
    0.10054456f, -0.28182793f, 0.39842781f, 0.09295027f, -0.08994481f, -0.28143504f, -0.18573411f, 0.06770457f, 
    -0.04444383f, 0.01478172f, 0.13681704f, -0.02815648f, 0.07038296f, -0.08638813f, 0.20129171f, -0.19900714f, 
    -0.05704371f, 0.07045411f, -0.04781013f, -0.09684493f, -0.06855757f, -0.25243142f, 0.06866185f, -0.32871532f, 
    0.16225858f, 0.53084302f, 0.17569013f, 0.11739593f, -0.13313347f, 0.09366097f, 0.21343189f, -0.14479239f, 
    0.01932097f, 0.00403282f, -0.09508961f, -0.01773535f, -0.18074171f, -0.49809808f, 0.05439803f, 0.00278967f, 
    0.20724763f, -0.13145207f, 0.21396515f, -0.08417467f, -0.03912340f, 0.07457807f, 0.23959197f, -0.14576662f, 
    0.30839169f, 0.22685742f, -0.02474722f, 0.00123992f, -0.10413822f, 0.08933268f, -0.01147203f, 0.05079782f, 
    -0.03772067f, 0.11988813f, 0.04900521f, -0.13032524f, -0.32828835f, -0.26531193f, -0.19283369f, -0.27984136f, 
    -0.07498838f, -0.13592958f, -0.02953568f, 0.01807553f, -0.01272134f, 0.06508920f, 0.05720436f, -0.10010584f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.19921637f, 0.10658232f, 0.09851921f, -0.13476132f, -0.14060669f, 0.04587673f, 0.05258345f, -0.12967217f, 
    0.05214668f, 0.07950877f, 0.05065066f, 0.00101838f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
