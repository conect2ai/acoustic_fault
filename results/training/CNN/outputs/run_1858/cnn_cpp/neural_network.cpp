#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.15895593f, 0.63580471f, 0.00005950f, 0.48519945f, -0.59065300f, -0.43878543f, -0.56622100f, -0.12615117f, 
    0.06887243f, -0.53488135f, 0.05463002f, 0.11386299f, 0.66313255f, -0.48110279f, -0.43664593f, -0.17694391f, 
    0.25600743f, 0.35654059f, 0.06142213f, -0.10132935f, 0.03859576f, 0.02484008f, 0.06941371f, 0.16228765f, 
    0.06973253f, 1.82350278f, 0.11715012f, -1.00575912f, -0.99496001f, -1.34109938f, 0.52537447f, 0.43344632f, 
    0.33602944f, 0.17202179f, -0.01629366f, -0.04731888f, 0.03984756f, -0.15758280f, 0.11132939f, -0.07555448f, 
    -0.14349677f, 0.06292588f, 0.23933002f, -0.15916482f, -0.22324845f, 0.14963685f, -0.06909472f, -0.05954927f, 
    0.20445409f, 0.00904207f, -1.25690556f, -0.75027722f, 0.08862526f, 1.04551494f, 1.07986116f, 0.60823178f, 
    -0.15900993f, -1.41007531f, -0.92473501f, 0.58125681f, -0.65108323f, -0.56887460f, -0.55535799f, -0.32938579f, 
    0.29528230f, -0.11982598f, -0.47077528f, 0.35581067f, 0.51166630f, 0.19877620f, 0.28945872f, -0.42952105f, 
    -0.19587979f, -0.26980036f, -0.30638492f, 0.60999388f, 0.84019589f, 0.51922524f, 0.21915087f, 0.26863566f, 
    0.37499028f, -0.17255603f, -0.36837205f, -0.18792114f, 0.17966874f, 0.12632586f, -0.05505073f, -0.01916812f, 
    -0.26794091f, -0.11261997f, -0.16706288f, -0.29095644f, -0.13664967f, 0.32654077f, -0.07101528f, 0.01560231f, 
    0.13623038f, -0.15887098f, -0.25947174f, 0.02577511f, -1.90245938f, -1.31229544f, 0.01149522f, 0.97317910f, 
    0.10952585f, 1.30795264f, 0.24606456f, 0.00000419f, 0.30417797f, -0.03861260f, -0.22955671f, -0.20995283f, 
    -0.09028637f, 0.60417944f, -0.44380420f, 0.05534771f, 0.30881959f, -0.08308678f, -0.17292611f, 0.11318492f, 
    0.11833346f, -0.26290748f, 0.13774155f, 0.28786489f, -0.05824823f, -1.69918633f, -0.23918197f, -0.67748511f, 
    -0.70838237f, -0.75264859f, 0.87212461f, 0.78340095f, 0.38223767f, 0.05485196f, 0.47986594f, 0.77548939f, 
    0.04701159f, -0.16239211f, -0.16937655f, -0.04013579f, 0.05488504f, 0.02761072f, -0.31292918f, -0.19315635f, 
    -0.22615515f, -0.13773650f, -0.10169656f, -0.15462756f, 0.03931608f, -0.43463174f, 0.88875252f, 1.34648204f, 
    1.21266150f, -0.74843150f, -0.87361580f, -1.24649370f, -0.39447916f, -0.56397980f, -0.90934658f, -0.98566079f, 
    0.16039620f, -0.24418327f, -0.34049478f, 0.45439807f, 0.13987081f, 0.01319138f, -0.27976257f, -0.06240908f, 
    -0.38090244f, 0.29604232f, -0.12267940f, 0.06856586f, -0.13286228f, -0.31999224f, -0.11437211f, -1.03053117f, 
    -0.96937805f, -0.83790553f, -0.71407825f, -0.73870873f, 0.41788718f, -0.11344878f, -0.54365057f, -0.56115741f, 
    -0.10052104f, -0.27569917f, -0.49374655f, -0.22794104f, 0.40742970f, 0.20916884f, -0.20267271f, -0.13390437f, 
    -0.16258787f, -0.31518611f, -0.47852638f, -0.35727078f, -0.29391167f, 0.14906877f, 0.04192962f, -0.17515348f, 
    -1.09913528f, -0.17780450f, 0.24123052f, 0.45486063f, 0.28353059f, -0.49300063f, -0.57006216f, 0.29963377f, 
    0.57028723f, 0.42474172f, -0.43274412f, 0.21685046f, -0.15456858f, 0.24311499f, 0.12422554f, 0.43356672f, 
    -0.01789595f, -0.37645835f, -0.71366525f, -0.04388415f, -0.18171135f, 0.29479927f, -0.02728011f, -0.14818069f, 
    0.28818274f, -0.22245188f, -0.94170016f, -0.58664078f, -0.22168170f, 0.48557866f, -0.19335781f, -0.05631731f, 
    0.10274725f, 0.34596550f, 0.18312813f, -0.07715305f, -0.00388530f, 0.38891566f, 0.06259664f, 0.26320311f, 
    -0.47521207f, -0.28639093f, -0.26952535f, -0.28876624f, 0.00963900f, 0.33521810f, 0.11750603f, 0.64019823f, 
    0.43502712f, 0.25105953f, -1.08473766f, 0.21070118f, -0.73932105f, 0.15371549f, 0.11771543f, -0.22997008f, 
    0.98822492f, -0.03119899f, -0.49966899f, -0.34680906f, -0.01119255f, 0.36722982f, 0.09323511f, -0.42036572f, 
    -0.07692857f, -0.23773836f, 0.22896171f, 0.31259471f, 0.04079847f, 0.18109973f, -0.07902146f, -0.19185832f, 
    -0.10243113f, 0.03566099f, 0.09172864f, -0.98177463f, -0.49840355f, 1.00836611f, 0.06426638f, -0.65044302f, 
    0.05488992f, -0.37942737f, -0.74790007f, 0.16421632f, 0.13792737f, 0.28582072f, -0.45961919f, -0.22754161f, 
    0.84597129f, -0.24582860f, -0.20643291f, -0.04641180f, -0.38102293f, -0.53627288f, -0.71961951f, -0.12835307f, 
    0.08098282f, -0.03727221f, -0.08933444f, -0.48660836f, 0.96454203f, -0.86584163f, -0.10430858f, 0.20248725f, 
    0.02123003f, -0.17126571f, -0.00563697f, 0.05577641f, 0.26009324f, -0.00665690f, -0.34688601f, -0.49427706f, 
    -0.29754108f, -0.31139210f, 0.38220084f, 0.01188330f, 0.31183869f, -0.00397141f, 0.00210035f, -0.37924442f, 
    -0.66924685f, -0.47979805f, -0.50838119f, -0.90217227f, -1.05354667f, 0.42109162f, 0.33787251f, 0.35094464f, 
    0.39380378f, 0.12968303f, -0.00721022f, 0.50880522f, 0.49824479f, 0.40129429f, -0.08624867f, -0.02497934f, 
    0.46459648f, -0.04125838f, -0.21317202f, -0.32396823f, -0.28492996f, 0.07230466f, -0.35742480f, -0.46665636f, 
    -0.46726379f, -0.14074327f, -0.05923855f, 0.16961707f, -0.15114844f, 0.08729728f, -0.31281477f, -0.54124087f, 
    -0.40548262f, -0.28391063f, -1.16714621f, -0.55859607f, -0.66557908f, -0.59986347f, -0.70211083f, -0.64214069f, 
    -0.62007564f, -0.23063815f, 0.55510348f, -0.71111512f, -0.02471390f, -0.13185763f, -0.21378942f, -0.16560106f, 
    0.05213711f, 0.08419675f, -0.02008680f, 0.46260750f, -0.38016155f, -0.24345957f, 0.28089759f, -0.80286509f, 
    -0.64705867f, -0.45249599f, -0.01946973f, -0.01546273f, -1.05308294f, -0.82588935f, -0.47701222f, -0.94146740f, 
    -0.57451999f, 0.89146864f, -0.32504022f, 0.62974507f, -0.47462788f, -0.31971374f, 0.21694541f, 0.37106699f, 
    0.32711729f, 0.09417222f, 0.24431607f, 0.11636865f, -0.41693488f, 0.17807919f, 0.07595395f, 0.08295596f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.60815859f, 0.75421071f, 0.70667613f, 0.35670143f, 0.29702103f, 0.25019461f, 0.20547155f, -0.32009384f, 
    0.75837106f, 0.46088204f, 0.66561007f, 0.35142964f, -0.08978325f, 0.02286655f, -0.36168969f, 0.49374777f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.16176872f, -0.24343055f, -0.18640114f, -0.11753108f, 0.09463932f, -0.00333282f, -0.44140646f, -0.16691181f, 
    -0.08309434f, 0.12515311f, -0.06116686f, 0.05894651f, -0.51517749f, -1.09144890f, -1.21658826f, 0.23543094f, 
    0.01832623f, -0.01892874f, -0.25219420f, -0.08810376f, -0.23516980f, -0.18140592f, -0.15178731f, -0.11903115f, 
    0.56582099f, 0.46244222f, -0.08449131f, -0.21529575f, -0.03414545f, -0.24124995f, 0.07741179f, -0.05250099f, 
    -0.08303379f, -0.01934295f, -0.11171504f, -0.03704504f, -0.40934244f, -0.66411650f, -0.48334184f, 0.43964258f, 
    0.11388770f, 0.02333562f, 0.05694843f, 0.09094426f, -0.03405209f, -0.08168884f, 0.06304926f, 0.06028271f, 
    0.70024008f, -0.15926161f, 0.15287253f, -0.26039422f, -0.02603315f, 0.02368279f, 0.12774917f, -0.01721194f, 
    -0.01615383f, 0.10247284f, -0.17247181f, -0.30556569f, 0.14813109f, 0.02837412f, -0.11902895f, -0.07582980f, 
    0.17344563f, 0.19151165f, -0.03907154f, 0.02148066f, -0.04128464f, 0.07239910f, -0.12734134f, -0.03505784f, 
    0.08705964f, -0.13191992f, -0.20269872f, -0.22855501f, 0.00005280f, 0.11411311f, -0.16429465f, -0.01106432f, 
    0.02252314f, 0.09565712f, 0.05239830f, 0.00027808f, 0.56970352f, 0.21447136f, -0.01330100f, -0.20226792f, 
    0.15401430f, 0.31018600f, -0.09504178f, -0.17471598f, -0.28029191f, -0.11903381f, 0.07900725f, -0.03641985f, 
    -0.74854839f, -0.23207729f, 0.55038148f, -0.58633167f, -0.23550656f, -0.09868396f, 0.10944789f, -0.10030197f, 
    0.03247897f, -0.12355434f, -0.26851478f, -0.36222339f, 0.04401122f, 0.30616361f, -0.02703825f, -0.07108886f, 
    0.06429774f, 0.13737042f, 0.04981657f, -0.46900359f, -0.21740273f, -0.18892463f, -0.05709500f, -0.01464768f, 
    0.32195523f, 0.20874672f, -0.10122070f, -0.09687652f, 0.00183393f, -0.24471517f, -0.00197499f, -0.16485512f, 
    -0.03957231f, -0.09359480f, -0.02309061f, 0.12303175f, 0.21674849f, 0.04521714f, 0.00938403f, -0.48166791f, 
    -0.07081537f, -0.14643683f, -0.13209523f, -0.08813735f, -0.19219905f, -0.15352902f, 0.07146417f, -0.05208495f, 
    -0.06560215f, -0.07450150f, 0.26588529f, 0.03218855f, 0.01382678f, 0.13373442f, -0.11122734f, -0.11754572f, 
    0.00929444f, 0.25113335f, 0.13638841f, 0.35421258f, 0.14000551f, -0.30182511f, -0.81086689f, -0.04596066f, 
    0.02402354f, 0.11836371f, 0.06904394f, 0.05283061f, -0.07267500f, 0.05230620f, -0.13213533f, -0.14981076f, 
    0.55654800f, 0.41674274f, 0.02371313f, -0.33372122f, 0.29517910f, 0.20989043f, 0.11856297f, 0.09407274f, 
    -0.10867342f, -0.10614397f, -0.04454234f, -0.09117754f, 0.41630128f, 0.43899101f, -0.07996930f, -0.43193579f, 
    0.06129945f, 0.00062015f, -0.06371873f, 0.23166278f, 0.00854642f, 0.13993141f, -0.01793914f, 0.02051521f, 
    0.13791902f, 0.04743780f, 0.06113925f, -0.19751495f, 0.00042174f, -0.26487562f, -0.06386386f, -0.20042908f, 
    -0.11152182f, -0.14185499f, 0.06649507f, 0.06837890f, 1.30451429f, -0.31938028f, 0.20558219f, -0.27003118f, 
    0.11254320f, -0.05842277f, 0.12246105f, -0.03507980f, 0.05273759f, 0.01793977f, -0.12463514f, 0.06186258f, 
    0.25370434f, -0.15527491f, -0.14874944f, -0.16375430f, 0.12705265f, -0.09160060f, -0.17457546f, 0.13286507f, 
    0.21289058f, -0.01342440f, 0.12043437f, -0.24947235f, 0.22706161f, 0.22299169f, 0.08697872f, 0.24672642f, 
    -0.09406178f, -0.00612974f, -0.10944232f, -0.00437044f, -0.02383346f, 0.06850236f, 0.12637499f, -0.03630250f, 
    0.04816483f, -0.24477956f, 0.16059743f, -0.03405992f, -0.06084555f, -0.05827130f, 0.25254139f, -0.00675708f, 
    0.21472481f, -0.21502747f, -0.06359556f, -0.14808193f, 0.29975927f, -0.27267998f, -0.34769392f, -0.26394901f, 
    0.07277521f, -0.01978686f, -0.01321429f, -0.01563350f, -0.08771894f, 0.05082471f, -0.04930405f, -0.07065934f, 
    0.47161993f, -0.48675954f, -0.22736749f, -0.65871239f, -0.10845891f, -0.46693054f, -0.25225696f, 0.26815125f, 
    -0.00119472f, -0.03647638f, 0.02017259f, -0.01503333f, 0.34900689f, 0.04076997f, 0.45017523f, 0.07312179f, 
    0.14148459f, 0.09500897f, 0.08953267f, -0.00097352f, 0.16636819f, 0.06320021f, 0.11809312f, -0.15546012f, 
    -0.81668389f, 0.40817329f, -0.06686902f, -0.00351972f, 0.13898231f, 0.20244451f, -0.03898065f, 0.12501200f, 
    -0.12032400f, 0.15351090f, 0.06457943f, 0.36636698f, -0.11105566f, 0.05289510f, -0.04080907f, 0.11629917f, 
    0.00549061f, 0.17491534f, 0.24013461f, 0.15526301f, -0.14548595f, 0.02311016f, 0.17286366f, -0.04207599f, 
    -0.22082809f, -0.47309256f, 0.01207836f, -0.13395415f, 0.05751041f, 0.04149131f, -0.01425395f, -0.38088652f, 
    0.13822865f, -0.01902520f, -0.03679358f, 0.08695374f, -0.28602722f, -0.23434438f, -0.31605187f, -0.15378274f, 
    0.11621904f, -0.11767118f, 0.11876610f, 0.19432008f, -0.10125075f, -0.30979845f, 0.13141558f, -0.18488774f, 
    -0.01569557f, -0.03497818f, -0.03262558f, 0.00724371f, 0.00830754f, 0.00526172f, -0.21871169f, -0.01868172f, 
    -0.36664003f, -0.18796703f, -0.18156184f, -0.26353282f, 0.47685647f, 0.33218238f, 0.52989054f, 0.27412185f, 
    -0.04923350f, 0.01929236f, 0.05182978f, -0.05490617f, 0.02265074f, 0.14811009f, -0.24481526f, 0.03362814f, 
    0.12345097f, 0.34559381f, -0.06204581f, 0.17982487f, -0.32033712f, 0.24902940f, -0.42336428f, -0.01988194f, 
    -0.06050937f, -0.03778868f, -0.03828206f, 0.11175056f, -0.34289166f, 0.27691373f, -0.18460619f, -0.11757509f, 
    -0.08749497f, -0.00646688f, 0.25398424f, -0.09737135f, -0.10663252f, -0.03430430f, -0.10928365f, 0.14267078f, 
    -0.53402513f, 0.03067663f, 0.24150375f, -0.24284515f, 0.01343703f, 0.21839623f, 0.06400862f, 0.08618186f, 
    0.07934161f, -0.20675880f, 0.13180207f, -0.02731601f, -0.60882974f, 0.92661542f, 0.29028282f, -0.35477340f, 
    0.01423351f, 0.11814596f, -0.08296021f, 0.01649572f, 0.03631245f, 0.00954321f, -0.02919387f, -0.12617180f, 
    -0.33240116f, 0.13955818f, -0.01159030f, 0.32315302f, 0.06604465f, 0.16374834f, -0.13653350f, 0.14823975f, 
    -0.01715859f, 0.12970555f, -0.08842852f, -0.14208876f, -0.43343815f, -0.09225197f, 0.22640692f, -0.77460366f, 
    -0.00559449f, 0.00277606f, -0.06215959f, 0.18436386f, -0.04747102f, -0.13464780f, 0.03582970f, -0.01562405f, 
    -0.12490331f, -0.30623776f, 0.33021700f, 0.23660597f, 0.05055517f, -0.04255075f, 0.08795347f, 0.35811117f, 
    0.02492189f, -0.06373838f, 0.10821045f, -0.05206307f, 0.19593683f, 0.33890992f, 0.60866034f, 0.32144278f, 
    -0.05698165f, -0.01384414f, 0.12375348f, -0.01084819f, -0.00665680f, -0.12349263f, -0.16952948f, 0.13302390f, 
    -0.71851128f, -0.49306270f, 0.49051425f, -0.62434351f, 0.00550038f, -0.33418268f, -0.51178944f, -0.37959677f, 
    0.12325975f, 0.01215034f, -0.07329661f, 0.06268135f, -0.48326451f, 0.07358296f, 0.98396361f, 0.45870870f, 
    -0.04667198f, 0.01221685f, -0.05733072f, -0.06594733f, -0.01561045f, 0.01380186f, -0.07231320f, -0.07953997f, 
    0.35039717f, 0.02740708f, -0.47863510f, 0.29500031f, 0.01702902f, 0.13105062f, 0.02282895f, 0.02582033f, 
    -0.12212428f, 0.12329251f, -0.27549267f, 0.31452474f, 0.02927106f, -0.16864832f, -0.12810820f, 0.17593643f, 
    -0.05221689f, -0.04785777f, 0.08376873f, -0.29819036f, -0.14256670f, -0.03347939f, -0.14977060f, -0.18819799f, 
    0.25009194f, -0.14824866f, 0.27346531f, -0.07776127f, 0.21602950f, -0.14532623f, -0.00253020f, 0.28526455f, 
    -0.00636716f, 0.19462223f, 0.13371402f, 0.01740446f, 0.43298319f, -0.07402346f, 0.34304839f, 0.12015619f, 
    0.12020600f, 0.03998295f, -0.13204630f, -0.00671457f, 0.02347431f, -0.28086635f, 0.22725049f, -0.03972459f, 
    -0.08133138f, -0.03235850f, -0.02563130f, 0.10156709f, -0.00765004f, 0.02206787f, -0.11169506f, -0.05141016f, 
    0.24659698f, 0.32328930f, -0.04515625f, 0.29363078f, -0.40074867f, -0.54897147f, -0.63937509f, 0.10623103f, 
    -0.03609009f, 0.01122052f, 0.01155235f, 0.01519977f, -0.01805366f, -0.17264840f, -0.05158872f, 0.10183336f, 
    -1.43884492f, -0.61760622f, -0.33981648f, -0.02949352f, -0.45362061f, 0.11284955f, -0.22955444f, -0.13670228f, 
    0.00907785f, -0.02344308f, -0.05062763f, -0.08841170f, -0.62456399f, -0.53688270f, -0.46675712f, -0.29051983f, 
    0.20866348f, -0.06146475f, 0.20481965f, 0.01374077f, -0.00089401f, 0.04773079f, 0.09800380f, 0.06007535f, 
    -0.25996244f, 0.09156634f, 0.12014486f, 0.37351975f, -0.20134236f, -0.03913977f, -0.10486022f, -0.14560983f, 
    0.15115181f, 0.24191920f, -0.29001817f, -0.01753688f, -0.75674117f, 0.28343412f, 0.15757011f, 0.79913431f, 
    -0.31855226f, 0.00070182f, -0.08706670f, -0.27610961f, -0.04821356f, -0.04883139f, 0.15670820f, 0.09409539f, 
    -0.16254850f, 0.35132232f, -0.32807159f, 0.08266788f, -0.00732731f, -0.00002721f, -0.11065477f, -0.24508575f, 
    -0.26126009f, 0.01988203f, 0.00857670f, 0.16952364f, -0.56298387f, -0.12004293f, 0.00400728f, -0.42070720f, 
    -0.64243406f, -0.20220734f, -0.58072776f, 0.12702310f, 0.24057758f, 0.10096442f, 0.05990539f, -0.01763555f, 
    -0.83381569f, 1.13877881f, -0.06616020f, -1.06091762f, 0.30235028f, 0.33021605f, 0.12039910f, -0.11151274f, 
    -0.78453887f, -0.07489797f, -0.06517234f, 0.01358579f, 0.52628630f, -0.31534868f, -0.00323609f, 0.19974449f, 
    0.25513557f, 0.10713220f, 0.29013604f, -0.04751881f, -0.19851321f, 0.05749651f, 0.06877857f, -0.06251340f, 
    -0.05957542f, -0.27050745f, 0.58040845f, 0.26390997f, 0.01830239f, 0.15780872f, 0.03134056f, 0.24182472f, 
    0.06583956f, 0.01465647f, 0.09740426f, 0.07003301f, -0.05661744f, -0.18233135f, 0.01713774f, 0.34176579f, 
    0.12992917f, 0.05175634f, 0.04642829f, -0.12603170f, 0.08100308f, 0.02127574f, -0.04263017f, 0.07099386f, 
    0.70315373f, 0.29485607f, -0.43972021f, -0.80142146f, -0.34485567f, -0.19077989f, -0.11565329f, 0.17956834f, 
    0.11259449f, 0.11305385f, -0.20809563f, -0.13104896f, 0.03372611f, 0.14688191f, 0.03184853f, 0.10616635f, 
    0.08491264f, -0.21889874f, 0.10885685f, -0.33406144f, 0.22552179f, 0.15944161f, 0.06803009f, -0.02635907f, 
    0.04823091f, 0.19620201f, -0.29679021f, -0.28673917f, 0.06350418f, -0.26731104f, -0.12818114f, -0.30416015f, 
    -0.24314860f, -0.11007997f, -0.32913998f, 0.00809592f, 0.09975239f, 0.04228276f, 0.37772971f, 0.14130723f, 
    -0.05424197f, 0.03653021f, -0.09927019f, -0.17444099f, 0.07587337f, 0.06114908f, 0.14990553f, -0.05023634f, 
    -0.19706921f, 0.52156746f, -0.11353100f, 0.23871888f, -0.19409074f, 0.01564517f, 0.03958172f, 0.07602600f, 
    -0.07182713f, 0.31166032f, -0.20785150f, 0.03450385f, -0.17340575f, -0.35120386f, -0.01404920f, -0.12309192f, 
    -0.02573693f, -0.05635891f, -0.07138284f, 0.15353781f, -0.13238764f, 0.13050206f, -0.21564068f, 0.03164244f, 
    -0.25190908f, -0.25324008f, -0.07179543f, 0.40544954f, 0.03074378f, -0.02536380f, -0.03607647f, -0.02884464f, 
    -0.12832186f, -0.05234351f, -0.19139694f, -0.17663239f, -0.03254242f, -0.17442942f, -0.25056776f, 0.21772686f, 
    0.10945134f, 0.12245244f, 0.00700221f, -0.16624552f, 0.12737419f, 0.14498618f, -0.03354868f, -0.00815669f, 
    0.06421779f, 0.02375946f, 0.04454264f, -0.00577194f, -0.05618786f, -0.02632837f, 0.18784639f, 0.12392306f, 
    0.09798189f, -0.08071372f, -0.02714957f, -0.24261217f, -0.60516506f, -0.15071672f, -0.22208735f, -0.07767695f, 
    0.05359050f, -0.18823881f, -0.33870038f, -0.08799271f, -0.17354155f, 0.06477182f, 0.10258162f, 0.10363951f, 
    -0.25578657f, -0.41428596f, 0.31135151f, 0.08000963f, -0.23512131f, 0.10929801f, -0.01783442f, -0.28813398f, 
    -0.31434688f, -0.08706361f, -0.12403247f, 0.10694546f, 0.21423596f, -0.06836747f, -0.14715427f, 0.24508996f, 
    0.15766221f, 0.11677480f, 0.10134593f, 0.05703116f, 0.09407420f, 0.06441485f, -0.00193480f, 0.14989409f, 
    0.28928873f, -1.10687602f, 0.03498451f, 0.01354310f, -0.40331811f, -0.15108213f, 0.04160375f, -0.11433189f, 
    -0.02471525f, 0.23488650f, -0.17210378f, 0.00866126f, 0.21930693f, 0.15332471f, 0.12316561f, 0.13183314f, 
    -0.02980943f, -0.17653519f, 0.02596114f, -0.03035437f, 0.05916239f, -0.07817303f, -0.06031676f, 0.03600030f, 
    0.23478031f, 0.65006030f, -0.05825461f, 0.45962122f, 0.20957617f, 0.36398244f, -0.04168930f, -0.06785403f, 
    0.16030028f, -0.08056311f, 0.02119283f, -0.01835973f, 0.06173079f, 0.22976846f, 0.06091214f, 0.12188032f, 
    -0.15710521f, -0.11627554f, 0.07527567f, -0.07473569f, 0.07737007f, 0.06183511f, 0.02366994f, 0.10423021f, 
    -0.22328499f, -0.33369556f, 0.00022100f, -0.07286981f, -0.11971307f, 0.00777226f, -0.09969304f, -0.05195291f, 
    -0.13582850f, -0.28011101f, -0.27144721f, -0.17511067f, 0.26976982f, 0.07282741f, 0.03347706f, 0.08105029f, 
    -0.07177779f, 0.09480678f, -0.33945724f, 0.07207963f, -0.02769553f, -0.12799880f, -0.13707836f, 0.02364229f, 
    -0.13930434f, -0.26693073f, 0.10883842f, 0.19452251f, -0.29448378f, -0.09179553f, -0.34569475f, -0.30803505f, 
    -0.11944114f, -0.06143326f, -0.06945288f, -0.25319707f, -0.05818460f, 0.19421625f, -0.26367250f, 0.13711360f, 
    -0.10287610f, -0.05285824f, -0.02600828f, -0.38998482f, 0.08760234f, 0.05134819f, -0.19001508f, -0.01615938f, 
    0.19902092f, 0.03875576f, -0.00593178f, -0.14747383f, -0.04209504f, -0.00340279f, 0.03183492f, -0.19378303f, 
    0.14826743f, 0.20134906f, 0.00272964f, 0.68667102f, -0.10338964f, -0.30277678f, -0.31387755f, -0.29196802f, 
    0.11146264f, 0.04638992f, 0.07949442f, 0.10180670f, -0.01954233f, 0.02044109f, 0.09986355f, 0.00010824f, 
    0.04964107f, 0.24463110f, 0.23006883f, -0.14866839f, -0.16884644f, -0.09516811f, 0.26604068f, 0.13554169f, 
    0.01577464f, 0.03691202f, -0.01088638f, -0.01893153f, 0.16222569f, 0.27393195f, 0.49788120f, 0.39478827f, 
    -0.25693053f, -0.11458279f, -0.33323193f, 0.04574891f, 0.15246509f, 0.03573787f, 0.00360645f, -0.02433818f, 
    0.46809879f, -0.16685799f, -0.56107450f, 0.13020682f, 0.18355161f, 0.08957946f, -0.06574998f, -0.06069947f, 
    0.09581026f, -0.02759048f, 0.05226047f, -0.06370782f, -0.12435210f, -0.25006190f, -0.66652530f, -0.48266920f, 
    0.09771120f, 0.05802975f, -0.11196717f, 0.13177735f, 0.20935963f, -0.17904006f, 0.01356168f, -0.18159969f, 
    -0.32346216f, 0.07128851f, 0.44596714f, -0.15876757f, -0.06677616f, -0.10668745f, 0.05688037f, 0.29819959f, 
    -0.05974665f, -0.03393391f, -0.12520787f, -0.08731411f, -0.14738314f, -0.26802957f, -0.17846277f, -0.00211350f, 
    0.13303542f, -0.00665411f, -0.03976858f, 0.05253461f, 0.10192442f, -0.06750161f, -0.16431600f, 0.01268794f, 
    -0.32144764f, -0.19726874f, -0.33233917f, 0.12962528f, -0.06070425f, -0.10782779f, -0.20804246f, -0.18687026f, 
    0.06115691f, -0.07690685f, -0.07857943f, 0.11735162f, -1.14603853f, 0.21402463f, -0.39232865f, -0.31235924f, 
    -0.09248965f, 0.02478678f, -0.01200796f, 0.01691855f, 0.25128523f, -0.18227956f, -0.14312369f, 0.00792855f, 
    -0.21018425f, 0.09885731f, -0.27936986f, 0.11924347f, 0.12292018f, 0.11841352f, 0.15261549f, 0.04162055f, 
    -0.11346351f, 0.10513699f, -0.01901428f, -0.08488288f, -0.13412258f, 0.03004941f, -0.17706817f, -0.31357062f, 
    0.07628277f, 0.05187117f, -0.11749237f, -0.17268549f, 0.00544747f, -0.11890314f, -0.15605511f, -0.01416292f, 
    0.06729441f, -0.52180696f, 0.32885295f, 0.47913787f, 0.30983961f, -0.07804526f, -0.01896370f, 0.06670824f, 
    0.23575909f, -0.00637423f, -0.00602427f, 0.11142522f, 0.05467632f, -0.31577855f, 0.08737525f, -0.16997714f, 
    -0.14700688f, -0.09156188f, -0.04662194f, -0.05755856f, 0.21041337f, 0.23737106f, 0.02911649f, 0.11969426f, 
    0.09401706f, 0.62478095f, -0.14143424f, -0.17498788f, 0.07439930f, 0.13598388f, 0.22825219f, 0.39184278f, 
    -0.02237471f, 0.04950547f, 0.28151137f, 0.18140689f, 0.06903599f, 0.07997787f, 0.38078848f, -0.02501261f, 
    0.13881895f, 0.20073451f, -0.03639586f, 0.01702873f, 0.11621583f, -0.00756448f, -0.34952468f, -0.19025058f, 
    0.09531365f, -0.31600988f, -0.08708928f, -0.08038028f, 0.02871177f, -0.01268299f, 0.09559599f, 0.09434516f, 
    -0.25678745f, -0.59499776f, -0.05944178f, -0.98992199f, 0.02648070f, -0.37590373f, -0.36845639f, 0.35160643f, 
    0.04333571f, -0.07063092f, -0.04923615f, 0.00785750f, -0.03687644f, -0.16144381f, 0.32643539f, 0.08761016f, 
    0.03651242f, 0.10202272f, 0.14869189f, 0.07406849f, 0.42793915f, -0.02546506f, 0.08394388f, -0.04525897f, 
    0.05098935f, 0.01765203f, 0.10017279f, 0.08185507f, 0.28946987f, 0.08944114f, 0.27705765f, -0.07030305f, 
    0.20825084f, 0.28816256f, 0.09614585f, 0.08400609f, -0.02597072f, 0.01226472f, 0.19863395f, 0.11097772f, 
    0.47652969f, -0.30619863f, -0.34088603f, -0.31272539f, -0.21409918f, 0.24519756f, 0.39442164f, -0.04813375f, 
    -0.03077765f, 0.02439579f, -0.22740111f, 0.04521343f, 0.75329882f, 0.56335795f, -0.22807388f, 0.14956908f, 
    0.19725122f, -0.22063351f, 0.20786272f, 0.04885339f, 0.25038025f, 0.12593946f, 0.11005812f, -0.03717719f, 
    -0.02579481f, -1.02860618f, -0.49623597f, 0.73907429f, 0.11890778f, 0.14526644f, 0.23805062f, 0.07329641f, 
    0.01943428f, 0.01420959f, 0.12005289f, 0.12506285f, -0.00841793f, -0.04713130f, -0.14147238f, -0.08264028f, 
    0.15160730f, 0.15986620f, 0.08065838f, -0.06893981f, -0.12081127f, -0.07118010f, -0.03168335f, -0.05671633f, 
    -0.34852821f, -0.24166432f, 0.40742451f, -0.07104448f, -0.14973977f, -0.09132716f, -0.01175776f, -0.11942821f, 
    -0.04651989f, 0.27673122f, -0.00672483f, 0.06516504f, -0.94018942f, 0.33560660f, 0.71218395f, 0.02157621f, 
    -0.08026177f, -0.00483324f, -0.09311561f, 0.08438362f, -0.05879797f, 0.11883784f, 0.42018053f, -0.13629997f, 
    0.00448748f, -1.40215516f, -0.36266944f, -0.47573799f, 0.07142656f, -0.00659603f, 0.24371047f, -0.33136782f, 
    -0.00478148f, -0.10196565f, 0.07499649f, 0.04049740f, -0.58332783f, -0.67328060f, -0.21300858f, -0.06778450f, 
    -0.31475842f, -0.30060387f, -0.35190219f, -0.00564500f, -0.08810253f, -0.00575696f, 0.11243787f, 0.08141567f, 
    0.11183517f, -0.04130081f, -0.23595242f, 0.11065254f, -0.08509631f, -0.15472908f, -0.01155778f, 0.31006190f, 
    -0.11637341f, -0.17774260f, 0.27229366f, -0.00612010f, -0.35807201f, 0.08799631f, 0.04305071f, 0.10388488f, 
    -0.10023946f, -0.08012597f, -0.46911058f, 0.35524777f, 0.00312588f, -0.19666243f, -0.04981751f, -0.00485173f, 
    -0.71634412f, -0.03586083f, 0.52143592f, 0.18678141f, -0.16947073f, 0.02730709f, 0.27554390f, -0.01828440f, 
    -0.08067755f, 0.03664126f, -0.06454594f, -0.00037316f, -0.22044769f, -0.24689674f, 0.11164018f, -0.51116586f, 
    -0.14201933f, 0.06862366f, 0.04194033f, 0.18488184f, -0.03871134f, 0.03921107f, 0.17416669f, 0.01875728f, 
    0.01142632f, 0.12724008f, -0.21881443f, -0.00611846f, -0.09438410f, 0.16336420f, 0.19365385f, -0.00799961f, 
    0.39150193f, 0.05346372f, 0.34317744f, 0.07636525f, -0.14640769f, 0.11923029f, 0.12253623f, -0.26416788f, 
    0.04549147f, -0.03645269f, 0.02878261f, 0.05113662f, -0.17379726f, 0.10060071f, -0.11342302f, 0.06328052f, 
    -0.94777012f, -1.14132524f, -0.66010320f, -0.24147838f, 0.13127996f, -0.31130871f, 0.11644535f, -0.56696081f, 
    -0.05754067f, -0.02625350f, -0.08894777f, -0.02605343f, -1.07556188f, -1.49088490f, -0.06292514f, 0.07547576f, 
    -0.29096949f, -0.11204372f, -0.10360232f, -0.38428062f, 0.02100939f, 0.04048435f, -0.04543973f, -0.08200368f, 
    -0.24761958f, 0.05805856f, 0.03808361f, -0.08562849f, -0.02761354f, -0.13825192f, -0.17037740f, -0.00676484f, 
    0.00123182f, 0.05809033f, 0.08176970f, 0.05562292f, -0.50491029f, 0.18012078f, -0.05796428f, 0.40900639f, 
    -0.05413459f, -0.08244178f, 0.35338435f, 0.07560103f, -0.17495494f, 0.14619280f, 0.17216130f, -0.09919911f, 
    0.29475498f, -0.97296304f, 0.22277427f, -0.66903585f, 0.09157011f, -0.06956828f, -0.24253739f, 0.13682336f, 
    -0.05335018f, -0.02157691f, 0.01874094f, -0.05170636f, 0.11162137f, 0.15748301f, 0.02093449f, -0.16008727f, 
    0.00674626f, -0.07531291f, -0.03382295f, 0.02933581f, 0.09059683f, 0.05368765f, 0.13145843f, 0.01024353f, 
    0.64534789f, 0.25572640f, -0.18143156f, -0.61517835f, -0.08939719f, 0.15916148f, -0.37970182f, 0.01465490f, 
    -0.14947774f, 0.19097109f, -0.00070703f, -0.13901320f, 0.81706870f, -0.99384081f, -0.84643608f, -0.35212243f, 
    -0.03282817f, -0.17247912f, 0.01994510f, 0.07577972f, 0.18568124f, -0.03656342f, -0.05480729f, 0.14221743f, 
    -1.25896049f, 1.22775209f, -0.77710891f, 0.34508047f, -0.19323441f, -0.05987848f, -0.03234367f, -0.01301161f, 
    0.14687109f, -0.00223030f, -0.01204317f, 0.01717624f, 0.02098340f, -0.63612950f, -0.22555491f, -0.63394076f, 
    0.26252586f, -0.15955362f, 0.18827277f, 0.26932535f, 0.03618548f, 0.00356401f, 0.07643571f, 0.03714391f, 
    0.44612533f, -0.16423391f, 0.01090742f, -0.03459005f, -0.07315190f, -0.12056745f, -0.01523266f, -0.11987387f, 
    -0.30291629f, 0.17834781f, 0.11447623f, -0.24663515f, 0.32428673f, -0.17228965f, 0.10557176f, 0.02622214f, 
    -0.13731104f, -0.22243205f, 0.06857482f, 0.10801984f, -0.04637313f, 0.11955113f, 0.01678476f, 0.06595670f, 
    0.21949124f, 0.04462725f, 0.00364260f, -0.09234717f, -0.25936079f, -0.38014778f, -0.16945076f, -0.02754282f, 
    -0.03248980f, -0.08151200f, -0.02061532f, 0.00232148f, -0.08716366f, -0.67786223f, 0.05325947f, 0.48833013f, 
    -0.30187020f, 0.00544365f, -0.20460173f, 0.08095219f, 0.08453247f, 0.08098001f, -0.10432810f, 0.08407564f, 
    0.17070454f, -0.18735835f, 0.22769235f, 0.04024807f, -0.00916954f, -0.12576844f, 0.11374287f, -0.15651104f, 
    0.01993732f, -0.22135001f, 0.01618240f, 0.16306706f, 0.12240299f, 0.12118031f, -0.04714890f, -0.15824737f, 
    0.03106388f, -0.03955355f, 0.00570222f, -0.00127297f, 0.05172132f, -0.08712447f, -0.11523589f, -0.31935120f, 
    -0.63313180f, -0.72857016f, -0.11581402f, 0.28640899f, 0.15884557f, 0.05816204f, 0.24892999f, 0.27241063f, 
    -0.00828555f, -0.04460442f, -0.05966201f, -0.18004738f, -0.88823581f, -0.92204785f, -0.44365454f, 0.72805750f, 
    0.15664242f, -0.07024542f, -0.02291709f, 0.30389199f, 0.05781762f, 0.02101682f, -0.17317455f, 0.04974474f, 
    -0.45767078f, 0.15090173f, -0.01237534f, 0.42632836f, 0.07630169f, 0.06349490f, -0.18609230f, -0.01481000f, 
    0.08583592f, 0.15480256f, 0.10882024f, 0.13487580f, -1.59665847f, -0.07317124f, 0.45807752f, 0.43793243f, 
    0.02546604f, 0.12339793f, 0.06341098f, -0.07043621f, 0.05393201f, 0.12051955f, -0.04252239f, 0.30754837f, 
    0.69086951f, 0.66459668f, 0.02229559f, -0.60882831f, 0.15789041f, 0.00158770f, 0.21043681f, -0.10924172f, 
    0.00165635f, 0.01903873f, -0.02555594f, 0.08264175f, -0.19999702f, 0.04851383f, 0.24912284f, -0.16099390f, 
    -0.22342165f, -0.12642311f, -0.16519955f, -0.07633372f, -0.09334155f, -0.01971686f, 0.04339196f, 0.08643803f, 
    0.08077627f, 0.10185879f, -0.68307698f, -0.44564757f, -0.05372148f, -0.32293829f, 0.11473726f, 0.08850972f, 
    0.27245560f, -0.17230225f, 0.03234600f, 0.10069367f, -0.49714625f, -0.32060125f, -0.04818241f, -0.09297530f, 
    -0.06718653f, 0.24145484f, 0.10192470f, 0.14387700f, -0.08117376f, 0.03180232f, -0.26527953f, -0.41259316f, 
    -1.04670203f, 0.13536079f, 0.27098536f, 0.15181156f, 0.22075312f, -0.23781025f, -0.22209971f, -0.04711439f, 
    -0.31430003f, -0.10647133f, 0.05368464f, -0.09653766f, -0.36425206f, -0.73226750f, -0.77571940f, -0.35828277f, 
    -0.04073583f, 0.23217468f, 0.38022378f, 0.01141755f, 0.05605353f, -0.18433268f, -0.09184353f, -0.01982102f, 
    0.43362385f, -0.06211600f, -0.45127824f, -0.25587717f, 0.24799405f, -0.02844825f, -0.00756743f, -0.10159156f, 
    0.13127321f, 0.19006272f, 0.19886591f, 0.29270387f, 0.02718586f, -0.33655146f, -0.43681052f, -0.37514967f, 
    0.09130744f, 0.09356315f, 0.11807058f, 0.11757810f, 0.14442657f, 0.12088080f, 0.21103783f, 0.17633547f, 
    0.24158841f, 0.13482077f, -0.23540159f, 0.16473505f, -0.27641085f, 0.12887886f, 0.11266178f, 0.26417747f, 
    0.11317380f, -0.03822892f, -0.13372737f, -0.10660796f, 0.27309281f, -0.39962101f, -0.30926377f, -0.85445994f, 
    0.19112159f, 0.09615657f, 0.26519766f, 0.27219298f, 0.20796178f, 0.10876589f, -0.23126327f, -0.41297492f, 
    -0.13771433f, -0.13974068f, -0.00692569f, 0.02674054f, 0.09524847f, 0.05423744f, 0.07682943f, -0.06675516f, 
    -0.21528755f, -0.14119069f, -0.15408629f, -0.78267622f, -0.42650095f, 0.23635787f, -0.15261635f, -0.28846735f, 
    -0.15342724f, -0.03041223f, -0.04696984f, -0.07946810f, 0.03489694f, -0.03172457f, 0.01819588f, 0.40279770f, 
    0.00497323f, -0.76245540f, -0.83166313f, 0.12072407f, -0.11939348f, 0.01058487f, -0.09113475f, -0.02646128f, 
    -0.01152711f, 0.03925333f, 0.08297203f, 0.08771336f, 0.10450086f, 0.01066034f, -0.60455304f, 0.03209473f, 
    -0.07985137f, 0.12737128f, 0.13612220f, -0.00130963f, 0.05421273f, 0.03542303f, -0.09579633f, -0.02539573f, 
    -0.15849626f, 0.07082763f, -0.69350076f, 0.19257115f, 0.25515291f, 0.16201177f, 0.12582569f, 0.14739898f, 
    -0.01146570f, -0.11298590f, -0.21555184f, -0.12665609f, -0.18823777f, 0.05753973f, 0.50301808f, -1.40664124f, 
    0.06030225f, -0.29225498f, 0.08502381f, -0.13001864f, -0.14003475f, 0.08945405f, 0.01230473f, 0.07762331f, 
    -0.02828906f, -1.60678434f, 0.41538188f, -0.06712831f, -0.19359148f, 0.29857340f, -0.11591350f, 0.02305576f, 
    -0.01424099f, 0.00511022f, 0.11163310f, 0.01950317f, 0.05212581f, -0.72542959f, -0.06830548f, 0.12243787f, 
    0.10476164f, 0.21413681f, 0.28256810f, -0.07281785f, -0.05963101f, 0.02456911f, -0.12239715f, -0.03004939f, 
    -0.12144671f, 0.24876340f, -0.28303182f, 0.65869337f, -0.04575079f, 0.13025151f, -0.50913310f, 0.00301093f, 
    0.15260838f, -0.13591141f, 0.05544217f, 0.16306219f, 0.13073224f, 0.26981357f, 0.34884447f, 0.26993150f, 
    -0.11321992f, -0.12024236f, -0.40654609f, -0.33581695f, 0.02434964f, 0.04919967f, 0.19850449f, 0.04993837f, 
    -0.14831111f, 0.84764928f, -0.83375925f, 0.02824005f, -0.20758779f, 0.03863429f, 0.21665387f, 0.15920609f, 
    0.08944917f, -0.03423038f, 0.05918470f, 0.10188798f, -0.18318674f, -0.19135968f, -0.02911280f, 0.03788484f, 
    -0.23656654f, 0.08428256f, -0.11664846f, 0.28943393f, 0.08544684f, 0.00173831f, 0.13728665f, 0.04085697f, 
    -0.22645871f, 0.30100214f, -0.07362256f, 0.49931589f, -0.02197339f, 0.01036036f, -0.07888185f, -0.34826145f, 
    0.22475125f, -0.20083375f, -0.03118276f, -0.38575348f, 0.17453213f, -0.04925784f, 0.39709568f, -0.00881076f, 
    0.40523338f, -0.31012791f, -0.02245967f, -0.12561686f, -0.02529790f, -0.25464594f, -0.07388149f, 0.08711275f, 
    -0.28892252f, -0.36275348f, -0.17504059f, -0.23298520f, 0.33541191f, -0.02775708f, -0.34518352f, -0.04342938f, 
    0.15700184f, -0.25511608f, -0.09721588f, 0.02472685f, 0.13120499f, 0.08208229f, -0.76910013f, 0.13040313f, 
    -0.27314159f, 0.10533223f, 0.05496083f, -0.07976574f, -0.14817357f, 0.02632390f, 0.11369057f, -0.04121533f, 
    0.09118728f, -0.11064595f, 0.19726871f, 0.04734709f, 0.10436881f, 0.01709581f, 0.04802640f, -0.11439049f, 
    0.19839853f, 0.11697711f, 0.11900330f, 0.42454067f, -0.34619337f, -0.06574915f, -0.07609605f, 0.31732646f, 
    0.04666942f, 0.17219310f, -0.03779924f, 0.06231999f, 0.21028534f, -0.02789159f, 0.12312735f, -0.21343473f, 
    -0.13879339f, 0.49568927f, -0.17905891f, -0.66749066f, -0.38810328f, -0.30443206f, -0.03194338f, 0.28600162f, 
    0.06246229f, 0.01542784f, 0.06961472f, -0.04193206f, -0.27276897f, -0.07514888f, -0.04779186f, -0.44732073f, 
    0.02882153f, -0.25689048f, 0.03874062f, 0.24355568f, 0.06130427f, -0.04649485f, -0.06147949f, -0.03840093f, 
    -0.31392607f, 0.03953934f, 0.23352990f, 0.14424914f, -0.17209573f, 0.10316348f, -0.05510986f, 0.16855767f, 
    -0.03451600f, 0.00632909f, 0.22676547f, 0.05624866f, 0.20339212f, -0.10675207f, 0.05069137f, 0.25171632f, 
    -0.15069900f, 0.19718789f, 0.11662754f, 0.06391452f, 0.04397764f, -0.05236344f, 0.00950619f, -0.11487735f, 
    -0.81219161f, 0.04365226f, -0.40209129f, 0.22895543f, 0.07263197f, 0.06886955f, -0.06423540f, -0.15809542f, 
    0.12493223f, -0.14653747f, -0.02629508f, -0.13842006f, -0.16042134f, -0.07790311f, -0.49706393f, 0.04288616f, 
    -0.33087459f, -0.43580338f, -0.11072674f, -0.22706412f, 0.00237102f, 0.13625170f, -0.17105949f, -0.06443623f, 
    -0.41438389f, 0.86984032f, -0.30313218f, 0.09767826f, 0.40327147f, 0.12806207f, -0.12855405f, -0.13546678f, 
    -0.23292291f, 0.11288659f, 0.16275606f, 0.05057560f, 0.52241409f, -0.53675032f, -0.00325588f, 0.12851974f, 
    0.05189266f, -0.02809027f, -0.28508595f, 0.18094544f, -0.12425735f, 0.14543019f, -0.35519245f, -0.32617792f, 
    0.12947105f, -0.81313175f, 0.00937939f, -0.12031566f, -0.18179694f, -0.14097142f, 0.12478855f, 0.02690857f, 
    0.01790008f, 0.06998447f, -0.07070828f, -0.06817459f, -0.34045616f, 0.01793490f, -0.64358515f, -0.16890037f, 
    -0.00093208f, -0.05788656f, -0.01239946f, 0.09744142f, 0.13578452f, 0.14812541f, -0.15763879f, -0.17133573f, 
    0.06545515f, 0.37783745f, 0.34288850f, 0.11803374f, -0.02157257f, 0.10516376f, 0.21218234f, 0.13109401f, 
    -0.09255626f, 0.06448168f, 0.06885247f, -0.17245416f, -0.37443155f, 0.47821677f, 0.04810911f, -0.08625254f, 
    -0.21782209f, 0.07202024f, 0.04402049f, 0.21286787f, -0.04600260f, 0.15677813f, 0.11366113f, 0.30666339f, 
    0.10650425f, -0.53114289f, 0.43651444f, 0.33091557f, 0.00601782f, 0.26953468f, 0.25052071f, 0.37352282f, 
    -0.25594598f, -0.09803477f, 0.15333246f, -0.22089101f, 0.08669610f, 0.78495073f, -0.16789249f, -0.29895550f, 
    0.07236660f, 0.02749676f, 0.32131359f, 0.06571201f, -0.25521758f, 0.20448071f, -0.43108436f, 0.01018358f, 
    -0.35949922f, 0.33779246f, -0.07385243f, -0.27163467f, 0.02626694f, 0.04341738f, -0.12040917f, 0.19818637f, 
    -0.53160262f, -0.27988189f, -0.30099127f, -0.56143856f, -0.27215242f, -0.09035517f, 0.01639402f, -0.69917083f, 
    -0.16535884f, -0.27641720f, -0.07482345f, -0.13186565f, -0.05325475f, -0.13475366f, 0.08508927f, 0.00868175f, 
    -0.29019362f, -0.77076238f, 0.52168173f, 0.23277633f, -0.18376504f, 0.39468935f, 0.09818266f, -0.11554290f, 
    0.05067639f, 0.07483973f, 0.14732254f, 0.06662093f, -0.20273644f, -0.80530411f, 0.07951501f, 0.41375318f, 
    0.07322880f, 0.04837198f, -0.25743502f, -0.06858905f, -0.08725050f, -0.05951678f, 0.14036828f, 0.27224055f, 
    0.53047395f, 0.01257869f, 0.85703760f, 0.06183873f, -0.11981248f, -0.10330547f, 0.05427636f, 0.28777936f, 
    -0.19572446f, -0.04869204f, -0.06797756f, -0.24611507f, -0.32982287f, -0.55101025f, 0.29899240f, 0.13772659f, 
    -0.20990480f, 0.31183699f, -0.13046746f, 0.31612182f, -0.52412701f, -0.09550720f, -0.02511400f, 0.10817983f, 
    -0.64742607f, 0.21751210f, -0.71347106f, 0.49889788f, -0.02535722f, -0.16523376f, 0.55082065f, -0.35820138f, 
    0.03628850f, 0.05999290f, 0.27835017f, 0.11496966f, 0.30861422f, 0.23725139f, 0.15908547f, -0.12106214f, 
    -0.17325865f, 0.14071591f, 0.00235000f, 0.14915974f, -0.14020370f, -0.02759416f, 0.04582351f, -0.12794112f, 
    -0.65188557f, -0.42220604f, 0.17213742f, 0.74946374f, 0.64652008f, 0.01356576f, 0.12789200f, -0.04025912f, 
    -0.11396690f, -0.08067781f, 0.23162866f, 0.15541723f, -0.50206566f, -0.00291774f, -0.89249998f, -0.15350926f, 
    -0.06866677f, -0.03621453f, 0.17203161f, -0.07554032f, -0.06726381f, 0.11903172f, 0.26628566f, -0.00002151f, 
    0.54736096f, -0.56325072f, 0.91411704f, -0.55298525f, -0.18881869f, 0.16736849f, -0.27941751f, -0.12698416f, 
    -0.02491019f, 0.09680445f, 0.02380961f, 0.03667286f, -0.14035191f, -0.09446942f, -0.19873898f, -0.20656632f, 
    -0.46501157f, -0.17599329f, -0.04246997f, -0.08729833f, 0.01928535f, 0.01288622f, 0.02137270f, -0.00982382f, 
    0.08195550f, -0.28266180f, 0.09448833f, -0.38518554f, 0.14341410f, 0.02129613f, -0.12772852f, 0.06801733f, 
    0.09997683f, -0.07354808f, 0.26718178f, 0.11107809f, -0.11695634f, -0.19265711f, -0.08002888f, 0.02703087f, 
    0.01769193f, -0.07411436f, -0.06990314f, 0.00987917f, -0.08195075f, -0.17178260f, -0.42887506f, -0.31717116f, 
    -0.16125125f, 0.60824752f, -0.16084328f, 0.51574326f, 0.06813134f, 0.20368712f, -0.17561540f, -0.09853330f, 
    -0.13227586f, 0.16881165f, -0.11495893f, -0.23473775f, -0.66358769f, -0.95331365f, 0.17289385f, 0.88309652f, 
    0.16689926f, -0.14905672f, 0.20652761f, -0.20909321f, 0.07093861f, 0.11641488f, 0.10094021f, 0.27901563f, 
    0.15555534f, 0.13720170f, -0.20578456f, 0.02854370f, 0.00756873f, -0.19379325f, 0.14899850f, 0.34585163f, 
    0.21542720f, 0.12392221f, 0.15376469f, 0.13216101f, 0.31164712f, 0.04860199f, -0.07542931f, -0.08743253f, 
    -0.04214088f, 0.02924481f, -0.03355142f, 0.23613423f, -0.23950760f, 0.07076482f, 0.15432307f, -0.30830166f, 
    0.05721853f, -0.65253294f, -0.11957913f, -0.11850800f, -0.12402114f, -0.42366782f, -0.08450739f, -0.03395885f, 
    0.13394889f, 0.06801318f, -0.12715027f, -0.09055816f, 0.05944002f, -0.43323094f, 0.18262979f, 0.14128068f, 
    -0.30637255f, -0.08150795f, -0.06293090f, -0.33562064f, -0.06544301f, -0.06957576f, -0.04185949f, -0.42622915f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.30448809f, 0.12711404f, 0.06548154f, -0.12106036f, -0.15606071f, 0.07630332f, 0.06742274f, -0.18644865f, 
    0.13433841f, 0.10336445f, 0.05098661f, -0.11168773f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
