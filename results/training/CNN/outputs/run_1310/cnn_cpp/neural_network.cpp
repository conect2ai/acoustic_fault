#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.45077971f, -0.00717798f, 0.00136548f, -0.83648247f, -0.33014446f, -0.82461005f, 0.58260244f, 0.22414412f, 
    0.06015917f, -1.13536739f, 0.15513530f, 0.40120500f, 0.05720007f, 0.78151810f, 0.16635889f, 0.11480200f, 
    0.25691742f, -0.25199506f, -0.17073338f, 0.59588039f, 0.70553857f, -0.23086247f, -0.76439065f, -0.10340052f, 
    -0.45783642f, -0.11208307f, -0.27339461f, 0.12373465f, -0.32583055f, -0.03320976f, -0.43179497f, 0.19025020f, 
    0.05176713f, -0.47938108f, 0.06138101f, 0.63924932f, -1.02837825f, 0.83542114f, 0.03615905f, -0.08085688f, 
    0.07622546f, 0.46374428f, 0.07730191f, -0.15419030f, 0.01755606f, 0.55365193f, -0.86296439f, -0.50029087f, 
    -0.19697349f, -0.29639065f, -0.36724693f, -0.12496522f, 0.26742682f, 0.00819491f, 0.50734377f, 0.09201149f, 
    0.51229924f, -0.13927902f, -0.15279932f, 0.65774846f, 0.28070647f, 0.03090930f, -0.28824577f, 0.79997891f, 
    -0.36304021f, -0.45869559f, 0.05428485f, 0.48342448f, -0.47273436f, 0.05229400f, 0.29337814f, 0.22449483f, 
    -0.51307106f, -0.66344815f, -0.02086883f, 0.93562698f, -0.55292171f, 0.39060166f, -0.25254056f, -0.27400634f, 
    0.05042825f, -0.53464627f, -0.93634158f, 0.12647857f, 0.55332768f, 0.47777450f, -0.14006878f, 0.33733720f, 
    -0.34520176f, 0.14832078f, 0.33140618f, 0.51734853f, -0.23555103f, 0.34257102f, 0.38404408f, 0.23788165f, 
    -0.09916729f, -0.40854922f, 0.36716419f, -0.63273811f, -0.56427002f, -0.58994263f, -0.08300120f, -0.59514964f, 
    0.58701915f, 0.07942067f, -0.05493956f, -0.25654531f, 0.20277311f, 0.64899105f, -0.71960241f, -0.26825452f, 
    -0.61518377f, -0.49240944f, -0.33821380f, -0.31375644f, -0.29810983f, 0.11840966f, 0.39292726f, 0.49387005f, 
    -0.27394316f, -0.04949068f, -0.42862505f, 0.43933728f, 0.30643895f, -0.23227425f, -0.24216127f, -0.03272438f, 
    -0.17059122f, -0.26591611f, -0.32033801f, 0.58295912f, 0.13717733f, 0.10736545f, 0.40984952f, 0.34936839f, 
    0.64172548f, 0.02014004f, -0.42482099f, 0.39765501f, -0.41554558f, 0.33867216f, 0.13123594f, -0.29331750f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.09875456f, 0.01162400f, -0.12750840f, 0.20608872f, 0.06261375f, 0.06594325f, -0.20167747f, 0.33121917f, 
    -0.11066257f, 0.19539523f, -0.33936802f, -0.18120000f, -0.17857282f, -0.30713877f, 0.01893036f, 0.36546555f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.03518320f, -0.03163545f, 0.03474500f, -0.00181789f, 0.02175186f, -0.02855799f, 0.00514913f, -0.03800439f, 
    0.04211067f, 0.01290470f, 0.03845733f, 0.02383963f, -0.01133987f, 0.02200814f, -0.04511144f, 0.00455922f, 
    -0.00977341f, 0.02730726f, -0.03639708f, -0.01436443f, -0.03948108f, -0.04648262f, 0.02005523f, -0.00704658f, 
    0.03625938f, 0.01807408f, -0.00690890f, 0.04752734f, -0.04177928f, -0.05195307f, 0.01636638f, -0.02159577f, 
    -0.03704518f, 0.00228871f, 0.03454064f, -0.04494462f, 0.02771545f, 0.03837466f, -0.04213078f, 0.00256630f, 
    -0.02886026f, 0.00925311f, 0.00032169f, -0.01172418f, 0.05151124f, -0.04773472f, 0.01489487f, -0.03791374f, 
    0.02887865f, -0.03120645f, 0.02729141f, 0.00299350f, 0.00405359f, 0.00833137f, -0.01656036f, -0.04514058f, 
    -0.05511667f, -0.00580241f, -0.04898712f, 0.02830017f, 0.03914995f, 0.03566318f, -0.03691757f, 0.02959365f, 
    -0.00053100f, -0.01101279f, 0.02297328f, -0.04279862f, 0.03519762f, 0.02951702f, 0.04237460f, -0.03748723f, 
    0.03401485f, -0.03335381f, 0.03604804f, 0.03343436f, 0.00720597f, -0.05886189f, -0.02524185f, 0.01446491f, 
    -0.01454108f, 0.00337816f, -0.04724678f, -0.02612638f, -0.02160415f, 0.03685214f, -0.02269895f, -0.01808608f, 
    0.00315995f, -0.05573339f, 0.03695656f, 0.01837290f, -0.00431842f, -0.05778586f, -0.02497269f, -0.01595614f, 
    -0.04649905f, -0.04821496f, 0.03444915f, -0.02502437f, -0.03696487f, -0.00424495f, 0.02801091f, -0.05536100f, 
    -0.06219683f, -0.04579836f, 0.03294721f, -0.04471202f, -0.01572857f, -0.04766744f, 0.03073964f, 0.01501424f, 
    0.04131072f, 0.02822152f, 0.03236425f, 0.04384636f, -0.01688487f, 0.00085653f, 0.02825103f, -0.03736346f, 
    -0.04729471f, 0.03966581f, -0.05129729f, 0.01093907f, 0.00441228f, 0.03893785f, -0.03414555f, -0.02368427f, 
    0.01060680f, 0.01812509f, -0.03318884f, 0.04101611f, -0.01699012f, -0.05759335f, 0.03874310f, -0.03859621f, 
    -0.00227074f, 0.00631727f, -0.05383862f, -0.03409507f, -0.05833666f, -0.00015659f, 0.02672416f, 0.00805300f, 
    -0.00186881f, -0.05027108f, -0.05835218f, 0.04204109f, 0.00628000f, -0.00387382f, -0.05299911f, -0.05828200f, 
    -0.05386281f, -0.06351101f, -0.02454725f, 0.01073603f, 0.00525005f, -0.02173487f, -0.01681158f, 0.03704677f, 
    -0.02920616f, 0.04893638f, 0.01749175f, 0.04435487f, -0.02581649f, -0.06235170f, -0.00024572f, 0.03320694f, 
    0.02301351f, -0.04880583f, -0.03965831f, -0.02466217f, -0.04953210f, 0.02204123f, 0.01268414f, 0.00967873f, 
    -0.04922304f, 0.00491820f, 0.03020902f, -0.03515058f, 0.00708341f, 0.01914362f, -0.03234766f, -0.04251751f, 
    0.00765401f, 0.00108120f, -0.05150041f, -0.04254874f, -0.06274348f, -0.03415773f, -0.01910266f, -0.02777579f, 
    -0.05598931f, 0.01059886f, -0.03938202f, 0.01278000f, -0.03286479f, -0.04382753f, -0.00582209f, -0.04365496f, 
    -0.05350450f, 0.01485516f, 0.00023707f, 0.00593868f, 0.05185324f, -0.03768066f, 0.00326883f, -0.04624428f, 
    -0.04180074f, -0.01965973f, 0.03853570f, 0.04657150f, 0.01463098f, -0.04298588f, 0.01891884f, -0.03185492f, 
    0.01375189f, -0.00441517f, -0.01497372f, 0.00069595f, 0.01679328f, -0.05105877f, -0.05797921f, -0.01906157f, 
    0.04242088f, -0.05805549f, -0.03768533f, 0.00165016f, -0.00585088f, 0.00997290f, 0.03876035f, 0.04508197f, 
    -0.05443064f, 0.03640239f, -0.06034413f, -0.06505708f, 0.02514905f, -0.04263961f, 0.00444684f, -0.03299942f, 
    -0.05547826f, -0.05722889f, 0.02862765f, -0.01106211f, -0.00170029f, 0.03183400f, 0.04315171f, 0.00128574f, 
    -0.01635086f, -0.02708805f, 0.01285309f, -0.01924055f, -0.05070065f, -0.04744119f, 0.02513446f, 0.03721775f, 
    -0.01922443f, -0.00130491f, -0.00756921f, -0.01399159f, 0.03362874f, -0.03543082f, 0.02287278f, 0.00734075f, 
    0.00820894f, -0.04715959f, 0.04041591f, 0.04354563f, 0.02238105f, 0.01526382f, 0.01427913f, 0.03600944f, 
    -0.04810602f, -0.02851967f, -0.04450071f, 0.02489886f, 0.03620277f, -0.00780973f, 0.02304454f, -0.03996446f, 
    -0.02193637f, -0.05802213f, -0.00993065f, -0.03291177f, -0.02993446f, -0.04724509f, -0.05714524f, 0.00074629f, 
    0.04040650f, 0.01506366f, -0.00776713f, 0.02965022f, -0.02964999f, 0.00762104f, 0.02417555f, -0.01823137f, 
    0.04303247f, 0.00572466f, 0.02975830f, 0.02897078f, 0.04885381f, 0.03734114f, -0.03341110f, -0.02183437f, 
    -0.02094105f, 0.04761803f, -0.03234741f, -0.01360572f, -0.02962955f, -0.03589550f, -0.05685733f, -0.00133309f, 
    -0.06413109f, -0.02070410f, 0.00355973f, -0.04558199f, -0.01029097f, 0.03758070f, -0.03807256f, -0.04343731f, 
    -0.36964998f, 0.09314099f, 0.06228741f, 0.21467352f, 0.08595257f, 0.02406766f, 0.05286286f, 0.07489237f, 
    -0.02315933f, 0.07799438f, 0.03092235f, 0.08766624f, 0.01589750f, 0.14719045f, -0.01303243f, 0.03046734f, 
    -0.02640462f, 0.00891117f, 0.02935020f, -0.08818443f, -0.14018352f, -0.38713643f, 0.00505584f, 0.04037808f, 
    0.22397819f, 0.03761804f, -0.04759942f, -0.00187179f, -0.04961967f, 0.12107543f, -0.05355529f, -0.02731637f, 
    -0.13533863f, 0.00461244f, -0.04310869f, -0.01836794f, -0.10622732f, 0.00513867f, -0.06277061f, -0.10661913f, 
    0.40536952f, -0.18971996f, -0.41780096f, 0.19098084f, -0.06005717f, 0.03006784f, -0.08936953f, 0.10020341f, 
    -0.06114766f, -0.04588153f, 0.00817050f, -0.02270732f, 0.01017218f, -0.02604366f, -0.06202476f, 0.07832161f, 
    0.05912121f, -0.00522816f, 0.05645674f, -0.00405564f, -0.12205984f, -0.02474253f, 0.15548050f, -0.06431292f, 
    0.09356566f, -0.04137753f, 0.11520977f, 0.02307986f, -0.08119077f, -0.01334005f, 0.06255772f, -0.09009858f, 
    0.21321079f, 0.03175254f, 0.02727320f, 0.08932091f, -0.03309609f, 0.03586245f, 0.04703219f, -0.08629358f, 
    -0.33682749f, -0.35147786f, 0.03452180f, 0.05945381f, 0.17632021f, 0.07262078f, -0.02761686f, -0.01903974f, 
    -0.01953658f, 0.02739253f, 0.04550629f, -0.00128200f, -0.07207026f, -0.00204638f, 0.02386609f, -0.02317603f, 
    -0.07643353f, 0.00145757f, -0.03431320f, -0.05771105f, -0.14872983f, 0.09659190f, 0.13641934f, 0.13079335f, 
    -0.01415927f, -0.12361332f, -0.03743435f, -0.12006275f, 0.03257518f, 0.10878088f, 0.06122477f, 0.00167426f, 
    -0.03528298f, 0.04185149f, 0.09771051f, -0.03045185f, 0.02632868f, -0.08957145f, 0.04553321f, 0.02467673f, 
    0.21013980f, 0.01537573f, 0.07741058f, 0.12365451f, 0.19316988f, -0.00250946f, -0.05446775f, 0.00190635f, 
    -0.01431175f, 0.04660799f, 0.05760501f, 0.11029582f, 0.03389142f, 0.05132819f, -0.02962344f, 0.01700853f, 
    0.01102781f, 0.04225875f, -0.03728279f, -0.04635595f, 0.40395084f, -0.11830696f, -0.06018951f, 0.00829741f, 
    -0.07187722f, -0.02430188f, 0.15225983f, -0.04491121f, 0.00232027f, -0.06661326f, 0.04551783f, 0.03945978f, 
    0.13491483f, -0.03354044f, 0.12398507f, -0.08640263f, -0.07229593f, -0.09055959f, 0.09158576f, -0.00991707f, 
    -0.24021028f, -0.06648038f, 0.08162676f, 0.38988563f, -0.12033702f, -0.14803696f, 0.03351370f, 0.00625824f, 
    0.07925430f, 0.06554681f, 0.09985674f, -0.06924997f, 0.03262445f, -0.11422355f, -0.10987065f, 0.06678092f, 
    -0.06824159f, 0.00006357f, 0.03894218f, 0.08540562f, 0.20677514f, -0.26851743f, 0.06087379f, 0.17530087f, 
    -0.13113169f, -0.02741057f, 0.05400630f, 0.02083102f, -0.02217962f, 0.00438885f, 0.00081226f, -0.02652594f, 
    0.11795744f, -0.08551420f, -0.07899432f, 0.07005904f, -0.11033902f, 0.01745683f, -0.08230686f, -0.08494417f, 
    0.20478396f, -0.06646043f, 0.09149243f, 0.07051159f, 0.08545043f, -0.11218677f, -0.02975566f, 0.01971343f, 
    -0.03424997f, -0.06128486f, -0.04961284f, 0.03412509f, -0.06275715f, 0.00813898f, -0.02023966f, -0.08537570f, 
    0.01046405f, -0.06352990f, -0.04867840f, -0.02293735f, -0.29322633f, 0.28558171f, 0.09928897f, 0.33393389f, 
    -0.09127262f, -0.15464029f, -0.11734926f, 0.09514128f, -0.02828955f, 0.16340178f, -0.08534462f, 0.00788685f, 
    0.00593763f, -0.01943934f, -0.11336412f, 0.00800250f, 0.05101999f, 0.07165836f, 0.02403758f, 0.05143489f, 
    -0.10541663f, 0.18145287f, -0.16332529f, 0.20289712f, -0.15089506f, 0.10041004f, -0.05239686f, -0.11072887f, 
    -0.09071608f, 0.11779062f, -0.08671419f, 0.11822329f, -0.00291447f, 0.08910995f, -0.04932004f, -0.06481013f, 
    -0.07483356f, -0.03179487f, -0.10163647f, 0.11638382f, 0.15036045f, -0.00221360f, 0.07162368f, -0.04424934f, 
    0.06721697f, -0.06310299f, 0.04085214f, -0.19974506f, -0.08929174f, 0.16545087f, -0.01693762f, -0.04257733f, 
    0.02080144f, 0.07724788f, -0.06686773f, -0.01506715f, -0.07619116f, -0.08105160f, -0.04912703f, -0.13145496f, 
    -0.31229967f, -0.13068095f, 0.15451024f, -0.02274700f, 0.02797589f, 0.01171255f, 0.04570238f, -0.01491922f, 
    0.02234790f, -0.04393197f, 0.08614261f, -0.02517299f, 0.14188160f, -0.06952993f, -0.06024455f, -0.11354819f, 
    -0.00121963f, -0.05235270f, -0.09638786f, 0.08815598f, 0.41983080f, 0.07101182f, 0.13002890f, 0.05654527f, 
    -0.06136969f, 0.03407888f, 0.10236835f, -0.03745488f, -0.04268533f, 0.02602228f, 0.07380572f, 0.04450604f, 
    0.07111366f, 0.12566268f, 0.02232978f, 0.00667120f, 0.08792731f, -0.02535567f, -0.00309771f, -0.11121819f, 
    -0.04575134f, 0.05803141f, -0.00275353f, -0.17856130f, -0.00724420f, 0.03064683f, 0.04494547f, -0.09114667f, 
    0.25451061f, 0.02507313f, 0.06563652f, 0.08060878f, -0.05813285f, 0.09745744f, -0.05267959f, -0.06567075f, 
    0.02452048f, 0.09633970f, 0.00870947f, -0.04796590f, 0.23430584f, -0.25094646f, 0.05145103f, -0.16487131f, 
    0.01611832f, -0.02166227f, 0.01277939f, -0.12553240f, 0.13004960f, 0.02900281f, -0.05918508f, -0.03500514f, 
    -0.06100274f, 0.02706162f, 0.09907035f, -0.02597018f, 0.10945670f, -0.18388261f, 0.03562034f, -0.05912072f, 
    -0.32345715f, 0.28032896f, -0.06043629f, -0.29951099f, -0.11560321f, -0.00976634f, -0.13709325f, -0.09124128f, 
    0.17443156f, -0.13580111f, -0.04337969f, -0.11126786f, 0.04345765f, 0.01965457f, -0.07380988f, 0.02872411f, 
    0.07604934f, 0.04220251f, 0.08337663f, -0.05802626f, 0.04531514f, -0.00047715f, -0.09152959f, 0.05165847f, 
    -0.09846535f, -0.04597532f, 0.15860806f, 0.15682627f, -0.15721345f, -0.00496245f, -0.05475502f, -0.04035908f, 
    0.04425004f, 0.08780526f, 0.05861858f, -0.00216348f, 0.16259424f, -0.01714484f, 0.02745719f, -0.17155172f, 
    -0.22216193f, -0.12402110f, 0.08788732f, -0.10549071f, 0.11275167f, 0.10110881f, -0.05009522f, -0.04585654f, 
    -0.08548652f, -0.07974280f, 0.00728184f, 0.05135698f, -0.00593362f, 0.02543474f, 0.16248836f, 0.07107867f, 
    0.11940405f, -0.13830253f, -0.05845410f, -0.07834741f, 0.09533564f, 0.26090893f, -0.20619561f, 0.15370704f, 
    -0.03134434f, -0.07463817f, 0.17656861f, 0.12011452f, -0.21446615f, 0.08124418f, 0.10080866f, 0.09280901f, 
    -0.05848937f, 0.10084182f, -0.00109860f, 0.01495907f, 0.00430163f, 0.15338783f, -0.10515814f, 0.06432834f, 
    0.26861516f, 0.07287324f, 0.07641364f, 0.11572524f, 0.23876111f, -0.09983161f, -0.00544125f, -0.10951886f, 
    0.00792726f, -0.09735250f, 0.02827364f, 0.01307950f, 0.00435372f, 0.10313174f, -0.07775518f, -0.12031951f, 
    -0.04266892f, 0.12894492f, 0.01936235f, -0.01905215f, 0.30378872f, 0.05125903f, -0.26151392f, 0.08366439f, 
    -0.09245459f, -0.18311870f, 0.01186155f, 0.05183161f, -0.03222793f, 0.00657400f, 0.00082481f, 0.04798456f, 
    0.00013281f, 0.13330655f, 0.07248016f, -0.06010826f, -0.03388933f, -0.07157432f, -0.07442690f, 0.04841167f, 
    0.17941207f, 0.29729059f, -0.01217999f, -0.15363313f, 0.13380736f, -0.11605018f, 0.16235618f, 0.09138674f, 
    0.14313318f, -0.10663522f, 0.01773813f, 0.08636755f, 0.06241156f, -0.16405210f, -0.00097016f, 0.04881314f, 
    0.07354753f, 0.09368414f, -0.02087340f, 0.02748891f, 0.30933160f, -0.06710411f, 0.12323834f, -0.11360753f, 
    0.09877155f, -0.11167934f, 0.01786068f, 0.04440406f, 0.22529951f, -0.04931844f, 0.12488554f, -0.07325892f, 
    0.09082020f, -0.14852667f, 0.13446678f, -0.07190831f, -0.02000627f, 0.00899944f, -0.07289661f, -0.07718047f, 
    0.17741156f, 0.04423605f, 0.08343811f, 0.00772081f, 0.15520482f, -0.15617026f, -0.04318203f, 0.00857660f, 
    0.04788389f, -0.16228306f, 0.08369098f, -0.03341240f, 0.14327441f, -0.14875938f, -0.11196946f, -0.01682583f, 
    -0.06758187f, -0.07800768f, -0.13303527f, -0.06673745f, 0.14768159f, 0.35519260f, -0.01794665f, -0.11063053f, 
    0.06509316f, 0.09469338f, 0.09008241f, 0.26398578f, -0.00499517f, -0.02708844f, -0.02061389f, 0.00148142f, 
    -0.11693852f, 0.00607238f, 0.19489552f, 0.06169848f, -0.07553543f, 0.10882213f, -0.06033486f, -0.10616848f, 
    -0.25546479f, 0.12660840f, -0.01510450f, -0.21401104f, -0.52343261f, 0.15366510f, -0.00168407f, -0.21552144f, 
    -0.14449626f, 0.06303488f, -0.16467212f, -0.01697598f, -0.10863480f, 0.10129759f, 0.09241501f, 0.02341850f, 
    -0.15254322f, -0.12650681f, -0.00368023f, 0.01694542f, 0.20821702f, -0.08693322f, 0.11359578f, 0.05041851f, 
    0.13286893f, -0.12346921f, -0.05801764f, -0.24446081f, 0.10322602f, -0.05101185f, -0.05711992f, -0.13899919f, 
    -0.05747426f, 0.08686210f, -0.10581660f, -0.13443407f, -0.11954512f, -0.16310579f, 0.21768220f, -0.07202794f, 
    -0.31285676f, -0.21067962f, -0.06792908f, -0.13668869f, 0.01499762f, -0.03205759f, 0.00778894f, 0.12837754f, 
    -0.03713732f, 0.08574492f, 0.10775242f, 0.14827566f, -0.04718833f, 0.16262956f, 0.08101216f, -0.18731903f, 
    -0.07862986f, 0.11529656f, -0.07149716f, -0.03326714f, 0.09778830f, -0.00528666f, 0.38321015f, 0.12125770f, 
    0.00284863f, -0.12926310f, 0.03143162f, -0.24054521f, 0.06662669f, -0.09621232f, 0.08682273f, -0.02498201f, 
    -0.03810222f, 0.05732814f, -0.01035212f, 0.02451680f, 0.04590096f, -0.10871404f, 0.07835247f, 0.13492249f, 
    -0.30275863f, 0.12896289f, -0.12124425f, 0.26243803f, 0.10141540f, 0.04580768f, 0.01821675f, 0.31526366f, 
    0.14662220f, 0.33712739f, 0.00348409f, 0.03802647f, -0.06088646f, 0.04890697f, 0.00070070f, 0.15131949f, 
    0.08091161f, 0.04891684f, -0.05456305f, -0.19549824f, 0.21591313f, 0.06565119f, 0.17055456f, 0.15818413f, 
    -0.05789896f, -0.13180216f, -0.03806989f, -0.25468042f, -0.11920082f, -0.17958294f, 0.02013328f, 0.01023719f, 
    -0.14585568f, -0.10258620f, 0.02909479f, -0.05168473f, 0.06033645f, 0.03088876f, 0.00140339f, -0.02545358f, 
    0.18963921f, -0.12026621f, -0.22539131f, -0.00629328f, 0.08875928f, -0.05958062f, 0.03162250f, 0.11135859f, 
    -0.02484628f, -0.18318944f, -0.03134494f, 0.09137566f, -0.03323560f, -0.01139852f, 0.02408428f, 0.16444509f, 
    0.02566255f, -0.12615496f, 0.07886920f, 0.10872009f, -0.46424907f, 0.00310081f, 0.17827897f, 0.02087330f, 
    -0.10332737f, 0.00252249f, 0.08853959f, -0.02768594f, -0.15228008f, 0.10679480f, -0.14497358f, 0.06372072f, 
    0.11458331f, 0.00005474f, -0.06141350f, -0.04932599f, 0.13317668f, -0.08349229f, 0.10627170f, 0.10115591f, 
    -0.21779369f, 0.00541094f, 0.05130788f, 0.10794214f, -0.02797649f, -0.02842848f, 0.00439140f, -0.07139226f, 
    -0.16001493f, -0.13630623f, -0.00796887f, 0.04917605f, -0.05939363f, -0.01676307f, 0.00370593f, -0.12011764f, 
    0.00554260f, -0.00365477f, -0.06252642f, -0.03628288f, -0.32983643f, 0.11566516f, 0.02803467f, 0.12608194f, 
    0.12626903f, -0.15109326f, -0.02985516f, -0.05222584f, 0.03100221f, 0.28870821f, -0.05385644f, 0.02689419f, 
    -0.05029150f, 0.04803663f, 0.00704322f, 0.08487096f, 0.16221532f, -0.21570313f, -0.22411747f, 0.02123712f, 
    -0.02401184f, -0.07761683f, -0.02452791f, 0.02619325f, 0.17770523f, -0.04783308f, -0.07779907f, -0.03001456f, 
    -0.05707884f, -0.06269620f, -0.02222791f, 0.07577281f, 0.04667931f, 0.03459827f, 0.01649943f, 0.00482329f, 
    0.01078071f, 0.14933302f, 0.00044137f, 0.07231905f, 0.24300568f, -0.03649331f, 0.14196196f, -0.12660341f, 
    -0.16249050f, -0.11986461f, -0.00979630f, -0.05682622f, 0.10702246f, 0.06709383f, 0.10569116f, -0.03628858f, 
    -0.04762661f, 0.12344344f, -0.09409574f, -0.10737323f, 0.06675080f, -0.02540646f, 0.16082314f, 0.10449140f, 
    -0.11494510f, 0.14001974f, -0.09938080f, 0.19063801f, -0.21656683f, 0.04601783f, -0.01473164f, -0.31782517f, 
    -0.01427411f, -0.09139382f, 0.21434931f, -0.07845467f, 0.09861667f, -0.18410124f, -0.07341791f, 0.20421155f, 
    0.12303423f, -0.02447031f, -0.02930645f, 0.02900433f, 0.36659667f, 0.02546697f, -0.03338200f, 0.18049878f, 
    -0.31652328f, -0.10697716f, -0.07837187f, -0.18147957f, -0.09570706f, -0.20993598f, 0.15835124f, -0.00270351f, 
    0.04002497f, -0.02916053f, 0.04573147f, 0.02079065f, 0.06282780f, 0.01003346f, -0.06867840f, 0.08706763f, 
    0.17661193f, -0.03418162f, 0.00529863f, 0.19803068f, -0.03544807f, -0.10522360f, -0.17119111f, 0.07359830f, 
    -0.19021839f, -0.13346508f, 0.01650763f, 0.06700373f, -0.06937582f, 0.04377350f, -0.02705173f, 0.05702212f, 
    -0.07506909f, 0.00073952f, -0.05433224f, 0.03068344f, -0.18110761f, 0.07009219f, 0.01062872f, 0.23821566f, 
    -0.18373549f, 0.02056018f, -0.13335951f, -0.15405336f, -0.08524457f, 0.06189820f, 0.08594077f, -0.05722494f, 
    -0.01410559f, -0.05591354f, -0.10512745f, 0.00715544f, 0.19657694f, 0.06456652f, -0.15412031f, 0.06833836f, 
    -0.02863099f, 0.06029808f, -0.35166991f, 0.01188418f, 0.08581811f, 0.10188352f, -0.11781919f, 0.14364450f, 
    -0.19918783f, 0.23166992f, -0.07576822f, 0.11418054f, -0.00378279f, -0.00970080f, -0.01933315f, 0.15071966f, 
    -0.02910405f, -0.13837846f, -0.23471667f, 0.05746364f, -0.12691350f, -0.08704678f, -0.13418677f, 0.06390625f, 
    0.00026912f, -0.19802146f, 0.02744647f, 0.00719330f, 0.00617992f, -0.05254914f, 0.04480342f, -0.01141236f, 
    -0.11115447f, -0.03487931f, -0.06827814f, 0.08838559f, 0.06747945f, 0.00787268f, -0.03554836f, -0.11634640f, 
    -0.24598059f, -0.14140956f, 0.08850322f, -0.02376257f, -0.13976879f, 0.04948344f, 0.05433711f, -0.09247833f, 
    -0.12720394f, -0.12536231f, 0.01955451f, 0.11744504f, 0.10399803f, -0.05115603f, 0.00173717f, -0.06810701f, 
    0.00608834f, 0.02132228f, 0.01482828f, 0.29638839f, 0.04905131f, -0.05010686f, 0.06548763f, 0.02360401f, 
    0.05824389f, -0.25657207f, 0.04551983f, -0.09739505f, 0.02590934f, -0.05568805f, 0.09803564f, 0.04853322f, 
    -0.01209925f, 0.01315254f, 0.03286671f, -0.02417199f, 0.09984489f, -0.03483064f, -0.01772282f, -0.01255907f, 
    -0.44779631f, -0.26899648f, -0.21666528f, -0.06650015f, 0.29494137f, -0.16364574f, -0.01303592f, -0.08260500f, 
    -0.04648644f, -0.24235711f, -0.02348562f, 0.04029595f, -0.04850940f, 0.08913209f, 0.04270141f, -0.01680671f, 
    0.04915785f, 0.12153111f, 0.09203222f, 0.04647056f, -0.06815113f, -0.52433592f, 0.11597773f, -0.11935987f, 
    -0.04478221f, 0.03898025f, -0.00386043f, 0.05119415f, -0.10557271f, 0.15317918f, 0.07277502f, 0.15671453f, 
    0.09560745f, 0.10416864f, 0.09752051f, -0.05228177f, 0.02047544f, -0.03255010f, 0.08073004f, 0.00807054f, 
    0.20128751f, -0.33777609f, -0.39677435f, -0.07585734f, -0.09713110f, 0.01766700f, 0.08121882f, 0.23081355f, 
    -0.04023339f, -0.22060183f, -0.09123849f, -0.14097559f, 0.03769225f, -0.02745102f, -0.11827733f, 0.02932161f, 
    0.02969833f, -0.11616774f, 0.01886000f, -0.16945717f, 0.02530378f, 0.09659655f, 0.08968157f, 0.08810436f, 
    0.28369907f, -0.10143036f, 0.24060225f, 0.07574584f, 0.07032162f, -0.03508965f, -0.05545232f, -0.13377228f, 
    0.15894914f, 0.07955663f, -0.01504453f, 0.15863420f, 0.15031856f, 0.04226722f, 0.23488528f, -0.12572576f, 
    -0.19396223f, -0.32628629f, 0.20410919f, -0.09507915f, 0.03501135f, -0.00420700f, -0.00616023f, 0.07011358f, 
    -0.02568620f, 0.10277199f, 0.12110119f, 0.08044276f, 0.01998870f, 0.12844056f, 0.14851305f, 0.02765576f, 
    0.06243269f, -0.14639926f, -0.00127172f, -0.00354028f, -0.27467006f, 0.11322578f, -0.44261450f, 0.25002399f, 
    0.01525039f, -0.08978402f, 0.11196083f, -0.15789190f, 0.00093908f, -0.08918889f, 0.05711053f, -0.00877571f, 
    0.00740806f, 0.06507185f, 0.10860311f, 0.01101397f, 0.00780595f, 0.16106880f, -0.05865447f, 0.08563530f, 
    0.26557353f, 0.12383132f, 0.19248775f, -0.10680075f, -0.03987177f, -0.05005191f, -0.08808234f, 0.05479338f, 
    0.01430591f, -0.00794093f, -0.08190281f, -0.12183360f, 0.05301655f, -0.06635136f, -0.07049011f, -0.07141015f, 
    0.09801140f, -0.14137366f, -0.00624809f, 0.07051194f, 0.15921633f, 0.04858455f, -0.12599264f, 0.22354753f, 
    -0.15291518f, 0.00776567f, 0.12817276f, -0.15947203f, 0.08502056f, -0.08923940f, -0.06335133f, 0.11112739f, 
    0.02750394f, 0.03636644f, 0.25227299f, -0.03625735f, -0.03505626f, -0.02351010f, 0.00644791f, 0.11014421f, 
    -0.07894295f, 0.21888295f, 0.09878255f, 0.44576824f, 0.11123185f, 0.06910715f, 0.02285344f, 0.13187255f, 
    0.02853038f, 0.19446760f, 0.02248311f, 0.01829338f, 0.06194995f, -0.06950126f, -0.10524676f, 0.19303982f, 
    0.05219828f, -0.10897163f, 0.08727293f, 0.06740543f, 0.00379283f, -0.01513280f, 0.09096426f, 0.08793968f, 
    0.07638992f, 0.03615458f, -0.04035629f, 0.14670362f, 0.10748301f, 0.22801222f, 0.00262155f, 0.03337359f, 
    0.13722989f, -0.01549635f, -0.11834238f, 0.05926572f, -0.03570577f, -0.02888978f, -0.00210595f, -0.01033237f, 
    -0.02752464f, -0.09510019f, 0.14812487f, -0.07232098f, -0.02216291f, -0.18913142f, -0.09904335f, -0.00570850f, 
    -0.02795269f, -0.20269148f, -0.14541046f, 0.11996046f, -0.05151990f, -0.00821906f, -0.03930708f, 0.02410661f, 
    0.00614107f, -0.10397372f, -0.09547004f, 0.04186966f, -0.31922793f, 0.24495254f, -0.01356530f, 0.08565558f, 
    0.12481618f, -0.16861470f, -0.07664026f, 0.09611976f, -0.06577975f, 0.06582143f, -0.03215341f, 0.04400634f, 
    0.09604411f, -0.11752781f, -0.13043647f, 0.19107626f, 0.05401178f, -0.08532301f, 0.11891067f, -0.06896252f, 
    -0.28441393f, -0.07989343f, -0.44406319f, -0.04840107f, -0.31720188f, 0.05026498f, -0.00811536f, -0.13725181f, 
    -0.06039880f, -0.24836364f, -0.00088102f, 0.00297105f, 0.04206310f, 0.08566849f, 0.07615647f, -0.00062780f, 
    -0.06442919f, 0.13732092f, -0.05733728f, -0.13200207f, 0.26708546f, -0.23895033f, -0.01106168f, -0.08575423f, 
    -0.06449093f, -0.00064729f, -0.10399514f, 0.06663480f, -0.15433180f, -0.07545950f, -0.04284960f, -0.02388340f, 
    -0.02890936f, -0.08612903f, 0.01636584f, 0.02108287f, 0.01868737f, 0.04587376f, 0.15263569f, -0.03666904f, 
    -0.25457707f, -0.14288774f, 0.19414867f, -0.08565655f, 0.03756666f, -0.16087553f, 0.11603343f, 0.00341887f, 
    -0.05258144f, 0.05833965f, 0.18993710f, 0.10751408f, 0.01093432f, 0.05308896f, 0.06372290f, -0.07099653f, 
    0.05709220f, -0.01810075f, 0.09107055f, 0.03598459f, 0.31827661f, -0.09922915f, 0.28848535f, 0.01113479f, 
    -0.10291531f, -0.01982165f, -0.02497937f, 0.09162568f, -0.02239356f, -0.05703149f, -0.02139531f, 0.07214983f, 
    0.08154090f, -0.05269282f, 0.14532007f, 0.10285787f, -0.00518728f, 0.06525648f, 0.09161168f, 0.15496041f, 
    0.23284476f, 0.29026559f, 0.18005271f, 0.08136854f, 0.18697158f, 0.23850793f, 0.28579107f, -0.00438943f, 
    0.15919544f, 0.14710408f, 0.18370344f, 0.05071853f, 0.07379179f, 0.02379198f, 0.08981310f, -0.10488810f, 
    -0.07851459f, -0.20907485f, -0.08286563f, -0.11836349f, 0.22482947f, 0.03732658f, -0.18686536f, -0.12252959f, 
    0.02305837f, 0.12073638f, -0.02181656f, 0.06856177f, 0.07424162f, 0.16041243f, -0.17850132f, -0.16333492f, 
    -0.08530185f, -0.11080138f, -0.16856357f, -0.13576163f, 0.02845888f, 0.02532573f, 0.02417534f, 0.06311657f, 
    0.36829537f, 0.20769979f, 0.23972890f, -0.02271249f, 0.31680131f, -0.13636810f, -0.09459895f, -0.19649054f, 
    0.08709989f, 0.10906386f, 0.05454972f, 0.09417473f, 0.14871693f, 0.01447240f, 0.11384626f, -0.04698370f, 
    0.08815383f, 0.21006332f, -0.00894140f, 0.01072370f, -0.04064256f, -0.03378094f, -0.00875985f, -0.11549447f, 
    0.10433026f, 0.11211114f, 0.01101802f, 0.09444375f, -0.04864831f, 0.07023322f, -0.00901681f, -0.00338167f, 
    -0.05225325f, 0.07354541f, 0.04632884f, -0.07058252f, -0.09837000f, -0.00055041f, -0.09847917f, 0.00135925f, 
    0.25209481f, -0.17494571f, -0.09412684f, -0.09740150f, -0.00226855f, 0.05963189f, -0.07398323f, 0.00934852f, 
    0.10300269f, -0.01718353f, -0.06483777f, -0.09465146f, -0.05966229f, -0.05189040f, -0.05496237f, -0.02151215f, 
    -0.04791972f, 0.08942766f, -0.08798611f, -0.01270717f, 0.01055007f, 0.12512098f, 0.13102764f, 0.08390654f, 
    0.17481752f, 0.06884716f, 0.09378061f, 0.14464112f, -0.18175769f, -0.04172545f, 0.04892641f, -0.00787200f, 
    0.05724574f, 0.02426305f, -0.05317168f, 0.00570301f, -0.06543963f, -0.04581106f, 0.11632181f, -0.01093894f, 
    0.15165016f, -0.16934371f, -0.08478371f, -0.01381819f, -0.03475578f, 0.11580006f, 0.06558224f, -0.01783166f, 
    0.00491814f, 0.02770388f, 0.06098140f, 0.27363473f, 0.07805452f, 0.09127954f, 0.04512741f, -0.01546365f, 
    -0.11074576f, -0.02978650f, -0.09213457f, -0.03882563f, -0.04145963f, 0.02153949f, -0.23244321f, -0.03353347f, 
    0.01075329f, 0.04571501f, -0.00211767f, 0.23087636f, -0.08530702f, -0.08199203f, 0.00019265f, -0.11267964f, 
    0.11562860f, -0.20336109f, -0.06093078f, -0.02041601f, -0.15724038f, 0.01757600f, -0.13742609f, -0.29288992f, 
    -0.22693288f, -0.09667569f, 0.30386829f, -0.26212600f, 0.22201693f, 0.04452123f, 0.04825168f, 0.15187883f, 
    -0.03968406f, -0.01959753f, -0.08786858f, 0.07242907f, -0.16205831f, -0.04176279f, -0.08011320f, -0.10614666f, 
    0.09241304f, 0.18957527f, 0.10734259f, -0.11465766f, -0.20688953f, 0.05510128f, 0.04280621f, -0.25010523f, 
    0.15861130f, 0.02283301f, 0.07514644f, 0.16766265f, -0.07370925f, -0.04728654f, -0.22441550f, 0.00847398f, 
    -0.01306987f, -0.14096808f, 0.00943193f, -0.06725872f, -0.03588473f, 0.02409057f, 0.03669425f, -0.08918758f, 
    0.24309924f, 0.01580697f, -0.10910332f, -0.03538988f, 0.02045374f, 0.08163194f, 0.17103109f, -0.05173708f, 
    0.09192375f, 0.08603162f, 0.13530990f, 0.08586482f, 0.09198277f, -0.10411958f, 0.00646646f, -0.27968991f, 
    -0.11526084f, -0.09402361f, -0.00718227f, -0.02621271f, 0.21529463f, 0.09700154f, 0.08901212f, -0.10929096f, 
    0.32145539f, -0.08389118f, 0.10194158f, -0.00026625f, 0.00299991f, -0.09906252f, 0.09637871f, -0.00437014f, 
    -0.02139220f, 0.14692698f, 0.07963226f, 0.05404679f, 0.08617688f, 0.17740300f, 0.00312679f, 0.07498383f, 
    -0.04541228f, 0.06704535f, 0.34642133f, 0.21401952f, 0.33238196f, 0.05487096f, 0.28776562f, -0.09561159f, 
    0.32276499f, 0.20350580f, -0.05190113f, -0.00078210f, 0.04879960f, 0.06227911f, -0.00651051f, 0.02166333f, 
    0.07485126f, -0.09752084f, 0.28380796f, 0.23851323f, 0.03472904f, 0.02204532f, 0.19877054f, -0.04140060f, 
    -0.00941943f, -0.00702048f, -0.07440246f, -0.16543707f, -0.03908144f, 0.09141495f, 0.13533643f, 0.01414535f, 
    0.12476747f, 0.02903336f, 0.03973406f, -0.15700251f, -0.02123428f, -0.09260589f, -0.08891509f, -0.12078728f, 
    0.06370531f, -0.05149398f, -0.03544008f, -0.01248343f, 0.07610376f, 0.13358891f, 0.04983960f, 0.03525674f, 
    0.09408248f, 0.08669760f, 0.02210888f, -0.04998151f, -0.01266485f, 0.00770531f, -0.01720357f, -0.02700121f, 
    -0.00964593f, 0.05420514f, -0.13134854f, -0.01450887f, -0.05852252f, -0.09316052f, -0.02358298f, 0.02283231f, 
    -0.11593857f, -0.02347305f, -0.10617714f, -0.16634978f, -0.09327307f, -0.02455413f, 0.05446022f, 0.00914908f, 
    0.08237331f, 0.03159691f, -0.01975305f, -0.08896407f, -0.04071335f, -0.11760107f, -0.03887317f, -0.14258049f, 
    -0.31088302f, -0.30261981f, -0.09522812f, 0.17113167f, 0.00787132f, 0.01646609f, 0.03521752f, 0.15946363f, 
    -0.14116398f, 0.08190079f, 0.10378754f, -0.00414623f, 0.05160131f, -0.05130039f, -0.01862861f, -0.06169827f, 
    -0.00568274f, -0.00939077f, 0.21242158f, -0.18956715f, 0.11530929f, 0.25014675f, 0.30007833f, 0.07440136f, 
    -0.03126471f, -0.02288908f, -0.04904896f, -0.15479775f, -0.13365220f, -0.13016810f, 0.08402653f, -0.07911383f, 
    -0.06515232f, -0.03956057f, -0.01131647f, -0.01490605f, -0.11866964f, -0.08373129f, 0.01033948f, 0.03151792f, 
    0.31846642f, 0.08262985f, -0.48101643f, 0.06128001f, 0.01565359f, -0.10925695f, 0.24923725f, 0.21198614f, 
    -0.04041687f, 0.06204065f, 0.02082824f, -0.01364734f, -0.01249957f, 0.04099278f, -0.04095661f, 0.11442058f, 
    0.01598759f, 0.01171828f, 0.11086305f, 0.15211168f, -0.48489347f, 0.16744530f, -0.07436790f, -0.13877715f, 
    0.06111724f, 0.03139922f, 0.08838247f, -0.06258953f, -0.03434644f, -0.06927177f, 0.17484227f, 0.11927062f, 
    0.04005964f, 0.09577671f, -0.09556930f, -0.00660321f, -0.01923153f, 0.13241784f, -0.12792909f, 0.06700227f, 
    0.12377409f, 0.17722180f, -0.03042801f, 0.20181394f, -0.01797870f, -0.01355057f, 0.00292718f, -0.01803038f, 
    -0.11767568f, 0.01330438f, 0.10345025f, -0.05622773f, 0.00672079f, -0.04600561f, 0.01262223f, 0.03074024f, 
    -0.07218118f, 0.01110449f, -0.00683777f, 0.00613034f, -0.16055472f, 0.00298628f, 0.25678161f, -0.01889042f, 
    -0.05803320f, 0.01053167f, 0.05806239f, -0.06265151f, 0.03090193f, -0.04749338f, 0.02614476f, 0.04452828f, 
    0.02794377f, 0.07824726f, 0.00981878f, 0.01024816f, 0.03544600f, 0.06402179f, -0.12000463f, -0.11205069f, 
    0.39023912f, 0.22350323f, -0.02502123f, 0.04605810f, 0.05723379f, 0.08516016f, 0.03219032f, -0.00369883f, 
    -0.06425623f, -0.02155751f, -0.05420490f, -0.12243821f, -0.00639233f, -0.06670529f, -0.04770470f, 0.00829121f, 
    -0.11452629f, -0.16186944f, 0.00566009f, 0.13576005f, 0.09117195f, 0.01629604f, 0.32933864f, -0.17511880f, 
    0.00701515f, 0.02824745f, -0.03041878f, 0.04427899f, -0.16626602f, -0.02203254f, -0.03476213f, -0.10804387f, 
    -0.02360763f, 0.01447539f, 0.08090226f, 0.08317601f, -0.07683426f, 0.09075683f, -0.17164920f, -0.14511526f, 
    -0.01077960f, -0.20102477f, 0.04126546f, -0.08645252f, -0.19581535f, -0.06077914f, 0.01654076f, -0.22235957f, 
    0.08074830f, 0.11695725f, 0.04897709f, 0.10808791f, 0.07641809f, -0.04743072f, -0.02309104f, -0.03058404f, 
    0.03030930f, -0.08149425f, 0.12345581f, 0.14264174f, 0.00306463f, 0.13542975f, 0.28914100f, 0.03822501f, 
    -0.15898308f, -0.12201486f, -0.12919903f, -0.25064525f, 0.01868511f, -0.05354638f, -0.09177472f, 0.17606622f, 
    -0.01272500f, 0.08885320f, 0.07357227f, 0.08226191f, 0.00724406f, -0.06877035f, 0.04726261f, 0.03982686f, 
    0.30909687f, 0.37674919f, 0.09483726f, 0.08088125f, 0.04715033f, 0.05789978f, -0.11629749f, 0.04102394f, 
    -0.09663446f, -0.00278841f, 0.15375045f, -0.21721105f, -0.19664933f, 0.02146660f, -0.13834390f, 0.00870893f, 
    -0.19055276f, 0.19611521f, -0.11786394f, 0.04979431f, -0.12987639f, -0.23944502f, 0.08971271f, 0.34948164f, 
    -0.13697015f, 0.04864846f, 0.00902156f, -0.13099591f, 0.03409450f, 0.13807008f, 0.11203667f, 0.08750418f, 
    0.12344461f, 0.05645527f, 0.02677808f, -0.09396486f, -0.01934467f, 0.02268110f, 0.20639290f, 0.05025959f, 
    0.09677342f, -0.05532323f, -0.13363793f, 0.14428470f, 0.15510029f, 0.21232776f, 0.17837432f, 0.09238374f, 
    -0.00795826f, 0.07909274f, 0.01003818f, -0.00040956f, -0.00044834f, 0.07981706f, -0.03998894f, -0.07412732f, 
    -0.01286565f, 0.11822233f, 0.02341812f, 0.22848962f, 0.05875614f, -0.31967840f, -0.14093676f, -0.03378914f, 
    0.14222518f, 0.06737549f, 0.18764150f, 0.05383999f, -0.04570441f, 0.00158139f, 0.02750640f, 0.01206106f, 
    0.06756427f, -0.13801011f, -0.07109816f, 0.06021950f, -0.01742497f, -0.07007106f, 0.18821220f, 0.04551007f, 
    -0.06504858f, 0.21500041f, -0.07807181f, 0.05808588f, -0.17538977f, -0.10778983f, -0.12747192f, -0.08852856f, 
    -0.01618136f, -0.06700886f, -0.06723131f, -0.00471732f, 0.06108054f, -0.02280878f, -0.01989600f, 0.03292573f, 
    0.05416968f, -0.11040439f, 0.00397183f, -0.10667986f, 0.39940932f, -0.06971674f, -0.08159398f, -0.07997173f, 
    0.08170399f, 0.05537579f, -0.02485962f, 0.10988840f, -0.04558938f, 0.06388958f, 0.08697367f, -0.08306334f, 
    -0.00364540f, -0.00503673f, 0.02204218f, -0.02903932f, 0.02614159f, 0.10137539f, 0.01710011f, 0.07921921f, 
    0.29664573f, 0.33719271f, 0.16911632f, -0.05174839f, -0.11838634f, -0.03293031f, 0.05163468f, -0.02325042f, 
    0.17933187f, -0.00371538f, -0.05379049f, 0.02581497f, 0.04735045f, 0.10685259f, -0.02195589f, 0.02282870f, 
    0.11913956f, 0.08861943f, 0.02217534f, 0.18849032f, -0.02788828f, -0.16292904f, -0.04751160f, -0.10043713f, 
    -0.13948908f, 0.04756580f, -0.01124254f, 0.07467680f, 0.19548692f, 0.05124138f, -0.09932008f, 0.01295334f, 
    -0.05524223f, 0.07839932f, 0.02769191f, -0.01435298f, 0.07395836f, 0.10368852f, -0.07301842f, 0.02132389f, 
    -0.64934653f, 0.06265436f, 0.16244401f, -0.00625263f, -0.08252537f, 0.14819698f, -0.24424663f, -0.29290235f, 
    -0.02635029f, -0.09645579f, 0.02548675f, 0.04237235f, 0.05141051f, 0.02120421f, -0.00754909f, -0.04684477f, 
    -0.00467698f, 0.01402754f, -0.04105790f, -0.02898512f, 0.29618812f, -0.09447088f, 0.17877847f, 0.09101003f, 
    -0.09022268f, 0.01330756f, -0.01749278f, 0.09540312f, -0.01249873f, 0.06596603f, -0.09877893f, -0.06736324f, 
    0.05974006f, -0.03354268f, 0.05242985f, 0.13134964f, -0.04859839f, -0.07507766f, 0.01841782f, 0.11088686f, 
    -0.16150372f, -0.09140873f, 0.12133125f, -0.13200173f, -0.05947395f, 0.06012496f, -0.08592472f, 0.04447540f, 
    0.09041256f, -0.02925782f, -0.18150271f, 0.13575236f, -0.01138692f, -0.02925115f, 0.02120421f, -0.03265143f, 
    0.04407924f, 0.18565546f, -0.06731061f, -0.00414700f, 0.21622844f, 0.20895933f, -0.09124950f, -0.02975194f, 
    -0.03524774f, 0.03156274f, 0.01247523f, 0.12679619f, 0.07513404f, 0.10303769f, -0.01385731f, -0.00143780f, 
    0.01636793f, -0.03659249f, 0.00557730f, 0.08612096f, -0.00681934f, 0.00344417f, 0.07014471f, 0.12535164f, 
    -0.47480476f, -0.19042963f, 0.01077590f, -0.04912534f, -0.13458301f, -0.00317357f, 0.04259331f, -0.09205721f, 
    0.05081660f, -0.05875504f, 0.02608843f, 0.05132316f, 0.08264636f, 0.09867362f, 0.14808773f, -0.08687890f, 
    -0.02190358f, 0.17766123f, 0.09299536f, -0.03219648f, -0.04013850f, -0.15276234f, -0.18432403f, 0.01619115f, 
    -0.00240809f, -0.04702977f, 0.11449013f, 0.02727590f, 0.15970285f, 0.06917442f, -0.13472623f, 0.05541609f, 
    0.04127732f, -0.02075543f, -0.05283195f, -0.03899098f, 0.09585071f, 0.05613083f, 0.11296792f, 0.15119159f, 
    0.26273602f, 0.39156589f, 0.19379516f, 0.03529394f, 0.17164575f, -0.00360051f, 0.15655449f, 0.10551134f, 
    0.06299127f, -0.08112583f, 0.05041165f, -0.09177550f, 0.00170647f, -0.03343648f, 0.02352021f, 0.10941982f, 
    -0.03653417f, -0.01417450f, -0.09857733f, -0.04368338f, 0.21289459f, 0.02144980f, -0.24324605f, -0.01635271f, 
    0.03710850f, 0.01523576f, -0.01625088f, 0.11633290f, 0.03032810f, 0.02962160f, 0.18312630f, -0.13430299f, 
    -0.03967806f, 0.04545816f, 0.10638256f, 0.00997732f, -0.07655681f, 0.06266752f, -0.01619234f, -0.00732353f, 
    -0.25866675f, -0.32724816f, -0.12305626f, -0.03199581f, -0.12071247f, 0.01987690f, 0.12700255f, -0.04185044f, 
    -0.00448412f, 0.03732873f, -0.05017832f, 0.15436333f, 0.03239721f, 0.04435709f, 0.11925620f, -0.08520820f, 
    0.02897462f, -0.03437306f, 0.11823861f, -0.01662686f, 0.08515920f, 0.35589188f, 0.13067114f, -0.12938938f, 
    0.02876081f, 0.13545461f, 0.19379643f, 0.21956827f, 0.08837919f, 0.06296944f, 0.04631040f, -0.11016299f, 
    -0.08222435f, -0.04073723f, -0.05212917f, 0.08402638f, -0.01032487f, 0.02945569f, -0.19084539f, 0.03832507f, 
    -0.07815267f, 0.27681121f, 0.05938087f, -0.13431382f, -0.32009283f, 0.09681362f, -0.04492348f, 0.16684587f, 
    -0.05709040f, 0.03116214f, 0.08014763f, 0.02792319f, -0.07931492f, -0.05610259f, 0.06251083f, 0.11644973f, 
    0.04386425f, -0.03199005f, -0.14583768f, -0.22923149f, -0.27645421f, 0.08737706f, 0.04988891f, 0.07943856f, 
    -0.13252151f, -0.10780745f, -0.23814355f, 0.06788591f, 0.02596555f, -0.18080594f, -0.00028124f, 0.01978821f, 
    0.02298063f, 0.12593827f, 0.02399168f, -0.05506974f, -0.05677771f, 0.08135836f, -0.00876917f, -0.01659519f, 
    0.01242024f, -0.19026339f, -0.04098844f, -0.02608255f, 0.00790378f, 0.00176521f, 0.03821794f, 0.07582842f, 
    0.01993101f, 0.17183775f, -0.03758839f, 0.06311433f, -0.03927569f, 0.04396719f, -0.03947560f, -0.07425483f, 
    0.07372946f, 0.12921911f, 0.03379285f, 0.12801920f, -0.42800421f, -0.05785028f, 0.00773962f, -0.00033641f, 
    -0.17501901f, -0.05713766f, -0.11064701f, -0.13424163f, -0.01207249f, -0.11790233f, -0.05448836f, 0.03187751f, 
    0.02747362f, 0.06664455f, -0.00029843f, 0.00680334f, 0.00332472f, -0.02956597f, -0.01436602f, 0.01198799f, 
    -0.04048445f, 0.00798297f, 0.04530801f, 0.02284538f, -0.00034253f, -0.03355926f, 0.03076094f, 0.01323326f, 
    -0.05644408f, 0.03602143f, 0.03605084f, -0.01860214f, -0.03933862f, 0.02277770f, -0.01894259f, -0.00187228f, 
    -0.02713464f, -0.05092424f, 0.01086942f, -0.04434613f, 0.00538784f, -0.05793370f, -0.01280187f, -0.00150640f, 
    -0.05264132f, -0.04689053f, 0.01084216f, 0.02207366f, -0.03367859f, -0.04614376f, -0.05029126f, -0.00215096f, 
    0.04008723f, -0.00791265f, 0.01640316f, -0.04938433f, -0.04359185f, -0.01429893f, 0.00151090f, -0.01246509f, 
    0.04645758f, 0.00860176f, 0.02373347f, -0.04684426f, 0.01983121f, -0.04185561f, 0.02959998f, -0.01465543f, 
    0.01408646f, -0.00342217f, 0.00991558f, 0.00901236f, -0.01656633f, -0.04462364f, 0.00285492f, -0.02490528f, 
    -0.03700827f, 0.03196098f, 0.01329606f, 0.00927076f, -0.05493180f, -0.03852820f, 0.00005346f, -0.00474804f, 
    -0.00451430f, 0.02352278f, -0.02058003f, 0.01141975f, 0.02403951f, -0.05575442f, 0.00416265f, 0.01000511f, 
    0.02729116f, -0.01580701f, -0.05801751f, 0.01270630f, -0.01098465f, 0.01080485f, -0.01468866f, -0.04045495f, 
    0.00102019f, 0.02214610f, -0.05210977f, -0.01472957f, 0.01103262f, -0.02754493f, -0.03864999f, 0.02985575f, 
    0.03503210f, -0.01757605f, -0.05008586f, -0.06074719f, 0.01352909f, 0.00117260f, -0.01440669f, -0.05309181f, 
    -0.01683231f, 0.02282681f, -0.04330295f, -0.00923650f, 0.00666836f, -0.00525404f, 0.02496159f, -0.06068583f, 
    0.01650931f, 0.02624942f, 0.03583217f, -0.04506104f, -0.03410548f, -0.06160800f, -0.05775476f, 0.03053536f, 
    0.01937958f, 0.02144752f, 0.01169724f, -0.05345421f, -0.01423360f, -0.04709803f, -0.00586631f, -0.02754619f, 
    -0.00477407f, 0.02451492f, -0.00678063f, 0.00555312f, 0.04595889f, -0.00996927f, 0.01462645f, 0.01519191f, 
    0.03253990f, 0.02622267f, -0.00309743f, -0.04939812f, -0.02093726f, -0.01317860f, -0.05191251f, 0.01016991f, 
    -0.01967845f, 0.02252907f, -0.00344481f, -0.02480930f, -0.03180467f, 0.02458576f, -0.01339816f, -0.01271661f, 
    0.02702532f, 0.02032351f, 0.02011315f, -0.01447343f, 0.02245429f, -0.02900610f, -0.01875151f, 0.04581640f, 
    -0.02582683f, 0.00783804f, -0.01383140f, 0.02426649f, 0.04345356f, -0.05728439f, 0.04205635f, 0.04174938f, 
    -0.01591052f, -0.00357122f, -0.04980607f, 0.01623159f, -0.02020432f, 0.00432032f, 0.04528590f, -0.01027176f, 
    0.02643767f, -0.02503812f, -0.04203877f, -0.00946351f, -0.01970927f, 0.01414706f, 0.04300954f, -0.04860220f, 
    -0.05981191f, -0.03178276f, 0.03794879f, -0.02438179f, 0.00394030f, -0.04765413f, -0.06187021f, -0.01289176f, 
    -0.03195744f, 0.03566733f, -0.02246259f, 0.03804274f, -0.02168892f, -0.02273565f, 0.03872631f, -0.02584628f, 
    0.03714842f, -0.05661080f, 0.04786630f, -0.00634830f, 0.01123488f, 0.04488647f, -0.01665061f, 0.03161462f, 
    0.02590570f, 0.03820739f, 0.02195226f, -0.00210591f, 0.05878784f, -0.01024417f, -0.01263512f, -0.02486257f, 
    0.00657343f, -0.01124845f, 0.03954290f, -0.00326123f, -0.02373968f, 0.05553304f, 0.03588161f, -0.01774705f, 
    0.01000538f, -0.02871676f, 0.00659911f, 0.02991563f, 0.00934363f, -0.01631663f, -0.04001493f, -0.02694608f, 
    0.01959068f, -0.01998739f, -0.03696705f, 0.02689802f, -0.02015335f, -0.00012180f, -0.03597532f, -0.04786924f, 
    0.02134442f, 0.02328223f, 0.00621877f, -0.01225055f, -0.03684640f, -0.02216409f, -0.00894897f, 0.01367654f, 
    -0.04135829f, -0.04060191f, -0.05674344f, 0.02923104f, -0.01291197f, 0.01380800f, 0.00274061f, -0.04164818f, 
    0.00234121f, -0.06121755f, 0.04549638f, 0.01277688f, -0.05352005f, 0.00471118f, -0.02352908f, 0.04788005f, 
    -0.00003218f, -0.02427816f, -0.04802939f, -0.03702389f, -0.00875098f, -0.04319970f, -0.01542962f, -0.01167476f, 
    0.04211792f, -0.03652474f, -0.01237918f, 0.00032826f, -0.04889941f, -0.03092415f, -0.04662513f, -0.02180484f, 
    0.00259119f, -0.03057759f, -0.03868633f, -0.05773691f, -0.05044515f, -0.00249464f, 0.03926854f, -0.02552719f, 
    -0.05439345f, -0.03754083f, -0.03466104f, -0.05659835f, 0.04619877f, 0.04889576f, -0.04104120f, 0.03408172f, 
    0.00056751f, -0.02442718f, 0.00010063f, -0.00006357f, 0.04680413f, 0.03050665f, -0.00576213f, 0.01855749f, 
    -0.05322893f, -0.05765988f, 0.05111225f, -0.03060881f, -0.00728568f, -0.02559140f, -0.02428443f, -0.03034369f, 
    0.03334144f, 0.04441293f, 0.03102871f, -0.01186216f, -0.03794024f, 0.03099362f, -0.02080069f, -0.04189713f, 
    -0.05391875f, 0.00921302f, -0.01518109f, -0.01971658f, 0.04048643f, -0.00917383f, -0.05429584f, -0.05197228f, 
    0.02780597f, 0.04757702f, 0.01783748f, -0.05533935f, 0.02490690f, -0.05021849f, 0.02189081f, 0.00573102f, 
    0.01345170f, 0.00867643f, -0.04032614f, 0.00747370f, 0.00158027f, -0.02769239f, -0.01895429f, -0.03005766f, 
    0.02816658f, -0.02183221f, -0.01781527f, -0.03520201f, 0.02391920f, -0.00635314f, -0.03755891f, -0.05508046f, 
    -0.00383368f, -0.05418878f, -0.02677342f, -0.05490473f, 0.03610533f, 0.03869860f, -0.02186380f, -0.01581468f, 
    -0.04119210f, -0.05928923f, -0.05969172f, -0.00942930f, 0.02715459f, 0.00383974f, 0.02823830f, -0.02091463f, 
    0.04647290f, 0.04027680f, -0.05093757f, 0.01811123f, -0.02917777f, 0.00232649f, -0.02792165f, -0.02745366f, 
    0.04564784f, -0.04307702f, -0.01745623f, 0.00752852f, -0.05137479f, -0.00642264f, 0.02577857f, 0.02389280f, 
    0.00616471f, -0.04224494f, -0.00663560f, 0.03615611f, 0.04959683f, -0.02260693f, -0.01133938f, 0.00940116f, 
    0.02492869f, -0.00222548f, 0.01433565f, -0.00520051f, -0.05660964f, 0.02783042f, 0.03740808f, 0.04271976f, 
    0.01446223f, -0.00956518f, -0.00543302f, 0.04123437f, 0.00601986f, 0.00015804f, -0.01577540f, 0.02515939f, 
    -0.02550597f, 0.00980246f, 0.03023849f, -0.03770500f, -0.04660075f, 0.04557231f, 0.02104722f, -0.01136243f, 
    0.04629342f, 0.00984949f, 0.01090348f, -0.03287823f, 0.04900258f, -0.04451473f, 0.03020792f, -0.03909190f, 
    0.04412150f, -0.05623308f, 0.01551994f, -0.01063406f, -0.01147861f, -0.03776599f, 0.04753395f, -0.06023166f, 
    0.00651789f, -0.03595591f, -0.04223219f, 0.04946487f, -0.02953513f, 0.01134304f, -0.05556617f, -0.00001805f, 
    0.01843233f, -0.03457309f, -0.03991887f, 0.00553194f, 0.00170398f, 0.03062321f, -0.04910641f, 0.00639207f, 
    0.02521263f, -0.00667720f, 0.01399869f, 0.02816968f, -0.02220725f, 0.01536833f, 0.03195599f, -0.05202067f, 
    0.02282026f, -0.05699711f, -0.05065111f, 0.00329489f, -0.02459778f, 0.01695867f, 0.02703526f, 0.01578212f, 
    0.01107886f, 0.00069512f, -0.05282850f, -0.04412227f, 0.02796537f, -0.04363603f, -0.04093513f, 0.00055644f, 
    -0.01698345f, -0.05792546f, -0.03530300f, 0.00016313f, 0.01439894f, -0.04734576f, -0.02660307f, -0.02101602f, 
    0.02540747f, -0.04999370f, 0.02264694f, 0.03057162f, -0.05568289f, 0.00068092f, 0.02329233f, -0.02414009f, 
    -0.05525398f, -0.05594422f, -0.01557431f, 0.04239761f, 0.03952247f, 0.00560030f, -0.05856532f, 0.02889219f, 
    -0.03546468f, 0.02285172f, -0.01188086f, 0.00557578f, -0.05598072f, -0.00304624f, -0.03551716f, -0.05371303f, 
    0.03480434f, 0.02880236f, 0.01440414f, -0.00562007f, -0.00336435f, 0.04132460f, -0.04802434f, -0.05214866f, 
    0.04918514f, -0.04529297f, -0.02335187f, 0.03449148f, -0.05114150f, -0.00376193f, 0.00023532f, -0.02513858f, 
    -0.02671047f, -0.04218265f, -0.05129979f, 0.02741536f, 0.02884556f, 0.02146104f, -0.00353494f, -0.03585397f, 
    -0.04681834f, -0.04626108f, 0.01972800f, 0.05298679f, -0.03744304f, -0.02736007f, -0.03002724f, 0.04222655f, 
    0.04525856f, 0.01340439f, -0.05871777f, 0.02162306f, -0.05502670f, 0.01878860f, 0.02017304f, 0.01762053f, 
    -0.03108443f, 0.04186064f, -0.01908548f, -0.01956899f, 0.00969772f, 0.00810770f, -0.00029501f, 0.04897688f, 
    0.00698069f, 0.03797108f, -0.04589815f, -0.00768336f, 0.04629658f, 0.02391108f, -0.05457561f, 0.01348652f, 
    -0.04639713f, -0.04107177f, -0.03953897f, 0.03496948f, -0.03464302f, -0.03829302f, 0.00782795f, -0.01231420f, 
    0.00301982f, -0.05903472f, -0.00832988f, 0.04086452f, -0.03520209f, -0.02734688f, 0.04943118f, -0.00730050f, 
    0.02594674f, 0.03290739f, -0.04823272f, -0.05339161f, -0.05685907f, -0.01537050f, 0.02357490f, -0.05412298f, 
    0.04692229f, -0.02721503f, -0.04661163f, -0.04916503f, -0.05050219f, -0.04706347f, -0.02112678f, -0.05256945f, 
    -0.02546742f, -0.01484364f, -0.03882594f, -0.02342958f, -0.01158409f, 0.02210585f, 0.00060854f, 0.00169255f, 
    -0.04758949f, 0.04082638f, 0.01458808f, -0.05485516f, 0.00576234f, -0.03223028f, 0.04898177f, -0.04546973f, 
    -0.04879493f, -0.01699928f, -0.02785617f, -0.04338415f, 0.02395405f, -0.03057227f, 0.03820488f, 0.02195342f, 
    -0.02948896f, -0.04902678f, 0.02900565f, 0.01190406f, -0.00627480f, -0.02998303f, 0.04831170f, -0.05107743f, 
    -0.00053230f, -0.01177365f, -0.00721166f, 0.00815811f, -0.04999974f, 0.04110318f, 0.02621938f, -0.02258248f, 
    0.02113399f, 0.02864614f, 0.03407051f, -0.05431158f, -0.05041629f, -0.05582630f, 0.02288649f, 0.04918843f, 
    -0.01850639f, 0.04950232f, -0.04512469f, 0.01541755f, -0.02603293f, 0.01144859f, -0.02707806f, -0.04524023f, 
    -0.13224965f, -0.15505926f, 0.00587922f, 0.19133921f, 0.07970715f, 0.04435824f, 0.03297988f, 0.11136527f, 
    -0.12864007f, -0.06131306f, -0.08713192f, 0.05602497f, -0.07548660f, -0.01540719f, 0.05068846f, -0.02181479f, 
    0.07508357f, -0.01098779f, -0.03309599f, 0.21880594f, 0.18644173f, 0.13408303f, 0.08732732f, 0.04275000f, 
    -0.11551779f, 0.09244429f, -0.21193142f, 0.09029334f, -0.09425870f, 0.05866197f, 0.03497710f, 0.07690483f, 
    -0.02717388f, 0.03763894f, 0.04155728f, -0.13621216f, 0.01657860f, 0.11804950f, 0.02429814f, 0.01880513f, 
    0.15506749f, -0.26531115f, 0.42077449f, 0.13795593f, 0.23919988f, -0.13097209f, 0.13180785f, 0.04695203f, 
    -0.14720295f, 0.12519661f, -0.02845846f, 0.13646014f, -0.07558393f, -0.02219307f, 0.02544108f, -0.07050008f, 
    -0.12839650f, -0.03206169f, -0.16588785f, 0.11037624f, 0.03520582f, -0.10759343f, 0.21924859f, 0.05889727f, 
    0.14892119f, 0.01631100f, -0.03572164f, -0.07203781f, 0.25145140f, 0.21834216f, -0.04029088f, 0.04784945f, 
    0.00994714f, 0.01978751f, -0.05955628f, 0.15012991f, 0.04857896f, 0.04303965f, 0.02980068f, 0.25534034f, 
    0.24419433f, 0.11180133f, -0.01098774f, -0.03594798f, -0.14021377f, -0.06243397f, 0.00367501f, 0.03778256f, 
    0.03140607f, 0.07731780f, 0.07198467f, 0.03612471f, -0.02204907f, 0.01518440f, 0.02891029f, -0.16339794f, 
    -0.05505248f, 0.16702482f, 0.09141389f, -0.02055249f, -0.13611351f, -0.05762401f, 0.10499161f, 0.06886762f, 
    0.07275230f, 0.03768317f, 0.06166703f, -0.04266621f, 0.27497858f, -0.00026784f, -0.15229487f, -0.05978347f, 
    -0.01841265f, -0.02175384f, -0.07893861f, 0.04228651f, -0.00999877f, -0.09899086f, 0.05189897f, -0.00309171f, 
    -0.07431008f, -0.22980081f, -0.02846417f, -0.04059178f, -0.18686129f, -0.11041958f, -0.23031962f, 0.01445295f, 
    0.07673777f, -0.02686949f, -0.02037753f, 0.09887277f, -0.01638068f, -0.03811216f, 0.19132271f, 0.05464849f, 
    0.01136649f, 0.03421326f, -0.01254529f, 0.05892862f, -0.21619387f, 0.04489459f, 0.14103469f, -0.01661434f, 
    0.10783723f, -0.00897468f, 0.04032128f, -0.10267493f, 0.11077391f, 0.03074268f, -0.03595644f, -0.10983354f, 
    0.11915030f, -0.05613044f, -0.06597438f, 0.17595327f, -0.01870911f, 0.07125191f, 0.12017087f, -0.00281953f, 
    -0.52261186f, 0.09460581f, 0.22704428f, 0.36401528f, 0.06719355f, 0.26157427f, 0.02373585f, -0.02012401f, 
    -0.11212774f, 0.09207983f, -0.19474533f, -0.08273499f, 0.00909385f, 0.13485725f, 0.12890291f, 0.05044478f, 
    -0.20459671f, -0.03624108f, 0.00542735f, 0.05849441f, -0.49723902f, 0.32609820f, 0.08784197f, 0.12778309f, 
    0.07018200f, 0.20983256f, 0.02829579f, -0.04954566f, -0.15821448f, 0.12945762f, -0.10141192f, 0.15377292f, 
    -0.04198232f, 0.21870454f, 0.06754859f, 0.03214630f, -0.10586507f, -0.04644755f, -0.07052350f, 0.12953579f, 
    0.12891434f, -0.23919895f, -0.16992547f, -0.06742004f, -0.06455136f, -0.12667064f, -0.06125960f, -0.08588316f, 
    -0.07400224f, 0.04301927f, 0.02556312f, 0.01707130f, -0.06546403f, 0.04081103f, 0.06644222f, 0.03544721f, 
    0.06194317f, 0.05086781f, 0.09282822f, -0.07015169f, -0.28539217f, -0.12295800f, 0.04359325f, 0.14311521f, 
    0.04574160f, -0.00770139f, 0.02144974f, -0.08970762f, 0.06490819f, -0.02617645f, 0.01165809f, -0.05761702f, 
    -0.01521197f, -0.16317469f, -0.13544099f, 0.04827749f, 0.10849411f, 0.06351037f, 0.00080042f, 0.12382194f, 
    0.19223243f, -0.25586763f, 0.03024256f, 0.04455406f, 0.38978079f, -0.06660429f, 0.08428368f, 0.25925165f, 
    0.04288597f, -0.07100081f, 0.06839900f, 0.11094705f, -0.02223656f, -0.10076986f, -0.06191850f, 0.06845172f, 
    -0.03706523f, -0.06142034f, 0.01937312f, -0.17664339f, -0.03147598f, -0.02418835f, 0.01944011f, -0.18454644f, 
    -0.07709287f, 0.05543042f, 0.06360349f, 0.32814771f, -0.06418230f, -0.01085174f, -0.06925389f, -0.01871788f, 
    0.00742636f, -0.02158588f, -0.05324423f, 0.03317997f, -0.09860712f, 0.13206518f, -0.19601446f, 0.02874677f, 
    0.01813430f, -0.08736260f, -0.02516753f, 0.10200563f, 0.05968260f, 0.07695407f, 0.01500593f, -0.05588026f, 
    -0.06953146f, -0.01140774f, -0.02195852f, -0.04197279f, 0.02071360f, -0.05039740f, 0.07505188f, 0.15071836f, 
    0.02327887f, 0.02203219f, -0.06102517f, 0.01518125f, 0.11131219f, 0.12866186f, -0.05507342f, 0.08479694f, 
    0.09365442f, 0.01955709f, -0.00726290f, 0.13892655f, 0.02175041f, -0.07488481f, -0.09320399f, 0.02737258f, 
    -0.02882925f, 0.04340950f, -0.04791403f, 0.13913126f, -0.05063000f, 0.14676178f, 0.01560026f, -0.10945947f, 
    0.27482176f, 0.11157542f, 0.28485718f, -0.27880928f, -0.07817078f, -0.02420228f, -0.00459805f, -0.10606930f, 
    0.15569775f, -0.09595934f, -0.04609900f, 0.06520814f, 0.03753258f, -0.01534695f, 0.04043941f, -0.08294959f, 
    -0.05650651f, 0.01045173f, 0.01770441f, 0.19530857f, -0.11317086f, 0.04699940f, -0.32308570f, -0.07725985f, 
    -0.14503375f, -0.04958302f, 0.07274453f, -0.01639671f, 0.10444292f, -0.01754809f, 0.07069750f, 0.06765194f, 
    0.03558760f, 0.08154698f, 0.12061490f, -0.08426702f, 0.04119387f, 0.08765402f, 0.05147883f, 0.07493204f, 
    -0.34369370f, 0.19865723f, 0.53569943f, -0.01122492f, -0.18023466f, 0.00922834f, -0.13975249f, -0.16603659f, 
    0.05035751f, -0.04529262f, -0.07980917f, -0.02656538f, -0.04926375f, 0.00867992f, -0.06382623f, -0.13037390f, 
    0.02320591f, 0.11098599f, -0.12877998f, -0.04721054f, 0.18908304f, 0.06885567f, -0.04634923f, 0.20037168f, 
    -0.03889950f, 0.11946413f, -0.10414401f, -0.01001840f, 0.09053091f, 0.16025873f, -0.04368638f, 0.07348176f, 
    -0.09333941f, 0.00158493f, 0.02248094f, 0.07772161f, -0.02040802f, -0.13374020f, 0.04624785f, 0.16570064f, 
    -0.08375251f, 0.14895552f, -0.08333197f, -0.13521400f, 0.01877077f, -0.07316504f, 0.02912545f, -0.05921947f, 
    0.03823340f, -0.09253272f, -0.05112270f, 0.14171194f, -0.01427576f, 0.03156951f, 0.03323260f, -0.06324578f, 
    0.16359311f, 0.05528302f, 0.04108355f, 0.06142505f, 0.33632976f, 0.14335524f, -0.01774978f, -0.05294229f, 
    -0.02576748f, 0.15695548f, 0.02299114f, 0.00825950f, 0.01909449f, 0.10684164f, 0.02778539f, -0.01804516f, 
    0.06775729f, 0.00969421f, -0.01016051f, -0.03070279f, -0.09109318f, 0.05516661f, 0.06185333f, 0.15654624f, 
    -0.26539949f, -0.00682349f, 0.01398534f, 0.12224956f, -0.09034675f, -0.03733573f, -0.05548251f, -0.12423659f, 
    -0.10201991f, 0.00155825f, -0.01453377f, 0.01147876f, -0.06835395f, 0.05972842f, 0.03113804f, 0.02459263f, 
    0.10906397f, 0.09807264f, 0.04926826f, -0.15152694f, -0.10885810f, -0.07610085f, -0.17472014f, 0.06917869f, 
    0.07211617f, 0.00015077f, 0.07496753f, 0.02447644f, 0.05088704f, 0.06551356f, 0.08818386f, 0.16466446f, 
    -0.07678881f, -0.09618611f, -0.05488850f, 0.07285757f, 0.14220420f, 0.07038748f, 0.09049841f, 0.21352491f, 
    0.08247627f, 0.24847648f, -0.04407607f, -0.21855555f, 0.16892703f, 0.20314655f, 0.09428697f, 0.17485292f, 
    -0.04073144f, -0.07053117f, 0.02790910f, 0.02604998f, 0.00816134f, 0.07788803f, 0.07849137f, -0.04248499f, 
    -0.13887301f, -0.13674307f, -0.02753502f, -0.00539287f, -0.03732710f, -0.09681176f, -0.43626216f, -0.24008115f, 
    -0.13242210f, 0.11871452f, 0.09655827f, 0.23497178f, 0.08404642f, 0.13691869f, 0.17283870f, 0.02752142f, 
    0.07117986f, 0.06186509f, 0.04323453f, -0.05560372f, 0.00583503f, 0.02561602f, 0.04315485f, 0.06283059f, 
    -0.09027875f, -0.11526970f, 0.03717428f, 0.10484765f, 0.04730487f, -0.08659066f, 0.00732174f, -0.14534236f, 
    -0.02236097f, -0.00702349f, -0.04538465f, 0.01632890f, 0.00295865f, 0.02840035f, 0.10872950f, 0.01013907f, 
    0.19473751f, 0.07160617f, 0.07528097f, -0.06561558f, 0.08834483f, 0.11484855f, 0.01339048f, -0.26458097f, 
    -0.04408775f, 0.23274334f, 0.13548960f, 0.17485803f, 0.10596228f, -0.02297102f, 0.01974305f, -0.02570846f, 
    0.03364576f, 0.05335441f, -0.04902272f, 0.03513534f, -0.06821073f, -0.07211793f, -0.05224780f, -0.00254806f, 
    0.17697699f, 0.19416685f, 0.17845355f, -0.09557360f, -0.20502926f, 0.01822036f, -0.02265564f, 0.10787767f, 
    -0.00881620f, -0.07600260f, 0.06316338f, 0.00385628f, 0.03269583f, 0.02266931f, -0.00627298f, 0.12823234f, 
    -0.06821755f, -0.12046795f, -0.12951708f, -0.20830725f, -0.11959893f, 0.21792191f, 0.06278707f, 0.09107125f, 
    -0.06188665f, 0.01357879f, -0.15199132f, -0.10636949f, 0.03282248f, -0.14382112f, 0.05512987f, 0.13655244f, 
    -0.04848062f, 0.02963741f, -0.03830425f, -0.00056596f, 0.00992920f, 0.08540247f, -0.07340543f, 0.06343436f, 
    -0.02026038f, -0.16901433f, -0.10207106f, -0.08932113f, -0.05946230f, 0.04706113f, -0.01037888f, 0.03978121f, 
    -0.03925447f, -0.02923203f, 0.08216988f, 0.12238178f, -0.02919706f, 0.01881816f, 0.00145622f, -0.00434030f, 
    0.04931549f, 0.09864078f, 0.10412967f, 0.09722079f, -0.24740176f, 0.14584497f, 0.06236330f, 0.16195038f, 
    0.06902973f, -0.06539979f, -0.10535660f, -0.05824989f, 0.02022467f, -0.00439855f, -0.08387244f, 0.14117768f, 
    -0.03071591f, 0.05517297f, -0.08263293f, 0.10154103f, 0.04509546f, 0.10818834f, 0.05290565f, 0.00054357f, 
    -0.09435754f, -0.13699396f, 0.16464016f, -0.04536064f, -0.12478381f, -0.08427071f, -0.07361516f, 0.10894767f, 
    0.08237340f, -0.18280369f, -0.04630179f, -0.04852505f, -0.06232883f, 0.07953696f, 0.09675593f, 0.04266995f, 
    0.10364241f, 0.18800205f, 0.13387619f, 0.05098701f, -0.44534984f, -0.05508471f, -0.25758377f, 0.07886239f, 
    -0.21763274f, -0.19636096f, -0.05243341f, -0.15579778f, 0.02721104f, -0.07619175f, 0.20408732f, 0.09618315f, 
    -0.00661350f, 0.05585782f, 0.21980155f, 0.04073999f, -0.04152352f, 0.02332539f, -0.01043072f, -0.14281942f, 
    -0.43492490f, -0.20199482f, -0.09710747f, 0.15624973f, -0.32140708f, 0.12715979f, -0.08094557f, -0.12164499f, 
    -0.18631129f, 0.06367169f, -0.04995846f, 0.01602842f, 0.07394040f, 0.07349411f, -0.08823200f, -0.07605311f, 
    -0.02161498f, -0.02934446f, 0.04007153f, -0.00951823f, 0.14326224f, -0.05204106f, -0.03335778f, 0.15546378f, 
    0.06762865f, 0.23875521f, 0.11376569f, 0.03933093f, 0.16243450f, 0.15636043f, 0.01914132f, 0.03967458f, 
    0.09993359f, -0.04812517f, 0.06865823f, 0.27724195f, -0.01468274f, 0.05847257f, -0.05084961f, 0.42570984f, 
    -0.47549072f, 0.24909198f, -0.19594786f, 0.08024123f, -0.01824655f, -0.05897454f, -0.07366791f, -0.11689364f, 
    -0.04664400f, 0.04006918f, 0.05064772f, 0.05533656f, 0.04269033f, -0.02494411f, 0.06024562f, 0.05654713f, 
    0.08706693f, 0.11317700f, 0.05168137f, 0.00787244f, 0.15232909f, -0.06859726f, 0.06124136f, 0.04241349f, 
    -0.02284312f, 0.11155068f, 0.16267547f, 0.04762092f, 0.09158145f, 0.13192894f, 0.11171881f, -0.11132112f, 
    -0.04473962f, -0.08126830f, 0.06810920f, 0.01883308f, 0.08194427f, 0.05081824f, -0.07542594f, 0.16701724f, 
    -0.46701133f, 0.10516346f, -0.11406141f, -0.08477425f, -0.15035050f, -0.29259241f, -0.30872133f, -0.10932984f, 
    -0.13254499f, -0.01348508f, 0.00728672f, 0.04992872f, 0.02618376f, -0.09435154f, 0.05285723f, -0.14531507f, 
    0.11721350f, -0.11454505f, 0.10397962f, 0.08246024f, 0.08948202f, -0.07719135f, 0.05992839f, -0.15173307f, 
    0.05330475f, -0.03511709f, 0.19321899f, -0.04272149f, 0.02181148f, -0.01682765f, 0.04153150f, 0.04962460f, 
    0.09463754f, 0.14416231f, 0.15052141f, 0.15378059f, 0.14679281f, 0.07823198f, 0.06807365f, 0.20573491f, 
    0.07512324f, 0.14003827f, -0.21618718f, 0.10892119f, -0.05290518f, 0.09181286f, -0.10150225f, -0.02862958f, 
    -0.03332571f, 0.02821756f, 0.09004154f, -0.05417985f, 0.08442515f, 0.08499305f, 0.02416092f, 0.18461159f, 
    -0.23788774f, -0.24344428f, 0.00898209f, 0.13035744f, 0.13401181f, -0.12399503f, -0.14010178f, 0.04500982f, 
    -0.14435822f, 0.08982220f, -0.00020261f, -0.03476204f, 0.01507551f, 0.08923840f, 0.21740149f, -0.02643894f, 
    0.05992628f, 0.02531512f, 0.10968126f, 0.03286966f, -0.14731294f, -0.14064384f, 0.00616005f, 0.09758946f, 
    -0.21171167f, 0.01919523f, 0.09925284f, -0.04208835f, 0.04064550f, -0.30946064f, -0.28794029f, -0.22356768f, 
    -0.23724994f, -0.18663996f, -0.07722387f, 0.07916013f, -0.05404872f, -0.01962339f, 0.05163006f, 0.07408679f, 
    0.08561053f, -0.13115898f, -0.09868159f, 0.05881011f, -0.37978545f, 0.05976233f, -0.16945577f, 0.07287766f, 
    -0.29631343f, 0.08022965f, 0.16789275f, 0.17144477f, 0.12834902f, 0.18499261f, 0.05290619f, -0.09594104f, 
    -0.04789341f, -0.10051528f, -0.02358672f, -0.05659379f, 0.03760322f, -0.00821239f, 0.06118197f, -0.00956572f, 
    0.12303588f, 0.20303021f, -0.01449536f, -0.09510051f, -0.34883666f, 0.30318469f, -0.16997950f, 0.11159426f, 
    -0.23349594f, -0.00146327f, 0.18343723f, 0.05104661f, -0.04144229f, 0.02209590f, 0.05365591f, 0.04361569f, 
    0.03056515f, -0.02474960f, -0.17381209f, -0.34422904f, -0.33054018f, -0.07664905f, -0.53386903f, -0.22618718f, 
    -0.15789025f, -0.16141905f, -0.15348005f, -0.11415557f, -0.05894666f, -0.13484815f, -0.09413952f, 0.11645579f, 
    -0.06820183f, -0.01340973f, -0.09415936f, -0.17326157f, 0.02586666f, 0.00202143f, 0.05801224f, 0.02849392f, 
    -0.25091931f, -0.23437075f, -0.13622266f, 0.01286295f, -0.03350636f, 0.02605439f, 0.07186893f, 0.00635323f, 
    -0.00191030f, 0.19963379f, -0.06257876f, 0.05232616f, -0.04766853f, 0.05233629f, 0.11820967f, -0.04981000f, 
    0.13196379f, 0.07435282f, 0.00549329f, 0.21862355f, 0.15121646f, 0.18607473f, -0.16846123f, -0.22578441f, 
    0.00161847f, -0.01202996f, -0.04311004f, -0.05609038f, -0.02383251f, -0.15996376f, 0.01218226f, 0.10317440f, 
    0.07067449f, 0.14363791f, 0.05379832f, 0.08623437f, 0.04026691f, 0.19882223f, 0.08354796f, 0.03698044f, 
    -0.02311680f, -0.04979138f, -0.05172791f, 0.01708864f, -0.03466256f, -0.03251590f, -0.05988126f, -0.05946072f, 
    -0.03168697f, -0.04047431f, -0.04336877f, -0.03304420f, 0.01380659f, 0.00498357f, 0.04286268f, -0.03578775f, 
    -0.02165385f, 0.03171805f, 0.04570753f, -0.06016847f, -0.03686116f, -0.03418809f, 0.04075915f, -0.06035351f, 
    -0.02308642f, -0.05405307f, 0.04220472f, 0.02085115f, -0.03882744f, 0.00215139f, 0.03177594f, 0.00334081f, 
    0.03922646f, -0.02556653f, -0.04317971f, -0.00440264f, 0.03539492f, -0.03791297f, -0.06366430f, 0.02229652f, 
    -0.02193197f, -0.04599831f, 0.02401087f, -0.06224924f, 0.04725478f, 0.04692565f, -0.00062106f, 0.02703808f, 
    0.03167836f, -0.05592168f, 0.00167295f, -0.05578684f, -0.04631097f, 0.04152171f, -0.04618561f, 0.02937927f, 
    -0.03852307f, -0.03794910f, -0.06320830f, 0.03606233f, -0.01189447f, -0.04570110f, -0.05806303f, -0.04942789f, 
    0.01071327f, -0.02540527f, -0.05789583f, -0.06209531f, -0.03715575f, -0.02881063f, 0.03556637f, -0.00478671f, 
    0.00904295f, -0.05171633f, 0.00569490f, 0.02584148f, -0.04252823f, -0.04921208f, -0.04160216f, -0.02982485f, 
    -0.00161248f, -0.02670830f, -0.00744940f, 0.02915310f, 0.04662624f, 0.02581307f, 0.01169157f, -0.00160678f, 
    -0.00401558f, 0.01064323f, -0.04329091f, -0.06167824f, -0.02614597f, -0.03291066f, -0.03443606f, 0.00797978f, 
    0.01395977f, 0.03432184f, -0.01455933f, -0.03096439f, 0.02556893f, -0.03884123f, -0.03228375f, 0.02464292f, 
    0.04472290f, -0.00351826f, -0.04790024f, 0.03551932f, 0.03208876f, 0.00013561f, -0.03730050f, 0.02092640f, 
    -0.05544637f, 0.00714649f, 0.01876919f, -0.02908165f, -0.00233991f, 0.01862449f, 0.03255004f, -0.04841305f, 
    0.00715052f, 0.03979196f, -0.03437142f, -0.04974158f, -0.03820137f, -0.01229275f, -0.00602757f, 0.01198861f, 
    -0.03354396f, -0.03155243f, -0.01817356f, -0.03563278f, 0.04307041f, 0.03432561f, 0.00398076f, -0.02530813f, 
    -0.01172880f, 0.00517918f, -0.02640767f, 0.02544179f, 0.00434989f, 0.03153801f, 0.03107425f, -0.03521148f, 
    -0.04040477f, 0.00943068f, 0.01935649f, -0.04090413f, -0.04195346f, -0.00294459f, -0.00858239f, 0.03116847f, 
    -0.05226603f, -0.01025644f, 0.02873142f, -0.03780620f, -0.04510564f, -0.04804584f, -0.05853719f, 0.03821758f, 
    0.03311873f, 0.00859054f, -0.03543326f, 0.01207695f, 0.00898674f, 0.00093919f, -0.04602470f, 0.00099122f, 
    -0.05629563f, 0.01002829f, -0.04131381f, -0.03059619f, -0.06151870f, -0.04444957f, -0.04948034f, -0.01315300f, 
    0.02494121f, -0.03438269f, 0.02653940f, 0.02823448f, -0.04093096f, 0.01993142f, -0.00047741f, 0.02129512f, 
    -0.03386457f, 0.03944638f, -0.01233344f, -0.03546952f, -0.05454055f, 0.02125201f, -0.05807859f, -0.04718243f, 
    -0.04977699f, 0.00792651f, -0.01316333f, 0.03588131f, -0.03504420f, -0.00355734f, 0.04643054f, 0.03160876f, 
    0.01621013f, -0.00093205f, 0.01360732f, -0.06042219f, -0.01882388f, -0.01347081f, -0.03881993f, -0.02811018f, 
    -0.01930850f, -0.05121000f, -0.05095408f, 0.03303019f, 0.03591868f, -0.05821174f, -0.03754986f, 0.03416876f, 
    0.00150975f, -0.05789673f, -0.04169518f, 0.00467621f, 0.01133095f, -0.00079855f, 0.04364679f, 0.01937849f, 
    -0.04564961f, 0.03345320f, -0.04431406f, -0.00036503f, -0.00994166f, 0.02934914f, 0.04112946f, -0.00512119f, 
    0.04732177f, -0.02564346f, -0.00117153f, 0.01516550f, -0.04337123f, -0.00571511f, -0.00741454f, 0.03592025f, 
    -0.00208439f, 0.01392408f, 0.01626402f, 0.04330817f, 0.02427732f, 0.03860947f, -0.03964469f, -0.00427561f, 
    0.01788383f, 0.01142351f, 0.03181186f, -0.05853314f, 0.02283984f, 0.02180634f, 0.04068384f, 0.00018201f, 
    -0.03160975f, 0.02065108f, 0.02289150f, -0.01590431f, -0.01722198f, -0.00393738f, 0.00223502f, 0.03035638f, 
    -0.05801582f, 0.02980497f, 0.03540301f, 0.03002195f, -0.06066243f, 0.04655080f, -0.05472871f, -0.04356943f, 
    -0.05405793f, -0.03907597f, 0.03271320f, -0.05674772f, -0.01816194f, 0.01749934f, 0.01387776f, 0.01626865f, 
    0.04722469f, 0.00676689f, -0.00928055f, 0.00128818f, 0.02722489f, 0.01864074f, -0.00521175f, -0.02129974f, 
    0.01589488f, -0.05246520f, -0.01061670f, -0.01463324f, -0.04824622f, -0.01661799f, 0.02986429f, -0.00470159f, 
    -0.00703160f, 0.03657031f, 0.03847430f, -0.04367290f, -0.04589178f, 0.02790832f, -0.05329801f, -0.05724294f, 
    -0.03901780f, 0.04596576f, -0.04130833f, -0.00608897f, 0.00902121f, -0.05292417f, -0.04031722f, -0.02217448f, 
    -0.00614011f, 0.01864765f, -0.06144740f, -0.05656742f, 0.04787174f, -0.00320971f, 0.04630530f, -0.03318538f, 
    0.09863842f, -0.04870744f, -0.00180401f, 0.20327313f, -0.04395333f, -0.04056444f, -0.20637201f, 0.09983680f, 
    -0.00207924f, 0.07197780f, -0.03796934f, 0.07884946f, 0.08906138f, 0.06843741f, -0.04388391f, 0.00674304f, 
    0.09654074f, 0.02311717f, 0.08628254f, 0.03970540f, 0.20301318f, 0.08601994f, -0.19069190f, -0.08636513f, 
    -0.27792063f, -0.12351535f, -0.06033945f, -0.11033583f, 0.04365233f, -0.24318437f, 0.18976155f, 0.03848156f, 
    -0.10025984f, 0.03930235f, 0.14734405f, 0.00745024f, -0.00884181f, 0.02474282f, 0.03424311f, -0.16314749f, 
    0.36123264f, -0.07702688f, 0.40205550f, 0.08911990f, -0.18299885f, -0.00310575f, -0.16919938f, -0.06765477f, 
    -0.15089658f, -0.07121983f, -0.14309287f, 0.07847682f, -0.00504362f, 0.01858140f, -0.11498491f, 0.07942538f, 
    -0.04617152f, -0.09048536f, -0.05447834f, 0.04772358f, 0.05101764f, -0.30874464f, 0.19369651f, 0.15180787f, 
    0.06751587f, 0.02263387f, 0.08458711f, 0.09217432f, 0.15255307f, 0.01829284f, 0.00137801f, -0.00632962f, 
    0.01573164f, -0.03082409f, 0.00269104f, 0.04055572f, 0.11359537f, 0.10500492f, -0.00441867f, 0.25814462f, 
    0.20543142f, 0.05661872f, -0.02077316f, -0.17697832f, -0.13429931f, -0.09350713f, 0.02454430f, -0.08721713f, 
    -0.02353268f, -0.12539150f, -0.02333551f, 0.06108546f, -0.09198534f, 0.00708371f, -0.00076214f, -0.06969125f, 
    0.04606298f, -0.01132396f, -0.00769753f, -0.04532733f, 0.02144144f, -0.08977326f, -0.15792640f, 0.18005244f, 
    0.22662270f, 0.05561967f, -0.20955819f, 0.00630180f, 0.14646120f, 0.15742196f, -0.06816424f, 0.12337486f, 
    0.03104959f, 0.00167790f, 0.02119351f, -0.03349495f, 0.01917270f, -0.00362511f, 0.04679106f, 0.00958924f, 
    0.10361686f, 0.11643345f, 0.27516255f, 0.01473696f, -0.13599864f, -0.04850022f, -0.01243253f, -0.05289033f, 
    0.06579875f, -0.15347065f, -0.02275837f, -0.02539907f, -0.01917250f, 0.01832405f, 0.03441032f, 0.00355478f, 
    0.02048218f, 0.04576613f, -0.01681420f, 0.04861203f, -0.09643344f, -0.03791777f, 0.20138244f, 0.05303277f, 
    -0.04794895f, 0.01760319f, 0.09865174f, 0.00395640f, 0.11929257f, 0.01947341f, 0.03950724f, 0.09011605f, 
    0.00805163f, 0.05615600f, 0.09841891f, -0.13290727f, 0.18195911f, 0.09448823f, 0.15620002f, 0.07544388f, 
    0.19849329f, -0.41215587f, -0.44054240f, 0.12627229f, -0.09450112f, 0.08505865f, 0.01238426f, -0.02794353f, 
    0.00905428f, -0.07218018f, 0.04895358f, -0.01095988f, 0.09024911f, -0.02947076f, 0.08341525f, 0.08802561f, 
    -0.01349339f, -0.16783878f, -0.00687819f, -0.16731605f, 0.23394626f, -0.18560559f, -0.57169467f, 0.01375202f, 
    -0.34441599f, -0.09632214f, -0.01002197f, 0.00998538f, 0.08745812f, 0.00697503f, 0.08629864f, 0.06782738f, 
    -0.00357439f, 0.00199135f, -0.09943514f, -0.02761310f, -0.00926363f, -0.01622848f, -0.01852185f, -0.02314715f, 
    0.05012323f, 0.10098183f, 0.21585959f, 0.20171887f, -0.16791523f, -0.17438002f, -0.02599465f, -0.07196750f, 
    -0.04724795f, -0.18427892f, -0.04763818f, 0.05910748f, -0.14899403f, 0.04157687f, 0.03764038f, 0.09961039f, 
    -0.12097166f, -0.02017453f, -0.04068268f, 0.01390755f, 0.02323023f, -0.17169051f, -0.13015124f, -0.24085680f, 
    -0.14474209f, 0.03081065f, 0.02005009f, -0.07509581f, 0.12572226f, -0.01815358f, -0.01157648f, 0.09252872f, 
    -0.01896548f, -0.09150375f, -0.07489314f, 0.03549445f, 0.03005684f, -0.01164011f, -0.09964125f, -0.03239545f, 
    0.14984000f, -0.12259686f, -0.13318665f, -0.04184902f, 0.02829841f, 0.16831483f, -0.00461812f, 0.24676310f, 
    -0.11025698f, 0.15206222f, -0.01777494f, -0.01763238f, -0.04339080f, 0.03778767f, -0.05972436f, 0.03129336f, 
    -0.05042560f, -0.11987742f, -0.08608513f, -0.05506908f, -0.02939546f, 0.17535436f, 0.12617904f, 0.03235499f, 
    -0.16888662f, -0.21880411f, -0.08718128f, -0.01374500f, 0.03540883f, -0.15032870f, 0.03574921f, 0.01893482f, 
    0.01018470f, -0.03919960f, 0.02758643f, -0.11180108f, -0.00768197f, 0.02854488f, 0.01305094f, -0.01039005f, 
    -0.00480058f, -0.27984816f, -0.07975451f, -0.08936629f, -0.11064625f, 0.11310263f, 0.06694253f, 0.00580590f, 
    -0.00814703f, -0.12358458f, 0.11119253f, -0.05733681f, 0.01181886f, 0.09205190f, -0.00221410f, -0.10121608f, 
    0.06314927f, 0.11705821f, 0.00458081f, 0.12082444f, 0.08957472f, 0.22101878f, 0.20360887f, 0.08961073f, 
    -0.01901053f, -0.18142951f, 0.02296632f, -0.17826302f, -0.03166665f, -0.05310628f, -0.05449295f, 0.06113482f, 
    0.11718151f, 0.03191777f, 0.09910814f, 0.01910538f, -0.00760431f, 0.14905022f, 0.09046770f, -0.01168471f, 
    0.12822065f, 0.29361588f, -0.05494620f, 0.11295953f, 0.04907877f, 0.01820482f, 0.18761557f, 0.09452574f, 
    0.07654034f, 0.31542659f, 0.10930402f, 0.05885718f, 0.03771470f, -0.01352449f, -0.09349913f, -0.06985737f, 
    -0.14067987f, -0.16398260f, -0.08934397f, 0.02911104f, 0.34840640f, 0.03357932f, 0.14246760f, -0.12606046f, 
    0.21058179f, 0.10983526f, 0.05269615f, 0.01049692f, -0.05720022f, 0.06343289f, -0.13410239f, 0.02047397f, 
    -0.02850963f, 0.03600185f, -0.11959058f, 0.03130934f, -0.01657866f, -0.20049664f, -0.00842989f, 0.11069337f, 
    0.34632179f, 0.18770163f, 0.02164208f, -0.13916209f, 0.17659590f, 0.11686432f, -0.17592588f, -0.02361788f, 
    0.07765639f, -0.04134001f, 0.13909550f, -0.03072189f, -0.02261356f, -0.10135458f, -0.01078177f, 0.02667835f, 
    0.07367462f, 0.04876816f, 0.10620124f, 0.10956994f, -0.06576333f, 0.11853188f, 0.11194824f, 0.03638507f, 
    0.03843343f, -0.05510873f, 0.10703779f, 0.07357860f, -0.00563444f, -0.09464587f, 0.00732730f, -0.05543420f, 
    0.00767714f, 0.04386054f, 0.11109180f, -0.17341733f, 0.05609380f, -0.10318863f, 0.06492599f, -0.34710842f, 
    0.17834207f, -0.29700279f, 0.18334827f, -0.14742774f, 0.07553437f, 0.02656610f, -0.02651432f, 0.02028885f, 
    0.04653000f, -0.12435061f, -0.03517327f, 0.12895727f, -0.09610493f, 0.14365178f, 0.03540890f, 0.05759904f, 
    -0.02983131f, -0.23164804f, -0.07639845f, 0.07858129f, -0.10006162f, 0.16729546f, -0.11333691f, 0.18235034f, 
    0.06635851f, -0.25822568f, -0.02689559f, 0.11578137f, -0.07203913f, 0.13216384f, -0.10376922f, 0.11749275f, 
    0.00916007f, -0.01254246f, -0.06053993f, 0.07098183f, -0.08011080f, -0.06009695f, 0.05989218f, -0.01261575f, 
    0.14356877f, -0.19450836f, 0.11989676f, 0.05502938f, 0.10091820f, -0.04935415f, 0.14855765f, -0.06912488f, 
    -0.00776270f, -0.09041397f, -0.02280850f, 0.07283694f, 0.06975556f, 0.09478498f, -0.13243121f, 0.02210137f, 
    -0.03916129f, -0.01157605f, -0.06704924f, -0.11791326f, 0.03518260f, -0.14254390f, -0.11865137f, 0.10539597f, 
    -0.03118357f, -0.11467621f, -0.01658458f, 0.06251194f, -0.04335396f, -0.02501568f, -0.03192424f, -0.00655437f, 
    0.03207003f, 0.07091957f, 0.02378464f, -0.13116308f, -0.16184004f, -0.16155042f, -0.05802987f, -0.07293023f, 
    0.29801491f, 0.16627875f, 0.31523943f, 0.19776624f, -0.03981748f, -0.06063818f, 0.14377195f, 0.07623556f, 
    0.07368726f, -0.17396852f, -0.03071166f, 0.08698631f, 0.00066424f, -0.03860455f, 0.00795479f, -0.08510666f, 
    0.09628174f, 0.14617008f, 0.04052624f, -0.11099754f, 0.27243561f, 0.15550523f, 0.03416960f, 0.15739501f, 
    0.01480736f, -0.07772174f, -0.02498921f, 0.10948008f, -0.10199361f, -0.10124064f, -0.09773402f, 0.05730664f, 
    0.01467093f, -0.02813042f, 0.04966521f, -0.07742995f, 0.01904188f, -0.01710114f, -0.08295985f, -0.01103014f, 
    0.05399154f, -0.19253536f, -0.08732489f, -0.02647022f, -0.08028983f, 0.08058545f, 0.09741634f, -0.02016197f, 
    0.05448648f, -0.00748814f, -0.03204349f, 0.01258107f, 0.20823991f, 0.05638568f, 0.04074437f, -0.08858275f, 
    0.00350086f, 0.03034100f, -0.04387569f, -0.04744169f, 0.45634562f, 0.15900551f, 0.27961496f, -0.06073896f, 
    0.19739936f, -0.06063687f, -0.13126910f, -0.10208581f, -0.02938751f, -0.19588816f, -0.01034544f, 0.11174528f, 
    0.00423421f, 0.14784767f, 0.10805727f, 0.06777935f, 0.04249706f, -0.01791650f, -0.04148028f, -0.05651727f, 
    -0.21754414f, 0.01902155f, -0.00238030f, 0.09628624f, 0.09382810f, -0.06660363f, 0.01550845f, -0.08676904f, 
    0.02084335f, 0.25264239f, -0.17665865f, -0.04486709f, -0.04849133f, -0.06373639f, -0.06248426f, -0.02106500f, 
    0.04989931f, 0.00217496f, 0.15315065f, 0.30483499f, 0.09613299f, 0.14520021f, 0.26958317f, 0.05277461f, 
    -0.08253716f, -0.20625612f, 0.02699217f, 0.11490333f, 0.14405482f, 0.06963752f, -0.01681783f, -0.01526697f, 
    0.11322695f, 0.15809512f, -0.02034483f, 0.05186821f, -0.06308684f, -0.08022716f, 0.02687060f, -0.04863450f, 
    0.03412156f, -0.11136951f, -0.00258989f, -0.04888096f, 0.09477235f, 0.00024106f, 0.08449502f, 0.01060628f, 
    -0.07387951f, -0.18877903f, 0.12915511f, 0.02330024f, -0.04366944f, 0.04598717f, 0.04733806f, -0.08511276f, 
    -0.19096273f, -0.10303798f, -0.11674023f, -0.13008715f, -0.13572212f, -0.10582116f, 0.36794141f, 0.15888554f, 
    -0.03194307f, -0.16173837f, -0.00438210f, -0.03966522f, 0.00212790f, 0.13512124f, 0.04146395f, -0.06069858f, 
    0.02740746f, -0.12222178f, -0.01868160f, -0.03489742f, 0.12883602f, -0.18820563f, -0.08857325f, 0.07262250f, 
    0.00688151f, 0.03213344f, -0.01517218f, 0.04910191f, -0.03408048f, 0.01375038f, -0.01450254f, 0.01527710f, 
    0.03813202f, -0.00750567f, -0.04921925f, -0.02745929f, 0.02252406f, 0.01637045f, -0.00794560f, -0.03228704f, 
    -0.05871399f, 0.01753116f, -0.05958751f, 0.02550644f, 0.02093199f, -0.05819695f, -0.00995810f, -0.01591049f, 
    0.01996205f, 0.03052945f, -0.02396563f, -0.04399247f, -0.03023593f, -0.00547722f, 0.00524284f, 0.04084557f, 
    -0.01557853f, 0.03993321f, -0.04204191f, 0.00150076f, 0.01006865f, -0.05514980f, -0.04183118f, 0.04603584f, 
    -0.00661053f, 0.02370443f, -0.04967396f, -0.01840110f, -0.00373684f, 0.00835529f, 0.03484955f, 0.01594557f, 
    0.02435026f, 0.03445374f, 0.05044368f, -0.03804706f, 0.02962992f, -0.01646060f, -0.04883492f, -0.01217387f, 
    -0.04000297f, -0.03615969f, -0.02283213f, 0.04296244f, 0.00547876f, -0.02717361f, -0.01417280f, 0.03715504f, 
    -0.03995238f, 0.03748387f, 0.01422618f, -0.04428136f, -0.02515365f, 0.00690223f, 0.01459395f, -0.03244713f, 
    -0.06472486f, -0.01155377f, -0.00776864f, -0.05412729f, 0.02785043f, -0.04253114f, -0.02219853f, -0.06311720f, 
    -0.05264742f, 0.03610754f, -0.05071287f, -0.03957388f, 0.03931339f, 0.02379701f, -0.04645243f, -0.03536414f, 
    0.01946129f, -0.02496596f, -0.01126040f, -0.05734416f, -0.05248982f, -0.01771321f, -0.04843007f, -0.05045044f, 
    0.02846853f, -0.05373764f, 0.02995726f, 0.01908863f, -0.02701883f, -0.05771982f, 0.01890490f, -0.06718010f, 
    0.01291628f, -0.00129513f, -0.03811358f, -0.04792100f, -0.02802604f, 0.00077530f, 0.00472616f, 0.01524886f, 
    -0.04696508f, -0.03034379f, -0.01430184f, 0.03314957f, -0.00407493f, -0.01031948f, 0.02392174f, 0.02099130f, 
    0.00167588f, 0.05284132f, 0.00097922f, -0.02576181f, 0.01266755f, -0.03887885f, 0.03466991f, 0.00033491f, 
    -0.00062851f, -0.04634583f, -0.01977970f, -0.05938725f, 0.00172642f, 0.03637863f, -0.02593731f, -0.02150160f, 
    -0.01074243f, -0.05602362f, -0.06285553f, -0.01490083f, 0.03502995f, 0.05299287f, -0.06424817f, 0.03125988f, 
    -0.01772241f, -0.05443447f, -0.04655755f, -0.03993418f, -0.01571719f, -0.00351112f, -0.01236847f, -0.01698696f, 
    -0.06000617f, -0.02428801f, 0.03312617f, -0.02432129f, -0.06462653f, -0.03697458f, -0.02036299f, 0.02017468f, 
    0.03140127f, 0.01893494f, -0.02378501f, -0.04504615f, -0.02338913f, -0.00815000f, 0.04855789f, 0.02646112f, 
    -0.03241701f, -0.01154629f, 0.02351820f, -0.01208833f, -0.06524029f, -0.05620620f, 0.01809857f, -0.00752374f, 
    0.03853244f, -0.06437025f, 0.05283787f, 0.00296703f, 0.03696853f, -0.02623673f, 0.03974085f, -0.06347079f, 
    0.03351309f, -0.03442470f, 0.03209044f, -0.00644560f, -0.00024906f, -0.02081577f, 0.00036110f, 0.03322934f, 
    0.01278611f, -0.03974734f, -0.01219252f, 0.02007330f, 0.01431359f, -0.02055605f, 0.02412326f, -0.04380385f, 
    0.01685936f, 0.01798421f, -0.00779161f, 0.03365338f, -0.01434918f, -0.04297515f, 0.05546596f, 0.00363594f, 
    0.03864292f, 0.01589203f, 0.02768868f, 0.04403653f, 0.02811899f, -0.01950005f, -0.00338131f, -0.04162475f, 
    -0.03961986f, -0.02376983f, -0.05566039f, 0.00352133f, -0.05575732f, 0.02994618f, 0.01901262f, 0.00453869f, 
    0.01517961f, 0.04570956f, 0.04493766f, 0.03993564f, 0.00964015f, 0.01602026f, 0.03210398f, 0.02102365f, 
    -0.05037568f, 0.03116874f, -0.05617548f, 0.03579574f, 0.00283349f, 0.04452847f, -0.04454014f, 0.00446452f, 
    -0.02801266f, 0.03503065f, 0.00133829f, 0.00214278f, 0.02541048f, -0.05755258f, -0.02916456f, 0.00661819f, 
    -0.05515688f, -0.04929164f, -0.00893836f, 0.03088387f, -0.06370769f, -0.02761619f, 0.01303921f, 0.00366085f, 
    0.04506503f, -0.03791530f, 0.04213370f, 0.02020767f, 0.03509646f, -0.01396219f, -0.01080435f, -0.01766409f, 
    -0.03589711f, -0.01141459f, 0.04127960f, -0.04462621f, 0.03533503f, -0.00834187f, 0.05370459f, 0.00671186f, 
    0.00870874f, -0.05755707f, 0.02499479f, -0.04662585f, -0.01298655f, 0.01503981f, 0.01225519f, -0.02554162f, 
    -0.03170878f, -0.04828191f, 0.03206067f, -0.04423185f, -0.05189553f, 0.04623516f, -0.02264435f, 0.01964685f, 
    0.01458200f, -0.00103053f, -0.00662973f, -0.00278921f, 0.03114804f, 0.01809246f, 0.04163514f, -0.05144120f, 
    0.01919831f, 0.01325000f, -0.00458484f, -0.05061172f, 0.00753381f, 0.01409096f, 0.01114708f, -0.01809255f, 
    0.02013317f, 0.01252922f, -0.04800464f, 0.04003501f, -0.05668414f, -0.02927054f, -0.04031189f, -0.00681090f, 
    -0.04774062f, -0.04602715f, -0.01155268f, 0.01434190f, 0.01794800f, 0.03307501f, -0.03242403f, -0.01835367f, 
    0.20941828f, 0.22078946f, 0.17673585f, -0.02168731f, -0.09648192f, 0.09279437f, 0.06034419f, -0.04845696f, 
    0.18763043f, 0.07323364f, 0.10063794f, 0.10692841f, 0.13043892f, 0.03813703f, -0.01392817f, -0.12407866f, 
    -0.08629152f, -0.05281265f, 0.00126635f, 0.08699212f, -0.07313012f, -0.14351951f, -0.11241809f, -0.02916367f, 
    0.21720521f, -0.08783692f, 0.01679708f, 0.02483941f, 0.05064464f, 0.08939571f, 0.01774684f, 0.02276837f, 
    -0.00705059f, 0.10061669f, -0.09941307f, 0.09780229f, 0.00459946f, -0.07925877f, 0.09556276f, 0.14418024f, 
    -0.31910855f, 0.34165817f, -0.09636561f, -0.02686026f, -0.09745073f, 0.08359756f, -0.10834830f, -0.20360875f, 
    0.13352579f, -0.05074928f, 0.06970918f, -0.06135534f, 0.03884279f, -0.15127994f, -0.11320259f, -0.05275329f, 
    0.17078121f, 0.10474793f, 0.13214964f, 0.03658848f, 0.10256947f, 0.15726353f, -0.09025716f, 0.05168818f, 
    -0.03930584f, 0.12667941f, 0.09336036f, 0.15054961f, -0.09698192f, 0.03322059f, 0.00773238f, -0.01438024f, 
    0.04136416f, 0.03992195f, 0.03663963f, -0.05252525f, 0.06614421f, 0.05735122f, 0.04544803f, -0.17183833f, 
    -0.37107399f, -0.20307843f, -0.16273080f, -0.22901024f, 0.23791409f, -0.02781986f, -0.18132973f, -0.15360492f, 
    -0.05404743f, -0.13806330f, 0.09461327f, 0.10231812f, -0.02074339f, 0.02841024f, 0.12990145f, 0.09604246f, 
    0.03826692f, -0.03356218f, -0.18556549f, -0.03183254f, 0.23093244f, 0.16529462f, 0.06465300f, 0.05658613f, 
    0.04205123f, 0.05493376f, 0.13980472f, 0.12630863f, -0.09610848f, 0.16316722f, 0.05673454f, 0.06823898f, 
    0.09508440f, -0.00022815f, -0.03606980f, 0.13081071f, 0.04901719f, 0.06847639f, 0.14606616f, 0.18049248f, 
    -0.33040282f, -0.40212718f, -0.61765301f, -0.00231403f, 0.12608950f, -0.11168122f, 0.15297753f, -0.12510833f, 
    -0.32246047f, -0.19914454f, -0.07156446f, -0.00586742f, -0.08569642f, 0.06518951f, -0.18551748f, 0.00445890f, 
    0.05492583f, 0.04426523f, -0.03118428f, -0.13797255f, 0.03743264f, -0.10917784f, -0.37836444f, -0.07760055f, 
    -0.16695750f, -0.04718065f, -0.11929544f, 0.09137176f, -0.12246308f, -0.09689561f, 0.02205339f, 0.10897825f, 
    -0.02651389f, 0.00587944f, 0.02770264f, -0.12548497f, -0.11763705f, -0.07207391f, -0.14385588f, -0.11157718f, 
    0.30195954f, 0.18861333f, 0.20197223f, -0.14424142f, 0.12667012f, 0.02048060f, 0.11620936f, 0.07753178f, 
    0.13902253f, -0.09703227f, 0.13032776f, 0.11411729f, 0.06575186f, 0.01355901f, -0.05510964f, -0.09949823f, 
    0.18641718f, 0.10869002f, 0.01784228f, 0.07080442f, 0.23510180f, -0.08002115f, 0.09890141f, -0.06608608f, 
    0.13395880f, -0.05182483f, -0.03720468f, 0.10959408f, 0.12776910f, 0.00702174f, 0.10214856f, 0.00925808f, 
    0.13646384f, 0.01991430f, 0.12888569f, -0.04038883f, 0.07991444f, 0.09347758f, 0.02916704f, -0.00950821f, 
    -0.00462264f, -0.31597838f, -0.47813222f, -0.76972944f, -0.10387589f, -0.01221050f, -0.16379207f, -0.29174650f, 
    0.05030953f, -0.48974144f, 0.07460806f, 0.03086346f, 0.11279171f, -0.06014702f, -0.01154901f, -0.06748315f, 
    0.12933542f, 0.03828154f, -0.02309616f, -0.07843175f, 0.23185684f, 0.31058484f, 0.10054830f, 0.06273017f, 
    0.13988753f, 0.17823412f, 0.09607935f, 0.28775442f, 0.00508491f, 0.01364881f, 0.03903008f, 0.02141914f, 
    0.05176226f, 0.02905889f, 0.09555604f, 0.07776711f, 0.04628236f, 0.00300633f, 0.01533035f, -0.04192450f, 
    -0.17293216f, 0.26203546f, 0.27233249f, 0.02393773f, -0.28644016f, 0.02077763f, -0.00110824f, -0.08153535f, 
    0.03026090f, 0.15375902f, -0.04408957f, 0.00388350f, -0.00417784f, 0.02115401f, 0.12382715f, 0.06140440f, 
    0.14227079f, -0.01941770f, 0.15712047f, 0.14420043f, -0.04060990f, 0.12585884f, 0.15250367f, 0.18202622f, 
    -0.24037690f, 0.02649122f, 0.05132662f, -0.26014039f, 0.12805264f, -0.01361650f, 0.09562793f, -0.04110847f, 
    -0.05776603f, -0.00017065f, -0.20832902f, 0.03385451f, -0.09798941f, -0.16913645f, 0.06027741f, -0.08841667f, 
    -0.18509322f, 0.02624789f, -0.21244444f, -0.08908067f, 0.11419061f, -0.04374855f, 0.02116018f, 0.04069648f, 
    -0.19004706f, -0.02762593f, 0.08337952f, 0.10156714f, 0.05951003f, 0.12652525f, 0.04266898f, -0.20773321f, 
    -0.02801936f, -0.02685955f, -0.22343694f, -0.11040175f, -0.22521281f, -0.20028710f, 0.08597819f, -0.00902424f, 
    -0.17543802f, 0.00819038f, 0.06496021f, -0.12772498f, 0.02630503f, -0.00460753f, 0.18254681f, -0.03219259f, 
    -0.06905288f, -0.03019398f, -0.17467265f, 0.07254843f, 0.11326446f, -0.12436816f, -0.01330615f, -0.00567490f, 
    0.15568671f, -0.16817857f, -0.25669783f, 0.15853423f, 0.25523454f, 0.01508192f, 0.10585584f, 0.12892361f, 
    -0.01716209f, 0.02931298f, 0.07182841f, 0.01900593f, 0.05921901f, -0.09052290f, 0.01241840f, -0.04072683f, 
    -0.05715985f, -0.21042141f, 0.13455899f, 0.02338124f, 0.10109217f, 0.35062087f, -0.11369003f, -0.21580251f, 
    -0.24844484f, 0.15561844f, 0.00141020f, 0.11618677f, -0.07274444f, 0.02547106f, -0.03863915f, -0.03715918f, 
    0.02599987f, 0.04885392f, -0.02395980f, -0.06526411f, -0.04232036f, -0.02080453f, -0.03146466f, 0.14030333f, 
    0.33081332f, 0.07254251f, 0.51212704f, -0.15938774f, 0.20221768f, -0.22699288f, -0.05551200f, 0.09612260f, 
    0.00851670f, 0.13372539f, 0.04821248f, 0.11640798f, 0.00043826f, 0.02708335f, 0.00946888f, 0.04910706f, 
    -0.00982956f, 0.07777607f, -0.13727051f, 0.14241943f, -0.10470979f, -0.07659196f, 0.12973608f, 0.02071586f, 
    0.13150525f, 0.04521322f, -0.05335957f, -0.03808373f, 0.05835661f, 0.04027891f, 0.05104358f, -0.02912095f, 
    -0.03813259f, 0.00101921f, 0.02766955f, -0.00991022f, -0.01983827f, 0.13399073f, -0.09667829f, 0.01090767f, 
    0.29480347f, 0.09285773f, 0.11070044f, -0.23379147f, -0.23066917f, -0.08034838f, 0.13223261f, 0.06743626f, 
    0.03297181f, 0.05651972f, 0.03370525f, -0.04571423f, 0.00620510f, -0.08389588f, -0.07388687f, -0.08487583f, 
    -0.06259727f, 0.04636006f, -0.11104370f, -0.05517561f, -0.25382632f, -0.01552348f, -0.09939481f, 0.16672182f, 
    0.18849042f, 0.06611916f, -0.05777786f, 0.01716711f, 0.15058632f, -0.01195947f, -0.13170372f, 0.01570896f, 
    -0.00604284f, -0.00842638f, 0.03829720f, 0.02904728f, -0.01955636f, -0.02739561f, 0.13760412f, -0.07707816f, 
    0.11552648f, 0.01530459f, 0.10559498f, -0.01887184f, -0.13083646f, -0.03445929f, -0.03138226f, -0.02817146f, 
    0.01424207f, -0.15803309f, -0.00077503f, 0.02490473f, -0.01153893f, -0.11030764f, -0.00104033f, 0.06153315f, 
    -0.01343482f, 0.00040913f, -0.17133388f, -0.00750965f, -0.39671290f, 0.03171062f, 0.10671217f, 0.20229861f, 
    0.07597892f, 0.04231493f, -0.01319888f, -0.01514328f, 0.04161160f, 0.03400375f, -0.18117760f, -0.09890030f, 
    -0.04256292f, -0.08804013f, -0.09473954f, -0.01581583f, -0.08439063f, 0.10704284f, -0.08129398f, -0.15636866f, 
    0.03455921f, -0.04754366f, 0.10189240f, -0.03638054f, 0.14429300f, 0.29736364f, 0.20978628f, 0.08895477f, 
    -0.01948712f, 0.06881963f, -0.15505268f, -0.09597965f, 0.01605388f, 0.09839965f, 0.14666124f, 0.02674030f, 
    0.02599830f, 0.11015376f, 0.08885371f, -0.01578375f, -0.29930475f, 0.21693857f, -0.23571424f, -0.14023563f, 
    -0.05931927f, 0.10274870f, 0.05524964f, -0.06974552f, -0.14018549f, 0.02804362f, -0.19889046f, 0.00512540f, 
    -0.07936092f, 0.12353128f, -0.01644078f, -0.03000069f, 0.01635507f, 0.01438361f, 0.02389211f, 0.10406471f, 
    0.06876806f, 0.04125154f, 0.01336974f, 0.07363378f, -0.15897693f, 0.01922233f, 0.09311236f, -0.06670339f, 
    0.17201626f, 0.06979751f, 0.11749374f, -0.08233341f, -0.03430710f, -0.00209622f, 0.00493467f, -0.07246487f, 
    -0.16343515f, 0.19384669f, -0.06962436f, -0.10559790f, 0.29729667f, -0.37504280f, 0.07127240f, -0.35476577f, 
    0.13274513f, 0.22964285f, 0.08943319f, -0.21750806f, 0.03771460f, -0.12220982f, 0.04630568f, 0.00285370f, 
    0.06859652f, 0.01957216f, 0.08132511f, 0.01944890f, -0.04697026f, 0.15476419f, 0.06220699f, 0.05935280f, 
    0.15511145f, -0.18987592f, 0.06416570f, 0.12226994f, 0.50567496f, -0.13051516f, 0.06235322f, 0.04715214f, 
    0.08358194f, 0.08806998f, 0.10837548f, 0.01782989f, 0.02822090f, -0.09337359f, 0.04408880f, 0.12316096f, 
    0.11096738f, 0.05954927f, 0.14703567f, 0.02191150f, 0.08260138f, -0.00091077f, 0.09725067f, 0.05520383f, 
    -0.09657489f, -0.02565051f, 0.00038444f, 0.27320451f, 0.00717753f, -0.02891708f, 0.03837303f, 0.03595981f, 
    0.09053025f, 0.01763091f, 0.06625745f, 0.03733095f, 0.08245932f, 0.13622661f, -0.00885027f, 0.11569647f, 
    0.08426078f, -0.15284780f, -0.02592289f, -0.01947495f, -0.03833980f, 0.14563005f, 0.01476015f, -0.06433893f, 
    0.06009424f, -0.06494883f, -0.02206422f, 0.00782935f, -0.01594522f, -0.06127831f, 0.09512422f, 0.06467922f, 
    0.03494831f, 0.12133960f, -0.06431958f, -0.13759597f, -0.10026527f, 0.00224410f, 0.06312995f, 0.20753859f, 
    -0.08662004f, -0.23268095f, -0.03746261f, -0.08045735f, 0.00369007f, -0.01087901f, -0.05651187f, -0.01523594f, 
    0.05955442f, -0.11246661f, -0.06213386f, -0.03303603f, 0.00948998f, 0.07703088f, -0.10788526f, 0.02335939f, 
    -0.50167483f, 0.00844695f, -0.31038746f, -0.63063920f, 0.10515924f, 0.25796497f, 0.36196119f, 0.03499891f, 
    0.03337945f, 0.14280586f, 0.14646344f, 0.08145808f, -0.04827522f, -0.01382442f, -0.11673618f, -0.13560638f, 
    -0.00916664f, 0.13561442f, 0.09077477f, -0.17844281f, 0.19236027f, 0.03442750f, 0.34316617f, 0.13805632f, 
    -0.01734315f, -0.10529354f, -0.05719049f, 0.06183500f, -0.05082802f, -0.04266671f, 0.04260505f, -0.14947751f, 
    -0.02760363f, 0.12241424f, 0.03414929f, -0.20425640f, -0.06625378f, -0.04427376f, 0.07465320f, -0.16714257f, 
    -0.01098163f, 0.28495860f, -0.11890940f, -0.04819113f, 0.28382438f, -0.20533195f, 0.09667906f, 0.07722993f, 
    -0.02509909f, 0.01392177f, -0.07121872f, -0.10517702f, -0.00371170f, 0.08072799f, 0.01440830f, 0.20335878f, 
    0.07538828f, 0.06374843f, 0.15310790f, 0.05125917f, -0.37976927f, 0.14029109f, -0.12569846f, -0.18688239f, 
    -0.00692361f, 0.07451214f, 0.29172465f, 0.16467571f, 0.01354733f, 0.14250754f, 0.12144914f, 0.20513853f, 
    0.05363743f, 0.20279971f, -0.06494825f, -0.09793538f, 0.07779139f, 0.03417161f, 0.11060488f, -0.02178685f, 
    0.07350303f, 0.14655940f, 0.14872999f, 0.23582835f, 0.03445908f, -0.05534026f, -0.08766458f, 0.08291028f, 
    -0.05625189f, 0.04795571f, 0.13795283f, -0.01036641f, 0.04480010f, 0.01898062f, -0.04427468f, -0.05431603f, 
    0.02383359f, -0.07120510f, 0.10509490f, -0.06743044f, -0.21402423f, 0.07454040f, -0.65178019f, -0.21100880f, 
    -0.21232767f, 0.15869673f, 0.25872642f, -0.03031017f, 0.00674528f, 0.05705518f, 0.11081745f, -0.01400853f, 
    -0.06234182f, 0.01052160f, -0.15898465f, -0.12451266f, 0.13332781f, 0.02216295f, -0.05867844f, -0.02842558f, 
    0.05457858f, 0.08350003f, 0.02745157f, 0.17031802f, 0.22877495f, 0.01451031f, -0.15377569f, -0.02626152f, 
    -0.08455811f, 0.00999076f, 0.10481878f, -0.02040036f, -0.09594031f, 0.08367714f, 0.10953161f, -0.15989679f, 
    -0.05829649f, 0.00805047f, 0.00055075f, -0.13725695f, 0.22665660f, 0.00791472f, 0.08997896f, 0.00455150f, 
    -0.03893049f, 0.05917937f, -0.03373999f, 0.06050392f, 0.08288735f, 0.08695802f, 0.36307713f, 0.20795523f, 
    0.12912196f, -0.02777534f, -0.03096950f, 0.02052005f, -0.01639305f, -0.00914014f, 0.07966153f, 0.02377266f, 
    -0.26727349f, -0.03681597f, -0.41449633f, -0.50163412f, 0.00522627f, -0.06203221f, -0.07249675f, -0.30906555f, 
    0.00399478f, 0.06975702f, 0.00425159f, -0.01859064f, -0.07336473f, -0.05284347f, -0.03729642f, -0.11338253f, 
    0.13026603f, 0.20397422f, -0.06108060f, 0.07373042f, 0.26854074f, 0.00767492f, 0.38080156f, -0.26482841f, 
    0.00719100f, 0.06103265f, -0.00100019f, 0.02891782f, 0.01547752f, -0.05421368f, -0.00503490f, -0.09803580f, 
    -0.04554677f, 0.06033578f, -0.05639866f, -0.04929823f, 0.06143301f, -0.07956852f, 0.08307890f, -0.01866311f, 
    0.12549643f, 0.14596723f, 0.12551947f, 0.17467959f, 0.20835149f, -0.06095255f, -0.23272271f, 0.01754985f, 
    -0.06854443f, -0.03702019f, 0.05506627f, 0.17475124f, 0.02318482f, -0.04458784f, 0.02155774f, -0.07032043f, 
    -0.12818478f, -0.07847727f, -0.05472107f, -0.09378165f, -0.64430505f, -0.34592426f, -0.77630430f, 0.08583023f, 
    -0.19939634f, -0.27495748f, -0.02415467f, 0.03774040f, -0.14202051f, 0.07986949f, -0.21498080f, -0.02495495f, 
    -0.07541794f, 0.00479644f, -0.09061941f, 0.09554952f, 0.19767830f, 0.12723656f, 0.05123993f, 0.04818371f, 
    0.01072057f, 0.15214097f, -0.63548154f, -0.17686671f, 0.00897726f, 0.04949989f, 0.09912887f, 0.05820645f, 
    0.00793794f, -0.08024944f, -0.14778811f, -0.01586310f, -0.10627603f, 0.08076848f, -0.07331660f, 0.01817232f, 
    -0.08850620f, 0.08916453f, -0.05977773f, 0.11957641f, 0.00832192f, -0.25141400f, -0.12214781f, 0.04944577f, 
    0.18435331f, -0.02500970f, 0.06407645f, -0.25262117f, -0.07250720f, -0.12758026f, -0.05131493f, -0.26694143f, 
    -0.01649505f, -0.01262303f, 0.08788600f, -0.11184634f, 0.02473884f, -0.27897298f, 0.01277723f, -0.24472778f, 
    -0.20311239f, 0.01915771f, 0.17912406f, -0.07721286f, -0.17897396f, -0.03129673f, -0.00459115f, 0.05585794f, 
    0.04301997f, 0.13848187f, 0.05073185f, 0.17993586f, 0.02155398f, -0.08800727f, -0.12593862f, -0.07198357f, 
    -0.12545656f, 0.03286892f, 0.06322295f, 0.00445388f, 0.24300355f, -0.00264551f, 0.03054149f, 0.09509350f, 
    0.24120826f, 0.22475305f, -0.07461476f, 0.06633265f, -0.06340908f, -0.07216076f, 0.14695670f, -0.02102408f, 
    -0.04506200f, 0.04680059f, 0.11653389f, 0.04186524f, 0.11497846f, -0.06321134f, 0.11123169f, -0.10136785f, 
    0.04744759f, 0.00255735f, 0.00614992f, -0.06141885f, -0.02912572f, -0.00712182f, 0.00216581f, -0.00453379f, 
    0.01471807f, 0.01254271f, 0.03438037f, 0.00490113f, 0.01387907f, -0.03076926f, -0.00409260f, -0.04236738f, 
    0.00202186f, -0.04873493f, -0.00751453f, -0.00745278f, -0.01484005f, 0.05250331f, 0.02622599f, -0.01107575f, 
    -0.04436205f, -0.00406475f, -0.03421757f, -0.03925558f, -0.03412325f, -0.01081927f, 0.00719036f, -0.06028137f, 
    -0.00452407f, -0.02470080f, -0.04793407f, -0.04859330f, -0.05348885f, -0.05169453f, -0.05137199f, 0.03160311f, 
    -0.01813227f, 0.02675326f, -0.04825003f, -0.03078088f, 0.04431150f, 0.01337651f, 0.04235336f, 0.04161500f, 
    -0.05512019f, 0.03945798f, 0.02179164f, -0.02221642f, 0.03978180f, 0.01310597f, -0.00369126f, -0.02386830f, 
    -0.02740664f, -0.00101434f, -0.01427506f, -0.06137582f, 0.00011641f, -0.04982283f, -0.01671991f, -0.03944105f, 
    0.04646472f, 0.00197994f, -0.01219063f, -0.03988819f, 0.00531587f, 0.00865298f, 0.01436272f, 0.02980738f, 
    -0.04066763f, -0.04689755f, -0.00314326f, 0.01654766f, 0.03576712f, -0.02314496f, -0.03147704f, -0.05567324f, 
    -0.03365222f, -0.04559571f, -0.04242905f, 0.04905560f, 0.01579414f, 0.02419627f, 0.04904694f, 0.03546593f, 
    -0.05510941f, -0.03535307f, -0.04925768f, -0.01853770f, 0.01736460f, 0.03353395f, -0.00684287f, -0.05344008f, 
    0.00408806f, 0.02249038f, -0.02730564f, -0.01306707f, 0.03609690f, -0.04644042f, -0.01734104f, 0.03226263f, 
    0.04362485f, 0.02899631f, -0.02841239f, 0.00612896f, -0.05858922f, -0.02214130f, -0.00913753f, -0.04520882f, 
    -0.04798472f, 0.04866957f, -0.05339320f, -0.02254353f, -0.05941026f, -0.00025864f, 0.02226929f, -0.04810626f, 
    0.02873199f, 0.03758782f, -0.01463006f, -0.03628545f, 0.03908492f, 0.02257572f, 0.03510512f, -0.05459075f, 
    -0.04867781f, -0.01767787f, 0.00215785f, -0.02499413f, 0.05250316f, -0.02151630f, 0.04579512f, -0.02984261f, 
    0.05036256f, 0.02175843f, -0.03133296f, 0.04666454f, -0.03849464f, -0.00866160f, -0.02380558f, -0.00653013f, 
    -0.03101711f, 0.00661771f, -0.02007512f, 0.00004521f, -0.01773887f, 0.03528607f, -0.01449661f, -0.03368994f, 
    0.03351740f, 0.03162088f, -0.02505432f, -0.04928432f, -0.04087733f, -0.04360855f, -0.05033238f, -0.05788181f, 
    0.04019507f, 0.01658515f, 0.01356528f, -0.05891349f, -0.05644235f, -0.04086717f, -0.03460686f, 0.01368141f, 
    -0.03354007f, -0.05778096f, -0.00384325f, 0.00927959f, 0.00954703f, -0.00758353f, -0.00059638f, 0.04591244f, 
    -0.05242005f, 0.04142204f, -0.00802594f, 0.03026572f, -0.03271287f, -0.06195289f, -0.00823526f, 0.00311334f, 
    0.03537279f, -0.05753390f, -0.01599668f, -0.04438708f, -0.02499731f, -0.03419129f, -0.05196751f, 0.02046442f, 
    -0.02233491f, 0.01611446f, -0.00012771f, -0.00302562f, -0.00449590f, 0.02529124f, -0.04673259f, -0.04559483f, 
    0.04752588f, -0.03112537f, -0.05163140f, 0.02906764f, 0.02740585f, -0.00831350f, -0.02419861f, -0.02975067f, 
    -0.04690024f, -0.02624127f, -0.01113793f, -0.01819651f, 0.02692189f, 0.03860846f, 0.04136832f, 0.01528018f, 
    -0.00852456f, -0.00892167f, 0.01942401f, -0.04625655f, -0.05679741f, -0.03182430f, -0.02734230f, -0.05052761f, 
    0.02932347f, -0.04690913f, 0.04699122f, 0.03455443f, -0.01699375f, -0.04130635f, 0.03750519f, -0.03410614f, 
    -0.02665915f, 0.04058227f, 0.03239849f, 0.03851072f, 0.00624457f, 0.04222010f, -0.00982265f, -0.06024937f, 
    -0.05841454f, -0.02408296f, 0.02222826f, 0.01262793f, 0.01960900f, -0.03631542f, -0.03234413f, -0.05804867f, 
    -0.04311795f, 0.01264615f, 0.05085506f, 0.03614952f, -0.03673586f, -0.03735656f, -0.04497843f, 0.02435327f, 
    -0.06105339f, 0.04097340f, 0.00965636f, 0.02932211f, 0.00233286f, 0.00405149f, -0.01587764f, 0.02936894f, 
    0.02851792f, -0.01952952f, -0.06064475f, -0.01175666f, 0.04581445f, 0.02384052f, -0.00278825f, -0.03582999f, 
    0.04065340f, -0.02127472f, 0.04899763f, 0.00008205f, -0.03373144f, -0.00407354f, 0.05130117f, -0.01369573f, 
    0.03508833f, 0.04597903f, 0.00762269f, 0.02489982f, 0.00025648f, -0.03823154f, 0.03243550f, -0.01205076f, 
    0.04478815f, 0.01631126f, -0.01336083f, -0.02350796f, 0.00320244f, -0.03288636f, -0.05882973f, 0.03130285f, 
    0.03385209f, -0.03809648f, 0.01729234f, 0.02685568f, -0.03969117f, 0.03658786f, -0.02360458f, -0.00209244f, 
    -0.01537505f, -0.04028073f, -0.03390871f, -0.01876236f, -0.00223422f, 0.02208754f, -0.03769390f, 0.01356762f, 
    -0.06170914f, 0.03010898f, -0.04572507f, -0.02143794f, -0.03888138f, 0.04394812f, 0.00404565f, -0.01954622f, 
    -0.21131651f, -0.09026935f, -0.01697876f, 0.11996730f, 0.03857235f, -0.16910514f, -0.13760594f, -0.08167315f, 
    -0.23983702f, -0.17652932f, -0.06125391f, 0.01511202f, 0.03787466f, -0.11227135f, -0.15224820f, -0.04796626f, 
    -0.10715478f, -0.05984995f, 0.07228715f, -0.07291234f, -0.50740814f, -0.36020967f, -0.08559037f, 0.06983961f, 
    0.26512092f, -0.04914457f, 0.17828818f, -0.00593157f, -0.12736617f, 0.13636611f, 0.06634503f, 0.02702385f, 
    0.10168764f, 0.09254555f, 0.06988130f, -0.05311569f, -0.01479000f, -0.01448856f, 0.00406037f, -0.06823477f, 
    0.53277642f, -0.25583920f, -0.10704184f, 0.24485630f, -0.01178365f, 0.03119654f, -0.03451297f, 0.23780705f, 
    -0.02750186f, -0.01268892f, -0.08257755f, 0.05086310f, -0.11861828f, -0.03640042f, -0.08031540f, -0.04795657f, 
    0.10234682f, -0.05068759f, 0.01852097f, 0.05428090f, 0.19886087f, 0.10017253f, 0.14588153f, 0.04525622f, 
    0.28942302f, -0.04322903f, 0.01051683f, 0.04138237f, 0.01085041f, 0.08812301f, 0.03104197f, 0.02926104f, 
    0.02958406f, -0.02165356f, 0.09401012f, 0.05034008f, 0.06644075f, 0.02085842f, 0.03188794f, -0.05886413f, 
    -0.46023238f, -0.22531056f, -0.01701859f, -0.05483189f, 0.29745859f, 0.08192947f, 0.09571621f, -0.03243175f, 
    0.08814736f, 0.20279463f, 0.10952044f, 0.02387434f, 0.08829641f, 0.03031153f, 0.14446242f, 0.06867234f, 
    -0.00466909f, -0.13792828f, 0.07397067f, 0.03084681f, 0.05283985f, -0.10160398f, 0.11200834f, -0.02758842f, 
    -0.07355235f, 0.06614340f, -0.03257314f, -0.20952159f, 0.07910319f, -0.10111613f, -0.04992049f, 0.03135347f, 
    -0.03381675f, 0.01803145f, 0.05079601f, -0.04546363f, 0.03181964f, 0.08505190f, 0.06794412f, -0.04727786f, 
    0.12717077f, 0.04754525f, 0.08503304f, 0.12202077f, 0.14169653f, -0.10114949f, 0.05368704f, 0.13047971f, 
    0.07187407f, 0.01085430f, -0.01700739f, -0.00673450f, 0.03439874f, 0.01676846f, -0.11031530f, 0.04519903f, 
    0.02867793f, -0.12162481f, -0.23096208f, 0.01741147f, 0.15083930f, 0.03078417f, -0.11193951f, 0.27224839f, 
    0.07952429f, 0.01436376f, 0.14311558f, 0.02213487f, 0.13284901f, -0.04522816f, 0.12763742f, 0.13525523f, 
    0.01581790f, 0.03844290f, 0.18774465f, -0.02680746f, 0.03403902f, 0.03489500f, -0.06531031f, -0.10765128f, 
    -0.32969809f, -0.58048815f, -0.00460444f, 0.34488273f, -0.31453612f, 0.02835976f, -0.05693558f, 0.20382005f, 
    -0.24790518f, 0.23946412f, -0.00811388f, -0.15907380f, 0.05227343f, 0.06256534f, -0.01661846f, -0.03777143f, 
    -0.02544015f, -0.01435649f, -0.00065720f, 0.04003685f, -0.22625996f, -0.26430392f, 0.13495123f, 0.30702302f, 
    -0.21540603f, 0.01364803f, 0.00921214f, 0.10847427f, 0.02137191f, 0.12205099f, -0.01825562f, -0.01904671f, 
    0.13943559f, -0.05287301f, -0.11766618f, -0.00738148f, -0.09246615f, 0.10237293f, -0.08510060f, -0.03303713f, 
    0.12048489f, -0.13583924f, 0.30202037f, -0.12844677f, 0.07553640f, -0.09288592f, 0.01590575f, -0.13757007f, 
    0.08060189f, -0.05236880f, -0.03908601f, 0.11974818f, 0.05611429f, 0.03193436f, 0.11456654f, 0.05087390f, 
    0.08312966f, -0.06077906f, -0.03323902f, -0.10743956f, -0.12661630f, -0.06494727f, 0.18129280f, 0.18563582f, 
    -0.16822653f, -0.16147625f, -0.13050520f, -0.04800382f, -0.14671253f, 0.20468093f, -0.08018881f, -0.02355688f, 
    0.06089014f, 0.04196273f, -0.08288124f, 0.09394459f, 0.04999186f, -0.04944422f, 0.09185378f, 0.08380180f, 
    0.05189320f, 0.05737432f, -0.12371938f, 0.14364718f, -0.07046325f, -0.02988883f, 0.01036089f, -0.19703239f, 
    0.21431579f, -0.15683571f, -0.06051670f, 0.07476982f, 0.11681261f, 0.01506598f, -0.11112417f, 0.08607516f, 
    0.06671249f, 0.05536114f, 0.11941815f, 0.10982747f, 0.15532887f, 0.05650372f, 0.07492631f, 0.10471556f, 
    -0.06794628f, -0.00210483f, 0.08631063f, -0.09019275f, -0.21415202f, 0.04413586f, -0.11029430f, 0.05730545f, 
    -0.05202169f, -0.01138996f, -0.00209624f, 0.07962161f, -0.16984569f, -0.15826489f, -0.17177445f, -0.11240637f, 
    -0.11743102f, 0.01615318f, 0.26168478f, -0.06597311f, 0.15981391f, -0.00764730f, 0.08607228f, -0.02212674f, 
    0.03060397f, -0.06105259f, 0.07709215f, 0.00376928f, -0.04272064f, -0.10220410f, 0.13456820f, -0.07638176f, 
    0.03515311f, -0.16906410f, -0.01098726f, -0.05186914f, 0.46639886f, 0.19029890f, 0.02436059f, 0.25154042f, 
    0.06813563f, 0.08188966f, 0.12455487f, 0.21465352f, 0.10963643f, 0.08142538f, 0.07403178f, -0.00939016f, 
    -0.03524764f, 0.06260310f, 0.14738943f, 0.18729925f, -0.04027830f, -0.07302867f, -0.03391463f, -0.03556861f, 
    0.22431648f, -0.31345955f, -0.22108054f, -0.30162036f, 0.04785459f, 0.03726739f, 0.01255906f, -0.15601847f, 
    0.03840179f, -0.19049734f, 0.08931462f, 0.02509468f, 0.08510055f, -0.07802304f, 0.00953123f, -0.11031162f, 
    -0.06271107f, 0.07472719f, 0.05375681f, 0.22658904f, -0.23720369f, 0.01031571f, 0.02359605f, 0.02591197f, 
    0.13091175f, 0.02595737f, 0.09077867f, 0.10343138f, -0.00195344f, 0.11546415f, 0.06932230f, 0.01885902f, 
    0.08625276f, 0.10824954f, 0.10071089f, 0.03940352f, -0.02314532f, -0.10928231f, 0.00527691f, 0.03897284f, 
    -0.29252177f, 0.23617968f, 0.01863430f, -0.25887764f, 0.12190757f, 0.04150571f, -0.09737355f, -0.00074631f, 
    0.07557648f, 0.02463084f, 0.06527969f, -0.06927554f, 0.02259457f, 0.00862498f, -0.01353624f, 0.00228745f, 
    0.03792305f, 0.04614342f, 0.00223512f, -0.05046354f, 0.34289205f, 0.15471537f, -0.25941890f, -0.05988785f, 
    0.05686301f, 0.07755274f, 0.12349049f, 0.09802791f, 0.09246084f, 0.05536959f, -0.00261865f, 0.03769699f, 
    -0.10393091f, 0.00019821f, 0.01458546f, -0.03243793f, -0.02133317f, 0.03920256f, 0.15989590f, -0.05799464f, 
    0.06255583f, 0.08810231f, -0.10104614f, -0.05753902f, 0.04584498f, 0.08652008f, 0.08939518f, -0.05740402f, 
    -0.03996606f, 0.05225673f, 0.03047914f, 0.09494831f, 0.11289327f, 0.05446914f, 0.11421371f, 0.12065870f, 
    0.00311869f, -0.17187093f, 0.05968685f, 0.02959572f, 0.16569997f, -0.10440448f, -0.21072865f, 0.00548318f, 
    -0.05577090f, -0.06656124f, 0.14573693f, 0.00336142f, -0.05185106f, -0.00590790f, 0.10032786f, -0.11040480f, 
    -0.03232606f, -0.06090549f, 0.04311080f, 0.04036018f, -0.02020661f, 0.22471982f, 0.08913450f, 0.11533085f, 
    -0.15983318f, 0.26555878f, -0.06937159f, -0.14887816f, -0.07918555f, -0.01500020f, 0.04165292f, 0.03093950f, 
    -0.06951573f, -0.01725010f, -0.05191912f, -0.12773053f, -0.09008025f, 0.09976602f, -0.06975546f, -0.21542892f, 
    -0.03805849f, 0.03860727f, -0.10151532f, -0.15316552f, -0.12326171f, 0.08913257f, -0.22097093f, 0.17329299f, 
    -0.02591123f, 0.00211886f, 0.09258264f, -0.02033290f, -0.06465459f, -0.01263459f, 0.05515254f, 0.09968615f, 
    -0.00321236f, 0.01111179f, 0.10515134f, 0.10998795f, 0.01758702f, -0.03887028f, -0.05626865f, 0.02187720f, 
    0.10221748f, 0.17864566f, -0.05830025f, -0.14798552f, 0.20979014f, 0.02137078f, -0.06550096f, 0.12113195f, 
    -0.01510212f, 0.15739381f, 0.02188925f, 0.05919864f, 0.02714945f, 0.20548849f, -0.01121362f, -0.03691525f, 
    0.05350389f, 0.07614611f, -0.16350718f, -0.07036626f, -0.14620663f, 0.03528698f, 0.34126821f, 0.02877443f, 
    0.33029515f, 0.02312322f, 0.14195107f, 0.14367551f, 0.09867146f, 0.13225935f, 0.13323899f, -0.11197004f, 
    0.18561000f, 0.00493502f, 0.05699013f, 0.04405101f, 0.12392974f, 0.01292538f, 0.05079804f, -0.00872852f, 
    -0.54942203f, -0.08153341f, 0.11091619f, -0.37226146f, 0.07094647f, -0.12314106f, 0.03962513f, -0.13680729f, 
    0.19975804f, -0.14071287f, -0.07293658f, -0.06383725f, 0.13582885f, -0.09365063f, -0.00390225f, 0.02223930f, 
    -0.10190893f, -0.11998937f, -0.16527566f, -0.02464372f, -0.00247171f, 0.00785708f, -0.16251732f, -0.12296564f, 
    0.08377393f, 0.04856626f, -0.03371353f, 0.19039710f, -0.09246603f, 0.00271346f, 0.00767337f, -0.05536015f, 
    0.03662135f, -0.08059642f, 0.06703003f, 0.06416065f, -0.08099973f, -0.11476284f, -0.03877333f, -0.04217602f, 
    -0.31944147f, -0.26224679f, -0.02631408f, -0.18745571f, -0.13975558f, -0.04992781f, -0.08941533f, -0.31736562f, 
    0.02107736f, -0.21355480f, 0.06358179f, -0.11143898f, 0.02493265f, -0.06304319f, 0.04142477f, -0.04357918f, 
    0.06631587f, 0.03707658f, 0.12620626f, -0.11319509f, 0.06551914f, -0.17904314f, -0.16032873f, 0.03743480f, 
    0.09346869f, -0.03737156f, -0.11710352f, -0.13670100f, -0.08198344f, -0.24539509f, 0.00509146f, 0.02470353f, 
    -0.12331617f, -0.00554598f, 0.08127606f, -0.06924126f, -0.07696843f, 0.03934694f, -0.02181352f, -0.05294306f, 
    0.04713156f, 0.16771276f, -0.31242004f, -0.18202199f, 0.05095300f, -0.09363019f, 0.02238144f, 0.11462565f, 
    -0.05383123f, 0.11173188f, -0.03557207f, 0.09391097f, -0.04610093f, 0.00256781f, -0.07068671f, 0.02936989f, 
    -0.04723429f, -0.03292911f, 0.04064925f, -0.10877655f, -0.16201042f, 0.11309198f, 0.14127265f, 0.02512993f, 
    0.08356047f, 0.07964488f, 0.07762180f, 0.04973719f, -0.02154790f, -0.01389055f, 0.07701349f, 0.02413065f, 
    -0.02852911f, -0.01568200f, 0.05449574f, 0.05724518f, -0.04883010f, -0.05926929f, -0.03520089f, 0.03556593f, 
    0.02359892f, 0.02362129f, 0.03693939f, -0.02472321f, 0.03281044f, 0.02135970f, -0.03789191f, -0.03011036f, 
    -0.00236824f, -0.04172792f, 0.00768261f, 0.05006801f, 0.01009437f, 0.03884300f, 0.02169475f, 0.03860954f, 
    0.02231306f, -0.04403765f, 0.05061275f, -0.00440937f, 0.04282441f, 0.04759924f, 0.04106075f, 0.00701641f, 
    -0.04101353f, -0.01992598f, 0.01745552f, 0.00311027f, -0.03741217f, -0.01211840f, -0.00856590f, -0.01061188f, 
    0.00374462f, 0.02628592f, 0.01352893f, 0.00432401f, -0.05272219f, 0.01984751f, 0.03276319f, 0.01256523f, 
    0.01615375f, 0.01579760f, 0.04431814f, 0.04391827f, 0.01092389f, -0.01803261f, -0.03483919f, -0.01537821f, 
    -0.01478232f, -0.01257132f, -0.00912176f, 0.01200812f, 0.00277395f, 0.04785076f, -0.02213452f, -0.04442606f, 
    -0.02945542f, 0.04298717f, -0.02868021f, -0.05674208f, -0.01207003f, 0.00796556f, -0.05517761f, 0.03589760f, 
    0.02714826f, -0.00197582f, -0.01454535f, -0.03989789f, -0.05424975f, 0.00764336f, 0.01282496f, -0.00086140f, 
    -0.03926745f, 0.01366963f, -0.02366601f, -0.04561755f, -0.04106557f, -0.02161803f, -0.04762276f, -0.01165632f, 
    -0.01829343f, 0.04942699f, 0.03901730f, -0.04123228f, 0.02854701f, -0.01102020f, 0.00089381f, -0.04835110f, 
    0.00139055f, 0.01932740f, 0.02153192f, -0.01470335f, 0.00075149f, -0.00599216f, -0.00917182f, -0.00888096f, 
    -0.00871206f, 0.01993097f, -0.02001870f, 0.01340865f, -0.03164919f, -0.04638226f, 0.02638687f, 0.02451568f, 
    -0.02961389f, -0.03859869f, -0.04738173f, -0.01832449f, -0.06449045f, 0.02255512f, -0.01311251f, 0.01009936f, 
    -0.04763215f, -0.05324457f, 0.04727924f, 0.02272153f, -0.02147480f, 0.00567826f, -0.05650879f, 0.02708829f, 
    0.03982353f, -0.01066812f, -0.04865991f, -0.05627317f, 0.00037764f, 0.01235523f, -0.01789523f, 0.03400326f, 
    -0.06019688f, 0.01225502f, -0.01134172f, -0.03681323f, 0.02215195f, 0.02644303f, -0.05937875f, -0.02674448f, 
    -0.04495682f, -0.00603269f, 0.03608466f, -0.02786115f, 0.02088609f, -0.01748312f, -0.03364119f, -0.02076083f, 
    0.01014701f, 0.00048822f, -0.03767434f, -0.03229634f, -0.06374492f, 0.05078044f, 0.02173021f, -0.02742513f, 
    -0.00844943f, 0.00224573f, -0.03317754f, 0.01415773f, 0.04371879f, -0.04326712f, 0.00594939f, 0.01635165f, 
    -0.02068719f, -0.04484540f, -0.01690925f, -0.03625758f, 0.04504818f, -0.00528373f, -0.03595056f, 0.00089446f, 
    -0.01958158f, 0.01221448f, 0.03459515f, 0.01990180f, -0.00373396f, -0.05590823f, -0.01573027f, -0.00761737f, 
    -0.02254425f, -0.04220564f, -0.04319190f, -0.02440893f, -0.03906262f, -0.01561313f, 0.01340489f, -0.04136514f, 
    0.03806113f, -0.05353194f, 0.01671942f, -0.01313468f, -0.03924027f, -0.04723095f, -0.01686965f, -0.03087583f, 
    0.04040523f, 0.04141898f, -0.03630231f, 0.00196077f, -0.04251866f, -0.05155345f, -0.05116215f, -0.01325591f, 
    0.00202687f, 0.01547693f, 0.04429206f, -0.01844728f, 0.00385911f, 0.01584148f, 0.02479709f, -0.01173127f, 
    0.04580960f, 0.02312998f, 0.03861587f, -0.00462455f, -0.05553818f, -0.00139360f, -0.01160827f, 0.04960328f, 
    -0.00819935f, 0.04013938f, -0.00009549f, 0.03490357f, -0.02035766f, -0.00326877f, 0.01174983f, -0.05444328f, 
    0.03302859f, -0.00787128f, 0.00823216f, 0.04117464f, -0.02907132f, -0.01888247f, 0.04640558f, 0.04133248f, 
    0.02738149f, 0.01158883f, -0.01406624f, -0.03601888f, -0.03839966f, 0.00320561f, -0.01662029f, 0.00542809f, 
    -0.05676624f, -0.02544034f, -0.02468055f, -0.05213002f, -0.00283052f, 0.00917733f, -0.01529447f, -0.00409174f, 
    0.05166825f, -0.03418041f, 0.04042646f, -0.04039105f, -0.00404858f, -0.00203019f, 0.03805928f, 0.04211487f, 
    0.05258260f, 0.03469332f, 0.01255649f, -0.02579791f, 0.04351049f, -0.00471455f, -0.06005597f, -0.02252734f, 
    -0.03574902f, 0.01057560f, 0.00648041f, 0.04152953f, 0.05006051f, -0.05736654f, 0.02630725f, 0.03294472f, 
    -0.01692733f, -0.02773202f, -0.01135006f, 0.02409493f, 0.03726006f, 0.03256137f, -0.03796422f, 0.03811050f, 
    0.02180465f, 0.00408629f, -0.03837824f, 0.00668123f, -0.04000338f, -0.03508415f, -0.01179059f, 0.01380126f, 
    -0.05783328f, 0.00477571f, 0.03270928f, 0.00871239f, 0.03826871f, -0.04491689f, -0.04334291f, 0.01853881f, 
    -0.01602241f, 0.00817857f, -0.05461002f, -0.02160944f, -0.05305647f, -0.01615984f, -0.04662536f, -0.00727294f, 
    -0.03185010f, -0.04751493f, -0.00814732f, -0.05379007f, 0.01928053f, -0.03005526f, -0.03161584f, 0.00339148f, 
    0.04850738f, -0.01508862f, 0.02392660f, -0.02125119f, 0.00702439f, 0.04323401f, -0.05078145f, 0.02191010f, 
    -0.25254712f, -0.31903186f, -0.29795441f, 0.16517141f, 0.24058810f, -0.00400965f, -0.04379923f, -0.20544934f, 
    0.00733906f, -0.09787127f, 0.03483130f, -0.02534446f, -0.08363263f, -0.00070876f, 0.05872615f, 0.05081025f, 
    0.04958384f, 0.07620467f, 0.05627365f, 0.17706421f, 0.06193458f, -0.42045766f, -0.03417712f, -0.16676840f, 
    -0.00324637f, 0.05073974f, 0.06645351f, 0.04352028f, -0.08087891f, 0.15203771f, 0.00092983f, 0.04900590f, 
    0.04452985f, 0.05189164f, 0.10899857f, 0.02536386f, 0.01272247f, -0.10903618f, 0.04106451f, -0.01063835f, 
    0.51495838f, -0.18293707f, 0.06153363f, -0.18010777f, 0.01299349f, 0.16302805f, -0.13012317f, 0.02213355f, 
    -0.02819325f, -0.11072193f, -0.11436179f, 0.04333512f, 0.03460741f, 0.09595136f, -0.03273757f, -0.09205604f, 
    0.02236033f, -0.09223565f, -0.00181836f, -0.02219174f, 0.24481268f, -0.25299960f, 0.02280219f, 0.00828067f, 
    0.24211101f, 0.00222149f, 0.23931538f, 0.15094626f, 0.11481885f, 0.10032140f, -0.03308341f, -0.02093678f, 
    0.16356359f, -0.02318924f, 0.05777332f, 0.22455965f, 0.09360726f, 0.07466178f, 0.20397542f, -0.02376170f, 
    0.02710815f, -0.34464270f, -0.02152708f, -0.22954206f, 0.01767495f, 0.12338877f, 0.03869117f, -0.02967298f, 
    0.00975628f, -0.01037169f, -0.00500700f, -0.04990046f, -0.00664086f, 0.04633276f, 0.07581934f, 0.08781868f, 
    0.03884443f, -0.11033163f, 0.00309209f, 0.02297444f, -0.25016922f, -0.07139420f, -0.26416153f, 0.32114354f, 
    0.14206347f, -0.09580321f, 0.06427118f, -0.14972813f, 0.02506232f, -0.00212533f, 0.08469781f, 0.00306277f, 
    -0.05302459f, 0.04661658f, 0.08417135f, 0.00805607f, 0.08088740f, 0.12839597f, 0.03903775f, 0.12107785f, 
    0.31803650f, 0.14229971f, 0.19341345f, -0.18668143f, -0.12895651f, -0.15935095f, -0.04053844f, -0.11244922f, 
    -0.04544589f, -0.15308589f, -0.04249519f, -0.01744286f, -0.05973548f, 0.03484175f, -0.11217000f, -0.03230745f, 
    -0.03590161f, -0.02041739f, -0.22345342f, -0.11044578f, 0.17563905f, 0.01741534f, -0.21076715f, 0.22299401f, 
    -0.10992032f, 0.00397010f, 0.18620096f, -0.04934859f, 0.10721619f, -0.06899390f, 0.00427499f, 0.03990440f, 
    0.06974013f, 0.02066331f, 0.13838972f, 0.02924659f, 0.08084846f, -0.07923629f, 0.08514256f, -0.04828303f, 
    -0.31173316f, 0.03705924f, -0.11472525f, 0.51301378f, 0.18554938f, 0.12711410f, 0.00639817f, 0.13264322f, 
    0.11088063f, 0.17046885f, -0.04818988f, 0.04157918f, 0.02913250f, 0.00370629f, -0.08907387f, 0.08535005f, 
    0.07644220f, 0.06317808f, 0.07082286f, -0.04192292f, -0.11184647f, 0.04861083f, 0.24618128f, 0.19462563f, 
    0.20096312f, 0.05014687f, 0.03763102f, 0.13358858f, 0.14846756f, 0.14714356f, 0.11630321f, 0.05792504f, 
    0.14562044f, -0.06599884f, -0.00889335f, 0.08110171f, 0.05226535f, 0.03342150f, -0.10296430f, -0.09114017f, 
    -0.09987929f, -0.17767115f, 0.18508646f, -0.11260024f, -0.06631713f, -0.23471138f, 0.00665392f, -0.08626192f, 
    0.03659313f, -0.19899103f, -0.15676658f, 0.12274991f, 0.09243933f, -0.19171375f, 0.01368078f, 0.14483956f, 
    -0.02614528f, -0.20309268f, -0.17743146f, -0.08524968f, -0.26774207f, 0.07201665f, -0.06945070f, 0.16220598f, 
    0.34334487f, -0.14520954f, -0.13103785f, 0.05649656f, -0.03738437f, 0.04777555f, -0.08987580f, 0.03554738f, 
    0.05656406f, -0.04019749f, -0.09208056f, 0.12669478f, 0.03171086f, 0.04128938f, -0.03364258f, 0.03755993f, 
    -0.20253213f, -0.32856503f, -0.18621986f, 0.01074969f, 0.08032541f, 0.01843341f, -0.14681205f, -0.28903916f, 
    0.02536709f, -0.13444652f, -0.03279707f, 0.04770906f, -0.04212722f, 0.00094254f, -0.02737839f, 0.10235713f, 
    0.02910477f, -0.00980978f, 0.04264786f, -0.03007283f, 0.29094931f, 0.02331232f, 0.17083766f, -0.13803498f, 
    -0.16381286f, -0.03984982f, -0.16419938f, -0.15122989f, -0.12125517f, -0.20918421f, -0.00359041f, 0.00158554f, 
    -0.03174798f, 0.01439207f, -0.00854940f, -0.15846829f, -0.10158651f, -0.05635069f, 0.00378792f, -0.16986093f, 
    -0.12987202f, -0.22254726f, -0.10012010f, -0.13345176f, 0.04587001f, -0.05288659f, 0.13467120f, -0.01615438f, 
    -0.08846736f, -0.03445138f, 0.15781112f, 0.04613438f, 0.02489846f, 0.02098491f, 0.03756247f, -0.10220821f, 
    0.04018072f, 0.00471880f, -0.18987778f, -0.00425547f, 0.28039417f, 0.22602855f, 0.36670956f, 0.08141513f, 
    -0.07844701f, -0.04477241f, -0.01146176f, -0.13261615f, -0.03331075f, -0.11735494f, 0.05153003f, 0.06720265f, 
    0.07904851f, 0.07930867f, 0.14290026f, 0.02786263f, -0.01169319f, 0.06425802f, 0.11325330f, 0.06468719f, 
    -0.19248879f, 0.02129758f, 0.44142622f, -0.04140756f, -0.25727189f, -0.04972235f, -0.06241901f, 0.11050623f, 
    -0.05465734f, -0.14753489f, -0.05598782f, 0.01346231f, 0.10363061f, -0.06597029f, 0.02956112f, 0.00824120f, 
    -0.00502012f, 0.10860065f, 0.20310277f, -0.01659073f, -0.51300895f, 0.03510258f, -0.24314171f, 0.22819836f, 
    0.11970183f, 0.01285723f, 0.01104139f, -0.20127061f, 0.03188711f, -0.17356011f, 0.20079614f, 0.04457781f, 
    0.07691333f, -0.02551271f, 0.13841979f, 0.04711445f, 0.00284316f, 0.06153486f, -0.00571232f, -0.08867795f, 
    -0.24871825f, -0.11471467f, -0.11650004f, 0.33116046f, -0.09800351f, 0.23309003f, 0.15142918f, -0.06823078f, 
    -0.08836366f, 0.06747840f, -0.03960858f, 0.13085136f, -0.06220792f, -0.03194309f, -0.04859383f, 0.00887627f, 
    0.04736959f, 0.11741297f, 0.02796154f, 0.01906619f, 0.15979093f, -0.00057198f, 0.07489111f, 0.14986074f, 
    -0.11935920f, 0.11662849f, -0.07656589f, -0.11622688f, 0.07399303f, 0.12302043f, 0.17563243f, 0.24953085f, 
    -0.04662513f, 0.04015240f, -0.05633150f, 0.25466490f, -0.05233451f, 0.05457306f, 0.01772282f, 0.29165262f, 
    -0.50748265f, 0.21434225f, -0.17945112f, 0.20223831f, 0.09743310f, 0.01208764f, -0.01116428f, -0.23703775f, 
    0.03532353f, 0.00687405f, 0.14102887f, 0.02338022f, 0.01935253f, -0.04553131f, 0.04842165f, 0.02133805f, 
    0.03747867f, 0.07527407f, 0.02651494f, 0.03745177f, 0.21979097f, -0.04960251f, 0.34375113f, -0.23604985f, 
    -0.15963805f, 0.12153606f, 0.06545029f, -0.00272772f, 0.03433693f, 0.03126968f, 0.11681802f, 0.03934733f, 
    0.03582629f, 0.01251980f, -0.02350753f, 0.03049161f, -0.01978928f, 0.08817510f, 0.17725939f, 0.02578614f, 
    -0.24247587f, -0.03691704f, -0.21775909f, 0.12002333f, 0.10262443f, 0.00282227f, -0.03137425f, -0.00974862f, 
    -0.01269685f, 0.13230461f, -0.13374674f, -0.09963757f, -0.03380054f, -0.06355976f, 0.13145447f, -0.03363253f, 
    0.02712927f, -0.16380976f, -0.10333702f, 0.02735128f, 0.24656270f, 0.00696955f, -0.00190971f, -0.11190014f, 
    0.10718723f, 0.00411829f, 0.12294383f, -0.05725904f, -0.07468480f, 0.00902100f, 0.13001473f, 0.01933629f, 
    -0.05773203f, -0.06744128f, -0.00953390f, 0.09444868f, -0.00323509f, 0.20186754f, -0.02121896f, 0.07105935f, 
    -0.14848115f, -0.25010982f, -0.04713579f, 0.05838161f, -0.17724012f, -0.05182653f, -0.06703059f, -0.04738680f, 
    -0.08864905f, 0.05734772f, 0.15887426f, -0.04811828f, 0.05306827f, 0.11507963f, 0.10003649f, -0.09500995f, 
    -0.08316161f, -0.19301574f, 0.05503485f, 0.20153859f, -0.06716243f, -0.24154466f, -0.04474876f, -0.04195888f, 
    -0.21284130f, 0.01122138f, 0.00574437f, -0.00685524f, 0.07356644f, 0.05196886f, 0.00483699f, 0.10254636f, 
    -0.08871017f, 0.02970340f, 0.08714809f, -0.02287672f, 0.02712757f, -0.03617624f, 0.01999747f, -0.02044149f, 
    0.18463653f, 0.02169466f, 0.07003259f, -0.06297968f, 0.25753513f, -0.08620591f, 0.01450769f, -0.08782244f, 
    -0.14999434f, -0.00841318f, -0.00222775f, -0.04133031f, -0.21179684f, 0.10326044f, -0.01191221f, -0.07070383f, 
    0.11442819f, 0.06019590f, -0.03953416f, 0.04019817f, -0.29071486f, -0.05796563f, 0.05544031f, 0.24662082f, 
    -0.34720123f, 0.01504354f, 0.05684416f, 0.12634292f, 0.00406930f, 0.18622351f, 0.08490561f, -0.02957808f, 
    0.03630506f, 0.00720894f, -0.10119799f, -0.07919557f, 0.09553231f, -0.02426184f, 0.20596081f, 0.11185536f, 
    0.20150977f, 0.31641546f, 0.06315732f, -0.02328234f, -0.23823735f, 0.05723683f, 0.03567067f, 0.09561323f, 
    -0.00610469f, -0.11345515f, 0.14143519f, 0.05531219f, 0.07460783f, 0.10818015f, -0.05942344f, 0.11428553f, 
    -0.04512094f, -0.09712985f, -0.07419373f, -0.04933597f, -0.13748471f, 0.11258452f, -0.13241704f, -0.00575608f, 
    0.17433260f, 0.18320291f, 0.02604080f, -0.11914432f, -0.03764738f, 0.08730273f, -0.20169851f, 0.10717692f, 
    -0.06623544f, -0.08003576f, -0.05205541f, -0.07651740f, -0.10668752f, -0.11906882f, -0.12555653f, -0.01950387f, 
    0.03180806f, 0.17689703f, -0.06278826f, 0.14691496f, -0.02966457f, 0.01620991f, -0.12437647f, -0.05343724f, 
    0.02091210f, 0.00394510f, -0.10405193f, -0.08608969f, -0.17993270f, 0.00563668f, 0.03849011f, 0.07767250f, 
    0.16243812f, -0.07721532f, 0.05184757f, 0.03742034f, 0.17619346f, 0.18905909f, -0.37884352f, -0.05859318f, 
    0.28184795f, 0.15824288f, 0.06267723f, 0.08494443f, -0.00302778f, -0.02437381f, -0.10519046f, 0.08622594f, 
    -0.02615811f, -0.00246495f, 0.00690262f, 0.06926066f, -0.02577219f, 0.11254025f, -0.06874284f, -0.19535626f, 
    -0.08604536f, -0.28071856f, -0.09645161f, 0.10245716f, 0.03433363f, 0.15916891f, 0.01796563f, -0.11306293f, 
    0.06645881f, -0.07814425f, 0.00813559f, -0.00116017f, 0.06774402f, 0.02813626f, 0.06311380f, -0.03505071f, 
    0.13102944f, -0.04629818f, -0.03566328f, 0.25751358f, 0.57577401f, 0.11519138f, -0.05266403f, -0.24948555f, 
    -0.36418542f, -0.02369494f, -0.04266864f, -0.01131389f, 0.09126853f, -0.07474032f, 0.02748180f, 0.02398412f, 
    -0.02326354f, -0.05202118f, 0.10556196f, -0.08578642f, -0.04786953f, 0.03964322f, -0.00536216f, -0.04890468f, 
    0.10846115f, -0.12030599f, 0.35808602f, -0.02150635f, 0.05817329f, -0.04123019f, 0.02212099f, -0.13445628f, 
    -0.04678779f, -0.01143192f, 0.01678985f, 0.10050704f, 0.00785577f, 0.02082957f, 0.00379193f, 0.03832155f, 
    -0.15547736f, -0.00405828f, -0.08515537f, -0.13853577f, 0.16723014f, -0.25305519f, 0.03372111f, 0.16287385f, 
    0.15089577f, 0.06979945f, 0.16073906f, 0.02447579f, 0.19404435f, 0.11473630f, 0.05296582f, 0.02357462f, 
    0.02657082f, -0.07372247f, -0.06470279f, 0.17877606f, 0.03388217f, -0.02083911f, 0.04312792f, 0.20775929f, 
    0.65050405f, 0.16407612f, -0.15194891f, -0.12095714f, -0.30162400f, -0.06420261f, -0.03358680f, 0.08677496f, 
    -0.04474939f, -0.03851178f, -0.10228597f, -0.11083268f, 0.08534214f, 0.03812504f, 0.00470605f, -0.03699943f, 
    -0.04879963f, 0.14847353f, 0.07900384f, 0.06164357f, -0.02125515f, -0.01788663f, -0.05886433f, 0.24744463f, 
    0.14741518f, 0.03833112f, 0.06661887f, 0.02911920f, 0.06174761f, 0.00100462f, 0.03479373f, 0.03500455f, 
    0.05871987f, -0.00942026f, 0.04222451f, -0.00278439f, -0.04747031f, -0.08706662f, 0.12883189f, 0.05214780f, 
    0.00723974f, 0.12754089f, 0.17993544f, -0.09995824f, -0.28558895f, -0.00903209f, -0.19713283f, -0.09838566f, 
    -0.09921621f, -0.05077973f, 0.06521354f, 0.00374546f, 0.00888897f, 0.00677340f, 0.02646717f, -0.02124260f, 
    0.02824610f, 0.19803104f, 0.03646587f, -0.03016519f, -0.15866201f, -0.00973879f, 0.12303067f, 0.02411319f, 
    0.05354569f, 0.00242579f, 0.07413255f, -0.07934581f, 0.01896478f, 0.05863149f, -0.00562854f, -0.09322044f, 
    0.09039274f, 0.05014028f, 0.00838283f, 0.09936458f, 0.11928050f, 0.07747430f, 0.27626163f, 0.08026767f, 
    -0.24919577f, -0.02391172f, -0.03770839f, 0.21714045f, 0.32434386f, 0.19762108f, 0.05121997f, 0.08735268f, 
    0.14471215f, -0.02109752f, -0.07797939f, 0.06889553f, -0.09892196f, -0.06267529f, 0.04460588f, -0.05269501f, 
    -0.15843520f, -0.15764259f, 0.08823936f, -0.09359287f, 0.02669674f, 0.06058444f, -0.06076569f, -0.15653789f, 
    0.16515099f, -0.01237368f, -0.02963152f, 0.03440928f, 0.20621370f, 0.09882582f, 0.05474610f, 0.08758625f, 
    -0.03699600f, -0.03828640f, 0.05708912f, -0.09474085f, -0.06656015f, -0.07067741f, -0.03145184f, 0.01814698f, 
    -0.08137351f, 0.14036436f, -0.00775527f, 0.14669119f, -0.09499735f, -0.07738519f, -0.07183478f, -0.02758299f, 
    -0.13834190f, -0.07587006f, 0.06462293f, -0.19376320f, -0.05578649f, -0.00584703f, -0.01055086f, 0.04592820f, 
    0.03386538f, -0.02565396f, 0.02679504f, -0.00875860f, -0.22920878f, -0.04704708f, -0.20796078f, 0.09109067f, 
    0.19438170f, -0.04464418f, 0.12228969f, 0.08072601f, 0.06515735f, -0.07923419f, 0.01134225f, 0.02551612f, 
    0.00308697f, -0.09341212f, -0.08517402f, 0.01210905f, -0.00105769f, 0.01706063f, -0.08301211f, -0.08340909f, 
    0.11819940f, -0.29437673f, 0.15167560f, -0.01006775f, 0.24085306f, 0.16761234f, 0.10206278f, 0.08337373f, 
    -0.07350232f, 0.05053643f, 0.14709198f, 0.00755082f, -0.03555983f, 0.03396990f, -0.02366981f, 0.06325291f, 
    -0.04083242f, -0.13745111f, -0.09285098f, -0.17657019f, -0.09618278f, 0.02869947f, 0.09436589f, -0.14526269f, 
    -0.04804562f, 0.14616053f, -0.09405927f, 0.12199850f, 0.05505722f, -0.12943485f, -0.01178375f, 0.00979374f, 
    -0.00140951f, 0.00757511f, -0.02672093f, -0.20187427f, -0.06471197f, 0.14025068f, 0.06911543f, 0.00331316f, 
    0.18879054f, -0.16343400f, -0.28601074f, 0.01954683f, -0.13413265f, 0.09267765f, 0.00421893f, 0.04549224f, 
    -0.00432144f, 0.04554087f, -0.07015334f, -0.07917362f, 0.03464196f, 0.06283820f, -0.04120705f, 0.08961330f, 
    0.09700035f, 0.21649776f, -0.04653841f, 0.04670925f, -0.13821761f, 0.21478710f, 0.24126676f, -0.06166900f, 
    0.01586569f, 0.05585099f, -0.03668772f, -0.06340262f, 0.06066249f, -0.05406530f, 0.07021771f, -0.05264287f, 
    0.05882546f, 0.03787679f, -0.02662937f, -0.05127902f, -0.11856959f, 0.24811752f, 0.17815655f, -0.00896244f, 
    0.30624971f, 0.46973494f, 0.39877021f, 0.13595061f, 0.02214362f, 0.22500408f, 0.17583284f, -0.01319889f, 
    0.11252615f, 0.12155278f, -0.03280995f, 0.03144841f, -0.01680575f, 0.08464707f, 0.03129372f, -0.01727522f, 
    0.04395814f, -0.15726908f, -0.16440304f, 0.04642447f, 0.40398940f, 0.09320796f, -0.17977509f, -0.20083795f, 
    -0.09841463f, 0.16449372f, -0.15897018f, 0.11245204f, 0.05298318f, 0.01644637f, -0.07004322f, -0.04843005f, 
    -0.07544142f, 0.00606636f, 0.05345497f, -0.00990440f, 0.07106385f, 0.05358113f, -0.03390666f, 0.03144876f, 
    0.06153560f, 0.03001972f, 0.29340035f, 0.12618695f, 0.11168201f, 0.03672594f, -0.02229793f, -0.26615778f, 
    0.10048981f, 0.08372371f, 0.04467022f, -0.01920686f, 0.01160529f, -0.01463308f, 0.00510169f, -0.01112338f, 
    0.04326467f, 0.12073150f, -0.05950654f, -0.07537572f, 0.17914180f, -0.12723789f, -0.00875520f, 0.06650724f, 
    0.05767586f, 0.18773086f, -0.10169696f, 0.02169237f, 0.01864799f, 0.14133620f, -0.03935899f, 0.10944618f, 
    -0.00556885f, 0.03749514f, 0.12544638f, 0.05417777f, -0.03717183f, -0.01170245f, 0.01857398f, 0.03745395f, 
    0.36815569f, -0.11050660f, -0.22911078f, -0.15698144f, -0.24303244f, 0.05549955f, -0.15547231f, -0.10378905f, 
    -0.06573366f, -0.18489413f, -0.05161327f, 0.08294569f, -0.03442805f, 0.04358646f, -0.00535134f, 0.08141100f, 
    0.07515319f, 0.10479619f, -0.01940071f, 0.10434250f, 0.02648837f, 0.16547675f, 0.01632323f, 0.20609066f, 
    0.34610245f, 0.03865378f, 0.03760111f, 0.00235825f, -0.16695225f, 0.14571242f, 0.00977217f, 0.04413199f, 
    0.12681302f, 0.01602948f, 0.01896171f, 0.02867267f, 0.01348715f, -0.12006457f, 0.04204140f, 0.02122502f, 
    -0.31131461f, -0.29644975f, -0.11085260f, 0.01170003f, -0.04387179f, 0.07562981f, -0.11058226f, -0.22034712f, 
    -0.21793419f, -0.07823289f, 0.11319398f, 0.19687587f, -0.04684483f, 0.07932421f, 0.04043513f, 0.05747810f, 
    0.09393816f, 0.12830411f, -0.00092530f, -0.07352731f, -0.00220083f, -0.10400251f, -0.22563393f, -0.23793253f, 
    -0.10411043f, -0.03270329f, -0.09943493f, 0.10267518f, -0.05030460f, 0.02037106f, 0.12114356f, -0.04337410f, 
    0.18277486f, -0.11110797f, -0.13115466f, 0.10908036f, -0.04452106f, 0.06735887f, 0.18296725f, -0.04721606f, 
    -0.21216734f, 0.33579713f, 0.17794597f, -0.10486390f, 0.25685567f, 0.13335927f, 0.19741070f, 0.19926979f, 
    0.00765864f, -0.07157177f, -0.04624199f, 0.09589995f, -0.08911172f, -0.04858452f, 0.02869427f, -0.06319542f, 
    -0.00588892f, 0.04427528f, -0.05858946f, -0.04192598f, 0.01513630f, 0.08036319f, -0.11059026f, -0.12975368f, 
    0.15405686f, 0.16931693f, 0.04217667f, 0.25239909f, 0.03663261f, -0.05017143f, -0.06874532f, 0.08280580f, 
    0.02128687f, -0.07825644f, 0.05544189f, -0.02754673f, -0.00134185f, -0.02949958f, -0.00524195f, -0.10028819f, 
    0.08867740f, -0.04853610f, -0.36483335f, 0.06963205f, -0.05715572f, 0.00676855f, 0.02855687f, -0.25197452f, 
    -0.15197717f, 0.00913133f, 0.19723803f, 0.07844277f, 0.07996032f, -0.16332893f, 0.07671900f, -0.07080027f, 
    0.13230267f, 0.07348536f, -0.00758668f, -0.01627492f, -0.08844546f, 0.19626354f, -0.03570941f, 0.06905381f, 
    0.37852153f, -0.03884057f, 0.14436324f, 0.14571859f, -0.09129351f, -0.14264187f, -0.04669933f, 0.00950629f, 
    -0.10286167f, 0.04504581f, 0.09994961f, 0.08815428f, 0.01757056f, -0.01113921f, -0.14666964f, 0.04460597f, 
    -0.22792992f, 0.11187648f, 0.36153811f, 0.07282262f, 0.16432965f, 0.11112066f, 0.23236483f, 0.13880423f, 
    0.09637461f, 0.26869732f, -0.01096366f, -0.00387407f, -0.05487599f, 0.00618749f, -0.07711439f, 0.01093393f, 
    0.11044348f, -0.14822903f, -0.02608351f, 0.00075606f, -0.27846694f, 0.27876392f, 0.28905118f, 0.06390751f, 
    -0.12608178f, 0.07328275f, -0.08431155f, -0.10306039f, -0.06369742f, -0.08377082f, 0.17026663f, 0.04532206f, 
    0.09697043f, 0.08759691f, 0.04780138f, -0.03800303f, 0.13375798f, -0.21352692f, 0.03246500f, -0.05727461f, 
    -0.03024356f, -0.24770963f, -0.20184948f, -0.11674447f, -0.07066029f, 0.14509945f, 0.04049609f, -0.01463479f, 
    -0.09680538f, 0.03050809f, 0.10455286f, 0.05288833f, -0.05026739f, 0.08787730f, -0.00466784f, 0.11106180f, 
    -0.02332286f, 0.12633769f, -0.05029434f, 0.07918381f, -0.33637396f, 0.04560332f, 0.01291593f, 0.09066803f, 
    -0.12468603f, -0.00012246f, -0.06544864f, -0.07568824f, -0.01362389f, -0.01201788f, 0.13615537f, 0.04468066f, 
    0.07811346f, 0.07585628f, -0.07572970f, 0.06380378f, 0.16728963f, -0.02690269f, 0.07568041f, -0.06713296f, 
    -0.11790029f, -0.01410159f, 0.11906903f, -0.37787452f, 0.02219847f, 0.10861153f, 0.13408527f, -0.12356865f, 
    0.10801884f, -0.08029432f, 0.00973247f, -0.01847636f, -0.07909946f, 0.03964846f, 0.02908112f, -0.08971987f, 
    -0.06522745f, 0.13411792f, -0.02782982f, 0.06395460f, -0.20033371f, -0.39261296f, 0.09185866f, 0.02846828f, 
    0.14889023f, 0.04574847f, -0.05789332f, 0.02700902f, 0.01017863f, 0.20281488f, -0.17617242f, -0.05797392f, 
    -0.08370166f, 0.07059611f, -0.01983398f, -0.01902337f, 0.12882540f, 0.04934752f, 0.01202969f, 0.03152520f, 
    -0.47770736f, 0.10127962f, -0.06816410f, -0.19061378f, 0.00858478f, -0.03091013f, 0.00120468f, -0.06077646f, 
    0.13224295f, -0.07970016f, -0.05502111f, -0.03719002f, -0.02193657f, 0.06849477f, 0.06442773f, -0.05697705f, 
    0.09405639f, 0.04927829f, 0.09479953f, -0.15041180f, -0.10996395f, 0.28948870f, -0.08974931f, 0.02444516f, 
    -0.08360967f, 0.10341693f, 0.06282169f, -0.01002496f, 0.04609470f, 0.00832216f, 0.00520690f, 0.00402676f, 
    0.09584740f, -0.01659004f, 0.01154285f, 0.07562005f, -0.00043337f, -0.01600699f, 0.11397430f, -0.01621457f, 
    -0.42022154f, -0.14581162f, 0.19513841f, 0.09953190f, 0.23287868f, 0.03204294f, -0.12303916f, 0.05275745f, 
    0.08457983f, 0.09835634f, -0.04708075f, 0.13255809f, -0.09480096f, -0.08180254f, 0.01586447f, -0.00647481f, 
    0.12884511f, -0.06912123f, 0.04818057f, 0.02065498f, 0.04244497f, 0.26031116f, -0.24391076f, -0.01907366f, 
    -0.20328128f, 0.15194388f, 0.16516568f, 0.09579834f, -0.05977601f, -0.04085543f, 0.16618215f, -0.04245637f, 
    0.00864460f, -0.00067202f, -0.01190950f, -0.08926233f, -0.07939535f, 0.19212312f, 0.02990720f, 0.16518393f, 
    0.20489845f, 0.00091973f, -0.02663228f, 0.11588870f, 0.19113640f, 0.00862184f, 0.04156521f, -0.06812504f, 
    -0.11008065f, 0.04383193f, -0.04898475f, 0.14480358f, -0.02484764f, 0.06744430f, -0.06613038f, -0.16687307f, 
    -0.06761335f, 0.06304072f, 0.02036746f, -0.09776253f, 0.21792014f, 0.10963276f, -0.27641708f, 0.03538612f, 
    -0.00276333f, -0.08556312f, -0.02561272f, -0.00016594f, -0.05451621f, -0.01073935f, 0.00546180f, 0.10362235f, 
    0.02619951f, -0.13189368f, -0.06693908f, 0.00201367f, -0.01351721f, 0.05244185f, -0.07958432f, 0.00597801f, 
    -0.12595783f, 0.50311708f, 0.15155119f, -0.25512120f, 0.06558681f, 0.01359581f, 0.08656929f, -0.03207934f, 
    0.01477311f, 0.18724817f, -0.01305650f, 0.06230848f, 0.05938610f, -0.07925441f, -0.06677940f, 0.02112821f, 
    -0.04443080f, 0.06666555f, 0.02818426f, 0.11592589f, -0.12505767f, -0.01494972f, 0.11340028f, -0.19127889f, 
    0.19693328f, 0.17300087f, 0.06493415f, 0.20091289f, 0.03550852f, 0.01311574f, -0.01404570f, -0.01323205f, 
    0.09656101f, 0.04319759f, -0.00111499f, -0.04287484f, -0.01882165f, 0.03400439f, -0.03419362f, -0.04132844f, 
    0.17316981f, 0.01755764f, 0.00329553f, 0.04167558f, 0.25900626f, -0.00097468f, 0.00808146f, 0.02677777f, 
    0.06107693f, -0.07600607f, 0.05624886f, -0.01685607f, 0.09606370f, -0.11747374f, -0.16267847f, -0.14961967f, 
    -0.01958516f, -0.04947263f, 0.03525695f, -0.03773827f, -0.05770018f, 0.29662371f, 0.02044003f, -0.17303322f, 
    -0.07343421f, 0.15825237f, 0.10304195f, 0.31841943f, 0.02715405f, 0.12923251f, -0.06991540f, -0.03596885f, 
    0.11185388f, -0.04060204f, -0.04301061f, -0.10522376f, -0.05756675f, -0.02702503f, -0.06965688f, -0.05049083f, 
    -0.06403052f, 0.28077686f, -0.01317182f, -0.00353062f, -0.29696894f, 0.08882731f, -0.01466909f, -0.01167005f, 
    0.03974648f, -0.16599074f, -0.15248206f, -0.05215876f, -0.09914070f, 0.04463593f, 0.13455203f, -0.08348754f, 
    -0.10773793f, 0.05170808f, 0.03884120f, -0.09271385f, 0.19564450f, -0.11607165f, 0.02051306f, 0.01418412f, 
    0.16447473f, -0.03679215f, -0.08752638f, -0.18157202f, 0.02778092f, 0.10910442f, -0.00285075f, 0.06266152f, 
    -0.03552514f, 0.04394547f, -0.04370321f, 0.13447638f, 0.05266779f, -0.06898735f, -0.06677092f, -0.11518142f, 
    -0.32015127f, -0.01153059f, 0.08786069f, -0.09453612f, 0.04521011f, -0.08978576f, 0.12666172f, 0.01931406f, 
    0.00261157f, 0.12976408f, -0.03360706f, 0.10074405f, 0.08112028f, 0.01984376f, -0.01301434f, -0.04489911f, 
    0.07023180f, -0.01942055f, 0.01637815f, 0.07279395f, 0.22642258f, -0.07977238f, 0.06801263f, 0.07143474f, 
    0.05446763f, 0.03119865f, -0.09094739f, -0.10050537f, -0.01190273f, -0.00607279f, 0.02984609f, 0.14575154f, 
    0.00621671f, -0.03791096f, -0.01762214f, 0.06996778f, 0.05277977f, -0.01118285f, 0.04973149f, -0.04143777f, 
    -0.36385748f, -0.44395086f, -0.26440257f, -0.12936524f, 0.00300311f, -0.04468818f, -0.07291907f, -0.14709219f, 
    -0.00035699f, -0.13049886f, -0.09719390f, 0.00966380f, -0.07073356f, 0.04511705f, -0.01063136f, 0.06928530f, 
    0.03605634f, 0.17052630f, -0.01172777f, -0.00256769f, -0.25473228f, -0.24001069f, 0.10220067f, 0.16414329f, 
    0.18502836f, -0.01397808f, 0.11267552f, -0.06395420f, -0.11026505f, 0.00877640f, 0.06745803f, 0.19926089f, 
    0.10258939f, 0.17007524f, 0.16824690f, 0.11104228f, 0.05534666f, -0.00912189f, 0.06053098f, 0.07285663f, 
    -0.04900843f, -0.13053043f, -0.42760587f, -0.09363730f, -0.03755359f, 0.16004094f, 0.20437323f, 0.25752422f, 
    0.07264858f, 0.00077118f, -0.05867536f, -0.10197345f, -0.07759939f, -0.02442310f, -0.09813693f, -0.04413403f, 
    0.10449657f, -0.11182789f, 0.04448462f, -0.00856362f, 0.10289168f, 0.17061388f, -0.17830056f, -0.08363942f, 
    0.14477460f, 0.00189166f, 0.10986563f, 0.06487942f, -0.01140132f, 0.02476089f, 0.03924528f, 0.01727513f, 
    0.08143085f, 0.04996155f, 0.04803596f, 0.07832159f, 0.15201496f, 0.07490595f, 0.15646036f, -0.09893618f, 
    -0.33048326f, -0.13906685f, -0.07570037f, 0.08134072f, 0.23617680f, 0.06306385f, 0.02906250f, 0.04521271f, 
    -0.06367351f, 0.00876367f, 0.17771140f, 0.06131307f, 0.15984464f, 0.04603268f, 0.19357297f, 0.00220042f, 
    0.06881415f, -0.08348826f, 0.06417222f, -0.02739259f, -0.20787434f, -0.05180772f, -0.12500194f, 0.06404921f, 
    -0.19843809f, -0.05902114f, 0.10466335f, -0.10238622f, -0.02365948f, -0.02562175f, 0.03321379f, 0.00439350f, 
    -0.05145817f, 0.05004989f, 0.02164512f, 0.05235706f, 0.03595433f, 0.11871666f, -0.13657326f, -0.07106269f, 
    0.06879840f, 0.04305361f, -0.00017241f, -0.00214649f, 0.13150236f, -0.07493924f, -0.04832638f, 0.02821275f, 
    0.01151310f, -0.00746373f, -0.01631603f, -0.12242245f, -0.02990280f, 0.00299816f, -0.18056646f, -0.04484279f, 
    0.18594639f, -0.12278781f, 0.00231433f, -0.02189861f, 0.18288867f, 0.11196272f, -0.05701882f, 0.03765906f, 
    -0.06323956f, -0.03261852f, -0.01509462f, -0.08530458f, 0.00917400f, -0.05225008f, 0.09468637f, 0.21706155f, 
    0.04957108f, 0.04855345f, 0.21381085f, 0.04101618f, 0.03133520f, -0.08874502f, 0.05002716f, 0.04322579f, 
    -0.13206251f, 0.27324215f, -0.06183556f, 0.31041136f, -0.25058824f, 0.02489352f, -0.10830162f, 0.11065247f, 
    0.10158317f, 0.14208324f, 0.10941766f, 0.02272107f, 0.17890531f, 0.17216153f, -0.04891061f, 0.05937020f, 
    0.09736355f, 0.04766757f, 0.03102691f, 0.03114765f, 0.01859348f, 0.05000883f, 0.53540671f, 0.28487435f, 
    0.09143665f, -0.00415882f, 0.04091939f, -0.00199429f, 0.04890984f, 0.08105568f, 0.16953349f, -0.05712051f, 
    0.26928493f, 0.04308749f, 0.04089157f, 0.02795284f, -0.01383009f, 0.00786411f, -0.04532957f, -0.02027103f, 
    -0.10517538f, -0.14464770f, 0.03829359f, -0.14215752f, 0.13694839f, -0.07095206f, -0.19240552f, 0.00343245f, 
    -0.07668250f, -0.06805633f, -0.09746888f, 0.00929219f, -0.00739678f, -0.12179981f, -0.01734232f, 0.13839611f, 
    0.12605093f, -0.03229983f, -0.05184743f, 0.04515430f, -0.36228788f, 0.20881592f, 0.02029205f, 0.29910207f, 
    -0.07113165f, 0.09167784f, -0.07777235f, 0.11570168f, -0.05233043f, 0.04754297f, -0.04001475f, -0.01764531f, 
    0.11793658f, 0.00018597f, -0.00203983f, -0.00185968f, 0.01853925f, -0.04116438f, 0.05629906f, 0.03539542f, 
    -0.26345858f, -0.25992772f, -0.32344890f, -0.09429835f, -0.28616509f, 0.02240529f, -0.14132236f, -0.29561365f, 
    -0.12598121f, -0.19395670f, -0.01711182f, 0.00360906f, -0.00848919f, -0.03770181f, 0.03689280f, -0.06745443f, 
    -0.19031388f, -0.02789795f, -0.03892899f, -0.07970107f, 0.14190336f, -0.17761177f, -0.10910518f, -0.13409746f, 
    0.07161524f, 0.01125759f, 0.06674537f, -0.13198259f, -0.04951011f, -0.00587661f, -0.03269182f, -0.01304401f, 
    -0.15072317f, -0.01466842f, -0.08692181f, 0.14340653f, -0.04972884f, -0.17138867f, 0.00766328f, -0.05178545f, 
    -0.16067745f, 0.17339383f, 0.07056517f, -0.00428573f, 0.07539748f, -0.08801401f, 0.00348699f, -0.10375727f, 
    -0.06603345f, -0.10381769f, 0.07404071f, 0.01798854f, 0.00913000f, 0.02332738f, 0.06124771f, -0.09654102f, 
    0.00389003f, -0.02927383f, 0.01838300f, -0.00110831f, 0.24808301f, -0.09068342f, 0.11678278f, -0.05399195f, 
    0.01648192f, 0.03543607f, 0.15173070f, 0.16969879f, -0.02275891f, 0.04537934f, 0.04465510f, 0.07897690f, 
    -0.04876160f, 0.02588375f, 0.02562224f, 0.13752474f, 0.02792362f, -0.10243034f, 0.11440063f, 0.03944156f, 
    0.01419530f, -0.06865854f, -0.00637985f, 0.12534656f, -0.10623944f, -0.04074050f, -0.08771546f, 0.15150683f, 
    -0.03409437f, 0.20348436f, 0.15471075f, -0.04766298f, -0.03399771f, -0.11865176f, -0.08696812f, -0.06411548f, 
    -0.11202540f, 0.00615833f, -0.06299661f, -0.15400052f, -0.30981749f, 0.33270368f, -0.01088532f, 0.20804432f, 
    0.34102252f, -0.08045042f, 0.04559468f, -0.11277495f, -0.22820418f, 0.01043974f, 0.10055250f, 0.01587107f, 
    0.18481825f, 0.04389542f, -0.04879900f, 0.06820604f, -0.08678469f, -0.18141173f, -0.08585076f, 0.00444610f, 
    0.30457294f, -0.03070932f, -0.21265179f, 0.22858649f, 0.20994259f, 0.07460507f, 0.16599984f, 0.10695919f, 
    -0.08081585f, -0.03348985f, -0.06028189f, 0.00193007f, -0.03532502f, -0.06436020f, 0.09054966f, 0.10680209f, 
    0.16669300f, 0.10068480f, 0.13034271f, 0.27331620f, 0.02326984f, 0.11465234f, -0.01936278f, -0.14392392f, 
    0.04723201f, -0.06070245f, -0.09741841f, 0.08360721f, 0.03922703f, 0.02078635f, 0.11108765f, 0.05875167f, 
    -0.05979946f, 0.00822053f, 0.04860419f, -0.04529877f, -0.11402363f, 0.11407910f, -0.10154123f, -0.14073497f, 
    -0.12120875f, 0.11550461f, -0.07497187f, 0.04182385f, 0.10269617f, 0.02532388f, 0.03294527f, -0.09831744f, 
    -0.03835835f, 0.06150961f, 0.12652011f, 0.04119408f, 0.13079119f, 0.08000939f, 0.06520348f, -0.01268119f, 
    -0.06638085f, -0.07309510f, 0.04827577f, -0.15233900f, -0.03535149f, -0.19220415f, 0.35648468f, -0.14430133f, 
    -0.11336504f, -0.11374076f, -0.01272335f, 0.01803567f, 0.06744760f, -0.01211360f, -0.00535574f, 0.03027773f, 
    -0.01318731f, 0.04578879f, 0.04139141f, 0.13255803f, 0.02543305f, 0.10087935f, 0.07998293f, -0.08574066f, 
    0.03090608f, 0.00633656f, -0.16068555f, -0.02971715f, 0.06566059f, -0.01604364f, 0.16248560f, 0.10197371f, 
    -0.02451752f, -0.07311402f, -0.04539769f, 0.04826001f, 0.07727084f, 0.02614776f, 0.07284865f, 0.16400097f, 
    -0.00134546f, -0.21285383f, -0.24279997f, -0.04192344f, 0.02696275f, 0.13057387f, 0.21952042f, -0.12290946f, 
    0.00134479f, -0.07922880f, -0.07818178f, 0.14137787f, -0.00171570f, -0.04448282f, 0.05745585f, -0.01047101f, 
    -0.01949805f, 0.08348753f, 0.02661028f, -0.02017673f, -0.11272223f, -0.06653273f, -0.24502639f, -0.28990844f, 
    0.03884897f, -0.27050340f, 0.10537215f, 0.07744512f, -0.19253579f, -0.10582819f, -0.10034497f, -0.08737139f, 
    0.04250484f, 0.01006240f, 0.13687776f, -0.10781712f, 0.00193844f, 0.23733972f, 0.04117236f, 0.02059147f, 
    0.13525286f, 0.28171042f, -0.05051402f, 0.05384314f, -0.07471263f, 0.24702042f, 0.30169526f, 0.20281778f, 
    -0.08584015f, -0.10312463f, 0.00556315f, -0.24588878f, -0.13903745f, -0.09980973f, 0.06116850f, -0.01359491f, 
    0.10040453f, 0.08973648f, -0.02747455f, 0.02025743f, 0.03903838f, 0.01763947f, -0.03208866f, 0.02418380f, 
    0.01411709f, -0.00651071f, 0.09286869f, -0.25625369f, -0.16284886f, -0.02916959f, -0.04510285f, 0.12248937f, 
    0.05539812f, 0.15233175f, 0.00962970f, 0.08430593f, 0.13674955f, 0.09537131f, 0.10747787f, -0.00531545f, 
    0.05152587f, -0.00625697f, -0.08338839f, -0.16366883f, 0.13962437f, -0.22250502f, 0.19477683f, 0.28563079f, 
    -0.07425155f, 0.00240832f, -0.16032866f, -0.18069871f, -0.02951756f, 0.08472162f, 0.14153711f, -0.00928632f, 
    -0.05610661f, 0.14125398f, 0.04835957f, 0.05029075f, 0.14032793f, 0.06531736f, 0.07701811f, 0.14430155f, 
    0.05813595f, -0.13639510f, 0.10570300f, 0.19870333f, 0.31159201f, 0.00028363f, 0.10822098f, -0.14526720f, 
    0.24435581f, 0.13609847f, -0.00734969f, -0.00871084f, 0.12222017f, -0.11104931f, 0.05564477f, 0.17091410f, 
    0.15859312f, 0.21953093f, 0.24420358f, 0.33269680f, -0.05645179f, -0.03237872f, -0.04600820f, 0.00432049f, 
    -0.08337487f, -0.09338447f, 0.19664274f, 0.02263233f, -0.10659438f, 0.17414808f, -0.14851825f, -0.10478878f, 
    -0.03711131f, 0.08620011f, 0.18037255f, 0.06703366f, 0.03281833f, 0.02027732f, -0.16565469f, -0.05616684f, 
    0.18749228f, 0.38785249f, 0.03612718f, 0.04817464f, 0.00585149f, -0.00532302f, -0.20174117f, -0.01276831f, 
    0.06355034f, -0.10440065f, 0.04435592f, 0.10864735f, 0.01571234f, -0.15967086f, 0.00198510f, -0.04020801f, 
    -0.16977547f, -0.27139899f, -0.12542038f, -0.32787263f, 0.19306657f, 0.01461856f, -0.15679739f, 0.03241026f, 
    0.09966417f, 0.02547223f, 0.22491716f, 0.24393925f, -0.01714929f, 0.10369523f, -0.04571326f, -0.08416682f, 
    -0.10405520f, -0.02277537f, 0.04012581f, 0.17526194f, 0.11325698f, -0.01803120f, -0.08620901f, -0.11625442f, 
    -0.37267035f, -0.12431079f, 0.04685337f, 0.32208359f, -0.02921354f, -0.01783608f, 0.04317589f, 0.15431497f, 
    -0.09046743f, -0.04476095f, -0.02822442f, -0.04793713f, -0.05963663f, 0.06692247f, -0.05355743f, 0.11479155f, 
    0.01272568f, 0.04459474f, 0.20131886f, -0.07862997f, -0.06440160f, 0.11004677f, 0.32395187f, 0.25929007f, 
    0.06731754f, -0.06293597f, -0.15637289f, -0.16389099f, -0.08180785f, 0.01595111f, 0.07434639f, 0.11241654f, 
    0.00540552f, -0.03747630f, 0.07101353f, -0.00689111f, -0.08409657f, 0.01137738f, -0.03776855f, -0.07617456f, 
    -0.18206389f, -0.28720856f, -0.52640563f, 0.36172268f, 0.00988607f, 0.01732372f, 0.23026156f, 0.09938949f, 
    -0.14320785f, 0.11783192f, 0.00383022f, -0.00399870f, 0.04062122f, -0.07738609f, -0.04210339f, 0.09382594f, 
    -0.01705291f, -0.00185646f, 0.07734151f, 0.03974458f, -0.12282130f, 0.05227242f, 0.10382274f, 0.07451319f, 
    -0.00964115f, 0.05484848f, 0.03519954f, 0.02768471f, 0.01922025f, 0.00336528f, 0.06345918f, 0.10395899f, 
    0.01703428f, 0.03893017f, -0.09129470f, 0.07594453f, -0.01044079f, 0.17054020f, -0.00824871f, 0.18577932f, 
    -0.11476605f, 0.07083494f, -0.13884957f, 0.23837049f, -0.08627153f, 0.01709495f, -0.16160400f, 0.00675356f, 
    -0.11429695f, 0.08653579f, 0.15232024f, -0.07187563f, -0.00455727f, 0.01191582f, -0.03152964f, -0.01940604f, 
    -0.00603659f, 0.08305232f, -0.00595677f, 0.07300227f, -0.16184269f, -0.03292869f, 0.35321233f, -0.04218740f, 
    -0.09163141f, -0.07468418f, 0.09857473f, 0.01965758f, 0.00486258f, 0.03583860f, 0.00627469f, -0.01722978f, 
    -0.00150954f, -0.02262140f, -0.02193502f, -0.00902035f, 0.07296191f, -0.09629096f, -0.08847632f, -0.07144967f, 
    -0.19743140f, -0.09999284f, -0.24860397f, -0.16598539f, 0.03126536f, -0.07828079f, -0.10144448f, 0.07302123f, 
    0.02515906f, 0.03707266f, 0.09605287f, -0.05361817f, -0.03950756f, -0.14528602f, 0.05834017f, 0.03007074f, 
    0.01791841f, -0.04541131f, 0.12402087f, 0.11808494f, 0.18554300f, 0.06792457f, 0.36678085f, -0.28449014f, 
    0.07390882f, 0.06652417f, -0.00282882f, -0.05753899f, -0.01641574f, -0.07822782f, 0.01471300f, -0.04004503f, 
    0.15573312f, 0.11332536f, 0.02729239f, 0.10423029f, -0.01915169f, 0.01267595f, 0.02878353f, -0.03956152f, 
    -0.10235420f, -0.00384092f, 0.05367367f, 0.21040317f, -0.18007162f, -0.10067514f, -0.08897830f, -0.19380395f, 
    0.16312158f, 0.06744456f, 0.00908502f, 0.06733423f, 0.01076778f, 0.10056645f, -0.01754127f, 0.05172747f, 
    -0.04078612f, -0.03075901f, 0.12611935f, 0.19358793f, 0.12636615f, 0.09831721f, 0.44442439f, 0.19265921f, 
    -0.03090764f, 0.01238342f, -0.04607753f, -0.29109183f, 0.00463693f, 0.05847879f, 0.02711793f, 0.12761427f, 
    0.06912367f, 0.08371351f, 0.08528706f, 0.04488371f, 0.02516064f, -0.02321277f, 0.02057446f, 0.05498543f, 
    0.05321886f, 0.11640511f, -0.19012809f, -0.10457585f, 0.06138230f, -0.04103501f, -0.25849590f, 0.09694450f, 
    -0.29803008f, -0.05026856f, 0.09194893f, 0.01730859f, -0.02348161f, 0.08543795f, -0.14223023f, 0.12519182f, 
    -0.09920018f, 0.11349219f, -0.00911317f, 0.13112400f, -0.44527793f, -0.01123258f, -0.06398562f, 0.52189064f, 
    -0.24791114f, -0.13284218f, -0.09541421f, -0.06770799f, 0.09465853f, 0.08221254f, -0.05213344f, -0.02613879f, 
    -0.04494777f, -0.05277158f, 0.00184343f, 0.01430302f, 0.08296400f, 0.01525896f, 0.18651126f, -0.02631190f, 
    0.08219618f, -0.04992626f, -0.09713155f, 0.12841198f, -0.05957460f, 0.15809381f, 0.15731269f, 0.15228522f, 
    -0.13835257f, 0.01631774f, 0.07285264f, 0.05903416f, 0.01532529f, 0.07928213f, -0.03378034f, -0.09324492f, 
    0.07536888f, 0.11426993f, -0.17003250f, 0.11037754f, -0.20635690f, -0.37945104f, -0.29208046f, -0.10996745f, 
    0.09040354f, 0.18096165f, 0.20168635f, 0.14981012f, -0.04131997f, 0.05958261f, -0.09361417f, -0.01111301f, 
    -0.06568331f, -0.09661866f, -0.15937319f, 0.02376590f, 0.06837004f, 0.02035706f, 0.00626585f, -0.02107345f, 
    -0.06943322f, 0.19957818f, 0.04888520f, 0.14365377f, -0.01104024f, -0.16336595f, -0.12522030f, -0.06865667f, 
    -0.03736169f, -0.06503374f, -0.04853361f, -0.06425595f, 0.02479869f, 0.03869219f, -0.08808009f, 0.06176353f, 
    -0.00227028f, -0.02440563f, 0.14206308f, 0.11395857f, 0.23540673f, -0.14090200f, -0.21849027f, -0.32335052f, 
    0.07107063f, 0.13085444f, 0.11250678f, 0.20317367f, 0.02439745f, 0.03313194f, -0.03339458f, -0.05692891f, 
    -0.00624441f, 0.02658059f, -0.00139675f, -0.00642474f, 0.02128993f, 0.06700106f, -0.06915554f, -0.08221927f, 
    0.00887628f, 0.01730892f, -0.00019441f, -0.05069674f, -0.00198762f, 0.00425932f, -0.02320276f, -0.05806900f, 
    -0.03053040f, -0.04497844f, 0.00557727f, -0.01560062f, 0.00033612f, -0.04955659f, 0.04353089f, 0.02237270f, 
    -0.04829168f, -0.03812244f, 0.01709088f, -0.05277077f, -0.02834701f, 0.01271008f, -0.04584487f, -0.03190640f, 
    0.04000661f, 0.02392911f, -0.04681718f, -0.01655087f, -0.02631825f, -0.01972430f, -0.01082485f, -0.05258542f, 
    -0.00744068f, -0.01595830f, -0.01508383f, 0.03836062f, 0.02129686f, -0.05845242f, -0.00553249f, 0.03442993f, 
    -0.05274839f, 0.00547222f, -0.05694017f, 0.02308552f, -0.02135926f, -0.04198084f, -0.01691974f, -0.02272121f, 
    0.02974946f, 0.02720579f, -0.02389751f, -0.06275161f, 0.02719362f, -0.05402037f, 0.03477965f, 0.01008234f, 
    0.02753851f, -0.01862651f, -0.00767167f, 0.01338769f, 0.01994588f, -0.04901259f, -0.00436737f, 0.01863261f, 
    0.00539087f, 0.01514900f, 0.00120329f, -0.00507378f, -0.03713823f, 0.04703752f, -0.02145309f, 0.00959218f, 
    0.01594285f, 0.01908168f, 0.03654476f, 0.02876636f, -0.01799915f, -0.00489834f, -0.04389333f, -0.03168949f, 
    -0.06339078f, 0.03062650f, -0.04335581f, 0.00882149f, 0.02563273f, -0.06058279f, 0.00462760f, -0.05818110f, 
    -0.00547493f, 0.02708274f, -0.04863498f, 0.00394821f, 0.02847546f, -0.06060519f, -0.01001268f, 0.01391574f, 
    0.01963001f, 0.02911473f, -0.03977466f, -0.04977111f, -0.01772241f, -0.04535459f, -0.03526127f, 0.00335780f, 
    -0.04954393f, -0.03302082f, 0.00809861f, 0.04183933f, -0.03968540f, -0.01066921f, -0.04968035f, -0.05282092f, 
    0.00239543f, 0.00885756f, -0.05429230f, 0.02612748f, 0.03416515f, 0.03927775f, -0.01471619f, -0.05077014f, 
    -0.05378900f, -0.01919647f, -0.03777184f, 0.00210249f, -0.03033514f, -0.03594792f, -0.06032695f, -0.03654929f, 
    -0.00782165f, -0.06022365f, -0.02294124f, -0.05055656f, -0.02684979f, -0.01843064f, -0.00304794f, 0.04239747f, 
    0.02064641f, 0.01398982f, -0.03013009f, 0.02290337f, -0.03150386f, 0.03562514f, 0.02790527f, -0.00942994f, 
    -0.04583151f, -0.06018624f, -0.02212429f, 0.02187578f, -0.02377926f, 0.00013131f, -0.04520831f, 0.00378908f, 
    -0.05442205f, 0.03038315f, -0.00717446f, -0.02828330f, -0.05863982f, -0.01259429f, 0.03117572f, 0.01007929f, 
    0.02067055f, -0.02507270f, -0.03314925f, 0.02427635f, -0.04555454f, 0.01346600f, -0.04021724f, 0.01780553f, 
    -0.03823598f, -0.03166032f, -0.06443947f, 0.01243740f, -0.00415058f, -0.02837466f, -0.01295556f, -0.04676838f, 
    -0.05388055f, -0.01206256f, -0.06138905f, 0.01320578f, 0.04410541f, -0.01535930f, 0.03651108f, -0.01523503f, 
    0.02805827f, -0.00401774f, -0.00933038f, -0.02049064f, -0.01698403f, -0.00113491f, 0.01311132f, 0.03942766f, 
    0.01969245f, 0.03401971f, -0.05244102f, -0.01195606f, -0.03992958f, 0.01215668f, 0.04526379f, -0.04563776f, 
    0.04146081f, -0.03809406f, 0.04081235f, 0.03787530f, -0.02041425f, 0.02544955f, -0.02350924f, 0.04289358f, 
    -0.06449478f, 0.03992971f, -0.00122312f, 0.04399416f, 0.02594876f, 0.04530863f, 0.02970141f, 0.01789613f, 
    -0.00085741f, 0.03538750f, -0.05548782f, 0.03243335f, -0.03936017f, 0.05655736f, -0.04668563f, 0.02130822f, 
    -0.05040345f, 0.01888349f, -0.03938720f, 0.01784169f, -0.04711071f, -0.03102041f, 0.02872636f, 0.04246724f, 
    0.00162983f, -0.00626922f, -0.05474907f, -0.04299692f, 0.02572679f, 0.04000039f, 0.04060861f, -0.02272352f, 
    0.01000184f, 0.00714959f, -0.00112163f, -0.01803502f, -0.01515668f, -0.00975624f, 0.04996535f, 0.00023343f, 
    0.01589327f, -0.02312643f, -0.04768430f, 0.00723936f, -0.04686096f, 0.04450759f, 0.02624686f, -0.01552740f, 
    0.01838838f, -0.05059263f, 0.01116944f, 0.02808763f, -0.01769907f, 0.00028597f, -0.03111780f, -0.06043983f, 
    -0.02630799f, -0.00513163f, 0.03811751f, -0.03037267f, -0.06041032f, -0.03128589f, -0.05608606f, 0.02987517f, 
    0.01775911f, -0.03128622f, -0.00128177f, -0.05366423f, -0.03083089f, -0.02885089f, 0.00166780f, 0.00641148f, 
    -0.02222318f, 0.01425482f, 0.05165911f, -0.03327873f, 0.03114950f, -0.02393151f, 0.02639095f, -0.05310063f, 
    -0.03283145f, -0.00525958f, -0.03996348f, 0.01976961f, -0.05334208f, -0.03145313f, 0.00157532f, -0.00433441f, 
    0.01959716f, -0.00177299f, 0.03682387f, -0.06534726f, -0.04601483f, -0.03921374f, -0.01369238f, 0.01891021f, 
    0.01464082f, 0.00222526f, 0.03368248f, 0.02590258f, -0.02961898f, -0.00003974f, 0.03011769f, 0.01109742f, 
    0.04551852f, -0.00826967f, -0.00255640f, -0.03944791f, 0.03086099f, 0.02581429f, -0.06047570f, -0.01888306f, 
    -0.09884641f, -0.13310122f, -0.03550304f, -0.24904560f, -0.07614734f, -0.01433452f, 0.01609272f, -0.29444271f, 
    0.03186900f, -0.19853161f, -0.05651951f, 0.05162840f, -0.03957574f, 0.15561348f, 0.07816932f, -0.09157347f, 
    0.00554079f, 0.16848290f, -0.01006114f, 0.15613087f, -0.11059486f, -0.45113048f, -0.00808910f, 0.01865140f, 
    0.15840794f, -0.14560270f, 0.05892852f, 0.13070633f, 0.10487022f, 0.19474196f, 0.06182514f, 0.06508598f, 
    0.03836608f, 0.09344724f, -0.06831788f, -0.05688752f, -0.03052450f, 0.08708633f, 0.02393680f, -0.07044712f, 
    -0.32252163f, 0.08414463f, -0.09062421f, -0.18962821f, -0.12125915f, 0.09721129f, -0.07291735f, -0.14356180f, 
    0.06490602f, -0.09141654f, -0.07220775f, -0.03324737f, 0.04475754f, 0.04649912f, -0.04215510f, -0.01349238f, 
    0.10199962f, 0.01116079f, 0.08931623f, -0.14734729f, 0.18222629f, 0.12467743f, -0.05006343f, 0.06455456f, 
    0.11322848f, 0.00211704f, 0.19491678f, 0.13917008f, 0.06545536f, 0.05099930f, 0.02760817f, -0.08142459f, 
    0.18136436f, 0.01361698f, 0.08447807f, 0.00328952f, 0.14943717f, 0.00676616f, 0.23909129f, -0.08949538f, 
    -0.13464449f, -0.15269761f, 0.01784778f, -0.02179855f, 0.15812685f, 0.02986420f, -0.07680965f, 0.13867827f, 
    0.05086247f, 0.16041164f, 0.03749724f, 0.05385465f, -0.05031491f, 0.10869905f, -0.01172452f, -0.06219547f, 
    0.05315649f, 0.01742381f, 0.09217097f, 0.07262180f, 0.04376175f, 0.00940672f, -0.29285422f, 0.03635472f, 
    -0.14987643f, 0.08235484f, 0.23665531f, -0.01961155f, -0.10678029f, -0.08144280f, 0.12511751f, -0.07113265f, 
    0.07869802f, -0.11651777f, 0.04863216f, -0.05290230f, 0.04276764f, 0.14453581f, -0.00947191f, 0.15904985f, 
    0.09351826f, 0.04692763f, 0.05422493f, -0.05693045f, 0.06802996f, -0.03662040f, -0.08562778f, 0.06356406f, 
    -0.04137398f, 0.12976481f, -0.02779153f, -0.08923755f, 0.02362630f, 0.14432462f, -0.08889154f, -0.25647941f, 
    -0.02019698f, 0.12931639f, 0.06739433f, -0.06759688f, 0.10798077f, -0.03940225f, -0.25218740f, 0.16627866f, 
    -0.05542824f, 0.01103964f, -0.01386531f, -0.05126039f, 0.06319001f, -0.06475024f, 0.11182576f, 0.16813730f, 
    0.15622936f, -0.03234532f, 0.09502730f, -0.10174938f, 0.03382224f, -0.08895733f, 0.08999705f, 0.13519891f, 
    -0.08849515f, 0.13112612f, -0.02189826f, -0.00148255f, 0.12338535f, -0.09113014f, 0.00689663f, 0.06614695f, 
    0.01112989f, 0.11301833f, 0.06467517f, 0.05086476f, 0.03988283f, -0.01851358f, -0.12346726f, 0.02153896f, 
    -0.03162573f, -0.01834129f, -0.04310390f, -0.01834674f, 0.01922436f, -0.26024872f, 0.23626404f, 0.01607924f, 
    0.23587202f, -0.03516495f, 0.04331941f, 0.25457981f, 0.19442233f, 0.12154290f, 0.14803579f, -0.03514218f, 
    0.05460373f, -0.14310418f, -0.08394601f, -0.08698048f, -0.03899488f, 0.05442546f, -0.01122688f, -0.01052656f, 
    -0.08318832f, -0.12209904f, 0.05420841f, -0.11255176f, 0.15680218f, -0.11992534f, -0.03204744f, -0.03512807f, 
    0.09014504f, -0.06497692f, -0.19698563f, 0.07133881f, 0.05892721f, -0.14609435f, 0.02972966f, -0.24414450f, 
    0.06885883f, -0.27995008f, 0.16276647f, 0.08465170f, -0.16954309f, 0.31526121f, -0.12775612f, -0.07733651f, 
    0.13360485f, 0.03840788f, 0.09243635f, 0.35831606f, -0.00844589f, 0.11365488f, -0.07181668f, -0.01760770f, 
    -0.00824839f, -0.11981153f, -0.07466853f, 0.09490024f, -0.01258466f, -0.02189476f, -0.11397582f, 0.02241477f, 
    -0.21375024f, 0.07026072f, -0.07166670f, -0.16627100f, -0.45333415f, 0.12487683f, -0.01517880f, -0.22015290f, 
    -0.04868900f, -0.12988473f, -0.08670972f, -0.00789422f, 0.04301791f, -0.06409645f, 0.05311308f, -0.16670229f, 
    -0.03097530f, -0.02576511f, 0.06978924f, -0.09962238f, 0.07178313f, -0.16035227f, 0.06614947f, -0.09830277f, 
    -0.00189850f, -0.02268076f, -0.25473994f, -0.24060985f, 0.02439136f, 0.02879615f, -0.06210552f, -0.07429057f, 
    0.01243276f, 0.08372940f, 0.02624095f, -0.00885318f, -0.17415302f, -0.04983507f, 0.06713322f, -0.05501556f, 
    -0.14531200f, 0.00952693f, 0.00685138f, -0.02224458f, 0.21057910f, -0.10029177f, 0.12318810f, 0.15833201f, 
    0.05384558f, 0.05983195f, 0.04510705f, 0.06657430f, -0.00771496f, 0.01563288f, -0.00026793f, -0.19758004f, 
    -0.01430721f, 0.11781895f, -0.01341260f, 0.06534307f, 0.07647263f, -0.04703131f, 0.14560540f, -0.00994895f, 
    -0.10209928f, 0.10111395f, -0.06609305f, -0.04540939f, -0.03374156f, -0.00684046f, -0.02110383f, -0.03178676f, 
    0.02001639f, 0.11497291f, 0.04769106f, 0.09379833f, -0.03341908f, 0.01029621f, 0.09972996f, 0.02581589f, 
    -0.09141190f, -0.26503515f, -0.33168682f, 0.17628857f, 0.14315157f, 0.10428628f, 0.06679092f, 0.01369485f, 
    -0.09067015f, 0.10279715f, 0.03382698f, -0.06388351f, -0.00501082f, -0.08784455f, -0.05334497f, 0.05108108f, 
    0.01181019f, -0.00787852f, -0.05261907f, 0.01640827f, 0.33407584f, 0.20337610f, 0.29872102f, 0.01010730f, 
    0.05535005f, 0.12241042f, 0.03655247f, -0.05417282f, -0.14594892f, 0.08160164f, 0.00229539f, 0.08892909f, 
    0.09175346f, -0.02472815f, 0.11906351f, -0.03294342f, -0.05075971f, -0.25322917f, 0.01797963f, 0.01630714f, 
    0.29894197f, -0.16431579f, -0.04638979f, -0.13132307f, 0.30660588f, -0.03509783f, 0.04671065f, 0.20368740f, 
    0.00460146f, -0.01350537f, 0.04335730f, -0.08847141f, -0.03773688f, 0.02338505f, 0.03384479f, 0.08935905f, 
    -0.02114132f, 0.02191625f, 0.05692039f, 0.03604371f, -0.04574334f, -0.08444162f, -0.02001760f, -0.09695799f, 
    0.10257626f, 0.00500365f, 0.11830773f, 0.01244995f, 0.05233365f, -0.00690782f, -0.02238180f, -0.02154082f, 
    -0.02627577f, 0.03893601f, -0.00808133f, -0.09183490f, 0.05554468f, 0.03543708f, 0.12570621f, -0.11554545f, 
    0.40649754f, -0.13171478f, -0.09536701f, -0.01926259f, -0.08603567f, -0.00182923f, -0.04238879f, 0.04503402f, 
    -0.11173297f, 0.01981832f, 0.02653456f, -0.00028009f, 0.13680941f, 0.05406209f, 0.04466010f, -0.00766813f, 
    -0.11548357f, -0.19226649f, 0.03155839f, 0.07841831f, -0.30280960f, -0.10048820f, -0.03400050f, 0.15298025f, 
    0.08401673f, -0.15398772f, -0.02335382f, -0.01714071f, 0.06338293f, -0.00802759f, -0.02190000f, -0.01121953f, 
    0.01174415f, 0.01694798f, -0.01904916f, 0.04189818f, -0.02806356f, 0.01861810f, 0.00368971f, -0.13391352f, 
    -0.02083642f, -0.09182536f, -0.07493825f, -0.24065097f, -0.15374050f, -0.11728773f, -0.02692030f, -0.00772349f, 
    -0.09151323f, -0.09077761f, 0.09538373f, 0.07088885f, 0.04429124f, 0.03108942f, 0.01628603f, 0.02378099f, 
    0.00894791f, -0.04055711f, -0.14663820f, 0.01986816f, -0.10660840f, 0.03425261f, 0.12204509f, -0.02089180f, 
    0.01049993f, 0.00102807f, 0.00976968f, -0.04981013f, 0.00082251f, -0.01293321f, 0.06020994f, 0.02064642f, 
    0.08970083f, 0.02332302f, 0.06609595f, 0.08131041f, -0.10082345f, -0.06708734f, 0.02408118f, -0.17876999f, 
    -0.20825505f, 0.17311025f, 0.07585713f, 0.39526236f, 0.12905161f, 0.06893746f, 0.02619230f, 0.00477086f, 
    0.10131445f, -0.01955273f, 0.02116534f, -0.00089499f, 0.04187519f, 0.04444005f, -0.00275995f, 0.00921744f, 
    0.01227424f, 0.15953189f, -0.00725871f, -0.11729344f, -0.13370264f, 0.34407490f, 0.51472241f, 0.28339338f, 
    0.25415537f, 0.01499431f, -0.02802502f, -0.16269822f, -0.02872360f, 0.04232948f, -0.09109472f, 0.03854446f, 
    0.13953154f, -0.02200344f, 0.06210644f, 0.00691561f, 0.05342882f, -0.10150456f, -0.05259629f, -0.06067903f, 
    -0.20711848f, -0.11180427f, -0.20776850f, -0.26372233f, -0.21036561f, 0.01486338f, -0.05908573f, 0.04015270f, 
    -0.08721445f, -0.01377717f, -0.05232247f, 0.08195264f, 0.15817142f, 0.00130298f, 0.09490454f, 0.10313445f, 
    -0.01855099f, -0.06680316f, -0.14999545f, -0.07301741f, -0.05076066f, -0.04619893f, 0.03109492f, 0.22183259f, 
    0.23055944f, -0.10287983f, -0.19479539f, -0.14909409f, -0.03944126f, -0.05958817f, 0.06416240f, 0.07113686f, 
    0.05857504f, 0.01357821f, -0.01089697f, 0.07231741f, 0.14008087f, 0.08297868f, 0.02247853f, -0.00276510f, 
    -0.10749713f, -0.48018792f, -0.04842579f, 0.12626514f, 0.34411961f, -0.11987675f, 0.09821357f, -0.11406480f, 
    -0.02742581f, 0.05258529f, 0.04535719f, -0.00408221f, 0.04032303f, -0.12771812f, -0.06236457f, 0.06146456f, 
    0.04084987f, 0.05706725f, 0.18352652f, 0.18546763f, -0.04230694f, -0.23691827f, 0.01984906f, -0.18190444f, 
    -0.01689268f, -0.00398766f, 0.04387633f, 0.10298842f, -0.11549199f, -0.06825449f, 0.07794228f, -0.10939308f, 
    0.02734675f, -0.05873616f, -0.02170815f, 0.03829060f, 0.00409745f, -0.09535526f, -0.04564035f, -0.05564535f, 
    0.03482135f, 0.05206769f, -0.14523439f, 0.02760409f, 0.07666209f, -0.10846221f, -0.02234369f, -0.07685948f, 
    -0.01732674f, -0.12752047f, 0.06203206f, -0.00850965f, 0.06770199f, -0.07138717f, -0.00032308f, 0.06328009f, 
    -0.09908339f, -0.03680600f, -0.03754939f, -0.10091906f, 0.01832715f, -0.12538630f, 0.16666137f, -0.08693689f, 
    -0.07431436f, -0.00912934f, 0.05069140f, 0.06239348f, -0.02491884f, -0.03222807f, 0.06708888f, -0.11789952f, 
    -0.02473822f, 0.00327987f, 0.13315040f, 0.05895012f, 0.07923743f, -0.04486745f, -0.05786800f, 0.02471598f, 
    -0.35345322f, -0.25959665f, -0.05074884f, 0.19218750f, -0.14568327f, 0.00439964f, 0.00908293f, 0.03232833f, 
    -0.04698488f, -0.01854951f, 0.02510187f, 0.02380944f, -0.03042413f, -0.07237224f, -0.13807070f, 0.08219090f, 
    0.00258652f, -0.04365519f, 0.02286031f, -0.06966609f, 0.00410794f, -0.11035859f, 0.10207695f, 0.17188534f, 
    0.24658546f, -0.02540010f, 0.03379700f, -0.15381964f, -0.00102908f, -0.07095630f, 0.06737999f, 0.02161871f, 
    -0.17346942f, 0.00179025f, 0.04240071f, -0.07928766f, -0.13389741f, -0.00649852f, 0.03581589f, -0.13055658f, 
    0.47166985f, -0.11207401f, -0.03650408f, 0.13106471f, -0.14617974f, -0.00245266f, -0.19615245f, 0.03018733f, 
    -0.07728352f, 0.03685824f, -0.11108008f, 0.07083845f, -0.07895146f, -0.00760168f, -0.04909986f, 0.04428025f, 
    0.13766697f, 0.01691782f, -0.01849434f, 0.18334803f, 0.02479340f, -0.21282260f, 0.18943775f, 0.07438665f, 
    0.12341756f, 0.05565766f, 0.08455414f, 0.01273062f, -0.06637713f, 0.03442046f, 0.00334727f, 0.05590829f, 
    0.07507150f, 0.00782626f, 0.04467830f, 0.06760325f, 0.02934130f, 0.09076022f, -0.05379010f, 0.11224405f, 
    -0.08014677f, 0.03381645f, -0.10877168f, 0.12886873f, 0.05893933f, -0.03486420f, -0.00615564f, -0.03326701f, 
    -0.16051076f, -0.02454324f, 0.08874483f, -0.15326434f, -0.09115572f, 0.12651177f, -0.02520782f, -0.14902462f, 
    0.01198004f, 0.07217229f, 0.09905265f, -0.06513033f, -0.15037507f, -0.10191655f, 0.21560320f, 0.13615373f, 
    -0.17277011f, 0.15722851f, 0.09281490f, -0.10387167f, 0.23759636f, -0.00524380f, -0.03356398f, 0.08182998f, 
    -0.03161054f, -0.08152948f, -0.00486012f, 0.05035179f, 0.19629657f, -0.02367472f, -0.03395186f, 0.04500915f, 
    0.05738245f, -0.01047542f, 0.11019950f, 0.02226215f, 0.02456301f, -0.23069280f, -0.06027231f, -0.02666307f, 
    0.02832628f, -0.01991932f, -0.04169002f, -0.01174233f, 0.04476776f, -0.03281876f, -0.02946620f, 0.00896581f, 
    0.05228166f, 0.06158010f, -0.21706027f, 0.05112524f, 0.04487660f, -0.04791875f, 0.26823881f, -0.13197416f, 
    0.03565971f, -0.03173928f, 0.10203102f, -0.04014826f, 0.08705760f, -0.02072200f, 0.00473401f, 0.05806452f, 
    0.13828444f, 0.09325959f, 0.02379526f, -0.08303590f, 0.02985792f, -0.04847096f, 0.13770691f, 0.02351373f, 
    -0.17482837f, -0.35038105f, -0.02488552f, 0.47696957f, -0.25166276f, -0.02270952f, -0.02639954f, -0.06208531f, 
    0.02440479f, -0.01329864f, -0.04286372f, -0.15436099f, 0.06531172f, 0.06370978f, 0.00738296f, 0.01243768f, 
    -0.05081696f, 0.07139167f, -0.01855811f, 0.08877353f, 0.07536822f, -0.18112707f, 0.43487823f, 0.38814563f, 
    -0.04211835f, -0.03622228f, 0.00600864f, -0.12685093f, 0.15427791f, -0.09266878f, 0.00171290f, 0.02701370f, 
    0.05621189f, 0.07513524f, 0.14001122f, -0.00725800f, -0.15320168f, 0.03215305f, -0.06696378f, -0.03043230f, 
    0.16871928f, -0.05536573f, 0.13430659f, 0.00529055f, -0.02725453f, -0.16700201f, -0.12703957f, 0.00032877f, 
    -0.16340832f, -0.09737846f, -0.07938486f, 0.13004601f, 0.02986712f, -0.10436437f, 0.04009941f, 0.05895887f, 
    -0.08896913f, -0.00142622f, -0.05640363f, -0.02596901f, -0.27372965f, -0.02373751f, 0.10434053f, 0.48042160f, 
    -0.06341345f, -0.04719625f, -0.10978248f, 0.02448997f, 0.00128424f, 0.13359107f, -0.07955374f, -0.07680364f, 
    -0.05216004f, -0.04297493f, -0.14187947f, -0.06512488f, 0.13802761f, 0.07842356f, -0.03396674f, 0.04073730f, 
    0.13344786f, -0.10901466f, 0.06951739f, 0.11279416f, -0.10647889f, 0.10324113f, -0.01129648f, -0.09165464f, 
    -0.00368067f, 0.09202540f, 0.01363086f, 0.14357498f, 0.04181753f, -0.06775287f, -0.21691772f, 0.09535497f, 
    0.10968679f, -0.08848091f, 0.01582419f, 0.18628442f, -0.16730666f, -0.00635011f, 0.08064049f, -0.14939119f, 
    -0.08552612f, -0.14624469f, -0.02493648f, -0.14853407f, -0.12714358f, -0.00693839f, -0.08629609f, 0.01021176f, 
    0.04827537f, -0.01081586f, -0.10947222f, -0.04679973f, -0.24850357f, -0.24027994f, -0.08314619f, -0.16761260f, 
    -0.08858796f, -0.09862058f, 0.01656383f, 0.11538338f, -0.02587392f, 0.03168181f, 0.00915889f, 0.07906552f, 
    -0.04963525f, -0.08882943f, 0.07785320f, -0.08266795f, 0.01550143f, -0.07958240f, 0.00024402f, -0.16144207f, 
    0.00603226f, 0.02596190f, -0.04915250f, -0.04565957f, 0.39630833f, 0.15798205f, 0.17186768f, -0.06259610f, 
    0.11363630f, -0.01716743f, 0.11962269f, 0.01228836f, -0.00763222f, 0.00882964f, 0.00081538f, 0.03142940f, 
    0.10472898f, 0.07019842f, 0.06801298f, 0.10445954f, -0.03039944f, -0.09390504f, -0.03669800f, -0.09878204f, 
    0.02507631f, -0.11051065f, -0.03227334f, 0.32324573f, 0.21100919f, -0.03810930f, -0.05904889f, 0.06364057f, 
    -0.18521668f, 0.00255976f, 0.02414738f, 0.00983749f, 0.07955926f, -0.03741186f, -0.00732183f, -0.03498906f, 
    0.08868083f, -0.06822882f, 0.06432447f, 0.08096445f, 0.30143425f, 0.22788967f, 0.02956320f, -0.08332305f, 
    -0.24166432f, -0.07381981f, 0.00118085f, 0.07765232f, -0.00185181f, -0.08055308f, 0.14255199f, 0.06661014f, 
    0.17040861f, -0.06641596f, 0.09824164f, -0.09052999f, -0.02763715f, 0.00195894f, -0.02808995f, 0.01885500f, 
    0.43046454f, -0.17461640f, 0.08240785f, 0.26146427f, 0.14064011f, 0.02227743f, 0.18973975f, 0.03995513f, 
    -0.09611493f, 0.12245766f, 0.01210124f, 0.03708323f, 0.00151254f, -0.06106421f, -0.01407773f, 0.09000198f, 
    -0.02222333f, 0.01290998f, -0.03856277f, 0.01651138f, 0.12175419f, -0.23777400f, 0.07065072f, -0.03386992f, 
    0.17495298f, 0.00376078f, 0.00050788f, 0.00080738f, 0.08869270f, 0.05912543f, 0.02603760f, 0.05785067f, 
    -0.08142535f, 0.09072831f, -0.08433464f, 0.09205893f, 0.02996077f, -0.00570078f, 0.09465756f, 0.03079573f, 
    0.53626335f, 0.07004911f, -0.07538717f, -0.15717483f, -0.22119159f, -0.06500711f, 0.02150422f, -0.04363833f, 
    0.05894280f, 0.04551135f, 0.09026314f, 0.03575362f, 0.10431465f, -0.00558210f, 0.03884526f, 0.01715316f, 
    -0.03111456f, -0.00488888f, 0.06746037f, 0.11593455f, -0.12352811f, -0.15780705f, 0.05774087f, 0.03314878f, 
    0.22091131f, -0.11280996f, -0.12925509f, -0.12569810f, 0.10415597f, -0.03966384f, -0.01352396f, -0.06372522f, 
    -0.09289030f, 0.03901625f, 0.02851151f, -0.00131445f, 0.06356782f, -0.04591981f, 0.04629372f, -0.18857345f, 
    -0.08714264f, 0.00628924f, 0.07157519f, -0.14560758f, -0.24790992f, 0.01564554f, -0.06407984f, 0.04406888f, 
    0.11141997f, -0.02612969f, 0.04037881f, -0.01592773f, 0.04282639f, -0.04786530f, 0.12902936f, 0.12378024f, 
    0.10881387f, -0.10575823f, -0.02256602f, 0.08067089f, -0.18130465f, -0.03436552f, 0.21626380f, 0.05496003f, 
    0.01108396f, 0.04866412f, 0.06724639f, -0.06276608f, 0.02443539f, 0.08120228f, -0.05348976f, -0.07854945f, 
    -0.01366915f, 0.06718466f, 0.04679989f, 0.08232420f, -0.05823202f, 0.07001874f, 0.04785150f, -0.08319136f, 
    -0.08403125f, -0.41926834f, -0.10955467f, 0.28760090f, 0.09007175f, 0.04014079f, -0.04748289f, 0.16907862f, 
    -0.04595465f, 0.07096542f, -0.00479889f, 0.07434255f, -0.14773926f, 0.12472864f, 0.09001025f, -0.10364205f, 
    0.03563850f, -0.13235503f, 0.01062112f, -0.03715645f, -0.09157789f, 0.10682446f, -0.05389305f, 0.00319364f, 
    -0.00881842f, -0.10158606f, -0.05384118f, 0.00534556f, 0.05765254f, 0.19088221f, 0.00479013f, 0.17389633f, 
    -0.06546461f, -0.13175327f, -0.02700108f, -0.01639849f, -0.03014142f, -0.07067885f, -0.00714794f, 0.00977113f, 
    -0.16992097f, 0.06482227f, -0.06038820f, -0.04048239f, -0.15261398f, -0.03190564f, 0.03648601f, -0.04395764f, 
    -0.06508743f, 0.12265269f, -0.05329180f, -0.01183679f, 0.01644168f, 0.08645398f, 0.13729246f, 0.09472980f, 
    0.07757225f, 0.01431932f, -0.11316649f, 0.01320073f, -0.09444346f, -0.34071106f, -0.09321988f, 0.07153644f, 
    0.05784706f, -0.18225120f, -0.07418931f, -0.22473350f, -0.04255367f, -0.06519217f, 0.00100274f, 0.08200566f, 
    -0.10322560f, 0.04126270f, -0.01299277f, 0.15522932f, 0.06254866f, 0.00726856f, 0.18159764f, -0.02837203f, 
    0.11316770f, -0.19889265f, 0.01634069f, 0.11471115f, 0.45225701f, 0.01882619f, 0.09420881f, 0.07448880f, 
    0.05372401f, 0.03499351f, 0.15828381f, 0.03280745f, 0.08136299f, -0.09963594f, -0.09531584f, 0.15402800f, 
    0.10877759f, 0.04512985f, -0.01816731f, 0.07626872f, -0.11016438f, 0.00580153f, 0.01993879f, -0.00092576f, 
    -0.08622986f, 0.03000663f, -0.02720065f, 0.19148843f, -0.04153280f, -0.13162030f, 0.00325359f, 0.00424026f, 
    -0.00197376f, -0.10130777f, 0.09210059f, -0.18160009f, 0.00318008f, 0.02992994f, 0.05469351f, 0.12437410f, 
    0.34632239f, 0.02886345f, -0.01089588f, 0.06339541f, -0.04268485f, 0.03190924f, -0.01409492f, -0.00545687f, 
    0.11075512f, -0.04913095f, 0.05316009f, 0.00672448f, -0.11858582f, -0.09341619f, 0.06957076f, 0.09677561f, 
    -0.02690177f, 0.01968311f, 0.14113334f, -0.07466634f, -0.06788041f, 0.07214677f, -0.06141398f, 0.01649158f, 
    -0.05009284f, 0.09280576f, -0.01777649f, 0.20434262f, 0.06807493f, -0.04447287f, -0.00267118f, -0.06450663f, 
    0.04456077f, -0.09240387f, 0.06519124f, 0.02444620f, -0.06315743f, 0.13714837f, 0.01214491f, 0.06741069f, 
    0.12554576f, 0.44521141f, 0.25814050f, -0.05917667f, -0.05711029f, -0.10911974f, -0.05303114f, 0.08248021f, 
    0.01657111f, 0.15836853f, 0.09593835f, 0.03423266f, -0.00565370f, 0.02975308f, -0.02064602f, 0.01641797f, 
    -0.06977069f, -0.07906003f, -0.01060496f, -0.10322699f, -0.16844882f, -0.08368348f, -0.05908598f, -0.02344564f, 
    -0.02907442f, -0.08254416f, 0.05681845f, 0.08792727f, 0.10415760f, -0.06033095f, -0.04656608f, -0.07065470f, 
    0.00507264f, -0.05723356f, -0.06235164f, 0.01561029f, 0.06238988f, 0.05020119f, -0.05205145f, -0.02865671f, 
    -0.05771458f, 0.22699693f, -0.31682298f, 0.11022535f, -0.10384346f, 0.12659454f, -0.26211572f, -0.10140721f, 
    0.03629464f, -0.04633982f, 0.10067484f, 0.03006986f, 0.01123369f, -0.00001038f, 0.04082404f, 0.07410299f, 
    0.09034884f, -0.04611548f, 0.11205965f, 0.01075902f, -0.05199232f, 0.08085453f, 0.14871590f, -0.02516555f, 
    -0.13266782f, -0.06721566f, -0.06324448f, -0.02402654f, -0.11823732f, -0.09683971f, -0.00257667f, -0.14191578f, 
    0.08866597f, -0.01345348f, -0.02830523f, -0.11329574f, -0.12686409f, -0.00718143f, -0.11831133f, -0.13124534f, 
    -0.18337885f, -0.11595999f, 0.17733534f, 0.00910596f, 0.11292031f, -0.07042865f, 0.05816424f, -0.03255244f, 
    0.06123576f, -0.09629758f, -0.01248889f, 0.04716097f, -0.01116635f, -0.05372408f, 0.11506302f, 0.06447374f, 
    0.00759130f, 0.11136205f, -0.22541064f, -0.06621119f, 0.22930352f, 0.07596630f, 0.17101000f, -0.13772647f, 
    0.01511398f, -0.04089097f, -0.10065738f, 0.03423401f, -0.07251431f, 0.10111492f, -0.05815718f, -0.03329959f, 
    0.00597463f, 0.05623315f, -0.07980742f, -0.00343092f, -0.01603856f, -0.06364479f, 0.05170296f, -0.00689034f, 
    -0.00239421f, 0.01437236f, 0.00979409f, 0.06489137f, 0.14158577f, 0.18154144f, 0.29780015f, 0.10378063f, 
    0.08311585f, 0.04045651f, -0.02235216f, 0.05735690f, 0.18973619f, 0.02376578f, 0.09179442f, 0.09034429f, 
    -0.01878874f, -0.07382034f, 0.07524458f, -0.02111325f, 0.18910781f, -0.13170938f, -0.03992448f, 0.04144859f, 
    -0.03371357f, -0.06803638f, 0.05723409f, 0.02199257f, 0.01048368f, 0.01519915f, -0.00177925f, 0.03062720f, 
    -0.05462233f, 0.10700648f, -0.06171029f, -0.09480342f, 0.02375718f, -0.05609425f, -0.13083561f, 0.06321294f, 
    0.55276102f, -0.20351383f, 0.05006544f, -0.18902421f, -0.11169697f, -0.22265631f, -0.00210228f, 0.01587585f, 
    -0.10075025f, 0.01457878f, 0.18202160f, -0.01014475f, -0.03779481f, -0.13509540f, 0.02739142f, -0.00634789f, 
    0.05798214f, -0.07888134f, -0.06629194f, 0.05688851f, 0.49458879f, -0.24850696f, -0.29500207f, -0.03464316f, 
    -0.25854182f, -0.08789720f, -0.07648952f, 0.01354045f, -0.11303157f, 0.02181005f, 0.05456976f, -0.04750926f, 
    -0.04765818f, -0.07640006f, -0.02276808f, 0.00304763f, 0.01919890f, 0.12924843f, 0.10218068f, -0.09176058f, 
    0.09891345f, 0.09117897f, 0.15269156f, 0.08062023f, 0.01718783f, 0.07488179f, 0.19681935f, 0.12273141f, 
    0.15138796f, 0.11624824f, 0.07180880f, 0.13124231f, -0.00852833f, 0.19360806f, 0.01474462f, -0.06759239f, 
    0.03747560f, 0.11371758f, 0.06156544f, -0.03841622f, 0.34643486f, 0.08892544f, 0.12883098f, -0.12985897f, 
    -0.20531937f, -0.02379927f, 0.09664996f, 0.07460134f, 0.00543757f, 0.04911807f, 0.01241889f, -0.05036499f, 
    -0.08589635f, 0.08911836f, 0.07788175f, -0.02026356f, -0.04366129f, -0.07118797f, 0.08415200f, 0.02201256f, 
    -0.04592334f, 0.37767327f, 0.06753729f, 0.01593279f, -0.30249035f, -0.04969992f, 0.00032798f, 0.09067480f, 
    0.05128414f, 0.09096354f, -0.11428096f, -0.09412452f, -0.00704972f, 0.03063291f, 0.04694498f, -0.06286418f, 
    0.04951559f, 0.01960133f, 0.01358955f, 0.14467409f, -0.00203971f, 0.32485062f, -0.05174945f, 0.22947453f, 
    -0.00263608f, -0.10057461f, 0.02325922f, 0.05186888f, 0.09373623f, -0.01553805f, 0.02136280f, 0.04105348f, 
    0.09994131f, 0.09301896f, 0.11889120f, -0.04439014f, 0.08620463f, 0.18093885f, 0.01457078f, -0.05095079f, 
    0.05990995f, 0.02539811f, 0.26854736f, -0.02794771f, -0.03156586f, 0.01573840f, 0.01015144f, 0.07032686f, 
    0.09187829f, 0.14036430f, 0.01594883f, 0.00972950f, -0.02125600f, 0.00397583f, -0.11154109f, -0.11605054f, 
    0.00244944f, -0.09367905f, 0.00679818f, 0.00862352f, -0.00775599f, -0.02542137f, -0.20983168f, 0.04944348f, 
    -0.02676870f, -0.04776872f, 0.11676927f, 0.04852081f, 0.01610535f, 0.03948740f, -0.03836009f, 0.04787185f, 
    0.04706041f, -0.05749697f, 0.02526091f, -0.05272212f, 0.02831278f, -0.05467527f, -0.10102250f, 0.01176478f, 
    0.07866105f, -0.29527092f, -0.05986004f, -0.04866409f, 0.03545304f, 0.11556198f, 0.05108266f, -0.03731239f, 
    0.06371051f, -0.06460688f, 0.00055475f, 0.02258759f, 0.06138792f, -0.03948858f, 0.06518238f, -0.09166089f, 
    0.04258864f, 0.04531591f, 0.01668880f, 0.12823032f, 0.37735644f, 0.33364069f, -0.21272501f, -0.14698581f, 
    -0.28723049f, 0.00193171f, -0.04301399f, 0.05057070f, 0.03891688f, -0.10656647f, 0.08764223f, 0.03443211f, 
    -0.01529657f, -0.00821387f, 0.03631565f, -0.13652630f, -0.01103295f, 0.02913849f, 0.15820494f, -0.03734091f, 
    0.06602108f, 0.07645421f, 0.58320528f, -0.15311280f, 0.09236238f, -0.17096707f, 0.01039828f, -0.19102445f, 
    -0.04222826f, 0.09765921f, -0.09999461f, 0.04567597f, 0.00316543f, 0.07136993f, 0.06071484f, -0.09632035f, 
    -0.11353844f, 0.08550154f, -0.14628625f, -0.06152029f, 0.15065411f, -0.26436633f, -0.10664541f, 0.15087554f, 
    0.07553884f, 0.09604575f, 0.07433797f, 0.01511004f, 0.10789721f, 0.01182939f, 0.02708855f, 0.17065091f, 
    -0.14114639f, -0.05011091f, -0.08806999f, 0.04309976f, 0.02059080f, 0.01491592f, -0.02877700f, 0.23847288f, 
    0.52949035f, 0.36205959f, -0.14685963f, -0.09929791f, -0.17165338f, -0.06278935f, 0.01950664f, 0.04376239f, 
    0.00926922f, -0.02729910f, -0.03942626f, 0.03562847f, 0.11368144f, -0.03371672f, -0.05664495f, -0.08737640f, 
    -0.03588673f, 0.01102144f, 0.09630623f, 0.00279265f, 0.02002529f, -0.05075247f, -0.09296312f, 0.12291935f, 
    0.13374582f, 0.08815166f, 0.10167298f, 0.08292492f, 0.13447948f, -0.04567216f, -0.04507197f, 0.03031695f, 
    0.03475849f, -0.05478103f, 0.02423995f, -0.05654306f, -0.04379361f, 0.04011954f, 0.00227118f, 0.01452746f, 
    0.12030392f, 0.21912456f, 0.14955159f, 0.05387558f, -0.06347533f, 0.03840053f, -0.11099176f, -0.12535259f, 
    -0.05163339f, -0.01030880f, 0.02752595f, -0.01923852f, 0.00085653f, 0.03447078f, 0.05663573f, -0.06811056f, 
    -0.01903791f, 0.18156655f, 0.03568383f, -0.02667270f, -0.28106540f, 0.05209726f, 0.10636710f, 0.09880529f, 
    0.06065714f, 0.06087700f, -0.00068434f, 0.12340494f, 0.04653593f, -0.02587232f, 0.02720799f, -0.00841456f, 
    -0.02216730f, 0.02054876f, -0.00556923f, 0.07675370f, 0.15126419f, 0.13708352f, 0.07723510f, 0.02620726f, 
    -0.22884828f, -0.04017842f, -0.20539583f, -0.10749352f, 0.21446271f, 0.26104572f, -0.00548223f, 0.01799990f, 
    0.04882018f, -0.09563017f, -0.07173176f, 0.04276484f, -0.07848207f, 0.03682664f, 0.06978031f, -0.11275929f, 
    -0.13035659f, -0.01699085f, 0.06416164f, -0.04802081f, -0.16562136f, 0.11285063f, -0.16583945f, -0.27389076f, 
    0.07670901f, -0.02068667f, 0.04135607f, 0.04248587f, 0.08768088f, 0.12633550f, 0.03187465f, 0.12454402f, 
    -0.01915745f, 0.02155166f, 0.02198103f, -0.04297183f, 0.06882481f, -0.06133768f, 0.03390280f, 0.04101594f, 
    -0.01528144f, 0.17609273f, 0.10212699f, 0.08860474f, -0.02905649f, -0.09116213f, 0.04122719f, -0.05795029f, 
    -0.01875843f, -0.02081974f, 0.02553601f, -0.10696860f, 0.03497189f, -0.01509591f, 0.14050105f, 0.06749313f, 
    0.02867820f, -0.04795667f, 0.02041265f, -0.04591405f, -0.06505164f, -0.14948703f, -0.16339795f, -0.15957138f, 
    0.13860130f, 0.09679360f, 0.13132311f, 0.07105909f, 0.02335278f, -0.05587848f, -0.00755294f, -0.08539498f, 
    -0.04462557f, -0.03770491f, -0.09284978f, -0.06856175f, -0.01865738f, 0.00961200f, -0.11443598f, 0.02223705f, 
    0.14023854f, -0.26280877f, 0.20611288f, 0.03855696f, 0.31726092f, 0.01210884f, 0.05395548f, 0.08594184f, 
    0.02983834f, -0.01593508f, 0.11134878f, 0.03019970f, -0.02928626f, -0.02429650f, -0.04021931f, 0.07012157f, 
    -0.08380934f, -0.08086512f, -0.07416499f, -0.13203098f, 0.00152396f, 0.12536834f, 0.15315661f, 0.05835166f, 
    -0.01798502f, 0.08944904f, -0.10784298f, 0.02491230f, 0.04626294f, -0.16160646f, 0.09198958f, 0.06961264f, 
    0.03607601f, -0.11407497f, 0.01966781f, -0.06468974f, 0.01627835f, 0.08703291f, 0.10786611f, 0.01446907f, 
    0.20570125f, -0.10628532f, -0.31361440f, -0.01343805f, -0.09376556f, 0.06905168f, 0.04789271f, 0.08000572f, 
    0.02319049f, 0.02403885f, -0.03138629f, -0.02557933f, 0.01555673f, 0.07598445f, -0.01465542f, 0.08927364f, 
    0.11525781f, 0.10043475f, -0.03469844f, -0.00390605f, -0.11811364f, 0.24325891f, 0.11618637f, 0.13554087f, 
    0.13457771f, 0.02717484f, -0.03649434f, -0.09786654f, 0.04124586f, -0.03612068f, -0.02972271f, 0.08790427f, 
    0.05620131f, 0.02522874f, -0.04662645f, -0.01670204f, -0.04693322f, 0.09398992f, 0.09537765f, -0.04323854f, 
    -0.09142768f, -0.40246323f, -0.36021999f, -0.24566990f, -0.05726759f, -0.03279607f, -0.10370553f, 0.13237470f, 
    -0.16999944f, -0.12396709f, 0.04576248f, 0.02096992f, 0.03300155f, -0.06538821f, -0.06306169f, -0.03379576f, 
    -0.15359610f, -0.01127974f, 0.07197848f, -0.03315266f, -0.40846056f, -0.00517592f, 0.03404533f, 0.02660021f, 
    0.03963357f, -0.08497120f, 0.16213857f, 0.05024494f, -0.14596435f, 0.10494789f, -0.01081115f, 0.00637439f, 
    0.02804608f, 0.15046777f, 0.08874711f, -0.07993935f, -0.05303804f, -0.00508966f, 0.04519432f, 0.00429857f, 
    0.36279410f, -0.09098793f, 0.27356383f, -0.17945148f, -0.04273175f, -0.06763358f, -0.04431222f, 0.20312655f, 
    -0.06294760f, -0.17433564f, -0.11941466f, 0.02495074f, -0.06903447f, 0.02809774f, -0.06661513f, 0.04816992f, 
    0.12748201f, 0.07469808f, 0.02705061f, 0.17840600f, 0.15106961f, 0.15504858f, 0.16768514f, 0.02801953f, 
    0.14609221f, -0.04965537f, 0.03685226f, -0.03367690f, 0.12904774f, 0.09793743f, 0.04437822f, 0.04383679f, 
    -0.00105332f, -0.03664649f, -0.01121498f, 0.01604057f, 0.06297310f, -0.02195553f, 0.03809959f, -0.02649619f, 
    -0.25998491f, -0.00001015f, 0.24871370f, -0.07626052f, 0.22325261f, -0.06957840f, 0.10543022f, -0.01686841f, 
    0.10681793f, 0.09137815f, -0.00032822f, 0.12698953f, -0.02666133f, 0.03703630f, 0.04458759f, -0.14698488f, 
    0.04625660f, -0.08835024f, 0.00756688f, -0.03629967f, -0.13128492f, -0.00820604f, -0.09829951f, -0.02736595f, 
    -0.27437571f, 0.18354952f, -0.08222414f, -0.15525125f, 0.29116929f, -0.05739126f, -0.06056493f, 0.06209047f, 
    -0.12694459f, -0.07423247f, -0.00378588f, -0.03500866f, 0.05351922f, 0.16706216f, 0.07998271f, 0.06596437f, 
    0.21119307f, 0.15585077f, 0.18354934f, 0.03736594f, 0.03673110f, -0.09038929f, 0.06851441f, 0.08406892f, 
    0.06530286f, -0.04249663f, -0.09399860f, -0.03703207f, 0.05200204f, -0.01604015f, 0.02151879f, 0.07641854f, 
    -0.02570950f, -0.06205193f, -0.17341055f, -0.01587164f, -0.08251161f, 0.09555275f, 0.05016994f, 0.27651379f, 
    0.05789198f, 0.03064090f, 0.13695911f, -0.01222384f, 0.15965170f, -0.02614639f, 0.03086031f, 0.16097227f, 
    -0.07182904f, 0.00783806f, 0.09056606f, -0.13588993f, -0.01978178f, -0.01843035f, -0.06724478f, 0.01656996f, 
    -0.11685425f, -0.17533211f, 0.22545934f, 0.31308126f, -0.38546127f, 0.16266774f, 0.02201310f, 0.06308649f, 
    -0.21358807f, 0.15547660f, 0.04504522f, -0.16959324f, 0.13091424f, 0.10361189f, 0.16897465f, 0.12147123f, 
    0.03521410f, 0.00399953f, 0.04465416f, -0.02359265f, -0.36188814f, 0.19560699f, 0.00064261f, 0.31728277f, 
    -0.25189582f, 0.05932453f, 0.04942740f, 0.03494356f, -0.07451942f, 0.11808349f, -0.00402104f, -0.04635772f, 
    0.09483998f, 0.16725227f, -0.12227996f, 0.04465090f, 0.02579849f, 0.05648199f, -0.02391005f, 0.02991050f, 
    0.01288745f, -0.17621210f, 0.32641551f, -0.11594214f, -0.08548375f, -0.09928951f, 0.03566824f, -0.09776879f, 
    0.20667110f, 0.00026908f, -0.16873197f, 0.15537423f, 0.00907896f, 0.06654161f, 0.02283537f, -0.02783077f, 
    -0.06579138f, -0.02339517f, -0.07324687f, -0.16659687f, 0.25613290f, -0.31221086f, 0.33493081f, -0.38567334f, 
    -0.42958403f, 0.16381072f, -0.28523499f, -0.23942010f, 0.04841460f, 0.12150909f, -0.01856453f, -0.02825242f, 
    0.07316557f, 0.04967749f, -0.11576084f, 0.08732700f, 0.03171544f, 0.03636207f, -0.03127523f, 0.01983497f, 
    0.25782341f, -0.31958640f, -0.32867098f, -0.05094785f, -0.02519843f, -0.05976200f, -0.10828970f, 0.00214280f, 
    0.21301672f, -0.13885270f, -0.09015288f, -0.09487522f, -0.00259072f, -0.07846576f, -0.05786799f, 0.14838554f, 
    0.09052248f, 0.21531902f, 0.22500172f, 0.07799432f, 0.16562240f, 0.02148176f, 0.04752824f, 0.08740650f, 
    -0.12561755f, -0.08880682f, 0.00768384f, 0.12536737f, -0.08126248f, -0.02091839f, -0.11301200f, 0.00708939f, 
    -0.08195993f, 0.07213365f, 0.15756546f, 0.09063889f, -0.20076004f, 0.07229549f, -0.09900443f, 0.02393976f, 
    -0.01978698f, -0.10316458f, 0.23662849f, -0.03174673f, 0.05512584f, 0.03883630f, 0.04640758f, -0.03394242f, 
    0.07721732f, -0.08428837f, 0.02270387f, 0.01337307f, 0.00223846f, -0.01750975f, 0.15311597f, -0.09469885f, 
    0.05261991f, -0.16767715f, -0.13908294f, -0.15180796f, 0.25434816f, 0.20371148f, 0.20913500f, 0.28348950f, 
    0.01384583f, -0.10453803f, 0.05598491f, 0.06630958f, 0.11935895f, 0.05717259f, -0.10215411f, 0.03293103f, 
    0.04464468f, 0.01789842f, 0.15281664f, 0.09176637f, -0.06007697f, 0.06520360f, -0.00722188f, 0.00510183f, 
    -0.16382445f, 0.10022912f, 0.29314896f, 0.20416130f, -0.03331693f, -0.14626381f, -0.06476509f, 0.05227096f, 
    -0.00788249f, -0.00375151f, -0.04239551f, 0.08083434f, 0.02885305f, 0.09913072f, -0.03329203f, -0.02465270f, 
    -0.00903057f, -0.05778525f, -0.02747183f, 0.12377445f, -0.18715514f, -0.36574757f, -0.27618101f, -0.05604983f, 
    -0.18152033f, -0.10354087f, -0.13797802f, 0.01330786f, 0.09179459f, 0.02878540f, 0.06770535f, 0.02242498f, 
    0.04694135f, 0.08283929f, 0.05392574f, -0.09774618f, -0.00401167f, 0.19535254f, 0.02023552f, -0.04142074f, 
    0.13703591f, -0.24603187f, 0.17256849f, 0.33832252f, -0.12381624f, 0.07448931f, -0.08782810f, 0.03215745f, 
    0.03027104f, 0.00719801f, -0.15090400f, 0.00853225f, -0.02775095f, 0.00478341f, -0.08143912f, 0.02725665f, 
    -0.00347087f, -0.07375360f, -0.06125001f, 0.08306289f, 0.12272304f, -0.16318519f, 0.28702778f, 0.14418750f, 
    0.10232910f, 0.08140139f, -0.02298357f, -0.04760709f, 0.14311615f, 0.10821711f, 0.04355140f, 0.03301447f, 
    0.15976089f, 0.05055028f, 0.02710792f, 0.19560644f, -0.06393472f, -0.02040470f, 0.00521019f, 0.21003211f, 
    -0.27757609f, -0.18224172f, 0.05109821f, -0.00663028f, 0.04578644f, 0.01129873f, -0.06383728f, -0.11617008f, 
    0.15224433f, 0.15895474f, 0.00241189f, 0.00806862f, -0.09673972f, 0.00200890f, 0.01687600f, -0.02937965f, 
    0.06305944f, 0.18357231f, -0.00464039f, -0.00132802f, 0.09942628f, 0.01859653f, 0.22937062f, 0.00131067f, 
    0.01504624f, 0.13053578f, -0.03631335f, -0.10896772f, 0.12858725f, 0.06300426f, -0.02203602f, 0.04066914f, 
    0.00705961f, 0.01812493f, 0.01544305f, -0.09902844f, -0.02032845f, -0.19036080f, 0.05517232f, 0.05033947f, 
    -0.01467695f, -0.10999473f, 0.09745043f, 0.22155806f, -0.07362048f, -0.05774476f, -0.19793285f, -0.12352860f, 
    0.14137876f, 0.01257291f, -0.04341288f, -0.03560909f, -0.01629606f, -0.16811448f, 0.03681405f, 0.09795555f, 
    -0.02254088f, 0.04937525f, -0.00531857f, 0.11349035f, 0.10924511f, -0.14637399f, -0.11858258f, 0.07152338f, 
    0.06326518f, -0.03959973f, 0.15351568f, -0.12863141f, 0.04469084f, 0.05639419f, -0.03188735f, -0.08574647f, 
    0.08249988f, 0.04689687f, 0.11705424f, 0.09361000f, 0.11013230f, 0.16538444f, 0.11218517f, 0.00644888f, 
    -0.14588891f, -0.43171936f, 0.07456856f, 0.27287397f, -0.10009679f, 0.02259903f, -0.01566537f, 0.10113833f, 
    -0.11845329f, 0.21356861f, 0.03508695f, -0.07974335f, -0.05015228f, -0.00586541f, 0.11420356f, 0.04777990f, 
    -0.14875446f, -0.28597832f, 0.06360339f, 0.07231651f, 0.03672719f, -0.28391606f, -0.44379398f, -0.03625670f, 
    -0.28819221f, 0.10668532f, -0.01373313f, 0.04240242f, -0.10169405f, 0.25197563f, -0.00349256f, 0.12137875f, 
    -0.04910165f, 0.13620779f, 0.02100298f, 0.00809716f, -0.10064278f, 0.03087479f, -0.06375194f, 0.03412968f, 
    0.25058895f, -0.06402215f, 0.07057180f, 0.19704369f, -0.01570220f, -0.19538714f, 0.01274009f, -0.18076463f, 
    -0.10541023f, -0.03847599f, -0.00604324f, -0.02164461f, -0.17315684f, -0.00621811f, 0.04223415f, 0.04706420f, 
    0.10751434f, 0.05755424f, 0.12201478f, 0.01413440f, -0.25260249f, -0.03150805f, 0.12038720f, 0.07791336f, 
    -0.16001058f, -0.10236318f, 0.05072794f, 0.02127745f, 0.03108032f, 0.16048497f, -0.06416668f, 0.00979864f, 
    0.08746796f, 0.00350647f, -0.16662018f, 0.04915500f, 0.02898720f, -0.08918396f, 0.07660437f, 0.00764233f, 
    0.17851847f, 0.36987558f, 0.01259691f, 0.08145967f, -0.09939663f, 0.03260989f, 0.04483661f, 0.22424746f, 
    0.08401227f, 0.00084844f, -0.03875312f, 0.09258558f, 0.07653304f, 0.00717165f, -0.13931870f, -0.01827494f, 
    -0.08671495f, -0.17983049f, -0.13802695f, -0.06108580f, -0.05720899f, 0.27628437f, 0.10141858f, 0.06065393f, 
    -0.12273419f, 0.05800181f, -0.15799765f, 0.14701487f, -0.05552951f, 0.06198947f, -0.11310465f, 0.11672541f, 
    -0.01521174f, 0.04406676f, -0.07721345f, 0.03989487f, -0.00624000f, 0.11810300f, -0.04904087f, 0.06575216f, 
    -0.05944455f, -0.33121356f, 0.21703587f, 0.09261099f, 0.04232187f, -0.01318652f, 0.01664926f, -0.11611226f, 
    0.06030574f, -0.00858810f, -0.06427610f, -0.08235326f, 0.03931015f, 0.03708216f, 0.05457805f, 0.02236516f, 
    0.17680226f, 0.03326181f, 0.04527614f, 0.05458726f, 0.18838701f, 0.22902796f, -0.10353203f, 0.16367866f, 
    0.00486107f, 0.06858227f, -0.01852099f, 0.04584586f, 0.09484138f, -0.00038615f, -0.07278608f, 0.01056343f, 
    0.05698000f, 0.10905948f, -0.01066735f, 0.03114676f, -0.00640282f, 0.15182482f, -0.02265534f, -0.04593052f, 
    0.20381843f, 0.35251939f, 0.31427068f, 0.21514092f, -0.35213292f, 0.03000161f, 0.00644956f, 0.11158613f, 
    0.14238213f, 0.21906944f, -0.10179659f, -0.02779467f, 0.01183371f, 0.13066186f, -0.02530577f, 0.01678322f, 
    -0.01119782f, -0.09906691f, -0.06524731f, -0.04651757f, 0.06875168f, 0.18654861f, -0.19967827f, 0.04543394f, 
    -0.11177027f, 0.04221834f, -0.08800495f, -0.23900598f, 0.04283420f, -0.27084413f, 0.06519587f, 0.00137518f, 
    -0.09015748f, 0.07590073f, 0.08456254f, 0.13140251f, 0.03220177f, 0.05338583f, 0.13856706f, 0.01737821f, 
    -0.34273893f, 0.01259741f, 0.05270066f, 0.13006742f, -0.14422876f, 0.07442985f, -0.06964781f, -0.08665153f, 
    -0.02075558f, 0.05539222f, -0.03227947f, 0.00099271f, 0.00781709f, -0.03986977f, -0.18972655f, -0.04123363f, 
    0.01363421f, 0.00983930f, 0.02844624f, -0.02630989f, -0.09289743f, 0.04922936f, 0.17150719f, 0.15781878f, 
    -0.04603897f, 0.13396816f, -0.06351701f, 0.01805983f, -0.03500139f, 0.03765459f, 0.07602583f, 0.07281278f, 
    0.06357069f, 0.07824521f, 0.02716160f, 0.04615983f, 0.06403829f, 0.03548113f, -0.09762602f, 0.15878059f, 
    -0.19558121f, 0.05926644f, -0.15295613f, 0.02260781f, -0.02910782f, 0.00988435f, -0.12856112f, -0.10824261f, 
    -0.13695800f, -0.22933242f, -0.06082548f, 0.07522395f, -0.10185011f, 0.08622765f, -0.04475077f, 0.04841518f, 
    0.16948396f, 0.09873020f, 0.00239363f, 0.01364186f, 0.21489146f, 0.03155536f, 0.14393635f, 0.04840393f, 
    0.02335166f, 0.05046222f, -0.04925515f, 0.11309069f, 0.14230826f, 0.25439212f, -0.00433848f, 0.06306129f, 
    0.07451084f, -0.00388568f, -0.07407361f, 0.01754435f, 0.12111808f, -0.13577512f, -0.01167712f, 0.13864440f, 
    -0.25598562f, -0.16369580f, -0.01888135f, 0.17674178f, 0.16792841f, -0.12081730f, -0.14488293f, -0.16747874f, 
    -0.19523346f, -0.18535356f, 0.12471134f, 0.05306640f, -0.01860859f, 0.02060295f, -0.08601375f, 0.05791456f, 
    0.19787562f, 0.31973237f, 0.04356826f, -0.01882539f, 0.05515528f, -0.19415347f, 0.04479808f, -0.27433148f, 
    -0.06970843f, 0.01062842f, -0.00467528f, -0.00576498f, 0.06616757f, 0.00625909f, 0.10360159f, 0.07926579f, 
    0.02010325f, 0.11488275f, -0.02462352f, -0.00755608f, 0.14084768f, 0.05507164f, 0.25777385f, 0.11855169f, 
    0.15691705f, 0.28569067f, 0.05777271f, -0.04266081f, -0.14767148f, 0.09221365f, 0.11758347f, -0.12164059f, 
    0.12302848f, -0.16909961f, 0.08368152f, -0.01050648f, 0.05640887f, -0.02123372f, 0.04225825f, 0.05846475f, 
    0.01168793f, -0.13933419f, 0.02330472f, -0.01652902f, 0.33494839f, -0.13132313f, -0.28982508f, -0.00247157f, 
    -0.35907501f, 0.02573435f, 0.02571561f, -0.01235071f, 0.05001928f, -0.17531168f, 0.08141548f, 0.02472078f, 
    0.08750454f, 0.08544785f, 0.10003670f, 0.02310826f, -0.02262826f, -0.08748464f, 0.02017073f, 0.05266166f, 
    0.11206412f, -0.09860337f, -0.06720312f, 0.26774105f, -0.02068591f, -0.08478040f, -0.21741073f, -0.05280532f, 
    -0.29296380f, -0.21825463f, 0.07815287f, 0.04300376f, 0.00457106f, -0.00252043f, -0.05189081f, 0.17218345f, 
    0.11314254f, 0.11196060f, 0.12093341f, 0.03233101f, 0.05345653f, 0.33805379f, 0.02850948f, -0.00770528f, 
    -0.26639113f, 0.24884973f, 0.13285525f, 0.05591705f, 0.04177783f, 0.03344757f, 0.02072010f, -0.00267367f, 
    0.05007876f, 0.00199754f, 0.02897074f, -0.03816666f, 0.13114434f, 0.08385863f, -0.16015399f, 0.00876244f, 
    -0.02057896f, 0.45132849f, 0.22031045f, -0.06316172f, -0.15362428f, 0.13549916f, 0.02469836f, 0.23286439f, 
    -0.08222060f, 0.37212273f, 0.01547023f, 0.03899374f, -0.02857824f, 0.04964149f, -0.02117347f, -0.01944916f, 
    -0.00627947f, -0.20285839f, -0.22663806f, -0.05249252f, -0.14794105f, 0.28513283f, 0.16945972f, 0.21543624f, 
    -0.17728814f, -0.05368095f, 0.03755409f, -0.10142548f, 0.11051276f, 0.00796240f, 0.05245267f, -0.03758144f, 
    -0.04950255f, 0.16729636f, -0.20279135f, 0.23293574f, 0.12399951f, -0.09140518f, 0.07484869f, -0.00760164f, 
    -0.27206340f, -0.29147518f, -0.11613481f, -0.02912134f, -0.21752170f, 0.09514222f, -0.04115880f, 0.02138809f, 
    -0.21903133f, -0.08820710f, 0.04025556f, 0.04228127f, 0.06080505f, 0.11576924f, 0.01487919f, -0.04051386f, 
    0.16229860f, 0.16437723f, -0.07309122f, 0.28235301f, -0.13467179f, 0.07028262f, -0.00474338f, -0.01907333f, 
    -0.02539606f, -0.05618615f, 0.00663585f, -0.09485669f, -0.02921649f, 0.07280967f, 0.12069868f, 0.10815977f, 
    -0.01170197f, 0.14384843f, -0.05436525f, 0.13545111f, 0.12592131f, 0.00748919f, 0.20678137f, 0.00026259f, 
    -0.00332991f, -0.22083686f, -0.04177152f, 0.13352956f, -0.11057376f, 0.07571092f, -0.04401542f, -0.00251755f, 
    -0.17255269f, -0.05573715f, 0.10696598f, -0.08986409f, -0.07034493f, -0.07970463f, -0.14202374f, 0.02337897f, 
    -0.06092530f, -0.03478327f, -0.10784409f, -0.21878165f, -0.34828418f, 0.28581306f, -0.02638425f, 0.36804777f, 
    0.46915072f, 0.13258721f, 0.05159340f, -0.20485452f, -0.12952355f, -0.02376568f, 0.08982481f, -0.02782675f, 
    0.13485020f, -0.04244825f, 0.06841587f, 0.05433439f, 0.01844263f, -0.02511433f, 0.06503772f, 0.07458812f, 
    0.26293513f, -0.16268049f, -0.03352709f, 0.11453278f, 0.06426611f, -0.04905356f, 0.13601345f, 0.01521828f, 
    -0.03041176f, 0.29643354f, -0.00773045f, 0.09087722f, -0.18247971f, -0.04045386f, 0.08966748f, -0.01279243f, 
    0.05612696f, 0.20890419f, 0.01835799f, 0.20771915f, 0.13718452f, 0.01783254f, -0.08034509f, -0.04984435f, 
    0.04021329f, 0.10538868f, -0.04395179f, 0.04467270f, 0.05835616f, 0.08042324f, 0.03992074f, 0.11367187f, 
    -0.01505442f, -0.03175339f, 0.04642312f, 0.00793787f, -0.07767543f, 0.02559252f, -0.13062300f, 0.07458379f, 
    -0.09046465f, 0.21775575f, -0.34407422f, 0.21416569f, 0.06788163f, 0.15987349f, 0.03520727f, -0.06358804f, 
    -0.14642680f, 0.07819833f, 0.07929836f, -0.07203434f, 0.25479755f, 0.00111638f, -0.00123017f, 0.01169242f, 
    0.00862911f, 0.10527992f, 0.18000706f, -0.03362778f, -0.02544228f, -0.21403456f, 0.31671289f, -0.04125523f, 
    -0.11252860f, 0.06392179f, 0.02858336f, -0.09330708f, 0.05324749f, -0.14244105f, -0.11152641f, -0.05367787f, 
    -0.01673147f, -0.02563210f, -0.11083541f, 0.02731671f, 0.12626681f, 0.11509559f, -0.13302188f, -0.08861758f, 
    -0.20222239f, -0.10882421f, -0.31724653f, -0.13667887f, -0.02424324f, -0.04070566f, 0.01456762f, 0.14340098f, 
    -0.05674061f, 0.02830244f, 0.07574913f, 0.02445918f, -0.05558654f, -0.04689060f, 0.12105488f, 0.07788872f, 
    0.11493074f, -0.04259809f, -0.15311670f, -0.00758049f, -0.01063628f, 0.20327243f, 0.18463400f, -0.26069203f, 
    0.15407319f, 0.03802165f, -0.05347307f, -0.00818523f, -0.00745785f, 0.00342106f, 0.16611519f, -0.02836556f, 
    0.07461762f, -0.00768586f, -0.10445252f, 0.17894056f, -0.03645197f, -0.10060751f, -0.01265002f, -0.17227428f, 
    -0.34198454f, -0.16141847f, -0.06000634f, 0.05401439f, -0.20230669f, 0.12676747f, -0.07611776f, -0.12459964f, 
    0.02430006f, 0.07189452f, 0.07756340f, -0.14212275f, 0.00802133f, 0.22130133f, 0.05429517f, -0.18931061f, 
    0.12621923f, 0.28447405f, 0.01343205f, 0.04619336f, -0.29122651f, 0.15836070f, 0.51733100f, 0.30212799f, 
    0.05959661f, 0.08489932f, 0.04101986f, -0.22500943f, -0.04946798f, -0.04428119f, 0.02245211f, 0.06524212f, 
    0.09616228f, 0.06984036f, 0.08032762f, 0.03717079f, 0.02429030f, -0.03932985f, -0.00358713f, -0.03460208f, 
    -0.15172522f, -0.03521557f, -0.13794003f, -0.42974761f, -0.07382274f, -0.03060867f, -0.09999948f, -0.02388113f, 
    -0.04202343f, 0.21420453f, 0.03823109f, 0.12687747f, 0.13306999f, -0.02641396f, 0.10876762f, 0.02871494f, 
    0.03242555f, -0.01158829f, 0.10701448f, -0.04122006f, -0.19215113f, -0.26376048f, -0.06391175f, 0.36163202f, 
    -0.02975654f, -0.01274370f, -0.14411660f, -0.11312713f, -0.00863539f, 0.02646987f, 0.04393112f, -0.13520209f, 
    -0.11615543f, 0.02392385f, 0.00542780f, -0.10402562f, 0.18262503f, 0.03400409f, -0.08309154f, 0.09638911f, 
    0.20900711f, -0.36484709f, 0.16033487f, 0.13695833f, 0.36851072f, 0.08346114f, 0.11533233f, -0.18400410f, 
    0.14341199f, 0.01957955f, 0.06506629f, 0.07640916f, 0.00222489f, -0.16399644f, -0.01843768f, 0.07182089f, 
    0.08925831f, -0.01336120f, 0.28081122f, 0.21298587f, -0.30423570f, -0.02015040f, -0.25596008f, -0.17257421f, 
    0.09587641f, -0.00294339f, 0.13281733f, -0.11166655f, -0.07795912f, 0.09569784f, -0.06267612f, -0.10593928f, 
    -0.13092461f, 0.05810828f, 0.04518321f, 0.06152239f, 0.04562480f, -0.03077184f, -0.03664100f, -0.17424585f, 
    0.09818365f, 0.42205140f, -0.11696593f, 0.08289311f, 0.09368918f, 0.00686541f, -0.18962978f, -0.01508762f, 
    -0.01650840f, 0.02432937f, -0.02898256f, 0.00539463f, 0.04292176f, -0.10356375f, -0.05200623f, -0.01892162f, 
    -0.10352951f, -0.11089781f, -0.17532107f, -0.12539062f, 0.16722591f, 0.12103719f, -0.31802842f, -0.06245584f, 
    0.22983786f, 0.10350756f, 0.18925835f, 0.12238203f, 0.12215548f, 0.08101673f, 0.08410119f, 0.00251625f, 
    -0.12525706f, 0.06010615f, -0.03161581f, 0.19090432f, -0.03082552f, -0.01080337f, 0.07269210f, -0.16810006f, 
    -0.01868528f, 0.01886084f, -0.05506308f, 0.00884162f, 0.03971907f, 0.03487666f, -0.00138314f, 0.03362640f, 
    -0.02540411f, 0.02827564f, -0.03622798f, -0.02236607f, 0.01806084f, -0.06186703f, -0.01942584f, 0.00936481f, 
    -0.00573129f, -0.02841760f, -0.00082347f, 0.01003373f, -0.04509749f, -0.02765462f, 0.02655889f, -0.03295173f, 
    0.02824334f, -0.00196420f, -0.01441042f, 0.02497561f, 0.01900155f, -0.04990187f, -0.03910504f, 0.03797346f, 
    -0.00337222f, -0.00793368f, -0.00784623f, -0.05640003f, -0.04047129f, 0.03051027f, -0.04608748f, -0.03260174f, 
    -0.02489647f, -0.06370080f, 0.01200728f, 0.00048574f, 0.02231197f, -0.04681942f, -0.04922798f, 0.04141995f, 
    -0.02020711f, -0.05952835f, 0.03850802f, -0.01528364f, 0.00672982f, -0.04040276f, -0.06057844f, -0.03828545f, 
    -0.04445195f, -0.05199327f, -0.04092012f, 0.02021315f, -0.04626540f, -0.04441689f, 0.00788645f, -0.04456121f, 
    -0.03496084f, -0.01091143f, -0.00836232f, 0.02057870f, 0.02239412f, 0.02235001f, -0.02855286f, 0.03700577f, 
    -0.04657687f, 0.00464518f, -0.05176475f, 0.00313265f, -0.03772919f, 0.04422124f, 0.01955693f, 0.01288128f, 
    -0.02348431f, 0.03947845f, -0.00743182f, -0.02423175f, 0.03178936f, 0.03933961f, -0.02232500f, 0.03997809f, 
    0.04083634f, -0.04289457f, 0.05242499f, 0.04736993f, 0.03765618f, 0.03457717f, 0.02160359f, -0.00937429f, 
    -0.05651560f, 0.01443824f, -0.02220308f, -0.00296176f, 0.00498533f, 0.03575911f, 0.04601029f, -0.04179024f, 
    -0.00295979f, -0.02975726f, -0.04741332f, -0.02235963f, 0.00186321f, 0.00271191f, -0.01916239f, -0.01245903f, 
    -0.03943172f, -0.01881535f, -0.00918966f, -0.04055187f, 0.04542749f, 0.01270086f, -0.01302231f, -0.03674522f, 
    0.00408410f, 0.00896029f, -0.03794634f, 0.01231825f, -0.02665032f, -0.04221766f, -0.01909565f, -0.02522238f, 
    -0.01337118f, 0.02676649f, -0.01865512f, -0.03359478f, 0.04094024f, 0.00529528f, 0.01567651f, -0.02600387f, 
    -0.03829925f, 0.03187637f, -0.05831392f, -0.01359259f, 0.03090750f, -0.02207224f, -0.01410171f, -0.05898622f, 
    -0.03152267f, 0.03221794f, 0.04274957f, 0.04718062f, 0.03545098f, 0.00284568f, -0.04031504f, -0.01929938f, 
    -0.05128646f, 0.00747400f, 0.03727121f, 0.03017451f, -0.00949050f, -0.04234941f, 0.02123850f, -0.05354711f, 
    -0.04663819f, 0.00757083f, 0.03807750f, -0.01974677f, -0.00577996f, 0.01658881f, 0.03377713f, 0.04109308f, 
    0.01954295f, 0.04979753f, -0.03782429f, 0.02177127f, 0.03187829f, 0.03966119f, 0.03873976f, -0.06062330f, 
    -0.05185870f, 0.00160699f, 0.02692658f, -0.04866166f, -0.04021669f, -0.04064255f, -0.02119613f, -0.02174726f, 
    -0.00765519f, -0.00611311f, -0.03555172f, -0.04469966f, -0.00404192f, 0.03121143f, 0.01823937f, -0.00193603f, 
    -0.01907267f, -0.05184717f, 0.01339162f, 0.01858302f, -0.02537277f, -0.02211989f, -0.00501501f, -0.03925159f, 
    -0.01078269f, 0.03220171f, -0.05450809f, -0.06509855f, 0.01526533f, -0.00224547f, -0.03917575f, -0.03940485f, 
    0.03198998f, -0.05560207f, -0.03743867f, -0.01808062f, 0.00932071f, -0.01096854f, -0.02276783f, -0.00615947f, 
    0.02014484f, -0.04932518f, 0.03376165f, 0.01282568f, 0.03118448f, 0.04211519f, -0.00011143f, -0.01556744f, 
    0.01924460f, 0.04172796f, -0.04401380f, 0.03614904f, 0.04916762f, 0.01746245f, -0.04375717f, 0.03696064f, 
    0.03009701f, -0.01135438f, -0.03361441f, 0.03970558f, -0.00049298f, 0.00521093f, -0.04687415f, 0.04727314f, 
    -0.02433615f, -0.04696004f, -0.04597226f, -0.05620711f, 0.00991776f, -0.04422366f, -0.05101293f, 0.01927179f, 
    0.03719086f, -0.06286189f, -0.02161838f, 0.02327186f, 0.00771554f, 0.00999411f, 0.00793996f, 0.00109827f, 
    -0.05224077f, 0.01179315f, 0.02359540f, -0.00827254f, 0.02706559f, 0.04312091f, -0.02670947f, 0.02069195f, 
    -0.04173510f, 0.01766911f, 0.02912088f, -0.01398975f, -0.04963188f, -0.04873863f, 0.04917919f, 0.03416236f, 
    -0.01524952f, 0.02239978f, -0.00111720f, 0.01675286f, -0.02621112f, 0.00252388f, -0.02104229f, -0.05946995f, 
    0.01319521f, -0.00173647f, -0.05993132f, -0.05548677f, -0.03166139f, -0.04200665f, -0.01339472f, 0.02378913f, 
    -0.00724732f, 0.05219571f, 0.01803680f, -0.05317936f, 0.02612366f, -0.00585629f, 0.03341116f, -0.00000668f, 
    0.04116264f, 0.00171856f, -0.06003130f, 0.01155975f, 0.04266394f, -0.04959199f, 0.01201947f, -0.03442088f, 
    0.04613749f, 0.02400012f, 0.00568030f, -0.04525058f, 0.00963979f, -0.04452169f, -0.02452902f, -0.03736955f, 
    0.02946870f, 0.03771978f, -0.02901251f, 0.03959493f, 0.04434930f, -0.03263068f, -0.01646530f, -0.03257575f, 
    0.08743756f, 0.02815939f, 0.10009690f, -0.07244005f, 0.05675110f, -0.17744686f, -0.07569782f, 0.20904800f, 
    -0.12438377f, 0.01352342f, 0.05827297f, 0.04296003f, 0.11317158f, -0.05686545f, 0.09156293f, -0.08304467f, 
    -0.06529063f, -0.07998785f, 0.19147822f, -0.06970362f, -0.08715300f, 0.22925644f, -0.17498013f, -0.04592142f, 
    -0.28501928f, -0.13642219f, -0.02724206f, -0.05418438f, -0.04352847f, -0.18146499f, 0.11101645f, -0.06020596f, 
    0.11647379f, -0.09283605f, -0.06518560f, -0.03128010f, 0.01962721f, -0.06954642f, 0.08275467f, -0.00020606f, 
    0.40959218f, 0.20940818f, 0.23108944f, -0.02434009f, -0.11405877f, -0.16147885f, -0.12715097f, -0.06068203f, 
    -0.13440929f, -0.07146558f, -0.02603649f, 0.03204173f, -0.03407396f, 0.02956632f, 0.01721129f, 0.07083090f, 
    0.01928236f, -0.00686390f, 0.04547852f, 0.13585880f, -0.12868884f, 0.00139449f, 0.08388177f, 0.03421338f, 
    -0.06731396f, 0.04796466f, -0.01130860f, 0.00919037f, 0.03096551f, 0.01956601f, 0.04171360f, 0.10823619f, 
    -0.06464300f, 0.03510099f, -0.05563692f, 0.00745036f, 0.04474302f, -0.01128399f, -0.04207803f, 0.15542935f, 
    0.01882852f, 0.17883150f, 0.06016544f, -0.09219524f, -0.03572757f, -0.06910269f, 0.04479582f, -0.09518617f, 
    0.02903842f, 0.00221250f, 0.11078378f, 0.07174763f, 0.04245987f, -0.08919301f, -0.07726371f, -0.03774443f, 
    0.02208103f, -0.16401529f, -0.06411385f, -0.04599432f, 0.09461997f, -0.02189645f, -0.05263285f, -0.18544428f, 
    0.16087443f, 0.12574470f, -0.04615929f, 0.00596252f, 0.16315626f, -0.09922183f, -0.02157893f, -0.03418257f, 
    0.00198397f, 0.11757649f, 0.05292428f, 0.01824669f, -0.01104702f, 0.12480740f, 0.13355561f, 0.18706821f, 
    0.32849517f, 0.28283018f, 0.13255416f, 0.16838478f, -0.00622030f, -0.01986418f, 0.07744062f, 0.00253463f, 
    0.01230804f, -0.04932273f, -0.09233804f, -0.03121190f, 0.08117598f, -0.08013301f, 0.06963052f, -0.06753265f, 
    0.07216369f, -0.09936570f, -0.10266414f, -0.03602857f, -0.03777609f, -0.00968238f, 0.09282290f, 0.23576918f, 
    0.04310257f, -0.04536282f, 0.07897751f, 0.17773345f, -0.08926900f, -0.02415694f, 0.05941376f, 0.11344732f, 
    -0.17012244f, 0.07754223f, 0.04335262f, -0.06690560f, 0.03806385f, 0.13645555f, -0.15801640f, 0.01269142f, 
    0.25594181f, -0.52096051f, -0.23444523f, -0.33161628f, -0.00283839f, 0.06788013f, 0.03911797f, -0.03456404f, 
    -0.06030899f, 0.25843430f, 0.05957651f, -0.09117868f, 0.04619109f, 0.04303454f, 0.12035355f, 0.06251336f, 
    0.03491718f, -0.14803657f, 0.11288249f, 0.12081075f, -0.02960645f, -0.06702182f, -0.68509489f, -0.24320555f, 
    -0.46880844f, -0.10282429f, -0.09852762f, -0.04424824f, 0.06774322f, 0.18370964f, -0.11828045f, 0.09323326f, 
    -0.00861693f, -0.01572290f, -0.10946533f, -0.05594056f, 0.04647922f, 0.03563379f, 0.17978661f, 0.13082835f, 
    0.22164707f, 0.27895206f, 0.34775126f, 0.19174765f, -0.02223966f, -0.12142731f, 0.11004598f, -0.07118626f, 
    0.08260160f, -0.09070348f, -0.02473854f, 0.03719180f, -0.00489944f, 0.23838383f, -0.02910859f, -0.14761704f, 
    -0.14680089f, -0.06075919f, -0.09072907f, -0.08402532f, 0.41660315f, -0.49890155f, -0.00152283f, -0.61640298f, 
    -0.34610590f, 0.10855054f, 0.03176446f, -0.15658255f, 0.13435350f, 0.04615994f, 0.06814689f, 0.05399045f, 
    -0.06070964f, 0.12414206f, 0.04236448f, 0.07427850f, 0.05475980f, 0.05671520f, 0.30117998f, 0.11001962f, 
    0.26282585f, 0.26991960f, -0.25045550f, 0.00073183f, 0.06785966f, -0.07200659f, 0.09700626f, 0.02165911f, 
    0.17010495f, 0.06660834f, 0.02890540f, -0.00624190f, 0.02480194f, 0.08631783f, 0.08648708f, 0.17610964f, 
    0.10304858f, 0.12916619f, 0.10889556f, 0.00324398f, 0.14570971f, 0.08958006f, 0.02052933f, 0.26166594f, 
    -0.07169525f, 0.02579083f, -0.01301963f, 0.03122744f, 0.02227071f, -0.08317533f, -0.08629115f, -0.00579806f, 
    0.01743317f, -0.03174381f, 0.14493135f, 0.00113597f, 0.01911324f, 0.15169981f, 0.21312831f, -0.03697978f, 
    0.06323880f, -0.13183093f, 0.03734193f, -0.06073632f, -0.20583807f, 0.10351559f, 0.03278248f, 0.03578767f, 
    0.15829083f, 0.01639413f, 0.14132182f, 0.12588716f, -0.03937620f, 0.00838994f, -0.03603847f, -0.07765382f, 
    0.08733635f, -0.12288821f, 0.07008359f, -0.09991687f, 0.26273713f, 0.31046697f, 0.07673808f, 0.29435840f, 
    0.06824064f, -0.12949374f, -0.11794612f, 0.03361644f, 0.07648665f, -0.06046254f, -0.07390371f, 0.02459434f, 
    0.12245609f, -0.10928163f, 0.08713315f, -0.05382096f, 0.04806920f, 0.18081288f, 0.08303551f, 0.00829415f, 
    -0.16072153f, -0.17367938f, -0.10753898f, 0.19270661f, -0.00409796f, 0.17953460f, 0.14942965f, -0.01759836f, 
    -0.07823816f, 0.00658311f, 0.20415156f, -0.01246192f, -0.08194131f, -0.09926509f, -0.06074212f, -0.07688920f, 
    -0.11036583f, -0.01530781f, -0.04972773f, -0.06221499f, 0.28993234f, 0.22362861f, 0.10019141f, -0.03416720f, 
    0.13493648f, 0.11907688f, -0.18069953f, 0.10222401f, -0.03946522f, 0.12009110f, -0.01151387f, 0.09007160f, 
    0.11625099f, 0.00428045f, -0.03263982f, -0.13614699f, -0.02115422f, -0.10494021f, -0.09240705f, 0.02529986f, 
    0.28332698f, 0.00133627f, 0.10514591f, 0.19298378f, 0.33807224f, 0.08129425f, 0.25346732f, 0.06209278f, 
    0.05800107f, 0.05945919f, -0.01586358f, 0.03788571f, -0.11004865f, -0.12476944f, 0.07132787f, 0.03902190f, 
    0.18073057f, 0.18344983f, 0.09625032f, 0.18700404f, -0.00835800f, 0.01257949f, -0.04688882f, -0.01782678f, 
    0.11310315f, -0.01004526f, 0.01758873f, 0.05146653f, 0.09880610f, -0.00567836f, 0.04043036f, 0.07890659f, 
    -0.12751248f, 0.04691292f, -0.00263200f, -0.10685457f, -0.02190365f, 0.15511322f, 0.05313445f, -0.18818264f, 
    0.42697629f, 0.05813678f, -0.07872088f, -0.07127169f, -0.09765108f, 0.05067396f, -0.10418407f, 0.08777171f, 
    -0.06710052f, -0.04435647f, 0.14004606f, 0.01384634f, 0.13489354f, 0.09391373f, -0.06306044f, -0.02897350f, 
    -0.09608898f, 0.03834161f, 0.07352442f, 0.07302178f, -0.27916035f, -0.03916786f, 0.18878211f, 0.10633621f, 
    -0.00090854f, -0.01797266f, 0.10076749f, 0.12432001f, -0.05456150f, -0.14523011f, -0.04483743f, -0.04703847f, 
    -0.00002657f, -0.01832045f, -0.01601914f, 0.10442715f, -0.05549565f, 0.13778694f, -0.05524379f, -0.14832196f, 
    0.19634715f, -0.13270319f, -0.06433690f, -0.12244271f, -0.09246563f, 0.02873485f, -0.11441123f, -0.03554285f, 
    -0.13871565f, 0.03735050f, 0.08236241f, 0.03449948f, 0.00873393f, -0.06787594f, 0.07125758f, 0.05688784f, 
    -0.08287960f, -0.02306860f, -0.08154786f, -0.00933785f, -0.08564087f, 0.16232806f, 0.10506984f, -0.16952048f, 
    0.12547357f, -0.02570041f, -0.14511558f, 0.05671947f, -0.18536207f, -0.08472548f, -0.01396476f, -0.10279611f, 
    0.16167951f, 0.04647176f, 0.01350963f, -0.00072100f, -0.23324594f, -0.00454182f, -0.14810328f, -0.25603583f, 
    -0.35686737f, -0.12086732f, 0.23938531f, 0.10165127f, 0.09108164f, -0.04066671f, -0.04921523f, -0.03536113f, 
    0.06928567f, 0.05831275f, 0.09392414f, 0.03327285f, -0.12967612f, 0.05280649f, 0.07330686f, -0.10068307f, 
    0.07966314f, 0.27907956f, 0.01996706f, 0.07427278f, -0.32829607f, 0.28634125f, 0.56730229f, 0.03043124f, 
    0.32552895f, -0.02862999f, -0.06269477f, -0.12993352f, -0.01884191f, -0.05283390f, -0.04689812f, 0.07116865f, 
    -0.03127072f, 0.01200685f, 0.04711292f, -0.05989443f, 0.04166502f, -0.04028827f, -0.01199609f, -0.01350034f, 
    0.20003465f, 0.05908839f, -0.24986409f, -0.19914916f, -0.03967213f, 0.18914084f, -0.06515753f, -0.09035780f, 
    -0.13848448f, 0.18378495f, 0.13925087f, 0.03378687f, 0.15752268f, 0.01609826f, 0.11548040f, -0.05731883f, 
    0.04391944f, -0.00059735f, 0.10071305f, -0.01439629f, -0.13285433f, -0.10092388f, -0.01784136f, 0.31420600f, 
    0.20553546f, -0.08116458f, -0.00354987f, -0.01049837f, 0.00886684f, 0.01509818f, 0.13697688f, -0.02207733f, 
    -0.07593546f, -0.01126405f, 0.03008380f, 0.00734980f, 0.15192206f, 0.01523875f, 0.10181156f, -0.00589493f, 
    0.06287897f, -0.25631347f, 0.30431646f, 0.23046230f, 0.44505155f, 0.09152187f, 0.26510254f, 0.00956501f, 
    0.29303300f, 0.02241292f, 0.05515502f, 0.04656705f, 0.01576137f, -0.14232200f, -0.06201517f, 0.09207044f, 
    0.12297101f, 0.06333838f, 0.27301899f, 0.26284501f, -0.07463222f, -0.35214040f, 0.14902633f, -0.18319264f, 
    0.05366809f, 0.21067409f, 0.07979210f, 0.07620059f, -0.10069996f, 0.04381588f, -0.00062213f, -0.10571139f, 
    0.01893614f, -0.13161157f, -0.02947837f, 0.12151537f, 0.03767037f, -0.14420384f, -0.08800434f, -0.10078919f, 
    0.16033050f, 0.28868902f, -0.19755422f, 0.08278629f, 0.02103234f, -0.03222108f, -0.08744165f, 0.02018443f, 
    -0.03449241f, -0.10732286f, 0.08211911f, 0.03601955f, 0.03794900f, -0.13460806f, -0.01635162f, 0.00332523f, 
    -0.21940444f, -0.09737802f, -0.10266020f, -0.31248388f, 0.15929449f, -0.15874936f, 0.01848729f, -0.06910481f, 
    -0.01555647f, 0.21763298f, 0.05083328f, 0.07090271f, -0.01792576f, 0.04269527f, 0.10660584f, -0.19588238f, 
    -0.09519542f, -0.11005572f, -0.00279244f, 0.08518483f, 0.03282828f, -0.02019034f, -0.08072229f, -0.09191026f, 
    0.02499552f, 0.23175655f, 0.08647026f, -0.08339871f, 0.02022607f, -0.05603180f, 0.04856691f, 0.05115873f, 
    0.00133830f, -0.07557549f, 0.04591576f, -0.02566193f, -0.04295426f, -0.00576129f, -0.12381662f, 0.04069761f, 
    -0.07214183f, 0.03099359f, 0.06913088f, 0.07231943f, -0.31037605f, -0.11661378f, 0.07388881f, 0.13301069f, 
    0.30071452f, 0.08940113f, 0.06780308f, -0.01597923f, 0.00093168f, 0.15898767f, -0.13790177f, 0.06202988f, 
    -0.01438182f, 0.12653233f, 0.01261701f, 0.06494544f, 0.06561445f, 0.04754360f, -0.07525372f, 0.06707081f, 
    -0.39211795f, -0.20396112f, -0.08503528f, 0.14707130f, 0.29409754f, 0.13252111f, 0.16410224f, 0.23665884f, 
    0.22195175f, 0.15068203f, 0.09903861f, -0.00948337f, -0.05755264f, 0.02604315f, 0.00581950f, -0.01487143f, 
    0.03865346f, 0.11618359f, -0.00115971f, 0.09516635f, -0.01100440f, 0.28406054f, -0.09259561f, -0.00881847f, 
    -0.16862325f, 0.14756155f, -0.17024234f, -0.23384774f, 0.06624771f, 0.07951616f, 0.04147511f, 0.03078663f, 
    -0.07683044f, 0.04690143f, 0.19189104f, -0.00865103f, -0.02331039f, -0.05731010f, -0.03903178f, -0.18660840f, 
    -0.29921377f, -0.18435696f, -0.02243724f, 0.10405317f, 0.21643223f, 0.01597299f, -0.05682108f, -0.00689111f, 
    -0.04314275f, 0.09747046f, -0.06450800f, -0.02922172f, 0.05637632f, 0.01172779f, 0.06828102f, 0.03548761f, 
    -0.01950134f, 0.07448271f, -0.08086608f, 0.05035533f, -0.02435670f, -0.03530897f, 0.26339817f, -0.15440717f, 
    -0.20346257f, 0.00505051f, -0.00578825f, 0.02128887f, -0.04259744f, 0.05629561f, 0.02891915f, 0.04060676f, 
    0.06453122f, -0.03052899f, -0.12006779f, -0.00558407f, -0.07637247f, -0.02512479f, 0.23056461f, -0.06731065f, 
    -0.20904560f, -0.16184744f, -0.14671516f, 0.00360214f, 0.10263278f, 0.06292815f, 0.05602279f, 0.05922388f, 
    0.01861575f, 0.02122468f, -0.05763071f, 0.05286085f, -0.06007221f, -0.00382037f, -0.05942107f, 0.16741744f, 
    -0.08932273f, -0.15898755f, -0.06689506f, 0.01013044f, 0.05964358f, -0.00177308f, -0.11359990f, -0.08262610f, 
    -0.00839671f, -0.02282782f, -0.12138229f, -0.01119418f, -0.09374927f, 0.01668071f, -0.05914522f, -0.03300857f, 
    -0.05798936f, -0.15469831f, -0.02249235f, 0.10566133f, -0.08084536f, 0.04604360f, -0.04996121f, -0.04190691f, 
    -0.17132866f, 0.37076810f, 0.54566890f, 0.18388745f, -0.26511580f, -0.13917457f, -0.06649080f, 0.11237111f, 
    -0.10973863f, -0.07577650f, 0.01637954f, 0.11141929f, 0.02368055f, 0.22755617f, -0.02858108f, -0.01820415f, 
    0.08818603f, 0.08188335f, -0.09900304f, 0.02528012f, -0.41326138f, 0.10558441f, 0.32915315f, 0.14273043f, 
    0.18301137f, 0.11654668f, 0.10470197f, 0.08395232f, -0.27378964f, -0.04235611f, 0.03403484f, 0.11493324f, 
    0.07669363f, 0.15514286f, 0.10305373f, 0.09280663f, 0.01194995f, 0.04521133f, -0.06953300f, -0.05055763f, 
    -0.03529112f, -0.15888284f, -0.06421169f, -0.13912235f, -0.01954454f, 0.13755827f, 0.10732147f, -0.04870752f, 
    -0.01053229f, 0.13549970f, -0.01863108f, -0.16708133f, -0.04826549f, -0.12273654f, -0.03409440f, 0.09291299f, 
    0.19980769f, 0.21586093f, -0.02526809f, -0.05318194f, -0.05353539f, 0.14142588f, 0.30677646f, 0.27172655f, 
    -0.09035366f, 0.02272663f, -0.03984352f, 0.09798757f, -0.03431128f, 0.00496961f, 0.05362641f, 0.13143067f, 
    0.09316265f, 0.06001787f, 0.04575147f, -0.09478319f, -0.02028146f, -0.02792312f, 0.01608333f, 0.00892808f, 
    -0.10174394f, 0.08891694f, 0.14074956f, 0.20039126f, 0.03135448f, -0.18761900f, 0.10194775f, 0.10593424f, 
    0.01598335f, -0.04317891f, -0.05878115f, 0.04187745f, -0.03031291f, -0.02043935f, 0.01341601f, -0.09627232f, 
    -0.09015518f, -0.02933070f, 0.11258118f, 0.11226274f, 0.01966612f, 0.09475010f, 0.00419220f, -0.10977422f, 
    0.07960356f, -0.02724565f, 0.08500723f, -0.06540669f, -0.00079553f, 0.11792354f, -0.00567776f, 0.00686506f, 
    -0.07687106f, 0.10794418f, 0.01258796f, 0.09163865f, -0.00416138f, -0.32590124f, -0.25048080f, 0.12586607f, 
    -0.00050045f, 0.17297868f, 0.07274859f, 0.03718013f, 0.13175665f, -0.00366478f, -0.11282136f, -0.17246269f, 
    -0.00654550f, -0.17143586f, -0.07025208f, -0.10702722f, -0.11429778f, -0.04898940f, 0.08664238f, 0.14212267f, 
    -0.02763265f, -0.03296711f, -0.01604076f, -0.02707790f, -0.07668828f, -0.14830039f, -0.13623822f, -0.02122783f, 
    0.00410424f, 0.10561504f, 0.18551117f, 0.07954216f, 0.00054361f, 0.15851372f, 0.00979166f, -0.04841327f, 
    -0.05422082f, 0.02798560f, -0.05016813f, 0.06166930f, 0.02992810f, -0.24686931f, -0.21002850f, 0.02440960f, 
    -0.07449606f, -0.39330572f, -0.27625722f, -0.05141050f, 0.05491047f, 0.03439329f, -0.02199835f, -0.10199536f, 
    -0.11774128f, -0.13017343f, -0.12544745f, 0.04736738f, -0.02989190f, 0.02920732f, 0.06645300f, 0.15842637f, 
    0.12048282f, 0.12540106f, 0.13788310f, 0.21551044f, 0.25445837f, 0.00987138f, 0.08852301f, -0.06826838f, 
    -0.22867088f, -0.16184883f, 0.02280775f, 0.03683144f, 0.01609379f, 0.06578889f, 0.07674773f, 0.10995299f, 
    0.06811400f, 0.05721832f, 0.09666347f, -0.12392862f, 0.02893612f, 0.08520520f, -0.04233650f, -0.02899190f, 
    0.10619267f, -0.13382907f, 0.28403881f, 0.03020583f, 0.09097280f, -0.03150951f, -0.05866683f, 0.05803944f, 
    -0.07638677f, 0.01384489f, -0.08362520f, -0.01451364f, -0.02960293f, 0.09230439f, 0.08221559f, 0.09711252f, 
    -0.05095069f, -0.07640468f, 0.00471664f, -0.00047025f, 0.15618435f, -0.19848576f, 0.08632638f, 0.08143213f, 
    0.10989589f, 0.00793191f, 0.14035840f, -0.01791451f, 0.17978680f, 0.17117572f, -0.02682707f, 0.07026637f, 
    0.05444847f, -0.03450602f, -0.02553050f, 0.20434003f, 0.03075354f, 0.05725497f, 0.23032334f, 0.22171864f, 
    0.37966359f, 0.15851450f, -0.02152566f, -0.13037363f, -0.20685913f, -0.10979874f, 0.00695928f, 0.00570417f, 
    0.04095569f, 0.06505292f, 0.02233725f, -0.03884884f, 0.09080485f, -0.06192582f, 0.01360194f, -0.13238746f, 
    -0.05670733f, -0.05272267f, 0.15152353f, -0.00917965f, -0.00408807f, -0.04521131f, -0.10573483f, 0.08274741f, 
    -0.03252587f, 0.00717636f, 0.02874482f, -0.07841004f, 0.22176890f, -0.06221233f, -0.03378145f, -0.08779148f, 
    0.01510197f, -0.05182079f, 0.02762955f, -0.10240724f, -0.05260862f, 0.13567963f, 0.07659959f, 0.03697057f, 
    -0.16102929f, 0.12077714f, 0.17428684f, -0.23693542f, -0.25422981f, -0.10922952f, -0.26467589f, -0.03552400f, 
    0.02884850f, -0.02420836f, 0.03847621f, -0.11946455f, -0.01818028f, -0.05529070f, 0.11333279f, -0.04485554f, 
    -0.04697130f, 0.02244306f, 0.01738897f, -0.04406330f, -0.27253944f, 0.03070217f, 0.06841779f, 0.15902105f, 
    -0.01611584f, 0.11123314f, 0.10326125f, -0.11986328f, 0.14136384f, 0.14014304f, -0.05689404f, 0.03746415f, 
    0.05433786f, -0.00355459f, -0.00913589f, 0.10580532f, 0.12202507f, 0.10122464f, 0.15174530f, 0.06468572f, 
    -0.10427316f, 0.01711103f, -0.08710128f, 0.44340074f, 0.19339079f, 0.15620412f, -0.05618425f, 0.15459149f, 
    -0.00005067f, 0.07983027f, -0.08197706f, -0.02997863f, 0.00953545f, 0.07968295f, 0.09580202f, 0.07078098f, 
    -0.11754088f, -0.10457683f, -0.05738261f, -0.08791441f, -0.09258779f, 0.15495719f, 0.08988346f, 0.19445013f, 
    0.17136493f, 0.09896918f, -0.01297669f, -0.00202613f, 0.10834283f, 0.23343602f, -0.03833583f, 0.08269224f, 
    0.06253671f, 0.01495609f, 0.00789317f, 0.05476148f, 0.06222181f, 0.00290715f, -0.01069748f, -0.03814411f, 
    -0.49216428f, -0.08162283f, 0.10797860f, -0.03769123f, -0.15795004f, -0.16521351f, -0.10963634f, -0.15282571f, 
    -0.07196618f, -0.00293832f, -0.08421175f, -0.03188317f, -0.11931274f, -0.01441824f, 0.06796131f, 0.06290097f, 
    -0.10276340f, -0.08065992f, -0.09488855f, -0.00955949f, -0.19670998f, -0.04874695f, -0.15796754f, 0.09406556f, 
    0.08354358f, -0.06479913f, -0.09776543f, 0.06051250f, -0.01333243f, 0.08571191f, -0.08693999f, -0.04226799f, 
    -0.04278533f, -0.04729988f, -0.10403322f, 0.04823323f, -0.00510161f, -0.09286303f, -0.04071205f, 0.01038317f, 
    0.12148549f, -0.34917033f, -0.10604586f, -0.15279031f, 0.08789162f, -0.06527168f, -0.14918871f, 0.01054059f, 
    -0.04940215f, -0.15691783f, 0.11184360f, 0.09719588f, -0.08150513f, -0.00148477f, -0.00090262f, 0.05481124f, 
    0.00234163f, 0.07633012f, -0.05926367f, -0.14219670f, -0.21945007f, -0.15994091f, -0.08493525f, -0.33840436f, 
    -0.05212519f, -0.02000609f, -0.08480185f, 0.00368576f, -0.20073918f, -0.20685406f, -0.07536801f, 0.05071586f, 
    -0.08743162f, -0.09126616f, 0.04060830f, -0.05517086f, -0.00191448f, -0.01837945f, -0.14425085f, -0.00485373f, 
    0.12758122f, -0.06129914f, -0.07506856f, 0.08371505f, -0.01366694f, 0.01427750f, 0.06739423f, -0.01027854f, 
    0.11385845f, 0.09772126f, -0.03971078f, -0.09613861f, -0.03879137f, -0.01352439f, -0.01985128f, 0.02947418f, 
    0.09984048f, 0.02954539f, 0.13474625f, 0.09019519f, -0.13164710f, 0.20198807f, 0.06655135f, -0.08849636f, 
    0.01250181f, 0.05140821f, -0.03076760f, 0.06716427f, -0.04377143f, -0.15114236f, -0.13076858f, -0.00163171f, 
    -0.04369035f, 0.06004344f, 0.11263683f, 0.00632035f, -0.04713751f, 0.13894510f, 0.00443135f, 0.05097494f, 
    -0.01113548f, -0.00206903f, 0.00308352f, -0.05544718f, 0.04117909f, -0.01904170f, 0.00830607f, 0.04006098f, 
    -0.04306123f, -0.05000880f, -0.00800259f, -0.05124279f, -0.01094488f, -0.03377886f, -0.04635721f, -0.04910395f, 
    -0.02995169f, -0.00595485f, -0.04408617f, -0.00153161f, -0.00069637f, -0.02626229f, -0.03260905f, 0.01025859f, 
    0.02333855f, -0.01018762f, 0.00826147f, 0.02213483f, 0.04383045f, -0.02544399f, -0.03631984f, 0.04609218f, 
    -0.02976610f, -0.00799640f, 0.04452225f, -0.02134098f, 0.04761862f, -0.00830048f, 0.01333710f, -0.05360498f, 
    -0.04052641f, -0.01296429f, -0.03856325f, -0.03178326f, -0.04585738f, -0.04931847f, 0.04982539f, -0.01889990f, 
    0.00707418f, -0.02159653f, 0.01352360f, -0.00597878f, -0.03023853f, 0.02961797f, 0.02772380f, -0.03202692f, 
    -0.02649801f, -0.06093903f, -0.03801531f, -0.00919966f, 0.03060106f, -0.00600162f, 0.00965444f, -0.04836376f, 
    -0.03182674f, 0.00476747f, 0.00062227f, -0.02630906f, 0.03821602f, 0.02730601f, 0.01989798f, -0.03022562f, 
    0.02360505f, 0.03313128f, 0.02996472f, -0.02693818f, 0.03764384f, 0.02895715f, -0.06025710f, 0.00358759f, 
    0.02090304f, 0.01113782f, 0.00087103f, -0.03610132f, -0.01851014f, -0.02329422f, -0.03126713f, -0.03936642f, 
    0.02770578f, -0.04908025f, 0.01496889f, -0.04265467f, 0.01110313f, 0.02710657f, -0.04091229f, -0.01205966f, 
    -0.01377406f, 0.00824216f, -0.03071578f, -0.01168900f, 0.03352557f, -0.05425391f, -0.01626629f, 0.04897356f, 
    -0.05118490f, -0.02352662f, -0.00099695f, 0.03442762f, -0.00698026f, -0.02964405f, -0.05545698f, -0.05197132f, 
    0.00576959f, -0.02769737f, -0.05375361f, -0.03071140f, 0.01649796f, 0.02607088f, 0.02509612f, 0.01621369f, 
    -0.01658748f, -0.02095934f, -0.04424240f, -0.03356127f, -0.05539585f, -0.03813314f, -0.05617374f, -0.01223636f, 
    -0.03752379f, 0.04573053f, -0.03666152f, -0.05007686f, 0.04225035f, -0.00692817f, 0.02887169f, -0.02048686f, 
    -0.00449508f, -0.03463090f, -0.02830460f, -0.04864495f, 0.01457100f, -0.02969344f, -0.05806664f, 0.03029645f, 
    -0.02459032f, -0.03620724f, -0.03210558f, -0.03105165f, -0.04973717f, -0.03858726f, -0.02907221f, -0.03453492f, 
    -0.03927230f, 0.00306656f, 0.04970957f, 0.04092658f, -0.03831414f, 0.03971331f, 0.00210954f, 0.03529562f, 
    0.03750491f, 0.01731712f, 0.00462251f, 0.03712537f, -0.04542929f, -0.05511677f, 0.04898330f, -0.01541895f, 
    0.05065689f, 0.01110241f, -0.05335408f, -0.03239549f, -0.00984175f, -0.05357585f, -0.04441472f, -0.05428920f, 
    0.00954819f, 0.02476235f, -0.01642950f, -0.00176861f, -0.01846553f, 0.03832056f, -0.03593220f, 0.02231527f, 
    -0.03562552f, -0.01224967f, -0.03017992f, -0.02900312f, 0.03461049f, 0.04655274f, 0.04634482f, -0.01121593f, 
    0.03997042f, -0.05400920f, -0.05318063f, 0.02473966f, 0.02487121f, -0.05139398f, 0.03258669f, -0.00997084f, 
    -0.04384538f, -0.03798075f, 0.00465431f, 0.05207240f, 0.05569890f, -0.01589123f, 0.04631907f, -0.04621546f, 
    0.04023468f, -0.01414745f, 0.03090565f, -0.02029784f, 0.00244658f, 0.03761826f, 0.01286139f, 0.04485493f, 
    -0.00835972f, 0.02986583f, -0.00716376f, -0.01371715f, -0.05990677f, 0.00184761f, -0.02000635f, 0.01401142f, 
    0.01808348f, 0.03519509f, 0.04369438f, -0.00406021f, 0.01131879f, -0.04117212f, 0.04139556f, -0.02315237f, 
    0.00494625f, -0.02780759f, 0.01334788f, -0.02740765f, 0.01739730f, 0.00570606f, -0.05221953f, -0.00530925f, 
    0.01614412f, 0.02975996f, -0.04109544f, 0.01979401f, 0.00241945f, -0.02377894f, -0.03664186f, -0.05175496f, 
    -0.00120084f, -0.00169338f, 0.04746998f, -0.03108674f, -0.02669256f, 0.00062233f, -0.02954259f, 0.01846328f, 
    -0.02815074f, 0.00016875f, -0.02965192f, -0.04648002f, 0.02254668f, -0.00938871f, 0.01737306f, 0.04416705f, 
    -0.01365069f, 0.02981053f, 0.01073034f, 0.03125970f, 0.00818353f, 0.03448767f, -0.02396570f, 0.04574296f, 
    -0.01858197f, -0.04709107f, -0.02852258f, -0.00921743f, -0.03670574f, -0.03383303f, -0.02328763f, 0.03095671f, 
    0.00043960f, -0.01554362f, -0.03908435f, 0.01513284f, -0.03051237f, 0.03002487f, -0.04141814f, 0.03684811f, 
    0.00082964f, -0.01972776f, 0.04398514f, 0.04057057f, -0.05260401f, 0.04924692f, 0.04880746f, 0.00153844f, 
    -0.04571472f, -0.04691445f, -0.04732108f, -0.04171811f, -0.05293301f, -0.01540458f, 0.04001629f, 0.03378104f, 
    0.02943749f, 0.02816828f, 0.00301573f, -0.05900412f, -0.04031024f, 0.03571548f, -0.04319907f, -0.03620696f, 
    -0.00961811f, -0.00879385f, -0.04472762f, 0.02412822f, 0.00769143f, 0.00520567f, -0.00777032f, -0.05636888f, 
    -0.01568100f, 0.49419925f, 0.10071809f, 0.20976692f, 0.27075484f, -0.07850392f, 0.05301220f, 0.10913664f, 
    -0.02181478f, 0.12877791f, -0.02028999f, 0.06071948f, 0.01717599f, 0.00110456f, 0.00487226f, 0.02968841f, 
    0.04742309f, -0.03544348f, 0.14935860f, 0.08548854f, 0.33071733f, -0.12793340f, 0.26838636f, -0.23204747f, 
    -0.17639397f, 0.05652921f, -0.19275023f, 0.12440881f, 0.02079892f, 0.10353789f, -0.11729935f, 0.01235005f, 
    -0.04318491f, 0.00371704f, -0.00566226f, -0.07100474f, -0.07961541f, 0.06743899f, -0.04492992f, -0.02081981f, 
    -0.08194507f, -0.31018457f, -0.36386257f, 0.07650017f, 0.05012768f, -0.07356180f, -0.03601036f, 0.04343222f, 
    -0.04770856f, -0.11834022f, 0.10293654f, -0.09391484f, -0.00286758f, -0.06095975f, 0.07142282f, 0.09829334f, 
    -0.16045903f, -0.18064903f, 0.04049474f, -0.07524755f, -0.14906633f, 0.17148328f, 0.21409483f, 0.05894319f, 
    0.04487567f, 0.00689751f, -0.02482750f, -0.05521967f, 0.06200105f, 0.03194651f, -0.01868504f, -0.19471987f, 
    0.03953428f, 0.06652442f, 0.02446821f, -0.04466527f, 0.06221812f, -0.06299521f, 0.04773531f, -0.11018632f, 
    0.07898495f, -0.37495646f, 0.20239285f, -0.11737752f, -0.07238918f, 0.07176753f, -0.06501950f, 0.14733262f, 
    0.03787088f, 0.07894401f, 0.03628783f, 0.03768464f, -0.08380499f, 0.11497652f, 0.08779906f, -0.03803508f, 
    -0.07720467f, 0.05592068f, -0.14677463f, 0.02648290f, -0.07442924f, 0.33944479f, 0.04969180f, 0.17448489f, 
    0.27643096f, -0.10663447f, -0.17889827f, -0.00590218f, -0.00839667f, 0.07021078f, -0.03769683f, 0.05237636f, 
    0.02967323f, 0.06065538f, 0.05928171f, -0.02634073f, -0.01982817f, -0.22226724f, 0.12719004f, -0.08017008f, 
    -0.30937240f, -0.45164624f, -0.07133411f, -0.21924905f, -0.17981946f, -0.00690000f, -0.03397854f, 0.00748087f, 
    0.10297520f, -0.03557223f, -0.03638458f, 0.11240341f, 0.02222028f, 0.00510555f, 0.00884864f, 0.14743899f, 
    -0.05982355f, 0.02776973f, -0.00447189f, 0.10023481f, 0.06467339f, -0.11415288f, -0.02299009f, 0.08545493f, 
    -0.04865735f, 0.00335737f, -0.08837989f, -0.01991916f, 0.07279363f, 0.02904201f, -0.17013671f, -0.04981839f, 
    0.06602439f, 0.04908310f, -0.00126696f, 0.03363103f, -0.02742877f, 0.06942762f, 0.08103971f, 0.03390281f, 
    0.30160797f, 0.41295004f, 0.29260275f, 0.28703383f, 0.27849329f, -0.05766544f, 0.22488311f, 0.07129000f, 
    0.01522385f, 0.06043924f, -0.13043846f, 0.01545460f, -0.09457131f, -0.17351055f, -0.02532956f, 0.13453124f, 
    0.02383605f, -0.10301129f, 0.04827851f, -0.07473460f, 0.23834255f, 0.12084595f, -0.08891598f, 0.05371435f, 
    0.01711468f, 0.11734504f, -0.06450821f, 0.04339773f, -0.11767686f, 0.07983167f, -0.20108937f, 0.05187659f, 
    -0.04107321f, 0.04532500f, 0.08250994f, -0.01355243f, -0.02242319f, 0.02573256f, -0.03029844f, 0.02071782f, 
    -0.02829904f, -0.24124700f, -0.39457178f, 0.04536683f, -0.28599858f, 0.02499434f, 0.00804824f, 0.07451002f, 
    0.01241528f, 0.08825388f, 0.09154459f, -0.07320221f, -0.03085735f, 0.11542302f, 0.08262097f, -0.01173879f, 
    -0.02841339f, 0.16909441f, -0.11543275f, 0.05479983f, 0.13890330f, 0.24622521f, 0.19023548f, 0.07609020f, 
    0.13373560f, -0.21474345f, 0.01243530f, -0.09709391f, -0.10241549f, -0.01339374f, -0.00313599f, 0.07333893f, 
    -0.05682916f, -0.07507548f, 0.02018447f, 0.11634433f, 0.01097751f, -0.00462160f, 0.06053034f, -0.00612481f, 
    -0.16902748f, 0.21354829f, -0.31169248f, 0.00319637f, -0.07077564f, -0.08621391f, 0.00855699f, 0.25749680f, 
    -0.13589470f, 0.18419316f, 0.02824715f, 0.07186984f, -0.09413937f, 0.00920624f, 0.00076782f, -0.04137645f, 
    0.06981034f, 0.06073256f, -0.23909247f, -0.01084327f, -0.16539785f, -0.24234906f, -0.06263076f, -0.09100217f, 
    -0.07075852f, 0.03652432f, 0.07439547f, 0.25072396f, -0.09359080f, -0.02388824f, 0.03189941f, -0.03723614f, 
    0.15379375f, 0.12829876f, 0.10055899f, 0.00977628f, 0.13800260f, 0.12574032f, -0.04957993f, 0.09638392f, 
    -0.09165662f, -0.13843600f, 0.31249210f, -0.00786263f, -0.01290667f, -0.01313948f, -0.00676116f, -0.05512748f, 
    0.08788805f, 0.07461883f, -0.01866063f, -0.03519375f, -0.02702518f, -0.02417486f, 0.07089310f, 0.11094696f, 
    0.07584555f, 0.02992526f, -0.00012705f, 0.14586532f, -0.26630926f, -0.39412034f, -0.00023339f, -0.04782824f, 
    -0.26401001f, 0.00228983f, -0.03752203f, 0.07469224f, -0.06608504f, -0.01782523f, -0.04891118f, -0.08101753f, 
    0.03079124f, -0.05629057f, 0.02943172f, -0.06795385f, 0.10764728f, 0.04832584f, -0.08921441f, 0.13893417f, 
    -0.07801116f, 0.23092331f, 0.31684348f, 0.17548023f, -0.01550845f, -0.12442804f, 0.01800549f, -0.05246660f, 
    -0.07075159f, -0.04094676f, -0.03597742f, 0.02698121f, -0.01438666f, -0.00962932f, 0.00436704f, -0.06118695f, 
    -0.10094284f, -0.07350288f, -0.06032678f, 0.03043888f, -0.33521545f, -0.27919006f, -0.36423543f, 0.10496306f, 
    0.27016324f, 0.12249427f, 0.04404229f, 0.03797229f, 0.00927652f, 0.17747714f, -0.01398168f, 0.09628031f, 
    0.05295841f, 0.03344493f, -0.03620354f, 0.03186903f, 0.05750490f, -0.01781802f, 0.06849133f, -0.07777044f, 
    0.25422880f, -0.36273468f, -0.09220230f, 0.26830450f, 0.15453760f, 0.09939092f, 0.01303932f, -0.06024892f, 
    0.06954705f, 0.12351277f, -0.01934068f, 0.06661079f, -0.12679505f, -0.16744033f, -0.00006240f, -0.05641952f, 
    0.18441573f, 0.09317352f, -0.10888778f, 0.03094474f, 0.32501888f, 0.11794890f, 0.20792852f, 0.15725815f, 
    0.12594874f, 0.11056232f, -0.05400372f, 0.00577122f, 0.10509483f, 0.11434049f, 0.02352778f, 0.09741382f, 
    -0.01753587f, 0.06826112f, 0.07350491f, 0.07042816f, -0.08038781f, -0.02529302f, -0.06788255f, -0.03073717f, 
    -0.34799615f, -0.26130059f, -0.11181280f, -0.10038747f, 0.17348810f, 0.20065373f, -0.03522845f, -0.07320892f, 
    0.07799678f, 0.05865818f, 0.05491409f, 0.10926412f, 0.00330742f, 0.02000240f, 0.19885735f, 0.10621400f, 
    -0.04092280f, 0.08928796f, 0.04782642f, -0.04638305f, 0.08122569f, 0.05688214f, 0.33181193f, 0.03423132f, 
    -0.06683230f, -0.01756768f, -0.02231206f, -0.11049505f, -0.07596170f, 0.00958038f, 0.09905713f, -0.02862736f, 
    0.01631145f, 0.00953953f, 0.00398442f, 0.12567492f, 0.03254542f, -0.06823216f, 0.13734663f, 0.08282368f, 
    -0.04580167f, -0.24528807f, -0.12923212f, 0.06230821f, -0.07564975f, 0.05299750f, 0.05615183f, -0.06564988f, 
    -0.04103241f, -0.07639271f, -0.07327630f, 0.10291266f, -0.00757225f, -0.13037427f, -0.02222392f, 0.12271454f, 
    0.05760944f, -0.04452639f, -0.10244791f, -0.00637877f, 0.18482944f, -0.04030373f, -0.29409552f, -0.02513497f, 
    0.02254370f, -0.04400249f, 0.16556916f, 0.00563897f, -0.06013646f, -0.06311170f, -0.01104572f, -0.01133783f, 
    0.18210359f, 0.10915362f, 0.13180646f, 0.07529236f, -0.03924860f, 0.06104078f, 0.03545063f, -0.14262562f, 
    -0.17534903f, -0.11764351f, 0.31698820f, 0.30325875f, -0.09888430f, 0.05112629f, 0.03904627f, 0.19927265f, 
    -0.05839698f, 0.22803542f, 0.01158675f, -0.05334092f, -0.08356472f, 0.07900238f, 0.01191684f, 0.08888277f, 
    -0.06136952f, 0.03494831f, 0.02984243f, 0.03944785f, -0.07230255f, -0.05566348f, 0.14165454f, 0.25274056f, 
    -0.10521090f, 0.06575882f, 0.01731353f, 0.09276783f, -0.09972955f, 0.20977554f, -0.08200295f, 0.02110355f, 
    0.04743546f, 0.11151946f, -0.03963808f, 0.04666342f, -0.09247814f, 0.02793353f, -0.06541284f, 0.05535401f, 
    0.08456127f, -0.28725335f, -0.07318835f, -0.24065864f, -0.08389935f, -0.04706150f, 0.12156623f, -0.20498270f, 
    -0.01019130f, -0.01055055f, 0.03131755f, 0.02381695f, 0.05958673f, -0.07282327f, 0.06538477f, -0.12838759f, 
    0.16982110f, 0.02260369f, -0.02345362f, -0.03071528f, -0.18589494f, 0.03381302f, 0.22015677f, 0.26645491f, 
    -0.08204842f, -0.13113348f, 0.02400510f, 0.09630556f, -0.05771368f, 0.08189901f, 0.02446806f, -0.07104114f, 
    -0.00478541f, 0.04593110f, -0.09655418f, 0.12346842f, 0.06958295f, -0.01686153f, -0.00342824f, 0.07918234f, 
    0.04010820f, 0.20896398f, 0.09446919f, 0.17254233f, 0.05702163f, 0.01809656f, 0.13565828f, -0.13625403f, 
    0.17281149f, 0.08495438f, 0.02062402f, 0.11450774f, 0.04276314f, -0.04089607f, -0.09322028f, -0.05315315f, 
    0.14111708f, -0.15592735f, 0.12662970f, 0.14410940f, 0.02071970f, 0.25665781f, 0.07047412f, 0.08971789f, 
    -0.05092448f, 0.11408711f, 0.04166872f, -0.02111592f, -0.12781289f, 0.15673430f, -0.08110894f, 0.05881728f, 
    -0.06592171f, 0.11219524f, 0.07233726f, -0.04849605f, -0.09851864f, 0.03569617f, -0.11977351f, -0.02411901f, 
    -0.03623336f, -0.02737608f, 0.16279347f, 0.03917604f, 0.13559434f, 0.05963994f, 0.09732086f, -0.07371922f, 
    -0.09857725f, 0.01172489f, 0.08264140f, 0.03110348f, 0.08909454f, -0.12011021f, -0.01511733f, -0.02333708f, 
    0.07545178f, -0.01619063f, -0.13302433f, -0.09455026f, 0.16964844f, 0.08632358f, -0.14560229f, 0.05331589f, 
    -0.00901800f, 0.02889308f, 0.07561500f, 0.01984692f, 0.09633052f, 0.13815847f, 0.02684412f, -0.00250205f, 
    0.05072552f, 0.07677881f, 0.00893962f, 0.14714608f, 0.07232583f, 0.06253864f, 0.05324786f, -0.04277496f, 
    -0.24680556f, -0.45735350f, -0.31038466f, -0.29599145f, 0.00429800f, 0.05527833f, -0.00725639f, -0.24472381f, 
    0.02446617f, -0.18330924f, 0.02627769f, 0.05887965f, 0.07228222f, 0.08491552f, 0.06120883f, 0.03859270f, 
    0.06911938f, 0.16558945f, 0.14783855f, 0.16896504f, 0.14371027f, -0.20837608f, 0.24510302f, -0.13776343f, 
    -0.07414455f, -0.12729843f, 0.00232207f, 0.09200177f, -0.06481386f, -0.00320563f, -0.00689923f, 0.07503268f, 
    0.10578974f, 0.13948782f, 0.10532044f, -0.00719742f, 0.01297106f, -0.04113398f, 0.02084737f, 0.00750157f, 
    -0.17878892f, -0.01878278f, 0.01665497f, -0.18448167f, -0.04224703f, -0.03383569f, -0.04601631f, 0.07219924f, 
    0.00824920f, 0.00333238f, -0.08396718f, -0.08499078f, 0.01454799f, 0.16374880f, -0.00167247f, -0.06667417f, 
    0.06313398f, -0.07966598f, 0.06855310f, -0.03698295f, 0.27869168f, -0.10527868f, -0.12041140f, -0.07134300f, 
    0.12035559f, -0.01947244f, 0.30806792f, 0.14895080f, 0.12448057f, 0.07895327f, 0.02625848f, 0.03117634f, 
    0.08963708f, 0.01481721f, 0.06306693f, 0.18154299f, -0.00252119f, 0.07325073f, 0.15147583f, 0.06521168f, 
    0.31302422f, -0.07601309f, 0.03540068f, -0.13026790f, -0.01994252f, -0.06543832f, -0.01066064f, 0.11935084f, 
    -0.01414459f, -0.00323713f, -0.04373061f, 0.04577645f, 0.17830737f, 0.13026057f, 0.06125297f, -0.00172850f, 
    0.00338145f, -0.13540654f, -0.01860126f, 0.04438715f, -0.10610007f, -0.05495616f, -0.36192521f, 0.00277637f, 
    -0.03715362f, -0.02172628f, 0.16423844f, -0.07940958f, 0.04838199f, -0.02623761f, 0.12434566f, -0.01788801f, 
    0.09440403f, 0.05705540f, 0.10138750f, 0.03962321f, 0.03933592f, 0.22642942f, 0.13100541f, 0.08792558f, 
    0.05476315f, 0.18979926f, 0.10761236f, -0.32638586f, -0.18830729f, -0.02186235f, -0.13422556f, -0.05857900f, 
    -0.10542192f, 0.03048608f, -0.01885151f, -0.21624748f, -0.01773133f, 0.09374273f, 0.02348252f, -0.17886232f, 
    0.07959644f, -0.00354088f, 0.00169714f, -0.04928889f, 0.02496657f, 0.08169009f, -0.07777583f, 0.13179407f, 
    -0.01635241f, 0.00393925f, 0.07253160f, -0.09049521f, 0.16042466f, -0.11513513f, 0.05404912f, 0.15045401f, 
    0.06346037f, -0.00157894f, 0.17352082f, 0.01811038f, 0.05261155f, 0.05446720f, 0.09521938f, 0.01947230f, 
    0.01780768f, 0.04960334f, -0.13487659f, 0.10127101f, 0.25550187f, -0.01334042f, -0.08470582f, 0.07993474f, 
    0.23710588f, 0.05748331f, -0.01242712f, 0.11612286f, 0.12803075f, -0.02810438f, -0.01389298f, -0.05924667f, 
    -0.02539221f, -0.05210840f, 0.05653284f, 0.01600826f, 0.12481385f, 0.09264401f, 0.33461919f, 0.01569063f, 
    0.31361121f, -0.02092006f, 0.06282026f, 0.07561616f, 0.27542940f, 0.12573761f, 0.11196151f, 0.07049940f, 
    0.13199067f, -0.00001227f, 0.04884583f, 0.05592411f, 0.02121217f, -0.03674423f, 0.02009016f, -0.00707483f, 
    -0.35205907f, -0.06352673f, 0.06090187f, -0.14206621f, -0.00060324f, -0.09509579f, -0.06755423f, -0.07608896f, 
    -0.06760469f, -0.21986525f, -0.17707834f, 0.00992992f, 0.10474867f, -0.00920726f, 0.01451630f, 0.03732159f, 
    -0.08208098f, -0.15884881f, -0.14419948f, -0.04717765f, -0.12748852f, 0.11544165f, -0.21349676f, -0.10983976f, 
    0.10121417f, -0.15452504f, -0.17544152f, 0.09991334f, 0.01622312f, 0.03822501f, -0.03957271f, 0.03538927f, 
    0.01701664f, -0.00491771f, 0.01522680f, 0.10142507f, -0.06184794f, -0.03566016f, 0.08917935f, -0.08868421f, 
    -0.31669739f, -0.44511631f, -0.24520490f, -0.29434827f, -0.39617622f, -0.02736183f, 0.08963214f, -0.09810384f, 
    -0.04702647f, -0.18929200f, 0.01126640f, -0.00866109f, 0.02943397f, 0.03764457f, 0.00336832f, 0.01349809f, 
    0.05411654f, 0.02094446f, 0.05408954f, -0.08796848f, 0.13273419f, -0.32187676f, -0.08122771f, -0.26182130f, 
    -0.13864003f, -0.10896197f, -0.14022413f, -0.13782418f, -0.20018299f, -0.19944309f, -0.09138975f, -0.01878303f, 
    -0.03184174f, -0.07232241f, -0.04241098f, -0.09491178f, 0.05738210f, -0.02800301f, 0.09633746f, -0.12440316f, 
    -0.05567001f, -0.00795701f, -0.19020112f, -0.15868759f, 0.10509627f, -0.16700177f, 0.03779595f, 0.08309756f, 
    0.01045619f, 0.14806463f, 0.16241367f, 0.02688670f, 0.09826119f, 0.04843872f, 0.06323116f, -0.00299729f, 
    0.01078754f, 0.01533732f, 0.04703631f, -0.07704804f, 0.05556554f, 0.02648357f, 0.33004177f, 0.01634133f, 
    -0.06799410f, 0.06366083f, 0.00478885f, 0.03117962f, -0.07453671f, -0.09604113f, -0.01211595f, 0.02164960f, 
    0.06693073f, -0.02273896f, 0.08610613f, 0.03475757f, 0.04028865f, 0.02750938f, 0.06625050f, 0.14121141f, 
    -0.02748101f, -0.00952565f, 0.01259217f, -0.03921324f, 0.02704416f, -0.06189490f, -0.04938045f, -0.02610802f, 
    -0.03398306f, -0.01811885f, 0.04787383f, -0.04995430f, 0.02113390f, 0.04039680f, 0.02732054f, -0.00515122f, 
    -0.04986542f, -0.04239001f, 0.00439117f, -0.00023886f, -0.00437918f, 0.03689807f, -0.01870752f, -0.01147567f, 
    0.03218773f, 0.04346888f, 0.00665025f, -0.05067152f, 0.01099849f, -0.04432099f, -0.05256984f, 0.01725808f, 
    0.02522992f, -0.02963127f, -0.01371832f, 0.04579369f, -0.02696001f, 0.02020647f, -0.05074938f, 0.02650640f, 
    -0.03124138f, -0.01495579f, 0.00928518f, 0.04693129f, 0.04694586f, 0.01457123f, 0.03856380f, -0.02224473f, 
    -0.03763831f, 0.00685823f, 0.00215662f, 0.04376272f, -0.02165385f, 0.03119076f, -0.03231977f, 0.02817816f, 
    0.02338771f, -0.04104824f, 0.00300747f, 0.01581614f, -0.03139553f, -0.03034757f, -0.02623637f, 0.02905548f, 
    -0.05363866f, 0.04094255f, -0.05179683f, 0.02377777f, -0.01430365f, -0.05376459f, -0.05094591f, -0.01708732f, 
    0.00748744f, -0.03006700f, -0.00066136f, -0.03263520f, -0.05071975f, -0.00109561f, 0.01656616f, -0.01404217f, 
    -0.00213491f, -0.04132418f, -0.01528258f, -0.04759525f, -0.06081069f, -0.05100417f, -0.02871412f, -0.02400869f, 
    0.01886372f, 0.03685857f, -0.03498394f, 0.01696707f, 0.03612659f, -0.00054255f, -0.02496410f, -0.04225476f, 
    -0.03722427f, -0.00106249f, -0.04768395f, -0.00482094f, -0.02572764f, -0.05918774f, 0.02790127f, -0.02197960f, 
    -0.03561892f, -0.03057981f, -0.02215892f, 0.03272861f, 0.02272424f, 0.01081777f, -0.01337108f, 0.01338908f, 
    -0.03157369f, 0.01966175f, -0.03965975f, 0.03554130f, -0.01998248f, 0.01865779f, -0.05421367f, 0.00196366f, 
    -0.04454459f, -0.05278910f, -0.01267581f, -0.00778058f, 0.04387316f, -0.01865175f, -0.00929148f, -0.02990648f, 
    -0.00259716f, -0.02580837f, -0.01883934f, -0.00294076f, -0.02830810f, -0.02636835f, 0.04398425f, 0.00035690f, 
    0.05475311f, -0.01651269f, 0.01556249f, 0.01930533f, -0.02554158f, 0.02294841f, 0.01485404f, -0.04840392f, 
    0.00404074f, 0.02471954f, -0.04838844f, -0.04706468f, -0.02290420f, 0.01381828f, -0.05754782f, 0.04190724f, 
    -0.05276961f, 0.01673732f, 0.01748345f, -0.03707140f, -0.05453878f, 0.02562861f, 0.00527040f, -0.00682153f, 
    -0.03637092f, 0.04367474f, 0.02632465f, 0.03441773f, -0.00052949f, 0.01194756f, 0.02997837f, -0.03135225f, 
    -0.02184514f, -0.00870976f, -0.02903264f, 0.01747835f, -0.03402913f, 0.01071159f, -0.04754938f, -0.01457235f, 
    0.04369270f, -0.05402813f, -0.03852920f, -0.03099418f, -0.02561270f, 0.04474955f, 0.01552633f, -0.04641139f, 
    -0.00283763f, 0.03688483f, -0.03789253f, -0.02505334f, 0.02892169f, -0.05658443f, 0.03184098f, -0.03441843f, 
    -0.01622421f, 0.04571744f, 0.03387013f, -0.02265607f, 0.00665241f, 0.03601127f, -0.03981994f, 0.03142950f, 
    0.03551481f, 0.01310169f, 0.05237697f, -0.02250577f, -0.01430668f, 0.00328442f, 0.05199312f, 0.01264118f, 
    -0.01983125f, 0.03942570f, -0.01035737f, 0.01765778f, 0.05408053f, 0.01907469f, -0.04328148f, 0.05195851f, 
    -0.00700931f, 0.02996430f, 0.04176636f, 0.02971093f, 0.04981961f, -0.01807714f, -0.03631577f, -0.06082231f, 
    0.03291935f, 0.02869210f, -0.03800762f, 0.00561800f, -0.00028825f, -0.05336870f, 0.04496213f, -0.00016807f, 
    -0.00435841f, -0.06049181f, -0.02690920f, -0.04672862f, -0.04262539f, -0.01255018f, -0.00855017f, 0.04096255f, 
    -0.00137083f, -0.00614685f, 0.04582861f, 0.04132899f, 0.01836275f, -0.04155716f, 0.04477185f, -0.04011376f, 
    -0.05193939f, 0.01314423f, 0.04457187f, -0.05512654f, -0.00409281f, -0.05957405f, -0.01900844f, -0.04429874f, 
    0.03349527f, 0.04387447f, 0.03902530f, -0.00042375f, -0.04088612f, 0.01287856f, -0.04442051f, -0.02761137f, 
    0.03334260f, 0.05539399f, -0.00611362f, -0.00613773f, 0.04055474f, -0.02958274f, -0.05783055f, -0.01262195f, 
    0.00908239f, -0.01343340f, 0.04334581f, -0.01684810f, -0.03843353f, -0.02147996f, 0.01540069f, 0.02645859f, 
    -0.04986014f, 0.03199304f, -0.01761273f, -0.05671973f, 0.01851648f, -0.02694187f, -0.01187050f, 0.02402909f, 
    -0.04037062f, 0.00933384f, -0.04940332f, -0.03865741f, 0.02204723f, -0.03952141f, -0.01749990f, 0.03208429f, 
    -0.03947792f, -0.03573493f, -0.02035609f, -0.03897004f, -0.05138153f, 0.00453047f, 0.02888236f, -0.03837844f, 
    0.02893651f, -0.01937088f, -0.01149059f, 0.04255215f, 0.02696935f, -0.01175932f, 0.04837803f, 0.04394236f, 
    0.01688032f, -0.03718089f, -0.01236747f, -0.03773911f, -0.02641569f, 0.00037436f, -0.02345612f, -0.03408466f, 
    0.23488705f, -0.24201803f, -0.05453908f, -0.16704212f, -0.08485759f, -0.08347726f, -0.23136620f, -0.00333261f, 
    0.02810971f, -0.13837001f, -0.01559970f, 0.01668807f, 0.01614909f, -0.02636493f, 0.02282897f, 0.05375253f, 
    0.00563371f, 0.16861677f, 0.03609127f, 0.08822091f, -0.36603251f, 0.28299940f, -0.18667555f, 0.11936734f, 
    -0.10587730f, -0.08178256f, 0.10714810f, -0.05504469f, 0.01382818f, -0.17378566f, 0.12670973f, -0.03219782f, 
    0.11166535f, 0.11427784f, 0.08895865f, -0.05909704f, 0.01815823f, 0.07635253f, 0.05376158f, 0.00942100f, 
    -0.07507095f, 0.06812870f, 0.61984164f, -0.15972151f, -0.08644218f, 0.13705289f, 0.04589418f, 0.05430638f, 
    -0.00130364f, 0.00277677f, -0.14181007f, 0.03688494f, -0.11407887f, 0.04481030f, -0.06668793f, -0.00229425f, 
    -0.00052381f, 0.05944591f, -0.05051378f, 0.12344947f, 0.25998038f, -0.03227300f, 0.04743772f, 0.16568908f, 
    -0.01454150f, 0.13793172f, -0.15503155f, -0.00224706f, 0.09908379f, 0.12401040f, 0.03728006f, 0.13999510f, 
    -0.10169629f, 0.09933206f, -0.02408786f, 0.15009813f, 0.14263478f, 0.03231267f, 0.02884650f, 0.18948434f, 
    -0.14543183f, 0.33678955f, 0.06650437f, -0.03258922f, -0.01675969f, -0.07573427f, 0.08454935f, -0.10311267f, 
    0.08460984f, -0.04961547f, 0.03151937f, 0.09784029f, 0.04350290f, -0.02580754f, -0.01582421f, -0.05974925f, 
    0.06392036f, -0.13280746f, 0.13851292f, -0.10794464f, 0.06052527f, -0.10764539f, -0.18261261f, -0.06093426f, 
    -0.08103161f, 0.26388943f, -0.07695353f, 0.04783977f, 0.23093729f, 0.02191311f, -0.02251230f, -0.02268752f, 
    -0.01506816f, -0.00057481f, 0.01042461f, 0.07685483f, 0.01695760f, 0.23775017f, -0.01966143f, 0.09443828f, 
    0.03510993f, 0.16197596f, 0.19851629f, 0.07871360f, -0.09131694f, -0.14700307f, 0.01830270f, -0.05584856f, 
    0.03681162f, -0.12866519f, -0.08076221f, -0.09840008f, -0.14708102f, -0.01470604f, 0.01244019f, -0.00058082f, 
    0.09587269f, -0.05309274f, -0.04217621f, -0.14540103f, -0.24255367f, 0.11502825f, 0.05521818f, 0.18700801f, 
    0.12439428f, -0.01364090f, 0.07954470f, -0.01505303f, 0.03314839f, 0.04174399f, 0.08036570f, 0.19567141f, 
    -0.20976758f, 0.08308169f, 0.00324945f, -0.10130192f, 0.08562966f, -0.02304501f, -0.04365794f, 0.10137291f, 
    0.11397447f, -0.03776002f, -0.08188722f, -0.08887620f, -0.04276472f, 0.15899968f, 0.00152455f, -0.01026474f, 
    -0.03046348f, 0.12223108f, 0.09354170f, -0.15758735f, 0.08933574f, 0.17903881f, 0.17911135f, 0.13491708f, 
    0.10935134f, 0.03347432f, -0.03202147f, 0.00491309f, -0.32072425f, 0.09820169f, -0.32453632f, 0.05515346f, 
    -0.17688833f, 0.04289537f, 0.06485136f, 0.05428489f, 0.06779054f, 0.08422700f, 0.15978213f, -0.07426636f, 
    -0.03704556f, 0.10102944f, -0.05578685f, 0.03157270f, 0.04336300f, 0.00258612f, 0.03285470f, 0.10928316f, 
    -0.13509169f, -0.11344798f, 0.30754310f, 0.02463973f, -0.11031795f, -0.19614378f, -0.01271089f, -0.10371676f, 
    0.08388618f, -0.06246896f, -0.21278036f, 0.01928890f, -0.06419830f, 0.03976957f, 0.07565790f, 0.09889671f, 
    -0.01321421f, -0.11690759f, 0.03712838f, -0.03330401f, 0.09724333f, -0.23432481f, -0.05125235f, -0.21229160f, 
    -0.17198543f, 0.26787865f, 0.05581503f, -0.11718424f, 0.06645781f, -0.02029278f, 0.08935922f, -0.04683394f, 
    0.06475641f, 0.05896108f, -0.01134548f, 0.06662715f, -0.00399111f, 0.12107657f, 0.06178755f, 0.05868762f, 
    0.06895077f, -0.16207141f, 0.01333227f, -0.06560126f, -0.01170869f, 0.00395112f, -0.08460052f, 0.04495535f, 
    0.07299537f, -0.05436619f, 0.12186203f, 0.02135683f, 0.04448150f, -0.01076755f, 0.06779569f, 0.28467089f, 
    0.06288001f, 0.05977434f, 0.06200780f, -0.09721018f, -0.01999141f, 0.23364973f, 0.04740527f, 0.14416698f, 
    -0.13173136f, -0.19076739f, -0.09145019f, -0.04011421f, -0.04401474f, -0.18539001f, -0.07258977f, -0.01116902f, 
    -0.13826810f, -0.13764152f, 0.01655260f, 0.06153727f, -0.08669234f, 0.03971782f, -0.03002864f, 0.07759164f, 
    0.07492275f, -0.10107752f, -0.00581827f, -0.10786825f, -0.11944574f, 0.04623440f, -0.09433113f, -0.00626845f, 
    -0.03246270f, -0.07532727f, -0.00381802f, 0.03986700f, -0.04729138f, 0.08207560f, 0.14325529f, -0.06374711f, 
    0.07390402f, -0.05657436f, 0.08266565f, -0.07926299f, 0.03275810f, 0.25741211f, 0.14069913f, 0.27897882f, 
    0.21605161f, -0.11604598f, 0.00986888f, -0.03936180f, 0.00346916f, -0.03433818f, -0.14099066f, 0.01647319f, 
    -0.08073708f, -0.08655352f, -0.03289357f, 0.09520904f, -0.01629962f, 0.08231074f, 0.03530726f, -0.02754787f, 
    0.09089230f, 0.29163805f, 0.47864139f, 0.25461888f, -0.15659423f, -0.05159923f, -0.01633109f, 0.03370775f, 
    -0.03473307f, 0.18769501f, 0.04239198f, 0.09060948f, 0.03944737f, -0.13154167f, 0.00117631f, -0.12099382f, 
    0.01019310f, 0.01381611f, 0.04681936f, -0.06720936f, -0.22560441f, 0.02230398f, -0.38764462f, -0.02637641f, 
    -0.04756970f, -0.18996523f, -0.31276950f, 0.05523625f, 0.10489298f, -0.05898796f, 0.09537642f, 0.03551343f, 
    0.03540387f, -0.02518073f, -0.04505874f, -0.17157400f, -0.08294781f, 0.21883240f, -0.17732242f, -0.06921133f, 
    0.14253195f, -0.10349501f, -0.02385698f, 0.51028001f, -0.04514601f, -0.00375023f, 0.14704838f, -0.15135218f, 
    -0.07735176f, 0.15806472f, 0.03644255f, 0.08351090f, -0.03820162f, -0.17712893f, -0.07853243f, -0.02376302f, 
    0.11254892f, 0.07895551f, 0.03266443f, 0.17782885f, 0.11943862f, 0.02531955f, 0.19878188f, 0.05888360f, 
    0.05468613f, 0.05250991f, -0.13943207f, -0.00211600f, 0.13240315f, 0.09490724f, 0.05164468f, 0.03936101f, 
    -0.11390977f, 0.12080389f, 0.05019264f, -0.02153153f, -0.08649718f, 0.09256414f, -0.15080582f, 0.21332240f, 
    0.00878017f, 0.17128603f, -0.38423073f, 0.19102967f, -0.02023388f, -0.09108665f, -0.09980608f, -0.10125124f, 
    0.09409225f, 0.16419639f, 0.08611315f, -0.01512657f, 0.08824164f, 0.08004897f, -0.05980496f, -0.05006488f, 
    -0.08708344f, 0.19765311f, -0.07008287f, 0.05540667f, 0.28961363f, -0.10126577f, 0.52183563f, -0.16208120f, 
    -0.00604524f, 0.14586578f, 0.00628228f, 0.09824026f, 0.01309518f, -0.05291432f, -0.05820330f, -0.04282281f, 
    0.08079897f, 0.07372275f, -0.02655818f, -0.00633532f, 0.09776109f, -0.12887268f, 0.08236956f, -0.03669061f, 
    -0.51598668f, -0.49292457f, -0.33334672f, 0.18327689f, 0.11800651f, 0.21021235f, -0.14692894f, 0.05071013f, 
    -0.09965675f, 0.14968614f, 0.00870268f, -0.07597266f, -0.03671124f, -0.13519128f, 0.18080926f, 0.10194103f, 
    -0.04668025f, -0.13809440f, -0.06035236f, 0.15347202f, 0.05482678f, -0.34816462f, 0.09165003f, -0.33761483f, 
    0.10147633f, 0.09284326f, -0.07726277f, -0.00321788f, -0.06422140f, 0.07428613f, 0.04130946f, -0.12216453f, 
    0.02897611f, 0.04449441f, -0.00874238f, 0.10037301f, -0.07485190f, 0.11197915f, -0.09986769f, -0.06296512f, 
    -0.07602078f, -0.46388516f, 0.08993646f, 0.01454005f, -0.15351070f, -0.16330551f, -0.06691319f, 0.09753200f, 
    -0.06425463f, 0.08777442f, 0.05960001f, 0.08018769f, -0.15440108f, 0.17457731f, 0.14759599f, -0.08284596f, 
    -0.09767170f, -0.02607638f, -0.00630431f, 0.06167816f, 0.01718071f, -0.24038054f, -0.13822983f, -0.09431224f, 
    -0.18114439f, -0.14412133f, -0.20394588f, -0.01198183f, -0.05723800f, 0.09141951f, -0.04720865f, 0.13620958f, 
    -0.11654957f, 0.08867255f, -0.05378937f, 0.04163878f, -0.05758473f, 0.04348997f, 0.07042810f, 0.03172478f, 
    0.23229750f, 0.06295106f, -0.33065549f, 0.00896029f, 0.04141228f, 0.21183945f, 0.05114251f, -0.04526246f, 
    -0.11708635f, 0.25959522f, 0.05105181f, -0.12204561f, -0.06848085f, 0.05158716f, 0.17260331f, -0.13644931f, 
    -0.07014776f, -0.08681682f, -0.08235258f, 0.03960664f, -0.09591100f, -0.20547542f, 0.08809207f, 0.16065967f, 
    -0.05436602f, -0.18289867f, 0.09903074f, 0.03228226f, 0.10554273f, 0.07510104f, 0.05581048f, -0.05107165f, 
    -0.06665690f, 0.07205137f, 0.01136466f, -0.02491177f, 0.14834204f, -0.07921121f, 0.09262619f, 0.08409839f, 
    0.27391812f, 0.28487647f, 0.29608664f, 0.16127785f, 0.06292924f, 0.06954354f, 0.18137683f, 0.21688144f, 
    0.12744650f, 0.12194061f, 0.05176234f, 0.05473018f, 0.13560867f, -0.03752482f, -0.07242802f, 0.06691299f, 
    0.13364357f, -0.07044305f, -0.03063558f, 0.11940797f, -0.40630230f, 0.20585565f, -0.08946186f, 0.10531324f, 
    -0.09118579f, 0.18673983f, -0.02461830f, -0.03626203f, -0.24141209f, 0.19867636f, -0.21671771f, 0.04317739f, 
    0.07820395f, 0.00223523f, 0.09792902f, 0.01642132f, 0.06662609f, -0.02734715f, -0.13344882f, -0.02332144f, 
    0.22216377f, 0.13873906f, 0.05619176f, 0.09792247f, -0.01683383f, -0.00666287f, -0.13968988f, -0.12177135f, 
    0.00051140f, 0.10201322f, -0.10478918f, -0.05748089f, 0.00253162f, -0.06303325f, -0.06441838f, 0.06891171f, 
    -0.03027926f, -0.11144876f, 0.04322913f, 0.00271558f, 0.07266727f, -0.01830739f, -0.73081493f, -0.13825196f, 
    -0.05896381f, 0.26134098f, -0.09556166f, 0.21860139f, -0.06062753f, -0.05910446f, -0.10348032f, -0.05140072f, 
    0.01016631f, 0.04381591f, -0.05159449f, 0.08852831f, 0.03107402f, 0.08625276f, -0.08559196f, -0.11956694f, 
    -0.18076953f, -0.37047270f, -0.36917493f, 0.03894287f, 0.12589237f, 0.05922905f, 0.08783327f, -0.05479167f, 
    -0.06368666f, -0.09978192f, 0.03218682f, 0.05518468f, -0.00781751f, 0.05825572f, 0.07825073f, 0.01985996f, 
    -0.00887690f, 0.06398574f, -0.05930219f, -0.03844864f, 0.33840489f, 0.16920422f, 0.22126223f, -0.01295108f, 
    -0.01410433f, 0.06991357f, -0.04898504f, -0.02271929f, -0.13604979f, 0.05730507f, -0.10353649f, -0.07875179f, 
    0.05307508f, -0.07512084f, -0.05017081f, -0.04086560f, 0.02234640f, -0.02445419f, 0.04941737f, 0.06743746f, 
    0.10434760f, -0.01221297f, 0.18386354f, -0.22983719f, 0.27729255f, -0.08810633f, 0.26419172f, 0.20869654f, 
    0.06066795f, 0.08607162f, -0.02598171f, 0.02089543f, 0.00822209f, -0.00920441f, 0.03378579f, 0.05836595f, 
    -0.06797307f, 0.03001821f, 0.00376211f, -0.01263964f, -0.15971784f, -0.03155938f, -0.12837297f, -0.02971232f, 
    0.11340408f, -0.07193504f, 0.06263864f, 0.08119571f, 0.10400860f, -0.03234126f, 0.06519485f, 0.08791734f, 
    0.02989054f, 0.04086313f, -0.01462195f, -0.04221603f, 0.03097552f, 0.03675680f, 0.13522860f, -0.16283599f, 
    0.42955369f, 0.12737700f, 0.03038846f, 0.03738116f, -0.06513901f, -0.07839737f, 0.08048581f, 0.13278838f, 
    -0.04321940f, 0.01134502f, -0.07097709f, -0.08158010f, 0.12655528f, -0.01384021f, -0.06691965f, -0.11391880f, 
    -0.00080430f, -0.07626744f, 0.12363868f, -0.01422033f, -0.29398546f, -0.02407727f, -0.25257063f, 0.14710125f, 
    0.07564252f, -0.02538461f, 0.11754602f, 0.05828887f, 0.01111602f, -0.14590894f, 0.02410276f, 0.07068699f, 
    -0.11315987f, 0.01269031f, 0.07764897f, -0.06047790f, -0.01376613f, 0.05966230f, -0.12415683f, -0.11202373f, 
    0.28096646f, 0.08763960f, 0.13807517f, -0.14182661f, -0.00416457f, -0.05213641f, -0.08590592f, -0.04610772f, 
    -0.08675770f, -0.00179063f, -0.08448242f, -0.06467023f, -0.07244228f, -0.08366255f, -0.09470000f, -0.05535672f, 
    -0.05765511f, 0.03132924f, 0.05573358f, 0.03237412f, -0.24265538f, 0.23147029f, 0.15554810f, -0.03079149f, 
    0.02444933f, -0.01119849f, -0.08485264f, -0.06158810f, -0.02754954f, -0.10387621f, -0.12480851f, -0.05615570f, 
    0.02135869f, 0.04364852f, 0.04521676f, 0.01871847f, -0.11685586f, -0.08999288f, -0.01354321f, -0.05551954f, 
    -0.31826746f, 0.12287342f, 0.01953142f, 0.06189611f, 0.25235820f, 0.11292738f, -0.02051841f, 0.03027821f, 
    0.16585639f, -0.02190080f, -0.16593668f, 0.05056640f, 0.06405154f, 0.01621305f, -0.00254665f, -0.01028475f, 
    0.12773015f, 0.07740504f, 0.06016636f, 0.03868468f, -0.27398232f, 0.21430856f, 0.37304881f, -0.03129135f, 
    0.35430601f, 0.01405561f, -0.00127438f, -0.08997060f, 0.01427505f, -0.10165300f, -0.11170847f, 0.12061613f, 
    0.06168101f, -0.02201588f, 0.04228862f, 0.08054757f, 0.03188589f, -0.07152844f, 0.01081507f, 0.08400908f, 
    0.03202154f, 0.15149896f, -0.13324383f, 0.04212795f, 0.02470421f, -0.02920814f, -0.13401383f, -0.02522376f, 
    0.00838698f, -0.06257488f, -0.12284533f, -0.22901118f, 0.03186203f, -0.05928750f, -0.06707513f, 0.04027804f, 
    -0.09537530f, 0.02533807f, 0.05900984f, 0.01744712f, -0.10898878f, -0.14588530f, -0.13994387f, 0.10443103f, 
    0.23985860f, 0.04404393f, -0.01475977f, -0.05866432f, -0.02522887f, -0.07557828f, 0.06206386f, 0.13848472f, 
    0.10235383f, -0.09726016f, 0.08943450f, -0.03139377f, 0.00271075f, 0.03575544f, 0.05359164f, -0.05856435f, 
    0.04400753f, -0.42612767f, -0.00880498f, 0.09435585f, 0.37753227f, 0.06606771f, 0.13536006f, -0.01255456f, 
    0.05643429f, -0.08042829f, 0.00614167f, -0.01645860f, -0.00770980f, -0.03222845f, 0.03112445f, 0.07406253f, 
    -0.15163133f, 0.12842925f, 0.14598145f, 0.02949495f, 0.06485284f, -0.36164734f, 0.09109724f, -0.13367712f, 
    0.05784094f, 0.02308442f, -0.03550422f, 0.16732915f, 0.00136842f, 0.06512616f, 0.01876525f, -0.10825230f, 
    0.04551939f, -0.06761731f, -0.08388407f, 0.01048142f, -0.03366023f, 0.04929602f, 0.15851733f, 0.10495337f, 
    -0.04290679f, 0.01123044f, -0.13575993f, 0.00498811f, 0.02234998f, -0.10064895f, -0.04878116f, -0.00253073f, 
    -0.02722200f, -0.09726594f, -0.01454129f, -0.03898059f, 0.05983803f, 0.09740666f, 0.10790283f, 0.03664298f, 
    -0.02132349f, 0.04640453f, 0.05535167f, -0.20267424f, 0.08705139f, -0.10359133f, 0.15465093f, -0.01452689f, 
    0.04723793f, -0.00883792f, -0.05558755f, -0.01506936f, 0.03195213f, 0.01204482f, 0.06924377f, -0.10044827f, 
    -0.08464495f, -0.08360948f, -0.07266422f, -0.03403089f, -0.06149707f, -0.05240364f, 0.05733326f, 0.07481954f, 
    0.12942776f, -0.31011426f, -0.06981675f, -0.13221806f, -0.09419330f, 0.09570010f, 0.08293363f, -0.10697822f, 
    0.12711474f, -0.07080473f, 0.03958253f, 0.00161416f, -0.09501128f, -0.04450282f, -0.00729185f, 0.02258365f, 
    0.09341446f, 0.03143049f, -0.02262476f, 0.16745202f, 0.13279755f, 0.25515148f, -0.30084395f, -0.03862917f, 
    -0.26455319f, -0.11218589f, 0.00834453f, -0.01838269f, 0.05855979f, -0.10847348f, 0.10625982f, -0.05502953f, 
    0.10279416f, 0.12932278f, 0.07523532f, -0.14491241f, 0.04922671f, 0.09354216f, -0.01914189f, 0.02510010f, 
    -0.04365229f, 0.07819167f, 0.60099268f, -0.08828048f, 0.03256831f, -0.04740579f, -0.08619797f, -0.13965331f, 
    0.03803374f, 0.09755941f, -0.01316649f, 0.00530670f, -0.01918425f, 0.11040638f, -0.02542684f, -0.03686216f, 
    0.01184053f, 0.11671694f, -0.02055302f, -0.02624588f, 0.17697808f, -0.14492948f, -0.16019298f, 0.17181484f, 
    0.02990883f, 0.14145473f, -0.04275990f, 0.13189100f, 0.14553045f, 0.17270243f, 0.03763850f, 0.13517851f, 
    -0.04992005f, 0.04439517f, -0.01714054f, 0.03994816f, 0.09563056f, -0.02240982f, 0.02094091f, 0.23916529f, 
    0.40738174f, 0.45727044f, -0.02225063f, -0.06297608f, -0.13129413f, -0.10239178f, 0.02164569f, 0.01127238f, 
    0.10375217f, -0.05112364f, -0.05231387f, 0.07864500f, 0.03508307f, 0.01918214f, -0.08236032f, -0.10365734f, 
    0.02260554f, 0.01150450f, 0.13961461f, -0.00659970f, 0.11608680f, -0.04818564f, -0.14996383f, 0.05249764f, 
    0.02020311f, 0.17856295f, 0.09577662f, 0.11655993f, 0.08947597f, -0.00917299f, 0.01475438f, -0.00592853f, 
    -0.03655047f, -0.04029807f, -0.06997494f, -0.09287746f, -0.01971672f, 0.17035054f, -0.02511746f, 0.15413280f, 
    -0.01654474f, 0.14623675f, 0.16854712f, 0.01879739f, -0.11588253f, -0.08316774f, -0.19563873f, -0.19515537f, 
    -0.15475570f, -0.10645787f, 0.05434136f, -0.05346812f, -0.07381830f, 0.01339355f, -0.01416241f, -0.09857700f, 
    0.08679546f, 0.09061782f, -0.03899980f, -0.10738423f, -0.36773190f, 0.10043563f, -0.04843330f, 0.11895652f, 
    0.16218510f, 0.07605519f, -0.00207496f, 0.07599114f, 0.08249447f, 0.00660252f, 0.07355659f, 0.11706384f, 
    0.00760529f, -0.04306072f, -0.08576651f, -0.00797284f, 0.13523664f, 0.06616803f, 0.11003219f, 0.14152947f, 
    -0.09364409f, -0.02564996f, -0.18899859f, -0.15806280f, 0.15664966f, 0.17910588f, 0.02779271f, 0.06032382f, 
    0.02765420f, -0.02038415f, -0.03902149f, -0.01933521f, 0.05807576f, 0.10732725f, 0.12991209f, -0.03355507f, 
    -0.01132078f, -0.02214524f, -0.04030778f, -0.10703488f, -0.20545572f, 0.02979679f, -0.24890150f, -0.16138868f, 
    -0.03261901f, -0.00950243f, 0.00067693f, 0.14588690f, 0.05794954f, 0.12880369f, 0.01362453f, 0.04747087f, 
    0.02700040f, 0.01687660f, 0.01482076f, -0.01648623f, 0.04662972f, -0.01900665f, 0.07305953f, 0.05582670f, 
    -0.15438110f, 0.10389131f, 0.15648928f, 0.00753182f, -0.00531563f, -0.11555565f, -0.07305851f, -0.23502195f, 
    0.00421880f, -0.10487565f, -0.07351609f, -0.05009526f, 0.05436525f, -0.10587899f, 0.04667100f, -0.01505332f, 
    -0.00075169f, -0.12610871f, 0.03636354f, -0.07384571f, 0.03919962f, -0.13668776f, -0.13035436f, -0.22138783f, 
    -0.02623337f, 0.16587645f, 0.06676567f, 0.08239631f, 0.05982154f, -0.00896636f, 0.04810146f, -0.06165474f, 
    -0.05514737f, -0.02510602f, -0.01952016f, -0.05858774f, -0.04989915f, 0.07595766f, -0.08332367f, 0.04570009f, 
    0.10417323f, -0.14487088f, 0.14474644f, -0.12382720f, 0.11234138f, 0.01442322f, -0.05522293f, -0.00053759f, 
    0.01684436f, 0.04687316f, 0.13900925f, 0.01466144f, -0.02756694f, -0.08890374f, -0.00865507f, 0.20104825f, 
    0.05786752f, -0.04083872f, 0.00817827f, -0.21392889f, -0.07794236f, 0.13644372f, 0.05988632f, -0.05298120f, 
    -0.08155065f, -0.08008163f, -0.10691307f, -0.18215521f, -0.03841912f, -0.20317815f, 0.03151785f, -0.04235391f, 
    -0.12647676f, -0.10070437f, -0.06475779f, -0.10438892f, -0.01031016f, 0.00279105f, -0.05635932f, 0.08773658f, 
    0.12073062f, -0.09090080f, -0.22311845f, -0.11551223f, -0.10590544f, 0.12068124f, 0.03207413f, 0.00209309f, 
    -0.00833987f, 0.04235607f, -0.03562426f, -0.04439492f, -0.03318575f, 0.11965419f, 0.07338694f, -0.05793641f, 
    0.07338548f, 0.01654340f, -0.06905093f, 0.05685623f, -0.18265004f, 0.20146053f, 0.05632631f, 0.12667835f, 
    0.19138375f, -0.01988384f, -0.08921796f, -0.20423907f, -0.04234863f, -0.10999501f, 0.02618907f, 0.02054904f, 
    0.01091402f, 0.00321503f, -0.10032322f, 0.07524509f, -0.11699315f, 0.08702814f, 0.08116620f, -0.05913602f, 
    0.00605958f, 0.04474670f, -0.02603279f, -0.00135714f, -0.04479495f, -0.06380461f, 0.02014137f, -0.01253313f, 
    -0.04625048f, -0.04205257f, 0.03732799f, 0.00218608f, -0.04738716f, -0.05157445f, -0.01966811f, 0.00946300f, 
    0.03943942f, -0.02038865f, 0.03618472f, -0.00250313f, 0.01899851f, -0.03183399f, -0.02426847f, -0.02948678f, 
    -0.06896613f, 0.03483501f, -0.02671356f, -0.05890210f, 0.01860635f, 0.05118916f, -0.05477237f, 0.02983466f, 
    -0.04832631f, -0.03753765f, 0.01601025f, 0.01247281f, -0.01499215f, 0.03411221f, -0.06804799f, -0.02330938f, 
    -0.07168175f, -0.06506760f, -0.05254871f, -0.01358025f, 0.00312963f, 0.03304800f, -0.00403476f, -0.00135363f, 
    -0.02413624f, -0.02950952f, -0.00976040f, -0.04361379f, 0.02676940f, 0.02143639f, -0.02802227f, -0.05862846f, 
    -0.04933256f, -0.01844565f, -0.02573417f, -0.01048790f, -0.02270769f, -0.02056739f, 0.01390492f, -0.04301544f, 
    0.04237081f, 0.01713523f, -0.04815769f, -0.00754668f, 0.02131068f, 0.00498081f, -0.00959703f, 0.01742192f, 
    0.00949154f, -0.00212082f, -0.05147697f, -0.03407544f, -0.06004036f, -0.02792796f, 0.04273403f, -0.06098115f, 
    0.03412697f, -0.01209131f, 0.01629539f, 0.00694527f, -0.03144600f, 0.04026633f, -0.05975599f, 0.02982670f, 
    0.04055756f, 0.03241795f, -0.02277282f, 0.00822526f, 0.00548819f, 0.01348776f, -0.03826149f, 0.03255277f, 
    -0.00524893f, -0.06053189f, 0.03404894f, -0.00848776f, -0.00380628f, 0.03660832f, 0.03765512f, 0.04246998f, 
    -0.04687471f, 0.02648791f, -0.01018142f, -0.04539322f, 0.02214900f, -0.02171054f, 0.02046880f, -0.04572300f, 
    -0.01642402f, -0.02854408f, 0.00721904f, -0.04256975f, -0.05820984f, 0.03872117f, -0.04119077f, -0.00882570f, 
    0.01066811f, -0.02929063f, -0.05136646f, -0.05867275f, 0.04768842f, -0.00861131f, -0.02801498f, -0.00696378f, 
    0.03578004f, -0.01814772f, 0.01284238f, -0.02231680f, -0.00240808f, 0.00349940f, -0.00663540f, -0.01683968f, 
    -0.01340192f, 0.04544319f, -0.07012242f, -0.01315491f, 0.00614370f, -0.02324523f, 0.00108597f, -0.05287147f, 
    -0.01836907f, -0.05295331f, -0.03670948f, 0.02638751f, 0.02752247f, 0.03101218f, -0.01455158f, 0.04554073f, 
    0.02329056f, 0.02241418f, -0.04718446f, -0.05652234f, -0.01710677f, -0.00754318f, -0.03243197f, 0.02710497f, 
    -0.02216553f, -0.01659973f, 0.05028806f, 0.00829613f, -0.03950852f, 0.01823929f, -0.00324203f, -0.01265068f, 
    -0.00087649f, 0.02434190f, -0.04451298f, -0.03225732f, -0.02022102f, 0.01562121f, -0.00435952f, -0.05734114f, 
    -0.01262330f, -0.05051554f, -0.04028914f, -0.06392332f, -0.04911960f, -0.01195810f, 0.04475178f, -0.00603610f, 
    -0.00709633f, -0.05244002f, -0.00382361f, -0.03618398f, 0.02951066f, -0.00204461f, -0.01879807f, 0.03357053f, 
    -0.05405703f, 0.02853278f, 0.01283838f, -0.04006481f, 0.04735257f, -0.04225364f, 0.00020074f, -0.02376624f, 
    -0.04995712f, 0.04578033f, 0.01756414f, -0.00179131f, -0.03242715f, 0.03568479f, -0.05788660f, -0.01656375f, 
    -0.00007741f, 0.02035587f, 0.00555357f, 0.04472905f, 0.00973628f, 0.04671447f, -0.03784304f, -0.00874252f, 
    -0.04532583f, 0.05618025f, 0.00035766f, 0.00256719f, -0.06263375f, 0.03312779f, 0.01492530f, 0.00539721f, 
    -0.01474140f, -0.01132398f, -0.02206972f, 0.03711962f, -0.02915139f, -0.01690591f, 0.04829442f, -0.00372366f, 
    0.01526673f, -0.00822157f, -0.03923171f, -0.04160297f, 0.04462693f, -0.00908642f, -0.00592736f, -0.00333757f, 
    0.02901232f, 0.02345218f, -0.03360191f, 0.02191964f, 0.01511676f, 0.05122321f, -0.03190373f, -0.03669027f, 
    0.01025721f, 0.02358228f, -0.00694816f, -0.05276909f, 0.02963550f, -0.00321187f, 0.04554835f, -0.03191280f, 
    0.03278393f, 0.04155831f, -0.04825688f, 0.00653342f, -0.03744303f, 0.05315381f, 0.02889610f, -0.03448251f, 
    -0.06138395f, -0.04283345f, 0.01085991f, 0.00119362f, -0.03453987f, 0.03035651f, 0.00630234f, -0.00578057f, 
    -0.00249051f, -0.00217228f, 0.00932073f, 0.05293417f, 0.04616477f, -0.00565416f, -0.05654053f, -0.01876669f, 
    0.00478686f, -0.02852550f, 0.02901584f, -0.00865688f, 0.00705143f, -0.01045894f, 0.02549135f, -0.03594426f, 
    -0.03406233f, 0.03216843f, 0.02895483f, 0.00485062f, 0.03868685f, -0.01207007f, -0.05222627f, 0.01851907f, 
    0.00707851f, -0.02743552f, -0.02783580f, -0.02946824f, -0.02179221f, 0.04877899f, -0.04144013f, 0.02460653f, 
    -0.01299303f, -0.03947484f, 0.03476004f, 0.02292478f, -0.05029282f, -0.00362586f, 0.02667764f, 0.00847397f, 
    0.04674191f, -0.02807772f, -0.03223123f, -0.00448324f, 0.00092284f, -0.03131333f, -0.02439819f, -0.03944162f, 
    0.10929155f, 0.37956586f, 0.00338858f, 0.15179242f, 0.10145263f, 0.04777041f, 0.00913724f, 0.21645722f, 
    0.11669387f, 0.25382531f, 0.04392862f, 0.08880226f, 0.08067469f, 0.11225262f, 0.02985546f, 0.03575768f, 
    -0.09496399f, -0.05151036f, -0.02388410f, 0.05459272f, 0.01773941f, 0.09246362f, 0.20161676f, -0.06482965f, 
    0.11287288f, 0.04955398f, -0.02154770f, -0.19805537f, -0.01696376f, -0.07157524f, -0.04294960f, -0.00652151f, 
    0.02799021f, -0.03052309f, -0.07327786f, 0.08799077f, -0.06612650f, -0.07824779f, 0.09577123f, 0.00193513f, 
    -0.01033819f, 0.10594936f, -0.33991563f, 0.15705669f, 0.13819107f, -0.00322523f, -0.01673280f, 0.08854951f, 
    -0.07195478f, -0.12084799f, 0.10528714f, -0.08345751f, 0.02996552f, -0.13037775f, -0.01578882f, 0.09067685f, 
    -0.05765825f, -0.10549070f, 0.05067018f, 0.14075756f, -0.10131517f, 0.25218022f, 0.10690921f, -0.02323185f, 
    -0.07274863f, -0.02011867f, 0.10895937f, -0.07118820f, -0.05236539f, 0.02044302f, 0.08961392f, 0.00261519f, 
    -0.03342896f, 0.04920021f, 0.02163423f, -0.09272660f, 0.02621979f, 0.02907786f, 0.06140111f, -0.25237152f, 
    -0.18085729f, -0.24120729f, 0.02907153f, 0.10596190f, 0.11505149f, 0.03061920f, -0.12634298f, -0.07108156f, 
    -0.17032190f, -0.19338880f, -0.02513842f, 0.11693066f, -0.09209064f, 0.16551374f, 0.06341615f, 0.00813333f, 
    -0.01062834f, -0.02841751f, -0.18169060f, -0.02494722f, -0.04054886f, 0.09878305f, 0.11578523f, 0.03506165f, 
    0.13036977f, -0.22549967f, -0.10185996f, 0.02574539f, 0.06813646f, 0.22933595f, 0.03040564f, 0.08522361f, 
    0.02533183f, -0.02486855f, 0.00362692f, 0.14263482f, 0.11422051f, -0.13144860f, 0.12899935f, 0.09311543f, 
    -0.40651917f, -0.36908525f, -0.37654573f, 0.02076103f, 0.05791201f, -0.01390999f, 0.15249270f, 0.07258725f, 
    -0.02602014f, -0.16147336f, -0.10902663f, 0.03606604f, 0.01159322f, 0.10979825f, -0.14779033f, 0.07567325f, 
    -0.09878102f, -0.03247259f, -0.03040514f, -0.13983750f, 0.10047352f, -0.03169195f, 0.14846869f, -0.24134040f, 
    -0.20393009f, -0.11184377f, -0.10597444f, 0.00929970f, -0.01274612f, -0.00077381f, 0.00854641f, -0.04798652f, 
    -0.02306458f, 0.01269680f, 0.06223271f, -0.27570647f, -0.09902299f, -0.06394889f, 0.00896598f, -0.00225233f, 
    0.24582627f, 0.26952580f, 0.18941054f, 0.24514775f, 0.08322337f, -0.01719530f, 0.11639717f, -0.03655166f, 
    -0.00591244f, 0.04818506f, 0.02480512f, 0.00979999f, 0.06173850f, 0.01913519f, -0.06622873f, 0.03990288f, 
    0.13640475f, 0.15192614f, 0.13361384f, 0.09765815f, 0.27617043f, 0.16041540f, 0.06048996f, 0.14327452f, 
    0.03544568f, -0.08607341f, 0.00601459f, -0.11122930f, 0.03037858f, -0.06891634f, 0.06162623f, -0.08363455f, 
    0.05271449f, 0.00787824f, 0.09355926f, 0.05093041f, 0.01866655f, 0.04980555f, 0.01644130f, 0.01114875f, 
    -0.11680603f, -0.28098011f, -0.29654515f, -0.09716410f, -0.28027967f, 0.01055772f, -0.10626242f, 0.24074425f, 
    -0.17932431f, -0.18205485f, -0.01869979f, -0.01957148f, 0.00265348f, 0.04908434f, 0.04904475f, -0.05367976f, 
    -0.00047050f, 0.10672253f, -0.09913448f, -0.11459188f, 0.17929158f, 0.19296122f, 0.20098186f, 0.26124588f, 
    0.03527837f, 0.14125903f, -0.06912056f, -0.04667683f, -0.03068524f, 0.07816401f, -0.04400147f, -0.01117969f, 
    0.03789140f, 0.02949231f, 0.17749543f, 0.13930491f, 0.07777331f, 0.04438090f, 0.02734432f, 0.21227182f, 
    -0.14886062f, 0.16144250f, -0.12798336f, 0.16022716f, 0.02566638f, -0.02937198f, 0.03884022f, 0.13957492f, 
    -0.10956287f, 0.23187542f, -0.01016903f, -0.02284924f, 0.03569743f, -0.05541950f, 0.11307828f, 0.01427388f, 
    0.13946286f, 0.02931390f, 0.05089454f, 0.23361090f, -0.15752026f, -0.04892708f, -0.05896280f, 0.19230795f, 
    -0.11956226f, -0.12391599f, 0.16891712f, 0.40519485f, -0.02335161f, 0.07713954f, -0.02548565f, -0.11854703f, 
    0.04566570f, 0.03550917f, -0.12577571f, -0.02253265f, 0.00138633f, -0.13192809f, -0.01697557f, -0.18991996f, 
    -0.16663189f, -0.08428387f, 0.16489056f, 0.04615228f, -0.13761699f, -0.04865002f, -0.11735015f, -0.02273948f, 
    -0.14838028f, -0.26698270f, 0.02031350f, 0.09837807f, 0.00597776f, 0.02338141f, -0.06346389f, -0.06015640f, 
    -0.10009496f, -0.04105042f, -0.01051770f, -0.01759787f, -0.21407424f, -0.22355846f, 0.09508348f, 0.01654319f, 
    -0.06395783f, -0.10738602f, 0.12662497f, 0.09167339f, -0.02074355f, 0.09064246f, 0.01734879f, -0.10337002f, 
    -0.00633291f, -0.13788006f, -0.02770189f, -0.11951502f, 0.16113266f, -0.13967367f, -0.06643906f, 0.07153181f, 
    0.02543631f, -0.03607944f, -0.02689910f, -0.02818099f, -0.02390571f, 0.00624680f, -0.05242393f, -0.01940476f, 
    -0.01346358f, 0.01917920f, 0.04319470f, -0.03139670f, 0.02255686f, 0.00012064f, -0.06002707f, 0.01284924f, 
    -0.00326438f, 0.04854390f, -0.00553511f, 0.04610009f, -0.00522715f, 0.00564469f, -0.01290100f, -0.01870618f, 
    0.04635758f, -0.04026781f, -0.03421394f, -0.01474488f, -0.03148660f, -0.06122953f, -0.05747830f, 0.02505713f, 
    0.04525607f, -0.03046838f, -0.02490135f, 0.04096237f, 0.01924215f, -0.00428069f, -0.00322163f, -0.04733075f, 
    -0.01969056f, 0.04155880f, 0.01355499f, 0.03605821f, 0.03568493f, 0.02056179f, -0.04881677f, 0.01962196f, 
    -0.05452289f, -0.04847054f, 0.02296588f, 0.01450035f, -0.00083264f, 0.03969670f, -0.00940512f, 0.00218437f, 
    0.03498673f, 0.03625058f, 0.01192347f, 0.04858479f, 0.03672722f, -0.03341996f, 0.04545131f, 0.05012608f, 
    -0.00927667f, 0.04208168f, -0.01438610f, 0.01243306f, -0.00205699f, -0.02793729f, 0.01144559f, 0.01760979f, 
    -0.04820979f, 0.00111851f, 0.02459643f, 0.03710051f, 0.00532045f, -0.00103823f, -0.04267086f, 0.01486744f, 
    0.01126608f, -0.04686805f, -0.04002305f, -0.01498686f, 0.02072271f, 0.00046138f, 0.00775448f, -0.05344817f, 
    0.01298214f, -0.01586298f, 0.01745940f, 0.01612858f, -0.00508536f, 0.00370182f, -0.00520712f, 0.00819824f, 
    -0.00454018f, -0.01398370f, -0.04289919f, -0.00090947f, -0.06042339f, 0.01529670f, 0.01919342f, -0.04472461f, 
    0.00004467f, -0.05170766f, -0.00926277f, 0.04341852f, -0.05129598f, -0.05226390f, 0.01139046f, 0.00584356f, 
    -0.03609998f, -0.05107022f, -0.00176904f, 0.00609256f, 0.00551226f, -0.01904507f, 0.01526479f, -0.05977066f, 
    -0.02560873f, -0.02675183f, -0.06028457f, 0.01831822f, 0.00096158f, 0.00917289f, -0.05623465f, 0.00063899f, 
    -0.05151983f, -0.04883797f, -0.01567988f, -0.05970985f, 0.04382157f, -0.03196718f, 0.03454750f, 0.01346275f, 
    -0.00220136f, -0.04876205f, 0.00012999f, -0.02287100f, -0.04624351f, 0.02975955f, -0.00921004f, -0.05193405f, 
    0.00754372f, 0.02140587f, 0.00326670f, 0.02916698f, 0.04857130f, 0.02419695f, 0.01474583f, -0.00095514f, 
    0.01720819f, -0.05750767f, 0.02109670f, -0.05737392f, 0.01844477f, -0.01141386f, 0.03122573f, 0.04630019f, 
    -0.04822311f, -0.03903316f, -0.01185272f, 0.03211515f, 0.01856636f, 0.04049153f, 0.02938875f, 0.00768578f, 
    -0.04312753f, 0.04588260f, -0.03102806f, 0.01105483f, -0.00024170f, -0.02788606f, -0.02869032f, 0.00698355f, 
    0.01397787f, -0.01810265f, 0.01733614f, 0.00196996f, -0.00326903f, -0.03837242f, 0.04139577f, -0.06103154f, 
    -0.05356870f, 0.02694432f, -0.04835353f, -0.05265896f, 0.02771891f, -0.05323408f, -0.01603360f, -0.00829220f, 
    -0.03301180f, -0.04795253f, 0.00883790f, -0.00711006f, 0.04818770f, -0.04901503f, -0.03815286f, 0.02483047f, 
    -0.02344275f, -0.04253840f, -0.04593720f, 0.03993288f, -0.02237327f, 0.02869397f, -0.03018490f, 0.05320674f, 
    -0.03216820f, 0.00592752f, -0.01215679f, -0.05844268f, 0.00723352f, 0.02391341f, -0.04489711f, 0.00595044f, 
    -0.00338009f, -0.03611155f, 0.04398270f, -0.05663190f, -0.05564717f, -0.05447875f, 0.04608367f, -0.05058810f, 
    -0.03000462f, -0.01874958f, -0.03252975f, -0.00728156f, 0.04169732f, -0.01331967f, -0.01289903f, -0.04389932f, 
    0.03482846f, 0.03629989f, -0.02598542f, 0.03771005f, -0.05929722f, 0.02944188f, -0.05751789f, -0.00219444f, 
    -0.00287984f, 0.00835716f, -0.01655058f, 0.01823458f, 0.00450996f, 0.02432529f, -0.04529550f, -0.00495172f, 
    -0.02088303f, -0.00958051f, 0.00911599f, -0.05953692f, -0.02605450f, -0.01976302f, 0.03718485f, -0.00170569f, 
    -0.04900254f, -0.01185982f, 0.03625977f, -0.00168269f, -0.01611671f, 0.02870384f, -0.02450747f, -0.03623974f, 
    -0.04114056f, 0.00677094f, -0.01213163f, 0.04392193f, -0.00975396f, 0.02530587f, 0.03428634f, 0.03910644f, 
    0.02944203f, -0.03225412f, 0.02666826f, -0.00006403f, -0.02426411f, -0.04924065f, 0.01363135f, -0.04492249f, 
    0.01188534f, -0.00614102f, 0.04743791f, 0.00742011f, -0.03867181f, -0.01815938f, 0.02318390f, -0.02698153f, 
    -0.04197063f, -0.04906308f, -0.00989105f, -0.03922716f, -0.01914979f, 0.02396074f, -0.04951709f, -0.00123644f, 
    -0.03974327f, -0.04972543f, 0.04594370f, 0.02448953f, -0.04059478f, -0.03959901f, -0.04117406f, 0.01060931f, 
    -0.04455709f, -0.02742215f, -0.03564821f, 0.03739367f, 0.00241037f, 0.02277564f, -0.06118765f, -0.05695236f, 
    -0.06070051f, -0.05852297f, -0.00769673f, -0.02551216f, -0.01568474f, 0.03823174f, 0.02938072f, 0.00076339f, 
    0.10342083f, 0.32689446f, 0.01935173f, 0.01108257f, 0.03383105f, 0.03124972f, -0.02373280f, -0.01584284f, 
    0.18920007f, 0.10120488f, 0.03565544f, -0.08788524f, -0.01035532f, 0.17351879f, 0.09367467f, 0.03632109f, 
    0.03166655f, 0.05598887f, -0.07378878f, 0.00314862f, -0.35501644f, -0.33655706f, -0.14601663f, 0.06462588f, 
    0.19068018f, 0.11088891f, 0.06638203f, -0.08498773f, -0.02284593f, 0.07131311f, 0.00630347f, 0.10024178f, 
    0.03681577f, 0.11067285f, 0.05946636f, 0.26150015f, -0.00269488f, -0.07981024f, -0.01122652f, -0.00930933f, 
    -0.11014383f, 0.15722965f, -0.58083427f, -0.05721314f, -0.04088087f, 0.30078441f, -0.12432896f, -0.03145278f, 
    0.03822532f, -0.07836054f, 0.06193462f, -0.05570164f, 0.00394219f, 0.03296812f, -0.03816603f, -0.03383642f, 
    0.12710257f, -0.01660608f, 0.12000035f, 0.05993700f, 0.10881477f, 0.08767086f, -0.03108151f, -0.08913134f, 
    -0.09985437f, -0.02540335f, 0.07623257f, 0.15498130f, -0.13729624f, -0.04189849f, -0.04639780f, -0.06432391f, 
    0.14488885f, -0.00637188f, 0.00744162f, -0.10883278f, -0.05371422f, 0.03554093f, 0.04510786f, -0.21600246f, 
    -0.47187483f, -0.32478645f, 0.02832729f, -0.07517779f, 0.11006090f, 0.10944762f, 0.00137110f, -0.10355682f, 
    -0.10328882f, -0.06847562f, 0.09674188f, 0.06051975f, 0.07536527f, 0.03698901f, 0.06058319f, 0.09725481f, 
    0.10961550f, -0.06650203f, -0.03774494f, -0.02394938f, 0.06549890f, -0.03854441f, -0.05889321f, -0.02352451f, 
    -0.06480186f, -0.06894502f, 0.07281976f, 0.08225033f, -0.10226308f, 0.16065998f, 0.09114707f, -0.01991290f, 
    0.02701990f, 0.14989449f, 0.04006642f, 0.04314024f, 0.08916780f, 0.10806433f, -0.13570780f, 0.08269040f, 
    -0.25388479f, -0.11359195f, -0.14757770f, -0.13509125f, 0.04657796f, 0.09000479f, 0.09579990f, -0.04649671f, 
    -0.12412638f, -0.01905243f, 0.03869079f, -0.04177104f, -0.03904504f, 0.08413028f, -0.10448094f, 0.02965570f, 
    0.08381989f, 0.02150980f, 0.00374643f, 0.03287352f, 0.24428847f, -0.10440573f, -0.26168397f, -0.14809841f, 
    -0.14356416f, -0.03066635f, 0.00500855f, -0.00264485f, -0.02590186f, -0.09711275f, 0.13549303f, 0.08827760f, 
    0.04301926f, 0.13363004f, 0.01681279f, -0.07531030f, 0.00930808f, -0.21340242f, -0.04616630f, -0.03827287f, 
    0.30263805f, 0.20530982f, -0.06319535f, -0.18857300f, -0.09992182f, -0.16418689f, 0.09280845f, -0.02595586f, 
    0.11347282f, 0.02868171f, 0.14569630f, 0.00293711f, 0.06971477f, -0.07027330f, -0.02113426f, 0.21883509f, 
    0.20285939f, 0.11987230f, -0.09971447f, 0.04511732f, 0.30519536f, -0.01647794f, 0.04718376f, 0.10055580f, 
    -0.08322809f, 0.02849593f, 0.02136273f, 0.08132558f, 0.05074486f, -0.11351635f, 0.12824155f, -0.11952072f, 
    0.12176925f, -0.01201993f, 0.04774517f, 0.11017250f, 0.02180905f, 0.12242670f, 0.02315141f, -0.08996348f, 
    -0.20364597f, -0.14592382f, -0.04003490f, -0.22027446f, -0.08951614f, 0.00240200f, -0.01500789f, -0.14186971f, 
    -0.05249037f, -0.04951728f, -0.09298316f, 0.13220094f, 0.12477651f, -0.03333647f, 0.03237380f, 0.12957960f, 
    0.05947594f, -0.09534857f, 0.06011703f, 0.05978622f, 0.06118523f, 0.23683989f, 0.01849978f, 0.00983418f, 
    0.02283533f, 0.07412719f, -0.06009975f, 0.11948267f, -0.00250272f, 0.11192036f, 0.07363918f, -0.00973073f, 
    -0.02951272f, 0.15180917f, 0.18301794f, 0.05490050f, 0.07316796f, 0.06691662f, -0.08123930f, 0.09303877f, 
    -0.27843544f, 0.12070621f, -0.10748599f, 0.06821302f, -0.24779679f, 0.02348154f, -0.07078659f, -0.24769533f, 
    -0.07037964f, 0.04121728f, -0.07643401f, -0.00988297f, 0.00122210f, 0.06875448f, 0.12026861f, -0.15088819f, 
    0.06234932f, -0.00722973f, -0.01418264f, 0.18709050f, -0.00701641f, 0.07183898f, -0.18628573f, 0.13543038f, 
    -0.10523453f, -0.06699150f, -0.10823771f, -0.10063288f, -0.03136197f, -0.07858647f, -0.03863044f, -0.09486658f, 
    -0.03210334f, 0.16912682f, 0.00258781f, 0.09252578f, 0.09286026f, -0.03245500f, 0.15447383f, -0.06331017f, 
    -0.08746549f, 0.01400180f, 0.05123885f, -0.16805266f, 0.07714739f, -0.08790901f, -0.04408390f, 0.04857325f, 
    -0.06477584f, 0.05982371f, 0.11482006f, 0.09711808f, 0.08784240f, 0.04316789f, -0.01548030f, -0.07980002f, 
    -0.06065280f, -0.02550699f, -0.07337103f, 0.04478788f, -0.12630042f, -0.11090333f, -0.07621164f, -0.16376469f, 
    -0.17617959f, 0.00404566f, 0.05437695f, -0.10661297f, -0.10304789f, -0.00016582f, -0.02013719f, -0.07184563f, 
    -0.04832330f, 0.03547306f, 0.03151863f, 0.06508204f, 0.12874918f, -0.08351444f, 0.09253243f, 0.02523881f, 
    -0.17822354f, 0.23470744f, -0.04328688f, 0.15204844f, 0.02356940f, -0.09348582f, -0.11031538f, 0.20048307f, 
    0.03524939f, 0.13466269f, 0.02940016f, -0.04272068f, 0.02052354f, 0.10119615f, -0.07912859f, 0.08832283f, 
    -0.01206966f, -0.07449510f, 0.04370071f, -0.16588023f, -0.08418560f, -0.04349066f, 0.08155409f, 0.15213177f, 
    0.06590807f, 0.05941472f, 0.00818316f, -0.09693169f, -0.08106019f, -0.03371106f, -0.03558071f, -0.07127240f, 
    -0.14450330f, 0.04437427f, 0.03550402f, 0.15526475f, 0.00977084f, -0.07727841f, -0.07814683f, -0.12528372f, 
    0.10028800f, -0.08132997f, -0.52257937f, 0.16759506f, 0.04675021f, 0.20666394f, -0.01319900f, 0.12363711f, 
    -0.01517229f, -0.11057467f, 0.08691487f, 0.07741702f, 0.01421666f, 0.01461981f, 0.06839544f, 0.07556750f, 
    -0.03835817f, -0.01470938f, 0.03940880f, -0.02665954f, -0.24602216f, 0.09436889f, 0.19636294f, -0.02774754f, 
    -0.07206073f, -0.02155956f, -0.06333311f, -0.09872502f, -0.06031253f, -0.05343993f, 0.05952088f, -0.00167878f, 
    0.06705741f, 0.00539906f, -0.05206703f, 0.00352783f, -0.13131325f, 0.06850267f, -0.05814054f, -0.06774116f, 
    -0.27301416f, -0.05511440f, 0.01143904f, 0.23481953f, 0.11430924f, 0.04188306f, -0.08651808f, -0.07460400f, 
    -0.01142696f, 0.02071887f, -0.04541558f, -0.03681003f, 0.00351798f, 0.01651704f, 0.12508053f, 0.12233632f, 
    -0.01177590f, 0.03997243f, -0.05240161f, -0.10372222f, -0.05344152f, 0.01743092f, 0.21613054f, -0.07798601f, 
    0.02802502f, -0.07164201f, -0.15218836f, -0.03496417f, -0.00972490f, 0.09522706f, -0.02385831f, -0.00744486f, 
    0.05011408f, 0.07236078f, -0.07973313f, 0.05851553f, -0.00099615f, -0.23497202f, -0.08437458f, -0.08438747f, 
    -0.01041900f, 0.02877851f, 0.01071513f, 0.02197589f, 0.17490959f, 0.03534634f, 0.11042232f, 0.07127427f, 
    -0.00863775f, -0.03477995f, 0.00785524f, 0.07103745f, 0.01164515f, -0.02614056f, -0.03363283f, 0.01580291f, 
    -0.08310948f, -0.02190769f, 0.00095604f, 0.00091727f, 0.27634141f, -0.05999821f, 0.09518648f, -0.06222616f, 
    -0.01280741f, -0.01362144f, 0.09544796f, -0.00704685f, 0.01935052f, 0.08791223f, 0.04733311f, -0.11975304f, 
    0.02013127f, 0.13715360f, -0.01993988f, -0.03632262f, 0.05340799f, -0.06500258f, 0.03277581f, 0.02349206f, 
    0.08518115f, -0.07750050f, 0.01390433f, 0.16714418f, -0.22760856f, -0.07523200f, 0.02969323f, -0.14704604f, 
    0.03953401f, 0.02591926f, 0.21145430f, -0.08050783f, 0.08686531f, -0.10534450f, -0.05932080f, 0.16032003f, 
    -0.00706937f, -0.06335703f, -0.04450317f, 0.03013528f, 0.24658071f, -0.05702421f, -0.06433713f, 0.23797737f, 
    -0.13021624f, 0.01260446f, -0.01643649f, -0.20735575f, -0.23106131f, -0.12567131f, -0.00621325f, -0.04452731f, 
    0.02759928f, 0.11813353f, 0.06779762f, 0.12169892f, -0.04351126f, -0.04058011f, -0.04672094f, -0.03786498f, 
    0.16851647f, 0.02577580f, 0.05222413f, 0.04853435f, 0.00569374f, 0.07469720f, -0.03415692f, 0.06924391f, 
    -0.06496682f, -0.03444928f, 0.03020624f, 0.01014227f, -0.16864306f, 0.05016583f, -0.13277797f, 0.08805285f, 
    -0.04334844f, 0.00771132f, -0.08354902f, -0.02453009f, -0.05945464f, 0.11641783f, 0.13023539f, 0.23448934f, 
    -0.16728678f, -0.09096441f, -0.03660886f, -0.11788341f, -0.00822825f, 0.10097162f, -0.02904161f, 0.00316537f, 
    -0.01789095f, -0.03718815f, 0.03397678f, -0.10188613f, -0.05009813f, -0.09507424f, -0.05876651f, 0.02174412f, 
    -0.02532310f, 0.20731989f, -0.26941165f, 0.16775766f, -0.00595723f, -0.01753421f, -0.05769314f, 0.08847505f, 
    -0.08051176f, 0.11435485f, 0.00223249f, 0.01280829f, 0.03867624f, 0.08253823f, -0.07076848f, -0.14711313f, 
    -0.05824530f, 0.04050186f, -0.10956094f, 0.10647544f, 0.01194762f, 0.14576866f, -0.09698005f, 0.07899453f, 
    0.13945541f, 0.06229631f, 0.10892897f, 0.03931050f, 0.05117247f, 0.11508056f, -0.05001986f, -0.04746867f, 
    0.02053258f, 0.16565253f, -0.04018264f, 0.05776208f, 0.12849589f, -0.01548760f, -0.10948979f, -0.01859228f, 
    -0.03918845f, 0.05258513f, 0.21901044f, -0.04798142f, -0.08666053f, -0.06112808f, -0.11681748f, -0.04370143f, 
    -0.02863930f, -0.06091085f, -0.00391769f, 0.03180594f, 0.17778951f, -0.06972068f, -0.12451600f, 0.04044519f, 
    -0.01138814f, -0.09137085f, -0.05020577f, 0.07049814f, 0.18827519f, 0.12302962f, -0.00713081f, 0.01355089f, 
    0.06803520f, -0.06555717f, 0.11704258f, 0.11297032f, -0.01081804f, 0.03827985f, 0.01900044f, 0.01342884f, 
    -0.02138145f, 0.03516445f, 0.07828156f, -0.03676407f, 0.06363706f, 0.04086844f, 0.00023164f, -0.03153021f, 
    -0.02284059f, 0.03067036f, -0.04972925f, 0.00839402f, -0.02566362f, 0.00592924f, -0.00349910f, -0.03481351f, 
    0.01731895f, -0.05777988f, -0.03748722f, -0.04201344f, -0.03762057f, 0.02879581f, -0.00806291f, -0.04330749f, 
    0.02069711f, 0.03388433f, -0.00868000f, 0.02578261f, -0.06602287f, 0.00293558f, -0.02252408f, -0.00356987f, 
    -0.05334453f, 0.02396431f, -0.05139324f, -0.02525344f, -0.03912949f, -0.02202586f, -0.04453945f, -0.04968841f, 
    0.03053055f, 0.03215963f, 0.02333042f, -0.03460414f, 0.01205942f, -0.04585362f, 0.00809421f, 0.05359868f, 
    0.01133879f, -0.03572580f, 0.03031811f, -0.05088121f, 0.04420905f, -0.00678960f, 0.03025496f, 0.04766924f, 
    -0.06107321f, 0.03417398f, -0.02687309f, 0.05003747f, -0.02791185f, -0.03172719f, 0.00865029f, 0.05921033f, 
    -0.03819751f, -0.00117131f, -0.00923981f, 0.02538139f, 0.04457024f, 0.02534772f, 0.04046729f, 0.00830829f, 
    -0.06252956f, 0.01221547f, 0.02690685f, -0.02960040f, -0.00812460f, 0.01925321f, 0.00812926f, -0.05406271f, 
    -0.00751977f, -0.05543432f, 0.03226533f, -0.02811721f, -0.05669193f, -0.02360762f, -0.06214490f, 0.03175146f, 
    -0.02080674f, 0.01712367f, -0.03943473f, -0.04152904f, -0.03907597f, -0.00629658f, -0.01305271f, 0.03469776f, 
    -0.05731487f, 0.04341132f, 0.03141428f, -0.01942552f, 0.02069882f, 0.00862548f, 0.04841735f, -0.02742712f, 
    0.02640162f, -0.02758234f, -0.00738427f, -0.03501790f, -0.02772574f, -0.01909251f, 0.03503799f, -0.04304765f, 
    -0.03825061f, -0.04987652f, -0.04043438f, 0.00924972f, 0.00930901f, -0.04753550f, 0.02084053f, -0.03207267f, 
    -0.00392960f, -0.01443804f, -0.01890327f, 0.04943931f, 0.03315742f, 0.02639871f, -0.03642107f, 0.04455860f, 
    -0.06553701f, 0.03282064f, -0.05496796f, -0.04524814f, -0.02881015f, 0.01215028f, 0.01158156f, -0.02082891f, 
    0.03642943f, 0.02518949f, 0.03621079f, 0.04617333f, -0.05654148f, -0.04715690f, 0.00285812f, -0.05350183f, 
    0.03796505f, -0.04002029f, -0.02222050f, 0.01369361f, -0.03986910f, 0.00355072f, -0.05802329f, -0.02495929f, 
    -0.00781850f, 0.02882346f, -0.02317885f, 0.00854801f, 0.04763938f, -0.01212619f, -0.04201406f, -0.04000414f, 
    -0.06085818f, -0.01235204f, -0.05952264f, 0.01149646f, 0.00188965f, -0.01185342f, -0.04840646f, 0.00175344f, 
    -0.04010737f, -0.04410884f, 0.01479820f, -0.03910759f, 0.03995987f, -0.06951118f, -0.06442694f, 0.03712373f, 
    0.04985660f, -0.02865119f, -0.02277354f, -0.02237121f, -0.04616046f, -0.02397392f, 0.03563071f, -0.04250205f, 
    -0.00328018f, -0.05977557f, -0.01510601f, 0.01597785f, -0.04733335f, 0.02032140f, -0.03074314f, -0.03739720f, 
    -0.02894294f, -0.05572524f, -0.00956219f, 0.04238053f, -0.03244313f, -0.02892947f, -0.05491135f, -0.01520143f, 
    0.03735612f, 0.05021958f, -0.01568311f, 0.01538886f, -0.03036256f, -0.05756424f, -0.02463244f, -0.02865860f, 
    0.00102415f, 0.01245421f, -0.02857161f, -0.00942336f, -0.01605883f, 0.00738652f, -0.05187811f, -0.03927131f, 
    0.03100994f, -0.02893347f, 0.02696919f, -0.00823352f, 0.01905499f, 0.03498340f, 0.02318674f, -0.04040227f, 
    -0.00424477f, 0.01011262f, -0.03016313f, 0.02590321f, 0.00235947f, -0.03629654f, 0.03913834f, -0.04862992f, 
    -0.04372848f, 0.02984916f, 0.04409709f, -0.04199942f, 0.01991309f, -0.02467707f, -0.03200003f, 0.04920607f, 
    0.03100044f, -0.03281133f, -0.03494748f, -0.00116476f, -0.03437573f, -0.03757252f, 0.04502856f, -0.01425135f, 
    0.04064614f, -0.04856851f, -0.02275792f, -0.03680908f, -0.03786219f, 0.00159603f, 0.04667269f, -0.03909152f, 
    -0.00402802f, -0.02532510f, -0.02699921f, 0.04289709f, -0.05899310f, 0.04527764f, -0.02321067f, -0.00184810f, 
    -0.00031818f, 0.03473000f, -0.03709143f, -0.03326591f, -0.02974330f, -0.02664908f, 0.04093289f, 0.00124696f, 
    -0.00455586f, 0.00361025f, 0.04141813f, 0.02756332f, 0.03169029f, -0.06115270f, 0.00727115f, -0.04911413f, 
    -0.02888456f, -0.06143524f, -0.02220032f, 0.01162388f, 0.02344999f, -0.03520446f, -0.03212499f, 0.01172176f, 
    -0.05996337f, -0.00880358f, -0.04963522f, -0.02048226f, 0.04765487f, 0.00750605f, 0.01246850f, -0.01408054f, 
    0.04192781f, 0.02759622f, -0.00889712f, 0.03126488f, -0.04264436f, 0.01066213f, -0.02737554f, -0.01268973f, 
    0.04757270f, -0.05340263f, 0.04002925f, -0.01138816f, -0.05118243f, 0.03402019f, -0.00391271f, -0.04758167f, 
    -0.01508292f, -0.00914846f, -0.02399415f, -0.04242473f, -0.03952831f, 0.04162135f, 0.00187362f, -0.01899886f, 
    -0.03520051f, 0.03575682f, -0.01553879f, 0.02874090f, -0.04626625f, 0.02769193f, -0.00376645f, 0.02333074f, 
    0.41410667f, -0.08357971f, -0.04781149f, 0.01177026f, -0.04099531f, 0.14032257f, 0.06596571f, 0.21757951f, 
    0.11814690f, 0.12626754f, 0.06191267f, -0.05432949f, 0.01120127f, -0.12541226f, -0.07833019f, 0.02846200f, 
    -0.09983365f, 0.09216049f, 0.03463882f, -0.00063675f, 0.07134625f, 0.63522369f, -0.05465424f, 0.10570461f, 
    0.08704569f, 0.11547106f, 0.01992388f, -0.22250332f, 0.03104912f, -0.14870606f, 0.03820743f, -0.01592703f, 
    0.01607107f, 0.03895390f, 0.04014172f, 0.07026764f, -0.05709838f, -0.19921643f, 0.10157055f, 0.22130336f, 
    -0.28412709f, 0.28236070f, 0.30233145f, -0.09289889f, 0.03810487f, -0.20553868f, 0.03385315f, 0.06283112f, 
    -0.14107360f, 0.11298410f, -0.01496439f, -0.10253233f, 0.04704835f, 0.02520106f, -0.00551505f, -0.02439811f, 
    -0.06862886f, 0.07339971f, 0.04523942f, 0.09664972f, -0.11919338f, 0.18495385f, -0.12724623f, -0.00692737f, 
    -0.05543643f, 0.15494385f, -0.07473295f, 0.04085070f, 0.00046312f, 0.04375956f, 0.06116870f, 0.16984606f, 
    -0.20103234f, 0.05614143f, -0.00381401f, -0.19884388f, 0.02463872f, 0.07742466f, 0.08754116f, 0.06803384f, 
    0.13345894f, 0.43125761f, -0.05363108f, 0.07454468f, -0.05525846f, -0.12253673f, 0.05438856f, -0.03531746f, 
    -0.09378353f, -0.14897464f, 0.04594882f, 0.06819257f, 0.15888004f, -0.02051079f, -0.16575423f, -0.08206812f, 
    -0.03151158f, -0.14596555f, 0.20477188f, -0.04358453f, 0.05536847f, 0.00453205f, 0.14616002f, -0.04299997f, 
    0.04371422f, 0.01432679f, -0.08825409f, 0.16946761f, 0.14032997f, 0.16910861f, -0.19524215f, -0.01610182f, 
    -0.00211392f, -0.14639068f, -0.03356379f, 0.06846655f, -0.00199109f, 0.12296160f, 0.08328220f, 0.09169758f, 
    -0.25932416f, -0.01773436f, -0.16771334f, -0.01235829f, 0.00120110f, -0.11790523f, 0.03181586f, -0.11045875f, 
    -0.21114245f, -0.06871801f, 0.00447789f, 0.05456650f, -0.03141239f, 0.04578415f, -0.06357720f, 0.03555917f, 
    0.10226548f, -0.03159773f, -0.13762349f, -0.23036885f, -0.35147047f, 0.08394241f, 0.31276375f, -0.24699086f, 
    0.03824105f, 0.02320154f, -0.17775427f, 0.16724588f, -0.05030860f, 0.01941524f, 0.05634204f, 0.15093383f, 
    -0.10204918f, -0.01475053f, -0.08255578f, -0.03840905f, 0.13144125f, 0.00280554f, -0.05106718f, 0.02696519f, 
    0.27264905f, 0.42339975f, -0.04032614f, -0.25880972f, -0.03084331f, 0.14880382f, 0.07203980f, -0.11369758f, 
    0.15663448f, -0.06817681f, -0.08484744f, 0.00179983f, 0.13500622f, 0.17690191f, 0.15701769f, 0.00893425f, 
    0.03318960f, 0.05785256f, -0.04642130f, -0.10069893f, -0.04727155f, 0.37829521f, 0.03771514f, -0.01027736f, 
    -0.03742750f, 0.07405429f, 0.10060093f, -0.10299981f, 0.06208825f, -0.19295467f, 0.05832413f, -0.01780271f, 
    0.12527478f, 0.13794596f, 0.06275576f, -0.03752721f, 0.08978656f, -0.21431275f, 0.13316005f, 0.20634457f, 
    -0.16469710f, 0.07478582f, -0.03600210f, 0.01180124f, -0.16722174f, 0.08888969f, -0.28107494f, 0.06950941f, 
    -0.12278353f, 0.03878834f, 0.08151998f, 0.06006487f, 0.14534242f, 0.08849405f, 0.05629416f, 0.03738156f, 
    -0.06523254f, 0.00976736f, -0.04179504f, 0.03440655f, 0.37228587f, -0.07532761f, 0.01153874f, -0.04261281f, 
    -0.05438579f, 0.40710044f, 0.04058788f, -0.09930402f, 0.13879278f, -0.00397039f, 0.02789048f, -0.13506633f, 
    0.07986785f, 0.10049696f, 0.16788034f, -0.16351852f, -0.01462197f, 0.07256504f, -0.00661285f, 0.09630539f, 
    0.06892647f, -0.22147495f, 0.21247554f, -0.03379889f, 0.34950823f, -0.02445167f, 0.03468085f, 0.12882856f, 
    -0.07440422f, 0.19381987f, -0.03211201f, -0.11841010f, 0.08606347f, -0.00485758f, 0.12998395f, 0.10961088f, 
    -0.03219326f, 0.17037427f, 0.05500434f, 0.04585065f, -0.33593410f, -0.08163141f, -0.08366455f, 0.02081074f, 
    -0.08120252f, -0.18856767f, 0.11784725f, 0.01815348f, 0.13464287f, 0.13837664f, 0.02689362f, -0.10315591f, 
    -0.07638755f, -0.12852457f, -0.21121331f, 0.08315455f, 0.10337360f, -0.13341063f, -0.19905008f, 0.01403302f, 
    0.14482760f, 0.11202692f, -0.27094492f, 0.01896625f, -0.20578480f, 0.03370328f, -0.22428434f, 0.08304539f, 
    -0.00069280f, -0.17541455f, 0.01076179f, 0.09897762f, -0.07061678f, -0.01411645f, -0.09624672f, 0.09765804f, 
    -0.03670719f, -0.08444852f, 0.09007758f, 0.00518995f, -0.29272988f, -0.06490915f, -0.02189538f, 0.01930666f, 
    0.16646983f, -0.06763235f, 0.05061805f, -0.06719343f, 0.01829672f, 0.15033573f, -0.05360584f, -0.02453636f, 
    -0.07047331f, -0.04659008f, -0.11453199f, 0.03017413f, 0.01900981f, -0.13689108f, -0.10082890f, -0.04856736f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.05648714f, 0.13297045f, 0.07084787f, 0.04926081f, 0.10674328f, -0.15618372f, 0.02178954f, -0.03257228f, 
    0.02430355f, 0.04790540f, 0.14782757f, 0.03568741f, 0.16805166f, -0.02002011f, 0.13886985f, -0.05009810f, 
    0.00089377f, -0.02132419f, -0.06490593f, 0.29195103f, -0.01666059f, 0.18957497f, 0.11395513f, 0.03995554f, 
    0.18964291f, 0.19606535f, 0.06944047f, -0.01168791f, 0.03540402f, 0.18532436f, 0.00145077f, 0.16244753f, 
    -0.05286829f, 0.04556890f, 0.08420715f, 0.22914971f, 0.00656238f, -0.15783598f, -0.01352733f, 0.09832407f, 
    0.07587532f, 0.14456342f, 0.08265650f, -0.00520880f, -0.04449148f, 0.01137528f, -0.07262271f, 0.07572271f, 
    0.01958002f, -0.07298328f, 0.10493352f, 0.11353615f, 0.03861879f, 0.05125296f, -0.01510785f, -0.05456711f, 
    0.08635646f, 0.01445239f, -0.04168659f, -0.00726719f, 0.00564981f, 0.07926614f, -0.03619963f, -0.00723862f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.11612562f, -0.29302838f, -0.24810885f, -0.09380171f, -0.19483386f, -0.12235479f, -0.07911969f, 0.19774069f, 
    -0.06304269f, 0.06598548f, 0.19896764f, 0.14148304f, 0.16270360f, -0.00740978f, 0.21758407f, -0.01108650f, 
    -0.04110521f, -0.17645267f, 0.30947521f, -0.20013960f, 0.02351958f, -0.23853669f, 0.08370798f, 0.11008698f, 
    -0.13009983f, -0.04809256f, 0.20190290f, 0.04282998f, -0.09391827f, -0.15754969f, -0.03582319f, -0.08328497f, 
    -0.11063886f, 0.02251741f, -0.00974204f, 0.13670029f, 0.04228061f, -0.08150674f, 0.22163905f, 0.10061328f, 
    0.10576624f, 0.15507856f, 0.05864288f, -0.07724664f, -0.09282482f, 0.01781621f, -0.08327325f, 0.18008649f, 
    0.02233057f, 0.00097207f, -0.15744753f, 0.19394225f, 0.03802330f, 0.20029473f, 0.04962233f, 0.00444938f, 
    0.23099676f, 0.10730132f, -0.12616365f, 0.08217138f, -0.22257394f, -0.17950426f, -0.04964910f, 0.25292161f, 
    -0.07488645f, 0.02974251f, -0.53466779f, 0.16219026f, -0.35484940f, 0.12319255f, 0.04905158f, -0.10227273f, 
    -0.00690191f, 0.04029671f, 0.19022243f, -0.15783601f, -0.20113067f, -0.06287754f, 0.00738545f, 0.12388406f, 
    0.01877738f, 0.12170152f, 0.16441317f, -0.23156857f, -0.00887973f, 0.05781338f, -0.10064115f, -0.12251403f, 
    -0.09117397f, 0.01060994f, -0.22229154f, 0.11082725f, -0.44126916f, -0.12614773f, 0.35989881f, -0.03977051f, 
    0.02572178f, -0.45850843f, -0.05716698f, 0.22867936f, 0.09312869f, -0.16273022f, -0.04238864f, 0.11529585f, 
    0.02455480f, 0.15371639f, 0.36279792f, 0.03483421f, 0.06107000f, 0.03634255f, 0.02209672f, -0.15836118f, 
    0.02758753f, 0.02701369f, 0.04380848f, -0.27719304f, 0.04136042f, 0.18225709f, 0.37952724f, -0.05815461f, 
    -0.00359762f, -0.01757054f, 0.24330834f, 0.06324469f, 0.04413645f, 0.12394911f, -0.04573447f, 0.17679161f, 
    -0.02157517f, -0.08923545f, -0.31699628f, 0.15081176f, 0.14170988f, 0.07545238f, -0.21339087f, 0.19954118f, 
    -0.02503493f, 0.02167529f, 0.25750440f, 0.17099454f, 0.02415699f, -0.06868780f, 0.14150226f, 0.12834454f, 
    0.11918123f, -0.06374277f, 0.33488065f, -0.11363196f, -0.10197620f, -0.20854649f, -0.06257777f, -0.01244920f, 
    0.00127885f, -0.13266920f, 0.04672047f, 0.29734653f, -0.04720348f, -0.30015129f, -0.24180041f, 0.00225278f, 
    -0.04661336f, -0.26592782f, 0.03290694f, -0.27003312f, 0.29857382f, -0.04262522f, 0.02502387f, -0.13858998f, 
    0.36451480f, 0.26152152f, -0.21871458f, 0.04107312f, -0.00213611f, 0.07039922f, 0.01704817f, 0.12240998f, 
    0.08016357f, 0.43681005f, 0.13908014f, -0.11136864f, 0.08930645f, -0.17687175f, 0.37235722f, -0.21575856f, 
    0.05469195f, -0.05183772f, 0.11835037f, -0.02592222f, -0.02774905f, -0.10402890f, 0.05203597f, 0.01022651f, 
    -0.09744763f, 0.08908177f, 0.06654254f, 0.02326100f, -0.13772653f, -0.11445843f, -0.03880106f, 0.01173037f, 
    -0.05342304f, 0.07105909f, 0.02570623f, 0.09232134f, 0.61752105f, -0.00131305f, -0.09115878f, -0.26043552f, 
    0.07290573f, -0.01595023f, -0.29363716f, 0.44250512f, 0.00937349f, 0.14135370f, -0.00841940f, -0.08677965f, 
    0.03067252f, 0.36879903f, -0.08243854f, -0.00053696f, 0.00969817f, 0.07901850f, -0.02725178f, 0.48441428f, 
    0.11343678f, 0.01003135f, -0.03047890f, 0.06838039f, -0.13197391f, -0.18926829f, -0.00674533f, -0.16425836f, 
    0.13747174f, 0.27778926f, 0.33718809f, -0.03580517f, -0.04664267f, -0.06017985f, -0.11582083f, -0.03308595f, 
    -0.01801461f, -0.16875255f, 0.09773721f, -0.08577172f, 0.07760118f, -0.00635024f, 0.13454358f, -0.17889781f, 
    0.09345125f, -0.05336402f, 0.03261429f, -0.01998229f, 0.08191362f, 0.00608286f, -0.06565218f, 0.03877504f, 
    -0.05153392f, 0.03548514f, 0.06364013f, 0.11968657f, 0.05169456f, -0.06917892f, 0.03492298f, -0.20684652f, 
    0.09057391f, -0.09304915f, 0.02612262f, -0.08269545f, -0.00892320f, 0.06430925f, 0.13506627f, -0.14373702f, 
    -0.00251539f, -0.61281586f, 0.16366167f, 0.41551775f, 0.11115976f, 0.25543439f, -0.07767884f, -0.07784913f, 
    0.23418966f, -0.16426888f, 0.02489795f, -0.01877113f, -0.07200596f, -0.02572479f, -0.14304888f, -0.24146073f, 
    -0.10572946f, -0.08467383f, -0.05685115f, -0.00545784f, 0.15500696f, -0.16395816f, 0.25666550f, 0.28033641f, 
    0.06300528f, -0.04716734f, 0.06749710f, 0.10268028f, 0.16148098f, -0.14406376f, -0.27429682f, -0.06385191f, 
    0.06666125f, -0.12020504f, -0.13204336f, 0.16854969f, 0.12333949f, 0.22523515f, -0.11954413f, 0.03392333f, 
    0.25804937f, 0.01740572f, -0.40408111f, -0.04603434f, -0.01832278f, -0.11045115f, 0.08831573f, -0.00129637f, 
    0.05824593f, -0.22670394f, -0.19450687f, -0.33559921f, -0.15273958f, 0.12362114f, 0.06713052f, -0.05187691f, 
    0.01742270f, 0.03797204f, 0.15704960f, 0.09332980f, -0.02279094f, -0.09557610f, -0.24760328f, -0.09886403f, 
    -0.11629871f, -0.09579071f, 0.16626707f, 0.01121187f, -0.08469901f, -0.16785401f, 0.12517335f, 0.03746699f, 
    -0.00032383f, -0.05965434f, 0.24005206f, 0.12607384f, 0.20818001f, -0.05408628f, -0.07230125f, 0.06341135f, 
    -0.11549719f, 0.21342345f, 0.21108752f, 0.02067689f, 0.12421396f, -0.40689865f, 0.33562988f, -0.11516226f, 
    -0.21961808f, 0.05862216f, 0.29787523f, 0.08720332f, -0.26489919f, 0.26416445f, 0.01699983f, 0.24487655f, 
    -0.05142881f, -0.20176469f, -0.13495749f, 0.36708295f, -0.11841224f, -0.07234358f, -0.08030663f, 0.30705017f, 
    0.30269367f, -0.11521539f, -0.14165592f, 0.10476501f, -0.11429672f, -0.33519286f, 0.09369886f, 0.20560934f, 
    -0.10161944f, 0.12549959f, 0.07937166f, 0.00271151f, 0.13563058f, 0.07009570f, -0.12346835f, 0.01679977f, 
    0.05938470f, -0.02213256f, 0.17746559f, 0.20195319f, 0.34811193f, -0.03905369f, 0.06863087f, 0.00647639f, 
    -0.06377143f, 0.04360844f, 0.02964773f, 0.03736650f, 0.06832480f, 0.22748508f, -0.00838004f, -0.08610109f, 
    0.35594386f, 0.20688123f, 0.05408707f, 0.04308818f, 0.03208982f, 0.07820051f, -0.16716625f, -0.34190804f, 
    -0.05280402f, 0.18204571f, -0.10116923f, 0.20000286f, -0.05026085f, -0.09988448f, 0.10905683f, 0.17805254f, 
    0.35086015f, 0.02080621f, -0.19718102f, 0.10344892f, 0.14465824f, -0.15500803f, -0.05136017f, 0.00997406f, 
    0.09162999f, -0.09209602f, 0.22535267f, 0.03598407f, 0.04296614f, 0.24266075f, -0.05503163f, 0.03066034f, 
    0.07668822f, -0.06893101f, -0.22371164f, -0.01880305f, -0.06665377f, 0.02195308f, 0.03976984f, -0.29049641f, 
    -0.06107211f, -0.00355256f, 0.05474370f, -0.10776280f, -0.03513636f, -0.14428191f, -0.04887763f, -0.09777158f, 
    0.00067894f, -0.08118011f, -0.10896167f, -0.09014749f, -0.04070592f, 0.00618893f, -0.15141982f, -0.05648776f, 
    -0.08928676f, -0.04690048f, 0.00507834f, 0.12182963f, 0.05128989f, -0.14015910f, 0.02840553f, -0.01638009f, 
    -0.06943730f, 0.04366373f, 0.03480722f, -0.01989077f, -0.10298961f, 0.00003940f, -0.07745776f, -0.07902858f, 
    0.10599081f, 0.02127722f, -0.05552514f, -0.15835154f, -0.10544137f, 0.03275517f, -0.05084242f, -0.03550442f, 
    0.05508841f, -0.15210806f, 0.03084772f, -0.01603188f, 0.04036001f, -0.14897195f, -0.02019297f, -0.08538245f, 
    0.12137328f, 0.05225152f, 0.04052082f, 0.07574487f, 0.02618593f, -0.09132081f, -0.08520003f, -0.10105666f, 
    0.02170926f, -0.05819014f, -0.06204240f, -0.05363551f, 0.02070813f, -0.05377941f, -0.02685770f, -0.09775010f, 
    0.08050914f, -0.01682004f, 0.41334096f, 0.23089185f, 0.25139317f, -0.21245539f, 0.02526840f, 0.04111234f, 
    -0.10125158f, -0.01821537f, -0.04781615f, 0.13680127f, 0.03319198f, -0.02374666f, -0.08380350f, 0.08895664f, 
    0.01300209f, 0.08728720f, -0.25049746f, 0.23924421f, -0.05755952f, 0.04930825f, 0.23266919f, 0.06457587f, 
    0.04517725f, 0.02902262f, -0.10083238f, -0.06956607f, 0.03448561f, 0.32636508f, 0.05069887f, 0.03470740f, 
    0.07045773f, 0.00842147f, 0.17225493f, -0.00854209f, -0.04247007f, -0.20577221f, -0.09526034f, 0.14728956f, 
    -0.19125912f, 0.08639742f, 0.17854311f, -0.08095011f, -0.12135455f, -0.14357030f, -0.04824336f, 0.01532761f, 
    0.06265008f, -0.13076492f, 0.02558339f, 0.25758156f, 0.06387889f, 0.01029272f, -0.54783815f, 0.09625888f, 
    0.09317851f, -0.08862273f, 0.07975394f, -0.12127852f, 0.16913922f, -0.02345908f, 0.07986104f, 0.15347469f, 
    0.09258016f, 0.12302900f, -0.06547294f, 0.20921353f, -0.03466475f, -0.23601981f, -0.12262615f, 0.01853267f, 
    -0.11631724f, 0.10855837f, 0.26508838f, 0.03485927f, 0.44387567f, 0.09849160f, 0.03493502f, -0.29210436f, 
    -0.01639106f, -0.13710010f, -0.18932875f, 0.28560621f, 0.09739519f, 0.12143122f, -0.01269556f, 0.08637346f, 
    0.10757844f, 0.32900670f, 0.01537555f, 0.05938501f, 0.08000302f, 0.17307456f, -0.27172029f, 0.27502680f, 
    -0.05317101f, -0.07809519f, 0.01052592f, 0.09524815f, -0.03495193f, -0.21026106f, 0.08930088f, 0.04738405f, 
    0.25608027f, 0.12200578f, 0.21503267f, -0.00766103f, -0.18409306f, -0.10004717f, -0.03293902f, 0.18157290f, 
    -0.03163707f, 0.00464875f, 0.09043011f, 0.03393301f, 0.04194499f, 0.05449612f, 0.01945599f, -0.10697825f, 
    0.08709060f, -0.00709722f, 0.09445304f, -0.05596936f, -0.05492744f, -0.06491780f, 0.09360657f, -0.06495260f, 
    0.03868072f, -0.18284965f, 0.32792133f, -0.07445297f, 0.02904993f, 0.03753697f, -0.09800825f, 0.06656884f, 
    -0.04101887f, -0.02626620f, 0.13393453f, -0.07254607f, 0.21040876f, 0.05792980f, 0.07081532f, -0.00435882f, 
    0.08375762f, 0.06873119f, -0.15147841f, 0.27294648f, 0.08799027f, -0.25444868f, 0.10090213f, 0.10709317f, 
    0.23898903f, -0.21948272f, 0.32706621f, 0.12075246f, -0.14165589f, 0.12688328f, -0.05624522f, 0.12475036f, 
    -0.11523300f, 0.23045331f, 0.14639808f, 0.20127790f, -0.00619264f, -0.44695085f, 0.20313540f, -0.08797181f, 
    -0.19837502f, 0.03369785f, 0.00491484f, 0.11664344f, -0.35241836f, 0.20532057f, -0.03071192f, 0.20643982f, 
    -0.09554057f, -0.11805566f, 0.00978257f, 0.23751418f, 0.09175941f, 0.00143076f, -0.31300232f, 0.14145246f, 
    0.10334915f, -0.07904454f, -0.02286349f, 0.10837252f, 0.00087417f, -0.20706664f, -0.08998200f, -0.02059879f, 
    -0.00055819f, 0.09122805f, -0.10903927f, -0.03927203f, 0.01849659f, 0.00619132f, -0.10287592f, -0.14755541f, 
    0.10384643f, 0.07331416f, 0.02689258f, -0.03401818f, -0.08918361f, 0.04131860f, 0.05884461f, -0.08493547f, 
    0.01715806f, 0.03242496f, 0.01209996f, -0.03479578f, 0.10416396f, -0.09940619f, 0.00129638f, 0.06560916f, 
    -0.05349831f, -0.11468774f, 0.08450774f, 0.08790360f, -0.02583080f, -0.11783914f, 0.03352725f, -0.07195464f, 
    0.05026294f, -0.08064552f, 0.08716200f, -0.08246569f, -0.05865685f, -0.10377618f, -0.13243441f, -0.05639622f, 
    -0.06751776f, 0.07383461f, -0.05069537f, 0.06359901f, -0.07008404f, 0.07673469f, 0.08543796f, -0.07360604f, 
    0.08855933f, -0.11345463f, -0.04578770f, 0.08734199f, 0.10553242f, -0.02437161f, 0.04419010f, 0.06858342f, 
    -0.03455176f, -0.03068598f, -0.09280265f, 0.01639502f, 0.02625440f, -0.02879564f, 0.01915907f, -0.13724197f, 
    -0.09282246f, -0.21941189f, -0.17615575f, -0.40150341f, -0.23867565f, -0.12826201f, -0.02707893f, 0.07018679f, 
    0.03096695f, -0.05613035f, 0.09076606f, 0.15108164f, -0.06876311f, -0.02791406f, -0.12958904f, -0.17667341f, 
    -0.10044994f, -0.01490762f, 0.17173225f, -0.13029076f, -0.02926168f, 0.03181759f, 0.02969936f, 0.11676966f, 
    -0.23470224f, 0.28124079f, -0.10703036f, -0.17892219f, 0.02821510f, 0.03474784f, 0.35338190f, 0.15347983f, 
    -0.11516428f, 0.07337891f, -0.02974097f, 0.14172117f, -0.13105136f, -0.03905890f, -0.01434183f, 0.24156614f, 
    -0.04392995f, 0.09947070f, 0.12272596f, -0.03246218f, 0.04885753f, 0.08239540f, -0.04147179f, 0.14479105f, 
    0.05884126f, -0.12127888f, 0.11783928f, 0.13692781f, -0.08931024f, 0.27789864f, 0.34429973f, -0.10435983f, 
    0.17941637f, 0.01732639f, -0.04444409f, -0.07392184f, -0.11368077f, -0.18815966f, 0.06804051f, 0.19860962f, 
    -0.11710668f, 0.13030604f, 0.21755947f, -0.17714532f, -0.00329191f, 0.15777414f, 0.14544384f, -0.17880900f, 
    0.00106034f, -0.04036704f, 0.05442362f, -0.09176439f, 0.06023404f, -0.04821816f, -0.09565786f, -0.06574702f, 
    0.11396368f, 0.01284480f, -0.10185156f, 0.37591398f, 0.03042273f, 0.13042191f, 0.14199123f, -0.05481188f, 
    0.15533294f, 0.12815051f, -0.00886502f, -0.01042293f, 0.14244300f, 0.04524054f, 0.01726082f, 0.09492398f, 
    -0.10288378f, 0.12864496f, -0.01080065f, 0.20214233f, -0.17982781f, -0.11243203f, 0.02711053f, 0.11950744f, 
    -0.07388114f, -0.26853123f, 0.17884329f, 0.00001334f, -0.01087557f, 0.21875061f, 0.07003821f, -0.05611861f, 
    -0.05579726f, -0.22889438f, 0.06913295f, 0.13279602f, 0.02687444f, -0.02204100f, -0.08934457f, 0.10171278f, 
    -0.03066612f, -0.13188478f, -0.07028639f, 0.07993896f, -0.10248189f, -0.05146759f, 0.01931443f, -0.16076948f, 
    0.02522594f, -0.08280919f, 0.10654344f, 0.06454072f, -0.00445198f, 0.17325181f, 0.14795025f, -0.13643312f, 
    -0.12218173f, 0.09319856f, 0.00082485f, -0.05170108f, -0.18984848f, -0.04013006f, 0.16828109f, 0.06659099f, 
    0.11447404f, -0.05378110f, 0.26564899f, 0.14021896f, -0.11338927f, -0.14090452f, -0.20601809f, 0.03786476f, 
    0.08393011f, -0.17631996f, 0.22804826f, 0.03134482f, -0.17156206f, -0.31366363f, -0.06588258f, 0.11152851f, 
    0.09834434f, -0.10559733f, -0.10132997f, 0.01087745f, 0.05800680f, -0.12693587f, 0.10824256f, -0.06327210f, 
    -0.11964799f, 0.16151428f, -0.18694174f, -0.10815042f, 0.18705396f, -0.01717187f, -0.49736306f, 0.12980297f, 
    -0.03245622f, -0.11742052f, -0.42426792f, 0.15004364f, -0.02353561f, 0.08396327f, 0.22945683f, 0.04056443f, 
    0.11697011f, 0.05038668f, -0.05184220f, 0.06335953f, -0.15443489f, -0.11867763f, 0.07299978f, 0.06245578f, 
    0.11556668f, 0.14151779f, -0.17638858f, 0.18090717f, -0.01106680f, -0.08706626f, 0.04597255f, 0.02689247f, 
    0.11152662f, 0.10152747f, 0.13706392f, -0.04834823f, 0.24027930f, -0.08552699f, -0.03980176f, -0.15119547f, 
    -0.11117661f, -0.22282697f, -0.24879259f, 0.36823338f, -0.12408419f, -0.11125650f, -0.04549186f, 0.00380751f, 
    -0.05286957f, 0.31897342f, 0.16892554f, -0.05194074f, -0.01924534f, 0.08124398f, -0.12517329f, 0.49397835f, 
    -0.10130562f, 0.02821094f, 0.04960487f, 0.23938711f, 0.23348704f, -0.15703762f, -0.10316213f, -0.21025993f, 
    0.09850620f, 0.00978484f, 0.06967190f, 0.04269481f, -0.27578878f, -0.02500100f, 0.11557222f, 0.20775352f, 
    0.07400590f, 0.15229790f, -0.00789310f, 0.10766012f, -0.11933856f, -0.18248528f, 0.19405733f, -0.05810319f, 
    0.04978040f, -0.10613890f, 0.11141381f, 0.11430033f, 0.00886603f, -0.13334742f, 0.02192623f, -0.09806080f, 
    -0.10362057f, -0.02889365f, -0.11951332f, -0.08737302f, -0.14855818f, 0.14195029f, 0.16831799f, -0.29234764f, 
    0.06370926f, -0.06551634f, 0.03472758f, -0.19310808f, -0.40226182f, -0.05649168f, -0.17958410f, 0.01020476f, 
    -0.00319428f, 0.10705359f, 0.11523773f, -0.08152144f, -0.08512783f, 0.14774846f, 0.17555533f, 0.05849534f, 
    0.15224276f, -0.11852366f, -0.11432799f, -0.12868671f, -0.36158001f, 0.02396294f, 0.46353245f, 0.22338292f, 
    0.08867219f, -0.16305289f, 0.31867465f, 0.13506094f, 0.22744699f, -0.13338967f, -0.03037005f, 0.11312570f, 
    -0.17357625f, -0.17956449f, 0.47694352f, 0.05765402f, -0.14343868f, 0.37577114f, 0.08524073f, -0.07646552f, 
    -0.01543224f, -0.16985728f, 0.00089352f, 0.07045259f, 0.10148738f, -0.02057831f, 0.05541915f, 0.15675184f, 
    0.02487945f, 0.08646275f, 0.16185738f, 0.01257862f, -0.01183914f, -0.15440398f, -0.12418305f, 0.08122521f, 
    -0.11155902f, 0.12855184f, 0.47897694f, 0.07771847f, -0.00091822f, -0.03307389f, -0.17163958f, 0.22125560f, 
    -0.05728595f, -0.05725352f, 0.06597835f, 0.04534052f, -0.08599298f, 0.11029989f, -0.13630524f, 0.32987347f, 
    0.00578620f, 0.15328163f, 0.05094840f, -0.13908432f, -0.04735572f, -0.20134521f, 0.15919565f, 0.01599391f, 
    0.22015333f, -0.33653900f, 0.00055326f, 0.14813517f, -0.05935847f, 0.02140971f, -0.07474811f, 0.05236613f, 
    -0.05470124f, 0.05450986f, 0.10742189f, -0.11907219f, 0.07359041f, -0.02580242f, -0.22284412f, -0.12621653f, 
    0.00670467f, 0.09605759f, -0.23287964f, 0.01315219f, -0.23454435f, -0.03917427f, 0.12801214f, 0.04439177f, 
    -0.08760671f, 0.25034761f, 0.13489717f, 0.09625622f, 0.02088772f, -0.13269140f, -0.23381530f, -0.03338118f, 
    -0.05492504f, -0.05431897f, 0.26924086f, -0.03691188f, 0.17444786f, 0.05406777f, -0.01835858f, 0.20247576f, 
    0.11964634f, -0.11703772f, 0.09847233f, -0.06093263f, -0.04042009f, -0.04022369f, -0.14151132f, 0.00572210f, 
    -0.07046671f, 0.09025531f, -0.10098662f, -0.10507972f, -0.10343079f, 0.03942873f, -0.01216868f, 0.15387501f, 
    0.06847700f, -0.11263110f, 0.03467156f, 0.02231033f, -0.04232827f, 0.10457021f, -0.10317210f, 0.04810737f, 
    0.01450341f, 0.04636014f, -0.04779143f, -0.04255969f, -0.08784945f, -0.10380505f, -0.12330925f, -0.18969542f, 
    0.07689019f, -0.04445285f, -0.05628395f, -0.04058468f, -0.09034085f, 0.00008203f, -0.08085837f, 0.03033208f, 
    -0.04814127f, 0.00477654f, 0.01978438f, 0.11562198f, 0.08296167f, -0.15275098f, -0.06573080f, -0.06024905f, 
    0.01253869f, -0.10032569f, -0.07667129f, -0.03764319f, -0.04759322f, 0.05647318f, -0.06495290f, -0.11766536f, 
    -0.06990275f, 0.12218681f, -0.01948759f, 0.03871304f, -0.12252603f, 0.03328437f, -0.10433532f, -0.07111660f, 
    0.07520617f, 0.20591494f, 0.30208722f, 0.49102947f, -0.29553741f, 0.09908643f, -0.07879526f, 0.07593895f, 
    0.05503029f, -0.02318569f, -0.07073360f, 0.04283831f, 0.25665957f, 0.06440426f, 0.13324483f, 0.17522979f, 
    -0.03145057f, 0.18230520f, -0.14290330f, 0.11446616f, 0.03538383f, 0.01545315f, -0.09646640f, 0.06679837f, 
    -0.10809478f, 0.17221463f, -0.24937341f, 0.11421721f, -0.14041781f, 0.00272368f, -0.05983247f, 0.13356122f, 
    0.03985657f, -0.16797103f, -0.11936895f, 0.24176829f, -0.10132521f, 0.03071861f, -0.23350051f, -0.07857850f, 
    0.14448537f, 0.39092538f, -0.04689929f, -0.07328305f, -0.11293094f, 0.04229375f, -0.08629409f, -0.31523266f, 
    0.08249551f, -0.04873478f, 0.12265776f, -0.23659323f, -0.04585302f, 0.10955705f, 0.05174056f, -0.23313938f, 
    0.00294553f, -0.06824458f, 0.27867445f, 0.05991194f, -0.04709681f, -0.03632273f, 0.11033652f, 0.12389518f, 
    -0.02872871f, -0.12778857f, -0.03373003f, -0.01587309f, -0.06917460f, -0.12332331f, -0.08898894f, -0.14316240f, 
    -0.00255485f, 0.07061805f, -0.13264610f, -0.08232859f, -0.10164852f, -0.08122073f, -0.00986707f, 0.01101884f, 
    0.04111139f, -0.02519614f, -0.02072141f, -0.11628622f, -0.06773154f, -0.13092652f, -0.10182045f, 0.04987212f, 
    -0.08831085f, -0.13739306f, 0.07711376f, -0.06181306f, -0.15526874f, 0.01933818f, -0.02134469f, -0.10390217f, 
    0.05537310f, 0.02756066f, -0.09786198f, -0.06009179f, -0.13534765f, 0.03158189f, -0.07432297f, -0.01809162f, 
    0.07279335f, -0.01408589f, -0.03054172f, 0.07004812f, 0.02751058f, -0.11817427f, -0.10289469f, -0.00337531f, 
    -0.07760985f, -0.11626434f, -0.02804001f, -0.03141532f, -0.03431103f, -0.00498928f, 0.07403378f, 0.05877128f, 
    -0.12608363f, -0.06756401f, 0.11610429f, 0.01031242f, 0.03411741f, 0.03609773f, -0.12222794f, -0.10229260f, 
    -0.10798555f, 0.05761354f, -0.07925034f, 0.29143831f, -0.13271107f, -0.15983011f, 0.06896568f, -0.06495129f, 
    0.07937057f, 0.10346329f, 0.02238245f, -0.12584440f, -0.04657085f, 0.03161275f, 0.10288279f, 0.13886625f, 
    0.08043453f, 0.03511594f, -0.18216658f, 0.36015344f, 0.08318752f, -0.07598542f, -0.04907477f, -0.03769798f, 
    -0.19414137f, -0.12646642f, -0.12027503f, -0.06001208f, 0.03797589f, -0.03667896f, 0.12633273f, 0.21234260f, 
    0.04601782f, -0.00430088f, 0.01427959f, 0.24660763f, 0.07184453f, 0.19008364f, 0.12144908f, 0.13122021f, 
    -0.19441211f, 0.17481098f, 0.24325003f, 0.03276639f, 0.16780321f, -0.11515851f, -0.29912829f, 0.02296122f, 
    0.05889474f, -0.10329577f, -0.27249414f, -0.01413285f, 0.07428893f, -0.08375102f, -0.18816601f, -0.04264079f, 
    -0.00477407f, -0.11817764f, 0.18862379f, -0.10345515f, -0.18092383f, 0.11215354f, -0.09439453f, 0.12035426f, 
    -0.04592834f, 0.23452072f, 0.26053450f, 0.17032179f, -0.02829248f, 0.12327123f, 0.09966710f, -0.14572830f, 
    -0.09963281f, -0.03755512f, -0.15320036f, 0.02261004f, -0.21456227f, -0.00687411f, 0.27552906f, 0.07895564f, 
    0.03994523f, -0.26773444f, 0.16032797f, 0.03384780f, -0.07387772f, 0.05672286f, -0.07739563f, 0.03268937f, 
    -0.03548515f, -0.14606279f, 0.24007256f, 0.00776976f, 0.00401749f, -0.07607634f, -0.11024105f, -0.28192660f, 
    -0.01337424f, 0.00789489f, -0.02880393f, 0.17947313f, -0.06383175f, 0.11154237f, 0.23001458f, 0.12058944f, 
    0.04359415f, 0.29678133f, 0.04824726f, -0.12707040f, 0.23258412f, -0.08372234f, -0.34164777f, -0.10217092f, 
    -0.06285863f, -0.26010254f, -0.12413811f, -0.15668008f, -0.06810485f, 0.11919741f, 0.00319224f, 0.00520201f, 
    0.26271361f, 0.07730991f, -0.38105065f, -0.07409114f, -0.19995810f, -0.04349571f, -0.04175082f, 0.07529642f, 
    -0.03148650f, 0.02722290f, -0.13013564f, 0.06556056f, -0.03390006f, -0.07098094f, -0.07899001f, -0.05488254f, 
    -0.05131663f, 0.08008226f, 0.10811175f, -0.13514769f, 0.01630666f, 0.04841566f, -0.05527752f, -0.13731277f, 
    -0.12387122f, -0.02704712f, 0.09106947f, 0.01357062f, -0.06221792f, -0.08145715f, 0.04449803f, -0.06160388f, 
    -0.09799846f, 0.01983565f, -0.07347382f, -0.07561969f, 0.00944458f, -0.14229997f, 0.05615961f, -0.11798768f, 
    0.06518328f, -0.00678992f, -0.09518128f, -0.06551515f, -0.02649255f, -0.09095407f, 0.01162220f, -0.03450495f, 
    -0.08389593f, -0.06150180f, 0.08094401f, -0.02347201f, -0.05864833f, 0.02830587f, 0.00981202f, -0.11612987f, 
    -0.12386660f, -0.07563510f, -0.08025389f, 0.09423067f, 0.08404364f, -0.09628239f, 0.02182120f, 0.00328297f, 
    -0.04484976f, 0.11192375f, -0.02958996f, -0.03392233f, -0.00469195f, 0.01077653f, -0.04155549f, -0.09174117f, 
    0.11035411f, 0.23586628f, 0.20657164f, 0.15770540f, 0.01919419f, 0.08018747f, -0.25157481f, 0.12114115f, 
    -0.10522921f, -0.11692894f, 0.05730250f, 0.11485358f, -0.20385176f, -0.03704070f, -0.04316412f, 0.42773736f, 
    0.00082617f, 0.05376062f, 0.06808596f, -0.23593737f, 0.07591245f, 0.13970573f, 0.08857907f, -0.11720110f, 
    0.19519287f, -0.25343543f, -0.13038872f, 0.14126275f, -0.19338948f, 0.02616685f, 0.16655350f, -0.04496126f, 
    -0.11775649f, -0.19298431f, 0.20095767f, 0.07112502f, 0.13400011f, 0.02371418f, -0.28855821f, -0.06149483f, 
    0.04238734f, 0.20024677f, -0.10044497f, 0.01517210f, -0.13375236f, -0.00822170f, 0.03423239f, -0.16442293f, 
    0.04523833f, 0.25592566f, 0.17275383f, -0.15636368f, -0.05348077f, -0.24844265f, 0.12020499f, -0.24916615f, 
    -0.20951308f, -0.02326657f, 0.30978301f, -0.03068861f, 0.11796389f, -0.05478618f, 0.05737077f, 0.07088064f, 
    0.03364342f, -0.00272436f, 0.06285704f, -0.00112529f, 0.11000320f, 0.02091527f, -0.10754758f, 0.02286341f, 
    0.04850892f, -0.07705860f, 0.17987056f, 0.00113406f, -0.18629943f, 0.01253231f, -0.03779523f, -0.00148263f, 
    -0.06768721f, -0.13251701f, 0.19045593f, -0.41788766f, -0.06447797f, -0.09236271f, 0.00396563f, 0.00986495f, 
    0.28774980f, -0.27505261f, 0.17822117f, 0.02540483f, 0.00139982f, 0.00589759f, -0.09785288f, -0.33197451f, 
    0.05139160f, -0.05370077f, 0.22419228f, 0.06315228f, 0.05201752f, -0.36064422f, 0.26124451f, 0.29706788f, 
    -0.12136775f, 0.03838157f, 0.01699727f, -0.08756197f, -0.02861621f, -0.04119772f, 0.16002545f, 0.24163315f, 
    0.04389146f, 0.03676873f, 0.05576936f, 0.27770972f, 0.08133690f, 0.21614315f, -0.41325808f, 0.17096645f, 
    0.17684543f, -0.10542610f, -0.04013855f, -0.06879160f, -0.13625602f, -0.15403308f, -0.08691026f, 0.14969379f, 
    0.10554539f, -0.15755557f, -0.10670853f, -0.04097149f, 0.08940247f, 0.17182475f, 0.05233076f, 0.04965802f, 
    -0.05494630f, 0.03070194f, 0.26700372f, 0.18734929f, -0.29005057f, -0.05500998f, 0.17721501f, 0.19981419f, 
    0.07544712f, -0.11890187f, 0.43397033f, -0.26090127f, 0.06941357f, -0.21003984f, 0.04541535f, 0.02343941f, 
    0.02141622f, -0.36378148f, 0.22554050f, 0.09001257f, -0.06411406f, -0.21222860f, -0.06740636f, -0.24799897f, 
    0.02717229f, -0.17910804f, 0.04573942f, -0.11173069f, 0.18003991f, -0.08567391f, 0.20267217f, 0.21591413f, 
    0.15314111f, 0.00640792f, -0.19257292f, -0.05290632f, 0.17489767f, -0.02955837f, -0.17243589f, 0.29134703f, 
    -0.06359649f, 0.24735549f, -0.14226747f, 0.14641912f, -0.10499556f, 0.10106716f, -0.30465764f, 0.15240596f, 
    0.19722454f, -0.09957898f, 0.04869448f, 0.00223162f, -0.17240068f, -0.16138187f, 0.05260540f, 0.09437637f, 
    -0.03834487f, 0.20025863f, -0.23239665f, 0.06279024f, 0.13015276f, -0.09705720f, 0.05671960f, 0.02334183f, 
    -0.00463163f, -0.10918348f, 0.02645594f, 0.08617469f, 0.10708068f, -0.05402372f, 0.03507505f, -0.07710454f, 
    0.06246412f, 0.02794568f, -0.03307328f, 0.07196137f, -0.04691128f, 0.31889531f, 0.04628119f, 0.02801348f, 
    0.14286841f, 0.42184320f, -0.15252987f, -0.15986399f, -0.17059286f, 0.03243249f, 0.09102850f, 0.08412404f, 
    -0.00582622f, 0.06971908f, -0.00313212f, 0.30647442f, -0.17462914f, 0.02641170f, -0.32150993f, 0.20198262f, 
    0.30819619f, 0.01900925f, 0.09156757f, 0.10417997f, 0.04364470f, -0.03566806f, 0.10492670f, 0.05765068f, 
    0.11052801f, 0.10951029f, 0.13507742f, -0.14268123f, -0.06163524f, -0.05901899f, 0.06003252f, -0.25631657f, 
    -0.20383038f, -0.05501510f, -0.02876030f, -0.02808206f, 0.03050859f, 0.00617620f, 0.11428515f, -0.02800621f, 
    0.07376057f, -0.12514354f, 0.21248919f, 0.06596185f, 0.05154525f, -0.19581088f, -0.29476541f, 0.17679772f, 
    0.08041579f, 0.07230437f, 0.06985802f, 0.26717854f, 0.55001932f, -0.07862342f, 0.18208431f, -0.07698502f, 
    -0.06136541f, 0.13725632f, -0.18859442f, 0.30065948f, 0.03394099f, -0.25937626f, 0.06377693f, -0.05725525f, 
    0.04002156f, 0.13810228f, 0.04067474f, 0.04293726f, -0.00578517f, -0.02278389f, -0.30377075f, 0.11642971f, 
    0.08323604f, -0.01134290f, -0.17220631f, -0.18419193f, -0.20478852f, -0.11521766f, -0.07859503f, -0.13078035f, 
    0.07229061f, 0.27327296f, -0.14589876f, -0.01055338f, 0.00991819f, -0.22015253f, 0.07119042f, 0.05811240f, 
    0.08874027f, 0.17577341f, 0.01631758f, -0.08418946f, -0.02373022f, 0.18792714f, -0.08978220f, -0.25237358f, 
    0.06580579f, -0.11853725f, 0.10701859f, -0.01504652f, -0.11328873f, -0.14876401f, -0.02324968f, 0.12458102f, 
    0.04387297f, -0.10712691f, -0.46684778f, -0.12334295f, -0.16225320f, 0.05250423f, -0.06761625f, 0.04155391f, 
    0.05041056f, -0.04316708f, 0.18895678f, 0.09102279f, -0.12225927f, -0.11334922f, 0.19267522f, 0.06543774f, 
    0.02449407f, -0.22178899f, 0.23523340f, -0.46535704f, 0.10775103f, -0.01772980f, -0.16402151f, -0.09070180f, 
    0.05341291f, 0.10348258f, 0.23977934f, 0.01861886f, -0.27881172f, -0.08404496f, 0.02458415f, -0.01039439f, 
    -0.04780284f, -0.20213406f, 0.06893215f, -0.02802407f, 0.24073772f, -0.19571491f, 0.27574635f, 0.00574480f, 
    0.28288344f, 0.08946536f, 0.11039577f, 0.06750792f, 0.06733285f, 0.11452838f, 0.01745409f, 0.02937707f, 
    0.00471550f, 0.01415818f, 0.07287139f, -0.08371843f, 0.08729221f, 0.15948033f, 0.28828180f, 0.13317184f, 
    0.23980729f, 0.07413155f, -0.10102609f, -0.04876674f, -0.25579441f, -0.11062700f, -0.02352114f, 0.04227530f, 
    0.05249861f, -0.19705507f, -0.37326536f, 0.05054949f, 0.13856134f, -0.06022914f, 0.01096857f, -0.05858425f, 
    -0.11694612f, 0.06052828f, 0.00046413f, 0.02265985f, 0.20075333f, 0.05404412f, -0.08233018f, -0.23088712f, 
    -0.12182465f, -0.13469808f, -0.12932678f, 0.06037977f, -0.00537671f, 0.06056276f, 0.13634817f, 0.02518276f, 
    0.19264346f, 0.07555851f, 0.18676504f, 0.17047988f, -0.21081080f, 0.25572327f, 0.06935250f, 0.36053014f, 
    -0.10242748f, -0.08063944f, 0.15157847f, -0.06428561f, 0.25907320f, -0.12126349f, -0.11883020f, -0.20046644f, 
    -0.24762939f, -0.10624338f, 0.36783597f, -0.10508002f, -0.08145417f, 0.09267850f, 0.07038076f, 0.23662841f, 
    0.06670570f, 0.10129000f, 0.08071642f, 0.24896459f, -0.06019825f, 0.14381014f, -0.04343203f, 0.23539111f, 
    -0.07297815f, -0.03449157f, -0.06597485f, 0.09213495f, 0.18365736f, -0.05911724f, 0.02549126f, 0.01312889f, 
    0.12513642f, -0.06754167f, -0.09881492f, -0.02168806f, 0.05713415f, 0.21083748f, 0.09977812f, 0.07606745f, 
    -0.01980037f, -0.05276157f, 0.01284817f, 0.06979846f, 0.24868068f, -0.00885590f, 0.11464801f, -0.24944718f, 
    0.10026911f, -0.07828902f, -0.00602342f, 0.31398714f, 0.00675726f, -0.20770903f, 0.00395531f, 0.08995669f, 
    -0.16652267f, 0.15533565f, 0.19571529f, 0.10160494f, -0.05710534f, -0.19492382f, -0.17830470f, 0.12894398f, 
    0.04590776f, -0.06146510f, -0.16213143f, -0.13714677f, 0.17192017f, 0.10418181f, 0.22966574f, -0.38070723f, 
    0.09593032f, 0.19482632f, -0.15484068f, 0.04588952f, 0.20552811f, -0.08764270f, -0.15955259f, -0.00433447f, 
    0.02649825f, 0.12181107f, 0.14659871f, -0.03267441f, -0.05128498f, -0.08279057f, 0.44788939f, -0.06472672f, 
    0.04106301f, -0.01389438f, -0.13427089f, 0.09091108f, 0.04112878f, 0.04363753f, 0.06042613f, -0.09808746f, 
    -0.01220510f, 0.12896049f, -0.23076721f, 0.08255898f, 0.18670636f, 0.05074453f, 0.18895710f, -0.20634860f, 
    -0.03559319f, 0.04832068f, 0.14278634f, -0.19172157f, -0.13525011f, -0.02545552f, 0.08241677f, 0.09968659f, 
    -0.04658943f, -0.22592802f, -0.06159372f, -0.16938654f, 0.02840436f, 0.07579182f, 0.00464390f, -0.01990737f, 
    0.20651627f, 0.02453017f, 0.04592292f, 0.05196811f, -0.20292832f, -0.01164996f, 0.22370169f, 0.31449410f, 
    0.05236007f, 0.02374591f, 0.21259786f, 0.03039414f, 0.36434960f, -0.13835563f, -0.16495724f, -0.10792545f, 
    0.13303986f, -0.20881604f, 0.20553762f, -0.03417006f, -0.06802686f, 0.28580114f, -0.08801526f, 0.20405900f, 
    0.03939338f, 0.09725213f, 0.14883924f, 0.02197392f, 0.02157668f, -0.21401043f, 0.12075875f, 0.12722999f, 
    -0.23558185f, 0.06247879f, 0.06120934f, 0.08068890f, -0.13843270f, -0.06612330f, -0.07782215f, 0.05156199f, 
    0.01886621f, -0.13578577f, -0.03794525f, 0.04142544f, -0.10117016f, -0.04018892f, -0.13120060f, -0.05262433f, 
    0.06884304f, 0.04598442f, -0.03317188f, -0.12425645f, 0.07389252f, -0.02873394f, -0.01846154f, -0.08826945f, 
    -0.12091407f, 0.03640795f, -0.06217914f, 0.08217837f, -0.12432739f, -0.07022916f, -0.09912784f, 0.05700995f, 
    -0.15885475f, -0.09469925f, -0.03418260f, 0.00801829f, -0.16937456f, -0.03574237f, -0.03612895f, -0.12602216f, 
    -0.12257506f, -0.00157582f, 0.06246597f, -0.07406591f, -0.01331130f, -0.00844806f, 0.05634268f, -0.00380635f, 
    -0.10315990f, -0.01884179f, 0.06308460f, 0.11217122f, -0.10640900f, -0.11727339f, 0.01023657f, -0.05696515f, 
    0.01159607f, -0.02243491f, -0.03186785f, -0.10911199f, 0.06873763f, -0.00077899f, 0.11407975f, -0.02126479f, 
    -0.12399658f, 0.00582805f, 0.01205313f, -0.07061248f, 0.01975856f, -0.16413160f, -0.03928664f, -0.01257378f, 
    -0.06834982f, -0.03745639f, -0.01792596f, 0.33302432f, 0.18427691f, -0.18338248f, 0.04312750f, 0.02235343f, 
    0.08233688f, 0.05416977f, 0.13783713f, -0.12886105f, 0.10100390f, 0.07233793f, 0.09004480f, 0.13530657f, 
    0.06182841f, -0.37045547f, 0.03644593f, -0.25331554f, -0.04929811f, 0.07857952f, 0.03827779f, 0.07034443f, 
    0.09799971f, -0.17111000f, 0.14369076f, -0.06769476f, -0.23082680f, 0.04412293f, -0.13574421f, 0.17141110f, 
    0.11358911f, -0.09548727f, 0.15676138f, 0.07118913f, 0.23848550f, 0.02045530f, -0.13435666f, 0.12786344f, 
    0.04189794f, -0.02981816f, -0.42761767f, 0.01203430f, -0.10253283f, -0.04896031f, -0.13147864f, 0.03925405f, 
    -0.04099490f, 0.17934354f, -0.11405247f, 0.06189657f, 0.05902970f, 0.02211896f, -0.29328731f, 0.10378687f, 
    0.02961717f, 0.03683452f, 0.02004204f, -0.07441525f, -0.07834896f, 0.18783695f, -0.00577037f, -0.06249110f, 
    0.01774747f, 0.01784436f, 0.05542442f, 0.15006092f, -0.03475184f, -0.11924055f, -0.00915810f, -0.06607528f, 
    -0.05645212f, 0.05438984f, -0.07470119f, 0.14427701f, -0.07103890f, 0.02456933f, 0.30700931f, 0.09576125f, 
    -0.12404197f, -0.23709913f, 0.16537787f, 0.23264550f, 0.02409299f, 0.05100768f, -0.03398338f, 0.11777113f, 
    0.17631607f, -0.25162181f, 0.08158451f, -0.03193045f, -0.28965259f, -0.19025734f, -0.05931345f, -0.42232823f, 
    0.01905680f, -0.01050340f, 0.11750440f, 0.12006726f, 0.34812382f, -0.03951138f, 0.25528038f, 0.16398221f, 
    -0.00259734f, 0.15606298f, -0.01197275f, -0.03416526f, 0.16729975f, -0.19592400f, -0.37608683f, 0.19729227f, 
    0.00117513f, -0.11377362f, -0.23034374f, 0.01311294f, 0.04964161f, 0.05391239f, -0.06083047f, -0.16721430f, 
    0.26948130f, -0.08694029f, -0.22683041f, 0.06578811f, -0.07020865f, -0.24475370f, 0.07201619f, -0.05306817f, 
    0.10275032f, -0.26106215f, -0.06512488f, -0.23723719f, -0.11064395f, -0.08410315f, -0.02597278f, -0.02900313f, 
    -0.00080682f, 0.00676923f, -0.03368123f, 0.01065410f, -0.10442793f, 0.01126544f, 0.22575711f, 0.05694944f, 
    0.09273793f, -0.18687691f, 0.12989338f, -0.28590313f, 0.00942793f, -0.21819615f, 0.18008241f, 0.08939618f, 
    0.18723533f, -0.26792434f, 0.33641371f, -0.01765936f, -0.39574826f, 0.05358713f, 0.07514495f, -0.01312629f, 
    -0.11544105f, -0.11221242f, 0.21427538f, 0.09112451f, 0.18634468f, -0.12381844f, 0.31717509f, -0.12038019f, 
    -0.21635549f, -0.01104461f, 0.16379872f, 0.10801470f, -0.07134323f, 0.09778874f, 0.00810212f, 0.29227656f, 
    -0.12033516f, 0.00767315f, 0.02696666f, 0.28692573f, -0.02615171f, 0.03694439f, -0.12902565f, 0.09715746f, 
    0.10055043f, -0.15268941f, 0.01521636f, 0.07993807f, -0.12565368f, -0.09484828f, -0.08130591f, 0.21024635f, 
    0.10829421f, 0.01829920f, 0.14662237f, 0.25435635f, -0.01187981f, -0.01186954f, 0.08726776f, -0.19429007f, 
    -0.11903039f, 0.03206685f, -0.03858934f, -0.15322095f, 0.03116412f, 0.05207946f, 0.03198556f, -0.06322070f, 
    -0.07574658f, -0.32160690f, 0.19951238f, 0.45534247f, 0.02008674f, 0.07402553f, -0.05883084f, 0.11119352f, 
    0.07943982f, 0.02012479f, 0.08202677f, -0.24352208f, 0.09443483f, -0.00761775f, 0.41362172f, 0.13859008f, 
    0.02120807f, -0.02369775f, -0.07265022f, -0.00498213f, -0.03631200f, -0.02846593f, -0.04745945f, 0.26885989f, 
    -0.01754861f, -0.09135849f, 0.02356657f, 0.04593078f, 0.26569882f, 0.02326866f, -0.13710414f, -0.25069112f, 
    -0.07758238f, -0.15566452f, 0.05675791f, 0.07828941f, -0.08559723f, 0.10083120f, -0.21143962f, 0.12456086f, 
    0.00835069f, -0.04769823f, -0.00522514f, -0.11920223f, 0.01272067f, 0.00570862f, -0.10757278f, -0.01243130f, 
    0.04353122f, -0.23877363f, -0.09213535f, -0.06050502f, -0.31326541f, 0.16218309f, -0.18698871f, 0.15545434f, 
    0.09152965f, 0.07356966f, 0.12809922f, 0.14372313f, -0.06431193f, 0.11444661f, -0.23708338f, 0.17554450f, 
    0.00673890f, 0.28058872f, -0.00727275f, -0.12636872f, -0.01784885f, -0.07350285f, 0.14539841f, 0.11749853f, 
    -0.16550033f, 0.27531129f, -0.23394178f, 0.21311116f, -0.01790982f, -0.14829919f, 0.23276095f, -0.04212417f, 
    0.07606696f, -0.02280929f, 0.01730250f, -0.19421183f, -0.02418437f, 0.04561305f, -0.02916239f, -0.04341887f, 
    0.09999859f, 0.06284300f, 0.29526687f, -0.01855428f, -0.07746909f, 0.14872712f, 0.20679750f, -0.19250217f, 
    -0.09523985f, -0.01739614f, 0.24332969f, -0.20037675f, 0.01645556f, -0.14356789f, 0.51778042f, -0.29985538f, 
    0.09234591f, -0.04046896f, 0.08150184f, 0.11715015f, -0.05701596f, -0.10362030f, -0.00198529f, 0.11583158f, 
    -0.10807125f, 0.04868328f, 0.04972009f, 0.20562218f, -0.07791087f, 0.04131094f, -0.09378300f, 0.21007271f, 
    -0.04714127f, -0.03703848f, -0.00015652f, 0.10545933f, 0.35548937f, 0.11303950f, 0.17505112f, -0.10860914f, 
    -0.00938547f, 0.27293316f, -0.11276049f, -0.04855946f, -0.03700725f, 0.11183483f, 0.03171860f, -0.03072323f, 
    0.24605402f, 0.17271835f, -0.03415217f, 0.09779835f, -0.08175844f, 0.01805720f, -0.22198446f, -0.16245589f, 
    -0.12327117f, -0.09841976f, 0.00020950f, 0.04916728f, -0.06603968f, -0.10225583f, -0.07943562f, -0.03861577f, 
    0.22772244f, 0.43312693f, 0.03392912f, -0.09480444f, -0.02157255f, -0.20408261f, -0.02134852f, 0.02222804f, 
    0.03848340f, 0.01956974f, 0.18788229f, 0.04309600f, -0.04508139f, 0.11202458f, -0.14167316f, -0.14789297f, 
    0.03882166f, 0.01688362f, 0.19110100f, -0.09097314f, 0.26616731f, 0.11729929f, 0.02312812f, 0.16587293f, 
    -0.09695175f, 0.22328301f, -0.24896561f, 0.15621397f, 0.10641135f, -0.19380367f, 0.23308811f, -0.05711702f, 
    -0.12433164f, -0.06043715f, 0.16412289f, -0.01824143f, 0.27019104f, -0.05051527f, 0.12679437f, -0.09352984f, 
    0.01735956f, -0.04592532f, -0.26483378f, 0.22003900f, -0.03334030f, -0.11602540f, -0.16854361f, -0.02570201f, 
    0.07327910f, 0.28507912f, 0.24720758f, -0.11862727f, -0.12051015f, 0.14298183f, -0.01029736f, 0.70106512f, 
    -0.07373829f, -0.09938630f, 0.12756455f, 0.26565716f, 0.15173392f, -0.02776493f, 0.11996169f, -0.24000566f, 
    0.21505892f, 0.14048465f, 0.19059825f, 0.10962781f, -0.07636483f, 0.18816310f, -0.03805812f, 0.07053501f, 
    0.06295919f, -0.07915664f, -0.06275089f, -0.18195827f, -0.05099301f, -0.19646338f, 0.26873475f, -0.05632773f, 
    0.01844688f, 0.12205136f, -0.06856078f, -0.04154699f, -0.08641858f, 0.19862525f, -0.00343978f, 0.11544058f, 
    0.11010090f, -0.18285772f, 0.04659673f, -0.44772795f, 0.28181952f, -0.12744725f, -0.23707040f, -0.16373327f, 
    0.00723158f, -0.11812867f, 0.02904972f, 0.03097756f, 0.04822198f, -0.05204251f, 0.09050956f, -0.00533723f, 
    0.00593770f, -0.30881605f, 0.15188442f, 0.00649699f, 0.09325018f, 0.28403491f, 0.26504576f, 0.08084587f, 
    0.10633255f, -0.04495498f, -0.11289797f, -0.23443404f, 0.03906415f, 0.09241486f, 0.14396375f, -0.22145332f, 
    -0.01696824f, 0.06641544f, 0.04677173f, -0.10577004f, 0.25488696f, -0.11198565f, 0.05990028f, 0.24499366f, 
    0.33632690f, -0.24624261f, -0.04249006f, -0.04085365f, 0.07555960f, 0.04853484f, 0.00946417f, 0.19724005f, 
    0.06993856f, -0.23244707f, 0.17479560f, 0.06016429f, -0.06180443f, 0.22206455f, 0.00660909f, -0.11360598f, 
    0.09172830f, 0.09171950f, -0.24498445f, 0.10506891f, -0.29160294f, -0.19537221f, -0.05755323f, 0.01539544f, 
    -0.10697323f, -0.10256771f, 0.07102221f, 0.01671249f, -0.14995883f, -0.11397278f, -0.10831020f, -0.12115713f, 
    -0.12596697f, 0.00700720f, -0.06304871f, -0.13826138f, 0.00690957f, -0.01151373f, -0.08349941f, 0.06753883f, 
    0.09305109f, -0.00411275f, -0.22736822f, 0.00647646f, 0.10523388f, 0.09397002f, -0.16137895f, 0.07467193f, 
    0.00666951f, 0.09580872f, 0.04609603f, 0.01630122f, -0.03373406f, 0.08433124f, 0.02870993f, -0.13073981f, 
    -0.08876593f, -0.01872398f, 0.04369483f, -0.08910473f, 0.02954935f, -0.01849649f, -0.01574796f, 0.09450749f, 
    -0.03834852f, -0.06269570f, 0.11216827f, -0.11829087f, -0.10870381f, 0.06002492f, 0.10431419f, -0.07899141f, 
    -0.03250343f, 0.18748660f, 0.15924107f, 0.02269910f, -0.07934907f, -0.12315653f, -0.09001434f, -0.09645282f, 
    -0.15375635f, -0.12533985f, -0.17260127f, 0.00900011f, -0.15185601f, -0.04608721f, -0.01400870f, -0.14932939f, 
    -0.01299223f, -0.02993969f, 0.14637305f, 0.17819969f, -0.01548036f, 0.08542961f, 0.11437688f, -0.05600948f, 
    0.00201519f, -0.01715580f, -0.07027612f, -0.03748583f, 0.15052022f, 0.08076681f, -0.11908183f, 0.01390460f, 
    0.09046990f, 0.05830397f, -0.05113160f, 0.17079324f, 0.09539531f, 0.02075628f, 0.12884809f, -0.07880589f, 
    0.03660713f, 0.04049784f, -0.05282873f, 0.10569989f, -0.07440414f, 0.07157364f, -0.03413394f, -0.05292650f, 
    0.07709098f, 0.11377808f, -0.06435244f, -0.10073658f, -0.02809558f, 0.03186582f, 0.05443497f, -0.06705832f, 
    0.06885925f, 0.11845578f, -0.21237172f, -0.09984103f, 0.10396375f, -0.11466531f, -0.04819766f, 0.10531546f, 
    -0.02445273f, 0.02028007f, -0.00734659f, 0.03283308f, -0.11987877f, 0.10848221f, 0.02848749f, 0.07229383f, 
    -0.13652778f, -0.05998014f, 0.14209306f, 0.08128725f, 0.05463832f, -0.02716825f, 0.11644430f, -0.10099290f, 
    0.00002777f, 0.01399006f, 0.40374464f, -0.04301996f, 0.17860839f, -0.00141074f, 0.06471707f, -0.05508304f, 
    -0.05356287f, 0.04029966f, -0.10030590f, -0.06707100f, 0.15511020f, -0.04058600f, -0.14739397f, -0.01969021f, 
    -0.05121813f, 0.27147767f, -0.47711563f, 0.48374370f, 0.02922552f, -0.03025491f, 0.21125111f, -0.01181089f, 
    0.06237778f, 0.05603877f, -0.07266057f, 0.05743948f, 0.00493629f, 0.15009697f, 0.05790206f, -0.02140643f, 
    -0.03552359f, 0.18935482f, 0.05938024f, -0.03201739f, 0.01667554f, 0.02600439f, -0.10138573f, -0.07175416f, 
    0.05576760f, 0.01583030f, 0.02142275f, 0.11417326f, -0.06933465f, -0.01499069f, -0.00998734f, -0.08005048f, 
    -0.05450529f, -0.04277580f, 0.07585426f, 0.10235383f, -0.02305317f, -0.11767241f, -0.01639927f, -0.16724198f, 
    -0.06743049f, -0.04461765f, -0.07936250f, 0.01295955f, 0.23296674f, -0.00907756f, -0.07849460f, 0.02615831f, 
    0.02916759f, 0.19846748f, -0.11624009f, -0.04074836f, 0.06390712f, 0.28514200f, 0.06035135f, -0.25077352f, 
    -0.11639711f, -0.08607635f, 0.20320928f, -0.11545096f, -0.23948011f, -0.11661632f, -0.03824360f, 0.15357478f, 
    0.05686273f, 0.18456165f, 0.24220346f, -0.12467087f, 0.11046283f, 0.20985226f, -0.20315921f, -0.10011421f, 
    0.11705699f, -0.01269866f, 0.04332485f, 0.15840700f, 0.12476224f, -0.01835917f, 0.31129131f, -0.04096047f, 
    -0.02888845f, -0.00706002f, 0.02776550f, 0.36415997f, -0.06583957f, -0.15254031f, -0.10371790f, 0.25193259f, 
    0.12924814f, 0.00885072f, 0.32818577f, -0.08113179f, -0.16935350f, 0.35503045f, 0.18307105f, -0.04782688f, 
    0.06618877f, -0.06827151f, 0.35041398f, -0.11613586f, -0.05510635f, -0.02152154f, 0.19070959f, 0.07213899f, 
    -0.01171048f, 0.00728579f, -0.08940414f, -0.08025037f, -0.04817882f, 0.04365814f, -0.04543421f, -0.12984696f, 
    -0.08907443f, 0.04611385f, 0.01717168f, 0.21900702f, 0.22996658f, -0.19776076f, -0.00644182f, -0.05583578f, 
    -0.07274505f, -0.07184242f, 0.04279859f, -0.07688401f, 0.19394861f, -0.06780525f, 0.07405449f, -0.00392948f, 
    0.09092814f, -0.03133892f, 0.14042087f, -0.04086539f, 0.11816400f, 0.19583645f, 0.18027097f, -0.03482791f, 
    0.18869898f, -0.11114535f, -0.17309214f, -0.19166397f, -0.02660279f, 0.31239960f, 0.30633867f, 0.19218197f, 
    -0.00414594f, -0.04249246f, 0.20178474f, 0.08369200f, -0.08860345f, -0.18283232f, -0.04044780f, 0.27400073f, 
    -0.28522930f, -0.12032947f, 0.28788105f, 0.03488744f, 0.02897402f, 0.05046410f, -0.04029673f, -0.01734985f, 
    -0.06198815f, -0.22118288f, 0.01971372f, 0.29663962f, -0.08510283f, 0.32352802f, -0.39196447f, 0.15067528f, 
    0.10960168f, -0.11682495f, 0.01220464f, 0.05940688f, 0.19210345f, -0.04358875f, 0.07350570f, 0.31665888f, 
    0.06121223f, -0.07376382f, -0.07202660f, 0.11812165f, -0.07468127f, 0.09605436f, -0.13193299f, -0.15829921f, 
    -0.01411882f, 0.06692408f, -0.02249532f, -0.00979071f, -0.07439662f, -0.07019587f, 0.02041011f, 0.03189439f, 
    0.10936724f, -0.05235774f, -0.10497952f, 0.15752450f, 0.08085950f, 0.06469657f, -0.13993143f, -0.00018373f, 
    -0.06570500f, 0.04863072f, -0.00666443f, -0.09357890f, -0.00798889f, -0.04743602f, -0.00948389f, -0.01714513f, 
    -0.10326906f, -0.06200130f, -0.07637561f, -0.02722413f, -0.04559551f, 0.03678012f, 0.06599792f, 0.19367664f, 
    -0.02585694f, 0.02285757f, -0.05014844f, -0.01288828f, 0.07824892f, 0.07602905f, -0.11954105f, -0.05770877f, 
    -0.09877785f, -0.18311675f, 0.00664600f, -0.07047667f, 0.03765881f, -0.10735698f, -0.04504869f, -0.14185245f, 
    0.07129847f, 0.02365360f, -0.13055700f, 0.05238366f, -0.09352586f, 0.06043743f, 0.02584435f, -0.10922591f, 
    -0.06186768f, 0.29357278f, 0.19600928f, 0.20537598f, -0.07817799f, 0.01932404f, -0.18368112f, 0.12618393f, 
    -0.10874228f, -0.02702758f, 0.02991185f, -0.09683233f, 0.01562535f, -0.05333005f, 0.21844982f, 0.16683334f, 
    -0.13427019f, -0.09355821f, -0.25123176f, -0.03479463f, -0.08462582f, 0.18500046f, -0.17344637f, 0.02814783f, 
    0.27479142f, -0.15044931f, 0.20331982f, 0.18126883f, -0.33190319f, -0.08960353f, -0.14299521f, 0.10429225f, 
    -0.07375523f, 0.10442295f, 0.16023223f, 0.30909410f, 0.23964310f, -0.20380561f, 0.11390857f, -0.24497041f, 
    0.20059216f, 0.17123754f, -0.02191032f, -0.09041575f, -0.26263252f, 0.06679657f, -0.08365583f, 0.18214428f, 
    0.06877561f, -0.02219334f, 0.04883960f, 0.19905519f, -0.11796522f, -0.11501444f, 0.12135103f, 0.10018287f, 
    0.03503554f, -0.10553753f, -0.03382622f, -0.02644692f, 0.01554007f, -0.12963159f, -0.10902671f, -0.25198928f, 
    0.10961674f, -0.15652494f, 0.14581022f, -0.10597116f, 0.03171370f, 0.09846797f, -0.21819553f, 0.07953246f, 
    -0.05088240f, -0.12110333f, 0.01237111f, 0.24979441f, 0.08170814f, 0.05169517f, 0.00267597f, -0.13251543f, 
    -0.00009115f, 0.02110308f, -0.03962256f, 0.20929521f, -0.03262848f, -0.00876800f, 0.17282179f, 0.12154679f, 
    0.14161363f, 0.01699466f, 0.10954705f, 0.13737336f, 0.08292998f, -0.04316359f, -0.18012664f, -0.27438280f, 
    -0.05453554f, 0.13779797f, -0.06420983f, -0.13075909f, 0.06163776f, 0.00141101f, 0.19976516f, -0.01676611f, 
    0.03980030f, -0.03807593f, -0.13703130f, -0.11685359f, 0.05168906f, 0.04435930f, -0.04133172f, 0.11632799f, 
    -0.05915575f, -0.12879242f, -0.06985676f, -0.02998152f, -0.06584185f, 0.03769126f, -0.13549387f, 0.06839518f, 
    0.23058233f, 0.02784576f, -0.13929127f, 0.09876324f, -0.09926633f, -0.14439325f, 0.08938355f, 0.17647891f, 
    -0.05933235f, -0.04782042f, -0.45810184f, 0.09624420f, -0.36200410f, 0.13240454f, 0.13236430f, -0.04518210f, 
    -0.04589433f, 0.02056293f, -0.05174112f, 0.09224860f, 0.12659155f, 0.06265922f, 0.08086211f, -0.05585238f, 
    0.05007346f, -0.05748339f, 0.12777102f, -0.00350063f, -0.03360796f, -0.13697605f, -0.00085092f, -0.07613182f, 
    -0.21881385f, 0.21943584f, 0.05978334f, 0.17481874f, -0.04274673f, -0.19802332f, 0.28888392f, -0.03325250f, 
    0.12055830f, -0.28668749f, 0.05843570f, -0.11896275f, 0.20120394f, 0.06255119f, 0.10422917f, -0.15645437f, 
    0.02566854f, 0.21305437f, 0.19917476f, 0.09089398f, 0.21358244f, 0.11925447f, -0.00523597f, -0.17841099f, 
    -0.05877015f, -0.07870463f, 0.07650934f, -0.27834243f, -0.11472643f, 0.02384526f, 0.32356957f, 0.01988590f, 
    -0.03412002f, -0.09841748f, 0.09439629f, 0.09332235f, -0.12652220f, 0.09109881f, -0.09080825f, 0.19337739f, 
    0.07293794f, 0.09392104f, -0.02606971f, 0.42768788f, 0.14269736f, -0.51598859f, 0.14428176f, -0.13404749f, 
    -0.04133525f, 0.08285720f, 0.07918163f, -0.11385575f, 0.34838191f, -0.02129878f, 0.06417545f, 0.03299575f, 
    0.10686661f, -0.13131364f, -0.10622559f, 0.10528707f, -0.09702607f, 0.00099447f, -0.11062445f, -0.09442463f, 
    -0.05917723f, 0.04427183f, -0.10485365f, -0.18755993f, -0.05631389f, 0.13827737f, 0.29493153f, 0.34003216f, 
    0.02221867f, -0.19968987f, 0.16116725f, 0.19625510f, -0.06714058f, 0.00106650f, -0.02976337f, 0.20393276f, 
    -0.01879108f, 0.17506111f, 0.06824692f, 0.12021831f, -0.03110251f, -0.01559517f, 0.03235934f, 0.04152003f, 
    0.10889224f, 0.18212010f, -0.02439982f, -0.02291069f, 0.01236086f, 0.11204751f, -0.31152886f, -0.05418948f, 
    -0.21362041f, -0.12311471f, 0.19675550f, -0.05017796f, -0.01963118f, 0.21385676f, -0.04566368f, 0.20063291f, 
    -0.00065763f, 0.02245061f, -0.09109766f, 0.09536029f, 0.02131264f, -0.16287439f, -0.14665677f, -0.01204208f, 
    0.11450207f, 0.06235513f, 0.02928696f, -0.15136254f, -0.02476882f, 0.05865656f, -0.00601229f, 0.07486551f, 
    0.00021273f, -0.01547156f, -0.04767779f, -0.06102252f, -0.06935517f, -0.00388805f, -0.13054892f, -0.07707648f, 
    -0.03352349f, -0.09132189f, -0.06990945f, 0.09988878f, 0.00523860f, -0.12632518f, -0.01682783f, -0.02897757f, 
    -0.11108677f, -0.11947102f, -0.12001748f, -0.04078393f, -0.09042252f, -0.02310225f, -0.06743763f, -0.05614311f, 
    0.07200340f, 0.02127880f, 0.00680760f, 0.06748939f, -0.06658823f, -0.10653725f, -0.00266037f, 0.02071751f, 
    -0.03172542f, -0.10032844f, 0.04189686f, 0.00130653f, -0.00819598f, 0.02729708f, -0.05475820f, 0.06217387f, 
    -0.03054052f, -0.10223837f, -0.03503450f, -0.07907005f, -0.10098132f, -0.15475550f, 0.08337320f, -0.09234914f, 
    -0.01562327f, -0.44551840f, 0.24994791f, 0.11057117f, -0.45405406f, 0.21291968f, -0.06465992f, -0.12504077f, 
    0.04333919f, 0.00114067f, -0.11955595f, 0.04172242f, -0.47706193f, -0.12585352f, -0.03472564f, 0.27477127f, 
    -0.10091057f, 0.27448273f, 0.30601549f, 0.28903088f, 0.07100912f, -0.42255315f, 0.09260499f, -0.11921335f, 
    -0.20638472f, -0.37045565f, -0.17601781f, 0.22375594f, -0.14438953f, -0.15962712f, 0.16839518f, -0.22391210f, 
    0.03637205f, -0.31798285f, 0.20067079f, -0.29264724f, 0.05843287f, -0.01471144f, 0.13796875f, -0.26967692f, 
    -0.30342895f, 0.07837284f, -0.02956011f, -0.02988097f, 0.08087263f, 0.32559782f, 0.11466254f, -0.17415576f, 
    0.05232054f, 0.20975018f, -0.04554656f, 0.05091780f, -0.02199454f, 0.07331524f, 0.20803604f, 0.08144434f, 
    0.09498976f, -0.08119470f, 0.22797930f, 0.06922207f, 0.14923090f, -0.25243774f, 0.01716552f, 0.28161287f, 
    -0.07184294f, 0.02057653f, 0.09235405f, -0.05114001f, -0.01851786f, 0.04984490f, 0.04735213f, 0.01209374f, 
    0.06041021f, 0.05776424f, -0.16091093f, 0.21304874f, -0.02549015f, -0.07631990f, 0.22163732f, -0.05155514f, 
    0.10432542f, -0.24815775f, -0.08683166f, 0.12958796f, 0.09530766f, -0.02126126f, 0.05411038f, 0.05274519f, 
    0.09063605f, -0.13496856f, 0.13618203f, 0.17209779f, 0.06732727f, -0.06162767f, -0.51908147f, -0.19331443f, 
    0.07740311f, -0.13123593f, -0.09759455f, -0.09711352f, 0.09812239f, 0.07944755f, 0.11126792f, -0.03770909f, 
    0.10221941f, -0.04481788f, -0.20891584f, -0.01593428f, 0.14320903f, -0.19215193f, 0.00084268f, 0.05712990f, 
    0.06966673f, -0.03113928f, 0.06495704f, 0.04462618f, 0.07700242f, -0.06487765f, -0.10754144f, -0.21446435f, 
    -0.06758924f, -0.04485306f, -0.41038376f, -0.04244713f, 0.03457303f, -0.04273122f, 0.03064273f, 0.10174244f, 
    0.11876582f, -0.04408364f, 0.10479073f, -0.27667996f, 0.10364503f, -0.17266829f, -0.18524420f, -0.00098353f, 
    -0.11205336f, 0.11766265f, 0.09188163f, 0.09733497f, 0.00439179f, 0.04624760f, 0.08373828f, 0.02877023f, 
    0.02136426f, 0.02429196f, -0.11735132f, -0.09719955f, 0.04785817f, 0.20513551f, 0.29007590f, -0.10599590f, 
    0.24464427f, -0.03098103f, -0.07269399f, -0.11551184f, -0.04851246f, 0.10900319f, -0.02613030f, -0.26296696f, 
    -0.10062255f, 0.08514939f, -0.03823620f, 0.00093373f, 0.16501531f, -0.00666343f, 0.02899206f, 0.26151708f, 
    0.04503416f, -0.25681549f, 0.13530689f, 0.11580568f, 0.08659149f, 0.04894138f, -0.07514308f, 0.08066486f, 
    -0.06502116f, -0.06279897f, 0.11241248f, 0.07075136f, 0.05034594f, 0.08060424f, -0.04777354f, -0.10841480f, 
    0.07722662f, -0.10810122f, -0.32690221f, 0.00916067f, -0.09465051f, -0.17570040f, -0.09734576f, -0.20944378f, 
    0.07811966f, -0.11153851f, -0.42330131f, -0.22815220f, -0.02227758f, -0.11037438f, 0.05470205f, -0.09051677f, 
    -0.01805371f, 0.08230691f, 0.07643441f, 0.22718985f, 0.28470972f, -0.05378400f, 0.17523438f, -0.33965427f, 
    0.10926827f, -0.06132569f, 0.04224434f, -0.11001644f, -0.04834422f, 0.25836384f, 0.18265216f, -0.03034464f, 
    0.05634559f, 0.46216851f, -0.10049096f, -0.03330018f, 0.00711719f, 0.00257810f, 0.00070310f, -0.26825914f, 
    -0.00787219f, -0.11817326f, -0.04004909f, -0.04992262f, 0.17310672f, 0.00672347f, -0.14246266f, 0.18035322f, 
    0.23178497f, -0.07586409f, -0.05640028f, 0.00325926f, 0.18042359f, -0.18043883f, 0.04683385f, 0.17245434f, 
    0.01400763f, -0.17015038f, 0.01443314f, 0.13213092f, 0.07882611f, 0.40281969f, 0.06969291f, -0.16167857f, 
    0.12626174f, -0.10757542f, -0.18092950f, 0.00136387f, 0.13971800f, -0.13961819f, -0.05446700f, -0.15266311f, 
    -0.12374024f, -0.28945309f, 0.14830597f, 0.02191035f, -0.33238384f, 0.06855210f, -0.07192036f, 0.00977766f, 
    -0.06472295f, 0.11485356f, -0.08414790f, 0.05119874f, -0.37133804f, 0.12220953f, 0.12520663f, 0.04106577f, 
    0.06672891f, 0.08664835f, 0.08379894f, 0.10526421f, 0.07907169f, -0.35748950f, -0.06984951f, 0.00177836f, 
    -0.39131451f, -0.22105259f, 0.03987850f, 0.11375014f, -0.09423501f, -0.29545307f, 0.05270985f, 0.09344192f, 
    0.07987587f, -0.06435117f, -0.02090804f, -0.06376731f, 0.00677456f, 0.00289832f, 0.08708799f, 0.08416366f, 
    -0.05612955f, 0.15998687f, -0.06057590f, -0.10063061f, -0.05317565f, 0.13170147f, 0.04228825f, -0.22717951f, 
    -0.00901119f, -0.01976164f, -0.10458861f, 0.12590785f, 0.03076749f, 0.06460688f, -0.05116691f, 0.10423087f, 
    0.13625865f, 0.12358688f, 0.15114109f, 0.04748607f, -0.13778138f, -0.22452243f, 0.03153034f, 0.21100974f, 
    0.06043915f, 0.08370122f, 0.00942801f, -0.23675345f, -0.12727678f, -0.03641399f, 0.02299521f, -0.13103056f, 
    -0.10405974f, -0.01716051f, -0.01095383f, -0.04426115f, 0.08383150f, -0.07823093f, 0.04005196f, -0.10163369f, 
    0.06257467f, -0.16134335f, -0.12467104f, -0.36687574f, -0.08767083f, 0.14741755f, -0.22355160f, -0.10566705f, 
    -0.09363350f, 0.07973068f, 0.06530982f, -0.04117643f, 0.11085346f, 0.20779352f, -0.29515910f, -0.02424217f, 
    0.09310722f, -0.00044515f, -0.14711170f, -0.01377436f, -0.17676494f, 0.14555763f, -0.06071763f, -0.05601805f, 
    0.15489896f, -0.11329207f, -0.09512855f, -0.07358059f, -0.07942148f, -0.14632580f, 0.15963328f, -0.13784976f, 
    -0.07458344f, -0.07244071f, -0.11165316f, -0.02803770f, 0.01276916f, -0.17952286f, -0.03099066f, -0.11039538f, 
    -0.06194162f, -0.07812923f, -0.24281414f, 0.11846729f, -0.05824885f, 0.20723233f, 0.02677825f, -0.08616270f, 
    -0.08124933f, 0.08446430f, 0.23261927f, 0.01099874f, -0.06335013f, 0.12050693f, -0.02198558f, -0.15274984f, 
    -0.09419650f, 0.04430097f, 0.05649599f, -0.12024704f, 0.04388937f, 0.09354144f, -0.12274212f, 0.18702325f, 
    0.04174824f, -0.06658205f, -0.16456218f, 0.32487392f, 0.11591513f, 0.00217274f, -0.18405485f, 0.03766306f, 
    -0.00924378f, -0.12561595f, -0.17249064f, 0.01599198f, 0.02625530f, -0.17653766f, -0.08704042f, 0.01693580f, 
    0.11403252f, 0.05252266f, -0.05088681f, 0.08356827f, -0.14456208f, -0.06074575f, 0.01781880f, 0.16915718f, 
    0.02472201f, 0.06512517f, -0.14999603f, -0.10043935f, -0.01975276f, -0.17380698f, -0.05597793f, -0.24433465f, 
    0.04851526f, -0.22296116f, -0.24747555f, -0.10420494f, -0.09567036f, 0.06325053f, -0.05401680f, -0.06809232f, 
    0.04602413f, 0.09318088f, -0.05653507f, 0.01828343f, -0.32613230f, 0.00235129f, 0.12368843f, -0.10863666f, 
    -0.10313650f, 0.12518504f, 0.55360949f, 0.04011633f, -0.00051254f, 0.16925704f, -0.10597119f, 0.22063310f, 
    -0.04171991f, 0.01281440f, -0.18252906f, 0.11328523f, -0.12101970f, 0.04208013f, 0.15077356f, 0.23152734f, 
    -0.03148204f, 0.41524702f, -0.25197518f, 0.15629129f, 0.10700212f, 0.08906639f, 0.02203057f, 0.09405018f, 
    0.12220496f, -0.11919095f, 0.06276507f, 0.09292738f, 0.06827348f, -0.00002792f, 0.03758030f, -0.22323908f, 
    0.10287552f, 0.27065396f, -0.03659095f, 0.13292648f, -0.10914076f, 0.17699128f, -0.08512390f, -0.11362211f, 
    -0.03408620f, 0.22633892f, -0.12953041f, 0.10371809f, -0.03931687f, 0.15971488f, -0.07748345f, -0.10625279f, 
    0.04029687f, -0.01750688f, -0.09116326f, 0.07710074f, -0.09116293f, 0.08367469f, -0.13033234f, -0.06519773f, 
    0.07790073f, 0.06129647f, 0.00441748f, -0.07639906f, 0.09311797f, -0.04952727f, -0.07063013f, 0.05158528f, 
    -0.06771894f, 0.10928740f, 0.13188037f, 0.08529562f, 0.32247797f, 0.14199363f, 0.10049968f, -0.04371808f, 
    0.08101352f, -0.10725516f, 0.25884780f, -0.04200720f, -0.11204861f, 0.04286911f, -0.11315686f, 0.14237677f, 
    0.06233814f, -0.11595184f, 0.16846885f, 0.24410807f, -0.07951857f, -0.04795596f, -0.10891137f, -0.12296282f, 
    0.19852507f, -0.18869326f, -0.01327803f, 0.12414666f, 0.15284263f, 0.07550928f, -0.13069379f, -0.05767358f, 
    -0.00558114f, -0.12382559f, 0.22271709f, -0.11594369f, 0.08326107f, -0.30078420f, -0.01363993f, 0.07128122f, 
    0.09810499f, -0.02114310f, -0.01329876f, 0.09097148f, 0.06535179f, 0.16737184f, -0.11258188f, 0.13636307f, 
    0.07339086f, 0.16136134f, 0.17056450f, 0.23519567f, -0.11981119f, -0.15223488f, -0.34314415f, 0.10248256f, 
    -0.07150782f, -0.00385302f, 0.02764537f, 0.06108375f, -0.21722820f, -0.20475228f, 0.10485047f, -0.15202849f, 
    0.01832677f, -0.02552502f, 0.35595945f, 0.02967623f, -0.18489817f, 0.17201464f, -0.25160760f, 0.10481185f, 
    -0.10227999f, -0.03015223f, 0.21124135f, 0.23995028f, -0.02779860f, 0.12027080f, -0.09444109f, 0.19993906f, 
    -0.10205253f, 0.36385494f, -0.11324479f, -0.05085251f, 0.04270484f, -0.16827554f, 0.02761384f, 0.02468597f, 
    -0.06458554f, -0.17436920f, -0.08311217f, 0.26880780f, 0.34884089f, -0.03782315f, 0.04700204f, -0.16276234f, 
    -0.01584355f, -0.04260211f, 0.20300223f, -0.04286145f, -0.15795647f, -0.10262289f, 0.13500206f, -0.10687210f, 
    -0.18459700f, 0.13489757f, 0.22904913f, 0.04204323f, -0.37175611f, 0.22274750f, 0.15258874f, -0.22507572f, 
    -0.10726754f, 0.13741285f, 0.21639428f, -0.01681477f, 0.06972498f, -0.14366156f, -0.13305095f, -0.14105153f, 
    0.01281311f, -0.06489558f, 0.22355089f, 0.02823833f, 0.13202089f, -0.14963752f, 0.06221274f, 0.10488913f, 
    -0.04186767f, -0.12923449f, -0.44085029f, -0.38270450f, -0.07530939f, -0.01856430f, 0.05807962f, -0.03301910f, 
    0.10902481f, -0.01676675f, 0.15860070f, 0.03042059f, 0.22240901f, 0.00704453f, 0.03349297f, -0.14349270f, 
    -0.11142855f, -0.09697016f, -0.05757896f, -0.21586052f, 0.09281098f, 0.30620804f, 0.13630830f, -0.06926658f, 
    0.07718056f, 0.21765454f, -0.11149760f, -0.03538596f, -0.11640038f, 0.18351024f, 0.24548781f, 0.18420720f, 
    0.03909692f, -0.15273644f, 0.02473561f, 0.16693564f, 0.14471109f, 0.04263274f, 0.02645860f, 0.27338946f, 
    -0.04047954f, -0.06745531f, 0.44836020f, 0.04759840f, -0.05206421f, 0.00714337f, -0.00839821f, 0.12056649f, 
    0.11428394f, -0.18259534f, 0.13009207f, -0.09037352f, -0.04537166f, 0.16483237f, 0.10126065f, -0.11236933f, 
    0.14869040f, 0.02479409f, -0.17014579f, -0.10670922f, 0.02060245f, -0.12945965f, -0.09702343f, 0.13998544f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.00451591f, -0.01378758f, 0.12953834f, 0.06767567f, 0.11065457f, 0.15528081f, 0.01565871f, -0.08193575f, 
    0.05928787f, 0.21515861f, 0.05631817f, 0.02054467f, 0.20397873f, 0.06008947f, -0.07163048f, 0.23890522f, 
    0.10497737f, -0.11665677f, 0.00562039f, 0.13335104f, -0.09745316f, 0.19157793f, 0.11153720f, -0.07571921f, 
    0.02493292f, 0.15365587f, -0.17153554f, 0.14084542f, 0.04779607f, -0.03379498f, 0.10150062f, -0.01934640f, 
    0.13037586f, -0.09299023f, 0.14227986f, 0.09181762f, 0.06385235f, 0.26818931f, 0.18661581f, 0.13566507f, 
    0.08878541f, -0.12526056f, -0.01088099f, 0.10597406f, 0.00534197f, 0.14449479f, 0.03275056f, -0.00991560f, 
    0.19355837f, 0.00523392f, -0.11537050f, 0.13551237f, -0.19336399f, -0.02153779f, -0.22011882f, -0.10312912f, 
    0.06596359f, -0.06366384f, -0.21309316f, 0.15172976f, -0.01316081f, 0.01803665f, 0.06535171f, 0.12980384f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.10080576f, -0.03809961f, 0.04248203f, -0.16812967f, -0.13264742f, -0.46434259f, -0.16981931f, -0.05479403f, 
    -0.04253993f, -0.32106093f, -0.43277475f, -0.02559918f, 0.07546801f, -0.07040660f, 0.00882868f, -0.27790087f, 
    -0.20949222f, 0.22622389f, 0.05300343f, 0.18113944f, 0.00613892f, -0.28720847f, -0.07664602f, -0.00341259f, 
    0.12295503f, -0.33937049f, 0.12863812f, 0.03762132f, 0.14828493f, -0.23412210f, -0.57625216f, 0.00942828f, 
    -0.44134384f, -0.01614523f, -0.11714627f, -0.05525334f, -0.40517327f, -0.16379650f, 0.22009858f, 0.04984165f, 
    -0.32349193f, -0.26342922f, -0.13208938f, 0.00251254f, 0.07110686f, -0.00746049f, -0.24845748f, -0.41038409f, 
    -0.22545889f, 0.03342105f, 0.04038824f, -0.14311114f, -0.07998148f, 0.17852059f, 0.04937574f, -0.16525115f, 
    -0.31876373f, 0.09820457f, 0.00883954f, -0.16746885f, 0.24913628f, -0.13042243f, 0.19802481f, -0.44192997f, 
    -0.29442719f, -0.62476432f, -0.03053747f, 0.21695150f, 0.34144574f, -0.27745992f, 0.14522052f, -0.04332566f, 
    0.08511747f, 0.11058243f, 0.17428258f, -0.09927883f, -0.40887752f, 0.06980702f, 0.14410028f, -0.01927509f, 
    -0.41238636f, 0.15222369f, -0.00514348f, 0.20481187f, -0.02290127f, 0.13567837f, 0.08835510f, -0.04869556f, 
    0.05972107f, -0.01787776f, -0.21430695f, 0.06051594f, 0.22605863f, -0.37441593f, -0.10297947f, 0.06961590f, 
    -0.16056724f, -0.05570151f, -0.10707776f, 0.18161614f, -0.24885544f, 0.11961821f, -0.11376521f, 0.18959445f, 
    0.04302244f, -0.22982046f, -0.07802229f, 0.08119714f, 0.17489934f, -0.01040081f, -0.10907238f, 0.10476675f, 
    0.16579334f, 0.12586389f, -0.25009957f, -0.05702736f, 0.01095232f, -0.23296216f, -0.03110609f, -0.03450362f, 
    -0.09001217f, -0.28647161f, -0.16991109f, 0.12341966f, 0.19828576f, 0.06210206f, 0.10595342f, -0.15614678f, 
    0.16728100f, -0.04883246f, -0.68029720f, -0.00236017f, -0.86624533f, 0.34492853f, 0.02768974f, -0.01585837f, 
    0.20200212f, -0.03501017f, 0.44125813f, -0.08455182f, 0.06352546f, 0.08682664f, -0.30105585f, 0.13244502f, 
    0.15472414f, 0.04725860f, 0.01656024f, -0.05686688f, -0.13356474f, 0.05866027f, -0.05608878f, -0.06172638f, 
    -0.13124804f, 0.13487333f, -0.43034953f, 0.08817758f, -0.56686848f, -0.05207325f, 0.15544713f, -0.29139841f, 
    0.05588596f, -0.06535780f, -0.11763661f, -0.42464900f, 0.20597087f, -0.31748149f, -0.08484352f, -0.00852244f, 
    0.03244586f, -0.29869455f, 0.04061022f, -0.10393868f, 0.10081828f, 0.16282550f, 0.02661583f, -0.24546622f, 
    0.31780365f, 0.06019231f, -0.41520461f, -0.10961451f, 0.01156329f, -0.17099197f, -0.00861901f, -0.03685242f, 
    -0.15030137f, -0.05438643f, 0.08483449f, -0.07817960f, 0.20984121f, -0.10068625f, 0.04467029f, 0.08529309f, 
    0.10427945f, 0.09679122f, 0.01793820f, -0.41975945f, -0.35180181f, 0.35995290f, -0.18384580f, -0.06729843f, 
    0.06414758f, -0.26379067f, 0.14706628f, -0.07048235f, -0.15294480f, -0.39274237f, -0.03479065f, -0.30004773f, 
    0.08648144f, 0.11431670f, -0.26536754f, -0.12864226f, -0.15598403f, 0.01091609f, -0.38172913f, -0.09815708f, 
    -0.05827557f, 0.29943866f, 0.36519203f, -0.25981370f, -0.18322040f, 0.16972500f, 0.03891046f, -0.07682736f, 
    -0.06241432f, 0.01795531f, -0.19659349f, -0.03296175f, 0.11033961f, -0.20586388f, 0.01100407f, -0.05324975f, 
    -0.32904968f, -0.27125245f, 0.06311822f, -0.22117420f, -0.21675515f, 0.09139421f, 0.06449576f, -0.14539401f, 
    -0.10325592f, 0.19152418f, 0.11713178f, -0.22236504f, -0.02798535f, 0.23233782f, 0.08110117f, -0.22487277f, 
    -0.31178918f, 0.06531172f, -0.44883156f, -0.29767197f, -0.07915324f, 0.21073647f, 0.19301900f, -0.17107210f, 
    -0.38198406f, 0.16576619f, 0.07413025f, -0.12645243f, -0.32840154f, -0.30634364f, -0.05037133f, -0.13119301f, 
    -0.32825366f, -0.22816297f, -0.30246109f, -0.07844900f, -0.12218413f, -0.05018530f, -0.23294894f, 0.06229569f, 
    0.19167331f, 0.00442227f, -0.15105304f, 0.01284759f, 0.01394149f, 0.08838814f, 0.22604676f, 0.03686778f, 
    0.17770864f, -0.40755495f, -0.18832953f, 0.05636354f, -0.38315403f, 0.11687461f, 0.08268331f, 0.15267009f, 
    0.26907656f, -0.01366489f, -0.14933135f, -0.05290048f, -0.17914018f, 0.02967671f, 0.17939030f, -0.02546034f, 
    -0.00846984f, 0.06788549f, 0.14744718f, 0.02098459f, 0.04011815f, 0.16726393f, -0.42249221f, 0.00635062f, 
    0.17766671f, -0.08858784f, 0.19776402f, -0.21517068f, -0.01172100f, 0.05065747f, 0.09530910f, 0.13937277f, 
    -0.19063771f, -0.11447603f, -0.09461585f, -0.16141221f, -0.07707263f, -0.08429750f, 0.01007422f, -0.13129562f, 
    0.16039312f, 0.05437492f, 0.04025319f, 0.25167701f, -0.26045009f, 0.02986772f, 0.09483027f, -0.08320863f, 
    -0.29479769f, 0.18421704f, -0.09828573f, -0.00019082f, 0.15818550f, 0.07900869f, -0.21910276f, 0.09788612f, 
    -0.43298134f, -0.18357362f, -0.03519868f, 0.11516407f, 0.02409484f, -0.35958683f, -0.03754773f, -0.10714262f, 
    -0.23378727f, -0.13032140f, -0.16098461f, 0.09991575f, 0.12566499f, 0.19188046f, -0.01540741f, 0.20839640f, 
    -0.16562083f, -0.10722204f, -0.27996540f, -0.29951793f, -0.22495504f, -0.01475588f, 0.13451459f, 0.07027636f, 
    0.15569963f, -0.13074335f, -0.08966467f, -0.02811708f, -0.07643761f, 0.02286567f, -0.23604120f, -0.19511718f, 
    -0.01028618f, 0.10849699f, 0.19318001f, -0.11904229f, -0.09377494f, -0.20911089f, -0.04838138f, -0.04431292f, 
    0.18147640f, -0.15097441f, -0.05227625f, -0.21485688f, -0.20216900f, -0.20900550f, 0.01083087f, 0.13971207f, 
    -0.36354756f, -0.36074126f, -0.44780785f, 0.08001443f, -0.09629322f, 0.19667237f, -0.11612298f, -0.01400217f, 
    0.13634764f, 0.02195083f, 0.08692461f, -0.05414009f, 0.15484740f, 0.26407883f, -0.19942968f, 0.04003565f, 
    0.21049927f, -0.47808665f, -0.12017254f, -0.67152905f, -0.08283772f, -0.13418454f, -0.47057828f, 0.05568406f, 
    -0.39138910f, -0.06153151f, -0.33158782f, 0.09507668f, -0.11409291f, -0.47906750f, 0.17943162f, -0.03647741f, 
    0.21150587f, 0.04097540f, -0.07876939f, -0.40279305f, -0.04273475f, 0.16847725f, -0.39444911f, -0.56264991f, 
    0.09689175f, 0.25739685f, 0.03966682f, 0.16252281f, 0.14882761f, 0.05045902f, 0.12657985f, -0.08922920f, 
    -0.34366816f, 0.00596714f, -0.40086687f, 0.07289657f, 0.05273319f, -0.21844894f, 0.02759249f, 0.13175233f, 
    0.04152309f, -0.13907818f, -0.02552341f, -0.09824098f, -0.43012130f, 0.22941449f, -0.75995320f, 0.13310032f, 
    0.27239510f, 0.01606108f, -0.10282136f, -0.36298275f, 0.01989539f, 0.16183347f, -0.14847183f, -0.03189515f, 
    -0.20178959f, -0.44254410f, 0.01115153f, -0.03641568f, 0.09290167f, -0.14748578f, 0.30034149f, -0.11952298f, 
    0.03354727f, -0.36433774f, -0.17972966f, 0.05120549f, -0.09009392f, 0.07661249f, 0.10362150f, -0.00862642f, 
    -0.42957383f, 0.04488017f, 0.19687265f, -0.14885710f, -0.35229060f, 0.24649201f, -0.15618709f, 0.11585911f, 
    0.08597228f, -0.04396383f, 0.14013495f, 0.16290843f, 0.23210531f, -0.01209374f, -0.40375039f, -0.43918118f, 
    0.19606975f, -0.03298629f, -0.02468895f, -0.05566156f, -0.13085388f, -0.07678451f, -0.05437904f, -0.09799463f, 
    -0.13246608f, 0.06481818f, 0.22379991f, -0.00238929f, 0.01492605f, 0.23740174f, -0.01982292f, -0.10548975f, 
    -0.28922829f, 0.13487385f, 0.05773097f, -0.09159947f, -0.05143975f, -0.17693517f, -0.46703422f, -0.02260291f, 
    0.24530917f, -0.40382653f, 0.00717929f, -0.06776404f, 0.14479974f, -0.01444757f, 0.08869398f, -0.03319459f, 
    0.11006668f, -0.08650809f, 0.17052573f, 0.04937381f, -0.03771842f, -0.31479767f, -0.01187611f, -0.08230028f, 
    -0.35445452f, 0.02959020f, -0.05042796f, -0.44923353f, -0.04900606f, 0.07939732f, -0.08866049f, -0.13649507f, 
    -0.42529103f, 0.05657510f, 0.06174355f, -0.00136511f, 0.16603640f, 0.00883345f, 0.24333887f, 0.09357268f, 
    -0.26766717f, -0.07774778f, 0.06063859f, 0.33823350f, 0.23127714f, -0.18397249f, -0.34949464f, 0.14496072f, 
    -0.11229890f, 0.20570894f, -0.03929527f, 0.00280524f, 0.04215388f, -0.60278398f, -0.00165488f, -0.20405298f, 
    0.13992381f, 0.17622113f, -0.25901696f, -0.15659033f, -0.03308047f, -0.29203936f, -0.00457322f, 0.22782610f, 
    0.29271570f, -0.20764671f, -0.19294545f, -0.19626170f, -0.01750963f, -0.34248826f, -0.45674580f, 0.06191381f, 
    -0.19889054f, 0.27526101f, -0.49932739f, 0.19847913f, -0.19447562f, -0.26840159f, -0.34070408f, -0.11266973f, 
    0.25685927f, 0.03469693f, -0.33848217f, -0.07088539f, 0.18753567f, -0.11796513f, -0.17053346f, 0.04635073f, 
    0.10494158f, -0.02462232f, -0.07103228f, 0.10770771f, -0.09264024f, 0.18020685f, -0.15878741f, -0.04604980f, 
    0.05067229f, -0.14712040f, -0.48077136f, 0.14519353f, -0.18603945f, -0.28174168f, 0.18275070f, -0.29399624f, 
    0.01640620f, -0.15953547f, 0.04723464f, -0.07490474f, 0.03912392f, 0.07877987f, 0.05469888f, 0.04059772f, 
    0.18231200f, -0.27293161f, -0.13330047f, -0.07257593f, 0.00233702f, -0.06523795f, 0.25017339f, -0.29077801f, 
    -0.33448082f, -0.44082180f, 0.17955406f, 0.30664808f, -0.13171475f, -0.09062918f, -0.12316123f, -0.34104085f, 
    -0.06934583f, -0.47095612f, -0.23550713f, -0.23758660f, -0.31884715f, -0.39011672f, -0.22937427f, 0.16638122f, 
    0.14968324f, -0.26668027f, 0.21152134f, -0.18652961f, -0.19127797f, -0.19246930f, 0.04926632f, -0.03308581f, 
    -0.05953804f, 0.10288148f, 0.04195867f, -0.00492674f, -0.36624351f, -0.24542941f, -0.20788798f, 0.23169985f, 
    -0.45473710f, 0.16875738f, -0.10229629f, -0.06989150f, 0.04259470f, -0.28240758f, -0.49479145f, -0.11431397f, 
    0.06277156f, 0.16726461f, 0.32009298f, 0.04129733f, 0.07260691f, 0.18128932f, 0.03055885f, 0.00569118f, 
    0.28391200f, -0.05034588f, 0.39121595f, -0.15629601f, 0.05894881f, -0.30746257f, -0.41399172f, -0.01677892f, 
    0.12998347f, -0.15552959f, 0.05697753f, -0.18774852f, -0.28166974f, -0.09276094f, -0.13780516f, -0.11440840f, 
    0.24710171f, -0.02628220f, -0.38659185f, 0.10453360f, 0.02310670f, -0.37705579f, -0.24816851f, -0.23553862f, 
    -0.13379939f, 0.00898641f, -0.35203543f, -0.21337950f, -0.29043281f, 0.41781819f, -0.20152791f, -0.28845790f, 
    0.03314465f, 0.09326202f, -0.18903585f, -0.36577484f, 0.04406592f, -0.29313901f, 0.28195173f, -0.03929258f, 
    0.01926461f, -0.06809522f, -0.43080291f, -0.05284862f, 0.12583809f, -0.05992563f, -0.25583667f, -0.41998866f, 
    -0.04551448f, -0.19730322f, -0.18346667f, -0.01114012f, -0.05846355f, -0.57509881f, -0.10202205f, 0.08196967f, 
    0.10573997f, 0.28695551f, 0.08500823f, 0.22556305f, -0.35574606f, 0.22041786f, -0.14227931f, -0.46895817f, 
    -0.02402154f, -0.19339946f, 0.01174987f, 0.07525576f, -0.06535313f, 0.10783861f, -0.02157752f, 0.01088023f, 
    -0.18143094f, 0.37552071f, -0.11501930f, -0.27770045f, -0.27980509f, 0.29183280f, 0.10320290f, -0.00104873f, 
    -0.08051115f, 0.06243864f, -0.13492993f, -0.02142047f, 0.01739545f, -0.38573778f, -0.47124657f, 0.25809833f, 
    0.28598922f, -0.44460756f, -0.22594315f, -0.20654179f, -0.24268664f, 0.03029638f, -0.12326227f, 0.17438027f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.10958266f, 0.04468327f, 0.08497256f, 0.04779891f, 0.05300394f, 0.08103669f, 0.04156143f, 0.04144922f, 
    -0.19205970f, -0.04257451f, 0.01450442f, -0.11547428f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
