#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.04072309f, 1.50792575f, -0.81641924f, 0.16831550f, -1.12814724f, 1.06669986f, -0.62317133f, -1.06795347f, 
    -0.38409904f, -0.36142650f, 0.24033020f, 0.14727427f, -0.00478491f, 0.13427170f, 0.06916903f, -0.02254872f, 
    -0.47817299f, 0.26605949f, 0.29148337f, 0.12566075f, 0.26290897f, -0.48482677f, -0.12362337f, -0.19125682f, 
    -0.06461387f, 1.52760565f, -0.25152984f, -0.05570761f, -0.67020893f, -0.51864552f, -0.61707139f, -0.49056861f, 
    -0.74004203f, -0.72423732f, -0.61708558f, -0.33551821f, 0.22070828f, 0.32223934f, -0.05201922f, -0.38990867f, 
    -0.57315153f, -0.31800973f, -0.70645094f, -0.23348866f, -0.04348651f, 0.07056769f, 0.57256103f, 0.22534172f, 
    -0.06311488f, 0.06253179f, 1.66070843f, 0.73487717f, 0.27915418f, 1.41973186f, 0.19726390f, 0.04829691f, 
    0.50084895f, 0.24319744f, -0.05027316f, 0.46952572f, -0.29949042f, 0.59717238f, 0.95378071f, -0.68447852f, 
    0.12453825f, -0.30633506f, -0.15576768f, 0.18411671f, -0.22977409f, 0.16707559f, -0.30132222f, 0.32105184f, 
    -0.11421091f, -0.06464633f, 0.15572383f, -1.71897185f, -0.36390337f, -0.39461756f, 0.82745802f, -0.55761057f, 
    0.75755709f, 1.70027614f, 0.06693043f, 0.63524133f, 0.74049723f, 0.00953401f, -0.57131070f, 0.20050454f, 
    -0.17906451f, -0.06309643f, 0.13521008f, 0.02653207f, 0.00616720f, -0.09824085f, -0.21417552f, 0.16755788f, 
    -0.17914049f, 0.00060824f, -0.15030611f, 0.01074897f, -0.53180063f, 1.10021603f, -1.04652250f, -0.60404372f, 
    0.85810697f, 0.56108743f, -0.43299004f, -0.48639858f, 0.93004239f, 0.39679003f, 0.30818564f, -0.39507484f, 
    -0.79728907f, 0.48499691f, -0.31748044f, 0.04765681f, 0.15485983f, 0.03084760f, 0.42156827f, -0.02843020f, 
    0.13852942f, 0.02686202f, -0.08676127f, 0.01330239f, 0.00602369f, -0.33580530f, -1.51683688f, -0.99974799f, 
    -0.80167729f, -0.36874112f, -0.64897126f, 1.54174161f, 0.78883332f, -0.71114719f, 0.26216236f, 0.02703471f, 
    -0.20650160f, -0.03290328f, -0.49271980f, 0.10811158f, -0.24626744f, 0.21909860f, -0.40497926f, -0.15182234f, 
    -0.08161520f, 0.01634597f, 0.15176068f, 0.35872018f, -0.04475015f, 0.20988503f, -0.14986549f, 0.68380874f, 
    -0.99417108f, -1.41775608f, -0.56065083f, 1.04718113f, -0.15714312f, -0.10324520f, -0.63875878f, -0.57925630f, 
    0.22380562f, -0.11514170f, 0.80488819f, 0.39670888f, -0.24295136f, -0.00386954f, 0.02239819f, -0.06633275f, 
    -0.09733262f, 0.06096866f, 0.05990542f, -0.32486132f, 0.40974218f, 0.06513593f, -0.01482654f, 1.39128649f, 
    1.52057314f, 1.26845634f, 0.53750134f, 0.65511566f, -0.63097429f, -0.70256841f, -0.07337247f, -0.16698392f, 
    0.42739776f, 0.04566228f, 0.33010477f, -0.50651598f, 0.21129584f, 0.17209971f, 0.03697937f, -0.21880567f, 
    0.18592483f, -0.17265716f, -0.19728558f, 0.55234784f, 0.43034911f, -0.00813412f, -0.05472650f, 0.36393914f, 
    -1.34304571f, 0.83432096f, 1.44193435f, -0.40397844f, 0.99250287f, 1.39019632f, -0.02390435f, -0.65411943f, 
    0.36755025f, -0.88335609f, 0.03244580f, 0.27855888f, -0.06415199f, 0.07784534f, -0.40807068f, -0.47373685f, 
    -0.06162742f, 0.10577960f, -0.34034792f, -0.05601969f, -0.00729832f, -0.11268073f, -0.28140658f, -0.10976905f, 
    -0.19736311f, 1.34987259f, -0.17503275f, 0.18751039f, 1.04245436f, 1.36194110f, 0.82479286f, -0.09870733f, 
    -1.16383719f, -0.65976095f, -0.62110931f, 0.45213208f, 0.54368168f, 0.02914407f, 0.38914350f, 0.17757675f, 
    0.20721316f, -0.07095715f, 0.37671885f, 0.48644507f, 0.43063557f, 0.05954984f, 0.15937069f, 0.38370323f, 
    0.04043112f, 0.22173990f, -0.50251412f, -0.58032072f, -1.14028108f, -1.29225290f, -0.82150340f, 0.18845727f, 
    -0.02942223f, 0.52478939f, 0.75932097f, 0.40593958f, -0.43684679f, 0.02234657f, -0.04724015f, -0.30904821f, 
    -0.43075264f, 0.06650330f, 0.09590930f, 0.26820543f, 0.20422469f, 0.23314694f, -0.32603258f, -0.15228051f, 
    -0.47481132f, -0.22633779f, -0.00607395f, 1.88799083f, 1.19557893f, -0.08844983f, -0.39143518f, -0.80891114f, 
    0.10738237f, 0.63363379f, -0.57457495f, 0.39659601f, 0.49684662f, 0.53409404f, 0.67651010f, -0.33662510f, 
    0.21125008f, 0.25952944f, 0.07019684f, 0.01207246f, 0.17615980f, -0.01576942f, 0.19250952f, -0.29682815f, 
    0.30515686f, 0.15345435f, 0.21795449f, 0.06249024f, 0.87603045f, 0.45515424f, 0.59894222f, -0.36206663f, 
    -0.23242272f, 0.13394991f, -0.32707489f, 0.41529858f, -0.04389321f, 0.42686182f, 0.52316689f, -0.29397172f, 
    -0.02124640f, 0.16471052f, 0.04810791f, 0.71386504f, 0.12811160f, -0.66078156f, 0.00575542f, 0.67292231f, 
    0.35801598f, 0.12592368f, -0.56164700f, -0.45082167f, 0.47202101f, -0.25993249f, 1.20081842f, 0.67307580f, 
    -1.12804759f, 0.14154157f, -0.20389082f, 0.87420452f, 0.74142808f, 0.61199260f, 0.90538651f, -0.22858846f, 
    0.51406807f, -0.04808569f, 0.15316670f, -0.32571352f, -0.22059532f, -0.16225146f, -0.41351530f, -0.22860825f, 
    -0.29648852f, 0.06629568f, -0.54855996f, 0.07169840f, -0.12078719f, -0.30384672f, -1.28653502f, -0.91943818f, 
    1.20649767f, 0.06882446f, -1.18536913f, 0.34000176f, 0.05213358f, 0.92054200f, -0.02147313f, -0.36782840f, 
    0.14041360f, 0.24331947f, -0.37883753f, 0.20400751f, -0.36735266f, -0.20035480f, 0.38425535f, -0.20479983f, 
    -0.11237763f, 0.01066974f, -0.02008965f, 0.06282295f, 0.29948384f, 0.19622208f, -0.08640114f, -1.26453269f, 
    0.93837029f, -0.27611610f, -0.63566869f, 0.10839979f, -0.59523159f, 0.92692256f, -0.44451207f, -0.74523282f, 
    -0.17218691f, 0.44376308f, 0.40705913f, -0.33087462f, -0.03148510f, 0.24258719f, 0.21668953f, 0.53330523f, 
    0.73895466f, -0.04204327f, -0.10010747f, 0.03625135f, 0.11708543f, 0.11684168f, 0.18253024f, 0.47085297f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.36759773f, 0.42049620f, 0.50887471f, -0.02836421f, 0.16460206f, 0.50317580f, 0.59888923f, 0.37870842f, 
    0.16589278f, -0.10215835f, 0.24730584f, 0.25432545f, 0.32303125f, 0.05873961f, 0.41460904f, 0.48345220f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.23301224f, 0.20328622f, 0.04944931f, -0.38698035f, -0.27819046f, 0.03617476f, 0.12846391f, -0.14918970f, 
    -0.07106993f, -0.05370444f, -0.07855126f, -0.03382466f, -0.33919957f, -0.07107311f, 0.13910790f, -0.00417907f, 
    -0.06106712f, 0.14700744f, -0.08024848f, 0.03286683f, -0.29564306f, 0.03918847f, 0.00598636f, 0.09427088f, 
    0.28960395f, 0.05368014f, -0.40487659f, 0.25575837f, -0.31469455f, -0.08329884f, -0.16634592f, 0.13568693f, 
    -0.03142449f, 0.16646408f, -0.03239956f, -0.03384358f, 1.00982499f, 0.57841575f, 0.11250023f, -0.07257982f, 
    0.08361533f, 0.17782523f, -0.09204463f, 0.04114534f, 0.09123354f, -0.06832871f, -0.11180083f, 0.10397530f, 
    0.34902260f, -0.08037630f, 0.68166697f, -0.15325496f, -0.00420149f, 0.08197767f, 0.07248217f, -0.22639346f, 
    -0.02549398f, 0.06814717f, -0.01066443f, -0.02089228f, -1.00023115f, 0.21852651f, 0.20786522f, -0.38885576f, 
    0.05363297f, 0.07731847f, 0.04135235f, -0.08662474f, -0.01183165f, -0.01107988f, -0.06421390f, 0.09876536f, 
    -0.22155231f, -0.10048580f, 0.27089816f, -0.48365089f, -0.20508605f, -0.19945358f, 0.02178332f, 0.05607014f, 
    -0.03807995f, 0.09677120f, -0.14637549f, 0.02683574f, 0.31813738f, -0.00293300f, 0.20367508f, -0.07215846f, 
    -0.33818933f, -0.15989642f, -0.05775173f, 0.07846017f, -0.01442431f, -0.08393669f, -0.00810496f, -0.15048559f, 
    -0.74402976f, -0.23528761f, 0.29162800f, 0.02538700f, -0.11180191f, -0.06292685f, 0.04018182f, -0.19648026f, 
    0.05130568f, 0.04278497f, -0.05570162f, 0.07731749f, 0.17833807f, -0.26483351f, 0.17967124f, 0.17530473f, 
    -0.35237169f, -0.03411457f, -0.10388462f, 0.27517024f, -0.08816341f, -0.04517345f, -0.06429274f, -0.11795264f, 
    0.15715723f, -0.01125802f, -0.19476163f, -0.84431189f, 0.24285647f, -0.00964611f, 0.19055626f, 0.02601536f, 
    -0.03265389f, -0.04125223f, 0.04549315f, 0.09322680f, -0.20832609f, -0.08323593f, 0.03444700f, -0.22494610f, 
    -0.00620215f, 0.01419154f, -0.14864005f, 0.13810267f, 0.01156863f, 0.02010255f, -0.00994835f, -0.05088693f, 
    0.03241374f, -0.17662758f, -0.14358576f, -0.33708116f, 0.08497927f, -0.02420108f, 0.12610453f, 0.24858828f, 
    -0.01122944f, 0.03541880f, 0.02041679f, -0.06842979f, 0.04394979f, -0.14033455f, -0.01742980f, -0.26110333f, 
    -0.11044186f, -0.12294544f, -0.01383237f, -0.12700343f, 0.24238078f, -0.12711079f, 0.16646826f, -0.21359560f, 
    -0.64191031f, 0.15700959f, 0.12043089f, 0.34619465f, -0.16639769f, 0.08008336f, 0.02971234f, 0.06466917f, 
    0.07446372f, -0.00209171f, 0.14475329f, -0.22549820f, 0.01397901f, -0.24754679f, 0.11480433f, -0.10546783f, 
    0.14479432f, -0.07060361f, 0.05303242f, 0.22955017f, 0.05627203f, -0.10934303f, -0.10237708f, 0.03672552f, 
    -0.55569255f, -0.47111312f, -0.08585477f, -0.05486863f, -0.07681265f, -0.05876471f, -0.14081889f, -0.03397689f, 
    0.03401665f, 0.22259930f, 0.01337882f, -0.04890186f, 0.20518714f, -0.41549763f, 0.01867864f, -0.42605969f, 
    0.10448316f, -0.14901558f, -0.07712412f, 0.02289642f, 0.03911255f, 0.12848006f, -0.11358787f, -0.30947360f, 
    0.46250743f, 0.22663531f, 0.31459904f, 0.57894701f, -0.01646711f, 0.15844056f, 0.02730353f, 0.01624911f, 
    0.08655029f, -0.14228193f, -0.08432238f, -0.17596343f, -0.36567923f, 0.06052735f, -0.29505348f, 0.03453494f, 
    0.07272218f, 0.01726784f, 0.06614229f, -0.00506763f, 0.07422742f, 0.15899913f, -0.01502351f, -0.00731022f, 
    -0.42062679f, -0.13901345f, -0.15648310f, -0.24467267f, 0.03478381f, -0.10036166f, -0.08053631f, 0.15456527f, 
    0.15575665f, -0.01602359f, -0.05317685f, -0.20846614f, 0.68842345f, -0.24260575f, -0.32291612f, -0.07539804f, 
    -0.20669237f, -0.01794605f, -0.11672275f, 0.08841295f, 0.05949907f, -0.01306018f, -0.21767484f, -0.25649485f, 
    -0.00302957f, -0.25755072f, 0.19174215f, -0.42568159f, 0.21273370f, -0.01957836f, 0.32419738f, 0.00068759f, 
    -0.00657575f, 0.03116314f, 0.18631335f, -0.10137970f, 0.24369200f, 0.01528085f, 0.03851601f, 0.29677770f, 
    -0.12748215f, -0.00135743f, 0.14449155f, 0.05306238f, 0.01490140f, -0.12114026f, -0.07644202f, 0.15143929f, 
    -0.07206494f, 0.00130831f, -0.12675504f, 0.01966806f, 0.00258377f, 0.06156331f, -0.08548392f, -0.14648259f, 
    -0.24979852f, 0.08001265f, -0.01957497f, -0.13396183f, 0.24061283f, -0.30597782f, 0.36851129f, 0.12462831f, 
    -0.08805496f, -0.05236848f, -0.08223321f, 0.08800248f, 0.08328261f, 0.15679160f, -0.05428077f, 0.04501364f, 
    -0.05163087f, -0.10063046f, 0.19662239f, -0.51440054f, 0.22292191f, 0.13481444f, 0.01307494f, 0.08966104f, 
    0.06484086f, 0.01111860f, 0.15706141f, 0.02504852f, 0.78062117f, -0.10618273f, 0.12420297f, -0.25668842f, 
    -0.12613031f, -0.20170017f, 0.11594501f, -0.16934513f, -0.36420909f, 0.02876243f, -0.03836332f, 0.20466390f, 
    0.12127130f, 0.12923025f, -0.07188944f, -0.04367744f, -0.08260477f, -0.20412193f, -0.09740826f, -0.11428195f, 
    -0.17263347f, 0.09186386f, 0.11375389f, 0.15402368f, -0.32236481f, 0.54779375f, 0.14196421f, -0.05722858f, 
    -0.10911469f, 0.02269063f, 0.09431207f, -0.08183731f, 0.12057061f, -0.02797879f, 0.07035296f, -0.05051745f, 
    -0.71202081f, 0.16589841f, -0.49119061f, 0.27182910f, -0.14377905f, -0.22760573f, 0.20074195f, 0.10308629f, 
    -0.18391924f, -0.18707728f, -0.17789781f, 0.18265697f, -0.40127820f, 0.28182232f, -0.85572243f, -0.27252761f, 
    -0.21756804f, 0.25877768f, -0.00196909f, -0.00294888f, 0.17412543f, -0.00089034f, 0.25596985f, 0.19603173f, 
    -0.28992537f, -0.19819546f, -0.21475008f, -0.71057028f, 0.13322034f, -0.17373399f, 0.24433513f, 0.02000031f, 
    0.01982519f, -0.08628785f, 0.02531080f, -0.04512418f, -0.89230180f, 0.49376452f, -0.34697562f, -0.60955763f, 
    0.09630776f, 0.00450693f, 0.23037989f, -0.17671819f, -0.10588729f, 0.23819283f, -0.21220453f, 0.02240449f, 
    0.03474053f, 0.09087278f, 0.04533905f, -0.06298524f, -0.01166184f, 0.14101638f, 0.08356297f, 0.04173910f, 
    0.13232495f, 0.14977729f, 0.15305829f, 0.00120770f, 0.59531581f, 0.14709377f, 0.16506253f, 0.07413543f, 
    -0.12106153f, -0.04901009f, -0.01634890f, 0.16159514f, -0.00692424f, 0.13092102f, -0.07953471f, -0.28341177f, 
    0.16511446f, -0.08124775f, -0.04763673f, 0.04343062f, 0.01958550f, 0.08813470f, 0.28890911f, -0.02062945f, 
    -0.09806789f, -0.01456865f, -0.00676784f, -0.16636755f, 0.79995841f, -0.11184097f, 0.03012273f, 0.42206541f, 
    -0.30394605f, -0.24220207f, -0.20563357f, -0.02745516f, 0.16021366f, 0.01111491f, -0.02645867f, 0.31908014f, 
    -0.66135895f, 0.07612804f, -0.01805389f, -0.33070269f, -0.01223399f, -0.10077955f, -0.06972823f, -0.07802643f, 
    -0.14502557f, 0.06940400f, -0.16050042f, -0.29361552f, -0.39386976f, 0.06677412f, -0.19432665f, -0.19726740f, 
    0.06724732f, 0.14645213f, 0.08461710f, -0.28874505f, 0.00145947f, -0.00261914f, 0.07009728f, -0.06624778f, 
    0.50870031f, -0.16649581f, -0.00622496f, 0.21788263f, -0.08300721f, 0.08781838f, 0.21513160f, -0.23503943f, 
    -0.19159235f, -0.04505821f, -0.18847443f, 0.10547873f, 0.13259748f, -0.30481327f, 0.16630960f, -0.13775384f, 
    0.19254677f, 0.06277651f, 0.03048744f, -0.13150102f, -0.14571674f, 0.00478695f, -0.07050541f, -0.16374251f, 
    -0.15256773f, 0.24243072f, 0.05100169f, 0.62897086f, -0.15903106f, -0.36964849f, 0.18596032f, 0.09316272f, 
    0.07261702f, -0.10016730f, -0.07799429f, -0.10861853f, 0.25525388f, -0.08693411f, 0.31747577f, -0.30160797f, 
    -0.02909323f, -0.04105480f, 0.17747171f, 0.02603759f, -0.09050236f, -0.13008086f, 0.18330312f, -0.10928604f, 
    -0.37671813f, 0.26790243f, 0.01237822f, 0.05117856f, -0.00940311f, -0.02104377f, 0.10420448f, -0.05918577f, 
    -0.16896294f, -0.28702039f, -0.07404688f, 0.03694489f, 0.54245704f, 0.08358882f, -0.27330098f, -0.19491236f, 
    -0.31928504f, 0.04442498f, 0.07702678f, 0.08968497f, -0.10009070f, -0.02381736f, 0.17786698f, -0.16564657f, 
    0.12308675f, -0.05171251f, -0.16682430f, -0.31985590f, -0.17059207f, -0.08797421f, -0.06806722f, -0.11257649f, 
    0.19675505f, 0.12625441f, -0.03115124f, -0.26520535f, 0.42055264f, -0.22803064f, -0.20009966f, -0.35868216f, 
    0.12032604f, -0.05730195f, -0.14172116f, -0.08123306f, -0.11432692f, -0.14648335f, -0.09699420f, -0.15422799f, 
    0.70430297f, 0.18113059f, -0.25354579f, 0.21284251f, 0.02339963f, 0.22432248f, 0.10934538f, 0.27046460f, 
    -0.00552705f, -0.01420466f, -0.09067205f, 0.11150617f, 0.18910974f, 0.11467687f, 0.31267026f, 0.03669823f, 
    0.04350020f, -0.03342297f, -0.01947170f, 0.26062083f, 0.05131484f, 0.15618904f, 0.10660177f, 0.07129375f, 
    -0.24368866f, -1.02388465f, -0.55381709f, -0.05542372f, 0.04181300f, -0.27558789f, -0.14777680f, -0.04088265f, 
    0.18635407f, 0.05262778f, -0.06628058f, -0.06527735f, -0.36270824f, 0.29670033f, -0.13230637f, -0.25401929f, 
    -0.09753371f, -0.14497986f, 0.07771086f, -0.03395900f, -0.02255502f, -0.09445449f, 0.04793242f, -0.31769896f, 
    0.72709590f, 0.34815690f, -0.23969361f, -0.21657774f, -0.07874458f, -0.08828636f, 0.14609744f, -0.16841689f, 
    0.03283644f, -0.14269154f, 0.02487709f, -0.12334131f, 0.25528568f, -0.12537782f, 0.15406367f, 0.11360435f, 
    -0.13254699f, -0.16589102f, 0.01347951f, 0.02669292f, -0.12107158f, 0.04512710f, -0.05134831f, 0.24157076f, 
    0.31257093f, 0.06658977f, -0.02042405f, -0.01704348f, -0.02514314f, -0.11262480f, 0.14045852f, -0.02002618f, 
    -0.00723167f, -0.07902277f, -0.16682002f, -0.06301837f, -0.79487920f, -0.97934705f, -0.54052442f, 0.42052501f, 
    -0.25500154f, 0.02960121f, -0.02768950f, -0.19653234f, -0.07977147f, -0.05286518f, -0.04773614f, -0.10532250f, 
    0.94987458f, -0.19520970f, -0.07917910f, 0.24453662f, 0.17979091f, -0.00342608f, 0.04173429f, 0.17581201f, 
    0.01316945f, 0.06821417f, -0.07533600f, -0.06669622f, -0.19239786f, -0.24269366f, 0.27802575f, 0.50753158f, 
    0.37498301f, 0.32569575f, 0.08338099f, -0.01905519f, -0.12887049f, -0.23238346f, -0.07894308f, 0.01530745f, 
    -0.15047942f, 0.07357357f, -0.11120177f, -0.33133331f, -0.47026771f, -0.08379127f, -0.01839245f, -0.02727373f, 
    -0.15540019f, -0.07068510f, 0.05143425f, 0.23740295f, -0.46889117f, -0.76518530f, -0.32153586f, -0.14620736f, 
    -0.26645356f, -0.09062190f, -0.14909570f, 0.38880423f, -0.05184385f, 0.04521056f, -0.06450241f, -0.03189442f, 
    -0.29040754f, -0.02483253f, 0.08272264f, -0.00166769f, -0.09730335f, 0.07411387f, -0.10335739f, 0.06066485f, 
    0.04316344f, 0.11636804f, 0.10958184f, -0.11643490f, -0.56124365f, 0.15404706f, 0.01471038f, -0.42425334f, 
    0.04327964f, 0.01201278f, 0.02129941f, -0.00160394f, -0.03452715f, 0.10559674f, -0.02178256f, 0.31089547f, 
    0.28385317f, 0.20694105f, 0.22064336f, -0.38870549f, -0.29579204f, 0.03246834f, -0.14752422f, 0.13313507f, 
    -0.15628280f, -0.02574407f, 0.18364333f, 0.10322407f, -0.20716262f, 0.42723387f, 0.19234590f, -0.00029941f, 
    0.07065808f, -0.15312859f, -0.09303805f, 0.01854683f, -0.05296055f, -0.25137809f, -0.12287582f, 0.06970698f, 
    -0.32509536f, -0.13110042f, 0.25274917f, -0.17468633f, 0.07629862f, 0.19617300f, 0.03234868f, -0.08590826f, 
    -0.11342376f, 0.02766520f, 0.01012296f, 0.01343497f, -0.08823885f, -0.38641563f, 0.16773237f, -0.03364835f, 
    -0.07299341f, 0.18886121f, 0.03371875f, -0.16859551f, -0.00984810f, 0.07860097f, 0.03492618f, 0.16567104f, 
    0.18911389f, -0.26965529f, 0.00704358f, 0.02283333f, -0.21092020f, -0.16955963f, 0.05629848f, 0.08333849f, 
    -0.03059975f, -0.00036068f, -0.08977012f, -0.07471208f, -1.12404072f, -0.08655334f, -0.07732935f, 0.02214288f, 
    0.06473169f, 0.07279097f, 0.03508599f, 0.07418943f, 0.03205564f, 0.04118512f, 0.03096697f, 0.00099277f, 
    0.40764394f, -0.04677626f, -0.42249510f, -0.02291928f, -0.27193022f, 0.20554070f, -0.11093906f, 0.03098633f, 
    0.03251083f, -0.03364606f, 0.18041341f, 0.04427674f, -1.02266121f, 0.04880033f, 0.20051455f, -0.00649083f, 
    -0.00342598f, 0.02321840f, 0.06696240f, 0.04869553f, -0.10137645f, -0.24930318f, 0.11100388f, 0.02099914f, 
    0.26216927f, 0.05815234f, -0.18519200f, 0.08168558f, 0.11655431f, -0.07519564f, 0.15227644f, 0.15035658f, 
    -0.23724930f, 0.00396405f, -0.09497201f, -0.00379028f, -0.18105461f, -0.15315746f, 0.18001908f, 0.24336667f, 
    -0.36721537f, -0.11973371f, 0.10328912f, -0.05497611f, 0.22058865f, 0.10856005f, 0.10725062f, -0.00656157f, 
    0.30384767f, 0.80274349f, -0.38985071f, -0.47573161f, -0.05735792f, 0.09649745f, 0.00761989f, 0.13769887f, 
    0.00633281f, -0.10644464f, 0.07746486f, 0.00707794f, -0.37665620f, 0.18831091f, 0.21548495f, 0.08958638f, 
    0.13468136f, -0.00402926f, -0.12224159f, -0.00731763f, 0.10526871f, -0.22024621f, -0.04512104f, -0.00544344f, 
    0.05161702f, -0.27215132f, 0.25286335f, 0.55068755f, -0.11178011f, -0.07607038f, 0.03499079f, 0.15313254f, 
    -0.08342809f, 0.17381170f, 0.20326522f, 0.07576844f, -0.37480727f, -0.27402535f, -0.01699880f, -0.30538851f, 
    -0.13872525f, -0.01738188f, -0.01784934f, 0.13786267f, 0.11661130f, -0.05692274f, -0.03648175f, 0.05260591f, 
    0.13013092f, -0.54364353f, 0.00196904f, -0.06320995f, -0.18565276f, -0.04259445f, -0.13279410f, -0.12718974f, 
    -0.08420448f, -0.06498829f, -0.21274918f, -0.46523887f, -0.00871814f, -0.03265754f, 0.12488775f, 0.30692324f, 
    0.08076711f, 0.02495047f, 0.13677658f, 0.10341658f, 0.02738986f, 0.15807335f, -0.01834598f, 0.12995671f, 
    0.28772488f, -0.18908499f, 0.17206576f, -0.50059670f, -0.02213383f, 0.23617159f, -0.24899292f, 0.11258356f, 
    -0.10436767f, -0.11215973f, 0.06583700f, 0.09000833f, -0.09191795f, 0.12243602f, 0.53316659f, -0.08163998f, 
    0.03287179f, 0.13404633f, 0.16823080f, 0.02899072f, 0.05676027f, 0.17150088f, -0.19139765f, -0.14842561f, 
    -0.30332220f, 0.20705646f, -0.11329280f, -0.02544405f, 0.02541960f, -0.03118738f, -0.05116686f, 0.12446123f, 
    -0.04159936f, 0.06226976f, 0.17897832f, 0.01164876f, 0.27829659f, -0.04429324f, 0.19947700f, 0.53241032f, 
    -0.07971659f, -0.19378126f, 0.12471466f, 0.16468471f, 0.01610359f, -0.25672331f, -0.06954651f, -0.23426618f, 
    -0.09127174f, -0.13885398f, 0.28992456f, -0.26692578f, -0.09321196f, -0.03327622f, 0.15987277f, 0.01391892f, 
    -0.06000173f, -0.16207089f, 0.12821637f, 0.16737323f, -0.78296095f, 0.07226393f, 0.02213920f, -0.06625783f, 
    0.02991663f, -0.05935489f, 0.08943324f, -0.21970780f, -0.00780096f, -0.33950204f, -0.05373110f, -0.10203549f, 
    0.34884378f, 0.05151291f, -0.02739792f, -0.17430530f, -0.06534306f, -0.22883824f, -0.00885008f, -0.06851423f, 
    -0.13459340f, 0.02556206f, -0.12815705f, 0.05222822f, -0.66499507f, -0.21197556f, -0.45762283f, -0.05566027f, 
    0.15599290f, 0.20672038f, 0.15341005f, 0.13318139f, -0.03741972f, 0.33847752f, -0.10640412f, 0.02391818f, 
    -0.53843099f, -0.23852928f, -0.07836634f, 0.36280507f, -0.08315614f, 0.14420477f, -0.17260849f, -0.02432443f, 
    0.24936873f, 0.09399761f, 0.25696135f, -0.03281991f, 0.10389376f, 0.19564104f, 0.21205364f, 0.10040390f, 
    -0.17945689f, 0.00872667f, -0.11065466f, 0.27968869f, -0.14651135f, 0.00041462f, 0.11782830f, 0.02459131f, 
    -0.38919604f, -0.49205005f, 0.47951028f, 0.39150190f, 0.01948688f, -0.03935299f, -0.09284733f, -0.05666133f, 
    0.02824266f, 0.10194299f, -0.08292720f, -0.05508587f, -0.01257178f, 0.03209544f, -0.00768387f, -0.01685831f, 
    -0.09895869f, 0.05359136f, 0.06850291f, -0.15019655f, 0.08422138f, -0.05483662f, 0.23443511f, 0.46531397f, 
    0.16029675f, -0.13614164f, -0.48209524f, 0.08527687f, 0.24813348f, 0.10155988f, -0.42268625f, -0.27737802f, 
    -0.08170909f, 0.00061428f, -0.09830597f, 0.03777979f, 0.02409096f, 0.05288670f, -0.27857831f, 0.03465788f, 
    0.06427610f, 0.01027232f, 0.18649355f, -0.10936266f, -0.02501729f, -0.08796395f, -0.01433189f, -0.09058415f, 
    0.33395064f, 0.11479437f, 0.02730708f, 0.09029775f, 0.08652481f, -0.00112802f, -0.14579096f, -0.20440403f, 
    0.21915646f, 0.35899669f, -0.11016688f, 0.31437436f, 0.43780023f, -0.00104960f, -0.04111902f, -0.23028731f, 
    -0.05500022f, -0.25168815f, -0.18490565f, -0.06126458f, -0.16384596f, 0.06429998f, -0.30591124f, -0.09761516f, 
    -0.64925617f, -0.32893366f, -0.42561698f, 0.17159235f, 0.23349766f, -0.06036319f, 0.07550212f, 0.03543009f, 
    0.12606941f, 0.03679218f, -0.09820357f, 0.08552180f, -0.13397300f, -0.41552669f, 0.24601413f, 0.20113301f, 
    -0.09146208f, -0.11037364f, 0.01029926f, 0.11105257f, 0.30379930f, 0.00858579f, -0.02647142f, 0.13705803f, 
    0.48811916f, -0.11038465f, 0.32409278f, 0.75377917f, 0.16477786f, 0.15435122f, -0.06707339f, 0.20409356f, 
    -0.03180080f, -0.26369444f, -0.15393162f, 0.13080840f, -0.21200560f, -0.14563380f, -0.50140703f, -0.28238451f, 
    0.14985812f, 0.06118089f, -0.11922901f, -0.09607593f, 0.02319768f, -0.13845475f, 0.20285001f, 0.06060946f, 
    -0.25641096f, 0.36462140f, 0.20967841f, -0.19568464f, -0.18668737f, -0.01894179f, -0.19316980f, 0.11709923f, 
    -0.14078090f, 0.11901984f, 0.18193392f, 0.06573767f, 0.26220602f, -0.66199976f, 0.03994619f, -0.15910174f, 
    -0.13568403f, 0.02651428f, 0.06968079f, -0.02092284f, 0.03873110f, -0.00291551f, 0.14255020f, 0.28156513f, 
    -0.65548187f, 0.02623975f, 0.16340443f, 0.13244337f, -0.06692865f, -0.01803748f, -0.11390015f, -0.17944044f, 
    0.01584905f, 0.18233243f, -0.06020880f, 0.06513416f, 0.14795250f, -0.12232986f, -0.04784774f, -0.42740017f, 
    0.05171630f, 0.09752750f, 0.00906618f, -0.19711736f, -0.01353373f, -0.19618049f, 0.30102751f, 0.08408845f, 
    0.46734494f, -0.04388252f, -0.22953279f, 0.23491640f, -0.12582013f, -0.03335859f, 0.04142965f, -0.10599915f, 
    -0.27018625f, 0.00720295f, -0.14192247f, 0.07093360f, -0.18039560f, 0.47913080f, 0.12286630f, -0.34551984f, 
    0.07323453f, 0.07089098f, -0.04998279f, 0.03298570f, 0.06945769f, 0.04312901f, -0.02250403f, 0.22032294f, 
    0.51515788f, -0.34726202f, -0.10143115f, 0.06859306f, -0.14845246f, -0.00515412f, 0.09042228f, 0.24883053f, 
    0.10000474f, 0.20111075f, -0.11404006f, 0.17690136f, 0.18221797f, 0.09199440f, -0.08684406f, -0.53213549f, 
    -0.02546617f, 0.14784224f, -0.01303526f, -0.02092146f, 0.02523891f, -0.07903030f, -0.09088305f, -0.33627748f, 
    -0.54589295f, -0.23887014f, -0.37542361f, -0.12923294f, 0.00808168f, -0.16342995f, 0.30550820f, -0.03653786f, 
    0.27980769f, -0.01419926f, 0.01093897f, 0.01144178f, -0.89803445f, 0.20150000f, 0.02283662f, 0.56286740f, 
    0.08955415f, 0.04557692f, -0.10796890f, 0.08586043f, 0.01893912f, -0.10154335f, -0.10002322f, -0.32590115f, 
    -0.45717943f, 0.17999846f, -0.18206018f, 0.09087815f, -0.00040850f, 0.32504502f, 0.10860160f, 0.06310946f, 
    -0.00109522f, -0.19661583f, 0.20304677f, -0.48099333f, -0.62869215f, -0.18053877f, 0.11046755f, 0.43662518f, 
    -0.02088743f, -0.05645347f, -0.04376951f, 0.07350779f, 0.14864193f, -0.05055947f, -0.04000425f, 0.20584691f, 
    0.09549172f, -0.29957616f, -0.26533544f, 0.02940997f, -0.08191441f, 0.07828924f, 0.02544547f, -0.16419479f, 
    -0.05555485f, -0.01954753f, 0.08581056f, -0.04184714f, -0.14730190f, -0.26747477f, -0.14709616f, 0.25295722f, 
    0.18676259f, -0.09903794f, -0.05230611f, -0.04774277f, -0.16630173f, -0.07873154f, -0.33615807f, -0.13703032f, 
    -0.13546821f, 0.41584277f, -0.27778074f, 0.46784794f, -0.15777266f, -0.36622214f, -0.08896887f, 0.10530806f, 
    -0.11116624f, -0.03514208f, -0.01146714f, -0.15829629f, -0.06341681f, -0.05172267f, -0.30527940f, 0.39733377f, 
    -0.30858094f, -0.15209822f, -0.06060085f, -0.15532923f, -0.41854379f, -0.26257226f, 0.06075567f, 0.13217217f, 
    -0.54044074f, 0.33279377f, -0.03805090f, -0.33793849f, 0.08924093f, 0.07748114f, -0.12346893f, -0.09839554f, 
    -0.07216280f, 0.02688897f, -0.08605022f, -0.07561847f, -0.08750746f, 0.26294437f, 0.20105000f, 0.01987357f, 
    0.14200629f, -0.11494374f, -0.03409652f, 0.06726515f, -0.05329043f, -0.00446809f, 0.15490566f, -0.04912656f, 
    -0.31816804f, 0.18933171f, -0.33146694f, -0.13497938f, 0.11692680f, -0.08149693f, -0.06189305f, -0.08016068f, 
    0.07192468f, -0.07471063f, 0.09395485f, -0.01411170f, 0.37064922f, 0.25558516f, 0.45652178f, 0.05825623f, 
    0.19446307f, 0.16506456f, 0.04794347f, 0.05862946f, -0.05850000f, 0.07493172f, -0.16070251f, 0.02129309f, 
    0.15215150f, 0.47775736f, 0.01951692f, 0.34293675f, 0.13395007f, -0.21164097f, -0.17368419f, 0.03452834f, 
    -0.04736293f, -0.11778679f, -0.19845368f, -0.02260600f, -0.39818168f, -0.19471376f, -0.34868968f, -0.45652187f, 
    0.08827464f, -0.13292436f, -0.05810938f, -0.16127020f, -0.20697746f, 0.10801776f, -0.04405256f, -0.10809937f, 
    -0.38100517f, 0.41122857f, -0.01203098f, -0.31801650f, -0.01125904f, -0.15724987f, 0.08780809f, -0.06825116f, 
    -0.17881994f, -0.03116497f, 0.06328784f, -0.27652359f, -0.55870616f, 0.20477164f, -0.30109841f, 0.17627306f, 
    -0.12382200f, -0.23464966f, -0.03785730f, -0.09783737f, 0.01251515f, -0.03953024f, -0.20959379f, -0.06148878f, 
    0.10179896f, 0.22994438f, 0.08987446f, 0.43739054f, 0.40925151f, 0.12883422f, 0.32807896f, -0.02114496f, 
    -0.09855080f, 0.16912054f, -0.09770933f, -0.24033009f, -0.62558681f, 0.13464271f, -0.48384827f, -0.15102367f, 
    -0.06174246f, 0.05562305f, -0.23728606f, 0.02799323f, 0.07383942f, 0.03353762f, 0.00893251f, 0.01947285f, 
    -0.53641719f, -0.14820702f, -0.30633265f, -0.22971387f, -0.07046085f, 0.07991842f, -0.04214562f, -0.04098915f, 
    0.18111588f, -0.22680587f, -0.02915969f, -0.25901020f, -0.02916558f, -0.11476706f, 0.00761490f, -0.04665824f, 
    -0.13377984f, -0.12253694f, 0.04251500f, -0.18489213f, 0.09517923f, -0.28464782f, -0.11187967f, -0.03304183f, 
    0.31228220f, 0.18671769f, 0.20646206f, 0.40739551f, 0.40554765f, 0.22482593f, 0.05657946f, -0.14814425f, 
    0.04403203f, -0.07578676f, 0.03784195f, -0.22829461f, 0.19768843f, 0.14432266f, 0.47112578f, 0.23061709f, 
    0.25244316f, -0.20423637f, -0.11192340f, 0.07656483f, -0.15146144f, -0.08847640f, -0.11583760f, 0.00137110f, 
    0.07736309f, 0.06321143f, -0.68573952f, -0.21786575f, -0.09168166f, -0.37658620f, -0.47857755f, -0.06428818f, 
    0.11303107f, -0.10605141f, 0.06867355f, -0.05865713f, -0.12117677f, -0.19069554f, -0.32493767f, -0.62969083f, 
    -0.05689053f, -0.15975761f, 0.15677977f, -0.03447958f, 0.30631921f, 0.10748427f, 0.01280297f, -0.44168335f, 
    0.51506710f, 0.03132926f, 0.13740458f, 0.15515743f, 0.23601079f, -0.01163745f, -0.07389371f, -0.17483303f, 
    -0.06763016f, 0.04564590f, 0.21824291f, -0.12314342f, 0.29793769f, -0.47316134f, 0.37401977f, 0.21056272f, 
    -0.24692781f, -0.20359145f, -0.31195405f, -0.10503641f, -0.03430772f, -0.36591578f, -0.09857534f, -0.17594923f, 
    -0.29647565f, 0.06130814f, -0.00370214f, 0.00022874f, 0.08714520f, -0.02418414f, -0.33577189f, 0.11375999f, 
    0.05896401f, -0.13541381f, 0.08496927f, 0.01507306f, -0.54086256f, 0.17696205f, 0.07552753f, -0.15534399f, 
    -0.12696706f, 0.18330181f, 0.18916608f, -0.05090353f, -0.01053935f, -0.00318149f, -0.29789937f, 0.07086701f, 
    -0.21945615f, 0.61682725f, -0.35347718f, -0.20826523f, 0.11021223f, -0.04916769f, -0.17520854f, -0.05141856f, 
    0.09256574f, -0.20412105f, 0.34623843f, -0.08095825f, -0.35681713f, -0.43250182f, -0.00423400f, 0.12685339f, 
    0.14382610f, 0.17177406f, -0.07404637f, -0.02756699f, 0.12583236f, -0.03420260f, 0.23922141f, -0.09757014f, 
    0.15447974f, -0.32312870f, -0.06621724f, 0.01376147f, 0.11752848f, -0.05820791f, -0.22174558f, -0.04781739f, 
    0.29871482f, 0.04685307f, -0.09031939f, -0.12150452f, -0.26454264f, -0.11381286f, -0.16837656f, 0.14312600f, 
    -0.07064375f, 0.12184111f, 0.13202856f, -0.43275258f, 0.08224946f, 0.15064487f, 0.11077626f, 0.13597347f, 
    -0.52989680f, 0.23626408f, 0.18471037f, -0.01732904f, -0.20440835f, 0.12835719f, -0.31341624f, 0.05532234f, 
    0.04384114f, -0.06437042f, -0.06350506f, -0.11959646f, 0.40365231f, 0.23311621f, -0.39589244f, 0.05968061f, 
    0.02523378f, -0.11308891f, -0.05365287f, -0.17522418f, 0.00245548f, -0.16878970f, -0.01086747f, 0.26764983f, 
    0.11840247f, 0.25422555f, -0.11386321f, -0.11225086f, -0.08636118f, 0.08340066f, -0.12182127f, -0.05127260f, 
    0.11718491f, 0.22927299f, -0.10495694f, 0.11373544f, 0.53685659f, 0.24549162f, -0.10294981f, 0.26127470f, 
    -0.07376542f, -0.00881388f, -0.27389780f, 0.00181855f, -0.22659209f, 0.15682711f, -0.00166798f, 0.20452748f, 
    -0.11916818f, -0.12420415f, 0.49283949f, -0.19996159f, -0.12370608f, -0.02247090f, 0.31695592f, -0.09505646f, 
    -0.07329614f, -0.08822257f, -0.14098118f, 0.18910688f, -0.25234148f, 0.06841586f, -0.32743949f, 0.06942742f, 
    -0.19251956f, 0.21377435f, 0.06858225f, -0.11787234f, 0.05426427f, 0.18789206f, 0.19078073f, 0.37994075f, 
    -0.62970644f, 0.02279916f, 0.43355104f, -0.38075963f, 0.04513438f, 0.03125955f, 0.09618873f, -0.20891193f, 
    0.00247737f, 0.04659255f, -0.02519425f, 0.08196321f, 0.06569491f, 0.34264544f, -0.39341348f, 0.24736165f, 
    0.02850782f, 0.16186948f, 0.03637807f, -0.15308243f, -0.09623844f, -0.04670184f, -0.04710743f, 0.33048451f, 
    -0.60825235f, 0.22457936f, -0.30556175f, -0.19912706f, 0.09720797f, -0.00504313f, 0.11759584f, 0.00088468f, 
    0.11137114f, -0.00409721f, 0.01373509f, 0.15091069f, 0.01869007f, -0.39186782f, -0.07196035f, 0.13980208f, 
    0.26221663f, -0.05306770f, -0.28832525f, -0.05455407f, 0.13576300f, 0.22971962f, 0.04339976f, 0.00987012f, 
    -0.60298300f, -0.14898077f, 0.13168024f, -0.07541271f, -0.12046760f, 0.13648997f, 0.17404848f, 0.16067070f, 
    -0.26133013f, -0.13520736f, 0.00058086f, 0.02055393f, -0.15241832f, -0.06261808f, -0.31243414f, 0.23856723f, 
    0.22735968f, 0.12228336f, -0.15807000f, 0.02887236f, -0.14127722f, 0.12428752f, -0.03146920f, -0.07504717f, 
    -0.52273601f, -0.22518604f, 0.39362136f, 0.13016109f, 0.00567179f, 0.20447250f, -0.33674896f, 0.13515575f, 
    0.20196143f, -0.14745699f, 0.07798064f, 0.06313321f, -0.08478449f, -0.04961797f, 0.21496759f, -0.24404646f, 
    0.04689952f, 0.08452438f, -0.08567186f, -0.43245283f, -0.34079057f, -0.03223610f, -0.16789363f, -0.17643388f, 
    -0.57849616f, 0.22485396f, -0.28998604f, -0.35159576f, 0.03876088f, -0.34250525f, -0.03512030f, 0.05435644f, 
    0.04349053f, -0.29481292f, 0.17794858f, 0.00043058f, -0.18822742f, 0.91548783f, -1.10279715f, -0.38823229f, 
    0.06756753f, -0.09419247f, 0.19201401f, 0.12255990f, -0.12708735f, -0.03325200f, 0.13214590f, -0.34823442f, 
    -0.32909054f, -0.35028666f, 0.22109385f, -0.27039054f, -0.00589648f, 0.03411125f, 0.17202610f, 0.38753459f, 
    -0.24023585f, -0.05605102f, -0.04283221f, -0.05295747f, 0.03158415f, 0.41845641f, 0.61200875f, 0.29066008f, 
    0.08926950f, 0.07281318f, -0.15433475f, 0.00212356f, 0.02287868f, 0.03332743f, 0.02320767f, 0.03873420f, 
    0.27645576f, 0.19325581f, 0.22890125f, -0.08062322f, 0.17113531f, 0.04693281f, 0.19625463f, 0.13551833f, 
    0.01614156f, -0.16428195f, -0.03028142f, -0.07365598f, 0.25525144f, -0.68202579f, 0.36371359f, 0.05214270f, 
    0.14009067f, -0.03661328f, -0.00192770f, -0.05285685f, -0.11503211f, 0.07600039f, 0.19561243f, -0.10032117f, 
    0.82334584f, 0.08944564f, 0.10567004f, 0.02453414f, 0.19655675f, -0.08557966f, -0.18104436f, -0.04103393f, 
    0.06052214f, -0.03216844f, 0.08650868f, 0.12922506f, 0.24035367f, -0.59289283f, 0.00479487f, -0.02244134f, 
    0.09775788f, 0.03195472f, -0.12782212f, -0.06240127f, -0.05381544f, -0.18821573f, 0.14200447f, -0.30387497f, 
    -0.09261475f, -0.07603560f, -0.05543669f, 0.11144597f, 0.11916966f, -0.00466437f, 0.00959903f, 0.10407167f, 
    0.12894966f, 0.22403161f, -0.09634375f, -0.03944900f, -0.06239775f, 0.05519431f, 0.50897932f, 0.18577813f, 
    0.24182154f, 0.14189546f, -0.05763350f, -0.00162318f, 0.29632458f, -0.04361886f, -0.10446007f, -0.09269603f, 
    -0.99013770f, -0.80002809f, -0.31554425f, -0.34571043f, 0.23538630f, 0.10034589f, -0.09214483f, -0.13802077f, 
    0.14117812f, 0.05456472f, 0.05551063f, -0.03145598f, 0.59511572f, 0.16827105f, -0.18247081f, -0.02787359f, 
    -0.17825100f, -0.17532262f, -0.06262347f, 0.11781007f, 0.01718241f, 0.03124474f, -0.02941157f, -0.04372532f, 
    -0.32622325f, -0.28433162f, -0.10504881f, 0.26535636f, 0.30688468f, -0.09753326f, 0.02468920f, 0.21398516f, 
    0.05291967f, 0.22367118f, -0.02635702f, 0.19873092f, 0.56559616f, -0.03169763f, -0.10252799f, 0.03476661f, 
    -0.31149754f, -0.09478204f, 0.19886544f, 0.04239902f, 0.11183343f, -0.09686518f, -0.27519625f, -0.23399152f, 
    0.30045849f, -0.03572062f, -0.04989889f, -0.09177207f, -0.09031919f, 0.05662286f, -0.14267865f, 0.05040126f, 
    -0.04491588f, 0.21428788f, 0.14786591f, -0.07949618f, -1.11059844f, -0.02695996f, -0.02291548f, -0.32420084f, 
    0.28872481f, -0.11812454f, -0.05747527f, -0.01835928f, 0.14716402f, 0.16084155f, -0.09144069f, 0.18335775f, 
    -0.40301961f, 0.16779958f, -0.15038985f, -0.54968905f, 0.36684048f, 0.02707924f, -0.12571861f, 0.05615847f, 
    0.25981194f, -0.22077721f, -0.07936814f, 0.06069719f, -0.04589487f, -0.21485478f, -0.10321366f, -0.34161699f, 
    -0.05348839f, -0.09084950f, 0.13640453f, 0.19970424f, -0.07067911f, 0.17599100f, 0.16120547f, 0.16532615f, 
    0.20884760f, 0.03773222f, 0.24300562f, -0.25855917f, -0.32101533f, 0.01605408f, -0.04998112f, -0.34926313f, 
    0.03788466f, -0.13832815f, -0.26470441f, -0.14813560f, -1.32448244f, -0.70411068f, 0.12738718f, 0.23051761f, 
    0.16649038f, 0.20446524f, 0.25893426f, -0.31610954f, 0.33272597f, 0.09822592f, 0.12690087f, 0.08144654f, 
    -0.26315948f, -0.23274092f, 0.08387931f, 0.10469919f, 0.12218247f, -0.19514722f, 0.03710417f, 0.10768640f, 
    -0.01090960f, 0.05223344f, 0.03974308f, 0.43802264f, -0.45617142f, 0.05547911f, -0.37780285f, -0.01569469f, 
    0.03029950f, 0.23297405f, -0.22459804f, -0.05627225f, -0.32908356f, -0.12241466f, -0.24698164f, -0.21234813f, 
    -0.12926687f, -0.01733943f, -0.00071027f, 0.16187549f, -0.10812975f, 0.10434109f, 0.19588999f, -0.05062675f, 
    0.00075882f, 0.12327612f, 0.08870228f, 0.07895567f, -0.23701066f, 0.11269798f, -0.23339663f, -0.06298158f, 
    0.02835642f, 0.15839715f, 0.24313812f, -0.13364157f, 0.01099608f, 0.16329576f, 0.24304245f, 0.28299013f, 
    0.41756096f, -0.42846519f, -0.53210026f, 0.20197749f, 0.18266812f, -0.13270625f, -0.13283633f, -0.28092965f, 
    0.11202089f, -0.06112074f, -0.03018080f, 0.04613042f, 0.24233982f, 0.47927418f, -0.00919160f, 0.07292668f, 
    0.01390283f, -0.14715786f, -0.09975434f, 0.16109948f, 0.02678376f, 0.13526088f, -0.07268718f, 0.08099451f, 
    -0.29420081f, -0.07089560f, -0.15427637f, -0.27818340f, 0.41434851f, -0.16418013f, 0.04184521f, -0.05889320f, 
    0.03874327f, -0.12156450f, -0.05633871f, 0.04771015f, -0.54212433f, -0.38167936f, -0.06376286f, -0.26994294f, 
    -0.14891842f, 0.06945574f, 0.00120550f, 0.24229227f, -0.30799091f, 0.04712960f, -0.01090764f, -0.06756193f, 
    0.19861229f, -0.08060466f, -0.07652913f, 0.43381831f, 0.02756079f, 0.21064742f, 0.12608030f, 0.16368067f, 
    0.06001445f, -0.04468109f, -0.09096753f, 0.02943018f, -0.30804166f, 0.31659096f, 0.06638424f, 0.23748834f, 
    0.02806273f, -0.13541338f, -0.05108576f, -0.18060136f, 0.08026814f, -0.01707838f, 0.24269468f, -0.01722177f, 
    0.13374852f, -0.48726109f, -0.34472713f, 0.06687234f, -0.04700643f, 0.21003143f, 0.02325915f, -0.15144742f, 
    -0.05855340f, -0.00236210f, -0.08884747f, 0.10385233f, 0.96399391f, 0.24180336f, -0.46477231f, -0.43916446f, 
    0.12327023f, -0.08565000f, 0.03810980f, 0.11578762f, 0.10070259f, -0.08443772f, -0.01623467f, 0.00035971f, 
    -0.12216935f, -0.16889367f, 0.15018634f, 0.33873659f, -0.02363235f, 0.19871804f, -0.11792910f, 0.02857438f, 
    -0.01237005f, -0.03558347f, 0.09308135f, 0.18320243f, 0.08688378f, -0.58630127f, 0.08156516f, 0.25492918f, 
    -0.00212355f, -0.04827848f, -0.00431505f, -0.13563582f, -0.10759806f, -0.02643235f, -0.17416495f, -0.28501514f, 
    0.18763873f, 0.19183944f, -0.09708303f, 0.11065190f, -0.25992504f, -0.17406610f, 0.11309359f, -0.27619553f, 
    -0.05053883f, 0.10699213f, -0.12735659f, -0.24049817f, 0.42563629f, -0.02194764f, 0.20093110f, -0.00767983f, 
    0.14446789f, -0.05425318f, -0.20419365f, -0.03464389f, -0.08234708f, 0.02778934f, 0.11277188f, 0.06773041f, 
    0.19718431f, -0.16373429f, 0.01921483f, 0.31114271f, -0.00463887f, -0.02341803f, -0.05565635f, 0.22206226f, 
    -0.20544556f, -0.04666718f, -0.02999768f, -0.05191775f, -0.93421829f, -0.30362517f, -0.24140045f, -0.08601875f, 
    0.08010107f, 0.22869235f, -0.00847148f, 0.22065148f, 0.28580898f, -0.02603080f, -0.02792861f, 0.15961842f, 
    -0.53346777f, 0.08498038f, 0.07004954f, -0.26136291f, -0.23325369f, 0.19926113f, -0.48555306f, -0.25162280f, 
    0.09764821f, 0.17122684f, 0.09323227f, -0.13847461f, 0.31278381f, 0.10871157f, -0.18619765f, 0.25633574f, 
    -0.15306708f, -0.10022094f, -0.16132198f, 0.09681758f, -0.39307532f, 0.00809807f, 0.21857628f, -0.26372477f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.17245223f, 0.04054086f, -0.18176387f, -0.03384205f, 0.07328284f, -0.02338990f, -0.07906135f, -0.15665117f, 
    -0.02010503f, 0.07988652f, 0.25212494f, 0.05378929f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
