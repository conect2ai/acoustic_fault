#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.27622908f, 0.92000747f, 0.53125924f, -0.40375873f, -0.23640563f, -0.71857554f, -0.29388815f, 0.13443470f, 
    -0.02720212f, -0.02239046f, 0.06862682f, 0.01838386f, 0.16485023f, 0.14118098f, -0.11981464f, 0.20652334f, 
    -0.25119928f, 0.20886035f, -0.07831039f, -0.21654733f, 0.09045552f, -0.00509337f, 0.16134906f, -0.10730489f, 
    -0.05391237f, 0.08348860f, -0.07625216f, -0.28874806f, 0.47706401f, -0.16524020f, -0.15825540f, 0.09940201f, 
    0.15680251f, 0.00134173f, 0.17520669f, -0.15467557f, -0.29564950f, -0.00626698f, 0.48973176f, -0.24211177f, 
    -0.19202588f, 0.13291241f, 0.15715373f, -0.11455590f, -0.21001473f, 0.21112868f, 0.37776086f, 0.39285228f, 
    0.12343315f, 0.09889998f, -1.01256156f, 0.02140253f, -0.29934546f, -0.90703732f, -0.28364831f, 0.52037668f, 
    0.00114223f, -0.44779935f, 0.07213715f, 0.22521295f, -0.23770085f, -0.32990396f, -0.30731499f, -0.28154996f, 
    -0.24088410f, 0.14879926f, 0.01683213f, -0.11874896f, 0.03240000f, 0.03895267f, -0.00986779f, 0.08911014f, 
    -0.04308239f, -0.05263280f, -0.11400434f, -0.89798772f, -0.60220498f, -0.19898111f, 0.62868118f, 0.79226089f, 
    0.47003883f, 0.14675418f, -0.11806170f, -0.28754985f, 0.03487720f, 0.22621855f, -0.41679510f, -0.15436122f, 
    0.06649894f, -0.29225403f, 0.03733428f, 0.02418067f, 0.04164726f, 0.18652371f, 0.21789055f, 0.07273244f, 
    -0.18712987f, -0.20024753f, 0.06248800f, -0.18666077f, 0.17767790f, 0.04082380f, 0.36610347f, 0.64308828f, 
    0.41207638f, 0.37345093f, -0.07405104f, -0.00089758f, 0.34203371f, 0.00634984f, 0.06154099f, 0.30374146f, 
    -0.10020984f, -0.33501098f, 0.05327028f, -0.05951611f, -0.00742676f, 0.03473456f, -0.21887068f, -0.03723320f, 
    0.04376328f, -0.00776438f, -0.01032786f, 0.00791136f, -0.06523096f, -0.48686254f, -0.43171719f, 0.41260427f, 
    -0.14168328f, 0.33760488f, -0.36909178f, -0.25347203f, -0.09416319f, 0.44698232f, 0.21771380f, -0.00868185f, 
    -0.15737662f, -0.28121442f, -0.09812771f, 0.28145689f, -0.12233004f, -0.21267705f, -0.21278815f, -0.15062131f, 
    -0.37641355f, -0.08462772f, -0.22169329f, -0.03769503f, -0.31559554f, -0.20131402f, 0.75614107f, 0.41870967f, 
    -0.09622838f, -0.31482717f, -0.12405518f, 0.11868364f, -0.10172903f, -0.02469497f, -0.20867312f, 0.29793298f, 
    -0.24807607f, 0.13653938f, 0.28572428f, -0.40069261f, -0.11617824f, 0.20598510f, -0.04516427f, -0.31618628f, 
    0.13657352f, -0.14114375f, -0.15361199f, 0.03845493f, -0.05520148f, -0.00066893f, 0.32251298f, -0.36289263f, 
    -0.26782307f, -0.15144014f, 0.36278489f, 0.47816283f, -0.15728247f, -0.48175868f, 0.09240752f, 0.46079525f, 
    0.10629664f, 0.00734632f, 0.05202497f, 0.16083406f, 0.26428002f, -0.21248041f, 0.02027068f, -0.19259205f, 
    0.31670132f, -0.45395535f, -0.24482732f, -0.32488856f, 0.07694934f, 0.33545321f, 0.32160655f, -0.14117150f, 
    -0.06800728f, -0.57670921f, 0.16625129f, 0.39090088f, -0.15207082f, 0.68052417f, -0.15820512f, -0.73079538f, 
    -0.51207101f, 0.05310365f, -0.12472680f, -0.03585235f, -0.11021787f, -0.23427390f, -0.21502681f, 0.23521087f, 
    0.22459704f, 0.29477522f, 0.10165779f, -0.04867547f, -0.19280827f, -0.07332590f, -0.10271119f, 0.07504679f, 
    -0.11337677f, -0.38250774f, -0.31032604f, -0.21472909f, 0.18363498f, 0.37205812f, -0.12904263f, 0.48023558f, 
    0.33139315f, 0.36038443f, 0.32559758f, 0.26664564f, 0.23143020f, 0.12454720f, 0.30218846f, -0.04291079f, 
    -0.32887140f, -0.29212388f, -0.07260290f, 0.01871300f, 0.11431727f, 0.28655151f, -0.18873315f, 0.08506783f, 
    0.30052394f, -0.10583299f, -0.21316333f, 0.07273491f, -0.36682388f, 0.43462479f, 0.27497214f, -0.36031923f, 
    -0.25870323f, -0.14348893f, -0.04991310f, -0.00144230f, 0.31370494f, -0.26422530f, -0.22218986f, 0.38962969f, 
    -0.04071702f, 0.01132309f, -0.13948502f, -0.12899211f, 0.21764584f, -0.12097052f, -0.04404521f, 0.03893215f, 
    0.18924958f, 0.19345911f, 0.45399359f, 0.07057311f, -0.11087250f, -0.22196913f, -0.30110675f, -0.40495059f, 
    -0.20897679f, -0.49872088f, -0.21515867f, -0.18395193f, -0.70410734f, 0.11231418f, 0.27307814f, 0.24509795f, 
    0.52639192f, 0.19956350f, -0.03117402f, -0.14465342f, -0.44901946f, -0.01696516f, -0.03984020f, -0.17960475f, 
    0.03015777f, 0.25392860f, 0.01416623f, -0.27457061f, -0.39182255f, -0.64849919f, -0.60175663f, 0.12910587f, 
    0.04939596f, -0.31084469f, -0.29650232f, 0.26719317f, 0.34420133f, 0.01109641f, 0.14900708f, 0.03671426f, 
    0.09757408f, 0.12227971f, 0.20449398f, -0.16035613f, -0.01588046f, 0.03838495f, 0.13620579f, 0.12720247f, 
    -0.33531833f, -0.10496738f, 0.02676403f, -0.23202474f, 0.04792429f, -0.83055913f, 0.51074970f, -0.64119452f, 
    -0.68247366f, -0.15104342f, 0.16036521f, 0.02846320f, 0.22857018f, 0.16809191f, 0.39667660f, 0.46944332f, 
    0.18891159f, 0.09246767f, -0.03351895f, 0.14211392f, -0.22941373f, -0.10939407f, -0.04055625f, 0.04010975f, 
    -0.26210877f, -0.01398490f, 0.20005977f, 0.08925586f, -0.13219750f, 0.22159326f, -0.40760130f, -0.67455304f, 
    -0.44459382f, -0.14770155f, -0.39084238f, 0.19312915f, 0.47377720f, -0.10658251f, -0.03435082f, -0.03377054f, 
    0.10037760f, -0.15955061f, -0.31146654f, 0.26966837f, -0.01063347f, -0.18832001f, 0.21891077f, -0.24988270f, 
    -0.29044339f, -0.45330432f, -0.07596395f, -0.32234204f, 0.17560549f, 0.32404041f, -0.05349939f, -0.23033190f, 
    -0.34877357f, -0.24825560f, -0.17061773f, 0.31596503f, -0.43806139f, -0.18522415f, -0.44317186f, -0.17143981f, 
    -0.23168276f, -0.10056571f, 0.25251472f, 0.28660980f, -0.07069765f, 0.25434226f, 0.09329666f, -0.07265026f, 
    -0.10312062f, -0.06565869f, 0.25563368f, 0.33486146f, 0.06329440f, 0.05617499f, 0.22020774f, 0.23587961f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.25159970f, 0.09753167f, -0.22900179f, -0.17853662f, 0.12524816f, 0.15761095f, 0.13441953f, 0.14184651f, 
    -0.06692118f, 0.00120337f, 0.29275590f, 0.09208812f, 0.25464448f, 0.31787741f, 0.07810554f, 0.05261456f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.05045575f, -0.00219043f, -0.07569380f, -0.00969864f, -0.01906873f, -0.06284016f, -0.00388950f, 0.00674732f, 
    0.02883619f, -0.03123746f, -0.02236111f, 0.01621551f, -0.03729089f, -0.02534467f, 0.04652187f, -0.06545382f, 
    0.03821199f, -0.03412696f, 0.05374334f, -0.06310589f, 0.02922926f, -0.05820337f, 0.05881518f, 0.02531736f, 
    0.03185312f, 0.02840903f, -0.06339917f, -0.02129257f, -0.06805708f, 0.05652949f, 0.04820506f, -0.07872707f, 
    -0.06513580f, 0.01236007f, 0.00082245f, -0.06997778f, -0.07768763f, -0.04626736f, -0.00755808f, 0.04277086f, 
    0.00566664f, -0.01252778f, 0.00114010f, -0.00120282f, -0.02560136f, 0.03653155f, 0.02918730f, -0.04328644f, 
    0.03108609f, 0.03351307f, 0.01121689f, -0.04686742f, 0.02268863f, -0.03652548f, -0.00413027f, 0.00721911f, 
    0.01325036f, 0.05977560f, 0.01359262f, 0.03707241f, -0.04714828f, -0.02176907f, 0.01457204f, -0.00228001f, 
    -0.07249224f, 0.04428792f, 0.02947620f, 0.02183205f, 0.04846632f, 0.04874540f, 0.02622391f, -0.04607147f, 
    -0.01091926f, -0.06864154f, -0.01480412f, -0.04593468f, 0.05933608f, 0.01354204f, 0.03995605f, -0.05442500f, 
    -0.06872470f, 0.01803637f, -0.00538241f, 0.01296206f, -0.01052217f, 0.03338362f, -0.02724815f, 0.01980656f, 
    -0.00212283f, 0.01576818f, -0.01550452f, 0.04998787f, 0.00191900f, -0.03821493f, -0.01368449f, 0.01037541f, 
    0.04894925f, 0.02448229f, -0.03357534f, -0.01141806f, 0.04562695f, 0.04108402f, 0.01757293f, -0.02674358f, 
    -0.00086892f, -0.05245857f, -0.04470844f, -0.08155668f, -0.06770086f, -0.07495488f, 0.01520318f, 0.00996178f, 
    -0.03739050f, -0.06905694f, -0.06144251f, -0.01315845f, -0.03531960f, 0.03413003f, -0.00836968f, 0.04899877f, 
    -0.07191934f, -0.01442005f, 0.05011830f, 0.01312085f, -0.00635756f, -0.07314812f, 0.03289088f, -0.06454869f, 
    -0.00122157f, -0.05373084f, -0.07004766f, 0.04450532f, -0.06075984f, -0.01357914f, 0.00576885f, 0.03814093f, 
    -0.00551736f, 0.00422012f, -0.02643604f, -0.03575652f, 0.02133003f, 0.00000170f, -0.03590219f, 0.04511150f, 
    0.00785622f, 0.03441655f, -0.06410115f, 0.06562091f, -0.06105406f, -0.06682982f, -0.02385920f, -0.03059132f, 
    -0.08390477f, -0.02060869f, -0.03360180f, -0.02617072f, 0.00148338f, 0.01786317f, 0.00736534f, -0.05773243f, 
    -0.02055380f, -0.04322592f, -0.07259103f, -0.04871442f, -0.01226268f, -0.00681806f, 0.02456400f, 0.04656085f, 
    0.02565856f, 0.00753478f, -0.01474568f, 0.03251479f, 0.03708584f, -0.05121303f, -0.05062274f, -0.06979884f, 
    -0.01196838f, -0.07380480f, -0.00033359f, 0.03847749f, 0.01486884f, -0.03880164f, 0.04206956f, 0.00001595f, 
    -0.00459842f, 0.00344451f, 0.00697975f, 0.07393175f, 0.05361737f, -0.07204221f, -0.02642396f, -0.03805266f, 
    -0.20773885f, 0.00268649f, 0.21283880f, 0.05611430f, 0.17209131f, -0.02020595f, -0.07890448f, -0.06109654f, 
    0.03445760f, 0.01215228f, 0.08212154f, 0.04156229f, -0.05928285f, -0.17805578f, 0.03212545f, 0.00577544f, 
    0.06110430f, 0.12007619f, -0.00265946f, -0.04635883f, 0.02610687f, 0.02985952f, 0.14011432f, 0.20366505f, 
    -0.05149976f, -0.12068182f, 0.15180723f, 0.14000617f, 0.05223101f, -0.09408031f, 0.06757898f, 0.05499281f, 
    -0.07551986f, -0.05159862f, -0.03365018f, 0.08585226f, 0.05515109f, 0.35047233f, -0.14167905f, -0.33761257f, 
    -0.08696191f, -0.19860677f, 0.04337078f, 0.09988053f, 0.00227698f, -0.00413125f, 0.04995489f, 0.11868725f, 
    0.04529328f, 0.19803920f, 0.09423818f, -0.16641442f, 0.01907229f, -0.11861378f, 0.09251593f, 0.05255901f, 
    -0.01217538f, -0.02549022f, 0.04812180f, 0.10690830f, 0.22727443f, -0.14071317f, 0.11765344f, -0.04886774f, 
    0.13571382f, -0.02202805f, -0.05819036f, 0.06097384f, 0.18821862f, 0.11375421f, -0.10700499f, -0.01651181f, 
    -0.19544058f, 0.04338517f, -0.01376699f, 0.06975239f, -0.12925138f, 0.17992169f, -0.10301925f, 0.07769904f, 
    0.19769828f, 0.01537999f, 0.07813805f, 0.13718465f, 0.36100480f, -0.18497951f, -0.06619481f, -0.09571263f, 
    -0.01499283f, -0.09440158f, 0.04330575f, -0.14595786f, 0.11274841f, 0.01643104f, 0.18001847f, 0.10288815f, 
    -0.24832417f, 0.27543136f, 0.26218092f, -0.00631279f, 0.01875671f, -0.03660081f, 0.04415574f, 0.07412719f, 
    -0.03356228f, -0.07642077f, -0.02392458f, -0.11953138f, 0.10663432f, -0.10987567f, -0.13869925f, -0.03698981f, 
    0.04745242f, -0.10390095f, 0.09377360f, 0.08523000f, 0.11486134f, 0.01341489f, 0.10561738f, 0.03990275f, 
    0.10259816f, -0.10425359f, -0.02414260f, 0.07676573f, -0.09291325f, 0.13848861f, -0.09965550f, -0.07455312f, 
    0.07557234f, -0.00870180f, 0.18658103f, 0.11117534f, -0.22989134f, -0.15265214f, 0.02049362f, 0.17894986f, 
    0.11992817f, 0.00895126f, 0.03158053f, -0.14669894f, -0.13634989f, -0.02158836f, -0.01121075f, -0.05375477f, 
    0.16968566f, -0.12727833f, -0.08053328f, -0.02709674f, 0.06723685f, 0.01181368f, 0.10462940f, 0.12817293f, 
    -0.03013100f, -0.04339861f, -0.03876517f, -0.05860871f, 0.02472660f, -0.21670817f, -0.27426469f, 0.12563479f, 
    0.04435783f, 0.14388901f, 0.16359490f, 0.05873418f, 0.10998398f, 0.04564255f, -0.02306111f, -0.05949072f, 
    -0.20888776f, 0.00254133f, 0.12950398f, -0.00752625f, -0.00754987f, 0.12881957f, 0.04753479f, 0.04847853f, 
    0.27237284f, -0.00913661f, -0.09460887f, 0.09579856f, 0.19188061f, -0.25634199f, -0.00222447f, -0.04438040f, 
    0.05218213f, 0.07823944f, -0.09122552f, 0.00112538f, -0.00919163f, 0.14551933f, -0.02943135f, 0.04291424f, 
    -0.19873579f, 0.16544008f, 0.05928600f, -0.02665281f, 0.04154911f, -0.20287399f, 0.20945102f, 0.03336486f, 
    0.00782228f, -0.02493966f, -0.08750937f, 0.06701982f, 0.00059281f, 0.17838396f, -0.16151464f, -0.13428101f, 
    0.00290361f, 0.03940094f, 0.00022364f, -0.06264189f, 0.06789441f, 0.22117458f, 0.03624370f, 0.23596290f, 
    0.02336913f, 0.05164069f, -0.05784776f, -0.22701313f, 0.03613539f, -0.03442498f, 0.13222143f, 0.04110697f, 
    -0.03405924f, -0.08969256f, -0.03198734f, -0.20758273f, -0.24015659f, 0.21241271f, 0.10205004f, 0.15718119f, 
    0.10583211f, 0.24335261f, -0.00131095f, -0.20922370f, -0.14102212f, -0.15977772f, 0.00726759f, -0.08949880f, 
    -0.12818860f, -0.02014128f, -0.07039612f, -0.15059397f, -0.09138010f, 0.07745489f, -0.12915695f, -0.09689225f, 
    -0.09918881f, -0.30685347f, -0.01489620f, -0.13334616f, 0.19017479f, 0.19128142f, 0.06273998f, 0.04063798f, 
    0.06771934f, 0.09398670f, 0.10032158f, 0.03763348f, -0.00339695f, -0.08340926f, -0.03409278f, -0.20866197f, 
    -0.05273373f, 0.17551872f, 0.07176544f, 0.31176978f, -0.14848319f, 0.01737641f, -0.01880994f, 0.18382369f, 
    0.04521372f, -0.17771171f, -0.13818076f, -0.02068841f, -0.00120266f, 0.17078398f, 0.01990883f, -0.16248122f, 
    -0.00370308f, -0.02876250f, 0.01669055f, -0.17313437f, 0.09981388f, -0.14427972f, 0.14814208f, 0.28364074f, 
    -0.04956288f, 0.15614812f, -0.18189985f, 0.20673102f, 0.16437659f, 0.08124044f, -0.13985801f, 0.01348984f, 
    -0.05088964f, -0.00849377f, 0.10577517f, 0.07022502f, -0.16812995f, -0.11257593f, 0.10318302f, -0.12974992f, 
    -0.10628775f, -0.01398089f, -0.23107171f, -0.19998278f, 0.09344639f, -0.08577753f, 0.20324524f, -0.00752694f, 
    0.05551189f, 0.04387870f, -0.18952926f, -0.03442051f, 0.07551768f, 0.19082013f, 0.19003382f, 0.23601812f, 
    0.10490351f, 0.12696230f, 0.02679050f, 0.16349351f, 0.06188000f, 0.03666821f, -0.06948093f, 0.02263351f, 
    0.06908267f, -0.04313180f, 0.02332423f, 0.05979202f, -0.10190485f, 0.07050538f, -0.08236305f, 0.00971594f, 
    0.06644882f, 0.15234058f, -0.02904876f, -0.09992274f, 0.02955071f, -0.02260082f, -0.06074702f, 0.05547098f, 
    -0.09342902f, 0.05454221f, -0.16884665f, 0.00021982f, -0.08282373f, -0.12421434f, -0.06117247f, -0.02689782f, 
    -0.10027390f, 0.01414737f, 0.06939146f, -0.00714969f, 0.00653164f, 0.11256053f, 0.02644181f, 0.00911415f, 
    -0.13228060f, 0.25667307f, -0.18473312f, 0.11244095f, 0.05709674f, 0.12766854f, -0.01798934f, 0.15869425f, 
    0.09547929f, 0.00689883f, -0.02955300f, -0.07376781f, -0.14647141f, -0.02581163f, 0.14557239f, 0.00787988f, 
    -0.09453098f, 0.22602075f, -0.00478313f, 0.28036085f, -0.05443390f, 0.05826105f, 0.08367722f, 0.20509571f, 
    0.05698005f, -0.04128840f, 0.03934996f, -0.01118272f, -0.01272085f, -0.00926915f, -0.01661138f, 0.01041858f, 
    0.02756628f, -0.00226296f, 0.03243287f, 0.01912725f, -0.01690597f, 0.02246927f, -0.02407699f, 0.04648534f, 
    -0.00061587f, -0.07558027f, 0.00181496f, -0.03683781f, 0.05658226f, -0.03459159f, -0.00552373f, 0.05117138f, 
    -0.03370372f, -0.01793860f, -0.03330131f, -0.04129218f, -0.01828989f, -0.03593758f, -0.01636784f, -0.07294495f, 
    -0.06269328f, -0.00101646f, -0.05203798f, -0.03018809f, 0.01283237f, -0.01180713f, 0.03814752f, -0.06965476f, 
    -0.00231677f, -0.01646254f, 0.01210897f, 0.05252334f, 0.04825180f, 0.05634573f, -0.06329751f, -0.07227021f, 
    -0.01931681f, -0.04064006f, -0.06230585f, -0.04967709f, -0.01624038f, 0.00021835f, -0.00809512f, 0.04197146f, 
    -0.06684385f, 0.03175106f, -0.06421754f, 0.04507244f, 0.02225716f, -0.07225233f, 0.00061159f, -0.03823191f, 
    0.05234104f, -0.06499863f, 0.01569673f, -0.05252225f, -0.04512133f, 0.01467835f, 0.02053351f, -0.00940479f, 
    -0.00409550f, 0.05601298f, -0.01520844f, 0.00803186f, -0.02726716f, 0.00000296f, -0.03382777f, 0.05101385f, 
    0.02999363f, 0.01539237f, -0.03846603f, 0.02479822f, -0.07748177f, 0.03007480f, 0.00595887f, 0.01880772f, 
    -0.03907569f, 0.04117582f, 0.00056728f, -0.01826825f, 0.05455853f, -0.01214457f, -0.03887158f, -0.07206616f, 
    -0.02022300f, -0.04194197f, -0.05664564f, 0.03296205f, 0.06347259f, 0.02578098f, -0.05392951f, 0.05006560f, 
    -0.02128440f, 0.00692844f, 0.01737566f, -0.06022901f, -0.02358880f, -0.03316431f, -0.04960554f, -0.04868406f, 
    -0.01927944f, 0.05012017f, 0.03092732f, -0.07295109f, -0.00814465f, -0.03772787f, -0.00960441f, 0.02473878f, 
    0.03833595f, 0.00622806f, -0.07479614f, 0.06318328f, 0.04795172f, 0.05321356f, 0.02682068f, -0.04737909f, 
    -0.06636342f, -0.00988930f, -0.08346723f, -0.04749152f, 0.02623145f, -0.03209770f, -0.03388797f, 0.03830918f, 
    -0.08241293f, -0.05685978f, -0.01702442f, 0.05170236f, 0.01737675f, -0.00808149f, -0.06310784f, 0.03099927f, 
    -0.01799454f, 0.04139259f, -0.02061015f, 0.00945009f, 0.00290960f, -0.00404310f, -0.04494947f, -0.00579700f, 
    0.02669198f, -0.03620790f, 0.01757554f, -0.01918109f, 0.06150609f, -0.02705253f, 0.06615826f, 0.03717320f, 
    0.04982657f, -0.05612068f, -0.05028624f, 0.00783511f, -0.02399896f, -0.02273500f, -0.05625601f, 0.05575750f, 
    -0.04957362f, -0.04050215f, 0.06650761f, 0.00475831f, -0.01848287f, 0.05248824f, 0.02133714f, 0.03626503f, 
    -0.04935204f, 0.01492348f, -0.04046815f, -0.00153671f, -0.01684853f, -0.00073796f, -0.05505836f, -0.01944681f, 
    0.02787304f, -0.00671007f, -0.01981445f, -0.07074115f, -0.02110215f, -0.07095504f, 0.02649347f, 0.00218627f, 
    0.25694272f, 0.31540489f, 0.12276228f, 0.10859107f, -0.06542405f, 0.00442216f, -0.03355138f, -0.08888386f, 
    -0.00507990f, 0.03488159f, 0.07033274f, -0.06392155f, 0.28294617f, -0.14296018f, -0.03718592f, 0.01775368f, 
    0.12497126f, -0.04494286f, 0.10574688f, 0.11097006f, 0.04751785f, 0.07547559f, -0.06542473f, -0.10755159f, 
    -0.07184099f, -0.28929693f, -0.06598794f, 0.00554300f, -0.03118532f, -0.07523406f, -0.00797207f, 0.00982515f, 
    0.10257137f, 0.00471284f, 0.13882169f, 0.18008630f, -0.21779919f, -0.16094242f, 0.05275893f, 0.20202889f, 
    0.09578221f, 0.24298948f, -0.14916033f, -0.02777774f, -0.08423026f, 0.12673400f, 0.14703695f, 0.02663217f, 
    0.30996662f, 0.24990517f, 0.06263881f, 0.01505728f, 0.10099087f, 0.01192052f, -0.03817781f, -0.03754750f, 
    0.00324824f, 0.16146562f, -0.03059068f, -0.05702316f, -0.04543581f, -0.16154861f, -0.02727767f, 0.25908539f, 
    0.12293750f, -0.01948903f, -0.04612462f, -0.21279199f, -0.01473121f, -0.01061127f, 0.08461113f, 0.11522949f, 
    0.11632176f, 0.16064845f, 0.27864498f, 0.08640511f, 0.04032163f, -0.01598505f, -0.06111528f, 0.02922102f, 
    0.04234584f, 0.22683281f, -0.00995987f, 0.00352332f, 0.09028026f, -0.15208192f, 0.21860999f, 0.02673169f, 
    0.06411133f, -0.03177739f, -0.14652252f, -0.08836073f, -0.09374116f, -0.12292371f, -0.05024360f, -0.15424103f, 
    -0.00935511f, 0.02269319f, 0.18851499f, 0.15367109f, -0.16252708f, 0.01314475f, 0.09019922f, 0.03974009f, 
    -0.10297207f, -0.05604038f, 0.05375458f, 0.06585412f, 0.17428492f, 0.00237919f, -0.05626201f, -0.06148226f, 
    0.14510627f, 0.05251697f, -0.01387581f, -0.06460637f, -0.02215465f, -0.01864878f, -0.08495490f, 0.09132735f, 
    0.04417770f, -0.14449900f, 0.10766324f, 0.11713023f, -0.09256801f, -0.02046498f, 0.04652595f, 0.24847984f, 
    -0.02845836f, -0.11363847f, -0.13168724f, -0.16733393f, -0.01204781f, 0.12782013f, 0.26664034f, 0.27512547f, 
    0.22556737f, 0.12936491f, 0.14878269f, 0.17657140f, 0.14884922f, -0.00555763f, 0.03068202f, 0.12880446f, 
    0.05769942f, -0.41882947f, 0.12592891f, 0.08008910f, 0.04029777f, -0.13590682f, -0.15632664f, 0.13193604f, 
    0.05885639f, 0.04824847f, 0.12726258f, 0.08138147f, 0.21257143f, -0.06885747f, 0.00093173f, -0.14160179f, 
    0.00817977f, -0.25577271f, -0.12738349f, -0.02249256f, 0.09331392f, -0.14543387f, 0.23323745f, 0.01740656f, 
    -0.05797765f, -0.12470258f, -0.21934287f, 0.21889366f, 0.10710324f, -0.02651345f, 0.01685363f, 0.08879124f, 
    0.01676500f, 0.19317015f, 0.06786031f, 0.05310187f, -0.15858634f, -0.14852868f, -0.06660108f, -0.19438180f, 
    0.05020824f, 0.12015244f, 0.12665612f, 0.00912967f, 0.10005617f, 0.01008503f, -0.02538638f, -0.04105340f, 
    0.05642558f, -0.00023084f, -0.06828629f, 0.01459619f, -0.05553454f, -0.03537834f, -0.04653550f, -0.06873021f, 
    0.02378223f, -0.02191478f, -0.07611233f, 0.04327407f, 0.02922931f, -0.05177037f, -0.05026579f, -0.01880375f, 
    0.00691565f, 0.04141769f, 0.05691888f, 0.06242500f, -0.00841668f, 0.06454959f, 0.04019101f, 0.02258971f, 
    -0.05651020f, 0.03464585f, 0.06249231f, -0.05038438f, -0.04641158f, 0.03560600f, 0.04511101f, -0.04224282f, 
    0.00499371f, 0.04549054f, -0.01948493f, 0.03569056f, -0.00964845f, 0.03590631f, -0.02311183f, 0.02548037f, 
    0.03348199f, 0.01049962f, -0.04024996f, 0.06006020f, -0.05423253f, -0.05560313f, -0.07039779f, 0.01465215f, 
    -0.07508732f, -0.02351002f, 0.05429904f, -0.01305742f, -0.04345809f, -0.04945748f, -0.01084978f, -0.07603569f, 
    -0.05722165f, -0.00132385f, -0.04747886f, 0.04078780f, 0.04265622f, -0.01303655f, -0.04870649f, 0.04644895f, 
    -0.03153010f, 0.02863705f, -0.07075620f, 0.02891215f, -0.02391626f, -0.01294070f, -0.01138249f, -0.01383749f, 
    -0.07644447f, 0.01268943f, -0.02657907f, -0.02037178f, -0.06362038f, -0.01042356f, -0.02631971f, -0.05593431f, 
    0.04089302f, -0.07004992f, -0.04524431f, -0.07270311f, -0.04648049f, 0.02735394f, -0.04047930f, 0.02418158f, 
    0.00477001f, -0.01984831f, -0.03029970f, -0.05173812f, -0.07307120f, -0.06235549f, -0.00527422f, -0.07421467f, 
    -0.04624940f, 0.01700422f, -0.05176081f, -0.03896590f, 0.00582288f, 0.01640227f, 0.04488450f, 0.00771671f, 
    -0.02618051f, 0.03431274f, 0.04328534f, 0.04800127f, -0.06072591f, 0.04094793f, 0.06438610f, 0.05165160f, 
    -0.03778437f, -0.01141720f, -0.04333680f, -0.03539259f, 0.04416752f, -0.05871972f, -0.04779995f, -0.05278388f, 
    -0.03848338f, -0.06200513f, -0.05999454f, -0.06302042f, 0.03391965f, -0.07711612f, -0.02550146f, -0.05635934f, 
    0.06803112f, 0.02653837f, -0.05575895f, -0.06363621f, -0.06824217f, -0.04951264f, 0.05677784f, -0.00887513f, 
    -0.06638023f, 0.06209161f, -0.01318730f, 0.00142891f, -0.06761548f, 0.04037113f, 0.02040562f, 0.04849759f, 
    -0.06386805f, -0.07188047f, 0.00094144f, 0.05214054f, -0.02900503f, -0.07903384f, -0.01427716f, 0.03202349f, 
    0.04934091f, -0.03580541f, 0.02857901f, -0.03595997f, 0.00113017f, 0.02782052f, -0.03533910f, 0.00288569f, 
    0.00217662f, -0.04014695f, 0.03943872f, -0.06689448f, -0.03069497f, -0.01148177f, 0.02326148f, 0.00738925f, 
    -0.07551455f, -0.03692769f, 0.05141586f, 0.06242022f, -0.05047877f, 0.06149491f, -0.05323354f, -0.02230466f, 
    0.02913157f, 0.01411483f, 0.01294282f, -0.05209624f, -0.03759910f, 0.04242227f, 0.04532454f, -0.07026087f, 
    0.00395851f, 0.03212317f, 0.05203737f, 0.06277125f, -0.04580380f, -0.04645176f, -0.06553295f, 0.04668213f, 
    -0.32341179f, 0.15812333f, -0.45533991f, 0.19638936f, -0.06105210f, -0.08857815f, -0.02542267f, -0.32062173f, 
    -0.07495396f, -0.05492210f, 0.06011292f, -0.06997710f, 0.31827086f, -0.24659590f, -0.08113635f, -0.01557136f, 
    -0.00502304f, 0.00855691f, -0.03543701f, 0.01836191f, -0.09013320f, -0.11857080f, -0.31208888f, -0.14143901f, 
    -0.47511062f, -0.20832701f, 0.12973027f, -0.13842021f, 0.01429200f, -0.02899319f, -0.01660087f, 0.07315790f, 
    0.04555004f, -0.04715913f, -0.05977149f, 0.24034491f, 0.09691901f, -0.08464323f, 0.18740951f, -0.02253460f, 
    -0.05352500f, 0.08866802f, 0.04717385f, 0.10220684f, 0.12270252f, 0.04953554f, 0.00774990f, 0.01572322f, 
    0.03404203f, -0.04972648f, 0.05855305f, -0.28517589f, 0.01009398f, 0.04779729f, -0.24008618f, -0.03455744f, 
    0.15240113f, 0.03315108f, 0.09270408f, 0.09394345f, 0.10233413f, -0.08950968f, 0.19494262f, 0.26798412f, 
    -0.00186550f, 0.01754043f, 0.00029642f, 0.01412246f, 0.19928791f, 0.00886627f, -0.02988780f, 0.19130881f, 
    -0.14918382f, 0.06561887f, -0.23024766f, -0.09827204f, 0.13327792f, -0.03774832f, -0.01157177f, -0.05333745f, 
    0.20773238f, 0.00469545f, 0.04129644f, 0.13057913f, 0.16360898f, -0.24582060f, 0.17068559f, -0.01426156f, 
    -0.25148019f, 0.02888847f, -0.08313598f, -0.20983942f, 0.07698824f, -0.03569590f, 0.14372124f, -0.05487749f, 
    -0.00689310f, -0.19587089f, 0.28175443f, -0.29343584f, -0.13217393f, 0.04066369f, 0.03374368f, 0.03856723f, 
    -0.05726821f, -0.03075519f, 0.00920233f, 0.03049384f, 0.17066507f, 0.07920824f, -0.03861912f, 0.11932307f, 
    -0.12541968f, -0.06725962f, 0.11263916f, 0.05733511f, 0.03832176f, 0.15223004f, 0.01970446f, -0.09012007f, 
    -0.14290804f, -0.02525269f, 0.14100963f, 0.02317468f, 0.07640062f, 0.13773775f, 0.03547700f, 0.00648972f, 
    -0.16900001f, -0.11019654f, -0.10736080f, -0.15419213f, 0.13679729f, 0.46672583f, -0.03410174f, 0.05483973f, 
    0.15584539f, 0.04707060f, 0.06257627f, -0.04331846f, 0.14435515f, -0.00273978f, 0.05607507f, -0.05019338f, 
    0.19498733f, -0.06956529f, 0.30085379f, 0.17366114f, -0.01433504f, 0.03358994f, 0.04269232f, 0.26891631f, 
    0.10944539f, -0.05417668f, 0.00556414f, -0.07475789f, 0.16203541f, 0.22100328f, 0.20481285f, -0.03087870f, 
    -0.08028466f, -0.13012877f, 0.11247055f, -0.02506639f, 0.18998057f, -0.07753236f, 0.03543356f, -0.08628497f, 
    0.06788517f, 0.08707951f, -0.07551004f, -0.03425472f, 0.04842093f, 0.02740952f, 0.00233675f, 0.12488470f, 
    0.09881763f, 0.08519793f, -0.01455466f, 0.08986274f, -0.03614721f, -0.13029246f, 0.12572709f, -0.20827742f, 
    0.15500192f, 0.07620093f, 0.08510361f, 0.05926511f, -0.03728828f, -0.12676813f, -0.05289163f, -0.06752665f, 
    0.61666584f, -0.05693215f, 0.20798653f, -0.22496475f, 0.06981336f, 0.14101008f, -0.09378385f, -0.09012260f, 
    0.05250774f, -0.11452620f, 0.03351512f, -0.01764546f, 0.00219690f, 0.14252679f, 0.04149436f, -0.01485831f, 
    0.00316794f, 0.05822925f, 0.12768570f, -0.07971530f, 0.00081500f, -0.18988329f, 0.02469034f, -0.05524304f, 
    0.14274289f, -0.21225622f, -0.05757760f, 0.28104761f, -0.01610623f, -0.06135389f, -0.00743654f, 0.03202982f, 
    -0.05837341f, 0.01057587f, 0.07051460f, 0.00735578f, -0.30332598f, 0.06884570f, -0.15130511f, 0.10461594f, 
    0.04815937f, 0.09351301f, 0.03657640f, 0.05817129f, -0.08086878f, 0.04088325f, 0.02101768f, -0.05752727f, 
    0.13514577f, 0.19087972f, -0.00426413f, 0.21797912f, -0.08081607f, -0.07882351f, 0.09088255f, 0.02198101f, 
    0.08117890f, 0.10772709f, -0.01579284f, 0.01641642f, -0.01330283f, -0.07584979f, -0.17990565f, 0.07616384f, 
    -0.01176258f, -0.05218450f, -0.07619411f, 0.03306083f, -0.08491455f, 0.08366797f, 0.13171503f, 0.02304334f, 
    0.25465670f, 0.11874852f, 0.40072653f, -0.08051912f, -0.05345171f, -0.18056254f, -0.12999038f, -0.03747806f, 
    0.06899928f, 0.22634089f, 0.03256206f, -0.00469979f, -0.12312210f, 0.18519831f, -0.19142815f, -0.02062152f, 
    -0.02244286f, 0.04090933f, 0.03246348f, 0.21416515f, 0.00289841f, 0.14169040f, -0.05934272f, -0.11342444f, 
    -0.12955637f, -0.11104795f, 0.14663014f, 0.19655113f, -0.08075321f, -0.05022671f, 0.05621728f, 0.20053951f, 
    -0.13455656f, -0.14088139f, -0.05385838f, 0.00731034f, -0.18180414f, 0.10131354f, 0.05302504f, -0.03920737f, 
    0.00417407f, -0.04950049f, -0.05923741f, 0.05074367f, 0.12709884f, 0.03254427f, -0.05638757f, -0.07070731f, 
    0.04542930f, -0.05359353f, -0.02650146f, 0.22885051f, 0.07709714f, -0.02891132f, -0.00131101f, 0.06353136f, 
    -0.02187288f, -0.16113621f, -0.07739097f, -0.03733759f, -0.23946811f, -0.20993809f, 0.17876364f, 0.07690997f, 
    0.07294128f, 0.04433797f, 0.03197098f, 0.00395613f, 0.12027029f, -0.10251719f, 0.05858446f, -0.03027913f, 
    -0.33147746f, 0.11803011f, -0.07425144f, 0.21290404f, 0.05480053f, -0.04249492f, 0.03774589f, -0.02532821f, 
    0.08958529f, 0.00694323f, 0.16543350f, 0.11635640f, 0.26084173f, 0.10985916f, 0.06792716f, 0.05955957f, 
    0.01576698f, -0.06852760f, -0.12708674f, 0.14367199f, -0.06043430f, 0.06102976f, 0.11192223f, -0.00144909f, 
    -0.01646261f, 0.01821704f, 0.20145053f, 0.10347816f, 0.03440943f, -0.09530371f, -0.00890975f, -0.01444846f, 
    0.06395140f, 0.20502707f, 0.16144909f, 0.10556328f, -0.28743473f, -0.10176691f, -0.08555355f, 0.08397570f, 
    0.07070849f, -0.05533172f, 0.05495737f, -0.04772903f, -0.19368540f, -0.01707735f, -0.05577328f, -0.07031652f, 
    0.12894341f, 0.04739036f, 0.22930929f, 0.00770509f, 0.13429460f, -0.07433692f, -0.07737486f, -0.03803103f, 
    -0.11679721f, -0.05605018f, 0.08694366f, 0.08102380f, -0.16166674f, -0.08174912f, -0.00047268f, -0.05171135f, 
    0.10253249f, 0.07451303f, 0.09020588f, -0.09784795f, -0.06090866f, 0.07169455f, 0.09317300f, 0.14577064f, 
    0.02839680f, -0.20884709f, -0.06636668f, 0.06037368f, -0.04957995f, -0.09154515f, 0.07097230f, -0.02337672f, 
    -0.05566888f, -0.03176900f, 0.01833053f, 0.03737637f, -0.00074651f, 0.11037652f, -0.31945917f, -0.32625803f, 
    -0.02493870f, -0.00316425f, 0.13048168f, 0.10612448f, 0.09047961f, 0.03623639f, 0.12122811f, -0.01821508f, 
    0.20880614f, 0.34889284f, 0.05400918f, -0.15669717f, -0.09970204f, -0.07269017f, 0.08847343f, -0.00361013f, 
    -0.09948474f, -0.04176076f, 0.05396110f, -0.00396038f, 0.14603423f, -0.27568841f, -0.08932163f, 0.03940621f, 
    0.10751372f, 0.01264787f, 0.02724122f, -0.01993685f, 0.20818205f, 0.10132802f, 0.06252592f, 0.04071349f, 
    0.00955166f, 0.12995927f, 0.34502569f, 0.19984895f, -0.01504277f, 0.08474258f, -0.04391046f, 0.08631199f, 
    0.04799309f, 0.10801578f, 0.04097572f, -0.02190143f, 0.30267325f, -0.00183636f, 0.01453811f, -0.19252096f, 
    -0.03580930f, 0.07197136f, 0.00424018f, 0.02332648f, 0.10571963f, 0.07340232f, 0.19358718f, -0.03103680f, 
    -0.27155948f, 0.23858553f, 0.21439917f, 0.10748707f, 0.04552523f, -0.01954143f, 0.16509157f, 0.15924866f, 
    -0.00557125f, -0.05397221f, -0.04952128f, -0.07231325f, -0.01119173f, -0.02057371f, -0.17545813f, -0.12910739f, 
    -0.07248203f, -0.08290884f, 0.03245826f, -0.00568212f, 0.06167246f, 0.14881667f, 0.13096809f, 0.05218463f, 
    0.08310433f, -0.14259438f, -0.01377963f, 0.08888296f, -0.00826480f, 0.06405807f, 0.03947016f, 0.08138736f, 
    -0.00509365f, 0.06009745f, 0.07935522f, -0.03836351f, -0.21923470f, -0.28576431f, 0.00342066f, 0.15140702f, 
    0.09980654f, 0.07114664f, -0.00620203f, 0.01808647f, -0.00659656f, -0.01833929f, -0.03375898f, 0.04561684f, 
    0.12505274f, -0.07496995f, -0.16704483f, 0.00759948f, 0.13216044f, 0.13305445f, 0.11723173f, 0.06444732f, 
    0.00689593f, 0.00334738f, 0.02527263f, 0.05750000f, 0.16801050f, -0.22481148f, -0.27068198f, 0.22838075f, 
    0.04427683f, 0.02757043f, -0.01416905f, 0.19056726f, -0.02806459f, 0.00781463f, 0.08522795f, -0.01433643f, 
    -0.22390142f, -0.12118590f, 0.08827169f, -0.08507457f, -0.01472819f, 0.11179362f, 0.04618331f, 0.02005942f, 
    0.24144880f, 0.05598538f, -0.05113897f, 0.05991000f, 0.03800418f, -0.22480424f, 0.11542324f, 0.06176552f, 
    -0.00776453f, -0.00614982f, 0.01777219f, -0.03105810f, -0.13290706f, 0.01915164f, -0.06859526f, -0.00828061f, 
    0.06506754f, -0.01868861f, -0.13913713f, -0.03824301f, 0.02844840f, 0.07792827f, 0.10569777f, 0.12971278f, 
    -0.07517414f, 0.10226893f, -0.06720982f, 0.02360471f, -0.02626972f, 0.02505728f, -0.10894927f, -0.14831223f, 
    -0.03015205f, 0.00550719f, 0.10561939f, -0.02084839f, 0.13843015f, 0.23827155f, 0.00193793f, 0.12489225f, 
    0.12052152f, -0.42522278f, -0.09317901f, 0.06928381f, 0.07344346f, -0.03552431f, -0.02909599f, -0.07034203f, 
    -0.05330606f, -0.09430258f, 0.07502633f, 0.18338586f, 0.19986652f, 0.21199727f, 0.03111892f, -0.28321549f, 
    0.18301612f, -0.06118950f, 0.07330755f, -0.02188683f, -0.14910145f, 0.14004627f, 0.04300268f, -0.04137539f, 
    -0.04711626f, 0.09105771f, 0.02176135f, -0.25630227f, -0.03887117f, -0.07841301f, 0.02446620f, 0.00627090f, 
    0.01115382f, -0.05814061f, 0.05512541f, -0.12745810f, 0.21992911f, -0.14359455f, -0.17093287f, -0.20199868f, 
    0.02176150f, -0.14180142f, 0.06506107f, 0.02675991f, 0.03577335f, 0.09054046f, 0.06044235f, 0.02016535f, 
    -0.26621491f, 0.16176933f, -0.09683532f, 0.11485500f, 0.00676704f, -0.02653959f, -0.03507092f, 0.06001476f, 
    0.03043998f, 0.00278911f, -0.00303076f, 0.00436562f, 0.34776831f, 0.02611230f, -0.12087144f, -0.18524995f, 
    0.03220484f, 0.02134429f, -0.01593041f, -0.01809329f, -0.05087338f, -0.01456203f, 0.05776567f, 0.06846520f, 
    -0.11704877f, 0.16638088f, 0.15116881f, 0.30062088f, -0.00093205f, 0.05063539f, 0.12207893f, -0.08176323f, 
    -0.02028875f, 0.08883998f, 0.08785707f, -0.04437860f, 0.08918887f, 0.04485498f, -0.06045896f, -0.17836818f, 
    0.00984159f, -0.04677586f, 0.01067478f, -0.02291299f, 0.06117598f, 0.09245932f, 0.04885967f, 0.08502959f, 
    0.05630999f, -0.00939362f, -0.14590482f, 0.02944232f, 0.00123704f, 0.00360289f, -0.00444624f, 0.18874517f, 
    0.16959752f, 0.06861115f, 0.07984029f, 0.15302996f, -0.15157217f, -0.05628246f, -0.05374455f, 0.15726489f, 
    0.13578169f, 0.09350994f, -0.06085251f, -0.08295492f, 0.03801780f, -0.11439091f, -0.06566131f, -0.02120884f, 
    -0.08350024f, 0.06581455f, -0.17603090f, -0.08935210f, 0.03879555f, 0.19879889f, -0.05425091f, 0.24488139f, 
    -0.10348442f, -0.04777392f, -0.06181141f, -0.01750780f, 0.39410156f, -0.04943490f, 0.04134402f, 0.31819731f, 
    0.03951993f, -0.03994242f, 0.05781729f, 0.01655007f, 0.07604973f, 0.02647457f, 0.10490495f, 0.06252965f, 
    -0.38242015f, -0.05270736f, -0.10468011f, -0.05416729f, -0.01153410f, 0.05088285f, -0.04532795f, 0.01933903f, 
    0.03616904f, 0.09017333f, -0.06178451f, 0.11595468f, -0.01011116f, -0.12123124f, 0.01257948f, -0.00176602f, 
    0.00991710f, 0.01338724f, -0.08508430f, -0.02941206f, 0.02271188f, 0.09398858f, 0.00341490f, 0.03838953f, 
    -0.33124244f, -0.13030249f, 0.25895643f, 0.23389134f, 0.00408361f, 0.07339148f, -0.23842335f, -0.11318097f, 
    0.03985308f, -0.00619989f, -0.06100076f, -0.08891234f, -0.02897577f, -0.40609160f, 0.11867278f, 0.04754091f, 
    0.10363914f, 0.07961793f, -0.16113348f, 0.05153726f, 0.00519310f, -0.12628458f, 0.02995105f, 0.03598207f, 
    0.01100558f, 0.15730616f, 0.10342773f, -0.03631936f, -0.02069825f, 0.13019603f, 0.02263000f, 0.03714455f, 
    0.05579432f, -0.07657354f, -0.04378089f, 0.12756808f, 0.27922034f, 0.33000928f, 0.06262682f, -0.20104808f, 
    0.00430315f, -0.15746965f, 0.28401813f, 0.16572946f, 0.12241398f, 0.08078302f, 0.04053133f, 0.10470166f, 
    0.21363865f, 0.06413327f, 0.18729843f, -0.08844005f, -0.09638140f, -0.16897531f, 0.05179412f, -0.01680808f, 
    -0.05893943f, 0.09836429f, 0.04485500f, 0.05575568f, 0.12660156f, -0.04253575f, 0.23051748f, 0.07197917f, 
    0.01847271f, 0.12368803f, -0.13916411f, -0.08796214f, 0.04644194f, -0.00790145f, -0.04912347f, 0.11721047f, 
    -0.23334984f, 0.08037134f, -0.22328778f, 0.17037632f, 0.09904097f, 0.10660244f, -0.14908077f, -0.10818293f, 
    0.13369790f, -0.05649839f, -0.04996867f, -0.00159635f, 0.10426462f, -0.23374923f, 0.23842750f, -0.03086635f, 
    -0.06184531f, 0.15268162f, 0.03554507f, -0.10717497f, -0.00297634f, -0.11754913f, 0.11411127f, -0.17179295f, 
    0.05096988f, 0.30154455f, 0.13460882f, -0.09147014f, 0.08758648f, -0.00175539f, 0.11010180f, -0.10244790f, 
    -0.18839233f, 0.14259620f, 0.14707664f, 0.08621857f, 0.29026884f, -0.14531569f, -0.38340408f, 0.03073040f, 
    -0.00446306f, -0.14626861f, 0.03658353f, 0.03369562f, -0.06653710f, 0.10463736f, 0.03407022f, -0.07043109f, 
    -0.00521510f, 0.09923220f, 0.21819116f, -0.04827323f, -0.01858453f, 0.24384293f, 0.14976184f, -0.03365942f, 
    -0.02812956f, -0.12814038f, 0.13156751f, -0.20933218f, 0.05894799f, 0.02318591f, -0.18562190f, 0.05478781f, 
    0.19727042f, -0.04444379f, 0.08015811f, -0.05339661f, 0.05562034f, 0.02778331f, 0.01578320f, -0.00545665f, 
    0.42427379f, -0.05284224f, 0.10562846f, -0.02834141f, 0.10748824f, 0.06516214f, 0.07291474f, 0.00406510f, 
    -0.11688667f, -0.04377577f, 0.08351984f, -0.01469768f, 0.26271653f, -0.13845633f, -0.13168804f, 0.03319961f, 
    0.06738088f, 0.04429310f, -0.07128391f, -0.05352802f, 0.14267141f, -0.11574269f, -0.00391406f, -0.02100732f, 
    0.10758584f, -0.09353361f, 0.06600080f, -0.10916943f, 0.19760488f, 0.09738387f, 0.07239150f, -0.04649132f, 
    0.05473120f, -0.07917000f, -0.10075450f, -0.00000846f, 0.40148470f, -0.00049991f, -0.01259236f, -0.22475837f, 
    0.19929211f, -0.04890706f, 0.13497481f, 0.02294947f, 0.12936513f, -0.00057318f, -0.13881990f, -0.01256015f, 
    -0.12972413f, 0.05283698f, -0.27851191f, 0.31293127f, -0.19051148f, -0.11235677f, 0.04384180f, -0.21094817f, 
    0.11518918f, -0.08995184f, -0.07869209f, -0.00649188f, -0.10424297f, -0.12048884f, -0.06651410f, 0.04202320f, 
    0.05316181f, -0.10215764f, -0.05229135f, 0.02345660f, 0.05699288f, -0.14310150f, -0.30072811f, -0.19977482f, 
    0.18000390f, 0.23630878f, -0.01592400f, -0.12682857f, 0.06304298f, 0.24838151f, 0.08687196f, 0.11508276f, 
    -0.00592932f, 0.07673089f, 0.07694954f, 0.16034867f, 0.24899247f, 0.04018351f, -0.06277180f, -0.12625666f, 
    0.09752509f, 0.21585967f, 0.11370078f, 0.02413418f, -0.10128843f, -0.03728929f, 0.23820990f, 0.16910426f, 
    -0.21186756f, -0.39133221f, 0.18782488f, 0.05673866f, -0.06807408f, -0.03514406f, -0.48396447f, -0.27831942f, 
    -0.10946535f, -0.08748850f, 0.05587449f, 0.13176361f, 0.11689345f, 0.28139377f, 0.07559552f, 0.02977231f, 
    -0.04681674f, 0.09051562f, 0.02746442f, 0.03311473f, 0.07447767f, -0.01331602f, 0.14602183f, 0.22933018f, 
    -0.34995446f, -0.04963288f, -0.38198060f, 0.05176479f, 0.12464280f, -0.15802611f, 0.08051676f, -0.06079286f, 
    -0.14415038f, 0.05373452f, 0.08011898f, 0.03441377f, -0.00367585f, 0.00539695f, 0.22259989f, -0.11879194f, 
    0.00262298f, -0.00862114f, -0.16404517f, -0.18457176f, 0.03146868f, -0.22089915f, 0.01341484f, 0.03092083f, 
    0.30501679f, -0.02815173f, -0.18753590f, -0.02569314f, 0.14563094f, 0.13971588f, 0.17969094f, -0.01327553f, 
    -0.09166322f, 0.04349865f, 0.07367400f, 0.08114529f, 0.13275114f, -0.07711707f, -0.15554754f, -0.03958919f, 
    -0.26661587f, -0.04044584f, -0.17490500f, -0.22717969f, -0.05362646f, 0.04477881f, -0.04408443f, -0.06476961f, 
    -0.01537951f, 0.13379559f, 0.14279695f, -0.24104136f, 0.02451175f, 0.07846237f, 0.09917059f, 0.01096067f, 
    -0.26313046f, -0.21495278f, -0.26333934f, -0.22841237f, 0.36271548f, 0.09846384f, 0.01728663f, 0.09348969f, 
    0.00542363f, -0.06206422f, -0.02039574f, 0.10638470f, 0.13615800f, 0.09861505f, 0.00926196f, 0.16267955f, 
    0.35982174f, 0.11472270f, 0.07789224f, -0.12423568f, 0.01036352f, 0.05361187f, 0.03411587f, 0.09553293f, 
    -0.05998364f, -0.05989993f, 0.07948018f, -0.05705814f, 0.02419756f, -0.13577439f, -0.02737976f, -0.07289569f, 
    -0.00229493f, -0.00603973f, 0.04255791f, -0.05567713f, -0.02533697f, -0.07683847f, -0.13215497f, 0.01537494f, 
    0.25514850f, -0.00427822f, -0.15183134f, 0.12150662f, 0.07820388f, 0.06987899f, 0.18270305f, 0.10490077f, 
    -0.08795328f, -0.01265134f, 0.12837806f, 0.04812354f, 0.24241991f, 0.26807579f, -0.05221460f, -0.18673822f, 
    0.04417004f, -0.09373398f, 0.08471844f, -0.00251531f, -0.16352589f, -0.08952864f, 0.00552190f, -0.25737321f, 
    -0.05351061f, -0.02613453f, -0.02113669f, -0.03683319f, -0.06492243f, -0.05246007f, -0.01195663f, -0.06271911f, 
    -0.02712127f, -0.03933473f, -0.05877268f, -0.04048636f, -0.07731902f, -0.01256125f, -0.06931176f, 0.05093267f, 
    -0.02918714f, -0.07749016f, -0.02937115f, 0.05707707f, -0.06250514f, -0.02627131f, -0.04080138f, -0.00409545f, 
    -0.06662286f, -0.04972125f, -0.06465968f, 0.04703159f, 0.02577150f, -0.06924187f, -0.03052894f, 0.03736469f, 
    -0.06671186f, -0.04584714f, 0.03159785f, -0.03929086f, 0.06220618f, -0.01763191f, 0.00541747f, 0.06213741f, 
    0.00505396f, 0.02919762f, -0.01494955f, -0.02268829f, -0.06302192f, -0.01426869f, 0.06441799f, -0.00073912f, 
    0.01357000f, 0.00132018f, 0.00126610f, 0.00680853f, -0.06167128f, -0.07208066f, -0.04676284f, -0.06021598f, 
    0.04255605f, 0.03120169f, -0.05809377f, 0.04584051f, 0.02801591f, 0.02781726f, -0.01259125f, 0.00085432f, 
    -0.02956060f, 0.02454059f, 0.06150924f, -0.00949286f, -0.06214889f, -0.04158745f, 0.02602926f, 0.03430237f, 
    -0.01070720f, -0.06403846f, -0.00514314f, 0.03863673f, -0.01180460f, 0.00655515f, -0.04745011f, 0.03921213f, 
    0.05244275f, 0.06583895f, 0.06173975f, -0.05580827f, -0.01525890f, -0.05605685f, 0.02002179f, -0.06624359f, 
    -0.04514965f, -0.05465213f, 0.01314082f, -0.06131097f, 0.01927713f, -0.01905307f, 0.04965089f, -0.00655743f, 
    -0.04042288f, 0.03383400f, -0.03066790f, 0.06010296f, 0.02260062f, 0.05836680f, -0.04690293f, -0.06645055f, 
    -0.03237060f, 0.00619583f, 0.03605944f, 0.05942240f, 0.01344071f, -0.01575261f, -0.02793309f, 0.01950848f, 
    -0.02332922f, -0.04377409f, 0.03974433f, -0.03598402f, -0.06446481f, 0.03007566f, -0.05291113f, -0.01349075f, 
    0.03993760f, -0.06260267f, -0.05031987f, 0.01959755f, 0.01943283f, -0.02962844f, -0.01210038f, -0.06034641f, 
    -0.03312520f, -0.06333392f, -0.00656409f, -0.01873233f, -0.07376767f, 0.04046559f, 0.01586270f, -0.06889773f, 
    -0.04682414f, 0.00400114f, 0.06510539f, 0.01284497f, 0.02591755f, 0.03798413f, 0.00400976f, 0.03236407f, 
    0.03527046f, 0.03587484f, -0.03042365f, -0.04774226f, 0.02577285f, 0.03300266f, 0.06215325f, -0.01351630f, 
    -0.02796146f, 0.02531912f, 0.00758354f, 0.00251196f, 0.04697143f, 0.02897416f, 0.01614882f, 0.06453227f, 
    0.06018784f, 0.00887595f, -0.06697885f, 0.04425752f, -0.01393295f, -0.03756498f, -0.04260047f, -0.00003659f, 
    -0.02911982f, -0.03757163f, -0.06012421f, -0.02281756f, -0.00580510f, 0.02316724f, -0.07130826f, -0.04950937f, 
    0.03563917f, 0.00099145f, -0.07110070f, -0.05740236f, -0.00551517f, -0.01698471f, -0.04151447f, 0.01636681f, 
    -0.05375480f, 0.02903506f, -0.06767635f, -0.00598922f, -0.01625735f, 0.04111532f, 0.03599681f, 0.04047344f, 
    -0.31326830f, 0.26100940f, -0.01365980f, -0.16074796f, 0.10523374f, -0.19101965f, -0.06286664f, -0.02710629f, 
    -0.00245878f, 0.12569183f, 0.06777626f, -0.02427797f, 0.14557715f, 0.00237795f, -0.15267028f, -0.04418425f, 
    -0.10615941f, 0.03282257f, -0.12770027f, -0.00931306f, 0.26538590f, 0.20207158f, -0.01781081f, 0.09095573f, 
    0.02974662f, 0.04361682f, 0.04214985f, -0.02408415f, 0.01175796f, -0.05322043f, 0.08066937f, -0.05288040f, 
    -0.12187575f, -0.10112076f, -0.04960639f, 0.10134071f, -0.39190078f, 0.44590166f, -0.04894850f, -0.02675323f, 
    -0.05170605f, 0.09337114f, 0.05946334f, -0.06077869f, -0.09527582f, -0.20493646f, -0.15628111f, 0.13868487f, 
    -0.10998804f, -0.00681974f, -0.12709540f, -0.31727284f, -0.31365231f, -0.24359767f, -0.14239849f, -0.21506557f, 
    -0.00370773f, -0.06721202f, 0.08534265f, 0.00383862f, 0.19375269f, -0.06308372f, 0.08584490f, 0.03888728f, 
    -0.02528012f, -0.02725913f, 0.06148833f, 0.11140263f, 0.04430234f, -0.04240076f, -0.25575334f, -0.16826484f, 
    -0.07230321f, 0.05516475f, -0.03456444f, 0.21622570f, -0.13563125f, -0.04213788f, -0.12651816f, 0.08825964f, 
    0.19806316f, -0.10410923f, -0.04452825f, 0.05000065f, 0.03249308f, -0.12788917f, 0.03036406f, -0.19512732f, 
    -0.26131350f, -0.09718183f, 0.01041407f, -0.05201270f, 0.17569567f, 0.01789782f, -0.03765266f, 0.18475048f, 
    -0.11889420f, 0.22433771f, 0.08114418f, 0.03265996f, 0.01813783f, 0.14660366f, 0.02925481f, -0.11935054f, 
    -0.02021567f, 0.04622275f, -0.01648299f, 0.05071887f, -0.27217588f, -0.31232980f, -0.18523414f, -0.21288477f, 
    -0.04956045f, -0.09527843f, -0.18456225f, -0.06686866f, 0.09799281f, -0.01541632f, 0.09765112f, 0.02445387f, 
    0.11282588f, -0.05647011f, -0.10036035f, 0.04824542f, -0.00773271f, 0.09738747f, 0.21612085f, 0.12684631f, 
    0.11879810f, -0.03592083f, 0.23637202f, 0.28520584f, -0.12290195f, 0.02327644f, -0.12106106f, 0.21689546f, 
    0.07495917f, 0.11537368f, 0.20772174f, -0.02465740f, -0.20321970f, -0.02871777f, -0.07240746f, -0.09928207f, 
    0.07755260f, -0.08163979f, -0.08968487f, -0.01094667f, 0.00232207f, 0.04530416f, -0.04102282f, 0.06213981f, 
    -0.08952650f, -0.10982423f, -0.15850526f, 0.01202750f, -0.14676540f, -0.01511726f, -0.05638674f, 0.04214573f, 
    0.03035217f, -0.13812692f, 0.05541069f, 0.05209664f, 0.01218369f, 0.11351763f, 0.10554669f, 0.06746665f, 
    -0.05660404f, 0.08505386f, 0.03559747f, 0.10476005f, 0.10071444f, 0.20455211f, 0.02664647f, -0.02958172f, 
    0.08071168f, -0.16566706f, -0.07638314f, 0.02189096f, 0.09261041f, -0.08498411f, 0.25758010f, -0.02027798f, 
    0.11820202f, 0.13685572f, 0.05329851f, 0.28372392f, 0.03730749f, -0.03678574f, 0.00984112f, 0.25870439f, 
    0.30457497f, -0.07836286f, 0.34533858f, -0.15263841f, 0.03196477f, 0.13096981f, -0.15191619f, 0.05316735f, 
    0.02977952f, 0.08576604f, 0.09310205f, -0.02259644f, -0.18580446f, 0.01891454f, 0.07374720f, 0.04397279f, 
    0.00858532f, 0.15817127f, 0.02825050f, -0.07145064f, -0.06465435f, -0.01533228f, 0.23731162f, -0.05327599f, 
    0.22200292f, 0.37713653f, 0.10609530f, 0.22089408f, 0.09034581f, -0.11750271f, 0.01220080f, -0.08606112f, 
    -0.03003572f, 0.04638979f, -0.01801837f, -0.14142518f, -0.05583358f, -0.12570859f, -0.21002635f, 0.05605722f, 
    0.02907831f, -0.20098639f, 0.19305770f, -0.00464145f, 0.15242383f, -0.14905420f, 0.09827941f, 0.05826327f, 
    0.21566829f, 0.14293776f, 0.01639810f, 0.21681046f, -0.07512771f, -0.05695770f, -0.08430061f, -0.07672323f, 
    0.00353756f, 0.01208497f, -0.06332532f, -0.02034638f, 0.03034628f, -0.03021010f, 0.01593486f, -0.07904416f, 
    0.08802736f, 0.01993317f, -0.08770391f, 0.11334337f, 0.03918907f, 0.03858988f, -0.00996461f, -0.21300383f, 
    0.53749114f, -0.03163260f, 0.37859735f, 0.06001839f, -0.14410059f, 0.11503476f, 0.02372457f, -0.06896278f, 
    0.01374018f, -0.00497700f, -0.00979558f, 0.02846871f, -0.06123118f, 0.08964156f, -0.02500985f, 0.11904030f, 
    0.07933270f, -0.11399322f, 0.09937144f, -0.03587095f, 0.12783428f, 0.23353958f, -0.08686787f, 0.08331577f, 
    0.02523094f, 0.11169238f, 0.11197945f, -0.02774149f, 0.02570895f, -0.14489086f, -0.12862186f, 0.08352390f, 
    0.05474755f, 0.02700410f, -0.12553321f, 0.07839847f, -0.02817577f, -0.11243153f, -0.11676225f, -0.05002682f, 
    -0.11391103f, -0.14248469f, -0.00129028f, 0.00670451f, 0.04347043f, -0.08036972f, 0.09254111f, -0.05403848f, 
    -0.04378418f, -0.15878779f, -0.08627004f, 0.05343539f, 0.04665468f, 0.07617151f, 0.11598906f, -0.09082980f, 
    0.02656458f, -0.01085519f, 0.04950631f, -0.00943160f, -0.19209783f, -0.39891148f, 0.08726961f, 0.00440837f, 
    -0.10796407f, 0.00912051f, 0.05594577f, -0.01048098f, -0.14351065f, -0.02171801f, 0.02942686f, 0.08394236f, 
    -0.01794510f, 0.00335614f, -0.18056850f, 0.07006375f, 0.10102863f, -0.04118227f, 0.15563503f, -0.17356211f, 
    0.12296426f, -0.00775375f, -0.01757781f, 0.04374781f, -0.12789650f, -0.02571079f, -0.25713620f, -0.03268180f, 
    -0.07843301f, 0.12477467f, -0.03165243f, 0.17858063f, -0.01635255f, 0.09163570f, -0.02026419f, 0.02314632f, 
    0.18621525f, -0.11239572f, 0.31000608f, -0.05352417f, -0.04602380f, 0.05096542f, 0.26434940f, 0.08014049f, 
    0.15414384f, -0.03621175f, 0.01228417f, 0.01719934f, -0.05026498f, -0.17201312f, -0.13547257f, 0.06947803f, 
    -0.02558675f, -0.05883151f, -0.00870749f, -0.03635729f, -0.02671531f, -0.00097875f, -0.04135527f, 0.04555107f, 
    0.16497470f, -0.30205277f, -0.02267639f, -0.04781931f, 0.12938134f, 0.06419962f, 0.05325169f, 0.05273941f, 
    0.07674003f, 0.09869793f, -0.03678848f, -0.07094277f, -0.12921026f, 0.04370330f, 0.12797466f, 0.04059853f, 
    -0.07160421f, -0.03271149f, -0.01188884f, -0.03051788f, 0.03208124f, 0.01913226f, 0.16022727f, -0.14174995f, 
    -0.18390970f, 0.41543195f, 0.20123962f, 0.06543595f, 0.08028409f, 0.06368619f, 0.01439587f, 0.11311723f, 
    -0.14508033f, 0.00724351f, -0.05471234f, -0.17846516f, 0.22214074f, 0.13223687f, 0.20418736f, -0.17164712f, 
    -0.05064511f, -0.25770617f, 0.23324789f, 0.08759569f, 0.03370109f, -0.05295842f, -0.09331974f, -0.05114276f, 
    0.06429626f, 0.08340072f, 0.03347208f, 0.26696974f, 0.08788384f, -0.02873945f, -0.07296486f, 0.10213553f, 
    0.13827719f, -0.13174109f, 0.02260303f, 0.08400960f, 0.02098950f, 0.12003917f, 0.14709754f, 0.00896358f, 
    -0.17738111f, 0.01958862f, -0.07041792f, 0.14940770f, -0.11090013f, 0.07556293f, -0.08633842f, 0.05603742f, 
    0.57950002f, -0.09499729f, -0.20697689f, 0.14366144f, -0.02512630f, -0.00397046f, -0.05144021f, 0.00500306f, 
    0.24582393f, -0.00777879f, -0.09115637f, 0.16231175f, -0.22959788f, -0.01229489f, 0.10434505f, 0.15219149f, 
    -0.02829987f, 0.05027227f, 0.08528541f, 0.19403104f, 0.01318309f, -0.09684271f, 0.07538293f, -0.11344510f, 
    0.00547997f, -0.02133465f, 0.05298929f, -0.36192012f, 0.18531099f, -0.07556204f, -0.13814518f, -0.09214182f, 
    0.01204445f, 0.10441359f, 0.00303114f, -0.05634721f, -0.07888731f, -0.02075912f, 0.15230517f, 0.15849158f, 
    -0.06214581f, 0.03696258f, -0.01491761f, 0.10617578f, -0.08598532f, -0.10966919f, 0.09418287f, -0.05996647f, 
    -0.19781551f, 0.02346226f, 0.04054220f, -0.13893764f, 0.06491654f, 0.13314450f, 0.05915417f, -0.03623492f, 
    0.01342458f, 0.06390156f, 0.05798593f, 0.06722026f, -0.17708933f, -0.13556333f, -0.13902427f, -0.14675488f, 
    -0.00107401f, -0.08233387f, 0.06100797f, -0.30517367f, -0.09777720f, 0.09473743f, 0.00141143f, -0.13357730f, 
    -0.11978856f, 0.23155132f, -0.02055493f, 0.02167478f, -0.15403651f, 0.01040909f, 0.03904271f, -0.00260493f, 
    -0.09849623f, 0.03996762f, -0.06080336f, -0.02606111f, -0.33576512f, 0.02923010f, 0.07243738f, -0.14738205f, 
    -0.02590918f, 0.15541910f, 0.05997923f, 0.13668849f, 0.05949575f, 0.05120833f, 0.03871742f, 0.11788996f, 
    0.18909740f, 0.00108198f, 0.32711020f, -0.29117185f, 0.00210375f, -0.01394462f, 0.03536002f, -0.06528425f, 
    0.03846551f, 0.07163240f, 0.10749759f, -0.17558858f, -0.09539251f, -0.02001126f, -0.03208690f, -0.07398321f, 
    0.16101211f, -0.05371074f, 0.00174818f, -0.04137148f, -0.04509172f, 0.03799547f, -0.01147777f, 0.11579733f, 
    -0.28182390f, -0.08095742f, -0.41517863f, 0.14890923f, -0.01993280f, 0.00321352f, 0.02907908f, -0.10988452f, 
    0.08212268f, 0.01452151f, 0.01367794f, -0.06070913f, -0.00417328f, -0.19006732f, 0.07760657f, -0.05773711f, 
    0.01404604f, -0.06367303f, -0.00114137f, -0.00325309f, -0.02064818f, 0.08660656f, 0.02774832f, -0.18885039f, 
    -0.10133133f, 0.36601004f, 0.19921295f, -0.05976131f, 0.09761786f, 0.10419316f, 0.06935859f, 0.16105849f, 
    0.11714202f, -0.13563234f, 0.03860409f, 0.01688782f, 0.16135383f, -0.04427443f, 0.17768592f, 0.05498588f, 
    0.12006642f, 0.04052782f, 0.10865426f, 0.20334432f, 0.20366800f, -0.01143767f, 0.00040375f, -0.01481731f, 
    -0.09898616f, -0.54980779f, 0.01466506f, -0.11249088f, 0.05242898f, -0.07006772f, -0.19136527f, -0.10031197f, 
    -0.03937514f, -0.09899859f, 0.10087125f, -0.03569952f, -0.00148219f, 0.05458145f, 0.16461995f, 0.12268787f, 
    0.04798527f, -0.01792136f, -0.05694867f, -0.03178819f, 0.10081591f, -0.00210217f, 0.00036772f, 0.11424677f, 
    0.05626236f, -0.32808357f, -0.35256499f, -0.01828220f, 0.06511202f, -0.01423253f, 0.04204655f, -0.09325069f, 
    0.09134539f, -0.09890680f, -0.00126553f, 0.13187560f, -0.20687310f, -0.19975239f, 0.28851569f, 0.07982336f, 
    -0.09574693f, 0.05350415f, -0.05929666f, 0.02131579f, 0.12919492f, -0.00040358f, 0.09786297f, 0.03065089f, 
    0.18895008f, 0.09870720f, 0.08422157f, -0.26043040f, 0.12243818f, 0.08062095f, 0.07255130f, 0.03977592f, 
    0.06339744f, -0.01648152f, 0.04053929f, -0.05835132f, -0.04687800f, -0.34570524f, -0.19197726f, 0.03537564f, 
    -0.03805965f, -0.07756872f, -0.08754978f, -0.17383520f, -0.10040569f, 0.00102945f, -0.00562419f, 0.03952763f, 
    -0.05160339f, 0.07001363f, 0.23627676f, -0.10692523f, -0.01941913f, -0.03471373f, -0.01456758f, 0.03817293f, 
    -0.03943294f, 0.00452303f, -0.15247542f, -0.06550057f, 0.25041139f, 0.32373935f, 0.11002221f, 0.05000196f, 
    -0.10783248f, 0.04146000f, 0.00978820f, 0.06184884f, -0.06872608f, -0.02415903f, 0.01441322f, 0.07115246f, 
    0.28463778f, 0.02581334f, 0.05110854f, 0.03268674f, 0.04578030f, 0.10147988f, -0.05811143f, 0.08824484f, 
    0.05502624f, -0.01735509f, -0.04426531f, 0.03711558f, -0.16100731f, -0.08029648f, 0.00682282f, -0.10604703f, 
    -0.08910840f, -0.00635261f, -0.05322634f, 0.05682207f, 0.01826910f, 0.04963864f, -0.06371564f, -0.10334277f, 
    0.21865098f, 0.12874636f, 0.09132195f, 0.02132237f, 0.04269027f, 0.04703892f, 0.14544567f, 0.09912077f, 
    -0.09302745f, -0.00612335f, 0.02724589f, -0.13899066f, 0.28150082f, 0.14554307f, 0.09141807f, -0.13571133f, 
    0.01318194f, -0.17882735f, -0.02098775f, 0.17325830f, 0.11928290f, 0.01646980f, 0.02527003f, -0.10150139f, 
    -0.17480752f, 0.23891096f, -0.13327712f, 0.15931533f, -0.08985745f, -0.06452757f, 0.02977873f, 0.08422147f, 
    0.05797321f, 0.01022606f, -0.02111836f, 0.07468142f, -0.04593104f, 0.15907268f, -0.08807551f, 0.02668518f, 
    0.00298290f, -0.08182359f, 0.00095126f, -0.08032639f, 0.05342629f, 0.15596806f, -0.10723562f, 0.01351253f, 
    -0.06531541f, 0.24518269f, 0.01046726f, -0.24010618f, 0.01857194f, 0.13686779f, -0.02260042f, 0.21095803f, 
    -0.05326245f, -0.10801176f, -0.13395065f, -0.02800453f, 0.24273379f, -0.04652273f, 0.24034613f, 0.10374808f, 
    -0.13692643f, 0.08575024f, -0.10420481f, -0.01913956f, 0.06062619f, -0.09801275f, -0.12886347f, 0.02525894f, 
    -0.02841970f, -0.25799453f, 0.15313148f, -0.08777498f, 0.03036614f, 0.00120001f, -0.03955495f, -0.13842295f, 
    0.04700976f, -0.15867427f, 0.16255860f, 0.02376711f, -0.03935711f, 0.19844840f, 0.13069959f, -0.05593067f, 
    -0.04414369f, 0.06855512f, -0.01370862f, 0.03247359f, -0.06760688f, -0.07254047f, -0.15446562f, -0.07497013f, 
    0.03909162f, 0.10940351f, -0.33046514f, 0.13584110f, 0.04817961f, -0.02712749f, 0.02872019f, 0.03475752f, 
    -0.01243785f, -0.15388353f, 0.06683845f, 0.17503883f, -0.14568868f, 0.19924824f, 0.11450151f, -0.03594388f, 
    -0.05397378f, -0.01095595f, -0.03474681f, -0.18844347f, 0.17094372f, -0.10246093f, 0.12644602f, 0.20518923f, 
    0.25932613f, 0.04363495f, 0.01636761f, -0.10237541f, 0.06114779f, 0.14480399f, -0.15899433f, -0.09148356f, 
    0.01591390f, -0.15196049f, 0.07512700f, 0.04964026f, 0.14134713f, 0.01149786f, -0.01671908f, -0.05468941f, 
    -0.03916645f, -0.07704347f, -0.03704205f, -0.01062974f, -0.03146443f, -0.11815742f, 0.01079620f, 0.02592058f, 
    -0.00182163f, 0.19434454f, 0.16562380f, -0.08323865f, -0.05772022f, 0.17266962f, 0.11886095f, -0.07619199f, 
    0.03988143f, 0.07562707f, -0.08993196f, 0.13156573f, 0.19195096f, 0.30673441f, -0.08852673f, -0.02610596f, 
    0.04022082f, 0.09846395f, 0.01851024f, 0.12268282f, 0.01526459f, 0.05623498f, -0.09733233f, -0.00381808f, 
    0.04072541f, -0.07862311f, 0.00324394f, -0.12559707f, -0.02324626f, 0.04438921f, 0.10888803f, 0.06508952f, 
    -0.08607719f, -0.16488983f, -0.11663514f, -0.01885090f, 0.06257205f, -0.05855349f, -0.07374081f, -0.23885679f, 
    0.00250415f, 0.04907553f, 0.15381809f, -0.04727957f, 0.02192308f, 0.09153595f, 0.00739067f, 0.00315996f, 
    0.19387190f, 0.12055786f, -0.24394836f, -0.10002449f, -0.00106922f, -0.03565651f, 0.00646099f, 0.16858785f, 
    0.06232215f, -0.01894628f, -0.06260106f, -0.12431246f, 0.01966834f, 0.15119106f, -0.00394790f, 0.00479910f, 
    -0.08434781f, 0.14470746f, 0.02923189f, 0.12401854f, 0.00926300f, 0.03607246f, 0.14069520f, 0.01439731f, 
    -0.08733531f, 0.01815699f, -0.08008318f, -0.00767611f, -0.10500757f, -0.03458454f, -0.04409206f, -0.05132696f, 
    -0.04701519f, 0.04201668f, -0.02324468f, 0.03622587f, -0.08650327f, 0.00228334f, -0.05671095f, -0.07075888f, 
    -0.09415181f, -0.05668850f, -0.09245941f, 0.02358714f, -0.01784386f, 0.02052730f, 0.00482395f, -0.05873564f, 
    -0.01205129f, -0.09544492f, -0.01115496f, -0.02695634f, -0.06926204f, 0.00578954f, -0.04956777f, -0.09270728f, 
    -0.07845154f, -0.04697676f, 0.00379628f, 0.00584556f, -0.10142209f, -0.00952396f, -0.05437727f, -0.03642228f, 
    0.01656238f, -0.03723523f, 0.00398494f, -0.08583453f, -0.01426818f, 0.02217042f, -0.03248330f, 0.03236341f, 
    0.02060623f, 0.04513862f, -0.04177538f, -0.06741238f, 0.01211251f, -0.03811309f, -0.06560000f, -0.06607018f, 
    -0.05677674f, -0.08980609f, -0.04835309f, -0.04094679f, -0.01114614f, 0.00850963f, -0.01564480f, 0.00103830f, 
    -0.07091583f, 0.03671681f, -0.04825115f, -0.03130390f, 0.03069695f, -0.09445795f, -0.07643335f, 0.01915432f, 
    -0.06164056f, 0.00815271f, 0.04173329f, -0.07099284f, 0.03689744f, 0.02316367f, -0.05364360f, -0.04430657f, 
    0.01858858f, 0.01084029f, 0.03196089f, -0.02989434f, -0.03971738f, -0.06910656f, 0.02187800f, 0.05653008f, 
    0.00965144f, 0.01427005f, 0.02595656f, 0.04015654f, 0.02829056f, 0.02969439f, -0.01802720f, 0.04007632f, 
    -0.04399742f, -0.06512494f, 0.02708947f, -0.09082237f, 0.05755051f, 0.01301823f, -0.08900042f, 0.01290748f, 
    0.02468587f, -0.06292064f, 0.00028446f, -0.02930231f, -0.02640813f, -0.05805571f, -0.03929833f, -0.07063867f, 
    -0.06725867f, -0.00394119f, -0.08803264f, -0.00274984f, -0.03068033f, -0.00340470f, -0.00265267f, -0.05448456f, 
    -0.06055218f, -0.04205482f, -0.04149753f, -0.01072227f, -0.09335257f, -0.00967556f, -0.06053734f, 0.01336384f, 
    -0.03511948f, -0.00049091f, 0.01507474f, -0.05941782f, -0.06429042f, -0.09084968f, -0.07892889f, -0.05411535f, 
    -0.07790121f, -0.05044782f, -0.05514033f, 0.00101221f, -0.09942031f, 0.03908033f, -0.07617672f, 0.00863021f, 
    0.01998771f, -0.02103596f, -0.01331308f, -0.04216909f, 0.00473628f, -0.04079486f, -0.05136916f, 0.03989760f, 
    -0.05902535f, -0.08875362f, 0.05800117f, -0.03018425f, -0.03009668f, -0.01632095f, 0.03476687f, 0.02193156f, 
    -0.07027776f, -0.01190800f, 0.01740936f, 0.00620095f, -0.02044403f, -0.06925749f, -0.09320002f, -0.08893144f, 
    -0.04991418f, -0.10404719f, -0.01283183f, 0.01450440f, -0.00929920f, -0.09040979f, -0.00489098f, 0.01498383f, 
    -0.03321251f, -0.05314384f, 0.03171822f, -0.06740417f, -0.00318996f, 0.02349521f, -0.07160221f, 0.03596576f, 
    -0.00845189f, -0.01379316f, 0.03531801f, -0.02109667f, 0.02044852f, 0.00980024f, -0.08277439f, -0.02169312f, 
    0.25033331f, 0.07233032f, -0.19647740f, -0.10811339f, 0.13349096f, -0.02137596f, 0.18975407f, 0.04836488f, 
    -0.12197216f, 0.09463597f, -0.07005846f, 0.12872475f, 0.01310908f, 0.09249135f, -0.16424344f, 0.01043112f, 
    0.06386348f, -0.16057082f, -0.04033484f, -0.05092528f, 0.08603053f, 0.14457043f, 0.02849037f, 0.14971782f, 
    -0.28125608f, 0.05940693f, 0.04387258f, -0.30743414f, 0.05374314f, 0.01389533f, 0.06171138f, -0.06464807f, 
    -0.12233024f, -0.05815443f, -0.03689152f, 0.04675213f, -0.13484076f, 0.11549164f, 0.17943127f, -0.08028568f, 
    0.12376385f, 0.00115492f, -0.03462977f, -0.05008264f, -0.06192087f, 0.02883833f, 0.10376438f, 0.03003121f, 
    0.08088828f, 0.00698276f, 0.00517320f, 0.14881411f, -0.03030725f, -0.01114972f, -0.16021547f, -0.14537366f, 
    0.03560594f, -0.23640147f, 0.10382592f, -0.07429343f, 0.02001551f, 0.07935776f, 0.03048363f, -0.05463826f, 
    0.11749246f, -0.01014712f, 0.15663171f, 0.24262029f, 0.12087783f, -0.05264284f, 0.02569785f, -0.08180339f, 
    0.35675102f, -0.02630361f, -0.10344756f, 0.08624262f, -0.04335636f, 0.00453895f, -0.03905631f, 0.02502168f, 
    0.09288529f, -0.14211538f, 0.00633213f, 0.15078621f, 0.17767543f, -0.03597370f, 0.03013127f, -0.02640489f, 
    0.03222220f, -0.16143025f, -0.03226763f, -0.08684377f, 0.17887460f, 0.10977237f, 0.15646198f, 0.23806031f, 
    -0.02791280f, 0.07263763f, -0.03602320f, -0.07612987f, 0.06699157f, -0.00487815f, 0.06508844f, -0.06125957f, 
    -0.09016776f, -0.03791007f, -0.00865469f, 0.01747596f, -0.14324832f, -0.00856994f, 0.17969175f, -0.03589069f, 
    -0.09682509f, -0.00691911f, -0.11806937f, 0.00426701f, 0.13321711f, -0.04679827f, 0.14698978f, -0.01318834f, 
    -0.00820632f, -0.06386691f, -0.10834226f, 0.04074406f, 0.08787181f, -0.03840203f, 0.06704485f, 0.00309858f, 
    0.15700209f, 0.09403557f, 0.01600748f, 0.19508828f, -0.00294450f, 0.13531125f, -0.09443379f, 0.00419862f, 
    0.02409098f, 0.10517091f, 0.00393991f, -0.14276657f, -0.10101112f, -0.06872124f, -0.06053980f, -0.19182499f, 
    -0.04249165f, 0.10448397f, -0.05987226f, -0.13222627f, -0.00703698f, 0.06008449f, 0.10069078f, 0.26907182f, 
    0.01951189f, 0.05471222f, -0.19118781f, -0.11718041f, -0.45165399f, 0.04909407f, 0.14888759f, -0.20326672f, 
    -0.25285992f, 0.04216646f, 0.06673660f, 0.20421754f, -0.00200765f, 0.08885511f, 0.09871870f, -0.00162976f, 
    -0.29165512f, 0.10809665f, 0.01668225f, -0.13515277f, 0.06315994f, 0.11390140f, -0.00981741f, 0.05213549f, 
    0.13985850f, 0.02561143f, -0.07028238f, 0.02427766f, -0.06416960f, -0.02960168f, 0.13157049f, -0.08626334f, 
    -0.03104353f, 0.17751834f, -0.00762157f, 0.04072331f, 0.00732777f, -0.09306314f, 0.03416175f, 0.03939327f, 
    -0.08039650f, 0.39813688f, 0.05475064f, 0.04078510f, 0.25234818f, 0.04189385f, 0.07858055f, -0.09371237f, 
    -0.13864768f, -0.03931123f, 0.04030653f, 0.00585909f, 0.10534330f, -0.28666264f, 0.00719064f, 0.00080216f, 
    0.17282021f, -0.06838391f, -0.02200997f, -0.05299587f, 0.03746515f, -0.02381065f, -0.00465401f, 0.08711604f, 
    -0.22052626f, -0.27576095f, 0.04463051f, 0.14568755f, -0.08412717f, -0.13070792f, 0.11997799f, -0.04017717f, 
    -0.00321059f, -0.16404082f, 0.05768027f, 0.23518105f, -0.42238155f, 0.06811199f, 0.02299142f, 0.27233738f, 
    0.03317196f, 0.10370455f, -0.01022690f, 0.07578518f, 0.01866264f, 0.04160598f, 0.19242615f, 0.17419662f, 
    0.01157129f, 0.12130235f, -0.12359676f, 0.00726613f, -0.09144465f, 0.10436604f, 0.06356402f, 0.03373519f, 
    -0.03107993f, 0.08818705f, 0.06954833f, 0.05133376f, 0.04779124f, -0.15148512f, 0.15849075f, 0.35535040f, 
    0.12621109f, -0.09956038f, 0.08969661f, -0.01393718f, 0.26317194f, 0.15896587f, 0.15264772f, 0.19615965f, 
    -0.28317276f, -0.01709131f, 0.36839864f, 0.03865532f, 0.07465760f, 0.12836769f, -0.13505255f, 0.12557213f, 
    -0.04960307f, 0.06062170f, -0.01408247f, -0.03487239f, 0.33676258f, -0.29115254f, -0.03155389f, 0.08511440f, 
    -0.07247155f, -0.20936266f, -0.05475954f, -0.21265374f, 0.02929488f, 0.17137316f, 0.10292457f, 0.09167961f, 
    -0.14698565f, 0.07061917f, 0.06894315f, 0.26066610f, -0.00723666f, 0.05439417f, 0.24497181f, 0.01801709f, 
    -0.08179586f, 0.09126625f, 0.05075443f, -0.02191984f, 0.01244264f, -0.12602527f, 0.01053373f, 0.08659479f, 
    0.12712805f, 0.01087024f, -0.00704198f, -0.05864423f, 0.04455598f, 0.18803933f, 0.14714327f, 0.03925157f, 
    0.25401747f, -0.11061309f, 0.04840265f, 0.09585591f, 0.07013930f, -0.04244519f, 0.03286811f, -0.02359246f, 
    -0.00107179f, -0.13234270f, -0.05826840f, -0.06618633f, 0.06203116f, 0.06315316f, 0.14476673f, -0.00403506f, 
    -0.09439760f, -0.01045684f, 0.03647829f, -0.01676633f, 0.06667584f, -0.02524424f, -0.01919159f, -0.02333287f, 
    0.26433423f, -0.00707273f, 0.32719442f, 0.31492504f, 0.10333510f, -0.19367769f, 0.05882787f, 0.20328175f, 
    0.00610146f, 0.01665311f, 0.09636821f, -0.01841585f, -0.09044477f, 0.29304746f, 0.30880588f, 0.17682156f, 
    0.03116060f, -0.17191082f, -0.11905803f, 0.04471350f, -0.01554989f, 0.01678812f, -0.00497369f, -0.05843934f, 
    -0.09251457f, 0.23877575f, 0.17390732f, 0.16485821f, 0.02606326f, 0.02992875f, -0.05392255f, -0.03804522f, 
    0.05073259f, -0.16645439f, 0.01242484f, 0.12002676f, 0.07859010f, -0.12280017f, 0.05242326f, -0.15012869f, 
    -0.05231586f, -0.04445878f, 0.08407822f, 0.05641090f, -0.20349056f, -0.07026052f, -0.24070807f, -0.25686255f, 
    0.26024541f, 0.07157016f, 0.18195488f, -0.23171587f, 0.15219040f, 0.15300050f, 0.07311469f, 0.14992051f, 
    -0.09611737f, 0.10564431f, 0.01519858f, -0.06425571f, -0.17103434f, 0.05170977f, 0.12830967f, -0.06679036f, 
    0.13562171f, -0.00999631f, -0.02974048f, -0.02854726f, -0.16495900f, -0.01974525f, 0.11120444f, -0.09339675f, 
    0.13801500f, 0.34982416f, 0.06693148f, -0.08231281f, 0.06880657f, 0.04524130f, 0.06828934f, -0.00163611f, 
    -0.15857480f, -0.01947535f, -0.06957743f, 0.11473051f, 0.18545045f, -0.04517677f, -0.12316738f, 0.02487865f, 
    0.14101364f, -0.03424773f, 0.20783257f, 0.05009105f, -0.03734686f, -0.10667974f, 0.19849046f, 0.03397292f, 
    0.19693241f, 0.10379244f, 0.07420032f, 0.15627857f, -0.05623027f, 0.03936686f, 0.06773578f, 0.05633710f, 
    0.03918532f, 0.02545054f, 0.04094960f, 0.05332364f, 0.08686832f, 0.01702537f, 0.03461556f, -0.00776845f, 
    0.11869755f, 0.06099786f, -0.11933859f, 0.15872248f, 0.08915704f, 0.10955137f, 0.13520128f, -0.12628959f, 
    0.42416844f, -0.18151262f, 0.24851760f, 0.15489042f, 0.04534757f, -0.06210632f, -0.09161436f, 0.05599767f, 
    -0.06913929f, 0.12495790f, 0.04463928f, 0.16125287f, 0.18558848f, -0.04600685f, 0.22630306f, -0.00977807f, 
    0.02837641f, -0.09482110f, -0.11491109f, 0.10083999f, 0.00009426f, 0.22658476f, 0.02560950f, 0.03717384f, 
    0.14736116f, 0.13631175f, -0.03058290f, -0.20350417f, 0.02723413f, -0.10475308f, 0.04656265f, 0.04374124f, 
    0.00709780f, -0.02713498f, -0.10393870f, 0.01756582f, -0.03286858f, -0.05113851f, 0.12931743f, 0.13564891f, 
    -0.13533162f, -0.08391628f, -0.01554555f, 0.02926157f, 0.16864452f, -0.02096920f, 0.13315089f, 0.03496946f, 
    0.12378420f, -0.00940872f, 0.00261991f, -0.10191455f, 0.06420676f, -0.21640776f, -0.15195040f, -0.06105831f, 
    -0.11126896f, 0.01967982f, 0.15016352f, -0.00389153f, 0.04293638f, -0.09886713f, -0.01069543f, -0.22607087f, 
    -0.25121018f, 0.03174457f, -0.07628358f, -0.07375272f, -0.03712815f, -0.00590020f, -0.00246889f, 0.04015719f, 
    0.13181029f, 0.03367155f, -0.06459738f, 0.00437920f, 0.04755971f, 0.01799526f, 0.11941928f, -0.06162030f, 
    0.07403041f, -0.06342904f, 0.01372567f, 0.00008861f, -0.45552459f, -0.13384216f, 0.01614670f, -0.13577607f, 
    -0.08289639f, 0.14319217f, -0.14629616f, 0.18719585f, -0.15197250f, 0.18827163f, -0.04334890f, -0.08248410f, 
    -0.01497493f, -0.22209379f, 0.06421941f, -0.20996341f, 0.00588079f, 0.09221399f, 0.07332335f, 0.12510939f, 
    0.06673246f, -0.08937971f, 0.02403522f, 0.01504702f, 0.03175191f, -0.00884389f, -0.08842142f, -0.03734623f, 
    -0.00151265f, -0.13735063f, -0.08193135f, -0.18267180f, -0.17872486f, -0.13828473f, -0.06280421f, -0.04063388f, 
    -0.19060667f, 0.28994831f, -0.49160451f, 0.14337695f, 0.05726688f, -0.13476598f, 0.06216665f, -0.05441850f, 
    0.11934780f, -0.09155855f, -0.05743679f, 0.01515681f, 0.24886544f, 0.00783972f, -0.11366344f, -0.00912618f, 
    0.05108370f, -0.05017895f, 0.03385310f, 0.07898337f, -0.04691342f, -0.13284567f, -0.01583112f, -0.03944834f, 
    -0.49876884f, 0.08697917f, 0.11694685f, -0.15518360f, -0.05893034f, -0.06723602f, -0.08690261f, 0.01088931f, 
    0.05229047f, 0.01670977f, -0.06432374f, -0.02085040f, -0.10187866f, -0.38704956f, 0.32757169f, 0.34975183f, 
    -0.09961137f, 0.03517558f, -0.14485544f, 0.05677893f, 0.11128345f, 0.14514817f, -0.01444992f, -0.14171508f, 
    -0.02792476f, -0.28116640f, -0.06902930f, 0.09250198f, 0.05745441f, -0.03593392f, -0.09177496f, -0.00539711f, 
    -0.01177468f, -0.11543665f, 0.01229634f, -0.04246956f, -0.09315860f, 0.15428939f, 0.17808415f, 0.31303510f, 
    0.06831337f, 0.05018727f, -0.08202017f, -0.01110559f, 0.10134155f, 0.02525042f, 0.00376734f, -0.01377915f, 
    0.09854575f, -0.11613851f, -0.11461563f, -0.21612063f, 0.08327115f, -0.03538658f, 0.04321935f, -0.10485692f, 
    0.09078056f, -0.03799687f, 0.02031984f, -0.02027385f, -0.02455200f, -0.11279912f, 0.10917800f, 0.24117270f, 
    0.03005794f, -0.01515861f, 0.00889349f, -0.08441258f, 0.13431187f, -0.03244673f, 0.03770803f, 0.06345336f, 
    0.13821660f, -0.50311428f, 0.03292526f, -0.28216410f, -0.03157063f, 0.10560655f, -0.07690609f, 0.07031368f, 
    0.17344806f, 0.08016872f, 0.05867765f, 0.10404360f, 0.16925503f, 0.08432843f, 0.21450777f, 0.25598362f, 
    -0.08846932f, -0.10440053f, -0.00030149f, 0.01491738f, -0.09662702f, 0.02943702f, 0.03319193f, 0.10263386f, 
    -0.04665394f, 0.09784668f, 0.10642283f, -0.10563537f, 0.02779922f, 0.08367163f, 0.17948209f, 0.07638438f, 
    -0.02744692f, -0.02967705f, -0.17899439f, -0.03398952f, 0.15760465f, 0.35657278f, 0.06530962f, -0.07265625f, 
    0.03976762f, 0.00611899f, 0.07905084f, 0.03642970f, 0.03168776f, 0.03170954f, -0.04635642f, -0.04468948f, 
    -0.00192264f, 0.05488813f, 0.16575088f, 0.13141888f, -0.01047528f, -0.18054502f, -0.02240555f, 0.09598751f, 
    0.07777883f, 0.01130199f, 0.07501451f, -0.08650780f, 0.03866458f, 0.31662849f, 0.33181739f, -0.21119991f, 
    -0.12760763f, -0.25710431f, 0.02426002f, -0.05269684f, 0.09276446f, 0.02594156f, -0.03928815f, 0.09820597f, 
    0.17507412f, 0.08745094f, 0.01123109f, -0.04754028f, -0.09464504f, -0.06156578f, -0.10926289f, 0.03055689f, 
    0.09152252f, 0.06861752f, 0.09843066f, -0.08737364f, -0.01010476f, 0.05971059f, 0.06861855f, -0.08766507f, 
    -0.05872937f, 0.03582223f, 0.01248167f, 0.18715709f, 0.08276813f, -0.02644739f, -0.04899398f, -0.05236486f, 
    -0.28628215f, -0.17041576f, 0.13811782f, -0.15817828f, 0.06864256f, 0.08287583f, -0.08049234f, -0.08838872f, 
    0.00934035f, 0.22899067f, 0.04974441f, -0.00159378f, -0.06052440f, 0.00429306f, 0.08421683f, -0.02112468f, 
    0.10365431f, 0.16226710f, -0.01742679f, -0.07234474f, 0.09652390f, 0.26864195f, 0.23654182f, 0.05850034f, 
    0.25952217f, 0.38633558f, 0.34726495f, 0.17663828f, 0.07253645f, -0.05364603f, 0.03543612f, 0.07411344f, 
    -0.01046178f, 0.01763541f, -0.12492780f, -0.07489066f, -0.39489841f, 0.34847116f, 0.05376408f, -0.10268671f, 
    -0.00366061f, -0.09468807f, 0.22205082f, 0.10709546f, 0.14461212f, -0.04771568f, -0.08866391f, -0.06820610f, 
    -0.16290058f, -0.18255888f, -0.05304942f, -0.16333921f, -0.22905073f, -0.15593325f, 0.02540977f, -0.15179028f, 
    -0.00284234f, -0.04315784f, -0.06350785f, -0.06239772f, 0.09863426f, -0.07238190f, 0.14316466f, 0.02612407f, 
    0.07065382f, -0.01488208f, -0.03174333f, 0.02842773f, 0.06617041f, -0.04327661f, -0.22042874f, -0.19476049f, 
    -0.01034636f, -0.05744933f, -0.10634082f, -0.05298470f, -0.16760267f, 0.09953106f, -0.06242691f, -0.17656796f, 
    -0.10310452f, -0.03077683f, -0.14361516f, -0.01129831f, -0.14333141f, -0.00466573f, -0.04485506f, -0.18348631f, 
    0.06774865f, -0.00179982f, 0.03010140f, -0.04884567f, 0.23050353f, 0.04993207f, -0.01318657f, -0.00969264f, 
    -0.00224242f, 0.36768299f, 0.16995506f, 0.07518641f, 0.13334325f, 0.05027525f, 0.04944354f, 0.00374296f, 
    -0.05889952f, 0.01980121f, 0.06401200f, -0.07937324f, -0.15946452f, -0.17808641f, -0.24585612f, -0.11930039f, 
    0.02986515f, -0.08515093f, -0.10044307f, 0.01298978f, 0.13192897f, 0.11342090f, 0.04115400f, -0.04743466f, 
    0.08573313f, -0.04592157f, -0.04726693f, -0.06687453f, 0.21056595f, 0.09442037f, 0.19547714f, -0.06113932f, 
    0.02963871f, -0.02786030f, 0.14248678f, 0.07193433f, -0.04023623f, -0.06738106f, -0.02728262f, 0.21110523f, 
    -0.00719552f, 0.07107078f, 0.03844265f, -0.00408409f, -0.32351413f, 0.00800371f, -0.01596660f, -0.10301606f, 
    -0.01787346f, 0.15472798f, -0.06914186f, 0.13517778f, 0.07199454f, -0.02893651f, -0.11301424f, -0.01674664f, 
    -0.01218668f, 0.03586256f, 0.02309559f, -0.00760591f, 0.20442751f, -0.04120811f, 0.00294406f, 0.13286625f, 
    0.07531478f, -0.07091722f, -0.02070104f, -0.07856365f, 0.02470542f, 0.21886812f, 0.05148460f, 0.09021623f, 
    0.31430140f, 0.19941708f, 0.32173219f, 0.08670275f, 0.08656152f, 0.01909684f, 0.11640593f, 0.02746136f, 
    -0.04059516f, -0.00380574f, -0.01555622f, -0.06527558f, 0.15681259f, 0.09632871f, 0.10944726f, 0.03135816f, 
    0.13018599f, 0.05801144f, -0.00286366f, 0.21205108f, 0.11605252f, 0.05763032f, -0.01307549f, 0.22854121f, 
    0.00610709f, -0.05090802f, -0.06378748f, 0.01688670f, -0.01376359f, -0.04804013f, -0.06679361f, 0.05204673f, 
    0.06054597f, -0.01250648f, 0.02478950f, 0.00566064f, -0.07572868f, -0.05925225f, 0.04759763f, 0.00915581f, 
    -0.05127596f, 0.03831936f, -0.06311497f, 0.05555946f, 0.00827553f, -0.06317696f, 0.01525838f, -0.03009335f, 
    0.01986790f, -0.06223954f, 0.03783382f, -0.04206926f, 0.06304226f, -0.01353210f, 0.01885023f, -0.03500630f, 
    -0.03426356f, 0.00491453f, 0.02338289f, 0.05186277f, 0.06470300f, -0.03841652f, 0.03134735f, -0.02861511f, 
    -0.02289557f, 0.00814175f, 0.04831107f, 0.06210151f, 0.04260999f, -0.05881922f, -0.04731143f, -0.03647080f, 
    -0.02309447f, -0.06563407f, 0.06255894f, 0.00845510f, 0.00817404f, 0.04757002f, -0.04520890f, -0.06513709f, 
    0.04146239f, 0.00758807f, -0.05969815f, -0.01934414f, 0.04323397f, 0.06249541f, 0.02876768f, 0.01834705f, 
    -0.07200109f, -0.07723769f, 0.02350010f, 0.00236864f, 0.02897951f, 0.05621583f, 0.02176049f, -0.02758258f, 
    -0.00324093f, 0.03351428f, -0.06184496f, 0.05742894f, 0.04928625f, 0.00113376f, 0.02059945f, -0.07165002f, 
    -0.00298460f, -0.05953610f, 0.04682185f, -0.00229454f, -0.05450918f, -0.07242675f, -0.01743680f, -0.07023790f, 
    -0.04198850f, -0.07095564f, 0.06218963f, -0.04333855f, -0.07260250f, -0.00004423f, 0.01167183f, -0.03519752f, 
    -0.04261126f, -0.03434813f, 0.04244941f, -0.06147049f, -0.03454747f, -0.06652721f, -0.05381466f, 0.05298226f, 
    -0.03781061f, -0.05175697f, 0.01878132f, 0.05804319f, -0.02250810f, -0.06956622f, 0.03537976f, 0.06354892f, 
    0.00588529f, -0.06228659f, -0.07528254f, -0.06618436f, 0.04090590f, 0.04883774f, 0.01779010f, -0.07503656f, 
    -0.06941561f, -0.02210251f, -0.03242411f, 0.03546381f, 0.00298251f, 0.01781783f, -0.00441847f, -0.04802355f, 
    0.03437246f, -0.07438781f, -0.05123052f, -0.07500598f, -0.01545418f, -0.01027003f, 0.00403402f, -0.01369033f, 
    -0.05053386f, -0.00932159f, -0.01058295f, -0.06685358f, -0.04493438f, -0.02768356f, 0.00892700f, -0.00813651f, 
    -0.06784079f, 0.01101843f, -0.00021408f, -0.07538959f, -0.06490795f, -0.03590941f, 0.03318333f, 0.01130197f, 
    -0.03017280f, 0.00476840f, -0.01378827f, -0.07605287f, -0.03009204f, 0.02397353f, -0.05234921f, -0.05533044f, 
    0.05457557f, -0.06136739f, -0.03184979f, 0.05579345f, -0.05658745f, 0.01541708f, -0.04145313f, -0.05723446f, 
    0.05039262f, -0.00621771f, -0.04051873f, -0.01473885f, -0.01462141f, -0.03332664f, 0.02459812f, -0.06394346f, 
    -0.00523082f, -0.07300007f, 0.03399609f, -0.00401957f, 0.06244954f, -0.01396075f, 0.02738512f, -0.02313883f, 
    -0.00823659f, -0.03708386f, -0.00725438f, 0.02035466f, 0.02804221f, -0.00983293f, -0.04075458f, 0.00800777f, 
    0.04509278f, -0.05310917f, 0.02457551f, 0.05257140f, -0.05454090f, -0.01515687f, -0.03351287f, 0.04023502f, 
    0.04277355f, -0.01463450f, -0.05957959f, 0.06522552f, -0.04420630f, -0.06031142f, -0.06570663f, -0.00296109f, 
    0.00048975f, 0.01162662f, -0.01685748f, -0.00164368f, 0.01219233f, -0.02288296f, 0.01682516f, -0.02094935f, 
    -0.02489136f, 0.05010841f, -0.04608252f, 0.06232696f, 0.04844375f, 0.00692805f, 0.02181141f, -0.06217709f, 
    -0.00673531f, 0.05776890f, 0.03275352f, 0.05748769f, 0.02498068f, -0.07427177f, 0.00317121f, 0.03460606f, 
    0.02852788f, -0.05285358f, -0.06093509f, -0.02747150f, 0.04317187f, -0.02260789f, -0.01961474f, -0.03014287f, 
    0.01471402f, 0.01385855f, -0.03465500f, 0.05496470f, -0.04090785f, 0.06867886f, 0.03832705f, -0.07336088f, 
    -0.05387476f, -0.07065271f, -0.06255665f, -0.01595581f, -0.04141265f, 0.01922490f, -0.05521053f, -0.02200080f, 
    -0.03351829f, -0.06464802f, -0.06850868f, 0.06045428f, -0.07688654f, 0.06215762f, -0.00748031f, 0.00474284f, 
    -0.05697770f, 0.06244611f, 0.07092131f, 0.06713182f, 0.01880620f, -0.03228956f, 0.04729446f, 0.05306984f, 
    0.00661717f, 0.02019932f, 0.06231636f, -0.05012551f, 0.02523929f, -0.02191149f, -0.03383235f, 0.04867845f, 
    -0.05300476f, -0.02109398f, 0.04942325f, -0.06794818f, 0.01227266f, -0.05070658f, -0.00531609f, -0.06224262f, 
    -0.03486129f, 0.03575623f, 0.02241734f, -0.04586572f, 0.01774470f, -0.00389590f, 0.03768379f, -0.02690743f, 
    -0.05454022f, -0.00068602f, 0.00365069f, -0.06096314f, -0.01986670f, 0.07210846f, -0.02749728f, -0.04765635f, 
    -0.04777366f, -0.05484051f, -0.04489836f, 0.05049552f, 0.03279868f, -0.00330720f, -0.05533610f, 0.01166935f, 
    -0.05603784f, -0.04782141f, -0.03892495f, -0.00826999f, -0.03679373f, -0.00280843f, 0.05685014f, 0.01651858f, 
    -0.07456329f, 0.03990655f, -0.04974323f, 0.00351769f, -0.05241919f, 0.00496778f, 0.04096043f, -0.02973402f, 
    -0.02918524f, 0.02313152f, -0.00690470f, 0.00376208f, -0.05281505f, -0.07705828f, -0.02254719f, 0.01858148f, 
    -0.05463218f, -0.04829282f, -0.01172429f, 0.00151965f, 0.03753136f, -0.03903329f, -0.06507827f, -0.06561656f, 
    -0.06204852f, -0.03710547f, 0.00913154f, -0.04490589f, -0.06247547f, -0.00317587f, -0.00840986f, -0.03482191f, 
    -0.07221721f, 0.05795227f, -0.04974829f, 0.05454433f, -0.02452019f, 0.00822159f, -0.05387544f, -0.07372752f, 
    0.05838873f, -0.00253795f, -0.01434383f, 0.00479683f, 0.01860581f, 0.00174993f, 0.05061517f, 0.02220779f, 
    0.03608521f, -0.03778315f, 0.01155228f, 0.01260774f, 0.04627703f, -0.03893379f, 0.05549086f, 0.01689384f, 
    -0.03111210f, -0.04620736f, -0.05817941f, 0.00579533f, -0.04580861f, 0.00243599f, 0.00441690f, 0.05156483f, 
    -0.02580127f, -0.06293188f, 0.00348386f, -0.05238775f, -0.06174352f, -0.02453263f, -0.02052519f, -0.02993872f, 
    0.04656508f, -0.06259485f, -0.04623268f, -0.05220759f, 0.03777789f, -0.03247507f, -0.06507505f, 0.04773527f, 
    -0.01594180f, 0.01779146f, 0.05146247f, 0.05296656f, -0.01986148f, 0.02920166f, -0.04439745f, -0.04999289f, 
    -0.03260496f, 0.05141552f, -0.01984788f, 0.00996487f, 0.00764860f, 0.01389796f, 0.02157703f, 0.04066493f, 
    0.00546906f, -0.01587499f, 0.03453011f, -0.00185609f, -0.03506747f, -0.07598110f, -0.06035438f, 0.05940860f, 
    -0.00655297f, 0.03478736f, 0.02596287f, -0.00358426f, -0.07393256f, 0.06328654f, -0.06072924f, -0.00067927f, 
    -0.07533746f, -0.00307166f, -0.03840670f, -0.02332855f, -0.06953356f, 0.02914009f, 0.06195596f, -0.03395605f, 
    -0.07122769f, 0.02985290f, 0.01024317f, 0.04430711f, -0.01792938f, -0.01949583f, 0.00507331f, 0.02399746f, 
    -0.04342780f, 0.01005705f, -0.04530589f, -0.03699370f, -0.02780327f, -0.04425026f, -0.01608690f, 0.06140658f, 
    -0.03228804f, -0.05915162f, 0.05152825f, -0.00252671f, 0.04435660f, -0.00460736f, -0.04035444f, 0.03337580f, 
    -0.07606242f, -0.06012575f, -0.07034330f, -0.05814017f, 0.05973420f, -0.03455564f, -0.00892666f, 0.03757547f, 
    0.01871350f, -0.06140672f, 0.06237730f, -0.01897256f, 0.00201014f, 0.06373187f, -0.05046397f, 0.03887364f, 
    -0.04653313f, -0.07089201f, -0.03392261f, -0.00585124f, -0.04648900f, 0.00542890f, 0.03855467f, -0.02546046f, 
    0.01818484f, -0.00335261f, 0.05900911f, -0.03944473f, 0.05584636f, -0.02676510f, 0.05384728f, 0.04555146f, 
    -0.06208230f, -0.03524121f, -0.04865355f, 0.02970184f, -0.04320836f, -0.05719110f, -0.02795996f, -0.02712891f, 
    0.02904098f, 0.03061948f, -0.05279146f, -0.04729626f, -0.04998381f, 0.03220011f, 0.01811490f, -0.03904282f, 
    0.02448244f, -0.03762227f, 0.00880079f, 0.01871543f, 0.00639386f, 0.01024461f, 0.01747497f, 0.06269826f, 
    -0.03285316f, -0.00561602f, 0.04952241f, -0.04556486f, -0.04951074f, -0.05339032f, 0.06379567f, 0.00315341f, 
    -0.02820668f, -0.01213474f, -0.00228549f, -0.07305445f, 0.06221729f, -0.05165343f, -0.02751843f, -0.03352690f, 
    -0.03659575f, -0.05897174f, -0.07717163f, -0.02485554f, -0.02689056f, -0.05391608f, -0.07244049f, -0.07239724f, 
    -0.03038187f, -0.06503131f, 0.03192809f, 0.05047302f, -0.03083298f, 0.04051213f, -0.02207342f, 0.02073173f, 
    0.05856659f, -0.01322635f, -0.03975731f, -0.01266776f, -0.00369068f, -0.02090253f, 0.06243244f, -0.06138612f, 
    -0.03747912f, 0.04174552f, 0.02436283f, -0.00813136f, -0.04921485f, -0.01385394f, -0.06347124f, -0.01498335f, 
    0.02998794f, 0.01964718f, 0.01215643f, 0.06995961f, 0.03667821f, -0.06654817f, -0.07385552f, 0.04395115f, 
    -0.26800704f, -0.46509099f, -0.11607294f, -0.05936356f, 0.00009368f, -0.01486006f, -0.09238184f, -0.03185245f, 
    -0.01588887f, 0.08687752f, 0.05344636f, 0.05114902f, -0.01970014f, 0.10440954f, 0.09075548f, -0.02888567f, 
    0.00078560f, 0.05586641f, 0.00127069f, 0.10848593f, 0.02820366f, 0.14119713f, 0.00676531f, 0.00538869f, 
    0.02551712f, 0.33080447f, 0.02526832f, -0.12642357f, 0.02309131f, 0.10112821f, 0.08154010f, 0.10842342f, 
    -0.04383064f, -0.06366276f, -0.03623288f, -0.14022753f, 0.13717444f, -0.14925113f, 0.22462504f, 0.25670487f, 
    -0.20961457f, 0.06970309f, -0.01092864f, -0.22802906f, -0.14208198f, -0.11047687f, -0.22802804f, 0.02799109f, 
    -0.36328590f, -0.31105563f, -0.14394081f, -0.27789280f, -0.01558318f, -0.00419214f, -0.00141280f, -0.06567470f, 
    0.06442835f, -0.05617051f, 0.08950226f, 0.00006763f, -0.13017634f, 0.16716437f, 0.05217808f, -0.07222055f, 
    -0.06594787f, -0.01193129f, 0.05995648f, 0.02272727f, -0.05670852f, -0.14966638f, 0.02392281f, 0.09501246f, 
    0.15053727f, -0.17481866f, -0.28170872f, -0.02821510f, -0.09553527f, -0.01611038f, -0.02250997f, -0.13620193f, 
    -0.06661462f, -0.07518478f, 0.05679523f, 0.11741675f, -0.40611723f, 0.00041421f, -0.02230754f, -0.24282816f, 
    -0.12239552f, 0.16945937f, 0.00091726f, 0.07576531f, 0.00886896f, 0.01498537f, 0.07249921f, 0.02341520f, 
    0.31708741f, 0.10196268f, -0.02486930f, -0.00750534f, 0.05025829f, -0.02537669f, -0.02140571f, -0.12003130f, 
    -0.00904001f, -0.10411114f, -0.00980016f, -0.06943246f, -0.12387224f, -0.09910918f, -0.18388361f, -0.00309297f, 
    0.00975896f, 0.03288432f, -0.04391851f, 0.07518388f, -0.01866997f, 0.01100231f, 0.01917041f, 0.14511189f, 
    0.08182465f, 0.29463601f, 0.28299007f, 0.16227169f, 0.00842322f, -0.00492994f, -0.07904086f, 0.27957565f, 
    -0.03623615f, 0.02487946f, -0.18811519f, 0.08356718f, 0.33078399f, 0.18788539f, 0.18641701f, 0.13748543f, 
    -0.02629573f, -0.05143068f, -0.11439314f, 0.07474556f, -0.02742997f, 0.06184762f, -0.10074401f, 0.07241341f, 
    0.02867837f, 0.05758804f, 0.06897213f, -0.06596249f, 0.09563501f, 0.18004182f, 0.01819313f, 0.05102194f, 
    0.05296808f, -0.08364851f, -0.16130556f, 0.00444989f, 0.15919811f, 0.04991295f, -0.10827713f, 0.04734606f, 
    0.06033342f, -0.00787665f, 0.14157452f, 0.06846520f, 0.02944749f, 0.01171437f, -0.05673711f, -0.07650184f, 
    0.20865220f, 0.16848290f, -0.04768340f, 0.12706310f, 0.07168208f, 0.03513664f, -0.03995653f, 0.04953468f, 
    -0.09100221f, -0.05286932f, -0.18624794f, -0.11604180f, 0.19867416f, 0.26228809f, 0.22015035f, 0.19034320f, 
    0.04790559f, 0.06457177f, 0.05785990f, 0.15771462f, 0.10200038f, 0.08218433f, 0.03139563f, 0.04000006f, 
    0.36627901f, -0.07860695f, 0.32263204f, -0.06713864f, 0.03489486f, 0.10023442f, -0.04627253f, -0.07667147f, 
    0.04804308f, 0.00331592f, 0.00474112f, -0.08989114f, 0.04985543f, -0.21400160f, 0.05132173f, -0.06785508f, 
    0.04779588f, 0.08493523f, 0.11670646f, 0.02917035f, -0.01502656f, -0.23876576f, 0.01092230f, -0.30827013f, 
    0.10727330f, 0.14414829f, 0.22053595f, 0.27980036f, -0.03318381f, 0.01523556f, 0.11228709f, -0.14210442f, 
    0.06710242f, 0.03914509f, 0.08618212f, 0.24211684f, -0.24655133f, -0.15460710f, -0.08679821f, 0.17159978f, 
    0.12899148f, -0.00682219f, 0.09363776f, 0.02241193f, -0.04055642f, 0.07176688f, 0.15239294f, 0.05614917f, 
    0.09429635f, 0.18442215f, -0.19192111f, 0.23264736f, -0.10208763f, -0.05504258f, 0.09207509f, 0.09917599f, 
    0.01388538f, 0.07470015f, -0.04023261f, -0.13967261f, -0.03255080f, -0.24667680f, 0.05307735f, 0.16873625f, 
    0.01289991f, -0.04854941f, -0.05884951f, -0.05855210f, 0.08345830f, 0.14330727f, 0.25500774f, 0.24919724f, 
    0.23411623f, -0.16499469f, 0.45262864f, -0.04317052f, 0.03772323f, 0.03774753f, -0.17023224f, -0.00511680f, 
    -0.02764548f, 0.26124060f, -0.08886985f, -0.14661534f, -0.01953643f, -0.16428433f, 0.11179417f, 0.16673739f, 
    0.04711606f, 0.06632450f, -0.16386326f, 0.12095051f, -0.03947671f, 0.10011554f, -0.06414296f, -0.25015545f, 
    -0.15897496f, 0.02288127f, -0.06509727f, 0.06393619f, -0.05891797f, -0.04816956f, 0.10228330f, 0.07873676f, 
    0.03348402f, 0.06531960f, 0.02749388f, 0.03922286f, -0.07512772f, -0.09828448f, 0.00784449f, 0.13459693f, 
    0.10201526f, 0.04734093f, 0.04838528f, -0.00482540f, -0.07190587f, 0.16273160f, -0.10677220f, -0.01950336f, 
    0.05660381f, -0.08155569f, 0.13701279f, 0.06072544f, 0.02802394f, 0.01891514f, 0.01736985f, 0.04966117f, 
    -0.12289316f, -0.22156413f, -0.07273535f, -0.25538814f, -0.03716341f, -0.14575595f, 0.22198479f, -0.06834479f, 
    0.10329503f, -0.06827990f, -0.04934627f, -0.13126898f, 0.17512459f, 0.00802703f, 0.01544959f, 0.07539321f, 
    0.12113256f, -0.03693953f, 0.11163127f, 0.11651240f, 0.12518390f, -0.06508970f, -0.02817333f, -0.05439854f, 
    0.05708161f, 0.06205368f, 0.10960175f, 0.16954674f, -0.08078685f, 0.21486259f, 0.11304652f, -0.02122352f, 
    0.01967531f, -0.09748686f, -0.27494162f, 0.14301547f, -0.03622411f, -0.02259574f, 0.04754253f, -0.09147993f, 
    0.02999509f, 0.08093520f, 0.24954352f, 0.01516111f, 0.10794391f, -0.09424433f, 0.04647328f, 0.00838897f, 
    -0.08582905f, -0.04257286f, 0.05676141f, 0.14578691f, -0.01703483f, 0.07619626f, 0.01684975f, -0.05676922f, 
    0.09059842f, -0.19898851f, 0.03531757f, -0.20219766f, -0.10033239f, -0.13700014f, -0.14949429f, -0.05328993f, 
    0.15943691f, 0.05154650f, 0.21624675f, -0.18189818f, 0.03407240f, 0.09535614f, -0.03105217f, 0.09839202f, 
    -0.06544382f, 0.10475988f, 0.04118461f, 0.20316203f, -0.20449494f, 0.02955922f, 0.05785177f, 0.03573967f, 
    0.11697870f, 0.05139195f, -0.03433048f, -0.05280708f, -0.05114534f, 0.15259089f, 0.06217426f, 0.12835662f, 
    0.27491444f, 0.19259095f, -0.06655244f, 0.00447489f, 0.02969597f, -0.03598103f, 0.13313967f, -0.07552667f, 
    -0.02431226f, 0.02270586f, -0.01254824f, 0.02698044f, 0.00022960f, 0.06806985f, -0.25255635f, 0.00211537f, 
    0.08012464f, -0.03089324f, 0.09009314f, -0.04366344f, 0.06049030f, -0.00740380f, 0.14940920f, 0.01017477f, 
    -0.08176203f, 0.06394871f, 0.01592258f, -0.00390947f, -0.11983059f, -0.14706591f, 0.02695172f, -0.08457821f, 
    -0.19037567f, -0.04107620f, -0.03552401f, 0.00998829f, 0.02727121f, 0.00309409f, 0.02561931f, -0.11697990f, 
    0.06155072f, -0.08171447f, 0.08598713f, 0.14998554f, 0.05867662f, 0.02578127f, -0.00017562f, -0.23574522f, 
    0.12154017f, -0.03945626f, 0.17955765f, 0.06306141f, -0.04483847f, 0.08503209f, -0.03521076f, 0.05213531f, 
    -0.02050796f, 0.00484426f, 0.02773198f, 0.06119530f, 0.10259967f, 0.17911479f, -0.09688304f, -0.14129750f, 
    0.15851474f, -0.17672831f, 0.06624383f, -0.06097173f, 0.13329175f, 0.23001350f, -0.02078100f, 0.28380802f, 
    -0.00754480f, 0.31821430f, -0.16262744f, 0.16776282f, -0.01152155f, -0.00281556f, 0.03147537f, -0.02842167f, 
    0.03047864f, 0.04278335f, 0.00521047f, 0.11435547f, -0.25794926f, -0.15361547f, -0.10758015f, -0.09890699f, 
    -0.13160817f, -0.05387896f, -0.11854112f, -0.14078331f, 0.12432360f, -0.04604885f, 0.11159759f, -0.00960189f, 
    0.18232435f, 0.00416598f, -0.09385595f, 0.02176609f, 0.02124324f, 0.03417016f, -0.02178120f, -0.10570844f, 
    0.09006117f, 0.02381245f, 0.10608613f, 0.06931514f, -0.05549897f, -0.33111417f, -0.03596020f, -0.02384460f, 
    -0.06380063f, 0.05972227f, 0.11373890f, 0.12937181f, -0.15550169f, -0.10051400f, 0.03383090f, -0.04347657f, 
    0.08630960f, -0.00938286f, -0.16798723f, -0.08409213f, 0.14722529f, 0.04404874f, 0.05219652f, 0.00431701f, 
    0.02583190f, -0.00519483f, -0.06615829f, 0.07528143f, -0.14620999f, -0.23292553f, -0.19549870f, 0.03458018f, 
    0.08386238f, 0.21428062f, 0.02373620f, -0.01155418f, -0.07673811f, 0.17952342f, 0.08437826f, 0.11856879f, 
    -0.00803365f, -0.06259301f, 0.08617453f, -0.03955133f, 0.02264443f, 0.17381386f, 0.14828977f, 0.09659337f, 
    0.14910546f, -0.13197215f, -0.06455082f, 0.04918147f, 0.09379034f, 0.00327623f, -0.07504576f, 0.08362610f, 
    -0.02213391f, 0.05771853f, 0.02149205f, 0.01357145f, -0.10864741f, -0.01943695f, -0.03586893f, 0.09705345f, 
    -0.04310540f, 0.32259402f, 0.20016147f, 0.09125613f, -0.03156142f, -0.14052328f, -0.08806093f, -0.06710925f, 
    0.06174619f, -0.09691288f, 0.00096777f, 0.11118209f, 0.09903342f, 0.03247055f, 0.11219376f, 0.03046753f, 
    0.07756919f, 0.11476935f, -0.00770164f, 0.06416386f, -0.08808453f, 0.04860196f, 0.09250600f, -0.04709287f, 
    -0.35920522f, -0.18837713f, -0.48332474f, -0.58855355f, 0.17616598f, -0.01812942f, 0.08228217f, 0.10313895f, 
    0.01492604f, -0.03610139f, -0.10684149f, -0.00272055f, -0.09847262f, 0.07064303f, -0.22887312f, 0.12271810f, 
    -0.20857176f, 0.23881654f, -0.23351735f, -0.05424948f, -0.00103752f, -0.17115648f, -0.19053449f, -0.01404848f, 
    0.25665015f, 0.07369995f, 0.20065045f, 0.11797106f, -0.08654333f, 0.06321734f, 0.03391812f, 0.01695076f, 
    0.19953561f, 0.06739820f, 0.08434457f, 0.12133332f, -0.12982595f, 0.24394408f, 0.19087000f, 0.09738281f, 
    0.03967309f, -0.00723056f, 0.01774364f, -0.00671637f, -0.01142855f, -0.02136896f, -0.19938077f, -0.18024306f, 
    0.25973439f, 0.35317200f, 0.12588800f, 0.05237018f, 0.00900074f, 0.00206785f, 0.05261367f, -0.07354907f, 
    0.18105613f, -0.02836573f, -0.04077417f, 0.25166011f, -0.00803259f, 0.08655460f, 0.13510656f, -0.01444162f, 
    -0.02640749f, -0.03649642f, 0.04537116f, -0.15972653f, 0.17766248f, -0.13472725f, 0.15594219f, 0.18233098f, 
    0.02790504f, -0.38902339f, -0.13862962f, -0.41902882f, -0.04939566f, 0.14793161f, -0.24227363f, 0.17505312f, 
    -0.06398349f, -0.07843798f, 0.03033001f, 0.13815719f, 0.16089138f, 0.03270259f, 0.02684280f, 0.07754565f, 
    -0.04054160f, -0.05693890f, -0.00539312f, -0.11376814f, -0.01807702f, -0.17780948f, -0.10036004f, 0.02313147f, 
    -0.08363587f, 0.04300620f, -0.08024678f, 0.09991503f, 0.05941942f, 0.21896403f, 0.23324409f, -0.19491851f, 
    -0.05209587f, 0.00798485f, 0.01139121f, 0.06737688f, -0.19270396f, -0.12458427f, -0.60055190f, -0.27707264f, 
    0.06726103f, 0.03132389f, 0.30370429f, 0.26584682f, -0.01982421f, 0.13829967f, 0.06542910f, -0.10644329f, 
    -0.27182174f, -0.49751255f, -0.08789888f, -0.19874096f, 0.05117669f, -0.13251758f, 0.06311496f, -0.04074547f, 
    0.07121622f, -0.01697457f, 0.10302644f, 0.06596288f, -0.11088486f, -0.08435577f, -0.31417117f, -0.54203010f, 
    -0.03832509f, -0.10014321f, 0.12132429f, -0.17303608f, 0.16935548f, 0.13876703f, -0.03480572f, 0.05742687f, 
    0.06817564f, -0.49430349f, -0.51784182f, -0.04621159f, 0.09260794f, 0.00652053f, -0.02769122f, 0.09392227f, 
    0.23464757f, -0.02994121f, -0.06344541f, -0.02274402f, -0.08274908f, -0.08471662f, -0.11487710f, -0.16148967f, 
    0.11790561f, 0.22206357f, 0.19213437f, 0.15299959f, -0.03391951f, 0.03558591f, 0.07659224f, 0.11839427f, 
    0.27955943f, 0.00058520f, -0.16560262f, -0.15664254f, -0.13752599f, -0.01543631f, 0.01682501f, -0.01364596f, 
    0.09347419f, -0.06810714f, 0.04582772f, -0.11203238f, -0.02245441f, 0.08070069f, -0.04698933f, 0.03979209f, 
    0.03679576f, 0.02813840f, 0.24921328f, 0.17449829f, -0.05520358f, -0.09240736f, -0.01817611f, -0.08346277f, 
    0.01476923f, 0.06791800f, -0.01590914f, 0.05651945f, -0.02956301f, 0.07103278f, 0.07900193f, 0.04339040f, 
    0.07782190f, -0.00781274f, -0.06796727f, -0.06645368f, 0.08929010f, -0.42399043f, 0.00623305f, 0.40466580f, 
    0.13752389f, 0.01971598f, -0.05998355f, -0.03879871f, 0.03097522f, -0.13458690f, 0.14114352f, 0.03593688f, 
    -0.05862703f, -0.07330068f, -0.12736502f, 0.19559298f, 0.03170786f, 0.02309666f, -0.01916634f, 0.05613403f, 
    0.01428468f, 0.02890807f, -0.03773575f, -0.06274232f, -0.15414910f, 0.01129340f, -0.13458574f, 0.10269611f, 
    -0.02034628f, -0.05673204f, -0.08660194f, -0.02628996f, -0.00407108f, -0.03402055f, 0.09516074f, -0.01132201f, 
    0.33546433f, -0.16720693f, 0.14642744f, -0.16971752f, -0.05069710f, -0.01728789f, 0.00878002f, -0.00018592f, 
    -0.03438257f, 0.23031750f, -0.03681443f, -0.03838375f, -0.25499547f, 0.11351860f, -0.05973468f, 0.18841304f, 
    0.11635429f, 0.03830779f, -0.09517323f, 0.15733723f, 0.03652480f, -0.01858323f, -0.08007851f, -0.20679374f, 
    0.18059209f, -0.41225401f, 0.02616204f, -0.03845626f, -0.01137852f, -0.05234203f, 0.00787944f, 0.06988875f, 
    0.07919227f, -0.08326515f, -0.10221961f, 0.12949684f, -0.04216021f, 0.00010819f, 0.15942748f, 0.04837061f, 
    0.02687117f, 0.06420827f, 0.01516633f, -0.03178726f, 0.03114878f, -0.08547429f, -0.04751423f, 0.12208361f, 
    0.01119009f, -0.09171520f, -0.03428870f, 0.03676339f, 0.01791840f, -0.21727140f, 0.12559742f, 0.10161840f, 
    -0.14125322f, -0.02695104f, -0.05702939f, -0.06445307f, -0.03268937f, -0.00179506f, 0.16204758f, -0.14516848f, 
    -0.07093731f, 0.05093899f, 0.06599396f, 0.02094314f, 0.02007351f, -0.04713933f, 0.02129241f, 0.11501942f, 
    -0.20174065f, 0.14570819f, 0.17426892f, 0.09319542f, -0.08767433f, -0.03118916f, -0.03792197f, -0.10461310f, 
    0.16724348f, 0.08261524f, 0.24164703f, 0.10926640f, -0.01400825f, 0.18922058f, 0.31969145f, -0.24612835f, 
    0.07868730f, -0.00424763f, -0.20849955f, 0.01860717f, -0.10126131f, -0.04206161f, 0.19748290f, 0.16839682f, 
    0.13665998f, -0.15850218f, 0.32144722f, 0.09686086f, -0.14986004f, -0.08781420f, 0.08108318f, 0.12110764f, 
    -0.14443719f, 0.05287980f, 0.31308043f, -0.11014510f, -0.19249138f, 0.04622950f, -0.07364011f, 0.10740276f, 
    -0.13102090f, -0.09211046f, 0.10938697f, -0.04466102f, -0.05907021f, -0.08873928f, -0.00144153f, 0.01977255f, 
    -0.23196356f, 0.05496103f, 0.25311911f, 0.15780562f, 0.14540225f, -0.08332627f, -0.15236044f, -0.09517960f, 
    0.07690404f, 0.15593970f, 0.02928438f, 0.09626692f, -0.04471949f, 0.00800742f, 0.12122188f, 0.10045107f, 
    0.08792597f, 0.07235432f, -0.04318960f, -0.00495842f, -0.04180337f, -0.15681459f, -0.07359727f, -0.02013596f, 
    0.09608937f, 0.39835051f, 0.08134436f, -0.15857598f, -0.13430864f, 0.11796177f, 0.05478188f, 0.01250857f, 
    -0.00492443f, -0.02265713f, 0.08135666f, 0.04403353f, -0.04698157f, -0.00050024f, 0.06752378f, 0.06737465f, 
    -0.28118530f, -0.06627952f, 0.03309212f, 0.01907186f, 0.19939491f, -0.04836698f, -0.03062720f, -0.00324795f, 
    -0.19371888f, -0.21727476f, -0.09886210f, 0.15204151f, -0.00402543f, 0.03630365f, 0.11153301f, 0.01025310f, 
    -0.09268110f, 0.07287116f, 0.03353519f, 0.11533545f, -0.10172565f, 0.14562985f, 0.26718763f, -0.05670217f, 
    0.09349637f, 0.04880878f, 0.03013333f, 0.02071382f, 0.10143509f, 0.01496176f, 0.11627338f, -0.03571723f, 
    -0.05127715f, -0.24445818f, 0.10849299f, 0.06161420f, 0.02965092f, 0.06037224f, -0.04621970f, 0.02722157f, 
    -0.12563857f, 0.04869880f, 0.07222955f, 0.01983353f, -0.16530922f, -0.00475599f, 0.10064130f, 0.06205365f, 
    0.16835138f, -0.07503676f, -0.04054608f, -0.04241413f, 0.19602472f, 0.06862014f, -0.01022105f, 0.07940742f, 
    0.23237815f, 0.07001162f, -0.16894642f, -0.04529190f, -0.02745062f, 0.04816538f, 0.06905202f, 0.00569827f, 
    0.00631064f, -0.05053111f, 0.13168862f, -0.08651351f, -0.03681157f, -0.28056645f, -0.08300692f, 0.11667411f, 
    0.01502688f, 0.08106705f, 0.01054643f, -0.02872339f, 0.07630026f, 0.05406493f, 0.02283253f, 0.01258739f, 
    0.14576468f, 0.02365303f, 0.20633356f, -0.16055340f, 0.03588637f, 0.01488028f, -0.01659058f, -0.21413113f, 
    -0.02248462f, -0.09210139f, -0.03394684f, -0.01575419f, 0.11076118f, -0.21119292f, -0.01657217f, -0.20069335f, 
    -0.14295934f, -0.04172299f, 0.12050904f, 0.09133425f, -0.02883691f, 0.12095255f, 0.01193777f, 0.01111649f, 
    0.42939374f, -0.01379255f, 0.06588114f, -0.02270339f, 0.22065932f, -0.07603924f, 0.27472767f, -0.12357514f, 
    0.14347260f, 0.00593236f, 0.06288873f, 0.20968597f, -0.16185932f, -0.07281622f, -0.08724090f, -0.17185833f, 
    0.12215023f, 0.16577816f, -0.03179155f, 0.03891059f, 0.05251643f, 0.11998743f, -0.11107088f, -0.08427399f, 
    0.25282109f, 0.07893220f, -0.01074366f, 0.00738591f, 0.04415292f, -0.02880981f, -0.02857147f, 0.10383102f, 
    -0.04514429f, -0.21052508f, 0.05612826f, 0.05033579f, 0.29090658f, 0.28411165f, -0.01399367f, -0.11087672f, 
    -0.06077065f, -0.07760011f, 0.10190242f, 0.02544610f, 0.05117058f, 0.00521547f, 0.05772425f, -0.08333965f, 
    0.03594457f, -0.08121161f, -0.10302594f, -0.02843069f, -0.10609965f, -0.00066613f, 0.03344731f, -0.07097551f, 
    -0.01275093f, -0.01093343f, 0.02152221f, 0.00241780f, -0.09894048f, 0.01782250f, 0.02188153f, -0.05734856f, 
    0.01019150f, -0.08117159f, -0.06111521f, -0.10010511f, 0.03032706f, -0.10758468f, -0.00024892f, -0.04657887f, 
    0.06188302f, -0.02412000f, 0.04450087f, -0.00274328f, -0.07402753f, -0.07012794f, 0.06771858f, -0.04984032f, 
    0.03053932f, -0.05062062f, 0.03354446f, 0.05753139f, -0.07582963f, -0.03241328f, -0.02680687f, -0.04813613f, 
    -0.01460875f, -0.02976484f, -0.06715451f, 0.00148645f, -0.03248919f, 0.01387227f, 0.07002365f, -0.05280279f, 
    -0.09019181f, -0.03521066f, -0.00831147f, -0.02311340f, 0.02595760f, -0.05813939f, 0.01536872f, 0.02419236f, 
    -0.04757239f, -0.05104624f, 0.01582491f, -0.07910012f, -0.01913810f, -0.00664894f, -0.01257715f, -0.05071317f, 
    -0.04916790f, 0.00711207f, -0.04660053f, -0.09629591f, -0.02911894f, 0.06663982f, -0.03326788f, 0.06001647f, 
    -0.06614263f, -0.02512820f, -0.03864801f, -0.09477017f, -0.10339294f, 0.00334491f, -0.05949118f, -0.07470736f, 
    -0.01803569f, -0.01760135f, -0.01856042f, -0.07899353f, -0.06561568f, 0.03189964f, -0.02897294f, -0.08573145f, 
    -0.03007353f, -0.02956816f, 0.01477566f, -0.03200197f, -0.04444116f, -0.04164482f, 0.01622481f, -0.01280845f, 
    0.06584530f, -0.00181366f, -0.02795310f, -0.02616148f, -0.04737895f, 0.05111406f, 0.00570404f, -0.04768224f, 
    -0.07273737f, -0.00558024f, -0.02285101f, -0.09226453f, -0.01349045f, -0.06066711f, -0.09116896f, -0.06910915f, 
    -0.08477250f, 0.00105334f, 0.01161189f, -0.04288291f, -0.05266543f, -0.00684634f, -0.07483678f, -0.11202220f, 
    -0.07490093f, 0.00788915f, -0.03143726f, 0.01489409f, -0.03365706f, -0.01487498f, 0.02678052f, -0.01445790f, 
    0.03406506f, -0.06150030f, -0.02241091f, -0.09641826f, -0.06132938f, 0.04054568f, -0.03901230f, -0.05528599f, 
    -0.06496026f, 0.03545173f, 0.02236835f, -0.05826682f, 0.04397510f, -0.06389248f, 0.02340240f, -0.09554926f, 
    0.02405984f, -0.07061728f, 0.01449697f, 0.02418081f, 0.00461102f, -0.05156099f, -0.01982477f, -0.07648757f, 
    0.02420276f, -0.03893115f, 0.02851621f, -0.03814438f, -0.02072745f, -0.03647728f, -0.01240593f, -0.05509684f, 
    -0.04513216f, -0.10328785f, 0.02277048f, -0.04137088f, 0.02513195f, 0.04629391f, -0.06222009f, -0.08646169f, 
    0.08067928f, -0.04923696f, -0.04769579f, 0.03378020f, -0.07476807f, -0.00905569f, -0.00102715f, 0.00030101f, 
    -0.06252861f, 0.00743388f, -0.00870890f, 0.01932546f, -0.01137808f, -0.07534004f, -0.07987575f, -0.06108537f, 
    0.01659992f, 0.05681601f, -0.04583182f, 0.05641188f, 0.02112136f, 0.01437075f, -0.09541529f, 0.02687497f, 
    0.27417433f, -0.21514609f, 0.53895050f, -0.07972242f, 0.14311890f, 0.02902570f, 0.06462781f, 0.04251406f, 
    -0.08957192f, 0.13257116f, -0.06323751f, 0.19632511f, -0.15579695f, 0.17893331f, 0.09433152f, 0.07208806f, 
    0.07573929f, 0.11916047f, 0.00969380f, -0.02831566f, -0.07587102f, -0.09623440f, 0.14311251f, -0.08440544f, 
    0.24849977f, 0.28563157f, 0.01876465f, 0.01494670f, 0.04349857f, 0.07954603f, 0.11980496f, -0.09227385f, 
    -0.16867913f, 0.02328815f, 0.03783988f, -0.18977413f, -0.51055646f, -0.01416140f, -0.13084498f, 0.07157218f, 
    -0.07423305f, 0.28241539f, 0.13599287f, -0.15229470f, 0.03378642f, -0.08741958f, 0.00345684f, 0.01705484f, 
    0.07384468f, 0.22124320f, 0.03663966f, 0.27039239f, -0.06637340f, -0.05619477f, 0.06767534f, 0.00674426f, 
    -0.02868144f, -0.02078936f, 0.06335516f, -0.03111251f, -0.15298373f, 0.11885107f, -0.07885190f, -0.02573140f, 
    -0.08274426f, -0.00169970f, 0.07815166f, -0.09523786f, -0.03734206f, -0.18012984f, 0.00320636f, 0.03673190f, 
    0.30187657f, 0.03069191f, 0.47852555f, 0.15602255f, 0.02202759f, -0.00886208f, -0.12061696f, 0.07432520f, 
    -0.25544614f, 0.02550863f, -0.05890857f, -0.03334065f, -0.07476737f, 0.12902659f, 0.03461215f, -0.03140800f, 
    0.04656293f, 0.05820400f, -0.06682460f, 0.02816642f, -0.03501823f, 0.08666422f, 0.09095060f, 0.08940299f, 
    0.02493624f, 0.20199288f, -0.33403105f, 0.27831507f, 0.00880235f, -0.03089615f, 0.13195540f, -0.13661149f, 
    -0.07654718f, -0.09660067f, 0.12929094f, -0.04402196f, -0.19952354f, -0.02139011f, -0.09313979f, 0.09512838f, 
    0.05443550f, 0.08093525f, 0.02095976f, 0.00673661f, 0.06666602f, 0.12994429f, -0.08285315f, -0.06886820f, 
    0.00042050f, 0.13281716f, 0.08140542f, 0.13022710f, 0.09923831f, -0.04531384f, -0.08899750f, 0.00127015f, 
    0.07692941f, -0.04707188f, -0.07306889f, 0.06262160f, 0.08512197f, -0.26369119f, 0.13608456f, -0.07801699f, 
    -0.13759686f, -0.01983916f, 0.07207774f, 0.09512578f, -0.01794647f, -0.02408173f, -0.17996734f, 0.02237698f, 
    0.18636760f, 0.01415080f, -0.12202775f, -0.16863851f, -0.00338201f, -0.08090550f, 0.11166727f, -0.26359141f, 
    0.05296603f, 0.02450956f, -0.09793497f, 0.03127280f, -0.14923616f, -0.11842535f, -0.22821851f, -0.03795698f, 
    -0.07043508f, 0.12593217f, -0.03709703f, 0.20455530f, -0.08003058f, 0.08124200f, -0.09328073f, -0.16458486f, 
    0.04259599f, 0.31795803f, -0.01046245f, 0.18468635f, -0.03026140f, -0.06590836f, 0.01156762f, -0.00290668f, 
    0.08345632f, -0.22172564f, -0.00060797f, 0.04604607f, 0.09143333f, 0.25116414f, 0.01609147f, 0.01043477f, 
    -0.02715163f, 0.06070725f, -0.00962028f, 0.04136591f, -0.09535027f, -0.05563178f, -0.06780147f, -0.05089304f, 
    -0.28001487f, 0.48095015f, -0.29623494f, 0.38348567f, -0.13294646f, -0.00205127f, -0.01018269f, -0.01311452f, 
    0.08769473f, -0.03527056f, 0.05099175f, 0.12887220f, 0.02857099f, 0.26155734f, 0.01012977f, -0.00017015f, 
    0.11283990f, -0.05057992f, -0.00405433f, -0.06732198f, 0.00403504f, 0.16933525f, -0.10865300f, 0.25248218f, 
    0.30575168f, -0.44219577f, -0.38799688f, -0.10266296f, 0.00087981f, 0.06568077f, -0.08280221f, 0.14316985f, 
    -0.06708833f, -0.07686784f, -0.00560239f, 0.08830147f, 0.44991595f, -0.03267076f, -0.15174252f, -0.15470450f, 
    0.17706379f, 0.11629453f, -0.08404668f, 0.07602210f, -0.06639657f, -0.01581591f, 0.07603735f, -0.05972571f, 
    0.01967729f, -0.13076337f, 0.25058037f, -0.23495375f, -0.01865740f, 0.10484149f, -0.06043009f, -0.11646737f, 
    0.06928335f, 0.07382136f, 0.12325913f, 0.10624862f, 0.24108347f, 0.24587683f, -0.03931352f, 0.01304504f, 
    0.00522645f, 0.03606204f, 0.01051325f, -0.01951633f, -0.06061553f, -0.00403824f, 0.06018779f, -0.10499589f, 
    -0.78127766f, 0.26397014f, -0.11867781f, 0.01178304f, 0.02580833f, -0.22269651f, 0.03084827f, -0.05269333f, 
    -0.00911848f, 0.04684696f, 0.10665310f, -0.06325973f, 0.20671390f, 0.27138597f, 0.09453066f, -0.14290200f, 
    0.09769125f, -0.12945388f, 0.02423563f, -0.14518906f, 0.06806324f, 0.10634872f, -0.08236520f, 0.16475537f, 
    -0.06131596f, -0.19405362f, 0.00675319f, 0.11563830f, 0.06825696f, 0.27616629f, -0.07679691f, 0.20174707f, 
    0.08392082f, 0.00452033f, -0.15861635f, 0.07647982f, 0.25238791f, 0.18563211f, 0.06493416f, -0.18952066f, 
    0.00703321f, -0.07051075f, -0.05696687f, -0.13012221f, 0.16600361f, -0.01826001f, 0.09961092f, 0.07518526f, 
    0.18054296f, 0.00445881f, -0.14512816f, -0.04551155f, 0.02776195f, 0.00388485f, 0.14204906f, -0.02749292f, 
    -0.02775153f, 0.12608489f, 0.06380875f, 0.01278375f, 0.06923266f, 0.08934381f, -0.25805292f, 0.09295162f, 
    0.08657615f, 0.11259809f, 0.10507854f, 0.33555812f, 0.02776063f, -0.03011028f, 0.09448213f, -0.03931860f, 
    -0.10662849f, 0.09733859f, 0.08801223f, 0.08213570f, 0.14456464f, -0.03677012f, 0.15020637f, 0.18280208f, 
    -0.10152938f, -0.06350075f, 0.15992725f, -0.11462927f, 0.67422915f, -0.00324396f, 0.19276170f, 0.24850135f, 
    0.08544892f, -0.21243432f, 0.17045094f, -0.26347923f, -0.07563812f, 0.08053074f, 0.17173906f, 0.17196369f, 
    0.04058089f, -0.16686787f, -0.23492359f, 0.14399782f, 0.00127016f, 0.08676714f, -0.04402107f, 0.15680251f, 
    -0.02680147f, 0.07952739f, 0.04132378f, -0.06939913f, -0.04942911f, -0.02702450f, -0.08940842f, -0.09332283f, 
    -0.12941720f, -0.03266864f, 0.08342495f, 0.05343094f, -0.06284384f, -0.09882459f, 0.12930477f, -0.12507109f, 
    -0.22544611f, 0.17392413f, -0.02813065f, 0.19361979f, -0.16225411f, 0.14376765f, -0.13374905f, -0.06884354f, 
    -0.07539919f, -0.05589148f, 0.01773432f, -0.13171412f, -0.11159889f, -0.30223224f, -0.08120505f, -0.03013236f, 
    0.13798788f, 0.14687312f, -0.04669735f, -0.12065636f, -0.30192268f, -0.18108444f, -0.26748845f, 0.08430882f, 
    0.25761211f, -0.18863019f, -0.10082879f, 0.14958423f, 0.06818835f, 0.06137577f, 0.03365271f, 0.05537265f, 
    0.09814726f, 0.02005130f, 0.13108015f, 0.13853930f, 0.17333600f, 0.34847447f, -0.20742728f, -0.29213598f, 
    0.02785974f, 0.08415750f, 0.08916089f, 0.19670415f, 0.16867414f, 0.22753020f, 0.17057668f, 0.12602876f, 
    0.20593026f, 0.08918017f, 0.27547282f, -0.15900871f, 0.01782048f, -0.05346533f, -0.04050699f, -0.07192359f, 
    -0.22694907f, 0.09068008f, -0.09178296f, 0.08040047f, 0.18173461f, 0.08339979f, 0.05590323f, -0.02287951f, 
    -0.06423540f, 0.14310874f, -0.09588210f, -0.13837777f, 0.08143429f, 0.11093466f, -0.00176600f, 0.10183033f, 
    -0.31115285f, 0.42578506f, -0.22078757f, 0.00453705f, 0.11944886f, -0.13669212f, -0.02279504f, -0.12258796f, 
    -0.14139450f, 0.02577760f, -0.01932146f, -0.08480123f, 0.11372195f, -0.06351992f, 0.02569951f, -0.26355320f, 
    -0.13316944f, 0.09646014f, -0.11164814f, -0.12853760f, 0.03874827f, -0.04696164f, -0.03403610f, -0.32387310f, 
    -0.15137950f, 0.12874913f, 0.03328191f, -0.13073222f, 0.09415948f, 0.20258081f, 0.04638484f, 0.14867154f, 
    -0.02215070f, 0.12185486f, -0.06062000f, 0.11923958f, 0.27322832f, 0.21439460f, -0.11026961f, -0.27762693f, 
    -0.17195210f, -0.22142719f, -0.10708670f, -0.10075492f, -0.05182525f, 0.17940636f, -0.06761751f, -0.07521640f, 
    -0.15701322f, -0.08451196f, -0.08553436f, -0.00778483f, 0.06144223f, 0.12264811f, 0.08988865f, -0.00403338f, 
    -0.14068866f, -0.15665023f, -0.08289699f, -0.34782287f, 0.06063827f, -0.01247456f, 0.06477217f, 0.19691363f, 
    0.05694598f, -0.07432735f, -0.04715130f, 0.03129680f, 0.11108185f, -0.15151416f, 0.08922659f, 0.06159837f, 
    0.11065710f, 0.02634420f, 0.09559780f, 0.03880777f, 0.08010691f, 0.00492279f, 0.01902430f, 0.02174162f, 
    0.13506092f, 0.12160384f, 0.14227393f, 0.08027080f, 0.64784104f, -0.07256567f, 0.01458450f, 0.31722367f, 
    0.09265324f, -0.13740639f, -0.11401801f, -0.22984406f, 0.03234988f, -0.11642519f, 0.13232519f, -0.08357175f, 
    0.09856867f, -0.05760805f, 0.07004884f, 0.08252262f, 0.11597989f, 0.05800621f, 0.07102212f, -0.01737603f, 
    0.08546834f, 0.11904860f, 0.07219499f, 0.01575409f, -0.09660470f, -0.10728593f, -0.20264433f, -0.14981450f, 
    0.10962959f, -0.03454755f, 0.04703468f, -0.00121087f, -0.12790173f, -0.13531044f, -0.09819474f, -0.15832511f, 
    0.00241510f, -0.07170546f, -0.01025391f, 0.00634810f, 0.00796990f, 0.00244680f, -0.01740685f, -0.05335176f, 
    -0.04577864f, -0.05575602f, -0.00148981f, 0.05226121f, -0.00056836f, 0.02177009f, -0.02329148f, -0.01231308f, 
    -0.01549802f, -0.00499829f, -0.07773217f, -0.05966979f, 0.02221967f, -0.07428947f, -0.07275686f, 0.03091536f, 
    -0.04830638f, -0.03238299f, -0.07125461f, 0.01260823f, -0.02285216f, 0.00801008f, 0.05375360f, -0.04449730f, 
    0.00058147f, 0.04061026f, -0.05575695f, 0.03900471f, 0.05234592f, -0.00684023f, -0.05901955f, 0.04941317f, 
    -0.02246229f, 0.05528678f, -0.03463779f, -0.07903325f, -0.01202335f, 0.00283595f, 0.03508863f, -0.01605233f, 
    0.03664545f, -0.02559244f, -0.00302801f, -0.03140574f, 0.00382280f, -0.07067002f, -0.00956623f, -0.03290869f, 
    0.04530382f, -0.06232910f, 0.03274291f, 0.01193221f, 0.04288996f, 0.04270797f, 0.02975742f, 0.05702989f, 
    -0.07666939f, -0.03235005f, 0.01117595f, -0.00886813f, -0.01091632f, -0.06636148f, -0.03645175f, -0.07242451f, 
    -0.06073851f, -0.02988496f, 0.04244940f, -0.02405817f, 0.04336261f, 0.00483687f, -0.06151407f, -0.01745252f, 
    0.04225280f, 0.03702348f, -0.07141281f, -0.03156459f, -0.07999600f, -0.00335570f, -0.01297845f, 0.00714029f, 
    -0.05951514f, -0.00850092f, -0.04495511f, 0.01848894f, -0.07562802f, 0.01354729f, -0.06163894f, 0.03108826f, 
    0.03286611f, 0.01759529f, 0.02315601f, 0.04613303f, -0.03591225f, 0.04598226f, -0.03912538f, -0.02560872f, 
    -0.00525098f, -0.03681832f, -0.03034629f, -0.04610744f, -0.01875286f, -0.04482017f, -0.03891088f, -0.04367451f, 
    0.02340268f, 0.05341045f, 0.02564451f, 0.01626978f, 0.03076891f, -0.07351907f, -0.02439140f, 0.00571823f, 
    0.04302415f, -0.00744989f, 0.05799534f, 0.05496585f, 0.04075836f, -0.04252335f, -0.01686448f, 0.05420357f, 
    -0.01205069f, -0.03322230f, 0.04546534f, -0.05291313f, -0.00885061f, 0.00974748f, -0.03646246f, -0.01683545f, 
    0.04173842f, -0.06778231f, 0.03285056f, -0.02884989f, 0.00556519f, -0.07762734f, -0.01879779f, 0.02231038f, 
    -0.05781387f, -0.04186567f, 0.04304074f, -0.05544459f, 0.02042179f, -0.02643998f, 0.02641640f, 0.05036410f, 
    -0.03931133f, 0.03220467f, 0.00208494f, 0.02500327f, 0.01950473f, -0.05003428f, 0.05254583f, 0.00460133f, 
    0.00093421f, 0.05598579f, 0.02898827f, -0.03621734f, -0.01715005f, -0.01399834f, -0.04955696f, 0.02257993f, 
    -0.00910253f, 0.01227532f, -0.02086916f, -0.05878102f, -0.06019140f, -0.03452267f, 0.05165001f, -0.03447930f, 
    0.05469614f, -0.01398428f, -0.06456427f, 0.04368618f, 0.04747443f, -0.02793103f, -0.06950213f, 0.00681672f, 
    0.05682601f, -0.02662769f, -0.06041041f, -0.00033103f, -0.01674024f, 0.00259942f, 0.00466135f, -0.01754934f, 
    0.22504744f, 0.00266776f, -0.07965812f, 0.01184596f, 0.05054161f, 0.14656784f, -0.06245890f, -0.15171887f, 
    0.02374676f, -0.22352701f, 0.07834428f, -0.03842301f, 0.10862093f, -0.01110730f, -0.18394008f, -0.03547952f, 
    -0.15901707f, 0.03300468f, -0.00110851f, -0.05655882f, 0.09561857f, -0.09849296f, -0.07234842f, 0.04369602f, 
    0.01265624f, -0.34671074f, 0.07138604f, 0.22870773f, 0.05288455f, -0.06692204f, -0.01692018f, 0.09741796f, 
    0.04964583f, -0.06029943f, 0.16011511f, 0.10287992f, -0.31836224f, 0.09964956f, 0.19963157f, -0.01675630f, 
    -0.01789373f, -0.02262710f, -0.12283288f, 0.06033580f, -0.00449679f, 0.16349345f, 0.05508418f, 0.11826079f, 
    -0.00515553f, 0.08750579f, 0.04619458f, -0.18129051f, -0.02307944f, -0.05301369f, 0.04495898f, -0.03718727f, 
    0.10711350f, 0.06850067f, -0.01294259f, -0.02749547f, -0.00557890f, -0.09240676f, -0.13393192f, 0.09848049f, 
    0.00638015f, 0.01426476f, 0.13842106f, 0.01703685f, 0.10941614f, 0.11980654f, 0.16605930f, 0.26625979f, 
    -0.02128959f, 0.12044723f, 0.00689386f, -0.05944140f, 0.01268096f, -0.07310268f, -0.00108356f, -0.06262805f, 
    0.00721891f, 0.26103997f, 0.05336451f, -0.15508801f, 0.01360361f, -0.01322159f, -0.16776906f, 0.00530641f, 
    -0.27351278f, 0.10028245f, -0.03186088f, 0.18344529f, -0.07682833f, 0.06216040f, 0.06382509f, -0.07248470f, 
    -0.12571838f, -0.15059374f, 0.32049066f, 0.23016918f, -0.07839002f, 0.03436278f, -0.01455764f, 0.09645108f, 
    -0.00576846f, 0.02843630f, -0.11490821f, -0.02676863f, -0.05144368f, 0.19622672f, 0.02569526f, -0.19544922f, 
    0.02746703f, -0.10233095f, 0.00630226f, 0.07157810f, -0.03479172f, 0.00290094f, -0.13344775f, -0.08733894f, 
    0.00671254f, 0.04134673f, 0.02639638f, 0.13310501f, 0.02506683f, 0.08725613f, -0.03665935f, 0.10072023f, 
    -0.03389514f, -0.09273054f, -0.03971732f, -0.15943328f, -0.05635507f, 0.12124269f, 0.16267364f, 0.18109865f, 
    0.14331518f, 0.08402164f, 0.07321652f, -0.03389688f, 0.08420730f, -0.05281708f, -0.02680580f, -0.09727883f, 
    -0.30673218f, 0.02277538f, 0.05307831f, 0.20743585f, -0.04262505f, -0.00641536f, -0.03404564f, 0.18731174f, 
    -0.08233404f, 0.03546992f, 0.00978402f, -0.01190756f, 0.40585774f, 0.35491633f, 0.21420103f, 0.15889823f, 
    -0.13570565f, -0.20216943f, 0.06042298f, 0.09541612f, -0.00610603f, -0.13513109f, 0.08381991f, -0.00728201f, 
    -0.08758386f, 0.12791523f, 0.17262246f, 0.12341011f, -0.03152028f, -0.08898863f, -0.03525438f, 0.10194949f, 
    -0.01999640f, 0.15665634f, 0.03706531f, 0.11072943f, -0.33621076f, -0.06537651f, -0.02442744f, 0.18685453f, 
    -0.04736403f, 0.06276257f, 0.02763691f, 0.12002745f, -0.08225037f, -0.10548014f, -0.09940621f, -0.13410586f, 
    0.04044067f, -0.16606677f, 0.00885592f, 0.07457090f, -0.02045100f, -0.00706169f, 0.08810554f, 0.14606448f, 
    -0.04073236f, -0.05044639f, -0.04781374f, 0.10858522f, -0.10205863f, 0.22535379f, 0.08458062f, 0.05680827f, 
    -0.09957997f, 0.04707936f, -0.05595040f, -0.15177815f, 0.03653337f, 0.19656718f, 0.16875322f, 0.03949600f, 
    0.11678567f, 0.28202555f, 0.02528589f, -0.11693093f, 0.10920143f, 0.03579853f, 0.04691086f, 0.11780193f, 
    -0.05049038f, 0.02111323f, -0.18296255f, -0.10139671f, 0.21779995f, 0.08119246f, 0.19193304f, -0.14675300f, 
    0.05638145f, -0.04023147f, 0.11605514f, 0.20378540f, -0.03784404f, -0.08522273f, -0.13443933f, -0.03878039f, 
    0.07918239f, 0.05247610f, 0.13346255f, 0.06707640f, 0.00588580f, 0.00573952f, -0.07137382f, -0.09061002f, 
    0.07585713f, -0.02038536f, 0.00433794f, -0.05709158f, 0.01870415f, 0.24968868f, 0.10124516f, -0.21892257f, 
    0.03125660f, 0.14992037f, 0.02791618f, 0.28046402f, -0.11154529f, 0.07155130f, -0.22024423f, -0.19453131f, 
    0.39501360f, 0.14592195f, -0.19693245f, 0.13902061f, -0.03628105f, -0.02795803f, 0.00227536f, 0.06837247f, 
    0.08190078f, -0.02078479f, -0.00648692f, 0.14643405f, -0.21733145f, 0.24900587f, -0.05375495f, 0.02374917f, 
    -0.12730697f, 0.00182989f, 0.13528211f, 0.08383270f, -0.10872476f, 0.06148624f, 0.11082424f, 0.18810998f, 
    -0.05630919f, -0.01069187f, 0.05272839f, -0.16507682f, 0.14603192f, 0.07955957f, -0.08299579f, -0.05137931f, 
    -0.13481633f, 0.03017331f, 0.01871686f, 0.03075373f, -0.08226936f, -0.00831045f, 0.08731774f, -0.03855708f, 
    -0.12384378f, -0.10142376f, -0.10321314f, -0.06232813f, 0.07840283f, -0.09478132f, 0.13276051f, -0.07559886f, 
    -0.16606607f, 0.16029365f, -0.16006926f, -0.11845813f, 0.02273198f, 0.07886174f, 0.01870314f, 0.00217353f, 
    -0.02875296f, 0.18259844f, 0.07354968f, 0.20026027f, -0.02292478f, -0.00890197f, -0.11999720f, -0.04549508f, 
    0.00127300f, 0.03270642f, 0.08024248f, -0.12000850f, -0.13778320f, -0.00122864f, -0.08294050f, -0.10753949f, 
    -0.28532410f, 0.22722921f, -0.11871977f, -0.02421968f, -0.15867679f, 0.19497338f, 0.09086892f, -0.01744553f, 
    -0.12600514f, 0.00511660f, -0.13301516f, -0.17026278f, -0.05677762f, -0.05723478f, -0.06004087f, -0.15995601f, 
    -0.17518169f, 0.15814495f, 0.16282986f, -0.01032064f, -0.09691783f, 0.11596243f, -0.06409656f, -0.04719430f, 
    0.02836803f, 0.06010387f, 0.15053786f, -0.18871202f, -0.06911571f, 0.00723288f, 0.08223244f, 0.09201195f, 
    0.16992871f, 0.12564647f, -0.04761959f, -0.02586862f, -0.17507043f, -0.02057500f, 0.00927068f, 0.07374549f, 
    -0.03007128f, 0.20605141f, 0.02515648f, 0.02909126f, -0.02621763f, 0.08422696f, 0.09810349f, 0.06355058f, 
    0.17682534f, -0.05603718f, 0.05236449f, -0.19672693f, 0.12311316f, 0.07858697f, 0.02820288f, 0.11530752f, 
    -0.14038476f, 0.08052035f, 0.05582974f, -0.01242422f, -0.28522834f, -0.03357441f, -0.06212724f, -0.07194135f, 
    0.06434630f, 0.07756643f, 0.07941811f, -0.02445031f, 0.06821980f, 0.13204816f, 0.05227450f, 0.19531456f, 
    0.15013309f, -0.10706826f, -0.03539378f, 0.02835069f, 0.12942196f, 0.04708770f, 0.07736371f, -0.10423988f, 
    -0.08883681f, 0.07139186f, 0.13276996f, 0.01744925f, -0.11815128f, 0.14379859f, -0.13135330f, -0.22311315f, 
    0.18487778f, -0.06795262f, 0.22242060f, 0.00866862f, 0.05040703f, 0.06524926f, 0.20362478f, 0.03514669f, 
    0.02964160f, 0.19050828f, 0.04379042f, -0.04796642f, -0.07461306f, -0.08312400f, -0.03943947f, 0.00145326f, 
    -0.15761547f, -0.05574219f, -0.00612275f, -0.03385185f, 0.21153924f, -0.05367998f, -0.19591729f, -0.21138854f, 
    0.10579843f, 0.07341003f, 0.07909029f, 0.23193802f, 0.11147220f, 0.11902611f, 0.12929606f, 0.05487900f, 
    0.05636611f, -0.06275032f, 0.05729057f, 0.04821004f, -0.06133970f, -0.03059326f, -0.04393557f, 0.03068125f, 
    -0.11485553f, 0.09688265f, 0.04006350f, 0.02845998f, 0.30684933f, -0.00642893f, -0.13912617f, -0.13761884f, 
    -0.09222404f, -0.11918076f, -0.06067840f, 0.12198698f, 0.03433857f, 0.38722742f, -0.01592940f, 0.03370414f, 
    -0.18216042f, 0.24758126f, -0.10229761f, 0.12218101f, 0.02974029f, -0.04857393f, 0.15671946f, -0.06094418f, 
    0.05403999f, 0.06304521f, -0.02098184f, 0.04808409f, -0.13975397f, -0.01530029f, -0.03968013f, -0.18254593f, 
    -0.03021228f, -0.05744341f, 0.03644859f, 0.04788992f, 0.19243404f, 0.11406635f, 0.09487882f, 0.04731407f, 
    0.08473612f, -0.16865592f, -0.04660359f, -0.03044022f, 0.05152318f, -0.19357409f, -0.04702006f, 0.05853874f, 
    0.22047272f, 0.05714749f, 0.14996803f, 0.07087236f, -0.13480164f, -0.14985429f, -0.02761224f, -0.06921774f, 
    0.02446055f, 0.10234727f, -0.01453838f, -0.02238919f, 0.00283008f, -0.05716050f, -0.00921072f, 0.09895565f, 
    -0.05709957f, 0.05670253f, -0.17503835f, -0.12337068f, 0.00199570f, 0.16409364f, 0.02776047f, 0.07898784f, 
    0.14666465f, -0.00471799f, 0.03272412f, 0.08890792f, -0.08040382f, -0.16451645f, -0.08627599f, 0.10039151f, 
    -0.07649553f, -0.02577650f, 0.01773044f, 0.13150164f, 0.04688810f, 0.10359685f, 0.05059581f, -0.02075779f, 
    -0.36033303f, -0.12188479f, 0.02210765f, -0.02066135f, -0.00044733f, 0.07042824f, 0.12493525f, -0.00836927f, 
    0.08190873f, 0.01945235f, 0.09557293f, 0.18129806f, -0.15174292f, -0.10400189f, -0.08107705f, 0.05149448f, 
    0.02943638f, 0.03161446f, -0.03190938f, -0.05441729f, 0.03064447f, 0.08937789f, -0.08019894f, -0.05081705f, 
    0.03028747f, -0.03346811f, -0.00655015f, -0.01270873f, -0.05042069f, 0.02687146f, 0.02200085f, -0.02565684f, 
    0.00594399f, -0.05508567f, 0.05314075f, -0.00868708f, -0.00997494f, -0.03396367f, 0.05879403f, 0.05767645f, 
    -0.02996971f, -0.04956429f, 0.05245782f, -0.07217594f, 0.04776064f, -0.06819314f, -0.06086165f, 0.04850888f, 
    -0.00355311f, -0.02669044f, 0.01199842f, -0.04371822f, 0.03400932f, 0.00547165f, 0.01093137f, 0.01547131f, 
    0.00875670f, 0.00610383f, 0.04808673f, -0.00629118f, -0.06847803f, 0.02671152f, 0.04638968f, -0.06556797f, 
    -0.07890030f, 0.01945226f, -0.04579815f, -0.02104318f, -0.03215935f, -0.00148639f, 0.04525966f, -0.05933993f, 
    -0.01526938f, -0.06889094f, -0.00578565f, -0.01915512f, -0.00325171f, -0.00643550f, 0.03261469f, 0.01552565f, 
    -0.07908767f, 0.01846572f, -0.07351525f, 0.00392983f, 0.06187617f, -0.05040588f, -0.01841198f, -0.06188512f, 
    -0.05503999f, 0.02657784f, 0.05312623f, -0.06739124f, 0.02932362f, 0.04960374f, 0.02262403f, -0.06445513f, 
    -0.06806675f, -0.06834265f, 0.03079233f, 0.05226946f, 0.04365205f, 0.06386368f, -0.06680996f, 0.00131730f, 
    -0.04577748f, -0.07521420f, 0.03003978f, -0.02952848f, 0.02166188f, 0.06470201f, -0.06495415f, -0.02395950f, 
    -0.05409281f, -0.02736705f, 0.06207798f, -0.03715751f, -0.02837509f, 0.01332478f, -0.06639068f, 0.01227110f, 
    -0.00744725f, 0.03032419f, 0.02021928f, 0.05800126f, -0.05129007f, -0.00646015f, -0.05224646f, -0.05934339f, 
    -0.02436417f, 0.04523632f, 0.01301893f, 0.03642231f, -0.03244645f, -0.05838998f, -0.02194723f, -0.06798058f, 
    0.04812626f, -0.05342561f, -0.06954547f, 0.04657485f, -0.06499571f, 0.03324156f, -0.05001570f, 0.04800963f, 
    -0.05493702f, -0.03572024f, 0.06362323f, 0.00499957f, -0.02370115f, -0.05906231f, -0.03720395f, -0.04763693f, 
    -0.04263084f, -0.01294498f, 0.05631426f, 0.03822349f, 0.02142707f, -0.01240468f, -0.01409977f, 0.01139135f, 
    -0.07329416f, -0.06966469f, -0.00318457f, 0.05652156f, 0.06245773f, -0.05998036f, -0.03753114f, -0.04044419f, 
    0.01129871f, 0.03256516f, 0.01466670f, 0.01704544f, -0.02120730f, -0.03352076f, -0.05777819f, -0.06595983f, 
    -0.07735771f, 0.04988181f, -0.06387261f, 0.05291006f, 0.06089999f, -0.05000579f, 0.06104421f, -0.06735115f, 
    -0.05161581f, 0.05106918f, -0.00897855f, -0.05122379f, 0.06007840f, -0.00928681f, -0.07596766f, 0.01200055f, 
    -0.00556669f, -0.07104599f, -0.06643227f, 0.06164681f, -0.06349244f, 0.02247372f, -0.00209556f, -0.07672775f, 
    -0.00369090f, -0.03672487f, 0.00371744f, -0.03509722f, 0.06485052f, 0.02382947f, 0.00914483f, -0.02149369f, 
    -0.01328486f, -0.00659168f, -0.06691653f, 0.01918927f, -0.07065040f, -0.00093945f, -0.06571841f, -0.05064673f, 
    0.25716409f, 0.10411838f, 0.14918767f, -0.03998687f, 0.08835324f, 0.02303799f, 0.14381808f, -0.07173105f, 
    -0.03852895f, -0.10246462f, 0.07659850f, 0.07347427f, 0.00865184f, 0.12835412f, -0.14979398f, 0.04752830f, 
    0.09585778f, 0.03691995f, 0.00370313f, 0.04408828f, -0.01494913f, 0.00980310f, 0.04676492f, -0.08553017f, 
    0.04427093f, -0.37728798f, -0.08305226f, 0.15743648f, -0.00111792f, -0.11993404f, -0.02327739f, -0.10587773f, 
    0.07622337f, 0.09652968f, 0.04273963f, 0.08562669f, -0.52672946f, -0.07590476f, -0.00148702f, 0.38317114f, 
    0.10882975f, 0.32301852f, -0.21109125f, -0.15523233f, -0.03528328f, 0.12802851f, 0.06005512f, 0.09569217f, 
    -0.14522436f, 0.12482343f, -0.23920704f, 0.04949498f, 0.00657020f, 0.05459277f, -0.07448273f, -0.01350095f, 
    0.01428520f, -0.01733941f, -0.08366631f, 0.05282945f, -0.03382165f, 0.21865106f, -0.20220925f, 0.18238522f, 
    0.17623733f, -0.03120268f, 0.18016925f, -0.04252937f, -0.03624754f, 0.06150584f, 0.01080177f, 0.04663721f, 
    0.02066033f, -0.06423017f, 0.52399844f, -0.16422808f, -0.07143562f, -0.02498312f, -0.05630452f, 0.07897590f, 
    -0.06578978f, 0.07488334f, -0.00603064f, -0.07890479f, -0.11492320f, 0.20986287f, -0.17837667f, 0.04755941f, 
    -0.03003005f, -0.10060281f, -0.00572950f, -0.08113529f, -0.04447962f, 0.01087276f, 0.04730570f, 0.23190048f, 
    -0.16582452f, -0.13217646f, 0.01000792f, 0.32200691f, -0.12443677f, -0.01646971f, 0.03326988f, -0.00521136f, 
    0.03239582f, -0.07726737f, 0.05192372f, -0.09300268f, -0.30245036f, -0.00397430f, 0.08968171f, 0.02231988f, 
    0.07172791f, 0.02209682f, -0.17457779f, -0.00899612f, 0.13391645f, 0.04612077f, 0.06656926f, -0.02531414f, 
    0.05677146f, 0.03392018f, -0.18355201f, 0.15287225f, 0.09315674f, -0.01109925f, 0.07093335f, 0.28380758f, 
    0.01785211f, -0.04039944f, -0.10868746f, -0.00844804f, 0.07196731f, 0.12595987f, 0.27889597f, 0.07820675f, 
    0.08176331f, -0.05942274f, 0.04432345f, 0.20077476f, 0.13870257f, 0.10635234f, -0.10034595f, 0.05906099f, 
    -0.15038395f, 0.15528689f, 0.05731457f, 0.21889880f, 0.03780213f, -0.11578379f, -0.06165105f, 0.11963336f, 
    0.03030864f, 0.09310687f, 0.12347676f, 0.05059572f, 0.08291361f, 0.37216723f, 0.27057159f, 0.20525138f, 
    -0.06041126f, -0.17246085f, 0.08316243f, 0.11563455f, -0.05376222f, 0.09109318f, 0.10963973f, -0.03008420f, 
    -0.02135348f, 0.32211491f, 0.04264145f, 0.26492801f, -0.01207543f, -0.02924349f, -0.04742552f, 0.07443700f, 
    0.01101711f, -0.02065338f, 0.16497622f, 0.08228035f, -0.22641003f, 0.02120838f, 0.04114170f, 0.12207346f, 
    -0.06601765f, 0.17404321f, -0.01327335f, 0.09106078f, -0.06250929f, -0.00537982f, -0.02675505f, -0.05978584f, 
    0.39369169f, -0.09460385f, -0.01577299f, -0.09719480f, -0.00378296f, 0.12843902f, 0.08670632f, -0.10439376f, 
    -0.00368065f, -0.01740591f, -0.06566266f, 0.09394056f, 0.01482236f, 0.10697962f, -0.04952350f, 0.12663068f, 
    -0.09845732f, 0.02263294f, 0.11087934f, 0.06969493f, 0.00905782f, -0.11776602f, -0.03701337f, -0.04814660f, 
    -0.32819718f, -0.09757491f, -0.05194513f, 0.19646735f, 0.00298864f, 0.01085129f, -0.05317279f, -0.07335024f, 
    -0.15182574f, -0.05586573f, 0.02034679f, -0.06792900f, 0.14622472f, -0.34333408f, 0.29543027f, 0.24556479f, 
    0.10978197f, -0.03685620f, -0.09307320f, 0.01974142f, -0.08994652f, 0.10092727f, 0.06040314f, 0.05290619f, 
    -0.01472347f, 0.12378274f, -0.03860405f, 0.21306077f, -0.01871818f, -0.02623045f, 0.01362817f, 0.05090526f, 
    0.03913821f, 0.03345038f, 0.03158092f, 0.03554789f, -0.08072585f, 0.19594079f, -0.25239250f, 0.07909545f, 
    -0.11099856f, 0.02999369f, 0.02983018f, 0.02947614f, -0.05388880f, 0.11244109f, 0.30271247f, 0.27517331f, 
    0.28203276f, -0.29348853f, 0.25381747f, -0.11321540f, -0.00062905f, -0.01613309f, -0.09732986f, -0.03355864f, 
    0.02234465f, 0.04659852f, 0.07440798f, -0.05628380f, -0.00985732f, 0.07170640f, -0.17138892f, 0.29031563f, 
    -0.10620513f, 0.08099715f, -0.06813587f, 0.24239099f, -0.11677324f, 0.06768608f, -0.01193145f, -0.00249771f, 
    -0.10208334f, -0.41220096f, -0.08596783f, 0.08652871f, -0.03179819f, 0.02132197f, -0.03723169f, -0.05396044f, 
    0.05735617f, -0.07888560f, -0.03595915f, -0.13312970f, -0.15184702f, 0.10755704f, 0.22709788f, 0.13439313f, 
    -0.08795992f, 0.02901594f, -0.09348276f, 0.05804526f, 0.08073024f, 0.12536587f, 0.04301127f, -0.02212126f, 
    0.01476006f, 0.01027563f, -0.10551601f, -0.01985994f, 0.15496913f, -0.10213606f, 0.06481177f, 0.24179764f, 
    0.03497769f, 0.06081749f, -0.09038784f, -0.06498607f, -0.05039285f, 0.08836345f, 0.04903620f, -0.22067261f, 
    0.00778123f, -0.11429559f, -0.12105518f, -0.08715160f, 0.19477041f, 0.04785724f, -0.03473256f, -0.09923351f, 
    -0.25379363f, 0.40000448f, 0.20305523f, 0.15853417f, -0.03058109f, 0.07889291f, 0.00929391f, 0.13472033f, 
    0.10283158f, 0.02898786f, 0.06774792f, -0.00046591f, -0.12375262f, 0.56096387f, 0.48017046f, 0.09489042f, 
    -0.02122645f, -0.11507133f, -0.12301235f, 0.30012417f, 0.07403850f, -0.04094538f, 0.08788592f, -0.02056223f, 
    -0.07719065f, 0.12258109f, 0.19609907f, -0.04261526f, -0.06046713f, -0.10059067f, 0.02610175f, -0.06455290f, 
    -0.09439735f, -0.06236797f, 0.16466536f, 0.08121640f, -0.19412413f, -0.07432813f, -0.12559663f, 0.00812798f, 
    -0.11306781f, -0.08547214f, -0.11135608f, 0.02767178f, -0.05751534f, -0.05962333f, -0.02370455f, -0.06475607f, 
    -0.06243222f, 0.11527003f, -0.57184130f, -0.05260869f, 0.00939282f, -0.03071934f, 0.15153915f, -0.00273068f, 
    0.07499123f, 0.04072656f, -0.00273473f, -0.02320618f, -0.07477301f, 0.06437770f, -0.00546981f, -0.05398070f, 
    -0.03967915f, -0.05835507f, 0.03682825f, 0.08470733f, 0.14985324f, 0.06785576f, -0.07611027f, 0.07085139f, 
    -0.44241628f, -0.02625874f, 0.10595199f, -0.04894364f, -0.03703686f, -0.01894914f, -0.01541704f, 0.00669985f, 
    -0.04259078f, -0.01715537f, 0.05614700f, -0.03133132f, 0.27768332f, -0.24511589f, 0.25916144f, 0.17997059f, 
    0.06184074f, -0.15370424f, 0.03044352f, 0.07215811f, 0.13623387f, 0.15142716f, -0.09410714f, 0.03763213f, 
    -0.02262692f, -0.24819855f, -0.01628356f, 0.06589825f, 0.01090483f, -0.05859298f, -0.13566263f, -0.04061721f, 
    0.08460973f, -0.05258982f, 0.10138607f, -0.05346115f, 0.13070862f, 0.07314123f, -0.00895950f, 0.16504781f, 
    0.02052160f, 0.05570306f, -0.01737133f, 0.23387611f, 0.10755541f, 0.09986802f, 0.14475171f, 0.07703023f, 
    0.12372693f, -0.24289447f, -0.43978861f, -0.14242649f, 0.05358853f, -0.06143269f, 0.06012246f, -0.03367991f, 
    0.19024660f, -0.01776518f, 0.02967020f, 0.01738816f, 0.08296124f, -0.00766106f, -0.00572189f, 0.19944389f, 
    -0.09369158f, -0.19955510f, -0.06400160f, 0.07024886f, 0.10384750f, 0.08363426f, -0.09939846f, 0.07526069f, 
    -0.03089979f, -0.51832551f, 0.18540707f, -0.36665732f, 0.14564390f, 0.02432110f, -0.06610891f, -0.01328793f, 
    0.18609159f, 0.18498695f, 0.01418098f, 0.08954858f, -0.02376348f, -0.02775834f, 0.22063121f, 0.14314790f, 
    -0.11597428f, -0.13471051f, -0.14317895f, -0.07868587f, 0.11237504f, -0.04059404f, 0.06575974f, 0.02207585f, 
    -0.13358723f, -0.06207711f, -0.06440113f, -0.22914506f, 0.19118460f, 0.04452045f, 0.14036414f, 0.16216807f, 
    0.05764652f, 0.01724863f, 0.11612839f, 0.13353981f, -0.10085160f, 0.25217000f, -0.06909467f, -0.20736898f, 
    0.02016573f, 0.07274535f, -0.13232838f, -0.12819245f, 0.04423394f, -0.04241315f, 0.08995803f, 0.00307715f, 
    -0.19824633f, 0.28406271f, 0.12532876f, 0.15363613f, -0.17357159f, 0.06946750f, 0.06108476f, 0.09554681f, 
    -0.03125058f, 0.04765902f, -0.04614899f, -0.03737880f, -0.27241284f, 0.30213115f, 0.51853359f, -0.11003995f, 
    -0.05141199f, -0.08271633f, 0.01756207f, 0.06566312f, 0.15384765f, 0.02227289f, 0.16661969f, 0.11800455f, 
    -0.01548036f, 0.06719621f, 0.24056129f, -0.10048304f, 0.01434928f, 0.06735963f, 0.03169908f, -0.11781419f, 
    0.05450327f, 0.05863252f, 0.17739074f, -0.12321320f, -0.15658771f, -0.19541423f, -0.15927707f, -0.08559968f, 
    -0.02014812f, 0.07383877f, 0.02217302f, 0.08719499f, -0.03117215f, -0.07861731f, 0.08183105f, 0.02449715f, 
    -0.50026274f, -0.08847678f, 0.18669929f, 0.11436748f, 0.15763669f, 0.06113429f, 0.07192688f, -0.10561950f, 
    0.01760165f, 0.01204543f, -0.00469501f, 0.21050443f, -0.12542036f, 0.04504653f, 0.06504640f, 0.13226092f, 
    -0.07198641f, 0.13973252f, 0.05090009f, -0.11182931f, 0.20017402f, 0.08103229f, 0.06739757f, 0.16537216f, 
    0.27963036f, 0.09189677f, 0.13819301f, 0.30402419f, -0.01060966f, 0.03484669f, -0.04950100f, 0.10292339f, 
    -0.10450008f, 0.05836204f, -0.08716378f, -0.14033753f, -0.02133775f, 0.19581497f, 0.00487951f, -0.17502935f, 
    -0.11706521f, 0.08926975f, -0.00385481f, 0.07932184f, -0.17362136f, -0.20160589f, -0.07706883f, -0.08347991f, 
    -0.12945743f, 0.01698024f, -0.00641155f, -0.07935032f, -0.17907394f, -0.30891776f, -0.11259061f, -0.25540203f, 
    -0.04082615f, -0.09925725f, -0.05188318f, 0.09458078f, 0.13760427f, 0.17833836f, 0.21186078f, 0.00976097f, 
    -0.03090833f, 0.07144015f, -0.04935976f, 0.11187403f, -0.05256852f, -0.05983689f, -0.05151007f, -0.09210143f, 
    -0.39954051f, -0.01428029f, 0.04281319f, 0.03646612f, -0.06665156f, 0.11375796f, -0.11351268f, -0.00026183f, 
    0.08326140f, -0.13430044f, -0.00166144f, 0.08155726f, -0.09114316f, 0.24889769f, -0.10782336f, -0.15329844f, 
    0.04301086f, -0.13435295f, 0.05097528f, -0.11020171f, -0.03393984f, -0.07640967f, 0.07301071f, 0.17479555f, 
    -0.09710303f, 0.03960816f, -0.00552493f, -0.03194408f, 0.09224458f, 0.13514915f, -0.03216316f, -0.00884397f, 
    0.03475425f, -0.08383533f, 0.02488384f, 0.02711941f, -0.05104547f, -0.08670056f, -0.13779847f, -0.19267875f, 
    -0.17297879f, -0.25785965f, -0.14989434f, -0.00945562f, 0.05075170f, -0.05024738f, 0.12691642f, -0.16850626f, 
    0.04770773f, 0.00654639f, -0.07734929f, -0.02429179f, 0.04762351f, 0.26477069f, 0.20444089f, 0.09087825f, 
    0.02560688f, 0.11517389f, 0.22315586f, 0.12934193f, -0.08298741f, -0.29008201f, -0.33230886f, 0.04425572f, 
    0.00316013f, 0.03772526f, 0.07358870f, 0.06451807f, -0.02777768f, 0.03408265f, 0.00517727f, 0.04610376f, 
    -0.02603612f, 0.21185540f, -0.11968400f, 0.14402805f, 0.06193348f, -0.02979336f, 0.01750183f, -0.01588983f, 
    -0.11977591f, 0.06749856f, 0.09710354f, -0.01009095f, 0.44328073f, 0.04537140f, -0.08600064f, 0.25010642f, 
    0.04101403f, 0.13454583f, 0.14899799f, -0.14180593f, -0.04958974f, 0.09748905f, 0.10525376f, 0.06983234f, 
    0.12532735f, 0.17019418f, 0.25065672f, 0.05766620f, 0.07070844f, 0.12805672f, 0.08452045f, 0.04110902f, 
    0.06941717f, -0.14578722f, -0.04232844f, -0.02926769f, 0.19515486f, -0.02480638f, -0.18043675f, -0.03337047f, 
    0.04370567f, 0.13706157f, 0.07677118f, 0.21083367f, 0.01997373f, 0.14967744f, -0.02103686f, 0.17067261f, 
    0.39313805f, -0.04856572f, 0.04443705f, -0.14900410f, -0.02107676f, -0.11984796f, 0.12701537f, -0.04415521f, 
    0.04572581f, -0.06799940f, 0.05501469f, -0.00290975f, 0.23027560f, -0.00342482f, -0.19035840f, -0.02414582f, 
    -0.05925232f, 0.06464857f, 0.05101114f, -0.04774377f, 0.12848182f, 0.06006444f, 0.01296617f, 0.08694951f, 
    -0.13566133f, -0.33301067f, 0.12691937f, 0.18324284f, 0.05322532f, -0.21153392f, 0.00171254f, -0.01556957f, 
    -0.00603760f, -0.08463805f, -0.03700138f, 0.04685014f, -0.29209885f, 0.14100966f, 0.03786995f, 0.08965564f, 
    -0.02350873f, 0.04760680f, -0.17742209f, 0.03474290f, -0.01964837f, 0.03076800f, -0.06965448f, 0.07497027f, 
    -0.03526681f, 0.12456373f, -0.23348850f, -0.01469972f, -0.04169890f, -0.09140656f, 0.01275768f, 0.01624660f, 
    0.11750373f, -0.04768938f, -0.08103915f, -0.04965640f, -0.01952608f, -0.09237985f, -0.14445916f, 0.17492579f, 
    0.09763891f, -0.04316988f, 0.11546785f, 0.06912646f, 0.07947216f, 0.06070984f, 0.01373459f, 0.07595050f, 
    0.25576571f, 0.11869783f, 0.28436652f, -0.06645782f, -0.07065774f, 0.05095860f, -0.15659915f, 0.11218274f, 
    0.21048084f, 0.15989114f, -0.06883863f, -0.03484052f, -0.00754900f, 0.01779659f, -0.14552517f, 0.01018953f, 
    -0.27001727f, 0.08238580f, -0.01823597f, 0.01359182f, -0.06271663f, -0.01313043f, 0.20593596f, -0.00755362f, 
    -0.25598991f, -0.05834369f, 0.16120291f, 0.22870728f, -0.06649563f, -0.03935568f, 0.06675932f, 0.09808274f, 
    -0.10228505f, -0.02376699f, 0.04254397f, -0.01893894f, -0.25745499f, 0.12870438f, 0.06977282f, -0.09557255f, 
    -0.06746469f, -0.07185140f, -0.07396043f, 0.07018182f, 0.09983858f, 0.08268399f, 0.05411755f, -0.04215041f, 
    0.07477738f, 0.02131946f, -0.12860274f, 0.27857184f, 0.03847846f, 0.11349665f, 0.12574258f, 0.31099826f, 
    -0.01820883f, 0.03008834f, -0.09059983f, 0.14211467f, -0.23427665f, 0.15966260f, 0.18933208f, 0.18949476f, 
    0.26473531f, 0.05451226f, 0.02646069f, -0.11954101f, 0.02632728f, 0.04006678f, -0.02093485f, -0.15892030f, 
    -0.21494217f, 0.07994809f, -0.00062816f, 0.12159950f, -0.05164537f, -0.03186021f, -0.09607763f, 0.23271903f, 
    0.03952144f, 0.07115683f, 0.01735924f, -0.06632908f, 0.05065529f, 0.21237178f, 0.23306972f, 0.17487332f, 
    -0.04346897f, -0.20621699f, 0.04355119f, 0.14103152f, 0.09137426f, -0.02911694f, 0.11212100f, -0.04468261f, 
    -0.20545787f, 0.09773418f, 0.08286032f, 0.16163290f, -0.03751170f, -0.03219289f, -0.00682232f, -0.02116973f, 
    0.13236232f, 0.15746441f, 0.03372547f, 0.00792412f, -0.28669918f, -0.13200018f, 0.07433852f, 0.14748091f, 
    0.11210552f, 0.15422937f, -0.07109953f, 0.07567313f, -0.07519316f, -0.05518714f, -0.09965671f, 0.02633590f, 
    -0.22709237f, -0.01925614f, 0.38835514f, 0.02209894f, 0.18924175f, 0.10149769f, -0.23696920f, -0.10100786f, 
    0.02054518f, -0.00972328f, -0.01374832f, -0.06984120f, 0.04719049f, -0.41149169f, 0.09164545f, 0.02799766f, 
    0.04183695f, 0.12276644f, -0.00931887f, 0.00691405f, 0.12275662f, -0.07880431f, 0.04766992f, -0.01936271f, 
    0.00432795f, 0.30326763f, 0.30274290f, 0.03447143f, 0.08500812f, 0.01393763f, 0.06495647f, 0.06403922f, 
    -0.12279995f, -0.04839582f, -0.12388515f, 0.06409875f, -0.13286424f, 0.33036315f, -0.00596474f, -0.12543681f, 
    -0.07436437f, -0.14181943f, 0.20907070f, 0.09261213f, 0.14899044f, -0.09392314f, -0.02509574f, 0.17433733f, 
    0.14171834f, 0.10263120f, 0.06981903f, -0.09623703f, -0.16405894f, -0.30344436f, -0.00055524f, -0.03747009f, 
    -0.02870875f, -0.02226357f, -0.10301229f, 0.05076040f, 0.08332684f, -0.08406622f, 0.32049710f, 0.12483618f, 
    0.04952038f, 0.06367114f, 0.02403201f, -0.00819681f, 0.09230696f, 0.07754967f, -0.13673857f, 0.02354133f, 
    -0.04080523f, 0.01470711f, 0.07134467f, 0.23045801f, 0.03168586f, 0.20631580f, -0.11788966f, -0.02948225f, 
    0.15831684f, -0.09133943f, -0.06758124f, 0.06158309f, 0.26455486f, -0.31237462f, 0.20097482f, 0.01319149f, 
    -0.11529201f, -0.09195431f, 0.11500166f, -0.17888489f, 0.05238970f, -0.03827945f, 0.21186413f, 0.04205700f, 
    -0.06761138f, 0.41511944f, 0.02179345f, -0.06455148f, 0.04417050f, -0.03261634f, 0.10263270f, -0.08175415f, 
    -0.00915445f, 0.03288001f, 0.01058126f, 0.00137475f, 0.09757736f, -0.33661962f, -0.47747087f, 0.11787096f, 
    -0.15413553f, -0.17157714f, -0.04069346f, -0.04292879f, -0.08194112f, 0.12252635f, 0.09458412f, 0.04540326f, 
    0.11773442f, -0.07458755f, 0.12504700f, -0.00352163f, 0.08909325f, 0.21092699f, 0.14583097f, 0.07580045f, 
    0.03258529f, -0.07424609f, 0.08927391f, 0.05104578f, -0.04861651f, -0.23037256f, -0.12845646f, -0.02970686f, 
    0.11181170f, 0.07430556f, 0.10346668f, -0.11505868f, -0.18071997f, 0.11946630f, 0.00746269f, 0.02121248f, 
    0.30028814f, -0.18531972f, -0.03842991f, -0.02103984f, 0.03243788f, 0.03029096f, 0.01249894f, -0.03784331f, 
    -0.20461856f, 0.10275244f, 0.05968260f, -0.01000901f, -0.13029154f, -0.10400610f, -0.20030229f, 0.10975528f, 
    -0.00434935f, 0.04506948f, -0.00565808f, 0.00744536f, 0.04274613f, 0.07448561f, 0.08687871f, 0.06650930f, 
    0.01791723f, 0.03416457f, 0.06796503f, -0.15489241f, 0.13934755f, 0.14084777f, 0.10679206f, -0.01963270f, 
    0.09771223f, -0.08751519f, -0.14328082f, 0.07143224f, 0.39563811f, -0.10953408f, 0.09288246f, -0.07670766f, 
    0.26687598f, 0.00553840f, 0.17443715f, 0.10620923f, 0.03044262f, 0.11840410f, -0.16574787f, 0.10289677f, 
    -0.34940371f, -0.12556720f, -0.14136249f, -0.02994696f, 0.13758855f, -0.01437945f, -0.05667238f, -0.07957636f, 
    0.07274265f, 0.05937787f, -0.05753483f, 0.06022544f, -0.15999466f, 0.17537963f, -0.02508625f, -0.00000473f, 
    -0.00638806f, 0.14438060f, 0.08821412f, 0.00501544f, -0.02815248f, 0.00128662f, 0.07847540f, 0.07770351f, 
    0.35261577f, 0.00015213f, -0.00909404f, 0.23231377f, -0.06159969f, 0.08430739f, 0.03175400f, 0.13703367f, 
    0.14106958f, 0.02657022f, -0.00740302f, -0.17969005f, -0.07152645f, 0.07863981f, -0.06795308f, 0.05961971f, 
    0.05460871f, 0.03642776f, -0.13702951f, 0.04548933f, 0.14792971f, -0.11585930f, 0.02532611f, -0.02486839f, 
    -0.26581547f, -0.20935467f, -0.13930908f, 0.02741683f, -0.08688959f, -0.10961612f, -0.07092017f, -0.01389869f, 
    -0.09635494f, -0.07098231f, -0.13700233f, 0.04598475f, 0.06283296f, 0.23743676f, 0.07619090f, 0.02809669f, 
    0.11404321f, -0.04898536f, 0.05028604f, 0.13609663f, 0.00795746f, -0.10202763f, -0.01359768f, -0.18232116f, 
    -0.30673677f, -0.06229513f, 0.02832392f, -0.13347985f, -0.09403587f, 0.13331848f, -0.00960976f, -0.04634507f, 
    -0.07846673f, -0.12876090f, 0.02180680f, -0.04935060f, -0.32539284f, 0.27807614f, -0.22654109f, 0.06941836f, 
    -0.08275072f, -0.07338081f, 0.04397178f, -0.07192615f, 0.04592315f, 0.07627592f, -0.09380938f, 0.12156303f, 
    -0.03758283f, -0.13130845f, -0.07435721f, -0.00430886f, 0.01043218f, 0.06144723f, -0.06144625f, 0.05443454f, 
    0.24279946f, 0.03020872f, -0.01897063f, 0.19540232f, -0.08180427f, -0.06937993f, -0.06742905f, -0.15892395f, 
    -0.01545561f, -0.11641753f, -0.13693553f, -0.03990797f, 0.13790448f, -0.03371289f, 0.17311814f, -0.10570069f, 
    -0.15062885f, 0.07515605f, -0.15714239f, 0.05975441f, 0.08201686f, 0.12526427f, 0.24401401f, -0.06589223f, 
    0.02608497f, -0.03149986f, 0.04919684f, -0.04008221f, -0.02375370f, -0.11556195f, -0.04272189f, -0.03536896f, 
    -0.14632611f, -0.00833617f, 0.16085847f, 0.14327453f, 0.01211408f, -0.01993182f, 0.14075054f, 0.13315076f, 
    -0.10356277f, 0.23494543f, -0.03159004f, 0.13557492f, -0.00836155f, -0.05568241f, 0.08622388f, -0.12968551f, 
    0.02622651f, 0.05047215f, 0.03344529f, 0.02743384f, 0.49009773f, 0.14997071f, -0.00203568f, 0.16049735f, 
    0.09018621f, -0.03947639f, 0.09634604f, -0.05427524f, 0.00082470f, 0.12477314f, 0.05029686f, 0.22687276f, 
    0.26243773f, 0.11771969f, 0.20637731f, 0.15541951f, 0.00286701f, 0.04668783f, 0.17569469f, 0.09018816f, 
    -0.02614097f, -0.00172758f, 0.17877772f, -0.07127997f, -0.03412746f, -0.01620557f, -0.10092086f, 0.05281889f, 
    -0.13432781f, 0.04856577f, 0.14720553f, 0.12038703f, 0.01603382f, 0.02714004f, 0.16713919f, 0.10553354f, 
    -0.03049088f, 0.01166228f, -0.02691144f, -0.08139049f, -0.02337442f, 0.00565857f, -0.04519557f, 0.02347775f, 
    0.05486927f, -0.03025016f, -0.06930686f, 0.02247275f, -0.06092285f, -0.03005278f, -0.07015785f, -0.00858586f, 
    0.02669206f, -0.02875665f, 0.04760841f, 0.00858598f, -0.01710186f, 0.02970326f, -0.04889211f, -0.00726769f, 
    -0.05616236f, 0.01519109f, -0.00421404f, 0.01650105f, -0.06988297f, 0.03381079f, 0.03919094f, 0.00851144f, 
    -0.06844094f, -0.05823698f, 0.02242017f, -0.00302839f, 0.06197024f, -0.01854759f, 0.05594925f, -0.05010888f, 
    -0.03979610f, -0.06717216f, -0.07276610f, 0.04356648f, 0.06129868f, -0.08028779f, -0.01241998f, 0.02956188f, 
    -0.03278814f, 0.02367065f, 0.04017379f, 0.05149389f, -0.01040242f, -0.07237859f, -0.07155835f, -0.00036861f, 
    0.04355855f, -0.06537823f, -0.00470786f, -0.07712454f, -0.01643307f, 0.02400942f, 0.03299954f, 0.04807682f, 
    0.03516113f, -0.00369728f, 0.03194251f, 0.04196844f, 0.03723118f, 0.00521968f, 0.02151151f, -0.06237422f, 
    -0.02643875f, -0.06961808f, 0.00534313f, 0.04144481f, 0.06801723f, -0.00974625f, 0.04859756f, 0.00361087f, 
    0.02045369f, -0.07363560f, 0.03021500f, 0.05868701f, 0.06083146f, -0.03101953f, 0.05690201f, -0.04995725f, 
    -0.05281873f, -0.03757823f, -0.07037057f, -0.01618819f, -0.00089886f, -0.00858693f, -0.08255992f, 0.02555667f, 
    -0.07946022f, 0.05717290f, 0.05884529f, -0.00748323f, -0.01384208f, -0.01661416f, 0.00643007f, -0.06408790f, 
    0.01758387f, 0.03299903f, -0.04862197f, -0.00776759f, -0.05037285f, 0.03609671f, -0.01405082f, 0.01316355f, 
    0.03785262f, -0.03472007f, 0.04041202f, -0.05298798f, -0.03632224f, -0.01318850f, 0.05723640f, 0.04348793f, 
    0.01991694f, -0.03055069f, 0.02865131f, -0.00793425f, -0.00139500f, 0.02398568f, -0.00689614f, -0.04801580f, 
    -0.03023818f, -0.03583311f, -0.03283487f, -0.05921433f, 0.02979760f, -0.02412321f, -0.05517205f, -0.00771534f, 
    0.03666003f, -0.06540107f, -0.01805600f, 0.04447652f, -0.00003112f, -0.04182303f, -0.03597019f, -0.00423329f, 
    -0.01623006f, 0.04202415f, -0.00867635f, 0.06402823f, -0.00367935f, 0.00567022f, 0.03266075f, -0.06710275f, 
    -0.03719234f, -0.01413877f, -0.04483292f, -0.03777178f, -0.04334483f, -0.06563244f, -0.00915780f, -0.04176659f, 
    0.01678753f, -0.02435174f, -0.05582352f, -0.07489647f, -0.04716828f, -0.04163753f, 0.04633740f, 0.02005039f, 
    0.06325639f, 0.04031830f, 0.00956472f, -0.00891663f, 0.03199063f, -0.03528894f, -0.04263164f, 0.04680854f, 
    -0.03885397f, -0.06924167f, 0.04546875f, -0.00949244f, 0.01326056f, -0.04155533f, -0.07101940f, 0.00913182f, 
    -0.07518452f, 0.04222488f, -0.00653939f, 0.02897545f, -0.04506414f, 0.01973987f, -0.02159802f, 0.04356742f, 
    0.16738090f, 0.20399153f, 0.09982509f, 0.15862556f, -0.05685014f, 0.05803503f, -0.18505955f, -0.15373433f, 
    -0.00900624f, -0.06379378f, 0.05555192f, -0.12106675f, 0.07147118f, -0.25345534f, 0.00316861f, -0.07458406f, 
    -0.02192773f, -0.06441135f, -0.18485098f, -0.08803935f, -0.06002998f, -0.08599216f, -0.13959277f, -0.21240741f, 
    0.08353102f, -0.22342412f, -0.04098971f, 0.07571178f, 0.01078271f, -0.03990378f, 0.09830324f, 0.06390475f, 
    0.16149233f, 0.03394165f, 0.15155002f, 0.26588809f, -0.04823131f, 0.20417975f, -0.04227952f, 0.08420097f, 
    0.08301666f, 0.20683745f, 0.01323566f, 0.05760165f, 0.10992934f, 0.16255251f, 0.15950768f, 0.10023086f, 
    0.14066425f, 0.15002091f, 0.03171837f, 0.01703427f, -0.01417970f, 0.07662006f, 0.02626517f, 0.06897861f, 
    0.05557078f, 0.23024105f, -0.14543454f, 0.10487573f, 0.01317929f, -0.03044611f, 0.00644737f, 0.14176032f, 
    0.00381718f, 0.03536819f, 0.04462349f, -0.20114346f, 0.22027165f, 0.08368141f, 0.04252209f, 0.22742109f, 
    -0.18075818f, 0.18725419f, 0.11817866f, 0.10362194f, 0.10451123f, -0.06923740f, -0.06603774f, 0.01415792f, 
    0.00354545f, 0.12809293f, 0.11851674f, -0.11711312f, 0.06691240f, -0.19100121f, -0.02465782f, -0.01723132f, 
    -0.00227090f, -0.01437842f, -0.25825912f, -0.14069331f, -0.04356935f, 0.10736006f, -0.11053193f, -0.18892714f, 
    -0.00792524f, 0.23003018f, 0.03782937f, 0.12821031f, -0.13744529f, 0.10309509f, 0.14470637f, 0.12756972f, 
    0.01798970f, 0.02820689f, -0.06815316f, 0.06188884f, 0.03040377f, -0.00945871f, -0.18612467f, -0.18989415f, 
    0.18574868f, -0.00468958f, -0.02161037f, -0.15434541f, -0.09705972f, 0.16981351f, -0.11675747f, -0.00753899f, 
    0.05916911f, -0.05492616f, 0.17689103f, -0.03372846f, -0.08323252f, -0.03562406f, -0.02516480f, -0.02903615f, 
    -0.00481621f, -0.19633998f, -0.17827687f, -0.41524342f, 0.12231690f, 0.02408477f, 0.19316025f, 0.16224965f, 
    0.08531843f, 0.02565824f, 0.06105786f, 0.12864417f, 0.07924502f, -0.15472016f, 0.12273327f, 0.06657471f, 
    0.23514591f, -0.11692964f, 0.24141079f, 0.06625197f, 0.16056865f, -0.02305569f, 0.03251976f, 0.05900400f, 
    0.15636702f, 0.04319508f, 0.10718188f, -0.02669124f, 0.19706474f, 0.00220373f, 0.02655139f, 0.09213788f, 
    0.11239348f, -0.29089278f, -0.17887115f, 0.00149550f, 0.00186553f, -0.07949524f, 0.01145450f, -0.09706230f, 
    -0.00665308f, 0.09131906f, -0.13496733f, 0.19064674f, 0.14013182f, -0.03831672f, 0.01072505f, 0.03321284f, 
    -0.04577379f, -0.05142541f, 0.04245508f, 0.20828439f, -0.00156740f, 0.02996796f, -0.01246384f, -0.20633960f, 
    0.09387153f, -0.06173940f, 0.08698245f, -0.00381987f, -0.13932362f, -0.19308200f, -0.21211578f, -0.34958228f, 
    0.00230872f, 0.31373188f, -0.28032279f, -0.06056054f, -0.03682411f, 0.07024362f, 0.12794097f, -0.07099837f, 
    -0.11783969f, 0.02552943f, -0.04326492f, 0.00199185f, 0.04823649f, 0.00479606f, -0.07155044f, -0.00351367f, 
    0.06461728f, -0.09448631f, -0.06762899f, 0.02828383f, -0.05341082f, 0.11216836f, -0.10933567f, 0.01011401f, 
    -0.11805139f, 0.16275392f, -0.04175372f, -0.52622950f, 0.04981402f, 0.01660880f, 0.05457682f, 0.05063085f, 
    0.03506564f, -0.02249178f, 0.11213797f, 0.09202550f, -0.11887327f, -0.01256137f, 0.21838650f, 0.21509746f, 
    0.04501310f, 0.13528979f, -0.01881758f, -0.05125787f, 0.07862905f, 0.15756683f, -0.04212983f, -0.02990251f, 
    0.09471998f, -0.17608514f, 0.12535754f, 0.14187783f, 0.05681634f, 0.11290053f, -0.08703075f, -0.10215147f, 
    0.03729690f, -0.02886899f, 0.11033308f, -0.05727918f, -0.11285758f, 0.10839783f, 0.22813107f, 0.04669284f, 
    0.00373053f, 0.04568035f, 0.02229747f, 0.06037840f, 0.11186794f, 0.04826633f, 0.06477084f, -0.16427352f, 
    0.29482791f, 0.10299078f, -0.22034046f, 0.01073655f, 0.08434726f, -0.12633465f, 0.01922546f, -0.05840369f, 
    -0.00554879f, -0.00685947f, 0.03928358f, 0.11766874f, -0.01807530f, 0.03864231f, 0.32895720f, 0.11484970f, 
    0.11671128f, -0.12635657f, -0.12965012f, -0.00275886f, 0.18016572f, 0.03672628f, -0.05864897f, 0.08006373f, 
    0.21693656f, -0.16761653f, -0.10923194f, -0.27088401f, -0.05917273f, 0.01864780f, -0.02285976f, 0.15228771f, 
    0.03833242f, 0.14724694f, -0.03289037f, 0.13189264f, 0.12814976f, 0.07866441f, 0.22734153f, 0.14822599f, 
    0.04600218f, 0.03058387f, -0.09120256f, -0.08234640f, 0.02629011f, 0.00382160f, 0.01307610f, 0.12599285f, 
    -0.02288627f, -0.03606838f, 0.03490998f, -0.07794407f, 0.05942455f, 0.04308550f, 0.02822122f, 0.04774712f, 
    -0.15183546f, -0.08596362f, -0.02962204f, 0.08815452f, 0.26913115f, 0.39707199f, -0.07181463f, -0.23238347f, 
    0.04976103f, -0.05974627f, 0.03529317f, 0.11665756f, 0.03163787f, -0.00257240f, -0.00127979f, -0.03834760f, 
    0.06088850f, -0.10742936f, 0.20490190f, -0.12499499f, 0.09625451f, -0.07682092f, -0.02979810f, 0.02142458f, 
    0.07196729f, -0.04911903f, 0.02061384f, 0.08237814f, -0.37524143f, 0.07402741f, 0.26061156f, -0.31663328f, 
    -0.04860915f, -0.16534059f, -0.01520511f, 0.00221232f, 0.10009869f, 0.02813263f, 0.04078571f, 0.03926519f, 
    -0.02100908f, -0.04821475f, -0.35326833f, 0.00289069f, 0.02797994f, -0.05607465f, -0.10139965f, 0.03581752f, 
    0.00846097f, 0.09316277f, 0.08959032f, 0.02231553f, -0.13755882f, 0.01898453f, -0.06448625f, -0.17058328f, 
    0.11006095f, 0.05050059f, 0.10446709f, -0.02722586f, -0.04920580f, -0.08613495f, 0.01368453f, -0.07744586f, 
    0.28948671f, -0.31964901f, 0.16526668f, -0.17653550f, 0.12026758f, 0.06599728f, -0.00859272f, 0.00346046f, 
    0.05365897f, 0.04161819f, 0.15101378f, -0.08345086f, -0.02016981f, 0.00087058f, -0.07500710f, -0.03744745f, 
    -0.04989452f, 0.04455847f, 0.09990995f, -0.08725255f, 0.07395437f, 0.17360766f, 0.00249336f, -0.06304924f, 
    0.01097131f, -0.24054228f, 0.10507926f, 0.17950310f, 0.15168348f, -0.07443714f, 0.00938217f, -0.09222436f, 
    -0.06549424f, -0.04735932f, 0.03433330f, 0.23449413f, -0.25930202f, 0.20157577f, 0.03094425f, -0.26740506f, 
    0.21969762f, 0.00039253f, 0.16054432f, 0.03969404f, -0.12578292f, 0.07729222f, 0.11523186f, 0.03137387f, 
    0.06358512f, 0.27252993f, -0.03791423f, -0.00616843f, -0.00788855f, -0.12396558f, 0.04253106f, 0.04470394f, 
    -0.03693766f, 0.05195596f, -0.08643086f, -0.12154204f, 0.02898582f, -0.16635872f, -0.13701116f, -0.07740573f, 
    -0.01956088f, -0.02508155f, 0.15484911f, -0.02409847f, -0.03008456f, 0.07578647f, 0.00514107f, 0.19038156f, 
    0.22916240f, 0.05359808f, 0.16836968f, 0.04914976f, -0.04407396f, -0.05176171f, -0.11848443f, 0.09678207f, 
    0.07335588f, 0.19803661f, -0.07696838f, -0.03739168f, 0.02619221f, -0.07325871f, -0.24064080f, -0.03852399f, 
    -0.10890172f, 0.11655990f, 0.02840242f, 0.18442005f, -0.12821904f, -0.03715417f, 0.01410741f, -0.22722010f, 
    -0.19622830f, 0.25008407f, 0.12088467f, 0.27609852f, 0.00212264f, -0.09065527f, 0.08789120f, -0.14548713f, 
    -0.11080112f, 0.04361917f, 0.11299686f, -0.07442706f, -0.06820266f, 0.12958220f, -0.10358368f, -0.17955159f, 
    0.03557003f, 0.02134758f, -0.01892206f, 0.08065891f, -0.01730127f, 0.10308957f, -0.11181869f, -0.05100816f, 
    -0.08317114f, -0.05860035f, -0.02234385f, 0.18707336f, 0.09703850f, 0.10225182f, -0.02116179f, 0.24483618f, 
    0.03403882f, 0.07156821f, 0.01255355f, -0.02034613f, -0.17087235f, -0.11869636f, 0.16763519f, 0.17457780f, 
    0.36536393f, 0.06601329f, -0.07248893f, -0.18418066f, -0.00635616f, -0.03692970f, -0.01697967f, 0.01203291f, 
    -0.22770439f, -0.00271816f, -0.12944070f, 0.05631436f, -0.00880929f, 0.13667691f, -0.04313331f, 0.12159574f, 
    -0.06297574f, 0.02827085f, 0.02175222f, -0.00077875f, 0.18127255f, 0.11810064f, 0.01697267f, 0.20839904f, 
    0.01883565f, 0.00056521f, -0.07358314f, 0.16025710f, 0.09563009f, 0.02422088f, 0.09038913f, -0.04022811f, 
    -0.29753706f, -0.03980681f, 0.09714992f, -0.02273710f, 0.06531798f, -0.03070964f, 0.02425850f, -0.04545165f, 
    -0.00610459f, 0.26243976f, -0.01910927f, 0.10031739f, -0.20198633f, -0.21346918f, 0.05366326f, 0.04537464f, 
    0.24078397f, 0.03682915f, -0.08098032f, 0.00630737f, 0.04292146f, 0.10055624f, -0.06369650f, -0.03611710f, 
    0.03111385f, 0.21339235f, -0.58477145f, 0.08213875f, 0.09657412f, -0.12181444f, 0.00322615f, -0.18670897f, 
    -0.15028827f, 0.01311051f, 0.06772853f, -0.03277268f, 0.28791040f, -0.21534805f, -0.08176687f, 0.01708240f, 
    0.11332142f, -0.09074277f, -0.07578281f, 0.03313265f, -0.02200905f, 0.09830467f, -0.18159367f, 0.02349162f, 
    -0.51872206f, -0.08513696f, 0.06172966f, -0.20459838f, 0.01813459f, -0.07351041f, 0.00810299f, -0.10735381f, 
    -0.08499196f, -0.12160703f, -0.01058480f, 0.24408571f, -0.26967350f, -0.02702008f, 0.22817552f, 0.04069401f, 
    -0.02476735f, 0.13205038f, -0.07833949f, 0.11124294f, -0.06952046f, 0.08420607f, 0.00687864f, 0.03334390f, 
    -0.02705289f, -0.15398753f, -0.15530109f, -0.14024572f, -0.16487490f, -0.10013980f, -0.10243307f, -0.04403706f, 
    0.00039875f, -0.04386931f, 0.15540428f, -0.02104914f, 0.09454975f, -0.05843641f, 0.17120816f, 0.17008016f, 
    0.11740714f, 0.09741368f, 0.11227158f, 0.06774606f, 0.17592813f, 0.01004666f, -0.02171551f, 0.05613380f, 
    0.24484694f, 0.07723100f, -0.36892259f, -0.08739661f, 0.00404957f, 0.07951239f, -0.09821165f, 0.12603150f, 
    0.09474978f, -0.07756280f, 0.02540081f, 0.21376733f, 0.21930076f, -0.35014179f, 0.08684789f, 0.02651550f, 
    -0.11879592f, -0.00839347f, -0.09946648f, -0.01652391f, 0.20610835f, 0.11064587f, 0.09456015f, 0.17460547f, 
    -0.03550368f, -0.07701176f, 0.16556914f, -0.19653738f, 0.04491129f, 0.07418158f, 0.12002017f, 0.04707870f, 
    -0.03401692f, 0.07941360f, 0.04977223f, -0.08357754f, 0.03544239f, -0.15811257f, -0.00499224f, 0.06400615f, 
    -0.10336094f, -0.05739171f, 0.12013146f, -0.04935253f, 0.02058622f, 0.14204302f, -0.00373589f, -0.01007505f, 
    -0.00456359f, -0.01168358f, 0.10802278f, 0.02084768f, -0.03981540f, 0.02764433f, 0.02347829f, 0.21896756f, 
    -0.03152861f, 0.00943085f, -0.04612399f, 0.13823710f, 0.06946117f, 0.25702640f, 0.07692896f, -0.05043542f, 
    0.11600928f, 0.11231515f, -0.05705144f, -0.14255618f, 0.04837185f, 0.01902265f, -0.11917286f, -0.13248220f, 
    0.06592644f, -0.09427615f, 0.12875114f, 0.14188848f, 0.08047331f, 0.07448621f, 0.12297396f, 0.29335523f, 
    -0.09246593f, -0.11788125f, -0.14975166f, -0.07323491f, -0.23552339f, 0.18401216f, 0.12589641f, -0.15894230f, 
    -0.09881452f, -0.12947948f, 0.08000218f, 0.04933180f, 0.11473360f, -0.12092324f, -0.02496150f, -0.11969469f, 
    -0.20420098f, 0.06994992f, -0.07765650f, -0.07074752f, 0.06147081f, 0.07529562f, -0.01582374f, 0.07193363f, 
    0.14822486f, 0.01751068f, -0.00775559f, 0.03071298f, -0.02388277f, -0.15180258f, 0.12191574f, -0.09809686f, 
    0.09680866f, 0.09350977f, 0.03018594f, 0.11708019f, -0.00969152f, -0.12259483f, -0.14885034f, 0.00673120f, 
    -0.00006757f, -0.03856708f, -0.02300009f, -0.02803764f, 0.05011547f, 0.03209094f, -0.07431085f, -0.03633060f, 
    0.06389322f, 0.04133148f, -0.06281821f, 0.02571594f, -0.04350618f, -0.02209359f, 0.01464873f, 0.00087443f, 
    -0.04137406f, -0.04323472f, 0.01485536f, 0.01293367f, -0.01327827f, 0.05899795f, -0.01892304f, -0.01066237f, 
    -0.06999288f, -0.07507773f, 0.05129700f, -0.02147246f, 0.06014249f, 0.02259058f, 0.06330576f, 0.02507805f, 
    -0.05410643f, 0.06117468f, -0.03774421f, 0.01864642f, 0.06509884f, 0.03735808f, -0.02957156f, 0.05419408f, 
    -0.02423895f, -0.01160326f, -0.04072045f, 0.02057754f, 0.01833859f, -0.00100025f, -0.01874910f, 0.05851438f, 
    -0.05736120f, -0.02113673f, 0.01280644f, -0.05517674f, 0.03958027f, 0.05234664f, -0.04067374f, -0.03957877f, 
    0.01265706f, -0.07668776f, -0.03091324f, -0.07317997f, -0.02144023f, -0.02603249f, -0.07164877f, -0.01793000f, 
    -0.01243823f, -0.03989561f, -0.07432543f, -0.01369867f, -0.05383707f, 0.03147908f, -0.06576650f, -0.04084511f, 
    -0.07151294f, -0.01170772f, -0.04475246f, -0.02619379f, 0.00035120f, -0.03526947f, -0.05955057f, 0.04839071f, 
    -0.05510663f, 0.06140406f, -0.01345590f, 0.02878040f, 0.05697822f, 0.00001610f, 0.04182952f, -0.01620747f, 
    0.03041873f, -0.05927328f, 0.01564845f, 0.03052661f, 0.02916016f, 0.01020556f, -0.04829711f, -0.04311578f, 
    -0.02899854f, -0.05523420f, -0.04267538f, -0.06613584f, -0.03284160f, -0.01969652f, 0.01623914f, -0.01517879f, 
    -0.00604171f, 0.04299741f, -0.01563836f, 0.01479567f, -0.07361812f, -0.06112074f, 0.03499607f, -0.07032566f, 
    0.05453446f, -0.07021920f, -0.07343056f, 0.06570590f, 0.01818806f, -0.01693112f, -0.03580161f, -0.04631569f, 
    0.03462718f, -0.06078234f, 0.02816638f, -0.05405105f, 0.00134875f, 0.00297756f, 0.01716835f, 0.02623224f, 
    -0.07195061f, -0.01213237f, 0.03665316f, -0.02117126f, 0.02379649f, -0.05571035f, -0.03995284f, -0.02519631f, 
    -0.00874617f, 0.05860756f, 0.02092894f, -0.04055150f, 0.06104991f, 0.06267709f, 0.04361714f, 0.00503876f, 
    -0.06414934f, -0.03111632f, 0.05208282f, -0.03040609f, 0.02364570f, 0.00137287f, 0.00345157f, -0.05359462f, 
    -0.07317986f, 0.02760225f, -0.06371197f, -0.05625733f, -0.00477042f, 0.06009285f, -0.07137723f, 0.00731182f, 
    0.03023743f, -0.02410497f, -0.00322479f, -0.01654747f, 0.00562544f, -0.05152413f, 0.06290487f, -0.05930241f, 
    -0.06499061f, 0.04883943f, 0.04188054f, 0.00626600f, 0.02084314f, 0.05998968f, -0.03282771f, -0.04887037f, 
    0.01036685f, -0.07156245f, 0.00475340f, -0.01726381f, -0.01569679f, 0.00572949f, -0.06159192f, 0.03264078f, 
    -0.01379734f, -0.02633047f, -0.01417247f, 0.04545889f, 0.02360109f, -0.00169666f, 0.01553769f, 0.00706900f, 
    -0.35444897f, -0.21018451f, 0.04545218f, 0.21471120f, 0.05949756f, 0.14309509f, -0.06607388f, -0.02678197f, 
    0.17790250f, -0.07588198f, 0.12023743f, 0.03166578f, 0.05524305f, 0.09803278f, 0.07104289f, 0.10703574f, 
    0.01570479f, 0.09411663f, 0.00573642f, -0.07432061f, -0.03904003f, -0.15968432f, 0.11512901f, -0.16212857f, 
    0.24390301f, 0.01620204f, 0.11891333f, 0.29470614f, -0.12214112f, 0.05924104f, -0.01631394f, 0.11664471f, 
    -0.03483539f, 0.08262525f, 0.00653771f, -0.05202393f, -0.18060966f, -0.00949852f, 0.06229394f, 0.04329766f, 
    -0.10560104f, 0.03978749f, -0.09659628f, -0.02396166f, -0.00888917f, 0.16974351f, -0.01531516f, -0.02340843f, 
    -0.32111803f, -0.33924100f, 0.08979440f, 0.07593803f, -0.02427816f, -0.08661565f, 0.05021559f, -0.01298450f, 
    0.01334130f, 0.12373268f, -0.11792708f, 0.22015843f, -0.07721896f, 0.09633865f, 0.05269302f, -0.00027656f, 
    0.00029946f, 0.06848375f, 0.07984845f, -0.12091169f, -0.02444775f, -0.06821921f, 0.03653054f, 0.05223351f, 
    -0.43372825f, -0.11164018f, -0.16975428f, -0.25381860f, -0.04464561f, -0.00174121f, 0.00785894f, -0.31322485f, 
    -0.20111313f, 0.05222137f, 0.13784266f, -0.14948499f, -0.29929626f, 0.13653691f, -0.10051169f, 0.07488258f, 
    0.00766267f, -0.00837829f, 0.11714710f, -0.07455724f, -0.07176821f, -0.07035264f, -0.05837044f, 0.09791516f, 
    0.00734279f, -0.19892935f, 0.08813918f, 0.18241046f, -0.03612821f, 0.03472624f, 0.02342217f, -0.08617673f, 
    -0.02175515f, -0.10619503f, 0.01329631f, -0.01418787f, -0.02593739f, 0.06484605f, 0.00241338f, -0.00349109f, 
    -0.05118513f, -0.07659598f, -0.01238331f, 0.05328494f, -0.03320608f, 0.08124605f, -0.11838508f, -0.08203533f, 
    -0.08798360f, 0.12657212f, 0.11943993f, 0.06664152f, -0.07702028f, 0.11566599f, 0.10279287f, -0.06659396f, 
    -0.15167339f, -0.06381196f, -0.19270733f, -0.10923421f, 0.10880692f, -0.03732036f, 0.08111438f, 0.17065929f, 
    0.07771198f, -0.01679739f, 0.11572200f, 0.13641232f, -0.00726065f, 0.04587036f, 0.00494697f, 0.06211831f, 
    -0.07865906f, 0.11911988f, 0.02945394f, 0.11570242f, -0.01228504f, -0.01045494f, 0.10667904f, 0.00991379f, 
    0.01633576f, 0.01632862f, 0.04050047f, 0.07207578f, 0.48941717f, 0.09517520f, 0.05018426f, 0.17201941f, 
    0.03165429f, -0.05705082f, 0.03803127f, -0.14777246f, -0.02718615f, 0.01569038f, -0.06517187f, -0.00045230f, 
    0.33146051f, 0.21087407f, 0.24286465f, 0.19783209f, -0.02894824f, -0.15120208f, 0.03558436f, 0.07305964f, 
    -0.06812543f, 0.08361548f, 0.17675202f, 0.01327512f, 0.09844507f, 0.13723955f, -0.06674136f, 0.04859910f, 
    -0.07496577f, 0.02129468f, 0.13069424f, 0.19634019f, 0.03080681f, 0.10796452f, -0.01028732f, -0.09844688f, 
    -0.27369678f, -0.34825614f, -0.05639940f, -0.25100037f, -0.13296746f, -0.04993653f, 0.27212283f, -0.05219202f, 
    -0.06081682f, 0.01919668f, -0.08223423f, 0.11304256f, -0.02743313f, 0.27776417f, 0.05475103f, -0.15295051f, 
    0.10455894f, 0.17350465f, 0.10537592f, -0.10038316f, -0.14812954f, 0.03814924f, 0.21841839f, -0.09682703f, 
    -0.00599862f, 0.33341742f, 0.10710027f, 0.03113525f, 0.02807374f, -0.00933908f, -0.04202726f, 0.04049418f, 
    0.03366826f, -0.08036207f, -0.11047478f, -0.21306947f, 0.20106925f, -0.34365630f, 0.17725202f, 0.19759786f, 
    -0.15833193f, 0.10480837f, -0.11055326f, -0.29119334f, 0.19227046f, 0.04087847f, -0.08623552f, -0.15384422f, 
    -0.22725621f, -0.39424831f, -0.10712029f, -0.46318793f, 0.08464145f, 0.10657460f, 0.03566925f, -0.30644751f, 
    0.06918215f, -0.27914271f, 0.09593430f, -0.07456867f, -0.00778669f, 0.07441963f, -0.05586352f, -0.00250217f, 
    -0.02633931f, -0.01661352f, -0.07227947f, -0.00370092f, -0.05819568f, -0.02429316f, -0.02062730f, 0.06255117f, 
    0.27090871f, -0.21119770f, 0.03048282f, 0.02511273f, -0.05709867f, 0.00756979f, 0.14557175f, 0.05699967f, 
    -0.08104492f, -0.06560837f, 0.00624256f, -0.04950939f, -0.36113477f, 0.23650001f, -0.03092994f, -0.02585157f, 
    -0.08502523f, 0.11478136f, 0.01588029f, -0.11548506f, 0.04683040f, -0.06543785f, 0.11986107f, 0.05585610f, 
    0.17049167f, -0.14496455f, 0.01470045f, -0.03793747f, 0.20152627f, -0.00592961f, -0.04843544f, 0.13275433f, 
    0.12998869f, -0.07606134f, -0.01436495f, -0.10963454f, -0.25255969f, 0.01899104f, -0.12405620f, -0.08430594f, 
    -0.21375145f, 0.02078556f, -0.05244761f, -0.03340728f, -0.02268360f, 0.03891399f, 0.08089247f, 0.01992704f, 
    0.00415245f, 0.17778000f, -0.01116223f, -0.00535184f, 0.06658573f, 0.01866416f, 0.02042952f, -0.02382653f, 
    -0.13313264f, 0.10029757f, -0.23014535f, 0.08384643f, 0.10304367f, 0.22566120f, 0.18121305f, 0.06396834f, 
    -0.07054384f, -0.06242465f, -0.04242235f, 0.16107219f, -0.16223034f, 0.01798314f, -0.09067623f, -0.01897269f, 
    0.16446352f, 0.16277133f, -0.02579678f, 0.04964819f, -0.04359035f, 0.07705180f, -0.04288055f, -0.02796547f, 
    0.18971030f, 0.07418413f, -0.00825341f, -0.03294761f, -0.13733983f, -0.05020790f, 0.01674394f, -0.19252893f, 
    -0.07797838f, 0.07761563f, 0.06259249f, 0.13591877f, 0.04641033f, 0.14882752f, -0.13914238f, 0.02318194f, 
    0.28999645f, 0.15442389f, 0.13608648f, 0.00099481f, -0.09496865f, -0.03353237f, 0.03552205f, 0.02849888f, 
    0.04405525f, 0.00962599f, -0.02748894f, -0.08420552f, 0.05771555f, 0.26194814f, 0.13993542f, 0.11955664f, 
    -0.04139472f, 0.09735244f, -0.15751350f, 0.18121631f, 0.09411946f, 0.16682640f, 0.15401331f, 0.07573170f, 
    0.04372795f, -0.01059797f, -0.02105908f, -0.02668078f, -0.01544531f, 0.05285764f, -0.01018818f, -0.05949820f, 
    0.00337483f, -0.04969085f, 0.05924137f, 0.05417408f, -0.06993019f, -0.02063921f, -0.00764610f, 0.00664450f, 
    -0.04730362f, -0.03595303f, 0.03790686f, -0.06957138f, -0.07190280f, 0.00693999f, -0.03469920f, 0.01515309f, 
    -0.03443620f, 0.02709556f, 0.00389109f, -0.06493136f, -0.01976439f, 0.01182012f, -0.07478198f, -0.02567253f, 
    -0.01318410f, 0.02355783f, -0.02844051f, 0.00462992f, -0.07258304f, 0.01827094f, -0.02705806f, -0.00382253f, 
    0.02095574f, -0.00309731f, -0.01085342f, 0.01305038f, 0.00341846f, -0.07672277f, 0.03301384f, 0.00075747f, 
    0.01029297f, -0.03245766f, -0.08246543f, -0.02318623f, 0.01163341f, -0.02591010f, 0.04226615f, -0.02759062f, 
    -0.02169425f, -0.02860788f, -0.06712884f, -0.00712301f, 0.06063819f, 0.02397335f, -0.01814823f, 0.05056813f, 
    0.01515642f, -0.00813096f, 0.02839246f, 0.03677879f, -0.03460940f, -0.00642649f, -0.00212428f, 0.01299170f, 
    0.05456227f, -0.06747792f, 0.03094981f, 0.02068229f, 0.01998825f, -0.03042935f, 0.01833138f, 0.00843544f, 
    -0.08096409f, -0.06870265f, -0.00767644f, 0.03027308f, 0.01603165f, 0.01447079f, 0.05462186f, -0.05027619f, 
    -0.02790954f, 0.02287711f, -0.04957599f, 0.05938259f, 0.06284436f, -0.05204178f, -0.00886947f, -0.08006141f, 
    0.00626074f, -0.07251262f, 0.02667894f, 0.01101450f, -0.02922276f, 0.04517708f, -0.04475188f, -0.04465095f, 
    0.02753955f, -0.01095820f, -0.05963427f, 0.04630606f, 0.01007301f, -0.01994441f, -0.02277464f, -0.00885317f, 
    -0.02713118f, 0.06296698f, 0.05545241f, -0.02511986f, -0.00642705f, 0.04156224f, -0.04158269f, 0.05845913f, 
    -0.06499744f, 0.06454042f, -0.06127467f, -0.03942008f, 0.06157002f, 0.04908231f, -0.00098906f, 0.05098330f, 
    -0.05266798f, 0.06031321f, 0.03964147f, 0.01491087f, -0.01466912f, -0.06230281f, 0.02412803f, 0.06473196f, 
    -0.03208485f, 0.02630145f, 0.05713879f, 0.06218132f, 0.05170538f, 0.02399727f, -0.00976979f, -0.04893035f, 
    0.02622529f, 0.03683995f, -0.01548326f, -0.01057341f, 0.04743711f, -0.05927937f, 0.03545421f, 0.05289604f, 
    -0.03515621f, -0.01480145f, -0.03404414f, 0.04193412f, -0.03392916f, -0.02283986f, -0.06840982f, 0.06484963f, 
    -0.07377265f, -0.01127074f, -0.06313118f, -0.00018324f, -0.01568457f, -0.07378320f, -0.01962067f, -0.00186006f, 
    -0.06244553f, -0.02638602f, -0.04675848f, 0.01076322f, -0.02827868f, 0.05347620f, -0.08375753f, -0.01652940f, 
    -0.00398876f, -0.05536444f, 0.02347180f, 0.00675906f, -0.04288875f, 0.00110764f, 0.00177178f, -0.03191085f, 
    -0.06085170f, 0.01836313f, 0.00148089f, 0.02692077f, 0.03808441f, -0.03387220f, -0.03073684f, -0.07622670f, 
    0.05521584f, 0.09582599f, 0.06641648f, -0.08833331f, -0.17063093f, 0.06768673f, -0.14932115f, 0.13226870f, 
    -0.04965493f, 0.18774645f, -0.03015556f, 0.06258275f, -0.10251620f, -0.07006804f, 0.05247432f, 0.02269256f, 
    0.10679750f, 0.05927819f, -0.11442178f, -0.11636503f, -0.06081400f, 0.18345675f, 0.13035105f, 0.08460647f, 
    0.31653291f, 0.23258942f, 0.03741381f, -0.09939691f, 0.01290737f, 0.11011686f, 0.17321664f, 0.09835958f, 
    -0.02041428f, -0.02874536f, 0.02825019f, 0.02997659f, 0.04682373f, 0.33716905f, -0.36075130f, -0.34324208f, 
    0.14766538f, -0.17025314f, 0.30052739f, 0.05599686f, 0.05318139f, -0.23171291f, 0.08208013f, -0.01824166f, 
    0.18446483f, -0.07207262f, 0.20649329f, -0.11960650f, -0.05028792f, -0.10578161f, 0.00614371f, -0.08414533f, 
    0.02256405f, -0.03147289f, -0.03858916f, -0.06357393f, 0.12243236f, -0.08260681f, 0.10919217f, -0.13234173f, 
    -0.02547166f, 0.04451998f, -0.07091218f, 0.13277760f, -0.04164164f, -0.12283374f, -0.07024480f, -0.21221055f, 
    0.02125721f, 0.19417377f, -0.05268000f, 0.24121690f, -0.09617166f, -0.14253481f, 0.08038467f, -0.07292553f, 
    0.05194464f, 0.03327448f, -0.08140273f, 0.06290232f, 0.11518638f, -0.03149061f, 0.09173083f, -0.25799054f, 
    0.08482389f, -0.05369420f, 0.00315904f, 0.09014568f, 0.02424861f, 0.10389945f, -0.11132175f, 0.15425766f, 
    0.14622431f, 0.38719627f, -0.05804439f, -0.02207657f, 0.09235983f, -0.02400275f, 0.01599105f, 0.12569910f, 
    -0.12672852f, 0.01057829f, -0.00916586f, 0.08763245f, -0.07308616f, -0.09509827f, -0.07915240f, -0.09720602f, 
    -0.09978624f, -0.05192172f, -0.00366115f, -0.10952883f, -0.01174769f, -0.00449549f, 0.14107120f, 0.16158527f, 
    0.08412843f, -0.09111126f, -0.01900828f, 0.02856100f, 0.03276860f, 0.03472834f, 0.05379471f, -0.13476263f, 
    0.00829369f, 0.03805570f, 0.25491160f, 0.14888817f, 0.06442727f, -0.12720105f, -0.09085339f, 0.05328878f, 
    0.09662221f, 0.16130854f, 0.06199388f, 0.08701376f, -0.09816606f, -0.14277369f, 0.05218042f, 0.04480521f, 
    0.14031456f, -0.11240693f, -0.18086137f, -0.09656764f, 0.15492496f, 0.06061597f, 0.00211635f, -0.10610975f, 
    -0.03870447f, -0.08686161f, -0.02207140f, -0.01302458f, -0.12592201f, -0.32082528f, -0.18367995f, -0.07550036f, 
    0.16417815f, 0.06153296f, 0.02891897f, -0.10749298f, -0.09766591f, 0.20722581f, 0.04761400f, 0.10356846f, 
    -0.02054301f, -0.17896859f, -0.11651757f, -0.09007336f, 0.14928482f, 0.16190803f, 0.13685808f, 0.15182421f, 
    0.04219712f, -0.07142868f, -0.01963206f, -0.04538542f, 0.13141160f, 0.01765097f, -0.05244799f, -0.02031456f, 
    0.22153883f, -0.05361006f, 0.09045029f, -0.04186455f, -0.11777131f, -0.02067760f, -0.01454737f, -0.01618379f, 
    0.47660953f, -0.41083294f, 0.19679213f, -0.27474838f, 0.06273815f, 0.07147648f, -0.04871633f, 0.10309357f, 
    -0.01018582f, -0.02008470f, -0.00002508f, 0.08202032f, -0.31192014f, 0.13667046f, 0.07623976f, 0.07388500f, 
    0.09077679f, 0.05210631f, 0.05824878f, 0.03448639f, -0.02429865f, -0.09089972f, 0.16194463f, 0.00880512f, 
    0.39114666f, 0.28050205f, -0.04778779f, 0.13166420f, 0.09785435f, 0.11821090f, 0.01542643f, -0.11763748f, 
    -0.12684734f, -0.06097710f, -0.02580695f, -0.20254372f, -0.06934258f, 0.03705318f, -0.22995046f, -0.02947482f, 
    0.09677479f, 0.04805492f, 0.17746942f, -0.08238562f, 0.11790790f, -0.02938994f, 0.09704963f, 0.09211667f, 
    -0.00078299f, 0.11806110f, -0.03502181f, 0.26353264f, -0.07411496f, -0.02029764f, -0.02122809f, -0.04437382f, 
    0.00594385f, 0.05809151f, -0.02355848f, 0.03514647f, -0.01452537f, 0.13516928f, -0.06755827f, -0.30216861f, 
    0.01418356f, 0.14445943f, -0.01230322f, 0.10042864f, -0.03536627f, 0.00831637f, 0.12296889f, 0.03652383f, 
    0.40082374f, -0.11746222f, 0.17006719f, 0.07375079f, -0.10856749f, 0.00407790f, -0.07544806f, 0.00906553f, 
    -0.16506152f, 0.18104097f, -0.01429777f, 0.15577175f, -0.22520871f, 0.14296505f, -0.05846673f, -0.11964183f, 
    -0.09937464f, 0.16429833f, 0.04661065f, 0.19086561f, -0.02841657f, 0.29821438f, -0.10987002f, 0.01122724f, 
    -0.08885271f, 0.21230628f, -0.23883590f, 0.12035888f, 0.10573714f, -0.02212358f, 0.02388207f, -0.03517689f, 
    -0.04021676f, 0.00439321f, -0.01991541f, -0.01047474f, -0.15352555f, 0.09370109f, 0.09850099f, 0.06934115f, 
    -0.08733473f, -0.00296468f, -0.04021725f, 0.13348185f, 0.14217274f, 0.05436509f, -0.01035356f, -0.14430799f, 
    -0.06757067f, 0.14651775f, 0.07357080f, 0.09478040f, 0.17453000f, -0.14132968f, 0.07287611f, 0.02413571f, 
    -0.06376477f, -0.09197076f, 0.09400348f, 0.00643212f, 0.06561317f, -0.33595297f, -0.03485828f, -0.14926311f, 
    -0.06843284f, 0.07741687f, -0.07677548f, -0.03847840f, -0.03252359f, -0.04293742f, -0.02663461f, 0.04859887f, 
    -0.20536309f, 0.26883438f, -0.16581979f, -0.07546320f, -0.00741686f, 0.22858943f, 0.11160842f, -0.15322362f, 
    0.09907206f, -0.04947958f, 0.04920899f, -0.02985749f, -0.03462655f, -0.00832387f, -0.02232585f, 0.09274744f, 
    -0.07867099f, 0.19152659f, -0.17090981f, 0.26010486f, -0.01107703f, 0.16447464f, -0.12343249f, -0.00349552f, 
    0.03342598f, 0.05263834f, 0.25940770f, -0.01107193f, 0.03031730f, -0.10754442f, 0.04511010f, -0.06464323f, 
    0.00005435f, -0.06906176f, 0.16105962f, 0.06996534f, -0.09947135f, 0.14323081f, -0.12948665f, 0.19448900f, 
    0.01004676f, -0.00533362f, -0.02744604f, -0.05872842f, -0.10118977f, -0.02384653f, 0.02443369f, 0.01257305f, 
    0.04959472f, 0.15620178f, 0.06675828f, -0.01668312f, -0.13709660f, -0.00840513f, -0.11012076f, -0.02343719f, 
    -0.07414478f, 0.02702256f, -0.02399178f, -0.00879943f, -0.19860592f, 0.02556531f, -0.05082504f, 0.02377953f, 
    0.14893116f, -0.01551862f, -0.03382210f, -0.11946466f, -0.14344618f, 0.06188360f, 0.04567383f, -0.08780580f, 
    0.17799856f, 0.42286342f, -0.00603046f, -0.18076137f, 0.09491912f, 0.08078911f, 0.04857613f, 0.16759270f, 
    -0.00215162f, 0.04288989f, -0.11464763f, 0.00632748f, 0.41835684f, 0.04204071f, -0.01233665f, -0.07591894f, 
    -0.09713081f, -0.01413909f, 0.23756990f, 0.09869275f, 0.10970020f, -0.07737960f, -0.04002236f, -0.09538215f, 
    0.17842956f, 0.02618962f, 0.22491832f, 0.17455913f, -0.13081731f, -0.08976804f, -0.14908093f, -0.11058739f, 
    0.00941265f, -0.10193142f, -0.02287230f, -0.02139120f, 0.02899402f, 0.08139652f, 0.14129069f, -0.14956746f, 
    -0.02352496f, 0.04989973f, -0.07578594f, 0.14997852f, -0.03390272f, -0.05162806f, -0.14769103f, -0.29688388f, 
    0.48202175f, 0.15186454f, -0.15026902f, 0.11116323f, -0.08181372f, -0.20916626f, 0.11593551f, -0.05169043f, 
    0.08095552f, -0.02731178f, -0.03721632f, 0.16415057f, -0.13782179f, 0.04555628f, 0.20527209f, -0.00631306f, 
    0.02521187f, 0.00562542f, 0.02756512f, -0.00504673f, 0.15768002f, -0.04715036f, 0.08938769f, 0.12222920f, 
    0.26300529f, 0.19750875f, -0.03455100f, -0.32689378f, 0.11925546f, -0.02597029f, -0.03898914f, 0.10392074f, 
    -0.03740468f, -0.08477340f, -0.01863564f, 0.07553951f, 0.11078329f, -0.07589839f, 0.01265457f, -0.04416483f, 
    -0.07736668f, -0.02205417f, -0.00973811f, -0.06446211f, 0.08237422f, -0.08621017f, 0.13343626f, 0.07836238f, 
    -0.17894800f, -0.01726342f, 0.02200200f, -0.15797307f, 0.08133870f, 0.04523002f, 0.03819032f, -0.11722155f, 
    -0.12785147f, 0.02497949f, 0.02548295f, 0.02457914f, 0.10637929f, -0.07328969f, -0.14231765f, -0.11094254f, 
    0.03476560f, 0.10708879f, 0.03871802f, 0.03523478f, -0.03960938f, 0.06413211f, 0.10850930f, 0.02770319f, 
    0.05515659f, 0.09699225f, -0.12685269f, -0.15328681f, 0.00095674f, 0.09791502f, 0.09085170f, -0.07787762f, 
    -0.05631281f, -0.01750111f, 0.00590671f, 0.04338084f, -0.19257410f, -0.24800090f, -0.18394753f, -0.23947586f, 
    -0.05312447f, 0.09385031f, 0.03841054f, -0.18188281f, -0.04944303f, 0.16161382f, 0.09170598f, 0.11899376f, 
    0.15905675f, -0.12082297f, -0.00138846f, -0.16467588f, 0.07290528f, 0.07983802f, 0.11472706f, 0.16477658f, 
    0.04142185f, -0.01796358f, 0.12653422f, -0.12194152f, 0.04104316f, 0.01394504f, -0.18895720f, -0.13902074f, 
    0.09693084f, 0.00634460f, 0.05173474f, -0.03900661f, -0.04533016f, -0.12713867f, -0.07171991f, 0.02302724f, 
    -0.17588851f, -0.06948980f, -0.11480699f, 0.06183573f, -0.07445031f, -0.09604212f, -0.14122912f, -0.02127114f, 
    0.09178489f, -0.05306222f, 0.09875280f, -0.09032500f, 0.16313878f, -0.08535320f, 0.00234917f, 0.01977667f, 
    -0.00927894f, 0.01319562f, -0.10507156f, 0.07294068f, 0.10105672f, 0.11661877f, 0.01593009f, -0.04985078f, 
    -0.29010627f, 0.05211449f, 0.09650529f, -0.10564575f, 0.08755839f, -0.04335992f, 0.06290789f, 0.14699715f, 
    -0.01353753f, -0.05348889f, 0.04214007f, 0.05994891f, -0.16019645f, 0.04992734f, 0.17274851f, 0.26082310f, 
    -0.20978118f, 0.18009822f, -0.04381476f, 0.09414322f, -0.14929612f, 0.15096770f, -0.13759768f, -0.11334446f, 
    -0.32694259f, -0.34803709f, -0.20378992f, -0.14304918f, 0.00918617f, -0.01963265f, -0.05663112f, -0.03436868f, 
    0.03800907f, 0.05453424f, 0.01094771f, 0.05200130f, -0.12891038f, 0.01574478f, 0.01498698f, 0.16375105f, 
    0.01338480f, -0.02795085f, 0.03930241f, -0.11008669f, -0.11707384f, -0.01991278f, -0.04693424f, 0.10864431f, 
    0.22260693f, -0.22507404f, -0.27297792f, 0.01474731f, -0.01984789f, -0.02985152f, -0.06931665f, -0.02788553f, 
    0.12466019f, -0.04639076f, -0.08647936f, 0.01519495f, -0.31411552f, -0.06777663f, 0.20390026f, -0.05241724f, 
    -0.12344560f, 0.04868030f, 0.03212203f, -0.06387927f, -0.09507527f, -0.19555496f, 0.15801936f, 0.07860959f, 
    0.17203605f, 0.21619515f, 0.24141948f, 0.13908440f, -0.01679442f, -0.02516092f, 0.02310526f, 0.07913849f, 
    -0.09546934f, -0.05618114f, -0.14810205f, -0.12832277f, -0.07588147f, -0.10421345f, -0.07673351f, 0.01218100f, 
    0.08245913f, 0.02540517f, -0.04823085f, 0.05179872f, 0.01446014f, 0.15242454f, -0.08860084f, 0.07161483f, 
    0.04342787f, 0.21047820f, 0.17126098f, 0.19091724f, -0.06978105f, 0.22591327f, 0.01896369f, 0.17025819f, 
    -0.01433972f, 0.00733932f, -0.20802121f, -0.06793226f, 0.26709005f, 0.39664373f, 0.30154109f, 0.44909963f, 
    0.17564760f, 0.09876852f, 0.05806378f, 0.11971112f, 0.04923685f, -0.01777701f, -0.08032630f, 0.02477871f, 
    0.12397628f, -0.01399634f, 0.10702288f, 0.04800143f, 0.06486090f, 0.03325861f, -0.02757452f, 0.06016257f, 
    -0.17511110f, -0.05013015f, -0.07859418f, -0.05379669f, 0.05947292f, 0.12615627f, 0.03745164f, 0.09064254f, 
    0.06699220f, -0.05745221f, 0.06678069f, 0.09847216f, 0.11670799f, -0.08642389f, 0.01061397f, 0.00763094f, 
    0.14723344f, 0.30281311f, -0.02032590f, 0.16576037f, 0.08771349f, 0.00637703f, 0.07609832f, 0.02827843f, 
    -0.16181691f, 0.01269920f, -0.11517621f, 0.03690353f, 0.23018658f, 0.30901793f, 0.29553959f, 0.05662229f, 
    0.12815629f, 0.15907228f, 0.07796660f, 0.26025471f, 0.04475883f, -0.00938782f, -0.00730115f, 0.05109115f, 
    -0.06095136f, 0.07211348f, -0.07083908f, 0.12457857f, 0.04421761f, -0.10767572f, 0.04422950f, -0.15261385f, 
    -0.03055232f, -0.00440212f, 0.08887587f, 0.00061986f, 0.16960403f, -0.12959778f, -0.08157486f, -0.02207444f, 
    0.00676110f, -0.03096322f, -0.09692037f, -0.00637526f, 0.01325465f, 0.01867587f, -0.03005448f, -0.11963108f, 
    -0.51031327f, 0.15596001f, 0.20845547f, -0.14166069f, -0.01466925f, -0.08437836f, -0.01363982f, -0.01705558f, 
    0.05962855f, 0.02951882f, 0.01693624f, 0.08291334f, -0.26539892f, -0.17328233f, 0.47187361f, 0.25568303f, 
    -0.06953404f, 0.01902825f, 0.02557250f, 0.23111640f, 0.00587523f, 0.06844462f, -0.16978586f, -0.02647597f, 
    0.04740464f, -0.11896458f, -0.19835085f, 0.22957081f, 0.08571885f, -0.04043902f, -0.02610840f, 0.02642334f, 
    0.01044893f, -0.15868124f, 0.09586404f, -0.08738270f, -0.15454915f, 0.00968905f, 0.20573287f, 0.32603478f, 
    0.08071328f, -0.04757927f, -0.02022270f, 0.11942624f, 0.13459437f, 0.00367484f, -0.10944677f, 0.07173146f, 
    0.47788328f, -0.22064573f, 0.06209927f, 0.05379685f, 0.13127586f, 0.04338929f, -0.06377645f, 0.12458809f, 
    0.22513166f, -0.07480968f, 0.04336345f, 0.00980634f, 0.05790768f, -0.24076439f, 0.25339270f, 0.31487283f, 
    -0.09875532f, -0.11666314f, 0.00096351f, -0.08491445f, 0.12301612f, -0.14646225f, 0.23286578f, 0.06051162f, 
    0.10657670f, -0.07982703f, 0.19252773f, -0.24930263f, 0.07342036f, 0.00957144f, 0.03629275f, 0.08645345f, 
    0.04447714f, -0.00970555f, 0.21654440f, -0.09471621f, -0.09987000f, -0.27565610f, 0.00179167f, 0.21626180f, 
    0.04757051f, -0.05551507f, -0.00584660f, 0.01463894f, 0.07650251f, 0.05386208f, 0.04238326f, 0.03416453f, 
    -0.03836118f, 0.04330054f, 0.13954821f, -0.05356668f, 0.09607027f, 0.13641271f, 0.06586298f, 0.09191471f, 
    0.05535420f, 0.08340400f, -0.09055392f, 0.07294299f, 0.06175897f, 0.27622846f, 0.03383275f, -0.02954050f, 
    -0.00572652f, -0.03097665f, -0.03605177f, -0.11903854f, -0.02323875f, 0.18672138f, -0.04797015f, -0.02540549f, 
    -0.00952220f, -0.02026225f, 0.14476973f, 0.03176476f, -0.13331391f, -0.05449760f, -0.00889984f, 0.03255603f, 
    0.06450357f, -0.00199448f, -0.02214777f, -0.06896807f, -0.55970520f, 0.17760223f, 0.14125088f, -0.19972330f, 
    -0.08439976f, -0.06447036f, 0.13789392f, 0.06833737f, 0.11985086f, 0.06194238f, -0.01977523f, -0.11629610f, 
    -0.00387199f, 0.03888716f, 0.08370575f, -0.03220507f, 0.11044584f, -0.03166903f, -0.04030016f, -0.04974070f, 
    0.17185074f, -0.04437694f, -0.10826907f, -0.00779490f, 0.03340749f, -0.05098151f, 0.13710581f, -0.18571056f, 
    0.02580188f, 0.16398576f, -0.00014467f, 0.07379766f, 0.09560725f, 0.03422041f, -0.00472204f, 0.06440178f, 
    -0.34876591f, -0.35503608f, -0.12872447f, 0.13237305f, 0.00914774f, 0.12039533f, -0.09889108f, -0.02720773f, 
    0.12032469f, -0.20934357f, -0.02069736f, 0.08239548f, -0.24152011f, -0.05590985f, 0.18917713f, 0.13211890f, 
    -0.01731430f, 0.09109422f, 0.11611975f, -0.14455497f, -0.04591053f, -0.28387782f, 0.08777820f, -0.22678401f, 
    0.11538082f, 0.19003683f, 0.08384357f, 0.28906772f, -0.05590155f, 0.12448438f, -0.08182681f, 0.07845215f, 
    0.14251781f, 0.09031379f, 0.02462483f, -0.04310194f, 0.22657986f, -0.22324963f, 0.07154537f, 0.08338011f, 
    -0.18326689f, 0.04022061f, 0.05816092f, -0.01386103f, 0.12617810f, 0.14310639f, -0.00532983f, 0.03744162f, 
    -0.14358108f, -0.26917881f, 0.05489991f, 0.09418101f, -0.03093965f, -0.26969323f, 0.08738253f, 0.07110463f, 
    -0.04852047f, -0.00752342f, -0.02724032f, 0.19470216f, -0.08000743f, 0.11090557f, 0.04334278f, 0.03372064f, 
    0.07439780f, 0.04149170f, -0.05750711f, -0.09830122f, 0.02424428f, 0.09058350f, 0.07621375f, 0.18717420f, 
    -0.17229913f, -0.24035977f, -0.13059716f, -0.27046615f, -0.04269598f, 0.20008536f, 0.02435502f, -0.26822940f, 
    -0.30250016f, 0.01310668f, 0.06105606f, -0.07325114f, -0.34367660f, 0.08663787f, -0.14124306f, 0.12898140f, 
    -0.07965371f, -0.15448309f, 0.21131028f, -0.07673052f, -0.08581152f, 0.01974694f, -0.04803095f, -0.02109251f, 
    0.14228907f, -0.20041513f, 0.03522792f, -0.13796055f, 0.12269062f, -0.01072824f, 0.02269159f, 0.01359265f, 
    0.13591592f, -0.01625243f, -0.06074059f, 0.11371906f, 0.10324686f, 0.12403794f, 0.04726714f, 0.05910228f, 
    -0.14673342f, -0.06491700f, -0.02330996f, 0.09618276f, -0.10547788f, 0.05656734f, -0.06500497f, -0.12450375f, 
    -0.07137923f, 0.06242876f, 0.09903598f, -0.07851339f, 0.02392477f, 0.00379480f, 0.13120447f, -0.13368940f, 
    -0.12751558f, -0.08902106f, -0.17529809f, -0.30065486f, 0.02773943f, -0.01578557f, 0.13040711f, -0.03623936f, 
    -0.06462064f, 0.07784742f, 0.11067262f, 0.13213858f, 0.06072107f, 0.02036567f, 0.05843924f, 0.03729289f, 
    0.02675126f, 0.08563893f, 0.04945683f, 0.16173738f, -0.07890061f, 0.05566186f, 0.09052216f, -0.09538727f, 
    0.09984359f, 0.00439805f, 0.05857546f, 0.07566033f, 0.47934261f, 0.22307174f, -0.01347406f, 0.01812578f, 
    0.01003688f, 0.07178381f, 0.06490618f, -0.09139913f, 0.07210176f, -0.01100110f, -0.02646961f, 0.01942207f, 
    0.42553803f, 0.03158248f, 0.16928157f, 0.00653287f, -0.02209252f, -0.02236665f, 0.11910067f, 0.04154854f, 
    0.09639893f, 0.05480003f, 0.13996413f, -0.01991122f, 0.09085928f, 0.10856606f, -0.15949565f, 0.03276789f, 
    -0.14055791f, -0.00064864f, 0.04512861f, 0.06072711f, 0.10913432f, 0.06222844f, -0.02950844f, -0.20522849f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.04868707f, 0.11429264f, 0.05333557f, 0.00095249f, 0.00016853f, -0.00392261f, 0.05366041f, 0.20209239f, 
    0.09495193f, 0.01210482f, -0.03962404f, -0.16066496f, -0.01400104f, 0.07646102f, 0.14195885f, 0.10453176f, 
    -0.01393590f, -0.04484123f, 0.00264117f, 0.23895030f, 0.10252490f, 0.19862042f, 0.09835831f, 0.07888488f, 
    0.04295814f, -0.06430311f, 0.04404467f, -0.14246640f, 0.11838495f, 0.11558807f, 0.04278513f, 0.12685984f, 
    -0.05525326f, 0.02880972f, 0.01841175f, 0.00339906f, -0.08768953f, 0.02296880f, 0.10437226f, 0.18727334f, 
    0.07995274f, -0.04790264f, 0.21355022f, 0.24930903f, 0.25278199f, 0.13207753f, 0.21660376f, 0.05583448f, 
    0.07338638f, -0.07694866f, -0.00502558f, 0.06189672f, 0.12100002f, 0.13254137f, -0.00050214f, -0.07045094f, 
    -0.08121096f, -0.02210498f, 0.02789918f, 0.11718598f, 0.09863785f, -0.15032856f, 0.14512445f, -0.00096178f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.13207112f, 0.25756776f, -0.05228763f, -0.06365803f, 0.15127504f, 0.10214065f, -0.25755984f, 0.05459860f, 
    0.16998288f, 0.00278326f, 0.06916115f, -0.10404272f, -0.06333809f, -0.21529511f, 0.27805236f, -0.08611920f, 
    -0.32441893f, -0.14597456f, 0.09401154f, 0.08969478f, -0.24657232f, 0.02180553f, -0.06283539f, -0.16637047f, 
    -0.10422702f, -0.07022432f, -0.04188365f, -0.01037982f, 0.05156165f, 0.28723991f, 0.35614365f, 0.01829534f, 
    -0.18478122f, -0.06936605f, -0.05513130f, 0.13686140f, 0.15989496f, -0.08685419f, -0.27301440f, 0.15595286f, 
    -0.06957331f, -0.05054811f, 0.09263457f, -0.03146385f, -0.29667068f, -0.26012790f, 0.06827978f, 0.07262411f, 
    -0.30794653f, -0.05202244f, 0.02454232f, 0.13802399f, 0.07602604f, -0.08652980f, 0.00501007f, -0.40777144f, 
    -0.02164519f, 0.05194660f, 0.29580420f, 0.08093980f, 0.20801282f, 0.16816445f, 0.09847420f, -0.38762644f, 
    0.03959456f, 0.01176942f, -0.11845757f, 0.08422561f, 0.05822628f, 0.00399175f, -0.05743394f, 0.02319306f, 
    0.01928234f, -0.26302978f, -0.06214568f, 0.01138428f, 0.05494647f, -0.02752955f, 0.11308596f, 0.06839577f, 
    0.11022742f, -0.16722481f, -0.01967226f, 0.15466197f, -0.20733480f, 0.17128450f, -0.14624184f, 0.00558327f, 
    0.12160410f, -0.08521733f, -0.03739803f, 0.11939389f, 0.04066697f, -0.17289376f, 0.06573886f, -0.10836874f, 
    -0.14651586f, -0.03080263f, 0.08531160f, 0.05745401f, -0.06851060f, 0.03067780f, -0.04884356f, -0.03991730f, 
    0.01767997f, 0.03383440f, -0.27521655f, 0.02321254f, -0.12614301f, -0.19337004f, -0.00098312f, -0.12094255f, 
    -0.12689616f, -0.08823302f, -0.04303683f, 0.06455026f, -0.13462761f, -0.23787929f, -0.10558636f, -0.08971133f, 
    -0.02965455f, -0.01222782f, -0.08289779f, 0.09864514f, 0.17813176f, -0.09293628f, -0.14478171f, -0.06526103f, 
    0.08866355f, 0.07846709f, -0.07692149f, 0.02257860f, -0.06881867f, 0.02991235f, -0.30105856f, 0.10069972f, 
    -0.10132431f, 0.21994907f, -0.16998433f, -0.14660424f, -0.06973755f, -0.03161684f, 0.06041371f, 0.21596566f, 
    -0.13645540f, 0.00430437f, -0.06918072f, 0.04620739f, -0.27546740f, 0.00885433f, -0.12655783f, 0.17671208f, 
    -0.09758608f, -0.08295850f, -0.08128905f, 0.14337271f, 0.14792095f, 0.06270599f, 0.17591548f, 0.19209383f, 
    0.04782556f, 0.02707862f, 0.09646235f, -0.16508928f, -0.15219621f, 0.12239502f, -0.18537110f, -0.02638078f, 
    -0.04850743f, -0.10500760f, 0.02663961f, 0.03848011f, -0.12678327f, -0.15590839f, 0.10256995f, -0.13389406f, 
    -0.18744798f, -0.10595012f, 0.00240297f, -0.11101652f, 0.20862851f, -0.24252070f, 0.03594762f, 0.07073729f, 
    -0.03720447f, 0.01484636f, 0.14499448f, 0.08704730f, 0.03456302f, 0.21230938f, 0.12800381f, 0.00715972f, 
    -0.02264122f, -0.03886615f, 0.18848199f, 0.03003056f, 0.02858249f, 0.11210435f, 0.19225606f, -0.12034032f, 
    -0.08047608f, -0.22694688f, 0.01712989f, 0.35334876f, -0.07401678f, -0.04787200f, -0.08099809f, -0.27517545f, 
    0.25672799f, 0.18797308f, -0.10865331f, -0.08925155f, 0.09732966f, -0.02071866f, 0.39262620f, 0.11119057f, 
    0.04809431f, -0.02622948f, -0.05654676f, 0.16769069f, 0.00636113f, 0.07108892f, 0.25989529f, 0.07725579f, 
    0.19776656f, 0.12266866f, 0.07605548f, 0.09228448f, -0.03369748f, 0.08801690f, -0.19857003f, -0.31987101f, 
    -0.22962773f, -0.00467143f, 0.14962934f, -0.08519592f, -0.00972215f, -0.10191207f, 0.02473800f, -0.01052040f, 
    0.03388797f, -0.01794816f, 0.12877579f, 0.20674384f, -0.26558354f, 0.20198882f, -0.02800262f, 0.19445214f, 
    0.25196099f, -0.01804477f, -0.21154274f, -0.21390791f, -0.04625124f, 0.28218350f, 0.25359225f, -0.01283612f, 
    -0.04862271f, 0.04150357f, -0.04620984f, 0.03486112f, -0.04173844f, 0.04751360f, 0.06101049f, -0.04884813f, 
    0.11315195f, -0.05531681f, 0.21667974f, -0.13453890f, -0.10726404f, -0.16632561f, 0.09448473f, 0.20916209f, 
    -0.05790407f, 0.00266549f, 0.10991538f, -0.12750529f, 0.08733322f, 0.18839464f, 0.20993106f, -0.10969063f, 
    -0.12413019f, -0.11148246f, 0.09924446f, -0.05225756f, 0.20391013f, 0.08929548f, -0.28659263f, 0.00337191f, 
    0.04874714f, -0.06620391f, 0.12989648f, -0.05739662f, -0.24835196f, 0.08768566f, 0.01701691f, -0.15242772f, 
    -0.03031563f, -0.00875291f, 0.01915802f, 0.31813607f, 0.01042869f, -0.03411530f, -0.09693623f, 0.08703445f, 
    0.04806083f, -0.02256857f, -0.08487414f, 0.02459074f, 0.08324488f, 0.17937863f, -0.00420676f, -0.01946766f, 
    -0.02199736f, 0.08647147f, -0.11876763f, -0.06890000f, -0.21277061f, 0.08880164f, 0.25434032f, -0.11954744f, 
    -0.03482326f, 0.11666922f, 0.00408509f, 0.01567697f, 0.13725853f, 0.04433657f, -0.19631740f, 0.10918814f, 
    0.18898238f, -0.00477604f, -0.18474047f, -0.27736419f, -0.02125967f, -0.02478070f, 0.26124939f, -0.23257042f, 
    -0.21567933f, -0.18873985f, -0.10915519f, 0.02905056f, 0.21383730f, 0.13769947f, -0.18915240f, -0.01941775f, 
    0.09865370f, 0.02773926f, -0.01368155f, -0.10013233f, 0.08542638f, 0.28716791f, -0.27868581f, 0.04819320f, 
    0.16531849f, 0.00633914f, 0.27663094f, -0.12249811f, -0.23551947f, -0.05732295f, 0.00679008f, -0.17283255f, 
    0.06207908f, -0.10308143f, 0.28555721f, 0.14131893f, -0.02773926f, 0.20455565f, 0.18265383f, 0.14046885f, 
    0.19404268f, -0.03801791f, -0.01881233f, -0.29445109f, 0.09194826f, 0.02587757f, 0.03004040f, -0.03960275f, 
    0.18020929f, 0.08611824f, -0.23440491f, 0.05906728f, -0.15825698f, 0.01691491f, 0.15044653f, 0.00689001f, 
    0.04896727f, -0.11043189f, -0.05791312f, 0.01731798f, -0.01501899f, 0.11208135f, -0.17554386f, 0.27134535f, 
    0.08329464f, -0.22751017f, -0.06172467f, -0.20294808f, 0.10078466f, -0.16741152f, 0.23498356f, 0.08896428f, 
    0.08261757f, -0.03517270f, 0.06023817f, 0.08523981f, 0.12655154f, 0.11076137f, 0.25016671f, -0.01324783f, 
    0.08007243f, 0.05237257f, 0.09299255f, -0.05987263f, 0.14002423f, -0.07751898f, 0.09501228f, 0.14083789f, 
    0.00576429f, 0.12698257f, 0.13447513f, -0.33367679f, -0.38453072f, -0.08912227f, -0.03644879f, 0.07021493f, 
    0.09469803f, -0.09597565f, 0.14981656f, 0.29623148f, 0.26947585f, 0.06283964f, -0.01320215f, 0.06358577f, 
    0.07614934f, -0.11956644f, -0.11478233f, 0.00489684f, 0.08914483f, -0.16647828f, -0.06252518f, 0.09297750f, 
    0.19899555f, -0.02384631f, -0.17588244f, 0.14341505f, 0.17708968f, -0.04951381f, 0.35502148f, 0.11997704f, 
    0.09330321f, -0.04888579f, 0.12144818f, 0.09193495f, 0.31747112f, 0.05225829f, -0.01852587f, 0.19766402f, 
    0.27794963f, 0.13151768f, -0.15472348f, -0.14615190f, -0.06811693f, -0.40036923f, 0.06105231f, 0.03418940f, 
    -0.24153514f, 0.01698419f, -0.11203816f, 0.15056865f, -0.08811941f, 0.12045661f, -0.09658872f, -0.41305742f, 
    0.03046578f, -0.12631333f, -0.04335806f, 0.04338953f, 0.20800292f, 0.09832637f, 0.20132446f, 0.07072786f, 
    -0.26268843f, 0.11679079f, 0.12892666f, 0.11745880f, -0.02057946f, 0.08970407f, 0.10370164f, 0.08426140f, 
    0.16262949f, 0.11927820f, 0.08150822f, 0.26292962f, 0.17201298f, -0.52200556f, 0.20057732f, -0.08938995f, 
    -0.36347741f, 0.05610553f, 0.22367783f, 0.36565322f, 0.13105863f, 0.12580201f, 0.07197566f, -0.41592532f, 
    0.02017757f, -0.05734573f, 0.21193609f, 0.14960940f, 0.31879753f, -0.08985493f, -0.04239777f, -0.16258797f, 
    0.12451839f, -0.10786923f, -0.06864130f, -0.04494821f, 0.01668684f, -0.07597084f, -0.10180937f, -0.07546840f, 
    -0.06495712f, -0.16986266f, 0.07036139f, -0.05159023f, -0.08773951f, -0.06400551f, -0.03718759f, 0.01358114f, 
    -0.01529518f, -0.09086096f, -0.00690055f, -0.08365683f, -0.08317011f, 0.00863422f, -0.06985047f, -0.00270449f, 
    0.06570344f, -0.03336440f, -0.06130199f, -0.04993536f, -0.12248565f, -0.03166513f, -0.15210603f, 0.05029614f, 
    -0.19874908f, 0.00872597f, 0.10388810f, -0.11255069f, 0.05750863f, -0.03422354f, -0.09947894f, 0.08388811f, 
    -0.01324105f, 0.03877009f, -0.12409326f, 0.00201891f, -0.07566059f, -0.05722379f, -0.02763281f, 0.07183255f, 
    -0.01816691f, 0.03038048f, -0.08217163f, -0.06265765f, 0.04307427f, 0.03989452f, 0.07831956f, 0.00827494f, 
    -0.07275891f, 0.08537745f, 0.01217206f, -0.05605671f, 0.03569948f, -0.13187772f, -0.11789742f, -0.00990033f, 
    0.08877250f, -0.16875875f, 0.01942464f, -0.11499586f, -0.09328335f, 0.02524924f, 0.04776816f, -0.05013324f, 
    0.01751823f, 0.01441985f, 0.05701737f, -0.12635942f, 0.04082449f, -0.11587333f, -0.08435172f, -0.05030388f, 
    0.01037578f, 0.07033744f, 0.00298217f, -0.10932232f, -0.01417910f, -0.11305905f, -0.05720883f, 0.09773324f, 
    -0.06463803f, 0.02823219f, 0.07134795f, -0.12374021f, -0.03846489f, -0.04643655f, -0.00494618f, -0.04983882f, 
    -0.09466808f, -0.01381799f, 0.08048233f, -0.05248962f, 0.04908561f, 0.11478304f, -0.07910213f, -0.05845252f, 
    -0.12723064f, 0.04445696f, -0.08624358f, 0.08454264f, 0.02652197f, -0.01856635f, -0.14312319f, -0.07533980f, 
    0.08759835f, 0.04919747f, -0.03475135f, -0.08916011f, -0.03281889f, 0.07730328f, 0.11231357f, -0.00343186f, 
    -0.05740193f, -0.04897739f, -0.05162887f, -0.11047900f, 0.02624647f, 0.00735509f, 0.07295029f, 0.06845965f, 
    -0.09760764f, -0.04123699f, 0.49460331f, 0.11781502f, -0.18068783f, 0.05390199f, -0.08895295f, -0.06540239f, 
    -0.00155948f, -0.03178379f, 0.17425451f, 0.22861913f, 0.06519014f, 0.08883584f, -0.00607938f, 0.12242046f, 
    0.22240400f, 0.01287936f, 0.01365721f, 0.32328928f, -0.04368033f, 0.19728078f, -0.01078145f, 0.15366402f, 
    -0.11470649f, 0.00059343f, -0.12459854f, 0.23936586f, 0.00425451f, 0.13558614f, -0.09247626f, -0.17735301f, 
    0.10475842f, 0.00869929f, 0.30634525f, -0.02332683f, 0.00988421f, 0.04091998f, -0.25234437f, 0.24529196f, 
    -0.16408718f, 0.11084648f, -0.03348035f, -0.06553330f, -0.15549515f, 0.13762334f, 0.04178820f, 0.05824133f, 
    -0.02574374f, -0.12078837f, -0.14099690f, 0.24222742f, 0.11300173f, -0.09296343f, -0.00807828f, 0.07384666f, 
    0.27675638f, 0.02267041f, 0.20794016f, 0.26721570f, 0.42629072f, 0.16820413f, 0.14825389f, -0.08359107f, 
    -0.03169683f, 0.27488959f, 0.21553412f, 0.04124006f, 0.20199037f, 0.06864181f, -0.02993228f, -0.09451911f, 
    0.20532991f, 0.11275736f, 0.01349235f, 0.01578050f, 0.01841195f, 0.29318315f, 0.13953170f, -0.05347245f, 
    -0.09189214f, 0.07105075f, 0.03970910f, 0.20676191f, 0.08405297f, 0.06712165f, -0.20267391f, -0.11147164f, 
    -0.07298724f, 0.07377283f, -0.08493903f, -0.01780740f, -0.08277526f, 0.28906369f, 0.13849322f, -0.16270584f, 
    0.23738831f, -0.00621476f, 0.14823097f, -0.08446251f, -0.23206450f, 0.10812493f, -0.24099688f, 0.03390483f, 
    0.21936189f, -0.03179230f, -0.02709889f, -0.14049745f, -0.08154221f, 0.09419839f, -0.03905868f, 0.18317761f, 
    0.00859927f, -0.03055919f, -0.02653256f, -0.06736138f, 0.05510108f, 0.38764220f, 0.06899831f, -0.27036718f, 
    -0.19617453f, 0.00164432f, 0.06761131f, -0.05809572f, -0.10902070f, -0.05254147f, -0.00376677f, -0.57223225f, 
    0.09824769f, 0.01205220f, -0.12663969f, -0.09077165f, -0.04431310f, 0.03882901f, -0.10756490f, 0.07613056f, 
    -0.02001802f, -0.07466385f, -0.12390342f, 0.01473981f, -0.12509732f, -0.11664361f, 0.00944223f, -0.05639306f, 
    -0.04272934f, 0.04359173f, -0.09565857f, -0.06494739f, 0.01089241f, 0.05522922f, -0.14608178f, -0.06425049f, 
    -0.05023450f, -0.06915900f, -0.11314504f, 0.02688020f, -0.03376439f, 0.02536780f, 0.05543648f, -0.13923384f, 
    0.07275005f, 0.07283884f, -0.06324191f, -0.03798282f, 0.01149662f, -0.06582164f, -0.00323089f, -0.09551436f, 
    -0.11905747f, 0.04746151f, -0.00420468f, -0.02887522f, -0.12620077f, 0.08032840f, -0.11630756f, 0.03086837f, 
    -0.13156804f, 0.06865723f, -0.14520028f, -0.08309062f, 0.06981125f, -0.13227862f, -0.00314640f, 0.04032532f, 
    -0.00101238f, 0.09062403f, -0.12775801f, -0.10871194f, -0.11026588f, -0.11392667f, -0.16904411f, -0.11856506f, 
    0.06863098f, 0.16538987f, -0.05904900f, 0.03431218f, 0.32064697f, -0.03778421f, 0.37679428f, 0.09602842f, 
    0.12519222f, -0.09401406f, 0.23790853f, -0.18097918f, 0.01324815f, 0.03665480f, 0.11694143f, 0.17693888f, 
    -0.01468899f, -0.12896876f, 0.07792556f, -0.02450422f, 0.14983702f, -0.07659543f, 0.20551646f, -0.03554687f, 
    -0.11491130f, 0.00059338f, -0.02331433f, -0.16057110f, 0.30598533f, -0.24316183f, 0.01749758f, 0.08295650f, 
    -0.10289984f, -0.00401857f, 0.01845104f, -0.27236012f, 0.11985075f, 0.10111207f, 0.11085142f, -0.09871543f, 
    -0.11531650f, 0.01182467f, -0.04006917f, 0.02860768f, 0.03705429f, -0.14708999f, 0.20732351f, 0.03970443f, 
    -0.14885312f, -0.08063049f, 0.32894650f, -0.03162525f, 0.22240971f, 0.40140319f, -0.03545161f, 0.11585006f, 
    -0.12851651f, -0.08228491f, -0.12401395f, -0.11455747f, -0.14640316f, 0.15117498f, 0.32137159f, 0.05824613f, 
    -0.03193039f, -0.02609451f, -0.25223836f, -0.10318239f, -0.02538087f, -0.06773542f, 0.26069200f, 0.29305589f, 
    0.11361481f, 0.11336333f, 0.00622814f, -0.53130144f, 0.04281110f, -0.38327026f, -0.12905073f, 0.08139513f, 
    -0.39798152f, 0.00233224f, 0.00370501f, -0.04775066f, 0.08071647f, 0.06258918f, -0.00391124f, -0.29960433f, 
    0.05675571f, -0.12585214f, 0.07932630f, -0.23192145f, 0.16517808f, -0.06014985f, -0.02195795f, 0.18046330f, 
    -0.22789545f, 0.08613092f, -0.24380942f, 0.27871895f, 0.12394094f, 0.09457005f, 0.29597062f, -0.06571560f, 
    0.10691621f, -0.00675051f, 0.02829290f, 0.45280182f, 0.23402134f, 0.05173918f, 0.20027338f, -0.07061670f, 
    0.11744764f, -0.07822790f, 0.15490261f, -0.04770223f, 0.11740833f, 0.15430878f, 0.02036325f, -0.06448883f, 
    -0.50920784f, -0.11749430f, 0.00081089f, 0.13416430f, 0.07838534f, -0.27171335f, 0.00766659f, -0.01318619f, 
    -0.02348106f, 0.09173050f, -0.06023609f, 0.04696446f, 0.09499432f, 0.11309754f, -0.31887174f, 0.17739558f, 
    0.04146463f, 0.02309003f, -0.14021745f, -0.17618580f, 0.09640361f, -0.04435575f, 0.20417425f, -0.06441161f, 
    -0.09672713f, 0.18199313f, -0.04445620f, -0.07011999f, -0.12157917f, -0.15283716f, -0.01214144f, 0.07911040f, 
    -0.02996904f, 0.06443818f, 0.10625742f, 0.02877796f, -0.06166060f, 0.12581410f, -0.05532577f, 0.04208959f, 
    -0.09767056f, -0.07180790f, 0.01962799f, 0.08663418f, 0.02256327f, -0.11251851f, 0.26356152f, 0.16641629f, 
    0.07049319f, -0.12096201f, 0.17633818f, 0.10823660f, -0.19444625f, 0.17887416f, 0.00899932f, 0.02057129f, 
    0.19669726f, 0.02679209f, -0.21263297f, -0.54684043f, 0.17504922f, -0.48659858f, -0.01905625f, 0.20572950f, 
    0.00439969f, -0.06518365f, -0.04029969f, 0.15932721f, -0.03030264f, 0.06692261f, -0.23743562f, 0.27913284f, 
    -0.02631415f, -0.01354878f, 0.00199686f, -0.11204518f, -0.16484427f, 0.09515393f, -0.05463324f, 0.05283392f, 
    0.04303860f, 0.03499276f, 0.03784879f, 0.00057619f, 0.11420850f, 0.02964668f, -0.06649266f, -0.10963469f, 
    -0.10119371f, -0.09416025f, -0.01873237f, -0.08210171f, 0.04864565f, -0.14715576f, -0.01644192f, -0.16070169f, 
    -0.10267830f, -0.02846606f, -0.00486476f, 0.05616102f, -0.13922115f, 0.07196457f, 0.07665383f, -0.05855324f, 
    -0.08598997f, 0.03304642f, -0.00451907f, 0.05908479f, 0.09168567f, 0.06044957f, -0.15569484f, -0.12319079f, 
    0.01377152f, -0.08789566f, -0.06422481f, 0.07362889f, -0.10416077f, -0.08117446f, -0.02762617f, -0.01024173f, 
    -0.03025888f, 0.05510205f, -0.06843886f, 0.03512617f, -0.06400265f, 0.08325332f, -0.04485525f, -0.04719027f, 
    -0.02510216f, -0.01158222f, -0.03559820f, -0.04328707f, -0.07178994f, -0.06242340f, -0.02946511f, -0.11369336f, 
    -0.09291986f, 0.04024366f, 0.09138337f, -0.06270223f, 0.05799337f, -0.02881924f, 0.01783001f, 0.09773584f, 
    0.10296164f, 0.05735854f, -0.08009165f, -0.20416737f, -0.03071575f, 0.10176349f, 0.15026754f, -0.22246808f, 
    0.05569108f, -0.06101165f, 0.04106092f, -0.13204098f, 0.00195227f, -0.35562879f, 0.10948508f, 0.09275067f, 
    -0.04859850f, 0.04915017f, -0.03572800f, 0.16459101f, -0.15741901f, 0.01097503f, 0.00220573f, 0.01514134f, 
    -0.06904165f, 0.08662190f, 0.13683081f, 0.00446574f, -0.00530040f, -0.02998858f, 0.15204699f, -0.05693751f, 
    -0.15925366f, -0.03018984f, 0.26706111f, 0.06433450f, -0.20513284f, 0.25645533f, 0.09037990f, -0.09416657f, 
    0.12180825f, 0.10060753f, 0.05852427f, -0.44404611f, -0.01090145f, -0.09598664f, -0.03600224f, 0.34026697f, 
    0.23822819f, 0.02145956f, -0.36568582f, -0.12162206f, -0.26619318f, 0.25737289f, 0.13192429f, 0.29882941f, 
    -0.05461871f, -0.16450712f, -0.00158135f, 0.10703434f, -0.05151388f, 0.11027168f, -0.07296375f, -0.00511418f, 
    -0.12257907f, -0.16538166f, 0.00035386f, -0.02674644f, 0.08127843f, 0.07627711f, -0.03087592f, 0.00305554f, 
    -0.11136306f, -0.02109806f, -0.08855075f, 0.06284416f, 0.05434351f, -0.04733435f, 0.02609688f, 0.06477209f, 
    0.00432214f, 0.00583254f, 0.04073380f, -0.08195163f, -0.11870044f, 0.01168658f, 0.01275646f, -0.19718593f, 
    0.02623270f, -0.06172726f, -0.15174413f, -0.01211919f, 0.08284184f, -0.10553416f, -0.08882953f, -0.10821258f, 
    0.04175661f, 0.05435359f, -0.09435984f, -0.03024887f, -0.02637602f, 0.03743622f, -0.01499978f, -0.03637260f, 
    0.00926104f, 0.05445653f, 0.05229935f, 0.00940069f, 0.01766528f, 0.04266654f, 0.08044271f, -0.09763636f, 
    -0.03875516f, -0.04098412f, 0.03117884f, -0.14150299f, 0.00401799f, -0.01509698f, -0.05267248f, -0.07890007f, 
    0.03836074f, -0.08183686f, -0.06123042f, 0.05839634f, -0.03085652f, -0.10965943f, -0.02750770f, -0.12869790f, 
    -0.04285258f, -0.06585540f, -0.01392114f, -0.07756698f, 0.00659183f, 0.08113433f, -0.12271287f, -0.06446550f, 
    -0.03777073f, 0.02584038f, 0.04477490f, 0.11024868f, 0.02024605f, 0.04815874f, -0.12319973f, -0.11345273f, 
    -0.10220100f, 0.00265115f, -0.04911086f, -0.12966755f, 0.05886308f, 0.11222632f, 0.09288710f, 0.00685834f, 
    -0.07754222f, 0.07673605f, -0.04735890f, -0.03801078f, 0.04999395f, -0.05047339f, 0.02430408f, -0.05546713f, 
    -0.08470105f, -0.11411706f, -0.10948946f, 0.04273780f, -0.07169227f, -0.09495031f, 0.05645048f, 0.09169874f, 
    -0.10223142f, -0.04977351f, -0.03803961f, -0.06486579f, -0.06052657f, -0.12826604f, 0.04091756f, -0.12992084f, 
    0.05908455f, 0.03184272f, 0.10395731f, 0.01065131f, -0.03555550f, 0.04230031f, 0.00623975f, -0.09690987f, 
    0.02474558f, 0.12543269f, -0.18551907f, 0.00711564f, 0.06630315f, -0.08669605f, 0.08798946f, 0.04015961f, 
    0.23423803f, 0.23425728f, 0.17082247f, -0.01203080f, -0.09579518f, 0.16735482f, 0.15849683f, -0.28490123f, 
    -0.02799451f, -0.26378351f, 0.06339969f, -0.04332932f, 0.21161053f, 0.03350306f, -0.23254679f, -0.02902493f, 
    0.07093035f, 0.00944716f, 0.08286789f, -0.19291981f, 0.20260532f, 0.19738381f, -0.26085910f, -0.15691042f, 
    -0.07676899f, 0.00079597f, 0.03316104f, -0.10398772f, 0.24431880f, -0.03141695f, 0.21327356f, -0.24881466f, 
    0.23444928f, 0.01049919f, -0.01164537f, -0.09542058f, -0.16036275f, -0.11871904f, 0.12548067f, 0.11253275f, 
    -0.14366859f, -0.03830155f, 0.26453438f, -0.08623674f, 0.09810758f, 0.19655263f, 0.02308061f, 0.01177958f, 
    -0.07408001f, 0.04713566f, 0.03377578f, 0.03322415f, -0.04519241f, -0.05845494f, -0.25184497f, -0.13774285f, 
    0.02759388f, 0.11035574f, 0.18038157f, -0.11850607f, -0.01036172f, -0.03808027f, -0.43968323f, 0.29533875f, 
    0.22807094f, -0.12577328f, 0.02191726f, -0.24032758f, 0.08108032f, 0.08666039f, 0.39826909f, 0.02073568f, 
    0.13888651f, -0.03245604f, 0.03332543f, 0.04436507f, -0.05464715f, 0.11266942f, -0.17616884f, 0.30582213f, 
    0.03052248f, 0.06855025f, 0.03076894f, 0.14260975f, 0.10527526f, 0.32909480f, 0.14874013f, -0.19723086f, 
    -0.08221446f, -0.09622978f, 0.21902217f, -0.27864689f, -0.22167517f, 0.08438621f, 0.01814402f, 0.18262286f, 
    0.05701147f, 0.01245671f, 0.15493166f, -0.04661603f, -0.26283845f, -0.02656199f, 0.21318811f, 0.28968963f, 
    0.02741021f, 0.08355004f, -0.15097304f, -0.06876879f, 0.10640640f, -0.25240898f, -0.06886893f, 0.17253086f, 
    0.28791049f, 0.06797631f, 0.24588861f, 0.10062458f, 0.27577281f, 0.09745264f, -0.03514474f, -0.01503910f, 
    -0.09247461f, -0.07558492f, 0.03311046f, -0.00701668f, 0.13122886f, 0.00204392f, 0.35488239f, -0.12788828f, 
    -0.10296778f, -0.03715485f, 0.04758351f, -0.03602206f, -0.03686551f, -0.07867717f, -0.04530357f, 0.13424610f, 
    0.05949291f, 0.07962795f, 0.10845355f, 0.33246773f, 0.11673675f, -0.02733169f, 0.26463443f, -0.08730319f, 
    0.04366735f, 0.00715475f, -0.04489921f, 0.06994398f, 0.01865634f, -0.07590246f, -0.03099148f, 0.04246058f, 
    -0.09575330f, 0.06844906f, 0.02107652f, -0.30199727f, -0.16809119f, -0.06498710f, 0.16254143f, 0.19260161f, 
    0.12370928f, 0.08592314f, 0.06923439f, 0.27132794f, 0.07036398f, -0.24894364f, 0.09959072f, -0.03414822f, 
    -0.23950492f, 0.04249732f, 0.04400079f, 0.13556063f, 0.20919876f, 0.47098443f, 0.01527413f, -0.05048354f, 
    -0.07604820f, -0.06380502f, -0.15473162f, 0.08352287f, -0.10210461f, 0.09809026f, 0.36701047f, -0.00996494f, 
    0.00798844f, 0.10398257f, 0.25290886f, -0.00812085f, 0.13339339f, -0.01574552f, -0.07975517f, -0.15780926f, 
    0.11922322f, 0.07138611f, 0.13256629f, 0.40810749f, 0.06828639f, 0.26083311f, -0.10643777f, -0.07776566f, 
    0.13706973f, 0.02765308f, 0.08747907f, 0.16790459f, 0.14004803f, 0.10078731f, -0.08080029f, 0.02269334f, 
    -0.07597212f, -0.00226232f, -0.11646450f, 0.10854141f, -0.02306225f, 0.05558698f, 0.10080559f, -0.19006753f, 
    0.07928915f, -0.04917347f, 0.22097345f, -0.12945846f, -0.02478578f, -0.02725588f, -0.26408732f, -0.11541580f, 
    0.17213175f, 0.09691705f, 0.03080939f, -0.19197634f, -0.11135814f, -0.00460069f, -0.07276708f, 0.11006955f, 
    -0.23628515f, -0.02304924f, 0.20379081f, 0.02768395f, -0.04472084f, 0.35088643f, 0.12873560f, -0.17190078f, 
    -0.05714944f, 0.02108155f, 0.03315697f, 0.06782398f, -0.08871149f, 0.18405469f, 0.19610812f, -0.27623123f, 
    -0.08664742f, 0.24685980f, 0.00102682f, 0.04691001f, -0.06879687f, -0.10482557f, 0.34189883f, -0.14829150f, 
    0.16664779f, 0.24557900f, 0.31863549f, 0.13959000f, -0.05915862f, 0.19857331f, -0.13210650f, 0.05151579f, 
    0.05259044f, 0.12963298f, -0.04718707f, -0.05025032f, -0.00536910f, -0.13737006f, -0.10990942f, 0.03425889f, 
    -0.09221248f, 0.09245116f, 0.10852757f, -0.09658342f, -0.17197949f, 0.01300297f, 0.14931086f, -0.31367680f, 
    0.09383404f, -0.07033044f, -0.09243685f, 0.15331860f, 0.31160241f, 0.06020318f, -0.17589082f, 0.21353450f, 
    0.06621385f, 0.04927832f, -0.21160904f, -0.34449726f, -0.03011166f, 0.12837829f, -0.08009727f, 0.33858222f, 
    0.01269066f, 0.00472290f, 0.15300727f, -0.02665268f, 0.04862407f, 0.32756928f, -0.09399898f, -0.08786338f, 
    -0.21836734f, -0.11194303f, 0.17997438f, -0.20857543f, 0.13021876f, -0.00310028f, 0.01559482f, -0.15040755f, 
    -0.03989463f, 0.19589373f, 0.15822102f, 0.07713322f, -0.09002119f, 0.08886871f, -0.03572534f, 0.14738879f, 
    -0.01830342f, 0.23450585f, 0.22487803f, -0.25056028f, -0.02947564f, 0.30419195f, -0.05836541f, 0.10495820f, 
    -0.28239733f, -0.01221387f, -0.04403976f, 0.20476544f, 0.00592244f, -0.15722087f, -0.23841321f, 0.04622097f, 
    0.02543043f, 0.03402118f, -0.01466858f, -0.22009510f, -0.03555449f, 0.09561146f, -0.24611023f, -0.32501876f, 
    -0.14358555f, 0.11562173f, -0.10140271f, 0.19693626f, 0.18511254f, 0.02005648f, 0.10199028f, 0.16678834f, 
    0.05595464f, 0.02406155f, 0.01959931f, 0.05012948f, 0.15604439f, 0.14076105f, 0.19062467f, 0.29299727f, 
    0.00911054f, -0.08531082f, -0.06963306f, -0.15748616f, 0.23553534f, 0.05285024f, -0.06437263f, 0.05169726f, 
    -0.15197258f, -0.05588517f, -0.07750320f, 0.12359516f, 0.00462986f, -0.17819086f, -0.01647172f, 0.03017188f, 
    -0.02867031f, 0.13808964f, 0.01232568f, -0.06191703f, -0.30056143f, -0.09909291f, -0.15470360f, -0.08366302f, 
    0.04806476f, -0.21595530f, 0.15464485f, 0.03656083f, -0.11658450f, 0.01844517f, 0.31275293f, 0.08316439f, 
    0.04437610f, 0.08756315f, -0.00087155f, -0.04873277f, 0.05540306f, 0.15578468f, 0.11823194f, 0.16646145f, 
    -0.06533521f, -0.04203546f, -0.08781874f, 0.04274760f, 0.03107401f, 0.17718288f, 0.10534213f, -0.00853693f, 
    0.12212605f, -0.02128227f, 0.09496938f, -0.22236994f, -0.08406506f, 0.10270539f, -0.08629744f, 0.08579160f, 
    -0.02508425f, 0.01462844f, 0.02346584f, -0.02671334f, 0.14404111f, 0.23294687f, 0.04200663f, 0.31232107f, 
    0.07647672f, 0.04294812f, -0.15608284f, -0.10379693f, -0.14175387f, -0.10429183f, 0.01323587f, 0.04279630f, 
    0.25754303f, -0.11253601f, 0.06920286f, 0.11269540f, 0.18073760f, 0.05948908f, 0.16116948f, 0.27049762f, 
    -0.06717627f, 0.00274749f, -0.27321041f, -0.07026387f, 0.13890342f, 0.00423012f, -0.17654188f, -0.00039170f, 
    0.14626069f, -0.02455266f, 0.24247667f, 0.09150412f, 0.09557378f, -0.06853624f, 0.24138916f, -0.20646073f, 
    0.01248960f, -0.11010231f, 0.02795731f, -0.15753108f, 0.16493692f, 0.06415387f, -0.30110303f, 0.04201302f, 
    -0.09921351f, -0.01554122f, -0.10286292f, -0.02285240f, 0.24310012f, 0.20862380f, 0.07899513f, -0.14901739f, 
    0.25889918f, -0.01250563f, 0.16209845f, -0.01896925f, 0.15873820f, -0.11447670f, -0.11010802f, -0.16060255f, 
    0.07646513f, 0.01389299f, 0.06816384f, 0.01021183f, -0.43207175f, -0.04748953f, -0.13418393f, 0.05017795f, 
    0.01487979f, 0.11830631f, 0.19907182f, 0.07808418f, 0.12874644f, -0.41326511f, -0.06618610f, 0.04129513f, 
    -0.01162335f, -0.03200413f, 0.34256506f, 0.22695228f, 0.23320226f, -0.00282738f, -0.29570350f, 0.13355063f, 
    -0.07373587f, 0.00894215f, -0.15019822f, -0.07414699f, 0.16032037f, 0.04980691f, 0.02586169f, 0.20848829f, 
    -0.08444040f, -0.08310161f, -0.03982294f, -0.04614790f, -0.09188405f, 0.15798599f, 0.12628913f, 0.02740679f, 
    0.11849854f, -0.04586197f, -0.06253455f, 0.03292089f, 0.02430659f, -0.03019345f, -0.02315018f, 0.01768883f, 
    -0.08564091f, -0.03326209f, 0.09014316f, -0.10543415f, 0.12014983f, 0.01701858f, 0.27288601f, 0.13634937f, 
    -0.06497415f, 0.08822475f, -0.11210620f, -0.01411134f, 0.16279727f, -0.11655063f, 0.17148283f, -0.09223206f, 
    0.02107101f, 0.03287543f, 0.09957105f, -0.37213248f, -0.15431444f, -0.13123789f, 0.18406230f, -0.00951363f, 
    0.09884114f, 0.09116077f, 0.10778656f, 0.05346920f, 0.03770800f, -0.01764913f, 0.08125290f, 0.00979256f, 
    -0.12447502f, 0.07384326f, 0.16533169f, -0.01361420f, 0.06923448f, 0.13753335f, 0.09365915f, -0.03776135f, 
    -0.08199927f, 0.11954075f, 0.21170326f, 0.11989264f, 0.02827719f, -0.08129396f, -0.14650691f, 0.02777810f, 
    0.26993817f, 0.17873593f, 0.10127281f, -0.19015934f, 0.01693262f, 0.04816611f, 0.07668449f, -0.35321751f, 
    -0.21909772f, -0.07044504f, -0.03488003f, -0.10497596f, 0.15784982f, 0.11822890f, -0.26054859f, 0.17485309f, 
    0.10212503f, -0.09684757f, -0.05416158f, -0.00822513f, -0.04820487f, 0.15348418f, -0.13366112f, -0.35299432f, 
    -0.06724238f, 0.07376328f, 0.04538669f, 0.33429536f, 0.21632808f, -0.10167753f, 0.15246978f, -0.06611484f, 
    0.22098032f, 0.02160451f, -0.00579753f, -0.32637319f, -0.43170348f, 0.10583653f, -0.00991916f, 0.15651354f, 
    0.03234924f, 0.04087190f, 0.00905171f, -0.13694212f, 0.04203507f, -0.19395164f, 0.11828390f, -0.06371402f, 
    -0.21029557f, -0.06794168f, 0.28437069f, -0.03380977f, -0.09586080f, -0.01626000f, -0.46999729f, -0.12913029f, 
    -0.09476031f, -0.00713554f, -0.03564725f, 0.08293204f, 0.10392162f, 0.02515244f, 0.19863394f, 0.11220403f, 
    -0.05107578f, -0.06136109f, -0.03847178f, 0.40738794f, -0.08949272f, -0.40248233f, -0.12595756f, -0.05666190f, 
    0.17006767f, 0.21065691f, 0.10674219f, 0.06344849f, -0.09359868f, 0.15293752f, 0.26708794f, -0.21478774f, 
    0.02176952f, -0.05908967f, -0.02688921f, 0.07230082f, -0.08673407f, -0.00740782f, 0.31676379f, 0.03938092f, 
    0.05250566f, 0.02140080f, -0.02938884f, 0.31728077f, 0.23435621f, 0.07683618f, -0.11607133f, 0.01551127f, 
    -0.21384825f, -0.08342490f, -0.07309072f, -0.06465637f, 0.23053701f, -0.03651735f, 0.01672771f, -0.25808239f, 
    0.00390716f, -0.04046164f, 0.16536756f, 0.17467324f, -0.18342021f, 0.00600041f, 0.06135046f, 0.03182305f, 
    -0.06697086f, -0.05777023f, 0.18096253f, -0.07091210f, 0.32471660f, 0.06275044f, -0.12121449f, 0.03531643f, 
    0.11673820f, 0.05063062f, 0.41480568f, 0.01958205f, 0.08168203f, -0.08783866f, -0.18612933f, 0.05864881f, 
    0.03852055f, 0.05542788f, -0.14778201f, -0.26659697f, -0.11481945f, 0.35443795f, 0.22748373f, -0.15381786f, 
    0.01275900f, 0.00862180f, 0.04871657f, 0.45973155f, 0.17669202f, 0.30007717f, 0.24808712f, 0.08026640f, 
    0.07758362f, 0.09288527f, 0.03562717f, -0.05885480f, 0.14415233f, 0.25224999f, -0.02339296f, 0.08414150f, 
    -0.02821793f, -0.00466739f, 0.07269382f, -0.09430111f, -0.25496441f, -0.12428424f, -0.13183998f, -0.02433610f, 
    0.12181512f, 0.11362500f, 0.12899545f, -0.07264209f, 0.31634864f, -0.14990628f, 0.02793936f, 0.06898341f, 
    -0.13296129f, -0.05018654f, -0.02865345f, 0.31339848f, -0.04251739f, 0.26316795f, -0.08391229f, -0.21031687f, 
    0.19391231f, 0.00181228f, 0.13140275f, 0.05704431f, 0.14535494f, -0.07643406f, 0.34626088f, -0.21503566f, 
    -0.03974275f, -0.07376477f, 0.09448496f, 0.11683863f, -0.05855808f, -0.06848368f, -0.09453197f, -0.10967374f, 
    -0.09319395f, -0.09736736f, -0.04285756f, -0.01707406f, 0.04471563f, 0.02802071f, -0.12109917f, -0.04230230f, 
    -0.10215944f, 0.03425652f, 0.12494327f, 0.01299901f, -0.11514714f, -0.12314838f, 0.06240882f, 0.03040048f, 
    0.02186723f, -0.10896343f, 0.01911728f, -0.10428715f, -0.09209456f, 0.01967397f, 0.00499502f, -0.00738306f, 
    0.01560749f, -0.08249038f, -0.04080246f, 0.04326305f, -0.04587081f, -0.10568592f, -0.06295621f, -0.07209083f, 
    -0.12204877f, 0.07805851f, -0.12374157f, -0.11444896f, -0.00578147f, 0.00999211f, -0.01246735f, 0.00424315f, 
    -0.01088311f, 0.04470406f, 0.08952618f, -0.06629513f, -0.07890384f, -0.09271759f, 0.07195319f, -0.02822529f, 
    -0.06901851f, -0.11980215f, -0.01323965f, -0.02007110f, 0.04316823f, -0.01945314f, 0.08604380f, 0.03904790f, 
    -0.10997560f, -0.02760257f, 0.42389730f, -0.06754106f, -0.17602804f, -0.03561242f, -0.15339513f, -0.04388353f, 
    -0.09952573f, 0.18418682f, 0.02673040f, -0.01624786f, 0.01204982f, 0.24428841f, -0.00735261f, 0.05449277f, 
    0.12707049f, 0.25114286f, 0.09014294f, 0.00965708f, 0.06645079f, -0.19635303f, -0.06055184f, 0.33051744f, 
    -0.12764849f, 0.09924588f, -0.00350015f, 0.37065342f, -0.18422411f, 0.24145819f, -0.14754517f, -0.03118013f, 
    0.17626260f, -0.03270981f, 0.20911391f, 0.10605359f, 0.17996635f, 0.08789227f, 0.07576233f, 0.12383430f, 
    -0.12390906f, -0.11738145f, 0.23710756f, -0.09181461f, -0.16000018f, 0.31247336f, 0.01188789f, 0.12558357f, 
    0.17968495f, 0.02624516f, -0.04171821f, -0.11054447f, 0.08387994f, -0.20333129f, -0.06639200f, 0.14989007f, 
    0.26711997f, 0.07424255f, 0.23197892f, 0.18962787f, 0.27441099f, 0.09079575f, -0.14068170f, -0.00130581f, 
    -0.11054967f, 0.16665636f, 0.22872812f, 0.00023216f, -0.02641785f, -0.06310977f, 0.37980327f, -0.10204077f, 
    0.09965747f, 0.23002112f, -0.02177541f, -0.13996232f, 0.09567856f, 0.20458607f, -0.15331599f, -0.02083526f, 
    -0.12083936f, 0.12211053f, -0.12106346f, 0.33204293f, 0.20362751f, -0.08390940f, 0.23269670f, -0.03022510f, 
    -0.05131912f, 0.01493812f, -0.03998980f, -0.03986131f, -0.15183386f, -0.07040529f, -0.47446322f, -0.30728725f, 
    -0.25801125f, -0.02114367f, 0.04985932f, 0.00804564f, 0.13493019f, -0.01687667f, 0.29512221f, 0.14199284f, 
    -0.06959230f, -0.08395415f, 0.21553062f, 0.22560793f, 0.17348063f, 0.10636631f, 0.09677705f, 0.08160915f, 
    -0.02309681f, -0.12900938f, 0.05274772f, 0.02015215f, -0.05453011f, 0.49235213f, 0.08631422f, -0.11407649f, 
    -0.02109698f, 0.11900154f, -0.18153268f, -0.03522423f, -0.10499513f, 0.14489768f, 0.11418081f, -0.16100539f, 
    -0.07062827f, 0.11135907f, -0.10066072f, -0.07180940f, -0.14083785f, 0.00668648f, -0.06109269f, -0.08332577f, 
    -0.12057976f, -0.09083012f, 0.26840162f, 0.33598617f, -0.11964022f, 0.16274841f, 0.01048225f, 0.11986233f, 
    0.37737495f, -0.02426327f, -0.11331444f, -0.17639308f, 0.01693932f, 0.04557830f, -0.22538191f, 0.27937484f, 
    -0.07300596f, 0.05878941f, 0.07329947f, 0.28046587f, 0.18942080f, -0.00379027f, -0.10293843f, -0.02366271f, 
    0.18872181f, 0.01892054f, 0.10749806f, -0.33047530f, 0.11180788f, -0.03306768f, -0.19272089f, -0.25125313f, 
    -0.08942216f, -0.11700064f, -0.18744759f, -0.16583745f, -0.23422590f, 0.12296062f, -0.04609674f, 0.31386423f, 
    0.09518682f, 0.01903263f, 0.09788460f, -0.02219785f, -0.02285190f, -0.19071704f, -0.01172266f, 0.01903981f, 
    0.15518704f, -0.07088513f, 0.27986497f, 0.14635235f, 0.08397226f, 0.39133745f, 0.07787696f, 0.04311807f, 
    -0.07604454f, -0.07072777f, -0.22535387f, -0.01459091f, 0.11913788f, 0.03073213f, -0.05415163f, 0.17115676f, 
    0.09545927f, -0.11046079f, 0.21274632f, -0.01372410f, 0.04456042f, -0.15767081f, 0.17446372f, 0.15273468f, 
    0.06980783f, -0.33255354f, 0.02440735f, -0.04079659f, 0.12226366f, -0.08837581f, -0.24885553f, -0.07621320f, 
    0.07584866f, -0.00582781f, -0.08133390f, -0.00500553f, 0.32345414f, -0.02986431f, -0.29891843f, 0.17702970f, 
    0.08148951f, -0.00307447f, 0.06353258f, -0.03164471f, 0.19563286f, -0.06105813f, 0.14665215f, -0.26410395f, 
    -0.14767933f, 0.06060454f, -0.01658968f, -0.02121798f, -0.45902216f, 0.05349940f, -0.03448772f, 0.23429324f, 
    0.07060938f, -0.03849790f, 0.27145252f, -0.01147296f, 0.07433805f, -0.11723662f, 0.03288747f, 0.17055118f, 
    -0.36020461f, -0.01715560f, 0.16232651f, 0.12950189f, -0.06718513f, 0.02546053f, -0.14269879f, -0.02095320f, 
    0.07258514f, -0.00003358f, -0.03553112f, 0.03964524f, -0.11364477f, -0.06144128f, -0.50436491f, 0.07138906f, 
    0.13091250f, -0.09946167f, -0.15838701f, -0.08356806f, -0.02240974f, 0.30855039f, 0.27872685f, 0.08461376f, 
    0.09283469f, -0.19298409f, 0.06847187f, 0.26659673f, 0.05240985f, 0.33804128f, -0.13349807f, 0.20156628f, 
    -0.04643260f, 0.11394482f, 0.10498683f, 0.11197298f, 0.21271271f, 0.36343300f, 0.03140944f, -0.02027454f, 
    0.21046327f, 0.00334768f, 0.27302122f, -0.22000201f, -0.45261472f, -0.11954939f, -0.28795546f, -0.04197716f, 
    0.18585964f, -0.00701389f, 0.03780024f, 0.12158117f, -0.05792075f, 0.03125801f, -0.11675818f, 0.30073816f, 
    -0.01936576f, 0.00674462f, -0.05216065f, 0.21691620f, -0.00388499f, -0.03196490f, 0.08071464f, -0.11604322f, 
    0.04576375f, -0.09819711f, 0.31314746f, 0.24392080f, 0.06578019f, -0.05906187f, 0.13540734f, 0.00796167f, 
    0.00100775f, 0.03025059f, -0.01345084f, 0.08262329f, 0.02272758f, 0.09888978f, -0.01128543f, -0.03272066f, 
    -0.06878842f, -0.07303803f, -0.13559654f, -0.02931750f, 0.00480007f, 0.00608453f, 0.08981507f, -0.12514901f, 
    -0.02473717f, -0.07689723f, 0.03393307f, 0.00964535f, 0.06229141f, 0.01988247f, 0.08653247f, -0.04698383f, 
    0.07981046f, -0.11785571f, 0.09840818f, -0.01493246f, -0.06502563f, -0.01143522f, 0.02967075f, -0.09969760f, 
    -0.06188412f, -0.05944729f, -0.08661263f, -0.10176879f, -0.07450696f, -0.03851317f, 0.02256805f, -0.16276389f, 
    0.06108379f, -0.10654962f, -0.05337185f, -0.19427975f, -0.02631510f, -0.03756230f, -0.05952764f, -0.11382295f, 
    -0.17055951f, -0.09954791f, -0.11285822f, -0.11605738f, -0.06080260f, -0.13361134f, -0.12415811f, -0.09398950f, 
    0.10851903f, -0.03733848f, -0.02083453f, 0.01441248f, -0.07621879f, 0.01299875f, -0.07171776f, -0.12533003f, 
    -0.00425569f, -0.05937003f, 0.00095231f, 0.08053620f, -0.02962785f, 0.09203610f, -0.07550128f, -0.10729305f, 
    -0.07159712f, -0.10051002f, -0.01041200f, 0.01293610f, 0.11847094f, 0.08431924f, 0.06325417f, -0.05496261f, 
    -0.09396721f, -0.10527857f, 0.06081688f, -0.02452448f, 0.08531196f, -0.10772898f, -0.01888352f, 0.06938807f, 
    -0.10577251f, 0.09663308f, -0.03158525f, -0.08432232f, -0.05204609f, 0.05002068f, -0.02354101f, -0.02757416f, 
    0.05447892f, 0.05483723f, 0.06124397f, 0.09384999f, 0.01359188f, 0.02650388f, 0.02149753f, -0.03237438f, 
    -0.07542610f, -0.08360200f, -0.04241643f, -0.07790244f, 0.06004345f, -0.08013731f, -0.11876890f, 0.05636023f, 
    -0.09417600f, 0.03812024f, -0.08127803f, 0.10567559f, -0.14281963f, 0.00666615f, -0.03199969f, 0.03229518f, 
    0.02393017f, 0.08827585f, -0.02188789f, -0.17124571f, -0.14441293f, -0.02499880f, -0.13514078f, -0.00234721f, 
    0.00624578f, 0.06440001f, 0.36329877f, 0.05341980f, -0.22671637f, 0.01618739f, -0.10517514f, -0.06426433f, 
    -0.07682516f, -0.18133335f, 0.18898819f, -0.11518314f, -0.01520140f, 0.20359987f, -0.05615466f, 0.15827437f, 
    -0.07171570f, 0.09854705f, -0.06480481f, 0.03414744f, -0.09260349f, -0.20904307f, 0.04863244f, 0.39116311f, 
    0.12120234f, -0.03058772f, -0.05102130f, 0.36994961f, 0.07559406f, 0.02369691f, 0.03344662f, -0.16184141f, 
    0.05453240f, 0.14589763f, 0.24557503f, -0.08003047f, 0.11010934f, -0.00622826f, 0.13107267f, 0.15175712f, 
    -0.04000168f, -0.10457984f, 0.11729353f, -0.05399083f, 0.04455848f, 0.39365077f, 0.20058890f, 0.23216188f, 
    0.10059740f, 0.03357590f, 0.06167136f, -0.24507095f, -0.03091151f, -0.22047870f, -0.06572092f, 0.35748556f, 
    0.29106444f, 0.07090479f, -0.00459619f, 0.21201070f, 0.05271597f, 0.23127477f, 0.00304183f, 0.23807986f, 
    0.12195046f, -0.10193288f, 0.16624513f, -0.05384054f, 0.00298080f, -0.08838790f, 0.15055472f, -0.03434050f, 
    -0.03014527f, 0.21055229f, -0.10858936f, 0.27487022f, -0.02973362f, 0.18157500f, -0.18750444f, -0.16657509f, 
    0.12192117f, 0.25673422f, -0.03673011f, 0.17072481f, 0.08922548f, -0.29910368f, 0.15425178f, -0.06943746f, 
    0.03240625f, 0.10550012f, 0.04276048f, 0.13630947f, -0.25461006f, -0.23639035f, 0.08029427f, -0.14822680f, 
    -0.16962086f, -0.01077885f, -0.21001151f, 0.48748234f, 0.20920104f, -0.06527901f, 0.21526733f, -0.08934765f, 
    -0.15458745f, -0.00262755f, 0.23591146f, 0.09464969f, 0.25332245f, 0.17595886f, 0.12265364f, -0.26868987f, 
    0.23784333f, -0.03846061f, 0.14489947f, 0.12710214f, -0.03672133f, 0.23160206f, -0.04302482f, 0.21771371f, 
    0.06475223f, 0.05509217f, -0.16125521f, -0.24876229f, -0.09577930f, 0.20914310f, 0.02171568f, 0.06798778f, 
    -0.00647189f, 0.03111226f, -0.02505690f, -0.04651883f, -0.07482250f, -0.06382299f, 0.22233000f, -0.17758243f, 
    0.16122037f, 0.03406923f, 0.15153682f, -0.18488552f, 0.04132207f, 0.14296280f, 0.19556040f, 0.04855944f, 
    0.17059651f, 0.11734971f, -0.02449283f, 0.13891782f, 0.09030005f, 0.29396099f, 0.38086164f, 0.07156383f, 
    -0.02051646f, -0.08229548f, 0.06872329f, 0.01337759f, -0.10830251f, 0.08821411f, 0.04814973f, -0.03041216f, 
    -0.03701363f, -0.00168840f, -0.22961028f, 0.21146938f, -0.04283978f, 0.02031434f, -0.09402470f, 0.16750379f, 
    -0.10050833f, -0.12158784f, -0.29008773f, 0.00566315f, 0.54185802f, 0.14851794f, -0.04845637f, 0.17541578f, 
    -0.00907198f, 0.08489884f, -0.19692808f, 0.31341913f, -0.05481464f, 0.38245195f, -0.03656364f, -0.12465032f, 
    0.10902032f, -0.10433333f, 0.16945772f, -0.16795227f, 0.31832615f, -0.11524558f, 0.22734785f, -0.13332286f, 
    -0.05285561f, -0.07666221f, 0.03028755f, -0.09192384f, 0.04245439f, -0.05337785f, -0.11288573f, -0.10054867f, 
    -0.05638287f, -0.10533356f, -0.00193490f, -0.07281203f, 0.10149785f, 0.15255551f, -0.11193484f, -0.05573249f, 
    -0.05941480f, 0.01582721f, -0.06597239f, 0.03401016f, 0.04407070f, -0.01889878f, -0.03039746f, -0.08782806f, 
    -0.06719758f, 0.10898761f, 0.01025360f, 0.11833924f, -0.15201598f, -0.13673019f, 0.06944485f, -0.09340535f, 
    -0.10269114f, 0.10677391f, -0.01531710f, -0.03231476f, -0.10047365f, -0.04956906f, 0.08479835f, -0.01735741f, 
    -0.02582539f, -0.05524885f, -0.03859525f, -0.07286980f, -0.02757432f, -0.03373224f, -0.17840482f, -0.00224003f, 
    -0.08960250f, -0.03040573f, -0.03790646f, -0.00491473f, 0.00415451f, -0.13956606f, -0.12135850f, 0.08004638f, 
    0.09534495f, -0.01314039f, 0.09891072f, -0.09579284f, -0.15425280f, -0.13106042f, -0.04694774f, -0.01214344f, 
    -0.11499913f, 0.14815603f, -0.14243571f, -0.08113448f, -0.04101853f, 0.10356538f, 0.14820544f, 0.05724136f, 
    0.06926095f, 0.11326938f, 0.09975825f, -0.21956827f, -0.10788697f, 0.10024165f, 0.08952642f, -0.05786890f, 
    -0.19657460f, -0.20954931f, -0.02835581f, 0.07584366f, 0.27782464f, 0.12696768f, 0.03768967f, 0.06965081f, 
    0.05384591f, -0.11661416f, 0.04664572f, -0.48884848f, 0.22928651f, 0.19932176f, -0.30440468f, -0.04491064f, 
    0.05057794f, 0.11011472f, 0.11221800f, 0.11027262f, 0.00953924f, 0.04753393f, 0.03451086f, -0.08823530f, 
    0.20164104f, 0.05931842f, 0.08192139f, 0.35485420f, 0.35460228f, 0.25596249f, 0.04970405f, 0.09530856f, 
    0.04810521f, 0.08274549f, 0.10183737f, -0.12372100f, -0.07749676f, 0.13229902f, 0.11857559f, -0.15935469f, 
    -0.49926555f, 0.08667239f, 0.05926298f, -0.11937507f, -0.08103210f, -0.39060974f, 0.08344349f, -0.14082064f, 
    -0.04193633f, 0.13371593f, -0.23298632f, 0.12960161f, 0.18860863f, 0.07215391f, 0.13197304f, 0.13567311f, 
    0.08922856f, 0.01968589f, -0.08437718f, -0.09473262f, -0.05634576f, -0.10317226f, -0.01996165f, -0.26788059f, 
    0.09217408f, -0.39396420f, -0.08444405f, -0.06359566f, 0.27138263f, 0.01379159f, -0.00070494f, 0.06603332f, 
    -0.00910895f, 0.07010140f, -0.04687772f, -0.10582219f, 0.27945477f, -0.17794597f, -0.30347213f, 0.02911372f, 
    -0.21141976f, -0.02062304f, -0.04696876f, -0.08240729f, 0.14528020f, -0.03130902f, 0.37297562f, -0.44381431f, 
    -0.10727756f, -0.03471049f, 0.28915757f, 0.35368788f, 0.15851462f, -0.14210334f, 0.30670765f, 0.03896472f, 
    -0.04814777f, 0.00659438f, 0.09532058f, -0.26272193f, 0.22918071f, 0.30456793f, -0.05009437f, 0.05275775f, 
    -0.06617247f, 0.04178150f, -0.36734885f, -0.05217557f, -0.37351498f, 0.10544650f, 0.12160984f, -0.04102415f, 
    -0.03615080f, 0.03393206f, -0.01640379f, -0.11169814f, 0.13379195f, 0.10997329f, 0.02570745f, 0.07925095f, 
    0.13524595f, 0.33539355f, 0.04486920f, 0.04291109f, -0.10561696f, 0.07965063f, -0.16784719f, -0.30272093f, 
    -0.15963827f, 0.12185819f, -0.10099281f, -0.08358734f, -0.05006287f, -0.08449827f, -0.39416596f, 0.00800252f, 
    -0.05825841f, -0.00290604f, 0.00097480f, -0.01116996f, -0.12709531f, 0.13607855f, -0.16057636f, -0.14391837f, 
    -0.24512474f, 0.08749044f, 0.05607281f, 0.14420035f, 0.32810599f, -0.06254192f, 0.14195032f, 0.08672614f, 
    0.23514554f, -0.11072480f, 0.00498416f, -0.24464191f, -0.16351926f, 0.00350456f, 0.13849260f, 0.02512847f, 
    0.02276552f, 0.04107819f, 0.24713555f, -0.02755771f, 0.20074484f, -0.16619483f, 0.10009736f, 0.09751705f, 
    -0.12258075f, 0.02232047f, 0.24052504f, 0.02607232f, 0.07684253f, -0.07018466f, -0.21985322f, -0.18248136f, 
    0.06516284f, 0.08567960f, -0.44341534f, 0.05611577f, 0.17628010f, -0.05986831f, 0.25835335f, 0.10431331f, 
    0.16487578f, 0.00264212f, 0.39279896f, 0.01475247f, -0.02267759f, -0.26526859f, 0.17868617f, 0.16693187f, 
    0.11855409f, 0.07663770f, 0.04326694f, -0.28736156f, -0.03125282f, -0.04450855f, 0.20408066f, 0.12646432f, 
    -0.08354509f, 0.05391503f, 0.04020423f, 0.20608023f, 0.13800055f, -0.16537702f, 0.05438048f, 0.20229904f, 
    0.20280124f, 0.07875813f, -0.15215574f, -0.08098980f, 0.25853807f, 0.03378714f, 0.09115074f, -0.09503489f, 
    -0.24774113f, 0.11508343f, -0.22607163f, -0.08776079f, -0.08079568f, -0.01674142f, -0.12177400f, 0.27680579f, 
    0.07386468f, -0.07912571f, 0.09868575f, -0.27444431f, 0.03015299f, -0.03219858f, 0.07179424f, 0.04229738f, 
    0.13727953f, 0.07646196f, -0.12218110f, -0.06812232f, 0.14565265f, -0.00189378f, 0.05083659f, 0.39310613f, 
    0.04064617f, 0.04631004f, -0.20226476f, 0.03572322f, 0.13732187f, -0.08230548f, 0.30171600f, -0.09825782f, 
    0.01436678f, -0.31995013f, 0.37089711f, 0.27571127f, 0.12925299f, -0.15309931f, -0.11383058f, -0.14189315f, 
    0.09379283f, 0.08927365f, 0.04990036f, -0.17467164f, 0.10247512f, -0.16663399f, 0.12413719f, 0.05657989f, 
    -0.08122402f, -0.00251888f, 0.07508700f, 0.13042733f, 0.14885928f, -0.12175179f, 0.26040494f, -0.21742150f, 
    0.20789334f, 0.04503876f, 0.05190116f, 0.15114453f, 0.23895092f, 0.10525993f, 0.00734934f, -0.06943009f, 
    -0.24806815f, 0.00141331f, -0.01454702f, 0.02270522f, -0.01302417f, 0.10060256f, -0.11344292f, 0.24314435f, 
    0.05924472f, -0.09939527f, 0.22911111f, 0.01167627f, -0.16661090f, 0.01232886f, -0.02174756f, 0.26537880f, 
    -0.05640496f, -0.06585963f, -0.18266495f, -0.14788154f, 0.04409783f, 0.20529392f, 0.04108946f, 0.21412003f, 
    -0.05585426f, -0.10018774f, -0.04256931f, 0.08644686f, 0.06460419f, 0.04356857f, -0.10503399f, 0.07709064f, 
    -0.12232874f, -0.15982439f, 0.10930772f, -0.02737214f, 0.10469723f, -0.11981678f, 0.07645869f, 0.02428571f, 
    -0.02354524f, -0.05852897f, 0.05628335f, 0.01065195f, 0.15137878f, -0.00943352f, 0.10709070f, -0.20589355f, 
    0.10169980f, 0.06219345f, 0.01588610f, 0.03363263f, 0.09785637f, -0.08205642f, -0.05684330f, -0.11198251f, 
    -0.11310548f, -0.00621299f, 0.17081821f, 0.02410953f, -0.11705221f, -0.08171327f, -0.18953075f, -0.13411339f, 
    -0.17323832f, -0.09893649f, -0.01528441f, 0.00263610f, 0.00278118f, -0.07386529f, 0.04100037f, -0.00883522f, 
    -0.19134890f, 0.02314978f, -0.11046629f, -0.06044137f, -0.08022504f, -0.07659664f, 0.04564276f, -0.14590546f, 
    0.00729133f, -0.09783065f, 0.03951035f, -0.03943603f, -0.13848698f, 0.02911064f, 0.02803897f, -0.16832483f, 
    0.05055590f, 0.04608628f, 0.00439492f, -0.12340781f, 0.04042744f, -0.10025845f, -0.05112796f, -0.11746877f, 
    0.17007792f, -0.00913806f, 0.15058906f, -0.07864834f, -0.09857967f, 0.03806609f, 0.01136615f, 0.10037238f, 
    -0.16240737f, 0.13617219f, -0.07371862f, -0.20166484f, 0.02173303f, 0.00856074f, -0.00066220f, -0.01708185f, 
    0.05039123f, -0.12107989f, 0.08889467f, -0.21464592f, -0.24403381f, 0.04873452f, 0.22596793f, 0.16990425f, 
    -0.01295941f, -0.11505054f, -0.04082540f, 0.19843049f, -0.00305158f, -0.10220924f, -0.07676295f, 0.00630894f, 
    -0.10430174f, 0.07147281f, -0.08448298f, 0.19339535f, -0.19526057f, 0.09586529f, 0.04837364f, 0.09388839f, 
    -0.12199701f, -0.08870560f, -0.07540335f, -0.17232801f, -0.11531081f, 0.01438860f, -0.08305645f, -0.13609134f, 
    -0.04057457f, 0.01859511f, 0.10876568f, -0.06445503f, -0.04506409f, -0.06624502f, -0.14004014f, 0.02319586f, 
    -0.03692940f, -0.05350637f, 0.06896321f, -0.06326738f, 0.12505953f, -0.06685141f, 0.27333635f, 0.05929694f, 
    -0.18857664f, -0.19097030f, -0.00144078f, 0.21991302f, 0.09768720f, 0.04834975f, 0.00480692f, 0.12663007f, 
    0.33370304f, 0.16682039f, 0.00478247f, 0.02436232f, 0.03153700f, -0.09826975f, 0.48876271f, 0.20249236f, 
    -0.10671206f, -0.11030506f, 0.05221514f, 0.17962311f, -0.00587482f, -0.18600495f, 0.18623549f, 0.04738782f, 
    -0.01080331f, 0.01612394f, -0.11382376f, -0.11243813f, -0.05338309f, 0.06993838f, 0.13222735f, 0.14500120f, 
    -0.09482854f, 0.09899402f, 0.12639573f, 0.23312309f, 0.38639954f, -0.08069145f, 0.10855461f, -0.03176837f, 
    0.11016855f, -0.08523000f, -0.09711523f, 0.26804605f, 0.11452587f, 0.15705363f, 0.06132445f, 0.02055018f, 
    0.24947730f, 0.02983856f, 0.06883034f, -0.02488204f, 0.08327455f, 0.09522577f, 0.28632671f, 0.27538052f, 
    -0.05041470f, -0.06993838f, -0.21813475f, -0.11165044f, -0.08356312f, -0.00359561f, -0.08591403f, 0.15782551f, 
    -0.05258664f, 0.02236160f, -0.12220746f, -0.20467161f, 0.08366761f, -0.29217288f, -0.05605449f, 0.03941431f, 
    -0.04611288f, -0.22708249f, -0.07215483f, 0.03955953f, 0.01331553f, 0.19615912f, 0.12490795f, -0.11994839f, 
    -0.09781192f, 0.04632035f, 0.01984681f, -0.15809274f, 0.10879127f, 0.07801158f, -0.27057070f, 0.27440414f, 
    0.07867651f, -0.01578503f, 0.04662136f, 0.21384165f, 0.15238421f, 0.08687978f, 0.12188999f, -0.10381441f, 
    0.17440963f, -0.02050066f, 0.18702267f, 0.46366334f, 0.44445580f, 0.18238001f, 0.04853101f, -0.18373142f, 
    0.29224366f, 0.04166961f, 0.06718143f, -0.18422766f, 0.07322897f, -0.22916450f, -0.00259946f, 0.14697544f, 
    -0.24583462f, -0.02206003f, -0.14814895f, 0.21037084f, -0.16165422f, -0.05489700f, -0.04783233f, 0.14535916f, 
    0.04904962f, -0.02277659f, 0.09202902f, 0.05154426f, 0.19075060f, -0.08130547f, -0.01028344f, 0.35192287f, 
    0.04461629f, -0.04060143f, -0.25025806f, 0.21614704f, 0.01988493f, -0.22325113f, -0.13240144f, -0.44451788f, 
    -0.05271995f, -0.21248169f, 0.01444747f, 0.13458881f, 0.23695785f, 0.00088719f, 0.03952568f, -0.01967272f, 
    -0.10867877f, 0.08742937f, -0.08707286f, -0.10659897f, 0.19361427f, -0.00839756f, 0.00668974f, 0.18820341f, 
    0.08230099f, 0.10641556f, 0.03991115f, 0.24947546f, -0.00813640f, -0.09214596f, 0.21651031f, -0.13431323f, 
    -0.07036266f, 0.11493792f, 0.28136417f, 0.05625800f, -0.19996554f, -0.07711155f, 0.21610062f, -0.29216459f, 
    -0.05161908f, 0.01817777f, 0.28087378f, 0.07744420f, -0.10209524f, 0.21509789f, 0.04490808f, 0.08101175f, 
    -0.03705526f, -0.00990075f, -0.07045024f, -0.14521933f, -0.22937508f, -0.03966642f, 0.01391317f, -0.09040601f, 
    0.11150500f, -0.14484330f, -0.00713611f, -0.09194811f, 0.12653823f, 0.11409564f, -0.04610027f, 0.26803946f, 
    0.19558458f, 0.23159294f, 0.04548591f, 0.12408651f, -0.11716761f, -0.22878383f, -0.16441900f, -0.29575852f, 
    -0.26407224f, -0.06877360f, 0.03943889f, -0.07285251f, -0.00955201f, -0.01558384f, -0.10227584f, -0.15064979f, 
    0.04976978f, -0.04437682f, -0.07681495f, 0.11515047f, 0.16937627f, -0.10593101f, -0.21407785f, 0.10976078f, 
    0.00562788f, -0.07028444f, 0.25179422f, 0.05142453f, 0.14470792f, 0.11804751f, 0.32050830f, -0.06898735f, 
    0.23787820f, -0.11749898f, 0.29981765f, 0.10907976f, -0.19620673f, -0.01065054f, 0.11994720f, -0.22800325f, 
    0.01719235f, -0.04865045f, 0.22491419f, -0.12913577f, 0.24200192f, -0.02280829f, 0.07843249f, 0.01568735f, 
    -0.09982468f, 0.09184273f, -0.16147287f, 0.21649340f, -0.14980510f, 0.13123178f, -0.18514577f, 0.12123570f, 
    -0.03073752f, 0.09906293f, 0.02355594f, 0.06367967f, 0.10304494f, -0.11149163f, -0.08771872f, 0.16561493f, 
    0.15717992f, 0.17203920f, -0.13101876f, -0.24202137f, -0.04119636f, -0.01326910f, 0.16082150f, -0.02284436f, 
    -0.16606300f, 0.15377054f, -0.05897624f, 0.02622217f, 0.00681446f, 0.03906532f, -0.15308750f, 0.03514988f, 
    -0.04564267f, -0.01041254f, 0.08084547f, -0.06805356f, -0.19191585f, 0.18266539f, 0.10437985f, 0.13935955f, 
    -0.09631050f, -0.07831560f, -0.06306469f, 0.43177399f, 0.17015967f, -0.05738736f, 0.16710351f, 0.20608951f, 
    0.10849258f, 0.06245583f, -0.04912511f, -0.06893416f, 0.05632697f, 0.00788158f, 0.12153976f, -0.14553288f, 
    0.17585436f, 0.05107350f, -0.17743996f, -0.11554357f, -0.00139220f, -0.13429789f, 0.11031833f, 0.02088908f, 
    0.17754214f, 0.06250423f, 0.16946146f, 0.05056519f, 0.10476869f, -0.11046916f, -0.23639604f, 0.17259380f, 
    -0.02080201f, -0.12937106f, -0.01795741f, 0.03547541f, -0.11626760f, 0.00062415f, 0.01045867f, -0.10943252f, 
    0.01969474f, 0.00105304f, -0.04762769f, 0.06838181f, -0.11789361f, -0.02205671f, 0.04483100f, 0.03211542f, 
    -0.06937481f, -0.01403515f, -0.04673007f, -0.07960911f, -0.03660683f, -0.03012042f, -0.10705531f, 0.04804204f, 
    0.01802976f, 0.05411568f, 0.04794299f, -0.11086687f, 0.03620482f, -0.12649338f, -0.04172690f, -0.10154564f, 
    -0.16497850f, -0.09943391f, -0.13796897f, -0.15312776f, -0.08338173f, 0.01347993f, -0.02352986f, -0.06672731f, 
    0.05868050f, 0.11864638f, -0.13269764f, -0.00431905f, -0.02672403f, -0.00556339f, -0.00728896f, 0.00316643f, 
    -0.02321001f, 0.01027656f, 0.02745377f, -0.08781300f, -0.07801196f, -0.10318823f, 0.02759614f, 0.02905421f, 
    -0.07468329f, -0.08936813f, -0.01943291f, -0.05136601f, 0.10772021f, 0.06794054f, -0.01761155f, 0.02966094f, 
    -0.07245636f, 0.09604424f, 0.20472172f, 0.10778102f, -0.27940068f, 0.09604477f, -0.14435418f, 0.17401947f, 
    0.17349021f, -0.04517685f, -0.11482049f, -0.40577701f, 0.00085596f, 0.04163199f, 0.20928611f, 0.06852836f, 
    -0.07034840f, 0.12150823f, 0.11781950f, 0.17234559f, 0.19226021f, -0.00988700f, 0.11124598f, 0.07791252f, 
    0.11619054f, -0.07962172f, 0.04906713f, -0.04040538f, -0.19541320f, 0.26191977f, -0.17417637f, -0.06339689f, 
    0.12756804f, 0.01938183f, 0.02088755f, 0.27891707f, -0.30078062f, 0.06866663f, -0.05845394f, 0.20624332f, 
    0.13190332f, -0.06630591f, 0.19423154f, 0.33763266f, 0.42733711f, 0.08770020f, 0.15244050f, -0.03775069f, 
    0.29830435f, 0.01885870f, -0.37397408f, -0.11451747f, -0.10653553f, 0.08973373f, -0.01876847f, -0.04689830f, 
    0.08697106f, 0.11333209f, 0.10179962f, 0.20228595f, 0.10574355f, -0.31382379f, -0.03997305f, -0.07243235f, 
    -0.00033725f, 0.08206811f, -0.38650477f, 0.13256314f, -0.07135116f, 0.09091581f, -0.21737842f, 0.27241343f, 
    -0.02877651f, -0.00089417f, 0.25476784f, 0.07885683f, -0.12059389f, -0.13693376f, 0.23658428f, 0.00014062f, 
    0.02627721f, -0.12566774f, 0.04523324f, -0.38293371f, 0.18077262f, 0.05345619f, -0.10610124f, 0.13801080f, 
    -0.09552875f, -0.01896502f, 0.07840350f, -0.02489821f, 0.25533620f, 0.02491598f, -0.16906203f, 0.25105926f, 
    0.15289576f, 0.04273326f, 0.08130928f, 0.00928278f, 0.23399471f, -0.07945882f, 0.01188714f, -0.17106901f, 
    -0.00685758f, -0.03390436f, -0.02627029f, 0.25521123f, -0.14045222f, 0.01755779f, -0.05662743f, 0.08629914f, 
    -0.04067945f, -0.04929237f, 0.20246872f, -0.09400783f, -0.04092364f, -0.25813642f, -0.05973311f, 0.25601766f, 
    -0.20526449f, 0.07981538f, -0.08653869f, 0.31620196f, -0.04557106f, -0.03488400f, -0.30543670f, 0.19083375f, 
    0.04520359f, -0.09970848f, 0.14851800f, -0.08328474f, 0.10373924f, 0.12433550f, 0.22448348f, 0.18268082f, 
    -0.03044460f, 0.05161566f, -0.12446377f, -0.18106347f, 0.00780955f, 0.19306566f, -0.13918093f, 0.04299224f, 
    0.04492131f, -0.12209555f, -0.03759906f, 0.16995379f, 0.18365440f, -0.06517432f, 0.15991624f, 0.06474512f, 
    -0.07864241f, 0.06030983f, -0.11205261f, -0.03825471f, 0.09479897f, -0.07661887f, -0.06352513f, -0.10547714f, 
    0.00053988f, -0.08720173f, 0.09573035f, -0.08315565f, -0.15007791f, -0.09703951f, 0.20291099f, 0.06995260f, 
    0.02672361f, -0.10930876f, 0.16893125f, 0.07553867f, -0.14139670f, -0.11532523f, 0.21377806f, 0.16300283f, 
    0.02534359f, -0.08991826f, 0.11069047f, 0.09563629f, 0.00684553f, 0.33488867f, 0.05570191f, -0.09170635f, 
    -0.06743169f, -0.01367518f, -0.19224544f, -0.15044327f, -0.23123595f, 0.16493994f, 0.26386416f, -0.08813489f, 
    -0.10933857f, -0.13088299f, -0.01518818f, -0.06880422f, -0.11959447f, -0.01096514f, -0.12296951f, 0.03837972f, 
    -0.00561944f, 0.05025989f, -0.04060035f, 0.08880010f, 0.02522823f, 0.07312883f, -0.06350145f, -0.02822107f, 
    -0.00932925f, -0.03201449f, -0.02522635f, -0.03430607f, 0.06919134f, -0.10640402f, 0.03560058f, -0.01032981f, 
    0.07931896f, 0.10271979f, -0.11940940f, 0.03772460f, -0.00205695f, -0.02776347f, -0.10330900f, 0.01544092f, 
    -0.08304393f, -0.00329031f, -0.09869256f, 0.00131114f, -0.12187573f, -0.10999810f, 0.09536863f, -0.00816693f, 
    0.02022335f, -0.10100166f, 0.02251298f, -0.03905655f, -0.00970561f, -0.04020046f, -0.11578969f, -0.13282436f, 
    0.01490732f, -0.02409211f, 0.10216982f, -0.02804414f, -0.00238094f, 0.00143925f, 0.08557853f, 0.00383971f, 
    -0.10040234f, -0.08296872f, 0.09124137f, 0.00820689f, -0.06524731f, -0.12089255f, -0.03168483f, -0.01431264f, 
    -0.04929719f, 0.18136132f, 0.41466600f, -0.02001209f, 0.11152361f, -0.06288218f, -0.24143255f, 0.09901124f, 
    0.15034007f, 0.02453770f, -0.01731001f, -0.13688385f, -0.11346275f, 0.39235774f, 0.00027716f, -0.01684400f, 
    0.05776171f, -0.04257432f, 0.09457266f, 0.22348073f, -0.02633179f, 0.06183498f, -0.34189600f, 0.19293013f, 
    -0.00302363f, 0.08954295f, 0.07728034f, -0.10260989f, -0.12290245f, 0.37035459f, -0.10910205f, -0.26933435f, 
    -0.09897929f, -0.03635693f, -0.02577947f, 0.14827932f, -0.16868642f, 0.08657748f, -0.06911802f, 0.13801603f, 
    0.19570670f, -0.02922725f, 0.19319102f, -0.24183770f, -0.08471318f, 0.20755441f, -0.00149898f, 0.01849828f, 
    0.17942588f, 0.08856463f, -0.10339152f, 0.09048254f, 0.10341365f, 0.02646381f, 0.09308363f, -0.01740677f, 
    -0.05386259f, -0.07238534f, 0.22092608f, 0.13654310f, -0.04986149f, 0.04788619f, -0.24410395f, -0.16379616f, 
    0.07584912f, -0.19457681f, 0.09040967f, -0.07620242f, 0.13255805f, -0.08931922f, 0.10790527f, -0.16837831f, 
    -0.21223576f, -0.32137516f, 0.06892003f, 0.58410239f, 0.03923623f, -0.28111035f, -0.29139662f, -0.49478316f, 
    0.17212416f, 0.20165451f, 0.12228150f, -0.20985900f, 0.20222639f, -0.11666029f, 0.19281891f, -0.10101356f, 
    -0.09193833f, 0.06398136f, 0.09196892f, 0.01177680f, 0.01528766f, -0.15253842f, 0.22353689f, -0.04013026f, 
    0.13221994f, -0.11176063f, 0.04086457f, 0.35023192f, 0.26199818f, -0.07109808f, 0.09205742f, -0.37635279f, 
    -0.14685363f, 0.03996605f, 0.15222086f, 0.04629526f, -0.12460259f, -0.07394525f, -0.21151471f, 0.04946707f, 
    0.06553011f, -0.10969735f, 0.18204877f, 0.31771579f, -0.21035790f, -0.08775433f, -0.05454117f, 0.26302120f, 
    0.11398525f, 0.11082312f, -0.14614010f, -0.09066336f, 0.00239901f, 0.04247961f, -0.04208824f, 0.24492323f, 
    -0.03133973f, 0.25658962f, -0.04389952f, 0.09649783f, 0.21161965f, 0.02435816f, 0.44265020f, -0.12925880f, 
    0.21252823f, -0.07128692f, 0.28477868f, 0.16741112f, -0.09923500f, 0.29411909f, -0.21615012f, -0.19393146f, 
    0.06447461f, -0.03930683f, 0.08012940f, -0.07368939f, 0.16226520f, -0.18540835f, 0.28045890f, 0.01286604f, 
    -0.11590491f, 0.01160920f, 0.04806352f, 0.05304792f, 0.00573633f, -0.20627739f, 0.20939846f, -0.33946568f, 
    0.02507327f, 0.03350431f, -0.18949004f, 0.20219724f, 0.14466442f, 0.02668363f, 0.14165728f, -0.30409688f, 
    -0.14863347f, 0.09656142f, -0.02821434f, -0.41229925f, -0.12706551f, 0.13112186f, 0.06884049f, 0.31333038f, 
    -0.03404403f, 0.06800956f, 0.17323668f, -0.00724164f, 0.02896455f, 0.45133588f, -0.00481544f, 0.01177843f, 
    -0.14388914f, -0.05067242f, 0.11699760f, -0.37723368f, -0.04914211f, 0.27480599f, 0.20537028f, -0.03749496f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.02343092f, -0.02424013f, -0.13450275f, -0.12207440f, 0.00479921f, 0.15241979f, 0.20151794f, 0.20578514f, 
    -0.01779200f, 0.03065053f, -0.08747122f, 0.00182992f, -0.13480170f, 0.11432854f, 0.22446179f, 0.12767240f, 
    -0.10947496f, 0.11732541f, -0.08396865f, -0.05726505f, -0.06096498f, 0.23765594f, 0.03260832f, -0.07648954f, 
    0.01152126f, 0.06340548f, 0.07318721f, 0.07134227f, 0.13919878f, 0.06168717f, 0.05572322f, 0.20872369f, 
    0.00187770f, 0.10311972f, 0.11345797f, -0.21682185f, 0.01426982f, 0.14682205f, -0.11961238f, -0.03208002f, 
    0.10615954f, 0.11084905f, 0.11382259f, 0.02602818f, 0.21203746f, 0.22432178f, 0.02373412f, 0.03862634f, 
    -0.06899766f, -0.10724610f, 0.14331421f, 0.08340959f, 0.15256618f, 0.04817104f, 0.10902689f, 0.11919789f, 
    0.01194051f, 0.34971178f, -0.04952879f, -0.00215163f, 0.05331914f, 0.21590783f, -0.20014569f, 0.03571995f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.12666364f, -0.70558560f, 0.18006697f, 0.15557410f, 0.04853512f, -0.47719494f, -0.14262025f, -0.20281062f, 
    -0.09767538f, -0.02390166f, 0.20667061f, -0.13288619f, -0.17700061f, -0.24127883f, -0.12116686f, -0.23367995f, 
    -0.06179962f, -0.11114532f, -0.00889986f, -0.10460493f, -0.22775620f, -0.13759805f, 0.06369658f, 0.13473149f, 
    0.07266661f, -0.25787267f, 0.11671434f, 0.21364014f, -0.26748767f, -0.18659407f, 0.27216977f, -0.32697022f, 
    -0.02988464f, 0.07236536f, -0.38149199f, 0.23541148f, 0.04066210f, -0.01175545f, -0.08394014f, 0.08696719f, 
    0.09064843f, -0.03027419f, -0.06296532f, -0.07860395f, -0.18545453f, -0.60332000f, 0.05602169f, 0.19737329f, 
    0.15173095f, -0.01159850f, -0.31236050f, 0.05678760f, -0.02106839f, -0.59076571f, -0.09479678f, -0.37849975f, 
    0.02017595f, -0.16283852f, 0.16965757f, -0.27252170f, -0.00607394f, -0.15602006f, 0.28490171f, -0.08010399f, 
    0.17564592f, 0.13180976f, -0.03591976f, 0.06727191f, -0.12133039f, 0.00838184f, 0.23393083f, 0.24939889f, 
    0.07201302f, -0.03804938f, 0.08870722f, -0.17698973f, -0.03533335f, -0.14245567f, 0.03566630f, 0.05476401f, 
    0.02398292f, 0.06680556f, -0.01000957f, -0.11402621f, -0.28636801f, 0.24938220f, -0.21695687f, -0.10060810f, 
    -0.23471785f, -0.11844474f, 0.18305852f, -0.00752999f, 0.04429545f, -0.33899841f, 0.11344867f, 0.13427679f, 
    0.10766345f, 0.03037895f, -0.37972549f, 0.14591874f, -0.13812712f, 0.22712772f, -0.03397333f, -0.12179963f, 
    0.07437743f, -0.26780421f, 0.12684850f, -0.12485532f, -0.25464493f, -0.41707006f, -0.15081958f, -0.00100540f, 
    -0.12320266f, -0.00248136f, -0.11838210f, 0.08004934f, -0.07953504f, -0.11471936f, -0.29032168f, 0.07544081f, 
    0.01520531f, 0.06310622f, 0.02585159f, -0.14185287f, 0.00707360f, 0.08337601f, -0.44397056f, -0.35317454f, 
    -0.16195433f, -0.34812397f, -0.00753953f, -0.44964629f, 0.10971914f, 0.07677057f, 0.15377258f, -0.45050487f, 
    -0.04271670f, -0.05886542f, -0.24310769f, -0.40968350f, -0.09082862f, 0.15469564f, 0.20102936f, -0.05942440f, 
    -0.02959958f, 0.05178955f, -0.05971690f, 0.11135428f, 0.02810413f, -0.07705103f, -0.05570858f, -0.43410006f, 
    0.02104826f, 0.19534276f, 0.15765759f, -0.22462894f, -0.06646530f, 0.01604580f, -0.31168497f, -0.16414042f, 
    0.02258897f, -0.18059450f, 0.02254050f, -0.29900479f, 0.20667067f, -0.12736133f, 0.08116247f, 0.04724267f, 
    0.12823306f, -0.16289437f, 0.05253724f, -0.03096541f, 0.24995790f, 0.27994809f, -0.25244540f, 0.30804738f, 
    0.01173272f, -0.08657233f, 0.01086591f, -0.05023523f, 0.23640810f, -0.15250634f, -0.11167477f, -0.06081346f, 
    -0.02055160f, 0.09333763f, 0.27245784f, 0.08190540f, -0.03376083f, -0.12631875f, -0.64511549f, 0.02553222f, 
    -0.29544023f, -0.22968015f, 0.13830435f, -0.14349060f, -0.49280912f, -0.11290948f, -0.26147056f, -0.55393595f, 
    -0.04536484f, -0.09125091f, -0.09556244f, -0.18256639f, -0.07068995f, -0.04906281f, -0.28031760f, 0.06709421f, 
    0.07445902f, 0.06683414f, 0.04429720f, -0.11958973f, 0.22266725f, 0.01521249f, -0.42815647f, 0.00801458f, 
    0.06825045f, 0.24228194f, -0.09428883f, 0.21142012f, 0.15126212f, 0.30268374f, -0.31813186f, -0.28548053f, 
    -0.09504534f, 0.06351823f, -0.18238740f, 0.09313968f, 0.17088111f, -0.07275291f, -0.13475677f, -0.13115466f, 
    0.07129539f, 0.04512655f, -0.31941572f, 0.04393362f, -0.07899921f, 0.10877408f, 0.37074554f, -0.01252637f, 
    -0.00209384f, -0.02463420f, -0.34692708f, -0.07194497f, -0.05693363f, -0.10142212f, 0.15149443f, 0.03769992f, 
    -0.00195876f, -0.21605976f, 0.21324083f, -0.03900092f, 0.08619647f, 0.18762363f, -0.09171862f, 0.13329659f, 
    0.21556672f, 0.01905874f, 0.19849518f, 0.20534664f, -0.09568200f, -0.05298314f, 0.03544033f, 0.02338607f, 
    -0.00832146f, -0.06789413f, -0.16465953f, 0.27530012f, -0.05154043f, 0.08898059f, -0.31104499f, -0.07447120f, 
    0.05852184f, 0.18960735f, -0.04600657f, 0.07783378f, -0.03849402f, -0.11538247f, 0.10512083f, 0.03143413f, 
    -0.10898176f, -0.11892071f, 0.00585286f, -0.13416535f, 0.01064563f, -0.46194631f, 0.09804003f, -0.24903107f, 
    -0.11705233f, -0.10626210f, -0.00558122f, 0.02896581f, -0.08253013f, -0.23223522f, 0.04834609f, -0.13052379f, 
    0.07041653f, 0.16056746f, -0.29907954f, -0.04240569f, -0.66216981f, 0.20433034f, -0.14378302f, 0.19649322f, 
    0.10981496f, -0.16940179f, 0.04619228f, 0.14972137f, 0.00206367f, -0.06219742f, 0.17689286f, -0.02791132f, 
    -0.05802823f, -0.51918060f, 0.01060210f, 0.02985380f, -0.09640632f, -0.24930906f, 0.14096116f, 0.13226977f, 
    -0.22435750f, -0.59432912f, -0.15952498f, 0.14927606f, -0.03906679f, -0.14763774f, -0.00857645f, -0.12772153f, 
    -0.06808423f, -0.09613596f, 0.12561807f, 0.15021369f, -0.12553383f, 0.12070400f, -0.30759609f, -0.48966241f, 
    -0.04608277f, -0.05437891f, 0.09382907f, 0.01802449f, -0.03266482f, 0.00427152f, 0.32056624f, 0.26758441f, 
    0.24901658f, 0.12840267f, 0.04358250f, -0.34335604f, 0.01556883f, -0.21745281f, -0.16457769f, 0.18169287f, 
    -0.01319757f, 0.00200334f, 0.26020959f, 0.11160355f, -0.16503072f, 0.06235665f, -0.08920267f, 0.05064680f, 
    0.05358292f, 0.02419446f, 0.25836220f, -0.02531756f, -0.07134977f, -0.08121829f, -0.13991937f, -0.10943803f, 
    0.01936765f, 0.13119990f, -0.22884007f, 0.12104343f, -0.39381942f, -0.43730563f, -0.56050622f, -0.19526620f, 
    -0.01273920f, -0.09610453f, -0.43316752f, 0.16487809f, 0.00414166f, 0.10173911f, -0.09897751f, 0.31658745f, 
    -0.48325548f, -0.10285658f, 0.00089713f, -0.67005402f, 0.00329137f, -0.06512544f, 0.02512695f, 0.19751732f, 
    -0.06669162f, -0.08035459f, -0.31606922f, -0.26876485f, -0.02803410f, 0.13235535f, 0.32386976f, -0.23965584f, 
    0.06682391f, -0.56317174f, 0.11825711f, 0.09609945f, 0.10093567f, -0.40444544f, 0.31581640f, -0.38777229f, 
    -0.32175612f, 0.01607573f, -0.35281828f, -0.46907577f, -0.03207274f, -0.29423910f, -0.09830908f, 0.06377766f, 
    0.12374993f, -0.63002616f, 0.24177185f, -0.19649093f, -0.11809579f, -0.08518195f, -0.08548538f, -0.06176512f, 
    -0.54928964f, -0.05751175f, 0.06190787f, -0.01210956f, 0.12073147f, 0.28836367f, 0.03102263f, -0.21982275f, 
    -0.61926091f, -0.00955590f, -0.12809467f, 0.08033881f, 0.35478532f, 0.04545497f, 0.26763013f, 0.08268888f, 
    0.07916046f, -0.00092541f, 0.00621822f, 0.03775818f, -0.05522488f, -0.10472488f, -0.52587450f, -0.61558533f, 
    0.08209869f, -0.25275606f, 0.16465858f, 0.08613858f, -0.31852365f, -0.47623399f, -0.29596210f, 0.11892822f, 
    -0.04501590f, -0.15115871f, -0.22053866f, -0.09966902f, -0.07469630f, 0.16743413f, 0.13960123f, 0.13740157f, 
    -0.07486780f, -0.32184952f, -0.06605271f, -0.06601132f, 0.18622984f, -0.12448723f, -0.01919181f, -0.07215054f, 
    0.28958124f, -0.15851150f, -0.32860681f, -0.03685857f, 0.09739634f, 0.21637061f, 0.25612476f, -0.17121315f, 
    0.12144978f, -0.30282822f, 0.02823827f, -0.28111285f, -0.05802996f, -0.49435639f, -0.08504319f, 0.03892655f, 
    -0.49643949f, 0.01737706f, 0.13701430f, 0.04881816f, -0.12571430f, -0.09029325f, 0.31064463f, 0.32920200f, 
    -0.01139197f, -0.03609229f, 0.16829878f, -0.21403861f, -0.38505486f, -0.15402560f, 0.05124020f, 0.17594391f, 
    -0.13191202f, -0.28794748f, -0.26504859f, -0.12800772f, 0.05507313f, -0.19345920f, -0.00865376f, 0.50043589f, 
    -0.10131442f, -0.13104028f, -0.26691470f, -0.11508515f, 0.00235163f, 0.17983955f, -0.16785692f, -0.18303554f, 
    0.00703607f, 0.05248227f, -0.10784575f, 0.35072058f, -0.07822733f, -0.35069394f, 0.02087858f, -0.15630704f, 
    0.06858622f, -0.38739929f, 0.06802203f, -0.09326150f, 0.14205608f, -0.07695004f, -0.52008545f, 0.17174737f, 
    0.25809067f, 0.12186393f, 0.04984656f, 0.02415706f, -0.21181817f, 0.36617440f, -0.08922350f, 0.15280564f, 
    -0.08668971f, -0.07542650f, 0.07320833f, -0.23161934f, -0.36068150f, 0.11057762f, -0.11035091f, -0.07610454f, 
    -0.30730024f, -0.16305120f, 0.16081615f, -0.01856621f, 0.24262738f, -0.36615413f, 0.11656846f, -0.37468889f, 
    -0.37612128f, 0.11239461f, 0.06246123f, -0.53947926f, 0.12352541f, -0.05994839f, -0.26329291f, 0.15890817f, 
    -0.07625984f, 0.24915329f, 0.03342035f, -0.43076557f, -0.07918779f, 0.22910659f, -0.43181771f, -0.04712302f, 
    -0.08512449f, -0.25235668f, -0.14083105f, 0.38762876f, -0.07067137f, -0.19604880f, 0.08406208f, -0.14544824f, 
    0.04720980f, -0.07930001f, -0.38704041f, -0.25243616f, -0.03184704f, 0.07221313f, 0.03437892f, -0.45302877f, 
    -0.14019501f, -0.11436789f, -0.02630042f, -0.10681810f, -0.13582022f, -0.43069530f, -0.00099370f, -0.13236099f, 
    -0.32378346f, -0.60784352f, -0.19415407f, -0.07939854f, 0.13873461f, -0.06861386f, 0.33270675f, 0.11334126f, 
    0.10701314f, -0.35400549f, -0.07023481f, -0.44930232f, 0.01778455f, -0.21039854f, -0.06953591f, -0.02568255f, 
    -0.29492217f, 0.23473775f, 0.11122953f, -0.07843137f, 0.03522220f, 0.09352674f, -0.25765058f, -0.10893800f, 
    0.01337155f, -0.09511781f, -0.30990472f, 0.14252588f, 0.17515747f, 0.29391220f, -0.02147248f, -0.04846311f, 
    0.09044398f, -0.02649918f, -0.02919515f, 0.18149775f, 0.05751441f, -0.20089819f, 0.45736659f, 0.15406220f, 
    -0.51974839f, -0.45545387f, -0.16941558f, -0.17823344f, -0.35109147f, 0.11220159f, -0.07318675f, -0.24405517f, 
    -0.05496629f, 0.10478237f, 0.12734601f, 0.03511773f, -0.06419264f, -0.43894863f, 0.02771072f, 0.29988143f, 
    0.05614051f, 0.20338534f, 0.10190769f, -0.11307330f, -0.27340198f, 0.10731074f, -0.17803277f, -0.12371320f, 
    -0.32096007f, 0.14254753f, -0.08868995f, -0.42834824f, -0.13955662f, 0.14847712f, -0.23923725f, -0.02355439f, 
    -0.02045161f, 0.20529005f, 0.24659926f, -0.38079751f, -0.45352563f, -0.18533316f, -0.12469608f, 0.07130367f, 
    0.18034886f, 0.23032103f, -0.25625184f, 0.00693497f, -0.18884714f, -0.15741694f, 0.20836118f, -0.73813516f, 
    -0.29080528f, 0.01672108f, -0.44481102f, -0.08316522f, 0.04175234f, 0.06275397f, 0.22368366f, 0.22737917f, 
    -0.03188388f, 0.25402009f, -0.38468289f, 0.04186465f, 0.03706283f, 0.23333287f, -0.04626581f, -0.42218730f, 
    -0.03712048f, -0.20012319f, 0.01501246f, 0.09569789f, 0.12526669f, 0.35479870f, 0.07095411f, 0.14078546f, 
    0.02608160f, 0.09539685f, -0.04706084f, 0.09369852f, -0.15500529f, 0.10824497f, -0.08788136f, -0.34684813f, 
    0.01332360f, -0.22886790f, -0.03124417f, 0.10380243f, 0.23587462f, 0.16279620f, 0.10943100f, 0.21681292f, 
    -0.30533063f, -0.22062986f, -0.11189187f, 0.38700080f, -0.06970081f, 0.16781382f, -0.51437706f, 0.12980822f, 
    0.01956974f, -0.21855699f, -0.04301062f, 0.00953002f, 0.23186743f, 0.24737935f, -0.11490449f, 0.07429072f, 
    -0.19114783f, -0.63867092f, -0.44459018f, 0.07918535f, 0.05301733f, 0.14864947f, 0.05111969f, -0.32933599f, 
    -0.18623315f, 0.15596838f, -0.39200822f, -0.40552238f, -0.13220806f, 0.14854106f, 0.27304766f, -0.28509617f, 
    -0.03915896f, -0.18977411f, 0.16212511f, 0.16946156f, -0.01099116f, -0.00145048f, -0.09858248f, -0.24588746f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.17465886f, 0.12860072f, 0.21638651f, -0.12602133f, -0.11057524f, -0.07430158f, 0.15064304f, -0.04026686f, 
    -0.04331229f, 0.03131357f, 0.06016274f, -0.08557975f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
