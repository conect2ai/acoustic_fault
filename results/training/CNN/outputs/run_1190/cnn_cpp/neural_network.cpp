#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.91303861f, -1.18424034f, -0.41130945f, 0.44414929f, 0.27619040f, -0.34334609f, -0.47324067f, -0.50791222f, 
    -0.54042709f, -0.43985599f, 0.45191875f, -1.01161516f, 0.38836673f, 0.63213253f, 0.03751377f, -0.21848339f, 
    1.19679248f, -0.71802366f, 0.77013636f, 0.94953835f, 0.05149812f, 0.56855249f, 0.83849609f, 0.11526894f, 
    0.33468890f, 0.96685189f, -0.47780952f, 0.50524223f, -0.41034666f, -0.29727107f, 0.65716892f, 0.69439447f, 
    -0.99908191f, -0.47423068f, -0.60435671f, 0.85979050f, 0.23046890f, -0.90389401f, 0.04360258f, -1.06312501f, 
    -0.93793559f, -0.86265880f, -0.28360575f, -0.16640951f, -0.67946768f, 0.54811656f, -0.58442968f, 1.10613048f, 
    -0.74242741f, 0.19538718f, 0.65240937f, 0.55549228f, -0.08827291f, -0.05075854f, -0.44547033f, 0.57146800f, 
    -0.19403903f, -0.04909562f, 0.31378618f, 0.29339975f, 0.69196051f, 0.88289642f, 0.39839879f, 0.39227995f, 
    0.16983560f, 0.33228740f, 0.48691595f, 1.03042698f, 1.11292434f, 0.46013609f, -0.54836851f, 0.57144660f, 
    1.43470228f, -0.25159350f, 0.71042281f, 0.92531800f, -0.47255385f, -0.39986807f, 0.36914730f, -0.05806935f, 
    0.09219155f, -0.11937304f, -0.13573115f, 1.35805702f, 1.01075184f, -0.70171553f, -0.73820186f, -0.00978000f, 
    -0.17994425f, 0.01078093f, -0.60213131f, -0.06137224f, 0.40404317f, 0.42712668f, -0.32442430f, -0.57199496f, 
    0.31053409f, 1.28628457f, -0.42689702f, 0.81586224f, -0.66723704f, 0.80242831f, -0.02988430f, -0.91512668f, 
    0.81710732f, 0.45472953f, -0.44695914f, -0.56922430f, -1.27240145f, -0.09501146f, -0.21107210f, -0.97203529f, 
    -0.68575853f, -1.63800347f, 0.18270515f, -0.50994527f, 0.50311327f, 0.22773850f, 0.26821515f, 1.19243550f, 
    -1.54450536f, -0.28225744f, -0.06727904f, 0.05870254f, -0.11942918f, 0.91034687f, 0.32519475f, 1.09209287f, 
    0.37611204f, -1.47609186f, -0.29444641f, -0.15149219f, 0.46948281f, 0.55243212f, 0.37369052f, -0.81484503f, 
    0.35208011f, 1.06972396f, 0.66429257f, 0.93873149f, 0.12160239f, -0.23572983f, -0.66464120f, 0.52350843f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.24020493f, 0.71413934f, -0.00783573f, 0.92298663f, 0.83577770f, 0.68158698f, 0.39115378f, 0.70242268f, 
    0.94203568f, 0.30833957f, -0.02112008f, 0.40268677f, -0.51877671f, 0.10323248f, 0.42812204f, -0.35183388f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.44004086f, 0.17755245f, 0.62635869f, -0.18929113f, -0.23841316f, -0.04092491f, -0.15207838f, 0.00749245f, 
    -0.06738776f, 0.48991427f, 0.41876274f, 0.52132934f, 0.09343677f, 0.28495628f, 0.27736795f, 0.15304871f, 
    0.34299442f, 0.38395837f, -0.02167120f, -0.15621354f, 0.01875632f, -0.24457301f, -0.06629899f, -0.33782175f, 
    -0.27025327f, 0.15767795f, -0.14693771f, -0.05345983f, 0.13207145f, 0.41856048f, -0.15949130f, -0.02493256f, 
    0.36033162f, 0.48075071f, 0.01478353f, 0.46052966f, -0.38944411f, -0.61705667f, 0.04130219f, 0.06880399f, 
    0.11761425f, -0.09807140f, 0.07254701f, 0.10440579f, 0.17843382f, -0.12328960f, -0.11744012f, -0.28394759f, 
    0.15142474f, 0.13281879f, 0.05252945f, 0.09180310f, 0.04933337f, -0.05203819f, 0.14615926f, 0.17081676f, 
    -0.32059643f, -0.20838197f, 0.00009675f, 0.14943026f, -0.19590481f, -0.03535381f, -0.07900853f, -0.04316535f, 
    -0.13430925f, -0.05633895f, -0.20598304f, -0.12289209f, -0.06582075f, 0.20632084f, -0.13662961f, 0.21020754f, 
    -0.40578368f, 0.41681769f, 0.19415784f, 0.01771425f, 0.14144702f, -0.06675865f, -0.05437410f, 0.06163090f, 
    -0.13145529f, 0.38622454f, -0.08250971f, 0.06694730f, 0.25179756f, -0.04978962f, -0.06262298f, 0.25637758f, 
    0.21598439f, -0.04664255f, -0.48526675f, 0.03521345f, -0.23789503f, -0.06700813f, 0.05715799f, -0.31741291f, 
    0.08295053f, -0.06726827f, 0.05642091f, 0.08447471f, 0.33354113f, -0.15998833f, 0.29081556f, 0.33895570f, 
    0.11591973f, 0.05517148f, 0.17420733f, 0.11276207f, -0.22968905f, -1.02562046f, -0.48948374f, -0.16642366f, 
    -0.42000741f, -0.49586046f, 0.07394125f, -0.05266251f, 0.15599643f, -0.65731609f, -1.25028074f, 0.06665958f, 
    -0.19167748f, -0.03406693f, -0.14431074f, -0.09596039f, -0.27116853f, 0.16026011f, -0.59552592f, -0.79498386f, 
    0.14867014f, -0.05716765f, 0.04686233f, -0.18678039f, 0.16965862f, 0.18467090f, -0.19742021f, 0.06353605f, 
    -0.02039345f, -0.53583914f, -0.09805240f, -0.38233507f, -0.13121974f, -0.10720081f, 0.00915769f, 0.26575550f, 
    0.13543397f, 0.20311862f, -0.02134526f, -0.07305811f, -0.08145808f, 0.08170182f, 0.10936165f, -0.00728218f, 
    -0.39785460f, 0.04490540f, 0.33655179f, 0.22519386f, 0.40761033f, 0.27409387f, 0.20779517f, 0.03901025f, 
    0.00113991f, 0.16988356f, -0.33129668f, -0.23701480f, -0.39658570f, -0.22736196f, -0.34475249f, -0.20479344f, 
    -0.28643888f, 0.09565914f, -0.07536193f, 0.34275433f, -0.02789610f, 0.38590717f, 0.07086228f, 0.26802143f, 
    -0.15277947f, 0.15060252f, 0.16552830f, 0.15281074f, -0.02307128f, -0.25236952f, -0.27071860f, 0.08039757f, 
    0.03876751f, 0.39883989f, 0.11326963f, 0.30212653f, 0.00068854f, -0.14085002f, 0.12942512f, 0.08893135f, 
    0.01071342f, 0.27752599f, 0.08148351f, 0.17006774f, 0.31072754f, 0.07878166f, -0.07352345f, -0.14709589f, 
    0.02946535f, 0.04831939f, -0.15243861f, -0.01693420f, 0.37911910f, 0.38743719f, 0.15466276f, -0.42162824f, 
    -0.33447719f, -0.37598374f, 0.22334018f, 0.01752673f, 0.20641077f, -0.12292235f, 0.12961164f, 0.11780989f, 
    -0.24362354f, -0.10297739f, 0.09337509f, -0.18025951f, 0.21795006f, 0.08886757f, -0.03709288f, 0.25717670f, 
    -0.06032878f, -0.23534164f, 0.06803026f, 0.25184521f, -0.19923633f, 0.24404253f, 0.04366588f, 0.10370372f, 
    0.15264653f, 0.09382410f, 0.17265202f, -0.08152749f, -0.12444085f, -0.10291708f, -0.31778708f, -0.26028502f, 
    -0.15406610f, 0.38272026f, 0.29862535f, -0.19530204f, 0.13659878f, 0.35050443f, 0.23323445f, 0.02903807f, 
    0.13221447f, -0.02376659f, 0.11481342f, -0.07143869f, -0.04478366f, -0.48138547f, -0.10225566f, -0.05336780f, 
    0.17616269f, 0.17438915f, 0.11902848f, 0.20898011f, 0.03596511f, -0.41564718f, -0.17189011f, -0.19255382f, 
    -0.01293265f, 0.18166043f, -0.08716701f, 0.01055650f, 0.27028260f, 0.22915900f, -0.48972774f, -0.24586917f, 
    0.14926755f, 0.03766343f, 0.05670177f, -0.03673821f, -0.04370897f, 0.11413418f, 0.29009977f, -0.16010949f, 
    -0.30512244f, -0.65367019f, 0.07378986f, -0.20067178f, -0.04830424f, 0.06835414f, -0.24890020f, -0.11289173f, 
    -0.36872521f, -0.10602981f, -0.28927720f, -0.00176210f, 0.06029203f, -0.14249747f, 0.03928586f, 0.09370758f, 
    0.11313044f, 0.12819463f, 0.33522016f, 0.76101160f, 0.40100431f, -0.07049778f, -0.22386463f, 0.22145125f, 
    0.35025629f, 0.11379000f, -0.03068150f, -0.07017281f, 0.16291484f, -0.24834552f, -0.10606647f, -0.08568523f, 
    0.07829570f, -0.03775264f, -0.06754056f, -0.00973243f, -0.38155079f, 0.19234845f, 0.21044944f, -0.00848868f, 
    0.06507681f, 0.19705717f, 0.13458261f, 0.03430289f, -0.02309965f, -0.15429397f, -0.84213275f, -0.00158084f, 
    -0.11831188f, 0.10399568f, 0.16103183f, 0.00228711f, 0.08013985f, 0.23964085f, -0.01504833f, -0.25068367f, 
    -0.10853728f, 0.09934846f, -0.04560282f, -0.14562675f, 0.09372763f, -0.07078312f, -0.21432664f, 0.09152836f, 
    0.09617162f, -0.11279752f, 0.10896749f, -0.00453113f, -0.13239004f, -0.29805350f, -0.16824651f, -0.10438924f, 
    0.20070462f, 0.12739997f, -0.02509450f, -0.14235669f, -0.02099611f, 0.22428812f, 0.14601317f, 0.16471715f, 
    0.60211849f, -0.39645925f, 0.07564165f, 0.08318674f, 0.01937426f, 0.20645279f, 0.03717289f, -0.02297758f, 
    -0.13920754f, -0.26383212f, -0.74176139f, 0.17907333f, 0.09743791f, -0.02926433f, -0.07412923f, 0.23083001f, 
    -0.02774792f, 0.09024722f, -0.51408553f, -0.47193953f, 0.04050352f, -0.22880898f, 0.11659104f, -0.27069443f, 
    0.06187161f, -0.09740482f, -0.21607624f, -0.20033526f, -0.49687937f, -0.16954361f, 0.05798449f, -0.06003081f, 
    0.23471175f, 0.23239222f, 0.18700604f, 0.16629210f, -0.26922962f, 0.27961984f, -0.43789047f, -0.14786789f, 
    -0.30713594f, -0.25911257f, 0.05223148f, 0.02930210f, 0.02733155f, 0.44947526f, -0.40426591f, -0.63432270f, 
    -0.03782462f, -0.01894624f, 0.15398870f, -0.09841048f, -0.12304513f, -0.03957978f, 0.68218374f, 0.36593783f, 
    -0.87351602f, 0.07312157f, 0.25309244f, 0.25500545f, 0.00410838f, -0.01459282f, -0.10136889f, -0.61476189f, 
    -0.18264571f, 0.04035586f, -0.15960604f, -0.33282411f, 0.04319736f, 0.19040699f, -0.09580493f, 0.24444449f, 
    -0.04161519f, 0.04112240f, -0.07435004f, -0.04307314f, -0.06960535f, -0.04320466f, 0.06490249f, -0.02908628f, 
    -0.03913700f, -0.02319664f, -0.08720725f, 0.05907581f, -0.06855619f, -0.00588156f, -0.07459793f, -0.00685046f, 
    0.03014944f, -0.07929140f, 0.01375308f, -0.06827980f, -0.07714083f, -0.07010806f, -0.03656148f, 0.03629319f, 
    0.02400020f, 0.05910093f, 0.05654862f, 0.01912786f, -0.02784441f, -0.07185291f, -0.01577206f, -0.06990346f, 
    -0.04412990f, 0.06349013f, 0.04141412f, 0.04854065f, -0.00957210f, -0.08872610f, -0.03248104f, -0.03507729f, 
    -0.02011531f, -0.05266224f, 0.05131863f, 0.01272788f, 0.02054380f, -0.02817192f, -0.06592178f, 0.00371880f, 
    0.08075932f, -0.05261712f, 0.03539087f, -0.08233778f, -0.08055445f, -0.01805959f, -0.03910299f, -0.03768067f, 
    0.03095294f, 0.02235078f, -0.07103994f, -0.02054525f, 0.04611905f, 0.07485837f, -0.06901806f, -0.04305237f, 
    -0.02249969f, -0.01377222f, -0.01240021f, -0.03421573f, 0.06780318f, -0.01796837f, 0.06300448f, -0.04509759f, 
    0.07068884f, -0.03091985f, 0.02957704f, 0.06468313f, 0.06109517f, -0.05379630f, -0.02397321f, 0.03092582f, 
    0.03761354f, -0.02938691f, -0.04109072f, 0.03353704f, -0.06842349f, -0.03831527f, -0.07916203f, -0.03951566f, 
    -0.05153013f, -0.00183051f, -0.02394830f, 0.07891691f, -0.01867789f, 0.01888606f, -0.08227088f, 0.02686541f, 
    0.00763864f, -0.04892329f, -0.01652772f, 0.06507110f, -0.03435492f, 0.02846366f, -0.07974578f, -0.08010478f, 
    0.00833550f, -0.04992456f, 0.04132668f, -0.04132539f, -0.04792861f, 0.00095189f, -0.02826253f, -0.07980095f, 
    -0.02138189f, 0.06451751f, -0.04605012f, 0.00882096f, -0.06964769f, -0.05735753f, -0.00643360f, 0.04390702f, 
    -0.03872751f, -0.04157483f, 0.03021754f, -0.03804307f, -0.06961680f, -0.00449974f, 0.05096717f, 0.02373993f, 
    -0.01058092f, -0.07650916f, -0.00653808f, 0.02864090f, 0.05894208f, 0.07187074f, 0.05233917f, -0.06832568f, 
    0.03427541f, 0.03675893f, -0.07348832f, 0.05594403f, -0.00924637f, -0.00164644f, -0.06150129f, 0.05264241f, 
    0.77038777f, -0.15421109f, -0.39227179f, 0.05867491f, -0.07038973f, -0.07796586f, 0.09881654f, 0.11404511f, 
    0.16127938f, -0.28502601f, -0.34673145f, 0.14375886f, 0.13910846f, -0.12618266f, 0.12308710f, 0.09576719f, 
    -0.00662813f, 0.23674032f, -0.24755290f, -0.15912315f, -0.30266500f, -0.09598337f, 0.06124362f, -0.03249323f, 
    -0.12735695f, -0.10866376f, -0.05307665f, 0.27068827f, -0.34069943f, 0.29334968f, -0.13025142f, -0.07873861f, 
    -0.15262306f, 0.02071832f, -0.14870119f, -0.16611610f, 0.13009669f, -0.01436566f, 0.12179907f, 0.06337496f, 
    -0.02175627f, 0.02550003f, -0.15007602f, -0.12254748f, 0.03624017f, -0.30063552f, 0.03711593f, -0.30819729f, 
    -0.21429598f, -0.09107365f, 0.04585584f, 0.21430489f, -0.06881350f, 0.09015159f, -0.00164604f, 0.10619406f, 
    0.08415138f, -0.09437609f, -0.09907336f, -0.18873487f, 0.04461021f, -0.13853389f, -0.25909230f, 0.41332048f, 
    0.20022739f, 0.03683160f, 0.11884758f, -0.59925032f, -0.25705457f, 0.02494163f, 0.19558029f, -0.12708656f, 
    -0.36410317f, 0.42598018f, -0.00830706f, 0.15571027f, 0.11913854f, -0.22696266f, 0.08792234f, 0.03182850f, 
    -0.22530754f, 0.19908346f, 0.79146183f, -0.00454952f, -0.19458076f, 0.20815718f, 0.01425714f, 0.16047408f, 
    -0.09129757f, -0.13461350f, 0.72116584f, 0.10526601f, 0.31445974f, -0.03013028f, 0.05750617f, 0.04314214f, 
    0.12824181f, -0.10699429f, 0.22303224f, -0.49881709f, -0.13596022f, -0.17199010f, -0.06948682f, -0.19234447f, 
    -0.05682584f, -0.00445968f, 0.31004411f, 0.29009408f, 0.66515493f, -0.02253634f, -0.10676436f, 0.02999400f, 
    -0.20629036f, -0.25646576f, -0.20503820f, 0.09661035f, -0.09247514f, 0.00277312f, 0.46592504f, 0.22682942f, 
    -0.00965856f, 0.06955791f, 0.17555347f, -0.03409176f, -0.10293497f, -0.40123439f, -0.08484134f, 0.41025710f, 
    -0.28793287f, -0.15301999f, 0.15052442f, 0.13237529f, -0.21179862f, -0.12069169f, -0.26788530f, 0.16124550f, 
    -0.05447629f, 0.02068284f, -0.25421533f, 0.04016015f, -0.08227390f, 0.18852453f, 0.19258697f, -0.06788065f, 
    0.18396094f, 0.14984421f, -0.06947946f, -0.19153772f, -0.12094370f, -0.01441472f, 0.16062959f, 0.17316681f, 
    -0.07178225f, 0.09100819f, -0.08810197f, 0.48209688f, 0.10429591f, 0.11354411f, 0.15624152f, -0.12010339f, 
    0.12851591f, 0.26205418f, 0.17339975f, 0.18906479f, 0.42558494f, -0.11473510f, -0.19648659f, -0.17621148f, 
    -0.05011507f, -0.02983219f, 0.16592515f, 0.00923807f, -0.21889716f, 0.46696353f, -0.14544627f, -0.11279383f, 
    0.01142352f, 0.33915904f, 0.11811388f, 0.42039016f, 0.19871679f, 0.49212015f, 0.26003176f, 0.00057420f, 
    -0.06544375f, -0.01965675f, 0.20665309f, 0.03954145f, 0.12497016f, -0.44482517f, -0.53266954f, -0.05056341f, 
    0.01971732f, 0.06001322f, -0.04037646f, 0.04410779f, 0.17475000f, 0.03434428f, 0.39473078f, 0.09815123f, 
    -0.02278332f, -0.14671551f, 0.08171450f, 0.03456635f, 0.14116992f, 0.09190715f, 0.06832857f, 0.06311619f, 
    -0.34464872f, 0.34087130f, -0.24779603f, -0.26923963f, -0.39905635f, 0.10000908f, -0.00682553f, 0.09154263f, 
    -0.07971060f, -0.36075306f, -0.26007816f, 0.10651870f, 0.01532660f, 0.27250582f, 0.11189620f, 0.34013885f, 
    0.13499534f, -0.48777181f, -1.03469670f, -0.90316296f, -0.06554706f, -0.10273439f, 0.15742421f, 0.00744107f, 
    -0.02168569f, -0.14213946f, 0.41555598f, 0.18026736f, 0.62413239f, -0.12191667f, -0.23063956f, -0.12664486f, 
    -0.06288936f, -0.10200863f, 0.32581806f, -0.15952733f, -0.56117380f, 0.47917274f, -0.06523085f, -0.18186706f, 
    -0.27395254f, -0.02391279f, 0.00853094f, 0.18520576f, 0.09356807f, 0.46833485f, 0.47676182f, -0.29248211f, 
    -0.13613692f, -0.17206155f, 0.03891183f, 0.23549429f, 0.23079379f, -0.95046264f, -0.79881287f, 0.49091643f, 
    -0.16411619f, -0.05182344f, -0.04426602f, -0.18867755f, -0.08322988f, -0.04738863f, -0.69477469f, -0.30134711f, 
    -0.31949812f, 0.06845864f, 0.19719203f, -0.10044620f, 0.08796959f, -0.05098663f, -0.17171979f, 0.39073092f, 
    -0.05919860f, 0.35605055f, -0.23360133f, -0.31215888f, -0.19636682f, 0.24846399f, -0.02362358f, -0.13603473f, 
    -0.07255107f, 0.44349134f, 0.55691677f, 0.49413690f, -0.22176765f, -0.07459801f, 0.03239773f, 0.02778472f, 
    -0.13756013f, -0.53866166f, -0.34574458f, -0.47629264f, 0.16088590f, 0.11108203f, 0.11380924f, -0.20248061f, 
    -0.02116549f, -0.18391612f, 0.23485990f, -0.14049450f, 0.27990729f, 0.15196472f, -0.07522176f, 0.03148590f, 
    -0.21844272f, -0.05569863f, -0.17460130f, -0.14097016f, -0.36546549f, -0.34497029f, 0.07084389f, 0.01223312f, 
    0.02546922f, 0.18458357f, 0.01766883f, 0.20288616f, 0.25902188f, 0.10323982f, -0.12551636f, 0.00229278f, 
    0.02954342f, 0.02359624f, 0.01886622f, -0.09587175f, -0.23262538f, 0.29905841f, -0.10501022f, -0.01325900f, 
    0.17922831f, -0.19051832f, 0.05794182f, 0.14408177f, 0.19529355f, 0.01806774f, 0.29233685f, 0.04208507f, 
    0.32725528f, -0.06884621f, -0.08135890f, 0.02358743f, 0.23742720f, -0.12330855f, -0.32574874f, -0.04037075f, 
    -0.12187207f, 0.45249230f, 0.04948902f, 0.03478238f, 0.08990440f, -0.07721244f, 0.26789102f, 0.02957574f, 
    0.34700206f, -0.15245412f, -0.13560659f, 0.22273284f, 0.12233328f, 0.12849934f, 0.11911456f, 0.04349988f, 
    0.21859245f, -0.13592882f, -0.34694445f, -0.28367424f, -0.01565133f, 0.09497523f, -0.04165218f, 0.12554911f, 
    0.32677954f, 0.08803876f, 0.50332749f, -0.42713681f, 0.02617909f, -0.04402351f, 0.26350898f, -0.19395618f, 
    -0.07361270f, -0.32936963f, -0.25078332f, 0.23740542f, -0.13349365f, -0.56413209f, 0.12719281f, 0.06976428f, 
    -0.01967220f, 0.03251020f, 0.30752656f, 0.22048931f, 0.14092900f, -0.38671106f, 0.06674683f, 0.14955340f, 
    -0.20063576f, 0.01757537f, 0.07092343f, 0.08677847f, -0.01966388f, -0.33693293f, -0.41866389f, -0.36876959f, 
    -0.02140099f, 0.28225440f, 0.01897664f, 0.04870917f, -0.17033859f, 0.18298425f, 0.14483292f, 0.02578253f, 
    0.08714556f, -0.22647505f, -0.33588943f, -0.00454085f, 0.10381653f, -0.12358221f, -0.04609800f, -0.20559995f, 
    -0.14547426f, 0.25461701f, -0.04076101f, -0.17241526f, -0.05028744f, -0.03936610f, -0.04466699f, 0.01031336f, 
    -0.43456787f, 0.01325815f, 0.15595672f, 0.05018327f, -0.03902223f, -0.19133285f, -0.28315765f, -0.09845692f, 
    -0.06782800f, -0.00261370f, 0.01748284f, 0.48603961f, 0.10061986f, -0.14647523f, 0.03885236f, 0.09547038f, 
    0.14799246f, 0.23828501f, 0.09453528f, -0.06167909f, 0.04896281f, 0.30730829f, 0.11960725f, -0.03750057f, 
    -0.07755648f, -0.08084434f, 0.16449684f, -0.23097587f, 0.15504591f, 0.26781014f, 0.21417214f, 0.04849289f, 
    -0.06749533f, 0.18594897f, -0.14289452f, -0.02320881f, 0.14516430f, -0.04483267f, 0.36521798f, 0.15144551f, 
    0.08562213f, 0.21127418f, 0.03991492f, 0.33780873f, 0.05693606f, 0.06389236f, -0.14913400f, 0.04146466f, 
    0.15690531f, 0.09703345f, 0.13332716f, 0.23852456f, 0.27409905f, 0.13857929f, -0.16963306f, -0.09561141f, 
    0.08320825f, -0.05457560f, 0.01085499f, -0.26357841f, 0.35377413f, 0.02822197f, 0.11189727f, 0.21888003f, 
    0.17432575f, 0.23771366f, 0.22768232f, 0.15052244f, -0.05852968f, -0.05950433f, -0.14465785f, -0.00132455f, 
    -0.19727376f, -0.16116038f, -0.12155217f, 0.26023379f, 0.15918097f, 0.04442901f, 0.17507173f, 0.02123879f, 
    0.18229999f, -0.31374159f, 0.16439584f, 0.50005233f, 0.11054818f, 0.29364586f, 0.02100903f, -0.09775652f, 
    -0.01947420f, -0.19303510f, -0.15528347f, -0.00006183f, -0.24926279f, -0.21307747f, -0.03404035f, -0.22404291f, 
    0.18544224f, 0.08418715f, 0.24335758f, -0.07756109f, -0.16193859f, 0.02070439f, 0.21238504f, -0.05624129f, 
    0.26194286f, 0.03761284f, 0.40265808f, -0.15678620f, 0.18286371f, 0.23509091f, 0.34334660f, 0.20551406f, 
    -0.13724072f, -0.11715702f, 0.02534635f, 0.11543240f, 0.12006658f, -0.41338104f, -0.22052367f, 0.25833908f, 
    0.15428154f, -0.03083900f, 0.03871170f, 0.09058090f, 0.02362273f, 0.00390061f, 0.10759046f, -0.10082319f, 
    -0.04296441f, 0.16139491f, -0.04520642f, 0.07642426f, -0.02236758f, -0.08786381f, 0.04985589f, -0.13122924f, 
    -0.00760591f, 0.21252093f, 0.25630501f, -0.05926703f, -0.16330697f, -0.02419817f, 0.04926894f, -0.21305947f, 
    0.71267372f, 0.03767838f, -0.09519799f, -0.05699309f, -0.15554325f, -0.23514761f, 0.06747161f, -0.05022272f, 
    -0.06384518f, 0.14456329f, -0.17298993f, -0.01693183f, 0.16193624f, 0.02883775f, 0.08324102f, -0.11616414f, 
    -0.23485152f, 0.00798007f, 0.23379493f, 0.17397398f, 0.38475394f, 0.15610836f, -0.06172647f, -0.22835073f, 
    -0.11098114f, 0.12631109f, -0.12898129f, 0.19310559f, 0.12880720f, 0.61823493f, -0.09785298f, -0.07732482f, 
    -0.02903160f, 0.27288771f, -0.15912950f, -0.33569941f, -0.56456023f, -0.17069685f, -0.16000149f, -0.01638030f, 
    0.11278178f, -0.04129210f, -0.01380250f, -0.11345171f, -0.28069082f, 0.13912047f, 0.28049031f, 0.44183505f, 
    -0.23621048f, -0.02731345f, 0.05715999f, -0.23770820f, 0.03347462f, 0.10930617f, 0.22900943f, 0.29253095f, 
    0.11345337f, 0.29536965f, 0.24058527f, 0.05926460f, -0.05689560f, 0.02220687f, 0.00051643f, -0.07867647f, 
    0.11166197f, -0.11825590f, -0.22559954f, -0.28660861f, -0.29276407f, -0.17530668f, -0.02752159f, -0.12831053f, 
    0.35981792f, 0.06578351f, 0.25240511f, -0.25798485f, 0.08103706f, -0.07579178f, 0.01231452f, 0.27645174f, 
    0.17813244f, -0.23447964f, 0.02401954f, 0.39939907f, -0.09897660f, 0.09516725f, -0.10855331f, 0.06263942f, 
    0.11275373f, 0.31088719f, 0.02217475f, 0.19489531f, 0.98512250f, 0.24334173f, 0.40668312f, -0.22940879f, 
    -0.09135365f, 0.07592253f, 0.04451372f, 0.10482655f, 0.15337656f, 0.60960400f, -0.45850748f, -0.08109295f, 
    0.03024332f, -0.39716589f, 0.17625837f, -0.10381477f, -0.27067775f, 0.28247413f, 0.83222717f, -0.06314757f, 
    0.05165280f, -0.04262397f, 0.04316444f, 0.24331845f, 0.02503118f, -0.41451067f, 0.25211960f, -0.23969133f, 
    -0.02471284f, 0.08211400f, -0.12452926f, 0.15456808f, 0.12897594f, -0.13787672f, -0.09023940f, 0.03530981f, 
    -0.03204549f, -0.11656229f, -0.10614464f, -0.19440477f, 0.10959418f, -0.04548095f, 0.15512334f, 0.07804882f, 
    0.23207197f, -0.03637068f, 0.37553576f, -0.00163548f, -0.42817003f, -0.05327778f, -0.01431104f, -0.00887125f, 
    0.33507228f, 0.05079941f, -0.48026618f, -0.04703432f, -0.25305814f, -0.05857962f, 0.05116273f, -0.05615235f, 
    -0.07231059f, -0.03763236f, 0.13281779f, 0.06464358f, 0.36785623f, -0.02134652f, 0.15650739f, -0.03450716f, 
    0.22379409f, -0.04560811f, -0.14623196f, 0.24949454f, 0.28721237f, -0.09154717f, -0.50107068f, -0.21718951f, 
    -0.23734745f, -0.07983657f, 0.08370466f, -0.34100112f, -0.24905865f, -0.14872289f, 0.16894339f, 0.19628288f, 
    -0.06452639f, 0.05523470f, -0.06625604f, -0.10655466f, 0.12967210f, 0.03912087f, -0.78903264f, 0.01976111f, 
    0.08697738f, 0.11288730f, -0.10588649f, 0.06484845f, 0.00476815f, 0.33174017f, 0.12226780f, -0.06868291f, 
    0.17876029f, -0.20129727f, -0.00915121f, -0.03892927f, -0.00945653f, 0.02248598f, 0.12444951f, -0.05651660f, 
    0.13590913f, -0.05178733f, 0.08892335f, 0.05929853f, 0.16291419f, 0.44452217f, 0.24093026f, 0.09100482f, 
    0.26486519f, 0.02039970f, 0.16568558f, -0.22137061f, 0.00491844f, 0.06999843f, -0.10429558f, 0.00373561f, 
    0.38404477f, 0.05874508f, 0.00710142f, -0.11247781f, 0.02387049f, -0.36797991f, -0.07769746f, -0.14076687f, 
    -0.19548918f, 0.20123921f, -0.29670587f, -0.38792360f, -0.06015863f, 0.03645469f, -0.07321385f, 0.05295158f, 
    0.05398332f, -0.17199035f, -0.00454584f, -0.11873931f, 0.38525558f, 0.03978270f, 0.13189188f, -0.16027901f, 
    0.03606686f, 0.14148962f, -0.01126336f, 0.15894310f, 0.18840328f, -0.22272304f, 0.08797647f, 0.03163646f, 
    -0.00697967f, -0.24657980f, 0.15675630f, 0.21985775f, 0.48781905f, 0.87367892f, -0.20513649f, 0.03980091f, 
    -0.25830957f, 0.06149618f, 0.01280926f, 0.09406658f, 0.13684455f, 0.11671563f, -0.11863254f, -0.30041096f, 
    -0.11592364f, -0.09074609f, 0.12214091f, 0.09715176f, 0.01337472f, 0.03387385f, -0.05825513f, -0.31560525f, 
    -0.19109093f, 0.04216693f, 0.25734240f, 0.04506315f, -0.03948513f, 0.23897257f, 0.25593054f, -0.09444186f, 
    0.07441684f, -0.06411482f, 0.11501783f, 0.17899223f, -0.01104902f, -0.19548383f, -0.27429596f, -0.17359333f, 
    0.83124930f, 0.44775063f, 0.46093750f, 0.23454653f, -0.06064796f, 0.42718354f, 0.11309730f, 0.26431245f, 
    -0.12792456f, -0.21654621f, -1.13060200f, -0.86132389f, 0.17568384f, -0.04716834f, 0.09944806f, -0.08992079f, 
    -0.23186742f, -0.25571349f, 0.11194167f, -0.62962437f, -1.52608263f, 0.10795872f, -0.15503877f, 0.13048200f, 
    0.10270686f, 0.10255404f, 0.09851807f, 0.21403839f, 0.00216333f, 0.19062039f, 0.25371653f, -0.20010212f, 
    0.18965015f, 0.17041454f, 0.03525600f, 0.12126918f, -0.10921266f, 0.06366041f, 0.03467498f, 0.00068758f, 
    -0.04897112f, -0.14232677f, -0.09029798f, -0.14769316f, 0.05517895f, -0.38322198f, -0.15648563f, -0.23711935f, 
    -0.16170253f, 0.32482922f, -0.07893044f, -0.01176904f, 0.20066607f, 0.15856372f, 0.29601371f, -0.08689707f, 
    -0.31295937f, 0.03602221f, 0.14184918f, -0.08352990f, 0.07249764f, 0.35319006f, 0.14278126f, 0.24069031f, 
    -0.21333341f, -0.02198288f, -0.05299067f, 0.02643153f, 0.16025309f, -0.04252739f, -0.25710371f, 0.26356205f, 
    0.15207244f, -0.40749091f, -0.06015174f, -0.11453092f, 0.14489935f, 0.07267716f, -0.00046914f, 0.08473006f, 
    0.15925437f, -0.59523338f, 0.13714124f, -0.37038738f, -0.13009536f, -0.04987783f, 0.35345316f, 0.10008633f, 
    -0.03725188f, 0.02306450f, -0.12141607f, -0.10779807f, -0.27938065f, -0.21175717f, 0.21220802f, -0.13542877f, 
    -0.19262221f, 0.07940149f, 0.15812062f, -1.00115740f, -0.29330501f, 0.13761686f, 0.20469387f, 0.24901639f, 
    -0.34527361f, -0.09557526f, 0.06003981f, -0.15254672f, 0.31812194f, 0.25812256f, 0.10650729f, -0.18708821f, 
    0.06630968f, -0.05279872f, 0.08111724f, 0.15073580f, 0.09997027f, 0.28910387f, -0.46602151f, -0.38980049f, 
    -0.09354812f, 0.07132452f, -0.34318322f, 0.04011262f, 0.16040774f, 0.18797483f, 0.24175616f, -0.25527185f, 
    0.01036424f, -0.46671918f, -0.14169469f, -0.49847391f, -0.13546111f, 0.04922298f, 0.23772998f, -0.18279697f, 
    -0.04973316f, -0.28066450f, 0.01054594f, -0.22566856f, -0.06480189f, 0.20362632f, -0.02469778f, 0.16436012f, 
    -0.22354206f, -0.51275563f, -0.70828515f, -0.01342360f, -0.36585975f, -0.01340121f, -0.00296006f, -0.16852841f, 
    -0.00312499f, -0.03833065f, -0.08595841f, -0.55960596f, 0.03678633f, 0.05266740f, 0.10156321f, 0.03152892f, 
    -0.15066333f, 0.18352120f, 0.08456881f, 0.34568322f, -0.16058958f, -0.05079598f, -0.10788677f, -0.22121254f, 
    0.00721170f, -0.09122157f, 0.04982656f, 0.16036624f, 0.48502246f, 0.28332072f, -0.02060694f, 0.20211056f, 
    0.07371097f, 0.48344532f, 0.09265925f, 0.25886187f, -0.09654212f, 0.02026207f, -0.06645153f, -0.04810889f, 
    0.20038718f, 0.32107741f, 0.19317088f, -0.00058101f, -0.18070142f, 0.38292199f, 0.13745816f, 0.13451487f, 
    -0.03258617f, 0.04534525f, -0.19119614f, 0.12500261f, 0.23962365f, 0.26971650f, -0.09291582f, -0.13100155f, 
    -0.20737334f, 0.00089070f, -0.05009975f, -0.02226418f, 0.27627838f, -0.05827172f, 0.21904825f, 0.29277903f, 
    0.21435204f, -0.02430254f, 0.04539863f, 0.02308735f, -0.14775820f, -0.14489767f, -0.38143897f, -0.31531021f, 
    0.23532888f, 0.22126055f, -0.08740113f, -0.13422920f, -0.04461030f, -0.04491525f, 0.17353578f, 0.31534982f, 
    0.25117722f, -0.58174604f, 0.29251525f, -0.21354727f, 0.00415353f, 0.05225945f, -0.10281664f, 0.08363614f, 
    0.07639969f, 0.02638443f, -0.49034292f, 0.07307683f, -0.07406923f, -0.23380585f, 0.04459762f, 0.17605853f, 
    0.01091953f, 0.07378820f, 0.07620727f, 0.07382695f, 0.34232545f, 0.00068073f, 0.06414009f, 0.16049232f, 
    -0.07255083f, 0.27952957f, 0.09907041f, 0.02715146f, -0.01529756f, 0.35611540f, 0.02865485f, 0.12130903f, 
    -0.17876242f, -0.22013836f, 0.13365611f, 0.04250234f, 0.00951717f, -0.22867605f, -0.05427705f, 0.17102197f, 
    -0.07945359f, 0.02557630f, -0.33254567f, 0.08247247f, -0.12696518f, 0.04416664f, 0.05097086f, -0.22478978f, 
    0.30302134f, 0.07786683f, -0.03286466f, 0.13526835f, -0.00841586f, -0.07395908f, 0.09458716f, -0.12101612f, 
    -0.05640006f, -0.20606622f, -0.04113120f, 0.02176750f, -0.34197015f, -0.13887627f, -0.04194036f, -0.49691802f, 
    0.03610203f, -0.06333914f, 0.01107346f, -0.07953337f, -0.05045214f, 0.00332554f, 0.04663769f, 0.05692247f, 
    -0.03949963f, -0.05496284f, -0.07213242f, -0.05231633f, -0.07037149f, -0.06187206f, -0.06918360f, 0.03101151f, 
    0.07585444f, 0.00393615f, -0.07132912f, -0.04627914f, -0.00465130f, 0.05504918f, -0.02705305f, 0.05710677f, 
    -0.07595277f, 0.04931858f, -0.06852368f, 0.03846477f, 0.02627507f, -0.05135154f, 0.04398675f, 0.00193431f, 
    -0.08646535f, 0.04507541f, -0.04698194f, 0.02058136f, -0.00919657f, -0.06321862f, -0.02459766f, 0.00967006f, 
    0.06910031f, -0.07935534f, -0.08454810f, -0.08571932f, -0.05228595f, -0.07092403f, -0.03719082f, 0.00776506f, 
    0.06776800f, -0.08542710f, 0.00887557f, -0.00148129f, -0.08764591f, -0.03255814f, 0.00313859f, 0.06467754f, 
    0.05428287f, -0.06451774f, 0.01412431f, -0.05999929f, 0.02608666f, -0.02811369f, 0.02112233f, -0.02421695f, 
    -0.07380803f, -0.06769054f, 0.02117191f, -0.05934847f, 0.01856690f, -0.08242413f, 0.06909771f, 0.00651726f, 
    -0.04334598f, -0.08364511f, -0.00014376f, 0.07379919f, -0.00767257f, -0.00488463f, -0.03304606f, 0.00063823f, 
    -0.03496343f, 0.05633106f, 0.01486825f, 0.06890635f, -0.00389185f, -0.03326489f, 0.06264381f, 0.07680669f, 
    -0.04624666f, -0.04015931f, -0.04576935f, 0.03631545f, -0.04425623f, 0.03593987f, 0.05812425f, 0.07674932f, 
    -0.06312563f, 0.04816334f, 0.04202563f, -0.07535128f, -0.03725415f, -0.04051861f, -0.07084352f, 0.00546090f, 
    0.07007825f, -0.08610744f, 0.06513723f, -0.07983361f, -0.05762271f, 0.02777005f, -0.06325566f, 0.02368904f, 
    -0.03175664f, 0.01786971f, 0.02783780f, 0.08311224f, 0.03824808f, 0.07692065f, -0.07454327f, -0.01093435f, 
    -0.08229871f, -0.03393302f, -0.02571397f, -0.00571735f, -0.03764588f, 0.07491659f, -0.07942280f, 0.03254789f, 
    -0.02256970f, -0.03541664f, -0.08659633f, 0.03832258f, 0.05213520f, -0.01043463f, -0.06622048f, 0.00402904f, 
    0.05638096f, 0.06324216f, -0.06721793f, 0.04814444f, -0.06316640f, -0.00946028f, -0.02773266f, 0.00910363f, 
    0.40707895f, -0.00445258f, -0.08569063f, -0.03134770f, -0.20640068f, 0.21963066f, -0.16098678f, 0.04400121f, 
    0.00231363f, 0.08783186f, 0.47075078f, -0.76030642f, -0.05400474f, 0.27922729f, -0.01084668f, 0.02760107f, 
    0.07556862f, 0.26944628f, -0.37514913f, 0.31936187f, -0.26736933f, 0.06024714f, -0.06970281f, 0.12648670f, 
    0.14657129f, 0.05914355f, -0.00609647f, -0.02102801f, 0.03043418f, -0.33045682f, 0.12019362f, -0.34336379f, 
    -0.01372696f, 0.18098199f, -0.15151180f, -0.00023133f, 0.02725966f, 0.22460899f, -0.00270561f, -0.15064943f, 
    0.17737943f, 0.04857595f, 0.12804808f, 0.11608782f, 0.00600544f, -0.16592103f, -0.45679039f, 0.12057149f, 
    0.22980942f, 0.18973421f, 0.09492101f, 0.05366217f, 0.09598315f, -0.04206497f, 0.11521868f, 0.06619672f, 
    -0.08254194f, -0.09612770f, -0.00726002f, 0.24014501f, 0.08830439f, 0.18808070f, 0.09734897f, -0.02176726f, 
    0.24683075f, 0.00519538f, 0.00328557f, 0.00030338f, -0.11449273f, 0.07371199f, -0.03128114f, 0.06487145f, 
    -0.69246918f, -0.13114741f, 0.23441564f, 0.09472430f, 0.11723584f, -0.04202312f, -0.14157043f, -0.04500123f, 
    -0.07831788f, -0.66445863f, -0.08058599f, 0.22702517f, -0.11196302f, 0.12741566f, -0.07414400f, -0.02005874f, 
    -0.09316886f, -0.07792684f, -0.25391540f, 0.05050433f, -0.21272820f, 0.11071154f, 0.19999069f, -0.14702965f, 
    0.29525492f, 0.09223151f, -0.31320897f, -0.48593619f, -0.04366589f, 0.15143058f, -0.00583492f, 0.14026614f, 
    0.15075886f, 0.05640694f, 0.08311480f, -0.06455862f, -0.22773318f, 0.54232216f, -0.27808711f, -0.09273039f, 
    -0.00626705f, 0.10122886f, -0.07280170f, 0.02487031f, 0.15666559f, -0.01002335f, -0.67488617f, -0.04834439f, 
    -0.14595458f, 0.10928642f, -0.25143433f, 0.15198751f, -0.09367491f, 0.11971051f, 0.57815456f, -0.24869882f, 
    0.10131726f, -0.08233041f, 0.05497700f, -0.22212030f, 0.04622294f, 0.24390887f, -0.03051730f, -0.32645711f, 
    0.20482515f, 0.36745954f, -0.01600102f, -0.11444698f, 0.01390869f, -0.24125294f, -0.04107786f, 0.03325115f, 
    -0.06539021f, -0.37873524f, 0.00684605f, 0.02531907f, 0.08075110f, 0.41448551f, 0.20708539f, 0.16630265f, 
    0.30967078f, -0.09324582f, -0.19670616f, 0.00492272f, 0.16399238f, -0.07808750f, -0.01728461f, 0.35222393f, 
    -0.07777531f, 0.26959744f, 0.11081342f, -0.14824164f, -0.01226909f, 0.13183638f, 0.08721974f, 0.38053158f, 
    -0.17039505f, -0.20589621f, -0.24655133f, -0.11496299f, 0.19005543f, -0.16875549f, 0.03623078f, 0.17084160f, 
    -0.08607569f, -0.19431265f, 0.00224473f, 0.08583169f, -0.00943245f, 0.33704615f, 0.67182684f, 0.42195216f, 
    0.16830614f, 0.15921006f, -0.00878300f, 0.07841501f, 0.22292572f, 0.04755322f, 0.28400105f, -0.10930583f, 
    -0.03710822f, -0.01042134f, 0.02215671f, 0.14542741f, 0.14473549f, -0.15234965f, 0.00567191f, -0.29107547f, 
    -0.02543989f, 0.06420558f, 0.14936656f, 0.11217346f, -0.09218717f, -0.43614370f, -0.93408984f, 0.10893843f, 
    -0.06261463f, -0.08798105f, 0.13766946f, 0.22589380f, 0.17837998f, -0.02893119f, 0.02994134f, -0.12463897f, 
    0.10996011f, 0.15109560f, -0.10139812f, -0.01411923f, -0.13794859f, 0.17441435f, -0.00098934f, 0.01818237f, 
    -0.03887997f, 0.36825770f, 0.52114403f, -0.15140785f, 0.04194152f, 0.00849849f, 0.01353550f, 0.05606647f, 
    0.12708363f, 0.02423710f, -0.07874447f, -0.43584257f, -0.24054199f, 0.30996054f, 0.18068434f, 0.11299557f, 
    -0.12824975f, -0.41159263f, -0.13872032f, -0.01078180f, 0.18326312f, -0.17653434f, 0.15643132f, 0.01104816f, 
    0.35632241f, 0.19541818f, 0.24519564f, 0.04000955f, -0.00783179f, -0.24563915f, -0.02354972f, 0.07368911f, 
    -0.01717076f, 0.07114300f, -0.17264487f, -0.22422704f, -0.07868879f, 0.08238918f, 0.27879295f, -0.40098745f, 
    -0.14351326f, -0.04208624f, 0.07685395f, 0.19828752f, -0.04340117f, -0.03734424f, 0.01867633f, 0.25509873f, 
    -0.14757636f, 0.13977529f, -0.19558328f, 0.03197869f, 0.04737882f, -0.14663126f, -0.25771937f, 0.21731034f, 
    -0.02362653f, -0.37839687f, 0.22758882f, 0.37545070f, 0.14104377f, 0.00815321f, -0.11367277f, 0.00386093f, 
    -0.81336969f, -0.21502100f, 0.41749179f, 0.10344351f, -0.13094176f, -0.15715060f, -0.14759183f, -0.10305338f, 
    0.08182943f, -0.27452892f, 0.38620853f, -0.15551029f, 0.02053552f, -0.06385547f, 0.28500330f, 0.11027121f, 
    0.06961915f, 0.00685928f, -0.42271599f, -0.16163149f, -0.01698065f, 0.10309079f, -0.01063955f, 0.07150643f, 
    -0.06408019f, -0.00678292f, 0.19951013f, 0.11023110f, 0.25772318f, 0.04250429f, -0.06682125f, 0.03989407f, 
    0.06366737f, 0.06467593f, -0.05154112f, 0.02875869f, 0.11815488f, 0.21172218f, 0.43066815f, 0.36425778f, 
    0.08731568f, 0.16596836f, 0.09384168f, -0.03682573f, -0.04352189f, -0.04312511f, -0.30997720f, -0.74737906f, 
    0.16012749f, -0.41537011f, -0.07765341f, -0.11880501f, 0.03305330f, -0.01251773f, -0.09289607f, -0.02980825f, 
    -0.11685205f, 0.04636892f, -0.26214513f, -0.04838429f, 0.09459027f, 0.22809260f, 0.12207391f, -0.03299006f, 
    -0.16909997f, -0.43343648f, 0.03630970f, -0.04536638f, 0.08893522f, -0.19907209f, 0.07753531f, 0.08250648f, 
    0.00742807f, -0.57175690f, -0.51905906f, 0.04579655f, 0.04567272f, -0.11834736f, 0.09627196f, -0.11265010f, 
    -0.11976693f, 0.11904346f, -0.69454849f, 0.15634614f, -0.08888375f, 0.15312161f, 0.20239216f, 0.16080636f, 
    0.10500762f, -0.19735110f, 0.38594997f, 0.08081941f, 0.37359533f, 0.08691210f, 0.08745202f, 0.08499594f, 
    0.16027883f, 0.14457925f, 0.16178197f, 0.51752353f, -0.18118332f, -0.44842032f, -0.03716028f, -0.19019307f, 
    -0.00545278f, -0.04767635f, 0.00484017f, 0.12952416f, 0.14173670f, 0.14227541f, 0.50629276f, 0.15022913f, 
    -0.16201276f, -0.05972057f, 0.20926268f, 0.00345681f, -0.03512042f, 0.29921165f, -0.04580768f, -0.27848274f, 
    0.27893358f, 0.02105205f, 0.07650485f, 0.06149955f, 0.20513496f, -0.15185861f, 0.24155188f, 0.20632440f, 
    -0.00486526f, 0.06186087f, -0.13021348f, 0.09383378f, -0.02078628f, 0.11344928f, 0.15324688f, 0.05445856f, 
    -0.20206332f, 0.56370503f, 0.15760404f, 0.09023137f, 0.26268008f, 0.12732176f, -0.30006108f, -0.04031543f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.52360344f, 0.31468931f, 0.29915270f, -0.01749007f, -0.12985697f, 0.18483618f, 0.14790465f, 0.20906450f, 
    -0.15146552f, 0.23071225f, 0.01861313f, 0.42933860f, 0.04433871f, 0.14696866f, -0.18300448f, 0.00639594f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.21940905f, -0.33354884f, 0.31615344f, -0.15619902f, 0.59343112f, 0.44030306f, 0.10882286f, -0.47453669f, 
    0.23606338f, 0.64940035f, 0.60268539f, -0.63000423f, -0.12862089f, 0.27023175f, -0.06164858f, -0.49248433f, 
    -0.49434289f, 0.25113508f, -0.11995484f, 0.13686714f, -0.98762220f, 0.07110029f, 0.19230069f, -0.00660833f, 
    0.20623226f, 0.02869503f, 0.61796147f, 0.48370683f, 0.23372339f, -0.28794810f, -0.36362508f, -0.22783729f, 
    1.07090390f, 0.35383248f, -0.69874960f, 0.19275805f, -0.29971191f, -0.14423183f, 0.57425511f, 0.07173223f, 
    -0.35002211f, -0.39653429f, -0.70685744f, -0.65981942f, 0.20376132f, -0.81526405f, 0.31841865f, -0.44303116f, 
    -0.50582302f, 0.19795926f, -0.91644210f, -0.03911289f, 0.73910743f, -0.49304557f, 0.07801162f, 0.25607410f, 
    -0.30610830f, -0.52302557f, 0.29910317f, -0.12389258f, 0.02039643f, -0.10847765f, 0.15325262f, 0.03727487f, 
    -0.96795940f, -0.48816639f, 0.22975878f, 0.19707590f, -0.06133942f, 0.61446828f, -0.12640661f, 0.09525253f, 
    -0.11193637f, -0.08218615f, -0.20459686f, -0.30612534f, -0.25260165f, -0.40254748f, 0.22164421f, 0.61038202f, 
    -0.13147636f, 0.08030304f, -0.72099328f, 0.12778853f, -0.63942730f, 0.09016576f, 0.33872300f, -0.06466210f, 
    -0.07066158f, 0.07564829f, -0.17128523f, 0.20765512f, -0.08709604f, 0.38028565f, -0.16419640f, 0.49681431f, 
    1.02505612f, -0.48785958f, 0.84905994f, 0.20103875f, -0.46076223f, -0.52783400f, -0.18293226f, -0.03228359f, 
    -0.31596869f, 0.36774722f, -0.93709821f, -0.14518903f, -0.03811834f, -0.74209529f, 0.38874090f, -0.46265528f, 
    0.18414854f, -0.38526708f, -0.71892530f, 0.08995127f, -0.00588851f, -0.27651337f, -0.24192201f, -0.48469546f, 
    0.58537525f, 0.09819898f, -0.06813873f, 0.50252753f, -0.01297467f, 0.25854629f, 0.09186179f, 0.33790502f, 
    -0.47287953f, 0.41506782f, 0.17750965f, -0.01500304f, -1.08027494f, -0.77160823f, -0.33570328f, 0.38374311f, 
    -0.50288045f, 0.66897053f, -0.80997938f, 0.34827623f, -0.02842586f, 0.39178002f, -0.47924346f, 0.27244705f, 
    -0.03724165f, -0.61092848f, 0.78432995f, 0.21966890f, 0.09349778f, -0.05489987f, -0.18249710f, -0.15977116f, 
    -0.37978679f, -0.30391204f, -0.25690261f, 0.13144037f, 0.06070084f, 1.19558299f, 0.54065013f, -0.18282737f, 
    -0.13683981f, 0.69220942f, -0.08909505f, -0.00315668f, -0.26859233f, 0.82769358f, -0.51634496f, 0.07025109f, 
    0.41829041f, -0.26391512f, -1.23315275f, -0.25545481f, 0.09137115f, 0.15900381f, -0.71475893f, -0.38487649f, 
    -0.28680888f, 0.32981446f, 0.06276342f, -0.24419305f, -0.10908496f, -1.06556273f, -0.73851615f, 0.32134005f, 
    0.23089145f, -0.97990167f, -0.09742445f, 0.06834137f, -0.16743051f, -0.05569714f, 0.30525210f, -0.78731042f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.35395178f, 0.31770149f, 0.22197327f, -0.23961323f, -0.01712375f, 0.11560687f, -0.44381621f, -0.40853941f, 
    -0.08652721f, 0.32728899f, 0.05436950f, 0.20150611f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
