#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.10596818f, -1.13945103f, 0.34986559f, 0.44435546f, -0.51413006f, -0.92334968f, 0.93968588f, -0.08554260f, 
    -0.32849178f, 0.02827547f, -0.16716814f, 0.33406734f, -0.19960843f, 0.17426158f, -0.14852335f, -0.72017705f, 
    -0.36376828f, -0.26786855f, -0.16651663f, -0.64539599f, 0.06859380f, 0.15433078f, 0.14833853f, 0.20114057f, 
    0.00070456f, 0.19029145f, 0.69013244f, -0.09164223f, 0.13221605f, 0.87464201f, -0.34877074f, 0.63718975f, 
    0.95519978f, 0.05026389f, 0.85451245f, 0.03924112f, -0.05450303f, 0.24556577f, 0.03168660f, 0.30538496f, 
    0.22273850f, -0.40000841f, -0.33746797f, -0.07362996f, -0.23972280f, 0.29339382f, 0.15776172f, -0.19977714f, 
    0.13395117f, 0.02328973f, 0.79565406f, -0.05413859f, -0.93806553f, -0.22043018f, -0.73037213f, 0.50162756f, 
    -0.15300719f, 0.65771741f, 0.65231687f, 0.41263688f, 0.18388392f, 0.21122634f, 0.01854149f, 0.26265660f, 
    0.14579901f, 0.24024437f, 0.16818480f, -0.05306436f, 0.00841029f, -0.08451556f, -0.32627296f, 0.45873955f, 
    -0.04640216f, 0.21435805f, 0.18502837f, -1.28209293f, 0.39386410f, -0.19329312f, -0.87384212f, -0.57435405f, 
    0.69525880f, 0.45584255f, -0.16893956f, 0.79415894f, 0.82870078f, 0.48595569f, -0.01582571f, -0.44821826f, 
    -0.07971585f, 0.20064571f, 0.18364754f, 0.40585902f, -0.11702148f, 0.38963145f, -0.05952663f, -0.23948553f, 
    0.06859656f, 0.13768780f, 0.05744986f, 0.32024774f, -0.17559324f, -0.50742871f, -0.45654735f, -0.33652529f, 
    0.29183018f, -0.41169491f, -1.20302272f, -0.49575365f, -0.02850301f, -0.79393899f, -0.21583763f, 0.51230234f, 
    0.35354549f, 0.40768102f, -0.10672832f, 0.06190595f, -0.00260114f, 0.24962002f, 0.42185679f, 0.50911081f, 
    0.13709167f, -0.18269336f, -0.26493227f, 0.16421370f, -0.06793670f, 0.53816831f, -1.32688379f, 1.01963174f, 
    0.95351332f, -0.26847285f, 0.37615940f, -0.00390337f, 0.47362202f, 0.34096813f, -0.42349142f, -0.19285454f, 
    -0.45452550f, -0.25366661f, 0.22107945f, -0.15727693f, 0.34231418f, 0.25117067f, -0.15806600f, -0.09373614f, 
    -0.01129181f, -0.22431955f, 0.22923073f, 0.18418059f, 0.12403518f, 0.05603522f, 0.96183562f, 0.95683169f, 
    0.65113866f, -0.44011700f, -1.08256221f, 0.21657553f, 0.26228532f, -0.68584251f, -0.37636623f, -0.30810872f, 
    0.19049251f, 0.22983536f, 0.05341351f, 0.17985284f, -0.27925864f, 0.06027760f, 0.23409911f, 0.37631777f, 
    0.26792824f, -0.14595398f, -0.37248456f, -0.34751308f, 0.05471912f, -0.29375654f, 0.10496499f, -0.33757982f, 
    -0.98231226f, -0.85281593f, -0.60873055f, -0.34783974f, -0.34508771f, -0.63631409f, -0.38365060f, -0.11368903f, 
    0.52423918f, -0.21955751f, 0.29555720f, -0.21476391f, -0.03023942f, -0.30037862f, -0.05881279f, 0.10118758f, 
    0.50548542f, -0.05223560f, -0.04393027f, -0.10422591f, -0.05367397f, 0.19849758f, 0.10146346f, 0.22024137f, 
    -0.91308272f, -1.74166822f, -1.05734479f, 0.08632529f, 0.47853336f, -0.30788308f, 0.74143255f, 0.34557116f, 
    -0.29192781f, 0.13958120f, 0.17266895f, -0.29163638f, 0.01445567f, -0.12694795f, 0.21936068f, 0.00300980f, 
    -0.05961801f, -0.19772916f, -0.21330802f, -0.26369444f, -0.06018948f, -0.23055370f, -0.37564230f, -0.13341261f, 
    -0.07708220f, -0.86768645f, 0.00701002f, 0.84940916f, 0.72559851f, -0.41770980f, -0.25556159f, -0.05946238f, 
    0.65874320f, 0.25638977f, 0.12171037f, 0.56581098f, 0.20187509f, 0.25808901f, 0.24389313f, 0.42783636f, 
    0.50615960f, 0.26602277f, 0.16555479f, -0.14693527f, 0.02161170f, 0.20105648f, 0.17763881f, -0.36568373f, 
    -0.03568166f, -0.18891031f, -0.42836782f, 0.37872228f, -0.07131782f, -0.85071903f, -0.73325330f, 0.52818966f, 
    -0.55827194f, -0.17322674f, 0.31845826f, -0.57536089f, -0.54060143f, -0.50599730f, -0.38833833f, -0.12825596f, 
    -0.40021506f, -0.36669460f, 0.36220369f, 0.06763564f, -0.13829936f, 0.11062798f, 0.24066430f, 0.27596921f, 
    -0.05428625f, -0.04803604f, -0.15178244f, 0.57966220f, 0.79554975f, -0.94836682f, -0.97362989f, -0.31109172f, 
    0.56983936f, -0.41277897f, -0.18165529f, -0.73763937f, -0.26251623f, 0.55458963f, -0.11045820f, 0.14696424f, 
    0.12437498f, -0.31843802f, -0.02325686f, -0.16413713f, -0.22388318f, 0.01890173f, 0.16819215f, 0.41003004f, 
    -0.04943961f, 0.03957814f, 0.30666539f, -0.03205475f, 1.23110247f, 1.01008189f, 0.79228342f, 0.02916742f, 
    -0.20711909f, -0.30658937f, -1.04298651f, 0.05886781f, -0.29219514f, 0.47046098f, 0.04057394f, 0.14949113f, 
    0.14619300f, 0.36475843f, -0.15039128f, 0.08868097f, -0.10305286f, 0.09542821f, -0.27552870f, -0.00253527f, 
    0.25621393f, 0.38799104f, 0.03508010f, -0.20169134f, 0.02897369f, 1.02999258f, 0.33759061f, 0.10480038f, 
    1.37716711f, 0.94995427f, 0.65194619f, 0.06211567f, -0.88037312f, -0.09347253f, 0.06444529f, -0.25076073f, 
    -0.05076581f, -0.15582594f, 0.31808093f, -0.45536366f, -0.15739569f, -0.05388083f, 0.10232784f, -0.15760119f, 
    -0.22817226f, -0.02888585f, -0.08642006f, -0.30617288f, -0.33654833f, 0.10749685f, 0.84226698f, 1.00666928f, 
    0.48528668f, 0.79670417f, 0.67393893f, -0.15786770f, -0.41317156f, 0.20724192f, 0.06115194f, 0.18090394f, 
    -0.08217748f, 0.20627482f, -0.39684966f, -0.24047923f, 0.02695240f, 0.13650168f, 0.22741251f, -0.02350072f, 
    0.08309717f, 0.48168817f, 0.05540261f, 0.07408769f, 0.32158053f, 0.24972698f, 0.10696269f, -0.19217376f, 
    -0.35578641f, 0.74113870f, 0.02412461f, 0.08984128f, 0.73852026f, 0.38983843f, -0.72280657f, -0.45848748f, 
    0.22133841f, 0.36634806f, 0.59475833f, -0.58512759f, -0.03843896f, 0.44579905f, 0.01269816f, -0.41881755f, 
    -0.36097765f, -0.23654963f, 0.31845859f, 0.00367749f, 0.35004297f, 0.22845365f, -0.14799522f, -0.14971672f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.22271764f, 0.09165650f, 0.29797614f, 0.14850758f, 0.33795434f, 0.04135309f, 0.26038831f, 0.26253137f, 
    0.24162331f, -0.06978548f, 0.13152169f, 0.16334882f, 0.13547806f, 0.04388183f, 0.16252755f, 0.27471420f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.14335063f, -0.17843930f, -0.23029131f, 0.22663383f, -0.21460938f, 0.17924871f, -0.00195968f, 0.06683110f, 
    0.20605268f, -0.02696966f, -0.06281516f, -0.22698420f, 0.69294363f, 0.17540373f, -0.02226475f, 0.01282813f, 
    0.27134600f, 0.15510708f, 0.06823200f, 0.12161468f, 0.17492139f, 0.21788347f, 0.01015942f, 0.09172668f, 
    0.30100411f, 0.09039989f, 0.34292895f, -0.12662406f, 0.18640563f, -0.14599071f, 0.22515166f, 0.11449872f, 
    0.07703030f, -0.12200806f, 0.08354078f, 0.14599364f, 0.16652022f, -0.27266040f, 0.09473598f, -0.07425659f, 
    0.15918623f, 0.07744718f, 0.02554009f, 0.04451355f, 0.19888259f, 0.14758311f, 0.09110919f, 0.00071772f, 
    0.03639996f, -0.20115031f, -0.04509373f, -0.07026395f, -0.06964385f, 0.00485161f, 0.19009152f, 0.09104260f, 
    -0.09026407f, 0.42154646f, 0.19072898f, 0.06082955f, 0.02942213f, 0.02555788f, -0.15998730f, 0.21745634f, 
    0.12671867f, -0.01651818f, 0.05544501f, 0.06260234f, 0.02215922f, 0.19181359f, 0.06318308f, 0.11686201f, 
    -0.09169115f, 0.20710766f, 0.24190247f, -0.35315254f, 0.21137486f, 0.09054379f, 0.03451273f, -0.03201944f, 
    0.05399133f, -0.14079648f, 0.19844170f, 0.13168484f, -0.06184306f, -0.30120310f, -0.01536432f, -0.22276393f, 
    0.22010891f, 0.15809312f, 0.17331851f, 0.14079200f, 0.19195755f, -0.10505810f, 0.19373809f, -0.01639729f, 
    0.58168536f, -0.03292783f, -0.05018836f, 0.15658894f, -0.03742297f, 0.08099999f, -0.11505855f, 0.08362323f, 
    -0.00082757f, 0.11068843f, -0.05673764f, -0.03302136f, -0.18525732f, 0.38218334f, -0.11974814f, 0.20527801f, 
    -0.03487220f, 0.13127889f, -0.20307423f, -0.13989836f, 0.01907729f, 0.05703653f, 0.17329822f, 0.26410270f, 
    -0.65777975f, -0.26635146f, 0.22911532f, -0.22934332f, 0.11438182f, 0.00592164f, -0.13650846f, -0.11426605f, 
    0.15421422f, 0.03651745f, -0.07392874f, -0.08470973f, 0.01337665f, -0.04127177f, 0.47674257f, -0.33557305f, 
    0.00546265f, 0.17903543f, 0.20341867f, 0.16883820f, 0.21118532f, 0.22459991f, 0.11191998f, 0.12343180f, 
    0.03218664f, 0.41129354f, 0.39071846f, -0.32525858f, 0.25893992f, 0.06082888f, 0.19902681f, -0.02590979f, 
    0.00569081f, -0.08650646f, -0.06827903f, 0.07582262f, -0.39173758f, 0.05412569f, -0.28376728f, -0.34381887f, 
    0.22393756f, 0.02169041f, -0.12907094f, 0.12484284f, -0.00218497f, 0.07384881f, -0.00441060f, 0.06777688f, 
    0.00837176f, -0.04842496f, -0.02916814f, 0.23122010f, 0.28460705f, -0.00009981f, 0.03606310f, -0.16468567f, 
    -0.11425299f, 0.03838848f, 0.16546564f, 0.15139037f, 0.20351093f, -0.00401839f, 0.25206420f, -0.11474079f, 
    0.01035959f, -0.01064704f, 0.20228057f, -0.05230200f, 0.00870458f, -0.01331328f, -0.11191998f, 0.06166182f, 
    0.10780896f, 0.08861741f, -0.35535091f, 0.29502910f, 0.10078754f, -0.00743963f, -0.00332373f, -0.17133594f, 
    0.15710168f, 0.05265892f, -0.04439881f, 0.09362947f, 0.09655851f, 0.30047858f, -0.02425243f, 0.03294988f, 
    0.07909252f, 0.14378126f, -0.08521084f, 0.21059455f, 0.23995608f, 0.09132744f, -0.07407837f, 0.07319639f, 
    0.26795644f, -0.27686328f, -0.03202353f, -0.10044754f, 0.08476132f, -0.27531299f, -0.13852870f, 0.06024938f, 
    0.06580356f, -0.00848192f, -0.01455696f, 0.08617625f, 0.41627476f, 0.08471831f, 0.01169278f, -0.01274847f, 
    -0.10712282f, 0.07928122f, -0.07174462f, 0.09592483f, 0.03446901f, 0.21624495f, -0.20804915f, -0.10464639f, 
    -0.23878652f, -0.08253291f, 0.22295967f, -0.19064029f, 0.06507258f, 0.09226026f, 0.10673112f, 0.06421048f, 
    0.08177520f, 0.07344247f, -0.01274877f, -0.15647708f, -0.34203681f, -0.27892962f, 0.22486588f, 0.27446952f, 
    -0.07492459f, 0.03521622f, -0.04995305f, 0.00158832f, 0.07578883f, 0.00018648f, -0.00730878f, 0.14514798f, 
    0.34955758f, 0.04824750f, -0.22747739f, -0.26598263f, -0.14545517f, -0.13546447f, -0.09801240f, -0.26337406f, 
    -0.00655796f, -0.11602740f, 0.07262167f, 0.19644126f, 0.10181014f, 0.02907341f, 0.04094213f, -0.27942097f, 
    -0.18914364f, -0.12835133f, -0.02658182f, 0.06607311f, -0.07507369f, -0.03363716f, 0.03112018f, 0.06427114f, 
    0.24838731f, 0.09129377f, 0.41955981f, 0.23496768f, 0.14766631f, 0.00473142f, -0.00864462f, 0.10659519f, 
    0.01619316f, -0.03051371f, -0.07796004f, 0.03080276f, -0.51434499f, 0.15233055f, 0.05930505f, 0.11704649f, 
    -0.01914771f, -0.00642718f, -0.03550319f, 0.03301636f, -0.20567924f, -0.02173952f, -0.04769805f, 0.00805948f, 
    -0.32430071f, -0.01156343f, -0.03106149f, -0.33028442f, -0.10514415f, -0.05667527f, 0.03984417f, -0.18307139f, 
    0.10822903f, -0.14830978f, 0.01104244f, -0.16970229f, 0.41102529f, -0.03632494f, -0.47353148f, -0.31534326f, 
    -0.02208965f, 0.16809250f, 0.23537533f, -0.06411064f, 0.10884877f, 0.09528224f, -0.05423753f, 0.14691979f, 
    0.42537102f, 0.10522074f, 0.02510553f, -0.14880717f, 0.11086304f, -0.06904975f, -0.02428265f, 0.09028474f, 
    0.27112430f, 0.07498410f, 0.14563993f, -0.02587818f, 0.59764677f, -0.45370248f, 0.10641067f, 0.55474299f, 
    -0.12552519f, 0.01869398f, -0.07082424f, -0.01438292f, 0.13420331f, 0.12983589f, 0.03092736f, -0.10178221f, 
    0.38165668f, 0.02773372f, 0.07398025f, 0.42607695f, 0.16399878f, -0.16773078f, 0.01503830f, 0.10128760f, 
    0.11941031f, -0.09571869f, 0.11128442f, 0.14130801f, 0.27373716f, -0.28267670f, -0.02424948f, 0.00456150f, 
    0.01008119f, 0.13749942f, 0.12613378f, -0.17700422f, -0.16468470f, -0.02278013f, 0.23069014f, -0.12573643f, 
    0.42418396f, -0.07287231f, 0.22442517f, -0.25238001f, 0.11587512f, -0.03252662f, 0.08943770f, -0.18707964f, 
    -0.03945728f, 0.15602604f, 0.07562938f, 0.22318037f, -0.17679037f, -0.17598949f, -0.06035802f, 0.30214658f, 
    0.09839323f, -0.11537531f, 0.06747699f, -0.16798061f, -0.03011491f, 0.02505932f, 0.08230167f, 0.09428072f, 
    -0.55290341f, -0.02340291f, 0.31394142f, 0.37670961f, 0.09215117f, 0.04492561f, 0.07252399f, 0.08076648f, 
    -0.01564667f, 0.00350597f, 0.01047477f, -0.17062466f, 0.01050962f, 0.00288568f, 0.14872536f, 0.31173471f, 
    -0.00858095f, -0.10503030f, 0.03324174f, 0.23478086f, -0.23094390f, 0.05161070f, 0.22147305f, -0.06321797f, 
    0.09002472f, 0.37177986f, -0.02527784f, 0.13635750f, -0.03350453f, 0.15291212f, -0.04739993f, 0.22314766f, 
    0.03929693f, -0.22965227f, -0.25083074f, -0.34129107f, 0.41242170f, -0.05738880f, 0.03310153f, -0.46685213f, 
    0.01992832f, 0.25231588f, 0.00593399f, 0.13021357f, -0.09705519f, -0.04712956f, 0.15373182f, -0.01268226f, 
    0.03495073f, -0.43378478f, 0.38685057f, 0.02522205f, 0.09452851f, 0.19548950f, -0.02745471f, 0.17952371f, 
    0.01578871f, 0.24776518f, -0.20691146f, -0.00976608f, 0.01170391f, 0.01078995f, 0.04445556f, 0.06010845f, 
    -0.12738948f, -0.17015240f, 0.00309166f, -0.00840221f, -0.16729708f, 0.21345623f, -0.16063200f, 0.15362287f, 
    0.44011897f, -0.18767697f, 0.20448223f, 0.30771437f, -0.15834719f, -0.17238024f, 0.06913012f, 0.30569437f, 
    0.11423482f, -0.02512510f, 0.20501558f, 0.23785044f, 0.34967533f, -0.14644706f, 0.04109602f, -0.06163358f, 
    0.05744332f, -0.02672338f, 0.17695117f, -0.00258516f, -0.07407533f, -0.03448367f, -0.16534266f, -0.26695180f, 
    0.15315270f, 0.44823009f, -0.21852791f, 0.11504874f, -0.14503473f, 0.06597276f, 0.05750618f, -0.07446396f, 
    -0.09146673f, 0.03133673f, 0.24627569f, 0.25632626f, -0.11534822f, -0.18809703f, -0.25639588f, 0.05074302f, 
    0.11379713f, 0.04442937f, -0.08553589f, -0.18176448f, -0.18700807f, -0.06536570f, -0.07240390f, -0.11833717f, 
    -0.42951182f, -0.02056572f, 0.15932202f, 0.00377404f, -0.00892570f, 0.23335433f, 0.01699887f, -0.09538883f, 
    -0.12265512f, 0.17011170f, -0.11313660f, -0.05127104f, -0.16676676f, 0.43318167f, -0.16499712f, -0.62171650f, 
    0.02855859f, -0.02137512f, 0.07526962f, 0.00361394f, -0.09359012f, -0.03060538f, 0.01324561f, 0.01891559f, 
    -0.06383253f, 0.13540010f, 0.04517331f, -0.50164539f, -0.04991409f, 0.18832034f, 0.00123938f, 0.07886962f, 
    0.11661153f, -0.14166534f, 0.08857135f, -0.44564021f, 0.18698099f, 0.03746434f, -0.11748966f, -0.13752390f, 
    0.21376243f, 0.02592189f, -0.22086020f, 0.08257380f, -0.05704356f, -0.02373350f, 0.13831671f, -0.07216719f, 
    -0.04364701f, -0.02367738f, 0.04218599f, -0.06244738f, -0.04942397f, 0.04045629f, -0.07674628f, -0.02720368f, 
    -0.00681221f, -0.04132397f, 0.04449680f, 0.02465936f, 0.02076047f, 0.01693983f, -0.05916406f, 0.01896041f, 
    -0.03870620f, -0.05649739f, 0.02667721f, 0.01829083f, -0.04885870f, 0.03255790f, -0.01010716f, -0.02204429f, 
    -0.05520984f, -0.02729596f, 0.02274860f, -0.00537284f, -0.01132032f, -0.01473476f, 0.00733214f, -0.00363827f, 
    -0.04317241f, -0.06172917f, -0.08234390f, 0.04131613f, -0.03394633f, 0.01973120f, -0.06988443f, 0.04274835f, 
    -0.04802158f, 0.05401270f, 0.04418933f, -0.05830934f, 0.06005247f, -0.01110961f, 0.05198594f, -0.06366862f, 
    -0.04847672f, 0.04599561f, -0.05771418f, -0.02390561f, -0.01112259f, -0.03484640f, 0.04280853f, -0.06014359f, 
    0.00053304f, 0.04725452f, -0.02321556f, 0.00050224f, 0.00728028f, 0.06160401f, -0.03298258f, 0.05975794f, 
    -0.02590421f, -0.07429484f, 0.06055189f, -0.02086839f, -0.03863498f, -0.04035940f, 0.03660256f, 0.01149623f, 
    -0.07386076f, -0.07810691f, 0.06027220f, 0.01721130f, -0.05556155f, 0.06423289f, 0.03400223f, -0.00742866f, 
    0.00503462f, -0.01027191f, -0.02288859f, -0.07796063f, 0.05428614f, -0.07890085f, 0.02261087f, -0.05080377f, 
    0.02446750f, -0.01810525f, -0.03073861f, -0.01565083f, 0.05795148f, 0.02603430f, 0.03448717f, -0.06490602f, 
    0.05202724f, -0.04494779f, 0.05102444f, -0.03106445f, -0.02896239f, 0.02219185f, -0.02716601f, -0.04343782f, 
    0.04906077f, -0.05115593f, -0.00760719f, -0.06697912f, -0.03430509f, 0.04718832f, -0.00314311f, 0.01714982f, 
    -0.01401521f, 0.00356470f, -0.07487176f, -0.02515153f, -0.05235830f, -0.03340580f, -0.07500409f, -0.07615217f, 
    -0.05784771f, -0.05119902f, -0.00356041f, -0.03488686f, -0.00278088f, -0.07005318f, -0.02941742f, 0.04246464f, 
    -0.06109203f, 0.04745823f, -0.03131291f, -0.02997935f, -0.07138819f, -0.03262847f, -0.01661818f, -0.06177305f, 
    0.01561138f, -0.06746806f, -0.02717679f, -0.04915990f, 0.04079931f, -0.02858876f, 0.03190364f, -0.03815373f, 
    -0.00391504f, -0.05219832f, 0.05162634f, 0.00526296f, 0.04253047f, -0.03409161f, -0.03689887f, 0.02808645f, 
    0.03549602f, -0.04408468f, -0.05963228f, -0.03497677f, -0.01622047f, -0.00818545f, -0.02451852f, -0.05086074f, 
    -0.01414580f, -0.03125938f, -0.01727469f, -0.01694500f, 0.03154385f, -0.07022325f, 0.00497067f, -0.06284019f, 
    0.05636968f, -0.01138693f, -0.04077790f, 0.04482968f, -0.01566525f, -0.03925800f, 0.01615402f, -0.01240280f, 
    0.03010548f, 0.05969713f, -0.01876835f, -0.01511386f, 0.06303711f, -0.01837796f, -0.00944091f, 0.04954422f, 
    0.01961098f, -0.04168951f, 0.00597487f, -0.06454221f, -0.02694483f, 0.05647812f, 0.04544226f, -0.01570835f, 
    -0.02043764f, -0.03028129f, -0.01633965f, -0.05812133f, -0.05186693f, -0.07282605f, 0.02537928f, 0.05281198f, 
    -0.07668308f, -0.03921944f, 0.01297847f, 0.00345354f, 0.01245247f, -0.06444830f, -0.01441074f, -0.04752777f, 
    -0.01518325f, 0.06554367f, -0.02413010f, -0.05698822f, -0.03177943f, 0.02788643f, -0.02637018f, -0.04850876f, 
    -0.00896463f, -0.07215933f, 0.05702017f, 0.01920354f, -0.00087375f, 0.01775506f, -0.02342919f, -0.01266549f, 
    -0.03938642f, -0.07051275f, -0.05130808f, -0.06424130f, -0.06145727f, -0.07255386f, -0.05440621f, -0.06716062f, 
    0.05015932f, 0.03388757f, 0.00217691f, 0.00107332f, 0.03165869f, 0.02299058f, 0.05987410f, -0.05962460f, 
    -0.06447419f, -0.02974419f, 0.01126108f, -0.03538574f, 0.06573398f, 0.01518341f, 0.02087189f, 0.00911890f, 
    0.00821616f, 0.01352755f, 0.00283229f, -0.06652845f, -0.03562734f, -0.00346056f, 0.01325388f, 0.01711208f, 
    -0.06228007f, -0.06604116f, -0.03518156f, -0.01153371f, 0.03167137f, -0.02484214f, -0.04095445f, 0.00251244f, 
    -0.01501278f, 0.06467654f, 0.05935378f, 0.05721999f, -0.05603357f, -0.05333802f, -0.00888369f, 0.05409966f, 
    -0.06802219f, 0.05731413f, 0.01962784f, -0.02766371f, 0.02412003f, 0.03296029f, 0.05886883f, -0.06951846f, 
    0.02958878f, 0.04647534f, 0.01995518f, -0.01108636f, -0.01230143f, -0.01155678f, -0.01441220f, 0.02242985f, 
    0.04060645f, -0.03890640f, 0.04286091f, 0.00993298f, -0.07688463f, -0.07436354f, 0.05827602f, -0.02976131f, 
    -0.07351045f, -0.00085917f, -0.07656755f, -0.05520739f, -0.03027941f, -0.00606665f, -0.01252822f, -0.04011982f, 
    -0.02291642f, 0.02394800f, -0.07398213f, 0.05614382f, -0.05709468f, -0.05925310f, -0.07213382f, 0.02443284f, 
    -0.06320189f, 0.02122915f, -0.04265182f, 0.04216112f, 0.01993319f, 0.03261203f, 0.06507686f, 0.06627805f, 
    0.05614694f, 0.03024737f, -0.01491267f, 0.01818470f, -0.03446915f, 0.03717515f, -0.04456545f, 0.06004941f, 
    0.04873828f, 0.02843345f, -0.07251379f, -0.00362780f, 0.03547832f, -0.04158067f, 0.01239375f, 0.01137210f, 
    0.01033709f, -0.04153906f, -0.07393117f, 0.00087106f, -0.00815365f, 0.04925633f, -0.02168318f, 0.04735542f, 
    -0.07236829f, 0.06319642f, -0.01977906f, -0.07515684f, -0.07432638f, -0.05937951f, -0.04438635f, -0.02692551f, 
    0.02453335f, -0.01601852f, -0.06564336f, -0.01464458f, 0.00949956f, 0.02583382f, -0.06911587f, -0.03051779f, 
    -0.01076473f, 0.02747401f, 0.04924368f, -0.03734845f, 0.00780731f, 0.01451020f, 0.02565964f, -0.04970213f, 
    0.02545064f, -0.03972688f, 0.03776322f, -0.02096524f, -0.05478242f, -0.07011586f, -0.01283420f, -0.07427453f, 
    -0.05022660f, -0.03023446f, 0.00106790f, 0.01747639f, 0.04792233f, 0.02100698f, -0.05400121f, 0.03548408f, 
    0.15329702f, -0.13175930f, -0.11438368f, 0.09813979f, 0.03625344f, -0.12345880f, -0.03144533f, 0.08105548f, 
    -0.06448621f, 0.06161460f, 0.16799691f, -0.24232200f, -0.30848801f, 0.04026021f, 0.07568937f, -0.13342026f, 
    -0.04540139f, 0.01602975f, 0.09255359f, 0.08334978f, -0.12819125f, -0.28220758f, 0.03472890f, -0.01762981f, 
    -0.17717238f, 0.26415297f, -0.11303090f, -0.05664319f, 0.07565943f, 0.05060994f, 0.01308696f, -0.05442841f, 
    -0.16789119f, 0.07736870f, 0.03447143f, -0.13808236f, 0.28987002f, -0.25717849f, 0.11528113f, 0.31706899f, 
    -0.00068801f, 0.02995857f, 0.15251313f, -0.23737730f, -0.14041714f, -0.08518203f, -0.06277727f, 0.00828807f, 
    0.17724156f, 0.00729088f, -0.21147537f, 0.00037164f, -0.01094264f, -0.10199281f, 0.08161634f, 0.02297696f, 
    0.02638281f, -0.11655361f, -0.02850347f, 0.13938203f, -0.13737562f, -0.02281147f, 0.04199560f, 0.02733549f, 
    0.16437717f, -0.06813554f, -0.04307536f, -0.04678566f, -0.18971577f, -0.10365368f, 0.06551045f, -0.03238128f, 
    -0.05765031f, 0.19943142f, 0.00989393f, 0.11147489f, 0.09834931f, -0.06369278f, -0.05535246f, -0.02431340f, 
    -0.04841588f, -0.01822019f, -0.06524920f, -0.12391856f, 0.04392141f, -0.00878640f, -0.15255041f, 0.10182456f, 
    -0.03079351f, 0.08635519f, -0.00639117f, 0.03008708f, 0.02852938f, 0.00324664f, 0.11626171f, -0.07517713f, 
    -0.72061121f, 0.20136324f, -0.00753125f, -0.29994348f, 0.17331477f, 0.20014216f, 0.07313658f, -0.22680591f, 
    0.08780733f, 0.01954520f, -0.03030477f, 0.04749114f, 0.34950641f, -0.24150531f, -0.00618709f, 0.06458629f, 
    -0.03124056f, 0.27576962f, -0.04116968f, 0.00105231f, 0.07100195f, 0.10515041f, 0.15204409f, -0.07010181f, 
    0.42392817f, 0.24186181f, 0.20222785f, 0.54007691f, 0.06095105f, 0.19330315f, -0.15129994f, -0.09828492f, 
    -0.08330224f, 0.05190425f, -0.02342003f, -0.09051708f, -0.22522533f, -0.15847155f, 0.07294197f, 0.46876863f, 
    0.14502287f, -0.10558218f, -0.18222928f, 0.11039015f, 0.15174179f, -0.21005026f, -0.05417671f, -0.01906023f, 
    0.33025792f, 0.63782179f, -0.05525005f, -0.26787379f, -0.07656039f, -0.06990080f, -0.10163090f, 0.01588722f, 
    -0.11453046f, -0.00724092f, -0.00492169f, 0.01038804f, -0.12165590f, 0.11040994f, 0.09491496f, -0.29146910f, 
    -0.07675949f, -0.14064632f, 0.08437219f, 0.02258104f, -0.02243407f, 0.17166153f, -0.06528145f, 0.07288193f, 
    0.01901709f, 0.36244759f, -0.02852497f, -0.36653447f, 0.06919258f, 0.03551387f, -0.06473501f, 0.07004077f, 
    0.11136033f, 0.16353758f, -0.01328749f, 0.04368092f, 0.06522024f, -0.14461784f, 0.18965226f, 0.26339850f, 
    0.03173436f, 0.06732683f, 0.06730243f, 0.05716331f, 0.14690191f, 0.19383731f, 0.16070502f, 0.08863839f, 
    -0.36583930f, 0.04595592f, 0.06406940f, 0.13146459f, 0.12205020f, -0.03602988f, -0.00437061f, 0.14572677f, 
    -0.09212760f, 0.01291240f, 0.00743002f, 0.00325618f, -0.09840558f, 0.24555486f, -0.05620692f, -0.00830729f, 
    -0.17822927f, 0.10498425f, -0.02795591f, 0.16769756f, -0.06893358f, -0.11620168f, -0.04474810f, -0.13866009f, 
    0.15004981f, 0.04492789f, -0.42382041f, -0.18092537f, -0.15502177f, 0.14868933f, -0.04641618f, -0.25838569f, 
    0.02669199f, 0.14576538f, -0.03540202f, 0.15907370f, 0.26739281f, 0.59719992f, -0.01765782f, 0.04808361f, 
    -0.07570019f, 0.08230420f, -0.05899660f, -0.13918470f, 0.12174574f, 0.12039874f, -0.06925151f, 0.17445602f, 
    0.12121566f, 0.10633778f, 0.17936900f, 0.09780962f, 0.07919761f, -0.03490567f, -0.02423809f, 0.09235992f, 
    0.08739588f, -0.16158628f, 0.13050964f, 0.08648861f, -0.43031651f, 0.25090691f, 0.21490006f, 0.41751668f, 
    -0.03637802f, 0.01902432f, 0.11239482f, -0.11143375f, 0.09388256f, -0.04232180f, -0.13136210f, -0.08340602f, 
    -0.18454072f, 0.06345458f, -0.25319108f, 0.08139105f, -0.13360524f, -0.09298443f, 0.06371530f, -0.09735368f, 
    -0.01914536f, 0.15559936f, 0.02269830f, 0.05675127f, 0.11740797f, 0.25142932f, 0.07592294f, 0.35686076f, 
    -0.06567043f, -0.10621875f, 0.02070746f, 0.13057621f, 0.05975047f, 0.07331795f, 0.04197445f, -0.21611658f, 
    -0.87891150f, 0.32438943f, 0.10181499f, -0.14946477f, 0.18103354f, 0.15353848f, -0.05644498f, -0.25713083f, 
    -0.03058600f, 0.04256305f, -0.14548764f, -0.05748277f, -0.13333714f, -0.23381072f, -0.10185184f, -0.07691494f, 
    0.03695540f, 0.07325724f, 0.05267614f, 0.19085860f, 0.03974146f, 0.03217033f, 0.09377364f, -0.02086737f, 
    0.60530555f, 0.21457088f, -0.09411254f, 0.32675827f, 0.07895014f, -0.10281041f, 0.20502156f, 0.11458144f, 
    -0.04387476f, -0.07821095f, 0.01229350f, -0.03104712f, -0.06200385f, 0.15535754f, -0.26260859f, 0.19675402f, 
    0.06746808f, -0.11239812f, 0.11073019f, -0.10995077f, 0.10936476f, -0.04125035f, -0.00960689f, -0.02439482f, 
    0.14803365f, -0.21542570f, -0.32375079f, 0.08694686f, -0.01943258f, -0.23568237f, -0.11679026f, 0.00410144f, 
    0.23509058f, 0.02349408f, 0.16329750f, 0.01015984f, 0.36339983f, -0.21542862f, 0.25741094f, 0.74491149f, 
    -0.14042540f, 0.07746462f, 0.14080893f, 0.05674502f, -0.10551864f, -0.07332490f, -0.06073871f, 0.03756269f, 
    0.23682407f, -0.19977589f, -0.02789527f, 0.24798708f, -0.13732365f, -0.00909263f, 0.06120972f, 0.14081743f, 
    0.10109781f, 0.08071049f, -0.01942870f, 0.25538078f, -0.28116068f, 0.10040727f, 0.13752151f, 0.10518827f, 
    -0.04615475f, -0.02886654f, -0.00762283f, -0.08772628f, 0.00827437f, 0.01923681f, 0.08929553f, 0.22044060f, 
    -0.03332245f, 0.01192169f, 0.00931771f, -0.05047600f, -0.05477939f, -0.07312706f, -0.05870480f, -0.01899568f, 
    -0.06720577f, -0.00625678f, 0.05061441f, -0.07537047f, 0.03186570f, -0.02436036f, -0.02991525f, -0.07956839f, 
    -0.04560253f, -0.04080789f, -0.06803736f, -0.05610203f, -0.05476530f, -0.03463675f, -0.03323381f, 0.00484042f, 
    0.03887255f, 0.04143601f, -0.03559765f, -0.06051644f, -0.03411610f, -0.04858545f, -0.07387290f, 0.03918501f, 
    -0.01109960f, 0.00059529f, -0.02209880f, 0.01428291f, -0.01295350f, -0.07194874f, -0.04817686f, -0.07304353f, 
    0.00828173f, 0.00392549f, -0.04942748f, -0.01169350f, -0.06392190f, -0.00879238f, 0.04218316f, -0.07688957f, 
    0.01280593f, 0.00731156f, -0.07034265f, -0.06657177f, 0.01267653f, 0.01769232f, -0.06526122f, 0.00235244f, 
    -0.04770743f, -0.02980112f, -0.06731141f, 0.02392908f, 0.01060762f, -0.01523293f, -0.03127947f, 0.00648540f, 
    -0.06109865f, 0.03540951f, 0.01594223f, 0.03710883f, 0.01664360f, 0.05995026f, -0.03302405f, -0.04821971f, 
    -0.02854609f, 0.02643742f, 0.02490873f, -0.01382386f, 0.00801443f, 0.05313677f, -0.06216413f, -0.06920780f, 
    0.01664124f, -0.04443148f, -0.02353193f, -0.03182125f, 0.03080960f, -0.04788880f, 0.06219770f, -0.02109385f, 
    -0.04743334f, -0.04357977f, 0.02310261f, 0.04709567f, 0.02055234f, 0.00356202f, 0.00537585f, 0.05380147f, 
    0.04218844f, 0.05502062f, -0.04313437f, 0.02189848f, -0.02382978f, -0.04053634f, 0.04650006f, -0.04472340f, 
    0.03570993f, -0.06914798f, -0.01168725f, -0.01666446f, -0.05042544f, -0.02290631f, 0.00473405f, -0.02568882f, 
    0.06306069f, 0.05334829f, -0.07528714f, 0.06756397f, -0.05826652f, -0.07821693f, -0.07496764f, 0.04798340f, 
    -0.03229934f, 0.05318325f, -0.06094116f, -0.02891532f, 0.05392526f, 0.02718097f, -0.00320208f, -0.02765936f, 
    -0.01763525f, 0.00475539f, -0.01800019f, -0.07772287f, -0.05397304f, 0.03008240f, -0.07816147f, -0.04724545f, 
    0.05298580f, -0.06926324f, 0.02865317f, -0.05756926f, 0.05178936f, 0.06254312f, 0.06070699f, 0.01022555f, 
    0.03775752f, 0.01059449f, -0.02968834f, 0.05479937f, 0.00515229f, 0.05553420f, 0.04674571f, 0.05944407f, 
    -0.00049930f, -0.03687122f, 0.05965575f, -0.05614754f, -0.03877870f, -0.06387483f, -0.01243326f, 0.02655373f, 
    0.00755508f, 0.05948460f, 0.01765878f, -0.05152225f, -0.05086910f, 0.04015642f, 0.02802681f, -0.06631850f, 
    0.02665840f, -0.02728098f, -0.07584043f, 0.00602478f, 0.02960063f, -0.00054875f, -0.03667820f, -0.02377750f, 
    -0.01166414f, 0.01918133f, 0.00819722f, -0.06381609f, -0.04354585f, -0.04986477f, 0.02955451f, -0.04212517f, 
    0.04040234f, -0.01851076f, 0.05449718f, -0.05511205f, -0.04624908f, -0.04704840f, 0.00737802f, -0.02152386f, 
    0.26942146f, 0.34573963f, -0.22306512f, 0.05393106f, 0.09909268f, 0.10689268f, 0.13881654f, 0.03561180f, 
    0.14582063f, -0.13689885f, 0.04291420f, 0.07078883f, -0.12708382f, 0.08652341f, 0.03963479f, 0.14593984f, 
    0.37304351f, 0.08366890f, 0.00548784f, 0.19453974f, 0.16762353f, 0.09204112f, -0.24863333f, 0.11354771f, 
    -0.17439777f, -0.28465125f, -0.05758901f, 0.05492378f, 0.27898550f, -0.08688637f, -0.01648820f, 0.20915332f, 
    0.15358177f, 0.09040073f, 0.14149579f, -0.00387819f, -0.48645654f, -0.15332046f, -0.42940590f, -0.00057184f, 
    -0.05547126f, -0.00780477f, 0.13016911f, 0.08437558f, -0.06561272f, 0.25184858f, -0.00944105f, -0.05783189f, 
    0.59456760f, 0.25219136f, 0.02745391f, -0.02902933f, 0.03596073f, -0.03904240f, 0.12449466f, 0.19558245f, 
    -0.08305658f, 0.15424141f, -0.05687217f, -0.03114074f, -0.23097919f, -0.27808088f, 0.00852733f, -0.41279790f, 
    0.09697480f, 0.06398708f, 0.03071398f, 0.08073868f, 0.13225606f, 0.19585355f, 0.19394433f, 0.05027452f, 
    -0.11708933f, -0.16295391f, 0.11393680f, 0.24066466f, 0.13739273f, -0.05075655f, -0.07470702f, -0.15234064f, 
    0.12320963f, -0.11553741f, 0.03015804f, 0.14531262f, 0.23823097f, 0.21462293f, -0.12752859f, -0.07672933f, 
    0.00201404f, -0.02522131f, -0.06540198f, -0.26075423f, 0.10046931f, 0.02737858f, 0.09542685f, -0.03102508f, 
    0.81890625f, -0.15215130f, -0.03597111f, 0.06862991f, -0.04964218f, -0.19306809f, 0.08952419f, 0.21883923f, 
    -0.10389162f, -0.06356332f, -0.02716511f, 0.10930705f, -0.39774248f, 0.03214338f, -0.07227185f, -0.16528895f, 
    0.16415045f, 0.04066055f, -0.23549831f, 0.09801780f, -0.21294534f, 0.06846969f, 0.04449620f, 0.05448978f, 
    -0.46509260f, -0.09055056f, -0.11181711f, 0.09137210f, -0.36283290f, 0.02049733f, -0.00045585f, -0.08989948f, 
    0.11068410f, -0.04209728f, 0.08315268f, -0.11581265f, 0.13290749f, -0.45934337f, -0.29078823f, 0.09397890f, 
    0.07733802f, 0.15936379f, 0.05893394f, -0.00786807f, 0.05460703f, 0.19654657f, 0.03010763f, -0.10612679f, 
    -0.22192192f, 0.23959742f, 0.21290387f, 0.23138317f, 0.11829451f, 0.10377415f, -0.03716205f, -0.04097719f, 
    0.16727096f, 0.08759540f, 0.07259618f, 0.18316497f, 0.10277604f, -0.30709454f, 0.07504779f, -0.62635571f, 
    0.04132217f, -0.06930687f, -0.15132932f, -0.03151787f, 0.04745404f, -0.19634637f, 0.08455164f, -0.01040766f, 
    -0.20494491f, 0.09414700f, -0.14697073f, -0.23284195f, 0.25474247f, 0.01083859f, 0.00534743f, 0.00507817f, 
    0.02296443f, 0.07293931f, 0.08759743f, 0.10830006f, 0.41950649f, 0.04896985f, 0.02147000f, 0.31057170f, 
    0.21243966f, 0.08122488f, 0.01810889f, 0.11936535f, -0.06463166f, 0.11328709f, -0.04569516f, -0.09024071f, 
    -0.19353727f, 0.19810973f, 0.16604309f, -0.07668264f, 0.18179844f, -0.16269171f, 0.10488721f, 0.15291463f, 
    -0.14325461f, 0.13238141f, 0.25790748f, 0.01651397f, -0.58904696f, -0.21338020f, -0.03647928f, 0.10303435f, 
    -0.18106800f, -0.13261569f, 0.14357702f, 0.01596422f, -0.03433427f, -0.20261365f, 0.08341443f, 0.08224576f, 
    -0.35583252f, 0.09826908f, -0.11672232f, 0.21697362f, 0.12842242f, 0.20022853f, 0.06132982f, -0.19469464f, 
    -0.03541628f, 0.19299023f, -0.09010569f, 0.00169941f, 0.16738969f, -0.33954701f, -0.01688456f, 0.18910038f, 
    -0.13838604f, 0.03075220f, 0.03378764f, -0.02575768f, -0.21496448f, -0.07307191f, -0.03028623f, 0.08679160f, 
    0.26667935f, 0.15350683f, -0.03549832f, 0.19062167f, -0.05175602f, -0.00001632f, -0.03635668f, 0.06188490f, 
    0.22307938f, -0.16636083f, 0.05513914f, 0.07941668f, -0.45648992f, -0.08290265f, 0.17217764f, -0.22108369f, 
    0.19999199f, -0.15348384f, 0.01899855f, 0.13966146f, -0.00422271f, -0.16977596f, -0.07034326f, -0.05595721f, 
    -0.19077840f, 0.06144577f, 0.10020701f, 0.16874219f, 0.02219092f, 0.18350036f, 0.01393500f, 0.03141288f, 
    -0.02040952f, 0.19325660f, -0.04223602f, -0.01607110f, 0.08942889f, 0.11363383f, -0.32434258f, 0.11194486f, 
    -0.02288892f, -0.05605958f, 0.09019646f, -0.03284573f, 0.09284666f, 0.15393774f, 0.14961740f, 0.13043448f, 
    -0.90627754f, 0.09335011f, -0.19242463f, 0.03821479f, 0.07816283f, -0.11394222f, 0.16422275f, 0.08024813f, 
    0.08683062f, -0.09091698f, 0.22373971f, 0.14070599f, 0.16266005f, -0.30173346f, 0.13046019f, -0.06062724f, 
    0.08464818f, 0.12134511f, 0.13147765f, 0.12755185f, 0.06460368f, 0.17602506f, -0.04715467f, -0.05585588f, 
    0.59218496f, -0.08111504f, -0.11708345f, -0.00159909f, -0.12017979f, 0.14214742f, -0.06137821f, -0.06939832f, 
    -0.02437849f, 0.06153971f, 0.12514001f, 0.22246027f, -0.02626439f, -0.06913997f, -0.36155456f, 0.62487668f, 
    0.22952092f, -0.12800924f, -0.08116008f, -0.04365635f, 0.07974859f, -0.12844464f, -0.13969675f, -0.03501007f, 
    -0.03627582f, -0.02980032f, 0.04916184f, 0.24688746f, -0.20677358f, 0.12352042f, -0.16796124f, -0.01497670f, 
    0.05498009f, 0.04624072f, -0.07524658f, -0.05634739f, 0.11205214f, 0.09463470f, 0.18650798f, -0.19192323f, 
    0.11411767f, -0.01727074f, 0.14726293f, 0.02744538f, 0.09558490f, -0.02290279f, 0.19248693f, 0.18314686f, 
    -0.04239874f, 0.03582107f, -0.07445425f, -0.24125364f, -0.11289345f, 0.11755285f, -0.05132767f, 0.15680771f, 
    0.31173754f, 0.09026811f, -0.15463224f, -0.10063454f, -0.26138705f, 0.15346175f, 0.11696010f, 0.21662197f, 
    0.08696091f, -0.02757137f, -0.03560130f, 0.19587339f, 0.19706883f, 0.05547045f, 0.14335465f, 0.10572387f, 
    -0.55665559f, -0.10338047f, -0.02218319f, -0.25262213f, 0.23636739f, -0.13522476f, -0.11822172f, 0.13603567f, 
    -0.04159097f, 0.14860946f, 0.06170705f, 0.09217393f, 0.42472348f, -0.13895325f, -0.23645951f, 0.23473887f, 
    0.00835829f, 0.00267514f, 0.04989315f, 0.04035488f, -0.09760401f, 0.17166731f, 0.12180597f, -0.22647925f, 
    -0.12411530f, 0.43282211f, 0.42114961f, 0.13213269f, 0.03355044f, 0.03647198f, 0.08758312f, 0.04622584f, 
    -0.09090350f, -0.02043796f, -0.05370809f, -0.03669766f, -0.24475160f, -0.07184728f, 0.29241130f, 0.20552738f, 
    0.12553568f, 0.01849862f, 0.12794654f, 0.18349326f, -0.08418907f, -0.16754502f, 0.16082819f, 0.00898205f, 
    -0.15386650f, -0.06204816f, -0.21940675f, 0.16212517f, -0.01163147f, -0.15689671f, -0.07220531f, 0.07375661f, 
    -0.00810287f, 0.23965761f, -0.05673108f, -0.07884838f, 0.44775057f, 0.30595869f, 0.35310563f, -0.60673779f, 
    0.05684241f, -0.13284136f, -0.14347599f, 0.03493988f, -0.08750740f, -0.02914767f, 0.00839946f, 0.19068423f, 
    0.51211613f, -0.25484890f, -0.03023539f, -0.11466477f, -0.11785013f, -0.00970634f, -0.07999437f, 0.02687206f, 
    0.02718315f, 0.09184110f, 0.24864593f, 0.02534354f, 0.25138506f, 0.00359431f, 0.06874721f, 0.05316226f, 
    0.08398569f, -0.09246674f, 0.07215261f, -0.01133676f, 0.03092211f, 0.00921169f, -0.14284256f, -0.09286869f, 
    -0.46425146f, 0.03809942f, 0.26881146f, -0.00555327f, 0.06579869f, -0.06218667f, -0.04613898f, -0.07329185f, 
    0.07536216f, 0.07856975f, 0.03765463f, -0.10982133f, 0.32362878f, 0.07615703f, 0.21603884f, -0.24512012f, 
    0.00643720f, 0.04915541f, -0.10844857f, -0.02899352f, 0.12699491f, -0.01609913f, -0.10167096f, 0.05916063f, 
    0.07848877f, 0.25041708f, 0.01465062f, 0.07804301f, 0.17178182f, 0.10379666f, 0.05817124f, 0.11662541f, 
    -0.07261027f, -0.11004775f, -0.08492088f, -0.03390662f, -0.01368012f, 0.20656054f, 0.23031706f, 0.17017959f, 
    0.15605345f, -0.13102449f, -0.11062496f, -0.05169800f, -0.03939485f, -0.00445833f, 0.00168230f, 0.10089246f, 
    0.42338976f, -0.29061505f, -0.18673310f, -0.20959137f, 0.08809714f, 0.00228762f, -0.08237781f, -0.00255378f, 
    0.07690961f, 0.13335940f, -0.02759324f, -0.05162856f, -0.44777143f, 0.51449728f, -0.21126454f, 0.04120182f, 
    0.21985023f, -0.02386646f, -0.06922404f, -0.08265489f, 0.03727312f, 0.09113920f, 0.05203696f, -0.05453854f, 
    0.08887676f, -0.09099250f, -0.01943951f, 0.16976531f, 0.25273785f, -0.06539220f, -0.03254469f, -0.08874958f, 
    0.03406043f, 0.01880465f, -0.02305249f, -0.09136610f, 0.19993909f, 0.00889580f, -0.18030353f, -0.11091252f, 
    -0.11679836f, -0.00196581f, 0.00342738f, 0.00409977f, 0.05968657f, 0.06929402f, -0.17317413f, 0.20350844f, 
    0.01637543f, 0.02592236f, -0.04585577f, -0.01451807f, -0.02277267f, -0.07569791f, -0.06858838f, -0.02181044f, 
    -0.01639528f, 0.02380528f, -0.02389942f, -0.03944797f, -0.07881703f, -0.07169370f, 0.01927607f, -0.04092344f, 
    -0.00220876f, -0.00812058f, 0.04451363f, -0.03293977f, -0.04412639f, 0.02304303f, 0.02563882f, -0.00308833f, 
    -0.06847834f, 0.03939767f, -0.05051516f, 0.00754482f, 0.03514739f, 0.03508430f, 0.04135206f, 0.02492537f, 
    -0.05446749f, -0.05203174f, -0.06260183f, -0.03260298f, 0.01422655f, -0.02941034f, 0.00748754f, 0.00532085f, 
    -0.00969722f, 0.04259815f, 0.05781757f, -0.02004335f, -0.05938850f, 0.04493906f, 0.03453241f, -0.07343689f, 
    0.04508216f, -0.01955202f, 0.00767616f, -0.00209859f, -0.05664740f, -0.06827767f, 0.02183052f, -0.07036798f, 
    -0.06935507f, -0.04568993f, -0.03068941f, 0.04750944f, -0.02072135f, 0.02509989f, 0.00075469f, -0.00895728f, 
    0.02625595f, 0.04958126f, 0.02298167f, 0.03960203f, -0.07204885f, 0.04891719f, -0.02185231f, -0.02790327f, 
    -0.05189421f, -0.01131022f, -0.00700632f, -0.07822326f, 0.01478373f, -0.00760897f, 0.03694439f, 0.01123679f, 
    -0.03349649f, 0.00645772f, 0.00114502f, 0.03753064f, 0.02753596f, -0.05484053f, 0.00869009f, 0.05180036f, 
    0.02196424f, 0.06849097f, 0.00315210f, -0.05456283f, 0.05510936f, -0.03656380f, -0.05325264f, 0.05908929f, 
    -0.05026732f, 0.04083604f, -0.06650727f, -0.00503761f, -0.06707512f, -0.05593780f, 0.06477001f, -0.06551515f, 
    0.00068606f, -0.01720894f, 0.03879142f, 0.06249479f, -0.06498360f, 0.01876869f, -0.02257025f, -0.01150607f, 
    -0.02886937f, 0.04088579f, -0.03207003f, 0.00102630f, -0.03169416f, -0.00432335f, -0.06095237f, -0.04025874f, 
    -0.03383099f, 0.01505221f, -0.00954612f, -0.06457897f, -0.00313748f, -0.03764817f, -0.05327341f, -0.07356702f, 
    -0.07327349f, 0.02203668f, -0.02860917f, 0.06537957f, 0.02426262f, -0.00646474f, -0.04086633f, -0.07496077f, 
    0.04686899f, 0.04082284f, -0.01943277f, 0.05132329f, -0.01477563f, -0.05581765f, 0.04497641f, -0.05537133f, 
    -0.03857021f, -0.03062074f, 0.00953243f, 0.05793142f, 0.05448849f, -0.04107577f, 0.02136518f, 0.03776974f, 
    0.03112378f, 0.05039297f, -0.05835217f, 0.01478138f, -0.06789701f, -0.07976098f, -0.01600706f, 0.00151426f, 
    0.05596045f, -0.01267465f, -0.05097456f, 0.01569765f, -0.01440324f, -0.07250284f, 0.06091332f, -0.05862011f, 
    0.05868470f, 0.01338516f, 0.01052352f, -0.06556257f, 0.02597760f, -0.07103185f, -0.00310893f, -0.03937361f, 
    0.00957998f, -0.01864755f, 0.00857223f, 0.06364069f, 0.00013437f, 0.02367101f, -0.06295352f, 0.00054879f, 
    -0.03689265f, 0.04778016f, -0.06909960f, -0.02179200f, -0.04782852f, 0.06137503f, 0.02169981f, -0.01396096f, 
    0.01555665f, -0.00935332f, -0.04087303f, -0.05029918f, 0.02139205f, 0.03891780f, 0.02487809f, 0.03237037f, 
    0.00165656f, 0.00151207f, 0.04508603f, -0.03238800f, -0.03422793f, 0.01378320f, 0.00078672f, 0.04929539f, 
    0.01199107f, -0.04898459f, -0.02239666f, -0.06203928f, 0.02068537f, 0.00490245f, 0.00753253f, -0.02689267f, 
    -0.03579189f, 0.00550675f, 0.02898782f, -0.07161216f, 0.04277031f, 0.05248616f, -0.05513720f, -0.07227185f, 
    0.02991471f, 0.02311142f, -0.06535994f, 0.04826555f, 0.04565123f, -0.01388727f, 0.05110141f, 0.05734465f, 
    0.03229493f, -0.03402643f, 0.06440528f, -0.00493189f, 0.04624421f, -0.06173580f, -0.07482859f, 0.00227310f, 
    -0.05950956f, -0.05976819f, -0.07667004f, 0.00512885f, 0.02061653f, -0.03987212f, -0.00694246f, -0.07739715f, 
    -0.02306901f, 0.03071202f, -0.02006202f, -0.06374019f, 0.01934336f, 0.04803983f, 0.03186122f, -0.00846037f, 
    0.02040431f, 0.03486278f, 0.01089090f, -0.07045091f, -0.02081805f, -0.06920580f, -0.06654807f, -0.04215697f, 
    0.03474825f, 0.03160461f, -0.01557616f, -0.05488861f, -0.01640070f, 0.00300441f, -0.06956460f, -0.06041065f, 
    0.05237807f, -0.03064367f, -0.07427467f, -0.00626706f, 0.00153484f, -0.03959104f, -0.01440313f, -0.07302937f, 
    -0.03241281f, -0.04158751f, -0.03596503f, 0.06429351f, -0.00683726f, 0.05726590f, -0.01937293f, -0.04486777f, 
    -0.00638512f, -0.00310181f, 0.04087814f, -0.06464887f, 0.04358048f, -0.07170863f, 0.04904127f, 0.00749745f, 
    -0.05661044f, -0.04731695f, -0.03127360f, -0.03572509f, -0.00731885f, 0.00218668f, 0.05016398f, 0.05110576f, 
    -0.02213435f, 0.00565982f, 0.00723189f, -0.04885487f, 0.00685172f, 0.02221546f, 0.01126924f, -0.06704561f, 
    -0.06786955f, 0.00538844f, -0.00178359f, 0.05597094f, -0.05255391f, -0.06195705f, 0.04649830f, -0.07347686f, 
    0.05846567f, 0.02311172f, -0.06292696f, 0.05956436f, -0.07696766f, -0.06879660f, -0.06778122f, 0.06238395f, 
    -0.03368071f, -0.09475619f, -0.06498728f, 0.02670212f, -0.03609551f, 0.06052319f, -0.01535338f, 0.01225982f, 
    -0.07498266f, 0.04662750f, 0.00228544f, -0.04248749f, 0.05076875f, -0.07822751f, -0.06947664f, -0.01050283f, 
    -0.02854984f, 0.06508734f, -0.03507221f, -0.01001254f, -0.01549127f, 0.00097908f, 0.01161895f, 0.00997072f, 
    0.05000591f, 0.05524644f, 0.05268303f, -0.03856101f, 0.03034163f, 0.03636154f, -0.07448939f, -0.00700991f, 
    -0.02102525f, -0.07702886f, -0.02833318f, -0.05479706f, -0.02507493f, -0.03459599f, 0.00668411f, -0.03637973f, 
    -0.05616038f, -0.04159328f, -0.02133370f, -0.01481094f, -0.02352353f, 0.04763968f, -0.00110466f, -0.05270386f, 
    -0.07164307f, -0.07116561f, 0.05433927f, -0.07296212f, 0.01942501f, -0.07739552f, 0.03052320f, 0.04645343f, 
    -0.06940237f, -0.01657582f, -0.00858385f, -0.00061633f, 0.06544468f, 0.05663372f, 0.04273047f, -0.06378531f, 
    0.05769257f, 0.06002669f, -0.02157335f, -0.06116172f, -0.02075423f, -0.00833970f, 0.02629752f, -0.06357330f, 
    0.00199966f, -0.02064268f, 0.00762802f, -0.02021293f, 0.02943780f, -0.05996627f, -0.00523693f, -0.06264688f, 
    0.00777172f, -0.00896109f, -0.03298638f, 0.04155030f, -0.02590510f, -0.05831792f, -0.06775971f, -0.06318872f, 
    -0.06151092f, -0.04822218f, -0.05493812f, -0.05715014f, -0.00800736f, -0.02174316f, 0.02295382f, -0.05067029f, 
    -0.03163334f, -0.04205145f, -0.02827649f, -0.02407541f, -0.04874162f, -0.02235020f, -0.00571541f, -0.05159610f, 
    -0.05515775f, 0.01678201f, -0.05653685f, -0.00703144f, 0.06571197f, -0.03604342f, 0.03728873f, 0.00245448f, 
    -0.04117705f, -0.06260381f, 0.03733009f, -0.03112168f, -0.03302608f, -0.04166692f, 0.01937865f, -0.07209175f, 
    0.04792523f, -0.03174168f, 0.03664345f, -0.03316426f, -0.06409625f, -0.03296464f, -0.01135626f, 0.02422817f, 
    0.01826747f, 0.05427874f, -0.05433463f, 0.00898790f, -0.04258403f, 0.00103097f, 0.05882750f, -0.03390811f, 
    -0.02492602f, 0.05619404f, 0.05594117f, 0.04939174f, 0.03851531f, 0.01525776f, 0.00190774f, -0.01360126f, 
    0.01015076f, 0.05862055f, -0.06150410f, -0.03512470f, 0.04633006f, 0.00711650f, -0.06891739f, -0.03023495f, 
    0.01709238f, 0.04180270f, 0.04805667f, 0.00488446f, -0.00067340f, 0.01923017f, -0.06316146f, -0.05144123f, 
    0.05066073f, -0.04843117f, -0.06539042f, 0.05249422f, 0.00487503f, -0.03778030f, 0.00752010f, -0.04878415f, 
    -0.03679857f, 0.06138277f, 0.02117250f, -0.05701531f, -0.01869063f, 0.04475030f, -0.03219517f, -0.04886447f, 
    -0.04501410f, -0.02391808f, -0.00145388f, 0.00753606f, 0.05784147f, 0.02423838f, 0.06354736f, 0.00310870f, 
    -0.02545819f, -0.04519242f, 0.01882762f, 0.00291003f, -0.01866156f, 0.00472422f, 0.04765549f, -0.05038891f, 
    0.03017491f, -0.05002076f, -0.04534277f, -0.02267711f, 0.02370955f, 0.02313295f, -0.03463110f, -0.03248959f, 
    -0.07053340f, -0.05810323f, 0.00203426f, 0.03474135f, -0.00809484f, 0.00753024f, -0.02529440f, -0.02033969f, 
    0.02984221f, 0.06462272f, 0.04438411f, -0.05773450f, 0.04611253f, -0.01209633f, -0.02837206f, -0.03555126f, 
    -0.06714459f, -0.04221139f, -0.02174124f, -0.01844398f, -0.05720278f, -0.05744406f, 0.05405943f, 0.00153528f, 
    -0.04726949f, -0.02464555f, -0.06778042f, -0.06428859f, 0.06448562f, -0.01176784f, -0.04100523f, 0.02414563f, 
    -0.05888684f, 0.04527610f, 0.04095182f, 0.06373732f, -0.04768040f, -0.05648275f, -0.03871994f, -0.02308171f, 
    -0.04098504f, -0.05098003f, 0.06311128f, -0.05700104f, 0.03762944f, -0.06747010f, -0.07190243f, 0.01332097f, 
    0.39281350f, 0.24022314f, 0.21596576f, -0.39821905f, 0.09444517f, 0.10119032f, 0.01488817f, 0.02552756f, 
    -0.09137212f, -0.03226447f, 0.07155400f, 0.28805405f, 0.02769712f, -0.14042777f, 0.04344528f, 0.29349196f, 
    0.18733026f, -0.13570949f, -0.05436585f, -0.16065723f, -0.03185561f, 0.10673069f, 0.12766656f, -0.00197941f, 
    -0.18359874f, 0.22049147f, 0.19521922f, 0.47367537f, -0.04660136f, 0.20440294f, -0.09183474f, 0.26085195f, 
    -0.00133714f, 0.03339496f, 0.00288697f, -0.10138799f, -0.48549181f, 0.06914297f, 0.01529571f, 0.17150399f, 
    -0.08715623f, -0.03405512f, 0.01809729f, 0.20378771f, -0.12001567f, -0.08780348f, 0.02527501f, 0.05833068f, 
    -0.20257294f, 0.25070402f, -0.08212935f, -0.02529174f, 0.05490089f, 0.09651958f, -0.13877569f, -0.04568087f, 
    0.02392736f, -0.16989245f, -0.07025422f, -0.17165498f, 0.23310654f, 0.05327915f, 0.16416164f, -0.46105871f, 
    -0.09554064f, 0.08322626f, -0.01191643f, 0.07837788f, -0.04567039f, -0.03744755f, 0.01592829f, 0.04635845f, 
    0.21957336f, -0.30141169f, -0.03232230f, 0.17579119f, -0.01611251f, 0.19974186f, 0.10324210f, 0.26270971f, 
    -0.02192433f, 0.10534558f, -0.02087891f, -0.05813039f, -0.18927468f, 0.20479748f, 0.15454823f, 0.24656077f, 
    0.00226597f, -0.11164628f, -0.11486459f, -0.10910995f, -0.10331362f, 0.07479072f, -0.13476330f, 0.05082364f, 
    0.28454214f, -0.27144873f, -0.01404932f, -0.04672787f, -0.10493875f, -0.09972499f, 0.12799792f, 0.25595376f, 
    0.10724039f, -0.06588476f, 0.12412644f, -0.02230786f, 0.64154446f, -0.21546549f, 0.12354982f, -0.37218487f, 
    0.09935802f, -0.19534217f, 0.03636384f, 0.07988531f, -0.09036611f, 0.00594697f, -0.10647021f, -0.08879061f, 
    0.17379209f, 0.25685856f, -0.23380548f, 0.10488264f, -0.16159169f, 0.01054754f, 0.13501483f, 0.29181388f, 
    0.13269627f, -0.01586936f, 0.01080823f, 0.29124135f, 0.13184088f, 0.02410502f, -0.23257211f, 0.11873989f, 
    0.09860293f, -0.12923130f, -0.14109609f, -0.00232293f, -0.19398916f, -0.08623602f, -0.01216959f, -0.06521162f, 
    -0.29780322f, -0.20146883f, -0.20838976f, 0.43298796f, -0.07234177f, 0.33929676f, 0.01921019f, -0.05722426f, 
    -0.10043141f, 0.11028557f, 0.05628087f, -0.03598425f, 0.13986976f, 0.23589200f, 0.22338545f, -0.17619255f, 
    0.16935825f, 0.09722617f, -0.04131092f, -0.16333033f, 0.08258345f, -0.03708613f, 0.07955731f, -0.05649555f, 
    -0.11573844f, 0.08208042f, -0.03104528f, -0.06353877f, 0.08669072f, 0.22493398f, -0.09059947f, 0.02613279f, 
    0.02027396f, 0.00308079f, 0.12793155f, -0.17641601f, 0.39030367f, 0.11605901f, -0.20651458f, -0.05034735f, 
    -0.06221905f, 0.07641172f, -0.05767400f, 0.21664144f, -0.02038099f, -0.07496934f, -0.10975891f, -0.11393960f, 
    -0.27967063f, -0.01939820f, -0.13986632f, 0.13086410f, 0.08604410f, -0.07795709f, -0.05189474f, -0.15978016f, 
    0.07985115f, 0.15571277f, 0.00116792f, 0.15435827f, 0.05095157f, -0.18165734f, -0.06264094f, -0.00362809f, 
    -0.05023009f, -0.05574321f, 0.10015931f, -0.06494347f, -0.01711540f, 0.27062884f, 0.06268540f, 0.11232013f, 
    0.11497912f, -0.11675321f, 0.23622103f, 0.12557933f, 0.19008039f, -0.17381269f, 0.01379864f, 0.06814294f, 
    -0.06504853f, -0.08768594f, -0.14045955f, -0.01094658f, 0.32122576f, -0.25153974f, 0.25380865f, -0.11752686f, 
    -0.03092223f, -0.01800427f, -0.12719163f, 0.28750414f, -0.09133513f, 0.04850062f, -0.01403836f, -0.11122329f, 
    -0.49758452f, -0.10958268f, 0.08543932f, -0.01943080f, -0.10452908f, 0.14266145f, 0.05881327f, 0.14513873f, 
    0.09325339f, -0.04881954f, -0.13923956f, -0.20116001f, 0.39652702f, 0.05842625f, 0.06109346f, -0.01383853f, 
    0.08330538f, 0.07418046f, -0.11259288f, 0.15907346f, -0.00366603f, -0.12921515f, 0.00375427f, -0.01221765f, 
    0.64776033f, 0.08409742f, 0.20761113f, -0.30111566f, -0.20697188f, 0.05848238f, 0.01875687f, -0.01150680f, 
    -0.05876378f, 0.00812428f, -0.08525617f, -0.00355981f, -0.02044873f, -0.27535978f, 0.07534474f, -0.20117082f, 
    -0.13251708f, -0.12800463f, 0.01194162f, 0.25441486f, -0.17250745f, 0.09783519f, -0.10804505f, 0.09896834f, 
    -0.04433801f, 0.01563932f, 0.12818252f, 0.35381651f, 0.04409269f, -0.07826702f, 0.09019145f, 0.13846239f, 
    0.09771810f, 0.07189469f, 0.21077776f, 0.11120606f, -0.10260768f, 0.28462243f, 0.20579012f, 0.13671049f, 
    -0.15338880f, 0.02704695f, 0.16477224f, -0.18080500f, 0.11416273f, -0.05483054f, -0.19376457f, -0.04934462f, 
    -0.08405315f, 0.01484490f, 0.04765294f, -0.31246194f, -0.01938255f, -0.00446803f, -0.05080718f, -0.00676333f, 
    -0.11558717f, 0.01177532f, 0.14759922f, 0.14772506f, 0.33982581f, 0.03829868f, 0.00474387f, -0.33018181f, 
    0.04780199f, 0.03985902f, 0.13420171f, -0.09062249f, -0.15696913f, -0.09944800f, -0.06149253f, 0.07405048f, 
    0.66032690f, -0.03854508f, 0.09605668f, -0.32536787f, -0.06896485f, 0.01018520f, 0.05134905f, -0.03907171f, 
    0.08040208f, 0.05317735f, -0.14673848f, -0.05307893f, 0.27035719f, 0.12298290f, -0.21396340f, 0.34747547f, 
    0.00664106f, 0.10455857f, 0.01036021f, 0.07908033f, 0.16714318f, 0.33554327f, 0.03052069f, 0.05307651f, 
    0.37603030f, 0.06387776f, 0.04802241f, 0.25982690f, 0.00657361f, 0.04047571f, 0.01823659f, 0.05984981f, 
    -0.00936477f, -0.22274384f, 0.00691503f, -0.24269608f, 0.17805192f, -0.23324615f, -0.00672862f, -0.24096212f, 
    0.09620499f, 0.10319566f, -0.08518344f, -0.10069401f, -0.04534673f, -0.00717288f, 0.19304936f, 0.03725214f, 
    0.00667786f, 0.03658668f, -0.07139681f, -0.02032687f, -0.00579200f, -0.00587585f, -0.06426287f, 0.00786994f, 
    -0.04042791f, -0.04221079f, -0.06934679f, -0.06626563f, -0.02299056f, 0.04901599f, -0.05163235f, -0.03232989f, 
    -0.01786259f, 0.01028919f, -0.01484462f, -0.05622330f, 0.01229394f, -0.03500640f, 0.00241892f, 0.05667109f, 
    0.06580258f, 0.02927608f, -0.06568378f, 0.01418889f, 0.02418303f, 0.05919362f, 0.05017036f, -0.06371271f, 
    -0.02267145f, -0.02436319f, -0.04682801f, -0.03328669f, -0.05983186f, -0.04213012f, 0.03384003f, 0.06600145f, 
    -0.03107205f, -0.04116443f, 0.06345922f, -0.03580082f, 0.02421404f, 0.06548807f, -0.02981849f, 0.05730969f, 
    0.00118440f, -0.03982310f, 0.04406058f, -0.02852222f, -0.01685474f, 0.05088334f, 0.01183851f, -0.04500063f, 
    -0.03882669f, -0.05312721f, 0.06745354f, 0.04352074f, -0.05706981f, -0.07129595f, 0.01077195f, -0.01732530f, 
    0.03984775f, -0.02506278f, 0.02430901f, -0.00873206f, -0.05492682f, -0.03596812f, 0.05496049f, -0.00425866f, 
    -0.05968773f, 0.00069099f, 0.05838104f, 0.06663537f, 0.04964801f, -0.07041255f, -0.01732206f, 0.02713842f, 
    0.00931180f, -0.03970097f, -0.04306488f, 0.00127896f, 0.01366248f, -0.02099426f, -0.00364549f, -0.04384283f, 
    0.02635240f, -0.07618312f, -0.04065486f, -0.05367555f, -0.04381987f, -0.06060125f, -0.03544778f, 0.03559020f, 
    -0.00109367f, 0.02613714f, -0.04366073f, -0.02431592f, 0.04779375f, -0.01109383f, 0.01394593f, 0.00108038f, 
    0.05170623f, -0.05916699f, 0.01835929f, 0.00915825f, -0.01115848f, 0.04613987f, 0.01550872f, -0.03860395f, 
    -0.02907931f, 0.00267081f, 0.03342967f, 0.00545835f, -0.06696946f, -0.04363431f, -0.07075135f, -0.01319123f, 
    0.03465199f, -0.02519845f, -0.02864732f, 0.00569836f, -0.01702342f, 0.06036474f, 0.04594938f, 0.04205813f, 
    0.03566910f, -0.02956492f, 0.03780205f, -0.02937260f, -0.06547009f, -0.07551602f, 0.03207975f, -0.06669614f, 
    -0.07311933f, -0.04307071f, -0.07208402f, 0.03411940f, -0.05471083f, 0.06715274f, -0.07421514f, -0.03775476f, 
    -0.00306013f, 0.01187824f, 0.03250497f, 0.06146454f, 0.06097532f, 0.03424428f, -0.03569307f, -0.01143852f, 
    -0.05208873f, -0.06376410f, -0.06388261f, -0.04855809f, -0.01098168f, -0.04479275f, -0.02109289f, -0.04139049f, 
    -0.05783911f, 0.00979756f, 0.01788764f, -0.02936002f, 0.01581199f, 0.05863973f, -0.02219154f, -0.01161177f, 
    0.04547448f, -0.01206307f, -0.04426420f, 0.06205622f, -0.02627979f, -0.05711962f, -0.05654999f, 0.06508724f, 
    0.05228299f, -0.05677291f, -0.05213730f, -0.02325782f, -0.04121790f, -0.06756049f, 0.04271125f, -0.07445757f, 
    0.03560087f, -0.07536020f, 0.03501030f, 0.03413154f, 0.05631391f, 0.00101735f, -0.05927020f, 0.06490447f, 
    -0.25355589f, 0.34967285f, -0.19828564f, -0.14599563f, 0.25611570f, -0.04696331f, 0.03502489f, 0.25845128f, 
    0.06756987f, -0.12544331f, 0.09467997f, -0.11458077f, -0.06488153f, 0.13851206f, -0.21795316f, 0.18926625f, 
    0.14596769f, 0.04714447f, 0.04331667f, 0.14994796f, 0.15388358f, -0.02305838f, -0.07390584f, -0.18053162f, 
    0.00173876f, 0.24818482f, 0.03437450f, 0.12565312f, 0.21816431f, 0.10295644f, 0.01986227f, 0.08111675f, 
    0.13498962f, 0.11214878f, 0.15522754f, -0.11664579f, -0.23669736f, -0.31827879f, -0.05466273f, 0.22659235f, 
    -0.12125583f, 0.09437221f, 0.21459852f, 0.03545268f, -0.03042531f, 0.06322133f, -0.15065275f, -0.00621266f, 
    0.17008840f, -0.02585086f, -0.14483668f, 0.12317745f, -0.02747121f, -0.21682605f, -0.09761168f, 0.02313262f, 
    -0.01512895f, 0.25630143f, 0.18675169f, 0.04203746f, -0.68323916f, 0.00287589f, 0.24109817f, -0.49011093f, 
    0.06640802f, -0.22581391f, -0.13400699f, 0.01286505f, 0.06518330f, 0.14801431f, 0.01317814f, 0.14376456f, 
    0.27705878f, 0.02712135f, -0.46735290f, 0.06988939f, 0.12461018f, -0.04260665f, -0.11594933f, -0.14236526f, 
    0.10059916f, -0.17976210f, 0.16373865f, 0.14062393f, 0.07812417f, 0.39572406f, -0.14131474f, 0.16493672f, 
    0.01433084f, 0.00301539f, -0.09639289f, -0.24904935f, 0.32385734f, -0.17587177f, 0.31054097f, 0.01575494f, 
    -0.29044321f, -0.11282095f, 0.03663419f, -0.14636679f, 0.04299891f, -0.12023909f, 0.28543520f, -0.13510744f, 
    0.00119400f, -0.01717388f, -0.00397567f, -0.01267547f, 0.09841372f, -0.10308474f, 0.02670777f, -0.44063979f, 
    0.05758003f, -0.00426316f, -0.18504885f, 0.17675890f, -0.11884861f, 0.14708751f, 0.04969494f, 0.03460998f, 
    -0.22691578f, -0.15798628f, 0.17651783f, -0.01752096f, -0.26887545f, 0.10765295f, -0.20233661f, 0.03260745f, 
    0.19913329f, -0.17276934f, -0.15432528f, -0.12043047f, 0.33099550f, 0.10779744f, -0.29328766f, 0.40435618f, 
    0.20548183f, -0.10231384f, -0.11935700f, -0.01871065f, 0.13006559f, 0.07890731f, 0.01621605f, -0.01503263f, 
    0.37383851f, 0.17001411f, -0.19309129f, 0.24591170f, 0.07062468f, 0.03234879f, -0.15163384f, -0.01464200f, 
    0.21932927f, 0.06354026f, 0.05713029f, -0.00200674f, 0.16469349f, -0.37204641f, 0.23838203f, -0.03436603f, 
    0.22480519f, 0.00279891f, -0.08803512f, -0.22276206f, 0.17607243f, -0.20874077f, 0.11386967f, -0.20647454f, 
    0.04411750f, 0.04074414f, -0.35133559f, 0.06486486f, 0.48577628f, -0.00229255f, 0.03347084f, 0.03806672f, 
    0.22037099f, 0.21330890f, 0.06152070f, 0.22513932f, 0.40150347f, -0.22092059f, -0.16979900f, 0.33059591f, 
    -0.07670368f, 0.04883090f, 0.12286870f, 0.15190628f, 0.15457487f, -0.07340101f, -0.12953322f, -0.04836262f, 
    0.00074952f, -0.00435110f, 0.06273222f, -0.01544052f, -0.07288770f, 0.00021421f, -0.06485713f, 0.00556908f, 
    0.06306422f, 0.02511413f, -0.01240120f, -0.04637586f, -0.04891794f, -0.07733220f, 0.01191847f, 0.04319379f, 
    0.04076659f, 0.03353992f, -0.04485193f, 0.05368099f, -0.05054430f, 0.05693271f, 0.05729324f, -0.07175486f, 
    0.03209295f, 0.00734758f, 0.01146140f, 0.00303962f, 0.02970764f, -0.03900068f, -0.05724724f, -0.04391538f, 
    -0.01498095f, -0.00933515f, -0.04047411f, 0.05782811f, -0.01261280f, 0.02219673f, 0.05237287f, -0.03645043f, 
    -0.07796396f, -0.01899632f, -0.00840493f, 0.03809161f, -0.03071850f, 0.05687120f, 0.03849775f, 0.00594682f, 
    -0.03869757f, -0.02891001f, -0.01576943f, -0.04482029f, 0.03633019f, -0.01054440f, -0.00698919f, -0.05710798f, 
    -0.05948475f, -0.06038265f, -0.06435586f, -0.01617133f, 0.01894161f, 0.04437280f, 0.02551010f, -0.02536855f, 
    -0.00454837f, -0.03941755f, 0.00646768f, 0.05374367f, -0.04302587f, 0.04419019f, -0.00037810f, 0.04898653f, 
    -0.06159357f, 0.04071127f, 0.03615765f, -0.06163940f, 0.04430138f, -0.04885471f, 0.00621575f, 0.01871697f, 
    -0.04018186f, 0.05716068f, 0.04415155f, -0.07683711f, -0.02109447f, 0.06573252f, -0.01373278f, -0.00916677f, 
    0.05107636f, -0.00041760f, 0.01168618f, -0.00958415f, -0.05303474f, 0.06413892f, 0.05557067f, -0.01051133f, 
    -0.04275390f, -0.07778972f, 0.02266732f, -0.03860562f, -0.03838674f, -0.00510985f, -0.05304361f, -0.05432627f, 
    0.00409038f, 0.00746856f, 0.06608035f, -0.02628400f, 0.00459193f, -0.03973249f, -0.02796647f, 0.00688283f, 
    -0.06459354f, -0.03877225f, -0.06208495f, -0.02422406f, -0.07199689f, 0.03782629f, 0.00666929f, 0.04101884f, 
    -0.05446827f, -0.04364068f, 0.01353701f, -0.00728720f, -0.03329508f, -0.04280815f, 0.00500457f, 0.05967297f, 
    -0.03403856f, 0.01281427f, -0.04369547f, 0.01372248f, -0.07661490f, -0.07089856f, -0.00627417f, -0.07641147f, 
    -0.02024231f, -0.03389375f, -0.02779355f, 0.05104161f, -0.01926481f, -0.01950494f, -0.06352000f, -0.06400315f, 
    -0.01020166f, -0.04314118f, -0.02046573f, -0.04397310f, -0.01022225f, -0.03291317f, 0.05826309f, 0.01964953f, 
    -0.01267251f, -0.00710498f, -0.07055385f, -0.06121452f, -0.05825770f, -0.02962812f, 0.05052246f, 0.04847324f, 
    0.00866610f, -0.06367315f, 0.00797192f, -0.06849311f, 0.02016727f, -0.00055668f, -0.01713308f, -0.01867482f, 
    -0.00208297f, 0.02850634f, 0.02563652f, 0.02372020f, 0.05013413f, 0.03600293f, -0.06018718f, 0.04433538f, 
    -0.05771228f, 0.04011437f, -0.03771711f, 0.05213407f, -0.02564663f, -0.04216099f, -0.01092525f, -0.04228996f, 
    -0.06671197f, -0.05112224f, -0.07336946f, -0.06553144f, -0.04313775f, 0.04960972f, -0.05844328f, -0.01287638f, 
    -0.08561886f, 0.05797578f, 0.01114762f, 0.05573319f, -0.04393205f, -0.08851227f, -0.00793225f, -0.00304888f, 
    -0.05377850f, -0.08102303f, 0.01706887f, 0.00697915f, -0.02677448f, 0.00186396f, -0.02533413f, 0.02146458f, 
    -0.06182896f, 0.05278090f, -0.00674958f, -0.03504769f, 0.03005547f, -0.07097770f, -0.03486069f, -0.01309381f, 
    -0.04987193f, 0.02330080f, -0.03675557f, -0.07984315f, -0.07662459f, -0.03100611f, -0.03872974f, -0.07262463f, 
    -0.02103134f, -0.07338853f, 0.01286364f, 0.02781763f, 0.05071296f, 0.02700604f, 0.04033075f, 0.05102025f, 
    -0.06489643f, 0.02425445f, 0.01816883f, -0.02639030f, -0.03689289f, -0.05982156f, 0.02765602f, -0.07207518f, 
    -0.03588772f, 0.01177408f, -0.05900475f, 0.02138927f, 0.05247152f, 0.03395454f, -0.07459601f, 0.04969613f, 
    0.03695482f, 0.01421780f, -0.05530526f, -0.02114470f, 0.04593317f, 0.02930073f, -0.00726303f, 0.04377620f, 
    -0.04670940f, 0.05061895f, -0.01361800f, 0.02550419f, 0.03747354f, -0.06416233f, 0.01006604f, 0.01487279f, 
    -0.00991529f, -0.06741943f, 0.02856440f, -0.06695789f, 0.01342366f, 0.02885475f, -0.04253488f, 0.02816035f, 
    0.03227699f, 0.04364773f, -0.03459782f, -0.02855065f, -0.02564240f, 0.04704940f, -0.04879293f, 0.01320099f, 
    0.02616313f, 0.01525037f, 0.02337987f, 0.00052342f, 0.02239240f, 0.04887087f, 0.05667116f, -0.06883825f, 
    0.02353196f, -0.07057534f, 0.00865011f, -0.06894027f, -0.05563630f, 0.01267013f, -0.01214555f, -0.00616464f, 
    -0.07786863f, -0.02482609f, -0.06622477f, -0.02740475f, 0.04608075f, -0.03525847f, -0.01350106f, -0.01055440f, 
    -0.02920510f, 0.04238416f, -0.02622828f, 0.03014773f, -0.06161233f, -0.02514667f, 0.00375687f, -0.02138117f, 
    -0.00103234f, -0.04921143f, 0.01205518f, -0.02430699f, -0.05849992f, 0.00517442f, -0.04438318f, -0.01475826f, 
    0.05828910f, 0.01803865f, -0.00267822f, -0.05418689f, 0.01835380f, 0.03989816f, 0.00401364f, -0.03526697f, 
    -0.00900618f, 0.05382782f, -0.03393849f, -0.06762796f, -0.00892784f, 0.02008460f, -0.03281898f, 0.01900398f, 
    -0.01328726f, 0.02034950f, -0.01389755f, 0.04769306f, 0.00110000f, 0.00082037f, -0.06651714f, -0.04591089f, 
    0.02352622f, 0.02770630f, -0.01641486f, 0.05585853f, 0.02563974f, 0.00632501f, -0.04763786f, -0.02987535f, 
    -0.04193003f, 0.02789747f, -0.00137511f, 0.01768576f, -0.01256526f, 0.02234592f, -0.06540219f, -0.00616446f, 
    0.04607875f, 0.00946977f, -0.01470709f, 0.03000838f, 0.00123043f, 0.04441352f, 0.05000252f, 0.05302025f, 
    0.04033163f, -0.08208553f, -0.07069720f, 0.03509799f, 0.01012486f, 0.05092889f, -0.04642054f, -0.05068624f, 
    -0.02830468f, -0.06753936f, -0.03365417f, -0.01221330f, 0.02086509f, 0.04069119f, -0.05885895f, -0.00794548f, 
    0.56771326f, 0.44589061f, 0.13442139f, 0.26525486f, -0.06117002f, -0.14044984f, -0.12872064f, -0.07000631f, 
    0.09187748f, 0.33512735f, 0.10567997f, 0.15864907f, -0.83646417f, -0.20163891f, -0.10016393f, -0.34693894f, 
    0.14057378f, 0.21483800f, 0.00391264f, 0.09057444f, -0.03196806f, -0.10592145f, 0.12320549f, 0.15319832f, 
    0.00533195f, -0.09248913f, -0.34360993f, -0.13131511f, -0.05909906f, 0.01164725f, -0.04982066f, 0.14570923f, 
    -0.02780489f, 0.03894451f, 0.00531976f, -0.18901591f, 0.08437031f, 0.32371658f, -0.04589539f, -0.39971781f, 
    0.00461594f, 0.00430498f, 0.05483658f, 0.02149390f, -0.05194894f, -0.13445768f, 0.03657565f, 0.00807697f, 
    0.49608269f, 0.27132291f, 0.17666991f, 0.35299519f, 0.05808276f, -0.05747417f, -0.06932894f, -0.22584468f, 
    0.14490452f, -0.08868292f, -0.18791860f, -0.07085527f, -0.02038169f, -0.46342647f, -0.19101033f, 0.05881541f, 
    -0.07945115f, -0.00023455f, 0.02731702f, 0.03359114f, 0.03459800f, 0.22990458f, 0.14622484f, -0.20399429f, 
    -0.38018766f, 0.18271764f, -0.08628427f, 0.55787474f, 0.08407302f, -0.04568045f, 0.02567013f, -0.03262057f, 
    -0.07231221f, 0.10800036f, -0.13797815f, 0.00146808f, 0.33190328f, 0.12628576f, -0.07629291f, 0.05037896f, 
    -0.06470041f, -0.17908260f, -0.22808181f, -0.15260856f, -0.05024888f, 0.07520055f, -0.09522305f, -0.06127164f, 
    0.33911037f, -0.00140559f, 0.00612198f, 0.01672226f, 0.01182644f, -0.09772510f, 0.27607763f, 0.02818899f, 
    -0.11170150f, 0.05592518f, -0.01605064f, 0.02223288f, -0.28668594f, 0.44352239f, -0.04365496f, 0.19448252f, 
    -0.09582511f, 0.29009792f, 0.12881789f, 0.02977727f, -0.02894453f, -0.04370759f, 0.16559559f, -0.07347512f, 
    0.17983909f, 0.04087788f, 0.03939817f, 0.58695304f, -0.07558382f, 0.21421365f, -0.08983546f, -0.15627147f, 
    -0.17258483f, 0.19824614f, -0.07472316f, -0.04566845f, -0.07371692f, -0.01203218f, 0.40965292f, 0.15720430f, 
    -0.06405065f, 0.06393932f, 0.12981053f, 0.18420301f, 0.12587984f, 0.02092603f, 0.08315789f, 0.02738985f, 
    0.45997187f, 0.21607159f, -0.32019398f, -0.05080556f, 0.09499742f, -0.04287849f, -0.02565700f, 0.02725171f, 
    0.03667819f, 0.02334074f, 0.02254462f, 0.14556132f, -0.15209404f, -0.43675998f, -0.09869348f, 0.15873395f, 
    0.06044523f, -0.03263908f, 0.11685821f, -0.19740120f, 0.10648254f, 0.06810547f, -0.20155394f, 0.04066931f, 
    -0.26224104f, 0.01812381f, -0.31212437f, -0.11137546f, 0.14568262f, 0.08939016f, -0.04162272f, 0.04686186f, 
    -0.12057029f, -0.16601218f, 0.13634257f, 0.05071061f, 0.43263203f, -0.02886502f, 0.29641962f, 0.45939541f, 
    0.14439131f, 0.10084110f, 0.17685887f, 0.12128495f, 0.18210113f, 0.07842048f, 0.34226176f, -0.06278946f, 
    0.17979659f, -0.01923723f, 0.14692934f, 0.18203568f, -0.05166486f, 0.01465463f, 0.01827820f, -0.11772313f, 
    -0.02741803f, 0.20563704f, 0.22260268f, 0.20795093f, -0.62182772f, -0.23870018f, 0.41288921f, -0.29873511f, 
    -0.01383972f, -0.00365583f, -0.01299737f, 0.03280926f, -0.15516827f, -0.04934819f, 0.18026496f, 0.12101757f, 
    0.13235499f, 0.04799191f, 0.02858187f, -0.09654757f, 0.00638232f, -0.01195430f, -0.17205794f, 0.13848293f, 
    0.06120116f, -0.07013254f, -0.00027755f, -0.17379203f, -0.38486785f, -0.21695007f, -0.11091522f, -0.54727417f, 
    0.02697444f, 0.06807598f, 0.00681994f, -0.03040324f, 0.11425938f, -0.23502515f, 0.04656669f, 0.06000617f, 
    -0.14183994f, -0.11008982f, -0.10881289f, -0.02042288f, -0.05890428f, -0.03887314f, -0.04934694f, -0.18221278f, 
    0.15886608f, -0.17581441f, -0.23889427f, 0.01098670f, 0.84167361f, -0.23540312f, -0.10720930f, 0.07907318f, 
    0.12208147f, -0.06180551f, -0.00677432f, 0.06500602f, -0.05650499f, -0.13557865f, 0.11796544f, 0.03503794f, 
    0.62088025f, 0.32373071f, -0.03820033f, 0.35682166f, -0.10658115f, 0.02179790f, -0.04628495f, 0.18910727f, 
    -0.11920271f, 0.00746204f, -0.02503238f, 0.01256073f, 0.01900335f, 0.03401169f, -0.15359612f, -0.42764205f, 
    0.00982369f, -0.07737829f, -0.11429603f, 0.05945440f, 0.00218771f, 0.04523506f, 0.00597562f, 0.16562799f, 
    -0.29056403f, -0.00683494f, -0.00006907f, -0.07158536f, 0.01133483f, -0.01478522f, 0.12378922f, -0.08602209f, 
    0.18410204f, 0.02223661f, 0.22518763f, 0.05319911f, 0.06516423f, 0.19921020f, 0.27447546f, 0.16876337f, 
    -0.01893069f, -0.09801359f, 0.04983662f, 0.03849312f, 0.25557551f, -0.00474001f, 0.01071453f, -0.12600689f, 
    0.04986962f, -0.06902428f, -0.05228515f, -0.10071947f, -0.01130403f, 0.08720281f, 0.07175004f, 0.07548428f, 
    -0.01591663f, 0.05459814f, 0.00165240f, 0.01014213f, 0.32179910f, 0.25269416f, 0.26767984f, -0.10933236f, 
    -0.12339102f, 0.14795353f, -0.06877274f, 0.11449517f, -0.08264359f, -0.01655387f, 0.14379890f, 0.11494274f, 
    0.75967860f, -0.01050883f, -0.16125649f, 0.09750655f, -0.14563033f, 0.07260331f, -0.09309154f, 0.12344968f, 
    -0.10521751f, 0.01017012f, -0.11777502f, -0.05562959f, -0.09834058f, 0.22352336f, 0.01213501f, 0.14911899f, 
    0.02653307f, 0.03962170f, 0.01989639f, 0.01131366f, 0.19942808f, 0.11201803f, 0.02609104f, 0.06917698f, 
    -0.15530901f, 0.07101608f, 0.12690020f, -0.04483099f, 0.05303032f, 0.09366477f, -0.06568018f, 0.05583881f, 
    -0.21789706f, -0.10884661f, -0.08177789f, -0.01357856f, 0.07494384f, 0.01315193f, -0.02206863f, 0.29189631f, 
    0.09311713f, 0.03560675f, -0.00994847f, -0.12338648f, 0.09175391f, 0.10101061f, 0.26098442f, -0.00821565f, 
    0.52964741f, 0.05676302f, 0.38397065f, -0.12255185f, 0.16434939f, 0.05481878f, 0.09594531f, -0.09263601f, 
    0.05258373f, 0.27066588f, -0.03511096f, 0.16384491f, -0.12672861f, -0.25265619f, -0.22348692f, 0.11413489f, 
    -0.02100752f, -0.11283350f, -0.02385335f, -0.21916887f, -0.05765386f, 0.00734399f, 0.06086042f, 0.08263255f, 
    -0.28922701f, 0.21205696f, -0.01342849f, 0.18134846f, -0.11482130f, 0.18916932f, 0.14840548f, -0.00083393f, 
    0.07336354f, 0.00522276f, -0.03032982f, -0.06436531f, 0.45777762f, 0.43565315f, 0.22462070f, 0.25017253f, 
    -0.13956101f, 0.06358144f, 0.16218112f, 0.20909823f, -0.07163262f, -0.13395323f, 0.14128202f, 0.08951126f, 
    0.19447097f, 0.31468946f, 0.13506286f, 0.02525241f, 0.02524422f, 0.14792629f, -0.06795695f, 0.02508263f, 
    0.23143797f, -0.19481584f, -0.07122688f, -0.24357469f, -0.12462597f, -0.21869913f, 0.12017991f, 0.00133915f, 
    -0.01987143f, 0.02459210f, -0.00911389f, -0.00592519f, -0.02198953f, 0.00294378f, -0.07092606f, 0.08982808f, 
    -0.50609380f, -0.21828289f, 0.06677069f, -0.01978258f, -0.00328987f, 0.14286380f, -0.02379661f, 0.15024379f, 
    -0.02155957f, 0.22615193f, -0.11242861f, -0.04731105f, 0.11206743f, 0.10841441f, 0.17280461f, 0.25324056f, 
    -0.14134167f, -0.11030108f, 0.04271527f, -0.10612231f, -0.11618500f, 0.14936733f, -0.15262863f, 0.17215009f, 
    0.07461460f, 0.00555725f, 0.28162599f, 0.25312230f, -0.11934173f, -0.17858697f, 0.12058284f, 0.21507113f, 
    0.04225327f, 0.01203661f, -0.02075501f, -0.05424669f, 0.34629560f, -0.12329593f, -0.08844991f, -0.07305887f, 
    0.04490278f, 0.00593285f, 0.30853170f, 0.11737350f, -0.06044399f, 0.06848765f, -0.09797984f, -0.07224093f, 
    0.47679442f, 0.27654856f, -0.08046123f, -0.18342222f, 0.04642245f, 0.18654454f, 0.12108991f, -0.02594735f, 
    -0.06084802f, 0.07073183f, -0.02303043f, 0.30309314f, -0.22810045f, 0.31926677f, -0.19537461f, 0.07330628f, 
    0.12449437f, 0.05503790f, 0.01597435f, -0.03185864f, 0.00499703f, -0.06348351f, 0.05040161f, 0.06616832f, 
    -0.62650973f, -0.38022253f, -0.14043686f, -0.03335593f, 0.08721154f, 0.21183962f, -0.09239133f, -0.00290797f, 
    -0.07479338f, 0.25226289f, -0.00917378f, 0.00251679f, -0.05952444f, -0.13346358f, -0.07549980f, 0.25556213f, 
    0.10222050f, 0.02285607f, -0.02379961f, -0.07174826f, 0.00240499f, 0.03014703f, 0.11538506f, 0.06796668f, 
    -0.21452604f, -0.12521888f, -0.15326335f, -0.11289319f, -0.04355587f, -0.00737970f, -0.09382657f, -0.06395463f, 
    0.02081557f, 0.02878803f, 0.02783728f, -0.16642961f, 0.04077366f, 0.15741839f, 0.01098774f, -0.18372275f, 
    0.07659446f, -0.03804456f, -0.08172576f, -0.01310290f, 0.18377483f, 0.04600696f, 0.26469776f, 0.10015001f, 
    -0.69389063f, 0.39556867f, 0.11587304f, 0.06421953f, 0.03181896f, -0.03302300f, -0.06119351f, 0.08472013f, 
    -0.07798112f, -0.19779301f, -0.03186245f, 0.06861417f, -0.08837706f, 0.15752377f, 0.15794937f, -0.05964473f, 
    -0.23493676f, -0.11535071f, 0.07611002f, 0.03417022f, 0.01156275f, -0.01653451f, -0.01009750f, 0.10210194f, 
    0.28917864f, -0.31720075f, -0.28536385f, -0.03146836f, 0.03222305f, 0.00110077f, -0.15615802f, -0.07879855f, 
    -0.13716714f, -0.02223905f, 0.01293369f, 0.10172088f, -0.38587469f, -0.02048631f, -0.10228065f, -0.25240397f, 
    0.03328115f, 0.01138128f, -0.19956505f, -0.00158346f, 0.14809591f, 0.00357371f, 0.07824716f, 0.04183057f, 
    0.00834916f, -0.14888921f, 0.29713494f, 0.44690993f, 0.13367878f, 0.00899116f, -0.03946273f, -0.02033654f, 
    -0.12470363f, -0.02345773f, 0.07970854f, 0.20634562f, -0.28326496f, 0.50973994f, -0.15014859f, 0.01411970f, 
    -0.09426562f, 0.12715690f, 0.14597151f, 0.16145223f, 0.09350374f, 0.05690730f, -0.07306816f, -0.20357671f, 
    0.13326028f, -0.02794304f, -0.11120515f, 0.01065082f, -0.21829733f, 0.11301202f, 0.23623456f, 0.14521664f, 
    0.05626592f, -0.03202461f, -0.07261065f, 0.07375403f, -0.06727663f, 0.06885487f, -0.02003765f, 0.30659366f, 
    0.12895906f, 0.04232686f, 0.07084979f, 0.25406078f, 0.04307047f, 0.05863471f, 0.16139312f, -0.04605262f, 
    -0.22785197f, 0.09318683f, -0.46384400f, -0.03930212f, 0.11384841f, 0.17208706f, 0.05170230f, -0.10463209f, 
    -0.07526527f, 0.07583335f, 0.08111349f, -0.07861486f, -0.38629320f, 0.16744107f, -0.14331099f, -0.08229783f, 
    -0.03056633f, -0.03028633f, -0.11373715f, 0.04162025f, 0.19705413f, -0.01479790f, -0.03977840f, 0.03628952f, 
    0.07099628f, -0.27666059f, 0.04660202f, 0.18830593f, 0.04965059f, -0.13844572f, 0.18962415f, 0.22255035f, 
    -0.07176152f, 0.04096129f, 0.07161865f, 0.06004128f, 0.31630233f, -0.33590853f, -0.09373503f, 0.04271074f, 
    -0.09949470f, -0.08138059f, 0.26684293f, 0.11701953f, -0.24283040f, 0.09327393f, -0.06077173f, -0.29006329f, 
    0.28784397f, -0.32340696f, 0.02184424f, 0.51794803f, -0.17349911f, -0.10914534f, 0.18104479f, -0.00113303f, 
    0.16102429f, -0.00823460f, 0.06720065f, 0.00946726f, 0.75394452f, -0.17653745f, 0.20832129f, 0.39039388f, 
    -0.08064257f, 0.23085646f, 0.12662610f, 0.06369013f, -0.02263107f, 0.00875312f, -0.00668730f, 0.16073194f, 
    0.39826423f, -0.09845619f, 0.09700859f, 0.27723894f, -0.20101985f, 0.15141402f, 0.12899652f, 0.09708042f, 
    0.04086931f, -0.03895442f, -0.03754748f, 0.09281391f, -0.28193909f, 0.04066582f, 0.03773895f, 0.00397380f, 
    -0.02080249f, 0.00156467f, -0.10758532f, 0.13269077f, -0.15505423f, -0.04621908f, -0.26416939f, -0.00186236f, 
    0.41266727f, -0.27926630f, -0.07388471f, -0.07173806f, -0.21002120f, 0.15959878f, -0.02687578f, 0.11642618f, 
    0.06468959f, -0.22955880f, 0.07125884f, -0.22963801f, 0.21452188f, 0.41392487f, 0.39543614f, -0.05291359f, 
    0.01368303f, -0.00652153f, -0.00617194f, -0.01163743f, 0.13714230f, -0.13808869f, -0.06146270f, 0.10344224f, 
    0.34000093f, 0.25430965f, -0.02211883f, 0.01734357f, -0.15713233f, -0.01218853f, -0.00008189f, 0.05827313f, 
    0.07939772f, 0.11403184f, 0.11828993f, 0.17145143f, 0.10617225f, -0.06690269f, -0.07767043f, 0.07740181f, 
    0.14453115f, 0.14968500f, 0.13524330f, -0.28302062f, 0.13028654f, 0.12772818f, -0.11585925f, 0.02999944f, 
    -0.37909737f, -0.16422133f, -0.18330148f, -0.26763955f, -0.03523530f, -0.01353524f, 0.10100204f, -0.16935745f, 
    -0.05514513f, 0.13704364f, 0.24305977f, 0.29185405f, -0.44574597f, 0.07691314f, -0.13763170f, 0.37705207f, 
    -0.00010858f, -0.09459080f, 0.05292096f, -0.10211116f, 0.10821909f, 0.11413828f, -0.02838539f, -0.00995617f, 
    0.02990510f, 0.38911277f, -0.35218012f, 0.07052497f, 0.14412314f, 0.03120067f, 0.12046936f, 0.12945800f, 
    -0.11166354f, -0.26722535f, 0.09307262f, 0.04632697f, -0.48321232f, -0.12920615f, 0.08696955f, -0.01762178f, 
    0.16883327f, 0.18338782f, -0.04475626f, -0.00513197f, 0.22745864f, -0.04344826f, 0.22650582f, -0.03910855f, 
    0.00872548f, -0.14736883f, -0.10564157f, -0.38358518f, 0.06955478f, 0.32128477f, -0.02014794f, -0.25240803f, 
    0.05627253f, 0.00501127f, -0.02936350f, 0.02297500f, 0.38910273f, -0.34019414f, -0.03961038f, 0.10242109f, 
    0.12001061f, 0.00450366f, -0.08249740f, 0.07062618f, 0.14215605f, 0.02872316f, 0.08502446f, 0.06526542f, 
    -0.16650085f, -0.34471080f, 0.04103017f, -0.14630497f, 0.19600242f, -0.09337121f, -0.16558973f, 0.20163648f, 
    0.27990320f, -0.07411006f, -0.06447966f, -0.14108582f, -0.02769012f, 0.21777377f, -0.05412468f, -0.01265039f, 
    -0.12734672f, 0.03080282f, 0.06287326f, 0.11202087f, 0.03563309f, -0.02603829f, 0.11399721f, 0.08314417f, 
    -0.21270168f, 0.40650868f, 0.01042151f, 0.20616803f, 0.00120583f, 0.17288752f, 0.13821539f, 0.16130871f, 
    -0.03060353f, -0.21531212f, 0.13403276f, -0.07064419f, 0.21689835f, -0.24777688f, 0.48888364f, 0.20053357f, 
    0.18662806f, 0.11985268f, 0.01207722f, 0.00966429f, 0.12529716f, 0.00277306f, 0.12797508f, -0.12068832f, 
    0.06274310f, 0.21248354f, 0.19675077f, 0.25584590f, 0.13362688f, 0.07843510f, 0.20330694f, -0.09300611f, 
    -0.15442851f, 0.15579213f, 0.05050166f, 0.32811999f, -0.02354438f, -0.07191631f, 0.16201845f, 0.10211545f, 
    -0.17817985f, -0.02996692f, 0.07564227f, 0.01933287f, -0.01935145f, -0.03668995f, -0.14279301f, -0.02219775f, 
    -0.12182525f, -0.17594314f, 0.20863013f, 0.19047473f, -0.05691044f, -0.04571233f, -0.14178544f, 0.09772449f, 
    -0.20388231f, -0.06107326f, -0.17629856f, 0.07916883f, 0.11949282f, -0.09464880f, 0.03079493f, 0.05712666f, 
    -0.14967626f, 0.01877349f, -0.23169184f, -0.19858567f, 0.06814308f, -0.20438427f, -0.12623258f, -0.08987933f, 
    0.08098687f, 0.17615423f, 0.08189563f, 0.23473181f, 0.16636646f, -0.01125393f, -0.13102509f, 0.20016915f, 
    0.01188864f, 0.02127691f, -0.16878740f, -0.27415425f, -0.23250209f, 0.21815535f, 0.27790651f, 0.34137195f, 
    0.46547350f, -0.08480969f, -0.08188091f, 0.12941670f, 0.07379404f, -0.12287591f, 0.22108361f, -0.07593498f, 
    0.60738254f, 0.21095879f, 0.13249725f, 0.12759668f, -0.16917348f, -0.11495351f, -0.08972678f, 0.00633170f, 
    -0.04262496f, 0.03776177f, -0.22637776f, 0.01505739f, 0.30446872f, 0.16085160f, 0.27183411f, -0.14166193f, 
    -0.18452775f, -0.05078445f, -0.06044533f, 0.17308749f, -0.08125754f, 0.10947467f, 0.09272800f, -0.27917132f, 
    0.36783358f, -0.13821894f, -0.29295704f, 0.13339356f, -0.10074701f, 0.08557532f, -0.05854470f, 0.22104430f, 
    0.09505001f, 0.02963677f, -0.02704666f, -0.20792010f, 0.46450421f, 0.22821273f, 0.42911074f, 0.56569451f, 
    0.22843893f, 0.27485487f, 0.12228866f, 0.07300074f, -0.11636830f, -0.07875338f, -0.14670396f, -0.18542814f, 
    0.28377950f, 0.25978574f, 0.16984019f, 0.12640157f, 0.05667542f, 0.21074684f, 0.15807253f, -0.14197980f, 
    -0.13780910f, 0.01888955f, -0.13989490f, 0.02687023f, 0.10468306f, -0.08723781f, 0.00783046f, -0.08567122f, 
    -0.15345235f, -0.10863607f, -0.14532235f, -0.22550987f, -0.26770517f, -0.11111737f, -0.29140082f, -0.07120676f, 
    0.32203227f, 0.30800635f, 0.16385621f, 0.57818985f, 0.11159875f, 0.15252818f, -0.08521885f, 0.06052877f, 
    -0.04809094f, -0.19575527f, 0.05319910f, 0.21857259f, 0.01482527f, 0.13717102f, -0.03412202f, 0.25799024f, 
    -0.28623942f, -0.05888357f, 0.04980239f, 0.01478842f, -0.12712674f, 0.03299927f, 0.08179333f, -0.25599128f, 
    0.18189482f, 0.06133644f, -0.11865587f, -0.14943761f, -0.12504677f, 0.00080385f, -0.01822463f, -0.03865341f, 
    -0.10837846f, -0.19283992f, 0.07979110f, 0.02745309f, -0.52480006f, 0.30383074f, -0.15601146f, -0.10863876f, 
    -0.00293685f, -0.00286235f, 0.13991892f, 0.01023495f, -0.15412511f, -0.00185227f, -0.00300770f, -0.20841993f, 
    0.17334382f, -0.20924166f, 0.07217652f, 0.00762935f, 0.13622370f, -0.10069327f, -0.06366240f, 0.03520012f, 
    -0.10178484f, -0.14784639f, -0.20892788f, -0.06147199f, -0.28267565f, -0.09373219f, -0.41513202f, -0.31775296f, 
    -0.17274681f, 0.02190892f, 0.14463322f, -0.06386009f, -0.20452894f, -0.02738462f, -0.29175740f, -0.05982162f, 
    -0.70151055f, 0.10054419f, 0.07386755f, 0.15881987f, 0.05334510f, 0.11903016f, 0.00314291f, 0.03513302f, 
    0.01597801f, -0.07649343f, -0.16622406f, -0.04116042f, 0.50074780f, -0.05351889f, -0.16489734f, -0.04953213f, 
    -0.05017297f, -0.00547935f, -0.11192976f, 0.25095358f, 0.05498688f, 0.24835896f, -0.03120166f, 0.03754580f, 
    0.20614763f, -0.24219300f, -0.02093326f, -0.26628649f, 0.07943427f, 0.07076787f, 0.13855374f, -0.17901133f, 
    0.03990586f, -0.07468708f, 0.03545852f, 0.29522336f, -0.24902150f, 0.11005453f, -0.14355478f, -0.23813212f, 
    0.06935550f, -0.04506284f, -0.05967306f, 0.10723156f, 0.24450219f, 0.09666882f, 0.09609428f, 0.15001734f, 
    0.43061382f, 0.02609702f, 0.19338864f, 0.19750640f, 0.07144065f, 0.11843068f, 0.11338848f, 0.04755420f, 
    0.03159982f, 0.25452802f, 0.12945893f, 0.15783627f, 0.21931244f, 0.14605466f, 0.12545557f, 0.08603487f, 
    0.03711408f, -0.00284432f, 0.10398512f, -0.01329187f, 0.11936693f, 0.06071220f, -0.01064355f, 0.07739001f, 
    -0.27002615f, -0.15855491f, 0.16868325f, -0.13654454f, -0.02615231f, 0.04023781f, -0.09925097f, -0.02593361f, 
    0.27960515f, 0.05728463f, 0.23932463f, 0.14888933f, 0.36381647f, 0.08443610f, 0.05053849f, -0.04197351f, 
    0.19166152f, 0.11359054f, 0.22984028f, 0.11204787f, 0.05120863f, -0.05319599f, -0.03212762f, -0.00840571f, 
    0.18132293f, 0.14421359f, -0.16904673f, 0.20691508f, 0.05156107f, -0.14155726f, -0.07457333f, 0.00260471f, 
    -0.15411429f, 0.07764290f, -0.15639685f, -0.06950568f, -0.55109781f, 0.03418338f, -0.06334928f, -0.04275522f, 
    -0.06014349f, -0.00365652f, -0.11737531f, 0.05185173f, -0.02749272f, -0.02864333f, 0.00367358f, 0.24839725f, 
    -0.20834714f, -0.01874783f, 0.08912948f, -0.12950191f, 0.18085177f, -0.14558803f, 0.09580205f, 0.03599797f, 
    0.03754564f, 0.05102746f, -0.04802004f, 0.00366220f, -0.12527500f, -0.03751679f, 0.17803051f, -0.24121563f, 
    0.05937635f, 0.01764373f, 0.08190757f, -0.02871841f, -0.02675159f, 0.12415625f, 0.05924294f, 0.00286754f, 
    -0.30638278f, -0.47434777f, 0.02905885f, 0.08794809f, 0.11467048f, -0.23434690f, 0.05960799f, 0.02021436f, 
    0.16239250f, -0.02486863f, 0.04135475f, 0.17420839f, -0.19654311f, 0.05425908f, -0.24757256f, 0.04587956f, 
    -0.03514351f, -0.11451121f, 0.03360842f, 0.08022824f, -0.07097793f, -0.10481045f, 0.12085320f, 0.05931275f, 
    0.03867504f, -0.35124123f, -0.05740527f, 0.30586484f, -0.17856553f, -0.22876342f, -0.00026220f, -0.03743195f, 
    0.01974930f, -0.06974626f, -0.08569273f, 0.11104789f, -0.40905374f, 0.34474424f, 0.04300498f, -0.23293185f, 
    0.05099113f, -0.10310421f, 0.01423464f, -0.02685455f, 0.00276394f, -0.02213896f, -0.11919493f, 0.16741064f, 
    -0.53617430f, -0.16249652f, -0.15680632f, -0.03573231f, -0.00824359f, 0.07576098f, -0.03752358f, -0.12380655f, 
    -0.14056391f, 0.04318562f, -0.01594834f, 0.13103163f, 0.23843633f, -0.21070430f, -0.07404298f, -0.02802434f, 
    -0.02937984f, -0.04574822f, 0.17303784f, -0.00401503f, 0.03055810f, -0.10670716f, 0.14160186f, 0.05581124f, 
    0.01785530f, -0.31933394f, -0.12936042f, -0.07786766f, 0.10242791f, 0.19325978f, 0.20403878f, -0.01708847f, 
    -0.02484533f, -0.07545577f, -0.06786425f, 0.13654609f, 0.65347284f, -0.07159074f, 0.12163468f, 0.01896635f, 
    0.11922493f, -0.01586575f, -0.05954690f, 0.20346138f, -0.05167650f, 0.11391389f, 0.14464749f, -0.07635847f, 
    -0.36694548f, -0.22023951f, 0.18367417f, 0.17388327f, -0.10184232f, 0.10545368f, 0.03840113f, 0.08016700f, 
    0.13459028f, -0.28006917f, -0.09851520f, 0.00874090f, 0.05349332f, 0.34434438f, -0.01678024f, 0.28289443f, 
    0.00482861f, 0.15346889f, -0.07034089f, 0.03194165f, -0.03428153f, 0.04192866f, 0.06973810f, -0.00292728f, 
    -0.09741990f, 0.20086172f, 0.39924705f, -0.14578876f, -0.12398148f, 0.04881854f, 0.21864963f, 0.08274373f, 
    0.20274080f, 0.19133350f, -0.17497554f, 0.00334836f, -0.27862078f, -0.38883895f, -0.09302647f, 0.22107309f, 
    0.03155498f, -0.13570195f, -0.05764470f, 0.26828998f, 0.03336334f, 0.18424185f, -0.16985959f, -0.07501947f, 
    -0.62524140f, -0.01499442f, -0.40060773f, 0.05935127f, 0.21483117f, 0.03058271f, -0.11182003f, 0.22573121f, 
    0.13127752f, 0.12564984f, 0.12515120f, 0.02892587f, 0.15791422f, -0.15337317f, -0.11636660f, 0.23722662f, 
    0.17240655f, -0.02540825f, 0.21448930f, 0.14351635f, -0.05726551f, 0.09308916f, -0.24100794f, -0.11166085f, 
    0.16163045f, -0.03579596f, -0.03404671f, -0.03794874f, 0.04170094f, 0.05156694f, 0.05449403f, 0.00847549f, 
    -0.01958541f, -0.07538426f, 0.21109864f, 0.12940323f, -0.03998761f, -0.31286523f, 0.03651103f, -0.18643151f, 
    -0.01350327f, -0.25373545f, 0.14210401f, -0.26077294f, -0.03509285f, -0.15463054f, 0.02158268f, -0.14700119f, 
    -0.38394594f, -0.08818536f, 0.42775276f, 0.15458457f, -0.20887509f, -0.12868518f, 0.12768836f, -0.17878729f, 
    -0.01704020f, 0.08352755f, 0.01706416f, 0.09583693f, 0.52877891f, 0.23042382f, 0.15374872f, 0.11517023f, 
    -0.13688903f, -0.01502617f, -0.03766070f, 0.14771806f, -0.12575106f, 0.14616217f, 0.06847437f, 0.14096549f, 
    0.45677790f, 0.09208675f, 0.48021913f, 0.12989531f, -0.29325879f, 0.01725078f, -0.08136718f, -0.00805665f, 
    0.22679695f, 0.06535908f, 0.00805387f, -0.20719208f, -0.51897109f, 0.09405389f, 0.09080955f, -0.40642658f, 
    0.28735372f, 0.00103467f, -0.11185674f, 0.15237097f, -0.04167906f, -0.11883954f, 0.17467022f, 0.02380900f, 
    -0.04598834f, -0.05696806f, -0.05795911f, -0.00452714f, 0.02346174f, -0.04679136f, -0.03652890f, -0.05022112f, 
    0.01162499f, 0.01025902f, 0.01518383f, -0.07574003f, -0.01316665f, 0.02595115f, 0.00881339f, 0.03499904f, 
    -0.07015989f, -0.03930631f, 0.04369795f, 0.01365674f, -0.08234677f, 0.01117815f, 0.04078623f, 0.00089452f, 
    0.02173346f, 0.03204106f, 0.05911646f, -0.00682772f, 0.00837546f, 0.03242485f, -0.07287721f, -0.05184399f, 
    -0.00347895f, -0.03988002f, 0.00917823f, -0.03142495f, 0.01304165f, 0.05203989f, -0.08211676f, -0.00732736f, 
    0.02643623f, -0.05524028f, -0.01708098f, -0.03776486f, 0.04550431f, -0.00229838f, 0.00835062f, -0.02097816f, 
    -0.02998043f, 0.04330721f, -0.06305154f, -0.06705725f, -0.03081993f, -0.08513064f, 0.04828979f, -0.04753394f, 
    -0.00048365f, -0.07549932f, -0.04644129f, -0.06206383f, 0.01203555f, -0.06275960f, -0.04802562f, -0.01772980f, 
    -0.05482754f, 0.00001182f, 0.00653564f, 0.06168884f, 0.02467115f, -0.04374865f, -0.08159640f, 0.00676575f, 
    -0.02598359f, 0.05614124f, 0.04141892f, 0.02881096f, -0.05704748f, 0.02874906f, 0.02983524f, 0.04846967f, 
    0.00397411f, -0.01360647f, 0.05962252f, -0.06449618f, -0.04469822f, 0.05059963f, 0.01124762f, -0.00102560f, 
    -0.04427326f, -0.07274449f, -0.06683353f, 0.01038759f, -0.06076587f, -0.06873871f, -0.06009453f, 0.03978897f, 
    0.04148142f, -0.02099298f, -0.04320214f, -0.04091132f, -0.05981998f, -0.00437977f, 0.04837416f, -0.00467466f, 
    0.02210693f, -0.06725380f, -0.05253633f, -0.06509770f, 0.02005822f, -0.07768928f, 0.07420301f, 0.03031522f, 
    -0.03665606f, -0.04515396f, 0.04524156f, 0.02021464f, -0.04183844f, -0.04013767f, 0.04559137f, -0.05502627f, 
    0.05141714f, -0.03513857f, 0.03668933f, -0.01927867f, 0.03615525f, 0.01351014f, 0.04014348f, 0.02407019f, 
    0.04191116f, -0.07297509f, -0.06259043f, 0.01650334f, -0.00805293f, 0.03558736f, 0.06282794f, -0.07793684f, 
    0.01244196f, 0.06924619f, -0.04314283f, -0.04153564f, 0.01548243f, -0.07453591f, 0.04987206f, 0.02402066f, 
    -0.00164179f, 0.01305740f, -0.04374453f, 0.03656970f, -0.07351381f, -0.01213069f, -0.04877846f, -0.05469361f, 
    0.05732879f, -0.01334881f, 0.04681262f, 0.02724614f, -0.04053951f, -0.04797049f, -0.06864045f, 0.02518578f, 
    0.05274165f, -0.01120681f, -0.01762584f, -0.03248680f, -0.02320508f, 0.04045660f, -0.02347690f, -0.02299656f, 
    -0.02023993f, 0.03578163f, -0.02194072f, 0.01458748f, -0.03701054f, 0.05712967f, -0.02964482f, 0.04696921f, 
    -0.00638633f, 0.00033939f, -0.08500680f, 0.05320044f, -0.00947898f, 0.06439167f, 0.04830243f, 0.06489260f, 
    0.05271214f, -0.01217758f, 0.00669540f, 0.05118642f, 0.01887271f, 0.01033042f, 0.00391932f, -0.03510142f, 
    -0.17815201f, -0.36231422f, 0.20608301f, -0.11124051f, -0.00526130f, 0.14163972f, 0.20186475f, 0.05390569f, 
    -0.03169316f, -0.13381389f, -0.03459703f, -0.03921205f, 0.41990620f, 0.14931053f, 0.35918009f, 0.15076290f, 
    -0.00560468f, 0.02059715f, -0.07418150f, 0.02831310f, 0.11167449f, -0.03159026f, -0.14329351f, -0.05706592f, 
    0.11814038f, 0.16473764f, 0.08993521f, -0.18362848f, -0.07716645f, 0.18168999f, 0.08172952f, -0.03596176f, 
    0.12619983f, 0.09543979f, 0.02783661f, -0.01434573f, -0.64852858f, -0.01077995f, -0.31004840f, 0.09990916f, 
    0.23436978f, -0.00780623f, 0.17922412f, -0.11785917f, 0.15711561f, -0.00740075f, 0.07675877f, 0.13992536f, 
    0.21949749f, -0.03587620f, -0.11335784f, -0.15641880f, 0.05305825f, -0.04724263f, 0.03613127f, -0.04043056f, 
    -0.02934668f, 0.11482070f, 0.14515300f, 0.18774433f, 0.60676390f, 0.22857988f, 0.12001494f, 0.16217488f, 
    -0.00536441f, -0.08829734f, 0.17631467f, -0.18325129f, 0.02449883f, -0.02800098f, -0.07770931f, 0.23290752f, 
    0.14372748f, -0.08006744f, 0.08762491f, 0.01995439f, 0.11996324f, -0.11210538f, 0.00424392f, 0.10754607f, 
    0.22004262f, -0.10950547f, 0.15530707f, -0.01040117f, -0.11311966f, 0.22948390f, -0.02877881f, -0.00297919f, 
    0.26203769f, 0.26707342f, 0.01769863f, -0.10739217f, 0.03029746f, -0.06514822f, -0.06789067f, -0.06391770f, 
    -0.19825211f, 0.19335352f, 0.03473891f, -0.30031633f, 0.16517179f, 0.00831423f, -0.16823000f, -0.16224182f, 
    0.02397889f, 0.01159809f, -0.11712340f, 0.04452404f, 0.19787125f, -0.39538962f, 0.08544338f, -0.00032654f, 
    0.31555653f, -0.13357386f, -0.10492526f, 0.07770865f, 0.02620576f, -0.04777615f, 0.18506391f, 0.05852378f, 
    0.01916009f, 0.18645225f, 0.03493890f, -0.00216223f, 0.10861434f, -0.17709182f, 0.05635156f, 0.17708392f, 
    0.28199893f, -0.03463748f, 0.05332026f, -0.12892967f, -0.10350604f, 0.23114087f, -0.03685698f, -0.03455833f, 
    -0.06212328f, 0.08002510f, -0.21460751f, -0.01605782f, -0.07830425f, -0.05466893f, 0.11557042f, 0.03449414f, 
    -0.39600268f, -0.19028845f, -0.13884617f, 0.18440856f, 0.11171354f, -0.00943465f, -0.08875959f, 0.01656141f, 
    -0.10132777f, -0.12126821f, 0.25395593f, 0.03204036f, -0.41042560f, 0.56941015f, 0.03158803f, -0.14009330f, 
    -0.21451879f, -0.09521136f, 0.02904551f, 0.02021017f, -0.00989033f, -0.17963871f, 0.15667076f, -0.08472755f, 
    -0.24750458f, -0.10700577f, 0.23427384f, -0.05371287f, -0.14500666f, -0.02245630f, -0.03159711f, -0.00739902f, 
    0.03768856f, 0.26967883f, -0.10064130f, 0.25784928f, -0.36020947f, 0.37383267f, -0.14515586f, 0.07472489f, 
    -0.03181640f, -0.04265158f, 0.03909740f, 0.04099878f, -0.05360480f, -0.05247310f, -0.20825291f, 0.06625045f, 
    -0.01785979f, -0.41232663f, -0.03068082f, 0.10873522f, -0.03709145f, 0.00380634f, 0.09484490f, -0.17231841f, 
    -0.09563252f, 0.13816208f, 0.06700944f, -0.02736658f, -0.15422340f, 0.00537366f, 0.44931138f, -0.43671945f, 
    0.15035307f, 0.07330531f, 0.09055098f, 0.04713224f, -0.10067180f, -0.05849598f, 0.13238673f, -0.12182963f, 
    -0.23957604f, -0.08864694f, 0.01853233f, -0.18220587f, 0.08731682f, 0.11796641f, 0.06037721f, 0.05526508f, 
    0.02102246f, -0.07422299f, 0.21501414f, -0.08899333f, -0.28970602f, -0.67522317f, -0.31545821f, -0.07665192f, 
    0.16834956f, 0.08101579f, 0.19989061f, -0.08590275f, -0.11463988f, 0.04033459f, 0.03672532f, 0.01839029f, 
    -0.01486029f, 0.04376217f, -0.15154435f, -0.13420105f, 0.00242601f, 0.02186257f, 0.05950601f, 0.10800131f, 
    0.10418484f, -0.00410522f, -0.06380972f, 0.24883336f, 0.36791638f, -0.04209623f, 0.08515242f, 0.05662451f, 
    0.27239516f, 0.03246274f, 0.13244839f, -0.21265142f, 0.08371550f, -0.06024416f, 0.10951877f, 0.14570741f, 
    0.10287544f, 0.31157580f, 0.28147247f, 0.35559279f, 0.12083213f, 0.11615201f, -0.04052424f, 0.09718294f, 
    0.01741330f, -0.09577062f, -0.03783755f, -0.04390160f, -0.26052389f, -0.11975709f, -0.24957740f, -0.15847394f, 
    0.12404249f, 0.08461964f, 0.10335678f, 0.02789382f, 0.12007684f, -0.02295994f, -0.03717042f, -0.07996429f, 
    -0.48637930f, -0.06262871f, -0.26288578f, -0.21123934f, 0.23922986f, 0.14371133f, -0.05934371f, 0.03477376f, 
    0.09647952f, 0.02041609f, 0.04820322f, -0.00689004f, 0.14910379f, -0.21548587f, 0.10808357f, 0.16864271f, 
    0.19932137f, 0.13808540f, -0.03244534f, 0.03843602f, 0.13297874f, 0.20264709f, 0.18828800f, -0.01843212f, 
    0.01322969f, -0.09832137f, 0.27765623f, 0.28824925f, -0.08474133f, 0.11788987f, 0.05309044f, -0.04357181f, 
    0.05656147f, -0.02766600f, -0.03513885f, -0.10176267f, -0.25092137f, -0.11576426f, 0.20686677f, 0.14490356f, 
    0.09273785f, -0.04186850f, -0.08557054f, 0.05286007f, 0.09574651f, -0.15328753f, 0.12952395f, 0.09594192f, 
    0.01275751f, 0.69439757f, 0.31341210f, 0.01573099f, -0.09360883f, -0.09674198f, -0.08925095f, 0.03839383f, 
    0.03168150f, -0.00927365f, 0.04322815f, 0.06463863f, -0.27165663f, 0.39114603f, 0.33604854f, -0.28308457f, 
    -0.20313998f, -0.14780153f, -0.07302272f, 0.06058463f, 0.03922132f, 0.11841691f, -0.04403884f, 0.02247547f, 
    -0.16680400f, 0.18765697f, 0.46096310f, -0.26302293f, -0.18332797f, 0.14180303f, -0.12309183f, -0.23279080f, 
    -0.00271003f, 0.21900421f, -0.04342769f, 0.03945687f, -0.11915056f, -0.02072501f, 0.11343223f, 0.13783073f, 
    0.07115193f, 0.02812894f, 0.08706484f, -0.19675735f, 0.00496183f, 0.09586083f, 0.00983697f, 0.15095583f, 
    -0.64928544f, 0.15711437f, 0.26857054f, 0.07222273f, -0.06776103f, 0.08626286f, -0.08152005f, 0.07020216f, 
    -0.16881692f, 0.10577052f, 0.00813351f, -0.04447708f, -0.01689942f, -0.31380421f, -0.15655346f, -0.31700256f, 
    -0.08792478f, -0.04593843f, 0.03571078f, -0.08469235f, -0.13833493f, -0.04383791f, 0.10493989f, -0.03384644f, 
    0.15855168f, 0.19511725f, -0.08051655f, -0.20941596f, -0.04950338f, 0.17983116f, 0.21390241f, -0.08706332f, 
    -0.08898526f, -0.02254480f, -0.07954196f, 0.02755614f, 0.21989520f, -0.09650148f, 0.08909906f, -0.13212304f, 
    0.13685489f, 0.12955734f, 0.07699109f, 0.07727747f, 0.08776246f, -0.19222747f, 0.08721468f, 0.20582123f, 
    0.16164508f, -0.05613014f, -0.08663280f, 0.27716702f, 0.02782254f, -0.13990249f, 0.03335403f, -0.08760431f, 
    0.12960079f, 0.03431385f, 0.11732951f, 0.21313618f, -0.00877049f, 0.06058230f, -0.08691179f, 0.11783243f, 
    0.13737531f, -0.09331647f, -0.05237074f, -0.00598458f, 0.06765638f, 0.00072127f, -0.07375636f, 0.02566960f, 
    -0.42005068f, 0.13113566f, 0.11820894f, -0.04913842f, 0.08577843f, 0.14013077f, -0.01287091f, 0.06559122f, 
    0.02837135f, 0.13535403f, 0.08766275f, 0.00596973f, 0.07644798f, -0.12192661f, -0.02607512f, 0.29938576f, 
    0.22161543f, 0.03317448f, 0.06133787f, 0.16058628f, 0.09730169f, 0.06088361f, 0.07737025f, -0.05809546f, 
    -0.48915714f, 0.12504037f, -0.41831091f, 0.04832774f, 0.03505570f, 0.09833340f, 0.09837052f, -0.09621021f, 
    0.01594436f, 0.16964363f, 0.02031949f, -0.12280196f, 0.21749601f, -0.02257393f, -0.04429609f, 0.05735264f, 
    -0.11085669f, 0.02394973f, 0.13680886f, 0.00286097f, 0.13318589f, 0.03907427f, -0.03307671f, 0.07139891f, 
    0.34986994f, -0.21315268f, 0.18778545f, -0.10386120f, 0.20253465f, 0.15919796f, -0.05148700f, 0.06747530f, 
    -0.14378455f, 0.14934847f, -0.05054839f, 0.09919063f, -0.27805838f, 0.29721165f, 0.52111387f, 0.27492166f, 
    0.05959849f, -0.14190534f, 0.05109042f, 0.10935029f, 0.12445629f, 0.04219659f, 0.03159630f, 0.06393211f, 
    -0.11765192f, -0.34185979f, 0.06764874f, 0.03149424f, 0.07877249f, 0.03351434f, -0.02271140f, -0.11101945f, 
    -0.08346341f, -0.01778401f, -0.10306744f, 0.03732497f, -0.13846922f, 0.17121369f, -0.16474980f, 0.14763708f, 
    0.18749991f, 0.03485958f, -0.00088984f, -0.01927712f, -0.00585303f, 0.01343852f, 0.15028773f, 0.11585865f, 
    -0.22289947f, -0.22328421f, -0.06130023f, 0.12541509f, 0.04072289f, -0.09924063f, -0.07800540f, -0.17703226f, 
    0.01511132f, 0.07911464f, -0.11310697f, 0.04034756f, -0.37265873f, 0.20265932f, 0.11356299f, -0.14292817f, 
    0.07191650f, -0.06090613f, -0.02447177f, -0.02102155f, 0.30047175f, 0.05389215f, -0.14261802f, 0.09365818f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.06195474f, -0.02534956f, -0.02551130f, 0.01608721f, -0.00740963f, -0.10871821f, 0.00150100f, 0.01328992f, 
    0.31303847f, 0.02808998f, -0.11057765f, -0.00943493f, -0.06748421f, 0.01825332f, 0.02381772f, -0.06971279f, 
    -0.00000635f, 0.11688240f, -0.06005161f, -0.08478397f, -0.01172566f, -0.11627866f, -0.04352139f, 0.03837726f, 
    0.01082942f, -0.04769043f, 0.09772969f, -0.00919597f, -0.05223075f, 0.11454757f, 0.05896188f, 0.06205998f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.01757626f, 0.34657559f, -0.48419684f, 0.06215011f, -0.05464623f, 0.21099021f, 0.40674743f, -0.15274563f, 
    -0.65694517f, -0.05201678f, -0.51675397f, -0.11836744f, 0.15966402f, 0.02792608f, -0.77758807f, 0.30159050f, 
    -0.11252721f, -1.11605918f, 0.10827176f, 0.15271212f, 0.07718647f, 0.23539369f, 0.00043737f, 0.06876422f, 
    -0.00773760f, -0.66355360f, 0.07813174f, 0.43112120f, 0.01816068f, -0.06500836f, 0.06489909f, 0.14456727f, 
    0.25173083f, 0.36285582f, -0.34425539f, -0.00774751f, -0.13219112f, -0.70363414f, -0.09595088f, 0.07333194f, 
    0.23904738f, -0.71744657f, -0.29542157f, -0.17133397f, -0.01075350f, 0.12003634f, -0.04747369f, 0.14154303f, 
    0.03096438f, -0.06001703f, -0.08852927f, 0.00985011f, -0.25813335f, -0.06155905f, -0.51604342f, 0.41564715f, 
    0.17944796f, 0.52868015f, 0.27966741f, 0.06312668f, 0.07643309f, 0.13010089f, -0.02897927f, -0.59297222f, 
    0.29827246f, 0.28466094f, 0.41166103f, -0.01187368f, -0.09759817f, -0.12672663f, -0.58895034f, 0.09419533f, 
    -0.04205310f, -0.39180949f, -0.48426893f, -0.13715903f, 0.16076472f, -0.11137627f, 0.29301035f, 0.30104935f, 
    0.07958608f, -0.19995306f, -0.13215554f, -0.08324485f, 0.03740812f, -0.55562884f, 0.44310263f, -0.38565943f, 
    0.40761697f, -0.72040355f, -0.64605641f, -0.00811014f, -0.07938875f, -0.71964121f, -0.48527357f, -0.34935385f, 
    -0.30607846f, -0.16626106f, -0.21545836f, 0.00279647f, 0.11383139f, -0.78251135f, 0.14624785f, -0.07327245f, 
    -0.01653701f, 0.05970230f, -0.28874487f, 0.07196412f, 0.03297530f, 0.05076022f, 0.28975749f, -0.17818269f, 
    0.09874661f, -0.12280687f, -0.00418184f, 0.06173953f, 0.49341869f, 0.37533650f, 0.32926381f, 0.39431131f, 
    -0.26745448f, -0.18378313f, 0.14492887f, -0.70918179f, -0.03919747f, -0.16505826f, -1.19564390f, 0.34687203f, 
    -0.20067824f, -0.27227968f, 0.27764529f, 0.06564012f, 0.07694403f, -0.14181590f, 0.18169133f, -0.02318932f, 
    -0.28997785f, 0.51956183f, 0.17020744f, 0.00026335f, -0.00448915f, 0.10017300f, 0.19796799f, 0.07031219f, 
    -0.02375099f, -0.17647023f, -0.07361334f, 0.15412065f, -0.51557004f, -0.45722693f, 0.20522934f, 0.30223542f, 
    -0.22275160f, 0.07296719f, 0.14993943f, 0.55607343f, 0.01433272f, 0.05402989f, -0.25286600f, 0.35582110f, 
    0.03703051f, -0.35416138f, -0.75352365f, -0.15489349f, 0.14035361f, 0.49864748f, 0.16742091f, 0.06522563f, 
    -0.19949509f, 0.25424829f, -0.19231813f, -0.10562628f, -0.16114476f, -0.01939455f, -0.19949074f, -0.34453472f, 
    -0.02796417f, 0.12233853f, 0.08150233f, -0.06878100f, -0.08271594f, 0.05944814f, -0.43243718f, 0.25469616f, 
    0.43568531f, 0.00949813f, -0.10196715f, -0.06289662f, 0.15955792f, 0.16962904f, 0.23467179f, 0.32023221f, 
    -0.27861643f, -0.08197540f, 0.54409224f, -0.16594325f, 0.08428793f, 0.23157120f, -0.28590858f, 0.01082732f, 
    0.29067832f, 0.43020880f, -0.57077295f, 0.07525015f, -0.16723464f, 0.14943603f, 0.37938830f, -0.10575631f, 
    0.01341325f, -0.14637055f, -0.15269780f, 0.06637388f, 0.00881839f, 0.49499527f, 0.07645521f, -0.19096151f, 
    0.10972677f, -1.22885966f, -0.43541700f, 0.00570741f, 0.12635072f, 0.17525534f, 0.40647903f, -0.66533107f, 
    -0.23432647f, -0.42718711f, 0.41079509f, 0.11223780f, -0.06707463f, 0.41818580f, 0.26769534f, 0.06001883f, 
    -0.14388217f, -0.60611105f, 0.41558903f, 0.10567363f, 0.00751904f, -0.14802040f, 0.38485479f, -0.54301679f, 
    0.07445402f, -0.44311512f, -0.18246013f, -0.09219195f, 0.17376202f, -0.31455842f, 0.26491293f, -0.30527183f, 
    -0.17519213f, 0.55815858f, -0.07968451f, -0.28666699f, 0.10478134f, 0.38820034f, -0.36253646f, -0.32135430f, 
    -0.06469376f, 0.37413535f, -0.64883548f, -0.11376598f, 0.01161579f, -0.32695216f, 0.16331734f, 0.05173258f, 
    -0.37969270f, -0.15214102f, 0.46108857f, -0.15592411f, -0.08725792f, 0.09543037f, 0.18367006f, 0.06593560f, 
    -0.10982468f, 0.40024373f, -0.08987465f, 0.00723485f, -0.68284625f, 0.04033791f, 0.14368258f, -0.50709385f, 
    0.35642019f, -0.26734543f, -0.11116578f, -0.70336580f, 0.04639789f, 0.29097566f, -0.19325168f, -0.20438722f, 
    0.28995201f, -0.58793718f, 0.28339586f, -0.09651366f, 0.11723520f, -0.09345130f, -0.88395548f, 0.04174118f, 
    -0.20857581f, -0.16754995f, 0.47819126f, 0.17302224f, -0.02833652f, -0.07946540f, 0.02363657f, 0.29908112f, 
    -0.03040932f, -0.60166520f, 0.09847884f, -0.15428928f, -0.17041998f, 0.53878248f, -0.09383230f, -0.38442674f, 
    -0.27730879f, 0.22687224f, 0.19625431f, -0.13548735f, 0.09247131f, 0.22409768f, 0.25263736f, 0.41096681f, 
    0.34083641f, -0.00075874f, -0.00905435f, 0.13864429f, 0.10728548f, -0.08594918f, -0.05380091f, 0.13411465f, 
    0.58051085f, 0.12317555f, -0.52632117f, 0.11647029f, 0.04353469f, 0.05280331f, -0.31749344f, -0.68874848f, 
    0.01731492f, 0.08539574f, 0.14856154f, 0.11993655f, 0.21642536f, -0.98051965f, 0.29619455f, -0.49790579f, 
    -0.20386922f, -0.37257609f, 0.51043320f, -1.11748409f, 0.05230882f, 0.14074649f, -0.30162469f, 0.17425328f, 
    -0.09024024f, 0.33255520f, -0.02309097f, -0.16319734f, 0.11216543f, 0.48315758f, -0.06457499f, -0.05574623f, 
    0.20702049f, 0.37188634f, 0.32403359f, -0.10321277f, -0.11011327f, 0.14678563f, -0.08491357f, 0.35308105f, 
    -0.06070944f, 0.53649843f, 0.16317309f, 0.10173424f, 0.26341477f, 0.15541407f, -0.23956797f, -0.07226175f, 
    -0.40130565f, -0.42546839f, -0.32938200f, -0.65597785f, -0.01061276f, -0.50633478f, -0.30668500f, -0.32276165f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.06972619f, 0.27793011f, -0.05502452f, -0.15559201f, -0.00285352f, 0.10360693f, -0.13485159f, -0.20759457f, 
    -0.22501102f, 0.18150456f, 0.26059681f, -0.19160986f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
