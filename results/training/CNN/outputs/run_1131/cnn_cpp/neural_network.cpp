#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.24524502f, 0.64568567f, -0.02801649f, -0.17913035f, -0.21762800f, -0.23829338f, -0.02655916f, 0.27381590f, 
    0.48910537f, 0.32985985f, 0.39211974f, -0.45464575f, 0.05220947f, 0.00853764f, -0.22647095f, -0.52557790f, 
    -0.19164361f, 0.66258925f, -0.06335160f, -0.16748910f, -0.21557853f, -0.50280660f, -0.39581922f, -0.42634627f, 
    0.25597239f, -0.10370992f, 0.40541905f, -0.02404117f, 0.38539326f, 0.10652087f, -0.20891087f, -0.56958449f, 
    0.44259450f, 0.34880823f, 0.02687702f, -0.29714674f, -0.55899632f, 0.93268043f, -0.85339898f, -0.05204842f, 
    0.35512319f, 0.25090137f, -0.16305345f, 0.02626572f, 0.08218145f, 0.28991318f, 0.42713642f, 0.19562131f, 
    0.19879389f, 0.49423981f, 0.42562783f, 0.00459084f, 0.27137238f, 0.11634613f, -0.33548570f, 0.19070436f, 
    -0.05553991f, -0.25571594f, -0.16669415f, 0.34205037f, 0.38238648f, 0.31964171f, 0.03587580f, 0.09235943f, 
    0.17882840f, -0.11069856f, -0.19261578f, -0.27521414f, -0.52803993f, 0.16297640f, 0.54840750f, -0.59182763f, 
    0.47610629f, 0.42119002f, -0.22254759f, 0.18217294f, -0.53901190f, -0.04603742f, -0.06934963f, 0.17982252f, 
    0.05120568f, -0.35910171f, -0.07943852f, 0.10626876f, -0.52889103f, 0.01581872f, 0.09423172f, 0.01073893f, 
    -0.23141164f, -0.47944179f, -0.11818672f, -0.14224134f, 0.08002456f, 0.09892387f, -0.54043955f, -0.44928902f, 
    0.04903751f, 0.53910691f, 0.21917287f, -0.36805034f, -0.06295161f, -0.33547693f, 0.11547453f, -0.08394532f, 
    -0.56728172f, -0.17405958f, -0.26292172f, -0.08726374f, -0.36235812f, 0.05829512f, 0.35950008f, -0.16830482f, 
    0.76780885f, -0.31170258f, -0.46942139f, -0.21906334f, -0.00328323f, -0.27527404f, -0.75390857f, -0.53536099f, 
    -0.10138807f, 0.62759262f, 0.01516838f, 0.28342611f, -0.02039046f, -0.08311675f, -0.38330439f, 0.28504902f, 
    0.13259566f, -0.35976419f, -0.16331357f, 0.54641485f, -0.33026174f, 0.18858823f, 0.14684254f, -0.02846213f, 
    -0.57583910f, -0.16243446f, 0.84092188f, 0.16882645f, 0.23747884f, -0.25305492f, -0.44756410f, -0.18414460f, 
    -0.38609761f, 0.33095300f, 0.48848313f, 0.21820861f, -0.37796915f, -0.62213862f, -0.00439213f, -0.41281709f, 
    -0.38722840f, 0.38039073f, 0.32542488f, 0.41809648f, -0.46202922f, 0.05208965f, 0.30027261f, 0.03884903f, 
    -0.19861244f, 0.13018616f, 0.34918281f, 0.52475452f, 0.48716196f, -0.43577003f, -0.06935330f, -0.38444924f, 
    0.29108083f, 0.08603420f, 0.36189866f, 0.23893900f, -0.39427373f, 0.07066975f, 0.69545984f, -0.61573273f, 
    -0.24706697f, -0.37397537f, 0.03112346f, 0.14714701f, 0.21416521f, 0.35916182f, 0.34406167f, 0.36727899f, 
    -0.32980984f, -0.33158711f, -0.32074764f, -0.11200754f, 0.19578531f, 0.04136363f, 0.06726143f, -0.08376160f, 
    0.54499203f, -0.04543200f, -0.61620593f, 0.41601562f, -0.13895439f, 0.52527171f, 0.11870816f, 0.17312329f, 
    0.12456200f, -0.19466846f, 0.25125548f, 0.48962635f, 0.40884453f, -0.51555604f, 0.41410756f, 0.24306108f, 
    0.69826001f, -0.40524295f, -0.33584026f, 0.48548046f, -0.30198312f, -0.25995913f, 0.17632432f, -0.20746288f, 
    0.51267475f, -0.77070755f, 0.59821254f, -0.36449862f, -0.07796879f, 0.59669238f, -0.11111776f, -0.05366309f, 
    0.28790087f, -0.01914751f, 0.28130636f, 0.35864136f, 0.16852629f, -0.50717431f, 0.15561342f, 0.23044068f, 
    -0.55934340f, 0.10663716f, 0.25546005f, -0.38370863f, -0.77704096f, -0.12859762f, 0.09339600f, 0.42304879f, 
    -0.14702469f, -0.01838890f, -0.21962613f, 0.75579667f, -0.43927458f, -0.48995596f, 0.23254471f, -0.01047726f, 
    0.42927989f, -0.07391465f, 0.15874530f, -0.14262921f, -0.41320834f, 0.31742918f, -0.05157069f, 0.00834843f, 
    -0.05180599f, -0.54327881f, 0.44645095f, 0.10731130f, 0.18405268f, 0.71655697f, 0.01835084f, 0.09528257f, 
    0.16954665f, 0.11199358f, 0.07782163f, -0.13530700f, 0.68442559f, -0.60554045f, 0.20574665f, -0.10255592f, 
    0.52103662f, -0.56385499f, 0.26340553f, 0.31514600f, 0.34715235f, -0.19775324f, -0.17469387f, 0.39699429f, 
    -0.63827318f, 0.54748553f, -0.00172386f, -0.17193645f, -0.32315007f, 0.06782819f, -0.20004255f, -0.13732518f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.18631400f, -0.22297850f, -0.05860277f, -0.08975942f, -0.15474346f, 0.00386679f, 0.05764684f, -0.11217505f, 
    0.07277367f, -0.20695502f, -0.17405088f, -0.19499752f, -0.17048509f, 0.10487214f, 0.29267418f, 0.01405317f, 
    -0.34247842f, -0.05184480f, -0.12129527f, 0.18319754f, -0.00253352f, -0.30047750f, -0.09517482f, -0.09645388f, 
    -0.04626935f, -0.07808231f, 0.17665605f, 0.33670437f, -0.14823064f, -0.11316936f, -0.08703213f, 0.36353704f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.03985559f, 0.04126954f, -0.23881759f, 0.06323376f, -0.02529348f, -0.02624115f, -0.06179830f, -0.09580373f, 
    0.16894992f, 0.31288937f, -0.08341442f, 0.02708821f, 0.10223882f, 0.03705089f, 0.18489803f, 0.00989405f, 
    -0.06337409f, -0.00643629f, 0.05522022f, 0.13930865f, 0.11026804f, -0.03034045f, -0.09468992f, -0.03974703f, 
    -0.10690605f, -0.01924796f, -0.02235189f, -0.21828216f, 0.06583237f, 0.24363384f, -0.03714113f, -0.06298272f, 
    -0.06128854f, 0.02607960f, 0.02683346f, 0.09468822f, -0.87795734f, 0.14728695f, -0.32716209f, -0.11631829f, 
    -0.12415817f, 0.14448376f, 0.05230481f, -0.04097629f, 0.13065360f, -0.14445092f, -0.45816225f, -0.25021592f, 
    -0.26634124f, -0.08502618f, -0.08568826f, -0.04449983f, 0.05992376f, 0.14026429f, -0.07340062f, -0.05235978f, 
    0.12596364f, 0.01092268f, -0.04129874f, 0.00760916f, 0.02974041f, -0.06491804f, -0.09622137f, -0.19038631f, 
    0.07709722f, -0.03627250f, -0.07740792f, -0.08732308f, -0.03630219f, 0.03034814f, 0.00368812f, -0.04274740f, 
    -0.01734855f, 0.10624892f, -0.27497730f, -0.23216937f, 0.04513335f, 0.07382883f, 0.06117946f, 0.08418888f, 
    0.04564795f, -0.04335273f, 0.08169900f, 0.21801642f, 0.12202307f, 0.00949748f, 0.06023678f, -0.03880450f, 
    -0.00407659f, -0.00475789f, 0.06485024f, 0.17286871f, -0.00533765f, -0.07860292f, 0.02319443f, 0.02321019f, 
    -0.02201672f, -0.15650603f, 0.05318342f, 0.09313857f, 0.16675532f, 0.06382792f, 0.06567830f, 0.10526107f, 
    0.11590943f, 0.09031460f, 0.03661680f, -0.10878687f, -0.12050045f, -0.28735653f, -0.08532677f, 0.15997401f, 
    -0.00948961f, 0.10667516f, 0.06485117f, 0.00449794f, 0.01467404f, 0.15078031f, -0.10445643f, -0.22396366f, 
    0.03157061f, 0.24148570f, 0.06289215f, 0.05927953f, -0.01005335f, -0.02237816f, -0.18650134f, -0.05724879f, 
    0.25276664f, 0.09807512f, 0.12537475f, -0.06251355f, 0.07515114f, 0.10674236f, 0.09609997f, 0.18561068f, 
    -0.01368638f, -0.12137865f, 0.02251039f, 0.05585406f, -0.12170319f, 0.13007899f, 0.06712300f, 0.00150841f, 
    -0.24331710f, 0.16234025f, -0.16084094f, 0.02331069f, 0.04217407f, 0.07024584f, 0.04917946f, -0.07112200f, 
    0.07863237f, 0.09859636f, -0.38727811f, -0.16295180f, 0.10628264f, -0.06274917f, -0.09874808f, -0.01851649f, 
    -0.02877690f, 0.00611181f, -0.24234141f, -0.13825588f, -0.17064388f, -0.06637606f, -0.14158198f, -0.02232546f, 
    -0.07366349f, -0.03927868f, 0.03412109f, 0.09636415f, -0.06270848f, -0.11500464f, -0.07118385f, 0.00432624f, 
    0.04196129f, 0.06194817f, -0.04730000f, -0.03908481f, 0.15840670f, 0.06924223f, -0.09125791f, 0.05644608f, 
    0.07083362f, -0.09432399f, -0.03393571f, -0.07667106f, -0.08208366f, -0.28350827f, -0.11965980f, 0.03501515f, 
    -0.24056123f, -0.19006155f, -0.02002445f, -0.05512071f, -0.04488599f, 0.05400351f, -0.28155461f, -0.07888447f, 
    -0.17415255f, -0.06454873f, -0.07583476f, 0.08647718f, 0.08793099f, 0.04540022f, 0.04997529f, -0.08634906f, 
    -0.28784317f, -0.12397163f, 0.08757530f, -0.03820620f, 0.11960468f, -0.00152176f, 0.01496648f, 0.04850325f, 
    0.31932294f, -0.34725487f, -0.13463826f, -0.13661531f, 0.09851502f, -0.15898652f, -0.01750195f, 0.10069007f, 
    -0.02044557f, -0.20919932f, 0.12617604f, -0.10187087f, 0.03938839f, 0.03258218f, 0.17289983f, 0.11298634f, 
    0.03948142f, 0.08439504f, 0.27420953f, 0.01807147f, 0.01818175f, 0.15392594f, 0.08057260f, 0.02287612f, 
    0.10897966f, 0.03693094f, -0.09888253f, 0.34908357f, 0.04381122f, -0.08139008f, 0.06915919f, -0.01649791f, 
    0.01245760f, 0.00584569f, 0.01143165f, 0.08189809f, -0.02470160f, 0.25852823f, 0.16602717f, -0.09259270f, 
    -0.11369933f, -0.03468726f, -0.12468158f, -0.12900500f, 0.11891785f, -0.08444966f, -0.17267080f, -0.07484421f, 
    0.00594139f, 0.09833892f, -0.04931147f, -0.01198962f, -0.04895166f, 0.03587098f, -0.07730933f, -0.19452535f, 
    0.23495556f, 0.08087450f, -0.15792036f, -0.17791905f, -0.17853370f, 0.01235308f, 0.15144981f, 0.14075944f, 
    0.05407871f, -0.15705109f, -0.05575487f, 0.13304415f, 0.12406579f, 0.04260693f, 0.10226636f, 0.07244933f, 
    -0.02648182f, -0.01026769f, 0.05074571f, 0.03652601f, -0.05827851f, 0.01562650f, -0.04302753f, 0.00243185f, 
    -0.05265538f, 0.01487546f, -0.03706081f, -0.03917823f, -0.04952556f, 0.03457982f, 0.00990354f, 0.05720478f, 
    0.00380855f, 0.03169591f, -0.02341585f, 0.03455666f, -0.02133087f, -0.04428251f, 0.02434145f, 0.01045665f, 
    -0.03008579f, 0.02465052f, -0.05926205f, -0.02593920f, -0.06649566f, -0.00818554f, -0.02980918f, -0.00794412f, 
    0.01770049f, 0.01234882f, -0.01073794f, -0.01163109f, 0.04525280f, -0.03083230f, 0.04322365f, -0.01746956f, 
    -0.01063970f, 0.01515896f, 0.05736295f, 0.00076411f, -0.02480861f, -0.02011554f, -0.06602014f, -0.02123828f, 
    0.01472786f, 0.01900477f, -0.00759370f, 0.04829882f, 0.04140057f, 0.04950270f, 0.01510261f, -0.05520013f, 
    -0.02783053f, 0.01762663f, -0.03898690f, -0.04277895f, -0.01380539f, 0.00166136f, 0.00869710f, 0.03368323f, 
    0.01734792f, 0.04343469f, -0.01938389f, 0.01671014f, 0.04494210f, -0.02403712f, -0.04194796f, -0.05706188f, 
    -0.03882889f, -0.00456013f, 0.00074628f, 0.04897354f, -0.03099855f, 0.04140491f, -0.05086071f, -0.01458723f, 
    -0.05576576f, -0.03424952f, 0.00660952f, 0.02908182f, 0.04264838f, 0.02076623f, 0.01222865f, 0.01098676f, 
    -0.02821699f, -0.03931420f, 0.00543391f, 0.01009746f, 0.02276969f, 0.03317749f, -0.00014659f, -0.00046018f, 
    -0.01983751f, -0.05665534f, -0.01029201f, 0.00144617f, 0.05588299f, -0.03816147f, 0.05105162f, -0.03818155f, 
    -0.02948852f, 0.00419276f, 0.01651534f, -0.02596402f, -0.05920200f, -0.02170597f, 0.03314365f, -0.01714636f, 
    0.03961058f, 0.01641423f, -0.00541208f, 0.00071530f, -0.05912080f, -0.04831775f, 0.03771622f, 0.03016251f, 
    -0.04892650f, -0.01900647f, -0.02685341f, 0.01388141f, 0.00181484f, 0.01188741f, -0.04033092f, 0.04731288f, 
    0.02606510f, 0.04250293f, -0.04162841f, -0.02967883f, 0.01065924f, 0.00260364f, -0.00783279f, -0.04512760f, 
    -0.05036988f, -0.03293584f, 0.02282748f, -0.02351513f, 0.03060290f, -0.00151720f, 0.00684426f, -0.01799763f, 
    -0.00336593f, 0.04101770f, -0.00233892f, 0.01142038f, -0.03732138f, 0.05076613f, 0.00418877f, -0.04485569f, 
    0.02330041f, -0.03992176f, -0.04139844f, 0.03995718f, 0.01351834f, -0.04561977f, -0.01759092f, 0.02379729f, 
    -0.06217719f, -0.05289472f, -0.01236526f, 0.00470836f, 0.02863936f, -0.05216352f, -0.01240628f, -0.03376374f, 
    0.04792804f, -0.04242782f, -0.00797427f, 0.02693862f, -0.00620785f, -0.00785821f, -0.00405347f, -0.05212187f, 
    -0.01058074f, -0.04182107f, 0.04131129f, -0.05103949f, -0.05079550f, -0.01368884f, 0.01009425f, 0.02514115f, 
    -0.03298783f, 0.01436417f, 0.00230643f, -0.01631349f, -0.03311646f, -0.00353753f, -0.02423629f, 0.00784761f, 
    0.04604600f, -0.01002303f, -0.03939528f, -0.02005392f, -0.05645908f, -0.04917350f, -0.05864291f, 0.02797025f, 
    0.01402124f, 0.02081312f, 0.01720354f, 0.00062924f, -0.04113713f, -0.04031410f, 0.01745659f, 0.03832456f, 
    0.04285315f, -0.00854258f, 0.03699990f, -0.01179057f, -0.02182200f, 0.04039894f, 0.03601528f, -0.03547449f, 
    -0.02297712f, -0.02782101f, -0.01644988f, 0.03926309f, 0.01588789f, -0.01744836f, 0.04461589f, 0.00477370f, 
    -0.02944325f, 0.02324976f, -0.02476739f, 0.03451715f, 0.00746177f, -0.02382745f, -0.03051235f, 0.04724628f, 
    0.04143224f, -0.05549834f, -0.05977827f, -0.02139265f, 0.02111012f, 0.01754334f, -0.03999565f, 0.00771493f, 
    0.04395339f, -0.04054878f, -0.04616762f, -0.01826629f, -0.02136877f, -0.02066087f, 0.00794365f, 0.00847164f, 
    -0.02810563f, -0.05191858f, -0.04596505f, -0.04343784f, -0.04506503f, 0.01341266f, -0.00606131f, -0.01436578f, 
    0.00167220f, -0.02908183f, -0.05293530f, 0.04366885f, 0.01913026f, 0.01667436f, 0.00284045f, -0.01865589f, 
    0.01341821f, -0.05252475f, -0.04001558f, -0.00250669f, 0.00851593f, 0.00090113f, 0.02677359f, 0.03720313f, 
    -0.00202007f, -0.05996437f, -0.00131031f, 0.03113099f, 0.03150056f, 0.03252659f, -0.00092550f, 0.00697560f, 
    -0.02038245f, -0.03096366f, -0.02399202f, -0.05020061f, 0.00948429f, -0.00706135f, -0.00677122f, -0.01659278f, 
    -0.04027270f, -0.15927695f, 0.03191520f, 0.12826894f, 0.06400377f, -0.08642868f, -0.15662801f, 0.11784369f, 
    -0.04923747f, -0.15847300f, 0.03435860f, 0.11522039f, 0.06326333f, 0.15135804f, -0.18207860f, 0.03241253f, 
    -0.05444721f, 0.12011565f, 0.06805118f, 0.12774007f, 0.11919008f, 0.11015917f, 0.16883820f, 0.02246898f, 
    0.01429135f, 0.00643185f, 0.00332789f, -0.04171343f, 0.08285624f, 0.01030662f, 0.02932475f, -0.13262850f, 
    0.15121049f, 0.10966876f, 0.11069306f, 0.14431377f, -0.12827684f, -0.13565989f, 0.09365256f, 0.13334805f, 
    -0.03076313f, 0.20044425f, -0.16322531f, -0.02463009f, -0.04943074f, -0.03431611f, -0.10717370f, -0.08372928f, 
    0.07221869f, 0.09988706f, -0.01653548f, 0.03978896f, -0.00226749f, 0.00145066f, 0.12812273f, 0.02006467f, 
    0.06740095f, -0.05294788f, -0.12619659f, 0.06296229f, 0.10152628f, 0.06589708f, 0.06833829f, 0.11130699f, 
    0.03642127f, 0.02540719f, 0.07213318f, 0.06937243f, 0.07754093f, 0.00860755f, 0.10611084f, 0.00387025f, 
    -0.20005709f, -0.21346238f, -0.19176213f, -0.05713534f, 0.00696651f, -0.06830399f, -0.07468671f, 0.14066520f, 
    -0.00052028f, 0.05742928f, 0.14256479f, 0.02344147f, 0.09868797f, -0.03801090f, 0.05905506f, 0.18623449f, 
    -0.01923354f, -0.22006220f, 0.15045020f, 0.13455419f, 0.14885072f, 0.09777891f, 0.03147431f, -0.05933737f, 
    0.05162472f, -0.08593129f, 0.03594733f, 0.07122748f, 0.31039360f, 0.21882872f, 0.03208400f, 0.09660273f, 
    -0.09288343f, 0.11169936f, 0.02242005f, 0.00339350f, -0.14439684f, -0.15491877f, -0.00115378f, 0.11846992f, 
    0.02873997f, -0.03829759f, -0.06170184f, -0.06724775f, -0.06054373f, 0.18369634f, 0.04236929f, 0.09083747f, 
    -0.04415266f, -0.03026319f, -0.05287034f, 0.02535441f, -0.01036112f, -0.13393794f, 0.06121313f, 0.03497281f, 
    0.04038795f, 0.07777683f, 0.02485873f, 0.05687798f, 0.03720872f, 0.12306584f, 0.14103188f, -0.06612842f, 
    0.00816088f, 0.06710169f, 0.09771924f, -0.04806642f, -0.16530864f, 0.04777517f, -0.15030624f, -0.07099472f, 
    -0.08647997f, -0.11853126f, -0.04589512f, 0.16189818f, 0.10717781f, -0.01791738f, 0.10733872f, -0.17553443f, 
    -0.26874071f, -0.29195517f, -0.07671550f, -0.09415326f, 0.00918566f, -0.04799309f, 0.01181207f, -0.04437780f, 
    -0.05110368f, 0.05517642f, -0.21267955f, -0.00218084f, -0.00093562f, 0.03734648f, -0.00894985f, 0.01973562f, 
    -0.10131408f, 0.12929083f, -0.00443564f, 0.08717168f, 0.00841453f, -0.00766109f, 0.06164777f, 0.07025953f, 
    -0.01858938f, 0.13475540f, -0.03900015f, 0.02491990f, -0.19029683f, -0.24456675f, -0.08170612f, 0.01230033f, 
    0.10359903f, -0.02902567f, -0.06744771f, -0.11018880f, -0.11035930f, 0.07725469f, -0.01104397f, 0.04038638f, 
    -0.00146038f, -0.10458061f, -0.18834819f, -0.11227936f, 0.11913166f, 0.17696010f, -0.00922619f, 0.03183689f, 
    -0.09037564f, 0.02176860f, -0.06533245f, 0.06598519f, 0.02054383f, -0.02655452f, 0.02592210f, -0.11747655f, 
    -0.35906294f, 0.01166339f, 0.13968372f, 0.03015254f, -0.02432242f, -0.22911747f, 0.05420905f, -0.01193867f, 
    -0.13400421f, 0.02570908f, -0.08373594f, -0.03325364f, -0.06362753f, -0.02044601f, -0.00619879f, -0.05250287f, 
    -0.05168261f, -0.40682748f, -0.16515575f, -0.08520659f, 0.19368723f, -0.10051835f, -0.02886086f, -0.09696963f, 
    -0.13890953f, 0.05195366f, 0.09539282f, 0.11430141f, 0.05192459f, 0.04261973f, -0.05623600f, 0.00994468f, 
    0.05144250f, -0.01003203f, -0.09824955f, 0.07154362f, 0.02566923f, -0.01899988f, 0.07621078f, 0.02707138f, 
    0.05086909f, -0.04350014f, -0.05040745f, -0.08916613f, 0.15874924f, 0.06488477f, 0.18144640f, 0.00241689f, 
    -0.01056519f, 0.04920543f, 0.02924926f, 0.05662338f, -0.05550302f, -0.08478186f, -0.26311383f, 0.19676924f, 
    -0.16897352f, 0.08016849f, 0.02283155f, -0.04602616f, 0.02760903f, -0.16353002f, -0.21479587f, 0.09824759f, 
    0.07611115f, 0.01283852f, -0.07629503f, 0.13012446f, -0.01427635f, -0.08239008f, 0.07545079f, 0.05642415f, 
    -0.01140532f, 0.02887104f, 0.04044149f, 0.14724419f, 0.12474737f, 0.03063882f, 0.10638344f, 0.00883261f, 
    -0.05540352f, 0.03826911f, -0.01936765f, -0.00687769f, -0.02782249f, 0.04510915f, -0.00872265f, -0.03307837f, 
    0.02552356f, -0.05261347f, -0.01930864f, 0.04820038f, 0.03745859f, 0.03554775f, -0.05126498f, -0.05286302f, 
    0.00678677f, 0.01817825f, 0.02551968f, -0.01681092f, 0.00594840f, 0.01370718f, 0.01342128f, 0.04780268f, 
    0.01040254f, -0.00643979f, 0.02653257f, -0.05554407f, 0.02670245f, 0.03364268f, 0.03839068f, -0.01548986f, 
    -0.04970573f, 0.00887246f, 0.02070891f, -0.02299035f, 0.02851630f, -0.00623597f, -0.01849486f, 0.00860737f, 
    -0.02624722f, -0.02935513f, -0.00200092f, -0.01768760f, 0.01843923f, 0.04902067f, 0.00836360f, -0.02874294f, 
    0.01959146f, 0.02152242f, 0.01642804f, 0.00522085f, -0.00482319f, -0.00065271f, -0.04464792f, -0.02881629f, 
    -0.02616999f, -0.06544816f, -0.05443692f, -0.02700061f, -0.02487950f, -0.04705964f, 0.00523243f, 0.05685622f, 
    -0.04073880f, -0.03019450f, -0.04845553f, 0.04206904f, 0.03260688f, -0.02137893f, -0.03563939f, 0.00756962f, 
    -0.00586337f, -0.04039612f, -0.06246214f, -0.04957635f, -0.03804587f, 0.00882476f, -0.05569110f, -0.01898773f, 
    -0.00396707f, -0.00315596f, -0.03775359f, -0.01789785f, -0.03411893f, 0.02132582f, 0.00444147f, -0.04769173f, 
    -0.04548983f, -0.05620923f, -0.01675699f, -0.04177479f, -0.06782431f, -0.03258469f, -0.03077493f, -0.04813553f, 
    -0.04795430f, 0.00191718f, -0.06344438f, -0.05139237f, 0.05165148f, 0.00674159f, 0.05537868f, -0.05050742f, 
    0.02620480f, 0.04008874f, -0.00000607f, 0.00684961f, -0.05127119f, -0.00558152f, -0.05424161f, 0.02796076f, 
    0.01673620f, 0.00607889f, 0.01622805f, -0.04518005f, -0.00264465f, -0.00560453f, 0.00529258f, 0.03802939f, 
    0.00575002f, 0.01407351f, 0.04649134f, -0.04667484f, -0.01690196f, -0.04936327f, -0.04782840f, -0.04387980f, 
    0.04798964f, 0.00148044f, -0.03010935f, -0.05153788f, -0.04570967f, -0.00971283f, 0.00021069f, 0.00532611f, 
    -0.04712064f, 0.00594880f, 0.04403201f, 0.02400620f, -0.00397946f, 0.03922022f, 0.01299858f, 0.04186606f, 
    -0.03268479f, 0.03842899f, 0.05990214f, -0.02981131f, -0.01154792f, 0.04061167f, -0.03283925f, -0.03361691f, 
    -0.01307233f, -0.01401361f, 0.02923199f, 0.00035034f, -0.03282981f, 0.03890571f, -0.03823369f, 0.03304989f, 
    0.04545286f, -0.01277288f, -0.00496778f, 0.03025013f, -0.04069207f, -0.06720964f, -0.01436027f, -0.00379050f, 
    0.03040084f, -0.01298231f, -0.00124543f, -0.02502137f, -0.03777998f, -0.04294044f, -0.02210296f, -0.03795030f, 
    -0.04007822f, -0.01287365f, 0.02601032f, 0.02241609f, -0.06205104f, -0.02181814f, -0.00564986f, -0.05589210f, 
    -0.03381411f, -0.02223678f, -0.06376270f, -0.01967580f, 0.04542127f, -0.06589983f, 0.02028811f, -0.03957439f, 
    0.03401306f, -0.05627992f, -0.02299960f, 0.02889639f, -0.00076784f, 0.02292635f, 0.02028395f, -0.02547569f, 
    -0.06261913f, 0.00062705f, 0.02604428f, 0.03493298f, -0.06233801f, -0.02086864f, -0.04138820f, 0.01660845f, 
    -0.02095528f, -0.04945913f, 0.02738205f, 0.02539511f, -0.00028727f, 0.04500580f, -0.02937093f, -0.00268860f, 
    -0.05939193f, -0.01006485f, 0.00721610f, 0.04136751f, -0.06031190f, -0.05117559f, -0.05224709f, -0.01929007f, 
    -0.04076305f, -0.00621192f, -0.02787936f, 0.00643131f, -0.02587105f, 0.01607652f, -0.02639970f, 0.00425763f, 
    -0.05650613f, 0.03973422f, -0.02336709f, 0.01460810f, 0.01109896f, -0.01191461f, -0.03280145f, -0.05127670f, 
    0.00644282f, -0.06509637f, -0.01993704f, 0.04331594f, -0.02127369f, -0.00198823f, 0.00328686f, -0.04012937f, 
    0.01488667f, 0.01579767f, 0.01235636f, 0.01523515f, 0.03874514f, -0.04139141f, -0.05657526f, -0.00463223f, 
    0.00974423f, 0.00353869f, -0.03510631f, -0.00722440f, -0.02932198f, 0.02807101f, 0.04717436f, 0.03189721f, 
    -0.06158394f, -0.00740214f, 0.03693856f, -0.02886783f, -0.05618810f, -0.06369785f, -0.05333952f, -0.01307213f, 
    -0.02353225f, -0.02635424f, 0.04715923f, 0.03226348f, 0.04764213f, 0.00254197f, -0.01541651f, -0.02467031f, 
    -0.00132885f, 0.04242964f, -0.01560971f, 0.05154267f, 0.01216726f, -0.05303370f, 0.04295990f, -0.00619903f, 
    0.01562237f, -0.38834050f, -0.17846373f, 0.01689632f, 0.06409138f, 0.00256985f, -0.05035045f, 0.03427358f, 
    -0.05696565f, 0.06457530f, -0.40089315f, -0.11346824f, 0.01662296f, -0.11428285f, 0.05843969f, -0.16072999f, 
    0.00256359f, 0.07853423f, -0.35580832f, -0.02403724f, -0.12747775f, -0.00080940f, 0.05729780f, -0.06881255f, 
    0.02259843f, -0.04648802f, 0.03237987f, 0.04546561f, -0.16893764f, 0.00424028f, -0.09121793f, 0.14684841f, 
    -0.07338613f, 0.14525090f, 0.03592851f, 0.06348412f, -0.10638205f, -0.13157353f, -0.07166637f, -0.14931335f, 
    -0.24456024f, -0.08347369f, 0.00717355f, -0.09295502f, 0.10702313f, 0.07260796f, -0.03330408f, 0.04105276f, 
    -0.10100698f, -0.02694323f, -0.06177931f, 0.05080078f, 0.00547392f, -0.00138618f, -0.09708142f, 0.05172552f, 
    0.03612161f, -0.15856843f, 0.02680143f, 0.06572012f, 0.09487016f, 0.11194749f, 0.00184533f, -0.17115416f, 
    -0.35247487f, -0.15444778f, 0.00942457f, 0.03144317f, 0.03719044f, 0.02034249f, -0.00710648f, 0.07036246f, 
    0.12981576f, 0.06980243f, 0.19142774f, 0.11022796f, 0.08662181f, -0.02939413f, 0.16026294f, 0.00346420f, 
    0.08778268f, -0.26444048f, -0.07356896f, -0.05112210f, -0.05526435f, 0.17174532f, 0.07679020f, 0.09364258f, 
    0.15439226f, 0.08158008f, -0.35083443f, -0.26276127f, -0.26724368f, -0.04949844f, 0.06118810f, -0.20556016f, 
    0.02162427f, -0.02527332f, -0.08207402f, -0.15845823f, -0.01125699f, 0.02161154f, 0.00226207f, -0.19708894f, 
    0.00656411f, 0.05355321f, 0.03813922f, 0.03181289f, -0.18954143f, -0.40622807f, 0.11267152f, -0.08109238f, 
    0.01093451f, -0.09188984f, 0.04496272f, -0.08208802f, 0.09808518f, -0.25114933f, 0.03705511f, 0.25118655f, 
    -0.04855376f, 0.09384464f, 0.11632825f, 0.16237305f, -0.08899458f, 0.05505583f, 0.10660058f, -0.01764183f, 
    0.08668331f, -0.00495035f, 0.02561436f, 0.06382610f, 0.15807913f, 0.20367722f, 0.18324374f, -0.14369316f, 
    -0.01384260f, 0.17556141f, -0.14641942f, -0.01861097f, -0.28266263f, 0.03801977f, -0.02113091f, -0.02150445f, 
    -0.56483889f, -0.31882611f, -0.20776822f, -0.08213928f, 0.13189118f, -0.00746236f, 0.07824651f, -0.20793858f, 
    -0.03206917f, 0.20380050f, -0.10688423f, -0.07092773f, -0.03779064f, 0.04486304f, 0.15028156f, 0.04656160f, 
    0.15595387f, 0.04470310f, 0.24006167f, -0.50388330f, -0.11481017f, -0.01797305f, -0.03700249f, -0.00758627f, 
    -0.08524829f, 0.10717990f, 0.01086690f, 0.04245463f, 0.05622039f, -0.21697567f, -0.01623553f, 0.06289705f, 
    -0.01025146f, 0.17827457f, 0.02655359f, 0.17764956f, -0.06816273f, -0.37124047f, 0.07365670f, 0.08543134f, 
    0.07972769f, 0.05314507f, 0.12770408f, 0.05964231f, -0.06271734f, -0.10900669f, -0.31665483f, 0.02151744f, 
    0.01579072f, -0.15607125f, -0.08213788f, 0.09222718f, 0.07247335f, 0.03830973f, 0.07429397f, -0.06592229f, 
    -0.06661056f, -0.01022860f, 0.00178780f, -0.08408159f, 0.17483293f, 0.08213051f, 0.07872011f, -0.03747371f, 
    -0.62589324f, 0.12288941f, 0.09405263f, -0.00095534f, 0.11155150f, -0.06417417f, -0.05563845f, 0.09994627f, 
    0.37132129f, 0.22935368f, -0.10773210f, -0.03268172f, -0.05389472f, 0.10375372f, -0.07758554f, 0.15434374f, 
    0.07112423f, -0.18169837f, -0.06639066f, -0.08059489f, 0.05367119f, 0.11824969f, -0.06838310f, 0.06936933f, 
    -0.07756701f, 0.08907587f, 0.05227611f, 0.12556085f, 0.00930856f, -0.06477785f, -0.05473922f, 0.12788413f, 
    0.06166009f, 0.01940877f, -0.06620071f, 0.28062546f, 0.23835850f, -0.10173620f, 0.01690828f, 0.03478110f, 
    0.11006524f, 0.04861857f, 0.08436057f, 0.04067286f, -0.25685829f, -0.33583203f, 0.01360446f, 0.06180038f, 
    0.03766954f, -0.04675391f, -0.02243708f, 0.00885234f, -0.13809626f, -0.04150589f, -0.12408197f, -0.24059826f, 
    -0.02804612f, -0.08381432f, 0.25982973f, 0.01470190f, -0.03805961f, 0.10925394f, 0.15639931f, 0.01536125f, 
    -0.16622081f, 0.02187135f, -0.14755544f, -0.07871886f, 0.02210036f, 0.14872921f, 0.02557599f, 0.16451292f, 
    -0.07816806f, -0.25046843f, 0.08372152f, 0.13160588f, 0.14179620f, 0.10716107f, 0.06223766f, 0.09400731f, 
    -0.04377426f, 0.02587993f, 0.03770351f, 0.03937631f, -0.05801340f, 0.01598932f, -0.00345315f, -0.01544129f, 
    0.04549347f, -0.03049970f, -0.05593231f, 0.03903143f, 0.03408934f, 0.00033508f, 0.01571548f, -0.05857728f, 
    0.00702694f, 0.01920933f, 0.01224754f, 0.05147450f, 0.01684600f, -0.02850859f, -0.01375861f, -0.02407880f, 
    0.00184010f, 0.01701606f, -0.04656850f, 0.03524202f, -0.01569387f, 0.01825746f, -0.02446016f, -0.03529438f, 
    0.04472641f, 0.00099002f, 0.02883946f, -0.06879902f, 0.00423155f, -0.03809615f, -0.04062237f, -0.05751980f, 
    -0.02846094f, -0.03615763f, -0.01291941f, 0.05081792f, -0.03077642f, 0.00893073f, 0.03481925f, -0.00809669f, 
    -0.03939894f, -0.00967678f, 0.00917118f, -0.01594033f, -0.05772620f, 0.02535366f, -0.06345002f, 0.01191616f, 
    -0.01508029f, 0.03225219f, 0.04566393f, -0.02111109f, -0.01345205f, -0.05209930f, -0.05360240f, -0.05687385f, 
    0.03308905f, -0.06481823f, -0.00493002f, -0.06566802f, -0.00346446f, -0.02625077f, -0.05197922f, -0.01052095f, 
    -0.04079935f, 0.00561333f, -0.06587651f, 0.00374365f, 0.00562566f, -0.01962749f, -0.03664095f, -0.02377187f, 
    0.03046823f, -0.00530733f, 0.01959779f, -0.06377268f, 0.01093191f, 0.04870734f, -0.05821302f, -0.00181359f, 
    -0.01988835f, 0.03934979f, 0.03081558f, -0.03015960f, 0.01387884f, 0.04334576f, -0.00666560f, 0.02186169f, 
    -0.02162898f, 0.03154656f, -0.04435699f, -0.01026428f, 0.00139926f, -0.03236371f, 0.01909683f, 0.00699674f, 
    -0.00662126f, 0.02071766f, -0.01162460f, 0.01024390f, -0.03044005f, -0.02574937f, -0.06257983f, 0.01045480f, 
    0.03748421f, 0.01097101f, 0.02719749f, -0.05374882f, 0.04085501f, -0.05740368f, -0.05121777f, 0.04887387f, 
    0.02301190f, -0.02915285f, -0.01688804f, -0.03445033f, -0.00437182f, 0.04403447f, -0.04557837f, -0.05236295f, 
    -0.03501005f, -0.02391813f, -0.02855111f, -0.02597800f, -0.01746566f, 0.01309229f, -0.03228822f, 0.01066844f, 
    0.00197452f, 0.02994869f, 0.03563458f, -0.05065529f, 0.04237561f, 0.03429745f, -0.03780965f, -0.03743506f, 
    0.04587943f, 0.00980622f, -0.01601267f, 0.03218287f, 0.05021251f, 0.00355726f, 0.02624193f, -0.04917980f, 
    -0.00943111f, 0.03122587f, -0.04679305f, 0.01890002f, 0.04359313f, -0.06555264f, 0.01079101f, 0.00851584f, 
    0.01574336f, 0.03541007f, 0.03078286f, -0.00849282f, 0.00495125f, -0.01849109f, -0.02851348f, 0.00423472f, 
    -0.04155531f, 0.01594591f, -0.05666435f, -0.02751354f, 0.01657003f, -0.02467279f, 0.02095700f, 0.02868043f, 
    -0.06627166f, -0.00091628f, -0.02616100f, -0.03764730f, 0.03359111f, -0.06803439f, 0.02290099f, -0.05601312f, 
    -0.00226597f, -0.01942738f, 0.00088415f, -0.06376594f, 0.00235447f, 0.01231009f, 0.03247347f, -0.04093941f, 
    0.03114293f, -0.01989268f, 0.03669978f, -0.05515246f, -0.00764420f, -0.06614865f, 0.01800409f, 0.02299162f, 
    0.04090023f, 0.03258019f, -0.06756806f, 0.02116613f, 0.00793246f, 0.04614626f, 0.02965624f, 0.01116859f, 
    0.02865136f, 0.02431590f, -0.04220749f, -0.05171923f, -0.02160350f, -0.05592662f, -0.01151738f, -0.02582990f, 
    -0.02242476f, -0.02967928f, -0.05581925f, 0.01726556f, -0.04529789f, 0.01570338f, -0.05914298f, 0.01011711f, 
    -0.04835101f, 0.00435499f, 0.03925748f, -0.02304763f, -0.02795349f, -0.00895723f, 0.01333711f, -0.00279201f, 
    0.01405982f, 0.01540220f, -0.06043629f, 0.03331602f, -0.05702440f, -0.02116207f, 0.01069532f, -0.04298781f, 
    -0.00226068f, -0.01067876f, -0.01638583f, 0.02777310f, -0.04709568f, 0.03774934f, 0.01770143f, -0.01592621f, 
    0.03266146f, -0.04616356f, -0.04219536f, -0.02713408f, 0.01738549f, -0.02295839f, -0.01336202f, -0.02094777f, 
    -0.04668956f, 0.01898803f, -0.01074357f, -0.04978394f, -0.06776710f, -0.01620200f, 0.00448559f, -0.03647505f, 
    0.03132239f, 0.01854364f, 0.00886668f, 0.04436395f, -0.06399175f, -0.00132185f, -0.06479128f, 0.02586608f, 
    -0.06333594f, -0.01225497f, -0.02356207f, 0.02409548f, 0.01376583f, -0.01713225f, -0.04096460f, -0.05293386f, 
    -0.06784531f, 0.00990438f, 0.00323766f, -0.00987596f, 0.02498423f, -0.05546840f, -0.00292505f, -0.05766932f, 
    0.10363311f, -0.08962289f, 0.13697253f, 0.06643734f, -0.02966811f, 0.24782090f, 0.15428168f, -0.06526187f, 
    0.22422647f, -0.27518463f, -0.08690728f, -0.04999248f, -0.01169439f, 0.16801453f, -0.00640049f, 0.03127817f, 
    -0.20539680f, -0.08464397f, -0.05814046f, 0.06225239f, -0.11233714f, 0.04091535f, -0.01243643f, -0.00003526f, 
    0.04130689f, 0.05970268f, -0.02642799f, 0.01784446f, 0.17079057f, 0.39838356f, 0.00357837f, -0.10450792f, 
    -0.13058576f, -0.00034527f, 0.01341652f, 0.16233620f, -0.06987898f, 0.02197759f, -0.06832450f, 0.13987017f, 
    -0.26860404f, 0.16590272f, -0.00870238f, -0.23989396f, -0.05733123f, 0.02990043f, 0.09823005f, 0.10706331f, 
    -0.12404368f, -0.12961051f, -0.07000528f, -0.03270658f, -0.23617923f, -0.01351526f, -0.03314579f, -0.10512297f, 
    -0.08675775f, 0.08563622f, 0.01951518f, -0.01326973f, 0.16447002f, 0.07940770f, 0.22699681f, 0.16162035f, 
    -0.05897348f, -0.09892724f, 0.15420671f, -0.08102908f, 0.23035951f, 0.04699713f, 0.10944844f, 0.06876980f, 
    -0.19870695f, -0.11767901f, 0.02185775f, -0.06072531f, -0.00126184f, 0.11462285f, -0.05273196f, -0.01031218f, 
    0.10781253f, -0.09947461f, -0.02399982f, -0.25372338f, 0.08771387f, -0.26231724f, 0.07899231f, -0.03130332f, 
    -0.10994001f, -0.33333752f, 0.12721729f, -0.09602020f, -0.01665192f, 0.04006568f, -0.06634635f, 0.01118419f, 
    -0.01211170f, 0.01257547f, 0.20657361f, -0.02305754f, 0.09736892f, -0.09333515f, 0.03530777f, -0.08164738f, 
    -0.02872113f, 0.09611345f, -0.12373217f, -0.00744722f, -0.01627874f, 0.03856608f, 0.05075955f, 0.20489445f, 
    -0.10187925f, -0.13529781f, 0.00250806f, -0.23937580f, -0.08958353f, -0.16047277f, -0.07429273f, -0.05562821f, 
    -0.13478540f, 0.09084294f, -0.09240595f, -0.08740353f, -0.10127389f, 0.00566888f, 0.12011398f, 0.12304906f, 
    0.17341463f, 0.17327113f, 0.23742327f, 0.08591679f, 0.13416931f, -0.01061262f, 0.07918332f, -0.02743084f, 
    -0.04367725f, -0.07019569f, -0.09889255f, -0.00823403f, -0.11217799f, -0.17724267f, -0.47806641f, -0.29130340f, 
    -0.48194239f, -0.06901767f, -0.21143185f, -0.07227156f, -0.10115174f, -0.00810798f, -0.06460651f, -0.24275804f, 
    -0.02159041f, 0.05317435f, 0.07053888f, 0.14275780f, -0.02544230f, -0.09462555f, -0.01120072f, 0.00458259f, 
    0.01540748f, 0.03737979f, -0.14661969f, 0.10930216f, 0.16852939f, -0.03503042f, -0.17713222f, 0.02176735f, 
    0.04648951f, -0.04056374f, 0.20415331f, 0.07074600f, -0.04314340f, 0.11026271f, -0.01908123f, 0.18748395f, 
    -0.05044987f, 0.07603934f, -0.03760862f, 0.09766278f, -0.13734284f, -0.02406620f, 0.06035127f, -0.07669476f, 
    0.03321949f, 0.01133639f, 0.13692838f, -0.04836385f, 0.05797910f, -0.07959606f, -0.14787544f, 0.01372662f, 
    -0.07340562f, -0.08882232f, 0.22019291f, 0.05764338f, 0.10117404f, -0.06240433f, 0.09099485f, 0.16084111f, 
    0.04222785f, -0.05901831f, 0.07754733f, 0.02807612f, -0.10530356f, -0.02922264f, -0.03455686f, -0.01829839f, 
    -0.10939630f, 0.13625482f, 0.00776623f, -0.11529323f, 0.03283142f, 0.08360639f, -0.08805069f, 0.05893720f, 
    0.42764449f, 0.10700409f, 0.03523666f, 0.02537566f, -0.09551122f, -0.02315170f, -0.05042703f, 0.17889102f, 
    -0.10827927f, -0.08905084f, 0.05090078f, 0.11625630f, 0.01109993f, -0.15959655f, -0.02558517f, 0.03339051f, 
    0.04746220f, -0.13795528f, 0.07834373f, 0.09292674f, -0.11224332f, -0.12953505f, 0.00233043f, -0.03670787f, 
    -0.02423338f, -0.05463994f, -0.03394491f, 0.20696890f, 0.01502299f, -0.00823060f, -0.05143091f, 0.06116759f, 
    0.09839901f, -0.01505411f, 0.06304970f, -0.05490334f, 0.07262114f, 0.01338830f, 0.03062108f, -0.05881074f, 
    -0.12367442f, 0.08503102f, 0.01794505f, 0.13494356f, 0.04108824f, 0.11989779f, 0.10633028f, 0.21613218f, 
    -0.12398363f, -0.02547690f, 0.07175122f, -0.06593884f, -0.14176907f, -0.08999572f, 0.08690286f, 0.13521481f, 
    0.20501572f, -0.07889057f, -0.06318437f, 0.04682281f, -0.15247776f, 0.01789265f, -0.13385321f, 0.15983689f, 
    0.11851015f, 0.03522709f, 0.10157987f, 0.17160377f, 0.10987897f, -0.00212158f, 0.06773613f, 0.10888046f, 
    -0.00554233f, -0.15505452f, -0.10501920f, -0.15667003f, -0.00281599f, 0.08640796f, -0.10240400f, 0.12529114f, 
    -0.12013672f, -0.09498189f, 0.16846746f, -0.09090853f, 0.04201993f, -0.00482174f, 0.13911933f, -0.02105926f, 
    -0.08503504f, 0.11250892f, 0.15746818f, -0.02659822f, 0.10370440f, -0.10301715f, -0.11031587f, 0.00527992f, 
    0.09543759f, 0.06762744f, -0.04708244f, 0.03874472f, 0.11322682f, 0.03823979f, 0.11612612f, -0.14128737f, 
    -0.04233607f, -0.04678483f, -0.00571643f, -0.04424568f, 0.14690357f, -0.72356391f, -0.39266366f, -0.09047545f, 
    0.19948721f, -0.26262724f, -0.20722914f, 0.04682847f, -0.01843485f, 0.10965441f, 0.11937976f, 0.18889125f, 
    -0.10694236f, -0.09172367f, -0.03485957f, -0.05104882f, 0.00671562f, -0.02238951f, 0.11461748f, -0.36117157f, 
    0.09050901f, 0.06885891f, 0.13512003f, 0.05070474f, 0.02254714f, 0.08142517f, 0.00051581f, -0.14247155f, 
    0.03028543f, 0.01835935f, 0.08461024f, 0.00562096f, -0.03284381f, 0.01144744f, 0.03421728f, -0.16131301f, 
    -0.14841093f, 0.17215763f, -0.08509039f, -0.15356787f, -0.02623382f, -0.06874686f, 0.12904848f, -0.00659307f, 
    -0.08549425f, 0.10385270f, 0.08579419f, -0.02058221f, -0.17717776f, 0.01447064f, 0.19616458f, 0.07337562f, 
    0.14075410f, -0.06954475f, -0.07869628f, 0.56510085f, -0.12285476f, -0.05370093f, -0.07352065f, -0.08308882f, 
    0.04236969f, 0.01630673f, 0.03796164f, 0.40889448f, -0.02866283f, -0.51488006f, 0.06286894f, -0.13593809f, 
    0.15998295f, -0.00324180f, 0.06306789f, 0.01517400f, 0.07153369f, 0.19058670f, -0.06627206f, -0.02017314f, 
    -0.25759354f, -0.14612181f, 0.12946138f, 0.09102148f, 0.18466723f, -0.01000557f, -0.37043324f, -0.38959903f, 
    -0.08725666f, 0.23321372f, 0.08991908f, -0.03263781f, -0.11724787f, 0.01384819f, 0.25763682f, -0.16508681f, 
    0.08092049f, 0.00780911f, 0.10307558f, 0.13069417f, 0.03884090f, -0.01031244f, 0.03256784f, -0.08464930f, 
    -0.27637634f, -0.34775782f, -0.10950174f, -0.06070151f, -0.00384641f, -0.01932998f, 0.01330206f, 0.00352076f, 
    -0.11874369f, 0.07121098f, 0.16473573f, -0.00326354f, -0.26676726f, -0.04471862f, -0.04036567f, 0.08873677f, 
    0.17662902f, 0.04517147f, 0.19223388f, 0.10930777f, 0.01518627f, -0.10981612f, -0.01154598f, 0.01358529f, 
    -0.00421347f, 0.04387886f, 0.00679242f, -0.02559736f, 0.05502241f, 0.00544227f, -0.07109052f, -0.16486163f, 
    -0.02104702f, 0.06499694f, -0.00476589f, -0.00904472f, 0.25330362f, -0.31174418f, 0.13813671f, -0.11882512f, 
    0.05472609f, 0.14269671f, 0.08981229f, 0.04493399f, 0.02855383f, 0.05004311f, 0.07974021f, 0.02811087f, 
    -0.05573184f, -0.02728683f, 0.06982276f, -0.00616331f, 0.02806907f, 0.00338329f, 0.16854468f, -0.37134445f, 
    -0.02327013f, -0.18089457f, -0.05627194f, 0.16709441f, 0.20868820f, -0.18879369f, -0.03125856f, 0.14364330f, 
    -0.08009795f, -0.00199056f, 0.07952151f, 0.01429366f, -0.04617291f, 0.02178492f, 0.03225509f, -0.17902566f, 
    0.08919266f, -0.02623328f, 0.05928375f, 0.21714903f, -0.32716623f, 0.02568594f, 0.06998502f, 0.02951894f, 
    0.23115857f, -0.14121485f, -0.14799753f, -0.06050599f, 0.03542973f, -0.11283237f, 0.31524131f, 0.03296168f, 
    -0.02234566f, -0.07552496f, 0.14888234f, 0.10469434f, 0.05451922f, -0.13217595f, -0.06638736f, 0.13335925f, 
    0.05338154f, 0.09549006f, -0.15402457f, -0.37722036f, -0.08856917f, -0.03830726f, 0.07835450f, 0.09455831f, 
    0.12782635f, -0.01922014f, 0.11666558f, -0.24342005f, -0.08295245f, -0.03669520f, 0.03166224f, 0.16646700f, 
    0.02356120f, 0.08442149f, 0.13717090f, 0.04629485f, 0.01675525f, -0.16675521f, 0.05517823f, -0.03943342f, 
    -0.08114434f, -0.10481022f, -0.00259972f, 0.19921236f, -0.15875025f, -0.20445682f, 0.24127185f, -0.03331736f, 
    -0.01878232f, 0.02422663f, -0.05649925f, 0.04913725f, 0.05278422f, 0.09177486f, -0.09926809f, 0.27035001f, 
    -0.01445788f, -0.05098215f, -0.03464832f, -0.03987140f, 0.10168441f, 0.03787852f, 0.03775217f, 0.35860872f, 
    0.06466062f, 0.01610555f, -0.06230419f, 0.22661531f, 0.01818989f, 0.07358796f, 0.00125651f, -0.08163235f, 
    0.02700048f, 0.12853557f, 0.04273104f, 0.04468983f, -0.08948975f, 0.07208156f, 0.19737755f, 0.17458574f, 
    0.00078530f, 0.17620987f, 0.22991353f, -0.04907480f, -0.08256318f, -0.01890785f, 0.03032422f, 0.08125003f, 
    0.07401751f, 0.08204480f, -0.01770510f, -0.06150198f, -0.17053625f, -0.10325374f, -0.00001339f, 0.09238712f, 
    0.06917583f, 0.16431507f, 0.13705672f, -0.06344999f, -0.18763100f, -0.06037733f, -0.01722668f, 0.01375242f, 
    0.15729165f, 0.01957195f, -0.03157140f, -0.04573875f, -0.06968091f, 0.33907121f, 0.40373838f, 0.21634308f, 
    -0.15839303f, -0.14222254f, 0.03602622f, 0.26127329f, -0.02198253f, -0.20521036f, -0.30619735f, -0.00507472f, 
    0.15527628f, 0.06582145f, -0.06876090f, 0.06384581f, 0.06773890f, -0.13723958f, 0.06311851f, 0.03537427f, 
    0.13871810f, -0.10801458f, -0.05427504f, -0.02261819f, 0.17054966f, 0.18676788f, 0.22301032f, -0.12765117f, 
    0.05641069f, 0.00094821f, 0.07503045f, 0.07002243f, 0.05659886f, -0.09474843f, -0.01258159f, -0.02459834f, 
    -0.06334031f, -0.14288157f, 0.09154847f, 0.16532272f, 0.12147354f, 0.15911695f, 0.14715342f, 0.10854808f, 
    0.21141316f, 0.04138665f, -0.02055148f, 0.24755108f, 0.14887442f, -0.10460535f, 0.05454500f, -0.15462273f, 
    0.05168422f, -0.28672448f, 0.03312262f, -0.04021743f, -0.20684908f, -0.09563030f, 0.00305037f, -0.02262998f, 
    0.09853675f, -0.07415307f, 0.01900002f, -0.07070693f, -0.05229968f, 0.10289579f, 0.08726530f, 0.00627933f, 
    0.02181127f, -0.00514066f, -0.18850224f, -0.23615617f, -0.05608259f, -0.15438510f, -0.07074694f, -0.03410066f, 
    -0.06086063f, -0.10402665f, -0.00814963f, 0.14238842f, -0.04818318f, -0.05037790f, 0.08926348f, 0.11021399f, 
    0.08870515f, -0.08746844f, 0.02019082f, -0.01232831f, 0.04721459f, -0.04996745f, 0.29605368f, -0.07616309f, 
    0.24029820f, 0.03160870f, 0.01403427f, 0.06178051f, 0.19210060f, 0.01598405f, 0.14985195f, -0.10343470f, 
    -0.03045403f, -0.07329950f, 0.09519968f, -0.05095058f, 0.02109753f, -0.30697387f, -0.14148001f, -0.24286470f, 
    -0.13186687f, -0.26749289f, 0.04391244f, 0.06131391f, -0.04399212f, 0.16149928f, -0.22669533f, -0.12320127f, 
    -0.39960063f, -0.17057754f, -0.19423687f, 0.05677659f, -0.05384382f, 0.07274698f, 0.09818581f, 0.00776719f, 
    -0.00640956f, -0.02533809f, -0.28974101f, -0.05966032f, -0.02755132f, -0.00503743f, 0.09193184f, 0.08898327f, 
    0.01136339f, 0.03904513f, 0.08377252f, 0.18733698f, 0.02191801f, 0.11172993f, 0.15476952f, 0.05622568f, 
    0.07635945f, 0.15089311f, 0.03123128f, 0.29002878f, -0.16950184f, -0.13564630f, -0.07394639f, 0.06588454f, 
    -0.09763993f, 0.08701413f, -0.02297746f, 0.02477006f, 0.11245069f, -0.14687939f, 0.02131002f, -0.17203268f, 
    0.04383617f, 0.12952378f, 0.11450770f, -0.07140324f, 0.30429783f, 0.09916119f, -0.19460632f, -0.16779879f, 
    0.02751106f, 0.09455925f, 0.17480439f, 0.12780833f, 0.04057759f, -0.15918829f, -0.15363863f, -0.00464528f, 
    0.16091880f, 0.02114894f, -0.11727040f, -0.14491688f, -0.08742669f, -0.08866982f, 0.04684494f, 0.00904059f, 
    -0.01409981f, 0.09179941f, 0.12740418f, 0.09994942f, 0.10606287f, -0.06359693f, 0.01565353f, -0.06404863f, 
    0.15825787f, -0.05173935f, -0.21948028f, -0.13407575f, 0.04172816f, -0.20417732f, 0.05370839f, 0.07914104f, 
    -0.01835117f, -0.13803497f, -0.02153032f, 0.15289094f, 0.12272184f, -0.04679025f, -0.08110173f, -0.06690598f, 
    -0.09240790f, -0.01092968f, -0.10698406f, 0.08542733f, 0.08585939f, 0.12647623f, 0.07965844f, 0.11418052f, 
    0.02144006f, -0.00864074f, -0.07789338f, 0.01155898f, 0.03911214f, 0.10688717f, 0.05765291f, -0.15566497f, 
    -0.09215987f, 0.03343562f, 0.02780591f, 0.31449860f, 0.12331598f, -0.23004775f, -0.30900574f, 0.14403866f, 
    -0.05022023f, 0.25273666f, 0.11493782f, -0.00629551f, -0.03504778f, -0.07459716f, -0.11823883f, -0.04126484f, 
    0.31332791f, -0.10864836f, -0.12174932f, 0.11680647f, 0.03498985f, 0.05332847f, -0.12103064f, 0.04583026f, 
    0.27627477f, 0.15567282f, -0.04010715f, 0.11660310f, 0.09603608f, 0.06555226f, 0.18178718f, 0.07422251f, 
    -0.19321522f, -0.51031864f, -0.18801478f, -0.02004076f, -0.12842941f, 0.03378376f, 0.00949959f, -0.04608965f, 
    0.06070522f, 0.00446079f, -0.28754583f, 0.17821184f, -0.13827042f, -0.15126762f, 0.04511561f, 0.02488230f, 
    -0.03235514f, 0.14699163f, -0.15796646f, -0.14256720f, -0.12244386f, -0.04561047f, -0.15601613f, -0.03899951f, 
    0.01558246f, 0.13179097f, 0.11211241f, 0.01169846f, -0.06474632f, -0.00099652f, 0.04943746f, 0.13942079f, 
    -0.06599220f, -0.02019479f, 0.05582029f, -0.13340567f, -0.06870873f, -0.18267272f, -0.44466156f, -0.06237076f, 
    0.10860445f, -0.08639346f, 0.05623231f, -0.15976763f, 0.09905019f, -0.18054853f, 0.06752604f, -0.00502839f, 
    -0.21390347f, -0.22427014f, -0.31683052f, 0.09248428f, 0.08589420f, -0.01556689f, -0.07719564f, 0.02357146f, 
    -0.12841702f, 0.14642690f, -0.00561029f, 0.14319690f, 0.08828343f, 0.12375844f, -0.02751841f, -0.16316217f, 
    -0.17178893f, -0.16883403f, 0.11322434f, -0.03412707f, -0.14123188f, 0.05473443f, 0.08259763f, 0.05958514f, 
    0.03406522f, 0.19719419f, 0.13753356f, 0.22148578f, -0.10962345f, -0.10586191f, 0.08841930f, 0.10190228f, 
    -0.07318798f, -0.13808423f, -0.14381467f, -0.03180290f, 0.00812307f, 0.12405933f, 0.19485129f, 0.14096221f, 
    0.13051945f, -0.07193600f, -0.15945055f, -0.37793118f, -0.11639094f, -0.11119502f, -0.05793165f, -0.11787539f, 
    0.00786390f, 0.01915994f, -0.06627224f, -0.14221391f, -0.21399783f, 0.03207971f, -0.00936160f, -0.07996430f, 
    -0.01988361f, -0.01403957f, 0.19419450f, 0.03428383f, -0.15936196f, -0.00297852f, -0.13374589f, -0.17902373f, 
    -0.04925791f, -0.05187259f, -0.02687366f, -0.06249705f, -0.03533453f, -0.06553880f, 0.14384003f, -0.03580609f, 
    0.14907780f, 0.14752208f, 0.03926611f, 0.04848111f, 0.14413004f, 0.10977294f, 0.02707534f, -0.09060206f, 
    0.01417403f, 0.21380934f, 0.08236598f, 0.21047644f, 0.08975576f, 0.17404838f, 0.08747448f, 0.01920295f, 
    0.04658960f, 0.13142082f, 0.01829420f, -0.01534572f, 0.05039582f, 0.00820660f, -0.01428590f, 0.14680544f, 
    -0.13416339f, -0.15368854f, -0.14023694f, 0.00033859f, -0.25515971f, 0.06120003f, -0.05665520f, 0.05929714f, 
    0.00209571f, -0.15921420f, -0.01052949f, -0.23072110f, -0.06744616f, 0.00988782f, 0.05049632f, -0.00379689f, 
    -0.05279487f, 0.04391148f, -0.31693846f, -0.37187359f, -0.03461794f, -0.03871919f, -0.11524859f, -0.01284445f, 
    -0.07266673f, -0.05241515f, 0.04670934f, 0.01599009f, 0.08150329f, 0.04036538f, 0.17759001f, -0.01042309f, 
    0.08478233f, 0.07624995f, 0.08520377f, 0.03490684f, -0.13920200f, 0.12596023f, 0.09413205f, 0.15750556f, 
    -0.14889716f, 0.00820153f, 0.01333693f, 0.02915620f, 0.02074135f, -0.32994917f, -0.22337955f, 0.17106430f, 
    -0.15123919f, -0.34738383f, 0.09716833f, 0.00288865f, 0.13493730f, 0.14654081f, -0.04027821f, -0.00747878f, 
    -0.31175601f, -0.20917936f, -0.07287663f, -0.02052528f, 0.06793998f, -0.13314369f, 0.12770639f, -0.18531460f, 
    -0.10002681f, 0.10911559f, -0.05605399f, 0.04393284f, -0.05794842f, -0.05239950f, -0.16105387f, 0.04506768f, 
    0.30348665f, -0.06347300f, -0.37644750f, -0.02240198f, 0.14160299f, 0.07500049f, -0.01124482f, 0.06349229f, 
    0.17858677f, 0.07100764f, 0.10177529f, -0.26909670f, -0.01459566f, -0.03692076f, 0.09219851f, 0.13883117f, 
    0.16225103f, 0.12179528f, 0.12837633f, 0.11979494f, 0.13892892f, 0.01436150f, 0.09211508f, 0.04251741f, 
    0.03383419f, 0.07375350f, 0.07283241f, 0.41638568f, 0.15243982f, 0.07989430f, 0.11244103f, 0.12191657f, 
    0.27778485f, 0.04797634f, 0.11874229f, 0.16843641f, -0.05581775f, -0.06215262f, -0.06138313f, 0.00307089f, 
    -0.09638913f, 0.08621241f, 0.15784135f, -0.01012941f, -0.02696563f, 0.17996079f, -0.09621540f, -0.45858756f, 
    -0.18101391f, 0.08225906f, -0.13731851f, -0.02463641f, 0.19227915f, -0.07843035f, 0.03925831f, -0.15395112f, 
    -0.51197916f, 0.01847826f, 0.13840747f, -0.03347449f, 0.06168900f, -0.08881590f, -0.10049393f, 0.11477122f, 
    -0.01594193f, -0.12629938f, 0.10872038f, 0.07180820f, 0.10937323f, 0.05377668f, 0.14637057f, 0.22906625f, 
    0.08821300f, 0.01682948f, 0.20248088f, 0.03977420f, 0.07668825f, 0.23031802f, 0.28886402f, 0.01473450f, 
    0.30595434f, 0.35463828f, 0.14393432f, 0.04093485f, -0.08415480f, -0.04838856f, 0.14415225f, 0.24041693f, 
    -0.04613376f, 0.00631865f, 0.03582115f, -0.00419239f, 0.06219698f, 0.17943229f, -0.07385311f, -0.08396249f, 
    -0.08014373f, 0.16191344f, 0.06908593f, -0.04663005f, -0.05555649f, -0.04390986f, 0.03843191f, -0.08127746f, 
    0.01814006f, -0.02581942f, 0.01117113f, 0.05143125f, 0.17229116f, 0.14926529f, 0.05743794f, 0.03868277f, 
    0.05820274f, 0.08005401f, -0.01617017f, 0.03848991f, -0.08603798f, -0.06067484f, -0.13926908f, -0.16394846f, 
    0.08313593f, 0.02182328f, 0.08551537f, -0.12993847f, -0.00465139f, -0.02086610f, 0.03756860f, 0.04688395f, 
    0.05946196f, 0.00082581f, -0.11652763f, -0.08076902f, 0.09970574f, 0.09713677f, 0.06985348f, -0.02741647f, 
    0.06789380f, -0.09163069f, 0.17935733f, 0.02870913f, -0.03156787f, 0.10778916f, 0.09344713f, 0.04200109f, 
    -0.00676846f, -0.04496014f, -0.09863148f, -0.00939333f, 0.07059817f, 0.04277152f, 0.11169368f, 0.03756833f, 
    -0.10407700f, 0.11988547f, -0.03556983f, 0.13442749f, -0.01310539f, -0.00591016f, 0.10914830f, -0.05918341f, 
    -0.14934124f, -0.26347342f, 0.20343988f, 0.01878040f, 0.20591152f, 0.18757729f, 0.02934059f, 0.24153462f, 
    0.09592371f, 0.05481173f, 0.14877318f, 0.12640475f, 0.19738944f, 0.13043387f, 0.07104207f, -0.07820778f, 
    -0.03551500f, -0.08797279f, -0.10887185f, -0.19868727f, 0.25917920f, -0.50405812f, -0.05673754f, -0.01639725f, 
    -0.00618557f, 0.07446475f, -0.06209498f, -0.04525112f, -0.11377659f, 0.16835067f, 0.04615136f, -0.21992142f, 
    -0.02138885f, 0.00783045f, -0.02437177f, -0.15266041f, 0.02030757f, -0.01077268f, -0.02571612f, -0.17559950f, 
    0.15754671f, -0.07665839f, 0.07034521f, -0.02294780f, -0.01668166f, -0.20000991f, -0.06402604f, 0.18963362f, 
    0.10809377f, -0.09826048f, 0.07663141f, 0.08866671f, 0.05618956f, -0.15457202f, -0.09835637f, -0.33549702f, 
    -0.06865250f, -0.13381889f, 0.07195647f, 0.17643388f, -0.14156380f, -0.01046484f, -0.00309100f, -0.06054086f, 
    -0.10625297f, -0.09949277f, -0.11771541f, -0.15491390f, -0.01849935f, 0.02313999f, -0.07111203f, 0.09748857f, 
    0.03394947f, -0.04875423f, 0.02736023f, 0.03625129f, 0.01701997f, 0.02069621f, 0.04152273f, 0.18242890f, 
    0.21540169f, 0.08001044f, 0.02885239f, 0.15001486f, -0.01495929f, -0.19500002f, 0.05081946f, -0.06677891f, 
    -0.00812484f, -0.08657983f, -0.12523331f, -0.09651168f, -0.01272248f, -0.06476961f, -0.28342509f, 0.17596962f, 
    -0.12017017f, 0.06146850f, -0.02741179f, -0.10484730f, -0.19216779f, 0.10837232f, 0.11004514f, -0.03715914f, 
    0.21420993f, 0.13575268f, 0.01094597f, 0.08690029f, 0.07729933f, 0.12869415f, 0.21801396f, -0.17692800f, 
    -0.21516137f, 0.10173906f, -0.01452458f, 0.04202579f, -0.12792853f, -0.06890518f, 0.06222906f, -0.02029938f, 
    -0.13211520f, -0.00055779f, 0.01754532f, 0.19260018f, 0.02112982f, -0.02804737f, -0.02964977f, 0.12853199f, 
    0.19577965f, -0.27836457f, -0.15055275f, 0.24379715f, -0.00396982f, -0.12669726f, -0.01250617f, -0.03315502f, 
    0.11504041f, -0.17232966f, -0.09170380f, 0.05452118f, 0.00024791f, -0.13513966f, -0.06987445f, -0.01148394f, 
    -0.06425937f, -0.04864075f, 0.17222224f, 0.16191624f, -0.20632213f, 0.09908366f, 0.03831311f, 0.05686850f, 
    -0.13107681f, -0.11754695f, -0.06091840f, 0.06110789f, 0.01141442f, -0.29212385f, 0.04935614f, 0.07086357f, 
    -0.04433960f, -0.07566132f, -0.12637943f, -0.12556966f, 0.00395300f, 0.13149278f, 0.16699597f, 0.05267432f, 
    0.04759264f, -0.02383933f, 0.16908851f, 0.08459745f, 0.31167144f, -0.00442697f, -0.24583258f, -0.15507194f, 
    0.09751821f, 0.08943881f, 0.08846300f, -0.00078807f, 0.01915918f, -0.20454901f, 0.08992077f, -0.14634842f, 
    -0.08175965f, 0.05358129f, 0.04098109f, 0.03182520f, -0.11078661f, 0.06901615f, -0.11147521f, 0.03852559f, 
    0.00066269f, -0.08146483f, 0.05796193f, 0.07608367f, 0.05440650f, -0.02503083f, 0.02136103f, -0.03597803f, 
    -0.06464935f, -0.12310351f, -0.07778244f, -0.03401753f, 0.06914937f, 0.03031748f, 0.15979454f, 0.13934797f, 
    0.19076593f, -0.29465216f, -0.44288933f, -0.03954559f, -0.09459321f, 0.07626998f, 0.14097203f, -0.04585233f, 
    0.02807322f, -0.02587266f, -0.08841901f, -0.25902009f, -0.15597868f, 0.00447289f, -0.09010999f, -0.02924546f, 
    0.04967943f, 0.16443512f, 0.10497206f, -0.04615770f, 0.08841436f, -0.01876008f, 0.06139605f, -0.04977350f, 
    -0.12441604f, -0.11628230f, 0.03025136f, 0.04121366f, -0.19220258f, 0.13324672f, -0.13151482f, 0.06895974f, 
    0.02518283f, 0.16241603f, 0.02458175f, 0.04696807f, -0.22840428f, 0.10300776f, 0.01648327f, 0.10955797f, 
    0.07046808f, 0.14202918f, 0.08363948f, 0.04974928f, 0.00953013f, -0.08095452f, 0.06541833f, 0.17300168f, 
    -0.04625535f, -0.10258085f, -0.04777803f, -0.00761076f, -0.01404273f, 0.15336706f, 0.14812821f, 0.07222201f, 
    -0.12405480f, -0.02849177f, 0.17045054f, 0.01016621f, 0.06012298f, 0.02774720f, -0.03757088f, 0.12518620f, 
    -0.05157173f, 0.06964396f, 0.15711504f, 0.05918426f, 0.12308622f, -0.13274352f, -0.03114772f, 0.07849443f, 
    -0.05370298f, 0.00353984f, 0.05708533f, -0.12822084f, -0.06923683f, 0.07439249f, -0.00381336f, -0.12278527f, 
    -0.03016251f, 0.11047479f, -0.21625370f, -0.16577139f, -0.19331524f, -0.03930240f, -0.06134199f, -0.06864472f, 
    0.12912904f, 0.06226413f, 0.18038437f, -0.10737015f, 0.10732736f, 0.08999019f, -0.02857083f, -0.11704884f, 
    -0.01291924f, -0.04398728f, 0.01015601f, -0.14256236f, -0.12119178f, -0.09214072f, 0.08406705f, -0.08298943f, 
    0.13854869f, -0.17520827f, -0.21783867f, 0.15482117f, -0.16105863f, -0.01542983f, 0.16483614f, -0.00053959f, 
    0.00131646f, 0.25912628f, -0.14280072f, -0.04016374f, -0.09437807f, -0.08061536f, -0.16356382f, 0.02051728f, 
    -0.00631190f, -0.02832559f, 0.02324205f, 0.04960532f, -0.08199694f, 0.07083801f, 0.17663907f, -0.08925999f, 
    0.09843207f, 0.00478218f, 0.08426551f, 0.17044200f, -0.08183913f, 0.08993280f, -0.12808658f, -0.12885636f, 
    -0.57922107f, -0.08557349f, -0.30492985f, 0.21072479f, -0.09123290f, 0.10244858f, -0.10333273f, -0.16746454f, 
    -0.00975075f, 0.02187589f, -0.02782238f, 0.08544108f, 0.04248818f, 0.06247686f, 0.10593486f, -0.01092772f, 
    0.03389192f, -0.10618167f, -0.10646005f, -0.08151706f, 0.05067089f, 0.07153891f, 0.05438714f, -0.01268577f, 
    -0.04287972f, 0.13153660f, -0.04923844f, 0.01665605f, 0.07205232f, -0.19678661f, 0.03376606f, 0.05541637f, 
    0.12212338f, -0.07603012f, -0.04687238f, 0.05181356f, -0.18685867f, -0.02389677f, -0.06147645f, 0.21427837f, 
    0.08105421f, -0.01871176f, -0.13706301f, -0.03243115f, -0.02082856f, 0.10494071f, -0.09559684f, -0.15695474f, 
    0.02710378f, -0.05071190f, 0.12157822f, 0.12095845f, 0.17532319f, 0.12837388f, 0.10979473f, -0.02200526f, 
    0.18212458f, -0.03108416f, -0.04667858f, 0.15626955f, 0.07780647f, 0.12778901f, -0.15851022f, -0.05173048f, 
    -0.13401386f, 0.25758320f, 0.05005002f, 0.18355758f, -0.09917819f, -0.23429875f, -0.22055849f, -0.21822657f, 
    0.18619065f, -0.06710838f, 0.07053272f, -0.00700606f, -0.03133607f, 0.19143359f, 0.03553872f, -0.01539665f, 
    0.07579342f, -0.08418404f, 0.10634349f, -0.14777924f, 0.10648163f, -0.06356374f, -0.06873956f, -0.15075423f, 
    0.10968696f, -0.03791501f, 0.16164997f, 0.20277442f, -0.01286095f, -0.00725851f, 0.10515294f, -0.08735006f, 
    -0.02766960f, -0.09752133f, -0.04515237f, 0.24691798f, 0.03374387f, -0.13060461f, 0.07696502f, 0.13471490f, 
    -0.15165639f, 0.04700899f, -0.04457700f, 0.00816281f, -0.03469059f, -0.09341465f, -0.03408008f, -0.20707434f, 
    -0.26404715f, -0.05789666f, 0.11774777f, 0.17122605f, 0.14589404f, 0.05503706f, -0.09432554f, -0.04799579f, 
    0.09042557f, 0.23770359f, 0.02781372f, -0.07920586f, 0.04398144f, 0.07926045f, 0.02743416f, -0.07334663f, 
    0.01100290f, 0.08929588f, -0.13911228f, 0.09480054f, -0.01966937f, -0.02991149f, 0.02630959f, 0.09562435f, 
    0.12260756f, -0.29164633f, -0.00380610f, 0.00614635f, -0.06188798f, -0.02962734f, 0.07930241f, 0.09417392f, 
    0.04805807f, -0.06049939f, 0.09149424f, 0.11218943f, 0.13711078f, -0.10411938f, -0.13664059f, 0.10932122f, 
    0.05744923f, 0.03069202f, -0.05126075f, 0.08048841f, 0.06170143f, -0.09846731f, -0.05584044f, -0.06161151f, 
    0.02519595f, -0.04409386f, -0.00012255f, 0.30305180f, 0.17255162f, 0.00340347f, -0.04800636f, -0.04773224f, 
    0.09420371f, 0.03478410f, 0.12294431f, -0.07131156f, 0.09273436f, 0.08594096f, -0.12580267f, 0.04998266f, 
    -0.23129922f, 0.05094259f, 0.04803098f, 0.12848727f, 0.01211704f, -0.25043827f, -0.27409890f, -0.01286743f, 
    0.30878067f, 0.13787949f, -0.06950951f, -0.17285404f, 0.00046074f, -0.09371164f, 0.02728329f, 0.03726188f, 
    -0.14857677f, -0.13597633f, -0.16003130f, 0.04954658f, -0.09945671f, 0.08957187f, -0.04360677f, -0.00030037f, 
    -0.03874832f, -0.09520400f, 0.00516921f, 0.00072533f, 0.06147121f, 0.08779594f, 0.06570413f, 0.01674090f, 
    0.27607098f, -0.04942489f, -0.11995722f, 0.08544903f, 0.13988407f, -0.04634605f, 0.16251969f, 0.10984740f, 
    -0.16712868f, -0.36235529f, 0.15228914f, -0.08057619f, -0.02586237f, 0.03394125f, -0.06820513f, 0.03035769f, 
    0.05929209f, -0.05892143f, 0.12439281f, 0.09007969f, 0.10105732f, -0.02315938f, -0.02134190f, 0.10333294f, 
    0.05987643f, -0.07533661f, 0.14840633f, 0.17579030f, -0.06477292f, -0.04911419f, 0.05604501f, -0.05805390f, 
    0.13070942f, 0.19014947f, 0.10329057f, 0.16298243f, 0.14608634f, 0.01891802f, 0.04918279f, 0.09040928f, 
    0.09800839f, 0.19696087f, 0.04849686f, -0.08725636f, -0.13524118f, 0.26209480f, -0.14937150f, 0.07170277f, 
    0.07410141f, -0.15714563f, -0.08189673f, 0.01599258f, -0.13562855f, -0.05685523f, -0.03580034f, -0.00674586f, 
    -0.06713981f, -0.07896965f, -0.03012545f, 0.06527208f, 0.00737222f, 0.03148735f, -0.14123408f, 0.05480726f, 
    0.03522849f, -0.02469954f, 0.03375399f, -0.05512010f, 0.00776096f, -0.07748015f, -0.00820084f, -0.04760965f, 
    -0.37914518f, -0.06997725f, -0.05184275f, 0.10953125f, -0.00374721f, -0.13908027f, -0.23003730f, -0.15905458f, 
    -0.24836318f, -0.39262882f, -0.22555363f, 0.13916048f, 0.01296252f, -0.00554143f, 0.11370224f, -0.06000775f, 
    -0.07285748f, -0.15875904f, 0.21485673f, 0.08645008f, -0.10886788f, -0.01837401f, 0.06654424f, 0.00437498f, 
    -0.10498427f, -0.07672182f, -0.19731343f, 0.12182523f, 0.10023807f, -0.05626144f, 0.07439956f, -0.07614061f, 
    -0.02775303f, 0.06133180f, 0.04687489f, 0.14572048f, -0.16913097f, 0.21315540f, -0.09900777f, 0.06277955f, 
    0.04221153f, 0.11471077f, -0.01881701f, -0.03749862f, 0.04541495f, -0.12078347f, 0.18407382f, 0.00969094f, 
    -0.03886094f, -0.08847836f, -0.13548553f, 0.02403517f, 0.03825294f, 0.06578027f, -0.03256914f, 0.14403823f, 
    -0.02502866f, -0.02586075f, -0.13645718f, 0.08200865f, 0.11281683f, 0.12504858f, -0.10784737f, 0.14811523f, 
    0.14135574f, -0.06349203f, -0.23976330f, -0.09465756f, -0.05609603f, 0.00182212f, 0.11573400f, 0.16366734f, 
    0.11039241f, 0.00788962f, 0.11464986f, 0.14632984f, 0.12524761f, -0.09469619f, 0.09430192f, 0.16134715f, 
    -0.16686308f, 0.23696062f, -0.16391203f, -0.05014911f, -0.05330414f, 0.36365354f, -0.08731604f, -0.22148751f, 
    0.04922936f, -0.23024538f, -0.02349063f, 0.24697506f, 0.01118218f, -0.10980204f, -0.23779133f, 0.00616694f, 
    -0.11096599f, -0.02742995f, 0.01919087f, -0.26002875f, -0.20647697f, 0.07156579f, 0.04050150f, 0.01377017f, 
    -0.03467106f, -0.12196387f, -0.05814442f, -0.08930187f, -0.10220928f, -0.15195458f, -0.01283556f, 0.08546788f, 
    0.07929896f, 0.05042654f, -0.03887500f, -0.08688872f, -0.07261056f, 0.09651183f, 0.06966857f, 0.00292490f, 
    0.01130194f, -0.11547143f, 0.13995180f, 0.22634064f, 0.14644602f, -0.09572984f, 0.17372499f, 0.30450153f, 
    0.04049233f, 0.04771460f, 0.02539832f, 0.08990283f, 0.15776064f, -0.12301859f, -0.15992811f, 0.21871948f, 
    0.04562089f, -0.06233711f, 0.05453929f, 0.13603382f, -0.09675755f, -0.05031213f, -0.08471062f, 0.16500096f, 
    -0.16488458f, -0.10078739f, -0.02809641f, 0.14784259f, 0.15809873f, -0.00969369f, -0.04699131f, -0.01398022f, 
    -0.03713682f, -0.20319538f, -0.26233438f, 0.08844202f, -0.04732357f, -0.10179936f, 0.07943996f, 0.10199922f, 
    0.03172207f, -0.14952219f, -0.22699651f, 0.05522870f, 0.17733175f, -0.00984359f, -0.19774234f, 0.06885741f, 
    0.07067849f, -0.04558630f, 0.16691807f, 0.21930920f, 0.09303388f, -0.19791144f, -0.02790460f, 0.02892944f, 
    -0.00558383f, 0.02280401f, 0.00005786f, -0.14646530f, -0.00947745f, 0.34848055f, -0.08031137f, 0.02612132f, 
    -0.12423233f, 0.02052101f, 0.00289803f, 0.02742431f, -0.79678780f, -0.46435270f, -0.37578368f, -0.05161095f, 
    -0.17577036f, 0.13198321f, 0.10131617f, 0.17662930f, 0.14120319f, -0.14498341f, -0.42984664f, -0.25919676f, 
    0.02474914f, -0.06743488f, 0.01017319f, 0.09132329f, 0.05883433f, 0.10564034f, 0.06651962f, -0.10289028f, 
    0.18035515f, -0.08491132f, 0.00020897f, -0.09062033f, 0.02421765f, 0.22224478f, -0.03918626f, 0.19460192f, 
    0.06380127f, 0.06050603f, -0.09767701f, 0.00819460f, -0.17423901f, 0.05611920f, -0.01674970f, 0.04578160f, 
    -0.10383309f, -0.20730373f, -0.31587073f, -0.09954769f, 0.12164360f, -0.16268970f, -0.08086787f, -0.03767147f, 
    -0.02006611f, -0.05219219f, 0.01826288f, 0.21965373f, 0.03482697f, 0.03659578f, -0.02122005f, -0.10228073f, 
    0.08675987f, 0.09960050f, 0.17249107f, 0.21387254f, 0.10112285f, -0.10330127f, 0.01977795f, -0.09324126f, 
    0.06219885f, -0.03946503f, -0.07905686f, 0.22505818f, 0.15523748f, 0.07760669f, 0.02398134f, -0.03937021f, 
    0.04282327f, 0.03307169f, 0.08321039f, 0.07076650f, -0.34482354f, -0.38052708f, 0.00629031f, -0.15382709f, 
    -0.01118742f, -0.16038309f, 0.20252438f, 0.06759153f, -0.01996679f, 0.29174528f, -0.04874736f, -0.07431038f, 
    -0.06241073f, -0.02966159f, 0.20743272f, -0.02583816f, -0.01792659f, -0.06376385f, -0.30160701f, -0.12205385f, 
    0.14680856f, -0.06584819f, 0.01401391f, 0.14077288f, 0.00208073f, 0.07614174f, 0.13751338f, 0.37649614f, 
    -0.10315834f, 0.06770406f, -0.07908843f, -0.08967343f, 0.13398147f, 0.02847045f, 0.08603644f, 0.06557591f, 
    0.04172209f, 0.21559034f, -0.15637966f, -0.02470827f, 0.02692950f, -0.13142836f, 0.17160578f, -0.00604734f, 
    0.06766388f, 0.29462925f, -0.33779019f, 0.10301418f, -0.06994539f, -0.24826232f, -0.08087070f, -0.02534041f, 
    -0.02160411f, -0.05830302f, 0.25287643f, -0.35374501f, 0.20290601f, -0.08125675f, -0.02630056f, -0.06051377f, 
    0.00429171f, 0.05848659f, 0.11613334f, 0.02625033f, -0.03001647f, -0.35006756f, -0.06512638f, 0.05016069f, 
    0.01159648f, -0.03041491f, -0.05312235f, 0.09634466f, 0.01614464f, 0.11656207f, -0.03469994f, 0.04321199f, 
    0.07895254f, -0.20888783f, 0.01085199f, 0.12320190f, -0.14137802f, 0.01964708f, -0.06026430f, 0.13063546f, 
    0.20512711f, -0.21916094f, 0.11510650f, -0.00802226f, 0.07541037f, -0.06105299f, 0.19673806f, -0.36536416f, 
    -0.01678098f, -0.17908591f, -0.06354026f, 0.01461965f, 0.11126107f, -0.09159736f, -0.05185841f, -0.15545654f, 
    -0.54324853f, -0.38407063f, 0.08700471f, 0.01174737f, 0.10379232f, 0.05551660f, 0.06314347f, -0.19721861f, 
    -0.38175425f, -0.09542287f, -0.04361618f, -0.18819419f, 0.10499609f, 0.00466755f, -0.01613843f, 0.04699740f, 
    -0.06297764f, -0.15128691f, 0.16053674f, 0.24701828f, -0.01330703f, -0.16136025f, 0.00201216f, 0.07389306f, 
    -0.05787484f, -0.13256606f, 0.24015570f, 0.11873279f, -0.00816286f, 0.02760697f, 0.05973896f, 0.13292930f, 
    0.11186364f, -0.12946884f, 0.03203395f, 0.40716657f, -0.02112629f, -0.13932163f, -0.01862939f, 0.11954534f, 
    0.07332911f, 0.08468553f, -0.05470534f, -0.05150245f, 0.13396277f, 0.17749920f, 0.19208266f, -0.04975291f, 
    -0.08184046f, -0.05480634f, 0.01440620f, 0.11575043f, -0.02587568f, 0.25140852f, -0.08393569f, 0.12923183f, 
    0.01146382f, -0.00318238f, 0.00187272f, -0.10305360f, -0.01550895f, -0.05063505f, -0.20423089f, -0.33319101f, 
    0.02739564f, -0.22396228f, 0.00205036f, -0.06455877f, -0.02032156f, -0.13497280f, -0.02559103f, 0.07989720f, 
    -0.07607576f, -0.09620233f, 0.00058333f, 0.02698101f, -0.04714127f, -0.00537626f, 0.07546543f, 0.06609619f, 
    -0.02081450f, -0.00878688f, -0.04927420f, -0.04822298f, -0.02178031f, -0.05225619f, -0.05860957f, 0.01764835f, 
    0.03903260f, 0.03848965f, 0.01205283f, 0.00329507f, -0.02851691f, 0.01111491f, -0.02117031f, -0.03806804f, 
    -0.05335949f, -0.04611085f, 0.03381055f, -0.04029659f, 0.01611456f, 0.00219265f, -0.04038272f, 0.01408514f, 
    -0.03933933f, 0.00120627f, 0.00923209f, 0.00578160f, -0.03575942f, -0.01328865f, -0.06146102f, 0.04922229f, 
    -0.02228871f, -0.05737108f, 0.03820317f, -0.01623544f, 0.04209688f, -0.04625031f, -0.02386537f, -0.00935727f, 
    0.04686436f, 0.02070491f, -0.00428447f, 0.04664093f, -0.05070069f, 0.02476461f, -0.05110804f, -0.03922325f, 
    -0.02581507f, -0.02501333f, -0.02849546f, -0.05131116f, -0.00689251f, -0.05696513f, 0.02243799f, 0.03430743f, 
    -0.00930419f, 0.00602774f, 0.00535844f, -0.02798957f, 0.02723881f, 0.04678389f, 0.00532325f, -0.01427905f, 
    -0.03408359f, -0.04273922f, -0.04131810f, -0.06167529f, -0.01120058f, -0.03058358f, 0.02609390f, -0.00522551f, 
    -0.03928786f, -0.06027800f, -0.02699227f, 0.02977520f, -0.04568212f, 0.00523299f, 0.03559031f, -0.05142878f, 
    -0.00188753f, 0.03787532f, 0.00478692f, 0.01699847f, 0.03919816f, 0.01327704f, -0.00109956f, -0.01300454f, 
    0.06037473f, -0.05860537f, -0.00035981f, 0.05829344f, -0.02418905f, -0.04632143f, -0.03321938f, -0.00162393f, 
    -0.05643370f, -0.01144514f, -0.00191672f, -0.02584182f, -0.05090902f, -0.03165214f, 0.00742077f, -0.05459018f, 
    -0.06369376f, 0.04479297f, 0.04659373f, -0.04384346f, 0.03626201f, -0.01761155f, 0.05429821f, 0.01983432f, 
    0.01657170f, -0.02147511f, -0.00109283f, -0.03753624f, 0.02190719f, 0.04796084f, 0.03556414f, 0.01475786f, 
    -0.02707259f, 0.02225336f, 0.01260214f, 0.03731727f, -0.04175299f, -0.06218287f, 0.02978422f, -0.03720511f, 
    -0.04093774f, 0.01853576f, 0.01572561f, 0.04954759f, -0.06584311f, 0.02124657f, 0.00002518f, -0.00638848f, 
    0.01385548f, -0.04121509f, 0.01849290f, -0.01034454f, -0.00992845f, -0.01003342f, -0.05066983f, -0.00033408f, 
    0.03583889f, 0.02759019f, 0.05564295f, -0.00412036f, -0.00333466f, 0.05897024f, -0.05375860f, -0.01203993f, 
    0.05310990f, 0.03384550f, 0.00649898f, 0.01064689f, 0.00427793f, -0.05229060f, 0.03701943f, -0.06806985f, 
    -0.03792063f, -0.05456204f, 0.03972991f, -0.02565046f, 0.04935946f, -0.07303260f, 0.03814017f, -0.02932470f, 
    0.00105511f, 0.01647871f, -0.03341158f, 0.00712842f, -0.02273456f, -0.01795776f, 0.03115889f, -0.03507692f, 
    0.04972076f, 0.03660364f, 0.00593922f, -0.02986665f, -0.04469999f, -0.01669271f, 0.04950347f, -0.00488183f, 
    -0.00653062f, -0.05109334f, 0.02473022f, -0.03674691f, -0.02719633f, 0.00919968f, 0.00055891f, 0.02724501f, 
    -0.03732790f, 0.02632942f, -0.00214519f, 0.03847286f, -0.01299498f, -0.04067715f, 0.01481742f, 0.01552039f, 
    0.03381174f, -0.04265871f, 0.04014314f, -0.04723958f, 0.03333174f, 0.05080137f, 0.02938800f, -0.00648359f, 
    0.04942569f, 0.05103712f, -0.00353353f, -0.00784809f, -0.04339231f, -0.02926067f, -0.04312377f, -0.02403339f, 
    -0.06449263f, -0.06081083f, -0.00400241f, -0.00469305f, -0.01368474f, -0.02869265f, -0.05701436f, 0.02123264f, 
    0.02915294f, -0.06735633f, 0.02381028f, -0.01827728f, 0.04441917f, -0.00167823f, -0.00352115f, -0.01896668f, 
    0.03951928f, -0.01792100f, -0.05433759f, 0.04669742f, -0.02236262f, -0.04292665f, -0.05128456f, -0.06166213f, 
    -0.02076750f, -0.04935806f, -0.03804616f, -0.06075968f, 0.02648885f, 0.05178594f, 0.02547479f, -0.03040279f, 
    -0.05247809f, -0.03825010f, -0.00907057f, 0.00188220f, -0.04541839f, -0.02348499f, 0.05727718f, -0.04814237f, 
    -0.04077746f, -0.04304843f, -0.02892984f, -0.00230995f, -0.02034353f, 0.01038918f, 0.01127681f, -0.06335798f, 
    -0.01967292f, -0.00803919f, 0.00582444f, -0.04452309f, -0.01336670f, 0.02539524f, 0.01901215f, -0.06090044f, 
    -0.04889067f, -0.02535726f, -0.01495798f, 0.00548346f, -0.00112252f, 0.01800375f, -0.03980879f, 0.02523064f, 
    0.00693225f, 0.02821089f, -0.02672630f, -0.00046509f, -0.02835341f, -0.06619927f, 0.03510348f, 0.03779992f, 
    0.11799228f, -0.01664333f, 0.15900025f, -0.01268452f, 0.11650392f, 0.00616672f, 0.09991630f, 0.07278580f, 
    0.00902790f, 0.36394230f, 0.00686393f, 0.23928714f, -0.43380588f, -0.03247444f, 0.19394955f, -0.14205794f, 
    -0.05730156f, -0.14136282f, -0.08111147f, 0.07394504f, 0.06829557f, 0.01263468f, -0.04691119f, -0.02361697f, 
    -0.00470192f, 0.07022143f, 0.00322036f, 0.15384129f, -0.08845078f, 0.15077390f, -0.01261049f, -0.04773461f, 
    -0.05574860f, -0.00634468f, -0.12268409f, 0.04745936f, -0.41433522f, 0.03821028f, -0.45556545f, -0.04410985f, 
    -0.26651186f, -0.10733683f, 0.04568146f, -0.03810716f, -0.14190736f, 0.07817120f, -0.04298105f, 0.08155546f, 
    -0.09374207f, 0.00708527f, -0.01169613f, 0.09687556f, 0.03168917f, 0.04505273f, -0.24804255f, 0.01790525f, 
    0.04627263f, 0.01567717f, 0.02937750f, 0.02921587f, 0.08795577f, 0.13403706f, -0.01567782f, -0.25709870f, 
    -0.04783110f, -0.24954711f, 0.08542870f, 0.10040443f, -0.10586255f, 0.10922346f, 0.07141753f, 0.10583030f, 
    0.36592987f, -0.20858842f, -0.00970536f, 0.06909430f, 0.22059374f, 0.04821665f, -0.09750728f, -0.02520748f, 
    0.11646847f, -0.25297344f, -0.15313181f, 0.16966742f, 0.02980844f, -0.01852888f, -0.03172131f, -0.09941079f, 
    0.04341947f, -0.17685762f, -0.22593923f, -0.10751470f, -0.20576970f, -0.12758751f, -0.00323912f, -0.03760847f, 
    0.01388758f, -0.03546446f, 0.00108928f, -0.08582091f, -0.00732939f, 0.13798334f, -0.07626286f, 0.08115248f, 
    0.13460928f, 0.12058876f, -0.06972536f, -0.10970628f, -0.12287020f, -0.09597999f, -0.28733721f, -0.12162881f, 
    0.11352140f, -0.18418813f, -0.10649021f, 0.10023836f, -0.02595413f, -0.06320014f, -0.00389782f, -0.00533932f, 
    0.18232468f, 0.05502162f, -0.02933742f, 0.01809471f, 0.03981526f, -0.00240818f, -0.00692607f, 0.03783239f, 
    0.24907865f, 0.19892398f, 0.10777149f, 0.07784665f, 0.10631137f, 0.09366718f, 0.11908439f, -0.12329765f, 
    -0.08994082f, -0.18324560f, 0.07128662f, 0.13569684f, -0.04375753f, -0.22847995f, -0.19658267f, -0.17655800f, 
    -0.46914640f, -0.26282352f, 0.04294356f, -0.04269057f, -0.02845434f, -0.00673357f, 0.08549930f, 0.11292438f, 
    -0.03717145f, 0.22415426f, -0.05680414f, 0.24610175f, -0.00915983f, 0.11747052f, -0.07047625f, 0.07104634f, 
    0.09969587f, 0.03707379f, 0.38375011f, 0.11056809f, 0.15162654f, 0.16906147f, 0.06557786f, -0.09293987f, 
    0.04893009f, 0.10085654f, 0.09697187f, 0.09223808f, -0.03429127f, 0.11662450f, -0.02927734f, 0.05960774f, 
    0.08082878f, 0.06988858f, -0.00220503f, -0.03909943f, 0.25204158f, -0.19224499f, 0.14100742f, 0.01575458f, 
    -0.01260842f, -0.01143600f, -0.00078828f, 0.21434474f, 0.16090067f, -0.08741630f, -0.22971289f, -0.02442812f, 
    -0.03582454f, 0.12373096f, 0.04475377f, 0.04391584f, -0.08994803f, -0.02929812f, 0.00284646f, -0.08689983f, 
    0.15853955f, -0.14126353f, -0.03139691f, -0.08587351f, 0.03497767f, -0.10835912f, 0.12160322f, 0.41979671f, 
    -0.22535463f, -0.06810603f, -0.04218969f, 0.03290743f, -0.05546335f, 0.02261255f, 0.06683542f, 0.02477245f, 
    0.16170883f, 0.07821803f, 0.27723446f, 0.12737474f, 0.00055129f, 0.08729579f, 0.01497810f, -0.08891506f, 
    0.03331976f, 0.16690317f, -0.24097900f, 0.14541569f, -0.03903618f, -0.08732885f, 0.08282526f, -0.03087204f, 
    -0.04543698f, 0.03375424f, -0.04614930f, -0.00416891f, -0.02991435f, 0.11663770f, 0.04578220f, -0.06579338f, 
    -0.09747582f, 0.01424365f, 0.01401503f, 0.17746764f, -0.03606646f, -0.01708125f, 0.04245961f, 0.05744343f, 
    -0.05818160f, -0.04157050f, -0.02854201f, 0.01257057f, -0.41234943f, 0.05294600f, -0.06644552f, -0.13032977f, 
    0.00738802f, -0.24022463f, 0.12177362f, 0.10157933f, 0.15420479f, 0.12262982f, -0.17927732f, 0.02424779f, 
    -0.02340367f, -0.04016180f, 0.01394491f, -0.11697857f, -0.10139743f, 0.10738832f, 0.05932985f, -0.01786430f, 
    0.08360860f, 0.01688525f, -0.02230481f, -0.04560148f, -0.07468168f, 0.00699158f, -0.10319697f, -0.02296954f, 
    0.10891771f, 0.09228954f, 0.14903900f, -0.00016809f, 0.24506111f, 0.02537408f, -0.06725387f, 0.09146883f, 
    -0.21963975f, 0.31759423f, -0.29036564f, -0.10157062f, -0.10956205f, 0.16533178f, -0.00370962f, 0.03505877f, 
    0.00303200f, 0.30180591f, 0.33121386f, -0.08045573f, -0.01126414f, -0.05493946f, 0.04256537f, 0.19670677f, 
    -0.06000471f, -0.05292590f, -0.01666155f, 0.26037318f, 0.03512031f, -0.11380738f, 0.13517852f, -0.20663811f, 
    -0.01541328f, -0.01330616f, 0.07486668f, 0.04947083f, 0.08442955f, 0.09320202f, -0.18619017f, -0.13988173f, 
    -0.14621322f, 0.08399779f, 0.10392926f, 0.11530328f, -0.18477789f, -0.22795315f, -0.58550388f, 0.04333380f, 
    -0.21708351f, 0.22590643f, -0.07914432f, -0.00547268f, -0.09746043f, 0.07509930f, 0.03181677f, -0.05326375f, 
    -0.07422086f, -0.23514186f, -0.16194524f, 0.05188778f, 0.03985484f, -0.00368371f, -0.13263381f, 0.05383890f, 
    -0.21364164f, 0.05423731f, -0.00129013f, 0.00163531f, 0.13706298f, 0.15609302f, 0.03776981f, -0.21354499f, 
    0.16068542f, 0.12351879f, 0.07211937f, -0.02674107f, -0.13074578f, 0.03340634f, -0.04803979f, 0.00576660f, 
    0.30493101f, 0.02949072f, -0.05401783f, -0.04615675f, -0.03542319f, -0.01855532f, 0.05746970f, 0.07187853f, 
    0.00311263f, 0.16216931f, -0.11624647f, 0.23687683f, -0.14767136f, 0.01521989f, -0.02848591f, 0.01678564f, 
    0.06690064f, -0.00677159f, -0.17103936f, -0.04539077f, 0.30582774f, -0.11468759f, 0.03979519f, -0.24970725f, 
    0.08297212f, 0.15463790f, -0.02182146f, -0.05567299f, 0.17152150f, 0.18993847f, -0.11831461f, 0.07265251f, 
    -0.18583250f, -0.01282005f, 0.01780836f, 0.10001050f, -0.43256932f, -0.31154588f, 0.03974350f, -0.05203122f, 
    0.02162292f, -0.44704998f, 0.03841883f, -0.24942166f, 0.11268613f, -0.15685390f, -0.24770837f, -0.05812041f, 
    0.10836216f, 0.00151441f, 0.14771850f, -0.01011163f, -0.00816459f, -0.01748652f, -0.18285719f, 0.12278558f, 
    -0.04146286f, 0.13735622f, -0.00487360f, 0.06894677f, 0.06535458f, 0.04957081f, 0.02627703f, -0.26272324f, 
    -0.31686476f, -0.08473396f, 0.04687440f, 0.11327765f, -0.08140388f, -0.22106849f, -0.04110722f, 0.10707860f, 
    -0.16069013f, -0.13355942f, 0.15893847f, -0.01200693f, -0.07207301f, -0.01731323f, 0.10282674f, 0.00932416f, 
    0.05428409f, 0.12361484f, 0.18153010f, 0.01092342f, -0.03377124f, -0.02184519f, -0.03841584f, -0.06123012f, 
    0.06712814f, -0.03329923f, 0.07457668f, 0.30166620f, -0.15749529f, -0.05708333f, -0.09015822f, -0.08559886f, 
    0.03917816f, 0.12226516f, 0.02628099f, 0.03892043f, 0.12151851f, 0.33406302f, 0.02525849f, 0.03538083f, 
    -0.02099223f, 0.00123737f, 0.07776495f, -0.11080078f, 0.04545115f, 0.21018800f, -0.15214182f, -0.02806561f, 
    -0.02119384f, -0.06596338f, 0.04981920f, -0.01514276f, 0.05585602f, -0.23575157f, 0.08263784f, 0.17859040f, 
    -0.19689426f, 0.09316665f, -0.37737456f, 0.10468622f, 0.02723799f, 0.09914850f, -0.22923975f, 0.22405493f, 
    0.08267839f, -0.08015167f, -0.17354999f, -0.06786701f, 0.01791403f, -0.10905953f, -0.00802222f, 0.24150078f, 
    -0.35394987f, 0.02210846f, 0.21438332f, 0.01853963f, -0.09120525f, -0.03382097f, -0.04937540f, 0.11656007f, 
    0.23544815f, -0.03829086f, -0.10585400f, -0.06088453f, -0.05306261f, -0.02140677f, 0.06055577f, -0.06954436f, 
    0.00796113f, -0.29506162f, -0.02505906f, -0.06342862f, -0.05532251f, -0.00930969f, 0.09037939f, -0.01303498f, 
    0.05809792f, -0.02074295f, -0.18363342f, 0.06012261f, -0.25879684f, 0.22029908f, -0.05707351f, 0.09760672f, 
    0.01596407f, 0.02822308f, 0.10013794f, -0.28350782f, -0.15171103f, -0.00358812f, 0.22071089f, 0.04265504f, 
    0.25106534f, 0.03653049f, -0.06690492f, 0.06218451f, -0.31645548f, -0.22914204f, 0.07541620f, -0.05978683f, 
    0.03396351f, -0.12904461f, 0.08527527f, 0.04857649f, -0.14323287f, -0.18747914f, -0.22975798f, 0.32386270f, 
    0.04649878f, -0.10216075f, -0.00168192f, -0.06127078f, 0.12071141f, 0.08891301f, -0.09645968f, -0.02170893f, 
    0.25963020f, -0.01619606f, -0.03042205f, -0.04102798f, -0.14340816f, -0.00823706f, -0.09869578f, 0.18387505f, 
    -0.02042791f, 0.02182705f, 0.04653074f, 0.20929407f, 0.12615253f, -0.03048204f, 0.16161309f, -0.02894476f, 
    -0.16543594f, -0.08989308f, -0.06290361f, -0.10734531f, 0.09995795f, 0.08881911f, -0.20985034f, 0.04674104f, 
    0.13175774f, 0.25948966f, 0.36493751f, 0.07005500f, 0.12117738f, -0.05024375f, -0.07311341f, -0.01961567f, 
    -0.04431282f, 0.00217511f, 0.08520019f, -0.16853723f, 0.10335954f, 0.05941418f, 0.06737579f, -0.01038999f, 
    0.06869093f, -0.12383521f, 0.04329585f, -0.02225746f, 0.25124729f, 0.20159175f, -0.09165216f, 0.05720844f, 
    0.01211099f, 0.14040715f, -0.08164191f, -0.02018340f, 0.00553006f, -0.13836637f, -0.04259572f, -0.26295620f, 
    -0.04101085f, -0.00152121f, 0.01773942f, 0.00628180f, -0.00771433f, 0.10596003f, 0.03099800f, 0.09330462f, 
    -0.01039792f, 0.00432119f, 0.01896232f, -0.09155014f, -0.08296094f, -0.15751208f, 0.06004743f, -0.21504377f, 
    -0.01903755f, -0.01161966f, 0.06557269f, -0.05335084f, -0.01689603f, -0.02574688f, 0.11767655f, -0.14823821f, 
    -0.00364891f, 0.06750724f, 0.06408817f, 0.00407152f, 0.07908405f, -0.02003428f, 0.10064997f, 0.06032976f, 
    0.42719123f, 0.12246246f, 0.04395288f, -0.04742461f, 0.03710998f, -0.01882796f, -0.00774077f, 0.03148131f, 
    -0.01567017f, 0.11330648f, -0.03096700f, 0.06756742f, 0.00829596f, -0.03595324f, 0.08421061f, 0.09948628f, 
    0.00507637f, 0.00029206f, -0.06457233f, 0.11807538f, 0.10203034f, -0.09714132f, 0.02384610f, -0.09861082f, 
    0.05387500f, -0.00778973f, 0.01051389f, 0.15943427f, -0.01424605f, -0.09131836f, -0.01334365f, -0.10399686f, 
    0.20886108f, 0.08825234f, 0.01119926f, 0.11072973f, 0.04292554f, 0.11674772f, -0.16625232f, 0.20889035f, 
    0.01796232f, -0.13429734f, -0.13509694f, 0.11192713f, 0.00320528f, 0.10175771f, -0.21402581f, -0.25028786f, 
    -0.01797581f, -0.01101366f, -0.04102255f, 0.03670827f, -0.05822078f, -0.04740637f, 0.14016411f, 0.01775366f, 
    0.17051382f, -0.02459662f, -0.02056050f, 0.05292611f, 0.10053271f, -0.04866403f, -0.05603459f, -0.24144045f, 
    -0.34511712f, -0.14036831f, 0.10307742f, -0.07411912f, 0.12957041f, 0.06864896f, 0.11581445f, 0.09621094f, 
    0.21206897f, 0.08367245f, 0.16647701f, 0.07557954f, 0.03322921f, 0.00074218f, -0.04387287f, -0.06831630f, 
    0.08619294f, 0.23913571f, 0.12533250f, 0.21037771f, -0.00506882f, -0.18920447f, -0.10506882f, 0.05276214f, 
    -0.00119520f, -0.12463507f, 0.27933869f, 0.19669451f, 0.02909340f, 0.00312410f, -0.03196861f, -0.10264108f, 
    0.04194927f, 0.01013366f, -0.01345300f, 0.11638901f, 0.25156587f, 0.01856377f, 0.07294805f, -0.05472139f, 
    0.08195877f, 0.06925854f, 0.07186589f, -0.13100842f, 0.52272666f, 0.14429255f, 0.02116934f, -0.07456327f, 
    -0.09634100f, -0.13624793f, 0.01144240f, -0.03232892f, -0.03011085f, -0.04179118f, 0.08889388f, -0.10500240f, 
    0.17301451f, -0.00542102f, -0.10666119f, -0.05528475f, -0.09435289f, -0.03058292f, 0.04061102f, 0.00143332f, 
    0.08375487f, 0.07403856f, -0.06317218f, -0.06798862f, -0.18399683f, -0.05470742f, -0.14724109f, 0.17439860f, 
    0.07117254f, -0.00500258f, 0.06735811f, 0.03950845f, -0.29533535f, 0.06021930f, 0.14335500f, 0.10888029f, 
    0.25230134f, -0.03701763f, 0.15679277f, 0.06856699f, 0.04209555f, -0.10827588f, 0.18073584f, -0.08342978f, 
    -0.27932751f, 0.25908005f, 0.27535468f, 0.16406150f, 0.06782658f, 0.03027239f, -0.21898796f, 0.03377083f, 
    -0.01875531f, 0.04985946f, -0.14837226f, -0.17421557f, 0.01899123f, -0.12524754f, -0.01723323f, 0.08787342f, 
    -0.00023680f, 0.00424212f, 0.04821426f, -0.05652279f, -0.13963059f, 0.01996833f, -0.01881401f, 0.06605774f, 
    0.03624883f, 0.04976269f, 0.00008067f, 0.12002320f, -0.14743148f, -0.17434493f, -0.06287084f, 0.20213826f, 
    0.03120193f, -0.02847707f, -0.09895951f, -0.24931885f, -0.02552465f, -0.01832934f, 0.18005159f, -0.06279934f, 
    -0.04275978f, 0.05426164f, -0.03350102f, 0.09931145f, -0.07074250f, -0.25400332f, -0.06785569f, 0.07086914f, 
    0.29730067f, -0.07959457f, -0.04707090f, -0.00098821f, 0.08436613f, -0.06669649f, -0.22681360f, 0.10065729f, 
    -0.03929989f, 0.02022322f, 0.02744609f, 0.01162629f, 0.00833605f, 0.19032457f, -0.17227571f, -0.02615360f, 
    -0.04662338f, 0.00230688f, -0.03107911f, -0.01258310f, -0.01061881f, -0.02415453f, -0.04037949f, -0.00807269f, 
    -0.02211200f, 0.05203487f, -0.04367567f, -0.06188455f, -0.05630543f, 0.01174723f, -0.00792494f, -0.04850743f, 
    -0.02000166f, -0.03811426f, -0.00089058f, -0.04304858f, 0.00197023f, 0.02147862f, -0.05662206f, 0.01268224f, 
    -0.04011240f, -0.00563327f, -0.06271003f, -0.04299213f, -0.04417502f, 0.02588275f, 0.01874974f, -0.06307110f, 
    -0.02753172f, -0.04074199f, 0.02454626f, -0.01999911f, -0.01520106f, -0.06392054f, -0.00487199f, 0.02847981f, 
    0.04182636f, 0.04172640f, 0.04972938f, 0.00430370f, -0.02172693f, -0.01392298f, 0.02521329f, -0.05064549f, 
    -0.03674411f, -0.00345361f, -0.00425996f, -0.02410967f, -0.03520093f, 0.00353082f, -0.02122199f, -0.04875324f, 
    0.04090752f, -0.04521998f, -0.00703198f, -0.02975268f, 0.00633303f, -0.00142400f, -0.00359888f, 0.01395198f, 
    0.04896797f, 0.00731626f, -0.05769288f, -0.04077543f, 0.05057685f, -0.04142186f, 0.02829592f, -0.01873740f, 
    -0.06156843f, -0.04444776f, -0.06033330f, -0.03378366f, 0.01436529f, 0.04872000f, 0.00596560f, 0.04552783f, 
    -0.04387438f, -0.03980654f, 0.04651661f, -0.01591155f, 0.02851893f, -0.00554818f, 0.03933623f, -0.04006202f, 
    0.04763262f, 0.00576136f, 0.00811542f, 0.03878890f, 0.01343061f, -0.05604141f, -0.05889476f, -0.05856109f, 
    0.04593046f, -0.04765148f, -0.03813953f, -0.05404792f, -0.05518467f, -0.05689923f, 0.04650329f, -0.01787550f, 
    -0.02662291f, 0.01464076f, 0.02352135f, 0.03289552f, 0.02832550f, -0.03583299f, 0.04659619f, 0.00293268f, 
    -0.02208877f, 0.03483587f, 0.04605375f, -0.01098766f, 0.00551643f, -0.05822041f, -0.04740190f, -0.05952701f, 
    -0.00250024f, -0.05670402f, 0.02917759f, 0.01696762f, -0.01625852f, -0.04357137f, -0.05075514f, -0.00097621f, 
    0.02913366f, 0.04470066f, -0.03629366f, -0.05456180f, -0.05674445f, 0.03246020f, -0.06341206f, -0.03358413f, 
    0.04523217f, 0.00309702f, 0.00047484f, -0.05752458f, -0.00442915f, 0.01612741f, -0.06020062f, 0.01152392f, 
    -0.01811556f, 0.02184473f, -0.06209505f, -0.00497852f, -0.02787127f, -0.03348557f, -0.04245440f, 0.03889989f, 
    0.03161580f, -0.05677736f, -0.01092256f, -0.01359680f, 0.03035911f, -0.00394547f, -0.04234240f, -0.03703576f, 
    -0.03638765f, -0.00481622f, -0.01078147f, -0.02926859f, -0.05826230f, -0.00819630f, 0.00185743f, -0.03823531f, 
    -0.03906142f, -0.05417454f, 0.02749237f, 0.03102420f, -0.00605288f, 0.01546246f, 0.01098018f, 0.03355489f, 
    0.04008477f, 0.03930400f, 0.02267710f, -0.03214873f, 0.01186122f, -0.05653454f, 0.04064061f, 0.03933749f, 
    -0.06459104f, 0.01916661f, -0.04720856f, -0.02607527f, 0.03661073f, 0.00437796f, -0.01252946f, 0.02892265f, 
    -0.04035366f, -0.02200198f, 0.04155661f, 0.03679891f, -0.04864776f, 0.02735601f, 0.01625968f, -0.00079283f, 
    -0.02656806f, 0.01417704f, 0.03007182f, 0.05092017f, -0.01345515f, 0.05607421f, -0.04789802f, -0.06224293f, 
    0.03910099f, -0.00124721f, 0.01466836f, -0.03902693f, 0.02830421f, 0.02240489f, -0.03931035f, 0.02205360f, 
    -0.06255162f, 0.00754976f, 0.05233558f, 0.02347835f, -0.03845834f, -0.05609604f, 0.03845301f, -0.04530136f, 
    -0.06068202f, -0.02686850f, -0.00959009f, -0.02767905f, -0.01137082f, 0.00039507f, -0.01460539f, 0.01690861f, 
    0.01286437f, -0.03151379f, 0.04072907f, -0.06180917f, -0.02481797f, 0.02830031f, 0.02699394f, -0.03396865f, 
    -0.01610282f, 0.01316802f, -0.01117931f, 0.02762117f, -0.01230171f, 0.01787240f, -0.01001472f, -0.02390900f, 
    -0.04688672f, -0.01209652f, -0.03138573f, -0.05080982f, -0.02582559f, 0.02876856f, 0.02816174f, -0.04456006f, 
    -0.04892062f, 0.00660429f, 0.00690553f, 0.04392111f, -0.04586510f, -0.00640995f, 0.03608296f, -0.05074579f, 
    -0.04099168f, 0.01548558f, -0.04488742f, -0.02054176f, 0.00850847f, 0.03535693f, 0.02570532f, 0.02656112f, 
    -0.00841953f, 0.00256025f, -0.03607675f, -0.05629900f, -0.06388601f, -0.03433981f, -0.05936426f, -0.02917274f, 
    -0.02545361f, -0.01823452f, 0.02120601f, 0.04713437f, 0.02261906f, 0.02289185f, -0.00290301f, 0.04080518f, 
    -0.03165292f, -0.04403544f, 0.06087133f, -0.14480367f, -0.03464328f, 0.17908569f, 0.02711341f, 0.12226284f, 
    0.06278933f, -0.11316390f, -0.03242652f, -0.12618200f, 0.02742871f, 0.06259834f, -0.02443689f, 0.09237311f, 
    0.12044492f, -0.01972372f, 0.02993646f, 0.12275600f, 0.06357526f, -0.04661837f, 0.10964588f, -0.02864535f, 
    -0.03151701f, 0.08085111f, 0.08834936f, -0.26848340f, 0.27524436f, 0.18208334f, -0.01492116f, -0.14219822f, 
    -0.06267334f, 0.00067891f, 0.01094968f, 0.11003438f, -0.30208153f, -0.25674304f, -0.23084655f, 0.06639507f, 
    0.07743671f, 0.15399648f, 0.11872199f, 0.04224050f, -0.16005594f, -0.00958606f, 0.12984288f, 0.04301016f, 
    -0.06632710f, -0.07039294f, -0.10010473f, -0.03571179f, -0.13517512f, -0.04352131f, 0.02522225f, -0.04092280f, 
    0.17888673f, 0.03778117f, 0.02654373f, -0.03145064f, -0.03086443f, 0.01285062f, 0.11424258f, 0.17958021f, 
    0.17329633f, -0.21801038f, -0.02050507f, 0.03767386f, -0.05984770f, 0.07828221f, 0.12284198f, 0.20163092f, 
    -0.39865035f, -0.02364619f, -0.17426306f, -0.13281645f, -0.10119339f, 0.07395189f, -0.10146352f, -0.02562541f, 
    0.06278936f, 0.08102602f, 0.10029291f, 0.07023168f, -0.04392820f, 0.11632159f, 0.01256390f, -0.03212460f, 
    -0.05947980f, -0.02837945f, 0.08328693f, 0.22164163f, -0.06614574f, 0.06927789f, -0.06723692f, 0.13426377f, 
    -0.00237613f, 0.11102945f, 0.13756600f, 0.27303723f, 0.20512214f, -0.14425123f, -0.02810870f, 0.10356641f, 
    0.12336217f, -0.02040575f, -0.12521072f, -0.09612911f, -0.01780318f, -0.00746884f, 0.11982732f, 0.06478917f, 
    -0.10986468f, 0.04919539f, -0.03220171f, 0.15968512f, -0.13522801f, 0.25463364f, -0.08980235f, -0.21835858f, 
    0.01890003f, 0.11757690f, 0.02897962f, -0.15397395f, -0.06436419f, -0.05125643f, -0.06203338f, -0.00208073f, 
    0.30540979f, 0.01433164f, -0.07507773f, -0.04234222f, 0.09303286f, 0.07203359f, 0.16892505f, 0.22395669f, 
    -0.10806070f, -0.11698771f, -0.09053598f, -0.02477763f, 0.00346612f, -0.00697945f, -0.04476279f, -0.06952113f, 
    0.03041733f, 0.12511167f, -0.36392280f, -0.09021568f, -0.09198460f, -0.04128550f, -0.02898573f, 0.01061553f, 
    -0.04035462f, -0.05944038f, 0.03680621f, 0.12794468f, 0.01066914f, -0.01921914f, -0.01464795f, -0.01391881f, 
    -0.04136113f, -0.03633896f, -0.10023571f, -0.09298693f, 0.16529809f, -0.19758236f, -0.01712864f, 0.11181352f, 
    0.01406016f, 0.06204437f, -0.01311446f, -0.05538969f, 0.01685367f, -0.24926147f, -0.02798178f, 0.00195064f, 
    -0.03520179f, 0.00176566f, 0.09830740f, 0.18555105f, -0.07377563f, -0.00283833f, -0.01911607f, 0.03442682f, 
    -0.10529135f, 0.03093595f, -0.09733348f, 0.10419731f, 0.03259752f, -0.13777843f, 0.14122100f, 0.13832118f, 
    -0.12494231f, -0.14510545f, -0.01206576f, 0.02797304f, 0.02546477f, 0.09102634f, 0.02750679f, 0.16468030f, 
    0.03471069f, 0.09177162f, -0.13864970f, -0.20522529f, -0.00042819f, 0.17169163f, 0.07253077f, -0.12858711f, 
    -0.13556749f, 0.05343631f, 0.07827080f, -0.08068110f, 0.01653140f, -0.00010496f, -0.01445223f, -0.10588502f, 
    0.05786393f, 0.17887390f, -0.07741617f, 0.03090627f, -0.10285182f, -0.13765177f, -0.06920487f, -0.09700852f, 
    0.03666680f, -0.08168542f, -0.01905594f, 0.07531287f, -0.16516349f, -0.00682084f, 0.07292440f, 0.00103177f, 
    0.11465096f, -0.00434347f, 0.18367542f, 0.00872644f, -0.08393713f, -0.06593873f, 0.05709488f, 0.04149815f, 
    0.03368240f, -0.06818979f, -0.07335415f, 0.15999252f, -0.07648282f, -0.05969467f, -0.06047853f, -0.05641649f, 
    -0.06341226f, 0.07754229f, 0.04276318f, -0.11821444f, 0.11913504f, 0.11630119f, 0.14386027f, -0.03099427f, 
    -0.06759119f, 0.10212753f, 0.06859924f, 0.04077720f, 0.13295245f, -0.14843671f, 0.07944366f, 0.06074883f, 
    0.09910153f, 0.06626117f, 0.06986260f, 0.11271150f, 0.02258662f, -0.13732724f, -0.11223464f, 0.08003657f, 
    0.29012474f, 0.04532689f, -0.00929332f, -0.05681581f, -0.08013818f, -0.05690239f, -0.03280924f, 0.05690314f, 
    -0.05087363f, -0.31395078f, -0.00478712f, 0.09446915f, 0.00771712f, -0.01148738f, 0.08524258f, -0.05708071f, 
    -0.13867202f, 0.20403554f, -0.05798922f, 0.03696642f, -0.12127711f, -0.02252478f, 0.06877875f, -0.30173311f, 
    -0.28464469f, -0.45192969f, 0.14763823f, 0.10740136f, 0.24242590f, 0.02085837f, -0.06359465f, -0.06491181f, 
    0.04057338f, -0.02153426f, 0.21802561f, 0.08893240f, 0.16087720f, 0.11397203f, -0.01732764f, 0.10826793f, 
    -0.04579780f, 0.04834879f, 0.00452740f, -0.10396193f, 0.17881422f, -0.35608226f, -0.08437164f, -0.03800465f, 
    0.10205535f, 0.00070780f, 0.09298544f, -0.10094871f, -0.21166117f, -0.04903780f, 0.09517089f, -0.01393761f, 
    0.05425605f, 0.05304635f, -0.12371755f, 0.08147497f, -0.01316907f, 0.15918648f, 0.08594674f, -0.08222001f, 
    -0.04696757f, -0.08242689f, 0.01182644f, -0.01864905f, -0.06508974f, -0.03078707f, 0.13280931f, 0.09332621f, 
    0.02642810f, 0.07457976f, 0.03684746f, -0.02772110f, 0.06090495f, 0.00948571f, 0.04067708f, 0.05235780f, 
    0.04124524f, 0.12398980f, -0.01717986f, 0.05540079f, 0.12712872f, 0.08760401f, -0.00676200f, -0.16297461f, 
    -0.20836923f, 0.28488138f, -0.08276687f, -0.04333808f, 0.12364526f, -0.05944173f, -0.01244058f, 0.03638365f, 
    -0.10270814f, 0.24012828f, -0.00270587f, -0.17110918f, -0.03003197f, 0.04366172f, -0.11833399f, 0.20465164f, 
    -0.00269518f, 0.01599666f, 0.31375277f, -0.02640836f, 0.25520000f, 0.07833049f, 0.04085168f, 0.07958266f, 
    -0.01452271f, -0.11762225f, -0.09635814f, 0.13899033f, -0.09582210f, -0.02789339f, -0.00688939f, -0.26896220f, 
    -0.18154247f, 0.00999542f, 0.06486277f, -0.00844176f, 0.25219944f, 0.05289148f, -0.05632258f, -0.01156355f, 
    -0.06712994f, -0.06796355f, 0.04135441f, 0.12633717f, 0.19981654f, 0.05829157f, -0.05296941f, 0.14078602f, 
    0.14127232f, 0.08020707f, 0.00349283f, -0.00831700f, -0.06590430f, 0.00003871f, 0.01458339f, -0.01377709f, 
    -0.05357151f, 0.09549542f, -0.02078898f, 0.12446405f, 0.03125398f, 0.06903107f, 0.06922996f, 0.18427989f, 
    0.22125581f, -0.04255426f, -0.08364231f, -0.04884311f, 0.05833276f, 0.11011961f, 0.04161378f, 0.01621749f, 
    0.47567368f, 0.23350102f, 0.14344227f, 0.01820456f, -0.07055462f, -0.18351179f, 0.19649322f, 0.13352270f, 
    0.05530107f, -0.23514259f, -0.17147198f, -0.28764421f, 0.11552873f, 0.03189733f, -0.03800927f, 0.00935771f, 
    0.12001338f, 0.06550595f, -0.13314345f, 0.17386577f, -0.09577328f, -0.09864194f, -0.02857421f, 0.06999724f, 
    -0.01983865f, -0.02304689f, -0.21986626f, 0.06249606f, -0.00407513f, -0.08644258f, -0.10753579f, -0.06432589f, 
    0.04378043f, -0.09222099f, 0.00208222f, -0.08818929f, -0.26487502f, 0.09457771f, -0.05876219f, 0.24317269f, 
    0.01391515f, -0.00428754f, -0.01157489f, 0.02335303f, -0.00950993f, 0.03851545f, 0.02524169f, -0.00757913f, 
    0.00857355f, 0.01525940f, 0.08952794f, 0.06584673f, -0.05544849f, 0.03535604f, 0.10156050f, 0.01010596f, 
    -0.01501707f, 0.02383342f, -0.00687919f, -0.07986852f, 0.11643039f, 0.15265682f, 0.00643141f, -0.34922552f, 
    0.15795358f, -0.22377832f, -0.09759615f, -0.21957219f, 0.04833491f, 0.16842444f, 0.10455651f, 0.08425725f, 
    -0.04330054f, -0.05142435f, -0.42876402f, -0.01703596f, -0.02640587f, -0.00333787f, 0.27180499f, 0.13981368f, 
    0.07558138f, -0.12510803f, 0.12034222f, -0.21810600f, 0.13234131f, -0.01557428f, 0.02067817f, 0.15189709f, 
    0.13197836f, -0.14736697f, 0.09678908f, -0.06787050f, 0.13006283f, -0.03782808f, -0.13751283f, 0.11635834f, 
    0.07623270f, 0.10826432f, 0.05864517f, -0.05553009f, 0.18626605f, 0.00894928f, 0.02737555f, -0.00051478f, 
    0.16403225f, 0.11908492f, 0.09744678f, 0.03178354f, 0.16724195f, 0.03988800f, 0.05755521f, -0.06443883f, 
    0.04412849f, 0.18472791f, 0.02646581f, -0.10785387f, -0.06668527f, -0.17241666f, 0.02211969f, -0.26150686f, 
    -0.14407307f, 0.01803531f, 0.02137620f, -0.04892100f, -0.01271756f, 0.18978024f, 0.04503567f, -0.25674447f, 
    -0.29692531f, 0.14041273f, -0.03859875f, 0.02571998f, 0.10519148f, 0.03432696f, 0.15965252f, 0.06720738f, 
    -0.03367996f, 0.01457967f, 0.18220571f, 0.02484204f, 0.02793031f, 0.22712937f, 0.08138981f, 0.00010596f, 
    0.12926678f, -0.26850632f, -0.02248600f, -0.00646288f, -0.07248417f, -0.10385608f, -0.09812379f, 0.02579492f, 
    -0.26103267f, -0.07308860f, -0.15709096f, -0.01437360f, 0.04227845f, 0.11503831f, -0.11203045f, -0.11383802f, 
    0.11966141f, -0.10002130f, 0.21274272f, 0.21810296f, 0.20099725f, 0.09254856f, 0.06013587f, -0.08682121f, 
    0.05235655f, -0.07275327f, -0.14715452f, -0.11989257f, -0.07958413f, -0.19775340f, 0.07988275f, -0.14699031f, 
    0.03087937f, -0.08077840f, 0.10038160f, 0.07193951f, -0.15106304f, -0.05046398f, -0.53350830f, -0.22321720f, 
    -0.06935575f, 0.07041695f, -0.02609280f, 0.06440670f, 0.05136509f, 0.08993021f, -0.29005018f, -0.35164821f, 
    0.02300723f, 0.17253841f, 0.14806445f, 0.13561006f, 0.11975802f, 0.07670099f, 0.13307177f, -0.10053750f, 
    -0.00726305f, 0.16553645f, -0.08990213f, 0.11808683f, 0.02324443f, 0.10923564f, -0.08015214f, 0.01054551f, 
    0.01459960f, 0.17425634f, 0.11112114f, 0.11555454f, -0.00779433f, -0.05190999f, -0.14462031f, -0.23145503f, 
    -0.02241511f, 0.01145441f, -0.35029665f, 0.02036235f, -0.00553627f, -0.01695865f, 0.14471018f, 0.06181978f, 
    0.11704846f, -0.08252253f, 0.01474090f, 0.26383114f, 0.06837307f, 0.01441719f, -0.00409139f, 0.05135580f, 
    -0.04073421f, -0.00444684f, 0.21283056f, 0.17231739f, 0.28247991f, 0.11431473f, 0.01734382f, 0.02935844f, 
    -0.08026504f, -0.22141126f, -0.03459881f, -0.04682641f, 0.13518813f, 0.12550291f, -0.03182806f, 0.09555197f, 
    0.05298757f, -0.00552948f, -0.06283940f, -0.02249917f, -0.30283007f, -0.44732231f, -0.16879885f, 0.18406242f, 
    0.03170048f, 0.11816167f, 0.05961614f, 0.01881247f, -0.09109955f, 0.02612917f, -0.06005409f, 0.07008070f, 
    0.07529180f, 0.09851436f, 0.12789346f, 0.12822445f, 0.05383933f, 0.09598967f, -0.07492807f, -0.11184625f, 
    -0.13057069f, 0.01414456f, 0.05583680f, -0.06086877f, 0.01307804f, 0.10458743f, 0.03281910f, -0.12283591f, 
    -0.04398769f, -0.12537368f, 0.06326355f, -0.06691824f, -0.07174743f, 0.15702134f, 0.00474407f, 0.16660391f, 
    -0.02006329f, 0.03972708f, 0.14752911f, -0.04422873f, -0.03730344f, 0.00304457f, 0.00290074f, 0.00640616f, 
    -0.05710080f, 0.08343878f, -0.19672091f, -0.24583070f, 0.07853349f, 0.06136452f, -0.07514590f, 0.00970796f, 
    0.05196320f, 0.10390475f, 0.02719330f, -0.12447371f, -0.02408030f, -0.10535109f, -0.12313058f, 0.02880176f, 
    0.06669130f, -0.03637427f, 0.00826290f, -0.06144537f, 0.02575815f, 0.03544373f, 0.02352626f, 0.07791968f, 
    -0.01461356f, -0.01365894f, -0.03103584f, -0.06316540f, -0.00190534f, -0.20114160f, -0.08474347f, -0.05021241f, 
    0.00916595f, -0.03924457f, -0.00011288f, 0.01187731f, 0.00770157f, 0.05489703f, 0.08400045f, -0.05849539f, 
    0.08455370f, 0.04182123f, -0.04380509f, 0.15013750f, -0.07698029f, -0.04311827f, 0.16657248f, -0.24899383f, 
    -0.48930204f, 0.12267752f, 0.03667246f, 0.11086006f, -0.10071039f, 0.15145712f, 0.00042474f, 0.11505156f, 
    -0.18685174f, -0.33078256f, 0.04067226f, -0.01789945f, -0.06787138f, 0.12309390f, -0.00396355f, -0.01572834f, 
    0.13607730f, -0.13212688f, -0.35845697f, 0.09655369f, -0.07054503f, -0.27377906f, 0.11191657f, 0.21443239f, 
    -0.08363216f, -0.02607022f, 0.07632512f, 0.11081539f, 0.04549247f, -0.07051815f, 0.07971779f, 0.00710841f, 
    0.06971806f, 0.05640968f, -0.05824598f, 0.03269372f, 0.02004679f, 0.11836376f, 0.04966061f, 0.19944865f, 
    0.06897295f, 0.04403020f, 0.03825925f, -0.03545367f, -0.03267189f, -0.02745406f, 0.05845682f, 0.05902110f, 
    -0.06995708f, -0.00085018f, 0.12430639f, 0.08513904f, 0.27127162f, 0.22463939f, 0.31463522f, -0.03406255f, 
    -0.09239469f, -0.04424585f, 0.01522116f, 0.01471150f, -0.13131243f, -0.20772409f, -0.10913029f, -0.21609013f, 
    0.12334923f, 0.07021517f, -0.02695269f, 0.22015095f, -0.01966866f, -0.04599673f, -0.01445790f, -0.11339932f, 
    -0.18647614f, -0.02248922f, -0.11966846f, -0.18805839f, -0.10408001f, 0.11760935f, 0.03543675f, 0.28947443f, 
    0.04395602f, 0.15952083f, 0.00414278f, 0.16808376f, 0.04412089f, 0.08590667f, 0.01410031f, -0.04890550f, 
    0.00567093f, -0.01491304f, 0.01336790f, -0.06223748f, 0.02103667f, 0.00453928f, -0.03443829f, 0.01332137f, 
    -0.03927297f, 0.03632811f, 0.01630779f, -0.02685540f, -0.00227621f, -0.06528565f, -0.02739825f, 0.01625406f, 
    0.00241544f, 0.02890499f, -0.02770463f, 0.00679912f, 0.02227325f, -0.06110873f, 0.03367123f, 0.05095103f, 
    -0.05833440f, -0.02181437f, -0.00695194f, -0.04671879f, 0.00629183f, -0.01613714f, -0.04683901f, -0.05235133f, 
    -0.01237587f, -0.06484472f, -0.00754590f, -0.05831204f, 0.01197752f, -0.01321476f, 0.01093158f, -0.04781485f, 
    0.02493216f, 0.02483951f, -0.03448958f, 0.03969843f, -0.05745175f, -0.01662122f, -0.01726509f, 0.02899398f, 
    -0.00509101f, -0.02272932f, -0.03125121f, -0.00505390f, 0.03835676f, 0.03206158f, -0.01746198f, -0.03246855f, 
    -0.03352886f, -0.00130373f, 0.01835429f, -0.00479675f, 0.04796848f, -0.05098390f, -0.00546562f, -0.01200852f, 
    0.01085722f, 0.00986937f, 0.03855551f, 0.01091678f, 0.03188660f, -0.06495728f, 0.00631549f, 0.05444630f, 
    -0.04484828f, -0.05327466f, 0.00406641f, -0.04545817f, 0.00212954f, 0.04019938f, -0.01147113f, -0.03290218f, 
    0.02230876f, -0.04299303f, 0.03828829f, -0.06210876f, 0.03082078f, -0.06260462f, 0.03018160f, -0.02896556f, 
    0.03633988f, 0.00184597f, -0.00476793f, -0.05938783f, -0.04150343f, -0.06341537f, 0.01115376f, -0.03856741f, 
    -0.00407300f, 0.04385817f, 0.03345716f, -0.01408388f, -0.01426827f, -0.02527050f, 0.03629719f, -0.02655185f, 
    -0.06336245f, 0.00708976f, 0.00196826f, -0.00770367f, -0.02354183f, -0.02568368f, 0.03456416f, -0.06260907f, 
    -0.04864646f, -0.03067299f, -0.04927606f, 0.02062061f, -0.04372059f, -0.02120517f, 0.05034583f, -0.06642546f, 
    -0.00567365f, -0.03128955f, -0.01670867f, -0.05423714f, 0.02591993f, -0.06513024f, -0.04087470f, -0.05551676f, 
    0.00675719f, -0.00671859f, -0.01287638f, -0.00629985f, 0.04766825f, -0.04545166f, 0.01006207f, -0.05950277f, 
    -0.01676006f, -0.01910646f, 0.02314254f, 0.00275581f, -0.00104544f, -0.00767281f, 0.05751870f, -0.00287895f, 
    -0.00070932f, -0.04191249f, 0.00290715f, -0.01962511f, -0.03582763f, -0.00224024f, 0.01011629f, -0.04974093f, 
    0.01562954f, -0.01515650f, 0.04114319f, -0.06748448f, 0.00994050f, 0.03244271f, -0.00517874f, -0.02426429f, 
    -0.01188611f, -0.05611474f, -0.04461025f, -0.05454089f, -0.00399004f, 0.02817130f, -0.03772359f, 0.03124134f, 
    -0.02369236f, 0.00029153f, -0.04081215f, -0.03101085f, 0.04689700f, -0.02656511f, 0.01474703f, -0.00487969f, 
    -0.05142111f, -0.05195792f, -0.00617172f, 0.04055050f, -0.02161215f, 0.03358199f, 0.02055368f, -0.04493373f, 
    -0.05933352f, -0.00321282f, -0.06911249f, -0.06153912f, 0.01155817f, -0.03271523f, -0.04602612f, 0.00423255f, 
    0.02569723f, 0.03312211f, -0.05245867f, 0.00103305f, 0.02825378f, -0.00502497f, 0.03298859f, -0.05521355f, 
    -0.05261803f, 0.01817412f, -0.00314467f, -0.02231481f, -0.03262305f, -0.04916325f, -0.01807208f, -0.03537400f, 
    0.01484973f, -0.06027222f, -0.00095412f, 0.01840392f, 0.04507374f, -0.03037302f, -0.03100600f, 0.01596996f, 
    0.00993064f, 0.00006460f, -0.04435243f, 0.03894832f, -0.05299777f, -0.02898642f, 0.04012692f, 0.01712799f, 
    -0.04468511f, -0.00545545f, 0.04398702f, 0.03396199f, -0.02904585f, 0.00948763f, -0.00183732f, 0.01128517f, 
    0.03444789f, 0.00957312f, -0.00535738f, 0.00932710f, 0.00162023f, -0.02203163f, -0.02909431f, 0.04421255f, 
    -0.00645029f, 0.02680668f, -0.05504368f, -0.04247731f, -0.03645409f, 0.00678748f, -0.02708626f, 0.03060366f, 
    -0.01648307f, 0.03396211f, 0.04574087f, -0.06944237f, 0.00574165f, -0.00818025f, -0.02494024f, 0.04220512f, 
    -0.05214400f, 0.03138189f, 0.03800534f, 0.03211022f, -0.03290470f, 0.00704799f, -0.00018154f, 0.01189123f, 
    -0.01973199f, 0.03035770f, 0.00302516f, -0.05070744f, 0.04563984f, 0.04432620f, -0.02715361f, 0.03185580f, 
    0.03283221f, 0.03528724f, -0.04371836f, -0.02024798f, 0.03176390f, -0.00612254f, -0.00271312f, 0.01299938f, 
    0.03953828f, -0.05271765f, 0.01060819f, -0.06912257f, -0.06323987f, 0.04105370f, -0.02192416f, -0.02238972f, 
    -0.20692705f, -0.04043419f, -0.23958312f, 0.00131357f, 0.13769469f, -0.02680104f, 0.14753890f, -0.09119387f, 
    -0.03366113f, -0.08592755f, -0.14389448f, 0.06743738f, 0.01512570f, -0.08699148f, -0.00145959f, 0.09859733f, 
    -0.13334110f, 0.01712002f, 0.00127136f, 0.29716170f, 0.22201563f, -0.02008928f, 0.01400231f, 0.02067681f, 
    0.01000914f, -0.07857852f, 0.07215011f, -0.21032165f, -0.31180030f, -0.26490220f, -0.12852457f, -0.00661865f, 
    0.03134304f, 0.10001480f, 0.04245817f, 0.01865097f, -0.08585578f, -0.38920578f, -0.04318272f, -0.21834548f, 
    -0.31411064f, 0.23815230f, -0.14463939f, 0.12030239f, 0.10928480f, 0.11997558f, 0.12636873f, 0.16318259f, 
    0.01008007f, -0.09609911f, 0.00437817f, 0.15466335f, 0.01253129f, 0.05402552f, -0.12173404f, 0.11185271f, 
    0.09320880f, -0.03732291f, 0.02758780f, -0.00524974f, 0.05116161f, 0.04925460f, 0.05170127f, 0.06362702f, 
    -0.03335651f, 0.23206224f, -0.01657651f, 0.01910748f, 0.07730487f, -0.05631686f, -0.07857734f, 0.15513216f, 
    0.11792304f, -0.31017134f, -0.58289665f, 0.06128024f, 0.01253716f, 0.10429768f, 0.05498531f, 0.09042334f, 
    0.06541632f, -0.11370812f, 0.02518995f, -0.06270310f, -0.03797700f, 0.04093182f, 0.01577138f, 0.02588076f, 
    0.16833405f, 0.06093898f, -0.03825083f, 0.12552279f, 0.28667119f, 0.06707609f, -0.01316756f, -0.01336237f, 
    -0.11374339f, 0.00692054f, 0.05825600f, -0.02323119f, -0.02529425f, 0.15286523f, -0.06712886f, 0.01626853f, 
    0.00272588f, 0.06446214f, 0.07929021f, 0.07067089f, -0.66957361f, -0.32398459f, 0.33353999f, -0.08758506f, 
    -0.14983568f, -0.08137270f, 0.17807427f, -0.01208370f, -0.02494958f, -0.00585077f, -0.17750764f, 0.32823583f, 
    0.04679555f, -0.01228871f, -0.17030886f, 0.02008751f, 0.12752917f, 0.04624307f, -0.30135009f, 0.02546583f, 
    -0.05279781f, 0.05191184f, 0.13290744f, 0.05491456f, -0.01376724f, 0.00056986f, 0.08724896f, -0.00362241f, 
    -0.20104414f, -0.15431982f, -0.16054174f, -0.00207393f, -0.11956192f, 0.02214695f, 0.02503789f, 0.14899789f, 
    -0.06771872f, -0.29959583f, -0.23646919f, 0.06088322f, -0.11923911f, -0.05081776f, -0.03799677f, 0.03600865f, 
    -0.07554667f, -0.07348899f, -0.00097416f, -0.13195196f, 0.09286219f, 0.05885163f, -0.02308805f, -0.03864276f, 
    -0.02056620f, -0.04555627f, 0.03857044f, 0.03358546f, -0.12480114f, 0.10782742f, 0.08969713f, 0.05878797f, 
    -0.06565729f, 0.05856751f, -0.12529683f, -0.03231742f, -0.15696019f, 0.24108976f, 0.01760591f, -0.01131923f, 
    0.04663071f, 0.11545232f, 0.04361452f, 0.11031120f, 0.12938248f, -0.49792644f, -0.01381371f, 0.07504662f, 
    0.00782497f, 0.07562510f, 0.07248764f, -0.00916986f, 0.02601288f, 0.27012441f, -0.19022013f, -0.27244642f, 
    -0.17172733f, 0.09556272f, 0.01490996f, 0.10897665f, 0.02826436f, -0.16717760f, -0.00937643f, 0.02761699f, 
    0.06342352f, -0.08813334f, -0.08647104f, -0.05918144f, 0.08586162f, -0.10869308f, -0.08878802f, -0.07091588f, 
    -0.25858063f, -0.27429515f, 0.08771885f, -0.02829204f, 0.01075909f, -0.02644287f, 0.15129071f, -0.02343264f, 
    -0.62605429f, -0.48791578f, -0.06287918f, 0.04349077f, -0.11132471f, -0.09300976f, -0.02038908f, -0.11132449f, 
    0.07427832f, -0.19277346f, -0.41793972f, -0.33395889f, 0.04121095f, -0.06406204f, -0.07165701f, 0.02232649f, 
    -0.17405246f, 0.02891839f, -0.16785128f, -0.03793746f, 0.04062539f, 0.14996353f, 0.09079178f, 0.08497647f, 
    0.03621124f, 0.08179645f, -0.03474969f, -0.00936471f, -0.07170201f, 0.11782365f, 0.13339709f, 0.03652332f, 
    0.01683526f, 0.03822256f, 0.00510905f, -0.03080938f, -0.04390774f, 0.10941228f, -0.08207522f, -0.09698750f, 
    -0.11964619f, 0.09407073f, 0.20343460f, 0.08152445f, 0.01618903f, 0.08832534f, 0.01671645f, 0.39522687f, 
    -0.00165713f, -0.11820944f, -0.00181241f, 0.05462390f, -0.01818299f, 0.17909397f, -0.46865660f, -0.39273417f, 
    -0.21638307f, -0.15165007f, -0.07985733f, -0.04567358f, 0.08708093f, -0.00469398f, 0.07368656f, 0.21850127f, 
    -0.06940033f, 0.02331033f, 0.05157750f, 0.10552480f, 0.14596820f, -0.01892375f, 0.09558188f, 0.07788470f, 
    -0.15007144f, 0.13041086f, -0.13348454f, -0.03383718f, -0.03268290f, 0.15954040f, -0.15681051f, -0.02974255f, 
    -0.07095464f, -0.16940738f, -0.04555181f, 0.27771538f, 0.06442194f, 0.10009302f, 0.03414709f, 0.01653622f, 
    0.05281514f, -0.08947084f, -0.31819037f, -0.21622436f, -0.22610743f, -0.12850915f, 0.00517841f, -0.04629982f, 
    0.04594475f, 0.00607491f, 0.12505744f, 0.11029959f, 0.02935228f, -0.09274664f, 0.00131830f, 0.08288255f, 
    -0.17037372f, -0.11108173f, 0.02545796f, 0.08114078f, -0.34167063f, -0.28655234f, -0.30793095f, 0.04757993f, 
    0.01363069f, 0.17193885f, 0.03637572f, -0.12864257f, -0.14006424f, 0.26957911f, 0.27237847f, -0.11355852f, 
    -0.07450821f, -0.06957893f, -0.03946504f, 0.05721811f, -0.04563553f, -0.02016087f, -0.00466645f, -0.30285642f, 
    -0.11380476f, 0.12108190f, 0.13448551f, 0.06458136f, 0.11065560f, 0.01894441f, 0.02611335f, -0.28764996f, 
    -0.19311057f, 0.11166617f, 0.10346150f, 0.04423296f, -0.19387658f, -0.13956660f, 0.07364321f, 0.00256777f, 
    0.00745799f, 0.11611244f, -0.06532311f, 0.03095497f, -0.01123913f, -0.03681516f, -0.05083545f, 0.06528013f, 
    -0.05553124f, 0.11618752f, -0.24144526f, -0.21372870f, -0.23649074f, -0.07555085f, 0.08214729f, 0.11416424f, 
    0.01612098f, 0.15682124f, -0.49673089f, 0.08622586f, 0.09881335f, 0.08140646f, -0.20605099f, -0.05321405f, 
    -0.18455850f, 0.00572657f, 0.01929729f, 0.23309930f, -0.42876351f, -0.48428339f, -0.26156852f, 0.05772517f, 
    -0.07801777f, 0.10811581f, -0.13355033f, 0.02910559f, 0.07928147f, -0.12296380f, 0.19666333f, 0.12420879f, 
    -0.10320237f, -0.14251550f, 0.11076047f, -0.19835679f, -0.03324367f, -0.32147062f, -0.53403264f, -0.01156198f, 
    -0.06097281f, 0.17938402f, 0.00139973f, -0.05964825f, 0.11157449f, -0.03890286f, 0.18035404f, 0.09344769f, 
    0.00329315f, 0.08454727f, 0.14301583f, 0.10369813f, 0.11518104f, -0.03536084f, -0.06872547f, -0.27403036f, 
    -0.10118112f, 0.01582501f, 0.13110293f, 0.03441103f, 0.02830806f, -0.07055077f, -0.00814406f, 0.03541531f, 
    -0.12507549f, 0.18625766f, -0.28733945f, -0.26585320f, -0.10936426f, -0.12502757f, 0.10917701f, -0.16586393f, 
    0.14565110f, 0.28414863f, 0.04828011f, -0.07057467f, -0.00578041f, 0.05450169f, 0.00209860f, -0.01814137f, 
    -0.00105660f, -0.05776003f, 0.33082002f, 0.10493912f, -0.19629833f, 0.10088965f, 0.08705416f, -0.08946224f, 
    0.08201382f, -0.07162280f, 0.04174907f, -0.33475658f, 0.05281654f, 0.21810508f, 0.03241868f, -0.02823364f, 
    -0.03571225f, -0.01034281f, 0.14523022f, 0.00944889f, 0.08076766f, 0.13623306f, -0.02739977f, -0.09055539f, 
    0.01377636f, -0.08126066f, 0.06431449f, -0.03938400f, 0.05168062f, -0.02983627f, 0.24637966f, 0.02182824f, 
    -0.10996392f, -0.08492512f, -0.08786367f, 0.19663969f, -0.00468561f, -0.14140460f, 0.18957242f, 0.13277556f, 
    -0.11232863f, 0.20147556f, -0.10239980f, -0.10368831f, -0.02653430f, 0.08444061f, -0.11911558f, -0.20120806f, 
    0.06153557f, 0.05177033f, -0.02359567f, 0.06788927f, 0.08378480f, 0.02252004f, -0.06971756f, 0.20645551f, 
    0.25521314f, -0.08799288f, -0.03422596f, -0.00375031f, -0.07042533f, -0.11384832f, 0.18915306f, -0.01744787f, 
    0.12345006f, 0.03692499f, -0.01661414f, -0.18332432f, -0.04950618f, -0.05621470f, -0.01324435f, 0.00981053f, 
    0.19422014f, 0.07212362f, -0.44996807f, -0.16884600f, -0.05525658f, -0.00906104f, 0.02567058f, -0.00643835f, 
    0.09376287f, 0.04041541f, 0.07738765f, -0.32092860f, 0.05690878f, 0.07008793f, 0.10091998f, 0.09489654f, 
    0.07288836f, 0.02636648f, 0.07853393f, 0.14287776f, -0.38084191f, -0.32304046f, -0.08060703f, -0.05484822f, 
    0.06801158f, 0.01119270f, 0.03114433f, -0.01494751f, 0.01359343f, -0.09151549f, 0.23688364f, 0.08654787f, 
    -0.15703386f, 0.01177331f, -0.10932804f, -0.17734677f, 0.19539608f, 0.03585898f, 0.31107864f, 0.11490545f, 
    -0.07425278f, -0.04754750f, 0.00368489f, 0.03975654f, -0.10359747f, 0.02952425f, -0.13503368f, -0.22497395f, 
    -0.03598733f, -0.00262387f, 0.06322703f, 0.04771680f, -0.05754869f, 0.16063678f, 0.06644680f, 0.01185202f, 
    -0.09074685f, -0.04325251f, 0.07203048f, 0.10635139f, -0.18206689f, -0.07874643f, 0.07413977f, 0.17614645f, 
    0.08125612f, -0.53205311f, 0.04490396f, -0.08395195f, -0.05089269f, -0.01572415f, -0.02272056f, 0.07862334f, 
    0.03518524f, -0.01793993f, 0.05093464f, 0.25638351f, 0.24658179f, 0.04038009f, 0.02372435f, 0.01587159f, 
    0.05836734f, 0.08172536f, -0.06397924f, -0.14804292f, 0.08170368f, -0.14946534f, -0.12739563f, 0.15845276f, 
    0.00304711f, -0.04763274f, 0.09306087f, 0.09212507f, -0.37261683f, -0.16783358f, -0.10200567f, -0.06678744f, 
    -0.02137060f, 0.03676143f, 0.12366721f, 0.08200457f, 0.05074453f, -0.22018613f, 0.00127212f, 0.02449854f, 
    -0.07692690f, -0.06088584f, 0.02412428f, 0.14894485f, 0.11315335f, 0.00521596f, -0.05931200f, -0.04703469f, 
    -0.02777299f, 0.07311574f, 0.11112250f, 0.08313072f, 0.14199769f, 0.06823730f, 0.15678558f, 0.24247056f, 
    -0.10234018f, 0.16908891f, -0.13774422f, -0.08919745f, -0.04320522f, 0.04740158f, -0.09845157f, 0.13391148f, 
    -0.19249544f, -0.10399153f, -0.21235728f, 0.07379174f, -0.13945580f, 0.17450976f, -0.11059342f, -0.03461283f, 
    0.11270414f, -0.07921587f, 0.02510228f, 0.07215043f, 0.11160292f, -0.11705988f, -0.11154438f, 0.03864217f, 
    -0.04558561f, -0.10259295f, 0.10521688f, -0.00284691f, 0.24724288f, -0.04317131f, -0.02611950f, 0.17966616f, 
    0.01757184f, 0.08646088f, 0.15838562f, 0.15568142f, 0.14612998f, 0.00883317f, -0.07768982f, 0.09970886f, 
    -0.17404045f, 0.12941024f, 0.05499486f, -0.26044449f, -0.49791771f, -0.24694024f, 0.10050990f, 0.01311685f, 
    0.14945191f, -0.15124521f, -0.01709210f, -0.01532812f, -0.21258579f, -0.01646486f, -0.05004020f, 0.27649692f, 
    -0.01125142f, 0.06548173f, 0.00253004f, 0.01280151f, 0.06404499f, 0.03565746f, -0.22658812f, 0.18689781f, 
    -0.18190682f, 0.07593683f, 0.10193086f, 0.14066215f, 0.06040500f, 0.17928614f, 0.09974491f, 0.09343193f, 
    -0.02293411f, 0.18727332f, -0.16457570f, -0.03503122f, -0.01600180f, 0.13470191f, -0.19510044f, 0.05144988f, 
    -0.26544875f, -0.27041256f, -0.20330881f, -0.06844852f, -0.12417748f, -0.14175560f, -0.01446431f, -0.00274535f, 
    0.04929698f, -0.06945440f, -0.05814890f, -0.06732300f, 0.08390368f, -0.05518231f, 0.00048465f, 0.08436560f, 
    0.06348892f, 0.08930846f, 0.10718317f, 0.12215578f, 0.06707820f, 0.13846187f, -0.18695731f, 0.00179706f, 
    0.04098547f, -0.04289968f, 0.05782090f, -0.01904772f, -0.06719276f, 0.13604766f, -0.12670945f, 0.02698357f, 
    0.07909326f, 0.12003157f, -0.02524891f, 0.08855198f, -0.08686838f, -0.19467597f, 0.06178131f, 0.03803996f, 
    -0.07566722f, 0.11072992f, 0.00680974f, -0.01589790f, -0.05356475f, 0.17507108f, -0.17312966f, -0.10348276f, 
    -0.09491397f, 0.06286773f, -0.04070505f, 0.02123930f, 0.03833580f, 0.16653363f, -0.16907886f, 0.04999250f, 
    0.02329951f, 0.00025558f, 0.00588812f, 0.05035523f, 0.03863699f, -0.03721745f, 0.15819336f, -0.28430989f, 
    -0.22692959f, -0.29824385f, 0.14200036f, -0.18566507f, -0.03806364f, -0.00382509f, 0.13096684f, -0.21875210f, 
    -0.43079987f, -0.07582083f, -0.06235848f, 0.18193355f, 0.09691741f, -0.19257215f, -0.09709269f, 0.00802741f, 
    -0.03753220f, -0.17083400f, -0.20927320f, -0.11924721f, -0.06463494f, 0.04552625f, -0.01069953f, -0.05794922f, 
    -0.06601373f, -0.04122590f, 0.11400741f, 0.07654591f, 0.12323669f, 0.07030734f, -0.05321475f, 0.15706642f, 
    -0.09680881f, -0.06281928f, -0.05058334f, 0.16386205f, 0.20455237f, 0.05236674f, 0.04816195f, 0.07459906f, 
    0.09600439f, -0.04946664f, -0.04023293f, 0.01399121f, 0.15983891f, 0.02850560f, 0.23641697f, 0.04690359f, 
    0.03123352f, -0.02059592f, -0.09014381f, 0.13626868f, 0.18760325f, -0.05354560f, -0.11585757f, 0.13859236f, 
    -0.19812106f, 0.01201057f, -0.14830004f, 0.02813104f, 0.03675027f, -0.06895717f, -0.09819229f, -0.26508859f, 
    -0.02191960f, -0.14927022f, 0.12048788f, -0.12885885f, -0.00826350f, 0.14724533f, -0.02108010f, 0.15005520f, 
    -0.09565955f, -0.04371773f, -0.05879907f, 0.12745628f, 0.05902695f, 0.11149672f, 0.11051276f, 0.01655570f, 
    -0.08244674f, -0.04722026f, -0.01807820f, -0.00597685f, 0.26212087f, 0.06293413f, -0.19653374f, -0.02771334f, 
    0.03653011f, 0.02868889f, 0.03510610f, -0.00913302f, 0.16791576f, 0.02599871f, 0.06364424f, 0.11015094f, 
    0.03466389f, 0.02338275f, -0.10403842f, 0.00277959f, -0.23418601f, 0.00144709f, 0.07193445f, 0.00013914f, 
    0.01364627f, -0.11241314f, -0.05995110f, -0.11644319f, 0.09942473f, 0.14934708f, -0.07799696f, 0.04252928f, 
    0.02254539f, 0.05645103f, 0.08698419f, 0.00354945f, -0.06274524f, 0.26478294f, -0.43334278f, -0.08931667f, 
    -0.19915748f, 0.00312849f, -0.06161581f, -0.07999650f, -0.12493653f, 0.24387991f, 0.18766825f, 0.13254167f, 
    -0.06697313f, -0.05618152f, -0.12905864f, -0.04632852f, 0.01285946f, -0.09041082f, 0.06829320f, 0.03016552f, 
    -0.00837159f, -0.12512858f, 0.09981323f, 0.07104824f, 0.05632317f, 0.02057853f, -0.08434917f, -0.43310323f, 
    -0.29697630f, -0.17607351f, 0.07550564f, -0.04572304f, -0.05200136f, -0.07721852f, 0.10313997f, -0.11086123f, 
    0.23971833f, -0.19371490f, 0.12047316f, 0.16786352f, 0.12169012f, 0.06382809f, 0.05487994f, -0.01345508f, 
    0.12068684f, -0.18724959f, -0.17618455f, -0.09868655f, -0.11182390f, -0.03138671f, -0.11785191f, -0.08126930f, 
    0.08146378f, 0.04988887f, -0.17419812f, -0.00775606f, 0.18402387f, 0.18000133f, 0.01231893f, -0.06825633f, 
    0.02700820f, 0.15841044f, 0.01061691f, 0.05114721f, -0.09759483f, 0.06364978f, 0.07762070f, 0.13009585f, 
    -0.09823582f, -0.01956264f, 0.03608385f, 0.12343068f, -0.15119250f, 0.21846323f, 0.35340056f, 0.18491940f, 
    -0.06454769f, -0.16843797f, -0.19732492f, 0.18396850f, 0.08061976f, -0.12634695f, -0.12859751f, -0.34124488f, 
    -0.07365493f, 0.08936034f, 0.10042486f, 0.02737951f, -0.02870199f, -0.11937523f, -0.22342794f, 0.11082254f, 
    -0.05891388f, -0.10180559f, 0.02493743f, 0.04111264f, 0.12419107f, -0.01148100f, -0.15282451f, 0.12680909f, 
    -0.05501165f, -0.08041509f, -0.10282927f, -0.08044682f, -0.05830158f, -0.16648242f, -0.01292526f, -0.00974732f, 
    -0.39770171f, 0.02049727f, -0.04511146f, 0.00148942f, 0.26977217f, 0.00050441f, -0.07790415f, -0.02987029f, 
    0.10472372f, 0.10295981f, -0.06775749f, 0.12193598f, 0.08658867f, 0.14150442f, -0.02715261f, 0.03766126f, 
    0.12159005f, -0.09487670f, 0.19943558f, -0.02303517f, -0.02216097f, 0.18670592f, 0.25008586f, -0.04061018f, 
    -0.05277230f, -0.00280706f, 0.01333038f, -0.07671481f, -0.03411032f, 0.28653920f, -0.13264476f, 0.08770603f, 
    0.02318305f, 0.16103013f, -0.00978243f, -0.09018645f, 0.05296142f, 0.09668098f, 0.05706533f, 0.28224760f, 
    0.13947654f, 0.03054937f, 0.08849589f, 0.00887179f, 0.13970460f, 0.17468122f, 0.15718226f, -0.02771141f, 
    0.01179181f, 0.04042922f, -0.07311467f, 0.09099479f, -0.11023714f, -0.09983633f, 0.03406907f, 0.21281604f, 
    0.15843318f, 0.01800151f, -0.16200015f, 0.01349008f, -0.05722921f, 0.21304552f, -0.17099354f, 0.07722026f, 
    0.14005426f, 0.05367428f, 0.09626744f, 0.19991617f, -0.01101690f, 0.26546162f, 0.05538718f, 0.22107929f, 
    0.16263689f, 0.00568496f, -0.02212985f, -0.11553028f, 0.08092424f, 0.05364879f, -0.02475186f, 0.05577861f, 
    -0.15946449f, 0.00532941f, 0.17922354f, 0.15486178f, 0.17540108f, 0.12073360f, -0.06025516f, 0.11910335f, 
    -0.00628659f, 0.15264726f, -0.09432647f, -0.02320933f, -0.29493755f, -0.06041539f, -0.07790491f, -0.00783920f, 
    -0.26017827f, -0.04501060f, -0.01213685f, 0.19234180f, -0.11047509f, -0.12112279f, -0.16715288f, -0.08636776f, 
    -0.04655122f, -0.10320722f, 0.03630940f, -0.07694182f, -0.10538343f, 0.03688477f, 0.04188986f, -0.09774149f, 
    0.10134198f, -0.06054638f, 0.02828066f, -0.02926449f, -0.08701570f, 0.32635888f, 0.00347991f, 0.12185715f, 
    -0.01681061f, 0.01031923f, -0.01968633f, -0.00369034f, 0.03257320f, -0.03047346f, 0.09143554f, 0.04897566f, 
    0.24195537f, -0.03720072f, -0.06822776f, 0.08127370f, -0.07410508f, 0.22340527f, -0.08497821f, -0.08700825f, 
    -0.16235988f, -0.03001871f, -0.01901551f, 0.16497159f, -0.07835780f, 0.00634047f, -0.11760934f, -0.13660429f, 
    -0.44475123f, -0.02717549f, -0.04871632f, 0.07637355f, -0.12834775f, -0.08641507f, -0.01378220f, -0.09481893f, 
    -0.20284557f, -0.19050717f, 0.09740286f, 0.33100352f, 0.06932700f, 0.01939930f, -0.00582090f, -0.09316733f, 
    -0.00878861f, -0.03975267f, -0.00800351f, 0.04730414f, 0.17778824f, 0.20222197f, 0.11156753f, -0.02310426f, 
    -0.08165944f, -0.02354738f, -0.14491081f, 0.14661412f, 0.30684933f, -0.07198644f, -0.12028084f, -0.01222995f, 
    0.09129530f, 0.02857878f, 0.20325197f, 0.02212584f, 0.07408761f, -0.13584045f, 0.07588331f, 0.15834862f, 
    0.25130302f, -0.03678501f, 0.03994619f, 0.17939374f, 0.10488386f, -0.12867282f, 0.02315131f, 0.17146395f, 
    0.03564889f, 0.11247979f, 0.12941189f, 0.04672432f, -0.01926552f, -0.04356766f, 0.07776850f, -0.06753773f, 
    0.01905947f, 0.05097571f, 0.06779408f, 0.09888797f, -0.04078846f, -0.05185811f, -0.14376894f, -0.08662566f, 
    0.17670517f, 0.08468997f, 0.09582522f, 0.16768743f, -0.04015047f, -0.00395963f, -0.12060308f, 0.19749077f, 
    0.12334768f, 0.13348033f, 0.23162387f, 0.07239663f, -0.15745547f, 0.00554484f, -0.06485226f, 0.05945697f, 
    0.05332136f, 0.10051701f, 0.10446396f, -0.09231673f, -0.03392540f, 0.15345383f, 0.11002531f, 0.06103910f, 
    -0.08731189f, 0.27808926f, -0.20716250f, -0.11899880f, 0.10889210f, 0.07214711f, 0.08944463f, -0.01999629f, 
    0.02407316f, 0.06099042f, -0.24738510f, -0.06595496f, -0.00546288f, 0.08040881f, 0.00096498f, 0.03211608f, 
    -0.00138137f, 0.01853951f, 0.04909296f, 0.12152056f, 0.07500189f, 0.05542639f, -0.16820675f, -0.05628099f, 
    -0.00812967f, 0.02629386f, 0.16484548f, 0.03785258f, 0.04604027f, 0.11629950f, -0.15377124f, 0.07853290f, 
    0.07310382f, 0.10150841f, 0.09957471f, 0.01954222f, 0.05780448f, 0.06562030f, 0.08003391f, 0.14877349f, 
    0.12411073f, 0.09529842f, 0.15001757f, 0.05620288f, 0.03134856f, 0.05141049f, 0.03468825f, -0.11464903f, 
    -0.14805235f, -0.14712700f, -0.01777355f, 0.02340283f, 0.20772967f, -0.02534245f, 0.03312423f, 0.15581062f, 
    0.16549574f, 0.24412486f, 0.06205013f, -0.05716066f, 0.00330924f, 0.01269545f, -0.10699590f, -0.02235514f, 
    -0.00184741f, 0.14119406f, 0.25486970f, 0.17336157f, -0.07234875f, -0.02662136f, 0.00731125f, -0.02106166f, 
    0.02596165f, -0.10009190f, 0.10082325f, 0.22483011f, -0.01658954f, -0.02953859f, -0.11341301f, -0.04811592f, 
    -0.10551891f, -0.06638379f, -0.11642065f, 0.11406428f, 0.10680132f, 0.26033688f, 0.07967242f, -0.07476201f, 
    0.17509019f, 0.01874357f, 0.05656546f, 0.04576220f, 0.20287433f, 0.19411442f, 0.17810835f, -0.13876036f, 
    -0.21079686f, 0.03359816f, -0.07069656f, -0.03185679f, -0.02582419f, -0.06763561f, -0.01093947f, -0.05327573f, 
    -0.09015632f, -0.08576279f, 0.05145214f, -0.08672546f, -0.03758652f, -0.22335909f, -0.02453368f, -0.08950989f, 
    0.09338281f, 0.06049114f, 0.14432611f, 0.04462395f, -0.01037812f, 0.08610155f, -0.09171015f, 0.08280409f, 
    0.20644113f, 0.16563863f, -0.17790164f, 0.05683284f, 0.04271993f, 0.08000296f, 0.16643134f, 0.19716455f, 
    -0.04742090f, 0.00450594f, 0.18062939f, -0.02971203f, 0.05622952f, -0.02935179f, 0.01311271f, 0.08522825f, 
    -0.09897070f, 0.15917502f, 0.27417961f, 0.04492033f, -0.06895814f, 0.18226697f, 0.07428613f, -0.11710002f, 
    0.04940263f, 0.07712512f, -0.00914826f, -0.09424197f, 0.18621109f, 0.07039851f, 0.09244361f, -0.08199073f, 
    -0.05087071f, 0.14150019f, 0.15795732f, 0.02962105f, -0.16178544f, 0.21384490f, 0.10096779f, 0.07312396f, 
    0.10626411f, 0.02983615f, 0.11944510f, 0.18278635f, -0.11940156f, 0.04043683f, -0.00773605f, 0.07024846f, 
    0.15987495f, -0.00938402f, 0.06675147f, -0.03564340f, -0.16352165f, 0.00655961f, 0.06512710f, 0.10891365f, 
    -0.07069784f, -0.02091752f, 0.21753153f, 0.16104534f, -0.03735847f, 0.02411180f, 0.08045985f, 0.24249002f, 
    0.08540119f, -0.01020123f, 0.09512846f, 0.02201157f, 0.04093286f, -0.07122660f, -0.13247174f, 0.11273019f, 
    0.10700703f, 0.21609513f, 0.21856625f, 0.03845525f, 0.00012063f, 0.10136633f, 0.18812478f, 0.14611721f, 
    -0.02866660f, 0.11934709f, -0.28708777f, 0.06850956f, -0.06393480f, -0.33472061f, 0.04695713f, 0.00770278f, 
    0.00528073f, 0.01962405f, 0.21759699f, 0.16193165f, 0.16881233f, 0.01650776f, -0.10813265f, 0.08161321f, 
    -0.05303003f, -0.06286123f, 0.03384907f, -0.09144506f, 0.23013903f, -0.08695351f, -0.04594366f, -0.19061881f, 
    -0.07204576f, 0.01532145f, 0.12904245f, 0.06950711f, -0.03343682f, -0.16626880f, -0.08693760f, 0.06100393f, 
    -0.02690421f, -0.06811271f, -0.01241095f, 0.06945677f, 0.24204095f, -0.07276589f, 0.09559827f, 0.03089184f, 
    0.13791907f, 0.08423202f, -0.06961645f, -0.03639831f, 0.08829440f, 0.07958347f, 0.13532823f, 0.00338457f, 
    -0.08912979f, -0.06266281f, 0.02126564f, 0.07698872f, 0.01241109f, -0.14972332f, 0.02897601f, 0.08358362f, 
    -0.12086772f, -0.01978342f, 0.05636385f, 0.05389231f, 0.03666147f, 0.04497591f, 0.00896914f, -0.01286845f, 
    0.23201682f, 0.18921229f, 0.03201814f, 0.05611545f, -0.21379454f, 0.10208130f, 0.09569251f, 0.12737827f, 
    0.16130893f, 0.20262092f, 0.14782608f, 0.11140332f, -0.07930818f, -0.07509398f, 0.01045015f, 0.10772838f, 
    -0.06184691f, 0.04857648f, -0.02871552f, 0.00709055f, 0.01287055f, -0.04328939f, 0.09921482f, 0.02021270f, 
    0.08967596f, 0.10502449f, -0.23610406f, -0.05194702f, 0.22127500f, 0.09343531f, -0.00580434f, -0.32443789f, 
    0.04971601f, 0.01629350f, 0.08877487f, -0.07632659f, -0.14350151f, 0.16589652f, -0.03003621f, -0.00226515f, 
    -0.17352715f, 0.09765732f, 0.12958844f, 0.10710297f, 0.10631783f, 0.14334710f, -0.14608891f, -0.10283644f, 
    -0.32740551f, -0.24451870f, 0.18774216f, -0.03787470f, 0.13444886f, 0.02793982f, 0.09692294f, 0.30991861f, 
    0.12531580f, -0.07820535f, -0.03567569f, 0.01942966f, 0.04709499f, 0.04241854f, 0.13453837f, 0.10824464f, 
    -0.10451891f, 0.01999534f, 0.04436802f, 0.00191514f, 0.05834104f, 0.05949914f, -0.07683171f, 0.09889382f, 
    -0.05214282f, 0.05437087f, -0.01750621f, 0.12607884f, 0.06258407f, -0.14769907f, 0.15388513f, 0.23827298f, 
    -0.02035022f, 0.23115619f, 0.27814347f, 0.02527234f, 0.01618329f, -0.16948000f, 0.02858460f, 0.03568555f, 
    -0.08545624f, 0.10645995f, 0.03541743f, -0.06411505f, -0.02431382f, 0.06002173f, -0.01552529f, -0.12449802f, 
    -0.02743850f, -0.10001261f, 0.05295046f, 0.06067213f, -0.09068793f, 0.02781763f, 0.06457357f, -0.20875213f, 
    -0.05406893f, 0.09613802f, 0.05411872f, -0.15115435f, 0.15093800f, 0.27340022f, 0.04681335f, -0.05322350f, 
    -0.03449377f, 0.05134404f, 0.01522160f, -0.03666317f, -0.16486527f, 0.17089090f, 0.01133991f, 0.11019007f, 
    -0.00110660f, -0.01503766f, -0.01270953f, -0.06790836f, -0.13005094f, -0.20860957f, 0.03918427f, 0.15128484f, 
    0.00672891f, -0.17577662f, -0.16498700f, -0.03271333f, 0.12262203f, -0.20218027f, 0.08648399f, 0.14275348f, 
    0.05459090f, 0.05472817f, -0.11329180f, 0.02049003f, 0.01218042f, 0.02803037f, -0.08521660f, 0.00801407f, 
    -0.00894639f, 0.05080220f, -0.03204537f, -0.00688516f, -0.10906997f, 0.03009894f, 0.00884246f, 0.07709925f, 
    0.13162363f, 0.12675883f, -0.10531089f, -0.10287539f, -0.06131187f, 0.09328582f, 0.01757128f, -0.10740528f, 
    0.03405520f, 0.01118678f, -0.04863220f, -0.12754333f, 0.02340917f, 0.02564437f, -0.00898229f, -0.13084583f, 
    0.08393126f, 0.00474326f, -0.07207219f, -0.05909492f, 0.21250825f, 0.00161069f, -0.11823978f, 0.05333200f, 
    0.06012180f, 0.20361066f, 0.04365623f, -0.04979742f, 0.23515370f, 0.22831389f, 0.14450242f, 0.00845698f, 
    0.09176061f, 0.07307651f, 0.09307676f, 0.06035984f, -0.09529220f, -0.03690055f, 0.02683682f, 0.01590878f, 
    0.01218576f, -0.16491003f, -0.03835746f, 0.11877972f, 0.03234202f, -0.01646904f, 0.09502468f, -0.01393644f, 
    -0.23918959f, -0.25014028f, -0.04138241f, 0.08276562f, 0.07128877f, 0.14151746f, 0.01003736f, -0.04312960f, 
    -0.22443114f, 0.10396285f, 0.01296382f, -0.03286507f, -0.00565973f, -0.08653847f, -0.22922537f, -0.02876019f, 
    0.11518269f, 0.26175377f, 0.06610041f, 0.14506756f, 0.09700599f, 0.07998683f, 0.08724519f, 0.12941813f, 
    -0.04634002f, -0.05562693f, -0.04387207f, 0.01339800f, -0.00299397f, 0.03959604f, -0.04939650f, 0.03614392f, 
    -0.04329989f, 0.00748471f, -0.03843021f, 0.00221631f, 0.04128687f, -0.03390526f, -0.03849684f, 0.03941907f, 
    -0.04643995f, -0.03300900f, 0.00952054f, 0.03786115f, -0.00835452f, 0.01509608f, -0.02843673f, 0.00867629f, 
    0.03199314f, 0.03377455f, -0.01874854f, -0.03175867f, -0.04970701f, -0.02012725f, -0.01395645f, 0.03891477f, 
    0.01396788f, 0.04602737f, -0.06164669f, -0.03022937f, -0.00837339f, 0.02847345f, 0.01723567f, -0.00840093f, 
    0.00108383f, -0.03781117f, 0.00176079f, -0.02504204f, -0.06013860f, -0.05059382f, 0.02749778f, -0.04115235f, 
    0.04271707f, -0.01421197f, 0.02400648f, 0.00623581f, 0.02782495f, -0.01395880f, -0.03256166f, -0.01111780f, 
    0.03178699f, -0.03821870f, 0.00766982f, -0.01525472f, -0.05623865f, 0.00741383f, 0.04093204f, 0.05264887f, 
    0.00332245f, -0.01318961f, 0.00373035f, 0.03895852f, 0.05379254f, 0.01176624f, 0.04759312f, -0.00324611f, 
    -0.04804917f, -0.01157742f, 0.02718919f, -0.01906954f, -0.04790927f, -0.04542463f, 0.03355494f, -0.00837105f, 
    -0.05334482f, -0.01905327f, -0.03196100f, -0.03934532f, 0.03087882f, -0.02922387f, 0.02226715f, 0.03431382f, 
    0.01777472f, -0.04016794f, -0.06260024f, 0.04186744f, -0.02494863f, 0.02214627f, -0.03325231f, -0.01453009f, 
    -0.00487387f, -0.02591356f, 0.03592843f, -0.02058032f, -0.05650940f, -0.00556366f, -0.05472470f, 0.05163597f, 
    -0.04308061f, -0.04910570f, -0.03569429f, -0.00175210f, 0.01684592f, -0.05722264f, -0.03086990f, -0.03631007f, 
    -0.04768418f, 0.03949565f, -0.02719798f, 0.01580657f, 0.02074183f, -0.05739759f, 0.02772911f, -0.00449535f, 
    0.00543344f, -0.05225841f, -0.03789822f, 0.04636410f, -0.01266595f, 0.00707562f, 0.04588669f, -0.02837709f, 
    0.04295946f, 0.02488798f, -0.02317340f, -0.02021121f, -0.00643152f, -0.02330597f, -0.01589805f, -0.04903875f, 
    -0.01285131f, 0.04434444f, 0.00432067f, -0.02945943f, 0.05225241f, -0.01708222f, -0.03871359f, 0.01291135f, 
    0.01807703f, -0.02479410f, 0.03116834f, 0.02269563f, 0.01253267f, -0.04469233f, 0.01742679f, 0.03606391f, 
    0.04275915f, -0.03626515f, 0.03270917f, -0.02689998f, -0.06308431f, -0.03220089f, -0.05890185f, 0.03794106f, 
    0.04924228f, -0.06372749f, 0.01501546f, -0.05019495f, -0.00968760f, 0.03193148f, -0.05424871f, 0.02399291f, 
    -0.05879901f, -0.05488019f, 0.02383042f, 0.04144784f, 0.03740741f, 0.01576536f, 0.00081150f, 0.01754619f, 
    0.02444257f, -0.02624375f, -0.00554748f, 0.03008596f, -0.01418658f, -0.01690260f, 0.00362476f, -0.02337879f, 
    0.04186607f, 0.04818659f, -0.02775214f, 0.05118467f, 0.02629106f, -0.03383439f, 0.03925013f, -0.05455178f, 
    -0.01299277f, 0.00298794f, 0.05906887f, -0.04104017f, -0.00186424f, 0.02082762f, -0.06281970f, 0.01311995f, 
    0.00795443f, 0.03208447f, -0.00736530f, 0.04080931f, 0.02093406f, 0.01407314f, -0.02098607f, -0.04304253f, 
    -0.02843352f, 0.00868915f, 0.04370434f, -0.05621883f, -0.00745160f, 0.05089959f, -0.05150696f, 0.05464143f, 
    -0.02533820f, 0.05398271f, 0.05137164f, -0.03645064f, 0.00547280f, 0.03046001f, -0.06444814f, -0.04035389f, 
    -0.02694732f, -0.01086894f, 0.00776801f, 0.01994879f, 0.01770249f, -0.00983950f, 0.04911216f, 0.03232069f, 
    -0.04581239f, -0.04875059f, -0.02030136f, 0.03184377f, -0.05849623f, -0.04460113f, 0.01555532f, -0.04884525f, 
    -0.04823869f, 0.04172317f, -0.06346248f, -0.06398251f, 0.01424047f, 0.01860170f, -0.03396787f, -0.02533915f, 
    0.00453300f, -0.05705822f, -0.04940398f, 0.04406734f, 0.02589311f, -0.04370847f, -0.03126175f, 0.04298159f, 
    -0.04922476f, -0.05132177f, -0.02344414f, 0.01899948f, -0.00900620f, 0.01903832f, 0.03445747f, -0.05290702f, 
    0.01970704f, -0.06261077f, 0.01576284f, 0.02664721f, -0.04042222f, -0.03954284f, -0.02195119f, -0.01336884f, 
    0.00250594f, -0.00724924f, -0.02617808f, 0.03604389f, -0.05526175f, 0.04309805f, -0.06246214f, 0.03315556f, 
    -0.01746617f, -0.02210965f, -0.04265690f, -0.03287024f, 0.03241594f, -0.02202130f, -0.06002337f, 0.01055320f, 
    0.01294231f, -0.05456793f, 0.04824815f, -0.01668306f, -0.06736563f, 0.02123225f, 0.04087844f, 0.02611601f, 
    -0.02140242f, -0.01076705f, 0.02293368f, -0.04031062f, -0.02975669f, -0.00566653f, -0.04444613f, -0.03051656f, 
    0.04878980f, -0.06306440f, 0.02040259f, 0.03822809f, 0.03983035f, -0.00311676f, -0.03441719f, -0.01844962f, 
    -0.00037513f, 0.00621890f, -0.04200150f, 0.00990833f, -0.02241276f, -0.04414004f, -0.02942039f, 0.00535620f, 
    -0.02345163f, -0.00267786f, -0.06719867f, 0.01315721f, 0.01457423f, -0.00723248f, -0.02496900f, -0.03046860f, 
    0.04074844f, 0.04835478f, -0.04602564f, 0.00472653f, 0.03420140f, -0.01923521f, 0.02919518f, 0.00180729f, 
    -0.04642883f, 0.04850248f, 0.01032668f, -0.01035631f, 0.03384247f, 0.02153317f, 0.00796187f, 0.03252244f, 
    0.03098779f, 0.04038626f, -0.00915166f, -0.01830160f, 0.03430242f, -0.03664620f, -0.05649770f, -0.03926087f, 
    -0.02695361f, -0.01374209f, 0.01027268f, -0.01520393f, -0.02395608f, -0.04913842f, -0.06465381f, 0.03944576f, 
    -0.06064485f, 0.03216887f, -0.05228041f, 0.04169516f, 0.02467266f, -0.02412944f, 0.02654086f, -0.02149650f, 
    0.00177893f, -0.05720508f, -0.00589894f, 0.01968455f, -0.02984418f, 0.01564712f, -0.00434445f, -0.03826458f, 
    -0.00187074f, 0.02287219f, 0.03186573f, -0.03767513f, 0.00649780f, 0.00803252f, -0.04668319f, -0.03694094f, 
    -0.01977935f, -0.01400191f, 0.01188819f, -0.04438036f, 0.02219906f, 0.05090567f, -0.04863746f, -0.05184773f, 
    -0.02540883f, 0.00683044f, -0.02659045f, -0.04600317f, -0.05899668f, 0.02120181f, -0.04718060f, 0.02026191f, 
    -0.03150814f, 0.03849189f, -0.05087365f, -0.02500278f, -0.05745812f, -0.05841658f, -0.02161632f, 0.01256203f, 
    -0.05178064f, -0.03088303f, 0.02951046f, 0.00252515f, -0.04147454f, -0.05086694f, -0.05385166f, -0.01911787f, 
    0.04607614f, 0.01419621f, -0.03415991f, 0.02158313f, -0.01073674f, 0.01172896f, -0.00409113f, -0.05475993f, 
    -0.03413785f, -0.05145767f, 0.01272622f, -0.06031003f, 0.00148258f, -0.03702852f, -0.01882479f, 0.04508525f, 
    0.04039076f, 0.03559316f, -0.03130940f, -0.00207865f, 0.04340107f, 0.04922549f, 0.01951751f, 0.00042986f, 
    0.02245140f, -0.01975212f, 0.00546493f, -0.05133501f, -0.06144540f, -0.03123567f, -0.01437719f, -0.04986574f, 
    -0.00418997f, -0.01583362f, 0.02252166f, -0.02549014f, -0.06612493f, 0.00516639f, -0.00909140f, -0.04713611f, 
    -0.03990809f, 0.05018089f, 0.02441092f, -0.01161881f, -0.01428791f, -0.00558030f, -0.01408164f, 0.04681537f, 
    -0.03705855f, -0.03950572f, 0.03899913f, -0.03950592f, -0.02662287f, -0.01786353f, 0.01122053f, -0.03905711f, 
    0.04489340f, -0.01959470f, -0.01225754f, 0.05057642f, -0.05943702f, -0.06162614f, 0.03026861f, -0.06552467f, 
    -0.04784311f, 0.00931420f, -0.04455778f, 0.04893545f, 0.02149046f, 0.02652749f, 0.04205687f, -0.01214242f, 
    0.00930476f, 0.04099266f, 0.04292658f, -0.00987798f, 0.01920408f, -0.04667187f, -0.02092488f, 0.05207248f, 
    0.01012381f, -0.03035045f, -0.00357033f, 0.03219097f, -0.02374896f, 0.00123987f, 0.01697519f, -0.02628207f, 
    -0.04967159f, -0.05779548f, 0.04894083f, -0.06131327f, -0.04106941f, -0.05797887f, 0.04812846f, -0.03429218f, 
    0.03475113f, -0.04970703f, -0.02228765f, 0.04549699f, 0.01409759f, -0.02743977f, -0.04902415f, 0.01451228f, 
    0.02398529f, -0.00143069f, 0.00805782f, -0.05187434f, -0.05831082f, -0.06414714f, 0.01946413f, -0.02140751f, 
    0.01823519f, 0.04316698f, -0.03759576f, -0.06452419f, 0.03716713f, 0.01165205f, -0.02148980f, 0.03333242f, 
    0.05032631f, -0.05553661f, -0.00312260f, -0.04857031f, 0.01412961f, -0.03414397f, 0.04939599f, 0.00706301f, 
    0.00458653f, -0.02266497f, 0.04330664f, 0.02910703f, -0.01487105f, 0.00518130f, -0.02139760f, 0.03329225f, 
    -0.00483926f, 0.00652612f, 0.00323606f, -0.01824849f, -0.02130793f, -0.02815245f, -0.05888437f, -0.02934208f, 
    -0.00555740f, -0.03675365f, 0.03284958f, 0.04376760f, 0.01670715f, -0.00173955f, -0.03063488f, 0.00947128f, 
    0.03161467f, -0.04665202f, -0.04758747f, -0.00759748f, -0.05675508f, -0.01012923f, -0.01786901f, -0.04520550f, 
    -0.01165081f, -0.03164424f, -0.15288071f, 0.08624899f, -0.09567844f, 0.04513635f, -0.00033804f, -0.05321050f, 
    -0.04422049f, -0.23348039f, 0.01830658f, 0.18835559f, 0.13529414f, -0.06873094f, 0.03435419f, 0.10334191f, 
    0.07833068f, -0.07472664f, 0.12671395f, 0.04971661f, -0.03042151f, 0.07333123f, 0.03783388f, -0.05758297f, 
    -0.02785035f, -0.05396456f, 0.05707213f, -0.02397764f, 0.10004182f, 0.06961741f, 0.02994812f, -0.00615093f, 
    0.05312297f, -0.08932798f, 0.14105815f, -0.14207871f, -0.23868127f, -0.03917883f, -0.22261582f, -0.02409786f, 
    -0.06792542f, 0.00447718f, 0.04846270f, 0.06562825f, 0.21666546f, 0.08478244f, 0.00007808f, 0.00401088f, 
    0.10339284f, 0.05562047f, 0.00341437f, -0.00936429f, -0.06150958f, -0.13358998f, 0.01046812f, 0.00185692f, 
    -0.03922698f, 0.05690971f, 0.02879135f, -0.04952173f, -0.00375419f, -0.07815080f, -0.23083039f, 0.06950451f, 
    -0.22315609f, 0.02623491f, 0.10037776f, 0.11973316f, 0.04896944f, -0.18602020f, 0.07371849f, -0.11460514f, 
    -0.23298904f, 0.21393783f, -0.13738188f, -0.07707429f, -0.02531607f, -0.07466273f, -0.08753920f, 0.07208411f, 
    0.05665537f, 0.14354081f, 0.06581378f, -0.26152736f, 0.16386569f, 0.13803588f, -0.03732485f, -0.10114603f, 
    -0.04645438f, -0.03404896f, 0.34109896f, -0.04927738f, 0.03200724f, 0.10492034f, -0.03834177f, -0.10383698f, 
    0.08597560f, -0.00377914f, -0.04452523f, 0.25353622f, -0.02618985f, -0.16508952f, 0.23178616f, -0.05582253f, 
    -0.01969030f, -0.13205807f, -0.06243254f, 0.05974725f, 0.23088886f, 0.10649497f, -0.10920712f, 0.00409717f, 
    -0.09879819f, 0.02971997f, 0.10331095f, 0.08721941f, 0.17608126f, 0.03018500f, -0.06768648f, -0.00429446f, 
    0.00618071f, 0.07819293f, -0.00274080f, 0.05638577f, 0.09710138f, -0.11080063f, -0.07334521f, -0.02887185f, 
    -0.04249373f, 0.06957489f, 0.03079136f, -0.06970501f, -0.02666538f, -0.05061675f, 0.11259943f, 0.17007160f, 
    -0.00259621f, 0.04198323f, -0.01798030f, 0.03723459f, 0.08821665f, 0.06073493f, 0.08602492f, 0.14455269f, 
    0.27212840f, 0.16807252f, 0.08437651f, -0.02203704f, -0.13528299f, -0.12827554f, 0.06460307f, 0.13987947f, 
    -0.05021461f, 0.01148764f, -0.02793214f, -0.13336426f, 0.08197823f, -0.01542275f, -0.23094262f, 0.07825988f, 
    0.08708274f, -0.03124333f, -0.07963648f, -0.01125471f, 0.11177457f, 0.02308710f, -0.07541903f, 0.02290354f, 
    0.05227517f, 0.02890394f, -0.03120980f, 0.08414480f, -0.18548511f, -0.16917075f, 0.00028860f, -0.04152641f, 
    -0.00986976f, -0.08830979f, -0.07538138f, -0.12884481f, -0.00326429f, 0.10228757f, 0.16436604f, -0.04130917f, 
    -0.08153116f, 0.02311170f, 0.10811961f, 0.06255138f, -0.07186101f, 0.17025733f, -0.16178785f, -0.06559398f, 
    0.06771363f, 0.02552281f, 0.08637935f, -0.15046404f, -0.08926852f, 0.00307559f, 0.01875111f, -0.08055440f, 
    -0.10938951f, 0.08260463f, 0.11989540f, 0.00742404f, 0.06234244f, -0.02560174f, -0.35727164f, -0.27097285f, 
    -0.04289077f, -0.13153404f, -0.08659104f, -0.23917261f, 0.09884461f, 0.09936230f, 0.01667447f, 0.05367056f, 
    -0.00335416f, -0.11821402f, -0.41269287f, 0.04788010f, 0.20650843f, 0.03622865f, 0.04298050f, 0.05455391f, 
    0.00253512f, -0.01093468f, 0.12024152f, 0.14789966f, -0.02984132f, 0.11415374f, 0.13087469f, 0.08656240f, 
    0.14171967f, -0.10034520f, 0.14408548f, -0.08990808f, 0.18087567f, 0.07998146f, 0.14052153f, -0.00127747f, 
    -0.03651866f, 0.03323269f, 0.01938742f, 0.07242344f, 0.05324578f, -0.01026638f, -0.05467552f, -0.07852528f, 
    -0.06184759f, 0.00422516f, 0.03381955f, 0.02465136f, 0.11314999f, 0.02421460f, -0.08328668f, 0.16505972f, 
    -0.11042804f, 0.00182820f, -0.11839729f, -0.07572865f, -0.01088979f, 0.12774019f, -0.07567324f, -0.25432387f, 
    0.01065475f, 0.03887945f, 0.17206825f, -0.02356010f, 0.03252202f, 0.07477172f, 0.12359595f, -0.07558531f, 
    -0.05780431f, 0.01296802f, -0.03043004f, -0.13453713f, 0.08278616f, 0.01839664f, 0.02458486f, -0.00030465f, 
    -0.14184919f, -0.13584296f, 0.04988099f, -0.06106561f, -0.09426648f, 0.04928473f, 0.13790090f, -0.00413763f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.09058262f, -0.05645175f, 0.06642132f, 0.00476785f, 0.14588732f, -0.05153944f, 0.09766958f, 0.09903040f, 
    0.01152831f, 0.12331328f, -0.11917011f, -0.00094138f, -0.07656065f, -0.03925956f, -0.00470759f, 0.07121725f, 
    0.06930862f, 0.02205905f, 0.01870978f, -0.03689368f, 0.00896537f, 0.03832262f, -0.02264177f, 0.11060066f, 
    0.07612438f, 0.12969150f, 0.00402973f, 0.12916735f, 0.07511640f, -0.03320212f, 0.03068635f, -0.07930611f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.24621785f, -0.15456034f, -0.11435580f, 0.15050246f, 0.06443817f, -0.08887518f, -0.02562601f, -0.03369432f, 
    0.20822719f, 0.25034672f, 0.26797026f, -0.02257290f, -0.28707930f, -0.30505866f, -0.14223592f, -0.09386858f, 
    -0.00914272f, -0.03744318f, -0.07158538f, -0.24114648f, 0.20056571f, -0.17345430f, -0.11000875f, -0.25699332f, 
    0.19813779f, -0.12668651f, 0.10752005f, 0.20335677f, 0.17343143f, 0.07818460f, -0.07013103f, 0.01204882f, 
    0.08433818f, -0.04658563f, -0.01777540f, -0.04375205f, -0.17559284f, 0.16926610f, -0.14723405f, -0.00405081f, 
    -0.28950584f, -0.18031846f, 0.16803579f, -0.04490011f, 0.04196741f, 0.05922331f, 0.05281095f, 0.00208690f, 
    0.02683731f, 0.40496865f, -0.15928876f, 0.02105774f, -0.02211258f, 0.31282851f, -0.14489445f, 0.48636800f, 
    -0.13552476f, 0.15698348f, 0.10435102f, 0.13167062f, -0.16224612f, -0.04844675f, 0.01756826f, 0.26065147f, 
    0.43034649f, -0.01948176f, 0.27294651f, -0.13372612f, -0.06340323f, 0.12125174f, 0.22444788f, 0.38761896f, 
    0.22587225f, 0.13826776f, 0.18872868f, 0.04518054f, 0.17004846f, 0.00499689f, 0.14269842f, 0.17203960f, 
    -0.08903605f, 0.05145419f, 0.04724412f, 0.14239566f, -0.16921021f, 0.16337429f, 0.09800612f, 0.06344103f, 
    0.21914130f, 0.15753084f, -0.10543351f, -0.21122600f, -0.13069981f, -0.17776057f, -0.10402911f, -0.08435705f, 
    -0.10498699f, 0.00132769f, -0.26064444f, 0.07036056f, 0.49094847f, 0.10227995f, -0.22144412f, -0.20753667f, 
    0.07096390f, 0.18697664f, -0.29183254f, -0.20737316f, -0.21013507f, -0.10853418f, -0.09988039f, 0.22406451f, 
    0.25552845f, 0.15822940f, 0.14094809f, -0.19583148f, -0.03416174f, -0.05198630f, -0.01656940f, 0.10188445f, 
    -0.11118357f, -0.00219466f, 0.13936989f, 0.25175175f, 0.11618640f, -0.05013422f, 0.06404772f, -0.19992493f, 
    0.15057153f, -0.02717046f, 0.03942218f, -0.05120951f, 0.13118468f, -0.02049256f, 0.30399892f, 0.14411074f, 
    0.14430614f, -0.03997343f, 0.05859310f, 0.16263713f, 0.43276867f, 0.40999264f, 0.07168721f, -0.07575843f, 
    0.10160851f, -0.12771678f, -0.15516047f, 0.19980431f, 0.10024118f, -0.00207395f, -0.17652701f, 0.11473677f, 
    -0.19026934f, -0.03001378f, 0.14004697f, -0.22646907f, -0.15262654f, 0.06493673f, -0.15050390f, 0.07807791f, 
    -0.10319121f, -0.12525505f, -0.03742738f, 0.00512568f, 0.42004749f, 0.12991683f, -0.49386632f, -0.02785541f, 
    0.12740886f, 0.13052063f, -0.12667988f, -0.12601086f, -0.31221867f, -0.19934998f, 0.06373315f, -0.01211334f, 
    0.18863288f, -0.14104658f, 0.00222962f, -0.19798246f, 0.14275497f, 0.17252061f, 0.09876521f, -0.17278841f, 
    -0.16310361f, -0.21181042f, -0.28012639f, 0.09025626f, 0.26131848f, 0.05457785f, -0.05200521f, 0.04513526f, 
    -0.20485242f, -0.06896193f, 0.01447486f, -0.06365912f, -0.08384171f, 0.12124299f, -0.15287898f, -0.12998627f, 
    -0.19819084f, 0.00158952f, -0.46420231f, -0.23944129f, -0.22819129f, 0.01796259f, 0.14156741f, -0.26662117f, 
    0.11015452f, 0.17474940f, -0.15823619f, -0.16771106f, 0.24589212f, -0.02060424f, 0.06272334f, 0.00636450f, 
    0.04196049f, 0.18719047f, -0.15710931f, 0.25355595f, 0.18038827f, -0.06099955f, 0.07946447f, 0.17644434f, 
    -0.06567632f, -0.09792604f, 0.00335283f, 0.12831576f, 0.09592740f, 0.06149921f, 0.11889477f, 0.00022773f, 
    -0.17716719f, -0.15316562f, -0.12564793f, -0.00486624f, -0.04829886f, -0.17138112f, 0.14801174f, -0.10826599f, 
    0.05945039f, 0.06406997f, -0.02911879f, -0.09725162f, -0.18799360f, -0.08647539f, -0.01248853f, -0.07677788f, 
    -0.19787955f, -0.06893724f, -0.21095380f, 0.07059850f, -0.04242909f, -0.08318643f, 0.10423664f, -0.12388512f, 
    -0.33079341f, 0.04432486f, 0.24944171f, -0.07486114f, -0.20703678f, 0.05162359f, 0.15713431f, 0.37260658f, 
    0.16424702f, 0.12867656f, -0.06553207f, -0.10557210f, -0.00898921f, -0.34210616f, -0.06875338f, -0.47153023f, 
    -0.13712069f, -0.06088422f, -0.00541114f, 0.00554243f, 0.23602498f, -0.12770189f, 0.16596319f, -0.12871490f, 
    0.43535328f, 0.31774828f, -0.12224016f, 0.10449310f, 0.11745641f, 0.07488271f, -0.09987269f, -0.06269184f, 
    0.25038278f, 0.12498491f, -0.17298427f, -0.14650416f, 0.03246593f, 0.16446877f, -0.08576809f, 0.32256782f, 
    -0.07629909f, 0.12148203f, 0.33794150f, 0.00644543f, -0.30234233f, 0.52160144f, 0.07728835f, 0.01514528f, 
    -0.13221176f, 0.24482962f, 0.04144352f, 0.24675369f, 0.08678746f, 0.14768584f, -0.01279912f, -0.27808833f, 
    0.26544976f, -0.00039092f, -0.04054489f, -0.13369718f, 0.00348883f, -0.10895038f, 0.16495192f, 0.30600220f, 
    0.03549587f, -0.13523892f, 0.03950052f, 0.04426984f, 0.34195623f, 0.02997638f, 0.16651060f, 0.10966431f, 
    0.14885971f, 0.24379243f, -0.15979216f, 0.05971688f, -0.03695495f, 0.15178104f, -0.00015982f, 0.28295550f, 
    0.39348984f, -0.09973566f, 0.17289528f, -0.30409029f, -0.08513609f, 0.24182595f, -0.08413102f, -0.23747514f, 
    0.14719616f, -0.15757461f, 0.04207733f, -0.13134442f, 0.04016929f, -0.03127811f, -0.03864187f, -0.07237171f, 
    -0.02621184f, -0.16686977f, -0.15856114f, -0.03476327f, 0.12839741f, -0.14358389f, 0.05249626f, -0.10168304f, 
    -0.07850245f, -0.12208229f, 0.08070976f, -0.00046804f, 0.02452550f, -0.01472198f, -0.02118596f, -0.12907474f, 
    -0.12700847f, -0.16411453f, -0.09098543f, -0.10005609f, -0.09656977f, 0.04209094f, 0.11614569f, 0.09427076f, 
    0.12153280f, -0.16253681f, -0.17176211f, 0.08534870f, -0.02198110f, -0.01413089f, 0.01428268f, -0.13616262f, 
    -0.18207778f, 0.09420794f, -0.09747661f, 0.04059475f, 0.33121765f, 0.04644477f, -0.22527981f, 0.26033258f, 
    -0.05246302f, 0.23820999f, -0.14236166f, 0.07035308f, -0.36544380f, -0.29446319f, 0.12682110f, -0.40178567f, 
    -0.29087311f, -0.05812473f, 0.00210930f, 0.03599057f, 0.24703610f, -0.13574374f, -0.10684496f, -0.33550832f, 
    0.32010472f, -0.23109558f, -0.22518428f, 0.19444191f, 0.28357527f, 0.13515499f, -0.12942350f, 0.18731125f, 
    -0.00783385f, 0.08575370f, -0.22313459f, -0.06271239f, 0.38482583f, 0.10270161f, -0.11314449f, -0.32888097f, 
    -0.27332813f, 0.21540238f, -0.44418055f, 0.06708041f, -0.35456005f, 0.17445505f, -0.08400128f, -0.27482504f, 
    -0.56975782f, 0.06552073f, 0.08686951f, -0.07101838f, 0.02727734f, -0.05966694f, 0.11750779f, 0.00074048f, 
    0.01539004f, 0.07456253f, -0.14062358f, 0.30448800f, 0.15250267f, 0.02427927f, 0.11085865f, 0.25781798f, 
    0.00581088f, 0.01511357f, -0.03398991f, -0.09541038f, 0.08064249f, -0.11538239f, 0.10195284f, -0.14222054f, 
    -0.08110416f, 0.13554843f, -0.16241772f, -0.14245090f, -0.00584911f, -0.04827567f, 0.10447453f, -0.13614620f, 
    -0.17490335f, -0.09595311f, -0.15077405f, 0.00324351f, -0.21591513f, -0.03333388f, -0.02872036f, -0.09615526f, 
    -0.17996094f, 0.07065975f, 0.14345936f, 0.01023591f, -0.10666224f, -0.05110142f, 0.15592729f, 0.05609453f, 
    -0.20643756f, 0.13208775f, -0.21451907f, 0.01199106f, 0.11260133f, 0.02739358f, -0.35322595f, -0.24668020f, 
    -0.07225876f, 0.10147543f, -0.31079739f, -0.11608920f, -0.12499474f, -0.03403478f, 0.03961517f, -0.01304227f, 
    0.55826646f, 0.19545712f, 0.04595857f, -0.38608611f, -0.08315485f, 0.19257480f, -0.14333880f, 0.57677025f, 
    -0.22127137f, 0.17779596f, 0.14831947f, 0.19851564f, 0.09644867f, 0.04973240f, -0.00899567f, -0.09559888f, 
    0.21138462f, 0.01315154f, 0.10342336f, 0.01627674f, -0.04786274f, 0.10480295f, -0.08268259f, -0.38653558f, 
    0.04826589f, -0.20534143f, 0.17714225f, -0.15224607f, 0.05033723f, -0.17561029f, 0.14589751f, 0.24003860f, 
    0.00505365f, -0.12219276f, 0.02879249f, -0.09411222f, 0.28566527f, 0.48876560f, -0.01428142f, 0.16244017f, 
    -0.53107429f, 0.09700523f, -0.00855612f, 0.14125884f, -0.12380858f, -0.03770972f, 0.03193128f, -0.10163102f, 
    0.03408133f, -0.07468969f, 0.21733637f, -0.11661875f, 0.09103477f, -0.16177347f, 0.13375142f, 0.31870523f, 
    -0.09609965f, 0.15106371f, -0.08745430f, 0.04096309f, 0.10882980f, 0.12406512f, -0.12409063f, -0.00276778f, 
    -0.50057715f, 0.09325001f, -0.16148345f, -0.16356385f, 0.06928293f, 0.05574404f, 0.08566081f, 0.76298225f, 
    0.14801818f, 0.71089935f, -0.28136623f, 0.12890829f, -0.05413290f, 0.07117185f, -0.02759421f, -0.20979226f, 
    -0.00445790f, -0.10806936f, -0.13241260f, -0.11229759f, -0.16754743f, -0.11899007f, -0.05759795f, 0.69095224f, 
    0.03039428f, 0.17142756f, -0.15346517f, -0.19232382f, 0.24355286f, -0.28517774f, 0.09597318f, 0.02637568f, 
    0.37521911f, 0.21100052f, -0.02356473f, -0.04884565f, 0.27654409f, 0.32093960f, -0.10975847f, -0.27901199f, 
    0.21878870f, -0.08690763f, -0.17295334f, 0.17764065f, 0.09897374f, -0.06805967f, 0.02834195f, -0.05052839f, 
    -0.17033090f, -0.17937742f, 0.11863949f, -0.16296390f, -0.00181820f, 0.03463327f, -0.13696614f, -0.16286886f, 
    -0.06383139f, 0.01811995f, -0.10975121f, 0.05427225f, -0.05880938f, -0.05492942f, 0.11460080f, -0.07985189f, 
    -0.14000247f, -0.00131425f, -0.02973078f, -0.12252296f, -0.20248307f, 0.00127119f, -0.05949762f, -0.13241667f, 
    -0.20198344f, 0.06090505f, 0.05477960f, -0.06124682f, -0.00726388f, -0.10786983f, -0.10210830f, -0.10940763f, 
    -0.27169928f, 0.02389968f, 0.00251760f, 0.05306339f, -0.20973669f, 0.14527775f, 0.05093897f, 0.18965949f, 
    -0.10717741f, -0.13073406f, -0.04840627f, -0.19432279f, -0.15984923f, 0.16402370f, -0.04448701f, 0.30002439f, 
    0.52749795f, 0.16285932f, -0.16840726f, -0.37299937f, -0.18673399f, 0.23477110f, -0.01086750f, 0.39333844f, 
    0.35525525f, 0.18646307f, 0.04478138f, 0.12024760f, 0.05791606f, -0.04101392f, -0.15966474f, -0.13833272f, 
    -0.14887552f, 0.07703318f, -0.12743697f, 0.05899387f, -0.13393547f, 0.10724019f, -0.03954104f, -0.02330332f, 
    -0.06850838f, -0.07512621f, 0.09005283f, 0.08048496f, -0.07043915f, -0.16189748f, 0.13767523f, -0.01853136f, 
    0.06465227f, 0.01916327f, 0.07136486f, 0.12714186f, -0.13929826f, -0.01915561f, 0.10606612f, -0.10805424f, 
    -0.10872006f, -0.15965866f, -0.09645278f, -0.01690764f, -0.12635471f, -0.17043774f, 0.04115069f, -0.13941713f, 
    0.01375594f, -0.01384483f, 0.07823405f, 0.04394479f, 0.08871490f, 0.11093966f, -0.02239271f, 0.13514553f, 
    -0.20678931f, 0.02998854f, 0.03820676f, -0.22556323f, -0.02362132f, -0.08366545f, 0.03619380f, -0.22157109f, 
    0.04655369f, 0.03871353f, 0.10626102f, -0.13493322f, -0.19541004f, 0.07426534f, 0.12023395f, -0.13815586f, 
    -0.10051437f, -0.20259500f, 0.05890578f, 0.02085067f, 0.08674528f, 0.10599072f, -0.01533379f, 0.07910693f, 
    0.14447157f, 0.10510050f, 0.08106969f, 0.02364819f, -0.17227787f, 0.10034562f, -0.02334482f, 0.05773699f, 
    -0.20312262f, 0.06320383f, 0.04526300f, 0.04721525f, -0.18258674f, -0.03528661f, -0.14309223f, -0.20215949f, 
    -0.08920760f, -0.11593907f, 0.06197458f, 0.04152850f, -0.10443703f, 0.10757712f, -0.15497345f, -0.02420029f, 
    -0.10128997f, 0.07435801f, -0.08304507f, -0.05393869f, -0.21158448f, -0.11562257f, 0.02219483f, -0.08480694f, 
    -0.04204698f, 0.05040200f, 0.02659746f, 0.04093444f, 0.23274960f, -0.05336836f, -0.07775421f, -0.35911408f, 
    0.21427716f, 0.35486928f, -0.10568328f, 0.10756180f, -0.25651330f, -0.41912028f, -0.06206738f, 0.09527844f, 
    0.14522506f, -0.13681541f, -0.14316355f, -0.38209775f, 0.03555620f, 0.04969608f, 0.17830838f, -0.25672117f, 
    0.03418562f, 0.07934383f, -0.24939787f, 0.21238509f, 0.15148646f, -0.06641114f, 0.07716186f, -0.02488095f, 
    -0.03024965f, 0.11905874f, -0.10987437f, -0.15443853f, -0.05959237f, 0.09462360f, -0.10883894f, -0.13380817f, 
    0.01638279f, -0.19317734f, 0.02274346f, -0.08685085f, -0.18060312f, -0.19497664f, 0.00367255f, 0.11111230f, 
    -0.12646781f, 0.01838553f, 0.15474799f, -0.15650825f, 0.04776243f, -0.07062185f, -0.13750713f, -0.03189002f, 
    -0.05443881f, 0.05708777f, -0.07994562f, -0.06812596f, 0.06010468f, 0.15639144f, -0.01394673f, -0.04357656f, 
    -0.10874292f, 0.10182250f, -0.14282842f, -0.02661221f, -0.12168100f, -0.11290032f, 0.12224496f, -0.07587537f, 
    -0.10326724f, 0.01417448f, -0.04305858f, -0.16340922f, -0.14094235f, -0.14737916f, 0.12227911f, -0.10887949f, 
    0.01719751f, 0.08789951f, 0.16020367f, 0.17365147f, 0.08266428f, -0.02898622f, 0.10312784f, 0.07292689f, 
    -0.04589858f, -0.11705590f, -0.09250180f, 0.01336354f, -0.08187255f, 0.08465902f, -0.00562187f, 0.10985627f, 
    0.46625990f, -0.10769874f, -0.06319797f, 0.00146910f, 0.37312949f, 0.13057320f, 0.25639012f, 0.17299885f, 
    0.20292021f, 0.41854244f, 0.18748768f, -0.00250050f, -0.18487179f, 0.12864815f, 0.01065599f, -0.04210943f, 
    0.19336450f, -0.18757664f, 0.13410202f, 0.19156326f, -0.03791278f, 0.12887308f, 0.07679521f, -0.41173935f, 
    0.26302895f, -0.20284614f, 0.01732186f, -0.19828822f, -0.14544483f, 0.17317219f, -0.03805779f, 0.09152321f, 
    0.34695804f, 0.09024620f, -0.01070054f, -0.13895443f, 0.01356141f, 0.03198867f, 0.33820722f, 0.24279711f, 
    0.13608973f, 0.01436798f, -0.06419735f, -0.23071711f, -0.03619617f, 0.15144010f, 0.06712972f, 0.25169307f, 
    0.17402957f, 0.14415553f, -0.14664012f, -0.16984013f, -0.16447118f, 0.43688267f, -0.09658108f, 0.11441517f, 
    -0.13454717f, -0.06486832f, 0.20597683f, -0.03652393f, -0.16850086f, -0.00817370f, 0.08738036f, -0.12965846f, 
    0.29468533f, 0.15776895f, 0.18585178f, -0.11168399f, -0.12682800f, -0.04893365f, -0.27815673f, -0.26223269f, 
    0.18651439f, -0.07082439f, -0.00201813f, -0.00252883f, -0.19034857f, -0.30216464f, 0.02169777f, 0.05512884f, 
    0.53438568f, -0.00880552f, -0.08940536f, 0.12173415f, 0.08144344f, 0.25976464f, 0.14496166f, -0.19475843f, 
    -0.27113098f, -0.32169852f, -0.39072454f, 0.19023064f, 0.08884497f, 0.00465610f, -0.06267371f, 0.09372421f, 
    0.27003765f, -0.08034842f, 0.25924250f, 0.02804751f, -0.17723261f, 0.06736389f, 0.07483675f, -0.14654699f, 
    0.30610141f, 0.13202417f, 0.29081550f, 0.18013667f, 0.22872196f, 0.03231640f, 0.09612784f, -0.24812166f, 
    -0.18577603f, -0.17359611f, 0.15356414f, 0.28473511f, 0.22348838f, 0.24255416f, 0.06676977f, -0.21853071f, 
    0.01305271f, -0.06928486f, -0.42676607f, -0.13391899f, 0.06571552f, 0.07563894f, -0.09370593f, 0.13155451f, 
    0.13947858f, -0.05709413f, 0.01285564f, -0.12847106f, 0.46451515f, -0.14066653f, 0.11402950f, -0.27083367f, 
    0.19466427f, 0.26883522f, 0.11613461f, 0.22189811f, 0.25031784f, -0.22329964f, 0.05010704f, -0.03446925f, 
    -0.41997430f, 0.02401341f, 0.13456890f, -0.01464406f, -0.06264713f, -0.18417440f, -0.10716041f, 0.11927446f, 
    0.03993322f, -0.09406215f, -0.16686738f, 0.12136341f, -0.10232582f, 0.09707837f, 0.06740642f, -0.22379732f, 
    0.16143014f, -0.06893783f, 0.09148046f, -0.13145351f, -0.03862711f, 0.12480575f, 0.14902499f, -0.50541955f, 
    -0.15660246f, -0.11521953f, -0.00407637f, -0.16404657f, -0.09714177f, 0.56268162f, -0.14086819f, 0.01101904f, 
    -0.21617723f, -0.11195643f, -0.12542896f, 0.42739913f, 0.13925686f, 0.00331416f, -0.03599149f, -0.02121803f, 
    -0.09017523f, 0.18846139f, -0.12555429f, -0.03372035f, -0.06228522f, 0.04436289f, -0.10420640f, 0.12951140f, 
    0.02176462f, -0.10582455f, 0.12268932f, -0.11711668f, -0.25477752f, 0.11954414f, -0.11577947f, -0.28761873f, 
    0.11323439f, -0.18815634f, 0.15493192f, 0.09536187f, -0.38151649f, 0.33937815f, -0.04165072f, -0.13394172f, 
    -0.26222742f, -0.25060889f, -0.02343148f, 0.35712886f, 0.22006704f, 0.01706331f, -0.07587342f, -0.38023064f, 
    -0.45855370f, 0.15167904f, 0.18030888f, -0.00569877f, -0.06285053f, -0.16886543f, 0.09529018f, 0.26856056f, 
    -0.18188293f, 0.10929891f, 0.00242591f, 0.05287472f, 0.04932700f, -0.17932104f, 0.16580367f, 0.16557835f, 
    -0.07501546f, -0.06078862f, -0.19427526f, 0.08715257f, -0.37289977f, -0.15594052f, 0.14118989f, 0.00127931f, 
    -0.30679363f, -0.12444266f, 0.15577509f, 0.01501012f, -0.40588805f, -0.31986544f, 0.13006917f, 0.36260155f, 
    0.19244069f, -0.32438946f, 0.23549697f, 0.00662089f, -0.28485754f, 0.01011826f, -0.05822261f, -0.10561428f, 
    -0.10784673f, -0.06451958f, 0.33059514f, 0.14095609f, -0.08606384f, 0.03558062f, 0.12645960f, 0.23485348f, 
    0.01181219f, -0.15271501f, 0.02761887f, -0.11084978f, 0.27871096f, 0.10588888f, -0.07462764f, -0.18451788f, 
    -0.05133714f, -0.04694216f, -0.14933451f, 0.17265837f, -0.08984467f, 0.11634895f, -0.12900120f, 0.56378931f, 
    -0.04669732f, 0.52468723f, -0.14304392f, 0.06792989f, 0.11166409f, -0.14065821f, -0.16945873f, -0.15920058f, 
    0.39343360f, -0.07596079f, 0.25540116f, -0.08349032f, -0.08252732f, -0.02717008f, 0.25188121f, -0.52668464f, 
    -0.16725996f, 0.16893479f, 0.11415445f, -0.18601727f, -0.17257786f, 0.41277483f, 0.10829239f, 0.05677016f, 
    -0.50099665f, -0.21079309f, 0.13429281f, 0.31453869f, 0.02356336f, -0.04280666f, -0.05038073f, 0.18971033f, 
    -0.63301837f, 0.22654507f, 0.02620035f, -0.21309273f, -0.08781245f, 0.06653155f, -0.05313364f, 0.13376835f, 
    0.12636687f, -0.09213554f, -0.17677079f, -0.12725027f, -0.12988961f, -0.14530674f, -0.06354666f, -0.06140747f, 
    -0.14968036f, 0.01400407f, -0.15791623f, -0.03406751f, -0.11622421f, -0.14454819f, -0.14853689f, -0.09615647f, 
    -0.00742360f, -0.10268034f, 0.02150239f, 0.00520113f, 0.16970591f, -0.16650636f, 0.14668690f, -0.17084295f, 
    0.04630967f, 0.00123006f, 0.13711046f, -0.09629939f, -0.08869711f, -0.06292094f, -0.01915193f, -0.14152190f, 
    -0.18639077f, -0.17580673f, 0.10722151f, 0.16432251f, -0.20561326f, -0.00952961f, 0.04892899f, 0.36896574f, 
    0.18070239f, 0.03334905f, 0.16364510f, -0.25118452f, 0.02161625f, -0.40837675f, -0.08761268f, 0.04079625f, 
    0.58087158f, 0.01031123f, 0.13413854f, -0.09067017f, 0.15630952f, 0.07268370f, -0.06783599f, -0.08629874f, 
    0.19878091f, -0.21298094f, -0.29382148f, -0.08155265f, 0.28236791f, -0.09119894f, -0.05179856f, -0.02414570f, 
    0.13951418f, 0.14357840f, 0.08174367f, -0.10294452f, -0.26515961f, 0.01686611f, 0.03671007f, 0.17038253f, 
    0.18242134f, -0.06950649f, -0.16700260f, -0.33687258f, -0.10463798f, 0.41535011f, 0.09190864f, 0.26066604f, 
    0.65038747f, 0.17252132f, 0.15017375f, 0.25180531f, -0.14288276f, 0.30622247f, -0.02383674f, -0.14607091f, 
    0.25966787f, -0.04550618f, -0.03528218f, 0.13242926f, -0.05827713f, 0.12057015f, 0.06873146f, -0.06835379f, 
    0.21625586f, -0.14584465f, 0.26618972f, -0.16127029f, -0.16360402f, -0.05305802f, 0.03480775f, 0.40489158f, 
    0.11229488f, -0.23214681f, 0.25598386f, -0.29092529f, 0.28339681f, 0.13085441f, -0.14527433f, -0.11789708f, 
    0.04189197f, 0.18921968f, 0.11231952f, 0.15057416f, 0.00059843f, 0.36615577f, 0.02467854f, 0.30842185f, 
    0.06992681f, 0.01944686f, -0.16961361f, 0.01923585f, 0.00829806f, 0.07854973f, -0.03753318f, 0.15051390f, 
    -0.18431953f, 0.13889015f, 0.07408515f, 0.14217694f, -0.59268683f, 0.04280208f, 0.24496835f, -0.08536647f, 
    -0.07005767f, -0.07576694f, 0.16685170f, 0.01724604f, -0.00081314f, -0.47515127f, 0.04921286f, -0.04923433f, 
    0.24510346f, -0.06601739f, 0.09227009f, 0.04626148f, 0.09843938f, -0.02417992f, -0.02823762f, -0.34787387f, 
    -0.15984929f, 0.07612929f, -0.00233232f, 0.11555982f, 0.23320730f, 0.14168414f, -0.01954943f, -0.01545611f, 
    0.35109422f, -0.14421776f, 0.27614444f, 0.10543618f, -0.07510475f, 0.07981696f, -0.11025274f, -0.15200171f, 
    0.16009241f, 0.06250865f, -0.28709048f, -0.15588923f, -0.16158627f, 0.15138642f, 0.16856301f, -0.23561403f, 
    -0.11948957f, -0.29487082f, 0.15175024f, 0.27040032f, 0.31970575f, 0.41709793f, -0.15672672f, 0.14364606f, 
    -0.50897223f, -0.23825158f, -0.57274169f, 0.08468606f, 0.18806997f, 0.03278302f, 0.06834874f, 0.00468102f, 
    -0.10204568f, -0.17252953f, -0.15436354f, 0.10113510f, -0.07180050f, 0.06723169f, -0.18804617f, 0.09473036f, 
    0.15380107f, -0.01723945f, -0.06443316f, -0.14190911f, -0.07525038f, -0.13356683f, -0.09278636f, -0.01616721f, 
    0.07529636f, -0.05030423f, -0.09577782f, -0.01227810f, -0.12402225f, -0.16927205f, 0.11256949f, -0.08359246f, 
    -0.15404382f, -0.02186679f, 0.02553990f, -0.12884890f, 0.01949164f, -0.07378419f, 0.08834790f, 0.12755652f, 
    -0.09029476f, 0.08449614f, -0.13394925f, 0.15085806f, -0.04568086f, -0.08880772f, 0.03534974f, -0.12288938f, 
    -0.10189673f, 0.13154967f, 0.14599235f, -0.03991525f, 0.16373898f, 0.14306132f, 0.06571763f, -0.01885651f, 
    -0.14590649f, 0.17644762f, -0.12894966f, 0.00130271f, -0.16449304f, -0.11973225f, -0.07378718f, -0.00961733f, 
    -0.09782897f, -0.14581358f, -0.13998914f, -0.15627213f, 0.03883749f, -0.03596761f, -0.05215194f, -0.13457543f, 
    0.14281973f, 0.04185549f, -0.11493605f, -0.06987859f, 0.00348704f, 0.09628077f, -0.08230645f, 0.08363473f, 
    -0.12329707f, -0.16529393f, -0.06566561f, -0.16858055f, 0.10932425f, -0.11123417f, 0.00141972f, -0.15088017f, 
    0.07702731f, -0.15054883f, -0.13986526f, -0.02928548f, -0.00713810f, -0.06833534f, -0.00507298f, 0.06825935f, 
    -0.11262889f, -0.10157721f, 0.03355721f, -0.15927534f, -0.11004169f, -0.06510424f, 0.17143337f, 0.15108281f, 
    0.10400859f, -0.07136215f, 0.41203716f, -0.14174369f, -0.33720714f, -0.05353249f, 0.24126323f, -0.26222029f, 
    0.17819588f, 0.20744699f, 0.06053041f, 0.11316161f, -0.00439161f, -0.22179393f, -0.09701514f, -0.22447874f, 
    -0.14957035f, -0.38844573f, -0.12008984f, 0.07371756f, 0.20598659f, -0.01547553f, -0.00801173f, -0.21809155f, 
    -0.38320050f, 0.20833185f, -0.30261531f, 0.13293278f, 0.04146020f, -0.06416717f, -0.04003746f, 0.21921593f, 
    -0.13517585f, -0.10147928f, -0.17034365f, 0.00442238f, 0.10612049f, -0.07325531f, 0.13006082f, 0.01586948f, 
    -0.20585783f, -0.07559873f, 0.07108501f, -0.03093254f, -0.07899278f, 0.09019014f, 0.15897186f, -0.12690945f, 
    -0.05838449f, -0.12144594f, 0.17655824f, -0.06422582f, -0.01418961f, 0.00549899f, -0.10582711f, -0.04816905f, 
    -0.00664045f, 0.00025123f, 0.11408114f, -0.09957672f, -0.17917636f, 0.05771178f, -0.07719144f, -0.18547614f, 
    0.27996984f, -0.12647125f, 0.21265200f, -0.14882796f, -0.19350342f, 0.16334888f, 0.24708900f, -0.47014758f, 
    -0.17382562f, -0.03707240f, -0.03722236f, -0.01438348f, 0.12744570f, 0.56380481f, 0.04323363f, -0.18111737f, 
    -0.16940802f, -0.33718923f, 0.10081781f, 0.10948180f, 0.10019456f, 0.14274003f, 0.10914741f, 0.09308261f, 
    -0.21816167f, 0.20480752f, -0.07383218f, -0.06927583f, -0.17966907f, 0.16999908f, -0.15976590f, 0.17513113f, 
    0.33252656f, -0.16980745f, -0.18010587f, 0.01683695f, -0.03582431f, 0.00113861f, -0.21960808f, 0.12110640f, 
    0.00574323f, 0.00745377f, -0.33910945f, -0.34602320f, -0.13753115f, 0.34057289f, -0.05108967f, 0.11795353f, 
    -0.26228216f, 0.19736087f, -0.08841848f, -0.17680256f, 0.11656617f, 0.35054478f, 0.12188248f, 0.36490187f, 
    -0.37764335f, 0.32222372f, -0.03554836f, 0.18267681f, 0.02513194f, -0.11294322f, 0.03448933f, -0.08907011f, 
    -0.23907198f, -0.11205002f, 0.10762604f, -0.03901829f, -0.15922157f, 0.00249146f, -0.13500178f, -0.37956661f, 
    0.09904909f, -0.12889750f, -0.09613381f, -0.06664145f, 0.11433144f, -0.40094060f, 0.09766532f, 0.15802209f, 
    0.28454727f, -0.08278783f, 0.00855558f, -0.29609779f, 0.22519842f, 0.02005248f, 0.04786917f, 0.55886424f, 
    -0.10405628f, 0.00720446f, -0.12207980f, 0.14940867f, 0.13728406f, -0.16477460f, -0.11532884f, -0.17638911f, 
    0.03013317f, -0.14225820f, -0.07989186f, 0.08127332f, 0.46454492f, 0.16149667f, 0.07288422f, -0.26847416f, 
    0.01772393f, 0.09217453f, 0.07657513f, 0.30571982f, 0.20947644f, -0.23196027f, 0.11542670f, 0.10002294f, 
    -0.51961184f, 0.02956367f, 0.04461244f, -0.09966174f, -0.07078328f, -0.21832508f, 0.14547265f, 0.37748465f, 
    -0.14791651f, 0.22048475f, 0.01897860f, -0.01690038f, 0.06301773f, -0.15822814f, 0.01657110f, 0.00053715f, 
    -0.09504219f, 0.03502093f, -0.03633619f, -0.04071596f, -0.25890931f, -0.08345871f, 0.12730220f, 0.19774570f, 
    0.28490233f, 0.05851264f, -0.05371356f, -0.22308256f, 0.10355335f, -0.13987413f, -0.06775239f, -0.16208215f, 
    0.07383789f, 0.01740262f, -0.11768658f, -0.18720365f, 0.04478392f, 0.02418396f, -0.02278568f, 0.39888814f, 
    0.30829620f, 0.46164814f, -0.11219747f, 0.08119118f, -0.01189405f, -0.06013162f, -0.05434990f, -0.03613511f, 
    -0.02883562f, -0.08180276f, 0.20994623f, 0.08306430f, -0.48138055f, -0.09305099f, -0.21256395f, 0.35045618f, 
    -0.24837799f, -0.34127828f, 0.00994530f, -0.27135539f, 0.09120882f, 0.25699228f, 0.17068157f, -0.29910097f, 
    -0.05552032f, 0.35649887f, -0.14847629f, 0.03929454f, 0.15654004f, 0.21466321f, -0.01752046f, 0.17846677f, 
    -0.06680404f, -0.07418188f, -0.09955811f, 0.10376295f, 0.19552682f, 0.12488210f, -0.15264036f, 0.17753147f, 
    -0.06742449f, -0.14902860f, 0.08981590f, 0.00815031f, 0.07992859f, -0.04094634f, -0.05675511f, -0.12667020f, 
    -0.07733987f, 0.11624562f, -0.03082080f, -0.00214384f, 0.01449135f, -0.19473371f, 0.01301455f, -0.10514411f, 
    -0.16655187f, 0.04842260f, -0.04445308f, -0.03637466f, -0.07680797f, 0.14810450f, 0.11050721f, 0.15772730f, 
    0.00271827f, -0.09338080f, -0.12854287f, -0.01046980f, -0.18238111f, 0.12433569f, 0.01566662f, 0.07060380f, 
    0.08675823f, -0.17307518f, -0.04777772f, 0.07959714f, 0.13597184f, 0.04911625f, 0.12694392f, -0.41655761f, 
    0.15042965f, 0.01496400f, -0.30689988f, -0.18512274f, 0.25863501f, -0.29810527f, 0.14368324f, 0.30796850f, 
    0.15146135f, -0.05474543f, 0.11694568f, -0.14634475f, 0.00836230f, -0.00231716f, 0.02092425f, 0.43645433f, 
    -0.33641970f, 0.05496101f, -0.23887126f, 0.24151780f, 0.23469065f, -0.06608231f, 0.00709564f, -0.39982724f, 
    0.24125066f, -0.13845798f, 0.14315291f, -0.03590459f, 0.29257452f, 0.16961145f, 0.07209244f, -0.05040504f, 
    0.21943429f, 0.08103611f, 0.20679800f, 0.29137972f, 0.39126700f, -0.33192110f, -0.17419411f, 0.25412709f, 
    0.33621427f, -0.23933835f, 0.14319497f, -0.03596087f, -0.13226917f, 0.04927180f, 0.15649809f, -0.08284225f, 
    0.07782835f, -0.32561845f, -0.08594684f, -0.10997743f, 0.17024347f, 0.03269265f, 0.12464354f, -0.29703218f, 
    0.08927244f, 0.03989376f, -0.05747113f, 0.10662573f, 0.12257415f, -0.16050662f, 0.00001837f, 0.03148736f, 
    0.00574382f, -0.06498303f, -0.04552371f, -0.07977965f, -0.12202995f, -0.04664065f, -0.09205502f, -0.14136201f, 
    -0.15078871f, 0.12378636f, 0.03338964f, 0.03073988f, -0.14597046f, -0.11006588f, -0.15132152f, 0.04569367f, 
    0.16736209f, 0.04078610f, -0.10287396f, 0.02809818f, -0.17593829f, -0.08283546f, -0.14520599f, 0.10990025f, 
    -0.11311182f, -0.11683104f, -0.10542193f, 0.16501777f, -0.09644400f, 0.04975511f, 0.05495770f, 0.01970022f, 
    0.02695894f, -0.14081055f, 0.08236305f, -0.13348515f, 0.04673432f, -0.08676441f, 0.02517697f, 0.00163669f, 
    -0.12217593f, 0.05610970f, 0.09935325f, 0.14406057f, -0.15001443f, -0.12937519f, -0.08525222f, 0.13838932f, 
    -0.10717307f, -0.02769316f, -0.02241154f, -0.16736855f, -0.14903577f, -0.07932252f, 0.00750549f, -0.09125517f, 
    -0.19481497f, 0.15171437f, 0.24173653f, 0.12743677f, 0.27189666f, 0.16589311f, 0.07402028f, -0.36117354f, 
    0.11451659f, 0.14594638f, -0.07880828f, 0.11000022f, -0.36644143f, -0.08849353f, -0.13791308f, 0.30558753f, 
    0.20419662f, -0.14674596f, 0.06654500f, -0.36007589f, -0.23547822f, 0.14665930f, 0.10882382f, 0.29474536f, 
    0.09693921f, 0.25882137f, -0.07166329f, 0.13919553f, 0.16073591f, -0.04671374f, 0.10149106f, -0.27416697f, 
    -0.06346071f, -0.11693393f, 0.13827187f, -0.10081989f, 0.30304947f, -0.09578305f, -0.15485884f, -0.09390339f, 
    0.18750465f, 0.06085511f, -0.21719594f, 0.12981842f, 0.12638566f, -0.10997689f, 0.14308205f, 0.06023492f, 
    0.04467316f, -0.34680083f, 0.06670365f, -0.29244253f, -0.11033382f, -0.28566149f, -0.04176485f, -0.14109327f, 
    0.08519057f, -0.05277749f, -0.11561482f, 0.13761564f, 0.23437285f, 0.09652644f, -0.01301905f, -0.20323999f, 
    0.43151337f, -0.06275055f, -0.16240668f, 0.03328254f, 0.40940329f, 0.04377840f, 0.06377397f, 0.14519823f, 
    -0.23311631f, 0.36068681f, -0.23247482f, -0.00663572f, -0.51116598f, 0.35536975f, 0.02077742f, -0.11566067f, 
    -0.38013044f, 0.16632886f, 0.12173293f, -0.02696839f, 0.13296022f, 0.22176477f, 0.10605820f, -0.45015773f, 
    -0.14649706f, 0.18661143f, 0.01778385f, 0.03706165f, -0.00561268f, -0.13712029f, 0.13808830f, 0.28324947f, 
    0.35312998f, 0.00077674f, 0.27397397f, -0.06471634f, 0.25846949f, 0.15925619f, 0.21275862f, -0.14639109f, 
    -0.04130503f, 0.37255406f, 0.05771722f, 0.30433515f, -0.43625250f, -0.21531773f, -0.15713392f, -0.02062543f, 
    -0.25427988f, -0.47401965f, -0.10823373f, -0.17865756f, -0.12042915f, 0.16687959f, -0.02731981f, -0.36421236f, 
    -0.44708899f, 0.24853672f, -0.43414098f, -0.00595327f, 0.02714287f, 0.00547134f, -0.13020916f, -0.00794153f, 
    -0.26340470f, -0.16356680f, 0.04320092f, 0.02761358f, 0.19752623f, 0.00790207f, -0.26830268f, 0.29068130f, 
    -0.08877039f, 0.10531091f, -0.13767241f, -0.25660166f, -0.21893816f, -0.23883863f, 0.00633734f, -0.10669205f, 
    -0.19032021f, 0.01297385f, 0.12784554f, -0.35794085f, 0.03851712f, -0.07556579f, -0.06089007f, -0.12115036f, 
    0.22329929f, -0.12611620f, -0.24648052f, 0.24091503f, 0.19632193f, -0.06553644f, -0.13580258f, -0.05901973f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.17116114f, -0.14541817f, 0.06312883f, 0.01986574f, 0.06695423f, 0.20967484f, 0.07012229f, -0.20068625f, 
    0.17752261f, -0.03571613f, 0.15174857f, -0.12238709f, 0.05604586f, 0.21598063f, 0.06909782f, 0.03798075f, 
    0.13420205f, 0.16733545f, 0.10131883f, -0.04910484f, 0.08700861f, -0.18704237f, -0.04957312f, -0.22033197f, 
    0.22791670f, -0.19586103f, 0.02385867f, 0.11896997f, 0.01333090f, 0.11656995f, 0.00791565f, -0.15367715f, 
    -0.13910803f, -0.20469739f, 0.13239108f, -0.07334866f, 0.02990097f, 0.04658303f, 0.08315975f, -0.09965912f, 
    -0.10679061f, -0.11458967f, 0.16632612f, 0.05333006f, 0.09387343f, -0.05600724f, 0.07800212f, -0.19209807f, 
    0.10827594f, 0.17995206f, 0.09044490f, 0.26366770f, 0.08563775f, -0.13023722f, -0.18786307f, 0.17096581f, 
    -0.01517559f, -0.04835283f, 0.08108398f, 0.08557174f, 0.19241144f, 0.13469701f, 0.06545059f, 0.22064175f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.12075071f, -0.28781775f, 0.08863528f, -0.09404790f, -0.00027770f, -0.02653964f, -0.17041099f, 0.06835620f, 
    0.21470012f, -0.12339114f, 0.00418700f, -0.00548530f, 0.21486790f, -0.09005620f, 0.07429893f, -0.39787024f, 
    -0.13353911f, 0.16852726f, 0.09207944f, 0.07191651f, -0.31228787f, -0.07142664f, 0.09096651f, 0.00873421f, 
    0.23084073f, 0.01026539f, 0.10309547f, 0.28001615f, -0.28194284f, 0.14112368f, 0.16166997f, 0.13206229f, 
    -0.15826358f, -0.09443995f, 0.13171135f, 0.20817840f, -0.12400207f, -0.03896071f, 0.26404506f, -0.15187363f, 
    0.15065512f, 0.05041816f, -0.09236563f, -0.03888692f, 0.08333192f, -0.03942370f, 0.16738428f, -0.01081811f, 
    -0.02061496f, -0.13724796f, 0.09900068f, 0.00396078f, 0.07887627f, -0.08081623f, 0.07737444f, 0.03507801f, 
    0.24306557f, -0.01832656f, 0.03007513f, -0.00318483f, 0.21059002f, -0.01733472f, 0.14559837f, -0.06945228f, 
    0.20498770f, -0.29870778f, -0.10942524f, 0.31570846f, -0.27337563f, 0.05648159f, -0.12634729f, -0.08237833f, 
    0.01509050f, 0.06172732f, 0.16423613f, 0.12141943f, 0.03901494f, 0.00612695f, 0.07268034f, 0.11512126f, 
    -0.17422260f, -0.00913841f, 0.23776205f, -0.09351046f, 0.01472170f, -0.01453335f, -0.13100830f, 0.06388606f, 
    0.26754060f, 0.05706963f, -0.09647069f, 0.32041276f, -0.02574706f, -0.06134076f, -0.13814372f, 0.04736687f, 
    -0.83832413f, 0.12266310f, 0.14585853f, -0.32694820f, -0.45890290f, 0.02713114f, 0.06650014f, 0.37583071f, 
    -0.10649942f, -0.25773799f, -0.77293193f, -0.02665774f, 0.05613679f, 0.02864867f, -0.03395493f, 0.10073126f, 
    -0.39157107f, -0.08350036f, 0.06732650f, -0.23075479f, 0.15519911f, -0.48988014f, -0.01551569f, 0.20666154f, 
    0.08336004f, 0.10488336f, -0.01968031f, 0.26645654f, 0.17872292f, 0.17949098f, -0.46033311f, 0.07884558f, 
    0.22808534f, -0.17326681f, 0.08268049f, 0.01826157f, -0.13742924f, -0.46987265f, -0.11637419f, 0.05366376f, 
    0.21850856f, 0.05774019f, 0.04710856f, 0.07017472f, -0.10531892f, 0.22698592f, 0.06632964f, -0.10964444f, 
    -0.14200144f, 0.12156130f, -0.02167612f, 0.05638068f, 0.14572892f, 0.03744407f, -0.04668441f, 0.02055125f, 
    0.12624684f, 0.15015841f, 0.10589115f, 0.10067612f, 0.13117123f, -0.21515559f, 0.08423673f, 0.00500241f, 
    0.28764889f, 0.30628067f, 0.70043987f, 0.11024904f, 0.56525075f, -0.00768800f, -0.00929411f, 0.09440994f, 
    -0.08202949f, 0.22168100f, -0.31585500f, 0.10895596f, 0.09887987f, 0.00360136f, 0.09952634f, 0.13294484f, 
    0.18295498f, -0.19099911f, -0.37899512f, -0.03220014f, -0.01440367f, -0.62072915f, 0.10819027f, -0.01664746f, 
    -0.17370725f, -0.08808351f, -0.10118100f, 0.21311691f, 0.05503245f, 0.17396308f, 0.15346165f, -0.00761526f, 
    0.14914685f, 0.04896974f, 0.09091224f, 0.16503474f, 0.17407359f, 0.04215968f, 0.13809510f, -0.00710790f, 
    -0.03493616f, 0.10543195f, -0.05394832f, 0.06475192f, 0.32153779f, 0.31174576f, -0.03517058f, -0.01639303f, 
    -0.18205348f, -0.05286825f, 0.15735263f, -0.02296750f, -0.09510805f, -0.08526245f, 0.29015854f, 0.12072358f, 
    -0.19470020f, 0.06407569f, -0.00703829f, 0.16204955f, 0.13221772f, -0.14589466f, -0.08414554f, -0.00000960f, 
    -0.04250468f, 0.20979896f, 0.20486233f, -0.09648691f, -0.01054203f, -0.04690810f, -0.08837727f, 0.17116815f, 
    0.11500293f, 0.09382081f, -0.10356071f, -0.06346603f, 0.06955557f, -0.00093834f, -0.23982421f, -0.05544779f, 
    -0.02645744f, 0.24085192f, -0.33702049f, 0.01456019f, -0.01886190f, 0.19582444f, -0.06402452f, -0.21269494f, 
    -0.07426131f, 0.11613767f, -0.09619340f, -0.33678135f, -0.28847748f, 0.41126087f, -0.02137084f, 0.08163851f, 
    -0.12215395f, 0.32246384f, -0.08512839f, -0.07055899f, -0.18349497f, 0.19636010f, 0.31882200f, -0.00470545f, 
    0.18959354f, -0.11663671f, -0.12108536f, 0.11382304f, 0.19823062f, 0.37131232f, 0.11567616f, 0.20340997f, 
    0.07944572f, 0.17567211f, 0.13273562f, -0.00860437f, 0.23421155f, -0.08460666f, 0.08690410f, 0.03417452f, 
    -0.17735803f, -0.02430258f, -0.01400601f, -0.41782522f, -0.21704872f, -0.00785702f, 0.06333287f, -0.29388773f, 
    0.08886485f, -0.08441527f, -0.26037675f, 0.07392702f, -0.18439887f, -0.02856304f, 0.00923729f, -0.01063066f, 
    0.06761590f, -0.31192365f, 0.18572649f, -0.00605692f, 0.09018656f, 0.00989093f, 0.02104899f, 0.05570804f, 
    -0.04288037f, 0.19857121f, 0.20664470f, -0.31979036f, 0.01189574f, 0.41882703f, 0.01078740f, -0.06950270f, 
    -0.38201979f, -0.06167104f, -0.05428006f, 0.01237392f, -0.07914044f, 0.16027068f, -0.24896899f, 0.27977455f, 
    -0.07693090f, -0.12122702f, 0.21015936f, 0.09508911f, 0.06973078f, -0.14412400f, -0.13747318f, 0.04968974f, 
    0.11063672f, 0.09098566f, -0.10248698f, -0.05928504f, -0.26765463f, -0.10516226f, -0.00254591f, 0.01469509f, 
    -0.17389870f, 0.10141668f, 0.05332715f, 0.03266647f, 0.17050727f, -0.09998458f, 0.18447469f, 0.06819163f, 
    -0.14632693f, 0.12081970f, -0.01082813f, -0.14723659f, 0.01867965f, -0.07751194f, 0.08683412f, -0.05340943f, 
    0.25359100f, 0.00666669f, 0.19361807f, 0.18158978f, 0.34412307f, 0.11430620f, -0.12267197f, 0.22063075f, 
    0.20260456f, -0.29791278f, -0.18952949f, -0.03698194f, -0.09446520f, 0.08161864f, -0.18558683f, 0.01950588f, 
    0.03143797f, 0.01746452f, -0.25702754f, 0.08222383f, 0.22633646f, 0.00705865f, 0.00758690f, 0.13005853f, 
    -0.22069429f, -0.02351354f, 0.00834045f, 0.06670915f, -0.08694626f, 0.09792132f, -0.13235442f, -0.14021431f, 
    -0.13184299f, -0.02643850f, -0.02819812f, -0.12045404f, -0.02459663f, 0.07489991f, 0.00885281f, -0.01957892f, 
    -0.09406067f, -0.06232513f, -0.09448333f, 0.11885288f, 0.04113165f, -0.11994545f, -0.10346910f, -0.13921416f, 
    -0.09679441f, -0.01409915f, -0.07988749f, 0.02261333f, -0.11054998f, 0.00035088f, -0.07806182f, -0.09209248f, 
    -0.10266331f, 0.01081456f, -0.04375508f, 0.07517746f, -0.10911699f, -0.08637062f, 0.05537581f, 0.01250110f, 
    -0.00624941f, -0.08888913f, 0.04362644f, -0.08841564f, -0.11797918f, 0.00631042f, -0.01644532f, 0.04763101f, 
    -0.00726989f, 0.03625200f, -0.08296509f, 0.10728744f, 0.08611515f, 0.02555281f, -0.08780400f, -0.04658374f, 
    0.06307526f, 0.08083600f, -0.08577228f, 0.02794367f, 0.00822689f, 0.00044803f, -0.09654045f, 0.02234828f, 
    -0.08658515f, 0.07126477f, -0.01276998f, 0.08872417f, -0.14687164f, -0.10782254f, -0.11089921f, 0.12257703f, 
    0.21632349f, -0.04764917f, -0.06439410f, -0.00962332f, -0.11112364f, 0.40225229f, -0.08202995f, -0.02300856f, 
    0.16288006f, -0.10763595f, -0.16975871f, -0.09850650f, 0.39591014f, -0.11463019f, 0.06200334f, -0.18061750f, 
    0.02424437f, 0.12207606f, 0.08592581f, 0.09357832f, -0.13209550f, -0.07814257f, 0.01648260f, -0.01524322f, 
    0.22708438f, 0.11328407f, 0.03322389f, -0.01562316f, -0.22292776f, 0.13360766f, 0.23983105f, 0.07503479f, 
    -0.37075508f, -0.17230311f, -0.05340109f, 0.15451682f, -0.38495752f, 0.05930136f, 0.40655544f, -0.10730999f, 
    0.16149329f, 0.55053478f, 0.07044233f, 0.08298670f, -0.07075404f, -0.01892038f, 0.14491215f, 0.05591680f, 
    -0.19047965f, -0.07230912f, 0.32895073f, -0.09217308f, 0.11921812f, 0.11373281f, -0.06976816f, -0.08174404f, 
    0.10041347f, -0.03115309f, -0.09761396f, -0.14953396f, 0.11864735f, -0.19215287f, 0.14190030f, 0.21370812f, 
    0.00946745f, 0.05639059f, 0.08173636f, 0.02183586f, 0.08713448f, -0.15318136f, -0.13637722f, -0.01456271f, 
    0.20510073f, -0.16084337f, -0.05196408f, 0.05928540f, 0.05092157f, 0.00649860f, 0.14240439f, 0.04171414f, 
    0.04019633f, 0.14565107f, 0.11179473f, 0.15794875f, -0.00279938f, 0.02430307f, 0.06350532f, -0.00974289f, 
    0.10933098f, 0.02394539f, 0.07704248f, -0.10302710f, -0.13366723f, -0.06427238f, 0.08584418f, 0.31643519f, 
    -0.24858813f, -0.45154712f, 0.32161063f, 0.37841359f, -0.12149287f, 0.08889340f, 0.00846361f, -0.55699694f, 
    -0.05095523f, -0.16577879f, 0.07687127f, 0.05153400f, 0.11033341f, 0.09703021f, 0.16297325f, -0.07526585f, 
    -0.14663407f, 0.16336618f, 0.47639504f, 0.17562065f, 0.09067021f, -0.20649920f, 0.08111972f, 0.24153823f, 
    0.16000907f, -0.12761986f, -0.08037016f, 0.11445071f, 0.14681716f, -0.06438904f, -0.04632043f, 0.08972909f, 
    0.13557056f, -0.18170847f, -0.22158009f, 0.18001141f, -0.37388408f, 0.38023248f, 0.16528225f, 0.10560054f, 
    -0.09136499f, 0.06817912f, 0.04500884f, -0.10062447f, 0.42774901f, 0.35638514f, -0.02799234f, 0.05689524f, 
    0.08570715f, -0.06108072f, -0.01729140f, -0.10438704f, 0.11236686f, -0.02037365f, -0.08993840f, -0.11913893f, 
    0.28915432f, 0.00081721f, -0.08185514f, -0.01989794f, -0.23041187f, 0.24153459f, -0.00324241f, 0.05940157f, 
    -0.09856422f, 0.15748662f, -0.21351433f, -0.21413545f, -0.09637009f, 0.10305259f, -0.03364059f, -0.00045373f, 
    -0.05448803f, -0.07790403f, 0.15122350f, -0.11090254f, -0.08764727f, -0.00041747f, 0.01552765f, -0.06929121f, 
    -0.15084088f, 0.13994066f, 0.19998837f, -0.05476416f, 0.00526900f, -0.15195996f, -0.04729383f, 0.14942023f, 
    -0.09896892f, -0.11785430f, 0.07011312f, 0.22888979f, 0.04733010f, 0.14924653f, 0.18339908f, 0.12107987f, 
    -0.02975014f, 0.13616958f, 0.07483759f, 0.09755214f, -0.01278265f, -0.08642346f, -0.16588415f, -0.01052635f, 
    -0.04801165f, 0.00956593f, -0.03927752f, 0.06634559f, -0.38507405f, 0.01992052f, -0.09651274f, 0.09841865f, 
    0.22781721f, 0.17187236f, 0.01578302f, -0.11632180f, 0.06346245f, 0.06041421f, 0.23230737f, -0.05708081f, 
    -0.13079642f, -0.10043788f, -0.04499275f, -0.00078300f, 0.24510776f, 0.10406675f, -0.01484800f, -0.07725394f, 
    0.14379768f, -0.06985984f, -0.02239740f, 0.11892375f, 0.21635641f, 0.11925554f, -0.19119278f, 0.12413257f, 
    0.05715428f, -0.04455604f, 0.18316002f, -0.06651273f, 0.05683121f, -0.03189993f, -0.02892366f, 0.14846818f, 
    0.23404667f, 0.22407024f, -0.22452551f, 0.07372448f, -0.02878253f, 0.17832696f, -0.06227294f, 0.04433978f, 
    0.01746418f, 0.12656707f, 0.03754798f, 0.04472737f, -0.09334732f, 0.22465345f, 0.08041902f, -0.25437871f, 
    0.19551967f, 0.21235897f, -0.09415786f, 0.02654521f, 0.09676769f, 0.12018330f, 0.19427891f, -0.07321858f, 
    0.08555958f, -0.04728814f, -0.15131554f, -0.02916330f, 0.37575567f, 0.48754671f, 0.01935976f, -0.01093083f, 
    -0.04652660f, -0.09002235f, 0.07877423f, 0.05418787f, -0.22920515f, -0.04744050f, 0.01770629f, -0.15379377f, 
    0.14475155f, -0.08124562f, -0.07061165f, -0.12573370f, -0.21313688f, 0.04641800f, 0.24716590f, 0.05910597f, 
    -0.24356751f, 0.14024647f, -0.08090863f, -0.06335758f, -0.26227555f, 0.10238808f, 0.00924248f, -0.44569278f, 
    -0.10742244f, 0.22199148f, 0.14000739f, -0.01178634f, 0.02069352f, 0.04521558f, 0.19688380f, 0.07975580f, 
    -0.02893973f, -0.05401214f, 0.10417660f, 0.17491937f, -0.07108108f, 0.06949044f, 0.02595396f, 0.14065789f, 
    0.04964091f, -0.01437259f, -0.10108617f, 0.05323769f, 0.05849547f, 0.04414177f, 0.11369560f, 0.13044433f, 
    0.24812545f, -0.02628434f, 0.04848677f, 0.06391086f, 0.06705493f, 0.08926368f, 0.19264625f, -0.04375011f, 
    0.22852141f, -0.02496901f, 0.17971578f, -0.11169218f, 0.48887435f, 0.29015300f, -0.07894124f, 0.04513260f, 
    -0.29590526f, -0.00295872f, -0.11819982f, 0.07119666f, 0.10599179f, -0.07028865f, -0.01492619f, -0.09866915f, 
    0.07434002f, -0.09099917f, 0.05944842f, -0.04474803f, -0.02160827f, -0.03790714f, -0.14491150f, 0.05655252f, 
    -0.40912578f, 0.01413231f, -0.05212687f, -0.13190708f, -0.02958608f, -0.08916731f, 0.16786155f, -0.02204608f, 
    0.03941552f, 0.07235461f, -0.09575018f, -0.00089242f, 0.04394135f, -0.01528803f, -0.10142848f, -0.11272664f, 
    -0.49776775f, -0.03078995f, -0.11254635f, 0.23876393f, -0.02743628f, -0.37768728f, -0.03066843f, -0.18105260f, 
    0.15595350f, 0.08052272f, -0.03497672f, 0.14810114f, 0.16077608f, -0.12037905f, -0.09591918f, 0.27128997f, 
    0.26896477f, 0.16162471f, -0.18364955f, 0.05825984f, -0.17052518f, 0.28876299f, 0.21981534f, 0.11878499f, 
    0.11747412f, 0.04361607f, -0.11581439f, 0.01330179f, 0.37480524f, 0.12548552f, -0.06574729f, 0.24745694f, 
    0.06200926f, 0.11329091f, 0.14424659f, -0.03638960f, 0.09851704f, 0.02272142f, 0.13050337f, -0.07083034f, 
    0.29263881f, -0.03972796f, 0.00226544f, -0.24689817f, -0.27765897f, 0.06941583f, 0.03356592f, -0.05999067f, 
    -0.23044270f, 0.13452935f, -0.15749942f, 0.05225074f, 0.01159576f, -0.04219069f, 0.19563539f, -0.17649174f, 
    -0.14212798f, 0.16406739f, -0.08914244f, 0.01719348f, -0.08187630f, -0.00678515f, 0.11110638f, 0.05068733f, 
    -0.13325761f, -0.07398294f, 0.09405075f, 0.05565277f, 0.12643826f, -0.08093092f, 0.09051581f, -0.07034869f, 
    -0.16399176f, 0.08057737f, 0.00412887f, 0.21802267f, -0.06982885f, 0.05841072f, 0.16506110f, 0.40640479f, 
    0.06602048f, 0.22459504f, -0.17030379f, -0.13334548f, -0.09400811f, -0.07385178f, 0.29160592f, -0.00576839f, 
    0.04573376f, 0.03988702f, -0.19259682f, 0.09565960f, 0.02680544f, 0.04202235f, -0.06218260f, 0.03394121f, 
    0.19215766f, 0.03666214f, 0.16289954f, 0.02813009f, -0.03457234f, 0.05284999f, 0.14324121f, 0.01764948f, 
    -0.23056674f, 0.06197542f, 0.03520039f, -0.28352013f, 0.13125989f, 0.01808588f, 0.03722850f, -0.26152557f, 
    -0.00869071f, 0.30027175f, 0.09949853f, 0.12548156f, 0.03810739f, -0.09526148f, -0.00609983f, 0.05059823f, 
    0.13631986f, -0.00439220f, -0.02727872f, 0.05857380f, -0.08235915f, -0.11115426f, 0.07103350f, -0.03413178f, 
    0.18896084f, 0.00589988f, 0.27584553f, -0.10444720f, 0.07593794f, 0.64724922f, -0.07304627f, -0.02002492f, 
    -0.37438509f, -0.07175054f, -0.12076873f, -0.13124017f, -0.01889947f, 0.03100292f, -0.08464963f, -0.09438606f, 
    -0.04402007f, -0.27890921f, 0.03879564f, 0.14184436f, 0.05871252f, -0.08626705f, -0.21635628f, -0.13258651f, 
    0.20513780f, -0.05486963f, 0.06184442f, -0.04132923f, 0.21762811f, 0.15223074f, -0.05896915f, -0.18223308f, 
    -0.18829693f, 0.29102015f, -0.01860225f, -0.12375462f, -0.05720328f, 0.13185741f, -0.11476192f, 0.01164628f, 
    0.30009720f, -0.03709595f, 0.02910954f, 0.23278670f, 0.07494994f, -0.10951068f, -0.02802105f, 0.29691425f, 
    -0.01383974f, -0.06790166f, 0.10734526f, 0.10503704f, 0.33742392f, 0.04888487f, -0.20321602f, -0.12529436f, 
    -0.06956089f, -0.17556322f, -0.08817866f, -0.00396013f, 0.00727849f, 0.01475264f, 0.16500737f, -0.03859952f, 
    0.00791585f, 0.16355157f, -0.27197614f, 0.07525071f, 0.14446452f, -0.39262849f, 0.13289385f, 0.06669096f, 
    -0.03943657f, 0.09008955f, 0.00037231f, 0.16415198f, 0.13545312f, 0.45203269f, 0.46263638f, 0.16178198f, 
    0.21057566f, -0.16620734f, -0.12925033f, 0.21283036f, -0.14790142f, 0.23595928f, 0.00239109f, -0.07343615f, 
    0.04155694f, 0.06268073f, 0.16395690f, 0.08919804f, 0.13665269f, 0.09566922f, -0.07938631f, 0.24851474f, 
    -0.20682018f, -0.04780455f, 0.12010052f, -0.01266184f, 0.13427348f, 0.02561715f, 0.06126174f, -0.03628196f, 
    0.18699786f, -0.09412211f, -0.03552836f, 0.09459314f, 0.01306499f, -0.07014507f, -0.57464093f, 0.02639816f, 
    0.01333159f, -0.10484750f, -0.05314963f, -0.22426014f, 0.01124896f, 0.06473523f, -0.00919899f, 0.07229820f, 
    -0.07484491f, -0.17034143f, -0.70048648f, -0.11124776f, -0.02073486f, 0.09749876f, -0.41974953f, -0.09866738f, 
    -0.00493017f, 0.03229277f, 0.17672989f, -0.03011030f, 0.17375189f, -0.07938358f, 0.01073967f, -0.01280002f, 
    -0.05109579f, -0.02884088f, 0.01751170f, -0.10935284f, 0.00398216f, 0.07402139f, -0.44858956f, 0.11845189f, 
    -0.17527422f, 0.10030483f, -0.00596461f, -0.12302315f, 0.06495439f, -0.24689719f, -0.03374550f, 0.00956540f, 
    0.09217383f, 0.04608581f, -0.21789613f, 0.04161450f, -0.18194522f, -0.03937047f, -0.06341703f, -0.03124611f, 
    0.08282830f, 0.10866276f, 0.05437548f, 0.09072082f, -0.00138737f, -0.13249193f, 0.02569771f, -0.05620836f, 
    -0.20402384f, 0.07009209f, -0.12913568f, -0.06056665f, 0.36559290f, 0.19211933f, 0.22155593f, -0.24814314f, 
    0.35829011f, 0.13253348f, 0.03563346f, 0.12657589f, 0.08120856f, -0.12456772f, -0.15333264f, 0.18883087f, 
    0.22541232f, -0.04844913f, 0.11798690f, -0.02420202f, -0.11910364f, -0.06922700f, 0.07956878f, -0.05815199f, 
    0.24379033f, 0.12526038f, -0.11604727f, -0.38048661f, 0.18095681f, 0.49965462f, 0.08051625f, 0.08050792f, 
    -0.10362125f, -0.07834502f, -0.08659343f, -0.24175537f, -0.23893102f, 0.03742015f, -0.07232507f, -0.15655528f, 
    0.02772241f, -0.22485466f, -0.11885080f, 0.08069773f, -0.44158477f, 0.11075803f, 0.11517939f, -0.04992858f, 
    0.27884752f, -0.02650782f, 0.03448107f, -0.07265596f, 0.28326645f, 0.15500726f, 0.07292125f, 0.04709108f, 
    -0.14797199f, 0.04159232f, 0.08935901f, 0.09165712f, 0.10141029f, 0.08380073f, -0.10359699f, 0.02202920f, 
    0.14406833f, -0.02453047f, 0.05498327f, -0.22609890f, -0.17654161f, 0.10548811f, -0.14481167f, -0.19616930f, 
    -0.15877771f, -0.17631541f, -0.10855182f, -0.14525864f, -0.31372958f, 0.04723158f, 0.34327751f, 0.05709660f, 
    -0.13732979f, 0.06436308f, -0.12971540f, 0.10297951f, -0.06981108f, -0.04915318f, 0.04851009f, -0.07153912f, 
    -0.23093064f, 0.00077044f, 0.09062888f, -0.19547485f, 0.12029938f, 0.03681122f, -0.08660942f, 0.10139660f, 
    0.07357807f, -0.02824954f, 0.10672545f, 0.14903618f, 0.19470558f, -0.07931033f, -0.14284344f, 0.31552830f, 
    0.04539338f, 0.05283641f, 0.12577455f, 0.00920306f, 0.07884257f, -0.07231860f, -0.35413867f, -0.00553819f, 
    -0.03563756f, 0.32981247f, 0.15481478f, -0.03857362f, 0.02368137f, -0.31760409f, -0.07313249f, -0.12842487f, 
    0.02280803f, -0.07282795f, 0.15017366f, 0.04104288f, 0.02709467f, -0.11393082f, 0.00409725f, -0.12588401f, 
    -0.06718561f, -0.05266368f, 0.03087370f, 0.30210406f, 0.11138186f, 0.09106306f, -0.01554261f, 0.01957011f, 
    -0.16027635f, -0.23908333f, 0.15136448f, -0.09529021f, 0.09093415f, 0.03626870f, 0.12561065f, 0.21532872f, 
    0.10436916f, 0.08613545f, -0.08650992f, 0.05918326f, 0.07773119f, -0.12460190f, -0.11208829f, -0.14213036f, 
    0.12301630f, 0.09054094f, -0.20448942f, -0.05727474f, 0.00768512f, -0.01383410f, 0.07540494f, -0.08755618f, 
    -0.06187820f, -0.10142618f, -0.09808621f, -0.06067883f, -0.22757290f, 0.34461111f, 0.25909272f, -0.09575114f, 
    0.06000597f, -0.00299669f, -0.05030548f, -0.10928738f, -0.02089135f, -0.15884151f, 0.42434347f, -0.05666577f, 
    0.29893747f, -0.08396997f, -0.31678635f, 0.07581350f, 0.09093937f, 0.11700335f, 0.03539567f, 0.03474269f, 
    0.06041931f, 0.01190266f, -0.00336833f, 0.02004497f, 0.09524676f, -0.04894969f, -0.07825921f, 0.01025435f, 
    -0.20757282f, -0.09246284f, 0.08527528f, -0.48567566f, -0.30452529f, -0.11706170f, -0.04147698f, -0.08573996f, 
    0.27912036f, 0.09923863f, 0.11821911f, 0.20571128f, -0.09174288f, -0.10453923f, 0.06688001f, -0.13573745f, 
    0.19038317f, 0.21344903f, 0.11532999f, 0.02314360f, 0.07552934f, 0.12324545f, 0.20857218f, 0.04517549f, 
    -0.00441656f, 0.18667974f, 0.31446275f, -0.05737161f, 0.20208679f, 0.34368682f, -0.16250522f, 0.12696663f, 
    -0.38377813f, -0.09540921f, -0.08528787f, -0.15673645f, -0.11846163f, 0.05030465f, -0.24985166f, -0.02315214f, 
    -0.10995260f, -0.12382871f, 0.19670771f, -0.14934027f, 0.15034983f, 0.10368629f, 0.06415634f, -0.05723419f, 
    0.21583921f, -0.16617511f, -0.16520213f, 0.01613806f, 0.04944467f, -0.04571979f, -0.08012693f, -0.15108508f, 
    0.44243163f, 0.14348137f, 0.02467832f, 0.02987459f, -0.24391304f, 0.12476365f, -0.11753673f, 0.08617976f, 
    0.06641731f, 0.05740053f, -0.01675649f, 0.20528498f, -0.08735189f, 0.06515356f, 0.34398943f, 0.05483360f, 
    -0.28168255f, -0.09179538f, -0.12703772f, 0.19814768f, -0.21471243f, -0.06613718f, 0.14679356f, -0.24262966f, 
    0.15009806f, -0.01870493f, 0.38892609f, -0.03506835f, -0.11731812f, -0.06451517f, 0.13274491f, -0.03716186f, 
    -0.11737505f, 0.22667852f, 0.31362712f, -0.03531276f, 0.17070833f, -0.05961245f, -0.01053276f, 0.25570419f, 
    -0.00214867f, 0.06638220f, -0.11135258f, 0.08222386f, 0.07976501f, -0.12722969f, 0.53294468f, -0.12998900f, 
    0.08557961f, 0.08204588f, 0.12826221f, -0.08776229f, -0.01112726f, 0.12514879f, 0.12910171f, -0.03845638f, 
    -0.00604395f, 0.28442785f, 0.13819575f, 0.05029978f, -0.21367247f, -0.09334452f, 0.13948646f, -0.03737777f, 
    0.18680114f, -0.03611314f, 0.18693693f, 0.04101285f, 0.19151798f, 0.11442406f, 0.08371983f, -0.06212142f, 
    -0.11394446f, 0.02886435f, -0.04951064f, 0.40525043f, 0.33173198f, 0.17708425f, -0.04602059f, -0.23356828f, 
    0.20514069f, 0.24228922f, -0.12125860f, -0.07743547f, 0.43054587f, 0.02540743f, 0.08067376f, 0.45923084f, 
    0.09729236f, 0.13639206f, 0.17485555f, -0.11395904f, 0.06563599f, 0.11689897f, 0.06618531f, -0.01960282f, 
    0.24143171f, 0.18643872f, -0.36297598f, -0.22018965f, -0.10481523f, 0.26529074f, -0.02288137f, -0.15845108f, 
    -0.06578793f, -0.00500635f, 0.03753734f, -0.00640134f, -0.26074642f, 0.46068481f, 0.45742217f, -0.15807346f, 
    0.05534152f, 0.36680561f, 0.09911518f, 0.11970377f, 0.09351014f, -0.00125097f, -0.02844358f, 0.05483829f, 
    -0.20598689f, 0.19655889f, 0.21511249f, 0.03898478f, -0.51470923f, -0.35717681f, -0.02221963f, 0.33889154f, 
    0.18776798f, 0.07481457f, 0.11361455f, -0.00801676f, 0.24542436f, 0.06525091f, 0.10119865f, -0.02462599f, 
    -0.10414812f, -0.11858402f, -0.02340761f, -0.26838788f, 0.26871562f, 0.01223402f, -0.15371129f, -0.21632473f, 
    -0.13006647f, -0.27352431f, -0.06993233f, -0.01222404f, -0.31836420f, 0.05180468f, 0.13858712f, 0.16342922f, 
    0.12799285f, 0.00035129f, 0.07768491f, -0.10444471f, -0.02220682f, 0.11914685f, -0.15288757f, -0.01026359f, 
    -0.09261815f, -0.01164349f, 0.37038991f, -0.06362861f, -0.12326068f, 0.44060171f, 0.09572659f, 0.07800376f, 
    0.06606758f, -0.03638539f, 0.04457605f, 0.13856696f, -0.25626937f, -0.02011510f, 0.02811657f, -0.03128804f, 
    -0.05804941f, 0.10112949f, 0.23187491f, -0.08596951f, -0.06219961f, -0.14809927f, 0.23118286f, -0.02469321f, 
    0.00696371f, 0.00999332f, 0.07226226f, -0.01281464f, 0.00396017f, 0.09059350f, 0.07560647f, 0.11508065f, 
    -0.25421512f, 0.32986853f, 0.12739247f, 0.10275911f, -0.02931343f, 0.06223463f, 0.08357894f, -0.05046988f, 
    -0.07038572f, -0.02923917f, 0.11749047f, 0.12176546f, 0.13141452f, -0.24353108f, -0.25011677f, 0.17486617f, 
    -0.25081801f, -0.32905462f, 0.52804494f, 0.27144966f, 0.20121109f, -0.09822759f, -0.06065116f, -0.14104687f, 
    0.02805246f, -0.51442695f, -0.38288143f, -0.04132149f, -0.07836843f, 0.07610910f, -0.26639605f, 0.00970529f, 
    0.00196049f, 0.14001194f, -0.05260860f, 0.18967244f, 0.17448562f, 0.16947120f, -0.05921911f, 0.06769003f, 
    0.00075570f, -0.11576906f, -0.06499226f, -0.05681220f, -0.17570616f, 0.08568810f, -0.23242693f, 0.17813201f, 
    0.15922190f, 0.13942267f, -0.24543297f, 0.26451883f, -0.07876947f, 0.13266674f, 0.65000105f, -0.05554869f, 
    -0.10259125f, 0.00722258f, 0.12107398f, 0.07560776f, 0.02246906f, 0.28230882f, 0.02618613f, 0.33663601f, 
    0.12284973f, -0.00857119f, 0.00753779f, -0.06260556f, 0.27131060f, 0.04059124f, 0.00724060f, -0.01482051f, 
    0.21004960f, 0.11669672f, -0.10643102f, -0.20726319f, -0.01391439f, -0.10000969f, -0.22389218f, -0.12849019f, 
    0.10657034f, 0.29881230f, 0.23531772f, -0.02341438f, 0.14145985f, -0.09018119f, -0.11922220f, 0.18971618f, 
    -0.15481876f, 0.20437452f, 0.07415962f, 0.03245506f, -0.07478949f, 0.08973071f, -0.02731686f, -0.09989551f, 
    0.11953607f, 0.03715750f, 0.06875146f, -0.06949624f, 0.14507565f, -0.00226078f, -0.00600567f, -0.00287785f, 
    -0.23425113f, -0.05436365f, 0.05512966f, 0.16475849f, -0.10694867f, 0.12714739f, -0.23209006f, -0.07992687f, 
    0.16902083f, -0.06727285f, 0.01762886f, 0.23103331f, -0.17545635f, 0.18199106f, -0.08473369f, -0.06512179f, 
    -0.15754424f, 0.07411896f, -0.10749924f, 0.00642745f, 0.45202023f, 0.15805386f, -0.04424845f, 0.10106237f, 
    0.02943593f, -0.07672516f, 0.09233350f, -0.06987634f, 0.08068927f, -0.05225982f, 0.07913361f, -0.00847820f, 
    0.04434333f, 0.12318193f, -0.04192273f, -0.06539202f, 0.06875727f, 0.16784917f, -0.13950548f, 0.15300333f, 
    -0.34288570f, -0.14875625f, -0.46741855f, -0.22346893f, -0.21384831f, -0.06360225f, 0.18723743f, 0.02930020f, 
    -0.00294865f, 0.08494642f, 0.16347936f, -0.09842188f, -0.02651959f, 0.12090780f, 0.02421311f, -0.02397298f, 
    -0.25570980f, -0.04309171f, -0.12087439f, 0.08522090f, -0.08208415f, -0.08269594f, 0.12862398f, 0.08621673f, 
    0.09668923f, 0.10307782f, -0.02428022f, -0.01634552f, 0.09586431f, 0.20400058f, 0.18984151f, 0.15808995f, 
    0.04218485f, 0.01431325f, 0.10161470f, -0.36185592f, 0.26372129f, -0.21207772f, 0.00050573f, 0.02755189f, 
    -0.05928325f, 0.18643169f, -0.08915720f, -0.05506648f, 0.00368303f, 0.24257345f, -0.13219564f, -0.31249902f, 
    0.18244629f, 0.00978943f, -0.22611237f, -0.04900781f, -0.40988478f, 0.00710822f, -0.02412310f, 0.02092152f, 
    -0.03645899f, -0.07995673f, -0.01822555f, 0.19934100f, -0.06679943f, 0.11957231f, 0.24155933f, 0.09155505f, 
    0.27967405f, 0.32116765f, -0.18625584f, 0.08032122f, 0.50370687f, -0.00901148f, -0.37941930f, -0.28288758f, 
    -0.09426742f, -0.11200190f, 0.11712821f, 0.03541982f, -0.08006513f, 0.03076732f, 0.14170076f, 0.00219269f, 
    0.32305384f, -0.04479905f, -0.31571397f, -0.02999220f, 0.06332250f, -0.05170365f, -0.03680546f, -0.12816726f, 
    0.04210167f, -0.05040006f, 0.03032713f, -0.13263930f, -0.14050169f, 0.01097147f, 0.16802908f, -0.11089274f, 
    0.01320445f, -0.13076605f, -0.34576961f, -0.01013030f, -0.32752421f, 0.19283512f, 0.48626119f, 0.03434838f, 
    0.25400469f, 0.12227480f, -0.07272765f, -0.10448554f, 0.57016033f, 0.44829780f, -0.03083378f, 0.00437212f, 
    -0.11048947f, -0.03214940f, 0.10209262f, -0.09898579f, -0.07564574f, -0.14442943f, 0.31753740f, 0.09887434f, 
    -0.02147237f, 0.10387263f, 0.05102826f, -0.25515980f, -0.31047243f, 0.03050703f, -0.08370617f, -0.31219208f, 
    0.05637758f, 0.05995784f, -0.08447034f, -0.02923463f, -0.11700922f, 0.02947547f, 0.24669287f, 0.10559834f, 
    0.08693051f, 0.21508190f, 0.27153894f, 0.06501003f, -0.12266804f, 0.00799102f, 0.10972464f, -0.06438176f, 
    -0.02333991f, 0.09451331f, 0.21722433f, -0.38370147f, 0.03205843f, 0.33205843f, 0.07682184f, 0.00742267f, 
    -0.49412796f, -0.09011328f, -0.02684240f, -0.29167935f, 0.06484117f, 0.24853085f, -0.08513403f, 0.40043688f, 
    0.12466191f, -0.12100363f, 0.15950422f, -0.05211385f, 0.11883777f, 0.18453483f, -0.44209611f, -0.04758998f, 
    0.07163255f, 0.33739123f, 0.18281309f, -0.05541070f, 0.27313304f, -0.28772002f, -0.06626469f, -0.27002361f, 
    -0.16416940f, -0.09134891f, 0.28457373f, -0.05645194f, 0.04982375f, 0.02018611f, -0.00937382f, 0.04740888f, 
    -0.07920668f, -0.03140009f, 0.01028990f, 0.50478595f, -0.08640735f, 0.04755445f, 0.29840225f, -0.11470991f, 
    0.01204922f, -0.06105288f, -0.14819345f, -0.04194055f, -0.10339294f, 0.04052991f, 0.33874822f, 0.14266527f, 
    0.17715369f, -0.00392254f, 0.10041286f, 0.04578776f, 0.06377366f, -0.07552890f, -0.09014015f, 0.04093803f, 
    -0.06192921f, -0.10949410f, -0.49296191f, -0.07386112f, 0.10461084f, 0.19354168f, 0.14663300f, -0.19689897f, 
    0.17112821f, 0.01264823f, 0.09421803f, -0.16320287f, -0.03731805f, 0.01605747f, 0.06708194f, -0.04119604f, 
    -0.10843509f, 0.02783891f, 0.05593008f, 0.07589199f, -0.11756301f, 0.04796723f, 0.07365505f, -0.04229701f, 
    -0.09587204f, -0.10413051f, -0.01112956f, 0.03838485f, 0.09780236f, 0.09986389f, 0.06003948f, -0.09412711f, 
    -0.09865839f, -0.07516964f, -0.11420130f, -0.06771296f, -0.07106668f, -0.08069840f, 0.02743162f, -0.04924446f, 
    -0.12572666f, -0.11603969f, 0.00589775f, 0.00794073f, -0.00949545f, 0.10799512f, -0.10371313f, -0.01859904f, 
    -0.03101104f, 0.00466003f, 0.07864221f, -0.07218128f, 0.01612536f, 0.04591173f, 0.08164091f, 0.00916786f, 
    0.03271999f, -0.03166387f, 0.07427260f, -0.01410933f, -0.00108537f, 0.08256577f, 0.01059570f, -0.02284385f, 
    0.07004437f, -0.09919730f, 0.09691905f, -0.04819870f, 0.04678012f, -0.01926596f, 0.03332353f, -0.02666917f, 
    0.03068901f, -0.04208837f, -0.06078701f, -0.07576142f, -0.00954549f, -0.07114594f, -0.10477282f, -0.02290686f, 
    0.22201869f, -0.02669025f, 0.14177850f, -0.18938161f, 0.19601616f, -0.40393236f, -0.12910509f, -0.04566968f, 
    0.17810832f, 0.11844605f, 0.21488617f, -0.11405672f, -0.43278974f, -0.36399058f, -0.04462049f, -0.07237994f, 
    0.08674385f, -0.14505239f, -0.31930801f, 0.16250823f, 0.20574281f, 0.10974519f, -0.08784296f, 0.05921412f, 
    -0.06546115f, -0.11404277f, -0.09747013f, 0.28934273f, 0.23476747f, -0.19233149f, 0.09748176f, 0.18799531f, 
    -0.07811203f, 0.13300277f, 0.08736438f, 0.07450515f, -0.09199711f, 0.00181700f, -0.12315606f, -0.23313040f, 
    0.00756342f, 0.16246793f, -0.10284632f, 0.06102257f, 0.05087602f, -0.09680790f, -0.01948488f, -0.09048994f, 
    0.01243939f, -0.19240613f, 0.03306914f, 0.08275725f, 0.01222964f, -0.04849305f, -0.04001553f, -0.26019135f, 
    0.20664506f, -0.06919787f, 0.00248678f, 0.27202675f, -0.22920504f, -0.63132161f, 0.12444367f, -0.34167871f, 
    0.03809233f, -0.09532630f, -0.00432749f, -0.09820714f, -0.06386245f, 0.09544697f, 0.10089128f, 0.09506138f, 
    0.06951380f, -0.00327165f, -0.03804773f, -0.10558151f, -0.14733520f, -0.00665918f, -0.12266420f, -0.13409515f, 
    0.07241014f, -0.14913529f, -0.04580812f, 0.04892077f, -0.08863292f, 0.01893155f, 0.00665155f, -0.09981191f, 
    -0.04076239f, 0.04208221f, 0.11032093f, -0.01947724f, -0.06103683f, 0.07654224f, -0.01801448f, -0.04573834f, 
    0.01670105f, 0.05622224f, 0.06726050f, -0.04883996f, 0.08817077f, -0.10184564f, 0.03761913f, 0.04593118f, 
    0.00776155f, 0.08516397f, -0.03422882f, -0.09193888f, -0.02409944f, 0.08260883f, -0.15152049f, -0.00927582f, 
    0.03942345f, -0.06362335f, 0.09119321f, -0.15941465f, 0.03394163f, -0.04414101f, 0.02570242f, 0.05364163f, 
    0.02016321f, 0.08426954f, 0.09426576f, -0.08890294f, 0.00729043f, -0.07411425f, -0.09619576f, -0.12485246f, 
    -0.17027169f, 0.10466895f, -0.14068288f, -0.08897295f, -0.11358543f, -0.05964547f, 0.39231557f, -0.09647785f, 
    0.06225163f, 0.00604407f, -0.23224300f, 0.05629545f, 0.18865857f, 0.11508864f, 0.02606211f, 0.34019154f, 
    -0.03572528f, 0.11619581f, 0.18089543f, -0.12040312f, 0.23023479f, -0.01222771f, 0.15432732f, 0.12500903f, 
    -0.06675998f, 0.02840552f, -0.11097038f, -0.43156937f, -0.19468877f, 0.10539886f, -0.09636250f, -0.42752543f, 
    0.15924986f, 0.16509387f, -0.15832905f, 0.23228581f, -0.17060752f, -0.08687449f, 0.06870575f, 0.42523870f, 
    0.02600113f, 0.10818987f, 0.16205890f, 0.10620563f, -0.07810806f, -0.07200395f, -0.04756448f, 0.07258409f, 
    0.15577738f, 0.17843600f, 0.22845466f, -0.29778403f, -0.00374259f, 0.51637751f, -0.12020705f, 0.03350844f, 
    -0.46897489f, -0.12295941f, 0.09383410f, -0.18810582f, -0.12949298f, 0.03324286f, -0.33098254f, 0.22701234f, 
    -0.10589108f, -0.13463940f, -0.03911741f, -0.01555993f, 0.03433267f, 0.00082454f, -0.01945184f, -0.00737716f, 
    -0.11106877f, 0.08659861f, 0.01555968f, 0.07114148f, -0.13653156f, -0.08507010f, -0.02808324f, -0.05737194f, 
    0.02648655f, 0.04874416f, -0.06671143f, 0.06834926f, -0.09274065f, 0.05445449f, 0.01812374f, -0.01259276f, 
    0.03433414f, -0.05340509f, -0.09352416f, 0.04430687f, 0.03608475f, -0.12065111f, -0.08682691f, -0.02111585f, 
    0.06891134f, -0.08986142f, 0.00297143f, 0.07873340f, -0.07018491f, 0.07900847f, 0.06025567f, -0.09126274f, 
    -0.07584804f, -0.06011947f, -0.09230636f, 0.07094107f, -0.09934054f, 0.07991055f, -0.00561620f, -0.07924695f, 
    0.07523361f, -0.01162950f, 0.08991963f, -0.07172428f, -0.13657488f, -0.12478864f, 0.11565919f, -0.09658731f, 
    -0.01541840f, 0.04339547f, -0.05154981f, 0.10017771f, -0.03384691f, 0.10312354f, 0.06932495f, 0.11094533f, 
    -0.15153642f, 0.09123515f, -0.11758760f, -0.04168373f, -0.05011600f, 0.08995853f, -0.09768379f, 0.04835722f, 
    -0.08801778f, 0.05913474f, -0.06321131f, 0.00107951f, -0.10746937f, 0.06153710f, 0.08402397f, -0.08923677f, 
    -0.03351960f, 0.01466768f, 0.02872407f, -0.02727620f, -0.12716736f, -0.05408518f, 0.03043075f, 0.00511567f, 
    0.05258275f, 0.07068300f, -0.08554472f, -0.09797224f, 0.05421205f, -0.09425596f, -0.08091540f, -0.05751899f, 
    -0.12092528f, 0.02403244f, -0.10032983f, 0.01659828f, -0.12670603f, -0.12261143f, -0.00067090f, -0.08214682f, 
    0.01438275f, -0.07539555f, 0.04084260f, 0.03679404f, 0.02771659f, -0.07204922f, 0.00948326f, -0.09871352f, 
    -0.00772853f, -0.13280231f, 0.05227425f, -0.06180182f, 0.02437332f, -0.14958699f, -0.05048759f, -0.06190557f, 
    -0.08041121f, -0.06335492f, 0.04689246f, -0.11379007f, 0.04740362f, -0.03149340f, -0.01143845f, 0.00582655f, 
    0.04461608f, -0.18181431f, -0.24820763f, 0.16394641f, -0.14087959f, 0.48964581f, 0.18021627f, -0.11119536f, 
    -0.03628780f, -0.11544616f, -0.04436993f, 0.08221394f, 0.45443359f, 0.39533594f, -0.04449289f, 0.23790166f, 
    0.16198751f, 0.14581475f, -0.01124401f, -0.15096018f, -0.11652108f, 0.09075884f, 0.07733361f, -0.02480508f, 
    0.39420223f, -0.10473764f, -0.04957981f, -0.08561242f, -0.24695389f, 0.16795063f, 0.05452928f, 0.03957358f, 
    -0.21206926f, -0.23325361f, -0.01169558f, -0.02451145f, -0.32639089f, 0.07365544f, -0.00118754f, -0.33828247f, 
    -0.02553794f, -0.35016498f, 0.23708048f, -0.00373145f, 0.10125148f, -0.10158661f, 0.15292533f, -0.03528299f, 
    -0.21333906f, 0.23833266f, 0.31374195f, 0.06828389f, -0.00361535f, -0.26832482f, -0.07624001f, 0.23904052f, 
    0.03865626f, -0.00644214f, -0.10341696f, 0.21911062f, 0.10049535f, -0.01918620f, 0.30357677f, 0.25833565f, 
    0.20637205f, -0.05673261f, -0.01372381f, 0.07838389f, -0.13526690f, 0.30691606f, -0.11675742f, 0.11261329f, 
    0.23959491f, 0.28990486f, 0.05401855f, 0.10620481f, 0.48920542f, 0.15582755f, 0.10556626f, -0.00795839f, 
    -0.16023745f, 0.02103505f, 0.12310601f, 0.15383379f, 0.07953938f, -0.07084716f, 0.10208134f, 0.09073591f, 
    0.01171804f, -0.00928082f, -0.07430389f, 0.28411230f, -0.16959105f, -0.01409374f, 0.13975653f, 0.00782882f, 
    -0.14974648f, -0.13528106f, -0.20832430f, -0.07551602f, -0.36827856f, -0.01229127f, 0.13565727f, -0.01735952f, 
    0.01649987f, 0.05508420f, -0.02877891f, 0.06701419f, 0.01817304f, -0.01988272f, 0.00236729f, 0.11377348f, 
    -0.11084904f, -0.13761546f, -0.27443859f, -0.05081579f, -0.12354012f, 0.08494465f, 0.05800121f, -0.14254873f, 
    0.06949551f, -0.00024374f, 0.02216871f, 0.05831434f, 0.09757426f, 0.27867168f, 0.23204201f, 0.24506326f, 
    0.02289712f, -0.07055812f, -0.12170663f, -0.12101576f, 0.01294812f, 0.08170487f, -0.01297309f, 0.10864585f, 
    -0.10145158f, -0.09309568f, 0.00534456f, -0.07235983f, -0.05117311f, -0.07042696f, 0.10797134f, -0.05379425f, 
    -0.09975514f, -0.07406654f, -0.04476747f, 0.12385669f, 0.04686235f, -0.01041633f, 0.03687408f, 0.09332153f, 
    -0.15194133f, 0.01279967f, -0.11815272f, 0.00717525f, -0.13020688f, -0.10146056f, -0.01222830f, -0.18332498f, 
    -0.00069638f, -0.10463095f, 0.06102176f, -0.06057445f, -0.09925458f, 0.01769258f, 0.05340891f, -0.08861836f, 
    -0.01191619f, -0.07492828f, 0.07010601f, -0.02259168f, -0.01802836f, -0.11757857f, -0.11948489f, 0.00027889f, 
    -0.05585647f, 0.04887040f, -0.13666366f, -0.00864744f, -0.06767280f, 0.09541130f, 0.08567207f, -0.04569882f, 
    -0.02981371f, 0.02591018f, 0.10656889f, -0.08352615f, -0.07481745f, 0.00447800f, -0.01067927f, -0.09302078f, 
    0.05577909f, 0.15488407f, -0.12970176f, 0.11910654f, -0.33111280f, 0.32753530f, 0.10208236f, 0.08964729f, 
    0.07333082f, 0.17008603f, 0.08093064f, 0.03924994f, 0.36473879f, 0.39528632f, 0.07807489f, 0.10724980f, 
    -0.02714638f, 0.13172889f, -0.02024288f, 0.08904520f, -0.05976048f, -0.01225519f, 0.08010314f, -0.10785367f, 
    -0.02340714f, -0.01163875f, 0.09090073f, -0.06457906f, -0.28512660f, 0.13645364f, -0.10470116f, -0.09536017f, 
    -0.05636445f, 0.03553268f, -0.07018691f, 0.07565921f, -0.22480306f, -0.03888160f, 0.02717623f, -0.24027996f, 
    -0.04090014f, -0.19241333f, 0.05765006f, -0.03341365f, 0.04595155f, -0.09894632f, 0.06902765f, 0.02135801f, 
    -0.19663112f, 0.05404640f, -0.11684805f, -0.04787409f, -0.01834820f, 0.16618556f, -0.05187260f, 0.11295325f, 
    -0.24969514f, -0.02768944f, 0.07876839f, -0.09556145f, -0.03146759f, 0.27651268f, 0.09891973f, 0.29494205f, 
    -0.06543245f, -0.12433098f, 0.06866992f, 0.10736675f, -0.26356536f, 0.07271843f, -0.35786277f, 0.01956458f, 
    -0.15700100f, -0.15679018f, 0.13542180f, -0.11433166f, -0.24630688f, -0.36306491f, -0.00725054f, 0.05941202f, 
    0.18018366f, -0.14884326f, 0.17785889f, 0.03930899f, -0.05092435f, 0.07365872f, 0.02722099f, -0.16780731f, 
    0.28020188f, -0.10268446f, -0.09596545f, 0.39056289f, 0.19955021f, 0.18057935f, 0.11364810f, -0.17017613f, 
    -0.21476717f, 0.05260063f, 0.23804155f, 0.04060192f, 0.03994671f, -0.05262695f, -0.01974691f, 0.25018886f, 
    0.04757881f, 0.05899443f, 0.05188836f, 0.00409827f, 0.09659085f, -0.02824782f, 0.03693656f, -0.05272552f, 
    0.11272420f, 0.03334185f, -0.12269152f, -0.14704168f, -0.10192456f, -0.34988710f, -0.00197283f, 0.22562142f, 
    -0.00065983f, 0.01694864f, -0.05982529f, -0.03809355f, 0.12658899f, 0.24077454f, 0.27256960f, -0.19438128f, 
    -0.10984083f, 0.22018166f, 0.19020721f, -0.06183048f, 0.04828353f, -0.12296204f, 0.01413631f, -0.06193876f, 
    0.03777421f, 0.08049164f, 0.14579804f, 0.06586407f, -0.23092182f, -0.37973660f, 0.03144254f, -0.11910288f, 
    0.03480379f, 0.10619142f, 0.23120242f, 0.00286618f, 0.25366715f, -0.16914374f, 0.15725231f, 0.01599248f, 
    0.10620463f, 0.05629921f, 0.07792827f, -0.06534955f, 0.11491042f, 0.18745044f, 0.20528010f, -0.12867799f, 
    -0.13016099f, -0.22929074f, 0.45513561f, 0.16684042f, -0.19650123f, -0.00381710f, 0.17354448f, 0.37885737f, 
    0.21928576f, -0.17194878f, 0.20163581f, -0.09884194f, 0.01155336f, -0.07366517f, 0.09718999f, -0.05485821f, 
    0.06746578f, 0.08208318f, 0.17638277f, -0.15479340f, 0.16861667f, 0.55883521f, -0.09593897f, 0.14429882f, 
    0.11237586f, 0.08592999f, -0.04008533f, -0.02243236f, -0.08247960f, -0.16254714f, -0.05064140f, -0.13894776f, 
    -0.20625225f, 0.21052855f, -0.02572466f, 0.00479277f, 0.13735510f, -0.08620027f, -0.04652789f, -0.05267150f, 
    -0.18352270f, -0.03018928f, -0.14536887f, -0.00896247f, -0.17900625f, -0.00556962f, 0.03142565f, 0.00700094f, 
    0.40406343f, 0.12242693f, 0.17323235f, -0.05699946f, -0.04599842f, -0.10082863f, -0.01953174f, 0.06276467f, 
    0.10991365f, 0.07182446f, 0.00790526f, -0.11992811f, 0.19523571f, 0.13540474f, -0.00943625f, -0.19459969f, 
    -0.11434410f, 0.27218091f, -0.17898871f, 0.14747983f, -0.16104248f, -0.06510475f, 0.04656370f, 0.10995419f, 
    0.00495109f, -0.04433741f, 0.28227571f, 0.08004260f, 0.07696863f, -0.01340184f, 0.18850847f, 0.13393730f, 
    -0.11443420f, 0.24792394f, 0.03538469f, -0.06807337f, 0.07595104f, 0.17708434f, 0.06581703f, 0.19086771f, 
    0.04788060f, 0.01563807f, -0.07928836f, 0.17549621f, -0.21860984f, 0.10013770f, 0.19169100f, 0.02251250f, 
    0.02507795f, -0.10646515f, 0.01763509f, 0.12907223f, 0.08382482f, 0.03267403f, -0.17281573f, 0.01857284f, 
    -0.14216523f, 0.20476331f, 0.08786083f, 0.12240183f, -0.02957666f, 0.18451001f, 0.10937542f, 0.09436843f, 
    -0.11050919f, 0.10232040f, 0.06530226f, 0.07024040f, -0.23718296f, 0.03650907f, -0.03148705f, -0.05207714f, 
    0.03105992f, 0.04898638f, -0.00170076f, 0.44999269f, -0.02741507f, 0.04224691f, 0.10219644f, 0.13131471f, 
    0.29192588f, 0.35968167f, -0.25796762f, -0.12542549f, 0.41822565f, -0.01139414f, -0.35760072f, 0.09071396f, 
    -0.03917646f, -0.12925294f, 0.08171323f, -0.03275441f, 0.06891800f, -0.12296316f, 0.00400373f, 0.08707353f, 
    0.10738855f, 0.10023483f, -0.43793690f, 0.06487643f, 0.01506331f, -0.14596857f, 0.01383693f, 0.00227666f, 
    0.04640357f, 0.06124445f, -0.09561230f, -0.14435151f, -0.12852471f, 0.57225072f, 0.27036539f, -0.19260599f, 
    0.06659019f, 0.10219951f, -0.08655070f, 0.24640188f, -0.26893201f, 0.17382199f, 0.09083287f, 0.02213384f, 
    0.04973501f, 0.05231986f, -0.01364405f, 0.10779174f, -0.17133817f, -0.23894252f, -0.02166063f, 0.26609108f, 
    0.09830619f, -0.09419948f, 0.08922796f, 0.09405632f, 0.31334442f, 0.15410121f, -0.16402484f, 0.09534790f, 
    0.19271128f, 0.09236441f, 0.03074172f, 0.10648400f, 0.21217899f, 0.14078921f, -0.38329607f, -0.17695391f, 
    -0.62427014f, 0.20311299f, -0.00891602f, -0.10122438f, -0.39689443f, -0.11914526f, 0.21364793f, 0.57312518f, 
    -0.02439279f, 0.01891781f, -0.36772341f, -0.09960479f, 0.06485654f, -0.10735366f, -0.25444394f, 0.04949160f, 
    -0.51613605f, 0.17654856f, -0.01091099f, -0.20294534f, 0.15899634f, -0.13591513f, -0.11371532f, -0.04635853f, 
    -0.05652995f, -0.08362062f, 0.10152230f, 0.09894117f, -0.17921253f, 0.03980577f, -0.34479985f, 0.07009345f, 
    0.19461024f, -0.23909344f, -0.04266391f, 0.09946319f, -0.25405502f, 0.26502410f, 0.18354987f, 0.06643357f, 
    0.23680104f, -0.08438956f, 0.05330562f, -0.10742998f, 0.47735241f, 0.18646201f, -0.04487044f, -0.03524746f, 
    -0.07763571f, 0.07959019f, 0.09350830f, -0.04917093f, -0.10732683f, -0.06357270f, -0.01672034f, -0.03311038f, 
    0.33622223f, -0.01199069f, 0.11180185f, 0.03384198f, -0.30919117f, 0.17092717f, -0.01583646f, 0.02172038f, 
    -0.33876210f, -0.05262783f, 0.12311278f, -0.04716987f, -0.24288513f, 0.09708723f, 0.20146960f, -0.11858056f, 
    -0.06410822f, -0.05744753f, 0.03169258f, -0.07522865f, -0.09412202f, 0.04869492f, 0.05098891f, -0.00952620f, 
    -0.20574284f, -0.09346782f, 0.18455216f, 0.13379298f, 0.12347007f, -0.31696218f, 0.04048900f, 0.14591232f, 
    -0.04990280f, 0.10662615f, 0.06669235f, 0.26927677f, 0.18253623f, 0.03295144f, 0.09342652f, 0.19715428f, 
    0.15974484f, -0.43493438f, 0.17880519f, -0.18509635f, -0.00629639f, 0.08523858f, -0.19408195f, 0.10605289f, 
    0.17153580f, 0.13374083f, 0.04440164f, -0.05282158f, 0.09857731f, -0.86843801f, 0.11039785f, -0.06732311f, 
    -0.09613940f, -0.01424358f, 0.24208263f, 0.06420562f, 0.06720383f, 0.04587630f, -0.00183478f, -0.08483349f, 
    0.09205631f, 0.08982076f, 0.08962651f, 0.40960488f, -0.03844607f, 0.15668510f, 0.24143349f, -0.06455410f, 
    -0.17791007f, -0.06863958f, 0.01730551f, 0.06198737f, -0.42934817f, -0.01624848f, 0.56858450f, 0.38201430f, 
    0.26271567f, 0.15001790f, -0.02209674f, 0.07316494f, 0.01208535f, -0.02984476f, 0.19488119f, 0.03218187f, 
    -0.26522139f, -0.00971119f, -0.28928381f, -0.36749956f, 0.13839248f, 0.33665371f, -0.06808298f, -0.09944396f, 
    0.23840040f, -0.11627962f, -0.09658411f, 0.03036387f, -0.04418184f, -0.19579893f, -0.25951082f, 0.01307371f, 
    0.13195837f, 0.39952180f, 0.19153507f, 0.12055653f, -0.05562179f, -0.13206679f, -0.06644326f, -0.08979087f, 
    -0.04043345f, 0.26438582f, -0.11676899f, 0.05131696f, -0.16560920f, 0.10330395f, 0.05377115f, 0.14088142f, 
    -0.01214025f, 0.27770221f, -0.06344044f, -0.02919691f, 0.28053185f, -0.06254362f, -0.05837132f, 0.01220873f, 
    -0.02370739f, -0.11142752f, -0.06061032f, -0.17320487f, 0.16182703f, -0.20473114f, -0.35748503f, 0.21874715f, 
    -0.04986113f, -0.30092540f, -0.16019163f, 0.05310459f, 0.02564822f, 0.04650770f, -0.18735225f, -0.08407550f, 
    0.15436396f, -0.07021037f, -0.21258439f, -0.03391311f, -0.10442283f, 0.03537327f, -0.22307819f, 0.11103571f, 
    -0.02552439f, 0.31324643f, 0.03449640f, 0.11809466f, 0.07129452f, 0.11264357f, 0.07549191f, -0.08514624f, 
    -0.14064458f, -0.04712249f, 0.02039738f, 0.15475467f, -0.10560964f, 0.28342634f, -0.05290717f, 0.13461711f, 
    -0.08156087f, 0.14314599f, -0.06332587f, 0.21854411f, 0.21694644f, -0.05841754f, -0.26690140f, 0.11647450f, 
    -0.17329615f, -0.11017020f, 0.03985236f, -0.06653808f, -0.48621085f, -0.10723016f, -0.10357746f, 0.37853163f, 
    0.11986939f, 0.17178501f, 0.01603699f, -0.02318545f, 0.09848435f, 0.09761634f, -0.03543771f, 0.11948543f, 
    0.07839321f, -0.10488653f, -0.00797720f, -0.11052231f, 0.14043289f, 0.10154746f, -0.12017687f, 0.04834450f, 
    -0.01167022f, -0.14535649f, -0.02209526f, 0.09368038f, 0.22880167f, -0.06269877f, -0.12062889f, 0.26336253f, 
    -0.05365766f, 0.13001333f, -0.12530608f, 0.09482862f, -0.00582319f, -0.00487199f, -0.01726835f, 0.03284812f, 
    0.23784879f, 0.14621465f, 0.34171405f, 0.07533309f, 0.05529054f, -0.26555121f, 0.07253591f, 0.34158233f, 
    0.11818001f, -0.07235046f, 0.12160635f, 0.16401149f, 0.06591420f, -0.21710002f, -0.19263722f, -0.22916302f, 
    -0.12179031f, 0.15793379f, 0.12552890f, -0.14559744f, 0.13673714f, -0.38902074f, 0.15952028f, -0.01819797f, 
    0.02309134f, 0.19004680f, -0.08511813f, -0.01148184f, -0.08739048f, 0.26477784f, -0.05473300f, -0.22718386f, 
    -0.12762761f, 0.07252479f, -0.16617475f, -0.07310135f, -0.28566623f, -0.01676621f, 0.12132305f, 0.04915932f, 
    -0.08582377f, 0.03882099f, -0.05629346f, 0.16546625f, -0.12601252f, -0.05266399f, 0.05876315f, -0.05454198f, 
    0.37904626f, 0.28011644f, 0.00921465f, -0.03603997f, 0.26276398f, -0.05933540f, -0.26048893f, 0.08003594f, 
    -0.03649318f, 0.11334968f, 0.02332897f, -0.06462712f, 0.01538575f, 0.06044957f, 0.13009465f, 0.02019846f, 
    0.18958159f, 0.07631074f, -0.41999513f, -0.03761612f, -0.08914843f, -0.01241085f, -0.00693777f, -0.05930105f, 
    0.04885629f, -0.01478201f, 0.12176065f, 0.00366070f, -0.12826650f, 0.10133737f, 0.18813300f, -0.27936742f, 
    0.00641048f, 0.01802957f, -0.24075113f, 0.29315290f, -0.13166530f, 0.12099234f, -0.04542411f, -0.03963771f, 
    0.01634969f, -0.02437404f, 0.15600984f, 0.01192915f, -0.02153290f, -0.05526365f, 0.00416395f, 0.26364928f, 
    0.07495081f, -0.13827126f, 0.30279413f, 0.05863817f, 0.04421885f, 0.02372443f, 0.09049815f, -0.02162750f, 
    -0.07286950f, -0.09987122f, 0.06525808f, 0.12699361f, 0.06982447f, -0.03725471f, -0.54244995f, 0.04189355f, 
    0.04080517f, -0.15668878f, 0.16177638f, -0.17832825f, -0.08139490f, 0.07034746f, 0.14213093f, 0.29178581f, 
    -0.03405671f, -0.03084775f, -0.60343766f, -0.01181732f, 0.08486828f, -0.03233938f, -0.33441633f, -0.02086848f, 
    -0.06120669f, 0.08338775f, 0.02112774f, -0.04062496f, -0.01424856f, 0.31147110f, 0.01416354f, 0.17956556f, 
    -0.12895809f, 0.01202948f, -0.06301296f, -0.03382905f, 0.07073428f, 0.12421560f, -0.58275360f, 0.09857695f, 
    -0.16021375f, 0.35631064f, 0.01065603f, -0.03332666f, 0.05157250f, -0.15414281f, 0.00956837f, 0.01424927f, 
    0.02023682f, 0.19751185f, -0.25726274f, -0.08184199f, -0.30422765f, 0.03770477f, -0.07332189f, 0.08021586f, 
    0.26063091f, -0.00705973f, -0.13802677f, -0.06132391f, -0.07701318f, 0.06848856f, -0.01851083f, -0.08940078f, 
    -0.02633105f, -0.08506238f, 0.11328562f, -0.13926028f, -0.12054817f, -0.03885942f, 0.25854200f, -0.13823186f, 
    0.51718533f, 0.21936211f, -0.02319639f, 0.18565463f, 0.40546313f, -0.01376751f, -0.33671176f, -0.08201776f, 
    0.05932072f, -0.04760323f, 0.16897264f, -0.01794459f, -0.00156258f, -0.11409907f, 0.24488194f, 0.11828546f, 
    0.31314084f, 0.19823764f, -0.04860651f, -0.14740616f, 0.16337438f, 0.12997742f, -0.03975957f, 0.06116134f, 
    -0.16783635f, -0.06856979f, -0.11962198f, 0.11294451f, -0.14047934f, 0.06664062f, 0.06292573f, -0.34836265f, 
    0.08885632f, -0.07540085f, 0.03840900f, 0.29482612f, -0.17490575f, 0.07989527f, -0.41606551f, -0.09248895f, 
    -0.00134733f, -0.14637393f, 0.04544276f, -0.01352642f, -0.29201001f, -0.15947534f, 0.05472114f, 0.31829360f, 
    -0.03033443f, 0.15993768f, 0.02287255f, 0.00387764f, 0.18952492f, -0.04691844f, -0.16202430f, -0.12720989f, 
    0.01557362f, -0.04838910f, -0.08231458f, -0.03730622f, -0.06642390f, 0.01210494f, -0.03422056f, 0.17590328f, 
    0.07545061f, -0.24485087f, -0.11733934f, 0.07220309f, 0.42704809f, 0.00992119f, -0.03508884f, 0.19675224f, 
    -0.04886857f, -0.31720871f, -0.00817882f, 0.08258117f, 0.06942777f, 0.03162020f, -0.05269497f, -0.04902521f, 
    0.11127097f, 0.23519984f, 0.13990179f, -0.04291311f, 0.07057004f, -0.45909065f, 0.02482458f, 0.22514202f, 
    -0.01529027f, -0.08552804f, 0.04422979f, 0.15332863f, 0.21962912f, -0.04701928f, 0.10335583f, -0.16591658f, 
    -0.38097316f, 0.25486630f, 0.06840312f, -0.26994500f, 0.09366188f, -0.41431040f, -0.04293248f, 0.02100310f, 
    -0.11268255f, 0.08689197f, -0.34102958f, -0.10590057f, -0.01212390f, 0.06352285f, -0.10521461f, -0.62367785f, 
    -0.07700285f, 0.09289370f, -0.08884083f, 0.06781076f, -0.29431915f, -0.04684545f, -0.03028847f, 0.06348908f, 
    -0.63156635f, -0.00309631f, -0.09199682f, -0.02916193f, -0.13957486f, 0.13663331f, 0.12827767f, -0.12021323f, 
    0.26138684f, 0.29222330f, -0.07993121f, 0.08140033f, 0.16066782f, -0.00044216f, -0.32137027f, 0.20129237f, 
    0.11768419f, -0.00778650f, 0.09525754f, -0.07942695f, -0.11162789f, 0.06068498f, -0.06570614f, 0.02286857f, 
    0.07406569f, 0.12834729f, -0.40227640f, -0.21899451f, -0.04607860f, 0.13016139f, -0.00757557f, -0.07290608f, 
    -0.23890465f, -0.00086419f, 0.09119152f, -0.33981815f, -0.14236428f, 0.17930242f, -0.48132935f, -0.36066890f, 
    -0.04816503f, 0.03472463f, 0.03019001f, -0.09303904f, -0.08666241f, 0.06198221f, -0.09617227f, -0.06984790f, 
    0.08605599f, 0.00863322f, -0.10662124f, 0.10912865f, -0.10827920f, 0.04530905f, 0.10925306f, 0.05035574f, 
    -0.10947512f, 0.11963469f, -0.08552925f, -0.08096828f, -0.16144294f, -0.04759362f, -0.02754425f, -0.03814782f, 
    -0.11900942f, 0.09666711f, 0.01999149f, -0.00057186f, 0.06620409f, -0.07249309f, -0.05963260f, -0.09488349f, 
    -0.02949135f, -0.10589331f, 0.00843078f, -0.01531135f, -0.06301935f, 0.03224061f, 0.03728038f, 0.05200205f, 
    -0.15811795f, 0.04202279f, 0.04254119f, -0.09382044f, 0.11970246f, -0.03939429f, -0.12077729f, 0.09418415f, 
    -0.07898654f, -0.09284097f, -0.11854362f, 0.06969957f, 0.05383261f, 0.05409401f, 0.09765603f, -0.11878406f, 
    -0.03035609f, 0.10226700f, 0.01117881f, -0.03140953f, -0.06420628f, -0.11151932f, 0.08509392f, 0.08084919f, 
    -0.00471968f, -0.06118269f, 0.13702431f, -0.01224053f, -0.07162864f, 0.19119737f, -0.11077685f, 0.01382403f, 
    0.08138054f, -0.28583649f, 0.21456516f, -0.06751978f, -0.30474189f, -0.59963393f, 0.01547324f, -0.03183794f, 
    0.21779963f, -0.06780739f, 0.04327699f, -0.03210147f, 0.24821603f, -0.02389455f, 0.00490942f, -0.10194091f, 
    0.04754827f, -0.00959340f, 0.11786851f, -0.05783767f, 0.19684970f, 0.11339454f, 0.16143225f, -0.21520683f, 
    -0.33212894f, -0.22771741f, 0.09295349f, 0.04292019f, -0.12743497f, 0.04513276f, 0.38903743f, 0.28582045f, 
    0.03563335f, 0.01120731f, 0.12212558f, 0.11755655f, 0.11384070f, 0.11990188f, 0.09852844f, 0.08276251f, 
    -0.16963939f, -0.07460752f, 0.43303493f, -0.11461624f, 0.01707567f, -0.18057080f, 0.02124961f, 0.32026780f, 
    0.26039115f, 0.00231718f, 0.10237110f, 0.30105659f, 0.17378922f, -0.38158572f, 0.22944598f, 0.01485396f, 
    0.04057075f, -0.14950794f, 0.12236013f, -0.15674245f, 0.23062877f, -0.05903552f, 0.10149613f, 0.05363999f, 
    0.21257779f, -0.11397058f, -0.14033277f, -0.02634671f, 0.10446769f, -0.11262256f, 0.07663351f, -0.25851494f, 
    0.18005340f, 0.07761833f, 0.09243294f, -0.03440683f, -0.42232621f, 0.04241378f, 0.14210060f, -0.02577536f, 
    0.21101360f, -0.04478065f, -0.10735356f, 0.14091577f, -0.16662362f, 0.15914413f, 0.15571320f, 0.09273576f, 
    0.12319568f, 0.49373186f, -0.01725105f, -0.09260435f, 0.26661080f, -0.09857142f, 0.09501094f, -0.07359894f, 
    -0.13672012f, 0.16107967f, 0.03849635f, 0.09487183f, 0.05682803f, 0.08874072f, 0.32667708f, -0.06664012f, 
    0.04278789f, -0.03419057f, 0.14797328f, 0.04821235f, 0.06955171f, -0.12923297f, -0.05947056f, 0.09265323f, 
    0.03752244f, -0.02753102f, -0.07113533f, -0.17809266f, 0.02304118f, 0.04706693f, 0.04402895f, 0.05621968f, 
    -0.06490952f, 0.14183910f, 0.09449060f, 0.02104806f, 0.03512954f, -0.15678366f, 0.13553819f, -0.01894112f, 
    0.30000818f, 0.02218965f, -0.09584688f, 0.03792790f, 0.08541013f, 0.05545522f, -0.13269949f, -0.03707015f, 
    -0.20323652f, 0.33550340f, 0.13617529f, -0.08568994f, 0.12416699f, 0.07424383f, 0.07162973f, 0.03558351f, 
    -0.05186646f, -0.05518718f, -0.08031633f, -0.03879020f, -0.12398395f, -0.14770713f, -0.12388333f, 0.05584855f, 
    0.08379471f, -0.25706512f, -0.39910185f, 0.27876163f, -0.09798753f, 0.09664120f, 0.02072786f, -0.10672977f, 
    0.21099918f, -0.26889256f, -0.20484523f, -0.05262682f, -0.04749580f, -0.08080822f, -0.14719294f, -0.01352249f, 
    0.04501545f, -0.01731824f, -0.05414067f, 0.08676670f, 0.25716060f, 0.17079204f, -0.07907636f, -0.13088322f, 
    -0.21671502f, 0.03681581f, 0.00582847f, 0.00885173f, -0.14213422f, -0.02017136f, -0.28825852f, 0.18089689f, 
    -0.10297323f, -0.16003841f, 0.15165432f, 0.03468023f, -0.00957890f, -0.24322446f, 0.01438137f, 0.01140537f, 
    0.22750255f, 0.18148206f, 0.12976921f, -0.05270566f, -0.09999781f, -0.21801195f, 0.04044265f, -0.11555815f, 
    -0.16903242f, 0.22217864f, 0.17559889f, 0.13155621f, 0.08717578f, -0.01200666f, 0.07252230f, 0.03276215f, 
    -0.05371621f, -0.02005135f, -0.04454480f, 0.04456865f, 0.10159877f, 0.05331908f, 0.19286776f, -0.15031655f, 
    0.16229358f, 0.08631802f, 0.42826170f, 0.24441616f, 0.35324481f, 0.11316484f, 0.13633455f, 0.24630666f, 
    0.17967834f, -0.24240237f, 0.04766867f, -0.02342466f, 0.11276557f, -0.04004107f, 0.03452109f, -0.01884328f, 
    0.18387002f, 0.09076262f, -0.27366012f, -0.20192683f, 0.16526334f, 0.09016902f, -0.14017744f, -0.05294860f, 
    -0.04100720f, -0.06846746f, 0.10640723f, -0.07415386f, 0.08886294f, 0.04040841f, -0.05659916f, 0.08841442f, 
    -0.12492432f, 0.13736226f, 0.08986887f, 0.09646150f, -0.07380686f, -0.04772007f, -0.03819780f, -0.08890135f, 
    -0.10546862f, -0.27400547f, -0.00295768f, 0.06150135f, -0.36000717f, -0.21021007f, -0.05279038f, 0.12995043f, 
    0.40706024f, 0.16710313f, -0.00971794f, -0.06220952f, 0.18079117f, -0.05864751f, -0.00245179f, 0.17484914f, 
    0.05430562f, -0.05747415f, 0.11898816f, -0.31925678f, 0.16919091f, 0.23107450f, 0.04580657f, -0.15480317f, 
    -0.31425875f, -0.20768161f, -0.38237172f, 0.31311992f, -0.32552394f, 0.08483039f, 0.17068224f, 0.48301750f, 
    0.19221777f, 0.07939646f, 0.25984091f, -0.12471690f, 0.09195277f, -0.12344085f, 0.13247034f, -0.14328340f, 
    -0.20183606f, 0.13658862f, 0.42073625f, -0.11950783f, 0.19967988f, 0.23246199f, 0.01401550f, 0.28233075f, 
    -0.08502136f, 0.04447227f, -0.07838957f, 0.18195929f, -0.14462547f, -0.31979361f, -0.26161325f, -0.12661883f, 
    -0.12276931f, 0.08003171f, -0.02373440f, 0.03091439f, 0.05941153f, -0.02714628f, -0.02264208f, 0.10559027f, 
    -0.06877673f, -0.02815836f, 0.02668609f, 0.08269218f, 0.09258457f, -0.11507846f, -0.06092869f, 0.10257374f, 
    0.00731099f, 0.08472919f, 0.02307513f, -0.11558737f, -0.10143995f, 0.03036478f, -0.06386180f, 0.10723959f, 
    -0.00254527f, 0.11388434f, -0.10038237f, -0.00035414f, 0.00737179f, -0.05467893f, 0.03200434f, 0.12080935f, 
    -0.04253897f, -0.03564923f, 0.10555137f, -0.12134041f, -0.05569723f, 0.03806593f, -0.13904756f, -0.04729937f, 
    -0.04822522f, 0.06852381f, 0.09052847f, 0.10747451f, -0.11023723f, -0.01919854f, -0.10973723f, -0.02288364f, 
    0.04780948f, -0.01714993f, -0.01259531f, -0.13787194f, -0.04736705f, 0.03041674f, 0.04139969f, -0.02126431f, 
    -0.14264341f, 0.09210993f, -0.09992003f, 0.04027633f, -0.12351200f, -0.06415090f, -0.10724227f, 0.05739301f, 
    -0.02006980f, -0.29818678f, 0.12560917f, 0.00843205f, 0.14288053f, 0.02621989f, -0.38102645f, -0.13666061f, 
    0.07047418f, -0.11584916f, 0.18524241f, 0.02504730f, 0.04243414f, 0.02785766f, -0.06276293f, -0.00746600f, 
    0.14438236f, 0.19522309f, 0.14703493f, -0.07633492f, -0.20627110f, 0.10015198f, 0.09484234f, 0.06733934f, 
    0.00197292f, -0.05246036f, 0.03373456f, 0.31783602f, 0.10706077f, 0.07552768f, -0.03807970f, 0.20819359f, 
    -0.01041087f, -0.27698797f, -0.23155864f, -0.01360918f, 0.29470709f, 0.06752114f, -0.08751566f, -0.00885755f, 
    0.10237740f, -0.26510134f, -0.04986306f, 0.03367193f, 0.02566551f, -0.00742373f, 0.01585297f, 0.04621281f, 
    0.03545219f, 0.02243548f, -0.22065046f, 0.05712976f, -0.01406529f, -0.60308993f, -0.01751423f, 0.15018679f, 
    -0.00688500f, -0.00454740f, -0.07447718f, -0.08627851f, 0.15636417f, 0.12430878f, 0.42133138f, 0.04935113f, 
    0.03283079f, 0.35757095f, -0.28946093f, 0.16904108f, -0.21005966f, 0.28139189f, 0.48325682f, -0.05080628f, 
    -0.06902386f, 0.06597465f, -0.07345206f, 0.00578891f, 0.25531113f, 0.66243547f, 0.11677450f, 0.24269842f, 
    0.38053828f, 0.01947708f, 0.08344489f, 0.08585360f, -0.08175694f, 0.01113992f, 0.13141651f, -0.13235746f, 
    0.24989273f, -0.10370392f, -0.11036000f, -0.10462488f, -0.14924279f, 0.18231216f, 0.07387545f, 0.03052180f, 
    -0.19619694f, 0.05996978f, -0.14506745f, -0.06661530f, -0.18291454f, 0.03567582f, -0.19850181f, -0.20008893f, 
    -0.04582523f, -0.06049529f, 0.26915067f, 0.00145736f, 0.00924316f, 0.06880356f, 0.12347196f, -0.11011617f, 
    0.07691487f, 0.23463741f, 0.24122199f, 0.12705185f, -0.03264203f, 0.14528017f, -0.00792149f, 0.25065818f, 
    -0.06656078f, -0.11342085f, 0.07098715f, 0.16849966f, 0.08396359f, 0.37404826f, 0.27646890f, 0.13309672f, 
    0.16624227f, -0.14468721f, -0.02782289f, 0.04238054f, -0.06104561f, 0.14737074f, -0.07818541f, 0.07064775f, 
    0.31771460f, -0.03811356f, -0.09774166f, -0.08920041f, 0.23490752f, -0.07314613f, 0.10308293f, 0.11531842f, 
    -0.26760811f, 0.02058871f, 0.13706037f, 0.06877382f, 0.02624957f, -0.08034699f, 0.05566001f, 0.04207077f, 
    -0.00043416f, 0.05067036f, 0.01957805f, -0.11598356f, -0.34358597f, 0.03884643f, -0.04125705f, -0.02770621f, 
    -0.17343108f, -0.17838256f, -0.26534188f, 0.15548672f, -0.33024827f, 0.12299503f, 0.17667295f, -0.14472894f, 
    0.20082507f, -0.02741954f, -0.29529184f, -0.08423281f, 0.04583972f, 0.00397572f, -0.01960349f, 0.06370626f, 
    -0.21426427f, -0.03593773f, -0.00016887f, 0.00266970f, 0.23911475f, -0.07116332f, 0.00196640f, -0.07874937f, 
    0.08568137f, 0.11157087f, 0.10085770f, -0.05892378f, 0.12120546f, -0.27435195f, -0.30823907f, 0.24370381f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.08073640f, 0.15198621f, 0.21876851f, 0.08478915f, -0.06462858f, 0.14777084f, -0.00792217f, 0.24289584f, 
    0.05598139f, 0.08475666f, 0.12773302f, 0.10456318f, -0.03945807f, 0.08089191f, 0.10765454f, 0.12927562f, 
    0.25746277f, 0.01950388f, -0.04647028f, -0.11559425f, 0.01231523f, 0.11088134f, 0.01009742f, -0.02735932f, 
    0.24054103f, 0.20938799f, -0.00725660f, 0.00520600f, 0.03816548f, -0.02075959f, -0.02553599f, -0.13044114f, 
    -0.08815984f, -0.09742075f, 0.08863193f, -0.11357656f, 0.09800492f, 0.09546166f, -0.14981519f, 0.04019899f, 
    0.14697912f, -0.04796376f, 0.18108211f, 0.05682189f, 0.18005410f, 0.04488842f, -0.04379334f, 0.20634207f, 
    0.00990058f, -0.16474530f, 0.20084992f, 0.07151754f, 0.15852809f, 0.02333663f, -0.14705080f, -0.07995769f, 
    -0.01558327f, -0.00653519f, 0.15447588f, -0.00978149f, -0.00915672f, -0.05192440f, 0.12933058f, 0.10484760f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.26448074f, -0.15193203f, 0.06158310f, 0.10046387f, 0.07272422f, 0.10195045f, 0.04458351f, -0.42765403f, 
    -0.29761854f, -0.36616042f, 0.14677480f, -0.01750631f, 0.12127697f, -0.59239906f, 0.09362283f, -0.29534256f, 
    -0.15875468f, 0.21772675f, -0.15073411f, -0.05939491f, 0.10280452f, -0.00209127f, 0.07664823f, -0.09728458f, 
    -0.41273183f, -0.12190370f, -0.12847476f, 0.20045836f, -0.11095617f, 0.00966782f, 0.04033012f, -0.00095788f, 
    -0.02147522f, 0.17317973f, -0.08012719f, -0.09437079f, -0.57348943f, -0.19577484f, -0.05162055f, -0.22923185f, 
    -0.22917725f, -0.04293020f, 0.09130467f, 0.20916316f, -0.35665539f, -0.00173984f, 0.06999277f, -0.21991046f, 
    0.04675881f, 0.29569796f, -0.15735933f, 0.11438702f, -0.29573992f, 0.62171704f, 0.05513657f, -0.37200701f, 
    0.11105682f, 0.13831261f, 0.15126674f, 0.05814026f, 0.10648352f, -0.22100678f, -0.04496315f, -0.27079269f, 
    -0.00878736f, 0.37654683f, 0.25921744f, 0.11763398f, -0.74489653f, 0.13260342f, -0.02449554f, -0.26232621f, 
    -0.05777707f, -0.22202221f, 0.14207342f, -0.05600194f, -0.21893792f, -0.10306979f, 0.09944103f, 0.24019381f, 
    0.13602163f, 0.05530401f, -0.35224873f, 0.05638491f, -0.06167138f, 0.08931685f, 0.14254901f, -0.21692175f, 
    0.23924692f, 0.19119550f, -0.14734295f, 0.22457679f, -0.60096508f, -0.05674182f, 0.05495450f, -0.24593237f, 
    -0.13354905f, -0.80921590f, -0.03273423f, -0.00210294f, -0.21117620f, -0.10862668f, -0.02931221f, -0.33081812f, 
    0.16681665f, -0.09090541f, -0.00006650f, 0.28926900f, 0.23884943f, -0.21914320f, -0.14334968f, 0.09596638f, 
    0.09900517f, 0.25900021f, 0.31476045f, 0.21064918f, 0.15471022f, -0.45643663f, 0.10357709f, -0.14488874f, 
    0.16740051f, -0.07048379f, 0.16524637f, -0.08188567f, -0.07961210f, 0.25616685f, -0.03333537f, -0.22885910f, 
    -0.10120431f, -0.17311023f, 0.16635592f, 0.04084883f, -0.04617814f, -0.29003781f, -0.02641102f, 0.08401106f, 
    0.02720775f, 0.25234205f, -0.02470165f, 0.19395863f, 0.15519804f, 0.14904141f, -0.41152140f, 0.16253226f, 
    -0.47289741f, -0.50775325f, 0.05634703f, -0.02834846f, -0.32384783f, 0.09749673f, 0.10934827f, -0.22189213f, 
    -0.36139780f, 0.05006810f, 0.18046106f, -0.36182523f, 0.27592590f, -0.21503204f, 0.02935048f, 0.12744103f, 
    -0.07072055f, -0.43176180f, -0.05828041f, -0.06344190f, 0.25257283f, 0.10091670f, -0.07091390f, 0.07696821f, 
    -0.00569459f, -0.34319186f, 0.02715624f, 0.13637535f, -0.24010251f, 0.19932212f, -0.51802200f, -0.23531871f, 
    -0.16652580f, -0.15847361f, -0.61079645f, -0.33295861f, -0.15860637f, -0.01627316f, 0.07398000f, -0.06433515f, 
    0.12098604f, -0.36245611f, -0.21439977f, -0.30569467f, 0.11236788f, 0.15348588f, 0.24368651f, -0.18701756f, 
    0.08229382f, -0.51334947f, 0.21081005f, -0.06732484f, 0.10170282f, -0.15211630f, -0.00068901f, 0.15294233f, 
    -0.13109788f, 0.03630140f, -0.07980516f, 0.18352073f, -0.44272643f, 0.09165792f, 0.12530711f, -0.12608390f, 
    -0.41774464f, 0.01470437f, 0.07229772f, -0.05277985f, 0.20645542f, 0.08972288f, 0.05252931f, -0.28339329f, 
    -0.39674574f, 0.02858658f, -0.10770439f, 0.09623476f, 0.33627945f, 0.04492789f, -0.02327115f, 0.09414239f, 
    0.00579986f, 0.14629960f, 0.10805132f, -0.05780303f, -0.01493087f, 0.05244156f, 0.04805139f, 0.07900922f, 
    -0.07622791f, 0.02191082f, 0.02071216f, -0.00918934f, -0.26310489f, 0.09053995f, 0.16749099f, -0.48712704f, 
    -0.62012225f, -0.00249005f, -0.41010222f, 0.07230011f, -0.35572645f, -0.05111107f, -0.05946272f, -0.16857085f, 
    0.22553526f, -0.17759545f, 0.01555305f, -0.03315772f, -0.10179625f, -0.20175128f, 0.16648106f, -0.10873045f, 
    -0.27556223f, -0.37524268f, -0.05540465f, -0.49931744f, 0.18584555f, -0.00909722f, -0.06840479f, -0.07917804f, 
    0.02123756f, -0.29709816f, 0.09653512f, 0.01752799f, 0.00018064f, -0.04360872f, 0.13633740f, -0.21237199f, 
    -0.22970089f, 0.10694406f, -0.46063957f, -0.00912964f, 0.20072295f, 0.04330029f, 0.05735916f, 0.23326966f, 
    0.13819279f, 0.11882179f, -0.34451857f, -0.10325622f, -0.03353684f, -0.29623106f, -0.03179464f, 0.19802287f, 
    -0.12482516f, 0.22403918f, -0.08255225f, -0.05220355f, -0.19279185f, -0.36329818f, -0.06206225f, -0.10851073f, 
    -0.16125776f, 0.14369898f, 0.02716016f, -0.29982460f, -0.31836578f, -0.43531555f, -0.17469180f, 0.08528631f, 
    0.08852168f, -0.04401914f, -0.28667852f, 0.10924755f, -0.12544844f, -0.39665392f, 0.05435395f, 0.02480744f, 
    -0.06517941f, 0.10551769f, -0.00066267f, 0.12842827f, -0.02190822f, -0.30816621f, 0.11843091f, -0.33455130f, 
    -0.06689397f, -0.53983772f, -1.07874572f, 0.01798114f, -0.21107629f, -0.07228050f, -0.11720992f, 0.07323211f, 
    -0.00635972f, -0.04936733f, 0.13995214f, 0.01920876f, -0.17339312f, -0.14552124f, 0.02664303f, -0.05656742f, 
    -0.20263381f, 0.05029736f, -0.27309731f, 0.16225979f, -0.25047144f, 0.14720389f, 0.14476627f, 0.27368966f, 
    -0.24846691f, -0.42632395f, 0.14658064f, -0.08136247f, -0.54759163f, 0.25042459f, 0.02888900f, -0.29642123f, 
    0.00153544f, -0.27493438f, -0.03957091f, 0.11915831f, 0.03932166f, 0.04702199f, -0.11741965f, -0.15800793f, 
    0.14884610f, 0.17875610f, 0.14081919f, 0.03420947f, -0.16481644f, -0.10940685f, 0.10889652f, -0.05279599f, 
    0.07266699f, -0.16096768f, 0.13814580f, -0.02421577f, 0.02194385f, -0.15970586f, -0.00444568f, 0.14143299f, 
    -0.06777193f, -0.28382459f, -0.02932888f, 0.15238358f, -0.09065102f, 0.09867740f, 0.03181194f, -0.20065954f, 
    -0.09892624f, 0.23081149f, -0.26102364f, -0.05150241f, -0.14024085f, -0.37898144f, -0.06638658f, -0.01401233f, 
    0.08800058f, 0.29871082f, -0.39089668f, 0.14345111f, 0.26934430f, 0.17254838f, -0.47992831f, 0.03804328f, 
    0.29395294f, -0.15365070f, 0.12798451f, -0.07348127f, -0.58502400f, -0.69097757f, -0.45112264f, -0.21214381f, 
    -0.16308759f, 0.11187661f, 0.25154796f, 0.07515869f, -0.07485947f, -0.07403437f, -0.02862079f, -0.04459929f, 
    -0.08686469f, -0.24782622f, -0.11581092f, 0.08186455f, 0.24785042f, 0.21214406f, -0.11971268f, 0.17312551f, 
    -0.22555839f, -0.64179629f, -0.69202840f, 0.14768994f, -0.04893732f, 0.17635110f, -0.44757229f, 0.08065563f, 
    0.09985290f, 0.32040608f, 0.25609255f, -0.34577477f, 0.14585002f, 0.00348838f, 0.04914308f, -0.26051313f, 
    -0.22981675f, -0.10649230f, -0.67545217f, -0.61041838f, -0.04491131f, -0.00360549f, 0.07956640f, 0.18762672f, 
    0.04983421f, -0.29926136f, -0.12344080f, 0.08592739f, 0.22455914f, 0.09822188f, 0.07465451f, 0.03074662f, 
    -0.04384381f, -0.21287739f, -0.01818128f, -0.61923760f, 0.11026798f, -0.03924375f, 0.11958255f, -0.15628922f, 
    -0.05312501f, -0.14891002f, 0.11491826f, 0.06771927f, 0.13111365f, -0.56839752f, 0.16973223f, -0.07051250f, 
    0.15308049f, -0.11892520f, 0.05380199f, -0.36300176f, 0.49605396f, 0.17020668f, 0.00934681f, 0.12713382f, 
    0.03425435f, 0.17389598f, -0.06614753f, -0.07570578f, -0.47498745f, 0.03722823f, -0.04498192f, 0.07771035f, 
    -0.37065661f, -0.08549221f, -0.45331371f, -0.12396616f, 0.00631549f, -0.21703000f, 0.17596740f, 0.14827822f, 
    -0.08175103f, -0.14566749f, 0.00581786f, -0.44682038f, -0.06260230f, -0.11537950f, 0.07873636f, 0.02024163f, 
    -0.65671080f, 0.30976927f, 0.19046044f, -0.16678108f, 0.01025907f, 0.04765759f, -0.47762454f, 0.20997685f, 
    0.21282758f, 0.07453033f, 0.27153498f, -0.29868624f, -0.24253722f, 0.06042963f, 0.04813118f, 0.22788891f, 
    0.12666957f, -0.24239396f, -0.22319606f, 0.04136171f, 0.18503460f, 0.17366226f, -0.40660611f, 0.17161249f, 
    -0.08376952f, -0.18009494f, 0.12224963f, -0.00434337f, -0.47790873f, 0.01315278f, -0.08524908f, -0.29508162f, 
    0.03880698f, -0.26385272f, -0.06816363f, -0.53659612f, -0.21908948f, 0.26738226f, -0.14769697f, -0.25903940f, 
    -0.06283432f, -0.40966585f, 0.12071206f, 0.09472431f, -0.22067223f, 0.23046024f, -0.02971275f, 0.00793640f, 
    -0.08193232f, 0.04667604f, -0.30642900f, -0.13305371f, -0.17878738f, 0.20025600f, 0.28726414f, -0.19235307f, 
    -0.20986286f, -0.27786624f, -0.24237283f, -0.55030364f, -0.01770925f, -0.00076449f, -0.02765041f, 0.03035981f, 
    0.15738411f, 0.41464287f, 0.27790573f, -0.21798769f, -0.04888734f, 0.03840668f, -0.61625326f, 0.24698231f, 
    -0.27067876f, -0.24913172f, -0.18037665f, -0.08614652f, 0.27373734f, 0.17619544f, 0.03217341f, -0.08462640f, 
    0.02081095f, 0.12410496f, 0.02247493f, -0.03224870f, 0.01731372f, 0.15418838f, -0.09529639f, 0.06752507f, 
    -0.03850742f, -0.56784338f, 0.02191307f, -0.20515308f, 0.07853357f, -0.06866059f, -0.14863765f, -0.01782304f, 
    0.29355440f, 0.09123223f, 0.08398768f, -0.29690799f, 0.05355505f, -0.45455784f, -0.06556070f, -0.18846078f, 
    -0.03041212f, 0.13983011f, 0.05528474f, 0.09505947f, 0.14238927f, 0.00260320f, 0.03698150f, 0.21127996f, 
    -0.25251898f, -0.16117242f, 0.02161097f, -0.06790014f, -0.02006103f, 0.06699157f, -0.58502561f, 0.39334333f, 
    0.03774910f, -0.11194454f, -0.08441629f, -0.00772393f, 0.07682102f, -0.20192719f, -0.07963446f, -0.26637661f, 
    -0.36457965f, 0.33517551f, -0.06488471f, 0.04285879f, -0.04527592f, -0.13800225f, 0.11688074f, 0.02893877f, 
    0.15754974f, -0.06150546f, -0.11475877f, -1.65274692f, -0.43074754f, -0.05405664f, 0.06665422f, 0.21018064f, 
    0.32943717f, -0.04557666f, -0.01612085f, 0.10332114f, -0.03562597f, -0.05965066f, -0.12640068f, 0.01922467f, 
    -0.32448015f, -0.15216945f, -0.09893632f, -0.54056913f, 0.24218430f, 0.23556000f, -0.84585869f, -0.22197048f, 
    -0.04525957f, -0.62021899f, -0.10662591f, -0.06819540f, -0.48147559f, -0.41641772f, 0.10656571f, -0.07575306f, 
    -0.05579158f, -0.42882597f, -0.08402003f, -0.10053338f, 0.24903609f, -0.33203220f, -0.07547753f, -0.47177580f, 
    -0.01245842f, 0.02186601f, 0.08832633f, -0.69668669f, -0.51691502f, 0.19609189f, -0.07367038f, -0.40607032f, 
    0.31421453f, -0.33093330f, -0.14536414f, -0.13298894f, 0.16845325f, -0.06036745f, 0.09339337f, 0.25734007f, 
    0.22463229f, -0.01584581f, -0.03824556f, 0.29041716f, -0.01509378f, 0.09221883f, -0.11991689f, 0.04446101f, 
    -0.20580398f, 0.22531638f, -0.10186006f, -0.66760337f, -0.12571861f, -0.10881564f, 0.04789516f, -0.07143764f, 
    -0.25784504f, 0.22085567f, -0.16779566f, -0.28282639f, 0.01905258f, 0.15176065f, -0.31591633f, -0.18653513f, 
    0.01284488f, -0.42225701f, 0.26284459f, -0.12264502f, -0.36443296f, -0.27279437f, 0.06318166f, -0.01663584f, 
    -0.47044113f, 0.14752229f, 0.12969324f, -0.26469439f, -0.17003818f, -0.13833228f, -0.11998189f, -0.17971306f, 
    -0.01789501f, -0.02194679f, -0.00481906f, -0.03916249f, 0.00197946f, 0.00685741f, 0.09889954f, -0.10388555f, 
    0.17181644f, -0.05770158f, -0.00135683f, -0.39109978f, 0.31496948f, 0.16612807f, 0.12759140f, -0.16782287f, 
    0.23302417f, 0.00033002f, 0.12066557f, -0.40341014f, 0.15508759f, -0.04826915f, -0.01160461f, 0.31804878f, 
    -0.09498933f, -0.43129551f, -0.09872366f, 0.23922977f, 0.02644006f, -0.19788684f, -0.19460763f, 0.05141700f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.13465133f, 0.01948207f, -0.07230756f, -0.04180032f, 0.03997342f, -0.05581095f, -0.01553791f, -0.15727796f, 
    0.02536429f, 0.07507613f, -0.07410944f, -0.19134457f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
