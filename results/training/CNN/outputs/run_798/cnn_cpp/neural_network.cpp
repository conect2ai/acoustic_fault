#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.74719274f, -0.94316339f, -0.88348341f, 0.08485997f, -0.12290569f, -0.04504015f, -0.03886634f, 0.21696885f, 
    -0.17915350f, 0.86911958f, -0.72129327f, -0.68018860f, -0.51815623f, 0.46863484f, -0.43336812f, -0.01134718f, 
    0.23333265f, 0.01272014f, -0.26042628f, -0.15411517f, 0.92911243f, 0.57454926f, -0.21980783f, -0.07528491f, 
    -0.63146591f, -0.39344090f, -0.43032196f, 0.74067289f, -0.19416346f, -0.69045031f, 0.48454776f, -0.75164813f, 
    -0.14744857f, 1.04129446f, 0.35153964f, -0.20324181f, -0.98648238f, 0.27379248f, 0.35550386f, -0.61028248f, 
    -0.40758422f, 0.36197594f, 0.33486190f, 0.31484082f, -0.19799668f, 0.62936538f, 0.53588486f, 0.56011957f, 
    0.14778821f, -0.69192249f, 0.63994926f, 0.06450547f, 0.06355258f, 0.12843940f, 0.71327865f, -0.41266972f, 
    -0.51598102f, -0.35142517f, -0.74467033f, 0.11293811f, -0.39294058f, -0.08023759f, 0.52041936f, 0.09861238f, 
    -0.89258051f, -0.61412406f, -0.30321884f, -0.47411692f, -0.30764940f, 0.08788915f, -0.15073927f, 0.09309230f, 
    -0.22580415f, -1.08688223f, -0.42113602f, -0.81638211f, 0.58777642f, -0.04867429f, 0.05146174f, 0.26971269f, 
    -0.20581348f, 0.81032044f, -0.33969942f, 0.60143691f, 0.93174922f, 0.61917621f, 0.02776566f, -0.31086078f, 
    -0.08036165f, -0.09530859f, 0.27066031f, -0.62035698f, -0.28001487f, 0.69590151f, -0.59836638f, 0.70694685f, 
    0.01497911f, -0.62349242f, 0.55574673f, -0.59784347f, -0.53994626f, -0.37408465f, 0.57594848f, 0.96065617f, 
    0.35378280f, -0.30821323f, -0.28718147f, -0.66338509f, 0.72194976f, 0.55643582f, 0.71195698f, 0.24162729f, 
    0.26420259f, 0.44465524f, -0.48219627f, -0.04287147f, 0.17948964f, -0.99867666f, 0.01967878f, 0.37166530f, 
    0.86711043f, 0.85711825f, 0.44989020f, 0.26786909f, 0.11350156f, 0.01931131f, -0.83441514f, -0.02747878f, 
    0.76895273f, -0.65740168f, -0.95530736f, 0.01005916f, 0.25686276f, -0.28939179f, 0.40277967f, 0.69126105f, 
    0.76271582f, -0.15294524f, -0.05914301f, 0.20132099f, -0.45829809f, 0.58644933f, 0.02023681f, 0.50289595f, 
    0.76695389f, 0.72315449f, 0.85539973f, -0.64206040f, -0.06766807f, -0.71872431f, -0.02606499f, -0.03113005f, 
    -0.02075322f, 0.60650969f, -0.21346322f, 0.49540958f, -0.18637593f, 0.78474760f, 0.58505160f, 0.49470392f, 
    0.39409730f, -0.15782112f, -1.02086568f, 0.62387407f, -0.70271462f, -0.27822483f, 0.88001347f, 0.47144374f, 
    -0.05594720f, 0.34279200f, 0.48498073f, -0.25755093f, 0.26017261f, 0.64251196f, -1.19183993f, 0.40401441f, 
    -0.49433446f, 0.37878424f, -0.28470388f, 0.41252995f, 0.56081074f, 0.61314434f, 0.47995463f, -0.42918023f, 
    -0.55006921f, 0.04399587f, 0.69275242f, 0.23865290f, -0.02682834f, 0.11374223f, -0.87387490f, 0.36341214f, 
    -0.94172901f, -0.30705643f, 0.68585050f, 0.22638530f, 0.42740896f, 0.47251788f, 0.36548766f, 0.60366106f, 
    -0.76987714f, 0.97148305f, 0.18084683f, -0.66580886f, -0.16587451f, -0.10585285f, 0.31943464f, 0.77139926f, 
    -0.50509393f, -0.77169228f, 0.09782721f, 0.50511974f, -0.60142422f, -0.36812925f, -0.22666495f, -0.49186495f, 
    -0.71286577f, -0.72956675f, -0.70628691f, 0.52180529f, 0.34843263f, 0.61674923f, -0.16586733f, -0.13190691f, 
    0.12203522f, 0.78573740f, 0.73750138f, -0.66425961f, -0.72547323f, 0.15531820f, 0.20604916f, -0.05850040f, 
    0.27121490f, 0.44568712f, 0.68206900f, -0.11774451f, 0.62621069f, -0.44427076f, -0.91266173f, -0.34313878f, 
    -0.62970102f, -0.51691061f, -0.05622919f, 0.95520347f, 0.51118428f, 0.28438580f, 0.22011262f, -0.78548813f, 
    0.38374561f, -0.68841636f, -0.22078942f, -0.58577961f, -0.82413703f, 1.07395673f, -0.47392389f, 0.13849324f, 
    -0.33623204f, -0.83751208f, 0.40436357f, -0.32067674f, -0.46284819f, 0.16615777f, 0.22898211f, 0.27238789f, 
    0.09774544f, -1.10117507f, -0.91442156f, -0.46999964f, 0.40079758f, 0.32349434f, -0.56278592f, -0.59549862f, 
    -0.93393236f, -0.64560747f, 0.12269665f, 0.50157899f, 0.78028047f, -0.21984373f, 0.24902013f, 0.64893377f, 
    -0.40813273f, -0.38304439f, -0.40398398f, -0.76920831f, -0.20721841f, -0.26784992f, 0.22444548f, -0.23476487f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.12298953f, 0.17261893f, -0.00857498f, -0.18433273f, 0.09824336f, 0.24914496f, -0.19111285f, -0.08512961f, 
    0.19267750f, 0.21364874f, 0.01129080f, 0.08695617f, 0.34496918f, 0.00799902f, -0.07213620f, -0.08656639f, 
    -0.02858673f, -0.30409819f, 0.29171643f, -0.23772472f, -0.07888338f, -0.05799287f, -0.27843288f, 0.00566186f, 
    -0.16836400f, -0.25346902f, 0.13706645f, -0.14466725f, 0.06074980f, -0.13198189f, 0.16305435f, 0.14828992f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.25507805f, -0.06188865f, 0.19637115f, 0.22615080f, -0.03186038f, -0.07281084f, -0.02561609f, -0.01186045f, 
    -0.01759347f, 0.03598808f, -0.07488242f, -0.01572135f, -0.17830068f, -0.02109096f, -0.16177374f, -0.10768372f, 
    0.09378059f, -0.01619707f, 0.27779377f, 0.06689657f, -0.29518890f, -0.04824454f, 0.22086285f, -0.04515779f, 
    0.14173058f, 0.01795815f, 0.00652044f, -0.19163117f, -0.13964012f, -0.23578638f, -0.12554835f, -0.06726198f, 
    -0.15462096f, -0.29025018f, 0.00541882f, -0.06640966f, -0.18979502f, -0.29407507f, -0.04040669f, -0.05053092f, 
    0.10383149f, -0.01290754f, -0.04897141f, 0.03363486f, -0.04119173f, -0.23526353f, 0.08114677f, 0.18343726f, 
    0.07681379f, 0.15524723f, -0.16475566f, -0.00500662f, 0.09193669f, 0.04892192f, -0.05703266f, -0.34322762f, 
    -0.10431242f, -0.05131892f, 0.03415478f, -0.14052528f, 0.08404968f, -0.01341389f, 0.02486522f, -0.07096247f, 
    -0.17210920f, 0.18857753f, 0.19179101f, 0.03037344f, 0.10841160f, 0.09333926f, 0.08349212f, 0.07832461f, 
    0.07438834f, 0.26822135f, -0.06228204f, 0.17998402f, -0.04940999f, 0.17610285f, 0.07311638f, -0.12998453f, 
    0.15423454f, -0.28701374f, 0.19251436f, 0.03680567f, 0.18651889f, 0.18913959f, -0.02421456f, 0.18016566f, 
    -0.11433008f, 0.03547626f, -0.29044637f, -0.38528025f, -0.23958446f, -0.08269340f, -0.11837289f, 0.03863707f, 
    0.05180179f, -0.10471924f, -0.13185276f, -0.08235601f, -0.20443951f, -0.11083633f, 0.10741219f, 0.05556153f, 
    0.25769684f, -0.02700397f, -0.04034542f, 0.11013405f, 0.22433351f, 0.30449700f, 0.33702025f, 0.17980038f, 
    0.08907780f, 0.19023919f, 0.18041997f, 0.02845497f, 0.06248311f, 0.33678761f, -0.01619534f, -0.13605982f, 
    0.19004856f, 0.10993186f, 0.20471583f, 0.00308280f, -0.02478785f, -0.01753104f, 0.14334102f, -0.05058923f, 
    0.01841039f, 0.03253889f, -0.17777058f, -0.12596413f, 0.01661642f, -0.04473019f, -0.29672486f, -0.18286270f, 
    -0.00580018f, 0.06612568f, -0.15674138f, 0.06183260f, 0.19100082f, 0.00543438f, -0.15383565f, -0.11234597f, 
    -0.28825015f, 0.35500523f, 0.46317753f, -0.06403627f, 0.07367243f, -0.17937203f, 0.18233989f, 0.07772572f, 
    0.17616877f, -0.31757313f, 0.05205153f, 0.11738233f, 0.13337415f, 0.22604917f, 0.07286578f, 0.08750841f, 
    0.08592871f, 0.00064422f, -0.13559461f, -0.08895719f, 0.17595737f, 0.01197598f, 0.15113299f, -0.03183554f, 
    -0.02757987f, -0.03572081f, 0.14228606f, -0.16971454f, 0.16650148f, 0.24134353f, -0.10679409f, -0.12256086f, 
    0.07384167f, 0.06112216f, -0.30656376f, -0.19902168f, -0.29528379f, -0.10250317f, 0.26094201f, -0.15654790f, 
    0.06427505f, -0.10567566f, 0.09960686f, 0.05449145f, -0.04439748f, -0.20592393f, -0.20150873f, -0.16357775f, 
    0.06958351f, 0.02971940f, 0.14517482f, 0.02934616f, -0.10398662f, -0.06533560f, -0.01439282f, -0.45563725f, 
    -0.09491224f, 0.03639803f, -0.03790463f, 0.04151684f, 0.10935347f, -0.11952594f, 0.04214179f, 0.07416066f, 
    -0.15439135f, 0.21870708f, -0.00585285f, -0.18223490f, -0.18948877f, -0.05622515f, 0.18936315f, 0.00273601f, 
    -0.41463414f, -0.12955725f, -0.13559172f, 0.22283512f, 0.00992476f, -0.04954214f, 0.06846295f, 0.10209203f, 
    0.07053355f, -0.00220532f, -0.15629004f, -0.11686637f, -0.33745748f, 0.11507817f, -0.17096196f, 0.14905605f, 
    -0.20764215f, -0.06304426f, -0.04658067f, 0.07029479f, 0.34922478f, 0.04867619f, 0.17767151f, -0.40626147f, 
    0.24169324f, 0.16764614f, -0.02149661f, -0.09954032f, 0.04804320f, 0.06376334f, 0.01271645f, 0.35943443f, 
    -0.11624545f, 0.10179937f, 0.03900722f, -0.09841643f, 0.34863374f, 0.17251833f, 0.03709886f, 0.07714563f, 
    0.03734513f, -0.17138737f, -0.08807199f, 0.12242786f, 0.34839776f, 0.04556133f, -0.01119142f, 0.33289936f, 
    -0.03282648f, -0.04274343f, -0.08296036f, 0.06115967f, -0.10416486f, 0.04018667f, -0.21833394f, 0.03579197f, 
    -0.20685022f, 0.15969916f, 0.00504178f, 0.11163159f, 0.09490037f, -0.07630645f, -0.06833239f, -0.01806093f, 
    -0.15282542f, 0.00818100f, -0.12553096f, 0.06672613f, -0.04492258f, 0.00912247f, 0.04422827f, -0.02628017f, 
    -0.00914543f, -0.06872521f, -0.03194250f, 0.02281088f, 0.03017176f, -0.06077911f, -0.04534378f, -0.05729827f, 
    -0.02130352f, -0.05376877f, -0.00448059f, -0.00780522f, -0.03583721f, -0.03515819f, 0.04835968f, -0.05034028f, 
    -0.04673281f, 0.03639095f, -0.01210133f, -0.05062539f, -0.05671953f, -0.01247007f, 0.00701209f, -0.02814733f, 
    -0.05262554f, -0.04255674f, 0.02661347f, 0.03263402f, 0.04956408f, -0.06741536f, -0.06888667f, -0.00398948f, 
    -0.05104032f, -0.02859655f, -0.01755219f, -0.02966173f, -0.01372067f, 0.00186227f, -0.00538043f, -0.03425081f, 
    0.04450611f, -0.04675555f, 0.04737439f, 0.04286472f, 0.01606984f, -0.05046021f, -0.05145051f, -0.00613475f, 
    0.00093232f, -0.03889383f, -0.00650656f, 0.02844365f, -0.04981497f, 0.00825002f, 0.03744360f, -0.06147154f, 
    0.02477510f, -0.05619951f, -0.01730890f, 0.04728231f, 0.03991047f, 0.04759519f, 0.04011976f, -0.06262016f, 
    0.04311007f, -0.04167385f, 0.01479416f, 0.05265018f, 0.01268113f, 0.02529829f, -0.04423629f, 0.04717519f, 
    0.04413197f, -0.03057715f, -0.03105927f, 0.02963045f, 0.03852443f, 0.01084360f, 0.03542756f, -0.03673381f, 
    -0.01156272f, -0.06106739f, 0.03625542f, -0.05737500f, -0.02625559f, 0.03317276f, 0.01724243f, -0.01859130f, 
    0.02265425f, 0.01966477f, -0.05835387f, -0.02611591f, -0.01318707f, 0.02153524f, 0.00973214f, 0.03585590f, 
    0.01553348f, 0.03781543f, 0.01512245f, 0.01561969f, -0.05294810f, 0.00137789f, 0.03821449f, -0.02767033f, 
    0.05031395f, -0.04467328f, 0.03351428f, -0.01827812f, 0.03034529f, -0.03455236f, 0.00646514f, 0.01821830f, 
    -0.06204302f, 0.04300102f, -0.05441746f, 0.02170818f, 0.04337659f, 0.00054004f, 0.01277292f, 0.01803663f, 
    -0.04858172f, 0.03881254f, -0.05341104f, 0.01307169f, -0.03482281f, -0.04565823f, 0.00680100f, 0.01947269f, 
    0.03416067f, 0.03517595f, 0.01148137f, 0.00547908f, 0.05380618f, -0.02348548f, -0.01011776f, -0.03845904f, 
    0.02161001f, -0.06263249f, -0.00781297f, -0.05922754f, 0.01274725f, -0.05067836f, 0.00859539f, 0.03922522f, 
    -0.01419092f, -0.03985089f, -0.02294421f, 0.02933197f, -0.03357193f, 0.02672351f, 0.05183930f, -0.00873969f, 
    -0.00848326f, 0.02665925f, 0.01100814f, -0.06055298f, 0.03606237f, 0.01699146f, 0.03632625f, -0.02612280f, 
    -0.03934741f, -0.05277310f, -0.02044130f, -0.03047979f, 0.03645509f, 0.02422244f, -0.06268164f, 0.00050094f, 
    0.01379910f, 0.01731709f, -0.01143905f, -0.02273933f, -0.01207830f, 0.04560841f, 0.01481297f, -0.05795621f, 
    0.04604682f, 0.00251172f, 0.02978827f, -0.05162767f, 0.02479850f, 0.00853855f, -0.00931840f, 0.04609755f, 
    0.00448571f, 0.01215925f, -0.05259969f, 0.03306300f, 0.05716400f, -0.00578505f, -0.00498172f, 0.03255840f, 
    0.01786120f, -0.06399474f, -0.01613325f, 0.04407642f, -0.03389763f, -0.02837992f, 0.03335585f, 0.03672395f, 
    0.02432133f, 0.00529919f, 0.03621124f, -0.01353554f, -0.00717246f, 0.04645697f, 0.04216938f, -0.03218835f, 
    0.03901298f, -0.05915720f, -0.00381567f, -0.01843912f, -0.05987895f, -0.00457417f, 0.01315402f, -0.03509521f, 
    0.01241180f, -0.01713697f, -0.04207414f, 0.00828303f, -0.00471626f, 0.00578898f, 0.01345602f, -0.01742098f, 
    -0.03584560f, -0.04491715f, 0.00486930f, -0.01737517f, -0.04356601f, -0.06128748f, -0.01058312f, -0.03441004f, 
    -0.05533282f, -0.05314635f, -0.06556793f, 0.01576435f, 0.04391152f, -0.03814873f, -0.03048307f, 0.04467782f, 
    -0.00870723f, -0.05742596f, -0.03045937f, 0.02589228f, -0.03965574f, -0.03425532f, 0.01970471f, -0.02752217f, 
    0.04315299f, 0.04904158f, 0.00479102f, -0.02106442f, 0.04513218f, -0.00823896f, -0.05738978f, 0.03818725f, 
    -0.03748986f, -0.00670195f, -0.04463594f, -0.01296369f, -0.06361207f, 0.03859494f, 0.00321398f, -0.02516017f, 
    0.00364964f, 0.00138835f, 0.05078395f, 0.02366689f, 0.01224201f, -0.05473636f, -0.02516790f, 0.04813625f, 
    -0.04997556f, -0.06381913f, -0.00390806f, -0.05900021f, -0.04182909f, 0.02600412f, 0.03436802f, 0.04009532f, 
    -0.01468261f, 0.01655095f, -0.02637831f, 0.00149385f, 0.01377264f, 0.03536483f, -0.00015659f, 0.01952195f, 
    -0.03764668f, 0.23603338f, 0.46459946f, 0.07823252f, 0.06248210f, -0.02505112f, -0.01749898f, -0.01038572f, 
    -0.02176672f, -0.02131181f, 0.18289565f, -0.17329293f, 0.11043502f, 0.04513575f, 0.19591747f, -0.02687937f, 
    -0.07522998f, -0.25013357f, -0.20444492f, -0.24180144f, -0.17699276f, 0.10251921f, 0.05642619f, 0.09001584f, 
    -0.08915359f, 0.02228859f, 0.08096979f, -0.22012453f, -0.17576833f, 0.08478427f, 0.03659353f, -0.03339577f, 
    0.11294183f, 0.28511065f, 0.05857997f, -0.04048309f, -0.22111706f, -0.02452518f, -0.25427273f, -0.13169743f, 
    0.06743865f, -0.00093215f, 0.01220689f, 0.03792115f, -0.03608015f, -0.10195534f, 0.11122812f, 0.03984463f, 
    0.18885669f, 0.04277685f, -0.01446457f, 0.04479732f, 0.06653637f, 0.21706812f, -0.37589681f, 0.16605307f, 
    -0.09214287f, 0.00409998f, -0.05665429f, -0.05389590f, -0.10560387f, 0.12086887f, -0.04772846f, 0.03876280f, 
    0.05095261f, -0.00298791f, 0.14264846f, -0.16333689f, -0.24969159f, 0.00010786f, 0.09726308f, -0.07758275f, 
    0.24416465f, 0.05073682f, -0.01852438f, 0.02296688f, 0.11266371f, 0.02139446f, -0.04703759f, -0.06330090f, 
    0.01336266f, 0.07492856f, 0.04889703f, -0.04387029f, 0.04100875f, -0.01164684f, 0.00109868f, -0.04126465f, 
    -0.03509559f, 0.13881527f, -0.08685546f, 0.15709592f, -0.16117233f, -0.01509591f, -0.10891223f, -0.08946690f, 
    0.06585804f, -0.07636942f, -0.14650801f, 0.18417323f, 0.05825979f, 0.16290535f, -0.04565791f, -0.15791164f, 
    -0.03162725f, -0.01803391f, -0.04683263f, 0.09080260f, 0.11683797f, -0.04776157f, -0.05604083f, 0.05710551f, 
    0.00067823f, 0.08022808f, 0.03841123f, 0.12992732f, 0.30500060f, 0.58032101f, 0.12278597f, -0.13524441f, 
    -0.10003050f, -0.15855631f, 0.20792127f, -0.07832771f, 0.09206048f, 0.18523915f, -0.35364217f, 0.05861039f, 
    -0.26732257f, 0.09514796f, -0.08362129f, -0.02162034f, -0.01009314f, -0.18941963f, -0.15723090f, 0.04290662f, 
    0.19656640f, 0.06515233f, -0.05953326f, 0.11805641f, -0.02241104f, 0.00754813f, 0.00657869f, -0.01654358f, 
    -0.24255334f, -0.00306734f, -0.13927683f, -0.02196456f, 0.18648247f, 0.10685527f, -0.06580240f, 0.02180542f, 
    -0.09594697f, 0.14255841f, 0.05873498f, -0.00249036f, 0.10413999f, -0.00622777f, -0.03268484f, 0.03154477f, 
    0.07765566f, 0.19031422f, 0.14314003f, -0.01451228f, 0.15795884f, -0.31661117f, -0.01078150f, 0.04331958f, 
    -0.02010277f, -0.05090201f, 0.05829661f, -0.01749353f, -0.32111499f, -0.30379659f, 0.00745526f, 0.15676990f, 
    0.05372430f, -0.17430972f, -0.14946903f, -0.23801509f, -0.03482823f, 0.23117770f, 0.09746447f, 0.00260951f, 
    -0.00598493f, -0.01904138f, 0.10473832f, 0.12030183f, 0.01602227f, 0.24757116f, -0.04967701f, -0.07747237f, 
    -0.04544147f, 0.13025334f, -0.08254085f, -0.13665429f, -0.03588520f, 0.10359653f, 0.13770771f, 0.08795530f, 
    -0.12982364f, -0.02295152f, 0.11906976f, -0.26379839f, -0.13941823f, 0.15461162f, 0.13250712f, 0.13188830f, 
    0.01634620f, 0.01232184f, -0.18418202f, 0.04000187f, 0.03016494f, -0.21451233f, -0.01719132f, -0.14207357f, 
    0.08933832f, 0.21771768f, 0.38666192f, -0.05452731f, -0.03054630f, 0.05081322f, -0.00898945f, -0.03041167f, 
    0.03092507f, 0.01954966f, 0.03365856f, -0.19249538f, 0.06491448f, -0.02866040f, 0.00605755f, -0.01482607f, 
    0.12531562f, 0.01548254f, -0.63370639f, -0.25795439f, -0.23789950f, 0.13620003f, 0.13108054f, 0.09231166f, 
    -0.06925769f, -0.08361521f, 0.11474565f, 0.13106944f, -0.14005157f, -0.01038519f, 0.05069501f, 0.18204105f, 
    0.05522867f, 0.09367131f, 0.27765983f, -0.01321488f, -0.20658356f, -0.13858537f, -0.31425020f, -0.24263579f, 
    0.20638594f, -0.16437015f, 0.03002956f, 0.07308424f, 0.15886876f, -0.36130083f, -0.17521924f, -0.31661370f, 
    -0.00032455f, 0.02333777f, -0.05208070f, -0.04896568f, 0.11344449f, 0.09859785f, 0.25642318f, 0.01085277f, 
    0.20243898f, 0.08438910f, 0.02288819f, -0.05176377f, -0.09035412f, 0.02878137f, 0.22498760f, -0.35296726f, 
    -0.05286502f, -0.02971071f, 0.18595973f, -0.00773995f, 0.05447783f, 0.04303598f, 0.05164495f, -0.16474868f, 
    0.06344038f, 0.36717668f, -0.31571484f, 0.06134971f, 0.00466718f, 0.14109720f, -0.10239177f, 0.03014998f, 
    0.11984409f, 0.45758143f, -0.03683283f, -0.20261224f, 0.06466072f, -0.02269926f, 0.00014704f, -0.00119790f, 
    -0.16762298f, -0.00489500f, -0.05471385f, -0.02309122f, -0.01720278f, 0.02978800f, 0.10844007f, -0.09141605f, 
    0.02909646f, -0.17392915f, -0.08655538f, 0.29286414f, 0.03256116f, -0.20567487f, -0.05173864f, -0.05555378f, 
    0.05605317f, -0.16261296f, 0.05793883f, 0.24162184f, -0.31534737f, -0.14428881f, -0.05880909f, 0.04698291f, 
    -0.15922707f, 0.04132743f, -0.10287179f, -0.16659907f, 0.13652748f, 0.12923263f, 0.10661580f, 0.26445410f, 
    0.15532582f, -0.02827475f, -0.14105126f, -0.05966565f, 0.11979840f, 0.06927855f, 0.17664550f, -0.25225821f, 
    -0.44405088f, 0.08183272f, -0.00682017f, 0.25147510f, -0.02096148f, -0.03294598f, -0.03901999f, 0.20522480f, 
    0.22616948f, -0.20133476f, 0.09577683f, -0.06272155f, 0.17648634f, 0.00803325f, 0.00081879f, 0.02665512f, 
    0.18658099f, 0.13571028f, 0.00292176f, 0.10046186f, 0.06966265f, -0.01569645f, -0.06273502f, 0.01324899f, 
    0.13050990f, 0.09607992f, 0.04816367f, 0.06729487f, -0.07148398f, -0.01504468f, -0.24082439f, 0.08398936f, 
    0.03607275f, 0.01157634f, 0.09432782f, 0.20512153f, -0.11415978f, -0.02612296f, 0.23684086f, 0.26546085f, 
    0.12032686f, -0.07759508f, -0.17790592f, -0.21462508f, 0.01632259f, -0.09062634f, -0.16215287f, -0.02960027f, 
    0.19777985f, 0.02911017f, -0.09543161f, -0.03237649f, 0.28113437f, 0.16213799f, 0.18347465f, -0.03509054f, 
    -0.07293908f, -0.06062272f, 0.11635865f, 0.15381534f, 0.01202028f, -0.32743472f, 0.10369737f, 0.19014527f, 
    -0.01467189f, -0.04469712f, 0.14726223f, 0.01871361f, 0.01773648f, -0.04414734f, -0.45000827f, 0.00883061f, 
    -0.30038089f, 0.02690521f, -0.03168813f, -0.10271382f, -0.17090346f, 0.08550628f, 0.06727294f, 0.18259877f, 
    -0.31244108f, 0.24980652f, 0.17921133f, -0.03993389f, -0.08261824f, 0.07139956f, -0.04754046f, -0.06304403f, 
    -0.23548330f, -0.17348248f, 0.18432674f, 0.23084664f, -0.06196197f, 0.12075651f, 0.10331766f, -0.09242404f, 
    0.10896736f, 0.05138507f, -0.21983622f, 0.15105972f, 0.08074372f, -0.09184541f, -0.08486617f, -0.01026020f, 
    -0.00488457f, 0.00306937f, 0.11364511f, 0.18491299f, 0.10436046f, -0.07629372f, 0.02757043f, 0.09413200f, 
    0.02671798f, -0.02026065f, 0.03313204f, -0.31838718f, -0.08148234f, -0.15268286f, -0.01190402f, 0.19717656f, 
    -0.03373058f, 0.11160501f, -0.14650407f, -0.10853406f, 0.01276883f, -0.11632249f, 0.17621706f, 0.06333650f, 
    -0.08812718f, -0.07595310f, 0.10613600f, 0.04119882f, 0.08525858f, -0.50189292f, 0.09665864f, -0.13222282f, 
    -0.01457095f, 0.00331074f, -0.02391420f, 0.07895894f, 0.17451683f, 0.15502688f, -0.11398142f, -0.25136960f, 
    0.02017999f, -0.13498290f, -0.07805835f, -0.14217640f, -0.08287726f, 0.08547772f, -0.01542507f, 0.40706155f, 
    0.00408896f, 0.10361842f, -0.06857689f, 0.03011365f, -0.12249800f, -0.37983924f, -0.06684121f, -0.11265847f, 
    -0.05801382f, 0.27967381f, -0.25458321f, -0.04389077f, 0.01080030f, 0.15407698f, 0.05466971f, 0.04054020f, 
    -0.28753957f, 0.16760713f, -0.53272849f, -0.15647937f, 0.03675240f, -0.17550182f, -0.02379073f, 0.06961080f, 
    -0.34721041f, 0.11346518f, 0.02445392f, -0.00475216f, 0.02390938f, 0.17130943f, -0.04094478f, 0.16100395f, 
    -0.08239499f, -0.05486273f, -0.00312474f, 0.00966270f, -0.03712757f, 0.24141383f, 0.07407985f, 0.13540955f, 
    -0.00170065f, -0.09475549f, -0.16185786f, -0.05766615f, 0.21690944f, -0.26205695f, -0.24249806f, 0.11503205f, 
    -0.02557887f, -0.10201407f, -0.01844694f, -0.01487130f, 0.03274476f, -0.44815564f, -0.04873077f, 0.11162204f, 
    0.07804026f, -0.06666540f, -0.03889488f, -0.07001829f, 0.04524180f, 0.19161521f, 0.16355249f, 0.09481743f, 
    -0.15195298f, 0.08949392f, 0.07415331f, -0.00613043f, -0.01222274f, -0.02856122f, 0.05199264f, 0.02833254f, 
    0.03566068f, -0.31060749f, 0.03045375f, -0.12431866f, 0.11904971f, 0.00400004f, -0.08763000f, -0.03670826f, 
    0.04435607f, 0.14767966f, -0.30321309f, -0.00950880f, 0.07848582f, 0.02415235f, 0.09929151f, -0.09206311f, 
    -0.07724991f, 0.04662309f, -0.52043194f, 0.01181666f, 0.01908873f, 0.10080072f, -0.01266653f, 0.04095705f, 
    0.05718294f, -0.07050951f, -0.14331186f, 0.15123017f, 0.25071391f, 0.09320604f, 0.18446775f, -0.22800025f, 
    0.17934015f, 0.19816805f, 0.04266135f, -0.05583260f, -0.24108620f, 0.19066241f, 0.03506508f, 0.01675556f, 
    -0.02467182f, 0.01431489f, 0.04640625f, 0.13660829f, -0.30050752f, 0.18401085f, -0.29659149f, 0.03315341f, 
    -0.15156211f, 0.25047702f, 0.13796875f, 0.12031828f, 0.04137893f, 0.07283794f, 0.15359563f, -0.01051598f, 
    0.12127366f, -0.12279999f, 0.04371057f, -0.06063124f, -0.04244402f, 0.06680996f, -0.06254768f, -0.29062465f, 
    0.04424768f, -0.02841860f, -0.08122932f, -0.01337093f, -0.03176577f, -0.07258571f, 0.15333550f, -0.25075850f, 
    -0.07775905f, 0.13294104f, 0.11538476f, 0.23863122f, 0.10467550f, -0.02183657f, 0.03915594f, -0.15445586f, 
    -0.08548056f, -0.12975533f, 0.07735773f, 0.04280972f, 0.06539411f, 0.13875020f, 0.20261528f, 0.02736864f, 
    -0.20169728f, 0.25583360f, 0.09747395f, 0.10741932f, -0.06114196f, 0.19241185f, -0.15015183f, 0.09025354f, 
    0.08332329f, 0.08827201f, -0.19225527f, 0.05516025f, -0.14967608f, 0.04120170f, 0.06127805f, -0.10399667f, 
    0.11673257f, -0.02668768f, -0.11538374f, 0.09745004f, 0.18330099f, -0.13010372f, -0.02447201f, -0.15315467f, 
    -0.21563840f, 0.10996491f, 0.05623455f, -0.02977364f, 0.11175041f, 0.15484871f, -0.07908722f, 0.05885565f, 
    -0.03969961f, -0.05757230f, -0.00115479f, 0.15327200f, -0.02279054f, 0.01426373f, 0.20608425f, 0.25832880f, 
    -0.15414454f, -0.13821545f, -0.15469863f, -0.02104607f, 0.07906402f, 0.03306105f, -0.40311909f, 0.15550171f, 
    -0.32549325f, 0.03271021f, -0.11844151f, 0.06988665f, -0.02035852f, 0.07747643f, -0.02371356f, 0.16611776f, 
    -0.07806990f, 0.07160269f, -0.23763464f, 0.08420498f, 0.09103008f, -0.17154594f, 0.02916420f, 0.01005541f, 
    0.31725550f, 0.04364445f, -0.12697552f, -0.00403679f, -0.07657540f, 0.11144213f, -0.04431587f, -0.03454861f, 
    -0.03598745f, -0.18286434f, -0.00033582f, -0.25619891f, 0.06504249f, -0.01447475f, -0.22015321f, -0.16477312f, 
    -0.06869493f, 0.15078020f, 0.23043251f, 0.24115106f, -0.38418493f, 0.08681297f, -0.05092105f, -0.07063923f, 
    0.07107947f, -0.03502420f, -0.07548416f, 0.27125114f, -0.17284110f, -0.39601761f, -0.10141645f, 0.04821317f, 
    0.13141991f, 0.01201339f, -0.01422912f, 0.01328960f, 0.12475499f, -0.05630789f, 0.03841919f, 0.00730663f, 
    -0.10225503f, 0.07145490f, 0.11881044f, -0.00826578f, 0.11471060f, -0.29921445f, -0.00250847f, -0.17747100f, 
    0.08382182f, 0.02764394f, 0.10956033f, 0.03479592f, 0.12409774f, 0.13659833f, -0.06500229f, -0.78440326f, 
    -0.23584065f, -0.28567034f, 0.03885672f, -0.13078541f, -0.05091817f, -0.09901132f, 0.00303035f, -0.08419295f, 
    -0.40823588f, -0.22091505f, -0.04408110f, 0.00664822f, -0.03328690f, -0.18154722f, 0.01752041f, -0.16360468f, 
    0.06066205f, 0.26169857f, -0.33947447f, 0.13223435f, -0.00397673f, -0.11430312f, 0.06343565f, -0.10464057f, 
    -0.06109468f, 0.30736741f, 0.05845321f, -0.17244665f, 0.10615321f, -0.05022608f, 0.02261049f, 0.01801315f, 
    -0.09748041f, 0.17278367f, 0.08500142f, 0.02713111f, 0.04711980f, -0.07873916f, -0.04430300f, 0.01594882f, 
    -0.03375241f, 0.03821022f, -0.02838402f, 0.25062275f, -0.11738778f, 0.06638619f, -0.10563207f, -0.09911185f, 
    -0.08048371f, -0.02927506f, 0.08807098f, -0.05065569f, 0.31827617f, -0.50370151f, -0.31404057f, 0.06052320f, 
    0.09801262f, 0.15931562f, 0.02120933f, 0.10420085f, -0.15432136f, -0.07917301f, 0.01350320f, 0.05838525f, 
    0.02564946f, -0.00564234f, -0.07259425f, -0.02559057f, 0.03255180f, 0.37345037f, 0.24577396f, 0.25695819f, 
    -0.15122604f, 0.08607487f, 0.04822811f, -0.00517676f, 0.04932239f, 0.06212658f, -0.04671432f, -0.15453759f, 
    -0.14522950f, 0.21911541f, 0.12708788f, 0.01472187f, -0.00698087f, 0.06358323f, -0.01724604f, -0.03402285f, 
    0.04460122f, -0.01844571f, -0.04380383f, 0.03706808f, -0.02364635f, 0.00460907f, 0.04918021f, -0.00535417f, 
    -0.04220954f, -0.02146252f, -0.01114827f, -0.03217359f, 0.05346475f, -0.06143215f, 0.01319739f, 0.02349363f, 
    0.05859146f, -0.01227981f, -0.01112101f, -0.00108619f, -0.05046028f, -0.00203197f, -0.01331262f, -0.04162104f, 
    -0.04111945f, -0.02769575f, -0.04552086f, -0.01101413f, -0.00746730f, -0.01212997f, -0.05129625f, 0.02133242f, 
    -0.00334647f, 0.03751942f, -0.00862117f, -0.05409469f, 0.00406690f, 0.00935654f, -0.05179131f, -0.01273680f, 
    0.05164136f, 0.02075245f, -0.05274635f, 0.04411151f, -0.06350207f, -0.01022275f, -0.00213252f, -0.03369237f, 
    0.03492440f, 0.00832363f, 0.00053170f, 0.01854631f, -0.00713986f, -0.02608884f, -0.05189079f, 0.01938612f, 
    0.02687147f, 0.05792205f, 0.00936064f, 0.00561952f, -0.05358249f, 0.02460867f, -0.05808859f, 0.04803136f, 
    -0.03128216f, -0.04238595f, 0.02488437f, 0.00655586f, -0.00884562f, 0.03349017f, 0.03450383f, 0.01518368f, 
    -0.03708070f, 0.03593401f, 0.04092532f, 0.01189898f, -0.01119380f, -0.02079230f, -0.04756212f, -0.03336353f, 
    -0.05214792f, 0.02721957f, -0.02237404f, -0.06744679f, -0.01331585f, 0.00319584f, 0.01268598f, 0.03495840f, 
    0.02159876f, -0.00873894f, 0.04456868f, -0.01374857f, -0.04818358f, -0.02242472f, -0.05778448f, -0.03486910f, 
    0.03770465f, 0.03485387f, 0.02635427f, -0.02027814f, 0.01636668f, -0.05304031f, -0.00852973f, 0.03016188f, 
    -0.04842274f, -0.04454470f, -0.03387363f, -0.02300829f, -0.06741098f, 0.01015198f, 0.04673477f, 0.04486067f, 
    -0.04867143f, -0.04182363f, 0.01563300f, 0.00277829f, -0.04146270f, -0.01146281f, -0.06459963f, 0.00534603f, 
    -0.01914382f, 0.00802494f, 0.02444027f, -0.02560448f, 0.03414130f, -0.00384445f, 0.01204716f, -0.03026633f, 
    0.05189591f, 0.04288520f, -0.02193369f, 0.01368650f, -0.01382433f, -0.04698186f, -0.05263537f, 0.00185183f, 
    -0.00880957f, 0.01151930f, -0.00144487f, -0.04416116f, 0.01519868f, -0.00475654f, -0.02406743f, 0.00563789f, 
    -0.05781465f, -0.05160981f, -0.02771215f, 0.01965714f, -0.02214828f, -0.03299032f, -0.02988584f, -0.02728331f, 
    -0.03022036f, 0.00556746f, -0.01158999f, 0.02113175f, -0.05513620f, 0.00398696f, 0.00608287f, 0.01999767f, 
    -0.02281059f, -0.04926442f, 0.03850856f, 0.00279932f, -0.01573066f, -0.05864272f, -0.00869862f, -0.04947308f, 
    0.01679940f, 0.01701603f, -0.00964061f, -0.00643348f, -0.04136769f, -0.04457170f, -0.04570863f, -0.00416081f, 
    0.01142901f, -0.00889136f, 0.00483214f, -0.05554345f, 0.03733502f, -0.02078002f, 0.02645029f, 0.01124727f, 
    -0.06531462f, -0.00289494f, -0.06242688f, -0.05648492f, -0.05557320f, -0.03652411f, -0.04217850f, -0.05906679f, 
    -0.01574924f, 0.03958056f, 0.01107972f, 0.01676771f, 0.04566759f, -0.06395947f, -0.02349337f, -0.02433137f, 
    0.05558243f, 0.01508118f, -0.02495625f, -0.06315213f, 0.04917430f, 0.02867618f, -0.01201158f, -0.05939712f, 
    0.03273758f, -0.05411044f, 0.02517541f, -0.03813636f, 0.04650699f, -0.02536165f, -0.05406138f, 0.03863920f, 
    0.04272640f, -0.04110768f, 0.01469753f, -0.04979672f, -0.06842214f, -0.00482484f, -0.01302518f, -0.03316623f, 
    -0.03627161f, 0.02308055f, 0.03918814f, -0.00875182f, 0.02349607f, 0.02088926f, 0.00934422f, -0.01017751f, 
    0.00814402f, -0.00213418f, -0.03985988f, -0.01907433f, 0.01540879f, -0.01445484f, 0.04679956f, -0.06108947f, 
    0.02652029f, 0.00484841f, -0.00680773f, 0.04783262f, -0.00314742f, -0.06613929f, 0.02184205f, -0.03887594f, 
    -0.04849419f, 0.05000618f, -0.05910917f, 0.00999358f, 0.00059469f, 0.05383265f, 0.04934521f, -0.01885087f, 
    0.00157923f, -0.03369329f, 0.02092271f, -0.03027690f, -0.02882043f, -0.01922000f, -0.00303077f, -0.03370217f, 
    -0.04167373f, 0.02376727f, 0.02982808f, 0.02679072f, -0.05320806f, 0.02286975f, -0.04637997f, -0.05152284f, 
    0.04902809f, -0.01907296f, -0.01422874f, 0.02626781f, -0.01413422f, 0.04745466f, -0.01641183f, 0.00981932f, 
    0.03410266f, -0.01317717f, -0.03402253f, -0.00494824f, -0.01622024f, 0.04762788f, -0.04066408f, -0.06161905f, 
    -0.37859380f, 0.26056802f, -0.50709105f, 0.26939040f, 0.06155270f, 0.01556468f, 0.15239315f, 0.09132428f, 
    0.01977444f, -0.40888092f, -0.17983586f, -0.21089818f, 0.13987181f, -0.02133207f, -0.02533627f, 0.01368605f, 
    0.00877805f, 0.09742898f, 0.13187239f, -0.10456067f, 0.09342586f, -0.00476996f, -0.04395476f, -0.00496233f, 
    0.20549998f, -0.01449674f, 0.11655200f, -0.08420673f, -0.02474097f, -0.27358723f, -0.02391369f, -0.16760065f, 
    -0.26155439f, 0.14932537f, 0.04510497f, 0.00073100f, -0.02383191f, -0.15643200f, -0.25610459f, 0.20299746f, 
    -0.09694186f, 0.11470816f, 0.10854184f, 0.06240122f, 0.11511343f, 0.11275692f, 0.23485574f, 0.24575464f, 
    -0.02751126f, 0.08715504f, 0.16366391f, 0.16812439f, -0.06701689f, 0.05341847f, -0.04260978f, 0.00736812f, 
    -0.20896947f, -0.03094809f, 0.15599981f, 0.13191645f, -0.03761175f, -0.09913690f, 0.15665902f, 0.03238697f, 
    0.25616267f, -0.38044342f, 0.23812519f, 0.15908475f, 0.03322632f, 0.05897722f, 0.04475468f, 0.08478718f, 
    0.20007960f, 0.23304960f, -0.41081402f, 0.26685098f, 0.11473101f, 0.08980288f, 0.02951655f, -0.13047405f, 
    -0.03922055f, 0.00176586f, 0.04711190f, 0.09895810f, -0.23574069f, -0.04370989f, 0.14523523f, 0.00375784f, 
    -0.00092325f, 0.18427961f, -0.47587860f, -0.15589881f, 0.30610049f, -0.01059199f, -0.01756099f, 0.13497810f, 
    -0.04006634f, -0.06168353f, 0.05500215f, -0.04828909f, -0.09265321f, -0.08488947f, 0.06143677f, 0.04010012f, 
    0.19949241f, 0.04102468f, 0.07928454f, -0.01662529f, -0.02748038f, 0.22990957f, 0.20974132f, 0.08089079f, 
    0.13094266f, 0.03349932f, -0.14900163f, -0.00754103f, 0.14879258f, -0.47166196f, -0.47513121f, 0.09702414f, 
    -0.05823641f, -0.09006204f, 0.06075015f, 0.02161872f, -0.03185181f, 0.04480670f, 0.11630416f, 0.18237211f, 
    -0.01781124f, 0.08960371f, 0.03262760f, 0.26143891f, 0.19092828f, 0.03766806f, 0.18119557f, 0.02305594f, 
    0.17132673f, 0.09557372f, -0.17854990f, -0.01022993f, -0.00788773f, 0.00393702f, 0.06816175f, 0.00752208f, 
    0.30442458f, 0.40299001f, 0.13670048f, 0.02990780f, 0.09388733f, 0.03616650f, -0.20350030f, -0.00157670f, 
    0.08831845f, 0.21138677f, -0.04287098f, 0.15895799f, -0.31762519f, 0.05467190f, -0.10750838f, -0.04482664f, 
    -0.00204085f, 0.14889196f, -0.44032767f, -0.35171881f, 0.11637805f, 0.00165501f, 0.12873273f, 0.04182288f, 
    0.15980931f, 0.08384539f, 0.04112929f, 0.34496826f, 0.39573294f, 0.05515069f, -0.13305645f, 0.13168298f, 
    0.12880044f, 0.04959734f, -0.06651589f, -0.08650509f, 0.22812650f, 0.12896729f, 0.07531196f, -0.05253661f, 
    0.00926245f, 0.21249905f, 0.14759682f, -0.16337517f, 0.12822071f, 0.06272384f, 0.23781474f, -0.33482143f, 
    0.13154042f, 0.01963895f, 0.06271692f, 0.08281202f, 0.03236223f, 0.02873259f, -0.39960614f, 0.11070052f, 
    0.41240945f, -0.08804463f, 0.13914576f, -0.22414370f, 0.21056499f, -0.06200054f, 0.18327057f, -0.43359134f, 
    -0.16431874f, -0.11432365f, 0.23823622f, -0.06962509f, 0.01341359f, 0.22815183f, 0.11098813f, 0.03950991f, 
    -0.36241031f, -0.12529513f, -0.20517980f, 0.12837841f, 0.08647563f, 0.03842117f, 0.08608018f, 0.04643027f, 
    0.01676214f, -0.01544947f, -0.07493348f, 0.24197565f, -0.11947606f, -0.03559761f, -0.01134756f, -0.12583435f, 
    -0.09059413f, -0.01123675f, 0.16082476f, 0.21614197f, -0.08144628f, 0.05968998f, 0.21736212f, 0.14840458f, 
    -0.15209830f, 0.08499891f, 0.18551609f, 0.08105342f, 0.16982916f, 0.11755957f, 0.35399777f, 0.06751516f, 
    0.01406154f, 0.05369097f, -0.04120197f, 0.16302852f, -0.15765536f, -0.12810886f, 0.19801383f, 0.01957821f, 
    0.02053169f, -0.01442199f, 0.05075157f, 0.09399857f, 0.02377329f, 0.41164616f, 0.10120745f, -0.37174326f, 
    0.01525239f, 0.13014302f, 0.08237965f, -0.12958270f, 0.21683294f, 0.17706406f, -0.45794865f, 0.03597153f, 
    -0.36438069f, 0.22098885f, 0.15559140f, 0.10139154f, -0.01723031f, -0.03025839f, -0.11941045f, 0.05072169f, 
    0.14643474f, -0.18069005f, -0.04410811f, -0.09231705f, 0.06163189f, 0.01519234f, 0.03228730f, -0.12947404f, 
    0.00294660f, -0.05197024f, 0.05149078f, -0.00415686f, 0.01595458f, 0.05008652f, -0.00440098f, 0.04647771f, 
    -0.04374312f, -0.03823798f, 0.02652705f, 0.03050818f, 0.03962370f, -0.03807598f, 0.00273854f, -0.04271038f, 
    -0.01076089f, -0.04577489f, 0.02312348f, -0.05533360f, -0.01032723f, 0.05253056f, -0.05054424f, -0.03854334f, 
    0.01833819f, 0.00169748f, 0.00702776f, -0.04217788f, -0.03159557f, 0.03702616f, 0.01040524f, 0.03399376f, 
    -0.03710197f, -0.05670326f, -0.01729065f, 0.02829491f, 0.04571133f, -0.03450628f, 0.01122399f, 0.01473724f, 
    -0.03388062f, -0.01448469f, -0.01662807f, 0.02413947f, -0.02574350f, -0.01199637f, -0.00791794f, -0.04142079f, 
    -0.05553886f, -0.01152948f, 0.01993864f, 0.02366773f, 0.05356645f, 0.05162660f, 0.02247619f, -0.01793518f, 
    -0.04189189f, 0.02369134f, -0.05572240f, 0.01366511f, 0.02086191f, 0.00936304f, 0.04532974f, 0.01282702f, 
    -0.04652150f, 0.03704084f, -0.04726907f, -0.02885928f, -0.04156143f, -0.01477830f, 0.02305089f, 0.01276066f, 
    -0.04937014f, 0.02813007f, -0.03768122f, 0.04149230f, -0.00972645f, -0.00085743f, -0.02658127f, -0.01848101f, 
    0.01407117f, 0.03022125f, -0.04320870f, 0.05088476f, 0.04275493f, 0.02428093f, 0.04063281f, -0.00817824f, 
    0.00918823f, -0.03508614f, 0.01849070f, 0.00099876f, 0.01550466f, 0.01033254f, -0.05522613f, 0.00331781f, 
    0.00360238f, -0.01274145f, -0.03539100f, 0.00975794f, -0.00328547f, -0.03144448f, -0.05507756f, 0.05351687f, 
    -0.00391738f, -0.00506881f, -0.04711254f, -0.01132516f, -0.05387390f, -0.00486987f, 0.00645867f, -0.05159954f, 
    -0.04022813f, -0.04707855f, -0.01535513f, -0.06284497f, -0.00354330f, 0.04043188f, -0.02666141f, 0.01640806f, 
    0.02409474f, 0.04064278f, 0.04633993f, -0.02601484f, -0.00097195f, 0.00778321f, -0.03840509f, -0.01708159f, 
    0.02760457f, 0.02088937f, -0.00258753f, -0.01341215f, -0.04054278f, -0.04333583f, -0.04508709f, -0.04517554f, 
    0.03286111f, -0.00488098f, 0.03972100f, -0.01489441f, -0.04709012f, 0.01815576f, -0.02349621f, -0.01818819f, 
    0.02089220f, 0.03668148f, -0.02688462f, -0.01831072f, -0.04813021f, -0.02731548f, -0.02900347f, 0.00820313f, 
    0.02126103f, 0.00200208f, -0.05592318f, -0.05455872f, 0.02401179f, -0.02428488f, -0.00091314f, 0.03667916f, 
    0.00193216f, -0.05291074f, -0.01956160f, 0.03949604f, -0.05572152f, -0.01745409f, 0.00393169f, 0.05058076f, 
    -0.03723615f, -0.04712016f, -0.04977692f, -0.02883247f, -0.02299179f, -0.02017090f, -0.05420329f, -0.03623454f, 
    -0.02492239f, 0.01317255f, 0.01658101f, -0.00911332f, -0.03085603f, 0.03138782f, -0.03184192f, -0.05557483f, 
    0.05049898f, 0.04358856f, -0.05269904f, -0.04570244f, 0.02545055f, -0.00978821f, -0.00395106f, 0.00386773f, 
    -0.00770671f, 0.00143985f, 0.04813381f, 0.00411572f, 0.01007727f, 0.04738147f, 0.05184060f, -0.05913527f, 
    0.00158245f, -0.06116766f, 0.05014492f, -0.04563443f, 0.02311874f, 0.00447916f, -0.00068361f, -0.03432921f, 
    -0.04818121f, 0.01484081f, -0.04800414f, 0.02670982f, -0.01353927f, -0.01120287f, -0.05053955f, -0.05098577f, 
    -0.05372119f, -0.02653129f, 0.04736048f, 0.04407492f, 0.03525392f, -0.02401203f, -0.04415269f, 0.03499187f, 
    -0.06262833f, 0.02969941f, -0.04856567f, -0.02506652f, 0.03680161f, -0.00551064f, 0.00473210f, 0.04693976f, 
    -0.03580059f, 0.01679069f, -0.02931625f, 0.01299323f, 0.02040689f, 0.00171924f, -0.04748489f, 0.00483447f, 
    -0.04050037f, 0.03840661f, 0.01173522f, 0.03502037f, -0.03117180f, 0.03033751f, -0.04729584f, -0.02258004f, 
    -0.02785981f, 0.01555323f, 0.04117904f, 0.05439810f, 0.04059397f, -0.01436302f, 0.03812324f, -0.04806165f, 
    -0.00685424f, -0.03353918f, -0.04469765f, -0.06216307f, -0.05107595f, -0.01974945f, -0.03243734f, -0.01988245f, 
    -0.01214428f, -0.05443790f, -0.04180973f, 0.02831678f, -0.05267308f, 0.05147492f, -0.02547608f, -0.05033254f, 
    0.04266940f, -0.02888395f, -0.03574361f, 0.03050075f, -0.03787042f, -0.00059212f, -0.01181675f, 0.02452718f, 
    -0.03681708f, -0.04308164f, 0.03641702f, 0.00908437f, 0.04530112f, -0.03344875f, -0.04091501f, -0.03177887f, 
    0.25742352f, -0.07085847f, 0.41256195f, 0.01560718f, -0.03226895f, 0.01822153f, 0.11213222f, 0.26580518f, 
    -0.00584588f, -0.01994838f, -0.04121922f, 0.33407712f, 0.04070411f, -0.01793396f, 0.04612540f, -0.06808195f, 
    0.00791247f, 0.02751644f, 0.31137529f, -0.16323245f, -0.00653673f, 0.04769289f, 0.02482046f, 0.04979251f, 
    0.01776732f, 0.04845251f, 0.06108045f, -0.15752546f, -0.21239029f, 0.06777871f, -0.12238158f, -0.01812236f, 
    -0.02011095f, 0.09470919f, 0.16245176f, -0.31072596f, 0.08455057f, -0.04986362f, -0.08389051f, 0.01754862f, 
    -0.07716040f, -0.11928319f, -0.06259832f, 0.13143715f, 0.07061548f, -0.29154789f, -0.22337164f, 0.01530719f, 
    -0.00832643f, -0.04668063f, -0.06394117f, 0.00152383f, -0.01942687f, 0.17092603f, 0.15446377f, 0.08096194f, 
    0.01670502f, 0.12660293f, 0.09196534f, -0.17452243f, -0.22771266f, -0.13326786f, -0.11252920f, 0.07633808f, 
    0.01404470f, 0.08750543f, 0.04535521f, -0.10891699f, 0.10728637f, -0.09455604f, 0.04603324f, -0.07632807f, 
    0.00408426f, 0.00823534f, 0.28696537f, 0.21019126f, -0.12953092f, -0.01974400f, 0.00218875f, -0.07477702f, 
    -0.01954355f, -0.09874818f, -0.04892785f, -0.20216627f, 0.13502094f, 0.00718646f, -0.19049336f, -0.02014160f, 
    0.05538151f, 0.00667094f, 0.09510772f, -0.08677854f, 0.00787899f, 0.03824738f, 0.14213279f, -0.09792905f, 
    0.01063212f, -0.13935697f, -0.07298522f, 0.13600844f, 0.00966750f, 0.10846590f, 0.06339484f, 0.06804454f, 
    -0.02155069f, 0.06324462f, -0.06852125f, 0.09413866f, -0.11021586f, -0.19489296f, 0.04522805f, 0.08997553f, 
    -0.07373285f, 0.02631994f, 0.07598282f, 0.02806378f, 0.16028424f, 0.19913115f, -0.02880287f, 0.04019339f, 
    0.04122654f, -0.06009370f, 0.01262898f, 0.06343675f, 0.04002500f, 0.02074424f, 0.10838708f, -0.06485070f, 
    -0.01685136f, -0.18996014f, 0.07381925f, 0.02746445f, 0.06746407f, -0.01205099f, 0.11031312f, -0.30258971f, 
    -0.26602432f, -0.01365219f, -0.06880604f, -0.10504385f, 0.00179710f, 0.13365023f, -0.14432855f, -0.05586877f, 
    -0.57629228f, -0.01952336f, 0.15148535f, -0.06202086f, -0.01728130f, 0.04642287f, -0.02410220f, -0.10229388f, 
    -0.01527572f, 0.06610212f, 0.22624858f, -0.10586279f, 0.10048680f, -0.08587267f, -0.09597260f, 0.09594777f, 
    -0.11971627f, -0.07853620f, 0.14424375f, 0.01141518f, 0.08304233f, -0.02451062f, 0.05480934f, -0.08018386f, 
    -0.24784938f, 0.06745739f, 0.09093263f, -0.20286560f, 0.17215043f, 0.10229334f, 0.13528135f, 0.02275609f, 
    -0.01476928f, -0.23489261f, -0.20508654f, -0.04688528f, -0.38657761f, -0.21528131f, -0.02111568f, -0.03197622f, 
    -0.12025671f, -0.02032691f, 0.02040449f, -0.01608293f, 0.04663444f, 0.07370362f, 0.04804888f, 0.02046643f, 
    -0.12105829f, -0.04352793f, -0.03359340f, -0.11055104f, 0.20140918f, -0.13507867f, 0.06237070f, 0.11866210f, 
    0.04190757f, -0.12612137f, 0.04158345f, 0.02699220f, 0.03201830f, 0.27657038f, -0.23133811f, -0.11748522f, 
    0.04089662f, 0.54009902f, -0.18046710f, -0.07111737f, -0.02280088f, -0.00939964f, 0.03485612f, -0.05913186f, 
    0.17428309f, -0.09886076f, 0.31844354f, -0.01381313f, 0.12818564f, 0.16647767f, 0.12872228f, -0.05608151f, 
    0.18113996f, -0.20720632f, -0.16582748f, 0.00957701f, 0.00610965f, 0.07061820f, -0.12207267f, -0.16305020f, 
    -0.00160149f, 0.00254410f, 0.01261540f, 0.09986729f, 0.21090779f, 0.03167864f, -0.08682624f, -0.01138166f, 
    -0.16809310f, -0.03488383f, 0.03095606f, -0.24949160f, -0.06067100f, 0.01227989f, 0.01367500f, 0.02596605f, 
    0.16844928f, -0.03287413f, -0.06223307f, 0.19325227f, 0.45203120f, 0.14657705f, -0.15773176f, 0.13653523f, 
    0.01846200f, -0.07349019f, -0.10338803f, 0.17032330f, -0.28657353f, 0.07974365f, -0.03713031f, -0.16484986f, 
    0.06628078f, -0.16492836f, 0.10600056f, -0.03781338f, -0.08327246f, -0.13923483f, 0.12342352f, -0.11267694f, 
    0.11602316f, -0.01722207f, -0.14647585f, -0.03392869f, 0.14245270f, 0.04298056f, -0.04712593f, 0.08949304f, 
    0.13461457f, 0.21852206f, -0.09870559f, 0.07839581f, 0.09990084f, -0.30945098f, 0.01577367f, -0.03819152f, 
    0.02528020f, 0.18801311f, 0.18365583f, 0.17451727f, -0.06756509f, -0.10139611f, 0.03051529f, -0.11107324f, 
    0.15852742f, -0.13906814f, 0.13588543f, 0.07312166f, 0.11759643f, 0.05306412f, -0.10002527f, -0.12108296f, 
    -0.04821093f, -0.22976449f, -0.20731448f, 0.10064950f, 0.21931943f, 0.00478196f, 0.07176039f, 0.01652502f, 
    0.02542756f, -0.07240134f, -0.06462802f, -0.27324075f, -0.09540240f, 0.06859939f, -0.20184192f, 0.28009111f, 
    -0.06764171f, 0.12285672f, -0.16133083f, -0.03390575f, -0.13074969f, -0.05103774f, 0.12033839f, 0.11124881f, 
    -0.12690929f, -0.13819937f, 0.00728949f, -0.07518768f, 0.06295939f, -0.02950010f, -0.03908535f, -0.31196463f, 
    0.03628191f, -0.05475395f, -0.09446277f, 0.13201915f, -0.13906240f, -0.10898583f, 0.01558212f, 0.11091473f, 
    -0.04769468f, 0.06672113f, -0.04180329f, 0.07017490f, -0.09005976f, 0.01954028f, -0.09826937f, 0.10157267f, 
    0.27372479f, -0.08143166f, -0.00360490f, -0.01600993f, 0.02206416f, -0.01446410f, 0.07689772f, -0.08423527f, 
    -0.09894292f, 0.01860474f, -0.11038741f, 0.02133683f, 0.01389595f, 0.06007901f, 0.00263812f, -0.10319278f, 
    -0.17989090f, -0.06010629f, -0.05232284f, 0.05446167f, 0.03916874f, 0.00370529f, 0.00903222f, 0.05171791f, 
    -0.03855152f, 0.10374464f, 0.13213728f, 0.00245583f, -0.05444168f, -0.03680066f, 0.18373062f, 0.07017590f, 
    0.19056831f, -0.12141965f, -0.09655940f, 0.45971364f, 0.32300320f, 0.07541752f, -0.05920353f, -0.07859978f, 
    -0.19078577f, 0.09797314f, 0.01383408f, 0.13180520f, -0.11993531f, -0.07023899f, -0.19061272f, 0.05150886f, 
    -0.05151279f, -0.06450939f, -0.12087835f, -0.00099336f, -0.06403203f, 0.34439579f, 0.22544451f, 0.08672838f, 
    -0.12391844f, 0.03056644f, -0.25949484f, 0.10967831f, 0.09808075f, 0.10231809f, 0.11148976f, -0.06605969f, 
    0.20336707f, -0.06129026f, -0.00286877f, -0.15137273f, -0.02920284f, 0.01323090f, -0.06827673f, -0.08407585f, 
    0.17583546f, 0.21406597f, -0.03044476f, -0.14888279f, 0.12282183f, -0.06404725f, -0.10833700f, 0.19168743f, 
    -0.19051449f, -0.15503405f, -0.13454071f, 0.02670008f, 0.05873078f, 0.02537974f, -0.22840007f, -0.11232366f, 
    -0.02830441f, -0.11374052f, 0.03236857f, -0.05117229f, 0.03429219f, 0.09826916f, -0.04521050f, 0.13712491f, 
    -0.07951105f, 0.14208668f, 0.03764771f, -0.09369240f, 0.02353306f, 0.00281187f, -0.13651982f, -0.00172226f, 
    0.20569572f, -0.15754400f, 0.05619111f, 0.02265834f, -0.07825097f, -0.00504789f, 0.07843449f, -0.08079388f, 
    0.03155164f, -0.00333460f, -0.07557437f, -0.09921047f, 0.17107609f, 0.19260079f, 0.07551242f, -0.15743591f, 
    0.06122307f, 0.13053520f, 0.11477917f, -0.01655223f, 0.01442132f, 0.14181167f, 0.08250815f, -0.00356776f, 
    -0.16482240f, -0.09048285f, -0.04390582f, 0.12528504f, -0.02003166f, 0.11283868f, 0.25902539f, 0.13988546f, 
    -0.15051079f, -0.07582062f, -0.05221831f, 0.00206739f, 0.18938376f, -0.00331339f, -0.09524024f, -0.20193517f, 
    0.06976558f, 0.06767055f, 0.14782086f, 0.05958069f, 0.06773756f, -0.19432648f, 0.15728377f, -0.14964825f, 
    0.18664940f, 0.17646229f, 0.26956147f, 0.06160386f, 0.04904704f, -0.14790305f, 0.11741278f, 0.07539640f, 
    0.30531538f, -0.18299386f, 0.12817113f, -0.17810768f, -0.00029692f, -0.28866705f, 0.14881167f, 0.07378659f, 
    -0.00954684f, 0.05612336f, -0.02398538f, -0.31768391f, 0.07133754f, -0.13976823f, 0.02399531f, 0.02382891f, 
    -0.23463054f, 0.04882278f, -0.07730301f, 0.20295580f, -0.22236295f, -0.06406230f, -0.00805483f, 0.04954726f, 
    0.15628859f, 0.06646287f, 0.01562642f, -0.05283082f, -0.05571914f, 0.06156800f, -0.01336960f, 0.03972281f, 
    -0.10807105f, -0.01566258f, 0.07419493f, -0.01776161f, -0.03171543f, 0.21584773f, -0.23452705f, -0.13893369f, 
    -0.12202607f, 0.14865354f, -0.04031264f, 0.07988617f, -0.03785107f, -0.13926250f, -0.03587848f, 0.08873846f, 
    -0.06623001f, -0.00754891f, 0.10067328f, -0.02759622f, 0.07410648f, -0.03582786f, 0.05336688f, -0.02915036f, 
    -0.00118937f, 0.00302284f, -0.06815931f, -0.11892174f, -0.04315182f, 0.04260393f, -0.19191355f, -0.28071085f, 
    0.16405673f, -0.37782592f, 0.16134608f, -0.00437132f, -0.04423288f, -0.02278712f, 0.09167281f, 0.09511743f, 
    0.14296564f, -0.17868929f, -0.33248413f, -0.03872961f, -0.02392275f, 0.18481712f, -0.09390584f, 0.17417747f, 
    0.14003201f, 0.06812735f, 0.00773669f, 0.02410356f, 0.05980953f, 0.08378264f, 0.20149668f, -0.01971344f, 
    0.14495978f, -0.04995041f, -0.10972495f, -0.25244546f, 0.12064438f, 0.25925645f, 0.01223822f, 0.14704858f, 
    0.05148545f, 0.07776330f, -0.10937929f, -0.13806915f, -0.11801746f, 0.15342677f, -0.12004841f, 0.10841023f, 
    0.07867854f, 0.00073846f, 0.03786384f, 0.14199939f, 0.01957033f, 0.00598989f, -0.00467026f, 0.14432739f, 
    -0.11962824f, 0.11588693f, 0.20560212f, -0.06071397f, 0.07073398f, 0.02839924f, -0.47686028f, -0.24596578f, 
    0.07704884f, -0.04464062f, -0.00321434f, -0.15315829f, 0.08398212f, 0.01169220f, 0.05196557f, -0.24646068f, 
    -0.08845118f, 0.24108332f, -0.08679921f, 0.17172849f, 0.05996700f, -0.22024773f, 0.03167054f, 0.00565373f, 
    -0.24647638f, -0.43547717f, 0.20800847f, 0.04372441f, 0.19249143f, -0.04577994f, 0.12641847f, 0.01139157f, 
    0.19978462f, 0.00726567f, 0.06077658f, 0.26123205f, 0.16305101f, 0.30932686f, 0.10418492f, 0.01823601f, 
    0.06188708f, 0.02308809f, -0.11222887f, 0.21397498f, -0.03054394f, -0.01448471f, 0.11739214f, -0.08422209f, 
    0.26389807f, 0.22960420f, 0.19063869f, 0.07741239f, -0.13188963f, -0.06034566f, 0.07582319f, 0.03100108f, 
    -0.07694910f, 0.13963811f, 0.22587632f, 0.03147460f, -0.14956827f, 0.08406807f, 0.14660452f, -0.16278720f, 
    0.03853071f, 0.03571595f, -0.06149748f, -0.02474131f, -0.04027332f, 0.07441385f, 0.17779976f, 0.00698760f, 
    0.02708530f, 0.00494376f, 0.07066955f, 0.19634677f, -0.02138728f, -0.01625586f, -0.18885680f, 0.10432486f, 
    -0.05992257f, 0.23810121f, 0.11003281f, -0.02857812f, -0.16623768f, -0.03218962f, 0.22181311f, 0.01848218f, 
    -0.21462941f, 0.13614805f, -0.26224250f, -0.05137057f, -0.04339715f, 0.06990100f, 0.08784482f, 0.01363938f, 
    0.15512541f, -0.27586874f, -0.25036061f, -0.20395328f, -0.03348675f, 0.07643174f, -0.10285944f, -0.00363047f, 
    -0.03470780f, -0.42221761f, 0.04669676f, 0.01705671f, 0.00537358f, -0.04986693f, -0.17856833f, -0.06558962f, 
    -0.02902024f, -0.04966024f, 0.43203941f, 0.25698400f, -0.09532301f, 0.11385995f, 0.08189558f, 0.01989040f, 
    -0.09683906f, 0.00353413f, 0.09410295f, -0.13192432f, 0.17334238f, -0.33162200f, 0.18265727f, -0.02476920f, 
    0.06803028f, -0.17440696f, 0.03500378f, -0.25756732f, -0.37081790f, 0.01063923f, 0.14317651f, -0.12970032f, 
    -0.01440017f, 0.03908682f, -0.05918152f, 0.23156999f, 0.01839431f, -0.24221452f, -0.18743148f, 0.23676594f, 
    -0.06087095f, -0.01260003f, -0.13945714f, -0.01348714f, -0.11144556f, 0.00331409f, -0.17709526f, -0.43297628f, 
    0.03350949f, -0.07345758f, -0.19412902f, -0.08837309f, -0.08167701f, 0.05826054f, -0.00190773f, -0.02664171f, 
    -0.33490559f, 0.02137358f, -0.14523123f, 0.06588898f, 0.15297943f, 0.18800281f, -0.03746693f, 0.10406608f, 
    0.42439297f, -0.00784657f, -0.17387563f, -0.00312869f, -0.03872778f, -0.28641343f, 0.04346664f, 0.10709311f, 
    0.33604211f, -0.03712337f, 0.04148033f, -0.05161969f, 0.11340174f, -0.20183060f, 0.03358703f, -0.11676572f, 
    0.03317013f, -0.17484874f, -0.15939435f, -0.04495912f, -0.16857871f, 0.11393266f, 0.04420331f, 0.08148193f, 
    -0.13590045f, -0.04692544f, -0.03480486f, -0.11521293f, -0.06634928f, -0.04639592f, -0.13181750f, -0.06295791f, 
    0.23492779f, -0.07676224f, -0.07265172f, -0.25848395f, 0.02215977f, -0.34898114f, -0.31830156f, 0.00515000f, 
    0.19094822f, -0.18115383f, 0.20186037f, 0.16260758f, 0.15346220f, 0.05768529f, -0.03312530f, -0.09575973f, 
    0.10386209f, 0.05264806f, 0.10051966f, -0.05334692f, -0.09096283f, -0.04400268f, 0.46486077f, -0.22377186f, 
    0.10965440f, 0.09851252f, 0.00986938f, -0.15748444f, 0.04510521f, 0.02581626f, -0.04472211f, -0.26614654f, 
    0.14597876f, 0.04666172f, 0.15887859f, 0.10337926f, 0.03481694f, -0.09333609f, 0.24046275f, 0.12625504f, 
    -0.23580723f, 0.07843311f, -0.06637508f, 0.08508565f, 0.05376311f, 0.00120771f, 0.05637562f, 0.04360629f, 
    0.02053889f, -0.13987058f, -0.13487056f, 0.11319275f, -0.05416156f, 0.07837716f, -0.00868380f, 0.10414190f, 
    -0.14207037f, 0.00629034f, -0.03792063f, 0.11350691f, 0.12214784f, 0.06938945f, 0.08472020f, -0.12321094f, 
    0.09163871f, 0.09063639f, -0.01071529f, 0.02585866f, 0.02148532f, 0.16935897f, 0.03640046f, 0.03011635f, 
    -0.01592432f, -0.03621658f, -0.02356733f, 0.13543750f, -0.20092100f, -0.16090126f, -0.16033961f, -0.15973918f, 
    -0.08838227f, -0.06671057f, 0.03539118f, 0.08121309f, -0.03460562f, 0.00265823f, -0.01609880f, 0.14132626f, 
    -0.07170606f, 0.00646217f, 0.00647259f, -0.09450714f, 0.07739364f, -0.04064000f, -0.08128466f, -0.18308382f, 
    -0.11038004f, 0.11403272f, 0.07597909f, -0.02567596f, 0.06803798f, 0.05387218f, 0.02591161f, -0.09314467f, 
    -0.20852482f, 0.20246749f, 0.15211350f, 0.14746733f, -0.02456367f, -0.10506346f, 0.17305550f, 0.02078729f, 
    -0.47876424f, 0.05804205f, 0.00511285f, 0.09757450f, 0.03614900f, -0.02176148f, 0.00988273f, -0.03107723f, 
    -0.13732706f, 0.10558927f, 0.21301243f, 0.09979952f, -0.16197234f, -0.14822727f, 0.15985529f, 0.26704597f, 
    0.19357373f, 0.19336775f, 0.32188192f, 0.01318898f, -0.17437044f, 0.06926215f, 0.05064462f, 0.03163217f, 
    -0.01436354f, 0.05050459f, -0.06430146f, 0.27379689f, 0.29033232f, -0.05401438f, 0.06809808f, -0.13059051f, 
    -0.12502009f, 0.11889260f, -0.00457859f, -0.05994912f, -0.00723820f, -0.04885280f, 0.17001867f, -0.04314975f, 
    -0.08693523f, -0.09141315f, 0.10763440f, 0.01588554f, 0.09083652f, 0.24405421f, 0.31004149f, 0.31920829f, 
    0.03784074f, 0.02363321f, -0.19283721f, 0.02256915f, 0.03128966f, 0.14200927f, -0.16126660f, 0.00347441f, 
    -0.17481744f, 0.00332362f, -0.05597619f, 0.06193170f, -0.09895607f, 0.03452929f, 0.20513701f, -0.13048945f, 
    0.24647717f, 0.06976831f, -0.07083128f, -0.03644408f, -0.02450760f, -0.10322605f, 0.05210059f, -0.00687658f, 
    -0.08143242f, 0.00309847f, 0.13743907f, -0.18942033f, -0.17187528f, -0.05276342f, -0.19954334f, -0.02598292f, 
    0.02761678f, -0.44647315f, -0.02722544f, -0.35779479f, -0.06318831f, 0.00984901f, 0.05706808f, 0.04753749f, 
    0.04738079f, 0.00812675f, 0.55644691f, -0.00454492f, 0.01767336f, 0.13293599f, 0.09834756f, -0.05516004f, 
    0.07643332f, -0.04497308f, 0.09829228f, -0.10634607f, 0.01935553f, -0.05737261f, -0.06696190f, -0.06641454f, 
    0.05528643f, -0.10486776f, 0.09570472f, 0.17635459f, -0.08155398f, 0.01405232f, 0.00644092f, -0.38289770f, 
    0.01344279f, 0.01510958f, -0.24622183f, 0.06784796f, 0.04664805f, -0.05072707f, -0.37849733f, -0.13209276f, 
    -0.05338980f, 0.23808943f, -0.09165231f, 0.09626449f, 0.05835988f, -0.00723521f, -0.02866844f, 0.12083618f, 
    -0.18053615f, 0.12992704f, -0.14635934f, -0.12430791f, 0.21892750f, 0.04440631f, -0.02879062f, 0.01715632f, 
    -0.03224331f, -0.03595559f, -0.19175979f, -0.16311137f, -0.15757807f, 0.02008288f, 0.04443343f, 0.06087621f, 
    0.09191073f, 0.17988741f, -0.26913735f, 0.07468376f, -0.00832691f, 0.00537951f, 0.02390097f, 0.00600744f, 
    0.01135110f, -0.35963148f, 0.00659274f, 0.11409768f, -0.24923530f, -0.15047130f, -0.00205874f, -0.06714751f, 
    0.09073327f, -0.01819596f, 0.14306858f, -0.13989806f, 0.18922867f, -0.07261337f, 0.00830538f, -0.14248897f, 
    -0.00699956f, -0.05003998f, -0.03267911f, 0.14541203f, -0.07835615f, 0.15394424f, -0.10295847f, -0.20382281f, 
    -0.20574255f, -0.04564058f, 0.02476357f, 0.06208524f, 0.19622545f, 0.06512852f, 0.05573813f, -0.12033147f, 
    0.12290423f, 0.04976002f, 0.00346047f, -0.11357361f, -0.01197097f, -0.22786559f, 0.21948516f, 0.06847891f, 
    -0.08823881f, -0.03074033f, -0.10204758f, 0.06816756f, 0.15546995f, 0.15813957f, -0.45055193f, 0.01888618f, 
    0.05530285f, 0.00228015f, -0.03668693f, -0.00394787f, 0.00718331f, 0.03884409f, -0.01010169f, 0.01282158f, 
    -0.13436225f, 0.06660282f, 0.06644511f, 0.06480468f, -0.01155925f, -0.11081862f, 0.06650060f, 0.07139182f, 
    -0.25981900f, 0.12554601f, 0.33330339f, 0.09552053f, 0.01268653f, 0.00608860f, -0.17865169f, 0.04881506f, 
    -0.03047306f, 0.00457056f, 0.49238431f, -0.09183298f, -0.10549278f, -0.04204868f, -0.09594274f, 0.01281128f, 
    0.02490660f, 0.09634067f, -0.04884196f, -0.06696830f, -0.02415685f, 0.01288697f, 0.05648002f, -0.00042310f, 
    0.08348095f, 0.17859216f, 0.27913952f, -0.23939256f, 0.26627150f, 0.07865258f, -0.19851191f, 0.07761394f, 
    -0.01400264f, 0.01357417f, 0.04029549f, -0.04441476f, -0.56126189f, 0.21456277f, 0.06757479f, -0.00921686f, 
    0.14721373f, 0.05183094f, 0.09683255f, -0.18076600f, -0.20300862f, -0.16907436f, -0.11198975f, -0.09569030f, 
    0.08212725f, 0.13889229f, -0.04654542f, 0.01867862f, -0.11650483f, -0.31382772f, -0.10318339f, 0.08662041f, 
    0.00977488f, -0.11286920f, -0.10073140f, 0.00724411f, 0.05753480f, 0.23668469f, 0.22173388f, -0.05151417f, 
    0.16400114f, 0.36952984f, -0.06322456f, -0.22539122f, -0.06589193f, 0.04027229f, 0.08788199f, 0.01133796f, 
    -0.17673869f, 0.16901685f, 0.09985335f, 0.01808522f, -0.03991259f, 0.14894626f, -0.19145529f, 0.05672655f, 
    -0.00343391f, 0.26772484f, -0.04216179f, 0.00199568f, 0.04376276f, 0.03798808f, 0.06149730f, -0.00947982f, 
    0.06562455f, 0.03652730f, -0.15036479f, 0.00264103f, 0.09795893f, -0.23495358f, 0.01083429f, 0.03144858f, 
    -0.05473389f, 0.02872903f, -0.04382363f, 0.09719517f, -0.01272572f, 0.11603554f, -0.15868632f, -0.16882066f, 
    0.32245141f, 0.05750401f, 0.22150987f, -0.03126493f, 0.02101180f, -0.01638477f, -0.02352045f, 0.19736384f, 
    0.10793879f, -0.12613922f, 0.03158149f, -0.01413838f, -0.16818404f, -0.04462744f, 0.12421075f, 0.08014125f, 
    -0.03038762f, -0.28087714f, 0.27264389f, 0.00174431f, 0.03355588f, -0.00072969f, -0.07299653f, -0.09985444f, 
    0.00891254f, -0.07389982f, 0.01798370f, -0.14167635f, 0.15564528f, 0.01291623f, 0.00958433f, -0.06815845f, 
    0.13772970f, -0.12517235f, 0.02618845f, 0.02083411f, 0.08200456f, -0.10607723f, -0.05959224f, -0.10535873f, 
    -0.35401687f, -0.18101171f, -0.42288169f, 0.21876660f, 0.09597212f, -0.06333102f, 0.00552361f, 0.02321023f, 
    0.12113200f, 0.06027251f, -0.42303073f, -0.07973801f, 0.20091300f, 0.02276465f, 0.12202170f, 0.05215398f, 
    -0.04506274f, -0.04825559f, -0.07847343f, 0.16086224f, 0.19963506f, 0.19024289f, -0.07491168f, 0.06626447f, 
    -0.02357142f, 0.10652426f, -0.12024100f, -0.29222995f, 0.15064409f, -0.33838621f, -0.19988267f, -0.01476122f, 
    -0.07958966f, 0.02524097f, 0.03259498f, 0.03232116f, -0.10401787f, 0.00555873f, 0.01389513f, 0.11657616f, 
    0.02013731f, -0.01704990f, 0.13021493f, -0.16957229f, -0.36161947f, 0.19578578f, -0.32061887f, 0.01417047f, 
    0.11632960f, 0.22282262f, -0.07957917f, 0.11681856f, -0.11276678f, -0.08151726f, 0.12791936f, -0.10301108f, 
    -0.07850648f, -0.13855723f, 0.04339982f, 0.04522300f, -0.05365582f, 0.12905069f, 0.13380183f, 0.07823563f, 
    0.31911367f, 0.18201493f, -0.10839164f, 0.07540859f, 0.06486193f, 0.13046393f, 0.08071776f, 0.13386466f, 
    -0.23058186f, -0.22917509f, 0.30534568f, 0.00400060f, 0.00784881f, 0.02150296f, -0.15016341f, -0.03664064f, 
    0.00901509f, -0.11022069f, 0.12433323f, -0.18911791f, 0.19424762f, -0.10932879f, -0.10052148f, 0.22280551f, 
    -0.00813872f, -0.11263622f, -0.29667005f, -0.00840130f, -0.23505084f, 0.22321443f, 0.21545281f, 0.00801341f, 
    0.11671875f, 0.05404100f, 0.14680505f, -0.11008679f, -0.02895595f, -0.09608477f, 0.08053150f, 0.06971822f, 
    -0.01178515f, 0.17316039f, 0.12986159f, -0.27686301f, -0.24303047f, 0.15756224f, -0.10913363f, 0.04309242f, 
    -0.10766958f, 0.03433876f, 0.17681924f, 0.19469485f, 0.24481167f, -0.09089199f, -0.31060135f, -0.28672379f, 
    0.10685226f, 0.11133089f, 0.14300573f, -0.03606422f, -0.07011975f, -0.03234186f, -0.13476449f, 0.05202142f, 
    0.20584550f, -0.10268502f, 0.13541980f, 0.03947081f, -0.08926494f, -0.10801180f, 0.01061056f, -0.25049216f, 
    0.27487111f, -0.04223294f, -0.07956869f, -0.06351322f, -0.16662714f, 0.22409867f, 0.11703899f, 0.13994545f, 
    0.01726644f, 0.13558961f, -0.14786254f, 0.04886664f, -0.01686130f, -0.07585756f, 0.05214509f, 0.14607611f, 
    0.06490330f, 0.14747226f, 0.21666849f, -0.25923812f, 0.00897015f, -0.04660373f, -0.12360498f, 0.03325346f, 
    0.05620984f, -0.03894323f, -0.20306854f, -0.02417743f, -0.04116487f, -0.02993456f, -0.06292987f, 0.18688880f, 
    0.21609169f, 0.05015824f, 0.23261803f, 0.18022847f, 0.13344711f, -0.19584544f, -0.07995234f, -0.20891479f, 
    0.02447568f, 0.15270403f, -0.04275195f, 0.02641868f, -0.28657085f, -0.01844364f, -0.02455234f, -0.00953615f, 
    -0.01905129f, 0.09654875f, 0.11497498f, -0.04334756f, 0.11216014f, -0.04086423f, -0.40327165f, -0.13500442f, 
    -0.03131231f, -0.02575008f, -0.13650382f, 0.03096205f, 0.07286920f, -0.09976207f, 0.43777886f, -0.06237114f, 
    -0.09234168f, -0.08020120f, -0.01592534f, -0.08474349f, 0.03680472f, -0.03675275f, -0.01723005f, 0.06903813f, 
    0.14831179f, -0.12396175f, 0.02033158f, -0.26201904f, -0.02110868f, -0.00802780f, 0.07262731f, 0.05231455f, 
    -0.10935421f, 0.15274073f, -0.06567124f, -0.06150152f, 0.04292144f, -0.06531234f, -0.04385607f, 0.08484429f, 
    -0.11937934f, -0.35432851f, -0.09855073f, -0.35408899f, 0.06432364f, -0.00255078f, 0.07129660f, 0.01230688f, 
    0.15460300f, 0.05643895f, 0.24732856f, 0.14025348f, 0.06051476f, 0.12551971f, 0.20367379f, 0.16989127f, 
    -0.10454539f, 0.01728426f, 0.09481782f, -0.14318447f, 0.17419487f, -0.01591871f, 0.03423759f, 0.04283916f, 
    -0.00857082f, 0.08340048f, 0.04774115f, 0.22265577f, -0.28055096f, -0.01429169f, 0.04600034f, 0.04202802f, 
    -0.05671908f, -0.05277245f, 0.06065611f, 0.21804918f, 0.03948821f, -0.19867262f, 0.11045060f, 0.11907452f, 
    -0.06622200f, 0.09320088f, -0.07563095f, -0.09019433f, 0.03874349f, 0.00328004f, -0.21945113f, -0.10492862f, 
    -0.23497808f, 0.04860993f, 0.04648473f, 0.13283655f, -0.11076191f, 0.02938325f, 0.08316381f, 0.06534155f, 
    0.01299891f, 0.09746929f, -0.07826284f, -0.02054883f, 0.12953340f, -0.14150335f, 0.17584611f, -0.01087802f, 
    0.09303847f, -0.39458716f, 0.10141101f, 0.08079965f, -0.02969683f, 0.14370795f, 0.00448039f, 0.03054085f, 
    0.16078837f, -0.02043619f, -0.16220844f, 0.08387800f, -0.04884734f, 0.06096626f, 0.00726076f, 0.14805032f, 
    -0.06443055f, -0.01177296f, 0.15031101f, 0.31632945f, -0.00591952f, 0.16153084f, -0.14924285f, 0.00613818f, 
    0.06879293f, 0.06885560f, 0.11027910f, -0.20980442f, -0.05801569f, 0.07431387f, 0.04871656f, 0.10272866f, 
    0.14283682f, -0.22927673f, -0.05176537f, 0.16967164f, 0.06864052f, -0.23780508f, 0.00854732f, 0.07118700f, 
    -0.00833907f, 0.09099481f, 0.07822309f, -0.01029591f, -0.17706113f, -0.07540849f, 0.11424687f, -0.24942762f, 
    -0.19910619f, -0.20477742f, -0.06506284f, -0.11329658f, 0.20393933f, 0.00086616f, 0.03975022f, -0.28028816f, 
    -0.06471404f, 0.07592718f, 0.03887524f, -0.05904895f, -0.07015648f, 0.07636364f, -0.05042732f, 0.10474575f, 
    0.18979059f, -0.30957285f, -0.11385603f, 0.07880864f, -0.18362349f, -0.10791555f, 0.04796523f, -0.07469394f, 
    0.19062516f, 0.19497292f, -0.13275942f, 0.01085337f, 0.16113131f, 0.01438950f, -0.17027375f, 0.05565192f, 
    0.16611297f, 0.02294600f, -0.41599789f, -0.07901055f, -0.22848792f, -0.02930659f, 0.09269428f, 0.01038069f, 
    -0.03568279f, -0.02337633f, 0.03540280f, -0.03793620f, 0.11483499f, 0.02827051f, -0.01122809f, -0.04026622f, 
    0.13121766f, 0.04497925f, 0.09478983f, -0.12606370f, -0.65079248f, 0.12021069f, -0.10376492f, -0.00693783f, 
    -0.11989651f, 0.17051344f, 0.02195274f, 0.17317376f, 0.65542531f, -0.19004029f, -0.13350430f, -0.08813903f, 
    -0.02097300f, 0.05614411f, 0.17072801f, 0.07175229f, 0.00910159f, 0.08765996f, -0.26516473f, 0.17619401f, 
    0.27453128f, -0.10002449f, -0.02360174f, 0.11775630f, -0.08796308f, 0.03616343f, -0.10480373f, 0.10166310f, 
    -0.26647431f, 0.01584063f, -0.20382106f, 0.05112649f, -0.02902355f, -0.18388246f, 0.00834814f, 0.07021862f, 
    0.13628276f, -0.14014530f, -0.01130897f, -0.05156857f, -0.11310505f, -0.02416043f, -0.00050027f, 0.01317439f, 
    -0.06216189f, -0.07462235f, 0.58351862f, 0.12003671f, 0.05982626f, -0.02587469f, 0.01783603f, 0.01460647f, 
    0.17448051f, 0.38153681f, -0.06065074f, 0.02197617f, -0.13011009f, -0.08942206f, -0.03999147f, -0.04927304f, 
    0.18688232f, -0.04205437f, 0.09506519f, 0.02713139f, -0.55018914f, -0.16097523f, 0.02402816f, 0.24089105f, 
    -0.01464433f, -0.08364815f, 0.03707115f, -0.07787580f, 0.04255152f, -0.14558016f, 0.03359018f, -0.04506943f, 
    0.11229507f, -0.00160199f, 0.04242397f, -0.25125346f, -0.09970472f, -0.19377315f, -0.18106651f, 0.05794103f, 
    -0.10546023f, -0.08212052f, -0.00372076f, 0.04093840f, 0.02627328f, -0.04068194f, 0.10445482f, -0.04071374f, 
    -0.05283337f, 0.02141896f, 0.03381725f, -0.14464228f, -0.05310187f, -0.05026729f, 0.39673096f, -0.09934296f, 
    0.11319585f, 0.07228075f, 0.15597627f, -0.08680730f, 0.04881407f, -0.10330006f, -0.05475321f, 0.21679795f, 
    0.02809976f, 0.30066109f, 0.10114463f, 0.00575292f, -0.03606391f, -0.07096790f, -0.03198159f, -0.15979616f, 
    0.10105431f, -0.15299873f, 0.24101740f, 0.07712431f, 0.05648563f, 0.08986867f, -0.22397114f, 0.15784830f, 
    0.01737755f, 0.08520306f, -0.18714465f, -0.04845066f, 0.14208719f, -0.04110392f, 0.26368818f, -0.06468735f, 
    0.15214692f, -0.04260345f, 0.22205630f, -0.08783397f, 0.21574999f, 0.10133667f, -0.06686811f, 0.01356678f, 
    -0.05372944f, -0.12479825f, 0.06790677f, -0.11050517f, -0.12424368f, 0.31800714f, 0.13151619f, 0.09777292f, 
    -0.04258289f, -0.07361326f, 0.06529161f, 0.17518999f, 0.02724032f, 0.07392728f, -0.09710431f, 0.04775115f, 
    0.00923015f, -0.02195237f, -0.02586110f, -0.01780974f, 0.13019954f, 0.00755238f, -0.01491838f, 0.04485397f, 
    0.20684378f, 0.12899634f, -0.01243534f, -0.04118216f, -0.00812966f, -0.04628880f, 0.09796835f, -0.14540213f, 
    -0.26616293f, 0.03516005f, 0.02259734f, -0.00801890f, -0.00400746f, -0.02464158f, 0.15836005f, -0.06629451f, 
    0.10702089f, -0.10939770f, -0.09054818f, -0.06660362f, -0.15251905f, -0.04556613f, -0.14147541f, -0.14906831f, 
    0.23248357f, -0.21279193f, -0.37626228f, 0.06567403f, -0.11317137f, -0.02287529f, 0.17892241f, 0.00340277f, 
    0.09086475f, -0.06400242f, 0.05902360f, -0.13568026f, -0.08478590f, 0.15341239f, -0.11384951f, -0.00680981f, 
    -0.00970509f, 0.03381217f, 0.10644801f, -0.36340594f, 0.14190269f, 0.04378905f, 0.08989754f, 0.14877199f, 
    -0.08030358f, 0.13543507f, -0.14250471f, 0.16310088f, -0.14134067f, 0.09827247f, -0.05863132f, 0.12051458f, 
    0.17554061f, -0.17873320f, 0.05462074f, 0.04046544f, -0.19548160f, 0.16890202f, -0.14732763f, -0.06121760f, 
    -0.10825720f, -0.16542920f, -0.00198283f, -0.01428129f, -0.18283096f, 0.16586871f, -0.10729010f, -0.29866236f, 
    -0.19190952f, 0.00220325f, -0.06036745f, 0.03564272f, -0.19575922f, -0.04459506f, 0.06907107f, 0.22201306f, 
    0.12149796f, -0.08685088f, -0.13895473f, -0.22190969f, -0.07789932f, 0.01079668f, 0.01146732f, 0.27497366f, 
    0.06161694f, 0.09283146f, -0.06304725f, -0.13413873f, 0.16043928f, -0.07264814f, 0.23039547f, 0.01971393f, 
    0.02268937f, -0.09084312f, 0.47957638f, 0.27704495f, 0.13398840f, -0.02574442f, -0.03721874f, 0.08692334f, 
    0.19735114f, -0.00639282f, 0.18789725f, 0.04397923f, -0.01180130f, -0.04257592f, -0.30806756f, -0.03818415f, 
    -0.32439193f, 0.06429800f, 0.20387885f, 0.13538583f, -0.29028046f, 0.01503175f, -0.00601649f, 0.06037036f, 
    0.16435587f, 0.09012241f, -0.04803262f, 0.40414315f, 0.24579985f, 0.15306513f, -0.18155068f, -0.07535139f, 
    -0.07720475f, -0.07718725f, -0.02862047f, 0.02212884f, -0.55403328f, -0.08591725f, -0.21924585f, 0.02236766f, 
    -0.01115113f, 0.00039744f, -0.12279661f, 0.07130251f, 0.20648563f, 0.01334166f, 0.14930815f, -0.29392749f, 
    -0.11885238f, -0.20165150f, -0.07068875f, 0.08781800f, -0.14911267f, -0.10710392f, -0.09697526f, -0.18774322f, 
    0.05969085f, -0.11859956f, 0.03742446f, -0.10012251f, -0.13714987f, 0.10875531f, -0.10488886f, 0.27827799f, 
    -0.04071213f, -0.01698397f, 0.08211712f, 0.01660163f, -0.15519872f, 0.04147704f, -0.10585914f, -0.13381475f, 
    -0.01729785f, 0.03182269f, 0.00027820f, -0.01916302f, -0.03726005f, -0.03283593f, -0.05847929f, 0.05565948f, 
    -0.05594267f, -0.03342702f, 0.03577991f, -0.05913800f, -0.00893268f, -0.03970456f, -0.02946389f, 0.01498181f, 
    0.05327566f, 0.01642904f, 0.00815093f, 0.00772797f, 0.02179991f, -0.06200600f, -0.03602427f, -0.02358183f, 
    -0.04656890f, 0.00782951f, -0.00362274f, 0.00994037f, -0.04410397f, 0.05827059f, -0.03069643f, -0.03402483f, 
    -0.03252726f, 0.01865557f, 0.02258873f, 0.03488597f, 0.00929388f, 0.03931271f, -0.02003479f, -0.04051217f, 
    -0.02655837f, -0.00493118f, 0.00626288f, 0.05313940f, 0.04972971f, -0.01090987f, 0.04698744f, -0.05443947f, 
    -0.03181496f, 0.00647227f, -0.02813238f, -0.00157086f, -0.04587283f, -0.04346902f, -0.04715738f, -0.03442271f, 
    -0.03458054f, -0.04776249f, -0.00384095f, 0.03890247f, -0.02853866f, 0.00099803f, -0.04211667f, -0.04814181f, 
    0.01758430f, 0.04703281f, 0.03594064f, -0.00666538f, -0.02131634f, 0.00038359f, -0.02059340f, 0.00011135f, 
    -0.02005092f, -0.00604792f, 0.00879215f, 0.01725124f, -0.03179196f, -0.05606141f, -0.04595698f, -0.05100349f, 
    -0.04515059f, -0.02787317f, -0.04203408f, 0.01183562f, -0.05494259f, 0.02947496f, 0.03940253f, -0.06061749f, 
    0.02166609f, -0.02741889f, 0.02906691f, -0.02201909f, -0.05982409f, 0.00611313f, 0.03261471f, -0.01251511f, 
    0.02041573f, 0.03405800f, 0.02804022f, -0.03460982f, 0.02257262f, 0.00983292f, 0.04373869f, -0.00917780f, 
    0.00464841f, 0.03386530f, 0.00976914f, 0.00894081f, -0.01742229f, -0.04460077f, 0.04463619f, 0.04317383f, 
    0.02242186f, 0.04012597f, -0.03842705f, 0.04199625f, 0.03951361f, -0.03015817f, -0.03883959f, -0.01441006f, 
    -0.00289029f, -0.06005119f, 0.00166122f, -0.02126771f, -0.02195916f, 0.00483990f, 0.00119771f, -0.03825842f, 
    0.01873869f, 0.02758872f, 0.00299829f, 0.05135155f, 0.04163672f, 0.00100124f, -0.05006463f, 0.00227844f, 
    0.04789549f, 0.04099657f, 0.03196981f, 0.00242308f, 0.03894925f, 0.04830939f, -0.02149651f, -0.00517909f, 
    0.00598678f, -0.03518480f, 0.02493383f, 0.04533634f, 0.05053269f, -0.02072806f, 0.02404304f, -0.04476600f, 
    -0.06245680f, -0.05926671f, 0.04517508f, -0.04947871f, -0.04902048f, 0.00180153f, 0.04125329f, -0.06083813f, 
    0.00280813f, -0.04727453f, -0.02146329f, -0.02414014f, 0.01418370f, -0.03263474f, -0.06274816f, 0.00944750f, 
    -0.02892004f, -0.06018607f, -0.02626726f, 0.00200613f, -0.05537471f, -0.02496704f, -0.01804298f, 0.02618593f, 
    -0.05998115f, 0.03823102f, 0.04811631f, -0.04428081f, -0.02733352f, -0.01103571f, -0.04626940f, 0.00097193f, 
    -0.05747461f, 0.00642284f, 0.00449176f, -0.05388514f, 0.04994595f, 0.00174590f, 0.02775045f, 0.04559852f, 
    -0.00165597f, 0.02840912f, 0.00778286f, 0.03657023f, 0.00493851f, 0.01489343f, -0.02820870f, -0.00739527f, 
    -0.03631615f, 0.02044720f, -0.05272269f, 0.01915325f, 0.03871694f, 0.04968432f, -0.01453691f, -0.01035620f, 
    0.04216316f, 0.04702659f, 0.02036338f, 0.03237783f, 0.00228527f, 0.03975938f, -0.03527653f, -0.03617967f, 
    -0.03882878f, -0.05606072f, 0.02506031f, -0.05252280f, -0.05592827f, 0.01210854f, -0.02052649f, -0.04518929f, 
    0.04583765f, -0.04064193f, 0.04659680f, -0.02365808f, -0.01794068f, 0.03365384f, -0.02538833f, 0.04947561f, 
    0.04866225f, -0.01834477f, 0.00702122f, -0.05616181f, -0.06307008f, -0.06222998f, -0.02531263f, -0.04381032f, 
    -0.04742138f, -0.01743816f, -0.02586522f, 0.03958889f, 0.00301378f, 0.04288468f, 0.00059753f, -0.00306299f, 
    -0.01759660f, -0.05747044f, -0.02155365f, -0.03682300f, -0.00807327f, 0.02458250f, 0.04967103f, 0.04073556f, 
    -0.03986268f, -0.03463835f, 0.00195481f, -0.03864586f, 0.03153418f, -0.02685075f, -0.03495360f, -0.04899129f, 
    0.02085690f, -0.01990625f, -0.05791478f, 0.02913140f, 0.04330587f, 0.01148111f, -0.00938820f, 0.02443699f, 
    -0.04828069f, -0.03712063f, -0.02447725f, -0.01192549f, 0.00578247f, 0.05552961f, -0.00452858f, -0.01030367f, 
    -0.02543937f, -0.02575308f, -0.06029188f, -0.04018818f, 0.00388153f, 0.03030821f, 0.02883664f, -0.02896289f, 
    0.01441026f, -0.13970469f, 0.27356955f, -0.02133704f, -0.11575808f, -0.02088154f, -0.19700943f, 0.03950132f, 
    0.09244340f, -0.03108543f, -0.00100876f, 0.32264429f, -0.10827198f, 0.05517590f, -0.11385331f, 0.04704316f, 
    0.29188335f, 0.05244780f, 0.10109718f, -0.20990074f, -0.13498801f, -0.02792843f, 0.03385854f, 0.28284648f, 
    -0.10972040f, 0.00240671f, 0.04466587f, -0.00907496f, 0.08271673f, -0.10583767f, -0.01482800f, -0.04323116f, 
    -0.06064378f, -0.04200069f, 0.07357430f, 0.01723202f, -0.08712214f, 0.10415375f, -0.18989706f, -0.18090700f, 
    0.05161358f, -0.03236467f, 0.06271993f, 0.18953446f, -0.04385861f, -0.02656095f, -0.20826781f, -0.16783741f, 
    0.04833946f, 0.03235200f, -0.00295232f, -0.00676506f, 0.06158976f, -0.15758573f, 0.09308878f, 0.04633799f, 
    0.12854166f, 0.07787316f, -0.01110438f, 0.20509037f, 0.07678601f, 0.06345357f, -0.01395523f, 0.08545563f, 
    -0.05515780f, 0.14974637f, -0.18520895f, 0.01219571f, -0.10612817f, 0.11606974f, 0.16944081f, 0.06810736f, 
    -0.01683765f, -0.00929431f, 0.09136727f, -0.00815244f, 0.03703861f, -0.04739651f, -0.03958265f, 0.08415512f, 
    0.14641337f, -0.29383978f, -0.24507470f, -0.25703841f, 0.13247456f, 0.03568142f, 0.26801521f, -0.01542370f, 
    0.02871738f, -0.01562741f, 0.09282852f, 0.12413382f, 0.08716191f, 0.07400626f, -0.04557068f, 0.05301188f, 
    -0.12338062f, -0.02064689f, -0.02750149f, -0.16908792f, -0.06399550f, 0.04377566f, -0.00660355f, 0.04584376f, 
    0.20830739f, -0.17814556f, 0.08529174f, 0.13094713f, -0.21408248f, -0.02667825f, -0.22819655f, 0.09720659f, 
    0.04190065f, 0.13757615f, 0.02519833f, -0.12076274f, -0.14364332f, -0.05844277f, -0.13561285f, -0.00623014f, 
    0.07188355f, 0.07175034f, 0.24003665f, -0.02796728f, 0.02397690f, -0.24275690f, -0.08263744f, 0.11919121f, 
    -0.10510403f, -0.07612858f, -0.04542343f, 0.02294376f, 0.22958608f, -0.03435373f, 0.04108069f, -0.17398308f, 
    -0.08431774f, -0.02645769f, 0.15916070f, -0.06547359f, -0.15696809f, -0.13753965f, -0.08990933f, 0.08062202f, 
    0.06466672f, -0.05241258f, -0.07798942f, 0.01608077f, -0.07472289f, -0.03873697f, 0.10492343f, -0.05752325f, 
    -0.00239159f, -0.32869628f, -0.17070322f, -0.08786290f, 0.14568609f, 0.14789428f, -0.02681266f, 0.05775876f, 
    0.00399364f, -0.13642772f, -0.23833814f, 0.15475726f, 0.05771753f, -0.03227571f, 0.02807211f, -0.00028455f, 
    0.04234904f, 0.08270858f, -0.03807583f, -0.20212664f, 0.20562720f, 0.01736332f, 0.09130146f, -0.04663672f, 
    -0.03259795f, -0.12389556f, -0.00461590f, -0.04416473f, -0.03841487f, -0.21465422f, -0.05839243f, -0.12667143f, 
    0.01180264f, -0.08567873f, 0.00289370f, 0.02942885f, -0.21081311f, 0.07787962f, -0.09611960f, -0.22575222f, 
    -0.06611439f, 0.06435515f, -0.06307670f, 0.20295107f, -0.06034331f, 0.03123127f, 0.05703256f, 0.06088627f, 
    0.00857827f, 0.19922501f, -0.12492087f, 0.15456331f, -0.31788200f, 0.05891899f, 0.00070988f, 0.04806039f, 
    0.18559702f, 0.29563442f, -0.09432827f, 0.03305766f, -0.06361005f, -0.03153982f, 0.18460515f, 0.09436125f, 
    -0.19557586f, -0.14555687f, 0.24734464f, 0.03197617f, 0.01839770f, 0.15044720f, -0.07347183f, 0.01110969f, 
    -0.00323376f, -0.15141340f, -0.14187260f, 0.04641233f, 0.10511751f, 0.09143484f, -0.16110010f, 0.11108917f, 
    -0.09449992f, 0.07154237f, 0.08002729f, 0.22773176f, -0.15299949f, 0.12517488f, 0.07607625f, 0.10013779f, 
    0.08978024f, -0.14065841f, -0.02011395f, 0.11612939f, 0.11386970f, -0.03974789f, 0.08859359f, 0.16550215f, 
    0.09839590f, -0.05710090f, -0.02657176f, -0.15304641f, 0.20707329f, 0.22191869f, -0.08217262f, -0.04096544f, 
    0.05317659f, 0.09846851f, -0.00035646f, -0.03133034f, 0.13586394f, 0.07110759f, -0.03903525f, -0.09858606f, 
    -0.04163636f, -0.01892187f, -0.07629973f, 0.03946808f, -0.01115841f, 0.00715593f, -0.18568099f, -0.06356127f, 
    0.12545519f, -0.15887769f, 0.09550557f, -0.08727116f, -0.03387777f, 0.07209239f, 0.03849261f, 0.17397203f, 
    0.14490406f, 0.11248704f, -0.08398671f, -0.06910066f, 0.05674061f, 0.17229553f, -0.02951280f, 0.10080536f, 
    -0.10935546f, -0.27784482f, 0.22705695f, -0.28335246f, 0.06792735f, -0.21474680f, 0.00028555f, -0.08206698f, 
    0.07501052f, 0.11739531f, 0.07155753f, -0.12044536f, 0.08030794f, 0.16775048f, -0.09752331f, 0.06752265f, 
    -0.06295377f, -0.04848906f, -0.15454926f, -0.06694400f, -0.18546596f, -0.04273159f, 0.01158240f, 0.10949883f, 
    0.08976679f, -0.09971207f, 0.06172667f, 0.16844019f, 0.10420048f, 0.02627904f, -0.05481661f, 0.03233330f, 
    0.05769893f, -0.12978794f, 0.08442124f, -0.02755971f, 0.21663140f, 0.07108979f, -0.16239029f, -0.12270506f, 
    -0.10206239f, -0.04617981f, 0.11041885f, -0.02352086f, 0.13336939f, 0.10825758f, 0.12408232f, -0.06879720f, 
    0.06235997f, -0.01364696f, 0.11666688f, -0.08186746f, -0.00051825f, -0.07923082f, 0.16041248f, -0.17336443f, 
    0.17423214f, 0.06753349f, 0.07187943f, 0.06272864f, 0.20715487f, 0.08887948f, -0.17765719f, -0.04619936f, 
    -0.47741383f, -0.16511887f, -0.00974150f, 0.05394433f, -0.24600062f, 0.08999305f, -0.00392499f, -0.03167125f, 
    0.16069190f, -0.08540966f, -0.12708201f, 0.04994384f, 0.10997789f, -0.03823149f, 0.04104281f, 0.04242956f, 
    0.03933036f, -0.13679582f, -0.05912143f, 0.07000933f, -0.00650163f, -0.03023620f, 0.27798483f, 0.06881339f, 
    0.07115778f, 0.11991148f, 0.13653030f, 0.00908848f, 0.19513872f, -0.03564774f, 0.08435950f, -0.09097540f, 
    -0.06271488f, -0.01215891f, -0.03689423f, 0.14795282f, -0.00477513f, 0.12513623f, -0.05185557f, -0.10289834f, 
    0.14141378f, 0.07418412f, 0.02777845f, 0.08254922f, -0.04719285f, -0.07712933f, -0.07369903f, 0.01774968f, 
    0.05130511f, 0.19631942f, -0.13043691f, -0.09890447f, -0.09937934f, 0.41627020f, -0.09539839f, 0.13286257f, 
    0.01776903f, -0.11799637f, 0.20501491f, -0.02725998f, -0.05901001f, -0.11456081f, 0.09531910f, 0.16610543f, 
    -0.00475475f, -0.08083291f, 0.04255731f, -0.17236963f, 0.12509727f, -0.06688081f, 0.14140096f, 0.13896327f, 
    -0.14250784f, 0.00436745f, -0.00283971f, 0.08990399f, -0.01951499f, -0.06226500f, 0.03613236f, 0.07493144f, 
    0.11294430f, 0.08809523f, -0.21526091f, 0.06254948f, 0.12610699f, 0.00096957f, 0.02611227f, -0.12213701f, 
    -0.00429704f, -0.11174359f, -0.02123534f, 0.12184585f, -0.06337945f, -0.14739674f, 0.10279269f, -0.11409984f, 
    0.15329829f, -0.08093841f, 0.12528540f, -0.00305242f, 0.13560134f, -0.30128199f, -0.13434926f, 0.25498828f, 
    -0.02976242f, 0.12900695f, -0.05890707f, 0.09880809f, 0.07674178f, -0.20605893f, 0.15885043f, -0.23257630f, 
    0.00760875f, -0.07003189f, -0.00227677f, -0.06879818f, 0.12314689f, 0.21840180f, -0.04874324f, -0.13412237f, 
    0.07336542f, -0.02190987f, -0.04495475f, -0.05023950f, -0.06182662f, 0.32315755f, -0.06691317f, -0.13405979f, 
    -0.16649097f, 0.13083601f, 0.00218584f, 0.08316895f, 0.10282107f, -0.00020286f, 0.07335324f, -0.03910920f, 
    0.20110965f, 0.03447352f, -0.18795271f, 0.07581555f, -0.24817042f, 0.03525646f, 0.16202120f, -0.08618919f, 
    -0.16650036f, 0.05865388f, -0.07777192f, -0.07595058f, -0.13914970f, 0.09982336f, -0.11035623f, 0.16093168f, 
    0.03738425f, 0.05970940f, 0.27561080f, -0.32145870f, 0.10618603f, -0.00446998f, 0.07165872f, -0.16140088f, 
    0.01168962f, 0.20606272f, 0.02911826f, -0.02403120f, 0.05497232f, 0.06301417f, 0.09763698f, 0.09425700f, 
    -0.05833890f, -0.20792481f, -0.14361016f, 0.06754463f, -0.14967713f, 0.15663026f, 0.06078029f, 0.06397767f, 
    -0.00321571f, -0.10541867f, -0.05543153f, 0.10454306f, 0.02022598f, 0.01100834f, -0.00037083f, -0.05423935f, 
    0.08209644f, -0.07726449f, -0.11621745f, -0.06490014f, 0.11941938f, -0.16658597f, -0.11240914f, -0.07581250f, 
    -0.01450226f, -0.09839287f, 0.01970915f, -0.06718839f, 0.07462843f, 0.05364240f, 0.14227743f, -0.03687849f, 
    0.03410806f, -0.05984269f, -0.17457989f, -0.08815753f, -0.01965697f, 0.03277437f, 0.14961703f, -0.00063316f, 
    -0.12635212f, -0.15322977f, 0.07963292f, -0.04644829f, -0.15546393f, 0.01484246f, 0.03828114f, 0.16978873f, 
    -0.19154468f, 0.06282599f, 0.12009272f, 0.14309491f, 0.02272072f, 0.10617658f, 0.12162731f, 0.07225117f, 
    -0.02950586f, 0.03202052f, -0.00557680f, 0.00634274f, 0.01868288f, -0.07048059f, 0.03006549f, -0.02638895f, 
    -0.05627835f, 0.00592818f, 0.02390227f, -0.00612529f, -0.00707851f, -0.06458715f, -0.00098515f, -0.04394665f, 
    0.01366562f, 0.04906785f, 0.03521832f, 0.01599596f, 0.01920217f, 0.00890102f, -0.04910488f, 0.03998777f, 
    -0.01717185f, 0.04817453f, -0.01009336f, -0.05940903f, -0.03409643f, -0.05411797f, 0.00340164f, -0.02486548f, 
    0.00760847f, 0.01681394f, -0.05469771f, -0.02579543f, -0.03614887f, -0.01317563f, 0.01696610f, 0.02028789f, 
    -0.00559539f, -0.02386925f, 0.04983409f, 0.03257088f, 0.01169652f, -0.04798897f, -0.03623128f, -0.02192049f, 
    0.03822841f, 0.00438447f, -0.02953177f, -0.04913160f, 0.04750173f, 0.03679876f, 0.00987923f, 0.01269831f, 
    -0.01787611f, -0.02158703f, 0.03351595f, -0.00613497f, 0.00765442f, -0.02036334f, -0.01159668f, 0.02461647f, 
    -0.00414877f, -0.01156521f, -0.00888909f, -0.00406317f, -0.00305107f, 0.03965958f, 0.04211867f, -0.03476662f, 
    -0.03480113f, -0.05557762f, 0.01714143f, -0.01543106f, -0.05218323f, 0.02364512f, 0.02477602f, -0.04630947f, 
    -0.06242188f, -0.02152978f, 0.02615462f, 0.04000007f, 0.05080913f, -0.04593538f, 0.01566586f, -0.06381053f, 
    -0.05901854f, -0.06432750f, 0.04996110f, -0.05017499f, -0.03462351f, -0.00905835f, 0.05181856f, -0.05050957f, 
    -0.03006494f, 0.04121732f, 0.05097208f, -0.02026811f, 0.00427927f, 0.04067723f, 0.02933854f, -0.05098453f, 
    -0.04768124f, -0.05761530f, 0.00126329f, 0.03396199f, -0.02798807f, 0.03643452f, -0.04762299f, -0.04392897f, 
    -0.01045689f, -0.02900819f, 0.03562678f, 0.03455707f, -0.00709682f, 0.02179096f, -0.06019074f, 0.03966222f, 
    -0.06369606f, -0.00869562f, 0.02524427f, 0.02667134f, -0.04960381f, 0.00869178f, -0.04402803f, -0.04287335f, 
    -0.02589743f, -0.00188823f, 0.00711704f, -0.04396707f, 0.00707280f, 0.03945738f, -0.03726121f, -0.01946364f, 
    0.00087865f, -0.05520752f, 0.02481923f, 0.02083746f, 0.01837740f, 0.02411474f, -0.03081995f, 0.03522843f, 
    -0.01847547f, -0.06311920f, -0.03395125f, -0.06143655f, 0.00186404f, -0.06158975f, 0.01848126f, 0.02329478f, 
    0.00943802f, 0.02376035f, -0.02747030f, -0.05623411f, 0.03518802f, 0.04867865f, -0.02253568f, 0.04547244f, 
    -0.01671617f, -0.05791004f, -0.05345112f, -0.05368898f, 0.02203963f, -0.03357486f, -0.02268682f, -0.01885305f, 
    -0.03704280f, -0.01158370f, 0.01948032f, -0.03637956f, -0.03734038f, -0.03741721f, -0.03505544f, -0.01503222f, 
    -0.04050446f, -0.02924584f, 0.03998144f, -0.01512449f, 0.00698113f, 0.00699138f, -0.05511253f, -0.00403037f, 
    -0.04819578f, -0.05528494f, 0.02009269f, 0.00482411f, 0.01291162f, 0.00755976f, 0.02373914f, 0.00384296f, 
    -0.00096232f, 0.03315477f, 0.02570050f, -0.01076708f, -0.02448936f, 0.04344060f, -0.00773281f, -0.03789464f, 
    0.04918311f, -0.05561719f, -0.01509902f, -0.04490806f, -0.03214852f, -0.04721035f, 0.02915906f, -0.00078312f, 
    -0.04683843f, -0.03235696f, -0.04286703f, -0.00797441f, -0.02915054f, -0.02335505f, 0.02078486f, 0.03929954f, 
    -0.06558838f, 0.01728670f, 0.02569406f, 0.03870346f, 0.04289429f, 0.01123187f, -0.01551604f, -0.04062368f, 
    0.00351644f, 0.04808024f, -0.04191481f, 0.03426146f, 0.02192735f, 0.01219751f, -0.00829517f, 0.05213589f, 
    0.00861504f, -0.02559473f, -0.04402992f, 0.04152247f, -0.00659481f, 0.04249012f, 0.00274957f, -0.05475057f, 
    0.00033720f, -0.02557295f, 0.03528624f, -0.00235481f, -0.01890762f, 0.01354969f, -0.05731624f, 0.03492150f, 
    0.02706389f, -0.05837895f, -0.01693607f, -0.05377213f, -0.00957937f, 0.02107248f, 0.04141263f, -0.04351317f, 
    0.01903287f, -0.05476235f, 0.02998178f, 0.01304290f, -0.04652336f, 0.00494792f, 0.02654149f, 0.01578109f, 
    0.04109310f, 0.04464732f, 0.04139312f, -0.00850005f, 0.04295336f, 0.00960389f, 0.01531679f, 0.00006540f, 
    -0.04514331f, -0.01688128f, -0.00892039f, -0.04392649f, 0.03694091f, -0.01428738f, -0.04015301f, 0.02942875f, 
    -0.00550911f, -0.01103726f, -0.05547229f, -0.03509602f, 0.05123823f, -0.01682475f, -0.00762476f, -0.00118069f, 
    -0.05358779f, -0.00758312f, -0.04777550f, -0.03086396f, -0.05731179f, 0.02583842f, 0.02504009f, -0.01198057f, 
    -0.05408494f, -0.04801039f, 0.04927186f, 0.01501046f, 0.00083552f, -0.06091012f, -0.02586471f, -0.02098879f, 
    -0.05944591f, 0.02129045f, 0.00807540f, -0.00820034f, 0.01372531f, -0.06703396f, 0.00244178f, -0.00263803f, 
    -0.02591579f, 0.04828371f, -0.01801201f, -0.03266297f, -0.03226274f, -0.05091717f, 0.00021683f, 0.01660180f, 
    0.02986104f, -0.02051126f, 0.04024120f, 0.02992252f, 0.00921129f, 0.05948044f, 0.02257770f, 0.01918319f, 
    0.04380095f, 0.03103623f, -0.02118769f, -0.06066271f, -0.05871496f, 0.04084034f, 0.02080340f, -0.03812271f, 
    -0.00633819f, 0.02240955f, -0.05345091f, 0.03080755f, -0.03418123f, -0.02574910f, -0.04443979f, 0.01264551f, 
    0.00593393f, -0.04423690f, -0.00903148f, 0.00653317f, 0.03075620f, -0.01838736f, 0.00730539f, -0.06146881f, 
    0.04310427f, 0.02272760f, -0.03213222f, 0.05662027f, 0.05433810f, 0.04121043f, 0.05117796f, 0.00385186f, 
    -0.05359097f, -0.05254416f, 0.04334329f, -0.06289604f, -0.05058562f, -0.00399677f, -0.00155856f, 0.03919903f, 
    0.01893006f, 0.01747006f, -0.05957760f, -0.04078811f, 0.04407880f, 0.03469259f, 0.02964683f, -0.06308371f, 
    0.05140620f, -0.04022496f, -0.02629780f, -0.05787499f, -0.03266965f, -0.00531312f, -0.02037602f, -0.02910473f, 
    0.02599945f, 0.00260936f, -0.00794572f, -0.05890236f, 0.03296009f, 0.01676199f, -0.00731746f, -0.02798498f, 
    -0.04733386f, -0.05526605f, 0.04329562f, 0.05943159f, -0.00745441f, -0.02893570f, -0.05198833f, -0.05813562f, 
    -0.02121565f, -0.01909780f, 0.00813228f, 0.00101782f, 0.01535404f, 0.01909025f, -0.01290507f, 0.00631531f, 
    0.00135580f, -0.04594512f, 0.04554012f, -0.03937715f, 0.00730660f, -0.01458861f, -0.01772933f, -0.00573530f, 
    -0.02713557f, -0.05794083f, -0.06182066f, -0.01380388f, -0.04136557f, -0.03118089f, -0.01681267f, -0.01888984f, 
    0.03486685f, -0.05394352f, -0.04812531f, -0.03586812f, -0.04531786f, 0.00105288f, -0.00048968f, -0.01992102f, 
    -0.04161091f, -0.03238562f, -0.01778158f, -0.04763415f, -0.03415620f, 0.04110961f, -0.01531299f, 0.04116116f, 
    0.02508750f, 0.00216270f, -0.06005811f, -0.03882113f, 0.03606484f, -0.03974055f, 0.04301689f, -0.02474178f, 
    0.00590064f, -0.05410093f, -0.01079218f, -0.03333737f, -0.01572623f, 0.03356728f, -0.00321600f, -0.03163484f, 
    -0.03665144f, -0.00560479f, 0.03407387f, 0.03844821f, 0.00682764f, -0.00958519f, 0.01836250f, 0.03089571f, 
    -0.00496859f, 0.02654465f, 0.00471799f, 0.04861696f, 0.03944013f, -0.01439213f, -0.01893447f, -0.03516116f, 
    0.02829865f, -0.05875207f, -0.00965850f, -0.02312031f, 0.03842867f, -0.05029948f, 0.03459812f, 0.01889000f, 
    0.02257878f, -0.06102170f, 0.05352592f, -0.00270388f, -0.02029082f, 0.00360444f, -0.04804094f, -0.02184063f, 
    -0.03743644f, 0.03258674f, -0.05145018f, -0.04782398f, -0.02263296f, -0.01098611f, 0.02331512f, -0.01263037f, 
    0.04361152f, 0.01557903f, -0.06927254f, 0.01334980f, 0.00535411f, -0.03163119f, 0.02851368f, -0.00380558f, 
    0.03909345f, 0.01206214f, -0.03632551f, -0.00672317f, -0.00138895f, -0.04495002f, -0.01686081f, -0.04325792f, 
    0.02562731f, -0.01905841f, -0.02601240f, 0.04981387f, -0.00567196f, 0.02839873f, -0.04281736f, -0.02615649f, 
    -0.02377416f, 0.01893215f, -0.05233944f, -0.04667415f, -0.04120112f, -0.01487995f, -0.04700515f, -0.04114762f, 
    0.03671828f, 0.03695539f, -0.01390256f, -0.05708384f, -0.00494788f, 0.03624365f, 0.02973705f, -0.04282587f, 
    0.01043689f, -0.04469208f, -0.00302609f, 0.04315588f, 0.02221474f, 0.02938886f, 0.04228263f, -0.03133952f, 
    0.04755584f, -0.06313585f, -0.02688672f, -0.02325317f, 0.01766679f, 0.01408516f, -0.05055201f, -0.00862259f, 
    -0.03439424f, 0.02267011f, 0.04413424f, -0.05669215f, -0.02609110f, -0.04963306f, 0.03071618f, 0.03770467f, 
    0.04613038f, -0.04324016f, 0.02429038f, -0.04032878f, -0.01723728f, -0.06320897f, -0.02783748f, -0.01208601f, 
    -0.00431802f, -0.00391975f, -0.05875418f, 0.01221216f, 0.01103481f, -0.05447791f, -0.02449491f, -0.03477330f, 
    0.24057826f, 0.14565881f, -0.15340544f, -0.19553018f, -0.04184700f, -0.05688667f, 0.02596119f, 0.02230089f, 
    -0.15433589f, 0.02466746f, -0.01885159f, -0.39264387f, 0.07951978f, 0.08558001f, 0.08563303f, 0.03876275f, 
    0.07053687f, -0.08022358f, -0.23015022f, -0.13997124f, 0.00491679f, -0.23727953f, 0.00418231f, -0.08824454f, 
    -0.03396994f, -0.09206382f, -0.03620265f, -0.07138251f, -0.13607486f, -0.24667774f, 0.19405447f, -0.13522664f, 
    0.01653676f, -0.06930441f, -0.00068327f, 0.00967143f, -0.16065890f, 0.14504874f, -0.18977252f, 0.00199586f, 
    0.04874926f, -0.05175120f, 0.09575634f, -0.05010956f, 0.11461776f, 0.40846592f, 0.15844586f, 0.12708223f, 
    0.00438439f, 0.07772223f, 0.20213269f, 0.23706715f, 0.04481206f, 0.17376542f, -0.15823941f, 0.24912453f, 
    -0.26091868f, 0.10443850f, -0.18096946f, 0.07977098f, 0.10589248f, -0.12389850f, 0.02365500f, 0.03009484f, 
    0.09327292f, -0.16130760f, -0.02351119f, -0.13725437f, -0.03017526f, 0.00573421f, -0.02743130f, -0.12583630f, 
    0.21328343f, 0.10457461f, -0.34941629f, -0.14039873f, -0.00033076f, 0.14382768f, 0.02991319f, -0.00037135f, 
    -0.12575935f, -0.36619070f, -0.22085628f, -0.10478733f, 0.12668671f, 0.34683117f, 0.09783433f, -0.02841692f, 
    -0.02628084f, 0.06267746f, -0.27029943f, -0.00953744f, 0.14703657f, 0.10772830f, 0.15851898f, 0.07856338f, 
    0.04760076f, -0.04643530f, -0.05054803f, -0.32107291f, -0.30019021f, -0.15679358f, 0.01409616f, 0.11203467f, 
    0.04384854f, -0.26321477f, -0.10827178f, -0.15620516f, 0.18826585f, 0.16085458f, 0.14299098f, 0.08773205f, 
    0.02176756f, -0.02185949f, 0.04366773f, 0.08538024f, 0.13467945f, -0.47562853f, -0.40477413f, -0.34869173f, 
    -0.07248215f, 0.31059107f, 0.04854887f, 0.06620228f, -0.02067289f, -0.10979332f, -0.10694040f, -0.19744910f, 
    0.06726468f, -0.20346764f, 0.02296307f, -0.00385356f, -0.06849036f, -0.15896517f, 0.14799725f, 0.41458961f, 
    0.05890695f, -0.21449170f, 0.17328443f, -0.04710011f, -0.13123167f, 0.15187792f, 0.20763059f, 0.01700272f, 
    0.77429414f, 0.33708265f, -0.07747269f, 0.10942475f, 0.00919086f, -0.07090985f, 0.08424282f, -0.09823042f, 
    0.01137444f, 0.22176701f, -0.01828827f, 0.02763540f, -0.03359058f, -0.19455181f, -0.02986037f, -0.05915108f, 
    0.22875592f, -0.04548578f, -0.26787305f, -0.02498824f, 0.00226176f, -0.06170609f, 0.05348017f, 0.13915786f, 
    -0.20897216f, -0.17336938f, -0.03326186f, 0.06251363f, 0.22300445f, 0.09068634f, 0.10284021f, 0.01324397f, 
    -0.04912658f, 0.01318353f, -0.08390890f, -0.11478838f, 0.41627276f, -0.02021924f, 0.00205792f, 0.18544778f, 
    -0.01442186f, 0.07774633f, 0.34389395f, 0.02834654f, 0.11900988f, -0.28414991f, 0.05987696f, 0.16890693f, 
    0.02177912f, -0.07205055f, -0.05220626f, 0.26379928f, 0.05093413f, 0.05875381f, 0.20685805f, -0.21486840f, 
    0.17567690f, 0.08522269f, 0.02817585f, -0.19385733f, 0.04944168f, -0.10925158f, 0.15337357f, 0.01822825f, 
    -0.18120593f, -0.14613138f, 0.03424174f, 0.11358268f, 0.07510903f, -0.03853551f, -0.12343192f, 0.12483601f, 
    -0.13298550f, -0.04386293f, -0.09184553f, 0.00680278f, 0.10482920f, -0.00116044f, -0.00631782f, -0.10497112f, 
    -0.16442525f, 0.15425070f, 0.38066801f, 0.02665661f, -0.01357876f, 0.09944328f, -0.02622805f, 0.06032218f, 
    -0.11459712f, 0.04198752f, 0.16144526f, 0.26502255f, 0.04245442f, -0.06444968f, 0.02847345f, 0.00246118f, 
    0.05100466f, -0.17915285f, 0.11507947f, 0.08486558f, 0.13721412f, -0.01194948f, 0.15590695f, 0.13699511f, 
    -0.02864479f, -0.00424491f, -0.03711725f, 0.10853507f, 0.08662613f, -0.34366643f, 0.03786223f, -0.12823431f, 
    -0.05305262f, -0.14737211f, 0.03198109f, 0.09750868f, 0.02158870f, 0.15230568f, 0.04940822f, -0.24725910f, 
    0.05213621f, -0.05620472f, 0.12928919f, 0.10682045f, 0.12125642f, -0.09629733f, -0.13002799f, 0.08894175f, 
    0.00234491f, 0.02417597f, 0.14589213f, -0.06510448f, -0.01601502f, 0.03608672f, 0.05525169f, -0.05156491f, 
    0.06408852f, -0.12676249f, -0.01334834f, -0.25357813f, 0.00990546f, 0.06810329f, 0.04255565f, -0.04869467f, 
    -0.02601358f, -0.05455060f, -0.01334406f, -0.05656709f, -0.03280219f, -0.05410827f, 0.01696730f, -0.02419850f, 
    -0.06628633f, -0.01725385f, -0.06084439f, 0.03482186f, 0.00919178f, 0.02922801f, -0.03259928f, 0.00589072f, 
    0.00306025f, 0.03587795f, -0.04065672f, 0.02951408f, 0.00403033f, 0.01926402f, -0.04516284f, 0.03814846f, 
    -0.02126501f, 0.00549275f, -0.03083905f, 0.03841828f, 0.02470104f, -0.05076529f, -0.00380818f, -0.01839873f, 
    -0.03900643f, 0.00670032f, -0.04685505f, 0.04078249f, -0.05878134f, -0.04561382f, 0.04027765f, 0.02258709f, 
    -0.00333033f, -0.01500573f, 0.00842923f, -0.01066240f, -0.05594943f, -0.02675714f, 0.03867266f, -0.01687367f, 
    0.04042934f, 0.02878847f, 0.00133054f, 0.00337771f, -0.02099429f, 0.03159238f, 0.01124984f, 0.03889856f, 
    0.04208415f, -0.01414680f, -0.04865841f, 0.02244275f, 0.02863521f, 0.05461647f, -0.02773915f, -0.04674290f, 
    -0.05958641f, 0.00072265f, -0.03114471f, 0.00641173f, 0.00386172f, 0.03608564f, -0.05447776f, -0.06026660f, 
    -0.05052408f, -0.02411624f, -0.00326575f, 0.00013306f, -0.00403722f, -0.04991999f, -0.03808559f, -0.05992554f, 
    -0.00038738f, -0.02042405f, 0.03451660f, -0.01615347f, -0.05124761f, -0.00844252f, -0.04918366f, 0.00998453f, 
    -0.01281564f, 0.00980389f, -0.04032268f, 0.02616122f, -0.00821794f, -0.03102544f, 0.01646945f, -0.03736788f, 
    -0.00172460f, -0.01920595f, 0.02824037f, 0.02521669f, 0.03196755f, -0.00179598f, -0.04712744f, 0.00484513f, 
    -0.05186056f, -0.03534124f, -0.00670122f, 0.03063310f, -0.05844961f, -0.05825358f, -0.06539570f, -0.02712394f, 
    0.00078523f, 0.03907993f, 0.00732632f, 0.04773382f, 0.02593800f, -0.02485340f, -0.00257621f, -0.01174116f, 
    0.04066820f, 0.05011189f, -0.03596924f, 0.04061757f, -0.01471663f, 0.03015823f, 0.00945215f, -0.04249604f, 
    -0.00320117f, -0.03080590f, -0.06533745f, -0.04653866f, -0.00151506f, -0.03515514f, 0.01079954f, -0.02507002f, 
    -0.00911474f, -0.06398460f, -0.03395119f, -0.01819976f, -0.04405394f, -0.03501828f, 0.02577114f, 0.01726573f, 
    0.00152579f, 0.01888599f, -0.04688336f, -0.05178339f, -0.00584392f, 0.00981691f, -0.00857683f, -0.04844740f, 
    -0.05640198f, -0.00822155f, 0.00281843f, -0.03815666f, -0.02100466f, -0.05561776f, -0.01021949f, 0.02714494f, 
    0.01974351f, -0.04675541f, 0.02072487f, -0.06451427f, -0.04544695f, 0.00357930f, 0.03447840f, -0.05591772f, 
    0.03907695f, -0.00681286f, -0.02663102f, 0.04264557f, 0.02180337f, 0.01110201f, -0.00656241f, 0.03809892f, 
    0.04817382f, 0.00597500f, -0.02976878f, -0.04722804f, -0.01274018f, 0.01297306f, -0.04529789f, 0.03653357f, 
    0.00886120f, -0.03118794f, -0.04921863f, 0.00174806f, 0.01049198f, -0.03438922f, -0.00886708f, -0.05095479f, 
    -0.05017312f, -0.06342946f, -0.00871204f, -0.04944103f, 0.01569970f, -0.04995630f, 0.03614889f, -0.01501400f, 
    0.01212887f, -0.05069118f, 0.04956289f, -0.05237200f, 0.03201453f, 0.01318494f, 0.03774292f, -0.01238591f, 
    -0.00797847f, -0.04540284f, -0.03237841f, -0.04606394f, 0.00756468f, 0.05685056f, 0.02330611f, 0.05009848f, 
    0.04424989f, 0.02959209f, -0.01986987f, -0.00655379f, -0.00008378f, 0.05041730f, 0.04475774f, 0.00435889f, 
    -0.03055841f, -0.03748141f, -0.01131420f, -0.01147566f, 0.03855815f, 0.02192335f, 0.03564410f, -0.06280702f, 
    -0.00797711f, -0.05942531f, 0.04158415f, -0.01867070f, 0.03176295f, -0.03808285f, -0.01038050f, -0.01089222f, 
    0.05164162f, -0.03326261f, -0.00544567f, -0.05129952f, 0.02909035f, -0.01154763f, 0.01391173f, 0.00735091f, 
    -0.00182336f, -0.03206891f, -0.02693134f, -0.02632583f, -0.01300985f, -0.01467282f, -0.03561569f, -0.03658500f, 
    -0.06436308f, 0.04689525f, -0.02561470f, -0.03942261f, -0.01535149f, -0.03832978f, -0.04000245f, -0.06611262f, 
    0.04381396f, -0.01343573f, 0.05112110f, 0.05051573f, -0.03520174f, 0.00083672f, -0.03869219f, -0.06670041f, 
    0.05310828f, -0.04988704f, 0.02729242f, 0.01517902f, -0.06242145f, 0.05190801f, 0.04315391f, -0.05026865f, 
    -0.02145562f, -0.00247141f, 0.04857939f, -0.03227528f, -0.06427559f, -0.01855937f, 0.01366417f, -0.02158238f, 
    0.06073871f, 0.16287002f, -0.03373403f, 0.00033255f, -0.04241122f, -0.00842014f, 0.09525599f, 0.09177345f, 
    -0.12923914f, 0.09025399f, 0.20659652f, -0.12855846f, -0.07357689f, -0.10537103f, -0.12628414f, -0.07112210f, 
    -0.00482713f, 0.01511856f, -0.15384157f, -0.17509322f, 0.07889270f, 0.04855410f, 0.15532067f, -0.07926087f, 
    0.10069680f, -0.19755448f, 0.17003557f, 0.21478963f, -0.18914303f, -0.04831298f, -0.08163074f, -0.10290013f, 
    0.20541506f, -0.11725037f, 0.08687717f, 0.14254513f, -0.18360491f, 0.13395859f, 0.13890587f, -0.02412592f, 
    -0.16331990f, -0.12937745f, 0.03156687f, -0.04433383f, 0.19662565f, -0.15485007f, -0.56491607f, -0.18085366f, 
    0.04716912f, 0.14369676f, 0.19034019f, -0.03264564f, -0.18282363f, -0.03587957f, 0.38905770f, 0.05327844f, 
    -0.33615318f, -0.05089138f, 0.04707314f, 0.13876249f, 0.01395430f, 0.07852856f, -0.13474549f, 0.13519265f, 
    0.30025253f, -0.26459929f, 0.00366299f, 0.02693455f, -0.00652585f, -0.06154253f, -0.08759874f, -0.04384192f, 
    -0.01133539f, 0.09853046f, 0.15837854f, -0.11910201f, -0.04454831f, -0.04370825f, 0.07288591f, 0.10005304f, 
    0.02157792f, -0.30791399f, -0.06209747f, -0.09203286f, -0.02980050f, 0.02668154f, 0.05600736f, -0.08888466f, 
    0.13254751f, -0.01540984f, -0.02308430f, 0.32773283f, -0.07462122f, -0.02466628f, 0.19606812f, 0.06370194f, 
    -0.05512461f, -0.00017269f, -0.20052646f, -0.04065495f, 0.13124691f, 0.10810091f, -0.00569806f, 0.00991361f, 
    -0.12141859f, 0.01584863f, 0.07333568f, 0.01483349f, -0.47958827f, -0.18046393f, -0.00659533f, 0.10925332f, 
    0.15416291f, 0.06582526f, -0.17721991f, 0.11401789f, 0.05877764f, -0.13261607f, 0.13417684f, 0.21575463f, 
    -0.03938678f, -0.04719061f, 0.01898078f, 0.04086932f, 0.07178766f, 0.00231716f, -0.20839325f, 0.04447261f, 
    0.05666600f, 0.10938036f, 0.07442670f, -0.09791368f, -0.15960565f, -0.08472377f, 0.20324975f, -0.06998893f, 
    -0.41234615f, 0.08909023f, 0.07750218f, 0.02955195f, 0.16709624f, -0.17435557f, 0.20746213f, 0.06387115f, 
    0.02862697f, -0.47322458f, 0.19154653f, 0.14957719f, 0.14895655f, 0.23637286f, -0.11635101f, -0.12028060f, 
    -0.06397881f, -0.05098728f, 0.06763271f, 0.10136666f, 0.00726261f, 0.01715017f, 0.02651470f, 0.24393095f, 
    0.03407396f, 0.07704974f, 0.00432583f, 0.13382040f, 0.06019788f, -0.24141543f, -0.20110530f, 0.02898159f, 
    0.19194356f, 0.15077379f, 0.02731928f, -0.33546618f, 0.06116920f, 0.15126057f, -0.05352508f, -0.08157834f, 
    0.13671803f, -0.06016528f, 0.03764244f, -0.00479741f, 0.23258676f, -0.40418527f, 0.07693478f, 0.02244584f, 
    0.22758536f, 0.23968400f, 0.04248609f, -0.09065229f, -0.01721142f, -0.19419751f, 0.14266135f, 0.05582343f, 
    -0.10437860f, -0.16824037f, -0.15373108f, -0.04928471f, 0.22982170f, 0.23829202f, 0.13599779f, 0.08221906f, 
    -0.20947224f, -0.26891524f, 0.00553480f, 0.03269360f, -0.18963793f, 0.08955320f, 0.00437035f, 0.03999935f, 
    0.25506139f, -0.18166970f, -0.13313125f, 0.06044484f, -0.12018660f, -0.19724287f, -0.17314798f, -0.12707657f, 
    0.20153187f, 0.21541589f, 0.05437666f, -0.09240823f, -0.02895000f, 0.00449406f, 0.04486283f, 0.10645126f, 
    -0.01402477f, 0.00150050f, -0.42191499f, 0.17146163f, 0.00730229f, -0.00797828f, 0.17594495f, 0.17490695f, 
    -0.04265182f, 0.02788309f, 0.09866560f, 0.13160908f, 0.17004205f, 0.12175651f, 0.09500530f, 0.03827488f, 
    -0.00945543f, -0.31348580f, -0.00965956f, -0.28444889f, -0.41024846f, 0.09009817f, 0.24690007f, 0.20462053f, 
    0.07822733f, -0.26093465f, -0.20683138f, -0.01822755f, 0.45484874f, -0.12895946f, -0.30671325f, -0.09125436f, 
    -0.03732885f, 0.10540750f, -0.07126958f, -0.00923206f, -0.04326407f, 0.10989448f, -0.16701995f, 0.02702629f, 
    0.07692191f, 0.04484157f, 0.12476461f, 0.10056837f, -0.07206395f, 0.03047295f, -0.09390869f, 0.05563890f, 
    0.11377870f, -0.08598498f, -0.06622519f, -0.00045045f, 0.09620845f, 0.07224314f, 0.17289196f, 0.15524374f, 
    0.12185622f, -0.14554241f, -0.05102916f, 0.05957884f, 0.07153030f, -0.01525705f, -0.18831006f, -0.18675913f, 
    -0.45774639f, -0.11678837f, 0.04108844f, 0.07734725f, 0.14141412f, 0.00704110f, 0.06453524f, 0.20551355f, 
    0.05462174f, -0.26167390f, -0.07620279f, -0.04348470f, -0.10498784f, 0.01027495f, 0.05854217f, -0.04718970f, 
    -0.00426576f, 0.03425119f, -0.20543601f, 0.03139023f, 0.18186469f, -0.05380248f, -0.02095485f, 0.06202743f, 
    0.16811016f, 0.21990941f, -0.16445446f, -0.00824839f, -0.10728289f, 0.29773167f, -0.00356353f, -0.17344262f, 
    -0.00490674f, 0.22976302f, 0.14263175f, -0.16578764f, -0.27499309f, -0.16403668f, -0.01902960f, 0.06250897f, 
    -0.08263813f, -0.03024905f, -0.01887519f, -0.16686589f, 0.07295049f, -0.08208545f, 0.17334403f, 0.16334501f, 
    -0.09128131f, -0.05025295f, 0.05905277f, -0.02806511f, 0.07444965f, -0.00539608f, -0.24888092f, -0.11568409f, 
    0.15998298f, 0.08523764f, -0.10942432f, -0.05380933f, -0.13729866f, -0.10847759f, 0.06778006f, -0.28535438f, 
    0.04868911f, 0.14720671f, 0.25306347f, 0.02121346f, 0.02629782f, -0.12839399f, 0.16839437f, 0.04637543f, 
    -0.16490570f, -0.15211920f, -0.21700400f, 0.02312475f, 0.06851122f, 0.07430967f, 0.00651058f, -0.07395646f, 
    0.02614852f, 0.31835878f, -0.02559755f, 0.12898904f, 0.04628678f, -0.08573891f, 0.03525150f, 0.16080841f, 
    0.00686559f, -0.03009799f, -0.06707976f, -0.23830357f, -0.03179802f, 0.13726538f, -0.04948931f, 0.14979257f, 
    0.13522008f, -0.11219208f, -0.00391780f, 0.29557607f, -0.16069274f, -0.31137156f, 0.30043578f, 0.12032970f, 
    -0.11303598f, 0.12833756f, -0.00963086f, -0.14965963f, -0.07353965f, 0.17225088f, 0.11879645f, 0.17925590f, 
    0.09575898f, -0.05602903f, -0.05760125f, 0.01710144f, 0.02392977f, 0.02435626f, -0.16451897f, 0.11280197f, 
    0.17503817f, 0.00972094f, -0.11728177f, 0.06838655f, -0.20717753f, -0.02146970f, -0.07494204f, 0.01680569f, 
    -0.19904609f, 0.03793155f, -0.06044917f, 0.08558418f, 0.01880069f, 0.04499874f, 0.28264681f, 0.03750068f, 
    0.23787047f, 0.02755312f, -0.12868695f, -0.03148394f, 0.08221152f, 0.03276714f, -0.01786323f, -0.11909214f, 
    0.27279109f, 0.19793981f, -0.00248004f, -0.03475275f, -0.09064951f, 0.00925076f, -0.15549274f, 0.08406470f, 
    0.03136875f, 0.04531295f, -0.25677648f, -0.10537940f, -0.00158890f, 0.01680120f, -0.07615764f, -0.01817777f, 
    -0.13458228f, -0.09789681f, 0.33334652f, -0.39431545f, -0.08957590f, 0.08976807f, -0.01513583f, -0.03032786f, 
    0.07366934f, -0.13400026f, -0.01491965f, 0.30348203f, 0.02222975f, -0.09428847f, 0.15445116f, -0.14215523f, 
    -0.03248534f, 0.16486706f, -0.16724153f, 0.05437644f, 0.28758776f, 0.23323439f, -0.02544415f, 0.04929143f, 
    -0.07446222f, 0.11309790f, -0.05668601f, 0.01550484f, -0.03851965f, -0.05172526f, -0.11497567f, -0.06985188f, 
    0.03926718f, -0.05025003f, -0.01234221f, 0.02495094f, -0.20730680f, -0.01832302f, -0.38878879f, 0.03807781f, 
    0.17051476f, 0.12346400f, -0.06552985f, -0.10619103f, 0.11999456f, -0.03171124f, -0.03024259f, -0.08980170f, 
    -0.25040221f, -0.15658018f, 0.06736860f, 0.00673700f, -0.01897763f, 0.04519812f, 0.15062562f, -0.16937689f, 
    0.02446950f, -0.34032893f, -0.24191359f, 0.26784167f, 0.06006636f, 0.17955998f, 0.01814859f, -0.09967242f, 
    0.03345220f, 0.01479734f, 0.07692503f, 0.09816664f, -0.23206374f, -0.06598825f, -0.00826311f, -0.16251512f, 
    -0.17348081f, 0.10778217f, 0.15062007f, 0.08090649f, -0.04476038f, -0.13778535f, 0.01041942f, 0.21981409f, 
    -0.06000860f, 0.21399936f, 0.19826330f, -0.00455934f, 0.12389270f, 0.23825745f, 0.04273316f, -0.18775453f, 
    0.07595637f, -0.01924361f, 0.19992211f, 0.08529688f, -0.07607985f, -0.13876592f, 0.17526160f, -0.10609220f, 
    -0.13385686f, -0.06708709f, 0.00656379f, 0.16975148f, -0.09260551f, -0.00180721f, 0.05142452f, -0.23851661f, 
    0.10745730f, 0.13642098f, -0.09495078f, 0.00807451f, 0.25652197f, 0.02685041f, -0.34962368f, -0.36685589f, 
    0.04811890f, 0.01310530f, 0.06896860f, 0.01801631f, -0.06020282f, -0.07884762f, -0.09451209f, -0.03332833f, 
    -0.01209516f, 0.04582107f, 0.10376556f, -0.01973188f, 0.03358212f, 0.02249222f, 0.10666753f, 0.11617375f, 
    0.13566224f, 0.10404675f, 0.13116005f, 0.10202944f, 0.01011950f, 0.04286492f, 0.08298855f, -0.01739156f, 
    0.01890131f, -0.01816405f, -0.00512664f, -0.00283643f, -0.13850476f, 0.05652062f, -0.03140000f, -0.10306168f, 
    -0.05056892f, 0.06461872f, 0.08855909f, 0.26022169f, 0.12502670f, 0.14739217f, -0.11269970f, 0.14874130f, 
    0.01877013f, -0.11557829f, 0.06457500f, -0.45411643f, -0.00646101f, -0.25239041f, -0.04096404f, -0.01925072f, 
    -0.03640314f, 0.07994626f, -0.07320657f, 0.00630791f, 0.00638777f, -0.26327324f, 0.08761188f, 0.20728560f, 
    0.06921463f, -0.12828754f, -0.04279985f, -0.05073668f, -0.13116883f, 0.10632502f, -0.06920682f, 0.04625569f, 
    -0.15386504f, 0.02854387f, -0.14235011f, -0.13395180f, -0.01073893f, 0.03222194f, 0.26185840f, 0.11884172f, 
    -0.03727970f, 0.00135193f, 0.10896931f, -0.14102763f, -0.14281008f, 0.36068127f, -0.09417608f, 0.12099301f, 
    0.16069996f, -0.00034749f, 0.08917430f, 0.02835839f, -0.13585629f, 0.08097959f, 0.01753840f, -0.11023085f, 
    0.11103026f, -0.09908944f, 0.20937762f, -0.16130972f, 0.10015426f, 0.03227632f, 0.02552755f, -0.07286965f, 
    0.02606383f, 0.05920797f, -0.07433083f, -0.01576665f, -0.08169352f, -0.05420717f, -0.08880713f, 0.05467200f, 
    -0.17746909f, -0.05293075f, 0.13448025f, -0.02619942f, -0.10837789f, 0.03437532f, 0.15602967f, 0.01030201f, 
    -0.02825351f, -0.16893433f, -0.12904873f, 0.05443116f, 0.29885232f, -0.15931784f, 0.04968819f, 0.12022053f, 
    0.00875863f, 0.03622776f, 0.01658927f, 0.16013549f, 0.30789146f, -0.11656088f, 0.02655714f, -0.06585045f, 
    -0.00631333f, -0.16214001f, 0.04666662f, -0.03632892f, -0.07483346f, -0.01159433f, 0.40627444f, -0.02577242f, 
    0.07389007f, 0.16753131f, -0.09087792f, 0.01491611f, -0.03182049f, 0.01779450f, 0.08704636f, -0.34823057f, 
    0.10383352f, 0.21384712f, -0.08800483f, -0.05944335f, -0.00607765f, -0.02267397f, 0.06464788f, -0.06527732f, 
    0.25187406f, 0.05897709f, 0.00812079f, -0.12229414f, -0.21302691f, -0.29956123f, 0.04839939f, -0.02362677f, 
    -0.07320351f, -0.19458069f, 0.03920735f, 0.04184622f, -0.01805278f, -0.15841034f, -0.00029742f, 0.14308380f, 
    -0.04870299f, -0.19688535f, -0.16425280f, -0.19080366f, 0.07819975f, -0.01123766f, 0.03507046f, 0.10309675f, 
    0.02471964f, -0.00586119f, 0.08123744f, -0.18494590f, -0.32722634f, -0.00779874f, 0.23339847f, -0.02858877f, 
    0.05101670f, -0.14956154f, 0.01244067f, -0.00983202f, -0.24087529f, 0.18471760f, 0.02128370f, 0.07501416f, 
    0.03560206f, -0.03902736f, 0.03903060f, -0.12686290f, -0.07186932f, 0.02087181f, -0.00099602f, -0.23039012f, 
    0.02054311f, -0.17145255f, -0.03160147f, 0.05325117f, -0.02159864f, 0.21158899f, -0.07191779f, -0.11764740f, 
    -0.18144529f, -0.03514419f, 0.06759631f, -0.21365650f, -0.09455872f, 0.04788500f, 0.07714146f, -0.07805647f, 
    -0.15356472f, -0.15674268f, -0.05876729f, 0.10199784f, 0.11863222f, -0.01000105f, 0.20185646f, -0.19229534f, 
    -0.03634594f, 0.12737966f, -0.15375924f, -0.06171545f, 0.24900036f, 0.06421921f, 0.11184753f, 0.16582099f, 
    0.14988157f, 0.01172158f, 0.07673579f, 0.08049961f, 0.14100000f, 0.16107494f, 0.13815932f, -0.06222695f, 
    0.13946800f, 0.07491633f, 0.21274145f, -0.33785933f, 0.03066129f, -0.16988066f, -0.09174319f, -0.07342513f, 
    0.13101864f, 0.07477004f, -0.15068342f, -0.15081872f, 0.06274822f, 0.04885188f, 0.00833194f, -0.10290020f, 
    0.01474307f, -0.00057658f, -0.09898219f, 0.24058837f, 0.16674921f, 0.18925080f, -0.14926723f, 0.09583762f, 
    -0.00712513f, -0.05575225f, -0.01018115f, -0.01570502f, -0.40308222f, 0.10025779f, -0.00493324f, 0.02540018f, 
    0.04760130f, -0.00103194f, 0.14455144f, -0.05425785f, 0.15662056f, -0.06072060f, 0.25590551f, -0.22148813f, 
    -0.21894383f, 0.03591262f, -0.17222235f, 0.06556696f, 0.08560539f, -0.09418273f, 0.15294681f, -0.05063241f, 
    0.00301488f, 0.03319165f, -0.04849815f, -0.17842096f, -0.05722073f, -0.12059510f, -0.02857055f, -0.11084509f, 
    0.10843042f, 0.01672386f, -0.17009078f, 0.06275678f, 0.03750676f, -0.21513416f, 0.02726666f, -0.06160166f, 
    0.19502130f, 0.10161350f, 0.15585077f, -0.06470233f, -0.01725601f, -0.14588766f, 0.09575552f, 0.07055314f, 
    -0.13613071f, -0.01483641f, -0.02309659f, 0.11601713f, 0.09241717f, 0.13538347f, -0.18996468f, 0.18861695f, 
    -0.07345461f, -0.22353223f, -0.27402538f, 0.16938007f, 0.15619682f, 0.22266439f, 0.01781072f, 0.07522516f, 
    -0.23077822f, -0.00627110f, -0.23620556f, -0.31279752f, -0.14348370f, -0.08431789f, 0.13549477f, -0.17406009f, 
    -0.18292484f, 0.22324285f, 0.08049882f, -0.31707430f, -0.02592057f, -0.14812925f, -0.10451924f, 0.03740057f, 
    0.09916708f, 0.00708488f, 0.06323130f, -0.12014668f, -0.03191461f, 0.05221097f, 0.01711495f, -0.28130627f, 
    -0.01934228f, -0.08537810f, 0.03974838f, 0.19349827f, 0.04672449f, 0.02247821f, 0.40705532f, -0.05051496f, 
    -0.04900895f, -0.17750150f, 0.27157485f, -0.10153064f, 0.04339160f, 0.03870433f, 0.08803017f, 0.18808120f, 
    -0.03495698f, -0.04603617f, -0.13225968f, -0.04587314f, -0.05933512f, 0.13416646f, 0.04280446f, -0.22843949f, 
    0.16901849f, -0.02532884f, 0.03766214f, -0.02283913f, 0.11244056f, -0.00413028f, -0.02004327f, 0.02601995f, 
    -0.15387021f, -0.56820083f, -0.24758354f, -0.23562141f, 0.17524201f, 0.04632049f, -0.01731694f, 0.08237658f, 
    -0.07890954f, -0.06561571f, 0.08826250f, -0.09769253f, 0.10841789f, -0.03044626f, -0.04677797f, -0.03402048f, 
    -0.17982504f, 0.02828775f, -0.09425623f, -0.04163293f, 0.13814603f, 0.09890650f, 0.14033732f, 0.02194376f, 
    -0.13965395f, -0.23585933f, 0.17922091f, -0.05194138f, -0.06304182f, -0.10749893f, -0.27826002f, 0.05957371f, 
    0.07154514f, 0.12014765f, 0.03555968f, -0.02495093f, -0.01948368f, -0.03403975f, 0.13272302f, -0.07215568f, 
    0.14845203f, 0.14968359f, -0.04891395f, 0.02845046f, 0.05237506f, 0.03549349f, -0.18836038f, -0.20195140f, 
    0.13097142f, -0.11445990f, 0.01912964f, -0.17294489f, -0.16847956f, 0.05566967f, -0.11914983f, 0.13240035f, 
    -0.05854495f, 0.26951107f, 0.08004533f, -0.13350974f, 0.00003080f, 0.24414364f, -0.05407652f, 0.00256194f, 
    0.46216375f, -0.22942707f, 0.05037918f, 0.08621959f, 0.01328319f, 0.15042837f, 0.07638059f, 0.19427346f, 
    0.04705685f, -0.27433920f, 0.05337612f, -0.10856165f, 0.02302093f, 0.03806298f, 0.10776585f, 0.20419288f, 
    -0.07222240f, -0.03847675f, 0.05171479f, -0.18457346f, 0.14881356f, 0.07024835f, -0.17013438f, 0.05871996f, 
    -0.11197106f, -0.02559295f, 0.10228053f, 0.22184083f, 0.06461550f, 0.14051357f, -0.11466879f, 0.08177768f, 
    0.00306325f, -0.07657381f, 0.17315166f, 0.00299219f, -0.03685845f, 0.01017321f, -0.05986872f, -0.03849717f, 
    -0.24915233f, 0.17231634f, 0.29789028f, -0.13617231f, 0.04269595f, 0.13669790f, 0.00998205f, -0.05111167f, 
    -0.10641512f, -0.21902338f, 0.05732710f, 0.13581984f, 0.01558227f, 0.22702916f, -0.20349678f, -0.26128438f, 
    0.23623309f, 0.16826852f, 0.04933272f, -0.08555041f, -0.19259244f, -0.07878543f, 0.13875490f, -0.19517872f, 
    -0.04240443f, 0.47983897f, 0.08047344f, 0.01034011f, -0.19898902f, -0.09630711f, -0.08415287f, -0.25410104f, 
    0.05586183f, 0.08486699f, 0.24553676f, 0.05340888f, 0.05841479f, 0.06775481f, -0.05365134f, 0.06042400f, 
    0.12300965f, 0.26987186f, -0.06624313f, 0.11010382f, 0.21681634f, 0.02057130f, -0.01866221f, -0.11852039f, 
    0.15753250f, 0.00465390f, 0.07768524f, 0.17346071f, -0.17104580f, -0.19962916f, -0.00928938f, 0.08892912f, 
    -0.10553379f, -0.07100224f, -0.04091852f, 0.09026285f, 0.12367582f, -0.30325574f, -0.06714029f, 0.11139831f, 
    0.07217442f, 0.05003250f, 0.12415233f, 0.24404322f, -0.17373213f, -0.09613938f, 0.29218459f, -0.02412460f, 
    -0.10992324f, 0.11244349f, -0.11681066f, 0.14353970f, -0.05408017f, 0.01290427f, -0.31908470f, 0.17796414f, 
    0.03825616f, 0.00814579f, 0.00046146f, 0.07241536f, 0.06841048f, -0.04002621f, 0.13768406f, 0.06240942f, 
    -0.05343773f, 0.08714986f, -0.01949132f, -0.07074015f, 0.13096543f, 0.06002434f, -0.04474745f, 0.12408880f, 
    0.01900998f, -0.11419401f, -0.26916808f, 0.09280730f, -0.18060197f, 0.10255100f, 0.06620049f, -0.05159048f, 
    0.02286252f, -0.00822680f, -0.09852610f, -0.11525412f, 0.05279024f, -0.02507010f, -0.18392214f, -0.01206954f, 
    -0.06300783f, -0.09877737f, -0.12670490f, -0.07981241f, -0.13058046f, 0.00920321f, 0.09575192f, 0.14522362f, 
    -0.07744049f, 0.16197318f, -0.29926431f, 0.00949575f, -0.11815499f, 0.18531503f, -0.00356587f, 0.06526513f, 
    -0.00443898f, -0.10424871f, -0.05363262f, 0.02090078f, -0.22216091f, -0.16655643f, -0.12371029f, 0.05876960f, 
    -0.05074799f, -0.13882849f, 0.06345320f, 0.02120105f, 0.06612422f, 0.29317734f, -0.13043176f, 0.11060984f, 
    0.00747760f, -0.09413461f, 0.13802986f, -0.04383098f, 0.13940804f, -0.41858003f, -0.24538188f, -0.16688189f, 
    0.13565904f, 0.17387196f, 0.08617029f, 0.00332603f, 0.14312989f, -0.09449000f, 0.10456717f, -0.17254394f, 
    0.05429235f, -0.05136090f, -0.28954858f, -0.00739548f, 0.08597532f, 0.12472690f, 0.19630896f, 0.13485624f, 
    -0.04720140f, 0.04598884f, 0.00550659f, -0.06557611f, -0.04467567f, 0.03208564f, -0.02340127f, 0.13269432f, 
    0.03271861f, -0.04065988f, -0.14505576f, 0.04828783f, -0.10611834f, 0.02931431f, -0.13660744f, 0.05539280f, 
    -0.00177526f, -0.25125316f, -0.10577402f, -0.24508061f, 0.04861381f, 0.01452622f, 0.00422954f, 0.03382669f, 
    0.17853643f, 0.03587340f, 0.21503234f, 0.05162845f, 0.07454398f, -0.02929255f, -0.01986461f, 0.16321315f, 
    -0.04792342f, 0.22700429f, -0.05694179f, 0.37712324f, 0.13179055f, -0.10146903f, -0.04426384f, 0.04860398f, 
    -0.07918276f, -0.05027967f, 0.06098400f, -0.16836198f, -0.50244564f, -0.39966372f, -0.15869334f, 0.13132286f, 
    0.13178860f, -0.07866638f, 0.04838673f, -0.01513991f, -0.05164390f, 0.29372436f, 0.05758559f, -0.21136852f, 
    0.02431168f, 0.09751624f, -0.02284511f, 0.12157024f, 0.03357438f, -0.04914647f, 0.17460652f, 0.44242856f, 
    0.05998258f, -0.24777247f, -0.01068754f, -0.06996408f, -0.07241511f, 0.01693152f, 0.15097590f, -0.26610625f, 
    -0.37658009f, 0.02253819f, 0.20570680f, 0.05496696f, -0.11047183f, -0.00498939f, -0.07248694f, 0.15848102f, 
    -0.07516300f, 0.10652055f, 0.01249350f, 0.24292408f, 0.17592475f, 0.00408218f, -0.02627839f, -0.00592280f, 
    0.02504373f, -0.32267663f, -0.22361191f, -0.10733479f, 0.05842708f, -0.00894041f, -0.00870772f, 0.07808160f, 
    0.20520782f, -0.13094865f, -0.04208082f, 0.05402124f, -0.02442117f, -0.02562422f, 0.07660986f, 0.07324715f, 
    0.03258150f, 0.12126151f, 0.02565089f, 0.17964835f, 0.10025936f, 0.22073765f, 0.02056949f, -0.13500713f, 
    -0.01125634f, 0.04966201f, -0.05398534f, -0.15713945f, -0.04456551f, -0.11632030f, -0.15866828f, 0.21376830f, 
    -0.00539179f, -0.06212091f, -0.07132757f, 0.06407300f, 0.03730204f, 0.09860387f, 0.02935199f, -0.01177348f, 
    0.15118995f, -0.09668893f, -0.08476111f, 0.03599708f, 0.09716444f, 0.00727499f, -0.21430467f, 0.06493109f, 
    -0.22385846f, -0.04066142f, -0.03128794f, 0.12534659f, 0.10551588f, -0.17988463f, 0.01499473f, -0.01690225f, 
    0.25358343f, 0.00832621f, -0.19252720f, 0.00775179f, 0.10464441f, 0.03404210f, -0.18408631f, 0.05370442f, 
    0.26143152f, 0.25337580f, -0.12784761f, -0.10435210f, 0.08262220f, -0.04554887f, -0.07954260f, 0.17976229f, 
    -0.09372498f, -0.59725010f, -0.14459984f, 0.01460102f, 0.18258105f, 0.12805581f, -0.02202669f, -0.03112252f, 
    -0.07286697f, 0.03421115f, -0.27618563f, 0.29334950f, -0.00528148f, 0.10985629f, 0.19139095f, -0.01534875f, 
    0.06350155f, 0.07933170f, -0.08607471f, -0.46272665f, -0.12351274f, -0.06450839f, 0.10953444f, 0.15700796f, 
    0.09804224f, 0.00734599f, -0.02652983f, 0.01472956f, 0.24203110f, 0.09684733f, -0.03444735f, 0.02630504f, 
    0.08907019f, -0.00302701f, 0.02430766f, -0.10822088f, 0.18388422f, 0.14430708f, 0.11290701f, -0.17758897f, 
    0.09733374f, 0.02003146f, -0.02082165f, -0.15759008f, 0.19014098f, 0.14813615f, 0.07625655f, 0.05957263f, 
    -0.10563443f, 0.07835800f, 0.06352546f, -0.05971474f, -0.07450324f, 0.17398177f, -0.09776644f, 0.07734007f, 
    -0.06500802f, 0.04286046f, 0.12530524f, 0.01465402f, 0.04540943f, 0.16487451f, -0.03857181f, 0.15747015f, 
    -0.03564231f, -0.02687415f, -0.01492277f, -0.04659766f, 0.03297717f, 0.00498409f, -0.05684581f, -0.05820160f, 
    -0.06019447f, 0.03285056f, 0.01964355f, 0.05290036f, 0.03083734f, 0.05024847f, -0.03735266f, -0.00110260f, 
    -0.03739312f, 0.04900884f, 0.03444355f, 0.01673414f, -0.04240233f, 0.03774010f, -0.02873164f, 0.03175083f, 
    0.03958720f, -0.04294781f, 0.04778012f, -0.02570372f, 0.00207521f, -0.04660857f, 0.04809728f, -0.06028450f, 
    -0.00156946f, -0.05936163f, 0.02110337f, -0.01050781f, -0.01742783f, 0.00441947f, -0.03662471f, 0.04609456f, 
    0.01957380f, 0.01375785f, 0.02691340f, -0.01083861f, -0.01632992f, -0.01699437f, -0.01130477f, -0.05950818f, 
    0.00127019f, 0.03443093f, 0.00927396f, 0.04923487f, -0.04990648f, -0.03677871f, -0.02089145f, -0.00100875f, 
    -0.04671969f, -0.01626472f, 0.02848692f, 0.00197717f, 0.02852370f, 0.02242751f, -0.05995853f, 0.02193551f, 
    -0.05530583f, 0.05248937f, -0.00413832f, 0.00983334f, 0.04952389f, -0.03452634f, -0.02016286f, -0.03210854f, 
    -0.06767967f, -0.02452126f, -0.02708560f, -0.04291568f, 0.01411524f, -0.06062593f, 0.01765545f, 0.04019891f, 
    0.03546698f, 0.03785375f, -0.00396579f, 0.04784163f, -0.03489061f, -0.02548675f, 0.00463892f, -0.03887057f, 
    0.04791385f, 0.04027355f, 0.00424707f, 0.02518411f, -0.02037258f, -0.03229646f, -0.00228328f, -0.05560268f, 
    0.04187495f, 0.00935172f, -0.00469607f, 0.00221983f, 0.02947801f, -0.05655301f, -0.02749955f, -0.03136259f, 
    0.00296559f, -0.03353089f, 0.01870178f, -0.04854488f, -0.06304569f, 0.05275666f, -0.00613881f, 0.01378437f, 
    -0.03586082f, 0.00843601f, -0.03156546f, 0.02333832f, 0.04627476f, -0.06040210f, -0.03888924f, 0.02535014f, 
    -0.01486745f, -0.01327539f, -0.02366701f, -0.04711446f, 0.00844546f, -0.03263299f, 0.05183705f, 0.04400493f, 
    0.00589115f, 0.01744851f, -0.06804701f, -0.01370549f, -0.01972274f, 0.00654059f, 0.00305005f, -0.00066967f, 
    -0.03661181f, -0.01243571f, 0.02467723f, 0.02481328f, -0.01293088f, -0.01603572f, 0.02948303f, -0.05006845f, 
    0.00178456f, 0.05200106f, -0.04907321f, 0.04186936f, -0.03265702f, -0.00935306f, 0.03692578f, -0.02990688f, 
    -0.03422453f, -0.03692043f, -0.00821926f, -0.02077738f, 0.00635817f, -0.04316355f, 0.02119409f, -0.00624280f, 
    -0.06650563f, -0.02413136f, -0.00385673f, 0.00512911f, -0.02346368f, 0.00335565f, -0.04779909f, 0.00198222f, 
    0.01491285f, -0.04536533f, -0.00476097f, -0.04161808f, -0.05484071f, -0.03789496f, -0.02116553f, -0.02456138f, 
    -0.00528728f, -0.05362649f, 0.02257316f, -0.05845188f, -0.04192385f, 0.00962664f, -0.04075759f, -0.04240809f, 
    0.02262559f, 0.02053940f, 0.00329050f, -0.06288537f, -0.06866585f, -0.01092483f, -0.05828950f, -0.02980086f, 
    -0.04509932f, 0.03069138f, -0.05028582f, -0.01708569f, -0.00277923f, -0.06177932f, -0.05008012f, -0.01870059f, 
    0.00736266f, 0.03688521f, -0.04470497f, 0.04455747f, -0.04465437f, 0.00018024f, -0.05577444f, 0.05499779f, 
    0.01978819f, -0.03958442f, -0.00982247f, -0.03257040f, 0.01397841f, 0.04334341f, 0.02484864f, 0.00793296f, 
    0.03950095f, -0.03296265f, -0.06612656f, -0.05361182f, -0.05621191f, 0.01342143f, -0.05486477f, 0.01350458f, 
    -0.00455132f, 0.05706941f, -0.04620932f, -0.00682505f, -0.03896143f, -0.02499652f, -0.06683115f, -0.02210823f, 
    0.04906071f, -0.01207698f, -0.01944253f, 0.00202727f, 0.02633818f, -0.01936140f, 0.01571034f, -0.02986373f, 
    0.04506227f, 0.04515166f, 0.00203357f, -0.03896438f, -0.02023163f, -0.01122264f, 0.04699069f, 0.04855510f, 
    -0.00831500f, 0.00037849f, -0.04331639f, -0.00128383f, -0.04438733f, 0.02749474f, 0.00523758f, 0.01943653f, 
    0.00100812f, -0.05194188f, -0.04253112f, -0.05283378f, -0.00246490f, 0.04457019f, -0.05020577f, 0.02894324f, 
    0.04857858f, 0.00567248f, -0.06763212f, 0.00775108f, 0.01300982f, 0.01289719f, -0.01816572f, -0.00569577f, 
    0.00144527f, 0.00503323f, -0.03991850f, 0.03321337f, 0.03042719f, -0.06006386f, -0.00803229f, 0.03140224f, 
    -0.03231699f, -0.04127437f, -0.05932048f, -0.02503055f, -0.03134114f, -0.04484405f, -0.04911167f, 0.02683721f, 
    0.04484299f, 0.04298498f, 0.03925210f, -0.05788907f, -0.00516210f, 0.04754450f, 0.05236318f, -0.03065667f, 
    -0.01374152f, -0.01424331f, -0.06506731f, -0.02775194f, -0.01378886f, -0.06098771f, 0.00240709f, 0.03906918f, 
    -0.03684372f, 0.04556981f, -0.04321422f, 0.02435540f, -0.03922803f, -0.01048078f, -0.06059762f, 0.01269448f, 
    -0.04534392f, 0.00304498f, -0.00818684f, -0.04672844f, -0.03953152f, -0.06274859f, 0.04906388f, -0.04729515f, 
    0.00545251f, 0.04231123f, 0.00203724f, 0.04562673f, -0.01511146f, 0.04689471f, -0.00970563f, -0.05572760f, 
    -0.03065697f, -0.05799078f, 0.04541873f, -0.05792486f, 0.02497873f, -0.02221716f, -0.02542527f, 0.04006506f, 
    0.03770595f, -0.05222093f, -0.03946239f, 0.03624542f, -0.02101500f, -0.02605927f, -0.04191292f, 0.00121125f, 
    -0.03571635f, 0.01473638f, -0.01454118f, -0.03304880f, -0.05910870f, -0.02338991f, 0.00639261f, -0.01685471f, 
    -0.00986854f, -0.00483241f, 0.05266003f, 0.03787209f, -0.01016017f, 0.04637127f, 0.04973488f, -0.02499808f, 
    -0.06324682f, -0.06677205f, -0.01774212f, -0.00089272f, -0.05771750f, 0.02931335f, -0.05910605f, -0.02375798f, 
    0.04466490f, -0.04821017f, -0.04925324f, 0.00837722f, 0.03144306f, -0.04177993f, -0.04246067f, -0.06055146f, 
    -0.03804750f, 0.00489846f, -0.04959432f, 0.03527053f, -0.05553038f, 0.02097547f, 0.03323486f, 0.01356574f, 
    0.00227657f, 0.00726883f, 0.02104368f, -0.03556207f, -0.00790304f, 0.04105480f, 0.04372463f, -0.00281293f, 
    -0.02393181f, -0.02824082f, -0.00828421f, -0.04339820f, 0.03810016f, 0.00145241f, 0.04127274f, -0.00133615f, 
    0.00235087f, 0.00102432f, -0.04134699f, -0.02915118f, -0.00926677f, 0.02692421f, -0.06408770f, -0.03926937f, 
    -0.06730983f, 0.01524165f, -0.02764075f, 0.04804252f, -0.02895776f, 0.03069124f, -0.00568963f, -0.05701009f, 
    0.03132733f, -0.04296512f, 0.03580250f, -0.05805596f, -0.04676399f, -0.00285192f, -0.00032563f, -0.01290441f, 
    -0.02533351f, -0.01919630f, 0.02554031f, 0.03982377f, 0.02927466f, -0.04654414f, 0.04072360f, -0.02727005f, 
    -0.01971385f, 0.01760466f, -0.04060879f, -0.02082533f, -0.04207106f, -0.02957214f, -0.06568652f, -0.05518268f, 
    -0.05851622f, 0.01048786f, -0.02644900f, -0.05106814f, 0.00631756f, 0.05019523f, -0.01419915f, -0.06215461f, 
    0.02556004f, -0.05539320f, -0.06316494f, -0.05925521f, -0.00782670f, -0.03453933f, -0.01211884f, -0.01024806f, 
    0.01780874f, 0.00532911f, 0.00021523f, -0.01172116f, 0.03625542f, -0.05911162f, -0.00013978f, 0.01641898f, 
    0.00157703f, -0.01742899f, 0.02248237f, 0.03999174f, 0.03830587f, 0.00989605f, 0.02116194f, -0.04085492f, 
    -0.04569816f, 0.03772381f, 0.00662282f, 0.02560321f, 0.04170765f, 0.00292009f, -0.06160104f, 0.00212278f, 
    -0.02605265f, 0.03347391f, -0.04262502f, 0.00664935f, 0.03238860f, 0.02661352f, 0.00992136f, -0.01369991f, 
    -0.03733397f, 0.04357027f, -0.00371528f, -0.00469558f, 0.00200085f, -0.02720601f, -0.03233676f, 0.02760253f, 
    -0.02830747f, 0.00796112f, -0.05162222f, -0.06513330f, -0.05335481f, 0.02688303f, 0.02522106f, 0.04417387f, 
    0.00781431f, -0.04115988f, 0.00555625f, -0.03020755f, 0.03420553f, -0.05116283f, -0.03446280f, -0.03041975f, 
    0.04873812f, 0.03233838f, 0.00302269f, -0.04382990f, -0.03621955f, 0.04852251f, 0.04119731f, 0.04336417f, 
    -0.02148825f, 0.02598837f, 0.04529932f, -0.04801286f, 0.00712142f, 0.01589809f, 0.03900289f, -0.01320528f, 
    0.01571074f, -0.02773727f, 0.02033112f, 0.01345528f, 0.03765233f, -0.05603014f, 0.04588874f, 0.03543532f, 
    0.04092154f, 0.01094584f, -0.01306482f, -0.04841112f, 0.03598352f, -0.00879636f, -0.05189520f, 0.00046677f, 
    -0.04786903f, -0.03527730f, 0.01886848f, 0.05369530f, 0.04692341f, -0.01014402f, -0.01646565f, 0.00467535f, 
    -0.06248362f, -0.05035242f, -0.02402068f, -0.04106613f, -0.03216508f, -0.02061346f, 0.02654807f, 0.03457172f, 
    0.04722331f, 0.02585538f, -0.02374243f, -0.02429876f, -0.02320243f, -0.01852883f, 0.04274112f, -0.02155158f, 
    0.00208821f, -0.03412854f, -0.00956407f, -0.05329833f, -0.04125959f, -0.00731876f, -0.00787107f, 0.01150652f, 
    0.24438851f, 0.07629741f, 0.14672409f, -0.20357752f, -0.00744604f, -0.04322038f, 0.07616118f, -0.03511303f, 
    -0.09522205f, -0.16415054f, -0.37227413f, -0.00102941f, 0.13166580f, -0.04582902f, 0.20163007f, 0.03084640f, 
    0.00602254f, -0.00992828f, -0.17035267f, -0.17549837f, -0.12963867f, -0.00987828f, -0.05279869f, -0.00914498f, 
    -0.05671223f, -0.02039640f, 0.01337360f, -0.36596245f, -0.30663803f, -0.02363001f, 0.03179351f, -0.08473703f, 
    0.07078706f, 0.26233837f, -0.04016452f, -0.01959645f, 0.04254624f, 0.03290566f, -0.32504514f, 0.12141828f, 
    -0.19304514f, 0.09930503f, 0.03972338f, 0.27366638f, 0.22421807f, -0.24408276f, -0.04188338f, -0.13884981f, 
    0.05093500f, 0.06504575f, 0.14273179f, -0.04284077f, 0.13626415f, 0.22928928f, -0.17855850f, -0.26538867f, 
    -0.01226213f, 0.08806081f, -0.00409073f, -0.00889542f, 0.00101520f, -0.16174626f, -0.04494298f, 0.07671046f, 
    -0.05555056f, -0.00254269f, -0.03410966f, 0.16178927f, 0.06645846f, -0.11175120f, 0.06435021f, -0.09010474f, 
    0.19425264f, -0.29558098f, -0.01472310f, -0.12359255f, -0.10816540f, -0.04514955f, 0.10406377f, 0.07573739f, 
    0.05755047f, -0.31286481f, -0.08323864f, 0.12764412f, 0.09295136f, 0.05610954f, 0.01439819f, -0.08363954f, 
    -0.00404393f, 0.19618791f, -0.25575864f, 0.18350826f, -0.06513140f, -0.04926366f, -0.01272705f, 0.14426625f, 
    0.24612196f, 0.02369887f, -0.01176520f, 0.18000178f, -0.15129302f, 0.03608651f, 0.06316679f, -0.05385843f, 
    -0.11205318f, 0.14155661f, -0.12333895f, -0.22634095f, -0.15392423f, -0.15743519f, -0.14745118f, 0.06824766f, 
    0.05269995f, -0.05865599f, -0.22248383f, 0.06970478f, 0.29174295f, 0.03834272f, 0.00204020f, -0.02320570f, 
    0.25156820f, 0.17378071f, 0.08090344f, -0.01954483f, -0.07726887f, -0.12959898f, 0.14314759f, 0.06095223f, 
    -0.45378587f, -0.11968799f, -0.00575100f, 0.23119475f, 0.00404285f, 0.07033838f, 0.21260779f, -0.00265506f, 
    -0.01547307f, 0.08429656f, -0.12029624f, -0.25330681f, 0.10858668f, -0.11499465f, 0.06588288f, 0.08607244f, 
    -0.00590400f, 0.16387086f, -0.23057781f, -0.00821829f, -0.04736617f, 0.18954486f, -0.10667492f, -0.11908232f, 
    -0.03873019f, -0.07915220f, -0.01667907f, 0.13143775f, -0.05406763f, -0.05516663f, -0.11010614f, -0.06995478f, 
    0.13429590f, 0.04841076f, 0.01113024f, 0.16881275f, -0.18153889f, 0.03410688f, 0.09775075f, 0.06749465f, 
    0.01561219f, 0.03681802f, -0.07064081f, 0.03982099f, 0.08842223f, -0.24849023f, -0.00522438f, 0.03578471f, 
    0.04034223f, -0.00392936f, 0.05330810f, -0.06852516f, -0.10108263f, -0.01704779f, -0.03834308f, -0.04516022f, 
    0.04636978f, 0.07007278f, 0.02545715f, 0.17110942f, 0.10817774f, 0.29942206f, -0.06960054f, -0.02249368f, 
    0.09921420f, -0.10845543f, 0.08548015f, 0.07514540f, 0.02941160f, 0.24861588f, -0.03913832f, -0.32593259f, 
    -0.00450406f, 0.02229813f, 0.02388622f, -0.02420167f, -0.00996357f, 0.05295373f, 0.03759645f, -0.13342866f, 
    -0.24602644f, -0.14263904f, -0.00216976f, 0.00621107f, -0.02006257f, -0.00398307f, -0.08362401f, -0.10171466f, 
    0.27716070f, 0.24438097f, -0.07926513f, 0.04714326f, 0.01324222f, 0.04333530f, -0.02181117f, -0.00447724f, 
    -0.11115748f, 0.21923831f, 0.15917556f, 0.04146073f, 0.09979767f, -0.13532411f, -0.02940096f, -0.05901586f, 
    0.02274005f, 0.19014210f, -0.35729066f, 0.00639099f, -0.14740974f, -0.15240131f, 0.06791893f, 0.20717324f, 
    -0.10447884f, -0.08278996f, 0.06150837f, -0.08405412f, -0.01379113f, -0.11620760f, -0.07292043f, 0.02215237f, 
    0.06391695f, -0.09613802f, 0.14728618f, 0.13143252f, -0.08831955f, -0.29772738f, -0.24170379f, -0.05317580f, 
    0.05470737f, 0.09986333f, -0.04271530f, -0.07129537f, -0.02332030f, -0.21198136f, -0.17942719f, -0.23732139f, 
    0.07544745f, 0.25545371f, -0.14911957f, -0.09058680f, 0.14507115f, 0.21553287f, 0.63785392f, -0.03574673f, 
    0.00706767f, 0.01777260f, -0.12482946f, 0.01839887f, 0.07192289f, 0.08218042f, 0.02654730f, -0.31383884f, 
    0.04580224f, 0.08752462f, 0.17055957f, 0.01873230f, 0.13248870f, 0.01368982f, -0.11862750f, -0.06768062f, 
    -0.04021826f, -0.21230370f, 0.31800613f, -0.21302700f, -0.05154733f, -0.17249398f, 0.15498763f, -0.10444854f, 
    0.07553944f, 0.25199950f, 0.07004943f, -0.02044328f, -0.08646746f, -0.01060529f, 0.15274256f, -0.17036869f, 
    -0.14977741f, 0.11217459f, 0.08405182f, -0.06246710f, 0.04521841f, -0.20451760f, 0.18740214f, -0.12010031f, 
    0.17182919f, -0.00623760f, -0.14865674f, 0.03570754f, 0.01879042f, 0.15668453f, -0.18626215f, -0.11529699f, 
    0.05518046f, 0.01746140f, 0.04053390f, -0.01163940f, -0.01669937f, 0.01400781f, -0.18861885f, -0.03508145f, 
    -0.12116352f, -0.04618877f, -0.14382493f, 0.13351339f, -0.02203249f, -0.17921795f, 0.19000666f, 0.00216807f, 
    0.00586361f, 0.04054125f, 0.09763248f, -0.14361537f, -0.11743604f, 0.01614129f, -0.53776467f, -0.01282130f, 
    -0.19505735f, 0.06445653f, 0.07692800f, 0.05623204f, -0.16510145f, 0.10161087f, 0.03622761f, -0.13215904f, 
    -0.25288668f, 0.11984056f, -0.27366057f, -0.00100210f, -0.12248870f, -0.03864118f, 0.15539902f, 0.04170430f, 
    0.43773627f, -0.05256354f, 0.18170452f, -0.00817676f, 0.12479402f, -0.04193190f, -0.23561397f, -0.05755464f, 
    0.20717052f, -0.05147461f, 0.02315711f, 0.11997026f, 0.00722173f, -0.08842546f, -0.08111320f, 0.11246347f, 
    0.09567734f, -0.10740024f, -0.06716911f, 0.15568984f, 0.10158966f, 0.10050037f, -0.13083903f, -0.29007199f, 
    -0.00342391f, 0.08071820f, 0.12266983f, 0.05955346f, -0.03901729f, -0.03677267f, 0.01616226f, 0.03969564f, 
    0.05932159f, 0.13214564f, -0.05148801f, 0.05899623f, -0.10726937f, 0.13218112f, 0.17847417f, -0.07812855f, 
    0.12707530f, 0.04441960f, 0.03809052f, -0.01673852f, 0.14392783f, 0.37433079f, 0.04307319f, 0.00432831f, 
    -0.13191968f, -0.06081418f, 0.08784266f, -0.14856975f, 0.02617906f, -0.10769005f, -0.02453758f, 0.06165733f, 
    -0.02130262f, -0.08029052f, -0.10149840f, -0.10061298f, -0.12016572f, -0.16693109f, 0.01564006f, 0.27021825f, 
    -0.13397825f, -0.17941859f, 0.04281852f, 0.08838163f, 0.03664114f, -0.07599417f, 0.03695529f, -0.12329630f, 
    0.13243280f, 0.27470919f, 0.05581007f, -0.00859007f, 0.24191874f, 0.06104399f, 0.22608496f, -0.13656095f, 
    -0.09134728f, -0.10100865f, 0.11319706f, 0.03979562f, -0.05277474f, -0.14781198f, 0.21487448f, -0.03933797f, 
    -0.12267563f, -0.14373243f, -0.10704719f, 0.20262410f, -0.09354721f, -0.26337910f, -0.21824646f, -0.14343975f, 
    -0.10466146f, -0.07288925f, 0.17112841f, 0.28072962f, 0.08784420f, -0.10153347f, -0.06748027f, 0.05956297f, 
    -0.01764885f, -0.06771602f, 0.12194959f, -0.07753164f, -0.08460864f, 0.08247162f, 0.03000997f, 0.06049538f, 
    -0.02898554f, -0.08206179f, -0.13111870f, -0.16552502f, -0.05120550f, 0.41555640f, -0.14647041f, 0.00137497f, 
    -0.17776974f, 0.10547207f, -0.08928148f, -0.01947247f, 0.01095980f, -0.08372208f, 0.17742217f, -0.33871683f, 
    -0.02035256f, -0.21236649f, 0.09182258f, -0.26387906f, -0.26940611f, -0.05761887f, -0.02534577f, -0.21270259f, 
    -0.30487064f, -0.22417274f, -0.08408937f, 0.01535724f, -0.02535337f, 0.04437401f, -0.20060532f, 0.13912083f, 
    0.11516458f, 0.05296224f, 0.16629128f, -0.15340659f, -0.09139737f, -0.14092778f, 0.20942605f, -0.02890395f, 
    0.05627185f, 0.16054478f, 0.30416036f, -0.36044815f, -0.11684070f, 0.06653792f, 0.12017345f, -0.02574208f, 
    -0.01103049f, -0.20066345f, -0.52849233f, 0.29119581f, 0.28576961f, 0.07335632f, 0.11341862f, 0.05501197f, 
    0.10689677f, 0.04034887f, 0.14183800f, -0.07485328f, 0.12902778f, 0.05079288f, 0.11020515f, -0.08760705f, 
    0.19382828f, -0.03738988f, 0.04317770f, 0.07780609f, 0.21756336f, -0.43916237f, -0.21614714f, 0.13273539f, 
    0.07505178f, 0.03626486f, -0.06553604f, 0.13530491f, -0.11863802f, -0.17035288f, 0.03626768f, 0.09036730f, 
    -0.07890698f, 0.11551244f, -0.12459245f, -0.00667813f, 0.10487445f, -0.10602432f, 0.37411264f, 0.07995886f, 
    0.00755735f, -0.21195835f, 0.11896868f, 0.02506304f, -0.10879883f, -0.01065976f, 0.12021373f, -0.17998056f, 
    0.09209235f, -0.13779932f, 0.03952710f, 0.10161898f, 0.18494999f, -0.18644542f, 0.01662740f, 0.00386385f, 
    0.01258902f, -0.00860878f, -0.05706967f, 0.00738031f, 0.01500985f, 0.04583346f, 0.04396768f, -0.01291606f, 
    0.03549992f, -0.04886623f, 0.01330926f, -0.05138419f, 0.01058955f, -0.03147299f, 0.03866996f, -0.00984102f, 
    0.05121316f, -0.01030500f, 0.00634461f, 0.02274137f, 0.03477692f, 0.04842553f, 0.00584508f, 0.03333467f, 
    -0.05448437f, 0.00224915f, 0.04520085f, -0.00764028f, -0.05540828f, 0.00931199f, 0.04146501f, -0.05782023f, 
    -0.03281809f, 0.01652227f, 0.02462407f, 0.02340823f, -0.05305630f, -0.03076704f, 0.02148183f, 0.03567968f, 
    0.02341408f, -0.03058632f, -0.06203898f, -0.03399710f, -0.04627434f, -0.05125242f, 0.04305051f, -0.04474110f, 
    -0.00473449f, -0.05888006f, -0.04712080f, -0.04610751f, -0.04395963f, 0.03965139f, -0.00988075f, 0.05237630f, 
    -0.03820710f, 0.03517870f, 0.00278005f, 0.03973898f, -0.05891857f, -0.03513874f, -0.03565235f, -0.01867093f, 
    -0.00934752f, 0.05209122f, 0.00558924f, -0.00963848f, 0.03319856f, -0.00720202f, -0.05172337f, -0.05726811f, 
    -0.03069943f, -0.02617079f, 0.01244304f, -0.01265758f, -0.04020072f, 0.01351444f, 0.00019062f, -0.01724927f, 
    0.04319813f, -0.05311747f, -0.03541708f, -0.00320617f, -0.01575947f, 0.03393943f, -0.01116352f, -0.03323307f, 
    -0.05850563f, -0.00515218f, 0.04200194f, -0.02742403f, 0.00385321f, -0.03345525f, 0.01040286f, 0.05290389f, 
    -0.00471943f, 0.01826569f, -0.05889571f, -0.04114116f, 0.01206603f, -0.06003392f, 0.02415264f, -0.05629505f, 
    -0.03049049f, 0.02918989f, 0.02994898f, -0.03599766f, -0.06574915f, 0.03901774f, 0.01385792f, -0.01896004f, 
    0.03244511f, 0.00863880f, -0.00793350f, -0.01589704f, -0.00877550f, -0.03811594f, 0.01648722f, -0.05594593f, 
    0.04716405f, -0.04010769f, 0.03051443f, -0.00748042f, 0.03265306f, 0.03490310f, 0.05625222f, -0.01049782f, 
    0.05467430f, -0.04487966f, 0.01067458f, 0.04345749f, 0.00008882f, 0.00637833f, -0.05729316f, -0.02391471f, 
    -0.04162558f, 0.02406789f, -0.04421085f, -0.04704294f, -0.00370971f, -0.01481812f, -0.01955787f, -0.02360840f, 
    0.01232675f, 0.02872326f, 0.01488316f, 0.03022988f, -0.04646419f, -0.02337248f, -0.01892358f, -0.06023970f, 
    -0.02671677f, 0.01165260f, 0.01965672f, 0.00711967f, -0.04259255f, -0.02883838f, -0.00822987f, 0.05192173f, 
    0.05233015f, 0.03052654f, 0.02745115f, 0.01623995f, -0.03042870f, 0.00094777f, 0.01724857f, 0.01506075f, 
    -0.05090146f, 0.04251064f, -0.05214740f, -0.02665987f, 0.05748958f, 0.00599687f, -0.05890039f, -0.03279687f, 
    -0.02686151f, -0.01627163f, 0.03599313f, 0.02072514f, 0.03014920f, 0.00900078f, -0.05243489f, -0.05650837f, 
    0.03724115f, 0.04212682f, -0.05916993f, -0.02952954f, -0.03023589f, -0.04752851f, -0.00260557f, -0.04641467f, 
    -0.00434810f, -0.01418723f, 0.02854166f, 0.01570063f, -0.01643153f, 0.00822056f, -0.01913355f, 0.00781849f, 
    0.00944191f, -0.04436640f, -0.01542807f, -0.04379741f, -0.02613651f, -0.05881404f, 0.02054268f, 0.00978563f, 
    -0.01123096f, -0.04368917f, 0.04540975f, -0.04448902f, 0.03311460f, 0.02557823f, 0.03268759f, 0.02524627f, 
    0.05580108f, 0.02317788f, -0.02494857f, 0.03135835f, -0.05509670f, -0.04127720f, 0.03553951f, 0.03880093f, 
    0.05131466f, -0.04346605f, -0.01171090f, -0.05160492f, -0.05464762f, 0.01798069f, -0.01080349f, -0.02481635f, 
    -0.02398969f, 0.02789310f, 0.01125498f, -0.02832576f, -0.06333984f, -0.02668989f, -0.05971472f, -0.03226336f, 
    -0.06367563f, -0.01164988f, 0.00836238f, -0.05978551f, -0.04814563f, 0.03987391f, -0.06744899f, 0.04035505f, 
    -0.00153640f, 0.02425941f, -0.01572697f, -0.01826978f, -0.00541619f, -0.05060548f, -0.03974649f, -0.02941954f, 
    0.02572291f, -0.00699132f, -0.05768902f, -0.05599201f, 0.00770973f, -0.03418501f, -0.00597817f, -0.05603260f, 
    -0.04911351f, 0.02224221f, 0.01396519f, -0.03520642f, -0.02107038f, -0.04222323f, 0.01728613f, -0.00857143f, 
    0.01424203f, 0.02690944f, 0.01768948f, -0.04412070f, 0.00645160f, 0.00025579f, 0.00731862f, 0.00679584f, 
    -0.00156263f, 0.00200933f, -0.01075150f, 0.03246448f, 0.02636688f, -0.02350690f, 0.05204653f, 0.00028326f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.06319603f, 0.02080905f, -0.03563163f, 0.00277250f, 0.03228483f, 0.03781608f, 0.05374451f, 0.04044672f, 
    -0.03419296f, -0.12756404f, 0.09470470f, 0.11097579f, 0.01327953f, 0.01123589f, -0.02563323f, 0.02492514f, 
    0.15878281f, 0.02672334f, -0.06162413f, -0.02499410f, 0.07974815f, 0.02756609f, -0.08122206f, 0.15121350f, 
    -0.15544721f, 0.01318500f, 0.14630060f, -0.04822470f, -0.01921536f, 0.11829709f, -0.06657651f, 0.01784156f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.47958788f, 0.00503498f, -0.38619968f, 0.00755328f, -0.36348063f, 0.13635440f, 0.32987240f, -0.12505034f, 
    0.09891856f, -0.50553179f, -0.23622335f, 0.21376014f, -0.00987073f, 0.05538477f, 0.17977554f, 0.14839046f, 
    0.35352448f, -0.14383379f, -0.13085189f, -0.05084312f, 0.10031064f, 0.14550214f, -0.42808995f, 0.52410203f, 
    -0.43020424f, -0.01808500f, 0.07042734f, -0.03130178f, -0.16916320f, -0.33126971f, -0.60360795f, -0.00773372f, 
    -0.07267318f, -0.06260756f, -0.01376063f, -0.14317808f, 0.03087347f, -0.08286329f, 0.01988373f, 0.06636947f, 
    -0.08199310f, 0.12210902f, -0.09339105f, 0.00575564f, -0.15004544f, 0.11117338f, -0.16011758f, -0.12451530f, 
    0.15352568f, -0.14791241f, 0.12332884f, 0.07751149f, -0.17716210f, -0.00978171f, -0.01093474f, -0.09831353f, 
    -0.04957120f, -0.18811499f, 0.02536038f, 0.07811943f, -0.01577932f, -0.19481435f, -0.19411872f, 0.11238687f, 
    -0.47763652f, 0.15739168f, -0.14530477f, 0.10992698f, 0.22029236f, 0.02331193f, 0.01298814f, -0.14302231f, 
    -0.13399851f, -0.05028536f, -0.26315954f, -0.56514537f, 0.36124811f, 0.22592834f, -0.31436846f, 0.11405152f, 
    0.21526559f, 0.31337780f, 0.06278392f, -0.10261298f, 0.45430827f, -0.02025856f, 0.11109488f, -0.27240685f, 
    -0.68007821f, 0.19146658f, 0.51675230f, -0.09279311f, -0.02323492f, -0.05132794f, 0.34466398f, -0.09819983f, 
    0.02779560f, -0.01640707f, -0.12894219f, -0.10195215f, -0.00154500f, 0.04400490f, -0.19805616f, -0.18135111f, 
    -0.04173093f, -0.19213060f, -0.01741936f, -0.19620848f, -0.05709049f, 0.01544090f, -0.07307793f, 0.15524273f, 
    -0.02450355f, 0.10559324f, -0.05046158f, -0.00319390f, -0.12211116f, -0.15969980f, -0.06284247f, 0.00300672f, 
    -0.16225366f, 0.11401355f, -0.17701796f, -0.03641772f, 0.10756566f, -0.16640028f, 0.13737176f, 0.12377508f, 
    0.24766344f, 0.08043513f, 0.33128467f, -0.24692440f, 0.41739252f, 0.10647207f, -0.22380024f, 0.16566308f, 
    0.17219171f, -0.33723220f, 0.45844930f, 0.27989119f, -0.07331897f, 0.04272915f, 0.45873776f, 0.01766955f, 
    0.15258428f, 0.42144623f, -0.07140970f, 0.03589088f, -0.35580376f, -0.02981850f, -0.37590182f, -0.10438920f, 
    0.64690459f, -0.10591900f, -0.21364523f, -0.03427898f, 0.10504229f, -0.02579366f, 0.50011140f, -0.17069983f, 
    -0.01947001f, -0.08755658f, -0.06755716f, -0.13325070f, 0.10224929f, -0.03200754f, -0.10134874f, 0.12617598f, 
    -0.02665255f, -0.01358514f, -0.09752668f, -0.19266683f, -0.13699485f, 0.02797917f, 0.11373822f, -0.11148958f, 
    -0.09794148f, -0.11266264f, 0.10152255f, -0.10202032f, -0.00718603f, 0.00338365f, -0.09697148f, 0.04730947f, 
    -0.09636603f, 0.03473614f, 0.03377350f, -0.11363371f, 0.00949750f, -0.09645683f, -0.09361836f, 0.03607926f, 
    -0.21836370f, -0.02846264f, 0.07450853f, 0.19818923f, 0.52939218f, -0.14450136f, 0.24257581f, 0.01132908f, 
    -0.10545304f, -0.02081710f, 0.40596876f, 0.52145523f, 0.26442531f, -0.04801399f, -0.17768040f, 0.13710429f, 
    -0.33153954f, -0.28532282f, -0.00119197f, -0.11084504f, 0.20238449f, 0.07373625f, -0.11829887f, 0.42571849f, 
    -0.06980271f, -0.20239384f, -0.07254703f, -0.05742256f, -0.02655879f, 0.39989558f, -0.32511199f, -0.01719296f, 
    0.11190185f, 0.11436412f, -0.09167285f, -0.15681663f, -0.16558857f, 0.01610829f, -0.00924657f, -0.04764263f, 
    -0.03144914f, -0.08241384f, 0.12227659f, -0.07556327f, -0.07601199f, 0.10153384f, 0.06069698f, 0.04567435f, 
    -0.15867098f, -0.04239087f, -0.11677986f, 0.13296315f, -0.11127702f, 0.06264216f, -0.16563363f, -0.11777104f, 
    -0.02387887f, -0.17298315f, -0.00841121f, -0.13660592f, 0.12943102f, 0.14404160f, -0.06629814f, 0.16943286f, 
    -0.43889156f, -0.02729766f, -0.13638437f, -0.09641648f, 0.02533301f, -0.15485404f, -0.07778660f, -0.03946784f, 
    0.35883230f, 0.02136872f, 0.27998430f, -0.44810373f, -0.30602074f, -0.09045716f, 0.42633390f, 0.14335866f, 
    0.06488549f, 0.20453112f, -0.03784265f, -0.03256589f, 0.28525063f, -0.08445378f, 0.37693116f, -0.25968796f, 
    -0.02741316f, 0.43741030f, 0.16602871f, 0.09772144f, 0.10331036f, 0.43008012f, 0.04018472f, 0.05297147f, 
    -0.42118290f, -0.10166439f, -0.11875567f, -0.16247432f, -0.10909960f, -0.01031486f, -0.02278557f, -0.06103009f, 
    -0.35177898f, 0.49394795f, 0.13430364f, 0.25825086f, -0.06525043f, -0.04567299f, 0.24903390f, -0.05202093f, 
    0.29107237f, 0.13145451f, 0.13847442f, 0.01377206f, 0.29719004f, 0.11395115f, 0.04392508f, 0.00691348f, 
    0.30676073f, 0.48656905f, -0.08630636f, 0.05437309f, 0.08197833f, -0.09963179f, -0.44826484f, 0.09966372f, 
    -0.10710125f, -0.13264231f, 0.14004596f, -0.06846620f, -0.00814276f, -0.08453815f, -0.13466182f, 0.03331548f, 
    -0.13350378f, 0.14421993f, -0.10445247f, 0.11543241f, -0.04574538f, 0.04738116f, 0.06537520f, 0.05751100f, 
    -0.20276986f, 0.11244222f, -0.17125562f, 0.13556151f, -0.19391969f, 0.13822503f, -0.18000308f, -0.14782457f, 
    -0.06128826f, -0.19668052f, 0.13470268f, 0.11080590f, 0.01698599f, 0.00114870f, -0.09884951f, 0.09388647f, 
    0.33375081f, -0.12970074f, -0.28158516f, -0.11824732f, 0.28067026f, -0.05858557f, -0.02473079f, -0.00142956f, 
    -0.05108210f, -0.20131314f, 0.04670399f, -0.34613860f, -0.11113172f, 0.35078943f, -0.16961333f, 0.06500152f, 
    0.27140522f, 0.06519331f, 0.13957873f, -0.15417831f, 0.31823900f, -0.05798641f, -0.06581768f, -0.25897655f, 
    0.22768418f, 0.47130272f, 0.00398100f, -0.11715559f, 0.17249045f, -0.10915822f, 0.31048220f, 0.13688827f, 
    0.12210586f, -0.05928112f, 0.25048730f, -0.05854657f, 0.06081992f, -0.06166504f, 0.04409823f, -0.07086819f, 
    -0.04580298f, -0.16963507f, 0.05160314f, -0.55893463f, -0.28140113f, -0.33617872f, 0.09586049f, 0.04439673f, 
    0.03942765f, 0.27470469f, 0.15845610f, 0.14334735f, 0.34724608f, -0.00114019f, 0.28942543f, -0.40100464f, 
    -0.03793184f, 0.22412023f, 0.54560137f, -0.09943229f, 0.02483676f, 0.07536337f, 0.78377068f, -0.16992247f, 
    0.30038673f, 0.04636035f, 0.38234895f, 0.48909217f, -0.05861806f, 0.16565081f, 0.27867872f, 0.13203160f, 
    -0.46151647f, -0.21794267f, -0.31356457f, -0.15192942f, 0.31734279f, -0.06296748f, 0.58789343f, 0.01513546f, 
    -0.05831316f, -0.11643688f, -0.03072554f, 0.06338904f, 0.37367740f, 0.16811720f, -0.06026492f, 0.06366234f, 
    0.12586331f, 0.28297696f, -0.42232949f, -0.07783598f, 0.09387121f, -0.09654644f, -0.12178370f, -0.00250068f, 
    -0.19290219f, -0.16205962f, 0.40460169f, 0.34837371f, 0.37801737f, 0.11546225f, 0.05504828f, -0.14873959f, 
    0.67644727f, 0.34155527f, 0.10072020f, 0.27443185f, -0.14119999f, 0.28496209f, -0.39975765f, -0.11179347f, 
    -0.20706099f, -0.27314609f, -0.10705680f, 0.15731622f, -0.36600229f, -0.13942932f, -0.00431149f, -0.08225399f, 
    0.23530591f, 0.31977698f, -0.06126302f, -0.12659222f, -0.14728585f, 0.70253992f, -0.10105488f, 0.06864791f, 
    0.37879744f, -0.08420485f, -0.13217494f, -0.06749973f, -0.10447064f, -0.14524481f, 0.10610127f, 0.06924105f, 
    0.21055114f, 0.15294755f, -0.23149158f, 0.01503735f, 0.28145763f, 0.14957929f, -0.25211203f, -0.17047030f, 
    0.24111465f, -0.00602436f, 0.02436861f, 0.03879529f, -0.24827243f, 0.15744604f, 0.20861943f, -0.16374776f, 
    0.47297278f, 0.23722950f, 0.24035476f, -0.16981260f, 0.10004286f, -0.30103275f, -0.14894696f, -0.17332138f, 
    -0.01497342f, 0.08467779f, -0.35779250f, 0.36564520f, 0.05338340f, -0.01412283f, 0.29612660f, 0.00934246f, 
    -0.17036147f, -0.05461362f, 0.01151916f, -0.07915792f, 0.25042316f, 0.35092455f, -0.03243207f, -0.00930771f, 
    -0.22167832f, -0.30105475f, -0.14924896f, 0.04626989f, 0.24501823f, -0.11790498f, 0.48371753f, 0.35280421f, 
    -0.07418434f, -0.02547090f, -0.32118958f, 0.13377570f, -0.12742634f, -0.48043841f, -0.02299431f, -0.13024691f, 
    -0.02401786f, -0.01153814f, 0.11067315f, 0.20255463f, 0.27848193f, -0.08807347f, 0.28499052f, 0.00722012f, 
    -0.19129431f, -0.39350018f, 0.10366122f, -0.19442716f, -0.06328768f, 0.05905656f, 0.07144801f, 0.07992308f, 
    -0.25849622f, 0.19370469f, -0.07253663f, -0.12271403f, 0.57497656f, -0.12964414f, -0.10733500f, 0.46715215f, 
    -0.32218459f, 0.14650734f, -0.30238888f, -0.02038524f, -0.05799109f, 0.35447684f, 0.06692163f, 0.01623806f, 
    -0.18562528f, -0.02746488f, 0.25031093f, 0.17046624f, -0.29122052f, -0.15973854f, 0.37472761f, 0.04745860f, 
    -0.53507930f, -0.16303901f, 0.01797549f, 0.23434436f, 0.27170497f, -0.39715138f, 0.55581599f, -0.12123165f, 
    0.04885116f, 0.06350406f, 0.12248476f, -0.08293392f, 0.04981626f, -0.07553394f, -0.24399716f, 0.47442704f, 
    -0.20361324f, -0.25088155f, -0.11159693f, 0.14756723f, 0.11736600f, 0.23328936f, 0.21533097f, -0.12444188f, 
    -0.17683940f, -0.17348680f, 0.16493222f, -0.17628452f, 0.45279342f, -0.08042628f, -0.09327517f, -0.02163737f, 
    -0.25682440f, -0.21799925f, 0.16849634f, -0.13757381f, 0.12583089f, -0.20228393f, 0.17943828f, 0.12195258f, 
    0.13922870f, 0.02417632f, -0.15689328f, -0.07929914f, 0.09367479f, -0.05029400f, -0.18043098f, 0.00760916f, 
    -0.02347853f, 0.09490653f, -0.24019735f, 0.16497754f, -0.03034984f, 0.42382568f, 0.30754998f, 0.08018929f, 
    -0.09520851f, -0.04455195f, 0.21772273f, -0.31696117f, -0.45802200f, 0.05146790f, 0.05529919f, 0.10411177f, 
    0.19846533f, 0.03840229f, -0.09526870f, -0.37846971f, -0.08350986f, -0.17655849f, 0.08187408f, -0.09810743f, 
    0.38986370f, 0.18079168f, 0.11607608f, -0.04221284f, 0.10755530f, -0.11236411f, 0.14953847f, -0.24156895f, 
    -0.13084862f, 0.32379118f, 0.58817220f, 0.05065457f, -0.00785299f, 0.33367398f, 0.25319192f, -0.13258527f, 
    0.28238836f, -0.12263481f, 0.23517516f, -0.22621818f, -0.58386749f, -0.15866973f, 0.14567198f, 0.10736243f, 
    0.44272947f, 0.31429073f, -0.20285043f, -0.17872666f, 0.07898373f, -0.16266030f, 0.32820830f, 0.14791234f, 
    0.22822529f, -0.06760740f, -0.12909548f, 0.14705461f, -0.21887884f, 0.10117182f, -0.00969711f, -0.32879952f, 
    0.40588698f, -0.02143233f, 0.15806372f, -0.06000984f, -0.17830339f, 0.17611635f, -0.38602281f, -0.14830628f, 
    -0.24459761f, 0.02039986f, 0.27905175f, -0.07336538f, -0.18467082f, 0.04841946f, -0.22283904f, -0.13029407f, 
    -0.20932774f, 0.05958722f, 0.20371501f, 0.07026555f, 0.18582834f, 0.19303775f, 0.55090606f, 0.13256907f, 
    0.47442687f, 0.38274723f, -0.08068284f, 0.07162737f, -0.03806734f, -0.13213800f, -0.03307398f, -0.25958762f, 
    0.29925257f, 0.35544392f, 0.16046862f, -0.09323885f, 0.00520529f, -0.14269923f, -0.38646513f, -0.15946791f, 
    0.02459898f, 0.14373562f, 0.37470663f, 0.05179192f, 0.42491144f, -0.03104286f, 0.04976526f, -0.11739010f, 
    0.34397501f, 0.58727962f, 0.14468946f, 0.50156862f, -0.17867443f, 0.02674131f, -0.25258905f, -0.15029190f, 
    -0.28400546f, -0.06725364f, -0.01383762f, 0.14866632f, -0.38151070f, 0.08493066f, -0.01024195f, 0.01929084f, 
    0.50458246f, -0.04409772f, 0.10778305f, 0.09816871f, 0.04911237f, 0.46252438f, -0.24404591f, 0.01168305f, 
    0.11759974f, 0.00986715f, -0.08856653f, -0.03822756f, 0.10860103f, -0.15228026f, -0.04170388f, 0.14937522f, 
    -0.04835569f, 0.05457110f, -0.17105153f, -0.15504517f, -0.05532880f, 0.03958931f, 0.09283315f, 0.16466002f, 
    -0.04535495f, 0.04657128f, 0.07799174f, 0.09076328f, -0.01424076f, -0.01396734f, -0.00759607f, -0.15177089f, 
    0.06530351f, -0.17582707f, -0.00224674f, 0.08388615f, 0.08645345f, 0.04226347f, -0.09145311f, -0.17627394f, 
    0.40891111f, -0.04028665f, -0.09670103f, 0.10992423f, -0.25634685f, 0.04829939f, -0.13440289f, -0.14791676f, 
    0.02306689f, -0.64660347f, 0.33474317f, -0.12235284f, 0.06487458f, -0.13958420f, 0.19071703f, 0.02390109f, 
    0.28742275f, 0.35170466f, -0.16513492f, 0.09825819f, 0.30686179f, -0.12495837f, 0.11196178f, -0.08309968f, 
    -0.29514557f, -0.07469560f, 0.34609836f, -0.08806268f, -0.05975663f, -0.40247890f, 0.24926355f, 0.04044252f, 
    -0.03568449f, -0.12498134f, -0.14474243f, 0.09377389f, -0.12994461f, -0.09422507f, -0.15519337f, -0.01169460f, 
    -0.10399026f, -0.12982389f, 0.07890211f, 0.05296047f, -0.19487414f, -0.13504140f, -0.18896233f, -0.02690115f, 
    0.13854125f, 0.00717411f, 0.05853535f, -0.14974828f, -0.01041235f, 0.02074987f, -0.16324443f, 0.02007796f, 
    -0.16029032f, -0.14641181f, -0.05888051f, -0.01628416f, 0.04482810f, 0.04955273f, 0.09937470f, 0.15704218f, 
    0.39291835f, 0.05503711f, 0.00805320f, 0.37735450f, -0.38446221f, -0.12331396f, 0.18834323f, -0.17931287f, 
    -0.12690990f, -0.24424273f, -0.11744605f, -0.22347154f, 0.30866838f, 0.36377978f, -0.35096699f, -0.12560305f, 
    0.17317931f, 0.24746089f, -0.06359336f, -0.07465877f, 0.05997287f, -0.07408383f, 0.32142797f, -0.29235756f, 
    -0.42728716f, -0.08769814f, 0.11630742f, -0.16283894f, -0.11703257f, -0.47309002f, 0.00030742f, 0.10733882f, 
    0.32358563f, 0.03177840f, -0.08907061f, 0.30967894f, 0.30118906f, -0.14853331f, -0.29963490f, -0.11308504f, 
    0.23593000f, 0.05433294f, 0.31004634f, 0.10732573f, 0.17032214f, 0.53028101f, 0.30855146f, -0.03636290f, 
    -0.02987270f, -0.13284256f, -0.07219332f, 0.14580645f, -0.18687108f, -0.11250992f, 0.15223578f, -0.00586287f, 
    0.73475438f, 0.29017213f, -0.41399866f, 0.05342730f, -0.03260259f, -0.51537293f, 0.03513166f, 0.01573443f, 
    0.14200841f, 0.12274822f, -0.53784806f, -0.04372198f, 0.20108983f, -0.03467463f, 0.05074418f, 0.09435210f, 
    0.48136869f, -0.33265132f, 0.46681023f, -0.33765140f, -0.33553627f, 0.28144053f, -0.26291829f, 0.07078867f, 
    0.21180514f, -0.00446053f, 0.12043214f, 0.05968705f, 0.33678591f, 0.16672546f, 0.30092391f, -0.08805794f, 
    -0.43932793f, -0.02910020f, 0.37666291f, 0.05103093f, -0.18302101f, -0.07409511f, -0.15957887f, -0.06899358f, 
    0.30207029f, -0.04245356f, 0.00002743f, 0.05840014f, 0.02318319f, 0.16753039f, 0.32398751f, -0.08237264f, 
    0.15026857f, -0.21971644f, 0.08375631f, 0.10959034f, 0.03586194f, -0.45992902f, -0.58672988f, -0.13619433f, 
    -0.16292122f, 0.00810198f, -0.08451276f, 0.03441048f, 0.28749433f, 0.06155040f, -0.43821377f, 0.01349787f, 
    0.04221612f, 0.08643343f, 0.43037164f, 0.17666793f, -0.02265523f, 0.32216442f, -0.31653437f, -0.08960613f, 
    -0.12705012f, 0.14129810f, 0.19193733f, -0.27044261f, -0.32539654f, 0.05121513f, 0.13244115f, 0.01157280f, 
    -0.60333693f, 0.29661539f, -0.14556977f, 0.43666157f, 0.37276632f, 0.16029322f, 0.34845412f, -0.15966853f, 
    0.28761542f, 0.37246293f, 0.02466287f, -0.14378124f, -0.30189487f, 0.02793263f, 0.01791447f, 0.25739616f, 
    0.15352488f, 0.13353787f, 0.01737846f, -0.00756053f, -0.05510549f, -0.31782714f, -0.21305311f, 0.10720326f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.23205234f, 0.05477282f, -0.04316914f, 0.03016709f, 0.15375088f, -0.16989172f, 0.35737941f, -0.08668622f, 
    0.07319059f, -0.15924887f, -0.10617475f, -0.14626519f, -0.05164355f, -0.19051702f, -0.08521284f, 0.07483467f, 
    0.07317317f, 0.19177140f, 0.20217328f, 0.20241122f, 0.10318930f, -0.09340485f, 0.31320667f, -0.12218713f, 
    -0.10236233f, 0.33544287f, -0.07118482f, 0.13681328f, -0.11774796f, 0.16833577f, 0.17311913f, 0.02816605f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.18170001f, 0.04503854f, -0.38080934f, 0.04169216f, 0.42194149f, -0.04402274f, 0.23429418f, 0.00137221f, 
    -0.66219723f, 0.21020578f, -0.08987129f, -0.12388141f, -0.52631742f, -0.38725224f, 0.26619118f, 0.12810551f, 
    -0.12849241f, -0.16331929f, -0.12133856f, -0.41974130f, -0.65983552f, -0.41784155f, 0.14208803f, 0.43828768f, 
    -0.02643831f, -0.40091354f, -0.03804727f, -0.39443648f, 0.39114723f, -0.13909684f, -0.00061405f, 0.29302371f, 
    -0.48008072f, -0.01991839f, -0.67216182f, -0.08564964f, 0.32152733f, -0.13530788f, 0.31614846f, -0.11725129f, 
    0.34435555f, -0.24949932f, -0.15294568f, -0.20113170f, -0.14276415f, -0.11398362f, 0.23763542f, -0.53529936f, 
    -0.06186767f, 0.28577954f, -0.02373796f, 0.20163868f, -0.35183138f, -0.30254939f, -0.18206759f, 0.13507777f, 
    0.08196110f, 0.10071253f, -0.08667986f, -0.50276047f, 0.26560372f, 0.29290941f, -0.02053853f, -0.49189836f, 
    -0.71904707f, -0.04249483f, 0.14116058f, -0.11228611f, 0.46855912f, 0.04212286f, -0.18564594f, -0.10739192f, 
    0.12786719f, -0.23135260f, -0.16975826f, -0.00247322f, 0.48196098f, -0.03131948f, -0.15451467f, -0.52073318f, 
    -0.72748554f, 0.24602970f, 0.37241182f, 0.46482417f, 0.40474555f, -0.17521527f, -0.19905427f, -0.04919231f, 
    -0.11813526f, -0.00439453f, -0.09694557f, -0.35345730f, -0.68307167f, -0.62190574f, -0.07270409f, 0.08971653f, 
    -0.06661116f, 0.06195137f, 0.39429611f, -0.08503588f, -0.25854135f, -0.15854405f, -0.51106936f, -0.10748059f, 
    0.20513766f, -0.16429143f, -0.00081416f, 0.19769385f, -0.05610033f, -0.73966849f, 0.12170261f, 0.18466869f, 
    0.34977204f, -0.23439933f, -0.81498164f, -0.93590850f, 0.07548404f, -0.23288760f, 0.02692190f, -0.22449723f, 
    -0.13758568f, 0.26777577f, -0.02125281f, 0.46420982f, 0.22639371f, 0.53010690f, -0.67960215f, -0.07751924f, 
    0.20619829f, -0.01899265f, -0.40629980f, -0.03070454f, 0.42062029f, 0.11749066f, -0.28949583f, 0.16891542f, 
    -0.48789558f, -0.67628628f, -0.07672953f, 0.12816377f, 0.05529961f, 0.21894658f, -0.09121271f, 0.06932931f, 
    -0.28839210f, -0.09546919f, -0.15457910f, -0.68560356f, -0.03509079f, 0.32802135f, 0.07026061f, -0.23539913f, 
    0.15656771f, 0.57204866f, -0.14065841f, 0.38139719f, 0.21067715f, 0.01983218f, 0.16751254f, -0.13602993f, 
    0.53308517f, -0.08611523f, -0.53985018f, -0.07775456f, -0.43957004f, 0.01862589f, 0.14095522f, -0.13798249f, 
    -0.22388464f, -0.22825010f, -0.06046215f, -0.29337245f, -0.43826598f, 0.15937367f, 0.41437188f, -0.02852626f, 
    -0.00700082f, 0.24534370f, 0.05972552f, -0.24405260f, -0.11169495f, 0.11869459f, -0.57687867f, 0.27228051f, 
    -0.16195902f, -0.65922517f, -0.03973255f, -0.13173518f, -0.25148770f, -0.17794760f, 0.35546389f, -0.11116760f, 
    0.44320142f, -0.18432082f, 0.01915658f, -0.01547765f, -0.53748959f, 0.00721025f, -0.00839163f, -0.15251800f, 
    -0.40418625f, -0.22998719f, -0.15344197f, 0.22705102f, 0.13347009f, 0.21883166f, -0.63385344f, 0.07561292f, 
    0.36865932f, 0.16988608f, 0.16110137f, -0.60472965f, -0.18990064f, -0.36618042f, -0.84124780f, -0.42816821f, 
    -0.04805062f, 0.33368310f, 0.00375535f, 0.14779206f, -0.34149215f, 0.24564441f, 0.37952247f, -0.14569199f, 
    -0.31730822f, 0.10865378f, -0.29522359f, 0.03320619f, -0.00310595f, 0.07263286f, -0.62057644f, 0.08492683f, 
    0.27238101f, 0.32815042f, -0.13096607f, -0.14830680f, 0.04244248f, 0.15912367f, 0.18261011f, 0.20586948f, 
    -0.24029277f, -0.51241642f, -0.20974040f, -0.04913503f, 0.15725777f, 0.66559595f, 0.24362360f, 0.07338347f, 
    0.04656853f, -0.59633499f, -0.01133329f, -0.39949140f, 0.27345988f, -0.25937495f, -0.66443908f, -0.02741016f, 
    -0.61036581f, -0.05919443f, 0.55334365f, -0.01090438f, -0.60807508f, 0.15336414f, 0.17169823f, -0.13182670f, 
    -0.66898936f, -0.34157011f, -0.05995237f, -0.91058910f, -0.08780232f, 0.61021876f, 0.14267224f, -0.15028940f, 
    0.42086217f, 0.14576831f, 0.21817447f, -0.22760811f, -0.54115736f, -0.58232903f, -0.14732683f, 0.00686707f, 
    0.06698444f, -0.45900443f, -0.01361180f, 0.38114652f, 0.09879086f, -0.63930225f, -0.22089651f, 0.08921187f, 
    0.39661366f, -0.03471620f, -0.31788161f, 0.05100182f, -0.03992928f, 0.10004775f, 0.09291777f, -0.02958702f, 
    0.00969024f, 0.38190061f, 0.04303150f, -0.93072748f, -0.63221335f, 0.23173216f, -0.45949274f, -0.20093539f, 
    0.00323002f, 0.10930421f, 0.44514340f, -0.06514234f, -0.00654303f, 0.16765872f, 0.42372218f, -0.28575060f, 
    -0.05841551f, 0.21060340f, -0.06743017f, -0.11309897f, -0.21293874f, -0.30871069f, -0.15791611f, 0.45522055f, 
    -0.35973036f, -0.12573804f, 0.47675270f, -0.16541456f, -0.50305814f, 0.12294355f, 0.03608835f, 0.04352286f, 
    0.33255622f, 0.01967212f, 0.08133628f, -0.26726222f, 0.36371088f, -0.87178248f, 0.17302674f, -0.11987064f, 
    -0.59404379f, -0.17107864f, -0.29811269f, -0.18950529f, 0.48978519f, 0.11671448f, 0.16452193f, 0.08866262f, 
    -0.00722837f, 0.14480276f, -0.13300276f, -0.10005161f, -0.66321963f, 0.24876092f, 0.38513491f, -0.26272804f, 
    -0.13155633f, -0.04801013f, 0.40122664f, -0.16198339f, -0.26450518f, 0.13758202f, -0.22648378f, 0.03203049f, 
    0.45050892f, 0.61188227f, 0.11278178f, 0.60817844f, 0.13969564f, 0.28249806f, -0.18462725f, -0.27128783f, 
    -0.09157579f, 0.21467879f, -0.25508904f, -0.03715679f, -0.00013962f, -0.68631768f, 0.37824827f, -0.49394190f, 
    0.12073754f, 0.13699861f, 0.14474609f, -0.12105250f, 0.08681093f, 0.03556915f, -0.18619198f, -0.14494814f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.20891745f, -0.07428097f, -0.23672345f, -0.15125553f, 0.11958658f, 0.14897533f, -0.05684708f, -0.22357777f, 
    -0.29272497f, 0.03274282f, -0.06015447f, -0.11557481f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
