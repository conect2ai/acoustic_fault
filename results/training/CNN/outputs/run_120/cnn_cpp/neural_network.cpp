#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.36553347f, 0.60300004f, -0.87557137f, 0.28986385f, 0.15125425f, -0.24592921f, 0.58861244f, -0.06766888f, 
    0.35004526f, 0.42058870f, -0.61405510f, -0.23715256f, 0.38202536f, -0.96914482f, 0.29815403f, -0.28498083f, 
    -0.12885547f, 0.34454998f, 0.73335928f, 0.58663422f, 0.29752657f, -0.23407482f, -0.09037950f, -0.43924215f, 
    0.20790404f, 0.18719104f, -0.31697395f, 0.75758678f, 0.19963714f, -0.01407813f, 0.61483079f, 0.45899606f, 
    0.12693310f, -0.24071082f, -0.21359998f, -0.42298725f, 0.15504391f, -0.42686006f, -0.23672600f, -0.71894181f, 
    -0.21383761f, -0.38000587f, -0.40120974f, -0.48048842f, 0.07427034f, -0.66522539f, -0.19609049f, 0.09389114f, 
    -0.72989219f, -0.40334266f, -0.05325909f, -0.17263275f, 0.16866235f, -0.24225247f, 0.42382312f, 0.52262503f, 
    0.16353159f, -0.68727678f, -0.35088143f, -0.44691184f, 0.33182490f, 0.02779411f, 0.49182400f, -0.05453927f, 
    -0.29220593f, -0.69093454f, -0.62186432f, 0.32225999f, 0.73871255f, 0.04342724f, -0.01868195f, 0.17715260f, 
    0.61926281f, 0.55212057f, 0.43594733f, 0.44869769f, 0.01820645f, 0.24620824f, -0.01635986f, 0.41033894f, 
    0.25823370f, 0.36668268f, -0.23487668f, 0.81594861f, 0.50348449f, -0.14318202f, -0.02018420f, -0.05324359f, 
    -0.24795096f, -0.04880920f, -0.66690183f, -0.41587448f, -0.10305057f, 0.61060035f, -0.17501701f, 0.02233437f, 
    -0.36067927f, -0.48484638f, -0.47890782f, -0.10970736f, 0.37660882f, -0.34522539f, -0.06674342f, -0.59237880f, 
    -0.64405537f, -0.37257987f, 0.33379492f, 0.21429086f, 0.00805801f, -0.79107809f, -0.67692518f, -0.05337126f, 
    -0.06178380f, -0.62159187f, -0.08258165f, 0.16811024f, 0.09801853f, -0.24947298f, -0.43253151f, 0.16680138f, 
    -0.69879901f, 0.64099449f, -0.41516426f, 0.30342236f, 0.41769692f, -0.14543059f, -0.76418048f, -0.38038409f, 
    -0.63078088f, 0.33016679f, 0.85806525f, 0.26207343f, 0.05901083f, -0.18459752f, 0.09848128f, -0.65237063f, 
    0.71519089f, -0.18895686f, 0.05856706f, -0.14724964f, -0.31581423f, 0.34112513f, 0.20986262f, -0.41327512f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.45036766f, -0.19393514f, 0.15570687f, 0.07573827f, -0.36571044f, 0.08179431f, -0.12102845f, -0.36429831f, 
    0.04294448f, -0.05096249f, -0.14315186f, -0.11638483f, 0.13505845f, 0.04475808f, 0.33465475f, 0.01204961f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.00637746f, -0.02313109f, -0.08777442f, 0.02727863f, 0.05372659f, -0.03969897f, -0.01529870f, 0.01353341f, 
    -0.07706542f, 0.06906661f, 0.04917697f, -0.03404327f, -0.03434858f, -0.02044627f, -0.09231367f, -0.02040925f, 
    -0.03481881f, -0.03302306f, 0.04996186f, 0.05814556f, 0.00929601f, 0.00137835f, -0.03354959f, -0.05141118f, 
    -0.02425722f, -0.06462534f, 0.05373416f, 0.00081542f, -0.05688763f, -0.07854860f, -0.03511251f, -0.02933137f, 
    -0.01493716f, 0.05322436f, -0.03958038f, -0.07935849f, -0.01618183f, -0.01770026f, 0.03531324f, 0.00246187f, 
    -0.00571797f, -0.01716750f, -0.04246099f, 0.02516443f, -0.02748035f, -0.06444170f, -0.05190947f, -0.02000412f, 
    -0.08168710f, 0.06484255f, -0.08491639f, -0.05424046f, 0.02141634f, -0.05345542f, -0.03723994f, -0.05001721f, 
    0.02444642f, 0.05360563f, 0.04387088f, 0.03604424f, -0.08091921f, 0.05676207f, -0.04596787f, 0.03776646f, 
    0.07547224f, -0.05877699f, 0.05315987f, 0.00474577f, 0.04896469f, -0.07859420f, -0.06382325f, 0.03284207f, 
    0.00610339f, -0.06124515f, -0.08089670f, -0.02424308f, 0.00616130f, -0.05446430f, -0.01220954f, -0.00394709f, 
    -0.07999574f, -0.08292991f, 0.01586173f, 0.01554535f, 0.03774106f, 0.06332497f, 0.01194239f, -0.01128314f, 
    -0.00437019f, -0.08248310f, -0.03143666f, -0.06339196f, 0.03550977f, -0.02546727f, 0.00236009f, 0.00393378f, 
    0.01817206f, -0.03723776f, 0.04803535f, 0.01633524f, -0.00679923f, -0.05938083f, 0.04651541f, -0.02540413f, 
    -0.07187082f, -0.03837794f, 0.01630264f, 0.02882084f, -0.07971073f, 0.05343502f, -0.08140860f, -0.03882201f, 
    0.05939136f, -0.00287813f, 0.02745968f, -0.08351879f, 0.07337861f, 0.01992024f, -0.07848436f, -0.06328887f, 
    -0.07011715f, -0.02477602f, 0.01157573f, -0.02697214f, 0.02757478f, 0.06865941f, -0.01812503f, -0.03342620f, 
    0.01401293f, -0.06483217f, 0.02554066f, 0.05249048f, -0.04828320f, 0.03251806f, -0.06340425f, -0.07417541f, 
    -0.00747574f, 0.07013970f, -0.06801054f, 0.05454155f, 0.02576389f, 0.05080739f, 0.02140275f, -0.07540044f, 
    -0.14213760f, 0.19396214f, -0.10611027f, 0.08650856f, -0.09433798f, -0.13876630f, -0.16747241f, 0.20001976f, 
    -0.01822832f, 0.09068694f, -0.31503966f, -0.12402903f, 0.04170044f, 0.18533961f, 0.10430568f, -0.01908606f, 
    -0.11745044f, 0.07316586f, -0.38831913f, -0.26335278f, -0.03054562f, -0.02587791f, -0.10449214f, 0.10639508f, 
    0.14723544f, -0.10008331f, 0.02781764f, -0.16637407f, 0.17541572f, -0.03371460f, 0.14382106f, 0.10178456f, 
    -0.20367017f, 0.30047789f, -0.03128443f, 0.11847332f, 0.02488670f, 0.05986692f, 0.18851896f, -0.06242414f, 
    -0.06021651f, -0.01092748f, -0.03079209f, 0.11973859f, -0.16135761f, -0.00818817f, 0.05189708f, 0.26053971f, 
    -0.01581375f, -0.10885164f, -0.05917737f, -0.09082254f, 0.08610783f, -0.17286836f, -0.17557546f, -0.19257098f, 
    0.09117676f, -0.13341329f, -0.13750570f, 0.16859494f, -0.11502139f, 0.13047095f, 0.05040754f, -0.15942623f, 
    0.17307724f, -0.21304913f, 0.01853383f, -0.00411031f, -0.06020426f, 0.09456579f, 0.05545276f, -0.02618934f, 
    -0.28036803f, 0.22539085f, 0.23075056f, 0.06146314f, -0.12096246f, 0.02154846f, 0.06003663f, 0.09032512f, 
    0.09129806f, -0.17946509f, -0.08014213f, -0.00503224f, 0.15647979f, -0.10235731f, 0.02189839f, -0.00017599f, 
    0.11759365f, -0.09494826f, 0.32043415f, -0.06194871f, -0.02847155f, 0.10930433f, -0.05641270f, -0.04819180f, 
    -0.01877086f, 0.01210143f, -0.06220876f, 0.19937728f, -0.02999226f, 0.08169995f, -0.07291760f, -0.07110748f, 
    -0.06821287f, 0.03791552f, 0.02760748f, 0.09668052f, 0.09100943f, 0.03586635f, -0.05907088f, -0.01421916f, 
    -0.16929221f, -0.02005180f, 0.10715506f, 0.01116291f, -0.04760457f, -0.26657599f, 0.22664700f, 0.25201130f, 
    0.13218938f, 0.03686585f, 0.00580967f, 0.18108635f, -0.14276437f, -0.05137218f, 0.06443405f, 0.06858741f, 
    0.01437022f, 0.06951644f, -0.03607379f, 0.07422309f, 0.01005145f, -0.01581464f, -0.03870459f, 0.22261018f, 
    -0.12623705f, -0.04676006f, -0.21808058f, 0.00780352f, -0.00109450f, -0.04583652f, 0.09837843f, 0.03810187f, 
    -0.20788790f, -0.21419805f, 0.00910219f, -0.24906433f, -0.17693247f, -0.19503444f, 0.12253387f, -0.09604305f, 
    0.12271821f, -0.07156072f, 0.00473627f, 0.09688006f, -0.06002679f, -0.07049845f, 0.05137049f, 0.07892903f, 
    0.06004841f, -0.01650207f, -0.24545220f, 0.11949657f, 0.07371428f, 0.20863649f, 0.11890858f, 0.02888052f, 
    0.03571923f, 0.03898083f, 0.11323309f, -0.21191858f, -0.26144928f, -0.17547648f, 0.11435941f, 0.05235529f, 
    0.11797224f, -0.11189894f, 0.05521028f, -0.22132879f, -0.17675892f, -0.09500096f, 0.05791651f, 0.08272850f, 
    0.03985196f, 0.14601454f, 0.00693377f, -0.14211838f, -0.02249457f, 0.21282420f, 0.16113789f, -0.12822789f, 
    0.01141112f, -0.03728634f, -0.00929297f, 0.03911272f, -0.04519862f, 0.12312238f, 0.10822657f, 0.14239267f, 
    0.05187137f, 0.10697360f, -0.07725886f, 0.00846134f, 0.01833572f, -0.02684641f, 0.09486402f, -0.18904938f, 
    -0.25748783f, -0.06113655f, 0.04509278f, 0.11529358f, -0.14004970f, -0.11952140f, 0.09747978f, -0.18296844f, 
    -0.79415184f, -0.46705848f, -0.17506133f, 0.10341175f, 0.10007451f, -0.03524131f, -0.01743199f, -0.03997685f, 
    0.06993701f, -0.82237613f, -0.24818838f, 0.05179503f, -0.01292842f, 0.13053678f, 0.23691668f, -0.13959353f, 
    -0.26047704f, 0.19958325f, -0.03648708f, 0.00678024f, -0.13320342f, -0.09775737f, 0.09097399f, 0.15505196f, 
    -0.04828332f, -0.21259005f, -0.11914158f, 0.28367487f, -0.18947889f, 0.01867047f, 0.04830712f, 0.02740146f, 
    -0.20289899f, -0.07200258f, 0.15451799f, -0.03634689f, -0.17241772f, -0.09429080f, 0.06057353f, -0.12229951f, 
    -0.06110427f, -0.10530043f, 0.08813146f, -0.01394007f, 0.20392130f, 0.16487157f, 0.01715855f, 0.05091836f, 
    -0.19191568f, -0.06400930f, 0.02826578f, -0.00152036f, 0.08408649f, -0.00385550f, 0.43540180f, 0.15705675f, 
    0.06068055f, 0.06778618f, -0.02336615f, 0.08101053f, 0.15664250f, 0.23064198f, -0.10552551f, 0.17846152f, 
    0.04606511f, 0.00638855f, 0.07691733f, -0.01375416f, 0.12949423f, 0.24964680f, 0.16654639f, 0.05397042f, 
    0.12400009f, -0.01037615f, 0.05008657f, -0.00712627f, -0.23756826f, -0.17028473f, -0.00669576f, 0.04251964f, 
    0.03406182f, 0.38021761f, -0.05752953f, -0.20688364f, -0.06968087f, -0.02809408f, -0.04361921f, -0.02532802f, 
    0.05033919f, -0.07565974f, -0.13037889f, -0.33263156f, -0.12166581f, 0.11172767f, 0.03407202f, 0.03966070f, 
    -0.24084380f, 0.02398659f, -0.26557985f, -0.09266181f, -0.11507450f, -0.12100200f, -0.04757496f, 0.04325455f, 
    -0.11197019f, -0.01542251f, -0.12073244f, -0.12464431f, 0.04060614f, 0.28281048f, -0.19615169f, 0.05587901f, 
    0.31239569f, 0.03501511f, 0.07264937f, -0.13937147f, -0.22815281f, -0.21126813f, 0.21502727f, 0.19550394f, 
    0.05939421f, -0.05431426f, 0.01629733f, 0.00151486f, -0.11458404f, -0.13993596f, 0.18129639f, -0.16938528f, 
    0.03363647f, 0.27876037f, 0.08425807f, 0.00903211f, -0.06687064f, -0.10308255f, 0.11969859f, 0.04796266f, 
    -0.03749134f, 0.09692063f, 0.00503852f, -0.06525768f, -0.04474225f, 0.17201608f, 0.05190445f, -0.16973816f, 
    -0.35533512f, -0.42685574f, -0.04289229f, -0.09382859f, -0.04743492f, 0.14791220f, -0.00548224f, 0.03634523f, 
    -0.04281574f, -0.28804019f, -0.42426375f, -0.09543043f, 0.14214256f, -0.04230002f, 0.07440923f, 0.00005498f, 
    0.01838983f, 0.05969578f, 0.09196788f, -0.18054576f, -0.03045426f, 0.05335995f, -0.07572642f, 0.01525827f, 
    -0.06329476f, -0.07626241f, -0.00270716f, 0.36436072f, -0.05866865f, 0.14177042f, 0.03526138f, 0.04775545f, 
    0.12953457f, 0.07751313f, 0.10662744f, 0.04547879f, 0.06646184f, -0.12828611f, -0.03410478f, -0.03799355f, 
    -0.03385418f, 0.09805564f, -0.13114902f, 0.16087291f, 0.05279586f, 0.03697514f, 0.26099116f, 0.19768317f, 
    -0.06182551f, -0.09749745f, 0.11090183f, -0.10273745f, -0.07047752f, -0.13466151f, -0.01956589f, 0.10931557f, 
    0.02678643f, 0.07590666f, -0.02076951f, 0.06995950f, 0.02636042f, -0.01210928f, 0.04011628f, 0.42835376f, 
    0.12064768f, 0.07113685f, 0.14094883f, 0.17758383f, 0.00070713f, -0.07218879f, -0.02529774f, -0.22429502f, 
    0.17520796f, -0.45269039f, -0.22127219f, 0.08730146f, 0.00915433f, 0.00606826f, 0.06053888f, 0.21502413f, 
    -0.02108963f, 0.01826163f, 0.18243936f, 0.17452019f, 0.16595963f, 0.03733017f, 0.23292699f, -0.04438328f, 
    0.09056401f, -0.00563328f, 0.14797381f, -0.02050000f, 0.04547526f, -0.03089386f, -0.12641580f, 0.11782675f, 
    0.02514777f, -0.25660554f, 0.18332596f, 0.03433067f, 0.00658684f, 0.11715268f, -0.01920919f, 0.02067850f, 
    -0.13702644f, 0.02075742f, 0.14207916f, 0.11440358f, 0.12727754f, -0.07785697f, 0.02449651f, 0.15032154f, 
    0.07000794f, 0.09627050f, -0.11554030f, -0.18459497f, -0.01023193f, 0.24519370f, -0.03533436f, -0.22823882f, 
    0.18799318f, 0.03778098f, 0.27907819f, -0.10608218f, 0.17080902f, -0.27326295f, 0.23531580f, -0.28520203f, 
    -0.16998045f, 0.01454997f, -0.14230062f, 0.27370965f, -0.09626795f, 0.14643317f, -0.03573854f, 0.23231959f, 
    0.10359125f, 0.23837522f, 0.13430949f, -0.10095724f, -0.05042058f, -0.01892494f, -0.06596630f, 0.11048985f, 
    0.35080430f, -0.09461541f, 0.12126876f, 0.14784893f, -0.00036302f, -0.18996665f, 0.01292815f, 0.00573472f, 
    0.13280112f, 0.16002536f, 0.15679047f, 0.14946590f, -0.00113693f, 0.08443216f, -0.02265225f, -0.05294663f, 
    0.05990351f, 0.02434185f, -0.15791090f, 0.25848112f, -0.16931650f, -0.02828960f, 0.01401468f, -0.27480933f, 
    0.08696096f, 0.17764899f, -0.00649504f, -0.07245980f, -0.10203099f, -0.51430446f, 0.27679166f, -0.11491319f, 
    0.15883148f, -0.02128917f, -0.18256068f, -0.07357500f, 0.42732257f, 0.02171143f, -0.21263801f, 0.00206297f, 
    -0.03741382f, 0.02176053f, -0.01349500f, -0.10644960f, 0.11339411f, 0.05885357f, 0.10379412f, -0.01683261f, 
    -0.05975838f, 0.11247442f, -0.01332307f, 0.03256999f, -0.26674101f, 0.07161388f, -0.18257736f, 0.08936215f, 
    0.08890780f, -0.00266504f, 0.17434290f, -0.08949789f, 0.05131290f, -0.22429383f, -0.13893750f, -0.33729643f, 
    -0.08875272f, -0.18125017f, 0.00099958f, -0.25078028f, 0.12592249f, 0.03628949f, -0.04182502f, 0.10582600f, 
    -0.32665798f, 0.45892015f, -0.09709375f, -0.08850057f, 0.01919818f, -0.08827459f, -0.29332131f, 0.01008459f, 
    -0.09646370f, -0.10159694f, 0.04270516f, 0.10243614f, -0.07181919f, 0.05716708f, 0.05885931f, 0.06531645f, 
    0.14855760f, -0.03314571f, 0.09108958f, 0.10926656f, 0.03418318f, 0.01292276f, 0.08817003f, -0.03202530f, 
    0.20601076f, 0.00294106f, 0.02334686f, 0.34762511f, 0.17724374f, -0.05808330f, 0.01919941f, -0.22431876f, 
    -0.23407248f, 0.12424129f, 0.10425020f, 0.06096150f, 0.02309486f, 0.21873073f, -0.07949854f, 0.04947456f, 
    -0.28712195f, 0.17344420f, 0.13955802f, 0.01677938f, 0.29940671f, -0.18863773f, 0.03626898f, 0.17689529f, 
    0.10818640f, 0.18168141f, 0.05390726f, 0.10200906f, -0.07939486f, -0.18479396f, 0.12335297f, 0.05329017f, 
    -0.04849933f, 0.01992963f, -0.04818508f, 0.07283923f, 0.16495891f, 0.04550501f, 0.09030516f, -0.26048970f, 
    -0.40574846f, -0.25949237f, -0.15611216f, -0.14004880f, -0.15826383f, -0.12592642f, 0.11831702f, 0.00737501f, 
    0.09029133f, 0.23403573f, -0.11946525f, 0.09824190f, -0.01379109f, -0.15361637f, -0.02246599f, 0.11258403f, 
    0.10502081f, -0.00881040f, 0.07423147f, 0.09524083f, -0.26077878f, -0.06061704f, -0.20917745f, -0.04373300f, 
    0.12238669f, 0.15042201f, 0.01268144f, -0.03402223f, 0.08478322f, -0.08876237f, 0.05320006f, -0.23397097f, 
    0.32193545f, 0.06426918f, -0.06405577f, -0.23300448f, -0.13653065f, -0.24960251f, 0.22358491f, -0.00571004f, 
    0.05094882f, -0.04228654f, 0.05722981f, -0.23354188f, -0.14522316f, 0.28839979f, 0.14384367f, 0.06744189f, 
    -0.06012796f, 0.09674507f, -0.03252156f, -0.11331426f, -0.14646719f, -0.40494338f, -0.13774380f, 0.14741676f, 
    0.12229303f, 0.21779802f, 0.06262843f, -0.17875925f, 0.00167727f, 0.05979350f, -0.00176570f, -0.33674273f, 
    0.03044583f, -0.01583776f, 0.02522822f, -0.02435316f, -0.10847206f, 0.01544575f, -0.01944936f, -0.34876969f, 
    -0.21873908f, -0.02057296f, 0.14549132f, 0.09706432f, -0.02675737f, 0.17057517f, -0.18145692f, 0.03137867f, 
    0.13039641f, -0.21391575f, -0.04447381f, -0.12314516f, -0.08971570f, 0.19426799f, 0.14162578f, 0.09146906f, 
    -0.18126346f, -0.11711262f, -0.15608349f, -0.27102703f, 0.17570327f, 0.10756289f, 0.11098750f, -0.13015941f, 
    -0.23186125f, -0.15040220f, -0.14648491f, -0.17939103f, -0.18014397f, -0.03953098f, 0.00835449f, 0.14609057f, 
    -0.09304587f, -0.06247510f, 0.07508898f, 0.01214677f, -0.02250926f, -0.12770048f, 0.12132058f, 0.03225378f, 
    -0.11214579f, 0.04614406f, -0.09733713f, 0.01444502f, -0.00517427f, -0.01094254f, 0.22660418f, -0.02468491f, 
    0.02198887f, 0.36092719f, -0.49383655f, -0.17027321f, -0.58055216f, 0.03933192f, 0.18720806f, 0.05687605f, 
    -0.08886731f, -0.03625665f, 0.12985133f, -0.15674013f, -0.03849004f, 0.10153461f, 0.00347612f, -0.14664863f, 
    -0.11247769f, -0.06300572f, -0.24688955f, 0.23862951f, -0.02241833f, -0.23658910f, 0.00809236f, -0.19428067f, 
    0.18009262f, 0.13220814f, 0.00700014f, -0.07436650f, -0.40544021f, 0.15692693f, 0.21630511f, 0.40603983f, 
    -0.21158925f, -0.07508298f, 0.06061049f, 0.02342864f, 0.01287361f, -0.13265291f, 0.08178866f, 0.03545076f, 
    0.35492334f, -0.06385715f, 0.12918228f, -0.00470620f, 0.14472653f, -0.15938778f, -0.19710056f, -0.02917281f, 
    -0.09905618f, -0.02814789f, -0.01540179f, -0.04324955f, 0.16143174f, -0.08940944f, -0.12503885f, 0.04439555f, 
    0.03128206f, 0.05899140f, 0.03714555f, 0.23341204f, -0.17395003f, 0.09363216f, -0.23217024f, 0.21464945f, 
    0.20244136f, 0.15691027f, -0.06373914f, -0.27327260f, 0.23056583f, 0.22133538f, 0.03223028f, 0.19659612f, 
    -0.13878676f, 0.27542332f, 0.15392929f, 0.12409217f, -0.17684799f, -0.14001340f, -0.03977203f, 0.20178810f, 
    -0.07984252f, 0.11546873f, -0.27445161f, 0.19040520f, -0.02167127f, -0.08434324f, 0.50149047f, 0.23460746f, 
    0.23163085f, -0.07111941f, 0.06763154f, -0.04086804f, 0.01789420f, -0.06791388f, -0.08507713f, -0.18464291f, 
    0.27705377f, -0.10140197f, 0.27120113f, 0.01781747f, -0.17237325f, 0.04627495f, 0.02869076f, -0.20771733f, 
    -0.26068670f, -0.16926903f, 0.26569808f, 0.04621077f, 0.00275901f, -0.21255186f, -0.05701891f, 0.04175001f, 
    0.06985515f, 0.00176098f, -0.13387728f, 0.26265368f, -0.18342395f, -0.22607760f, -0.12834947f, 0.13639736f, 
    -0.11655010f, -0.12395918f, -0.18715371f, 0.18575634f, 0.12245811f, -0.22631124f, 0.07742421f, -0.16278535f, 
    -0.11643834f, 0.10916065f, 0.03448451f, -0.22279365f, 0.47310433f, -0.10058803f, 0.21958087f, -0.21496215f, 
    0.34604368f, -0.09995873f, -0.08580457f, -0.17093997f, -0.02230776f, 0.06760153f, -0.08938070f, 0.03113763f, 
    0.07108834f, 0.07876824f, 0.07882161f, -0.07037237f, 0.07415754f, 0.13359095f, 0.05040048f, -0.08014205f, 
    0.12345040f, 0.29800224f, -0.02648235f, -0.00845042f, 0.16713975f, 0.21063825f, -0.33583227f, 0.05302842f, 
    0.15440421f, 0.05130459f, 0.03494334f, -0.40894672f, 0.04699047f, -0.03150951f, -0.01323424f, -0.31971005f, 
    -0.08546185f, -0.04036843f, -0.12287947f, -0.19263326f, 0.30096963f, -0.00004751f, -0.19438899f, -0.17641892f, 
    -0.38554418f, 0.10849453f, 0.01136683f, -0.00522619f, 0.19524539f, 0.01171959f, 0.07743624f, 0.14813353f, 
    -0.33816722f, 0.22337383f, 0.24039696f, -0.33124855f, 0.04523553f, 0.28308263f, 0.22198272f, 0.25427678f, 
    0.02610048f, -0.32510769f, -0.03577887f, -0.25848272f, -0.22319467f, -0.03443781f, -0.08685941f, 0.08990829f, 
    -0.06595632f, 0.07896494f, -0.02463416f, 0.16512842f, -0.01568122f, 0.19721770f, -0.12298314f, 0.14097759f, 
    -0.17815022f, 0.01143647f, 0.11054737f, 0.00513280f, 0.14382750f, 0.17389341f, 0.07426647f, 0.37438583f, 
    0.07243667f, -0.12195897f, -0.05621744f, -0.06829228f, 0.17544010f, -0.00316319f, 0.29729435f, -0.06542188f, 
    0.16511939f, -0.08125118f, 0.06635496f, -0.22379623f, 0.18788771f, 0.04525780f, -0.14257179f, -0.19043699f, 
    -0.05282515f, -0.04520020f, -0.01070430f, 0.01430199f, -0.07112975f, -0.07776315f, 0.16792119f, 0.47869539f, 
    0.12162047f, 0.11734571f, -0.09189127f, -0.06859033f, 0.10635857f, 0.00375741f, 0.22037208f, 0.11114531f, 
    0.01834330f, -0.29830521f, 0.03664340f, 0.19916670f, 0.07022821f, 0.00472794f, -0.01292503f, -0.11654455f, 
    -0.05472723f, 0.06464697f, -0.08037210f, -0.00635905f, -0.04397913f, -0.20836414f, 0.05691304f, 0.05179280f, 
    0.03771910f, -0.16097245f, 0.71234405f, 0.26528636f, -0.20066978f, 0.04215756f, -0.14741503f, -0.01190963f, 
    0.03448554f, 0.00541284f, 0.08123837f, -0.25966868f, -0.23703229f, -0.14751044f, 0.14139062f, 0.11480574f, 
    0.12948041f, -0.05995765f, 0.01402976f, -0.00054005f, -0.03363142f, 0.11727097f, 0.03135513f, 0.13933797f, 
    0.11901491f, 0.07333818f, 0.07712696f, -0.04566131f, 0.18036924f, -0.02280552f, 0.27814811f, 0.09237213f, 
    0.05416323f, -0.14540966f, 0.00455858f, 0.05152548f, 0.01442149f, -0.00870562f, 0.52655882f, 0.25105131f, 
    -0.10552781f, -0.03828515f, -0.02529541f, -0.04888021f, 0.26041216f, -0.00728076f, -0.08850747f, -0.37760460f, 
    -0.14749090f, -0.04367179f, 0.00388585f, 0.03960783f, -0.09639303f, 0.00747887f, -0.08296668f, -0.06386511f, 
    0.37749967f, -0.04289757f, 0.13796385f, 0.02031237f, 0.13024728f, 0.03412120f, 0.16606376f, 0.02145140f, 
    0.13851577f, 0.04933028f, -0.17534897f, -0.12472645f, -0.03212348f, 0.08608589f, 0.04881234f, 0.18028383f, 
    -0.12604053f, 0.08028220f, -0.38096389f, -0.20783021f, 0.15532658f, -0.07649159f, 0.08850683f, 0.09644329f, 
    -0.35398373f, -0.03688904f, 0.05095396f, -0.17535819f, 0.07598389f, -0.14396183f, 0.28173369f, 0.04041066f, 
    0.03336959f, 0.02649998f, -0.21553126f, -0.03272450f, 0.37648895f, 0.26011989f, -0.10939779f, -0.07520688f, 
    -0.18216689f, -0.06347913f, -0.07573400f, 0.06833360f, 0.00176530f, -0.06146064f, 0.13135532f, -0.08924171f, 
    0.01928884f, -0.10323422f, 0.09421022f, -0.00223713f, 0.05101002f, -0.00460455f, -0.31447279f, -0.15430984f, 
    0.36897388f, 0.02339192f, 0.16771966f, 0.11218674f, -0.13412642f, 0.10822591f, -0.00273047f, 0.24628510f, 
    0.02670897f, 0.01977010f, -0.10438196f, -0.01558504f, -0.04769885f, -0.09430801f, -0.00470709f, -0.09575244f, 
    -0.34759715f, 0.01693865f, 0.08431422f, 0.10447286f, -0.00071289f, -0.06063963f, -0.14438298f, -0.01731991f, 
    0.00551621f, 0.57955784f, 0.01865566f, 0.15077291f, 0.10750062f, 0.03986707f, -0.06396857f, 0.02626853f, 
    -0.02920472f, -0.24434820f, 0.07080026f, 0.01231972f, 0.00849894f, 0.03266727f, -0.20138159f, -0.10781219f, 
    -0.06901149f, 0.10924271f, 0.06073646f, 0.40375319f, 0.11829025f, 0.08641853f, -0.01586451f, 0.06061940f, 
    -0.10155039f, -0.01846363f, 0.11656990f, 0.05004218f, 0.25362045f, 0.01216474f, 0.25020480f, -0.10628631f, 
    0.04817614f, -0.00184205f, -0.39216998f, 0.09899504f, -0.12115940f, -0.17196818f, -0.32521710f, -0.17189917f, 
    0.13436748f, -0.02069572f, -0.16149320f, -0.07678588f, 0.16595222f, 0.02565182f, -0.18597868f, 0.01665948f, 
    -0.01011659f, -0.25935644f, -0.05396242f, -0.13880847f, -0.07581743f, 0.04043128f, -0.06406450f, -0.00342566f, 
    0.25099814f, 0.00828272f, -0.14744036f, -0.11924007f, 0.01443696f, 0.08014457f, 0.10734201f, 0.03742667f, 
    -0.05969409f, 0.12386630f, -0.09510345f, 0.01084561f, -0.09718227f, -0.03049497f, 0.08027476f, 0.15596865f, 
    -0.01645332f, 0.05881469f, 0.02262991f, -0.24326634f, -0.09621928f, -0.00773491f, -0.11127447f, 0.03647272f, 
    0.01986090f, 0.19660695f, 0.12448085f, 0.06795645f, -0.08111141f, 0.09397539f, -0.02319697f, 0.12967303f, 
    -0.00515794f, -0.09879427f, -0.04261428f, -0.23893934f, 0.00756149f, -0.03969038f, -0.07676659f, 0.00754333f, 
    -0.08547100f, -0.08196390f, -0.01899408f, 0.05686384f, 0.01939074f, -0.07380512f, 0.16136675f, -0.25639442f, 
    -0.04740483f, 0.01593811f, 0.02460887f, 0.02434391f, -0.02343425f, -0.22936919f, -0.19063130f, 0.14758186f, 
    0.07310156f, -0.01927439f, 0.06713898f, 0.06522278f, 0.02245219f, -0.07799239f, 0.29464102f, 0.12430776f, 
    0.20849495f, 0.08992140f, 0.07946110f, 0.06920403f, 0.02133771f, -0.02556613f, 0.03180188f, 0.11082889f, 
    -0.03842224f, -0.26951200f, 0.03614177f, -0.00184791f, -0.02791181f, 0.01097342f, -0.17606495f, -0.03358381f, 
    -0.03918762f, 0.14086713f, -0.09782313f, -0.08355356f, 0.00494380f, -0.06915673f, -0.05715946f, 0.19009216f, 
    -0.10332349f, 0.33112970f, 0.07924571f, -0.05342910f, -0.24195482f, -0.07854597f, 0.02805754f, -0.04702549f, 
    0.04373065f, 0.04706608f, -0.24177589f, -0.03607571f, 0.14122383f, 0.03214455f, -0.05967358f, -0.12507515f, 
    -0.00264947f, 0.08493766f, -0.19408178f, -0.04827899f, 0.00375346f, -0.18002115f, 0.12733690f, -0.01352340f, 
    0.14981601f, -0.05897782f, -0.05405203f, -0.04214245f, 0.09627920f, -0.15231419f, -0.10388949f, 0.01028203f, 
    -0.02825627f, -0.12591368f, -0.16240089f, -0.24139956f, 0.14850575f, -0.01199566f, -0.17697217f, 0.05131922f, 
    0.03889628f, -0.18894418f, 0.19180523f, -0.02886333f, 0.21197240f, 0.00768881f, -0.28318763f, 0.06695633f, 
    -0.21476220f, -0.11617208f, -0.08455887f, -0.11924160f, -0.31617332f, -0.00953765f, -0.08839564f, 0.02572666f, 
    0.13256808f, -0.29747009f, 0.28151748f, 0.05865971f, 0.13805476f, 0.18748344f, 0.05589887f, -0.00874749f, 
    0.11290327f, -0.01224885f, -0.01142031f, -0.14852656f, -0.10284616f, 0.05879463f, -0.01630782f, -0.01757648f, 
    -0.04805402f, 0.10610317f, -0.09121897f, -0.01153176f, -0.02760217f, -0.09363408f, 0.07202217f, -0.05164405f, 
    0.06654515f, -0.04810309f, 0.32473987f, 0.27589539f, 0.19733799f, 0.10372698f, 0.01120190f, 0.20303416f, 
    0.12089007f, -0.03550643f, -0.02520323f, 0.11874270f, 0.11949614f, -0.22409183f, -0.02448689f, -0.07479525f, 
    -0.14890137f, 0.02242229f, -0.03905046f, 0.02082310f, -0.20799935f, 0.19813885f, 0.04211742f, -0.15338224f, 
    0.07766249f, -0.03414614f, 0.02322060f, -0.09038915f, 0.03750243f, -0.15608206f, 0.20744538f, 0.06030559f, 
    0.00208617f, -0.01090277f, -0.05694556f, -0.08452217f, -0.06792256f, -0.03278421f, 0.16185343f, 0.25418356f, 
    -0.07402095f, 0.23349100f, -0.05527246f, -0.00250528f, -0.05575527f, -0.01334405f, 0.08534060f, 0.33380958f, 
    -0.07327229f, 0.08910220f, 0.12745546f, -0.22276574f, -0.06282669f, 0.08102312f, 0.19027156f, 0.07322784f, 
    -0.31551817f, -0.07220908f, 0.44790581f, -0.00863895f, -0.20164973f, -0.15693080f, 0.05988684f, -0.01610245f, 
    -0.18351577f, -0.28275755f, -0.01966468f, -0.23485102f, 0.10868588f, 0.04707968f, -0.12209023f, 0.02560866f, 
    -0.03715288f, 0.11515047f, 0.18311523f, 0.35198441f, -0.00346925f, -0.07842784f, -0.00076666f, 0.02513258f, 
    -0.00642692f, -0.00109546f, 0.01375158f, -0.11497027f, -0.07967217f, -0.01249874f, 0.01481982f, 0.23309599f, 
    0.08386124f, -0.01736906f, -0.02011049f, 0.00639899f, -0.20650107f, 0.06481034f, -0.09244715f, 0.03474759f, 
    0.06309465f, 0.03929138f, -0.14650831f, -0.01749029f, -0.09091078f, 0.14706400f, 0.09169878f, -0.43580076f, 
    0.06348831f, -0.00881869f, 0.09282365f, 0.05528450f, 0.20747557f, 0.00926179f, 0.32868239f, 0.44985986f, 
    -0.08125903f, 0.11032920f, -0.11451820f, 0.02365103f, 0.05239540f, -0.31416193f, -0.01582005f, -0.35221332f, 
    -0.46850380f, 0.03754711f, 0.21928933f, -0.03634872f, 0.06907524f, -0.01201435f, 0.01788628f, 0.14043982f, 
    0.09707393f, 0.24090770f, 0.31155628f, -0.08970402f, -0.02880326f, -0.05948488f, 0.00159686f, -0.00934692f, 
    -0.02407180f, -0.09323654f, -0.00014455f, 0.23094264f, -0.15473942f, 0.10035443f, 0.10162196f, 0.01791593f, 
    0.06527992f, 0.02006935f, -0.07588183f, -0.04378907f, -0.31783009f, -0.08201946f, 0.04194728f, 0.10126051f, 
    0.01360739f, 0.25598672f, -0.09196936f, 0.02086482f, -0.08821988f, -0.16574316f, 0.04688063f, 0.00665422f, 
    -0.05797756f, -0.10693748f, -0.02072392f, 0.27575815f, -0.15525639f, 0.17968853f, -0.39832735f, 0.01166051f, 
    -0.06164369f, 0.06521276f, -0.02787448f, 0.10025833f, -0.06780979f, 0.47137061f, -0.07673576f, -0.14863631f, 
    -0.01884229f, 0.11561704f, 0.13571858f, 0.05309496f, -0.06260704f, -0.11912578f, -0.38126859f, -0.11503594f, 
    -0.30201775f, 0.01175120f, -0.00467849f, 0.23030959f, -0.04651312f, -0.09348102f, -0.16621549f, 0.02641308f, 
    -0.09886986f, -0.12591355f, 0.04630789f, 0.00102178f, -0.12188399f, 0.01593951f, 0.00909925f, 0.01367555f, 
    -0.37645915f, -0.23789042f, -0.11718881f, -0.19972800f, -0.09805540f, -0.18286489f, 0.03892791f, -0.05123674f, 
    0.00906987f, -0.39153060f, 0.05314830f, -0.12469617f, 0.02140956f, -0.04290529f, -0.06108674f, 0.04226447f, 
    -0.00080030f, 0.02699800f, 0.08881248f, -0.04693026f, 0.09343619f, -0.21636635f, 0.06110165f, 0.15599535f, 
    -0.04209786f, 0.08384025f, 0.02903339f, 0.07302141f, 0.00478661f, -0.05731016f, -0.25849086f, -0.11733311f, 
    0.22069742f, 0.22965428f, 0.09494510f, -0.02218683f, -0.22111703f, -0.15466890f, 0.18211475f, -0.08315367f, 
    0.40599817f, -0.01214219f, 0.17412773f, -0.12437344f, 0.00192269f, -0.19649424f, -0.22153063f, 0.05375027f, 
    0.08084746f, 0.00548894f, 0.09409576f, 0.16488385f, 0.27781698f, 0.02839141f, -0.00930744f, -0.08941608f, 
    0.29649976f, -0.34043235f, 0.03682780f, 0.12158423f, -0.00862140f, 0.08370261f, -0.04030938f, -0.14570494f, 
    0.09856515f, -0.36341456f, -0.00781634f, -0.10804198f, 0.10286257f, 0.01839253f, -0.23536299f, 0.04857917f, 
    0.10262521f, 0.17955332f, 0.24984100f, -0.10402007f, 0.01667529f, 0.06601863f, -0.01886545f, 0.02966710f, 
    -0.09702911f, -0.10193685f, 0.01620505f, 0.29870373f, 0.03033711f, -0.05436039f, 0.13239868f, 0.06954049f, 
    0.10087373f, -0.07524967f, 0.08369143f, -0.04698803f, 0.10669228f, 0.20763153f, -0.23278928f, 0.15812805f, 
    0.17804126f, 0.04716032f, -0.07725219f, -0.18444245f, 0.11825568f, -0.20116612f, 0.00127604f, 0.01991401f, 
    -0.04020321f, -0.36393324f, 0.06772417f, 0.32342577f, -0.04844470f, -0.08802623f, -0.18040906f, -0.03059237f, 
    0.07906715f, 0.17203052f, -0.32468036f, 0.04440503f, 0.16013938f, -0.19974294f, -0.07329335f, -0.05504212f, 
    0.19056706f, 0.15130606f, 0.14540739f, -0.12347154f, 0.03210998f, -0.00881162f, 0.45980597f, 0.17443472f, 
    -0.26350924f, 0.13918142f, 0.21269873f, 0.14973113f, 0.01288171f, -0.04259472f, -0.10636976f, -0.09067066f, 
    -0.09381325f, 0.05923691f, 0.27811179f, 0.13881575f, 0.03934677f, 0.03856396f, 0.15869243f, -0.04595409f, 
    0.03822711f, 0.01008951f, 0.02012892f, 0.03193059f, -0.01186694f, 0.06327786f, 0.02519681f, -0.01438888f, 
    0.01770963f, -0.02221763f, 0.07572407f, -0.02497645f, -0.02243054f, -0.09152262f, -0.02820159f, -0.08065445f, 
    0.00145394f, 0.00472381f, -0.07415784f, -0.03126226f, -0.02610875f, -0.07004234f, -0.03452388f, -0.05279799f, 
    0.04239015f, -0.06502054f, 0.02898205f, -0.04938479f, 0.02511739f, 0.04656686f, -0.01318932f, -0.04170706f, 
    -0.04600643f, -0.07077602f, -0.06840412f, -0.08398666f, -0.09405139f, 0.04513454f, -0.00845972f, -0.07970275f, 
    0.02150956f, -0.07508630f, -0.09177145f, 0.02917524f, -0.04840789f, -0.01103453f, -0.00546329f, 0.03272546f, 
    0.03998484f, 0.00896814f, 0.04198239f, -0.01377752f, 0.03017002f, -0.01272026f, 0.02466447f, 0.00325914f, 
    -0.00536600f, -0.05191261f, 0.01933410f, 0.06176160f, -0.07705782f, 0.06079022f, -0.01871133f, 0.03236421f, 
    -0.05817703f, -0.01618134f, 0.03992483f, -0.09180267f, 0.01299363f, -0.09991743f, 0.04954133f, -0.03112420f, 
    -0.03624574f, -0.04939745f, -0.07086338f, -0.02475775f, -0.00842058f, -0.00528284f, -0.03262566f, -0.05036860f, 
    -0.05700570f, -0.03337349f, -0.05096775f, 0.03459351f, -0.00274218f, 0.03204532f, 0.04185146f, -0.00194181f, 
    -0.02560337f, -0.06750108f, -0.06337718f, -0.04590374f, -0.05805262f, 0.00099632f, -0.01728692f, -0.01951625f, 
    -0.07437013f, 0.02401232f, -0.03450437f, -0.06594169f, -0.03458298f, 0.04627315f, -0.07187512f, 0.01296512f, 
    -0.00836554f, -0.05399630f, -0.03217583f, -0.02519315f, -0.05094267f, -0.06668708f, -0.06197805f, -0.02017423f, 
    -0.03506165f, -0.03188383f, -0.08320098f, 0.04236763f, 0.02212155f, 0.01122587f, 0.02873900f, -0.05770632f, 
    -0.04479569f, 0.02515021f, -0.04610074f, -0.03108344f, 0.02843044f, -0.06825698f, 0.04099940f, 0.01154833f, 
    -0.02534731f, -0.04013310f, 0.05509861f, -0.07506718f, 0.03726782f, -0.00450951f, 0.01783983f, 0.02686631f, 
    -0.09056532f, -0.02726976f, 0.01510024f, -0.06385934f, 0.04159960f, -0.09848987f, 0.06642078f, -0.05157332f, 
    0.40310118f, -0.32993472f, -0.09876774f, 0.15911858f, -0.14021859f, -0.11077596f, 0.00743182f, -0.04466936f, 
    -0.06867050f, -0.70937628f, 0.19059104f, 0.01934757f, 0.01126934f, 0.23459727f, -0.00112267f, -0.05406405f, 
    -0.02532334f, -0.06515136f, -0.24837382f, 0.14094582f, 0.14823435f, -0.07424618f, 0.04125742f, 0.10165131f, 
    0.05326905f, 0.02856561f, -0.12264916f, 0.22634684f, -0.22439404f, 0.15472154f, -0.14695388f, -0.05366902f, 
    0.20336239f, -0.11294240f, 0.16526620f, 0.11669685f, 0.07296883f, -0.25549954f, -0.09250402f, 0.11200710f, 
    0.17612527f, 0.06815508f, 0.02303751f, -0.10361636f, 0.22471203f, -0.14803250f, -0.14818825f, -0.28127921f, 
    0.01019876f, -0.01495635f, 0.04133352f, -0.06505152f, -0.00423476f, 0.00929417f, 0.06896809f, 0.19611527f, 
    -0.32488075f, 0.04987445f, -0.00961985f, 0.02886012f, -0.08939382f, -0.00937051f, -0.01888375f, 0.63490808f, 
    -0.17834766f, -0.03550898f, 0.01259285f, -0.18746021f, -0.09958213f, -0.05174444f, -0.14996484f, 0.17836402f, 
    -0.30601633f, 0.16773397f, 0.14254172f, -0.22634523f, 0.29694095f, 0.14210156f, -0.13000667f, 0.01510111f, 
    -0.00343124f, -0.45300055f, -0.17294782f, 0.21968763f, 0.11555222f, 0.43792081f, 0.03804526f, 0.01096069f, 
    -0.06284375f, 0.06395186f, 0.23710187f, -0.35302052f, 0.17023511f, -0.12772033f, 0.19437926f, -0.04595029f, 
    -0.02392177f, -0.01143993f, -0.05796784f, -0.40984663f, -0.07931900f, -0.16993047f, -0.06074324f, -0.00842866f, 
    0.04857288f, 0.07695000f, 0.14866917f, -0.03406533f, -0.34254017f, -0.52466935f, 0.26648653f, -0.02242412f, 
    0.32014215f, -0.18759915f, 0.09732428f, -0.21490778f, -0.04429496f, 0.42462847f, -0.09936750f, -0.33102533f, 
    0.13586386f, -0.07215823f, 0.13006179f, -0.06326363f, -0.03790944f, 0.04150292f, 0.31197399f, 0.29495025f, 
    -0.20494615f, -0.04527811f, -0.13722257f, -0.08770812f, 0.11973344f, 0.09265501f, -0.02965527f, 0.15866105f, 
    -0.29546580f, -0.40214157f, -0.06319674f, 0.00310845f, 0.11613686f, 0.17176113f, 0.05828113f, 0.07498933f, 
    0.14064866f, -0.03785472f, 0.10656346f, 0.10047918f, -0.17778642f, 0.05819594f, 0.03952844f, -0.08826213f, 
    -0.05293686f, 0.17489871f, 0.01227887f, 0.05841143f, 0.07985888f, 0.20086922f, 0.03237683f, 0.03679920f, 
    0.05934750f, -0.02693640f, -0.11140648f, 0.15805952f, -0.03390573f, 0.20156741f, 0.00518477f, 0.03894279f, 
    0.04470328f, 0.02183799f, 0.13224761f, -0.06633758f, 0.24214590f, 0.00493264f, 0.07434781f, 0.17228945f, 
    -0.05386313f, -0.02908405f, 0.13742782f, 0.00296913f, 0.10095888f, -0.15507315f, 0.24329729f, -0.04214570f, 
    -0.14583886f, -0.02464049f, 0.08076481f, 0.16855086f, -0.06986859f, -0.39095324f, 0.09007525f, -0.01691437f, 
    0.04409968f, 0.05578209f, -0.07374537f, 0.09909574f, -0.10536942f, 0.12901217f, 0.34535727f, 0.07871830f, 
    -0.16900393f, 0.19671854f, 0.03314593f, -0.20045987f, -0.04667003f, -0.09867123f, -0.12313467f, 0.13406272f, 
    -0.20632130f, 0.17857011f, -0.48842415f, -0.01534872f, -0.21322101f, -0.01668345f, 0.07832093f, 0.11579610f, 
    -0.01535354f, -0.21343639f, -0.03982558f, 0.13434693f, 0.06348785f, 0.24326554f, -0.00157416f, -0.17945310f, 
    -0.01687221f, 0.13251081f, 0.02649403f, -0.61424839f, 0.15318710f, -0.04724552f, 0.14550227f, 0.03398645f, 
    -0.16445315f, 0.12422387f, -0.16551363f, -0.27570835f, 0.10856029f, -0.06732713f, 0.05694154f, 0.02430528f, 
    -0.08889759f, 0.11744127f, 0.11855969f, 0.30301422f, -0.03471819f, -0.10849229f, -0.18796320f, -0.15721557f, 
    -0.14807069f, 0.09157982f, 0.10085571f, -0.12197645f, 0.00371057f, -0.23435251f, 0.19393857f, 0.02326200f, 
    0.01717525f, 0.06516355f, -0.01740989f, 0.01610139f, 0.05648207f, -0.31315589f, -0.07060028f, -0.12185092f, 
    0.11242146f, -0.09609205f, 0.08145759f, -0.00302491f, 0.00535492f, -0.08768982f, -0.14573093f, 0.14212063f, 
    0.45995945f, -0.25432649f, -0.09249160f, 0.10723004f, -0.04031610f, -0.10557525f, 0.15777948f, -0.06330361f, 
    0.05809320f, 0.04707333f, -0.16102037f, -0.26169452f, -0.15485089f, -0.02035899f, 0.08902262f, 0.16335793f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.01880435f, 0.01921250f, 0.28082234f, 0.13403380f, 0.11877868f, 0.09202308f, 0.10077397f, 0.19659781f, 
    0.17424932f, -0.06658090f, -0.15684888f, 0.19376808f, 0.08034427f, 0.03961255f, 0.10007012f, 0.26011243f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.12793629f, 0.16541271f, -0.07135893f, -0.38775912f, 0.09209841f, 0.45676070f, 0.20221569f, 0.04663937f, 
    0.18852998f, -0.34440565f, -0.03744198f, 0.59108579f, 0.34231675f, -0.00325373f, -0.02113815f, -0.49803931f, 
    0.05859330f, 0.23386146f, -0.39874569f, 0.32192403f, -0.29475498f, 0.37129572f, -0.00619657f, 0.39998308f, 
    -0.30206209f, 0.36079985f, 0.29170907f, -0.07658001f, 0.41565228f, 0.07224034f, 0.10330182f, -0.11448124f, 
    0.11869597f, 0.11224246f, -0.32077816f, 0.19774699f, -0.07214564f, 0.05016554f, -0.40149459f, 0.24964325f, 
    0.45740348f, 0.28388232f, 0.23150797f, 0.29825327f, 0.06836422f, 0.10728768f, -0.58820784f, 0.06215477f, 
    -0.13954641f, 0.01172241f, -0.20044337f, -0.00303814f, -0.20743275f, 0.06597796f, 0.24424350f, -0.14830381f, 
    -0.21214086f, -0.12545246f, 0.02593037f, -0.18677099f, -0.06804546f, -0.14818653f, 0.10174070f, 0.00980727f, 
    -0.14876378f, -0.28315729f, -0.30865821f, -0.20334244f, 0.59428823f, 0.37243500f, 0.32288525f, -0.27341908f, 
    0.47462654f, -0.04142259f, -0.63852978f, -0.35925019f, -0.29271674f, -0.20787585f, 0.39455208f, -0.00607795f, 
    0.24228674f, -0.08822980f, -0.35784572f, 0.11440443f, 0.19879907f, -0.02689677f, -0.37651077f, -0.08090945f, 
    -0.20683174f, 0.10068458f, 0.16412807f, -0.50267291f, 0.18691044f, -0.07761303f, 0.50864547f, 0.11954635f, 
    0.03512969f, 0.03335004f, -0.41798031f, 0.55450702f, -0.06070814f, -0.02432269f, 0.28080359f, 0.28046677f, 
    -0.22018753f, 0.55823988f, 0.62557179f, 0.17399675f, 0.14419137f, -0.24591880f, 0.51223594f, -0.50532758f, 
    0.06186142f, 0.52607316f, 0.02120037f, 0.03911639f, -0.04691027f, 0.01734885f, 0.32542726f, -0.01748411f, 
    -0.09422662f, 0.10330944f, 0.07321308f, -0.10373020f, 0.39369479f, 0.05510529f, -0.43583593f, 0.19243391f, 
    0.23647071f, -0.02660727f, -0.05688780f, 0.20741577f, -0.04274392f, 0.11985631f, 0.03430252f, 0.24083909f, 
    0.37903318f, 0.41081637f, 0.30260101f, -0.89770246f, 0.53000116f, -0.11191811f, -0.27239093f, -0.16415425f, 
    -0.08981583f, -0.14701712f, 0.17053388f, -0.54371357f, 0.40382853f, 0.30526531f, -0.06373490f, 0.21644449f, 
    0.05811346f, 0.04406304f, -0.10147694f, 0.03989822f, 0.18983251f, -0.07667260f, 0.20046215f, -0.24023759f, 
    -0.00356779f, 0.11212289f, 0.29677737f, 0.49157402f, -0.10399982f, -0.11172792f, 0.05923573f, -0.14345801f, 
    -0.13009094f, 0.66864800f, 0.33676001f, 0.44865233f, 0.33007848f, 0.17494361f, 0.12309822f, -0.46349272f, 
    -0.09406105f, 0.15599619f, 0.40158099f, 0.16410659f, -0.21174291f, -0.45586079f, -0.21192780f, 0.45311773f, 
    0.37506229f, 0.25042051f, 0.46075559f, -0.18721630f, -0.12642308f, 0.20989396f, 0.36647350f, -0.04924028f, 
    -0.04110502f, -0.06945101f, 0.37849450f, 0.01350893f, -0.24190392f, -0.44965807f, -0.18582849f, 0.36202097f, 
    0.10359824f, -0.28638923f, 0.07379145f, 0.08884419f, 0.19573911f, -0.06824568f, 0.32329890f, 0.29806969f, 
    0.18822557f, -0.11265395f, 0.03425905f, -0.01207154f, -0.19911273f, -0.09346972f, 0.08634563f, -0.23931953f, 
    -0.15772350f, -0.10291449f, -0.11019076f, -0.23082754f, -0.09500128f, -0.05067341f, -0.07596518f, -0.12913026f, 
    0.21236745f, -0.04407750f, 0.14031616f, -0.26810232f, 0.33683085f, -0.55386996f, 0.10102243f, -0.23982389f, 
    0.14783722f, 0.40350899f, 0.41000840f, -0.37888443f, -0.30441490f, 0.15468979f, -0.09393092f, 0.36012429f, 
    0.07902038f, -0.01878058f, -0.14100516f, -0.23380826f, -0.25649637f, -0.03553808f, 0.26441175f, -0.04993213f, 
    -0.20753612f, 0.19231981f, -0.35664839f, -0.08463721f, 0.50206447f, 0.16653082f, 0.80007350f, 0.08233683f, 
    -0.01651263f, -0.33920386f, 0.28738388f, -0.53101587f, -0.24675159f, 0.62649751f, 0.21685106f, 0.25779730f, 
    -0.04314525f, 0.35243547f, -0.39332357f, 0.22457998f, -0.01817463f, -0.12254781f, -0.22101055f, 0.08765642f, 
    -0.18736136f, -0.11672308f, 0.47367084f, 0.51490384f, -0.09076504f, -0.58609891f, 0.29622892f, 0.05014470f, 
    0.31026691f, -0.14753139f, -0.31862861f, 0.01997452f, -0.44192541f, -0.15162195f, 0.27031502f, 0.14291796f, 
    0.05965106f, 0.05971808f, -0.01473608f, 0.06358324f, 0.33726606f, 0.00934985f, -0.00656164f, 0.11902980f, 
    0.36644483f, -0.28512353f, -0.43388626f, 0.78538650f, 0.03225118f, 0.01251605f, -0.33813626f, -0.01357851f, 
    0.15604146f, 0.41369119f, 0.30835092f, 0.04972170f, -0.15001778f, -0.15791689f, 0.14619628f, 0.00968891f, 
    -0.30631441f, 0.73343629f, 0.50238663f, 0.06312864f, -0.15406960f, 0.14751263f, -0.20644580f, -0.04244598f, 
    -0.02165132f, -0.40152937f, 0.51007730f, -0.21451613f, 0.34974167f, -0.10271946f, 0.11906452f, 0.34291634f, 
    0.49716192f, -0.04529678f, -0.36100242f, 0.33924323f, 0.05364253f, -0.16692321f, 0.39615116f, -0.34474826f, 
    0.13110146f, 0.29788044f, 0.31418651f, 0.02582496f, -0.10030020f, -0.02113416f, 0.14559416f, -0.24905540f, 
    -0.05030521f, -0.25834289f, -0.14214058f, 0.15746835f, -0.00583164f, 0.13077475f, -0.46156681f, 0.25279951f, 
    0.04481468f, -0.57071793f, -0.47258604f, -0.22890782f, 0.04305000f, -0.49016067f, -0.03808638f, 0.25331044f, 
    0.37404403f, 0.16480136f, -0.18329456f, -0.07982691f, -0.15242481f, -0.03211307f, 0.42034960f, 0.15101516f, 
    0.14261496f, -0.23445973f, 0.12283339f, 0.06917495f, -0.06921871f, -0.24428093f, -0.11587501f, 0.04839415f, 
    0.40471578f, -0.31113353f, -0.05907306f, -0.21958889f, 0.04216699f, 0.13691992f, -0.23022117f, -0.06408873f, 
    -0.17675668f, -0.19828051f, 0.04876736f, -0.09706801f, -0.19612175f, -0.04655135f, -0.10629815f, -0.02835917f, 
    -0.14170623f, -0.10382336f, 0.22454435f, 0.07961121f, -0.21080256f, 0.21144381f, -0.18170545f, -0.20112216f, 
    0.10264660f, 0.47965279f, 0.41480643f, 0.29721084f, -0.29091260f, -0.28888220f, 0.44576910f, 0.20060259f, 
    -0.14159182f, 0.12878436f, -0.17959213f, -0.13202094f, -0.27706513f, -0.12166477f, 0.26752439f, 0.39380789f, 
    -0.20187888f, -0.07827158f, 0.67512798f, 0.30527240f, 0.02301817f, -0.28474897f, 0.21845663f, 0.09375437f, 
    0.55724877f, -0.45226774f, -0.41960382f, -0.06913763f, -0.30058324f, -0.03590892f, -0.12336471f, 0.43915451f, 
    0.16479118f, 0.66118437f, 0.10698607f, -0.01068066f, 0.01622219f, -0.29767472f, 0.34241712f, 0.38272417f, 
    -0.02143426f, -0.19245774f, 0.32598189f, 0.02458720f, -0.16943538f, 0.05135222f, -0.18320806f, 0.15919447f, 
    0.09025472f, 0.40161571f, -0.41464424f, 0.17456861f, -0.19954161f, -0.28595832f, -0.10339102f, 0.34897044f, 
    0.20955679f, 0.10880534f, 0.43193430f, -0.01578744f, 0.11971368f, -0.05582656f, -0.14587438f, 0.55117983f, 
    -0.02843514f, -0.08952095f, -0.51889747f, -0.24831875f, 0.11558314f, 0.54078829f, -0.17160439f, 0.33656961f, 
    -0.06752579f, 0.38799429f, -0.06013350f, -0.45721352f, 0.31288236f, 0.15347286f, -0.49417195f, 0.23657075f, 
    0.13759553f, -0.05924492f, 0.22307348f, 0.09333400f, 0.27890792f, 0.10542545f, 0.22560616f, 0.06561457f, 
    -0.14804152f, 0.38982713f, 0.30989036f, -0.51845342f, -0.24266139f, 0.17010230f, 0.18547592f, 0.40660104f, 
    0.11128122f, 0.31533164f, -0.45297986f, 0.05882470f, 0.33379304f, 0.17581519f, 0.40565082f, -0.27406445f, 
    -0.04748270f, -0.09206060f, -0.19935411f, 0.54660159f, 0.11033008f, -0.09492720f, 0.12481499f, -0.50380147f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.30549780f, 0.19259860f, -0.02242126f, 0.12460233f, 0.22412428f, -0.40091935f, -0.24547581f, 0.25769919f, 
    0.43919802f, 0.42466798f, -0.22563805f, -0.02787823f, 0.50697911f, 0.10148456f, -0.11697923f, -0.04543341f, 
    0.31592244f, 0.05929679f, -0.00887140f, 0.02712613f, 0.35025814f, -0.03493366f, 0.01112172f, -0.10191265f, 
    -0.14006644f, -0.05634842f, 0.37397775f, 0.02569123f, -0.17386353f, 0.29501891f, -0.01019350f, -0.28318596f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.05501287f, -0.05661565f, 0.03993715f, 0.04739061f, -0.15571725f, 0.04069735f, 0.05357775f, -0.13689294f, 
    -0.01294671f, 0.11054379f, -0.17453113f, -0.15626369f, -0.15428823f, -0.09708075f, -0.09650334f, -0.13157643f, 
    -0.17449121f, -0.08907317f, -0.04430542f, 0.16458111f, -0.16391785f, 0.01061688f, -0.01267545f, -0.03035195f, 
    0.00437699f, -0.04216463f, 0.02775477f, -0.02323678f, 0.08320694f, -0.17217213f, -0.05831847f, -0.02008951f, 
    0.49678347f, 0.21343647f, 0.16701296f, 0.09267389f, 0.10940065f, 0.56024069f, 0.18779990f, -0.12598976f, 
    0.21788837f, 0.37593150f, -0.16604248f, 0.01631113f, -0.08222445f, -0.06957387f, -0.20749386f, -0.57138467f, 
    0.37284216f, -0.23793676f, 0.27764106f, -0.02061545f, 0.34282821f, -0.38799235f, 0.74043429f, -0.04792512f, 
    -0.02235589f, -0.28703928f, -0.01612413f, 0.20707121f, -0.11091969f, 0.14799568f, -0.22074240f, 0.18249603f, 
    -0.28521186f, 0.31126538f, 0.45946342f, -0.12005461f, -0.28240520f, 0.35878700f, 0.22291853f, -0.17460902f, 
    -0.14616005f, -0.18641497f, -0.12406122f, 0.23958661f, 0.19496852f, 0.11380362f, -0.81921291f, 0.03415306f, 
    0.06756683f, 0.46244079f, 0.08032952f, -0.38726705f, 0.14989893f, 0.24146657f, 1.31732953f, -0.08872187f, 
    0.03219404f, 0.14294721f, 0.16758797f, -0.10617501f, 0.37157941f, 0.26248994f, -0.18028228f, -0.48312518f, 
    -0.15640484f, -0.03708754f, -0.13017669f, -0.09516136f, 0.07213186f, 0.14230765f, 0.01104020f, -0.10264719f, 
    -0.05085517f, 0.11195638f, 0.10804374f, -0.03677987f, -0.16950226f, 0.12770317f, -0.05743349f, -0.13896330f, 
    -0.12802765f, -0.10955835f, -0.13998823f, -0.10998721f, -0.05992395f, 0.13341190f, -0.06512526f, 0.00103664f, 
    0.04806608f, -0.12313290f, 0.14124680f, -0.12404311f, -0.15006661f, 0.13429601f, -0.13483199f, -0.04771908f, 
    0.03625053f, 0.09902994f, -0.02726824f, 0.16838777f, 0.87143254f, -0.02700745f, 0.25678828f, -0.01260610f, 
    0.33334655f, 0.42954925f, 0.24275681f, -0.16539477f, -0.31240720f, 0.05545397f, 0.18513818f, 0.22997244f, 
    0.34867620f, -0.39338025f, 0.00740404f, 0.03308030f, 0.38130769f, 0.02906309f, 0.85132825f, 0.46240094f, 
    -0.09672493f, -0.28880021f, -0.11944970f, -0.17925797f, -0.41964632f, 0.48821697f, 0.14469622f, 0.58920610f, 
    -0.00088138f, -0.21406472f, 1.04436028f, 0.14050433f, 0.32079640f, -0.26608163f, -0.02550883f, 0.51290983f, 
    0.32387340f, -0.00943045f, 0.01566304f, -0.20842075f, -0.38976905f, 0.12968056f, 0.33576950f, -0.50380850f, 
    0.03173364f, -0.20315187f, 0.40036184f, 0.11794657f, -0.10502319f, -0.39244726f, -0.08905358f, 0.29100353f, 
    -0.00012246f, -0.33721450f, 0.19063361f, 0.21408755f, 0.54756910f, 0.54100531f, 0.02917376f, 0.15439668f, 
    0.41116065f, 0.40888622f, -0.02280259f, 0.16223758f, -0.31473264f, -0.33048707f, 0.35614523f, -0.03323918f, 
    -0.04963255f, 0.52191502f, 0.38876030f, 0.08726618f, 0.28132847f, -0.02200531f, -0.21771784f, -0.02687081f, 
    0.68829912f, -0.45729163f, 0.20152043f, -0.01945019f, 0.38410634f, -0.10125093f, 0.32165793f, -0.19248846f, 
    0.12547979f, -0.28624418f, -0.38136992f, -0.07612645f, -0.54305273f, 0.05470266f, -0.00243452f, 0.12005372f, 
    -0.21752176f, -0.23458295f, -0.39351901f, -0.09079319f, -0.01793360f, -0.31615382f, -0.33748904f, 0.17242108f, 
    0.02898042f, -0.15605852f, -0.19131526f, 0.47944257f, 0.32975262f, -0.07993989f, 0.03539765f, 0.24493958f, 
    -0.20140299f, 0.33498913f, -0.34190467f, 0.05287696f, 0.11663488f, -0.13144490f, -1.00569451f, 0.25986698f, 
    0.13625966f, 0.56003559f, 0.48408651f, 0.30309665f, 0.22903572f, -0.36574247f, 0.27329192f, -0.20889221f, 
    -0.17391464f, 0.08970591f, 0.14116962f, 0.01738950f, -0.28890035f, 0.64265949f, -0.05014879f, -0.13623589f, 
    0.05642610f, 0.03530058f, -0.12878864f, 0.46189296f, 0.38575298f, 0.08736548f, -0.44552144f, 0.00238138f, 
    0.48917463f, 0.35333297f, -0.18606895f, 0.55777091f, 0.17097443f, 0.01862525f, -0.16884120f, -0.32323948f, 
    -0.07150345f, 0.36139515f, 0.29701963f, 0.47910520f, 0.29369909f, -0.01446630f, 0.36409068f, -0.64323354f, 
    0.01127555f, -0.13403735f, -0.17334528f, 0.12229839f, -0.16453692f, -0.09330050f, -0.04706306f, 0.13007312f, 
    -0.16386208f, 0.00304478f, -0.05055670f, 0.06052840f, -0.04505995f, 0.11785736f, -0.13586123f, -0.07791846f, 
    -0.11036336f, 0.02343536f, -0.17812921f, 0.00707954f, 0.04470725f, -0.14842118f, -0.12956111f, 0.12795728f, 
    -0.06913128f, -0.14760800f, 0.09619299f, -0.13666938f, -0.01573699f, 0.08011627f, 0.07513164f, -0.08788790f, 
    -0.15337774f, 0.31201580f, -0.24833283f, -0.01367270f, -0.03438123f, -0.52609897f, 0.39513242f, 0.30442691f, 
    0.18562512f, -0.05305677f, -0.02622944f, 0.15780593f, 0.00181559f, 0.16501004f, -0.08972381f, 0.51883519f, 
    -0.01536046f, 0.16632646f, -0.35123184f, 0.44267249f, -0.18999240f, 0.11218623f, -0.29759803f, 0.05049763f, 
    0.13349095f, 0.50358874f, -0.13022371f, 0.19056550f, 0.20042197f, 0.22814858f, 0.34708935f, 0.02569533f, 
    -0.04583372f, 0.37906012f, -0.09650102f, 0.12312448f, 0.40191606f, -0.43432325f, 0.46810681f, -0.06430856f, 
    0.14623189f, -0.01114293f, 0.37883016f, -0.12622599f, -0.25863904f, -0.07606281f, 0.38697413f, 0.27356669f, 
    0.04828328f, -0.06669164f, -0.13311942f, 0.32449582f, -0.05666833f, 0.07808576f, 0.11826453f, -0.05378019f, 
    0.14406945f, 0.05683721f, -0.51840740f, -0.17665525f, 0.05954074f, -0.11231637f, 0.04837666f, 0.32920045f, 
    -0.11759747f, 0.46111077f, -0.17071375f, 0.11461740f, 0.16143824f, -0.45137194f, 0.53566051f, 0.01082147f, 
    0.32524928f, -0.15166911f, 0.30009761f, 0.25214323f, 0.21281515f, -0.10458462f, -0.30560493f, 0.76629186f, 
    -0.27686235f, -0.20840256f, -0.20706211f, -0.23175308f, -0.01045526f, 0.03178761f, -0.30748922f, 0.06764361f, 
    0.12753974f, 0.01491159f, -0.14825891f, -0.08322375f, 0.22750239f, 0.14498235f, -0.06815771f, -0.16593881f, 
    0.37200606f, 0.22415723f, 0.13621306f, 0.09444242f, 0.09151097f, -0.50671065f, -0.02754172f, 0.60128123f, 
    -0.04374886f, 0.18121782f, 0.11256507f, -0.26758721f, -0.14460595f, 0.02140296f, 0.51988715f, -0.05753725f, 
    0.32245955f, -0.73660147f, 0.18623266f, 0.77805650f, -0.08956689f, 0.01176761f, -0.22768399f, -0.33534992f, 
    0.09990301f, 0.03500108f, -0.10789035f, 0.29331613f, 0.15190881f, 0.23108938f, -0.02183623f, 0.43155631f, 
    0.03051955f, 0.60594928f, 0.18527955f, -0.09722829f, -0.36181855f, -0.21553801f, 0.42125362f, -0.07910878f, 
    0.06877404f, 0.24339239f, 0.01687664f, 0.25843540f, 0.22027017f, -0.16468816f, -0.13577253f, 0.69476402f, 
    0.28433228f, -0.36054721f, -0.24447282f, 0.42874971f, -0.03537583f, -0.31707084f, 0.14567748f, -0.07480739f, 
    0.08531578f, 0.06745999f, -0.47908896f, 0.02090828f, 0.51098597f, 0.52345693f, -0.26872087f, -0.21042918f, 
    0.21727242f, -0.31656384f, -0.43403912f, 0.01980124f, 1.21033752f, 0.39559850f, -0.23195767f, 0.21349047f, 
    0.14918904f, 0.20238258f, -0.34657982f, -0.23677541f, 0.10829691f, 0.04965873f, -0.04131278f, -0.32416755f, 
    0.14633438f, 0.39216888f, 0.21942055f, -0.15147024f, 0.23455764f, -0.19323155f, 0.03483833f, 0.42524004f, 
    -0.03792921f, 0.39397544f, 0.57337797f, 0.18630147f, 0.03218580f, 0.00002480f, 0.04624560f, 0.50106865f, 
    0.01789098f, -0.26518285f, 0.50827289f, -0.02398422f, 0.31358662f, 0.98410833f, 0.09739097f, -0.20345877f, 
    0.03454763f, -0.15852980f, -0.22149137f, 0.36692035f, 0.14384824f, 0.16287860f, -0.39886534f, -0.51047641f, 
    -0.23663886f, 0.41131216f, 0.32316405f, -0.58149874f, 0.30959076f, 0.05643599f, 0.36865881f, 0.47056589f, 
    0.02610257f, -0.07609752f, 0.49771115f, 0.11232904f, 0.21706466f, -0.25221050f, -0.13868532f, -0.09871113f, 
    0.03143100f, -0.20521350f, -0.28563982f, 0.00271801f, 0.10698813f, -0.39299828f, 0.15865962f, 0.00668814f, 
    0.22020167f, 0.26272261f, 0.42717883f, 0.33083856f, -0.03645136f, 0.01330696f, 0.31408468f, -0.05573516f, 
    -0.13679042f, 0.26488993f, 0.14630373f, -0.25786823f, 0.40468448f, 0.15477774f, -0.19186558f, 0.09500365f, 
    0.08419248f, -0.13235134f, 0.24035035f, -0.32920831f, -0.29239646f, -0.49279436f, -0.12785022f, 0.22156751f, 
    0.09034513f, 0.06433159f, -0.18422133f, -0.16833432f, -0.01582171f, 0.48050213f, 0.25801951f, -0.19912057f, 
    -0.11169019f, 0.02484446f, 0.26602334f, 0.02639735f, 0.03068304f, -0.11835936f, -0.23964514f, 0.22913200f, 
    -0.23577927f, -0.00436162f, -0.16932149f, -0.11680038f, 0.00670872f, -0.65504354f, 0.22983290f, 0.30218723f, 
    0.01516066f, -0.22806241f, -0.41608858f, -0.04165645f, -0.16844457f, -0.10842632f, 0.22674142f, 0.22041309f, 
    0.12552376f, -0.51051575f, -0.28873903f, -0.12705538f, -0.17824066f, -0.10326832f, -0.12996118f, 0.02244937f, 
    0.00993457f, 0.10194285f, 0.12543646f, 0.49951714f, 0.57349223f, -0.08865075f, -0.02061875f, -0.43929803f, 
    -0.16178255f, 0.48193750f, 0.19766147f, -0.32773685f, 0.38733280f, -0.00040094f, -0.41504112f, 0.22470947f, 
    0.14489387f, 0.28334758f, 0.65450579f, 0.22328411f, -0.20427488f, -0.87742186f, -0.28004119f, -0.11614630f, 
    -0.13639155f, 0.40965733f, 0.81764621f, 0.04643026f, -0.83075494f, 0.16611733f, 0.07349423f, 0.20990212f, 
    0.17696670f, -0.05921308f, 0.27276206f, 0.45002878f, 0.37883702f, -0.05656287f, -0.28223774f, -0.28943503f, 
    0.04561398f, 0.01243000f, 0.19665839f, -0.19795197f, -0.15126774f, -0.15546799f, -0.10278901f, -0.20928901f, 
    0.16667500f, -0.08565351f, 0.19173063f, 0.39033780f, 0.50945997f, 0.36080161f, -0.51388359f, -0.16842155f, 
    -0.19280691f, 0.03639232f, 0.12103093f, -0.11498043f, 0.14096414f, 0.04733744f, 0.11095895f, -0.24378116f, 
    -0.10398864f, 0.01057136f, -0.00961790f, 0.02871324f, 0.04091669f, -0.01760345f, 0.25837910f, -0.02510460f, 
    0.05446665f, -0.13834855f, -0.22609712f, 0.03013655f, 0.03516285f, 0.07608310f, 0.08000980f, -0.12140702f, 
    -0.09295380f, -0.17502964f, -0.16248153f, -0.03938599f, 0.12578954f, -0.04984981f, 0.01156037f, -0.22658512f, 
    0.39324397f, 0.04240118f, -0.16429399f, 0.12372977f, 0.45071101f, 0.19923533f, -0.23776381f, -0.01471808f, 
    0.23494616f, 0.66035497f, -0.16486211f, -0.10045764f, 0.06572341f, -0.13891619f, 0.16466807f, -0.31338823f, 
    0.70228028f, 0.05014037f, 0.23583916f, 0.21583296f, 0.27238455f, -0.35380051f, 0.62596089f, 0.00533503f, 
    0.10611343f, -0.03163545f, -0.04495594f, -0.13751718f, 0.02900133f, 0.16285469f, -0.30825087f, 0.21642706f, 
    -0.22203405f, 0.06574438f, 0.12746333f, 0.09120520f, 0.14921024f, 0.14999919f, 0.07726940f, -0.12735109f, 
    0.16625412f, 0.11429796f, 0.17646542f, 0.61542118f, 0.16967332f, -0.13731173f, -0.21439189f, 0.57494622f, 
    -0.02442546f, 0.18381780f, -0.30754787f, -0.03841446f, 0.09881222f, 0.01818074f, 0.34483153f, 0.30703789f, 
    0.16952658f, 0.25901294f, -0.17006609f, -0.12433672f, 0.12971427f, 0.04089539f, 0.22037844f, -0.40189800f, 
    0.14437045f, 0.33135471f, 0.16381994f, -0.09768017f, -0.17881505f, 0.06643642f, 0.21517707f, 0.19676279f, 
    0.02378053f, -0.04799033f, -0.12468371f, 0.31629956f, -0.24925700f, -0.03766892f, 0.31483451f, -0.08219407f, 
    0.09409972f, -0.43015859f, -0.28756824f, 0.38839018f, -0.19166838f, 0.06704927f, -0.15244614f, -0.12305538f, 
    -0.08551762f, 0.23365764f, -0.13537768f, 0.32603166f, 0.03196006f, 0.44275999f, 0.06036961f, 0.02507113f, 
    -0.20407379f, 0.28759527f, -0.32948887f, 0.11570888f, -0.06189003f, -0.08157784f, 0.03180039f, 0.29034054f, 
    0.33914560f, -0.21678346f, -0.02258742f, 0.09719568f, 0.17236900f, -0.00110368f, -0.76819438f, 0.43193308f, 
    -0.17396787f, 0.30961549f, -0.17460260f, -0.09678779f, 0.02527578f, 0.17728035f, -0.53689337f, -0.00734440f, 
    0.14269985f, 0.22958146f, 0.43496677f, 0.26331568f, -0.05578631f, 0.20069072f, 0.41576979f, -0.41595542f, 
    0.24527763f, 0.47149524f, 0.49217319f, 0.15654822f, -0.60250235f, -0.34772152f, 0.10105122f, 0.33791983f, 
    0.28745896f, -0.20570526f, 0.38955653f, -0.05042066f, 0.36540550f, -0.13700168f, 0.38423523f, -0.00193301f, 
    -0.05679341f, -0.39587417f, 0.25635090f, 0.27638176f, 0.22020714f, 0.09364061f, -0.22642002f, -0.08896276f, 
    0.13664448f, -0.15937690f, 0.12590593f, 0.34589818f, 0.33325484f, -0.06339097f, -0.73336315f, 0.19356659f, 
    -0.21960096f, -0.19896203f, -0.12834059f, -0.01455114f, 0.15078489f, -0.84479880f, 0.47808903f, -0.00681311f, 
    -0.11178087f, -0.45495179f, 0.43400604f, 0.22433080f, -0.30964777f, -0.07273876f, 0.29106182f, -0.36401102f, 
    -0.30290794f, 0.65899599f, 0.10447904f, 0.42120537f, -0.12834854f, -0.44052574f, -0.07361574f, 0.00030053f, 
    -0.15502414f, 0.45534423f, 0.10383660f, 0.40579996f, -0.06934677f, -0.51720721f, 0.58476871f, 0.15918300f, 
    0.16741064f, 0.28294528f, 0.53841084f, -0.01396205f, -0.19781257f, -0.78384483f, 0.36900702f, 0.36302850f, 
    0.30794573f, 0.04897551f, 0.31847042f, 0.00215142f, 0.06793062f, 0.07293928f, -0.19885895f, 0.19637963f, 
    -0.12620993f, -0.21218215f, -0.04981273f, 0.22988246f, 0.00700104f, -0.19273013f, -0.25898647f, 0.09880601f, 
    -0.11126903f, -0.07001502f, -0.25218832f, 0.28464028f, 0.48889744f, -0.03939055f, -0.40577883f, 0.00661267f, 
    -0.24174920f, 0.31071422f, 0.13809837f, 0.00720058f, -0.61736041f, -0.52048838f, -0.31166294f, 0.18351391f, 
    0.28691238f, -0.11836326f, 0.13494235f, -0.12291773f, -0.06227346f, -0.04753376f, -0.62549967f, -0.14026447f, 
    0.21172616f, -0.00050070f, -0.09735578f, 0.52061987f, -0.00279397f, 0.28103885f, 0.03803435f, -0.34501049f, 
    0.16174637f, 0.38651013f, 0.22651850f, -0.05490309f, -0.11468280f, 0.67125273f, 0.15418771f, -0.64564431f, 
    0.27320850f, 0.00253360f, -0.47117338f, -0.12234662f, 0.52986801f, -0.54407191f, 0.02622857f, 0.09732705f, 
    -0.21254684f, 0.12142786f, 0.03482249f, -0.60302174f, -0.13477883f, -0.03017792f, -0.00850475f, 0.09918202f, 
    0.06763868f, 0.13398322f, 0.39701992f, 0.19372584f, 0.16818516f, 0.30611932f, -0.57965690f, 0.00677463f, 
    -0.00056081f, 0.01031827f, 0.04972051f, 0.24052331f, -0.42634812f, -0.10051318f, -0.21680418f, 0.76870477f, 
    -0.06733887f, 0.01699213f, 0.16536042f, -0.10981534f, 0.23631707f, 0.15400766f, -0.07781144f, -0.03049354f, 
    -0.19140555f, 0.01977906f, -0.27829063f, -0.20539548f, 0.10359535f, -0.10465764f, -0.10743504f, 0.11208058f, 
    0.38377103f, -0.31892440f, 0.24959482f, 0.06241019f, -0.10359948f, 0.09617741f, 0.17040935f, -0.16424431f, 
    -0.14401957f, 0.04996734f, -0.10010698f, -0.16044138f, 0.06409700f, 0.02930569f, 0.08859151f, 0.07138646f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.08995172f, 0.33523443f, -0.02209703f, 0.01755054f, 0.16848154f, -0.04812254f, 0.37879348f, -0.04386558f, 
    0.01090446f, -0.09667140f, -0.05281669f, -0.49219221f, -0.17392664f, 0.10923211f, 0.08062986f, 0.37948176f, 
    -0.03526230f, 0.28513750f, 0.10905574f, 0.49576452f, 0.04134077f, -0.05931810f, 0.22521102f, -0.13585001f, 
    0.19491084f, 0.06034832f, 0.04940185f, -0.56054902f, 0.00680612f, 0.32244942f, -0.03573009f, 0.09471911f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.03796293f, -0.20187967f, -0.57805133f, -0.00652524f, 0.20694190f, -0.02301156f, 0.02878190f, 0.07020419f, 
    -0.21755649f, -0.06667458f, 0.24118875f, 0.19066727f, 0.34037110f, 0.12852095f, 0.25838700f, -0.49630696f, 
    -0.82234031f, 0.01305568f, 0.02405886f, -0.47236469f, -0.10578869f, -0.08167300f, -0.13608795f, 0.22994445f, 
    0.22686349f, 0.17210875f, 0.01041435f, -1.07627594f, 0.20618491f, 0.56005788f, -0.81304562f, -0.50614905f, 
    -0.07701352f, 0.09832331f, 0.05561529f, -0.04042300f, 0.24845506f, -0.28155735f, 0.31255430f, -0.45008391f, 
    -0.32645682f, 0.01271662f, 0.00177408f, 0.40860742f, 0.13934872f, -0.02021366f, -0.07100731f, 0.09381329f, 
    -0.31919417f, 0.28012273f, 0.15458666f, -0.42971259f, -0.36002803f, -0.10061210f, 0.14446138f, -0.15542616f, 
    0.05811146f, 0.17050174f, -0.14832225f, 0.30350846f, 0.01603132f, -0.34210479f, 0.29151443f, -0.21648221f, 
    0.08850951f, 0.19156820f, 0.74824005f, -0.05630743f, 0.28639969f, -1.34274268f, 0.24570689f, -0.03577967f, 
    0.05476913f, 0.03012240f, -0.31023628f, 0.03659514f, -0.03032407f, -0.93972051f, 0.19125549f, 0.10865002f, 
    0.18319592f, 0.22579610f, 0.08533301f, 0.30633309f, -0.52006686f, 0.01719995f, 0.23212090f, 0.35107675f, 
    -0.27108377f, -0.16010091f, -0.91318798f, -1.25827849f, -0.60991532f, -0.49949786f, -0.34852871f, 0.12011133f, 
    0.07080775f, -0.48736104f, 0.48336557f, -0.14534999f, -0.81898034f, -0.29707053f, -0.94885433f, 0.09855035f, 
    -0.00256542f, -0.19679746f, 0.12468880f, -0.63449985f, 0.35834175f, -0.47680223f, -0.09390789f, 0.09457116f, 
    0.19698893f, -0.05997437f, -0.16987169f, 0.26514816f, 0.32204747f, -0.13240856f, -0.49511197f, -0.07410379f, 
    -0.40552169f, 0.42365825f, 0.17747968f, 0.01708057f, 0.00621104f, 0.30816206f, 0.14655058f, -0.05588414f, 
    0.10931426f, 0.15524158f, 0.10219231f, 0.00787581f, -0.28114539f, 0.04830191f, -0.20029430f, 0.02077342f, 
    0.22965571f, -0.05659759f, 0.03865693f, -0.26497105f, 0.02420066f, -0.14082070f, 0.24359263f, -0.13503516f, 
    0.10810936f, -0.48170194f, -0.03766969f, -0.03309591f, 0.28624865f, 0.07144297f, -0.00323987f, 0.07753807f, 
    0.29514825f, 0.19763699f, -0.09420859f, -0.60783482f, 0.13186622f, 0.12546879f, -0.47663578f, -0.49373972f, 
    -0.15708031f, 0.02607648f, -0.59206355f, 0.12541886f, -0.01074035f, -0.05808601f, 0.00186264f, -0.09320964f, 
    -0.38288826f, 0.09333653f, 0.02485556f, 0.13997753f, -0.13108540f, 0.32069504f, 0.25791857f, 0.13297354f, 
    -0.40117431f, -0.07472431f, -0.54487759f, 0.09886961f, -0.10363078f, -0.01051193f, 0.21636687f, -0.33653501f, 
    -0.04263042f, -0.46882105f, 0.28866857f, 0.17743818f, 0.25442740f, -0.66635257f, 0.45303926f, 0.04284750f, 
    0.08606264f, 0.17213374f, -0.00253505f, 0.17118137f, -0.14223310f, 0.09684529f, 0.31744686f, -0.63449466f, 
    -0.15624624f, -0.08140343f, -1.08572483f, -0.58092517f, -0.31074318f, -0.00262691f, -0.07410342f, -0.30876121f, 
    0.18339178f, 0.33120957f, 0.27433243f, 0.33415103f, 0.42548001f, -0.12483724f, 0.04181739f, -0.41154453f, 
    -0.00036485f, -0.64186025f, 0.31997985f, -1.04419410f, 0.11161577f, -0.06160238f, -0.21728420f, -0.36023328f, 
    -0.03742324f, -0.66368771f, 0.03147648f, 0.06081738f, -0.34429705f, 0.18920520f, -0.55771005f, 0.06286687f, 
    0.15229864f, -0.12025888f, 0.41964126f, 0.41731587f, 0.18261239f, -0.02646850f, 0.35009190f, -0.67450237f, 
    -0.41957733f, -0.53732061f, -0.18571234f, -0.58805430f, 0.13063325f, 0.01579460f, -0.54766214f, 0.18214026f, 
    0.08264995f, -0.10132000f, -0.07704560f, 0.33826655f, 0.21097505f, 0.07504065f, 0.12632379f, 0.10539917f, 
    -0.14615029f, 0.22829826f, -0.82978588f, 0.11545585f, 0.51186419f, 0.66324705f, -0.16565907f, -0.51622015f, 
    -0.89713502f, -0.14767663f, 0.18247278f, 0.12010559f, -0.72120965f, 0.28734958f, -0.76195294f, 0.51867467f, 
    0.11571874f, -0.38025561f, -0.13643080f, -0.73872143f, -0.67643768f, 0.31847832f, 0.20414689f, -0.71978587f, 
    -0.21643502f, -0.35247171f, -0.66198349f, 0.18917118f, -0.41367012f, -1.03625059f, 0.50255919f, 0.32694548f, 
    -0.13549697f, 0.11972687f, 0.35293755f, -0.14964247f, -0.01208092f, 0.07057294f, 0.19480866f, -0.47181681f, 
    0.15437703f, -0.00302986f, -0.20041311f, -0.36981657f, -0.34904650f, 0.10709781f, 0.05198340f, -0.05663904f, 
    -0.27786526f, -0.46031377f, -1.10700643f, -0.39500877f, 0.26119772f, -0.08667117f, 0.26835772f, -0.25292325f, 
    -0.06627872f, -0.13287066f, 0.07172164f, 0.34745038f, 0.05877550f, 0.56094676f, -0.58587307f, 0.36880350f, 
    -0.04027492f, -0.30795348f, -0.83467352f, 0.10722337f, -0.37033111f, -0.52663374f, -0.06780907f, 0.42948496f, 
    0.32518145f, 0.09282847f, 0.01943963f, -1.00775003f, -0.44933203f, -0.17739551f, -0.65367228f, 0.39220607f, 
    -0.10803635f, 0.31402186f, 0.20282380f, 0.49942297f, -0.32939452f, -0.15307516f, 0.03395561f, -0.08500098f, 
    -0.19591230f, 0.19502652f, -0.23287380f, 0.11730159f, -0.43840969f, 0.02147279f, 0.23731574f, 0.17698245f, 
    -0.01029201f, 0.04688872f, -0.11096931f, 0.13401303f, -0.07918327f, 0.34001386f, -0.48971897f, 0.12953831f, 
    -0.07472301f, 0.10879716f, -0.49034449f, 0.27309284f, -0.22701715f, -0.38427061f, -0.76861352f, 0.21833535f, 
    0.49892446f, 0.31466478f, -0.30331963f, 0.34063658f, 0.12173802f, 0.00103904f, 0.11919488f, 0.07656409f, 
    -1.00305653f, -0.02789238f, -0.04908725f, -0.26748076f, 0.06202376f, -0.72615290f, -0.79241586f, 0.16629723f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.05775168f, -0.12040146f, -0.05629345f, -0.03800470f, -0.05847729f, 0.21626870f, 0.13445102f, -0.49157095f, 
    -0.19546586f, 0.15819131f, 0.36967260f, -0.15333940f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
