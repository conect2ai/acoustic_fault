#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.96212077f, 0.56802636f, -0.49603632f, -0.11435507f, 0.46108654f, -0.50255388f, 0.31230450f, -0.15767439f, 
    0.37959978f, 0.26051253f, -0.65227300f, -0.43651661f, -0.58053845f, 0.18877330f, -0.89331216f, 0.06975348f, 
    0.27423057f, 0.36376509f, 0.08062594f, 0.75967914f, 0.07266840f, -0.65744227f, 0.46327582f, -0.22450301f, 
    -0.26261947f, 0.29611719f, -0.08631482f, -0.44453305f, 0.05334318f, 0.60045421f, -0.85395885f, -0.51559389f, 
    -0.03429610f, 0.37316793f, 0.31308395f, 0.49932212f, -1.17912340f, 0.84533828f, 0.36464953f, -0.37143078f, 
    0.22715855f, 0.28606462f, -0.45625305f, 0.03557491f, -0.21468903f, -0.74862564f, -0.24585095f, 0.66330528f, 
    -0.12990531f, -0.70430851f, -0.42330632f, 0.09203456f, 0.12239204f, 0.04005355f, 0.01499933f, -0.42777243f, 
    0.58246779f, -0.94052261f, -0.84980786f, -0.51195574f, 0.24111138f, 0.48541090f, -0.50037867f, 0.06404456f, 
    0.39285153f, -0.81463903f, -0.20601581f, -0.81700295f, 0.23411791f, -0.54583305f, -0.33861312f, 0.01742346f, 
    0.43538848f, -0.84924835f, -0.40943274f, -0.18096615f, 0.83802962f, -0.09314483f, 0.30626550f, -0.36877921f, 
    -0.43117413f, -0.82550746f, 0.25992918f, 0.67029059f, -0.25732645f, -0.27119547f, -0.50297844f, 0.51346976f, 
    -0.18783793f, -0.39333370f, -1.02307081f, 0.49361804f, 0.61076540f, 0.34137547f, 0.17906553f, 0.09722997f, 
    -0.19261973f, -0.29108426f, -0.38696554f, 0.28557107f, 0.08045273f, -0.03576334f, 0.11180037f, 0.37329766f, 
    0.62223148f, 0.32259309f, 0.40271834f, -0.35703313f, -0.38923270f, 0.25821778f, -0.99249285f, -0.36607698f, 
    0.03479477f, 0.61818689f, 0.27091250f, -0.27868256f, 0.35266513f, -0.74821389f, -0.84533834f, -0.59598118f, 
    -0.87861967f, -0.14318162f, -0.46941969f, 0.32672074f, -0.30434144f, 0.21031249f, 0.88572413f, 0.63646764f, 
    0.59961605f, -0.58973491f, -0.17410974f, -0.38745239f, 0.17035674f, 0.14807582f, 0.15752494f, -0.38124907f, 
    0.06192940f, 0.98152328f, 0.60819024f, -0.48999012f, -0.21050079f, -0.55440438f, -0.30450818f, -0.12284491f, 
    0.89898682f, 0.74023181f, -0.82518756f, 0.66922271f, 0.27352396f, -0.24282011f, 0.08424441f, -0.03889577f, 
    0.28025818f, 0.13111642f, 0.39923146f, 0.82268929f, 0.64250177f, -0.03171048f, 0.11614007f, 0.19011706f, 
    0.39053634f, -0.19544771f, 0.34606794f, -0.33033621f, -0.01111265f, 0.05709808f, -0.28390419f, -0.65019363f, 
    -0.55325907f, -0.18620475f, -0.66844749f, 0.45023769f, -0.40500566f, 0.63342172f, -0.75462186f, 0.33034667f, 
    -0.49241424f, -0.12756601f, -0.27455592f, -0.40779877f, 0.34981933f, -0.90631288f, 0.70505118f, 0.39322600f, 
    -0.49710536f, -0.20176707f, -0.31298369f, 0.09416269f, 0.05131634f, 0.44093287f, 1.06692517f, 0.51850879f, 
    0.00929967f, -0.49121729f, 0.08803782f, -0.49217123f, 0.29749584f, 0.32603458f, -0.04768237f, -0.90449011f, 
    0.22308853f, 0.31490454f, -0.39544299f, -0.00112850f, -0.25911045f, 0.62084937f, -0.52336329f, 0.88180095f, 
    0.49149713f, 0.63544452f, -0.11109477f, 0.57531810f, -0.43726465f, 0.12789327f, 0.26763409f, -0.45852065f, 
    0.44756368f, 0.67092931f, 0.45151564f, 0.42562291f, 0.06905228f, 0.53891516f, -0.52008235f, 0.07525299f, 
    -0.34913674f, 0.87609905f, 0.65354484f, 0.04786349f, 0.06014878f, 0.43382585f, -0.02645374f, -0.55189127f, 
    -0.42131591f, -0.12197250f, -0.60778081f, 0.28779796f, 0.44269347f, 0.75602782f, 0.78038651f, -0.03360279f, 
    -0.30291221f, -0.53460950f, 0.26399976f, -0.23816657f, 0.80913639f, 0.89081234f, -0.48447728f, 0.47515386f, 
    -0.50573653f, -0.19178860f, 0.39005032f, -0.35437921f, 0.60850835f, 0.56568384f, -0.84193784f, -0.66154104f, 
    0.45648289f, 0.70580131f, -0.20950989f, -0.39241114f, 0.21315339f, 0.00555888f, -0.71932089f, 0.81193215f, 
    -0.86743116f, 0.53474551f, 0.08159468f, -0.04315339f, 0.10366027f, 0.46181586f, 0.88041407f, -0.15736103f, 
    0.57030636f, -0.40406325f, -0.41839296f, 0.40866208f, 0.54795402f, -0.29654217f, -0.07090773f, -0.63408756f, 
    0.32702869f, 0.38523406f, -0.41038281f, 0.15870285f, 0.66902864f, -0.40837914f, -0.19333526f, 0.10438024f, 
    0.18144843f, -0.82167673f, -0.55842280f, 0.26580742f, 0.41561112f, -0.71214736f, -0.08731287f, 0.41138113f, 
    -0.00213324f, -0.70941657f, -1.11686611f, -0.50288230f, -0.11882867f, 0.21760607f, 0.25522321f, 0.50059462f, 
    -0.10026151f, 0.01410939f, 0.18375081f, -0.00262052f, -0.01612503f, -0.15920383f, 0.40764806f, 0.03947239f, 
    0.40578243f, 0.72968274f, 0.10563739f, -0.62552482f, -0.15798268f, 0.02768770f, -0.04854039f, 0.77588463f, 
    -0.56083953f, 0.31091833f, 0.34640914f, -0.28941000f, 0.26778641f, -0.08369391f, 0.16946372f, 0.16316715f, 
    -0.23598009f, 0.74657732f, 0.28081012f, -0.49867851f, -0.46109375f, 0.41537637f, -1.10312450f, 0.71096444f, 
    -0.27944893f, 0.08741511f, 0.60893202f, 0.09352297f, -0.19374448f, -0.29122144f, 0.58784509f, 0.67973322f, 
    -0.05646151f, -0.47819778f, 0.37184629f, 0.61540401f, -0.23851371f, -0.17617650f, 0.12003536f, -0.05098012f, 
    0.62598598f, -0.40722170f, -0.63284981f, 0.20591415f, -0.20469218f, -0.26831308f, 0.06072037f, -0.33841959f, 
    0.96996123f, -1.06787908f, 0.53605878f, 0.38857535f, -0.75741100f, 0.40581185f, 0.00583532f, 0.03894391f, 
    -0.51603323f, -0.71631205f, -1.11351073f, -0.18562064f, 0.53573805f, 0.61393815f, 0.19620825f, -0.52613103f, 
    0.01525345f, -0.19903894f, -0.47565389f, 0.29626167f, 0.02505400f, -0.80692160f, -0.47285503f, 0.03860205f, 
    0.32403952f, 0.61952645f, -0.60920501f, 0.96773875f, -0.10384588f, 0.28807676f, -0.61631078f, -0.44727606f, 
    -0.43899366f, -0.12986696f, 0.16009785f, -0.02591653f, -0.42151451f, -0.79637247f, 0.56401706f, -0.62808448f, 
    0.60376358f, 0.49922797f, -0.27463362f, -0.16406733f, -0.07953471f, -1.12993586f, 0.71129483f, -0.13193460f, 
    -0.16815448f, 0.73927617f, -0.67698097f, -0.36068726f, 0.24808612f, 0.45637977f, -0.58579570f, 0.65306151f, 
    0.12316157f, 0.81423610f, -0.07121166f, -0.31189564f, 0.20231378f, 0.24862322f, -0.28295931f, -0.38332656f, 
    0.48362011f, -0.51512539f, 0.40459180f, 0.62861621f, 0.45765704f, 0.35119075f, 0.08878963f, 0.34952632f, 
    -0.81301188f, -0.97861409f, -0.67687833f, -0.02084453f, 0.60202646f, 0.76517367f, -0.11780225f, -0.16468699f, 
    0.13593563f, -0.61032724f, 0.38956505f, 0.74513918f, -0.54862499f, 0.50605744f, -0.05575667f, -0.12899607f, 
    -0.00837105f, 0.27246037f, 0.61519194f, -0.65763605f, -0.88518429f, -0.82487983f, -0.39048514f, -0.18408491f, 
    0.02749568f, -0.04342087f, 0.36053377f, -0.21438436f, 0.74741501f, 0.39830253f, -1.00278544f, 0.49406174f, 
    -0.32008529f, 0.13751839f, -0.30047077f, 0.05387617f, 0.58982974f, -0.09230319f, 0.02994706f, 0.85266131f, 
    -0.84141481f, -0.14839886f, 0.59571010f, 0.26428610f, -0.27379337f, 0.54880619f, 0.78009498f, 0.67067236f, 
    0.44841763f, -0.20021501f, 0.37755516f, 0.16124408f, -0.25066358f, -0.21423821f, 0.72074860f, -0.28571898f, 
    -0.51075643f, 0.66686058f, 0.80731171f, 0.56661904f, -0.04532722f, -0.19150071f, -0.57679105f, 0.59111297f, 
    -0.90734375f, 0.07696052f, -0.37290505f, 0.54235476f, -0.26266652f, 0.10044467f, 0.25798765f, 0.09534592f, 
    0.13008362f, -0.64629966f, -0.13587131f, 0.06552549f, 0.46646845f, -0.54967606f, 0.24798362f, 0.29460958f, 
    0.19363752f, 0.38824043f, 0.56709450f, -0.23961864f, -0.72839099f, -0.56490594f, -0.75822526f, 0.38655403f, 
    -0.30414304f, 0.16042963f, -0.41757077f, -0.06173879f, 0.32801938f, -0.89152122f, -0.55706626f, -0.50873697f, 
    -0.38898420f, 0.02593147f, -0.03296285f, 0.43773541f, 0.46007335f, 0.14764784f, 0.71978790f, -0.04095351f, 
    -0.66367662f, -0.42965612f, 0.06998378f, -0.30706978f, 0.71543115f, 0.74873030f, 0.54649150f, 0.41826034f, 
    -0.71954751f, -0.78290588f, 0.39410785f, 0.30734974f, 0.00966787f, -0.47077942f, -1.00971413f, -0.81835663f, 
    0.14031494f, 0.43434176f, 0.32096571f, -0.60537177f, 0.20318702f, 0.12629433f, 0.20049338f, 0.47298706f, 
    0.59592360f, -0.58294213f, 0.48905668f, 0.18728355f, 0.35736188f, 0.22724107f, 0.34559566f, -0.90016824f, 
    -0.31999213f, -0.43061665f, 0.36814263f, 1.07121241f, -0.06787880f, 0.14803939f, -0.14509283f, 0.00157950f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.00897972f, 0.19803941f, -0.00313627f, 0.03428474f, 0.04254586f, 0.03174616f, 0.05455224f, 0.19036497f, 
    -0.09946097f, -0.27149287f, -0.06509022f, 0.10979429f, 0.09481166f, -0.11652597f, -0.14292169f, -0.32961079f, 
    0.02818814f, 0.18244663f, -0.31091958f, -0.23578405f, -0.00384283f, -0.08722336f, -0.01352007f, -0.00031321f, 
    -0.12983976f, -0.14375314f, -0.01123277f, -0.21194217f, -0.14182654f, -0.08658901f, -0.05821088f, 0.00298867f, 
    0.20741308f, 0.14215153f, -0.36062583f, -0.15462276f, -0.21964522f, -0.17622103f, -0.01677320f, -0.05170354f, 
    -0.15001960f, -0.04609006f, -0.10696340f, -0.12759604f, -0.01674554f, -0.13397145f, -0.06421742f, 0.11662386f, 
    0.09617513f, 0.04643125f, 0.03930201f, -0.10345947f, -0.13679212f, 0.11145961f, -0.12818912f, -0.01003987f, 
    0.16560951f, -0.07881802f, 0.18126857f, -0.06150485f, -0.29463214f, 0.04295788f, -0.10923675f, -0.12991385f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.07009126f, 0.07767177f, 0.05893745f, 0.02728215f, 0.18504201f, -0.08054461f, 0.01725513f, 0.02826577f, 
    0.10685459f, 0.02132817f, -0.00353210f, -0.06301979f, 0.01633400f, -0.01038909f, -0.05193980f, 0.05257377f, 
    -0.07426452f, 0.02381509f, -0.04326473f, -0.04679314f, -0.07254191f, -0.29007855f, 0.07135346f, 0.08740912f, 
    -0.13609791f, -0.03199549f, -0.07499437f, 0.06901509f, 0.02464630f, 0.06692535f, 0.02890866f, -0.01309808f, 
    -0.03839717f, 0.03248177f, -0.04748795f, -0.07545639f, -0.04153149f, -0.01934880f, 0.01243839f, -0.06850705f, 
    -0.00477404f, 0.01112351f, 0.00156276f, -0.14404838f, 0.17203228f, -0.02580441f, -0.01375894f, -0.08118066f, 
    -0.03968601f, 0.07921283f, -0.07756756f, -0.01069028f, 0.02384750f, -0.11832503f, 0.05397994f, -0.08245880f, 
    0.05723418f, 0.00171792f, 0.02068717f, -0.07354393f, -0.15864255f, -0.04645648f, -0.11348249f, 0.07606596f, 
    -0.02941786f, 0.00408332f, 0.05104152f, -0.09829367f, 0.00814878f, -0.02690768f, -0.00054162f, -0.00347627f, 
    0.04525946f, -0.02144359f, 0.01551544f, -0.02447820f, 0.07222618f, -0.01693496f, 0.04873576f, -0.02740104f, 
    -0.00975392f, 0.11278390f, 0.08733746f, 0.07452114f, 0.17129602f, 0.02065363f, -0.03134236f, 0.00746991f, 
    -0.05978808f, -0.02752471f, 0.01788123f, -0.05116097f, -0.05096173f, -0.03120435f, 0.02026610f, 0.06342251f, 
    -0.05058459f, -0.01579275f, 0.05078126f, 0.06025385f, -0.40405983f, -0.00585853f, -0.14704540f, 0.06378239f, 
    -0.03165024f, 0.02465121f, -0.01927065f, 0.01371387f, -0.00416017f, 0.01640078f, 0.01773597f, 0.03430120f, 
    -0.01279997f, -0.01074930f, -0.08810765f, -0.08345496f, -0.03810847f, 0.05817296f, 0.04304375f, -0.01488042f, 
    0.07864162f, -0.16145861f, -0.07425267f, 0.12963897f, -0.18857558f, -0.08117734f, -0.02892560f, 0.00436243f, 
    -0.01197070f, -0.06837787f, 0.02620919f, 0.02661988f, 0.01541747f, -0.04451517f, -0.02425755f, 0.05189051f, 
    -0.01498999f, 0.00232656f, -0.02832690f, -0.01278788f, 0.11243442f, -0.04348476f, 0.05785177f, 0.03464592f, 
    0.04985449f, -0.02098086f, 0.02270779f, -0.01976557f, -0.07189305f, 0.01675111f, -0.03304545f, 0.02468832f, 
    0.01622828f, 0.04321126f, 0.01793786f, -0.00159866f, 0.00495411f, -0.05543736f, -0.14050174f, -0.01520090f, 
    -0.18383795f, 0.08286009f, 0.07107206f, 0.06986450f, -0.17929408f, -0.06297683f, -0.00170307f, -0.00729242f, 
    -0.10348461f, 0.09569309f, -0.01186213f, -0.02901817f, -0.00348629f, -0.04445411f, 0.00352822f, -0.06769364f, 
    0.00108028f, 0.05948085f, -0.06758440f, 0.06282055f, -0.29965141f, 0.09785445f, -0.08836471f, 0.04137691f, 
    -0.09540598f, -0.12057160f, -0.04737806f, 0.01848395f, 0.02794492f, 0.00040336f, 0.07645015f, 0.05230342f, 
    0.04777454f, 0.04217384f, -0.13973057f, 0.05231382f, -0.01099984f, -0.01390800f, 0.01576276f, -0.03894690f, 
    0.06466214f, 0.08541366f, 0.27710119f, 0.10079315f, 0.14693867f, -0.07767260f, -0.00317102f, 0.07713842f, 
    0.05820455f, 0.03406073f, 0.00327910f, -0.00602196f, 0.05380259f, -0.04524276f, -0.02842597f, 0.08391676f, 
    -0.03121799f, -0.08315855f, 0.04430625f, 0.05950715f, -0.06635709f, 0.04998242f, -0.07128444f, -0.17173204f, 
    0.00569671f, -0.06168623f, 0.01811401f, -0.07624179f, -0.06189359f, 0.01879436f, -0.01750114f, -0.04326135f, 
    0.04077138f, 0.05525147f, -0.00010442f, -0.01158201f, -0.04753849f, -0.04822668f, -0.03632448f, -0.06697452f, 
    -0.10225415f, 0.13445848f, -0.06458265f, -0.05681499f, -0.13810819f, -0.01158887f, -0.03747427f, 0.00061784f, 
    0.03091455f, -0.04031657f, -0.04664455f, 0.02289478f, -0.01068295f, 0.09401565f, 0.06038180f, -0.01842014f, 
    -0.01311669f, 0.01785844f, -0.08429814f, -0.12141921f, -0.33159408f, -0.36060441f, -0.14398696f, 0.04358071f, 
    -0.10892073f, 0.04260644f, -0.10292323f, 0.01318861f, 0.10162441f, 0.01463230f, 0.00718915f, -0.04475854f, 
    -0.08139119f, 0.03669995f, 0.05983612f, 0.01350994f, -0.03597720f, 0.00486363f, 0.01205106f, -0.01187042f, 
    0.12819691f, 0.18435806f, -0.01411551f, -0.15611140f, 0.00474861f, -0.12622869f, -0.11492445f, -0.12995148f, 
    0.05459949f, 0.02340319f, 0.02856866f, 0.01503847f, -0.07664280f, -0.01925665f, 0.04379314f, -0.02213861f, 
    -0.01054076f, 0.02834759f, 0.05480692f, -0.00558354f, -0.22762741f, 0.01211538f, 0.08331534f, 0.22210436f, 
    -0.14370725f, 0.00898458f, -0.12390955f, 0.09421478f, -0.00852937f, 0.00392304f, -0.00981173f, -0.04199933f, 
    -0.00853904f, 0.10198803f, -0.01096675f, 0.01162972f, -0.07780988f, 0.04856095f, 0.03888910f, 0.00522017f, 
    0.01424136f, -0.19047582f, 0.06002754f, -0.09818196f, 0.38005713f, -0.16698487f, 0.01333373f, 0.02160635f, 
    0.08319002f, -0.03124445f, -0.00872137f, 0.04784378f, 0.01247557f, 0.02587354f, -0.03121525f, 0.09157865f, 
    -0.06052319f, 0.07082003f, -0.05365869f, 0.02734820f, -0.21141358f, 0.01612930f, 0.07145807f, 0.01432219f, 
    -0.05522207f, -0.06562750f, -0.03695309f, 0.02402776f, -0.03331328f, -0.01095515f, 0.04989463f, 0.03147783f, 
    0.02787818f, 0.03060084f, -0.06540961f, -0.05267275f, -0.02753805f, -0.05955338f, -0.02737946f, -0.02020323f, 
    0.12839770f, -0.17621380f, 0.18920743f, 0.02091984f, 0.03800058f, 0.12051093f, -0.16193721f, 0.01763176f, 
    -0.00318751f, 0.01793318f, -0.04457143f, 0.04005402f, -0.00586801f, 0.10934249f, 0.03840386f, 0.07418492f, 
    -0.03477938f, 0.03219102f, 0.00327245f, 0.01156349f, 0.29920489f, -0.15531169f, -0.02146676f, 0.12382413f, 
    -0.12568085f, -0.05234609f, -0.02320686f, 0.04183420f, 0.02757591f, 0.04519879f, 0.02624076f, 0.10259286f, 
    -0.09228525f, -0.02488305f, -0.01050007f, 0.02555344f, -0.07271663f, 0.07337970f, -0.01963488f, 0.06002942f, 
    0.14608432f, -0.20322113f, 0.12029050f, 0.03582045f, -0.36407554f, 0.08667903f, -0.05693024f, 0.03244699f, 
    -0.07267412f, -0.03843090f, -0.14378124f, 0.07444131f, -0.04495427f, 0.07639386f, 0.05715187f, 0.01016655f, 
    -0.02422921f, 0.04429533f, -0.05148725f, -0.08693285f, 0.07441395f, 0.11679795f, 0.15603329f, -0.19236055f, 
    0.12555273f, -0.05795389f, -0.14971672f, -0.03126330f, 0.01676510f, -0.01556337f, 0.03082732f, -0.09641477f, 
    -0.06015281f, 0.07714460f, 0.01633722f, -0.00918793f, 0.06553166f, 0.04543379f, -0.04114040f, 0.04589072f, 
    0.06146931f, -0.12533051f, 0.01548583f, -0.03329066f, -0.38135976f, 0.07034545f, -0.02618198f, 0.02901709f, 
    0.07699521f, 0.05810037f, -0.07090281f, 0.03936487f, 0.06460979f, -0.01170320f, -0.06373634f, -0.00071319f, 
    -0.05436591f, -0.13979994f, -0.14680003f, 0.02826672f, 0.09438068f, 0.10051391f, 0.03435899f, -0.15007287f, 
    0.03126875f, -0.10347135f, -0.11401018f, -0.05331671f, 0.04361209f, -0.01145924f, -0.00007256f, 0.09541932f, 
    -0.02194344f, -0.03847210f, 0.05713790f, 0.02727934f, 0.01777633f, -0.01577359f, -0.00722400f, -0.00416591f, 
    0.06763949f, 0.06142560f, 0.04273576f, -0.04109421f, 0.12821475f, -0.07883231f, -0.14806630f, 0.01730395f, 
    0.02704974f, -0.04483572f, -0.00424197f, 0.06945952f, -0.01878214f, 0.01294971f, 0.00250445f, 0.08118400f, 
    0.05084913f, -0.09583422f, -0.05063060f, 0.08654038f, 0.10129894f, 0.04392938f, 0.04379243f, -0.06488597f, 
    0.22487055f, -0.09101427f, -0.08280025f, 0.02024630f, 0.03685676f, -0.00247985f, 0.06344195f, 0.08506788f, 
    0.04465553f, -0.05625923f, -0.02095132f, 0.04872185f, 0.04869943f, -0.04078064f, -0.02439312f, 0.07894477f, 
    0.25777099f, 0.04619905f, 0.21460509f, 0.00367416f, -0.02531025f, -0.02883873f, -0.07344445f, 0.01095689f, 
    -0.02585156f, -0.02451717f, -0.00966675f, -0.02762034f, -0.05540283f, 0.01514148f, 0.03769265f, -0.03923519f, 
    0.03548709f, -0.04320671f, -0.01881883f, 0.08522350f, -0.12780723f, 0.07748432f, 0.03546683f, -0.03513163f, 
    0.11033222f, -0.01549336f, 0.01073342f, -0.01202541f, -0.03989236f, 0.05368405f, -0.00518998f, 0.06585503f, 
    -0.00549493f, 0.02160224f, 0.01883220f, 0.05403106f, -0.01842091f, 0.05710304f, 0.01844023f, -0.13674387f, 
    -0.26399797f, 0.07808120f, 0.03486229f, -0.09324483f, 0.23188369f, -0.09245963f, -0.04336911f, -0.08420400f, 
    0.04467731f, -0.01746088f, 0.01824635f, -0.01826778f, 0.09098255f, 0.08199657f, 0.06966473f, -0.01913800f, 
    0.05835764f, -0.04131135f, -0.06280857f, -0.05887337f, 0.21046610f, -0.13689238f, -0.11568755f, 0.11291369f, 
    -0.25772855f, 0.00331736f, 0.00524833f, 0.08778220f, 0.02177321f, -0.07933631f, 0.00730481f, 0.00396084f, 
    0.01243113f, -0.01555684f, 0.04581171f, -0.08696924f, 0.03325274f, -0.01623599f, -0.00880247f, 0.03468780f, 
    0.20783617f, -0.03033070f, -0.00081175f, 0.01733229f, -0.06366279f, -0.07632679f, -0.05471485f, -0.08216508f, 
    -0.03294549f, -0.04530859f, -0.13080309f, -0.03148074f, 0.00568332f, -0.00568633f, 0.06438595f, -0.03736419f, 
    -0.00809705f, 0.02554702f, 0.04735979f, 0.04030189f, -0.16843461f, 0.10902866f, -0.00452563f, 0.12729777f, 
    0.16829669f, -0.00069245f, -0.02157729f, 0.01194515f, -0.00013890f, 0.00158666f, 0.10997684f, -0.00197981f, 
    -0.01325027f, 0.01105031f, 0.00863299f, 0.02391282f, 0.01688892f, -0.07943634f, 0.13348140f, 0.06756987f, 
    -0.14961840f, -0.07638724f, -0.02525130f, -0.04538755f, -0.08124604f, -0.06029001f, -0.06767853f, 0.07555857f, 
    -0.00232020f, -0.00039378f, -0.06077593f, 0.08451956f, 0.06308082f, -0.02449317f, 0.03875478f, -0.07925532f, 
    0.00435499f, 0.05307177f, -0.02268554f, 0.02994499f, -0.16539606f, 0.03153207f, -0.13132119f, -0.03738805f, 
    -0.24464123f, 0.04085471f, 0.01330896f, -0.01016043f, 0.03810415f, 0.02617108f, -0.03104819f, -0.01764642f, 
    -0.03603775f, 0.00818658f, 0.02314542f, 0.00920092f, 0.03540073f, -0.03487603f, 0.04727418f, -0.01510651f, 
    -0.19345571f, -0.04541769f, 0.00660794f, 0.09991775f, 0.00973371f, 0.04849230f, -0.00261365f, -0.10881612f, 
    -0.07501291f, 0.10032175f, 0.13704753f, 0.10611672f, 0.03765310f, 0.06869688f, 0.01922648f, 0.10756753f, 
    -0.03702183f, 0.00280753f, -0.05590994f, -0.01832318f, 0.00338028f, -0.00776724f, 0.19187935f, -0.00219413f, 
    -0.17690574f, 0.01293269f, -0.01070330f, -0.01831731f, 0.09461731f, 0.04499097f, 0.03550365f, 0.09177055f, 
    -0.03101178f, -0.01314621f, -0.01110533f, 0.07503561f, -0.03273471f, 0.02130657f, 0.02446822f, -0.04622252f, 
    0.07939366f, -0.09166862f, 0.07141974f, -0.02814034f, -0.07205964f, -0.05980274f, 0.00681968f, 0.01954435f, 
    -0.08473002f, 0.08903812f, -0.06999159f, -0.04150132f, 0.11060705f, -0.07845540f, -0.00682873f, -0.00955071f, 
    -0.04594425f, -0.02909732f, 0.04881594f, -0.05977490f, 0.10481400f, -0.03225394f, -0.10571744f, 0.09841918f, 
    -0.36410698f, -0.05499124f, 0.01131810f, 0.03878877f, -0.05859835f, 0.01342910f, 0.03106121f, 0.04212075f, 
    -0.06766696f, -0.01554285f, 0.01926871f, -0.05814562f, -0.00165611f, 0.00071502f, 0.05085753f, 0.11317771f, 
    -0.07661723f, 0.06307179f, -0.05346750f, -0.13129438f, 0.24073625f, -0.15182911f, -0.08959414f, -0.09515137f, 
    0.07132766f, -0.06193085f, 0.03629975f, -0.03700676f, 0.15014599f, 0.00534472f, 0.07817648f, 0.03128319f, 
    0.11622456f, -0.08553308f, -0.01376084f, 0.03795017f, 0.02143611f, -0.05137012f, 0.05755497f, -0.09298938f, 
    0.20641974f, -0.00647253f, -0.02164576f, -0.05079034f, -0.10404985f, 0.03434972f, -0.02543558f, 0.01757169f, 
    0.08061311f, -0.13214055f, 0.04898676f, -0.08802646f, 0.03800817f, 0.05073160f, 0.07806643f, -0.01712819f, 
    0.30266112f, -0.25301778f, 0.10115719f, 0.05680510f, -0.35272592f, -0.00089996f, 0.03361298f, -0.04993009f, 
    0.00400444f, 0.00201985f, -0.20468780f, 0.03133694f, 0.02129357f, 0.08224991f, 0.02934242f, 0.01471680f, 
    -0.03008033f, 0.02533406f, 0.06825246f, -0.02856986f, -0.16550896f, 0.16036855f, 0.08275770f, -0.08196022f, 
    -0.38095936f, 0.09230748f, 0.03782003f, -0.02416662f, 0.03311391f, -0.04135504f, 0.01410519f, -0.05960566f, 
    0.00176594f, 0.00650969f, -0.02273517f, 0.02844831f, -0.00375005f, 0.00393421f, 0.00604720f, -0.01560462f, 
    -0.22066449f, -0.03018618f, -0.01704406f, 0.12951976f, 0.03748681f, -0.01170159f, -0.02204417f, 0.01852318f, 
    -0.04027512f, 0.01435627f, -0.01655848f, -0.09277429f, 0.07826214f, -0.05222811f, -0.01900829f, 0.00596024f, 
    0.05941270f, -0.06346247f, 0.00557952f, -0.13370706f, 0.15713122f, -0.02369346f, 0.08809691f, 0.03570155f, 
    -0.00678106f, -0.00104356f, -0.06411374f, -0.06801412f, 0.07151864f, 0.04558781f, -0.05998661f, 0.00780257f, 
    0.01263858f, 0.03476728f, -0.00642775f, -0.00390951f, -0.03213915f, -0.02349898f, 0.05917207f, -0.04199033f, 
    -0.12047631f, 0.04327465f, -0.05680144f, 0.08677032f, -0.16337605f, -0.03071334f, -0.02641484f, 0.03866371f, 
    0.04515622f, -0.06345008f, 0.06807633f, -0.02185019f, -0.11999468f, -0.00659888f, 0.03032270f, -0.06468302f, 
    -0.01481863f, -0.01332022f, 0.05438979f, 0.02980141f, 0.29828960f, -0.01853609f, 0.11450236f, -0.13214195f, 
    0.03303520f, -0.02056848f, -0.00131679f, 0.02101190f, -0.02348429f, 0.02116450f, 0.01513529f, 0.06233814f, 
    -0.09560601f, 0.00039166f, -0.00029620f, -0.06712930f, -0.02765978f, 0.07786731f, 0.04855866f, 0.02115101f, 
    0.04522575f, 0.01513792f, 0.19031002f, -0.05012773f, -0.03984548f, -0.01857659f, -0.06085231f, 0.11384497f, 
    -0.06090927f, -0.03481292f, 0.01603608f, 0.08209983f, 0.04971668f, 0.04009137f, 0.07752560f, 0.00123157f, 
    0.00167061f, -0.09809001f, 0.01117953f, -0.05214251f, 0.21272758f, 0.05140769f, -0.01860603f, -0.21246235f, 
    -0.04712452f, 0.02501934f, 0.01935272f, -0.02514576f, -0.00844913f, -0.06875864f, -0.00796021f, -0.01471980f, 
    -0.01909962f, 0.07441337f, 0.11833923f, 0.04863729f, -0.00856628f, 0.03136099f, 0.01118055f, -0.05159892f, 
    -0.07094160f, 0.22609012f, -0.14247294f, -0.19166590f, -0.28331518f, 0.09483134f, 0.03355672f, -0.05018630f, 
    0.05751108f, -0.02965197f, 0.01783947f, -0.01678886f, -0.00533199f, 0.06225376f, 0.00021655f, -0.00057114f, 
    -0.08253771f, 0.00993471f, 0.03333346f, -0.00039583f, -0.13596021f, -0.02911858f, 0.09562653f, 0.06742265f, 
    0.08137988f, -0.04302666f, 0.00034099f, 0.04143577f, 0.04122340f, 0.00971710f, 0.02332328f, 0.00457423f, 
    0.02360967f, 0.06082913f, 0.00840549f, 0.02733413f, 0.04024349f, -0.01505695f, 0.04640273f, -0.02972900f, 
    -0.19794253f, -0.38229820f, 0.08918388f, 0.10561848f, -0.03315147f, 0.01160564f, 0.00872282f, 0.11463077f, 
    0.04505241f, 0.06193840f, -0.02447005f, -0.03371268f, -0.03494646f, 0.05431312f, 0.02628426f, -0.00919187f, 
    -0.07240766f, -0.00033586f, 0.02960709f, -0.09607434f, 0.03880482f, -0.02337435f, -0.01230500f, -0.05501640f, 
    0.02724945f, -0.10102551f, -0.00301079f, -0.03571397f, 0.00589260f, 0.00688804f, -0.00987659f, 0.03525796f, 
    0.01216679f, -0.09419587f, 0.05205296f, -0.07920542f, 0.00812060f, 0.04787168f, -0.01055685f, -0.06947753f, 
    0.21650572f, -0.41018718f, 0.11778369f, -0.05130747f, 0.01379217f, -0.10035742f, 0.09712323f, -0.00228038f, 
    -0.00747445f, 0.01069740f, -0.08816097f, -0.00159594f, 0.01362998f, 0.07486212f, 0.03846223f, 0.11131591f, 
    -0.01854412f, 0.03717494f, 0.00199320f, 0.03254414f, 0.00056146f, 0.02262430f, 0.02976609f, -0.09171753f, 
    0.08892322f, -0.15128988f, -0.15282460f, 0.02604197f, -0.02868888f, 0.00099030f, 0.01373845f, 0.01558153f, 
    -0.01102426f, -0.01441919f, 0.03618483f, 0.01117043f, 0.00137759f, -0.03090047f, -0.05987220f, 0.06487437f, 
    0.10250751f, 0.20772874f, 0.06323673f, -0.06788420f, 0.08984518f, -0.01770638f, 0.00557554f, -0.00128264f, 
    0.01195991f, -0.03058802f, -0.04125775f, 0.00855562f, -0.00474960f, -0.04910118f, -0.02031072f, 0.06051086f, 
    0.01315784f, 0.02691154f, -0.01662338f, 0.00564528f, 0.06221092f, -0.14018962f, 0.07436321f, 0.06234170f, 
    -0.18215330f, -0.05683663f, -0.06786523f, -0.01760642f, -0.04880068f, 0.05283596f, -0.01588917f, 0.09620035f, 
    -0.01587970f, -0.02928811f, 0.01971003f, -0.01128373f, -0.07381205f, -0.03993272f, 0.03058993f, 0.00581793f, 
    -0.14956625f, -0.11539643f, -0.03773575f, 0.05180588f, -0.08085451f, -0.11524285f, -0.07714933f, -0.01736369f, 
    -0.01268957f, 0.00027958f, -0.00056536f, 0.03288764f, 0.01147659f, -0.02871297f, -0.01319013f, -0.02566966f, 
    -0.00427682f, 0.02972513f, -0.03890150f, 0.01355769f, 0.04662359f, 0.01901074f, 0.12269485f, 0.06697877f, 
    0.06167317f, -0.06217676f, -0.00775051f, -0.03333126f, 0.03389630f, 0.05581336f, 0.08835930f, -0.02788635f, 
    0.04729245f, -0.01494069f, 0.01341437f, 0.02808861f, -0.07619251f, 0.06910942f, 0.00724009f, -0.11291023f, 
    -0.02721576f, -0.03038562f, -0.08672569f, 0.09798912f, -0.01685319f, -0.00148188f, -0.00790789f, -0.04704426f, 
    -0.00092765f, 0.03686419f, -0.02959898f, 0.02436998f, -0.07941698f, -0.00555338f, -0.07781244f, -0.00583367f, 
    0.00382448f, 0.04639927f, 0.07819217f, -0.01449112f, 0.13236772f, -0.06816120f, 0.06054413f, 0.02697738f, 
    0.13668175f, 0.04793425f, -0.17171425f, -0.01301318f, 0.03587009f, 0.01278896f, -0.04318492f, 0.05407902f, 
    -0.02820973f, 0.09204790f, -0.08280221f, -0.01878565f, 0.04964424f, -0.00715876f, -0.05606661f, 0.03831689f, 
    -0.00475920f, 0.05397495f, 0.06222315f, -0.16487953f, 0.01834161f, -0.12906581f, -0.06308375f, 0.03381863f, 
    -0.00891542f, -0.06182595f, 0.03125621f, 0.02836968f, -0.01355327f, 0.01531723f, -0.06233260f, 0.07269318f, 
    0.00955547f, 0.07742894f, 0.01751716f, -0.04581580f, 0.01566237f, 0.08089661f, -0.20187680f, -0.16651101f, 
    -0.28854492f, 0.00903385f, 0.02507231f, 0.04966806f, -0.01189181f, -0.04140992f, 0.07568638f, -0.00223142f, 
    0.02342252f, 0.00547230f, 0.02409494f, -0.01673852f, -0.02428234f, 0.05085792f, -0.07079396f, 0.05249158f, 
    0.06678256f, 0.02482957f, -0.06561475f, -0.00058412f, 0.03070696f, -0.00596063f, -0.07201482f, -0.13055940f, 
    0.01409502f, 0.01044164f, -0.02106406f, -0.10166193f, 0.06126007f, -0.03953715f, 0.02182546f, -0.14304379f, 
    -0.00873208f, 0.00057448f, -0.08633247f, -0.03188427f, 0.41153333f, 0.21525560f, 0.23058617f, -0.20667675f, 
    -0.26435131f, 0.01530862f, 0.03601972f, -0.05340837f, 0.04847488f, -0.09799886f, -0.00858720f, -0.02018527f, 
    -0.03676075f, 0.05972937f, 0.07993664f, 0.10091457f, 0.05419941f, 0.06505019f, -0.00972147f, -0.01887851f, 
    0.32864028f, -0.12352180f, 0.07568782f, -0.13687029f, 0.05192728f, -0.00505399f, -0.09550671f, -0.01975864f, 
    -0.03741325f, -0.03884802f, 0.00974953f, 0.06815951f, -0.00197444f, -0.01242948f, 0.09355538f, -0.07198030f, 
    -0.02229491f, -0.03111590f, -0.03850513f, 0.00586920f, 0.19608636f, -0.26202315f, -0.05704045f, -0.01121396f, 
    -0.00493670f, 0.04122526f, -0.02135232f, 0.04082920f, 0.04197257f, 0.09130388f, 0.02873837f, 0.02674499f, 
    0.02956512f, -0.02160715f, 0.10043148f, 0.08432683f, -0.05085109f, 0.00002526f, -0.04348330f, -0.03295928f, 
    0.11127539f, 0.12052456f, -0.07956321f, -0.09655795f, 0.00223747f, 0.05016269f, -0.01044795f, 0.02460763f, 
    0.06397082f, 0.02305629f, 0.01184143f, -0.01740249f, -0.02488797f, 0.12267718f, -0.01783664f, 0.03993972f, 
    0.05284134f, 0.03343134f, -0.02016593f, 0.03778552f, -0.23782137f, -0.16598447f, -0.01370229f, -0.05407019f, 
    -0.07429355f, 0.01608500f, -0.08062555f, -0.05197868f, 0.07392296f, 0.04988246f, -0.02528731f, 0.03832114f, 
    -0.00276835f, 0.01753563f, -0.01685419f, -0.03593316f, -0.05881540f, -0.01987449f, -0.00388519f, 0.00759973f, 
    -0.24850453f, -0.05445052f, -0.25317463f, -0.25839847f, -0.09969743f, 0.07265386f, 0.15203404f, -0.00789091f, 
    0.01204365f, -0.03220614f, 0.02316018f, 0.04532231f, 0.07593587f, -0.03312279f, 0.01817632f, -0.02263746f, 
    -0.03413339f, 0.08720393f, -0.08439840f, -0.07934609f, -0.09553749f, -0.02934499f, 0.07908873f, 0.01882198f, 
    -0.30128866f, 0.02420058f, -0.01326822f, -0.00515742f, 0.03548867f, -0.01215257f, -0.04084576f, -0.01591367f, 
    0.03321425f, 0.03323532f, 0.02222949f, -0.02554868f, -0.06531149f, -0.09530768f, -0.13170233f, -0.00714778f, 
    -0.34183973f, -0.02619792f, -0.05598581f, 0.02780417f, -0.24801822f, 0.06675266f, 0.05339690f, -0.03196258f, 
    0.02515565f, 0.00019489f, -0.05303846f, -0.04731946f, 0.00208507f, 0.05481879f, -0.04188986f, -0.03954887f, 
    -0.05720019f, -0.11322726f, -0.06885047f, -0.02516326f, -0.09813643f, -0.10305090f, 0.02602313f, -0.23653653f, 
    0.10580893f, -0.08157181f, -0.04444382f, 0.03987304f, 0.12839708f, -0.08704193f, 0.00378828f, -0.06500836f, 
    -0.04688155f, -0.01819232f, -0.09686676f, -0.08507110f, 0.00610747f, -0.03175258f, 0.19020918f, -0.19177918f, 
    0.31258264f, -0.36225736f, -0.12453094f, -0.12191194f, 0.06333817f, -0.00159773f, -0.03114106f, -0.04591696f, 
    -0.02035740f, -0.02233164f, 0.16205539f, 0.06193372f, -0.08533502f, -0.02822727f, -0.05716435f, 0.05698610f, 
    -0.05508343f, -0.09446613f, -0.06466798f, -0.01518086f, -0.15955423f, -0.22096102f, -0.31753102f, -0.12824658f, 
    -0.21037740f, 0.05364418f, 0.07595064f, -0.05537933f, 0.02035611f, -0.01841463f, -0.11681484f, -0.05912630f, 
    -0.08249117f, -0.05179557f, -0.01226409f, 0.00475107f, -0.08790821f, 0.00538721f, -0.09876695f, -0.00476428f, 
    -0.22002392f, 0.03699049f, -0.25792646f, -0.08445363f, 0.04469835f, 0.07928941f, 0.00977926f, 0.00004962f, 
    -0.06320865f, -0.01314014f, 0.03563951f, 0.09713574f, 0.01253774f, -0.01897543f, 0.02654715f, 0.09062567f, 
    -0.14469197f, 0.11524162f, 0.00031117f, -0.04924729f, 0.19731551f, -0.00680305f, 0.07027322f, 0.05513052f, 
    0.04793565f, -0.00152666f, 0.00636284f, 0.07551862f, 0.06757230f, -0.05398270f, -0.00385818f, 0.01086963f, 
    -0.08205906f, -0.02477169f, -0.09717722f, -0.05211467f, 0.03466353f, 0.06085276f, 0.03650841f, 0.13958248f, 
    0.25039658f, 0.04755471f, -0.08581296f, -0.02351912f, 0.03373916f, 0.03623318f, 0.01136972f, 0.03744446f, 
    0.02169265f, 0.07190406f, 0.01870289f, -0.05677741f, 0.02470802f, -0.08470278f, 0.04506856f, -0.00358796f, 
    0.02436697f, 0.02374118f, 0.03087074f, 0.12927806f, 0.23186480f, 0.02072619f, 0.02403606f, 0.06112335f, 
    -0.09519693f, 0.05666960f, 0.05585780f, 0.12887961f, 0.06622303f, 0.05206029f, -0.04966438f, -0.04318805f, 
    0.00417247f, 0.09729169f, 0.03357560f, 0.07597699f, -0.02279743f, -0.11734606f, -0.17526622f, -0.25332701f, 
    0.18702991f, 0.02658867f, 0.01681117f, 0.16059287f, 0.05695195f, 0.01201593f, -0.06258295f, 0.02278907f, 
    0.02942436f, -0.00885468f, 0.01719258f, -0.00607872f, 0.03598819f, 0.09413556f, 0.05365889f, 0.04620691f, 
    0.02655578f, -0.04898871f, -0.04963886f, -0.02042601f, 0.08245002f, 0.04655593f, -0.16928832f, -0.06252621f, 
    -0.10221789f, -0.19541697f, 0.04431691f, 0.03659149f, -0.09478564f, 0.14090429f, -0.03433111f, 0.04190433f, 
    0.00939593f, -0.03178589f, -0.03891324f, 0.06468175f, -0.12541598f, -0.04690957f, 0.05268970f, 0.09181821f, 
    0.19906707f, -0.18875539f, 0.22862749f, -0.10229001f, 0.00989064f, -0.01266654f, -0.09270751f, -0.01241408f, 
    -0.02819353f, -0.04518329f, -0.08870224f, -0.00717935f, -0.01382507f, 0.05911631f, 0.05844476f, -0.09352352f, 
    0.02842581f, -0.10441168f, 0.05531300f, -0.03329075f, 0.05451280f, 0.09178354f, 0.08335386f, 0.01068790f, 
    0.09113604f, -0.09805637f, 0.04114489f, -0.00962113f, -0.05601661f, 0.07304270f, -0.04620809f, -0.01119620f, 
    0.01439380f, -0.08638903f, 0.02847436f, -0.06246981f, 0.07485107f, 0.02450230f, 0.02922835f, 0.14872776f, 
    0.15910605f, -0.01132161f, -0.04089691f, -0.11665361f, 0.05328741f, -0.06304925f, -0.02199765f, 0.00603272f, 
    -0.02051214f, -0.02509634f, -0.07646489f, -0.20070416f, 0.04404810f, -0.08024783f, -0.07083547f, -0.12350281f, 
    -0.04723585f, -0.08157606f, 0.06956400f, 0.15994559f, 0.11724798f, 0.00502970f, -0.12197023f, 0.08059677f, 
    0.10510030f, 0.08052204f, -0.06986808f, 0.03550924f, -0.01682750f, -0.03267683f, 0.05575956f, -0.04635905f, 
    -0.05012948f, -0.06741566f, -0.09165314f, -0.09958139f, -0.13595580f, -0.06695467f, -0.00746595f, 0.07408454f, 
    -0.03151135f, 0.08662554f, 0.04603929f, -0.01715827f, -0.19432804f, -0.18987265f, 0.03526186f, 0.03063826f, 
    0.00644762f, 0.09859245f, 0.11434230f, -0.06452320f, 0.05067593f, -0.08007085f, 0.07696697f, -0.09798739f, 
    0.02538134f, -0.12632589f, 0.13902846f, 0.11158941f, 0.16787420f, 0.15738483f, -0.06462632f, 0.03838091f, 
    0.15549342f, 0.00632662f, 0.00173841f, 0.03676194f, -0.00196637f, 0.01138839f, 0.02214511f, -0.05720000f, 
    0.08077700f, 0.00187069f, 0.15339954f, 0.04187340f, 0.01059778f, 0.00710469f, -0.02651186f, -0.05372404f, 
    0.18368123f, 0.01184417f, 0.09273398f, -0.00560488f, -0.20106222f, 0.06928177f, 0.06234572f, 0.05855859f, 
    0.02308021f, 0.01525270f, 0.00367876f, -0.06105480f, 0.04638673f, 0.02349477f, -0.04066106f, -0.07195789f, 
    0.18070138f, 0.05024843f, 0.09736425f, 0.15974316f, 0.12453851f, 0.09389009f, 0.09954819f, 0.07717814f, 
    0.22979629f, 0.00165758f, -0.03622363f, -0.00400034f, -0.04343496f, -0.00594647f, 0.06020563f, -0.05101295f, 
    -0.01470729f, -0.01533909f, -0.04654318f, -0.06770526f, 0.12771592f, 0.03312466f, 0.00165653f, 0.04112207f, 
    0.14044872f, 0.15155356f, 0.07016009f, 0.10534125f, 0.18729204f, -0.03961651f, 0.02105381f, -0.00537217f, 
    -0.00963111f, 0.04546768f, 0.00011659f, 0.00553469f, -0.02063132f, -0.06495447f, -0.07191652f, -0.00250290f, 
    0.01611305f, 0.00855777f, 0.04580336f, -0.09303749f, 0.19569200f, 0.09267236f, 0.17316939f, 0.08546297f, 
    0.13901596f, -0.04161597f, -0.05209858f, 0.01688158f, 0.02312633f, 0.00270570f, -0.05790718f, -0.02455196f, 
    -0.14361334f, 0.02540893f, -0.03148779f, -0.06153816f, 0.01924198f, 0.03075761f, 0.02614840f, -0.01570523f, 
    -0.26800779f, 0.02173184f, 0.00724753f, 0.04389066f, 0.12449884f, -0.00693153f, 0.06315965f, -0.01545652f, 
    -0.07083733f, -0.01585759f, 0.05329433f, 0.13589112f, 0.01637241f, -0.04619237f, -0.00052731f, 0.04684154f, 
    -0.06320582f, 0.02481912f, 0.05834562f, -0.04449640f, -0.07459726f, 0.15768307f, -0.10704932f, 0.02943765f, 
    0.11598998f, -0.01502552f, 0.03971117f, 0.07488851f, -0.02938028f, 0.13209890f, 0.07238803f, -0.08788704f, 
    0.06477374f, -0.00871141f, -0.09613190f, -0.09090547f, 0.04310470f, 0.05573542f, -0.13009661f, 0.10308962f, 
    0.36865887f, -0.12772970f, 0.09663703f, -0.16306143f, 0.02384380f, -0.04125562f, 0.00988603f, -0.14828248f, 
    0.07209811f, -0.10239635f, -0.04778162f, 0.03022338f, -0.15510330f, 0.07526090f, 0.01773434f, -0.05241144f, 
    -0.02257530f, 0.06957845f, -0.01047132f, 0.04118557f, -0.42562285f, -0.01725570f, -0.03290737f, 0.00991461f, 
    0.00367108f, -0.01700488f, -0.06973696f, -0.10687678f, -0.02217751f, -0.02676048f, 0.09070428f, 0.06506547f, 
    -0.08126529f, 0.03086345f, 0.00328862f, -0.06521975f, -0.05869971f, 0.00315121f, 0.02065500f, 0.05287042f, 
    -0.01207001f, 0.05755740f, 0.06769439f, 0.06253091f, -0.08522203f, 0.01659948f, -0.05307728f, 0.05278452f, 
    0.00991090f, 0.02399494f, 0.06835800f, 0.06172529f, -0.04278212f, 0.00531591f, -0.08827220f, 0.07771142f, 
    -0.12034732f, -0.00335892f, -0.00213740f, -0.03765673f, -0.04817655f, -0.01296739f, -0.10811320f, -0.14636669f, 
    -0.20533268f, 0.00410419f, 0.03948075f, -0.01945410f, 0.02394937f, -0.04719931f, -0.01053192f, 0.02792956f, 
    -0.03470679f, 0.00420196f, 0.00746778f, 0.06600082f, -0.05748307f, 0.09682985f, 0.01503572f, -0.01616963f, 
    0.23548970f, -0.25201115f, -0.10188133f, -0.02873377f, -0.05896907f, 0.04543982f, -0.01686605f, -0.02299863f, 
    0.10061148f, 0.04696283f, 0.01277016f, -0.05225275f, 0.03004945f, 0.01430677f, -0.01440446f, 0.18338799f, 
    0.06575118f, -0.04480387f, -0.01015684f, -0.01343506f, 0.27848437f, 0.04837992f, -0.09435776f, 0.09759412f, 
    -0.14341144f, -0.03993585f, 0.06013271f, -0.02426662f, 0.07053184f, 0.03464605f, 0.00570030f, -0.05933416f, 
    -0.02683282f, 0.07068887f, -0.03923313f, 0.12857030f, 0.06957380f, -0.02585037f, 0.01401348f, -0.03276278f, 
    0.05260222f, -0.00681159f, 0.01507615f, -0.02665463f, 0.00194984f, -0.16475315f, -0.01543663f, -0.02651245f, 
    0.02967497f, 0.08212747f, 0.01852015f, -0.02398104f, -0.05130349f, -0.04938727f, -0.08280861f, 0.02152454f, 
    0.04286462f, -0.04181119f, -0.01766728f, 0.09666435f, -0.23473655f, -0.03547300f, -0.15913199f, 0.02139541f, 
    0.06550954f, -0.08174993f, -0.03594097f, -0.01774635f, -0.00226746f, 0.11312075f, -0.00740482f, -0.12378461f, 
    0.00168091f, -0.02397916f, -0.04505879f, 0.03657825f, 0.07307579f, -0.03266435f, -0.07246585f, 0.01578736f, 
    -0.13744023f, 0.12662859f, 0.04796468f, 0.10043851f, 0.17807746f, -0.03033010f, -0.08509557f, 0.02829054f, 
    0.01490742f, 0.03395091f, 0.06577318f, 0.06943315f, -0.07207328f, -0.01235649f, -0.01963368f, -0.01763780f, 
    0.00726504f, 0.00383760f, 0.04610394f, 0.07471315f, -0.14463854f, -0.06357075f, 0.02451092f, 0.07270872f, 
    -0.00305286f, -0.07862759f, -0.00879713f, 0.01469659f, 0.04633202f, 0.01714546f, 0.01239408f, -0.00233562f, 
    -0.00540496f, 0.05524652f, -0.08710820f, 0.03854035f, -0.05433627f, -0.01196991f, 0.05893040f, -0.08970027f, 
    0.28229496f, 0.14931291f, 0.06834787f, 0.04396277f, 0.02607765f, 0.02179260f, -0.07196461f, -0.03106313f, 
    0.02249726f, -0.01852954f, -0.02235543f, 0.03432155f, -0.13422161f, 0.10766884f, -0.03830721f, 0.01241424f, 
    -0.04499189f, 0.08946849f, -0.00436486f, -0.00158177f, 0.03510820f, 0.02276680f, -0.18800525f, -0.27457225f, 
    0.01933458f, -0.04548487f, -0.00206837f, 0.05253585f, 0.06548576f, 0.05573603f, 0.01353564f, -0.09822593f, 
    -0.05081842f, 0.16843399f, -0.10310526f, 0.01879679f, 0.00798324f, -0.00138656f, 0.01620258f, -0.03339202f, 
    0.09572489f, 0.11191910f, 0.12371930f, -0.08253861f, 0.05128403f, -0.05643405f, 0.00742731f, 0.04684949f, 
    0.02974166f, 0.00815370f, 0.09038772f, 0.00018836f, 0.09064971f, -0.00206704f, -0.02710342f, 0.06774090f, 
    -0.05453087f, -0.04175799f, -0.01988267f, 0.03913438f, 0.21188386f, -0.05447780f, -0.19420601f, 0.05880935f, 
    -0.33182415f, 0.01540656f, -0.02453323f, 0.02275099f, -0.03407861f, -0.01238159f, 0.08451869f, 0.10193456f, 
    -0.00185128f, 0.04989010f, 0.00150486f, 0.06873905f, 0.06682181f, -0.01702706f, -0.05351380f, 0.10464149f, 
    -0.11317999f, -0.16641264f, -0.16007519f, -0.02374661f, -0.14523405f, 0.04899015f, -0.03299257f, -0.05046628f, 
    0.02432540f, 0.01349557f, -0.00236912f, 0.01582331f, -0.01899350f, 0.05623747f, -0.08453424f, -0.10229821f, 
    -0.02665432f, 0.06912191f, -0.08692403f, -0.03735450f, 0.22000329f, -0.11517018f, -0.01258953f, 0.06783848f, 
    -0.00870221f, 0.09071716f, -0.03610938f, 0.04065467f, 0.02460732f, -0.08196343f, 0.04964057f, -0.01513634f, 
    -0.00681096f, 0.02543073f, 0.05356668f, 0.03701697f, -0.05885700f, -0.08516741f, -0.10141415f, 0.03199554f, 
    -0.17134857f, -0.01271083f, -0.03085500f, -0.00307193f, -0.12611450f, -0.02814703f, -0.00632706f, -0.03375022f, 
    -0.07911391f, -0.00060346f, 0.08344141f, 0.02593764f, -0.08509146f, -0.06102629f, -0.02715512f, -0.04076306f, 
    -0.10510413f, 0.04182201f, -0.13944839f, 0.08720987f, -0.47752988f, 0.02718625f, -0.06737087f, -0.22018133f, 
    0.17309323f, -0.06741678f, 0.05262792f, 0.01371001f, -0.04804198f, 0.08449386f, 0.01529336f, -0.08159479f, 
    0.12075758f, -0.05495533f, 0.04336208f, -0.00524274f, 0.00590787f, 0.04415238f, -0.06182066f, -0.07283980f, 
    -0.27378657f, -0.17502689f, 0.03685194f, -0.05274869f, 0.14290161f, 0.02003074f, -0.00339524f, -0.02578623f, 
    -0.04909037f, 0.01928855f, -0.01704104f, 0.09780023f, -0.10072073f, -0.04456571f, -0.05729368f, 0.02943742f, 
    -0.03236059f, 0.02505733f, -0.01515672f, 0.08081517f, 0.05072266f, 0.04746089f, -0.01760579f, -0.00611798f, 
    -0.01267290f, -0.01744461f, 0.04534115f, 0.03761234f, -0.05094716f, -0.00183836f, 0.02796022f, 0.01865947f, 
    -0.00695007f, -0.09514775f, -0.01334704f, 0.08673626f, 0.02554170f, 0.02951746f, 0.02082354f, 0.08022353f, 
    0.19309911f, 0.00862796f, -0.09632740f, -0.04089280f, -0.29885164f, -0.10765680f, -0.03311731f, -0.02488897f, 
    -0.02411756f, 0.09589441f, -0.00076846f, 0.00270491f, -0.01650002f, 0.00230751f, 0.05995508f, 0.04279342f, 
    0.08656549f, 0.00813849f, 0.01999757f, 0.05533604f, -0.19470151f, 0.07035495f, -0.15739594f, -0.19141743f, 
    0.11522406f, -0.03063040f, 0.06614559f, -0.00856072f, -0.08598956f, -0.02552011f, 0.01728348f, -0.03738927f, 
    0.04192519f, 0.02893780f, 0.00982398f, -0.01309221f, 0.00636781f, 0.02240474f, -0.10998202f, 0.02926555f, 
    0.13047421f, -0.23513594f, -0.05576398f, -0.05273681f, 0.03644474f, 0.03104424f, 0.01984181f, 0.04700376f, 
    0.09793420f, 0.03577697f, -0.08742158f, 0.02813791f, 0.04217020f, 0.00871300f, 0.02708677f, -0.02637722f, 
    -0.13065781f, -0.02362336f, -0.05243969f, -0.11708094f, 0.04764073f, 0.09189060f, -0.19025719f, -0.11409397f, 
    0.08208099f, 0.03671983f, 0.01888165f, -0.01496068f, -0.00764852f, 0.01632759f, 0.03916212f, -0.11320735f, 
    0.04144482f, 0.03855048f, -0.02837001f, 0.07358233f, 0.00752789f, -0.01051963f, -0.12403711f, 0.03493075f, 
    -0.06241489f, 0.10684194f, 0.21613364f, -0.05952434f, -0.03714429f, 0.00274409f, -0.06122773f, 0.04938265f, 
    -0.04731259f, -0.07006375f, -0.02052299f, 0.04035181f, 0.06477722f, 0.05199966f, -0.06382770f, -0.04855214f, 
    0.02247650f, -0.05968359f, 0.03633084f, 0.01280443f, -0.00892812f, 0.12652637f, 0.15680876f, 0.11272250f, 
    0.17847522f, -0.02471011f, 0.00280743f, 0.06083283f, 0.01778022f, 0.02566327f, -0.15095924f, 0.00597390f, 
    0.03103254f, 0.07364713f, -0.03139142f, -0.01458228f, 0.04195154f, 0.01877230f, -0.00340463f, 0.02592906f, 
    0.22590481f, -0.39790335f, 0.06874566f, -0.02113776f, 0.04952836f, -0.08040337f, 0.06097609f, -0.11930094f, 
    -0.01348439f, -0.01863822f, 0.10320701f, 0.04378262f, -0.05494668f, 0.05905097f, -0.03654722f, 0.01513975f, 
    -0.01452643f, -0.02453292f, 0.02962923f, 0.06080059f, 0.13872813f, -0.27722076f, -0.00522064f, 0.01678164f, 
    0.01552499f, 0.04322983f, 0.03325619f, 0.01802368f, -0.02802422f, 0.00390440f, 0.07911007f, 0.03171500f, 
    0.02946334f, -0.02332212f, -0.01184643f, 0.08020556f, 0.02365787f, 0.07675847f, -0.05997676f, 0.03452516f, 
    0.12355789f, -0.23409644f, -0.07540919f, 0.03814507f, 0.00852047f, 0.02214637f, -0.03896962f, 0.00300191f, 
    0.01782358f, 0.00779397f, 0.07088065f, -0.00119251f, 0.02122606f, 0.00039764f, 0.02726244f, 0.11439385f, 
    -0.01419897f, -0.03409835f, 0.01802186f, -0.02672749f, 0.11438973f, -0.18197332f, -0.22458470f, -0.14329500f, 
    -0.01318371f, 0.01904961f, -0.09405035f, 0.13876420f, -0.03601705f, -0.06205387f, -0.09994808f, 0.01196247f, 
    -0.02740762f, 0.08754994f, 0.05883397f, -0.09837596f, -0.05455298f, -0.15764922f, -0.05607936f, -0.02468032f, 
    -0.09897418f, -0.10117012f, -0.06766456f, -0.05983122f, -0.24299376f, 0.01805727f, -0.00419723f, 0.03550914f, 
    0.03091269f, 0.02735091f, -0.05938552f, -0.05502713f, 0.02531923f, 0.02774587f, 0.00126899f, -0.04029999f, 
    -0.03083006f, -0.07453693f, -0.16728455f, 0.01118843f, 0.03940310f, -0.02438744f, 0.06712626f, -0.10308556f, 
    0.18594681f, -0.11182028f, 0.01204142f, -0.04480826f, -0.01286631f, 0.01941886f, -0.04087417f, -0.07220510f, 
    0.04926080f, -0.09594756f, 0.02887582f, -0.03573500f, 0.00403975f, -0.04602640f, 0.09221561f, 0.03181237f, 
    -0.07310940f, 0.00708853f, 0.15425754f, 0.00347477f, 0.16859446f, -0.05124058f, -0.06385698f, 0.03975761f, 
    -0.00975297f, -0.06708262f, -0.00311074f, -0.01191541f, 0.14609261f, 0.00805986f, 0.00904988f, -0.10018860f, 
    -0.04796642f, -0.09485808f, 0.00097097f, 0.03920269f, 0.12581064f, -0.15020062f, 0.00346004f, 0.00063654f, 
    -0.21750881f, -0.02737454f, 0.01135430f, -0.00489909f, 0.04556188f, 0.08220886f, 0.04101956f, -0.05787335f, 
    0.07903689f, 0.05045828f, -0.07715460f, 0.09348153f, 0.09649712f, -0.04128427f, -0.03157594f, 0.01638825f, 
    -0.01418345f, 0.18581530f, 0.03039761f, 0.01566490f, 0.05000892f, -0.04696162f, -0.02743192f, 0.00752913f, 
    -0.02341519f, -0.01541633f, 0.10184230f, 0.02891716f, -0.04709399f, 0.00300750f, 0.05968639f, 0.06232304f, 
    -0.03912835f, 0.06223026f, -0.06287480f, 0.05180322f, -0.08342499f, 0.00728192f, -0.24039795f, -0.01180768f, 
    -0.06883401f, -0.01834546f, 0.05289138f, -0.05630101f, 0.00327605f, 0.04953517f, 0.02254600f, 0.06649795f, 
    -0.09007907f, -0.10652233f, 0.03196565f, 0.07282277f, 0.02583176f, -0.03164039f, -0.01497404f, 0.01978519f, 
    0.13204725f, 0.02086210f, 0.03637386f, -0.11539239f, -0.01823448f, -0.02760276f, -0.07285247f, 0.07196990f, 
    -0.00283775f, -0.02498132f, -0.10546213f, -0.00717102f, 0.02003599f, -0.00671178f, -0.00389984f, 0.02019255f, 
    -0.01805960f, 0.08289557f, 0.05126219f, 0.00072418f, 0.11825211f, -0.02463336f, -0.03497536f, -0.17321037f, 
    -0.23388663f, -0.07315014f, 0.03706799f, -0.01873671f, 0.02694424f, 0.04384622f, 0.03257517f, -0.05956171f, 
    0.00022927f, -0.00504953f, -0.04798191f, -0.00286949f, 0.03193739f, 0.08363449f, -0.02220815f, -0.04518133f, 
    0.09201553f, 0.13649172f, -0.08363947f, -0.13298187f, 0.01032626f, 0.01647824f, 0.06488237f, 0.03255267f, 
    -0.06909914f, -0.02647211f, -0.05319237f, -0.03216125f, 0.03250794f, -0.04788917f, 0.01977541f, -0.00666837f, 
    0.03742262f, -0.03384256f, -0.07695015f, 0.00206187f, 0.13534965f, 0.05772650f, -0.11481604f, 0.03368137f, 
    -0.15992789f, 0.03419781f, 0.07641885f, -0.00647496f, -0.03453330f, 0.00801656f, 0.01780688f, -0.02205506f, 
    0.00229431f, -0.09511968f, -0.05600427f, 0.06387827f, 0.04465973f, -0.04401772f, 0.14336325f, -0.03014779f, 
    0.19993395f, 0.07227365f, -0.35034075f, -0.07475805f, -0.00465784f, -0.04660888f, 0.03821920f, 0.07390630f, 
    -0.00321033f, 0.01873362f, -0.04328218f, 0.00033710f, 0.00263046f, -0.03085556f, -0.00879742f, -0.01800697f, 
    0.04618958f, -0.07767253f, 0.01453071f, 0.06664634f, 0.24428256f, -0.07114529f, -0.22427025f, 0.03072982f, 
    -0.17684489f, -0.09569477f, 0.02433260f, 0.06739767f, 0.05642486f, -0.02572630f, -0.00425764f, 0.01797653f, 
    -0.04669793f, -0.05836505f, -0.03413374f, 0.03995515f, 0.01728910f, 0.05593798f, 0.08850127f, 0.01482557f, 
    -0.03851677f, -0.02488961f, -0.02710288f, -0.04543481f, -0.14565207f, -0.01398251f, 0.05935016f, -0.07419100f, 
    0.00319091f, -0.03077415f, 0.06214159f, -0.02141452f, 0.04007930f, -0.04937165f, -0.08973043f, 0.03975858f, 
    0.02231422f, -0.04655216f, 0.04285835f, -0.04559382f, -0.20507431f, -0.16657101f, -0.20647989f, 0.03483595f, 
    -0.20604081f, 0.02183712f, -0.02104893f, 0.00027885f, -0.00624207f, 0.00423915f, -0.02546025f, -0.01977929f, 
    0.00928190f, -0.00566640f, 0.00997306f, -0.01962980f, -0.02847483f, 0.04937278f, -0.03264226f, -0.06519213f, 
    0.12479263f, -0.11233779f, 0.16465157f, -0.03274084f, -0.02870367f, -0.01215071f, -0.01454303f, -0.01440834f, 
    0.07958002f, 0.04275407f, -0.04564773f, 0.00757282f, 0.08605949f, 0.05493073f, 0.05117096f, 0.06305506f, 
    0.00927811f, 0.09883678f, 0.03872722f, -0.03172328f, 0.22744423f, -0.16228627f, -0.19250622f, 0.13577168f, 
    -0.13624942f, -0.06980314f, 0.04900065f, 0.05778817f, 0.00792754f, -0.12499271f, -0.04852669f, -0.05467267f, 
    -0.05597708f, 0.03186693f, 0.00960862f, 0.04329574f, 0.05374382f, -0.01038968f, 0.03608764f, -0.00122702f, 
    0.22838496f, -0.01240074f, -0.20316428f, -0.00019783f, 0.05029333f, -0.03185803f, -0.07316814f, 0.08542348f, 
    0.02818396f, 0.06643348f, -0.06248591f, -0.02117271f, -0.01445620f, -0.02997873f, -0.01146766f, 0.00396148f, 
    -0.01003577f, -0.10838950f, -0.06260001f, 0.01101010f, 0.05191294f, 0.08850953f, 0.14232536f, 0.00814112f, 
    0.06470841f, -0.01444442f, -0.08196758f, 0.02969300f, 0.01167658f, -0.03397769f, 0.02204153f, -0.06174156f, 
    0.02565374f, 0.02499349f, -0.04049566f, -0.00105037f, -0.06321510f, -0.05080761f, 0.02367830f, -0.05103704f, 
    -0.00585071f, 0.07322414f, -0.01538199f, 0.12171086f, -0.06201422f, -0.02516531f, -0.08058878f, 0.02453671f, 
    -0.01011101f, 0.06500738f, 0.01534904f, -0.01262267f, -0.00112447f, -0.03114138f, 0.01477216f, 0.03509440f, 
    -0.08896296f, 0.00039985f, 0.03898718f, -0.04564357f, 0.37901130f, -0.46441841f, -0.21276008f, -0.09869801f, 
    -0.28789255f, -0.18380226f, 0.01909264f, -0.15025805f, 0.07307997f, 0.05714762f, 0.00941614f, 0.02728568f, 
    0.03145622f, -0.05499995f, -0.00948828f, -0.01906413f, 0.00833443f, 0.06600300f, 0.07632510f, 0.05240966f, 
    -0.13266432f, 0.22127761f, -0.08523711f, -0.10822325f, 0.02272082f, 0.04765187f, 0.08165003f, 0.05309694f, 
    -0.03321202f, -0.08925645f, -0.06815869f, 0.06097920f, -0.08370566f, -0.09927618f, 0.03270783f, 0.04055024f, 
    0.00661012f, 0.00753381f, 0.01473872f, 0.00920761f, 0.11309183f, -0.16187988f, -0.03083931f, 0.05835040f, 
    -0.06848498f, -0.02326507f, 0.04868417f, 0.04580722f, 0.02656191f, -0.04787363f, -0.06728963f, 0.00969955f, 
    -0.03930686f, 0.04271443f, 0.03103895f, -0.02007089f, 0.08959389f, 0.07099608f, -0.09017643f, -0.00267015f, 
    0.29390720f, -0.13719611f, 0.04992291f, -0.14187951f, -0.07671209f, -0.00718284f, -0.14475255f, 0.11844072f, 
    0.03110437f, -0.00160526f, -0.07810719f, 0.01780723f, 0.03054346f, -0.02222473f, -0.06597962f, -0.01805589f, 
    -0.11192106f, 0.02622788f, -0.04695672f, -0.03123326f, 0.01604820f, -0.00591977f, -0.01515923f, 0.04167068f, 
    0.02145791f, -0.06575610f, 0.07284267f, 0.03603677f, -0.01330094f, -0.04176117f, 0.03168229f, -0.01221517f, 
    -0.03213986f, -0.01123038f, -0.02845424f, 0.02559461f, -0.03376368f, -0.06549156f, -0.00156842f, 0.00202341f, 
    -0.36077002f, -0.15853870f, -0.08778284f, -0.04382067f, -0.08653810f, 0.12519051f, 0.02961317f, 0.02555057f, 
    -0.00318609f, -0.05956497f, 0.02959530f, 0.01579518f, 0.05070896f, -0.03061520f, 0.03029087f, -0.04374823f, 
    -0.06217188f, 0.01472891f, -0.07617706f, -0.15529339f, -0.23097563f, 0.17945650f, -0.03409149f, -0.09996209f, 
    0.02848612f, 0.02029058f, -0.01937647f, -0.00264661f, 0.05211525f, -0.10514930f, -0.05816485f, -0.02117878f, 
    -0.03963731f, 0.04753882f, 0.00929857f, -0.02375673f, 0.07000876f, 0.01147650f, 0.02873576f, -0.09216824f, 
    -0.32946557f, -0.08582275f, 0.00631780f, -0.04427078f, -0.07952278f, 0.01556445f, 0.10818032f, -0.05205025f, 
    -0.05349109f, -0.01426142f, -0.07204163f, -0.02426747f, 0.02495807f, -0.07928254f, 0.01940664f, -0.00614315f, 
    0.04898129f, 0.06180734f, 0.00310921f, -0.04149913f, -0.03886578f, 0.06267391f, -0.03199644f, -0.08666528f, 
    -0.01771487f, 0.02191474f, 0.05074128f, 0.10850406f, -0.06060818f, -0.07477784f, -0.02773437f, 0.10388407f, 
    0.00455150f, 0.02258145f, -0.03639664f, 0.07144228f, -0.02268540f, 0.01422397f, -0.07702642f, 0.04225841f, 
    -0.21331127f, -0.16620734f, 0.04811130f, -0.04520137f, -0.03494494f, -0.07036807f, 0.02640624f, -0.08171801f, 
    0.01983702f, -0.00235162f, -0.05533817f, -0.03128386f, 0.09881826f, -0.03462725f, 0.09601952f, -0.03834652f, 
    0.00862135f, -0.09601905f, 0.05481051f, -0.05526789f, 0.00063847f, 0.08031772f, 0.02453049f, -0.14996882f, 
    0.10933369f, 0.07274692f, 0.03662262f, 0.05719158f, 0.02760812f, -0.05318230f, 0.05068764f, -0.02781478f, 
    0.01684606f, -0.02890007f, 0.01641664f, 0.02678279f, -0.03214605f, -0.01759884f, -0.01414184f, -0.07014848f, 
    0.03744470f, -0.05253220f, 0.02967162f, -0.12811497f, -0.02127510f, 0.08170314f, -0.02995062f, 0.05049418f, 
    0.01646874f, 0.04938583f, 0.00181938f, 0.03452391f, 0.03287114f, 0.05201895f, -0.07988626f, -0.11710884f, 
    -0.08834077f, -0.00614872f, -0.07536730f, 0.01560985f, 0.14131032f, -0.11984325f, 0.00257420f, -0.16078494f, 
    0.00337444f, 0.08142462f, -0.03692923f, 0.05807091f, 0.00520180f, 0.03833706f, -0.07994475f, 0.04882328f, 
    0.06194344f, -0.00203957f, 0.00095952f, -0.06327107f, -0.02922652f, 0.03648513f, -0.04474327f, -0.04104861f, 
    0.20964156f, 0.03106791f, 0.11623237f, -0.03296631f, 0.07805914f, 0.05319904f, -0.04081933f, -0.00745704f, 
    0.03227109f, 0.09422929f, 0.00853866f, 0.05907018f, 0.06293065f, 0.02651744f, 0.00406014f, -0.01963490f, 
    -0.07287080f, -0.01584927f, -0.06217314f, -0.08034756f, 0.20716147f, 0.06850368f, -0.24964394f, -0.01611509f, 
    -0.05574604f, -0.01853327f, 0.03162735f, 0.02384079f, -0.04925974f, -0.04340756f, -0.02754930f, -0.05696203f, 
    0.01881047f, -0.03992519f, 0.10581609f, -0.06091414f, 0.02962697f, -0.09084792f, 0.00014989f, -0.03038339f, 
    -0.00141696f, -0.02323563f, -0.17482825f, 0.15479346f, -0.12307093f, 0.05493588f, -0.04793499f, 0.07511480f, 
    0.07983898f, 0.05139208f, -0.01078284f, 0.01711235f, 0.06957301f, -0.01824715f, 0.04111246f, -0.06737733f, 
    -0.08632229f, -0.06096915f, 0.05179738f, 0.00792164f, 0.32294914f, 0.07499896f, -0.10379361f, -0.06667449f, 
    -0.07583612f, -0.05306932f, 0.03927449f, -0.00367455f, 0.00349581f, 0.02332906f, 0.03903984f, -0.03649530f, 
    -0.04913415f, -0.04253244f, -0.07285286f, 0.04117117f, 0.08019084f, 0.00239112f, 0.07726166f, -0.04700364f, 
    -0.17336796f, 0.15900652f, -0.01160214f, -0.01485850f, 0.04576774f, -0.03230287f, -0.02199006f, 0.03049580f, 
    0.09497490f, -0.03545862f, -0.02265173f, 0.02274296f, -0.01442842f, -0.01710638f, 0.04946189f, -0.07225800f, 
    0.06849744f, -0.05360711f, 0.00737433f, -0.01694513f, 0.08796757f, 0.03766714f, -0.18678786f, 0.06887744f, 
    -0.01919468f, -0.03691142f, 0.01054605f, 0.00955110f, 0.06176211f, 0.00264743f, 0.02947265f, 0.00424053f, 
    -0.04528692f, -0.00813690f, 0.02625852f, -0.00882175f, -0.00249600f, -0.13691343f, 0.03503609f, 0.00662180f, 
    0.00247769f, -0.25178269f, 0.12507315f, -0.10636960f, -0.01775171f, -0.10076831f, -0.03205267f, 0.01872405f, 
    0.04574466f, 0.00498715f, -0.00758129f, -0.08552341f, -0.01989043f, -0.00013832f, -0.02525285f, -0.01654484f, 
    -0.01563377f, 0.03689978f, -0.05094679f, -0.03695978f, 0.16788243f, -0.10796296f, 0.10585524f, 0.05076551f, 
    0.08693296f, -0.16852562f, -0.02349496f, -0.06529951f, 0.02448982f, 0.03633520f, 0.04564328f, -0.03273023f, 
    0.04446490f, -0.07047042f, 0.02633148f, 0.03851752f, -0.03398439f, -0.00588298f, 0.02136927f, 0.06607214f, 
    0.14574368f, 0.10311692f, 0.18548024f, -0.04633823f, -0.00576293f, -0.05217884f, 0.13505508f, 0.00715255f, 
    -0.08861268f, -0.08082656f, 0.02426283f, -0.09074444f, 0.07967735f, -0.03086857f, -0.00192054f, -0.02811773f, 
    -0.00835006f, 0.02298558f, 0.03918612f, -0.03595757f, 0.30145797f, -0.12695536f, 0.05970530f, -0.08378816f, 
    -0.05526064f, -0.07168103f, -0.03894144f, -0.03078197f, 0.00227983f, 0.02407970f, 0.00160904f, -0.05704806f, 
    0.05560829f, -0.01966874f, -0.02085947f, 0.01060966f, -0.03166246f, -0.02963005f, 0.03995483f, -0.05960933f, 
    -0.08863787f, 0.16131885f, 0.06287212f, 0.05505930f, 0.01636989f, 0.01823402f, -0.09813761f, -0.01132199f, 
    0.10244746f, -0.03662777f, 0.01290401f, 0.04227762f, 0.04599194f, 0.05116648f, -0.00595829f, -0.10537639f, 
    0.04554597f, -0.05485703f, -0.04336847f, -0.03152895f, 0.07371483f, 0.19636931f, -0.16286570f, -0.07361681f, 
    -0.09242692f, -0.00734580f, 0.02449999f, -0.02456351f, 0.07056944f, 0.02116903f, 0.03569661f, 0.02045178f, 
    0.01452528f, -0.00558071f, -0.01688045f, 0.03810715f, -0.07630387f, -0.03400063f, 0.04754807f, 0.02675677f, 
    -0.02028148f, 0.03288636f, -0.04425318f, 0.00822456f, 0.02201125f, 0.07597100f, -0.04745940f, 0.07825162f, 
    0.07950146f, -0.00579124f, -0.05407145f, 0.03091316f, 0.01857482f, 0.01797565f, -0.03372033f, -0.08635065f, 
    -0.08471833f, -0.03905920f, -0.03222148f, 0.02290191f, 0.00187339f, -0.05514111f, -0.17524166f, -0.06558091f, 
    -0.07363056f, 0.02296467f, 0.04673916f, 0.02311014f, -0.07557615f, 0.05391984f, -0.09346119f, -0.09114547f, 
    0.00678879f, -0.02020549f, 0.00634036f, -0.03078874f, 0.01117505f, 0.00970551f, -0.03382186f, -0.04456245f, 
    -0.49144104f, 0.18616638f, -0.04615676f, -0.05977061f, -0.02482816f, 0.04535317f, 0.08507952f, -0.05300397f, 
    0.09302168f, 0.04600072f, -0.02499237f, -0.02168676f, 0.01591145f, -0.05222672f, 0.04706362f, -0.04090332f, 
    0.04024528f, -0.04447281f, 0.08946599f, 0.01176222f, 0.22291209f, -0.09779817f, 0.06213645f, 0.06421782f, 
    0.24518339f, -0.20274492f, -0.06767200f, -0.06833079f, 0.01973710f, 0.01048624f, 0.08585982f, -0.08621485f, 
    -0.02641913f, -0.02678204f, 0.04422178f, -0.08572528f, -0.02021890f, -0.09582011f, 0.02948021f, 0.01707491f, 
    0.02081722f, -0.15059114f, 0.03464562f, -0.08237753f, -0.14698285f, 0.02912934f, 0.01335642f, 0.06529246f, 
    -0.05819533f, -0.00028525f, -0.03608287f, 0.00783046f, 0.05804576f, -0.05389146f, -0.08481764f, 0.00303466f, 
    0.00724175f, -0.09808148f, 0.06432524f, -0.07193394f, -0.34943879f, 0.18243307f, -0.03098706f, -0.19170029f, 
    0.04666475f, 0.01409194f, 0.06680836f, 0.00881276f, 0.03908058f, -0.02113549f, -0.03186659f, 0.02980565f, 
    -0.00320874f, -0.08256929f, -0.02566508f, 0.05341573f, 0.06971277f, 0.01811776f, 0.08055953f, -0.00176548f, 
    0.20180374f, 0.03535233f, -0.16085303f, -0.04759404f, -0.04154794f, -0.03715688f, -0.06342535f, 0.05428775f, 
    0.06048894f, 0.03711856f, 0.03962885f, 0.01574874f, 0.00708832f, -0.02405364f, -0.00751922f, 0.07726207f, 
    -0.00459681f, -0.05330652f, 0.07444064f, -0.07673674f, 0.24353890f, -0.03156257f, -0.18698867f, -0.15461954f, 
    -0.14318846f, 0.04506839f, -0.00260139f, -0.06025011f, -0.04229638f, 0.03465793f, 0.01029406f, 0.03031422f, 
    0.00731411f, -0.02211995f, 0.04020276f, -0.05557899f, -0.01102934f, -0.03111990f, -0.01866990f, -0.03188946f, 
    0.16455309f, -0.02717098f, 0.06103639f, -0.01068260f, 0.02806836f, -0.06494445f, -0.03852398f, 0.05674717f, 
    -0.06829531f, -0.03035747f, -0.05851457f, -0.02693648f, -0.02522856f, 0.02845841f, -0.04998824f, -0.01639953f, 
    -0.01525336f, 0.00056515f, 0.02053078f, 0.02171082f, 0.07931995f, 0.09084623f, 0.09357345f, 0.00808329f, 
    0.06597965f, 0.03203056f, -0.07216266f, -0.01068520f, 0.03144551f, -0.01610301f, -0.00803226f, -0.01972585f, 
    0.04613161f, -0.01704995f, -0.05794209f, -0.01356007f, -0.08724895f, -0.00536042f, 0.01640770f, -0.01921859f, 
    0.19666268f, -0.00842321f, 0.04699284f, 0.18851773f, 0.19050170f, -0.15229541f, -0.05326211f, -0.09183532f, 
    0.06797424f, 0.03606999f, 0.12933134f, -0.01569726f, -0.00917714f, -0.00766271f, 0.00878295f, -0.01479737f, 
    -0.05059757f, -0.04090511f, -0.03204889f, 0.00314766f, 0.21062122f, 0.00602788f, -0.21223618f, 0.02205532f, 
    -0.14069451f, -0.01298888f, -0.02783745f, 0.01966634f, -0.04507484f, -0.02173104f, -0.00429952f, -0.04528198f, 
    0.01538627f, -0.05647825f, 0.01591172f, 0.04006359f, 0.02613322f, -0.06070780f, 0.09097447f, -0.02569404f, 
    0.28122246f, -0.23450837f, -0.11008032f, -0.15704557f, -0.48083392f, -0.00437327f, 0.01043334f, 0.01642804f, 
    -0.04919939f, 0.02835651f, 0.03969226f, -0.00987591f, -0.01425248f, -0.12929954f, -0.06940065f, -0.03064009f, 
    -0.01109795f, 0.07435795f, 0.06143364f, -0.01884404f, 0.09935588f, 0.07824854f, -0.10371150f, -0.07515271f, 
    -0.15300687f, 0.01372499f, 0.03215883f, -0.05162565f, -0.09106024f, -0.01731751f, -0.06560753f, -0.04398835f, 
    -0.04960576f, -0.05420944f, 0.02614271f, 0.00457561f, 0.00811611f, -0.05678224f, -0.01848651f, -0.01526514f, 
    -0.23969570f, 0.02596347f, 0.06221987f, -0.01463047f, -0.02868721f, 0.04579709f, -0.00178591f, 0.03134872f, 
    -0.03881036f, 0.05231987f, 0.01774618f, 0.04146587f, 0.03803800f, -0.04434007f, 0.00237448f, 0.11355644f, 
    -0.01120500f, -0.10816789f, -0.04753223f, 0.01339079f, -0.01095960f, 0.00240102f, 0.02406953f, -0.06470960f, 
    0.09126275f, 0.05025552f, 0.01534924f, 0.05272312f, 0.01420656f, -0.03467876f, -0.00850234f, 0.03886631f, 
    -0.00155456f, 0.01122731f, -0.01163325f, -0.03873879f, 0.01529184f, -0.07810999f, -0.14243215f, -0.03844104f, 
    0.07949882f, 0.08042565f, 0.14164747f, 0.06261097f, 0.05992578f, -0.01061428f, -0.16521721f, -0.00065819f, 
    0.13674498f, 0.09461408f, 0.03727369f, -0.05055312f, 0.02948044f, 0.04197883f, -0.07888679f, 0.00556976f, 
    -0.01178144f, -0.01952953f, -0.05471443f, -0.02936714f, 0.16604163f, 0.05658213f, 0.03500402f, -0.17393543f, 
    -0.02658194f, -0.04674168f, 0.00173795f, 0.03297990f, 0.05800909f, 0.00112216f, -0.01220036f, -0.11261037f, 
    -0.00646238f, -0.03935998f, -0.06265652f, -0.00743863f, 0.06457934f, 0.07349084f, 0.04963551f, 0.01309383f, 
    0.12327433f, -0.05704130f, 0.07567203f, -0.08140559f, -0.03737419f, -0.01375356f, -0.03116092f, 0.00899353f, 
    0.02341452f, 0.02302654f, -0.00029302f, -0.04841794f, -0.00336473f, -0.01554127f, -0.02180425f, -0.02332192f, 
    -0.00433728f, 0.08423009f, 0.00513294f, 0.00222475f, -0.13039450f, 0.00844729f, -0.14775671f, -0.13839307f, 
    -0.03937336f, 0.04640726f, -0.04007134f, 0.05350572f, -0.07785579f, 0.02553725f, -0.07027996f, 0.04147436f, 
    -0.02154762f, -0.07423630f, -0.03907429f, 0.04660812f, -0.01462997f, 0.08457203f, -0.02810275f, -0.05617123f, 
    -0.00736815f, -0.05746067f, -0.19266905f, -0.05014096f, -0.16569082f, 0.01807543f, -0.00083675f, -0.03989905f, 
    0.03001671f, -0.05875579f, 0.02512427f, 0.04669093f, -0.01969798f, -0.04273972f, -0.05157847f, 0.00450607f, 
    0.05922222f, -0.02221014f, 0.02750290f, -0.05858337f, 0.03292001f, -0.24393100f, 0.06609296f, 0.01257143f, 
    -0.05849895f, 0.08543434f, 0.03976820f, 0.08598412f, -0.04291535f, 0.00836011f, -0.00011161f, 0.00572456f, 
    0.00355564f, -0.05437609f, -0.02027834f, 0.00964944f, -0.09147962f, -0.02579120f, -0.13418159f, -0.03419758f, 
    0.06698450f, -0.02981260f, 0.06024176f, -0.09029406f, 0.05953790f, 0.07525466f, 0.07161981f, 0.10056067f, 
    -0.03502621f, -0.05354267f, -0.00591462f, 0.05260933f, -0.00617160f, -0.13493787f, -0.05490949f, 0.07539455f, 
    -0.03237687f, -0.02134103f, -0.10396775f, -0.00603101f, 0.19220142f, -0.05205941f, 0.06897084f, 0.18832183f, 
    0.16412398f, -0.18535106f, -0.10651840f, -0.11083949f, 0.04714148f, -0.06520225f, 0.11485872f, -0.03736746f, 
    -0.08066662f, 0.03903066f, 0.00943510f, -0.08227389f, 0.03725647f, -0.00880594f, -0.04874819f, -0.00667543f, 
    0.13398950f, 0.08333337f, -0.07339796f, -0.01060781f, -0.03310138f, 0.03398465f, 0.03412888f, 0.03278428f, 
    -0.04631054f, -0.08915365f, 0.03019870f, 0.00189919f, -0.04943235f, -0.03254304f, 0.03140486f, 0.02337610f, 
    -0.03105229f, -0.07282983f, -0.00764550f, 0.02768937f, 0.35199109f, -0.02822853f, 0.19378448f, -0.02702464f, 
    0.19325864f, -0.03693969f, -0.09246251f, -0.11066765f, 0.04370073f, 0.05800726f, 0.05027507f, -0.00683697f, 
    0.01157389f, -0.02358324f, 0.00218730f, 0.02917697f, -0.08614060f, 0.06157616f, 0.00074405f, -0.04530885f, 
    -0.05889933f, -0.21598554f, -0.08369448f, -0.03500955f, 0.02065499f, -0.00949776f, -0.04226370f, -0.00818492f, 
    -0.00034694f, 0.03011276f, -0.06551376f, 0.01943995f, -0.01460672f, 0.03165442f, -0.02503533f, -0.00757480f, 
    0.01802027f, -0.03899713f, -0.02490157f, -0.07601377f, 0.03078922f, 0.15991697f, 0.10168095f, 0.01103428f, 
    -0.04840718f, -0.06864117f, 0.05304250f, -0.01871782f, -0.01913884f, -0.01541306f, -0.00130137f, 0.01625165f, 
    0.00541281f, -0.00207954f, 0.00396294f, 0.02249569f, -0.01287107f, 0.07639819f, -0.04213567f, -0.05450277f, 
    -0.19090243f, 0.13624056f, -0.13908929f, -0.06751695f, 0.17001832f, -0.04481180f, 0.04110589f, -0.02628152f, 
    0.03605822f, -0.00646381f, -0.03551099f, 0.02868371f, 0.00975152f, -0.01924141f, -0.00564095f, 0.06572302f, 
    -0.00248114f, -0.02084782f, 0.05491772f, 0.05119018f, -0.23517703f, 0.10040980f, 0.10467297f, 0.12634192f, 
    0.03759874f, -0.02351282f, 0.05300669f, 0.06694753f, 0.00241941f, -0.01874766f, 0.00172715f, -0.02728091f, 
    0.01824080f, -0.01661334f, -0.05650942f, -0.00147261f, 0.03569112f, -0.01925586f, -0.00760565f, -0.04231098f, 
    -0.14908549f, 0.25657624f, 0.07964393f, -0.06865133f, -0.02699221f, -0.08958788f, -0.08368589f, -0.01708358f, 
    0.03684502f, -0.00436529f, 0.02926913f, 0.01779124f, 0.00860065f, 0.00661575f, -0.07081182f, -0.03992422f, 
    0.04019666f, -0.06730244f, 0.09158368f, 0.02656712f, -0.07231360f, 0.05166473f, 0.18708244f, 0.06221326f, 
    0.00339601f, 0.02077677f, 0.04018426f, 0.10498370f, 0.05661508f, 0.00488274f, 0.00580304f, 0.05348964f, 
    -0.06638716f, -0.04728700f, -0.06341773f, -0.00903367f, -0.06648134f, 0.02233703f, 0.03068532f, -0.01382504f, 
    -0.11719120f, 0.25002691f, 0.04134371f, 0.22912748f, 0.12418725f, 0.04918060f, 0.08727434f, 0.05169018f, 
    -0.01016484f, 0.05467422f, -0.06618838f, -0.04495887f, -0.04297074f, -0.06811003f, -0.03544103f, 0.00068078f, 
    -0.05409212f, 0.02421299f, 0.07845591f, -0.10912164f, 0.11992422f, 0.03012020f, -0.01006182f, 0.11905330f, 
    0.02199161f, -0.05711364f, 0.08798227f, 0.00866749f, -0.04964652f, 0.04012357f, 0.03146975f, -0.01715317f, 
    0.00584938f, 0.06331332f, 0.00542025f, -0.08000313f, 0.02021803f, 0.03472443f, 0.02644677f, 0.00404978f, 
    -0.07430894f, -0.05127043f, 0.00781692f, 0.03349581f, -0.03692474f, -0.08943849f, -0.03216464f, 0.05518728f, 
    -0.03977169f, 0.09418532f, -0.09611072f, 0.05953424f, -0.05331711f, 0.03246877f, 0.04434446f, -0.01260558f, 
    0.07009385f, -0.02024500f, -0.02878981f, -0.04107274f, -0.00225082f, 0.19130513f, 0.04791250f, 0.06877949f, 
    0.02465490f, 0.07435130f, -0.02355663f, 0.03238893f, 0.05743533f, 0.06084601f, 0.07024350f, 0.07100481f, 
    0.00489259f, -0.07444409f, -0.01676543f, -0.09224210f, -0.01339259f, -0.01980426f, 0.05797627f, -0.02280592f, 
    -0.02953833f, 0.11912873f, 0.08622223f, -0.06987907f, -0.04458334f, -0.00874086f, -0.08836328f, -0.04426167f, 
    0.04995519f, -0.01427538f, 0.03873976f, -0.01689304f, 0.04677500f, -0.02503040f, -0.05217101f, -0.04783433f, 
    0.05998597f, -0.00721157f, 0.04425611f, 0.04759259f, -0.10176893f, -0.30878824f, 0.08523177f, -0.09634255f, 
    -0.12027503f, -0.03092627f, -0.05580858f, -0.03877426f, -0.06286442f, -0.12059621f, -0.03289372f, 0.00703799f, 
    -0.02505727f, 0.06780874f, 0.05623470f, 0.05218016f, -0.03719589f, -0.10007756f, -0.03750647f, -0.09499764f, 
    0.08650509f, 0.04917786f, -0.10547709f, -0.00396891f, -0.10795615f, -0.10153931f, -0.05507319f, 0.04555715f, 
    -0.06237761f, 0.00082137f, -0.01562314f, -0.00242425f, -0.04002738f, -0.04482643f, 0.03131945f, -0.03908208f, 
    0.02127111f, -0.00102810f, -0.01947980f, 0.01878114f, -0.03849851f, 0.08622602f, -0.01006487f, 0.08533455f, 
    -0.02114389f, -0.10884419f, -0.14254543f, 0.03302314f, -0.02917677f, -0.02229697f, -0.11594297f, -0.08627883f, 
    -0.05234689f, -0.02721866f, 0.04020034f, -0.00613460f, 0.02901781f, 0.15114382f, 0.03985618f, 0.02789140f, 
    -0.23725942f, -0.26629919f, -0.24712381f, 0.09830799f, 0.18868697f, -0.04789033f, 0.03472742f, 0.10920761f, 
    -0.00786399f, -0.05890458f, 0.03446027f, 0.02433341f, -0.08449034f, -0.17230695f, 0.00418921f, 0.03624946f, 
    0.03479271f, 0.00366148f, -0.03391175f, -0.02599866f, 0.01407573f, -0.40685728f, -0.04148134f, 0.12299588f, 
    -0.02227793f, 0.03836131f, 0.02239339f, 0.03595681f, 0.04136439f, -0.07738159f, 0.04179117f, 0.01718802f, 
    -0.05560568f, 0.04114714f, 0.05579080f, -0.04658007f, 0.09097504f, 0.04655950f, -0.02221122f, -0.00158837f, 
    -0.03419958f, -0.04858498f, -0.18763396f, 0.02403813f, -0.05248037f, 0.00576958f, -0.06948421f, -0.04381603f, 
    0.01613200f, 0.00117484f, -0.05815495f, -0.04465448f, -0.03952288f, 0.03845335f, -0.00922604f, -0.11561897f, 
    -0.04359870f, -0.01691565f, -0.05615298f, 0.05603721f, -0.09448370f, -0.24311310f, -0.09390000f, 0.06471864f, 
    -0.03545864f, -0.03919051f, -0.07564982f, 0.04049413f, 0.03372063f, -0.06830204f, -0.01294256f, 0.00435607f, 
    -0.01460742f, -0.01394021f, -0.04391599f, 0.00921598f, -0.00377656f, 0.04372347f, -0.02213199f, -0.05968747f, 
    -0.04921640f, -0.13953540f, 0.16445716f, 0.06611642f, 0.03284339f, -0.05725149f, 0.06574608f, -0.02375813f, 
    -0.01583178f, 0.10041628f, 0.02579186f, 0.04288464f, 0.00212009f, 0.03317063f, -0.00308959f, 0.11190258f, 
    0.02421970f, -0.04466706f, -0.01108069f, 0.02262844f, -0.33814892f, 0.27352861f, 0.00566842f, 0.10775096f, 
    0.09663055f, 0.05307459f, 0.11301041f, 0.02012583f, -0.00561106f, 0.07885221f, -0.01672409f, -0.00015937f, 
    0.07963102f, 0.03044742f, 0.00807119f, 0.02974418f, 0.02294962f, -0.05455169f, 0.07010163f, 0.08847746f, 
    0.06825139f, 0.06370456f, -0.02712746f, 0.06572475f, 0.05298698f, 0.02111413f, 0.16355540f, -0.00452285f, 
    0.04619682f, -0.00579699f, 0.04335690f, -0.03451332f, -0.08949020f, 0.04643656f, -0.03666911f, 0.03979794f, 
    0.03107878f, 0.01331460f, 0.07590249f, -0.01254589f, 0.07016858f, -0.66339213f, -0.21882749f, 0.09311555f, 
    0.15427963f, -0.02326089f, -0.06157995f, 0.09652952f, 0.02360545f, -0.04202795f, 0.05513991f, 0.03973981f, 
    -0.13368073f, 0.05214835f, -0.04539112f, 0.04439004f, 0.00184477f, -0.01153342f, -0.01283976f, -0.00288800f, 
    0.12360496f, 0.00793192f, -0.02114586f, 0.03123396f, -0.04017372f, -0.04346023f, 0.02698764f, -0.10313727f, 
    0.06683307f, 0.02282844f, 0.05004949f, -0.00856575f, -0.02413112f, -0.02512498f, -0.02182773f, 0.00117078f, 
    -0.07448584f, 0.02702167f, 0.00931003f, -0.02011704f, -0.36396265f, 0.03808184f, -0.26837763f, 0.01363310f, 
    0.06032379f, -0.11563729f, -0.00736764f, -0.05822209f, 0.05044225f, -0.01464164f, -0.07105487f, -0.01595846f, 
    0.05922194f, -0.06092981f, 0.01357408f, -0.03760643f, -0.01027166f, -0.03127216f, -0.01388480f, 0.04100124f, 
    -0.40106192f, -0.52559453f, -0.28197885f, -0.02654448f, -0.12471484f, -0.16975810f, -0.14183113f, 0.05393866f, 
    0.01883127f, -0.05135584f, -0.08220957f, 0.01770000f, 0.06414524f, 0.05206880f, 0.07167330f, 0.10672652f, 
    -0.08625537f, -0.00737615f, -0.04835414f, 0.06813198f, -0.26667878f, -0.26739985f, -0.38147768f, -0.11655743f, 
    -0.08195715f, -0.01607428f, -0.04825188f, -0.04813813f, -0.04916503f, 0.00387674f, -0.02896596f, 0.01011003f, 
    0.07263231f, 0.07707585f, -0.09148366f, 0.02257436f, 0.00397496f, -0.05848391f, -0.04440114f, 0.11807644f, 
    -0.11333136f, -0.07075299f, -0.05088709f, 0.00954464f, -0.14355038f, 0.00123791f, -0.09254546f, -0.03152062f, 
    0.01150311f, -0.09588864f, 0.01035757f, -0.05785448f, -0.00777759f, -0.01661497f, 0.02278447f, 0.05479948f, 
    0.04083129f, 0.04301938f, -0.00569191f, 0.07308497f, -0.04050082f, 0.27031785f, -0.12691884f, 0.12538654f, 
    0.19445774f, 0.03648416f, 0.00473263f, 0.03778327f, 0.08178648f, 0.00099197f, -0.01093059f, -0.02676984f, 
    -0.01603745f, 0.01313350f, -0.06238332f, -0.05235560f, -0.05377886f, -0.07049948f, 0.08807907f, 0.05671413f, 
    0.03549656f, -0.19616973f, -0.09199884f, -0.06894191f, 0.01177430f, -0.13211541f, 0.02398197f, 0.07738046f, 
    -0.05420644f, 0.03620397f, 0.02408446f, -0.00554069f, -0.07193215f, 0.00385831f, -0.03755485f, -0.00122628f, 
    0.00322792f, 0.00887306f, 0.06875696f, 0.01808521f, -0.13874103f, 0.32087457f, 0.02197764f, 0.13030596f, 
    0.05327594f, -0.00599125f, -0.03496816f, 0.04121075f, 0.00645282f, -0.13415566f, -0.07230289f, -0.01278010f, 
    0.00229207f, 0.06679508f, 0.02629808f, 0.04600310f, -0.05662661f, 0.00307290f, 0.03203689f, -0.01674329f, 
    0.02555896f, -0.33940637f, -0.10239666f, 0.14436236f, 0.14071992f, -0.02383960f, 0.09448332f, 0.04102395f, 
    0.01413693f, -0.05644470f, -0.07164185f, 0.06232717f, 0.01299148f, -0.05982845f, -0.00209380f, -0.00428565f, 
    0.03278260f, -0.03058618f, 0.06908451f, -0.12556528f, -0.21011555f, 0.03075977f, 0.10352820f, -0.04029910f, 
    -0.05375471f, -0.03684691f, -0.04134086f, 0.04199051f, 0.01152953f, -0.03099832f, -0.02595763f, -0.02805130f, 
    0.02426801f, 0.02372922f, 0.02370134f, 0.00898685f, -0.01286946f, -0.07444805f, 0.02874413f, -0.04444190f, 
    0.08827355f, 0.03883517f, -0.01877268f, -0.01469860f, -0.01000016f, -0.05841305f, -0.01338049f, -0.03810208f, 
    -0.01621065f, 0.00986764f, -0.01758745f, 0.06121806f, 0.05753538f, 0.07692637f, -0.01201044f, -0.02663315f, 
    0.01176233f, 0.04018458f, -0.06593812f, -0.06148836f, 0.19694878f, -0.06553239f, 0.01837334f, -0.06484264f, 
    -0.04962325f, -0.09699478f, -0.05438853f, -0.04951630f, -0.01757111f, -0.01076697f, 0.00052549f, 0.00945642f, 
    0.04392411f, -0.02026880f, 0.06678275f, -0.07846527f, 0.02953217f, 0.01462274f, 0.02950398f, 0.01611536f, 
    -0.16646653f, -0.06655221f, 0.08231051f, -0.05387063f, 0.00418212f, -0.02290421f, -0.04622104f, -0.03086797f, 
    0.02019031f, -0.10711902f, 0.02419427f, -0.00201528f, 0.00928116f, 0.05867662f, 0.09429552f, 0.04365447f, 
    0.00045060f, -0.15670247f, 0.08034936f, -0.07197732f, -0.14595827f, 0.23746136f, 0.08516999f, 0.04427192f, 
    0.07607146f, 0.04934884f, -0.08163375f, 0.01923265f, 0.02685989f, -0.06278255f, -0.04308217f, 0.02498708f, 
    -0.02249998f, 0.04994867f, -0.00253902f, -0.09283663f, 0.02045294f, -0.02839495f, 0.02775707f, -0.02832592f, 
    -0.05835877f, -0.15179476f, -0.02793717f, -0.06734346f, 0.03468237f, -0.00300840f, 0.07836535f, -0.00189756f, 
    -0.03420790f, -0.02734013f, -0.04636276f, 0.02903059f, 0.01833414f, 0.02337771f, 0.06375214f, 0.02410789f, 
    0.03012201f, -0.08300502f, 0.01331253f, -0.04948907f, 0.20223524f, 0.02553212f, 0.06630612f, -0.00205267f, 
    0.00741859f, 0.02164673f, 0.10270832f, -0.03206497f, 0.03892172f, -0.02319346f, -0.02650480f, 0.02287789f, 
    -0.00971330f, -0.06355181f, 0.06146888f, -0.06547027f, 0.06746496f, -0.04320626f, 0.04109649f, 0.02218034f, 
    -0.08974395f, -0.52432477f, -0.14399415f, -0.19323948f, -0.01588397f, -0.14414944f, -0.02822011f, 0.03262958f, 
    0.01655370f, -0.06609328f, -0.02328307f, 0.04620929f, 0.00874628f, 0.01573793f, 0.04032425f, -0.00325592f, 
    -0.00159840f, -0.02052164f, -0.02217131f, 0.05405334f, -0.00569386f, 0.12270163f, 0.07230528f, -0.06383169f, 
    0.18779646f, -0.02885592f, 0.09188685f, 0.04322409f, 0.01324402f, 0.03890222f, -0.06959546f, 0.02005321f, 
    0.04345072f, -0.01339536f, 0.02369199f, 0.00840561f, 0.06984471f, -0.02403703f, 0.11372891f, 0.09918004f, 
    0.15484625f, 0.00389418f, -0.06800795f, 0.11589725f, 0.05317514f, -0.04470040f, 0.10336062f, -0.06083133f, 
    0.02185998f, -0.08460370f, 0.02297145f, 0.05998666f, -0.12217943f, -0.02093122f, -0.01468566f, -0.02759881f, 
    0.02625495f, 0.00195954f, 0.00946638f, 0.00063367f, -0.00503406f, -0.03430334f, 0.02493376f, -0.06977565f, 
    -0.13663872f, -0.03947140f, -0.13600831f, 0.00956532f, 0.01768493f, -0.02590843f, -0.06477234f, -0.05177097f, 
    0.06800159f, -0.08213259f, 0.09682990f, 0.02275120f, -0.00726061f, 0.02182158f, 0.08068207f, 0.12165102f, 
    -0.28709924f, 0.13531733f, 0.13612014f, 0.11697210f, 0.09205952f, 0.02435786f, 0.08999529f, 0.04586690f, 
    -0.03409052f, 0.00872665f, -0.01906992f, -0.02878259f, -0.02948828f, 0.00005713f, 0.05040144f, -0.02340514f, 
    0.03218296f, -0.03555923f, 0.08264493f, -0.07251289f, -0.03145805f, -0.02158630f, -0.00428286f, 0.06273317f, 
    0.15116435f, 0.02480199f, 0.09571788f, 0.02040262f, -0.01768547f, 0.00991440f, 0.09184998f, 0.00137672f, 
    -0.08714741f, -0.02945028f, -0.07905024f, 0.02685759f, -0.00020034f, 0.03202522f, -0.00327390f, 0.00348958f, 
    0.08060286f, 0.14399919f, 0.08376937f, 0.06752624f, 0.00235015f, 0.00649174f, -0.08007528f, 0.00270306f, 
    -0.03724979f, -0.07283571f, -0.06254493f, -0.07959799f, -0.06429916f, 0.06228707f, 0.08328924f, 0.04304758f, 
    0.03733807f, 0.05386630f, 0.08622255f, 0.00292757f, 0.19302124f, 0.32074261f, 0.09256229f, -0.01174631f, 
    -0.03838387f, -0.00603913f, -0.06473352f, -0.04370009f, 0.06431482f, -0.04447170f, 0.00663419f, -0.02360045f, 
    -0.15952732f, 0.05602217f, -0.12147568f, 0.00637377f, -0.05731755f, -0.05189463f, 0.03087406f, 0.02318698f, 
    0.37852845f, 0.19710952f, -0.03898340f, 0.01564418f, 0.00025818f, 0.01590885f, -0.03583701f, -0.06305660f, 
    0.07348410f, -0.05303024f, -0.08663166f, -0.05112508f, -0.02014306f, 0.01965526f, -0.02426532f, -0.03074763f, 
    0.02535567f, -0.00986930f, 0.06661882f, 0.00840270f, -0.11468945f, 0.03797901f, -0.02551156f, -0.12557884f, 
    -0.06974552f, -0.00143814f, -0.06674977f, 0.04281146f, -0.02981171f, -0.04505934f, -0.02789891f, -0.05334888f, 
    -0.01483370f, 0.04683453f, -0.06295265f, -0.01341468f, -0.02994642f, -0.05604130f, 0.02375338f, 0.03600693f, 
    0.06175419f, -0.09659268f, -0.00193164f, -0.04740836f, -0.09959218f, -0.03870390f, -0.11125207f, 0.08951119f, 
    -0.08028118f, 0.00134054f, -0.10660380f, 0.02319088f, -0.00704072f, -0.04093664f, 0.05114295f, 0.02344732f, 
    0.02946650f, 0.09262685f, 0.06734755f, 0.00938847f, -0.28908232f, 0.21129397f, 0.02375136f, 0.02151917f, 
    0.04878268f, 0.02336170f, -0.02028182f, 0.06635410f, 0.05940781f, -0.02243229f, -0.04291642f, 0.00563314f, 
    0.01183569f, 0.01475134f, -0.02516470f, -0.02477549f, -0.02205840f, -0.08629110f, 0.05002985f, -0.01138386f, 
    0.19375168f, 0.10754549f, 0.13739672f, 0.05198163f, -0.02562646f, -0.05800067f, 0.01091549f, -0.01014326f, 
    -0.06910906f, 0.06215308f, 0.02432747f, 0.03182282f, 0.03869580f, -0.06560563f, 0.02193096f, -0.01211702f, 
    -0.01082075f, 0.08271996f, 0.04115191f, 0.05896837f, -0.34030351f, 0.20315275f, -0.07288679f, 0.01991024f, 
    0.15619558f, 0.02442673f, 0.01983711f, 0.03214619f, 0.05089422f, -0.01677199f, -0.09484249f, -0.00899449f, 
    0.00160442f, -0.07454916f, -0.00580558f, -0.00151391f, 0.09845437f, -0.07511838f, 0.05512973f, 0.01328577f, 
    0.01542907f, 0.11350083f, -0.51401740f, 0.25925428f, -0.00290067f, 0.03367349f, 0.05043069f, 0.02872232f, 
    0.00255444f, -0.00142891f, -0.05226346f, 0.03091163f, -0.06948528f, -0.10114210f, 0.03860977f, -0.00517676f, 
    0.00711639f, 0.10595574f, -0.07760497f, -0.14262775f, -0.29609761f, -0.35234004f, -0.25186488f, 0.03490925f, 
    -0.04844449f, -0.08526052f, -0.04242048f, -0.02099619f, 0.02140481f, -0.05249086f, 0.01777074f, -0.00482820f, 
    0.09433937f, 0.04999738f, -0.00017965f, 0.04687588f, -0.03083117f, -0.04223485f, 0.04361558f, -0.01460708f, 
    -0.19252788f, -0.18845120f, -0.15798287f, -0.12486924f, -0.21839647f, -0.04781586f, -0.08377495f, -0.03238453f, 
    0.03586496f, 0.02903770f, -0.10925358f, 0.01366904f, 0.00761444f, 0.01273574f, -0.00275602f, 0.05237419f, 
    -0.04241804f, -0.00376367f, -0.01514298f, 0.04406212f, -0.11065250f, 0.12206414f, 0.01888910f, 0.07562587f, 
    -0.02137551f, -0.06298207f, 0.02934593f, -0.03818663f, 0.05151641f, -0.00696368f, 0.01174669f, 0.03498840f, 
    0.01458585f, -0.00615755f, -0.00767037f, 0.01015813f, -0.01789932f, -0.00021001f, -0.03571648f, 0.00902276f, 
    -0.01467288f, 0.07276603f, -0.00116189f, 0.00340720f, -0.01674674f, -0.00369219f, 0.01585692f, 0.01614910f, 
    -0.00593160f, 0.00788554f, -0.02654960f, 0.01374511f, -0.00884750f, 0.03252862f, -0.04332744f, 0.00027486f, 
    0.00796451f, 0.03353968f, -0.03221464f, -0.00170148f, 0.08682185f, 0.04851384f, 0.02014660f, 0.07787393f, 
    0.20414369f, 0.04031109f, 0.14991525f, 0.02546153f, -0.02058822f, 0.08221179f, -0.00715693f, -0.04846078f, 
    -0.02701263f, -0.09345344f, -0.06707575f, 0.02711832f, 0.03165174f, 0.02651375f, -0.00610557f, -0.02367018f, 
    -0.05906394f, 0.20437934f, 0.07327764f, 0.17426260f, 0.09316717f, 0.05640380f, 0.10313523f, -0.00309408f, 
    0.00798723f, 0.02450729f, -0.00008995f, -0.06963006f, -0.00128907f, -0.01331624f, -0.05586978f, 0.01434015f, 
    -0.00846247f, 0.10670737f, 0.05169313f, 0.04865409f, 0.17372292f, -0.16830570f, -0.19814517f, 0.10161334f, 
    0.07669522f, 0.01585050f, -0.05442014f, -0.09403140f, 0.04142406f, -0.03051484f, -0.03429462f, -0.03114134f, 
    -0.04891006f, 0.10483721f, -0.03428194f, 0.07075813f, 0.07813164f, 0.04525667f, -0.01538315f, -0.01484205f, 
    0.15337682f, -0.30340210f, -0.25400153f, 0.19773337f, 0.07872969f, 0.05949954f, -0.00838791f, 0.03637537f, 
    0.03430334f, -0.06370600f, -0.00409977f, 0.00306892f, -0.07916854f, -0.12410983f, 0.00688673f, 0.02066224f, 
    0.05789087f, 0.11628492f, -0.04709250f, -0.06753725f, 0.06314684f, -0.03085640f, -0.11621826f, 0.00621736f, 
    -0.14735326f, 0.00810562f, -0.10214204f, 0.02435465f, -0.05262176f, 0.00852818f, -0.06168927f, -0.00893388f, 
    0.07552133f, -0.04000279f, 0.06689221f, -0.01078879f, 0.04295969f, 0.06622418f, 0.04518038f, 0.02942796f, 
    -0.47427648f, -0.07494750f, 0.05900707f, 0.02576194f, 0.02974144f, -0.06033888f, -0.03695245f, 0.04567700f, 
    0.01762662f, -0.12039042f, -0.02678086f, -0.02042999f, 0.03758222f, -0.07794233f, 0.05720001f, 0.00846647f, 
    0.00811712f, -0.03909172f, -0.06985198f, -0.00847895f, -0.27208328f, 0.15507175f, -0.07362268f, -0.00966744f, 
    -0.04160518f, 0.00164223f, -0.18063106f, 0.01848733f, 0.01165480f, -0.06291596f, -0.00406909f, -0.03770278f, 
    -0.05698908f, -0.01729593f, -0.01340014f, -0.01833578f, 0.02638265f, 0.02668232f, 0.10234760f, 0.01764784f, 
    0.07352623f, -0.06589084f, 0.01544477f, -0.07602388f, -0.13628654f, -0.04386929f, 0.05413578f, -0.02926284f, 
    -0.02533804f, -0.04754878f, 0.08973504f, -0.03963196f, 0.01748333f, 0.02705780f, -0.00526297f, -0.05202859f, 
    0.05655166f, -0.09293229f, -0.01630528f, -0.05414244f, -0.14785083f, 0.00634243f, -0.05228323f, 0.10899508f, 
    -0.03064454f, 0.05974000f, 0.01976171f, -0.00693775f, 0.00832603f, -0.12986834f, 0.03875728f, -0.02553389f, 
    0.00704805f, -0.01161073f, 0.02136603f, 0.03774515f, -0.04911009f, 0.01128139f, -0.00266165f, -0.01089850f, 
    -0.10925268f, -0.00187738f, 0.20679255f, 0.17055245f, 0.01458434f, 0.00112595f, -0.13041380f, 0.06317302f, 
    -0.08336353f, -0.13345166f, 0.03385697f, -0.00878029f, -0.00186501f, -0.05362555f, 0.03252906f, 0.05005299f, 
    -0.00387482f, -0.02997961f, -0.06599384f, -0.01184978f, -0.05459629f, -0.20443730f, 0.04818655f, 0.10893379f, 
    0.12972923f, 0.00111394f, 0.04573248f, -0.00232631f, -0.09987710f, -0.07214611f, -0.01170757f, 0.05661134f, 
    -0.10748874f, 0.02095957f, -0.00576665f, -0.07691241f, -0.05597797f, -0.05019742f, -0.01102396f, -0.09597417f, 
    0.32286623f, 0.19467278f, 0.04094805f, -0.09165647f, -0.00954634f, -0.05624919f, -0.05018715f, 0.07905993f, 
    0.02107682f, -0.02818719f, 0.03044382f, -0.03264142f, -0.00817264f, 0.07287099f, 0.03053237f, -0.06164438f, 
    -0.01658573f, 0.06577858f, -0.02986801f, -0.04167992f, 0.07834342f, -0.02932292f, 0.00920883f, -0.09688746f, 
    0.02615531f, -0.08538408f, 0.01190880f, -0.12299260f, 0.00532870f, -0.09817035f, 0.06389773f, -0.03101663f, 
    -0.10001396f, -0.06054010f, 0.06778668f, -0.07143521f, 0.00513718f, 0.03462554f, 0.05559056f, -0.01513176f, 
    -0.11997715f, -0.21503651f, 0.08628526f, 0.10416450f, 0.03163728f, 0.07402554f, -0.01966030f, -0.02923494f, 
    -0.06802365f, 0.04476787f, 0.02110571f, 0.02059919f, 0.00162791f, 0.02286923f, 0.01020618f, -0.01520577f, 
    -0.12786257f, 0.04963222f, 0.05894939f, 0.04138895f, 0.13742423f, -0.11452411f, -0.09363585f, 0.10633848f, 
    -0.08184657f, -0.04014709f, -0.03908642f, 0.07514558f, -0.04946644f, 0.01809631f, -0.01453468f, -0.00149121f, 
    0.06877974f, 0.00785484f, 0.00327717f, -0.00388312f, 0.02331027f, 0.02590688f, 0.02097827f, 0.11277946f, 
    -0.38651147f, 0.10110799f, 0.16921748f, -0.03776512f, -0.06674818f, -0.10412756f, 0.04220936f, 0.01737035f, 
    0.10967789f, -0.05933009f, -0.01952828f, -0.10034126f, 0.08854025f, 0.02776020f, 0.09851464f, -0.01875469f, 
    0.02739294f, 0.08681037f, 0.14970411f, -0.00721188f, -0.01251386f, 0.12997456f, 0.11439075f, -0.08857390f, 
    -0.05950104f, -0.03331929f, -0.07151061f, -0.00042077f, -0.10163479f, 0.06558754f, 0.02051594f, 0.04007452f, 
    -0.10263822f, -0.08027044f, 0.07969330f, -0.04024553f, 0.06702244f, -0.03819226f, 0.02160292f, 0.05046928f, 
    0.37414286f, 0.23407112f, -0.19708423f, -0.12311079f, 0.01684591f, -0.04778452f, 0.00460710f, 0.04457536f, 
    -0.00485502f, -0.02915775f, 0.00318435f, 0.01991430f, -0.00042658f, 0.07365944f, 0.04218346f, -0.07881987f, 
    0.10222277f, -0.04630101f, -0.01290231f, 0.08462793f, -0.16997224f, -0.13187088f, 0.00971500f, 0.04237761f, 
    0.01486793f, -0.07715907f, 0.12701309f, 0.01412149f, -0.11563487f, 0.04189806f, -0.00677246f, 0.04609706f, 
    0.10229233f, 0.05649784f, -0.03830966f, 0.10642556f, -0.01534603f, -0.03871801f, -0.01700790f, -0.00684897f, 
    0.19412334f, -0.06307847f, -0.15875331f, 0.07595536f, 0.07300632f, 0.07984578f, 0.01675624f, -0.02877415f, 
    -0.07832941f, -0.01381845f, 0.00472977f, 0.06007225f, 0.00281085f, -0.08305010f, -0.02996565f, -0.11748967f, 
    -0.08824837f, -0.05421153f, 0.05328165f, -0.12932961f, -0.01867516f, -0.03289592f, -0.04367678f, 0.09298050f, 
    0.06172711f, 0.10327055f, 0.03782484f, -0.00224287f, 0.08007642f, 0.07779269f, 0.14852779f, 0.01267022f, 
    0.03805669f, -0.04189374f, 0.04523784f, -0.00495617f, -0.10417661f, 0.07325467f, 0.11020453f, 0.06926741f, 
    -0.26748416f, -0.31759125f, 0.11705932f, 0.16037197f, 0.03707159f, -0.07138427f, 0.00020353f, -0.00877318f, 
    -0.03137568f, 0.02503891f, 0.07335279f, -0.01722985f, -0.02434460f, -0.07177752f, -0.01000119f, -0.06361537f, 
    0.02645610f, -0.06132445f, 0.05242085f, 0.00122295f, 0.27725652f, 0.23119235f, -0.22411835f, -0.27689207f, 
    0.03159542f, -0.02588928f, 0.07521868f, -0.00094705f, 0.06271526f, -0.08904145f, -0.00962089f, 0.06802190f, 
    -0.02467494f, 0.08116007f, -0.09068879f, -0.04889796f, 0.07608100f, 0.10716014f, -0.11662873f, 0.07259732f, 
    0.14625631f, -0.03457531f, -0.28794801f, 0.06219672f, -0.30379006f, 0.03721650f, -0.01976535f, 0.01987832f, 
    0.04663641f, 0.02077662f, 0.00799295f, -0.09036159f, 0.03478101f, -0.01597505f, 0.01686605f, 0.00766499f, 
    0.06376858f, -0.02898759f, -0.11178274f, -0.00813509f, 0.08524009f, 0.12014911f, -0.07135015f, -0.18398640f, 
    0.09411110f, 0.03696546f, -0.01511312f, -0.06480865f, 0.06363070f, 0.02225196f, -0.02659285f, -0.08532885f, 
    0.01905297f, -0.02241561f, -0.04651800f, 0.07948665f, -0.00516851f, -0.05706089f, 0.02574445f, -0.02347796f, 
    -0.01303854f, 0.19335459f, 0.02508792f, 0.22026727f, -0.03122928f, -0.01426650f, -0.01578380f, 0.00610226f, 
    0.04811154f, -0.05147478f, 0.10250200f, -0.03118353f, -0.02857758f, 0.09334125f, 0.03888772f, -0.00185821f, 
    0.00542388f, 0.06150433f, -0.00700072f, 0.09516542f, -0.17520180f, 0.11533105f, 0.18605103f, 0.02323067f, 
    -0.02636619f, 0.00757437f, -0.03269641f, -0.03324065f, 0.02348316f, 0.09389140f, 0.01883985f, -0.13206494f, 
    0.12771092f, -0.06813427f, 0.10197159f, 0.07609250f, 0.02311487f, 0.05096855f, 0.03548980f, 0.07799686f, 
    -0.15471669f, 0.07076906f, 0.02682352f, -0.06835649f, -0.09841337f, 0.02998953f, 0.01776265f, -0.10534947f, 
    0.00831171f, -0.10284321f, 0.00391780f, -0.08452513f, -0.03419669f, 0.12262949f, -0.15359537f, -0.03949279f, 
    0.03539241f, 0.01637617f, 0.05179760f, 0.00393289f, -0.09057963f, -0.16586675f, 0.15764081f, 0.09380855f, 
    0.06460098f, -0.12949251f, 0.02301215f, 0.06430696f, 0.01674960f, 0.03099472f, 0.05966920f, 0.04547775f, 
    0.07080682f, -0.02621374f, -0.12405997f, -0.04205293f, -0.01119543f, 0.00159084f, 0.06740465f, 0.01467033f, 
    -0.08583307f, 0.08342667f, 0.01250798f, -0.00817405f, 0.08422561f, -0.05222819f, -0.00056986f, -0.09343532f, 
    0.02147315f, 0.00903079f, 0.08394147f, -0.04523232f, -0.03142842f, 0.02470296f, -0.03761106f, -0.13635471f, 
    -0.08867073f, -0.02925559f, 0.05163833f, 0.01091941f, -0.08887075f, 0.00667412f, 0.19519986f, -0.09738117f, 
    -0.04725629f, 0.00805102f, 0.05239058f, -0.04259830f, 0.00444156f, 0.04427307f, 0.07328678f, 0.01203754f, 
    -0.00056872f, -0.09609829f, 0.04716996f, 0.04872936f, -0.05291526f, -0.05662816f, 0.01296900f, 0.01761202f, 
    0.07775897f, -0.07863889f, 0.01089027f, -0.06366870f, 0.08766080f, -0.00738382f, -0.02837832f, 0.10068442f, 
    0.06990315f, 0.04501117f, 0.06574024f, -0.01026178f, 0.06787876f, 0.01961330f, -0.02627597f, 0.03273172f, 
    0.03298288f, -0.01571142f, -0.05808031f, -0.01060766f, 0.15172426f, 0.05867358f, 0.09637383f, 0.00917158f, 
    -0.03562136f, -0.01102451f, -0.02528077f, 0.04224163f, 0.04062551f, 0.07286803f, 0.02760368f, 0.07569645f, 
    -0.03133237f, -0.01046444f, 0.04395240f, -0.01140392f, 0.10530251f, -0.00555960f, -0.00046492f, -0.03388501f, 
    -0.12909444f, 0.18773371f, -0.30130827f, -0.01908019f, 0.00071154f, 0.11125444f, -0.04017089f, 0.10386828f, 
    0.06858247f, 0.03177148f, -0.01986521f, -0.01698860f, -0.06179962f, 0.02696157f, 0.01177852f, -0.02847282f, 
    0.12198567f, 0.02979176f, 0.02065073f, -0.00160165f, -0.24050231f, 0.11553969f, 0.17614834f, 0.04100652f, 
    -0.02761517f, -0.08061500f, -0.05557146f, 0.04984347f, 0.00776624f, -0.03152246f, 0.00244759f, 0.03627050f, 
    0.00654787f, -0.07958433f, 0.08312364f, 0.07525799f, 0.01125119f, -0.01960407f, 0.00491118f, 0.02430345f, 
    0.32917812f, -0.14142124f, 0.01462705f, -0.10113972f, -0.07708221f, 0.06405786f, -0.03851334f, 0.05185120f, 
    -0.11534944f, 0.06570774f, 0.02087505f, -0.00995807f, 0.03180816f, -0.02152863f, 0.04809542f, -0.00505785f, 
    -0.02604349f, -0.04267003f, 0.04869517f, -0.07815714f, -0.33271703f, 0.00899607f, -0.01854660f, -0.14188585f, 
    0.05746172f, -0.05287936f, -0.05503792f, -0.00166169f, 0.04042649f, 0.12377484f, -0.05265518f, -0.04503099f, 
    0.09059034f, 0.04516769f, -0.00325775f, 0.00995517f, 0.07396035f, -0.04740150f, 0.01469937f, -0.11513778f, 
    0.01221167f, -0.13062051f, 0.15382355f, -0.14495510f, -0.00060842f, -0.06715015f, -0.00197193f, -0.02434838f, 
    -0.03141854f, 0.06748188f, -0.03062273f, -0.01684603f, -0.08657983f, -0.01231581f, 0.10127809f, -0.08915157f, 
    0.01206590f, -0.05748175f, 0.05017287f, -0.01833190f, 0.16585304f, 0.05647222f, 0.01184734f, -0.05555967f, 
    0.08773308f, 0.01225970f, 0.04508534f, 0.01613315f, 0.01676099f, 0.02457935f, -0.02879258f, -0.06529304f, 
    -0.00296703f, 0.02137222f, -0.01850478f, -0.02726534f, 0.00521474f, 0.00672414f, -0.08397621f, -0.08841112f, 
    -0.15307574f, 0.19672635f, 0.07428157f, 0.11261248f, -0.06209832f, 0.05049659f, -0.04284910f, 0.05243700f, 
    0.07896425f, -0.07602691f, -0.04993182f, 0.03192369f, -0.05153536f, -0.00986014f, 0.01531176f, 0.02075266f, 
    -0.03888261f, 0.02274234f, -0.04702444f, 0.06072508f, -0.25623474f, 0.13561110f, -0.16161823f, 0.03052968f, 
    0.16043852f, 0.04328098f, -0.01209305f, 0.01639214f, 0.06027487f, 0.04838115f, -0.04261849f, 0.00917010f, 
    0.03089248f, -0.01311078f, -0.02692516f, -0.04260491f, 0.02255180f, 0.02232871f, 0.00187516f, 0.04108324f, 
    -0.29221645f, -0.08807126f, 0.05787332f, 0.03457930f, 0.15114538f, 0.12371534f, -0.02600566f, 0.14664143f, 
    -0.02859909f, -0.11383383f, 0.02905870f, 0.18286461f, 0.00325701f, 0.01770354f, 0.00274912f, -0.06480028f, 
    -0.12017847f, 0.07941411f, -0.08752426f, -0.09009035f, -0.11533989f, -0.01297770f, 0.01240304f, -0.13140659f, 
    -0.05315258f, 0.06536888f, 0.04117937f, -0.04673856f, -0.00494368f, -0.00419990f, -0.06644633f, 0.09078415f, 
    -0.06796019f, 0.02003866f, 0.08276635f, -0.01654037f, -0.04629941f, 0.01894613f, 0.00966179f, -0.04817284f, 
    0.02693441f, -0.18470061f, 0.06510554f, 0.05078705f, 0.02958369f, -0.06029915f, 0.03162596f, -0.05220184f, 
    -0.06192346f, -0.00706571f, 0.01991419f, -0.01768775f, 0.00293999f, 0.10035232f, 0.03264725f, -0.05629170f, 
    0.03586352f, -0.07056323f, -0.03051566f, -0.02002850f, -0.35852161f, -0.05663697f, 0.07836352f, -0.17650875f, 
    -0.01052014f, 0.06577227f, 0.01300491f, -0.02824858f, -0.03041469f, 0.04790149f, -0.02108152f, 0.01471562f, 
    0.01882952f, -0.07565878f, 0.00653531f, 0.01175474f, 0.05436840f, -0.05662342f, 0.04727244f, -0.02570515f, 
    0.20927879f, -0.15616193f, 0.14229742f, -0.08090997f, -0.05950263f, -0.04470677f, 0.02532283f, 0.04518204f, 
    -0.06400764f, 0.04549671f, 0.03643957f, 0.01157851f, -0.04692204f, -0.08112755f, 0.00406470f, -0.06312287f, 
    -0.01780283f, -0.07439119f, 0.05650568f, -0.03719297f, 0.03978812f, 0.09417500f, 0.11334980f, 0.05436718f, 
    -0.10791489f, -0.01367239f, -0.04610752f, 0.09826141f, -0.05378070f, -0.03730381f, 0.00270296f, 0.00304866f, 
    -0.02367377f, -0.00689316f, 0.04566990f, 0.03726371f, -0.01196684f, 0.04933869f, -0.06224684f, 0.06364232f, 
    -0.12082101f, -0.04749069f, -0.01949344f, -0.09296686f, -0.14365399f, 0.09662153f, -0.03484747f, -0.05400366f, 
    -0.11673660f, -0.01751370f, 0.12319831f, 0.00671124f, -0.03251348f, -0.05450226f, -0.09105793f, 0.00766232f, 
    0.02148275f, -0.12219508f, -0.04573992f, -0.01662804f, -0.47081614f, -0.00448502f, -0.07937586f, 0.05578748f, 
    0.22701547f, -0.01855653f, -0.04034949f, -0.09327329f, 0.07916764f, 0.06129182f, -0.00729137f, 0.01169469f, 
    -0.02063798f, 0.10042748f, 0.03850419f, 0.02415738f, 0.04729976f, 0.08146346f, 0.08058220f, 0.00888232f, 
    0.09438380f, -0.09729191f, -0.08458322f, 0.05792070f, -0.00851775f, -0.10518558f, 0.07770655f, 0.00520828f, 
    0.00074066f, -0.04735801f, 0.00861232f, 0.01547938f, -0.07457505f, -0.01763263f, 0.04145403f, 0.00437899f, 
    -0.03527896f, 0.10184401f, -0.01322770f, 0.07776234f, -0.06573448f, -0.14793311f, 0.07457000f, 0.20772284f, 
    -0.10871018f, -0.09080759f, 0.03393769f, -0.02202112f, -0.00099963f, -0.01766375f, 0.06456015f, 0.01306170f, 
    -0.02257043f, -0.03269828f, -0.02154866f, 0.00431992f, 0.03166672f, 0.09110408f, -0.01348060f, 0.04665012f, 
    -0.32844937f, 0.03480424f, 0.00271909f, -0.03948405f, 0.11981867f, 0.00266264f, 0.06216883f, -0.00663129f, 
    0.06560116f, 0.12611797f, -0.05061441f, -0.05903282f, 0.05585219f, 0.06710394f, -0.02189310f, -0.05474793f, 
    0.06750748f, -0.00640735f, -0.01113082f, -0.11891582f, -0.23764227f, 0.22121783f, 0.12917091f, -0.14820005f, 
    -0.21886788f, 0.13893406f, -0.00610489f, 0.00552031f, -0.03130987f, -0.05084801f, 0.07791393f, 0.04116045f, 
    -0.10593937f, 0.02965805f, 0.09777527f, -0.01150628f, 0.08605010f, -0.01920110f, 0.02043493f, -0.01513327f, 
    0.28291053f, 0.20385721f, -0.07195164f, -0.19725128f, -0.02186256f, 0.03961162f, -0.03864551f, 0.00887163f, 
    0.09126803f, 0.02899410f, -0.00949439f, -0.08528822f, 0.04724825f, -0.03281902f, 0.00051597f, -0.03426090f, 
    0.09509028f, 0.03308170f, -0.04015688f, 0.00210977f, -0.07472087f, -0.05384776f, -0.11191271f, 0.07758702f, 
    0.04499443f, 0.03350324f, 0.05570121f, 0.05510260f, -0.06258193f, -0.00463702f, 0.01435279f, 0.03282699f, 
    0.03098959f, 0.01631422f, -0.00055220f, 0.02403790f, 0.02780606f, -0.09003527f, 0.02007070f, -0.04914524f, 
    -0.35218978f, -0.06939132f, -0.04914296f, 0.06628031f, 0.19504002f, -0.00047337f, 0.01256837f, 0.00895676f, 
    0.04138794f, 0.07984270f, -0.02110937f, -0.01831296f, 0.03053264f, 0.08854961f, -0.01064027f, -0.01401464f, 
    0.00695094f, 0.05921715f, 0.11767636f, -0.07698519f, -0.23220302f, 0.17370217f, -0.02349220f, 0.04937663f, 
    0.02184024f, 0.04463784f, -0.05943031f, 0.00646063f, 0.01441642f, 0.00968347f, -0.01352490f, -0.00673971f, 
    -0.02828624f, -0.02612562f, 0.00027550f, 0.03739601f, 0.04756309f, -0.06254824f, -0.06409869f, -0.07133394f, 
    0.01452083f, 0.10688813f, -0.28011975f, 0.19465138f, -0.13397412f, 0.01864626f, -0.05718768f, 0.05682004f, 
    0.00994776f, -0.07795794f, 0.01582486f, 0.03678271f, 0.03611437f, -0.02131104f, -0.01827447f, -0.00877497f, 
    -0.00030139f, 0.06111507f, 0.07150412f, -0.02565720f, -0.40191585f, -0.00935069f, 0.09180298f, 0.14987126f, 
    0.05499377f, 0.05981170f, -0.06345920f, 0.04378792f, -0.05668453f, -0.04119717f, 0.05218131f, 0.03540400f, 
    -0.06645487f, 0.04873261f, 0.02165212f, -0.03354593f, 0.06304879f, -0.06756373f, 0.01414834f, -0.04206403f, 
    -0.20454678f, -0.04756133f, -0.01580434f, -0.06196832f, -0.09292088f, -0.02582421f, -0.01890511f, -0.09730945f, 
    -0.13988343f, -0.02915454f, 0.03589431f, -0.11241262f, -0.04172451f, -0.07501081f, 0.02656781f, -0.02553121f, 
    -0.05276544f, -0.03269965f, -0.23108990f, -0.08862458f, 0.02559329f, 0.02592036f, 0.05869606f, -0.01667956f, 
    0.08940227f, 0.01672039f, 0.02946682f, -0.03864012f, 0.03698303f, 0.04725801f, 0.00065455f, -0.01058009f, 
    0.01592435f, -0.00533912f, -0.05310386f, 0.01346217f, 0.03863551f, -0.06664202f, 0.08465837f, 0.02977475f, 
    -0.25676635f, -0.05350753f, 0.00501575f, 0.07473242f, -0.04586578f, 0.06597556f, 0.01557829f, 0.04927443f, 
    -0.10342831f, 0.02567011f, -0.02595284f, -0.00839878f, 0.10460757f, 0.10200336f, 0.06626352f, 0.03609844f, 
    0.03236931f, -0.04608322f, -0.02629976f, -0.07422906f, -0.30748856f, 0.13073221f, -0.00339788f, -0.02031341f, 
    -0.08781521f, 0.01221050f, -0.01741545f, -0.01301826f, -0.00629828f, -0.07712153f, -0.06300677f, 0.04572286f, 
    0.03203053f, 0.02541173f, -0.03509445f, -0.00712811f, -0.01763710f, -0.00620164f, -0.02847345f, -0.03443399f, 
    -0.21681324f, 0.08426487f, 0.01560065f, -0.00739074f, 0.00107192f, 0.04357001f, 0.00017027f, 0.04707039f, 
    -0.03052766f, -0.09541199f, -0.00834947f, 0.05158393f, -0.05863829f, 0.06680158f, 0.00486425f, 0.03013680f, 
    -0.06893623f, 0.01103067f, -0.02391721f, -0.01215675f, -0.16590035f, -0.20919202f, 0.04638713f, 0.16059597f, 
    -0.12662321f, -0.09260617f, 0.00079383f, -0.02990930f, -0.09970389f, 0.02169253f, 0.00663049f, 0.07329288f, 
    0.00674766f, -0.04062129f, 0.11696294f, -0.01486181f, -0.02760383f, 0.04631585f, 0.04299204f, 0.08112170f, 
    -0.05481258f, -0.06345010f, 0.09745367f, 0.15809941f, -0.00307201f, -0.00565434f, 0.06344797f, 0.02924086f, 
    -0.03328197f, -0.02247753f, 0.04194059f, 0.03939562f, 0.02969163f, 0.05405124f, 0.01600614f, -0.03985162f, 
    -0.02627265f, 0.02429399f, 0.08365251f, -0.00849448f, -0.03772175f, 0.24234192f, 0.01653880f, -0.01441713f, 
    -0.07722342f, 0.06750376f, 0.01291134f, 0.01093724f, 0.03919135f, 0.00651185f, 0.02352962f, -0.06521245f, 
    -0.01234899f, 0.11677755f, -0.01668319f, -0.10122306f, 0.03536096f, 0.01662965f, -0.11940773f, 0.01713076f, 
    -0.37989900f, -0.10690004f, 0.15047324f, 0.07086319f, -0.02150517f, -0.07632037f, 0.03985703f, -0.15146324f, 
    0.00482309f, 0.05571798f, -0.01418245f, -0.05116464f, -0.01356099f, 0.00771112f, 0.05727523f, -0.06621655f, 
    0.01721082f, -0.03962655f, -0.04981241f, 0.00579243f, -0.39542076f, 0.18526562f, -0.01453679f, 0.15397553f, 
    0.14670117f, 0.04550384f, -0.13771866f, -0.00297343f, 0.12910280f, 0.17446725f, 0.03798069f, 0.05505458f, 
    0.01283472f, 0.01493459f, 0.03486294f, 0.06089291f, -0.03653647f, 0.01365067f, 0.07611150f, -0.01982050f, 
    -0.31751636f, -0.13684653f, -0.06059419f, -0.01256694f, 0.09777068f, -0.01411745f, -0.02771270f, 0.07096078f, 
    0.03474094f, -0.02167233f, -0.01463290f, 0.02624032f, -0.06750974f, 0.04525286f, 0.00841120f, -0.01624611f, 
    0.04736837f, -0.09438568f, 0.01776623f, -0.10171768f, -0.42805523f, -0.06242967f, -0.04383882f, -0.05161848f, 
    0.17821664f, 0.02525288f, -0.00510812f, 0.07443081f, -0.01488588f, -0.04945904f, -0.06498004f, -0.04132371f, 
    0.04168867f, 0.06454970f, -0.03435514f, -0.02761274f, 0.00243380f, 0.09345715f, 0.13668793f, -0.04961796f, 
    -0.02741344f, 0.10492732f, 0.02094489f, 0.13456585f, 0.15173759f, -0.00986420f, -0.16177909f, 0.07178482f, 
    -0.03853548f, 0.05655115f, -0.00561668f, -0.04473414f, -0.02534503f, -0.01888064f, -0.00529895f, 0.05955525f, 
    0.06010265f, -0.05541401f, 0.09386070f, 0.09573016f, -0.18348640f, -0.08869085f, 0.05336113f, 0.12073900f, 
    0.08789377f, 0.03355797f, -0.04797691f, 0.00824018f, 0.02414594f, 0.12986881f, -0.00328754f, 0.04600814f, 
    0.09774771f, 0.07437276f, -0.00846051f, -0.11330123f, 0.09870484f, -0.18650140f, -0.02183975f, 0.00007264f, 
    0.04491924f, -0.03184482f, -0.00659501f, 0.06165449f, -0.05315949f, -0.04114909f, 0.02868250f, 0.04217744f, 
    -0.02328056f, 0.09006410f, 0.04631516f, 0.00356111f, 0.00520767f, 0.07909582f, 0.00140846f, -0.08216837f, 
    -0.09126791f, -0.05410612f, 0.11842968f, 0.02954516f, 0.11118607f, 0.08903632f, -0.00059996f, 0.01006132f, 
    -0.02591933f, -0.00185344f, -0.05560907f, 0.06418350f, 0.00211259f, 0.05204990f, 0.02710944f, -0.03136050f, 
    0.04184689f, 0.14354761f, 0.06738385f, 0.07321095f, 0.01899063f, 0.05809345f, -0.25708744f, 0.09660109f, 
    -0.13978766f, -0.05200627f, 0.06216917f, 0.14787498f, -0.15348344f, 0.02524793f, 0.01492904f, -0.01495328f, 
    0.03353355f, 0.05064991f, 0.05656464f, 0.03182225f, -0.04500991f, 0.03365758f, -0.04230270f, -0.04726836f, 
    -0.06284655f, -0.03505094f, 0.00173501f, -0.08437420f, 0.10142796f, -0.03341112f, -0.01198975f, 0.00631295f, 
    0.11537832f, -0.03216862f, 0.02410831f, 0.00330995f, -0.02798749f, 0.04456535f, -0.00787673f, -0.01993745f, 
    0.05410914f, 0.11382809f, 0.16877899f, 0.01332150f, 0.06998692f, -0.05583457f, -0.05743856f, -0.01243283f, 
    0.05225460f, 0.03367395f, -0.04162691f, -0.03622945f, 0.26776379f, -0.04694835f, -0.08842479f, 0.04497450f, 
    0.12256151f, 0.11155270f, 0.02867466f, -0.00982409f, -0.00542159f, 0.08332780f, 0.14303432f, -0.00391307f, 
    0.08437401f, -0.02219443f, -0.14646383f, -0.02785815f, -0.03089358f, 0.08216913f, 0.09972762f, -0.05694139f, 
    -0.10504482f, 0.11070208f, 0.07432172f, -0.08012862f, -0.03223187f, 0.14502490f, -0.00698877f, 0.03938516f, 
    0.00805667f, 0.03759463f, -0.06202560f, 0.04689716f, -0.07386344f, 0.04165319f, -0.02116206f, -0.00709387f, 
    -0.22697306f, 0.04122389f, -0.24974622f, -0.04514869f, 0.09874626f, 0.10695938f, 0.03619387f, -0.04226894f, 
    -0.03189088f, -0.13991441f, -0.02734179f, -0.04307188f, -0.06887335f, 0.00368028f, -0.13456021f, -0.03588470f, 
    -0.00246215f, -0.01015196f, -0.02126815f, -0.03240171f, -0.01156531f, -0.04635554f, 0.03170673f, -0.00180844f, 
    -0.06494290f, -0.01714651f, 0.05355136f, 0.00564959f, 0.01063432f, -0.05551247f, 0.03622019f, -0.01690597f, 
    0.11920868f, 0.07274411f, 0.10668688f, -0.12734586f, 0.03018518f, 0.05686350f, -0.05877070f, -0.03960522f, 
    -0.16715369f, -0.06120513f, 0.20481014f, 0.15863892f, -0.42532375f, 0.00271146f, 0.01125652f, 0.02851294f, 
    -0.09629468f, -0.01428641f, 0.03303747f, -0.04658714f, -0.04374301f, -0.02713650f, -0.09502468f, -0.08744673f, 
    0.00427813f, 0.08664817f, 0.07343754f, -0.00950619f, -0.02756606f, 0.13421629f, 0.08512311f, -0.02067093f, 
    -0.04599873f, -0.02217480f, -0.03575264f, -0.08191563f, -0.06862352f, -0.03645701f, 0.04195259f, 0.05276665f, 
    -0.13162732f, -0.07827007f, 0.04013270f, 0.03534451f, 0.02284985f, 0.11192901f, 0.01858465f, 0.03686843f, 
    -0.38264593f, -0.03995164f, -0.02445243f, -0.04523174f, 0.05221472f, 0.00251413f, 0.01767332f, -0.04650633f, 
    0.02956838f, -0.00118056f, 0.08585529f, -0.06315753f, -0.06453361f, 0.04780557f, -0.06341213f, 0.08799335f, 
    0.10655970f, 0.02494693f, -0.09176987f, 0.07223094f, -0.38605070f, -0.00049442f, -0.12569092f, -0.00806851f, 
    0.11220295f, 0.08796936f, 0.02217739f, -0.10567101f, -0.02435618f, 0.00526966f, -0.02455527f, 0.08924612f, 
    0.15129119f, 0.10494886f, -0.06038714f, -0.02112157f, -0.05251474f, -0.03326034f, -0.25592980f, 0.02106060f, 
    0.12346936f, 0.03797726f, 0.07949839f, 0.06234815f, 0.04067686f, -0.12012679f, -0.05714779f, 0.08115239f, 
    0.00964091f, 0.09383596f, -0.08790777f, -0.15936626f, 0.04642994f, 0.04544859f, 0.08318868f, 0.01253108f, 
    0.03768831f, -0.04208663f, -0.00251112f, 0.02998730f, -0.19360308f, -0.06552462f, 0.19073533f, 0.20701456f, 
    -0.03663260f, 0.10682715f, 0.00727873f, 0.00105943f, -0.01083818f, 0.01228353f, 0.01263615f, -0.09153264f, 
    -0.04294881f, -0.08618243f, 0.05063624f, -0.09574275f, -0.05258494f, -0.08527450f, 0.03182319f, -0.05493176f, 
    -0.02627181f, 0.21584350f, -0.03233168f, -0.00690618f, 0.04208386f, -0.01190372f, -0.00816495f, -0.03040384f, 
    -0.06551677f, 0.08367465f, 0.07985207f, -0.02383426f, -0.00643496f, -0.01603374f, -0.07129894f, 0.05286317f, 
    0.00681304f, -0.06480411f, 0.16221361f, 0.03737848f, -0.11700395f, -0.05195401f, 0.09396544f, 0.20682669f, 
    -0.05437160f, 0.05430165f, 0.05143064f, 0.01515346f, 0.03415947f, -0.01292249f, 0.02407312f, 0.05128177f, 
    -0.00313652f, 0.03689693f, 0.07611679f, -0.04891701f, 0.04340948f, 0.02580857f, -0.03181927f, -0.14254263f, 
    0.03066971f, 0.10297494f, -0.11493632f, 0.07803921f, 0.09608035f, 0.05373102f, -0.05376134f, 0.02450006f, 
    0.05631209f, 0.09392347f, 0.04904292f, 0.19153446f, 0.04647588f, -0.04642294f, 0.01519311f, -0.13211726f, 
    -0.00761430f, 0.01214018f, -0.12967470f, -0.13168883f, -0.08070925f, 0.02616707f, -0.07372830f, -0.01722268f, 
    0.06226858f, -0.05993498f, 0.08874879f, -0.04265982f, -0.00191788f, -0.01166276f, -0.11018071f, 0.08195575f, 
    0.02929222f, 0.04148517f, 0.00739953f, -0.18232627f, 0.00109571f, -0.00751844f, -0.09812976f, -0.10623524f, 
    -0.04711883f, 0.01657236f, -0.00849496f, 0.23362713f, 0.10447540f, 0.02437113f, -0.07367416f, 0.07224704f, 
    0.03502255f, 0.05216667f, 0.00359698f, 0.12233699f, 0.01335242f, -0.00343087f, 0.02956785f, 0.11822260f, 
    -0.07153647f, -0.01372662f, -0.07006323f, -0.12206223f, 0.09730010f, 0.03410816f, 0.01545639f, 0.07490110f, 
    -0.20127535f, 0.00423279f, -0.05103458f, 0.05467674f, 0.01861377f, 0.00655413f, -0.13540623f, 0.00446880f, 
    -0.02052233f, 0.04967268f, -0.02028958f, -0.00065902f, 0.01021070f, 0.01349365f, 0.08501835f, 0.01838690f, 
    -0.36415559f, 0.17221005f, -0.21039774f, 0.16250859f, 0.09073776f, 0.01941326f, -0.11425909f, 0.04274599f, 
    -0.11290779f, 0.10207177f, 0.04524216f, 0.06927508f, 0.00363267f, -0.05904391f, -0.00990382f, 0.12529612f, 
    -0.01967578f, 0.02490923f, -0.12461881f, -0.22782904f, -0.08970752f, -0.11339594f, -0.03331489f, 0.12891196f, 
    0.07992209f, -0.02088973f, 0.01193984f, 0.06653073f, 0.00494724f, -0.06410594f, -0.08135362f, -0.02137809f, 
    0.02711413f, 0.02066589f, 0.04601827f, -0.07697712f, 0.00421587f, 0.06824500f, -0.01383942f, -0.04666725f, 
    0.10033983f, 0.04564744f, 0.16501197f, -0.00430210f, -0.07669666f, 0.03170400f, -0.01716965f, 0.00601828f, 
    -0.06391668f, -0.02702669f, 0.03928522f, 0.00631946f, -0.01756347f, 0.05011234f, 0.03285107f, 0.03731014f, 
    0.00889654f, 0.12410107f, 0.07147517f, 0.00292779f, 0.11176290f, -0.05450930f, 0.02289059f, 0.06063578f, 
    0.10946918f, -0.08884533f, -0.01617436f, -0.08495921f, -0.07786749f, 0.01340091f, 0.01310996f, -0.02242943f, 
    0.12685765f, 0.03253139f, 0.05438768f, -0.01602729f, -0.00141143f, 0.01782157f, 0.01542859f, 0.01361846f, 
    -0.18195814f, 0.09138015f, 0.13046773f, 0.07501876f, -0.16883457f, -0.06271102f, 0.07428305f, 0.00628390f, 
    -0.06614648f, -0.08539017f, 0.07762209f, -0.04927722f, 0.03730350f, -0.07747410f, -0.05398173f, 0.04814814f, 
    0.00409300f, 0.06051081f, 0.02385568f, 0.02716858f, -0.00235091f, -0.03087884f, -0.00093039f, 0.01378050f, 
    -0.27544376f, -0.01955839f, 0.00604812f, -0.10819112f, 0.06196725f, -0.11412065f, -0.04931318f, 0.03243545f, 
    -0.02673086f, 0.04825155f, 0.16722827f, -0.10683649f, 0.01325512f, -0.01604297f, 0.03877591f, -0.08462006f, 
    0.00369757f, 0.02980223f, 0.06765312f, -0.02465981f, 0.08696388f, -0.04574142f, -0.02800979f, -0.00242314f, 
    -0.14658323f, 0.05289894f, 0.01116054f, 0.02315889f, 0.02115600f, -0.03236863f, -0.11575420f, -0.01197307f, 
    -0.03431643f, 0.13376299f, 0.07352523f, 0.00152977f, -0.04743639f, -0.00403984f, -0.03117980f, 0.00043474f, 
    -0.16991878f, 0.03191879f, 0.01782844f, -0.03029887f, -0.00361962f, 0.01660812f, -0.02798835f, -0.01783382f, 
    -0.00444055f, -0.05079704f, -0.09458029f, 0.08686893f, -0.12252431f, 0.01531154f, -0.02525782f, 0.04421908f, 
    0.06016646f, 0.02609093f, 0.03068507f, 0.07669319f, 0.07782031f, -0.04459740f, 0.13474141f, -0.03717043f, 
    0.02725850f, 0.05086664f, 0.08771077f, -0.11804824f, 0.07239829f, 0.03366628f, -0.05139577f, 0.09807593f, 
    0.09686082f, 0.03255552f, -0.05642533f, 0.01317920f, 0.03056364f, 0.05767076f, 0.01641512f, -0.03442387f, 
    0.01991840f, 0.01153170f, -0.00789103f, -0.02650884f, 0.01350641f, 0.06344043f, 0.06898540f, -0.03333458f, 
    0.02400759f, -0.04034138f, -0.09919387f, -0.07629895f, -0.04455282f, 0.08687709f, 0.02007981f, 0.03535669f, 
    -0.28840935f, -0.06579533f, -0.08522620f, -0.01252400f, 0.10027027f, 0.09366912f, 0.09813210f, -0.08216796f, 
    0.00684561f, 0.07938050f, 0.02249689f, -0.04267307f, 0.06676602f, -0.00119346f, 0.03985883f, -0.09193392f, 
    0.08943775f, -0.10043360f, 0.09894624f, -0.08653755f, -0.53441489f, -0.21502152f, -0.19322979f, -0.13300112f, 
    -0.04976828f, 0.09574613f, 0.00684454f, 0.03833254f, -0.06815115f, -0.10408809f, -0.00588149f, 0.07474358f, 
    -0.03152330f, -0.02318373f, 0.00857250f, 0.04129045f, -0.01963268f, 0.06127132f, -0.05082632f, 0.00410667f, 
    -0.00110163f, 0.00398396f, 0.01863715f, -0.05976461f, -0.02495448f, 0.02169548f, -0.12912676f, 0.10870367f, 
    0.07005214f, 0.00915115f, 0.00586306f, -0.04324628f, -0.08396169f, -0.03619883f, 0.06996620f, 0.09770821f, 
    0.06383675f, -0.11491631f, -0.08619832f, 0.04161142f, -0.12847683f, -0.20662354f, -0.02791775f, -0.14840074f, 
    0.07173092f, 0.00734800f, -0.00663110f, 0.12483262f, 0.06350300f, -0.11387093f, -0.01859866f, -0.03941204f, 
    -0.00431011f, 0.03577909f, -0.00434854f, -0.02620772f, 0.03650983f, 0.02137071f, -0.06599233f, 0.05649019f, 
    0.00614999f, 0.03589687f, -0.07369210f, -0.05220244f, -0.00703757f, 0.03856198f, -0.01315294f, -0.02795628f, 
    -0.04175807f, -0.04426232f, -0.04420104f, -0.04410842f, -0.11135845f, 0.03795468f, -0.03211973f, 0.11056674f, 
    0.05164846f, 0.05356225f, -0.01332596f, -0.00742038f, -0.20562078f, 0.12249129f, -0.02089851f, 0.02302175f, 
    -0.12470317f, 0.04168374f, 0.03936432f, -0.00048792f, 0.04862674f, 0.04451344f, -0.00219651f, -0.02560734f, 
    0.01101759f, 0.02306471f, -0.03011214f, 0.01946745f, -0.06708122f, -0.00097839f, -0.12301682f, -0.06658544f, 
    0.09419889f, 0.02580859f, 0.07037923f, 0.02302539f, 0.00251297f, -0.04412961f, -0.04907151f, -0.05418251f, 
    -0.11761185f, 0.09060334f, 0.05602969f, 0.01688477f, -0.00352872f, -0.05457938f, -0.11125454f, 0.05087459f, 
    -0.08013336f, 0.11875433f, 0.13656087f, 0.05072759f, 0.03995388f, -0.09919901f, 0.09474360f, 0.08877958f, 
    0.06318390f, 0.02377322f, 0.07074938f, -0.06357181f, 0.03841898f, 0.01640685f, 0.02273613f, -0.00414954f, 
    -0.03613625f, 0.05572681f, 0.00958337f, -0.04565352f, -0.10534464f, -0.07718977f, 0.05229785f, 0.01733677f, 
    -0.22516499f, -0.06826302f, -0.03656136f, 0.19985358f, 0.06203857f, -0.04369224f, -0.02367910f, -0.05998206f, 
    0.00026158f, 0.05593104f, 0.08569022f, -0.03324447f, 0.05459360f, 0.03606988f, 0.04051255f, -0.02267065f, 
    -0.12316004f, -0.04169896f, -0.15577313f, -0.08774137f, -0.22120030f, 0.27630794f, -0.26967344f, -0.13806750f, 
    -0.06560303f, 0.09304687f, 0.08120131f, 0.02817033f, -0.05316243f, -0.02961709f, -0.00670129f, 0.01951123f, 
    0.04258827f, -0.15759587f, -0.01663509f, 0.05115154f, -0.00357925f, -0.02902260f, 0.09167918f, -0.06258504f, 
    0.04987205f, 0.03252666f, -0.09750934f, -0.02898370f, 0.17704855f, -0.06087855f, -0.10898323f, -0.02691700f, 
    0.12770537f, -0.01422124f, 0.03494535f, 0.00602426f, -0.05853555f, 0.21296413f, 0.11251367f, -0.01771579f, 
    -0.04315353f, 0.08144783f, -0.20943654f, 0.08692431f, 0.00817935f, -0.00364788f, -0.03273644f, 0.03722974f, 
    0.15009232f, -0.06733914f, -0.15026124f, 0.00855817f, -0.00150623f, 0.03831544f, -0.03220101f, -0.08919028f, 
    0.03150130f, 0.03206557f, 0.01549518f, -0.02407338f, -0.02889990f, -0.05878157f, -0.05531514f, -0.06754062f, 
    0.04899442f, 0.16892725f, -0.19330791f, -0.07219270f, -0.09625501f, 0.08457534f, 0.05476276f, 0.03194814f, 
    0.05548447f, -0.04483957f, 0.00691510f, 0.03357614f, -0.06316550f, -0.05211906f, -0.09613142f, 0.02289327f, 
    -0.03007988f, 0.01460490f, 0.06105384f, -0.01471473f, -0.26601714f, -0.15614069f, -0.05763841f, 0.12635770f, 
    -0.21417333f, -0.00585114f, 0.03570616f, 0.07525939f, 0.02113507f, -0.03469450f, -0.05041926f, 0.05534216f, 
    0.09328816f, 0.05438534f, 0.00833576f, -0.00014472f, 0.00259407f, -0.16990666f, -0.01134931f, -0.00081812f, 
    -0.20014110f, -0.20006627f, 0.00254947f, 0.09237248f, -0.16644239f, 0.07998955f, 0.03525340f, -0.04680317f, 
    -0.04660080f, 0.08605593f, -0.02082122f, 0.01323541f, 0.01880969f, 0.01993172f, 0.00160451f, -0.03604803f, 
    -0.02149560f, 0.05057614f, 0.04285046f, -0.06461673f, -0.28294095f, 0.10547487f, 0.03681190f, -0.01739478f, 
    -0.05453273f, -0.05181279f, -0.03127380f, 0.00902212f, -0.02571857f, -0.02905977f, 0.08100448f, 0.03816374f, 
    -0.04574263f, 0.00511624f, 0.01200839f, 0.00719186f, 0.02981982f, 0.00110886f, -0.01881603f, -0.00782132f, 
    -0.37957609f, -0.01564042f, -0.30481622f, -0.14514059f, -0.04710140f, 0.08260599f, 0.12581350f, 0.01460004f, 
    -0.03290840f, -0.13652776f, -0.01324926f, 0.03685816f, 0.02957054f, -0.06449906f, -0.02001523f, 0.05815863f, 
    0.01796404f, 0.01275229f, -0.06155798f, 0.06317899f, 0.04355031f, -0.01037741f, -0.01604102f, 0.05047638f, 
    -0.30840927f, 0.00369936f, -0.08142728f, -0.02188993f, 0.00241830f, -0.00020882f, -0.02662072f, 0.07486042f, 
    0.02155408f, 0.07045744f, 0.03016393f, -0.00392516f, -0.02778595f, 0.03246290f, -0.02967699f, 0.01708039f, 
    -0.10697318f, -0.18393405f, 0.01874243f, 0.01375954f, 0.11437291f, 0.00018305f, -0.03092609f, -0.10194834f, 
    0.03336184f, 0.05210656f, 0.01744520f, -0.06527756f, 0.03744725f, 0.12325102f, 0.01174294f, 0.04868663f, 
    0.00657305f, -0.13824840f, -0.17115159f, 0.06261092f, 0.09577291f, -0.00396767f, 0.05335191f, 0.07801750f, 
    -0.24338488f, -0.13778852f, -0.06182337f, 0.03593767f, 0.08844499f, 0.05402110f, -0.00270081f, 0.02650680f, 
    0.08748922f, 0.04792756f, 0.02837099f, -0.10182529f, -0.06243120f, 0.00512390f, 0.00139979f, 0.05473824f, 
    -0.08648518f, -0.01636998f, -0.08025225f, 0.13638826f, 0.04780001f, 0.00600964f, 0.01486686f, -0.04007834f, 
    0.06412197f, 0.10073654f, 0.12585069f, -0.02608170f, -0.03880847f, -0.04196995f, -0.00107980f, 0.01472159f, 
    0.04884317f, -0.06955777f, -0.00955751f, -0.01028813f, 0.10275149f, 0.05238856f, -0.00080963f, 0.06458272f, 
    -0.19654925f, 0.00864611f, -0.02333135f, 0.00635993f, -0.06188900f, -0.00151017f, 0.03456109f, 0.01955696f, 
    0.09246428f, -0.02180517f, 0.00842104f, 0.02980357f, -0.06041255f, 0.11568116f, 0.07583320f, 0.01771212f, 
    0.03052051f, 0.23292254f, -0.03369621f, -0.05317058f, -0.03258286f, 0.02284461f, 0.00804354f, -0.06617057f, 
    -0.08082224f, -0.12563463f, 0.00778283f, 0.06370857f, -0.09219102f, -0.04488408f, 0.07671665f, 0.01536177f, 
    0.02403348f, 0.05744745f, 0.12291694f, -0.04008520f, -0.24943011f, -0.01280105f, -0.00316715f, 0.05551914f, 
    0.03069834f, 0.00237532f, -0.07137878f, 0.09040067f, 0.10422332f, 0.01665124f, 0.00124514f, -0.07113390f, 
    -0.02870733f, 0.00360745f, 0.06530422f, -0.06853262f, 0.05378737f, -0.09483242f, 0.00110941f, -0.06370691f, 
    -0.20711851f, -0.01891067f, -0.02631731f, 0.02332161f, 0.10263640f, 0.03272318f, 0.03425268f, 0.04525170f, 
    0.03985495f, 0.06613569f, -0.02085932f, 0.00993655f, 0.12707074f, 0.00202038f, 0.08079439f, -0.02332041f, 
    0.14793001f, -0.11804415f, 0.03142874f, 0.00453071f, 0.06315458f, 0.06575643f, 0.11347199f, 0.14919919f, 
    0.09863067f, -0.02896648f, -0.01883990f, -0.01596180f, 0.05161972f, 0.11773241f, -0.07440927f, -0.17042412f, 
    -0.01340117f, 0.14115953f, 0.01934217f, 0.04421607f, 0.07825632f, -0.21983513f, -0.03799970f, 0.12199625f, 
    0.18518701f, 0.09413186f, 0.01329293f, -0.00480735f, 0.06241967f, 0.03268735f, -0.09998025f, 0.03313766f, 
    -0.05402070f, -0.04063342f, -0.00542308f, -0.02245019f, 0.02520848f, 0.07859078f, 0.10168011f, -0.03800553f, 
    0.00889033f, -0.08669715f, -0.12841932f, -0.05165324f, -0.04230710f, -0.16563022f, 0.03239088f, 0.16019338f, 
    -0.06265412f, -0.00044244f, -0.03447478f, 0.04044268f, -0.00878290f, -0.00604681f, 0.01692052f, 0.00021866f, 
    -0.03878541f, -0.02408556f, 0.09385803f, 0.04329119f, 0.00686706f, -0.04018261f, 0.08393367f, -0.05254673f, 
    0.02317789f, 0.00250614f, -0.10564432f, 0.18506733f, 0.01870318f, 0.04319889f, -0.03814828f, 0.04276262f, 
    0.02961986f, 0.07471788f, -0.07790620f, -0.01163371f, -0.02257560f, 0.05785419f, 0.07958888f, -0.00903116f, 
    0.08178646f, -0.01869348f, 0.06901229f, -0.02649483f, -0.27927464f, 0.01281405f, -0.34667870f, -0.19210377f, 
    0.05438416f, 0.06785944f, 0.14847380f, -0.02644626f, -0.06959850f, -0.09886023f, -0.01231937f, 0.10909701f, 
    -0.01341412f, -0.09319536f, 0.01115876f, -0.10622161f, 0.04492712f, 0.08989380f, 0.09634466f, -0.02319933f, 
    0.11511971f, 0.06218152f, 0.03513880f, -0.01536761f, -0.22945641f, -0.12316455f, -0.05910686f, -0.00001547f, 
    -0.00127574f, 0.08151843f, -0.00760949f, 0.00123332f, 0.09734738f, -0.01165755f, -0.01108015f, 0.02555170f, 
    0.03687443f, 0.01510241f, 0.06390518f, 0.08354064f, -0.51864946f, 0.02741550f, -0.15675440f, -0.20341365f, 
    -0.03936350f, 0.03461353f, 0.01070793f, 0.15852657f, -0.01851204f, -0.03747841f, 0.14400683f, -0.06599344f, 
    0.02205604f, -0.06868365f, -0.01324011f, -0.03412359f, -0.03793651f, -0.09356338f, -0.07779121f, 0.05802012f, 
    -0.10760759f, 0.09645613f, -0.06500714f, 0.16836783f, -0.14394529f, 0.08088090f, 0.11991706f, -0.05910543f, 
    0.07751358f, 0.00723462f, -0.07093570f, 0.02262606f, 0.11981835f, 0.01544532f, -0.12172736f, 0.11271876f, 
    -0.01741070f, 0.02007075f, -0.02215442f, -0.02115061f, -0.00523424f, 0.09077769f, -0.04832432f, -0.16211386f, 
    0.07310468f, -0.05716597f, 0.03289576f, -0.03791910f, -0.09836160f, -0.05947167f, -0.04403370f, -0.18313581f, 
    -0.03782188f, -0.03365857f, -0.04198281f, 0.03092837f, -0.00766543f, 0.12304341f, 0.11123249f, 0.04215667f, 
    -0.19411987f, 0.04612694f, 0.06132796f, 0.04413174f, -0.18890119f, 0.09362822f, 0.09282508f, 0.09453902f, 
    0.06675687f, -0.01274198f, -0.05282269f, 0.02298483f, 0.01181290f, 0.10679816f, -0.13085906f, -0.04897014f, 
    0.05300080f, 0.00054048f, 0.05750339f, -0.03875779f, 0.02674865f, -0.06913220f, -0.03242164f, -0.02442178f, 
    0.00800220f, 0.03551816f, 0.07714730f, 0.04573850f, -0.00483954f, -0.07792826f, 0.05647288f, -0.04915272f, 
    -0.09818424f, -0.06593417f, -0.03034367f, -0.05193856f, 0.03696336f, -0.00008329f, 0.06688090f, -0.12933217f, 
    0.09699387f, -0.12821063f, -0.03390156f, -0.03220435f, 0.04272304f, -0.02603909f, -0.08099984f, 0.04404616f, 
    -0.05179732f, 0.07462000f, -0.03828917f, 0.01327924f, -0.06317730f, -0.04219543f, -0.04717859f, 0.06385423f, 
    -0.00652493f, 0.07422094f, 0.04211381f, 0.03313543f, 0.09429199f, -0.06819683f, -0.06863935f, -0.22425757f, 
    -0.02608836f, 0.10517287f, -0.03601793f, 0.04001807f, -0.08637656f, -0.02635395f, 0.06443600f, 0.05958200f, 
    0.00470149f, 0.02896253f, -0.14859571f, 0.05387851f, -0.10646904f, -0.01817576f, 0.10164665f, 0.03967406f, 
    0.01038582f, 0.12214155f, -0.11995193f, -0.10526515f, -0.08522382f, 0.04989581f, 0.05512398f, 0.03071870f, 
    -0.04465010f, 0.01852342f, -0.06022986f, -0.01911837f, -0.04609285f, -0.05365947f, -0.04931878f, 0.00437109f, 
    -0.03452969f, 0.13594344f, 0.08616669f, 0.08366842f, -0.01047306f, 0.08922923f, 0.06189850f, -0.03750282f, 
    -0.04797245f, -0.05672597f, -0.01928752f, 0.06825925f, -0.01046388f, 0.04721879f, 0.11615487f, -0.08713567f, 
    -0.02288011f, -0.04237086f, -0.03908177f, 0.04519909f, -0.06980843f, -0.02719052f, 0.00844039f, 0.00719167f, 
    0.33196959f, -0.08545631f, -0.06631114f, -0.19524717f, 0.19487678f, 0.04513660f, -0.06454853f, 0.02371274f, 
    0.06323615f, -0.09932607f, -0.04248610f, 0.05887154f, 0.14052069f, 0.05823233f, 0.00629416f, 0.13097520f, 
    0.04116147f, 0.05965328f, -0.08478747f, 0.15837082f, 0.29603213f, -0.01819829f, 0.08878519f, -0.12816143f, 
    0.20410964f, -0.04372042f, -0.08241775f, 0.03039542f, -0.01946047f, 0.04784714f, -0.05883237f, 0.00907769f, 
    0.05233267f, -0.05952515f, -0.07833450f, -0.04176264f, 0.05230303f, 0.01631439f, -0.02501462f, 0.04836108f, 
    0.23979399f, -0.22652291f, -0.05431911f, 0.00540407f, 0.04485052f, 0.01425774f, -0.01560733f, -0.00844321f, 
    0.01839915f, 0.11095544f, -0.03463170f, -0.01604538f, -0.01765268f, -0.06993606f, 0.05414188f, 0.07055038f, 
    -0.10025535f, 0.02635794f, -0.05387662f, -0.00332449f, 0.03265989f, -0.09719463f, -0.06272783f, 0.14137401f, 
    0.06173560f, 0.01691015f, -0.05385586f, 0.00287616f, 0.13211897f, 0.02757842f, -0.01409076f, 0.01716651f, 
    0.13957642f, -0.04629188f, 0.04534292f, -0.04431808f, 0.09070654f, -0.06193393f, -0.05283726f, -0.06677313f, 
    -0.25657740f, -0.00246149f, 0.08974575f, 0.00732261f, 0.04892635f, 0.01584397f, -0.03928263f, 0.02353138f, 
    -0.08302795f, 0.05701171f, -0.00174081f, -0.04207577f, -0.04746627f, 0.05087948f, -0.08577136f, -0.00956304f, 
    -0.03612987f, -0.11481577f, 0.12283500f, 0.00248933f, -0.27456579f, 0.13072620f, -0.06129564f, -0.31053978f, 
    0.05892435f, -0.08841203f, 0.04735237f, 0.08691289f, -0.09211986f, -0.02774050f, 0.03042985f, -0.04541675f, 
    -0.10931144f, -0.02350515f, 0.01555635f, -0.00049846f, 0.04816741f, -0.02539245f, 0.13757688f, 0.03763179f, 
    -0.07723778f, 0.22862725f, 0.21292183f, 0.06850479f, -0.32241154f, 0.02846557f, 0.06346039f, -0.04715838f, 
    0.03787588f, 0.02306235f, -0.01424441f, 0.08545762f, -0.00164935f, 0.06835136f, -0.14382035f, 0.09885430f, 
    -0.06452107f, -0.06733207f, -0.05015304f, -0.06743478f, 0.06127612f, 0.10359517f, -0.07949225f, -0.07234839f, 
    -0.03268278f, 0.07315264f, 0.05946048f, -0.00107633f, 0.07355713f, 0.09918851f, -0.04603018f, 0.07064106f, 
    0.01815023f, -0.04853114f, 0.07475363f, 0.02460684f, 0.02291301f, -0.06540292f, 0.04752301f, 0.07195678f, 
    -0.08049300f, -0.05686211f, -0.25976035f, 0.21376750f, -0.03638368f, -0.14038475f, 0.08586090f, -0.11035223f, 
    0.05391271f, 0.08086837f, -0.03090787f, 0.09074694f, 0.03952799f, -0.07756636f, -0.02822594f, -0.00586517f, 
    0.00805246f, 0.04638169f, -0.17040758f, -0.02918220f, -0.05515786f, 0.10355698f, -0.12660843f, 0.14781155f, 
    -0.08797356f, -0.03754347f, -0.09825986f, 0.02847654f, 0.08045076f, 0.01371146f, 0.06893731f, 0.08342559f, 
    -0.02036525f, 0.02965612f, -0.06311359f, -0.00695522f, -0.05122156f, -0.02074523f, -0.05039789f, 0.04532417f, 
    -0.23301622f, -0.02353187f, -0.15486270f, -0.17497924f, 0.06171907f, -0.13261399f, 0.12760870f, 0.02302917f, 
    0.07955387f, 0.05137617f, -0.01559014f, -0.04087594f, -0.08137390f, -0.00934344f, 0.13199383f, 0.03258878f, 
    -0.04789595f, -0.01483509f, 0.10011125f, 0.13844757f, 0.18191609f, 0.04544866f, 0.14169367f, -0.06249832f, 
    -0.08212101f, 0.04743078f, 0.07403523f, 0.04068777f, -0.03024654f, -0.08125545f, -0.07940360f, 0.05805799f, 
    0.06087988f, 0.06954987f, 0.06583223f, 0.13068049f, 0.03229109f, -0.12078591f, 0.10346518f, 0.08524218f, 
    -0.13483723f, -0.11525649f, -0.03127737f, 0.01071549f, 0.29848811f, 0.01725587f, 0.00982274f, 0.01192046f, 
    -0.02947695f, 0.01725817f, -0.08225688f, 0.01515655f, 0.07016864f, -0.09668837f, 0.03280883f, 0.01150588f, 
    -0.08170586f, 0.10996498f, 0.05248973f, 0.01962898f, -0.24725348f, 0.28718105f, 0.09741230f, 0.10899210f, 
    -0.26601237f, -0.05238399f, 0.01261515f, -0.04058437f, 0.04245528f, 0.08183971f, 0.00992668f, 0.09833618f, 
    0.05767698f, -0.03048726f, -0.01735114f, -0.05652495f, -0.08360566f, -0.05030043f, -0.09559106f, -0.10109232f, 
    -0.12464497f, -0.03900044f, 0.09500214f, -0.13241731f, 0.11434679f, -0.04599717f, -0.03161689f, 0.04980328f, 
    -0.01647886f, -0.17111015f, 0.02453355f, -0.01906414f, -0.01238284f, -0.00906719f, 0.06259168f, -0.01065789f, 
    -0.11220498f, 0.04992798f, 0.09135279f, 0.00318446f, -0.15569349f, 0.13220033f, 0.09436876f, 0.07724233f, 
    -0.22516014f, -0.01451266f, -0.03415158f, -0.04750401f, -0.04087939f, 0.04391638f, -0.04601406f, 0.02537539f, 
    0.04389879f, 0.08156177f, 0.00745707f, 0.03415421f, 0.00398224f, -0.05185449f, -0.00395605f, -0.03658054f, 
    -0.31814870f, 0.23357619f, -0.03954053f, 0.22644663f, -0.21851459f, -0.14888385f, -0.07690580f, -0.00777556f, 
    0.10805406f, 0.11229291f, -0.05290803f, -0.00494673f, -0.01994814f, 0.05326814f, 0.08981086f, -0.00621879f, 
    0.02034703f, -0.06994700f, -0.04969408f, -0.03590031f, -0.32520160f, 0.09851289f, 0.01626097f, 0.06948631f, 
    -0.27746272f, -0.03234414f, -0.06262000f, 0.00207860f, -0.00610055f, 0.04237970f, -0.05173108f, -0.06989863f, 
    0.00938132f, 0.04557561f, -0.03041949f, 0.02004844f, -0.04717661f, -0.05809239f, -0.01664531f, -0.01059242f, 
    0.26269925f, -0.28926069f, -0.12301189f, 0.07684740f, -0.08420533f, -0.03543021f, 0.04786577f, 0.00434228f, 
    0.03966813f, 0.07027444f, -0.09488254f, -0.03333649f, -0.00772129f, 0.05541952f, 0.00060493f, -0.02656422f, 
    0.03159068f, 0.02528965f, -0.10822681f, -0.03159312f, 0.01846202f, 0.02253528f, 0.06559701f, -0.02209908f, 
    -0.03787080f, 0.16517580f, 0.02891475f, 0.10813580f, -0.00814190f, 0.04825741f, -0.07266477f, 0.02900790f, 
    -0.01710766f, -0.00655885f, -0.11464542f, 0.04326760f, -0.05517744f, 0.00212754f, 0.00266345f, 0.05408777f, 
    -0.53351533f, 0.08078833f, -0.03507371f, 0.27259025f, 0.02439049f, 0.04321114f, -0.13503191f, 0.06249024f, 
    0.05824400f, -0.06962015f, -0.01390425f, -0.01788682f, 0.01201833f, -0.01338126f, -0.10545854f, 0.08625428f, 
    0.01413802f, -0.15013517f, -0.09433530f, 0.04965545f, 0.35885486f, -0.10281128f, -0.00255580f, 0.12451600f, 
    -0.04462431f, 0.01897649f, 0.07237701f, 0.08941101f, -0.02838037f, -0.01528210f, 0.11936857f, -0.01353122f, 
    0.07012524f, -0.01716833f, 0.08745857f, -0.03252121f, 0.03220139f, -0.04132551f, -0.09612773f, -0.05734301f, 
    -0.01761381f, 0.01822949f, 0.05966982f, -0.01682601f, 0.07827669f, -0.04533318f, 0.00829733f, 0.00138782f, 
    0.05535968f, -0.14193656f, -0.05406943f, 0.00730587f, 0.07587797f, 0.04447568f, 0.00960805f, 0.01978571f, 
    0.03463434f, -0.05132638f, 0.07492179f, -0.07290575f, -0.02637574f, -0.20344950f, -0.01395592f, -0.10461548f, 
    -0.14671585f, 0.07715540f, -0.11181246f, 0.05636413f, -0.08565465f, 0.02550682f, -0.00970689f, -0.00452960f, 
    -0.08655460f, -0.03385286f, 0.08607063f, 0.02086119f, 0.01745181f, -0.06495977f, 0.04771974f, -0.03056158f, 
    0.04718799f, -0.13322693f, -0.10351047f, -0.23798202f, 0.12178809f, -0.03498830f, 0.03436847f, -0.01964164f, 
    -0.07535893f, -0.08537992f, 0.00114583f, -0.01974050f, -0.06377895f, -0.02471054f, -0.01820275f, -0.02873936f, 
    -0.00118899f, 0.13765666f, 0.02282604f, 0.11166719f, -0.03760258f, -0.00214311f, 0.01267988f, -0.22806966f, 
    0.01608098f, -0.05336796f, 0.01152804f, 0.06144959f, -0.07153516f, -0.05358414f, 0.01237332f, 0.00549049f, 
    0.01218677f, 0.03690277f, -0.00721259f, -0.04375479f, -0.04972612f, 0.00832048f, -0.03487333f, 0.09888698f, 
    0.06482007f, -0.05901186f, -0.02175511f, 0.08101412f, 0.02049262f, 0.04212307f, 0.09055427f, -0.08244033f, 
    -0.02797263f, -0.00708605f, -0.10541216f, -0.12353410f, 0.08359258f, -0.02381121f, -0.03874383f, -0.13917975f, 
    -0.00207603f, 0.15021786f, -0.05613280f, -0.20768438f, 0.08760807f, 0.00211534f, -0.09755045f, 0.11630562f, 
    -0.10925067f, 0.07849249f, 0.11952018f, -0.02984661f, -0.08728298f, 0.00587186f, 0.01170162f, -0.01352534f, 
    0.02899993f, -0.01575735f, 0.08699551f, -0.06702259f, -0.03443928f, 0.11434119f, -0.02973179f, -0.01157364f, 
    -0.18177830f, -0.17518845f, 0.01645219f, 0.02046077f, 0.03699012f, 0.09737882f, 0.04213402f, -0.00282546f, 
    0.00275807f, -0.07717435f, 0.04831946f, 0.06296045f, 0.05269093f, 0.11499215f, 0.05956445f, 0.12221578f, 
    -0.06344597f, -0.07615381f, -0.00462342f, -0.03339627f, 0.29383093f, -0.19095924f, 0.09902526f, 0.03719795f, 
    0.21328327f, 0.00552641f, -0.12047213f, -0.00967263f, 0.01867890f, -0.05686411f, -0.04493466f, -0.02229303f, 
    -0.02365653f, 0.00251094f, 0.09562552f, -0.04274359f, -0.02058972f, -0.00556587f, 0.06225929f, -0.01321039f, 
    -0.57734573f, 0.21151654f, -0.00545447f, 0.16030216f, -0.08112417f, 0.00520850f, -0.07636767f, 0.01007907f, 
    0.05471294f, -0.02699089f, -0.03119969f, 0.04952655f, 0.00038373f, 0.03622648f, 0.00522553f, 0.01069332f, 
    0.07308594f, -0.17080988f, -0.10997538f, -0.08889179f, -0.24721295f, 0.02572503f, -0.03875452f, 0.12908977f, 
    -0.16196623f, 0.02410222f, 0.01601302f, 0.09100213f, 0.05751638f, 0.04586450f, -0.07366054f, 0.03533896f, 
    0.00097737f, 0.04319789f, -0.13518694f, 0.00519638f, 0.03354020f, 0.00523508f, 0.04616053f, 0.06196467f, 
    -0.01036376f, -0.10322897f, 0.08773725f, -0.04982583f, 0.30794752f, -0.03159881f, -0.02679897f, 0.06449241f, 
    0.02521454f, -0.10531250f, -0.19346267f, 0.00513537f, -0.08936827f, 0.02798191f, 0.10274965f, -0.05191060f, 
    0.00920956f, 0.11391474f, 0.11047818f, 0.04340553f, 0.07007340f, -0.46298474f, -0.02792751f, -0.23038833f, 
    0.01973429f, -0.09012497f, 0.06729465f, -0.04354645f, 0.00312264f, -0.05422233f, 0.02016542f, 0.05354651f, 
    0.03442987f, 0.08760960f, 0.04965764f, 0.09952597f, 0.03040769f, -0.07684402f, -0.10955620f, 0.04339116f, 
    -0.06200381f, 0.04112412f, 0.03019153f, -0.03610653f, 0.06686848f, 0.14221103f, 0.01172206f, 0.03202376f, 
    -0.15691896f, -0.08600213f, 0.02718025f, -0.12520866f, 0.14770053f, -0.07791354f, -0.00590286f, 0.04072293f, 
    -0.00970714f, 0.07625403f, 0.13154528f, 0.08514009f, 0.02223126f, 0.12869534f, 0.00261571f, -0.04304201f, 
    -0.15260860f, -0.03853285f, 0.07254593f, 0.04825335f, -0.00347448f, 0.03142672f, -0.10327531f, -0.01031754f, 
    0.03248910f, 0.05835958f, 0.01888655f, 0.05289140f, 0.03417746f, 0.05313530f, 0.02110416f, 0.07853819f, 
    0.25980279f, -0.32173929f, 0.01355715f, -0.06830876f, -0.06755122f, 0.03255758f, -0.02651818f, 0.09171113f, 
    -0.10770031f, -0.06365226f, 0.00133439f, -0.06275749f, 0.12835146f, 0.02951416f, 0.03200119f, 0.01402440f, 
    0.03328048f, 0.00632248f, -0.05799301f, -0.00487697f, 0.06086401f, -0.12961152f, 0.00116522f, 0.13709146f, 
    0.22264616f, -0.01686290f, 0.00332607f, 0.06215883f, -0.05771592f, -0.07526344f, -0.04385887f, -0.02349126f, 
    -0.07739051f, -0.03033583f, -0.05415561f, -0.00311609f, 0.07184816f, 0.20508291f, 0.15147275f, 0.06119439f, 
    0.16215816f, -0.10598847f, -0.14686090f, 0.19566011f, 0.02397645f, -0.05828243f, 0.07943013f, 0.01747897f, 
    0.08711061f, -0.08206944f, 0.03313677f, 0.06661110f, 0.05889169f, 0.01360027f, 0.01082605f, 0.03509205f, 
    -0.02489339f, 0.03365590f, -0.09074370f, 0.04162177f, -0.08283217f, -0.14200898f, -0.09881399f, 0.13887525f, 
    0.04288154f, -0.08567468f, -0.04101766f, 0.00886906f, 0.05191195f, 0.05301799f, 0.00904270f, 0.01371007f, 
    -0.01154036f, -0.05015224f, 0.03233400f, -0.05109325f, -0.02873249f, -0.01381933f, -0.05059482f, -0.09357684f, 
    -0.16183133f, -0.38292950f, -0.03812947f, -0.26466864f, 0.05435523f, -0.00169417f, -0.01435000f, 0.02751116f, 
    -0.09308211f, 0.03611634f, -0.03050584f, -0.00423091f, 0.04059872f, 0.11995113f, -0.02902132f, -0.00318006f, 
    0.01096654f, -0.08794792f, -0.01033922f, 0.04205045f, 0.18825243f, -0.08666972f, 0.07540327f, 0.02657680f, 
    -0.00317115f, 0.08135569f, -0.06090806f, 0.05017670f, -0.03382842f, 0.05322478f, 0.00328191f, -0.01774507f, 
    -0.11956003f, -0.11670786f, 0.02201186f, -0.09419449f, 0.07123487f, 0.07163469f, 0.03174939f, -0.01492870f, 
    -0.15876472f, -0.02499774f, -0.10923921f, -0.17935359f, 0.21046039f, 0.01513063f, 0.08057354f, 0.01542325f, 
    -0.09291333f, 0.03896946f, 0.03466443f, -0.03925521f, 0.03939182f, 0.02902661f, -0.09195735f, -0.00779016f, 
    0.06761961f, 0.03009500f, 0.10236846f, 0.04765806f, 0.02248136f, 0.07170532f, 0.16483468f, -0.07138798f, 
    -0.00750663f, 0.12496477f, -0.01167542f, 0.08165149f, 0.06945977f, -0.10744166f, -0.09283778f, -0.04374302f, 
    -0.20005506f, 0.02221341f, -0.01359009f, 0.00493425f, 0.04653551f, 0.06932537f, 0.05599574f, -0.03172342f, 
    0.00985532f, -0.08963115f, -0.21837792f, 0.02912729f, 0.15017873f, -0.09719151f, 0.05109746f, 0.02889691f, 
    -0.01430687f, -0.05378760f, 0.00219894f, -0.04355729f, -0.10419387f, 0.03401647f, -0.01027716f, -0.15941808f, 
    -0.06363034f, 0.21441254f, -0.02526319f, 0.10828231f, -0.24669568f, 0.15871277f, -0.01529877f, 0.13297710f, 
    -0.15263554f, -0.03465481f, -0.04974277f, -0.03328613f, 0.06642663f, 0.00206904f, 0.07051878f, 0.03513099f, 
    -0.00256477f, 0.06404649f, 0.01914952f, 0.01661911f, -0.02863823f, -0.05003136f, -0.04551240f, -0.04487585f, 
    -0.00385713f, -0.35071838f, -0.07251714f, -0.05936185f, 0.23505056f, -0.02538487f, -0.02431626f, -0.02156259f, 
    0.09430709f, 0.06714267f, -0.06557879f, 0.01091451f, 0.02317378f, 0.11490690f, -0.00351781f, 0.01865271f, 
    -0.08111002f, -0.07681695f, -0.14591675f, -0.00915161f, 0.28619975f, 0.04021809f, 0.06252656f, 0.01022558f, 
    0.11576701f, -0.03272456f, -0.06108383f, -0.02181054f, -0.02426478f, -0.07548935f, 0.03874070f, -0.06579326f, 
    0.05647475f, 0.01852601f, -0.10897946f, 0.00586218f, 0.00660961f, 0.11184981f, 0.00308925f, -0.00181429f, 
    0.11012549f, 0.04217492f, 0.02606189f, -0.09314662f, 0.03553367f, -0.04481343f, 0.00114969f, 0.01470231f, 
    -0.08947728f, -0.08034696f, 0.02133603f, -0.06467845f, -0.04025493f, -0.03084793f, 0.00156505f, -0.01389319f, 
    -0.06061096f, 0.09480754f, -0.03386572f, 0.06199101f, -0.04704503f, 0.15287888f, -0.04383030f, -0.09414501f, 
    -0.16214249f, 0.07743996f, 0.02833026f, -0.05773766f, 0.02813536f, -0.00383100f, -0.03471857f, 0.02498513f, 
    -0.04497444f, 0.04955075f, -0.10401915f, 0.09392972f, -0.00444849f, 0.02925061f, 0.11697362f, -0.03456863f, 
    -0.01278964f, 0.03440413f, -0.11916639f, -0.19779046f, -0.01179415f, 0.02303835f, 0.04003601f, 0.05053817f, 
    -0.03259278f, -0.01190953f, -0.04133163f, 0.01987387f, -0.05902282f, -0.07220075f, -0.00629783f, 0.05730891f, 
    -0.01193118f, 0.03380665f, 0.07818538f, 0.02540399f, -0.13170123f, 0.00401943f, -0.06347949f, 0.02707728f, 
    -0.05196575f, -0.07653681f, 0.06952543f, 0.11384451f, 0.05686386f, -0.03198343f, 0.03215906f, -0.05517258f, 
    0.03198944f, -0.03203576f, 0.00668141f, -0.01573082f, 0.00758871f, 0.13227250f, -0.09511257f, 0.17958716f, 
    -0.10411855f, 0.16941375f, -0.02587560f, 0.11633014f, -0.21672714f, -0.10385890f, 0.01284945f, 0.04557826f, 
    0.07549986f, -0.04693110f, 0.09004600f, 0.10743985f, -0.08406138f, -0.05934905f, -0.18061820f, 0.02064358f, 
    -0.08637715f, 0.03565254f, -0.12190117f, 0.08202867f, -0.10647392f, -0.28984594f, 0.12243330f, -0.46352267f, 
    0.20059907f, -0.04593533f, -0.03278945f, -0.04283419f, 0.02716471f, -0.11594968f, -0.03467620f, -0.07084475f, 
    -0.00318052f, 0.10646034f, -0.03826979f, 0.01213927f, 0.00864499f, -0.07808862f, 0.01172994f, 0.05351775f, 
    0.03898780f, 0.07814835f, 0.15096502f, 0.07511724f, -0.05607668f, 0.07287633f, 0.00176616f, 0.00341190f, 
    -0.02303145f, 0.03697339f, -0.00294590f, -0.01983674f, 0.01738707f, 0.04133135f, 0.01866896f, 0.00969758f, 
    -0.00863875f, -0.05590314f, -0.05585806f, -0.17153975f, 0.02353783f, -0.29691043f, -0.15279043f, 0.00399651f, 
    -0.10842761f, -0.02166690f, 0.09027747f, 0.00174886f, -0.02899646f, -0.02425407f, 0.02912893f, 0.03711737f, 
    -0.00446249f, 0.10303736f, 0.06348209f, -0.06789318f, 0.00386340f, 0.08725856f, -0.07760994f, 0.06044038f, 
    -0.26586473f, 0.03372100f, -0.07578407f, -0.08395763f, -0.07085703f, -0.08976412f, 0.05343368f, -0.07545940f, 
    0.00131139f, -0.08187831f, -0.01352895f, -0.06456888f, -0.01865986f, 0.02561241f, -0.09020793f, -0.02873957f, 
    0.01913141f, 0.03322719f, -0.01376867f, -0.02207988f, 0.11874057f, 0.02334335f, 0.15707497f, -0.00821570f, 
    0.15177286f, -0.05465063f, 0.06366551f, 0.02214415f, -0.00046664f, -0.02125766f, 0.05331934f, 0.00075441f, 
    -0.06448932f, -0.06476028f, -0.05778830f, -0.07685993f, -0.03216066f, 0.02437640f, -0.02123084f, -0.04979993f, 
    -0.00364695f, -0.21670617f, 0.03875141f, 0.00176473f, -0.09432174f, 0.00460174f, -0.01398021f, -0.05418250f, 
    0.03209751f, -0.03406222f, -0.05565443f, -0.05683471f, -0.03013808f, -0.05545552f, -0.03994069f, -0.02524894f, 
    0.04326404f, 0.00899537f, -0.03699056f, -0.03331093f, 0.08020962f, -0.18186055f, 0.07736024f, -0.02652384f, 
    -0.03118191f, -0.02029719f, -0.09996881f, -0.02634373f, -0.05261681f, 0.03401765f, -0.04084875f, 0.00047222f, 
    -0.00127101f, -0.03351428f, -0.00529143f, -0.06081105f, 0.07925774f, 0.03937521f, 0.04925739f, 0.00087748f, 
    0.10071044f, -0.30367836f, 0.14565974f, 0.06954970f, -0.08544400f, 0.12812579f, -0.00494916f, -0.02050991f, 
    -0.12055879f, 0.03465313f, -0.04137751f, -0.01956415f, -0.03945572f, -0.01990037f, -0.06972899f, 0.01082202f, 
    0.08091396f, -0.04669511f, -0.06672711f, -0.00708266f, 0.08722813f, -0.05405300f, 0.01535621f, 0.13684265f, 
    0.10237593f, 0.12264390f, -0.04223676f, -0.03569694f, -0.00805003f, 0.03426085f, -0.01698640f, -0.02817986f, 
    0.00101735f, -0.09277894f, -0.01348237f, 0.00662392f, -0.01891696f, 0.01753830f, 0.05811807f, -0.03004997f, 
    0.10319117f, -0.04866449f, -0.05705870f, 0.02751638f, 0.15691820f, -0.03796216f, -0.03677234f, -0.06796452f, 
    -0.05778853f, 0.00384314f, -0.02750600f, 0.03701898f, -0.00789268f, -0.00367963f, -0.05227179f, -0.00346936f, 
    0.02344810f, 0.02631747f, -0.00771106f, -0.01023412f, 0.12229358f, 0.14943284f, 0.04833508f, 0.04651162f, 
    0.10841110f, 0.01518743f, 0.01251614f, -0.03371770f, -0.01220390f, 0.03011592f, -0.01157554f, -0.01672092f, 
    -0.06884479f, 0.04143449f, -0.04976213f, 0.03873299f, -0.03789269f, 0.01314108f, -0.09437597f, -0.02637257f, 
    0.02032885f, 0.11810748f, 0.19105773f, 0.01406393f, 0.09353472f, -0.07239588f, 0.06992675f, -0.06845238f, 
    0.03416910f, 0.03538372f, 0.01892019f, 0.07369667f, -0.03479305f, -0.07949058f, -0.10038216f, 0.01338293f, 
    -0.02571320f, 0.00839292f, 0.06649674f, -0.01860565f, 0.14501975f, 0.03816874f, 0.07289971f, 0.13414834f, 
    0.13229868f, 0.04654394f, 0.05069217f, -0.02047631f, -0.03818123f, 0.08584663f, 0.04945736f, -0.07039503f, 
    0.02004470f, 0.00084075f, 0.04265598f, 0.05131072f, -0.00956851f, 0.02112628f, 0.02408236f, 0.03495912f, 
    0.01006652f, 0.01885482f, 0.08997419f, 0.07872493f, -0.05966353f, 0.14034611f, 0.04391659f, 0.01303181f, 
    -0.07379623f, 0.01358588f, -0.02247896f, -0.00967420f, 0.03587873f, -0.02499039f, 0.00449893f, 0.03841110f, 
    0.01897241f, -0.06726802f, -0.02854967f, -0.04378686f, -0.00817385f, -0.04885718f, -0.03131257f, -0.08461355f, 
    -0.12353816f, -0.05160409f, -0.03701483f, -0.11112132f, 0.01996537f, -0.00992971f, 0.04830999f, 0.01646134f, 
    -0.03384722f, -0.00863126f, -0.02673725f, -0.02392522f, -0.04872594f, -0.02470976f, 0.03907723f, -0.05414803f, 
    -0.02769980f, 0.01898251f, 0.12321057f, -0.02834990f, -0.00306080f, 0.06647160f, -0.02070374f, 0.00013167f, 
    0.01260599f, 0.08460725f, 0.00183775f, 0.04858208f, -0.02659305f, 0.05915872f, -0.04310986f, -0.00847631f, 
    -0.10723429f, -0.00529398f, -0.00076599f, -0.02646927f, 0.08179779f, 0.13613483f, 0.21224245f, 0.01908855f, 
    0.14383565f, 0.02346027f, 0.07378902f, -0.05446311f, -0.05257344f, 0.03764896f, 0.00242872f, 0.03365705f, 
    0.00589615f, -0.12472510f, -0.03615863f, 0.01243925f, 0.02480388f, -0.01288190f, 0.14816573f, -0.02836120f, 
    -0.19949339f, -0.23701145f, -0.24447574f, -0.07633524f, -0.09721067f, -0.07459657f, -0.07801276f, 0.00651178f, 
    0.00336443f, -0.03094825f, -0.08693808f, -0.04301230f, 0.00511169f, -0.00598413f, -0.01867009f, -0.04527774f, 
    0.09093911f, 0.01198717f, 0.04180245f, 0.02959901f, 0.11446492f, 0.10756005f, -0.07534658f, 0.08054335f, 
    0.14037299f, 0.08734035f, -0.03328451f, -0.05674645f, -0.05470800f, -0.05835079f, -0.05421092f, 0.08423220f, 
    0.00151206f, -0.02179684f, -0.03401043f, 0.13179785f, 0.03190937f, -0.04340110f, 0.00835979f, -0.05342667f, 
    -0.23893477f, 0.22368386f, 0.12383295f, -0.07055815f, -0.05586882f, -0.03715032f, 0.03175639f, -0.09090144f, 
    -0.00354141f, -0.05338499f, -0.05849868f, 0.00164386f, -0.02435572f, 0.01133085f, -0.09504875f, 0.02764586f, 
    0.03454506f, 0.02844288f, -0.01830527f, -0.05308841f, -0.08522227f, -0.03142744f, -0.09759212f, -0.14977671f, 
    -0.07691213f, 0.05894581f, -0.00206745f, 0.01591674f, -0.03313018f, -0.09051026f, -0.12107206f, -0.02069264f, 
    -0.05419714f, -0.00563811f, 0.01292895f, 0.00982372f, -0.07117666f, -0.02101795f, 0.00387500f, -0.00678995f, 
    0.05338310f, 0.05312248f, -0.08880863f, 0.11587961f, 0.08915872f, -0.05249000f, -0.02352285f, -0.02201186f, 
    0.01289314f, -0.10829966f, 0.00042780f, 0.01963951f, -0.08180200f, -0.00474967f, -0.15469980f, -0.03854565f, 
    -0.03326102f, -0.12433777f, -0.00903491f, -0.07945552f, 0.16113456f, -0.17664760f, -0.04354857f, 0.01363356f, 
    0.13474004f, -0.07105472f, -0.11053906f, 0.02725684f, 0.03241325f, -0.02680448f, 0.01378045f, 0.07744751f, 
    -0.07906044f, 0.04820070f, 0.06425139f, 0.03817501f, -0.03119349f, 0.00105548f, -0.03436494f, -0.02241439f, 
    -0.01001096f, 0.00798294f, -0.10059968f, -0.01875892f, 0.19392051f, 0.04247538f, 0.00533901f, -0.00914241f, 
    0.05310581f, -0.05523815f, -0.03843686f, -0.00051590f, -0.05200409f, -0.09155887f, -0.04340585f, 0.01212495f, 
    -0.04045176f, -0.01796268f, -0.06370354f, -0.05686906f, -0.16241178f, -0.01840064f, -0.11889821f, -0.12494019f, 
    -0.22677639f, -0.06140445f, -0.11675683f, -0.07738987f, 0.02729759f, -0.03802412f, -0.11224152f, 0.02247810f, 
    0.04921982f, -0.02230795f, -0.08792331f, 0.01169797f, 0.08778136f, 0.00246698f, 0.01607234f, 0.03128124f, 
    0.09930909f, -0.06918754f, 0.08715372f, 0.15087624f, 0.17979506f, 0.02094802f, 0.12762444f, -0.00321351f, 
    0.08766678f, -0.05105987f, 0.02099010f, -0.01292414f, -0.11067698f, -0.03083516f, 0.01947489f, -0.07780758f, 
    -0.03546868f, 0.07274605f, -0.06945648f, -0.00498827f, -0.12691295f, -0.27974486f, -0.24350122f, 0.04148574f, 
    -0.16726103f, -0.01629881f, -0.06350335f, 0.07073849f, -0.03475829f, -0.10838754f, 0.01390758f, -0.02848327f, 
    -0.12216197f, 0.06736846f, 0.01547352f, 0.00954925f, -0.03940182f, -0.01924491f, 0.00811011f, -0.03618056f, 
    0.07281663f, -0.14718813f, -0.15896012f, -0.17404073f, -0.22101384f, -0.06376056f, -0.07502465f, -0.00569025f, 
    -0.05984206f, -0.11134005f, 0.04102184f, -0.03240882f, -0.04727007f, 0.01956088f, -0.07949546f, 0.02254948f, 
    -0.04219355f, -0.03858818f, -0.03399695f, 0.03504168f, -0.15078531f, -0.04227804f, -0.12712121f, -0.12365844f, 
    -0.21251681f, -0.11538389f, -0.06078555f, -0.00790638f, -0.01581517f, -0.03625626f, 0.01126024f, 0.02442276f, 
    -0.00438209f, 0.03844138f, 0.00418250f, 0.06148854f, -0.03853616f, -0.05888113f, -0.03783845f, -0.05438919f, 
    -0.00475998f, 0.06664278f, -0.04565170f, -0.00461102f, -0.09264582f, 0.01765355f, 0.00049183f, -0.03059176f, 
    -0.01856349f, -0.00026412f, 0.01622451f, 0.08213041f, 0.05005272f, 0.00912729f, -0.01433060f, -0.01481653f, 
    0.02485804f, -0.05995027f, 0.01377173f, -0.02067392f, 0.06742963f, -0.47615850f, 0.08940735f, 0.00766277f, 
    -0.15867163f, 0.09593014f, -0.04746483f, 0.01249313f, 0.04838285f, -0.01318952f, -0.03089073f, -0.06125358f, 
    -0.00049550f, 0.01274941f, -0.06722362f, 0.03027934f, 0.05881490f, 0.00690738f, -0.00934163f, -0.07671866f, 
    -0.02544847f, -0.07672126f, 0.00303680f, -0.15083782f, -0.07740165f, 0.06307739f, 0.04710675f, -0.00586312f, 
    0.01303705f, 0.03867006f, -0.00834080f, 0.03329446f, 0.01409429f, -0.03264073f, 0.06673083f, 0.02686338f, 
    0.00797282f, -0.05581582f, -0.03946730f, 0.03461293f, 0.25048566f, -0.25832075f, 0.10923142f, -0.08158313f, 
    0.15102845f, -0.01914739f, 0.08398245f, 0.00670263f, -0.03172740f, 0.04789240f, -0.01544101f, -0.02237240f, 
    -0.08209131f, 0.04873812f, 0.00617649f, -0.04595018f, 0.04379090f, -0.00209520f, -0.00296609f, -0.04712753f, 
    -0.04132076f, 0.11639529f, -0.28846738f, -0.08348066f, 0.08361001f, -0.14963907f, -0.05365753f, -0.03801307f, 
    -0.04023635f, -0.00135839f, -0.09411285f, -0.06769399f, -0.02146646f, -0.02846854f, -0.02625056f, 0.00607582f, 
    -0.08191102f, 0.03052584f, -0.00546657f, 0.02772292f, 0.12000526f, -0.25713554f, 0.05064359f, 0.06236049f, 
    -0.09281826f, 0.00961096f, -0.01161452f, -0.02166255f, -0.05730311f, 0.03162373f, 0.03126664f, 0.03321905f, 
    -0.05412313f, 0.00878458f, -0.05268171f, -0.04891859f, 0.03881340f, -0.02921614f, -0.00770572f, -0.00320669f, 
    0.03898100f, 0.08636950f, 0.19997446f, 0.02172796f, 0.16895361f, -0.07415973f, 0.07439213f, -0.01150859f, 
    0.03864389f, 0.04304503f, -0.00160306f, 0.02605147f, -0.15268147f, -0.04163106f, -0.06594041f, -0.05442316f, 
    0.00414855f, 0.00160037f, -0.03660206f, -0.05257673f, 0.00553686f, 0.10506681f, 0.23224849f, 0.07806829f, 
    0.12888137f, 0.01353489f, 0.05284491f, -0.05797775f, 0.01486094f, -0.02702976f, -0.02800599f, 0.06409283f, 
    -0.01333613f, -0.11769757f, -0.02703019f, 0.01323490f, -0.00211755f, -0.02094686f, 0.06344839f, -0.09555890f, 
    0.08775894f, -0.03917961f, 0.02766557f, -0.02088026f, -0.05612702f, -0.08156361f, -0.03266223f, -0.04773790f, 
    -0.05163438f, -0.08013633f, 0.00196078f, 0.07505929f, 0.02992324f, 0.08008603f, -0.04513287f, -0.09061926f, 
    -0.08374650f, 0.04556619f, -0.05543122f, -0.05969946f, 0.03123921f, 0.18332562f, 0.16313548f, 0.05491705f, 
    -0.01624776f, -0.01694390f, 0.04760682f, 0.03228241f, 0.00974984f, -0.01776427f, -0.01896159f, -0.00539586f, 
    0.02598015f, 0.03897095f, -0.02087584f, 0.02492975f, -0.04416514f, -0.01068833f, 0.09800451f, -0.03255575f, 
    -0.04094518f, 0.05435902f, -0.21277127f, -0.11620354f, -0.17946166f, -0.04248103f, 0.01113323f, -0.06003294f, 
    0.03768742f, -0.02338392f, 0.05564962f, -0.00670128f, 0.08897075f, -0.03075500f, -0.00276848f, 0.04204715f, 
    -0.12469586f, -0.02920764f, -0.00503848f, 0.00638524f, 0.09965588f, -0.04263886f, -0.02851781f, 0.01934602f, 
    0.20512426f, -0.13269609f, -0.04408308f, -0.04668640f, 0.03586351f, 0.00867347f, 0.00338248f, 0.04198135f, 
    0.01541569f, 0.02076763f, -0.00854300f, 0.05632733f, -0.07190765f, -0.06425253f, -0.03507723f, -0.01972943f, 
    -0.15401141f, -0.19159336f, -0.12374343f, -0.16233854f, -0.20513126f, -0.05050144f, -0.02401702f, 0.01656078f, 
    -0.05112619f, 0.05229844f, 0.01327872f, 0.04968125f, 0.01618459f, -0.05304020f, 0.00582350f, 0.03023918f, 
    0.07941042f, -0.05567383f, -0.04152783f, 0.01350819f, 0.03696363f, -0.07913519f, 0.03595409f, 0.00298056f, 
    0.10013454f, 0.07748669f, -0.05616820f, -0.09105696f, 0.00438030f, -0.03380239f, -0.01070673f, -0.07853825f, 
    -0.06648308f, 0.00199880f, -0.07423081f, 0.00438496f, -0.00965185f, -0.03873425f, -0.04242739f, -0.01525952f, 
    -0.03357667f, 0.15391964f, -0.14235002f, 0.06939303f, 0.13914928f, 0.01121001f, -0.01981588f, -0.09638928f, 
    0.04310716f, -0.00805425f, -0.13497169f, -0.00312538f, -0.09266338f, -0.03893727f, -0.04150862f, -0.00932678f, 
    -0.07184335f, -0.02315395f, -0.08051728f, 0.00092766f, 0.02523907f, 0.05387957f, 0.25854364f, 0.15395433f, 
    0.14422889f, 0.08480318f, 0.15531345f, 0.08512212f, -0.01225233f, -0.06242882f, 0.02796438f, 0.00406655f, 
    -0.02052977f, -0.01802553f, -0.03782973f, -0.06422687f, 0.05501903f, 0.02836347f, -0.00173312f, -0.00737633f, 
    0.09338537f, -0.07504721f, 0.06655339f, 0.02800659f, 0.00830113f, 0.03163350f, -0.02277077f, -0.01621684f, 
    0.00936479f, -0.01322783f, -0.00628738f, 0.02685341f, 0.01199015f, -0.04346141f, -0.07520632f, -0.00476702f, 
    0.11826238f, -0.02305699f, 0.05865099f, 0.00130148f, -0.01549093f, 0.04927583f, -0.25829262f, 0.07275403f, 
    0.06730901f, -0.08512049f, -0.05383894f, -0.02471234f, -0.02522504f, -0.02558984f, -0.11571640f, -0.03368518f, 
    -0.02423971f, -0.04234201f, -0.01586668f, 0.01678579f, 0.03376738f, -0.01881796f, -0.04289515f, 0.00120957f, 
    0.13668345f, -0.15828897f, 0.10908161f, -0.01574834f, 0.20048295f, 0.02288136f, 0.05446377f, -0.01595844f, 
    -0.00195054f, 0.03074787f, -0.01722862f, 0.04785656f, -0.02564490f, 0.03034508f, -0.00465075f, -0.02654695f, 
    0.05230081f, -0.04981893f, -0.00539701f, -0.07458784f, 0.05600189f, -0.16975923f, 0.10170501f, 0.15508406f, 
    -0.06862432f, 0.17048296f, -0.11164781f, 0.01372584f, 0.04908046f, 0.04042320f, -0.06826613f, 0.11684067f, 
    0.00587568f, -0.04142420f, -0.02777172f, 0.02384779f, 0.04355576f, -0.00058529f, -0.01024889f, -0.01261619f, 
    -0.23434168f, 0.11756300f, -0.00564182f, 0.07048829f, -0.14576843f, 0.05204272f, -0.02597134f, 0.02083243f, 
    0.01298259f, -0.04836451f, 0.00418143f, 0.01591040f, 0.06226692f, -0.01452826f, -0.01381963f, 0.05657630f, 
    0.02754234f, 0.02860252f, 0.07196368f, -0.02063039f, -0.10076006f, -0.12404292f, 0.02397319f, 0.02096153f, 
    -0.07527095f, -0.04537326f, -0.14116749f, 0.00731493f, 0.00463498f, -0.02987411f, 0.03522237f, 0.03018792f, 
    -0.02463123f, 0.04827328f, -0.01250237f, -0.06142050f, -0.08251786f, 0.01599127f, 0.00693791f, -0.03895044f, 
    0.07818595f, 0.07471460f, 0.26675230f, 0.09230466f, 0.06941868f, 0.02394744f, 0.07348779f, 0.06022814f, 
    -0.00339709f, -0.03783428f, -0.03410202f, 0.07788806f, -0.04019134f, 0.01125086f, -0.06485562f, -0.05416846f, 
    -0.00677804f, 0.00152288f, 0.03893115f, -0.02037486f, 0.21749082f, -0.32950550f, 0.17434150f, 0.09939049f, 
    -0.10781934f, 0.07284193f, 0.00050831f, -0.05468871f, -0.02060876f, 0.05323370f, -0.01326165f, -0.01435539f, 
    -0.01925056f, 0.04218427f, -0.03554443f, -0.03390892f, 0.07385020f, -0.04361206f, -0.01621876f, -0.02866301f, 
    0.14553528f, 0.20974281f, 0.13250037f, -0.07462424f, 0.17814773f, -0.04587297f, 0.11660733f, -0.04975995f, 
    0.00373643f, -0.04510048f, 0.01192234f, -0.01379680f, -0.05372391f, -0.08696283f, -0.07852671f, 0.02200670f, 
    0.01457298f, 0.07946146f, -0.00740996f, -0.03086885f, 0.11138461f, -0.27973396f, 0.12734881f, 0.04712828f, 
    -0.11794174f, 0.00823127f, 0.04229098f, -0.07859965f, 0.04895568f, 0.08139106f, -0.02964505f, 0.03354745f, 
    -0.10497116f, -0.00363730f, -0.06374772f, 0.00213432f, 0.01859163f, 0.03058643f, -0.06014059f, 0.01276081f, 
    -0.27185723f, 0.20857860f, -0.22115007f, -0.01044673f, 0.03574105f, -0.01676165f, -0.02531748f, -0.14053506f, 
    0.06011305f, -0.00576261f, -0.13807045f, 0.12855586f, -0.06194798f, -0.04865763f, 0.02220109f, -0.03415221f, 
    -0.08131699f, -0.01572786f, 0.01954940f, 0.02173411f, -0.04260248f, -0.12306433f, -0.13975410f, -0.20293763f, 
    -0.23204497f, 0.01703455f, -0.02627892f, -0.00888108f, -0.02440215f, -0.07633289f, -0.06737839f, -0.01602266f, 
    -0.08246341f, -0.00612460f, 0.02724749f, -0.01784721f, -0.06210137f, -0.01729542f, -0.00408160f, 0.04036217f, 
    -0.21684830f, -0.11055626f, 0.01178422f, -0.08622384f, -0.11292611f, -0.14835058f, 0.03862764f, -0.03964951f, 
    -0.05407622f, -0.02962002f, 0.01131875f, 0.02794833f, 0.03946933f, -0.02926085f, -0.02199204f, -0.01980083f, 
    -0.01102480f, 0.00095935f, -0.02597364f, -0.01831499f, 0.11517292f, -0.02788626f, 0.00211027f, -0.01808739f, 
    0.13526836f, -0.11560805f, 0.03183880f, -0.04184063f, -0.02100397f, 0.02403974f, -0.00658729f, 0.04616804f, 
    -0.11948830f, 0.09400271f, -0.03070310f, -0.02587095f, -0.02950828f, 0.02529294f, -0.03938784f, -0.00710494f, 
    0.04872778f, 0.06877071f, 0.17905587f, 0.00435064f, 0.12288260f, -0.09666591f, 0.05346415f, 0.02194715f, 
    -0.00108935f, 0.01380985f, 0.03357147f, 0.06397218f, -0.11497632f, -0.03041471f, 0.00086879f, -0.03807551f, 
    -0.06438578f, -0.01819920f, -0.03233809f, -0.08836291f, -0.19286418f, -0.01000680f, -0.03479638f, -0.04355898f, 
    0.04920676f, -0.06619593f, -0.02686373f, -0.15543564f, 0.00642313f, 0.00203086f, 0.00432370f, 0.00547730f, 
    0.02505651f, -0.03404193f, -0.07358570f, 0.00945416f, -0.04121173f, 0.01604590f, 0.00698961f, 0.02910138f, 
    0.01957032f, -0.11041146f, -0.01789523f, -0.02168844f, 0.10220294f, 0.03283338f, -0.09432816f, -0.04531429f, 
    -0.03761029f, -0.02641515f, -0.04073922f, -0.00779191f, -0.04156059f, -0.00491587f, -0.03106130f, -0.05065439f, 
    0.00754025f, -0.01691672f, 0.01881958f, -0.03350504f, 0.01763953f, 0.16480649f, -0.13555112f, -0.02079744f, 
    -0.04746284f, -0.04585452f, -0.04586845f, 0.03895094f, -0.04870741f, -0.03835372f, -0.04758313f, 0.06464381f, 
    -0.00330451f, 0.00928197f, -0.14016436f, 0.04595000f, -0.01555664f, -0.02062560f, 0.00164882f, -0.10265135f, 
    -0.36134586f, 0.06829037f, -0.23216806f, -0.06243396f, -0.00022938f, 0.00669092f, -0.11105537f, 0.01543633f, 
    0.01564238f, -0.04224392f, -0.09996998f, -0.00247960f, 0.02673424f, 0.04495038f, -0.07842246f, -0.03846511f, 
    -0.04778481f, 0.01898739f, 0.03678246f, 0.05598177f, 0.14894685f, 0.06062420f, 0.28340816f, 0.10492132f, 
    0.16419218f, -0.04111943f, 0.11111917f, 0.01493960f, 0.00258120f, -0.00489875f, -0.01862295f, 0.04198796f, 
    -0.13493620f, 0.07084546f, -0.02814163f, -0.09994622f, 0.03131243f, 0.07305960f, -0.00842393f, -0.02246599f, 
    0.16389267f, -0.27733743f, 0.06799545f, -0.05670455f, -0.07623842f, -0.00627974f, 0.04899472f, -0.02260006f, 
    -0.01435554f, 0.02803539f, -0.02057366f, -0.09988199f, -0.04094107f, 0.02887031f, -0.04830503f, -0.09358337f, 
    0.10659124f, 0.02098220f, 0.02511312f, 0.06877907f, -0.04760832f, 0.17561732f, 0.24895161f, 0.10400696f, 
    0.01566749f, 0.10718568f, 0.06148749f, 0.06174780f, 0.06225767f, -0.07736831f, -0.06015613f, 0.05402154f, 
    0.07147708f, 0.03036091f, -0.10097811f, 0.01147317f, 0.02429083f, 0.04857435f, 0.04555675f, -0.03888959f, 
    -0.01004247f, 0.02962606f, -0.23916821f, 0.08362232f, -0.07792647f, 0.07700612f, 0.06699187f, -0.00947048f, 
    -0.06710950f, -0.03631227f, 0.04728641f, 0.01781134f, 0.01039965f, -0.03446569f, 0.01137071f, -0.01554352f, 
    -0.03383308f, -0.02631063f, 0.07101506f, 0.01571883f, 0.00975517f, 0.17947431f, -0.02497497f, -0.12573990f, 
    -0.20844291f, -0.09486139f, 0.00755670f, -0.05196360f, -0.07873016f, -0.03346022f, -0.03632043f, -0.00298820f, 
    0.11189697f, -0.00952608f, 0.04468575f, 0.02523712f, -0.01924406f, -0.15423128f, -0.12260388f, 0.07807067f, 
    -0.03439058f, 0.04705327f, -0.26970148f, 0.05236572f, 0.10368553f, -0.04399128f, -0.01511306f, -0.09712764f, 
    -0.06572005f, 0.01054198f, 0.00633142f, 0.00110751f, -0.01925735f, -0.00626947f, 0.01975617f, -0.02894869f, 
    -0.06237879f, -0.00568961f, 0.06590251f, 0.00269969f, 0.04753045f, 0.02110908f, 0.06760146f, -0.12736726f, 
    -0.03809081f, -0.09095100f, -0.02335099f, 0.02589941f, 0.00339508f, -0.12145623f, 0.04489132f, 0.06491766f, 
    0.01166666f, 0.04790856f, 0.01363698f, 0.07461882f, -0.04286325f, 0.04489134f, -0.15952754f, 0.04942207f, 
    -0.09866918f, 0.05817226f, 0.04621321f, 0.02555266f, 0.05074329f, 0.01387756f, -0.00238461f, -0.07651713f, 
    -0.14844081f, 0.03393243f, -0.01857450f, -0.00405349f, -0.04192476f, -0.08011463f, 0.03435291f, -0.09174904f, 
    0.00456270f, -0.01832056f, 0.02217499f, -0.08103742f, -0.07676575f, -0.20188351f, 0.10608212f, -0.23637442f, 
    -0.11328596f, -0.08694527f, -0.06158294f, 0.05938266f, -0.05671560f, -0.00918317f, 0.00120612f, 0.04497760f, 
    0.03485288f, 0.03300526f, 0.00568708f, 0.03775935f, -0.05968878f, 0.04507124f, -0.19828971f, 0.00123915f, 
    -0.10897046f, -0.16170040f, -0.09501587f, -0.27464354f, -0.10141537f, -0.01591845f, -0.00791280f, -0.01623574f, 
    0.01276803f, -0.01754398f, 0.08580712f, 0.06010854f, -0.04921002f, 0.06072629f, -0.04740010f, 0.04608831f, 
    0.05241721f, -0.00641661f, -0.25731120f, -0.02798693f, -0.26670948f, -0.01219282f, -0.12994666f, -0.09231157f, 
    -0.25280538f, 0.06010499f, -0.00488597f, -0.04991312f, 0.06048399f, -0.07439180f, 0.03003872f, 0.00915320f, 
    0.01760903f, -0.02334237f, 0.05817961f, -0.06637004f, 0.03491273f, -0.11136293f, 0.02373415f, -0.03413005f, 
    -0.03509991f, 0.16051221f, -0.02325166f, 0.01467369f, -0.06353900f, 0.03391394f, -0.06621481f, 0.02372485f, 
    -0.08122762f, 0.02538696f, 0.07205617f, -0.00534163f, -0.02989646f, 0.01141933f, 0.09747769f, -0.03693661f, 
    0.05875513f, -0.05027439f, 0.03956301f, 0.03223369f, -0.11783534f, -0.22249343f, -0.06399874f, -0.20934780f, 
    -0.07640292f, 0.11020561f, -0.06316397f, 0.00898565f, -0.00405268f, -0.02507978f, 0.01782088f, 0.07226414f, 
    -0.00764581f, 0.05819873f, 0.00261175f, 0.04604150f, -0.01492373f, -0.00337495f, -0.10674681f, -0.11718164f, 
    -0.03559275f, 0.05224425f, 0.02009330f, 0.00638746f, 0.06076249f, 0.00448804f, -0.01294648f, -0.04212849f, 
    -0.04447197f, 0.02479034f, -0.01084160f, 0.03229986f, -0.04859251f, -0.06874549f, 0.05705537f, -0.06503705f, 
    0.01541053f, 0.01570677f, 0.02918909f, -0.01180755f, 0.08370381f, 0.14548096f, -0.05937207f, 0.07608245f, 
    0.09888943f, 0.01782807f, -0.08017547f, 0.02747497f, -0.04822198f, 0.00751315f, 0.02995162f, -0.02442545f, 
    -0.03074977f, 0.05381598f, 0.03546338f, 0.05621176f, -0.01242454f, 0.02707878f, 0.03130367f, -0.00947760f, 
    -0.06116611f, 0.08562639f, 0.03791252f, -0.05550322f, 0.02248717f, -0.01911778f, -0.01132661f, -0.06630004f, 
    -0.00719450f, -0.00299409f, 0.01316083f, 0.02752068f, 0.09104937f, 0.00990073f, -0.02299769f, -0.00833368f, 
    -0.05399425f, 0.00389297f, -0.01167818f, -0.00123835f, -0.17901394f, -0.09717191f, 0.16813770f, -0.16039141f, 
    -0.12087440f, 0.04895066f, -0.02967816f, -0.00399229f, -0.14172667f, -0.06652150f, 0.04208507f, 0.05374640f, 
    0.07964990f, 0.08341420f, 0.03211049f, -0.06950240f, 0.07293674f, -0.04611182f, -0.36912921f, -0.00050732f, 
    0.02118735f, -0.18726313f, -0.20408459f, -0.00281605f, 0.13839377f, 0.08749289f, 0.04436228f, -0.00827309f, 
    -0.02955725f, -0.00520196f, -0.01504141f, -0.00641444f, 0.03056544f, 0.00922208f, -0.01287753f, 0.01228344f, 
    0.04905669f, 0.05210219f, 0.05505035f, -0.01950101f, -0.00569028f, -0.00500728f, 0.15066667f, -0.18102051f, 
    0.03350001f, 0.02574122f, 0.01789117f, -0.07771359f, -0.04324433f, -0.10153499f, 0.09311745f, 0.06716958f, 
    0.08881097f, -0.01644642f, 0.09843352f, -0.00585416f, -0.02188616f, 0.05242312f, -0.02365311f, -0.01794063f, 
    0.06251457f, 0.10560576f, -0.10308617f, 0.06694373f, -0.02626429f, -0.05469768f, 0.04411542f, -0.12390791f, 
    -0.02340864f, -0.06177406f, 0.04610979f, 0.03051487f, -0.02624904f, -0.06195809f, 0.03103852f, -0.03555064f, 
    -0.00878373f, 0.02982906f, 0.14455931f, -0.01110712f, 0.10501786f, 0.11586646f, -0.03240137f, 0.01363505f, 
    0.08121081f, 0.02282759f, -0.08503631f, 0.02772379f, -0.00387007f, 0.01730445f, 0.02789336f, 0.01948155f, 
    -0.04943218f, 0.00476826f, -0.04844276f, 0.02848093f, -0.06276000f, 0.05644489f, 0.01114635f, -0.04632375f, 
    -0.00114371f, -0.01608535f, 0.11638709f, -0.06065483f, -0.04098500f, 0.00707294f, 0.00482986f, -0.04960800f, 
    -0.10944723f, 0.00827005f, 0.03231533f, 0.06988102f, 0.10633606f, -0.03566840f, -0.01171990f, -0.16454346f, 
    0.00915917f, -0.00205748f, -0.06918043f, -0.18377523f, -0.04750044f, -0.13642521f, -0.13893539f, -0.05125864f, 
    -0.00980526f, 0.06941549f, 0.09510732f, -0.09155183f, -0.08946134f, -0.00773730f, 0.00827526f, -0.00929614f, 
    0.16575639f, 0.01216990f, 0.03556564f, -0.02746913f, 0.03551997f, 0.04754659f, -0.08307423f, -0.12199556f, 
    -0.04885248f, 0.10114464f, 0.10930707f, -0.16387226f, 0.00393406f, -0.00783691f, -0.07223720f, -0.03625342f, 
    -0.05886773f, -0.10534625f, 0.04601472f, 0.04391979f, 0.00847652f, 0.06800848f, -0.00635200f, -0.00573652f, 
    0.00450663f, -0.02104646f, -0.03865045f, 0.02359498f, 0.00330207f, -0.07007867f, -0.09480969f, 0.02720594f, 
    0.17582755f, 0.05710827f, 0.03015925f, -0.09774744f, -0.01983926f, 0.04874559f, -0.00488746f, 0.01086044f, 
    -0.00235924f, -0.03280325f, 0.07359064f, -0.05730453f, 0.03900891f, 0.05324845f, 0.05403949f, 0.04584415f, 
    -0.12973958f, -0.08908351f, -0.00869697f, -0.18214694f, -0.03338031f, -0.08720198f, 0.00541563f, 0.05909117f, 
    -0.08047575f, -0.01115670f, -0.03600259f, 0.05714092f, 0.05141373f, 0.08160599f, -0.02955237f, 0.00382465f, 
    0.02071928f, -0.11273233f, -0.08683635f, -0.05445832f, 0.13329758f, -0.00128251f, -0.18501920f, 0.09039904f, 
    0.13061932f, 0.12688157f, 0.06483316f, -0.00680112f, -0.05244987f, -0.01506076f, -0.10807724f, -0.04957763f, 
    -0.00565420f, 0.05543497f, -0.04868142f, -0.02356363f, -0.02625832f, 0.00830539f, 0.06064105f, -0.09105517f, 
    0.17554970f, 0.10407470f, -0.06832090f, 0.07236340f, 0.19055486f, 0.05895828f, 0.07963563f, -0.11099884f, 
    -0.00188541f, -0.03839578f, -0.05056065f, 0.03250707f, -0.11507077f, -0.08658894f, -0.02564039f, -0.16659023f, 
    0.02401269f, 0.02920544f, 0.04159492f, -0.00651844f, 0.14989111f, 0.01285743f, -0.11215471f, 0.14864451f, 
    0.14510642f, 0.07004055f, 0.05890070f, -0.06612838f, -0.03116028f, -0.06450517f, 0.02549403f, 0.02235711f, 
    -0.05794182f, -0.06082763f, 0.00345285f, -0.13273013f, -0.07715741f, 0.03139014f, 0.09977038f, -0.06032121f, 
    0.13236836f, 0.04409120f, -0.02830626f, -0.01891182f, 0.08805929f, -0.03539903f, -0.00749037f, -0.09186785f, 
    0.02690566f, 0.08091811f, 0.00795059f, -0.05409614f, 0.00451210f, -0.17808014f, 0.02771161f, 0.02159639f, 
    -0.05067641f, -0.01879263f, 0.07266123f, 0.00591476f, -0.00066419f, -0.09170624f, -0.25229457f, 0.04110625f, 
    0.12339184f, 0.02923542f, 0.01467143f, -0.04112991f, 0.03155969f, -0.01045757f, 0.04888358f, -0.05314954f, 
    0.00211911f, -0.01126838f, 0.06311271f, 0.03102067f, -0.06172084f, 0.03953822f, 0.04623021f, -0.02114354f, 
    0.00534434f, 0.12090717f, -0.19692557f, 0.00578108f, -0.06434565f, 0.02703944f, 0.01532097f, -0.00730305f, 
    -0.10408923f, -0.02721987f, 0.01414835f, 0.04233355f, -0.02089384f, 0.01806684f, 0.00670033f, -0.07082399f, 
    -0.14068848f, -0.01539487f, 0.07821774f, -0.05785531f, -0.00220256f, -0.06976317f, 0.12016660f, -0.08891141f, 
    0.01034598f, -0.01517004f, 0.02969819f, -0.04330479f, -0.07924403f, -0.03498897f, -0.03843303f, -0.00423613f, 
    0.02563968f, -0.06793594f, 0.05398138f, 0.05565516f, 0.02220667f, 0.01200409f, -0.06179421f, 0.08840020f, 
    -0.05462195f, -0.01049748f, -0.08926380f, -0.06361496f, 0.02911250f, 0.12359426f, 0.05635704f, -0.03494030f, 
    -0.06579388f, -0.06405918f, 0.05115998f, -0.01137912f, -0.00121334f, -0.06344402f, -0.11496453f, -0.07050899f, 
    0.06719363f, 0.09080217f, -0.01189435f, -0.01503412f, 0.04189225f, 0.01284097f, 0.10437489f, -0.01071294f, 
    0.14870903f, 0.00542453f, 0.02983862f, -0.03388487f, -0.11011939f, 0.05934192f, -0.05460118f, 0.04707710f, 
    0.01574008f, -0.01506341f, 0.00894954f, -0.03977230f, -0.06628265f, 0.08078775f, -0.06369315f, -0.07977448f, 
    0.00895787f, 0.14395702f, 0.09703124f, -0.03316526f, -0.15786439f, -0.13265765f, 0.01830775f, -0.01721862f, 
    -0.02235139f, 0.01059547f, -0.00673155f, -0.03870819f, 0.07068498f, 0.03586496f, 0.04336292f, -0.06124508f, 
    -0.04144416f, -0.12153239f, -0.01984708f, -0.01371611f, -0.18171564f, -0.09618846f, 0.26401949f, 0.00425911f, 
    0.04127717f, 0.03711535f, -0.04465635f, 0.02115440f, -0.05439502f, -0.04025525f, 0.02202979f, 0.03789754f, 
    -0.01258816f, 0.09060131f, 0.00877146f, -0.05697354f, 0.06532020f, 0.02729593f, -0.03630387f, 0.06356327f, 
    0.12481809f, 0.09527812f, -0.19473960f, 0.01424133f, 0.05898517f, -0.11586600f, -0.03174656f, 0.02870799f, 
    -0.00700238f, 0.04102297f, -0.03235026f, 0.06652442f, 0.02561609f, 0.07145670f, -0.03192858f, 0.05500040f, 
    -0.03760684f, -0.00950056f, 0.01200161f, 0.03397312f, 0.07349492f, -0.12220372f, -0.15957943f, 0.06559904f, 
    -0.06401081f, -0.00859882f, 0.01052469f, -0.10327665f, -0.05269798f, -0.04264901f, 0.05269603f, 0.05107284f, 
    -0.00546967f, 0.09608011f, 0.06682882f, 0.08054028f, 0.00641538f, -0.04177075f, 0.07308204f, 0.00565991f, 
    0.01692796f, 0.20073274f, -0.06074194f, 0.00272732f, 0.04570464f, 0.03316085f, 0.02376626f, -0.02995471f, 
    0.01104894f, -0.01291690f, 0.02151263f, -0.01498020f, -0.08489714f, 0.03280282f, 0.05016776f, -0.14929572f, 
    -0.01062835f, 0.10232940f, -0.00893448f, -0.06836071f, -0.14370881f, 0.03912164f, 0.01002089f, -0.04566109f, 
    0.00591588f, 0.14334594f, 0.04512600f, -0.05222943f, -0.15561967f, -0.00359730f, 0.11462576f, -0.02843250f, 
    -0.02375067f, 0.02188045f, 0.05428104f, -0.01523391f, 0.08255090f, 0.12043405f, -0.16676781f, -0.03461260f, 
    0.08242778f, 0.01121901f, -0.10211903f, 0.07465217f, 0.06093310f, 0.01071318f, 0.05939602f, -0.07443337f, 
    -0.06289153f, -0.04267807f, -0.01922712f, 0.04625749f, -0.02080468f, -0.02305949f, -0.01234636f, -0.06429841f, 
    -0.09286553f, 0.05272958f, 0.09402453f, -0.03533786f, -0.10209291f, 0.10683672f, -0.29231548f, -0.01079150f, 
    -0.02617527f, 0.07758889f, -0.05708413f, -0.16116010f, -0.09294460f, -0.01890180f, 0.04085146f, 0.03740561f, 
    0.04063107f, 0.02294448f, 0.04046895f, -0.01398331f, -0.12200890f, -0.08749298f, 0.00938449f, -0.03590096f, 
    -0.12023021f, 0.19239132f, -0.00105828f, -0.14345081f, 0.01470299f, -0.01563181f, 0.02731588f, -0.03576123f, 
    -0.09218935f, -0.11175200f, 0.12808277f, 0.11339532f, 0.04786138f, 0.07794008f, -0.05205813f, -0.10388673f, 
    0.07942030f, 0.00419683f, 0.01295481f, -0.07823586f, -0.09939713f, -0.16185808f, 0.18531382f, -0.02197472f, 
    0.07499234f, -0.04141276f, -0.07238566f, 0.00944628f, -0.04892860f, -0.04204845f, -0.01547279f, 0.01329209f, 
    -0.11449863f, -0.13645333f, 0.08352026f, -0.00436330f, 0.00091771f, -0.03154172f, 0.03225193f, -0.02462061f, 
    -0.21669720f, -0.01330711f, -0.09974386f, -0.16227278f, -0.06216496f, 0.05208894f, -0.00363224f, -0.01283098f, 
    -0.06847379f, 0.00965548f, 0.06906396f, 0.01103347f, -0.04183340f, 0.11701629f, -0.01530479f, 0.09967197f, 
    -0.03734519f, -0.07238428f, -0.15169920f, 0.07823071f, -0.07752381f, -0.05094757f, -0.07676869f, -0.16932780f, 
    0.01318153f, -0.02744283f, 0.02985052f, -0.06095097f, -0.06982918f, 0.00038625f, 0.08591089f, 0.02886787f, 
    0.07696205f, 0.05125624f, 0.04019494f, -0.05494644f, 0.14545016f, -0.00360253f, 0.01023813f, -0.00159739f, 
    -0.02402215f, -0.12201679f, 0.10970412f, -0.04405543f, -0.00137492f, 0.03573011f, 0.00231067f, 0.00550861f, 
    -0.13803746f, 0.04894616f, 0.03183035f, -0.01823707f, -0.00153593f, 0.01524336f, 0.05064242f, -0.01872447f, 
    0.02361663f, -0.00695466f, -0.04716230f, 0.05400042f, -0.05493805f, 0.05819491f, -0.11455394f, 0.04500565f, 
    -0.09941258f, 0.00146306f, 0.04090915f, -0.05892089f, -0.13034828f, 0.05569075f, 0.03475548f, -0.01343586f, 
    0.01749105f, -0.02988113f, 0.03741432f, 0.04656072f, -0.09141577f, -0.05060611f, 0.05313012f, -0.00277923f, 
    0.07347239f, 0.07722781f, -0.07983620f, 0.06301039f, -0.04841029f, 0.00141332f, -0.09377421f, -0.02774870f, 
    0.06401542f, -0.02748488f, 0.10836764f, -0.10306088f, -0.02720447f, 0.01425796f, 0.06640276f, 0.02423787f, 
    -0.03633957f, -0.03005904f, 0.01440211f, 0.02126576f, 0.06413124f, 0.12634531f, -0.00657181f, 0.13857687f, 
    0.14534192f, -0.08658424f, -0.04363815f, -0.10349663f, -0.07274076f, -0.00611599f, -0.06861196f, -0.04865216f, 
    0.04075902f, 0.02279660f, -0.01738903f, 0.06733256f, 0.05886073f, 0.00494305f, 0.05162405f, 0.03458432f, 
    -0.13010234f, -0.05782443f, 0.25144207f, 0.07259426f, 0.14489514f, -0.07507689f, 0.02554872f, 0.06732672f, 
    -0.06097445f, 0.01312075f, 0.00339674f, -0.07252013f, 0.02525945f, -0.15443397f, 0.02463647f, -0.00029653f, 
    0.00073843f, 0.02461969f, -0.03159334f, 0.04441119f, 0.02167918f, -0.05254505f, -0.02590327f, -0.04153176f, 
    0.06933155f, -0.02361367f, 0.05776788f, -0.01531916f, -0.05343454f, -0.03079332f, -0.03073719f, 0.01519370f, 
    0.00860792f, -0.09083652f, 0.01148651f, 0.05061087f, -0.00173057f, 0.03942896f, 0.06075946f, 0.00361558f, 
    -0.24004953f, 0.23177518f, -0.03686246f, -0.11982094f, -0.28117463f, -0.07153511f, -0.06197168f, -0.07236476f, 
    0.04953587f, -0.09058043f, 0.04885332f, -0.02957822f, 0.00612883f, 0.10056430f, 0.04577033f, -0.03891136f, 
    0.04994126f, -0.11377386f, -0.12113353f, 0.13486834f, -0.06386972f, -0.09260131f, -0.22151737f, 0.04444502f, 
    0.10027471f, 0.04036835f, 0.01867692f, -0.01340216f, -0.03856996f, -0.03290771f, 0.00055351f, 0.07691441f, 
    0.05747530f, 0.00388301f, 0.02113066f, 0.01995344f, -0.09006284f, -0.08289416f, 0.01677508f, -0.02350773f, 
    0.01934759f, 0.19435191f, 0.03006382f, 0.00298719f, -0.08496431f, -0.03650828f, 0.05440178f, -0.01190736f, 
    0.01251549f, -0.03924029f, 0.02797881f, -0.01584806f, 0.00244806f, 0.12734957f, -0.01562335f, -0.04490919f, 
    0.03305257f, -0.04853546f, 0.08056753f, -0.18640181f, 0.08388005f, 0.12920484f, 0.01369031f, 0.05621245f, 
    0.17125237f, 0.10100548f, 0.07312471f, -0.11093240f, 0.00101133f, -0.05537821f, 0.03245814f, -0.02708359f, 
    -0.02511856f, -0.03177492f, -0.04041120f, -0.08353736f, -0.00611078f, 0.02567211f, 0.05435552f, -0.07207938f, 
    0.16923255f, 0.21376790f, -0.04266668f, 0.04419962f, 0.08099897f, -0.09843040f, -0.04621330f, -0.00093352f, 
    -0.02801171f, -0.08127321f, 0.04579793f, -0.03330809f, -0.04502206f, -0.05369618f, 0.09239704f, 0.00499814f, 
    0.02687780f, 0.07237307f, 0.10836083f, -0.02139938f, 0.07078315f, 0.15892962f, -0.06617852f, -0.08671978f, 
    -0.03057386f, -0.03277493f, 0.08699136f, -0.02010810f, -0.08176732f, -0.00385530f, 0.03612412f, -0.08216717f, 
    0.06886565f, -0.02492377f, 0.03758391f, -0.02369892f, 0.04411992f, -0.09812260f, 0.01210085f, 0.03812337f, 
    0.07101345f, 0.08963796f, 0.03885350f, -0.03244637f, -0.10490071f, -0.10470862f, 0.07188559f, -0.01568132f, 
    -0.07384572f, -0.01511679f, -0.01951280f, -0.01348075f, 0.05824189f, 0.06058350f, 0.01167898f, 0.02331742f, 
    -0.00820354f, -0.14822964f, -0.01467862f, -0.01611688f, -0.14307803f, -0.06308787f, -0.28657877f, -0.18635504f, 
    -0.13456891f, 0.07641025f, -0.03817138f, 0.03157490f, 0.01751008f, -0.08556939f, 0.09202948f, 0.08949253f, 
    0.01507653f, -0.02624854f, 0.00008038f, -0.01005711f, 0.07873447f, -0.01699062f, -0.01349576f, -0.04981518f, 
    -0.14297359f, -0.08378468f, -0.03320395f, -0.33911744f, -0.09082562f, -0.02402963f, 0.00181469f, -0.02530971f, 
    -0.03122159f, 0.00685084f, 0.08563299f, 0.00550408f, 0.05145714f, -0.01584362f, 0.08248697f, -0.02463332f, 
    0.00243116f, 0.04729765f, -0.10908152f, -0.10056904f, 0.09166580f, -0.01042080f, 0.07754024f, 0.04137622f, 
    0.10324167f, -0.02934983f, 0.01536290f, -0.07474405f, -0.03160894f, -0.04159916f, 0.04433801f, -0.06694359f, 
    0.04998112f, -0.08102573f, 0.12776226f, -0.04025056f, -0.00022541f, 0.01432034f, 0.08802412f, -0.04701173f, 
    0.08025450f, -0.00444867f, -0.14194852f, 0.03703604f, 0.12163245f, 0.11534157f, 0.03784334f, -0.00499580f, 
    0.01007025f, -0.01645301f, 0.06860298f, -0.03184038f, -0.03493069f, 0.03814667f, -0.00701081f, 0.03794875f, 
    0.04404230f, 0.08068071f, 0.07911523f, -0.03337495f, -0.22240296f, 0.08295989f, 0.19720310f, 0.00511113f, 
    -0.05574056f, 0.03999312f, 0.00004985f, 0.07669473f, 0.04334904f, -0.05160252f, 0.01720306f, 0.00462192f, 
    -0.04912813f, -0.05302741f, 0.00246071f, 0.00073544f, 0.05110599f, 0.01542481f, 0.03399888f, -0.02742259f, 
    0.13088405f, -0.08395746f, -0.09709634f, 0.00133757f, 0.16820347f, 0.07186823f, 0.07556462f, 0.04412883f, 
    0.01500379f, -0.07320175f, -0.09315975f, 0.08128070f, 0.00546962f, -0.01681513f, -0.07262144f, 0.06895991f, 
    0.03089110f, 0.01441535f, 0.03080212f, 0.07193130f, -0.00510339f, -0.20335357f, 0.13139866f, 0.09106203f, 
    0.06438025f, -0.13986394f, 0.00603714f, -0.03379125f, -0.10635643f, 0.00554064f, 0.01535328f, -0.05144386f, 
    -0.07240734f, 0.03103665f, 0.09594396f, 0.04708377f, 0.00987991f, -0.05022621f, 0.03887273f, -0.02322570f, 
    -0.30529737f, 0.06016143f, 0.13539715f, -0.06772164f, -0.06191233f, 0.01112990f, 0.01109528f, 0.04089839f, 
    -0.01167900f, -0.02597903f, 0.01603395f, -0.06171256f, -0.06463035f, 0.03377364f, -0.02773432f, -0.00735750f, 
    0.03824966f, 0.13698417f, -0.08697327f, -0.00466251f, -0.19142781f, 0.00234372f, -0.06167747f, 0.02053734f, 
    0.03578839f, -0.02769721f, 0.05883754f, -0.00765156f, 0.01787640f, -0.05790393f, -0.14803818f, 0.09757575f, 
    -0.09942315f, 0.05825920f, 0.01955989f, 0.03483697f, -0.02180622f, 0.07178115f, 0.04116871f, 0.07724539f, 
    0.14166312f, -0.23131812f, 0.08322456f, -0.09838635f, -0.07678075f, -0.02508502f, -0.04671803f, -0.06951003f, 
    -0.00771568f, 0.00519604f, 0.02241285f, -0.00461159f, -0.01505260f, -0.04870322f, -0.01476861f, 0.01260586f, 
    -0.04277286f, 0.02538482f, -0.02110576f, 0.04414666f, 0.03676539f, 0.05400455f, 0.05633383f, -0.09082261f, 
    -0.07308605f, -0.03717518f, 0.03830202f, -0.01235093f, 0.00207654f, 0.13691919f, -0.01469116f, -0.02494642f, 
    0.08839138f, -0.13571203f, -0.02334384f, 0.10551264f, -0.05241441f, 0.04162654f, 0.13233319f, 0.06705627f, 
    0.18165956f, -0.43671742f, 0.03129216f, 0.14217694f, 0.01833368f, -0.05782997f, -0.03551504f, -0.04746611f, 
    0.05913296f, -0.07662664f, -0.01162148f, 0.01996991f, 0.07349250f, 0.04573429f, 0.07496960f, 0.05024234f, 
    0.06322888f, -0.11190492f, -0.05552526f, 0.02536182f, -0.12208927f, 0.05655411f, -0.11040258f, 0.02901136f, 
    0.09907503f, 0.01167050f, -0.01276848f, 0.00171036f, 0.03364589f, 0.07586157f, -0.08391551f, 0.04118644f, 
    0.01552360f, -0.04445820f, -0.02566708f, 0.09327774f, 0.00251442f, 0.08725638f, -0.01036616f, 0.04961614f, 
    0.07004081f, -0.07308262f, 0.06029241f, -0.23490714f, -0.10953137f, -0.12093323f, 0.04992248f, 0.02631782f, 
    -0.08784868f, -0.00602191f, 0.06595414f, 0.02774396f, 0.04661300f, -0.01942262f, 0.00908869f, -0.05721678f, 
    0.05569757f, -0.00018221f, 0.15408976f, 0.06886226f, -0.05847533f, -0.11053481f, 0.07757480f, -0.01616732f, 
    0.02197795f, -0.09660405f, 0.01837625f, -0.04491286f, 0.07925957f, -0.03781172f, -0.09746967f, 0.06917207f, 
    -0.00631116f, 0.07431845f, 0.12133398f, 0.07646386f, 0.04135643f, 0.06308898f, 0.03600591f, 0.09711246f, 
    -0.10827970f, -0.00149611f, -0.20748745f, 0.13741966f, -0.11141934f, -0.00116927f, 0.04589251f, -0.04567415f, 
    0.03824985f, 0.10803232f, -0.02924162f, 0.04394345f, 0.08339931f, 0.08012278f, 0.07402730f, 0.02380264f, 
    -0.08329880f, -0.12267533f, -0.02708765f, -0.09468587f, -0.19938950f, -0.09604926f, -0.00611026f, 0.05595425f, 
    0.15241770f, -0.02320229f, 0.01365347f, -0.01359861f, -0.06074749f, 0.10736487f, -0.02078758f, 0.03644813f, 
    -0.01836068f, 0.03334533f, -0.02425937f, 0.09168740f, -0.08431058f, 0.04547060f, -0.01922400f, 0.08450725f, 
    -0.14530255f, -0.24303329f, 0.03663193f, 0.03856349f, 0.07625386f, 0.01527041f, 0.03292365f, -0.05716447f, 
    0.06430853f, 0.01401951f, 0.01067984f, -0.05623908f, -0.02998923f, 0.11643075f, 0.06845619f, 0.01036617f, 
    0.07346078f, -0.09446726f, 0.01252444f, 0.00504934f, 0.09542226f, 0.06090717f, -0.02510694f, 0.04385988f, 
    -0.08333157f, 0.10661149f, -0.02595634f, 0.02004614f, 0.06972400f, -0.07085856f, 0.03175331f, -0.03633195f, 
    0.03014479f, -0.05615194f, 0.07394989f, -0.05258707f, -0.04549145f, -0.01768100f, -0.00258462f, 0.01312889f, 
    0.07729246f, -0.28481284f, 0.11447946f, -0.02518054f, -0.10663632f, -0.06982804f, 0.01511360f, 0.08417125f, 
    0.19631609f, -0.10079726f, -0.07472898f, 0.03120421f, 0.06652380f, 0.02266604f, 0.00827812f, 0.01140366f, 
    0.06818130f, 0.07859072f, 0.01936196f, -0.01044556f, -0.01572114f, -0.22705960f, 0.01624981f, 0.23310657f, 
    0.11119321f, -0.13906993f, 0.01175997f, -0.05024961f, -0.07216602f, -0.03125764f, -0.11816233f, 0.07520029f, 
    -0.13807505f, -0.10349159f, -0.00689416f, -0.03246947f, 0.09113038f, 0.01585763f, 0.07439546f, 0.10195900f, 
    -0.08443607f, -0.12987161f, 0.10442284f, -0.25717142f, -0.27647135f, 0.00873429f, 0.08839762f, -0.06930531f, 
    -0.03734189f, 0.01701761f, -0.08536841f, 0.03347970f, -0.04497092f, -0.03962579f, -0.03003475f, -0.10495697f, 
    -0.10851920f, 0.12056758f, 0.02578882f, -0.01262975f, 0.00006662f, -0.05467072f, 0.02295727f, -0.39381319f, 
    0.06844765f, 0.02099555f, -0.14189966f, -0.13093801f, 0.04063629f, 0.07464860f, 0.00317877f, -0.06380597f, 
    0.04912377f, 0.03282864f, -0.00759915f, 0.09030961f, 0.00292493f, 0.03547150f, -0.04804146f, -0.21772513f, 
    -0.51380122f, 0.23043101f, 0.34788918f, -0.05671897f, 0.09850197f, 0.15765081f, 0.06149899f, 0.11282885f, 
    -0.05271088f, -0.12794133f, 0.06936463f, 0.00785707f, 0.03079033f, 0.05546947f, 0.08293135f, -0.00104170f, 
    0.01171408f, 0.07203428f, -0.20276445f, 0.05166642f, 0.05843663f, 0.01611909f, 0.06030434f, -0.24492647f, 
    0.00239166f, 0.03852355f, 0.02938151f, -0.01826496f, 0.00127202f, -0.05317549f, -0.06320027f, 0.02772238f, 
    0.06303533f, 0.03940827f, 0.00143352f, -0.00136419f, 0.00580291f, -0.01510882f, 0.04544181f, -0.07669344f, 
    0.02973491f, 0.05608438f, 0.00477410f, -0.12757848f, -0.18882036f, -0.09612095f, 0.04114546f, -0.08840154f, 
    0.10957299f, 0.04122807f, -0.06337321f, -0.01034770f, 0.01710613f, 0.05207476f, 0.00066835f, 0.18355736f, 
    0.11994996f, 0.04552259f, 0.06458623f, -0.04598899f, -0.12467945f, -0.21399832f, -0.04849670f, -0.10501899f, 
    -0.43709314f, -0.12986214f, 0.00363092f, -0.04053604f, -0.02196136f, -0.10591789f, 0.00467476f, -0.06018942f, 
    -0.06046715f, 0.11486793f, -0.05168055f, -0.02415919f, 0.06340480f, 0.10026569f, 0.02753583f, -0.02459512f, 
    0.37444377f, 0.01897974f, -0.23310494f, -0.31732014f, -0.07005239f, -0.02455630f, 0.01929356f, -0.03056647f, 
    0.01268207f, -0.02601956f, -0.03687223f, -0.01743912f, 0.04482180f, 0.01995477f, -0.08455155f, 0.01694274f, 
    0.06805402f, 0.00620438f, -0.04638153f, 0.11782605f, 0.06690123f, -0.15622331f, 0.03751288f, -0.16432688f, 
    -0.20597830f, -0.02200976f, 0.16095451f, -0.07298256f, -0.08881506f, -0.06604585f, -0.01891995f, -0.06543252f, 
    -0.10518524f, -0.10178380f, -0.03374989f, -0.02580711f, 0.04262526f, -0.08191360f, -0.03885136f, -0.04210294f, 
    0.29227445f, -0.04289817f, -0.13929814f, -0.07602071f, 0.02045592f, 0.03460342f, 0.02765495f, 0.07341906f, 
    -0.04843187f, 0.00385580f, -0.02853301f, 0.00187112f, -0.00295963f, 0.02915465f, 0.01890480f, 0.11805955f, 
    0.03470130f, 0.07131139f, 0.09659821f, 0.04629672f, -0.05402375f, 0.00932896f, 0.07892806f, -0.06705690f, 
    -0.14936894f, 0.08005802f, 0.01452995f, -0.06049289f, 0.02927308f, -0.10467120f, -0.08858556f, 0.03621878f, 
    -0.05651925f, 0.04329813f, 0.00559893f, -0.00679945f, 0.00301147f, 0.09934725f, 0.04647597f, -0.02181841f, 
    -0.05751459f, -0.02660099f, -0.00151194f, 0.07332678f, -0.07976042f, 0.05482807f, 0.15017943f, -0.04674692f, 
    0.01307656f, -0.23216473f, 0.00247835f, 0.01991612f, -0.03514409f, -0.01294630f, 0.02382754f, 0.00398660f, 
    -0.02877752f, -0.09522168f, -0.02098895f, -0.04513775f, -0.25100920f, 0.06405549f, -0.03482352f, -0.00253510f, 
    -0.02577545f, 0.09052022f, 0.07848880f, 0.06652810f, 0.02984957f, -0.13003746f, 0.01591281f, -0.00855970f, 
    -0.00838026f, -0.01742931f, -0.02963389f, 0.07806514f, -0.07966608f, -0.00998830f, -0.13802741f, 0.00831944f, 
    0.02417682f, -0.10381281f, 0.13833421f, -0.21008591f, 0.19218458f, 0.06546985f, 0.00121744f, -0.02096998f, 
    -0.01558805f, 0.02870180f, 0.04301383f, 0.04466651f, -0.02656277f, 0.09994603f, -0.06138945f, 0.01245866f, 
    -0.05477991f, -0.00212766f, -0.02695253f, -0.08366404f, 0.04307517f, -0.36188418f, 0.29377800f, -0.30935922f, 
    0.05016131f, -0.02613252f, -0.03603302f, -0.15352593f, 0.03239687f, -0.05611131f, 0.03831467f, 0.01234057f, 
    -0.07164704f, -0.01227117f, 0.01285182f, -0.06410293f, 0.05834190f, 0.02912997f, -0.10018964f, -0.00387764f, 
    0.03164871f, 0.02265736f, 0.09467211f, -0.02630725f, -0.09638337f, -0.07789538f, 0.03925334f, 0.03047969f, 
    0.10707098f, 0.00006221f, 0.00415662f, 0.00847232f, 0.06083803f, 0.04547406f, -0.00504984f, 0.06139275f, 
    0.03478499f, 0.00920490f, -0.01860347f, -0.01901917f, -0.05932956f, -0.24914289f, 0.17488128f, -0.01851577f, 
    -0.09452736f, 0.05792484f, 0.01928514f, -0.03492498f, -0.00427801f, -0.05014658f, -0.11886413f, -0.01585908f, 
    -0.08804620f, -0.00498266f, 0.01563874f, -0.03020539f, 0.00145962f, 0.05759294f, 0.01540904f, 0.00827013f, 
    0.16995530f, -0.04496598f, -0.08511479f, 0.10664956f, -0.39023423f, -0.00571510f, 0.03587222f, 0.12030152f, 
    -0.07644665f, 0.10948603f, 0.03879493f, 0.00471031f, -0.03547909f, 0.03808859f, 0.02671137f, -0.00966085f, 
    -0.03884206f, -0.05730484f, 0.03125393f, -0.00367466f, 0.21559860f, -0.19248369f, 0.01244093f, 0.13240951f, 
    -0.01362320f, -0.01768999f, -0.01994206f, 0.05783161f, 0.02213755f, -0.03401134f, -0.07347906f, 0.05334241f, 
    0.04046195f, 0.01657367f, 0.03169011f, 0.05977418f, 0.04105848f, -0.05685649f, -0.04399885f, 0.02301734f, 
    -0.21321093f, 0.03773574f, -0.10535196f, 0.09720255f, 0.00206470f, 0.08118369f, -0.00114771f, -0.05864785f, 
    -0.07807672f, 0.09389228f, -0.00644213f, 0.05013316f, -0.01047972f, -0.02931417f, 0.00289362f, 0.06004512f, 
    -0.09011921f, -0.00261966f, 0.01170778f, -0.03042535f, 0.21311601f, -0.17940089f, -0.02779903f, 0.16933614f, 
    0.04923040f, 0.00122618f, 0.01539333f, -0.05636292f, -0.01407458f, 0.11525425f, 0.00588226f, 0.06488546f, 
    0.07590376f, -0.06632704f, 0.09620686f, -0.07226612f, -0.04039668f, -0.07480282f, 0.04566266f, -0.03459035f, 
    -0.05993841f, 0.05677582f, -0.02938338f, -0.15312798f, -0.11374678f, 0.01636267f, -0.03120813f, -0.03582394f, 
    -0.04773366f, -0.02210326f, -0.05161146f, -0.07960472f, 0.09480544f, -0.05343816f, 0.05912579f, -0.15352257f, 
    0.01920858f, -0.06686857f, 0.11275968f, 0.07495207f, -0.21461153f, -0.12685366f, 0.03599915f, 0.00993552f, 
    0.20114124f, 0.03852242f, -0.03298408f, 0.02190587f, -0.06834976f, 0.01395747f, 0.06011469f, -0.00563051f, 
    -0.01519685f, -0.01839417f, 0.00129519f, -0.08776242f, -0.00783823f, -0.04565604f, 0.02871660f, 0.14912038f, 
    0.33489078f, 0.16695453f, -0.08873501f, -0.06772207f, -0.01369832f, -0.09729444f, -0.02531345f, 0.15655558f, 
    0.06374988f, 0.02435525f, 0.11015616f, -0.01346473f, 0.05034301f, -0.04140052f, -0.05739865f, 0.02023295f, 
    -0.00030642f, 0.04164076f, -0.00509536f, 0.06320959f, 0.39781782f, -0.10755088f, -0.12987083f, 0.06315347f, 
    -0.04861422f, -0.03402952f, 0.07510018f, 0.10809140f, -0.02968790f, -0.06900569f, -0.00553934f, -0.02402879f, 
    0.07742266f, 0.10514296f, 0.03398140f, 0.05416270f, 0.04400937f, 0.06186292f, 0.09407892f, 0.09358791f, 
    0.13285090f, -0.11317729f, 0.00671273f, 0.12508149f, -0.18766980f, 0.03700975f, 0.05113843f, 0.08845124f, 
    0.02622017f, -0.03227067f, -0.02237129f, -0.03852571f, 0.03221448f, -0.04647774f, -0.03274340f, 0.03977326f, 
    0.00419547f, -0.05015810f, -0.08434526f, -0.08471370f, 0.11992720f, -0.20910601f, 0.12846176f, -0.03047939f, 
    -0.08106487f, -0.02562991f, -0.12128416f, -0.08551805f, -0.00749724f, -0.01709699f, 0.05257916f, 0.03110909f, 
    0.04332760f, -0.02902880f, -0.00996559f, -0.00673307f, 0.00967796f, 0.03705155f, -0.00743872f, 0.06576324f, 
    0.43259129f, 0.05456830f, -0.19659446f, 0.04352688f, -0.23815717f, 0.00852351f, 0.00132828f, 0.16666877f, 
    -0.01737396f, -0.08861645f, -0.03400559f, -0.06373902f, 0.02771219f, 0.00747951f, 0.02558454f, 0.03886329f, 
    0.08521353f, 0.06111800f, 0.04672807f, 0.17036334f, 0.07485343f, -0.20557941f, -0.10729633f, 0.10851941f, 
    0.05374870f, 0.14257906f, -0.10060654f, 0.00885207f, -0.05398613f, 0.16107869f, -0.06609188f, -0.05098704f, 
    0.04382781f, 0.09527137f, -0.00045007f, -0.03007337f, -0.03920995f, 0.00155938f, 0.07480574f, -0.11334191f, 
    0.05504698f, -0.28462979f, 0.14034651f, 0.01468963f, -0.10651008f, -0.07426046f, 0.04233564f, -0.07487742f, 
    0.01600683f, 0.07398502f, 0.08210777f, 0.06313184f, 0.01842902f, -0.17251953f, 0.03386251f, -0.06009281f, 
    -0.00340327f, -0.15125331f, 0.08579089f, -0.01513548f, -0.05623524f, 0.00226848f, 0.00749637f, -0.17019208f, 
    -0.35466164f, -0.01670474f, 0.10451359f, -0.02244806f, -0.06684787f, 0.01947930f, -0.03263282f, -0.00436719f, 
    -0.07963576f, 0.02023655f, 0.07019323f, -0.04801342f, -0.00501331f, 0.02613311f, 0.12055141f, 0.00067048f, 
    0.18573876f, -0.20794469f, 0.10942176f, 0.03681808f, -0.02864880f, -0.01597326f, 0.06199133f, -0.00646851f, 
    0.00115148f, 0.01408842f, -0.03978069f, 0.02047256f, -0.02614509f, 0.05961778f, 0.01209471f, 0.02199196f, 
    0.03344001f, -0.03291930f, 0.05892304f, 0.04373569f, 0.42375827f, -0.43065614f, 0.04363570f, 0.06472772f, 
    0.27637362f, -0.11729235f, -0.01041185f, 0.05049999f, 0.08662531f, -0.07281866f, 0.04934983f, -0.06674039f, 
    -0.07199685f, 0.06991961f, -0.02517107f, 0.06015563f, -0.08769123f, -0.00328580f, -0.09068442f, 0.06907058f, 
    -0.35937604f, 0.00424627f, -0.00598709f, -0.07998154f, 0.09119090f, -0.00670202f, -0.00568810f, -0.04832295f, 
    -0.00564377f, 0.04428520f, -0.06492646f, -0.05410346f, -0.01341010f, -0.02045783f, -0.03409229f, 0.02864205f, 
    0.01806479f, -0.06812575f, 0.04985388f, -0.05816114f, 0.03604072f, -0.19370326f, 0.13020912f, -0.05742229f, 
    -0.10014924f, 0.04857068f, 0.08964124f, -0.06200197f, -0.01053974f, -0.03423702f, -0.07324226f, 0.06412992f, 
    0.02993006f, -0.03441213f, -0.03778988f, -0.09798003f, -0.01253448f, -0.03103429f, -0.01316563f, 0.06090186f, 
    0.09587586f, -0.04921399f, -0.10743442f, 0.14236936f, -0.01414043f, 0.03486003f, -0.04706790f, -0.08161069f, 
    0.07366472f, 0.04918762f, -0.05891304f, 0.06379991f, -0.03767173f, -0.01908134f, 0.09665289f, -0.00027653f, 
    -0.02891739f, 0.05826012f, -0.00068853f, 0.01417356f, 0.23400000f, -0.24804123f, 0.21634622f, -0.12322169f, 
    0.10268692f, 0.02821221f, 0.09433984f, -0.03399660f, 0.01521124f, -0.06771769f, 0.04889010f, -0.06068699f, 
    -0.02361800f, -0.00081787f, -0.00384393f, -0.05661524f, -0.06767500f, -0.06642282f, -0.02825418f, 0.01931929f, 
    -0.22003342f, -0.08379918f, 0.00699589f, 0.13071392f, -0.06492805f, -0.00420946f, -0.02066689f, -0.01261948f, 
    -0.02628204f, -0.00641251f, -0.10277921f, -0.03450523f, -0.11091062f, -0.00479330f, 0.09414045f, 0.00852608f, 
    -0.00255348f, 0.04326463f, 0.00145718f, 0.00454324f, 0.18458252f, -0.24875227f, 0.15044484f, -0.08084983f, 
    0.05706687f, -0.08438959f, -0.00417864f, -0.08177353f, 0.02910213f, -0.00598301f, 0.03104859f, -0.02013223f, 
    0.04052843f, -0.08997373f, -0.09418932f, 0.01309977f, -0.02824924f, 0.03442396f, 0.02096503f, 0.07442763f, 
    0.25804392f, 0.18313369f, 0.07288170f, -0.16492043f, -0.16263703f, -0.00507685f, 0.01005326f, 0.12066852f, 
    0.09990462f, -0.02117476f, -0.11645974f, 0.01219773f, 0.11200473f, -0.10772476f, 0.06600619f, 0.02368818f, 
    0.01470137f, -0.00089331f, 0.02020590f, 0.05881922f, 0.07767138f, -0.05950826f, 0.06724387f, -0.09991377f, 
    -0.01013097f, -0.02901812f, 0.12348246f, 0.00522984f, -0.05847749f, -0.06530647f, 0.08331939f, -0.02035828f, 
    -0.05782430f, -0.06194356f, 0.04189825f, 0.00380295f, 0.00498255f, -0.03670908f, -0.08710460f, -0.05868832f, 
    -0.14898302f, 0.26697227f, -0.03805966f, 0.14323741f, -0.05587744f, 0.05921711f, -0.02268747f, 0.02852573f, 
    0.01217990f, 0.03337423f, 0.02416558f, 0.00365955f, 0.08161413f, -0.02948392f, -0.00522121f, 0.02734469f, 
    -0.11680928f, -0.00298685f, -0.07788053f, -0.00569240f, -0.07018579f, -0.00615258f, -0.15359126f, 0.04407426f, 
    -0.14717889f, 0.02361345f, 0.11437306f, -0.03030962f, 0.00873562f, 0.00912170f, -0.16679889f, 0.00576925f, 
    -0.04943893f, 0.05569681f, 0.10447665f, 0.00947992f, -0.02451298f, -0.03740178f, 0.06893283f, 0.00670841f, 
    -0.08478470f, -0.03630989f, -0.11115464f, 0.06573810f, 0.04984628f, 0.05064166f, 0.04876840f, -0.03925901f, 
    -0.00468608f, 0.09123574f, -0.06178427f, 0.05095194f, -0.06704863f, -0.02488869f, -0.04044870f, -0.05227392f, 
    -0.03786929f, 0.05229411f, -0.01019260f, 0.02523053f, -0.14357378f, -0.01617848f, 0.13373876f, -0.11146177f, 
    -0.15727413f, -0.09807782f, -0.00343615f, 0.01164160f, -0.01411540f, 0.04754833f, 0.02983746f, -0.04658469f, 
    -0.02174269f, -0.11086453f, 0.01563693f, -0.06869915f, 0.01827404f, 0.11668710f, 0.01482370f, -0.01803617f, 
    -0.05209746f, -0.14388558f, 0.05351012f, -0.03855326f, -0.00166093f, -0.06954424f, 0.00965849f, -0.01686102f, 
    0.02517438f, 0.05918813f, 0.06590132f, 0.00892987f, 0.01700441f, -0.09074918f, -0.04414636f, 0.00957641f, 
    0.05797469f, 0.03094568f, -0.00204223f, 0.00927943f, -0.23579413f, 0.27903152f, 0.05480478f, -0.08158020f, 
    0.02677234f, -0.00936516f, 0.10778081f, -0.07079665f, 0.00586210f, 0.08559856f, -0.03990112f, 0.06609038f, 
    0.02862167f, -0.03026845f, 0.04738380f, 0.13140801f, 0.01326761f, 0.02945363f, -0.00042840f, -0.04993768f, 
    0.09070173f, 0.17934151f, 0.10516653f, -0.51959717f, -0.25721890f, -0.01174983f, 0.00780111f, -0.07512058f, 
    -0.02913248f, 0.10002712f, -0.04542786f, -0.07477155f, 0.08748887f, -0.11620255f, 0.05136111f, 0.04622540f, 
    0.01152566f, 0.05949887f, -0.04190764f, -0.02003915f, -0.07164480f, -0.15067822f, -0.04784637f, 0.14741467f, 
    -0.00059203f, 0.05314827f, -0.04545064f, 0.01365187f, -0.06770284f, 0.12825696f, -0.00545357f, -0.03432867f, 
    -0.02826308f, 0.02838203f, 0.08330006f, 0.03514311f, -0.11849587f, 0.04408491f, -0.04821354f, -0.04982879f, 
    0.04121320f, -0.14205463f, 0.13052996f, -0.02264400f, -0.21161434f, 0.03344940f, 0.06680929f, -0.00758093f, 
    -0.04981526f, 0.03994533f, -0.02292357f, -0.01700583f, 0.02246628f, -0.03136382f, -0.03407500f, -0.07982587f, 
    -0.03854577f, -0.02008272f, 0.06405254f, 0.05920019f, 0.02530428f, -0.32894647f, -0.17941850f, 0.14498696f, 
    0.10988988f, 0.04399987f, -0.05144980f, -0.08345391f, -0.01723947f, 0.15890093f, -0.01670566f, 0.03050243f, 
    0.00641081f, 0.04142917f, -0.06409711f, -0.11344376f, 0.00942583f, 0.01312674f, -0.02966116f, 0.03794574f, 
    -0.32898259f, -0.23867781f, -0.03818711f, -0.02750033f, -0.07237466f, 0.09807263f, 0.10051519f, 0.01791750f, 
    0.01588305f, -0.00860176f, 0.08731408f, 0.01669152f, 0.01743654f, -0.00039341f, 0.08050302f, 0.01605669f, 
    -0.03189656f, 0.02352896f, 0.03031592f, 0.00251859f, 0.08344993f, 0.06738685f, -0.01494016f, -0.01391439f, 
    -0.06149454f, 0.07938419f, 0.07637408f, -0.00571143f, 0.03996738f, 0.06912582f, 0.01734916f, 0.01452658f, 
    0.02532264f, -0.00330620f, 0.00561430f, 0.07050477f, 0.04506322f, -0.13539766f, 0.04321865f, 0.05301308f, 
    -0.27059877f, -0.12245766f, -0.00101525f, 0.08113430f, -0.02628971f, 0.01984120f, 0.00076348f, -0.02543372f, 
    0.02766962f, 0.05281577f, 0.00012110f, 0.04710260f, -0.01333040f, 0.04355093f, 0.02307208f, 0.09796645f, 
    0.03341911f, -0.01266626f, -0.01405277f, -0.02036463f, 0.18934701f, 0.17685899f, 0.02409255f, -0.08434362f, 
    0.02279836f, 0.05722262f, -0.00104959f, 0.06963944f, 0.07525986f, 0.01170242f, -0.02878696f, 0.04366476f, 
    0.05237357f, 0.05222787f, -0.02202948f, 0.13527039f, 0.10087074f, 0.06842049f, -0.03812263f, 0.08836062f, 
    -0.36797971f, 0.09171576f, -0.09599542f, -0.05348413f, 0.11953149f, 0.04298201f, 0.04436254f, -0.08618957f, 
    0.00373688f, 0.00158699f, 0.06727027f, 0.05037282f, -0.01459818f, -0.05343337f, 0.10700554f, -0.02573415f, 
    -0.01937329f, 0.02427253f, -0.09835442f, 0.04717627f, 0.17417572f, 0.21095470f, 0.00258844f, 0.02800767f, 
    0.03905397f, -0.01405218f, -0.04366617f, 0.02581988f, 0.03159443f, 0.02416232f, -0.02943518f, 0.02470646f, 
    0.14034106f, 0.03063642f, 0.00329629f, 0.03090407f, 0.09539316f, -0.01257738f, -0.01938829f, 0.00645171f, 
    0.24598517f, 0.20749386f, 0.18985021f, -0.07443388f, -0.13772808f, 0.04516186f, -0.07872321f, 0.03298198f, 
    0.08151872f, -0.03900784f, -0.09294147f, 0.02408579f, 0.03176254f, -0.00925784f, 0.00664498f, 0.03289931f, 
    0.07997888f, -0.05489218f, -0.10272829f, 0.02061226f, -0.09407850f, -0.10174654f, 0.06591506f, 0.00749096f, 
    0.14235987f, 0.07428750f, 0.09141547f, 0.00829008f, -0.00392464f, -0.04025327f, 0.07229149f, 0.07129860f, 
    -0.03815338f, -0.03926468f, 0.00107324f, 0.04229262f, -0.02208857f, -0.07725311f, -0.01017410f, 0.03771580f, 
    0.10949857f, -0.14458144f, -0.11272188f, 0.08568381f, -0.03531190f, -0.02963308f, 0.00011183f, 0.08190960f, 
    0.00311235f, -0.01181701f, 0.01443197f, -0.05606278f, -0.08911391f, -0.13178055f, -0.00283389f, -0.03880305f, 
    -0.00029148f, -0.01985266f, 0.00719423f, 0.02257124f, -0.10242514f, 0.20181310f, -0.00498050f, -0.01822769f, 
    0.03313129f, 0.03018305f, -0.05926979f, -0.04536459f, 0.02824255f, 0.03359241f, -0.03113518f, -0.03403572f, 
    0.04561400f, 0.02480110f, -0.01488581f, 0.05177566f, -0.03045372f, -0.07999334f, -0.00005498f, -0.01733638f, 
    -0.35188216f, 0.08316909f, -0.13216656f, -0.05885310f, 0.04869994f, 0.02178880f, 0.03271911f, -0.11359993f, 
    0.05956405f, 0.03480547f, 0.05451993f, 0.02522690f, -0.06706546f, -0.03463168f, 0.02400922f, -0.05960284f, 
    -0.05898197f, 0.05954592f, 0.00092189f, 0.02733592f, 0.06612290f, -0.03432809f, -0.06119328f, -0.00404952f, 
    0.04243843f, 0.04044021f, 0.05485036f, -0.02244756f, -0.00999983f, 0.04350602f, -0.01435691f, 0.01597421f, 
    -0.07176800f, 0.02641352f, 0.03834684f, -0.06742588f, 0.14603584f, 0.14173877f, 0.07956921f, 0.09003368f, 
    0.06293887f, -0.06828433f, 0.05726742f, -0.00152216f, 0.09251150f, -0.00162028f, 0.07204922f, -0.01023343f, 
    0.05924807f, -0.07026490f, -0.00366503f, -0.01716416f, 0.03654819f, 0.04525169f, 0.08653951f, -0.00940159f, 
    0.12129705f, 0.08296429f, -0.03724653f, 0.04218647f, 0.19911647f, 0.11261349f, -0.01087991f, -0.02226113f, 
    -0.12871510f, -0.00713219f, 0.08346480f, 0.02024253f, -0.07267220f, -0.01098342f, -0.04158865f, -0.00413242f, 
    -0.07513171f, 0.04354597f, -0.06089757f, 0.07063819f, 0.03931135f, -0.07015340f, -0.21555234f, 0.03387491f, 
    -0.35827720f, -0.18465666f, 0.15101518f, -0.19189794f, -0.18369827f, 0.07295860f, -0.01041539f, -0.04880904f, 
    0.04221762f, 0.03525559f, 0.01564407f, 0.07004078f, 0.03953400f, 0.13097507f, 0.01546187f, 0.09777298f, 
    0.00049419f, -0.03443290f, -0.02079847f, -0.02262830f, -0.40498993f, 0.15535529f, 0.00965499f, 0.00264991f, 
    -0.11014441f, 0.01598406f, 0.01714580f, -0.03548437f, -0.09919181f, 0.10464574f, -0.02276685f, -0.05034147f, 
    -0.02080314f, -0.05064913f, -0.02639187f, -0.11372127f, -0.06030243f, 0.01573949f, 0.03707312f, -0.03929210f, 
    -0.41076761f, -0.37404165f, -0.19656096f, -0.08967645f, 0.05779934f, 0.01539229f, 0.06003823f, 0.05262563f, 
    -0.01058959f, 0.01473536f, 0.12764160f, -0.04538414f, 0.02252531f, -0.05017439f, 0.06869634f, 0.07205595f, 
    -0.01334867f, 0.06565610f, 0.17326806f, -0.00632386f, -0.37141070f, -0.05552626f, -0.04665703f, -0.11548843f, 
    -0.09191724f, 0.05433359f, 0.06292166f, -0.04187665f, -0.01563056f, 0.09368201f, 0.01620714f, 0.01236351f, 
    0.05257961f, 0.04564903f, 0.01304980f, -0.10461985f, 0.02938114f, 0.10303140f, 0.09164884f, 0.09274416f, 
    -0.30030453f, -0.03010376f, 0.12457509f, -0.10457053f, -0.19110553f, 0.01122610f, 0.02987810f, -0.02348889f, 
    -0.01516300f, -0.00294903f, -0.04236161f, -0.11725616f, -0.05092823f, -0.08598571f, -0.11651234f, -0.01532299f, 
    -0.08089156f, -0.10617494f, 0.04709939f, -0.05532379f, -0.22006847f, -0.09518850f, 0.09569340f, -0.06396346f, 
    -0.06097096f, -0.04123325f, 0.06708518f, 0.01473718f, 0.01311978f, 0.03020830f, -0.07498805f, 0.01561417f, 
    -0.03597559f, -0.19228853f, 0.01565027f, 0.07408066f, -0.07142635f, -0.09818370f, -0.13260905f, -0.02264204f, 
    -0.00063364f, 0.08460300f, 0.08096227f, 0.01370520f, -0.06296516f, 0.02289312f, -0.02693535f, 0.04582231f, 
    -0.11052694f, 0.04721323f, -0.00899382f, 0.03880685f, 0.06724648f, -0.02584928f, 0.04440228f, -0.04972759f, 
    -0.01320129f, -0.02503907f, 0.02028184f, 0.05667052f, -0.36991423f, -0.18894686f, -0.08017092f, -0.09050652f, 
    -0.04858473f, 0.10130884f, -0.02653041f, -0.10240754f, -0.08483477f, 0.07597359f, 0.01799264f, 0.02437381f, 
    -0.02934870f, 0.02435388f, 0.04493903f, 0.02589917f, -0.00694139f, 0.04548570f, 0.02568345f, 0.03006886f, 
    0.05799209f, 0.10713433f, 0.05627385f, 0.00089721f, 0.00331058f, 0.12345976f, 0.04933097f, 0.03788223f, 
    -0.05288931f, 0.06262749f, 0.05749690f, 0.01308821f, -0.01234070f, -0.00385203f, 0.00390811f, 0.00346316f, 
    0.05371820f, 0.04926276f, 0.03767360f, 0.08374055f, -0.48435730f, -0.21114367f, -0.17294872f, -0.14557387f, 
    -0.31995574f, 0.04418513f, 0.07086888f, -0.00732981f, -0.07071590f, 0.11904783f, 0.04683177f, 0.05178305f, 
    -0.00980653f, 0.02279441f, -0.00008758f, 0.01902239f, 0.01862972f, 0.02717739f, -0.00380608f, 0.02797997f, 
    -0.39013326f, -0.24291505f, -0.19996573f, -0.14368738f, -0.22077031f, 0.02581516f, 0.12652147f, -0.12824033f, 
    -0.03580759f, 0.03935187f, -0.00578272f, -0.07802849f, -0.04812512f, -0.05169014f, 0.01630259f, -0.04630162f, 
    -0.02096565f, 0.11085212f, 0.09140149f, -0.00463573f, -0.37874535f, -0.34648398f, -0.05785769f, -0.04440407f, 
    -0.23144281f, 0.01043375f, 0.08471936f, -0.04038475f, -0.03745590f, -0.07284138f, 0.05592770f, -0.05391123f, 
    -0.03812622f, -0.05219579f, -0.03111100f, -0.06586982f, -0.06771792f, 0.04299814f, 0.07556622f, -0.02456038f, 
    -0.04277776f, 0.06267639f, -0.19680786f, -0.03707416f, -0.03748844f, -0.01683699f, -0.04111222f, -0.03949384f, 
    0.02141503f, -0.00544916f, 0.03671106f, -0.04966802f, 0.02548829f, -0.14469527f, -0.01142606f, -0.04789161f, 
    0.01810052f, 0.10042445f, 0.05360126f, 0.00928578f, -0.38927832f, -0.01594477f, -0.15234722f, -0.07480873f, 
    -0.01949811f, 0.00758393f, 0.03345811f, -0.07169561f, 0.00576072f, 0.10093387f, 0.01253586f, 0.01819400f, 
    0.03760052f, 0.00879720f, -0.05201387f, 0.06610839f, -0.07633618f, -0.03582262f, -0.10283210f, 0.00875082f, 
    -0.25799471f, -0.21783234f, 0.03014871f, 0.03828653f, 0.28068024f, 0.01014493f, 0.11170919f, -0.03268085f, 
    -0.01659905f, -0.12750040f, -0.02395952f, 0.01995978f, 0.00144921f, 0.07387879f, 0.11138959f, -0.04010276f, 
    -0.00016690f, 0.07701205f, -0.02745992f, 0.03611508f, -0.06681716f, -0.01752790f, -0.04467843f, -0.10360789f, 
    -0.03759857f, 0.02530906f, 0.10832036f, 0.01607418f, 0.01900171f, 0.06389359f, 0.05268906f, 0.06184504f, 
    -0.00923449f, -0.07062377f, -0.00148084f, 0.11731461f, 0.05718559f, -0.00869742f, -0.01615887f, 0.13306558f, 
    -0.36035845f, -0.10956752f, 0.04874621f, -0.02884321f, -0.09203801f, 0.04754042f, -0.02355059f, 0.00345628f, 
    -0.02846957f, 0.05217750f, -0.01764651f, 0.04518327f, 0.01376304f, 0.01819451f, 0.01396935f, 0.04209321f, 
    0.01194226f, 0.05140325f, -0.03529201f, 0.07977530f, -0.11600625f, 0.04109431f, -0.06687023f, -0.09117889f, 
    0.05010260f, 0.01267560f, 0.04585245f, -0.08889990f, 0.03447885f, -0.05362736f, 0.07380589f, 0.00525248f, 
    0.02324062f, -0.00945732f, 0.06699957f, -0.00494630f, 0.01713294f, 0.10369942f, -0.10118666f, 0.08726958f, 
    0.13467050f, 0.11129749f, -0.13390991f, 0.00748402f, -0.09541282f, 0.01512379f, -0.04254535f, 0.02797371f, 
    0.07246503f, 0.01057678f, 0.05538584f, -0.05116045f, 0.01615395f, 0.01460479f, 0.01794516f, 0.05427455f, 
    -0.00000219f, -0.07547233f, 0.03487248f, 0.03279171f, 0.10209260f, 0.10412081f, 0.00821067f, 0.00657538f, 
    -0.05501993f, 0.02056774f, -0.05500080f, 0.02797125f, 0.02311641f, -0.00615923f, -0.05202448f, 0.01137959f, 
    -0.08575749f, 0.06169197f, -0.06573629f, 0.06774910f, 0.05619759f, 0.02944894f, -0.00625061f, -0.01213844f, 
    -0.15876126f, -0.08252010f, -0.16678204f, -0.04019301f, -0.03558300f, -0.01190059f, -0.01123210f, -0.03895749f, 
    0.06249224f, 0.08179599f, -0.07665706f, -0.05299468f, -0.11735659f, -0.10731607f, -0.06637160f, 0.04919187f, 
    0.08693862f, 0.13309883f, 0.12326156f, 0.15853266f, 0.05226160f, 0.03297406f, -0.10777506f, 0.05377293f, 
    -0.00634077f, -0.06860487f, -0.01127092f, -0.00095159f, -0.00259144f, 0.10310888f, 0.01521373f, 0.01880759f, 
    -0.08702591f, -0.00489778f, -0.04611758f, 0.08561066f, -0.02758033f, 0.02187451f, 0.01831202f, 0.00572270f, 
    -0.06121249f, -0.11510257f, 0.00274375f, -0.03059693f, 0.06410588f, -0.04663799f, -0.05045150f, -0.04364310f, 
    -0.09043664f, 0.01226490f, -0.08882421f, 0.05981230f, -0.06163136f, -0.03891709f, -0.02255329f, -0.13163477f, 
    0.09007577f, 0.04157096f, -0.00301307f, 0.02064595f, -0.08139224f, -0.11016495f, 0.06843370f, 0.00237793f, 
    0.09047002f, -0.02572140f, 0.00706871f, -0.07176901f, -0.06703483f, -0.04392914f, -0.05613133f, 0.05623687f, 
    -0.00164862f, -0.03979969f, 0.00925701f, -0.10168979f, -0.00622520f, 0.01211602f, -0.10484227f, 0.08740913f, 
    -0.41253802f, -0.21096115f, -0.11721310f, -0.03639550f, 0.02945046f, 0.06949161f, 0.08353539f, -0.07002869f, 
    -0.02782919f, -0.06157381f, -0.01362668f, -0.06782247f, -0.00553226f, 0.14190358f, 0.05712399f, -0.03873483f, 
    0.02062442f, 0.07631186f, 0.03135845f, 0.04681357f, -0.10215952f, -0.00797124f, 0.04959479f, 0.18760422f, 
    0.05206091f, -0.01621928f, 0.00901458f, 0.00110423f, 0.00725503f, 0.00926757f, -0.00446520f, 0.03478398f, 
    -0.06283091f, 0.04128394f, 0.08614668f, 0.03918182f, -0.03644951f, -0.09254123f, -0.10167999f, -0.06208612f, 
    -0.34679177f, -0.16678660f, 0.17891011f, 0.04155271f, -0.02690472f, 0.05448792f, -0.01262488f, 0.02228114f, 
    -0.07148007f, 0.08242436f, -0.01180296f, 0.05380327f, 0.04066487f, -0.06648251f, 0.05345510f, -0.01686196f, 
    -0.04787183f, -0.05101927f, 0.03777562f, -0.00913034f, 0.28275651f, 0.12743504f, -0.08485526f, 0.03688557f, 
    -0.04558966f, -0.14108248f, -0.09740543f, -0.00150849f, 0.04238968f, -0.04736169f, -0.05464182f, -0.00797474f, 
    -0.03498666f, -0.13724004f, -0.08102582f, -0.00585748f, -0.05940978f, 0.04035605f, -0.07952167f, -0.07215161f, 
    0.23571995f, 0.20991333f, 0.04275486f, -0.06262845f, 0.01169397f, 0.14748041f, -0.03911489f, 0.04151674f, 
    0.03683867f, -0.04934671f, -0.13594039f, 0.03914550f, -0.06095730f, 0.07607058f, -0.01036584f, 0.04524958f, 
    0.06835495f, -0.01984323f, -0.11250594f, 0.03961598f, -0.19135027f, -0.13817091f, 0.21963727f, -0.07054245f, 
    -0.15866758f, 0.03038479f, -0.03816852f, 0.06127825f, 0.03999858f, 0.11777756f, 0.00257515f, 0.09768888f, 
    0.02821806f, -0.01558172f, -0.00076825f, -0.02166145f, 0.02123449f, -0.05966906f, -0.13834506f, -0.07743996f, 
    0.10528187f, -0.05172574f, -0.07477522f, -0.04940354f, 0.13712768f, -0.04595183f, 0.05440904f, -0.07007878f, 
    0.03259223f, -0.02539999f, 0.00612677f, 0.07180077f, -0.05283726f, -0.06106506f, -0.00546504f, 0.03423950f, 
    -0.00429111f, 0.01443121f, -0.20240389f, 0.08595812f, -0.04446792f, 0.03521659f, -0.28172752f, 0.09211802f, 
    0.15327606f, -0.06966238f, -0.01356213f, -0.04474308f, 0.00001274f, 0.08031867f, -0.07327704f, 0.02487261f, 
    0.11264613f, -0.12171564f, 0.12263038f, 0.05120646f, 0.07080283f, 0.02520953f, -0.08399276f, -0.03698456f, 
    -0.29027659f, -0.09602107f, -0.09610958f, -0.00350848f, -0.08102155f, 0.04183492f, 0.00999313f, 0.02286278f, 
    -0.01530279f, 0.04111822f, 0.05570301f, 0.02263637f, 0.01219910f, 0.00939544f, -0.02684657f, -0.01283933f, 
    -0.03487999f, 0.07354037f, 0.02551812f, 0.01804294f, 0.07792924f, 0.01404970f, -0.01978214f, -0.00484197f, 
    0.04639539f, -0.09406364f, -0.00129189f, -0.05452688f, 0.08847646f, -0.02204170f, -0.07690028f, 0.02352821f, 
    -0.03577926f, -0.04063552f, 0.07846048f, -0.00137458f, 0.09597806f, 0.10025743f, 0.01098756f, 0.02450199f, 
    0.19160528f, 0.06669658f, -0.01977411f, 0.00240501f, -0.02574330f, -0.12900639f, -0.09522378f, -0.04922117f, 
    0.04316023f, -0.06728587f, -0.04335142f, 0.04025235f, -0.02648680f, -0.03636780f, -0.06132619f, -0.03547496f, 
    0.06259146f, -0.01665890f, -0.09271913f, 0.03042690f, -0.29797029f, 0.03162944f, -0.14680232f, -0.06958770f, 
    0.08516599f, 0.03514563f, 0.04280204f, -0.01228132f, 0.02433553f, 0.05157275f, 0.06313655f, -0.01832614f, 
    0.06953835f, 0.00543381f, 0.03974528f, 0.10497067f, -0.02418259f, 0.05743901f, 0.00758866f, 0.04394590f, 
    -0.00173553f, -0.07215901f, 0.01499179f, 0.00472096f, 0.01435303f, 0.05704135f, 0.10495648f, 0.01737434f, 
    0.05856275f, -0.04718569f, -0.01818390f, -0.00018677f, -0.01573890f, 0.01652071f, -0.02361236f, -0.00116989f, 
    0.01557743f, -0.15354390f, -0.07126212f, 0.03032719f, -0.11822245f, -0.00017607f, -0.03261189f, 0.02494691f, 
    0.07478937f, 0.04728856f, 0.04072276f, -0.01498689f, 0.01340708f, 0.07838076f, -0.00587294f, -0.03833430f, 
    0.00416045f, 0.04177618f, 0.06085508f, 0.05986802f, -0.09453626f, 0.03638485f, -0.00337036f, 0.00656717f, 
    -0.20192145f, -0.34491503f, 0.11210576f, -0.05684827f, 0.06161216f, 0.12219315f, 0.00469968f, 0.04647718f, 
    0.03103251f, -0.00438338f, 0.00708118f, 0.04057968f, 0.00461906f, 0.10217406f, -0.09180190f, 0.06083957f, 
    0.03911568f, 0.04460816f, 0.18110442f, 0.13803582f, -0.44253340f, -0.18028869f, -0.13208745f, -0.12460230f, 
    -0.17098619f, 0.09756038f, 0.04025819f, -0.04973653f, -0.04982054f, 0.01514146f, -0.01936038f, 0.02408192f, 
    -0.06826617f, 0.06087517f, 0.03576614f, -0.05572817f, -0.07927810f, 0.08075368f, 0.02265737f, -0.00683137f, 
    0.12290183f, -0.03208191f, -0.11685180f, -0.01147491f, -0.00599683f, -0.08899879f, -0.00226010f, 0.02357069f, 
    -0.00216789f, -0.03676516f, -0.02724793f, -0.01606985f, -0.02414822f, -0.11463339f, 0.02442870f, -0.11210069f, 
    0.09474882f, 0.04261240f, 0.11765052f, 0.00926313f, -0.01964604f, -0.05166487f, -0.06981166f, -0.01300226f, 
    -0.07191809f, 0.02086370f, 0.05784038f, 0.01456547f, 0.07810441f, 0.08688513f, 0.03388261f, 0.00130471f, 
    0.02338392f, -0.01221106f, -0.01199940f, 0.04565790f, 0.00558315f, 0.04540372f, 0.06954702f, 0.10341167f, 
    0.09531061f, 0.09535348f, -0.10269465f, -0.00967871f, -0.09653430f, 0.01002111f, -0.01275701f, 0.01990069f, 
    0.04899022f, 0.06234599f, 0.09314989f, 0.01209557f, 0.00398940f, -0.02690316f, 0.04270031f, 0.12659813f, 
    0.04259866f, 0.02122491f, 0.11664803f, 0.06333456f, 0.05861189f, 0.11947189f, 0.23388870f, 0.04519232f, 
    -0.03530230f, 0.10699879f, 0.02850926f, 0.02837719f, 0.05419235f, -0.05065764f, -0.07238955f, 0.01313164f, 
    0.04215868f, 0.08003946f, 0.02514863f, -0.03475434f, -0.04268866f, -0.14288700f, -0.05514818f, -0.04402683f, 
    0.26942477f, 0.16476662f, 0.09551177f, 0.00549505f, 0.05506606f, 0.03147009f, -0.03591758f, 0.04203965f, 
    0.04718070f, 0.03450307f, -0.07051753f, 0.06236707f, 0.02388327f, -0.04179917f, -0.00999834f, 0.06430588f, 
    0.00279715f, -0.12839279f, -0.14457960f, 0.00299650f, -0.46329522f, -0.22512585f, -0.02992748f, -0.13540043f, 
    -0.22233756f, 0.06051846f, 0.08846024f, 0.03295868f, -0.09289896f, 0.02627256f, 0.08008123f, -0.03822072f, 
    0.06509595f, 0.00566076f, -0.02623996f, -0.05125377f, -0.07442769f, 0.03074806f, 0.08921144f, -0.00466717f, 
    -0.32110745f, -0.09432335f, -0.09639266f, -0.17284778f, -0.17409754f, 0.03369166f, -0.01512701f, 0.00258180f, 
    -0.02764479f, 0.07625394f, 0.01370379f, -0.00616044f, 0.05487627f, 0.08285731f, -0.07282778f, -0.00640245f, 
    -0.01111085f, -0.12464943f, -0.02519423f, -0.03885304f, 0.22166677f, 0.06566940f, 0.02176358f, -0.07937787f, 
    -0.03456337f, -0.10445356f, -0.09265266f, 0.03457287f, 0.10188458f, -0.02752544f, -0.09037038f, -0.03352812f, 
    -0.02208949f, -0.09001861f, -0.03496514f, -0.03606133f, 0.00143296f, -0.07679101f, -0.01194768f, -0.03111129f, 
    -0.37546328f, -0.16805694f, -0.16254430f, -0.12082060f, -0.01976904f, 0.07132652f, 0.05133785f, -0.04572482f, 
    0.04790201f, 0.04053793f, -0.05328169f, -0.03597588f, 0.01225717f, 0.05700649f, -0.02021330f, 0.11578122f, 
    0.04651147f, 0.10691845f, 0.11086452f, 0.11799861f, 0.27074248f, 0.08804675f, -0.17699018f, 0.10150962f, 
    -0.06280081f, -0.13203682f, -0.13915417f, 0.00341540f, -0.04513054f, -0.09725349f, -0.02906675f, 0.05326058f, 
    -0.09259589f, -0.06568503f, -0.02412053f, -0.08253314f, 0.02435160f, -0.07008386f, -0.08732687f, -0.04086969f, 
    0.12608337f, 0.04376706f, -0.04246232f, 0.07156534f, -0.06238321f, 0.05864797f, 0.06664195f, -0.04288633f, 
    -0.00300216f, 0.07439207f, 0.01936872f, 0.07714523f, 0.01123453f, 0.00903643f, 0.00340935f, -0.02105698f, 
    0.01530925f, 0.04294353f, -0.02822307f, 0.01663889f, -0.07277252f, 0.05146920f, -0.08092635f, -0.07345914f, 
    0.19651629f, 0.09522644f, -0.07831835f, -0.04719846f, 0.00751870f, -0.04320719f, 0.05155475f, 0.02507618f, 
    -0.02403499f, -0.00593649f, -0.05563801f, -0.01680128f, 0.06653278f, 0.12259550f, 0.00468039f, -0.02102593f, 
    0.24609041f, 0.02842612f, -0.09067850f, 0.02491517f, -0.20551093f, -0.08244231f, -0.02084624f, -0.02218599f, 
    0.03922005f, -0.01188573f, 0.05961142f, 0.02164435f, 0.03266650f, -0.05960706f, 0.00005205f, 0.00485760f, 
    0.00910215f, 0.00197246f, 0.00608988f, -0.02607427f, -0.06113581f, 0.04536231f, 0.01267004f, -0.01269600f, 
    0.11012810f, -0.01514307f, 0.03944270f, -0.03449893f, 0.02202164f, 0.04118194f, 0.06273437f, -0.00529269f, 
    -0.11747253f, 0.02317545f, 0.05172889f, -0.04121222f, -0.08884033f, -0.00564984f, 0.09285756f, -0.03202649f, 
    -0.47916552f, 0.05100025f, 0.05211848f, -0.00932259f, 0.00241041f, -0.06513655f, -0.01428554f, -0.09818757f, 
    0.08016559f, -0.08760462f, -0.04016170f, -0.00989030f, 0.10333336f, 0.04700857f, 0.03794689f, 0.05059036f, 
    0.02222829f, -0.03433648f, -0.03468603f, 0.02715433f, -0.07377855f, -0.04346617f, 0.06445015f, 0.08064722f, 
    0.15177788f, -0.06515335f, 0.09053782f, 0.01218003f, 0.09217034f, 0.08354270f, 0.03216644f, -0.09082461f, 
    -0.03955131f, 0.05535022f, 0.09271297f, -0.00211426f, 0.03737917f, -0.04862089f, 0.06874984f, 0.04656040f, 
    0.03789768f, -0.01020400f, -0.08121855f, -0.10421095f, 0.21859095f, 0.05887027f, -0.04039577f, -0.06615898f, 
    0.08625796f, 0.00549959f, -0.00846416f, -0.01355736f, -0.03435244f, -0.03358658f, 0.12421920f, 0.02812763f, 
    -0.04692179f, 0.01216696f, 0.05485026f, 0.04839761f, 0.04505940f, 0.21923932f, -0.06601720f, 0.05872089f, 
    0.05895964f, 0.03559921f, 0.00846260f, -0.00678746f, -0.01035436f, -0.07588188f, 0.01313013f, 0.02043254f, 
    0.07811805f, -0.02755562f, 0.05306764f, 0.00108715f, 0.05851891f, 0.01154753f, -0.05583718f, 0.06849134f, 
    -0.09773927f, 0.01548029f, 0.05628206f, 0.09212571f, -0.03340338f, 0.13376738f, -0.02004431f, 0.04987018f, 
    0.02882299f, -0.03951165f, -0.05917241f, -0.01176860f, -0.05338942f, -0.00869589f, -0.08318435f, -0.12101974f, 
    0.00300932f, -0.07800284f, 0.08825083f, -0.03144280f, 0.09913671f, -0.07866664f, -0.01061933f, 0.08672468f, 
    0.09546676f, -0.03647855f, 0.01724499f, -0.04420630f, 0.10692301f, -0.04343227f, 0.00488242f, -0.06155350f, 
    0.00063991f, 0.10734779f, 0.09072451f, 0.04009544f, 0.08178486f, 0.01564613f, 0.06672788f, 0.00228556f, 
    -0.34818044f, -0.15947491f, 0.03071361f, -0.03228689f, 0.04557681f, -0.03449120f, 0.06595045f, -0.02670831f, 
    0.05532188f, -0.08109018f, -0.04875118f, 0.04873013f, 0.04950839f, 0.09339333f, 0.05438247f, 0.00659577f, 
    0.08950158f, -0.06685803f, -0.09760412f, 0.03703083f, -0.23934801f, 0.00452153f, -0.05100648f, -0.06097014f, 
    -0.04728701f, 0.05644543f, 0.09788021f, 0.06545152f, -0.01137767f, 0.10188288f, -0.00904687f, 0.00587531f, 
    0.05800624f, -0.13264599f, -0.05312396f, 0.02656697f, -0.01714392f, -0.06287685f, -0.15479976f, -0.07489208f, 
    -0.10326707f, 0.03635367f, 0.10554873f, 0.01555333f, 0.00008512f, 0.01234813f, 0.04150441f, 0.02487835f, 
    -0.12038839f, 0.03534903f, 0.01590914f, 0.02655218f, -0.00592742f, -0.08565170f, -0.10794914f, 0.06544816f, 
    0.06229410f, -0.03414841f, 0.02402728f, -0.01800984f, -0.05746554f, 0.15840888f, -0.02352398f, -0.16645768f, 
    0.04623958f, -0.14455079f, -0.05321517f, 0.01611672f, -0.04908309f, -0.13628580f, 0.03733333f, -0.08069506f, 
    0.06024753f, -0.07974330f, -0.04835631f, -0.01506931f, -0.01687966f, -0.00048464f, 0.14169338f, -0.00299262f, 
    0.39741004f, 0.16386503f, -0.22365433f, -0.07185508f, 0.08734450f, -0.00852678f, 0.03680519f, -0.04886198f, 
    -0.07886547f, 0.02934036f, 0.09493452f, 0.08628409f, 0.00600660f, 0.01105177f, 0.01352738f, -0.01777963f, 
    -0.09998726f, 0.03734760f, -0.00032981f, 0.06756472f, -0.05238387f, -0.21356036f, 0.11398034f, -0.03306131f, 
    0.13423568f, -0.11339248f, 0.08021761f, 0.01695308f, 0.05927013f, -0.00010170f, 0.01297947f, -0.06872583f, 
    0.02834468f, -0.05327279f, -0.04870198f, 0.06847013f, 0.06606409f, -0.14940657f, 0.02611513f, 0.06161029f, 
    0.06706859f, -0.16906694f, -0.11675664f, 0.08880250f, -0.09869307f, 0.11351049f, 0.04323114f, -0.03714785f, 
    -0.00095487f, -0.01431970f, 0.02502994f, 0.00706481f, -0.02971296f, 0.05523516f, -0.02214039f, -0.00123511f, 
    0.00528474f, -0.09220506f, -0.09823638f, -0.03427693f, 0.14733297f, -0.17769638f, -0.00272640f, 0.00823256f, 
    0.01542311f, 0.01774896f, 0.03257939f, -0.00734402f, -0.00879955f, 0.01099853f, 0.06532792f, 0.01102507f, 
    0.00537090f, 0.03675512f, 0.00360889f, 0.05432966f, 0.07020371f, -0.09436059f, -0.02637180f, 0.01262528f, 
    -0.04903789f, -0.16913730f, -0.05544173f, -0.12935320f, 0.05516816f, -0.08892746f, -0.04578698f, 0.07015506f, 
    -0.01851299f, -0.07119168f, 0.02479979f, -0.08398972f, -0.02853077f, 0.00639985f, -0.05504199f, -0.00673129f, 
    -0.00892589f, 0.08636817f, 0.04657491f, -0.06317022f, 0.14316933f, -0.04254803f, -0.04196908f, -0.07861368f, 
    0.31132340f, 0.15442057f, -0.16062982f, 0.00696182f, -0.06112837f, -0.02855737f, 0.03555908f, -0.05124283f, 
    -0.06805083f, 0.05467099f, -0.12848300f, -0.00995865f, 0.08559154f, 0.06791788f, 0.07580649f, -0.11252901f, 
    0.00440610f, -0.15048856f, -0.00047342f, 0.07179598f, 0.12277585f, 0.03748853f, -0.08292279f, 0.03246809f, 
    0.16126242f, 0.05453198f, 0.00151660f, -0.00102533f, 0.00874231f, 0.10296991f, -0.01584648f, 0.10654083f, 
    0.03277404f, -0.00605351f, 0.00432340f, -0.05918649f, 0.23904456f, 0.16090895f, -0.06280584f, 0.00232974f, 
    -0.09480772f, 0.07781535f, 0.05641574f, -0.06967663f, 0.03218745f, 0.00765592f, 0.11032978f, -0.00040751f, 
    -0.00227838f, 0.00013371f, 0.02939454f, 0.01694776f, -0.04534426f, -0.04540784f, 0.01107336f, 0.08176392f, 
    -0.10922316f, 0.01222375f, -0.02862345f, -0.01065863f, 0.11579653f, -0.05643335f, -0.09062832f, -0.09950020f, 
    0.03571475f, -0.05648697f, -0.09156107f, 0.03139037f, -0.07333790f, 0.00203799f, 0.05494442f, 0.11298621f, 
    -0.05631601f, 0.06877232f, -0.02372870f, -0.07172459f, 0.39528108f, -0.02557156f, -0.17278662f, 0.00168457f, 
    -0.03154418f, -0.00518480f, -0.03690113f, 0.02328697f, -0.05105061f, 0.04544409f, 0.06620482f, 0.00193648f, 
    0.03851606f, -0.03333276f, -0.11340550f, 0.01166970f, -0.05095025f, -0.04757077f, -0.04406145f, -0.00279310f, 
    -0.14388388f, -0.26932272f, -0.08609425f, -0.20815794f, -0.30375177f, 0.08235303f, 0.04036664f, 0.02497501f, 
    -0.02334975f, 0.09465129f, 0.06824739f, 0.00671555f, 0.00924398f, -0.09090709f, -0.05229230f, -0.08865999f, 
    0.10009374f, -0.05005291f, -0.04856013f, -0.03573089f, -0.02447951f, 0.07115794f, -0.13995475f, -0.09993496f, 
    -0.38660127f, 0.08016398f, 0.05531539f, 0.06459709f, 0.04720726f, 0.08491018f, 0.04539875f, -0.03774915f, 
    -0.02205737f, -0.00538356f, 0.07143164f, -0.03655640f, 0.03551368f, -0.03229635f, -0.04960552f, -0.00161108f, 
    -0.22872226f, -0.28808290f, 0.00491724f, 0.00650985f, -0.00976308f, -0.02202995f, 0.08649732f, 0.03026290f, 
    0.01972695f, 0.04583998f, -0.11184117f, -0.01171075f, 0.02144418f, 0.02579476f, -0.01323096f, -0.03980084f, 
    0.00330117f, -0.08331683f, -0.07071779f, 0.01161975f, 0.35282955f, -0.01607128f, -0.14062148f, 0.09044429f, 
    -0.17073260f, -0.07844448f, -0.06098279f, 0.06099062f, 0.01429415f, -0.01813897f, 0.06500740f, -0.02001259f, 
    0.04192945f, 0.03229881f, -0.08090410f, 0.05006732f, -0.00092432f, -0.05901745f, 0.04227974f, -0.01235317f, 
    -0.33980295f, 0.29542199f, 0.02208414f, 0.11548671f, -0.31525257f, 0.07412937f, 0.06013221f, 0.02050093f, 
    0.03959465f, 0.04232490f, 0.00293800f, -0.04701055f, -0.03456159f, -0.07908929f, 0.04499490f, 0.02104607f, 
    0.07666811f, 0.02570712f, -0.03936487f, 0.00159221f, -0.26891023f, 0.21672256f, -0.05681887f, 0.04541900f, 
    0.28605083f, 0.04969614f, -0.08715401f, 0.01955174f, -0.00483585f, 0.12979168f, -0.00989444f, 0.05500231f, 
    0.08861309f, -0.03568907f, -0.01121407f, -0.06350847f, 0.05696809f, -0.01700753f, -0.01708214f, -0.03659327f, 
    0.00382910f, 0.16688143f, -0.06460393f, -0.12291731f, 0.11696773f, 0.15798078f, -0.00385403f, 0.03955526f, 
    0.04562924f, 0.01512354f, 0.03658458f, -0.03910759f, 0.09051986f, -0.05806806f, -0.00491313f, 0.01333944f, 
    0.00144676f, 0.03219069f, -0.10258066f, 0.03041574f, -0.46835983f, 0.04291501f, 0.03339195f, -0.00899070f, 
    0.04583053f, -0.01967130f, -0.03424126f, -0.07142566f, 0.07834353f, 0.02732299f, -0.05319610f, 0.01121576f, 
    -0.00729649f, -0.06155993f, -0.01355547f, -0.02074886f, -0.00207177f, -0.04927280f, -0.02064546f, 0.01811829f, 
    0.11088019f, -0.06522862f, -0.00136458f, 0.02477061f, 0.03053008f, 0.08587918f, -0.03235545f, 0.03764063f, 
    -0.10234328f, -0.04681014f, -0.01396008f, -0.00817395f, -0.07941774f, -0.02972923f, -0.12494158f, -0.02980573f, 
    0.00037710f, 0.02648816f, -0.02280766f, -0.00198351f, 0.00061824f, 0.10033448f, 0.04235411f, -0.04801787f, 
    0.01212819f, -0.02036424f, -0.00413593f, 0.03993707f, -0.06264670f, -0.12928779f, -0.00153917f, -0.06301925f, 
    -0.00171599f, -0.09641819f, 0.00483065f, -0.05916104f, -0.09773953f, -0.05738229f, 0.00441639f, 0.00166621f, 
    0.07175253f, 0.05825340f, -0.09270984f, -0.05412983f, -0.01494168f, 0.06082400f, 0.03290185f, 0.01605979f, 
    0.00843091f, 0.10692482f, -0.03997299f, -0.02280489f, -0.02642378f, -0.03327330f, 0.03708088f, -0.09193317f, 
    -0.09356333f, 0.00912295f, -0.06428186f, -0.08093897f, 0.10453048f, 0.11075198f, -0.01051090f, -0.01251767f, 
    -0.07916304f, 0.00334876f, 0.00294632f, 0.03729849f, -0.04056586f, -0.03639760f, -0.06309278f, -0.01314754f, 
    0.10990781f, -0.03191382f, -0.04531859f, 0.06431755f, -0.00719121f, 0.07290538f, -0.09549662f, -0.07385051f, 
    -0.10036953f, -0.12185422f, 0.02715372f, -0.00287437f, -0.21659382f, 0.05802669f, 0.06884129f, 0.05747449f, 
    0.06316020f, 0.05144826f, -0.07383721f, 0.00710461f, 0.00056177f, -0.09223171f, -0.00058702f, -0.02287594f, 
    -0.09670974f, -0.01232618f, -0.03054203f, 0.03392142f, -0.47141615f, 0.12327055f, -0.05873307f, -0.09045275f, 
    0.13605164f, 0.07439762f, -0.06276140f, 0.04754436f, 0.07682769f, 0.05407689f, -0.04140043f, -0.05916444f, 
    0.07343332f, 0.02868386f, 0.03310004f, 0.09645178f, 0.00694409f, -0.04440274f, -0.06550572f, -0.03894518f, 
    -0.24975735f, 0.22258650f, -0.13076045f, 0.04745387f, -0.24023446f, 0.08436458f, 0.05725093f, -0.01855757f, 
    0.04550819f, 0.08718516f, 0.04961051f, -0.03214090f, -0.00754559f, -0.03960894f, 0.10574816f, 0.02373476f, 
    -0.02534538f, 0.00951012f, -0.11315455f, -0.01119200f, 0.08386038f, 0.10978436f, -0.08293803f, -0.02611738f, 
    -0.26245776f, -0.05459449f, 0.00780121f, 0.00980716f, 0.03200592f, -0.07043954f, 0.11127745f, 0.03437878f, 
    0.02392442f, -0.06919006f, 0.04560088f, 0.02855496f, 0.06879227f, 0.01443744f, -0.07132954f, -0.08636835f, 
    -0.14264247f, -0.06071620f, -0.05922593f, -0.18738775f, 0.09673934f, 0.04307355f, -0.15941782f, 0.00305358f, 
    0.10958648f, 0.07568240f, -0.08764102f, -0.05712227f, -0.01875664f, 0.03509205f, 0.03107068f, 0.08245640f, 
    0.07838105f, 0.13148974f, -0.00008184f, -0.04886765f, -0.15658350f, 0.03334345f, 0.05060968f, -0.05862336f, 
    0.06059662f, -0.02911364f, -0.01003873f, 0.02875538f, -0.01081440f, -0.15923233f, -0.10313669f, -0.01418389f, 
    0.02618572f, -0.01993862f, -0.00350104f, -0.03569780f, -0.13842352f, 0.05393837f, -0.06360472f, 0.09768676f, 
    0.09638979f, 0.08478826f, -0.01189869f, -0.03210561f, -0.02464606f, -0.00770462f, 0.04929947f, 0.02057760f, 
    0.03569870f, 0.00307906f, 0.02635149f, -0.01571086f, -0.05965712f, -0.09641526f, 0.08416285f, 0.06957384f, 
    -0.12997414f, -0.01667170f, 0.03953062f, -0.03354548f, 0.12363511f, 0.13108709f, -0.16579048f, -0.16777202f, 
    0.19156811f, 0.01867548f, -0.02190427f, -0.03466665f, 0.00066747f, -0.01912209f, 0.04210649f, 0.01913100f, 
    -0.02307015f, -0.06127173f, -0.04178982f, 0.05487569f, -0.02464885f, 0.12503316f, 0.01282083f, 0.08431155f, 
    -0.39474061f, 0.19607946f, -0.02023597f, 0.00990581f, 0.14827335f, 0.08236469f, -0.08758945f, 0.03582039f, 
    0.03606415f, 0.06202390f, 0.00584688f, 0.01268034f, 0.05197310f, -0.01714398f, 0.02040963f, -0.02651082f, 
    -0.00049373f, 0.01750196f, -0.01366723f, -0.01752848f, -0.19874187f, 0.09636235f, 0.00433513f, 0.05242277f, 
    -0.08775548f, -0.09301871f, -0.01899941f, 0.01390943f, -0.01554138f, -0.04111280f, -0.06645475f, -0.02374834f, 
    0.05873112f, 0.03337046f, -0.06074269f, 0.05523362f, 0.01280229f, -0.03336870f, -0.00741541f, -0.05623077f, 
    -0.01974978f, -0.09185020f, -0.00494594f, 0.08163946f, 0.04246560f, 0.00686889f, 0.04630321f, 0.04023396f, 
    -0.05823134f, -0.09763176f, 0.02990395f, 0.00734209f, -0.00535037f, -0.06068010f, -0.02443545f, -0.03492256f, 
    0.02709952f, -0.04235314f, -0.08076509f, -0.03739507f, -0.07309087f, -0.19860895f, 0.00054891f, 0.00481963f, 
    0.00454604f, 0.04059518f, 0.06093513f, 0.01721000f, 0.01392689f, 0.05957915f, -0.05665987f, 0.03422654f, 
    -0.00647795f, 0.00038284f, -0.11329627f, -0.01417593f, -0.01688820f, -0.04968760f, -0.03430921f, -0.08366057f, 
    -0.05888186f, 0.08766296f, 0.07478479f, 0.03245255f, 0.00438242f, 0.04150194f, 0.01202175f, 0.01661452f, 
    -0.06268635f, -0.11034883f, 0.00030768f, -0.05990134f, 0.02293099f, -0.05412308f, -0.08182646f, -0.03857381f, 
    0.00938777f, -0.08406159f, 0.01260903f, -0.01736644f, 0.05147990f, 0.05531868f, -0.03883198f, 0.05364810f, 
    0.06873218f, -0.03014440f, -0.01634665f, -0.04218064f, 0.05209273f, 0.03834591f, 0.01660074f, 0.03287072f, 
    -0.02317900f, 0.04362404f, -0.05452468f, 0.06624655f, -0.01899633f, -0.04652468f, 0.02090973f, 0.01732409f, 
    -0.10067855f, 0.20105627f, -0.06159577f, -0.13084304f, 0.17177214f, 0.12054652f, -0.11936065f, -0.03899509f, 
    -0.02516799f, -0.07456771f, 0.11604783f, 0.09321778f, 0.02344401f, -0.05453681f, -0.00622937f, -0.01017133f, 
    0.03694509f, 0.04919506f, 0.04334441f, -0.01184124f, 0.25009492f, -0.07793363f, -0.12626377f, 0.04265965f, 
    -0.07728708f, -0.04368912f, 0.00937761f, -0.03424266f, -0.02697231f, 0.04754522f, -0.04624414f, 0.08739957f, 
    0.02202378f, 0.01497296f, 0.00402659f, 0.01689767f, 0.00570082f, 0.01583727f, 0.08096571f, -0.08848456f, 
    0.17008391f, -0.34683040f, -0.05398951f, -0.05264958f, -0.03127951f, 0.08341878f, -0.06693587f, -0.06901179f, 
    0.01701669f, 0.02484663f, -0.03986797f, 0.04433689f, 0.01891848f, 0.07384605f, 0.05963975f, 0.00578292f, 
    0.02960137f, 0.00931485f, 0.00058954f, -0.02107351f, 0.26536667f, -0.26023778f, -0.15212804f, -0.12029757f, 
    -0.19916479f, 0.00624281f, 0.03100623f, -0.03317804f, 0.00514945f, 0.03679904f, 0.03715529f, 0.00304716f, 
    -0.01701866f, -0.01672989f, 0.03253285f, 0.00628219f, 0.04683365f, -0.11328603f, -0.00730431f, -0.03163269f, 
    -0.26879090f, -0.26928961f, -0.04481435f, -0.04673703f, -0.18300536f, 0.02796991f, 0.02442249f, 0.12010416f, 
    0.00644246f, 0.10540424f, -0.02605962f, 0.04281816f, -0.02460957f, -0.01635491f, -0.21668056f, -0.14600140f, 
    0.01999191f, -0.13056807f, -0.05476229f, -0.02255456f, -0.18717568f, 0.03987505f, 0.00112052f, -0.02987531f, 
    0.16639096f, 0.17251460f, -0.07569940f, 0.03642668f, 0.00124963f, 0.06816270f, -0.03941372f, 0.04754297f, 
    0.04248162f, -0.01850605f, 0.02120204f, 0.01403639f, 0.02175878f, -0.01393403f, -0.03468130f, -0.02184342f, 
    0.00933148f, 0.01345290f, -0.01041586f, 0.04688529f, 0.02710048f, 0.11870389f, -0.00402244f, 0.01691062f, 
    0.01911576f, -0.01857450f, -0.01226643f, -0.06283373f, -0.02029714f, 0.02377303f, -0.10526808f, -0.01181089f, 
    -0.02411466f, 0.03566607f, -0.03228780f, -0.03112532f, 0.24985807f, 0.07277108f, -0.24044698f, -0.07991543f, 
    0.11477029f, 0.00572311f, 0.03668490f, -0.09369619f, 0.02885545f, -0.02680970f, 0.04846506f, 0.00617847f, 
    0.03380588f, -0.01266666f, -0.04226733f, -0.00526522f, -0.04441922f, 0.07678233f, -0.04199225f, 0.00382471f, 
    -0.06931832f, -0.00573676f, -0.00898188f, -0.02015103f, 0.08700959f, -0.06967268f, -0.02742356f, -0.05271030f, 
    0.03840581f, -0.06048517f, 0.05839569f, 0.01080988f, -0.00629569f, 0.02209826f, -0.00099181f, 0.07179897f, 
    -0.08134881f, 0.01063088f, 0.06598946f, 0.06646310f, 0.12074202f, -0.11649635f, -0.15924416f, -0.00608967f, 
    -0.18902770f, 0.02638291f, 0.03648613f, 0.05875545f, -0.02804022f, -0.03704648f, 0.01460918f, 0.06461111f, 
    -0.05634363f, 0.00682466f, -0.08514242f, 0.01863258f, 0.05678112f, -0.05913414f, 0.04557715f, -0.05446151f, 
    0.33462453f, -0.09175442f, -0.26236460f, 0.07969655f, -0.00237751f, -0.00364452f, 0.03743781f, -0.07710625f, 
    -0.03318027f, -0.00094214f, 0.12247350f, -0.01676028f, 0.00163843f, 0.07546125f, 0.02300250f, 0.05451408f, 
    -0.07683821f, -0.06684113f, 0.04219690f, 0.06229244f, 0.08513341f, 0.06583415f, -0.04347325f, 0.08030517f, 
    -0.00931569f, 0.09312336f, -0.05363606f, 0.06745686f, -0.13921598f, -0.10262564f, -0.03816160f, -0.00658473f, 
    0.07904634f, 0.02979413f, -0.08852257f, -0.01672867f, -0.01949253f, 0.01713178f, -0.07113206f, -0.02765571f, 
    0.15533713f, -0.01259641f, -0.12779257f, -0.00822467f, 0.12858650f, -0.00136971f, 0.03402201f, 0.02465999f, 
    -0.00580284f, 0.06129497f, -0.02461775f, 0.06388691f, -0.01050216f, -0.05927589f, 0.04236070f, -0.01623970f, 
    -0.05334122f, 0.02315747f, -0.01619283f, -0.04591616f, 0.00967190f, -0.10024749f, 0.05937675f, -0.01020060f, 
    -0.06741107f, 0.03002691f, 0.08239638f, 0.00212992f, 0.01173799f, -0.05107878f, -0.22116715f, 0.01338332f, 
    0.11239114f, -0.01076326f, -0.13719724f, 0.04530868f, 0.01698793f, 0.03967404f, -0.15702140f, -0.04117386f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.05370036f, 0.05212598f, -0.01859116f, -0.03884503f, 0.00167191f, -0.00603247f, 0.00598652f, -0.07556044f, 
    -0.01178053f, -0.00249013f, 0.07702936f, 0.00143230f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 5120);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
