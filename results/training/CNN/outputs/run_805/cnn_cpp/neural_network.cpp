#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.65725869f, -0.30058253f, 0.65154862f, 0.72621793f, 0.20777301f, -0.34160614f, -0.28934702f, -0.16949618f, 
    0.43940529f, 0.69205672f, 0.53713822f, -0.58753186f, 0.23699015f, -0.02093550f, -0.44200096f, 0.11308829f, 
    0.25628489f, 0.15836039f, -0.39087647f, 0.18267404f, 0.25983560f, 0.33979204f, -0.43568397f, -0.70870864f, 
    -0.54939085f, -0.36809278f, -0.18372086f, -0.46932200f, -0.65933543f, 0.78593206f, -0.14051835f, -0.03119754f, 
    -0.40266582f, 0.36283144f, 0.25555646f, 0.13023515f, 0.70615780f, 0.11455151f, 0.50395918f, 0.11471944f, 
    0.32949147f, -0.18242078f, 0.42638460f, 0.33483309f, 0.13383146f, -0.67630297f, 0.55758983f, -0.29387859f, 
    0.00708810f, -0.08710135f, -0.56861621f, 0.22197242f, 0.08922870f, -0.18731655f, 0.53594607f, -0.63233942f, 
    0.22129677f, -0.21818723f, -0.69099873f, 0.44595933f, 0.34006894f, -0.06347776f, 0.51042533f, 0.58952194f, 
    0.30053946f, 0.19710408f, -0.66855758f, -0.06520338f, 0.60950059f, 0.10744456f, -0.27589506f, -0.50957000f, 
    0.48574331f, 0.61347038f, 0.80590266f, -0.21025600f, -0.44479731f, 0.36970425f, -0.63749635f, 0.31470612f, 
    0.05993683f, -0.40865478f, -0.15853965f, -0.63216472f, 0.01084058f, -0.54358858f, 0.16725765f, -0.50498134f, 
    0.23689823f, -0.08515339f, -0.60628432f, 0.66508919f, 0.69643128f, 0.69690365f, 0.54722923f, 0.38003802f, 
    -0.04867499f, 0.09821054f, 0.13198817f, -0.24867187f, -0.37652332f, -0.55570948f, 0.57013553f, 0.30592269f, 
    0.38084254f, 0.05177520f, -0.32565337f, 0.16261879f, -0.13172758f, -0.58608836f, -0.72817153f, -0.09664728f, 
    -0.54635471f, -0.12820213f, -0.13759114f, 0.30399254f, 0.38811174f, 0.60488409f, 0.68358552f, 0.62844050f, 
    -0.53468108f, -0.43475446f, -0.74360305f, -0.23883472f, -0.25911051f, -0.22775340f, 0.54786211f, 0.70126164f, 
    -0.26003966f, -0.51094645f, -0.66132182f, 0.11255752f, -0.05100921f, -0.05150230f, 0.15030707f, -0.38526466f, 
    -0.41944826f, -0.65739501f, -0.17881301f, 0.60755467f, 0.74380618f, -0.11178371f, 0.03374523f, -0.26797530f, 
    0.48689908f, 0.26432791f, 0.58000338f, 0.32883877f, -0.57562160f, 0.52521259f, 0.27457109f, -0.48103794f, 
    -0.31201077f, -0.66212338f, -0.60578442f, -0.33633706f, -0.48073730f, -0.47426125f, 0.63632447f, 0.01834922f, 
    0.16837846f, -0.03657812f, 0.76004595f, -0.58131939f, -0.59966874f, -0.14576536f, 0.10756199f, -0.52702570f, 
    -0.38383821f, -0.24326268f, -0.26917943f, -0.71344501f, -0.48879158f, -0.36621398f, 0.21755214f, 0.54475278f, 
    -0.29473534f, 0.10238069f, -0.22513439f, -0.12335749f, -0.70316356f, 0.32074919f, -0.04088477f, -0.49534336f, 
    0.33686760f, -0.34615687f, -0.31410122f, -0.45634452f, -0.41995174f, -0.57405716f, 0.39326212f, 0.35321230f, 
    -0.22054301f, -0.35862803f, 0.76093495f, 0.06971829f, 0.22511643f, 0.62775528f, 0.34698811f, -0.20393667f, 
    0.19371292f, -0.78306246f, 0.65006965f, -0.34835050f, 0.08337198f, 0.02645022f, 0.08913730f, -0.14392382f, 
    0.20249982f, -0.00396523f, -0.51288146f, -0.58570081f, -0.85057670f, 0.07909174f, 0.08788726f, 0.52995759f, 
    -0.19143771f, -0.57627517f, -0.79818803f, -0.47720319f, 0.19812134f, 0.32085136f, -0.02975606f, -0.32580525f, 
    0.46265662f, -0.59412557f, -0.78574544f, -0.19326183f, 0.26694077f, -0.19852041f, -0.01132661f, -0.09742229f, 
    -0.23518929f, 0.08473644f, -0.10714978f, 0.64495742f, -0.14950903f, -0.46596184f, 0.66510797f, -0.05486399f, 
    0.42924029f, 0.03566759f, -0.55202019f, 0.49842399f, 0.83992589f, -0.98793817f, 0.39356393f, 0.25771311f, 
    0.20026462f, 0.34886718f, -0.00593570f, 0.08512313f, 0.63294816f, 0.35425645f, 0.31168759f, 0.34547707f, 
    0.07842899f, 0.01696871f, -0.26879978f, 0.32581910f, -0.48027241f, -0.77027053f, -0.04903332f, -0.42077002f, 
    0.37607279f, 0.40845656f, 0.51117676f, 0.47396341f, 0.12169224f, 0.11255527f, -0.26665741f, -0.47453961f, 
    -0.38207743f, -0.14543545f, 0.77088439f, -0.55473143f, -0.00764575f, 0.25088793f, -0.16803302f, -0.17522416f, 
    0.48541996f, 0.03763579f, -0.57426822f, -0.34189424f, 0.21212786f, 0.49481997f, 0.17267327f, 0.23119129f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.13104607f, 0.29188883f, -0.04349066f, -0.35227060f, -0.04657225f, 0.24000220f, 0.27561903f, -0.33261845f, 
    -0.04249753f, 0.14551245f, -0.01972940f, -0.11223529f, 0.14636171f, -0.08837187f, -0.08430917f, 0.02947620f, 
    0.10292442f, -0.08070544f, -0.13193747f, 0.07280022f, -0.24683529f, -0.02078540f, 0.08448422f, -0.13440277f, 
    0.11356782f, 0.07336891f, -0.16990352f, -0.44975930f, -0.09236725f, -0.05413539f, 0.11225102f, -0.08377609f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.01122122f, -0.02446515f, -0.04522206f, -0.06915215f, -0.07484308f, 0.01121206f, 0.03547952f, 0.31231833f, 
    -0.08646349f, 0.35846853f, -0.13447352f, 0.12029348f, -0.06990557f, -0.00299473f, -0.08599342f, 0.13531126f, 
    0.20057073f, 0.01631994f, -0.21402220f, -0.06291281f, -0.01664813f, -0.09514753f, -0.04058942f, 0.12649527f, 
    0.06402832f, 0.01010172f, -0.06914609f, -0.41241497f, -0.03972529f, -0.14958012f, 0.04866721f, 0.04976615f, 
    0.02207453f, 0.03918455f, 0.04258713f, -0.21790715f, 0.16803871f, -0.29049513f, -0.12253287f, -0.00285736f, 
    -0.08459852f, -0.15080968f, -0.04480752f, 0.09279160f, 0.02234345f, 0.10087196f, -0.15680228f, -0.06689303f, 
    -0.24642108f, 0.00393372f, 0.11414448f, -0.11010241f, 0.13617669f, 0.16489950f, 0.08417527f, -0.21870546f, 
    -0.12149876f, 0.19010746f, 0.09786141f, -0.10181159f, -0.00429618f, -0.06903046f, -0.20496149f, 0.18849280f, 
    0.00397285f, -0.05583048f, -0.22995242f, 0.17504598f, -0.04237940f, 0.01082271f, 0.04616889f, 0.09224661f, 
    0.00629574f, 0.03214805f, -0.14896899f, -0.12825333f, -0.05184731f, -0.22383295f, 0.14190573f, -0.09621313f, 
    -0.14441976f, -0.00469244f, -0.08506189f, 0.13733615f, -0.06714625f, 0.02866664f, 0.10743472f, 0.07348070f, 
    -0.04361514f, 0.22970045f, -0.04365286f, -0.03189272f, 0.05879675f, -0.01393765f, 0.07014900f, 0.15116797f, 
    -0.03029822f, -0.15991695f, -0.32048735f, -0.12937762f, -0.06904888f, 0.26058182f, 0.03990690f, 0.09062499f, 
    0.10705745f, -0.14377639f, -0.07915352f, -0.01610238f, 0.09852380f, -0.08653443f, 0.07126355f, 0.00663489f, 
    0.02528220f, 0.05073234f, 0.10714572f, -0.04854184f, -0.07657187f, 0.45810324f, 0.15387461f, -0.28157398f, 
    -0.11822416f, -0.38437444f, -0.13903180f, 0.22043550f, 0.16569190f, 0.10024449f, 0.30573532f, 0.00194589f, 
    -0.01462010f, -0.02358970f, 0.02819509f, -0.11749753f, 0.03503887f, 0.16774079f, -0.00454853f, -0.14809622f, 
    -0.01618874f, 0.07264251f, 0.01430547f, -0.05569731f, 0.05821038f, -0.06574684f, -0.15062207f, 0.09024261f, 
    0.14167739f, 0.03445048f, -0.06928444f, 0.24913079f, 0.03960545f, -0.03843451f, -0.09010681f, 0.07281844f, 
    -0.06892888f, -0.05154775f, 0.13274622f, -0.11036547f, -0.01899517f, 0.04932575f, -0.10890425f, 0.08373013f, 
    0.08903037f, 0.05567339f, 0.35770437f, 0.11380121f, 0.10281284f, -0.01059740f, -0.04596501f, -0.04678013f, 
    0.12773126f, 0.14881603f, 0.14019193f, 0.17487788f, -0.11031562f, 0.26387915f, -0.07828007f, -0.12582460f, 
    0.10286741f, -0.04934701f, -0.05607561f, 0.14809932f, -0.24647735f, 0.03886990f, -0.14449802f, -0.26067242f, 
    -0.11487871f, 0.08794119f, 0.11333085f, -0.06992634f, -0.03960742f, -0.37496880f, 0.05658127f, -0.06793072f, 
    -0.09527653f, 0.20708789f, 0.08784126f, 0.03511233f, -0.19281647f, -0.25885558f, 0.16658527f, -0.03253965f, 
    0.04951661f, -0.14857773f, -0.03332580f, 0.06129740f, 0.04015326f, 0.01827245f, -0.02305677f, -0.12857200f, 
    -0.12835357f, -0.09801231f, 0.10359813f, -0.06485264f, -0.13608275f, -0.00680708f, 0.08761574f, 0.04953966f, 
    -0.09722655f, 0.10887296f, 0.28430948f, -0.05049587f, 0.10643835f, -0.06961893f, 0.04918637f, -0.00050358f, 
    0.02953308f, 0.01810571f, -0.05105010f, -0.02447578f, -0.20075367f, -0.10481828f, 0.05656980f, -0.06783459f, 
    -0.10290683f, -0.06226341f, 0.09834964f, 0.04167819f, -0.28357640f, -0.12110399f, 0.06554455f, -0.01221019f, 
    -0.12631893f, 0.15233651f, -0.10859395f, -0.04583927f, 0.07633585f, 0.22192505f, -0.07087984f, 0.27868176f, 
    -0.04437743f, -0.07430096f, 0.03684290f, -0.15069197f, 0.26549354f, 0.02582288f, -0.10205024f, -0.00866645f, 
    -0.02835806f, -0.24134858f, 0.19274327f, 0.08841365f, -0.01119217f, 0.19721459f, -0.03549511f, 0.18515190f, 
    0.02657022f, 0.08656146f, 0.12851138f, -0.03593356f, -0.12871738f, -0.09301201f, -0.05353624f, 0.09631299f, 
    0.10747618f, 0.00168556f, -0.01505162f, 0.05743049f, -0.08123446f, -0.07178333f, 0.05992763f, -0.35571817f, 
    0.00969697f, -0.24615781f, 0.02272804f, 0.08586520f, -0.01127843f, -0.04482574f, -0.09271547f, -0.11664104f, 
    0.07487293f, -0.17427213f, -0.26717505f, 0.04902615f, 0.02884478f, 0.22190368f, -0.03180894f, -0.09834320f, 
    0.14446603f, 0.25750732f, 0.03330880f, -0.22472854f, 0.05003805f, 0.05529995f, 0.09958759f, 0.04946991f, 
    -0.06037756f, 0.00507437f, -0.17765434f, -0.08729400f, -0.14980744f, 0.00436060f, -0.09126641f, 0.00683845f, 
    0.04986183f, -0.09724467f, 0.00658912f, -0.18350315f, -0.28163207f, -0.00166186f, 0.02417982f, -0.06383780f, 
    0.00249295f, -0.17743590f, -0.16902158f, 0.08401118f, 0.16501530f, -0.03058882f, -0.26870054f, 0.14436878f, 
    0.10509256f, -0.06552909f, -0.02528219f, -0.07429617f, 0.12780073f, -0.16692698f, 0.00208205f, 0.08438317f, 
    0.08452728f, -0.11156342f, 0.04714576f, 0.02680277f, 0.11057495f, -0.05033762f, 0.02914005f, -0.01290878f, 
    0.22386469f, 0.08440917f, 0.13807192f, -0.16437672f, 0.05416968f, 0.14958881f, -0.07589813f, 0.02697256f, 
    -0.20135024f, -0.27351075f, 0.05678919f, 0.11151901f, 0.08258306f, 0.05216559f, -0.01566872f, -0.16705841f, 
    -0.12276141f, -0.18893939f, -0.22934739f, 0.15745102f, -0.01526473f, 0.03049932f, 0.12426517f, -0.15876958f, 
    -0.08354397f, 0.05349436f, -0.01474760f, 0.14030407f, 0.03178509f, 0.05463770f, -0.05614923f, 0.01632466f, 
    -0.08542491f, 0.09084571f, 0.18585241f, -0.14628696f, -0.14644879f, -0.00602096f, -0.01244950f, -0.04864433f, 
    0.03343794f, -0.06838171f, 0.30434099f, -0.01058270f, 0.04786586f, 0.14708531f, 0.01624188f, 0.09723715f, 
    0.01402341f, -0.17837404f, 0.01842797f, 0.11966833f, 0.01182300f, 0.14299583f, 0.19324113f, 0.12073928f, 
    -0.01064629f, -0.03828024f, 0.09026969f, -0.04813380f, -0.04975925f, 0.07512210f, 0.10831252f, -0.40873870f, 
    0.14556600f, 0.06787643f, -0.06766786f, -0.01916268f, -0.02822374f, -0.01510179f, 0.13159446f, 0.00695324f, 
    0.05301768f, 0.02058627f, 0.04562620f, 0.06970885f, 0.16089666f, 0.04684161f, 0.00480404f, -0.04475635f, 
    0.15060671f, 0.05984997f, -0.17329185f, 0.07721379f, 0.05941619f, -0.04935012f, 0.06571402f, -0.02740292f, 
    -0.03540021f, 0.06813728f, -0.16932060f, 0.04895452f, 0.06608281f, -0.11836655f, -0.04958924f, 0.14527228f, 
    -0.06252974f, -0.07025738f, 0.12325300f, 0.18942577f, -0.15922149f, -0.00138594f, -0.07590964f, 0.09678891f, 
    0.00334228f, 0.14847434f, 0.26880568f, 0.04913556f, 0.08627290f, -0.03858583f, 0.04935911f, -0.17397131f, 
    0.06954367f, 0.04321882f, 0.15197161f, -0.15161754f, -0.21631332f, 0.14703281f, 0.00107812f, -0.05334466f, 
    0.03152313f, -0.19227470f, 0.01746705f, -0.02414124f, -0.22950536f, 0.05821156f, -0.10217371f, -0.14845334f, 
    -0.00143951f, -0.08757685f, -0.13354577f, 0.02010923f, 0.08873703f, -0.02590777f, -0.14388499f, 0.07824858f, 
    -0.06326114f, 0.21659608f, -0.08132158f, -0.11252175f, -0.09178594f, 0.12506755f, 0.02377023f, 0.03623847f, 
    -0.21885723f, 0.00467471f, -0.03108344f, 0.10618439f, 0.06899460f, 0.04448278f, 0.01870864f, 0.10627429f, 
    0.11153578f, -0.00141320f, -0.07299129f, -0.06576055f, 0.00817088f, 0.02742579f, 0.00347475f, -0.11148702f, 
    -0.06784304f, 0.11965754f, 0.18352139f, -0.14328669f, 0.08636901f, -0.09464563f, 0.05393060f, 0.08073756f, 
    0.12556252f, 0.08711211f, 0.05580899f, 0.17337848f, -0.14243965f, -0.16371344f, 0.02522966f, -0.06639364f, 
    -0.10559018f, 0.14865342f, -0.03626576f, -0.05254740f, -0.09335796f, -0.08157634f, -0.02717963f, 0.03350599f, 
    -0.01725187f, 0.03546516f, -0.07874791f, 0.00700625f, -0.06256728f, -0.28773350f, 0.07174218f, -0.05901750f, 
    0.24067605f, -0.03448921f, 0.02788568f, -0.02748647f, 0.20579495f, -0.05504157f, -0.05365603f, 0.01817487f, 
    0.00139291f, 0.08303238f, 0.13946061f, 0.22940756f, 0.08196699f, 0.05371101f, -0.07689270f, 0.10358480f, 
    0.00546644f, 0.03586336f, -0.03558640f, -0.06816559f, 0.07954367f, 0.03893358f, -0.07254501f, 0.10140344f, 
    -0.03379878f, -0.02279624f, -0.17021482f, 0.08861814f, -0.18273844f, 0.00309927f, 0.02789593f, 0.03689228f, 
    0.21348387f, -0.02068362f, 0.06948362f, 0.03315990f, -0.04644278f, 0.05404028f, 0.05093938f, -0.11579473f, 
    0.15481053f, 0.01959636f, -0.26669332f, 0.03341498f, -0.00395291f, 0.02129199f, 0.07191557f, 0.11455679f, 
    0.08294554f, -0.15526977f, 0.10106708f, 0.08771479f, 0.04842562f, -0.06575160f, 0.04988900f, 0.04241731f, 
    -0.13440816f, 0.01102800f, 0.06291470f, 0.05382681f, -0.15344320f, 0.14672945f, -0.12049965f, 0.04121745f, 
    0.08325786f, -0.04872559f, 0.10327680f, 0.39125043f, -0.37612382f, -0.10831308f, 0.03616042f, -0.07212748f, 
    0.03098644f, 0.05548930f, 0.15581267f, -0.06349173f, -0.07074586f, 0.08653352f, 0.10278556f, -0.01694788f, 
    -0.03544747f, 0.02646601f, 0.05764343f, 0.00819215f, 0.00225989f, 0.18531165f, -0.05332114f, 0.03132504f, 
    0.13038997f, -0.03681061f, 0.14406145f, -0.12448969f, 0.07988934f, 0.04137101f, -0.02800283f, -0.17421840f, 
    -0.06151915f, -0.12362369f, 0.01695471f, -0.11685886f, 0.06764149f, -0.19120039f, 0.04689768f, -0.25340006f, 
    0.02812587f, -0.06013837f, -0.02753127f, 0.14383878f, -0.06439793f, -0.00872231f, 0.03740024f, 0.28660625f, 
    -0.13064437f, 0.11713311f, 0.19522670f, -0.04832577f, 0.14129935f, 0.00995024f, -0.11192588f, 0.06041340f, 
    0.02172463f, 0.09578256f, 0.02418204f, 0.12275077f, 0.07170533f, 0.06694383f, 0.09392279f, -0.18106762f, 
    0.12596311f, -0.04209347f, 0.15013123f, -0.10173616f, -0.18362062f, -0.04201177f, -0.15265019f, 0.04828334f, 
    0.19930267f, 0.07056566f, -0.01229009f, -0.13502406f, -0.07271349f, 0.14793451f, -0.08303192f, 0.05997841f, 
    0.15715581f, 0.16030553f, -0.02012394f, 0.02837951f, 0.15179943f, -0.06825595f, 0.21013629f, -0.01955844f, 
    0.01124908f, -0.05582669f, 0.03473753f, 0.12091835f, 0.09821686f, -0.09575342f, 0.21710926f, 0.22895758f, 
    0.15561420f, -0.11278927f, -0.00610292f, 0.04619602f, -0.10034920f, 0.04287078f, -0.44737065f, -0.09763519f, 
    0.13148637f, -0.02862807f, 0.13420473f, -0.43761769f, -0.16414104f, 0.01975873f, 0.08616155f, 0.06691273f, 
    -0.10118122f, 0.12716992f, 0.01140359f, -0.01837249f, 0.13016112f, -0.03021781f, 0.13071489f, 0.08209250f, 
    0.06524587f, -0.08130087f, 0.02153723f, 0.11823663f, 0.12853312f, -0.08480617f, -0.01185344f, 0.11798996f, 
    0.18838121f, -0.05756375f, -0.22039352f, 0.26806527f, 0.08467545f, -0.02205814f, -0.03859563f, 0.02833782f, 
    0.09708762f, -0.06785507f, -0.18776557f, 0.05116675f, 0.28143865f, -0.11430499f, 0.01899164f, -0.05360799f, 
    -0.06582779f, 0.08066968f, 0.09274305f, -0.02774042f, -0.02444227f, 0.19776970f, -0.00827006f, 0.03878422f, 
    0.00880353f, 0.00387163f, 0.05540049f, 0.09055319f, 0.14039533f, 0.01237171f, 0.01726085f, 0.08176272f, 
    -0.12646732f, -0.11138578f, 0.02008753f, -0.09872210f, -0.03637052f, -0.06322108f, -0.38685042f, -0.16617401f, 
    0.07533345f, -0.04383647f, 0.01451174f, 0.02945463f, 0.02487471f, -0.04960612f, -0.10520028f, 0.13151698f, 
    -0.17743818f, 0.06836584f, 0.02868707f, -0.02290472f, -0.05811984f, 0.09226490f, -0.03483032f, 0.00660938f, 
    0.02449254f, -0.02511824f, -0.04498439f, -0.00326671f, -0.07043742f, -0.13154337f, -0.01547207f, -0.09649837f, 
    0.03063023f, -0.10127566f, 0.26165885f, -0.06754372f, 0.09138684f, 0.03911677f, -0.03467188f, 0.04589672f, 
    -0.00663298f, -0.03392719f, -0.14821237f, 0.13348889f, 0.05293667f, -0.02981189f, -0.11091265f, 0.15092723f, 
    -0.06667449f, -0.01270371f, -0.14348084f, 0.03462414f, -0.09164451f, 0.05037762f, 0.04444259f, -0.01636840f, 
    0.13203259f, -0.03288794f, 0.14161004f, -0.10569775f, -0.23192778f, -0.03409239f, 0.01776452f, -0.04477356f, 
    -0.02490907f, 0.03735359f, 0.12878197f, -0.02514107f, 0.18738990f, 0.14280187f, 0.03350764f, 0.19283834f, 
    -0.15191594f, 0.02687927f, 0.04744847f, 0.03499624f, -0.06277581f, 0.17373610f, 0.09224982f, 0.02218790f, 
    0.00488397f, -0.00737809f, 0.03728143f, 0.05194181f, 0.00808052f, -0.00473583f, 0.09527372f, 0.03188409f, 
    0.23140500f, -0.00976689f, -0.03493010f, -0.04315370f, -0.07277227f, 0.00399152f, 0.03070942f, 0.01407605f, 
    -0.26979619f, -0.10615180f, -0.09288782f, -0.10476366f, 0.01834342f, -0.00799536f, 0.04114307f, 0.02759454f, 
    0.05749460f, -0.04244078f, -0.04228005f, 0.06062171f, 0.03737880f, -0.09451961f, 0.08785326f, -0.09305201f, 
    -0.00302631f, -0.17161654f, 0.13487884f, -0.00390740f, -0.12640488f, -0.08463234f, -0.01390307f, 0.01252151f, 
    0.10773071f, 0.07121196f, -0.11044177f, 0.19925734f, 0.00046915f, -0.13992979f, -0.10027832f, -0.06463248f, 
    -0.20012824f, 0.09912900f, -0.02832768f, 0.28041711f, 0.07079148f, -0.13337183f, 0.09701374f, 0.18725443f, 
    -0.09307740f, -0.00356337f, -0.18450163f, 0.00882651f, 0.02685430f, -0.15265611f, 0.04061769f, -0.03169110f, 
    -0.01720879f, -0.04306256f, 0.24846108f, 0.05268538f, -0.01600116f, -0.29869029f, -0.08016533f, -0.05961553f, 
    -0.14887343f, -0.06646572f, 0.11026748f, -0.02039153f, 0.02137457f, -0.09223235f, 0.02435758f, 0.04503119f, 
    -0.04582340f, 0.12799007f, -0.05103439f, -0.09985391f, -0.03981945f, 0.12099721f, -0.02357958f, -0.00267557f, 
    -0.18237479f, -0.08293040f, -0.06883036f, -0.12030683f, 0.03260370f, -0.03219620f, 0.33655220f, -0.08012979f, 
    0.23411323f, -0.06266636f, -0.10838132f, -0.26419899f, -0.15792985f, -0.23128937f, -0.18110877f, 0.01073243f, 
    0.15381524f, 0.17781930f, 0.18129808f, 0.12933852f, 0.05244066f, 0.02690076f, -0.00202177f, -0.15204918f, 
    0.13672149f, -0.02742741f, -0.24442604f, 0.16729307f, -0.12212659f, 0.11809311f, -0.06381489f, -0.18057303f, 
    0.12228408f, 0.16146484f, 0.09077527f, 0.26970866f, -0.02827522f, -0.11345322f, 0.21266335f, 0.14232972f, 
    0.05766368f, 0.17964901f, 0.10987970f, -0.16580355f, 0.10182356f, 0.23950435f, 0.03532099f, -0.09532218f, 
    0.10427307f, -0.12771216f, -0.13663079f, 0.04620852f, -0.21853296f, 0.02809904f, -0.08381166f, 0.17949709f, 
    -0.23942396f, -0.08294129f, 0.12067049f, 0.23635547f, 0.15377657f, 0.15344781f, 0.09886544f, 0.13933505f, 
    0.20536426f, -0.10579921f, -0.16588180f, 0.01200826f, 0.19517490f, -0.01679406f, 0.03537016f, 0.21183185f, 
    -0.05519515f, 0.10261516f, 0.08103625f, 0.01420264f, -0.07937820f, 0.10697367f, 0.13696550f, -0.06912790f, 
    0.16032214f, 0.14896943f, 0.00025967f, -0.17912307f, -0.06045669f, -0.17953701f, -0.05161840f, -0.08131461f, 
    0.21868682f, 0.00462394f, 0.08195324f, 0.11752160f, 0.12164853f, 0.07176786f, -0.06543116f, -0.02274562f, 
    -0.02624254f, 0.06644194f, 0.27150044f, -0.01835996f, -0.00189402f, -0.19047032f, 0.02617144f, 0.07383080f, 
    -0.31249484f, 0.04978034f, -0.05467447f, 0.22600882f, 0.15827934f, 0.12041976f, 0.16588213f, 0.01697141f, 
    0.08488649f, -0.10218854f, 0.00531355f, 0.08167018f, -0.03568701f, 0.11547634f, 0.03538495f, 0.01369532f, 
    0.15013231f, 0.08300986f, -0.03025797f, 0.37654176f, 0.01715740f, 0.06776095f, 0.05398375f, -0.12163407f, 
    0.07422768f, -0.02952003f, -0.15937908f, -0.26757821f, 0.09960552f, -0.00546566f, -0.22563557f, -0.29723394f, 
    -0.04589131f, -0.00883214f, 0.10156544f, -0.01180748f, -0.12708293f, -0.24336210f, -0.13877326f, -0.17489140f, 
    -0.11607832f, 0.00272506f, -0.09445386f, -0.04726116f, 0.00333708f, -0.02332159f, 0.02682321f, -0.26265040f, 
    0.19524240f, 0.06660912f, 0.04530438f, 0.21304542f, 0.04466232f, -0.20583569f, -0.19680086f, 0.06956552f, 
    -0.20041724f, 0.21415725f, 0.24155509f, 0.03538227f, 0.09421346f, 0.12491497f, 0.12660028f, -0.05833759f, 
    0.05967675f, 0.02400385f, 0.06974706f, -0.15456398f, -0.27521136f, -0.06082720f, 0.14139865f, -0.04286440f, 
    0.15954185f, -0.04396086f, 0.09908922f, -0.14859983f, 0.10240540f, -0.17488842f, 0.14525256f, 0.01763661f, 
    -0.00046517f, -0.05920632f, -0.00344480f, 0.07686878f, 0.25627431f, -0.03542317f, 0.02176250f, -0.16883107f, 
    -0.21958780f, -0.07402580f, 0.02859139f, 0.05337882f, 0.00574560f, 0.20934002f, -0.04056324f, 0.04434628f, 
    0.11185116f, 0.08778130f, 0.09986436f, 0.12164097f, -0.02341911f, 0.06875799f, -0.00037276f, -0.04406781f, 
    0.05866706f, 0.07949050f, 0.05538943f, -0.00447303f, -0.01758600f, -0.10213213f, -0.06376307f, 0.11602397f, 
    -0.12271035f, -0.12402143f, 0.00708670f, -0.20232327f, 0.20944107f, -0.20422791f, -0.14327204f, 0.12232235f, 
    -0.00821418f, 0.01860493f, -0.00753478f, -0.07437573f, -0.06660895f, -0.00377086f, 0.00560208f, -0.06570890f, 
    -0.02868519f, -0.03042857f, -0.01218243f, 0.02014025f, 0.02979951f, -0.00461208f, -0.06155676f, -0.01651316f, 
    0.01221038f, -0.05121901f, 0.06511970f, 0.01832478f, 0.01401876f, 0.03055733f, -0.02098080f, -0.00869033f, 
    -0.05347772f, 0.01386861f, 0.02066491f, -0.03010349f, -0.01647167f, -0.05558620f, -0.04310724f, -0.00224973f, 
    0.00547275f, -0.02633689f, -0.00292578f, -0.03965372f, -0.02694633f, -0.00177017f, 0.03191027f, 0.03159025f, 
    -0.05363380f, 0.00128727f, -0.01819571f, 0.00616238f, -0.07768452f, 0.00145829f, -0.01417956f, -0.02638269f, 
    -0.05852470f, 0.04208026f, -0.02487654f, -0.01080606f, 0.02418708f, 0.01278358f, -0.05604596f, -0.01322862f, 
    -0.05991035f, 0.02720908f, -0.05460887f, -0.01006797f, 0.03603058f, -0.00266466f, -0.05620454f, -0.02485774f, 
    0.02876228f, -0.01549477f, -0.00923045f, -0.08177331f, 0.02725800f, -0.01277896f, 0.00016171f, -0.03005892f, 
    0.01019448f, -0.00614492f, 0.02332391f, -0.01199404f, -0.04426012f, 0.03004915f, 0.00855003f, 0.01711255f, 
    -0.01448984f, -0.04734245f, -0.03383173f, -0.04075006f, -0.04016730f, 0.00174765f, 0.02905006f, -0.01976668f, 
    0.00261288f, 0.00033422f, -0.04628891f, -0.06703956f, 0.01432706f, -0.03530032f, -0.04069768f, -0.00615633f, 
    -0.02085705f, -0.01102789f, -0.02567986f, 0.01323419f, 0.00070372f, 0.03189911f, 0.01736534f, 0.00053339f, 
    0.02588692f, 0.01901027f, 0.03168723f, -0.06643330f, 0.02595675f, -0.01925907f, -0.00865274f, -0.03308843f, 
    0.03434679f, -0.03638981f, -0.01175542f, -0.05081196f, 0.00079179f, -0.04514996f, -0.06653300f, 0.00916740f, 
    -0.01913803f, -0.01660295f, -0.04342572f, -0.02732904f, -0.05419889f, 0.03159842f, -0.01600176f, 0.01929229f, 
    -0.01099414f, 0.02769792f, 0.02646168f, -0.08153866f, -0.05552896f, 0.01860143f, -0.07145283f, 0.01882721f, 
    -0.06799382f, -0.03141789f, -0.07609610f, -0.05220506f, -0.07297640f, -0.04176642f, -0.05013764f, -0.00227970f, 
    -0.07502819f, -0.07108511f, -0.04927747f, -0.07228049f, -0.00878882f, -0.00141819f, -0.03856080f, 0.01263180f, 
    -0.05766812f, -0.05556376f, -0.05853970f, -0.00788918f, -0.03477195f, -0.00649024f, -0.07651524f, 0.00440085f, 
    0.01448965f, -0.06321844f, -0.00973454f, -0.01175181f, -0.03477409f, 0.01931127f, -0.02363251f, -0.00483848f, 
    0.00922692f, -0.06245960f, 0.01410887f, -0.05428420f, -0.00153223f, -0.05026955f, -0.02604586f, -0.01499176f, 
    0.00728287f, 0.00447084f, -0.06259979f, 0.04277897f, 0.03095706f, -0.02219398f, 0.00416636f, 0.01339536f, 
    -0.04059954f, 0.01783898f, -0.02181087f, -0.04606687f, -0.04943152f, 0.02303408f, -0.01568411f, -0.02551485f, 
    0.03126255f, -0.03064733f, -0.01423845f, 0.03644915f, -0.01633049f, 0.01519218f, -0.07269587f, 0.02684542f, 
    0.00827851f, -0.03184877f, 0.00126657f, -0.06165959f, -0.05876451f, 0.02444960f, -0.03359421f, -0.04448490f, 
    0.04643924f, -0.03705378f, -0.04921445f, 0.02041741f, -0.01721384f, 0.01038409f, 0.01861435f, -0.06293191f, 
    -0.05442732f, 0.00497570f, 0.02782946f, -0.05229413f, -0.00358774f, -0.02033846f, -0.05755656f, -0.02592501f, 
    0.00073614f, -0.01109031f, -0.04600890f, -0.02175518f, 0.01644233f, -0.06793136f, 0.00416837f, -0.02645169f, 
    -0.02682867f, -0.01331485f, -0.00210206f, 0.00295731f, 0.01215590f, -0.04513225f, 0.00718367f, 0.00193538f, 
    -0.05052894f, -0.05604098f, -0.03767057f, 0.00252992f, 0.00999657f, 0.03477188f, 0.01552928f, 0.03193505f, 
    0.00853731f, 0.00668830f, -0.07643933f, -0.05990640f, -0.05307543f, 0.01146324f, -0.05440319f, -0.04314957f, 
    -0.04327238f, 0.03433474f, 0.03230739f, -0.06962417f, -0.02003929f, -0.03333153f, -0.05946289f, -0.06024798f, 
    0.01039579f, -0.01957767f, 0.00130997f, -0.06296145f, -0.01004254f, -0.01311613f, -0.07156875f, -0.00106466f, 
    0.01128032f, -0.03471465f, 0.04124095f, -0.05655896f, -0.05389057f, -0.05918490f, -0.05840765f, -0.04784926f, 
    0.02959018f, -0.03223183f, 0.01046071f, -0.00386715f, -0.03922912f, -0.06624760f, -0.05992987f, -0.04747301f, 
    -0.01538082f, -0.00786570f, -0.04159137f, -0.02034443f, -0.00965498f, 0.01143216f, 0.02944006f, 0.00444476f, 
    0.03615367f, -0.06607606f, -0.04146285f, 0.00584853f, 0.02164199f, 0.04417626f, -0.03893887f, 0.02499900f, 
    -0.00390704f, 0.02588727f, -0.02051436f, -0.00080823f, 0.03661369f, -0.02349576f, -0.02434237f, -0.03893971f, 
    -0.05970372f, -0.01524030f, -0.06120775f, 0.00614202f, -0.06477694f, -0.05127406f, 0.03525849f, 0.04258014f, 
    0.03022976f, -0.04484519f, -0.03354796f, 0.02089829f, 0.03153704f, 0.02074302f, -0.01881332f, -0.03859228f, 
    -0.06062925f, -0.03698090f, 0.04190946f, -0.05358598f, 0.03010306f, 0.02216381f, 0.02794823f, -0.04967760f, 
    0.05056621f, -0.02754131f, -0.02393793f, 0.04575504f, -0.00343828f, 0.02319038f, 0.01977412f, -0.04340073f, 
    -0.04275864f, 0.02209427f, -0.01658360f, -0.04652914f, 0.00615006f, 0.00742557f, 0.05837001f, -0.04135958f, 
    0.03954030f, -0.02215994f, -0.00506697f, -0.03132670f, -0.05503662f, -0.04839870f, -0.03752145f, 0.02648055f, 
    0.01885913f, -0.02041651f, -0.01148663f, -0.04120349f, -0.02884687f, 0.01813996f, -0.03832414f, -0.01054475f, 
    0.00843369f, 0.03466420f, -0.03859276f, 0.00987797f, 0.00826187f, -0.01182295f, 0.03881940f, -0.00561460f, 
    -0.00068714f, -0.07278430f, 0.02321030f, 0.02646293f, 0.04174799f, -0.03353601f, 0.03874550f, -0.02912157f, 
    0.05046873f, 0.03787852f, 0.04300335f, 0.00522749f, -0.01390629f, -0.04948872f, -0.03367737f, -0.04499764f, 
    -0.00171945f, -0.04052424f, -0.05164000f, 0.04381430f, -0.00667413f, 0.00517571f, -0.03180195f, -0.03049198f, 
    0.00655094f, -0.06147753f, 0.04922374f, -0.06446470f, -0.03200252f, 0.04818081f, 0.03908326f, 0.00426722f, 
    0.05239638f, -0.01014290f, 0.06838303f, -0.05454253f, -0.00976559f, -0.05567923f, 0.02345895f, -0.01062621f, 
    -0.05157889f, -0.03995710f, -0.05189011f, 0.02790933f, -0.03684312f, -0.00812153f, -0.01576461f, -0.04394849f, 
    0.03907646f, -0.04826511f, -0.02838377f, -0.03664085f, -0.00055522f, -0.06128736f, -0.04940123f, -0.05558357f, 
    -0.03910208f, 0.00560092f, -0.02858952f, 0.01445797f, -0.02022623f, 0.01310167f, -0.06271720f, -0.00920396f, 
    -0.00836267f, 0.02402271f, 0.06249719f, 0.00181077f, -0.05406129f, -0.02351863f, -0.07060118f, -0.00193855f, 
    0.03566119f, 0.02605007f, 0.05139688f, 0.03797121f, 0.00211747f, -0.00274921f, 0.02242184f, -0.03707680f, 
    -0.04558429f, 0.03653206f, 0.00920278f, 0.02666575f, -0.04825343f, 0.01538712f, -0.06245045f, 0.02844684f, 
    -0.00285930f, -0.04206500f, 0.02961317f, 0.01321955f, -0.03406781f, -0.06330062f, -0.03223916f, -0.00326820f, 
    0.00840592f, -0.01157287f, 0.04914747f, -0.01630626f, -0.07368126f, -0.05330024f, -0.01982903f, -0.05442281f, 
    0.01108942f, 0.05135269f, -0.05568968f, -0.00005391f, 0.05621835f, 0.04366518f, -0.00725288f, 0.01724087f, 
    -0.02494084f, -0.06263333f, -0.02140770f, -0.00208489f, -0.00048514f, 0.01305381f, -0.03939695f, -0.04869259f, 
    0.02932929f, 0.05086006f, 0.00747392f, 0.02083211f, 0.04079866f, -0.03384968f, -0.04125993f, -0.02964037f, 
    0.02177626f, 0.00501105f, -0.02342978f, 0.03560919f, -0.05358846f, 0.03083237f, -0.05380406f, -0.04981526f, 
    -0.05728600f, 0.01538026f, 0.00904642f, 0.03107536f, -0.01946929f, 0.01902757f, 0.02905041f, 0.04699948f, 
    0.01936822f, -0.04802379f, -0.00871812f, -0.02359908f, -0.04731892f, -0.05493126f, -0.03610077f, 0.04300041f, 
    0.06062539f, -0.01151846f, -0.04185351f, -0.06023791f, -0.01888054f, -0.03031690f, 0.00396875f, 0.03539644f, 
    0.02304799f, 0.02396145f, -0.05385587f, 0.00373591f, -0.03275598f, 0.03229878f, -0.02624604f, 0.01784161f, 
    0.02194489f, 0.02675048f, -0.05728843f, 0.04504771f, -0.01187132f, -0.01773425f, -0.01608056f, -0.03621092f, 
    -0.01689633f, 0.02184470f, -0.05969371f, 0.06123043f, -0.02266076f, 0.01694798f, 0.05143833f, -0.00978966f, 
    -0.03414451f, 0.05214603f, 0.02356722f, 0.00981617f, 0.03325135f, 0.02632408f, -0.03487317f, 0.01696494f, 
    0.00865999f, -0.03479939f, -0.04590676f, 0.02231365f, -0.02152416f, 0.04588931f, 0.03149985f, -0.02659626f, 
    -0.00441073f, -0.00854454f, -0.04294663f, 0.03669424f, 0.01503312f, -0.05432146f, 0.03010197f, -0.03435754f, 
    -0.03638283f, 0.04975923f, -0.02389687f, 0.04454695f, 0.03850247f, -0.05207099f, 0.01126447f, 0.05113846f, 
    0.02494999f, 0.05096535f, 0.03674068f, 0.02384349f, -0.03633291f, -0.06209940f, 0.00131677f, -0.04203673f, 
    0.00102300f, 0.00922407f, 0.03426741f, -0.04926756f, 0.01674700f, 0.02681112f, -0.02921096f, 0.03694962f, 
    0.02691990f, 0.01688331f, 0.02060856f, -0.01902015f, 0.02270514f, -0.01700711f, 0.00155749f, -0.05908936f, 
    0.04217461f, -0.01334685f, -0.01524191f, -0.05588779f, -0.06331199f, -0.02626466f, 0.01143774f, -0.02721872f, 
    -0.00926256f, -0.03708899f, -0.05284446f, 0.00769374f, -0.05070060f, -0.03570383f, -0.05998680f, 0.04517624f, 
    -0.03486877f, -0.00266600f, 0.01332470f, -0.01373143f, -0.04628344f, -0.05569144f, -0.01948472f, -0.02969932f, 
    0.03059160f, 0.01230171f, 0.03773054f, -0.04990339f, 0.02175224f, -0.05584012f, 0.01657902f, 0.02820633f, 
    0.01008087f, 0.04576885f, -0.01811482f, -0.02945433f, 0.03778404f, 0.00644614f, -0.01221623f, 0.03023113f, 
    0.04517733f, 0.02666822f, -0.01971406f, -0.03429022f, -0.04834266f, -0.04946781f, 0.01097910f, 0.01496830f, 
    -0.01209938f, -0.06145320f, 0.01486058f, -0.04081109f, 0.01103254f, -0.03778196f, -0.04259055f, 0.01596335f, 
    -0.03968137f, -0.03941755f, -0.02735693f, 0.04751546f, 0.02173834f, 0.01747770f, -0.03555520f, -0.05922773f, 
    -0.01092027f, -0.04560943f, 0.03334447f, -0.04655797f, 0.04836434f, 0.01719874f, 0.00246474f, -0.01450445f, 
    0.00612160f, -0.02873495f, -0.03007349f, -0.00694078f, 0.04092411f, 0.02610251f, 0.00485683f, -0.04495735f, 
    0.03267816f, -0.03923394f, 0.04588778f, -0.00867561f, -0.03705800f, -0.00013972f, 0.02808264f, -0.02146302f, 
    -0.00953760f, -0.06359037f, -0.02330725f, 0.00945274f, -0.02532205f, 0.02629968f, 0.01928673f, -0.02572626f, 
    0.01596246f, -0.02598800f, -0.01278356f, 0.04762444f, 0.00837961f, -0.00874173f, -0.03482273f, -0.04105812f, 
    0.05108584f, -0.06098047f, -0.01009766f, -0.05931607f, -0.06179487f, 0.03191974f, -0.04235879f, 0.02955238f, 
    0.02614701f, 0.04992179f, 0.04859291f, 0.03055209f, -0.04495400f, -0.04068219f, -0.03711235f, 0.02884720f, 
    -0.06407797f, 0.04712063f, 0.01058206f, -0.02373777f, -0.05317007f, 0.02223733f, 0.04708812f, 0.02911509f, 
    -0.06059620f, -0.04196964f, -0.02508106f, -0.05658289f, 0.00077048f, -0.04454508f, 0.02528795f, 0.03972046f, 
    0.03830273f, 0.00321887f, 0.03433643f, 0.02513384f, 0.02551639f, -0.05344277f, -0.00024798f, -0.04277311f, 
    0.04880600f, -0.00728574f, -0.02970913f, 0.02171175f, -0.06405758f, -0.03859571f, -0.06119901f, -0.03823343f, 
    0.00908609f, 0.03699499f, -0.03305510f, 0.03776110f, 0.00413374f, -0.03575682f, -0.02540812f, 0.01275062f, 
    -0.02142589f, -0.03530759f, 0.01878824f, -0.03940177f, -0.05083110f, 0.03246346f, -0.04946025f, 0.02681300f, 
    -0.06377102f, 0.00320005f, -0.06215587f, -0.00266935f, -0.04690741f, -0.01338208f, -0.04531697f, 0.05261972f, 
    0.01761266f, 0.03034315f, -0.01220405f, -0.00198221f, 0.00379006f, 0.02063286f, -0.05590583f, -0.00355389f, 
    -0.03897487f, -0.04603311f, -0.03838366f, -0.05628001f, 0.02006557f, -0.00833633f, -0.03805900f, 0.04146595f, 
    -0.00031512f, -0.03577171f, 0.03620577f, -0.02406534f, 0.01288368f, -0.00542045f, -0.01826566f, -0.01511151f, 
    0.03539694f, 0.01095077f, 0.01075662f, 0.02447885f, -0.04541745f, -0.06779494f, 0.02575998f, -0.04071219f, 
    -0.04680265f, -0.04162321f, 0.04028174f, -0.00010820f, -0.06391586f, 0.00764587f, -0.00698139f, -0.01176333f, 
    0.02436076f, 0.00235430f, 0.04988878f, 0.03450917f, -0.04002922f, 0.01638580f, 0.01637471f, -0.04517343f, 
    -0.02538812f, -0.03626369f, 0.02490842f, 0.03482721f, 0.04508639f, 0.01443125f, 0.00780589f, -0.06036758f, 
    -0.06386557f, -0.01058560f, 0.00290466f, -0.05859126f, -0.03153001f, -0.02140351f, 0.00970609f, 0.03421154f, 
    0.03213025f, -0.00674843f, -0.00270760f, 0.00823026f, 0.00561863f, 0.02445405f, 0.00723001f, 0.00521134f, 
    0.06428518f, -0.21015380f, 0.11861785f, 0.00104802f, -0.17427902f, 0.09967989f, -0.01411040f, -0.03370583f, 
    0.15179068f, -0.02718129f, -0.25543645f, 0.09334683f, 0.03831399f, 0.19673778f, 0.05791815f, 0.00680735f, 
    -0.04972124f, 0.06174800f, -0.09894859f, 0.04945857f, -0.10198253f, 0.21412466f, 0.02680090f, -0.10585567f, 
    -0.33660904f, -0.06971773f, -0.10520207f, -0.24248180f, 0.01391279f, 0.26767069f, -0.14732710f, -0.11435267f, 
    -0.09541383f, -0.11750931f, -0.07392851f, 0.08477742f, -0.07450479f, -0.10754586f, -0.00089767f, 0.16251042f, 
    -0.05479923f, 0.10858914f, 0.12042560f, -0.02219897f, 0.06030926f, -0.00201634f, 0.03532101f, -0.20075168f, 
    0.10537229f, 0.00104820f, -0.02838244f, 0.03913883f, -0.05263756f, -0.14179797f, -0.07247107f, -0.01900280f, 
    0.03317433f, 0.04079876f, 0.11171971f, -0.17359561f, -0.00193602f, -0.04113973f, 0.17366323f, -0.27419853f, 
    -0.04412786f, 0.04425709f, 0.12767245f, -0.21852610f, -0.01746949f, 0.12521975f, 0.01453301f, 0.04505223f, 
    -0.16405550f, -0.01748168f, 0.04995127f, 0.11594258f, -0.10638665f, 0.07398234f, -0.13090937f, 0.03628284f, 
    0.11273995f, -0.01060130f, 0.00410471f, -0.01711407f, 0.06251964f, 0.06595425f, 0.06870999f, 0.14100467f, 
    0.11641544f, 0.03619206f, -0.32936364f, 0.08903997f, 0.14542775f, -0.06392328f, 0.03613750f, -0.07942585f, 
    0.04539654f, 0.13855737f, 0.02447228f, 0.16123571f, 0.21283360f, -0.00740940f, -0.13212675f, -0.12099893f, 
    -0.20300464f, 0.09747260f, 0.12141443f, -0.02622648f, -0.08580852f, -0.12332916f, 0.04114276f, 0.02648807f, 
    0.08032545f, 0.08889651f, 0.10771431f, 0.04276712f, -0.11561894f, 0.04910408f, -0.06155233f, 0.11674375f, 
    0.15590176f, 0.13030146f, 0.18018341f, -0.13557187f, -0.12644911f, 0.01236288f, 0.06502416f, -0.21227872f, 
    0.10720523f, 0.09123656f, 0.06888147f, -0.02520867f, 0.03476011f, -0.35950860f, 0.04347049f, 0.04543835f, 
    -0.01315964f, 0.23007658f, -0.08988521f, 0.11501521f, -0.20459695f, 0.11542437f, 0.18510267f, -0.00621107f, 
    -0.18626983f, 0.10273455f, 0.06063788f, 0.26482379f, -0.15050843f, -0.13390388f, -0.23542385f, -0.06394892f, 
    0.05798387f, 0.08224353f, -0.01521711f, 0.04138873f, -0.04839066f, 0.04472509f, -0.07359257f, -0.06223152f, 
    0.04810676f, 0.04207797f, -0.10813013f, 0.08229518f, 0.13948841f, 0.18814033f, 0.18626580f, 0.16679174f, 
    -0.00701199f, -0.22870488f, -0.08574726f, -0.02330217f, 0.13410498f, 0.01693753f, -0.00327445f, 0.09433064f, 
    0.15026045f, 0.07170048f, 0.03187947f, -0.00974562f, -0.03483606f, 0.09470981f, -0.09740560f, 0.10562691f, 
    0.11923712f, 0.22320557f, -0.05909973f, 0.01717945f, -0.13562901f, 0.04064121f, 0.04317367f, -0.26451650f, 
    -0.11760424f, 0.05740904f, 0.01249591f, -0.02279379f, 0.12071908f, 0.08972962f, 0.19990483f, -0.11498310f, 
    -0.09946437f, -0.08722238f, -0.02113834f, 0.09468859f, 0.13661966f, -0.14847746f, -0.18736587f, 0.01959343f, 
    -0.03755287f, -0.14667784f, 0.01703955f, 0.29194206f, 0.09874266f, 0.04966239f, -0.13806118f, 0.00145795f, 
    -0.10327362f, -0.19641428f, 0.00464740f, 0.06085755f, 0.11124732f, -0.13753231f, -0.13579847f, 0.18483183f, 
    0.29126620f, -0.11608585f, -0.11642990f, -0.08123477f, -0.01940866f, 0.08157011f, 0.00389858f, -0.07322381f, 
    -0.05725837f, 0.15955931f, 0.03460745f, -0.01409152f, 0.02566641f, 0.00463219f, -0.16468617f, 0.03915904f, 
    0.05030083f, 0.19874969f, -0.08664916f, -0.35272741f, -0.25165299f, 0.11657345f, -0.02058315f, -0.05670119f, 
    -0.03259095f, -0.06036729f, -0.12804754f, 0.03080760f, -0.23792988f, -0.18759049f, -0.02052903f, -0.00994195f, 
    -0.09828753f, 0.05548385f, -0.18756540f, 0.11114245f, -0.17138089f, 0.15250544f, 0.13400672f, 0.02372890f, 
    0.00719855f, -0.08312906f, 0.00411017f, 0.23334809f, 0.03378877f, 0.00997520f, 0.04643534f, -0.08476154f, 
    0.00837550f, 0.06290296f, 0.03474199f, 0.08579928f, 0.12476633f, 0.00727640f, -0.15814194f, 0.07024948f, 
    -0.13213697f, -0.22997668f, 0.05655591f, -0.03725976f, 0.16325133f, 0.00671194f, -0.08537066f, -0.07133334f, 
    -0.05523504f, 0.16675098f, -0.04397177f, -0.01938491f, 0.04369571f, 0.05817201f, -0.09824343f, 0.03374939f, 
    0.09897461f, 0.04669641f, 0.24907428f, 0.01778975f, 0.07729346f, 0.10797752f, 0.07587047f, -0.07533957f, 
    0.00419754f, -0.00947517f, 0.00840650f, -0.33342391f, -0.15670788f, 0.05218128f, 0.14182921f, -0.16050613f, 
    0.06124594f, -0.03063898f, 0.06650666f, -0.00570410f, -0.36301628f, -0.31310150f, 0.06689326f, -0.01998277f, 
    -0.04021537f, -0.21570499f, -0.08062457f, -0.01492932f, 0.12195432f, 0.13637052f, -0.05909074f, -0.02181564f, 
    0.07466336f, 0.07139210f, -0.04046135f, -0.05912193f, -0.07608852f, -0.35415807f, -0.24159318f, -0.19360866f, 
    0.17721914f, 0.13485509f, 0.02863150f, -0.00920143f, 0.02094689f, -0.06910013f, 0.07802086f, -0.06047932f, 
    -0.04281899f, 0.10357895f, 0.06475876f, 0.05063691f, 0.02721757f, -0.06988467f, 0.15542990f, -0.01616465f, 
    -0.08564189f, 0.07514081f, 0.03152607f, 0.08029629f, 0.17240615f, 0.00390226f, 0.19206819f, 0.22303921f, 
    -0.05902494f, -0.11001286f, 0.11576040f, 0.04436620f, 0.12570414f, -0.12946010f, 0.19599412f, 0.01692617f, 
    0.06242153f, -0.26237467f, -0.14792530f, -0.01965551f, 0.13567816f, 0.01440082f, -0.07095750f, 0.03537969f, 
    -0.14115281f, -0.13115479f, 0.10251807f, 0.07330415f, -0.14537546f, 0.05262788f, -0.16502866f, -0.11541943f, 
    -0.03378924f, 0.03248071f, 0.17290296f, -0.01085978f, 0.00065148f, 0.08178929f, -0.00303331f, -0.08618480f, 
    0.04606730f, -0.10981885f, -0.08457577f, 0.03495163f, -0.22927794f, -0.00766559f, 0.15673712f, 0.20284362f, 
    0.08261815f, 0.00297160f, -0.00000511f, -0.01401022f, -0.09291890f, -0.23223336f, -0.23679410f, -0.00984426f, 
    0.15767170f, 0.09666720f, 0.14984034f, -0.03629452f, -0.09447518f, 0.05506995f, -0.06354134f, -0.02606627f, 
    -0.03022953f, 0.13510251f, 0.09316446f, 0.00341391f, 0.04829922f, -0.00953400f, 0.08974267f, -0.16211559f, 
    0.06665452f, -0.03260440f, 0.01543374f, -0.22200611f, 0.01763948f, -0.04662939f, 0.09149558f, -0.06220303f, 
    0.05745180f, 0.07888281f, 0.13888723f, -0.06647704f, 0.04913953f, 0.03751878f, 0.02380944f, 0.01247847f, 
    0.05049087f, -0.42479640f, -0.06658917f, -0.05173012f, 0.02464542f, -0.02294414f, -0.01677682f, -0.14907372f, 
    0.02621162f, -0.07584390f, 0.37236780f, 0.05066863f, 0.05865685f, 0.00811252f, -0.06492989f, 0.00452361f, 
    0.21543865f, -0.02430669f, -0.01701899f, -0.54536313f, -0.47449857f, 0.21073014f, 0.00110808f, 0.08918059f, 
    -0.00316027f, -0.06734383f, -0.08074038f, -0.01194827f, -0.16555913f, -0.04766032f, -0.26599106f, -0.03427547f, 
    0.02921174f, -0.08969505f, -0.03099874f, -0.01390228f, 0.08608689f, 0.17986837f, 0.05304586f, 0.11302061f, 
    -0.04337451f, -0.05548766f, -0.10811228f, -0.03530900f, -0.06011394f, 0.07034305f, 0.07836135f, 0.06244311f, 
    -0.09427476f, -0.03913440f, 0.05576131f, 0.05592589f, 0.10160819f, -0.04448918f, 0.16116656f, -0.17689371f, 
    0.04453560f, -0.39928299f, 0.13249882f, 0.05396729f, 0.11038943f, 0.01102590f, 0.04537810f, 0.00699233f, 
    -0.38399863f, -0.04754427f, 0.17820868f, -0.00596213f, -0.18298322f, 0.15125628f, -0.02611105f, 0.03404364f, 
    0.04276445f, 0.18032953f, -0.07727747f, 0.23541404f, -0.03280362f, -0.08448567f, -0.00568848f, -0.04464964f, 
    0.10110178f, 0.04285548f, 0.18779948f, -0.06196041f, -0.20860855f, 0.02805354f, -0.10068665f, -0.13371314f, 
    0.05346787f, 0.00483172f, 0.00728196f, 0.00331905f, 0.33408657f, -0.34506309f, -0.06573048f, 0.09709040f, 
    -0.28956309f, -0.07228098f, -0.07593090f, 0.04313957f, 0.12581617f, 0.12093655f, 0.18027472f, -0.01858795f, 
    -0.05339058f, 0.02186425f, 0.08595703f, 0.07922922f, -0.03568828f, -0.18124133f, -0.20869726f, 0.10068750f, 
    -0.20434733f, -0.03060000f, 0.08938525f, -0.06438168f, -0.03982682f, 0.05739563f, -0.18662545f, -0.13165873f, 
    0.03140186f, 0.03089999f, 0.09856289f, 0.14549482f, 0.01416600f, -0.06027409f, 0.05571605f, -0.02911790f, 
    0.30253899f, -0.13930897f, 0.07544743f, -0.01098689f, -0.17972188f, 0.08237801f, -0.06414369f, -0.10378011f, 
    -0.13916391f, -0.17945158f, 0.07088923f, -0.01117398f, 0.07076117f, -0.00906988f, -0.00914302f, 0.22275451f, 
    -0.14415278f, 0.02275818f, -0.01140102f, -0.00970568f, -0.04834263f, -0.04082850f, 0.17491169f, 0.14601319f, 
    0.12222595f, -0.06959569f, 0.12896384f, -0.15624228f, 0.18574072f, 0.02429178f, -0.10072698f, -0.02801635f, 
    -0.02670782f, 0.05591091f, -0.02710203f, 0.17485987f, -0.04316049f, -0.00719427f, -0.08920616f, 0.04691673f, 
    0.00440091f, 0.10338339f, -0.17208540f, -0.30756944f, -0.21254532f, 0.03398818f, 0.08550902f, -0.05482933f, 
    -0.05900861f, 0.12904000f, -0.09472510f, -0.13947508f, -0.05231294f, 0.30017760f, -0.03621070f, 0.06778952f, 
    0.02805464f, 0.03084863f, -0.00008210f, 0.12950429f, -0.00011144f, -0.11349667f, 0.14156547f, 0.08419256f, 
    -0.01258531f, 0.11183857f, 0.12794884f, 0.03968049f, -0.06336166f, 0.10554218f, -0.27840579f, -0.23894887f, 
    -0.00028194f, -0.13903098f, 0.07551606f, -0.08658911f, 0.21386637f, 0.10061494f, -0.30783057f, -0.13976452f, 
    -0.35340264f, 0.04296901f, 0.06984863f, -0.07636040f, 0.11693050f, 0.08407819f, 0.19834825f, -0.10827596f, 
    0.05654075f, 0.05560435f, -0.14730532f, 0.08452080f, -0.21240243f, 0.09274837f, 0.19577967f, 0.04896038f, 
    -0.10174009f, 0.33967933f, 0.23263831f, -0.01051791f, 0.07832298f, -0.12409415f, 0.13324830f, 0.19520280f, 
    -0.07034310f, -0.14265330f, -0.22735652f, -0.02549007f, -0.17763622f, -0.01727238f, -0.09873360f, 0.03770788f, 
    -0.02631493f, 0.09685842f, 0.14714468f, -0.01104499f, 0.07600511f, -0.07374416f, 0.05429723f, 0.01306049f, 
    0.08059678f, -0.02245775f, -0.01355101f, 0.06932427f, 0.17052627f, 0.05223681f, -0.08345325f, 0.01621194f, 
    -0.09058814f, 0.03825128f, -0.04911203f, 0.16836102f, -0.10651028f, 0.05244938f, -0.18298660f, 0.04468166f, 
    -0.13428774f, 0.02094033f, 0.19688016f, 0.04582304f, 0.10761626f, 0.11332319f, -0.04529314f, 0.03574474f, 
    0.07519587f, -0.09528173f, -0.13849783f, -0.01071681f, 0.08319299f, 0.12597966f, 0.11735194f, 0.10393555f, 
    -0.28762475f, -0.01759689f, 0.04105029f, 0.00216417f, 0.02949605f, 0.05502552f, 0.08648786f, -0.06812852f, 
    0.04688868f, 0.15724437f, -0.06836011f, -0.10834356f, -0.06169217f, 0.08913887f, -0.15074307f, -0.00292628f, 
    0.04627050f, 0.20015357f, 0.11323114f, 0.00298993f, 0.00247719f, -0.00297124f, -0.04026630f, 0.09197485f, 
    0.08728991f, 0.10271539f, 0.03785656f, 0.27135652f, 0.00722212f, 0.04146801f, -0.10736644f, -0.20739666f, 
    -0.01974394f, 0.22768085f, 0.17164764f, 0.27410448f, 0.05109102f, 0.31328443f, -0.21415401f, 0.03558058f, 
    0.04384789f, 0.03628037f, -0.22420260f, -0.01437166f, -0.01526858f, 0.05768393f, 0.11712164f, -0.18366188f, 
    0.00974921f, 0.02377624f, 0.04203583f, 0.08126916f, -0.08650038f, -0.16410446f, 0.17057456f, 0.17604980f, 
    -0.07112305f, -0.05241583f, -0.08303460f, 0.07917413f, 0.01144349f, -0.09837440f, 0.02209514f, -0.04173572f, 
    0.21226190f, 0.08339202f, 0.09828032f, -0.00405799f, -0.18446282f, -0.02871428f, 0.11854687f, 0.00440680f, 
    0.05536511f, -0.03159027f, 0.14396049f, 0.04962355f, 0.01372978f, -0.03679655f, 0.02714736f, -0.11204084f, 
    -0.01855353f, 0.18424194f, -0.09619326f, 0.06412131f, -0.10562238f, -0.08486352f, -0.05697670f, 0.03075541f, 
    0.02154636f, 0.00780103f, -0.07236195f, 0.31318754f, -0.01248486f, -0.04490391f, -0.03737196f, 0.16858481f, 
    0.04169132f, -0.01450655f, 0.05415832f, 0.15589178f, -0.11924197f, -0.02279940f, 0.01597111f, 0.08198865f, 
    0.06115861f, 0.22538371f, -0.06247619f, -0.10801816f, -0.37179330f, 0.00916015f, 0.06947522f, 0.17179109f, 
    -0.12032118f, 0.11055249f, -0.05222123f, 0.08718259f, -0.05886522f, 0.45780864f, 0.02358507f, -0.04918812f, 
    -0.10590715f, 0.11698844f, -0.15208617f, 0.15448229f, 0.04911128f, 0.03292152f, 0.05678375f, 0.09075601f, 
    0.10350900f, 0.18943328f, 0.01926287f, -0.02604569f, 0.19349855f, -0.05748907f, 0.21076742f, -0.05356843f, 
    0.02707201f, 0.08358945f, 0.20687985f, 0.05296082f, -0.10826545f, 0.07948766f, 0.00645772f, -0.19726805f, 
    -0.11225172f, 0.13260514f, -0.15420111f, -0.03130763f, 0.00756035f, -0.01641186f, 0.09379764f, 0.05644338f, 
    0.01839924f, -0.18723387f, 0.07178523f, 0.30045062f, 0.16646689f, 0.05469406f, -0.02717255f, 0.03435296f, 
    -0.05080292f, -0.01330696f, -0.00068108f, -0.03144424f, 0.00153813f, 0.02969420f, 0.10910986f, 0.02207148f, 
    0.12016428f, 0.07996139f, 0.26749757f, 0.08662900f, -0.14281447f, -0.19442172f, 0.02462330f, -0.10546742f, 
    -0.01061069f, 0.05476502f, -0.12309480f, -0.02808032f, 0.23951299f, 0.03433950f, 0.09252973f, -0.10680938f, 
    0.00686155f, -0.12342513f, 0.09219243f, -0.04679154f, -0.03117986f, 0.02864485f, -0.09972663f, -0.02868902f, 
    0.01279384f, 0.07127038f, 0.01414611f, 0.07405712f, 0.08304040f, -0.01384013f, 0.24972002f, -0.02061825f, 
    -0.14225365f, -0.09185757f, 0.01042935f, 0.01373901f, 0.15132232f, -0.08244731f, 0.04557851f, -0.17834279f, 
    0.05143091f, 0.22664775f, -0.16215657f, 0.03084675f, 0.20417680f, -0.07319167f, -0.08402141f, 0.06860458f, 
    0.06153380f, -0.08099331f, 0.18210377f, 0.05880597f, 0.08186263f, 0.05658310f, 0.04341642f, 0.12286727f, 
    0.05712917f, -0.29187438f, 0.01364635f, 0.07909860f, -0.01288293f, 0.01710844f, -0.02858398f, 0.04774341f, 
    0.02942701f, -0.06184161f, 0.10140510f, -0.37288696f, -0.10869467f, -0.02258363f, 0.10462662f, 0.00039743f, 
    -0.19083743f, 0.02659457f, -0.04451830f, -0.23476890f, -0.05887710f, 0.01873552f, 0.14379232f, -0.01866047f, 
    -0.07849319f, 0.12944603f, -0.01684332f, -0.07696701f, -0.15428716f, 0.00788664f, -0.10056096f, 0.13322507f, 
    0.13648744f, -0.18986575f, -0.01690708f, -0.06206369f, -0.06820530f, 0.17990765f, -0.01306727f, 0.19508946f, 
    -0.08756260f, -0.04452644f, -0.01862324f, -0.10327404f, 0.10957362f, 0.14155927f, -0.06181977f, -0.04642903f, 
    0.17146501f, -0.07790108f, -0.08460192f, 0.09800330f, -0.12638918f, -0.05299702f, 0.15104407f, -0.04677070f, 
    -0.05150875f, -0.25615126f, 0.08696897f, -0.00903540f, -0.03751932f, -0.06262653f, 0.08494823f, -0.18060234f, 
    0.28603828f, -0.05426043f, 0.16224502f, 0.10744487f, 0.00655063f, 0.25791159f, 0.05887984f, 0.02266200f, 
    -0.06294186f, -0.28091368f, 0.00932750f, -0.22295192f, -0.00891633f, 0.12138988f, 0.11782684f, -0.11542884f, 
    -0.05984456f, -0.22611564f, -0.16446082f, 0.23289846f, -0.39553189f, 0.08170790f, -0.00631007f, 0.21745473f, 
    -0.15771793f, 0.08307362f, -0.04970465f, -0.50907153f, -0.28997979f, -0.19548869f, 0.09374741f, 0.09306044f, 
    0.01109038f, 0.11126001f, 0.06160026f, -0.09909654f, 0.21865773f, -0.29710919f, 0.14471476f, -0.13769759f, 
    0.11520211f, 0.02002428f, -0.19951469f, 0.19023265f, 0.14861019f, 0.03774200f, -0.24623278f, -0.01976645f, 
    0.00373543f, 0.04934521f, 0.11212061f, -0.03791334f, 0.00441107f, -0.07240438f, -0.12084818f, 0.13018891f, 
    0.08075111f, -0.08925155f, 0.11258329f, -0.01631638f, 0.05536189f, -0.11992408f, 0.12743877f, 0.18079130f, 
    0.22744271f, -0.10108813f, -0.06451949f, -0.02638361f, 0.19915122f, -0.01652054f, -0.04292691f, 0.00906157f, 
    -0.45035547f, -0.06462907f, -0.26684883f, 0.07983358f, -0.14526457f, -0.05200490f, -0.08280689f, 0.06537580f, 
    -0.01504340f, 0.07794616f, -0.02563723f, -0.23604591f, 0.08276326f, 0.08042465f, -0.00018790f, 0.08941951f, 
    0.12537350f, 0.04552552f, 0.36212069f, -0.42526367f, 0.05750662f, 0.04567111f, -0.03196380f, -0.21518721f, 
    0.03947621f, 0.00423062f, 0.01754379f, -0.34660214f, -0.15656966f, 0.57755613f, -0.02725706f, -0.11696129f, 
    -0.31951943f, -0.01487456f, -0.06680685f, 0.08906497f, -0.18307756f, 0.16342063f, 0.16099736f, -0.03850591f, 
    0.09430121f, 0.02391086f, 0.05284849f, 0.24002570f, -0.00583723f, -0.37500176f, -0.44329795f, -0.15504827f, 
    -0.13263990f, 0.04833276f, -0.12258030f, 0.12773383f, -0.00937816f, -0.04622995f, -0.20598358f, 0.03322246f, 
    -0.04882653f, 0.10761693f, 0.07856495f, 0.12750335f, 0.10630094f, -0.15848519f, -0.05439397f, 0.13082656f, 
    -0.08650638f, -0.06334943f, 0.03293304f, -0.05366099f, 0.12863810f, -0.00316553f, 0.02047095f, 0.02464486f, 
    0.02625577f, 0.02695752f, -0.13188535f, -0.08304569f, 0.05778415f, -0.14282894f, 0.03612464f, -0.09843130f, 
    0.27730876f, 0.09192813f, 0.18614860f, -0.09076530f, 0.11268670f, -0.00958833f, -0.08182616f, -0.08714893f, 
    -0.07015198f, -0.11668456f, 0.14296927f, -0.28972194f, -0.24314678f, -0.08652333f, -0.04763735f, -0.04861674f, 
    0.10087358f, -0.05944490f, 0.11359879f, 0.20946480f, -0.20973767f, -0.00188408f, -0.16573992f, -0.00432465f, 
    -0.00586614f, 0.03569569f, -0.16547881f, -0.04825122f, 0.17618953f, 0.02213600f, -0.09198560f, 0.14190897f, 
    -0.07620271f, -0.08001918f, 0.02892602f, -0.05212996f, 0.14930058f, -0.31117615f, -0.18102032f, -0.09202802f, 
    0.17497560f, 0.01783324f, -0.00225860f, -0.07470472f, -0.00299682f, 0.04137039f, 0.07582071f, 0.13845648f, 
    0.04086366f, 0.15917429f, -0.04048585f, 0.06735343f, 0.04894847f, 0.25492191f, -0.08483950f, -0.01350801f, 
    -0.20113720f, -0.04040022f, 0.06814884f, 0.02461228f, 0.07351909f, 0.07088552f, 0.09308475f, 0.09166873f, 
    -0.12909614f, -0.05275492f, 0.04629850f, 0.14801084f, 0.03609104f, -0.03328110f, 0.04182293f, -0.07464670f, 
    -0.10868057f, -0.01260194f, -0.01959472f, 0.12867972f, 0.07282989f, 0.03607179f, 0.09566216f, 0.12732494f, 
    0.01613194f, -0.01470847f, 0.18550825f, -0.07086581f, 0.06333943f, 0.01214435f, -0.13715757f, -0.06652418f, 
    -0.02854715f, 0.20718917f, 0.12623133f, 0.04048688f, 0.21669242f, 0.15733622f, -0.01007472f, -0.01284529f, 
    -0.00496259f, 0.05612142f, -0.08407659f, 0.03742543f, -0.16419512f, 0.20877658f, 0.21265832f, 0.00779756f, 
    -0.14824565f, 0.01903186f, 0.03454148f, -0.07006294f, 0.05069247f, -0.22099708f, -0.31996822f, -0.17923187f, 
    0.10070404f, 0.10218506f, 0.01650631f, -0.12322802f, -0.28876352f, -0.01644248f, -0.09911264f, -0.14122023f, 
    -0.04302453f, 0.15769294f, -0.06172333f, -0.01132989f, -0.01255941f, 0.09098580f, -0.07209690f, -0.00635248f, 
    0.14949612f, 0.10746908f, -0.09505175f, 0.12627362f, -0.12844236f, 0.02578319f, 0.05922526f, -0.18185557f, 
    -0.16343728f, 0.15701787f, 0.00947990f, 0.04914508f, -0.05671412f, 0.05041902f, 0.08875628f, 0.23027091f, 
    0.01894668f, -0.23842128f, -0.06111137f, 0.18564962f, -0.09591020f, 0.12443031f, -0.18282676f, -0.00119267f, 
    -0.09859578f, 0.11906786f, 0.26246509f, 0.08948778f, -0.23728307f, 0.10841340f, -0.03052825f, 0.00436194f, 
    0.03649592f, -0.03539445f, 0.00735572f, 0.03229791f, -0.01755421f, 0.10391776f, 0.08532710f, 0.01511787f, 
    0.09145192f, 0.02922148f, -0.09953720f, -0.05491564f, -0.22838603f, -0.00855962f, -0.41292599f, 0.15604660f, 
    0.12862773f, 0.13375597f, 0.03659342f, -0.07989521f, 0.10191139f, 0.05048241f, -0.11855526f, 0.16221587f, 
    -0.07716984f, 0.10006640f, -0.12858091f, 0.00581593f, 0.05069798f, 0.11201816f, 0.05068404f, 0.02298944f, 
    -0.29347745f, 0.05245309f, 0.07248412f, 0.18965662f, 0.00372516f, -0.09523048f, -0.00031956f, -0.07716069f, 
    -0.25420952f, -0.16749008f, 0.04363305f, -0.06132448f, -0.11824578f, 0.16238581f, 0.03373618f, -0.02455333f, 
    -0.00541060f, 0.14504346f, 0.19672596f, 0.03805508f, -0.13254462f, -0.00988027f, -0.11076090f, 0.00756358f, 
    0.16995770f, 0.21945888f, 0.05013986f, 0.16880728f, -0.14186604f, -0.15015763f, -0.06379892f, 0.09043666f, 
    0.13359848f, 0.22962789f, -0.07210512f, -0.14537527f, -0.39398178f, 0.02842757f, 0.08262151f, 0.04297680f, 
    -0.01652042f, -0.15564166f, -0.02357435f, 0.06011178f, 0.06629616f, -0.15902932f, 0.05225572f, 0.00277315f, 
    -0.08240511f, -0.00582264f, 0.03178563f, 0.03422965f, 0.17710924f, 0.03133954f, 0.10630654f, -0.07961202f, 
    -0.07264764f, 0.00663564f, 0.10661883f, -0.07013439f, 0.00343415f, 0.03246672f, -0.10437979f, 0.05831077f, 
    -0.26936716f, 0.10878648f, -0.10297165f, -0.01223469f, -0.10288560f, 0.04515059f, -0.09785481f, 0.10285962f, 
    -0.25201792f, -0.04336850f, -0.01055087f, 0.08084997f, 0.08676600f, -0.02900883f, 0.09506734f, 0.05841080f, 
    0.07485678f, -0.07588330f, 0.17623101f, -0.03245201f, -0.26392239f, 0.04283345f, -0.03966608f, -0.07998375f, 
    -0.15773804f, -0.09332313f, -0.23031865f, -0.03816118f, 0.05081099f, 0.06468011f, 0.09670774f, 0.07950895f, 
    0.19682503f, -0.04453678f, -0.05675862f, -0.16555661f, 0.00079971f, 0.07580162f, -0.04290517f, -0.05805525f, 
    0.04667963f, 0.04381917f, 0.39199340f, -0.08703192f, 0.00086367f, -0.01257565f, 0.03339512f, 0.02438599f, 
    -0.11940372f, 0.06425191f, 0.06845853f, 0.04444047f, 0.14571519f, 0.01543861f, -0.01106509f, -0.09972844f, 
    0.10928423f, -0.08334965f, -0.04529130f, -0.10118885f, -0.24931787f, -0.36771798f, 0.11534198f, 0.03742423f, 
    -0.06996921f, 0.04708479f, 0.06841353f, 0.08304738f, -0.03996944f, 0.40899977f, 0.10754225f, 0.04827414f, 
    0.05544085f, 0.02905625f, -0.02708588f, -0.04814260f, 0.04003566f, -0.04693834f, 0.26859137f, -0.19289553f, 
    -0.01195374f, -0.13490359f, 0.00324514f, -0.01889887f, -0.09490138f, 0.03395216f, 0.05072899f, -0.21643649f, 
    -0.11691089f, 0.03901288f, -0.01008446f, 0.03984513f, -0.04756632f, 0.09119520f, -0.06706310f, 0.01684104f, 
    -0.26714885f, -0.39410070f, 0.26696375f, 0.09820338f, 0.00400763f, 0.12011123f, -0.13605390f, 0.10121182f, 
    -0.05603753f, 0.03867532f, 0.24815013f, 0.05072334f, -0.04037077f, 0.08775880f, -0.04336606f, 0.02542975f, 
    0.04241730f, -0.08040335f, -0.06210733f, 0.05121280f, 0.03333405f, -0.04864362f, -0.11983821f, -0.05760543f, 
    0.02425473f, 0.06387555f, -0.10781540f, 0.12353665f, 0.02691437f, -0.13934998f, 0.19664820f, -0.06095045f, 
    0.11089553f, 0.03748558f, -0.00526286f, 0.03594286f, 0.21741518f, 0.09176701f, 0.01009165f, 0.03083112f, 
    0.00958498f, -0.14481992f, -0.00221080f, -0.05068304f, 0.02293936f, -0.24772708f, -0.35730806f, 0.21864682f, 
    0.13026354f, 0.08791316f, 0.12038957f, 0.01502936f, -0.07023166f, -0.02109474f, 0.10427381f, -0.30506423f, 
    -0.28644884f, 0.06315526f, 0.03759056f, -0.03635713f, -0.03005796f, -0.04676871f, -0.27321333f, -0.00549668f, 
    0.10484345f, -0.00014975f, 0.07146765f, -0.12990578f, -0.09214978f, 0.04331497f, 0.10069994f, -0.00154292f, 
    -0.28649175f, -0.33099806f, 0.08381125f, 0.11994716f, 0.05960333f, 0.01741315f, -0.07645983f, -0.01409070f, 
    0.03829587f, -0.05544635f, 0.11541752f, 0.10103874f, -0.13688387f, 0.03816189f, -0.24380691f, -0.05643107f, 
    0.03031144f, 0.02154679f, 0.04445628f, 0.31275722f, 0.00489256f, -0.05358410f, -0.05545554f, -0.06228239f, 
    -0.15960547f, -0.10824829f, -0.13107958f, 0.24036759f, 0.13928111f, 0.04667278f, 0.00560105f, -0.05502370f, 
    0.01619915f, -0.00552109f, 0.08556526f, 0.05229758f, 0.09651320f, 0.22859150f, 0.16774014f, 0.09140024f, 
    0.10517223f, 0.00669602f, -0.08659334f, -0.15603706f, 0.04361740f, -0.11306445f, -0.15512744f, -0.08218069f, 
    -0.05830286f, 0.00994076f, -0.14440712f, 0.05689954f, -0.18310310f, 0.10317756f, -0.24093996f, 0.08993736f, 
    -0.03544420f, 0.01998499f, 0.08885638f, -0.12585886f, -0.01299159f, -0.03039813f, -0.06903537f, 0.25282747f, 
    0.00075976f, 0.04723038f, -0.04534522f, -0.09281704f, -0.07291146f, -0.03589906f, -0.04833914f, -0.04288849f, 
    0.07884865f, 0.08168643f, -0.08119514f, 0.09047616f, -0.08370633f, -0.01736863f, 0.05852904f, 0.07288883f, 
    -0.02946603f, 0.11294457f, 0.12359686f, 0.07663015f, 0.04671897f, 0.01752814f, 0.00643653f, -0.14969757f, 
    -0.04850654f, -0.06219010f, -0.23816046f, 0.06273454f, 0.02047908f, 0.15024664f, 0.08093791f, -0.21204281f, 
    0.11447570f, -0.13233323f, -0.02579995f, 0.03515842f, -0.03433289f, -0.23201519f, -0.07379242f, 0.07155245f, 
    -0.15508990f, -0.11356162f, 0.05966485f, -0.12846644f, -0.22410986f, -0.19190377f, -0.00054471f, 0.01620428f, 
    -0.02180174f, 0.04343120f, -0.09186342f, -0.06044326f, 0.00431106f, 0.12859784f, 0.11873844f, 0.09872083f, 
    -0.06542850f, 0.05754207f, -0.06249699f, 0.06081505f, 0.03806460f, 0.17614891f, 0.11669140f, 0.17592394f, 
    0.03438433f, 0.00797091f, 0.01232641f, 0.07756033f, -0.14379220f, 0.00860176f, -0.07419477f, -0.14454871f, 
    0.15093343f, -0.14330570f, 0.05102257f, -0.07613993f, -0.10540634f, -0.20980832f, 0.08452471f, -0.12279642f, 
    0.04555812f, 0.01603839f, 0.00411225f, -0.02300853f, -0.04651620f, -0.04650752f, 0.03698186f, -0.03807848f, 
    0.01777990f, 0.04596841f, 0.00713098f, 0.00117256f, -0.04757702f, -0.04055394f, -0.03362690f, -0.06301596f, 
    0.04993481f, -0.05651924f, -0.01949029f, -0.01645996f, 0.02451640f, -0.03872605f, 0.01058349f, 0.02359786f, 
    0.03866629f, -0.00837906f, -0.00378343f, 0.03999459f, 0.04296251f, 0.02175197f, -0.01638544f, 0.01518255f, 
    -0.01257479f, -0.02283489f, -0.04132666f, 0.00993879f, -0.04861767f, -0.04821159f, -0.03792802f, 0.03809135f, 
    -0.01137675f, -0.04837265f, -0.03133079f, -0.04333376f, 0.04968724f, 0.04232433f, -0.01037249f, 0.02080606f, 
    -0.05667922f, -0.04726963f, 0.00721427f, -0.02013272f, -0.04235429f, -0.01337549f, -0.00035949f, -0.02242562f, 
    -0.02355797f, 0.00890061f, -0.01651886f, -0.03603725f, 0.04678108f, -0.01816448f, 0.04796544f, 0.02340597f, 
    -0.06981464f, -0.03199301f, 0.03461496f, -0.00711994f, -0.02214019f, -0.00879951f, -0.06421110f, -0.00956148f, 
    -0.01746707f, -0.05332658f, 0.00568970f, 0.04254353f, -0.01745204f, -0.00203254f, 0.03640813f, -0.00930559f, 
    -0.00721757f, 0.02708470f, -0.02059884f, -0.04721168f, -0.01730224f, -0.05897563f, 0.02901243f, 0.00415144f, 
    -0.04485944f, -0.05919718f, -0.01603716f, 0.04145641f, 0.04351573f, 0.02405034f, 0.01861053f, -0.00689877f, 
    -0.02297046f, -0.04554288f, -0.05037934f, -0.05693104f, 0.00051457f, 0.03425726f, -0.02479153f, 0.05355221f, 
    0.04714148f, -0.05770893f, -0.00394022f, -0.03451578f, 0.02557209f, -0.00575804f, 0.04811929f, 0.04870664f, 
    0.03263074f, -0.05728881f, -0.06859238f, 0.01797369f, 0.01012710f, -0.05977736f, 0.01927819f, -0.05210923f, 
    -0.02083506f, 0.02497243f, -0.04995193f, -0.05007720f, 0.00475618f, 0.05106670f, 0.01694585f, -0.04284774f, 
    -0.05740412f, -0.02606244f, 0.04401636f, -0.01715348f, 0.05092572f, -0.02699646f, 0.00700908f, -0.06913785f, 
    -0.03388472f, -0.03859138f, -0.04467081f, 0.04923550f, -0.03923281f, 0.03193075f, 0.01732109f, -0.01603814f, 
    -0.04732176f, -0.00395103f, -0.04367848f, 0.03365927f, -0.03148432f, 0.01924789f, 0.04696143f, 0.05126939f, 
    -0.00795619f, -0.05793992f, -0.02107713f, -0.00784173f, 0.00517941f, -0.01679623f, 0.01738407f, 0.01404150f, 
    -0.06724625f, -0.00858692f, -0.00450636f, 0.03647104f, 0.01151103f, 0.00575132f, 0.00597522f, 0.04027264f, 
    -0.06906197f, -0.05495666f, -0.03737359f, -0.04413195f, 0.03374819f, -0.01938890f, -0.06560705f, -0.03901894f, 
    -0.00306367f, 0.01426606f, -0.06582559f, 0.01464115f, 0.00920173f, -0.06526964f, 0.04103648f, 0.01862608f, 
    0.04118278f, 0.04498735f, -0.02288999f, 0.04233287f, 0.00438844f, 0.04073593f, -0.00713206f, 0.00338210f, 
    -0.05580796f, -0.05315989f, -0.03222976f, 0.02214017f, -0.06118044f, -0.03600882f, 0.03698828f, -0.01159854f, 
    -0.05516703f, -0.01094106f, -0.01067363f, -0.00724091f, 0.01817801f, 0.04981413f, 0.04888931f, -0.00753608f, 
    0.00123220f, -0.02153648f, 0.03917153f, -0.01975474f, 0.00389311f, 0.03306583f, -0.05380569f, 0.02953702f, 
    -0.01974969f, 0.01405464f, -0.01361913f, -0.00450627f, 0.02479466f, 0.03409850f, -0.00269286f, -0.01668842f, 
    0.02165375f, -0.02948289f, -0.06455569f, -0.01495870f, 0.00156467f, 0.04092528f, -0.02268364f, 0.04447994f, 
    -0.06292105f, -0.05485686f, 0.00029537f, 0.01374860f, 0.00121902f, -0.04585816f, -0.04941053f, -0.03727013f, 
    -0.00260992f, -0.02247507f, -0.00635842f, 0.00953915f, 0.00337421f, 0.00799160f, -0.00466874f, -0.02988437f, 
    -0.02065923f, -0.04999655f, 0.03658083f, 0.04644459f, -0.05790967f, 0.01823390f, 0.02905450f, -0.02416877f, 
    0.02028880f, -0.06257702f, -0.06165297f, -0.03368695f, 0.05478634f, -0.04864327f, -0.00420067f, 0.01548218f, 
    -0.03943267f, -0.01751727f, -0.01295511f, -0.02712953f, 0.01065070f, 0.03588155f, 0.01887658f, -0.05911123f, 
    -0.02379619f, -0.02523189f, -0.05746216f, 0.01407373f, -0.03587981f, -0.06063719f, -0.02965388f, -0.03516762f, 
    0.04286810f, -0.02828329f, -0.02220342f, 0.05271523f, -0.04006819f, -0.05728003f, -0.01168572f, 0.04195809f, 
    -0.20233770f, -0.09394734f, 0.03996502f, 0.27280906f, -0.19813032f, -0.06609427f, 0.06553496f, 0.15954176f, 
    0.02305299f, 0.06207472f, -0.03769308f, -0.10759017f, 0.18488586f, 0.09697484f, 0.06312658f, -0.05099970f, 
    -0.02218271f, 0.08551171f, -0.17606188f, -0.15075873f, 0.06799592f, 0.05594831f, 0.08731377f, 0.07381945f, 
    0.01809347f, 0.05852037f, -0.16187797f, 0.11320210f, -0.13879271f, -0.11556435f, 0.06920384f, 0.09469537f, 
    0.13551871f, 0.15815935f, -0.05972016f, -0.09261329f, 0.24263994f, -0.07340849f, 0.01034323f, 0.09836285f, 
    0.03554809f, -0.19944592f, 0.17292792f, 0.00612311f, 0.24644950f, -0.08654934f, -0.21023394f, -0.01985380f, 
    0.07715502f, 0.04289820f, 0.11078451f, -0.04334309f, -0.02540662f, -0.11379164f, -0.19533873f, 0.17053503f, 
    0.13653964f, 0.24285220f, 0.00828951f, 0.04664652f, 0.13516504f, 0.10538891f, -0.07872362f, 0.01384029f, 
    -0.03772450f, 0.01528011f, 0.20931476f, -0.31270251f, 0.06592890f, 0.01118501f, -0.06646159f, -0.00727674f, 
    0.14727125f, 0.12008190f, -0.07566749f, 0.14599870f, -0.13484630f, -0.04422816f, -0.03633208f, -0.03875707f, 
    -0.00622798f, 0.14071105f, 0.01436618f, -0.04638818f, -0.02151451f, -0.04959636f, -0.05470505f, -0.06743935f, 
    -0.13029733f, -0.16591382f, -0.40137002f, -0.20038475f, 0.10209365f, -0.10208684f, 0.00642458f, -0.30995074f, 
    0.05286762f, 0.03895001f, 0.15610723f, -0.00175426f, 0.11791027f, -0.00842576f, -0.04940338f, 0.03004721f, 
    -0.09894966f, 0.05975586f, -0.10649585f, -0.04731479f, 0.00418294f, -0.01742077f, -0.23340429f, -0.02164977f, 
    0.02860392f, 0.23465896f, 0.05799224f, -0.02824843f, -0.06833480f, 0.13467774f, 0.13719530f, -0.17201228f, 
    -0.14578924f, 0.00503824f, 0.22059660f, -0.18892704f, -0.18006007f, -0.01089234f, 0.15772960f, 0.28735167f, 
    0.01464252f, 0.09614950f, 0.01679103f, 0.14474218f, -0.00003822f, -0.05223403f, 0.00675879f, -0.01030991f, 
    0.03607087f, -0.09203788f, 0.01856792f, -0.08176368f, -0.03516544f, -0.02418761f, 0.00006482f, -0.00056706f, 
    0.05568317f, 0.04227315f, 0.13316745f, -0.02868121f, 0.02806187f, 0.11222360f, 0.13858368f, 0.12039028f, 
    0.09135024f, 0.03441164f, 0.27763960f, -0.11661082f, 0.21096039f, -0.03642857f, 0.01148433f, -0.12417336f, 
    0.03668642f, -0.17730093f, -0.03676227f, -0.04570032f, -0.10464412f, 0.15025470f, 0.06515248f, 0.11443989f, 
    0.02265844f, -0.02551803f, -0.03670403f, 0.00022025f, -0.01791126f, -0.31805170f, 0.01935958f, 0.02382401f, 
    0.00776456f, 0.03688936f, -0.11859792f, -0.13999319f, -0.13822447f, -0.02295958f, -0.02602699f, 0.18097480f, 
    0.01884895f, -0.05748636f, 0.01279222f, -0.00232058f, -0.14574894f, -0.06341948f, 0.09985346f, 0.02186072f, 
    0.11420441f, -0.09395865f, 0.00463328f, 0.04385498f, 0.07430367f, -0.02641222f, 0.03546243f, -0.08933031f, 
    0.06237442f, 0.06579436f, 0.03259026f, -0.01347557f, 0.02973644f, -0.07198875f, 0.07293400f, 0.10644886f, 
    -0.08031929f, -0.29433551f, 0.08933855f, 0.07415768f, 0.22243409f, -0.10391667f, 0.09711468f, -0.32843494f, 
    -0.13436306f, 0.03379969f, -0.02537868f, 0.05358335f, -0.02876483f, -0.01161876f, -0.01191369f, -0.04169330f, 
    0.10396264f, 0.12671900f, 0.08836293f, 0.18661614f, -0.11203294f, 0.03181224f, 0.03104361f, 0.12697023f, 
    0.12216863f, 0.03198834f, 0.13898882f, -0.23262836f, 0.03072524f, -0.03604720f, 0.05594599f, -0.01506797f, 
    -0.01464368f, -0.08390507f, 0.19375888f, 0.17447738f, -0.10487507f, -0.19753492f, 0.04567879f, -0.21451092f, 
    -0.08639492f, -0.12995216f, 0.12875476f, 0.10031835f, 0.05308079f, -0.11892843f, 0.02350214f, 0.06095094f, 
    -0.05825755f, -0.09617897f, -0.00609512f, -0.03062938f, 0.04197340f, -0.22566055f, -0.10789812f, -0.01827302f, 
    -0.16775510f, -0.14649564f, 0.04572693f, 0.15300195f, -0.08812305f, 0.04976171f, 0.04958610f, -0.05772125f, 
    -0.19120899f, -0.01146200f, 0.05997656f, 0.05904307f, 0.15547493f, -0.24654575f, 0.01475799f, 0.24885237f, 
    -0.15525107f, -0.07138702f, 0.02063985f, 0.09180312f, 0.07696564f, 0.05295269f, -0.03729902f, 0.12835380f, 
    -0.00660605f, 0.03250137f, -0.01518290f, 0.02736677f, -0.00162222f, 0.00072668f, -0.02235786f, -0.00246750f, 
    0.03060796f, 0.05173646f, 0.00681578f, -0.01160603f, 0.01114323f, 0.01123150f, -0.01718489f, 0.01960041f, 
    0.00470549f, -0.01599609f, -0.03921190f, 0.00460454f, -0.04247930f, -0.04590387f, -0.05829784f, -0.05289062f, 
    -0.04517958f, -0.01230257f, -0.00299976f, 0.00579875f, 0.04757356f, -0.03187877f, -0.05910230f, -0.03841389f, 
    -0.02238463f, -0.01306409f, -0.05127662f, -0.03144470f, -0.02550060f, 0.04749853f, 0.03634477f, 0.01577106f, 
    0.00482979f, -0.03952544f, -0.02305395f, -0.01570487f, 0.04466954f, -0.01900977f, 0.03960369f, -0.03492537f, 
    -0.01631186f, -0.01654772f, -0.01720223f, -0.05763398f, -0.02259012f, -0.01344756f, 0.03238182f, 0.01289231f, 
    0.03924350f, 0.01748279f, -0.00369312f, -0.02507059f, -0.05915078f, 0.04074718f, -0.03873387f, -0.01752215f, 
    0.02732936f, -0.04263285f, -0.03919582f, 0.04945171f, 0.01239017f, 0.03163673f, 0.04135179f, -0.00274630f, 
    -0.05047108f, 0.01933672f, 0.03076398f, -0.05600707f, -0.02056553f, -0.00737847f, -0.00074366f, -0.04317460f, 
    0.05280203f, -0.01799580f, 0.00757905f, 0.03918717f, -0.05968462f, -0.00110493f, -0.06421931f, 0.03638398f, 
    0.00317484f, -0.00928733f, 0.01181481f, -0.05520319f, -0.02044349f, 0.03681837f, -0.01448757f, -0.02825189f, 
    -0.03352397f, -0.01578750f, -0.04729476f, -0.00567640f, -0.05958219f, -0.01205925f, -0.03894036f, -0.02257259f, 
    0.03272533f, -0.02340879f, -0.02932980f, 0.02742339f, 0.03275569f, 0.04583590f, -0.05452720f, 0.04658303f, 
    0.01922688f, 0.01839761f, -0.05023162f, -0.03810461f, -0.03668728f, -0.00113430f, -0.01338883f, -0.05250500f, 
    -0.06395818f, 0.00742908f, -0.06462334f, -0.05314724f, -0.01419019f, -0.00054958f, 0.02943330f, 0.00769007f, 
    0.05244264f, -0.03249200f, 0.04462922f, -0.05517022f, 0.03030965f, 0.04201785f, 0.00262507f, -0.05087120f, 
    -0.05638469f, 0.01863283f, -0.00555891f, -0.00979289f, -0.06227697f, -0.02891429f, 0.01868645f, 0.04241693f, 
    -0.00223120f, 0.02206841f, -0.00676393f, -0.02062296f, -0.01527267f, 0.03925474f, -0.03930119f, 0.00410519f, 
    0.00102615f, -0.04267362f, -0.04098852f, -0.01016845f, -0.03420355f, -0.04739822f, -0.01755605f, -0.02932514f, 
    0.04239921f, -0.00967367f, 0.05172386f, 0.02085392f, -0.01760516f, -0.05841333f, -0.04163877f, 0.02555124f, 
    0.00637335f, -0.04031498f, -0.02580557f, -0.01369152f, -0.03990434f, -0.03058388f, -0.02113610f, -0.02709581f, 
    -0.05433001f, -0.05661914f, -0.06361846f, 0.04713733f, -0.04434561f, -0.03087934f, -0.02680510f, -0.00931738f, 
    -0.00285077f, 0.05156765f, 0.01180683f, 0.04911695f, 0.02282771f, -0.00533205f, -0.04875333f, 0.01534786f, 
    -0.06273691f, -0.05195146f, -0.05266975f, -0.03780933f, 0.01907557f, 0.01320093f, -0.05496315f, -0.02263591f, 
    -0.05149425f, -0.06489851f, -0.04578026f, 0.04391262f, -0.00476873f, 0.03357858f, 0.02818654f, 0.03712014f, 
    -0.02102878f, 0.03611348f, -0.05665689f, 0.04970777f, 0.00691715f, 0.00590420f, 0.04642369f, -0.06058116f, 
    -0.04719242f, -0.01963024f, 0.00809108f, 0.05165927f, -0.03378307f, -0.04802571f, -0.04827441f, 0.00610837f, 
    -0.01269653f, 0.04722634f, -0.01264667f, -0.03390579f, 0.00011245f, 0.01552731f, -0.02685031f, -0.05394645f, 
    0.05219676f, -0.02282607f, -0.00997818f, -0.04526649f, -0.01255822f, -0.02199298f, 0.04987416f, -0.04008232f, 
    -0.02716009f, 0.01889463f, -0.05149477f, 0.04492856f, 0.01748239f, -0.03467805f, 0.02025620f, -0.03469964f, 
    -0.05222015f, 0.02686126f, 0.01713506f, 0.00541814f, -0.05789315f, -0.05601319f, 0.01647130f, -0.04934631f, 
    -0.05349534f, 0.03356360f, 0.00573407f, -0.04849121f, 0.03132021f, -0.01274020f, 0.00754864f, -0.03964040f, 
    0.00340890f, -0.01060454f, -0.05341174f, 0.02138644f, -0.04357731f, -0.02941229f, -0.03208499f, -0.04302801f, 
    -0.04637902f, 0.00645832f, -0.04519422f, 0.01993778f, 0.04461358f, 0.02763606f, 0.00752337f, 0.05146793f, 
    -0.00448524f, -0.01457706f, -0.04239893f, 0.02281829f, -0.04355745f, -0.02105652f, -0.06163602f, -0.02680088f, 
    0.11682796f, -0.01890426f, 0.15119024f, -0.25064042f, 0.11653192f, 0.07605657f, 0.12011619f, 0.09043583f, 
    0.15038235f, -0.00786096f, -0.10729908f, 0.11893442f, 0.02002577f, 0.11097806f, -0.10075683f, -0.05347686f, 
    -0.05837400f, 0.15478308f, -0.08675032f, -0.04560090f, 0.06600988f, 0.02528236f, 0.13828507f, -0.12492685f, 
    0.23661573f, 0.27808040f, 0.12270301f, -0.35350585f, -0.39651000f, 0.06323171f, -0.03264944f, 0.01716818f, 
    -0.10513612f, -0.12545706f, 0.10723834f, 0.02929763f, 0.26498565f, 0.04366650f, 0.18565038f, 0.00528276f, 
    0.04915183f, 0.01727135f, -0.01885566f, -0.07523350f, -0.03100087f, 0.26249528f, -0.07040142f, 0.03481321f, 
    0.02503062f, 0.05609475f, 0.17244555f, -0.03435839f, 0.07127617f, 0.22227372f, -0.19539049f, -0.12272092f, 
    -0.09416620f, -0.07244217f, 0.08166387f, 0.11452779f, -0.12603772f, -0.09957498f, 0.22229125f, -0.17229438f, 
    0.21665731f, -0.03781151f, 0.04678707f, -0.21775764f, 0.10739262f, -0.04700141f, 0.17390487f, 0.09246975f, 
    0.07816228f, 0.22187729f, -0.06537046f, 0.10966270f, -0.04618526f, 0.07717057f, 0.08021634f, -0.00232394f, 
    0.15111981f, -0.06240119f, -0.27905348f, 0.00216563f, -0.05203842f, 0.03265927f, -0.09805908f, 0.18052182f, 
    0.04661033f, 0.03905765f, 0.11372037f, 0.20790601f, 0.37391210f, 0.03645238f, -0.05775055f, -0.04899957f, 
    0.02109067f, 0.01499787f, -0.02042629f, 0.03830342f, -0.00750339f, -0.43554777f, 0.14904940f, 0.13629159f, 
    0.00852113f, -0.00073030f, 0.09691042f, -0.20994294f, -0.23081492f, -0.35682786f, -0.19517969f, -0.08076540f, 
    0.12464917f, -0.04592733f, -0.04132811f, -0.01979790f, 0.04779298f, 0.11845078f, 0.14822352f, 0.04692017f, 
    0.03968431f, 0.07317484f, 0.18132880f, -0.17005293f, 0.15812519f, 0.12563589f, 0.02645331f, 0.12065843f, 
    0.13468572f, -0.07710122f, -0.16851568f, -0.00319526f, -0.16039771f, 0.03398883f, 0.07637462f, 0.11434176f, 
    -0.03077893f, -0.60394430f, 0.06953795f, 0.01298468f, 0.08889531f, 0.07603372f, -0.06295007f, -0.08758069f, 
    -0.00804526f, 0.09941638f, 0.15202330f, 0.11399179f, 0.05828127f, 0.09654339f, 0.05911765f, 0.19565760f, 
    0.00555932f, -0.39360636f, -0.13263643f, -0.12522374f, 0.22225824f, 0.10717864f, -0.00432603f, 0.00289244f, 
    0.05579740f, -0.15079451f, -0.15027308f, -0.41134983f, 0.03801055f, -0.12004935f, 0.01699749f, -0.29248795f, 
    0.06758725f, -0.08110095f, -0.11489020f, 0.09525674f, 0.09705030f, -0.04524262f, -0.00010958f, -0.01311893f, 
    -0.00061208f, -0.03703189f, 0.01834816f, 0.01208056f, -0.07333625f, 0.01008016f, 0.07457944f, 0.02640289f, 
    0.13224900f, -0.05629968f, 0.06444824f, 0.02978506f, -0.03090609f, -0.21929629f, -0.03496769f, -0.05453055f, 
    0.06962042f, -0.01992534f, -0.01004110f, -0.05952502f, -0.04233056f, -0.02866570f, 0.27693531f, -0.26673830f, 
    -0.11034261f, 0.06276994f, 0.12018114f, 0.13408861f, 0.07572086f, -0.05866992f, -0.06813266f, 0.03784446f, 
    0.00790400f, -0.11198258f, -0.08639422f, -0.08529091f, 0.08867387f, 0.05021415f, 0.07701449f, 0.35460487f, 
    -0.14515369f, -0.09031138f, -0.13973160f, 0.01622785f, -0.03294413f, 0.02602145f, -0.03137463f, 0.04825168f, 
    -0.03576927f, -0.22638230f, 0.04270353f, -0.24023362f, 0.06982323f, 0.00006560f, 0.04467214f, 0.01841973f, 
    0.22679861f, -0.13915673f, -0.03451798f, 0.12889421f, -0.13147594f, -0.04697009f, 0.08030432f, -0.13603781f, 
    -0.11612500f, 0.05550225f, -0.01668600f, -0.30018377f, -0.18593059f, -0.04125040f, -0.15467153f, 0.04652158f, 
    -0.17725058f, -0.29627219f, -0.11229494f, -0.04346253f, -0.00692348f, -0.00462037f, 0.08325636f, 0.02865390f, 
    0.02977706f, 0.16177060f, 0.07223377f, 0.03855249f, 0.00352915f, 0.14327511f, 0.12614501f, -0.31627360f, 
    0.16705607f, -0.05749510f, -0.04678703f, 0.20848478f, -0.13112856f, 0.00573535f, 0.04760278f, -0.12496503f, 
    -0.10626866f, 0.05810415f, 0.09613670f, 0.12474978f, -0.08857001f, -0.10411679f, -0.14790389f, -0.04343910f, 
    0.11960871f, -0.19341004f, -0.08125587f, 0.01538111f, -0.09104194f, -0.28751528f, -0.05283593f, -0.00232397f, 
    0.07742001f, 0.02308032f, -0.29841846f, -0.06120887f, 0.00816549f, 0.04754787f, 0.01390638f, 0.04494811f, 
    -0.09429988f, 0.00843703f, 0.08224806f, 0.06839655f, -0.07042064f, -0.16235784f, -0.19025011f, -0.18588145f, 
    0.11586846f, -0.11089772f, 0.25916028f, -0.08784608f, -0.21406445f, 0.00508582f, -0.09714922f, 0.19321752f, 
    0.00899515f, 0.09495764f, 0.01283576f, -0.13067597f, 0.08448311f, -0.06632267f, 0.01826400f, -0.03027656f, 
    0.18225372f, 0.03712347f, -0.02544240f, -0.00680209f, -0.13459180f, -0.07646461f, -0.02053770f, -0.11536948f, 
    -0.01925836f, 0.12693648f, -0.14728710f, -0.06567968f, -0.05427149f, 0.32317635f, 0.16028824f, -0.08399016f, 
    0.04609543f, -0.01290725f, -0.03979909f, -0.06641477f, 0.02620542f, 0.01951165f, 0.31696239f, -0.05508370f, 
    -0.06971423f, -0.07484328f, -0.07738504f, 0.01310092f, -0.04900860f, -0.02504154f, -0.02924387f, -0.27903354f, 
    -0.01475918f, -0.12346274f, -0.15196541f, 0.18880093f, 0.11699030f, 0.07093440f, -0.04850348f, -0.07828982f, 
    0.01521036f, 0.04232049f, -0.02017025f, -0.01030981f, 0.13681157f, 0.06564599f, -0.06209138f, -0.07770558f, 
    -0.00229936f, -0.07609870f, -0.11952213f, 0.16407171f, -0.08239888f, -0.01515512f, 0.14615344f, -0.04979178f, 
    -0.12956750f, 0.08934189f, 0.15803422f, -0.03210380f, -0.08890070f, 0.07674246f, -0.17223313f, 0.14674753f, 
    0.12843865f, -0.11452484f, -0.14039810f, 0.06715494f, 0.02217248f, 0.27555755f, -0.03759602f, 0.00912682f, 
    0.06126371f, 0.03401415f, 0.04440017f, 0.11437916f, 0.14405470f, -0.04276394f, 0.03025587f, -0.04496912f, 
    -0.08620280f, -0.12582637f, 0.14363615f, 0.00996303f, 0.06512030f, -0.18423030f, 0.02655442f, -0.15640874f, 
    0.17037840f, 0.00191011f, 0.06106245f, -0.03005043f, 0.07265536f, 0.05730070f, 0.03283522f, 0.01790700f, 
    -0.21263579f, -0.06045620f, 0.21225157f, -0.05551394f, 0.07864288f, 0.04722330f, -0.21164192f, -0.10155522f, 
    0.07281805f, 0.30692720f, -0.17311522f, -0.00542191f, 0.01612667f, 0.02234780f, 0.12432644f, 0.00561242f, 
    0.00707532f, 0.05556365f, -0.41423067f, -0.02264874f, 0.05611220f, 0.09013161f, 0.15665935f, -0.11005177f, 
    0.07145619f, -0.06730793f, -0.09895257f, 0.02401992f, 0.05592068f, -0.02004118f, -0.01678109f, 0.03457973f, 
    0.07817879f, 0.11344886f, 0.17969641f, 0.08261076f, 0.36236581f, -0.07832931f, -0.03790560f, -0.03532602f, 
    -0.03005742f, 0.08979712f, 0.08384175f, -0.24205814f, -0.02038576f, 0.18553236f, 0.08876907f, 0.06629619f, 
    0.07178111f, -0.16341700f, 0.15149288f, -0.01352019f, 0.07113514f, 0.27825609f, -0.05894538f, -0.02327598f, 
    0.01038915f, -0.04333817f, -0.03530191f, -0.19888860f, 0.08826095f, -0.03070313f, -0.09910176f, -0.03933399f, 
    -0.01846435f, 0.01266599f, -0.08047342f, -0.00306376f, 0.00085300f, 0.03861260f, -0.17472902f, 0.06692825f, 
    -0.16645731f, -0.12397446f, -0.03446779f, -0.06778775f, 0.02006078f, 0.00978455f, -0.06936785f, 0.04833873f, 
    0.20793973f, -0.02846567f, 0.12557434f, -0.04877520f, -0.18047012f, 0.06336584f, 0.01163528f, -0.16427968f, 
    0.09693912f, -0.13886206f, 0.18468183f, -0.04537624f, 0.12901355f, 0.00520912f, -0.01391386f, 0.01511628f, 
    0.01999485f, -0.13188493f, -0.12437858f, 0.15307742f, -0.09536718f, -0.06795950f, -0.07565422f, -0.01714807f, 
    -0.04057578f, -0.00760349f, -0.18438007f, 0.24786068f, 0.07481726f, -0.08123707f, -0.08167392f, 0.05858005f, 
    -0.01635620f, -0.05471171f, 0.00813754f, -0.04540731f, 0.23451984f, 0.24897265f, -0.01029926f, -0.07899320f, 
    -0.07739303f, -0.17355150f, 0.00420062f, -0.02877196f, 0.19580786f, 0.08882925f, -0.38431025f, 0.20695287f, 
    0.00455390f, 0.16800115f, 0.04793159f, -0.01851187f, -0.16083638f, -0.02224374f, 0.11529824f, 0.00168261f, 
    0.06584410f, -0.21661890f, -0.04116038f, -0.06418096f, -0.01578047f, 0.24672581f, -0.15333903f, 0.13427606f, 
    0.18435785f, -0.00972999f, -0.00796928f, 0.07386338f, -0.08955176f, -0.03939766f, -0.02695633f, -0.23317847f, 
    0.01911191f, -0.00395409f, -0.11308105f, 0.00543138f, -0.09699164f, -0.04705264f, 0.17250502f, 0.02076585f, 
    -0.03425937f, -0.01509646f, 0.01332608f, 0.03612883f, 0.01592086f, -0.05859794f, -0.05044398f, 0.00970801f, 
    -0.02540176f, -0.01499999f, 0.00636607f, -0.02568342f, 0.02669898f, -0.04927158f, -0.02090772f, -0.03732472f, 
    -0.02681196f, -0.05808625f, -0.01590417f, -0.03546202f, -0.05411420f, -0.05297762f, 0.05212642f, 0.03377456f, 
    -0.02596988f, 0.03686931f, -0.00621960f, -0.06353651f, -0.01098309f, -0.05509179f, 0.04700238f, -0.03149422f, 
    -0.04535652f, 0.04403085f, -0.06138368f, -0.03498412f, -0.00979461f, -0.00047448f, -0.06272978f, -0.04717384f, 
    0.02202554f, 0.03790043f, 0.04060044f, 0.05339905f, -0.01823388f, 0.01431368f, -0.02613593f, 0.03164977f, 
    -0.04948927f, 0.03257534f, -0.05475604f, 0.04620702f, -0.04571839f, 0.01550407f, 0.05046139f, 0.04596799f, 
    -0.02526311f, -0.06505072f, 0.00353681f, -0.02758433f, 0.00389595f, -0.02095807f, -0.04762522f, -0.02801115f, 
    -0.00591880f, 0.02028179f, -0.03914837f, 0.00425807f, -0.01822016f, -0.05201976f, 0.03829462f, -0.06326201f, 
    -0.04533854f, -0.06648561f, 0.02672996f, -0.03918078f, -0.02192672f, -0.00043869f, 0.04834526f, 0.03282023f, 
    -0.02407349f, -0.03429646f, -0.01536129f, 0.01534135f, -0.04111952f, -0.01675215f, -0.05786137f, 0.05075619f, 
    -0.06147003f, -0.03307271f, -0.02983734f, -0.03708155f, 0.00669064f, -0.00410940f, -0.01714455f, 0.00748739f, 
    -0.01544598f, 0.03456710f, 0.04537627f, 0.05289713f, 0.03886744f, 0.02139203f, 0.01122875f, -0.01859426f, 
    -0.05211380f, 0.04493093f, -0.00658150f, -0.01316854f, -0.01464207f, 0.00854661f, -0.03167787f, -0.03229648f, 
    -0.00199817f, 0.00120646f, 0.01273589f, -0.06501926f, -0.02272110f, -0.04430085f, 0.00559697f, -0.05262749f, 
    -0.00193383f, 0.03386177f, -0.02723325f, -0.04187746f, -0.03135792f, -0.00284180f, -0.00763051f, 0.03559851f, 
    0.02286438f, -0.01392544f, -0.02332841f, -0.01699198f, -0.03697176f, -0.02668413f, 0.03895836f, -0.05788171f, 
    -0.02719739f, -0.03099250f, 0.01242566f, 0.01029331f, 0.02242620f, -0.03232594f, -0.02588408f, 0.00048514f, 
    0.02703496f, 0.02422897f, 0.03020282f, -0.03263318f, -0.00918196f, -0.00043470f, -0.03515046f, -0.05289434f, 
    -0.03117672f, 0.04062243f, -0.04063303f, 0.03343366f, 0.03855732f, 0.00354306f, -0.03470236f, -0.03668039f, 
    -0.05321154f, -0.02769532f, -0.00329950f, 0.01654608f, -0.01496000f, -0.02890938f, 0.00628403f, 0.00630935f, 
    0.02043427f, -0.01497970f, 0.02196596f, -0.00339359f, -0.00440534f, 0.04655526f, 0.02662707f, 0.00171824f, 
    0.02948745f, -0.05697900f, -0.02379418f, -0.06391650f, -0.05264003f, -0.00944575f, -0.03947824f, -0.00540771f, 
    -0.02613250f, 0.01177843f, 0.04914749f, 0.01597857f, -0.05278934f, 0.04555840f, 0.00735193f, 0.01114024f, 
    -0.02891871f, 0.04130976f, 0.05171693f, 0.00911400f, 0.00476307f, -0.01830607f, 0.04076257f, -0.06618708f, 
    -0.04664827f, 0.04689021f, 0.02949230f, -0.01889485f, -0.00618880f, 0.01982589f, -0.03068549f, 0.01574905f, 
    -0.06359098f, -0.02378936f, 0.04329120f, -0.03655546f, 0.00684766f, 0.02842346f, 0.01033708f, 0.02791381f, 
    0.02003798f, 0.03837014f, -0.03856790f, -0.04830555f, -0.05636420f, 0.05192908f, -0.04980969f, 0.04012002f, 
    -0.05711491f, -0.02085344f, -0.02436145f, 0.00560816f, -0.04131482f, 0.01062515f, 0.01881527f, 0.01154322f, 
    0.01937243f, 0.01973778f, 0.00280844f, 0.01164974f, -0.04081894f, -0.02219037f, 0.00009235f, -0.02141618f, 
    -0.03587343f, 0.03144890f, 0.00524691f, -0.03335259f, -0.00835326f, 0.00315770f, -0.00945847f, 0.04170662f, 
    -0.04350455f, -0.03983468f, 0.03774857f, 0.00204593f, 0.00379558f, 0.01622528f, 0.01614721f, 0.01206168f, 
    -0.03701208f, 0.02015544f, -0.02805100f, -0.00625752f, 0.01887999f, 0.02737465f, -0.05775302f, 0.01935264f, 
    -0.03794818f, -0.01198661f, -0.01500305f, -0.04524628f, -0.02430387f, -0.00376415f, -0.00413272f, -0.00092456f, 
    0.02499417f, -0.00281435f, -0.00386769f, -0.00657647f, -0.00526840f, -0.04360287f, -0.03681386f, -0.02019738f, 
    -0.04564211f, -0.03290832f, 0.03876308f, -0.02344643f, 0.01169338f, 0.01557374f, -0.00539705f, 0.02476926f, 
    -0.18685648f, -0.07811972f, -0.22102776f, -0.13069184f, 0.04749641f, 0.20721512f, 0.03634415f, 0.15491918f, 
    -0.07230294f, 0.02409795f, -0.01596806f, 0.00086039f, 0.22844487f, -0.09386264f, -0.05443403f, -0.05892840f, 
    0.02951819f, -0.04199839f, 0.03448123f, -0.15790088f, 0.01856008f, 0.12597494f, 0.07145281f, -0.01437900f, 
    0.00934527f, 0.02220837f, 0.05532893f, 0.31946519f, 0.14658567f, -0.15572961f, -0.05255555f, -0.06231435f, 
    -0.01027134f, 0.06620869f, -0.09530899f, 0.10370047f, -0.34266096f, -0.22404225f, -0.12156484f, -0.01388584f, 
    0.18467502f, 0.00383617f, -0.05338791f, 0.14339109f, -0.10288315f, 0.29078087f, -0.02495309f, 0.11201682f, 
    -0.00459203f, 0.02054620f, -0.12231603f, 0.15883215f, 0.03953092f, 0.03632334f, 0.11386187f, 0.01827431f, 
    0.07848114f, -0.11859971f, 0.06591042f, -0.09354301f, 0.10510001f, 0.13965432f, -0.21673453f, 0.27565101f, 
    -0.22103205f, -0.17049378f, -0.07591736f, 0.29405352f, 0.07704408f, 0.10948914f, -0.13767089f, -0.10311823f, 
    -0.21594980f, -0.28710452f, 0.12514736f, 0.11830987f, 0.31206033f, 0.12661789f, 0.02262935f, -0.14284995f, 
    -0.01037849f, 0.04160421f, -0.05307058f, -0.08249539f, 0.00097498f, 0.22162248f, 0.00753765f, -0.04153769f, 
    -0.13937236f, 0.19601703f, 0.09140411f, 0.01968914f, -0.18646903f, 0.17588080f, -0.03247098f, 0.13161346f, 
    -0.04117527f, -0.08332544f, -0.18442072f, 0.02765188f, -0.01793141f, -0.07729145f, -0.01074680f, 0.06603799f, 
    0.11404040f, -0.21532165f, 0.03036357f, 0.08461758f, 0.30718574f, -0.06216357f, -0.18415755f, 0.10475820f, 
    0.03613960f, -0.02940482f, -0.00240164f, 0.04732523f, 0.07590288f, 0.37330654f, 0.16275343f, 0.01208800f, 
    0.22048055f, 0.02601500f, -0.14704083f, -0.05263099f, -0.04212204f, 0.23499665f, 0.23945224f, 0.05616254f, 
    -0.29879799f, 0.24078362f, -0.01810591f, 0.04491505f, 0.07744084f, 0.01030476f, 0.04264749f, 0.04335057f, 
    -0.02130260f, -0.17263718f, -0.11717081f, -0.03216651f, 0.00173261f, -0.13520384f, 0.11078470f, -0.00840236f, 
    -0.00376712f, -0.32639885f, -0.09745194f, 0.07725483f, 0.09718011f, 0.18733299f, -0.00684570f, -0.08983868f, 
    -0.03486616f, -0.02877738f, 0.14829428f, -0.15769775f, 0.02846985f, 0.09195019f, -0.20666803f, 0.02285513f, 
    -0.07582328f, 0.11170312f, 0.01368780f, 0.35650247f, -0.22461221f, 0.09901132f, 0.10539731f, 0.01172460f, 
    0.04122684f, -0.08884051f, 0.15309669f, 0.05195689f, -0.19353506f, 0.05096049f, -0.05687597f, -0.11819780f, 
    0.01760443f, -0.12529948f, 0.17308573f, 0.13808286f, 0.14946540f, 0.16596079f, 0.07263842f, -0.09563414f, 
    -0.03224415f, 0.10955910f, -0.03974648f, -0.00861209f, -0.16470101f, -0.16496699f, 0.04451349f, 0.01551431f, 
    -0.07351527f, 0.06419987f, 0.17696482f, 0.14906852f, 0.02335453f, -0.20799609f, -0.04608469f, 0.24928847f, 
    0.02413128f, -0.11475410f, 0.04556928f, -0.08175672f, 0.16420642f, 0.09041794f, 0.12213977f, 0.27089679f, 
    0.18419191f, 0.10427777f, 0.01950248f, -0.08819316f, -0.23929241f, 0.15074685f, -0.00538626f, 0.10753446f, 
    -0.03808014f, -0.01748885f, -0.05408974f, -0.02955477f, 0.16278535f, -0.00044794f, 0.07175967f, 0.09619857f, 
    -0.01688895f, -0.02145645f, 0.00499479f, -0.11774395f, -0.09001578f, 0.05200687f, 0.05070018f, 0.01112435f, 
    -0.25176302f, 0.14576258f, 0.28079411f, -0.07161763f, -0.03433168f, -0.06038805f, 0.05511506f, -0.13944510f, 
    0.08827174f, 0.15226339f, -0.10998240f, -0.07819212f, -0.26242471f, 0.08602219f, 0.24429370f, -0.00062732f, 
    0.15193795f, -0.13872699f, 0.05906845f, -0.19821252f, -0.28876752f, -0.42066064f, -0.11152245f, 0.33523303f, 
    0.10975535f, 0.03910000f, 0.14734702f, 0.10697957f, 0.09253155f, 0.03885047f, 0.07169144f, 0.02613441f, 
    -0.03409038f, 0.26160660f, -0.09941006f, -0.04107428f, -0.02893836f, -0.04858086f, -0.07409818f, 0.06822807f, 
    0.04306015f, 0.02409182f, -0.07291141f, -0.06240055f, -0.22788613f, 0.16359271f, 0.06513465f, 0.00236349f, 
    0.18449308f, 0.05898104f, -0.09105902f, -0.11749846f, 0.14346676f, 0.17208271f, 0.10678755f, -0.09774825f, 
    -0.21915412f, -0.07268677f, 0.01576087f, 0.20226450f, -0.04830150f, 0.04388961f, 0.10642489f, 0.06970048f, 
    -0.01121766f, 0.05244641f, -0.27321222f, 0.14233349f, 0.02368750f, 0.07648673f, -0.02702835f, 0.00532616f, 
    -0.04368226f, 0.05637530f, -0.22595197f, -0.20086519f, 0.00912048f, 0.08248413f, 0.09672733f, 0.03361044f, 
    -0.00864253f, -0.04948375f, 0.01701858f, 0.21269694f, 0.26804626f, 0.02742909f, -0.10709087f, -0.26723865f, 
    -0.01469242f, -0.04838402f, 0.03601994f, -0.01084090f, -0.13323700f, -0.26905265f, 0.00131220f, 0.27278033f, 
    0.04575554f, 0.03184922f, 0.07627130f, 0.09286728f, 0.00483872f, 0.00763689f, -0.07439688f, -0.06258097f, 
    0.03540525f, -0.04597206f, 0.13785221f, -0.03912768f, 0.00101098f, 0.04646230f, -0.03596662f, 0.23321167f, 
    0.04164758f, 0.01755615f, -0.17283987f, -0.05866262f, 0.03479809f, 0.22624916f, 0.11017366f, -0.11101563f, 
    -0.09595469f, 0.00388172f, 0.06292617f, -0.00716766f, -0.05442690f, 0.01637375f, -0.08666838f, -0.08080135f, 
    -0.17064476f, -0.21676098f, -0.11056679f, 0.16617481f, 0.07434330f, 0.07840633f, 0.08961771f, 0.01372638f, 
    0.03510477f, 0.05001343f, -0.10622430f, 0.09214365f, 0.07682402f, -0.02674767f, 0.05060935f, -0.07709084f, 
    0.05982274f, -0.04431196f, -0.05615795f, 0.21790108f, -0.14518557f, 0.03820362f, -0.02025766f, 0.02613750f, 
    0.11791378f, -0.03726630f, 0.16268027f, 0.24938098f, 0.41267321f, 0.15245375f, -0.14287710f, -0.09558395f, 
    -0.09075165f, -0.06202295f, 0.15483482f, -0.16609980f, 0.09476046f, -0.04066302f, -0.01996688f, 0.20243955f, 
    -0.07426573f, 0.02679465f, -0.00692259f, 0.03029590f, 0.07341987f, -0.02247019f, -0.24054587f, 0.27796000f, 
    0.18896618f, 0.16068324f, 0.03941390f, -0.15527618f, -0.08360767f, -0.16087985f, 0.08285905f, -0.22393762f, 
    0.07562638f, 0.19386844f, 0.07464626f, -0.01586919f, -0.00594323f, -0.03697217f, -0.05393238f, 0.26007533f, 
    -0.01316422f, 0.18228717f, 0.03518251f, 0.11220780f, -0.08037078f, 0.01826607f, 0.06542388f, 0.01414517f, 
    -0.05155720f, -0.25580931f, 0.08102252f, 0.22902629f, 0.08264378f, -0.05478246f, -0.11508993f, 0.00515301f, 
    -0.03298084f, -0.01817907f, 0.09741594f, 0.07437170f, 0.00817250f, -0.10288867f, 0.10090712f, -0.00777326f, 
    0.05053080f, -0.07479912f, -0.20964192f, -0.04022012f, 0.00533834f, -0.02151700f, 0.06771975f, -0.00139363f, 
    -0.06179886f, -0.11305784f, -0.03044427f, 0.01743362f, 0.17842241f, -0.03160680f, 0.00059792f, 0.04817095f, 
    -0.13246539f, 0.09298664f, -0.05018862f, -0.01315617f, -0.12994081f, -0.17742544f, -0.17518248f, -0.12770912f, 
    0.01026139f, 0.02016858f, -0.08425322f, -0.08107461f, -0.08839799f, 0.02050092f, 0.27709177f, -0.06095387f, 
    -0.11244181f, -0.03061153f, 0.03395263f, 0.16510449f, 0.01087932f, 0.06118164f, 0.07096285f, -0.12174410f, 
    -0.10603308f, -0.02912147f, 0.02688927f, -0.01087739f, 0.06656270f, 0.10388172f, -0.04807878f, 0.23437402f, 
    0.06645671f, -0.04626701f, -0.12900448f, 0.09049542f, -0.11421184f, 0.06656767f, 0.07387123f, 0.06484884f, 
    0.16324349f, -0.02262842f, -0.09022874f, 0.08080779f, -0.05149793f, -0.03006728f, 0.01503721f, 0.08148956f, 
    0.18666971f, -0.09790680f, 0.24627405f, 0.02928168f, -0.08790945f, -0.10722764f, 0.01146693f, 0.00839647f, 
    0.06537619f, 0.07822299f, -0.06684724f, -0.05090953f, -0.19453365f, -0.09445827f, -0.03104536f, -0.18391581f, 
    0.01378943f, 0.03284638f, -0.05094330f, 0.08613552f, -0.18111147f, -0.12086238f, -0.05014025f, 0.00395319f, 
    0.07308070f, 0.03591079f, -0.04047818f, 0.06647108f, -0.27777272f, -0.35389224f, -0.19201675f, -0.02271914f, 
    0.10042161f, 0.00400874f, -0.01390889f, -0.15911213f, 0.03496864f, 0.13599494f, 0.21658389f, 0.10757899f, 
    -0.10184447f, -0.02674678f, -0.00455684f, 0.01354426f, -0.03954964f, -0.06909578f, 0.04520366f, -0.04868267f, 
    -0.09497184f, -0.21407835f, -0.06592295f, -0.14609335f, 0.14425866f, 0.06643005f, -0.08027955f, 0.28286812f, 
    0.12070487f, -0.04984675f, 0.04035083f, 0.04392070f, -0.07832715f, -0.01723615f, -0.04016752f, -0.01219212f, 
    0.05012333f, 0.02428263f, 0.00338167f, -0.02523412f, -0.01841192f, -0.03110247f, -0.06056108f, -0.05037383f, 
    -0.00608669f, 0.03647147f, -0.03549487f, -0.01785896f, -0.01672101f, 0.00860813f, -0.00290879f, -0.04039138f, 
    0.02141089f, -0.05868306f, -0.03060105f, 0.05505080f, 0.01005103f, -0.01316207f, 0.04304750f, -0.01714289f, 
    0.04304984f, -0.04287311f, 0.03589626f, -0.00503553f, 0.04096097f, -0.00074547f, -0.02629371f, 0.05111180f, 
    -0.00442999f, -0.04717013f, 0.02144322f, 0.02078612f, 0.00519329f, -0.00176273f, -0.01901345f, -0.01228170f, 
    0.03353927f, -0.03460125f, 0.04241234f, -0.05972656f, 0.02751370f, 0.02150566f, -0.01727244f, -0.00116922f, 
    -0.04447590f, 0.02556451f, -0.04456645f, -0.03202140f, -0.04674090f, 0.01520175f, -0.01916688f, -0.03678611f, 
    -0.04354671f, 0.00244340f, -0.01827553f, 0.03138251f, 0.05205009f, -0.05942771f, 0.02746669f, 0.04231767f, 
    -0.02726366f, -0.01446208f, 0.01059605f, 0.05338699f, 0.05284347f, 0.03051890f, 0.00849969f, 0.02009464f, 
    0.01715297f, 0.02154447f, 0.02162556f, -0.00832053f, 0.00748561f, 0.00462787f, -0.02819950f, -0.03876830f, 
    0.00010340f, 0.04136031f, -0.03137298f, -0.05801257f, -0.04879270f, -0.04719394f, 0.05676257f, 0.03637276f, 
    -0.06734513f, 0.03581610f, 0.00142472f, -0.06410950f, -0.05676627f, 0.02900095f, -0.05297216f, 0.00171002f, 
    0.03839414f, 0.02364239f, -0.00056312f, -0.01377679f, 0.00684698f, 0.04736779f, 0.04308149f, -0.05422958f, 
    0.00103280f, -0.03878303f, 0.04217781f, 0.03203471f, 0.01741677f, -0.03794473f, -0.02680517f, 0.01376845f, 
    -0.05467450f, -0.05885164f, 0.01107848f, -0.04259099f, 0.03343140f, -0.01730151f, 0.01689754f, 0.00823404f, 
    -0.03469896f, -0.02706891f, 0.03979599f, -0.01171587f, -0.02441178f, -0.05624746f, -0.01062067f, 0.03074030f, 
    -0.01153160f, 0.00267599f, 0.04906117f, -0.04016016f, 0.00303362f, 0.04081957f, -0.05430130f, -0.01389399f, 
    -0.05088455f, -0.00491643f, -0.04582356f, 0.01101487f, -0.03517972f, -0.06029207f, -0.04647447f, -0.02910209f, 
    -0.05194316f, -0.01288798f, -0.01394229f, 0.03081636f, -0.00423581f, -0.03935159f, -0.00806640f, -0.06085803f, 
    0.01144497f, -0.01947997f, 0.03223985f, -0.02729923f, 0.04368833f, -0.04466564f, -0.03990530f, -0.05676549f, 
    -0.03871993f, 0.00895100f, -0.00641974f, -0.05480233f, -0.04054691f, 0.04158494f, 0.01960477f, 0.01287587f, 
    -0.01214791f, -0.05604416f, 0.04391442f, -0.02345687f, 0.04757737f, -0.06640764f, -0.04797159f, -0.05647014f, 
    0.03167975f, 0.04885534f, -0.03297263f, -0.05332388f, -0.04690345f, -0.00435312f, -0.02609007f, -0.01607621f, 
    0.05381357f, 0.01795904f, -0.06001343f, -0.01398777f, 0.01188708f, 0.01470147f, 0.03767421f, 0.00996980f, 
    -0.05318362f, 0.05084352f, -0.04367784f, 0.04964481f, -0.05091625f, -0.04892533f, -0.02649062f, -0.04912846f, 
    -0.06142544f, 0.03107055f, 0.02644512f, 0.00889495f, -0.00646227f, 0.00327156f, -0.02343649f, -0.04251522f, 
    0.05051807f, 0.00839036f, -0.06394810f, 0.04131870f, -0.02528959f, -0.03538063f, -0.04506228f, -0.05779754f, 
    0.01300905f, -0.04433740f, -0.05300454f, -0.05586997f, -0.03263231f, -0.03404686f, 0.05843811f, -0.02430501f, 
    -0.02568865f, -0.02796270f, -0.01372202f, -0.02603790f, 0.00648602f, -0.04775565f, 0.03436216f, 0.03705607f, 
    0.02453768f, 0.03658914f, 0.00567127f, -0.03553163f, -0.01266433f, -0.00782277f, 0.00264254f, 0.04964216f, 
    0.00114098f, 0.04363666f, -0.06617245f, -0.04281067f, 0.00824452f, -0.02603845f, -0.03964114f, -0.02061171f, 
    -0.00497607f, 0.02363550f, 0.01860871f, 0.02080046f, -0.03102861f, 0.02664489f, 0.01655858f, 0.00237802f, 
    0.03546850f, -0.02797492f, 0.04579594f, -0.06477410f, -0.03466997f, 0.05382682f, -0.00522851f, 0.00933140f, 
    -0.00962531f, -0.03921195f, -0.05016692f, -0.01475550f, -0.00470862f, -0.05018331f, 0.02952533f, -0.03487253f, 
    -0.03290237f, -0.03598939f, -0.03306101f, 0.00599315f, -0.00496216f, -0.00263211f, 0.01081135f, -0.02819851f, 
    -0.02919857f, -0.02231433f, 0.04280982f, 0.04905539f, 0.04942710f, -0.02295115f, -0.01209491f, 0.03026962f, 
    -0.13140406f, -0.00422863f, -0.08742534f, 0.00991730f, 0.12522925f, 0.11530247f, 0.12614378f, -0.16572839f, 
    0.09411302f, 0.24982458f, -0.01691791f, 0.11036069f, 0.09998349f, 0.17058647f, -0.11843511f, 0.09186970f, 
    0.06558724f, -0.02900005f, -0.31119496f, -0.02603036f, -0.02618623f, -0.20203139f, 0.15352699f, 0.03203098f, 
    0.06296603f, -0.16309042f, 0.19065250f, 0.15811908f, 0.15747499f, -0.33779117f, 0.13039795f, -0.33316061f, 
    -0.02678166f, -0.26577502f, -0.01396559f, 0.19800101f, 0.05947783f, -0.10314263f, -0.10478543f, 0.15930195f, 
    0.08554201f, 0.04460751f, 0.08209959f, 0.06947234f, -0.02917944f, 0.00232650f, 0.04240349f, 0.04779632f, 
    -0.05726506f, -0.03925702f, 0.06267958f, 0.07816507f, -0.02101064f, 0.28590605f, 0.06942458f, 0.12978595f, 
    -0.03741672f, 0.11479314f, -0.05838964f, 0.17458259f, 0.03593184f, 0.02907785f, -0.13374215f, 0.21741909f, 
    0.28197190f, 0.17575689f, 0.16513859f, -0.00813665f, -0.16552052f, -0.15951172f, 0.03158140f, 0.00349023f, 
    0.14700061f, 0.10682385f, 0.02436184f, 0.00878293f, -0.03883208f, 0.14490932f, 0.11252767f, -0.06525132f, 
    0.05090012f, 0.11013010f, 0.08821490f, 0.09333561f, -0.06465968f, -0.07103727f, 0.15360932f, 0.08322968f, 
    0.13306037f, 0.09979258f, -0.14308237f, -0.31315303f, -0.06965389f, 0.04565701f, -0.00469684f, 0.18480244f, 
    0.00433867f, -0.15962383f, -0.04019149f, 0.08188865f, -0.15767530f, 0.05625581f, -0.07153253f, 0.01257298f, 
    0.01789833f, -0.06708429f, 0.06800813f, -0.01266946f, 0.25149313f, 0.18232389f, 0.01180029f, -0.05261718f, 
    -0.15902808f, 0.08120480f, 0.16783172f, 0.15030624f, 0.01210103f, 0.49860206f, 0.46641964f, -0.21500666f, 
    -0.07983343f, 0.06949333f, 0.01039616f, 0.10061891f, 0.07036422f, 0.05701417f, 0.30751225f, 0.12820257f, 
    0.00039461f, 0.02299048f, 0.17357759f, -0.01212320f, -0.04874058f, 0.17920989f, -0.14950930f, -0.12247607f, 
    -0.02854951f, 0.11195359f, 0.08707730f, 0.12582590f, 0.07013904f, -0.04784080f, 0.10432411f, 0.00376087f, 
    0.24139988f, 0.02743820f, 0.03881863f, 0.16313867f, 0.07736320f, -0.11172216f, -0.12607729f, -0.10520454f, 
    -0.01716703f, -0.00133245f, 0.00746103f, -0.09311337f, 0.02933992f, 0.04113799f, 0.07420581f, -0.05709607f, 
    0.22031021f, 0.11242811f, 0.14944732f, 0.26742473f, -0.15484457f, -0.14679125f, 0.11231186f, 0.01563957f, 
    0.04807952f, 0.04394295f, 0.01943574f, 0.06846670f, -0.36653224f, 0.04675755f, -0.02024377f, 0.10067546f, 
    -0.11215746f, -0.03598750f, 0.11000917f, 0.13617188f, -0.06786834f, 0.01910778f, -0.00038825f, 0.09698002f, 
    0.11828081f, 0.08491658f, -0.01000016f, -0.21080241f, 0.05556786f, -0.08647108f, 0.09181409f, -0.10138244f, 
    0.02160496f, -0.05841197f, 0.15068373f, -0.17620808f, 0.02016434f, -0.03726379f, 0.14836690f, 0.08302967f, 
    -0.00696186f, 0.22612636f, -0.05401027f, 0.10568251f, 0.08264111f, -0.03710625f, 0.15718184f, 0.28323478f, 
    0.10335293f, -0.08971492f, 0.01399688f, -0.08207535f, 0.08023063f, 0.13717051f, 0.25779375f, -0.08281590f, 
    0.12744085f, -0.02168793f, 0.18550101f, -0.05249140f, -0.07861929f, -0.03395712f, 0.19859786f, 0.13339885f, 
    -0.04158553f, 0.20069970f, -0.01921905f, -0.05995358f, -0.16697189f, -0.10399012f, 0.08742131f, -0.00881210f, 
    0.09041404f, 0.10672924f, 0.17549735f, -0.13283773f, 0.17951034f, 0.10438701f, 0.02749782f, -0.06282488f, 
    -0.05405766f, -0.00145069f, 0.19488706f, 0.05008925f, 0.05423533f, 0.21019156f, 0.01245400f, 0.03423371f, 
    -0.16395226f, -0.02263852f, -0.03486589f, 0.06780452f, 0.17678423f, 0.07624859f, 0.07655188f, 0.06014279f, 
    0.09112054f, 0.16321906f, 0.17616449f, 0.02096134f, 0.01871379f, -0.17159884f, -0.20960893f, 0.05551072f, 
    0.14439888f, 0.01317176f, 0.11781272f, -0.11576126f, 0.19767709f, -0.05891180f, 0.02326185f, -0.04788934f, 
    -0.11658058f, -0.03150426f, 0.01930195f, 0.16357547f, -0.05262189f, 0.03900779f, 0.06793775f, 0.10961169f, 
    0.09754281f, -0.00555570f, 0.09910620f, -0.12896281f, -0.03431924f, 0.09114741f, 0.12415169f, 0.02237681f, 
    -0.12242395f, 0.02859710f, -0.24767132f, 0.07840844f, -0.05116989f, 0.03079163f, 0.02021676f, 0.12732798f, 
    0.11267939f, -0.04737498f, 0.09635723f, -0.13969965f, 0.16398197f, -0.18340100f, 0.10762215f, 0.04808577f, 
    -0.04542025f, -0.02339425f, 0.15347452f, 0.02160484f, 0.05906978f, -0.12608376f, -0.05106966f, -0.04683911f, 
    0.06147782f, -0.09507672f, 0.02709433f, 0.01797167f, -0.08690061f, -0.01557190f, 0.05986667f, -0.18176518f, 
    -0.12607551f, 0.06088388f, 0.02254904f, 0.12133795f, -0.02297208f, 0.16293627f, 0.02416985f, 0.08579470f, 
    -0.10803816f, 0.07646044f, -0.03388037f, -0.01586033f, 0.00483890f, 0.20465475f, 0.04230736f, -0.07034959f, 
    -0.06507324f, -0.08304375f, 0.00106075f, -0.05373100f, 0.00005041f, 0.05095386f, 0.17660400f, -0.12407918f, 
    0.01353219f, -0.05541949f, -0.12332414f, -0.13529463f, 0.00339359f, -0.11205316f, -0.01315006f, -0.07444564f, 
    -0.09902135f, -0.07044116f, -0.10466810f, 0.07620642f, 0.12983105f, 0.06775330f, 0.17251630f, 0.06125383f, 
    0.06650839f, 0.06438088f, 0.26974577f, -0.10973527f, -0.09680143f, -0.02907641f, 0.15908967f, 0.15648815f, 
    -0.05672392f, 0.16964431f, 0.01728480f, 0.05412645f, -0.07404228f, -0.06065293f, 0.06007031f, 0.01154677f, 
    0.15661225f, 0.17033131f, 0.05078955f, 0.08348437f, -0.03750646f, 0.07969994f, -0.05889663f, 0.15693316f, 
    0.10888161f, 0.08818520f, -0.00599873f, 0.12675256f, -0.06015029f, -0.31071851f, 0.14718725f, 0.14156488f, 
    0.07419747f, -0.02495925f, 0.07020930f, -0.05014378f, 0.08973200f, -0.01333675f, 0.08676897f, -0.04512129f, 
    0.08207124f, 0.00556937f, 0.04327961f, 0.01880204f, 0.08421575f, -0.03426354f, 0.07376542f, 0.25537983f, 
    -0.03081395f, -0.16913965f, -0.17930445f, 0.21591462f, 0.03403237f, -0.08207408f, -0.21306682f, 0.04816635f, 
    -0.09410549f, -0.23160404f, -0.12438339f, -0.04515941f, 0.21672393f, 0.11513124f, -0.13934065f, 0.12165188f, 
    -0.02518878f, -0.13409102f, 0.11771897f, 0.07409068f, -0.00593147f, -0.03112933f, 0.01802054f, 0.07104392f, 
    -0.03937832f, -0.01641785f, -0.00949300f, 0.21497253f, 0.11275129f, 0.10640466f, 0.12586324f, 0.05960365f, 
    0.06058726f, 0.06898488f, -0.07221548f, 0.07353893f, 0.03650397f, 0.11091071f, 0.02913754f, 0.02811698f, 
    -0.07824819f, -0.04615636f, -0.02561190f, 0.05633789f, -0.02423584f, -0.05850041f, 0.06574107f, -0.22783239f, 
    -0.02276515f, 0.01085703f, 0.00498483f, 0.11505886f, 0.29109263f, -0.04042707f, 0.10161315f, 0.04163423f, 
    0.03473556f, -0.05883656f, -0.06003129f, 0.00901216f, 0.09316746f, 0.17281532f, 0.04894965f, -0.13217646f, 
    -0.07993316f, -0.23617163f, 0.07708803f, -0.11752561f, -0.08406467f, -0.06896558f, -0.19957756f, 0.01647323f, 
    0.00643340f, 0.03850266f, 0.09082078f, 0.05103874f, 0.07090912f, -0.04097432f, -0.03037386f, -0.00265235f, 
    0.01910358f, 0.05625217f, -0.03283269f, 0.05556086f, 0.01012754f, -0.19649102f, -0.05910607f, 0.10319054f, 
    -0.08796750f, -0.06980919f, -0.11996298f, -0.20465940f, -0.13959965f, -0.01085559f, 0.08917928f, -0.00687366f, 
    0.27601969f, -0.01938343f, 0.00378199f, -0.10952765f, 0.15370288f, -0.04631152f, 0.06014129f, 0.02907909f, 
    0.02922431f, 0.05184505f, 0.10506114f, 0.08821696f, -0.02768977f, 0.00040275f, -0.11008519f, 0.02120262f, 
    0.06039761f, -0.13926072f, -0.07812200f, 0.14187823f, -0.18674037f, -0.00399034f, -0.04062085f, 0.03107786f, 
    0.12947856f, 0.02986390f, 0.21784605f, -0.38949400f, 0.12371562f, -0.15409036f, 0.00861416f, -0.11830311f, 
    -0.05944878f, 0.05322924f, -0.13617525f, -0.01722882f, -0.24691448f, 0.12768102f, 0.04435966f, 0.20173460f, 
    -0.00567506f, 0.14288595f, 0.27991208f, 0.05374620f, -0.08156836f, 0.28434220f, 0.08433553f, -0.04563452f, 
    0.15730043f, 0.11046077f, 0.01337369f, 0.18085955f, 0.05545643f, 0.01391905f, -0.07513580f, 0.18545254f, 
    0.12943347f, 0.12517232f, 0.02117101f, -0.03731393f, 0.11372977f, -0.13768661f, 0.03728670f, -0.02807963f, 
    -0.07986549f, -0.09607831f, -0.05514274f, 0.05957846f, -0.08948164f, 0.02447304f, 0.01474445f, -0.08167969f, 
    -0.01565341f, 0.03023142f, 0.01522035f, 0.04076234f, -0.01914266f, -0.03501343f, 0.01730623f, -0.02620910f, 
    -0.01727170f, 0.00830971f, -0.00246233f, 0.02729348f, -0.01128796f, -0.04458387f, -0.05853681f, -0.06123333f, 
    -0.01670564f, -0.02887515f, -0.02600773f, -0.01316040f, 0.02561538f, -0.00051731f, -0.03689874f, -0.03393293f, 
    -0.06566593f, 0.01976221f, -0.02741958f, -0.04334209f, -0.00693176f, 0.00284665f, 0.04181900f, 0.01902905f, 
    -0.03486254f, 0.03910621f, 0.02592069f, 0.03742152f, -0.01234065f, 0.01389995f, -0.05922738f, 0.01543178f, 
    0.03054104f, 0.03066161f, 0.04322850f, 0.03834216f, -0.00972476f, 0.01061156f, -0.01182413f, -0.04911460f, 
    0.03768495f, -0.03619755f, 0.04195191f, -0.04588736f, -0.02874525f, -0.06449885f, -0.03768433f, 0.05251894f, 
    -0.01839023f, 0.04908314f, 0.02332728f, -0.05640788f, 0.00103363f, -0.03852639f, -0.04347353f, 0.01290830f, 
    0.02856535f, -0.05678385f, 0.03699436f, -0.00820687f, 0.00856006f, -0.00375927f, 0.01315828f, -0.05450017f, 
    0.03729125f, 0.03521108f, 0.01948010f, -0.06768376f, -0.03736182f, -0.05837894f, -0.03359603f, 0.01632777f, 
    -0.00350611f, 0.04141578f, 0.04077944f, 0.03193733f, 0.05011410f, 0.04564561f, -0.04976916f, -0.04277587f, 
    -0.03863348f, -0.04186032f, 0.03723084f, -0.00452786f, 0.00608574f, 0.00299029f, -0.02313607f, -0.03221896f, 
    0.01333491f, 0.00708504f, 0.03688598f, 0.01198860f, -0.05545313f, -0.05307120f, -0.05491330f, -0.06954720f, 
    0.05000026f, 0.03848027f, -0.01216678f, -0.04184349f, 0.04408124f, -0.05683213f, 0.03270130f, -0.01329606f, 
    -0.02680478f, -0.01935049f, 0.01695095f, -0.05065003f, 0.05111853f, 0.00243854f, -0.03141074f, 0.00836357f, 
    0.00945732f, -0.01508701f, -0.06009446f, -0.04056327f, -0.03957987f, -0.01595569f, -0.05459542f, -0.04291612f, 
    0.02610805f, -0.02219680f, 0.03316597f, -0.04106922f, -0.00055540f, 0.00407466f, 0.02607097f, -0.05706775f, 
    0.02124338f, 0.04042393f, -0.00056826f, -0.06057058f, -0.04683162f, 0.01471905f, -0.06147496f, -0.06115263f, 
    0.05665258f, -0.03153601f, -0.02948260f, 0.03162460f, 0.03051320f, 0.04763664f, 0.00993253f, -0.05135835f, 
    0.00841054f, -0.05367852f, -0.02075551f, -0.03351326f, -0.00053732f, 0.05434457f, 0.04208858f, -0.00281932f, 
    -0.05102055f, 0.01777584f, 0.03055021f, 0.02457950f, -0.04881438f, -0.03420967f, 0.03741280f, -0.03886461f, 
    -0.02437056f, 0.03101235f, -0.02604742f, 0.00875360f, -0.05079158f, -0.00841331f, 0.01675335f, 0.00255872f, 
    -0.01450932f, -0.00372922f, -0.02561807f, -0.05178979f, 0.03082759f, 0.03823199f, -0.06471021f, -0.02337316f, 
    0.01003012f, -0.05846496f, 0.02643545f, 0.00780542f, -0.02306366f, -0.02469094f, 0.03390329f, -0.01578864f, 
    -0.05450999f, 0.01040164f, 0.00185245f, -0.04811110f, -0.05701901f, 0.00943390f, 0.01705664f, 0.01050362f, 
    -0.00447331f, 0.00686126f, -0.00425538f, -0.05897127f, -0.00953704f, -0.00646916f, 0.04114794f, 0.04495524f, 
    0.01652116f, -0.06380907f, 0.01621628f, -0.06203774f, -0.00941915f, 0.03446091f, -0.06439374f, 0.01579960f, 
    -0.01273633f, 0.00321929f, -0.00707800f, -0.00110379f, 0.02475498f, -0.01470605f, 0.04979220f, 0.04544732f, 
    -0.06163353f, 0.02451641f, 0.03337561f, 0.03866926f, 0.00666474f, 0.02421586f, -0.00431988f, 0.02907978f, 
    -0.04995504f, -0.04404233f, 0.00068022f, -0.06255586f, -0.04018444f, -0.04330553f, 0.04110237f, 0.01572931f, 
    -0.05442004f, -0.03527576f, 0.02147060f, -0.03674253f, 0.01078708f, -0.04870148f, 0.01773644f, 0.04560230f, 
    0.02015627f, -0.01652045f, -0.01839931f, 0.03210090f, -0.02805367f, -0.05335733f, 0.04428144f, -0.02172031f, 
    -0.00795758f, -0.01845466f, 0.02341810f, 0.01987579f, 0.01192494f, -0.04164888f, 0.02556445f, 0.04562427f, 
    0.01847461f, -0.00329257f, 0.04051214f, -0.03890694f, -0.06266822f, -0.04802572f, 0.01346820f, 0.00900101f, 
    -0.03898900f, -0.05652266f, -0.03497917f, -0.02605692f, 0.01067015f, -0.03491638f, -0.01500219f, -0.01150161f, 
    -0.02900136f, -0.06128235f, -0.02937855f, -0.02095277f, -0.02124432f, 0.04733703f, 0.02621471f, -0.01948074f, 
    0.13824135f, 0.13552500f, -0.09445737f, -0.15911043f, -0.02723924f, -0.00720636f, 0.09184586f, 0.17822880f, 
    0.09225231f, -0.05503849f, -0.03316013f, 0.02102867f, -0.07671715f, -0.03492643f, -0.03316899f, -0.09536219f, 
    0.13417388f, 0.00803245f, -0.09027773f, 0.09248423f, 0.01785124f, 0.01970025f, 0.21975987f, -0.20472115f, 
    0.29435989f, 0.00617876f, 0.03072916f, -0.34117082f, -0.45985988f, 0.04052646f, 0.13490638f, -0.03117575f, 
    -0.25001517f, -0.05724011f, -0.02181495f, 0.14607419f, -0.18979767f, 0.13565162f, 0.12182690f, -0.13001625f, 
    0.00837394f, 0.01518224f, -0.00657549f, -0.07706894f, -0.16730314f, -0.09057795f, 0.05003869f, 0.20645522f, 
    0.07389498f, 0.08384196f, -0.08333955f, 0.03999383f, 0.17539248f, -0.02205634f, 0.01521276f, -0.31455630f, 
    -0.11541609f, 0.00942874f, 0.02445711f, 0.02630926f, -0.06570110f, -0.05403600f, 0.08751959f, 0.13307302f, 
    -0.07368063f, 0.02302512f, -0.16044420f, -0.11552729f, -0.02775108f, 0.20498118f, 0.06263299f, -0.13013826f, 
    0.18459217f, 0.05750775f, 0.23525266f, -0.05924103f, 0.13081986f, 0.05007765f, 0.18731400f, 0.04159568f, 
    -0.06873686f, -0.21435256f, -0.08620150f, 0.18161562f, 0.15199518f, 0.05943146f, 0.01274948f, 0.05989799f, 
    -0.04949486f, 0.05945861f, 0.15618372f, 0.09015401f, 0.13936515f, 0.08948365f, 0.09023182f, 0.04430635f, 
    0.08784875f, 0.08992568f, -0.12574309f, 0.01029548f, -0.02897401f, -0.10726988f, 0.09375422f, 0.06116970f, 
    0.15988773f, 0.17665467f, -0.08808892f, -0.04748180f, -0.18118683f, -0.17447270f, 0.01344121f, 0.16324416f, 
    0.07675444f, -0.02012151f, 0.08843517f, -0.03386451f, 0.09760306f, 0.08362594f, 0.19686082f, 0.24617863f, 
    -0.00568498f, 0.15022282f, -0.16358067f, 0.08839957f, -0.00966069f, 0.06825811f, -0.01317225f, -0.04523489f, 
    0.27013069f, -0.28241035f, -0.01563157f, -0.12842356f, -0.11291461f, 0.08572470f, -0.12132682f, -0.10762763f, 
    -0.05746908f, -0.18433832f, 0.19051221f, 0.19504309f, 0.05078427f, -0.13251175f, -0.10936186f, 0.10324779f, 
    0.05763330f, -0.05469751f, 0.22577807f, -0.02858895f, 0.02767872f, 0.12825513f, 0.17323382f, -0.07267245f, 
    0.05615971f, -0.19725519f, -0.18657187f, -0.13982968f, 0.16519825f, 0.14776571f, -0.05855910f, 0.04078709f, 
    -0.15518056f, 0.08920560f, 0.12478048f, -0.02904473f, -0.01240208f, -0.04052689f, -0.04502116f, -0.07288182f, 
    -0.01078799f, -0.06118101f, -0.02044041f, -0.33575851f, 0.01708348f, 0.09092112f, 0.05208397f, 0.04377218f, 
    -0.00964541f, 0.00754980f, -0.01130711f, 0.00244941f, 0.06050095f, 0.08878100f, 0.11851784f, -0.10848067f, 
    -0.10729878f, -0.10677834f, 0.10319687f, -0.00266001f, -0.03469139f, -0.07537138f, -0.12048850f, -0.14351575f, 
    -0.01149998f, -0.00647091f, 0.09282058f, 0.01354689f, -0.01935215f, -0.05827791f, -0.15273869f, 0.02319193f, 
    0.06060090f, -0.03106400f, -0.05441507f, 0.14114217f, -0.02032214f, 0.04826699f, 0.02070936f, 0.09297523f, 
    -0.00509489f, 0.15923589f, -0.02592548f, -0.06879491f, -0.04148419f, -0.04149480f, 0.04289460f, 0.14524370f, 
    -0.05394434f, -0.11765458f, -0.09312709f, 0.02571243f, 0.10266058f, 0.01304747f, 0.06747434f, -0.14904882f, 
    0.15244117f, -0.33224896f, -0.07064249f, -0.07268905f, 0.10621279f, 0.06631413f, -0.00843122f, 0.03761157f, 
    0.04995247f, 0.00368527f, -0.29826039f, 0.08020069f, -0.00704202f, 0.06254019f, -0.13553070f, 0.01440574f, 
    0.06067267f, -0.00027550f, 0.10280903f, -0.28178599f, -0.10653140f, -0.04514941f, -0.19488241f, -0.16256382f, 
    -0.16145034f, 0.03106366f, -0.07540675f, -0.20374967f, 0.01968806f, 0.13049442f, 0.10023648f, -0.03825171f, 
    0.10589563f, 0.13548121f, 0.14833103f, 0.01103133f, -0.06390925f, -0.09328001f, -0.01866527f, -0.16158271f, 
    0.02683968f, 0.22918044f, 0.02233058f, 0.00761312f, -0.07276995f, -0.09981284f, -0.11518770f, 0.14605202f, 
    -0.00279029f, 0.15439594f, -0.03068940f, 0.14171889f, -0.09200793f, -0.02123597f, -0.06727408f, -0.05689935f, 
    0.05511828f, -0.09888464f, 0.00499351f, -0.08455803f, -0.00232938f, -0.01670341f, 0.11953306f, -0.03018737f, 
    -0.11594973f, 0.02783515f, -0.02122003f, -0.07133120f, -0.06288290f, 0.25331396f, -0.08705854f, -0.02492337f, 
    -0.00552691f, 0.16724244f, -0.00715428f, 0.06131497f, 0.00276979f, 0.00983797f, -0.04159620f, 0.00966526f, 
    -0.04453002f, 0.05128796f, -0.13865760f, 0.13712922f, -0.09536001f, -0.05105403f, 0.15753227f, -0.06285033f, 
    0.30330333f, -0.07711884f, 0.06548607f, 0.12966630f, -0.25884607f, 0.19358781f, -0.10020852f, 0.18027982f, 
    0.04779722f, -0.08575509f, -0.06803812f, 0.06225129f, 0.32246605f, 0.13284101f, -0.06653656f, -0.24301264f, 
    -0.07413477f, -0.07634347f, -0.05629977f, 0.07041477f, -0.04213480f, 0.04692540f, -0.05462293f, -0.03436916f, 
    0.03129459f, -0.08928949f, -0.02643009f, -0.16968897f, 0.03500969f, 0.02079524f, -0.34404388f, -0.04265328f, 
    0.06666456f, 0.12507443f, 0.04339359f, 0.04607056f, 0.06278519f, -0.08017858f, -0.02910516f, 0.26061639f, 
    0.18657215f, 0.20116572f, 0.04632545f, -0.17478499f, 0.04960990f, 0.05078071f, -0.01678825f, 0.01769415f, 
    0.41401315f, 0.20922402f, 0.24722002f, 0.00535661f, -0.16927907f, 0.08807714f, 0.16617171f, -0.04727510f, 
    0.12515941f, -0.05213621f, 0.11930396f, -0.23079143f, -0.08101976f, -0.03515188f, -0.02850555f, 0.04200696f, 
    -0.01213219f, -0.03783489f, 0.15209775f, -0.18025108f, -0.00738553f, -0.08109262f, 0.13590497f, 0.13452850f, 
    -0.02197018f, -0.13198869f, -0.18510334f, -0.29482326f, -0.31412026f, -0.23038329f, 0.10286646f, 0.01037900f, 
    0.12732214f, -0.17410950f, -0.17307816f, -0.02451687f, 0.08450333f, 0.25317678f, -0.19151022f, 0.06450449f, 
    0.04524501f, -0.23354924f, -0.08054063f, -0.11704879f, -0.06869663f, 0.41303095f, 0.36675403f, 0.10162335f, 
    -0.12210540f, 0.03887014f, -0.12906632f, 0.12254152f, 0.02188835f, -0.02779338f, 0.35944429f, 0.25778189f, 
    0.15013498f, -0.00918230f, -0.08236385f, -0.01250854f, 0.00916696f, 0.04552165f, -0.01022791f, 0.06355342f, 
    -0.10852908f, -0.18153264f, 0.06364013f, 0.09028499f, 0.17207183f, -0.16402778f, -0.08466771f, -0.02080964f, 
    0.12439997f, 0.10568228f, 0.22363997f, 0.10015114f, -0.00403333f, 0.08998202f, 0.04187616f, -0.00772567f, 
    0.00336457f, 0.01171801f, 0.05578856f, -0.26157147f, -0.08812559f, 0.09302695f, 0.06182736f, 0.00135277f, 
    -0.11170134f, -0.04043447f, -0.09837272f, -0.10451656f, -0.17125350f, -0.07069147f, -0.00673559f, -0.07533646f, 
    0.06395365f, -0.11389143f, 0.04339956f, 0.12383457f, -0.07936082f, -0.12984788f, 0.06721570f, -0.02195484f, 
    -0.04892473f, 0.05692940f, -0.04980149f, 0.03666542f, -0.01827038f, -0.02754681f, -0.12030453f, -0.07107306f, 
    -0.04258370f, -0.21389674f, -0.20153378f, -0.16708989f, -0.07254318f, -0.25513715f, -0.16227642f, 0.10203871f, 
    -0.24459733f, 0.03677128f, 0.00288731f, 0.12055087f, -0.18676646f, -0.00701754f, -0.03858378f, -0.04250824f, 
    -0.08388001f, -0.00408884f, 0.14495608f, -0.03626341f, 0.05086185f, -0.07099972f, 0.06478368f, 0.15256141f, 
    0.02998937f, -0.11857561f, 0.13901973f, 0.02833128f, 0.01204882f, 0.08298200f, -0.11167520f, -0.02580928f, 
    0.16337585f, 0.21783347f, -0.23223111f, 0.00991279f, -0.01258137f, 0.08396354f, 0.00765080f, -0.13146262f, 
    -0.02372758f, -0.12700981f, -0.00740754f, -0.02222079f, -0.02414414f, -0.08195452f, 0.01275619f, 0.20687790f, 
    -0.11091005f, -0.11568116f, -0.06260342f, 0.08261483f, -0.11942700f, 0.07793892f, -0.02161498f, 0.12387460f, 
    -0.21471298f, -0.06635561f, -0.06611121f, -0.16333815f, -0.08804727f, 0.30460629f, -0.05929012f, 0.00729521f, 
    -0.10621954f, -0.01047324f, -0.12664354f, 0.04543135f, 0.35202071f, 0.14674667f, 0.08084204f, 0.02711572f, 
    0.06050734f, 0.02892161f, 0.09922378f, 0.01651606f, -0.03588282f, -0.25020537f, -0.19496389f, -0.00357252f, 
    0.04638233f, 0.12985055f, -0.06351241f, -0.08927944f, -0.14027834f, -0.12924272f, 0.18796691f, -0.06206074f, 
    -0.03767363f, 0.13371797f, 0.21328767f, 0.04010647f, -0.01537795f, -0.11464579f, 0.04377989f, -0.06165310f, 
    0.02401731f, 0.04845973f, 0.03967769f, 0.11486264f, -0.06068636f, -0.12236147f, -0.08462929f, -0.16048051f, 
    -0.19232136f, -0.10776147f, -0.04051750f, 0.02250366f, 0.04514386f, 0.20664154f, 0.10826589f, 0.02435824f, 
    0.14112863f, -0.16542226f, 0.11109318f, 0.06056801f, 0.11809864f, -0.02491837f, 0.02687752f, 0.05138296f, 
    -0.02680420f, 0.13627069f, -0.07623838f, -0.29214868f, -0.00858666f, 0.01322378f, 0.01424546f, 0.08490794f, 
    0.00077173f, -0.03562376f, 0.06041271f, 0.13734266f, 0.35578761f, -0.12849754f, -0.32324171f, 0.00695395f, 
    0.10292967f, -0.13304688f, 0.05782758f, -0.03956577f, -0.28332368f, -0.32119828f, -0.08772013f, 0.09501128f, 
    0.04071830f, -0.01829001f, 0.10514690f, 0.07752413f, 0.04249456f, 0.00754631f, -0.08790467f, 0.04344208f, 
    -0.00160831f, -0.04659738f, 0.02173117f, -0.03168812f, 0.13636826f, -0.00079878f, -0.04953239f, 0.24505161f, 
    0.11228552f, -0.00962370f, -0.17333063f, 0.11718472f, 0.05193692f, 0.01651268f, 0.02804900f, -0.01854691f, 
    -0.04368212f, -0.26031974f, 0.03050665f, -0.08808806f, -0.21482517f, 0.08378271f, -0.06049042f, 0.00125746f, 
    -0.06804511f, 0.03903262f, -0.22752331f, -0.00748194f, -0.07208766f, -0.06224209f, 0.08752296f, 0.06140941f, 
    0.10382042f, 0.20849136f, 0.08257338f, -0.02576940f, -0.00311483f, 0.13909546f, 0.01505483f, 0.01572127f, 
    0.16918375f, -0.06587382f, -0.43035355f, 0.03355408f, -0.19009314f, 0.20541386f, -0.04827744f, -0.05257172f, 
    -0.14115149f, 0.10845788f, 0.06821411f, 0.18342428f, 0.10614555f, 0.06844382f, -0.16428944f, -0.08313696f, 
    0.04609762f, 0.10886823f, 0.01919677f, -0.13035235f, 0.27501130f, 0.01531611f, -0.07685867f, 0.03702002f, 
    -0.14664289f, 0.06171255f, 0.05144786f, 0.04565253f, 0.00065948f, 0.39376333f, 0.30071265f, 0.00105721f, 
    -0.03091704f, -0.02402394f, 0.05772720f, -0.03520507f, -0.00478744f, -0.07649631f, 0.40456763f, 0.08615060f, 
    -0.27848029f, 0.10928577f, -0.06822523f, -0.07551162f, -0.11653150f, -0.04449803f, 0.06456731f, 0.06221276f, 
    -0.08250140f, 0.04340735f, -0.19525124f, -0.04714619f, -0.22958295f, 0.01871615f, 0.21663994f, 0.03240346f, 
    0.02099688f, -0.32674733f, -0.02242077f, 0.26191750f, 0.13715632f, -0.01066931f, -0.12874895f, 0.05333263f, 
    0.01529075f, -0.05677235f, 0.24206284f, -0.12273226f, 0.03066693f, -0.04514267f, -0.08939703f, 0.00198104f, 
    0.05631762f, -0.09438328f, 0.01346738f, 0.24906807f, -0.01457455f, 0.04201744f, 0.00236778f, 0.08751300f, 
    0.00719609f, 0.10687969f, -0.19165827f, 0.04419412f, 0.02532251f, -0.11752576f, -0.18568259f, 0.02672196f, 
    -0.08271402f, -0.07373535f, 0.16263551f, 0.00189932f, -0.42355976f, -0.08257628f, 0.14843382f, 0.19982156f, 
    0.06256983f, 0.03912313f, -0.16657756f, -0.00578182f, 0.03177904f, -0.22629097f, 0.07371362f, -0.09510263f, 
    0.00376185f, -0.04418582f, 0.12011652f, 0.02847337f, 0.00957924f, 0.09661514f, -0.15215446f, -0.05036625f, 
    -0.02001067f, 0.04961183f, -0.03600618f, 0.13694714f, 0.05508835f, -0.05724226f, 0.07628800f, 0.22155498f, 
    0.02593505f, -0.07939634f, -0.08335723f, 0.01065166f, -0.03188602f, 0.02250812f, -0.05143488f, -0.00836926f, 
    -0.07886858f, 0.02229812f, -0.13749397f, -0.02356787f, 0.02334530f, -0.00543864f, 0.12267811f, 0.13681862f, 
    0.08456797f, 0.06131368f, 0.08452637f, -0.05952962f, -0.10464574f, 0.00729013f, 0.05548609f, 0.14095101f, 
    -0.03955330f, 0.04315231f, -0.08434306f, -0.25536102f, -0.04676659f, 0.03451013f, -0.04687379f, -0.09104399f, 
    0.07985432f, 0.00805486f, 0.01553686f, -0.24796969f, -0.31479692f, -0.08793139f, 0.02253206f, 0.04801078f, 
    0.02929972f, 0.01514098f, 0.04182031f, 0.08078098f, -0.16895427f, -0.37344503f, -0.13508138f, 0.00066182f, 
    0.07307116f, -0.06545889f, 0.03972519f, -0.13574918f, -0.07363553f, 0.03575740f, 0.03738015f, 0.13634701f, 
    -0.02761519f, 0.23348472f, -0.06312830f, -0.01667605f, -0.00766156f, -0.03710479f, 0.04998760f, -0.09935690f, 
    -0.00499186f, -0.16365425f, 0.01870362f, 0.06609078f, -0.04120864f, 0.05447518f, -0.18052036f, 0.27143520f, 
    -0.06705955f, -0.06221644f, -0.09509023f, -0.07759236f, 0.04401562f, 0.01636386f, -0.12060525f, 0.01281968f, 
    0.13005175f, 0.09567402f, -0.11835501f, -0.05313689f, 0.07100054f, -0.02060736f, 0.02658456f, -0.10158590f, 
    -0.16745025f, -0.15481102f, 0.21122457f, -0.10141768f, -0.11341025f, -0.18015687f, -0.05763001f, -0.16465230f, 
    0.01208384f, -0.02893811f, -0.00767951f, 0.14707847f, -0.03971683f, 0.01216976f, -0.01524768f, 0.07540096f, 
    -0.02584151f, -0.05970369f, 0.09063116f, 0.08150935f, -0.03230100f, 0.02836533f, 0.10734419f, -0.05353718f, 
    -0.00101842f, -0.04647800f, -0.11491229f, 0.08112198f, 0.09196969f, -0.22443435f, 0.35325474f, -0.18014218f, 
    0.04498371f, -0.02466301f, -0.06041247f, 0.03958469f, -0.17146769f, -0.14136013f, -0.03509313f, 0.01126195f, 
    0.04883563f, -0.14970186f, 0.02237384f, 0.00362621f, -0.09012109f, -0.10590603f, 0.08323794f, 0.05463342f, 
    -0.15524197f, -0.19726396f, -0.20857817f, -0.06270280f, -0.03736474f, -0.20651631f, -0.10029501f, 0.11524850f, 
    -0.28381675f, -0.00997266f, -0.08754503f, -0.06581279f, 0.17482740f, 0.18052344f, -0.02178131f, -0.01136473f, 
    0.14520469f, -0.06586752f, 0.04848482f, -0.12923551f, -0.11229474f, 0.00018268f, -0.17910020f, -0.02522272f, 
    0.07989987f, 0.04842667f, -0.03617380f, 0.15417361f, 0.03382709f, 0.14060883f, 0.05635341f, 0.02208011f, 
    0.02824642f, -0.03018423f, 0.01601052f, 0.07469129f, 0.15245877f, -0.03587790f, -0.01647525f, 0.00403288f, 
    -0.08739144f, 0.14666258f, -0.02275361f, 0.24783914f, -0.01205419f, -0.01952359f, -0.07041448f, 0.06553690f, 
    0.09323125f, 0.08464050f, -0.01193432f, -0.04609787f, 0.02898584f, 0.06493705f, 0.16336766f, -0.04409463f, 
    -0.01655462f, -0.00899429f, -0.11149399f, 0.09319088f, -0.01807672f, 0.08288699f, -0.27487472f, 0.02411208f, 
    -0.18178686f, -0.17297514f, 0.01129735f, -0.07289391f, 0.12511292f, -0.02529656f, 0.04402827f, 0.15677522f, 
    -0.03082134f, -0.07885460f, -0.16198635f, 0.04613804f, -0.00871706f, 0.12077567f, -0.09757931f, 0.30822805f, 
    -0.05546439f, -0.04849749f, 0.15876167f, 0.13225640f, -0.09623220f, -0.04688691f, 0.10144835f, 0.08888163f, 
    0.12281580f, 0.02117229f, -0.14654790f, -0.12582870f, -0.09036037f, 0.12391793f, 0.02534500f, -0.03765006f, 
    -0.04113221f, -0.02167453f, -0.15194464f, 0.13150665f, 0.07922239f, 0.00479126f, 0.02631940f, 0.09958259f, 
    0.12783663f, 0.00214653f, 0.03577376f, -0.02149823f, 0.20468751f, -0.19373600f, -0.09873857f, 0.13392362f, 
    0.03600814f, 0.00579497f, -0.03095474f, 0.15177462f, 0.38872248f, 0.07731515f, 0.27053198f, 0.01701279f, 
    0.08201522f, -0.08429880f, -0.05810512f, -0.06542511f, -0.01889778f, 0.03659918f, 0.11206196f, 0.18890269f, 
    0.05709950f, 0.02637114f, 0.10732810f, -0.18836470f, -0.06564962f, -0.13954501f, -0.25183606f, 0.02336403f, 
    -0.03335771f, -0.09313574f, -0.09739631f, -0.11859530f, 0.13608621f, -0.04522575f, -0.03562137f, -0.29360604f, 
    0.05118884f, -0.04059102f, 0.13483435f, 0.02933448f, -0.15412576f, -0.05652704f, -0.10534446f, -0.07975066f, 
    -0.05556292f, -0.08346529f, 0.09464614f, -0.12211128f, -0.03110410f, -0.08884390f, -0.11122063f, 0.07536834f, 
    0.21493727f, 0.05868084f, -0.00826952f, 0.01644531f, 0.02747706f, 0.01062545f, -0.11948982f, 0.10873608f, 
    -0.06328104f, -0.03794146f, 0.21475993f, 0.11456922f, 0.10283028f, -0.00905791f, 0.04647029f, 0.12569550f, 
    -0.09177707f, -0.08156362f, 0.04305297f, -0.19018331f, 0.03632630f, -0.08746437f, -0.12017485f, -0.05840651f, 
    -0.05287512f, -0.12624900f, -0.16684037f, -0.25970599f, 0.35343519f, 0.04669580f, -0.09473652f, -0.01956551f, 
    -0.00705205f, -0.03829283f, -0.06817074f, 0.02754269f, 0.10529047f, -0.03632686f, -0.05388998f, 0.05689159f, 
    -0.02242308f, 0.02412555f, 0.15606943f, -0.06380243f, -0.06099380f, 0.32938412f, 0.02937471f, -0.05046848f, 
    0.14389367f, 0.08292869f, 0.12460285f, 0.06225436f, 0.09577584f, 0.09302801f, -0.07936464f, 0.10214515f, 
    0.05043200f, 0.09204029f, 0.02299666f, 0.02254800f, -0.04835636f, 0.04744849f, -0.13793959f, 0.07224727f, 
    -0.00075105f, -0.07580971f, 0.03274138f, -0.18536918f, -0.07498485f, 0.08114192f, 0.06543586f, -0.15028958f, 
    -0.03057130f, -0.00088702f, 0.01165425f, 0.01425292f, 0.03924622f, -0.02596137f, -0.04807008f, 0.02187603f, 
    -0.01045705f, -0.03689100f, -0.02558988f, 0.03972868f, 0.02240892f, 0.04334690f, -0.02948387f, -0.01909603f, 
    -0.02942776f, 0.02965505f, -0.06075798f, -0.01770102f, 0.01334718f, 0.00811166f, -0.03664422f, -0.02644845f, 
    -0.00204777f, 0.01559678f, 0.02584862f, 0.03063956f, -0.06497291f, -0.04756988f, -0.00737866f, -0.04895353f, 
    0.00625923f, -0.06723148f, -0.01644767f, -0.05082335f, -0.01892369f, -0.01839530f, -0.02257367f, -0.02114008f, 
    -0.03764961f, -0.06398192f, -0.00628715f, -0.04328715f, -0.07294010f, 0.00876138f, 0.02866215f, -0.05351501f, 
    -0.01620501f, -0.02689007f, -0.04070828f, 0.02698312f, 0.02261559f, 0.05095479f, -0.02870770f, 0.04611764f, 
    -0.01894452f, -0.06619098f, -0.03371301f, -0.06956610f, -0.03274707f, 0.03893477f, 0.05061794f, -0.03612084f, 
    -0.00723575f, 0.02692062f, -0.05411367f, 0.03291544f, -0.05471161f, -0.04510295f, -0.04429056f, -0.04989733f, 
    0.03244457f, -0.00461241f, 0.05008417f, -0.00431607f, 0.01841157f, -0.03007179f, -0.03820059f, 0.01288061f, 
    -0.04949222f, -0.01315354f, -0.05989653f, -0.05986040f, -0.02333883f, -0.06283627f, -0.04117057f, 0.00152456f, 
    -0.01570895f, 0.00071414f, -0.00560375f, -0.01177454f, 0.02587370f, 0.02149802f, 0.00764429f, -0.04615941f, 
    -0.05496038f, 0.03370230f, 0.02881601f, 0.00980901f, 0.01700588f, -0.03096269f, 0.01292961f, -0.02447446f, 
    -0.05813959f, -0.02283745f, 0.04266993f, -0.02667723f, 0.00127914f, 0.00117545f, -0.04179182f, -0.03649326f, 
    -0.05754888f, 0.04919528f, -0.01421173f, -0.05207740f, -0.01957442f, 0.02841244f, -0.05927769f, -0.01832071f, 
    -0.02478228f, 0.02030236f, -0.03115618f, 0.00469002f, 0.04402770f, 0.02048342f, 0.03617149f, 0.00484492f, 
    0.04270554f, -0.05881526f, 0.04033362f, -0.01418350f, -0.04278686f, 0.03078301f, -0.05622675f, -0.01825113f, 
    0.04451528f, -0.05967021f, -0.05008641f, -0.03517973f, 0.01993796f, -0.01032713f, -0.00484341f, -0.04045595f, 
    -0.01938071f, 0.01001687f, -0.04985585f, -0.02039175f, 0.01575529f, 0.03932678f, 0.04993653f, -0.05970931f, 
    0.03455457f, 0.02266653f, -0.01672317f, -0.00479498f, 0.04656132f, -0.01888788f, -0.06799069f, 0.05053085f, 
    0.02776385f, 0.02693655f, -0.00771564f, 0.03351285f, -0.01134285f, 0.02219225f, -0.03655529f, -0.02935558f, 
    -0.03137841f, -0.01058096f, -0.02724957f, 0.03018399f, 0.00427386f, -0.03463343f, -0.05909585f, -0.02185411f, 
    0.02584369f, -0.06902786f, 0.04202540f, 0.03306219f, 0.01522070f, 0.01274843f, 0.01317397f, -0.00947089f, 
    -0.05095820f, -0.05842028f, -0.04924776f, 0.02937605f, 0.02376457f, -0.04053066f, 0.02648423f, -0.03980023f, 
    -0.06710913f, -0.04412984f, 0.01130711f, 0.03246569f, -0.05814028f, -0.02319186f, -0.03166370f, 0.03198215f, 
    -0.01036510f, -0.01595189f, -0.04749687f, -0.00670659f, 0.00788131f, -0.03429835f, -0.04591994f, 0.03774085f, 
    -0.00372554f, -0.00881241f, 0.02763505f, -0.03700882f, -0.05256804f, 0.03702412f, -0.06245359f, -0.00266035f, 
    -0.05154257f, -0.01928588f, -0.02174894f, -0.06321474f, -0.03226050f, 0.03931216f, 0.03249642f, 0.02860471f, 
    -0.02914639f, -0.05631801f, 0.04995243f, 0.00948390f, -0.00378849f, -0.05405885f, -0.00992612f, -0.01157579f, 
    0.01165138f, -0.02145139f, -0.03510695f, -0.05325730f, 0.02949286f, 0.04025291f, 0.00816310f, -0.06088421f, 
    0.00587682f, 0.00698003f, -0.03116253f, 0.01043365f, 0.04137436f, -0.01035208f, 0.03609027f, -0.04596590f, 
    -0.04377633f, -0.03215010f, 0.00831071f, 0.02859906f, 0.02778430f, -0.03799194f, -0.00737892f, 0.02494159f, 
    -0.03106542f, 0.01601894f, 0.01988985f, 0.01423380f, 0.02565408f, -0.01930627f, -0.02444569f, 0.02484148f, 
    -0.00747882f, -0.04837362f, 0.05212870f, 0.01079713f, 0.04496282f, -0.01178218f, 0.04042693f, -0.05651199f, 
    0.03762164f, -0.05176210f, -0.00450124f, 0.03279813f, -0.01764205f, -0.03707169f, -0.01876605f, -0.00090151f, 
    0.04806723f, 0.03338226f, -0.05384019f, 0.03642660f, 0.03768160f, -0.04563280f, -0.02997909f, 0.02416418f, 
    -0.19417186f, -0.22797997f, 0.20123473f, -0.12648734f, 0.07300992f, 0.04386157f, -0.00985909f, 0.12416842f, 
    0.11738305f, 0.29539970f, -0.33867621f, -0.08909050f, -0.10679085f, -0.01066435f, 0.06162077f, -0.19664268f, 
    0.06014685f, -0.01758201f, 0.01070732f, -0.37476343f, 0.05892768f, -0.04036149f, -0.02173924f, 0.01815272f, 
    -0.01933074f, 0.17001303f, 0.08039209f, 0.10991526f, -0.61838835f, -0.06892700f, -0.30887982f, 0.07365239f, 
    0.01240702f, -0.10560910f, -0.06345055f, -0.12285681f, -0.19687970f, 0.11749740f, 0.04576524f, -0.00628105f, 
    0.01294175f, -0.07072398f, -0.13417056f, -0.08072841f, -0.09750848f, -0.04965139f, -0.32417423f, -0.29478884f, 
    0.22021626f, 0.04519960f, -0.03746593f, 0.04405396f, 0.08944243f, 0.11857036f, -0.23555578f, 0.06302079f, 
    -0.02230521f, 0.17844068f, 0.04308617f, 0.07602219f, -0.03107747f, 0.01155645f, 0.01656359f, -0.34926835f, 
    0.08047852f, -0.11945110f, -0.13225468f, -0.27829298f, 0.12811817f, 0.07151730f, 0.17147882f, 0.04668232f, 
    -0.21857791f, 0.22410281f, -0.16388132f, 0.04438920f, 0.01112373f, 0.09303907f, -0.09073232f, 0.00793943f, 
    0.12250081f, -0.30751190f, -0.06556980f, 0.00330293f, -0.04635631f, -0.07346319f, 0.05434489f, 0.01634951f, 
    0.12789758f, 0.06713051f, 0.32721978f, 0.16423634f, 0.01479781f, -0.14939421f, 0.04941822f, -0.00845052f, 
    -0.10874110f, 0.16724315f, 0.14719459f, 0.12250164f, 0.40913051f, 0.02960456f, 0.16071333f, -0.12098047f, 
    -0.07222335f, 0.09488755f, 0.09505457f, -0.08165367f, -0.25378922f, -0.19013631f, 0.05273337f, -0.05994912f, 
    0.03007107f, -0.05904095f, -0.09697021f, -0.04993746f, -0.08742940f, 0.00227445f, 0.16538675f, -0.11838946f, 
    0.03814472f, 0.06421753f, -0.03930045f, -0.12162916f, 0.11802843f, 0.00902379f, -0.32370481f, -0.25089779f, 
    0.05542441f, -0.07352646f, -0.09330165f, 0.14450410f, -0.00224593f, -0.09001140f, -0.06764730f, 0.41741362f, 
    0.18388590f, -0.06873127f, 0.02050860f, -0.02781789f, 0.02260496f, 0.02395464f, -0.03744070f, 0.10416596f, 
    -0.24701969f, 0.18788736f, 0.04458866f, -0.04196708f, -0.10814571f, 0.07453097f, -0.04894014f, 0.06808452f, 
    -0.05219781f, 0.06095145f, -0.03424924f, -0.12956449f, 0.06067894f, -0.11136201f, 0.19148092f, -0.12481240f, 
    0.05090154f, 0.14954796f, -0.14802815f, -0.81685883f, 0.01052888f, 0.07934597f, 0.11284342f, 0.09578967f, 
    -0.08858624f, 0.04106658f, -0.17614332f, 0.20737970f, 0.04395156f, -0.00238863f, 0.17235528f, 0.04234948f, 
    -0.09793883f, 0.04362166f, 0.08267257f, -0.09476243f, -0.14255577f, -0.09485921f, -0.40950602f, 0.18728000f, 
    0.15959905f, 0.07667106f, -0.00163240f, 0.03246933f, -0.10975648f, 0.01039929f, 0.34147331f, -0.48374677f, 
    0.09035639f, 0.05819216f, -0.17207256f, -0.07970678f, -0.09635364f, 0.06742229f, 0.39954796f, 0.15977342f, 
    -0.27350613f, 0.15763560f, -0.02348595f, 0.09944034f, -0.14091447f, -0.09189672f, 0.05989419f, -0.25627798f, 
    0.19845098f, -0.25916398f, 0.14244974f, 0.06381467f, -0.02515332f, 0.00286722f, 0.11698144f, 0.10483935f, 
    0.78933412f, -0.13550507f, -0.17175661f, 0.00782411f, -0.06305800f, -0.15523003f, -0.03802355f, -0.03273438f, 
    -0.00101186f, 0.00324371f, 0.05016210f, 0.29413813f, 0.02521669f, 0.09422513f, 0.00664915f, -0.00684783f, 
    -0.02375287f, 0.03645241f, 0.09340838f, 0.12952495f, -0.26001632f, -0.10608786f, -0.00034806f, 0.16197488f, 
    -0.00451512f, 0.03251896f, 0.15377359f, 0.38517159f, -0.62752831f, -0.30807006f, -0.23158257f, -0.17623055f, 
    -0.16580907f, -0.11190315f, -0.07163582f, 0.11665541f, 0.13638034f, 0.00756853f, 0.12326200f, -0.00785304f, 
    -0.08623029f, 0.07290057f, -0.20116033f, -0.00218255f, -0.14706950f, 0.33507925f, 0.25477922f, -0.24606527f, 
    0.19069105f, -0.03172290f, 0.09093487f, -0.04212080f, -0.04521940f, 0.03998732f, 0.12361051f, -0.39963344f, 
    -0.13781908f, 0.18289196f, 0.17776513f, -0.01475069f, 0.05001501f, -0.01187070f, -0.03816410f, -0.22033152f, 
    -0.07795137f, -0.16183139f, 0.16432990f, 0.14035796f, -0.09082151f, 0.02315841f, -0.05094756f, -0.00440696f, 
    0.09654763f, 0.12762581f, -0.01319572f, 0.02182507f, -0.03986537f, -0.15185444f, 0.07421182f, 0.21798518f, 
    -0.11255991f, -0.34473783f, 0.13578956f, 0.18495712f, 0.10914601f, -0.00043632f, 0.11992011f, 0.03404481f, 
    0.06081064f, 0.03038973f, 0.00298794f, 0.04711334f, -0.23376937f, -0.09316850f, 0.11763987f, 0.16196993f, 
    -0.11806007f, 0.01376936f, -0.00843874f, 0.23412824f, 0.13226378f, -0.07995486f, 0.02691701f, -0.05488434f, 
    0.01501633f, 0.23607376f, 0.08414584f, -0.04535183f, -0.02520658f, -0.08445417f, 0.07443801f, -0.01483803f, 
    -0.11303612f, -0.03020154f, 0.16970642f, 0.02873111f, 0.07873113f, -0.13104355f, -0.03693284f, -0.04752806f, 
    0.06286999f, 0.10589778f, 0.17716788f, -0.19005981f, 0.02173836f, -0.19562672f, 0.07560711f, 0.04615102f, 
    -0.09895284f, -0.04991201f, 0.04633992f, 0.01121228f, -0.01304112f, 0.07260827f, -0.03737630f, -0.01601668f, 
    -0.09254012f, -0.10643245f, 0.11930233f, -0.07845905f, 0.01365296f, -0.00908661f, 0.05307722f, 0.24885556f, 
    0.07673012f, -0.25823385f, 0.04577173f, -0.12411344f, -0.00260969f, 0.01441593f, -0.04933529f, -0.02124510f, 
    0.27854037f, 0.20616704f, 0.05210913f, 0.07774162f, 0.02685449f, 0.13857502f, -0.04542998f, 0.03279922f, 
    0.16690087f, -0.01972411f, -0.10715675f, 0.01959360f, -0.15878712f, 0.08035041f, -0.07175366f, -0.01298753f, 
    -0.03005374f, 0.09282175f, 0.08184281f, 0.08781525f, 0.18220593f, -0.03798574f, 0.00943574f, 0.05193450f, 
    -0.01089236f, 0.21009226f, -0.00077198f, -0.02033093f, 0.05858482f, 0.13724075f, 0.14793260f, -0.05568021f, 
    0.14278677f, -0.00554149f, 0.02593555f, 0.07643337f, -0.01320690f, -0.39285806f, -0.25370020f, -0.09094469f, 
    -0.10957310f, -0.06192949f, 0.21730137f, -0.15413785f, 0.05001258f, 0.12077130f, -0.09474666f, 0.05605502f, 
    0.20383850f, -0.06034568f, -0.14981253f, -0.01677785f, -0.17934652f, 0.06609626f, 0.02128947f, 0.14029863f, 
    -0.11305273f, 0.19058087f, 0.17905478f, -0.04128148f, -0.14798781f, 0.07540450f, 0.11487953f, 0.02668800f, 
    0.00337956f, 0.08650415f, -0.05688675f, 0.00423429f, 0.07827196f, -0.09005114f, -0.04233838f, 0.08199288f, 
    0.07856372f, 0.10665940f, -0.08213791f, 0.10335643f, 0.11818615f, 0.01624540f, -0.04919419f, 0.07208707f, 
    0.20280716f, -0.03305956f, -0.00420830f, 0.04313350f, 0.08295354f, -0.08218199f, -0.03907019f, 0.10160041f, 
    -0.17899907f, 0.03547770f, -0.24086097f, 0.13577688f, 0.23556383f, 0.26760083f, 0.04216566f, -0.09252279f, 
    0.20766105f, -0.14841941f, 0.11768536f, -0.08544977f, 0.00269348f, -0.15693057f, 0.02244203f, 0.05115285f, 
    0.07803681f, 0.22062068f, -0.03954801f, 0.17658131f, -0.08254828f, 0.04114240f, -0.18646269f, 0.06306426f, 
    -0.01835162f, 0.00454620f, 0.01159322f, 0.13310395f, 0.15548989f, 0.04712301f, -0.21259643f, -0.21811970f, 
    0.05238448f, 0.09528901f, 0.16118018f, 0.00831626f, -0.10761499f, -0.01927341f, 0.03061518f, -0.09609456f, 
    -0.17733786f, -0.17643866f, 0.05552487f, -0.16061778f, 0.23625804f, -0.11864851f, -0.06462964f, -0.12647074f, 
    0.17745687f, 0.09486238f, 0.13035426f, 0.15742935f, 0.05712052f, -0.05346909f, -0.02890141f, 0.06357922f, 
    -0.11150380f, 0.04806780f, 0.22121151f, 0.09137718f, -0.01047009f, -0.07512043f, 0.09365428f, 0.08701320f, 
    0.13049085f, 0.00307169f, 0.01196684f, -0.02211095f, 0.00314670f, 0.02583559f, 0.01682653f, -0.19790311f, 
    0.04579836f, 0.02596146f, 0.01969413f, -0.37982038f, 0.14346398f, 0.26163742f, 0.08925027f, 0.01384985f, 
    -0.08040863f, 0.20372932f, -0.10766617f, 0.00913884f, 0.02416996f, 0.08576401f, 0.01671349f, 0.00325154f, 
    0.08398969f, 0.00022106f, 0.05663629f, 0.09248580f, 0.02829585f, 0.14840616f, 0.18389875f, 0.13212994f, 
    -0.00359606f, -0.13039479f, 0.12409513f, 0.05613872f, -0.03418075f, 0.13263705f, -0.00813660f, -0.04559910f, 
    0.11757664f, 0.06472089f, -0.16117688f, 0.09741611f, 0.10139077f, 0.02255011f, -0.16433957f, 0.02360399f, 
    -0.15633091f, 0.02855084f, -0.17053546f, -0.01213216f, -0.06645041f, 0.13972659f, -0.07347096f, 0.00660485f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.07478777f, 0.01713810f, -0.02707934f, -0.10733366f, -0.05667599f, -0.04943248f, -0.03845860f, 0.05586950f, 
    0.19291566f, 0.07865889f, 0.08996739f, 0.02337131f, 0.01287268f, 0.04232546f, 0.06497473f, 0.02652434f, 
    0.11978094f, 0.00507144f, -0.06305119f, 0.06410929f, 0.02827720f, 0.02749226f, 0.16488363f, 0.05041036f, 
    -0.02545749f, 0.12117597f, 0.01285640f, 0.09490669f, -0.09217046f, -0.05319637f, 0.10215586f, 0.04800820f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.03464037f, -0.18349670f, 0.42165864f, -0.19548883f, -0.10856218f, -0.12180643f, -0.13754740f, 0.06443376f, 
    -0.30823907f, 0.23847887f, -0.48567030f, -0.34149271f, 0.40637049f, 0.13941906f, -0.49056411f, 0.07174592f, 
    0.01000615f, 0.34494364f, -0.10197822f, 0.26881525f, 0.06409360f, 0.12149929f, 0.02276560f, 0.30711925f, 
    0.05416905f, 0.23336291f, -0.35254642f, 0.17229815f, 0.10101192f, 0.01291981f, -0.29735041f, 0.17032586f, 
    -0.10420413f, -0.08878819f, -0.19063015f, 0.01984210f, 0.11692721f, -0.02546135f, 0.15865174f, -0.11159486f, 
    -0.09518422f, -0.02998766f, -0.20920666f, -0.10852040f, -0.08834686f, 0.00127465f, -0.13672620f, -0.09166703f, 
    -0.03076215f, 0.01061437f, 0.08946545f, 0.05865265f, -0.12298143f, 0.09634552f, -0.06686248f, -0.00195258f, 
    -0.04943350f, 0.01277412f, 0.10222389f, -0.12169753f, -0.17295460f, 0.16153006f, -0.19782579f, 0.06765252f, 
    0.35267222f, 0.23103587f, -0.27749002f, 0.02977558f, 0.03407263f, -0.04477594f, -0.00842400f, -0.37759516f, 
    -0.12637608f, 0.16776398f, 0.51147562f, -0.30123660f, -0.47954148f, 0.06603994f, 0.14796123f, 0.13519610f, 
    0.25877079f, -0.30300871f, -0.01445939f, 0.20158516f, -0.14423911f, 0.05058028f, 0.16726498f, 0.11063446f, 
    0.13791060f, 0.21215728f, 0.36219585f, -0.35349327f, -0.10418101f, -0.06175296f, -0.10438988f, -0.00330475f, 
    -0.44473937f, -0.30684468f, -0.02451908f, 0.27966329f, 0.02510698f, 0.09453943f, 0.11024760f, 0.02513092f, 
    0.36502570f, -0.19878960f, 0.25420061f, -0.27826861f, 0.16135754f, -0.07482241f, 0.26534176f, 0.08884291f, 
    0.43893299f, -0.59212875f, -0.08585793f, -0.12120748f, 0.08978583f, -0.12703162f, -0.05559795f, 0.16196135f, 
    -0.05593328f, 0.30529085f, -0.22650960f, 0.32294244f, 0.42371380f, -0.03290170f, 0.04684789f, 0.42017654f, 
    0.17480095f, -0.08134529f, -0.02222553f, -0.17213979f, -0.16130055f, 0.03047287f, -0.07246533f, 0.08123153f, 
    -0.11941380f, 0.24894935f, -0.50509357f, -0.07140919f, 0.29866457f, 0.10629330f, -0.16571909f, 0.00737332f, 
    0.24473560f, 0.20273767f, -0.07643356f, 0.20408478f, -0.12605032f, 0.12747541f, -0.05167336f, 0.14414375f, 
    0.04556968f, 0.01954047f, -0.17678736f, -0.06102882f, 0.00424561f, 0.09796190f, 0.22810011f, -0.10841789f, 
    0.17209059f, 0.07434644f, 0.32995847f, 0.12683509f, -0.14346378f, 0.12391674f, 0.11793744f, 0.00196744f, 
    -0.46069387f, 0.30186728f, -0.14328234f, -0.45632929f, -0.13807386f, -0.14056137f, -0.38790533f, 0.11114762f, 
    0.36324504f, -0.04472456f, -0.17968710f, 0.15580846f, -0.47426468f, -0.01093992f, 0.13109593f, 0.32761747f, 
    -0.11478491f, 0.29941332f, 0.30717185f, -0.35796839f, -0.11308342f, -0.02545417f, 0.17549895f, -0.21477014f, 
    -0.09954560f, -0.19735160f, -0.04892166f, -0.15049036f, 0.10611790f, -0.12311160f, 0.12871704f, -0.05989670f, 
    -0.14755875f, 0.13383237f, 0.07848980f, -0.15735328f, 0.05519142f, 0.13541025f, -0.11800765f, -0.09743390f, 
    -0.01661212f, 0.03100931f, -0.01785581f, -0.04240570f, -0.10681547f, -0.03687232f, -0.04193952f, -0.13192108f, 
    -0.13528021f, 0.09923030f, -0.11956239f, 0.01049588f, -0.17792280f, -0.01650620f, -0.08551858f, -0.15963848f, 
    -0.04471452f, -0.11067094f, -0.06580564f, -0.12054991f, -0.07897659f, 0.02801927f, 0.06898149f, -0.16370487f, 
    0.17119072f, -0.03519553f, -0.05397812f, -0.14079198f, -0.06295464f, -0.00155467f, -0.01480204f, 0.09042851f, 
    -0.03876435f, 0.11108290f, -0.01771780f, 0.16721632f, 0.02793622f, -0.03268208f, -0.15557286f, 0.04893123f, 
    -0.16807647f, -0.08450963f, -0.00212515f, -0.01593471f, -0.00653803f, -0.15472324f, -0.16165204f, -0.07926752f, 
    -0.04732521f, -0.09770295f, -0.13738956f, 0.31228292f, -0.11930295f, -0.13722639f, 0.07896974f, 0.29123086f, 
    0.55531913f, 0.03081939f, -0.07165235f, 0.48780832f, -0.18452637f, 0.17426229f, 0.14314322f, 0.15794168f, 
    -0.11925706f, -0.24011633f, -0.17931384f, -0.14728752f, 0.24903664f, -0.14976622f, 0.13697083f, -0.14116706f, 
    0.01125026f, -0.29694575f, -0.00478445f, 0.13478629f, -0.15631187f, -0.12408476f, 0.58058089f, 0.21592265f, 
    -0.20261174f, -0.20048067f, 0.04031888f, -0.11684695f, 0.00952283f, -0.01571184f, 0.12337779f, -0.05923633f, 
    -0.17866141f, -0.00374701f, -0.04900770f, 0.12022832f, -0.13177909f, 0.10232610f, -0.09361384f, 0.01386926f, 
    0.11655773f, -0.05031119f, 0.07378242f, 0.10932339f, -0.05555761f, -0.03005428f, -0.02599373f, -0.09651414f, 
    -0.03917168f, -0.18942931f, 0.06330951f, -0.05305891f, -0.09754502f, -0.16560233f, -0.19622996f, -0.10733237f, 
    0.11333642f, 0.41488951f, -0.05541968f, -0.06858063f, 0.16673648f, 0.08087400f, -0.16237326f, 0.11872092f, 
    0.56656557f, -0.14358528f, 0.29392287f, 0.53588766f, 0.09173713f, 0.10450701f, 0.32011718f, -0.12719446f, 
    -0.05181566f, 0.14802596f, 0.07482588f, 0.08043164f, 0.16760755f, 0.12123014f, 0.35668012f, -0.19373809f, 
    0.14430477f, -0.16177486f, 0.18247107f, -0.02510418f, -0.24352734f, 0.08299521f, -0.02468028f, 0.06195992f, 
    0.39193308f, 0.18693979f, -0.17544128f, 0.14548752f, 0.16406038f, 0.10388187f, 0.12489375f, 0.39983699f, 
    -0.06669000f, 0.32619181f, -0.55876118f, -0.15022016f, 0.00298461f, -0.11847579f, -0.03963516f, 0.09541718f, 
    -0.45538560f, -0.00398091f, 0.02068874f, 0.35915828f, 0.56293666f, 0.08650941f, 0.34139043f, 0.16866021f, 
    -0.10340796f, -0.25843304f, 0.31124088f, 0.46540651f, -0.66324091f, -0.11863393f, 0.41071352f, -0.05329543f, 
    0.38892150f, 0.07227746f, -0.08845130f, 0.34539518f, -0.06825404f, 0.10671827f, 0.04261001f, 0.11719754f, 
    0.51817924f, 0.26400760f, -0.09531034f, 0.60089648f, 0.23106657f, -0.08220387f, -0.28765509f, -0.02607813f, 
    -0.41329581f, 0.54651630f, -0.15994635f, -0.04370200f, 0.17959349f, 0.02231240f, 0.04520252f, -0.03629356f, 
    0.02995866f, -0.05479946f, -0.29200512f, -0.18328786f, 0.18389396f, 0.02212864f, 0.75930786f, 0.11028509f, 
    0.18244334f, -0.10105740f, -0.37924773f, 0.37792456f, -0.06842525f, -0.04447837f, 0.14905563f, 0.29018980f, 
    -0.20148630f, 0.08176670f, -0.27619174f, -0.14663747f, 0.08685784f, 0.09487420f, 0.58259249f, 0.04690173f, 
    0.54786903f, -0.40832618f, -0.17893276f, 0.20558472f, -0.01174097f, -0.01923210f, 0.19228502f, 0.12640232f, 
    0.04798699f, -0.43429995f, -0.01876257f, 0.63295156f, 0.39421177f, 0.08303149f, -0.35382468f, 0.22858661f, 
    -0.54364449f, -0.10763176f, 0.20138559f, -0.36185157f, 0.07115027f, -0.13662569f, -0.09879465f, 0.05334762f, 
    0.15516424f, 0.02833746f, 0.11210180f, -0.05399768f, 0.28952244f, -0.16904807f, -0.06228047f, -0.13151589f, 
    -0.05411557f, 0.26266849f, -0.06344145f, 0.16454577f, 0.28768623f, -0.02695950f, 0.02992301f, 0.13062513f, 
    -0.12136559f, 0.14840259f, -0.36523956f, 0.05970453f, -0.59978992f, -0.17159872f, 0.14133522f, -0.02168880f, 
    0.34719908f, 0.44302377f, 0.13575372f, -0.05576408f, 0.08752435f, -0.04058687f, -0.00104143f, -0.43420041f, 
    0.27491084f, 0.27982217f, 0.23619205f, -0.02025606f, -0.57310587f, -0.10848539f, 0.10520940f, -0.03876502f, 
    -0.10199510f, -0.12374564f, -0.11051738f, 0.15588157f, -0.23639546f, -0.14840689f, 0.31138030f, 0.16878989f, 
    0.03160295f, 0.47946876f, 0.24712084f, -0.12322666f, -0.11284150f, -0.05946976f, 0.20270781f, -0.24277121f, 
    -0.16024148f, -0.23159346f, 0.02396826f, -0.30637506f, 0.10195417f, 0.06393014f, -0.12449889f, 0.22535209f, 
    -0.14857198f, -0.01849709f, 0.52991110f, -0.06021726f, -0.09441248f, -0.13944554f, 0.30609307f, -0.15456197f, 
    0.00387451f, -0.30359235f, 0.00486424f, -0.05320672f, 0.35661289f, 0.13514785f, 0.19960658f, -0.09206131f, 
    0.10276013f, 0.06003143f, 0.52922249f, 0.09364550f, -0.74963140f, -0.15389457f, 0.38547075f, -0.16243969f, 
    0.00217757f, 0.26910651f, -0.14874579f, 0.29445365f, -0.17323604f, 0.09490402f, -0.04173631f, -0.02343379f, 
    0.58081239f, -0.25737202f, 0.40122363f, 0.48277989f, -0.34716350f, -0.08117477f, 0.38270494f, -0.09928652f, 
    0.10572424f, -0.41008705f, -0.15184514f, -0.07567678f, 0.23832801f, 0.12715156f, 0.19192414f, -0.07698397f, 
    0.00193211f, 0.00279116f, -0.13244747f, 0.10207631f, 0.09091821f, -0.07810763f, 0.14000955f, 0.20128919f, 
    0.07179052f, -0.17624755f, 0.17636698f, 0.09924103f, 0.02492778f, -0.01193567f, 0.11375707f, -0.10957406f, 
    -0.18661454f, 0.13245654f, -0.48881787f, 0.03302262f, -0.26343888f, 0.14909387f, 0.15659012f, -0.05935129f, 
    0.53104335f, -0.24327552f, 0.11289473f, -0.18293092f, 0.04648292f, -0.06308036f, -0.23785523f, 0.09253447f, 
    0.01253303f, 0.19842878f, -0.01544122f, -0.04550786f, 0.45457163f, 0.16363478f, 0.65417105f, 0.42096147f, 
    -0.29703969f, -0.03576614f, 0.26143387f, -0.11801839f, 0.08791084f, 0.04678936f, -0.13473313f, 0.11223914f, 
    -0.27649844f, -0.14878424f, -0.20586039f, -0.14733768f, 0.24496645f, 0.03912199f, -0.12168486f, -0.11277962f, 
    -0.50729454f, 0.23856510f, -0.12949763f, 0.27939773f, 0.41458520f, -0.01797283f, 0.15329561f, 0.24431451f, 
    -0.10288143f, -0.11269233f, -0.18917844f, 0.51603943f, 0.00297378f, 0.07001732f, -0.13480683f, 0.29334116f, 
    -0.11289036f, -0.11720952f, -0.05784928f, -0.16808879f, 0.05780485f, 0.01459649f, -0.10775927f, -0.10233379f, 
    -0.02351849f, -0.10081789f, -0.04866379f, -0.01261673f, -0.01069381f, -0.12978016f, -0.10221797f, 0.15988243f, 
    -0.19935809f, 0.04427139f, 0.06576860f, 0.07116591f, -0.18784346f, 0.07490148f, 0.11345689f, -0.10662024f, 
    -0.09907147f, 0.08937825f, 0.01827474f, -0.02670990f, 0.04518020f, 0.00136122f, -0.13067460f, -0.12454585f, 
    -0.19139786f, -0.00062218f, 0.41780609f, 0.22702804f, 0.05632098f, -0.09423732f, 0.02455246f, -0.06585734f, 
    0.27329832f, -0.10122205f, 0.38712335f, 0.13992219f, 0.50345784f, 0.06503496f, -0.33459350f, 0.08204371f, 
    0.14824985f, 0.36171344f, -0.13556169f, -0.07798892f, -0.21644902f, -0.00625109f, 0.00532621f, 0.24613425f, 
    0.05969635f, 0.30533019f, -0.14659163f, -0.19501838f, 0.48236680f, -0.08700690f, -0.54804468f, 0.36817423f, 
    -0.39904088f, -0.18009594f, 0.03688119f, -0.16092618f, -0.12433657f, -0.14052598f, 0.13989171f, -0.01871681f, 
    0.13217027f, -0.11691416f, 0.18318272f, -0.15491697f, 0.04681487f, -0.02089065f, 0.16184576f, 0.11255219f, 
    0.39831054f, -0.35112423f, -0.17102180f, -0.14372666f, 0.00072292f, 0.07849693f, 0.03978322f, 0.07084931f, 
    -0.14334336f, 0.22167988f, -0.11717906f, 0.02482941f, 0.21354437f, 0.07345518f, -0.15815976f, 0.09508016f, 
    -0.24216340f, -0.16616470f, 0.42016125f, -0.21176338f, -0.05246864f, 0.13527603f, 0.07657700f, 0.35757107f, 
    -0.10040448f, 0.28522947f, 0.07433628f, 0.04735377f, 0.38040036f, 0.07403807f, -0.07033490f, -0.13799448f, 
    0.39732313f, -0.02414597f, -0.02534093f, -0.02252890f, -0.24479152f, -0.08478510f, -0.19944063f, 0.26251951f, 
    -0.17687334f, 0.41258490f, 0.22754347f, -0.39662796f, -0.34729445f, 0.16348487f, 0.59329045f, -0.03617749f, 
    0.08209588f, -0.29209620f, 0.10881184f, -0.27742359f, 0.10679813f, 0.04253324f, -0.01401493f, 0.29449126f, 
    -0.48220447f, 0.25447756f, -0.24808681f, -0.09547834f, 0.27660748f, -0.11889015f, 0.10429931f, 0.01446377f, 
    0.02545403f, 0.11670589f, 0.05461025f, 0.24774066f, 0.11345750f, -0.01432889f, 0.04162800f, 0.21150620f, 
    0.13068806f, -0.37486342f, 0.13449004f, 0.47958729f, -0.23863722f, 0.12958255f, -0.28368491f, 0.01905157f, 
    -0.09722663f, -0.14736529f, -0.02320450f, -0.10700063f, -0.00129409f, -0.01016204f, 0.10076467f, 0.03645343f, 
    0.09962881f, -0.16891898f, -0.14872001f, 0.16341604f, -0.03039868f, 0.10699426f, -0.08469533f, 0.09326784f, 
    0.03296505f, 0.14423078f, 0.10575616f, -0.16922176f, 0.12413819f, -0.13748032f, -0.11584303f, 0.04385561f, 
    -0.10358270f, -0.12367722f, -0.14720924f, 0.16428949f, 0.14516230f, -0.01007674f, -0.15882303f, -0.02391306f, 
    0.00417171f, -0.21514170f, -0.02601469f, 0.19597018f, -0.16348892f, 0.07980891f, 0.09806126f, 0.03844298f, 
    -0.34703183f, 0.03606326f, -0.43434340f, 0.24583079f, 0.33963245f, 0.11159609f, -0.13910855f, -0.13803788f, 
    0.07465308f, 0.16439751f, 0.10819624f, 0.02095199f, 0.02130762f, 0.09642060f, -0.12569757f, 0.17100869f, 
    -0.00293056f, 0.01880950f, -0.08074827f, -0.14240195f, 0.62839496f, -0.00233643f, -0.10415881f, 0.37205046f, 
    -0.01397474f, -0.14993222f, 0.01160395f, -0.17167024f, 0.07537635f, 0.04410716f, 0.10836338f, -0.15454373f, 
    -0.10791913f, 0.06597272f, 0.10125076f, 0.00282892f, -0.12136941f, -0.08578757f, -0.16574779f, -0.04189532f, 
    -0.12229629f, -0.09277674f, 0.12207348f, 0.03704419f, 0.04408249f, -0.11513571f, -0.15098330f, 0.13429391f, 
    0.15812182f, -0.06125326f, -0.17145239f, 0.12668972f, 0.09827971f, -0.03405946f, 0.08336307f, -0.02746274f, 
    -0.08908650f, -0.05986231f, -0.05298476f, 0.11635667f, -0.10607044f, -0.12510064f, 0.14899676f, -0.16231012f, 
    0.07999817f, -0.10339443f, -0.10836329f, -0.12258305f, -0.04395007f, 0.14534032f, 0.04826995f, 0.01158330f, 
    -0.03686664f, -0.00740857f, -0.07189150f, -0.04162213f, 0.11392988f, 0.17647658f, -0.06842973f, -0.17103392f, 
    -0.01765923f, 0.00780365f, -0.11546309f, -0.11081370f, -0.06302012f, 0.12855572f, 0.04617078f, 0.09722471f, 
    0.32912299f, -0.05148487f, 0.16734952f, -0.19383025f, 0.09836908f, -0.14645128f, 0.16020206f, -0.35476369f, 
    -0.03734760f, 0.17475760f, 0.45505124f, -0.48432153f, -0.04111603f, -0.05718261f, 0.03134195f, 0.12290651f, 
    0.49301839f, -0.01640931f, -0.00183047f, 0.32555991f, -0.50519806f, 0.02224260f, 0.19124666f, 0.19383597f, 
    0.15143868f, 0.32126397f, 0.24055628f, -0.13900907f, 0.31027585f, -0.00605648f, -0.43880588f, 0.08582080f, 
    -0.06907783f, 0.00978566f, -0.01207764f, -0.22154529f, 0.09636047f, 0.06279358f, -0.16989401f, 0.11458334f, 
    -0.16450207f, -0.03132808f, 0.04123020f, -0.02607779f, 0.06302936f, 0.16205110f, -0.18479291f, 0.12177737f, 
    -0.10503980f, 0.06424877f, -0.04482393f, -0.16897801f, -0.06361293f, 0.05552837f, 0.04291788f, -0.08356038f, 
    -0.10334801f, 0.02406953f, 0.02349581f, 0.08422451f, -0.05247419f, 0.08273514f, -0.17567976f, -0.03110230f, 
    -0.18882856f, 0.10237052f, -0.02279501f, -0.20179941f, 0.00590530f, -0.16340511f, 0.07246226f, 0.10014927f, 
    -0.17027609f, -0.10752124f, 0.00179371f, -0.10101725f, -0.01244898f, -0.10555333f, -0.13916579f, -0.15909107f, 
    -0.06054542f, -0.17190452f, -0.07547306f, -0.05906181f, 0.02690293f, 0.06972056f, -0.12632805f, 0.08453620f, 
    0.10564711f, 0.02460572f, 0.04129678f, -0.17974140f, -0.08804394f, 0.09340208f, -0.09525153f, -0.00384467f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.08921156f, -0.08959547f, 0.01717193f, 0.18049340f, 0.01104928f, -0.08726387f, 0.03469191f, 0.13186079f, 
    0.12909062f, -0.18600282f, 0.02311754f, 0.24045305f, -0.10572524f, -0.10966302f, 0.27524975f, 0.27837640f, 
    -0.05683667f, -0.13682503f, 0.04082953f, 0.07236946f, -0.21297902f, -0.05846872f, 0.06795484f, 0.26100251f, 
    0.13469227f, 0.06238221f, -0.22107542f, -0.14058176f, 0.14419125f, 0.16313487f, -0.04821379f, 0.04797301f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.24397722f, 0.01121663f, 0.18442906f, -0.36684883f, 0.48061165f, 0.50751776f, 0.01042633f, 0.07983030f, 
    -0.00389201f, -0.07462547f, -0.08438015f, 0.18475606f, -0.14189360f, -0.30232874f, 0.31156817f, 0.34535724f, 
    -0.02364225f, -0.20237219f, 0.22036017f, -0.12992105f, -0.09486255f, -0.04420712f, -0.15287533f, 0.55786794f, 
    -0.09513576f, 0.00412883f, -0.23382890f, 0.01630318f, 0.15266967f, 0.23778576f, 0.16785482f, -0.10085119f, 
    0.00930519f, -0.16099447f, 0.16795176f, 0.12466730f, 0.09536746f, -0.01480128f, -0.03143445f, 0.15169995f, 
    0.13038652f, -0.07192884f, -0.06885713f, -0.17333278f, -0.17527920f, -0.06783006f, 0.13115269f, -0.07590541f, 
    0.10575490f, -0.10954278f, 0.05745375f, 0.12537290f, -0.09106067f, -0.10800944f, 0.04026356f, -0.07826798f, 
    0.13772964f, 0.10675426f, 0.18016173f, 0.08350685f, -0.15175198f, -0.15632394f, 0.17242341f, -0.13035285f, 
    -0.25599495f, 0.03298453f, -0.25285500f, 0.18602833f, -0.30368847f, -0.17628057f, -0.16894281f, 0.04166016f, 
    0.58525115f, -0.08399796f, 0.32901418f, 0.32032955f, 0.36387071f, -0.02337330f, 0.11136138f, 0.04188538f, 
    0.48190826f, 0.14691938f, 0.03447619f, 0.18150079f, -0.02007385f, -0.45469263f, -0.33033025f, 0.16199736f, 
    -0.05558491f, -0.04223683f, -0.36014464f, 0.01760775f, 0.03621559f, -0.36235827f, 0.00869709f, 0.10400701f, 
    -0.25267813f, -0.10369592f, 0.53604704f, -0.00989395f, 0.03521958f, 0.07275122f, -0.01430168f, -0.01412733f, 
    0.10220548f, 0.03563866f, 0.07268297f, 0.20487460f, -0.03030345f, 0.48203540f, -0.80925405f, 0.24019755f, 
    -0.00146112f, 0.36085370f, 0.32373938f, -0.29241139f, 0.05747333f, -0.24249616f, -0.14884053f, -0.17342445f, 
    0.01973746f, 0.09665442f, 0.01397544f, -0.03741626f, 0.00515033f, 0.27573907f, 0.04431022f, 0.10142670f, 
    0.49202427f, -0.07160182f, -0.20021291f, -0.23799898f, 0.13378130f, 0.09948257f, -0.17145891f, -0.14631464f, 
    0.06153740f, -0.02472871f, 0.05489951f, 0.16465545f, 0.32083818f, 0.12530415f, 0.02252657f, 0.05047886f, 
    -0.53102511f, -0.21142437f, -0.31455603f, 0.20816277f, -0.08492523f, 0.47819769f, -0.52354592f, -0.22799441f, 
    0.10024258f, 0.01166127f, 0.45253223f, -0.13057241f, -0.15225783f, 0.16872731f, 0.08847219f, 0.15758881f, 
    0.28081957f, -0.00519650f, -0.19842282f, 0.50664186f, 0.05357376f, 0.04276866f, -0.15118966f, -0.05431230f, 
    -0.18048976f, 0.12667146f, -0.29404527f, 0.14886348f, -0.11636470f, 0.08214532f, 0.13746722f, -0.13269496f, 
    -0.19006956f, -0.11001339f, 0.48239449f, 0.51137298f, 0.12305994f, 0.32337543f, 0.29164764f, -0.18780117f, 
    -0.00474016f, 0.07613990f, 0.62359154f, -0.11239000f, 0.12369012f, -0.09346429f, -0.12350574f, -0.03054340f, 
    0.45064318f, 0.08106129f, -0.20431051f, -0.16280106f, 0.23087884f, 0.36077815f, -0.02372936f, 0.02208368f, 
    0.03194559f, 0.07889157f, -0.21831816f, 0.34174067f, 0.31396574f, -0.21162283f, 0.10442925f, 0.14162497f, 
    0.03600848f, -0.34599134f, 0.22875741f, 0.38308439f, 0.05874687f, -0.12196916f, -0.14325704f, 0.14570585f, 
    0.12935251f, 0.08865713f, 0.09065819f, -0.09511888f, -0.09483349f, -0.03207319f, -0.13583489f, -0.00294354f, 
    -0.02458218f, -0.13952668f, -0.10441407f, -0.02604987f, 0.08481653f, -0.04962349f, -0.05586116f, -0.11286176f, 
    0.03009467f, -0.00388240f, 0.10654572f, 0.14091516f, -0.12183524f, -0.01824993f, -0.11887936f, -0.15284210f, 
    -0.03433321f, -0.14929031f, -0.06762276f, -0.20800337f, 0.11924089f, 0.12947243f, -0.09678509f, -0.04621471f, 
    -0.10142957f, -0.14909998f, -0.06231018f, -0.11183877f, 0.09866446f, -0.13187975f, -0.03549713f, -0.08716202f, 
    0.07751811f, -0.07133028f, 0.05642176f, -0.21017498f, -0.28147110f, -0.19392154f, -0.04194997f, -0.16196094f, 
    0.05698714f, -0.15890893f, 0.21493866f, 0.14108257f, -0.19203243f, 0.21147542f, 0.16247006f, 0.06857353f, 
    0.39645547f, 0.32972425f, -0.51787168f, 0.46829444f, 0.02438418f, 0.04467607f, 0.03255953f, -0.37328830f, 
    0.39297074f, -0.16245417f, -0.10971083f, 0.04770604f, -0.01488681f, 0.06615126f, -0.18002217f, -0.13567004f, 
    -0.08920550f, -0.08191737f, -0.10182662f, 0.15708388f, 0.07187000f, -0.05579245f, -0.14324057f, -0.13977157f, 
    0.29443264f, -0.10549324f, -0.04780253f, 0.18250589f, 0.35427254f, 0.19644275f, -0.13159345f, -0.01358325f, 
    -0.08820065f, 0.04769183f, 0.92371398f, 0.00006343f, -0.19038469f, -0.32253104f, 0.05961308f, 0.08075580f, 
    0.03603799f, 0.14336230f, 0.42045459f, 0.08156759f, 0.08630165f, -0.16541028f, 0.03392258f, 0.00846641f, 
    0.22046418f, 0.05799070f, 0.35776505f, 0.20112310f, 0.14972878f, 0.52986020f, 0.04449875f, -0.12157869f, 
    -0.20502898f, -0.05166062f, 0.12014103f, 0.11623859f, -0.47289535f, 0.29468486f, 0.11206132f, 0.21319872f, 
    0.01060779f, -0.29926476f, 0.01652839f, -0.05666944f, 0.01596471f, -0.24720557f, 0.31798330f, 0.20131758f, 
    0.18777291f, -0.13741326f, -0.21136604f, -0.16060531f, -0.06720105f, 0.18529142f, -0.11451256f, -0.08061466f, 
    -0.24429128f, -0.03172136f, -0.06455274f, -0.00346955f, 0.19856402f, 0.04720527f, 0.05297072f, 0.10032246f, 
    0.33012074f, -0.08412028f, -0.16094406f, 0.11633742f, 0.29124182f, -0.08051524f, 0.12757963f, -0.18757561f, 
    0.50949287f, 0.05905999f, 0.35586709f, -0.15151946f, -0.16625996f, -0.26732677f, -0.20056181f, 0.52077007f, 
    0.10441305f, 0.12911053f, -0.14327189f, 0.06888984f, 0.10704263f, -0.10351739f, -0.10929531f, -0.17964299f, 
    0.10420039f, -0.12182759f, -0.12046813f, -0.04353762f, 0.04992853f, 0.06700858f, 0.12961605f, 0.02376115f, 
    -0.04901895f, -0.17409061f, -0.08529029f, -0.16815475f, -0.06283285f, 0.05441184f, 0.15059975f, -0.07169576f, 
    0.14880952f, -0.17719524f, 0.09020587f, -0.00264394f, -0.04914807f, -0.10795890f, 0.12066320f, -0.08222996f, 
    0.03428068f, -0.00764276f, 0.16538699f, 0.03273898f, -0.10333674f, -0.13655014f, 0.10459517f, -0.06222672f, 
    -0.07676352f, 0.16482873f, 0.00925162f, -0.03880138f, -0.12123587f, 0.09534187f, 0.13424909f, 0.09960691f, 
    -0.01928932f, -0.17409274f, -0.07435718f, -0.01589973f, -0.13564977f, -0.17605920f, 0.12694359f, -0.14133465f, 
    0.07092009f, 0.03955498f, -0.01814695f, -0.12555963f, 0.14716122f, -0.07374936f, 0.16539472f, 0.08247908f, 
    -0.02080859f, 0.03636251f, 0.00528454f, 0.16319443f, -0.03542232f, -0.03172750f, 0.07762746f, 0.11432162f, 
    -0.17961021f, 0.02533801f, -0.19999287f, 0.10565569f, -0.08065196f, 0.02257132f, 0.11887061f, 0.10340156f, 
    0.10726529f, -0.12033641f, -0.15975070f, -0.02106978f, 0.11617821f, -0.15027049f, -0.18777266f, -0.14869443f, 
    -0.10639323f, -0.10734422f, -0.04619272f, 0.12433928f, -0.15710786f, 0.12721996f, 0.16466978f, 0.07332122f, 
    -0.06875890f, -0.13604867f, 0.04848978f, 0.00338892f, -0.02826785f, -0.05974454f, -0.01357847f, -0.13963109f, 
    0.31427175f, 0.16240166f, -0.19563659f, 0.47001275f, 0.10854954f, 0.27223673f, 0.04470628f, -0.14174096f, 
    0.07499756f, 0.02911114f, -0.23251253f, -0.16268638f, -0.00141081f, 0.20869589f, 0.12308938f, -0.17679438f, 
    -0.18382326f, -0.14098608f, 0.66580445f, -0.14074354f, 0.03693927f, 0.29010957f, 0.36249354f, 0.43448946f, 
    0.15014425f, 0.16547364f, 0.77539814f, -0.13486114f, 0.03428952f, 0.23673268f, -0.01221552f, 0.05097063f, 
    -0.20035304f, 0.13721111f, 0.62583315f, 0.43588006f, -0.24056932f, 0.44922665f, 0.02458404f, -0.12319532f, 
    -0.11627968f, -0.14961554f, 0.16937725f, -0.06489278f, -0.36459929f, 0.24709995f, -0.56913573f, 0.37961432f, 
    0.03415357f, 0.18050329f, -0.03555426f, -0.25412729f, 0.05653379f, 0.28772986f, 0.24752417f, 0.08863651f, 
    -0.20994291f, -0.00210346f, -0.14472809f, 0.12531352f, -0.10920035f, 0.51780879f, 0.00155103f, -0.05095091f, 
    0.03764704f, 0.10690552f, -0.20342296f, -0.00394755f, -0.00003829f, 0.03817871f, 0.09471606f, 0.08243555f, 
    -0.10445473f, -0.10278217f, -0.07692639f, -0.07554955f, 0.02129729f, -0.17972369f, 0.13916704f, -0.17120115f, 
    0.04927541f, 0.03539249f, 0.06488236f, -0.16897972f, -0.15178546f, -0.02069390f, 0.09742501f, 0.01091580f, 
    -0.20150785f, 0.14035809f, -0.09759919f, 0.05488122f, -0.15826172f, 0.11887266f, -0.10601412f, 0.16393019f, 
    0.15430740f, 0.11152396f, -0.03488824f, 0.61623758f, 0.02258894f, -0.08426122f, 0.09512217f, -0.11323861f, 
    -0.12198677f, -0.07776999f, 0.13973901f, -0.19812784f, -0.09614670f, 0.13046350f, 0.25989825f, -0.15545437f, 
    -0.10370649f, 0.11097195f, -0.23294759f, 0.30416673f, 0.00485746f, 0.79377031f, 0.18754517f, 0.22491631f, 
    0.08598677f, 0.01709341f, 0.32366937f, -0.11326300f, 0.03853513f, 0.17146435f, 0.16324422f, 0.00097998f, 
    0.13685302f, -0.14715701f, 0.45755813f, -0.63602912f, 0.22863108f, 0.64307028f, -0.05588567f, 0.15585612f, 
    -0.21628086f, 0.02498690f, -0.05159226f, 0.22164974f, 0.26401451f, -0.26702574f, -0.04182633f, 0.39474329f, 
    -0.03674296f, -0.33348322f, -0.40821722f, 0.02482961f, -0.00651444f, 0.08703132f, -0.59439981f, 0.07040941f, 
    0.07662398f, -0.00928276f, -0.37138847f, -0.01995854f, 0.13759856f, 0.27474898f, -0.05275837f, -0.08926513f, 
    0.02236665f, -0.13856208f, 0.03069349f, 0.39086938f, -0.30021036f, -0.31657773f, 0.20286897f, 0.04134325f, 
    0.29189733f, 0.14096008f, 0.12987924f, 0.24389681f, -0.30416933f, 0.42105913f, 0.09081158f, -0.15900181f, 
    0.57585061f, 0.15606375f, -0.31790525f, 0.20775558f, -0.07648978f, -0.40902990f, 0.36561972f, -0.16369656f, 
    0.23613068f, -0.06114223f, -0.15366033f, -0.16844900f, -0.01311233f, -0.01727192f, -0.06315590f, -0.05138418f, 
    0.08286647f, -0.05827498f, -0.29721648f, -0.39405304f, 0.44112915f, -0.19756781f, 0.05145808f, 0.06931180f, 
    0.15746120f, -0.03618971f, 0.07247142f, 0.25301537f, 0.26853383f, 0.33437032f, -0.15869395f, -0.33168846f, 
    0.07991648f, -0.25603309f, -0.26445410f, 0.28245237f, -0.01734999f, -0.18045068f, 0.05329931f, -0.18259825f, 
    0.39215469f, -0.04141497f, 0.36656958f, 0.17581162f, 0.09208142f, -0.03901535f, 0.14339460f, -0.09930707f, 
    -0.33945465f, 0.15210219f, 0.08021582f, 0.65309703f, -0.41073841f, -0.26067889f, -0.08431344f, 0.00480461f, 
    0.28620476f, -0.16520561f, 0.12288462f, 0.17947173f, -0.10812193f, 0.05268351f, 0.10462036f, -0.03822662f, 
    0.28925747f, 0.60185218f, -0.17505154f, -0.03356981f, -0.03707198f, -0.08812128f, 0.47807729f, -0.00121150f, 
    -0.10467500f, 0.01715728f, -0.17080562f, 0.07261221f, -0.07128927f, 0.01797945f, -0.04773687f, 0.14955187f, 
    -0.14814697f, -0.15041192f, -0.13840726f, 0.20140977f, 0.38918188f, 0.15967789f, -0.11036930f, 0.10512214f, 
    0.19243722f, 0.14917700f, 0.05694691f, 0.09597608f, 0.16752213f, 0.08691041f, -0.20196299f, -0.11086152f, 
    -0.28137025f, 0.22723024f, 0.57474697f, -0.37816554f, 0.01939905f, 0.02799094f, 0.08803876f, 0.14860389f, 
    0.02267608f, 0.07692932f, 0.41507012f, 0.14739878f, 0.03920741f, -0.11154290f, 0.14530063f, -0.12616898f, 
    0.29150888f, -0.06054372f, -0.13645536f, -0.16725327f, 0.33412817f, 0.05166581f, 0.14653648f, -0.01995544f, 
    -0.27063060f, 0.16288669f, -0.01978339f, 0.21648656f, -0.26609734f, 0.24625862f, 0.35113952f, -0.03923794f, 
    0.35995999f, -0.42413470f, -0.14680423f, 0.31566167f, -0.06297542f, -0.17124949f, 0.07621273f, 0.13979499f, 
    0.64179814f, 0.08478746f, -0.28495738f, 0.06065816f, -0.08748147f, 0.29893643f, -0.05339932f, 0.13129330f, 
    -0.15700509f, 0.07146211f, 0.10536960f, -0.02380449f, -0.06496350f, 0.13291414f, 0.12738383f, 0.09626403f, 
    -0.14852802f, 0.01146940f, -0.13070115f, -0.09351607f, 0.08781341f, -0.16710763f, -0.02262084f, -0.13782021f, 
    0.09968239f, -0.11696795f, -0.10898066f, -0.06801230f, -0.01581076f, 0.05565108f, 0.11519577f, -0.18240657f, 
    -0.12547821f, -0.07896341f, 0.07324214f, -0.03876680f, 0.12729941f, 0.08952982f, -0.12991688f, -0.06863412f, 
    -0.33965179f, 0.01601261f, 0.15240709f, -0.13892905f, -0.21876132f, -0.31591392f, 0.06014417f, 0.10704665f, 
    0.46397713f, 0.02380556f, 0.43449032f, 0.28363952f, 0.47284657f, 0.37427953f, -0.25472352f, 0.31425211f, 
    -0.35271582f, 0.43742460f, 0.00594573f, -0.09813362f, -0.00732178f, -0.37643981f, -0.16799982f, -0.41923383f, 
    -0.24738944f, -0.09477863f, -0.01397963f, -0.09824692f, -0.13588375f, -0.08902468f, -0.03364541f, 0.01879720f, 
    0.06230750f, 0.10435028f, 0.05326632f, -0.60261869f, 0.06518513f, -0.12547946f, -0.16827990f, 0.11980160f, 
    0.03290854f, -0.10243498f, 0.44298920f, 0.36100143f, 0.30387929f, -0.27520183f, 0.35152814f, 0.27637029f, 
    -0.00720274f, 0.04644571f, -0.58136076f, 0.23136255f, -0.18071604f, -0.12027265f, -0.31439379f, 0.02225115f, 
    0.08420716f, 0.09219418f, -0.42311075f, 0.13910726f, -0.11758148f, 0.02825832f, -0.05676858f, -0.00471651f, 
    0.37008289f, -0.16747172f, -0.45025235f, -0.36813432f, -0.00175370f, 0.01220715f, -0.15819953f, -0.07033753f, 
    -0.09502354f, -0.14469598f, 0.15504842f, 0.10825858f, 0.19751565f, 0.11909339f, -0.00407140f, -0.28422010f, 
    -0.02533243f, -0.42053473f, -0.51600289f, 0.32757869f, -0.09564211f, 0.42957190f, -0.00878461f, 0.17011291f, 
    0.27538458f, -0.03817528f, 0.39594379f, -0.05737134f, -0.07337338f, -0.16650064f, -0.10253792f, -0.08144782f, 
    -0.07604408f, -0.03535939f, -0.14372052f, 0.08509803f, 0.09182125f, -0.02852031f, -0.13725932f, 0.05448776f, 
    -0.11311875f, 0.06032984f, -0.03758751f, -0.15603621f, -0.03567040f, 0.07919215f, -0.14343244f, -0.16587208f, 
    0.03147937f, 0.11975873f, 0.14485247f, -0.11935787f, 0.08937239f, -0.12702923f, 0.17450264f, -0.16055237f, 
    0.05819732f, 0.05426223f, -0.03548862f, 0.13236293f, 0.11244690f, -0.14396514f, 0.17518948f, -0.06526083f, 
    -0.03468323f, 0.12872069f, -0.06806497f, -0.08622973f, 0.00100984f, -0.15384777f, -0.10140551f, -0.15647438f, 
    0.11031933f, 0.06054932f, -0.08162869f, -0.17120461f, 0.04358513f, -0.16098410f, 0.10913517f, -0.00399997f, 
    -0.04296660f, -0.03867049f, -0.16083100f, 0.07952271f, -0.04631730f, 0.12943223f, -0.03829798f, -0.15533522f, 
    0.11792471f, 0.10256790f, -0.09069243f, -0.07408651f, 0.17056882f, -0.15659313f, -0.02209894f, 0.10888501f, 
    -0.01990423f, 0.01104422f, -0.16397822f, 0.26942191f, -0.43768555f, -0.28342733f, -0.02458652f, -0.10560083f, 
    0.35692185f, -0.06253695f, 0.29582733f, -0.14694232f, 0.44434705f, -0.37868443f, 0.19483599f, 0.23902155f, 
    0.12725490f, 0.44483718f, -0.13448565f, -0.06009521f, 0.13436171f, 0.60649502f, -0.05328607f, 0.15860714f, 
    -0.53709364f, -0.03753120f, 0.20869754f, -0.13386136f, -0.16251358f, 0.08979352f, -0.19381902f, 0.04206133f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.23872367f, -0.04560044f, 0.22405984f, -0.11586837f, 0.08184071f, 0.08035305f, 0.09750710f, -0.16424140f, 
    0.15136264f, 0.16347036f, 0.17845364f, -0.13682094f, -0.03034752f, -0.11828849f, -0.06463899f, -0.15272032f, 
    0.21359791f, 0.01526425f, 0.01996217f, 0.04468007f, 0.27165234f, -0.17095046f, 0.21114118f, -0.07406889f, 
    0.05876278f, 0.04376009f, 0.06221061f, 0.12278140f, 0.00040187f, -0.00985347f, 0.02426906f, 0.05776697f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.17379697f, 0.10306542f, -0.46115980f, 0.12214536f, 0.12970912f, 0.18385626f, 0.16230768f, -0.09226934f, 
    -0.48961049f, 0.40223217f, 0.16681841f, -0.32853678f, 0.00148888f, -0.12644963f, 0.01950697f, 0.33087513f, 
    0.05624260f, 0.05218560f, -0.03910637f, -0.02627579f, -0.55220520f, -0.53231722f, -0.53803307f, 0.27286354f, 
    -0.03924457f, 0.08186214f, -0.00381774f, -0.39575577f, -0.70239162f, -0.14079694f, 0.06098025f, -0.28217643f, 
    -0.06999315f, -0.11137909f, 0.31750107f, 0.10597004f, -0.18181789f, -0.37050703f, -0.08653146f, -0.06333821f, 
    -0.49460378f, 0.25816357f, -0.11575765f, 0.31260699f, 0.14192486f, -0.04980184f, 0.11075340f, 0.19841667f, 
    0.11259115f, 0.12548847f, -0.19708180f, -0.21045585f, 0.05872855f, 0.30947191f, 0.21957214f, 0.30600962f, 
    -0.45221013f, -0.16453362f, 0.01112854f, -0.39171374f, 0.23905297f, -0.00894110f, -0.15586105f, 0.11669058f, 
    0.35599989f, -0.09760027f, 0.34327987f, -0.09130608f, -0.56502980f, -0.92381400f, 0.26351058f, -0.17891689f, 
    -0.27045146f, 0.38752505f, 0.02828596f, 0.27959961f, 0.08911237f, 0.11634904f, 0.07342077f, -0.32063779f, 
    -0.20382415f, -0.08887926f, -1.20918334f, 0.29936251f, -0.25263506f, -0.32521057f, -0.10353840f, -0.10784468f, 
    -0.13287185f, 0.06924559f, 0.15401252f, 0.40152931f, -0.76326072f, -0.01062547f, 0.17124300f, 0.09500655f, 
    -0.01811504f, -0.01667690f, -0.10266360f, -0.60598499f, 0.25464842f, -0.12618285f, 0.15995550f, -0.13647844f, 
    0.00676192f, -0.31481043f, -0.00880384f, 0.23733263f, -0.06254496f, -0.03654956f, -0.18842089f, 0.02708470f, 
    -0.62114424f, -0.08660873f, 0.14382415f, -0.01130269f, 0.04696304f, 0.26913318f, -0.43995243f, -0.19545798f, 
    0.37869295f, 0.10996494f, -0.42776832f, 0.14407778f, 0.24681544f, 0.13458064f, -0.15821402f, -0.40817747f, 
    0.28843290f, 0.09491611f, 0.03495291f, -0.37621284f, 0.22565442f, 0.05425195f, 0.42606181f, 0.16279908f, 
    -0.09037038f, -0.27002266f, -0.00183880f, -0.01961587f, 0.15867490f, 0.05632733f, 0.05072971f, -0.01679119f, 
    -0.08073236f, 0.08466408f, 0.14419529f, 0.32501459f, -0.55000275f, -0.77323800f, -0.35621729f, -0.23421644f, 
    -0.01815151f, -0.06280352f, -0.52149755f, 0.09023733f, -0.13188870f, 0.13040197f, 0.12725461f, 0.06700365f, 
    0.05350852f, -0.06348825f, -0.23600586f, -0.08056045f, -0.52483761f, 0.50309825f, -0.38874424f, -0.05341710f, 
    -0.27567023f, -0.15124290f, 0.19165023f, -0.58221853f, 0.11548795f, 0.02025995f, -0.14252768f, 0.19957724f, 
    0.29995292f, -0.11557161f, 0.42055398f, -0.46708119f, 0.09469756f, 0.19114043f, 0.28602445f, -0.09447011f, 
    -0.20083132f, 0.08901672f, -0.16701251f, -0.44841626f, 0.15974356f, -0.07717414f, 0.06832495f, 0.15336852f, 
    0.21482836f, -0.02980103f, -0.35128975f, 0.22573261f, -0.43944383f, -0.89281249f, -0.07223743f, -0.15261257f, 
    0.06574047f, -0.52477360f, 0.39487660f, -0.21703109f, 0.07101807f, 0.02641846f, 0.08551329f, -0.09820416f, 
    0.42140460f, -0.08485118f, -0.08270643f, 0.35770729f, -0.05710942f, -0.27616179f, -0.18731883f, -0.59906512f, 
    0.29428431f, -0.08362693f, -0.41182151f, -0.12042999f, -0.10426265f, -0.04372333f, 0.11637074f, -0.41256574f, 
    -0.46875352f, -0.13897100f, -0.40231490f, -0.39255238f, 0.25120112f, 0.25491250f, 0.15376209f, 0.15644445f, 
    0.05268265f, 0.03891591f, -0.61647803f, -0.00780185f, 0.04250236f, -0.17174210f, -0.10957451f, 0.32813746f, 
    -0.33836716f, -0.13696885f, 0.36253354f, -0.30192441f, -0.42328861f, 0.17686567f, -0.40851530f, -0.06085047f, 
    -0.16988553f, -0.17437820f, -0.54138911f, -0.63364559f, 0.17300779f, 0.01328686f, -0.13641784f, 0.33841178f, 
    -0.36239305f, 0.14238258f, 0.35685447f, 0.08208209f, -0.14198118f, -0.29814598f, -0.63480651f, -0.04413413f, 
    0.31080326f, 0.02044108f, -0.62905169f, 0.01318099f, 0.12899823f, 0.13944359f, -0.03023537f, -0.60060853f, 
    -0.12984595f, -0.11822458f, -0.05759285f, -0.68141139f, 0.06286348f, -0.26305929f, 0.13034903f, 0.17189902f, 
    -0.49039567f, 0.14732715f, 0.45531806f, 0.22394414f, -0.24847543f, 0.10665062f, 0.03735376f, 0.37293184f, 
    -0.02795472f, 0.11206857f, -0.25041357f, 0.05241221f, 0.10536932f, -0.03520082f, -0.29148722f, 0.05191621f, 
    -0.03983311f, -0.44306496f, -0.11481766f, -1.06543398f, -0.01200389f, 0.13678715f, 0.07854791f, -0.33658460f, 
    0.25858474f, -0.07961749f, 0.20732324f, 0.30919099f, -0.39630869f, -0.56022704f, 0.02060273f, -0.45040148f, 
    -0.35191953f, -0.08049785f, 0.22630970f, 0.22719836f, -0.89347386f, 0.09474713f, 0.16889447f, 0.47618660f, 
    -0.41830808f, 0.16532092f, 0.30803710f, -0.30213800f, -0.11655799f, 0.20377910f, 0.11185750f, -0.06222244f, 
    0.37580878f, 0.12021732f, -0.16686587f, 0.26909116f, -0.09632199f, -0.10120431f, -0.14981182f, -0.24996701f, 
    -0.65852386f, -0.13796949f, -0.07471742f, -0.62099493f, 0.52926368f, 0.19603130f, 0.24430989f, -0.60514796f, 
    0.26112956f, 0.01739643f, -0.01551736f, -0.03968083f, -0.09765056f, 0.05775273f, 0.01699508f, -0.15401460f, 
    -0.29831803f, -0.16345660f, 0.02214702f, 0.32221738f, 0.07314374f, -0.26474485f, 0.03296040f, -0.08724536f, 
    0.34220904f, 0.10124725f, 0.02054243f, -0.46410573f, -0.01762246f, 0.08763407f, 0.14660110f, -0.40501824f, 
    0.03480557f, 0.03773129f, -0.54310089f, 0.05279620f, 0.32582438f, 0.17716543f, -0.00860184f, -0.18312164f, 
    0.00422646f, 0.16028865f, 0.33167440f, 0.02868487f, -0.30139351f, 0.07562318f, 0.10019165f, -0.63650256f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.01423725f, 0.09201529f, 0.00644437f, -0.16061708f, -0.02354408f, 0.05056283f, -0.18283735f, -0.24286883f, 
    0.06815976f, 0.20679931f, 0.12925403f, -0.24979809f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
