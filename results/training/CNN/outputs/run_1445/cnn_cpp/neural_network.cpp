#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.31254143f, 0.55090791f, 0.26396281f, -0.28401622f, -0.92294419f, 0.73127800f, 0.00337906f, 0.08797276f, 
    0.19181521f, -1.16937304f, -0.13732029f, -0.02925857f, 0.30956054f, -0.47823659f, -0.92191100f, 0.24491316f, 
    0.82795054f, -0.02889216f, 0.98346585f, -0.53293890f, -0.12359095f, 0.58163923f, 0.66237825f, 0.31117737f, 
    -0.36466670f, 0.49637774f, 0.11681174f, 0.26648077f, -0.28938407f, 0.12239167f, 0.56874245f, -0.20823050f, 
    0.58717901f, 0.60089737f, -0.54105937f, -0.72895539f, -0.57183242f, 0.19836712f, 0.56338066f, 0.29177061f, 
    -0.43225715f, -0.22319448f, -0.53004491f, 0.26602805f, -0.12196232f, -0.44923007f, -0.28748477f, 0.02147774f, 
    -0.48120061f, -0.83875823f, 0.25613835f, 0.65429962f, 1.05553854f, -0.61213624f, -0.03891703f, -0.40889204f, 
    -0.37572214f, -0.72058356f, -1.12640989f, -0.93757230f, 0.37543219f, -0.80834728f, 0.98996568f, -0.62658632f, 
    -0.17559581f, 1.17802632f, 0.21545178f, -0.08680329f, 0.62756634f, -0.22115366f, -0.07608058f, -0.14116672f, 
    0.78348559f, 0.30965197f, 0.77503878f, -0.36857164f, -0.69823778f, -0.34505907f, -0.22013305f, 0.49897680f, 
    0.29353312f, -1.31376815f, -0.43255919f, 0.31373957f, 1.26271796f, 0.05303262f, -1.26646912f, -0.28621691f, 
    -0.35393053f, -0.28816929f, -1.02941477f, -0.79805303f, -0.71018648f, -0.00134700f, 0.26556647f, 0.34633768f, 
    0.18620092f, -0.03547121f, 0.88959777f, -0.10961966f, 0.73237842f, 0.20089716f, 0.91910589f, -0.60902679f, 
    -0.71131873f, 0.35875002f, -0.69329709f, 0.28710195f, -0.63909948f, 1.26279557f, -0.80772024f, -1.04626524f, 
    0.90517926f, -0.93676364f, -0.15743645f, -0.12579192f, 0.18919621f, 0.61728525f, 0.58894551f, 0.76660389f, 
    0.07740723f, 0.31428334f, -0.43667752f, -0.20787197f, 0.35883176f, -0.35831353f, -0.88365537f, -0.59603316f, 
    -0.35958764f, 1.11239135f, 0.12273400f, 0.65086806f, -0.43808457f, -0.42733771f, -0.11811879f, 0.44498345f, 
    -0.61957753f, 0.52231932f, -0.71006531f, -0.17583153f, -0.10976970f, 0.26206380f, 0.34439850f, 0.86436945f, 
    0.05351190f, -0.15878740f, 0.19642758f, 0.96361303f, -1.00841856f, -0.67325747f, -0.28664643f, -0.18684578f, 
    -0.55172545f, 1.09680927f, -0.54526651f, -0.65618759f, 0.22602916f, -0.37503070f, 0.02089084f, -0.49511790f, 
    -0.36756021f, -0.66730374f, -0.40646854f, 1.11632991f, -0.65171629f, -0.30489680f, 0.78840709f, -0.03283259f, 
    0.18160266f, -0.46543524f, -0.27296290f, -0.68065250f, 0.69769681f, -0.96207893f, -0.93353188f, -0.51403975f, 
    -0.60335994f, -0.34527406f, -0.65912730f, -0.49926695f, 0.77423590f, 0.45849162f, 0.06143359f, -0.85425556f, 
    0.43870687f, 0.25570333f, -0.37009373f, -0.62317252f, -0.20839471f, 0.03278276f, -0.17268859f, 0.16781546f, 
    0.24900030f, 0.69995934f, 0.51373082f, 0.85792011f, -0.48489803f, -0.30380213f, 0.28558913f, 0.26765275f, 
    -0.13461277f, 0.34817398f, 0.55215663f, 0.11381286f, 0.21559466f, 0.57907414f, 0.45947373f, -1.00915909f, 
    -0.42627665f, -0.44716185f, -0.18512492f, -0.82698113f, -0.48960984f, -0.47010359f, -0.54444641f, -0.61535770f, 
    -0.67439842f, -0.14712267f, 0.39938557f, -0.50354040f, -0.72930229f, -1.36171377f, 0.53206813f, 0.75525820f, 
    0.47847366f, -1.32164967f, 1.00860834f, 0.07433794f, -0.87262648f, 0.50129437f, 0.86639673f, -0.19227780f, 
    0.30324781f, 0.02871144f, 0.84314072f, 0.36090517f, 0.67985493f, -0.62526470f, -0.62337494f, -0.74982131f, 
    0.61474228f, 0.37510890f, -0.25593814f, -0.65167755f, -0.58034927f, -1.32020450f, 0.21253671f, 0.78595746f, 
    0.61333179f, 0.02481362f, 0.40055612f, -0.39239261f, -0.09048868f, -0.18724917f, 0.39802614f, -0.13628219f, 
    0.44860986f, -0.37795293f, 0.02459596f, 0.32697421f, 0.64085454f, -0.96620607f, -0.29168049f, -0.42062807f, 
    1.26876009f, -0.30400541f, -0.24543053f, -0.21092314f, -0.51454031f, -0.30992499f, 0.85205328f, -0.90007293f, 
    -1.16084075f, 1.14561892f, 0.15298516f, -0.44212782f, 0.63885856f, 0.14500377f, 0.08387578f, 1.31328058f, 
    -1.05553401f, -1.12528431f, -0.60490263f, -0.08955432f, 0.20424184f, 0.24214780f, 0.41812539f, 0.22860406f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.47809425f, 0.26163313f, 0.42297235f, 0.07738575f, 0.64094687f, -0.09866814f, -0.18689001f, 0.44714925f, 
    0.28605229f, 0.32040414f, 0.60314053f, -0.19422807f, 0.04447090f, -0.12353355f, -0.14450753f, 0.26914883f, 
    0.66233283f, 0.23762694f, -0.06416017f, -0.12483521f, -0.00305026f, 0.07810177f, -0.19072360f, -0.55188692f, 
    0.08805702f, 0.43424311f, 0.06180944f, 0.42614257f, 0.62765449f, -0.21672150f, 0.04342679f, 0.30212402f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.02089928f, 0.03047199f, -0.05431090f, -0.00796405f, -0.04092259f, -0.01777393f, -0.02760481f, -0.04787861f, 
    -0.01666841f, 0.02998597f, 0.04787305f, -0.05363877f, -0.03681579f, -0.06300568f, -0.03014591f, -0.00977961f, 
    -0.03169400f, 0.01985692f, -0.03572398f, 0.01796652f, -0.01468520f, 0.02164355f, -0.02009509f, 0.05131723f, 
    -0.06339005f, 0.02278702f, 0.00497658f, -0.03028925f, -0.02143522f, -0.03336463f, 0.05152633f, 0.00742856f, 
    0.02064486f, 0.02722070f, 0.01001268f, -0.00562787f, -0.01839828f, -0.05725424f, -0.04395691f, 0.01172924f, 
    0.02316618f, -0.00354994f, -0.05010668f, 0.01418784f, -0.01587877f, 0.01195802f, -0.03071840f, 0.01893319f, 
    0.03726988f, -0.05260975f, -0.02350622f, -0.03778515f, 0.01540485f, 0.04948151f, -0.02037188f, -0.05618755f, 
    0.01142532f, 0.01669138f, 0.01301510f, -0.01347859f, 0.00052676f, -0.04338533f, 0.03293188f, 0.00272761f, 
    0.03786849f, -0.04713725f, -0.03477499f, 0.00101656f, -0.04138382f, 0.02237040f, -0.00536411f, -0.04757573f, 
    -0.06079648f, 0.03685597f, -0.01065611f, -0.01760607f, -0.01246808f, -0.02522545f, 0.03331342f, 0.01324271f, 
    -0.05216286f, -0.01446973f, 0.04800508f, -0.02975999f, -0.01606431f, -0.04057595f, -0.02258828f, -0.00419847f, 
    -0.05349287f, -0.01498701f, -0.03842924f, 0.03181598f, 0.01591018f, -0.03021312f, -0.02987505f, 0.03347515f, 
    0.02980666f, 0.02745186f, -0.06092657f, 0.03865485f, 0.00030335f, -0.06006955f, -0.01977299f, -0.04910491f, 
    0.02626495f, -0.01315848f, 0.04426701f, 0.01588393f, 0.01591551f, -0.01642372f, 0.00655143f, -0.03822999f, 
    -0.03352793f, -0.02040931f, 0.04442880f, -0.03988393f, 0.05027816f, -0.00096438f, -0.02128898f, -0.02806595f, 
    0.00558406f, -0.02047479f, 0.02051576f, -0.05786728f, 0.00958707f, -0.05854738f, 0.01362362f, 0.02099955f, 
    -0.05955030f, -0.00592126f, 0.03488444f, -0.03457468f, -0.05501962f, 0.04142115f, -0.01674070f, -0.01030291f, 
    0.01665703f, -0.03942332f, -0.00898301f, -0.01817602f, -0.03932096f, -0.04721153f, -0.00898561f, -0.04667773f, 
    -0.03334560f, -0.06087391f, -0.04316980f, 0.04817116f, -0.02363561f, 0.00225757f, 0.01755593f, -0.02309210f, 
    -0.00046859f, 0.04829058f, -0.03122712f, -0.03499886f, -0.02630659f, -0.01303369f, -0.02962626f, 0.01096926f, 
    -0.00872921f, -0.02221861f, -0.05490463f, -0.03048836f, 0.03710887f, -0.03453288f, 0.03051448f, 0.01431419f, 
    -0.03718052f, 0.00461131f, -0.02492679f, 0.03815262f, -0.00531891f, -0.04447656f, 0.03469878f, -0.05227108f, 
    0.00268309f, 0.05288398f, -0.03126419f, -0.05351191f, 0.03798572f, 0.00136809f, 0.00690101f, 0.03064839f, 
    -0.06182051f, 0.04231990f, -0.02580178f, -0.05502409f, 0.02448096f, 0.05362186f, -0.00490380f, -0.04519184f, 
    -0.02344503f, 0.03101619f, -0.02346452f, 0.02573350f, -0.04104599f, -0.03524932f, 0.03989577f, -0.02112064f, 
    -0.03355376f, -0.04824878f, -0.03937351f, -0.04371892f, 0.01703836f, 0.01935129f, -0.01518925f, 0.03984886f, 
    -0.04652322f, -0.01792967f, -0.06118951f, -0.01441220f, 0.01111791f, -0.03137200f, 0.00363618f, -0.04310292f, 
    -0.03873123f, -0.02655374f, 0.00055696f, -0.05923256f, 0.03505600f, -0.06279990f, 0.03836606f, -0.00025271f, 
    -0.00434035f, 0.05329577f, -0.00398612f, 0.00062136f, -0.01010133f, -0.05371891f, -0.00375354f, -0.01776589f, 
    0.01872032f, 0.00903061f, -0.03197852f, 0.01394811f, 0.03415020f, 0.03809860f, -0.05453196f, 0.00478433f, 
    -0.00304944f, 0.02786559f, -0.01606351f, 0.01117747f, -0.02511746f, 0.03061354f, -0.03745600f, 0.03765002f, 
    -0.03282350f, -0.02306694f, -0.03332593f, 0.03204762f, 0.02439900f, -0.04529958f, -0.03393545f, -0.01040906f, 
    -0.00276811f, -0.02467072f, -0.01054392f, -0.04001918f, 0.02077618f, 0.03162646f, 0.00919410f, 0.01830883f, 
    0.04634151f, 0.01236116f, -0.05321674f, -0.04424291f, -0.03736901f, -0.02802717f, 0.00150421f, 0.00196669f, 
    -0.02272896f, -0.06143766f, -0.02530594f, 0.04434174f, -0.01846532f, -0.00015219f, 0.04973507f, 0.03255862f, 
    0.01413924f, 0.03002974f, 0.03139313f, 0.03977092f, -0.03008637f, 0.02004769f, -0.03041634f, -0.04417995f, 
    0.05805472f, 0.01864873f, 0.07790801f, 0.01305778f, 0.05832607f, 0.12638974f, -0.02477875f, -0.09793570f, 
    0.01037061f, -0.24347487f, -0.02754440f, 0.17914912f, -0.05555898f, -0.06078381f, 0.03406354f, 0.13768907f, 
    -0.01636813f, 0.08260080f, 0.14464517f, 0.07637427f, 0.10731474f, 0.05696221f, -0.00952096f, -0.09353114f, 
    0.22728933f, -0.08709672f, 0.11171302f, 0.16769609f, 0.03811338f, -0.13343583f, -0.01862834f, 0.11123762f, 
    0.07676508f, -0.04218249f, 0.04144073f, -0.33267602f, -0.16259663f, 0.07430431f, 0.20980051f, -0.01993065f, 
    -0.07285814f, -0.16671677f, 0.10036356f, -0.22515260f, 0.02987668f, -0.27975723f, 0.03464139f, 0.27163336f, 
    0.13900168f, -0.41979605f, -0.27569330f, -0.02445811f, 0.06157273f, -0.01713662f, 0.36861849f, 0.45252010f, 
    -0.25699592f, -0.03846742f, 0.04679744f, -0.03645486f, 0.06965913f, 0.09374432f, -0.16925043f, 0.09188581f, 
    0.02191735f, 0.03881575f, -0.07802328f, 0.12953179f, -0.09689260f, -0.15755054f, -0.12188982f, -0.13527074f, 
    -0.04376802f, -0.44057363f, 0.04760791f, 0.06341542f, 0.02523655f, -0.02010277f, 0.11344802f, -0.06603152f, 
    0.04143123f, -0.36187521f, 0.18992805f, -0.23228729f, -0.07737018f, -0.15872689f, 0.04404811f, 0.16057310f, 
    -0.09530713f, -0.33725294f, 0.02516673f, -0.00737317f, 0.02286130f, -0.06120436f, -0.17644183f, -0.14617690f, 
    0.11434694f, 0.03226500f, 0.19220242f, -0.36899993f, -0.00672894f, 0.05301552f, 0.00567761f, 0.01594041f, 
    -0.13075894f, -0.15630430f, -0.09144769f, -0.38081485f, 0.07496288f, 0.01714098f, -0.92078310f, 0.01253863f, 
    -0.00278171f, -0.05144495f, 0.11707857f, -0.00251809f, -0.08500814f, -0.14531253f, -0.08257460f, 0.10819145f, 
    0.17022911f, 0.01939234f, -0.05312641f, 0.22548814f, -0.14149339f, 0.17659959f, 0.20667176f, -0.14821632f, 
    -0.12621006f, -0.21778511f, -0.20984858f, 0.01832554f, 0.00504498f, -0.16620794f, -0.16807482f, -0.01103294f, 
    -0.16591170f, -0.06908181f, 0.09267773f, 0.26856929f, -0.04942235f, 0.28042313f, 0.25079915f, 0.17086960f, 
    -0.07846490f, -0.00358228f, 0.02410304f, 0.10227621f, 0.02280536f, 0.09934448f, 0.00835180f, 0.11660928f, 
    -0.17134404f, 0.01068214f, -0.34908652f, -0.44635522f, -0.04919600f, -0.01670111f, 0.03391854f, 0.01380480f, 
    0.14279665f, -0.01935102f, 0.11772801f, -0.04606917f, -0.07889684f, -0.16647112f, 0.07161577f, -0.09502706f, 
    0.11379939f, -0.09231906f, 0.01278546f, -0.00550250f, 0.18503442f, 0.13959655f, -0.04873430f, 0.01601519f, 
    0.01548685f, 0.16845353f, -0.00412283f, -0.04155761f, -0.02163191f, -0.02755995f, 0.09986284f, 0.07323835f, 
    -0.02789617f, 0.05621596f, 0.08871884f, 0.00078739f, 0.15585674f, 0.18551192f, 0.04439576f, 0.16239136f, 
    0.06102774f, 0.12726986f, -0.10859051f, 0.01911916f, -0.03955938f, 0.06917132f, 0.05375797f, 0.00905697f, 
    0.12731726f, 0.06535783f, -0.18650427f, 0.01114626f, 0.31524375f, 0.06332123f, 0.12286068f, -0.00044101f, 
    0.42495283f, 0.43075085f, -0.03141046f, -0.11852248f, 0.10301056f, 0.04759986f, -0.07587867f, -0.11996629f, 
    0.22871983f, 0.10370933f, 0.38093460f, -0.08518762f, -0.02732199f, 0.19640344f, -0.01595752f, 0.01501418f, 
    0.14169233f, -0.00264374f, -0.04199897f, 0.20605253f, -0.09094919f, 0.09469813f, -0.01441395f, 0.08027019f, 
    -0.06648201f, 0.00654014f, -0.00851950f, -0.63983524f, 0.10469381f, 0.00207604f, 0.04320073f, 0.06237873f, 
    0.07907584f, -0.02939020f, 0.01692940f, 0.20080796f, -0.08905002f, -0.00984624f, -0.08998638f, -0.01288089f, 
    0.04344148f, -0.08605052f, -0.08604697f, 0.10024589f, 0.07613505f, -0.03714733f, 0.00868621f, 0.08089422f, 
    -0.08065303f, -0.03247634f, 0.25071728f, 0.15984629f, 0.28040326f, -0.01115749f, 0.00580725f, -0.15157311f, 
    -0.09241342f, -0.19981523f, 0.05786017f, 0.02200046f, -0.17845221f, -0.21802092f, 0.18323733f, 0.05480919f, 
    -0.23947218f, 0.09647904f, -0.03802368f, 0.01905842f, 0.15020885f, 0.17527233f, 0.00265845f, 0.16251306f, 
    0.12756185f, -0.42251956f, -0.15153897f, 0.34654090f, 0.04186213f, 0.07293916f, 0.13593410f, -0.04762440f, 
    -0.45756721f, 0.06420338f, -0.24820182f, 0.08640638f, -0.00187094f, -0.13469580f, -0.19664232f, 0.21867016f, 
    0.02447736f, 0.73137051f, -0.13461384f, 0.37929919f, -0.19159625f, 0.07341228f, -0.10304166f, -0.01019448f, 
    -0.15414219f, 0.07927110f, 0.05852608f, 0.04392942f, 0.34624147f, -0.06761683f, -0.47735730f, -0.30919045f, 
    0.11004736f, 0.01265310f, 0.10717157f, 0.03283779f, 0.05744500f, -0.04338282f, 0.01414182f, -0.20459354f, 
    -0.12269381f, -0.07572570f, 0.00740625f, 0.04268304f, 0.12239771f, 0.22919139f, -0.27533168f, -0.20909958f, 
    0.18149804f, -0.28714430f, -0.09624615f, -0.22168730f, 0.01566854f, 0.53092229f, 0.25814727f, 0.32780382f, 
    0.12317046f, 0.18736407f, 0.04244847f, 0.14023145f, 0.14964435f, -0.05181203f, 0.12458643f, 0.49099028f, 
    0.62034792f, -0.10215174f, 0.01471677f, -0.08515048f, -0.09210815f, -0.15533051f, 0.05003027f, 0.17102730f, 
    0.25291407f, 0.08405198f, -0.56711555f, -0.19159152f, -0.34978458f, -0.26293769f, 0.20925792f, -0.10939109f, 
    -0.47187510f, 0.54763734f, -0.08491898f, 0.07407156f, 0.01017601f, 0.12107736f, 0.15151447f, -0.04332167f, 
    0.23550600f, 0.29751003f, -0.67363662f, -0.17378341f, -0.32932395f, 0.19788808f, -0.52679461f, -0.05011957f, 
    -0.00957032f, -0.05384520f, 0.47623646f, -0.10316038f, 0.06389472f, 0.04440746f, -0.04027378f, -0.07876068f, 
    0.13851999f, 0.04664225f, 0.04856241f, -0.15951942f, 0.18951620f, 0.05888423f, -0.10467357f, -0.04399969f, 
    -0.24140486f, 0.09962793f, 0.22117138f, -0.02691622f, 0.04772682f, 0.33447847f, 0.02396077f, -0.15363355f, 
    -0.00351786f, -0.13742623f, -0.12970768f, 0.02153183f, -0.22178388f, -0.04291388f, 0.03508181f, 0.25450441f, 
    0.18756202f, 0.03307188f, 0.07855387f, -0.04218656f, -0.00389730f, -0.02025404f, 0.43459997f, -0.00764321f, 
    0.43327755f, -0.06609623f, -0.06248432f, -0.69351029f, 0.00513729f, -0.18066196f, 0.03828785f, -0.19209439f, 
    -0.00000688f, 0.01400988f, -0.03693609f, 0.05192186f, 0.21377058f, 0.02714519f, -0.02545115f, 0.13721436f, 
    -0.09527449f, -0.04764226f, -0.15636183f, -0.16290513f, -0.00684898f, -0.16474731f, -0.05080967f, -0.14620598f, 
    -0.01787690f, -0.11912930f, -0.23545945f, -0.08933237f, 0.11553854f, -0.18997866f, -0.05307697f, -0.15829083f, 
    0.09917109f, 0.09180091f, -0.00881851f, 0.21375084f, 0.07968614f, -0.43135875f, -0.08368533f, 0.11632428f, 
    -0.05980699f, 0.50717926f, -0.30510139f, 0.10855743f, -0.09051180f, 0.14132875f, 0.07061872f, -0.17540190f, 
    0.04207965f, 0.05787635f, 0.03068948f, -0.01264963f, -0.00242873f, 0.10857858f, 0.06208598f, 0.17337212f, 
    0.05058963f, 0.14264785f, -0.22222134f, 0.30767718f, 0.17998984f, 0.08672196f, 0.26827291f, 0.14006129f, 
    -0.63782483f, -0.26436374f, -0.34341240f, 0.06526817f, -0.00335954f, 0.05471881f, 0.14850546f, 0.24031945f, 
    0.26048312f, -0.19549181f, -0.33323321f, -0.27626497f, 0.24584763f, 0.12811683f, 0.19682981f, 0.14090486f, 
    0.02178969f, 0.13441449f, 0.06524964f, -0.02669924f, -0.17049414f, 0.17524345f, 0.12460917f, 0.13002643f, 
    0.52209193f, 0.30718106f, 0.27882233f, -0.13455354f, -0.08816264f, -0.01820872f, 0.14805767f, -0.12343644f, 
    0.14101966f, 0.21289596f, 0.41756973f, -0.27599677f, -0.08182412f, -0.04919032f, -0.14822447f, -0.01815239f, 
    0.22146806f, 0.01537636f, -0.27804404f, 0.21618181f, 0.44852284f, -0.04893765f, 0.10314091f, 0.18823887f, 
    0.17678225f, 0.03696120f, 0.00874849f, 0.27185509f, -0.04075681f, 0.15087670f, -0.03096259f, -0.34622711f, 
    -0.23132627f, 0.03166321f, 0.02368346f, -0.06829365f, 0.07658570f, 0.05812990f, -0.02535820f, -0.03430727f, 
    0.11259887f, -0.01867487f, 0.12576543f, 0.05625755f, 0.13979718f, 0.16512637f, -0.75607562f, 0.13678280f, 
    -0.08203744f, 0.02283509f, -0.30119222f, -0.08754793f, -0.17567752f, 0.16102174f, 0.02560032f, -0.37232736f, 
    0.48509416f, -0.30066803f, -0.32481742f, -0.22465935f, 0.15633033f, 0.06290466f, 0.22537854f, -0.36486974f, 
    0.28782156f, 0.25422540f, 0.11750748f, -0.00248513f, 0.13813274f, -0.08774970f, 0.05204253f, -0.07068071f, 
    0.07439555f, 0.13565426f, 0.12029516f, -0.05191405f, -0.00817669f, 0.03825985f, 0.12602414f, -0.03350541f, 
    -0.13563676f, 0.02310233f, 0.14813069f, -1.01758516f, 0.03326739f, 0.04698679f, 0.04453935f, -0.08634195f, 
    -0.05762197f, 0.09742084f, 0.27333573f, 0.05850568f, 0.13177617f, -0.01117233f, -0.06980374f, -0.02105710f, 
    -0.04577402f, -0.04938497f, -0.06580810f, 0.10146502f, -0.09158268f, 0.12049019f, 0.04699323f, 0.08767056f, 
    0.04193695f, -0.23643115f, 0.12582807f, 0.37748080f, 0.23732622f, 0.50358844f, 0.67203343f, 0.13326226f, 
    0.26131219f, 0.17156744f, 0.04163493f, -0.03832752f, 0.15062547f, -0.38716432f, 0.01680373f, -0.23756589f, 
    0.12613404f, 0.27542394f, -0.12434161f, -0.07267066f, -0.15445350f, -0.06594592f, 0.44446406f, 0.08453535f, 
    -1.30490565f, -0.15597436f, 0.06089925f, -0.02363894f, -0.23340395f, -0.03016097f, -0.03663615f, 0.15066367f, 
    0.16654736f, 0.14273696f, 0.01626843f, 0.08828445f, 0.05128163f, -0.08278195f, -0.08002673f, -0.01816495f, 
    0.19408105f, 0.14400764f, 0.08979605f, -0.00340508f, 0.01227122f, 0.00257927f, 0.04095531f, -0.00179556f, 
    -0.03894358f, 0.18200904f, -0.00033016f, -0.99658537f, -0.27139223f, 0.02354868f, -0.00971072f, 0.20123555f, 
    0.09980167f, 0.05246764f, -0.35079083f, -0.41124558f, -0.12923089f, -0.03219470f, -0.00000176f, 0.15337956f, 
    0.09879362f, -0.01906046f, 0.00795503f, 0.19704726f, -0.22690697f, 0.26277369f, -0.05574820f, 0.16691144f, 
    -0.05810810f, 0.07112163f, -0.05869078f, -0.25146282f, -0.57883728f, -0.20819926f, -0.79263866f, 0.06019694f, 
    0.30898005f, 0.13733079f, 0.05512571f, 0.00043384f, 0.14057030f, 0.11703352f, 0.10314987f, 0.21230917f, 
    -0.11806089f, -0.10622927f, -0.08729207f, 0.07314659f, -0.00478575f, -0.15331766f, -0.27479386f, -0.18995489f, 
    -0.46190655f, -0.14330478f, -0.22528864f, -0.38297182f, -0.08899231f, -0.08427249f, -0.13781886f, -0.04843346f, 
    -0.04701973f, -0.12050405f, 0.20091110f, -0.07802810f, -0.04900431f, 0.14740075f, 0.11310992f, 0.08973043f, 
    0.31396258f, -0.27993107f, -0.10774338f, 0.09000764f, 0.16306007f, 0.09131801f, 0.01618038f, 0.15900493f, 
    0.08952072f, 0.61632609f, -0.33779290f, -0.24721496f, -0.02483222f, -0.00425494f, 0.08447905f, -0.10286524f, 
    -0.03900127f, 0.06372738f, 0.05357316f, 0.01779816f, 0.08108258f, 0.04037888f, -0.04411323f, 0.07929406f, 
    -0.08331099f, -0.13989584f, 0.19257605f, -0.17677823f, -0.40635166f, -0.96103299f, -0.05565103f, -0.08048235f, 
    0.03154123f, -0.07732291f, 0.03912552f, 0.06753293f, 0.22511588f, 0.07828789f, 0.17962094f, -0.09555156f, 
    -0.00934239f, -0.01790565f, -0.02452963f, -0.00978640f, 0.06255570f, 0.08720636f, 0.06038302f, 0.17916381f, 
    0.07284915f, 0.06300810f, -0.13026889f, -0.21628606f, -0.07747659f, 0.07171141f, 0.01975039f, -0.02469746f, 
    0.03440799f, -0.00908422f, 0.01577795f, -0.12825005f, 0.02171892f, -0.05630258f, -0.18401518f, -0.26826280f, 
    -0.64521664f, -1.35999417f, -0.25794509f, -0.15789564f, -0.09552296f, -0.02591472f, 0.07261422f, 0.11974659f, 
    0.01400865f, 0.00968541f, -0.47894815f, 0.14871636f, -0.01515811f, 0.01201892f, -0.10127312f, -0.17537090f, 
    0.02539474f, -0.12924898f, 0.07318404f, 0.16827600f, 0.24812885f, -0.04018875f, -0.02025886f, 0.20204069f, 
    -0.07216810f, 0.01563835f, 0.28668097f, 0.18807581f, 0.09700602f, -0.07944589f, -0.00814420f, -0.09441093f, 
    -0.10376531f, -0.06275600f, -0.12009175f, -0.23699030f, -0.51385045f, -0.40540689f, -0.09392571f, 0.09768805f, 
    -0.23134500f, -0.08768938f, -0.14856265f, 0.01220670f, 0.05021356f, -0.00403664f, 0.02537741f, 0.12643920f, 
    0.00311969f, 0.00162649f, 0.17476803f, 0.09875286f, -0.04510649f, -0.49849379f, -0.01941846f, -0.46195060f, 
    -0.21653751f, -0.17736937f, -0.27887520f, 0.02266257f, 0.09637059f, -0.02084459f, 0.37310219f, -0.35311833f, 
    -0.20058557f, -0.04939297f, -0.10265986f, -0.10801416f, -0.01945735f, 0.13130999f, -0.10049310f, 0.84611320f, 
    -0.17338042f, -0.41014695f, 0.34123430f, 0.12658624f, 0.09231371f, 0.12582129f, 0.04303684f, -0.02995610f, 
    0.09936263f, 0.33334994f, -0.31043637f, -0.12244917f, 0.02701239f, -0.12188143f, 0.06823718f, -0.19328699f, 
    -0.09658699f, 0.14355308f, -0.35547110f, 0.00082468f, 0.16236271f, 0.16102347f, 0.28246909f, 0.08419153f, 
    0.05382942f, 0.03645633f, -0.12597895f, 0.11403679f, 0.02280212f, -0.04802764f, 0.08439614f, 0.12817658f, 
    -0.04710305f, -0.11071333f, -0.18983233f, 0.00956863f, 0.03968387f, 0.06042566f, 0.03665420f, 0.18668890f, 
    -0.01906502f, 0.02678953f, -0.26980001f, -0.12899911f, 0.41506922f, 0.01030366f, 0.03509447f, -0.11485094f, 
    -0.13981667f, 0.04307899f, -0.19668807f, 0.12648502f, -0.05600573f, -0.00630761f, 0.07753843f, -0.08306401f, 
    -0.00408394f, 0.10252602f, 0.08371555f, 0.00523997f, -0.25430009f, 0.08802241f, 0.11756967f, 0.21273367f, 
    0.34980595f, 0.39848953f, -0.05778039f, -0.04602364f, -0.13783017f, -0.12205731f, -0.09329917f, 0.36197212f, 
    -0.05825420f, 0.05545316f, 0.01929707f, 0.11639522f, -0.08434840f, -0.12415202f, -0.07753608f, -0.25021076f, 
    0.10928879f, 0.40681019f, -0.13654980f, -0.34761795f, -0.00359641f, -0.04714892f, 0.04261212f, -0.04906617f, 
    0.04851435f, 0.15273215f, 0.02314487f, -0.00256272f, -0.04172945f, -0.02105579f, 0.09862947f, 0.04290545f, 
    -0.14420091f, 0.16066366f, -0.12754306f, -0.19375458f, 0.10736109f, -0.01713595f, -0.06126684f, -0.19485556f, 
    -0.08041994f, -0.05103980f, -0.02414036f, 0.47234821f, 0.14809400f, 0.06484172f, 0.14383018f, -0.08218799f, 
    0.12788250f, -0.11011583f, 0.32706645f, -0.18474236f, 0.48495537f, 0.79542518f, -0.08594906f, -0.03128309f, 
    -0.21915533f, -0.15085831f, -0.22105928f, 0.02663340f, 0.03072037f, 0.22566180f, 0.23184077f, -0.26153791f, 
    -0.12499607f, 0.01514947f, -0.00463780f, 0.06920312f, 0.02971734f, 0.02417035f, -0.14659275f, -0.27008307f, 
    0.19473858f, 0.33670953f, 0.26589468f, 0.20440337f, 0.19994073f, 0.13411352f, 0.29647088f, -0.11301649f, 
    0.08826139f, 0.02839880f, 0.06794357f, -0.18343937f, -0.21313973f, -0.28766784f, -0.17142287f, -0.25885478f, 
    0.42686367f, 0.17471394f, 0.22827703f, -0.03121443f, 0.05233489f, 0.20082282f, 0.08347452f, -0.00145910f, 
    -0.09586661f, -0.12755212f, 0.26401645f, 0.00804138f, 0.24685632f, -0.11946877f, 0.29769924f, 0.10823134f, 
    0.09265842f, -0.05216008f, -0.10407703f, 0.24515489f, 0.05007743f, -0.00449686f, 0.25249955f, 0.05526708f, 
    0.01231404f, 0.25391728f, -0.03582283f, 0.08088842f, 0.08171021f, 0.47310960f, 0.13877094f, 0.08687601f, 
    -0.00078876f, -0.03451955f, -0.00976216f, 0.01799300f, -0.43649653f, 0.36457497f, -0.26956078f, 0.09236760f, 
    0.04018725f, 0.15346393f, 0.23158574f, 0.07349926f, -0.00656527f, -0.03220471f, -0.10697955f, 0.10053898f, 
    0.02470661f, 0.13268322f, 0.02626030f, -0.13906777f, -0.17527349f, -0.04631251f, 0.00497330f, -0.10620874f, 
    -0.05045150f, 0.00641492f, 0.05373034f, 0.07772605f, -0.30754530f, -0.28576627f, -0.21417411f, 0.00718997f, 
    0.20045497f, 0.34269539f, 0.20709409f, -0.01862865f, -0.07880782f, 0.02706086f, -0.00748815f, 0.14978242f, 
    0.06618791f, -0.27156207f, 0.05261398f, 0.15514712f, -0.00265741f, 0.12592453f, -0.24910472f, -0.13278119f, 
    -0.11312203f, -0.01995963f, 0.04797930f, -0.32039958f, -0.16710846f, 0.10743885f, 0.01309736f, 0.00105836f, 
    -0.12854689f, 0.16225359f, 0.09199924f, 0.33681622f, 0.02449204f, 0.03272984f, -0.27724370f, -0.23552658f, 
    -0.00921061f, -0.02842218f, 0.03573139f, -0.13197650f, -0.15917295f, 0.44629979f, -0.00668719f, 0.18691632f, 
    -0.01543683f, 0.04890199f, 0.19510314f, 0.34393087f, 0.00410249f, -0.08928386f, -0.09931590f, -0.14476392f, 
    -0.03879909f, 0.00060780f, -0.21835001f, -0.19772272f, -0.30913860f, -0.00103468f, -0.21594274f, 0.05937347f, 
    0.23200502f, 0.00846782f, 0.12446875f, 0.17045838f, 0.09569099f, 0.24654566f, -0.05950816f, -0.20132217f, 
    0.16250071f, -0.08755492f, -0.01291040f, 0.09079316f, -0.20929557f, 0.06892817f, -0.23028509f, -0.30061415f, 
    0.16735636f, 0.39041990f, -0.00307029f, 0.20791203f, -0.24081506f, 0.00059370f, -0.04742570f, -0.08510620f, 
    -0.00141707f, -0.24522713f, 0.06855007f, -0.14964074f, -0.14971253f, -0.20642690f, -0.00309716f, 0.19962376f, 
    0.10478024f, 0.01241438f, 0.39006969f, 0.46013620f, -0.13948475f, -0.25097063f, 0.01178951f, -0.17174517f, 
    0.15223686f, 0.05243868f, -0.15469624f, -0.39010203f, -0.05058636f, -0.12899929f, -0.01503363f, -0.02712812f, 
    0.03114911f, 0.20843044f, 0.05119942f, 0.07952489f, -0.30434716f, 0.10523630f, -0.00787061f, 0.10327891f, 
    -0.17732675f, -0.09060141f, -0.18747701f, 0.10597655f, -0.33144677f, -0.34669515f, 0.44673616f, 0.10926947f, 
    -0.05227159f, 0.00938885f, 0.22497520f, 0.15990248f, 0.14326771f, -0.24362728f, 0.34901521f, 0.28278595f, 
    0.18742089f, -0.23121640f, -0.23525324f, -0.06544966f, 0.31086764f, 0.11409020f, 0.19169213f, 0.43713081f, 
    0.54999727f, -0.10667430f, -0.23833604f, -0.21167558f, -0.08374000f, -0.07877118f, 0.23381546f, -0.45539984f, 
    -0.16739450f, 0.29545555f, 0.00718171f, -0.04816560f, -0.01914227f, 0.06457210f, -0.00754561f, -0.00785954f, 
    -0.13723196f, -0.47792411f, -0.13286254f, -0.10205258f, -0.04043578f, 0.13464227f, 0.07850093f, 0.07166145f, 
    0.22435708f, 0.13924435f, -0.13549000f, -0.12979157f, 0.05214574f, 0.01425045f, 0.07361260f, 0.11786057f, 
    0.06494211f, -0.14405933f, -0.03536072f, 0.11868510f, -0.08975908f, 0.02528354f, -0.07042028f, 0.11010264f, 
    -0.00269927f, 0.08728303f, 0.00858544f, -0.03851135f, -0.45475078f, -0.49408370f, -0.11030634f, -0.38133124f, 
    -0.12025643f, -0.03277627f, 0.13320935f, 0.04192304f, -0.66709906f, 0.12179558f, 0.26286855f, -0.45844153f, 
    0.10246558f, 0.40011299f, -0.22777627f, -0.05570167f, 0.09161309f, 0.19344275f, 0.24566196f, 0.83686894f, 
    0.02702882f, -0.00626039f, -0.10471155f, 0.08933710f, 0.17312874f, 0.08455794f, 0.10807732f, -0.17419548f, 
    -0.17504263f, -0.19128142f, 0.12687044f, -0.17659380f, 0.09659939f, 0.04225372f, -0.15869981f, -0.17157927f, 
    -0.09135371f, 0.13642217f, 0.08058392f, 0.18234836f, 0.19885506f, -0.13048755f, -0.15493067f, 0.11200968f, 
    0.00990565f, -0.01218905f, -0.13552885f, 0.00098873f, -0.06687413f, 0.02258740f, 0.14407811f, -0.10134480f, 
    0.07346046f, 0.32345057f, -0.01004717f, 0.09955569f, 0.04301992f, -0.12823766f, -0.00932128f, 0.25663280f, 
    -0.12041485f, -0.02344232f, -0.36018375f, -0.19660313f, 0.17172277f, -0.03878751f, -0.09571081f, 0.11794996f, 
    -0.16845706f, 0.00429986f, -0.10957327f, -0.08853117f, 0.36308563f, 0.18531737f, 0.07676325f, 0.18032259f, 
    0.23875630f, 0.05902312f, -0.04963541f, -0.04642455f, 0.28730750f, -0.24375491f, 0.26786366f, 0.02765691f, 
    -0.20848002f, -0.24178275f, 0.05905149f, 0.03239917f, 0.12573043f, -0.05072692f, -0.21329962f, 0.30549669f, 
    0.01195253f, -0.06039427f, -0.13002621f, -0.02270031f, -0.01536979f, 0.12231568f, 0.08475510f, -0.03070509f, 
    -0.17241615f, -0.00426182f, 0.07206939f, -0.01395557f, -0.01768373f, 0.01142986f, 0.21054614f, 0.20450072f, 
    0.23286068f, 0.10701094f, -0.11276374f, 0.02465884f, -0.13292146f, 0.08009653f, -0.08549100f, 0.04869302f, 
    -0.01160521f, 0.38257554f, 0.10115287f, 0.02739063f, -0.17218196f, -0.01041429f, -0.04346334f, -0.06364276f, 
    0.14602876f, -0.81987667f, -0.41586685f, 0.11314417f, 0.01133426f, 0.01271601f, 0.17450510f, 0.14425318f, 
    0.21996358f, 0.00302698f, -0.26883283f, -0.18330045f, -0.49182484f, -0.09068460f, 0.08769687f, -0.04357922f, 
    -0.10735800f, 0.03840687f, 0.08668690f, -0.27998269f, -0.10133997f, -0.36280489f, 0.15617464f, 0.14052832f, 
    -0.04762503f, 0.17786966f, 0.09445875f, -0.04981059f, -0.18215671f, -0.11837756f, 0.04297058f, -0.00037914f, 
    0.11886585f, 0.16473244f, 0.02735999f, 0.18747881f, 0.05146914f, 0.05480888f, -0.21125308f, -0.22874020f, 
    -0.14944008f, 0.14017349f, -0.02962966f, 0.09140007f, 0.00716497f, -0.20595041f, -0.02602457f, -0.15285084f, 
    -0.43709633f, -0.15830316f, 0.17008615f, -0.05686621f, -0.01045915f, 0.04110565f, -0.16910532f, 0.03939852f, 
    -0.15515323f, -0.07008051f, 0.14207160f, 0.28295434f, 0.06366235f, 0.25105044f, -0.17065260f, -0.21417190f, 
    0.08253802f, -0.05172019f, 0.34333682f, -0.03663454f, 0.17186242f, 0.15920395f, 0.03546941f, -0.01000542f, 
    0.13303506f, -0.36611032f, -0.13489397f, 0.05519897f, -0.02402123f, -0.07714558f, -0.00480568f, 0.10734859f, 
    -0.02810494f, 0.13644020f, 0.03743614f, -0.03099652f, -0.09609946f, 0.21040812f, 0.09959278f, 0.04141286f, 
    0.14716008f, -0.16482779f, 0.16007346f, 0.09208420f, -0.13018468f, -0.07842854f, -0.24066946f, 0.09109817f, 
    0.03760109f, -0.04825997f, -0.18189605f, -0.37925553f, 0.02931273f, -0.15794313f, 0.37087023f, 0.25356427f, 
    0.00622367f, 0.11557724f, 0.14883599f, 0.03319277f, -0.01732744f, -0.34511018f, -0.14088115f, 0.18043907f, 
    -0.09146521f, -0.19400036f, 0.08193191f, 0.05439498f, 0.16432968f, -0.01950007f, 0.11980321f, -0.09188709f, 
    -0.32541218f, -0.16014192f, 0.11172795f, -0.07966691f, 0.18244395f, 0.13321373f, 0.05189129f, -0.08555784f, 
    -0.02488865f, 0.11750219f, 0.17051725f, -0.10525119f, 0.20305185f, -0.07609741f, 0.01671984f, -0.05403233f, 
    0.00427571f, 0.12337189f, -0.12380374f, 0.11784291f, 0.02676135f, 0.11433093f, -0.02286500f, -0.04846951f, 
    0.06009833f, -0.22240186f, -0.10013728f, 0.15345697f, 0.24254426f, -0.01902211f, -0.10324428f, -0.01378573f, 
    -0.12189055f, -0.06759567f, -0.25847375f, 0.11493512f, 0.09938002f, 0.09221128f, 0.01947597f, -0.04802673f, 
    -0.06909574f, -0.03817834f, 0.08033028f, -0.13295263f, -0.33204946f, -0.03564880f, 0.10078400f, 0.02210619f, 
    0.16121122f, 0.05873424f, 0.06571201f, -0.00985010f, -0.31335685f, 0.34903169f, 0.31654951f, 0.39441568f, 
    -0.03287259f, 0.24719934f, 0.23995771f, 0.29960987f, 0.36986732f, -0.08893582f, -0.16913044f, -0.09984437f, 
    -0.04048365f, -0.01071937f, 0.06707111f, 0.00925458f, -0.04677263f, -0.15048073f, -0.35005057f, -0.01814726f, 
    -0.10751447f, 0.16517594f, -0.05301646f, -0.13305824f, -0.23439834f, -0.08331470f, -0.12994929f, 0.02996255f, 
    0.07701144f, -0.04902433f, 0.00774259f, 0.28989878f, -0.09939393f, 0.13568580f, 0.15562089f, 0.20808424f, 
    0.29600748f, -0.01087090f, -0.14979641f, 0.16573550f, 0.09270886f, 0.11576536f, 0.20262566f, 0.07152256f, 
    -0.12151463f, 0.30140653f, -0.11879466f, -0.06285872f, -0.01504772f, -0.02953961f, 0.07288986f, -0.33859724f, 
    0.06128751f, -0.29413515f, -0.07011551f, 0.08623081f, -0.04509396f, 0.14808728f, -0.25778747f, 0.35374862f, 
    0.07844929f, -0.04766547f, -0.27429986f, -0.28661948f, 0.07461794f, 0.00990060f, 0.06595005f, 0.04432982f, 
    0.13112509f, -0.07780337f, -0.04198541f, -0.11483707f, 0.05724308f, -0.13959113f, -0.03237287f, -0.24483897f, 
    -0.09200481f, 0.06706464f, -0.20787068f, -0.08139958f, -0.33586642f, 0.03855925f, -0.11445335f, -0.07448222f, 
    0.16867554f, 0.12089787f, 0.17195401f, -0.11200607f, -0.06497068f, -0.10084011f, -0.14058900f, -0.06965268f, 
    -0.00669609f, 0.06374523f, -0.09241812f, -0.05124315f, -0.10909303f, -0.06546929f, 0.12110096f, -0.34892750f, 
    -0.23377839f, -0.17927423f, 0.01550373f, -0.00914738f, -0.02865596f, -0.20395333f, -0.06684434f, 0.02438145f, 
    -0.33296648f, 0.19160585f, -0.27705812f, -0.04223056f, -0.05242970f, 0.05899056f, 0.14667694f, 0.13901347f, 
    0.04125935f, -0.03613264f, 0.16878690f, -0.01322404f, 0.20544977f, 0.05956586f, 0.08127714f, 0.15539768f, 
    0.19530652f, 0.01909499f, -0.20242774f, -0.00316615f, -0.33905390f, 0.05949640f, 0.04764019f, 0.06383195f, 
    -0.00314589f, 0.15250447f, -0.06586904f, -0.21502709f, 0.32843488f, 0.01790112f, 0.38184518f, 0.00768548f, 
    0.20900857f, -0.26435646f, 0.02998178f, -0.09759550f, -0.04423939f, 0.04483480f, 0.05935769f, 0.15936011f, 
    -0.00978702f, -0.07187458f, 0.26078516f, 0.23654139f, 0.34157416f, -0.32861277f, -0.04063745f, -0.00926512f, 
    -0.01437753f, 0.03396024f, -0.26905164f, -0.22782929f, -0.20748930f, -0.15943487f, 0.13674617f, 0.11816137f, 
    -0.10254467f, -0.00120892f, 0.00772833f, -0.03525739f, 0.03973068f, 0.11617893f, 0.11426907f, 0.10129985f, 
    -0.10127456f, -0.07786749f, 0.22070654f, -0.02134752f, -0.16655555f, -0.04716592f, 0.01103799f, 0.10532843f, 
    -0.05915067f, 0.11432590f, 0.26733476f, 0.01092751f, -0.11094258f, 0.01279155f, 0.10565620f, 0.00380137f, 
    -0.10035724f, -0.44583055f, -0.16049530f, 0.08044099f, 0.03994303f, -0.10739464f, -0.41565847f, 0.04446758f, 
    -0.09396482f, -0.12032209f, 0.31197000f, -0.21183074f, 0.08469173f, 0.02406810f, -0.04631077f, 0.07322367f, 
    0.01158725f, 0.04398905f, 0.05892004f, 0.21987401f, 0.11409382f, 0.15309082f, 0.04751390f, 0.22674568f, 
    0.16734105f, -0.00153210f, 0.21247542f, 0.10435818f, -0.50531960f, -0.08355332f, 0.34389678f, 0.18788989f, 
    0.06080350f, -0.09134593f, -0.01593078f, 0.05708525f, 0.00193357f, -0.00216704f, 0.05688888f, -0.07130173f, 
    0.06735542f, -0.06162322f, 0.00128700f, 0.11801731f, -0.26785612f, -0.36519915f, -0.36198634f, 0.23362443f, 
    -0.30014497f, -0.07862758f, 0.16891347f, -0.01578470f, 0.03013209f, 0.10069914f, 0.08107296f, -0.08459217f, 
    0.30790749f, 0.14054413f, 0.12713408f, 0.03249759f, -0.02797691f, 0.07918299f, 0.03926595f, -0.03570437f, 
    0.21392570f, 0.00772088f, 0.13190576f, -0.08334827f, -0.04013879f, -0.15819144f, 0.17874846f, -0.11348366f, 
    -0.03795822f, -0.32885784f, 0.08573700f, 0.35822615f, 0.27043134f, -0.02369281f, -0.26003039f, -0.00615725f, 
    0.14358419f, 0.07387441f, -0.35448462f, 0.16273777f, 0.33525404f, -0.16094685f, 0.17268673f, -0.16928820f, 
    0.01431618f, -0.01284106f, 0.09766252f, 0.44366437f, 0.22866361f, -0.01464619f, -0.09746656f, 0.20130010f, 
    -0.05911161f, 0.02823162f, 0.11285745f, 0.06380421f, -0.19034678f, -0.53262842f, -0.46774903f, -0.00095983f, 
    -0.05148445f, -0.01143124f, 0.08394264f, -0.19472063f, -0.15286292f, 0.37721100f, 0.07906853f, 0.19104286f, 
    0.07981678f, 0.16006443f, 0.02735573f, 0.09728868f, 0.13732725f, -0.04261468f, -0.43754122f, 0.38892654f, 
    0.19197054f, -0.17800757f, -0.05926276f, -0.42656797f, -0.07069118f, 0.07238210f, 0.19442950f, -0.03367789f, 
    0.16262437f, -0.28680652f, -0.03329954f, 0.17437966f, 0.15710819f, -0.05797087f, -0.18487470f, -0.07318665f, 
    -0.22407979f, -0.03117424f, 0.13774604f, 0.08241567f, 0.22422279f, 0.02170613f, 0.16745131f, 0.21955143f, 
    -0.04557619f, 0.15744913f, -0.04909367f, -0.16233486f, -0.07730249f, 0.03750793f, 0.10330669f, -0.08025080f, 
    0.05390555f, 0.14066397f, 0.15687057f, -0.32874203f, -0.17356010f, -0.02705532f, -0.13781738f, 0.11436594f, 
    0.01660827f, 0.27937239f, 0.10921715f, -0.23460449f, -0.16023993f, -0.35668993f, 0.07788491f, 0.11286731f, 
    -0.07800572f, -0.03258204f, 0.08359564f, 0.02581716f, 0.54520869f, -0.37821639f, 0.17898400f, 0.08172395f, 
    -0.00110674f, -0.05518152f, 0.15357783f, 0.08593295f, 0.29680702f, 0.11059928f, -0.15521769f, 0.27343127f, 
    0.02863300f, 0.09476645f, 0.06269722f, -0.02436526f, 0.07228974f, 0.05516168f, 0.12688524f, -0.09116570f, 
    0.07020824f, 0.12223719f, 0.05553132f, 0.07156021f, -0.08945700f, 0.00650254f, -0.19864790f, -0.20189475f, 
    0.27438664f, 0.03902664f, 0.02037836f, 0.06121091f, -0.27059096f, -0.06621879f, 0.04971991f, 0.12934114f, 
    -0.38314378f, -0.00266217f, -0.11759615f, -0.18686920f, 0.05167787f, -0.21503903f, -0.21294448f, -0.29093704f, 
    -0.01888340f, -0.61583120f, 0.02012417f, 0.20318060f, 0.09529115f, 0.04541419f, 0.07539656f, -0.09778164f, 
    0.14503942f, 0.03184161f, 0.21225765f, 0.06438629f, 0.09905576f, -0.13151020f, -0.14520505f, -0.15410876f, 
    0.10505605f, -0.08676369f, -0.02626142f, -0.19760412f, 0.14455283f, 0.05859921f, -0.09315579f, -0.13150036f, 
    -0.17290206f, 0.15326403f, -0.00846985f, 0.07811141f, 0.12744752f, -0.00418100f, -0.04512211f, 0.00881448f, 
    0.03079356f, -0.02778360f, -0.14265040f, -0.15307498f, 0.00737064f, -0.42188966f, 0.28434187f, 0.37580088f, 
    0.03561986f, 0.07845156f, -0.25121346f, -0.10350744f, 0.10595219f, 0.18678884f, 0.25201261f, -0.12734814f, 
    -0.16582812f, 0.27060530f, -0.04156530f, 0.16477527f, 0.09300163f, -0.08172360f, -0.11754751f, 0.33891910f, 
    0.19168420f, -0.04620471f, 0.18491435f, -0.10883939f, 0.12469700f, 0.03502574f, 0.00145644f, 0.10938121f, 
    -0.05537878f, 0.02628110f, -0.00312866f, -0.06981777f, 0.02017905f, -0.03240476f, -0.01127836f, 0.03798591f, 
    -0.04555524f, -0.05638647f, 0.04566143f, -0.00376325f, 0.02645965f, 0.03956660f, -0.03019898f, 0.01753972f, 
    -0.02529429f, -0.00106718f, 0.02902503f, -0.04867960f, -0.04109482f, 0.01789090f, -0.02101616f, -0.06601963f, 
    -0.02153196f, -0.02214116f, 0.01138461f, -0.05083453f, -0.04519276f, -0.01826319f, -0.01201245f, -0.06465290f, 
    0.00881494f, -0.02701971f, -0.02717428f, 0.00982603f, -0.06155450f, -0.02120044f, -0.03751232f, -0.03419079f, 
    0.04123849f, -0.06501553f, 0.03383186f, -0.03850247f, 0.03008842f, 0.01581092f, -0.04377652f, -0.02473071f, 
    0.01184791f, 0.03438532f, -0.00117563f, -0.01601141f, 0.03539863f, -0.00742159f, -0.02158361f, -0.00801073f, 
    0.02851498f, -0.04006397f, 0.03576189f, -0.04164168f, 0.03337163f, -0.02088905f, 0.02328339f, 0.01259360f, 
    0.01873340f, 0.04020213f, -0.06429657f, -0.04462398f, -0.02265009f, -0.07179439f, -0.03171828f, 0.03259405f, 
    -0.04796528f, -0.02973283f, -0.05641900f, -0.03055746f, -0.02948060f, 0.04232119f, 0.02459338f, 0.03193705f, 
    -0.01979139f, 0.03363436f, -0.02227110f, 0.03865143f, -0.04295951f, -0.05719220f, 0.04068639f, -0.02159083f, 
    0.01387054f, -0.02385781f, -0.05865556f, 0.03961536f, -0.00548211f, -0.06851908f, -0.04301467f, 0.04549169f, 
    -0.02445767f, 0.02622558f, 0.04339364f, -0.03419069f, -0.01265741f, -0.00943255f, 0.03058730f, 0.04106809f, 
    0.00214590f, 0.01988911f, 0.00957346f, 0.01666069f, 0.03889685f, -0.03436895f, -0.05870837f, 0.04915765f, 
    -0.05717101f, 0.02226663f, -0.04436130f, 0.04533843f, -0.05137558f, -0.00403992f, 0.01143626f, 0.00869563f, 
    -0.02106856f, -0.04927232f, -0.05799577f, -0.00595643f, -0.05359625f, 0.04262221f, -0.02065972f, 0.04529713f, 
    -0.03255026f, 0.02598292f, -0.06278647f, 0.03829570f, 0.04338975f, -0.01882991f, -0.00989806f, -0.01422899f, 
    -0.02132610f, 0.03388326f, -0.03602636f, 0.03112460f, -0.06721172f, 0.03494139f, 0.01892603f, -0.05403448f, 
    -0.04895224f, 0.04708634f, -0.01556150f, -0.00620405f, -0.00981693f, -0.05186775f, -0.02042384f, -0.05572211f, 
    0.00482660f, 0.02416082f, 0.00585032f, -0.05206212f, -0.04464047f, -0.00802106f, -0.01975613f, -0.01378189f, 
    0.01243134f, 0.03877333f, -0.02998294f, -0.02994839f, 0.00420479f, -0.00415906f, 0.01354479f, 0.04323337f, 
    0.01794288f, 0.03849996f, -0.06173075f, -0.00696875f, -0.02814254f, -0.04608514f, 0.01512264f, 0.03130151f, 
    -0.00879939f, -0.06385183f, -0.05522390f, 0.00711143f, -0.04686075f, -0.00223196f, -0.03850493f, -0.05559037f, 
    0.03081766f, -0.00144947f, -0.04504290f, 0.03803055f, -0.00319307f, 0.00648958f, 0.02429827f, -0.04527678f, 
    0.02375865f, -0.05436725f, -0.05401653f, 0.03531112f, -0.00123961f, -0.05710593f, 0.00254042f, 0.03783097f, 
    -0.01746792f, 0.04437705f, -0.00438552f, 0.03300225f, -0.01256469f, 0.03102323f, 0.04672530f, -0.03915252f, 
    0.00852545f, -0.03210762f, -0.05924312f, -0.00461458f, -0.02527823f, -0.02652052f, 0.01777075f, 0.01008406f, 
    0.01428948f, -0.01292981f, 0.00620049f, 0.04381783f, 0.04450596f, -0.01471899f, -0.02996011f, -0.00407975f, 
    0.03627538f, 0.01476152f, 0.04306218f, -0.00857329f, 0.02529906f, -0.03118158f, 0.00749934f, -0.02401023f, 
    -0.01255711f, 0.03559385f, 0.00128398f, 0.00043093f, -0.06471461f, 0.03242759f, 0.01337875f, -0.00871180f, 
    -0.00247701f, 0.03485889f, 0.03190147f, 0.04984516f, 0.02285167f, -0.03718898f, -0.04333932f, -0.06034606f, 
    -0.06963703f, -0.02356051f, -0.00428349f, -0.00798983f, -0.03735117f, -0.03327774f, 0.04525314f, -0.04368538f, 
    -0.05641960f, 0.02485612f, -0.06803609f, -0.02975860f, -0.06428121f, -0.04210795f, -0.04912616f, 0.04482776f, 
    -0.01922788f, 0.00362052f, 0.04748609f, 0.03161194f, 0.03135568f, -0.05664383f, 0.02281586f, -0.02515333f, 
    -0.01120808f, -0.06059336f, 0.04788763f, -0.04292209f, -0.05395980f, -0.05847097f, -0.03183692f, -0.04994352f, 
    0.04699644f, -0.02238918f, 0.03534720f, -0.03025264f, -0.05647143f, 0.02720598f, -0.03614012f, 0.04352650f, 
    -0.33031288f, -0.32958278f, -0.10907246f, -0.09076320f, -0.16348119f, -0.03958273f, 0.05177912f, -0.02380717f, 
    -0.02824092f, 0.24047312f, 0.26166046f, 0.51746255f, 0.01845644f, 0.11107342f, 0.21121766f, -0.08673225f, 
    0.05261531f, -0.00910337f, 0.30185732f, -0.26427364f, -0.65749896f, -0.12301420f, 0.07478582f, -0.00740617f, 
    -0.14454216f, 0.07427562f, 0.15279511f, 0.22924277f, -0.31605124f, -0.38220507f, 0.00750118f, 0.00799297f, 
    -0.04369036f, 0.26271406f, 0.09943105f, -0.05987104f, -0.24312045f, -0.13054377f, -0.05242902f, -0.16746889f, 
    0.12215430f, 0.07330403f, 0.02831122f, 0.21707101f, -0.06794834f, -0.04005977f, 0.19330575f, 0.21545246f, 
    0.07124889f, 0.16166277f, -0.30188939f, 0.03356254f, 0.08863772f, 0.12962331f, 0.43437281f, 0.47747400f, 
    0.29789245f, -0.10860964f, -0.15059707f, -0.03684467f, 0.04035783f, -0.05622520f, 0.03301696f, -0.27473402f, 
    -0.41014710f, -0.28833872f, -0.08215228f, -0.02322974f, -0.12803209f, 0.07243152f, 0.23207149f, 0.29200006f, 
    -0.08564483f, -0.43908447f, -0.53635573f, -0.22483163f, -0.09636305f, -0.14444919f, 0.08368985f, 0.17263538f, 
    0.07429718f, 0.47733387f, 0.10179003f, 0.11168808f, 0.06692585f, 0.00831398f, 0.04555875f, -0.04708045f, 
    -0.11283868f, -0.04130539f, -0.05238416f, -0.01978418f, -0.08980589f, 0.14225306f, -0.01852968f, 0.19335282f, 
    -0.17886388f, -0.03701365f, 0.15562741f, -0.33281875f, -0.06942572f, -0.35681078f, -0.04273186f, -0.24248682f, 
    -0.20845744f, 0.08778280f, 0.16487038f, 0.14156914f, -0.20915869f, -0.43985632f, -0.33344507f, -0.07613374f, 
    -0.22182304f, 0.04955195f, 0.23952241f, 0.15730357f, 0.03637012f, -0.32169694f, -0.71904045f, -0.54347563f, 
    0.19201139f, 0.14579874f, 0.11820529f, -0.02652710f, -0.01258416f, -0.16108704f, 0.38041258f, 0.05066815f, 
    0.15300928f, 0.10952694f, -0.08801945f, -0.03721213f, 0.19048584f, 0.12576500f, -0.02614279f, 0.18066086f, 
    0.03689534f, -0.09027748f, -0.08128756f, -0.11125016f, -0.01662796f, 0.06745747f, 0.20327131f, 0.24012437f, 
    0.01854069f, -0.00600586f, -0.37117290f, -0.15445381f, 0.02380673f, -0.04231831f, 0.06923027f, -0.07982262f, 
    -0.11207437f, 0.38010979f, 0.12702304f, 0.17313010f, -0.09929111f, -0.08783284f, -0.10145418f, 0.17777205f, 
    -0.15126607f, -0.26800954f, -0.74863893f, -0.43948373f, -0.47465816f, 0.10052747f, -0.16817077f, -0.09810261f, 
    0.21730186f, -0.13372093f, 0.10536014f, 0.02021792f, 0.22596835f, 0.35517108f, 0.03526583f, -0.13457933f, 
    0.17756164f, 0.07766449f, -0.04724910f, -0.21117057f, -0.15495978f, -0.19543870f, -0.21748355f, 0.08120424f, 
    -0.01835015f, 0.07105371f, 0.05476522f, 0.01762327f, -0.01638955f, -0.26633292f, -0.40724307f, -0.40321654f, 
    -0.12687507f, -0.08928367f, -0.11575683f, -0.23831955f, 0.05807479f, -0.02178902f, 0.06529987f, 0.01477971f, 
    -0.23231727f, -0.01509564f, 0.00679967f, 0.01096248f, 0.02084258f, -0.02163391f, 0.19311412f, 0.48008135f, 
    0.26653925f, 0.39403918f, 0.23788626f, -0.05560927f, 0.08589009f, 0.10871280f, -0.00113153f, -0.11926537f, 
    0.28326064f, 0.39349410f, 0.55172276f, 0.01709186f, -0.04224767f, -0.00079841f, -0.04384505f, 0.15440404f, 
    0.13281165f, -0.71028042f, -0.66842771f, -0.30868924f, 0.19073828f, -0.12614559f, -0.00912296f, 0.01914138f, 
    0.12556037f, 0.17544132f, -0.26989853f, -0.08293910f, -0.29184911f, -0.10766282f, -0.14668068f, -0.20114824f, 
    -0.01783778f, 0.09661159f, 0.10289816f, 0.12345608f, -0.18525572f, -0.25103644f, 0.22004613f, 0.11379954f, 
    0.27990478f, 0.09322638f, 0.05260453f, -0.15449218f, -0.06960557f, -0.15054858f, -0.14125909f, -0.05351492f, 
    -0.07539123f, 0.06892401f, 0.05432301f, 0.14537828f, 0.07478525f, 0.38665426f, 0.29647243f, 0.27922133f, 
    0.06369480f, -0.02168233f, -0.04443298f, 0.05219478f, -0.03356927f, 0.04597536f, 0.09136339f, -0.09957531f, 
    -0.62970811f, 0.21561737f, 0.19978882f, 0.14762092f, -0.09978335f, 0.18083254f, 0.18405305f, 0.25995606f, 
    0.17984979f, -0.19337331f, 0.07825189f, 0.06336381f, -0.04094197f, -0.11297140f, 0.02285269f, 0.00001038f, 
    -0.00128268f, -0.03485323f, 0.04257400f, 0.02346879f, -0.02039181f, -0.03982845f, 0.02912547f, -0.02250169f, 
    0.02885695f, 0.03649694f, -0.03291181f, -0.00950757f, -0.01217028f, 0.00807051f, 0.03648816f, 0.02302945f, 
    0.00607497f, 0.03613673f, -0.01197203f, -0.01788110f, -0.03812604f, 0.03985836f, 0.03023600f, -0.00561371f, 
    -0.06468713f, -0.05434274f, -0.06302512f, 0.04417853f, -0.06225902f, -0.05499607f, -0.00712775f, -0.06104182f, 
    0.00717572f, -0.04453456f, -0.00170319f, 0.04188049f, -0.03468208f, -0.04634340f, 0.03440462f, 0.03070696f, 
    0.04696089f, 0.02448721f, -0.01246936f, -0.06350309f, 0.03261034f, -0.01710648f, -0.04737959f, -0.05049004f, 
    0.03104418f, 0.01411683f, -0.01694064f, -0.01358707f, -0.03475022f, -0.03756266f, -0.03903273f, -0.06491562f, 
    0.02708844f, 0.01643120f, -0.04827688f, 0.01114630f, -0.00745603f, -0.05879746f, -0.03635263f, 0.03980283f, 
    -0.03421698f, -0.04020747f, 0.04271640f, -0.02393135f, -0.02210263f, 0.02076677f, 0.01861957f, 0.03504460f, 
    -0.06410640f, 0.02996046f, 0.03316969f, -0.05366403f, -0.06145262f, -0.06252021f, -0.03208647f, 0.00524478f, 
    -0.05160485f, -0.05283382f, -0.05715087f, -0.05583325f, 0.01714875f, 0.00967387f, -0.03621758f, -0.03823906f, 
    -0.01962374f, -0.04610907f, 0.01282976f, -0.01785718f, 0.03742952f, 0.03266178f, -0.02220301f, -0.01712903f, 
    -0.05525115f, -0.04918286f, -0.01425773f, 0.05289967f, 0.06116983f, 0.03925402f, 0.00315063f, -0.00940731f, 
    -0.05930838f, 0.01075162f, 0.00133540f, 0.02162671f, -0.03155787f, -0.00036398f, 0.00281972f, 0.03630640f, 
    -0.02039509f, 0.04432594f, -0.01052173f, -0.01875746f, -0.02590176f, 0.02446280f, 0.02046659f, 0.00228263f, 
    0.03922945f, -0.00265363f, -0.00738925f, 0.06080474f, -0.03415142f, -0.05904361f, -0.01647195f, -0.01636685f, 
    0.04603287f, 0.04488341f, -0.06716995f, 0.03469404f, -0.04491487f, 0.02630563f, 0.02414019f, -0.04723698f, 
    -0.00439341f, -0.05945267f, -0.02489290f, 0.00296839f, -0.05247783f, -0.01951027f, 0.02855946f, -0.01830904f, 
    -0.03373355f, -0.04595412f, 0.04969054f, 0.01249726f, 0.04521868f, -0.04839352f, -0.03958017f, -0.03362569f, 
    0.00491848f, 0.01863596f, 0.01667796f, -0.05829191f, 0.01929321f, -0.02855102f, 0.04286293f, 0.04620856f, 
    -0.00403932f, 0.00637412f, -0.04369497f, 0.04629428f, -0.00135889f, -0.01948584f, 0.01631651f, -0.01755110f, 
    -0.03611236f, 0.01550129f, -0.04950528f, 0.03375294f, -0.01443021f, -0.01675083f, -0.05446986f, 0.02122504f, 
    0.00499171f, 0.00252903f, -0.03075802f, -0.02379792f, -0.01975070f, 0.02216363f, -0.01244495f, -0.03701397f, 
    0.02888388f, 0.04873271f, 0.00140460f, -0.06299994f, -0.06125966f, -0.04794185f, -0.03702921f, -0.05095984f, 
    0.00819477f, -0.06160716f, -0.05121702f, -0.06330922f, 0.04528468f, -0.00332512f, 0.05430278f, -0.02315039f, 
    0.04270777f, -0.02810316f, -0.04913485f, 0.05045391f, 0.05497976f, -0.05711715f, -0.05211312f, -0.06169038f, 
    0.02616603f, -0.04689007f, 0.00903402f, -0.00987420f, 0.01960466f, 0.04170386f, 0.04303995f, -0.05954658f, 
    0.00397849f, -0.02597095f, 0.00448955f, -0.01184200f, -0.02817970f, -0.04775302f, -0.00187760f, 0.01917760f, 
    -0.06435782f, -0.05994476f, -0.05323126f, -0.05629901f, 0.03706092f, 0.00201136f, -0.04008458f, -0.01698478f, 
    -0.03814336f, -0.04425677f, 0.05072876f, 0.02495082f, 0.03053533f, 0.04326532f, -0.01741179f, -0.00137024f, 
    -0.05028275f, -0.02284417f, -0.02829045f, -0.02578986f, 0.01337209f, 0.04875010f, 0.00740238f, -0.04232730f, 
    -0.01648844f, -0.02059340f, 0.00449296f, 0.01223082f, 0.00685974f, -0.03621404f, -0.00609485f, -0.02209336f, 
    0.02517404f, -0.00146910f, 0.02334645f, -0.06080735f, -0.00804531f, 0.01875599f, 0.04831396f, 0.02486933f, 
    0.00410137f, -0.04183223f, -0.05035790f, 0.02419583f, 0.02449202f, -0.03463588f, -0.00563865f, -0.06486502f, 
    -0.03032256f, 0.00078779f, 0.01967458f, -0.05649439f, -0.02554396f, 0.03193234f, 0.00221806f, 0.03159799f, 
    0.02510396f, -0.02940194f, -0.03389538f, -0.01032685f, 0.02341868f, -0.05622519f, 0.01347277f, -0.01160284f, 
    0.33294198f, 0.29736435f, 0.14244157f, 0.05641317f, -0.01769453f, -0.15280978f, 0.02615562f, 0.00316317f, 
    0.15707417f, -0.12755644f, -0.09695446f, -0.01826156f, 0.02256816f, 0.00933155f, -0.06840914f, -0.02126955f, 
    -0.01304277f, -0.01316003f, 0.04065872f, 0.10494242f, -0.06774950f, -0.14268295f, 0.06000394f, -0.12434558f, 
    0.06251279f, -0.13876155f, -0.08455868f, -0.21669146f, 0.16598745f, -0.13359620f, -0.09475195f, 0.00103816f, 
    -0.12657663f, 0.01657879f, 0.10100979f, 0.25392833f, 0.19427218f, 0.53579640f, 0.04317500f, 0.23216389f, 
    -0.10469717f, 0.20790830f, 0.10772318f, 0.14195843f, 0.12188040f, -0.46064350f, -0.28838325f, 0.02991516f, 
    -0.06364821f, 0.01378925f, -0.04745849f, -0.02887257f, 0.16180846f, 0.10383072f, -0.64929408f, -0.09300963f, 
    0.52910763f, -0.11459744f, 0.04337173f, -0.29150206f, -0.05606768f, 0.03401694f, 0.06998462f, 0.01325664f, 
    0.00488421f, -0.24459927f, 0.01141944f, -0.02985366f, 0.01708121f, 0.13390812f, 0.08561686f, 0.12793104f, 
    0.45964867f, 0.35089338f, 0.07935493f, 0.00402168f, -0.14454699f, -0.14617434f, 0.11513211f, 0.09245843f, 
    0.07869937f, -0.36545932f, -0.33873087f, -0.39055976f, 0.00430621f, 0.19945051f, 0.23135936f, 0.14901733f, 
    -0.10747685f, 0.04212122f, -0.39235464f, -0.72421461f, -0.43547288f, 0.12049498f, 0.17915611f, 0.08000194f, 
    0.06526630f, 0.05253688f, -0.04229695f, 0.17151718f, 0.31400967f, -0.02725613f, -0.16201510f, -0.14190441f, 
    -0.23202802f, 0.09115691f, 0.14272979f, -0.00057847f, -1.21380103f, -0.29236487f, 0.04753053f, 0.12282472f, 
    0.40697601f, 0.19323030f, 0.21097681f, 0.06247927f, -0.04653202f, 0.29753646f, 0.30375019f, 0.02080355f, 
    -0.14069511f, -0.08623416f, -0.16239521f, -0.08493157f, 0.03282909f, 0.03745198f, -0.69337219f, -1.17184424f, 
    -0.62513083f, 0.01569440f, -0.03983232f, 0.22220851f, -0.20141707f, -0.21006165f, -0.13926803f, 0.00836633f, 
    -0.11564384f, 0.02248790f, -0.06381380f, 0.05793612f, 0.02350410f, 0.01453352f, 0.27899313f, 0.01636059f, 
    -0.07590844f, 0.47519392f, 0.07862485f, 0.01404587f, -0.20958945f, 0.21429323f, 0.00713220f, 0.11199768f, 
    0.19090939f, 0.00309199f, 0.12064183f, -0.10533923f, -0.13657828f, 0.09454433f, 0.01957856f, -0.05440554f, 
    0.08951776f, 0.12374449f, -0.00966412f, 0.09420804f, -0.32995212f, -0.11059307f, 0.13397561f, -0.10106933f, 
    -0.03332326f, 0.22727396f, 0.04946607f, -0.03065168f, -0.61152256f, -0.69101173f, -0.12934560f, -0.10686933f, 
    0.01835028f, 0.10599563f, -0.11551520f, 0.07120293f, 0.45842886f, 0.23914847f, 0.41989508f, -0.11649452f, 
    -0.06681011f, -0.13952161f, -0.07855789f, 0.07047379f, 0.07796708f, 0.00620434f, 0.17473413f, -0.22473568f, 
    -0.04600517f, -0.01451172f, -0.09470396f, -0.02282049f, -0.11540046f, 0.01756129f, 0.03098483f, 0.08381680f, 
    -0.12367272f, -0.16003530f, 0.00814402f, 0.01819891f, 0.17024340f, -0.07683295f, -0.00199873f, 0.28869554f, 
    0.00976988f, -0.63844949f, -0.18439412f, -0.39842814f, 0.10187705f, 0.06515794f, -0.04125070f, -0.05752284f, 
    -0.47772723f, -0.07954684f, 0.26307580f, -0.15746298f, -0.04875960f, 0.03313933f, 0.12506156f, 0.07279457f, 
    -0.00832132f, 0.29531220f, -0.03589978f, -0.22221524f, 0.09741641f, 0.17872000f, 0.04620510f, 0.07673888f, 
    -0.05848628f, 0.05395132f, 0.43050644f, 0.62399310f, 0.34448507f, -0.17567930f, 0.03380082f, -0.14527796f, 
    -0.03922813f, 0.01573555f, 0.06103174f, -0.42061418f, -0.78663361f, -0.55627191f, 0.05097646f, 0.20567885f, 
    0.02892635f, -0.13287359f, 0.01391429f, -0.00131906f, 0.12586163f, 0.05169813f, -0.09487154f, -0.00955707f, 
    0.05660865f, 0.09430207f, 0.22466892f, 0.13206135f, -0.10137838f, -0.35198933f, -0.65923524f, -0.17298631f, 
    -0.24375853f, 0.11046591f, 0.55106467f, -0.01873554f, -0.09283223f, -0.03377112f, -0.59468931f, -0.10067944f, 
    0.01730806f, -0.12402407f, 0.33439848f, 0.30452272f, 0.26992041f, 0.13848886f, -0.09547946f, -0.61939400f, 
    -0.51671588f, -0.07991174f, 0.05854647f, 0.11808176f, 0.32844937f, -0.17005359f, 0.14374956f, 0.10980946f, 
    -0.20713751f, -0.21530995f, -0.59153950f, 0.04631734f, 0.07280507f, 0.09510659f, 0.01205292f, 0.13690126f, 
    0.04452815f, 0.00466961f, 0.12271007f, 0.31931561f, -0.04036145f, 0.04404036f, -0.03392948f, 0.13146423f, 
    0.08065475f, 0.13016716f, -0.14006130f, -0.01441481f, 0.18127847f, -0.02357344f, -0.14649411f, -0.08419266f, 
    0.16352141f, 0.09541462f, 0.20146121f, -0.17256580f, -0.24582849f, 0.00678599f, -0.12490844f, -0.21495505f, 
    0.00124157f, -0.01808720f, 0.09031841f, 0.00341719f, -0.25964889f, 0.06924498f, 0.31998163f, 0.01732996f, 
    0.13306817f, 0.07578591f, 0.05322028f, 0.08507186f, 0.07649015f, -0.26439339f, 0.17754097f, 0.51627302f, 
    0.03462887f, -0.19592009f, 0.00410022f, 0.18487811f, 0.15161201f, 0.06296623f, -0.09229873f, 0.38536572f, 
    0.42290702f, -0.15899079f, 0.04254729f, -0.15069301f, -0.02543622f, -0.09961177f, 0.01149543f, -0.50755590f, 
    -0.28160784f, -0.08769292f, -0.33746547f, -0.01016460f, 0.05672555f, 0.03215868f, 0.19578512f, 0.00207496f, 
    0.01152380f, -0.19110028f, -0.25119165f, 0.33798099f, -0.08665780f, 0.21803543f, 0.02276626f, 0.08590731f, 
    -0.11200873f, -0.52962238f, -0.16512185f, 0.15231149f, -0.16839615f, 0.20564228f, -0.24193883f, 0.22339949f, 
    -0.00861636f, -0.06014988f, 0.16772315f, 0.02832323f, 0.55898416f, 0.00360412f, 0.10405090f, -0.14915942f, 
    0.06218951f, -0.01076834f, 0.13858153f, -0.03456514f, -1.46082783f, -0.19801034f, -0.10437620f, 0.10257909f, 
    -0.42210558f, -0.17539811f, -0.10202312f, -0.19192863f, -0.13587107f, -0.22745034f, 0.05436220f, 0.15678371f, 
    0.25417313f, -0.05094923f, -0.07165881f, -0.02378079f, -0.13137254f, -0.79887253f, -0.48525840f, 0.30201462f, 
    -0.01717429f, -0.12796611f, -0.07171258f, 0.12581231f, -0.09650128f, -0.16366519f, -0.25842378f, 0.02438671f, 
    0.34185413f, -0.13576837f, -0.07378341f, -0.20839640f, 0.23238118f, -0.03403023f, 0.03419049f, -0.13070983f, 
    -0.11708347f, -0.07493494f, 0.06900650f, -0.01979841f, 0.11957942f, 0.09919653f, -0.04968710f, 0.12880455f, 
    -0.05109616f, 0.10579111f, 0.14981878f, 0.23437436f, 0.20532277f, 0.03533758f, 0.01892642f, 0.07856628f, 
    0.01776960f, 0.33649594f, -0.36326203f, -0.28117976f, 0.12888502f, -0.19833994f, 0.06226823f, 0.14478901f, 
    0.27265540f, 0.05896286f, 0.40659404f, -0.45638177f, -0.38332197f, -0.11818089f, 0.10893217f, -0.08634213f, 
    0.16606475f, -0.02272548f, 0.05020935f, -0.11793743f, -0.03675262f, 0.09844813f, 0.02130299f, -0.03321587f, 
    0.10160851f, 0.12873951f, 0.10930920f, 0.09112132f, -0.24833082f, -1.15389752f, -0.10999949f, -0.03937784f, 
    -0.05632560f, -0.05633122f, 0.14106995f, -0.15167224f, 0.13001005f, 0.01188246f, -0.00694543f, 0.16309127f, 
    -0.16032200f, -0.09896344f, -0.20191072f, 0.03032873f, 0.25707272f, 0.03592345f, -0.10965348f, 0.10130532f, 
    0.18265751f, 0.03176992f, -0.03501591f, -0.17028840f, 0.39808375f, 0.08542384f, 0.15784785f, -0.39960104f, 
    0.05727334f, 0.16874599f, -0.04170287f, 0.04307865f, 0.09111065f, 0.18551926f, 0.04175105f, 0.02561739f, 
    0.11909523f, 0.23568343f, 0.15775104f, -0.07151380f, -0.28318492f, -0.00161570f, 0.09674608f, -0.02484057f, 
    0.05486767f, -0.53296554f, 0.05927325f, -0.17069329f, -0.02352804f, 0.14136018f, 0.11919344f, -0.08649547f, 
    0.16095284f, 0.08644857f, 0.03350288f, -0.25926292f, -0.40736505f, -0.06612343f, -0.06405626f, -0.05525144f, 
    -0.07050090f, 0.00065726f, -0.05317795f, 0.16917175f, 0.32484499f, 0.30819589f, 0.15314916f, -0.02926518f, 
    -0.07887891f, -0.05221209f, 0.03426307f, -0.03294102f, 0.00844682f, -0.01302031f, -0.07171958f, -0.04928158f, 
    0.13632774f, -0.13692841f, 0.10165266f, 0.08767923f, 0.28896883f, -0.49108568f, -0.34360871f, 0.20911443f, 
    -0.06999525f, -0.00779387f, -0.08865399f, 0.11557651f, -0.04506825f, -0.08481260f, -0.05504192f, -0.39458895f, 
    0.16039288f, -0.19831590f, -0.27475199f, 0.07187379f, -0.17289689f, -0.02037479f, 0.15052210f, -0.62797952f, 
    0.36415079f, 0.26744023f, 0.17367640f, -0.13584085f, 0.01941691f, 0.09346343f, -0.07691443f, 0.10376213f, 
    0.08345584f, -0.16818924f, -0.04212438f, 0.08851850f, 0.02416768f, -0.13445765f, -0.00621360f, 0.27775428f, 
    -0.04803234f, -0.10719427f, 0.13550338f, 0.04834884f, 0.22665238f, -0.09159219f, -0.04320970f, 0.07459532f, 
    -0.03964106f, 0.10940720f, -0.03091170f, -0.09243669f, -0.17275953f, 0.06722067f, 0.13067932f, -0.04862654f, 
    0.08307982f, 0.19690047f, 0.01505270f, -0.08651287f, 0.07515685f, -0.06747838f, 0.00192225f, 0.26057649f, 
    -0.26337862f, -0.17477077f, -0.66509211f, 0.22587021f, 0.13646220f, 0.11734429f, 0.33438724f, -0.02400036f, 
    0.07787982f, -0.05500237f, 0.25259465f, -0.06183332f, -0.19649424f, 0.22417386f, 0.11693363f, 0.03987473f, 
    -0.01180848f, -0.11893578f, -0.04203369f, 0.14637950f, -0.01982733f, 0.06935447f, 0.41326723f, 0.13454075f, 
    0.13609582f, 0.07572683f, 0.02775054f, 0.07754909f, 0.06377817f, -0.02751723f, -0.03986608f, 0.01636748f, 
    -0.14661035f, -0.14154406f, 0.10361924f, 0.03855522f, 0.04320957f, -0.19469866f, 0.05468478f, -0.27805373f, 
    0.10393782f, -0.13652512f, 0.17297436f, 0.05693322f, 0.05606123f, -0.02769949f, 0.08951438f, 0.18162377f, 
    -0.05822561f, -0.46866676f, 0.33566508f, 0.16104539f, 0.07915712f, -0.08926783f, 0.20204735f, 0.17724217f, 
    -0.07748169f, 0.01371970f, 0.05433524f, -0.65088230f, -0.14461669f, -0.09959694f, -0.09460889f, -0.06904653f, 
    0.11979388f, 0.04585633f, -0.01720414f, -0.10401456f, 0.18433294f, -0.20313118f, -0.00588525f, 0.06066978f, 
    -0.14719607f, 0.43699163f, 0.13695310f, -0.16055560f, 0.00849171f, -0.01364453f, 0.46279603f, -0.17416084f, 
    0.40241322f, 0.12607852f, 0.31762418f, 0.17908211f, -0.00011976f, -0.26629606f, -0.06539410f, 0.10294705f, 
    0.11996130f, -0.02800776f, -0.07145472f, 0.03939031f, -0.11265060f, 0.12741224f, -0.20283015f, 0.01402289f, 
    -0.59899485f, -0.01289377f, -0.29584393f, 0.34530181f, -0.07406732f, -0.20833299f, -0.08385418f, 0.18897109f, 
    -0.15463945f, -0.06342361f, 0.08810481f, -0.02440194f, 0.05975645f, 0.09076064f, 0.16485964f, 0.05155827f, 
    0.02258722f, 0.26350802f, 0.20274511f, 0.12870830f, -0.02507439f, 0.02453849f, 0.25260380f, -0.22878487f, 
    -0.12011215f, 0.13232481f, 0.07788456f, -0.12378376f, 0.16688965f, 0.05694475f, -0.10472720f, 0.07801656f, 
    -0.16591926f, -0.05712744f, 0.30309811f, -0.04180196f, -0.44613659f, -0.09028012f, 0.17788076f, 0.00834065f, 
    -0.04494947f, -0.01991187f, -0.14541362f, 0.09528071f, -0.00315089f, 0.01117286f, 0.05372368f, 0.04919121f, 
    0.13746847f, 0.08842301f, -0.00897603f, -0.11301682f, -0.02647118f, -0.20824064f, -0.09296755f, -0.02215979f, 
    0.06574905f, -0.08816894f, -0.10577371f, -0.12607868f, 0.04629626f, 0.05845740f, 0.11179196f, -0.24647912f, 
    -0.01852946f, 0.09719107f, -0.15784536f, 0.06053171f, -0.01570323f, -0.01295359f, 0.11141421f, 0.00944445f, 
    -0.11536716f, -0.03263609f, 0.00477046f, 0.01980010f, 0.13110386f, 0.09007356f, 0.19405492f, -0.23486125f, 
    0.08448743f, 0.03607297f, 0.10906953f, -0.06378104f, -0.11665659f, 0.10971078f, 0.06695651f, 0.07593181f, 
    0.16842395f, 0.09115458f, 0.40561923f, 0.07233357f, -0.02459302f, 0.07735486f, -0.04213427f, 0.08658262f, 
    0.08315044f, 0.32429257f, -0.02530199f, -0.36224478f, -0.02053154f, 0.11153600f, -0.12620953f, 0.01976154f, 
    -0.03964229f, -0.03129910f, -0.18868221f, 0.03673021f, 0.26912796f, 0.09732064f, -0.12554671f, 0.01401818f, 
    0.05779479f, 0.17067781f, 0.07777391f, -0.02864648f, -0.29842517f, -0.36184841f, -0.17860258f, 0.07939123f, 
    0.17823824f, 0.03925611f, 0.03472666f, -0.01643451f, 0.12939881f, -0.11416922f, -0.07803167f, -0.00809630f, 
    0.00023949f, -0.04640158f, 0.11169437f, 0.20994927f, 0.17484447f, -0.46620640f, 0.20509796f, -0.31323093f, 
    0.10043671f, -0.29202875f, 0.31406862f, -0.01634812f, -0.07121339f, -0.02723907f, -0.42052674f, 0.14584915f, 
    -0.25211039f, -0.07258898f, 0.27163890f, -0.00005714f, 0.15995257f, 0.07469314f, -0.06752083f, 0.10176566f, 
    -0.36635849f, 0.08788195f, -0.27196431f, 0.15109392f, 0.13525303f, 0.17776048f, -0.02060518f, -0.20007502f, 
    -0.03591497f, 0.01656192f, -0.06318539f, 0.03827334f, 0.02544776f, 0.04332463f, -0.00184552f, -0.01033646f, 
    -0.00754028f, -0.05611312f, -0.00146923f, -0.03987061f, -0.01991349f, -0.03152032f, -0.02803286f, -0.02732898f, 
    0.01638557f, -0.04621378f, 0.02405151f, 0.01677463f, -0.06351886f, 0.00111795f, 0.01883160f, -0.03050636f, 
    -0.07399949f, -0.02931357f, 0.00134877f, 0.03271166f, 0.03287350f, 0.02928029f, 0.00184743f, -0.00624489f, 
    -0.04297675f, -0.04521452f, 0.03021856f, -0.01985468f, -0.02336396f, -0.04973087f, -0.01402757f, 0.01245518f, 
    0.04242108f, -0.05985938f, 0.04604597f, -0.06255132f, 0.01567113f, -0.03650296f, 0.00849958f, -0.03329708f, 
    -0.00247502f, 0.02186082f, -0.05918744f, -0.01529424f, 0.01577028f, -0.03461738f, -0.01311321f, 0.02234244f, 
    -0.06717295f, -0.02041457f, -0.03195241f, -0.06277821f, -0.04808285f, -0.06441550f, -0.00530041f, -0.03666673f, 
    -0.04787523f, 0.03406174f, 0.00138978f, 0.02328493f, 0.01791648f, -0.01705209f, -0.00338749f, -0.01026196f, 
    0.00589447f, 0.01956447f, -0.02813756f, 0.01412565f, -0.01618601f, -0.06005300f, 0.03653445f, -0.02570820f, 
    0.01728483f, -0.06206498f, -0.05531596f, -0.05344542f, -0.04589325f, -0.03699259f, 0.00271012f, 0.04665120f, 
    -0.05077519f, -0.05496780f, 0.04513963f, -0.00159960f, -0.01679232f, -0.04620050f, 0.02850936f, 0.03332323f, 
    0.04113826f, -0.03602324f, 0.03249504f, 0.03794708f, -0.03164334f, 0.01866631f, -0.00439692f, 0.01759888f, 
    -0.02323044f, -0.05710032f, 0.04273134f, 0.04742175f, -0.03551678f, -0.04369867f, -0.01612653f, -0.02281867f, 
    -0.01608851f, 0.03727730f, 0.01738380f, -0.01739698f, 0.01246200f, 0.01316901f, 0.04694477f, -0.01169219f, 
    0.00923608f, 0.00372289f, -0.03843729f, 0.00847363f, -0.01701264f, -0.02090654f, 0.02696428f, 0.04216859f, 
    0.01828657f, 0.02070863f, -0.05248110f, -0.01391168f, -0.06910031f, -0.01226355f, 0.04982849f, -0.01582342f, 
    0.01122514f, 0.01426406f, -0.06334484f, -0.04631193f, 0.04416266f, 0.00270548f, -0.00258307f, 0.04191158f, 
    -0.06618268f, 0.04219808f, 0.00965827f, 0.03318103f, -0.06260145f, -0.01701681f, 0.00364961f, -0.01303664f, 
    -0.02775760f, -0.04848788f, -0.01356956f, -0.00384757f, -0.03203670f, -0.02459202f, -0.06461786f, 0.04717889f, 
    -0.02148652f, -0.05923938f, -0.00130916f, 0.03946066f, -0.03557374f, -0.01077820f, -0.01108056f, -0.02459116f, 
    -0.00415263f, -0.01979025f, -0.03595080f, -0.01364913f, -0.03882253f, 0.01210524f, 0.02448551f, 0.00890342f, 
    -0.02226762f, -0.02873674f, -0.01457190f, 0.01782596f, 0.04657454f, 0.01116499f, -0.04626342f, 0.03616412f, 
    -0.02976141f, 0.02595530f, 0.02217989f, -0.06466094f, -0.05671024f, 0.03064060f, 0.01179363f, -0.04318310f, 
    -0.03306722f, 0.04375105f, -0.06811634f, 0.02905236f, -0.02932218f, -0.07012431f, 0.04658274f, 0.04813789f, 
    0.00375826f, -0.00859888f, 0.01952291f, 0.01622310f, -0.04629021f, 0.03162596f, -0.07707079f, -0.04351685f, 
    -0.03291109f, -0.01834698f, 0.00516722f, 0.01579836f, 0.00371307f, -0.02783233f, 0.04984897f, -0.03519850f, 
    0.02929895f, -0.03202272f, 0.01578216f, -0.03182923f, -0.01853082f, 0.04375306f, -0.00167738f, -0.03258628f, 
    -0.04126432f, -0.06680825f, -0.01212603f, 0.02159002f, 0.02834336f, -0.06408695f, -0.01706154f, 0.00516364f, 
    -0.03734097f, -0.04471526f, -0.01381405f, -0.06613442f, -0.00120544f, 0.03302724f, -0.06613363f, -0.03303825f, 
    -0.02318962f, -0.01461203f, -0.02647643f, -0.00844523f, 0.01509208f, -0.00714135f, -0.02245580f, 0.01519020f, 
    -0.05458978f, -0.03090195f, -0.03931716f, -0.05432611f, 0.03156177f, -0.03671740f, 0.04269766f, 0.00498803f, 
    -0.03474378f, -0.02133901f, 0.03587686f, 0.01298595f, 0.03635401f, -0.03760184f, -0.05815077f, 0.01874992f, 
    0.00204645f, 0.04236647f, -0.04538562f, -0.05762221f, 0.04600162f, -0.02586557f, -0.06923877f, -0.05807590f, 
    0.00709561f, -0.01253769f, 0.02323863f, -0.04751438f, -0.02626274f, 0.04723439f, -0.01528824f, 0.03855217f, 
    0.00915518f, 0.04380794f, -0.00329140f, 0.02562845f, 0.03201284f, 0.01693230f, 0.01014465f, -0.00658257f, 
    -0.03460167f, -0.04707997f, -0.03127485f, -0.05052816f, -0.00901202f, -0.04442671f, 0.04399341f, -0.04369241f, 
    0.03323896f, 0.03259733f, 0.05268891f, -0.00310265f, 0.04252938f, -0.03518150f, -0.04789981f, -0.06106034f, 
    -0.05372304f, -0.05445288f, -0.02849904f, -0.06324720f, -0.06277049f, 0.00322973f, -0.05401761f, 0.04945010f, 
    -0.04413459f, 0.03256861f, -0.04558437f, 0.03279507f, 0.03119134f, -0.02882235f, 0.05125054f, 0.01391782f, 
    0.02974935f, -0.04233572f, 0.00020920f, -0.03532050f, -0.01280026f, -0.02040944f, -0.00187475f, -0.03779720f, 
    0.00319740f, -0.05774363f, -0.04686175f, -0.05254908f, 0.02870079f, -0.05544882f, -0.05196549f, -0.03937383f, 
    -0.05072768f, -0.02690768f, 0.02111493f, 0.04823614f, 0.01437307f, -0.00062082f, 0.02592794f, -0.03445586f, 
    0.01847028f, -0.04960440f, -0.04954736f, -0.04216242f, -0.01263579f, -0.01625082f, -0.05492982f, -0.00992181f, 
    0.00307678f, 0.03837578f, 0.02174201f, -0.04044628f, -0.06354200f, -0.05349346f, 0.05124875f, -0.04489990f, 
    0.00783819f, 0.01874769f, -0.00100183f, -0.00938946f, -0.01494696f, 0.05200106f, -0.05348036f, -0.00232598f, 
    -0.02060446f, 0.00085583f, 0.00252234f, 0.01623743f, -0.02921166f, 0.02855870f, 0.04779455f, -0.03095248f, 
    -0.04264124f, 0.01416509f, 0.03988292f, -0.00069065f, -0.05613011f, 0.02363814f, -0.05714566f, 0.01979163f, 
    -0.04509047f, 0.00700065f, -0.02040781f, 0.03185356f, -0.06070769f, -0.03244595f, -0.06298486f, 0.00805514f, 
    -0.00547180f, -0.01335349f, 0.03554856f, 0.02722225f, 0.02769749f, 0.02747640f, -0.00489247f, 0.00455395f, 
    0.04358000f, -0.02824017f, -0.06196238f, 0.03048265f, -0.04562652f, 0.01629477f, -0.00007915f, -0.05007781f, 
    0.04924696f, 0.01152500f, 0.02132260f, -0.01556067f, -0.02483314f, 0.02376723f, -0.01260048f, -0.04888245f, 
    0.04078085f, -0.05175263f, -0.05171804f, -0.05364901f, -0.05161279f, -0.00703299f, -0.01685275f, -0.02463851f, 
    0.00811752f, 0.00152090f, -0.00994317f, -0.05472896f, -0.05289476f, 0.04978763f, -0.03184507f, -0.04347285f, 
    -0.02814017f, 0.04951122f, 0.01522774f, -0.01399553f, 0.02234964f, 0.00486196f, -0.01763953f, -0.02729803f, 
    -0.03354486f, 0.02746969f, 0.04664722f, 0.04838811f, -0.04296989f, 0.04338412f, -0.02455717f, 0.03758129f, 
    0.00256445f, 0.02850466f, 0.03763371f, -0.02052283f, 0.01157524f, 0.04749035f, -0.01176696f, -0.03205114f, 
    -0.04239557f, 0.01906242f, 0.01700820f, 0.03291957f, -0.05008850f, -0.00181280f, 0.02974244f, -0.03926579f, 
    0.01892988f, 0.04719480f, -0.02060170f, -0.05652526f, 0.04225084f, 0.05087658f, -0.06336466f, 0.01472994f, 
    0.01067476f, 0.02259332f, 0.02006511f, -0.00991078f, -0.00015713f, 0.03532744f, 0.03217636f, 0.02992951f, 
    -0.05280059f, -0.01009229f, 0.00604147f, -0.04834522f, -0.05964754f, -0.05303229f, -0.00250361f, -0.01403438f, 
    0.04050977f, 0.02334144f, 0.05018333f, -0.02084694f, -0.01476125f, -0.00088175f, 0.02204084f, -0.03619156f, 
    0.02863265f, -0.04178492f, -0.05563556f, -0.01249358f, -0.06172150f, -0.06300271f, -0.03588782f, 0.03973877f, 
    0.02830020f, -0.03514736f, -0.06415492f, -0.01483836f, 0.02803758f, -0.03254356f, 0.01869078f, -0.01330161f, 
    -0.05214353f, 0.03543717f, 0.00430287f, -0.01745398f, -0.00856500f, -0.04613881f, 0.03049737f, -0.05151402f, 
    0.02090646f, -0.01543637f, 0.04413344f, -0.00990637f, 0.00000254f, 0.00010851f, 0.01282830f, -0.04705053f, 
    0.00626158f, -0.04486521f, -0.01037208f, -0.00697195f, -0.01150907f, -0.01361490f, 0.04027372f, -0.01273141f, 
    -0.05737551f, -0.03591928f, -0.04969854f, 0.02267417f, -0.02455460f, 0.00438748f, -0.03200096f, 0.03846784f, 
    0.01244261f, 0.00873476f, -0.04089121f, 0.02087041f, -0.01915575f, -0.04461362f, -0.01405231f, -0.05705064f, 
    -0.02987796f, -0.01463513f, 0.04152173f, -0.06016136f, 0.05086425f, 0.00534076f, -0.01389279f, -0.04398550f, 
    0.02894454f, 0.02736036f, -0.02360216f, -0.02176626f, 0.01740005f, 0.04601786f, -0.04884259f, -0.00657489f, 
    0.04917130f, 0.04518742f, 0.04965951f, -0.05993669f, 0.00840228f, -0.00820330f, -0.02642897f, 0.05077106f, 
    -0.05329691f, -0.12607810f, 0.01527255f, -0.11785679f, -0.05634873f, -0.09131926f, 0.09490503f, 0.08520358f, 
    -0.11273704f, 0.21105629f, -0.03600181f, -0.32692853f, 0.29637441f, -0.13597429f, 0.08726779f, 0.01664528f, 
    -0.04352847f, -0.07577886f, -0.11093944f, 0.14139149f, 0.17137623f, 0.06872667f, -0.00354403f, 0.04272852f, 
    -0.10818484f, -0.24884377f, -0.09666745f, -0.26892671f, -0.02948300f, -0.32016304f, 0.09505602f, 0.08593667f, 
    0.17506385f, 0.09755991f, 0.49466911f, -0.22569416f, 0.19884323f, 0.24042931f, -0.29198608f, -0.15671051f, 
    -0.08264907f, -0.12594885f, 0.01902052f, -0.09449525f, -0.12099452f, 0.08443945f, -0.19649890f, -0.06820281f, 
    0.16595872f, 0.24217896f, 0.12220576f, 0.26796210f, 0.17458734f, -0.41542700f, -0.11934508f, 0.00231913f, 
    -0.16910930f, -0.05142719f, 0.33186790f, -0.08055281f, 0.04761572f, -0.03705754f, -0.05676207f, 0.26198158f, 
    0.33562940f, -0.20864913f, 0.02549475f, 0.01475220f, 0.18413128f, 0.05388832f, 0.07280723f, -0.29169315f, 
    -0.20787773f, 0.10240683f, -0.07754043f, -0.11701559f, -0.12558240f, 0.05249715f, 0.06980832f, 0.14443038f, 
    -0.06530659f, 0.09578954f, 0.11200480f, -0.29726681f, 0.01678511f, 0.01276464f, -0.13587917f, -0.05455467f, 
    0.17580530f, 0.15973221f, 0.44370773f, -0.13208629f, -0.00710214f, -0.10124026f, 0.00671952f, -0.12986033f, 
    0.24932167f, -0.27340588f, -0.13718046f, -0.03921169f, -0.33780533f, 0.24909152f, -0.30283725f, 0.45224586f, 
    0.25642452f, 0.09731914f, -0.00884041f, -0.05482412f, 0.33980343f, 0.03455266f, 0.00782396f, 0.23961654f, 
    -0.26283401f, -0.21153575f, -0.11821640f, -0.15830071f, 0.27521777f, -0.15137842f, -0.09413067f, -0.20228383f, 
    -0.11203711f, -0.11566220f, 0.08967900f, 0.12076772f, 0.04847120f, 0.05740681f, 0.30291563f, 0.07174984f, 
    -0.25215706f, 0.15624253f, 0.19665860f, 0.28331700f, -0.04625333f, 0.36187759f, 0.26143774f, -0.12156474f, 
    0.03511345f, 0.11762854f, -0.05559687f, -0.02476148f, -0.21697845f, -0.18693408f, -0.14265920f, -0.25474912f, 
    -0.14013830f, 0.03864143f, 0.15835015f, -0.24771218f, 0.15682928f, -0.11251570f, -0.08469172f, 0.14079016f, 
    0.12340228f, -0.32511339f, -0.13915323f, 0.14026541f, 0.08344869f, -0.08970128f, 0.08396744f, 0.05726467f, 
    0.16222295f, 0.22917214f, 0.16283178f, -0.23577036f, 0.01410207f, 0.07530367f, 0.21035904f, 0.21499333f, 
    -0.02343282f, -0.14021695f, 0.34351283f, 0.19905715f, -0.03938339f, -0.11555365f, 0.10640540f, -0.05683067f, 
    -0.24998473f, 0.01022300f, -0.14554527f, 0.21511208f, -0.37758821f, -0.10017157f, 0.21316117f, 0.10811166f, 
    0.14896679f, -0.00593741f, 0.25754273f, -0.00433529f, -0.05578769f, 0.02205096f, -0.01677614f, 0.14319205f, 
    0.08520009f, 0.09345807f, 0.10163938f, -0.11249989f, 0.00078778f, 0.02245415f, -0.05812297f, 0.03982282f, 
    0.03902564f, 0.03159374f, 0.03213133f, 0.07026951f, -0.10766456f, -0.09774205f, -0.26698279f, 0.28188461f, 
    0.07717841f, -0.06812222f, 0.05690080f, -0.04037856f, -0.33020517f, -0.03168373f, -0.06663330f, 0.07375475f, 
    0.00882384f, -0.06872173f, -0.26612788f, 0.28133184f, 0.02368113f, 0.02806533f, -0.18379205f, -0.03459350f, 
    -0.35541779f, 0.27364323f, 0.28937548f, 0.00844550f, -0.07467449f, 0.08429658f, -0.02380638f, -0.04653122f, 
    -0.12435777f, 0.04403641f, -0.12581390f, 0.07148776f, -0.00411970f, -0.18699640f, -0.15776187f, 0.17166734f, 
    0.03072671f, 0.14396068f, 0.05685427f, 0.30486074f, -0.19967355f, -0.13406062f, -0.02573989f, 0.08777364f, 
    0.01898074f, 0.03011268f, 0.05832812f, 0.23484205f, -0.14763770f, 0.00044845f, 0.07901676f, 0.05176308f, 
    -0.06532086f, -0.08593459f, -0.36107326f, -0.31318799f, -0.04280156f, 0.16850436f, 0.02658152f, -0.37480921f, 
    0.31789574f, 0.27275822f, 0.01014248f, -0.08704361f, 0.30953112f, 0.40480578f, -0.12650898f, 0.11065464f, 
    0.02959144f, 0.10952932f, -0.06122295f, 0.03628947f, -0.25210929f, 0.40023127f, -0.02056938f, -0.24211860f, 
    -0.06285109f, 0.15883306f, 0.07581377f, 0.01393698f, -0.21429430f, -0.08753999f, -0.06370165f, 0.18458113f, 
    -0.06171635f, 0.00439157f, 0.01115313f, 0.03046780f, -0.04947543f, 0.04246100f, -0.04932547f, -0.06341197f, 
    -0.01054788f, 0.04396186f, 0.05093280f, 0.00514512f, -0.00083039f, 0.03647587f, -0.02606136f, 0.05093193f, 
    -0.04280157f, 0.03323849f, -0.04108417f, -0.02146370f, -0.05703140f, -0.02767310f, 0.00597219f, 0.01384525f, 
    -0.03069233f, 0.02215488f, -0.04635962f, -0.02105429f, 0.04010178f, -0.05784282f, 0.02531501f, -0.01778514f, 
    0.03575047f, 0.02372662f, 0.03513055f, 0.03744365f, 0.02812351f, -0.05133490f, -0.00151746f, -0.05410095f, 
    -0.00763547f, -0.03095526f, -0.03985315f, 0.01644930f, 0.00653510f, -0.03147460f, 0.04058443f, -0.00365468f, 
    0.00455321f, -0.05966252f, -0.05620367f, -0.01852776f, -0.02171971f, 0.00658229f, 0.00841755f, -0.04737196f, 
    -0.04458746f, -0.04260017f, -0.03125213f, -0.05391828f, 0.01736042f, -0.05024347f, -0.04145068f, -0.04805849f, 
    0.04764808f, 0.00329096f, 0.04635998f, -0.04092394f, -0.04778247f, 0.00746854f, -0.02613400f, -0.03809918f, 
    0.03960591f, -0.01894023f, -0.03207238f, -0.00816132f, -0.02667218f, -0.00221608f, 0.01508391f, -0.00814096f, 
    -0.02179436f, -0.05605192f, -0.02564605f, -0.01997243f, -0.01941908f, -0.00472749f, -0.00935224f, 0.04677590f, 
    -0.02993351f, -0.03057393f, -0.02799882f, -0.03957165f, -0.01903893f, 0.03435693f, 0.01866069f, 0.03647557f, 
    -0.01311601f, 0.01640444f, -0.05546157f, 0.02111933f, 0.02616294f, 0.02612868f, -0.04035549f, 0.02818101f, 
    0.04536369f, 0.01131707f, 0.00728490f, -0.02177145f, 0.04588476f, 0.02959812f, 0.03359699f, 0.00278963f, 
    0.04453064f, -0.05618829f, 0.05075566f, 0.01017765f, -0.04610004f, -0.01388589f, -0.01263811f, -0.06604730f, 
    -0.04833992f, -0.06467900f, -0.03304297f, -0.02541787f, 0.05179364f, 0.02561864f, -0.03443934f, 0.02002932f, 
    -0.05564034f, -0.01078390f, -0.06302425f, 0.00263542f, -0.00252526f, -0.01052157f, -0.00440483f, -0.03445378f, 
    0.03223955f, -0.00320145f, -0.01914263f, -0.06238077f, 0.00320306f, 0.04177157f, -0.05226433f, -0.04954979f, 
    0.03550574f, 0.04121513f, 0.03034424f, -0.04072477f, 0.00953645f, -0.05723316f, -0.01869229f, 0.05057305f, 
    -0.00702961f, 0.00814651f, -0.05824658f, 0.03133051f, 0.00332041f, -0.00116145f, -0.00373697f, -0.01314385f, 
    -0.04370562f, 0.01502699f, 0.03545858f, 0.03232006f, 0.01567776f, -0.02039972f, -0.05110734f, 0.04053382f, 
    -0.03343787f, -0.01637798f, -0.04264541f, -0.06097242f, -0.02855747f, 0.04164137f, -0.00980687f, -0.00127834f, 
    -0.04746898f, 0.02596445f, -0.06459820f, 0.04841350f, 0.04416998f, -0.04893290f, 0.00605706f, -0.00684144f, 
    0.02581498f, 0.04117218f, -0.05121827f, 0.03117232f, -0.00255310f, -0.01088167f, -0.03615749f, -0.04669899f, 
    -0.02027881f, -0.00818046f, -0.05930801f, -0.06641496f, -0.02342290f, 0.01057268f, 0.03070871f, 0.03424853f, 
    0.03365849f, 0.05109702f, 0.00671831f, 0.02864894f, 0.04148974f, 0.04872462f, -0.00559314f, -0.01834993f, 
    -0.03636035f, -0.02812741f, 0.03643434f, -0.04276219f, 0.00320678f, -0.04842624f, -0.03875836f, -0.04810601f, 
    0.01763761f, 0.04027256f, -0.00670584f, -0.05025943f, 0.02732061f, -0.03139718f, -0.06171801f, 0.04015420f, 
    0.02066627f, -0.05222172f, -0.03206395f, -0.03090694f, -0.01064953f, 0.04959105f, 0.00760518f, -0.03887987f, 
    0.02940523f, -0.01609178f, -0.00871407f, -0.00071913f, -0.04246170f, -0.05744535f, 0.05037201f, 0.01179019f, 
    -0.03715890f, -0.05980803f, -0.05468139f, -0.02323266f, 0.00649652f, -0.06159545f, 0.00683413f, -0.03884904f, 
    -0.05555197f, 0.03830552f, -0.00701441f, -0.05632031f, -0.03009530f, 0.03646102f, 0.02040886f, 0.00568314f, 
    -0.05437993f, 0.02018373f, 0.00241757f, -0.03539406f, -0.01789754f, 0.02201337f, 0.01627647f, -0.05886542f, 
    0.03090171f, -0.02500442f, 0.00779512f, 0.01753514f, -0.05824265f, -0.01037007f, -0.04570367f, -0.01079271f, 
    -0.04294226f, -0.05772541f, -0.06660146f, 0.03532266f, -0.03757035f, -0.04056969f, 0.01648602f, 0.01333385f, 
    -0.04239913f, -0.00561568f, 0.00938530f, -0.01244973f, -0.00062151f, -0.02963010f, 0.03122331f, 0.02893175f, 
    0.24074292f, 0.04203847f, 0.00190806f, 0.08692587f, 0.10848890f, 0.11002340f, 0.01338773f, -0.05578934f, 
    0.14380203f, -0.61493397f, -0.31459892f, 0.25146976f, -0.26550320f, 0.13167073f, -0.20796296f, -0.00031119f, 
    0.03647317f, -0.07558372f, 0.03487833f, 0.21785028f, 0.08171569f, -0.01017982f, 0.05496580f, 0.05100058f, 
    0.01432836f, 0.21185948f, -0.04248001f, 0.07292787f, 0.12701395f, 0.01310102f, 0.06407353f, 0.08087137f, 
    -0.18927597f, -0.09488544f, -0.24953015f, 0.36571410f, 0.17193036f, -0.00514224f, -0.07040729f, 0.08707660f, 
    0.27100977f, 0.16957463f, 0.18242620f, 0.17012185f, 0.08814348f, -0.32185891f, -0.12535928f, -0.02041492f, 
    -0.13764243f, 0.06117269f, 0.17191304f, -0.06834124f, -0.17070727f, -0.35137552f, -0.23666814f, -0.45337921f, 
    0.09071530f, -0.09284493f, -0.20625332f, -0.14112635f, 0.07131110f, -0.04796718f, -0.02741464f, -0.04393579f, 
    0.14898813f, -0.25654730f, -0.03167213f, 0.02295605f, 0.00631875f, 0.06669201f, 0.04882057f, 0.13954142f, 
    0.36895394f, -0.28891551f, -0.39741388f, 0.03906059f, 0.13341445f, 0.05341841f, 0.14479971f, -0.13280347f, 
    -0.01179414f, 0.18488269f, -0.34498179f, -0.02307886f, 0.03272787f, 0.02317630f, 0.07220219f, 0.07058570f, 
    0.02087219f, 0.17184000f, -0.47660944f, 0.38753101f, 0.40194413f, -0.09295283f, 0.22898051f, 0.15479757f, 
    0.10020322f, -0.02295151f, 0.10060313f, -0.15481044f, -0.95677227f, -0.01533660f, -0.27616483f, 0.21291089f, 
    -0.18472464f, 0.09617179f, -0.01040890f, -0.05305674f, -0.56378329f, -0.60591406f, -0.74743932f, 0.28787556f, 
    0.09317374f, -0.13621397f, -0.03062221f, -0.01417296f, -0.18678132f, -0.12271380f, -0.09816423f, -0.13006239f, 
    -0.04115764f, -0.07740236f, -0.19981691f, -0.11222239f, -0.13212821f, -0.09515291f, -0.01504082f, -0.01323966f, 
    0.11608456f, -0.15657686f, -0.01940150f, 0.14740425f, 0.14459394f, 0.08460794f, 0.18119004f, 0.17334031f, 
    0.09744242f, -0.47509924f, 0.16170172f, -0.03438848f, 0.00476509f, -0.10990969f, 0.07497210f, 0.19157153f, 
    0.16345030f, -0.55231917f, -0.03731836f, 0.09240953f, 0.25250074f, 0.01842547f, 0.13624729f, 0.15125182f, 
    0.08547959f, -0.02846241f, -0.24140286f, 0.12944379f, 0.06681919f, 0.05974507f, 0.06254268f, 0.14967506f, 
    -0.00338265f, 0.04679586f, -0.44519684f, -0.00367088f, -0.07983477f, 0.00682827f, 0.01237153f, 0.09116662f, 
    0.05601166f, -0.09184300f, 0.09539301f, -0.26653454f, 0.05165662f, -0.49845120f, -0.01177385f, 0.06268436f, 
    -0.16507639f, -0.03663779f, 0.12094560f, 0.13389070f, -0.42252460f, 0.08341043f, -0.06492970f, -0.10210053f, 
    -0.04099120f, -0.00893243f, 0.02106526f, -0.00681811f, 0.10976558f, 0.02279452f, 0.29953325f, 0.10830149f, 
    -0.02630662f, -0.09618710f, -0.13375768f, -0.00010713f, 0.04886597f, 0.16175015f, -0.03276917f, 0.03369831f, 
    -0.02870903f, 0.02716560f, -0.08235618f, -0.16028635f, -0.11661629f, 0.09307063f, -0.02209379f, 0.27437821f, 
    0.02120060f, 0.03063814f, -0.14837438f, -0.04305395f, -0.09725615f, -0.02261930f, 0.20105956f, 0.19601546f, 
    -0.18062502f, -0.09363984f, -0.16517267f, -0.22490114f, 0.15444851f, -0.13375330f, -0.20604683f, -0.06512931f, 
    -0.04416022f, -0.21317281f, 0.15460670f, -0.08456206f, 0.03910465f, -0.06241437f, 0.05032707f, 0.14885433f, 
    0.16494334f, -0.21632005f, 0.67969954f, -0.32933536f, -0.80495483f, 0.00507777f, 0.07527779f, -0.02424821f, 
    0.04361197f, -0.19034907f, 0.06175575f, -0.29111287f, 0.00706178f, 0.65436047f, 0.05781319f, 0.17991903f, 
    0.01848293f, 0.05205167f, 0.11149178f, -0.17054084f, 0.02209765f, -0.11362644f, -0.04697579f, -0.01200678f, 
    -0.06703459f, 0.05279182f, 0.15770338f, 0.07724470f, 0.19637203f, 0.22399290f, -0.03485799f, 0.11719399f, 
    -0.13209201f, -0.11809744f, 0.11938693f, 0.08107532f, -0.00882707f, 0.02032556f, -0.03861333f, 0.09541300f, 
    0.13775049f, 0.02916365f, 0.05183410f, -0.15323487f, 0.00525292f, 0.08683155f, -0.15030602f, 0.03723492f, 
    0.44599697f, -0.09260810f, 0.14464249f, -0.05598609f, 0.07685658f, 0.04751839f, -0.11467604f, -0.12207057f, 
    0.03592505f, -0.01268626f, -0.05978422f, 0.04633615f, 0.02343949f, -0.04478310f, 0.03588393f, -0.05746421f, 
    0.04823624f, 0.01907184f, 0.00090842f, 0.00518366f, -0.07316068f, -0.06154309f, 0.01264674f, -0.05327704f, 
    -0.00621583f, -0.00683089f, -0.01078400f, -0.03159799f, -0.02632598f, 0.02913776f, 0.00309970f, -0.02245283f, 
    -0.04180734f, -0.01456062f, 0.04306244f, -0.00258656f, -0.03919825f, -0.03223114f, -0.06255446f, -0.01453632f, 
    -0.05749724f, 0.04017880f, -0.06100700f, -0.00416817f, 0.04757625f, -0.03480554f, -0.04944592f, 0.02261530f, 
    0.01650178f, -0.06164325f, -0.03558402f, 0.04832615f, -0.06250354f, 0.02422282f, -0.06183153f, -0.01191694f, 
    -0.05017813f, -0.06409436f, 0.03964784f, -0.00320338f, -0.01488522f, 0.00774959f, 0.04339446f, -0.02993112f, 
    -0.01085839f, 0.04258925f, 0.03706060f, -0.03782637f, 0.01916359f, 0.04056112f, -0.00446059f, 0.03505768f, 
    -0.00560537f, -0.00805505f, -0.02924936f, 0.04874881f, -0.04417611f, 0.04564955f, -0.01277150f, 0.00662795f, 
    -0.00681360f, -0.00795259f, -0.01709848f, 0.04391229f, 0.03252924f, 0.04958672f, -0.00993528f, -0.04680046f, 
    -0.05440896f, 0.02593337f, -0.01980657f, 0.01028480f, -0.05463927f, 0.00345090f, 0.03887895f, -0.04923477f, 
    -0.01998298f, -0.03441713f, 0.00564292f, 0.05122949f, -0.00978878f, -0.02752097f, 0.00572720f, 0.03309366f, 
    -0.01813132f, 0.01536031f, 0.01413936f, 0.01029536f, -0.05106765f, 0.02991522f, 0.04311392f, -0.06115514f, 
    0.00874916f, -0.03064094f, -0.06249691f, 0.00072077f, -0.03319490f, -0.03161294f, -0.01829492f, -0.00440150f, 
    -0.05796488f, -0.03219179f, 0.04861804f, 0.04050549f, -0.02674369f, 0.01966494f, -0.06074147f, 0.03248611f, 
    -0.03510538f, 0.01962611f, -0.04349613f, -0.01683397f, 0.01378430f, -0.02409494f, 0.01655458f, -0.04704312f, 
    0.02019233f, 0.04557739f, -0.00374977f, -0.02998105f, 0.02679947f, -0.03258798f, 0.00524042f, 0.02081463f, 
    0.01019159f, -0.05393884f, -0.02461932f, -0.00822996f, 0.03361602f, -0.05361212f, 0.03314344f, 0.01773843f, 
    -0.04412857f, -0.02340102f, -0.06271988f, -0.05810524f, 0.03184130f, 0.01241385f, 0.02125961f, 0.03843307f, 
    0.00178704f, -0.01621990f, -0.02477846f, 0.03419949f, -0.04504475f, 0.01420269f, -0.02545452f, -0.05438970f, 
    0.00120330f, -0.03202222f, 0.04364214f, 0.02913374f, -0.04268366f, -0.01473910f, -0.04134674f, -0.05672021f, 
    0.04426374f, -0.05082337f, 0.03275999f, 0.00962040f, 0.05223705f, -0.02364404f, -0.06415113f, 0.01359504f, 
    0.02968016f, -0.02224332f, -0.04863458f, -0.00202849f, 0.01534439f, 0.01527685f, 0.00959855f, -0.02624203f, 
    -0.05088249f, 0.01055473f, -0.03786290f, -0.04076387f, 0.05500716f, -0.01602222f, -0.01278555f, -0.04968850f, 
    0.03764407f, -0.03657512f, 0.04470266f, 0.02774990f, 0.00009774f, 0.01628614f, -0.03379272f, -0.06568112f, 
    0.03915792f, -0.02892089f, 0.02783369f, -0.04975322f, -0.00267551f, 0.00955146f, 0.02174755f, -0.04332127f, 
    0.00972290f, -0.01375319f, 0.00647610f, -0.04803167f, -0.00743080f, -0.00738931f, 0.02520563f, 0.02039894f, 
    0.03042879f, 0.01024608f, -0.01429171f, -0.01271856f, 0.00762374f, 0.00728586f, 0.03268716f, -0.01455675f, 
    0.04364606f, -0.04312380f, -0.03289131f, 0.04555302f, -0.02640182f, 0.00274065f, -0.01244944f, -0.01670963f, 
    -0.02851290f, -0.01952486f, 0.05157738f, -0.05945000f, -0.02892430f, -0.03521343f, 0.03855014f, 0.00116117f, 
    -0.05308392f, 0.01357021f, 0.03770721f, 0.03727225f, 0.04664810f, -0.05635533f, 0.01761695f, -0.03935926f, 
    -0.01172032f, -0.00939655f, -0.04241647f, -0.06253771f, 0.00029205f, -0.01137912f, 0.04451625f, 0.00961550f, 
    -0.06341344f, 0.03661868f, -0.00473389f, -0.04790506f, -0.01692405f, 0.04804593f, -0.04837487f, -0.03003744f, 
    0.04607751f, 0.04666417f, -0.01738788f, -0.01710844f, -0.06217654f, 0.00681768f, 0.04950988f, -0.03431955f, 
    0.01638385f, -0.00171211f, -0.01141015f, 0.02780590f, -0.01138219f, 0.03415316f, -0.05681897f, -0.04847482f, 
    -0.00155568f, -0.02558372f, 0.01534840f, -0.03718759f, 0.00975517f, -0.01403785f, -0.05239717f, -0.02297402f, 
    -0.12551551f, 0.10202742f, 0.20027384f, 0.18797730f, 0.07786859f, -0.12025143f, 0.10587738f, 0.23850539f, 
    -0.04512053f, -0.22685371f, -0.32311222f, 0.74323493f, 0.01804138f, 0.09500334f, -0.16232833f, -0.04181290f, 
    0.12905684f, -0.05326176f, 0.12747604f, 0.11597930f, 0.00213406f, -0.31338066f, 0.04137901f, 0.06954040f, 
    0.16133359f, 0.06872096f, 0.12096836f, 0.08673872f, 0.17471237f, 0.08889566f, -0.01518406f, -0.01178629f, 
    -0.25391677f, 0.09807433f, 0.09378756f, 0.48623210f, 0.10348105f, 0.08127736f, 0.05728493f, 0.24144863f, 
    -0.13390781f, 0.05820512f, 0.27287766f, 0.32535669f, 0.05652031f, -0.23556739f, -0.29146877f, 0.08550458f, 
    -0.05205972f, 0.37691933f, -0.18472205f, 0.03522733f, 0.02305264f, -0.01606766f, -0.79717368f, -0.94061136f, 
    -0.30026537f, 0.04751847f, -0.20748782f, -0.03980517f, -0.01013996f, -0.03565925f, 0.07611057f, 0.20020388f, 
    0.17938645f, -0.03450014f, 0.11926665f, 0.04898951f, -0.12504904f, 0.09248811f, 0.16937789f, 0.28728625f, 
    0.09908848f, -0.06204266f, 0.09169247f, 0.02714138f, 0.06703857f, -0.07235881f, 0.13207841f, -0.00680879f, 
    -0.20288453f, -0.15768193f, -0.21690825f, 0.25645468f, -0.07625429f, -0.06081693f, -0.00809521f, -0.00489229f, 
    0.19345753f, -0.04411062f, -0.02698647f, 0.53253347f, 0.34008226f, -0.06972151f, 0.18630165f, 0.11531292f, 
    -0.03287841f, 0.07543243f, 0.14136262f, -0.16795675f, -0.03558173f, -0.03628376f, -0.03134502f, -0.20406756f, 
    -0.09089408f, -0.13734242f, 0.15470855f, 0.11741990f, -0.17032321f, -1.09867358f, -0.11591975f, 0.04546232f, 
    -0.07110745f, -0.09253565f, -0.08471502f, -0.31783029f, -0.13016117f, 0.03525937f, 0.05071482f, 0.18255220f, 
    -0.01824778f, -0.08446614f, -0.19272813f, -0.29869518f, 0.11803859f, -0.10831018f, -0.65863001f, -0.32484043f, 
    0.21585183f, -0.18449695f, 0.00239039f, 0.10307246f, 0.11999412f, 0.17579162f, 0.13602678f, -0.01412827f, 
    -0.30169359f, -0.43959415f, 0.17112225f, 0.02851343f, -0.00548964f, -0.01243314f, -0.08094106f, 0.05898884f, 
    -0.17146432f, -0.20256773f, -0.18113106f, 0.08813525f, 0.03380199f, 0.03965116f, 0.25594395f, 0.36139968f, 
    -0.00781131f, -0.16830893f, 0.01748407f, -0.02816821f, -0.00586585f, 0.04593351f, 0.00333737f, 0.26396555f, 
    0.33574843f, 0.19765389f, 0.09828071f, -0.12654802f, -0.00804397f, -0.12162096f, -0.18725441f, 0.20982067f, 
    0.05425758f, 0.11213461f, 0.05163537f, -0.83199847f, -0.42499974f, -0.64978421f, -0.06490339f, -0.02201057f, 
    0.12896603f, -0.05935333f, -0.13735889f, -0.09894679f, 0.04692779f, 0.12636338f, 0.06616580f, 0.01624371f, 
    0.05637193f, -0.02369361f, 0.42645288f, -0.06320639f, 0.33033353f, 0.20391810f, 0.18948478f, 0.02849551f, 
    -0.14151061f, -0.11701520f, -0.11898346f, 0.24293222f, 0.09868854f, 0.19479357f, 0.06952439f, -0.04157823f, 
    -0.17637677f, -0.45200294f, -0.39535961f, -0.23209299f, 0.07784860f, 0.04658110f, -0.04394606f, -0.67726344f, 
    -0.18180436f, -0.69736505f, -0.09227944f, -0.04525615f, -0.06473545f, -0.20775807f, -0.13197377f, -0.18234639f, 
    -0.40628392f, -0.57974333f, 0.05992146f, 0.05430372f, 0.05969870f, -0.15915357f, 0.00346855f, 0.07435263f, 
    -0.02024829f, 0.16193880f, 0.08023043f, -0.14630423f, -0.10560099f, 0.03670181f, 0.03431301f, -0.04685714f, 
    0.08170255f, 0.11193022f, -0.39598501f, -0.39553604f, -0.07968502f, 0.20537335f, 0.18877259f, -0.08714806f, 
    -0.07365446f, 0.05069311f, -0.07727536f, -0.14958358f, 0.42059955f, 0.65792102f, -0.26023999f, 0.18802528f, 
    0.14870141f, 0.12254585f, 0.17150696f, 0.01652630f, 0.16241282f, -0.08646296f, -0.02545143f, -0.07520261f, 
    -0.02554848f, 0.05115587f, 0.03238894f, -0.03886310f, -0.00949592f, -0.58977872f, -0.23685345f, 0.18763611f, 
    -0.22837871f, -0.15682045f, -0.02959672f, 0.01204035f, 0.04754066f, 0.00092492f, 0.13995042f, 0.26163378f, 
    -0.02041990f, -0.35053912f, -0.12684970f, 0.01419813f, 0.06591382f, 0.09058534f, 0.04187957f, 0.08799532f, 
    0.69971472f, -0.58779967f, 0.07244802f, 0.07989507f, -0.21628779f, 0.15162334f, 0.10172198f, 0.07960530f, 
    -0.10587523f, 0.06057114f, -0.08126508f, 0.10094693f, -0.01985452f, -0.12467813f, 0.27990493f, 0.06914535f, 
    0.08756700f, 0.09618684f, -0.05296635f, 0.30553541f, -0.12392369f, 0.13268152f, -0.10258362f, 0.04642535f, 
    0.03733844f, 0.08672938f, 0.17551182f, -0.00211668f, 0.01412119f, -0.05581569f, -0.02864644f, 0.15111573f, 
    -0.23217054f, -0.05553297f, 0.08214797f, -0.07805146f, 0.00772637f, 0.35469881f, -0.05203454f, 0.05925626f, 
    0.04466590f, -0.11961919f, 0.10725010f, 0.17644833f, -0.23657815f, 0.24123962f, 0.21980892f, -0.03917094f, 
    0.26451087f, -0.04309429f, 0.13437825f, 0.23444906f, 0.08589034f, -0.00128220f, 0.15867129f, 0.10452943f, 
    -0.13813847f, -0.16141096f, -0.03812440f, 0.03701186f, 0.24393527f, 0.20691834f, -0.35847986f, 0.26226228f, 
    -0.04545057f, -0.27431422f, -0.12142896f, 0.08069415f, 0.15685499f, 0.15281430f, 0.08243258f, 0.02144100f, 
    0.18567531f, 0.10083864f, -0.00774987f, 0.25283962f, -0.21525121f, 0.30716997f, -0.11379307f, -0.03610251f, 
    -0.11726569f, -0.05529490f, -0.04098240f, -0.04503516f, 0.03979689f, 0.01776631f, 0.18049385f, 0.19485928f, 
    -0.04180352f, 0.24810338f, -0.22932567f, 0.35196489f, -0.16008623f, 0.05447851f, -0.28146607f, -0.17370743f, 
    -0.13350682f, -0.03085808f, 0.25347859f, -0.10091781f, 0.01386252f, 0.03441554f, -0.06605073f, -0.05923520f, 
    0.07415299f, 0.13753185f, -0.11911008f, -0.00952978f, 0.40538564f, 0.25610289f, -0.34164283f, -0.14173837f, 
    0.00455932f, 0.00002544f, 0.13540190f, 0.32463062f, -0.54234987f, 0.37408069f, 0.94971144f, -0.09370738f, 
    0.32264996f, 0.28175643f, -0.06914013f, -0.07742155f, 0.29766923f, 0.08017869f, 0.09824546f, 0.20525350f, 
    -0.08598389f, -0.03392285f, -0.03863429f, 0.15050842f, 0.03688220f, -0.00522815f, 0.57752174f, 0.00608368f, 
    -0.13411100f, 0.07546695f, -0.03641208f, -0.10376408f, -0.15100840f, -0.21112719f, -0.32747743f, -0.19865660f, 
    0.05239476f, -0.02686919f, 0.24252743f, 0.18398498f, -0.06924202f, 0.16083615f, 0.01971011f, 0.09536257f, 
    0.20292051f, -0.03992669f, 0.43459496f, -0.29011267f, -0.00419609f, -0.03696022f, -0.08957562f, -0.09074639f, 
    -0.10575693f, 0.16348438f, 0.03383243f, -0.05680208f, -0.03485331f, 0.02401127f, 0.12626222f, 0.01056968f, 
    -0.07711264f, -0.15980576f, 0.00941797f, 0.11609584f, 0.13210897f, 0.09193917f, -0.02416920f, -0.16918007f, 
    -0.24093030f, -0.23511183f, 0.30960619f, -0.18349603f, -0.20142554f, 0.07490315f, -0.22934771f, 0.17161305f, 
    -0.06284873f, 0.03476594f, -0.19569661f, -0.16775693f, -0.05578052f, 0.02601412f, 0.03740123f, -0.10091416f, 
    0.02534069f, -0.08599123f, 0.02192795f, 0.04811949f, -0.08018167f, 0.01017531f, 0.13384151f, 0.22063510f, 
    -0.07780702f, -0.00665223f, -0.19144474f, -0.17591521f, 0.11509591f, -0.10441151f, 0.07270662f, 0.01025823f, 
    -0.09112602f, 0.08043201f, -0.00618389f, -0.18147640f, -0.29739955f, -0.10456716f, -0.02459356f, -0.04167056f, 
    -0.23510464f, 0.27091748f, -0.13099280f, -0.03432723f, -0.13159339f, 0.03867394f, -0.10605558f, -0.13223870f, 
    -0.20464557f, -0.19572204f, 0.11493272f, 0.01821220f, -0.09878278f, -0.12851501f, 0.03153173f, 0.08968268f, 
    0.04299923f, 0.25578237f, 0.16296352f, -0.23245881f, 0.04934003f, -0.05439023f, 0.00046062f, -0.09509639f, 
    0.04228554f, 0.14613283f, -0.36463642f, -0.13768567f, 0.08971694f, -0.11843982f, 0.10816478f, 0.04763707f, 
    0.07100852f, 0.06426272f, 0.03135657f, 0.37933466f, -0.26662254f, -0.54889244f, -0.09561837f, -0.25754583f, 
    0.10037530f, -0.07084593f, 0.04607033f, -0.09697442f, 0.03570383f, 0.13278870f, -0.01494193f, 0.19049270f, 
    0.16189270f, -0.10508589f, 0.04890906f, 0.04114104f, 0.14487691f, 0.17971614f, -0.45625770f, 0.24607155f, 
    -0.03928442f, 0.10055213f, -0.19362476f, -0.11374985f, -0.22689785f, -0.31520540f, 0.06215675f, -0.42304513f, 
    0.32142392f, -0.09529100f, 0.14220448f, 0.21631522f, -0.16058196f, 0.02461843f, -0.02700263f, -0.08531775f, 
    -0.11728645f, 0.10377254f, -0.29131332f, -0.01023529f, 0.24078162f, 0.12668358f, 0.14283942f, 0.15985331f, 
    -0.02483888f, -0.06243945f, -0.05837618f, -0.05400388f, -0.05157049f, 0.03201052f, -0.02200403f, 0.02128680f, 
    -0.02156099f, -0.02666528f, -0.00030261f, -0.01357746f, 0.01553103f, -0.04721810f, -0.06681193f, -0.02225235f, 
    0.00654514f, 0.02275546f, 0.01095675f, -0.06080868f, -0.01896086f, 0.01065430f, 0.00689057f, 0.04335544f, 
    -0.02150277f, -0.00072966f, -0.02660031f, -0.00584110f, 0.03396030f, 0.05601739f, -0.04562220f, 0.04266849f, 
    0.04700770f, -0.00389849f, 0.03864835f, 0.05390263f, 0.04779411f, 0.02664552f, 0.00233613f, -0.04177268f, 
    -0.03057964f, -0.03704229f, -0.05242621f, -0.04387491f, -0.03772989f, -0.06335318f, -0.01678372f, -0.03703382f, 
    -0.05548850f, -0.02158952f, -0.04296330f, -0.02252081f, -0.03577706f, -0.00922480f, 0.00219726f, 0.05239341f, 
    -0.00117306f, -0.06879521f, -0.01728078f, 0.05082309f, -0.01312559f, 0.02768920f, -0.01407870f, 0.00580137f, 
    -0.00074553f, -0.00632609f, -0.03720089f, -0.04705816f, -0.04036670f, 0.05967654f, -0.05270815f, -0.05267193f, 
    -0.01565823f, 0.05690786f, 0.02813976f, 0.01764594f, -0.01250684f, -0.05888743f, -0.01971168f, 0.00071131f, 
    -0.05136689f, -0.05387178f, 0.00496694f, -0.05026497f, 0.00482283f, -0.06211639f, -0.03210054f, -0.02741490f, 
    0.00554622f, 0.03157536f, -0.00993231f, 0.04552335f, -0.00068997f, 0.01703972f, -0.02759536f, 0.00854800f, 
    -0.01015037f, 0.02489372f, 0.00275532f, 0.02093472f, -0.01153114f, 0.02590650f, 0.00990718f, 0.03934914f, 
    -0.02548070f, 0.03250118f, -0.03421665f, -0.04869682f, 0.00013198f, 0.03829417f, -0.00876013f, -0.05017014f, 
    -0.01855139f, 0.00573882f, -0.03783734f, -0.02144999f, -0.00311439f, 0.02232718f, -0.01398258f, -0.05218846f, 
    -0.05409531f, 0.00132493f, -0.04252921f, -0.03256855f, 0.02755941f, 0.03366560f, -0.05165215f, -0.05727577f, 
    -0.02672026f, 0.05284853f, 0.04149174f, -0.03084362f, -0.06470654f, -0.07109806f, -0.04682423f, 0.02064613f, 
    -0.05707474f, -0.03362412f, -0.04117810f, -0.03368372f, 0.05557137f, -0.03324455f, 0.02952884f, 0.00580176f, 
    -0.05099835f, -0.02278086f, 0.04478747f, 0.01444142f, 0.01298521f, 0.04559875f, -0.00069933f, -0.02936913f, 
    0.00027329f, 0.00120997f, 0.01313796f, 0.01516084f, -0.06819581f, -0.02076425f, -0.05890666f, 0.00096101f, 
    -0.03591062f, 0.02405157f, 0.03876226f, -0.01184058f, 0.04644859f, -0.02998565f, -0.00102304f, 0.02732058f, 
    -0.01784895f, 0.02047579f, -0.00320989f, -0.05145144f, -0.04678505f, -0.03922217f, 0.01678415f, -0.01334985f, 
    0.03371368f, -0.01389597f, 0.00955495f, -0.06153837f, 0.02592752f, 0.03967772f, -0.04361757f, -0.07705578f, 
    -0.03027306f, 0.03154721f, 0.03656875f, -0.02282709f, -0.02890912f, -0.02042240f, 0.00034745f, 0.01761395f, 
    0.01211529f, 0.02147418f, 0.04558152f, -0.03532232f, 0.01393374f, 0.03983513f, 0.00068686f, -0.00579403f, 
    -0.03780231f, 0.00094441f, -0.05222710f, 0.01655404f, -0.00040256f, -0.04139022f, 0.00287572f, -0.02711934f, 
    -0.05213465f, -0.03320668f, 0.04751487f, -0.05093405f, -0.05549707f, -0.04917806f, -0.03014431f, 0.02674625f, 
    -0.04760786f, 0.05828021f, -0.05773984f, -0.05563080f, -0.06662305f, 0.03807850f, -0.02180664f, -0.00749667f, 
    0.01578709f, 0.03818671f, 0.00762869f, 0.00390929f, 0.00839158f, -0.01164831f, -0.02446161f, 0.05592191f, 
    0.05222898f, -0.01023234f, -0.00612720f, 0.02025791f, 0.02067623f, -0.02325511f, 0.00811003f, -0.01640339f, 
    0.03322565f, 0.00410896f, 0.00923462f, -0.00931764f, -0.06130733f, -0.05466529f, 0.02884723f, 0.02021929f, 
    -0.00586358f, -0.05874124f, -0.03872527f, -0.05411943f, 0.02391977f, 0.04230931f, 0.02349600f, 0.02077690f, 
    0.04283939f, -0.01860964f, 0.04650027f, -0.02793332f, 0.01378308f, -0.06195538f, -0.01394288f, 0.05232992f, 
    -0.05873971f, -0.04164790f, 0.00756378f, -0.02296250f, -0.03737397f, 0.04793537f, -0.04254511f, -0.04159717f, 
    0.03319886f, -0.01867002f, -0.06297092f, 0.02730834f, 0.01192556f, -0.04267821f, 0.03033605f, 0.04933612f, 
    -0.00903615f, 0.01483911f, 0.05015419f, -0.04803059f, 0.00028032f, 0.00038915f, -0.00128032f, -0.01816799f, 
    -0.55830580f, 0.09692667f, -0.01062402f, -0.04874350f, -0.16373588f, 0.13950571f, 0.12492760f, -0.12733288f, 
    0.05899086f, 0.46634808f, 0.18853071f, 0.11823798f, -0.11320774f, -0.04360905f, -0.01890467f, -0.04226522f, 
    -0.12596682f, 0.05551510f, -0.10244445f, -0.02036407f, 0.11122440f, -0.12455672f, 0.05358232f, 0.16427189f, 
    -0.05554138f, -0.10919113f, 0.04230976f, -0.20713697f, 0.11122440f, 0.25488597f, -0.04336559f, 0.01888048f, 
    -0.16618125f, 0.13086380f, -0.15253662f, -0.02169279f, 0.38020375f, -0.00672422f, 0.10637928f, 0.01168038f, 
    -0.07830027f, 0.09396075f, -0.09738933f, -0.02384545f, -0.14439157f, 0.23704863f, 0.39115137f, -0.35060215f, 
    0.04933638f, -0.33634934f, 0.07535655f, 0.29607469f, -0.04617894f, 0.06375138f, 0.21982694f, 0.06722502f, 
    -0.16188245f, -0.12876873f, 0.02083534f, -0.15532726f, 0.09774759f, 0.19186988f, 0.12105346f, -0.03668667f, 
    0.07384863f, 0.14018023f, 0.13480173f, 0.21686375f, 0.10432429f, -0.14277799f, 0.01460548f, -0.01457523f, 
    -0.59431499f, -0.04232690f, -0.18761727f, -0.12172475f, -0.03446786f, 0.04224956f, 0.10281853f, -0.02924637f, 
    0.26613989f, 0.63491207f, 0.02205034f, -0.07493323f, -0.05322728f, 0.01885041f, -0.04351697f, -0.01178953f, 
    0.05048624f, -0.00157749f, 0.21786295f, 0.43311936f, 0.20422339f, 0.12964281f, 0.10676938f, -0.01338301f, 
    0.08154310f, 0.11213830f, -0.08695026f, -0.47242013f, -0.03318684f, 0.23994708f, -0.15214135f, 0.20925698f, 
    -0.09382608f, -0.08986735f, 0.08880300f, 0.04033639f, 0.01923841f, 0.32833716f, 0.80049938f, 0.07760021f, 
    0.17662732f, 0.10423105f, 0.23629476f, -0.01867597f, -0.20438550f, -0.37539229f, -0.07064586f, 0.01519719f, 
    -0.07675751f, 0.06141832f, -0.03389465f, -0.06268211f, 0.10235560f, -0.07216632f, 0.05354395f, 0.38524315f, 
    0.13646932f, -0.02820891f, 0.06483551f, -0.16478711f, 0.12276001f, -0.01225557f, -0.20672147f, -0.04043956f, 
    0.09560370f, -0.02740127f, -0.05724846f, 0.24024919f, 0.08852711f, 0.08873100f, -0.05391741f, 0.27263743f, 
    0.15891436f, -0.22584304f, -0.10174406f, -0.10016613f, -0.18579984f, -0.28583670f, 0.12009941f, -0.03640725f, 
    -0.24247254f, 0.03307193f, 0.10417948f, -0.10285450f, 0.01345540f, 0.26627478f, -0.29746768f, -0.01322523f, 
    -0.31162795f, -0.04315308f, -0.14748770f, 0.37464213f, 0.19573936f, -0.02540172f, 0.10904612f, -0.00912003f, 
    -0.06884389f, -0.29745924f, -0.19617109f, 0.39930767f, 0.17179582f, -0.08636832f, 0.15030667f, 0.09556882f, 
    -0.00779822f, 0.05370361f, -0.07838308f, -0.02781389f, -0.25571981f, 0.11397906f, 0.23140213f, -0.09014530f, 
    -0.07909963f, -0.05925479f, -0.08663449f, -0.06517991f, -0.09546246f, -0.17859888f, -0.05146178f, 0.31256208f, 
    0.01829050f, -0.03143926f, 0.17806064f, -0.15081754f, -0.05887550f, 0.23107903f, -0.02915605f, 0.07024617f, 
    0.01028979f, -0.07468461f, 0.01742764f, 0.10049973f, -0.04233095f, -0.01128546f, 0.09860015f, 0.61427999f, 
    0.02159810f, -0.24959639f, 0.00606153f, 0.16182113f, 0.04630024f, -0.00206696f, 0.05234979f, -0.09044608f, 
    0.27301696f, 0.00071192f, -0.00209334f, 0.04412999f, 0.03968091f, -0.04303320f, 0.10352442f, -0.03146352f, 
    0.20035718f, -0.17533255f, 0.38491991f, 0.09281694f, -0.08236984f, 0.15161942f, 0.13909613f, -0.01390578f, 
    -0.13203856f, -0.05665646f, -0.64686710f, -0.09930293f, -0.18707502f, -0.11145279f, -0.00539819f, 0.11748523f, 
    0.14825423f, -0.02963334f, 0.19219096f, -0.26762730f, 0.19641259f, 0.16462028f, 0.02913203f, -0.08993809f, 
    -0.20184954f, -0.10734095f, -0.09555688f, -0.13751568f, -0.04286556f, 0.06478120f, -0.00053856f, -0.04793185f, 
    0.07168090f, -0.01175667f, 0.00920260f, 0.00956973f, 0.12212246f, 0.53981799f, 0.22718017f, -0.01624009f, 
    0.01485272f, 0.21587721f, -0.12518851f, 0.11599762f, 0.16659248f, -0.27275538f, 0.04364523f, 0.11918598f, 
    0.76155025f, -0.12786683f, 0.16979061f, -0.04980314f, 0.08243398f, -0.10114910f, 0.01249303f, 0.47695115f, 
    -0.28106204f, 0.00091906f, -0.26057577f, 0.01664807f, 0.15120453f, 0.19394188f, -0.07770178f, 0.03302348f, 
    -0.37356356f, 0.03647128f, 0.20882101f, 0.00545189f, -0.04903619f, -0.03404322f, -0.07501868f, 0.18408774f, 
    0.06227340f, 0.34354198f, 0.32958552f, -0.11155865f, 0.00862296f, 0.09093214f, -0.04378109f, 0.07895575f, 
    0.02781782f, 0.07448502f, -0.07653163f, -0.11099086f, -0.14971611f, -0.01080373f, 0.06996194f, -0.22544335f, 
    0.06981330f, -0.01353991f, -0.01878665f, -0.11076931f, -0.12801662f, 0.11328641f, 0.28672090f, 0.10396256f, 
    0.00213320f, -0.33263406f, -0.40695092f, -0.34597850f, 0.17362154f, -0.05748725f, 0.02544981f, -0.08039024f, 
    0.10374889f, 0.03622945f, 0.08860652f, -0.00239883f, -0.19734992f, 0.24490333f, 0.18693733f, -0.14175530f, 
    0.10185334f, -0.11283221f, -0.17651954f, -0.03871659f, 0.07442884f, 0.00394304f, 0.47107798f, 0.08439543f, 
    -0.00319427f, 0.02910993f, -0.00853915f, 0.02150723f, -0.04973058f, 0.05644486f, -0.08988004f, -0.06269191f, 
    -0.12000781f, -0.01400736f, 0.16591902f, 0.13214941f, 0.25231484f, -0.12007430f, -0.14626732f, -0.39556554f, 
    -0.37009373f, -0.14680421f, -0.11763667f, 0.03550486f, 0.08726076f, 0.06132248f, -0.16303135f, 0.06433778f, 
    -0.03001108f, 0.28995028f, 0.04678962f, -0.09309243f, 0.05812302f, 0.05146746f, 0.17378634f, -0.06896297f, 
    -0.06726461f, -0.12972328f, 0.23952277f, 0.23662719f, -0.00349465f, -0.08809675f, -0.15177965f, -0.23998781f, 
    0.08584821f, 0.10892895f, 0.15398669f, -0.40689719f, -0.10284114f, -0.16774774f, 0.06923762f, 0.09316649f, 
    0.04723644f, -0.21644329f, 0.04942231f, 0.11990299f, 0.23727137f, 0.23011875f, 0.39321491f, -0.00422406f, 
    0.20784394f, 0.22449249f, -0.02940113f, 0.28012666f, 0.44758311f, -0.15266915f, -0.02808144f, -0.00200491f, 
    -0.02160698f, -0.01491064f, 0.22161946f, 0.03436499f, -0.19596381f, -0.41048968f, -0.12626103f, -0.07357456f, 
    -0.24097988f, 0.28314146f, 0.12279546f, 0.08549141f, -0.12797984f, -0.03889259f, -0.07593243f, -0.02556049f, 
    -0.07283147f, 0.14656629f, 0.07987263f, 0.10035501f, -0.09684872f, 0.08452197f, 0.14003833f, 0.06970491f, 
    -0.03875368f, -0.07133328f, -0.25189123f, 0.03541749f, -0.04097980f, 0.15200622f, 0.02134706f, -0.03262891f, 
    -0.15788087f, -0.00354306f, 0.11435892f, 0.05015445f, 0.11146168f, -0.03178254f, 0.08602732f, -0.11913441f, 
    -0.24308182f, -0.57564896f, -0.07313561f, -0.04816709f, 0.07785311f, 0.16903885f, 0.08306544f, 0.04419092f, 
    -0.39196193f, -0.19652583f, -0.31557211f, 0.11535337f, 0.38181859f, 0.04432260f, 0.13337727f, 0.12860128f, 
    0.13100550f, -0.01337476f, -0.02101868f, -0.20962818f, -0.13678482f, -0.04885881f, 0.06437589f, 0.10639084f, 
    -0.02498243f, 0.05726932f, -0.53815800f, 0.04360834f, -0.01667842f, -0.04979666f, -0.07599207f, 0.07568082f, 
    0.12115507f, 0.25371045f, -0.23790124f, -0.05658184f, -0.01126189f, -0.10695828f, -0.09306377f, -0.06028505f, 
    -0.04509756f, -0.12573400f, -0.21515678f, -0.21675478f, -0.00785386f, 0.12774867f, 0.14004686f, 0.28715116f, 
    0.26168984f, -0.22687405f, 0.09629507f, -0.04214938f, 0.08312211f, 0.11613195f, -0.02312852f, -0.21382739f, 
    0.33920285f, 0.29032758f, -0.22224966f, 0.09354743f, 0.02850768f, 0.15866700f, 0.14936011f, 0.15500699f, 
    -0.00350246f, -0.02837549f, 0.04305821f, 0.29339102f, 0.07531203f, -0.00876446f, 0.04585503f, -0.04200605f, 
    0.12711224f, 0.01959013f, -0.50187731f, 0.15478915f, -0.39765957f, -0.00056650f, 0.09579697f, 0.09583956f, 
    -0.21292022f, 0.17328864f, 0.01010809f, 0.21069507f, 0.08499528f, -0.19301198f, 0.04134235f, 0.19306317f, 
    -0.09412830f, -0.02186751f, 0.02472086f, 0.08720932f, -0.06958028f, 0.03378866f, 0.04049437f, -0.14640994f, 
    0.02352291f, -0.34247816f, 0.09734555f, 0.24443498f, 0.18363240f, -0.13437688f, -0.14642410f, -0.30349323f, 
    0.20732628f, 0.04061304f, 0.04945401f, -0.18763718f, -0.08202039f, 0.00655534f, 0.15128164f, 0.17817797f, 
    -0.08017936f, -0.23766105f, 0.04823235f, 0.12185340f, 0.09519121f, 0.10086676f, 0.33222008f, 0.09563377f, 
    -0.28872594f, -0.23314352f, 0.20266359f, 0.24641111f, 0.03197291f, 0.05905594f, 0.04149354f, 0.03228644f, 
    0.24937445f, 0.13568431f, -0.06094785f, -0.11911371f, -0.01752690f, 0.08471060f, 0.12911429f, 0.10024475f, 
    -0.12800597f, -0.25350294f, 0.17248794f, -0.04402019f, -0.07269967f, -0.06590337f, -0.31130475f, 0.12454547f, 
    -0.02436528f, 0.20658332f, 0.10176001f, -0.11703414f, -0.10223310f, 0.02860200f, 0.00810969f, 0.05846706f, 
    0.12182473f, 0.07682899f, -0.10163051f, 0.10858282f, -0.31130287f, 0.42261067f, -0.07961638f, 0.09709924f, 
    0.00579958f, 0.04278487f, -0.06962984f, 0.06528758f, -0.53872287f, 0.03150457f, -0.01568513f, 0.02304512f, 
    -0.06156997f, 0.19096456f, 0.27294412f, 0.02519493f, 0.07267662f, -0.07354345f, -0.06197302f, 0.02714699f, 
    0.14307275f, -0.08184390f, -0.17503059f, -0.07054328f, -0.19839214f, 0.22872666f, 0.13703077f, 0.46265641f, 
    0.11827265f, 0.05234886f, -0.25910708f, -0.24073903f, -0.08290165f, -0.10540917f, 0.01709248f, -0.43923324f, 
    -0.04193029f, 0.18674976f, 0.13550054f, 0.04515238f, 0.09324192f, -0.06046351f, 0.07701617f, -0.14549163f, 
    0.45590472f, -0.12356857f, -0.11323455f, -0.21998204f, 0.03180728f, 0.23661840f, 0.00102143f, -0.05825113f, 
    -0.14137465f, -0.35014227f, -0.10095955f, -0.10930374f, -0.25562248f, 0.02660501f, -0.03769253f, 0.11773045f, 
    0.04064792f, 0.30446091f, 0.04420564f, 0.21736605f, 0.11020023f, 0.00975399f, -0.12288468f, -0.10176246f, 
    -0.06854056f, 0.08153021f, -0.13570312f, 0.27854663f, -0.63039434f, 0.25436997f, 0.05518315f, -0.31118447f, 
    0.20778747f, -0.08636799f, 0.03359897f, -0.09821323f, -0.20858333f, -0.20925614f, -0.02352545f, 0.18489298f, 
    0.24856228f, -0.50628662f, 0.05917498f, 0.03901913f, -0.04095876f, 0.39079207f, 0.16804358f, 0.12666191f, 
    -0.01019500f, -0.01357202f, 0.03256088f, 0.09579402f, 0.06357095f, -0.22076952f, -0.36117035f, -0.03574610f, 
    -0.00763312f, -0.13597761f, 0.19557667f, -0.06136070f, -0.20713988f, -0.15755172f, 0.13311744f, -0.02721404f, 
    -0.01874586f, -0.11702171f, 0.15818098f, 0.03265496f, -0.19725007f, -0.01952589f, -0.17388034f, -0.34627077f, 
    0.08689281f, -0.10730198f, 0.18426742f, -0.02430452f, -0.00017355f, 0.20169578f, 0.10030860f, 0.06388193f, 
    0.02595652f, 0.13341500f, -0.37396845f, 0.24504481f, -0.17638506f, 0.06471315f, 0.14963354f, 0.09952118f, 
    -0.00241284f, 0.13548179f, -0.19636890f, -0.31862512f, -0.08721218f, 0.03190641f, 0.02372639f, 0.02637238f, 
    0.23807552f, -0.02950906f, 0.22522907f, -0.05802555f, 0.06122817f, 0.03313828f, 0.01426526f, 0.06176665f, 
    0.10734937f, 0.06150352f, 0.13734838f, 0.08400954f, 0.29819497f, -0.07355343f, -0.19605796f, 0.01921406f, 
    -0.11853867f, -0.01545459f, 0.17087446f, 0.12161223f, -0.14954439f, -0.00209418f, -0.07778548f, 0.09079704f, 
    -0.00010067f, -0.00528823f, 0.00606316f, 0.05552515f, 0.27993211f, 0.11017635f, 0.19910444f, -0.01049250f, 
    0.01498767f, 0.07252827f, -0.09534536f, -0.06192353f, 0.29093346f, 0.24836589f, -0.32830548f, 0.03429058f, 
    0.13344243f, -0.05239718f, -0.14918388f, 0.03750449f, 0.21272333f, 0.03193036f, 0.05989794f, 0.24368648f, 
    -0.25557020f, 0.03274054f, -0.05804150f, -0.16562879f, -0.01158855f, -0.43755072f, 0.02301154f, -0.10083255f, 
    0.06453127f, -0.54443586f, 0.07340841f, -0.08255298f, 0.04420810f, 0.06745171f, 0.16181439f, -0.02321970f, 
    0.22888739f, -0.23145054f, 0.65020269f, 0.00643459f, -0.43981639f, -0.04212270f, 0.23179284f, -0.00150459f, 
    -0.01886150f, -0.04820897f, -0.08193610f, 0.10184689f, 0.07351580f, -0.05510608f, 0.08087489f, 0.00568099f, 
    -0.04989307f, -0.03224626f, 0.15375242f, 0.20787886f, -0.03577090f, -0.03014512f, 0.04543676f, 0.07677782f, 
    0.04624273f, -0.11453511f, 0.17538483f, 0.14131796f, -0.21239164f, -0.34910628f, -0.20002180f, 0.05718423f, 
    -0.33408079f, 0.23100954f, 0.09606548f, -0.06642073f, 0.01816504f, 0.16417183f, 0.27344370f, -0.42085192f, 
    -0.14948528f, 0.13685539f, -0.10372841f, 0.08657642f, 0.02225441f, 0.07469300f, -0.18418095f, -0.00768094f, 
    -0.15677296f, -0.03683644f, 0.22615209f, -0.20695233f, 0.01918045f, -0.05424071f, 0.07957730f, -0.05479883f, 
    0.09957041f, 0.03339932f, 0.24518196f, 0.23538393f, 0.14123781f, 0.11280286f, 0.12009656f, 0.29692692f, 
    0.11562089f, -0.19354646f, 0.13281283f, -0.01936162f, -0.02926551f, -0.02886388f, 0.28048855f, 0.02014817f, 
    0.03279348f, -0.01488272f, 0.03755228f, 0.05661728f, -0.06408158f, 0.09820640f, 0.11788543f, 0.16419192f, 
    -0.05522363f, -0.00504872f, 0.07321910f, -0.11579354f, 0.11949477f, -0.02906416f, -0.00311049f, 0.02732297f, 
    -0.20896652f, 0.04454345f, 0.12326325f, 0.19686390f, 0.01901882f, 0.10412193f, 0.02329519f, 0.03485860f, 
    0.29851368f, 0.25046942f, 0.30934557f, 0.05807921f, -0.09647499f, -0.16671252f, -0.13137907f, 0.33204937f, 
    -0.17711645f, -0.26325616f, 0.15544723f, 0.19956382f, 0.10288750f, 0.01701620f, -0.14610796f, -0.32644978f, 
    -0.65943253f, -0.02572694f, -0.04029903f, -0.09848160f, 0.10912912f, 0.17889385f, -0.06765488f, 0.01853085f, 
    0.15715080f, -0.04943736f, 0.12103364f, 0.09394588f, -0.08676172f, 0.28904787f, 0.10421145f, 0.01450274f, 
    0.10933428f, -0.28756106f, 0.01069837f, 0.06452452f, 0.19609879f, 0.13176994f, 0.11040743f, 0.12516066f, 
    0.02438018f, -0.17987780f, 0.01404662f, -0.31121174f, 0.10346092f, -0.14386262f, 0.01299619f, -0.05566362f, 
    0.03562473f, 0.05494670f, 0.00178173f, 0.27428955f, 0.04552807f, 0.13124409f, 0.35933420f, 0.08708233f, 
    0.09220584f, 0.11167662f, 0.06356882f, -0.43430045f, -0.53488702f, 0.05148812f, 0.07981700f, 0.31527776f, 
    -0.26205859f, 0.24666809f, 0.35233432f, -0.08388284f, -0.33627754f, -0.28797126f, -0.52861577f, 0.08755346f, 
    0.00021004f, 0.10784391f, -0.21859059f, 0.21390422f, -0.09006447f, -0.19837926f, -0.32084709f, -0.14399420f, 
    -0.08742682f, -0.02179865f, -0.06003906f, -0.13792154f, 0.01754415f, -0.04730222f, 0.08654134f, 0.01864122f, 
    -0.06952191f, -0.26673678f, -0.14899582f, -0.28285998f, -0.05191231f, 0.09696352f, 0.08614461f, 0.30181339f, 
    0.16152048f, 0.06354114f, -0.08353342f, 0.24580106f, 0.04928266f, 0.19796181f, 0.29604065f, 0.17942750f, 
    -0.20352291f, -0.35843503f, -0.01186282f, 0.21941474f, 0.21777028f, 0.14857024f, 0.13697523f, 0.10450318f, 
    -0.03831451f, -0.11385196f, -0.28263786f, 0.01140970f, 0.00871385f, 0.09009524f, -0.02973195f, 0.03017492f, 
    0.10793420f, 0.15617201f, -0.29016846f, -0.08442555f, -0.16751949f, -0.13769282f, -0.07638662f, -0.05502494f, 
    -0.22982252f, -0.19321261f, 0.14805907f, -0.01708554f, -0.32422927f, -0.42764688f, 0.10524041f, 0.02542684f, 
    -0.04938859f, -0.00523184f, 0.22332297f, 0.16246428f, -0.25543430f, -0.15340896f, -0.21943794f, -0.13682158f, 
    0.10587581f, -0.07277277f, -0.11047280f, -0.19234832f, 0.10498589f, 0.01980216f, 0.15345573f, 0.06071514f, 
    0.15012467f, 0.19119029f, 0.05284765f, 0.10527275f, 0.02668807f, 0.24124309f, -0.06143986f, -0.04765987f, 
    -0.09248497f, 0.09646684f, -0.01256939f, -0.07265703f, -0.02609299f, 0.08555590f, 0.07524088f, 0.04122384f, 
    -0.14463174f, -0.16437945f, 0.04259055f, -0.08984293f, 0.01077883f, -0.00071974f, 0.05434335f, 0.06065147f, 
    -0.03227155f, 0.18101545f, -0.10307461f, -0.21405266f, 0.03774011f, 0.13944539f, 0.00139166f, 0.01156470f, 
    -0.00302756f, -0.09436126f, 0.07457286f, -0.06683724f, 0.06522525f, -0.10014158f, -0.06351461f, 0.17922418f, 
    0.04972016f, 0.22359750f, 0.20967947f, -0.53174824f, -0.12881593f, 0.00975025f, 0.03006179f, 0.03719070f, 
    -0.05020582f, -0.06834429f, -0.07908406f, 0.13865443f, 0.14448714f, 0.30879307f, -0.09024464f, -0.08605948f, 
    0.01534573f, -0.03954842f, 0.05429676f, 0.15513833f, 0.01720366f, 0.05848778f, 0.08573364f, -0.05800798f, 
    0.05479518f, 0.03755059f, 0.21111578f, 0.12471937f, 0.11220416f, 0.08013683f, -0.02077764f, -0.51385194f, 
    -0.09089386f, -0.14788792f, -0.13227810f, -0.12129668f, -0.04253981f, -0.16820303f, 0.01369957f, -0.07037008f, 
    -0.41589031f, 0.30026880f, -0.00164657f, 0.11220501f, -0.02576295f, 0.20547158f, 0.14033626f, 0.12724912f, 
    0.20847586f, -0.07942636f, 0.00542262f, 0.04432476f, 0.08252804f, 0.19946194f, -0.01972377f, -0.02161044f, 
    -0.38440758f, -0.17518212f, 0.29079276f, 0.03688191f, -0.19907042f, -0.16055234f, 0.21007940f, 0.09137649f, 
    -0.01666170f, -0.02397516f, 0.00302850f, 0.06494748f, 0.10550984f, -0.02874291f, -0.04606575f, -0.06957421f, 
    -0.05128804f, 0.08793458f, 0.93335068f, -0.16473435f, -0.23852775f, -0.07174611f, -0.09337495f, -0.14143041f, 
    0.10695089f, 0.12508635f, 0.11702974f, -0.19641957f, -0.00585569f, -0.07502750f, -0.16032875f, -0.07723458f, 
    -0.11860156f, 0.28007713f, -0.16672780f, 0.28950816f, -0.16267072f, 0.26830819f, -0.00003905f, -0.02222143f, 
    -0.05885649f, 0.17074758f, 0.00873161f, 0.17124231f, 0.19195235f, -0.09451513f, -0.65530676f, 0.11333442f, 
    0.00635489f, 0.05311343f, -0.29800826f, -0.08062174f, -0.14525574f, -0.29031467f, -0.29778540f, 0.23333672f, 
    -0.24011368f, -0.08473019f, 0.13599326f, -0.25206873f, 0.05446072f, -0.01081583f, -0.03040590f, -0.04705353f, 
    0.11610131f, -0.50625741f, -0.02947605f, -0.05374608f, -0.10271289f, 0.18124399f, 0.04329768f, 0.05146178f, 
    -0.05381682f, 0.09995452f, -0.33262587f, -0.23628792f, -0.15105981f, -0.19364585f, 0.10442191f, 0.09694047f, 
    -0.07204071f, 0.37868008f, 0.38436872f, 0.27701142f, 0.02512225f, -0.03917424f, 0.27078250f, 0.12289854f, 
    0.02204834f, 0.13963816f, -0.01811645f, -0.02740584f, 0.33814615f, 0.06285127f, 0.18507315f, 0.20918064f, 
    0.07897094f, 0.19383004f, 0.28185907f, -0.79899240f, 0.62758040f, -0.93126667f, 0.07664385f, -0.28820664f, 
    0.13038169f, 0.12577422f, 0.19853400f, 0.19043885f, -0.88849717f, -0.94038337f, -0.79813093f, -0.08111976f, 
    -0.37482962f, -0.14716874f, 0.14480847f, -0.08661647f, -0.00922501f, -0.28736648f, -0.01184428f, -0.29981622f, 
    -0.37004939f, -0.22082317f, 0.11217386f, -0.00793859f, -0.11332856f, 0.03020828f, 0.24440937f, 0.40220234f, 
    0.53055149f, -0.00516129f, 0.16508554f, 0.07166247f, 0.16851416f, 0.09532359f, -0.14147739f, -0.03510874f, 
    -0.09235492f, -0.32466367f, -0.17435969f, 0.23544008f, -0.08820304f, -0.01951567f, 0.08666319f, -0.11379583f, 
    -0.01214536f, 0.14169362f, -0.22188036f, 0.01269867f, 0.01447351f, 0.20224096f, 0.09801783f, 0.08026280f, 
    0.34133452f, 0.50956923f, 0.00051314f, 0.46715021f, -0.00163224f, 0.14741282f, 0.10177386f, 0.14775394f, 
    0.01028114f, -0.16485651f, -0.99359006f, -1.00055361f, -0.48888507f, 0.15008244f, 0.06913868f, -0.48705167f, 
    0.04285528f, -0.21577778f, 0.13163729f, -0.41794893f, -0.00362388f, 0.11449097f, 0.10523636f, 0.06371561f, 
    -0.11723407f, 0.08400950f, 0.06648171f, -0.10447907f, -0.04779303f, -0.34416911f, 0.22534692f, 0.16172884f, 
    -0.33168122f, -0.25250077f, -0.21321258f, -0.02964034f, -0.02566479f, -0.49600178f, -0.22234601f, -0.25293532f, 
    -0.05964365f, -0.05934218f, -0.13920680f, 0.19895917f, -0.07327072f, 0.47025588f, -0.47492468f, -0.65645647f, 
    -0.09086800f, -0.42109668f, -0.23712088f, -0.04458080f, 0.05926728f, -0.15879224f, -0.08260894f, 0.03442615f, 
    0.06241702f, 0.14129417f, -0.13598306f, 0.12886347f, 0.08362014f, 0.17650689f, -0.02560361f, -0.05460028f, 
    -0.04844042f, 0.23496948f, 0.07144743f, 0.08748086f, 0.04829369f, -0.10486776f, -0.19922194f, -0.27046382f, 
    -0.07104121f, -0.27743539f, -0.65112501f, 0.02210024f, 0.12724884f, -0.10573498f, -0.08159665f, 0.05746614f, 
    0.05137139f, 0.23833324f, -0.40802887f, 0.12947038f, -0.08855111f, -0.29388151f, -0.32944971f, -0.41715690f, 
    -0.31085986f, -0.08380224f, 0.25195631f, 0.24627326f, 0.20645832f, 0.34684610f, -0.01861067f, 0.09873331f, 
    0.13620746f, 0.23402011f, 0.01376129f, -0.01977546f, 0.03724989f, 0.02651389f, 0.13541211f, -0.06143256f, 
    0.09611739f, 0.25146282f, -0.03343420f, -0.01742041f, 0.03309248f, 0.11577503f, 0.54389334f, 0.58597547f, 
    0.02035653f, 0.12539421f, 0.04575353f, 0.06207331f, -0.07161911f, -0.01941323f, 0.34260428f, -0.06719273f, 
    -0.53423136f, -0.13553271f, -0.05154375f, 0.15699601f, 0.07346897f, 0.11571532f, 0.34629872f, 0.38243416f, 
    0.19075236f, 0.14091487f, 0.08472113f, 0.03504935f, -0.00960422f, -0.03365661f, -0.17341802f, -0.07525627f, 
    0.06347673f, -0.06179385f, 0.17678729f, 0.05350310f, 0.06952906f, 0.10376854f, 0.11825145f, 0.06442358f, 
    0.15412609f, -0.06665210f, -0.09378400f, 0.11005068f, -0.16006041f, -0.02669798f, -0.02984884f, 0.04367322f, 
    -0.01073916f, -0.09979468f, 0.17878520f, 0.11372209f, -0.01971288f, -0.19354466f, -0.14053884f, -0.03425868f, 
    -0.03124087f, -0.13971944f, -0.12910132f, -0.03937099f, 0.09830339f, 0.01863664f, -0.09147554f, -0.06397139f, 
    0.03732684f, -0.45838109f, -0.16322158f, 0.30522126f, 0.04140845f, -0.03267777f, 0.57442439f, 0.06081870f, 
    0.17230742f, 0.09987533f, 0.14056559f, 0.19852464f, 0.12786876f, -0.00045869f, 0.16445106f, 0.23175910f, 
    0.15709315f, -0.01063688f, 0.07988110f, -0.03097583f, 0.14888251f, -0.22030769f, -0.05355052f, 0.42179650f, 
    -0.16721714f, 0.03156245f, 0.10962231f, 0.04650630f, 0.11121342f, 0.13780314f, -0.32928091f, -0.05929283f, 
    0.05298229f, 0.02892206f, 0.15998550f, 0.10351610f, -0.03782932f, -0.12959771f, -0.01911392f, -0.08170337f, 
    0.19955035f, -0.24207553f, 0.15102701f, 0.02351356f, 0.04115356f, 0.01781792f, 0.26308519f, 0.05266039f, 
    0.30096278f, -0.18100788f, -0.12391577f, 0.02844745f, 0.02509701f, 0.05257356f, 0.03765523f, 0.01039435f, 
    0.02906297f, 0.09389263f, 0.10457613f, -0.13600789f, -0.22828628f, -0.10739512f, 0.15866761f, -0.04886466f, 
    0.08494435f, 0.02147829f, -0.09771342f, -0.49333930f, 0.10007681f, 0.38361591f, -0.11865230f, 0.09816900f, 
    0.00555749f, -0.00365376f, -0.03699685f, -0.19689967f, -0.30507049f, -0.23446967f, 0.50101888f, 0.23421206f, 
    -0.08413971f, 0.06455633f, 0.12059679f, -0.21103388f, -0.11021779f, 0.03497740f, -0.02991899f, 0.14120740f, 
    -0.09835169f, -0.03294754f, -0.19086595f, 0.22007225f, 0.02065381f, 0.08762702f, -0.02549880f, -0.10900360f, 
    -0.15894374f, -0.10558571f, -0.10822511f, -0.23816009f, -0.01424723f, -0.11008564f, 0.04050564f, 0.08226365f, 
    0.14018743f, -0.13267499f, 0.06983784f, 0.24563964f, 0.11182167f, 0.07575870f, 0.09344936f, 0.07052372f, 
    -0.02473432f, 0.03238999f, 0.34731901f, 0.19423203f, 0.08064446f, 0.06646017f, -0.01862626f, -0.14118238f, 
    0.00227260f, 0.08538657f, -0.17682816f, -0.14287622f, 0.06299069f, 0.13604566f, 0.22713594f, -0.08944820f, 
    -0.15887463f, -0.16946654f, 0.05312103f, 0.11722078f, 0.00341881f, 0.10680642f, 0.10474890f, -0.26415688f, 
    -0.20048183f, -0.42413470f, 0.07325761f, -0.20393237f, 0.01373324f, -0.23949799f, 0.01992184f, -0.00745705f, 
    -0.01230735f, 0.03961077f, 0.26721591f, -0.30454066f, 0.08926753f, -0.03106569f, 0.00697732f, -0.07325877f, 
    0.09728979f, -0.08740992f, -0.16900681f, 0.00451929f, -0.08247017f, 0.15362874f, 0.05803216f, 0.05079388f, 
    -0.11989969f, -0.03418991f, -0.32915035f, -0.29750690f, 0.02622088f, -0.02856085f, -0.04328691f, 0.07866668f, 
    -0.05667452f, -0.07262664f, -0.00578688f, -0.07936245f, 0.00681929f, -0.00724711f, -0.06538307f, -0.16763900f, 
    0.24244833f, -0.03890673f, -0.03397717f, 0.00562429f, -0.05974102f, 0.03021622f, 0.17542107f, 0.06007736f, 
    -0.12540509f, 0.10820907f, 0.19888978f, 0.07463006f, 0.14820358f, 0.06985147f, 0.06646009f, 0.03607220f, 
    -0.08373397f, 0.21256714f, 0.11508986f, 0.13764203f, 0.05960708f, 0.06200887f, -0.09909537f, -0.05289153f, 
    -0.13174461f, 0.05293890f, 0.01313002f, -0.16725250f, 0.21904565f, -0.16166613f, -0.02888271f, 0.01303359f, 
    -0.04345832f, 0.06683796f, 0.29826796f, 0.03602573f, -0.19141977f, -0.49853092f, -0.11100534f, -0.15987158f, 
    -0.22840340f, 0.01968977f, -0.07498652f, 0.08223327f, 0.12128197f, 0.20744054f, 0.00702759f, 0.04302691f, 
    0.18003194f, 0.07445396f, 0.22827250f, 0.15787326f, -0.08338157f, -0.16908592f, 0.28867885f, 0.16744746f, 
    -0.02887512f, -0.14664517f, -0.05516964f, -0.09345337f, -0.08723713f, -0.00102226f, -0.17187278f, 0.02013817f, 
    0.09668918f, -0.35620397f, 0.23206459f, 0.18871137f, -0.00580867f, 0.12756643f, 0.01068249f, 0.26474226f, 
    0.00425898f, -0.24505566f, -0.17005363f, 0.02378619f, 0.06862013f, 0.02029165f, -0.04920812f, -0.01613233f, 
    0.08821522f, 0.03231695f, -0.47177806f, 0.03846880f, -0.11338989f, -0.08286482f, 0.06928027f, -0.00182138f, 
    -0.00447290f, 0.26614511f, 0.01595830f, 0.30522394f, 0.07317959f, -0.05401031f, 0.01728651f, 0.09264718f, 
    0.13914816f, -0.22404943f, -0.08267552f, 0.14805864f, -0.35962707f, 0.08286542f, -0.18548889f, -0.05668590f, 
    -0.19022888f, -0.01630608f, -0.10983994f, -0.01097321f, 0.04315567f, -0.17094097f, 0.03817150f, -0.01202801f, 
    -0.18032520f, 0.10575810f, 0.00191683f, 0.26897955f, 0.06517506f, -0.09677619f, 0.17184645f, -0.00285603f, 
    -0.00892980f, 0.07361861f, -0.00093130f, 0.05404335f, -0.07354001f, 0.06164804f, 0.15699312f, 0.14727546f, 
    0.19860375f, 0.02530250f, -0.20069952f, 0.11643251f, -0.49312815f, 0.01645365f, 0.35011223f, 0.37810764f, 
    0.17466658f, 0.15354966f, 0.13621971f, -0.22308201f, 0.01263895f, -0.07996023f, -0.04225002f, 0.18428271f, 
    -0.03719365f, -0.03480075f, -0.10378189f, -0.18986617f, 0.02323555f, 0.15124394f, 0.11196842f, 0.12997913f, 
    -0.02870456f, -0.06004025f, -0.10031189f, 0.21768968f, 0.13969676f, -0.09192023f, -0.02030356f, -0.04493340f, 
    -0.06633510f, 0.14533861f, -0.17497337f, 0.24552102f, -0.20232949f, 0.03175857f, 0.03124587f, -0.05134995f, 
    -0.14888841f, 0.02880681f, 0.15204819f, -0.07429159f, 0.13006888f, 0.08288539f, 0.01089338f, 0.00429950f, 
    -0.12751152f, -0.10764865f, -0.10876621f, 0.41382262f, 0.24806629f, -0.23374285f, 0.04774554f, 0.08556274f, 
    0.11839222f, -0.00209113f, -0.07354285f, -0.20491076f, -0.02199301f, 0.12498699f, -0.31255326f, -0.32472000f, 
    -0.31393862f, 0.14592025f, -0.09433253f, 0.01924060f, -0.28027150f, 0.03001128f, -0.27340311f, -0.17892754f, 
    0.07172275f, -0.01139026f, -0.10239640f, 0.02891763f, -0.25973397f, 0.01872041f, 0.09814234f, -0.48261476f, 
    -0.05628052f, 0.07692947f, 0.01855184f, 0.07800940f, -0.06613014f, 0.12367488f, 0.31337118f, -0.09139206f, 
    0.00426918f, -0.12506782f, -0.03175807f, -0.10496178f, -0.28661519f, 0.10752621f, -0.05396107f, -0.44718698f, 
    0.06236499f, 0.04112604f, 0.13277121f, -0.22288279f, 0.14472702f, 0.26565269f, 0.07801331f, -0.00238798f, 
    0.07248079f, -0.15985863f, 0.32285246f, 0.09096008f, 0.02124768f, -0.00188742f, -0.13262279f, 0.05375833f, 
    0.19021270f, 0.13407996f, 0.42838264f, 0.18768464f, -0.57478440f, -0.08202448f, -0.10071601f, 0.18466844f, 
    0.08823248f, -0.30206028f, 0.10008641f, 0.17130238f, 0.02358913f, 0.33464751f, -0.14129639f, 0.10723572f, 
    0.01338577f, 0.09490683f, 0.06152250f, -0.00467180f, 0.06207215f, 0.17315455f, -0.25023991f, 0.32252324f, 
    -0.03499997f, -0.03872135f, -0.01917995f, 0.22666720f, 0.17378226f, 0.29357675f, -0.10901526f, -0.28713924f, 
    -0.00468144f, -0.06344880f, 0.01055984f, -0.01778910f, -0.20279184f, 0.24808165f, 0.07591075f, -0.17719685f, 
    0.15318798f, 0.06385691f, 0.05556640f, 0.17065366f, -0.16589420f, -0.23045142f, -0.28743997f, 0.21592210f, 
    0.02746531f, 0.27761972f, 0.12019402f, 0.22188172f, 0.12664354f, 0.04213564f, -0.08033213f, 0.06068826f, 
    0.29221037f, 0.20358945f, 0.35894421f, -0.02200044f, -0.13622592f, -0.06005805f, 0.03794258f, 0.07079837f, 
    -0.35820416f, -0.07322261f, 0.12679343f, -0.43442419f, -0.00576542f, -0.08222707f, 0.08721397f, -0.07348588f, 
    -0.00431196f, 0.22118162f, 0.06956469f, -0.05329269f, 0.14217821f, 0.05539051f, -0.07417820f, 0.10953669f, 
    0.15774684f, -0.21402656f, -0.09400599f, 0.05035315f, -0.17991650f, 0.08179519f, 0.06674396f, 0.02394971f, 
    0.16567376f, -0.16315904f, -0.00466961f, 0.23284066f, 0.04592564f, -0.23868227f, -0.05656450f, -0.05690990f, 
    0.02677866f, -0.03238750f, -0.06480941f, -0.24872521f, -0.67149335f, 0.08726829f, -0.30624279f, 0.08144994f, 
    -0.13553210f, 0.07008222f, 0.14230011f, 0.06858237f, -0.14078771f, 0.10559119f, 0.32075623f, 0.22734693f, 
    0.22342396f, -0.25520390f, -0.06768262f, -0.07438128f, -0.11890896f, -0.12975997f, -0.06625964f, -0.26376641f, 
    0.43024087f, 0.17341439f, 0.08998828f, 0.07877862f, -0.02055181f, 0.11680985f, -0.09967220f, 0.02501583f, 
    0.18374075f, 0.14260888f, -0.08621574f, 0.02990017f, -0.15193743f, -0.11824723f, 0.04020244f, 0.11751162f, 
    0.14023428f, -0.05781999f, -0.16775008f, 0.21220520f, -0.10651799f, 0.13118441f, -0.04464756f, -0.03649509f, 
    0.04833332f, 0.28927857f, 0.03562639f, 0.02392432f, -0.00876052f, -0.25440690f, 0.17319204f, 0.14903645f, 
    0.20422843f, 0.03487424f, 0.15241379f, -0.08593889f, -0.02006037f, 0.07123833f, -0.02041925f, -0.27101579f, 
    -0.19021823f, 0.18816762f, -0.04655483f, 0.27071837f, 0.23422363f, 0.16917448f, -0.05674501f, -0.01794721f, 
    0.10177045f, -0.01134971f, 0.15353474f, 0.03224225f, 0.13197708f, -0.14340019f, -0.80018878f, -0.43178239f, 
    -0.18587179f, 0.08847371f, -0.07452210f, 0.14848459f, -0.01978668f, 0.08838511f, -0.26744607f, -0.52860528f, 
    0.43797401f, 0.00047486f, -0.08913151f, -0.10133550f, 0.01161537f, 0.00536529f, 0.13205802f, 0.17612657f, 
    -0.02796659f, -0.27744114f, 0.05546959f, 0.11881035f, 0.02096253f, -0.03584063f, 0.04555988f, 0.04148949f, 
    0.04502096f, 0.17761259f, 0.15856466f, -0.06006983f, 0.01943716f, -0.13662176f, 0.15356274f, -0.09544975f, 
    0.09528763f, -0.06916602f, 0.15357490f, 0.34174064f, -0.00775116f, 0.03475925f, -0.15188593f, 0.03221884f, 
    0.11495139f, -0.14145736f, 0.00625644f, 0.08933396f, 0.36000666f, 0.05134899f, 0.16289365f, 0.01414923f, 
    -0.00511290f, 0.03407066f, 0.08999694f, -0.20478782f, -0.04857876f, -0.01000456f, -0.02644718f, -0.32310086f, 
    -0.26802820f, 0.10297260f, -0.02963172f, 0.16359799f, 0.33588189f, -0.43497625f, 0.71393508f, -0.06719710f, 
    0.00789217f, 0.06362671f, 0.08330108f, -0.22050524f, 0.35158587f, 0.03950208f, 0.01141870f, 0.05937967f, 
    -0.13843763f, -0.14810361f, -0.23609498f, -0.16370095f, -0.06762791f, 0.15674712f, -0.36358774f, -0.08380175f, 
    0.13079581f, 0.09318867f, -0.03789713f, -0.07197559f, -0.15816906f, -0.05388048f, 0.04244651f, 0.09400257f, 
    -0.26396686f, -0.36772272f, 0.17331462f, -0.00101581f, 0.10910615f, 0.01128669f, 0.10880121f, 0.05028769f, 
    -0.09234763f, 0.20983347f, 0.41197315f, 0.10802569f, -0.03686741f, -0.06479001f, 0.30548304f, 0.12723623f, 
    -0.02951699f, -0.03190594f, 0.19338983f, 0.15018168f, 0.05414956f, -0.02734214f, 0.05196771f, 0.14814790f, 
    0.15596770f, 0.04136116f, 0.13038093f, -0.40290397f, -0.09268522f, -0.18324320f, -0.17574154f, 0.02544527f, 
    -0.28010327f, -0.05529391f, -0.01999221f, -0.12113398f, -0.14979845f, 0.16717105f, -0.15205877f, 0.01529224f, 
    0.21486242f, 0.09774520f, 0.07047901f, 0.05396409f, 0.02400806f, -0.05011609f, 0.03955682f, -0.22427794f, 
    -0.10775595f, -0.11172646f, -0.17633334f, 0.03420054f, -0.04558956f, 0.07359206f, 0.04249725f, 0.08222543f, 
    0.07828441f, 0.01376341f, -0.28440705f, 0.20985630f, 0.05081666f, 0.13292372f, 0.06862069f, -0.06694280f, 
    -0.06734128f, -0.25628561f, 0.02642919f, 0.02585303f, 0.11871161f, 0.18745837f, 0.18084918f, -0.36522374f, 
    -0.23650515f, 0.10242491f, -0.11739457f, -0.01377402f, 0.01758488f, 0.07734694f, 0.13953918f, -0.05454906f, 
    -0.46311766f, -0.66107643f, 0.07011527f, -0.10841992f, 0.10050333f, -0.04334848f, -0.00630528f, 0.03982455f, 
    0.08614755f, 0.31549957f, -0.01487433f, -0.32711548f, -0.13399462f, -0.17143551f, -0.15755843f, -0.05571665f, 
    0.06598154f, 0.10159732f, -0.27017748f, -0.15374440f, 0.03119856f, -0.03237873f, 0.00629565f, -0.18758234f, 
    0.05109252f, -0.03876192f, 0.33767548f, -0.06228768f, 0.10489310f, 0.43422148f, -0.06468529f, 0.13668571f, 
    -0.12823473f, -0.07316105f, 0.02867017f, 0.15781698f, 0.05578000f, -0.12914146f, -0.04616222f, 0.08321773f, 
    -0.02626681f, 0.18844113f, 0.11686430f, 0.05320629f, 0.08607455f, -0.27457044f, -0.13996400f, 0.17760429f, 
    -0.07079868f, 0.01251380f, -0.10134342f, -0.13347761f, 0.13537148f, -0.03153376f, -0.27586222f, -0.02560763f, 
    0.27609837f, -0.20150168f, -0.23259473f, -0.15036280f, 0.14423627f, 0.07115942f, 0.12726836f, -0.05473121f, 
    -0.31701368f, -0.01307595f, 0.10855979f, 0.16637160f, -0.00075257f, 0.12723200f, 0.08792339f, -0.03593560f, 
    0.22091056f, 0.23032814f, -0.16927379f, -0.02038962f, 0.09053803f, 0.17427769f, -0.02744414f, 0.21083613f, 
    0.10353061f, -0.11321009f, -0.21337418f, -0.03670185f, -0.01221437f, 0.18581063f, -0.05960277f, -0.00432889f, 
    -0.02369855f, 0.15181383f, -0.03206614f, -0.13328326f, 0.04183480f, 0.08415845f, -0.04045287f, 0.16158861f, 
    -0.04784774f, 0.09995166f, 0.00550544f, -0.25868732f, -0.28405076f, 0.34930861f, -0.07867786f, -0.08073878f, 
    0.00494580f, 0.07953478f, 0.05559555f, 0.17053026f, -0.11751667f, 0.28446960f, 0.11088379f, 0.15849988f, 
    0.01437792f, -0.02545759f, 0.07280682f, 0.00629265f, 0.12706584f, -0.00994134f, -0.22982287f, -0.03738488f, 
    0.17686629f, -0.00242763f, -0.10296106f, 0.15435886f, -0.26157245f, 0.14874330f, -0.09230237f, -0.04818138f, 
    0.26133099f, -0.00083598f, 0.00018616f, -0.36054355f, -0.29006416f, -0.04104733f, 0.05631931f, -0.01621071f, 
    0.12717621f, -0.04417344f, 0.03761039f, 0.06143795f, 0.03686442f, 0.17711399f, -0.09957098f, 0.09747253f, 
    0.19720066f, 0.40922827f, 0.29487842f, -0.00590665f, -0.01834811f, 0.09274244f, -0.02111468f, -0.04200318f, 
    -0.09576809f, -0.22187814f, 0.16822942f, 0.15056933f, -0.21339786f, 0.32800704f, -0.34892172f, 0.02879131f, 
    0.03304580f, 0.33329877f, -0.05233827f, 0.15160787f, 0.22570969f, 0.05343250f, -0.05882121f, -0.15376747f, 
    -0.07975203f, 0.06377137f, -0.17964675f, -0.05965426f, -0.03288582f, 0.08513578f, 0.30584034f, -0.06763907f, 
    0.15500882f, -0.22362329f, 0.08023494f, -0.12227251f, 0.36299509f, 0.20272291f, 0.49709743f, -0.35134932f, 
    -0.08901148f, 0.11290888f, 0.02247900f, -0.06072737f, 0.13942884f, -0.13732061f, 0.19111592f, -0.00432024f, 
    0.03560158f, 0.01173412f, 0.04554358f, 0.09039559f, 0.03000373f, -0.08055522f, -0.41653746f, -0.18278530f, 
    0.03289246f, -0.35099417f, 0.02199604f, 0.01407279f, -0.21072550f, 0.03846342f, 0.34343994f, 0.11432913f, 
    0.09147305f, 0.18418482f, -0.01317913f, 0.08057568f, -0.25750849f, 0.28362888f, -0.10357452f, -0.22291021f, 
    0.10538565f, 0.24408773f, 0.58645308f, 0.09343653f, -0.02875971f, -0.01612777f, -0.04634921f, 0.29926670f, 
    0.13267852f, -0.21883887f, -0.11102986f, 0.39517853f, 0.09734693f, 0.06818560f, 0.25007966f, -0.00316773f, 
    0.23248640f, 0.17205748f, 0.22169209f, -0.50234836f, -0.42619890f, -0.08760779f, -0.05723222f, -0.00422076f, 
    0.11546456f, 0.32168508f, -0.04849008f, 0.00259539f, -0.15669881f, 0.21411939f, -0.00576795f, 0.07891881f, 
    -0.11246488f, -0.06885315f, -0.01336638f, 0.17983776f, -0.13436119f, -0.19501248f, -0.20273051f, 0.05512225f, 
    -0.12207969f, 0.09566852f, -0.00255563f, 0.08250460f, -0.22922374f, -0.06879663f, -0.05937818f, 0.07885309f, 
    0.01911790f, 0.09652541f, 0.01270025f, 0.12859365f, 0.30461583f, 0.18314923f, 0.08702242f, 0.04192160f, 
    0.06407485f, 0.04290392f, -0.01276639f, 0.00845992f, 0.27425346f, 0.22531052f, -0.01869530f, -0.29023740f, 
    -0.18931957f, 0.07454853f, 0.12657353f, 0.11411814f, -0.09847394f, 0.01306843f, -0.00220049f, 0.09340692f, 
    -0.08554310f, -0.13511086f, -0.06689740f, -0.03155293f, 0.08858675f, -0.56390822f, 0.01382578f, -0.19280466f, 
    -0.09329915f, -0.04212796f, 0.09443633f, -0.17672133f, 0.10455788f, 0.14120071f, 0.12956727f, 0.24226187f, 
    0.16479859f, -0.09743727f, 0.12314712f, 0.34611169f, 0.25484642f, -0.39437941f, -0.09850658f, -0.04393226f, 
    -0.11128685f, 0.00719843f, -0.11300474f, 0.14683394f, -0.06642697f, 0.10851788f, 0.08288323f, 0.09761434f, 
    0.22022627f, -0.07616697f, -0.00356290f, 0.26826429f, 0.12496697f, 0.06728069f, 0.12173448f, 0.09417826f, 
    0.09540942f, -0.08763292f, 0.38584158f, 0.20697944f, -0.09989753f, -0.30279309f, -0.22767669f, -0.05169126f, 
    -0.13422117f, 0.14884029f, -0.15298460f, -0.02283478f, 0.03072981f, 0.36962423f, -0.03511020f, -0.10948850f, 
    0.14456075f, -0.11674546f, -0.05116349f, 0.00310289f, 0.17305100f, -0.05018384f, -0.29183042f, 0.01482827f, 
    -0.08545157f, 0.53165245f, -0.01824771f, 0.01141134f, 0.01255486f, -0.10438824f, 0.00159231f, -0.05199613f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.02664476f, 0.12890375f, -0.04585665f, 0.57168990f, -0.03480294f, 0.08188166f, 0.33137301f, 0.00876386f, 
    -0.05206824f, -0.07868225f, 0.00702988f, 0.23632620f, 0.31915691f, 0.16814005f, 0.04905815f, 0.02339807f, 
    -0.21376406f, 0.03774866f, 0.28434086f, 0.00837911f, 0.12706603f, 0.05936556f, 0.00565004f, -0.15843488f, 
    -0.04591677f, 0.21915787f, 0.28685513f, 0.18992637f, 0.08977720f, -0.02631975f, 0.09582453f, 0.24188951f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.13874182f, 0.10138150f, 0.05554727f, -0.34638149f, -0.18721116f, 0.33996654f, -0.17574541f, 0.19682582f, 
    0.12066980f, 0.37424085f, 0.03162559f, -0.32083848f, -0.55455357f, -0.63199782f, 0.11426765f, 0.14784184f, 
    0.18903889f, 0.16409048f, -0.22475560f, 0.01157606f, 0.14510243f, -0.27837172f, 0.13445309f, 0.34582451f, 
    0.29621357f, -0.00244242f, -0.31482518f, 0.35842562f, -0.05380968f, 0.11780009f, -0.69478571f, -0.23896894f, 
    -0.10632850f, 0.15590174f, -0.21241960f, 0.76032764f, -0.23256578f, 0.23814079f, 0.11185247f, 0.23687914f, 
    -0.13708350f, 0.41653940f, 0.07320355f, 0.10486753f, -0.21350040f, -0.21129556f, 0.04518189f, 0.02981742f, 
    -0.41382545f, -0.06830347f, 0.30092555f, -0.14516646f, -0.19818328f, 0.06266013f, 0.07059337f, 0.13599932f, 
    0.04338466f, -0.03065420f, 0.09021766f, 0.64092815f, 0.33026826f, -0.51677829f, -0.30419853f, -0.31009683f, 
    -0.17221256f, -0.22556698f, -0.22420295f, -0.18588239f, -0.04365239f, -0.42531028f, -0.00809067f, 0.05396382f, 
    -0.18141158f, -0.62078393f, -0.07477581f, -0.62938261f, 0.22510575f, -0.33100060f, 0.13524729f, -0.06927858f, 
    0.22821867f, -0.09159289f, -0.10778170f, 0.01397184f, 0.47855109f, -0.19700241f, 0.06698231f, -0.01166588f, 
    -0.00220101f, -0.27968919f, -0.08404957f, 0.77675855f, -0.09453911f, -0.02966749f, 0.42770255f, 0.09874447f, 
    0.15477571f, 0.04050568f, 0.42468217f, -0.95190454f, 0.32089943f, -0.48449218f, -0.62385368f, -0.45167354f, 
    0.08810453f, -0.08937263f, -0.06402050f, -0.42416534f, -0.60679436f, 0.10014964f, 0.12193201f, 0.08531547f, 
    0.60541570f, -0.12805380f, -0.56251311f, -0.08769045f, -0.66883171f, -0.10026380f, -0.03550693f, 0.03472716f, 
    0.17652415f, -0.76860952f, 0.30768427f, 0.04297425f, -0.72779226f, 0.28100911f, 0.17310579f, 0.31733137f, 
    -0.01719475f, 0.16922617f, 0.39634904f, -0.23034759f, 0.08897477f, 0.14817016f, -0.29416353f, 0.29232192f, 
    0.02532877f, 0.20820478f, -0.00412772f, -0.22503939f, 0.67443132f, -0.04938697f, -0.14569837f, 0.12016921f, 
    -0.04845011f, -0.00697680f, -0.45446849f, -0.09333728f, -0.08484101f, -0.22220598f, -0.07216431f, -0.27456829f, 
    -0.04845442f, 0.46621808f, -0.53000581f, -0.25335872f, -0.14528005f, 0.26307172f, -0.26806462f, 0.14269246f, 
    -0.03440731f, 0.23197474f, -0.20148608f, -0.10461610f, -0.13115841f, 0.46316999f, 0.28621876f, 0.04311979f, 
    -0.03251850f, 0.12940168f, -0.09727798f, -0.15750127f, 0.01305519f, 0.54715157f, -0.16865587f, -0.05082102f, 
    -0.30834398f, 0.04822336f, -0.50710028f, -0.00417681f, -0.15353832f, 0.08389213f, -0.10961718f, -0.38256902f, 
    0.32941657f, -0.00148283f, -0.13213409f, 0.02273701f, -0.07973013f, 0.06135474f, 0.00955741f, 0.04655456f, 
    -0.01222461f, -0.14385967f, -0.69475746f, -0.35267541f, 0.38157836f, -0.18285023f, 0.01266242f, 0.15967751f, 
    0.11753212f, -0.87498534f, 0.01949652f, -0.37226909f, -0.49432653f, -0.55694354f, -0.07451235f, 0.07737674f, 
    0.07994951f, -0.06543297f, 0.95607054f, -0.03266653f, 0.46927419f, -0.24965325f, -0.09797101f, -0.33842322f, 
    -0.24015412f, 0.33076367f, 0.31733388f, -0.95532006f, -0.11687231f, -0.48647040f, 0.21068804f, 0.03234692f, 
    0.08709542f, -0.14166549f, 0.18550022f, -0.51293367f, -0.01118873f, -0.21639115f, -0.36274141f, -0.10699987f, 
    -0.09131064f, -0.04078851f, -0.07533140f, 0.50064057f, -0.46677643f, 0.42550370f, 0.11771238f, -0.08538035f, 
    0.13947783f, -0.03465682f, -0.24488647f, -0.18691894f, 0.07544060f, 0.40433756f, -0.04547805f, -0.16636826f, 
    -0.05086133f, -0.19749340f, -0.31635404f, -0.52996749f, 0.20226485f, 0.42668557f, 0.09836822f, -0.30212787f, 
    0.08458984f, 0.22191273f, -0.37239596f, 0.07125346f, -0.45109013f, -0.78828609f, 0.39596421f, -0.59070975f, 
    -0.04858139f, 0.02669785f, 0.12503523f, 0.46858609f, -0.14064924f, 0.45858547f, -0.05346910f, 0.06789540f, 
    -0.10412064f, -0.06674054f, 0.12288910f, 0.13587825f, -0.28545925f, -0.24513230f, 0.10404827f, 0.21566465f, 
    0.36516824f, -0.32831016f, 0.05376020f, -0.40862149f, 0.11897248f, -0.41201109f, 0.20369694f, 0.09990565f, 
    -0.12480617f, 0.33622757f, 0.06318453f, -0.07439286f, 0.43766022f, -0.62597197f, -0.03731677f, -0.06842531f, 
    0.08810614f, -0.26373917f, 0.05989109f, -0.35483697f, 0.76699108f, -0.04649144f, 0.15432201f, 0.10968971f, 
    -0.09773677f, -0.07800197f, 0.40304983f, 0.03856837f, -0.13021830f, -0.23426041f, 0.05232006f, -0.56263953f, 
    -0.36911604f, 0.28005394f, 0.22884621f, -0.15033831f, -0.08263819f, 0.40253085f, -0.39527774f, 0.20066816f, 
    -0.17041601f, -0.69974273f, 0.20114622f, -0.78836095f, -0.12152678f, 0.51233208f, 0.35419115f, -0.61759663f, 
    -0.08843736f, -0.52413654f, 0.00479709f, -0.73136759f, 0.20485137f, -0.21284634f, 0.02189793f, 0.06507591f, 
    -0.40210354f, 0.11731560f, -0.19943456f, 0.06378376f, -0.06658154f, 0.57263464f, 0.13864312f, 0.40423435f, 
    0.27456224f, -0.04842824f, -0.07615298f, -0.66328752f, -0.07086592f, -0.82033050f, 0.05215143f, 0.12679358f, 
    -0.10214433f, -0.82240152f, -0.62909687f, -0.33362573f, -0.19701709f, -0.10462306f, -0.09136764f, 0.44585195f, 
    -0.04919561f, -0.79361355f, 0.04361863f, 0.15331456f, -0.36095130f, -0.16378602f, -0.15356894f, 0.06165790f, 
    0.21589720f, -0.10128910f, -0.24452023f, -0.14584064f, -0.55808270f, 0.31636661f, 0.11576539f, 0.25151274f, 
    -0.33539501f, 0.34915370f, 0.10192902f, -0.17587855f, 0.01231935f, -0.23162505f, 0.45292351f, 0.50772625f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.13535891f, -0.13620798f, -0.08715298f, -0.05755573f, -0.05551208f, 0.05670599f, -0.07064751f, -0.16263810f, 
    0.15190618f, 0.15733224f, 0.15955661f, 0.09129945f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
