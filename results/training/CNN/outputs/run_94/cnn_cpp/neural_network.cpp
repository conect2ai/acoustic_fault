#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.49805972f, -0.34417927f, 0.17389990f, 0.34958735f, 0.45572135f, 0.47979730f, 0.36745948f, 0.37460360f, 
    -0.16391639f, 0.25065574f, -0.13409467f, 0.08683542f, -0.32184315f, -0.07490740f, -0.33168763f, -0.44875342f, 
    -0.28323564f, 0.16772884f, 0.43542230f, -0.56726134f, 0.39563954f, 0.46910232f, 0.03712474f, 0.03531186f, 
    -0.11515478f, -0.21693054f, 0.34842026f, 0.27401870f, -0.27044901f, -0.16982158f, 0.35974911f, 0.59928930f, 
    0.10448030f, 0.15329359f, 0.78003275f, -0.53396189f, -0.00065347f, -0.05255715f, -0.36112183f, -0.37660471f, 
    0.09150010f, -0.16609411f, -0.17158483f, 0.41780120f, 0.09730352f, -0.15195365f, -0.38159499f, -0.35695505f, 
    -0.00866274f, 0.22604309f, 0.49083653f, -0.54261464f, 0.53677499f, 0.68647176f, 0.24519046f, 0.02217677f, 
    -0.75894839f, 0.00564483f, -0.09978634f, -0.63002664f, 0.04962839f, -0.40678683f, -0.17483857f, 0.05556884f, 
    0.08816553f, 0.17297705f, 0.49059400f, -0.01522355f, 0.22408646f, 0.15295494f, 0.13393480f, 0.01170277f, 
    -0.05389714f, 0.34227869f, -0.06639782f, 0.08480397f, 0.66967881f, 0.73495609f, 0.38518417f, 0.69976205f, 
    0.56466037f, -0.13837190f, -0.65013474f, -0.87974131f, -0.63978010f, 0.32351112f, -0.08999886f, 0.10729442f, 
    0.33832073f, -0.33339679f, 0.03890988f, -0.10007098f, 0.01865843f, -0.15245047f, 0.05699266f, -0.11882781f, 
    0.22415394f, 0.17923763f, -0.04588317f, -0.00797306f, 0.89194107f, 0.67150182f, 0.57253915f, 0.50753862f, 
    0.70694536f, 0.08348250f, -0.03576095f, -0.41497999f, 0.33884400f, -0.33007821f, 0.04778385f, 0.29826039f, 
    -0.02714674f, -0.11475573f, 0.16158383f, 0.24838540f, -0.01256900f, 0.15556896f, 0.09577141f, -0.04376710f, 
    0.26754588f, 0.22661819f, 0.27953255f, 0.17054808f, 0.38968006f, -0.69825584f, -0.95707923f, -0.65682214f, 
    0.14764856f, 0.11986066f, -0.47622457f, 0.51447386f, 0.62874478f, 0.08510973f, -0.36911786f, 0.05623426f, 
    -0.33326471f, 0.20795864f, 0.28684744f, -0.09990485f, -0.16868004f, -0.21630181f, -0.28332543f, -0.20584276f, 
    -0.15732062f, -0.01863728f, 0.04079399f, 0.03780244f, 0.05959304f, 0.15507984f, -1.01172841f, 0.79254532f, 
    0.71254712f, 0.37682140f, -0.66554725f, -0.28937119f, 0.35499015f, -0.17463772f, 0.28518298f, 0.14333041f, 
    -0.08724544f, 0.10414144f, 0.01346287f, -0.39894685f, 0.17427036f, -0.06626289f, -0.02936380f, 0.03057240f, 
    -0.17909992f, -0.14542399f, 0.22634818f, -0.05851622f, -0.36928764f, -0.15788767f, -0.16500576f, 0.44563654f, 
    -0.16898885f, -0.56455636f, -1.08549333f, 0.72603893f, 0.54788375f, -0.20401041f, 0.58395141f, 0.32246998f, 
    -0.03866902f, -0.34289417f, 0.00319466f, -0.43545052f, -0.03792769f, 0.11828984f, 0.13814448f, -0.23007917f, 
    -0.08804684f, 0.09160805f, 0.06118496f, -0.09978816f, 0.03827491f, -0.21365778f, -0.10247224f, -0.20997424f, 
    1.03293955f, -0.68490863f, 0.59564859f, -0.61463255f, -0.44752821f, 0.45070156f, 0.18062018f, 0.19366492f, 
    -0.09572774f, 0.08773932f, 0.10960504f, -0.08254655f, -0.25326714f, 0.28767353f, -0.23813224f, 0.24234040f, 
    -0.20541658f, 0.02943831f, -0.07108305f, 0.02819027f, 0.03712381f, 0.15530235f, 0.22802962f, -0.16557780f, 
    0.27729517f, -0.54995632f, -0.26418290f, -0.56748044f, -0.42385915f, -0.27818176f, -0.27458277f, -0.35769361f, 
    -0.18928084f, 0.08486268f, -0.54907888f, -0.14076583f, -0.13723473f, 0.30074403f, -0.02406822f, -0.35510215f, 
    0.25612456f, 0.40433976f, -0.30008447f, 0.02875605f, -0.28261405f, 0.06408408f, -0.03200366f, 0.12247325f, 
    -0.04484762f, -0.29565138f, -0.22471665f, 0.62673450f, -0.03250886f, -0.03693597f, 0.54849756f, -0.92652553f, 
    0.50568980f, -0.20114996f, -0.64423984f, -0.34384581f, 0.12639523f, 0.27567884f, 0.25995281f, -0.15301877f, 
    0.30454594f, 0.26020896f, 0.45401675f, 0.42702177f, -0.03922998f, -0.19930114f, -0.23757513f, -0.23865819f, 
    0.30279446f, 0.50837189f, 0.20418751f, 0.50428462f, 0.37037054f, -0.60369742f, 0.89034480f, 0.57786751f, 
    -0.06996717f, -0.37824294f, -0.55582631f, 0.01217015f, 0.18528569f, 0.02485207f, 0.16003707f, 0.17777066f, 
    0.12113032f, -0.10257975f, 0.08377068f, 0.33810350f, 0.29012170f, -0.03447707f, 0.25182658f, -0.11136395f, 
    -0.22637463f, -0.21983904f, 0.25158852f, 0.14008595f, -0.48128274f, -0.55181450f, -0.60787457f, -0.27657405f, 
    -0.12043612f, 0.33178601f, -0.44720584f, -0.15369812f, 0.33140099f, -0.27767825f, -0.44509298f, 0.08303875f, 
    0.20524366f, 0.10356735f, 0.24435465f, -0.03587914f, -0.08154675f, 0.16742411f, 0.31159747f, -0.06635324f, 
    0.55562580f, 0.18000190f, 0.27105546f, 0.07159866f, -0.21154368f, 0.10861930f, -0.32843474f, 0.04258879f, 
    -0.19658791f, -0.22283646f, 0.45841414f, -0.04772783f, -0.72062814f, -0.77360255f, -0.53010029f, 0.03401571f, 
    0.34292015f, 0.16493639f, -0.11103158f, 0.23610005f, -0.31865543f, -0.17905046f, -0.55044830f, 0.15328290f, 
    -0.36966404f, -0.19305824f, 0.25474817f, 0.23402727f, 0.28262410f, 0.15900426f, -0.31675413f, -0.69033146f, 
    -0.71302390f, 0.30742279f, -0.11826473f, -0.28716806f, 0.33490220f, -0.01502041f, -0.48549005f, 0.07582808f, 
    0.44446856f, 0.35662079f, 0.33757123f, 0.09497042f, 0.25506982f, -0.65134746f, 0.17860664f, 0.42461175f, 
    -0.36846849f, 0.00059463f, 0.06465524f, 0.42541102f, -0.43162000f, -0.22947823f, 0.20354329f, -0.05064871f, 
    0.24383049f, -0.53776330f, -0.55155337f, -0.70174932f, 0.79620242f, 0.80597907f, 0.19942401f, 0.43945006f, 
    0.44214925f, 0.11541262f, -0.06687757f, -0.18698470f, 0.08053479f, -0.28303665f, 0.08041158f, -0.10732069f, 
    -0.25167915f, 0.00375594f, 0.25334120f, 0.28902823f, -0.26147318f, -0.01006324f, 0.02645546f, -0.13048440f, 
    0.52816081f, -0.32462108f, 0.61948228f, 0.73944187f, 0.56869256f, -0.74149978f, -0.47921827f, -0.25028318f, 
    0.04493867f, -0.15052278f, 0.36831817f, -0.13663380f, -0.44815448f, 0.16285731f, 0.07895037f, 0.02240049f, 
    -0.20874168f, -0.02469603f, 0.04032296f, 0.39961743f, -0.22801198f, -0.18863070f, 0.09492704f, 0.03970620f, 
    0.06409476f, -0.33141765f, -0.63546818f, -0.69539720f, -0.47842982f, -0.16638258f, 0.08710670f, -0.00636325f, 
    0.34271547f, 0.28723156f, 0.02791995f, -0.33981517f, -0.27388170f, -0.42420235f, 0.14955267f, 0.14344114f, 
    0.09630189f, 0.23189083f, -0.42739183f, 0.21202430f, 0.23030066f, 0.32909536f, 0.00218555f, 0.46497613f, 
    -0.12811208f, 0.21468790f, -0.25424320f, -0.02365169f, 0.50090313f, 0.54994565f, -0.39842454f, -0.94862396f, 
    0.04194546f, -0.19219783f, -0.65048724f, -0.13652256f, 0.27833083f, 0.02531557f, -0.04962577f, 0.40760830f, 
    -0.22615120f, -0.19210950f, -0.31220922f, 0.23427325f, 0.25700164f, -0.63766360f, 0.21165888f, -0.10780172f, 
    0.09264721f, 0.13214435f, 0.22168860f, 0.53729630f, 0.03040458f, -0.27989718f, 0.31216007f, 0.72070134f, 
    0.10761075f, -0.69618642f, -0.48439255f, -0.24772544f, 0.21130797f, 0.18370792f, -0.24140500f, 0.27057770f, 
    0.20082113f, 0.12186643f, -0.22915463f, -0.43191424f, 0.38250750f, 0.18955980f, 0.20204727f, 0.15142676f, 
    -0.12185472f, 0.18874899f, 0.08994430f, -0.16655496f, -0.08434094f, -0.35208765f, 0.43473217f, 0.27492264f, 
    -0.53883594f, -0.54019034f, -0.67009288f, -0.32862973f, 0.21961349f, -0.49036801f, 0.30510968f, -0.22436228f, 
    -0.22654206f, 0.20696887f, 0.42035222f, 0.22630794f, -0.39057752f, -0.39915580f, -0.06329389f, -0.05144660f, 
    0.38663119f, 0.03384760f, -0.10203949f, -0.24200389f, -0.12920219f, 0.07977445f, -0.23833966f, 0.62331122f, 
    0.76029599f, -0.13811338f, 0.35146579f, 0.11918998f, -0.41862333f, 0.13997197f, -0.33414298f, 0.28991854f, 
    0.38050121f, 0.31426618f, -0.41668624f, -0.14137962f, -0.32183903f, 0.11118797f, 0.32561091f, -0.01937565f, 
    0.23233560f, 0.12518838f, 0.12179259f, -0.35355595f, 0.25605139f, -0.10697538f, -0.60244298f, -0.30023691f, 
    -0.15472403f, 0.64336699f, 0.89950460f, 0.88115084f, 0.12158857f, -0.62582242f, 0.32904720f, -0.38637468f, 
    0.22095250f, 0.10114114f, -0.21001618f, 0.15013537f, -0.06127690f, -0.23845457f, 0.04958694f, -0.11498230f, 
    -0.37047070f, -0.06401947f, 0.04682074f, -0.10776129f, -0.30139765f, -0.04943787f, -0.14564398f, -0.43587407f, 
    -0.26560345f, -0.38001090f, 0.22340305f, -0.69312531f, 0.81501222f, 0.80634159f, 0.07586110f, 0.58204699f, 
    0.48390391f, -0.09369266f, -0.48650023f, 0.21277444f, -0.46393839f, -0.13791077f, -0.06191168f, 0.12408684f, 
    0.18780851f, -0.10047292f, -0.11013016f, 0.01533361f, -0.30108353f, 0.12385024f, -0.00428144f, 0.01460848f, 
    -0.09990530f, -0.02345706f, 0.58040458f, -0.42112827f, -0.69469148f, -0.41525471f, -0.60872686f, -0.21616484f, 
    0.42871484f, -0.02566711f, 0.06407645f, -0.29984686f, -0.32668206f, -0.08507101f, 0.37597132f, -0.47883806f, 
    0.19392665f, 0.10915478f, -0.16839060f, 0.03331831f, -0.20471628f, 0.26138666f, 0.14466971f, 0.10551932f, 
    -0.30606845f, -0.56165123f, 1.00167918f, 0.14827836f, -1.10344422f, 0.10594561f, 0.79669708f, -0.48645046f, 
    -0.55057615f, -0.11175523f, -0.39558828f, 0.31239986f, -0.11590675f, -0.16994616f, 0.36561337f, -0.14958860f, 
    0.02131060f, 0.09703132f, -0.33264890f, -0.08288990f, -0.20624846f, 0.00212728f, 0.11422329f, 0.15138704f, 
    0.05450644f, -0.04531984f, -0.97309428f, 0.83416915f, 0.61273569f, -0.65678519f, -0.10850704f, 0.02634116f, 
    0.54115796f, 0.17692782f, -0.03436689f, -0.33205703f, 0.11287038f, 0.03556732f, 0.11380222f, 0.05511119f, 
    -0.25628763f, -0.38838539f, -0.24650259f, 0.12552571f, -0.56114990f, -0.17377399f, -0.15848641f, -0.17142293f, 
    0.22223796f, -0.13808952f, -0.07210634f, -1.00157070f, 0.31360057f, 0.88072228f, 0.04433802f, 0.02693167f, 
    0.68331414f, -0.37736794f, 0.27926797f, -0.10947288f, -0.70051396f, -0.26054582f, 0.05115953f, -0.11339066f, 
    0.30929732f, -0.04270958f, 0.00978212f, 0.14564341f, -0.06952917f, 0.14966720f, -0.17835094f, -0.07266311f, 
    -0.35717437f, -0.16421637f, -0.26960820f, -0.03926199f, 0.73067385f, 0.07138696f, -0.53632414f, -1.02957892f, 
    -0.44998813f, 0.43251863f, -0.22244267f, -0.35387915f, -0.34739318f, -0.53058702f, 0.32722506f, 0.45782545f, 
    0.29476896f, 0.31769055f, -0.12481175f, 0.03583373f, 0.13101065f, 0.01211869f, -0.07151272f, 0.32950580f, 
    0.03101564f, 0.37617075f, -0.22707401f, 0.11284691f, 0.35600522f, 0.78671527f, 0.40397587f, 0.40852413f, 
    0.57463145f, 0.73485458f, 0.29189128f, -0.22591886f, 0.03318465f, -0.05816704f, 0.22590531f, 0.23799820f, 
    0.17256364f, 0.07577717f, 0.33219275f, 0.02056235f, -0.08060002f, 0.06640019f, 0.48101807f, 0.20651400f, 
    0.24192198f, 0.06492404f, 0.05854257f, 0.19735460f, 0.04809549f, 0.22396906f, 0.76269031f, 0.10801767f, 
    0.22719684f, 0.44734648f, 0.47290292f, 0.15689279f, -0.14743342f, -0.13018037f, 0.44333413f, 0.49803829f, 
    0.15166126f, 0.14140244f, -0.13393602f, 0.46804118f, -0.05709204f, 0.00510723f, -0.34153906f, -0.18169855f, 
    0.12984987f, -0.43282038f, 0.16396728f, 0.02018394f, -0.15368749f, 0.03111765f, 0.27532497f, -0.45521218f, 
    -0.29571745f, -0.02001836f, 0.23201165f, -0.55830920f, 0.42605472f, 0.27088141f, -0.64090657f, -0.26868767f, 
    -0.34639347f, 0.26211268f, 0.50337738f, -0.18478842f, 0.10527101f, 0.29413971f, 0.35149363f, -0.16175707f, 
    -0.32142562f, 0.09249952f, 0.23175752f, 0.12235410f, 0.07448425f, 0.09255469f, 0.33094230f, 0.16380517f, 
    -0.96626240f, 0.81183261f, -0.26965675f, -0.71975005f, 0.30759868f, 0.06700172f, 0.69623041f, 0.24905153f, 
    -0.00315028f, 0.47937164f, 0.20651366f, -0.24765040f, 0.18056026f, -0.57327908f, 0.07955795f, 0.36835715f, 
    0.04101092f, -0.26650536f, 0.14604531f, -0.18118227f, -0.16506927f, 0.37996647f, 0.01497279f, -0.26875460f, 
    -0.04974477f, 0.90611851f, -0.11278006f, 0.45998818f, -0.34481391f, -0.36319295f, 0.59652191f, -0.66274065f, 
    0.55959374f, 0.63454950f, 0.54698384f, 0.16992919f, 0.09044058f, -0.36411744f, -0.25731897f, 0.08076865f, 
    0.26112601f, 0.03820735f, -0.00496848f, -0.12393253f, 0.05662047f, 0.23009267f, -0.02573808f, 0.08544265f, 
    0.03936828f, -0.40369210f, -0.27605370f, 0.15631986f, 0.40559214f, 0.12588337f, 0.32898214f, -0.98283935f, 
    -0.01765364f, -0.01492553f, -0.34361741f, -0.26476741f, 0.57977051f, -0.44122380f, -0.07535896f, -0.01009828f, 
    0.12473293f, 0.30502871f, 0.01808337f, -0.34450471f, 0.32386076f, -0.30102798f, 0.12983701f, -0.27088007f, 
    0.05883310f, -0.01296649f, 0.13795803f, 0.07935735f, 0.62115037f, 0.49170005f, 0.96730226f, 0.14791523f, 
    0.30269757f, 0.15841942f, -0.42988929f, 0.36286512f, 0.15640743f, -0.39514428f, -0.34473369f, -0.00683689f, 
    0.46053275f, -0.42696142f, -0.17479898f, 0.11707503f, 0.54117596f, -0.12247919f, -0.17346048f, -0.24004789f, 
    -0.24101479f, -0.29683450f, -0.00947055f, -0.31797096f, -0.71926224f, 0.07236340f, -0.09842755f, -0.37315720f, 
    0.16277678f, -0.32414579f, 0.29037753f, -0.28112185f, 0.44587710f, -0.03245348f, -0.16337308f, 0.31355405f, 
    -0.48362362f, 0.45093003f, 0.15245873f, 0.34146190f, 0.33555359f, 0.38943285f, 0.10312969f, 0.07643113f, 
    -0.33934483f, 0.11625992f, 0.21162164f, -0.09001724f, 0.33813125f, -0.10368215f, -0.91974384f, -0.69369894f, 
    -0.46603811f, -0.30201572f, -0.47319856f, 0.47744167f, 0.49900067f, 0.27764544f, 0.31493521f, 0.12137681f, 
    0.09622572f, 0.00773406f, -0.10416229f, -0.37765905f, -0.10873672f, 0.21902712f, -0.01721919f, 0.15380473f, 
    0.21110323f, 0.02978926f, -0.18948559f, 0.04706896f, -0.31072530f, 0.24708506f, -0.33308572f, -0.64907438f, 
    -0.26759556f, -0.31084204f, -0.23871644f, 0.41335788f, -0.54876059f, -0.37854555f, -0.23878400f, 0.37254217f, 
    -0.10186806f, -0.34776166f, -0.21774991f, -0.44731405f, -0.08132245f, 0.06729729f, 0.02071653f, 0.41941801f, 
    -0.03193722f, -0.22610855f, 0.21482261f, 0.40455163f, 0.15864161f, 0.53456426f, 0.10972552f, -0.57383573f, 
    -0.45728236f, -0.30939403f, 0.40922126f, 0.70828170f, 0.36713931f, 0.01009985f, -0.03281860f, 0.47882152f, 
    -0.16393867f, 0.24260764f, 0.08575983f, -0.44833812f, 0.02228558f, 0.10413653f, 0.27167106f, -0.29707339f, 
    0.36418277f, 0.13221844f, -0.03740463f, -0.22670156f, -0.01089972f, -0.27350655f, 0.01327769f, -0.25516987f, 
    0.59121591f, -0.14414628f, -0.43113312f, 0.97601044f, 0.66224480f, 0.20104329f, 0.39683548f, 0.09599336f, 
    0.37222865f, 0.36166301f, -0.22941925f, -0.22850688f, -0.22132818f, -0.34853241f, -0.27935433f, -0.19505997f, 
    -0.45982221f, -0.33318037f, -0.36211142f, 0.12071288f, 0.11202873f, 0.07928491f, 0.29272258f, 0.16187286f, 
    -0.14152871f, 0.82330167f, 0.08231705f, -0.39961633f, 0.06210222f, 0.34109786f, 0.44805440f, -0.28751746f, 
    -0.71351951f, 0.37267178f, 0.17569639f, 0.11413626f, -0.18644401f, -0.12037655f, -0.03864349f, 0.04491951f, 
    0.26841536f, 0.42062539f, -0.38447809f, 0.40480971f, -0.00943899f, -0.44902605f, -0.00848001f, -0.12254083f, 
    -0.14666663f, 0.40168658f, 0.62069112f, -0.53489137f, 0.29365963f, 0.06256691f, -0.67972791f, 0.69439471f, 
    -0.74422330f, -0.21685375f, -0.47570720f, -0.30203640f, -0.17295966f, -0.13395409f, 0.13424625f, -0.18249620f, 
    0.13488024f, 0.04066445f, 0.08447242f, 0.20637026f, 0.00215849f, 0.33817998f, -0.27416646f, -0.27393678f, 
    0.12088075f, 0.21846288f, -0.11819800f, 0.70071495f, 0.59959400f, 0.49593234f, 0.60879260f, 0.64141148f, 
    -0.06416938f, -0.05275152f, 0.51202774f, 0.20710398f, 0.32387328f, -0.27696729f, -0.22157593f, 0.15694603f, 
    -0.09763125f, 0.41342127f, 0.48954776f, 0.07338250f, -0.16520125f, 0.23389937f, -0.06100057f, 0.20413546f, 
    0.19140650f, -0.03361155f, -0.03810121f, -0.24104224f, -0.17436473f, 0.55691844f, 0.08127952f, -0.61799103f, 
    0.09554334f, 0.40291107f, -0.22231363f, -0.60344392f, 0.03645794f, -0.31235501f, -0.28551620f, -0.33992648f, 
    -0.69935030f, -0.06353358f, -0.48873988f, -0.14424929f, 0.04568178f, -0.23083474f, -0.35010630f, -0.11489666f, 
    0.09941969f, 0.05928643f, -0.24299845f, -0.00615697f, -0.24891675f, -0.43738878f, -0.65530753f, -0.89213347f, 
    -0.58987308f, 0.21768889f, -0.14651842f, -0.03038835f, 0.39340323f, 0.14054884f, 0.56233668f, -0.19501185f, 
    -0.17907326f, 0.11477220f, -0.34889168f, -0.21872556f, 0.26865244f, -0.17431705f, 0.12347308f, -0.20346257f, 
    -0.29730347f, 0.05132044f, -0.23657344f, -0.00017305f, 0.42159024f, 0.27708510f, -0.14934950f, 0.74956274f, 
    0.63347864f, -0.28386566f, 0.87946105f, 0.43277386f, 0.53972125f, -0.36564943f, -0.09387748f, 0.28774938f, 
    -0.41648617f, 0.20142531f, 0.31694335f, 0.12582768f, 0.15430686f, -0.17958622f, 0.02708123f, -0.22149895f, 
    0.06411166f, 0.03223709f, 0.02441105f, -0.24664871f, -0.17616916f, -0.00486128f, 0.02595813f, -0.96631986f, 
    0.67390019f, -0.86757863f, 0.58612913f, -0.01973523f, 0.02341333f, 0.10188744f, -0.15484978f, -0.42237464f, 
    -0.18558085f, -0.22120447f, 0.07024533f, 0.23465370f, 0.21938573f, 0.16059117f, -0.37238258f, -0.24515481f, 
    -0.46253169f, -0.25748539f, -0.37586296f, 0.29089239f, 0.10860124f, 0.16199638f, -0.09066190f, 0.00296952f, 
    -0.33698016f, 0.94949585f, -0.59712434f, -0.15788993f, 0.66601205f, -0.27424183f, 0.26279005f, 0.40090978f, 
    -0.05342633f, -0.53629178f, -0.17089769f, -0.56646949f, 0.19343214f, 0.19989103f, 0.33131227f, 0.19081038f, 
    -0.02787476f, -0.21911575f, -0.01358031f, -0.00981893f, -0.18416868f, 0.15743837f, 0.14266056f, -0.05818874f, 
    0.31080440f, -0.30052021f, -0.87652880f, -0.28239423f, 0.05312110f, 0.63954264f, 0.07252309f, 0.61220747f, 
    0.10470297f, 0.15504433f, 0.43404806f, -0.34645382f, 0.09142286f, -0.17918548f, 0.10101605f, 0.12573266f, 
    -0.26382664f, 0.02372868f, 0.08941258f, -0.25131762f, -0.01466923f, 0.01192727f, -0.24130870f, 0.21354882f, 
    -0.24636117f, -0.17276862f, 0.69621885f, 0.72875953f, -0.24297914f, -0.04562268f, -0.54258078f, -0.32049972f, 
    -0.61037076f, 0.29490596f, -0.22444303f, 0.01195407f, -0.06142439f, 0.10241739f, 0.31000781f, 0.29521012f, 
    -0.11038248f, 0.19424438f, -0.16235933f, 0.04667937f, -0.07064611f, 0.40140656f, 0.26061010f, 0.18272650f, 
    0.03860163f, 0.05239427f, -0.38633761f, -0.57905561f, 0.86526024f, -0.71212327f, 0.85102868f, -0.61812675f, 
    0.49721426f, -0.19800526f, -0.54387093f, -0.05664570f, 0.06014401f, 0.08793909f, 0.09760491f, -0.29233652f, 
    -0.05507991f, -0.14156805f, -0.02237408f, 0.01110490f, -0.00441901f, 0.22814932f, 0.03841639f, 0.00912464f, 
    -0.29502034f, -0.06428313f, -0.18694466f, -0.31338614f, 0.27235445f, 0.29257989f, 0.26795417f, 0.06964602f, 
    0.63844347f, 0.09982155f, 0.22781040f, 0.72250104f, -0.21725985f, 0.50207072f, -0.43017390f, -0.48171401f, 
    -0.13536586f, 0.13761929f, -0.28557786f, -0.22710064f, -0.25795987f, 0.28356630f, -0.25458989f, -0.35017112f, 
    0.00320534f, -0.23803306f, -0.09397928f, -0.35711527f, -0.16983461f, -0.42072108f, 0.01585429f, 0.30268511f, 
    -0.60088497f, 0.98181063f, 0.60849589f, -0.57990706f, -0.05702563f, -0.33159178f, 0.00075587f, 0.26413104f, 
    0.17623143f, 0.13066985f, 0.38995078f, -0.06941290f, -0.15620688f, 0.24733002f, 0.19472615f, 0.43924171f, 
    0.09168445f, -0.07933854f, -0.11490207f, -0.28536031f, -0.02759872f, 0.23648411f, -0.72058791f, 0.30888209f, 
    0.75225729f, -0.49485716f, 0.06812558f, -0.76876760f, -0.08337256f, -0.26004538f, 0.06222871f, 0.02944873f, 
    0.40409836f, 0.53511739f, -0.07669538f, 0.12135319f, 0.06936016f, 0.22834487f, 0.00105990f, 0.08475757f, 
    0.08104426f, 0.31146738f, 0.37510112f, 0.22503987f, -0.09562804f, 0.02839863f, -0.24681303f, 0.87846392f, 
    0.60197592f, 0.87547207f, -0.17534459f, -0.55712742f, -0.04141487f, -0.83370453f, 0.10443105f, 0.07453211f, 
    0.59009552f, 0.12586366f, -0.20264985f, -0.21906990f, 0.02682208f, -0.18110809f, -0.18323444f, -0.07776511f, 
    -0.04013941f, -0.16926326f, -0.08086583f, 0.32524389f, 0.14916438f, 0.14640066f, -0.00276564f, 0.15964268f, 
    0.57361782f, 0.29704899f, 0.83617359f, 0.49921343f, 0.46877119f, 0.54728097f, 0.05738045f, 0.03152719f, 
    -0.61872727f, 0.26965767f, 0.34567308f, 0.47252709f, 0.08403557f, -0.18710323f, -0.24694338f, 0.09939681f, 
    -0.07461502f, -0.08003699f, 0.04109303f, -0.33344069f, 0.48921093f, 0.04057232f, 0.00512429f, -0.02915238f, 
    -0.00750679f, 0.50096202f, 0.60003805f, 0.29179525f, -0.26400533f, -0.29206917f, -0.00202753f, -0.30809852f, 
    0.44451499f, 0.25742543f, 0.29747972f, -0.21507250f, 0.11253304f, 0.05000739f, 0.36864647f, 0.06954223f, 
    -0.05547249f, 0.54819590f, 0.28386411f, -0.45166990f, -0.46116060f, -0.41275054f, -0.09963114f, 0.15075593f, 
    0.00273410f, 0.37760329f, -1.06640244f, -0.20259093f, 0.61286193f, 0.17372024f, 0.10089485f, -0.21899228f, 
    0.85106534f, 0.25545996f, 0.25131628f, 0.14727905f, -0.42139357f, -0.46123260f, 0.22695778f, 0.06440772f, 
    -0.15950905f, 0.22097357f, -0.11862708f, -0.09878632f, 0.07034663f, 0.10577988f, 0.03141165f, 0.23086239f, 
    -0.12567262f, -0.00196816f, 0.03337468f, -0.84445214f, 0.09711894f, -0.47414941f, -0.56952196f, -0.81080323f, 
    0.36086658f, 0.34643334f, -0.63894922f, 0.37048918f, 0.48783273f, 0.04765155f, 0.25904968f, 0.16138001f, 
    0.05703462f, -0.06451741f, 0.20949003f, 0.34597573f, 0.33065987f, 0.17104810f, 0.01336215f, -0.09763011f, 
    -0.34352425f, -0.39774528f, -0.27140817f, 0.19361153f, 1.09836054f, 0.45955658f, -0.76456988f, -0.20087856f, 
    -0.14894119f, -0.27971005f, 0.30519351f, -0.04577975f, 0.21865277f, -0.36869013f, -0.11049613f, -0.20849806f, 
    -0.09531695f, 0.13322717f, 0.15879144f, -0.01975749f, -0.47731295f, 0.03070659f, 0.11956168f, 0.16267926f, 
    -0.06564900f, -0.03312132f, 0.14923088f, -0.26622012f, -0.43501994f, -0.72162443f, -1.25942326f, -0.36414793f, 
    0.47982192f, -0.05672818f, 0.53352851f, 0.96738303f, 0.24855766f, -0.04045123f, 0.05016293f, 0.01834890f, 
    0.09388015f, -0.26240876f, 0.38656178f, 0.28909865f, 0.16491055f, 0.29067943f, -0.18983342f, -0.13319400f, 
    0.13917923f, -0.05649490f, 0.13179316f, 0.05783342f, 0.06118419f, -0.02685492f, 0.93121439f, 0.71060014f, 
    0.86496729f, -0.50781548f, -0.55051351f, -0.50100708f, 0.37409002f, -0.24982096f, -0.06965373f, 0.28394333f, 
    0.00253363f, 0.13349800f, -0.16683288f, 0.03136197f, 0.11158654f, -0.13159585f, -0.32288799f, 0.08999216f, 
    0.27215576f, 0.16127647f, -0.06875633f, 0.33578435f, -0.06676792f, -0.03031642f, 0.42310357f, 0.94741684f, 
    0.59676909f, 0.43804803f, 0.71429175f, 0.07072021f, -0.07898377f, 0.61618018f, -0.30819100f, -0.21033995f, 
    0.02695910f, -0.03156617f, 0.02828169f, -0.27862445f, 0.17398934f, -0.15767395f, -0.20754248f, 0.10284889f, 
    0.06749289f, 0.06325724f, -0.09320082f, -0.15734620f, 0.16156484f, -0.16782656f, -0.02338800f, 0.11820544f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.01093555f, -0.00623327f, 0.09770744f, -0.00367722f, 0.22616495f, 0.07752508f, 0.03569470f, 0.24945149f, 
    0.26383951f, 0.09701966f, 0.09858501f, 0.22466381f, 0.27165157f, 0.21286274f, -0.03221181f, 0.00506929f, 
    0.18509920f, 0.07783101f, 0.18909128f, 0.18996999f, 0.16702631f, 0.08583409f, 0.35588104f, 0.14396840f, 
    0.29115701f, 0.04713330f, 0.01964742f, -0.04963733f, 0.23711775f, 0.01489530f, 0.25638276f, 0.23023702f, 
    0.15702952f, 0.25568530f, 0.11697911f, 0.01646498f, 0.12022751f, 0.14290673f, -0.02598570f, 0.24888164f, 
    0.14514010f, 0.19243848f, 0.18761235f, 0.10315611f, 0.03338238f, 0.20186746f, -0.00761207f, 0.10369996f, 
    0.06588371f, 0.21230410f, 0.04992500f, 0.07863197f, 0.16185233f, 0.17141837f, 0.15863147f, 0.29874063f, 
    0.27785864f, 0.11357792f, 0.27599201f, 0.21941225f, 0.09633223f, 0.14267772f, 0.31998008f, 0.13950409f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.02920202f, 0.06908630f, 0.00015856f, -0.02687838f, 0.02549430f, -0.02217674f, 0.07953794f, -0.06233719f, 
    -0.06473128f, 0.10826097f, 0.06403928f, -0.05374230f, 0.20612134f, 0.10176434f, 0.06833609f, -0.02623489f, 
    0.03997727f, 0.00576259f, -0.02601370f, -0.04613307f, 0.02128450f, 0.02974214f, -0.12054060f, 0.03381468f, 
    0.16015883f, -0.16617492f, -0.07539943f, 0.19497655f, -0.01798340f, 0.00365879f, 0.12424976f, -0.03674204f, 
    -0.00897786f, -0.09711355f, 0.07122830f, -0.11058372f, -0.08862269f, 0.14078657f, 0.07717227f, -0.12532660f, 
    -0.17261349f, -0.07773352f, -0.00795822f, 0.06731942f, 0.07303266f, -0.03380146f, 0.00295380f, -0.00518034f, 
    0.12672526f, 0.01479101f, -0.05707880f, -0.08192199f, -0.13811736f, -0.10065003f, -0.04395376f, 0.06385863f, 
    -0.02428828f, -0.00502056f, -0.01600158f, -0.04533951f, -0.37645081f, 0.20688717f, -0.19362472f, -0.08914580f, 
    -0.06530061f, 0.01163828f, -0.04471041f, 0.01744542f, 0.11831059f, 0.01794831f, -0.02822844f, -0.01291384f, 
    0.13457428f, 0.16369674f, 0.06428665f, 0.27290851f, -0.07530499f, -0.04412971f, 0.04333432f, -0.19844785f, 
    0.01755663f, 0.11349612f, 0.00366029f, -0.06696854f, 0.13015988f, -0.01233232f, 0.22171630f, -0.27434194f, 
    -0.06472733f, -0.04222523f, 0.10543715f, -0.11334035f, -0.01307540f, -0.05505952f, 0.03079386f, 0.11399221f, 
    0.04545346f, -0.02243535f, 0.16309626f, -0.22515485f, -0.10267203f, 0.03547090f, -0.06859630f, -0.04755415f, 
    -0.09225991f, 0.13106130f, -0.19607103f, -0.02338035f, -0.19683376f, -0.19855669f, -0.04432829f, -0.00235394f, 
    -0.02799437f, -0.05276866f, -0.04485783f, -0.04610125f, 0.04251637f, 0.01972925f, -0.00272870f, -0.08161376f, 
    -0.03397184f, -0.09477507f, -0.01883831f, 0.03395896f, 0.06648149f, -0.18579109f, 0.01654461f, -0.10737296f, 
    -0.00888644f, 0.02019469f, -0.08502728f, -0.04555452f, 0.13749596f, -0.12399200f, 0.15125626f, 0.14522840f, 
    -0.17390873f, -0.02004298f, 0.04320081f, 0.02650927f, 0.05781895f, 0.07909545f, -0.05358013f, -0.03204262f, 
    -0.01927373f, -0.01851986f, 0.00726855f, -0.06626584f, 0.02827394f, -0.07567480f, 0.09244970f, 0.06071605f, 
    -0.05438489f, -0.06235985f, 0.02316651f, -0.01810870f, -0.26003811f, 0.02301364f, 0.12092753f, -0.05839895f, 
    -0.05486110f, -0.02253856f, -0.02789633f, -0.02591686f, -0.09811413f, 0.09250822f, 0.07310354f, -0.05458380f, 
    -0.29808465f, -0.06038371f, -0.13414504f, 0.08071322f, 0.05252553f, -0.17917752f, 0.01980395f, 0.02047601f, 
    -0.00617204f, -0.03726769f, -0.21465820f, 0.14208487f, 0.24220793f, 0.09282724f, -0.05927120f, -0.25903517f, 
    0.02598213f, 0.16356082f, -0.00712368f, 0.02434690f, -0.05285119f, 0.04200566f, 0.01339230f, 0.06577049f, 
    0.25955138f, -0.08816289f, -0.10382699f, 0.22956347f, -0.21065319f, -0.06760650f, 0.04533393f, 0.06085397f, 
    0.02810731f, -0.06241296f, -0.06175582f, -0.01618477f, 0.06706724f, -0.01035721f, -0.14663434f, -0.19186983f, 
    0.02853811f, 0.06609767f, 0.03466238f, 0.07458512f, 0.05238668f, -0.06643441f, 0.09282658f, 0.05828969f, 
    -0.11416095f, 0.05095464f, -0.13500161f, 0.17432947f, -0.05019654f, -0.04828222f, 0.10004899f, -0.04681180f, 
    -0.14760260f, 0.04787058f, -0.03092140f, -0.04076826f, 0.24643606f, -0.03489217f, 0.16679581f, 0.14170869f, 
    -0.11611854f, 0.03027986f, -0.00799554f, 0.06043402f, -0.01821808f, -0.03919686f, -0.05086626f, -0.05633109f, 
    -0.06534396f, 0.03304803f, -0.10090052f, 0.17635778f, -0.02343564f, -0.02559658f, -0.03803787f, -0.01491901f, 
    0.09145623f, -0.01612342f, -0.02075373f, 0.09182397f, 0.01043562f, -0.04031270f, -0.06065910f, 0.10951535f, 
    -0.04702672f, 0.00512063f, 0.07421726f, -0.06233352f, 0.00914319f, 0.06132964f, -0.16679119f, 0.01663756f, 
    -0.22582759f, -0.06605747f, 0.08376668f, 0.15713237f, 0.07702317f, -0.04538416f, -0.03322544f, -0.13415740f, 
    -0.03585599f, 0.00067271f, -0.00156374f, -0.02943064f, 0.37547463f, 0.15797693f, 0.00784093f, -0.08926333f, 
    0.08265416f, 0.09530791f, -0.04070891f, -0.03378019f, -0.00758359f, -0.07361890f, -0.01120955f, 0.11913556f, 
    -0.18390164f, 0.00414519f, -0.19754040f, 0.25746912f, 0.04507164f, 0.01761459f, -0.04524836f, 0.07191499f, 
    -0.02016399f, -0.02181745f, -0.04558020f, 0.02584340f, -0.23440777f, 0.15828690f, 0.10835970f, -0.32772592f, 
    -0.15406750f, -0.00437109f, 0.10369191f, -0.05174718f, 0.01876577f, 0.04328351f, -0.01348125f, 0.05007157f, 
    -0.00643152f, 0.01464247f, 0.08015985f, -0.09063420f, -0.02229457f, -0.04170599f, 0.04994109f, 0.05177516f, 
    0.01535093f, -0.06316904f, 0.11198746f, -0.00982902f, -0.47255641f, 0.11977065f, -0.01759501f, 0.19553186f, 
    -0.04199659f, -0.00237372f, 0.08584739f, 0.03924347f, 0.06997156f, 0.00071484f, 0.00300260f, -0.13124292f, 
    -0.35308671f, -0.11498708f, 0.14568511f, -0.29050416f, -0.12147366f, -0.00154952f, 0.10064285f, -0.01915688f, 
    0.01136529f, -0.14364246f, -0.12685676f, 0.08714958f, 0.18854280f, -0.09191579f, 0.01100764f, 0.04908915f, 
    -0.15213400f, -0.04295346f, -0.00309256f, 0.07253268f, 0.01180236f, 0.06091715f, -0.10194486f, -0.00934701f, 
    0.23070434f, -0.14025505f, -0.01396668f, 0.15875995f, -0.03203946f, -0.11672625f, -0.03661892f, 0.02333464f, 
    -0.09251714f, 0.10954726f, 0.12281385f, -0.07875694f, -0.20938610f, 0.11237435f, 0.09316302f, -0.02319591f, 
    -0.04530061f, 0.02403086f, 0.03879001f, 0.06807379f, 0.05715310f, 0.06590200f, 0.11967763f, -0.09924041f, 
    0.31716940f, 0.01437565f, 0.18233077f, -0.18865953f, -0.10195796f, 0.01964190f, 0.07101256f, -0.12071801f, 
    -0.03601085f, -0.05372334f, -0.11425050f, -0.03085134f, 0.21375158f, -0.16128153f, -0.01330743f, 0.05201341f, 
    -0.05297631f, 0.01183995f, -0.06000536f, -0.00990461f, -0.04592399f, -0.00877087f, 0.00637819f, 0.03108402f, 
    -0.08816224f, 0.06951975f, -0.01223312f, 0.09033667f, -0.11717600f, -0.10176235f, -0.06452477f, -0.03837333f, 
    0.06329013f, 0.06991901f, 0.02170003f, 0.01014140f, -0.03316249f, 0.11606561f, -0.14506508f, 0.22612852f, 
    -0.10441753f, -0.01028745f, 0.02237708f, 0.03087214f, 0.12229001f, -0.02482979f, -0.06704433f, 0.11100785f, 
    -0.17498690f, -0.04505878f, 0.02403466f, -0.07447053f, 0.17635049f, 0.08809923f, -0.02979633f, 0.09975494f, 
    0.00577773f, 0.05854797f, -0.08058292f, -0.02848837f, -0.15794210f, 0.11521832f, -0.17659198f, -0.32931358f, 
    -0.01275298f, -0.00131294f, 0.10733847f, 0.01286587f, -0.00217055f, 0.00716383f, -0.01746037f, -0.04370024f, 
    -0.06173820f, -0.11243348f, -0.03645240f, -0.07523012f, 0.11068194f, 0.05730936f, 0.10034096f, 0.08604546f, 
    -0.01021188f, 0.01155966f, -0.04758056f, -0.02146202f, -0.12426721f, 0.01282500f, 0.07940292f, 0.12905733f, 
    0.14650056f, 0.05966021f, 0.01714018f, -0.04169313f, -0.05021354f, -0.12746383f, -0.02878441f, -0.09493490f, 
    -0.04900219f, 0.20242471f, 0.05844210f, 0.29920769f, -0.05691418f, 0.13118480f, -0.15665458f, 0.01069207f, 
    -0.09232743f, 0.04430634f, 0.07416499f, -0.02178128f, 0.04860816f, -0.27439290f, 0.14865838f, 0.07232057f, 
    -0.05168415f, -0.07204772f, -0.04295649f, 0.06484437f, -0.00051666f, -0.04127121f, 0.08487301f, 0.05218476f, 
    0.04615859f, -0.17257406f, 0.04879940f, 0.03008083f, 0.10264490f, -0.07611071f, -0.05979119f, 0.00378453f, 
    -0.18226355f, 0.00217486f, -0.16017988f, 0.08836165f, 0.14910865f, -0.07488602f, -0.06336214f, 0.06497823f, 
    -0.14787747f, 0.02811007f, 0.00250269f, -0.01665883f, -0.02378447f, 0.07275204f, -0.00171946f, 0.04623061f, 
    -0.27756122f, 0.00332489f, 0.10757701f, -0.18278329f, -0.02500848f, -0.01670859f, 0.05545269f, -0.09584143f, 
    -0.05206759f, 0.09166917f, 0.01835426f, 0.07530094f, -0.01495361f, 0.13034627f, -0.10389751f, -0.21620628f, 
    0.04150589f, -0.00098507f, -0.10923267f, 0.04026698f, -0.06874548f, 0.05701157f, -0.14696351f, -0.00442175f, 
    -0.11566546f, -0.19698496f, 0.15047765f, -0.03707585f, -0.07161865f, 0.03954900f, 0.07614964f, -0.02183740f, 
    0.04593220f, -0.06403029f, -0.01283258f, 0.05176821f, 0.14627962f, 0.14311375f, 0.01065994f, 0.03492328f, 
    0.03321711f, -0.05763903f, -0.14248788f, -0.01775984f, 0.04261564f, 0.01133012f, 0.04001444f, 0.02224684f, 
    -0.07392056f, 0.10815836f, 0.08545373f, -0.29475549f, -0.09859208f, -0.11673348f, 0.01421041f, 0.01723147f, 
    -0.00636526f, 0.09270310f, -0.00557566f, -0.06731455f, -0.22440507f, 0.05276222f, 0.02239872f, 0.01014840f, 
    0.04052097f, 0.03525619f, 0.01510781f, -0.11654892f, -0.02886714f, 0.00774712f, 0.03172639f, 0.07128567f, 
    -0.05827298f, 0.04157986f, 0.06408418f, -0.17840615f, 0.04774521f, 0.04999169f, -0.06489361f, 0.05468328f, 
    -0.08139274f, 0.00823768f, -0.09225848f, 0.02586380f, 0.36473694f, 0.20916425f, -0.03474319f, -0.03026434f, 
    -0.05409451f, 0.04729006f, 0.03140511f, -0.17708901f, 0.04007452f, 0.04679381f, -0.06313925f, -0.03618615f, 
    -0.15359181f, -0.01843707f, 0.10840984f, 0.00873222f, -0.08349046f, 0.10943597f, -0.03634422f, -0.00312809f, 
    0.08705059f, 0.10394865f, 0.01507324f, -0.05814838f, -0.19046350f, -0.22092582f, 0.20331398f, -0.28486958f, 
    -0.00914897f, 0.03600293f, -0.04771269f, -0.19359294f, 0.04153498f, 0.11977854f, -0.01662021f, -0.03161795f, 
    -0.26289272f, -0.07979439f, 0.03481501f, 0.10626839f, 0.02396111f, 0.11206564f, -0.02696138f, 0.01687913f, 
    0.04539502f, -0.00057082f, 0.00845193f, 0.02013916f, 0.01056431f, 0.00021164f, -0.05307344f, -0.00970389f, 
    -0.02224857f, -0.13345914f, -0.06113957f, -0.04807120f, -0.05391436f, 0.00854874f, -0.03663820f, -0.00232949f, 
    -0.02088190f, 0.03393681f, -0.01531462f, -0.06280997f, -0.09858505f, -0.09051131f, 0.06164054f, -0.03915485f, 
    0.00045045f, 0.00315950f, -0.02521073f, -0.03686336f, 0.08487456f, -0.09822650f, -0.03306556f, -0.12058847f, 
    -0.10875961f, 0.01361833f, -0.01454853f, 0.01329369f, -0.01399579f, 0.09572393f, -0.04048258f, -0.03745009f, 
    0.07859448f, 0.04668046f, 0.09844015f, 0.12986514f, -0.10197142f, 0.03163380f, -0.00786714f, 0.11962029f, 
    -0.04136956f, -0.09679801f, -0.01996163f, -0.04191975f, 0.47375754f, 0.00016071f, -0.05870772f, -0.24231718f, 
    0.06461076f, -0.04405052f, -0.02656062f, 0.01415956f, 0.07831310f, 0.00135897f, -0.08046124f, 0.00214245f, 
    -0.12252299f, 0.21223603f, -0.00553408f, -0.28601652f, -0.24470823f, 0.02195762f, -0.10480888f, 0.09373681f, 
    0.00394462f, -0.09122936f, 0.01571357f, -0.03319036f, -0.24704385f, 0.08133960f, 0.12807597f, -0.11287279f, 
    0.10122188f, 0.14708363f, -0.06023322f, 0.03407950f, 0.07144143f, -0.03469463f, 0.07904355f, 0.03576075f, 
    0.00569463f, 0.13127463f, 0.05224356f, -0.14150025f, -0.03124607f, 0.03891685f, -0.11279903f, 0.05173301f, 
    -0.04942311f, -0.03744203f, -0.05470672f, 0.03951276f, 0.11886279f, 0.14634694f, -0.07254562f, 0.10899745f, 
    -0.28111684f, -0.14320965f, -0.03053822f, 0.06873263f, -0.07006872f, 0.01057107f, -0.06207931f, 0.02291428f, 
    0.13602409f, -0.01513080f, 0.10229604f, 0.15264833f, -0.06985889f, -0.03751448f, -0.02807734f, 0.05638797f, 
    0.08237889f, -0.03014228f, 0.01494324f, -0.00213066f, -0.13538939f, 0.01124142f, 0.08278285f, 0.04097052f, 
    0.13206619f, -0.04241895f, -0.05437543f, -0.04099928f, -0.00132970f, -0.02550863f, 0.01404152f, -0.00669298f, 
    -0.20608346f, 0.10972139f, -0.04031820f, 0.09001114f, -0.02844152f, 0.05880345f, -0.00452749f, 0.01525987f, 
    0.10068583f, 0.07723274f, -0.09209438f, 0.10622390f, 0.12197646f, -0.11702102f, 0.15952796f, -0.05039804f, 
    -0.01456177f, -0.00083691f, 0.05828359f, -0.03691116f, -0.09852109f, 0.00288244f, 0.02204941f, -0.03696531f, 
    0.10423137f, -0.05419639f, 0.14381948f, 0.28122580f, -0.07238037f, 0.02001883f, 0.06946686f, 0.00888265f, 
    -0.01924349f, 0.01388776f, -0.03975297f, 0.06046790f, 0.21273868f, 0.03840417f, -0.07821292f, 0.11457223f, 
    -0.08800362f, 0.02393568f, 0.00115092f, 0.05327801f, -0.03913299f, -0.10502937f, -0.03718361f, -0.02082253f, 
    -0.34245703f, -0.01870755f, -0.28967598f, -0.11431611f, 0.04532507f, -0.00193254f, -0.04911729f, -0.10469667f, 
    -0.12700595f, -0.13587482f, 0.15093137f, 0.06079777f, 0.08177458f, -0.17933567f, 0.12451562f, -0.24123842f, 
    0.08805246f, 0.09103028f, -0.07146660f, 0.04543414f, -0.01359102f, 0.13876039f, 0.02606869f, -0.06514567f, 
    0.21642244f, -0.07638580f, -0.18500428f, -0.11258610f, 0.11847842f, -0.09054101f, 0.03209809f, 0.01185271f, 
    -0.02077573f, -0.02915617f, 0.03962251f, -0.05928812f, -0.04243357f, 0.03665627f, 0.08202858f, -0.09319929f, 
    -0.09782800f, -0.00238723f, 0.11291201f, 0.12111098f, -0.06497531f, -0.05463530f, -0.06385607f, 0.09979185f, 
    -0.12045847f, 0.18246897f, -0.05340046f, -0.10107943f, -0.05669595f, 0.17917840f, -0.10049354f, 0.01411579f, 
    0.08778942f, 0.09815499f, 0.13926186f, 0.07552756f, 0.01624504f, -0.18641850f, -0.08433969f, 0.00186827f, 
    0.05026899f, -0.04226350f, -0.08615284f, 0.04631546f, 0.00111399f, -0.01595866f, 0.02439469f, -0.00527776f, 
    0.04410999f, 0.06721660f, 0.02629041f, -0.06217865f, -0.05357033f, -0.10039837f, 0.05013727f, -0.06955772f, 
    0.08952434f, 0.06946972f, 0.06804563f, 0.12124180f, -0.06919529f, -0.12986916f, -0.10890956f, -0.09237386f, 
    -0.00380642f, 0.02513918f, -0.03123096f, 0.05347280f, -0.00907444f, -0.06041221f, -0.09675152f, -0.05149547f, 
    0.05310316f, 0.02783757f, -0.07978766f, 0.07763746f, -0.05110828f, 0.05432002f, -0.08967002f, -0.02325956f, 
    0.10658250f, -0.20165762f, 0.18927900f, -0.08486688f, -0.08217238f, -0.31801832f, 0.05211239f, -0.13427243f, 
    0.04178334f, -0.11311940f, -0.05248152f, -0.06689752f, 0.05344252f, 0.03003686f, -0.07962102f, -0.01808218f, 
    -0.08732448f, 0.00584053f, 0.00896303f, 0.11361203f, 0.00577036f, 0.01568521f, -0.04391160f, 0.01106395f, 
    -0.04468617f, -0.02095924f, -0.00614851f, -0.00580426f, 0.02464743f, -0.03188603f, 0.02125798f, -0.12587552f, 
    -0.11784157f, -0.00048070f, 0.02375558f, 0.04371272f, 0.10117322f, 0.04664121f, -0.05706941f, -0.05961330f, 
    -0.27312014f, -0.03956148f, -0.21240969f, 0.02959930f, -0.06392844f, 0.13132967f, -0.09395874f, 0.07712054f, 
    0.09640879f, -0.03882788f, 0.00251724f, 0.04828126f, -0.02929013f, -0.08082107f, 0.06247419f, -0.04845976f, 
    -0.08702694f, -0.12672709f, 0.06368116f, -0.09958860f, -0.04317560f, 0.10720962f, -0.01673754f, 0.03660355f, 
    -0.39834404f, 0.07118083f, -0.05588721f, 0.02993607f, -0.05608192f, 0.07935032f, -0.01927256f, 0.04156162f, 
    -0.13969986f, -0.01096650f, -0.06160028f, 0.06281909f, -0.18860973f, -0.04840613f, 0.02398652f, 0.12493219f, 
    -0.08964160f, 0.04663906f, -0.03625836f, -0.05784729f, -0.02026323f, 0.02030036f, 0.10364447f, -0.07323224f, 
    0.07002851f, 0.08564357f, -0.16125876f, -0.00253834f, 0.09439321f, 0.07708623f, -0.09229305f, 0.05643420f, 
    -0.13108499f, -0.00856227f, 0.06321147f, -0.10423241f, -0.12456084f, -0.05534006f, -0.02147024f, 0.04911687f, 
    0.09033643f, -0.00581893f, 0.00587401f, 0.01689494f, 0.08563378f, 0.08120582f, 0.01883198f, 0.07698633f, 
    -0.38245556f, -0.03210932f, -0.03272005f, -0.09479298f, -0.06114457f, -0.12002966f, -0.01318398f, -0.05938304f, 
    0.06393375f, -0.06051393f, 0.11850590f, 0.09902886f, -0.25733718f, -0.12160940f, 0.08613797f, -0.32039243f, 
    -0.07757162f, 0.04555450f, -0.00647415f, -0.03324494f, 0.02394255f, 0.02915065f, -0.02558729f, -0.05407682f, 
    -0.34951055f, 0.16462515f, -0.11585487f, -0.17273432f, -0.11724662f, 0.02715157f, 0.09827468f, -0.07270814f, 
    -0.10349604f, -0.19834757f, 0.05153258f, -0.03535895f, 0.12434980f, 0.15623102f, -0.23076726f, 0.10677543f, 
    -0.01888548f, 0.05526779f, -0.02035055f, -0.26334214f, -0.02773967f, 0.06602273f, -0.14444175f, 0.16138993f, 
    0.27848062f, -0.22231166f, -0.04543734f, -0.23432977f, -0.04967989f, 0.05869764f, -0.11650021f, 0.07116213f, 
    -0.06220369f, 0.11009749f, 0.05924901f, -0.05654687f, 0.05767555f, -0.01296489f, 0.13893998f, 0.17244835f, 
    -0.05129796f, -0.10493249f, -0.03752584f, 0.00733539f, -0.04956718f, -0.08679065f, 0.01444330f, 0.02553155f, 
    0.14958325f, 0.00513049f, 0.17965791f, 0.15384492f, -0.04631158f, 0.04424892f, -0.02807586f, 0.04438522f, 
    0.06278781f, -0.04942437f, -0.16063593f, -0.02822810f, -0.26384485f, -0.08385943f, -0.18458699f, -0.01364190f, 
    -0.04656903f, -0.05058453f, -0.02447702f, 0.00033440f, -0.09565005f, 0.03567068f, -0.15910420f, 0.05954802f, 
    -0.01955642f, 0.12958150f, -0.05778987f, -0.21344943f, 0.02172342f, 0.02945559f, -0.01456540f, 0.04073894f, 
    0.08818699f, 0.01559041f, 0.11912164f, 0.09161349f, 0.03410091f, 0.01300039f, 0.09646936f, -0.07213663f, 
    0.01580513f, -0.08345149f, -0.05445026f, -0.04011568f, 0.06901708f, 0.06404451f, 0.03003590f, -0.06950411f, 
    -0.00899056f, -0.01093036f, -0.18648826f, -0.02801411f, 0.13214132f, 0.16026427f, 0.00382564f, 0.03731393f, 
    0.00192977f, -0.00876106f, -0.17690508f, -0.02453022f, 0.10130512f, -0.06772088f, -0.08085977f, 0.14839824f, 
    0.01572665f, -0.00133503f, 0.00836982f, 0.01140338f, 0.02208816f, -0.16657755f, 0.05965292f, -0.15540403f, 
    -0.04988415f, 0.02499770f, -0.18074346f, -0.06749846f, -0.15073548f, -0.00487198f, 0.10325056f, 0.07716724f, 
    0.07804340f, 0.02341459f, 0.01004883f, 0.02563670f, 0.20886548f, -0.18802978f, -0.04342255f, -0.07583943f, 
    0.03449570f, -0.11555088f, -0.01203215f, 0.16342165f, 0.02160271f, -0.00701839f, 0.05508941f, 0.06833661f, 
    -0.04354422f, 0.06547597f, 0.08928183f, 0.06992429f, -0.01605662f, -0.10709292f, 0.03391580f, -0.01718842f, 
    0.06697229f, -0.06533159f, -0.03166084f, 0.12129132f, 0.15221778f, 0.07095251f, -0.05043000f, 0.08384827f, 
    0.09620950f, 0.00071263f, -0.04483662f, -0.00654695f, -0.10028700f, 0.05667875f, -0.01241564f, 0.03221857f, 
    0.24094209f, -0.10602119f, 0.10748928f, 0.13765794f, -0.03236042f, 0.09432745f, 0.05336258f, 0.01337460f, 
    0.08209441f, 0.12638816f, -0.10622175f, 0.07113833f, 0.10958885f, -0.18859720f, 0.09274247f, -0.06797788f, 
    0.14268667f, -0.05571975f, -0.12123757f, -0.07277883f, -0.10651266f, 0.04947945f, 0.02322122f, -0.05636100f, 
    0.03646824f, 0.13867654f, -0.08383900f, 0.06541122f, -0.05533136f, 0.15483303f, 0.15534794f, -0.12006249f, 
    0.12409385f, 0.11679952f, 0.09745979f, -0.04246838f, 0.18027811f, 0.08587158f, 0.01833631f, 0.17180659f, 
    -0.02920571f, -0.09282532f, 0.04118330f, 0.01393013f, 0.10169919f, -0.06885907f, -0.05178905f, 0.07644509f, 
    -0.10245828f, -0.05519304f, -0.13326690f, -0.16148669f, -0.01674188f, 0.03366599f, -0.07113120f, 0.06491105f, 
    -0.00182896f, -0.00483502f, -0.11002322f, -0.33123004f, 0.15636066f, -0.04535088f, 0.03508151f, -0.23516956f, 
    0.03003704f, 0.04917899f, 0.01395644f, 0.03793037f, 0.03488167f, -0.14239766f, -0.06715270f, -0.01183909f, 
    0.17984714f, 0.21103136f, 0.01036096f, -0.02218902f, -0.15158276f, -0.04094561f, 0.04595965f, -0.00063061f, 
    0.06942374f, 0.02493128f, 0.03719539f, -0.04826467f, -0.02963706f, 0.03256078f, -0.22505738f, -0.14294118f, 
    0.10018253f, 0.03897161f, -0.07304028f, 0.02050191f, 0.04660155f, -0.12941763f, -0.14848106f, -0.12450726f, 
    -0.04895893f, 0.06346724f, -0.15523088f, -0.15027826f, 0.10631191f, 0.02572003f, 0.09546520f, 0.05264227f, 
    -0.00408135f, -0.06038297f, -0.05577926f, 0.05874914f, 0.31132317f, -0.11245534f, -0.03102530f, -0.05983199f, 
    -0.03494412f, 0.03167205f, -0.02495063f, 0.04386205f, 0.01386603f, 0.11450552f, 0.06045153f, -0.07039809f, 
    0.09803495f, -0.14652474f, 0.01152541f, -0.03379202f, -0.04212862f, -0.10249303f, 0.02434440f, 0.07991640f, 
    0.05563007f, 0.02414512f, 0.03272723f, 0.12137385f, -0.41489783f, -0.39081293f, -0.40322375f, 0.08735455f, 
    0.12812102f, -0.20070067f, -0.08641195f, -0.01903121f, -0.01163324f, 0.04308110f, -0.12442286f, 0.09825643f, 
    0.17486849f, 0.05886814f, 0.05788100f, 0.12404841f, 0.03409645f, 0.02696437f, -0.02497943f, 0.05357314f, 
    0.01269280f, 0.03343420f, -0.04641613f, -0.09137728f, 0.18849640f, -0.00047503f, 0.00979840f, 0.02468106f, 
    -0.09488551f, 0.02738022f, 0.02064151f, 0.22214200f, -0.10183649f, 0.04920071f, 0.08877830f, 0.03201656f, 
    -0.49961966f, 0.04628186f, -0.12207915f, -0.08858916f, 0.03914027f, -0.11326703f, -0.11716000f, 0.02300601f, 
    -0.04188459f, 0.03265195f, 0.00002623f, -0.06895034f, 0.04711649f, 0.13003956f, 0.00373736f, 0.01044139f, 
    -0.09938851f, -0.03272901f, 0.10769282f, 0.09217703f, -0.07141626f, -0.06171316f, 0.06702970f, -0.02805755f, 
    0.19299217f, 0.12676457f, 0.11740170f, 0.14306132f, -0.15099128f, 0.03784584f, 0.06300852f, 0.04098294f, 
    0.00118366f, 0.00106023f, 0.00532917f, 0.00719630f, 0.01662926f, 0.10078707f, -0.04118702f, -0.03278331f, 
    -0.04368922f, -0.04451393f, -0.05153271f, -0.02714862f, -0.08689436f, -0.20723607f, 0.10352649f, -0.10596244f, 
    -0.17410153f, 0.02647641f, -0.14666617f, 0.02277545f, 0.04632853f, -0.00175311f, -0.10800648f, -0.12784754f, 
    -0.01953220f, 0.16702697f, -0.07930573f, -0.06755096f, -0.27963230f, -0.12038778f, 0.01910455f, -0.08673182f, 
    0.06839736f, 0.00407882f, 0.05973714f, 0.04634489f, 0.05520390f, 0.07380109f, 0.02118739f, 0.01716339f, 
    0.36072609f, -0.22459738f, 0.11587781f, -0.11699679f, 0.01543284f, -0.29706857f, 0.05704052f, 0.06853360f, 
    -0.16955620f, 0.01129985f, -0.10343498f, 0.12848850f, 0.26958850f, 0.08322827f, -0.24747401f, 0.10774428f, 
    -0.07243004f, 0.15760221f, 0.00071978f, -0.01873855f, -0.00807537f, 0.09394667f, -0.05214623f, 0.13457955f, 
    0.18417796f, 0.08290325f, -0.10670725f, 0.02861629f, -0.02977426f, -0.16365182f, 0.04139972f, 0.06643079f, 
    -0.01204097f, 0.01419526f, -0.08627418f, -0.01643721f, 0.32250777f, 0.00960878f, 0.04526691f, 0.05879960f, 
    -0.08912772f, -0.02621037f, 0.01851149f, 0.01544634f, 0.10198489f, 0.00086277f, 0.08734836f, -0.05080869f, 
    -0.01620801f, 0.01616846f, 0.15748556f, -0.00875473f, -0.02225453f, 0.04753464f, -0.02233531f, 0.00535172f, 
    -0.03772909f, -0.01088098f, -0.02868824f, 0.06321296f, 0.23082267f, 0.00517794f, 0.02655316f, -0.00784835f, 
    -0.03602969f, 0.06516781f, 0.14905679f, 0.09632036f, -0.01822236f, 0.05337711f, 0.05321307f, -0.08484536f, 
    -0.27921224f, 0.04482153f, -0.14529012f, -0.01891179f, 0.02053010f, 0.02196441f, -0.05181294f, 0.01736757f, 
    0.03833207f, -0.14844738f, 0.04778122f, -0.03866823f, 0.07386161f, 0.06767844f, -0.09794337f, 0.09047634f, 
    0.07564986f, 0.02539095f, 0.00574648f, -0.10843914f, 0.06219428f, 0.04223529f, -0.08532698f, -0.04070429f, 
    0.06273534f, 0.03931642f, -0.05611912f, -0.00218141f, 0.10614963f, 0.03750734f, 0.04706459f, -0.06591064f, 
    -0.00313212f, 0.05103846f, 0.06901652f, -0.04550130f, 0.36368454f, 0.01147805f, -0.10229348f, 0.03923751f, 
    -0.13861059f, -0.01259924f, -0.02800961f, -0.01429276f, 0.14346687f, 0.02988549f, 0.06967773f, 0.03814523f, 
    0.22534800f, 0.02498286f, -0.28662437f, -0.06848635f, -0.07140232f, 0.03649556f, 0.08619387f, -0.04986923f, 
    -0.05988901f, -0.00256358f, 0.03216934f, -0.00853739f, -0.36894730f, 0.13174739f, -0.05215756f, 0.10778739f, 
    0.00792236f, 0.02015595f, -0.00622038f, 0.00685993f, 0.03264975f, -0.05892008f, -0.06183337f, 0.03478791f, 
    -0.24227600f, -0.02230153f, -0.05392177f, -0.07107870f, -0.05279119f, -0.03278902f, -0.02870435f, -0.00674766f, 
    -0.12008093f, -0.04747184f, -0.03148146f, 0.04391428f, -0.28021207f, -0.03188256f, -0.06686971f, -0.13018632f, 
    0.04763444f, 0.00393571f, -0.03940228f, -0.03563066f, 0.04536552f, 0.07198104f, -0.02306502f, 0.04508075f, 
    0.32357103f, -0.03888394f, -0.21444143f, -0.19897573f, 0.17224410f, 0.00381114f, -0.02088334f, -0.07120957f, 
    -0.15279429f, -0.04200757f, -0.04059743f, -0.14261310f, 0.04361261f, -0.18537199f, 0.02588759f, -0.03651691f, 
    0.10801841f, -0.02372974f, 0.07278500f, -0.03071375f, -0.14227095f, 0.01078270f, -0.00985445f, -0.08402466f, 
    -0.23226951f, -0.00790693f, -0.04411259f, 0.04442732f, -0.14436422f, 0.04681869f, -0.03834682f, -0.01843310f, 
    -0.04354887f, 0.00464671f, -0.09560367f, 0.03408022f, -0.03541537f, -0.14710698f, 0.01711702f, -0.40948597f, 
    -0.07892250f, -0.02205877f, -0.04606732f, 0.02045136f, -0.03129233f, 0.04136032f, 0.00257723f, -0.04867372f, 
    0.38335577f, -0.01151678f, 0.12190928f, 0.02651663f, 0.06109661f, -0.02599848f, 0.15827404f, 0.01598709f, 
    -0.03427051f, 0.02016485f, -0.23383620f, -0.08970939f, 0.30715120f, 0.16494876f, 0.16392070f, 0.18383126f, 
    -0.06450148f, -0.09684701f, 0.01630498f, 0.11893010f, -0.06220834f, 0.05428421f, 0.06715710f, -0.06000893f, 
    0.02453598f, 0.03650425f, -0.25151923f, 0.06652064f, -0.05186862f, 0.02183579f, -0.10436309f, 0.05072886f, 
    -0.07090408f, -0.00739683f, 0.02656147f, -0.05198684f, 0.10662218f, 0.01659545f, -0.01882416f, 0.28901014f, 
    -0.06427412f, -0.03451331f, -0.03457864f, 0.02063308f, -0.04015182f, -0.13940060f, 0.05290695f, 0.11334212f, 
    0.15760981f, 0.03770524f, -0.22720522f, -0.09918633f, -0.00980268f, 0.11032102f, 0.03724418f, -0.02533292f, 
    -0.08031387f, 0.00733417f, -0.02258727f, -0.09151376f, -0.13393316f, -0.03208090f, -0.00573314f, -0.08783675f, 
    0.05155543f, 0.04342636f, -0.03613600f, -0.04526418f, -0.10244130f, -0.01677296f, -0.01321014f, -0.03238698f, 
    -0.06164680f, -0.16313508f, -0.15845521f, -0.15520728f, -0.00722430f, 0.10664894f, -0.06281772f, 0.01563929f, 
    0.15420648f, 0.02723308f, -0.11177137f, 0.00254950f, -0.01607731f, -0.05813126f, 0.01978305f, 0.07782285f, 
    -0.10510091f, -0.00016888f, -0.01962289f, -0.03076193f, 0.01190091f, -0.07551674f, -0.05941361f, 0.05097990f, 
    0.13411228f, -0.36486033f, 0.05010763f, 0.03532415f, -0.00159857f, 0.01920807f, -0.07445918f, 0.03622205f, 
    0.01358600f, -0.04252306f, -0.06741563f, 0.07181014f, 0.17296378f, 0.09830605f, 0.11704957f, 0.08622920f, 
    0.04249762f, -0.07123958f, 0.01106475f, 0.11240071f, 0.00414444f, 0.07355081f, -0.06682078f, -0.02969363f, 
    -0.19611920f, -0.09023796f, 0.05021260f, -0.10376664f, -0.08046401f, 0.11412905f, -0.08608591f, -0.01287503f, 
    0.01104017f, 0.00943177f, -0.00199481f, 0.04407235f, 0.08115393f, 0.06867460f, -0.06749770f, 0.02479810f, 
    0.10981575f, 0.02303028f, 0.03633856f, -0.03224838f, -0.00362298f, 0.02622242f, -0.07300714f, -0.06916415f, 
    0.32954830f, 0.12550911f, -0.20668720f, -0.02171725f, -0.01077140f, 0.05888293f, 0.01037863f, 0.06460640f, 
    -0.07456944f, 0.05955474f, 0.01331047f, 0.01570775f, 0.16751043f, 0.09668963f, -0.08387311f, 0.00672143f, 
    -0.09625248f, 0.04616255f, -0.06607537f, 0.10296851f, -0.05321502f, -0.00643966f, -0.09242612f, -0.09219614f, 
    -0.56321245f, -0.09687439f, 0.07671403f, -0.26301536f, 0.06556663f, -0.08628359f, 0.09390456f, -0.07735310f, 
    -0.02374428f, -0.07889032f, 0.01749483f, -0.06044219f, -0.00650168f, 0.10970905f, 0.02695872f, 0.04102606f, 
    0.07376269f, 0.06546764f, 0.00719734f, -0.00135209f, -0.12463505f, 0.01545429f, -0.07710560f, 0.01572127f, 
    -0.01536756f, 0.04448963f, 0.01948809f, -0.01893729f, -0.01822788f, -0.00016903f, 0.03703680f, 0.03897059f, 
    -0.06564616f, 0.03654816f, 0.06797785f, -0.06378955f, 0.28464082f, -0.20581470f, 0.07559567f, -0.22604057f, 
    -0.03782548f, 0.04861900f, -0.03640171f, -0.00526660f, -0.00793155f, -0.10040107f, 0.06610933f, -0.04202889f, 
    0.21828730f, 0.01266124f, 0.01219648f, 0.02110394f, 0.02892501f, 0.00880053f, -0.01558586f, -0.02242123f, 
    -0.01791163f, 0.01512680f, -0.00113325f, -0.07638805f, -0.15522097f, 0.16039382f, 0.09972618f, 0.07798602f, 
    -0.06431431f, -0.05576766f, 0.01177164f, 0.01382059f, 0.01637551f, -0.07267679f, 0.02962723f, -0.06964204f, 
    0.28662494f, -0.04281404f, -0.33271039f, 0.00904733f, 0.05357935f, 0.02767496f, -0.11307677f, -0.06769444f, 
    -0.13214742f, -0.04500507f, 0.02453538f, -0.05863364f, 0.01497689f, -0.12801865f, 0.01833372f, 0.02939742f, 
    0.05884454f, 0.03508156f, -0.01177566f, -0.07156835f, -0.04548898f, 0.03104574f, -0.07577061f, -0.03019579f, 
    0.21936615f, -0.01707789f, -0.18659848f, 0.02835552f, -0.04279920f, -0.09628898f, -0.17982407f, -0.03300526f, 
    -0.11387175f, -0.09166753f, -0.07878634f, 0.03967024f, 0.28757060f, 0.06787682f, 0.11844559f, 0.23766932f, 
    -0.21241552f, -0.11095862f, 0.06032468f, 0.02665962f, -0.06969454f, 0.00058563f, 0.00368646f, 0.05308651f, 
    -0.24680075f, -0.23130655f, 0.11466902f, -0.06303580f, -0.09939467f, -0.08308879f, -0.02837943f, -0.13283928f, 
    0.04298782f, 0.07400929f, 0.02048404f, 0.12818459f, 0.02132609f, -0.20616429f, 0.05077500f, 0.05823076f, 
    -0.11626263f, -0.01363809f, 0.01671185f, -0.03630014f, -0.03638688f, 0.03065416f, -0.07505599f, 0.00230878f, 
    0.02080842f, -0.12490103f, -0.04500972f, -0.04125591f, 0.09672529f, -0.00277456f, -0.04220759f, 0.02997252f, 
    0.02706251f, 0.07664193f, 0.11494549f, 0.03539086f, -0.01715207f, -0.11187019f, 0.06816882f, -0.13800482f, 
    0.05412448f, -0.09015029f, 0.06544789f, 0.08803988f, 0.00374222f, -0.05784839f, 0.01525153f, -0.11149378f, 
    -0.43258658f, -0.17851013f, 0.03516736f, -0.24443662f, -0.04764324f, 0.01733685f, -0.12643716f, -0.01221968f, 
    -0.10919628f, -0.00003374f, -0.01027957f, -0.08486959f, -0.15335295f, 0.10174958f, 0.01818562f, -0.03846842f, 
    0.05832160f, 0.04749119f, 0.02634308f, -0.00796409f, 0.06018588f, 0.01250035f, 0.07470351f, -0.07882740f, 
    -0.01480951f, -0.13688512f, -0.14827931f, -0.13862386f, 0.03246773f, 0.06630142f, 0.08281478f, -0.10636883f, 
    0.04472192f, 0.13784046f, -0.01815861f, 0.00731156f, 0.16055839f, 0.02891429f, 0.03442160f, 0.23403633f, 
    -0.09834153f, -0.11487796f, -0.12182685f, -0.06646964f, 0.02485487f, 0.06532555f, -0.06562930f, 0.00183038f, 
    0.23351415f, -0.26562601f, 0.12154695f, 0.01707281f, 0.04606526f, 0.00858883f, 0.04413784f, 0.00697227f, 
    0.02897691f, 0.05239415f, 0.01292586f, 0.05988487f, 0.03005345f, 0.02121184f, -0.17067236f, -0.18003522f, 
    0.00848319f, 0.07518247f, -0.05053039f, -0.12345440f, 0.01056265f, 0.03665232f, -0.10707885f, -0.09735568f, 
    -0.13324700f, -0.10244798f, -0.10349184f, -0.12092357f, -0.02605027f, 0.06591173f, -0.00870559f, -0.07556725f, 
    0.01453173f, 0.07027690f, -0.00481126f, 0.16313793f, 0.16325153f, -0.07007211f, 0.08123684f, 0.01719246f, 
    -0.03409433f, 0.09737161f, -0.02443783f, 0.03951234f, 0.04776753f, -0.04681493f, -0.04372235f, 0.05078250f, 
    -0.30375686f, 0.13224843f, -0.09664353f, -0.07719296f, -0.05295122f, 0.05622957f, 0.13868523f, -0.06104823f, 
    -0.09551412f, -0.02601694f, -0.01666223f, -0.05130421f, 0.02543122f, -0.19167264f, -0.09099816f, -0.25801378f, 
    0.04876621f, 0.00855214f, 0.04552010f, -0.01168014f, -0.04936852f, -0.08094025f, 0.02703189f, -0.03371476f, 
    -0.05500799f, -0.02332064f, -0.03801733f, -0.05851421f, 0.13135965f, -0.06509836f, -0.03194320f, -0.04089492f, 
    -0.01714003f, 0.00270056f, -0.02067626f, 0.09410041f, 0.05480745f, 0.03708320f, 0.05373906f, 0.13166282f, 
    -0.03371119f, -0.05563056f, 0.05807771f, -0.05373280f, -0.08144037f, -0.06258888f, -0.04898479f, -0.04787699f, 
    0.23502050f, -0.05572353f, -0.13154760f, 0.00520563f, -0.02866382f, 0.06891008f, 0.03155331f, -0.04504446f, 
    -0.06425031f, -0.09497488f, -0.07515968f, -0.07291710f, -0.13721365f, 0.02238517f, 0.04412716f, -0.12904680f, 
    -0.03400278f, 0.06627655f, 0.08912193f, -0.03777365f, -0.02116680f, 0.03090707f, -0.05205153f, 0.00740152f, 
    -0.01751951f, 0.00892027f, 0.01646804f, 0.05192838f, -0.04105278f, 0.04456661f, 0.03086297f, -0.01767949f, 
    0.01975411f, 0.08611912f, -0.03426996f, 0.00612318f, -0.12081222f, 0.04992135f, 0.02425716f, 0.01531731f, 
    0.06863050f, 0.01864279f, 0.08863670f, -0.00144183f, -0.07924623f, 0.10209437f, -0.05130142f, -0.02044114f, 
    0.19962034f, -0.08431576f, -0.13188370f, 0.02545300f, -0.11818506f, -0.07468669f, 0.10413466f, 0.02221163f, 
    -0.00449601f, -0.03747582f, 0.02020782f, -0.03592937f, 0.21159421f, 0.03272495f, 0.10085145f, 0.06183507f, 
    0.02179091f, -0.07068020f, 0.02520308f, 0.06441358f, -0.03084048f, 0.05729397f, -0.06893163f, -0.14041941f, 
    0.09348050f, -0.11565044f, -0.18389875f, -0.06749287f, -0.01171085f, -0.03268506f, 0.14456815f, 0.03446126f, 
    0.01823483f, 0.06768399f, 0.08986212f, -0.03693817f, 0.37455636f, -0.07520915f, 0.14212599f, -0.04612008f, 
    -0.14364597f, -0.10115559f, -0.08338444f, 0.08440807f, 0.09639957f, -0.03024133f, 0.04497676f, -0.12332442f, 
    -0.16519462f, 0.08841202f, 0.01100024f, -0.10275541f, -0.06667271f, 0.11897499f, 0.02723302f, -0.03680197f, 
    -0.02866104f, 0.02270295f, 0.04381424f, -0.00688149f, -0.09583355f, 0.02658547f, -0.05051477f, -0.15953885f, 
    0.06547563f, 0.06217499f, -0.00039647f, -0.03283340f, -0.03211274f, 0.06349017f, -0.08610974f, -0.00168861f, 
    -0.25926298f, -0.09309283f, -0.09772229f, -0.05089650f, -0.04859374f, 0.04065052f, 0.01850296f, -0.01082665f, 
    -0.00913591f, -0.00083803f, 0.07412066f, 0.00773608f, -0.28906319f, 0.06570262f, -0.05803893f, -0.04118762f, 
    0.00394826f, -0.02517443f, 0.02447290f, 0.06472081f, -0.01104744f, 0.02647941f, 0.08056917f, -0.04754671f, 
    0.10105663f, -0.17662582f, 0.09599955f, 0.15638679f, 0.02113467f, 0.07769860f, 0.03597898f, -0.03179931f, 
    -0.01097050f, -0.06645191f, 0.02044411f, 0.00456273f, 0.18116024f, -0.33984441f, 0.12944642f, 0.27799520f, 
    -0.01858927f, 0.00706162f, -0.09642691f, 0.06602288f, 0.02927647f, -0.04098787f, -0.04844276f, -0.08218094f, 
    -0.19479583f, -0.39969635f, -0.20966874f, 0.00100551f, 0.03004040f, -0.08131184f, -0.01645576f, -0.05110047f, 
    -0.04437821f, -0.02380344f, -0.06400087f, -0.06034031f, 0.11989326f, 0.08197409f, 0.05230834f, 0.09284978f, 
    -0.05214658f, -0.07845945f, 0.11720515f, -0.06039150f, -0.15489051f, -0.01472000f, -0.01398455f, 0.08576559f, 
    -0.35163841f, 0.24125677f, -0.05597153f, -0.02149529f, -0.01085570f, 0.09130570f, 0.01149360f, 0.11777028f, 
    -0.03291735f, 0.05947953f, -0.03412508f, 0.02928417f, -0.14501630f, 0.02312135f, -0.08345932f, 0.07142370f, 
    -0.13370663f, 0.02387963f, -0.01982566f, -0.03089669f, -0.02200647f, -0.00376072f, -0.01262082f, -0.02823604f, 
    -0.04157249f, -0.10713420f, -0.18321951f, -0.04595169f, -0.03919322f, -0.00345652f, -0.06860884f, 0.12828340f, 
    -0.06011435f, 0.02306187f, -0.01350007f, 0.00870411f, 0.06131141f, -0.00225282f, -0.01660927f, 0.09555714f, 
    -0.08993276f, -0.05703671f, 0.00588362f, -0.05279892f, 0.00430910f, 0.03903143f, 0.01364943f, 0.03082996f, 
    -0.28927165f, 0.07216985f, 0.18257309f, -0.01892847f, 0.04628028f, 0.02007935f, 0.02677579f, 0.08565520f, 
    0.00069611f, 0.03169325f, -0.15133676f, -0.04931952f, 0.10659993f, -0.00862984f, -0.07607243f, 0.13450298f, 
    -0.00029078f, -0.01134383f, 0.08542663f, -0.03608319f, 0.02067504f, -0.11634400f, -0.04946135f, -0.04083566f, 
    0.05865681f, -0.02641040f, -0.02784132f, 0.02554255f, -0.07329531f, -0.04286745f, -0.01113404f, 0.04832557f, 
    0.00331804f, -0.02711838f, -0.03157363f, 0.05533656f, 0.13564241f, 0.02821056f, 0.06589237f, 0.10624072f, 
    -0.04793631f, 0.00772538f, -0.00115979f, 0.07071394f, 0.00788471f, 0.03273953f, -0.01215732f, 0.02632350f, 
    0.08534978f, 0.13079312f, -0.05814480f, -0.01540627f, -0.14596215f, -0.08601152f, 0.03213595f, 0.03530138f, 
    0.00696481f, -0.01213320f, -0.07553909f, 0.11991226f, -0.14663084f, 0.02547100f, -0.06535566f, -0.07312198f, 
    -0.00043877f, -0.01430204f, 0.01083176f, -0.02292605f, -0.09452233f, -0.07399236f, 0.10110717f, -0.07069182f, 
    -0.11847156f, -0.15760823f, 0.06512704f, 0.13258497f, 0.01601174f, 0.05099802f, 0.02555505f, -0.07206058f, 
    -0.09380056f, 0.01527544f, 0.04211951f, -0.20198755f, 0.01320382f, 0.00508943f, -0.08635023f, 0.02205370f, 
    -0.05291540f, -0.05370262f, 0.06004050f, 0.07824658f, -0.07157863f, -0.05913291f, 0.11438090f, -0.03202765f, 
    -0.20272839f, 0.14908525f, 0.17740616f, 0.02152572f, 0.06773819f, -0.00939278f, 0.02444326f, -0.05481758f, 
    -0.04787610f, 0.02280270f, -0.01481853f, 0.03632693f, 0.13014749f, 0.05801396f, 0.05378883f, 0.10311025f, 
    0.03448356f, 0.12667263f, -0.05655714f, -0.08363419f, -0.00442179f, -0.03561996f, 0.01637247f, -0.05796783f, 
    0.08946660f, 0.03094763f, 0.02488650f, -0.01089128f, 0.03481542f, 0.03953962f, -0.05996999f, 0.00458953f, 
    0.09405144f, 0.00779704f, 0.11013494f, -0.06290185f, -0.16705804f, -0.30024260f, 0.00846248f, 0.05131920f, 
    0.08267159f, -0.07276206f, -0.00259113f, 0.06660914f, -0.03427590f, 0.10013156f, -0.08996103f, -0.05868688f, 
    0.26158693f, 0.04330586f, -0.12555252f, 0.07496633f, 0.07206563f, 0.03291110f, 0.05751993f, -0.02673454f, 
    -0.00411022f, 0.06546853f, 0.01775521f, -0.02817617f, -0.11702885f, -0.02023499f, -0.08752788f, -0.27360538f, 
    0.00877633f, 0.01838976f, 0.04258985f, -0.02501447f, -0.03224129f, -0.01222219f, 0.06196869f, -0.05039344f, 
    0.00342124f, 0.03892668f, 0.00230639f, -0.01832189f, -0.05002788f, 0.04169998f, -0.02539159f, 0.07891805f, 
    0.01049881f, -0.04231612f, 0.04414317f, 0.07185484f, 0.57316929f, 0.19715129f, 0.04011383f, 0.05276636f, 
    0.03211742f, -0.06126504f, -0.08725991f, 0.12478866f, -0.02278581f, -0.06937117f, -0.04966585f, -0.06805163f, 
    -0.03253399f, 0.26198903f, 0.15460384f, -0.14846160f, 0.03219072f, -0.03079213f, -0.03654579f, 0.04710287f, 
    0.06047106f, 0.04922906f, -0.04979949f, -0.01537981f, 0.14105426f, -0.14373127f, 0.02144063f, 0.20066074f, 
    0.11072530f, -0.09638959f, 0.06121823f, 0.08795812f, 0.05618637f, -0.03410565f, 0.01609976f, 0.00896483f, 
    0.06602554f, -0.02205535f, -0.00082053f, 0.16760409f, -0.09955635f, -0.08811166f, 0.06312257f, 0.12252516f, 
    -0.14446498f, -0.01145703f, -0.07183364f, -0.06062848f, -0.37223238f, -0.09902424f, -0.12247092f, 0.07901167f, 
    -0.01656914f, 0.02943222f, 0.00839123f, -0.08201453f, 0.05089945f, -0.10840712f, -0.03104842f, 0.03769763f, 
    -0.15663822f, -0.15989582f, -0.23459846f, -0.05507789f, -0.01178958f, -0.02126138f, 0.01010578f, -0.15434878f, 
    0.00969472f, -0.04433103f, -0.01501914f, -0.04567548f, 0.04848253f, 0.01609829f, 0.07003323f, -0.08529621f, 
    0.10971593f, -0.06721214f, -0.04391816f, 0.03256358f, -0.07871748f, -0.02316267f, -0.03394198f, -0.07109281f, 
    -0.29087654f, 0.22299047f, 0.04739133f, -0.10069127f, -0.03123029f, -0.00160830f, -0.08914309f, 0.13682458f, 
    0.08612432f, -0.06220724f, -0.03341928f, 0.02087189f, -0.15548074f, -0.06538205f, -0.20396365f, -0.00214596f, 
    -0.07302677f, 0.10896187f, -0.06301725f, 0.02242635f, 0.00102747f, 0.09431187f, -0.04045264f, 0.00980578f, 
    -0.23374738f, 0.15967880f, 0.11692297f, 0.14478289f, 0.09976201f, -0.06624923f, 0.03749473f, 0.00971396f, 
    -0.09861236f, 0.06329729f, -0.07748780f, -0.20973495f, 0.17055982f, -0.14437711f, -0.17053661f, 0.20440750f, 
    -0.14158922f, -0.04472008f, 0.07064141f, -0.02012487f, 0.06783400f, 0.00754503f, 0.08776654f, -0.01539534f, 
    -0.02588789f, 0.17028801f, 0.07117673f, -0.04118555f, -0.10869115f, -0.09931020f, -0.07756736f, -0.07091164f, 
    0.00180898f, -0.09663811f, 0.09315819f, 0.10745884f, 0.01635060f, -0.04540326f, -0.07167386f, -0.03482869f, 
    -0.12611718f, -0.07475627f, 0.02041931f, 0.00519356f, -0.15134642f, -0.01254839f, -0.06489059f, 0.01644752f, 
    0.16697718f, 0.11746208f, -0.02347087f, -0.08231872f, -0.01662749f, -0.14946921f, 0.02462664f, 0.07683780f, 
    0.02788273f, 0.00771237f, -0.05579246f, 0.05651681f, 0.05422831f, 0.00446324f, 0.04465909f, -0.01175033f, 
    -0.06661125f, 0.02625093f, 0.03174570f, -0.02385828f, 0.01569843f, -0.00308029f, -0.01965436f, -0.02761398f, 
    -0.04423001f, -0.00939346f, -0.06607325f, -0.03797987f, -0.03570969f, 0.03502161f, 0.04312906f, -0.03463450f, 
    0.01654326f, 0.08747882f, 0.07671294f, -0.06590669f, 0.07595367f, 0.08895688f, -0.00566058f, 0.03677462f, 
    -0.00690035f, 0.04893640f, 0.09535536f, -0.04165127f, 0.11078746f, -0.07849781f, 0.01397972f, 0.01251572f, 
    0.19058645f, -0.10744388f, -0.09411875f, 0.12047914f, 0.11528082f, 0.04204690f, -0.08953972f, 0.09468877f, 
    -0.07436606f, -0.03939535f, -0.01251935f, -0.02552743f, -0.31499499f, -0.28063843f, -0.11772522f, -0.00111515f, 
    -0.13504396f, -0.00741878f, 0.03801492f, -0.08164647f, -0.02001674f, -0.13482432f, 0.03939296f, -0.00287540f, 
    0.44406110f, 0.08189812f, 0.06961472f, -0.00638450f, 0.09044454f, 0.05401671f, 0.02982877f, 0.01106651f, 
    -0.07084233f, 0.08027840f, 0.10755113f, 0.01785897f, 0.14713484f, 0.03626941f, -0.01837984f, 0.02449609f, 
    -0.07060540f, -0.07917619f, -0.04505021f, -0.06155324f, -0.05462989f, 0.09638823f, -0.04839294f, -0.10686478f, 
    0.29257974f, -0.26846278f, 0.03663532f, -0.08469952f, -0.05271803f, -0.07623924f, 0.01265364f, 0.02195161f, 
    -0.03292030f, 0.02106121f, -0.09274047f, 0.02547207f, 0.23762801f, 0.23720030f, 0.06693945f, -0.00870221f, 
    -0.05608108f, 0.01058979f, 0.03411183f, 0.04390602f, -0.06905080f, 0.06382041f, -0.01114215f, 0.07213147f, 
    0.10872931f, 0.23284501f, -0.12529215f, -0.02929620f, 0.01929436f, -0.02490723f, 0.10087441f, 0.08404768f, 
    0.02963308f, -0.02937020f, -0.03398857f, -0.00148255f, -0.04369267f, 0.04438762f, -0.06680934f, 0.07093682f, 
    -0.05340068f, 0.04200364f, -0.02310861f, -0.05206382f, -0.03215606f, 0.02720975f, 0.02524734f, -0.06854340f, 
    0.28385282f, -0.29900151f, -0.09768140f, 0.11789496f, -0.04571126f, 0.13196447f, -0.02531422f, 0.06790673f, 
    0.08232640f, 0.00776749f, -0.05584807f, 0.11211296f, 0.39891273f, 0.29105565f, -0.14229371f, 0.14830762f, 
    0.04953938f, 0.09021714f, 0.17923798f, 0.18364169f, -0.04493519f, -0.09988460f, 0.03858730f, -0.02648909f, 
    -0.42916769f, -0.37523529f, -0.00000034f, -0.03675820f, -0.20210817f, -0.01816118f, -0.04684865f, -0.07320549f, 
    0.12541407f, -0.01228361f, 0.07564848f, -0.04681921f, 0.18947588f, 0.07857300f, 0.06389420f, 0.05779963f, 
    0.08393374f, -0.03716651f, 0.04206696f, -0.05437896f, 0.02551865f, -0.11764315f, -0.09788185f, -0.04272548f, 
    -0.17216301f, 0.13606885f, 0.07888916f, 0.15403417f, 0.11136127f, 0.05440518f, 0.01674101f, -0.00488818f, 
    -0.02966901f, -0.01759459f, 0.08740582f, 0.00573242f, -0.10414033f, -0.36596087f, -0.31085396f, 0.15062529f, 
    -0.03541032f, 0.02784316f, 0.04183084f, -0.04913956f, 0.03216767f, 0.11044607f, 0.00583277f, 0.03188273f, 
    -0.47139356f, -0.48948205f, -0.04343200f, 0.21035379f, -0.04930488f, -0.01859515f, 0.02282950f, -0.12084129f, 
    0.02588916f, 0.04729713f, -0.00128961f, -0.02793374f, -0.21025556f, -0.29525265f, -0.11048026f, -0.07132491f, 
    -0.08825521f, -0.06125271f, -0.05386012f, 0.07644290f, -0.06324226f, 0.08633937f, -0.10667970f, 0.00307592f, 
    -0.19749089f, 0.17272457f, 0.07254968f, 0.10167802f, -0.00233521f, -0.15136874f, 0.02799356f, 0.02630956f, 
    -0.07051257f, -0.06817377f, 0.00807330f, 0.00816753f, -0.13655463f, 0.10648579f, -0.01627143f, -0.14874938f, 
    -0.14601284f, 0.01923375f, -0.03887914f, -0.02068076f, -0.00598983f, -0.12050124f, -0.04197143f, 0.09701896f, 
    0.07894219f, -0.00707820f, 0.03788235f, -0.10115728f, -0.05965367f, 0.06061933f, -0.03562170f, 0.08551040f, 
    -0.02149125f, -0.06046560f, 0.10151963f, 0.01745055f, 0.10271178f, -0.04019146f, -0.00375226f, 0.00151050f, 
    -0.00403543f, -0.09883808f, -0.01487549f, -0.03100586f, -0.02579302f, -0.06011834f, -0.01422034f, -0.11347075f, 
    -0.35142747f, 0.00593737f, -0.17060743f, -0.05764753f, -0.07101849f, -0.01456720f, -0.03541171f, 0.02327085f, 
    -0.03845183f, -0.06436647f, 0.11238030f, 0.01206538f, -0.52650148f, -0.37003756f, -0.25332856f, 0.07857654f, 
    -0.14905299f, 0.01430870f, -0.00473697f, 0.01290589f, -0.04979357f, 0.01133973f, 0.10222615f, 0.04371919f, 
    -0.11478183f, 0.12267272f, -0.04738986f, -0.00173654f, 0.10359041f, 0.01112161f, 0.00828524f, -0.07077884f, 
    -0.11422466f, -0.06912702f, -0.01028585f, -0.02492077f, -0.24220482f, 0.05720253f, -0.00565772f, 0.08111914f, 
    -0.01025734f, -0.14915694f, -0.02595556f, 0.05647561f, -0.10628350f, 0.07808705f, 0.08983548f, 0.04080812f, 
    -0.01955516f, 0.12164916f, 0.15390456f, 0.10198594f, 0.05841224f, 0.02005020f, 0.00166747f, 0.00549088f, 
    0.07529942f, -0.01067904f, -0.02579564f, 0.02003431f, -0.35003459f, 0.27395889f, 0.15399699f, -0.03657598f, 
    0.03974812f, 0.08126309f, -0.04565889f, 0.04742482f, -0.05131093f, -0.00800961f, 0.15694961f, 0.08033165f, 
    0.03826937f, 0.07700978f, 0.05155503f, 0.11951690f, -0.13971893f, -0.05345111f, -0.04539965f, -0.00901998f, 
    0.04024605f, -0.04464741f, -0.05730534f, -0.04381785f, -0.33619541f, -0.02372549f, -0.20358846f, -0.16757363f, 
    0.08300209f, -0.06131434f, -0.03449788f, 0.07955561f, -0.02615243f, -0.11054146f, -0.03444432f, 0.08169810f, 
    -0.14962272f, -0.05809920f, 0.06059625f, -0.25318167f, -0.03495979f, 0.11081500f, 0.07522898f, 0.01876404f, 
    0.06009417f, 0.10468754f, -0.04689819f, -0.03589338f, 0.02678896f, -0.28091305f, -0.26437819f, 0.06571141f, 
    -0.01517017f, -0.02398981f, 0.07862649f, -0.19213444f, 0.02542361f, -0.06645579f, 0.07571365f, 0.05610215f, 
    -0.31005538f, 0.01409953f, 0.23767135f, -0.17721239f, 0.04688515f, 0.07520363f, -0.14723369f, 0.02055635f, 
    0.09793772f, 0.02404672f, -0.05301551f, -0.01701174f, 0.11110296f, -0.02128592f, 0.07957824f, 0.03227198f, 
    0.04652221f, -0.04028518f, 0.06625389f, 0.13953923f, 0.02346843f, -0.01698853f, 0.02418650f, 0.18214144f, 
    -0.15834780f, -0.13502136f, 0.30557188f, 0.05251912f, -0.08508378f, -0.03204145f, 0.01922434f, 0.01801887f, 
    0.10820442f, -0.05814856f, -0.11005536f, -0.07774651f, 0.06925090f, 0.03505291f, 0.04967523f, 0.06782399f, 
    -0.15923755f, 0.10695560f, 0.02855349f, 0.01204560f, -0.01623814f, -0.09700436f, -0.09337859f, -0.06719928f, 
    -0.02836570f, -0.00385646f, -0.08072352f, -0.02025101f, 0.05088063f, 0.08272959f, 0.01089659f, 0.10560895f, 
    -0.02072066f, -0.15475745f, -0.07012279f, -0.01058083f, -0.22166598f, 0.04916076f, 0.11063025f, -0.16309391f, 
    0.10201953f, -0.07275818f, -0.00455819f, -0.05488302f, 0.01751434f, -0.00371475f, 0.04113314f, 0.10504851f, 
    -0.30372420f, 0.06182009f, 0.05971703f, -0.10650226f, 0.02572139f, -0.04571633f, -0.01139890f, -0.04147698f, 
    0.01412662f, -0.03726295f, -0.06078593f, 0.05370596f, -0.16303290f, 0.06122738f, 0.09637211f, 0.26688853f, 
    0.06376322f, 0.09387827f, -0.02981969f, 0.02012048f, 0.03637804f, 0.02885675f, -0.02003730f, 0.02058458f, 
    -0.16780478f, 0.02862658f, 0.17142805f, 0.07453218f, 0.08851173f, -0.00103106f, -0.00306118f, -0.07420754f, 
    0.08653696f, 0.06252339f, -0.07693254f, -0.07688390f, -0.04850752f, -0.00569088f, -0.15266572f, 0.18860248f, 
    -0.03689874f, -0.05339653f, 0.04702158f, 0.06395040f, -0.02812612f, -0.16387445f, 0.00985696f, 0.00167256f, 
    -0.22133812f, -0.13389927f, 0.10706636f, 0.01043845f, 0.13264668f, 0.07146660f, -0.08008157f, 0.02954568f, 
    0.04392951f, -0.09979881f, -0.09544562f, 0.02202162f, -0.12095112f, -0.05183709f, 0.00718499f, 0.10981061f, 
    -0.01977123f, 0.03190176f, -0.07350023f, -0.06944174f, -0.00187598f, -0.04306745f, 0.08261297f, 0.00888260f, 
    -0.03031695f, -0.07068507f, 0.01569911f, 0.01217040f, 0.05909967f, -0.06973004f, -0.08399121f, -0.19839048f, 
    -0.12011290f, -0.06234996f, -0.03404771f, -0.07833396f, -0.12626450f, 0.08835939f, -0.03696231f, -0.07324947f, 
    0.02711651f, -0.00505692f, -0.08752622f, -0.01868595f, -0.06676536f, -0.11374919f, 0.05462522f, -0.03754655f, 
    -0.13542347f, 0.12231376f, -0.11102052f, -0.33269531f, -0.02320974f, -0.03832715f, 0.11552723f, -0.05193761f, 
    0.08691978f, -0.09373803f, 0.00525696f, 0.06881392f, -0.62907404f, -0.08987057f, -0.00552789f, 0.21717566f, 
    0.01690514f, -0.01904500f, -0.06840985f, -0.03162546f, -0.02665559f, 0.04875636f, 0.03766659f, -0.03842530f, 
    0.17096217f, -0.01647755f, -0.02688592f, -0.07135138f, 0.06954201f, 0.09080245f, 0.06055342f, -0.06617722f, 
    -0.01478001f, 0.04786164f, 0.01372541f, 0.01343560f, 0.34116203f, 0.07120293f, -0.04376202f, -0.13622133f, 
    0.01330120f, -0.14766943f, 0.02497248f, 0.00715995f, 0.00119648f, 0.01052015f, 0.01065183f, -0.11010425f, 
    0.19029364f, 0.22306342f, -0.04342391f, -0.10864981f, 0.08743762f, 0.09856953f, 0.04792829f, -0.06339652f, 
    -0.01391680f, 0.06638034f, -0.04056606f, 0.13614722f, 0.31967682f, 0.13447104f, -0.01446982f, -0.48885104f, 
    -0.00052327f, 0.02629406f, 0.05023370f, 0.16528298f, 0.00736502f, 0.03879974f, 0.02267948f, 0.02949389f, 
    0.07055490f, -0.04694016f, 0.06288105f, 0.10380126f, 0.10933924f, 0.09721797f, 0.11257938f, 0.00152411f, 
    -0.06704941f, -0.04075051f, 0.03355644f, -0.00822103f, -0.11643469f, -0.14189322f, -0.05680615f, 0.03211275f, 
    -0.05310920f, -0.00481118f, 0.01311039f, 0.06046765f, 0.06019183f, -0.03249037f, -0.05682127f, -0.01322531f, 
    -0.10651118f, -0.05940735f, -0.10523862f, 0.03494018f, -0.00051524f, -0.07678146f, 0.02967574f, -0.03959526f, 
    0.06538470f, 0.01123202f, -0.05134268f, 0.02917152f, -0.09543753f, 0.09834599f, 0.06335007f, -0.13803893f, 
    0.06029782f, -0.06565742f, -0.03022808f, 0.07156976f, -0.02697780f, -0.03099504f, -0.07228252f, -0.00305869f, 
    -0.05600028f, 0.09953132f, -0.02095714f, 0.00940892f, -0.07580282f, -0.04371104f, 0.03383407f, -0.07497525f, 
    -0.04930116f, -0.00903037f, -0.00609234f, 0.06668824f, -0.14922789f, -0.08523861f, 0.07093195f, -0.11591460f, 
    0.06673159f, 0.05492378f, -0.01952298f, -0.04699966f, 0.05165499f, 0.07121114f, 0.00987423f, 0.00187407f, 
    -0.24835777f, -0.10618465f, 0.07874661f, 0.17613642f, -0.06548265f, -0.16431329f, 0.07921571f, -0.00239935f, 
    -0.07095768f, 0.00408886f, 0.00430407f, -0.17012353f, -0.05672804f, 0.18933529f, -0.13489582f, -0.05038968f, 
    -0.16442801f, 0.17673016f, 0.04339350f, 0.05930150f, -0.01220433f, 0.04491498f, 0.04192805f, 0.09745085f, 
    0.21658468f, 0.15117745f, 0.07921376f, 0.04457166f, -0.06568941f, -0.07520308f, -0.13096920f, -0.08383800f, 
    0.12304079f, -0.14237329f, 0.03858316f, 0.03514310f, -0.35906318f, 0.20284306f, 0.19402489f, 0.19904351f, 
    0.00641761f, 0.11865062f, -0.02632828f, 0.05430525f, 0.00981181f, 0.00610202f, 0.03944165f, -0.04461297f, 
    0.00831412f, -0.08775735f, 0.02774768f, 0.06194275f, 0.08616205f, 0.03884651f, -0.12115179f, 0.10488289f, 
    -0.05204185f, -0.09678961f, -0.00682962f, 0.08671745f, -0.00431021f, 0.00771148f, -0.10401448f, -0.12082903f, 
    -0.03065244f, -0.00540996f, 0.07524134f, 0.11692499f, 0.12277270f, -0.07115366f, 0.11630777f, 0.01079860f, 
    0.18840723f, 0.04300014f, -0.07338378f, 0.02196479f, 0.04909273f, 0.04382760f, 0.08486941f, 0.03703958f, 
    -0.08504807f, -0.09550221f, -0.00881543f, 0.00755512f, -0.01885087f, 0.02981837f, -0.02318384f, 0.12896857f, 
    -0.07080328f, -0.03828174f, 0.09543721f, 0.13643728f, -0.05352996f, -0.01757510f, -0.05948039f, -0.11008918f, 
    -0.07817288f, 0.25543129f, 0.15747072f, -0.04155953f, -0.04523883f, 0.07080492f, -0.04617610f, -0.08858277f, 
    0.00206187f, -0.12275220f, 0.03891326f, 0.06344099f, 0.24089605f, -0.10895535f, 0.01068249f, 0.09513610f, 
    -0.14561941f, -0.09685351f, -0.01575201f, 0.07822359f, 0.06717571f, 0.14702943f, -0.02244505f, -0.16214392f, 
    0.19373441f, 0.09487459f, 0.04435657f, 0.18056095f, -0.01731661f, -0.07715339f, 0.04982460f, 0.09227533f, 
    0.01242450f, 0.00228396f, 0.09456437f, 0.16975848f, -0.15772335f, -0.05024799f, -0.11999141f, 0.22003753f, 
    0.09430940f, -0.15173326f, 0.10048202f, 0.07952575f, -0.13997872f, -0.00806201f, 0.03985699f, 0.00667590f, 
    -0.22500235f, 0.12607835f, -0.32273018f, -0.06530747f, -0.00407685f, -0.00580458f, -0.02034129f, 0.09503574f, 
    -0.01514915f, 0.02428307f, -0.05114750f, -0.10293584f, -0.11397550f, -0.13920577f, 0.05015431f, -0.06285372f, 
    0.13549289f, 0.03806622f, 0.11793157f, -0.06601842f, -0.05406222f, -0.08093385f, 0.07404493f, 0.02945373f, 
    0.26285982f, 0.03933814f, -0.05684115f, -0.04707542f, -0.02564249f, -0.08833125f, -0.01997575f, -0.10805792f, 
    0.04371430f, -0.22902866f, 0.10409196f, -0.02668208f, -0.37061492f, 0.03335273f, -0.06521006f, 0.09022410f, 
    0.02086219f, 0.01364611f, -0.00179714f, -0.00572210f, -0.02429029f, -0.01328273f, 0.02275884f, 0.07503378f, 
    0.08707976f, -0.26896760f, -0.07529604f, 0.02483285f, -0.27691394f, -0.00858439f, 0.10799313f, -0.29894471f, 
    -0.03594883f, 0.06031769f, 0.09048222f, -0.14765851f, -0.00956078f, -0.22748123f, 0.11550650f, -0.23789793f, 
    0.01556152f, 0.24182247f, 0.02725958f, 0.05123766f, -0.00167532f, -0.02282273f, 0.08081699f, -0.01693523f, 
    0.18992127f, -0.01783844f, -0.08698064f, 0.22330284f, -0.06280331f, -0.00557543f, 0.07069743f, 0.08762956f, 
    -0.02138227f, -0.00572718f, 0.00798814f, 0.13634337f, -0.12491457f, 0.12153185f, -0.17696211f, -0.08298638f, 
    0.10882457f, -0.13702050f, -0.06457988f, -0.02222093f, 0.04450526f, 0.03339613f, -0.02597924f, -0.09748603f, 
    0.04697000f, 0.12971628f, -0.01933476f, -0.04986739f, -0.08305563f, -0.07160459f, 0.07081913f, -0.14016981f, 
    0.03975873f, 0.05464596f, -0.04962893f, -0.01346012f, -0.09828352f, -0.24226139f, 0.19971898f, 0.00035020f, 
    -0.06349792f, 0.04104488f, -0.06323507f, -0.01902795f, 0.10674819f, 0.05770218f, -0.00696999f, 0.01172061f, 
    -0.24399573f, 0.10646439f, 0.00931384f, 0.03929587f, 0.10652712f, -0.10584142f, -0.08588813f, 0.01496780f, 
    0.05581431f, -0.10886283f, -0.05931542f, -0.06735527f, 0.05253816f, -0.31728122f, -0.00275238f, -0.02132659f, 
    -0.11048305f, -0.00624997f, -0.01096969f, 0.03290390f, 0.02979780f, 0.15466906f, 0.08915777f, 0.07800978f, 
    -0.24235907f, 0.21790668f, -0.12580426f, -0.02946056f, -0.11666054f, 0.01403781f, 0.07880892f, 0.04306066f, 
    0.03057098f, -0.13970248f, 0.02665269f, -0.02029477f, 0.05339226f, 0.01925456f, 0.24043369f, 0.15403427f, 
    0.03382747f, 0.03228015f, 0.12268724f, 0.08854665f, -0.06151247f, 0.07490868f, 0.06699730f, 0.07083635f, 
    0.19995818f, -0.00383803f, 0.08027586f, -0.04957639f, -0.01133294f, -0.03339230f, 0.02127475f, -0.11951455f, 
    0.06767733f, 0.06091810f, 0.04627183f, 0.04961713f, -0.76424533f, -0.01438060f, -0.10073631f, -0.05366204f, 
    0.03227857f, -0.09707913f, -0.00968529f, 0.11160766f, -0.01346413f, -0.07287611f, -0.04477224f, 0.06895664f, 
    -0.31313249f, -0.15032691f, 0.14843063f, -0.11590666f, -0.12207790f, -0.01466648f, -0.02056543f, -0.08179118f, 
    0.08875353f, -0.03931150f, 0.06186153f, -0.12557644f, 0.05707661f, 0.18917395f, 0.11939668f, -0.05717695f, 
    0.06335372f, 0.08407442f, 0.02942867f, 0.08224595f, 0.05172591f, 0.00342670f, -0.04034736f, -0.04487911f, 
    -0.06491432f, 0.02821606f, 0.13232806f, -0.10953846f, -0.04644871f, -0.10668146f, -0.16069919f, 0.13906452f, 
    0.18451504f, -0.13817926f, 0.10495515f, -0.09168683f, 0.14978416f, -0.03124658f, -0.04256198f, -0.15632632f, 
    0.00034485f, 0.08802471f, -0.06744816f, 0.00944102f, -0.13942127f, 0.00987088f, 0.04838389f, 0.05082575f, 
    0.00575217f, -0.06958235f, -0.06520545f, -0.01542701f, -0.05637978f, -0.20427899f, -0.08821562f, -0.01423736f, 
    -0.00486722f, 0.03900952f, 0.04139678f, 0.17026480f, -0.00666302f, -0.10267795f, 0.10863533f, 0.27685466f, 
    -0.15375055f, 0.07510202f, 0.16094002f, -0.00428530f, -0.06645618f, 0.00981450f, 0.01722629f, 0.16451953f, 
    0.08418536f, 0.01235937f, 0.03605614f, -0.01079532f, 0.04348630f, 0.06982279f, -0.00228087f, 0.02071193f, 
    0.05944519f, 0.07458948f, 0.01998798f, 0.07358637f, -0.58505076f, -0.17243841f, -0.18359007f, -0.17674816f, 
    0.05982193f, 0.05926657f, 0.02739706f, -0.01224178f, 0.02423343f, 0.09931314f, 0.08322240f, -0.05442818f, 
    -0.32305789f, -0.00303554f, 0.06688123f, 0.18591230f, 0.03415832f, -0.11517666f, -0.13168937f, 0.14245929f, 
    0.05659324f, -0.03051573f, 0.04126673f, 0.09083787f, 0.15404281f, 0.09491254f, 0.12042806f, -0.16607037f, 
    0.03430957f, -0.01342367f, -0.16494679f, 0.02048224f, 0.05960395f, -0.05144367f, -0.11896083f, -0.03526222f, 
    -0.26743469f, 0.07162651f, -0.01590953f, 0.07808977f, -0.17818721f, -0.08307543f, 0.09201347f, -0.00534802f, 
    0.10145243f, -0.01926158f, 0.05331084f, 0.07046361f, -0.13410708f, -0.19758858f, -0.03791435f, -0.02716314f, 
    0.04496044f, 0.18686029f, -0.02950000f, -0.11635637f, 0.10680583f, 0.02633190f, -0.05209932f, -0.02021885f, 
    0.08909025f, 0.07406481f, 0.05183304f, 0.00680016f, 0.05805226f, 0.00577541f, 0.12561581f, -0.00129075f, 
    0.09470668f, -0.20911801f, 0.08588061f, 0.15700871f, 0.06171412f, 0.00892129f, 0.10684272f, -0.32343978f, 
    -0.01222414f, -0.06211461f, 0.02089297f, -0.04694188f, -0.01941218f, -0.01010963f, 0.05166707f, 0.21168154f, 
    -0.22256659f, -0.23918459f, -0.11258480f, 0.02251874f, 0.01475686f, 0.12852012f, -0.06571189f, 0.05802854f, 
    0.03449765f, 0.18582712f, 0.10933594f, -0.00108641f, -0.00028980f, 0.09988994f, 0.11990483f, 0.23156646f, 
    -0.14124496f, 0.09832371f, 0.07923304f, 0.08481497f, -0.11474358f, -0.00382374f, 0.04885509f, -0.07011548f, 
    -0.45731452f, -0.09344706f, -0.04341929f, -0.07495447f, 0.00992724f, -0.02778632f, -0.15347545f, 0.02268239f, 
    -0.09985945f, 0.13919027f, 0.13644494f, 0.06789291f, 0.15382259f, 0.13841021f, -0.21501569f, -0.18211725f, 
    -0.00258172f, -0.06271379f, -0.04942010f, -0.06966343f, 0.07771084f, 0.03490091f, -0.00507440f, -0.08598027f, 
    -0.02128544f, -0.06340353f, -0.03542852f, -0.03778171f, -0.00833542f, 0.05841684f, -0.02640613f, -0.03860618f, 
    0.04735433f, 0.05753574f, 0.08481147f, 0.15933251f, -0.10981280f, 0.01794808f, -0.11945274f, -0.11355870f, 
    0.11985745f, 0.13858461f, 0.08598649f, -0.09504429f, 0.03963958f, 0.14676943f, -0.14646204f, -0.05405776f, 
    0.19380973f, 0.07229374f, 0.04333395f, 0.11636218f, -0.06457709f, -0.14301750f, -0.04957338f, -0.03060268f, 
    -0.02617781f, -0.19192582f, 0.07095748f, -0.02623446f, 0.00616247f, -0.08943112f, -0.07030320f, -0.02665502f, 
    0.05701839f, 0.00575965f, -0.01217391f, 0.12754366f, 0.07449537f, 0.01120810f, 0.02490917f, 0.02086255f, 
    0.08111356f, 0.00491597f, 0.09615295f, 0.10220079f, 0.02722104f, 0.06280494f, 0.02926762f, 0.13410872f, 
    -0.02328072f, 0.14293750f, 0.05520279f, 0.06193642f, -0.14540122f, 0.14361024f, 0.03569721f, 0.04335464f, 
    -0.03877725f, -0.00114380f, 0.01144590f, 0.04274116f, 0.00227405f, 0.01346079f, 0.14375147f, 0.09580916f, 
    -0.14058927f, -0.07369230f, 0.15366894f, -0.33071738f, -0.05563002f, 0.04979321f, -0.01544895f, -0.00632285f, 
    -0.02860894f, 0.07444098f, -0.03146775f, 0.01137982f, 0.04868881f, 0.22764055f, -0.18444063f, -0.06028273f, 
    -0.00081675f, 0.03532908f, -0.02871046f, -0.09092310f, -0.07392208f, -0.17815636f, -0.00225596f, -0.14808221f, 
    0.05017075f, -0.03072559f, 0.05683275f, 0.08107479f, 0.10835743f, -0.02369237f, 0.05244904f, 0.07908081f, 
    -0.07374047f, -0.02109740f, 0.00515575f, -0.14205101f, -0.35290161f, -0.19432954f, 0.13252157f, 0.24417529f, 
    -0.07188941f, 0.07783344f, 0.05480444f, -0.06457153f, 0.01557402f, -0.04882390f, -0.04367090f, 0.04070324f, 
    -0.23394604f, -0.27915844f, 0.01260585f, 0.25979570f, 0.00854181f, -0.13372546f, -0.05966451f, 0.05347077f, 
    -0.02112580f, 0.07851299f, -0.12194788f, -0.15954582f, -0.37300852f, -0.23967829f, 0.28468582f, 0.09456565f, 
    0.12821168f, -0.05548581f, -0.06311578f, -0.12669742f, -0.03482428f, -0.03099823f, 0.05172233f, 0.01474025f, 
    -0.16206586f, 0.14224237f, 0.06102564f, 0.19555396f, -0.05485513f, -0.08158465f, 0.00663059f, 0.04968662f, 
    0.11940362f, 0.04661313f, 0.04421474f, 0.13563241f, 0.01743741f, 0.05297302f, 0.02630643f, -0.09745228f, 
    -0.01608775f, 0.16498297f, 0.08423853f, -0.03568232f, 0.03198292f, 0.03115438f, 0.05601719f, 0.11812256f, 
    -0.01102653f, -0.03555736f, -0.10083321f, -0.09995219f, 0.05787183f, 0.04101433f, -0.03137587f, 0.02882576f, 
    -0.00892270f, -0.11661748f, -0.00179021f, -0.03822735f, -0.16925994f, -0.06600907f, 0.05324473f, 0.04165752f, 
    0.01139582f, -0.00520127f, -0.00085276f, -0.06250931f, -0.05115042f, 0.00702399f, 0.00151629f, 0.10755866f, 
    -0.22616191f, -0.15752143f, 0.07282238f, 0.04014788f, 0.11798939f, -0.03296101f, -0.03741873f, -0.22002682f, 
    -0.00451891f, 0.03411346f, -0.07425343f, 0.04551753f, 0.16553584f, -0.05924594f, -0.12121675f, 0.03827379f, 
    0.06917766f, -0.24138145f, -0.08842687f, -0.08892718f, 0.09437026f, -0.04180406f, -0.07967856f, 0.00732872f, 
    0.10891014f, 0.11944897f, 0.06925114f, -0.02313367f, 0.00266736f, -0.01444828f, -0.02241598f, 0.09000561f, 
    -0.04857408f, -0.05222591f, -0.06593294f, 0.23309781f, 0.06213536f, -0.01438094f, 0.17280886f, 0.00417486f, 
    0.13065945f, -0.06103045f, -0.01072007f, -0.06905543f, -0.07652740f, -0.01249972f, 0.01869188f, -0.01945727f, 
    0.07420187f, -0.03545987f, 0.12338429f, -0.14235169f, 0.10768595f, 0.00754898f, 0.00122642f, -0.06696402f, 
    0.01837806f, 0.07208986f, 0.02082280f, 0.08394716f, -0.23152231f, -0.20804915f, -0.18252978f, 0.03484009f, 
    0.01925225f, 0.00558516f, -0.03162459f, -0.06975907f, 0.10653087f, -0.01514232f, -0.10181087f, 0.05572640f, 
    0.06498310f, 0.04116919f, -0.16790566f, 0.18385963f, 0.13391840f, 0.16512503f, -0.06279703f, 0.17785133f, 
    0.04786221f, 0.03421600f, 0.07028641f, -0.36952576f, -0.12055311f, 0.10894475f, -0.08156246f, -0.33506200f, 
    -0.03565679f, 0.03945211f, 0.08698524f, -0.12462916f, 0.08687365f, 0.07617486f, -0.01567596f, -0.00579241f, 
    -0.03952167f, 0.10946942f, 0.06818129f, -0.39909056f, -0.13938797f, -0.10185092f, 0.01689112f, 0.05555046f, 
    0.10851149f, -0.04801466f, -0.22884624f, -0.07750294f, -0.01819206f, 0.15666756f, -0.08797491f, -0.04535401f, 
    0.04797633f, 0.04768229f, 0.02217104f, -0.17030551f, 0.00688380f, -0.03915974f, -0.12660494f, 0.08739454f, 
    -0.04213746f, -0.15067546f, 0.01603090f, 0.00938993f, -0.13406587f, -0.16385719f, -0.03884592f, -0.00669217f, 
    0.05552932f, -0.03029181f, 0.04563099f, -0.12880298f, 0.10674015f, 0.07777119f, 0.10206821f, -0.14808381f, 
    0.02386517f, -0.03738598f, 0.01521201f, -0.02390608f, -0.05789915f, -0.06223249f, -0.07880303f, 0.14555892f, 
    0.13071775f, -0.15186712f, 0.18790227f, 0.19232063f, 0.15160707f, -0.00170474f, 0.02058226f, 0.09910513f, 
    0.03046441f, -0.00321253f, -0.23462625f, -0.10484010f, -0.15035376f, -0.03554463f, -0.15716751f, -0.13237484f, 
    0.04665632f, 0.29982841f, 0.05347148f, -0.04237260f, -0.01176099f, -0.07816126f, 0.05775352f, -0.13010959f, 
    -0.16305248f, 0.05731708f, 0.18659979f, -0.06539915f, 0.19417244f, -0.02662332f, 0.00299157f, -0.02032052f, 
    -0.16384964f, -0.03698394f, 0.01608383f, -0.03711934f, -0.26122513f, -0.06395810f, 0.22688262f, 0.06392416f, 
    -0.23194006f, 0.12501761f, 0.13015811f, 0.20389034f, -0.08923727f, -0.04795741f, 0.06089475f, -0.10919414f, 
    0.04120985f, 0.04208911f, 0.13769196f, 0.23606578f, -0.02743519f, 0.10195087f, 0.02545397f, -0.03077910f, 
    0.14826672f, 0.05766615f, 0.09475376f, 0.19968009f, -0.11927643f, 0.19643506f, -0.09460167f, -0.29698786f, 
    0.03410520f, 0.00391184f, 0.05453528f, -0.08307524f, -0.00493806f, -0.17980367f, -0.13551955f, -0.20366605f, 
    0.12912193f, 0.17657940f, 0.13681161f, 0.05659875f, 0.09423026f, -0.10970149f, -0.04858135f, 0.06410217f, 
    -0.03896310f, -0.05065812f, 0.01006875f, -0.09515650f, -0.16435616f, 0.23502006f, 0.15601587f, -0.15872408f, 
    -0.02414156f, -0.01537091f, 0.00809780f, 0.02090443f, -0.03677860f, 0.05247955f, -0.05304967f, -0.09159807f, 
    0.13199317f, 0.18062557f, 0.14882714f, -0.03913882f, -0.04723618f, -0.13616951f, -0.03052834f, -0.04621954f, 
    -0.12200933f, -0.18913895f, 0.10116768f, -0.13591465f, -0.13185552f, -0.11324625f, 0.02533048f, -0.00705125f, 
    0.02359356f, 0.06022965f, -0.01287958f, -0.07475720f, -0.00545321f, -0.06122315f, -0.01372944f, 0.10176753f, 
    0.09592200f, 0.01974679f, -0.00414145f, 0.01214486f, -0.08384701f, -0.20223080f, -0.00107494f, -0.03696209f, 
    0.03443982f, 0.06994429f, -0.05195350f, 0.19516830f, 0.11472735f, 0.06507900f, -0.06937148f, 0.01786594f, 
    0.01023801f, -0.02257233f, -0.06261948f, 0.04143523f, 0.02818826f, -0.05760112f, -0.05327876f, -0.04114394f, 
    -0.02967057f, -0.06560412f, 0.23767200f, 0.18610395f, 0.07094343f, 0.04853329f, -0.04578349f, 0.03936565f, 
    -0.01735510f, 0.10269785f, -0.08238214f, 0.01304614f, 0.14902401f, 0.07119351f, 0.01625298f, 0.08101785f, 
    0.11553032f, -0.00540703f, 0.04735188f, -0.12036155f, -0.02969123f, -0.13965821f, 0.03246479f, 0.05532607f, 
    -0.10575670f, -0.02436452f, -0.00521358f, -0.01148861f, 0.06062914f, 0.06421161f, -0.05771804f, -0.10710594f, 
    0.05112777f, -0.01850305f, 0.03964802f, 0.04210771f, -0.22881383f, -0.17092949f, -0.29255319f, -0.02836996f, 
    0.09999469f, 0.06630360f, -0.18906590f, -0.21858628f, 0.10352238f, -0.22367170f, 0.19347912f, -0.00192683f, 
    0.02067796f, -0.04031123f, 0.03184376f, 0.17024381f, 0.00898972f, -0.08939223f, -0.10761693f, -0.14837530f, 
    -0.06463933f, 0.01790502f, -0.01472635f, -0.14397281f, -0.73574567f, 0.17089471f, -0.06732585f, -0.18004327f, 
    0.11754075f, 0.07485836f, 0.08607294f, -0.08836849f, -0.05183394f, 0.05436391f, -0.14498346f, -0.02716093f, 
    0.02649463f, -0.02100476f, 0.04521175f, -0.05431357f, -0.11650246f, 0.01857449f, 0.05757384f, 0.01099577f, 
    -0.00891813f, -0.00434513f, 0.19356668f, 0.00765803f, -0.12103439f, -0.06124502f, 0.05084320f, 0.11997995f, 
    -0.01098400f, 0.02235577f, 0.06040118f, -0.01305102f, -0.11311936f, -0.06446580f, 0.05453328f, 0.06615367f, 
    0.27965617f, -0.08967502f, 0.07629441f, -0.11913788f, -0.06246049f, -0.06496412f, 0.02602009f, 0.09240150f, 
    -0.09122778f, 0.13121340f, 0.00461914f, 0.18233956f, -0.09793415f, 0.00626498f, -0.06353112f, 0.14927141f, 
    -0.07645547f, -0.06226029f, 0.09286154f, -0.14417236f, 0.14437650f, -0.07230192f, -0.00595421f, 0.04118064f, 
    0.11010801f, 0.01008573f, 0.03639911f, -0.36427215f, 0.02823741f, 0.11624422f, 0.09297263f, 0.01035299f, 
    -0.04786056f, 0.01465105f, -0.07604138f, -0.13070913f, 0.15001446f, -0.04177102f, -0.07557169f, -0.27599728f, 
    0.03189076f, -0.05661227f, 0.01249005f, 0.09109584f, 0.01132340f, -0.06342904f, 0.04349462f, -0.09977702f, 
    -0.19277519f, 0.20057629f, 0.02363177f, -0.24263310f, 0.02074715f, 0.04657190f, -0.00831951f, 0.04400551f, 
    -0.00939467f, 0.06262760f, 0.01812144f, -0.02782792f, 0.04707088f, -0.12955764f, 0.12755184f, -0.04850099f, 
    0.07534684f, -0.00000654f, 0.04601061f, -0.20785877f, 0.09613644f, -0.05426655f, 0.17502065f, 0.05983456f, 
    0.47390449f, -0.09177352f, 0.20615405f, -0.11202125f, 0.03874317f, -0.09086750f, 0.16572738f, 0.02454972f, 
    0.03068759f, 0.01637701f, 0.03438753f, -0.10655670f, -0.24523216f, -0.14325771f, -0.07455774f, 0.01954930f, 
    0.02916738f, 0.04922451f, 0.08040608f, 0.01406475f, 0.01991272f, 0.05359215f, 0.05706526f, 0.01273761f, 
    0.06674983f, 0.09111271f, -0.17235939f, 0.16521789f, -0.00854829f, 0.09315635f, 0.02168907f, -0.12295852f, 
    -0.13317835f, -0.01618368f, 0.09231456f, -0.03990066f, -0.03302746f, -0.00235060f, -0.15458454f, -0.05071589f, 
    -0.05542322f, -0.05587495f, -0.07689369f, -0.10715431f, -0.01489165f, 0.14339100f, 0.13133308f, -0.00579670f, 
    -0.08801548f, -0.01868710f, -0.02465167f, -0.00162511f, 0.01841947f, -0.03890834f, -0.08482586f, 0.08450053f, 
    -0.07930733f, 0.06378125f, -0.24749921f, -0.04890832f, 0.01797096f, 0.18864518f, -0.04233868f, -0.00424967f, 
    -0.09074333f, 0.03355733f, -0.05210949f, -0.05790606f, 0.04433706f, -0.06965666f, -0.05619252f, -0.11354820f, 
    -0.06634872f, 0.07070047f, -0.02143251f, -0.09937825f, -0.02225020f, -0.01882570f, 0.01199668f, -0.06577899f, 
    -0.11502495f, 0.03379922f, -0.06090106f, -0.07932378f, 0.10510606f, -0.06341243f, -0.04188139f, -0.14392322f, 
    -0.00600489f, -0.05276832f, -0.05774613f, -0.03670629f, -0.03097416f, -0.04697174f, 0.01412644f, 0.04249237f, 
    0.01135270f, 0.00807429f, 0.03670149f, -0.06652175f, -0.10380567f, 0.05683884f, 0.11540177f, 0.15125027f, 
    0.02130373f, 0.10685026f, -0.08815651f, -0.05665995f, -0.10926674f, -0.17769293f, -0.16020307f, 0.08542120f, 
    0.06147660f, 0.09091599f, -0.00804617f, -0.00040973f, -0.01784774f, 0.00114843f, 0.12077297f, 0.05257279f, 
    0.25444803f, 0.22273016f, 0.11450606f, -0.37324134f, -0.09129722f, 0.07511340f, 0.09225403f, 0.01681881f, 
    -0.09516875f, 0.04881898f, -0.09713351f, -0.02098013f, -0.14076856f, 0.01537190f, 0.00440307f, -0.22750625f, 
    -0.05089679f, -0.10619795f, -0.02666749f, -0.01689894f, 0.00809834f, -0.09746334f, 0.08228123f, -0.01507538f, 
    0.05899647f, -0.02238077f, 0.04680435f, -0.33881998f, 0.08064228f, -0.10209575f, 0.02092163f, 0.00536406f, 
    0.07229601f, 0.14085369f, -0.12826738f, 0.06068515f, 0.12522678f, 0.15151916f, 0.10361033f, -0.14096616f, 
    0.00695217f, -0.04071743f, -0.00515093f, -0.02936668f, -0.00991832f, -0.06750373f, -0.05380449f, 0.09351934f, 
    -0.07013412f, 0.04338988f, -0.04088616f, -0.11513745f, 0.02200643f, -0.01285817f, 0.05761367f, 0.00351705f, 
    0.03219536f, -0.07661538f, 0.07564332f, -0.07786969f, 0.19592622f, -0.08641946f, 0.09940532f, -0.19931602f, 
    -0.00952113f, -0.03425632f, 0.04091722f, -0.02255621f, -0.01387637f, -0.03985615f, -0.08267893f, 0.01780836f, 
    0.25598377f, -0.24236955f, -0.09151135f, 0.10254885f, -0.08941992f, 0.11385277f, 0.01973396f, 0.05373679f, 
    0.11902840f, -0.01064370f, -0.02940369f, 0.01580061f, 0.11853926f, -0.16958223f, 0.02266224f, -0.05716897f, 
    -0.09372211f, 0.02415927f, -0.01604440f, 0.00984151f, 0.00581732f, 0.04532031f, 0.00308209f, 0.18160513f, 
    -0.18316086f, 0.02962960f, -0.00093935f, 0.02311047f, 0.02317170f, -0.06876747f, 0.04609875f, -0.09470551f, 
    -0.07303923f, 0.15477268f, -0.01316786f, -0.02088796f, 0.04141374f, -0.06027616f, -0.07100067f, 0.15870486f, 
    0.03672367f, 0.02872371f, -0.04595894f, -0.00185009f, -0.16471082f, 0.07539490f, 0.00322682f, -0.02200931f, 
    0.25257635f, -0.27409336f, -0.16525620f, 0.19564836f, -0.07282718f, -0.08988353f, 0.00380701f, -0.01443499f, 
    0.04187280f, -0.00143108f, -0.06430101f, 0.09251676f, 0.06669589f, -0.12846495f, -0.08246456f, -0.05967228f, 
    -0.09862208f, -0.04272883f, 0.03347213f, 0.11353900f, 0.05248116f, -0.01100146f, -0.04072285f, -0.00845081f, 
    -0.01008259f, -0.25379777f, -0.41802391f, 0.08654333f, -0.02073297f, 0.06114017f, -0.03634398f, -0.04636606f, 
    -0.00585853f, -0.14366381f, -0.07462573f, -0.18714878f, 0.08297538f, 0.13933986f, 0.11265104f, -0.21162082f, 
    -0.06631842f, -0.02351476f, -0.08481244f, 0.02886392f, 0.07151128f, 0.00288191f, -0.11188339f, -0.02876257f, 
    -0.05472890f, 0.12545276f, 0.17822573f, -0.08645877f, -0.07269298f, -0.07184488f, -0.02346297f, 0.04743065f, 
    -0.02067838f, 0.10391299f, 0.12434695f, 0.10873117f, 0.11017255f, -0.03355311f, 0.03046223f, -0.02621120f, 
    -0.03620476f, 0.14539866f, -0.05671630f, -0.13492040f, -0.09228644f, -0.15590523f, 0.09160736f, -0.25151825f, 
    -0.22235744f, -0.15322061f, -0.13615373f, 0.07020494f, -0.05586227f, 0.03747930f, 0.18806919f, 0.10930026f, 
    -0.03819731f, -0.10504327f, -0.00450271f, -0.04181607f, -0.44295979f, 0.09083638f, -0.00954608f, 0.15810017f, 
    -0.00411251f, 0.04609894f, 0.15769833f, 0.03562267f, -0.06421813f, 0.03755009f, 0.09740519f, -0.01010135f, 
    0.07498708f, -0.01189025f, 0.08437602f, -0.14795581f, -0.10985624f, 0.06546772f, 0.06678398f, -0.00040437f, 
    0.09473860f, -0.04746214f, -0.00955380f, -0.06971907f, 0.14788681f, 0.08082555f, 0.15580934f, -0.25579402f, 
    -0.05031069f, 0.02645988f, 0.13932325f, 0.09156317f, 0.04391311f, 0.11465730f, -0.03436535f, 0.03464232f, 
    -0.16057450f, -0.19838805f, -0.04720363f, 0.03551143f, -0.06666836f, 0.02009035f, -0.04170846f, 0.01012849f, 
    -0.09202831f, 0.04912265f, -0.00064809f, -0.22336173f, -0.11378331f, -0.10369582f, -0.08834772f, -0.16073990f, 
    0.02608639f, -0.02687668f, 0.01717308f, -0.08937909f, -0.05438738f, -0.06896064f, 0.11587950f, -0.03107395f, 
    -0.00625402f, 0.00689040f, -0.07852202f, -0.34220973f, -0.21037199f, -0.04177577f, -0.02988551f, -0.12177766f, 
    -0.25443342f, 0.11724044f, 0.03122377f, 0.11958213f, -0.02104143f, -0.26629004f, 0.07370719f, -0.13243893f, 
    0.06888724f, 0.12299154f, -0.07137189f, 0.02160991f, 0.04029174f, -0.00935689f, -0.07536382f, 0.07988777f, 
    -0.01387847f, -0.06972985f, 0.05748509f, -0.08194241f, -0.01314510f, -0.03920148f, -0.05723239f, -0.05273703f, 
    -0.07712376f, -0.00329669f, 0.03849262f, 0.08401878f, -0.04186762f, 0.09724140f, -0.16946098f, -0.12986276f, 
    -0.18843856f, 0.03956043f, -0.03470583f, 0.01540321f, 0.12976639f, 0.07568178f, -0.01027266f, -0.13853553f, 
    -0.01773404f, -0.02146057f, 0.05283184f, 0.02264564f, 0.13434516f, -0.02732148f, 0.04620850f, 0.02609118f, 
    -0.07626637f, 0.05298853f, -0.10917532f, 0.09071381f, -0.20213412f, 0.19612123f, 0.14452101f, -0.17890060f, 
    0.02315134f, 0.09978621f, 0.06634527f, 0.02674907f, -0.06979270f, -0.01689324f, 0.01785632f, -0.09051441f, 
    -0.10258148f, -0.09008965f, -0.21111904f, 0.02690258f, 0.01267828f, 0.15813699f, -0.06890619f, 0.09279479f, 
    0.02172049f, 0.01208001f, 0.01684109f, 0.11756164f, -0.20689674f, -0.13465892f, 0.01883269f, -0.33705077f, 
    -0.08401457f, -0.08288839f, -0.08325969f, -0.10479832f, -0.06667195f, -0.00623992f, 0.11652371f, 0.10041738f, 
    -0.18239914f, -0.04172532f, 0.02374628f, 0.12990978f, -0.14972228f, -0.01785694f, 0.04912283f, -0.02560951f, 
    -0.02004422f, -0.03789883f, -0.03880081f, 0.05685453f, 0.05635381f, 0.08108982f, 0.04138245f, 0.18446894f, 
    0.00625261f, -0.06282397f, -0.14946190f, -0.01114995f, -0.05369650f, 0.00989091f, 0.13513730f, -0.04550277f, 
    -0.36345699f, 0.11430864f, 0.05709080f, 0.11314993f, 0.03125878f, -0.13723083f, -0.05365077f, -0.08833394f, 
    -0.08305965f, -0.00195236f, -0.08689807f, -0.25934303f, 0.07689984f, -0.18514000f, 0.12076405f, -0.06320477f, 
    -0.02130052f, -0.04567136f, -0.03349005f, 0.15902549f, 0.01754297f, 0.08281697f, 0.04164863f, 0.12003559f, 
    -0.17284426f, 0.00501677f, 0.00385433f, 0.15889762f, 0.03124136f, 0.05758582f, -0.01009867f, 0.03504786f, 
    0.04129037f, -0.00800363f, 0.00555578f, -0.02112240f, 0.26273090f, 0.16735387f, 0.25166643f, 0.27441755f, 
    -0.06996670f, 0.11126808f, -0.00831637f, 0.00314745f, 0.05034753f, 0.00705284f, 0.09916697f, 0.04770980f, 
    -0.08178267f, 0.02952452f, 0.19726034f, -0.06068037f, -0.03447019f, 0.04994171f, 0.08807807f, 0.04856402f, 
    0.04255472f, 0.06900234f, -0.05826173f, 0.21341799f, -0.03974846f, -0.00845199f, -0.02570592f, 0.03821600f, 
    -0.05238616f, -0.02702605f, 0.04833199f, -0.03214718f, 0.13086109f, 0.04925682f, -0.06972107f, -0.01715318f, 
    0.05782502f, -0.09457766f, 0.05066532f, 0.05292733f, 0.16923979f, 0.11661505f, 0.05226634f, -0.09464552f, 
    -0.04472216f, 0.00831958f, 0.02478710f, -0.06839685f, -0.32033974f, 0.20948732f, -0.00218611f, 0.21511322f, 
    0.00627022f, 0.09651197f, 0.00618330f, 0.04216794f, -0.04050188f, 0.01045914f, 0.00716285f, -0.02260259f, 
    0.14800945f, 0.06372277f, -0.03973588f, -0.10258576f, -0.09486441f, -0.00132844f, 0.05094064f, 0.00801912f, 
    0.02934485f, -0.09665870f, 0.07294741f, -0.00032018f, -0.14705703f, 0.14910719f, -0.00072459f, 0.12589249f, 
    -0.06682145f, 0.01810810f, -0.00842297f, 0.03943449f, 0.06898508f, 0.04787885f, -0.12742299f, -0.10350490f, 
    0.29300383f, -0.37133902f, -0.01235582f, -0.01006389f, 0.07645237f, 0.09680481f, 0.07664365f, 0.03658209f, 
    -0.07459587f, -0.03225700f, -0.04922026f, -0.01360937f, -0.11187974f, -0.23795982f, -0.19357461f, 0.11950492f, 
    -0.11493178f, -0.03656613f, 0.03429962f, -0.00419599f, -0.03214550f, 0.14365964f, -0.09634422f, -0.03669238f, 
    -0.15406382f, -0.00282270f, -0.14571521f, 0.18902792f, 0.13074689f, 0.10063110f, 0.04580670f, 0.07771881f, 
    0.03754492f, -0.04138398f, -0.01069138f, 0.17587124f, 0.16815683f, -0.32660747f, -0.04698745f, -0.08882719f, 
    -0.00936054f, 0.02929365f, 0.06962896f, 0.00888582f, -0.01812983f, 0.03609101f, 0.11183915f, -0.09103286f, 
    -0.32738602f, 0.06387448f, 0.02345383f, 0.23420908f, 0.02596033f, 0.02889509f, -0.00537910f, -0.02620928f, 
    -0.02476958f, -0.05395821f, -0.05170630f, -0.10626741f, 0.03078023f, 0.11065190f, 0.14247325f, -0.11803160f, 
    0.04095024f, -0.02601917f, 0.02650857f, 0.03859296f, 0.04343068f, 0.08434013f, 0.03967134f, 0.02012897f, 
    -0.17257944f, -0.13419493f, -0.04124139f, -0.08316013f, 0.02355841f, 0.06766538f, -0.01615602f, -0.04521170f, 
    -0.08029665f, 0.06885098f, 0.00882712f, -0.01282148f, 0.00129573f, 0.00615205f, -0.01754237f, -0.12335711f, 
    0.04655128f, 0.00826960f, 0.02488190f, 0.00599965f, 0.07666481f, 0.00786956f, -0.03368339f, -0.06327438f, 
    0.07629374f, 0.07381403f, -0.10571802f, 0.01212091f, -0.02006003f, -0.03600255f, 0.00361850f, -0.06187795f, 
    -0.03445098f, 0.02878210f, -0.00577820f, -0.01438148f, -0.26275751f, -0.08274981f, -0.00622036f, 0.10735817f, 
    -0.07993908f, -0.06310290f, -0.01879255f, -0.01179549f, -0.06198251f, 0.05687018f, 0.07333312f, 0.04415698f, 
    -0.35542113f, -0.04483734f, -0.16837901f, -0.12546179f, -0.00666937f, -0.06985343f, -0.00136244f, -0.06850432f, 
    -0.06103356f, -0.01538046f, 0.03016985f, -0.00849818f, 0.16061845f, -0.21146624f, 0.17378788f, -0.02320936f, 
    0.07769385f, 0.05579259f, -0.08391339f, 0.00023149f, -0.00739166f, 0.06575663f, -0.07417850f, -0.05209903f, 
    0.18492889f, -0.23811908f, 0.04026195f, -0.01858977f, 0.21761087f, 0.02137688f, -0.01031863f, -0.08665852f, 
    -0.05775631f, -0.03296520f, 0.06356496f, 0.00705475f, 0.16694099f, 0.09666724f, 0.00530387f, 0.16651824f, 
    0.01752777f, 0.05329870f, -0.02036787f, -0.06777103f, -0.01533268f, -0.04606750f, -0.01836422f, -0.03862870f, 
    -0.11804340f, 0.02534219f, -0.08887459f, -0.02340703f, -0.03401301f, -0.03767462f, -0.09309314f, 0.02942691f, 
    0.06360268f, -0.01363199f, 0.02031117f, -0.04606143f, 0.13965726f, 0.16961685f, 0.10223889f, 0.11602120f, 
    0.10299743f, 0.08074839f, -0.01132635f, -0.03107715f, -0.05012018f, -0.01682293f, -0.05315084f, -0.06884459f, 
    0.06391808f, -0.30194846f, 0.20186372f, -0.01822407f, -0.06430219f, -0.09133571f, -0.06253603f, -0.03471233f, 
    0.05245092f, 0.07364484f, -0.04226420f, -0.00229265f, -0.30303213f, 0.23157150f, -0.00324902f, -0.11921129f, 
    -0.00680460f, -0.01492629f, -0.09465364f, -0.00752680f, 0.01562427f, 0.01144460f, -0.03881227f, -0.08150615f, 
    0.07191642f, 0.22464462f, 0.11250524f, 0.03181954f, -0.02304587f, 0.04896251f, 0.10297535f, -0.06873736f, 
    -0.07598448f, -0.06062855f, -0.02695065f, -0.05761961f, 0.01084273f, -0.01023991f, 0.07537009f, 0.16039912f, 
    -0.03953836f, -0.04597824f, 0.03653779f, -0.01781311f, -0.05864000f, 0.02250623f, -0.05815240f, 0.04390263f, 
    0.09220748f, -0.00425061f, 0.16536954f, 0.01430332f, -0.07763353f, 0.00047114f, -0.00919028f, -0.03133425f, 
    -0.00898652f, 0.14332193f, -0.05154965f, -0.02625109f, -0.11447725f, 0.21375662f, 0.01557047f, 0.10741574f, 
    -0.03333654f, -0.05254507f, 0.06741299f, -0.01177738f, 0.12194644f, -0.01329372f, 0.01162727f, -0.03026964f, 
    0.14146562f, -0.05530724f, -0.17439215f, -0.02413143f, -0.09942564f, -0.05072321f, -0.01890245f, -0.07033003f, 
    0.01155657f, -0.01315033f, 0.05106578f, -0.05338635f, 0.09494592f, 0.12988065f, 0.15294015f, 0.20869757f, 
    0.08926329f, 0.11796644f, 0.00101324f, -0.03941754f, 0.00953179f, -0.03550789f, -0.00320690f, -0.01005829f, 
    0.18457843f, -0.11665505f, 0.03849651f, -0.01763466f, 0.08808392f, -0.07387885f, -0.02389972f, -0.05465967f, 
    -0.02613574f, -0.01282260f, -0.10515298f, -0.08605852f, -0.22462019f, 0.10350251f, -0.12758666f, -0.12914266f, 
    -0.02910122f, -0.03912596f, -0.09397351f, -0.07992096f, -0.05639355f, -0.03613330f, -0.02717862f, -0.05348703f, 
    0.19015206f, 0.04880945f, 0.01411441f, 0.09687665f, -0.04158915f, -0.08061834f, -0.00066154f, -0.06602907f, 
    0.06748511f, -0.03415962f, 0.02279514f, -0.07643923f, -0.06443062f, -0.00915833f, 0.02638648f, -0.09968317f, 
    0.01034643f, -0.06615171f, 0.01286456f, -0.02595855f, -0.01798799f, -0.03772197f, -0.02945225f, 0.01205477f, 
    -0.36809522f, 0.11330064f, 0.06596783f, -0.19572662f, -0.06633414f, -0.01084800f, 0.01428232f, -0.10660091f, 
    -0.00445036f, -0.05126154f, -0.00860757f, -0.05600095f, -0.14452775f, 0.11844234f, 0.02465968f, 0.01877420f, 
    -0.01882380f, -0.05287176f, -0.07746437f, -0.00095411f, -0.06910203f, 0.07552371f, 0.01204351f, -0.05622746f, 
    0.16905247f, 0.08810192f, -0.01105004f, 0.07032625f, 0.06411705f, -0.02583550f, -0.05437735f, -0.05721907f, 
    -0.16912305f, 0.03045756f, -0.02772506f, -0.05344814f, -0.07615958f, 0.19001476f, -0.04234866f, 0.24378194f, 
    0.09049084f, -0.01692482f, -0.10496231f, 0.05319195f, 0.02214844f, 0.01761079f, 0.06056215f, -0.00788429f, 
    0.18191579f, -0.13013314f, 0.16888790f, 0.09847753f, 0.11824162f, -0.00336139f, -0.07048343f, -0.08117159f, 
    -0.07816168f, -0.00463867f, -0.09152234f, 0.01078154f, 0.16963676f, 0.12795770f, 0.09368637f, 0.15669845f, 
    0.05309793f, -0.03650779f, 0.02923983f, -0.00298526f, 0.02191673f, 0.03515335f, -0.01902433f, -0.13135420f, 
    0.00900330f, 0.18519244f, -0.10998607f, 0.14113094f, 0.03694950f, -0.06758972f, -0.10815739f, 0.00796015f, 
    0.09272770f, 0.00349946f, -0.03131961f, 0.00745277f, -0.19985467f, 0.12655731f, -0.11271706f, -0.12013306f, 
    0.05042326f, -0.01808526f, 0.04692115f, -0.06064164f, -0.05452576f, 0.00099635f, -0.04418265f, -0.06144248f, 
    -0.20931002f, 0.04924810f, -0.16168578f, -0.10288757f, -0.00685721f, 0.05721413f, -0.04743739f, -0.07604843f, 
    -0.12569478f, 0.02582186f, -0.03533506f, -0.06554300f, 0.09990484f, 0.07323058f, 0.10829714f, 0.11873215f, 
    -0.01227547f, 0.02106438f, 0.03748968f, -0.04118378f, 0.01167178f, -0.04662124f, 0.00118035f, -0.02740731f, 
    -0.06971668f, 0.05134057f, 0.06967619f, 0.11922896f, 0.10799378f, -0.00104618f, -0.04384192f, -0.04936225f, 
    -0.02753414f, -0.00419852f, -0.01353928f, -0.04922983f, -0.10080861f, -0.01887792f, -0.16080518f, -0.07257424f, 
    -0.04954986f, -0.02382750f, -0.12014645f, -0.02460431f, -0.02242261f, -0.08702096f, -0.02053388f, -0.05811300f, 
    0.18984996f, -0.27943665f, 0.08654270f, 0.07111368f, -0.07771845f, -0.10874669f, -0.04687301f, -0.02659787f, 
    0.03094761f, 0.01807943f, 0.03823395f, 0.00015217f, -0.25742489f, 0.09490571f, 0.05531428f, -0.09697830f, 
    -0.03756031f, 0.05007065f, 0.02620380f, -0.01407254f, -0.03437984f, 0.05971127f, -0.00436703f, -0.04618887f, 
    -0.10890255f, -0.00560329f, 0.09820714f, -0.02862885f, 0.16078366f, 0.03413122f, -0.00206491f, 0.04350177f, 
    -0.08863912f, 0.00221609f, 0.02479439f, 0.04934704f, 0.16908973f, 0.15805721f, 0.22132827f, 0.05973755f, 
    0.07583384f, 0.07962724f, 0.01948368f, -0.04719884f, 0.04004616f, 0.09725761f, -0.05055054f, -0.02643102f, 
    -0.04457156f, 0.08016341f, 0.14458391f, 0.21014379f, 0.11698835f, 0.14530171f, 0.03315296f, -0.03867256f, 
    -0.12907074f, 0.03612655f, -0.00560566f, -0.05210622f, -0.23806477f, -0.03863016f, 0.09531371f, -0.13225858f, 
    -0.04310039f, -0.04352385f, -0.00234558f, -0.05158203f, 0.02040017f, -0.02612197f, 0.10353190f, -0.04895175f, 
    -0.15868884f, 0.07843121f, -0.03757045f, -0.15618263f, -0.00512760f, -0.01333297f, -0.12761250f, -0.07423022f, 
    0.00662817f, -0.03996051f, -0.00863692f, -0.02542559f, -0.17956395f, 0.11523189f, -0.14525558f, -0.07196508f, 
    -0.04365584f, 0.01672189f, -0.02676586f, 0.04698615f, -0.05936821f, -0.02868897f, -0.02741787f, 0.00972727f, 
    -0.04829209f, 0.09562533f, -0.03131130f, 0.20386979f, -0.06630407f, -0.10767782f, -0.16849583f, 0.00899596f, 
    -0.12308103f, 0.01045854f, -0.02117655f, -0.08731502f, -0.09798393f, 0.03382729f, -0.07309983f, -0.10434064f, 
    0.00895658f, 0.01805103f, -0.01499765f, -0.00074606f, -0.10500932f, 0.02761946f, -0.00123212f, -0.03696192f, 
    0.02844109f, 0.18965960f, -0.05793247f, 0.16969736f, -0.03055472f, -0.03474411f, 0.02567345f, -0.06406115f, 
    -0.02835725f, 0.00330805f, 0.04659995f, 0.05170737f, 0.04238448f, 0.10257769f, 0.16285950f, 0.24259295f, 
    0.06914344f, 0.06771804f, 0.04507906f, 0.02649410f, -0.04798612f, -0.01471193f, -0.02300619f, -0.03291677f, 
    0.00612166f, 0.14825378f, 0.03043358f, 0.01874740f, -0.02804851f, 0.00347373f, -0.01980318f, -0.02067149f, 
    -0.07752884f, 0.02469818f, -0.00574444f, -0.08029089f, -0.05024036f, -0.02219291f, 0.03052023f, -0.03328951f, 
    0.02408302f, -0.09621247f, 0.03921379f, 0.01268821f, -0.07519517f, 0.01840403f, 0.02389951f, 0.09594624f, 
    -0.15803440f, 0.00189481f, 0.13370053f, 0.09768246f, 0.02129740f, 0.01148175f, -0.06786708f, 0.02903587f, 
    -0.04366464f, -0.03349347f, -0.07482366f, -0.01280429f, -0.10916468f, -0.11923593f, 0.06641161f, -0.09943892f, 
    -0.09724326f, 0.00833975f, -0.04248207f, -0.07660014f, -0.06181191f, -0.00137612f, -0.04445038f, 0.00747640f, 
    -0.09159590f, 0.04745727f, -0.09207284f, 0.03683116f, -0.06482787f, -0.05894816f, -0.11468221f, -0.02486831f, 
    -0.04257856f, -0.06508593f, 0.02619014f, -0.09574935f, -0.20308775f, 0.06825843f, 0.04598596f, 0.10968002f, 
    -0.01567792f, -0.06610200f, 0.05129949f, 0.02358522f, -0.01395791f, -0.01634684f, 0.04647186f, -0.09425381f, 
    0.14220195f, -0.09520918f, -0.11540050f, -0.11036169f, -0.01199291f, -0.00019912f, 0.01177077f, -0.06807490f, 
    -0.03431127f, -0.01844464f, -0.01093522f, 0.05355715f, -0.11951109f, 0.02465749f, -0.11134434f, 0.02727049f, 
    -0.00094826f, -0.00451204f, 0.05102237f, -0.02715219f, 0.03506861f, -0.05581093f, 0.00609433f, -0.06589501f, 
    0.31550023f, -0.22755522f, 0.10403279f, 0.00249039f, 0.07572989f, 0.03298771f, -0.01797607f, -0.03672381f, 
    -0.04293892f, -0.03217101f, -0.01736034f, -0.07561951f, -0.09740064f, -0.14471495f, -0.17872566f, -0.26540250f, 
    0.01156649f, -0.06810055f, 0.00114728f, -0.02809973f, -0.00035720f, 0.01161306f, -0.01073784f, 0.02514548f, 
    -0.21328905f, -0.05791622f, -0.15690790f, -0.24404357f, 0.06409892f, 0.01462644f, -0.00181846f, -0.03084070f, 
    -0.02851680f, -0.04734068f, -0.06478666f, -0.00745056f, -0.04850383f, -0.02265157f, -0.13359417f, -0.12283476f, 
    0.01809186f, 0.04650272f, -0.00551626f, 0.00998298f, -0.02479530f, 0.05950301f, -0.02300394f, 0.00679195f, 
    0.10740935f, -0.08029976f, 0.08862752f, -0.05145089f, 0.04428747f, -0.00892772f, -0.03252754f, 0.00270761f, 
    -0.03930847f, 0.02359505f, -0.00951403f, -0.01104334f, 0.04548027f, 0.17820112f, 0.03765624f, 0.18995489f, 
    0.18731494f, -0.07043660f, 0.00427597f, 0.00594581f, 0.00945961f, -0.01136347f, -0.05928863f, -0.06892221f, 
    -0.08025121f, 0.07813776f, -0.04247043f, 0.09726508f, -0.00785386f, 0.04603387f, -0.03986660f, -0.04142279f, 
    -0.06866338f, 0.03720220f, 0.00149656f, -0.07242136f, 0.07966438f, 0.04453568f, 0.21571232f, 0.01813572f, 
    0.09150095f, 0.05645775f, -0.08666248f, 0.07571666f, -0.06073492f, 0.02741821f, 0.03293273f, -0.01002533f, 
    -0.01664931f, -0.33526409f, -0.16541865f, -0.13165952f, 0.03818196f, 0.02894416f, -0.06814913f, -0.02260627f, 
    -0.06146996f, -0.10910691f, -0.01648087f, -0.02681339f, -0.13878903f, -0.10041554f, -0.01329577f, -0.04415793f, 
    -0.03527314f, -0.02628662f, 0.04261836f, -0.04739476f, -0.01671563f, -0.06936274f, -0.04229289f, -0.07811765f, 
    0.14967704f, 0.00606564f, -0.03528294f, 0.07207859f, -0.01330133f, -0.04520222f, -0.01758553f, 0.11637751f, 
    0.05144906f, -0.06576763f, 0.01656496f, -0.15291552f, 0.17357959f, 0.08522091f, -0.07026799f, 0.06435514f, 
    -0.06384984f, 0.04984714f, -0.02341111f, 0.01941412f, -0.13643852f, -0.04997325f, -0.02388853f, 0.07668272f, 
    -0.16392776f, -0.09430143f, 0.07631353f, 0.08540712f, -0.04879308f, -0.01668526f, 0.05507267f, 0.00658389f, 
    -0.03053647f, 0.11197970f, 0.06284051f, 0.06636515f, -0.09433660f, -0.04895410f, -0.14576523f, 0.12612294f, 
    0.16711816f, 0.05443700f, -0.00831498f, -0.02888540f, 0.04992897f, 0.05482369f, 0.05600398f, 0.00377948f, 
    -0.01203211f, -0.09836089f, 0.05539206f, 0.10411417f, 0.07611401f, 0.10764486f, 0.02230417f, -0.04690509f, 
    0.02888143f, 0.00497211f, 0.04809095f, 0.04382858f, -0.13994928f, -0.13153394f, 0.19165955f, -0.15336879f, 
    0.06465617f, -0.00260329f, -0.00433614f, -0.09147053f, -0.07627614f, -0.04979310f, 0.05115010f, 0.00498425f, 
    0.12513949f, -0.05693087f, 0.06174766f, -0.09298570f, 0.01441200f, -0.05602307f, -0.06953080f, -0.03298449f, 
    0.08512897f, 0.03319449f, -0.10286900f, -0.09521043f, -0.22766365f, 0.16610546f, -0.07821929f, -0.04146550f, 
    -0.03713324f, -0.06997835f, -0.11964636f, 0.01774381f, -0.00789904f, 0.00711910f, -0.04988171f, -0.04906267f, 
    0.17797476f, 0.17314033f, -0.01180517f, -0.01399549f, 0.01402947f, 0.00384940f, -0.07236417f, -0.15164669f, 
    0.09163048f, -0.04999319f, 0.02967643f, -0.07320365f, -0.25351873f, -0.19252256f, -0.04651629f, -0.16097200f, 
    0.00000551f, -0.11179032f, -0.08160723f, -0.10692861f, -0.04586110f, -0.12295574f, 0.04473633f, -0.00483040f, 
    -0.02086103f, 0.04641404f, -0.21400401f, 0.00909508f, -0.01122215f, 0.06103450f, 0.02963650f, -0.13823180f, 
    -0.01277415f, 0.00691343f, 0.10445929f, 0.12323187f, -0.05234857f, -0.03043329f, -0.07440022f, 0.11071149f, 
    -0.00463990f, 0.04079891f, -0.06891234f, -0.03163333f, 0.01332545f, 0.06416529f, 0.09230061f, 0.05908030f, 
    -0.15857856f, -0.01994088f, 0.09500088f, -0.11572056f, -0.00578359f, -0.11036968f, 0.05250997f, 0.08614634f, 
    0.05632469f, -0.02270869f, 0.07447986f, -0.09245557f, 0.04899646f, 0.00923975f, -0.19479659f, -0.18505752f, 
    0.01477327f, 0.02298865f, 0.15491556f, -0.04046606f, 0.00793267f, 0.01719694f, -0.00929884f, -0.02462096f, 
    0.04560167f, 0.02792240f, 0.08604453f, -0.13194783f, -0.00778702f, 0.06493459f, -0.11511914f, 0.04941954f, 
    -0.02709634f, -0.03447258f, 0.05153072f, 0.02640717f, 0.12740199f, 0.13750945f, 0.02466380f, 0.14106241f, 
    -0.13079122f, -0.04459210f, -0.01285218f, 0.05288577f, -0.08125471f, -0.10580487f, -0.05586911f, 0.06800028f, 
    -0.23292491f, -0.28570986f, 0.03984747f, 0.13811283f, 0.07423941f, -0.02938070f, -0.02595529f, -0.01554431f, 
    0.01834406f, 0.04498585f, -0.01084785f, 0.06683881f, -0.22861239f, -0.02319443f, 0.08745477f, -0.04652575f, 
    0.03623157f, 0.08349711f, 0.00608834f, 0.01531432f, -0.00612487f, -0.01271705f, -0.05181303f, -0.05096587f, 
    -0.03807774f, -0.14969034f, -0.12302269f, -0.12383805f, -0.08712979f, -0.10980839f, 0.06759116f, -0.02991452f, 
    0.00077650f, -0.00724283f, 0.16872600f, 0.09701525f, -0.17081711f, -0.02074187f, -0.07663342f, 0.03631008f, 
    -0.01271202f, -0.00996137f, 0.01314882f, 0.07186995f, 0.05958284f, 0.10688335f, 0.08853863f, -0.07673364f, 
    -0.03589754f, -0.23707339f, 0.06358007f, -0.22145560f, -0.00114503f, -0.09980443f, -0.11422949f, 0.13427973f, 
    -0.00599320f, 0.05876314f, -0.08089882f, 0.01873938f, 0.18436374f, -0.08690845f, 0.03622914f, 0.07065675f, 
    0.08172462f, -0.03264270f, -0.01457996f, 0.03625155f, 0.00528525f, 0.00513681f, 0.06352160f, 0.01551753f, 
    -0.01716894f, -0.16174930f, 0.13281672f, 0.10011929f, -0.09757026f, -0.04205440f, -0.04358529f, -0.03866972f, 
    0.05899373f, -0.02678121f, -0.08674689f, 0.01671330f, 0.11397155f, -0.12428369f, 0.08812415f, 0.05124383f, 
    -0.12535454f, -0.09045881f, -0.04442774f, -0.01321385f, -0.03023931f, -0.03349843f, -0.08807173f, -0.04256929f, 
    0.06947230f, -0.17295547f, 0.00072551f, -0.20835869f, 0.08058783f, -0.08162458f, 0.02395520f, 0.04548125f, 
    -0.02025578f, -0.04070805f, -0.06046387f, -0.06683400f, 0.06153776f, 0.18311243f, -0.26950231f, -0.09224207f, 
    0.11014205f, -0.14674766f, -0.04289733f, 0.00010877f, 0.05204660f, -0.03914830f, -0.04004655f, -0.00101188f, 
    0.13473889f, 0.05247654f, -0.02784550f, -0.08763599f, 0.11051053f, -0.08882606f, -0.05015264f, 0.02898151f, 
    -0.16447443f, 0.04146850f, 0.04361932f, -0.04086659f, 0.00586733f, -0.23596323f, 0.09216230f, -0.10424194f, 
    0.00969823f, 0.00213529f, -0.08177443f, -0.09957238f, 0.01075897f, -0.03506005f, 0.12615174f, -0.03305443f, 
    0.06458842f, 0.25746956f, -0.12002176f, -0.14674947f, -0.08142407f, 0.03529066f, -0.06090125f, 0.02317784f, 
    0.10478393f, 0.02855215f, 0.13611625f, 0.05925008f, 0.02000537f, -0.00442167f, 0.00071175f, 0.13320507f, 
    0.10244270f, 0.09806192f, -0.04578627f, -0.01744186f, 0.02358474f, 0.02269574f, 0.16240327f, -0.01098248f, 
    -0.02392250f, 0.02506465f, 0.09482762f, 0.11632000f, 0.02233890f, -0.00396695f, -0.01907061f, -0.02919473f, 
    -0.04746601f, -0.03384880f, 0.14997706f, -0.08695031f, 0.12193415f, -0.11366792f, -0.02202048f, -0.08507563f, 
    0.01403809f, 0.00096353f, 0.05824601f, -0.06211909f, -0.01358168f, 0.01454455f, 0.01073022f, 0.06273569f, 
    0.01721265f, 0.18653636f, 0.03100287f, 0.12241361f, -0.02742448f, -0.10937430f, -0.12900165f, 0.03705149f, 
    -0.01014601f, -0.07162926f, -0.04618697f, -0.04488365f, 0.08508273f, 0.13318670f, -0.03230877f, 0.05669943f, 
    -0.03183755f, 0.04739796f, -0.01660462f, -0.11003283f, 0.03034524f, -0.01715996f, -0.08202555f, 0.06370027f, 
    -0.13689473f, -0.08548696f, -0.00936986f, -0.20293146f, -0.02528476f, -0.02315364f, 0.03944030f, -0.04482377f, 
    0.01067277f, -0.00664698f, 0.01880582f, 0.11999539f, 0.14728487f, -0.11128106f, 0.08412025f, 0.17317767f, 
    0.07840043f, -0.09193600f, -0.07844601f, -0.03356007f, 0.11200926f, -0.10125604f, 0.21752994f, -0.06467545f, 
    -0.11274935f, -0.04392975f, -0.02661825f, -0.01673344f, 0.04802951f, 0.07890662f, -0.08216996f, -0.15812874f, 
    0.05555860f, -0.00321594f, 0.04790843f, 0.06449128f, -0.14999038f, 0.03364882f, 0.16348477f, 0.06290595f, 
    -0.13327818f, 0.03564731f, -0.08408731f, -0.02451449f, 0.05830375f, -0.05967300f, -0.03688744f, 0.08605277f, 
    -0.21096604f, -0.08502211f, 0.05655910f, -0.11903482f, -0.03543412f, 0.02593196f, 0.10381517f, 0.04985728f, 
    0.12523164f, -0.03325053f, -0.03937568f, -0.01951583f, -0.13604040f, -0.07414641f, 0.09725419f, 0.17173572f, 
    -0.07447181f, -0.02663003f, -0.01923078f, 0.05607912f, -0.01302394f, 0.06832569f, 0.00030897f, 0.07665762f, 
    0.18124692f, -0.00227818f, 0.05754614f, 0.07842293f, -0.00637875f, -0.09529937f, 0.02732413f, -0.09588129f, 
    -0.01516654f, -0.00483624f, -0.11529453f, -0.06282786f, -0.17502047f, 0.05635481f, 0.04956713f, 0.07894678f, 
    -0.10361518f, 0.02689639f, -0.00408967f, 0.00910930f, 0.02241319f, -0.09305914f, -0.00799270f, 0.07102866f, 
    -0.10000349f, 0.11914402f, -0.15847248f, -0.17443217f, -0.07451643f, -0.06843051f, -0.00207727f, -0.10190780f, 
    0.10334659f, 0.08538221f, -0.02638618f, 0.03312351f, 0.13023643f, -0.02883638f, 0.09914954f, 0.12223761f, 
    0.06179295f, 0.01893060f, -0.05368546f, -0.03407657f, -0.04583791f, 0.09618264f, -0.00766077f, -0.03298288f, 
    0.00023702f, -0.10717656f, -0.13898243f, -0.09521425f, 0.02099909f, -0.10064028f, -0.16252296f, 0.02129683f, 
    0.06562792f, -0.03252782f, -0.01325433f, -0.14164354f, -0.21435273f, -0.01771943f, 0.15632643f, -0.00298353f, 
    -0.02671364f, 0.09771167f, 0.00416803f, -0.08268229f, 0.03212558f, -0.01333838f, -0.10227960f, -0.10118208f, 
    0.12671739f, 0.09214096f, -0.06146958f, 0.13928135f, 0.05285928f, -0.06646250f, -0.14538150f, -0.04288667f, 
    0.00160716f, 0.01500281f, -0.10625681f, -0.04283471f, -0.00770852f, 0.03239473f, -0.10140816f, -0.08099149f, 
    0.04137361f, -0.00742083f, -0.17584229f, -0.00557287f, -0.00288463f, 0.04009179f, -0.00637271f, -0.09245212f, 
    -0.00234712f, 0.07069138f, -0.07229599f, -0.03785150f, 0.05220563f, 0.11001121f, -0.06290099f, -0.03693133f, 
    -0.02716946f, 0.02845075f, 0.05148559f, 0.05043216f, -0.02807252f, 0.03205311f, 0.05635354f, 0.10691029f, 
    -0.08289018f, -0.06716646f, -0.06064843f, -0.09561506f, 0.04269025f, -0.00740618f, -0.06610174f, -0.04738292f, 
    0.06135005f, 0.05943472f, -0.25539383f, -0.17198110f, 0.07672656f, 0.03098782f, -0.02920856f, 0.02836877f, 
    0.11065535f, 0.07657714f, 0.01217245f, -0.05691297f, -0.00995151f, -0.17121217f, -0.22947665f, -0.12367202f, 
    0.06305430f, -0.21688926f, -0.33518231f, -0.08526981f, 0.01245435f, -0.01226714f, -0.06907603f, -0.03950968f, 
    0.20304045f, 0.07610253f, -0.02723498f, 0.03029328f, 0.08552133f, -0.06194783f, -0.17166868f, -0.02876932f, 
    0.06999578f, -0.04330910f, 0.06906818f, -0.31191182f, -0.04700593f, 0.04796858f, 0.05875620f, 0.03908986f, 
    -0.09733386f, 0.05993981f, -0.05776471f, -0.09452467f, -0.00491139f, -0.00351328f, 0.10600217f, -0.00572226f, 
    0.10381392f, -0.12653382f, 0.02510824f, -0.16306797f, -0.11361004f, -0.01407837f, 0.02313577f, 0.03728284f, 
    0.04669721f, 0.06634945f, -0.04670590f, 0.05686184f, 0.01268049f, -0.04171838f, -0.16484921f, -0.03147691f, 
    0.03653183f, 0.05261506f, -0.01741557f, -0.02766712f, 0.00810710f, 0.00778799f, 0.08826887f, -0.03664002f, 
    0.11162550f, 0.04617054f, -0.02985165f, 0.14596893f, 0.01178979f, 0.01121405f, -0.06216215f, 0.00627988f, 
    0.04062501f, -0.02546992f, -0.02509496f, -0.04149325f, 0.01282869f, 0.05494005f, -0.03357168f, -0.01889937f, 
    0.02724252f, 0.04148038f, -0.09642930f, 0.02562483f, 0.00469345f, -0.07086227f, 0.00355842f, 0.06123346f, 
    0.01343234f, -0.05881530f, 0.13113858f, -0.00308713f, 0.00045950f, -0.07623907f, -0.05142901f, -0.09199388f, 
    0.02160989f, -0.08102508f, -0.00345565f, -0.02719121f, 0.05205316f, 0.10231900f, -0.01882089f, 0.05468360f, 
    -0.11116368f, -0.07568886f, -0.08449254f, -0.02261776f, 0.00738276f, -0.12997824f, 0.06379450f, 0.07735959f, 
    -0.16229771f, 0.05862753f, -0.31410277f, -0.04352641f, 0.03262560f, -0.01703452f, -0.08982469f, -0.04335498f, 
    0.01246838f, 0.02082309f, -0.13959387f, -0.21045578f, -0.08383577f, -0.13977017f, 0.16223894f, -0.05218399f, 
    -0.06357127f, -0.15674457f, 0.11122623f, -0.06331888f, -0.04518743f, 0.02682485f, -0.10414889f, 0.00882486f, 
    0.21831843f, -0.05871114f, -0.26266599f, 0.03562993f, 0.08008523f, 0.04741549f, 0.03481935f, -0.04859384f, 
    -0.03430649f, 0.06282901f, 0.03462094f, 0.01030132f, 0.14002901f, -0.07277233f, -0.09182065f, 0.21175213f, 
    0.17570549f, -0.02074892f, -0.05609464f, -0.02768650f, -0.04488749f, -0.04380717f, 0.03694367f, -0.00922517f, 
    -0.04802747f, 0.23526216f, -0.19525284f, 0.02767628f, 0.13905445f, 0.03643787f, 0.03403334f, -0.22203416f, 
    -0.13496210f, 0.02847291f, -0.09907531f, 0.09399606f, 0.07603237f, -0.17155352f, 0.23003717f, 0.01759135f, 
    0.04822451f, 0.04996944f, 0.09908723f, -0.01814958f, 0.10803295f, 0.06234314f, -0.00700036f, 0.00638643f, 
    0.18448721f, 0.05706126f, -0.18023959f, -0.19756839f, 0.08952840f, -0.14059062f, -0.00009607f, 0.07179686f, 
    -0.07327882f, -0.09850390f, -0.02682606f, -0.17004552f, -0.15302981f, 0.12246485f, -0.27690414f, -0.36280623f, 
    0.11286921f, 0.01848081f, -0.18683361f, 0.03084548f, 0.01341417f, -0.06231129f, -0.19637263f, -0.00609559f, 
    -0.13824251f, 0.16381967f, -0.01552122f, -0.27708027f, 0.08189368f, 0.00668118f, -0.02225345f, -0.12953241f, 
    -0.16993949f, -0.02654352f, -0.02430650f, -0.18858303f, 0.17200176f, -0.01910061f, 0.04023980f, 0.34272423f, 
    -0.05643747f, -0.00870481f, -0.10858954f, 0.01968537f, -0.07778677f, 0.15344530f, -0.05456717f, 0.02201002f, 
    0.16257536f, -0.00162070f, 0.06574202f, 0.16061099f, -0.09826136f, 0.04798310f, 0.10839607f, 0.02630083f, 
    -0.03553842f, -0.02362753f, -0.06067184f, 0.05727658f, -0.11369589f, 0.29714105f, -0.13148561f, 0.12582980f, 
    0.00989122f, -0.01860049f, -0.00743086f, 0.15908095f, -0.01096182f, -0.02170943f, 0.08442078f, -0.05172670f, 
    0.45922452f, 0.09894882f, 0.00724696f, 0.02944917f, 0.03081900f, 0.03147320f, 0.06930267f, 0.01632014f, 
    -0.02143846f, 0.05100083f, -0.00123423f, 0.07647155f, -0.02771446f, -0.15917118f, -0.16536464f, 0.19772817f, 
    0.03379710f, -0.00374634f, -0.02108888f, 0.17523111f, -0.04571940f, 0.01443249f, -0.03460543f, -0.09055588f, 
    0.27612939f, -0.12197231f, -0.08273834f, -0.08973480f, -0.13204485f, 0.02812651f, -0.07903200f, -0.04465022f, 
    -0.00822357f, -0.03025948f, 0.12140194f, -0.16637453f, -0.31730157f, 0.21344757f, 0.03214999f, -0.22941121f, 
    0.11361601f, -0.09866085f, 0.02700995f, -0.03170980f, 0.03501013f, 0.03904453f, -0.01376236f, -0.01006749f, 
    -0.18166004f, -0.24272360f, 0.02335741f, 0.21852191f, 0.01234500f, -0.06746416f, -0.02798420f, -0.07617100f, 
    0.07202177f, -0.06500202f, -0.10553189f, 0.09675688f, -0.13153225f, 0.12729837f, -0.13676903f, 0.10139427f, 
    0.01592918f, 0.00206808f, -0.05529944f, -0.05348555f, -0.01776200f, 0.03126539f, 0.03493633f, 0.02050886f, 
    -0.13362134f, -0.23873951f, -0.01449264f, -0.01829127f, 0.01326301f, 0.05646643f, -0.01399048f, -0.16973092f, 
    -0.01846397f, 0.09522971f, -0.08347195f, -0.02833379f, -0.42080230f, -0.04563544f, 0.14757036f, -0.06360941f, 
    0.13773814f, 0.05448653f, 0.01977323f, -0.07112671f, 0.07768548f, 0.00994604f, 0.02772778f, 0.00238957f, 
    -0.16520926f, -0.05817378f, -0.05535566f, -0.26141018f, 0.00353919f, -0.12097829f, 0.02998821f, -0.01560883f, 
    0.11713289f, -0.09914070f, 0.03590913f, 0.06396933f, -0.02298686f, -0.13647415f, -0.02295585f, 0.08264492f, 
    0.02437441f, -0.05179963f, -0.08870994f, -0.04199386f, -0.10937227f, -0.03040158f, 0.10884868f, 0.05080098f, 
    -0.04447010f, -0.12578820f, 0.10683356f, -0.07924291f, -0.11600937f, -0.05835997f, -0.00939663f, 0.01418821f, 
    0.02961346f, 0.06537921f, 0.00562600f, 0.02153465f, -0.17303285f, 0.17939129f, -0.02794844f, -0.15956996f, 
    -0.08453922f, 0.06475746f, 0.02926754f, 0.09096915f, 0.01711460f, -0.09571277f, -0.00424513f, -0.04775442f, 
    0.14032838f, 0.02787033f, -0.03328705f, -0.02087191f, -0.14078872f, -0.05979658f, 0.03670009f, -0.07431920f, 
    0.11276376f, 0.05172332f, 0.00938219f, 0.00795986f, 0.10549022f, 0.25572294f, -0.15297967f, -0.08403881f, 
    -0.04465456f, 0.00981164f, 0.02329805f, -0.02191715f, 0.02810185f, 0.08258401f, -0.11715864f, -0.00750589f, 
    -0.35302553f, 0.28248808f, -0.20993629f, 0.19186693f, -0.00822094f, -0.07801186f, -0.02393285f, 0.04427303f, 
    -0.03360400f, 0.01798567f, 0.02427306f, -0.00082232f, -0.13911924f, -0.09495697f, -0.03022771f, -0.03434914f, 
    0.03983032f, 0.04692866f, 0.06233295f, 0.06289115f, 0.04371211f, 0.10034411f, 0.04491667f, 0.03918019f, 
    0.14196643f, 0.02677607f, 0.10496552f, -0.06717799f, -0.13136770f, 0.01792286f, 0.02915440f, 0.05532231f, 
    0.02024106f, -0.06967662f, 0.03425190f, 0.03760077f, -0.37104616f, -0.10266354f, 0.06864530f, -0.22950330f, 
    -0.12343604f, 0.04887741f, -0.11578212f, 0.04352058f, -0.02400904f, -0.09926910f, 0.10079938f, 0.05430618f, 
    0.03661382f, -0.34144849f, 0.18105763f, -0.01462066f, 0.01848169f, 0.02462100f, -0.12171920f, 0.02379589f, 
    0.09520523f, 0.11258096f, 0.15646715f, 0.00812241f, 0.12032817f, 0.07739493f, -0.13928752f, -0.02369280f, 
    0.07042732f, -0.04157010f, 0.00649649f, 0.06065729f, -0.05392713f, 0.02101360f, -0.00464149f, 0.11707897f, 
    -0.01449408f, 0.22695577f, 0.19724128f, 0.03804108f, 0.13270244f, 0.07129414f, -0.00843469f, -0.02496314f, 
    -0.04608030f, -0.00023628f, -0.07549404f, -0.01273046f, -0.10797128f, 0.16054808f, -0.12136371f, -0.19479230f, 
    0.05683756f, -0.04174647f, -0.03977316f, -0.00671989f, -0.02296639f, -0.09540766f, -0.15554717f, -0.15952843f, 
    -0.06435682f, 0.22095692f, -0.00016090f, -0.20106839f, 0.01587164f, 0.06258450f, -0.00194175f, -0.18004829f, 
    -0.01334240f, -0.01834816f, -0.02035730f, 0.08385640f, -0.11129402f, 0.10624654f, -0.14498065f, 0.14644034f, 
    0.03733321f, -0.03224801f, 0.05765492f, 0.08625016f, 0.10368411f, 0.02496530f, -0.01402669f, -0.05966344f, 
    0.24549311f, -0.54434776f, -0.01789245f, 0.09864809f, 0.09256857f, 0.07223503f, 0.03963707f, 0.09326996f, 
    -0.06245789f, 0.03823522f, 0.06132752f, -0.05871532f, 0.43869483f, 0.12811650f, -0.08060475f, 0.00942395f, 
    -0.04957426f, 0.07523610f, 0.08361317f, 0.11770801f, -0.05709169f, -0.02284941f, 0.05209508f, -0.03294790f, 
    -0.01152239f, -0.21301752f, -0.12357651f, -0.12586442f, -0.03901040f, -0.05270107f, -0.02427759f, 0.00242310f, 
    0.06983440f, -0.00971389f, 0.14079131f, -0.17134908f, -0.16063575f, 0.06962096f, 0.10412605f, -0.05435099f, 
    0.04240057f, -0.05736807f, -0.11242555f, 0.01511287f, 0.00365882f, -0.01024518f, -0.10009785f, 0.07718034f, 
    -0.08299931f, -0.33166218f, 0.01903355f, 0.10613770f, 0.01130321f, -0.04772957f, 0.12240506f, 0.09651307f, 
    -0.15471779f, -0.08332390f, -0.01533687f, -0.05981636f, 0.02345446f, -0.25452226f, -0.10300927f, 0.02937765f, 
    0.10855279f, 0.10580564f, 0.02234208f, 0.06223619f, -0.10673529f, 0.05123119f, -0.05851864f, -0.13590029f, 
    -0.04757899f, -0.10762647f, -0.12580664f, -0.11603073f, 0.04099915f, 0.07956922f, 0.07268888f, -0.18165287f, 
    0.05739712f, 0.03429272f, 0.01389555f, -0.01828595f, 0.00321356f, 0.08199539f, -0.17756544f, 0.30825588f, 
    -0.04353494f, -0.01979060f, 0.03483017f, 0.01190239f, -0.00986239f, 0.00368090f, 0.05134068f, -0.08892662f, 
    -0.32711247f, 0.15072571f, -0.12377083f, -0.05828496f, 0.03491697f, 0.04394586f, -0.07532340f, -0.03783724f, 
    -0.03091675f, -0.04667356f, 0.14961962f, -0.03402004f, -0.15044136f, 0.17582099f, 0.03061881f, -0.07537247f, 
    0.08338305f, 0.04693294f, -0.00109242f, 0.05568328f, -0.08428331f, 0.04849900f, 0.02485570f, 0.00294726f, 
    0.13968103f, 0.08690955f, -0.07882100f, -0.15685883f, 0.01313649f, 0.01710175f, -0.05128897f, 0.14432812f, 
    -0.02706450f, -0.02786485f, -0.00803718f, -0.09923993f, 0.00500463f, -0.05610281f, -0.09334480f, -0.02315224f, 
    0.06538361f, 0.09148206f, -0.01794837f, -0.15555914f, -0.03641000f, -0.03003243f, 0.09448159f, -0.01130205f, 
    -0.26180473f, 0.01096305f, -0.08209674f, -0.20683029f, -0.11168380f, 0.02306097f, -0.01475294f, -0.06345627f, 
    -0.04635037f, -0.06372749f, 0.15309326f, 0.03383242f, 0.02187433f, -0.13103323f, -0.06402873f, 0.10969292f, 
    0.01267375f, -0.11794512f, 0.05172997f, 0.04575017f, 0.00379005f, 0.06916152f, 0.06812504f, 0.12984814f, 
    0.27395785f, 0.02597031f, -0.00889377f, -0.33453149f, 0.04947596f, 0.08820588f, -0.12290949f, 0.09441575f, 
    0.05991488f, 0.00049938f, 0.18419769f, 0.00221229f, 0.16138545f, -0.39272624f, -0.08297156f, 0.08173779f, 
    -0.17261681f, -0.02408342f, -0.03453499f, -0.01435558f, 0.03404788f, 0.16009198f, -0.06098226f, 0.17399222f, 
    0.30359516f, -0.47374257f, -0.09380970f, -0.00591937f, -0.09130803f, -0.08536541f, 0.10847318f, 0.14762433f, 
    -0.06245437f, -0.01112534f, -0.02256490f, -0.00592036f, -0.06957494f, -0.05424892f, -0.03543513f, 0.05191765f, 
    0.01725196f, -0.00991013f, -0.08826882f, -0.08332682f, 0.02709014f, -0.02189819f, 0.02027217f, 0.00440160f, 
    -0.08660333f, -0.03734577f, 0.25180322f, -0.15893200f, 0.04996851f, 0.01097844f, 0.06698801f, -0.07883663f, 
    0.03761037f, -0.06637519f, -0.06431387f, -0.00676608f, -0.49231070f, -0.10845088f, 0.04678087f, -0.06083816f, 
    -0.10109738f, -0.00536477f, 0.06312156f, -0.05747329f, -0.04909410f, 0.02556951f, -0.08255499f, 0.12509055f, 
    -0.07757614f, 0.03894950f, -0.23495233f, -0.04432515f, 0.01766033f, 0.04652300f, 0.07985788f, -0.03357702f, 
    0.09559057f, 0.19437015f, 0.03930863f, 0.00547855f, 0.03613105f, 0.07423823f, -0.27316296f, -0.17760280f, 
    0.05269714f, -0.04948613f, 0.01236746f, 0.02708308f, 0.05658283f, -0.08486633f, -0.01224487f, -0.04387092f, 
    0.03167798f, -0.28824568f, 0.08787868f, -0.13884644f, -0.00337760f, 0.06956961f, 0.02022014f, -0.03498382f, 
    -0.03640907f, -0.08234788f, 0.07414641f, -0.16023734f, 0.26153120f, -0.03841537f, 0.17771254f, -0.12206352f, 
    -0.04304007f, 0.03860790f, 0.09318779f, -0.15710238f, -0.02299737f, -0.01658840f, -0.00772329f, 0.02063904f, 
    -0.04085491f, 0.13266541f, -0.10327426f, -0.21558695f, 0.09010235f, 0.09923816f, 0.01961202f, -0.04021376f, 
    -0.15707682f, -0.01119270f, 0.10847859f, -0.02249660f, 0.07040550f, -0.00587511f, 0.29741472f, -0.02046669f, 
    0.00065522f, -0.00584904f, -0.08774796f, 0.00008207f, -0.02987300f, 0.06145393f, -0.01701316f, 0.02710897f, 
    0.28508991f, -0.17085123f, 0.15204470f, 0.02484493f, 0.04071343f, -0.03423650f, -0.00246800f, -0.00198985f, 
    -0.11646546f, 0.05981934f, 0.01587554f, 0.09310102f, -0.32927299f, -0.26362360f, 0.16047336f, -0.14438596f, 
    0.02818363f, 0.05856143f, 0.00969867f, 0.12255582f, -0.00028205f, 0.00737085f, -0.11484769f, -0.01237187f, 
    -0.28685227f, 0.18304379f, 0.15912855f, 0.06442169f, -0.02497042f, 0.12017846f, -0.09760387f, 0.12627962f, 
    0.08330134f, 0.00123196f, 0.09018554f, 0.04550101f, 0.28034189f, -0.10563660f, -0.09334183f, 0.14954402f, 
    0.00410639f, -0.01045231f, -0.10317762f, -0.04534057f, 0.08121973f, -0.02564606f, 0.01917940f, -0.05164672f, 
    0.18564385f, -0.03960358f, 0.20305206f, 0.03452934f, 0.09514084f, 0.06551331f, -0.08533647f, -0.08232161f, 
    -0.08738721f, 0.06939332f, -0.07678089f, 0.10581058f, -0.37454453f, 0.02114191f, -0.03672862f, -0.08401698f, 
    0.04583627f, -0.02454269f, -0.01478876f, 0.05752386f, 0.04952780f, 0.00042107f, -0.01776051f, -0.00123130f, 
    0.05328987f, -0.12391731f, 0.01847208f, -0.04273383f, -0.05426168f, -0.07341491f, -0.05493688f, 0.01849803f, 
    0.06628467f, 0.01100572f, 0.08637960f, -0.05138281f, -0.14515273f, -0.02174959f, -0.12042919f, -0.01820684f, 
    0.01353259f, 0.10177888f, -0.12093582f, -0.04692092f, 0.03957554f, -0.05490134f, -0.10795712f, -0.02455409f, 
    -0.25485161f, 0.09099873f, 0.00667977f, -0.12782000f, 0.01727404f, -0.07896881f, 0.00002307f, 0.08484003f, 
    -0.00609457f, 0.14446133f, -0.01312008f, 0.00285247f, -0.09524558f, 0.05613302f, -0.20763238f, -0.42245528f, 
    0.07609954f, -0.05622584f, 0.01232096f, 0.03513926f, 0.03820515f, 0.00935445f, 0.06227225f, -0.04202243f, 
    -0.38418758f, -0.13346057f, -0.14785407f, -0.15093951f, -0.00546243f, 0.08465295f, 0.03393925f, 0.05939423f, 
    0.00115079f, 0.10391103f, 0.08114510f, 0.12206809f, 0.27389747f, -0.11451685f, 0.02660955f, 0.00411098f, 
    -0.00965899f, 0.06336688f, -0.07039818f, 0.05646877f, 0.07415258f, 0.08211798f, -0.09667290f, -0.05650876f, 
    -0.45353672f, 0.08559788f, -0.14453301f, 0.05525885f, 0.03964528f, -0.01324346f, -0.16694553f, -0.04195573f, 
    -0.02344007f, -0.04751561f, -0.03481168f, -0.05567434f, 0.15103832f, -0.06936580f, 0.12947053f, -0.05662557f, 
    0.00245901f, -0.06307827f, 0.04392125f, 0.10574538f, 0.00147129f, -0.01127301f, -0.04618444f, -0.04801849f, 
    -0.10749042f, -0.11344077f, 0.17514247f, 0.10961298f, -0.02013866f, -0.01518761f, 0.08933464f, 0.01201828f, 
    0.04482257f, 0.02547115f, 0.05541875f, 0.04111470f, 0.07158315f, 0.03369811f, 0.05047403f, -0.10974275f, 
    0.02095713f, 0.01570432f, 0.04724677f, 0.00695479f, -0.07081421f, -0.12255096f, -0.02423178f, -0.01112836f, 
    0.04794951f, -0.03676795f, -0.12423030f, -0.01190922f, -0.03132043f, 0.06310326f, 0.01933305f, -0.05894034f, 
    0.03837087f, 0.07267548f, 0.08084197f, 0.10145281f, 0.07087930f, -0.17871897f, -0.10239396f, 0.01425573f, 
    -0.01126412f, 0.01718592f, -0.03229704f, 0.03318063f, 0.05726262f, 0.10572782f, 0.08227912f, 0.08422484f, 
    0.21656431f, -0.00140578f, -0.02087176f, -0.04542845f, 0.05241449f, 0.02996053f, 0.01388517f, -0.06152206f, 
    -0.02392019f, 0.17157707f, 0.11774826f, -0.02556729f, 0.19220817f, 0.08775831f, -0.06732991f, 0.08145046f, 
    0.17780007f, -0.02081091f, 0.00658035f, -0.02893313f, 0.05800948f, 0.04535893f, -0.02699832f, -0.06507167f, 
    0.11055299f, -0.01698223f, -0.14851420f, 0.05462911f, -0.00380149f, 0.03021832f, -0.10032485f, 0.05750084f, 
    -0.03616592f, 0.04078164f, 0.15137464f, 0.00394276f, 0.13832451f, -0.06090918f, -0.08713071f, -0.11697801f, 
    -0.18637833f, -0.05342937f, 0.05525579f, 0.04510608f, -0.00408551f, -0.05748437f, -0.07722175f, -0.04127707f, 
    -0.03507032f, 0.21277812f, 0.06865263f, -0.10458932f, 0.03395452f, -0.10910795f, -0.00145061f, 0.00237737f, 
    -0.01618188f, 0.04734215f, -0.06374556f, 0.07037102f, 0.25034130f, -0.11640118f, 0.05715924f, -0.03494611f, 
    -0.11174480f, 0.01572603f, 0.00054367f, -0.02619224f, 0.14316729f, 0.13247418f, -0.10698980f, 0.03355381f, 
    0.13116500f, 0.19203351f, 0.13913357f, 0.00500204f, 0.02766243f, 0.11765120f, 0.05273111f, 0.10750647f, 
    0.02271773f, -0.05780125f, 0.12862663f, 0.02866826f, 0.08870178f, -0.05913715f, 0.08647050f, 0.02745523f, 
    -0.00475115f, 0.07355977f, 0.08665787f, 0.07852329f, 0.06431485f, 0.10868209f, 0.08514820f, 0.00699161f, 
    0.07778487f, 0.18598622f, 0.11383858f, 0.06706948f, 0.08361974f, 0.07776291f, 0.00580716f, 0.02211913f, 
    -0.14786825f, -0.02060681f, -0.00038068f, 0.07405994f, -0.07020461f, 0.11878427f, -0.00136168f, -0.09420490f, 
    -0.06480655f, 0.02520899f, -0.06146626f, 0.01757818f, 0.00004682f, 0.00050613f, 0.13804448f, 0.14306229f, 
    0.22999193f, 0.08889938f, -0.01470391f, -0.00363856f, -0.03366349f, -0.11574259f, -0.01855562f, 0.12889436f, 
    -0.00079288f, -0.14978826f, -0.05580350f, 0.00084794f, 0.16715083f, 0.05283463f, -0.02928950f, -0.00552563f, 
    -0.12707600f, -0.05878812f, 0.04487516f, -0.07669272f, 0.03082491f, -0.06856944f, -0.03359731f, -0.05696478f, 
    -0.03236788f, 0.14792770f, 0.16168915f, 0.07532562f, 0.13620563f, 0.01411921f, 0.01501315f, -0.10949343f, 
    -0.06237935f, 0.08497330f, -0.08986717f, -0.03493891f, -0.27337182f, -0.12778740f, -0.20470379f, -0.09623133f, 
    0.20776415f, -0.05687683f, 0.01433321f, 0.00604553f, -0.00446442f, 0.06380210f, 0.00242378f, -0.07299519f, 
    -0.25536817f, -0.02054028f, -0.21852361f, -0.19561438f, 0.05407880f, -0.03737773f, 0.01669622f, -0.00265693f, 
    0.04718919f, -0.09702209f, -0.02772479f, -0.17870241f, -0.25128829f, -0.01077453f, -0.06206264f, -0.01625790f, 
    -0.04174075f, 0.10686200f, -0.06810280f, -0.11302747f, -0.00829324f, -0.06419227f, -0.07257298f, -0.14820199f, 
    -0.02273708f, -0.09250769f, -0.01076272f, -0.04017523f, 0.03468956f, 0.04639786f, -0.10398537f, -0.00815792f, 
    0.11004096f, 0.00270442f, 0.07470804f, 0.03721336f, -0.34703591f, -0.27853525f, -0.03718065f, -0.10891038f, 
    -0.03525698f, -0.01955342f, 0.03750587f, 0.01591431f, -0.03553936f, 0.12104630f, 0.15697703f, 0.03398048f, 
    -0.35120907f, -0.27700499f, -0.05367569f, 0.03872657f, 0.07187089f, 0.08532173f, 0.05138965f, 0.02825908f, 
    0.07919958f, -0.00935888f, -0.07002531f, 0.04406029f, 0.09496886f, 0.05787034f, -0.07210994f, 0.09852436f, 
    0.04536662f, -0.02560195f, 0.08028193f, -0.03044309f, 0.04940935f, 0.10194966f, 0.00119716f, 0.10139204f, 
    0.01784349f, 0.06490207f, -0.06091834f, 0.01435502f, 0.00310168f, -0.06909419f, -0.02397377f, -0.03180824f, 
    -0.03777098f, 0.03657785f, -0.04421620f, 0.05220828f, -0.26059592f, -0.20181805f, 0.09799253f, 0.05881379f, 
    0.03978514f, 0.02386620f, 0.03260040f, -0.02761979f, -0.02693456f, -0.02758374f, -0.05522410f, 0.10071253f, 
    0.10850941f, 0.28430793f, 0.05061003f, -0.03493345f, 0.02337374f, 0.10957629f, 0.01118883f, 0.07761267f, 
    0.03490724f, -0.01516256f, 0.10525677f, 0.16810866f, -0.51548737f, -0.22546865f, 0.00165342f, -0.11556953f, 
    0.09466130f, -0.06596480f, -0.10994445f, -0.04580335f, -0.09355035f, -0.12343446f, -0.01663769f, 0.02229196f, 
    0.03485803f, -0.03584473f, -0.05417237f, -0.01641582f, 0.00421076f, 0.03693533f, 0.09491985f, -0.05435299f, 
    -0.08501084f, 0.10376136f, -0.00190026f, -0.00695013f, 0.19398327f, 0.03684248f, 0.04127320f, -0.18017459f, 
    0.01060638f, -0.03054390f, -0.00539544f, -0.01575060f, 0.09195389f, -0.04720982f, -0.07063859f, 0.00041981f, 
    0.00794304f, 0.12749842f, 0.01497026f, 0.09755930f, 0.04467142f, -0.01503567f, -0.07088234f, -0.09724122f, 
    0.03509728f, 0.10333766f, 0.04100772f, -0.04344306f, 0.18580028f, -0.01665688f, -0.04098537f, 0.02378347f, 
    0.16009609f, -0.13828303f, -0.09294357f, 0.04298587f, -0.07272547f, -0.03729677f, -0.07994825f, 0.08393378f, 
    0.05958147f, -0.21821454f, -0.19021195f, 0.00597108f, 0.00937133f, -0.09259560f, 0.01538200f, 0.02185177f, 
    0.04526462f, -0.00860864f, -0.11813910f, 0.02917071f, -0.15721330f, -0.10037358f, 0.00621597f, 0.06190747f, 
    0.08867976f, -0.04909549f, 0.05033972f, -0.08557011f, 0.02584126f, 0.00749436f, -0.01683992f, 0.13332407f, 
    -0.05597508f, -0.02784246f, 0.05629873f, 0.11177681f, 0.04199086f, -0.02724982f, 0.14453937f, -0.08083276f, 
    -0.01401985f, 0.06030326f, -0.05216376f, 0.03168589f, -0.43442026f, -0.19093882f, -0.17642425f, -0.13081534f, 
    0.06578731f, -0.04864575f, -0.10987968f, -0.00655423f, -0.05338621f, -0.02367932f, -0.02946420f, 0.13795650f, 
    -0.25615755f, -0.04816144f, 0.01064075f, -0.11558750f, 0.07349106f, -0.01891597f, -0.08614474f, -0.01498620f, 
    -0.01044945f, -0.19970194f, -0.23482604f, -0.17375571f, 0.12142041f, 0.01748416f, -0.00214154f, -0.05249167f, 
    -0.07356794f, -0.04565028f, 0.06158986f, -0.02864949f, 0.02353457f, 0.01288166f, 0.02482201f, -0.04429993f, 
    -0.53826731f, -0.01356670f, -0.28658545f, -0.15032749f, 0.07517022f, 0.01700308f, -0.05176928f, -0.08408421f, 
    0.09589145f, -0.00329738f, 0.00432214f, -0.00720714f, 0.10738133f, 0.03336925f, -0.01652234f, 0.10587529f, 
    -0.02343172f, -0.01016208f, 0.00388924f, 0.03903151f, 0.08218833f, 0.06488071f, -0.00317918f, -0.05649537f, 
    0.04769070f, -0.07733919f, 0.00085001f, -0.00107446f, 0.01221273f, 0.04346349f, 0.02117330f, -0.02600211f, 
    0.01822476f, 0.13356093f, -0.08428180f, 0.04819713f, 0.20725003f, 0.04114167f, -0.05490196f, 0.07654443f, 
    0.02930966f, -0.08966707f, -0.04179573f, -0.00853099f, -0.02208774f, 0.00935325f, -0.03048744f, -0.02222358f, 
    -0.37452632f, -0.08887761f, 0.01301673f, 0.00097554f, 0.01641366f, 0.00977294f, 0.02983318f, 0.01974500f, 
    0.03837683f, 0.07531956f, 0.00676648f, 0.06650748f, -0.04684361f, 0.03706477f, 0.02584391f, 0.15918036f, 
    0.09178036f, -0.13274661f, -0.04339684f, 0.04192379f, -0.05016033f, 0.03095785f, 0.00134242f, 0.09762488f, 
    -0.16382937f, 0.01533975f, -0.15851502f, -0.10934988f, 0.06477241f, 0.02956171f, -0.04684218f, 0.04656398f, 
    -0.03473547f, -0.12046194f, -0.08822243f, -0.10572544f, -0.04779472f, 0.13526970f, 0.05801516f, -0.07203601f, 
    0.13025866f, -0.04740966f, -0.01211531f, 0.05285021f, 0.04005079f, 0.09167109f, 0.11042405f, 0.07443272f, 
    0.07776722f, 0.21006767f, -0.04049800f, -0.14024915f, 0.02168306f, -0.08581913f, -0.01114968f, 0.14006908f, 
    0.01950444f, 0.09917470f, 0.01671585f, 0.09473796f, -0.48050225f, 0.01712207f, 0.06679342f, 0.07752731f, 
    0.12272335f, -0.03131551f, 0.01625542f, -0.01980404f, 0.02608306f, -0.01329239f, -0.04285876f, 0.09736349f, 
    -0.24053860f, -0.19858547f, -0.10612606f, -0.13842565f, 0.03610624f, 0.07128111f, -0.05545825f, -0.00051798f, 
    0.01752923f, -0.05132230f, 0.09064259f, 0.06830955f, -0.34708023f, -0.05942725f, -0.01088823f, 0.02598157f, 
    0.09877799f, 0.05688152f, -0.04738759f, -0.05150084f, 0.09360033f, -0.07721012f, 0.05555000f, -0.00039041f, 
    0.09813233f, 0.05484250f, -0.16637748f, -0.09607167f, 0.03936357f, 0.05772016f, -0.03990510f, 0.09287331f, 
    0.09694053f, 0.06871193f, 0.02373222f, 0.00466954f, 0.09112805f, 0.07050729f, -0.06043577f, -0.02979149f, 
    -0.10732201f, -0.00333450f, 0.03938650f, -0.06296158f, -0.02458109f, -0.06080279f, 0.05099247f, -0.08988025f, 
    -0.46655181f, -0.26863560f, 0.11596616f, -0.02017962f, 0.06371858f, -0.01210496f, 0.06650022f, -0.02500358f, 
    0.09787655f, -0.03222284f, -0.12310318f, -0.05724112f, 0.23520601f, 0.04125003f, -0.11366166f, 0.07219017f, 
    -0.18714555f, -0.07126197f, 0.06965042f, 0.08486543f, -0.03630709f, 0.04596974f, 0.00603927f, 0.03762902f, 
    -0.45295951f, -0.16521920f, 0.10236657f, 0.13830185f, 0.07665254f, 0.06254433f, 0.10000198f, 0.00467814f, 
    0.09333881f, 0.12783425f, -0.11319741f, 0.02453480f, -0.58296138f, -0.41134390f, -0.05530295f, -0.16481330f, 
    0.02459007f, 0.03110748f, -0.06172800f, -0.08867396f, 0.02336961f, -0.03316798f, -0.01344003f, -0.09396962f, 
    -0.21007483f, -0.16353352f, -0.17830940f, -0.14285943f, 0.07506120f, 0.04970223f, 0.00222065f, -0.06705696f, 
    -0.05094613f, -0.05319974f, -0.26822332f, -0.04107593f, -0.15045847f, -0.07314731f, 0.00019930f, -0.10934378f, 
    -0.09095027f, 0.03054055f, 0.03973078f, 0.10745143f, 0.10081165f, -0.01725655f, -0.05015992f, -0.05403946f, 
    -0.00749560f, -0.11363780f, 0.08348352f, -0.12434936f, 0.03014847f, -0.06226221f, -0.03102760f, 0.02812457f, 
    -0.04675607f, -0.07430865f, -0.00752773f, -0.10569017f, 0.27265844f, -0.32692578f, -0.14050433f, 0.15216419f, 
    -0.00249786f, -0.08624177f, 0.01016533f, -0.16556162f, 0.05429329f, 0.02053537f, 0.08218593f, 0.02071974f, 
    0.24167022f, -0.06947657f, -0.13849805f, 0.09651496f, 0.00647122f, -0.01741209f, -0.01464177f, -0.03645789f, 
    0.03065374f, -0.05839102f, -0.07824463f, -0.05712743f, -0.20185572f, 0.15819821f, 0.14188631f, -0.11019468f, 
    0.02830945f, -0.00624404f, 0.06794327f, -0.01877853f, 0.03830288f, 0.01922082f, 0.04120426f, -0.05911675f, 
    0.16757482f, 0.06596066f, 0.03434267f, -0.09959614f, -0.14578918f, 0.05008547f, -0.05025659f, -0.03590804f, 
    -0.00307718f, -0.02307576f, 0.02740048f, 0.10913644f, 0.01970477f, -0.10764449f, -0.00348170f, 0.19673261f, 
    0.03214165f, -0.01649860f, -0.00977904f, -0.03866029f, -0.02742161f, 0.05185411f, 0.01564244f, -0.01006824f, 
    -0.06234740f, -0.07240210f, 0.07146064f, 0.05959392f, 0.05450995f, -0.09888786f, -0.03613240f, 0.05113506f, 
    -0.01413845f, 0.00639834f, 0.03583829f, -0.06598280f, 0.10576186f, 0.09706482f, -0.14392886f, -0.16318788f, 
    -0.11976022f, -0.01755553f, -0.04542109f, -0.12236959f, 0.01240900f, -0.00251664f, -0.01298705f, -0.09308715f, 
    -0.07788473f, 0.12853135f, -0.09568601f, 0.07718744f, 0.02772921f, -0.04437129f, 0.03397483f, 0.03122700f, 
    -0.22754814f, 0.05506674f, -0.02584085f, -0.07963032f, 0.00320079f, 0.05193664f, 0.00051682f, 0.10336354f, 
    0.16283293f, -0.02586007f, -0.00835439f, 0.08469155f, -0.09957764f, 0.02435748f, -0.05490208f, -0.01600047f, 
    0.18437867f, 0.03101477f, -0.00161156f, 0.06647446f, -0.03621651f, 0.04414908f, 0.00429965f, -0.04626500f, 
    -0.04186305f, -0.04271005f, 0.02189644f, 0.05146603f, 0.03113307f, -0.27109876f, -0.10725647f, 0.07705920f, 
    0.01425942f, 0.03849712f, 0.05576881f, -0.03979987f, 0.13842314f, -0.01627756f, 0.00092069f, 0.01901788f, 
    0.06338033f, 0.11045919f, -0.02666438f, 0.02680365f, 0.13434446f, 0.04706692f, 0.08131883f, -0.21677548f, 
    0.03812035f, -0.12105659f, 0.02503007f, -0.12100514f, -0.20021105f, -0.27933007f, -0.08577557f, 0.03206767f, 
    0.01607756f, 0.02679357f, -0.00537327f, 0.00419348f, -0.11051416f, 0.03658307f, -0.04241544f, 0.01294381f, 
    0.07138889f, -0.03529990f, -0.09005581f, -0.15863070f, 0.12803242f, -0.05775187f, -0.03483659f, 0.07930635f, 
    -0.01506956f, -0.09177434f, -0.01818306f, -0.01339491f, 0.05696269f, 0.08931284f, 0.08220034f, -0.01787210f, 
    0.00986721f, -0.12287536f, -0.07040651f, -0.14448918f, -0.05565420f, 0.04992498f, 0.06176043f, 0.02081968f, 
    0.15876739f, 0.13795169f, -0.11126445f, 0.17315355f, -0.08054890f, -0.00681345f, 0.07812694f, -0.01301158f, 
    -0.01336730f, 0.08329435f, -0.06846233f, 0.01863322f, 0.18627144f, 0.04158973f, -0.07660234f, 0.15728638f, 
    0.13002706f, -0.09941626f, 0.00719371f, 0.05175963f, 0.07134960f, -0.03906774f, -0.04032516f, -0.03616224f, 
    0.08261648f, -0.00518649f, 0.01137502f, -0.24070053f, -0.02116518f, -0.05877232f, 0.02339073f, -0.00971907f, 
    -0.00737402f, -0.15805829f, -0.01526662f, 0.04394605f, 0.07280865f, -0.14002840f, 0.04831245f, -0.12368312f, 
    0.16987862f, -0.01657766f, -0.11411261f, 0.01124310f, 0.05721018f, -0.04649615f, -0.07555065f, -0.02750015f, 
    0.24210122f, -0.10453667f, 0.14605130f, 0.07208250f, 0.03465207f, -0.00215842f, 0.08313823f, -0.05201191f, 
    -0.02793466f, 0.07421687f, 0.02540210f, 0.12298236f, -0.09170710f, -0.35227251f, 0.07197576f, -0.08459746f, 
    -0.12478108f, -0.01638315f, 0.07658026f, 0.15482517f, -0.01239721f, -0.01101782f, -0.09358343f, -0.17126007f, 
    0.17957841f, -0.02056390f, 0.06564823f, -0.02361698f, -0.02992346f, 0.03395759f, -0.10674005f, 0.00366931f, 
    0.12387081f, -0.06484693f, -0.02068880f, 0.08696552f, 0.04081595f, -0.45672604f, -0.09211315f, 0.37130940f, 
    -0.02849161f, 0.11337891f, -0.01176112f, 0.05622516f, 0.07243254f, -0.06419485f, -0.01624278f, 0.11494141f, 
    -0.31347585f, 0.01958420f, 0.07544715f, 0.11265530f, 0.01804586f, 0.11357437f, -0.15577488f, 0.03477392f, 
    0.02138279f, 0.03440156f, 0.18866727f, -0.02482625f, -0.23111039f, -0.17278531f, 0.22428925f, -0.05465538f, 
    -0.13572825f, 0.06178525f, -0.02676609f, 0.07507414f, -0.09518723f, 0.01505769f, 0.14092176f, 0.00048050f, 
    0.14869381f, -0.25129259f, -0.08549511f, 0.08044270f, -0.03207841f, -0.04991357f, -0.02689268f, -0.06241313f, 
    0.00610458f, -0.01195169f, -0.10057102f, -0.05515215f, 0.19118005f, -0.21090893f, -0.16178374f, -0.02146387f, 
    0.05856206f, 0.01482678f, -0.00656283f, -0.05279722f, -0.01634863f, -0.01946055f, -0.06552058f, -0.04307061f, 
    0.19047724f, -0.05397739f, -0.08116961f, -0.14840893f, -0.01469570f, -0.03133496f, -0.00707347f, 0.09367098f, 
    -0.06986316f, 0.06207944f, -0.02549132f, 0.02845906f, 0.08359896f, -0.07729861f, -0.01639439f, 0.10685254f, 
    -0.00716460f, 0.02978051f, -0.05217641f, 0.01812053f, 0.06426548f, -0.03571473f, 0.01229544f, 0.02968959f, 
    -0.18971342f, -0.04298320f, -0.05457886f, 0.09220341f, -0.08471277f, 0.10541471f, -0.02903196f, 0.04171686f, 
    -0.10669219f, 0.10116886f, 0.05987974f, -0.14085142f, -0.14005859f, -0.11331725f, 0.06622093f, -0.18856961f, 
    0.04328625f, -0.04013297f, -0.07424462f, 0.12813440f, -0.11550540f, -0.06490383f, 0.05227604f, 0.04820637f, 
    -0.04385078f, 0.04169407f, -0.05069556f, -0.02602394f, 0.08721595f, 0.09395251f, 0.00856423f, -0.05925266f, 
    -0.04586499f, 0.03557059f, -0.06621566f, 0.08331438f, -0.02069454f, -0.13889025f, -0.12528989f, -0.35596871f, 
    0.03777169f, -0.02741938f, -0.00977531f, -0.04114025f, -0.00919312f, 0.07048988f, -0.14301229f, 0.03051648f, 
    0.04340877f, 0.06176455f, 0.01327970f, 0.07357751f, -0.07646209f, -0.16719702f, 0.09370495f, 0.15818986f, 
    -0.01057951f, -0.07299761f, -0.05230439f, -0.10558169f, -0.12799761f, 0.20063236f, -0.10060150f, -0.02391746f, 
    -0.05968340f, -0.01376344f, 0.01014346f, -0.10502550f, 0.02209734f, 0.09572646f, 0.01829315f, -0.14913835f, 
    0.18699045f, -0.12679328f, -0.02775200f, -0.02563657f, -0.20833428f, -0.02735114f, 0.04226859f, -0.01974905f, 
    -0.06497248f, -0.03313809f, -0.00933137f, -0.17758676f, 0.11171316f, 0.01359238f, 0.04181587f, -0.06822626f, 
    -0.10513762f, -0.07968559f, 0.04684579f, 0.09093928f, -0.04083289f, 0.01257060f, -0.04974676f, 0.05568974f, 
    -0.23434405f, -0.20416519f, 0.01201492f, -0.07136710f, 0.14032760f, -0.06980743f, 0.05522422f, 0.03771130f, 
    0.04418558f, -0.03913856f, 0.02098844f, 0.02257612f, 0.17166926f, -0.09370520f, 0.06882148f, 0.14176853f, 
    -0.01226534f, 0.01129587f, 0.01327063f, 0.07123300f, -0.00911686f, 0.04232433f, -0.00057000f, -0.00778010f, 
    0.00578530f, -0.25036970f, -0.01083555f, 0.04055623f, 0.05540492f, -0.15373041f, -0.02673266f, 0.09478325f, 
    0.04856386f, -0.06176834f, 0.05049098f, 0.06620544f, -0.10575155f, 0.07039760f, -0.12398019f, -0.10243296f, 
    -0.04799399f, -0.02172979f, -0.01818486f, 0.06549151f, 0.06666934f, -0.04636560f, -0.01650937f, -0.09784437f, 
    0.07072675f, -0.02937322f, -0.13386840f, 0.18103473f, -0.10113785f, -0.00142009f, -0.03609825f, -0.14154823f, 
    0.07173300f, -0.01776252f, 0.05954278f, 0.07923593f, -0.08968803f, 0.10513496f, -0.02921160f, -0.03141481f, 
    -0.01485063f, -0.10130771f, 0.06364235f, -0.02296141f, 0.05816044f, 0.08283920f, 0.03926218f, -0.00923516f, 
    -0.06137523f, -0.13897462f, -0.13869026f, 0.17931649f, -0.05322158f, 0.03125974f, -0.01207109f, 0.04912211f, 
    0.09198042f, 0.01657738f, 0.07030603f, 0.04267372f, -0.19956136f, 0.04177262f, 0.04471464f, 0.03981173f, 
    0.09439212f, -0.06640749f, 0.05113689f, -0.06625698f, -0.08454838f, -0.03871521f, 0.07104596f, 0.18559761f, 
    -0.16862094f, -0.09696852f, 0.14938889f, 0.14080852f, 0.10802340f, 0.05209481f, -0.12165703f, 0.00127948f, 
    -0.08676133f, -0.17097504f, 0.02176190f, -0.02098596f, 0.03177208f, -0.04011253f, -0.05263538f, -0.05263281f, 
    0.01524519f, -0.07904902f, 0.07570195f, 0.10849347f, -0.07057040f, -0.00369143f, -0.06160141f, 0.00808465f, 
    0.12753557f, 0.26320097f, -0.06030933f, -0.01942273f, 0.12810498f, 0.03118753f, -0.15547848f, 0.02369346f, 
    0.05767288f, -0.00546521f, 0.02954136f, 0.08673083f, 0.13164681f, -0.11221374f, -0.06245712f, -0.14939293f, 
    -0.06558070f, -0.04705824f, -0.06017401f, -0.07118971f, -0.07334718f, -0.02907142f, 0.13073796f, 0.03066761f, 
    -0.34340212f, -0.06625909f, -0.20800510f, -0.24819887f, 0.08502154f, 0.01762228f, 0.06961498f, -0.04551574f, 
    0.08230428f, 0.01242045f, -0.01092725f, -0.03797206f, 0.04842858f, -0.25908786f, 0.03670776f, 0.32145539f, 
    -0.07819141f, 0.13989131f, 0.08376789f, 0.07496972f, -0.06896329f, 0.03005375f, -0.10589284f, -0.06375703f, 
    0.10874318f, 0.02299117f, -0.05083520f, 0.12841037f, -0.11251558f, 0.14416221f, -0.03489811f, 0.13724750f, 
    0.05512572f, -0.15624712f, -0.07421631f, -0.06422126f, 0.50272948f, 0.06360963f, -0.00340453f, -0.21489489f, 
    -0.00707036f, -0.07692352f, -0.13659689f, 0.04773070f, 0.04093089f, 0.07552939f, 0.08955397f, 0.07260191f, 
    0.31299594f, -0.23060386f, -0.21938640f, -0.13958971f, 0.06320966f, -0.06355760f, 0.04692731f, 0.05033037f, 
    0.02698927f, 0.07294018f, -0.01811656f, -0.02676383f, 0.08999440f, -0.10852281f, 0.00090342f, 0.02258142f, 
    -0.01771040f, -0.05096098f, 0.03630537f, 0.07529119f, 0.04247789f, 0.06324435f, -0.09247629f, -0.00169227f, 
    -0.54177642f, 0.21611287f, 0.08339921f, -0.07305738f, -0.07808691f, -0.03373731f, -0.07396465f, 0.05715290f, 
    0.02049042f, 0.14883010f, 0.01223203f, -0.03751493f, 0.17971355f, -0.01783695f, -0.09036917f, 0.06367014f, 
    -0.14612709f, 0.00976843f, 0.05245420f, -0.04525987f, 0.00707929f, -0.01064871f, -0.15562940f, -0.10943332f, 
    -0.05666943f, 0.12602885f, -0.18357360f, 0.12270900f, 0.17554326f, 0.10778645f, -0.04703994f, -0.12585333f, 
    0.08447311f, 0.06301320f, 0.01465497f, 0.00026325f, -0.09934638f, 0.04007449f, 0.12991507f, 0.00613426f, 
    0.09283351f, -0.02111832f, 0.04762100f, -0.03248924f, -0.04254247f, -0.00855828f, 0.09397047f, 0.04988292f, 
    0.50932074f, 0.13706227f, -0.00191786f, 0.05020816f, -0.02705283f, -0.02532552f, -0.02288557f, 0.02399876f, 
    0.10253565f, 0.02069369f, 0.01570667f, 0.04174031f, 0.41267791f, -0.12958206f, -0.12000838f, -0.19669273f, 
    0.08604670f, -0.05318227f, 0.06346928f, -0.10257442f, 0.03035154f, 0.01580166f, -0.04066626f, -0.00660469f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.05759543f, 0.00897414f, -0.04726705f, -0.00950352f, -0.01052331f, 0.01995476f, 0.00962783f, -0.05696810f, 
    -0.02346514f, -0.02714927f, 0.05244223f, 0.03088852f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
