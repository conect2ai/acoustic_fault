#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.04993091f, 0.20960662f, -0.34907523f, -0.27885869f, 0.10335881f, 0.01427305f, 0.38422608f, 0.17650901f, 
    0.16328669f, -0.01264470f, -0.02080540f, 0.51409358f, -0.29201165f, -0.18767549f, 0.32607189f, -0.08837890f, 
    -0.51740837f, 0.04790356f, 0.09235529f, 0.29139104f, 0.23277870f, 0.02919752f, 0.05753098f, 0.29380703f, 
    0.16513126f, 0.68939525f, 0.54760993f, 0.87927246f, -0.16693716f, -0.02919932f, -0.36888534f, 0.44050023f, 
    -0.21802782f, -0.22901385f, -0.06568898f, -0.26282680f, 0.30568400f, 0.27013999f, 0.28767014f, 0.26690277f, 
    0.06588140f, 0.09837654f, -0.04337310f, -0.03721185f, 0.16916271f, -0.40768501f, 0.11671779f, 0.00744999f, 
    0.05502828f, -0.06232621f, 0.23183233f, 0.45144719f, 0.52414238f, 0.00508980f, -0.35556585f, -0.09103307f, 
    -0.36201751f, -0.70377016f, -0.27922589f, -0.12636952f, 0.02033873f, 0.45390552f, 0.49390575f, 0.31542993f, 
    -0.14780536f, -0.08143374f, -0.30475357f, 0.01311540f, 0.31349048f, -0.00319449f, -0.17534798f, 0.13816231f, 
    -0.03651066f, -0.11624353f, 0.31289691f, -0.57491767f, 1.21284282f, -0.39890608f, -0.18510139f, 0.45323056f, 
    -0.15597264f, 0.31563401f, 0.14975013f, -0.28360912f, 0.33225664f, 0.03220794f, -0.20133588f, 0.20224242f, 
    -0.21202442f, -0.03345672f, 0.00019354f, -0.17860730f, 0.11965752f, 0.11745153f, -0.39189765f, -0.08750626f, 
    0.05996262f, -0.22945155f, 0.02287739f, 0.17548925f, 0.96617180f, 0.32131261f, -0.25969601f, 0.82395905f, 
    0.44168088f, 0.30922467f, 0.35423967f, -0.55913210f, 0.42121273f, -0.15715881f, 0.10157160f, 0.06197166f, 
    -0.11384381f, -0.20457499f, -0.44765091f, 0.28287005f, -0.27069563f, -0.00820293f, -0.08858206f, 0.08274490f, 
    0.00293317f, -0.00059544f, 0.18394300f, -0.19152048f, 0.11348657f, 0.18614256f, -0.23625094f, -0.58035839f, 
    -0.75206715f, 0.46942458f, -0.03176711f, -0.03482278f, 0.41359383f, 0.17302187f, 0.09244145f, -0.55675358f, 
    0.00208068f, -0.16451772f, -0.19138892f, 0.00777769f, 0.23027827f, -0.36716962f, 0.17866886f, -0.03114849f, 
    -0.31707928f, -0.19845006f, 0.14294922f, -0.44766477f, 0.08555733f, 0.13827404f, -0.22477217f, 0.08770885f, 
    -0.33751255f, -0.03772390f, 0.58439493f, -0.03855556f, 0.33417255f, -0.37349400f, -0.08284857f, 0.11811601f, 
    0.44086415f, -0.08973883f, -0.13721900f, 0.18961051f, 0.10472589f, 0.08013695f, -0.06685501f, 0.10867078f, 
    0.10155948f, 0.14833522f, 0.17786469f, -0.20734473f, -0.41059196f, 0.25794092f, 0.32310587f, -0.24821468f, 
    -0.61738431f, -0.04173602f, -0.47362772f, -0.06907809f, 0.67848945f, -0.02545706f, 0.38041127f, 0.39699927f, 
    0.23983189f, 0.12469382f, -0.09597385f, -0.09204818f, -0.02734314f, 0.34504893f, -0.02296409f, 0.00433682f, 
    -0.27622494f, 0.00735946f, 0.17056148f, -0.07796275f, -0.14433967f, 0.18512279f, 0.07461809f, 0.08685610f, 
    -0.21394865f, -0.67947417f, -0.07584831f, 0.17593747f, -0.60376608f, -0.04037455f, 0.31025138f, 0.58375716f, 
    0.02557504f, -0.00816439f, -0.22090963f, 0.13670920f, -0.07075042f, 0.24178538f, -0.44056994f, -0.21112551f, 
    0.25061679f, -0.03604117f, -0.08641660f, -0.13304088f, 0.03229512f, 0.22093110f, 0.15234706f, -0.09171280f, 
    0.20570475f, 0.02882521f, 0.45491773f, 0.43578759f, -0.02354481f, -0.49893269f, -0.65761560f, -0.46402779f, 
    -0.23445725f, -0.54023451f, 0.03120236f, 0.34376690f, 0.04397455f, -0.20927796f, 0.05911548f, -0.27440652f, 
    0.21991009f, -0.15034139f, -0.11825702f, -0.11341222f, -0.19356738f, 0.05773501f, 0.22536866f, 0.11498263f, 
    0.19673438f, 0.29340574f, -0.50423008f, 0.41256604f, -0.09284632f, -0.38614842f, 0.47335079f, -0.45900282f, 
    0.15534322f, 0.05167379f, -0.37153891f, -0.12271933f, 0.07809404f, 0.24573699f, 0.54399502f, 0.18744071f, 
    0.16869403f, -0.21142767f, -0.06580938f, 0.30657944f, -0.05958152f, 0.23639736f, 0.52012289f, -0.07478910f, 
    -0.13531725f, -0.04890022f, -0.10536050f, 0.43810344f, 0.20810880f, -0.54414994f, -0.29352942f, -0.57750660f, 
    0.62024182f, 0.63188678f, -0.38318655f, -0.11987429f, 0.28240660f, -0.20722243f, -0.08937197f, -0.47203642f, 
    0.04858924f, -0.06659560f, 0.21515264f, -0.08905171f, -0.17293230f, 0.03341446f, 0.06061250f, -0.12888910f, 
    -0.25862849f, -0.28380188f, -0.17993160f, -0.03965717f, -0.18241145f, -0.39306048f, -0.15274170f, -0.42341104f, 
    -0.47451621f, -0.06820995f, 0.55614573f, 0.12568471f, 0.14461921f, -0.02898850f, 0.33052060f, 0.41131353f, 
    -0.25505608f, 0.04423258f, 0.37924868f, -0.47492999f, 0.09555333f, 0.17565958f, -0.10854930f, -0.00848695f, 
    0.16345580f, -0.15303604f, 0.12841547f, -0.10238197f, -0.05104845f, 0.44291109f, -0.22227365f, 0.73037183f, 
    0.82709080f, 0.17481709f, -0.11096873f, 0.09026090f, 0.03614373f, -0.31723037f, -0.15450288f, 0.41950130f, 
    0.11897042f, -0.25152883f, -0.11606367f, -0.11146375f, -0.36732575f, 0.06137800f, -0.09344440f, -0.18447545f, 
    -0.07005337f, 0.03294213f, 0.29654074f, 0.29523399f, -0.11498213f, 0.16471237f, 0.60942894f, 0.26468730f, 
    0.23955905f, 0.67101872f, 0.64773190f, 0.18299000f, -0.23033077f, -0.06601239f, -0.34651008f, 0.14463663f, 
    0.05737159f, 0.45556858f, -0.13348623f, 0.28462872f, -0.02536916f, 0.24997757f, -0.01471888f, -0.17084388f, 
    0.00018225f, -0.19129881f, 0.17991704f, 0.00622356f, -0.15977941f, 0.08098889f, 0.25194007f, -0.76990229f, 
    0.71447545f, -0.26966652f, -0.31306550f, 0.07524970f, 0.57944626f, -0.27677256f, -0.39894217f, 0.16458088f, 
    -0.09185975f, 0.17019519f, 0.07636771f, -0.16347310f, 0.18299820f, -0.14843301f, -0.14727966f, 0.11873145f, 
    -0.14601292f, -0.06386352f, -0.06899980f, -0.04868207f, 0.00163817f, 0.27976263f, -0.03634308f, -0.37401503f, 
    -0.35651976f, -0.51098758f, 0.12644772f, 0.29704189f, 0.45347121f, -0.16572990f, 0.19403711f, 0.36555594f, 
    -0.19764523f, -0.42513967f, 0.38189313f, -0.26906380f, 0.02462956f, 0.26041064f, 0.19295740f, 0.46726856f, 
    0.16131084f, -0.34170166f, 0.10864132f, -0.09121278f, -0.15643060f, -0.02414755f, 0.36113256f, -0.19656822f, 
    0.32707876f, -0.32688823f, -0.08515485f, 0.20342922f, -0.32599577f, 0.04028895f, -0.18861696f, -0.21774922f, 
    -0.35863537f, -0.42056367f, 0.46687624f, -0.32402956f, 0.43372852f, 0.35506096f, -0.26849908f, 0.16193238f, 
    -0.19547108f, 0.03291229f, -0.03872363f, 0.16818690f, -0.14516410f, -0.18032701f, -0.09963240f, -0.02664158f, 
    -0.18183082f, -0.18858303f, -0.41737518f, -0.47881472f, -0.42422175f, -0.29802707f, 0.21504466f, 0.34524760f, 
    0.33477712f, 0.27054602f, 0.59588099f, 0.28691331f, 0.19201967f, -0.03129283f, 0.28876755f, -0.08634547f, 
    -0.43401021f, 0.22679313f, -0.09048477f, 0.15439327f, -0.26963481f, -0.02252475f, -0.32544473f, 0.15102389f, 
    -0.17342426f, -0.11603136f, -0.16047020f, -0.13697453f, 0.08708644f, 0.00429927f, -0.03210713f, 0.47754258f, 
    0.15912320f, -0.27986023f, -0.22759002f, -0.53509641f, -0.21854243f, -0.38592863f, -0.28942412f, 0.21277072f, 
    -0.27220172f, 0.08751909f, 0.12476993f, -0.25642323f, 0.18862867f, -0.33006454f, -0.34507871f, 0.14223436f, 
    -0.00329668f, 0.32641000f, 0.22682060f, 0.24170464f, 1.00845373f, 0.27288142f, -0.79398203f, 0.43492931f, 
    0.10725490f, -0.34455180f, -0.16201551f, 0.66387582f, 0.18769863f, 0.13050297f, -0.19809179f, 0.05959573f, 
    0.33040619f, -0.03917656f, -0.24296165f, -0.28231359f, -0.03310269f, -0.08815251f, -0.24576814f, -0.10505833f, 
    0.10827032f, 0.11777775f, -0.27098921f, 0.20493628f, 0.06405094f, 0.57303107f, -0.13738780f, -0.55379355f, 
    -0.31971648f, 0.00924867f, 0.07119937f, 0.79868263f, 0.32955033f, 0.14174128f, 0.39054918f, -0.39624712f, 
    -0.15036760f, -0.37995103f, -0.14129826f, 0.16556942f, -0.18842231f, 0.20149389f, -0.10638259f, 0.05878584f, 
    0.00443365f, 0.03163424f, -0.06931691f, 0.48669681f, -0.07150575f, -0.38612002f, -0.39701834f, -0.68911302f, 
    -0.62457150f, 0.01283177f, 0.02668225f, 0.40955707f, 0.37248835f, 0.08504947f, 0.18232562f, 0.32607794f, 
    0.05562531f, -0.20557375f, 0.17339259f, -0.17991856f, 0.30477586f, -0.23139511f, -0.04277797f, 0.12718664f, 
    0.29563388f, -0.53253937f, 0.17853385f, -0.22700623f, 0.13115266f, 0.13885352f, -0.08347018f, 0.86043328f, 
    0.59010619f, -0.38221577f, -0.55659580f, -0.10602380f, -0.05966879f, 0.28743306f, -0.08365310f, 0.25441366f, 
    0.17690900f, 0.15409084f, -0.00683020f, 0.03609777f, 0.11280125f, -0.15389945f, 0.07361264f, 0.04768787f, 
    0.04890749f, 0.13190687f, 0.06709756f, 0.35206935f, 0.11220554f, -0.17842405f, -0.21736886f, 0.26833451f, 
    -0.09026673f, -0.42542148f, -0.37385157f, -0.26801255f, -0.18072078f, -0.07055984f, 0.53717029f, 0.14255124f, 
    -0.34307587f, -0.08033921f, -0.12838419f, -0.00138411f, -0.23932916f, 0.15915729f, -0.01171395f, 0.28353488f, 
    0.28347084f, 0.48118833f, 0.00494437f, -0.15164202f, 0.08783354f, -0.23655328f, -0.32957214f, 0.08616618f, 
    0.18130237f, 0.79521805f, -0.00836297f, 0.11907753f, 0.03205233f, 0.54261875f, -0.57618058f, -0.14156580f, 
    0.13500348f, 0.05330539f, -0.41205689f, -0.04590300f, -0.29489940f, 0.03711532f, -0.07720927f, 0.07580440f, 
    0.00849061f, 0.05438288f, 0.15730362f, 0.08864452f, 0.17721672f, 0.16762181f, 0.17031260f, 0.13544998f, 
    0.19270453f, 0.00821391f, 0.25025323f, 0.13427065f, 0.41547093f, -0.13718046f, 0.37050840f, -0.35802063f, 
    -0.22844367f, -0.66788077f, -0.36406150f, -0.23693515f, 0.02757999f, 0.45376635f, -0.05683149f, 0.08681273f, 
    0.18444952f, 0.06189683f, -0.23832491f, 0.06147490f, -0.15084627f, -0.08804775f, 0.19399276f, 0.18097250f, 
    0.03110355f, -0.11385364f, -0.08334863f, 0.45687762f, 0.59931195f, -0.13122205f, -0.12728716f, 0.52805787f, 
    -0.11049064f, -0.08568808f, -0.48231617f, -0.09391452f, -0.11610667f, -0.07643887f, -0.10184696f, 0.11891022f, 
    0.34544316f, 0.07294316f, -0.08689375f, 0.15394655f, 0.35003588f, 0.20249939f, 0.34481984f, -0.09712742f, 
    -0.29473349f, -0.30031362f, -0.09403683f, -0.37139940f, -0.80208093f, -0.57049471f, -0.10307910f, 0.47655773f, 
    0.33161363f, -0.23955281f, 0.60805529f, 0.06370284f, -0.22704877f, 0.13077255f, -0.24005519f, 0.22248635f, 
    0.44022343f, -0.19057426f, 0.09032686f, -0.31401533f, 0.17074490f, 0.16220152f, 0.26295844f, -0.12793854f, 
    0.18869831f, 0.10274117f, -0.24219507f, -0.03687967f, -0.06428044f, -0.21863388f, -0.37829036f, -0.53322572f, 
    0.48225644f, 0.16805065f, -0.12239238f, -0.52208352f, 0.28877473f, -0.35747823f, -0.08719582f, -0.02963994f, 
    0.18892403f, 0.09870876f, 0.01377361f, -0.04224471f, 0.18620579f, 0.13520972f, 0.01208158f, -0.51322114f, 
    0.33233300f, -0.15946794f, 0.02391620f, 0.00859120f, 0.01273220f, -0.17025094f, -0.66479081f, -0.22393525f, 
    -0.17512164f, 0.35954633f, -0.11668944f, -0.14316641f, 0.21964979f, -0.31481418f, 0.62247592f, 0.22366717f, 
    0.18626229f, -0.18595494f, 0.12722039f, -0.15314716f, -0.27929974f, 0.34544325f, 0.23176689f, 0.49122787f, 
    0.18009746f, -0.14693761f, 0.17549506f, 0.20780969f, -0.13198844f, -0.08813109f, 0.42060143f, 0.44735864f, 
    0.48343161f, 0.35656497f, 0.81382430f, 0.53232223f, -0.17477490f, -0.34952047f, 0.19973148f, -0.09918053f, 
    -0.08748011f, -0.08814556f, 0.23623042f, 0.07158990f, 0.18395333f, -0.05887449f, 0.09104280f, -0.03050187f, 
    -0.04048283f, 0.35898176f, 0.27262288f, -0.13071409f, -0.02533427f, -0.19818299f, -0.01260833f, -0.07622088f, 
    0.03074031f, 0.40285158f, 0.43829829f, 0.67256987f, 0.25608915f, 0.30443379f, 0.13814557f, 0.26781160f, 
    -0.21126275f, 0.43974870f, -0.18165717f, -0.24299860f, -0.13639708f, -0.02810614f, -0.24102688f, -0.21270539f, 
    0.00385728f, 0.19272557f, -0.00717964f, -0.18107483f, 0.03378850f, -0.26794171f, -0.07780990f, 0.04189492f, 
    0.10221507f, -0.15439238f, -0.15102810f, -0.39659128f, -0.33569872f, 0.32800448f, -0.15023510f, -0.29419333f, 
    -0.59767467f, -0.28074700f, -0.16342436f, -0.08231346f, 0.32468015f, 0.19523023f, -0.07562646f, 0.10249744f, 
    0.34948641f, 0.16483797f, 0.01813277f, 0.01287904f, -0.11873657f, 0.23828223f, -0.00906972f, 0.46160251f, 
    -0.05872337f, 0.10955599f, -0.65624034f, -0.15404885f, -0.42083377f, -0.01559780f, -0.31386030f, -0.00502825f, 
    -0.45208430f, -0.09289398f, 0.38233474f, 0.34602597f, 0.28708774f, -0.02147826f, -0.39550522f, -0.24425764f, 
    -0.10481568f, 0.08763143f, 0.35516602f, -0.20230590f, -0.31345180f, 0.00178986f, -0.12512136f, 0.23949739f, 
    0.43836838f, 0.21497405f, 0.21520114f, -0.19412394f, -0.18656653f, 0.19215423f, -0.28275707f, -0.30997646f, 
    -0.34313738f, -0.19912821f, -0.29301801f, -0.58865458f, -0.50025022f, -0.29242101f, 0.31444183f, -0.10994944f, 
    0.07300539f, -0.36516070f, 0.33855772f, -0.29107913f, 0.27333611f, 0.13382080f, 0.21293494f, -0.03004760f, 
    -0.05200913f, 0.12739804f, 0.09983855f, 0.24817370f, 0.18563415f, 0.51712841f, -0.03025377f, 0.32210594f, 
    -0.00118240f, 0.07657933f, 0.52089089f, 0.67295378f, 0.24006099f, 0.34803894f, 0.01851802f, -0.08306802f, 
    -0.22416720f, -0.34218621f, -0.19629069f, -0.21438989f, -0.06073403f, -0.02584966f, 0.23345272f, -0.03976303f, 
    -0.13725986f, -0.03922330f, 0.01469629f, -0.10831364f, -0.02076595f, 0.07097823f, 0.34480241f, -0.68277317f, 
    -0.50029296f, -0.37981862f, 0.62845051f, -0.10651252f, -0.13837537f, -0.35231447f, 0.24620436f, 0.08102192f, 
    0.10779177f, 0.03298629f, 0.21755050f, 0.01812919f, 0.08479136f, -0.42870989f, -0.09058396f, -0.13934951f, 
    -0.07892081f, 0.22023475f, -0.20745447f, 0.13211101f, -0.34634408f, 0.21864597f, 0.44936547f, 0.12869868f, 
    0.63833767f, 0.54782516f, 0.61765754f, 0.38421148f, 0.21077034f, -0.03971083f, 0.15399159f, 0.02715139f, 
    -0.22422178f, 0.12151679f, -0.19092119f, -0.25347278f, -0.06473897f, -0.22308135f, 0.27317593f, 0.07121729f, 
    -0.15919596f, 0.19928229f, 0.31783181f, 0.20445891f, -0.04521251f, -0.00248138f, 0.27355999f, 0.01902431f, 
    0.57928133f, -0.62536949f, 0.45085549f, -0.09789608f, 0.00592359f, -0.07021610f, 0.31172723f, -0.23112589f, 
    -0.38399959f, -0.45590407f, -0.13937677f, 0.00422143f, 0.06742506f, 0.38329101f, -0.14451958f, -0.00491593f, 
    -0.10339742f, 0.04948460f, 0.08996298f, 0.25307047f, -0.01192298f, -0.21758936f, -0.05318232f, -0.19829209f, 
    -0.20434265f, -0.07497455f, -0.21751718f, 0.31898153f, -0.47397447f, -0.38535428f, -0.55645984f, -0.25664592f, 
    0.09973965f, 0.21882901f, -0.11249831f, 0.08255371f, -0.25319517f, 0.29839340f, 0.12090997f, -0.31701609f, 
    -0.19300370f, 0.34401408f, 0.23290285f, 0.18063609f, 0.18254396f, 0.47806656f, -0.40393955f, -0.08741634f, 
    -0.19919832f, -0.07769734f, 0.27308702f, -0.28855750f, 0.07941260f, -0.12167957f, 0.21979675f, -0.59817201f, 
    0.16738456f, 0.07778212f, -0.17178231f, -0.48451698f, -0.28981555f, -0.02740456f, 0.15128633f, -0.32034925f, 
    -0.25563145f, 0.08783491f, 0.19362363f, 0.03836340f, -0.28079262f, -0.16099121f, -0.19867977f, -0.20271359f, 
    -0.17980789f, -0.31400198f, 0.16243772f, -0.37163109f, 0.25807500f, 0.67917770f, 0.45227712f, 0.76869613f, 
    0.48887157f, 0.08340504f, 0.31285438f, 0.20978051f, -0.59009838f, -0.20973711f, -0.05864670f, 0.14825019f, 
    -0.07182356f, -0.25754318f, -0.11531828f, -0.26446196f, -0.01656507f, 0.08472373f, -0.09741323f, -0.07351816f, 
    -0.14069963f, 0.12541439f, 0.12199059f, 0.71134877f, 0.30363968f, -0.56342381f, 0.14441611f, -0.12329956f, 
    -0.33546087f, -0.47938001f, 0.06759676f, 0.14349400f, -0.08022319f, -0.31469586f, -0.06906799f, 0.47109970f, 
    -0.08712527f, -0.19106704f, 0.03315350f, -0.09236223f, -0.08658668f, 0.35775235f, 0.00562296f, -0.11539301f, 
    0.27453530f, 0.22469454f, -0.47488287f, -0.25657955f, 0.43302453f, 0.55767149f, 0.56055862f, 0.67440414f, 
    -0.12949784f, 0.06266282f, 0.18743263f, -0.47250864f, -0.25274351f, 0.33647573f, 0.05627842f, 0.12504458f, 
    0.26232079f, -0.15537003f, -0.26488858f, -0.26141220f, -0.25785446f, 0.10437742f, 0.01093133f, -0.24902231f, 
    -0.03626305f, 0.19994737f, 0.15543437f, 0.12951341f, 0.01148174f, -0.30773699f, -0.23347624f, -0.37438178f, 
    0.24978258f, 0.45998031f, -0.11296201f, 0.43263561f, 0.65073681f, 0.13258474f, 0.08118276f, -0.28012732f, 
    -0.50292748f, -0.41288787f, -0.09143737f, -0.11230486f, 0.07609937f, 0.05206344f, -0.08715514f, 0.08835756f, 
    -0.09260498f, 0.40897697f, -0.08540966f, 0.15285085f, -0.29056916f, 0.36060831f, 0.46624652f, 0.38001576f, 
    0.46773067f, 0.02720204f, 0.41411707f, 0.01736836f, -0.42992017f, 0.24873284f, 0.13393641f, 0.41121012f, 
    0.04364867f, 0.39856976f, -0.36274526f, -0.12805702f, 0.05380639f, -0.08692257f, -0.29819655f, -0.16794851f, 
    0.31172770f, -0.01295868f, -0.15090831f, -0.06799572f, 0.11242089f, -0.16903931f, -0.08141270f, -0.10165516f, 
    0.13842973f, -0.51537997f, -0.41315365f, 0.22512811f, 0.22320060f, -0.28159770f, -0.39875054f, 0.13294460f, 
    -0.10905840f, -0.34937826f, -0.11308125f, 0.31964982f, 0.07006489f, -0.15670684f, -0.40175846f, 0.25991911f, 
    -0.04280940f, 0.11970568f, -0.10692322f, 0.00668243f, -0.25653395f, 0.28889146f, 0.08712010f, 0.30057332f, 
    0.16072242f, -0.76499981f, -0.24924764f, 0.40009588f, -0.03115581f, -0.78653020f, 0.58828944f, 0.54320574f, 
    -0.72175962f, -0.42956090f, -0.16038951f, -0.23472871f, -0.11018087f, 0.12647896f, 0.36368176f, 0.03304205f, 
    0.14559168f, 0.31353420f, 0.11443449f, 0.21159324f, 0.00744193f, -0.06038151f, 0.09779613f, 0.08826695f, 
    -0.10965456f, -0.43152902f, -0.29262713f, -0.14541009f, -0.39724508f, 0.44108370f, 0.05351023f, 0.14106099f, 
    -0.40623021f, -0.26102328f, -0.31448382f, 0.03712385f, 0.38164896f, 0.24694742f, 0.06257270f, 0.34805086f, 
    0.33931398f, 0.07134493f, -0.07323716f, 0.26680073f, 0.49383610f, 0.01452844f, 0.10388777f, -0.10116065f, 
    -0.05195386f, 0.27376613f, 0.69194150f, -0.55235159f, 0.29514417f, -0.05937530f, -0.18052810f, 0.60824651f, 
    0.34929451f, 0.37676975f, 0.13523567f, 0.34797016f, -0.12650429f, -0.20126300f, -0.28910607f, -0.05851564f, 
    -0.23067194f, -0.20902668f, 0.12499759f, 0.23261426f, -0.03785295f, -0.31538039f, 0.07444154f, 0.09214411f, 
    0.09205843f, -0.16485083f, -0.16636008f, 0.45375526f, -0.26174816f, -0.57178468f, -0.14152178f, -0.51054186f, 
    -0.34797469f, 0.20899336f, -0.49379319f, 0.06329534f, 0.37092134f, 0.42424807f, 0.16172750f, 0.18628250f, 
    -0.00624780f, 0.03701751f, 0.10109589f, -0.09654179f, 0.16682938f, -0.10551639f, 0.34453580f, 0.15166704f, 
    0.14348277f, 0.26922271f, 0.32105684f, 0.09537618f, -0.35557848f, -0.75708711f, 0.42371511f, 0.64880568f, 
    0.38319913f, -0.92744523f, 0.46784797f, 0.09226281f, 0.04334486f, 0.25559434f, -0.07244805f, -0.07174387f, 
    0.29439148f, 0.03028603f, 0.19208533f, -0.22451045f, 0.21851546f, -0.18333516f, 0.01494521f, 0.16827616f, 
    0.05997969f, -0.20728298f, -0.09575135f, -0.16035068f, 0.10865401f, 0.40441939f, 0.42252010f, 0.15422665f, 
    -0.42060685f, -0.31631634f, 0.00122447f, -0.44364268f, -0.38596269f, 0.01037612f, 0.08063519f, -0.02374724f, 
    -0.31421411f, 0.04746919f, 0.13089512f, 0.08280093f, 0.27317926f, 0.35282367f, 0.26577690f, -0.15101251f, 
    -0.30221692f, -0.46374589f, -0.33067900f, -0.16948727f, 0.03088714f, 0.24023107f, -0.00717162f, -0.56685644f, 
    -0.81697106f, -0.48658410f, -0.29227918f, 0.45331842f, 0.37891722f, 0.21516883f, 0.55778545f, 0.33106691f, 
    0.05269792f, -0.24264412f, -0.10663231f, -0.12473626f, 0.17060252f, 0.08448379f, -0.12624012f, 0.07552993f, 
    -0.09769767f, 0.29212132f, -0.14661777f, -0.35253450f, -0.22806665f, -0.31565404f, 0.29315260f, 0.54153693f, 
    -0.24173057f, 0.26969719f, 0.60333818f, 0.65540427f, -0.69642955f, -0.28221184f, 0.09027581f, -0.40876299f, 
    -0.05985731f, -0.04476658f, 0.15620610f, -0.04370765f, 0.23842905f, 0.23546055f, 0.03838371f, 0.24532147f, 
    0.29340357f, 0.17555216f, -0.02827219f, 0.12594350f, 0.22476971f, -0.09325915f, -0.19738492f, -0.01011368f, 
    -0.63090038f, -0.51439172f, -0.47470123f, 0.28265083f, 0.06063399f, 0.21518490f, -0.09244043f, 0.33641276f, 
    0.26748255f, -0.63715959f, -0.35897923f, -0.13909310f, -0.26422036f, 0.11340944f, -0.32939014f, 0.32071212f, 
    0.13829444f, -0.02548894f, 0.11405137f, -0.01473540f, -0.06033979f, 0.03115058f, 0.08422282f, 0.21715438f, 
    0.15888737f, -0.50393069f, -0.57781166f, -0.59418112f, 0.50806820f, -0.18063268f, -0.48151022f, 0.68553489f, 
    0.72856027f, -0.61250818f, 0.00611091f, 0.22413637f, -0.21793653f, 0.16230240f, -0.18210654f, 0.22864266f, 
    -0.38236609f, -0.31600612f, -0.37790072f, -0.00822304f, -0.42256206f, -0.31654891f, 0.11383488f, 0.00816668f, 
    0.02011232f, -0.14413725f, -0.03443565f, -0.54284352f, 0.22566314f, 0.10082491f, -0.45443138f, -0.59234411f, 
    -0.50124168f, 0.27765298f, 0.03825647f, 0.04668915f, -0.29341075f, -0.18105800f, -0.04317319f, -0.11055090f, 
    0.09890478f, -0.28690150f, -0.34933555f, -0.16725460f, -0.42746988f, -0.28349298f, -0.01354755f, 0.07911145f, 
    0.03792647f, 0.10618275f, 0.27318862f, -0.07251322f, 0.60375172f, -0.12263978f, -0.62724286f, -0.56428456f, 
    0.32574385f, -0.50342715f, -0.33676419f, -0.31062081f, -0.27738929f, 0.34759244f, -0.25211900f, 0.19203968f, 
    0.18880987f, -0.02783279f, 0.27405253f, -0.23626217f, -0.24178268f, -0.16978985f, 0.21148729f, -0.10547213f, 
    0.06865760f, 0.24331665f, -0.26906198f, 0.05906947f, -0.48791158f, -0.65357524f, -0.29789802f, 0.02933506f, 
    -0.08601999f, -0.44152981f, -0.35327566f, 0.03849092f, -0.43461701f, 0.22479922f, -0.08879645f, 0.17930841f, 
    0.05020032f, -0.23796317f, 0.16407102f, -0.12808774f, -0.09737407f, 0.46183199f, 0.04902070f, -0.26822925f, 
    0.02368710f, -0.22395290f, -0.27277327f, -0.13673887f, 0.10380138f, -0.02544764f, -0.48035663f, -0.43782949f, 
    -0.33556357f, -0.15467623f, -0.09006039f, -0.70372647f, -0.20455973f, 0.36354044f, -0.02928889f, -0.29651836f, 
    -0.22292832f, 0.32551879f, 0.01820432f, -0.24972431f, 0.12120210f, 0.26835233f, 0.07289940f, 0.24945003f, 
    0.10782197f, 0.27434203f, 0.08234312f, 0.21640405f, 0.08563793f, -0.23382415f, -0.46375936f, 0.19240926f, 
    -0.54752409f, 0.41777176f, -0.14084379f, 0.01574931f, 0.40106481f, -0.64920110f, 0.43671876f, -0.02958974f, 
    0.33436280f, 0.00944509f, -0.08665900f, 0.03467736f, -0.25977603f, -0.23281127f, 0.09332047f, -0.04445343f, 
    -0.10416032f, -0.29863682f, -0.13035606f, 0.25850523f, -0.30599973f, 0.03246792f, -0.24694511f, 0.16536325f, 
    0.62011594f, 0.44025207f, -0.73397666f, 0.47757038f, -0.71714962f, 0.45451707f, -0.17043990f, -0.69512892f, 
    -0.02478622f, 0.22766632f, 0.17775042f, 0.01576851f, -0.18601036f, -0.40555736f, -0.02629009f, -0.20429455f, 
    -0.05739095f, -0.11406114f, -0.14262012f, 0.08120059f, -0.00612207f, -0.03640164f, -0.19464289f, -0.09759013f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.18254527f, 0.17778049f, 0.02250190f, 0.13005510f, 0.13333471f, 0.22748314f, 0.18452410f, 0.18401131f, 
    0.26642182f, 0.23880841f, 0.17937720f, 0.13827740f, 0.27671957f, 0.00449623f, 0.12195370f, -0.04626445f, 
    0.02598163f, 0.15349218f, 0.23775926f, 0.07300405f, 0.16692865f, -0.07379390f, -0.02475050f, 0.31455633f, 
    0.03901892f, 0.08912268f, 0.07768290f, 0.18429437f, 0.26876235f, 0.17187655f, 0.27049062f, -0.06938685f, 
    0.00823014f, 0.15904969f, 0.33768108f, -0.06640735f, -0.13504580f, 0.00370453f, 0.28368554f, -0.01146763f, 
    0.23260050f, -0.06690013f, 0.22670332f, 0.10525842f, 0.22309691f, -0.03994964f, 0.17957671f, 0.26277551f, 
    0.15662864f, 0.06031835f, 0.11599764f, -0.07809189f, 0.28869033f, 0.22269300f, -0.03196154f, -0.19872017f, 
    -0.05837755f, 0.16103068f, 0.10007016f, 0.22189984f, -0.06042296f, 0.03985581f, -0.07835408f, 0.17439394f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.01499401f, 0.04106186f, 0.01039414f, -0.00765200f, 0.00090484f, -0.03707789f, -0.02708421f, 0.02777771f, 
    0.00635327f, -0.03336271f, 0.01710545f, 0.01388873f, 0.01217598f, -0.00567195f, -0.04161874f, -0.00331553f, 
    -0.02477273f, -0.02554580f, -0.00342879f, -0.00552641f, -0.03181862f, 0.02122296f, 0.02636428f, -0.01894964f, 
    -0.00772416f, 0.00766576f, 0.00041174f, 0.01605193f, 0.00435073f, 0.00164698f, -0.03670210f, 0.01112385f, 
    0.02168269f, 0.02535072f, 0.00404801f, -0.04157832f, 0.01676106f, -0.02862579f, -0.03016112f, -0.00765016f, 
    0.00010660f, -0.04200622f, -0.03266764f, -0.00875187f, 0.01805586f, -0.00736368f, -0.02147598f, -0.02135556f, 
    -0.02562761f, 0.02083591f, 0.02314795f, -0.01588282f, 0.01708871f, -0.00737454f, -0.01979415f, 0.02006763f, 
    -0.01372834f, -0.03451593f, -0.01396099f, 0.00538783f, -0.04167581f, 0.01511127f, -0.01449400f, -0.02986899f, 
    0.02649138f, -0.00109479f, -0.03918801f, 0.01485139f, 0.00699544f, 0.02053180f, -0.01660100f, 0.02747638f, 
    -0.02023502f, 0.00420386f, 0.01912793f, -0.02900125f, -0.00034964f, -0.03148920f, -0.03715157f, 0.02883647f, 
    -0.00607775f, -0.03146510f, -0.03907137f, -0.00836964f, -0.00941622f, 0.02419514f, -0.02433470f, 0.02065463f, 
    -0.04051607f, -0.03020745f, -0.04161384f, 0.02587070f, -0.00592149f, 0.00824030f, -0.02528987f, -0.01344522f, 
    0.00487990f, -0.02580055f, -0.02473523f, 0.02706997f, 0.00215356f, 0.02889124f, 0.02806021f, 0.02289121f, 
    0.00354625f, 0.00302700f, 0.00104595f, 0.01556278f, 0.02165332f, -0.00835959f, -0.00987257f, -0.02220077f, 
    -0.01929484f, 0.02982796f, -0.00190298f, -0.01309264f, -0.03333060f, -0.02592406f, -0.01023278f, -0.03513487f, 
    0.00878915f, 0.00836572f, -0.01631781f, 0.00137405f, -0.04197861f, 0.02447466f, 0.01130117f, 0.01077104f, 
    0.02304450f, -0.03751117f, 0.00310654f, 0.01188780f, 0.01611184f, 0.01621566f, 0.02789844f, -0.00611285f, 
    -0.03551379f, -0.02560212f, -0.00739667f, 0.02172414f, 0.00805548f, 0.01073073f, 0.00470942f, 0.00124258f, 
    0.00441747f, -0.00812390f, -0.03344291f, 0.00604202f, -0.01939712f, 0.02465841f, 0.01228558f, -0.02647327f, 
    -0.02764096f, 0.00361069f, 0.02053851f, -0.00275644f, -0.02250910f, -0.02312330f, 0.02596633f, -0.02531396f, 
    -0.00057970f, 0.02776075f, 0.01411965f, -0.00305070f, -0.03362570f, -0.03748151f, 0.00456627f, -0.00050365f, 
    0.02688496f, -0.01120530f, -0.00106308f, 0.01618046f, -0.03718651f, -0.00105548f, -0.01614877f, 0.02851740f, 
    -0.02055868f, -0.00949891f, 0.00249256f, -0.03009344f, -0.04096467f, 0.02099771f, -0.00868945f, 0.00381936f, 
    0.00903896f, 0.02018625f, 0.00857052f, -0.00094871f, -0.00185078f, -0.02972468f, 0.02930473f, 0.02969399f, 
    -0.03508954f, -0.00257932f, -0.01486541f, -0.01776323f, 0.02439336f, -0.02239205f, -0.02860387f, -0.02683879f, 
    -0.00115326f, -0.01344541f, 0.00025235f, 0.01110711f, -0.02495118f, -0.03853266f, 0.01247333f, 0.01435823f, 
    0.02055383f, -0.00910656f, -0.00647620f, -0.02264241f, -0.02252335f, 0.02513891f, -0.01638304f, -0.01320328f, 
    -0.00459385f, 0.02324813f, -0.00596822f, -0.01677953f, -0.02926176f, 0.01333053f, -0.03110558f, -0.02913610f, 
    0.01556053f, -0.03294423f, -0.00815186f, -0.02976961f, 0.01128758f, 0.01188851f, -0.01053442f, -0.03572337f, 
    -0.02043398f, -0.03482065f, -0.00890073f, -0.00584623f, 0.01038126f, -0.01968824f, 0.00615123f, 0.01701463f, 
    0.02354605f, 0.00042766f, -0.00012241f, 0.01882566f, 0.00495523f, -0.03299811f, -0.01506427f, -0.02131335f, 
    -0.04151770f, 0.00978429f, 0.02464488f, 0.02632792f, -0.02051974f, 0.00670760f, 0.00540590f, 0.00515552f, 
    0.03826752f, 0.02503215f, -0.01622725f, 0.00934223f, 0.02081969f, -0.00787240f, 0.00485556f, -0.03833275f, 
    -0.02177568f, 0.02939290f, 0.01641448f, 0.02257928f, 0.00931192f, -0.00036745f, 0.02482526f, -0.03215646f, 
    0.00631447f, -0.00068992f, 0.01639648f, -0.03375782f, -0.01535668f, 0.01399220f, -0.00740556f, -0.03925801f, 
    -0.02341674f, -0.01724942f, -0.02312692f, 0.02371549f, -0.00281741f, -0.02351036f, -0.01786991f, 0.00436583f, 
    -0.01897815f, 0.01222404f, -0.02172604f, -0.01211026f, -0.03936051f, -0.01068210f, 0.01441568f, 0.01332492f, 
    -0.03109687f, 0.01604010f, -0.03345587f, -0.01429489f, 0.03088746f, 0.03572644f, -0.00753412f, -0.03401290f, 
    -0.03689494f, 0.00394262f, -0.00983012f, -0.00434861f, 0.01595934f, -0.01361816f, 0.01584679f, 0.01804794f, 
    -0.02621904f, 0.00501204f, -0.01521252f, -0.01787093f, 0.03817498f, -0.02985657f, 0.00986975f, 0.02058801f, 
    -0.00863503f, -0.01461565f, 0.00215848f, -0.03871839f, -0.00739754f, -0.02919272f, -0.01738947f, 0.01568266f, 
    0.02902665f, 0.03624645f, 0.02613657f, 0.01528125f, -0.03456979f, -0.03156507f, 0.02621543f, -0.03872961f, 
    -0.01437533f, 0.00774379f, 0.01132105f, -0.00193423f, -0.03988913f, -0.00559503f, 0.01000963f, -0.02917094f, 
    -0.02295119f, 0.00123095f, -0.03997908f, -0.02635765f, 0.00346229f, 0.02084137f, 0.02588928f, -0.01140474f, 
    -0.02946965f, 0.01965853f, 0.01667700f, -0.00693663f, -0.01347933f, -0.01440813f, 0.02353629f, 0.02854819f, 
    -0.02393033f, 0.03156660f, 0.00272430f, -0.02849842f, 0.00620400f, -0.03823494f, -0.00799091f, -0.00614489f, 
    -0.00563054f, -0.00490771f, -0.00900032f, -0.01178121f, -0.01407704f, -0.01236814f, -0.02328844f, -0.00442105f, 
    -0.00017958f, 0.01969389f, 0.02010871f, -0.00672102f, 0.01975986f, -0.01794799f, -0.02117511f, -0.03158498f, 
    0.01848846f, -0.04050018f, -0.00075575f, -0.04061462f, -0.02885164f, 0.00924651f, -0.04182873f, -0.01760805f, 
    0.01226422f, -0.00017536f, -0.01014244f, 0.00415028f, -0.02778321f, 0.01006041f, -0.02677950f, 0.01940067f, 
    -0.01162564f, 0.00216086f, -0.03359636f, -0.01027266f, -0.01851885f, 0.01423893f, 0.02512242f, -0.00206701f, 
    -0.02417483f, 0.01733100f, -0.00484364f, -0.01406962f, -0.03712977f, -0.00487087f, 0.02849140f, -0.03815765f, 
    -0.02005808f, -0.01693712f, -0.02568339f, -0.02056107f, -0.04196480f, 0.00595069f, -0.01540890f, 0.00786960f, 
    -0.01947780f, -0.03059341f, 0.02141626f, -0.01556041f, 0.00097299f, 0.02511013f, -0.02950720f, 0.01268910f, 
    0.02078377f, 0.01669088f, -0.02182367f, -0.01329575f, -0.01925617f, 0.00096697f, -0.01040313f, -0.02863977f, 
    0.02200147f, 0.00575149f, 0.00486405f, 0.00876079f, -0.03465752f, -0.01315350f, 0.01464626f, 0.00112944f, 
    0.00966624f, -0.02741311f, 0.00967442f, -0.03773033f, -0.00345375f, -0.00789413f, -0.01819968f, -0.00519672f, 
    -0.03686123f, -0.00591783f, -0.01546705f, -0.02731936f, -0.02667404f, 0.01681487f, -0.00199449f, 0.02874290f, 
    0.02562478f, -0.00602206f, 0.02485317f, -0.02158468f, -0.02024886f, 0.00482070f, -0.02685551f, -0.03028096f, 
    -0.01286648f, -0.02957864f, -0.00538787f, -0.01557445f, -0.03510543f, -0.00182555f, 0.02014963f, -0.02570849f, 
    -0.00543762f, -0.01141445f, -0.03546510f, 0.01108200f, -0.01213899f, 0.02366139f, -0.02618413f, 0.02233666f, 
    -0.00280928f, -0.03144054f, -0.03619092f, 0.00466925f, -0.02741342f, 0.01808625f, -0.00257183f, 0.01804613f, 
    -0.00473802f, -0.03954859f, -0.02772665f, 0.01786974f, -0.02269809f, -0.01884943f, 0.01980985f, -0.00063444f, 
    0.01457241f, -0.03562991f, 0.00779681f, 0.01447984f, 0.02690972f, -0.02384317f, 0.01992594f, -0.03193583f, 
    -0.01755005f, -0.01522847f, -0.03114886f, -0.01943319f, 0.00275111f, 0.01177414f, 0.01375632f, 0.01751314f, 
    -0.00271300f, -0.01797006f, -0.03827044f, 0.02771834f, -0.00578673f, -0.02351152f, -0.02527339f, 0.00406619f, 
    -0.01738975f, -0.03721930f, 0.00853254f, -0.02143963f, 0.02074357f, 0.00986189f, -0.02294894f, 0.02573777f, 
    -0.00732823f, -0.01124426f, 0.03763653f, -0.01337282f, -0.02374244f, -0.00991110f, 0.01393428f, -0.01659757f, 
    -0.03405455f, 0.00430071f, -0.02732480f, -0.01210715f, -0.01282541f, 0.01299438f, 0.02720886f, -0.02770118f, 
    -0.01848934f, -0.03617829f, -0.02307236f, 0.01895907f, 0.01186419f, -0.02560982f, 0.02333105f, -0.02660077f, 
    -0.02601098f, -0.00385066f, -0.00529839f, -0.02245144f, -0.03380764f, -0.03614727f, 0.01444751f, 0.01351297f, 
    -0.03959797f, -0.01944375f, -0.02640522f, 0.01941419f, -0.03878529f, -0.00933227f, -0.01172924f, -0.02666540f, 
    0.01003142f, 0.00813902f, 0.02406122f, -0.02548797f, -0.01694565f, -0.01561098f, -0.02825092f, -0.02905057f, 
    0.01925859f, 0.00554288f, -0.04008127f, -0.04078107f, -0.02451934f, -0.00344529f, 0.01037863f, 0.01510499f, 
    0.02216042f, -0.02871830f, 0.01090874f, 0.02352183f, -0.01348653f, -0.02781715f, -0.03087812f, -0.02443074f, 
    -0.00963573f, -0.02501989f, -0.00892981f, 0.02706469f, 0.01547178f, 0.00755553f, 0.02772755f, -0.00084586f, 
    -0.03316075f, 0.00564159f, 0.00766145f, 0.03450512f, -0.01255248f, -0.01323869f, 0.01019594f, -0.01710231f, 
    -0.02326635f, -0.04108988f, -0.00225314f, 0.00147949f, -0.00430990f, 0.02444558f, 0.02016898f, -0.03496660f, 
    0.03274217f, -0.00746060f, -0.02932713f, -0.03662030f, -0.04125516f, -0.02940605f, 0.00347759f, 0.00928387f, 
    0.00712734f, 0.00503888f, 0.02401060f, 0.01453830f, 0.02215482f, -0.00213449f, -0.01527598f, -0.03637099f, 
    -0.03205372f, -0.00817635f, 0.01824586f, -0.04091088f, -0.00665302f, 0.02671272f, -0.00554218f, -0.02612797f, 
    0.01263414f, 0.00161955f, 0.02897893f, 0.03000409f, 0.00361793f, -0.02181592f, 0.02497565f, 0.02601639f, 
    0.00730901f, -0.03711810f, -0.02595208f, 0.02945389f, -0.02092166f, 0.01510079f, -0.03571082f, 0.04157034f, 
    -0.01521788f, 0.03884632f, 0.02737244f, 0.01468119f, 0.01256028f, 0.00796571f, -0.00909391f, -0.00915862f, 
    -0.01450412f, 0.01766666f, 0.00814300f, 0.01378155f, -0.01911090f, -0.02763697f, -0.00415908f, -0.01724680f, 
    0.00015325f, -0.02464087f, -0.01590085f, -0.02780910f, 0.02796830f, 0.00187159f, 0.01581959f, -0.02156460f, 
    0.01582165f, -0.01759892f, -0.02950978f, -0.01654769f, 0.02246744f, -0.00885314f, -0.01459447f, 0.00471677f, 
    -0.00928325f, -0.01748515f, 0.02277722f, -0.02231411f, -0.02451716f, -0.01774830f, 0.02702808f, -0.01082506f, 
    -0.01974872f, -0.01708200f, -0.02005852f, -0.03939011f, -0.01246489f, 0.02346400f, -0.02473757f, 0.01225569f, 
    -0.03063233f, 0.01064725f, -0.03487567f, -0.02891719f, -0.02800347f, -0.00187843f, 0.01102891f, 0.01563625f, 
    -0.02686924f, -0.03132677f, 0.03820650f, 0.02873436f, 0.02478524f, 0.00708426f, -0.03341649f, -0.02805824f, 
    0.01632182f, -0.02959954f, 0.02576074f, -0.04077890f, -0.00999981f, -0.03564437f, 0.01060089f, -0.00164231f, 
    0.02056022f, -0.03871141f, -0.00883436f, 0.01749373f, -0.01611080f, -0.00207884f, -0.00472515f, 0.02008970f, 
    0.02689416f, 0.00049978f, 0.00256563f, -0.03567614f, 0.01186858f, 0.01446853f, 0.03945205f, 0.03699910f, 
    0.00323002f, -0.00108196f, 0.02134099f, 0.00376236f, -0.00525012f, -0.00344017f, -0.02500013f, 0.01546246f, 
    0.01372074f, 0.02035270f, -0.01576828f, -0.02915302f, -0.02737338f, -0.03168963f, -0.01135300f, -0.01835083f, 
    0.02178147f, -0.02771886f, -0.01872035f, -0.10555101f, 0.00460111f, -0.00194212f, 0.03133903f, 0.04178908f, 
    0.00079905f, 0.05549387f, 0.02083557f, -0.04623309f, -0.13953739f, -0.30350566f, 0.13429865f, -0.08312936f, 
    -0.00094200f, 0.04732585f, -0.05639197f, 0.11209056f, -0.03088889f, -0.01897372f, 0.02588529f, 0.04955383f, 
    -0.14021195f, -0.05020163f, 0.01938586f, -0.02304135f, -0.05464517f, 0.00619413f, -0.02275067f, -0.08722591f, 
    -0.09823983f, -0.01065596f, 0.08381881f, 0.12259159f, 0.17013872f, -0.16655773f, 0.22841305f, 0.15879256f, 
    0.03661272f, -0.17320247f, -0.09463072f, -0.08520114f, 0.09396339f, -0.03256013f, -0.09851358f, 0.03028143f, 
    -0.24535558f, 0.28793117f, -0.04825427f, 0.03565292f, -0.08715077f, -0.05997205f, -0.05629132f, -0.03918090f, 
    -0.03358213f, -0.07086451f, -0.05034583f, -0.01903231f, 0.20897570f, 0.00625897f, 0.12762903f, 0.28110108f, 
    -0.12767145f, 0.12730218f, 0.00658375f, -0.00641786f, -0.03410322f, 0.00936438f, 0.00793887f, -0.04099149f, 
    -0.24892595f, 0.10894234f, 0.04521432f, -0.08994009f, -0.00705015f, -0.06490213f, 0.05947591f, -0.04527209f, 
    0.07681815f, 0.04035184f, 0.01226754f, 0.01606799f, 0.11235335f, 0.10165460f, -0.04050641f, 0.04267716f, 
    0.11433365f, -0.05241767f, 0.04802027f, -0.03409142f, 0.13997519f, -0.02640864f, -0.07129202f, 0.04105811f, 
    0.25497600f, 0.11373713f, 0.09445317f, 0.16441154f, 0.17038627f, 0.18651469f, 0.03688853f, 0.05373278f, 
    -0.05387320f, 0.03209762f, -0.00880818f, -0.05495261f, -0.04464771f, -0.08593776f, 0.23363292f, 0.24817030f, 
    0.03460436f, -0.11640318f, 0.02579175f, -0.09000216f, 0.03894617f, -0.01814646f, -0.00367806f, 0.00593084f, 
    0.03713705f, -0.08122274f, 0.13144182f, 0.06252646f, 0.03163409f, -0.05473919f, 0.02336577f, -0.02424920f, 
    0.10608979f, 0.06913599f, -0.04318134f, 0.04827036f, -0.18587495f, 0.31716546f, 0.05548924f, -0.00327380f, 
    0.02569893f, -0.00534377f, 0.02317373f, 0.02255832f, 0.10270199f, -0.01920630f, 0.04551334f, 0.09527001f, 
    -0.00625352f, 0.13467675f, 0.09180226f, 0.08450943f, 0.00790182f, -0.00476006f, 0.01773647f, 0.02098106f, 
    0.12990884f, 0.00706192f, -0.03853481f, 0.07568070f, -0.22000737f, 0.03173858f, -0.07964547f, 0.06360241f, 
    -0.06139136f, 0.04525556f, 0.01104182f, -0.09651774f, -0.09406365f, -0.06407821f, -0.06695058f, 0.03053529f, 
    -0.36295274f, 0.03230259f, -0.08251403f, 0.03019412f, 0.01118712f, 0.03045304f, -0.04354842f, -0.03669345f, 
    -0.07056555f, 0.02444449f, 0.02565577f, 0.09618195f, -0.06100664f, 0.23509468f, 0.17540145f, 0.03529108f, 
    0.20766655f, -0.09095170f, 0.01958651f, 0.04239233f, -0.00978351f, -0.03357674f, 0.01218630f, -0.04947838f, 
    0.02597293f, -0.08937589f, 0.00703453f, -0.01769218f, -0.04956346f, -0.02557880f, -0.13537912f, 0.00532098f, 
    0.03008335f, 0.02325413f, 0.05636048f, 0.09037285f, 0.17619771f, -0.10594993f, 0.08048911f, 0.01478991f, 
    0.05686241f, -0.02720077f, 0.01992522f, -0.04513668f, -0.02440671f, 0.12053556f, -0.03348853f, 0.02950085f, 
    0.03989090f, 0.24215412f, -0.00663835f, 0.13065033f, 0.10912051f, 0.03705134f, 0.04078343f, -0.04353334f, 
    -0.02203393f, -0.09200996f, 0.00578803f, -0.05551739f, 0.03689373f, 0.05353469f, 0.09944765f, 0.10785960f, 
    0.04519626f, -0.10748507f, -0.02028758f, 0.11743166f, 0.01392663f, -0.00612258f, 0.05791906f, -0.03781954f, 
    0.09709437f, 0.10468128f, -0.00790304f, -0.07159440f, -0.11436063f, 0.11268163f, 0.00408460f, -0.08945745f, 
    -0.14546616f, -0.05068653f, 0.09259986f, -0.07475841f, -0.12022765f, 0.13708587f, -0.02751918f, 0.05286125f, 
    -0.06203608f, 0.25553781f, -0.14130832f, -0.07530083f, 0.00197796f, 0.07961839f, 0.01153301f, -0.04824600f, 
    -0.23335038f, 0.16737790f, 0.13267080f, -0.02861246f, 0.13775827f, 0.02035484f, 0.09985494f, -0.01928635f, 
    -0.00975255f, -0.03515765f, -0.01604410f, -0.03705545f, -0.25837710f, -0.02287788f, 0.08367547f, -0.13951840f, 
    -0.06158650f, 0.06536968f, -0.08150960f, 0.05180741f, -0.00240262f, 0.04248866f, 0.04893226f, 0.05488583f, 
    0.09886792f, 0.14659925f, 0.24775016f, 0.04413239f, 0.12675157f, 0.08243036f, 0.01541086f, 0.01147987f, 
    0.07923931f, 0.05924968f, -0.02842312f, 0.09300459f, 0.26439545f, -0.42650205f, -0.01728312f, 0.05459273f, 
    -0.17617258f, -0.00085533f, -0.07822827f, -0.06333531f, -0.04399487f, -0.09652608f, 0.03218751f, -0.06137348f, 
    -0.06334740f, -0.14623930f, 0.14853537f, 0.12492167f, -0.01849096f, -0.05634543f, -0.13550979f, -0.10465740f, 
    -0.09182845f, 0.12876494f, 0.05141730f, -0.06034048f, -0.27459475f, 0.04565005f, 0.00211655f, -0.08249620f, 
    -0.12334990f, 0.05085653f, 0.01951784f, -0.01751690f, 0.02316560f, 0.02909423f, 0.00007489f, -0.01224406f, 
    -0.18104067f, 0.09862293f, 0.19914815f, -0.28189006f, 0.05056620f, -0.00269469f, -0.04148481f, -0.02104039f, 
    -0.03207901f, 0.07752338f, 0.01730113f, -0.09315810f, 0.13001250f, -0.10650011f, 0.10896678f, 0.09506179f, 
    0.06722871f, 0.04619621f, -0.03466705f, 0.05711979f, -0.04178556f, 0.12037285f, -0.12753490f, 0.04944379f, 
    -0.21095167f, 0.22029534f, 0.14685944f, 0.00019330f, 0.26214674f, 0.09552065f, -0.04092951f, -0.04669448f, 
    0.05074392f, -0.01734137f, 0.10962424f, 0.07264803f, -0.07291857f, -0.19615100f, -0.08896553f, 0.09052128f, 
    0.01030352f, 0.06564102f, -0.04618529f, -0.05470468f, -0.09050555f, -0.06388672f, 0.11775275f, 0.03414156f, 
    -0.26246944f, -0.03805732f, -0.00991944f, 0.04163850f, -0.07953899f, 0.00310487f, -0.03037795f, -0.11072107f, 
    -0.07265409f, -0.14775461f, -0.02000121f, -0.10296520f, 0.13824771f, 0.07266784f, 0.06322403f, 0.25244090f, 
    -0.04169901f, 0.00983712f, 0.05200011f, 0.06619889f, 0.05418270f, 0.05674218f, 0.12100300f, 0.07421044f, 
    -0.02318206f, 0.06566332f, -0.00085390f, 0.12567370f, 0.17212297f, 0.06231537f, 0.04397760f, 0.15507628f, 
    0.03772980f, 0.05951687f, -0.04403664f, -0.12538783f, 0.24613862f, -0.06867016f, 0.28146371f, 0.13558327f, 
    0.07922684f, 0.04345370f, -0.06989974f, 0.02949301f, 0.04683134f, 0.06951585f, 0.04488797f, 0.09291161f, 
    0.15021598f, 0.01985812f, 0.08527673f, -0.06204598f, -0.04064790f, -0.02848402f, -0.05170531f, -0.13626096f, 
    -0.01063682f, 0.04375258f, 0.06666264f, -0.10779630f, -0.11312731f, 0.12023515f, 0.06068757f, 0.04286043f, 
    -0.02181432f, -0.00200617f, 0.02929719f, 0.06451026f, -0.07647398f, -0.05350528f, -0.03646309f, 0.00157631f, 
    -0.27204919f, 0.03438750f, -0.13295589f, -0.06299704f, 0.02727499f, -0.03749035f, -0.05761877f, -0.08154510f, 
    0.02765337f, 0.10552892f, -0.13637753f, -0.01837167f, 0.17710672f, -0.06202760f, 0.11179400f, -0.19044970f, 
    0.01519114f, 0.07711154f, 0.07763027f, -0.07476394f, -0.01314751f, 0.03634990f, -0.04240547f, -0.03800273f, 
    0.08119918f, 0.01540947f, -0.07579486f, 0.05807404f, 0.06318495f, 0.00994614f, -0.08583703f, -0.11045787f, 
    0.02127485f, -0.00574979f, 0.05118350f, -0.04337793f, 0.24060111f, 0.21040571f, 0.13568695f, 0.12729867f, 
    -0.02580491f, 0.03066196f, 0.06104557f, 0.05194492f, -0.16926791f, -0.04393451f, -0.02158112f, 0.06582645f, 
    -0.12321424f, 0.43832758f, -0.18552619f, -0.04209000f, 0.04697499f, -0.01721998f, -0.00986987f, -0.07976419f, 
    0.04911624f, 0.02527313f, -0.01355373f, -0.07750334f, 0.13251546f, -0.05891603f, -0.00857780f, 0.04708107f, 
    -0.11850783f, -0.04724874f, 0.00928114f, -0.09967043f, -0.02318761f, -0.06741258f, -0.00585914f, -0.01573226f, 
    -0.43827796f, -0.04941841f, -0.04703151f, 0.03642786f, 0.01015071f, 0.00007745f, -0.04454527f, -0.04109955f, 
    -0.00923006f, -0.03288735f, -0.19730948f, 0.05193654f, 0.14951460f, 0.14664645f, 0.06911910f, -0.10711627f, 
    -0.07657090f, 0.08324273f, -0.02267823f, -0.01077975f, -0.00096903f, 0.06032430f, -0.01297734f, 0.02489931f, 
    -0.05889988f, -0.20757076f, -0.17721511f, -0.12345092f, -0.01720296f, 0.03667740f, -0.02436873f, -0.09695077f, 
    -0.08951908f, -0.05283706f, -0.07028075f, -0.16211714f, 0.14976452f, 0.13443886f, 0.04087598f, 0.19270842f, 
    0.03625108f, 0.06948259f, 0.09720495f, 0.01426998f, 0.08612023f, -0.04122863f, 0.00931833f, 0.02405949f, 
    -0.00293967f, -0.01149187f, 0.00891627f, -0.09320630f, -0.10611260f, 0.07669236f, -0.01821739f, -0.06790848f, 
    0.01396993f, 0.07109872f, 0.05572412f, -0.04147484f, -0.08405692f, -0.02880684f, 0.01721689f, 0.02874796f, 
    0.09934163f, -0.03323738f, -0.00071966f, -0.04166387f, -0.00697384f, 0.20166717f, 0.13745122f, 0.13533625f, 
    -0.02332198f, 0.20675525f, -0.11887547f, 0.00368483f, -0.01447930f, 0.01317764f, -0.11018715f, -0.13392590f, 
    -0.00278674f, 0.07507619f, -0.03957529f, 0.03495760f, -0.10319098f, 0.10356143f, -0.00780481f, 0.11715722f, 
    -0.09376775f, 0.08390778f, 0.05746632f, 0.03201083f, 0.03208128f, 0.01937742f, -0.06635786f, 0.01220322f, 
    -0.30104405f, -0.01059018f, 0.04927711f, -0.20682800f, 0.03274441f, -0.00559413f, -0.04607520f, 0.04716741f, 
    -0.06455585f, -0.04155522f, 0.02226792f, 0.03135287f, -0.10836845f, -0.08317155f, 0.06560918f, -0.07339465f, 
    0.07614338f, 0.05170165f, -0.02115792f, 0.10047609f, -0.11489345f, 0.01863213f, -0.01343605f, 0.12001450f, 
    0.00317190f, 0.27270392f, 0.01249935f, -0.01045891f, 0.08269894f, 0.21759014f, 0.02722407f, -0.07386822f, 
    0.02929962f, -0.05270753f, -0.04733058f, 0.05279289f, -0.15984502f, -0.19016570f, 0.00876352f, 0.05741026f, 
    -0.09633026f, -0.02994106f, -0.03444329f, -0.06781434f, 0.03660794f, 0.02377376f, 0.17294762f, -0.02232460f, 
    0.25439203f, 0.12438553f, 0.05991640f, 0.28263694f, 0.22769907f, 0.08264866f, 0.06091547f, -0.02471214f, 
    0.02837950f, -0.01491653f, 0.06090517f, 0.05479876f, -0.03972769f, 0.05596929f, -0.07654490f, -0.10945002f, 
    0.01843229f, -0.04715332f, -0.07615740f, 0.10570802f, -0.08131526f, 0.05341418f, -0.03682432f, -0.00754701f, 
    0.30773121f, 0.04390368f, 0.03689227f, 0.17474118f, -0.06391745f, 0.16226004f, 0.03666106f, -0.06380554f, 
    0.01024444f, 0.12371003f, -0.08201499f, -0.07161879f, -0.18212827f, 0.15936154f, 0.14252740f, 0.14940134f, 
    -0.05201854f, -0.15962526f, -0.03317972f, -0.01715907f, -0.00360057f, 0.01201201f, 0.05365678f, -0.06428026f, 
    0.06233950f, -0.02516711f, 0.22170584f, 0.09812599f, 0.17510368f, 0.02842851f, 0.11021727f, -0.07007474f, 
    -0.01495057f, 0.04170705f, 0.06657230f, -0.05794704f, 0.25587702f, 0.19154537f, 0.08921479f, 0.11165184f, 
    0.14537232f, 0.13437475f, 0.04254979f, 0.06874465f, 0.02660426f, 0.00696415f, -0.04522474f, -0.00921693f, 
    -0.42784092f, 0.08235004f, 0.06312358f, -0.02912475f, -0.04877331f, -0.03782154f, -0.03381816f, 0.12283220f, 
    0.03872544f, -0.09122252f, -0.09661010f, 0.06724606f, -0.01558340f, -0.28054360f, 0.33369905f, 0.15372421f, 
    -0.02339319f, -0.07391252f, -0.02634167f, -0.03042837f, -0.03923549f, 0.03087714f, -0.05065754f, -0.04470066f, 
    -0.03923266f, 0.00972473f, -0.00990108f, 0.01472753f, 0.03056743f, -0.02401208f, 0.01443391f, 0.02705866f, 
    -0.01780604f, -0.00377420f, 0.01025602f, -0.01524981f, -0.04140612f, 0.00626518f, 0.01332348f, 0.00542076f, 
    -0.00433357f, -0.01127926f, -0.00215806f, -0.03193356f, -0.00873669f, -0.04032982f, -0.02727268f, 0.03014486f, 
    -0.01266318f, 0.01431379f, 0.01145730f, 0.00331210f, -0.03257608f, 0.00232199f, 0.02996210f, -0.01909301f, 
    0.00323560f, 0.00269293f, -0.02097914f, 0.01515314f, -0.03387750f, -0.00951311f, -0.01415328f, 0.00705701f, 
    -0.02290735f, 0.01695431f, -0.00479122f, 0.01740923f, 0.02030828f, 0.02401884f, 0.00691003f, 0.02739830f, 
    0.00334191f, -0.02063667f, -0.04019663f, 0.01970841f, -0.03683798f, 0.02756686f, 0.00726660f, 0.01946300f, 
    -0.02424375f, -0.01990776f, -0.00872876f, -0.03874137f, 0.01368521f, 0.01487397f, -0.02376838f, 0.02861695f, 
    -0.01130782f, -0.00585617f, 0.01079419f, 0.00478679f, 0.01646243f, -0.01724733f, -0.00292881f, -0.02467325f, 
    -0.02945319f, -0.03846985f, 0.02018957f, 0.01033584f, -0.01583352f, -0.03376538f, 0.03175892f, -0.01188363f, 
    -0.02899845f, -0.02429598f, -0.03602072f, -0.03758952f, -0.01148557f, 0.03124938f, 0.02487753f, 0.00410687f, 
    0.02293218f, 0.02358897f, 0.01085998f, 0.01863015f, 0.00050396f, 0.01176186f, 0.02927599f, -0.00673290f, 
    0.02283103f, 0.00834662f, -0.00454089f, 0.00776649f, -0.02003537f, -0.02141517f, 0.02770392f, 0.02275710f, 
    -0.02874828f, 0.00283741f, 0.01613463f, 0.02947444f, -0.00694629f, -0.00612391f, 0.02115502f, 0.00242143f, 
    -0.01026693f, -0.03226356f, -0.00493471f, 0.02473201f, -0.00325516f, 0.03192894f, -0.00676503f, 0.00408382f, 
    -0.00497108f, -0.03063261f, -0.01608583f, -0.00505064f, -0.03785725f, 0.02493009f, 0.03108199f, 0.02457811f, 
    0.00895706f, -0.00215547f, -0.01260277f, -0.00087077f, 0.00627259f, 0.02846627f, 0.01201018f, 0.03046700f, 
    0.00478264f, -0.03078331f, 0.02094861f, -0.02229080f, -0.03462046f, 0.00076913f, 0.00395564f, -0.00135401f, 
    -0.00182134f, 0.02830512f, -0.01422962f, -0.02259178f, -0.02378871f, -0.02720276f, -0.03868834f, -0.01327350f, 
    -0.01941221f, -0.00487327f, -0.03203736f, 0.02945167f, -0.02736561f, -0.03296902f, 0.03144772f, -0.03358712f, 
    -0.03860635f, -0.00573752f, 0.01758417f, 0.00695910f, 0.01742697f, -0.01015417f, -0.00859307f, -0.02780306f, 
    0.00984265f, -0.03890149f, 0.02492463f, -0.02086682f, 0.01576982f, -0.00764981f, -0.03923213f, 0.03278785f, 
    -0.02623923f, -0.02858172f, 0.02343995f, 0.01662224f, 0.00823984f, -0.01627397f, 0.01875633f, -0.03107192f, 
    -0.01504041f, -0.01826245f, -0.00682666f, -0.01641071f, -0.02867887f, -0.00692962f, -0.00944674f, -0.01404385f, 
    -0.02869715f, -0.01723582f, -0.02622028f, -0.00412022f, 0.00048319f, 0.02113136f, -0.00738153f, -0.01121562f, 
    -0.00792182f, -0.00838236f, -0.03682536f, -0.00642333f, -0.01223309f, -0.01097472f, 0.00258943f, -0.00414879f, 
    0.02587471f, -0.03253656f, 0.00960550f, 0.01284293f, -0.01878228f, -0.03138967f, 0.02617702f, -0.02796700f, 
    0.01800001f, -0.01300477f, -0.02751645f, -0.02162223f, 0.01012997f, 0.02674271f, -0.02597962f, -0.02610269f, 
    0.01787206f, -0.00332464f, -0.03700366f, -0.03954450f, -0.03682457f, -0.00121580f, -0.03204264f, -0.03522311f, 
    -0.03524674f, -0.02108830f, -0.02092866f, -0.02083871f, -0.00379736f, -0.01249503f, -0.01741226f, -0.02882278f, 
    -0.01488890f, 0.00411193f, 0.01329174f, 0.00111344f, -0.01231653f, 0.02495802f, -0.01463814f, -0.00075485f, 
    0.00200243f, -0.04056898f, -0.00824286f, 0.00367241f, 0.00303289f, -0.02611209f, 0.01721045f, -0.01282982f, 
    -0.03529164f, 0.00607630f, -0.01983485f, 0.01607829f, 0.02236308f, 0.02818222f, 0.02348672f, 0.02120095f, 
    -0.00049504f, -0.01136521f, -0.01066622f, -0.03172467f, -0.01784558f, -0.02139848f, -0.03007654f, -0.01686029f, 
    -0.03920716f, 0.02597193f, -0.00528838f, -0.01912474f, -0.02021663f, 0.00826444f, 0.02962858f, 0.00991692f, 
    0.00256557f, -0.01083567f, 0.00021687f, 0.02558097f, 0.01731191f, 0.01671639f, -0.02245886f, 0.01069178f, 
    0.01077450f, 0.00260735f, 0.00765415f, -0.01215697f, 0.01206598f, -0.02387639f, 0.00050176f, 0.02326882f, 
    -0.03749391f, -0.01335124f, -0.01938340f, -0.00766309f, -0.02625414f, -0.00012557f, -0.01185895f, 0.01453799f, 
    0.01829630f, -0.03367004f, -0.01920342f, -0.03058260f, 0.02787553f, -0.03362532f, 0.00731368f, -0.02215815f, 
    -0.02162516f, -0.03307408f, 0.02672759f, -0.01573156f, -0.01604326f, 0.02007811f, 0.02880872f, -0.01198967f, 
    -0.01738069f, -0.00165670f, -0.01034333f, -0.00619401f, 0.02892924f, 0.02266784f, -0.03141261f, -0.03962899f, 
    0.02879840f, -0.00207889f, 0.00672174f, -0.02113125f, -0.00726059f, -0.03141508f, -0.01184953f, -0.01988450f, 
    -0.02557167f, -0.02699122f, -0.02741787f, 0.01279326f, -0.00825122f, -0.03969371f, -0.01803273f, -0.01636617f, 
    0.01058626f, -0.01347905f, 0.00021897f, -0.02261321f, -0.00476479f, 0.03227624f, -0.00112167f, -0.01863796f, 
    0.02436574f, -0.00152515f, -0.01603354f, -0.00348037f, -0.03695142f, 0.01498585f, 0.00854438f, -0.03924488f, 
    0.00118884f, -0.02286481f, -0.01864218f, -0.03737209f, 0.03100226f, 0.02225152f, 0.01183571f, -0.03460725f, 
    -0.03603578f, -0.02382853f, 0.01410847f, -0.00125306f, 0.03305459f, 0.02154938f, -0.02117774f, -0.03696452f, 
    0.02990075f, 0.02746480f, -0.00814145f, -0.01190238f, -0.03768039f, 0.01012806f, -0.02735496f, -0.03235528f, 
    -0.00515629f, -0.02210295f, -0.02855925f, 0.03107825f, -0.03212601f, -0.04431593f, 0.02462828f, 0.01829952f, 
    -0.03194358f, 0.02182797f, -0.03263333f, -0.01330487f, 0.00245514f, 0.00314818f, 0.03080077f, 0.01167355f, 
    -0.02704267f, 0.00521776f, 0.02339848f, 0.02342487f, 0.02831670f, -0.03758786f, 0.00686010f, 0.01496862f, 
    0.00551702f, -0.00320832f, 0.00673964f, 0.00044549f, -0.00848399f, 0.00645190f, -0.02931032f, 0.02184943f, 
    -0.03119816f, -0.03598553f, 0.01126121f, -0.02989008f, -0.00504451f, 0.02772904f, -0.03185177f, -0.00716368f, 
    -0.03421491f, -0.00436407f, -0.00993653f, -0.02540751f, 0.01755311f, -0.01314500f, -0.01148272f, -0.02933569f, 
    -0.02924108f, 0.02472204f, -0.03772198f, -0.02384695f, 0.00837783f, -0.03755235f, -0.03447249f, -0.03583569f, 
    0.02317171f, 0.02021950f, 0.01283057f, -0.03398236f, 0.01271486f, -0.00227377f, 0.03026072f, -0.01420932f, 
    -0.00902679f, -0.02242082f, 0.01497774f, 0.01356107f, -0.03032755f, 0.01932842f, -0.00768393f, -0.02988449f, 
    -0.02844370f, -0.03641072f, -0.00572710f, -0.00054018f, -0.00646948f, 0.01491557f, 0.02066735f, -0.00870822f, 
    0.00512821f, -0.03551157f, -0.03454793f, 0.01431183f, -0.03415971f, -0.00342655f, 0.02726471f, 0.02923638f, 
    0.01442565f, -0.01079056f, -0.00146589f, -0.02177862f, -0.03404498f, -0.01755793f, -0.01216387f, -0.01356221f, 
    -0.00002901f, 0.02517517f, 0.00903146f, -0.02026576f, 0.00450224f, -0.00044218f, 0.01857220f, 0.02207310f, 
    0.00106335f, -0.01883719f, -0.00180646f, 0.01000805f, 0.02628326f, -0.01292076f, 0.01987742f, -0.02419703f, 
    0.01003340f, 0.02501789f, -0.01577350f, 0.02780205f, 0.02363636f, 0.01352495f, -0.01499275f, -0.00048899f, 
    -0.00130948f, 0.02317626f, 0.00537869f, -0.01546049f, -0.00303070f, -0.02814617f, 0.00394396f, -0.01283424f, 
    -0.02586047f, -0.02466708f, 0.00000243f, 0.01715049f, -0.01239038f, -0.03048677f, -0.03590555f, 0.02683585f, 
    0.00892679f, -0.02107972f, -0.04076281f, 0.02105708f, -0.03858786f, 0.00527330f, 0.01311291f, -0.01948617f, 
    -0.01014511f, -0.02472669f, 0.03218251f, 0.00953120f, -0.03973750f, -0.00116315f, 0.02162835f, -0.00409359f, 
    -0.02848113f, -0.00430241f, 0.02299421f, 0.01065614f, -0.02043931f, -0.02196956f, -0.01878597f, -0.01700270f, 
    0.00111299f, -0.02132173f, 0.01155251f, 0.01918856f, -0.00467719f, -0.04028289f, 0.03331583f, -0.01473178f, 
    -0.00082257f, 0.02908639f, -0.03727037f, -0.02271075f, 0.02755206f, -0.02662019f, -0.02824409f, -0.00685467f, 
    0.00334167f, -0.01272825f, -0.00164006f, -0.03628081f, -0.03104964f, 0.02951356f, -0.02602143f, -0.00965382f, 
    -0.00585588f, -0.02617923f, -0.01195126f, 0.01002318f, -0.03000320f, 0.01005788f, -0.02225429f, -0.01150946f, 
    -0.01777674f, 0.00410270f, 0.01850048f, 0.00799500f, 0.00476276f, 0.02328871f, -0.00442194f, 0.03028130f, 
    -0.02394636f, 0.00760001f, 0.02179915f, 0.02739920f, 0.03084883f, 0.01655077f, -0.03773470f, -0.03668458f, 
    -0.03086503f, -0.02019285f, 0.00214365f, 0.01687567f, -0.01469994f, 0.03069379f, -0.01924825f, -0.03006296f, 
    -0.03313970f, 0.00558977f, -0.02207169f, -0.02063823f, 0.01104358f, 0.00932008f, 0.01603634f, 0.01256242f, 
    -0.02650640f, -0.01986076f, -0.00132185f, -0.00561185f, -0.02913634f, -0.03409300f, 0.00154834f, -0.03236112f, 
    -0.03626237f, -0.03628451f, 0.02913143f, -0.01700060f, -0.02880763f, -0.03587734f, 0.03133194f, 0.02407662f, 
    0.03059235f, 0.01970202f, 0.01847663f, 0.02431065f, 0.02465757f, 0.00750493f, 0.03089559f, -0.03741593f, 
    -0.02216419f, 0.01336314f, 0.01298422f, 0.00447518f, 0.01677733f, 0.02209152f, -0.01742957f, -0.03376907f, 
    -0.00092444f, -0.02985435f, 0.00915699f, -0.02981922f, -0.02856987f, 0.02503045f, 0.03282182f, 0.02422986f, 
    0.02344730f, -0.01189722f, 0.03015514f, -0.01279943f, -0.04038577f, -0.01861031f, 0.01781777f, 0.01170653f, 
    0.02497254f, 0.02090054f, -0.03156221f, -0.02230600f, 0.00255643f, -0.04110701f, -0.03152871f, 0.02094395f, 
    0.00025092f, 0.01181176f, -0.00365114f, -0.03900997f, -0.01644571f, -0.00966134f, 0.00508337f, 0.00899905f, 
    0.02255856f, 0.02650728f, -0.00411499f, 0.01044377f, -0.01066745f, -0.02068508f, -0.01281215f, 0.01627387f, 
    0.01890527f, -0.03818177f, 0.01804523f, 0.00476646f, -0.01275816f, -0.02337293f, -0.00293376f, -0.03280025f, 
    0.02092285f, 0.00360403f, -0.02439150f, -0.03690924f, 0.02371659f, 0.02279428f, 0.00822054f, 0.01510113f, 
    -0.02515307f, -0.00317376f, 0.02119960f, -0.02899547f, -0.00313721f, -0.02953386f, 0.00349764f, -0.00343389f, 
    0.01380419f, 0.00146506f, -0.00111986f, -0.00745821f, 0.01644244f, 0.01704709f, 0.01179750f, 0.01662271f, 
    0.00600483f, 0.00850120f, 0.00958963f, 0.02752271f, 0.01548117f, 0.02544151f, -0.03217165f, 0.01944567f, 
    -0.03688664f, -0.00537165f, 0.00729392f, 0.02609138f, 0.03294123f, -0.00496538f, 0.00424308f, -0.03200685f, 
    -0.00621969f, -0.00000272f, 0.03049296f, -0.00781668f, -0.02685318f, -0.01144254f, 0.01932764f, 0.01409551f, 
    -0.03544955f, -0.03648727f, 0.01144777f, -0.00433623f, 0.01156947f, -0.03143099f, 0.00457491f, -0.01892460f, 
    -0.01916068f, 0.02361007f, 0.02681230f, -0.00209136f, -0.01649013f, 0.00751974f, -0.01798925f, 0.02847637f, 
    -0.01212582f, -0.02719849f, -0.03499864f, -0.03375553f, 0.02850829f, -0.02932874f, 0.01960714f, -0.02834767f, 
    -0.03895466f, 0.03139311f, 0.00804684f, -0.02597605f, 0.03140476f, 0.02806286f, -0.00230908f, -0.00528091f, 
    -0.02503056f, -0.00378666f, 0.01677501f, 0.00725922f, -0.01305402f, 0.00010093f, 0.02987918f, -0.00252252f, 
    -0.00797312f, -0.02444615f, 0.02943072f, 0.00701445f, -0.02088026f, -0.00907719f, -0.01564809f, -0.01445783f, 
    0.00615726f, -0.02416210f, -0.02730591f, -0.02720241f, 0.02588573f, -0.02932193f, 0.00878206f, -0.02909171f, 
    -0.04030161f, 0.01883428f, -0.03726304f, -0.02227180f, 0.03496768f, 0.00816340f, 0.02583379f, -0.00000149f, 
    0.01568652f, -0.03754104f, -0.01737865f, -0.03264237f, -0.02288823f, -0.02042342f, -0.02648471f, -0.01054919f, 
    0.00379221f, -0.01652912f, 0.02224143f, -0.02318136f, -0.03508830f, 0.00174670f, -0.00419566f, 0.00043586f, 
    0.00123705f, 0.01678333f, -0.03792352f, -0.01246301f, -0.03233159f, 0.02023164f, -0.03900736f, 0.01722433f, 
    -0.02929741f, -0.04552966f, -0.03788158f, 0.01623469f, -0.00817517f, 0.03105777f, -0.00008110f, 0.02026172f, 
    0.01156431f, 0.02306413f, 0.00643350f, -0.03839269f, -0.00950552f, -0.03391590f, -0.02545761f, -0.04165811f, 
    0.00819863f, 0.02659768f, -0.00590623f, 0.01918349f, -0.01955901f, -0.00157561f, -0.01926005f, -0.01386980f, 
    -0.00881349f, -0.01944186f, -0.02354372f, -0.00890561f, -0.00663716f, -0.00933613f, -0.02999562f, 0.03129127f, 
    0.02155161f, -0.01052972f, 0.00920822f, -0.03043971f, -0.03648445f, 0.01770147f, 0.01181714f, 0.00007640f, 
    -0.02537662f, 0.02281452f, -0.00223241f, 0.03040225f, -0.00555683f, -0.04114038f, 0.02682201f, 0.03296373f, 
    -0.00668184f, -0.00855935f, -0.00757500f, 0.02018117f, -0.01988735f, -0.04195253f, -0.03431573f, -0.02091651f, 
    0.02779526f, 0.00833925f, 0.00493138f, -0.02584441f, 0.02687899f, -0.00355008f, -0.00674091f, -0.01940384f, 
    -0.00086219f, -0.03262247f, -0.01272582f, -0.01522680f, 0.01900273f, -0.00024451f, -0.03167409f, 0.01084536f, 
    0.02075531f, -0.01356874f, -0.03796167f, 0.01475426f, -0.03982509f, -0.01070642f, 0.00898985f, -0.01207545f, 
    0.02570616f, 0.02412647f, -0.00117760f, 0.01051052f, 0.00848769f, -0.00783674f, -0.02155206f, 0.00788409f, 
    0.01264626f, 0.01397645f, -0.03796155f, -0.02486353f, -0.02052354f, -0.01965174f, -0.01640406f, 0.00122833f, 
    0.01255562f, -0.01943810f, -0.02006843f, -0.03990331f, 0.02269197f, -0.00494985f, -0.00460005f, -0.03591520f, 
    0.03350274f, -0.02104906f, 0.03047071f, -0.00368116f, 0.00542458f, -0.01465469f, 0.02362493f, 0.00593110f, 
    -0.00035137f, -0.03700215f, 0.02253137f, -0.00031274f, -0.02363442f, -0.01514825f, -0.00907284f, 0.02057596f, 
    -0.03527383f, 0.00554700f, 0.02762643f, 0.00764119f, -0.00361727f, 0.01982768f, -0.02836235f, -0.02229477f, 
    0.00118272f, -0.02339626f, 0.00700670f, -0.00690500f, 0.02099351f, -0.01480396f, 0.01669451f, -0.03052969f, 
    -0.01259275f, -0.00658302f, -0.03150981f, -0.01212293f, 0.01658056f, -0.02557610f, -0.02698622f, 0.00247483f, 
    -0.00674627f, 0.02164919f, -0.03513313f, 0.00492579f, -0.00198505f, -0.02757815f, -0.03295540f, -0.02617563f, 
    -0.01492674f, 0.02639244f, -0.01200711f, -0.03217153f, 0.01473899f, -0.02818464f, -0.02614672f, 0.00706276f, 
    -0.03588565f, 0.02727780f, -0.03607741f, -0.00296753f, -0.00173462f, 0.00890240f, -0.03648134f, -0.01410961f, 
    0.01150812f, 0.02972398f, -0.00806959f, -0.02276928f, -0.02805732f, -0.01943890f, 0.02917975f, 0.02871069f, 
    -0.00281363f, -0.03840724f, 0.02542177f, -0.00230661f, -0.03388820f, -0.00528517f, 0.02830192f, 0.01102273f, 
    -0.01485976f, -0.02262313f, -0.01109951f, -0.01431117f, -0.02950200f, 0.02205540f, 0.00267193f, -0.03151476f, 
    0.02584839f, -0.03899276f, -0.01930467f, 0.02853129f, -0.03528896f, -0.03522718f, 0.00390086f, -0.02528175f, 
    -0.00398618f, -0.00136076f, 0.00703642f, -0.00574479f, 0.03050868f, 0.02150323f, 0.00024123f, -0.00764280f, 
    0.00026594f, -0.03079418f, 0.01338600f, -0.00268965f, -0.01176179f, 0.01152643f, -0.01297176f, 0.02714990f, 
    0.01100939f, -0.01629410f, -0.02589819f, 0.00679155f, -0.00825663f, 0.00234165f, 0.02701120f, 0.01430288f, 
    -0.00835137f, 0.00109219f, -0.01092220f, -0.03835616f, 0.00387517f, -0.02109607f, 0.02278680f, -0.00557285f, 
    0.00993765f, -0.02410198f, 0.00353453f, -0.00683956f, -0.01521684f, 0.02486688f, 0.03243501f, -0.00772396f, 
    0.00870226f, -0.00469413f, 0.02183085f, 0.01421468f, -0.00531446f, -0.00581637f, -0.03993497f, -0.03146423f, 
    0.02442648f, -0.00411949f, -0.02503459f, 0.01349697f, 0.01782242f, 0.01594474f, -0.01534416f, 0.01713352f, 
    0.02769445f, 0.01981554f, -0.01654298f, -0.02477152f, -0.00266859f, 0.01339321f, 0.00406276f, 0.01313789f, 
    -0.01820681f, 0.00288468f, -0.02821995f, 0.00047481f, -0.03287013f, -0.01301692f, -0.02800709f, -0.01405499f, 
    -0.02186438f, -0.00285158f, 0.00092736f, -0.02593304f, -0.00759453f, -0.02511601f, 0.03066779f, 0.02464963f, 
    -0.01360159f, -0.00290485f, 0.00237568f, -0.00256113f, -0.02157997f, 0.01619008f, -0.01299121f, -0.01033226f, 
    0.01482648f, -0.00172165f, 0.02995086f, -0.03148528f, -0.00890964f, -0.00023385f, 0.01307692f, 0.01027442f, 
    -0.01768504f, 0.02706079f, -0.01502295f, -0.03511924f, 0.02982726f, -0.01154933f, -0.01985249f, 0.00467155f, 
    0.00149149f, -0.00428310f, -0.02954094f, -0.02652860f, -0.00317343f, -0.02515801f, 0.02305457f, -0.01980808f, 
    -0.03657235f, 0.01898787f, 0.01585900f, -0.01848189f, -0.03503787f, 0.01081470f, -0.00786172f, -0.02651532f, 
    -0.03196155f, -0.00131410f, 0.02136997f, -0.02008873f, 0.02789764f, -0.02271720f, 0.02283026f, 0.00782094f, 
    -0.01095195f, 0.02457466f, -0.01622756f, -0.01134779f, -0.03208106f, -0.03777498f, -0.02619362f, 0.01772660f, 
    0.00066964f, -0.03199363f, 0.02376278f, -0.00079525f, 0.02962370f, 0.02448087f, 0.01136490f, 0.02800831f, 
    0.01046823f, -0.01439934f, -0.00295880f, 0.02960832f, -0.03401805f, -0.02659320f, 0.00651224f, 0.02853063f, 
    -0.00143249f, -0.03753503f, 0.01797399f, -0.01167088f, 0.00264193f, -0.03926262f, 0.00871145f, -0.01272820f, 
    -0.02194987f, 0.01193079f, 0.01994749f, -0.00550580f, -0.02244551f, 0.01647975f, 0.02258122f, 0.02167331f, 
    0.01208639f, 0.01731439f, 0.02113226f, 0.02955243f, -0.02995468f, 0.02751477f, -0.04173424f, -0.03206496f, 
    -0.03068848f, 0.00722750f, -0.03503698f, 0.03386768f, 0.01817754f, 0.02115283f, 0.02792676f, 0.01411952f, 
    -0.00545514f, 0.02155789f, -0.01928662f, 0.01136171f, -0.01317490f, -0.03810443f, 0.01101031f, 0.02958450f, 
    -0.01213095f, 0.02541946f, -0.03863452f, 0.01268946f, 0.01945367f, -0.02994723f, -0.02289080f, -0.03175171f, 
    -0.00467414f, 0.00378785f, 0.00248426f, 0.00440010f, 0.00476843f, 0.00402027f, -0.02294599f, 0.01567161f, 
    0.01775629f, -0.00942474f, -0.03089930f, 0.00873008f, -0.02848285f, 0.03043346f, 0.02395969f, 0.01116847f, 
    -0.02378679f, 0.02237129f, 0.02812319f, 0.01267130f, 0.00385949f, -0.03592426f, -0.01035416f, 0.02559881f, 
    -0.01352723f, 0.00745561f, 0.00847119f, 0.02542665f, -0.00376088f, 0.00023151f, 0.01445591f, -0.03288351f, 
    -0.02834939f, -0.00472595f, 0.00845135f, -0.02654545f, -0.01208182f, -0.02868176f, 0.03001373f, 0.01287720f, 
    0.01100967f, -0.03948617f, 0.00294960f, -0.03976102f, -0.01234757f, 0.00766535f, -0.00685504f, -0.03880292f, 
    -0.02750993f, 0.01958895f, -0.03388324f, -0.03616306f, -0.01167236f, -0.00347301f, 0.01064042f, 0.02896047f, 
    -0.00717084f, 0.02201608f, 0.01687205f, 0.02253097f, 0.02192244f, 0.02907178f, 0.02604720f, 0.02884192f, 
    0.02225239f, 0.00719507f, -0.01415945f, -0.02653678f, -0.02702900f, -0.02065733f, -0.01892382f, 0.00739247f, 
    -0.03265715f, -0.00414520f, 0.01975893f, -0.01428906f, -0.02869328f, -0.02949669f, -0.01572204f, 0.02610559f, 
    -0.02791510f, -0.01282256f, -0.02113208f, -0.02314117f, -0.01321455f, -0.03583089f, -0.02219696f, 0.01975849f, 
    0.00157301f, 0.01939988f, -0.03726835f, 0.01028662f, 0.01369964f, -0.00915930f, -0.00307830f, 0.02317503f, 
    0.00376873f, 0.02468595f, 0.01498243f, -0.02228762f, 0.02667509f, -0.03919166f, 0.00367980f, 0.02832439f, 
    -0.00174711f, -0.01646595f, 0.01402692f, -0.00522809f, -0.00374512f, -0.03810384f, -0.03265881f, -0.03808265f, 
    0.02499941f, 0.00780661f, -0.03216656f, -0.01775804f, -0.01149077f, 0.01948548f, 0.00121694f, -0.01094807f, 
    0.02459732f, 0.01314803f, -0.03930299f, -0.00051218f, 0.01394125f, -0.03321298f, -0.01294576f, -0.01302267f, 
    -0.01809431f, -0.02809719f, -0.01331942f, 0.01686736f, -0.00394100f, 0.00768623f, 0.03240464f, -0.01207400f, 
    -0.01930805f, -0.02441048f, -0.02397879f, 0.00099431f, 0.00852112f, -0.03705401f, 0.01916943f, -0.03466879f, 
    -0.01163008f, 0.02882237f, 0.03944382f, 0.02394507f, -0.01870186f, -0.03148681f, -0.03435674f, -0.03179437f, 
    -0.03749990f, 0.02439016f, 0.01143916f, 0.01198579f, 0.01899701f, 0.02980823f, 0.02611171f, -0.00195895f, 
    -0.02825930f, -0.00440153f, -0.03935438f, 0.02792965f, 0.01225528f, 0.02161580f, -0.01842418f, 0.01114773f, 
    -0.01839666f, -0.02478239f, 0.02602455f, -0.03090320f, -0.02433119f, -0.02917621f, -0.03470957f, 0.00742988f, 
    0.02997708f, -0.00816084f, -0.02873361f, -0.03889896f, -0.03079977f, 0.00477828f, 0.02557959f, -0.01145296f, 
    0.01117594f, 0.01952432f, -0.01417270f, -0.01942053f, 0.00798908f, 0.02528305f, -0.00476227f, -0.02918697f, 
    0.02075606f, -0.03342227f, -0.02698691f, 0.01284518f, -0.01058979f, 0.03027777f, -0.00929708f, 0.00886358f, 
    0.00495013f, -0.01378113f, 0.00257824f, 0.02424021f, 0.00314903f, -0.01980972f, 0.01137881f, -0.01393889f, 
    -0.01214669f, -0.02693574f, 0.02906020f, -0.01834694f, 0.00771212f, 0.00715156f, 0.02928817f, 0.03288097f, 
    0.03329156f, -0.02699831f, -0.01747132f, -0.00682110f, -0.03074199f, -0.02728933f, 0.02238152f, -0.01119223f, 
    0.00452998f, 0.00314871f, 0.02749008f, -0.00789751f, -0.00712764f, 0.01013359f, -0.01304645f, 0.02162780f, 
    -0.00593220f, -0.01556654f, -0.02641403f, -0.03913730f, 0.00118400f, -0.01217076f, -0.02353724f, -0.00089079f, 
    0.01820504f, 0.00071627f, 0.01626633f, -0.02262112f, 0.00470825f, 0.02794349f, 0.00436309f, 0.01350276f, 
    -0.03324432f, 0.02425463f, -0.01391399f, -0.03560040f, 0.00709107f, -0.04286429f, 0.01391083f, 0.02056336f, 
    0.01186440f, -0.02549577f, 0.01547618f, 0.00510385f, 0.00871774f, -0.02682249f, 0.00960034f, 0.02140822f, 
    -0.00809096f, -0.02105092f, 0.01273265f, 0.01623015f, -0.03432434f, 0.01236047f, -0.03135717f, -0.00090891f, 
    0.02708342f, -0.03420400f, -0.01524129f, -0.02454141f, -0.01884837f, -0.01331170f, -0.02423358f, -0.03143435f, 
    -0.03492157f, -0.00890880f, 0.02439800f, -0.01921488f, 0.01349974f, 0.00576905f, 0.01114387f, 0.03043150f, 
    0.03299896f, -0.01811144f, 0.02201542f, 0.01587644f, -0.02725465f, 0.00063944f, -0.00338569f, 0.02600427f, 
    0.03056164f, 0.01664666f, 0.00049687f, -0.00766985f, 0.00725962f, -0.00161706f, -0.01012353f, -0.01203514f, 
    -0.03274086f, -0.02836940f, 0.00740491f, -0.04063313f, 0.02060569f, 0.02920307f, -0.03639706f, 0.02388598f, 
    0.00956612f, 0.01503169f, -0.06642065f, -0.24239433f, 0.09475424f, 0.10958312f, 0.09464715f, -0.09473845f, 
    -0.06247574f, -0.02481828f, 0.11297483f, 0.03682030f, -0.34094885f, 0.17032622f, -0.08136762f, -0.03491629f, 
    -0.12453572f, -0.07408402f, 0.04547628f, 0.01544255f, -0.02167746f, 0.09244075f, 0.06893422f, -0.01752101f, 
    -0.07803801f, -0.10327342f, 0.07884043f, 0.10451114f, -0.07192326f, 0.09285833f, 0.03090121f, 0.07275147f, 
    0.14573367f, 0.06809381f, -0.13524772f, -0.02928816f, 0.09444703f, 0.09566103f, 0.04938577f, -0.18214026f, 
    0.03866553f, -0.06575204f, 0.05232561f, 0.01597594f, 0.07315755f, 0.05503792f, -0.17443587f, 0.01717347f, 
    0.37876409f, -0.18290253f, -0.07483584f, 0.04546148f, -0.12586784f, -0.03762332f, -0.11908256f, 0.13016340f, 
    -0.04176502f, 0.02195025f, -0.00140788f, -0.07659729f, 0.08617119f, -0.14127138f, 0.11074558f, -0.07534347f, 
    0.02507665f, -0.16972570f, 0.05476096f, -0.11063586f, -0.07671736f, 0.05599548f, -0.06862406f, -0.03320412f, 
    0.06694850f, 0.06279176f, 0.07748456f, -0.05627107f, -0.01477966f, 0.00453525f, 0.00660933f, 0.07329580f, 
    -0.02006175f, 0.02032040f, 0.07172966f, -0.08855367f, 0.15134016f, 0.07989783f, -0.01638630f, -0.08058401f, 
    0.02736247f, 0.10366767f, -0.17465673f, 0.04023778f, 0.06718384f, 0.02028638f, 0.03791771f, -0.00591386f, 
    0.10733187f, 0.03446485f, 0.05343767f, -0.11766972f, -0.13896960f, 0.03629692f, -0.01043354f, 0.06546077f, 
    -0.05397131f, -0.01404944f, -0.06415895f, 0.00419819f, -0.20030390f, -0.00503064f, -0.04202338f, 0.15068232f, 
    0.02886604f, 0.18628296f, 0.05045719f, 0.07318898f, 0.00450506f, -0.01018766f, -0.02504567f, -0.02799331f, 
    -0.23368733f, 0.26799345f, 0.06863262f, -0.04246780f, -0.04639219f, -0.01732030f, -0.03247951f, 0.01109202f, 
    0.05133824f, -0.14677237f, -0.07190380f, 0.11422998f, 0.00327254f, -0.13377164f, 0.04582880f, 0.08669685f, 
    -0.00285798f, 0.01916713f, 0.03769886f, 0.10477109f, -0.08648238f, 0.10119227f, -0.01839082f, -0.00089096f, 
    0.08453666f, -0.02763244f, 0.06262092f, -0.07801296f, -0.03897876f, 0.04615303f, -0.07702731f, 0.00419006f, 
    -0.02389307f, -0.01168872f, -0.01106347f, 0.04279212f, -0.14623910f, -0.09431291f, -0.04319997f, 0.20620130f, 
    -0.04588477f, 0.01838959f, 0.02588849f, -0.08955726f, -0.08701468f, 0.12340462f, 0.00907596f, 0.00059179f, 
    0.01150916f, -0.34729388f, -0.01565035f, 0.18101643f, -0.10613130f, -0.02433764f, -0.01636653f, 0.04535654f, 
    0.07125534f, 0.03706922f, -0.02939736f, -0.05184064f, 0.66436481f, 0.30754745f, -0.18533592f, -0.10569994f, 
    0.02753132f, -0.01694692f, 0.02912879f, 0.07417949f, 0.06118787f, 0.05584455f, -0.01264923f, 0.04256336f, 
    -0.19606479f, 0.09494765f, 0.07893553f, 0.07240517f, -0.08660641f, 0.00017804f, -0.02224084f, -0.01962820f, 
    0.02705054f, -0.00524727f, -0.11339592f, -0.16211469f, -0.00537392f, 0.13730799f, 0.07405726f, -0.02472894f, 
    0.06155689f, -0.07627010f, -0.17628387f, 0.00822810f, 0.14327250f, 0.01760140f, -0.09636407f, 0.02276753f, 
    0.04379506f, 0.28350413f, -0.08544456f, -0.04421556f, -0.08407906f, 0.00608900f, 0.04072011f, 0.00673392f, 
    0.01222284f, 0.04054240f, 0.01252201f, 0.05979279f, 0.19468111f, 0.01293197f, 0.03557551f, -0.13565104f, 
    0.15722992f, -0.04290182f, -0.03222686f, -0.11936690f, -0.05607331f, 0.05738331f, -0.06902018f, 0.19277306f, 
    0.36735392f, -0.29962444f, -0.02049818f, 0.13036503f, -0.01399313f, -0.19295050f, 0.02249960f, 0.03979345f, 
    -0.06484578f, 0.06955903f, 0.11800050f, 0.01638359f, 0.01243834f, -0.16644670f, 0.07255375f, -0.04853333f, 
    0.00350187f, 0.05007641f, -0.06471018f, 0.02974102f, -0.09361364f, 0.01775541f, 0.11606195f, 0.06233436f, 
    0.29763401f, 0.14563736f, -0.12505402f, -0.07338560f, 0.00085165f, -0.09314710f, 0.05491154f, 0.07768069f, 
    0.04991858f, 0.07917134f, -0.04057332f, -0.02302615f, -0.00446099f, -0.22298729f, 0.07069757f, -0.31740820f, 
    -0.08770014f, -0.05664376f, 0.07049435f, 0.04642410f, 0.00461705f, -0.03602053f, -0.04935595f, 0.04163165f, 
    0.05176729f, 0.02221341f, 0.16829570f, 0.04312458f, -0.02407546f, -0.07585083f, 0.06811118f, 0.03946371f, 
    0.00818933f, 0.12623774f, -0.04464504f, 0.04921282f, 0.09249998f, 0.11929294f, 0.16688100f, -0.04512453f, 
    0.05683934f, 0.06461310f, -0.02313861f, 0.02561069f, 0.06270245f, 0.02651480f, 0.01709467f, -0.08206082f, 
    -0.01141855f, 0.06000710f, 0.12115901f, 0.14390929f, 0.09733269f, 0.04321723f, -0.02029962f, -0.03118086f, 
    0.03624546f, 0.10162799f, 0.00278797f, -0.08604643f, 0.25723422f, 0.04224903f, 0.12253612f, -0.02912807f, 
    -0.06116679f, 0.06136444f, 0.05934803f, 0.02970832f, 0.02355638f, -0.05677345f, -0.06341086f, 0.02643161f, 
    -0.18184818f, 0.15167226f, 0.04275994f, -0.04296840f, -0.05565640f, -0.02668640f, 0.02660985f, 0.17601790f, 
    -0.00868003f, 0.07458245f, -0.10584766f, 0.06507801f, 0.30088648f, 0.05263715f, -0.05515550f, 0.19002739f, 
    0.04838032f, -0.01582392f, 0.07196879f, -0.01816862f, 0.06828041f, -0.09066069f, 0.04119786f, -0.12338333f, 
    0.14721999f, 0.26756763f, -0.07607126f, -0.10973611f, -0.04701506f, 0.05773224f, 0.07939092f, 0.03808736f, 
    -0.03320857f, -0.01615926f, -0.05130611f, -0.04681123f, 0.24376354f, -0.05861282f, -0.07753233f, 0.13082501f, 
    -0.15638088f, -0.06294699f, 0.02644368f, 0.05905788f, 0.11359364f, -0.08627956f, 0.01643203f, -0.10204567f, 
    -0.20558332f, -0.06219672f, -0.03930463f, 0.10805508f, -0.12715895f, -0.07996918f, -0.00613619f, 0.07729065f, 
    0.02610373f, 0.02072958f, 0.03122625f, 0.04151147f, 0.10890342f, -0.09101162f, 0.11801399f, -0.04595476f, 
    -0.05439302f, -0.03555336f, 0.02325636f, 0.07119305f, 0.04597917f, -0.01813646f, -0.06621539f, -0.04242629f, 
    0.20706369f, 0.13679340f, -0.08758965f, -0.05825952f, -0.07186573f, 0.00320203f, -0.05119691f, 0.07811826f, 
    0.05359195f, -0.00106480f, 0.10472810f, -0.01332412f, -0.02572790f, 0.21859817f, 0.22435260f, 0.02653290f, 
    0.10226213f, 0.16379218f, 0.00042473f, -0.01520034f, 0.04409654f, -0.14615910f, -0.07765824f, 0.07399672f, 
    -0.33630252f, -0.10450859f, 0.01508388f, -0.13660246f, -0.02144366f, 0.08157088f, 0.14172427f, 0.03544876f, 
    0.00610624f, -0.02863765f, 0.08228507f, -0.06567758f, 0.19276962f, -0.07382538f, -0.09026527f, 0.02066967f, 
    -0.05132368f, -0.03421556f, 0.13897628f, 0.09711523f, -0.03909937f, -0.08000204f, -0.11143685f, -0.00378571f, 
    0.04018808f, -0.21843839f, -0.12989886f, -0.01868907f, -0.17896411f, -0.08778914f, 0.00934325f, -0.04667640f, 
    -0.03159720f, -0.01017107f, 0.01284165f, 0.08814034f, 0.34141546f, 0.08742265f, -0.04424932f, -0.02665341f, 
    0.05118741f, 0.05297305f, 0.13862748f, -0.00779675f, -0.05727888f, -0.03668493f, 0.07115305f, 0.05652627f, 
    0.08800734f, 0.21797930f, -0.08361390f, -0.01402710f, -0.03721985f, 0.00194261f, 0.10709506f, 0.04812773f, 
    -0.02755740f, -0.08617222f, 0.01758462f, 0.17251079f, 0.09268764f, 0.03977768f, -0.13256949f, 0.09399486f, 
    -0.03523755f, 0.02733712f, 0.11619867f, 0.02568114f, 0.08006249f, -0.09470309f, -0.10702319f, 0.06317104f, 
    -0.07942343f, -0.04362259f, -0.27702063f, 0.09756294f, 0.00363612f, -0.01254613f, -0.03072413f, 0.10777263f, 
    0.08126535f, -0.01839474f, 0.03470475f, 0.04974316f, 0.25813994f, -0.10913419f, 0.00945141f, -0.03051921f, 
    0.03755192f, 0.10434626f, 0.02648760f, -0.02080772f, 0.04658796f, 0.04090250f, 0.02451047f, 0.02643415f, 
    -0.13802503f, -0.01465556f, -0.13181573f, 0.05758541f, -0.00916751f, -0.03472812f, -0.06826019f, 0.06883877f, 
    0.08840737f, 0.05782251f, -0.04515165f, 0.11220317f, -0.05364435f, 0.02471718f, 0.02618127f, 0.00214420f, 
    -0.03374349f, -0.03739723f, 0.02056768f, 0.07107825f, -0.04621531f, 0.23034790f, 0.10874148f, 0.03818466f, 
    -0.21557298f, -0.19168273f, -0.15769891f, 0.06699518f, -0.05178037f, 0.04926104f, 0.05970235f, 0.02695368f, 
    0.07432417f, 0.03936857f, 0.13895233f, -0.01165431f, 0.20689771f, 0.07543551f, 0.14963022f, 0.05171690f, 
    -0.08755042f, -0.16522786f, 0.01211297f, -0.00189863f, -0.02115344f, 0.08282964f, -0.00232519f, 0.06745935f, 
    0.03572540f, -0.04456470f, 0.24479248f, 0.10053545f, 0.00962268f, 0.09997129f, -0.02568111f, -0.00519654f, 
    0.07492301f, -0.00469550f, 0.03601680f, 0.08045910f, -0.07012103f, 0.03564318f, 0.06962361f, 0.00038025f, 
    -0.04931687f, 0.13526754f, -0.03061297f, 0.03336541f, 0.07926398f, -0.06824380f, -0.05520967f, -0.01793103f, 
    -0.27299705f, -0.08776407f, 0.09593894f, -0.18928176f, -0.00634378f, -0.01277309f, 0.02441357f, 0.06474366f, 
    -0.04057667f, 0.14974488f, -0.02770283f, -0.02473827f, -0.01536298f, -0.17112090f, -0.13741632f, -0.01054752f, 
    -0.14049684f, 0.15288383f, 0.05388848f, 0.11326768f, -0.00728172f, 0.08174466f, -0.00641021f, -0.05792398f, 
    -0.10726128f, 0.09425113f, -0.03526442f, 0.30128524f, -0.21607584f, 0.12633120f, -0.00308038f, -0.02394133f, 
    0.03458753f, 0.01579769f, -0.03014734f, 0.07607988f, 0.00952497f, -0.01343695f, 0.04935019f, 0.10122949f, 
    -0.03732281f, 0.13521589f, 0.06783273f, -0.01532456f, 0.09717338f, 0.15457173f, 0.02128156f, 0.04131752f, 
    0.15469946f, 0.00227634f, -0.03941883f, 0.00511529f, -0.09553147f, -0.02992262f, 0.14726490f, 0.07897149f, 
    -0.04778855f, 0.01147449f, 0.06107137f, 0.02396516f, -0.01010405f, 0.04459654f, 0.16101287f, 0.25620908f, 
    0.03795030f, 0.21013486f, -0.00349479f, -0.08909736f, -0.04861033f, 0.00830094f, -0.02501768f, -0.03582993f, 
    -0.09585182f, -0.05853307f, -0.17313878f, -0.03005028f, -0.00121027f, -0.06040325f, -0.06548417f, 0.06637708f, 
    0.11378829f, -0.03870965f, 0.09306842f, 0.00699397f, 0.08541348f, 0.06897887f, 0.06842952f, 0.00965951f, 
    0.09856836f, 0.04561211f, 0.01879727f, -0.04678241f, 0.09723774f, -0.06288546f, -0.10119137f, 0.11746250f, 
    0.08822364f, -0.06777529f, -0.03657784f, 0.03095217f, -0.10657573f, -0.02304609f, -0.06910452f, -0.13809244f, 
    -0.03918933f, 0.08506019f, 0.00730398f, 0.06530303f, 0.12064371f, -0.03165530f, -0.05488783f, -0.07755204f, 
    -0.08860988f, 0.02376528f, 0.00251508f, 0.14006533f, -0.01064288f, 0.08092809f, 0.05076567f, 0.00249449f, 
    0.16884394f, -0.05298235f, -0.01218788f, 0.02179767f, -0.03764861f, -0.17623822f, -0.05865561f, 0.12560153f, 
    0.05424764f, 0.12818353f, -0.05660259f, 0.09383308f, 0.04063024f, -0.08870339f, 0.05188448f, -0.07589556f, 
    0.00592507f, 0.08002197f, 0.05606478f, -0.04972832f, -0.07983255f, 0.04370113f, -0.07095610f, 0.03754833f, 
    0.54251999f, 0.16830200f, -0.18028465f, 0.10004017f, 0.07885202f, 0.19376698f, 0.12829383f, -0.00649503f, 
    0.03244097f, 0.04635334f, -0.01332949f, -0.00857243f, -0.33557859f, 0.27784008f, 0.16252393f, 0.01540902f, 
    0.02081844f, 0.13028498f, 0.02038586f, 0.01179257f, 0.04991722f, 0.00771629f, 0.08136783f, -0.13621017f, 
    -0.02447689f, 0.02279392f, -0.03600343f, 0.01566523f, 0.02582071f, 0.01355437f, 0.01115788f, -0.02508771f, 
    0.02929494f, -0.03842546f, -0.01488563f, -0.01101207f, -0.02684492f, -0.02252202f, -0.03641032f, 0.00061275f, 
    -0.03089788f, -0.01723608f, 0.00205036f, 0.00139563f, -0.00280689f, -0.02164946f, 0.02567099f, 0.02383790f, 
    0.01849831f, -0.03930837f, 0.02672740f, -0.01963401f, 0.01948051f, -0.02446311f, 0.02315231f, -0.02029370f, 
    -0.01676714f, -0.00522066f, -0.00990796f, -0.00287844f, 0.01501978f, 0.01733662f, 0.01168466f, -0.00106571f, 
    0.02586127f, 0.03339146f, -0.00700284f, -0.00104798f, -0.00052049f, -0.00821975f, 0.01111269f, -0.03216591f, 
    -0.04321297f, 0.00884118f, -0.00874722f, -0.04090649f, -0.00550391f, -0.00624665f, -0.02435917f, -0.01825713f, 
    -0.02855924f, 0.00490915f, -0.03729216f, -0.03567992f, -0.02515918f, 0.01697435f, -0.03447064f, -0.00065088f, 
    -0.00827743f, 0.01087484f, -0.00947193f, -0.00905474f, -0.01632235f, -0.01616609f, -0.01937470f, 0.02906160f, 
    0.02546172f, 0.00436830f, 0.02499165f, -0.02043907f, -0.00671881f, -0.00429563f, -0.03595415f, -0.00685877f, 
    0.02343890f, -0.02050933f, -0.00379147f, -0.03722859f, -0.01596435f, -0.02498277f, -0.03560503f, 0.02228978f, 
    0.00306298f, -0.03711427f, -0.01457696f, -0.03227673f, -0.00393597f, 0.02639333f, -0.03021757f, -0.02007231f, 
    -0.00696005f, -0.00167377f, -0.01313518f, -0.01457972f, 0.00456107f, 0.03788929f, 0.01528831f, -0.02978729f, 
    -0.03063529f, 0.00770701f, -0.03262234f, -0.03550019f, 0.01619770f, 0.03043242f, -0.00760102f, -0.00197282f, 
    -0.02457045f, 0.01699563f, -0.03110904f, -0.01486198f, 0.00218222f, -0.01044542f, 0.01411449f, -0.03390265f, 
    -0.01803296f, 0.01991582f, -0.00015050f, 0.02782775f, 0.00923888f, 0.02034441f, -0.03568678f, -0.00664175f, 
    -0.04017797f, 0.00864452f, -0.01873575f, 0.02515442f, 0.02615509f, -0.02883616f, -0.02433169f, 0.01930596f, 
    0.01989382f, 0.02803577f, 0.01936163f, 0.02114452f, -0.02329574f, 0.01213006f, -0.01909133f, -0.01371276f, 
    0.01792818f, 0.01291067f, 0.03215270f, -0.00248610f, -0.02175746f, -0.03500830f, 0.02382633f, 0.03461619f, 
    -0.02246426f, -0.02832254f, -0.01976400f, -0.01370968f, 0.02007054f, -0.01182044f, -0.00489876f, 0.03744825f, 
    -0.04035189f, -0.03012658f, -0.04298997f, 0.01083295f, 0.00723163f, -0.01236108f, -0.01253164f, 0.02141425f, 
    -0.01083245f, 0.02694774f, -0.03460376f, -0.03202759f, 0.00712244f, -0.01697235f, -0.01441307f, -0.03513242f, 
    -0.02536591f, 0.01236619f, 0.03451622f, 0.02506868f, -0.00775846f, 0.01429544f, 0.02433388f, 0.03922377f, 
    0.01913382f, -0.02319850f, -0.00896421f, 0.00214324f, 0.01116060f, -0.01324811f, -0.00551344f, -0.00358249f, 
    -0.01902535f, 0.00563469f, -0.04035842f, -0.00485150f, 0.02903870f, 0.02043957f, 0.03309431f, -0.00450955f, 
    -0.02140781f, -0.01734210f, -0.02729226f, 0.02061939f, 0.02224672f, -0.02298082f, 0.01874842f, 0.01974928f, 
    -0.00221518f, -0.00540063f, -0.01415858f, 0.00008748f, -0.02116330f, -0.00340958f, 0.01297598f, 0.02379809f, 
    0.01058123f, -0.01764963f, -0.01868154f, -0.01470069f, 0.00320862f, 0.00665246f, 0.02052173f, 0.00313289f, 
    -0.00783506f, -0.00563312f, 0.01929416f, 0.00147642f, -0.02876780f, 0.01921879f, -0.00170061f, 0.00503267f, 
    -0.00667477f, 0.00890249f, -0.01865389f, -0.02171448f, -0.01734523f, -0.01878210f, -0.03447720f, -0.02090764f, 
    -0.00976891f, -0.00639588f, 0.02134523f, -0.00469791f, 0.01749107f, -0.02411062f, -0.03060694f, -0.00441886f, 
    -0.01744953f, -0.03982111f, -0.01552372f, 0.01747158f, 0.01164865f, 0.00898433f, -0.00836979f, 0.00272455f, 
    -0.03164131f, 0.01206841f, 0.00973145f, 0.00506973f, 0.02342740f, -0.03375943f, 0.01183158f, -0.01232885f, 
    0.00284631f, -0.02709663f, 0.02352555f, -0.01690490f, -0.02476096f, -0.03723472f, -0.00904245f, 0.02171247f, 
    -0.02373300f, 0.01594120f, -0.01662613f, 0.01786254f, 0.00267727f, -0.01945419f, -0.01797480f, -0.00934294f, 
    -0.01731213f, -0.00198125f, 0.00769201f, -0.01978228f, 0.02397139f, 0.01053200f, 0.01361502f, 0.01908756f, 
    0.01728953f, -0.02855702f, -0.01851098f, 0.01250032f, 0.02887393f, 0.01402572f, -0.03438856f, 0.01337311f, 
    0.02760842f, -0.02115219f, -0.00375815f, -0.03520742f, 0.00095539f, 0.02582772f, -0.01278726f, 0.04379518f, 
    0.00786580f, 0.01150387f, 0.02016641f, 0.02061092f, 0.03647272f, 0.03235564f, 0.02414876f, 0.00104352f, 
    0.01784998f, 0.03704936f, -0.00608005f, -0.00598079f, -0.04380766f, 0.02007871f, 0.00762199f, 0.01691440f, 
    0.01011137f, -0.01368131f, 0.00718339f, 0.02196304f, -0.00218573f, -0.01808860f, -0.02909666f, 0.00820255f, 
    -0.01399318f, 0.01588304f, 0.03605696f, -0.00433919f, 0.02405670f, -0.02661260f, 0.02494450f, 0.00334978f, 
    -0.04122589f, -0.03358532f, 0.01199604f, 0.00970960f, -0.03197142f, 0.00847333f, -0.00737553f, 0.02091568f, 
    -0.02084845f, -0.00035721f, 0.02498274f, 0.01865457f, -0.03183032f, -0.03813914f, -0.02495508f, 0.01065242f, 
    0.02621984f, -0.02836758f, -0.00484875f, 0.02267691f, 0.00296178f, 0.01394904f, -0.02563090f, 0.01088910f, 
    -0.00517864f, 0.03644045f, -0.02364646f, 0.00095942f, 0.00842006f, 0.00033101f, -0.02303535f, 0.02282154f, 
    -0.03860033f, -0.03457203f, 0.01889192f, -0.03334573f, 0.03271845f, -0.01026790f, 0.01022189f, 0.01119780f, 
    -0.01057291f, -0.02973507f, 0.01106568f, 0.01862486f, 0.00362956f, 0.03096302f, -0.01865386f, -0.00715726f, 
    0.02612627f, -0.02948253f, 0.01551557f, -0.01135142f, 0.00843501f, 0.03446466f, -0.02596219f, -0.02308579f, 
    0.02159493f, 0.02114947f, -0.02318317f, 0.02694422f, -0.02467193f, 0.01334206f, 0.01505073f, 0.01552101f, 
    -0.02176883f, -0.02094198f, 0.01760049f, -0.02886742f, -0.01785869f, 0.00386023f, 0.02406512f, 0.00387785f, 
    0.00722981f, 0.00608874f, -0.00345915f, -0.01390309f, -0.02408905f, 0.00876699f, 0.00423732f, -0.03767836f, 
    -0.00489634f, 0.02853875f, -0.02461411f, -0.04071321f, -0.02608387f, 0.03665898f, -0.00219505f, 0.02680525f, 
    -0.02722770f, 0.01320271f, -0.03085132f, 0.00863944f, -0.02551970f, -0.00897971f, -0.03024232f, 0.02224971f, 
    -0.02497052f, 0.00814006f, 0.00779716f, -0.04347688f, 0.03244078f, -0.01804304f, 0.00130560f, -0.01272848f, 
    -0.03071014f, -0.02191392f, 0.03313303f, 0.00250822f, -0.02058378f, -0.01575102f, -0.00093456f, -0.03947161f, 
    0.01426131f, -0.00040122f, 0.03132456f, -0.03087646f, -0.00266219f, -0.02827699f, 0.00480087f, -0.01223527f, 
    -0.03054069f, -0.01961884f, -0.01479821f, -0.00388315f, 0.01122825f, 0.02710981f, -0.00003501f, -0.01287619f, 
    -0.01876256f, -0.00397294f, 0.02557979f, -0.01868971f, -0.03341482f, -0.01503261f, -0.01064547f, -0.00250102f, 
    0.01316776f, -0.04153734f, 0.01272798f, -0.01096517f, 0.00763802f, 0.01341599f, -0.03766029f, 0.02941683f, 
    -0.02981722f, -0.01657538f, -0.03244361f, 0.00359334f, -0.04075128f, 0.01184634f, 0.00731248f, 0.03196951f, 
    -0.03991087f, 0.03553459f, 0.00992843f, 0.02343917f, -0.01590339f, 0.02516519f, -0.02576145f, -0.02338955f, 
    0.02834961f, 0.02011937f, 0.00689170f, 0.02028433f, 0.03241403f, -0.00386997f, 0.00780722f, 0.00608414f, 
    -0.00449740f, 0.02360830f, 0.02079662f, 0.02264689f, -0.03457488f, 0.01451223f, 0.01700426f, -0.00529411f, 
    -0.02171319f, 0.03411695f, -0.03063620f, -0.03034016f, -0.03887363f, 0.01835925f, 0.01029747f, 0.02952283f, 
    0.01579461f, -0.02426695f, 0.00792031f, 0.01446657f, 0.00637384f, -0.00752389f, 0.02185538f, 0.01809590f, 
    -0.00344392f, -0.03393577f, 0.02301171f, -0.01890405f, 0.02779985f, -0.01892231f, 0.00409585f, -0.00030871f, 
    -0.01192475f, -0.02176841f, 0.00899033f, -0.03049419f, -0.01804206f, -0.01638208f, 0.01273576f, 0.02124502f, 
    0.03189967f, 0.00821408f, -0.00387356f, -0.02432128f, -0.00852055f, 0.03435415f, -0.01085696f, 0.03155208f, 
    -0.01752281f, -0.01304378f, -0.00853409f, -0.00267971f, -0.02998782f, -0.02021371f, -0.03285827f, 0.00935982f, 
    -0.03619371f, -0.02340037f, -0.00808428f, 0.00596269f, -0.02272953f, 0.02888264f, 0.00047288f, -0.00521621f, 
    0.00309296f, -0.00190829f, -0.02333713f, 0.01272361f, -0.03803421f, -0.03553748f, -0.02995038f, 0.02330337f, 
    -0.02540700f, -0.00697656f, -0.00180773f, 0.01710508f, -0.04101746f, -0.02043322f, 0.01017763f, 0.02720051f, 
    0.03270556f, -0.00438577f, -0.00270800f, -0.03142079f, -0.00472863f, 0.01957345f, 0.02283089f, 0.00805986f, 
    -0.02772531f, -0.00950514f, -0.01553025f, -0.01193085f, 0.00832991f, -0.03743691f, -0.01612149f, -0.04167704f, 
    -0.00475455f, 0.01417778f, -0.01955538f, -0.02003764f, -0.00036174f, -0.01373404f, 0.00842372f, -0.03052108f, 
    -0.03068354f, -0.01253975f, -0.03373386f, 0.00249673f, -0.01583557f, -0.00724935f, -0.00435220f, -0.01617256f, 
    0.00801006f, -0.02255324f, 0.02665493f, 0.00336366f, 0.01704980f, -0.02473997f, -0.02178337f, 0.02367673f, 
    -0.03523152f, 0.01429765f, -0.00081851f, -0.01625198f, -0.00236097f, -0.01786659f, 0.00609247f, 0.02576700f, 
    -0.02822052f, -0.03095463f, -0.00755620f, 0.02382712f, 0.00699251f, 0.03625448f, 0.00724329f, 0.00201032f, 
    -0.00410186f, 0.02624856f, -0.03111513f, 0.01262135f, -0.02293338f, 0.02828215f, 0.01362188f, 0.00373383f, 
    0.02323749f, 0.00072414f, -0.01594353f, -0.00867813f, 0.01237080f, -0.02218425f, 0.01415529f, -0.02343380f, 
    0.01289590f, 0.00451855f, 0.02319440f, -0.00892196f, -0.03495589f, 0.01794505f, -0.02377794f, -0.00184819f, 
    -0.00658139f, 0.01288826f, 0.02364457f, 0.02937854f, -0.01199612f, -0.03232559f, -0.00091821f, 0.03229214f, 
    -0.02470203f, 0.03937385f, -0.00278656f, 0.00063336f, -0.01474719f, -0.00523102f, 0.02766611f, 0.00989888f, 
    0.02810837f, 0.01990593f, 0.02167492f, 0.01527002f, -0.00777742f, -0.03807482f, -0.04078454f, 0.00587620f, 
    0.01455151f, 0.03477472f, 0.02279644f, -0.01767122f, 0.00296321f, 0.00892527f, -0.00962981f, 0.00291233f, 
    -0.00459203f, 0.00880354f, -0.02607940f, -0.00164518f, -0.01114708f, 0.01908064f, 0.02191496f, 0.03584818f, 
    0.01358670f, -0.00824156f, 0.01996813f, 0.00169162f, -0.01704715f, 0.01583265f, -0.03979095f, 0.02979477f, 
    -0.02170294f, 0.01606654f, 0.01193610f, 0.00408684f, 0.01229803f, 0.00358078f, -0.00014517f, -0.03414034f, 
    -0.02070853f, -0.00569100f, 0.01390773f, -0.00909838f, -0.01158328f, -0.02713126f, 0.02633088f, -0.02276025f, 
    0.00229541f, -0.02713902f, 0.03356078f, 0.00079360f, -0.02182964f, 0.03221733f, -0.02873239f, 0.03220423f, 
    -0.01738891f, 0.01681127f, 0.03175554f, -0.04117125f, -0.03234268f, -0.01166796f, 0.00332953f, -0.00714825f, 
    0.02493326f, -0.01981414f, 0.03039824f, -0.03356111f, -0.00383129f, -0.01950396f, 0.00279414f, -0.01589793f, 
    0.02281468f, -0.00340064f, -0.03463602f, 0.01409374f, 0.01374455f, 0.01260512f, -0.00543544f, 0.01522253f, 
    -0.03457530f, 0.01982101f, -0.01169849f, -0.01766585f, 0.00508779f, 0.00383805f, -0.02785945f, -0.00721863f, 
    -0.02179798f, -0.02527667f, -0.02066777f, -0.03639521f, -0.02971300f, 0.02219387f, -0.00584188f, -0.00121488f, 
    0.02002557f, 0.02469202f, 0.00736728f, 0.02790804f, 0.02482655f, -0.01216338f, -0.02176208f, -0.01300077f, 
    -0.01632407f, 0.00408933f, 0.02161350f, -0.03687207f, -0.01350584f, -0.01033423f, -0.03642804f, 0.02468335f, 
    -0.00297698f, -0.02028521f, -0.02076572f, -0.02327028f, 0.02077720f, 0.02822490f, 0.01735762f, -0.00169060f, 
    -0.00349666f, 0.01099205f, -0.02876503f, -0.00367348f, -0.00644942f, 0.01514063f, 0.02790741f, -0.01892659f, 
    0.01738165f, 0.00375235f, -0.01649701f, -0.02644693f, -0.01668411f, 0.01431013f, -0.02273420f, -0.04130047f, 
    -0.02263377f, 0.00816450f, -0.02671786f, 0.03189027f, 0.00804496f, 0.02273561f, -0.04136653f, -0.01139307f, 
    0.00725209f, -0.01029159f, -0.01739700f, 0.00064225f, -0.03218120f, -0.01081824f, 0.02629778f, 0.00740364f, 
    -0.04049593f, -0.00122086f, -0.01943970f, 0.02669880f, -0.03731253f, 0.00494226f, 0.01123071f, -0.01320387f, 
    0.01909616f, -0.01178945f, -0.01674628f, -0.01160568f, -0.01805315f, -0.00279778f, 0.02962623f, -0.01796458f, 
    0.00947347f, 0.01310102f, -0.00886147f, -0.02091773f, 0.00015376f, 0.00582486f, -0.01478386f, 0.02116318f, 
    -0.00379933f, 0.02815459f, 0.02412364f, 0.01130931f, 0.02817172f, -0.03433759f, -0.01092236f, 0.00304002f, 
    0.02315191f, -0.03142572f, 0.01497074f, 0.01904573f, 0.01907957f, -0.01748208f, -0.01125841f, -0.03245822f, 
    -0.02547397f, -0.01215885f, -0.02125547f, -0.03521450f, -0.00172985f, 0.01438336f, -0.01845027f, -0.00191080f, 
    0.03073417f, -0.00760036f, -0.01176046f, -0.01125339f, -0.03032334f, 0.02258907f, -0.03775952f, 0.02375814f, 
    0.02785322f, 0.00293419f, 0.02026815f, -0.02599695f, -0.01223441f, -0.02561074f, 0.01204473f, 0.02565201f, 
    0.00362723f, 0.03193071f, 0.00035524f, -0.01868860f, 0.00376764f, 0.00479700f, 0.00438071f, -0.00577653f, 
    0.00516330f, -0.01573603f, -0.03848245f, -0.03563065f, -0.00530475f, -0.02000689f, -0.03422042f, 0.02494598f, 
    0.02997318f, 0.02372259f, -0.01298009f, -0.03512419f, 0.00319543f, -0.02738782f, 0.01340913f, -0.00542108f, 
    -0.00812832f, -0.01300408f, -0.03530972f, -0.03772296f, 0.00505700f, 0.01815630f, 0.02200994f, -0.03739710f, 
    0.01941868f, -0.01978178f, -0.01347844f, 0.01283351f, 0.00485655f, -0.00182201f, -0.01993796f, -0.01901715f, 
    -0.00958333f, 0.02693717f, -0.04083522f, 0.02408686f, -0.00376074f, 0.02122893f, -0.01037489f, -0.00516523f, 
    0.02690806f, -0.00162578f, -0.02905080f, 0.02731824f, -0.02596121f, 0.01692649f, 0.02144838f, 0.00558146f, 
    -0.01383938f, 0.00404684f, -0.02845360f, 0.03195614f, -0.02932560f, -0.00652108f, 0.02593442f, 0.02748334f, 
    0.00569447f, -0.02269312f, -0.00402533f, -0.02438376f, 0.02342277f, 0.02770460f, 0.00685247f, -0.01096778f, 
    0.01922030f, -0.03808948f, -0.01269251f, -0.02943407f, -0.02028407f, -0.03145098f, 0.00786812f, 0.02965160f, 
    -0.02871015f, -0.03483297f, 0.01450311f, 0.01281370f, 0.00862002f, 0.00578900f, -0.01651696f, -0.00676547f, 
    0.00596526f, -0.01639174f, -0.03778264f, 0.00347792f, -0.02967772f, 0.00606862f, -0.01408366f, 0.02454914f, 
    -0.03408798f, -0.01605336f, 0.02353859f, 0.00054306f, -0.01515643f, -0.03780660f, -0.01468531f, -0.02505856f, 
    -0.03102875f, 0.02026338f, 0.00138383f, -0.01011328f, -0.03446032f, -0.03863303f, -0.04202917f, 0.01981244f, 
    0.02423256f, -0.00876764f, 0.01531012f, -0.00735034f, -0.03665072f, -0.04040419f, -0.01888344f, -0.03442722f, 
    0.00656543f, -0.02495270f, 0.01415256f, -0.01153740f, -0.03703129f, 0.02601253f, -0.01338436f, -0.01553628f, 
    -0.02026377f, 0.02993860f, 0.00194214f, -0.01189741f, -0.01285734f, -0.02135396f, 0.00539966f, 0.00854264f, 
    -0.02630690f, 0.01940826f, 0.02830060f, 0.00306416f, 0.01236607f, 0.01485740f, 0.01598843f, -0.01552801f, 
    -0.02151114f, -0.01382215f, 0.02886217f, 0.01211248f, -0.00259452f, -0.02905317f, -0.01364224f, 0.01376570f, 
    0.02372663f, -0.00208392f, -0.03280903f, 0.00479747f, -0.00003424f, 0.02974392f, 0.00120394f, -0.03427324f, 
    -0.00296644f, 0.02178412f, -0.02680700f, -0.01286708f, -0.03439132f, -0.03543910f, 0.02707089f, 0.00974431f, 
    0.00676670f, -0.01606211f, 0.00649968f, 0.02059958f, 0.01215260f, 0.00442504f, 0.01397257f, 0.02377516f, 
    -0.03252263f, -0.02543833f, 0.00571197f, -0.00785473f, 0.01466263f, -0.02589853f, 0.01692554f, -0.01455500f, 
    0.02483605f, -0.03949078f, 0.02426563f, 0.00642344f, 0.01957009f, -0.01140978f, 0.00122861f, -0.00178799f, 
    -0.01286909f, -0.01528337f, 0.02617660f, -0.02371016f, -0.00558231f, 0.00490319f, -0.04118316f, 0.02514124f, 
    -0.00834551f, -0.02797576f, 0.02396828f, -0.02515808f, 0.01926269f, 0.01967175f, 0.02555954f, -0.01652664f, 
    -0.02415043f, -0.03699854f, -0.01389662f, -0.03598342f, -0.01648030f, -0.00774488f, -0.02626681f, -0.03930156f, 
    -0.02945441f, 0.02568275f, -0.03658353f, -0.02380514f, -0.00267067f, 0.01891686f, 0.02662913f, -0.03357766f, 
    0.00032626f, 0.01854046f, -0.00630845f, -0.02767635f, 0.00583816f, -0.02701403f, -0.02247800f, 0.01116210f, 
    -0.03205170f, -0.03414122f, -0.03053414f, -0.01021136f, 0.02764960f, -0.01385058f, 0.02246754f, 0.02015297f, 
    0.00762357f, -0.00634479f, 0.01570467f, -0.01418499f, -0.00942081f, -0.00128042f, -0.00158300f, 0.02690760f, 
    -0.00714827f, 0.02505631f, -0.02869967f, -0.02091381f, -0.02396265f, 0.01717328f, 0.01002590f, -0.01422518f, 
    -0.01610989f, -0.01114369f, -0.02191483f, 0.02133365f, -0.01854775f, 0.01113544f, 0.00596233f, 0.01918081f, 
    -0.03171832f, -0.00516602f, -0.02870102f, -0.00703061f, -0.02298480f, 0.02586647f, -0.03980602f, 0.02993487f, 
    -0.00942481f, -0.01926717f, 0.01209121f, 0.02370049f, -0.00697264f, 0.02117462f, 0.00557419f, -0.02847182f, 
    0.01423818f, -0.01449930f, -0.01239943f, -0.00829503f, -0.03058083f, 0.01336975f, -0.03786373f, -0.00144321f, 
    0.02296816f, -0.03197857f, 0.00842675f, 0.01829364f, -0.00057737f, -0.00197746f, 0.00094610f, 0.01727035f, 
    -0.03112224f, 0.02085689f, -0.02958667f, -0.00508486f, -0.01349018f, 0.02505917f, 0.00700171f, 0.01496949f, 
    -0.00084346f, -0.01472601f, -0.02418051f, 0.02463274f, -0.03615360f, -0.00587400f, 0.01546279f, -0.01908089f, 
    -0.01303675f, -0.02782781f, -0.02940468f, -0.02801447f, -0.02471474f, -0.02512492f, -0.02608424f, -0.00689959f, 
    -0.02827870f, -0.04005390f, -0.03144243f, -0.02514132f, 0.02123056f, -0.02745906f, 0.01696615f, 0.00675580f, 
    -0.01675140f, -0.00453326f, -0.04316244f, -0.04372547f, -0.01876464f, 0.01991318f, 0.00725506f, -0.01049642f, 
    0.01748089f, -0.00242717f, -0.01622404f, -0.01629998f, -0.00106785f, 0.01559998f, 0.00838233f, -0.02843672f, 
    0.01120412f, 0.01640220f, -0.03970697f, -0.01245611f, -0.02941015f, -0.03062223f, 0.00475687f, -0.02450175f, 
    0.01043708f, -0.02036696f, -0.00791602f, -0.00383651f, 0.01763832f, 0.03037186f, -0.02903756f, 0.02073663f, 
    0.01263519f, -0.00323279f, -0.00552070f, -0.01932609f, 0.00572497f, 0.01413324f, 0.02538550f, -0.00983084f, 
    -0.03139819f, 0.00628041f, 0.00537056f, -0.00113259f, 0.02215827f, 0.00951597f, -0.00566653f, 0.03361319f, 
    -0.02488728f, 0.03169563f, 0.00554443f, -0.02866175f, -0.02326324f, 0.00046017f, -0.01673161f, 0.01536430f, 
    -0.03479850f, -0.01740578f, -0.02038023f, -0.00799325f, -0.02009082f, 0.00369234f, -0.03224887f, 0.00189691f, 
    0.01964900f, 0.01585335f, -0.03836333f, 0.01832489f, 0.00796301f, -0.03003998f, -0.03439684f, 0.01736259f, 
    -0.03749936f, -0.02049473f, 0.02159687f, 0.02051245f, -0.02422142f, 0.02304574f, -0.00535534f, 0.01737965f, 
    0.01480762f, 0.02770262f, 0.02383071f, -0.03731309f, -0.03181898f, -0.03756250f, 0.01756321f, -0.03561002f, 
    -0.02389294f, -0.03339840f, 0.01093775f, 0.02329688f, -0.03317946f, 0.00009372f, 0.00963170f, -0.01154826f, 
    0.00077506f, 0.02122608f, 0.00252073f, -0.02088851f, -0.03061972f, -0.00758815f, 0.02477432f, -0.04140395f, 
    -0.02800769f, -0.01976327f, -0.02038197f, -0.03757413f, 0.02263846f, 0.02972351f, 0.02072952f, -0.03465587f, 
    0.02345514f, -0.00824717f, -0.00747597f, 0.02188914f, 0.01723589f, -0.03254656f, -0.03555959f, -0.02112345f, 
    -0.00484461f, -0.03367277f, -0.00329524f, -0.02904710f, -0.02014843f, 0.02903717f, -0.02154057f, -0.02339589f, 
    -0.01549727f, -0.01450353f, 0.00925952f, -0.01230162f, -0.02069701f, -0.02920788f, -0.01236164f, -0.04157167f, 
    -0.00442622f, -0.03347164f, -0.01152146f, -0.01981606f, 0.02816379f, 0.02904478f, -0.01061178f, 0.00561224f, 
    -0.03505469f, -0.00873697f, -0.02240340f, -0.01209110f, -0.00335894f, -0.02320147f, 0.01794136f, -0.01841825f, 
    -0.02132854f, 0.01438155f, -0.00932100f, 0.02526714f, -0.01004705f, -0.03630183f, 0.00571092f, 0.00964954f, 
    0.00346490f, -0.01998104f, 0.01166265f, -0.03137624f, 0.02933839f, 0.01322315f, 0.03044572f, -0.03409415f, 
    -0.02654561f, 0.02157937f, -0.03902685f, 0.01291446f, 0.00219647f, 0.02163865f, 0.01123791f, 0.00630394f, 
    0.01367627f, -0.00906588f, 0.00687129f, 0.02664936f, -0.03660376f, -0.01513442f, -0.02946297f, 0.00469204f, 
    -0.01055280f, -0.03229657f, 0.02632499f, -0.00926520f, -0.01598273f, 0.01640216f, 0.02922576f, -0.01068439f, 
    0.02631227f, 0.01809493f, -0.01838909f, -0.03365173f, -0.01192221f, 0.02643031f, -0.00819696f, -0.00577269f, 
    -0.01533152f, 0.00924529f, -0.02009021f, -0.00026460f, 0.02507067f, 0.02631618f, -0.01804836f, -0.00019003f, 
    0.03051101f, -0.01799486f, -0.02066110f, -0.02853822f, -0.03777687f, 0.02079595f, -0.02871725f, -0.03741961f, 
    -0.02308733f, -0.00460731f, 0.00153074f, -0.00447916f, -0.01304454f, -0.03011417f, 0.03012996f, -0.02771323f, 
    -0.02800511f, 0.01786792f, 0.01456269f, -0.04274718f, -0.01988257f, 0.02794071f, -0.00591004f, -0.03788994f, 
    0.01827774f, 0.02790491f, 0.01520979f, 0.00457028f, 0.00358455f, 0.01950896f, -0.01773237f, 0.02655550f, 
    -0.01735214f, 0.01465662f, -0.03302161f, -0.00264424f, -0.01196759f, 0.02265572f, 0.01738621f, -0.02584118f, 
    0.00123560f, -0.03529240f, 0.01166137f, -0.01731124f, -0.02231068f, -0.01368203f, 0.00407123f, -0.00875281f, 
    -0.02008601f, 0.00208100f, 0.01358022f, 0.03208623f, -0.04085806f, 0.02444551f, -0.03594364f, 0.00769702f, 
    -0.02085341f, 0.00259614f, 0.01279424f, 0.01299246f, 0.00961858f, -0.02247819f, 0.00226488f, -0.03570095f, 
    -0.03277857f, -0.01993195f, 0.00850589f, -0.02002387f, -0.01219569f, 0.01295046f, 0.02652118f, -0.03391645f, 
    -0.02229331f, -0.03416649f, 0.01098588f, -0.01831604f, -0.00658840f, -0.00621804f, 0.02506083f, -0.02994415f, 
    -0.03550284f, -0.00341791f, -0.03144528f, -0.02128834f, -0.02003798f, -0.00678245f, 0.01229774f, 0.01192748f, 
    0.01619036f, 0.01155133f, -0.02752881f, 0.00804535f, 0.00125270f, -0.01835930f, 0.00741536f, -0.00599043f, 
    0.00212594f, 0.01177242f, -0.00158542f, 0.02134006f, -0.02820597f, -0.00720786f, 0.01080640f, 0.00874349f, 
    0.19510472f, 0.00663543f, -0.08244308f, 0.30531958f, -0.09022475f, 0.00049285f, -0.03181328f, 0.12333287f, 
    -0.00211873f, 0.07516009f, 0.04731994f, -0.02400855f, -0.34979740f, -0.10378367f, -0.02730640f, 0.02676640f, 
    0.04648107f, -0.05354354f, -0.02181100f, -0.07989485f, 0.01596832f, 0.04313129f, -0.07751699f, -0.00496529f, 
    0.13197349f, -0.16041143f, -0.24940439f, 0.01762983f, 0.19370803f, 0.00103080f, -0.01827342f, -0.01606511f, 
    0.22481564f, 0.11290682f, 0.03203044f, -0.09240051f, 0.01614916f, 0.10511791f, -0.22222897f, 0.00675951f, 
    0.03349914f, 0.02970235f, -0.03468951f, 0.17429724f, 0.00059044f, 0.06196377f, 0.00125501f, 0.00032781f, 
    -0.02599602f, -0.16016304f, -0.03646057f, -0.23747543f, 0.05388854f, -0.00966078f, 0.01033565f, -0.05626528f, 
    -0.03943548f, 0.02613446f, 0.18030474f, 0.14548944f, -0.07048677f, 0.06613136f, -0.00640167f, 0.41164231f, 
    -0.11441286f, -0.14128101f, -0.05808689f, 0.03544730f, 0.05135885f, 0.11642999f, 0.08891662f, 0.02904473f, 
    0.22429767f, 0.10190632f, -0.02443447f, 0.22470227f, 0.01555630f, 0.02295823f, 0.05928903f, 0.14354497f, 
    -0.01700857f, 0.07804448f, 0.04629115f, 0.04395262f, 0.02015289f, 0.12668306f, 0.19094132f, 0.18789113f, 
    -0.12936650f, 0.02541239f, 0.01726709f, 0.17437106f, -0.12861815f, -0.06348410f, 0.07543804f, -0.12547874f, 
    0.29414031f, -0.02208571f, 0.35712489f, 0.05290972f, -0.14793544f, -0.02973429f, 0.04404261f, -0.04130122f, 
    -0.05932166f, 0.13831058f, 0.10209102f, -0.02692591f, 0.26754761f, -0.02205428f, 0.03661458f, -0.14904512f, 
    0.15278535f, 0.04758026f, 0.06627767f, 0.04502005f, 0.02028579f, 0.00801433f, -0.03536617f, 0.05281824f, 
    0.24202219f, 0.14479966f, -0.02150766f, -0.04474438f, -0.04910755f, 0.11118077f, -0.00183268f, -0.08013830f, 
    0.04674946f, -0.05082192f, -0.03563656f, 0.01487743f, -0.23069941f, 0.01282726f, 0.05180346f, 0.18715030f, 
    -0.04891365f, 0.01405246f, 0.19819558f, 0.01730181f, -0.13276982f, -0.04462127f, 0.02073790f, 0.11228963f, 
    0.32248905f, 0.11365415f, 0.09048402f, -0.09283420f, -0.14971936f, 0.09359504f, 0.03649012f, -0.01196173f, 
    -0.05762715f, 0.04522646f, 0.11103234f, 0.00069883f, -0.02022053f, 0.04398716f, -0.08570690f, -0.29150811f, 
    0.13345049f, 0.07530996f, -0.05969277f, 0.03487804f, 0.11143257f, 0.07611763f, 0.08255932f, -0.06749969f, 
    -0.20351586f, -0.13204978f, -0.16052647f, -0.02628269f, 0.02215620f, -0.05435429f, -0.06936898f, -0.08190392f, 
    0.07651206f, 0.05730546f, -0.00405858f, -0.04002521f, 0.16829453f, 0.32306749f, -0.29486313f, 0.06316715f, 
    -0.06716718f, -0.08340918f, -0.07391118f, 0.02838818f, -0.07333253f, 0.05371914f, 0.14957306f, 0.06328626f, 
    0.21737725f, -0.15126242f, 0.06573837f, 0.00576736f, -0.02595231f, -0.03763536f, 0.04749743f, 0.08349906f, 
    -0.01517317f, 0.01915940f, 0.00970745f, -0.07482697f, 0.31421202f, 0.14528692f, -0.02580433f, 0.00785699f, 
    0.05525853f, 0.09783243f, -0.02193731f, -0.01940617f, 0.06187482f, 0.02497874f, -0.02053228f, -0.03785008f, 
    0.09836806f, 0.15309143f, 0.20188048f, 0.21584772f, -0.07407758f, -0.03162599f, 0.03407351f, 0.07939780f, 
    0.08744647f, -0.10177822f, 0.13264993f, 0.08246710f, 0.07250445f, 0.02939848f, 0.00934537f, 0.05168557f, 
    0.08852079f, 0.02312974f, 0.02217176f, -0.05517475f, 0.14217083f, 0.05875659f, 0.02818066f, 0.07394220f, 
    -0.19548310f, -0.01632666f, -0.10758186f, 0.05059820f, 0.03979919f, -0.02734170f, 0.10075042f, 0.02345424f, 
    0.12548099f, 0.02545287f, -0.00839580f, 0.09077094f, -0.14900361f, 0.03240284f, -0.10268766f, 0.21263599f, 
    0.07289361f, -0.03432841f, 0.19940947f, 0.11016015f, -0.03681959f, -0.03833471f, 0.05091788f, 0.01549146f, 
    0.32743013f, 0.01404995f, 0.13040951f, 0.27105907f, -0.19298664f, -0.04519392f, 0.24109034f, 0.02438646f, 
    -0.17013870f, 0.11275465f, 0.05416758f, -0.06816520f, -0.14359625f, -0.00920863f, 0.05244661f, 0.23559450f, 
    0.01929004f, 0.06306228f, 0.06144707f, -0.07677202f, 0.03178208f, 0.06843146f, -0.02107926f, 0.00983772f, 
    0.19364409f, -0.02005666f, 0.09449647f, 0.11957991f, -0.14124173f, -0.09709772f, 0.03886608f, -0.05702534f, 
    -0.20594239f, 0.05671949f, 0.08007123f, -0.04708193f, -0.38769999f, -0.03615076f, 0.00666030f, -0.05897325f, 
    0.11772686f, 0.02286235f, 0.04641463f, 0.02161592f, 0.03052765f, 0.07526900f, -0.00104349f, 0.03041580f, 
    0.11810377f, 0.00316218f, -0.09595945f, 0.11359404f, 0.13694887f, -0.05112158f, 0.07106151f, -0.02385261f, 
    0.19691291f, -0.00984206f, 0.09010180f, -0.06451054f, -0.11154726f, -0.04973665f, -0.09012101f, 0.14203070f, 
    0.22199529f, 0.04139978f, 0.00153268f, -0.00630302f, 0.02325359f, -0.00801263f, -0.04928277f, 0.00711256f, 
    0.27011687f, -0.11642058f, 0.17081827f, 0.08908636f, -0.13406084f, -0.05606045f, 0.05020938f, -0.05337727f, 
    -0.07741164f, 0.10355025f, -0.01799915f, 0.04235379f, 0.25641420f, 0.04340869f, -0.05120161f, -0.01192631f, 
    0.00347546f, -0.03684116f, 0.13240510f, 0.01328716f, -0.04180026f, -0.01939624f, 0.03463667f, 0.01304433f, 
    0.04705076f, -0.00830973f, 0.14230573f, -0.13272628f, -0.11264804f, -0.03480278f, 0.07861522f, -0.03000147f, 
    -0.18421209f, 0.11648344f, 0.14737856f, -0.08877246f, -0.22519857f, -0.09130634f, -0.22835992f, 0.02510597f, 
    0.08473136f, -0.03552391f, -0.03576716f, -0.06441747f, 0.06506312f, -0.05635647f, -0.08243035f, -0.17514294f, 
    -0.11117540f, -0.16005810f, -0.18748048f, -0.31541887f, 0.01678078f, -0.01375633f, -0.08667880f, 0.03422001f, 
    -0.03115040f, 0.02436382f, 0.05345036f, 0.06117468f, 0.28829581f, 0.06022386f, -0.21159631f, -0.04386568f, 
    0.07623599f, 0.02248334f, 0.03545193f, -0.02673529f, 0.02847994f, -0.01860636f, -0.11318660f, -0.10920827f, 
    -0.04231580f, 0.09663248f, 0.16266824f, 0.00346465f, -0.08057246f, -0.05530560f, 0.04327165f, -0.00287645f, 
    -0.08826881f, 0.02797167f, 0.10656130f, 0.06885723f, 0.26979020f, 0.04840320f, -0.06983565f, -0.09954004f, 
    0.00329563f, 0.10124186f, 0.04223409f, -0.07096305f, 0.07098616f, -0.00527217f, -0.09189218f, -0.07352410f, 
    -0.18110213f, -0.15105465f, -0.16729124f, -0.14123735f, 0.03313600f, 0.02448322f, -0.04812111f, -0.01960992f, 
    -0.01508106f, -0.04502711f, -0.03108982f, -0.00659126f, -0.05623863f, 0.10794758f, 0.02252162f, 0.15664820f, 
    0.06526467f, -0.03355334f, 0.01238511f, -0.05616884f, -0.02592197f, -0.02971864f, 0.02485804f, -0.01789623f, 
    -0.14593895f, -0.07472477f, -0.18437450f, -0.17907734f, 0.04388639f, 0.10138369f, -0.04518150f, -0.00886164f, 
    0.01343240f, -0.02838549f, 0.09579616f, -0.00717208f, 0.01676520f, -0.11461198f, -0.12319349f, 0.14435489f, 
    0.08947996f, -0.04017800f, 0.03901485f, -0.01070097f, 0.03453713f, -0.05405070f, -0.08490139f, 0.06902327f, 
    0.16447735f, 0.12893225f, 0.07830443f, -0.20173302f, 0.04688356f, 0.05744933f, -0.04436945f, -0.07658107f, 
    0.07112387f, 0.02947777f, -0.07902024f, 0.07395387f, 0.13401470f, 0.15272410f, -0.19168891f, 0.01903161f, 
    0.00043854f, -0.01451371f, 0.10186225f, 0.08409822f, -0.00256106f, 0.03044177f, 0.03300536f, -0.03543815f, 
    0.10172076f, -0.01992992f, -0.01934728f, -0.11034098f, -0.03121537f, -0.05987160f, 0.04835257f, -0.01536977f, 
    0.05820886f, -0.02551638f, 0.00025650f, 0.06999221f, -0.15370579f, 0.12471446f, -0.08481302f, 0.08588978f, 
    0.12768869f, 0.09527717f, -0.06017540f, -0.06492376f, 0.17040454f, 0.08172067f, 0.04048965f, 0.06526224f, 
    -0.08368029f, -0.17815514f, -0.06000769f, -0.21429110f, 0.12622647f, 0.07869472f, -0.02843738f, -0.08225436f, 
    0.10159504f, -0.01291341f, 0.15433367f, 0.05054142f, 0.10284688f, -0.30559489f, -0.02639640f, 0.12717104f, 
    -0.05607755f, -0.09604560f, -0.02499567f, -0.00304888f, -0.16613433f, 0.01292077f, 0.20609075f, 0.01663574f, 
    -0.14823145f, 0.08142979f, -0.14855342f, 0.01043914f, 0.11794937f, 0.09378705f, -0.01270733f, -0.07253683f, 
    0.10090453f, 0.10345694f, 0.06556353f, 0.02871587f, 0.09459390f, 0.10968789f, -0.17464656f, 0.16186996f, 
    0.09302226f, 0.00610831f, -0.06626702f, 0.03463737f, 0.02787771f, 0.18693158f, -0.06012899f, 0.08312974f, 
    0.12684231f, -0.20494871f, 0.11180949f, -0.01226115f, 0.00091196f, 0.00666103f, 0.14196448f, 0.07070022f, 
    -0.02717422f, -0.10280433f, -0.11594833f, 0.07406670f, 0.31859383f, 0.06300344f, -0.09754501f, -0.00950277f, 
    -0.07376812f, -0.10488220f, 0.03538926f, 0.11435337f, 0.08718623f, -0.09323069f, -0.12481425f, -0.09750821f, 
    -0.29063573f, 0.00125951f, -0.07633754f, -0.05477645f, 0.00047742f, -0.01650001f, 0.07294080f, 0.04960814f, 
    -0.08298588f, -0.00450369f, 0.07483142f, -0.06068356f, -0.00699489f, 0.12906130f, 0.07649386f, -0.20159739f, 
    0.06861942f, 0.07948776f, -0.15153205f, -0.08852641f, -0.02524910f, 0.00815970f, -0.01020811f, 0.02594418f, 
    0.02011978f, 0.18983851f, 0.00206059f, -0.03763996f, -0.04409495f, 0.04607056f, -0.00679317f, 0.12862712f, 
    0.03040661f, 0.01641124f, 0.02211011f, 0.04138540f, -0.17696212f, -0.22772069f, -0.07317463f, 0.06851724f, 
    -0.04879989f, 0.07894994f, -0.02304645f, -0.01889587f, 0.00908957f, -0.03827128f, -0.04712671f, 0.03486899f, 
    0.01904034f, -0.07281730f, 0.24246360f, 0.26451764f, -0.11294623f, -0.02977000f, 0.19291358f, 0.11099487f, 
    -0.07845951f, -0.11486469f, 0.00355102f, -0.11879580f, -0.40520182f, -0.00338266f, -0.02439444f, 0.07908712f, 
    0.15363854f, 0.04256587f, -0.01879927f, 0.01565985f, -0.05885790f, -0.02739768f, -0.10052201f, -0.10132213f, 
    0.33192945f, -0.18284279f, 0.19092081f, 0.03839719f, -0.11692697f, -0.04106890f, -0.08934408f, -0.01258454f, 
    -0.11499498f, 0.01624190f, 0.07199132f, 0.01570719f, 0.51458442f, -0.20460191f, 0.14022000f, 0.05399147f, 
    -0.01660620f, 0.06910110f, 0.17082240f, 0.01040784f, 0.09579415f, 0.10047964f, -0.01841805f, 0.06803893f, 
    0.21943630f, 0.30140474f, 0.08264545f, -0.23134606f, 0.01565369f, 0.00421210f, 0.01660930f, 0.05256927f, 
    0.07134673f, 0.06454157f, 0.11339568f, 0.10680658f, 0.18306987f, -0.02525209f, -0.05262678f, -0.04564828f, 
    0.16126068f, -0.02757384f, -0.02700838f, 0.04940910f, 0.10687277f, 0.04102289f, 0.01711662f, -0.00232473f, 
    0.20775941f, 0.03524614f, -0.00488249f, -0.01497706f, -0.15375365f, -0.00678858f, 0.05955153f, -0.17250496f, 
    -0.11679682f, 0.11629105f, 0.04102072f, 0.00120507f, 0.10242857f, 0.17499085f, -0.07109848f, 0.09649900f, 
    0.00249260f, 0.01632208f, -0.08173153f, -0.03192644f, 0.01868847f, -0.02220720f, -0.04921986f, 0.00170511f, 
    0.16126257f, -0.06654520f, -0.00555004f, -0.00550096f, -0.01810059f, -0.06154890f, -0.06466009f, 0.05096644f, 
    -0.04057965f, 0.10560147f, 0.03844900f, -0.01496036f, 0.09017877f, -0.00758052f, -0.06174565f, 0.22523019f, 
    0.09359048f, 0.06943922f, 0.07363395f, -0.02424336f, 0.08788519f, 0.08684569f, 0.00959295f, -0.05957750f, 
    0.08453690f, 0.11649923f, -0.03867383f, 0.25454858f, -0.01082464f, -0.05929628f, 0.07416005f, 0.03653682f, 
    0.07719600f, -0.00766013f, 0.11646505f, 0.04635982f, 0.23818998f, 0.06206557f, -0.02291793f, 0.10650676f, 
    0.11763388f, 0.12887667f, 0.03258772f, -0.02101493f, -0.02281469f, 0.05296646f, -0.00350799f, 0.04475378f, 
    0.10560547f, 0.06981603f, 0.05568154f, -0.17991860f, 0.00156908f, 0.05089855f, 0.01629087f, 0.05030723f, 
    -0.00452507f, 0.14284927f, 0.08464681f, -0.00865270f, 0.16325966f, 0.10774581f, 0.11711216f, -0.04550777f, 
    0.14592022f, 0.04479678f, 0.04138936f, 0.01861814f, -0.09000087f, 0.10269105f, 0.07868204f, 0.03201195f, 
    -0.04252791f, 0.30797589f, 0.18408252f, 0.36829549f, 0.04370974f, 0.11543024f, 0.02662242f, 0.11536693f, 
    -0.02461612f, 0.11156856f, 0.01726031f, 0.04017544f, -0.13564733f, 0.16602837f, 0.00600764f, -0.11299975f, 
    0.08017375f, 0.13696705f, -0.02035034f, 0.09037670f, 0.09642458f, 0.00174060f, -0.08293859f, 0.14269798f, 
    -0.12478906f, -0.02049082f, 0.03533997f, 0.01110435f, 0.11037330f, 0.06658574f, -0.10277627f, 0.03318406f, 
    0.15980527f, 0.05278709f, 0.03377577f, 0.06237683f, 0.10882315f, 0.07093644f, 0.09652609f, 0.07590198f, 
    0.02204873f, 0.04982977f, 0.10515101f, 0.02780752f, 0.01700971f, 0.07894256f, 0.10215668f, 0.16882844f, 
    0.22152552f, -0.22382331f, 0.14318638f, 0.05505466f, 0.03872596f, 0.05411899f, 0.04758393f, -0.00395821f, 
    0.04349545f, -0.00164563f, 0.09054239f, 0.09519306f, -0.14720443f, 0.08615480f, -0.16563028f, -0.29745382f, 
    0.09284575f, 0.07216173f, 0.05665605f, -0.02948153f, -0.05214896f, 0.06240803f, 0.10976771f, 0.06732652f, 
    0.13426796f, -0.15906858f, -0.03405791f, -0.10184430f, 0.09264395f, -0.06135633f, -0.04725520f, 0.04774142f, 
    0.03722169f, 0.00787663f, 0.11942031f, -0.01262056f, 0.19201910f, 0.21767572f, 0.05060161f, -0.07439419f, 
    0.05803807f, 0.03926216f, -0.07112056f, 0.06256957f, 0.07880409f, -0.02003867f, 0.06279169f, 0.08449550f, 
    0.13433674f, 0.00267532f, 0.00400218f, 0.07475308f, 0.07153171f, 0.07717037f, 0.08931741f, 0.02326059f, 
    0.06992476f, -0.02677900f, 0.05475422f, 0.01086451f, 0.19728926f, 0.13506579f, 0.11174563f, 0.08580767f, 
    0.10550151f, -0.03516137f, 0.02851318f, 0.05741429f, 0.09484795f, 0.02673697f, 0.07273503f, 0.10637442f, 
    0.05692309f, 0.26918891f, 0.15152985f, 0.02611290f, 0.08491303f, 0.02201349f, -0.03465230f, -0.00998426f, 
    0.04838390f, 0.03264751f, 0.19455932f, -0.10483117f, -0.33146182f, 0.02041440f, 0.03288225f, 0.01242473f, 
    0.11257846f, 0.09284545f, 0.01363185f, 0.04764657f, 0.04783427f, 0.06197565f, 0.04937321f, 0.00601294f, 
    0.27285853f, -0.08017048f, -0.07998499f, -0.03717758f, -0.01901205f, 0.10218713f, 0.12078629f, -0.12108620f, 
    0.04939700f, 0.10978907f, 0.01755759f, -0.07865387f, -0.06910657f, 0.01178340f, -0.04076945f, -0.05693928f, 
    0.03759861f, 0.04865733f, 0.08356732f, 0.05535120f, -0.01874056f, 0.00494899f, 0.09163260f, 0.06465678f, 
    -0.03111055f, -0.22790712f, 0.17275484f, -0.02289668f, -0.02024549f, 0.13709778f, 0.02313155f, 0.12317779f, 
    0.02609240f, 0.12359554f, -0.01196856f, 0.06605904f, -0.30576929f, 0.03753213f, -0.11819477f, -0.18466823f, 
    -0.00787388f, 0.04715456f, 0.05783563f, -0.09826621f, 0.04120556f, 0.22047538f, 0.03088862f, -0.04246007f, 
    -0.11547226f, 0.16145794f, 0.11273479f, 0.06864935f, 0.10887472f, 0.06923314f, 0.02986847f, 0.19011888f, 
    0.09584031f, 0.02675993f, 0.09022810f, 0.17164510f, 0.11801790f, 0.18415308f, 0.01251811f, 0.12011655f, 
    -0.00751653f, 0.04714340f, -0.01395689f, 0.02838521f, 0.12008660f, 0.01801853f, 0.06956493f, 0.19332848f, 
    -0.06526905f, -0.04969349f, 0.27903044f, 0.06057315f, -0.02520860f, 0.19371232f, 0.02389457f, 0.00079342f, 
    -0.00283143f, 0.11598063f, 0.03345374f, 0.17342645f, -0.02821457f, 0.34057644f, -0.12412551f, 0.23715626f, 
    0.17461742f, 0.08831035f, 0.01283397f, 0.07140034f, 0.03977803f, -0.03437561f, 0.04892278f, -0.03361730f, 
    0.05950246f, 0.00479160f, -0.19141446f, -0.10883243f, 0.04727352f, 0.05984958f, 0.02810961f, 0.05625873f, 
    0.10483086f, 0.04482223f, 0.02812301f, -0.03943606f, -0.06870917f, 0.10222622f, -0.15522173f, 0.00243699f, 
    0.03003470f, 0.04341691f, 0.01434866f, 0.08616710f, 0.02428640f, 0.06268103f, 0.06891673f, 0.03101869f, 
    -0.04817379f, 0.00874060f, -0.21677995f, -0.38615739f, -0.01229674f, 0.06674640f, 0.07526254f, 0.00844165f, 
    0.05583961f, 0.02632168f, 0.08024488f, 0.07213493f, -0.12293764f, 0.11948739f, 0.03399166f, -0.04910319f, 
    0.06392215f, -0.00311265f, -0.01177676f, 0.06176084f, 0.07083699f, 0.11005610f, -0.00247924f, 0.06267952f, 
    0.42264310f, -0.19685557f, 0.05170299f, 0.14680147f, 0.00232661f, 0.08729525f, 0.10099982f, 0.01723512f, 
    0.16779108f, -0.04960828f, -0.11808454f, 0.12700526f, -0.20173945f, 0.04558001f, 0.23597173f, -0.13234872f, 
    -0.06096987f, 0.12073998f, -0.07512247f, 0.02389857f, 0.03633344f, 0.03801437f, 0.04734965f, -0.01847289f, 
    0.08509699f, -0.23014095f, 0.11006207f, 0.18571635f, -0.03326056f, -0.09334306f, 0.06234946f, -0.01307071f, 
    0.02835057f, 0.07647690f, -0.00423009f, 0.06311575f, 0.05261472f, 0.26943395f, 0.31708917f, 0.11604571f, 
    0.05264204f, 0.08492232f, 0.00222472f, -0.01749018f, 0.01989544f, 0.12849809f, 0.08652351f, -0.00540806f, 
    0.21736966f, 0.17979209f, 0.21198024f, 0.19609660f, 0.11380092f, -0.03340577f, 0.03385451f, -0.03879377f, 
    0.03586064f, 0.10755603f, 0.04162702f, 0.02723065f, -0.30447847f, 0.04756904f, -0.12196460f, -0.35591319f, 
    0.02560688f, 0.08168610f, 0.04978550f, -0.02293225f, 0.09220078f, 0.03640336f, 0.00964004f, 0.04606436f, 
    -0.34022948f, -0.09196305f, 0.19931310f, 0.01845315f, 0.00770498f, -0.02411902f, 0.01899075f, -0.07908181f, 
    0.00816561f, 0.02503706f, 0.04896608f, 0.13818443f, -0.16853772f, -0.16370293f, -0.21651295f, -0.29550156f, 
    0.00629815f, -0.04234905f, 0.12879311f, -0.01650416f, 0.00451645f, 0.09947194f, -0.01926106f, 0.09562521f, 
    0.26338980f, 0.00586845f, 0.07102808f, 0.28155115f, 0.09817204f, -0.03610882f, 0.06970983f, 0.04733663f, 
    0.09779139f, -0.00948084f, 0.04214059f, 0.14911972f, 0.09755933f, 0.31269401f, 0.08396603f, 0.00846638f, 
    -0.04128744f, 0.00691939f, 0.06912580f, 0.03783349f, 0.02432427f, 0.05816553f, 0.05568042f, 0.09552319f, 
    0.04121964f, 0.28012475f, 0.26782861f, 0.26624432f, 0.07943580f, 0.03736495f, -0.02117228f, -0.01517817f, 
    0.09738244f, 0.07186007f, 0.06928916f, 0.01104747f, -0.02701620f, -0.04078715f, -0.11884340f, 0.07273215f, 
    -0.05317910f, -0.09934886f, -0.06802516f, -0.00075049f, 0.11791822f, 0.16944899f, 0.06919440f, 0.04554422f, 
    -0.19882044f, -0.20836230f, 0.10099781f, -0.03079666f, 0.04272695f, -0.11926164f, 0.13886163f, -0.03611116f, 
    0.05999156f, 0.13825496f, 0.01895826f, 0.07620790f, -0.15081142f, -0.04069997f, 0.07668549f, -0.04489320f, 
    0.04367121f, -0.01596884f, 0.01923836f, 0.12043952f, 0.06249883f, 0.00948281f, -0.00344120f, -0.00368416f, 
    0.21309978f, -0.07557290f, 0.27076733f, 0.12962809f, -0.04876273f, 0.05958610f, -0.05067478f, -0.00537055f, 
    0.02897688f, 0.03904822f, 0.07144262f, 0.12412363f, -0.17620395f, 0.03176657f, 0.11498706f, -0.06534775f, 
    0.11905009f, 0.06452721f, 0.04008366f, 0.17576335f, 0.02605999f, 0.03127135f, 0.02768607f, 0.05562491f, 
    0.10384803f, 0.17423056f, 0.12762113f, 0.11918426f, 0.06316055f, 0.07248948f, 0.08457719f, -0.02760621f, 
    -0.06378491f, 0.15272783f, 0.04770002f, 0.00162456f, 0.12481764f, -0.03350945f, 0.09229419f, 0.19374488f, 
    -0.01461441f, 0.12597810f, -0.02835839f, 0.07805932f, 0.13624212f, 0.00022870f, 0.10580180f, 0.10210545f, 
    0.01692870f, 0.23644897f, 0.27046293f, 0.21031626f, 0.00101529f, 0.00408971f, 0.11478362f, 0.03769669f, 
    -0.01951354f, 0.12499491f, 0.03880220f, 0.05686344f, -0.27109101f, 0.11837614f, 0.07345892f, -0.27251047f, 
    0.17947555f, 0.05604091f, -0.05639841f, -0.01457556f, -0.02910988f, 0.01111055f, -0.02977069f, 0.03638062f, 
    0.57219040f, 0.04623168f, -0.11086433f, -0.04498208f, -0.04173588f, -0.03248307f, 0.11700102f, 0.03686680f, 
    0.00281313f, 0.03683098f, 0.06466464f, 0.05386680f, -0.12416917f, -0.01486426f, 0.02345913f, -0.10388079f, 
    -0.04645080f, 0.09691487f, 0.16458769f, 0.02878149f, 0.18084945f, 0.02350631f, -0.00179989f, -0.04815209f, 
    0.42357993f, 0.08410656f, 0.01643566f, 0.27790007f, -0.00864780f, 0.07307868f, 0.14129838f, 0.02479848f, 
    0.11652903f, 0.04552356f, 0.11687411f, 0.10795996f, -0.13504687f, 0.33178473f, 0.10096039f, -0.01601712f, 
    0.00138364f, 0.01978488f, 0.12522757f, -0.01119734f, -0.01819741f, 0.12110984f, 0.09638131f, 0.11545686f, 
    0.53002435f, -0.19887711f, 0.20673504f, 0.03748689f, 0.01230537f, 0.04021086f, 0.09292036f, -0.11437501f, 
    0.19314604f, -0.00140750f, 0.02027546f, -0.04547852f, -0.13667448f, 0.22979869f, -0.12885375f, 0.03497970f, 
    0.15248661f, -0.06981371f, -0.04641049f, 0.07823727f, 0.09281430f, 0.02828789f, 0.00331140f, -0.04933046f, 
    -0.03814121f, 0.09136464f, 0.12544018f, -0.01494360f, 0.05280627f, 0.05258201f, -0.07216877f, 0.13347699f, 
    0.09218420f, 0.05478216f, 0.08975022f, 0.05946265f, 0.44002259f, 0.17278166f, 0.09806798f, 0.01635890f, 
    -0.05620573f, 0.04245557f, 0.06069547f, 0.05015349f, 0.05775156f, 0.17278180f, 0.03248838f, 0.06474949f, 
    -0.24112001f, -0.07476791f, 0.11540692f, 0.09521020f, -0.02226215f, 0.00847031f, -0.00844539f, 0.04451096f, 
    -0.01547158f, 0.08789386f, -0.00286350f, 0.07811452f, 0.45591718f, 0.02514419f, 0.12086382f, 0.06555388f, 
    -0.07746701f, 0.06347520f, 0.04103862f, 0.01329845f, 0.05933537f, 0.15367748f, 0.19424860f, 0.02179412f, 
    0.08158299f, -0.08988453f, 0.04649079f, -0.03851131f, 0.16367817f, 0.08187998f, -0.02818527f, -0.00660556f, 
    0.07304353f, 0.01420979f, 0.07715611f, 0.06575537f, 0.00403443f, 0.22298412f, -0.11376170f, -0.07108086f, 
    0.08690325f, 0.12785879f, 0.01864650f, 0.03541502f, 0.07320812f, -0.04386873f, 0.08443480f, 0.08512850f, 
    -0.10943748f, -0.25881669f, 0.25187543f, -0.11459308f, -0.07582062f, 0.11654769f, 0.02966136f, -0.01112601f, 
    -0.02161909f, -0.06041619f, 0.05508840f, 0.08420719f, -0.42587268f, 0.07273319f, 0.14440972f, -0.09592357f, 
    0.01804209f, -0.00903417f, 0.06946597f, 0.18351479f, 0.04177395f, -0.01412094f, 0.13782740f, 0.06454867f, 
    0.03920723f, -0.09185389f, 0.05988554f, 0.15282965f, 0.09473670f, 0.01184481f, -0.11558289f, 0.03182703f, 
    0.06957518f, 0.12814227f, 0.01879643f, 0.10312869f, 0.38774425f, 0.04194991f, -0.18048848f, -0.11599395f, 
    0.17130467f, -0.00470718f, -0.00489707f, 0.03740237f, -0.02335317f, 0.03397511f, 0.03066561f, 0.15794952f, 
    0.02528521f, -0.01664034f, -0.03104051f, -0.00150260f, -0.02516955f, 0.03777473f, -0.00790438f, -0.00130595f, 
    0.01838881f, -0.01188454f, -0.01666914f, -0.02398775f, 0.02590046f, 0.00449634f, -0.02259882f, -0.03337952f, 
    0.00234543f, -0.03283331f, -0.00348226f, 0.02651407f, 0.02004906f, -0.02457887f, 0.02133301f, 0.02462461f, 
    0.00819773f, 0.00587774f, 0.02727350f, -0.01415528f, -0.00420838f, 0.02011937f, 0.00211291f, 0.03211134f, 
    0.03273494f, 0.02662794f, -0.00033645f, -0.01642646f, 0.03274013f, 0.00292465f, -0.01095974f, 0.01604807f, 
    0.00338763f, -0.02937509f, 0.01918160f, 0.02654479f, -0.00149499f, 0.03167026f, -0.02566413f, -0.03483675f, 
    -0.01910760f, 0.00944536f, -0.01908174f, 0.00789382f, -0.03764593f, -0.00669913f, -0.00362341f, 0.02100522f, 
    -0.00839776f, -0.00256865f, 0.01433366f, -0.02319744f, -0.03987618f, 0.02486558f, 0.03542741f, 0.01063261f, 
    0.01373157f, -0.00472475f, -0.02869662f, 0.02971198f, 0.03950537f, -0.00789132f, 0.02146520f, 0.00801253f, 
    -0.01879457f, 0.04345371f, -0.01076609f, -0.01517581f, -0.00468514f, 0.02495333f, 0.01585540f, -0.00863050f, 
    0.03152296f, -0.01821541f, 0.02291711f, 0.00876473f, -0.03742070f, -0.03127544f, 0.00815366f, -0.02332928f, 
    -0.03168008f, -0.02732818f, 0.02707754f, -0.02564655f, -0.00868929f, -0.02511974f, 0.00434975f, -0.00354356f, 
    -0.01004919f, 0.00398976f, 0.02023204f, -0.00746097f, -0.01289397f, 0.01604336f, -0.00612256f, -0.00374907f, 
    0.00579307f, -0.01120500f, -0.00366011f, -0.03337120f, -0.02678119f, -0.03490069f, 0.03173658f, -0.03229945f, 
    0.03500465f, -0.03531951f, -0.01325718f, -0.01955392f, -0.02268242f, -0.01709927f, 0.00663850f, -0.03031197f, 
    0.03260391f, -0.00253643f, -0.00785858f, 0.03100083f, 0.01656603f, -0.01011690f, -0.02737147f, -0.01851348f, 
    -0.00825867f, 0.03765018f, 0.01429031f, 0.02268439f, 0.01048987f, -0.03145843f, 0.02778879f, -0.02980666f, 
    -0.00929696f, 0.00803628f, -0.01275945f, 0.01225126f, 0.01832584f, -0.03287391f, -0.00546843f, -0.02427690f, 
    -0.02722794f, 0.00255611f, -0.00531473f, -0.03551267f, 0.02449079f, -0.00907921f, -0.04225233f, 0.01143151f, 
    -0.02435659f, -0.03164437f, -0.00024293f, 0.00959687f, -0.01959591f, -0.02197023f, -0.00477909f, 0.00581907f, 
    -0.01872692f, -0.02922177f, 0.00877426f, -0.01861222f, -0.02649261f, 0.01819412f, -0.00171540f, -0.02992832f, 
    -0.01326196f, 0.01266837f, -0.01086599f, 0.01388490f, -0.03401915f, -0.02905092f, 0.02891983f, -0.01056002f, 
    0.01242989f, -0.03843400f, -0.01838246f, 0.01192688f, 0.00722040f, -0.02963422f, -0.01098750f, -0.01059119f, 
    0.03280400f, 0.03784275f, -0.02212837f, -0.00250140f, -0.03801800f, 0.02978192f, 0.01595002f, -0.02761887f, 
    -0.02103761f, 0.00556095f, -0.02920254f, -0.03858459f, 0.00161657f, 0.03081394f, 0.03257652f, -0.01905600f, 
    0.01754026f, 0.03636917f, 0.00730712f, 0.01450918f, 0.02944549f, 0.01802102f, -0.01798131f, -0.02682135f, 
    0.03181867f, -0.03173832f, 0.00653505f, -0.01681986f, 0.01204559f, -0.03863073f, 0.00523411f, -0.00447652f, 
    0.00369094f, -0.00040166f, -0.00634230f, 0.00444343f, 0.00649018f, 0.00029241f, 0.00619206f, -0.00429015f, 
    -0.03541315f, 0.03000811f, 0.00182038f, -0.01777128f, -0.00426442f, -0.00469710f, -0.00569679f, 0.02212923f, 
    -0.01682620f, 0.01887680f, -0.03054653f, 0.02778414f, 0.00561393f, 0.00780063f, -0.04083331f, -0.01594535f, 
    0.00037383f, 0.01896489f, 0.00122596f, -0.02101251f, -0.01432672f, -0.01715642f, -0.00290264f, 0.02732905f, 
    0.01245896f, 0.02463410f, -0.03164247f, -0.02650256f, -0.03527897f, 0.01718904f, -0.00930143f, -0.01906911f, 
    -0.03810473f, 0.02218183f, 0.03064786f, -0.01016856f, 0.03605489f, -0.02013332f, -0.02562688f, -0.01546310f, 
    0.00065313f, 0.01018462f, -0.02449472f, 0.02484735f, -0.02913704f, 0.00361847f, -0.01566378f, 0.00491141f, 
    -0.02936131f, 0.03215025f, -0.01462912f, 0.01396250f, -0.02307300f, 0.00621191f, 0.01693202f, -0.00526837f, 
    -0.03937212f, -0.00962013f, -0.00448735f, 0.01926675f, 0.01323125f, 0.01782696f, 0.00920759f, -0.03436124f, 
    -0.03420064f, -0.02148519f, -0.00055052f, -0.02473068f, 0.01616339f, -0.01456469f, -0.01766017f, -0.03184829f, 
    -0.00798237f, -0.02591361f, -0.00467743f, -0.00452815f, -0.02909292f, 0.02246383f, 0.00591963f, 0.02396338f, 
    -0.01466157f, 0.01244459f, 0.03319151f, 0.03104734f, -0.00065825f, 0.02477528f, 0.02891821f, 0.03208582f, 
    0.01793680f, 0.01015533f, -0.03015636f, -0.01333831f, -0.02799961f, 0.00088760f, -0.00562372f, -0.00815310f, 
    -0.02530040f, -0.02953055f, 0.02944475f, 0.03514652f, 0.02021460f, 0.00163214f, -0.02826783f, -0.02856789f, 
    -0.01052752f, -0.00984970f, -0.00680345f, 0.01839310f, -0.00145100f, -0.02169949f, 0.00863951f, 0.00945703f, 
    -0.00578136f, -0.02062794f, 0.00855185f, 0.01793832f, 0.02664432f, 0.03798515f, 0.00886713f, -0.03002251f, 
    -0.00199126f, -0.01774892f, -0.02739061f, -0.02662421f, -0.01493838f, 0.02690240f, -0.03642295f, 0.00036316f, 
    0.02864480f, -0.02109536f, -0.02870318f, 0.00225476f, -0.03194034f, -0.00742304f, 0.00395109f, -0.01028873f, 
    -0.03242704f, -0.03353375f, 0.03567184f, 0.02912194f, -0.03836785f, -0.01856130f, 0.03110141f, 0.01987524f, 
    0.01049239f, -0.00783473f, 0.00119149f, -0.00693950f, 0.00582975f, 0.01517126f, -0.00775590f, 0.01762799f, 
    -0.00329220f, -0.01745917f, -0.00769787f, -0.02885664f, 0.02649317f, 0.03703392f, -0.02485559f, 0.01222122f, 
    0.02907291f, -0.04214514f, 0.00665753f, 0.02366249f, 0.03893259f, 0.00602303f, 0.02677172f, -0.00376927f, 
    -0.00539603f, -0.03487290f, -0.01835593f, 0.03398231f, 0.01415859f, 0.02987881f, -0.03027580f, 0.02787614f, 
    0.02418979f, -0.00572515f, 0.02013763f, 0.00693438f, -0.01650324f, -0.00703122f, -0.00112128f, 0.00415487f, 
    0.01721894f, -0.01591145f, -0.00348265f, -0.00269016f, 0.00448459f, 0.01563081f, -0.02784171f, -0.03452808f, 
    -0.00936862f, -0.03567471f, 0.02367945f, -0.00783477f, 0.02198598f, 0.00680284f, -0.00094822f, -0.03342636f, 
    -0.01525570f, 0.00523593f, -0.00413767f, -0.00074414f, -0.02297797f, -0.01894436f, 0.01228070f, -0.00628375f, 
    -0.01431195f, -0.00793880f, -0.02509642f, -0.02125931f, 0.02380606f, -0.02516829f, 0.00418886f, -0.02331869f, 
    -0.00371108f, -0.00110149f, -0.01265952f, -0.02950292f, -0.03098390f, 0.01502869f, -0.01639019f, -0.00285763f, 
    0.02346886f, 0.00966302f, -0.01290941f, 0.02310237f, -0.03176995f, 0.01364984f, -0.00929554f, -0.03279345f, 
    0.01779977f, 0.01525550f, 0.00732979f, -0.02841189f, 0.00756167f, 0.03410671f, 0.01770668f, -0.02641083f, 
    -0.00266724f, -0.02738681f, -0.01036276f, -0.02469020f, 0.02355941f, -0.01640631f, 0.01441297f, -0.01015021f, 
    -0.03097330f, 0.02710714f, -0.02932873f, -0.00741121f, 0.02116722f, 0.00511119f, -0.02588811f, 0.01812640f, 
    -0.02135710f, -0.03601995f, -0.01826775f, -0.02860695f, -0.00765050f, 0.02524691f, 0.02033634f, -0.03782346f, 
    0.00284203f, -0.02259774f, 0.02397203f, -0.03028287f, 0.00802187f, -0.03496290f, -0.01347021f, -0.02462459f, 
    -0.00126436f, 0.01580055f, -0.03844076f, 0.03208201f, -0.00718526f, -0.02071540f, -0.00313537f, 0.02388741f, 
    0.01068690f, -0.04063711f, 0.01470486f, 0.02190770f, 0.01938047f, 0.00027890f, -0.00813402f, -0.01531824f, 
    -0.02143196f, -0.00662340f, -0.01012287f, 0.02444086f, 0.03738672f, -0.00263644f, 0.00441541f, -0.01250927f, 
    0.00278085f, 0.00744247f, -0.02548178f, 0.02167919f, -0.01351419f, -0.00183312f, -0.00691614f, 0.00407478f, 
    -0.01749267f, 0.00327900f, -0.04107213f, -0.02649791f, 0.03630605f, -0.01311941f, -0.00842391f, -0.02776924f, 
    0.01557158f, -0.02399966f, 0.00593382f, 0.01629349f, -0.02971428f, -0.01401943f, -0.00429069f, -0.02734302f, 
    -0.00199759f, 0.00150137f, 0.00005593f, 0.02032981f, -0.02592941f, -0.02587743f, 0.00215002f, -0.00062640f, 
    0.01145513f, 0.01975567f, -0.03261143f, -0.03286141f, 0.03298204f, 0.01638162f, -0.02405915f, -0.03754637f, 
    -0.00647097f, -0.04151328f, -0.02632857f, 0.00882085f, -0.02328556f, -0.00164095f, 0.02678503f, -0.04143016f, 
    0.00365354f, -0.01017919f, -0.03505744f, -0.03596932f, 0.02490151f, 0.01240272f, 0.00290358f, 0.00285346f, 
    0.01891067f, -0.01955887f, -0.01774619f, 0.00981117f, 0.02837221f, 0.02043520f, -0.02843853f, -0.00139471f, 
    0.03674475f, 0.03149362f, -0.02423096f, 0.02852014f, 0.02581840f, 0.00018404f, 0.02087411f, 0.00153329f, 
    -0.00110948f, 0.02416332f, 0.01966864f, 0.01197528f, -0.03016859f, -0.02137492f, 0.03521633f, -0.00215420f, 
    -0.00894415f, -0.03424587f, -0.00618151f, 0.02355588f, -0.03401005f, -0.02378983f, -0.02207274f, -0.01069343f, 
    0.00250176f, -0.01164944f, -0.01622794f, -0.02208008f, 0.03134232f, 0.00750642f, 0.03483445f, 0.01191934f, 
    0.03083400f, 0.00831276f, 0.00330885f, 0.00030095f, 0.04181603f, 0.02314912f, -0.00204008f, 0.01256046f, 
    0.00223843f, -0.03563023f, -0.00080121f, -0.01345541f, -0.02106463f, -0.02324241f, 0.03576532f, -0.02275784f, 
    0.00822216f, -0.04142842f, 0.03480563f, -0.00406039f, 0.00627726f, 0.02526578f, 0.00427693f, 0.00458729f, 
    -0.00942953f, -0.00384299f, 0.02171111f, -0.02256176f, -0.02417838f, 0.02954622f, 0.00742487f, 0.03198091f, 
    0.01840386f, -0.00125703f, -0.02801229f, -0.03450463f, 0.00120807f, -0.02265741f, 0.02019430f, -0.00539348f, 
    -0.01982928f, 0.02135315f, -0.01461776f, -0.02485192f, 0.02926201f, 0.02418102f, -0.01588650f, -0.00796985f, 
    -0.04105829f, 0.00916555f, 0.02034565f, -0.01760683f, -0.01879554f, 0.02124546f, 0.00285242f, -0.00171374f, 
    -0.01774276f, -0.04276725f, 0.02732437f, 0.01594929f, -0.01976952f, 0.00674783f, -0.03008000f, -0.02334760f, 
    -0.00437014f, -0.01541377f, -0.02632372f, -0.01354215f, -0.03541238f, -0.00698801f, -0.01101821f, -0.00929038f, 
    -0.01046110f, -0.04366564f, -0.03482650f, 0.00962861f, -0.00030294f, -0.03131199f, 0.01045902f, 0.02990455f, 
    0.01842876f, 0.00955929f, 0.01063408f, 0.02649860f, -0.00985743f, 0.00467395f, -0.03474792f, -0.01326071f, 
    -0.03115516f, -0.00905759f, -0.01816881f, -0.03794223f, 0.01260551f, 0.03208659f, -0.01103902f, -0.01364454f, 
    -0.03591118f, 0.02385391f, -0.01403057f, -0.00616374f, 0.01527462f, 0.01921584f, 0.02569761f, 0.02593497f, 
    -0.03040997f, 0.01270340f, 0.01334584f, -0.03552322f, -0.02712803f, -0.02541300f, 0.02056514f, -0.02546838f, 
    -0.01814397f, -0.01386669f, 0.02083099f, -0.00420251f, 0.01572021f, 0.03131193f, -0.00490035f, -0.01316178f, 
    -0.00311413f, -0.02039038f, -0.02044263f, -0.01000858f, -0.00301302f, -0.01575778f, -0.03275864f, -0.00673257f, 
    0.02314359f, 0.03361329f, 0.01493203f, 0.03141487f, 0.00587948f, 0.02547439f, -0.01567064f, -0.03274921f, 
    0.00079857f, 0.02407943f, -0.03160353f, -0.02865137f, -0.00687312f, 0.02139029f, -0.02674509f, -0.01327948f, 
    0.01433467f, -0.03024629f, -0.02065672f, 0.02000857f, -0.01198147f, -0.00809015f, 0.02685937f, -0.02717606f, 
    0.01563845f, -0.02981812f, -0.04354284f, -0.02407503f, -0.02854873f, 0.02492265f, -0.03094875f, 0.01553987f, 
    -0.00952591f, -0.00986543f, 0.00279266f, -0.03153696f, -0.04195402f, -0.03023792f, -0.01344356f, -0.01250651f, 
    -0.02766376f, -0.03022896f, 0.01846479f, -0.02125924f, 0.00358234f, 0.02820752f, 0.01758183f, -0.00926273f, 
    -0.01990938f, -0.00900448f, 0.00080688f, -0.03087918f, 0.02365251f, -0.01176136f, 0.01959842f, -0.02513729f, 
    -0.01029571f, -0.01361525f, -0.04178121f, 0.00744348f, 0.02369772f, -0.00633643f, 0.01870595f, -0.02405321f, 
    0.02075516f, -0.03283224f, 0.01476448f, 0.01879092f, -0.01314133f, 0.00162039f, 0.01509425f, -0.02029246f, 
    -0.00563128f, -0.00784673f, -0.00068695f, 0.02791180f, -0.01185511f, -0.02310031f, 0.01196085f, -0.01312493f, 
    0.02744410f, 0.01812314f, -0.00069989f, -0.00135541f, -0.00390295f, 0.02280575f, 0.02827006f, -0.00108902f, 
    -0.01134842f, 0.01226677f, 0.02367171f, 0.00047438f, -0.00866110f, -0.01260975f, -0.02837487f, 0.01920799f, 
    -0.01020104f, 0.01475262f, 0.01488641f, -0.02000355f, 0.00647050f, -0.00877030f, -0.01510002f, 0.02684455f, 
    -0.00942991f, -0.03100217f, 0.00869330f, 0.01384307f, 0.02529680f, -0.00530012f, -0.02353206f, 0.00196697f, 
    -0.02771957f, -0.02809389f, -0.04479346f, 0.00230187f, 0.02381498f, -0.01649769f, -0.01746835f, -0.03436138f, 
    0.02443907f, 0.02642516f, -0.00958851f, 0.00606584f, -0.04424519f, -0.03161153f, 0.02154392f, 0.00787800f, 
    0.01963711f, -0.02389358f, -0.00359418f, -0.03900399f, -0.01590681f, -0.01729778f, 0.00760206f, 0.01681055f, 
    0.01678412f, -0.01471092f, 0.00664800f, 0.00504834f, 0.01453611f, 0.01473003f, -0.00610148f, -0.01933999f, 
    -0.02777617f, 0.01930263f, -0.03412623f, 0.02797726f, 0.01008330f, 0.01451879f, -0.01661356f, -0.03879680f, 
    0.00787744f, -0.02122957f, 0.02833263f, -0.03584885f, 0.02014829f, -0.03093654f, 0.00590919f, -0.03823378f, 
    -0.00983001f, -0.03051157f, -0.03900041f, -0.00684173f, -0.03580126f, 0.02788085f, -0.00542403f, -0.03192371f, 
    0.03059934f, 0.00787475f, -0.03740417f, -0.01157338f, -0.01677849f, 0.01929414f, -0.03075498f, 0.00560021f, 
    0.01722813f, 0.00280902f, 0.00825951f, -0.01097398f, -0.01128331f, -0.02038139f, -0.02664602f, -0.02533101f, 
    0.03117028f, -0.03117044f, -0.03303998f, 0.01594794f, 0.00797648f, -0.04141037f, 0.02592537f, -0.01632178f, 
    -0.01363179f, -0.02907136f, -0.03305293f, -0.03938453f, -0.03798630f, -0.00965911f, 0.01237271f, 0.00891480f, 
    -0.02311186f, 0.02539620f, 0.02479823f, -0.03956545f, -0.01581999f, -0.00157422f, -0.03923165f, -0.00286263f, 
    -0.03422967f, -0.03359009f, 0.01992233f, 0.00368094f, -0.00118382f, -0.01567511f, 0.01211108f, -0.02084577f, 
    0.00010981f, -0.00313838f, -0.03265188f, -0.04018455f, 0.01987799f, 0.02585690f, -0.03913429f, 0.01725961f, 
    0.00135860f, -0.01742463f, -0.01981329f, 0.02303950f, 0.01507514f, -0.02791491f, 0.00108425f, 0.02070942f, 
    0.02263735f, -0.01402724f, 0.01473318f, 0.00328010f, -0.02245191f, -0.00749332f, -0.00084783f, -0.03107205f, 
    0.00077372f, 0.01661157f, -0.02694569f, 0.00189289f, -0.01513902f, -0.02788731f, -0.02150595f, 0.01508817f, 
    0.01840377f, 0.03033397f, 0.02494487f, -0.02244273f, 0.01450751f, 0.00966485f, -0.02497735f, -0.03348800f, 
    -0.03048852f, -0.03502771f, 0.01607408f, -0.01843820f, -0.00695388f, 0.02939479f, 0.02055822f, 0.02757437f, 
    0.02972849f, -0.04537186f, -0.00632256f, -0.01777156f, -0.01275415f, 0.01943956f, -0.03534671f, 0.01936980f, 
    -0.02923645f, 0.02284044f, 0.02928255f, -0.01657847f, -0.02587015f, 0.01202740f, 0.00618158f, 0.01781001f, 
    0.01096031f, 0.00675078f, 0.01439534f, -0.00325950f, -0.01544136f, -0.02532396f, -0.00556799f, -0.01038596f, 
    -0.02626913f, -0.04518633f, -0.03199255f, -0.02492291f, 0.02278470f, 0.01156950f, -0.00209718f, -0.00285051f, 
    -0.01194211f, -0.02406317f, -0.02684021f, -0.03413437f, 0.02648898f, 0.00537560f, -0.04059989f, -0.03117002f, 
    -0.02665531f, -0.04296971f, -0.03297957f, 0.01914504f, -0.00533780f, -0.00165161f, -0.00350192f, -0.02802482f, 
    -0.01960166f, 0.01565197f, 0.02802720f, 0.02605440f, 0.00946134f, -0.03332213f, -0.03532596f, -0.03162185f, 
    0.00121693f, 0.02858456f, 0.00709660f, 0.01132472f, 0.00133453f, 0.01122107f, 0.02507667f, 0.01460640f, 
    0.02135518f, -0.02592535f, -0.01583496f, -0.02240727f, -0.02995179f, 0.02516188f, -0.01927895f, -0.01012487f, 
    0.00660278f, 0.00761638f, -0.00797703f, 0.00000516f, 0.00537271f, -0.04178220f, 0.02029379f, -0.00765751f, 
    -0.00903855f, -0.02701054f, -0.01790946f, -0.01860584f, -0.00658550f, 0.02180065f, 0.01679310f, -0.04121602f, 
    -0.02219052f, 0.01677873f, -0.00094592f, 0.00022092f, 0.02370344f, 0.02120204f, 0.00843553f, -0.01203286f, 
    0.01547896f, -0.03472675f, -0.01870137f, 0.01586663f, -0.04090222f, 0.01381746f, 0.01082818f, -0.02599991f, 
    -0.04229975f, -0.01272931f, 0.00518868f, -0.01289516f, -0.03241145f, -0.03439174f, 0.00061920f, -0.01043437f, 
    0.01700843f, 0.00721640f, -0.02249292f, 0.00481004f, -0.03679213f, -0.02945720f, 0.00919217f, 0.00499071f, 
    0.00425021f, 0.00988173f, -0.04331260f, 0.00156591f, 0.00191971f, -0.00410854f, -0.00796307f, 0.01247597f, 
    -0.00379512f, 0.02575249f, 0.00631997f, -0.02522407f, -0.01133564f, 0.02484539f, -0.02318859f, -0.01913499f, 
    0.02283606f, 0.02484525f, -0.00148514f, -0.01489424f, -0.01726309f, -0.01190279f, 0.01331722f, 0.02278607f, 
    -0.01216792f, 0.02768859f, -0.04193538f, -0.04297665f, 0.01409716f, -0.01874763f, -0.02424218f, -0.03512364f, 
    -0.04205440f, 0.01325023f, -0.02216371f, 0.01624355f, 0.02412452f, -0.03206493f, 0.02225091f, -0.02960048f, 
    0.00078990f, -0.00337760f, 0.01278323f, 0.03687624f, -0.03838025f, 0.00959738f, 0.02274527f, -0.04102583f, 
    0.01207307f, -0.01331898f, -0.01901333f, 0.03195706f, 0.00996667f, -0.02264868f, 0.02043649f, -0.03361892f, 
    0.01276411f, 0.00323146f, -0.00793133f, 0.01507666f, 0.02833817f, -0.01969926f, 0.00920127f, -0.00815135f, 
    -0.01573704f, -0.01026195f, -0.00927101f, 0.03625721f, 0.02383457f, -0.01850228f, -0.00003961f, -0.04525489f, 
    -0.03416011f, 0.00316570f, -0.01741551f, -0.01373222f, 0.01868347f, -0.01540119f, -0.00367439f, -0.04078906f, 
    0.00038956f, 0.02504759f, 0.00476865f, -0.00767530f, -0.02804113f, 0.02378681f, -0.00588305f, 0.00747324f, 
    0.02459542f, -0.03594151f, -0.01906950f, -0.00876433f, -0.01344236f, 0.01206847f, -0.03356467f, -0.00562121f, 
    -0.01882618f, 0.01264347f, -0.00907688f, 0.02690225f, 0.02387628f, -0.00925904f, -0.01060138f, 0.00439311f, 
    -0.00325718f, -0.02167431f, 0.01384739f, -0.03978337f, -0.00861145f, -0.03951992f, 0.01157133f, 0.03495190f, 
    0.01604878f, 0.00341195f, 0.00724594f, -0.02348266f, -0.03459382f, -0.01601189f, -0.03619092f, 0.01227382f, 
    0.02222369f, -0.04208026f, -0.02673021f, -0.02285986f, -0.01818499f, 0.00773159f, 0.01037799f, -0.01483603f, 
    -0.00659567f, -0.02447000f, -0.03711713f, -0.04211527f, 0.04280071f, -0.03581702f, 0.00615924f, 0.00756114f, 
    -0.00782568f, -0.02130816f, -0.01643772f, 0.02274134f, -0.01740962f, 0.00098667f, -0.02785566f, 0.00244525f, 
    0.01784825f, -0.01208256f, -0.00450272f, -0.03827876f, 0.00348581f, 0.00652138f, -0.01494564f, -0.00482628f, 
    -0.02707512f, -0.01805059f, -0.01292369f, 0.03016254f, -0.00163144f, -0.00193892f, 0.03499413f, 0.00120107f, 
    0.01001947f, -0.02260496f, 0.00541180f, -0.03973899f, -0.00653129f, 0.00675938f, -0.01459302f, 0.01965813f, 
    -0.00970299f, -0.02263830f, 0.02475681f, -0.00307616f, -0.02521773f, -0.02299322f, -0.00350205f, -0.02437182f, 
    -0.01418167f, 0.00277292f, -0.01582247f, 0.00907809f, 0.00619531f, -0.03885454f, -0.03622470f, -0.02577134f, 
    0.00138786f, -0.02852673f, 0.00771945f, -0.02053719f, -0.00918285f, -0.03828742f, -0.04211179f, -0.00557501f, 
    0.00756546f, 0.00333413f, -0.01907101f, -0.01147128f, -0.02401719f, 0.03010654f, 0.02227151f, -0.01881854f, 
    -0.02002820f, -0.00452319f, -0.03880984f, 0.00081546f, -0.00199731f, -0.02378895f, 0.00874038f, 0.00619637f, 
    -0.00240936f, -0.01574827f, -0.03059577f, 0.02332744f, 0.00885452f, -0.03396255f, -0.00489661f, -0.02144450f, 
    -0.02973349f, -0.00807544f, -0.02120652f, -0.04482495f, 0.01754634f, 0.01361651f, -0.02841325f, -0.01893587f, 
    -0.03120622f, 0.00184154f, -0.01287702f, 0.00356356f, 0.02369278f, 0.00011356f, 0.00956340f, -0.02193953f, 
    0.01146310f, 0.01478602f, 0.02492699f, 0.01519245f, -0.02590308f, -0.00452575f, 0.01275445f, -0.02835132f, 
    0.01339179f, -0.01672174f, -0.03341140f, -0.02422660f, -0.03806996f, -0.03127923f, -0.01897457f, -0.01230942f, 
    -0.01025412f, -0.03188954f, 0.00479000f, 0.00146446f, 0.01406564f, -0.00123308f, 0.01756831f, 0.00583844f, 
    0.01253933f, -0.01946670f, -0.03640522f, -0.03772632f, -0.03378139f, -0.02876496f, -0.01686468f, -0.00148692f, 
    -0.03095779f, 0.00886171f, 0.00616439f, -0.02033528f, 0.02175778f, -0.03912892f, -0.01298301f, 0.02281596f, 
    -0.01518548f, -0.03615208f, -0.00631929f, 0.01363741f, -0.03295624f, 0.01118298f, 0.03439270f, 0.02556021f, 
    -0.01398038f, -0.01849210f, -0.01781676f, -0.00691104f, 0.02205452f, 0.02400380f, 0.02567786f, -0.01547974f, 
    -0.04402219f, -0.03743956f, 0.02796724f, -0.02192106f, 0.01381697f, -0.03038735f, -0.02566327f, -0.00057194f, 
    0.02728780f, -0.02603327f, 0.02866899f, 0.02868857f, -0.01770156f, -0.00083313f, -0.01851555f, 0.01207797f, 
    0.01347083f, 0.01982473f, -0.02920299f, 0.00022403f, -0.00907825f, -0.01737193f, -0.00442503f, 0.02337949f, 
    -0.00235400f, -0.02257641f, 0.02093939f, 0.02788420f, -0.03015152f, 0.01203665f, 0.01924667f, 0.00603766f, 
    -0.03443183f, 0.00292231f, -0.03349487f, -0.02315865f, 0.01218015f, -0.03440978f, -0.01859828f, -0.01085510f, 
    0.00878308f, 0.01895488f, -0.02577947f, -0.04311490f, -0.03032595f, -0.00872131f, 0.00208701f, -0.00004669f, 
    0.00628388f, -0.01377622f, 0.03078660f, -0.00687488f, -0.00249246f, -0.02350911f, -0.02427718f, -0.00721226f, 
    0.01282741f, 0.01139499f, -0.01259297f, -0.02446680f, -0.01292302f, 0.00695637f, -0.03449091f, -0.02969341f, 
    0.02292224f, -0.01094453f, -0.03749372f, 0.00358791f, -0.04427435f, -0.01812225f, 0.02734505f, -0.03779506f, 
    -0.01086846f, -0.03557127f, -0.02483850f, 0.03262972f, -0.02367255f, -0.00016362f, -0.01799914f, 0.00441889f, 
    -0.00756847f, 0.03737925f, -0.03404771f, -0.03958784f, 0.02527209f, 0.02050975f, -0.02619721f, -0.00766823f, 
    -0.01944473f, -0.00466163f, -0.03136722f, 0.02613715f, 0.01085489f, 0.00546227f, 0.00935817f, -0.03105004f, 
    0.00160030f, 0.02236940f, -0.02409822f, -0.00191710f, -0.00095142f, 0.00298738f, -0.04170943f, -0.02594456f, 
    -0.01284430f, 0.00894597f, -0.02592556f, 0.02652841f, -0.03450124f, 0.02099636f, 0.01640725f, 0.02029247f, 
    -0.02846437f, 0.01164076f, 0.00631380f, -0.03122410f, 0.02336273f, -0.02838954f, 0.01884425f, 0.01488161f, 
    0.01551919f, 0.01069644f, 0.02787727f, -0.03037030f, -0.01729712f, 0.03413282f, -0.02101735f, 0.02634187f, 
    -0.02514432f, 0.00679026f, -0.02443355f, 0.00564177f, -0.00755068f, 0.02441066f, -0.02279644f, -0.00725998f, 
    0.02617860f, -0.03549853f, -0.00434125f, 0.01582115f, -0.00723634f, -0.03592530f, -0.01890281f, -0.01480338f, 
    0.03261417f, -0.01745926f, 0.00651748f, 0.04024046f, -0.01771201f, -0.04056885f, -0.01380655f, 0.00288747f, 
    0.01457596f, -0.02318673f, -0.00831094f, -0.04766520f, -0.04005536f, 0.02411053f, -0.00566045f, -0.01856215f, 
    -0.00891296f, 0.01197084f, 0.02663641f, 0.02685788f, 0.02842771f, -0.03946077f, 0.01062429f, -0.03277929f, 
    0.00451900f, -0.02446216f, -0.01477807f, 0.01337900f, -0.00687590f, 0.02402844f, 0.01079519f, 0.01169095f, 
    0.00417283f, -0.01839682f, -0.03469807f, -0.02716545f, 0.01289270f, 0.02334818f, 0.01078059f, -0.01073715f, 
    0.01549215f, 0.00253213f, 0.00718284f, 0.02980040f, 0.00200722f, -0.02303599f, 0.00481418f, 0.00211113f, 
    -0.03533359f, -0.02645632f, -0.00922283f, -0.04169414f, -0.01807837f, -0.00490793f, -0.01290495f, 0.00768381f, 
    -0.01661343f, -0.01126858f, -0.00849283f, 0.00125461f, 0.02587289f, 0.00616280f, 0.01735292f, -0.00639644f, 
    0.00981899f, -0.04015602f, -0.00817834f, 0.01512218f, -0.01204813f, -0.02357825f, 0.02922773f, -0.03077261f, 
    -0.02862183f, -0.03183699f, -0.02471741f, -0.01094597f, -0.01226170f, -0.03459854f, -0.02963004f, 0.00734994f, 
    -0.02138984f, -0.03344239f, -0.03230694f, 0.00385018f, -0.02987945f, -0.01095314f, 0.01976041f, -0.02562723f, 
    0.01931815f, -0.00039695f, -0.01191927f, -0.00368842f, -0.01194575f, -0.00907357f, 0.03099238f, -0.03266330f, 
    -0.01478458f, -0.03025395f, -0.01344028f, -0.00569891f, -0.01618156f, 0.02258485f, 0.03085546f, 0.02932227f, 
    0.00837140f, -0.02131648f, -0.03372200f, -0.01779670f, -0.01053645f, 0.01030748f, 0.01635524f, 0.02116444f, 
    0.00759842f, 0.01144470f, -0.03468978f, 0.00700689f, 0.01674165f, -0.02933879f, -0.01181254f, -0.01111586f, 
    -0.04547312f, -0.02051009f, -0.00513625f, 0.01061176f, 0.00155358f, -0.03037555f, -0.00365992f, 0.01371890f, 
    0.03245881f, -0.02735965f, 0.01770526f, -0.02528461f, -0.00492747f, 0.01771096f, -0.02454026f, -0.01154071f, 
    -0.02321911f, 0.00050299f, -0.01916218f, -0.03984699f, 0.00969033f, 0.01791450f, -0.03456264f, 0.01049535f, 
    0.01766835f, -0.00128736f, 0.02098342f, -0.01772636f, -0.01750902f, 0.00123485f, 0.02092526f, -0.04092412f, 
    -0.03335704f, 0.02868665f, 0.01679656f, -0.00705499f, -0.02444353f, -0.01006575f, -0.01938787f, -0.00542746f, 
    -0.00123445f, -0.01901821f, -0.00346904f, 0.00861863f, 0.00187706f, 0.02493431f, -0.00934179f, -0.01664203f, 
    -0.00646750f, -0.02607170f, -0.01035812f, -0.00442552f, 0.00633112f, -0.03301408f, -0.03019381f, -0.01323054f, 
    -0.00351629f, 0.01448409f, 0.00943322f, -0.00918032f, -0.03461799f, -0.00446062f, 0.00785145f, 0.00993087f, 
    0.00280161f, 0.01139437f, 0.03073808f, 0.00938847f, -0.03833807f, -0.02637514f, 0.01369788f, 0.02676600f, 
    -0.02823385f, 0.00023293f, -0.00010341f, -0.01702453f, 0.00655423f, 0.00314855f, -0.01935431f, -0.03325135f, 
    -0.00306190f, 0.00169236f, -0.03935686f, 0.00054913f, 0.00955718f, -0.02014014f, -0.03796841f, -0.00893104f, 
    -0.01692328f, 0.02760153f, 0.02113651f, 0.00122119f, 0.02222354f, -0.01308129f, 0.00257158f, -0.00793651f, 
    -0.01517329f, -0.02494732f, 0.02797968f, 0.00718600f, 0.02829250f, 0.00281305f, 0.00447303f, -0.00499141f, 
    0.01364608f, -0.00094926f, 0.03007359f, 0.02581572f, -0.01716648f, -0.02735425f, -0.01101854f, 0.02061234f, 
    -0.01302860f, -0.03246549f, 0.01428585f, -0.00900054f, 0.02046928f, -0.00603664f, -0.00804961f, -0.01750984f, 
    -0.00548652f, -0.02609679f, 0.03453405f, -0.03812166f, -0.04436506f, 0.04093205f, -0.03199607f, -0.03315900f, 
    0.03311634f, -0.02865452f, -0.00005331f, -0.00422445f, -0.03189116f, -0.02175370f, -0.00711162f, -0.03400083f, 
    0.02486284f, 0.02764074f, 0.00023126f, -0.00463708f, -0.03064501f, 0.00633718f, 0.03482812f, -0.01494982f, 
    0.02459065f, 0.00626465f, -0.01337695f, -0.00317733f, -0.03392097f, -0.01511116f, 0.00088193f, -0.01321277f, 
    -0.01689501f, 0.00341983f, 0.01431156f, -0.00345237f, -0.04196845f, 0.03082202f, 0.01320518f, 0.01565855f, 
    -0.01127471f, -0.01402124f, 0.02366557f, -0.00011891f, -0.01311259f, 0.02077170f, -0.01902412f, 0.03161878f, 
    0.02099125f, -0.02795814f, 0.02522310f, -0.01566329f, -0.01040338f, -0.02062455f, 0.02056570f, -0.04066577f, 
    -0.01775131f, -0.02613538f, 0.03101752f, 0.02549211f, -0.04060278f, 0.01765748f, 0.02649172f, -0.02210721f, 
    -0.03684716f, 0.00412048f, -0.00773098f, 0.00904901f, 0.02229639f, 0.01048450f, 0.01547526f, -0.03570973f, 
    -0.02233610f, -0.01798080f, 0.01036959f, -0.01092266f, -0.00046793f, 0.02000584f, -0.02994856f, -0.02641424f, 
    0.02976693f, -0.00555571f, -0.03677537f, 0.01819633f, -0.01973664f, -0.03226032f, 0.01318408f, 0.02704337f, 
    0.02163599f, 0.00336580f, 0.02908537f, -0.02420089f, -0.01998682f, 0.03134124f, -0.02838116f, -0.02943313f, 
    0.03408713f, 0.00175348f, 0.02188966f, 0.01826928f, 0.01084261f, -0.02304719f, -0.02553148f, 0.01911866f, 
    -0.02710195f, 0.02248327f, -0.00823892f, -0.03115727f, -0.01503803f, -0.01906887f, -0.02393710f, 0.00165377f, 
    -0.00709940f, 0.02939846f, -0.01235283f, 0.02928283f, -0.00621128f, 0.00935731f, -0.01933678f, 0.01231931f, 
    0.02710833f, -0.03343812f, 0.03144366f, 0.02466540f, -0.02775908f, -0.02053523f, -0.03760989f, -0.03047540f, 
    -0.00313945f, -0.00065085f, 0.03075195f, -0.01695876f, -0.02617896f, -0.03982675f, -0.02771612f, 0.02205315f, 
    0.02592079f, 0.02483473f, 0.01867791f, -0.01165052f, 0.01021461f, -0.02155087f, 0.03229795f, -0.01160107f, 
    -0.03395417f, 0.00055918f, 0.01008798f, -0.03634621f, 0.01564400f, 0.02331984f, -0.01769049f, -0.01481424f, 
    -0.03110269f, 0.02420596f, 0.02369375f, 0.00310182f, -0.03309267f, 0.02396832f, -0.02857821f, -0.03600869f, 
    -0.00086433f, -0.01054084f, 0.01670075f, -0.02255300f, -0.03683729f, -0.00422979f, 0.02434824f, -0.00765331f, 
    -0.02490697f, -0.00245855f, 0.00721883f, -0.02143348f, -0.02577758f, -0.03749051f, -0.00383256f, 0.03078779f, 
    0.02673152f, -0.02789120f, 0.02197550f, 0.00945906f, -0.03678065f, 0.02398260f, -0.02791363f, -0.00503629f, 
    -0.03669343f, 0.03128600f, -0.00682883f, 0.03308267f, -0.02952516f, 0.01073493f, -0.00059690f, 0.03729475f, 
    0.02524175f, 0.00194048f, -0.00078319f, 0.01188836f, -0.02179430f, 0.01515208f, 0.02317696f, 0.00857800f, 
    0.00316319f, -0.00656011f, -0.00316685f, -0.02427142f, -0.03129461f, -0.00014040f, 0.00392058f, -0.01607694f, 
    0.02560698f, 0.03221111f, -0.01585679f, 0.01188136f, -0.04346243f, 0.00925544f, -0.02246458f, 0.01496094f, 
    0.02152463f, -0.02479375f, -0.02740778f, -0.01860332f, -0.02216033f, 0.01751584f, -0.00455884f, -0.00195604f, 
    0.01498074f, 0.00429815f, -0.01967099f, -0.00892326f, 0.03448445f, -0.01659466f, 0.00241327f, -0.00748923f, 
    -0.03674978f, -0.02797026f, 0.01902375f, -0.02271825f, -0.01229787f, -0.00581543f, -0.00246703f, -0.01488756f, 
    -0.01107795f, -0.01360260f, -0.03068044f, -0.02448320f, 0.00270970f, 0.01604349f, -0.01376336f, 0.01526458f, 
    0.02650765f, -0.00169810f, 0.00373444f, 0.03064187f, -0.01038583f, -0.02556498f, -0.00681452f, 0.01376706f, 
    0.02175360f, -0.00661739f, 0.01569973f, 0.01473536f, -0.00863116f, 0.02275808f, 0.03008489f, -0.00642751f, 
    -0.02658732f, 0.02195171f, -0.02009330f, 0.00114815f, -0.03447249f, -0.02848749f, -0.00410122f, -0.01169530f, 
    0.01272854f, -0.03759342f, 0.01148397f, 0.03541286f, 0.01489183f, 0.01302705f, -0.02046295f, 0.02838411f, 
    0.02652290f, -0.03909534f, -0.01591901f, 0.00218318f, -0.02136891f, 0.02720480f, -0.01090507f, -0.01614249f, 
    -0.02920244f, -0.02711168f, 0.00901796f, 0.00455912f, 0.00811446f, -0.01961037f, 0.01948678f, 0.02179633f, 
    -0.02228200f, -0.00625260f, 0.01467801f, -0.04060623f, 0.02076987f, 0.01333691f, 0.02596436f, 0.02361463f, 
    -0.02017465f, -0.01820018f, -0.02892404f, 0.00104714f, -0.02888411f, 0.01846842f, -0.00548795f, 0.00967797f, 
    -0.01647989f, 0.01591173f, 0.02515376f, -0.02937340f, -0.03596578f, -0.02238118f, -0.03234902f, 0.02339639f, 
    0.01360808f, -0.01459406f, 0.00069558f, 0.01342250f, -0.00704793f, -0.03634555f, 0.02718039f, 0.00838772f, 
    -0.02738175f, -0.01077853f, -0.00925761f, -0.02350814f, 0.02954045f, -0.02693090f, -0.01313016f, -0.03122631f, 
    0.02989925f, 0.03019659f, 0.01358247f, -0.02911533f, -0.01679835f, -0.01102169f, 0.01591651f, 0.01437785f, 
    -0.00369532f, -0.03659691f, -0.01480033f, -0.04097059f, -0.03478493f, 0.01951224f, -0.03743449f, -0.01545757f, 
    0.01353511f, 0.02812871f, -0.03112098f, 0.01341585f, -0.01101012f, 0.02095997f, 0.03117153f, 0.02887248f, 
    -0.02877642f, -0.03039494f, 0.00291101f, -0.00159329f, -0.00871483f, 0.02892315f, -0.00353725f, -0.04120632f, 
    -0.01519233f, 0.01540011f, 0.02236333f, 0.03375205f, -0.02180192f, -0.02575177f, -0.03942836f, 0.03935824f, 
    -0.02081543f, -0.00395081f, -0.03951533f, 0.02232072f, 0.00022369f, 0.00815490f, 0.01178782f, 0.01664244f, 
    -0.00335534f, -0.01569355f, 0.01113251f, -0.02866438f, -0.00941725f, -0.00644033f, 0.01530263f, 0.02194738f, 
    -0.01609609f, 0.00584181f, -0.03327339f, 0.02582040f, -0.00860979f, 0.00837698f, 0.00181711f, -0.00811393f, 
    -0.03682029f, 0.00782646f, -0.01057055f, -0.03036254f, 0.02511930f, -0.01604457f, -0.01382239f, -0.03608101f, 
    0.00434666f, -0.02512792f, 0.02908618f, 0.01665204f, 0.02769271f, -0.01032728f, -0.03921695f, 0.02825803f, 
    -0.01325904f, -0.02633138f, 0.03191542f, 0.02070681f, -0.00920188f, 0.00515208f, -0.03259008f, -0.02576565f, 
    0.02413618f, -0.03620050f, -0.02410879f, 0.00076891f, -0.00320038f, -0.01617520f, -0.02176915f, -0.03231904f, 
    -0.00841556f, 0.00266697f, -0.00362967f, -0.01318168f, -0.01620186f, 0.02731619f, -0.00624533f, 0.01441700f, 
    0.00249917f, -0.00808837f, 0.01252685f, 0.03266919f, 0.00927202f, -0.04044164f, -0.01270213f, -0.03793835f, 
    0.00138199f, -0.03466172f, -0.01910955f, 0.00218309f, -0.02416047f, 0.00162350f, 0.00063864f, -0.03203366f, 
    0.02670868f, -0.00297432f, -0.02322197f, -0.03106514f, -0.01154385f, -0.03657616f, -0.01337828f, -0.00820014f, 
    -0.01503729f, -0.01947770f, -0.02542866f, 0.02336167f, -0.00140618f, 0.00193771f, 0.02991442f, 0.01910654f, 
    0.02366267f, -0.01077223f, -0.01316920f, -0.03275556f, -0.00479356f, -0.01895855f, -0.01989039f, 0.00913357f, 
    0.00850829f, 0.02008522f, -0.00820818f, 0.01703765f, 0.02457523f, -0.03935898f, 0.02045898f, -0.03504870f, 
    -0.03296937f, -0.01282670f, -0.00942560f, 0.01052024f, -0.02027899f, -0.00853466f, -0.00172383f, 0.02157291f, 
    -0.01381155f, -0.03800641f, 0.00826107f, 0.03230574f, 0.01588341f, -0.02190722f, -0.01820911f, 0.01519824f, 
    0.00509608f, 0.01199602f, 0.02346676f, 0.02231791f, -0.02134843f, -0.00682037f, -0.00306306f, 0.00861247f, 
    0.02811229f, -0.03103150f, -0.01697102f, 0.01810460f, 0.00619671f, -0.01111674f, 0.01876056f, -0.04369333f, 
    -0.00247302f, -0.00072866f, 0.00798939f, -0.00722337f, 0.02110540f, -0.03506389f, 0.00052459f, 0.00592236f, 
    0.01877374f, 0.00793310f, 0.01316508f, 0.00239488f, -0.04021860f, -0.00328615f, -0.04084795f, -0.01970318f, 
    -0.03790724f, 0.00573186f, 0.02750181f, -0.01101460f, 0.00318976f, 0.00327750f, 0.02848385f, -0.00340817f, 
    0.02651965f, -0.01149831f, -0.00984947f, 0.01527278f, -0.03671043f, 0.00086094f, -0.02797309f, 0.02384772f, 
    0.02840192f, -0.00182474f, 0.01888995f, 0.01629127f, 0.00962685f, -0.00008669f, 0.02123205f, -0.01604606f, 
    0.02957902f, 0.01361135f, 0.00695260f, 0.02250966f, 0.01208105f, 0.00098793f, 0.01394330f, 0.01722432f, 
    -0.02885327f, 0.02410724f, 0.00452857f, 0.00143105f, 0.00266558f, -0.02524968f, -0.03446638f, 0.01628293f, 
    -0.02140637f, -0.02812996f, 0.01554446f, -0.03234486f, -0.03709419f, 0.02094299f, -0.03850664f, -0.01131745f, 
    -0.01298265f, -0.03393721f, 0.01050619f, 0.01001025f, 0.01807573f, -0.03100221f, -0.04060285f, -0.03817957f, 
    -0.04320385f, 0.00718750f, -0.02380122f, -0.00292330f, -0.00103835f, 0.00391889f, -0.04018081f, -0.01707307f, 
    0.00405162f, 0.00367908f, 0.02719960f, -0.02024355f, -0.00676858f, 0.02900466f, -0.03086957f, -0.02835053f, 
    -0.03013542f, 0.01846302f, 0.02151822f, 0.01102994f, 0.02384716f, 0.02465043f, 0.01804237f, -0.00489493f, 
    -0.02653301f, -0.03567421f, 0.01781658f, 0.03582291f, -0.00172028f, 0.00387707f, 0.02324872f, -0.00938018f, 
    -0.01929710f, 0.02593188f, -0.03632761f, 0.01258409f, -0.03218334f, -0.00666830f, -0.03882184f, 0.00530220f, 
    -0.02378155f, -0.01586794f, -0.03665900f, -0.04067662f, -0.02411105f, 0.00514046f, -0.02172950f, 0.00102820f, 
    0.02197486f, -0.00080893f, -0.02439620f, 0.02086249f, -0.03245049f, 0.00066281f, 0.01075138f, 0.02196573f, 
    -0.03547684f, -0.00467005f, 0.00808507f, 0.02677252f, -0.02913933f, 0.00902200f, 0.00697589f, 0.01710222f, 
    0.02409190f, -0.03719743f, -0.00590860f, 0.01554835f, -0.03946257f, -0.03378302f, 0.01754506f, 0.01593888f, 
    0.02815018f, -0.04369827f, -0.03807765f, -0.04357272f, -0.02790350f, 0.00462996f, -0.00578585f, -0.04159137f, 
    -0.03477939f, -0.01436198f, 0.02076788f, 0.02508641f, 0.02480228f, -0.00308613f, -0.04341801f, 0.02250461f, 
    -0.01031825f, -0.01009560f, -0.01112385f, 0.00138890f, -0.03843283f, -0.00123876f, -0.01469934f, -0.03169283f, 
    -0.01212965f, -0.04231332f, -0.02639098f, 0.00696301f, 0.02886336f, -0.03907001f, -0.00027433f, -0.01163298f, 
    0.01224596f, -0.01331752f, -0.03614265f, -0.03660353f, 0.00466567f, -0.02002668f, -0.00115102f, 0.01796972f, 
    0.02465188f, -0.00800051f, 0.02445543f, 0.03175633f, -0.00632914f, 0.01890904f, -0.00697736f, -0.00813730f, 
    -0.04267484f, 0.00592326f, 0.01707938f, -0.00645962f, -0.01426830f, -0.00142832f, -0.01208577f, 0.01419457f, 
    -0.04098815f, 0.01365848f, 0.00573752f, 0.03035046f, 0.01086265f, -0.02014254f, -0.03703102f, 0.01011303f, 
    -0.01134110f, -0.01657053f, -0.02356847f, 0.03355668f, 0.02388022f, 0.00056639f, 0.02768739f, 0.00743886f, 
    -0.00387393f, -0.01693524f, -0.02062896f, 0.00184136f, 0.02257809f, 0.02115233f, -0.03763808f, -0.03636354f, 
    -0.02377599f, -0.03717208f, -0.03701400f, 0.00640502f, -0.00260634f, -0.02324767f, -0.00227593f, -0.02426578f, 
    0.01907595f, -0.01564934f, 0.02917472f, -0.02706277f, -0.01297114f, 0.02397332f, 0.02454009f, 0.00937690f, 
    -0.02195077f, 0.02197536f, -0.03539148f, -0.01101256f, -0.03352639f, -0.02742953f, -0.00189233f, 0.02724511f, 
    -0.00717866f, 0.01803129f, 0.00579902f, -0.03502683f, -0.03780872f, 0.02144176f, 0.01467732f, -0.01164235f, 
    0.01373351f, 0.00645511f, 0.01434950f, 0.01610128f, -0.02580256f, -0.04270710f, -0.02890261f, -0.01162423f, 
    0.02877732f, -0.01519202f, 0.02637114f, 0.00473985f, 0.00539084f, -0.00275318f, -0.02808337f, 0.02237460f, 
    -0.03405524f, 0.02226698f, 0.02803311f, -0.01822869f, -0.03900092f, 0.01494271f, 0.01562449f, -0.00364806f, 
    0.02336565f, -0.04069855f, -0.04429568f, -0.01380734f, -0.02184051f, -0.00146421f, 0.02131696f, 0.00652604f, 
    0.01056770f, 0.03565364f, -0.03384287f, -0.01398604f, -0.02006874f, -0.03792905f, -0.00602473f, -0.02357063f, 
    -0.01700749f, 0.01745407f, -0.00440353f, -0.00437997f, -0.03330480f, 0.01639786f, 0.00057394f, 0.00986838f, 
    0.00892628f, -0.00768630f, -0.03414299f, -0.00010321f, 0.02271473f, 0.02747631f, -0.00023243f, -0.01540389f, 
    -0.00083608f, 0.03043815f, -0.00093638f, -0.02274430f, -0.00903707f, 0.02255717f, -0.02995328f, -0.03116412f, 
    0.02882862f, -0.01141370f, 0.01266384f, -0.04393082f, -0.01793126f, -0.04352628f, -0.02357716f, -0.00755126f, 
    -0.04148135f, 0.00447643f, 0.00934715f, -0.02308225f, 0.00729516f, -0.02129572f, 0.02429561f, -0.02545358f, 
    -0.01081989f, 0.00979726f, 0.02315260f, 0.00386890f, -0.03059070f, 0.00497040f, 0.01813042f, -0.01160692f, 
    -0.01396951f, 0.02129958f, 0.02153373f, -0.02883719f, -0.03969663f, -0.01738722f, -0.03109840f, -0.03916216f, 
    0.00867836f, 0.02079568f, -0.00396063f, -0.03349701f, -0.01809354f, -0.02130184f, 0.00808026f, -0.00749560f, 
    -0.01491978f, 0.01188672f, -0.01612815f, 0.00122367f, -0.00721390f, -0.01570905f, -0.01732866f, -0.02235738f, 
    -0.02319122f, -0.00852097f, 0.01274739f, 0.02609871f, 0.02110413f, -0.03914405f, -0.01574253f, -0.01260294f, 
    0.00862129f, -0.03311669f, 0.01309924f, 0.01974948f, -0.04118771f, 0.01918585f, -0.00409085f, 0.00536750f, 
    0.00415407f, -0.00338521f, 0.01446757f, 0.02976789f, -0.00744249f, -0.03787803f, 0.01554625f, 0.02079307f, 
    0.00187785f, 0.00594951f, -0.00077506f, -0.01137206f, -0.00074758f, 0.00291967f, -0.01031418f, -0.02925087f, 
    -0.03249967f, -0.03637416f, -0.04535970f, -0.00744749f, -0.01365869f, 0.01332233f, -0.02018271f, -0.04221725f, 
    0.02134499f, -0.03477364f, 0.00996557f, -0.00127602f, -0.01178620f, -0.02624089f, -0.03597788f, -0.04152744f, 
    0.00645769f, 0.00961505f, 0.00318255f, 0.00393247f, 0.01333095f, -0.02871898f, 0.01261519f, 0.02829056f, 
    -0.03998705f, 0.00210893f, -0.03925182f, -0.03339955f, -0.02288143f, -0.02220939f, 0.01133630f, 0.00431583f, 
    -0.03027101f, 0.01782831f, -0.04092158f, -0.02150080f, -0.01827548f, -0.00809690f, -0.02504113f, -0.00269700f, 
    -0.04359767f, -0.03176964f, 0.00856623f, -0.00548923f, -0.04041959f, -0.03799527f, 0.00869077f, 0.01762229f, 
    0.00064624f, -0.02228505f, -0.03893798f, -0.02845477f, -0.02032330f, -0.03663473f, 0.01054573f, -0.02099490f, 
    -0.01453653f, 0.00462622f, -0.02610987f, -0.02815564f, 0.02673336f, -0.03645507f, 0.00275334f, -0.00579888f, 
    -0.00768243f, 0.02533572f, -0.00959424f, -0.02444471f, 0.00189723f, -0.01155324f, -0.01901294f, -0.02056395f, 
    0.02310423f, -0.00462516f, 0.00717871f, 0.01775393f, -0.01206321f, -0.02808944f, 0.00563763f, -0.01058818f, 
    -0.01801929f, 0.02600987f, 0.00976871f, -0.02688934f, -0.04449837f, 0.01492672f, -0.01490307f, -0.04187204f, 
    -0.00786318f, -0.03600064f, -0.03236300f, 0.00977723f, 0.02688575f, 0.00120651f, -0.04224728f, 0.00864088f, 
    0.02514677f, -0.00034666f, -0.01654216f, 0.00593358f, -0.01019837f, -0.00632576f, 0.02738725f, 0.01680024f, 
    0.02958691f, -0.03998582f, -0.04177122f, 0.01233509f, 0.01371542f, -0.01199824f, 0.01695274f, 0.00611390f, 
    -0.03198694f, 0.02100931f, -0.00225419f, -0.03740180f, -0.01985664f, 0.00346883f, -0.00379330f, 0.02403500f, 
    0.01841820f, -0.03199591f, 0.00389163f, 0.02495013f, -0.00749619f, -0.03172317f, -0.01150809f, -0.01481763f, 
    0.02194658f, -0.02153368f, -0.03074027f, -0.03438091f, -0.00538778f, -0.00297796f, -0.02445554f, -0.02397526f, 
    -0.03872455f, -0.01516676f, 0.00502340f, -0.01131976f, -0.02131128f, 0.00354589f, -0.02396004f, -0.03262388f, 
    0.01541264f, -0.01805899f, -0.02474856f, -0.02455010f, 0.01219864f, 0.01918010f, 0.02422407f, -0.03359574f, 
    -0.03691281f, -0.00905251f, -0.01642173f, -0.02138860f, -0.03076552f, 0.00875293f, -0.01386669f, -0.02383474f, 
    -0.03073487f, 0.00151677f, -0.02244463f, 0.00266567f, -0.02420723f, 0.01343592f, -0.02721310f, 0.02644037f, 
    -0.03322354f, 0.01340427f, -0.02716633f, -0.04248064f, -0.02587208f, -0.02509411f, -0.01273103f, 0.01620291f, 
    -0.00240039f, -0.00263184f, -0.01784320f, -0.02841108f, -0.02459520f, -0.03270977f, 0.00744729f, 0.02967542f, 
    0.01976112f, -0.00726387f, -0.00878540f, 0.00978581f, 0.00753282f, -0.03531051f, -0.04355873f, -0.01755335f, 
    0.03218333f, 0.02524148f, -0.04007623f, -0.01665283f, -0.02289428f, 0.02504809f, 0.01416340f, 0.00208766f, 
    0.01116618f, 0.03016894f, 0.00386069f, 0.00874665f, 0.01742107f, 0.00323278f, -0.02144421f, -0.03781595f, 
    -0.02060539f, 0.02093271f, 0.01501740f, -0.02599702f, -0.00939960f, -0.02107927f, -0.00833833f, 0.01404183f, 
    0.02684894f, -0.01106334f, 0.01468390f, -0.02154300f, -0.00317097f, -0.03639245f, 0.00988050f, -0.00445618f, 
    0.02718367f, 0.02008469f, -0.02924159f, 0.01628038f, 0.01195734f, 0.01225743f, -0.02157858f, 0.00276579f, 
    -0.01176410f, -0.03786293f, -0.02808737f, 0.01107323f, -0.02565881f, 0.02514079f, 0.01897204f, -0.02869519f, 
    -0.01391400f, -0.02052683f, -0.01711887f, 0.02902918f, 0.00445741f, -0.03969429f, -0.01602876f, -0.01982478f, 
    0.03044204f, -0.00150641f, 0.01335243f, -0.02615638f, 0.02596287f, 0.00711162f, -0.03048488f, -0.01047710f, 
    -0.04559632f, -0.02615389f, 0.00942589f, 0.01694729f, 0.01545353f, 0.01650597f, -0.03728851f, -0.01696770f, 
    -0.00807367f, -0.01887296f, -0.00081503f, -0.02794106f, 0.02138536f, 0.02079082f, -0.02967380f, -0.02185933f, 
    0.00515295f, -0.00615919f, 0.01090451f, 0.01544187f, -0.03536537f, -0.03899371f, 0.01336698f, -0.02238337f, 
    -0.01596642f, -0.04097212f, 0.00492812f, -0.02905692f, -0.03388877f, -0.01260611f, -0.01339129f, 0.00521212f, 
    -0.02111623f, -0.02883782f, -0.01273480f, -0.03144692f, -0.01729154f, 0.02823830f, -0.00791866f, 0.01466710f, 
    0.01013674f, 0.00348508f, 0.00345626f, -0.02142755f, 0.02296290f, 0.00094664f, -0.02908333f, 0.00567674f, 
    -0.01972733f, 0.01350462f, 0.00700360f, -0.03667250f, -0.02458268f, -0.00322235f, -0.03796985f, 0.01078145f, 
    -0.02626996f, 0.00374987f, 0.00604738f, 0.00478571f, 0.01954670f, 0.02481155f, 0.02069970f, 0.00096205f, 
    0.00120608f, -0.03243981f, -0.00915716f, -0.03804696f, -0.00732331f, 0.00983981f, 0.02010041f, -0.01271687f, 
    -0.01512690f, -0.00419951f, 0.03160482f, -0.02481545f, 0.00631422f, -0.00201357f, -0.02190678f, 0.00559296f, 
    -0.03951935f, -0.01741687f, -0.00634580f, -0.03960542f, -0.00227795f, 0.02390726f, -0.02725315f, -0.02691525f, 
    0.02517998f, 0.02033357f, 0.01180880f, 0.01115359f, -0.03577711f, 0.00130590f, -0.00433309f, 0.00808534f, 
    -0.11129571f, -0.02374303f, 0.06135506f, -0.15072882f, 0.06747042f, 0.09518530f, 0.00627431f, -0.06814595f, 
    0.05025415f, 0.04944462f, -0.07281683f, 0.08122303f, 0.09478104f, 0.30830231f, 0.27047619f, 0.14128716f, 
    0.02681345f, 0.10174827f, 0.06349937f, -0.05170653f, 0.16742544f, 0.03641942f, 0.07786217f, 0.13290779f, 
    -0.08103108f, 0.23700121f, 0.28867316f, 0.05407014f, -0.13489862f, -0.00634960f, 0.05422833f, -0.06583589f, 
    0.01088201f, -0.15221317f, 0.03788694f, 0.11061289f, 0.02418668f, -0.01192060f, -0.01927271f, 0.07921049f, 
    -0.02701513f, 0.12968048f, 0.10917362f, -0.09387069f, 0.10969465f, -0.01201928f, 0.12943438f, 0.05838927f, 
    0.27865168f, -0.06972672f, 0.18459952f, 0.04297857f, 0.11094493f, -0.03169911f, 0.06891501f, 0.02611552f, 
    0.18216611f, 0.15798488f, 0.04879728f, 0.09541080f, 0.06098542f, -0.10340314f, -0.07232833f, -0.24059479f, 
    0.27188471f, 0.12755838f, 0.14724325f, 0.10668221f, 0.05258007f, -0.02880757f, 0.10628378f, 0.04828469f, 
    0.20699576f, -0.07853168f, -0.06998938f, -0.18300116f, 0.12377659f, 0.05921084f, 0.02935227f, 0.06100401f, 
    0.09051437f, 0.06387653f, 0.01108161f, -0.03341471f, -0.08657473f, -0.10961059f, -0.12061846f, -0.15480296f, 
    0.16517612f, 0.11617746f, 0.10845009f, 0.01378048f, 0.13865343f, 0.10064045f, -0.01207918f, 0.15769678f, 
    -0.44450411f, 0.17021853f, -0.29482663f, -0.04408996f, 0.15545724f, 0.09404488f, -0.00111348f, 0.16121444f, 
    0.10568279f, -0.06144736f, 0.06590331f, 0.01692191f, -0.03141264f, 0.17383395f, 0.20765048f, 0.10213943f, 
    -0.06247156f, 0.03588182f, 0.02453712f, -0.01216323f, 0.08860262f, 0.11593077f, 0.14478765f, 0.05549806f, 
    -0.08638587f, -0.04557570f, -0.13179907f, 0.00270051f, 0.07128022f, 0.05844077f, 0.14662099f, 0.09538454f, 
    -0.00665790f, 0.12682614f, 0.09223802f, 0.00516596f, 0.14100650f, -0.18452255f, 0.10899155f, -0.10694981f, 
    0.16747001f, 0.10997839f, -0.05656267f, 0.02809873f, 0.12276123f, 0.03726188f, -0.00666495f, 0.01573296f, 
    -0.28103608f, -0.17089371f, -0.07986784f, -0.00542125f, 0.22114043f, 0.09690952f, 0.10704889f, 0.07506127f, 
    0.10429291f, 0.05731732f, -0.02253389f, 0.06089170f, -0.05576409f, 0.25897759f, 0.34096646f, 0.22350781f, 
    -0.05117022f, -0.00037535f, -0.00477287f, 0.01120602f, 0.01317604f, -0.00481504f, 0.12928489f, 0.06816988f, 
    0.25662002f, 0.20601000f, 0.29618639f, 0.16641860f, 0.04035705f, 0.05288811f, 0.06256660f, 0.01312373f, 
    0.05165751f, -0.01632170f, -0.03129084f, 0.23838389f, -0.04759147f, -0.39901894f, 0.20403197f, -0.05470590f, 
    -0.00932588f, 0.12270025f, 0.17701477f, -0.01469176f, 0.07146426f, 0.15105121f, -0.05903790f, 0.06651621f, 
    -0.15391414f, 0.25234738f, -0.07869121f, 0.03184393f, 0.19365029f, 0.03057091f, 0.02284118f, 0.17265418f, 
    0.06170442f, 0.03699087f, 0.11051386f, 0.08626711f, -0.10278087f, -0.10202111f, -0.04564100f, 0.09637403f, 
    0.00717767f, 0.02982106f, 0.18906343f, 0.10912368f, 0.00540784f, -0.01302044f, 0.04839388f, 0.06005089f, 
    -0.08045087f, -0.03262775f, -0.18212782f, -0.10593272f, 0.15927617f, 0.03456114f, 0.08928989f, 0.13431811f, 
    0.00174531f, 0.08622702f, -0.00497633f, -0.01960816f, 0.25029054f, 0.16102737f, 0.08664765f, 0.10423865f, 
    -0.06347606f, 0.07169129f, 0.01267773f, 0.06769087f, -0.03449149f, -0.03312453f, 0.09601174f, 0.02439672f, 
    0.06680384f, -0.09215631f, 0.05195522f, 0.04098466f, 0.03066750f, 0.03636090f, 0.01835687f, -0.08593218f, 
    0.01094639f, 0.03598956f, -0.04779041f, 0.02197611f, 0.27954063f, -0.12463295f, 0.09475867f, -0.12379134f, 
    0.08046046f, -0.06537653f, 0.08090635f, -0.06615363f, 0.13177614f, 0.01321788f, -0.11990356f, -0.00528965f, 
    -0.18418166f, -0.04468174f, -0.34803191f, -0.05547215f, 0.25886506f, 0.01411821f, -0.00894367f, 0.08097742f, 
    0.16341203f, -0.09209383f, 0.04518668f, 0.08516844f, 0.18433997f, -0.22205070f, 0.16623366f, -0.09676451f, 
    -0.03344879f, -0.04363628f, 0.09569611f, 0.08532908f, 0.09603873f, -0.04622150f, 0.09507746f, -0.02203532f, 
    -0.20979008f, -0.04627101f, -0.18849221f, 0.07442718f, 0.18441847f, 0.09973254f, 0.06660344f, 0.10876317f, 
    0.16684395f, -0.00492268f, -0.06428526f, -0.00521543f, 0.38571215f, 0.13624987f, 0.24329080f, 0.23238331f, 
    -0.05341329f, -0.01001190f, 0.05337121f, -0.00196760f, 0.09853099f, 0.09989162f, 0.03817555f, 0.21633489f, 
    -0.03087718f, 0.16417819f, 0.33481601f, 0.03609429f, -0.02310033f, 0.03202230f, 0.00418549f, 0.00067117f, 
    0.01647492f, -0.01201956f, -0.00890344f, 0.21200886f, 0.26112622f, -0.04281821f, 0.14610073f, 0.05037704f, 
    -0.13403091f, -0.01994167f, 0.04986734f, 0.02934005f, 0.00641561f, 0.06356315f, 0.03626925f, 0.05411746f, 
    -0.16736284f, 0.18025844f, -0.29695496f, 0.03175729f, 0.26168495f, 0.11990233f, 0.00061514f, 0.18018651f, 
    0.12279973f, -0.02948408f, 0.21617718f, -0.00526482f, -0.14339264f, 0.00410908f, -0.09161694f, 0.00047490f, 
    0.20824178f, 0.01233727f, 0.11719685f, 0.06867728f, 0.10461009f, -0.00225361f, 0.16547580f, 0.18056203f, 
    0.12273171f, -0.02055732f, -0.17256078f, 0.21208027f, 0.19364868f, 0.09412847f, 0.02748448f, 0.14173956f, 
    0.18958545f, 0.07041213f, 0.04792725f, 0.08555242f, 0.22478811f, 0.21178797f, 0.23478320f, 0.04896066f, 
    -0.02971506f, 0.00654472f, 0.04595007f, 0.01883705f, -0.01005880f, 0.13049443f, 0.02083103f, 0.18281129f, 
    0.26318082f, 0.24198048f, 0.22062409f, 0.17775454f, 0.02762159f, 0.13002875f, 0.05681149f, 0.09644763f, 
    0.01433507f, 0.14009842f, 0.07909492f, 0.05333219f, 0.04893076f, 0.00522975f, 0.13065051f, 0.09002977f, 
    0.10353628f, 0.03712799f, -0.03122535f, 0.04290966f, 0.05517685f, 0.17044212f, 0.18491052f, 0.16559745f, 
    0.25843772f, -0.06340615f, -0.04233744f, 0.07926810f, 0.16863468f, 0.17298619f, 0.07739768f, 0.01095808f, 
    0.15316413f, 0.09289559f, -0.01288448f, 0.11144957f, -0.07170349f, 0.11949811f, 0.04016991f, 0.03842641f, 
    0.10424156f, 0.02371190f, -0.01563730f, 0.06738251f, 0.08438493f, 0.09598286f, 0.14925158f, 0.07666015f, 
    0.26658699f, 0.23945683f, 0.15408164f, 0.02267182f, 0.03499539f, 0.05902636f, -0.03340733f, -0.00344480f, 
    0.00897835f, -0.00577749f, 0.04748177f, 0.09521211f, -0.01874060f, -0.24864186f, -0.05028723f, -0.04741530f, 
    0.11633517f, 0.10247745f, 0.10300048f, 0.15637983f, 0.16103531f, 0.05066098f, 0.11046720f, 0.04087370f, 
    0.33125246f, 0.15964302f, 0.29640540f, 0.12001837f, 0.05614346f, -0.01574234f, 0.06131135f, 0.05021595f, 
    0.02703015f, -0.00544783f, 0.16056535f, 0.16132341f, -0.01576510f, 0.05955617f, 0.11379102f, 0.02586679f, 
    0.10192273f, 0.08271674f, -0.01640717f, 0.12697487f, -0.00123967f, -0.01545865f, 0.06083524f, -0.02147284f, 
    -0.00741830f, -0.03595483f, 0.03497745f, 0.23261015f, 0.07259589f, 0.13474844f, 0.00189078f, 0.26068154f, 
    0.09660836f, 0.06403688f, 0.07773516f, 0.06895457f, -0.19519462f, -0.12057604f, 0.11071827f, -0.07536272f, 
    0.07315381f, 0.04095873f, 0.01499280f, -0.03065033f, 0.13519812f, 0.11042191f, 0.13041103f, 0.07089682f, 
    0.15342283f, 0.20573677f, 0.01410372f, 0.00547292f, 0.06369907f, 0.12874305f, 0.00616789f, 0.17250530f, 
    0.04961407f, 0.08304591f, 0.11543973f, 0.05455198f, -0.00368818f, -0.11565664f, 0.15197457f, 0.08692233f, 
    -0.03745500f, -0.07168580f, 0.17794982f, -0.02493638f, -0.07055189f, 0.01544784f, 0.01876213f, 0.05082149f, 
    0.09367109f, 0.24257714f, 0.28896180f, 0.13916941f, -0.06724709f, 0.03749288f, 0.11125164f, 0.01569231f, 
    0.06493805f, 0.03431852f, 0.12251115f, 0.07456961f, 0.13393265f, 0.21343786f, -0.18169956f, 0.02559778f, 
    0.15953395f, 0.04178299f, 0.06846288f, 0.08563672f, 0.16489235f, 0.03439843f, -0.01970956f, 0.07172673f, 
    0.16019890f, 0.02187187f, 0.30336329f, 0.07641121f, -0.01798538f, -0.02562674f, -0.03364658f, 0.06421110f, 
    0.09407581f, 0.02089348f, -0.02011142f, 0.21109901f, -0.01732338f, -0.21437068f, 0.06116072f, -0.08129802f, 
    0.05429963f, 0.05169810f, 0.16420265f, 0.12690321f, 0.09522777f, 0.02629339f, 0.18252236f, -0.04034274f, 
    -0.26679370f, 0.20184006f, -0.12681775f, 0.18615438f, 0.10336699f, 0.06801743f, -0.12989312f, 0.08165428f, 
    0.01682688f, 0.14770983f, 0.11350499f, 0.03876190f, -0.06675740f, 0.00646726f, -0.02698419f, -0.04283828f, 
    0.17618065f, 0.01532446f, 0.03632115f, 0.01550161f, -0.00943238f, 0.11431449f, 0.09949372f, 0.10600403f, 
    0.10505119f, 0.10357212f, 0.14748494f, 0.04158870f, 0.09633306f, 0.04167210f, 0.01579811f, -0.02846404f, 
    0.18313687f, -0.03357217f, 0.03645471f, 0.17937933f, 0.10840906f, -0.27619883f, 0.03210381f, 0.17589276f, 
    0.21542525f, -0.01172605f, 0.09122013f, 0.01315585f, 0.13765064f, -0.06669872f, 0.03914653f, -0.01301456f, 
    -0.01998574f, 0.00215520f, -0.06936891f, 0.16461627f, 0.15957008f, 0.04592156f, -0.00851646f, 0.12750284f, 
    0.04347223f, 0.13296661f, 0.11279670f, 0.05420233f, 0.23030654f, 0.10124797f, 0.32366818f, 0.05342378f, 
    0.04423871f, 0.07285614f, 0.16966599f, -0.02620829f, 0.06501282f, 0.02351096f, 0.09778987f, 0.05836334f, 
    -0.09753317f, -0.19367592f, -0.15120758f, -0.05392911f, 0.18254647f, 0.03204907f, -0.07686073f, -0.00098319f, 
    0.14734648f, 0.08034948f, 0.05754077f, 0.14290424f, 0.14876270f, 0.07299211f, 0.14664339f, 0.13605635f, 
    0.03810385f, -0.06225796f, -0.06989258f, -0.03971788f, 0.15206739f, 0.08824177f, 0.09724594f, 0.16225803f, 
    -0.17799520f, 0.06349483f, -0.28527486f, -0.12816861f, 0.16904740f, 0.09324598f, 0.14450166f, 0.12859261f, 
    0.11993487f, 0.06225075f, -0.08289181f, 0.01393428f, -0.45351714f, 0.20484391f, -0.16617617f, 0.04551344f, 
    0.10937577f, 0.05489099f, 0.01346706f, 0.12236785f, 0.01434415f, -0.01267937f, 0.07643095f, -0.01371863f, 
    -0.36421677f, -0.18634573f, -0.09639788f, 0.18610342f, 0.13119121f, 0.12712608f, 0.06342107f, 0.12443228f, 
    -0.09204649f, 0.09920965f, 0.00729758f, -0.06746215f, -0.14990786f, -0.03068028f, 0.20621616f, -0.00422457f, 
    0.09685658f, 0.12068019f, 0.15245239f, -0.02149317f, -0.02707114f, 0.11466058f, 0.08261371f, 0.09128224f, 
    -0.03625501f, -0.00301607f, -0.17971955f, 0.10553405f, 0.21422872f, 0.11144825f, -0.03168968f, 0.28352931f, 
    0.14338696f, 0.04816633f, 0.02642795f, 0.01625029f, -0.14243083f, -0.34994316f, 0.05942226f, 0.12188756f, 
    0.11437274f, 0.04273700f, 0.14083892f, -0.02802124f, 0.09112304f, 0.07863088f, -0.00171598f, 0.07985587f, 
    0.02564592f, 0.00559532f, 0.06985536f, -0.02081728f, 0.08582635f, 0.17033143f, 0.22716796f, 0.10868721f, 
    0.08893176f, -0.00856859f, 0.13101716f, 0.02978734f, -0.06737804f, 0.34429398f, 0.03753992f, -0.09943669f, 
    -0.10564110f, -0.07728865f, 0.11354749f, -0.00172108f, 0.11598410f, 0.06927268f, 0.11313240f, 0.14549364f, 
    -0.03626247f, 0.06173994f, -0.00573438f, 0.01041324f, 0.10243888f, -0.02444438f, 0.08008838f, -0.02363351f, 
    0.03545795f, -0.10758323f, 0.13967146f, 0.01687485f, 0.31441143f, 0.06536156f, -0.24569519f, 0.05511810f, 
    -0.06322575f, 0.01639423f, -0.07626403f, 0.10434755f, -0.11671561f, -0.05779022f, -0.05323459f, -0.01633113f, 
    0.11919860f, 0.22088642f, -0.15752529f, 0.02129328f, 0.01636077f, -0.04204623f, 0.02514867f, 0.07728411f, 
    0.02065458f, 0.08677927f, -0.24305524f, -0.02462501f, 0.04361758f, -0.25489962f, 0.22164579f, 0.00882582f, 
    -0.00422216f, -0.14016624f, 0.02494646f, 0.07297898f, -0.07003962f, 0.05744893f, -0.14680643f, 0.03695702f, 
    -0.23984171f, 0.21177979f, -0.17841716f, -0.22866634f, 0.08784528f, 0.07955489f, -0.08470920f, 0.03179664f, 
    0.08709934f, -0.06046719f, 0.06439524f, -0.17478448f, -0.01490952f, 0.21375328f, 0.01028598f, 0.12947816f, 
    -0.06239032f, -0.15799490f, 0.14661886f, 0.00729093f, 0.09503122f, 0.09882379f, -0.06102254f, -0.01997269f, 
    -0.02750662f, 0.01075211f, 0.28707120f, 0.03543561f, 0.07615961f, -0.14591272f, 0.01297114f, 0.03054222f, 
    -0.13410319f, -0.14295992f, -0.05089762f, -0.07155570f, 0.02428486f, -0.04031838f, -0.10465150f, -0.08318730f, 
    0.08441710f, 0.07375891f, 0.06878943f, 0.18725377f, -0.01584767f, -0.17526570f, 0.17628162f, -0.01976000f, 
    0.10777756f, 0.12895115f, 0.04835929f, 0.00640421f, -0.02731863f, -0.00995908f, 0.09139242f, -0.14547588f, 
    -0.05229769f, 0.15098585f, 0.01374229f, 0.03451115f, 0.23991415f, -0.18839687f, 0.01106860f, 0.04665554f, 
    -0.04021038f, 0.03431070f, -0.09475885f, -0.01266644f, 0.00528009f, 0.06240369f, -0.01268564f, -0.08862511f, 
    -0.04248440f, -0.14394206f, -0.01524047f, 0.17707250f, 0.02193488f, -0.02621633f, 0.00003364f, -0.01848020f, 
    0.11512318f, -0.15170191f, -0.18278658f, 0.04053689f, 0.15141939f, 0.02689414f, 0.06401238f, 0.10015105f, 
    -0.10130569f, -0.02070563f, 0.19362749f, 0.15839350f, 0.15942514f, 0.07957060f, -0.02143227f, -0.03809834f, 
    -0.13847217f, 0.06784852f, 0.02696276f, 0.02905892f, -0.00791525f, 0.01013098f, -0.03776787f, -0.06128081f, 
    -0.05732397f, 0.03997088f, -0.02477262f, -0.00999819f, 0.45127138f, -0.16856995f, -0.21437322f, -0.13989694f, 
    0.13462415f, -0.11751853f, -0.01765113f, -0.02494369f, -0.01832172f, 0.14584272f, -0.12246339f, 0.03711337f, 
    0.20746486f, 0.01727978f, -0.09842324f, -0.22466511f, -0.01306802f, -0.08690633f, 0.09951267f, 0.05290127f, 
    -0.09051924f, -0.06397733f, 0.15087336f, -0.08522532f, 0.23601083f, -0.07466738f, 0.11564541f, 0.05346704f, 
    -0.00562230f, 0.10921669f, -0.12373981f, 0.10592224f, 0.01194425f, -0.02128903f, -0.06274160f, 0.13183239f, 
    0.01164994f, -0.00898682f, 0.00959773f, 0.07054522f, 0.11867232f, 0.00186067f, 0.00291393f, 0.00292913f, 
    0.05205864f, -0.00333948f, 0.16351628f, -0.22830124f, -0.20711847f, -0.04779519f, -0.03463571f, -0.11149000f, 
    0.08030460f, 0.13178252f, -0.11953115f, 0.04755942f, 0.04379873f, 0.02654168f, -0.17335862f, 0.10686310f, 
    -0.03306286f, -0.09954706f, 0.05159163f, 0.00832104f, 0.03865819f, 0.06583114f, 0.16166413f, 0.08502910f, 
    0.09340261f, 0.14681281f, -0.00510058f, -0.02453563f, -0.20916785f, -0.13610187f, 0.01257379f, 0.17468522f, 
    0.07107056f, -0.03483459f, -0.02682532f, 0.14114566f, -0.08962366f, 0.11325504f, 0.05825534f, 0.19263266f, 
    -0.14028879f, 0.35419375f, -0.02295835f, -0.00947669f, 0.06309737f, 0.02859659f, 0.05367673f, 0.07289798f, 
    -0.02031310f, 0.23456378f, 0.14302251f, 0.09584428f, -0.33917978f, 0.17650768f, -0.07320386f, 0.04640955f, 
    0.15244195f, 0.15403481f, 0.02068488f, 0.03259869f, -0.08288898f, -0.08328678f, 0.20867965f, 0.12821975f, 
    -0.13326019f, -0.10568902f, 0.15697606f, -0.09319675f, 0.03992529f, 0.04240808f, 0.05363908f, -0.02882589f, 
    -0.01522735f, 0.00928741f, -0.03316681f, 0.07173590f, -0.07222500f, 0.33205286f, 0.05536582f, 0.14711514f, 
    0.23257306f, 0.04170572f, 0.10076038f, -0.15804078f, 0.06468291f, 0.04079574f, -0.07407403f, -0.01228943f, 
    0.03277158f, 0.06206099f, 0.08806978f, 0.04174587f, -0.01406322f, -0.02684244f, 0.11929896f, 0.10270953f, 
    0.01569278f, 0.05201173f, -0.03727206f, 0.07334860f, 0.12530856f, 0.25767690f, -0.00930168f, -0.10489248f, 
    0.16159877f, -0.03219081f, -0.00627447f, -0.08940442f, -0.09274422f, -0.23600391f, 0.04115825f, -0.18223801f, 
    0.24799675f, 0.04460383f, -0.19357462f, -0.01713993f, -0.06880518f, -0.03942978f, -0.02308146f, 0.01692815f, 
    -0.05970334f, 0.06192681f, -0.10161235f, 0.00198724f, 0.09011317f, 0.25614831f, 0.06357805f, 0.08009832f, 
    -0.06296682f, 0.06199855f, 0.05171029f, -0.02837193f, 0.14355686f, -0.19583136f, -0.07113702f, 0.04361759f, 
    0.02261154f, 0.04738809f, 0.10886849f, 0.04359303f, -0.01090926f, -0.01358056f, 0.12842005f, -0.07671712f, 
    -0.02071337f, 0.06544789f, -0.11209482f, 0.05819748f, 0.01411574f, 0.13737506f, 0.06751346f, 0.07038119f, 
    -0.00666567f, 0.04420637f, -0.15328303f, -0.06841294f, 0.06398387f, 0.06924687f, -0.14371391f, -0.17683162f, 
    0.10202700f, 0.01991501f, 0.07185057f, -0.10480512f, -0.09921496f, 0.01855448f, 0.06990866f, -0.10621152f, 
    -0.10921022f, -0.06777290f, -0.31362885f, -0.08218864f, 0.16573538f, 0.17834365f, -0.08157331f, -0.18939941f, 
    -0.05027165f, 0.08973742f, -0.02690556f, 0.00962230f, 0.05807506f, -0.13971528f, -0.00554015f, -0.09958117f, 
    -0.08301724f, -0.12643591f, -0.04119726f, -0.20329770f, 0.06563957f, -0.11815806f, 0.05284029f, -0.04159891f, 
    0.07523550f, 0.04753802f, -0.13595909f, 0.14449283f, -0.17795280f, -0.12619030f, -0.06215472f, 0.13277467f, 
    -0.01422802f, 0.02731844f, -0.13470609f, -0.02388998f, 0.04832582f, -0.09965245f, -0.16176130f, -0.12283757f, 
    0.14100680f, -0.05688287f, -0.11424422f, -0.11440305f, -0.09069917f, -0.07204743f, -0.13425562f, 0.17512769f, 
    -0.09593846f, 0.14180371f, -0.00340775f, -0.16680767f, -0.29217103f, 0.01229502f, -0.07199707f, 0.15368614f, 
    -0.08491723f, -0.07052416f, 0.02143059f, 0.08629241f, 0.03107020f, -0.18974760f, -0.07734153f, -0.08819065f, 
    -0.27662736f, -0.08047563f, -0.12575428f, -0.16012794f, -0.05840843f, 0.06161371f, 0.12741826f, 0.11984368f, 
    0.01329503f, 0.12305512f, 0.02436692f, 0.07790027f, 0.34853891f, -0.07543638f, 0.08228894f, 0.10868971f, 
    0.07501350f, 0.04408203f, 0.08508084f, -0.03910788f, 0.05488646f, 0.16361125f, 0.01767190f, 0.15600865f, 
    0.04423284f, -0.00850700f, -0.14368936f, -0.10164250f, 0.02314651f, -0.09213109f, -0.10606565f, -0.04595187f, 
    -0.00899751f, 0.09183013f, -0.15277480f, -0.01891639f, 0.07009566f, 0.28811532f, 0.15866068f, 0.11298390f, 
    -0.12817645f, 0.09843668f, 0.18309158f, -0.05935218f, 0.11615349f, -0.11048312f, 0.13870722f, 0.14028616f, 
    0.06220482f, 0.10413656f, 0.02266435f, -0.07343916f, 0.06916258f, 0.10280803f, 0.18737888f, -0.22120973f, 
    -0.02624577f, 0.06886169f, -0.07716549f, -0.00532513f, 0.18551794f, 0.21658200f, 0.01547359f, 0.20163943f, 
    0.00511716f, 0.08299245f, 0.15801482f, -0.03762640f, 0.11152226f, 0.15730861f, -0.05694546f, 0.23394851f, 
    -0.28405124f, -0.19202043f, 0.09046560f, -0.01634426f, 0.10439729f, -0.12099092f, 0.00239940f, -0.06303018f, 
    0.07314647f, -0.12177109f, -0.01226659f, 0.14490619f, 0.03968268f, 0.39048436f, -0.04122405f, 0.02138476f, 
    0.01618948f, 0.21415687f, -0.08713892f, -0.01813849f, 0.09291806f, 0.03714400f, 0.05873096f, 0.12264842f, 
    0.25177562f, 0.08536904f, -0.17534150f, -0.10645375f, 0.10876942f, 0.01182408f, -0.15298937f, -0.00113368f, 
    -0.03605251f, 0.13364492f, -0.14863671f, 0.06440111f, -0.29567808f, 0.11914141f, 0.18113400f, -0.13789728f, 
    0.10368338f, -0.03994624f, 0.09830362f, -0.00652156f, -0.17623761f, -0.07432789f, 0.09301551f, -0.05317331f, 
    0.13311176f, 0.12431069f, -0.11986470f, -0.05171086f, -0.02145021f, 0.18694337f, -0.07831403f, 0.00274815f, 
    0.04584303f, -0.01161578f, 0.08986533f, 0.00134397f, 0.12391546f, 0.14543194f, 0.03827953f, 0.25481507f, 
    -0.08171517f, 0.00998789f, -0.09926151f, -0.09112254f, -0.01675742f, 0.09501762f, -0.06176532f, 0.25966719f, 
    0.13128152f, 0.18071572f, 0.08339007f, 0.02705674f, 0.19762136f, -0.05177239f, 0.18253830f, 0.00100080f, 
    0.02801741f, -0.16016203f, 0.00777987f, 0.00607384f, -0.07650394f, -0.25776812f, 0.06960297f, 0.23401624f, 
    0.01616632f, 0.08770586f, -0.09723634f, -0.07620325f, 0.12566850f, -0.19057170f, -0.10105787f, -0.16914500f, 
    -0.00980715f, -0.04236627f, -0.13048841f, -0.05299385f, -0.04228958f, 0.11708691f, 0.12973398f, 0.06713337f, 
    -0.16073500f, 0.17554876f, 0.00278412f, 0.05415150f, -0.20850028f, 0.09973324f, 0.08506968f, -0.13917300f, 
    -0.02510417f, -0.17991006f, -0.04803738f, -0.09967376f, -0.09001874f, 0.02873474f, -0.03065821f, -0.06648176f, 
    0.14814830f, 0.06495312f, -0.00791125f, 0.15363535f, 0.02341401f, -0.09233561f, 0.08983650f, -0.10552206f, 
    0.00203419f, -0.08628749f, -0.16479465f, 0.02433431f, 0.11498065f, 0.12914687f, -0.01222972f, 0.07097346f, 
    -0.01728133f, -0.02141823f, 0.03999450f, 0.04396823f, 0.12865865f, 0.15047771f, -0.04929884f, -0.13169080f, 
    0.07713803f, 0.07966547f, -0.07800725f, -0.23037483f, 0.00225964f, -0.06094386f, 0.16521932f, 0.08040082f, 
    -0.00459512f, -0.04121776f, -0.00048420f, -0.08237819f, 0.33451697f, 0.14908445f, -0.13683362f, -0.19523075f, 
    0.00566753f, -0.04017230f, 0.10049808f, -0.11072222f, -0.12057725f, -0.11245522f, -0.13373040f, -0.06968857f, 
    0.03405618f, 0.23943782f, 0.07540426f, 0.18176651f, 0.06716786f, -0.01911667f, -0.08805197f, -0.05580323f, 
    0.04329249f, -0.02765792f, 0.17858557f, -0.17806497f, -0.18708423f, 0.07643434f, -0.07924557f, 0.03934709f, 
    0.06251000f, -0.11296812f, 0.10051822f, 0.07407103f, 0.11285547f, 0.04728738f, 0.15176073f, 0.06663462f, 
    0.21032707f, 0.07394758f, -0.10629706f, 0.13960817f, -0.00479574f, -0.16775402f, -0.08332025f, -0.07113436f, 
    0.03304529f, 0.00026377f, 0.20973247f, 0.09912172f, 0.28900588f, -0.04109314f, -0.06454026f, 0.15299226f, 
    -0.08172020f, 0.10760699f, -0.17254815f, 0.12901475f, 0.07190972f, -0.15146059f, 0.02735961f, 0.03445872f, 
    -0.18285009f, 0.01110309f, -0.22065705f, -0.09406023f, -0.02896863f, 0.07952277f, 0.19361246f, 0.06626683f, 
    0.07357187f, 0.09142539f, -0.16540986f, -0.08487636f, 0.23126034f, 0.16071649f, -0.24128984f, -0.04158400f, 
    0.03008323f, -0.02389589f, -0.08681185f, 0.04290511f, -0.11227889f, 0.04781286f, -0.05937491f, -0.08574285f, 
    0.13357893f, 0.13977584f, 0.23784196f, -0.05443008f, -0.05952007f, -0.07071184f, 0.08705353f, -0.07316329f, 
    -0.03723238f, 0.13111641f, 0.01084264f, 0.03470231f, 0.26298699f, -0.20019041f, 0.02916677f, 0.12555896f, 
    -0.02483538f, 0.18692355f, -0.03337445f, 0.13623635f, -0.06251742f, -0.02904301f, 0.10491551f, -0.10408741f, 
    -0.03027363f, 0.02028146f, -0.00012472f, -0.01892476f, 0.01348983f, 0.02929000f, 0.02362515f, -0.01955140f, 
    -0.03763893f, -0.01375315f, 0.02784060f, -0.01436652f, -0.02708980f, 0.01215283f, 0.01035031f, -0.02456979f, 
    -0.01157066f, -0.02766495f, -0.01641004f, -0.03029645f, -0.00090197f, 0.02112253f, -0.03071757f, -0.03802821f, 
    0.01628845f, 0.00456508f, -0.00408689f, -0.00477546f, -0.04144234f, -0.02636181f, 0.01110012f, 0.02317779f, 
    -0.04105457f, -0.02577837f, -0.01849154f, -0.02586391f, 0.02832191f, -0.00146926f, 0.02101384f, -0.00138695f, 
    -0.02563635f, 0.01089212f, 0.01218847f, -0.00520260f, 0.02247238f, -0.03217563f, 0.00166720f, -0.00177197f, 
    -0.00045904f, -0.01446592f, 0.00951197f, 0.00190901f, -0.01364181f, 0.02840434f, 0.02932505f, -0.02681026f, 
    -0.02436838f, -0.01295627f, -0.01916341f, -0.04032606f, -0.01541071f, 0.01568984f, -0.02628639f, -0.03480828f, 
    -0.03829533f, -0.02605335f, -0.01766200f, -0.02069571f, -0.01238078f, 0.01538547f, 0.00700310f, -0.00359992f, 
    -0.01690912f, 0.00015978f, -0.00303722f, -0.02092069f, 0.01866130f, 0.00009994f, -0.01244847f, -0.00729143f, 
    0.02897660f, -0.01805984f, 0.00300325f, -0.02264283f, -0.01448480f, 0.02346466f, -0.00802864f, 0.02570267f, 
    0.01280873f, 0.01661384f, -0.00331698f, -0.02286798f, 0.01575205f, -0.00473839f, -0.02357879f, 0.01556326f, 
    -0.00481072f, -0.00100198f, -0.03340481f, -0.02257376f, 0.01481785f, -0.03189024f, -0.02225892f, -0.02543383f, 
    -0.01637918f, 0.01173302f, 0.01975797f, 0.02218969f, -0.00807530f, -0.02176687f, -0.04033802f, 0.01418975f, 
    -0.01030369f, 0.00118549f, 0.02828382f, -0.01178632f, -0.03494437f, 0.01408918f, -0.03536508f, -0.01753278f, 
    -0.03598372f, 0.03002767f, 0.01862543f, -0.02770617f, -0.03477544f, 0.00775343f, -0.02502021f, -0.01775504f, 
    0.02305781f, -0.03549068f, -0.02357204f, -0.02832667f, 0.02644288f, -0.02868770f, -0.01662119f, -0.00680711f, 
    0.02708973f, -0.02717883f, 0.02101944f, 0.00771302f, 0.01104109f, 0.01812277f, 0.01794172f, 0.02604950f, 
    0.01403096f, -0.03244646f, -0.02341656f, 0.00447931f, -0.01088506f, -0.00723712f, 0.00181886f, 0.00357339f, 
    0.01959177f, -0.02984310f, 0.00697116f, -0.04124277f, -0.01855167f, -0.01064810f, 0.00125337f, 0.01330827f, 
    -0.00413520f, -0.00596277f, -0.03472015f, -0.03841203f, 0.00517512f, 0.02285755f, 0.02263126f, 0.02215200f, 
    -0.00933002f, 0.00429378f, -0.01902791f, 0.01969428f, 0.02783141f, 0.02028902f, 0.01017054f, -0.00288419f, 
    0.02550274f, -0.01495357f, -0.03349912f, -0.03881405f, 0.01598731f, -0.01729227f, 0.00726726f, -0.03231133f, 
    -0.03950814f, -0.02970159f, 0.02198318f, 0.02475854f, 0.00976513f, 0.02212113f, -0.03654877f, 0.01731251f, 
    0.00224993f, -0.02242704f, -0.02225040f, -0.02590952f, 0.01183502f, -0.02728460f, -0.00429319f, -0.01641863f, 
    -0.01320237f, -0.00312824f, -0.01779152f, -0.01475737f, 0.00045771f, -0.00164119f, -0.00477831f, 0.02368744f, 
    0.00797611f, -0.02074665f, 0.00063780f, -0.01008115f, 0.02630420f, 0.02371704f, 0.03012556f, 0.00606762f, 
    -0.03726088f, -0.01806116f, -0.02887714f, 0.00270744f, -0.03995049f, 0.00550404f, 0.01483838f, -0.00431596f, 
    0.00524977f, 0.02587391f, -0.00322336f, -0.00837513f, 0.02855776f, -0.00384576f, -0.00610961f, -0.00972305f, 
    -0.00725401f, -0.01787572f, 0.01886355f, -0.03550992f, -0.01395605f, 0.01793950f, 0.00298109f, -0.03837027f, 
    -0.03165120f, 0.01568717f, -0.00920029f, 0.01265113f, -0.00696589f, -0.00259229f, 0.01244911f, 0.00303083f, 
    -0.02151255f, 0.00308323f, 0.02970835f, -0.03933645f, -0.01586615f, -0.02448642f, 0.00724171f, -0.00202154f, 
    -0.01869693f, -0.01765603f, -0.00397679f, -0.03496045f, -0.03837349f, -0.02455729f, 0.00128757f, 0.01247350f, 
    -0.00601211f, -0.02781552f, -0.01378418f, 0.02334421f, 0.02171219f, 0.01487644f, 0.00583917f, -0.00193162f, 
    -0.00017123f, 0.00638485f, -0.02377047f, 0.00843227f, -0.01089581f, 0.00931448f, -0.02477772f, 0.00063890f, 
    -0.02276405f, 0.01556675f, -0.01619198f, -0.02930782f, -0.04161182f, -0.03490771f, 0.01629312f, -0.00214294f, 
    -0.00966416f, 0.00065161f, -0.00893788f, 0.01526082f, 0.01294928f, -0.00866322f, -0.00970708f, -0.02659146f, 
    -0.00256469f, -0.02219953f, 0.01735613f, -0.00280061f, -0.03850663f, -0.00126876f, -0.01981390f, -0.02198882f, 
    0.00518652f, -0.03765726f, 0.00357665f, 0.02287159f, 0.01516176f, -0.01864807f, -0.03829410f, 0.00710585f, 
    -0.03560601f, 0.02081260f, 0.01939858f, -0.00134872f, -0.00550997f, 0.02577158f, -0.00913363f, -0.02145289f, 
    -0.02747755f, 0.01501699f, -0.02987048f, -0.04180189f, 0.01760933f, -0.02632534f, -0.00558885f, -0.01353352f, 
    -0.00255215f, 0.02375584f, -0.02174541f, 0.01247999f, 0.00793783f, -0.02993950f, 0.00668220f, -0.02866904f, 
    0.00051445f, -0.00619686f, -0.03163453f, -0.03713831f, 0.00832933f, -0.02623846f, -0.01917613f, 0.00052810f, 
    -0.01613812f, 0.02401232f, 0.01271832f, -0.01557452f, 0.01761296f, -0.00078045f, -0.02915152f, -0.02882705f, 
    -0.03419000f, 0.02533831f, 0.01163787f, 0.01233013f, 0.00056437f, 0.01614464f, -0.03607907f, 0.01358160f, 
    -0.00446102f, 0.01222758f, 0.01217176f, -0.02769564f, -0.01868065f, 0.00334654f, -0.01845386f, 0.01371355f, 
    -0.01557599f, -0.01526392f, -0.01862440f, 0.00202379f, 0.00008349f, 0.01087457f, -0.01500804f, 0.00450893f, 
    -0.03970385f, -0.02198505f, -0.02010378f, 0.02394942f, -0.02623839f, 0.00176696f, -0.01565659f, 0.00454956f, 
    0.01132881f, 0.01948930f, -0.03610551f, 0.01231281f, -0.00383061f, 0.00832876f, -0.03250428f, -0.02855874f, 
    0.00153452f, -0.01382699f, -0.02867110f, 0.01632165f, -0.02913882f, -0.01955984f, 0.01180110f, 0.02942900f, 
    0.00845765f, 0.01797255f, -0.00639097f, 0.01047591f, -0.03514588f, -0.00099634f, -0.03947927f, -0.03611783f, 
    -0.02420510f, 0.04063714f, 0.01584569f, 0.02532436f, 0.01361852f, 0.00320052f, -0.02000526f, -0.03104797f, 
    0.00541002f, -0.03776836f, -0.03517030f, 0.01880358f, -0.02097897f, 0.02867787f, -0.01840375f, -0.01922532f, 
    0.01077946f, -0.03872662f, 0.01859016f, -0.01724008f, -0.01884077f, 0.02620916f, -0.01581817f, -0.04114035f, 
    -0.03119965f, 0.02042031f, -0.02405392f, 0.01834667f, 0.01621820f, -0.01422241f, -0.02657815f, 0.02364622f, 
    0.00710676f, -0.00753426f, -0.01430352f, 0.01975192f, 0.02408183f, 0.01901409f, -0.01885501f, 0.03736608f, 
    0.02865870f, 0.02699897f, 0.00872704f, 0.00494280f, -0.03121665f, -0.02576109f, 0.00302767f, -0.02715682f, 
    0.02243082f, -0.00849813f, 0.02784628f, -0.01949750f, 0.00302909f, -0.01787254f, -0.01475673f, -0.02706498f, 
    -0.00902649f, -0.00054756f, 0.00129855f, -0.02157507f, -0.02071155f, -0.02801685f, 0.02018020f, 0.03146138f, 
    0.00250408f, 0.02785339f, 0.02643936f, 0.02929808f, 0.02661701f, -0.02516502f, -0.02704557f, -0.01565250f, 
    0.00189574f, 0.01212107f, -0.02262970f, -0.02806047f, -0.01165637f, -0.00733192f, -0.00901451f, 0.00164593f, 
    -0.03992235f, 0.02087180f, 0.00494530f, -0.03889904f, 0.00915593f, 0.01780362f, 0.04093448f, 0.02148613f, 
    -0.00330038f, 0.02533846f, -0.00081472f, -0.01050932f, -0.03875490f, -0.02201436f, 0.00223327f, -0.00206927f, 
    -0.00059261f, -0.02636178f, -0.01404641f, -0.02766176f, -0.00921363f, -0.00446968f, 0.02914439f, 0.00763575f, 
    -0.00616907f, 0.02794322f, 0.01679871f, 0.01368060f, 0.02151904f, 0.01472459f, -0.00692528f, 0.02361033f, 
    -0.02581249f, -0.01458813f, -0.03741163f, -0.02292835f, -0.00055102f, -0.03172507f, -0.03643429f, 0.01207265f, 
    0.02232791f, -0.00896463f, -0.01005013f, -0.00171688f, -0.01872810f, -0.02080152f, -0.03152969f, 0.01234346f, 
    0.00829529f, -0.03361538f, -0.01835586f, 0.01437993f, 0.01532008f, 0.02958178f, -0.01862983f, -0.00986081f, 
    -0.03096029f, -0.01476100f, 0.00753303f, 0.02328770f, -0.03433802f, -0.03821913f, -0.00915281f, -0.01382522f, 
    -0.00181877f, 0.00907525f, -0.02905887f, -0.04091216f, 0.02797111f, -0.00744751f, 0.01542481f, -0.00228826f, 
    -0.01023303f, -0.00256614f, 0.02585268f, -0.02441535f, 0.01229796f, -0.01049041f, 0.00594460f, 0.02960208f, 
    -0.02288529f, -0.01680588f, 0.01844074f, 0.00974819f, 0.00899182f, 0.01062903f, -0.04163541f, 0.01440016f, 
    -0.02713593f, 0.01124584f, 0.01854379f, -0.02222167f, -0.01678371f, 0.00806696f, 0.01715416f, 0.01770568f, 
    0.00620155f, -0.00661853f, -0.02908891f, -0.00819770f, -0.02612607f, -0.01397227f, -0.01344888f, -0.00867467f, 
    -0.00954186f, 0.00150201f, 0.00232850f, -0.02835781f, 0.02503878f, -0.04041740f, -0.01268632f, 0.00987841f, 
    -0.00175228f, 0.02356745f, -0.00332044f, -0.02530979f, 0.00260294f, 0.00826406f, -0.03018914f, -0.03011324f, 
    -0.03454676f, -0.03043078f, 0.01130984f, 0.00835774f, -0.00338755f, -0.00574675f, -0.02023506f, -0.03612567f, 
    0.02219377f, -0.01419273f, 0.00725378f, -0.02458691f, -0.02940627f, -0.04188533f, -0.01006434f, 0.02736717f, 
    -0.02522838f, -0.01675988f, -0.02853373f, -0.00933661f, -0.03931920f, -0.01395106f, -0.00737238f, -0.02524508f, 
    -0.02117852f, -0.02716169f, -0.02766446f, -0.03255317f, -0.03427877f, 0.01243314f, -0.02509055f, -0.02115351f, 
    0.02495598f, 0.00542176f, 0.00773904f, -0.02614496f, -0.03728038f, -0.00224104f, -0.03127468f, 0.02817354f, 
    -0.02562066f, -0.00644412f, 0.00649356f, -0.03835508f, -0.03051625f, -0.02765585f, -0.03524722f, -0.03501608f, 
    -0.01457225f, 0.00898827f, -0.00566834f, 0.04117606f, 0.02116643f, 0.01258771f, -0.03405572f, -0.00453682f, 
    -0.00704159f, -0.01512607f, -0.01299262f, -0.01640933f, -0.02480155f, -0.03427884f, 0.01415898f, -0.01697663f, 
    -0.01335111f, -0.03609100f, 0.01537602f, -0.00204162f, 0.03350064f, -0.03737310f, -0.02167626f, -0.01907453f, 
    -0.01974910f, -0.02201867f, 0.00426943f, -0.01216583f, 0.00045747f, -0.02462048f, -0.01850705f, -0.02082689f, 
    -0.03188732f, 0.02162816f, 0.01240081f, -0.04144752f, 0.02567711f, 0.01073959f, -0.01502772f, -0.04029093f, 
    0.02105329f, -0.00696846f, 0.02953353f, -0.00346140f, 0.02904340f, 0.01983843f, -0.04002815f, 0.02106146f, 
    0.00564627f, -0.01562901f, -0.01341711f, -0.00797131f, -0.01059067f, -0.04152516f, -0.02090710f, -0.00792425f, 
    0.00177941f, -0.02054223f, 0.00249185f, -0.00793436f, 0.01647184f, 0.02327057f, -0.03018885f, -0.03908686f, 
    0.02046475f, -0.01725706f, 0.04069845f, 0.01646424f, 0.02966170f, -0.03891567f, 0.00349162f, 0.00807674f, 
    -0.03863946f, 0.02785081f, 0.02159750f, 0.02115791f, -0.01482718f, -0.01420210f, 0.00978655f, -0.00750302f, 
    -0.03564065f, -0.02989563f, -0.02846571f, -0.01965698f, -0.03928357f, -0.03218163f, 0.00640725f, 0.01562093f, 
    0.01506784f, 0.00520446f, 0.01940567f, -0.02935882f, -0.04182623f, 0.02762502f, 0.02390890f, -0.01493378f, 
    -0.03334652f, 0.00659449f, -0.02807945f, -0.01668553f, 0.02124934f, -0.01423474f, -0.03102310f, -0.03233490f, 
    -0.01020338f, -0.02421090f, -0.03851678f, 0.00766772f, -0.02774434f, 0.01941626f, 0.02748059f, 0.01220765f, 
    -0.13157070f, -0.14106816f, -0.02244590f, 0.00078317f, 0.05215741f, 0.05638531f, 0.08262879f, 0.03016627f, 
    0.04059273f, -0.00784758f, 0.06380170f, -0.05741721f, 0.11520419f, 0.10710975f, 0.11020455f, 0.10607014f, 
    -0.03066788f, -0.05468232f, -0.07060491f, 0.10749942f, -0.09290446f, 0.00134663f, 0.05462186f, -0.01035621f, 
    0.05346063f, 0.03743941f, 0.10758299f, 0.05676449f, -0.04431786f, -0.00400689f, 0.02337402f, 0.00660602f, 
    0.01622482f, 0.01326663f, -0.08158180f, 0.01496848f, -0.17368683f, -0.04777042f, 0.07470664f, 0.05918157f, 
    -0.02604796f, -0.01707353f, 0.11628702f, -0.01346520f, -0.04757553f, 0.01723128f, -0.07289614f, 0.00362488f, 
    -0.23674564f, 0.34208047f, 0.01301113f, -0.17330660f, -0.10612494f, 0.17422579f, 0.00941948f, 0.04827419f, 
    0.06476732f, -0.11379269f, -0.03984595f, -0.00066889f, -0.02184424f, -0.05636313f, 0.06718362f, -0.08504740f, 
    0.01621616f, -0.00365191f, 0.15609987f, -0.03938989f, 0.04676302f, -0.02503201f, -0.05757742f, 0.05233983f, 
    -0.15980834f, 0.01933394f, 0.08657939f, -0.02293849f, 0.04380634f, -0.01327017f, -0.03536183f, 0.06359487f, 
    0.06417998f, -0.12781245f, 0.00900062f, -0.13476668f, -0.16706628f, -0.11986627f, -0.24547371f, -0.05768098f, 
    0.05509933f, 0.01725675f, 0.00390038f, -0.06361748f, 0.06901384f, -0.00500972f, 0.06806147f, -0.02506066f, 
    -0.13217556f, -0.08802016f, -0.04183002f, -0.09511467f, 0.05770798f, 0.03311377f, 0.07091998f, -0.12503526f, 
    -0.03784395f, 0.09662072f, 0.05054473f, 0.03282736f, 0.03147952f, -0.22744079f, 0.02167218f, 0.10256954f, 
    -0.00401561f, 0.03610227f, -0.00406069f, -0.02059085f, -0.09798232f, 0.13045774f, -0.05730568f, -0.10811106f, 
    -0.03677779f, -0.19042999f, 0.07479600f, 0.15488808f, 0.07366374f, -0.05687513f, -0.04724475f, 0.04631218f, 
    0.02996118f, -0.11251772f, -0.06650755f, -0.02378156f, -0.10565826f, -0.00923327f, -0.06472605f, 0.30849117f, 
    0.03671388f, 0.06853189f, -0.02470040f, 0.10264356f, 0.13424440f, 0.09178941f, -0.04675802f, 0.00924876f, 
    -0.26520780f, 0.03368288f, 0.00884459f, 0.05650526f, 0.14500967f, 0.02324805f, -0.02809275f, -0.06505125f, 
    -0.02016237f, 0.08351293f, -0.03192050f, 0.03322000f, 0.29634809f, -0.04912203f, 0.08861771f, -0.18583426f, 
    0.10197716f, -0.16532528f, 0.07251802f, 0.03034001f, -0.08030414f, -0.06976095f, -0.04896608f, 0.07137977f, 
    0.09043549f, 0.15843561f, 0.05631788f, -0.13525853f, -0.07723288f, -0.00621448f, 0.06897834f, 0.10718768f, 
    -0.03385422f, -0.06377264f, 0.11791316f, -0.01909362f, 0.15670976f, -0.09323293f, -0.02956977f, 0.13748235f, 
    -0.11835603f, 0.14546053f, -0.01947923f, 0.00745603f, 0.01931636f, 0.02844192f, -0.05345766f, 0.10729630f, 
    -0.06697402f, -0.06199401f, -0.04104720f, 0.00804427f, 0.03932400f, 0.01110881f, 0.05935478f, 0.02151160f, 
    0.01466789f, -0.00599367f, 0.17083138f, -0.09879038f, -0.14278153f, 0.00968350f, 0.03114623f, -0.00470201f, 
    0.07477349f, 0.04087177f, -0.12118102f, -0.02292861f, 0.05788676f, 0.02714397f, -0.04014389f, 0.19160010f, 
    -0.17902362f, -0.19540991f, -0.13585690f, -0.02984874f, 0.03042804f, 0.11039119f, 0.07651160f, -0.03854896f, 
    0.08021911f, 0.13489397f, 0.05291332f, 0.10332830f, 0.03166975f, 0.11062113f, -0.04724894f, 0.00018886f, 
    -0.03422250f, 0.05273498f, -0.04768924f, 0.12362382f, -0.15010154f, 0.06998009f, 0.03961686f, 0.10389873f, 
    -0.03433649f, 0.09190185f, 0.20046780f, 0.01870122f, -0.04916076f, 0.12263435f, -0.08960614f, -0.02544532f, 
    -0.09855170f, 0.06915560f, 0.06858882f, -0.01344798f, -0.26839340f, -0.04983085f, 0.08546708f, -0.05471095f, 
    0.10051475f, 0.02509793f, -0.22236669f, 0.00267141f, 0.04460084f, -0.02867759f, 0.11068080f, 0.08899591f, 
    -0.32005352f, -0.16180722f, -0.11293924f, -0.22455043f, 0.04396854f, 0.06792440f, 0.00086168f, -0.01535948f, 
    -0.00866685f, 0.10276198f, -0.00650502f, 0.07654663f, -0.12288272f, 0.03576358f, -0.02828812f, 0.18147662f, 
    0.09818551f, 0.01774380f, 0.00855246f, 0.01353633f, -0.00886215f, -0.05684761f, 0.00207072f, -0.15633467f, 
    -0.12823325f, -0.08383570f, 0.03551402f, 0.02740147f, 0.18995228f, 0.15303367f, 0.05462620f, 0.12319151f, 
    0.03879229f, 0.01139763f, -0.01710441f, 0.07508137f, 0.28945494f, 0.17146675f, 0.20908208f, -0.07365090f, 
    -0.04048420f, 0.10420763f, -0.01486804f, -0.01199835f, -0.01095316f, -0.07748577f, 0.04810706f, -0.09756148f, 
    -0.06776379f, -0.00052616f, 0.10962614f, -0.00782807f, 0.00735705f, -0.01380028f, 0.01817156f, -0.01605492f, 
    -0.10116974f, 0.01507047f, 0.00193397f, 0.15821129f, 0.05979237f, 0.22932217f, 0.15571222f, 0.02207968f, 
    -0.16419113f, 0.02941898f, 0.01795859f, 0.08349277f, 0.03387552f, 0.00765237f, -0.03610766f, 0.01810081f, 
    -0.13675348f, -0.04553056f, 0.00450561f, -0.10399676f, 0.00846246f, 0.10140269f, 0.10035713f, 0.07739345f, 
    0.03403075f, 0.05316989f, 0.03398463f, 0.05374051f, -0.04992530f, 0.16247526f, 0.11375650f, -0.14492744f, 
    0.00584433f, 0.06742862f, -0.07079542f, -0.14131168f, 0.14872575f, -0.02078827f, 0.01925513f, -0.16983658f, 
    -0.08777871f, 0.00562837f, 0.02257336f, -0.12471060f, 0.02145543f, 0.09885210f, 0.03236041f, -0.07673075f, 
    0.00339618f, 0.01376458f, -0.08922269f, -0.02930678f, 0.11981585f, 0.18547490f, 0.26556778f, -0.27876765f, 
    -0.15535851f, 0.02329834f, 0.03764868f, 0.07203216f, -0.00026163f, -0.06906803f, 0.00653010f, -0.04936457f, 
    0.03551747f, 0.16640341f, 0.17848033f, 0.00513610f, -0.02850810f, -0.06928928f, 0.11821529f, 0.10169032f, 
    0.04333224f, 0.07120148f, -0.08219827f, 0.14828859f, -0.11047320f, -0.05716452f, 0.08586960f, 0.02923277f, 
    -0.10936452f, 0.05333588f, -0.04140783f, 0.09891108f, -0.05637938f, -0.01639621f, -0.04104583f, -0.02163818f, 
    0.12230391f, 0.07036848f, -0.22336803f, -0.09321982f, -0.00553345f, 0.04160139f, -0.06870613f, 0.06285760f, 
    0.02640038f, 0.10158253f, 0.02181340f, -0.08790361f, -0.05520535f, -0.09547975f, 0.00570647f, 0.12395358f, 
    0.03217296f, 0.05949473f, 0.04408253f, 0.00708379f, 0.07013477f, -0.07455333f, 0.02032266f, -0.02138478f, 
    -0.24695083f, -0.00449064f, 0.16162431f, 0.06019406f, -0.02660408f, 0.00417005f, 0.11634685f, 0.07396062f, 
    0.06559511f, 0.09408848f, -0.03938334f, 0.08626621f, 0.20109729f, -0.03504191f, -0.18300585f, 0.24983315f, 
    0.04018405f, 0.13649803f, -0.03019552f, -0.00019234f, 0.05783698f, 0.05866443f, -0.00059282f, 0.04569149f, 
    0.13220847f, 0.16605274f, 0.12427196f, -0.08074814f, -0.05836663f, -0.07606930f, -0.06263169f, 0.08261333f, 
    -0.04286684f, -0.06748750f, -0.01071773f, -0.00431567f, 0.18345213f, 0.19181100f, 0.24234235f, 0.26135767f, 
    -0.03309542f, 0.08223535f, 0.10433973f, -0.09377360f, 0.01657490f, -0.04981160f, 0.04328915f, -0.04345649f, 
    -0.04996783f, 0.16236241f, 0.04869313f, 0.02628693f, 0.05827976f, -0.03715194f, 0.19244258f, 0.04901130f, 
    0.00911711f, 0.01618762f, 0.10448723f, -0.00945126f, 0.19962767f, 0.16011550f, 0.12846087f, 0.15273620f, 
    0.00399655f, -0.04507893f, 0.10972821f, -0.11929652f, 0.09936783f, 0.10032421f, -0.00814693f, 0.17912562f, 
    -0.09715741f, -0.07057659f, -0.00456914f, 0.06734657f, 0.01149323f, -0.04183064f, 0.00811556f, 0.02025513f, 
    0.02581728f, -0.09654047f, -0.03444718f, 0.11550806f, 0.06037154f, 0.06608185f, 0.03302330f, 0.10796457f, 
    -0.01533910f, 0.23182075f, -0.03509379f, 0.04599323f, 0.01079413f, -0.02400388f, 0.03701935f, 0.09485525f, 
    0.08927487f, 0.18825120f, 0.09865355f, -0.03425267f, -0.02910631f, -0.02987702f, -0.03723247f, 0.07838725f, 
    -0.02496152f, 0.02956402f, -0.07539758f, 0.09954481f, -0.17803609f, -0.06575195f, 0.18433081f, -0.15540031f, 
    0.03783506f, 0.00461478f, 0.09980713f, -0.03671280f, -0.10378724f, -0.15551502f, 0.02006560f, 0.10612725f, 
    -0.03562990f, 0.12342083f, 0.03021891f, 0.04457000f, -0.06832656f, 0.04693469f, -0.05495615f, 0.07009472f, 
    0.07091435f, 0.01386435f, 0.03120579f, 0.11000242f, 0.21518813f, -0.01888746f, 0.14668317f, 0.15528414f, 
    -0.15521011f, -0.00141304f, 0.06197678f, -0.08985124f, 0.00751991f, 0.04746172f, -0.06796774f, -0.00810054f, 
    -0.12585489f, 0.04498534f, 0.15977710f, -0.14053045f, 0.08290236f, -0.00095413f, -0.00943601f, -0.06768638f, 
    -0.03560544f, 0.04631041f, -0.04825110f, -0.01867592f, -0.18299145f, -0.05879788f, -0.01887743f, 0.11655702f, 
    0.02040294f, 0.16373041f, -0.02035682f, 0.04160834f, 0.08980860f, -0.05336033f, 0.01772309f, -0.11044554f, 
    -0.09147470f, -0.01988993f, 0.08601329f, 0.00873751f, -0.01684115f, -0.02634341f, 0.01238808f, 0.02167396f, 
    -0.03815321f, 0.00279133f, -0.02142373f, 0.11313409f, -0.13262993f, 0.11992846f, -0.17194179f, 0.06803945f, 
    0.04047648f, 0.06437399f, -0.02202498f, 0.06440125f, -0.05942206f, 0.04871752f, -0.02153101f, -0.15621787f, 
    0.02785675f, 0.03529681f, 0.10779293f, 0.04391120f, 0.05692115f, -0.00180974f, 0.17658643f, 0.00203989f, 
    0.03817119f, -0.04373333f, 0.01389185f, 0.00544143f, 0.24451898f, 0.17155446f, 0.05384486f, 0.21523879f, 
    0.08350783f, -0.00091608f, 0.03932951f, 0.07267812f, 0.12117980f, 0.11402693f, -0.08697934f, -0.05326625f, 
    -0.15714754f, -0.07780459f, -0.13795191f, -0.04239899f, -0.02203039f, -0.01686616f, -0.02152255f, -0.12554879f, 
    0.18884309f, 0.04976733f, 0.11117334f, 0.04815019f, 0.28409755f, 0.14378053f, 0.17385890f, -0.21648908f, 
    -0.06991202f, 0.04430882f, 0.04119700f, -0.01231257f, -0.02930117f, 0.04552368f, 0.00526927f, 0.05239755f, 
    -0.08099348f, 0.08222939f, -0.03441675f, -0.11199792f, 0.05881910f, 0.08952784f, 0.00997436f, -0.00077912f, 
    0.06802160f, 0.01453971f, 0.05699006f, -0.06573714f, -0.27087542f, -0.03035941f, 0.03585517f, -0.00911368f, 
    0.04927152f, -0.03735162f, 0.02363491f, -0.02704874f, 0.11313640f, -0.04537532f, 0.10603930f, 0.10447625f, 
    -0.05160397f, -0.05370832f, 0.06162411f, -0.05457984f, 0.07315392f, -0.09879754f, 0.06495187f, -0.03033398f, 
    -0.01006862f, -0.05131778f, 0.03914661f, -0.04649013f, 0.24236837f, -0.03168447f, -0.07697666f, 0.23107040f, 
    -0.06707881f, 0.12857856f, -0.00992998f, 0.04010229f, -0.10851777f, -0.07065804f, 0.09090800f, -0.00993927f, 
    -0.23237833f, 0.01041064f, 0.00828069f, -0.19471890f, 0.13601710f, 0.16824365f, 0.02185239f, 0.18476558f, 
    0.13621092f, -0.01263537f, 0.05715976f, -0.00384390f, 0.11353604f, 0.03674592f, -0.12349012f, 0.00951097f, 
    0.01839588f, -0.01987807f, -0.03614476f, 0.04752591f, -0.14241236f, 0.04798998f, 0.00774654f, -0.11692113f, 
    -0.00490408f, 0.20292978f, 0.23351829f, 0.11113212f, 0.04678147f, 0.09732991f, 0.12060360f, -0.07901642f, 
    0.07276905f, 0.02173758f, 0.06218173f, 0.15151761f, -0.03943183f, -0.12766609f, 0.15830089f, 0.21114247f, 
    0.01052206f, 0.09947397f, 0.03779704f, 0.01834716f, -0.08109822f, -0.13420808f, 0.06485088f, 0.07520773f, 
    0.02224445f, -0.03348947f, 0.00604768f, -0.01090669f, 0.01885246f, 0.00501022f, 0.02003133f, -0.01773980f, 
    -0.02572872f, -0.02639716f, 0.01551519f, 0.00461783f, 0.01546356f, 0.00187686f, -0.00985081f, 0.01832333f, 
    0.00221757f, -0.03552974f, 0.01589945f, -0.00405711f, 0.02027575f, -0.01107240f, -0.02781999f, -0.00185866f, 
    0.01658147f, -0.01323024f, -0.00418255f, -0.01998018f, 0.02877624f, 0.02475129f, 0.01105256f, 0.00841168f, 
    0.01227888f, 0.01387664f, -0.02646689f, -0.00466551f, 0.00402072f, -0.01840950f, -0.00327783f, 0.00745092f, 
    -0.00661326f, 0.00322099f, -0.02532100f, 0.00926720f, -0.03639657f, -0.02554733f, -0.01221159f, 0.01426445f, 
    -0.03888875f, -0.01724943f, -0.03165020f, -0.03439409f, 0.02002079f, -0.03128728f, -0.02806554f, -0.02411960f, 
    0.01212397f, 0.02049845f, -0.00096398f, 0.01428324f, -0.03581065f, 0.00878146f, -0.01909156f, -0.03545713f, 
    -0.00964089f, -0.01737379f, -0.00359671f, 0.02319855f, -0.01015238f, -0.03965715f, 0.01129494f, -0.02043991f, 
    -0.04057655f, 0.00315279f, 0.01844660f, -0.01780661f, -0.01044854f, -0.02889106f, -0.00884359f, 0.01031532f, 
    -0.03768544f, 0.02393892f, -0.02834768f, -0.03032389f, 0.00152685f, 0.00336461f, -0.00478482f, -0.01220127f, 
    -0.03162205f, -0.03338869f, 0.01858173f, 0.01706224f, 0.01111529f, 0.00864016f, -0.03102069f, -0.01323547f, 
    -0.02164998f, 0.02519641f, -0.03320432f, 0.01104515f, -0.01630867f, 0.01111971f, -0.03747965f, -0.00102826f, 
    -0.04137816f, -0.02727885f, -0.02770999f, 0.00954147f, 0.01833661f, -0.02134454f, -0.00345097f, -0.04170331f, 
    -0.01319733f, -0.02483068f, 0.01285550f, -0.00932819f, -0.04025027f, -0.01619212f, -0.01745308f, 0.01955293f, 
    -0.01021739f, -0.02964353f, -0.03232280f, -0.03612111f, -0.02333022f, 0.02612484f, -0.02499700f, -0.03952704f, 
    -0.02581296f, 0.02042107f, -0.03416252f, 0.00535713f, -0.01104885f, 0.00000953f, 0.00333451f, 0.00648093f, 
    -0.00968192f, -0.04391444f, -0.00426927f, -0.03164865f, -0.01990090f, -0.03256685f, -0.00236915f, 0.01171887f, 
    0.02139780f, 0.00496586f, -0.01054491f, -0.03198327f, -0.03193649f, 0.00669230f, 0.00310457f, -0.01238291f, 
    -0.02874291f, 0.00757623f, -0.01804949f, -0.00133834f, -0.00484523f, -0.01208553f, -0.00350729f, -0.02241258f, 
    -0.00883728f, -0.01602553f, -0.04305967f, -0.03914952f, -0.00877560f, -0.02094460f, -0.03084949f, 0.00464820f, 
    -0.02259716f, -0.03879482f, -0.00297236f, -0.03429379f, 0.03107720f, 0.00848081f, -0.02361053f, -0.00691092f, 
    0.02004203f, -0.00072960f, 0.01943942f, -0.00885201f, -0.00431825f, 0.01976327f, -0.00898681f, -0.00609375f, 
    -0.03698576f, -0.00969683f, -0.03035191f, -0.01504938f, 0.00898592f, -0.02538168f, 0.01467100f, 0.02591147f, 
    0.00375611f, -0.02137455f, -0.00774653f, -0.02687674f, -0.00883129f, -0.01107419f, -0.01015261f, -0.04068292f, 
    -0.03962855f, 0.02566599f, -0.02038574f, 0.02365193f, -0.02712404f, -0.00981012f, 0.02203557f, 0.00668989f, 
    0.01237021f, -0.04351941f, -0.03878870f, 0.00649274f, 0.02524626f, -0.02523991f, -0.03823421f, 0.01266520f, 
    0.02786312f, -0.00993347f, 0.01813359f, -0.02590234f, 0.02466294f, -0.00562516f, 0.00315065f, 0.00298293f, 
    -0.03479903f, 0.00441201f, -0.00749264f, 0.01944804f, -0.01115654f, 0.02056080f, -0.01747134f, 0.01251100f, 
    0.00302966f, 0.02499683f, 0.01234856f, -0.00560276f, -0.01737296f, 0.02439955f, 0.00905953f, 0.02681806f, 
    0.02084931f, 0.01612579f, -0.03573005f, 0.02563863f, -0.04275415f, 0.02208400f, 0.01005183f, 0.01619114f, 
    -0.02433499f, 0.00659103f, -0.03024972f, -0.03001877f, -0.02919835f, 0.02482175f, 0.00162167f, -0.03583749f, 
    0.00190399f, 0.01250625f, -0.00797016f, 0.02134204f, -0.03415518f, 0.01920446f, 0.01577204f, -0.04089968f, 
    0.02177850f, -0.03967988f, 0.01528200f, -0.00705916f, 0.01657851f, 0.01082868f, 0.01154730f, -0.01992392f, 
    -0.00106869f, -0.01969054f, -0.02262977f, -0.01264935f, -0.02989219f, -0.00223639f, -0.02124989f, -0.01363999f, 
    0.00546748f, -0.02557548f, -0.00568148f, -0.02437740f, -0.00990690f, 0.00189987f, 0.02596598f, 0.02251607f, 
    0.01763943f, -0.04186969f, 0.01722612f, 0.00870818f, -0.00982652f, -0.03006975f, -0.03938414f, -0.01497000f, 
    -0.01641899f, 0.01777364f, -0.03118717f, 0.01348804f, -0.01498470f, 0.00329631f, 0.01486270f, 0.02509438f, 
    0.00639745f, -0.02515606f, -0.04264282f, -0.03751025f, -0.02013379f, -0.02133371f, 0.01344477f, 0.01086561f, 
    -0.02331929f, -0.00353006f, 0.02707585f, 0.00035183f, -0.01970823f, 0.02656764f, -0.02427255f, -0.02730620f, 
    -0.03057528f, 0.00694898f, 0.00350075f, -0.04358821f, 0.01948682f, 0.02401972f, -0.02621587f, 0.02439166f, 
    -0.03725163f, 0.00064849f, 0.02101288f, -0.01846382f, -0.04577562f, -0.03316797f, 0.02397077f, 0.01093877f, 
    -0.02253263f, -0.02435151f, 0.02134727f, 0.01847253f, -0.00389009f, -0.02135010f, -0.02948521f, -0.00714283f, 
    0.02495470f, 0.02584050f, -0.02485660f, -0.03545437f, -0.01171716f, 0.01301614f, -0.04212135f, 0.01726455f, 
    -0.02540386f, 0.01027767f, -0.01266654f, -0.04327893f, -0.02778022f, -0.02770430f, -0.02722994f, -0.00211442f, 
    0.00228097f, -0.01541875f, -0.03566140f, -0.01150166f, -0.00923453f, 0.01876685f, 0.00817916f, -0.03129444f, 
    0.01654570f, 0.00221344f, -0.02544717f, 0.01904684f, 0.02156310f, 0.01846363f, -0.01005521f, -0.03864279f, 
    0.01967643f, -0.01793387f, -0.02665771f, -0.03419884f, 0.00200001f, -0.01813205f, -0.01704681f, -0.01033717f, 
    -0.00287332f, -0.00157817f, -0.02760290f, -0.00376796f, 0.01280770f, -0.02938260f, -0.03748480f, -0.03989765f, 
    0.02642029f, 0.01748861f, -0.03342488f, 0.01968270f, -0.02813344f, -0.03921610f, 0.02608618f, 0.01556921f, 
    -0.04015197f, -0.02479016f, -0.02262757f, -0.03070610f, -0.02398241f, -0.03652783f, 0.01861681f, -0.02898743f, 
    -0.02899863f, -0.03103779f, 0.00294617f, 0.02047377f, -0.01718467f, 0.02222861f, 0.00011212f, -0.00769071f, 
    0.02172612f, -0.04303756f, 0.01615463f, 0.01236617f, 0.01575886f, 0.02102909f, 0.00913820f, 0.01413507f, 
    -0.01128986f, 0.01171351f, -0.00044599f, -0.01404052f, 0.02794335f, -0.02400991f, 0.01863049f, -0.00643783f, 
    -0.02365643f, -0.03647192f, 0.02522421f, -0.02917924f, -0.04040490f, 0.01771781f, -0.00295539f, -0.04269743f, 
    -0.02862218f, -0.03925585f, -0.02292863f, -0.03376816f, -0.02694047f, -0.02945511f, -0.01343206f, 0.02687087f, 
    -0.01905450f, -0.01026501f, -0.00159057f, -0.01912045f, 0.00789322f, -0.01819836f, -0.01587969f, 0.00804044f, 
    0.02463083f, 0.01155168f, 0.02433930f, 0.00787469f, 0.00701329f, -0.02995659f, -0.01073831f, -0.01966291f, 
    0.01714618f, -0.00610137f, 0.02490520f, -0.04460692f, 0.00605087f, -0.00244496f, -0.01634706f, 0.01403364f, 
    -0.03377082f, -0.02360698f, -0.02312852f, 0.01647387f, 0.01345415f, 0.02117437f, -0.00352571f, 0.01515687f, 
    -0.00792207f, -0.01732051f, 0.00273506f, 0.01010184f, 0.02361023f, 0.00812505f, 0.02514101f, -0.01254348f, 
    0.00955787f, -0.03067678f, -0.03819208f, -0.00085569f, -0.01185129f, -0.03496195f, -0.02137556f, 0.02826921f, 
    -0.03249291f, -0.02827585f, -0.04251040f, 0.01273230f, 0.01186954f, -0.01988802f, 0.00136095f, -0.01805045f, 
    -0.03905594f, -0.02729587f, 0.02529730f, -0.03396119f, 0.00109877f, -0.02453316f, 0.01754885f, -0.00454237f, 
    0.00996316f, -0.03022806f, -0.00735145f, -0.03170385f, -0.01207061f, 0.01288760f, -0.02320570f, 0.00280250f, 
    0.02205569f, 0.02314307f, 0.02903588f, -0.02437589f, -0.03130447f, 0.01193650f, -0.00116375f, -0.00893081f, 
    -0.00764670f, 0.01576066f, -0.02823603f, 0.02032489f, -0.03580599f, 0.01944353f, -0.04062404f, 0.01850302f, 
    -0.02230909f, -0.03379503f, 0.01324836f, 0.01824714f, -0.00418604f, 0.01875547f, -0.02643430f, -0.03052384f, 
    -0.02026928f, 0.02144791f, -0.01798678f, 0.02267457f, -0.01304667f, -0.01996255f, 0.01185626f, -0.00456017f, 
    0.01953126f, 0.02072352f, -0.02838300f, 0.02848751f, -0.02730589f, -0.04294864f, 0.02553868f, -0.00050649f, 
    0.01659396f, -0.02080880f, -0.00195776f, -0.04433926f, -0.04209010f, -0.01718769f, -0.00495027f, -0.03289666f, 
    -0.02484120f, 0.01877063f, 0.01055541f, -0.03681113f, -0.02049043f, -0.03590051f, -0.00434957f, 0.00017541f, 
    0.02020563f, -0.01595940f, 0.01908889f, -0.03323963f, 0.00191722f, -0.02676430f, -0.00678577f, -0.02446986f, 
    0.01240521f, -0.03610697f, -0.03592243f, 0.00969020f, -0.01829002f, 0.00682893f, -0.01731909f, -0.02903241f, 
    -0.02352138f, 0.02371399f, -0.01395299f, -0.03028402f, 0.01654639f, -0.00824265f, -0.04244901f, 0.01633337f, 
    0.02016257f, 0.00645592f, -0.04304609f, -0.04024734f, -0.01251467f, -0.02844516f, 0.00841485f, 0.00041312f, 
    -0.00519788f, -0.00831897f, -0.00588140f, 0.00428035f, -0.02802547f, -0.03022100f, -0.01592973f, -0.01776313f, 
    0.02344771f, 0.01942878f, 0.02807743f, -0.00576408f, 0.01417306f, -0.01592234f, -0.01577441f, 0.02102588f, 
    0.02290121f, -0.00085136f, -0.04507065f, -0.00134442f, -0.01462966f, 0.02073000f, -0.03302271f, 0.01548950f, 
    0.02396793f, 0.01441910f, -0.02299391f, -0.00330446f, -0.01230184f, -0.00308373f, -0.01079477f, 0.02218344f, 
    0.00447198f, 0.01773084f, -0.02016453f, -0.00105075f, 0.01953093f, -0.03880429f, 0.00970390f, -0.03448498f, 
    -0.00737005f, 0.00363289f, 0.02071783f, -0.02197718f, 0.01365640f, -0.02024411f, 0.01836653f, 0.00947206f, 
    -0.01060118f, -0.01275828f, -0.01451760f, -0.01442744f, 0.03517723f, 0.00307408f, 0.00535744f, -0.01070930f, 
    0.00881303f, -0.02551331f, -0.03677861f, -0.00130515f, 0.00104741f, 0.02300117f, 0.00313475f, -0.01155735f, 
    -0.00694960f, 0.02096213f, 0.01973692f, -0.03108055f, -0.00098018f, -0.00097306f, 0.01332088f, 0.02142549f, 
    0.01821466f, -0.02733142f, -0.01045513f, 0.01152739f, -0.00368479f, 0.00988338f, -0.00065888f, -0.01690388f, 
    -0.01952197f, 0.02285244f, -0.01544947f, 0.00617367f, 0.00313628f, -0.04264970f, 0.01865760f, 0.00012165f, 
    -0.02221976f, 0.01221236f, 0.00721437f, -0.02582818f, -0.00397450f, -0.02059263f, 0.02516882f, 0.00494006f, 
    -0.00916359f, 0.01861463f, 0.00235466f, -0.02756990f, -0.02782725f, 0.02564809f, -0.00976943f, -0.02077302f, 
    -0.01845534f, 0.01022159f, 0.01998058f, -0.01745334f, 0.01545555f, -0.02285144f, -0.00190459f, -0.00122067f, 
    0.01978422f, -0.01844527f, -0.03802844f, -0.01863819f, -0.03114841f, -0.03726517f, 0.01467750f, -0.03951607f, 
    -0.00311772f, -0.02092840f, 0.01982280f, -0.01751290f, -0.02875047f, -0.00551433f, -0.01203873f, -0.01810328f, 
    -0.04335889f, -0.02297699f, -0.02555236f, -0.00856002f, 0.01832943f, -0.01080057f, -0.01283858f, 0.01404815f, 
    0.02550730f, -0.04088518f, -0.01185196f, 0.00830257f, -0.04040394f, 0.01207679f, -0.03535779f, 0.00510381f, 
    -0.02792729f, 0.00681686f, -0.01397544f, -0.03337409f, -0.02446033f, -0.03384305f, -0.02641324f, -0.03618319f, 
    -0.02197878f, 0.00055757f, -0.03617943f, -0.04117715f, 0.00561042f, -0.00079235f, -0.03566960f, -0.00231343f, 
    0.05716317f, 0.07626134f, 0.13548067f, -0.08116180f, -0.00866746f, -0.03393826f, 0.00569950f, -0.02036068f, 
    0.03321308f, 0.07104002f, 0.03472615f, 0.11965504f, -0.11922506f, -0.00104929f, -0.00545812f, -0.14469384f, 
    0.02976590f, 0.08604642f, 0.05398673f, -0.01971081f, 0.14702030f, 0.01090849f, -0.09188341f, 0.05183986f, 
    -0.15021443f, -0.00099635f, 0.03866974f, -0.08970247f, -0.00159858f, 0.04955418f, -0.02393101f, 0.06087060f, 
    -0.03036533f, -0.00552711f, 0.04547876f, 0.01497959f, 0.23801494f, 0.02192988f, 0.06477110f, -0.17149910f, 
    0.07349829f, 0.06332870f, 0.00329764f, -0.04405858f, 0.08713061f, 0.04323523f, 0.06030328f, 0.07108618f, 
    0.20667967f, -0.17235349f, 0.04788799f, 0.28837249f, 0.04552907f, -0.14044331f, 0.01507664f, 0.03144615f, 
    -0.05669759f, 0.10298050f, -0.03404003f, -0.00964837f, 0.21193068f, 0.00912013f, 0.05075239f, -0.06011364f, 
    0.04171810f, 0.04912535f, -0.05268699f, 0.12655647f, -0.03215835f, 0.08620396f, 0.03454098f, 0.00934087f, 
    0.09709961f, -0.09070984f, -0.04317391f, -0.15025526f, -0.02948619f, 0.02632610f, 0.03442274f, -0.01193195f, 
    0.04753925f, 0.17010707f, 0.02176488f, 0.09091166f, 0.34600028f, 0.16160636f, 0.13750905f, -0.07448899f, 
    0.01810630f, -0.04224175f, 0.03556697f, -0.00476461f, 0.06836835f, 0.13143554f, 0.04569079f, 0.06140117f, 
    0.16354139f, 0.09022537f, -0.07567734f, 0.08921862f, 0.01625895f, -0.01231333f, -0.07581361f, 0.17988119f, 
    0.04333468f, -0.03879432f, -0.00791050f, 0.05305469f, -0.15894477f, 0.30759415f, 0.03874279f, -0.00453944f, 
    0.13900700f, 0.12440959f, 0.03971879f, 0.09154014f, -0.01095153f, -0.08851749f, 0.12448856f, 0.10894138f, 
    0.07609523f, 0.08099901f, -0.07283941f, -0.26867488f, -0.04174787f, -0.04089616f, 0.03819466f, 0.00748271f, 
    -0.04092932f, 0.11544447f, 0.09991665f, 0.03919556f, 0.18841673f, 0.03641341f, 0.18426418f, -0.33537945f, 
    -0.00169174f, -0.03520159f, 0.01959181f, -0.02192717f, -0.03044091f, -0.05486180f, 0.07345381f, 0.02601369f, 
    0.25279352f, -0.08010589f, -0.02771845f, -0.00271674f, -0.06972142f, -0.03283782f, 0.04702345f, 0.15936629f, 
    0.16481857f, -0.00775889f, 0.05232935f, 0.04861360f, -0.34606004f, 0.15939841f, -0.08555415f, 0.22948635f, 
    -0.16941248f, 0.12519886f, -0.00229049f, 0.01052800f, 0.03153548f, 0.06405792f, 0.04852579f, -0.05206204f, 
    -0.06703138f, -0.04572444f, -0.05547215f, 0.03058912f, 0.08786684f, 0.08698627f, -0.09790011f, 0.00872232f, 
    -0.01749012f, 0.05237896f, -0.09023353f, -0.01805327f, -0.15180552f, 0.02393648f, 0.09802007f, -0.09599346f, 
    0.18833818f, -0.12536639f, 0.05239584f, 0.04921412f, -0.00735312f, -0.00701332f, 0.02857565f, -0.06038975f, 
    0.18264951f, 0.09157878f, -0.05398176f, 0.03832623f, 0.01025319f, 0.02793024f, -0.10291237f, -0.00521137f, 
    0.03801132f, 0.05092755f, -0.11167158f, 0.05374716f, 0.14080690f, 0.00816448f, 0.06158925f, 0.06351299f, 
    -0.06229837f, -0.05280961f, 0.15044083f, 0.12623325f, 0.01566922f, 0.05200429f, 0.07114106f, -0.13427515f, 
    0.28325468f, 0.19268249f, 0.00769916f, -0.06284384f, -0.02518934f, -0.07379428f, -0.03438870f, 0.09974413f, 
    -0.07059925f, -0.05396673f, -0.06411315f, -0.02148308f, 0.08551565f, -0.00609203f, 0.04980825f, -0.13577844f, 
    0.07386239f, -0.03179860f, 0.03640248f, -0.08944740f, 0.09441840f, 0.01719818f, -0.02094847f, -0.04401025f, 
    0.16687693f, -0.11842112f, -0.06649978f, 0.06662860f, 0.05200445f, -0.15358195f, 0.06954596f, 0.10756742f, 
    -0.00982253f, -0.10262074f, -0.03870561f, 0.02158033f, 0.45903209f, -0.02799579f, -0.01067213f, -0.03997215f, 
    -0.08302119f, 0.01868929f, 0.12054716f, 0.02370725f, -0.02944513f, 0.02692201f, -0.07024118f, -0.00121069f, 
    0.40364334f, 0.18315282f, 0.02060468f, 0.11470401f, 0.02772228f, -0.01341082f, -0.06011560f, 0.04203036f, 
    0.09389975f, -0.04656366f, 0.04828558f, 0.04846840f, 0.13155152f, -0.15808395f, 0.17924896f, -0.23496465f, 
    -0.03543026f, -0.05928057f, 0.00607517f, 0.09935949f, -0.02581837f, -0.00507863f, 0.03903968f, 0.16005288f, 
    0.19072877f, 0.05430370f, -0.03943072f, 0.04292174f, -0.05083879f, -0.00304000f, -0.07383910f, 0.00621417f, 
    0.09570748f, 0.08541652f, 0.01500414f, -0.02925097f, -0.09449993f, -0.19462192f, -0.22809534f, 0.01839693f, 
    0.02566027f, -0.00688601f, -0.01688000f, 0.01398610f, -0.02566594f, 0.05657534f, -0.02623332f, 0.08568119f, 
    0.01838274f, 0.01090598f, 0.02107372f, -0.16428454f, 0.00025795f, 0.10228831f, 0.02592135f, 0.04388866f, 
    0.08953644f, 0.00373069f, -0.02837363f, -0.09910547f, -0.02608284f, -0.18680112f, -0.01865195f, -0.18427163f, 
    0.10296126f, -0.00844641f, 0.06165627f, -0.01533217f, -0.00643492f, 0.04941425f, 0.01994596f, -0.00861357f, 
    0.31802881f, 0.06253976f, -0.07241878f, 0.13719203f, 0.00179759f, -0.05857135f, -0.05330645f, 0.01652320f, 
    0.03070917f, 0.01297239f, -0.03643379f, 0.00305506f, 0.16054040f, -0.06313209f, -0.10886155f, 0.23037240f, 
    0.03010185f, 0.04313362f, 0.00541546f, 0.17432222f, -0.10420527f, 0.00962945f, 0.03328163f, 0.09229898f, 
    0.11236560f, 0.03683292f, -0.07493686f, 0.17279394f, 0.12385309f, -0.05124757f, 0.01699908f, 0.13513933f, 
    0.08368450f, -0.00866072f, 0.05855771f, 0.07935068f, -0.08217817f, -0.09557927f, -0.12608239f, 0.10284331f, 
    0.10973510f, 0.05968658f, 0.01756346f, -0.05200808f, -0.00401345f, 0.09054370f, 0.00629128f, 0.07698291f, 
    -0.08122908f, -0.05035035f, -0.06575943f, 0.05449192f, 0.04872809f, 0.08932848f, -0.05782461f, -0.05926364f, 
    -0.06218548f, -0.04412158f, 0.06705490f, -0.13239832f, 0.06742241f, 0.07360604f, 0.00845973f, -0.00554114f, 
    0.17268877f, 0.04276404f, 0.04791545f, 0.01151124f, 0.03352042f, 0.02623314f, 0.08769538f, 0.10675717f, 
    -0.07455679f, -0.09538359f, 0.14612199f, 0.08354878f, 0.11932956f, 0.05139259f, 0.10655578f, -0.03509980f, 
    0.06071996f, -0.08872489f, 0.07011078f, 0.10278033f, 0.02336389f, 0.12009506f, 0.06910349f, -0.13291651f, 
    0.12323212f, -0.02527382f, -0.04295120f, 0.03956751f, -0.01217383f, 0.14006272f, 0.01154839f, 0.08956319f, 
    0.29585806f, -0.01998680f, -0.02492712f, -0.01881486f, 0.02131674f, -0.00193666f, 0.00628963f, -0.06874707f, 
    0.01123299f, -0.09009055f, -0.00349183f, -0.02085562f, -0.11141933f, -0.00524642f, 0.24969564f, -0.27745351f, 
    -0.13642646f, -0.07765071f, 0.07386557f, 0.08487158f, -0.03068393f, 0.03479845f, 0.04761602f, -0.03650057f, 
    -0.12858130f, -0.10730497f, -0.07575746f, 0.02586559f, 0.01396415f, 0.07213237f, 0.05872843f, -0.04789528f, 
    0.01170544f, 0.02256959f, 0.01729720f, 0.02416288f, -0.11132175f, -0.18232076f, -0.17478199f, -0.21890764f, 
    -0.04182721f, -0.03734574f, -0.07796304f, 0.10787024f, -0.01838254f, 0.07971453f, -0.03496780f, 0.07414202f, 
    -0.03976631f, -0.15037182f, -0.03197479f, 0.08041184f, -0.06439304f, 0.07319152f, -0.06036632f, -0.01839397f, 
    -0.00530734f, -0.01497664f, -0.04406621f, 0.10145167f, -0.15270373f, -0.14359291f, 0.02500040f, -0.05287775f, 
    0.05841872f, 0.07447308f, -0.01933903f, 0.11158168f, -0.04253989f, -0.12302597f, -0.03355438f, -0.09166641f, 
    0.10670594f, 0.12131036f, 0.03531935f, -0.00339120f, 0.02978766f, 0.08669458f, 0.04368417f, 0.04605780f, 
    0.04782924f, 0.09544929f, 0.09680268f, -0.02968205f, 0.08142409f, -0.24267705f, 0.10555197f, -0.03974792f, 
    0.05621997f, -0.13461138f, 0.13426383f, 0.04292359f, -0.04897972f, 0.05211356f, -0.04652109f, 0.02664030f, 
    -0.20391619f, -0.11033850f, -0.04196455f, 0.02821586f, 0.00034861f, 0.09792673f, 0.05591285f, 0.03625588f, 
    0.01502054f, -0.01003958f, 0.03404945f, -0.00568440f, 0.24038769f, 0.13017884f, -0.19969319f, 0.16164285f, 
    0.00791158f, 0.10289989f, -0.09141970f, 0.10177787f, 0.19501525f, 0.21976914f, -0.00522395f, -0.01738091f, 
    0.01600687f, -0.02468541f, 0.13449740f, -0.02225997f, 0.01079400f, -0.01176950f, 0.08687691f, -0.05812425f, 
    -0.04886332f, -0.03813141f, 0.05168763f, -0.11776333f, -0.17247294f, 0.01453917f, 0.01711347f, -0.11201832f, 
    0.20802894f, -0.04189640f, 0.00770441f, 0.17047252f, 0.02654573f, -0.02502756f, 0.11087849f, 0.03697645f, 
    0.34888127f, 0.05169667f, -0.16715945f, 0.15540466f, -0.11385772f, 0.05427057f, -0.03717514f, 0.12100781f, 
    0.05246091f, 0.06797971f, 0.13999641f, 0.00712214f, 0.17434449f, 0.05668245f, 0.02860855f, -0.13976975f, 
    -0.01500857f, -0.01771002f, 0.12726502f, 0.02431182f, -0.05661345f, 0.09161064f, 0.02334727f, 0.13711835f, 
    0.31150496f, 0.07843732f, -0.03444961f, 0.11866031f, 0.09529058f, 0.09767210f, 0.08344121f, -0.00383010f, 
    0.12886196f, 0.01735368f, -0.01189355f, -0.08134975f, 0.13590527f, -0.26719192f, 0.17539831f, -0.04900958f, 
    0.01142557f, -0.01730037f, 0.09740756f, -0.00830698f, 0.10543249f, -0.00975526f, 0.10770320f, 0.16156061f, 
    0.12204235f, -0.03343441f, -0.06903686f, 0.03009645f, -0.01078576f, 0.06550691f, -0.03976358f, -0.06381111f, 
    0.06072970f, 0.06841188f, 0.08849987f, 0.03613763f, -0.19575642f, -0.07373808f, 0.14677455f, -0.08460659f, 
    0.05723326f, 0.06836434f, 0.07652464f, 0.00131688f, -0.07405335f, -0.09209213f, 0.09529946f, 0.05094940f, 
    0.28796846f, 0.11324496f, 0.04080327f, -0.06352948f, 0.01770645f, -0.02141135f, -0.01828840f, 0.19356488f, 
    -0.04052185f, 0.01939042f, -0.02069134f, 0.05614456f, -0.08882245f, -0.06498670f, -0.16130458f, 0.06954232f, 
    -0.04990846f, 0.00126873f, -0.00054373f, 0.01970703f, 0.05174528f, -0.00195753f, 0.07107702f, -0.03079756f, 
    0.07284640f, -0.01796484f, -0.13972077f, 0.28943548f, 0.02227145f, -0.04026758f, 0.04699287f, 0.12051740f, 
    0.05536639f, 0.03033249f, 0.00281134f, 0.09056441f, 0.34709695f, 0.17880464f, -0.04238382f, 0.12592699f, 
    -0.00146383f, 0.01484080f, -0.12758133f, 0.08686178f, -0.02069441f, 0.07997271f, -0.06726611f, -0.02691459f, 
    0.18269679f, 0.01245219f, -0.07013181f, 0.14426035f, -0.10038911f, 0.14435117f, 0.00411561f, -0.02846473f, 
    0.02750940f, 0.05948434f, -0.00615445f, 0.02032165f, -0.30441901f, 0.10688295f, 0.17382461f, -0.20912564f, 
    0.09567116f, 0.02259514f, 0.05142104f, -0.01580036f, 0.06756921f, 0.12921473f, -0.01977860f, 0.03053132f, 
    0.39501497f, -0.01646548f, -0.00601466f, 0.21934293f, -0.03196011f, -0.05853714f, 0.02137161f, -0.05390254f, 
    -0.14320669f, 0.00388491f, -0.03195944f, 0.09138928f, -0.19101310f, -0.18240190f, 0.22456113f, -0.01957027f, 
    0.09353817f, 0.07044149f, 0.14187613f, 0.01054434f, 0.10819986f, -0.00255542f, 0.04965659f, 0.13031733f, 
    -0.00906488f, -0.11521885f, -0.19019964f, 0.08548693f, 0.00792677f, -0.06627389f, -0.06052331f, 0.10380475f, 
    -0.00748993f, 0.06186698f, 0.02342207f, -0.07171714f, 0.11878707f, 0.16295353f, -0.03050958f, -0.29676473f, 
    0.03242774f, -0.07185507f, -0.02792244f, -0.01417682f, 0.08199842f, 0.10544489f, -0.02496794f, -0.04297465f, 
    -0.05066320f, -0.02072866f, -0.04527264f, -0.11291682f, 0.07670905f, 0.11790777f, -0.00152978f, -0.09411315f, 
    -0.06273842f, -0.08465385f, -0.02546017f, 0.01379758f, -0.01138750f, 0.10300118f, 0.09162445f, 0.15062802f, 
    0.00551640f, 0.00356463f, 0.02961058f, -0.01858620f, -0.01592543f, 0.01662213f, 0.11804965f, -0.01195138f, 
    0.00475060f, -0.14154077f, 0.00920453f, 0.22121824f, -0.04167547f, 0.03953204f, 0.06141311f, 0.03303946f, 
    0.13650744f, -0.15839474f, -0.01311574f, 0.06260362f, -0.07344411f, 0.15979089f, -0.12955536f, 0.20115975f, 
    -0.06174169f, 0.01183670f, -0.06691553f, 0.02060105f, 0.03598604f, -0.04698502f, -0.05208199f, -0.00324497f, 
    0.25953215f, 0.11425371f, 0.04185689f, -0.04576160f, 0.02665459f, 0.01220031f, -0.00551002f, -0.06084651f, 
    0.02931730f, -0.04603961f, -0.01749024f, 0.06091888f, -0.07688032f, -0.17894125f, 0.07309201f, 0.03847266f, 
    0.02279853f, -0.03122635f, 0.05832809f, -0.11365701f, 0.01398902f, -0.02200130f, 0.06593334f, -0.00849533f, 
    0.01472530f, 0.08466025f, -0.09244544f, 0.00808463f, 0.02895461f, -0.00805009f, 0.01376859f, -0.02154179f, 
    -0.03304999f, -0.05016904f, 0.03641259f, -0.19800417f, -0.14900562f, -0.01370970f, -0.10982113f, 0.05858750f, 
    0.04705327f, -0.00960427f, -0.11242676f, -0.07869000f, -0.01976242f, -0.02400572f, -0.06630237f, -0.07520288f, 
    -0.15843086f, -0.04637999f, 0.01071148f, -0.03596793f, -0.03427202f, 0.04997140f, -0.05671036f, 0.07360697f, 
    -0.06677704f, 0.03267860f, -0.03728046f, 0.00576165f, -0.00432928f, -0.26344168f, 0.00102096f, 0.17047766f, 
    -0.01141308f, -0.01306014f, 0.04987689f, 0.04314932f, 0.03634118f, 0.03041306f, -0.07261854f, -0.06499225f, 
    -0.10213823f, 0.13388562f, 0.08183033f, 0.15196149f, -0.05896699f, 0.09048740f, 0.01457883f, -0.09791209f, 
    -0.00664974f, -0.02341218f, -0.05678500f, -0.00291717f, -0.14192688f, -0.03108539f, -0.02299112f, 0.24566048f, 
    0.05091121f, 0.09296115f, 0.01030965f, 0.06991298f, -0.04745053f, 0.00108265f, 0.00754728f, 0.00732037f, 
    -0.11859465f, 0.09088172f, 0.02288059f, 0.00365725f, -0.01473182f, 0.07138649f, -0.12983537f, -0.01436199f, 
    -0.01941971f, 0.04481968f, -0.07951561f, 0.11785404f, -0.07765654f, -0.09227331f, 0.17210174f, 0.15391038f, 
    0.13057506f, -0.00579041f, -0.02336219f, -0.02938604f, -0.04445188f, -0.01640609f, 0.03143721f, -0.02589742f, 
    0.00549254f, -0.08159322f, 0.07363810f, 0.27960211f, -0.01824713f, 0.01606132f, 0.09742394f, 0.01945287f, 
    0.05850147f, -0.03654624f, -0.08594611f, 0.15521407f, 0.47828412f, 0.24436304f, -0.00398882f, -0.03070982f, 
    -0.05139885f, 0.01069864f, -0.03204674f, 0.01045976f, 0.06065682f, 0.03732016f, -0.03211608f, 0.07406560f, 
    -0.33960524f, 0.02324018f, 0.07729844f, -0.07115088f, 0.02277436f, -0.11185454f, 0.02304056f, 0.02230838f, 
    -0.06974149f, -0.09245631f, 0.09906787f, -0.00894367f, 0.02566994f, 0.00415720f, 0.07978158f, 0.06030872f, 
    0.05828251f, -0.00566664f, -0.03440594f, -0.06090347f, 0.08958670f, -0.04260382f, -0.04681478f, 0.19258250f, 
    -0.11799794f, 0.17762810f, -0.05890153f, 0.15159109f, 0.02883036f, -0.03202405f, 0.05525900f, -0.08565386f, 
    0.04953858f, 0.04452796f, 0.02970350f, 0.04211474f, 0.10366648f, 0.12212452f, 0.00396753f, 0.14005126f, 
    -0.04925286f, 0.00044282f, -0.01781441f, 0.02100868f, 0.01738036f, -0.01853810f, 0.00616576f, 0.07909758f, 
    0.37070358f, -0.07881107f, 0.04198999f, 0.01814652f, -0.13120992f, 0.03003923f, -0.03538510f, -0.23366717f, 
    -0.04945626f, 0.03683677f, -0.01726622f, -0.07564940f, -0.04559580f, -0.05721983f, 0.15616140f, -0.01092989f, 
    0.04227928f, 0.03268517f, -0.13847043f, -0.06752113f, 0.07193080f, 0.01561574f, 0.03018805f, -0.03624288f, 
    -0.12749539f, -0.04190310f, -0.17898794f, -0.04160164f, -0.01939018f, -0.09412038f, -0.01233127f, 0.00618316f, 
    0.05370496f, -0.04223232f, -0.02853182f, -0.08536024f, 0.09180755f, -0.10585869f, -0.10092646f, -0.12439253f, 
    -0.09238929f, -0.01144978f, -0.02018151f, -0.00497911f, 0.04907040f, -0.04397380f, -0.01562649f, -0.07727837f, 
    -0.20824470f, -0.04212576f, 0.20429280f, 0.01286648f, 0.01193920f, 0.01134544f, 0.06590234f, 0.10666464f, 
    0.06356936f, 0.04377127f, -0.02524385f, 0.12605748f, 0.16686560f, -0.08185602f, 0.24430126f, 0.07912172f, 
    0.02102533f, 0.10170649f, 0.01972210f, -0.08104844f, 0.09006592f, 0.04443290f, -0.03259271f, 0.01587154f, 
    -0.27616504f, -0.08806806f, 0.15501718f, 0.34425989f, 0.14348802f, 0.02191869f, -0.07416117f, -0.02653965f, 
    0.02909701f, -0.00375103f, 0.05089780f, 0.13445164f, 0.16327776f, 0.04599969f, -0.02024900f, 0.08564340f, 
    -0.01477336f, 0.09128901f, 0.00732832f, -0.04689367f, -0.03413222f, -0.10818930f, 0.04011989f, 0.01621895f, 
    -0.43569967f, 0.06772000f, 0.02283149f, -0.14650448f, 0.01668683f, -0.00161988f, -0.00671835f, 0.05086984f, 
    -0.02905703f, 0.05855062f, 0.11129861f, -0.04750407f, -0.04500862f, 0.01279073f, -0.02168062f, -0.04726806f, 
    0.09121551f, -0.11138383f, 0.15497319f, -0.04945339f, 0.09470922f, -0.03656444f, 0.04044891f, 0.04719457f, 
    -0.11541309f, 0.09794731f, -0.01723264f, -0.09482018f, 0.01052483f, 0.07397380f, -0.04345878f, 0.00330323f, 
    -0.00822200f, 0.00208611f, 0.08500238f, -0.05042822f, 0.25940359f, -0.03935470f, 0.05603472f, 0.19560081f, 
    0.02577328f, -0.07626560f, 0.07929862f, 0.04107045f, -0.03720773f, -0.11281004f, -0.03580256f, -0.01860560f, 
    0.05535472f, 0.06625920f, 0.06375197f, 0.18292089f, 0.02001193f, -0.02610144f, -0.01454061f, 0.09371667f, 
    0.01509642f, 0.04639230f, 0.05035404f, 0.05992752f, 0.00557175f, -0.01490655f, 0.17065094f, 0.13779631f, 
    -0.14758737f, -0.09630612f, -0.00279740f, 0.06729829f, 0.00621884f, 0.06815675f, -0.00436521f, -0.01027293f, 
    0.20828019f, 0.12951489f, -0.13071744f, 0.04484979f, -0.03991015f, 0.08500337f, 0.02385021f, 0.05217174f, 
    0.07101814f, 0.03466525f, -0.04180160f, -0.01881105f, 0.07640827f, -0.03173646f, 0.09944282f, 0.09032550f, 
    0.07417184f, 0.03013564f, 0.01103700f, -0.01777674f, 0.11396447f, -0.08586805f, 0.03799266f, -0.02084871f, 
    -0.01907584f, 0.16687618f, 0.08739541f, 0.00330912f, -0.05017735f, 0.06820142f, -0.00112223f, -0.00182643f, 
    -0.00418249f, 0.05277173f, 0.06980243f, -0.09578390f, 0.02570844f, 0.06217586f, -0.10739403f, 0.18033235f, 
    0.04274648f, 0.10132761f, -0.01389453f, 0.09218803f, 0.04313408f, -0.04570765f, 0.01762382f, -0.01081697f, 
    0.19113094f, -0.03152588f, 0.04943833f, 0.01874673f, -0.01424814f, -0.00083918f, -0.04032451f, 0.02633688f, 
    -0.00985703f, -0.04599240f, 0.03444177f, 0.02089019f, 0.34066150f, 0.09588811f, 0.04306276f, 0.04563660f, 
    0.14053677f, 0.06453799f, 0.06109688f, -0.01299049f, -0.04617578f, -0.10614266f, 0.08689721f, -0.08167604f, 
    0.05486256f, 0.09523224f, -0.07120926f, 0.03626620f, -0.04330220f, -0.04308816f, -0.07657174f, 0.16847587f, 
    0.03690878f, -0.05515595f, 0.11242089f, -0.00374967f, 0.13467459f, 0.04523261f, -0.10776718f, 0.05324938f, 
    -0.03089270f, -0.01763429f, 0.04682785f, 0.04880684f, 0.04552424f, 0.06324276f, 0.10502836f, 0.06020319f, 
    0.08150774f, 0.20120856f, -0.23906374f, 0.01670431f, 0.06921446f, 0.01999593f, 0.03173477f, 0.10915878f, 
    0.01359436f, -0.00087214f, 0.02205726f, -0.01369913f, 0.28967431f, -0.05239390f, -0.16816695f, 0.11745660f, 
    -0.04105449f, 0.11511955f, 0.01222560f, -0.07730934f, 0.03440730f, -0.03562213f, -0.06993812f, 0.03502055f, 
    -0.07995949f, 0.05910851f, 0.08609378f, 0.13262816f, 0.04454266f, -0.03107696f, -0.01106577f, 0.04824226f, 
    0.07223560f, -0.09731025f, -0.00863081f, 0.07488749f, -0.04911460f, -0.10592162f, 0.04317100f, -0.01094589f, 
    -0.03853150f, -0.04907530f, 0.09959580f, -0.12297352f, -0.09751552f, -0.02734156f, 0.02454306f, -0.03572755f, 
    -0.05354851f, -0.12195141f, -0.16704929f, 0.06164498f, 0.14910610f, 0.01041501f, -0.04172388f, -0.01935404f, 
    0.04796490f, -0.04173992f, -0.06237938f, 0.10729910f, 0.23089799f, -0.04585267f, 0.01814307f, 0.10066361f, 
    -0.17745604f, -0.06836914f, 0.06067010f, -0.01747118f, 0.10529850f, 0.03569510f, 0.01334539f, -0.03955294f, 
    -0.46480229f, -0.09423249f, 0.28426403f, -0.07222626f, 0.11815377f, 0.02991471f, -0.05942646f, -0.00395834f, 
    0.01537579f, 0.02113515f, -0.01459435f, 0.03479442f, -0.16936488f, 0.08043177f, -0.01217592f, 0.02422065f, 
    0.02070618f, -0.04483510f, -0.14800334f, 0.01684618f, -0.05716772f, 0.00270433f, 0.03379208f, -0.01873840f, 
    -0.28017616f, 0.05265269f, 0.11776398f, -0.16781935f, -0.03618030f, -0.06775961f, -0.13382114f, -0.00340450f, 
    0.09463041f, -0.00733101f, 0.02127712f, 0.04632011f, 0.14771824f, 0.00024990f, -0.23898733f, 0.14325573f, 
    -0.01471150f, 0.11742251f, -0.04655147f, 0.08036955f, -0.03907331f, -0.06340150f, -0.07832798f, -0.15686484f, 
    -0.39573407f, 0.08047601f, 0.04728125f, 0.06909493f, -0.02152312f, 0.02823113f, 0.00511749f, 0.11392041f, 
    -0.07689707f, 0.00930630f, 0.01599078f, 0.01772437f, 0.15946923f, -0.04678236f, -0.02494782f, 0.02880964f, 
    -0.04104407f, 0.14043270f, 0.08434109f, 0.01385912f, 0.04933194f, 0.07708544f, 0.03273110f, 0.16743971f, 
    -0.12273633f, -0.02918332f, 0.02699123f, 0.16928425f, -0.04144301f, 0.07600998f, 0.02133197f, -0.09193798f, 
    0.08262966f, 0.00713793f, 0.08157884f, 0.01456565f, -0.18165708f, -0.13950332f, 0.27341238f, 0.24742202f, 
    0.15882224f, 0.11904116f, -0.02351800f, -0.11689846f, 0.08860431f, -0.03120953f, 0.04468440f, -0.00459188f, 
    -0.09443287f, -0.06568298f, -0.07256959f, -0.21697801f, -0.01886218f, -0.05598719f, 0.04265353f, -0.03491710f, 
    0.01684687f, 0.02213541f, 0.03185191f, 0.06092364f, -0.28610808f, -0.14275964f, 0.09271596f, -0.09292072f, 
    0.07950764f, 0.02221368f, 0.05543484f, -0.01796282f, -0.01944703f, -0.09568485f, -0.07998680f, 0.06554820f, 
    -0.24713862f, -0.11938589f, 0.07293604f, -0.07334869f, -0.04695617f, -0.03320612f, 0.08363064f, 0.05337467f, 
    -0.10439841f, 0.06002843f, -0.07786660f, -0.01483757f, 0.18175045f, 0.03524290f, -0.04706843f, 0.06981373f, 
    -0.04519873f, -0.05649993f, 0.00631476f, 0.06584972f, -0.07974982f, 0.09748211f, 0.11497585f, -0.09986002f, 
    -0.14601117f, -0.04523546f, 0.04689422f, 0.00101673f, 0.05878664f, -0.06424946f, -0.08044660f, 0.19877630f, 
    0.18474108f, 0.05457793f, 0.05300651f, -0.00154616f, 0.16368994f, -0.12249000f, -0.08372770f, 0.05929979f, 
    -0.13996796f, 0.01538956f, 0.00300547f, -0.04314021f, -0.00836993f, 0.03478704f, -0.04725146f, -0.01538575f, 
    0.07191005f, 0.23679017f, -0.02558803f, -0.00013571f, 0.04857403f, 0.17964678f, 0.11596859f, -0.00132199f, 
    -0.00560944f, -0.06219107f, 0.06564624f, 0.02676790f, -0.38255280f, 0.04496840f, 0.19854879f, 0.30015019f, 
    -0.01231098f, 0.10431428f, 0.07860812f, -0.01137583f, 0.08899640f, -0.05381914f, 0.04637543f, -0.00661874f, 
    -0.04470406f, 0.00680878f, -0.04217941f, 0.01365618f, -0.00266288f, -0.03664413f, -0.00526616f, 0.01906002f, 
    -0.02324627f, -0.04317603f, 0.00794735f, 0.01102420f, -0.01511590f, 0.00408090f, -0.00225129f, -0.02150915f, 
    0.02511942f, 0.01627761f, -0.00061369f, 0.02489218f, -0.00392350f, -0.04067424f, 0.00260282f, 0.01459471f, 
    -0.04305165f, -0.04376956f, -0.00945896f, -0.00515214f, -0.00942744f, -0.02377951f, 0.01111553f, 0.00611838f, 
    -0.02312750f, -0.00463540f, 0.02037876f, -0.03734916f, 0.00336496f, -0.00930846f, -0.00248753f, 0.02109989f, 
    -0.03408278f, 0.02492988f, -0.00431127f, 0.00936259f, 0.01622900f, -0.01105756f, 0.02050279f, -0.00895869f, 
    0.01003079f, 0.01394737f, -0.01556960f, 0.00437461f, -0.01576001f, 0.00177887f, 0.01512404f, -0.03596994f, 
    0.02497911f, -0.01802845f, -0.02051748f, -0.04292496f, 0.01068281f, -0.01858017f, 0.02200450f, -0.02322589f, 
    -0.02810814f, 0.00009475f, 0.02551354f, -0.00322485f, 0.01059884f, 0.02235465f, 0.00968517f, -0.01981546f, 
    -0.02187854f, 0.02165318f, -0.00976833f, -0.03905244f, 0.00836352f, -0.01603087f, -0.02816191f, 0.02368015f, 
    -0.03056197f, -0.03304467f, -0.01995150f, -0.03854531f, -0.01254191f, 0.01859113f, -0.02541894f, -0.03445918f, 
    -0.02236410f, 0.01237335f, 0.00776683f, 0.00020457f, -0.00551866f, -0.03511403f, 0.00382763f, 0.01321544f, 
    -0.02366821f, 0.00481550f, 0.01203512f, -0.00155303f, -0.02334478f, 0.02703092f, -0.02048293f, 0.00530429f, 
    0.00826204f, 0.01278396f, -0.00644135f, -0.02042967f, 0.02529951f, -0.02690790f, 0.00429445f, 0.02200120f, 
    0.02201809f, -0.01230435f, 0.02129943f, -0.02054681f, 0.01235478f, -0.02978224f, -0.02011018f, 0.02611312f, 
    -0.00759416f, 0.01133853f, 0.01773820f, 0.01146680f, -0.01159848f, -0.00413235f, 0.00201744f, 0.02485909f, 
    0.00677873f, -0.01548248f, 0.01624087f, -0.02669040f, -0.00138112f, 0.00024281f, -0.01700131f, 0.00185125f, 
    0.01875199f, -0.02712132f, -0.04108977f, -0.00860710f, -0.00618923f, 0.01624635f, 0.01768268f, -0.00206284f, 
    0.01746739f, -0.00218475f, -0.03508877f, -0.04145293f, 0.01922757f, -0.02259694f, -0.01916596f, -0.01088450f, 
    0.00912921f, -0.02292751f, -0.03372608f, -0.00338189f, -0.00879592f, -0.00997265f, -0.04338946f, -0.02273308f, 
    0.01533820f, -0.03729658f, -0.00447529f, -0.01580427f, 0.00855891f, -0.00109870f, -0.00334101f, -0.00183458f, 
    -0.01322467f, -0.03921947f, 0.00911040f, -0.03894743f, -0.03452676f, -0.00876058f, 0.01861109f, -0.04268457f, 
    -0.02108097f, 0.01653855f, -0.03348210f, 0.01551455f, 0.00016310f, -0.00672256f, -0.03722718f, -0.01021958f, 
    -0.01944917f, -0.00718748f, 0.01843029f, 0.02389030f, -0.00385614f, -0.04250640f, 0.00245716f, 0.01458407f, 
    0.00523537f, 0.01308099f, 0.02591682f, -0.01820437f, 0.01730696f, 0.02102475f, -0.01122925f, -0.00853522f, 
    -0.02829704f, -0.02195351f, -0.01211001f, -0.03601199f, -0.02831518f, 0.01113463f, 0.00473132f, -0.02162752f, 
    0.02195073f, -0.02096377f, -0.04293875f, -0.03079652f, -0.02036096f, 0.01049170f, 0.01439115f, -0.02733592f, 
    -0.02631503f, -0.02420747f, -0.03175297f, 0.00270976f, 0.02415533f, -0.03299432f, -0.01113355f, 0.00939701f, 
    0.02249526f, 0.00588707f, 0.02019391f, -0.01823646f, 0.00455814f, 0.01932383f, 0.01953375f, 0.00764731f, 
    -0.00047711f, 0.02593512f, -0.01360500f, 0.00406450f, -0.01972742f, 0.01553920f, 0.01098352f, -0.02717474f, 
    -0.01685943f, -0.03857263f, -0.02166653f, 0.01064273f, -0.00168266f, 0.01852397f, -0.03621759f, -0.02039272f, 
    -0.03872791f, -0.03979840f, -0.04561567f, 0.02600515f, -0.02844586f, 0.02015456f, -0.03160619f, 0.00560950f, 
    -0.00868701f, 0.00493674f, 0.01275496f, -0.03426729f, 0.02475277f, -0.03299422f, 0.01701339f, 0.01405588f, 
    -0.03832986f, 0.01949596f, -0.04246357f, -0.02572903f, 0.00798772f, -0.00471328f, -0.01986047f, -0.03189577f, 
    -0.02764599f, 0.00947239f, -0.02825262f, 0.01253805f, -0.03211107f, -0.00762903f, 0.02655014f, -0.00993776f, 
    -0.04330777f, -0.01393916f, -0.04434633f, 0.02297967f, 0.01469950f, 0.00906193f, -0.03849537f, -0.02682130f, 
    -0.00420711f, 0.02003478f, -0.02996838f, 0.01410800f, -0.04120402f, 0.01000643f, 0.03383456f, -0.00510611f, 
    -0.04315285f, 0.02020053f, -0.04295775f, 0.02430387f, 0.02903261f, -0.01391730f, -0.01778920f, -0.01729226f, 
    0.01165377f, -0.02879312f, -0.04544523f, 0.02336585f, -0.02596946f, -0.03372174f, -0.04018325f, 0.01343971f, 
    -0.02125693f, -0.01681946f, -0.00728980f, -0.02281626f, -0.04394967f, -0.01877514f, -0.00666222f, -0.00523245f, 
    -0.02564721f, 0.00380292f, -0.00783504f, 0.00866343f, 0.00990084f, -0.02904612f, -0.01779253f, -0.04407692f, 
    0.00308333f, -0.00266781f, 0.01096115f, 0.01099151f, -0.01429002f, -0.00370842f, -0.02766111f, -0.00961880f, 
    -0.01529131f, -0.00798180f, 0.01375346f, 0.00870444f, 0.00223578f, 0.00597839f, -0.03420064f, 0.01388902f, 
    0.01430897f, -0.02933404f, 0.01968314f, 0.02375953f, 0.00143783f, -0.02535991f, -0.03661124f, -0.04056928f, 
    -0.03318159f, 0.00260206f, 0.02613662f, 0.00775209f, -0.00741620f, -0.00974150f, -0.01735461f, -0.00664710f, 
    -0.02293459f, 0.01391724f, 0.00205215f, -0.00377587f, 0.02608639f, 0.00322890f, -0.01481903f, -0.03149553f, 
    -0.02942069f, 0.00796517f, 0.00902723f, -0.02179355f, -0.02442552f, -0.01264461f, -0.02261310f, -0.03482130f, 
    0.01120795f, 0.02653162f, -0.00180532f, 0.02447217f, -0.02322896f, -0.01424404f, -0.00922260f, 0.01376230f, 
    0.02552823f, 0.00992968f, -0.04302891f, 0.02444593f, -0.04146473f, -0.04178366f, -0.00877587f, -0.01220779f, 
    0.02838366f, -0.04464654f, 0.01852664f, 0.00095223f, -0.00876408f, 0.02033248f, -0.00260651f, -0.00345509f, 
    -0.03298935f, 0.02061626f, 0.02489092f, -0.03741614f, -0.00423775f, -0.01056561f, -0.02259021f, 0.02091099f, 
    -0.00880462f, 0.00669775f, 0.01581804f, -0.03903816f, -0.03601110f, -0.03701369f, 0.00381026f, -0.01901798f, 
    -0.02895151f, -0.02389881f, -0.04172352f, 0.02588170f, -0.02984336f, -0.00541309f, -0.03595455f, 0.02278214f, 
    0.00329938f, 0.01384404f, 0.01459678f, -0.03409389f, -0.03175384f, -0.00919882f, 0.01646432f, 0.02020266f, 
    0.01187497f, -0.00769139f, -0.00473974f, -0.03234332f, 0.02705226f, -0.04053063f, -0.00204284f, -0.02480103f, 
    0.01846523f, 0.00037262f, 0.02279660f, 0.00220127f, 0.02685117f, 0.00203378f, 0.01915512f, 0.02178952f, 
    0.02159832f, 0.02367795f, -0.03115618f, -0.03873496f, 0.02439489f, 0.02022179f, -0.01980887f, 0.02146300f, 
    -0.03669989f, -0.03479189f, -0.03371624f, -0.02231931f, 0.01222077f, -0.00157410f, -0.02502933f, -0.01365391f, 
    -0.03024592f, -0.02734440f, -0.01941850f, -0.01875109f, -0.01786637f, -0.01843845f, -0.03080441f, -0.03389226f, 
    0.02337608f, -0.02273323f, -0.04270259f, -0.00722978f, -0.02146317f, -0.01231958f, -0.02697641f, -0.00204538f, 
    -0.02097378f, -0.03982733f, -0.02322520f, -0.00293777f, -0.03749340f, -0.01032833f, -0.02856286f, -0.01570818f, 
    0.00231343f, -0.00867075f, -0.01381924f, -0.01664385f, -0.01562850f, -0.00651295f, -0.01196006f, -0.02146120f, 
    -0.02821206f, -0.03755820f, -0.00016934f, -0.02716614f, -0.01363190f, 0.02113012f, 0.02346718f, -0.00973801f, 
    -0.00987851f, -0.00224076f, -0.04196160f, 0.00996392f, 0.00780868f, 0.00043173f, 0.00479749f, 0.00086982f, 
    -0.04241963f, -0.00035416f, -0.00100079f, 0.01681851f, -0.02578448f, -0.01746295f, 0.02146868f, -0.03647886f, 
    -0.01598224f, -0.02188052f, -0.01191072f, -0.03615071f, -0.01480897f, 0.01677957f, 0.00273980f, 0.00619869f, 
    -0.02935021f, -0.02751251f, 0.01254322f, -0.02906160f, 0.01062563f, -0.02065182f, 0.02221016f, 0.00050913f, 
    -0.03242505f, 0.02574188f, 0.02410325f, 0.01847690f, 0.02111692f, -0.00836276f, 0.01691554f, 0.02222936f, 
    -0.00778938f, -0.01677843f, -0.00475520f, -0.00476133f, -0.01019849f, -0.00270582f, -0.03696902f, -0.03323441f, 
    -0.02302699f, -0.00470692f, 0.02146763f, 0.00455301f, 0.00305754f, 0.01587936f, 0.02581940f, 0.01948434f, 
    -0.01918800f, -0.01474245f, -0.03868296f, -0.04440241f, -0.00424847f, -0.02499711f, -0.00671451f, -0.00018010f, 
    -0.02301350f, -0.03301432f, -0.01244978f, 0.00105336f, 0.01797163f, 0.02106821f, 0.00184326f, -0.04027692f, 
    -0.03850756f, -0.00357387f, -0.04294961f, -0.03700524f, -0.00659694f, 0.01665396f, -0.00105004f, -0.03496808f, 
    -0.03492792f, -0.01781743f, 0.01892770f, -0.03949920f, 0.02625663f, 0.01983517f, -0.01916561f, -0.02537962f, 
    -0.01850328f, -0.02272128f, -0.03590329f, 0.02422712f, -0.03655971f, -0.04137544f, 0.01164492f, 0.00974168f, 
    0.00057199f, 0.02616775f, 0.00562097f, -0.02359957f, 0.01606644f, -0.00631079f, -0.00484450f, 0.02517039f, 
    -0.01780184f, 0.01302448f, 0.01343129f, 0.00655250f, 0.01675138f, 0.00937637f, 0.00287309f, -0.03010567f, 
    -0.01762566f, -0.00494446f, 0.01712893f, 0.00863371f, -0.00040524f, -0.02834258f, -0.04346669f, 0.01808562f, 
    0.01790894f, -0.00618823f, 0.02228784f, 0.00236030f, 0.01864451f, -0.01047805f, -0.03860512f, -0.01858994f, 
    -0.03737938f, -0.01119262f, -0.00885187f, -0.04274769f, 0.01865346f, -0.03685950f, 0.00316184f, -0.03334250f, 
    -0.00959171f, -0.02497536f, 0.02606300f, 0.01165411f, 0.02048692f, 0.01319162f, 0.01140381f, -0.01688836f, 
    0.00908931f, -0.03037133f, 0.00156239f, 0.00843569f, 0.01600221f, -0.00283639f, -0.02789547f, -0.03294813f, 
    -0.03901589f, 0.01125524f, -0.01279965f, 0.00932517f, -0.00636729f, 0.00369034f, -0.01853063f, 0.00041444f, 
    -0.00290264f, 0.00942903f, -0.02833161f, -0.02255263f, -0.03376385f, 0.01377772f, 0.01884881f, 0.00346482f, 
    0.03366501f, 0.03132929f, -0.01963795f, 0.01458852f, -0.01695168f, 0.02063225f, -0.03656162f, 0.01635470f, 
    -0.02058450f, 0.01015575f, -0.01393900f, -0.04256878f, -0.00816118f, -0.03547861f, -0.00974077f, -0.04433666f, 
    0.01947779f, 0.01772396f, -0.02814733f, 0.00536465f, 0.02254602f, 0.02349390f, -0.02990697f, -0.00176489f, 
    0.02904839f, -0.03140245f, 0.00492448f, 0.00147749f, 0.02501856f, -0.02382009f, 0.00542210f, -0.02384282f, 
    0.00106351f, 0.01690066f, -0.02219890f, 0.02787763f, 0.00854923f, -0.04032935f, -0.02840206f, 0.02643961f, 
    -0.01836455f, -0.01308608f, -0.02170935f, 0.02178199f, -0.03952334f, -0.03715006f, 0.00682694f, 0.00392976f, 
    0.02632349f, 0.02773648f, -0.01361014f, -0.04394916f, -0.03890300f, -0.02594020f, 0.02725267f, 0.01626106f, 
    0.01498621f, -0.02316939f, -0.00070783f, -0.01815365f, 0.00265279f, -0.00980791f, -0.00907928f, -0.04039820f, 
    0.00842566f, -0.00607699f, -0.03430324f, -0.00684748f, 0.02143518f, 0.00403744f, -0.02129294f, -0.00125797f, 
    -0.03179095f, 0.00639153f, 0.00109560f, 0.00562811f, -0.01234373f, -0.02308196f, 0.01791173f, 0.00645343f, 
    -0.04100717f, 0.00121795f, -0.00220416f, -0.02471156f, -0.02223023f, 0.01434404f, -0.04035161f, -0.00639875f, 
    0.01421892f, -0.01072999f, -0.00434736f, 0.00705889f, -0.02347066f, -0.03173253f, 0.01401581f, -0.03502611f, 
    0.02957351f, -0.00269687f, 0.00359316f, -0.03403353f, -0.00053069f, 0.02993675f, 0.01365167f, 0.01440983f, 
    0.02665012f, 0.00581973f, 0.01088089f, 0.01467238f, 0.00438987f, 0.00057131f, -0.04224011f, -0.03353989f, 
    -0.00185110f, 0.02747377f, 0.02648270f, -0.03701946f, -0.02653387f, 0.01253839f, -0.03796807f, -0.03029063f, 
    -0.00094950f, 0.02281644f, -0.01397116f, -0.00362891f, 0.01664104f, 0.00065876f, 0.00424631f, 0.00474152f, 
    -0.02731628f, -0.02000629f, -0.00160544f, 0.00022450f, -0.02741015f, -0.03375434f, 0.02292110f, 0.03021584f, 
    -0.01511770f, -0.02819001f, -0.03812005f, -0.01428294f, -0.03304431f, -0.04157124f, -0.02918179f, -0.03392502f, 
    -0.01107315f, -0.02218299f, 0.01861497f, 0.01170851f, 0.02676736f, -0.03484151f, -0.00379276f, -0.02194070f, 
    -0.04046851f, 0.01062083f, -0.03141700f, -0.02482796f, 0.02771157f, 0.02578767f, -0.03163148f, 0.00853195f, 
    -0.02887485f, -0.00560533f, -0.03320374f, 0.02009169f, 0.03014934f, 0.01514202f, -0.01016885f, -0.01606425f, 
    -0.01622290f, -0.02636949f, 0.00627021f, 0.00888756f, 0.02960813f, -0.02813438f, -0.00794072f, 0.01900876f, 
    -0.03079666f, -0.00609243f, 0.00937107f, 0.00193236f, 0.00255647f, -0.02702457f, 0.02895748f, 0.02153489f, 
    -0.03827361f, -0.03965352f, -0.00872754f, 0.01968837f, 0.01057606f, 0.02487465f, 0.01984910f, -0.00607436f, 
    0.00636921f, -0.02341752f, -0.02107634f, -0.00016816f, 0.01031790f, 0.02549201f, 0.01499588f, -0.02286439f, 
    0.02813746f, 0.02885763f, 0.01895107f, -0.02618922f, 0.01329508f, -0.01290489f, 0.02227300f, 0.01513169f, 
    -0.00744939f, 0.00436203f, -0.01062807f, -0.03335439f, -0.04066039f, -0.01018701f, 0.01533967f, -0.01054844f, 
    -0.00622375f, 0.00196032f, -0.03942380f, 0.00509916f, -0.03197536f, -0.03561554f, -0.03623915f, -0.00391883f, 
    -0.03242537f, 0.00470240f, 0.01438615f, 0.02871768f, 0.02498882f, -0.03121420f, 0.02273097f, -0.02590024f, 
    -0.02723819f, 0.01557409f, 0.00793980f, -0.01247864f, -0.02956608f, -0.01826084f, -0.01968444f, 0.01480925f, 
    -0.03989242f, -0.01420638f, 0.00759192f, -0.01315001f, -0.01689552f, 0.00313015f, -0.02246918f, 0.00790071f, 
    0.01535929f, -0.00002146f, 0.00534835f, -0.02120387f, 0.01788717f, -0.01307632f, 0.01640946f, 0.01139833f, 
    0.00176879f, -0.01484117f, -0.01884398f, 0.01674506f, 0.02458647f, -0.00450551f, -0.03255063f, -0.02274678f, 
    0.02338487f, -0.01037016f, -0.02157506f, -0.01784373f, -0.01329970f, 0.00002043f, -0.00952476f, 0.02388865f, 
    -0.03074931f, -0.01463311f, -0.02035376f, 0.01807013f, -0.00744128f, 0.02493134f, -0.01234475f, -0.00995817f, 
    0.00839115f, 0.01157780f, -0.04110025f, -0.03329647f, -0.03680918f, 0.02450060f, -0.01092054f, 0.01032793f, 
    -0.03132606f, -0.02417889f, -0.01262426f, -0.03794660f, -0.02749552f, 0.00680686f, -0.01383125f, 0.02746990f, 
    -0.01454801f, 0.01466285f, 0.02026835f, -0.02769001f, 0.00033910f, -0.01009495f, -0.03494313f, 0.02712852f, 
    0.02433730f, 0.01782890f, 0.01335279f, 0.01429683f, -0.02995835f, -0.01112771f, -0.02669121f, -0.03718759f, 
    -0.03083622f, 0.03035898f, 0.03001081f, 0.02274367f, -0.00729406f, -0.03599654f, 0.01269632f, -0.02194272f, 
    -0.00940968f, -0.01271641f, -0.03995605f, -0.02024089f, -0.01089048f, -0.02949313f, 0.00592513f, -0.00514494f, 
    -0.01129076f, -0.03172242f, -0.02944633f, 0.00694612f, 0.02717853f, -0.02506659f, 0.00805756f, 0.02904411f, 
    0.00740248f, 0.02476785f, -0.02269212f, -0.02372310f, 0.01462952f, 0.00793534f, 0.00027527f, -0.03126143f, 
    -0.01618487f, -0.00077043f, -0.01221813f, 0.02206990f, -0.03415587f, 0.00177116f, -0.01402949f, 0.02057733f, 
    0.02967255f, 0.02308611f, 0.00633614f, -0.01386004f, -0.01925486f, -0.01028958f, -0.00488508f, 0.00328915f, 
    -0.01019892f, -0.03733327f, 0.02265844f, -0.02814459f, -0.04099512f, -0.03477040f, -0.03525127f, 0.00134083f, 
    0.00798768f, 0.00889294f, -0.00768328f, -0.01385099f, 0.01394855f, 0.00970085f, 0.00718786f, -0.01645060f, 
    -0.00774920f, -0.01700228f, -0.00849069f, -0.03427454f, 0.00719407f, -0.01715875f, -0.03702253f, 0.02126268f, 
    -0.01230031f, 0.00192590f, 0.00315569f, 0.00922876f, 0.00627907f, -0.01820826f, 0.02609428f, -0.01644805f, 
    -0.00748425f, 0.02570953f, -0.00083071f, 0.00995306f, -0.04034000f, -0.00355885f, 0.00454678f, 0.02165701f, 
    -0.02367008f, -0.02561124f, -0.03591931f, -0.03288127f, -0.00993868f, -0.01949929f, 0.01910566f, -0.03017087f, 
    -0.02762692f, 0.03013684f, -0.01379334f, 0.01141850f, -0.00791143f, -0.03141021f, -0.02586757f, 0.00383944f, 
    -0.03770901f, -0.03313113f, 0.01721861f, 0.00403261f, -0.03738724f, -0.03180883f, -0.02245532f, -0.02280183f, 
    -0.03103725f, 0.02207159f, 0.00180367f, -0.02300028f, -0.02451253f, -0.00232518f, 0.00685954f, -0.02699833f, 
    0.00542246f, 0.01821963f, 0.02876586f, 0.00925048f, 0.02430052f, 0.00708434f, -0.03920909f, -0.01988054f, 
    -0.01189888f, -0.01859529f, -0.03326795f, -0.02233818f, 0.02703422f, 0.02832425f, 0.00265345f, 0.01826205f, 
    0.02909578f, -0.00444450f, -0.02442070f, 0.02992208f, 0.02590691f, 0.02186804f, -0.04012368f, -0.01631113f, 
    -0.00559305f, -0.01598270f, 0.00420042f, 0.01933176f, -0.01270516f, -0.02366965f, -0.04040758f, 0.03037373f, 
    0.01876327f, 0.02992603f, 0.02695510f, -0.00886369f, -0.03586586f, -0.02398311f, 0.00114929f, -0.04096387f, 
    0.01744194f, -0.03585273f, -0.01802573f, -0.03336627f, -0.02801716f, 0.02821378f, -0.00643481f, -0.03666372f, 
    0.02115888f, 0.02011228f, -0.00465109f, 0.01802350f, -0.01876217f, 0.00582289f, 0.01834027f, -0.02834905f, 
    -0.03337355f, -0.02801402f, -0.02633139f, 0.02633969f, 0.00250479f, 0.00850672f, -0.00175183f, -0.02427715f, 
    0.01286269f, -0.01623849f, 0.01051523f, -0.02115546f, -0.02184925f, 0.01894334f, -0.03492722f, 0.01202915f, 
    -0.00909591f, -0.03616220f, 0.01107067f, -0.01554827f, -0.01503144f, 0.02853321f, -0.00517447f, -0.02640050f, 
    0.00538715f, -0.03014659f, -0.03272601f, 0.00107958f, -0.01140590f, 0.00994397f, 0.01847209f, 0.01979328f, 
    0.01137884f, -0.01372058f, -0.03280573f, 0.02619000f, 0.02540944f, 0.01922959f, -0.00819620f, 0.03043170f, 
    -0.00687839f, 0.02068183f, 0.02704528f, -0.02053939f, -0.03210113f, 0.01840700f, -0.01613897f, -0.02049430f, 
    -0.03635742f, -0.02014832f, -0.01137377f, 0.01396429f, -0.03894893f, -0.01257336f, -0.01220705f, -0.03222595f, 
    0.01862965f, 0.01125427f, -0.00489671f, 0.00220497f, -0.03738515f, -0.00370457f, -0.02461728f, -0.00131237f, 
    -0.03405254f, 0.02103804f, 0.02003945f, 0.00374852f, -0.00956655f, -0.02456300f, -0.02541230f, 0.00686805f, 
    -0.02048905f, -0.00492060f, -0.03265125f, 0.00686291f, 0.00279981f, -0.01051505f, -0.01554368f, 0.00022681f, 
    -0.00516469f, -0.02650341f, -0.01162630f, -0.00264272f, 0.01895216f, 0.00134231f, 0.02006981f, -0.04159471f, 
    0.01096160f, -0.00997504f, -0.03377647f, -0.00734860f, 0.01277594f, 0.00756963f, 0.01038412f, 0.02907975f, 
    -0.01100827f, -0.03382838f, -0.01104189f, 0.02203769f, 0.00074077f, 0.00923586f, -0.01673034f, 0.00626546f, 
    -0.02384052f, -0.00297887f, 0.01507818f, 0.01234968f, 0.01500204f, -0.03307041f, -0.02719808f, -0.00785691f, 
    -0.03076194f, -0.01207080f, -0.03909789f, -0.01447666f, -0.03143753f, -0.00160749f, 0.01526834f, 0.02730579f, 
    -0.00541305f, -0.00662598f, 0.01171316f, 0.00092309f, 0.02083934f, 0.00988810f, 0.00347653f, -0.00384705f, 
    0.00327774f, 0.00817912f, 0.00880538f, 0.02625706f, 0.02254164f, 0.02161714f, -0.03044327f, 0.00209820f, 
    -0.03667081f, -0.04061818f, -0.01876756f, -0.01508170f, -0.02427843f, 0.00131419f, 0.01190203f, -0.01510702f, 
    -0.03610807f, 0.01412721f, 0.00116389f, 0.02042700f, -0.00848720f, 0.02329306f, -0.02911936f, 0.02615346f, 
    0.00180432f, 0.02190235f, -0.00429774f, 0.01973983f, 0.01502289f, -0.00171245f, -0.02515258f, 0.01436222f, 
    -0.02845179f, 0.01235167f, -0.02484993f, -0.03177746f, 0.02009308f, 0.02641011f, -0.00942102f, 0.01114148f, 
    -0.00623891f, 0.01921694f, 0.02144760f, -0.01175599f, -0.00015166f, -0.03967021f, -0.00042781f, -0.03546843f, 
    0.02634266f, -0.04224120f, -0.02279991f, -0.03930748f, 0.01311148f, 0.01886553f, -0.03869972f, -0.02645868f, 
    0.01600028f, -0.03954080f, -0.02494247f, 0.01583885f, 0.02581490f, -0.03672477f, 0.01544263f, -0.00918497f, 
    -0.00589015f, -0.00798622f, -0.03663256f, -0.03727435f, -0.00524630f, -0.00227393f, -0.00880396f, 0.01791035f, 
    -0.02207224f, -0.02379225f, -0.01306544f, -0.01309265f, 0.00350415f, -0.02983950f, 0.01933154f, -0.03273238f, 
    -0.02729726f, -0.01460369f, 0.00132443f, -0.01284083f, 0.00334704f, -0.02117748f, -0.00278175f, -0.02755332f, 
    -0.01147223f, 0.02879400f, -0.00884448f, 0.00696384f, -0.01335719f, 0.00283302f, -0.02298397f, -0.02247581f, 
    -0.04037289f, -0.02823383f, -0.00455745f, -0.01586011f, -0.00711492f, -0.02698141f, 0.01848554f, -0.01184849f, 
    0.02298731f, -0.02859055f, 0.02995382f, -0.02448632f, -0.03306147f, -0.02144813f, 0.02545188f, -0.03292457f, 
    -0.00137695f, 0.00503604f, -0.04075125f, -0.01168124f, 0.01552592f, -0.00958324f, -0.03218624f, 0.00027062f, 
    -0.01447964f, 0.01033445f, 0.02743914f, 0.01232818f, 0.00276685f, 0.02874458f, -0.00947271f, 0.02926866f, 
    0.02769798f, 0.02230784f, 0.02961080f, -0.00656418f, 0.04403932f, -0.02436219f, 0.00177065f, -0.02937576f, 
    -0.03784057f, 0.02776149f, 0.00995757f, -0.04048910f, -0.00539341f, 0.02566915f, -0.01413533f, 0.01088445f, 
    -0.00477625f, -0.03422210f, -0.03201007f, -0.02156959f, -0.00180753f, -0.01911929f, -0.02632714f, 0.00220439f, 
    0.02087482f, 0.00043961f, -0.02223855f, 0.00312021f, 0.01395151f, -0.03801298f, -0.02272192f, -0.04066136f, 
    0.00458166f, -0.01006024f, -0.00396256f, 0.02829053f, 0.01528260f, -0.00612048f, -0.03811067f, 0.01298072f, 
    0.01094976f, -0.03118817f, -0.02302032f, 0.02938014f, 0.02010427f, 0.00341603f, 0.02076011f, 0.00863468f, 
    -0.02716058f, 0.00131405f, -0.03407859f, 0.00922034f, -0.03261001f, 0.01436347f, -0.02276089f, -0.03624531f, 
    0.01308232f, -0.01445310f, 0.02905765f, -0.01900732f, 0.02433150f, -0.01309818f, -0.02200867f, 0.00121960f, 
    -0.00161004f, 0.01998768f, -0.01973421f, -0.02600574f, -0.02688079f, -0.03500506f, 0.01570633f, 0.02528954f, 
    0.01079718f, -0.02766953f, -0.03333112f, -0.00843373f, -0.03909309f, -0.02468752f, -0.00025528f, -0.00697290f, 
    -0.02989397f, -0.00279461f, 0.02630584f, -0.04087650f, 0.01753509f, 0.02666731f, -0.03171791f, 0.02400375f, 
    -0.00466733f, 0.01816737f, -0.02326825f, -0.03437769f, 0.01083772f, 0.03025048f, 0.02627726f, -0.03253033f, 
    0.02991789f, -0.00370431f, -0.02157241f, 0.00497234f, -0.00164457f, 0.02887791f, -0.02810579f, 0.00186369f, 
    -0.02532030f, -0.02097231f, -0.02784931f, 0.01060322f, -0.03404728f, -0.03512965f, 0.02609182f, -0.01787782f, 
    0.01653140f, 0.01997882f, -0.04042517f, 0.00646234f, -0.00686884f, 0.01454529f, -0.02722854f, 0.00801222f, 
    -0.07544956f, -0.00236825f, -0.00209406f, -0.03124533f, 0.08778820f, 0.06747153f, -0.03586213f, -0.02992910f, 
    -0.05605819f, -0.00993053f, 0.16892411f, -0.11067533f, -0.19766001f, 0.07255661f, -0.01320526f, -0.10073886f, 
    -0.05436879f, -0.07195157f, -0.04899976f, 0.12172329f, -0.01942533f, 0.00388634f, 0.03259484f, -0.05962804f, 
    -0.11920923f, 0.00034599f, 0.08706971f, -0.10125325f, -0.01169951f, 0.05064368f, -0.01661284f, 0.02275455f, 
    0.11723523f, 0.07456782f, -0.15250520f, -0.06890997f, 0.34514871f, -0.20741199f, 0.08047374f, -0.24257654f, 
    0.02016619f, -0.06735737f, 0.11961865f, 0.07723854f, -0.01164501f, 0.10726579f, -0.19483344f, 0.03225435f, 
    -0.04661745f, 0.28373000f, -0.10479082f, -0.01743112f, -0.08034407f, 0.03604750f, 0.00488387f, 0.15064502f, 
    0.00676961f, -0.03046053f, 0.02317937f, -0.10077530f, 0.01686134f, -0.13653074f, -0.03309931f, 0.17743412f, 
    -0.07814201f, -0.21062087f, 0.09294617f, 0.05962152f, -0.06216522f, 0.07886536f, -0.03050891f, -0.05101051f, 
    0.02804336f, 0.00424817f, 0.08818188f, 0.03446578f, 0.03847038f, -0.01575406f, -0.00123327f, 0.10112260f, 
    -0.02359584f, 0.01193554f, 0.02297568f, -0.17516991f, 0.15051600f, 0.04626465f, -0.00217239f, 0.04975873f, 
    0.12955901f, -0.01838057f, -0.13784574f, 0.07563059f, 0.00842959f, -0.13753738f, 0.13621002f, -0.05338772f, 
    0.15856260f, 0.06460921f, 0.10335815f, -0.01246664f, -0.04051817f, 0.05965169f, -0.03151918f, -0.06604915f, 
    -0.10281598f, 0.09458185f, 0.01226624f, -0.00092818f, -0.10710575f, -0.11581176f, 0.08739902f, 0.02248231f, 
    -0.00174914f, 0.18988906f, 0.04484377f, -0.03563077f, -0.03987645f, 0.06062305f, -0.06707274f, -0.09785669f, 
    -0.03821341f, -0.02620545f, 0.09244412f, -0.01937953f, 0.00915287f, -0.02988164f, -0.03382207f, 0.04565505f, 
    0.08250322f, -0.18971711f, -0.10947337f, -0.00180020f, -0.21653058f, 0.04554951f, 0.24153659f, 0.21273577f, 
    0.05937684f, -0.03790316f, 0.12277442f, 0.14880283f, 0.02913584f, 0.14968650f, -0.00660827f, 0.04417171f, 
    -0.07967629f, 0.00901711f, 0.11909329f, 0.04742187f, 0.00551802f, 0.00846156f, -0.01705505f, -0.06112843f, 
    -0.04442869f, -0.04438853f, -0.00642645f, -0.04635787f, 0.00752121f, 0.06354560f, -0.14346160f, -0.13025160f, 
    0.03203586f, 0.04129218f, 0.05964085f, 0.00419529f, -0.06250589f, 0.11831861f, -0.09018920f, 0.05965533f, 
    -0.10558521f, -0.05137498f, -0.13449271f, -0.00395764f, 0.01737899f, 0.00216677f, 0.03269372f, 0.13481112f, 
    0.05468473f, 0.06546136f, 0.09456215f, -0.11907386f, 0.43816295f, 0.13031837f, -0.12716150f, -0.04249762f, 
    0.00106580f, 0.06157456f, -0.03923817f, -0.03536891f, -0.02063702f, 0.02723611f, 0.00514044f, 0.04815942f, 
    0.09704247f, 0.02369889f, -0.02765183f, 0.08108137f, 0.00748809f, -0.03766024f, -0.02180923f, 0.08522898f, 
    -0.02825850f, -0.01815342f, 0.05099496f, -0.23670493f, -0.10699600f, -0.00303291f, 0.16117275f, -0.07699273f, 
    0.05333346f, -0.02902558f, -0.18025509f, -0.07985128f, 0.07973150f, 0.04917350f, -0.13847092f, 0.06709910f, 
    -0.01636653f, 0.09566857f, -0.05578805f, 0.15089306f, -0.00797713f, 0.06700259f, 0.04269458f, 0.11026800f, 
    0.02760871f, 0.15232855f, 0.00248119f, 0.01709246f, -0.00371697f, 0.06041792f, -0.04632978f, -0.08872276f, 
    0.11769556f, -0.06939172f, -0.03658567f, 0.02425091f, -0.07302366f, 0.02869602f, -0.04102452f, 0.16532561f, 
    0.13765830f, -0.04253040f, 0.03368413f, 0.04957188f, 0.07397255f, -0.08969730f, 0.00935924f, 0.03676872f, 
    -0.06599469f, 0.13139357f, 0.05607627f, 0.01811539f, -0.28084391f, 0.08765844f, 0.08232298f, 0.17623904f, 
    0.08771466f, 0.08456457f, -0.15857965f, 0.03024067f, -0.10135297f, -0.09858149f, 0.20254029f, 0.07144269f, 
    -0.00687499f, -0.06427045f, -0.08236791f, 0.05622084f, 0.17156869f, -0.06488932f, 0.06499741f, 0.01849981f, 
    -0.02045351f, 0.12381169f, -0.07436287f, 0.07566302f, -0.12032699f, -0.02875019f, 0.21636447f, -0.12143740f, 
    0.06504276f, -0.02203704f, 0.06506743f, 0.02424120f, -0.06405252f, -0.06290553f, -0.10067560f, -0.02635172f, 
    0.03570401f, -0.04317784f, 0.25110635f, 0.26165554f, 0.01121284f, -0.08345632f, 0.01247407f, 0.02827687f, 
    -0.05301952f, 0.04367879f, -0.04215001f, 0.06929435f, 0.15999839f, 0.07249144f, -0.02419852f, -0.09235347f, 
    0.03394561f, 0.03900974f, -0.04140973f, -0.01456043f, -0.07208105f, -0.09338672f, 0.03891977f, -0.14637202f, 
    -0.09962503f, -0.05709804f, 0.12581944f, -0.01780277f, 0.02831552f, -0.05346701f, -0.06004440f, -0.07167044f, 
    -0.01003077f, 0.12818120f, 0.02589782f, 0.01109977f, 0.12269112f, 0.19850306f, 0.13301085f, -0.09881554f, 
    -0.11074789f, 0.08703712f, 0.07381114f, 0.12234921f, 0.10239930f, -0.04962350f, -0.09189193f, -0.05249588f, 
    -0.06248036f, 0.01022819f, 0.05268792f, -0.01901030f, -0.07692665f, -0.02897502f, 0.04447812f, 0.06502242f, 
    -0.09072426f, 0.06409439f, -0.08629533f, 0.04243312f, 0.13173524f, 0.06200571f, -0.10089106f, 0.13304524f, 
    0.06096226f, 0.11369135f, -0.06910754f, 0.04428887f, 0.09222233f, -0.01111599f, -0.01160784f, -0.16819771f, 
    0.08205475f, 0.18425912f, -0.01193499f, -0.00850079f, -0.00680324f, 0.05604793f, 0.05438565f, -0.00886086f, 
    -0.04503628f, 0.05194051f, -0.05888577f, 0.02526419f, 0.05127536f, 0.01021957f, -0.11351109f, -0.00927277f, 
    -0.07481074f, 0.01535068f, 0.06442096f, 0.09131524f, 0.13399330f, -0.11499912f, -0.01515652f, -0.16142565f, 
    -0.21697989f, -0.00881639f, -0.08447699f, -0.01079311f, 0.02594812f, -0.04472845f, 0.12000312f, 0.04386849f, 
    -0.02696653f, 0.02156818f, -0.11468694f, 0.09956123f, -0.02138715f, -0.10221880f, 0.04208593f, 0.08414970f, 
    -0.07717644f, 0.02300201f, 0.05691252f, 0.09121776f, -0.00826091f, -0.07606716f, -0.12914382f, -0.01284759f, 
    0.18084094f, 0.07313152f, -0.07454640f, -0.12578680f, -0.12296296f, -0.06749918f, -0.11286061f, 0.05075260f, 
    0.01927225f, 0.00897092f, 0.15834501f, -0.07210381f, -0.03871429f, 0.17790760f, 0.22775933f, -0.10412017f, 
    0.01909333f, 0.14540607f, 0.04206805f, -0.02481773f, 0.06939981f, -0.11991595f, -0.01907645f, 0.08200256f, 
    -0.32787544f, -0.26778081f, 0.05887784f, 0.03536228f, -0.00026487f, 0.12212514f, 0.20172638f, 0.06173159f, 
    -0.00307750f, 0.03400307f, 0.00544920f, -0.10699834f, 0.14843480f, -0.08509526f, 0.05684677f, 0.12959862f, 
    0.00901812f, -0.02569334f, 0.18390477f, -0.03213820f, -0.08008911f, 0.08414334f, -0.12520321f, 0.04561104f, 
    0.00428692f, 0.11456594f, -0.20637849f, -0.11544839f, -0.04030419f, -0.05416377f, 0.04167782f, -0.04524252f, 
    -0.01876623f, -0.04478875f, -0.14762197f, -0.02500513f, 0.32537794f, 0.05051527f, -0.01461294f, 0.04308091f, 
    0.07517972f, 0.08900725f, 0.24734546f, -0.09875814f, 0.00961748f, 0.05291167f, 0.02459381f, 0.08655287f, 
    -0.01547064f, 0.13547300f, -0.01024783f, -0.00861329f, -0.00682062f, 0.05957245f, 0.19309756f, -0.09003781f, 
    -0.00738360f, -0.05690847f, -0.06982240f, 0.12508562f, 0.08852062f, 0.09473582f, -0.11053489f, 0.09844394f, 
    -0.09696293f, -0.07534441f, 0.20996891f, -0.00004019f, 0.12595339f, 0.03626685f, -0.09253344f, 0.22304595f, 
    -0.17028865f, 0.06508975f, -0.24113607f, 0.08100270f, 0.10782676f, -0.06155187f, 0.03407752f, 0.08610424f, 
    0.07682811f, -0.06519740f, 0.08789241f, 0.13287833f, 0.07477758f, -0.07211217f, 0.05035714f, -0.00570200f, 
    -0.03602258f, 0.21798566f, 0.05826098f, 0.00854609f, 0.06553520f, 0.02143898f, -0.02306522f, 0.04526816f, 
    -0.11168052f, 0.09655748f, -0.16023405f, -0.16049719f, 0.01976953f, 0.08529480f, -0.06614794f, 0.06455584f, 
    0.02490299f, 0.05102976f, -0.10640779f, 0.15676872f, -0.06102631f, -0.06299345f, 0.07163409f, 0.11358142f, 
    0.02789627f, -0.08670272f, 0.00508874f, 0.04034120f, -0.14497446f, 0.06991469f, 0.17748325f, 0.07990570f, 
    -0.10919639f, -0.04898947f, -0.09854121f, 0.06245563f, -0.04847199f, 0.09034168f, 0.03926647f, 0.01041540f, 
    0.06815103f, 0.00883226f, 0.12490988f, -0.06671330f, 0.18151768f, 0.05929473f, 0.11172043f, 0.12570147f, 
    -0.10595305f, -0.12681067f, -0.00208600f, 0.02336480f, -0.00642803f, 0.07644607f, -0.07535324f, 0.16442797f, 
    0.01406667f, 0.09100313f, 0.09261496f, 0.04340778f, 0.02743784f, 0.08166663f, -0.01681127f, -0.03258378f, 
    0.02604085f, -0.03722181f, -0.01536121f, 0.02217569f, -0.03536860f, -0.03736300f, 0.10014442f, 0.07680607f, 
    0.01500641f, 0.14067921f, 0.03238919f, -0.01305986f, 0.14235704f, -0.08460437f, -0.03873238f, -0.09012651f, 
    -0.17371967f, 0.11144710f, 0.07984119f, -0.01960954f, 0.02826931f, 0.08753726f, 0.07797921f, 0.03715282f, 
    -0.10654841f, 0.18432307f, -0.00317885f, -0.06222013f, -0.17074943f, 0.00525422f, -0.08913549f, -0.05214829f, 
    -0.02606286f, 0.09486274f, 0.03235944f, 0.03392369f, -0.08384725f, 0.07839303f, -0.06459858f, -0.10414675f, 
    -0.13459820f, 0.01868235f, -0.04313689f, 0.24112763f, -0.12671451f, 0.06701708f, 0.10522600f, -0.03224728f, 
    0.01865990f, -0.05719675f, -0.01277460f, 0.13889331f, 0.13166441f, -0.05151871f, 0.13526948f, 0.02378784f, 
    -0.11990493f, 0.04137620f, 0.02946812f, 0.05609993f, 0.05197122f, 0.17213967f, -0.03478573f, -0.02385140f, 
    0.05495018f, -0.01516324f, 0.10026840f, 0.07639132f, 0.04963477f, -0.17282675f, 0.11101224f, 0.11418036f, 
    0.01963146f, -0.04809105f, 0.05832360f, -0.00890774f, 0.01858973f, 0.03950118f, 0.01822303f, 0.04944829f, 
    -0.02645185f, 0.10078612f, 0.12825187f, -0.02308540f, -0.03927587f, 0.01423124f, -0.06077171f, -0.10633432f, 
    0.05875797f, -0.03476506f, -0.17362355f, 0.27717417f, 0.00932005f, 0.03912284f, -0.22566426f, 0.03563959f, 
    0.10194410f, -0.04135303f, 0.09937397f, 0.07558700f, -0.07000828f, 0.06826641f, -0.03585095f, 0.10824074f, 
    0.03505560f, 0.04005425f, -0.02369730f, 0.00264658f, 0.04405656f, -0.01636431f, 0.04336653f, 0.16011961f, 
    0.13668475f, 0.03817423f, -0.06336667f, -0.06480905f, -0.16970870f, -0.13127130f, -0.07371877f, -0.16361743f, 
    0.06544593f, 0.10354710f, 0.04090524f, 0.16362275f, 0.13670819f, -0.07673426f, 0.05775777f, -0.03882496f, 
    -0.16711523f, 0.09887417f, -0.02431729f, 0.09182737f, -0.04970151f, 0.00579082f, 0.06483766f, -0.08437856f, 
    -0.01925801f, -0.04100778f, -0.06434188f, 0.00928167f, -0.05882780f, -0.01048027f, 0.03428186f, 0.09380943f, 
    0.04607151f, 0.09602262f, -0.00525824f, 0.04006477f, 0.07290415f, 0.02802637f, -0.04369963f, -0.01194535f, 
    -0.00921449f, 0.02550803f, -0.00690306f, 0.07858258f, -0.09465685f, 0.04293581f, -0.05517947f, 0.02242407f, 
    0.17809345f, 0.09466577f, -0.00975755f, 0.13012919f, 0.04156628f, 0.20802264f, 0.13293575f, -0.02754975f, 
    0.03963490f, 0.06879923f, -0.02160080f, 0.10350837f, -0.20039497f, -0.07460236f, 0.19758391f, -0.07769566f, 
    0.00333387f, 0.15569182f, 0.03228177f, -0.03071497f, -0.00677614f, -0.00390021f, 0.08390184f, -0.12060812f, 
    -0.02798409f, 0.00774437f, -0.04789874f, 0.00587735f, -0.03130518f, -0.00013941f, 0.01202680f, -0.02034332f, 
    -0.03031625f, -0.04195586f, 0.02322902f, 0.01378996f, 0.00193162f, 0.00747550f, -0.00632228f, 0.02377303f, 
    -0.00205129f, -0.02568690f, -0.01670891f, -0.01044660f, 0.05264696f, -0.03395868f, -0.02473655f, 0.02619064f, 
    -0.03249600f, -0.03227846f, -0.01190583f, 0.00262552f, 0.01123391f, -0.01964830f, 0.01883476f, 0.00394235f, 
    0.02130252f, 0.01106551f, -0.04166804f, -0.03860032f, 0.00822648f, -0.04511034f, -0.01778489f, -0.04709631f, 
    -0.01536194f, -0.01454674f, -0.03737116f, -0.01772050f, -0.01982768f, -0.03864161f, -0.01554615f, 0.01292024f, 
    0.03335685f, -0.00007006f, -0.02437776f, -0.04377391f, 0.02198986f, 0.02112822f, -0.02297956f, -0.01157736f, 
    -0.02541298f, -0.00307207f, -0.03802115f, -0.01545282f, 0.02437675f, -0.00883177f, 0.00170894f, 0.00891226f, 
    -0.03701719f, 0.00456612f, -0.02081420f, -0.00903374f, -0.02009038f, -0.01530756f, -0.03799637f, -0.02501658f, 
    0.02836943f, 0.00719824f, -0.02265150f, 0.00396645f, -0.01834484f, -0.03641339f, -0.03020298f, -0.00597108f, 
    -0.00350745f, -0.00345583f, -0.02081287f, -0.02683830f, -0.03292551f, 0.02063474f, -0.04194570f, -0.03648829f, 
    -0.02110880f, 0.00023319f, 0.00933594f, 0.02440993f, -0.03011291f, -0.02673781f, -0.00895117f, 0.01575617f, 
    0.02771187f, -0.03518276f, -0.03237769f, -0.01091769f, 0.01617131f, 0.02228076f, 0.00838795f, -0.01897931f, 
    -0.01788975f, 0.02702406f, 0.00809674f, -0.01297984f, 0.02501536f, -0.03525222f, 0.01389199f, 0.03596175f, 
    0.00914398f, -0.02133199f, 0.00086005f, -0.00335492f, -0.02615040f, 0.02360838f, -0.00525046f, 0.00156052f, 
    -0.00218175f, 0.04208956f, -0.01704681f, 0.02365719f, 0.01509029f, -0.02980070f, -0.03098997f, -0.01037090f, 
    0.00865744f, -0.04373243f, -0.01810379f, 0.02432038f, -0.00860996f, -0.00945368f, 0.00569700f, -0.01441957f, 
    -0.01013009f, -0.01514137f, -0.00815604f, -0.03247200f, -0.00551289f, 0.02267833f, 0.01997604f, 0.02435405f, 
    -0.01651620f, 0.02528760f, -0.04372348f, -0.02504518f, -0.04066220f, -0.00206400f, -0.02098006f, -0.00674249f, 
    -0.04411073f, 0.00375645f, 0.01380604f, -0.03639144f, -0.01833889f, 0.01406331f, -0.02309898f, 0.03096856f, 
    0.00685392f, -0.00508843f, -0.03136146f, -0.04114821f, -0.00972163f, 0.00398406f, -0.02736270f, 0.02443068f, 
    -0.03028790f, -0.04645314f, -0.03071330f, -0.02218664f, -0.02376972f, 0.01570248f, -0.04898144f, 0.01641136f, 
    -0.02342993f, 0.01497834f, -0.04050662f, 0.01522060f, 0.02988585f, 0.02376731f, 0.02618177f, 0.00520719f, 
    -0.00629794f, -0.01307166f, 0.00554257f, 0.02368375f, -0.02692001f, -0.00451865f, 0.00098437f, 0.02749004f, 
    -0.01371952f, -0.01039812f, -0.02013555f, 0.02433352f, -0.01439156f, 0.02011278f, 0.00588226f, -0.02580875f, 
    -0.02581198f, 0.02441657f, 0.01014405f, -0.01629141f, 0.00050228f, -0.02009227f, -0.00476511f, -0.03357927f, 
    -0.00543288f, 0.00461938f, 0.00777770f, -0.01888606f, -0.03988007f, -0.01074919f, -0.01014848f, -0.00966495f, 
    0.01864354f, 0.00134026f, 0.02277962f, -0.01978203f, 0.02259789f, -0.01490844f, -0.01088724f, -0.00461807f, 
    -0.01057019f, -0.02004040f, 0.01306096f, -0.04211218f, 0.01385788f, 0.00739271f, -0.03148262f, -0.04316552f, 
    0.01915311f, -0.04046334f, 0.02008162f, -0.02214963f, -0.00546352f, 0.01993297f, 0.00474676f, 0.03180599f, 
    -0.02371973f, -0.00392472f, -0.03200229f, 0.01822632f, -0.03503053f, 0.00563706f, 0.00792853f, -0.03004828f, 
    -0.04564611f, -0.01076998f, -0.04512176f, 0.00461465f, -0.02020188f, -0.00108248f, -0.03592267f, 0.01955467f, 
    0.02560222f, -0.02525938f, -0.00185119f, -0.00723115f, -0.04204237f, -0.01942283f, -0.04090992f, -0.00535560f, 
    0.00739609f, 0.00449392f, 0.00588955f, -0.02787917f, -0.01038403f, 0.01928348f, -0.03193581f, -0.02758017f, 
    0.00090808f, -0.02294369f, 0.02142322f, -0.03858669f, -0.01134623f, 0.02505266f, -0.03890298f, -0.02046831f, 
    -0.01400896f, -0.01555306f, -0.02986196f, 0.01520262f, -0.03314787f, 0.01186949f, -0.03388575f, 0.02891095f, 
    -0.03263845f, 0.00126244f, -0.03787540f, -0.03788358f, 0.01452598f, -0.02906371f, -0.02928146f, 0.01472780f, 
    0.02530651f, -0.00069074f, -0.02427486f, 0.00774402f, -0.02349695f, 0.00655444f, 0.00283862f, -0.03869368f, 
    0.00693321f, 0.02462193f, -0.02184327f, -0.04538264f, 0.04153447f, -0.00122232f, 0.01906358f, -0.00649145f, 
    0.00174995f, -0.00539429f, 0.01354963f, -0.01307479f, 0.02155857f, 0.01811598f, -0.01700214f, 0.00730501f, 
    -0.01201423f, -0.00460619f, -0.01738759f, -0.02416173f, 0.00231911f, 0.01603656f, -0.00936005f, -0.00808788f, 
    -0.02628449f, 0.02016993f, -0.00474783f, -0.04306404f, -0.03790740f, -0.04630544f, -0.02711573f, -0.00562360f, 
    0.01191734f, -0.00738800f, 0.02364398f, -0.01394607f, 0.00438865f, -0.03957065f, -0.04733898f, -0.01225198f, 
    0.01467825f, -0.00209062f, -0.01690676f, -0.02756220f, 0.02325309f, -0.01461400f, 0.02127396f, 0.00793350f, 
    -0.04415249f, -0.03677130f, 0.02102955f, -0.02130958f, 0.02520369f, 0.01303773f, 0.02105161f, 0.00077026f, 
    -0.01816248f, -0.01436648f, 0.00582938f, -0.01201468f, 0.01609049f, 0.00492491f, -0.04052499f, 0.02387782f, 
    -0.04400215f, -0.04285673f, -0.04260053f, 0.01990105f, -0.02654750f, -0.02777449f, -0.01478488f, 0.01996872f, 
    -0.00442208f, -0.00106478f, -0.00726231f, -0.04128943f, 0.02224829f, -0.03554516f, -0.03167713f, -0.03730166f, 
    -0.02840473f, -0.04704228f, 0.01288608f, -0.00551178f, -0.01891345f, -0.02511760f, -0.04466360f, -0.04203910f, 
    -0.03710709f, 0.02466053f, 0.00490046f, 0.02168915f, 0.00798839f, 0.02729736f, 0.02224860f, 0.00592354f, 
    -0.01392128f, -0.03622131f, -0.02997421f, 0.02060493f, -0.01611793f, -0.00436997f, -0.01676018f, 0.01202635f, 
    -0.02033897f, 0.01871131f, 0.01636934f, -0.01569828f, 0.00127616f, 0.04986753f, -0.01641491f, -0.00074808f, 
    -0.01811639f, -0.00139613f, -0.02320196f, -0.01494724f, -0.00203519f, 0.02305755f, 0.00650235f, 0.02541872f, 
    -0.01018456f, -0.03012714f, -0.01169542f, -0.00000492f, 0.02306281f, -0.00044646f, -0.00527519f, 0.00828341f, 
    -0.03122653f, 0.01784664f, -0.00982945f, 0.00150819f, -0.02188196f, -0.00721134f, 0.00675590f, -0.00530005f, 
    -0.04492037f, -0.04488073f, 0.01167138f, -0.00152553f, 0.02712192f, 0.00627822f, 0.01405060f, -0.03858166f, 
    -0.01223350f, -0.00790339f, -0.02667568f, 0.02520006f, 0.01972853f, 0.03530459f, 0.00431645f, 0.01728084f, 
    -0.02170237f, -0.01218867f, -0.02018282f, -0.01173287f, -0.01318839f, -0.00240407f, 0.01150934f, -0.04772645f, 
    0.01874695f, 0.02123783f, -0.04279574f, 0.01901872f, -0.03974520f, 0.02541554f, -0.00973611f, -0.02912579f, 
    0.01128441f, -0.04112546f, 0.01077732f, -0.04109130f, 0.00633357f, -0.02946830f, 0.02048172f, -0.00527368f, 
    -0.03865572f, 0.01889875f, -0.00129632f, -0.02105775f, 0.02427872f, 0.01152648f, 0.01945456f, -0.01476368f, 
    -0.02695265f, -0.01598835f, -0.01488125f, 0.00959553f, 0.02067518f, 0.02713749f, -0.03569582f, -0.03795137f, 
    -0.03460219f, -0.00825875f, 0.02398233f, 0.00630521f, -0.00282823f, -0.03051167f, 0.01865756f, -0.02236030f, 
    -0.02957410f, 0.01815546f, -0.02208738f, 0.00579837f, -0.00336354f, 0.01719627f, -0.02867779f, -0.01515392f, 
    -0.01974177f, -0.01391659f, 0.02636857f, -0.02033158f, 0.00414109f, 0.04687697f, 0.02626396f, -0.04420376f, 
    -0.02032332f, -0.00285755f, -0.02185797f, 0.01069456f, -0.02087387f, 0.02332567f, -0.01969632f, 0.01187481f, 
    0.04836764f, -0.00142381f, -0.03627811f, 0.01632318f, 0.02643729f, -0.00269081f, 0.00976985f, -0.04232888f, 
    0.02932643f, -0.02970937f, -0.02370047f, -0.04454146f, -0.03320306f, 0.02149426f, 0.01109540f, 0.00266921f, 
    -0.04473500f, -0.03397255f, 0.00225671f, 0.00427947f, -0.01497725f, -0.00340016f, -0.01925652f, -0.00254192f, 
    -0.04905213f, -0.00206284f, 0.01926118f, -0.03401459f, 0.00522934f, 0.00802354f, -0.03491739f, -0.04237839f, 
    -0.02754167f, -0.01108230f, -0.04326837f, -0.03941599f, -0.03739013f, 0.01466846f, -0.02892784f, -0.03295528f, 
    0.01774184f, -0.02383995f, -0.00846466f, -0.01276825f, -0.00847517f, -0.02438490f, -0.03174252f, 0.02037624f, 
    -0.02649607f, -0.04117168f, -0.01548256f, -0.01680724f, 0.00424921f, -0.01071452f, -0.03161138f, -0.03199160f, 
    -0.01651109f, -0.01095945f, -0.01050691f, -0.01179720f, -0.01028097f, 0.00179452f, 0.00480793f, -0.01740953f, 
    -0.01357774f, -0.02614408f, 0.01115808f, 0.02206924f, -0.02133328f, -0.01479020f, -0.01899948f, -0.02556777f, 
    0.02334932f, -0.03599975f, 0.01453626f, -0.00647348f, -0.02079150f, -0.04280344f, -0.01584945f, -0.04706435f, 
    -0.00319934f, 0.01575600f, -0.02183500f, -0.03001436f, 0.01565599f, 0.05022176f, -0.02279582f, -0.01694563f, 
    0.02747755f, -0.04113213f, 0.00935987f, -0.04117072f, 0.00777635f, -0.01921855f, -0.04612379f, 0.03108460f, 
    -0.03446244f, -0.03825442f, 0.00550834f, -0.01365517f, -0.02560743f, -0.03471032f, 0.01781385f, 0.01201788f, 
    -0.04631725f, -0.02163453f, -0.01944263f, 0.02830036f, 0.03627435f, -0.01621926f, -0.02762783f, 0.00325748f, 
    0.02012208f, -0.01971564f, 0.02017007f, -0.03979400f, -0.03134848f, 0.02175646f, -0.03035301f, 0.01200784f, 
    0.02433446f, 0.03949311f, -0.02510494f, -0.02748083f, -0.03717899f, 0.00408445f, 0.02411019f, 0.00402900f, 
    -0.00948580f, -0.02849991f, -0.03880916f, -0.00354564f, 0.00176921f, -0.00455949f, -0.04554332f, -0.04830608f, 
    -0.00350323f, 0.00072949f, -0.02026756f, -0.03659916f, -0.02656846f, -0.00568468f, -0.03100291f, 0.03413995f, 
    0.03676904f, 0.01911697f, 0.04151930f, -0.00025498f, 0.02531914f, -0.04122453f, 0.01272152f, 0.02161339f, 
    -0.02341473f, -0.03203176f, -0.00231251f, -0.03876491f, -0.03142659f, 0.00693582f, -0.01559005f, -0.01748653f, 
    -0.01124449f, -0.01236538f, 0.01105074f, -0.04306408f, -0.04153065f, -0.01401734f, -0.01080438f, -0.03041825f, 
    -0.02985153f, -0.01881139f, -0.01526175f, 0.01420118f, 0.02238601f, -0.00477370f, 0.01888523f, 0.00266771f, 
    0.01445115f, 0.02669057f, 0.02392148f, 0.01662304f, -0.00256524f, 0.03611316f, -0.01473558f, 0.02965774f, 
    -0.02553470f, -0.02547252f, -0.00759217f, 0.00056202f, -0.01441158f, -0.04318828f, -0.00700338f, -0.02725958f, 
    -0.00351512f, 0.03863062f, 0.03415058f, -0.04094000f, -0.03460396f, 0.01724317f, -0.03414927f, 0.00598803f, 
    -0.04066413f, 0.00923039f, -0.00841970f, 0.00952737f, -0.01007805f, 0.03753940f, -0.00638955f, -0.01714044f, 
    0.00567481f, -0.00596599f, -0.03933762f, 0.00913716f, -0.02613776f, -0.03907437f, 0.00702131f, 0.00228006f, 
    0.01036902f, -0.03304193f, -0.03216439f, -0.04441775f, -0.00776948f, -0.02796322f, -0.01747541f, 0.00768295f, 
    -0.03317122f, 0.01115196f, -0.02964287f, -0.01317943f, 0.00361439f, -0.04097030f, -0.03488468f, -0.00616979f, 
    0.01434157f, 0.00151663f, 0.01153488f, -0.00587820f, 0.01096538f, 0.01060070f, -0.02599005f, -0.02608494f, 
    -0.05592053f, 0.00205154f, 0.10882261f, 0.16011539f, -0.06988973f, -0.00859291f, -0.08550705f, 0.20392935f, 
    0.06518684f, 0.08984713f, 0.03471507f, -0.11697290f, -0.07557432f, -0.21068615f, 0.22657053f, 0.09037198f, 
    0.08531525f, 0.06163879f, -0.05287872f, 0.07387111f, 0.05997776f, 0.00670599f, 0.02095321f, 0.05985315f, 
    0.07192659f, 0.16755618f, -0.01934785f, -0.04209498f, 0.06191551f, -0.02955770f, -0.01782454f, -0.03253104f, 
    -0.03378371f, -0.00455297f, -0.01395759f, 0.05607373f, 0.09501405f, -0.34888861f, -0.06958316f, 0.17677921f, 
    -0.02137559f, 0.01238955f, -0.00656951f, 0.07197003f, 0.06282671f, 0.08699147f, 0.05459630f, 0.00110010f, 
    -0.42641902f, 0.23920339f, -0.08036095f, -0.39475897f, 0.10261704f, 0.02987349f, 0.10998577f, -0.06246368f, 
    0.08848591f, -0.01888658f, 0.08144916f, 0.07792258f, -0.01049086f, 0.08958222f, -0.08412886f, 0.48275957f, 
    -0.26015484f, -0.02861317f, 0.07000934f, 0.17129785f, 0.13593443f, 0.08507811f, 0.10028787f, -0.02470736f, 
    0.17928092f, 0.10991146f, 0.07910015f, 0.12097783f, 0.03524681f, -0.04840284f, 0.14866500f, 0.06129378f, 
    0.02551881f, 0.11930966f, 0.01485598f, 0.07873120f, 0.05144526f, -0.05362395f, -0.02927228f, 0.12224904f, 
    0.01627454f, -0.07163691f, 0.17700845f, 0.19037905f, 0.05193384f, -0.06441361f, 0.05365101f, -0.06490225f, 
    0.06534870f, 0.24482541f, 0.06431228f, 0.14347625f, 0.12162953f, 0.00274890f, 0.05850663f, -0.03778102f, 
    0.03532975f, 0.12102161f, 0.08945917f, 0.02281661f, 0.35652533f, -0.05573312f, 0.34139827f, 0.11505532f, 
    0.00927663f, -0.07053624f, -0.03331445f, -0.02386037f, 0.04788646f, 0.03099262f, 0.02600571f, 0.04724364f, 
    0.29380554f, -0.19674435f, -0.04794515f, 0.07948053f, -0.00610009f, 0.02440375f, 0.11720094f, 0.00005798f, 
    0.08979160f, 0.02938357f, -0.07381655f, -0.02842126f, -0.38119426f, 0.07759668f, 0.06013221f, 0.21382965f, 
    -0.00527049f, -0.00947169f, 0.13042393f, 0.08114590f, 0.10839495f, 0.00352526f, 0.06795622f, 0.00768532f, 
    -0.09489705f, -0.01851171f, 0.06257223f, 0.05608823f, -0.02986971f, -0.05067400f, 0.12579161f, -0.00145636f, 
    -0.03011066f, 0.12863226f, -0.00244199f, -0.03565942f, -0.01112730f, 0.11934377f, -0.08246668f, -0.38836312f, 
    0.19813530f, -0.00912302f, -0.04887766f, -0.00295720f, 0.06345598f, -0.03842840f, -0.02504036f, 0.03365736f, 
    -0.23313914f, 0.17874102f, -0.10171241f, -0.21253233f, 0.17564233f, 0.03145645f, 0.08606207f, -0.03056105f, 
    -0.06624132f, 0.01802567f, 0.01499446f, 0.07187174f, -0.26244572f, -0.20063387f, 0.06639148f, 0.15263157f, 
    -0.08802075f, 0.08885319f, -0.04056796f, 0.02542036f, -0.12994263f, -0.02513859f, 0.07288153f, 0.09404529f, 
    0.29041275f, -0.03247632f, -0.06166063f, 0.02541979f, 0.17566627f, -0.10455041f, 0.05075578f, 0.21491621f, 
    0.06015229f, -0.03348919f, 0.20231880f, 0.07416721f, 0.06315425f, -0.12575161f, -0.12272770f, -0.00882168f, 
    0.04280715f, 0.12533325f, 0.10438344f, 0.02187722f, 0.02137662f, 0.06490981f, -0.03566239f, -0.02572883f, 
    0.06635734f, -0.00405063f, -0.03130207f, 0.17712899f, 0.06096699f, -0.08224721f, 0.07889206f, 0.11871690f, 
    0.05569384f, -0.02747231f, 0.09347864f, 0.01610902f, 0.09862889f, -0.01630285f, 0.06176257f, 0.25540411f, 
    0.02305075f, 0.00277741f, 0.04294069f, 0.23590615f, 0.03150587f, -0.08437262f, 0.14425687f, 0.01350580f, 
    -0.35092038f, 0.21064560f, -0.08740238f, -0.01470421f, 0.12833032f, 0.17666511f, 0.06642885f, -0.05663884f, 
    0.05250521f, 0.05784578f, -0.03099356f, -0.00349985f, -0.36830798f, 0.15818791f, -0.15177342f, 0.17428961f, 
    0.11569992f, 0.06008144f, 0.14627212f, 0.12287114f, 0.00596719f, -0.03365460f, 0.05750480f, -0.03191460f, 
    -0.19954103f, -0.14969686f, -0.00332162f, 0.14786227f, 0.07224647f, -0.08814199f, 0.06862424f, 0.08371910f, 
    -0.03293202f, -0.01702983f, 0.10401826f, -0.06393887f, -0.16841197f, 0.02269972f, 0.31019601f, 0.23102503f, 
    0.05849220f, 0.16167998f, 0.00211091f, -0.05759723f, -0.07899448f, 0.08991917f, 0.02051522f, 0.02350732f, 
    -0.02426148f, -0.09663440f, -0.03669284f, 0.18509792f, -0.05190498f, -0.04578499f, 0.02292154f, -0.00582094f, 
    -0.07055823f, -0.03367105f, 0.02915484f, 0.00252212f, -0.14692561f, -0.14946836f, -0.07543562f, -0.02551716f, 
    0.05708067f, -0.02660500f, 0.04150488f, -0.02626480f, 0.00102632f, -0.03140865f, 0.00378339f, 0.01384056f, 
    0.02860206f, 0.10570576f, 0.13173749f, 0.05598116f, -0.10230982f, -0.10971224f, -0.01278616f, 0.01306240f, 
    -0.01263947f, -0.01181834f, 0.06138871f, -0.00809329f, -0.22005402f, 0.04899865f, 0.04882241f, 0.10989294f, 
    0.00056919f, 0.05995353f, 0.04301331f, 0.05210579f, 0.00096404f, 0.03533772f, -0.00153724f, -0.00049912f, 
    0.05215646f, -0.04314846f, -0.00160809f, 0.01861468f, 0.07140743f, -0.06580064f, 0.08602086f, -0.11038378f, 
    0.00167249f, 0.12677646f, 0.14043476f, -0.02112686f, 0.07207962f, -0.02931301f, -0.05086181f, 0.02199475f, 
    0.13164021f, 0.00294744f, 0.00129126f, 0.01716853f, -0.02027536f, 0.04551392f, -0.07713940f, 0.12657496f, 
    -0.04316253f, -0.04373414f, 0.09122662f, 0.04037661f, 0.17084031f, 0.06323768f, 0.05707933f, 0.05557647f, 
    -0.04378232f, 0.12138114f, 0.05138205f, 0.01336988f, -0.33988041f, -0.08792549f, -0.17557409f, -0.21708131f, 
    0.11804499f, 0.12702867f, 0.02355143f, -0.00314008f, 0.01917210f, -0.04729806f, -0.00166981f, 0.06425600f, 
    -0.20522691f, -0.07417722f, -0.14242613f, -0.33346152f, 0.15599683f, 0.07555512f, 0.00257397f, -0.02464490f, 
    0.02138949f, -0.03794626f, -0.04170808f, 0.01346002f, 0.20317838f, -0.01751619f, -0.16816813f, 0.30589387f, 
    0.05468340f, 0.01010057f, 0.01590392f, -0.01567049f, 0.06552528f, -0.01392817f, 0.00666523f, 0.06981692f, 
    0.07773953f, -0.06815521f, -0.04354358f, 0.10431039f, 0.01907959f, -0.01205326f, 0.03883781f, 0.08963918f, 
    0.00008047f, 0.20166185f, 0.01542075f, -0.03050081f, 0.30734447f, -0.07607709f, -0.01240485f, 0.09886093f, 
    -0.02604992f, -0.03427877f, -0.01660022f, 0.04563420f, 0.03941430f, 0.03491538f, 0.07308191f, 0.01132794f, 
    -0.07726821f, -0.13854313f, -0.05039094f, -0.06887025f, 0.02252719f, 0.08409902f, -0.10900177f, 0.01974950f, 
    0.00565862f, 0.03294336f, -0.02261976f, 0.04160479f, -0.21188232f, -0.14860404f, 0.09022728f, 0.15339439f, 
    0.05460752f, 0.02530263f, -0.02592604f, -0.05148873f, 0.04295966f, 0.06834209f, 0.06203969f, 0.08107882f, 
    -0.20946683f, 0.13258371f, -0.22613083f, -0.26495829f, 0.25470442f, 0.06611061f, 0.02974412f, -0.01929123f, 
    0.01594894f, -0.00290255f, -0.10609211f, -0.06559320f, -0.00518588f, -0.06458734f, 0.21901360f, -0.03363514f, 
    0.11673175f, 0.10542145f, 0.12179124f, -0.03821315f, 0.05480347f, 0.02722076f, -0.02156830f, 0.03479586f, 
    0.14284383f, -0.02051435f, 0.06273857f, 0.00176127f, 0.08392408f, 0.16495438f, -0.07399594f, -0.04647597f, 
    0.03923750f, -0.00081549f, 0.03740951f, -0.10603844f, 0.13104425f, 0.05582910f, 0.04541428f, 0.04278559f, 
    0.06247903f, 0.09512123f, 0.00708184f, -0.03250651f, -0.09579016f, 0.18378532f, 0.05867361f, 0.07181001f, 
    -0.15849367f, 0.21248451f, -0.00577383f, -0.17285566f, 0.25837758f, -0.02171041f, 0.06451429f, -0.08094052f, 
    0.03592258f, -0.00826917f, 0.03642006f, 0.04778090f, -0.27544653f, 0.11929514f, 0.03690791f, 0.19215022f, 
    -0.02882095f, 0.07741068f, 0.00617901f, -0.15406805f, 0.08216605f, -0.02123889f, 0.02651597f, 0.02640966f, 
    -0.12633345f, -0.10969324f, 0.00832266f, -0.28390068f, 0.13098352f, 0.06957819f, -0.05048955f, 0.02249514f, 
    0.07260012f, -0.03647126f, -0.00775028f, 0.02859233f, 0.04774533f, -0.00218646f, -0.10553345f, -0.07276577f, 
    0.06456903f, -0.18207131f, 0.09466812f, -0.01671381f, -0.08932909f, -0.12439064f, 0.03650804f, 0.05310373f, 
    0.03043234f, 0.00118171f, -0.01502631f, -0.10958151f, 0.04442044f, 0.16302405f, -0.06141037f, -0.07361480f, 
    0.10874175f, 0.03036024f, -0.00174582f, 0.05922528f, 0.01370502f, -0.05523119f, -0.13300517f, 0.28467518f, 
    -0.00440027f, 0.11039373f, -0.02465581f, 0.02598955f, 0.04971847f, 0.09468154f, -0.01708087f, 0.12669557f, 
    -0.22229718f, 0.05023897f, -0.16761179f, -0.00663292f, 0.11169333f, -0.04602868f, 0.13023596f, 0.02994031f, 
    -0.00595139f, -0.05257982f, -0.00865109f, -0.04155210f, 0.28141907f, 0.04006137f, -0.11918073f, 0.05891914f, 
    0.14454037f, -0.13847715f, 0.06215968f, -0.01091397f, 0.04436803f, 0.07506756f, 0.06636289f, 0.04726854f, 
    -0.13992329f, 0.14747547f, -0.14452772f, -0.00751346f, 0.10992731f, -0.02103228f, 0.03174249f, -0.00137094f, 
    -0.10031606f, -0.00671635f, 0.07788660f, -0.00394841f, -0.17620791f, 0.05478331f, 0.20367584f, -0.07887246f, 
    0.11271228f, -0.05815494f, -0.06054918f, -0.07963536f, -0.02184826f, 0.02151197f, -0.14073099f, 0.01131971f, 
    -0.16142908f, 0.19731402f, -0.06122520f, -0.20488855f, 0.19392772f, -0.13062006f, 0.06162593f, 0.13545899f, 
    0.00638141f, -0.00317290f, 0.04488265f, 0.08461544f, 0.02116735f, -0.17029218f, 0.22333583f, 0.04078005f, 
    -0.03726566f, 0.05337719f, 0.03449305f, -0.00652569f, -0.09531387f, -0.07731939f, 0.00091226f, 0.02480270f, 
    -0.19095863f, -0.05036851f, 0.01489949f, 0.13679388f, 0.02828018f, -0.00649158f, 0.13021496f, 0.01859115f, 
    -0.03005530f, -0.10362514f, -0.05064458f, -0.06228812f, -0.32267356f, -0.02829180f, -0.18619289f, -0.22448964f, 
    0.08222765f, -0.13813965f, 0.04349049f, -0.03158970f, -0.03871539f, -0.03739915f, 0.02153419f, -0.00740817f, 
    0.32275546f, -0.03637926f, 0.05664484f, 0.24666737f, 0.06979435f, 0.11200727f, -0.01516105f, -0.12666436f, 
    -0.06543790f, -0.11260538f, 0.00564239f, 0.02652543f, -0.20903154f, -0.05147082f, -0.15902206f, -0.01359528f, 
    0.04677376f, -0.07891604f, -0.04227726f, 0.19308628f, 0.05187479f, 0.09192502f, 0.04981194f, 0.01619404f, 
    0.15393247f, 0.20059891f, -0.08711612f, -0.04693845f, 0.07340250f, -0.04975862f, 0.09454861f, -0.00357797f, 
    0.12269292f, 0.09390145f, 0.11871870f, 0.01298628f, -0.00983159f, -0.16432391f, 0.17014158f, 0.09517670f, 
    0.04542679f, 0.03490498f, -0.02408295f, -0.05573824f, 0.07892220f, -0.01356274f, 0.01701764f, 0.01772832f, 
    -0.08594827f, 0.11038700f, -0.20265910f, -0.04868042f, 0.03301072f, 0.12884955f, 0.20753606f, -0.09978689f, 
    -0.00567156f, 0.05431880f, 0.02597142f, -0.13243464f, 0.26003966f, 0.03268410f, -0.18313859f, 0.13549300f, 
    0.06598447f, 0.04435909f, -0.10641201f, -0.02784022f, 0.06628795f, 0.02016690f, -0.06702757f, -0.01305524f, 
    -0.45610395f, -0.03751857f, 0.28455114f, -0.17592806f, -0.14268100f, -0.09701993f, 0.08216213f, 0.11753358f, 
    0.04407652f, 0.10010997f, 0.08260707f, 0.15343411f, 0.14673772f, -0.37707394f, 0.08853738f, 0.17014681f, 
    -0.08112462f, -0.06873892f, 0.08111773f, -0.01744054f, -0.04012964f, 0.07171861f, 0.03328502f, 0.01189066f, 
    0.11376481f, -0.02333693f, -0.02202053f, 0.08421626f, 0.02830345f, 0.13322766f, 0.02425177f, 0.06170858f, 
    0.12352338f, 0.13231501f, -0.19548686f, 0.14560173f, 0.25036284f, -0.08210486f, -0.08232110f, 0.10239483f, 
    0.05858728f, 0.02622405f, 0.04211475f, -0.07321616f, 0.05280114f, 0.06788311f, 0.03777835f, 0.06876498f, 
    0.30541748f, -0.16270928f, -0.23267515f, 0.17245111f, 0.17386968f, -0.09276471f, 0.14017557f, 0.06724557f, 
    0.11118132f, -0.08213997f, 0.18757774f, 0.10785589f, -0.45521361f, 0.24089712f, -0.05386360f, 0.32481650f, 
    0.00804520f, 0.13857096f, -0.17384343f, 0.13818333f, 0.06881383f, -0.01800098f, 0.21964130f, -0.01906738f, 
    -0.00201433f, -0.32764181f, 0.01938742f, -0.14941283f, 0.07135420f, 0.01557238f, 0.05897642f, -0.14334682f, 
    0.05532600f, -0.06003157f, 0.05326571f, 0.09853221f, 0.16919057f, 0.15596186f, 0.18183805f, -0.08934227f, 
    0.04180987f, 0.13022394f, -0.06263348f, -0.09763817f, 0.04713394f, -0.02331174f, 0.20019242f, 0.01815555f, 
    0.10336294f, 0.06023773f, 0.00102187f, 0.13769077f, 0.04511978f, 0.05312043f, 0.02922527f, 0.00979008f, 
    -0.03901450f, -0.02525577f, 0.01988096f, 0.14540340f, -0.26268291f, -0.05412607f, 0.03172833f, 0.07719171f, 
    -0.07003463f, 0.09375484f, 0.08191857f, -0.05864725f, 0.00576091f, 0.08968992f, -0.12347685f, -0.00026879f, 
    -0.10993724f, 0.04672319f, -0.01295378f, 0.01256450f, 0.00997399f, 0.01159730f, 0.06808253f, 0.02376032f, 
    0.15910608f, -0.03716752f, 0.04357194f, -0.01844771f, 0.36436662f, -0.07368743f, -0.07923193f, 0.15578003f, 
    0.00923711f, -0.07871523f, 0.00372509f, 0.16666755f, 0.15043381f, 0.01939582f, 0.02574014f, 0.12745093f, 
    0.00785462f, 0.20666195f, 0.11752442f, 0.23496073f, 0.04231402f, 0.15463342f, 0.05659901f, 0.02127929f, 
    -0.02403380f, 0.21911894f, 0.09796999f, 0.05841832f, 0.29695642f, -0.09628236f, -0.27425802f, 0.05788875f, 
    -0.06508697f, 0.07105988f, -0.01365965f, -0.18256296f, -0.05797036f, -0.04168668f, -0.04938696f, -0.05053918f, 
    0.14947084f, 0.20662850f, -0.06971880f, 0.00739253f, 0.00574909f, 0.02481727f, -0.09146319f, 0.04819388f, 
    -0.00090956f, 0.11409874f, 0.14647755f, 0.05960177f, 0.19775406f, -0.25850996f, 0.00907518f, 0.03140662f, 
    0.02416881f, 0.04969308f, 0.02893805f, 0.06285175f, 0.06367777f, -0.00582075f, 0.11919485f, -0.01069897f, 
    0.13162504f, -0.14141934f, -0.01173774f, 0.00913232f, 0.00870655f, 0.06803695f, 0.04117630f, -0.01604192f, 
    -0.02153941f, 0.04117493f, -0.08438259f, 0.23637958f, -0.05304609f, 0.09076864f, 0.03407836f, 0.14153965f, 
    -0.04938184f, -0.13009553f, 0.05447082f, 0.08138712f, 0.05281834f, 0.01953072f, 0.00827118f, 0.08339324f, 
    -0.33799529f, -0.00867784f, 0.21437462f, -0.06128174f, 0.05359019f, 0.09004418f, 0.03249279f, 0.02548195f, 
    0.06193021f, -0.01011559f, -0.02026676f, 0.32928929f, 0.22703958f, 0.10273137f, -0.08928073f, 0.19884649f, 
    0.04739561f, 0.01608604f, 0.02424318f, -0.00525999f, -0.00803057f, 0.03398546f, 0.04898453f, -0.04938675f, 
    0.09213114f, 0.07704920f, 0.12446964f, -0.04770379f, 0.04882541f, -0.06795854f, -0.04118441f, -0.19128342f, 
    0.05925011f, -0.10573511f, 0.09365630f, 0.00588361f, 0.11363094f, -0.07778405f, 0.06872851f, 0.25181171f, 
    -0.04931524f, 0.12234624f, 0.12454779f, 0.10854616f, 0.12693647f, -0.09832768f, 0.07999837f, -0.02745816f, 
    0.03579242f, 0.18471317f, -0.03362855f, -0.06494062f, -0.00970593f, 0.13680138f, -0.02689334f, -0.05525658f, 
    0.09973305f, -0.07699189f, -0.05357041f, -0.00658985f, 0.16361414f, -0.07571130f, -0.01636934f, -0.19623303f, 
    0.03754170f, -0.04589187f, 0.15830205f, 0.00893287f, 0.08081841f, 0.16213872f, -0.13436566f, -0.04877546f, 
    0.17322245f, 0.18653551f, 0.07933667f, -0.00902829f, -0.06629583f, 0.05876909f, 0.00363090f, 0.00357653f, 
    0.04892937f, -0.01919194f, 0.11004756f, -0.09209485f, 0.21250559f, 0.06249260f, -0.19266824f, 0.12012665f, 
    0.05959607f, 0.09244954f, 0.00749803f, -0.02218499f, 0.07990780f, 0.16114743f, 0.12932421f, 0.13410433f, 
    0.15191029f, 0.13801275f, 0.01886665f, -0.09983255f, 0.03394508f, 0.08594118f, 0.02185529f, -0.03747283f, 
    0.03169762f, -0.01850958f, 0.10790608f, 0.05620457f, -0.11967639f, 0.01474373f, 0.16096641f, 0.06053812f, 
    0.04487075f, 0.10781737f, 0.10056176f, 0.09434962f, 0.12653853f, 0.07100045f, 0.01125072f, 0.14837348f, 
    0.27697191f, -0.06206750f, -0.18000667f, 0.34489411f, 0.01846894f, -0.01581184f, 0.13568354f, 0.16694798f, 
    0.02333849f, -0.02658681f, 0.01515652f, 0.04294090f, 0.03539570f, -0.08636149f, -0.17448977f, 0.24225859f, 
    0.17548500f, -0.00560872f, -0.01722303f, -0.07575990f, -0.01552882f, -0.00636807f, 0.19147982f, 0.08488575f, 
    -0.14095570f, 0.17291027f, 0.01203620f, -0.00938126f, 0.04878822f, 0.03045729f, 0.03477917f, -0.05413911f, 
    0.01961688f, 0.03525599f, 0.22534336f, -0.06087699f, 0.04992920f, 0.14135131f, 0.07354688f, -0.06552418f, 
    0.01725218f, -0.09384993f, 0.12423926f, -0.05281667f, -0.04179724f, 0.08988063f, 0.09521557f, 0.19732273f, 
    -0.09655782f, 0.12558298f, 0.01597675f, -0.15018904f, 0.03715077f, 0.06833376f, 0.02665630f, 0.03556601f, 
    0.03598594f, -0.05553050f, 0.20314568f, -0.01470822f, 0.03713814f, -0.15533328f, -0.04412341f, -0.08859490f, 
    0.09357348f, 0.02715624f, -0.04387204f, -0.03662704f, -0.00584608f, 0.03199768f, 0.02477135f, 0.09066332f, 
    0.09288739f, -0.11099643f, -0.02745915f, -0.12818964f, 0.00325273f, 0.05948417f, -0.07626742f, 0.03770483f, 
    0.01586302f, -0.05086692f, 0.17181501f, -0.06687880f, 0.29589042f, 0.11110219f, 0.04788999f, 0.15473668f, 
    0.12550190f, -0.01427910f, -0.04811352f, -0.02943506f, -0.02572080f, 0.16016439f, 0.18003473f, -0.04219737f, 
    0.07961710f, 0.19070068f, 0.00043481f, 0.07198294f, 0.11570079f, 0.09673999f, 0.14882140f, 0.03220797f, 
    0.06787131f, 0.00064831f, -0.11154157f, 0.04694776f, 0.11618852f, -0.12276819f, -0.11041836f, 0.37661621f, 
    -0.00975177f, 0.01504401f, 0.03234479f, 0.04400416f, 0.04410430f, 0.03579191f, 0.06745429f, -0.14551258f, 
    0.01290032f, 0.19907641f, -0.10126811f, -0.18280156f, 0.05924400f, -0.02966071f, -0.14423586f, -0.02329373f, 
    0.03565063f, 0.10624478f, -0.10347910f, -0.00937071f, 0.06057285f, 0.16261680f, -0.11328442f, 0.01649591f, 
    0.07964068f, 0.06959740f, -0.21520479f, -0.00765096f, 0.12662709f, -0.03995831f, 0.11361879f, 0.00135583f, 
    0.11517178f, -0.24862176f, 0.04609153f, -0.00850223f, -0.01897744f, 0.08536603f, 0.04162579f, 0.11247379f, 
    0.04337709f, 0.01375175f, 0.11790321f, 0.07348158f, -0.26977330f, 0.09211477f, 0.17013304f, 0.14493403f, 
    -0.04601787f, 0.02749872f, -0.11913987f, 0.18196802f, 0.04636335f, -0.05430433f, 0.05645716f, -0.08575700f, 
    0.29968897f, 0.17330308f, -0.02264719f, -0.03718644f, 0.08640804f, 0.01875792f, -0.24210878f, 0.15281077f, 
    -0.00553429f, 0.06650995f, 0.12634392f, -0.15853356f, 0.24691479f, 0.13635421f, 0.01274541f, -0.00616348f, 
    0.07438792f, 0.06131899f, -0.12110121f, -0.08237002f, -0.03223265f, -0.01153738f, 0.17632590f, -0.22502902f, 
    0.08351162f, -0.10560767f, 0.08125012f, -0.01550222f, -0.10449079f, 0.04372934f, 0.04560696f, -0.03339985f, 
    -0.02109205f, 0.10754007f, -0.05099667f, -0.14422002f, 0.22616549f, 0.20099910f, -0.14981659f, 0.01446789f, 
    0.01282095f, -0.17338410f, -0.09873651f, 0.02806510f, 0.00041287f, -0.01596701f, 0.06371713f, -0.00075124f, 
    0.28758296f, -0.13836676f, -0.01905298f, 0.07361612f, 0.06232120f, -0.13139112f, 0.11648756f, -0.05292428f, 
    0.01813068f, -0.07141456f, 0.09555594f, 0.00023008f, -0.12380143f, 0.09714498f, 0.14532381f, -0.19838235f, 
    0.04101985f, 0.07174066f, 0.02498020f, -0.04745143f, -0.00161064f, 0.02163517f, -0.08649644f, -0.13934779f, 
    0.09774125f, 0.07745674f, -0.14402717f, -0.11604259f, 0.12763292f, 0.02897384f, -0.02172694f, 0.02557107f, 
    0.04307169f, 0.02625629f, -0.12478220f, 0.09181082f, 0.14677495f, 0.07630523f, -0.09897000f, 0.19247344f, 
    0.06751446f, 0.17605606f, 0.09254806f, 0.01386207f, 0.03430713f, -0.04230021f, 0.09660880f, -0.09177551f, 
    -0.41171864f, -0.11696266f, 0.21455118f, -0.02562083f, 0.07721008f, -0.00544200f, 0.09261377f, 0.06807325f, 
    0.01516396f, 0.07282790f, -0.04960392f, -0.00532675f, 0.15906502f, 0.10481757f, 0.01312082f, 0.15162893f, 
    0.01136341f, -0.08348975f, -0.12650095f, 0.01611457f, -0.16792375f, 0.14635094f, 0.10351565f, 0.14791805f, 
    -0.12806180f, -0.10908318f, -0.00503756f, -0.12808898f, -0.03913949f, -0.10594181f, -0.09175861f, 0.02539252f, 
    0.03652059f, -0.10358683f, 0.00597876f, 0.01189194f, 0.42779869f, 0.08077151f, 0.00777208f, 0.09827303f, 
    0.17476769f, -0.07110500f, -0.08899056f, 0.07863619f, 0.18290073f, -0.05678115f, 0.17168950f, 0.09884790f, 
    -0.14403559f, 0.22765471f, -0.07149521f, -0.21966285f, 0.11520894f, -0.05444439f, -0.07478777f, 0.14386842f, 
    -0.10235376f, 0.08952487f, 0.09535117f, -0.04200549f, 0.15409344f, 0.04625995f, -0.19547449f, 0.01372904f, 
    0.08082245f, 0.05414159f, 0.01726145f, -0.03408222f, -0.02554562f, -0.08220793f, 0.02794849f, 0.14765613f, 
    0.14177679f, -0.04228646f, -0.02668386f, -0.10668571f, -0.06378035f, 0.11242539f, -0.03690270f, -0.20515774f, 
    0.00586529f, 0.10195988f, -0.08972370f, -0.04332176f, -0.22482072f, -0.11419080f, -0.07285824f, -0.06577052f, 
    0.07165013f, -0.01664843f, -0.07551817f, 0.10212401f, -0.00984352f, -0.07782289f, 0.11002239f, 0.14766166f, 
    0.32232639f, 0.24667488f, 0.39228004f, -0.33465818f, 0.00117535f, 0.08762121f, 0.26393747f, -0.08732893f, 
    -0.10015943f, 0.12029146f, -0.00421672f, -0.07028656f, -0.13181600f, -0.08240578f, 0.18321964f, -0.04937068f, 
    0.09392089f, -0.08917953f, 0.10340067f, -0.01802566f, -0.00131727f, -0.02503045f, -0.11137398f, -0.08736106f, 
    -0.13879040f, 0.21161205f, 0.09819379f, 0.00841304f, 0.12118227f, 0.01111771f, 0.14645559f, 0.16950731f, 
    0.00649963f, -0.10863698f, -0.02796308f, -0.11367106f, 0.12788950f, -0.03144589f, -0.03561492f, 0.23976006f, 
    0.17540352f, -0.11096720f, 0.00955233f, 0.04657717f, 0.11141950f, 0.05839340f, -0.06710426f, 0.10017980f, 
    0.08260433f, 0.41252530f, -0.04994959f, 0.00723556f, 0.09164041f, 0.00918817f, -0.07732399f, -0.10715644f, 
    -0.01242281f, -0.00110194f, 0.08647337f, -0.03860391f, 0.49573779f, 0.15563422f, -0.12451937f, 0.06962021f, 
    -0.04540406f, -0.05084223f, 0.01231734f, -0.09053492f, 0.09172033f, -0.00234433f, 0.08053479f, 0.02136508f, 
    -0.10018098f, 0.12984972f, 0.02690661f, -0.05999302f, -0.01450386f, -0.21438015f, -0.02740234f, -0.01457010f, 
    -0.07460948f, -0.10304043f, 0.06887956f, -0.15893932f, 0.06491821f, -0.08932122f, -0.07266413f, 0.32933837f, 
    -0.03429903f, 0.08706934f, 0.06749146f, 0.14571603f, 0.04656341f, 0.02213915f, -0.02426384f, 0.01624268f, 
    -0.03633774f, 0.00164910f, 0.01367416f, 0.02908127f, -0.02263911f, 0.00945884f, -0.00358878f, 0.01647400f, 
    -0.00205136f, 0.02616688f, 0.02734681f, 0.02452786f, -0.01736059f, 0.02338864f, -0.02466572f, -0.01417000f, 
    0.02513276f, 0.00632515f, 0.01771499f, 0.03196468f, -0.00919455f, 0.00094019f, -0.00438774f, -0.02210365f, 
    0.00024887f, -0.01617727f, 0.00274257f, -0.02730780f, 0.00190646f, 0.02994677f, 0.01242451f, 0.02778224f, 
    -0.01616485f, -0.03554274f, -0.00005773f, -0.02090383f, 0.01038775f, -0.01100977f, 0.01803331f, 0.03049251f, 
    0.01380137f, -0.01832447f, -0.03129010f, 0.00698012f, -0.03725552f, 0.02191925f, -0.03132375f, -0.00028236f, 
    -0.00692667f, -0.02062264f, -0.01589851f, -0.03001337f, -0.03138325f, -0.03219271f, 0.02459111f, -0.00951757f, 
    0.01768602f, 0.00175641f, -0.02295100f, -0.01462622f, 0.03184786f, -0.00317685f, -0.02077930f, 0.02731497f, 
    0.01584189f, -0.02387079f, 0.00661587f, 0.01980739f, -0.03128331f, 0.00989673f, 0.00292426f, 0.00029974f, 
    0.01973017f, 0.02654577f, -0.01173268f, 0.00113912f, 0.00960038f, -0.02744151f, 0.02190939f, 0.02261762f, 
    -0.02061232f, -0.03201282f, -0.02194897f, -0.03211203f, -0.01172128f, 0.02231515f, -0.03069966f, 0.01527687f, 
    -0.02151080f, 0.02093529f, -0.03573548f, 0.00434263f, 0.02372230f, 0.02759791f, -0.00710966f, 0.00903028f, 
    -0.02730092f, -0.00903162f, 0.00453408f, 0.00795722f, -0.02630757f, 0.02058995f, 0.02646438f, 0.01281277f, 
    -0.02089462f, -0.00657999f, -0.01662114f, -0.01794261f, -0.02952514f, 0.00804976f, -0.00209511f, 0.00461989f, 
    0.02152168f, 0.02945467f, -0.02284783f, -0.01320993f, 0.02656446f, 0.01470411f, 0.01531749f, -0.03330997f, 
    0.01331811f, 0.01359179f, 0.02764209f, -0.04078423f, 0.01002959f, -0.03314455f, 0.02899576f, 0.00813537f, 
    0.00067893f, -0.01300608f, -0.01914493f, 0.01626161f, 0.01291734f, 0.01224726f, 0.02590164f, 0.02014725f, 
    0.02072577f, -0.02995387f, 0.00418574f, 0.01546061f, 0.02900403f, -0.03252494f, 0.00871724f, 0.01489602f, 
    -0.00288806f, -0.02571720f, -0.02388305f, 0.02964670f, -0.01367202f, 0.02080376f, -0.00084220f, 0.01557533f, 
    0.02964173f, 0.01416323f, -0.01366733f, 0.02120060f, -0.03585845f, -0.01074571f, -0.00012723f, -0.01575196f, 
    0.01606712f, -0.00457711f, -0.01627775f, -0.02644174f, -0.00483545f, 0.00110733f, -0.02481223f, -0.01794531f, 
    -0.01700914f, 0.01844931f, -0.01251830f, -0.00247708f, 0.01637991f, -0.03429694f, -0.02470013f, 0.01831128f, 
    0.01108725f, 0.02850655f, 0.01170088f, 0.01736279f, -0.00424845f, -0.02244558f, 0.02595891f, 0.02289185f, 
    0.02242303f, 0.02910017f, -0.03165967f, 0.01458230f, 0.00167463f, 0.03489925f, -0.00655485f, -0.02754866f, 
    0.00648508f, -0.00329527f, 0.00310185f, -0.00355456f, 0.03846397f, -0.03832213f, -0.01550303f, -0.03796064f, 
    0.02911508f, -0.02492402f, 0.02174145f, -0.03276711f, 0.01379215f, 0.03041148f, -0.00472063f, 0.02519126f, 
    -0.02477669f, -0.00071894f, -0.03467900f, -0.01739063f, -0.01760444f, -0.03796084f, 0.01403822f, 0.00022742f, 
    -0.00545199f, -0.03511205f, -0.02281330f, -0.03062582f, -0.01589531f, -0.04054381f, 0.01838408f, -0.00742898f, 
    -0.03818538f, 0.02501872f, 0.02966905f, 0.00839524f, 0.00920173f, 0.03123489f, -0.00477987f, 0.02528168f, 
    -0.00411970f, -0.01933045f, -0.01993834f, 0.00841925f, -0.00537480f, -0.00958398f, 0.01048302f, 0.02325365f, 
    0.01574182f, 0.02742014f, -0.00572599f, 0.00331637f, 0.01858297f, -0.00668978f, 0.00877328f, 0.02758367f, 
    0.01859344f, -0.03601974f, -0.02580813f, -0.02137518f, -0.03370048f, -0.03034778f, -0.01941908f, 0.00485229f, 
    0.03384192f, -0.00126251f, 0.02074339f, -0.01773123f, 0.02483518f, -0.02511307f, -0.00108058f, -0.00464056f, 
    -0.01471498f, 0.01829200f, -0.02343671f, -0.00886826f, 0.02884340f, -0.02569785f, 0.01462373f, 0.02555203f, 
    -0.00473721f, -0.01911169f, 0.01904739f, -0.02869421f, 0.01112950f, -0.03414095f, -0.02048763f, -0.02500719f, 
    -0.01038009f, -0.03197789f, -0.01791769f, -0.03849564f, 0.01239223f, 0.02837241f, 0.02486651f, -0.01415998f, 
    0.00242913f, -0.00657240f, -0.01852004f, 0.03223060f, -0.01079508f, -0.01605735f, -0.03495541f, -0.02997310f, 
    -0.03130414f, -0.01538793f, -0.03210049f, -0.00128602f, 0.02783682f, 0.01124602f, -0.01188869f, -0.03202015f, 
    0.01142517f, 0.02210178f, -0.00881016f, -0.01177199f, 0.02913721f, -0.03909728f, 0.01545502f, -0.03247650f, 
    -0.01287085f, 0.01908542f, -0.03732253f, 0.02614014f, -0.01571850f, -0.03182064f, 0.00369038f, -0.01583554f, 
    0.03832954f, -0.02997829f, -0.00375346f, 0.03227397f, -0.02968756f, 0.03085747f, 0.00002535f, 0.02572140f, 
    0.02569582f, 0.02480216f, -0.00993906f, -0.03944346f, -0.00005607f, -0.03260688f, -0.00491027f, 0.00920715f, 
    -0.00230407f, -0.00398285f, -0.01473167f, -0.01249444f, -0.02947141f, 0.00215725f, 0.02194659f, 0.01870874f, 
    0.03311230f, 0.01992413f, 0.00733320f, 0.03196359f, -0.03455050f, -0.02285222f, -0.02570719f, -0.03800752f, 
    -0.02339710f, -0.02047915f, -0.02014510f, -0.00054625f, -0.03468283f, 0.03370207f, 0.01476976f, -0.00045466f, 
    -0.00047639f, 0.02595124f, -0.01352713f, 0.00937704f, -0.01096610f, 0.03362898f, -0.03452763f, 0.00799120f, 
    -0.03156906f, 0.01928634f, -0.00148003f, -0.01566838f, 0.02022213f, -0.03586617f, 0.00436864f, 0.00891767f, 
    0.02753818f, 0.00167206f, 0.00799986f, 0.03753308f, -0.01352013f, -0.01704308f, -0.00786486f, -0.03384507f, 
    0.00997360f, -0.01086362f, -0.02512275f, -0.00112150f, 0.02821776f, -0.02319525f, -0.00322343f, -0.02133657f, 
    0.00747812f, 0.00137680f, 0.00679528f, 0.01609925f, -0.03111151f, -0.03764356f, 0.01995486f, 0.00661252f, 
    -0.01342885f, 0.02869769f, -0.03783109f, -0.00811377f, -0.00032571f, 0.00143303f, 0.00986680f, -0.03848594f, 
    -0.00146668f, -0.00958997f, -0.02865166f, -0.00531601f, 0.02476833f, 0.02079006f, -0.02585364f, -0.01193311f, 
    0.03292426f, 0.02366973f, -0.03381465f, -0.00315197f, 0.03250744f, -0.01581722f, -0.03582549f, 0.01522235f, 
    0.02589470f, 0.01725581f, -0.03600020f, -0.02803016f, 0.01654474f, -0.02265438f, 0.00606926f, -0.00060379f, 
    -0.00239864f, 0.01326847f, 0.02689040f, -0.03073350f, -0.00471397f, -0.03533707f, -0.02385724f, 0.00454645f, 
    0.02654074f, -0.03464311f, -0.02942977f, 0.02762130f, -0.03152153f, -0.03134481f, -0.03550754f, -0.00964085f, 
    -0.03558707f, 0.02169320f, 0.00020234f, -0.02434935f, -0.01833390f, 0.00781365f, -0.00238702f, 0.02790263f, 
    -0.03445052f, 0.02739052f, -0.02682026f, 0.01580655f, 0.00815904f, -0.00114988f, 0.02102863f, 0.00984151f, 
    -0.02675671f, -0.02581507f, -0.02100576f, -0.01852725f, 0.02543817f, -0.01080303f, 0.00475412f, 0.00721324f, 
    0.00323064f, -0.01871687f, -0.02441194f, -0.02206328f, -0.02546999f, -0.00187118f, 0.03531761f, -0.01968331f, 
    0.00422690f, -0.01009424f, -0.03443354f, -0.03426010f, -0.00674823f, 0.01236578f, -0.00708485f, -0.01940211f, 
    -0.01769964f, 0.00918723f, -0.03151088f, 0.03277846f, 0.00571752f, 0.00760782f, 0.02054660f, 0.01848334f, 
    -0.03314077f, 0.02022611f, 0.00608871f, -0.03921256f, 0.02754064f, -0.00687194f, -0.02438023f, 0.02757157f, 
    0.00564668f, 0.01658382f, 0.00800947f, 0.01119028f, 0.00422661f, -0.02180731f, 0.03055303f, 0.02279802f, 
    0.02621552f, -0.00861323f, -0.02052632f, 0.02788739f, 0.02647754f, -0.02197642f, -0.01190848f, 0.00831473f, 
    -0.00505279f, -0.03215394f, 0.00457392f, 0.02045751f, 0.00349541f, -0.02306295f, -0.01237239f, 0.03016800f, 
    -0.00571511f, -0.03009779f, 0.02347501f, 0.02919574f, 0.02372427f, -0.03456302f, 0.00616427f, -0.02756594f, 
    0.00659938f, 0.02099844f, -0.01732880f, -0.02193318f, -0.01382414f, -0.01641149f, -0.01931105f, -0.03010729f, 
    -0.03593157f, -0.00148047f, -0.02964508f, -0.02891352f, 0.00618729f, 0.02279952f, -0.02485427f, -0.03412642f, 
    -0.03892241f, 0.00071651f, -0.00783864f, -0.01804036f, -0.01306630f, 0.00601146f, 0.01870677f, -0.02447973f, 
    -0.00123674f, 0.03152518f, -0.01749808f, 0.02494576f, 0.02105913f, 0.02159199f, -0.03312593f, 0.00641925f, 
    -0.00899156f, 0.01756072f, 0.02779003f, -0.03035233f, 0.02636916f, 0.01077874f, 0.00252404f, -0.01976380f, 
    -0.02297325f, -0.01062052f, -0.01631988f, 0.02113853f, 0.01298197f, 0.02327741f, -0.02258832f, -0.02422132f, 
    0.02016538f, -0.01196137f, 0.03360317f, -0.03244000f, 0.00425961f, -0.02841180f, 0.02722866f, -0.02020837f, 
    -0.01452608f, 0.01709221f, -0.02654890f, -0.00253312f, -0.00007757f, -0.02147606f, -0.01131015f, -0.03632578f, 
    -0.00800530f, 0.01835227f, -0.02635033f, 0.00756669f, 0.02165028f, -0.02138677f, 0.02985824f, -0.02599509f, 
    0.03353723f, 0.00032748f, 0.01684544f, 0.01573077f, 0.02975769f, -0.03418778f, 0.00113894f, 0.01021169f, 
    0.01492030f, -0.02773241f, 0.02068891f, -0.02592937f, 0.02639736f, 0.00439573f, 0.02453431f, 0.01757211f, 
    0.00067878f, 0.00393216f, 0.03035611f, -0.00234886f, -0.01452578f, -0.03292721f, -0.01270617f, -0.02519843f, 
    -0.02978056f, -0.00222938f, -0.01325630f, -0.00293752f, 0.02109184f, -0.01614905f, 0.00571542f, 0.01963142f, 
    0.01040247f, 0.02631416f, 0.00842879f, -0.02370651f, 0.00542592f, -0.01025888f, -0.00550849f, 0.00261492f, 
    0.02390285f, -0.03411828f, -0.00783809f, -0.02682228f, 0.02648724f, 0.03283735f, -0.00650212f, 0.01366600f, 
    -0.02854656f, 0.02824660f, 0.00895088f, -0.00047333f, -0.02846633f, -0.00512783f, -0.01274542f, -0.02928703f, 
    0.00998267f, 0.00254419f, 0.00810564f, -0.03902992f, 0.02395784f, 0.02295361f, 0.03078939f, 0.02086892f, 
    0.01429053f, 0.00366334f, -0.00685822f, 0.02249153f, -0.01776902f, 0.00239174f, -0.00412040f, -0.01162483f, 
    -0.02869755f, -0.01445594f, 0.02024918f, -0.01895374f, -0.01412171f, -0.00496814f, 0.01541276f, 0.00472918f, 
    0.01620319f, 0.00808336f, 0.03308453f, 0.01394845f, -0.02381347f, -0.03480390f, -0.03493248f, 0.00658116f, 
    0.02230867f, -0.02609224f, -0.03177076f, 0.01218245f, -0.02806981f, -0.00166337f, -0.01057013f, -0.03550753f, 
    0.02393406f, 0.02803509f, 0.02030773f, -0.03394777f, 0.01882381f, 0.00170989f, 0.00028098f, 0.00256135f, 
    -0.02194321f, 0.01378317f, -0.00814577f, -0.03480710f, 0.02500914f, -0.01972505f, -0.02251047f, 0.00434342f, 
    0.02882517f, 0.03110239f, -0.01929658f, -0.01175210f, -0.02821214f, -0.01427992f, -0.00182905f, -0.01445709f, 
    0.01267391f, -0.02301322f, -0.02898228f, 0.03496429f, -0.00818880f, 0.00112388f, 0.02732371f, 0.01556114f, 
    -0.02107081f, -0.03303650f, -0.02870558f, -0.00269415f, -0.01214321f, -0.03705742f, -0.03806857f, -0.03530711f, 
    -0.02540843f, -0.00112782f, 0.00196479f, -0.00307838f, -0.03044131f, -0.00883781f, 0.02609126f, 0.02441422f, 
    -0.00988414f, -0.02695716f, -0.00620858f, 0.03638142f, 0.02712036f, 0.00132939f, -0.01591435f, 0.03020202f, 
    -0.03106618f, 0.01111981f, 0.02306569f, -0.00035875f, -0.02115918f, -0.00932143f, -0.01909661f, -0.03986860f, 
    -0.03458294f, 0.01030806f, -0.01372959f, 0.02040848f, -0.02362946f, 0.01387255f, 0.03124416f, -0.00134437f, 
    -0.01498774f, -0.00285373f, 0.01030927f, 0.01970463f, 0.01828440f, 0.03122692f, 0.02173444f, -0.02408984f, 
    0.01387541f, 0.01714815f, 0.02671444f, -0.00308518f, -0.03113513f, -0.02162605f, -0.01248803f, -0.02299675f, 
    0.02193339f, -0.03640287f, 0.02170657f, -0.02432044f, -0.02803987f, -0.02453045f, -0.00350396f, -0.01769632f, 
    -0.01171849f, 0.02001116f, -0.00801595f, 0.02929837f, 0.02727113f, 0.01400405f, -0.01199981f, -0.01066126f, 
    0.03218671f, -0.00074085f, -0.02395312f, -0.02790835f, 0.03099091f, -0.00573038f, 0.01673804f, -0.03525802f, 
    -0.01293546f, -0.02045698f, 0.02716500f, 0.03086318f, 0.01289817f, -0.01920985f, 0.00718941f, -0.02274587f, 
    0.02084742f, -0.02109293f, 0.02883732f, -0.00883422f, 0.00065270f, -0.00476584f, -0.00856980f, 0.00783465f, 
    0.01442241f, -0.00084128f, 0.02326836f, -0.00336075f, 0.01806970f, -0.00962421f, 0.01105646f, -0.00403904f, 
    0.00069499f, 0.00204462f, 0.01295176f, -0.01115751f, -0.01276415f, -0.03243729f, -0.02056142f, 0.00208717f, 
    0.00814934f, -0.00624418f, -0.00911854f, -0.02003558f, -0.03310585f, -0.01294795f, -0.02174823f, 0.00546327f, 
    -0.00622416f, 0.02128856f, -0.02022201f, -0.02399146f, -0.03078476f, 0.01895057f, -0.00271795f, -0.03826313f, 
    -0.01649152f, 0.01752907f, -0.02194144f, -0.00606762f, -0.00852942f, -0.01947967f, -0.03669070f, -0.03768784f, 
    -0.03303108f, -0.00809935f, -0.00106252f, -0.00738770f, 0.00806218f, -0.03729491f, -0.03096271f, -0.03541992f, 
    0.02931381f, -0.03558535f, 0.03150369f, -0.02247851f, -0.01346922f, 0.02607544f, 0.03157705f, -0.00467436f, 
    -0.03861972f, -0.01169348f, 0.01617971f, -0.02601856f, -0.03801228f, 0.01258182f, -0.02416127f, -0.02428371f, 
    -0.01156372f, -0.01565742f, 0.00569302f, -0.00466586f, 0.03021107f, -0.00601775f, -0.01036958f, 0.02839438f, 
    0.01266927f, -0.03569572f, 0.02628820f, 0.00014299f, -0.02360262f, -0.00717598f, 0.00657817f, 0.00730386f, 
    0.02648938f, 0.01620301f, -0.01283599f, 0.01847272f, 0.01196910f, 0.01863286f, 0.02108141f, 0.01360564f, 
    -0.02970619f, -0.00170919f, 0.01002882f, -0.01845232f, -0.00434195f, 0.00325240f, 0.00598004f, -0.02459746f, 
    0.02186816f, 0.02712524f, 0.02152894f, -0.02104707f, -0.00140647f, -0.00925347f, -0.02684189f, -0.00296495f, 
    -0.01118994f, 0.02301336f, -0.03628631f, -0.00571817f, -0.02043816f, -0.03190969f, -0.01002781f, -0.02178911f, 
    -0.03015740f, -0.00988218f, -0.00152009f, -0.00780874f, -0.03322792f, 0.01520807f, -0.02024435f, -0.01407964f, 
    0.00418537f, -0.02068851f, 0.02703789f, -0.01259412f, -0.03566781f, 0.01254984f, -0.00629091f, -0.02411499f, 
    -0.02951817f, -0.00856623f, -0.03066646f, 0.01735617f, 0.01234190f, -0.03808955f, -0.03890183f, -0.00777103f, 
    0.02595272f, 0.01375351f, 0.02073968f, 0.00813623f, 0.03027462f, -0.00479034f, -0.00344547f, 0.02694913f, 
    0.00684795f, -0.02205227f, -0.00385724f, -0.01185987f, 0.02048590f, -0.01375198f, -0.02395143f, -0.03833550f, 
    0.02071303f, 0.03204969f, 0.01653347f, 0.02460908f, 0.00523340f, -0.03732210f, -0.02280157f, -0.01599541f, 
    0.01743318f, -0.03727607f, 0.00770079f, -0.02687978f, -0.00674781f, -0.00976845f, 0.02982421f, -0.02270739f, 
    -0.02604031f, -0.01743851f, -0.00842435f, 0.00778048f, 0.02081826f, 0.00982743f, 0.02954813f, -0.00254816f, 
    0.01748086f, 0.00439007f, -0.01451467f, -0.00777338f, 0.03156766f, 0.00119114f, 0.02841365f, 0.00814678f, 
    -0.00372911f, -0.00367285f, -0.02332784f, 0.01062800f, -0.02883476f, -0.03504169f, 0.01639092f, -0.00768562f, 
    -0.02416052f, -0.00000207f, 0.01883233f, -0.01777151f, -0.02525544f, -0.01189755f, -0.02975626f, 0.02854185f, 
    0.02822306f, 0.03015636f, 0.00220646f, -0.02166210f, 0.01160426f, 0.02853884f, -0.00674243f, -0.01316779f, 
    -0.00903918f, 0.02515279f, 0.02916954f, -0.01828809f, 0.02491906f, -0.02365078f, -0.00972422f, 0.02218747f, 
    0.01463752f, -0.01812942f, 0.02253528f, -0.02767399f, 0.03376750f, -0.02926272f, 0.00415907f, 0.02472435f, 
    0.00585488f, 0.01977331f, -0.00625317f, 0.01545101f, -0.03769224f, -0.03458087f, 0.01179887f, -0.02944147f, 
    0.02289585f, -0.03350092f, -0.02555543f, 0.01848470f, 0.02629869f, -0.01070889f, 0.02588772f, 0.02022300f, 
    -0.03416266f, -0.02352081f, -0.01712755f, -0.02233047f, -0.00343658f, 0.02783549f, -0.01208294f, -0.03587493f, 
    0.01718022f, -0.01347762f, 0.01093568f, -0.01159277f, -0.02902976f, 0.01552869f, -0.01557908f, -0.00824834f, 
    -0.03090236f, 0.00151782f, -0.02611131f, -0.01578237f, -0.01948630f, -0.02573322f, 0.02026512f, -0.01853557f, 
    0.00980707f, 0.00385315f, 0.00165769f, -0.00677284f, -0.01880371f, 0.02229627f, -0.02288940f, -0.01440146f, 
    -0.03193795f, -0.01109911f, 0.00253985f, -0.00368987f, -0.03154932f, -0.00680305f, -0.01587349f, -0.02642505f, 
    -0.03221958f, -0.01508546f, 0.01795608f, -0.00058834f, 0.03212749f, 0.01213625f, -0.02571592f, 0.00214098f, 
    0.01109097f, 0.02231612f, -0.01139284f, -0.00684608f, -0.01389280f, 0.03009481f, -0.03730655f, 0.00655196f, 
    -0.03533543f, -0.01493300f, 0.01298206f, -0.01462614f, -0.01990017f, -0.00506566f, -0.01504732f, -0.01765432f, 
    0.02841391f, 0.02595430f, 0.02101240f, 0.02036385f, -0.01839256f, -0.02650898f, -0.02007038f, -0.02152056f, 
    -0.03357368f, -0.01359545f, -0.03429990f, -0.00175068f, 0.02621076f, -0.03824687f, -0.02050009f, -0.01036443f, 
    -0.03276434f, -0.01931577f, -0.02372187f, 0.01149338f, -0.02910573f, 0.01688811f, -0.00388871f, 0.01057871f, 
    -0.04055906f, -0.02487459f, 0.00555097f, -0.01585036f, 0.01762500f, -0.02556355f, -0.01459937f, -0.02802391f, 
    -0.00350672f, 0.01784422f, -0.00833859f, 0.03103887f, -0.01987682f, -0.03003167f, 0.01790320f, 0.01793200f, 
    0.01746451f, 0.02059144f, -0.02478140f, -0.01197469f, -0.03862477f, -0.03358390f, 0.00820252f, 0.02092698f, 
    0.03232763f, -0.02681776f, -0.00848562f, -0.01507411f, 0.03580957f, -0.00584686f, 0.01020428f, -0.02845633f, 
    -0.00082979f, -0.01533742f, -0.00722277f, 0.01546037f, -0.03148582f, 0.00852094f, 0.00655705f, 0.01707059f, 
    -0.03712592f, -0.02953911f, 0.01415638f, 0.02683745f, -0.02192231f, -0.02334449f, -0.01091885f, -0.00537263f, 
    -0.01559252f, -0.01665523f, -0.02502559f, -0.01779582f, -0.02785767f, -0.00337886f, -0.02262027f, 0.02313449f, 
    -0.01068240f, -0.03608078f, -0.03332947f, 0.03052991f, -0.00404440f, -0.00426478f, -0.03720391f, -0.00742644f, 
    -0.00399216f, -0.00727231f, -0.03363441f, -0.03536636f, 0.02333707f, -0.02597141f, -0.01158250f, 0.02170124f, 
    -0.02986206f, -0.00640598f, 0.02915454f, -0.03794396f, 0.00422282f, -0.00945377f, -0.02966740f, 0.01501913f, 
    -0.03707443f, 0.01394355f, -0.00450718f, 0.02319372f, -0.01191923f, 0.00806374f, -0.02302887f, -0.01284487f, 
    0.00970426f, 0.00214814f, 0.02983008f, 0.01537750f, -0.01020950f, 0.02009194f, 0.02464472f, 0.00857386f, 
    0.01553146f, 0.03039174f, 0.03023886f, -0.00809207f, -0.01499232f, -0.03410980f, -0.01377263f, -0.00813743f, 
    -0.00055248f, -0.00324226f, -0.03737747f, -0.02498827f, 0.00424104f, 0.02126820f, 0.02689359f, 0.02192600f, 
    -0.02810244f, 0.02030350f, 0.00053573f, 0.02244793f, -0.03810029f, -0.03344339f, -0.01911237f, 0.00896115f, 
    -0.02795523f, 0.01419174f, 0.00595601f, 0.03160221f, 0.00236133f, -0.01239740f, -0.03117063f, 0.02995161f, 
    -0.02524959f, -0.01412949f, -0.03005677f, 0.02336293f, 0.01468702f, -0.00075966f, -0.02707723f, 0.01872424f, 
    0.00306430f, -0.01575463f, 0.00398790f, -0.02468397f, -0.03004579f, -0.01973505f, -0.00926687f, -0.01231659f, 
    -0.00089532f, -0.02361467f, -0.03279328f, -0.00647620f, -0.03204339f, -0.01452265f, 0.01390182f, 0.01517877f, 
    -0.00009353f, 0.01884869f, 0.02306634f, 0.02600216f, -0.00447280f, -0.00038571f, 0.02308915f, -0.00138364f, 
    -0.03709763f, 0.02825401f, -0.03144046f, -0.01622204f, 0.01854536f, 0.01399069f, -0.03724504f, -0.01215467f, 
    -0.00766340f, 0.02651669f, -0.01846274f, -0.03462850f, 0.02618060f, 0.00722407f, 0.02709282f, -0.00979944f, 
    0.00550239f, -0.03558211f, -0.00348732f, -0.01069241f, -0.01787308f, -0.01735669f, -0.01233167f, 0.03178975f, 
    0.03076532f, -0.02444047f, -0.00374978f, 0.02509007f, -0.00218689f, 0.02945209f, 0.00851848f, -0.02469152f, 
    -0.01921555f, -0.01255983f, 0.01203766f, 0.02145062f, -0.03500684f, 0.01010028f, -0.03827056f, -0.00385812f, 
    -0.02295030f, 0.01868375f, 0.01439862f, 0.03140017f, 0.02417534f, 0.00958627f, -0.02138450f, -0.03925848f, 
    0.00500929f, -0.02470380f, -0.02384802f, -0.03513118f, 0.00140893f, 0.03094522f, -0.00679784f, -0.00705503f, 
    0.02385473f, -0.02402494f, -0.02230899f, -0.01794926f, -0.03362719f, -0.00971433f, -0.02300000f, -0.01840137f, 
    0.01652919f, -0.00136808f, 0.00516427f, -0.02032986f, 0.02230925f, 0.00163572f, 0.02546856f, -0.03278565f, 
    -0.02716327f, -0.00329927f, -0.03869502f, -0.03658089f, -0.03263282f, -0.02310534f, 0.00389978f, -0.01739331f, 
    0.02656311f, -0.01128087f, -0.02619370f, 0.03049943f, -0.02659061f, -0.03673096f, 0.00948882f, 0.01260268f, 
    0.03030448f, -0.03145928f, 0.00447572f, 0.02114205f, -0.03653608f, 0.01121722f, -0.03362708f, -0.02889127f, 
    -0.00250180f, 0.00678290f, -0.00404595f, -0.01888733f, 0.01410163f, -0.00501727f, -0.01140275f, 0.00631740f, 
    0.01345844f, -0.03704593f, -0.02837108f, 0.03189539f, 0.00511367f, 0.02594508f, 0.02308072f, 0.01455235f, 
    -0.01700508f, 0.01231866f, -0.02767559f, 0.02727135f, 0.01353558f, -0.01785193f, 0.00187063f, -0.00648327f, 
    0.00861862f, -0.00218604f, 0.00249357f, -0.01218049f, 0.00075063f, -0.03200252f, -0.01345562f, -0.01797330f, 
    0.02917845f, -0.00695318f, -0.03011478f, 0.01725609f, -0.03070520f, 0.03183717f, 0.00699822f, -0.03386162f, 
    0.02776839f, -0.00825323f, 0.00154438f, -0.00987669f, -0.02003343f, -0.00258200f, 0.01255010f, 0.01422505f, 
    0.00985833f, 0.01621272f, -0.01770522f, -0.00691994f, -0.03135368f, 0.01264803f, 0.02355697f, 0.02204513f, 
    0.00990920f, -0.01176198f, -0.03778693f, -0.03597886f, 0.00536716f, -0.02244110f, -0.00362883f, -0.03282855f, 
    0.00722280f, 0.02616994f, 0.01977111f, -0.00334599f, -0.03012593f, -0.03452641f, -0.01787583f, -0.02171192f, 
    0.00898297f, -0.03446443f, -0.02276828f, 0.00267386f, -0.02919334f, 0.00381032f, -0.00506953f, -0.02703533f, 
    0.00311009f, -0.00659821f, -0.01166142f, 0.00637427f, -0.01508583f, -0.00316936f, 0.03207251f, 0.02312618f, 
    0.02619518f, 0.00367288f, 0.01957411f, 0.00735844f, -0.03238237f, -0.01629342f, -0.00389444f, -0.02844792f, 
    0.00953881f, 0.00775027f, -0.02965350f, -0.00104550f, -0.01382982f, -0.01442135f, 0.02308516f, 0.01914917f, 
    0.00469786f, -0.00375988f, -0.03061592f, -0.02849419f, -0.03043101f, -0.02436858f, 0.02672130f, 0.01467262f, 
    0.00789779f, 0.03188689f, -0.02495088f, 0.03225005f, -0.02846073f, -0.02231456f, -0.03814118f, 0.00952613f, 
    -0.00790017f, 0.00951511f, -0.02962739f, 0.01050913f, 0.01363095f, 0.02173034f, 0.00060160f, -0.00135826f, 
    0.00275767f, -0.00401987f, 0.00273083f, -0.01045397f, 0.02106777f, -0.02320511f, -0.00597799f, 0.00483532f, 
    0.02702502f, -0.01222466f, -0.01468951f, -0.03670170f, 0.02079137f, 0.00596378f, 0.02401643f, 0.02833822f, 
    -0.00324411f, 0.02511177f, 0.02753059f, 0.03045052f, -0.02458627f, 0.00853743f, 0.00507084f, -0.00479865f, 
    -0.00788178f, -0.02836978f, -0.02871503f, -0.02062666f, -0.01322474f, 0.00816956f, 0.01945216f, 0.01275973f, 
    0.02978218f, -0.03777439f, -0.04168987f, -0.00551240f, -0.03348142f, -0.01954652f, -0.03591749f, 0.00302929f, 
    0.00469391f, -0.00338469f, -0.00228082f, 0.00427812f, -0.02050018f, -0.01308121f, -0.01033147f, 0.00218111f, 
    -0.01742960f, 0.02425165f, -0.01541729f, -0.02787299f, -0.01493252f, -0.00255719f, -0.02989793f, 0.00422942f, 
    -0.02422555f, -0.01450713f, -0.00632335f, -0.00013813f, -0.01720289f, -0.01722327f, 0.01418138f, -0.00670847f, 
    0.02167870f, -0.04327631f, -0.02836975f, 0.02317925f, -0.00561088f, -0.01043841f, 0.00509462f, -0.00044689f, 
    -0.00967193f, -0.02633676f, -0.01873868f, -0.03936410f, 0.00142917f, 0.00890537f, -0.01847709f, -0.03468441f, 
    0.02818048f, 0.00500275f, 0.01154899f, -0.03954789f, -0.02592204f, 0.00859581f, 0.02496983f, 0.00866934f, 
    0.03373368f, -0.00186925f, 0.00049124f, -0.03937616f, 0.00143402f, 0.02334732f, -0.02738330f, -0.02001560f, 
    0.00077927f, 0.02430955f, 0.01232838f, 0.02787267f, 0.03843366f, -0.02952672f, 0.00702420f, 0.03271134f, 
    0.01394626f, -0.00216109f, 0.02857781f, -0.01761886f, -0.01590247f, -0.00128275f, 0.01683121f, 0.01810084f, 
    0.00685648f, -0.00641108f, 0.00066645f, -0.02633654f, -0.02795679f, -0.01028668f, -0.03332147f, -0.03225382f, 
    -0.00480556f, -0.04072074f, 0.00126977f, 0.02558799f, 0.02476647f, 0.03576358f, -0.03222294f, 0.02844071f, 
    -0.02660924f, -0.03326692f, -0.03690999f, -0.02312969f, 0.01172664f, -0.03062394f, -0.01655876f, 0.01711286f, 
    0.00331955f, -0.00473935f, -0.00553380f, 0.02993619f, 0.01271354f, -0.02127898f, 0.01909253f, -0.03831908f, 
    -0.03823715f, 0.03206469f, 0.01570285f, -0.03182733f, 0.00271836f, 0.00596587f, -0.02651758f, 0.01940791f, 
    0.02794788f, 0.00452713f, -0.04299694f, -0.00790837f, -0.00549445f, 0.00101007f, -0.03721529f, -0.04168857f, 
    0.00290374f, 0.01751192f, 0.00118420f, -0.04071188f, -0.00197757f, -0.00772699f, 0.02792790f, 0.01943292f, 
    0.02040400f, -0.03290261f, 0.00260055f, -0.00017869f, 0.01009090f, -0.03999222f, -0.01015589f, -0.01719558f, 
    0.03079242f, -0.02825560f, -0.02975923f, 0.03172170f, -0.00296133f, 0.01020592f, 0.01376849f, -0.00092666f, 
    -0.00743868f, -0.00936105f, 0.02415762f, -0.03243500f, -0.01759143f, -0.01311243f, 0.03446800f, -0.00629092f, 
    -0.02354759f, 0.02651758f, 0.00770334f, 0.01462931f, -0.03512627f, -0.00203384f, 0.02417371f, -0.02353936f, 
    -0.02376026f, 0.02289484f, -0.01668893f, -0.00935939f, 0.03208869f, 0.02771235f, -0.02366585f, -0.02152405f, 
    -0.02006548f, 0.00762507f, -0.01274227f, 0.02363129f, -0.01972913f, -0.00493053f, -0.00770862f, -0.00462651f, 
    -0.00028584f, -0.00518367f, 0.00180278f, -0.02812796f, -0.01036619f, -0.00076396f, 0.01021997f, -0.02618767f, 
    -0.00863783f, 0.00542217f, -0.02798944f, 0.00404218f, 0.01100844f, -0.04137954f, 0.01993043f, -0.02693025f, 
    0.02730021f, -0.00370282f, 0.00553481f, -0.02701291f, 0.02090786f, -0.01505778f, 0.02098257f, -0.03007655f, 
    -0.00553152f, -0.00983009f, -0.03682289f, -0.03733542f, -0.02465774f, 0.02377588f, -0.01536717f, 0.00186836f, 
    0.01999868f, 0.01660676f, -0.04099685f, 0.00493310f, -0.01343871f, 0.02868455f, -0.03210517f, -0.01441696f, 
    -0.00589276f, 0.01695175f, -0.01068342f, -0.00761738f, 0.02139115f, -0.00862324f, 0.01316990f, -0.04010877f, 
    0.00120301f, -0.00495429f, 0.00883166f, -0.00396630f, 0.01199275f, 0.00855389f, -0.04250747f, 0.00333455f, 
    -0.01621794f, 0.02519485f, -0.00510048f, -0.03832654f, 0.01469386f, 0.00925721f, -0.02192157f, 0.00242941f, 
    -0.00401489f, 0.00411684f, -0.00351653f, 0.00725688f, -0.03194456f, 0.01570723f, 0.02314107f, 0.02537771f, 
    0.00314913f, 0.00143521f, -0.04291781f, -0.00320730f, 0.03281171f, -0.01878321f, -0.02942227f, -0.01278329f, 
    -0.01484614f, 0.00923374f, -0.03819491f, -0.01735536f, -0.02051479f, 0.00837060f, -0.03641509f, -0.01878568f, 
    0.00780862f, -0.02961655f, -0.02896913f, 0.01050312f, 0.00880584f, -0.01649497f, 0.01275280f, -0.02740754f, 
    0.02228782f, -0.03497567f, 0.01059197f, 0.01883829f, -0.02660351f, -0.03732575f, 0.00235600f, -0.00934703f, 
    0.02503275f, -0.02345087f, -0.00651274f, 0.01944958f, -0.04163783f, 0.02182248f, -0.03690280f, -0.02133827f, 
    -0.02793290f, 0.01144885f, -0.02246016f, -0.00274356f, -0.00498223f, 0.01111843f, 0.02625713f, -0.02729740f, 
    0.00363921f, -0.02879532f, 0.01782412f, 0.00794447f, -0.02866245f, -0.00003615f, 0.03098574f, 0.03231563f, 
    -0.01456059f, 0.02979502f, 0.00637122f, 0.02674023f, -0.03982596f, -0.02811741f, -0.02297918f, -0.03698617f, 
    -0.02752474f, -0.02995105f, -0.02484305f, -0.00445729f, -0.01621404f, -0.01389333f, -0.02102749f, 0.01775329f, 
    0.02593078f, -0.02765752f, -0.04418077f, 0.02468190f, 0.01357852f, 0.00224691f, 0.02675964f, -0.02177797f, 
    -0.03596071f, -0.03335920f, -0.03745370f, -0.01965226f, 0.00626065f, -0.02633223f, -0.04217879f, -0.00669704f, 
    -0.03806921f, -0.01889577f, -0.02300471f, 0.02713066f, -0.03552068f, -0.01455817f, 0.02111498f, 0.02118219f, 
    -0.02208793f, 0.00061975f, 0.00194903f, -0.02790974f, -0.03225180f, 0.01979020f, -0.00467748f, -0.02399115f, 
    -0.03213051f, -0.00429454f, 0.00653976f, 0.00311923f, 0.00974679f, -0.00131471f, -0.02337440f, 0.02497390f, 
    -0.03503916f, -0.01637125f, -0.00558122f, 0.03050114f, 0.01625907f, 0.02761114f, -0.00393645f, 0.01182235f, 
    -0.02305637f, -0.00695358f, 0.02145641f, 0.00436603f, -0.00036831f, 0.01060888f, 0.02893167f, 0.01128887f, 
    0.01549203f, 0.00648958f, 0.02334604f, -0.02538692f, 0.00182127f, -0.02410264f, 0.00993555f, 0.02560478f, 
    -0.03639767f, -0.02433755f, -0.00518822f, -0.02104747f, -0.01951291f, -0.03423200f, 0.02597023f, -0.00737612f, 
    -0.00308788f, 0.02643258f, -0.02340229f, 0.00815774f, -0.00833261f, 0.00266714f, -0.02458483f, -0.01502443f, 
    0.02652997f, 0.00188683f, 0.02933657f, -0.03721003f, 0.03567672f, 0.02627771f, -0.00467723f, -0.03531979f, 
    -0.00914556f, 0.00399702f, -0.02893137f, 0.02100029f, -0.01754318f, -0.00659456f, -0.03109487f, 0.02860365f, 
    0.02732049f, 0.01918696f, -0.03985238f, 0.01764553f, 0.02379476f, -0.03232465f, -0.01641170f, -0.01652646f, 
    -0.02620004f, -0.02618121f, 0.00035278f, 0.02382277f, -0.02749231f, 0.01224595f, -0.00337778f, -0.00441007f, 
    0.00605643f, 0.02908071f, 0.02126780f, -0.01450633f, -0.02947568f, -0.01345241f, -0.00130826f, -0.03006768f, 
    0.00984009f, -0.00627818f, -0.03106963f, 0.01808759f, -0.00626961f, 0.00039098f, 0.02755710f, -0.01431167f, 
    0.01534863f, -0.02575414f, -0.01953643f, -0.02788097f, -0.03740884f, -0.03135601f, -0.02894907f, 0.03317014f, 
    0.03136804f, 0.01619122f, 0.01672466f, -0.02774528f, 0.00058886f, -0.00507040f, 0.02191190f, -0.02284090f, 
    -0.02450031f, -0.01103243f, -0.00002814f, -0.02103749f, -0.02456466f, -0.02183437f, -0.03197059f, 0.01669718f, 
    -0.01943612f, 0.00218932f, -0.03195976f, 0.00324870f, -0.03102286f, 0.00503060f, -0.00331288f, 0.00251123f, 
    -0.00284678f, 0.00366577f, 0.00909314f, 0.02902556f, -0.00246903f, -0.02187064f, 0.00467396f, 0.03405795f, 
    -0.03786253f, 0.01807624f, 0.00462378f, -0.00495645f, -0.02173221f, -0.00863009f, 0.01882223f, 0.00631768f, 
    0.00486515f, -0.03702431f, 0.00911600f, -0.03216551f, 0.00306145f, 0.00066726f, -0.01884048f, -0.02984906f, 
    0.00190601f, -0.01283360f, 0.01830707f, -0.03547831f, 0.00460723f, 0.01001032f, -0.00622114f, -0.00400221f, 
    -0.01188426f, 0.00204889f, -0.01168336f, -0.03264308f, 0.02546503f, -0.03277909f, -0.01686453f, 0.03237719f, 
    -0.00318698f, 0.03506920f, 0.01449788f, -0.02803108f, 0.01907574f, -0.01550862f, -0.04066484f, -0.01826736f, 
    -0.01618063f, -0.00258580f, 0.02969310f, -0.03554190f, 0.02778880f, -0.00872800f, -0.02487229f, 0.02204697f, 
    0.02381647f, -0.03942781f, -0.00106699f, -0.00286355f, -0.03406952f, -0.01118668f, -0.01982967f, 0.00409761f, 
    0.01247449f, -0.01904118f, 0.01304340f, 0.01145868f, 0.02621340f, 0.00103417f, -0.02719072f, 0.02588775f, 
    -0.02256028f, -0.01023784f, 0.02651631f, 0.00759338f, 0.00402435f, -0.04278485f, -0.03681469f, -0.03595562f, 
    -0.02102760f, -0.03780527f, -0.00749760f, 0.01484198f, -0.01017628f, 0.03006653f, -0.02842592f, -0.03954399f, 
    0.00508116f, -0.03977017f, 0.02763761f, 0.03423176f, 0.00779104f, 0.02377015f, 0.00225692f, 0.01359775f, 
    0.00694918f, -0.03667328f, -0.01189273f, 0.02121039f, 0.00830853f, -0.03843761f, -0.04109967f, 0.00265079f, 
    0.00613268f, 0.00642852f, 0.00279041f, 0.02327505f, -0.01955901f, 0.00345347f, 0.02444329f, -0.02113823f, 
    -0.00227649f, -0.01955799f, 0.01031613f, -0.00529656f, -0.02855179f, 0.01625506f, -0.00990634f, -0.02022877f, 
    0.00961907f, -0.00280813f, 0.02556535f, 0.02555973f, 0.00237586f, 0.00237609f, 0.02488962f, 0.02251893f, 
    0.00400512f, -0.02926341f, 0.01140402f, 0.03724902f, -0.02738738f, -0.01060263f, -0.01502139f, -0.01133969f, 
    -0.01062298f, 0.00599202f, -0.01091968f, 0.01335459f, -0.00201612f, 0.01957396f, -0.03505925f, -0.03928103f, 
    -0.02006029f, -0.03394245f, -0.00794555f, -0.03045963f, -0.01816293f, -0.00180218f, -0.01833723f, -0.03686127f, 
    -0.01029388f, -0.00586329f, -0.00371530f, 0.02227064f, 0.00661808f, -0.02628654f, 0.02896903f, -0.00500327f, 
    -0.02505047f, -0.00362709f, -0.01834806f, 0.02111582f, -0.00867373f, 0.00993601f, 0.01842412f, -0.02017589f, 
    0.01081777f, -0.01423645f, 0.01162253f, -0.01353356f, 0.02549548f, -0.03370137f, -0.00941860f, 0.01969205f, 
    0.01768933f, 0.02138276f, -0.02193730f, -0.03543201f, 0.00996141f, 0.00589959f, -0.00221292f, -0.00513355f, 
    -0.02186961f, 0.03131393f, -0.01837278f, 0.00957840f, 0.00264243f, 0.00423307f, -0.03796764f, 0.03729443f, 
    0.03290921f, 0.03038415f, 0.01773744f, 0.01721005f, 0.02158740f, 0.03729262f, 0.00290387f, -0.02702690f, 
    -0.03564327f, 0.03064858f, -0.01596643f, 0.02427436f, -0.03348546f, -0.01671970f, 0.02765269f, -0.01013745f, 
    0.00567867f, -0.03006748f, -0.03939592f, -0.01839682f, 0.01274952f, -0.02227298f, 0.03010130f, 0.02492898f, 
    -0.02453172f, -0.01388739f, 0.01036194f, 0.00131141f, 0.02626192f, -0.03662887f, -0.01435081f, -0.02230247f, 
    0.01777303f, 0.01367244f, 0.03647154f, 0.00190285f, -0.02019953f, 0.00188718f, -0.03450139f, 0.00237654f, 
    -0.00435593f, 0.02942650f, -0.00912937f, -0.00542568f, -0.02225711f, 0.01541854f, 0.03016845f, 0.00964389f, 
    -0.01538930f, -0.00049227f, -0.02719492f, 0.01771765f, 0.01561057f, -0.02921153f, -0.00315866f, 0.00858239f, 
    -0.04284850f, -0.00283681f, -0.03548904f, -0.02228616f, -0.02394529f, 0.02135803f, 0.02618696f, -0.00329198f, 
    0.00090418f, -0.00080308f, -0.02282864f, 0.01592896f, -0.03472900f, 0.00946792f, -0.03833285f, 0.02261142f, 
    -0.00520620f, 0.02775068f, 0.01787145f, -0.02047417f, -0.03766858f, -0.01712256f, 0.00054747f, -0.00283510f, 
    -0.02528398f, -0.00824830f, -0.02274748f, 0.02509665f, -0.00601579f, -0.00920598f, 0.02423804f, -0.00792356f, 
    -0.00015656f, -0.01211283f, -0.00789233f, -0.01282623f, 0.02232110f, 0.02245133f, -0.00453167f, 0.00443534f, 
    -0.02767984f, -0.04104244f, -0.00744369f, -0.03121174f, 0.02762476f, -0.03660926f, 0.00424505f, 0.02286690f, 
    0.00057059f, -0.03551247f, 0.01005905f, -0.00599359f, 0.01445547f, 0.02848874f, -0.03074675f, -0.01791017f, 
    -0.01874081f, -0.02302048f, -0.03856510f, -0.03122780f, 0.00218079f, -0.01214429f, -0.04175986f, 0.01551983f, 
    0.00716869f, -0.04012002f, 0.01663234f, -0.01082257f, 0.02665910f, 0.02561860f, 0.00006799f, -0.00589340f, 
    0.01294783f, -0.03153609f, 0.00989575f, 0.02088045f, -0.02165918f, 0.00168056f, -0.02230315f, 0.02004921f, 
    -0.00002028f, -0.04082397f, 0.00956810f, -0.04224684f, 0.01270379f, -0.04276191f, -0.03142684f, -0.01071279f, 
    -0.02400334f, 0.01493864f, -0.01717107f, -0.02890904f, -0.00116259f, 0.00134557f, -0.02576662f, 0.01373502f, 
    -0.01579336f, -0.04191691f, 0.00892565f, 0.02240677f, 0.00980849f, -0.01989712f, 0.01412092f, -0.03401767f, 
    -0.00693387f, -0.03107279f, -0.01278908f, -0.02597296f, -0.01581113f, 0.00367451f, -0.01228547f, -0.03527603f, 
    0.02272928f, 0.01115531f, -0.02502805f, 0.00964132f, -0.02523013f, 0.02056213f, -0.02616714f, -0.00570852f, 
    0.00737552f, -0.00501175f, -0.00382891f, 0.01095940f, -0.00174200f, -0.04312643f, -0.03169546f, 0.01560351f, 
    -0.00378755f, -0.04185505f, 0.01781189f, -0.00261312f, -0.01269105f, -0.00092705f, 0.01128974f, -0.03695499f, 
    -0.02345216f, -0.00630262f, -0.00048743f, 0.02156441f, -0.01896429f, -0.01616850f, 0.02054057f, -0.02140135f, 
    -0.02729264f, 0.00675733f, -0.02834027f, 0.01696588f, -0.01409204f, 0.01556329f, -0.03565881f, 0.01718597f, 
    -0.03492875f, -0.00641280f, 0.01899304f, -0.03405980f, -0.04258583f, 0.00802637f, -0.01382588f, 0.00899507f, 
    -0.00880805f, 0.02275126f, 0.00257181f, -0.00142440f, 0.00984504f, 0.00646626f, -0.00605288f, -0.00351020f, 
    0.00343688f, 0.01322946f, 0.01502038f, 0.00526935f, 0.01082389f, -0.04358058f, -0.03183107f, 0.00318427f, 
    -0.03072747f, 0.00333741f, 0.00028580f, 0.00126585f, -0.03703633f, -0.01693828f, -0.01665805f, -0.00628187f, 
    -0.02903762f, -0.00611276f, 0.01855789f, -0.01585441f, -0.01776102f, -0.03642996f, -0.01204000f, 0.01537103f, 
    -0.03271248f, 0.01402462f, -0.00239119f, 0.01187398f, -0.01245906f, 0.00619711f, -0.03539906f, -0.01018427f, 
    -0.02871281f, -0.01078874f, -0.02514365f, 0.01076963f, -0.01811405f, -0.00566383f, -0.00055492f, 0.01655062f, 
    -0.04297299f, -0.03969645f, 0.00941085f, 0.00009366f, -0.00856212f, -0.01254719f, 0.01957043f, 0.01399152f, 
    -0.03085686f, -0.03405909f, -0.04141077f, -0.04160360f, -0.03835814f, -0.03838624f, -0.04021352f, -0.02906488f, 
    -0.03236265f, -0.01930592f, -0.01525346f, -0.00101293f, 0.02319662f, -0.02486178f, 0.01303605f, -0.01384255f, 
    0.00737028f, -0.01617335f, -0.00479402f, -0.02825490f, 0.00194524f, 0.02209552f, 0.00590339f, 0.00314948f, 
    0.00250201f, 0.02161709f, -0.01282245f, -0.01368900f, -0.01193047f, 0.02022852f, -0.01591543f, 0.02025711f, 
    -0.02270694f, -0.04055722f, -0.00111251f, -0.04207224f, -0.00225935f, -0.04235097f, -0.00799798f, 0.01201057f, 
    0.02470230f, -0.01250018f, 0.00823247f, 0.00902686f, -0.00142286f, 0.02520182f, -0.00496844f, -0.04147398f, 
    -0.00849745f, -0.00366474f, 0.00370575f, -0.02268072f, 0.00696441f, 0.02395557f, -0.04277394f, 0.01057477f, 
    -0.00851600f, -0.03518648f, 0.02114359f, -0.02465523f, -0.00930700f, 0.02748048f, 0.02060288f, 0.02545356f, 
    0.00753661f, -0.03582865f, -0.00832222f, -0.00138994f, -0.03490686f, 0.01685827f, -0.01782238f, -0.01672159f, 
    0.01299164f, -0.00893608f, -0.00618139f, -0.02839025f, 0.00862755f, -0.00214205f, 0.00573981f, -0.01254238f, 
    0.02561840f, 0.01977647f, 0.00568909f, -0.01933694f, 0.00814733f, -0.03796908f, 0.01611219f, -0.03238082f, 
    -0.03135900f, 0.02640927f, 0.02103793f, -0.03687877f, 0.00527379f, 0.01191718f, 0.02428573f, -0.02720248f, 
    -0.03120962f, 0.01811223f, -0.02838972f, -0.03429537f, -0.00310140f, -0.03705803f, 0.00358054f, -0.02636798f, 
    -0.02524931f, -0.04339185f, -0.01738808f, 0.00381357f, -0.00602400f, -0.00357845f, -0.01031141f, 0.00486724f, 
    -0.00430645f, 0.00048568f, 0.00975253f, -0.02821473f, -0.00308409f, -0.01993262f, 0.01645791f, 0.02728856f, 
    -0.01513005f, -0.01281389f, 0.02473469f, 0.01476490f, -0.02109094f, 0.02457500f, -0.03460133f, -0.01326220f, 
    -0.00644670f, -0.01468566f, 0.02437646f, -0.01443378f, -0.03984158f, -0.03167060f, -0.02009231f, -0.03071147f, 
    -0.00319396f, -0.00212245f, -0.01824684f, 0.01898739f, -0.01344799f, 0.02092566f, -0.02935983f, 0.01739909f, 
    0.02222666f, 0.00581177f, 0.02675813f, -0.03264492f, 0.00050966f, -0.04405313f, -0.02004034f, -0.00862771f, 
    -0.00661525f, -0.01972985f, -0.00100663f, 0.00503588f, 0.01141649f, -0.03082628f, 0.01507157f, 0.00062678f, 
    0.01253368f, -0.01727287f, 0.01091578f, -0.00251151f, -0.00241751f, -0.03540469f, 0.00784818f, 0.02719264f, 
    -0.01041756f, -0.01902501f, -0.00141902f, 0.02891183f, 0.00011135f, -0.02960323f, -0.02140994f, -0.02313023f, 
    -0.01180136f, -0.03802708f, -0.02955533f, -0.01299014f, 0.02117164f, -0.01312727f, -0.02518208f, 0.02581780f, 
    -0.04102242f, -0.03846038f, -0.01891974f, 0.02751448f, -0.04073090f, 0.01436260f, 0.02347528f, -0.01515619f, 
    -0.01634499f, -0.02815602f, -0.01662149f, -0.04059187f, -0.00343973f, -0.03080213f, 0.00690836f, -0.02871418f, 
    -0.04091405f, -0.03113202f, 0.00756575f, -0.01110211f, 0.01418419f, -0.00038622f, 0.02290873f, 0.01125181f, 
    0.02458703f, 0.02773282f, -0.03861622f, 0.02544388f, 0.00476153f, -0.02040610f, -0.00517408f, -0.00346183f, 
    -0.03931489f, 0.02530090f, -0.02447876f, 0.02860409f, 0.00598925f, -0.01808205f, 0.00812905f, 0.00450204f, 
    0.02025326f, -0.02331773f, -0.00986963f, -0.04098647f, -0.03589979f, 0.01118681f, 0.01987887f, -0.03735522f, 
    -0.02745709f, 0.00156159f, -0.02181781f, 0.00868332f, 0.01605784f, -0.00778318f, 0.02068512f, 0.01691955f, 
    0.00071792f, -0.00789306f, -0.00754565f, 0.00603676f, -0.00728329f, 0.02153243f, -0.00178439f, -0.00384144f, 
    0.01345115f, 0.00249547f, 0.02687747f, -0.02215963f, 0.01787391f, -0.02460451f, 0.02157680f, 0.00168402f, 
    -0.01492067f, -0.01968657f, 0.02487687f, -0.04211329f, -0.03193552f, -0.04071599f, 0.01013797f, 0.02346329f, 
    0.01711861f, -0.00425842f, 0.02114277f, 0.00803393f, 0.01500069f, -0.02666055f, 0.01423532f, -0.03785273f, 
    -0.02052112f, 0.00090062f, -0.02688614f, -0.00786346f, -0.01905722f, -0.02593403f, -0.04311671f, -0.03970237f, 
    -0.02811084f, -0.00072101f, 0.00579773f, 0.00227634f, -0.03563776f, -0.00204085f, 0.00620126f, 0.00353985f, 
    -0.02789350f, 0.02099874f, -0.02580214f, -0.00449096f, -0.01930931f, -0.03528237f, -0.03849631f, -0.02181176f, 
    -0.00395046f, -0.03318969f, -0.02612155f, -0.03175181f, 0.01834228f, 0.01918333f, -0.00946252f, -0.00794225f, 
    -0.02952757f, -0.00757276f, 0.01760509f, 0.02268614f, -0.02864954f, -0.00751943f, -0.00068989f, -0.04322258f, 
    -0.00359735f, 0.02586078f, -0.00287954f, 0.00170630f, 0.01530664f, 0.01847360f, -0.00193460f, 0.00670232f, 
    -0.01593971f, -0.03517943f, -0.04126875f, -0.01753257f, 0.00417816f, 0.02333649f, -0.03722807f, 0.01429557f, 
    -0.04320779f, 0.01195871f, 0.00921757f, 0.00436547f, -0.03661224f, 0.00171173f, 0.02234568f, -0.02514347f, 
    -0.00558456f, -0.01099919f, 0.02633129f, 0.00010820f, -0.02788709f, -0.01772386f, 0.00988391f, -0.00673823f, 
    -0.02866402f, -0.01148028f, 0.00524575f, -0.02784669f, -0.01611274f, 0.00286130f, -0.01833695f, 0.02090374f, 
    -0.02088875f, -0.03276409f, -0.00758504f, -0.01388283f, -0.04104416f, -0.02033524f, -0.04387497f, 0.02331649f, 
    0.00805362f, 0.00739007f, 0.01607601f, -0.02148744f, 0.01991935f, -0.01212582f, -0.00586296f, 0.02281384f, 
    0.00808083f, -0.04220467f, -0.03654333f, -0.01132695f, -0.01949874f, -0.02998563f, -0.00662341f, -0.00961128f, 
    -0.04155528f, 0.00686650f, -0.03409629f, -0.01301835f, 0.00045407f, 0.01004670f, 0.01325293f, -0.02706092f, 
    0.02815110f, -0.02534375f, -0.03404082f, -0.00544007f, -0.00047814f, -0.02706904f, 0.02072846f, 0.00459291f, 
    0.01060484f, -0.04112145f, 0.00156302f, -0.02045567f, -0.00143670f, 0.01311823f, 0.00981394f, -0.00571587f, 
    -0.02768929f, -0.00943804f, -0.00767026f, -0.02060851f, -0.02936814f, 0.01701996f, -0.04371825f, 0.01292536f, 
    -0.02304805f, -0.01298598f, 0.01767300f, 0.02187135f, -0.01802990f, -0.04349390f, -0.00686639f, 0.00295108f, 
    0.01785513f, -0.01572616f, 0.01560376f, 0.02433482f, -0.00378076f, -0.02773705f, 0.01846505f, 0.01811459f, 
    0.02438609f, 0.02449220f, -0.01873579f, 0.02445190f, 0.01637946f, -0.00687898f, -0.01661066f, 0.01585300f, 
    -0.03599748f, -0.03154602f, 0.02209923f, -0.03664698f, -0.03416206f, 0.01604318f, -0.04208961f, 0.02803198f, 
    0.01717713f, -0.02854836f, 0.01965172f, -0.04146072f, -0.03433725f, -0.00182831f, -0.00827156f, 0.00533421f, 
    -0.03412122f, 0.01869934f, 0.00219994f, -0.01011536f, -0.00620777f, -0.02449413f, -0.04003343f, -0.04120382f, 
    -0.01197734f, -0.01918592f, 0.01881528f, 0.00413852f, -0.04329539f, -0.00035281f, 0.00187968f, -0.02971452f, 
    -0.02108205f, -0.03399797f, -0.03075686f, -0.01195247f, 0.02774610f, -0.01027855f, 0.00907881f, -0.01172609f, 
    -0.00332245f, 0.01450737f, -0.00484989f, -0.00823164f, -0.00072165f, -0.03465760f, 0.01896925f, -0.00549775f, 
    -0.03329958f, -0.03717223f, 0.00425598f, -0.02182501f, -0.02542316f, -0.03835706f, 0.00170061f, 0.00586404f, 
    0.01345184f, -0.04166457f, 0.01652577f, -0.03872970f, -0.04390514f, 0.00942592f, -0.04248565f, -0.03790201f, 
    -0.02060258f, -0.00534600f, 0.02071625f, 0.00444893f, -0.01602855f, 0.00080056f, -0.03817148f, -0.01075000f, 
    -0.03148603f, 0.01025886f, -0.03977637f, -0.02557872f, 0.00018164f, -0.03078287f, -0.03277154f, 0.02626066f, 
    0.00843225f, 0.00305615f, -0.00916361f, 0.00916264f, 0.01649512f, -0.03225177f, 0.00335520f, -0.00742352f, 
    0.00622527f, 0.00244874f, 0.00423250f, -0.03404561f, -0.01655041f, -0.03885363f, -0.04321814f, 0.00787524f, 
    -0.02238854f, -0.02477961f, 0.02053256f, 0.00865380f, 0.01490292f, -0.02363053f, 0.01273583f, -0.00121309f, 
    -0.00827941f, -0.00876680f, 0.00313306f, -0.02419245f, -0.01764446f, -0.00228353f, 0.00707298f, -0.03019160f, 
    0.01870006f, -0.03423084f, 0.00654588f, -0.00049875f, 0.01743141f, 0.01829245f, -0.00410138f, -0.02071553f, 
    0.00412717f, 0.00778629f, 0.01709293f, -0.02824792f, -0.04182826f, -0.01117586f, 0.02651720f, 0.02873560f, 
    0.02933560f, 0.02684283f, 0.02103687f, 0.00291937f, 0.00751720f, -0.03009767f, -0.00584595f, -0.03743833f, 
    -0.02590103f, -0.02211843f, 0.00864916f, 0.02436511f, -0.01014879f, 0.02925553f, -0.00005737f, 0.00514744f, 
    0.01477478f, -0.04093966f, 0.00901450f, -0.03545799f, -0.01244976f, 0.01886535f, 0.00749039f, 0.01624535f, 
    0.01831517f, 0.01993367f, 0.02717654f, -0.01293997f, 0.00062082f, 0.01515977f, 0.00374453f, 0.00409555f, 
    -0.02688552f, 0.01684758f, -0.04133319f, 0.03205604f, 0.00897523f, 0.01072429f, -0.02497835f, 0.01337919f, 
    -0.00791336f, 0.00639438f, -0.01939979f, -0.02054927f, 0.02245057f, 0.01707813f, 0.01167042f, -0.00912022f, 
    0.00630098f, 0.00380537f, -0.02392395f, 0.02900992f, -0.02187090f, 0.01073912f, -0.01221343f, 0.00320797f, 
    -0.03742323f, -0.02507019f, 0.02793038f, -0.00140019f, -0.01393333f, 0.02629543f, -0.03771036f, 0.00592595f, 
    0.00829075f, 0.02613327f, -0.02555750f, -0.00505719f, -0.01210788f, -0.01659540f, 0.02620185f, -0.02689983f, 
    0.00297133f, -0.00917390f, -0.00546732f, 0.00399373f, 0.00187741f, -0.00032833f, -0.00008725f, 0.00351261f, 
    0.00684634f, 0.00511686f, -0.01426653f, -0.02766386f, 0.01184991f, 0.02960744f, -0.00057546f, 0.02229354f, 
    0.00831095f, 0.01690967f, -0.01093994f, 0.02189867f, -0.01683569f, 0.01059953f, -0.02559179f, -0.01397396f, 
    0.00853246f, 0.03086004f, -0.01277131f, -0.02069766f, -0.00953873f, -0.01323741f, 0.00323147f, 0.02706264f, 
    0.00569155f, -0.00496668f, -0.02302448f, -0.03362687f, -0.02374581f, -0.01422565f, 0.00790076f, -0.02349577f, 
    -0.03187333f, -0.03025201f, -0.01312690f, -0.03233805f, 0.02136672f, 0.02222692f, -0.00057167f, -0.01560259f, 
    0.03251729f, 0.02822026f, 0.00896730f, -0.01243466f, 0.02758492f, -0.01794102f, 0.02252508f, 0.02760055f, 
    -0.02609193f, -0.00965915f, 0.00875773f, -0.00909343f, -0.03750728f, -0.03407887f, 0.02043816f, -0.01913756f, 
    -0.02015800f, 0.00853437f, 0.03178202f, -0.02421726f, 0.02756062f, 0.00736388f, -0.01515125f, -0.03040804f, 
    0.00041562f, 0.00971611f, 0.01721755f, -0.01020203f, -0.01451356f, -0.03262913f, 0.01616932f, 0.01973867f, 
    -0.01022642f, -0.01111398f, -0.03624936f, 0.00498101f, -0.01200566f, -0.01909770f, -0.01716017f, 0.01906291f, 
    0.00659446f, 0.00618586f, -0.00517623f, -0.02386431f, 0.03410787f, 0.01442380f, -0.02380376f, 0.02662464f, 
    0.01309308f, -0.02125325f, 0.00615615f, -0.03049824f, -0.00727204f, 0.00039904f, 0.00771856f, -0.01683749f, 
    0.01455410f, -0.03129718f, 0.02133956f, -0.02458366f, -0.02487393f, -0.02555131f, -0.00083138f, -0.00734540f, 
    0.02435173f, -0.03390093f, 0.02856707f, -0.03226367f, -0.00754851f, 0.01270252f, 0.00051784f, 0.03376136f, 
    -0.02799922f, 0.01020024f, 0.02269798f, -0.01142179f, -0.01171254f, -0.01819752f, 0.00571807f, 0.02900752f, 
    -0.02030405f, -0.02302803f, 0.02559225f, -0.03531602f, 0.01126056f, -0.01294833f, -0.02717184f, -0.01486721f, 
    -0.02162181f, 0.00720834f, -0.02346535f, -0.03242726f, -0.03087900f, -0.00874876f, -0.01754307f, -0.00386760f, 
    0.02077540f, 0.01098038f, -0.03126174f, -0.01445088f, -0.00630299f, -0.03254392f, -0.02363367f, 0.00379126f, 
    -0.03768318f, -0.01962359f, 0.02277161f, -0.01747485f, 0.03344208f, -0.00598602f, -0.01720695f, -0.02708549f, 
    0.01140697f, 0.01279794f, -0.00270485f, -0.00081236f, -0.00977778f, -0.00759980f, -0.00003339f, -0.03867406f, 
    -0.03437558f, 0.00195803f, 0.00436935f, -0.00985253f, -0.01559659f, 0.00690749f, -0.00108899f, 0.00650937f, 
    -0.00909802f, 0.00214950f, -0.00271926f, -0.00080680f, -0.02286729f, -0.01717041f, 0.01209556f, -0.03578483f, 
    -0.00755823f, 0.02272882f, -0.01903251f, -0.03308634f, 0.01731378f, -0.02521811f, -0.00164601f, -0.03190126f, 
    0.00425077f, -0.00822622f, -0.02580630f, 0.02517892f, -0.01854736f, -0.00289050f, -0.00778338f, 0.03001054f, 
    -0.01513220f, -0.02411907f, 0.01458846f, -0.02118712f, -0.02377863f, 0.00324818f, -0.03085888f, -0.00794074f, 
    0.01896774f, -0.04036874f, -0.03184357f, -0.01051221f, 0.01461880f, 0.00408161f, -0.03892187f, 0.00716681f, 
    -0.03934377f, 0.02745387f, -0.03486047f, -0.00652130f, -0.03309955f, -0.00413718f, 0.01490433f, -0.04207784f, 
    0.03717987f, -0.02480104f, 0.02598615f, -0.02084577f, 0.01272772f, 0.00960046f, 0.03088372f, -0.02692856f, 
    -0.00224734f, 0.00083866f, -0.00863687f, 0.00969720f, -0.04092766f, 0.00303550f, -0.04420764f, -0.02873580f, 
    0.00701663f, -0.01943388f, -0.02623021f, -0.01004155f, -0.01851494f, 0.00370674f, -0.01998121f, -0.04134614f, 
    -0.01298878f, -0.02714999f, 0.02412489f, -0.01328052f, 0.02868822f, 0.02340678f, 0.00121725f, 0.02306079f, 
    -0.00376531f, -0.03279791f, -0.02919734f, -0.00306777f, -0.00333741f, 0.02300340f, -0.02367247f, -0.01672613f, 
    -0.03850794f, -0.03372087f, -0.03898205f, 0.02404910f, -0.03350239f, -0.03481152f, 0.00991658f, 0.00465106f, 
    -0.02417563f, -0.00518380f, -0.03575632f, -0.04142299f, -0.03768951f, -0.01698310f, -0.04052361f, 0.01727110f, 
    -0.01637517f, -0.00444354f, -0.03082987f, -0.00402353f, 0.02026920f, 0.01290631f, 0.02732164f, 0.02392664f, 
    -0.02627290f, -0.02005604f, -0.02999629f, -0.01413911f, 0.02268689f, -0.01583761f, 0.01918751f, -0.03610089f, 
    -0.01950787f, -0.02021928f, 0.01165869f, 0.03115794f, 0.01358429f, -0.01864798f, -0.00066570f, -0.03572889f, 
    0.01826908f, -0.00280213f, -0.00427291f, -0.00862630f, -0.02145232f, -0.00846361f, -0.00476660f, 0.02583151f, 
    -0.03045222f, -0.00664619f, -0.01815505f, 0.00879106f, 0.02266447f, 0.03089670f, 0.03085949f, -0.00062079f, 
    -0.00505416f, 0.01521844f, 0.00711066f, -0.01112082f, 0.02839233f, -0.03187747f, -0.03280416f, 0.01020627f, 
    0.02331163f, 0.03804654f, 0.00690503f, 0.00754868f, -0.01957542f, 0.02230320f, 0.01855142f, 0.00514918f, 
    0.01260990f, 0.01701014f, 0.00315744f, 0.02310636f, -0.02683935f, -0.00566620f, -0.02934742f, -0.01679313f, 
    -0.03763584f, -0.01705746f, -0.01534708f, -0.00575876f, 0.02839174f, -0.01364143f, -0.02002440f, -0.00353166f, 
    -0.00320337f, -0.00136572f, 0.02629111f, -0.02056656f, -0.02716156f, -0.00544233f, -0.01745435f, 0.02523600f, 
    0.01870305f, 0.00150662f, 0.01783252f, 0.01347566f, -0.02548247f, 0.03188408f, -0.01377337f, 0.01689135f, 
    0.01779957f, 0.01590310f, 0.01093431f, -0.02941369f, -0.02702414f, -0.01767785f, 0.01022525f, 0.02466867f, 
    -0.02207314f, 0.02107291f, 0.01480122f, 0.00433051f, -0.02849876f, -0.02203382f, -0.00849878f, -0.02883412f, 
    0.02747802f, -0.02392009f, -0.03068160f, -0.03094564f, -0.01653614f, -0.03075543f, 0.04116235f, -0.02343509f, 
    0.00629122f, 0.02005995f, -0.03614462f, 0.03307641f, -0.00150159f, -0.02059775f, 0.02138011f, -0.01998555f, 
    0.01998340f, -0.03087563f, -0.03842468f, 0.00948963f, 0.00987378f, 0.02279789f, -0.01277884f, 0.01329201f, 
    0.00382655f, 0.00400113f, -0.01710295f, -0.02564113f, 0.00944456f, 0.02458718f, 0.02596178f, -0.01446331f, 
    -0.01623853f, 0.02445093f, 0.00164577f, -0.01316922f, -0.00308896f, 0.00480476f, -0.01080547f, -0.00676766f, 
    -0.02881344f, 0.00680789f, -0.01783455f, -0.01013119f, 0.03426828f, -0.02569516f, 0.01244238f, 0.01382680f, 
    -0.02650784f, 0.02101482f, 0.02040714f, 0.00961190f, 0.02840096f, -0.03008092f, -0.02091405f, -0.01011953f, 
    -0.02470866f, 0.00351463f, 0.03293203f, -0.01460912f, -0.00382034f, -0.03216071f, 0.01277723f, -0.03054379f, 
    -0.03310065f, 0.02013789f, 0.02162631f, 0.03142173f, 0.02450979f, 0.00298233f, -0.01948498f, -0.02229833f, 
    -0.00835167f, -0.01475671f, -0.03417967f, -0.02383750f, -0.01604476f, 0.01816315f, 0.00494749f, 0.01941944f, 
    -0.02738297f, -0.03026674f, 0.01781317f, 0.02019168f, -0.01181039f, 0.00944891f, -0.00186293f, 0.02223942f, 
    -0.00644430f, -0.03066391f, 0.02136945f, -0.03110791f, 0.02310619f, -0.00834145f, -0.01944609f, 0.00208229f, 
    -0.00172727f, -0.03135089f, -0.00271776f, 0.03082014f, -0.00952309f, 0.01397576f, -0.02970845f, -0.04101146f, 
    -0.03337599f, 0.00100582f, 0.01361756f, 0.01838045f, -0.03212183f, 0.02622397f, 0.02803785f, -0.00272923f, 
    0.00202152f, -0.03041212f, 0.00109752f, -0.03526762f, -0.00536088f, -0.03843459f, -0.03096190f, -0.02604951f, 
    -0.00487304f, 0.00418547f, 0.02376521f, 0.02868433f, -0.03664504f, -0.03878903f, 0.02215555f, 0.01998465f, 
    -0.00291120f, -0.00564954f, 0.01189987f, -0.00891340f, 0.01876983f, -0.01699415f, 0.02281190f, -0.00620908f, 
    -0.01174093f, 0.00371594f, -0.03472233f, 0.01866805f, -0.02283763f, 0.02737092f, -0.03610075f, -0.00247370f, 
    0.02637766f, -0.01713733f, 0.01323893f, -0.01034519f, 0.00076404f, 0.00010089f, -0.02368561f, -0.01297772f, 
    -0.00992693f, 0.03097072f, 0.00558028f, 0.02356320f, -0.02111037f, 0.02299278f, -0.00154300f, 0.02233583f, 
    0.01552325f, -0.03730072f, 0.01983110f, -0.00174620f, -0.01743141f, -0.02530116f, 0.02130541f, 0.02809237f, 
    0.03182505f, 0.02055646f, -0.03486898f, -0.03125198f, -0.01873103f, -0.00446235f, -0.00089138f, -0.01567213f, 
    0.01048940f, -0.00740264f, 0.01769728f, -0.03187311f, 0.03192546f, 0.02144252f, 0.02191096f, -0.02636518f, 
    -0.03688733f, -0.01752596f, -0.04052690f, 0.01007543f, 0.02391350f, -0.03648768f, -0.01401524f, -0.03540063f, 
    -0.01162750f, -0.02021246f, 0.00515129f, 0.02591299f, -0.00297113f, -0.02423011f, 0.02580092f, 0.00582703f, 
    0.01226880f, -0.02472177f, -0.01299350f, -0.01685265f, 0.01193314f, 0.01971224f, 0.00909201f, -0.02608122f, 
    -0.02700427f, 0.00610922f, 0.02280769f, -0.00787694f, -0.00264311f, -0.02360143f, -0.03538549f, 0.01660446f, 
    0.00264506f, -0.03138926f, 0.01585315f, -0.01656174f, 0.02593015f, 0.00515554f, 0.00154300f, 0.03666362f, 
    0.02498207f, -0.02262492f, 0.03438425f, 0.02720866f, 0.00598309f, -0.00042941f, 0.00097125f, 0.00685424f, 
    -0.00881132f, -0.02816886f, 0.02704680f, -0.01332582f, 0.02521503f, -0.01810711f, -0.01891202f, -0.02989410f, 
    0.01020701f, -0.02383976f, 0.01780651f, -0.01369621f, -0.03122298f, 0.01619765f, -0.01422225f, -0.01964866f, 
    -0.02387416f, 0.01972727f, 0.03181797f, -0.02672250f, -0.00801534f, 0.00285263f, 0.01023158f, -0.02083837f, 
    0.01936355f, 0.02867053f, -0.03411256f, -0.00556926f, 0.02843385f, 0.00017825f, -0.00742759f, 0.02477919f, 
    -0.02745016f, -0.01819804f, -0.03128708f, 0.02033729f, 0.00295795f, -0.02808674f, 0.00875782f, 0.02022051f, 
    -0.02445550f, 0.02147204f, 0.00843691f, 0.02224494f, -0.01628070f, 0.02832229f, -0.01856567f, 0.00288995f, 
    -0.00013558f, -0.02228403f, 0.00457653f, 0.02856003f, 0.00431386f, 0.00840744f, 0.02319047f, -0.02874532f, 
    -0.01644642f, 0.03305592f, -0.00384564f, 0.03186222f, -0.02693143f, 0.02235644f, 0.00618982f, 0.00542975f, 
    -0.01391062f, -0.03056316f, -0.01749835f, 0.02914466f, -0.02069146f, -0.00303362f, 0.00787123f, 0.01068428f, 
    0.01810050f, 0.01560079f, 0.01132683f, -0.02776748f, 0.02423271f, -0.02589215f, -0.02278029f, -0.02683391f, 
    0.02059684f, -0.01134354f, 0.01228633f, 0.02278436f, -0.02179123f, 0.00385704f, 0.02762327f, 0.02591886f, 
    0.03107872f, -0.03625508f, -0.00021791f, 0.02526335f, 0.02686759f, 0.01080022f, 0.01606396f, -0.03700966f, 
    0.02609702f, -0.02436971f, -0.01353901f, 0.00688387f, 0.02020510f, -0.01950922f, -0.03273521f, -0.00596793f, 
    0.01577195f, -0.01552937f, 0.01958005f, -0.03224314f, 0.01081585f, 0.00047540f, 0.01617078f, 0.01920787f, 
    0.00847885f, -0.00112971f, -0.02321951f, 0.00487482f, 0.00462538f, -0.02904487f, 0.01449403f, 0.02604469f, 
    -0.02319110f, -0.00559124f, -0.01875763f, 0.02522998f, -0.02338720f, -0.00464696f, 0.04508569f, -0.02091650f, 
    -0.03518567f, 0.02901375f, 0.01033342f, 0.01345716f, 0.01567936f, 0.00411282f, -0.02490664f, -0.02478781f, 
    0.01038914f, -0.03857450f, -0.04145182f, -0.03330753f, -0.01125270f, 0.00744988f, -0.00299268f, -0.01865593f, 
    0.01503330f, -0.01946471f, 0.01282185f, 0.02723774f, 0.01650685f, -0.04079200f, -0.03217427f, 0.01332864f, 
    -0.02300449f, -0.03897399f, -0.02387096f, -0.02223185f, -0.03509697f, -0.03861666f, 0.00053778f, 0.01165285f, 
    -0.00458608f, 0.02085183f, -0.03596802f, 0.02555168f, 0.03293924f, -0.01855164f, -0.01676534f, -0.02236540f, 
    0.01141515f, -0.00416805f, -0.00376212f, -0.02790394f, 0.00169975f, 0.00061006f, 0.01573200f, 0.02405636f, 
    0.00906859f, 0.01693626f, -0.02949566f, 0.02684635f, 0.01688171f, 0.00899813f, -0.01377748f, 0.01942770f, 
    -0.02422777f, 0.00430585f, -0.00902591f, -0.00342943f, -0.03914531f, -0.02845063f, -0.00970301f, -0.00408754f, 
    0.00890234f, 0.02671628f, 0.02145831f, 0.02601647f, 0.02401749f, -0.00803848f, 0.03061290f, -0.02480354f, 
    -0.01714996f, -0.00397103f, 0.00482964f, -0.00860111f, -0.02812750f, 0.01922792f, -0.01515779f, 0.03249037f, 
    -0.03264458f, 0.03295713f, -0.04466514f, -0.02601610f, 0.01935062f, 0.02690590f, 0.00078817f, -0.00174100f, 
    -0.01696498f, -0.01547275f, -0.02287680f, -0.04045725f, -0.03604204f, -0.01956874f, 0.00036771f, 0.02677256f, 
    0.03605550f, 0.01699912f, 0.01093513f, -0.03348713f, 0.02765716f, -0.03671201f, -0.02047302f, 0.00775580f, 
    -0.00103084f, 0.02270157f, -0.04347611f, 0.02794577f, -0.02656827f, 0.01234869f, -0.03221111f, -0.03166658f, 
    0.00236377f, 0.02578064f, 0.02639121f, -0.03340972f, 0.02199139f, -0.01239448f, 0.00623872f, -0.00923554f, 
    -0.03842144f, -0.02013507f, -0.00091146f, -0.02458122f, 0.00717482f, -0.01095424f, 0.02730232f, -0.02780307f, 
    0.02677275f, 0.00378281f, -0.02455605f, -0.02539483f, 0.01016076f, -0.00941921f, -0.00765785f, 0.02803089f, 
    -0.00219915f, -0.03145881f, 0.03862706f, 0.02197619f, 0.01604839f, -0.00246326f, -0.02592196f, 0.02184509f, 
    -0.00117242f, -0.00656747f, 0.01620483f, 0.00992003f, 0.00265263f, -0.03591454f, 0.01096672f, 0.02273265f, 
    -0.00193795f, 0.00978278f, -0.01511407f, 0.02813079f, 0.01838127f, 0.02863601f, -0.02993766f, 0.00135432f, 
    0.02197888f, -0.01113176f, -0.00150806f, 0.03449769f, 0.02741904f, -0.03180515f, 0.01530892f, -0.03653068f, 
    0.01727878f, 0.04120591f, -0.01915385f, -0.01702600f, -0.00525695f, 0.00712030f, 0.01503733f, 0.00354410f, 
    -0.03138801f, -0.03940663f, -0.02978359f, -0.03307442f, -0.01677521f, 0.00446644f, -0.04110700f, -0.03990298f, 
    0.00364644f, 0.00852519f, 0.01022561f, -0.01916861f, -0.03276931f, 0.03555870f, -0.00285695f, -0.01422174f, 
    -0.01307779f, -0.00416137f, -0.03568110f, -0.03828924f, -0.02726487f, 0.00411209f, -0.00891686f, -0.00886868f, 
    -0.00671845f, 0.02152026f, 0.03429331f, 0.00599550f, -0.02687561f, -0.00830097f, 0.01892819f, -0.01782353f, 
    -0.00238952f, -0.01332190f, -0.01645497f, 0.02861976f, 0.02092335f, -0.00145972f, 0.00141077f, 0.02570564f, 
    -0.01899962f, -0.00922020f, -0.00113035f, 0.02728253f, -0.00119129f, 0.01189378f, -0.00719588f, 0.02241206f, 
    -0.01327750f, -0.01460487f, 0.03645885f, -0.01460005f, 0.01093352f, -0.01354370f, -0.03775904f, -0.02435453f, 
    0.00813026f, -0.01152643f, -0.03181254f, -0.03395030f, -0.03388137f, 0.02161611f, 0.01560807f, 0.01476690f, 
    0.03903988f, -0.03691394f, 0.01914751f, 0.03250040f, -0.01315619f, 0.02716315f, 0.02026417f, -0.00104536f, 
    0.04287470f, -0.02653349f, -0.02658945f, 0.00677696f, -0.04113182f, 0.00242065f, -0.03336897f, -0.02203428f, 
    0.00422985f, 0.04067570f, -0.01141687f, 0.01126437f, 0.02006109f, 0.00980466f, 0.00421061f, -0.04208286f, 
    0.00101457f, -0.04125831f, 0.02625688f, -0.00489502f, -0.00507261f, -0.02506432f, 0.01845721f, -0.01620897f, 
    -0.02897171f, -0.03615833f, -0.00612938f, 0.02604213f, 0.01676264f, 0.02574634f, 0.02012415f, 0.03644348f, 
    -0.00125106f, 0.01983907f, 0.01982201f, -0.03824715f, -0.01912788f, 0.00426437f, -0.03242692f, 0.02626937f, 
    0.01093650f, -0.01626899f, 0.01180865f, -0.01181124f, -0.02243944f, 0.00874143f, 0.02254840f, -0.00915201f, 
    -0.00886062f, -0.00626404f, 0.01234763f, -0.03172806f, 0.03218606f, -0.03011996f, -0.01252173f, -0.03233167f, 
    -0.00035323f, 0.03647566f, 0.02672034f, 0.01254478f, -0.00676984f, 0.01735341f, 0.02107485f, -0.01524568f, 
    -0.00178231f, 0.02157659f, -0.02243178f, -0.03572613f, -0.00177104f, -0.02063406f, -0.03675842f, -0.02771055f, 
    0.00973662f, 0.02343105f, -0.01529256f, 0.00292772f, 0.00224840f, 0.03020781f, 0.00939061f, 0.01726229f, 
    -0.00026502f, -0.00146179f, 0.01390903f, -0.00044082f, 0.01589719f, 0.01939042f, -0.00404588f, -0.01674249f, 
    -0.03213460f, 0.01330085f, -0.01510745f, 0.03035521f, 0.00360277f, -0.00816344f, 0.01848795f, -0.00206892f, 
    -0.03618868f, 0.01468653f, -0.02391543f, 0.00761398f, -0.03316353f, -0.03944563f, -0.01881796f, 0.01398284f, 
    0.01637339f, -0.03824215f, -0.02052301f, -0.01471332f, 0.00552833f, -0.00009246f, -0.02542551f, 0.00146256f, 
    -0.02774492f, -0.02438085f, 0.02571590f, -0.03031620f, -0.02207146f, 0.00207247f, 0.00303704f, 0.01300443f, 
    0.03609502f, 0.02298198f, -0.04147479f, 0.00926853f, 0.01210401f, 0.02077667f, -0.02223397f, -0.04481784f, 
    -0.00616318f, -0.01147787f, 0.01958778f, -0.02073171f, 0.00303288f, -0.02394744f, -0.02280658f, 0.02864984f, 
    -0.03560249f, -0.00988915f, -0.02580797f, 0.01157702f, 0.01319305f, -0.01273110f, -0.00554847f, -0.03189220f, 
    -0.01567502f, 0.02056578f, -0.00876428f, 0.01914858f, 0.00762527f, -0.01878648f, -0.01474581f, -0.00404022f, 
    -0.01979193f, -0.00835634f, -0.00639723f, -0.00131515f, -0.00837554f, 0.00690366f, -0.03939893f, 0.04094706f, 
    -0.03386657f, 0.01941200f, -0.02998336f, 0.02274081f, -0.01426569f, -0.00544550f, -0.02670765f, -0.01500970f, 
    -0.03783670f, -0.03696861f, -0.03433411f, 0.00350212f, -0.02537384f, -0.03058330f, 0.01389523f, -0.03857059f, 
    0.02510573f, -0.00116743f, 0.02870734f, 0.02475972f, -0.03807775f, -0.00614819f, -0.01064355f, -0.03020980f, 
    0.00391936f, 0.01984074f, -0.03333182f, 0.00819727f, 0.02722901f, 0.00267239f, -0.02479266f, 0.01527071f, 
    0.01809496f, -0.03571499f, -0.00830636f, -0.01319360f, 0.01094024f, -0.01998673f, -0.03596910f, 0.02050370f, 
    -0.03397796f, -0.00715084f, -0.03787594f, -0.03909967f, 0.00660695f, 0.02364655f, -0.01731189f, 0.01936383f, 
    -0.01101277f, 0.02170121f, -0.03443692f, 0.01538637f, -0.00596685f, 0.01669821f, 0.01411202f, -0.04009147f, 
    -0.03089663f, 0.03085613f, 0.02597481f, -0.00731114f, -0.01546614f, -0.01141327f, 0.01841658f, 0.01215078f, 
    0.02587517f, 0.02262628f, -0.02117302f, -0.02763034f, 0.00655030f, -0.01072088f, -0.01491207f, 0.00132927f, 
    -0.03958536f, -0.02871032f, -0.01867703f, -0.02943965f, -0.02831735f, 0.03532974f, -0.01080745f, -0.03047131f, 
    -0.03510943f, -0.01679409f, -0.02020324f, -0.02570107f, -0.03113818f, -0.01760539f, 0.02665299f, -0.01494161f, 
    -0.01327683f, 0.01228514f, -0.01784461f, -0.01177473f, 0.01991247f, -0.02600410f, 0.04058007f, -0.00751758f, 
    0.00108250f, -0.00391627f, 0.00669557f, 0.00548274f, 0.00499768f, -0.01402932f, 0.03068769f, -0.04389185f, 
    -0.03246000f, -0.04380655f, -0.02885888f, -0.03391856f, -0.04092226f, 0.00074815f, 0.00628270f, -0.01518343f, 
    -0.01529509f, -0.03609572f, -0.02569264f, -0.03911763f, 0.02604027f, -0.01161915f, -0.03325450f, 0.00556725f, 
    0.01186799f, 0.01588096f, 0.01315346f, 0.04678479f, 0.03552124f, 0.01450677f, 0.00612238f, 0.03583694f, 
    0.01570629f, 0.00803421f, -0.02670780f, -0.02409416f, -0.00954204f, -0.00059945f, -0.00836075f, -0.00720473f, 
    -0.04049576f, 0.00070928f, -0.01582909f, -0.02530515f, 0.02745583f, -0.02118788f, -0.02591455f, -0.01540258f, 
    -0.00484633f, 0.01352344f, 0.01806714f, 0.01760571f, 0.01147195f, 0.01651183f, 0.02665412f, -0.02433607f, 
    0.01935883f, -0.00658782f, -0.04269950f, -0.02061605f, 0.01233271f, -0.02390870f, -0.01762502f, -0.00670141f, 
    0.01599056f, 0.00526133f, -0.01699642f, 0.00070647f, 0.00879195f, 0.02313251f, 0.03897929f, -0.01769103f, 
    -0.01277973f, -0.00220220f, -0.00187998f, 0.01145559f, 0.02695956f, 0.02109218f, -0.01058763f, -0.00123500f, 
    0.01456247f, -0.03372202f, 0.01011274f, -0.01539949f, -0.03465410f, -0.01171238f, 0.03741745f, -0.03505227f, 
    0.02783134f, -0.01280955f, 0.02479212f, 0.01986934f, 0.01301070f, -0.03161445f, -0.04071374f, 0.00972399f, 
    0.01545110f, 0.01281636f, 0.00929469f, 0.02905426f, 0.00686066f, 0.01465967f, 0.04501237f, -0.00873084f, 
    -0.04118861f, 0.03690916f, 0.01929597f, 0.03130736f, -0.00480218f, -0.04020755f, 0.00750233f, -0.02479506f, 
    -0.02758439f, 0.00010283f, 0.01701152f, 0.01042323f, -0.03541660f, 0.00630789f, 0.00446397f, 0.02077233f, 
    0.00603466f, 0.00511656f, -0.01463812f, -0.03839108f, 0.01001154f, 0.01608092f, 0.01340277f, 0.00870431f, 
    -0.02187827f, -0.00449764f, -0.03647236f, 0.01734361f, 0.01302822f, -0.03422400f, 0.00654472f, 0.00821920f, 
    0.01982351f, -0.01173537f, 0.01418836f, -0.02596474f, -0.00974417f, 0.02934247f, -0.01155176f, 0.02424622f, 
    0.02303165f, -0.00500629f, -0.00603658f, 0.00674280f, -0.02197089f, -0.00632597f, 0.00178374f, -0.02116755f, 
    0.01782067f, -0.01937030f, 0.01374592f, 0.00948763f, 0.02213578f, -0.00087255f, -0.02907240f, -0.03385323f, 
    -0.04070963f, 0.01000802f, -0.02764129f, -0.02837718f, 0.00387624f, 0.01124305f, 0.02348964f, -0.03114863f, 
    0.01382020f, -0.00279828f, 0.03807744f, 0.01004135f, -0.01083464f, 0.02928903f, 0.00722681f, 0.02094197f, 
    -0.00316444f, 0.02838309f, -0.02754495f, -0.01667128f, -0.02599187f, -0.01662802f, -0.00489808f, 0.01708921f, 
    -0.01315463f, 0.01886103f, 0.02106882f, -0.02816753f, -0.01707388f, -0.02556540f, 0.03132942f, -0.00163458f, 
    -0.02771065f, 0.01122603f, -0.02190977f, 0.02590233f, -0.00177053f, -0.00174807f, 0.00981180f, 0.01148839f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.03158548f, -0.05044761f, -0.01323851f, 0.00764759f, -0.04781150f, -0.03854316f, 0.03083053f, 0.06631007f, 
    -0.01747271f, -0.01277577f, -0.00196312f, 0.01396623f, 0.01522192f, 0.12840091f, -0.02644699f, -0.02036992f, 
    -0.03566067f, -0.02454498f, 0.05267226f, 0.02109856f, -0.01564042f, 0.01721844f, -0.04717378f, 0.00540923f, 
    0.10820170f, 0.10581362f, -0.01350346f, 0.02528572f, 0.02519075f, 0.00580261f, 0.03165434f, 0.01306170f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.06483051f, -0.02118277f, 0.11847126f, -0.16921201f, 0.01590325f, 0.03767529f, 0.16048023f, -0.01972087f, 
    -0.17063054f, -0.11814719f, 0.03120684f, -0.10921209f, 0.08600964f, 0.02628545f, -0.15769762f, -0.06312222f, 
    0.01701994f, 0.10273510f, -0.11951262f, 0.11285711f, -0.00147281f, -0.00428632f, -0.09860227f, -0.09450255f, 
    0.12939851f, -0.02570326f, 0.15778419f, -0.06972456f, 0.05920986f, 0.08656121f, -0.17488141f, 0.01347474f, 
    -0.09461947f, 0.30408028f, 0.12583217f, -0.05223974f, 0.37776130f, 0.15664665f, 0.06483019f, -0.31375924f, 
    0.06332727f, 0.07424080f, 0.04493706f, 0.15078793f, 0.16793242f, 0.02073022f, -0.05407792f, 0.00974468f, 
    0.14125738f, -0.14001818f, 0.01735834f, 0.55856150f, -0.03976224f, -0.02035227f, 0.05599425f, -0.08581302f, 
    -0.51324135f, 0.29545090f, 0.14965421f, 0.03482119f, 0.07186816f, -0.05260655f, 0.11198313f, 0.06452771f, 
    -0.11751550f, 0.25110316f, -0.10852123f, -0.07827058f, 0.20340100f, 0.05230551f, -0.08185109f, -0.01634760f, 
    -0.13969256f, 0.01191622f, -0.11590283f, 0.12780285f, -0.02476461f, 0.03269178f, 0.44611388f, 0.03548403f, 
    0.27996203f, -0.04028558f, -0.38693804f, 0.48971173f, -0.05728953f, -0.12530413f, 0.06679023f, 0.18346959f, 
    0.15086333f, 0.20194073f, 0.14522931f, 0.17998867f, -0.08689936f, 0.16123436f, 0.10668805f, -0.09988116f, 
    -0.02631053f, -0.08516637f, 0.15911688f, 0.01642361f, -0.14326102f, -0.04146203f, 0.12165869f, -0.08339778f, 
    -0.15507191f, -0.10009919f, 0.03158492f, 0.16503085f, 0.07248445f, -0.12496339f, -0.02290933f, 0.09648215f, 
    -0.15064165f, 0.06760895f, 0.08696136f, -0.07016978f, 0.02803366f, -0.04729032f, -0.13525416f, 0.00948643f, 
    -0.02503215f, -0.07279565f, 0.08371191f, -0.15864438f, -0.04618275f, 0.12452856f, -0.06862457f, 0.15557924f, 
    -0.02790351f, -0.02992940f, -0.14094251f, 0.02247127f, -0.05520261f, 0.02905319f, -0.03585970f, 0.03640622f, 
    -0.10006195f, 0.10330814f, 0.08245704f, -0.11582826f, 0.06655748f, -0.11588521f, -0.02045896f, -0.09086605f, 
    -0.13934597f, -0.04402211f, -0.10209090f, -0.09531035f, -0.05855959f, 0.01623324f, -0.13259822f, 0.01589164f, 
    0.08342750f, 0.10163590f, 0.03985393f, 0.12543100f, -0.14866775f, 0.02425279f, 0.05906672f, 0.13881575f, 
    -0.08353247f, -0.04883303f, 0.13031931f, -0.06422606f, 0.50216067f, 0.08310647f, -0.00151948f, -0.02163807f, 
    -0.21241637f, -0.08526213f, -0.04166615f, -0.02842345f, 0.07472615f, 0.21170828f, -0.38536987f, -0.06477955f, 
    0.02678098f, 0.12450404f, 0.14856116f, 0.34052923f, -0.17905654f, 0.01764276f, 0.19529960f, -0.14247912f, 
    -0.08348422f, -0.08710650f, -0.02492323f, 0.08944132f, 0.04868219f, -0.07970354f, 0.13418402f, 0.03899754f, 
    -0.10064700f, -0.46530965f, -0.16913514f, -0.12226071f, 0.02490585f, 0.18474063f, -0.13999075f, -0.19917090f, 
    0.15647221f, 0.06441750f, 0.16568591f, -0.12438305f, -0.08722960f, 0.09809103f, 0.59449118f, -0.10068939f, 
    0.08496246f, 0.00307055f, -0.11442454f, -0.09922900f, -0.09249612f, 0.12897389f, 0.36635578f, -0.05327884f, 
    -0.02432028f, -0.15735449f, -0.07091278f, -0.02586043f, -0.17891727f, 0.05515400f, -0.16154088f, -0.00379223f, 
    -0.04415315f, -0.05984768f, 0.14802781f, 0.15474510f, 0.49985045f, -0.11172125f, -0.01320889f, -0.15619005f, 
    -0.01442820f, -0.17186259f, 0.12060793f, 0.10048518f, 0.12742727f, 0.11351336f, 0.25851792f, -0.16370371f, 
    0.25976443f, 0.10619748f, 0.04721215f, 0.18844131f, -0.09110352f, -0.10130970f, 0.37568107f, 0.10090648f, 
    -0.07338751f, -0.29669547f, 0.17080505f, 0.14738610f, 0.06394888f, 0.14215529f, 0.17491737f, -0.04073528f, 
    -0.10834425f, -0.40158796f, -0.16581149f, 0.01564622f, -0.25168318f, -0.15923092f, -0.01616289f, -0.04339660f, 
    0.12591763f, 0.14352097f, 0.03249842f, 0.14621100f, -0.14056140f, 0.32762069f, -0.23400088f, -0.06667811f, 
    0.20515536f, 0.16875729f, -0.10635868f, -0.08778676f, -0.02287708f, -0.14726610f, -0.41587767f, 0.07345227f, 
    0.04348042f, 0.26591182f, -0.12675032f, -0.16235620f, -0.10722704f, 0.04562523f, -0.02384534f, 0.08074156f, 
    -0.17166638f, 0.09610387f, 0.07831777f, 0.16404441f, 0.02487561f, -0.16329928f, 0.04195778f, 0.06739875f, 
    -0.18109348f, 0.00775506f, 0.13302080f, 0.06486009f, -0.09985375f, -0.11628395f, -0.11259476f, 0.01579939f, 
    -0.17694561f, -0.05226020f, 0.15478750f, 0.06484295f, 0.07153165f, -0.13917290f, 0.09584841f, -0.00481113f, 
    -0.12527128f, -0.01592928f, 0.16511135f, 0.00829010f, 0.07128840f, -0.01956116f, 0.04821284f, -0.10773866f, 
    0.08815192f, -0.49312067f, 0.07409191f, 0.04777774f, -0.06839717f, -0.07938365f, -0.16052374f, -0.04111079f, 
    0.18063475f, 0.11840585f, -0.12670983f, 0.16687584f, -0.01227729f, 0.01563877f, 0.34826815f, 0.10961055f, 
    0.24814366f, 0.06888226f, -0.31454068f, 0.15884402f, -0.04151751f, -0.15772553f, -0.11617522f, 0.06238513f, 
    -0.09610371f, 0.32386103f, 0.17323819f, 0.11837383f, -0.07898261f, 0.10111620f, -0.11150648f, 0.05551972f, 
    -0.00246130f, 0.35822600f, -0.17641729f, 0.11479486f, -0.36135945f, 0.04901436f, -0.04855451f, 0.45429423f, 
    0.22523360f, 0.01715654f, 0.14164563f, -0.09907384f, 0.02117237f, -0.16175985f, -0.05243159f, -0.11875080f, 
    -0.29091048f, 0.16628131f, 0.32206526f, -0.15107484f, 0.07271913f, -0.16231841f, -0.26182163f, 0.02089919f, 
    0.36463580f, 0.08495778f, -0.10494792f, 0.14046258f, 0.11956065f, 0.10648184f, 0.12424170f, -0.01119308f, 
    0.13741225f, -0.13012801f, 0.13526756f, 0.06522912f, 0.13409579f, 0.03379982f, -0.07513263f, 0.12720034f, 
    -0.14636396f, 0.04719352f, -0.01315311f, 0.15450680f, 0.05943444f, -0.12679942f, 0.07132280f, -0.02680857f, 
    -0.10999552f, 0.05230903f, -0.13166931f, -0.01653414f, -0.04570257f, 0.10312739f, 0.04322350f, -0.08358036f, 
    0.11780091f, -0.02741364f, 0.01414440f, -0.08778788f, 0.14887647f, -0.03109385f, -0.11774366f, 0.02372144f, 
    0.15317988f, -0.06799618f, -0.14476161f, -0.06825268f, -0.15303354f, -0.00019840f, 0.02060444f, 0.02618674f, 
    -0.14308466f, 0.15673071f, -0.00752734f, -0.10038266f, 0.05702105f, -0.16593786f, 0.08034259f, -0.05884948f, 
    0.06372888f, 0.13416071f, -0.09148759f, -0.12781131f, 0.00107672f, -0.08251099f, -0.15379666f, -0.07031713f, 
    -0.04475709f, -0.12005099f, -0.16242975f, -0.13637915f, -0.08754174f, 0.09474329f, -0.07502899f, 0.05562137f, 
    0.13350829f, 0.25209221f, -0.00751572f, -0.04532431f, 0.49896926f, -0.01247744f, 0.12003122f, -0.22273012f, 
    0.00518179f, -0.07863073f, 0.06485851f, -0.06694043f, 0.14782259f, 0.02002231f, 0.43319446f, 0.07364853f, 
    -0.18615384f, 0.04442813f, 0.00356694f, 0.09228569f, 0.02828076f, -0.04110039f, 0.20571132f, -0.08678540f, 
    -0.22646186f, -0.20593795f, 0.01288379f, 0.17382661f, -0.07880291f, 0.16089749f, -0.10665978f, 0.16137590f, 
    -0.00336067f, 0.10354991f, 0.13443141f, 0.10707306f, 0.16319561f, -0.06184602f, 0.00008950f, 0.24495204f, 
    -0.21300381f, 0.00819368f, -0.09274662f, -0.01982936f, -0.09139244f, -0.14741452f, 0.31234309f, -0.14437953f, 
    -0.05589144f, 0.08811557f, 0.11520319f, -0.06368702f, -0.10654450f, -0.16631091f, 0.09098107f, -0.04921658f, 
    0.02569946f, 0.35239902f, -0.09411593f, -0.08406553f, 0.06340277f, -0.06024075f, 0.01034165f, -0.01736704f, 
    0.01384961f, -0.17700796f, -0.14174774f, 0.03452559f, 0.08910896f, 0.11473065f, 0.00046233f, 0.36094433f, 
    0.24919546f, 0.08154648f, 0.13251737f, 0.14235729f, -0.04262038f, -0.03751794f, -0.32095912f, -0.10242910f, 
    0.03445779f, -0.05865911f, 0.09424966f, 0.10822334f, -0.11229151f, 0.08113236f, 0.28235608f, -0.06015624f, 
    -0.18445942f, -0.28063509f, -0.03258422f, -0.06070913f, 0.15339978f, 0.12366891f, 0.14245231f, -0.03482317f, 
    0.12173408f, 0.65476519f, 0.05436975f, -0.02943226f, -0.20141298f, -0.15796752f, -0.05613304f, -0.32408571f, 
    -0.00546901f, 0.09234695f, 0.15845288f, 0.02282950f, -0.06659544f, -0.00085796f, 0.23297961f, 0.11265291f, 
    0.23101215f, -0.13361101f, 0.12314465f, -0.24199736f, 0.14371282f, 0.11605138f, 0.29194430f, -0.04527778f, 
    0.41034523f, -0.04356167f, -0.03733642f, 0.13846168f, 0.03354286f, 0.02060392f, 0.14910661f, 0.16932932f, 
    -0.00287340f, -0.14883614f, 0.13467444f, -0.05886865f, -0.09172060f, -0.09388195f, -0.15903859f, 0.04047511f, 
    -0.09220281f, -0.08513049f, -0.10050506f, -0.12471560f, 0.10366757f, -0.14542711f, 0.12166749f, -0.07035670f, 
    -0.11467890f, -0.10318092f, 0.16111031f, 0.00862840f, 0.11920926f, -0.15739727f, 0.11217095f, -0.03648480f, 
    -0.08982904f, -0.10336640f, -0.14169689f, 0.13075633f, -0.02219965f, 0.12717529f, 0.07069932f, -0.05902103f, 
    -0.05827674f, -0.09480194f, -0.01373526f, 0.01482026f, 0.02882412f, 0.14367092f, -0.03988024f, 0.07576497f, 
    0.07146601f, -0.15216351f, 0.04637495f, 0.08551192f, 0.08682057f, -0.16062690f, -0.15011671f, -0.13389567f, 
    -0.12822263f, -0.04836869f, -0.06324325f, -0.06060730f, 0.16036655f, 0.07397385f, 0.08065614f, 0.03333546f, 
    0.07889260f, 0.02683498f, -0.13537863f, 0.04233177f, -0.06222709f, -0.01546629f, 0.02284964f, 0.10020003f, 
    -0.14011197f, 0.05219145f, -0.01116088f, 0.01507314f, -0.44359517f, -0.07677242f, -0.00844720f, -0.48940516f, 
    0.15284239f, -0.12998255f, 0.05419955f, 0.17894648f, 0.16472389f, 0.33568132f, -0.34492302f, -0.04449366f, 
    -0.13419046f, -0.06024842f, 0.43977478f, 0.02576170f, -0.14830558f, -0.15384065f, -0.32407317f, 0.08701444f, 
    -0.03587605f, 0.17961144f, -0.12905011f, -0.14316377f, 0.09998097f, 0.08287954f, 0.12780909f, 0.09828789f, 
    0.03367670f, 0.04782616f, 0.14038825f, -0.01006998f, -0.12241011f, 0.07115593f, 0.01022103f, 0.15930058f, 
    -0.11097293f, 0.03140842f, -0.13654533f, 0.00227048f, -0.06031018f, 0.06026652f, 0.05569362f, -0.17390721f, 
    0.25085297f, -0.04538479f, -0.32387361f, 0.38183904f, 0.16521028f, -0.09066928f, 0.23566535f, 0.11703970f, 
    0.33921552f, 0.16381276f, 0.14784577f, 0.02003338f, 0.09518337f, 0.15953267f, 0.04513183f, 0.14731179f, 
    0.10177374f, 0.07666451f, 0.04293676f, -0.03460275f, -0.04654645f, 0.11533729f, -0.09896961f, -0.02990698f, 
    -0.06271967f, -0.15114830f, 0.02131101f, -0.06320236f, -0.06158388f, -0.05842377f, 0.12387833f, 0.16692737f, 
    -0.09289405f, -0.14273129f, -0.00987568f, 0.10240101f, 0.01521809f, -0.05523176f, -0.10717269f, 0.01651398f, 
    0.04665985f, -0.12293329f, 0.14856412f, 0.15318739f, -0.10934559f, 0.04488778f, 0.16594993f, 0.01273031f, 
    -0.13651377f, -0.40917864f, -0.05121081f, 0.00603281f, 0.00058678f, -0.08772966f, 0.08377930f, -0.03559479f, 
    0.23255281f, 0.02331994f, 0.04937712f, 0.01517696f, -0.10054296f, 0.14413573f, 0.24379565f, -0.04189711f, 
    0.11576907f, 0.09532008f, 0.31644529f, -0.58224779f, 0.01267652f, 0.13156310f, 0.06288876f, -0.06810408f, 
    0.03928117f, -0.06928347f, -0.07340827f, -0.17905603f, -0.09655981f, 0.07293803f, -0.08874955f, -0.10751276f, 
    -0.01899975f, -0.15609178f, -0.15546927f, 0.15877236f, -0.00818772f, 0.03640151f, 0.11567458f, -0.09026437f, 
    -0.03888679f, -0.18088521f, 0.14882441f, 0.03162512f, 0.10257259f, -0.05201733f, 0.01316212f, 0.06473397f, 
    0.01709826f, 0.10449640f, 0.08123843f, -0.11229250f, 0.07891031f, 0.02458938f, 0.08134556f, 0.10598377f, 
    0.13665383f, -0.05883301f, 0.02408155f, 0.10748932f, 0.02249767f, 0.01781494f, 0.04146267f, 0.04587098f, 
    0.15857811f, -0.12820800f, 0.10774656f, 0.05919467f, -0.01647605f, 0.04494039f, -0.03080739f, -0.17065929f, 
    -0.13796410f, 0.11595655f, 0.01173966f, -0.16666862f, -0.14583141f, -0.01812852f, -0.06827065f, 0.12837857f, 
    0.11290260f, -0.04187410f, 0.09285844f, 0.05011804f, -0.10654866f, 0.15807183f, -0.07644174f, -0.13132103f, 
    -0.01598167f, -0.06367559f, -0.04297468f, -0.03034708f, 0.01830126f, -0.07151554f, -0.16228069f, 0.09926777f, 
    0.11164569f, 0.01069132f, 0.03027966f, 0.02655721f, -0.15646438f, -0.09529502f, -0.17439227f, -0.12613381f, 
    -0.02440063f, 0.14001402f, 0.13497695f, 0.04629246f, -0.18008927f, -0.04317320f, 0.09677111f, -0.00326503f, 
    0.11277870f, 0.17869362f, -0.18424626f, -0.11122588f, -0.08644638f, -0.12133177f, 0.12731384f, -0.15256217f, 
    -0.15296787f, -0.03925924f, -0.06125811f, -0.01085937f, 0.11519077f, 0.11764276f, 0.07023960f, -0.09974615f, 
    -0.06185459f, 0.30360836f, 0.06690436f, -0.01293879f, -0.05653593f, 0.01144744f, 0.10676688f, 0.47591940f, 
    -0.09122172f, -0.13670057f, 0.16414309f, -0.13845198f, -0.06249946f, -0.05554909f, 0.48310101f, 0.06880976f, 
    0.21694201f, -0.07659368f, -0.32778701f, 0.16078864f, -0.00450897f, 0.11212599f, 0.35325864f, -0.13163333f, 
    0.64916968f, 0.07941213f, -0.11428765f, 0.13044992f, 0.12518275f, 0.08035972f, 0.06179169f, -0.16784172f, 
    0.12373704f, -0.06250071f, 0.12688999f, -0.11654525f, 0.56806457f, 0.05279255f, 0.01037565f, 0.41169649f, 
    -0.01354174f, -0.03589007f, 0.08124445f, 0.08880588f, 0.10688297f, -0.05430187f, -0.18175340f, -0.03328102f, 
    -0.28721344f, 0.06426631f, 0.51779193f, -0.12139144f, -0.08758763f, -0.01701529f, 0.20602381f, 0.07035264f, 
    -0.13662615f, 0.13578194f, 0.12530927f, 0.11880795f, -0.03171117f, 0.15921426f, 0.09056757f, 0.06672112f, 
    0.11980606f, -0.14331743f, -0.07512607f, -0.06939156f, -0.06146422f, 0.02163940f, -0.13721471f, 0.05616618f, 
    -0.09291545f, -0.13792419f, 0.09985860f, -0.17050451f, -0.07729694f, -0.16163571f, -0.08930046f, 0.07857371f, 
    -0.08999365f, 0.01948639f, 0.06376539f, -0.11861201f, -0.14793175f, 0.17449500f, 0.14536230f, 0.12184694f, 
    0.10337036f, 0.06417497f, -0.03148083f, -0.02131564f, 0.05787719f, -0.16717334f, -0.09741088f, -0.16711949f, 
    -0.03841603f, 0.23869641f, -0.06530409f, 0.03173904f, -0.01364790f, 0.08911635f, -0.04108483f, -0.47156328f, 
    -0.00413938f, 0.02795525f, 0.14502126f, 0.07411645f, -0.06092278f, 0.23744844f, -0.10562782f, -0.16209880f, 
    0.07180183f, 0.01734406f, 0.05722084f, 0.14710572f, -0.15345018f, 0.05934339f, 0.10163439f, 0.09209880f, 
    0.18166158f, -0.28160343f, -0.15723485f, 0.05379988f, 0.11408903f, -0.03166240f, 0.09750620f, 0.14356989f, 
    0.05799753f, -0.13398267f, 0.01498642f, -0.14028503f, 0.14852956f, 0.06992596f, -0.06190664f, 0.16389824f, 
    -0.31240025f, 0.12043837f, -0.04354566f, -0.07452063f, 0.17487399f, 0.17133433f, -0.34091109f, 0.12054010f, 
    -0.17446053f, 0.15656520f, 0.11675961f, 0.41747084f, 0.09232528f, 0.08401766f, -0.08295541f, 0.06941724f, 
    0.24770506f, 0.27900785f, 0.17220078f, -0.11433144f, 0.01270152f, -0.08082982f, 0.04895501f, 0.15738475f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.07370378f, -0.20554996f, 0.04886873f, 0.06123583f, -0.15834473f, -0.00008548f, 0.10841665f, 0.11112317f, 
    -0.01843493f, -0.12396880f, 0.15994164f, 0.03659275f, -0.06841300f, 0.04902619f, -0.09444642f, 0.15183596f, 
    -0.01885024f, 0.02190157f, 0.16270749f, -0.01034859f, 0.01424926f, -0.07165959f, -0.10077960f, 0.01335443f, 
    -0.16835341f, -0.00231755f, 0.07642480f, 0.05916402f, -0.05431341f, 0.07646432f, -0.11294290f, -0.03116043f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.03398373f, 0.34890467f, -0.03901481f, 0.16088837f, 0.06169820f, 0.05761212f, 0.29277256f, 0.19373323f, 
    -0.07255868f, -0.03456303f, -0.17404127f, -0.68920642f, 0.12127327f, -0.12467564f, 0.53368145f, -0.44162560f, 
    -0.22903064f, 0.12504059f, -0.12895495f, -0.01021170f, 0.05505906f, -0.25607303f, 0.09619101f, 0.07827806f, 
    -0.06060349f, 0.05878551f, 0.12634176f, -0.32918894f, 0.03278745f, -0.12469244f, 0.18978086f, -0.46553591f, 
    -0.00923931f, 0.23847798f, -0.48518842f, -0.12225298f, -0.01283852f, 0.31485230f, -0.09132802f, -0.09593415f, 
    0.17764527f, -0.12102958f, -0.09112465f, -0.30259451f, -0.01556020f, 0.13354932f, -0.48986182f, 0.28510448f, 
    0.14275879f, -0.29246977f, 0.04644131f, -0.08713741f, 0.33994803f, -0.11427742f, -0.03206935f, -0.03666420f, 
    0.04593880f, -0.14114358f, 0.03873681f, -0.54894155f, 0.11618551f, 0.02257957f, 0.11698476f, 0.10852881f, 
    0.12146480f, -0.42767432f, -0.56834614f, 0.08170069f, 0.02308143f, -0.20476510f, 0.17511399f, 0.12864959f, 
    -0.02850764f, -0.06421196f, -0.21045867f, 0.19894871f, -0.16009428f, 0.14546295f, 0.08369305f, -0.53880447f, 
    0.34889269f, -0.20885943f, 0.01357022f, 0.09546211f, 0.06373131f, -0.51204783f, 0.00971257f, 0.33880341f, 
    0.01618162f, -0.01914138f, 0.09936101f, -0.12224253f, 0.32201010f, 0.08415814f, -0.39171812f, -0.41002476f, 
    0.05976526f, 0.23318195f, 0.22773646f, -0.14069431f, -0.06721450f, 0.26997977f, -0.42130795f, 0.26237461f, 
    -0.44975665f, -0.06505018f, 0.08546001f, -0.20002437f, -0.11847351f, -0.07448258f, 0.40468729f, 0.06975254f, 
    0.01563073f, -0.16381380f, -0.01960905f, -0.16831239f, -0.51705319f, 0.09250400f, 0.09342361f, -0.37160772f, 
    -0.08992621f, -0.11674911f, -0.07740101f, 0.04923928f, 0.31204185f, 0.10452604f, -0.65713584f, 0.22565416f, 
    -0.08260274f, 0.15681729f, 0.15068087f, -0.15901543f, -0.15518035f, 0.34707022f, 0.03627763f, 0.07961916f, 
    -0.05626015f, 0.17042799f, -0.23296845f, -0.34329152f, -0.12329732f, 0.10024168f, -0.02493313f, -0.41327459f, 
    0.30910894f, -0.02413216f, -0.03753358f, -0.17043595f, -0.17249545f, 0.29389620f, 0.15865816f, -0.37732542f, 
    0.16804205f, 0.01172312f, 0.00595458f, 0.23494640f, -0.26926932f, -0.03469938f, 0.21588968f, 0.20666745f, 
    0.00204915f, 0.14959675f, 0.15902874f, 0.03685895f, -0.09103869f, -0.08135728f, -0.15163809f, -0.14223760f, 
    0.33020270f, 0.07129572f, 0.02621775f, -0.05576639f, -0.15090030f, -0.13173059f, -0.33332598f, -0.26468968f, 
    -0.73203790f, 0.14682481f, -0.09512492f, -0.03714925f, 0.32803303f, 0.05691188f, 0.12552689f, -0.08132558f, 
    -0.03593137f, 0.01878346f, 0.12797390f, -0.20757557f, -0.46136475f, 0.06303112f, 0.06087457f, 0.21725440f, 
    0.08923420f, 0.01252664f, 0.10142537f, -0.12587686f, -0.16598588f, -0.19970243f, 0.13864234f, 0.17495668f, 
    0.22422838f, 0.16204748f, 0.44803631f, -0.40736240f, 0.10772858f, 0.06722633f, -0.47783753f, -0.66173226f, 
    0.14654548f, -0.13220057f, 0.03927151f, 0.13416903f, -0.24231048f, 0.19231856f, 0.08050785f, 0.14238566f, 
    0.12198116f, -0.03402939f, -0.02253222f, 0.09292705f, -0.41124123f, 0.05081358f, -0.27329952f, -0.53711283f, 
    -0.16906437f, 0.26281735f, 0.14318159f, 0.09814703f, 0.00453681f, -0.62929475f, -0.44316545f, -0.26068938f, 
    -0.39256108f, -0.00068753f, -0.11829372f, 0.26093459f, -0.13497373f, 0.08885340f, -0.03398814f, 0.31986979f, 
    0.05052647f, 0.34056389f, 0.10472797f, 0.02594406f, -0.27199322f, 0.14127180f, -0.13862370f, -0.36470577f, 
    0.04205216f, 0.14352329f, -0.16953154f, 0.27528831f, 0.00784772f, 0.09039597f, -0.20064086f, -0.34623113f, 
    0.10765514f, 0.20532161f, -0.11674451f, -0.14169531f, -0.04294167f, -0.53161031f, -0.31412339f, -0.67988086f, 
    0.34452072f, -0.15065676f, 0.19631898f, 0.40307596f, 0.03436970f, 0.00294211f, -0.54471081f, -0.37912971f, 
    0.18413948f, -0.50857604f, -0.14775938f, -0.14408858f, 0.26408336f, -0.10926090f, -0.00180574f, -0.04950812f, 
    -0.16330931f, 0.04521577f, 0.16206281f, -0.31956968f, 0.06940439f, 0.07885037f, -0.84978104f, -0.06858049f, 
    -0.09354837f, -0.71537846f, -0.15709244f, 0.00153587f, 0.11310241f, -0.33774120f, 0.10401247f, 0.02721438f, 
    -0.18207183f, -0.11790857f, -0.14052592f, 0.21458119f, 0.13068467f, -0.12392983f, -0.17513649f, -0.32160848f, 
    0.02953443f, 0.37150955f, -0.15206884f, -0.01051516f, 0.06566820f, 0.13511102f, 0.09828518f, 0.10797710f, 
    -0.04238280f, 0.11394037f, -0.00608178f, 0.27905744f, -0.22358975f, -0.00503093f, 0.16083078f, -0.40910059f, 
    -0.15784746f, -0.31749162f, -0.18682402f, -0.07594470f, -0.01414851f, 0.13786264f, -0.64565343f, -0.27998313f, 
    0.11256717f, 0.12499428f, -0.42438656f, 0.27791035f, 0.12844667f, 0.16619053f, -0.50763482f, 0.01250260f, 
    -0.07109304f, -0.04166029f, -0.02976309f, -0.07028596f, -0.13347200f, 0.03479064f, 0.12430985f, 0.09047838f, 
    0.13541536f, 0.16920133f, -0.02946544f, 0.16709222f, 0.26196393f, 0.08921048f, -0.48296827f, 0.38575462f, 
    0.04717905f, -0.25797942f, 0.16232322f, -0.14125267f, 0.13751125f, -0.14838175f, 0.29251865f, -0.25087863f, 
    0.14184381f, -0.03056098f, 0.37215355f, -0.19965406f, 0.08072474f, 0.16308402f, -0.28012544f, 0.35584792f, 
    -0.67291236f, -0.20294999f, -0.00516264f, 0.19147334f, -0.23314473f, 0.24972929f, -0.06741690f, -0.12574956f, 
    -0.09106990f, -0.05921060f, 0.11367051f, 0.21981169f, -0.06513385f, 0.04797065f, -0.71973699f, 0.30270085f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.06169493f, -0.11808746f, -0.00237798f, -0.03223827f, -0.15031040f, -0.10553197f, 0.00288961f, -0.03813948f, 
    0.15261264f, -0.03025398f, 0.13530582f, 0.07185004f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
