#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.72266322f, -0.10786367f, -0.78732133f, -0.39735514f, -0.65269768f, -0.82331109f, 0.18079834f, -0.26329938f, 
    0.11920668f, -0.31298995f, -0.99432153f, 0.66840625f, -0.01185340f, -0.56732273f, -0.54004937f, 0.15419665f, 
    0.11598445f, -0.30552164f, -0.23063621f, 0.37561551f, 0.28101540f, -0.50369841f, 0.53920639f, 0.77345210f, 
    -0.08481388f, 0.29784498f, 0.58605623f, -0.75445199f, -0.59432840f, 0.76668996f, 0.72904754f, 0.59068555f, 
    0.16487488f, -0.17991243f, -0.13454731f, 0.07188487f, -0.51699179f, -1.10703063f, -0.61377382f, -0.17325523f, 
    0.47376382f, 0.62021005f, -0.11328111f, -0.26532173f, -0.37553665f, -0.28787541f, -0.46246463f, -0.60451227f, 
    0.54617560f, 0.97385544f, -0.28462422f, 0.23840588f, 0.06968402f, -0.15814248f, 0.55313802f, -0.46261525f, 
    -0.72475874f, 0.27670652f, -0.47601601f, -0.54545712f, -0.05937126f, -0.20449837f, 0.39225793f, -0.61183149f, 
    -0.97370511f, -0.52843553f, -0.72302395f, 0.09955743f, 0.48025164f, 0.22444935f, 0.26279446f, 0.59590679f, 
    0.89020914f, 1.12612867f, 0.49900457f, -0.15921710f, -0.21247119f, 0.77968514f, -0.18160681f, -0.04800497f, 
    -0.25860667f, 0.09195147f, -0.48559502f, -0.57577133f, -0.17703976f, -0.89597481f, -0.52668786f, -0.47749537f, 
    0.48565271f, 0.37223974f, 0.65357190f, -0.03075502f, 0.28330866f, 0.64424759f, 0.72963220f, 0.20306112f, 
    -0.26342568f, -0.00312768f, -0.17432868f, 0.29625469f, 1.18538988f, -0.81054449f, 0.23889849f, -0.01427271f, 
    0.06287968f, 0.55567813f, -0.19613968f, 0.50992507f, 1.35503328f, 0.31768247f, -0.24654239f, -0.83938670f, 
    -0.48550633f, -0.10197128f, 0.06722966f, -0.06843825f, 0.14094907f, -0.11839538f, -0.37094903f, -0.18906690f, 
    0.49315268f, -0.88581139f, 0.18589097f, -0.56556547f, -0.46118626f, -0.45399705f, 0.59328020f, 0.89257300f, 
    -0.42966169f, 0.92714190f, -0.03513028f, -0.84022003f, -0.37327707f, -0.28303865f, -0.25142476f, -1.44911087f, 
    1.01656938f, -0.18744953f, 0.16050190f, 0.78426880f, -0.20707709f, -0.26604477f, 0.01281176f, -0.10476134f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.08721326f, 0.32621881f, 0.23819931f, 0.19293578f, 0.17039670f, 0.09760615f, 0.07817651f, 0.14316811f, 
    0.30418038f, 0.47808442f, 0.12863569f, 0.00062163f, 0.01012062f, -0.30333924f, 0.12942524f, 0.10315703f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.05751358f, 0.03350766f, -0.04611538f, 0.01162353f, -0.01648320f, -0.03014393f, 0.01841996f, 0.00527715f, 
    -0.04977934f, -0.01274628f, -0.03112583f, -0.04108145f, 0.03127552f, 0.01388991f, 0.01632231f, -0.04077465f, 
    -0.01092107f, 0.00777702f, -0.03411399f, 0.00392502f, -0.04998920f, 0.01076408f, -0.04361596f, 0.03262650f, 
    0.03143311f, -0.03518264f, -0.01707003f, 0.02430341f, 0.00002017f, -0.02841993f, -0.01630062f, -0.06302659f, 
    0.02421307f, -0.02456086f, 0.05107629f, -0.01203304f, -0.03321674f, 0.03802541f, 0.03372541f, 0.00648949f, 
    -0.05096369f, -0.02779610f, 0.02537122f, -0.03775065f, 0.00188591f, -0.03501150f, -0.04414763f, 0.00165216f, 
    0.03806135f, -0.04349525f, -0.04164641f, -0.02787631f, -0.01250274f, -0.03443995f, 0.01403588f, 0.02195553f, 
    -0.06578350f, 0.00995235f, -0.03816449f, -0.00770142f, 0.05009667f, -0.01846688f, 0.03843312f, 0.04425420f, 
    -0.05460887f, 0.01359873f, 0.03235791f, -0.04343533f, -0.03296785f, -0.04587473f, 0.00712280f, 0.00183679f, 
    -0.05805838f, -0.02730649f, 0.03297627f, 0.03910347f, -0.04603111f, 0.01280048f, -0.05743688f, 0.03457236f, 
    0.03055163f, -0.03853753f, 0.02503247f, 0.04895138f, 0.00283373f, 0.00576068f, -0.05766641f, 0.01664975f, 
    -0.04259991f, -0.03883183f, 0.01059006f, 0.04310181f, 0.00648260f, 0.00826789f, 0.03821938f, -0.00039547f, 
    0.02894282f, -0.02609058f, -0.01993181f, 0.03494537f, 0.02694730f, -0.06222481f, -0.03570113f, -0.00399981f, 
    0.04908934f, 0.04811556f, 0.03962781f, -0.02250043f, 0.00816514f, -0.05268761f, 0.02136240f, -0.04691739f, 
    -0.03014865f, -0.05349865f, -0.02257346f, -0.01093783f, 0.04150207f, -0.03779973f, 0.02342757f, -0.04072849f, 
    0.03084437f, -0.02619277f, -0.03265974f, -0.01804568f, 0.01131229f, -0.03836028f, -0.00116457f, 0.04364756f, 
    -0.01546405f, -0.06325769f, -0.06011094f, 0.02388344f, -0.05395516f, 0.03874273f, -0.05389269f, -0.05538953f, 
    -0.03994932f, 0.01778644f, -0.05351733f, -0.00478590f, 0.01209043f, -0.02435767f, -0.01955146f, 0.04149535f, 
    0.04617573f, -0.03189243f, -0.02013198f, -0.01976193f, -0.00638609f, 0.03793591f, -0.01335880f, 0.00252858f, 
    -0.05996842f, -0.00100161f, -0.03297515f, -0.01348204f, -0.03037707f, -0.01142150f, 0.00544475f, -0.04968920f, 
    -0.04464757f, 0.03090953f, 0.01688888f, 0.05101885f, -0.01179831f, -0.05813444f, -0.00334607f, -0.04537053f, 
    -0.02248303f, 0.02294483f, -0.03374887f, -0.04832035f, -0.00116982f, 0.04522964f, 0.00142695f, 0.02001953f, 
    0.04727325f, 0.02337430f, 0.01022325f, -0.00007785f, -0.05658433f, -0.06369397f, 0.01878052f, -0.00981517f, 
    0.04022944f, -0.04837197f, 0.04194454f, -0.06141833f, -0.01918556f, -0.02351362f, -0.06007636f, 0.01632965f, 
    -0.01386723f, 0.02244621f, -0.05391614f, -0.02277143f, 0.02808287f, 0.03742673f, 0.05184878f, 0.00747576f, 
    -0.01685086f, -0.01894740f, 0.02332990f, -0.00494659f, -0.01016294f, -0.03268799f, -0.02654474f, 0.00074989f, 
    0.01061566f, -0.00872250f, -0.03658692f, -0.00737025f, 0.04082356f, -0.00920824f, -0.00415609f, -0.06204440f, 
    -0.05984088f, -0.03662264f, -0.04147715f, -0.04293223f, 0.01034773f, 0.01131335f, -0.05305170f, 0.00390244f, 
    0.03961824f, -0.04324778f, -0.00671239f, 0.01168918f, -0.05499101f, 0.01590845f, 0.00474938f, -0.02340464f, 
    -0.05906348f, -0.01928923f, 0.00029231f, 0.04829830f, 0.04632650f, -0.03218244f, 0.04016045f, 0.00095150f, 
    0.03459327f, -0.03791356f, -0.02628109f, 0.01412731f, 0.03355377f, 0.01544634f, 0.02564283f, 0.05458364f, 
    0.02104538f, -0.05551562f, -0.00617882f, -0.04868949f, -0.02488844f, 0.05115819f, 0.04847543f, -0.00611359f, 
    -0.01577594f, -0.00807859f, -0.05382670f, -0.03742760f, 0.05738709f, 0.01481315f, -0.05415509f, -0.02126948f, 
    -0.03549203f, 0.04031358f, 0.01221236f, 0.00953373f, 0.02952185f, -0.02030309f, -0.00540411f, 0.01637465f, 
    0.01720184f, -0.00314177f, -0.03932247f, -0.01657855f, 0.01119457f, 0.02582993f, 0.05288371f, 0.03220984f, 
    0.03843962f, -0.01946445f, 0.02299448f, 0.00051880f, -0.00873674f, 0.03701394f, -0.01072741f, -0.03283294f, 
    0.00660411f, -0.05364516f, 0.05143382f, -0.03808534f, 0.00967052f, -0.02754631f, -0.01352563f, 0.03192310f, 
    -0.03151696f, -0.02068458f, 0.01794525f, 0.02929592f, 0.05560905f, -0.06299467f, -0.05710470f, -0.01861995f, 
    -0.01114431f, -0.02331961f, -0.03775861f, -0.04563247f, 0.01246579f, -0.00408621f, -0.03469566f, 0.03505918f, 
    0.03241044f, -0.03128669f, 0.01792834f, -0.03738954f, -0.01557460f, 0.03452340f, 0.00743816f, 0.01722681f, 
    0.26306140f, 0.17510056f, 0.13564387f, 0.29770258f, 0.18738599f, -0.07651415f, 0.14994439f, 0.01397151f, 
    0.07522444f, 0.04459621f, 0.03859705f, 0.04674211f, -0.07711654f, -0.21857208f, 0.21351822f, -0.05949478f, 
    0.01081931f, 0.21143982f, 0.06444047f, 0.11629730f, 0.26320750f, 0.07253294f, -0.05661127f, -0.04375209f, 
    0.04291721f, 0.22011231f, -0.02276909f, -0.11101869f, -0.15387958f, 0.14776975f, 0.13661060f, 0.18190758f, 
    -0.08940980f, -0.05529237f, -0.11052381f, 0.11487468f, 0.00101564f, 0.09759690f, 0.08436039f, -0.01272793f, 
    -0.18397500f, -0.35363728f, 0.00463200f, 0.01748812f, -0.00539530f, 0.00131975f, 0.01813475f, 0.14523123f, 
    -0.05474223f, 0.01976485f, 0.06930601f, -0.02837731f, 0.05318879f, 0.16706161f, 0.17581938f, -0.05371339f, 
    0.03759798f, -0.12175179f, -0.12342408f, -0.07879307f, -0.02823069f, 0.13867570f, -0.26355284f, -0.13559982f, 
    -0.10453921f, 0.18735383f, -0.11361558f, -0.00261806f, 0.16217463f, -0.03822965f, 0.05011625f, -0.00027084f, 
    0.03406420f, 0.15807699f, 0.04589770f, 0.01514492f, 0.17368166f, 0.01756604f, -0.01155253f, -0.06620380f, 
    -0.40265754f, -0.09261778f, -0.12973800f, 0.03672455f, 0.01821906f, 0.10679185f, 0.11193907f, 0.11149593f, 
    0.22747977f, 0.14491445f, -0.07553686f, 0.00959906f, 0.15890650f, 0.10519129f, -0.03303491f, 0.06029599f, 
    0.13708058f, 0.06379955f, 0.16481227f, 0.09291376f, -0.82513273f, 0.16006967f, 0.05530754f, 0.01684304f, 
    0.04926987f, 0.01965190f, 0.16028593f, 0.10614866f, 0.00856216f, -0.16174833f, -0.05955559f, 0.20652132f, 
    0.14129432f, 0.03916186f, 0.00419201f, -0.06501601f, 0.04000115f, 0.13476335f, 0.08963324f, 0.06811577f, 
    0.09760497f, 0.01423268f, 0.03612449f, 0.20649172f, 0.09833440f, 0.07526887f, 0.16006421f, 0.01866140f, 
    -0.02841715f, -0.07673857f, 0.00558531f, -0.17600338f, 0.02694197f, 0.03998184f, 0.12384433f, 0.22500257f, 
    0.01036664f, 0.27731338f, -0.09249108f, 0.13797891f, -0.27201092f, -0.03888128f, -0.22450452f, 0.00910363f, 
    0.08071747f, 0.19061068f, -0.07444542f, -0.05537248f, 0.11342825f, 0.09265268f, -0.05115024f, 0.09125704f, 
    -0.10382041f, 0.01385554f, -0.01791783f, -0.06629860f, 0.02668566f, -0.12488651f, -0.00173059f, -0.03927024f, 
    -0.08310329f, -0.46335670f, 0.32113019f, 0.17318963f, 0.09451016f, -0.37129629f, -0.15990993f, -0.00091507f, 
    -0.02910271f, 0.15671642f, 0.04246375f, 0.08168116f, 0.05087826f, -0.10239135f, 0.07996989f, 0.08744673f, 
    0.01869410f, 0.01893045f, -0.00465283f, 0.07751109f, 0.26787904f, -0.10304721f, -0.06101456f, 0.36904833f, 
    0.00818478f, 0.02461828f, 0.15149879f, 0.01098976f, -0.04996965f, 0.02665100f, -0.01573149f, -0.07046412f, 
    -0.13589610f, -0.03647851f, 0.02484407f, 0.06724793f, -0.01917392f, 0.09503358f, 0.01789632f, 0.06038325f, 
    -0.65875274f, 0.04659173f, -0.19438124f, 0.02832658f, -0.13997674f, 0.03575097f, -0.02199238f, -0.10532002f, 
    0.15809707f, -0.07728389f, -0.02979403f, 0.12136218f, 0.11173286f, 0.17202218f, 0.13382345f, 0.08553547f, 
    0.02117123f, 0.01506903f, -0.12274022f, 0.02113627f, -0.22756311f, -0.11084326f, -0.03377459f, -0.00501221f, 
    -0.19675252f, -0.13171481f, -0.01974487f, -0.01924808f, 0.10506451f, -0.10187360f, -0.08283877f, -0.00452115f, 
    0.08584886f, -0.03054838f, 0.05129129f, -0.04313800f, 0.00238832f, 0.03634581f, -0.10761002f, -0.00341251f, 
    0.11664431f, -0.44361827f, 0.38621777f, 0.47298583f, 0.18052863f, -0.22323647f, -0.03633136f, -0.19388315f, 
    -0.23301280f, 0.07615501f, 0.03232072f, 0.09346391f, 0.08410759f, -0.10485551f, 0.00349593f, 0.11766678f, 
    0.10276776f, 0.12111394f, 0.19221935f, 0.10021320f, 0.18289705f, -0.07242641f, -0.12885638f, 0.48047757f, 
    0.03899346f, 0.03413989f, 0.18919991f, 0.03907416f, 0.05262747f, 0.00939194f, -0.04351022f, -0.01327126f, 
    -0.00474304f, -0.13308552f, 0.10448077f, 0.17819226f, 0.01087493f, 0.06393819f, 0.01623334f, 0.24221964f, 
    0.09186076f, 0.54257774f, 0.16697474f, 0.15625760f, 0.11019971f, -0.06351216f, 0.05853381f, 0.09541094f, 
    0.22780451f, 0.01426713f, 0.10104532f, 0.06353905f, -0.06015930f, 0.19115250f, -0.02454285f, 0.06963900f, 
    0.08084365f, 0.08839154f, -0.10128025f, 0.06696648f, 0.61239761f, 0.04962048f, 0.32488167f, -0.10686202f, 
    -0.09309380f, 0.06139171f, 0.05245887f, 0.20421886f, 0.16710719f, 0.03274067f, -0.01405448f, 0.09473012f, 
    -0.06449658f, 0.06319908f, 0.02494597f, -0.07287028f, 0.09375976f, 0.01466050f, 0.07353236f, 0.10349523f, 
    0.02546290f, 0.00418549f, -0.04266297f, -0.04610665f, 0.01313091f, -0.03151384f, 0.04860193f, -0.03231307f, 
    -0.01836098f, 0.01220865f, -0.05126867f, -0.02714523f, 0.03303003f, -0.00033315f, -0.02214629f, -0.02033575f, 
    -0.03872263f, 0.01654716f, 0.04466931f, -0.05170098f, 0.01472676f, 0.04886762f, 0.03424168f, -0.02630522f, 
    -0.02796894f, 0.04267894f, -0.02881281f, 0.04308373f, -0.00351034f, -0.01601506f, -0.01092004f, -0.01773193f, 
    0.04233834f, 0.01849950f, -0.00071543f, -0.00496158f, 0.00140976f, -0.05845794f, -0.00777152f, -0.00975008f, 
    -0.00678615f, 0.04456358f, 0.03597465f, -0.04681972f, -0.03604694f, 0.02962988f, -0.01883078f, -0.01489933f, 
    0.04067552f, 0.00892151f, -0.04808327f, -0.00583526f, -0.01311029f, -0.04449369f, -0.02213476f, -0.01280296f, 
    -0.04952199f, 0.02744102f, -0.01329264f, -0.05563623f, -0.03746156f, -0.00593488f, -0.01662971f, -0.04057627f, 
    0.02908338f, 0.02375862f, -0.01075208f, 0.04866253f, -0.02869078f, 0.04337639f, -0.02890648f, 0.02103902f, 
    -0.01438506f, 0.01065151f, -0.04353569f, -0.00533009f, -0.02382529f, -0.03251176f, -0.02008702f, 0.00350633f, 
    -0.01208275f, 0.05007343f, -0.03152707f, 0.01673794f, -0.03432712f, -0.00183008f, 0.04567579f, 0.04408880f, 
    -0.00075071f, -0.03733016f, 0.04599432f, 0.03276619f, -0.00854414f, 0.04676817f, -0.04976406f, -0.00360668f, 
    -0.06185167f, 0.00854395f, -0.04378516f, -0.02426825f, -0.00037259f, 0.02351616f, 0.02239830f, -0.01656684f, 
    0.00444595f, -0.03260484f, 0.02372981f, -0.02041555f, -0.04948314f, 0.04501910f, -0.02568297f, -0.01532407f, 
    0.02586066f, -0.05362216f, 0.04708758f, -0.01607345f, 0.00980293f, -0.04516276f, -0.04513280f, 0.03475004f, 
    -0.01170914f, 0.02885714f, 0.03194145f, 0.03111319f, 0.02533025f, -0.05279851f, 0.00089370f, -0.02601383f, 
    0.01915851f, 0.01218594f, 0.02120804f, 0.03886603f, -0.01323533f, -0.01237186f, -0.01048683f, -0.03785392f, 
    0.01583411f, -0.06224179f, -0.02018567f, -0.05069080f, -0.02137304f, -0.04158119f, -0.02978235f, 0.01341494f, 
    0.00430361f, 0.04116989f, -0.01253765f, -0.00802223f, -0.00072841f, 0.01892246f, -0.00390556f, -0.03876932f, 
    0.02738241f, -0.00967187f, -0.02422520f, -0.00945330f, -0.06045130f, 0.01915503f, -0.00872167f, -0.04515187f, 
    -0.04309300f, -0.05550619f, 0.02408806f, -0.00652495f, -0.04903845f, -0.02089309f, 0.00879787f, -0.01764444f, 
    0.03615648f, -0.03382546f, -0.04037466f, -0.04733717f, 0.03641069f, 0.04745162f, 0.02016190f, -0.02629408f, 
    -0.01488890f, 0.00868167f, -0.04861373f, -0.04967008f, -0.05831353f, -0.00693580f, -0.00990482f, -0.03518016f, 
    -0.03778404f, 0.03092092f, 0.00925885f, -0.05867402f, -0.01031685f, -0.05489600f, 0.02475760f, -0.05556912f, 
    -0.06043903f, -0.04493865f, 0.04414343f, -0.01429231f, -0.02922011f, 0.01068015f, 0.00011311f, 0.01372467f, 
    -0.03533485f, 0.04137813f, -0.00208855f, -0.01969655f, 0.00533459f, 0.04474159f, 0.04233587f, 0.01723551f, 
    0.02459853f, -0.04786327f, 0.03918889f, 0.02750743f, 0.04824325f, -0.00426648f, -0.00403621f, 0.03802439f, 
    0.00388990f, -0.06022052f, 0.01010915f, -0.03522555f, 0.00919410f, -0.04729645f, -0.04795255f, -0.02196646f, 
    0.02106828f, -0.04458411f, -0.00869610f, -0.03189137f, 0.01459171f, 0.00152260f, -0.02724159f, -0.05748814f, 
    -0.04199773f, 0.02827580f, -0.01685709f, -0.00092296f, 0.00282086f, -0.01346941f, 0.01326508f, 0.04420681f, 
    0.01225217f, -0.04984462f, 0.02743915f, 0.01525787f, -0.05002239f, 0.02693602f, 0.02604669f, -0.03014506f, 
    0.02066476f, 0.03128470f, 0.02714969f, -0.04712730f, -0.02330773f, -0.04115301f, 0.01116826f, -0.02610071f, 
    -0.03827030f, 0.04496907f, -0.01066733f, 0.00492595f, -0.04204300f, 0.03879033f, -0.01357772f, -0.03602646f, 
    0.03947433f, 0.03183360f, 0.00718211f, 0.04439414f, -0.02093208f, 0.03294780f, -0.01748637f, 0.02169040f, 
    -0.05774640f, -0.03535644f, -0.05624771f, -0.05981869f, 0.02536072f, -0.05667377f, 0.03086777f, -0.06007553f, 
    -0.00871847f, -0.05563853f, 0.02206435f, -0.04066335f, 0.01954408f, -0.01559249f, 0.02637496f, 0.00922493f, 
    -0.04465931f, -0.03079779f, -0.00893242f, -0.02741330f, -0.01562172f, 0.02675956f, 0.01837072f, 0.02061023f, 
    0.02674839f, -0.05357492f, 0.03678023f, -0.01588367f, 0.04409343f, 0.00113470f, -0.05380136f, 0.01671688f, 
    -0.06124937f, 0.03882657f, -0.05334958f, 0.00257350f, -0.03957019f, 0.02459032f, 0.01681826f, -0.03903634f, 
    -0.06162801f, 0.04330966f, -0.02414587f, -0.00474757f, 0.04716359f, -0.01309083f, -0.00993089f, 0.01376985f, 
    0.22878450f, 0.35391304f, -0.08544194f, -0.05769442f, 0.01314850f, 0.25815555f, -0.05829298f, 0.13505889f, 
    -0.09163716f, 0.01522141f, 0.07824952f, 0.04021448f, 0.15846218f, 0.10802515f, 0.00771682f, -0.12616906f, 
    -0.06307174f, 0.06476948f, -0.10854972f, 0.00077512f, 0.09675849f, 0.11336933f, 0.40846869f, -0.14569654f, 
    -0.10689940f, -0.00561144f, -0.03443898f, 0.04081298f, 0.02390632f, 0.17041144f, 0.06775190f, -0.02987865f, 
    0.12476586f, 0.04543745f, -0.00581572f, -0.04741269f, 0.09077128f, 0.01371140f, -0.14020288f, -0.01515426f, 
    0.29366666f, 0.03287308f, 0.13842569f, 0.00675223f, -0.02305891f, -0.03806985f, -0.00629742f, -0.12967560f, 
    0.06069090f, -0.03672891f, 0.00506916f, 0.18726584f, -0.08249313f, 0.01978075f, 0.11439569f, 0.18742795f, 
    0.14322948f, -0.06031761f, 0.11760245f, 0.17192590f, 0.20120406f, 0.07046968f, -0.04006087f, -0.17254071f, 
    0.12535200f, 0.04183935f, -0.00205590f, 0.07746599f, 0.05002299f, -0.07405563f, 0.09880719f, 0.02204587f, 
    -0.00404043f, -0.05794169f, 0.08040578f, -0.06597664f, 0.04498532f, 0.01738747f, 0.05891359f, 0.05640805f, 
    0.27792245f, -0.30719110f, 0.30635008f, 0.28414330f, 0.25960693f, -0.06701607f, -0.04110350f, 0.10238949f, 
    0.01004967f, 0.06972952f, 0.06003442f, 0.08647300f, -0.01419944f, -0.02872659f, 0.10179625f, -0.14396748f, 
    0.08829666f, 0.11379983f, 0.05155965f, -0.13238776f, 0.20612900f, 0.15953979f, -0.03375908f, 0.12660111f, 
    0.12436371f, -0.11742052f, -0.06948549f, 0.06026363f, 0.06169509f, 0.07943089f, -0.08073372f, -0.11343908f, 
    -0.00316082f, -0.05076423f, 0.05792642f, -0.05473892f, 0.07177368f, -0.01889746f, 0.03930006f, 0.00106560f, 
    -0.00245717f, 0.31675503f, 0.07912645f, 0.20590770f, -0.18220681f, 0.09026019f, -0.01297418f, 0.11235556f, 
    0.00112867f, -0.01446293f, 0.00402784f, 0.08827499f, -0.07444947f, -0.09181867f, 0.10634641f, -0.12276981f, 
    -0.01439663f, -0.00226315f, -0.02036948f, 0.07964294f, 0.55572367f, -0.14812236f, 0.33440512f, 0.06377814f, 
    0.09558665f, 0.01468805f, 0.02951255f, -0.01090001f, -0.00033912f, 0.06833041f, -0.02219298f, 0.07061891f, 
    -0.03338893f, 0.02946138f, -0.00947993f, 0.06457178f, 0.07169636f, 0.18870182f, -0.06501709f, 0.04306540f, 
    -0.29215977f, -0.52118945f, -0.29890642f, -0.14551616f, -0.13150017f, 0.06266849f, 0.14932543f, -0.09413154f, 
    -0.11583503f, -0.04801665f, -0.13063005f, -0.01544099f, -0.03222618f, 0.04766931f, 0.01598310f, 0.02908592f, 
    0.03707712f, 0.07207398f, 0.01300985f, -0.05559321f, 0.12871052f, 0.24634564f, -0.02590760f, 0.10450774f, 
    0.02590114f, 0.10487314f, 0.05154381f, -0.03330812f, -0.03634724f, -0.00507130f, 0.06537180f, 0.05886561f, 
    0.08940833f, -0.00542420f, 0.01489527f, 0.16724312f, 0.07185505f, -0.12643948f, -0.01972045f, 0.02314589f, 
    -0.13802218f, 0.14525361f, -0.03324874f, -0.18772374f, -0.31209040f, -0.01164809f, 0.00304183f, -0.13722748f, 
    -0.09248215f, -0.08272284f, 0.04664757f, -0.06046484f, 0.17880984f, -0.13021824f, 0.05431103f, -0.06163415f, 
    0.04896121f, 0.05130137f, 0.04101968f, 0.01545626f, -0.18518768f, 0.15900907f, -0.30109146f, -0.11910914f, 
    -0.17101890f, 0.07986678f, -0.09858388f, 0.09831945f, -0.02657054f, -0.04085490f, 0.16384013f, 0.02658320f, 
    -0.01243777f, 0.03304386f, -0.02277492f, 0.01932727f, 0.07284485f, 0.06226125f, 0.22736079f, 0.12555411f, 
    -0.41763917f, -0.70006657f, 0.11719059f, -0.15609549f, -0.11978257f, -0.01659430f, 0.15831770f, 0.08815902f, 
    -0.05853816f, 0.00930185f, 0.06257851f, 0.05087816f, -0.08762772f, -0.02837589f, -0.05071219f, -0.05370314f, 
    -0.02963056f, 0.12366271f, 0.01540550f, -0.00494094f, -0.30100372f, 0.13285083f, 0.02531975f, 0.15915722f, 
    0.18350731f, 0.03678735f, 0.07784268f, -0.04683842f, -0.02046612f, -0.00043680f, -0.04718086f, -0.02357151f, 
    -0.07785813f, -0.04812929f, -0.08528011f, -0.05861075f, -0.02497384f, -0.01794661f, -0.12121116f, -0.22064228f, 
    -0.18283917f, -0.22509275f, 0.05926413f, 0.01289303f, -0.09638330f, 0.07674981f, -0.01812082f, -0.03591819f, 
    -0.14896192f, 0.13366407f, 0.14412145f, -0.06302077f, 0.09411162f, -0.00294298f, -0.00800996f, -0.06601875f, 
    -0.11700604f, -0.03324841f, 0.10322436f, -0.03147072f, -0.08071016f, 0.22560798f, -0.36617646f, -0.07750753f, 
    0.11543590f, 0.02899520f, -0.12190784f, -0.15420963f, 0.03158322f, 0.09568763f, 0.02797459f, 0.04082516f, 
    0.05872732f, -0.05899892f, 0.14816150f, 0.01553749f, 0.03093401f, -0.08363921f, -0.01354783f, -0.02612091f, 
    0.10863574f, 0.20922437f, 0.11957829f, 0.19932438f, 0.03988838f, -0.23334821f, 0.02224974f, 0.03852861f, 
    -0.07634075f, -0.02058348f, 0.00205655f, -0.03590051f, 0.03299924f, -0.04791861f, 0.07880097f, -0.14393693f, 
    0.09287773f, 0.07321146f, 0.04828503f, 0.09823887f, 0.08103158f, 0.11862405f, -0.14426315f, 0.02699601f, 
    0.58542997f, 0.11339123f, -0.03150216f, 0.02600778f, -0.06796711f, 0.00084036f, 0.07700551f, 0.01066144f, 
    0.10789298f, 0.03803987f, 0.19076836f, 0.13484767f, 0.16253547f, -0.01976655f, 0.08908959f, -0.10088278f, 
    0.08363434f, -0.08900805f, 0.01084077f, 0.04111358f, -0.16743053f, 0.09008953f, 0.02935618f, -0.01150208f, 
    0.03154765f, 0.22779755f, -0.01737635f, 0.01326269f, 0.00592280f, 0.02020256f, -0.05031540f, -0.04603856f, 
    0.02372342f, -0.05184357f, 0.05494281f, -0.06340316f, -0.15700215f, 0.03147469f, -0.25116724f, -0.05143688f, 
    0.01110266f, 0.16669710f, -0.08929987f, -0.06718315f, 0.02889024f, 0.01371509f, -0.01563719f, -0.07612093f, 
    0.03953252f, -0.04391384f, 0.02546755f, -0.05566958f, 0.00680959f, 0.01504484f, 0.08259801f, 0.01257458f, 
    -0.27473712f, 0.00058453f, -0.22337674f, -0.00010583f, 0.07317684f, 0.06434201f, 0.08153550f, 0.16128564f, 
    -0.04384509f, -0.03204165f, -0.12084816f, -0.11214276f, -0.06794914f, 0.02883653f, 0.06091657f, 0.06017674f, 
    0.02358027f, 0.03878766f, 0.09067523f, 0.07662226f, -0.46855110f, 0.03521184f, -0.04246229f, -0.01938530f, 
    -0.01598607f, 0.04226694f, 0.04474194f, 0.03413335f, -0.00920278f, 0.01217907f, -0.09700267f, 0.03090086f, 
    0.00338159f, -0.02605654f, -0.06446949f, -0.10845620f, 0.10712953f, -0.04212112f, 0.08843313f, 0.02593129f, 
    0.27077317f, 0.50655246f, -0.10274081f, 0.15038143f, 0.13851573f, 0.05398392f, -0.09536900f, -0.00692007f, 
    0.04946301f, 0.08609678f, 0.06299984f, -0.12704395f, -0.00427188f, 0.07121716f, 0.09385844f, 0.13125636f, 
    0.05919214f, 0.05912635f, 0.01913931f, -0.04450494f, -0.56497002f, -0.01806457f, -0.14932621f, -0.04428700f, 
    0.08657642f, -0.01325807f, -0.05400640f, -0.11513222f, -0.08600980f, -0.12575792f, -0.06263659f, 0.08981062f, 
    0.01510095f, -0.02942379f, 0.01806696f, -0.04375109f, 0.13005362f, 0.00179494f, -0.02862879f, -0.04163093f, 
    0.19855684f, -0.06197434f, -0.09405907f, 0.01855738f, -0.25493124f, 0.17977774f, 0.14977111f, 0.06670004f, 
    -0.03401573f, 0.09380793f, 0.09815727f, 0.13304409f, 0.09403856f, -0.02445702f, 0.13197502f, -0.02935061f, 
    -0.16213013f, 0.09869260f, 0.04333103f, 0.13548428f, 0.16985668f, 0.20216440f, -0.21913970f, 0.30790150f, 
    -0.03167472f, -0.06364102f, -0.14344092f, 0.09879831f, -0.05295623f, 0.20992507f, 0.00584174f, 0.09119434f, 
    0.01453903f, 0.07845506f, 0.06722993f, -0.04067653f, -0.03290456f, 0.03362633f, 0.11408491f, 0.13967381f, 
    -0.30088925f, -0.12043262f, -0.25834671f, -0.04936481f, -0.26301411f, 0.14046861f, 0.14591029f, -0.01581729f, 
    0.02962863f, 0.03574451f, 0.07646099f, 0.09336898f, -0.06968985f, 0.06614368f, 0.08772906f, 0.01937550f, 
    0.08120439f, 0.03533250f, 0.07299384f, -0.02268117f, -0.14921896f, -0.11178606f, 0.07181294f, 0.06326839f, 
    -0.23483784f, 0.02099725f, 0.05944242f, -0.06805640f, 0.06746697f, 0.10904184f, 0.01365040f, -0.09807505f, 
    -0.07177532f, -0.08283850f, -0.06016561f, -0.02290520f, 0.22088638f, -0.08634357f, 0.15146546f, 0.11984791f, 
    -0.02210817f, 0.26922283f, -0.13839464f, 0.07246513f, 0.25115952f, -0.06028890f, 0.02629799f, 0.08243324f, 
    -0.11992161f, 0.11690564f, -0.03111957f, -0.07859089f, -0.03214314f, -0.01158135f, 0.22536910f, -0.00181171f, 
    0.03927339f, 0.09849425f, -0.07572926f, 0.10145890f, 0.40375319f, 0.08498822f, 0.04240267f, 0.03974183f, 
    0.04466493f, 0.05040618f, -0.02801498f, 0.00035635f, 0.00594737f, 0.10748993f, 0.01873096f, -0.03839240f, 
    0.07244916f, 0.00815584f, 0.01120463f, -0.02706254f, 0.01843266f, 0.12515080f, -0.01162856f, 0.03883965f, 
    -0.01639230f, 0.53816462f, -0.03561526f, 0.01397185f, -0.12020406f, 0.21577291f, 0.11440985f, 0.04649939f, 
    0.07923608f, -0.00277939f, 0.02628448f, 0.03050054f, -0.03253857f, 0.09014473f, 0.02579940f, 0.00704138f, 
    0.06785242f, -0.00481310f, -0.00427397f, 0.14804760f, -0.17721702f, -0.17961814f, 0.22267053f, 0.10956155f, 
    -0.18275030f, -0.06238871f, -0.05069134f, 0.03141857f, 0.09371732f, -0.09681379f, -0.03476495f, 0.00538352f, 
    0.10104237f, 0.12764631f, 0.04970480f, 0.00662451f, 0.06943614f, -0.10131893f, 0.04391318f, 0.15515473f, 
    -0.05863814f, -0.04694031f, 0.04365621f, -0.02799369f, -0.03128199f, 0.02692366f, 0.04029334f, 0.02045632f, 
    -0.03319139f, -0.01663580f, 0.00100125f, -0.04077283f, 0.01295882f, 0.03348132f, -0.01437184f, 0.04148983f, 
    0.05111735f, -0.02436713f, -0.01893873f, 0.00601678f, 0.00153159f, -0.00394278f, 0.00697354f, -0.01703110f, 
    -0.00286235f, -0.05901676f, -0.02093475f, 0.02852005f, 0.01316779f, -0.01136971f, -0.00136816f, 0.03643497f, 
    -0.03251127f, 0.03683100f, 0.03740555f, 0.01288693f, -0.03545390f, -0.01164925f, -0.02721620f, -0.02011967f, 
    0.00811160f, 0.00246801f, 0.00487939f, -0.00028616f, -0.04297347f, -0.01201861f, -0.02843364f, -0.00448953f, 
    -0.04904925f, -0.05860035f, 0.03050248f, -0.05167380f, 0.00018560f, -0.01484471f, 0.01575441f, -0.02948727f, 
    -0.05261737f, -0.06141315f, -0.01080373f, 0.01052521f, -0.00474433f, -0.04136952f, -0.01697064f, -0.05540859f, 
    0.04924231f, -0.02504827f, -0.05013967f, -0.03434283f, -0.03607826f, -0.00748056f, 0.03021455f, -0.03491983f, 
    0.02556803f, 0.01147474f, -0.04553154f, -0.02928362f, -0.04794492f, -0.03359943f, -0.04146663f, 0.00675109f, 
    -0.02607579f, -0.05880191f, 0.03764706f, 0.02720336f, 0.01358948f, -0.01988198f, 0.02869076f, 0.02038612f, 
    -0.04041903f, 0.00834366f, 0.03602267f, 0.04784774f, -0.02836496f, -0.05331310f, 0.02808102f, -0.04859320f, 
    0.03751349f, -0.04900964f, 0.01370905f, 0.04242092f, 0.03899546f, -0.01667115f, 0.03583929f, -0.00459738f, 
    0.02275564f, -0.01668994f, 0.02427882f, -0.03682611f, -0.04174254f, -0.04408560f, -0.01621921f, -0.01111978f, 
    -0.00422706f, 0.01957800f, 0.02269409f, -0.03044424f, -0.02742527f, 0.02447487f, -0.00966964f, 0.01985716f, 
    -0.03519004f, -0.02531683f, 0.01241573f, -0.03847458f, 0.04105465f, -0.01655455f, -0.05515574f, 0.02453471f, 
    0.00730417f, 0.02263100f, -0.00185386f, 0.00055935f, -0.02872848f, 0.00134501f, 0.04897106f, -0.03112296f, 
    0.04537058f, 0.01985126f, -0.04695520f, -0.05751058f, -0.01103214f, 0.03265764f, 0.01902238f, 0.03467893f, 
    -0.00564408f, 0.02516133f, -0.03693008f, 0.00773077f, -0.04197991f, 0.02297342f, -0.05189123f, -0.04145694f, 
    -0.00448301f, 0.00425646f, 0.01721974f, 0.04809092f, 0.02141366f, 0.03046412f, 0.02935456f, -0.04781106f, 
    0.03627091f, -0.03814233f, -0.04131204f, 0.01491825f, -0.05122604f, 0.00474995f, -0.03794681f, -0.01227760f, 
    -0.05467685f, 0.04565169f, -0.03581494f, 0.01608546f, -0.04173109f, 0.02854278f, 0.00734960f, -0.02270564f, 
    0.00491532f, 0.03125043f, 0.01847220f, -0.00935558f, -0.01421766f, -0.05404754f, -0.05223224f, 0.00657709f, 
    0.04622927f, -0.00170777f, -0.05896500f, -0.03535556f, 0.01485822f, 0.01202972f, 0.04725904f, 0.03215286f, 
    0.03881615f, -0.04408857f, -0.01963224f, -0.04090706f, 0.00624590f, 0.02728403f, -0.00852479f, 0.00241413f, 
    0.03942563f, 0.01104724f, 0.02292451f, 0.04784932f, -0.04337317f, -0.05813286f, 0.01176116f, -0.02976179f, 
    0.04552427f, -0.00944893f, 0.01149368f, 0.01865980f, -0.04298757f, -0.01846814f, -0.01100042f, -0.03890125f, 
    0.04264053f, 0.03030643f, -0.05483701f, -0.03075195f, 0.02546727f, -0.02120512f, 0.04821702f, -0.03837170f, 
    -0.05751238f, 0.03285457f, 0.04635541f, -0.04812148f, -0.06113439f, 0.00632170f, -0.05250437f, 0.01954132f, 
    0.00425402f, -0.02104376f, -0.04093589f, -0.00600326f, -0.04213950f, -0.03878369f, -0.00757600f, 0.01653630f, 
    0.04045220f, 0.03869711f, -0.00051135f, 0.00068365f, 0.00603587f, 0.02754742f, -0.04337338f, 0.03451993f, 
    0.04155986f, 0.02790305f, -0.03914786f, 0.01633929f, -0.01732861f, -0.05449319f, 0.00130262f, -0.05970631f, 
    0.01253206f, 0.00748903f, 0.03551785f, 0.00208739f, -0.01723495f, -0.00964735f, 0.02718784f, 0.00835804f, 
    0.01234210f, -0.03172392f, 0.01507863f, -0.00494737f, -0.00629233f, -0.02650765f, 0.01894059f, -0.01971859f, 
    -0.03314883f, -0.02539541f, -0.05058236f, -0.02818945f, -0.04291117f, -0.04227152f, -0.03035568f, -0.00187919f, 
    -0.04774893f, -0.03163755f, -0.01710369f, 0.04643839f, 0.03022861f, 0.04262687f, 0.02054115f, 0.03842982f, 
    0.01393698f, 0.00369593f, -0.05111109f, -0.02436122f, 0.04539988f, -0.05389747f, -0.05584873f, 0.04023947f, 
    -0.00481230f, 0.00483669f, -0.01526842f, 0.03121683f, -0.02749690f, -0.03080247f, -0.04887655f, -0.04583369f, 
    -0.04383313f, -0.03596425f, 0.00177406f, -0.05029875f, -0.05730334f, -0.04847587f, -0.00154653f, -0.06065474f, 
    -0.05908386f, 0.04279749f, -0.05585148f, -0.00246779f, -0.05282247f, 0.01120908f, 0.03168528f, -0.02663795f, 
    0.30902192f, 0.38703641f, -0.05647135f, -0.11899059f, 0.05948674f, 0.07726930f, 0.01498071f, 0.00785757f, 
    -0.12493441f, 0.20332347f, 0.04196206f, -0.08160266f, 0.10267029f, -0.02197415f, 0.01744870f, -0.03316895f, 
    0.01745661f, -0.13450246f, -0.06632447f, 0.08443334f, -0.26538694f, 0.33344895f, 0.06410734f, 0.07652079f, 
    0.45566773f, 0.04575814f, 0.07413044f, 0.03559170f, 0.10701734f, 0.05764014f, -0.02795513f, -0.15029873f, 
    0.10484763f, 0.10397375f, 0.20913570f, 0.05348997f, 0.07176534f, -0.09523480f, -0.00891724f, -0.11226787f, 
    0.08972875f, 0.19466752f, 0.22509241f, 0.03160617f, -0.05576232f, -0.03018351f, 0.05132214f, -0.00577133f, 
    0.01734635f, 0.13386290f, -0.08461385f, 0.11017273f, -0.11093324f, -0.04906684f, -0.11122920f, -0.09002627f, 
    0.15505321f, 0.09962512f, -0.03051427f, 0.07228240f, -0.23208193f, 0.12106824f, -0.20882072f, 0.05770752f, 
    0.24748670f, -0.06967701f, 0.04823399f, -0.01865461f, 0.02873783f, -0.05485916f, 0.00270416f, -0.01067446f, 
    0.03451959f, -0.03740989f, -0.05541290f, -0.11271705f, -0.07453749f, 0.12026849f, 0.02885090f, 0.10297504f, 
    0.09691054f, 0.00736644f, 0.37936494f, 0.14841528f, 0.38711488f, 0.07570656f, -0.06031395f, 0.09892315f, 
    -0.03644545f, -0.02013147f, 0.08008949f, 0.07520618f, 0.01224765f, -0.00100181f, 0.00007489f, -0.05821390f, 
    0.05210649f, -0.01345918f, 0.00296172f, -0.05283942f, 0.02538733f, -0.03193760f, -0.01741487f, 0.04357650f, 
    0.04709945f, -0.16699556f, -0.08511164f, 0.09450611f, -0.02837946f, -0.08238493f, -0.06495254f, -0.13990881f, 
    -0.07234704f, -0.01570647f, -0.02403745f, -0.08730141f, 0.10041432f, -0.12582031f, 0.05034249f, -0.00862937f, 
    0.44545394f, 0.40647858f, -0.19387217f, 0.12409774f, 0.16375694f, -0.00949393f, -0.10987442f, -0.07043602f, 
    0.09387115f, -0.01838493f, 0.11928301f, 0.01421853f, -0.08429372f, -0.09048058f, -0.00026132f, -0.15352222f, 
    0.00420837f, -0.05863549f, 0.02525393f, -0.05640472f, -0.11559550f, 0.02602039f, 0.28971970f, -0.06681356f, 
    0.15437788f, 0.01716158f, 0.05027732f, 0.04511971f, -0.03482740f, 0.04769911f, -0.02744676f, 0.03737812f, 
    0.06428233f, -0.02676211f, -0.12475163f, -0.04311778f, 0.03448681f, 0.10433438f, -0.03517833f, -0.05596848f, 
    0.17332271f, -0.08087222f, -0.15578671f, 0.17501801f, -0.21839350f, 0.12842387f, 0.12467561f, 0.04824283f, 
    -0.01011738f, 0.05710674f, 0.18840149f, -0.03582315f, 0.04930920f, 0.09644088f, -0.05773304f, 0.05941450f, 
    -0.03658747f, 0.07603265f, -0.01464394f, 0.03663334f, 0.32458961f, 0.15744878f, -0.12808320f, 0.05908249f, 
    0.10358791f, 0.06007969f, 0.00187554f, 0.02142385f, 0.06443964f, -0.02435332f, 0.06678742f, 0.07763932f, 
    0.12292919f, -0.00399196f, 0.08471631f, 0.02946962f, -0.00692270f, -0.09133680f, 0.00780722f, 0.02089386f, 
    -0.00223189f, -0.17786284f, -0.03593919f, 0.06241637f, -0.10737550f, -0.01572003f, 0.01004976f, 0.03271468f, 
    0.10178764f, -0.03577329f, 0.06323243f, -0.05215772f, -0.09656214f, 0.07945066f, -0.01598590f, -0.10174485f, 
    -0.01308587f, 0.04268797f, 0.04328782f, -0.12161086f, -0.16312949f, 0.02614059f, -0.13145436f, 0.34682304f, 
    -0.23984534f, 0.05578001f, 0.02985879f, -0.08238004f, -0.04541547f, 0.14029798f, -0.01692161f, -0.03878628f, 
    -0.13694827f, -0.10222264f, -0.11010589f, -0.09011875f, 0.12594959f, -0.21608441f, 0.29133904f, 0.18603580f, 
    0.20440336f, -0.02140711f, -0.18945332f, 0.02322805f, 0.24830066f, 0.05825851f, 0.09835712f, 0.05464133f, 
    -0.04092874f, -0.00154776f, 0.01124240f, 0.07654396f, -0.11324411f, 0.08815864f, 0.05054246f, 0.06959011f, 
    0.04728821f, -0.03612171f, -0.18365934f, -0.03428023f, 0.01554690f, 0.09850892f, -0.00217426f, -0.01877401f, 
    0.34305942f, 0.06261145f, 0.02479281f, 0.08222229f, -0.02205406f, -0.05526989f, 0.08335971f, 0.16040990f, 
    0.07981692f, -0.07902760f, -0.07522710f, -0.23596391f, 0.00321464f, -0.03171647f, -0.05235947f, -0.01113330f, 
    0.00328852f, 0.03694196f, -0.10125485f, 0.03844360f, -0.29954013f, 0.14173578f, 0.02662790f, 0.03024411f, 
    0.00652412f, 0.05605127f, 0.01516198f, -0.02611974f, 0.10300030f, -0.01605443f, 0.01729965f, -0.10017744f, 
    -0.06879276f, -0.04081462f, 0.11589467f, -0.05202823f, -0.77648509f, 0.06922388f, -0.11622623f, 0.05560376f, 
    -0.19245349f, 0.00335606f, -0.01419256f, 0.00409543f, -0.02337754f, 0.02601983f, -0.00906312f, 0.06294895f, 
    0.12683249f, 0.09325038f, -0.06022648f, 0.04614038f, -0.00185535f, -0.04422374f, -0.06356072f, 0.07374314f, 
    -0.04631195f, 0.05062345f, 0.03671867f, 0.04425358f, -0.03698925f, -0.05060400f, 0.03922147f, -0.05170957f, 
    0.01672471f, -0.03362357f, -0.04578819f, -0.04914903f, 0.02010497f, -0.01527911f, 0.04858689f, -0.03975312f, 
    -0.02311481f, 0.03875906f, -0.02125065f, -0.00203722f, -0.00375469f, -0.00339632f, -0.01413034f, 0.01442760f, 
    0.03667334f, -0.02583029f, -0.05664263f, -0.02745711f, -0.03784448f, -0.01686424f, 0.01038863f, -0.04341554f, 
    -0.00386926f, 0.01669517f, -0.00361621f, -0.01791476f, -0.01936447f, -0.04229259f, -0.05975270f, -0.04578729f, 
    0.01881924f, -0.05783684f, 0.01934502f, 0.00472438f, 0.03762729f, 0.04454417f, 0.05308129f, 0.00916168f, 
    -0.01404405f, -0.00992136f, 0.05202644f, 0.03217040f, 0.01011607f, -0.02658317f, -0.01338337f, -0.02176278f, 
    0.04872606f, -0.02722795f, -0.05885049f, -0.01386633f, 0.04396962f, -0.04268491f, -0.05370021f, 0.02037654f, 
    -0.05676549f, 0.00790710f, -0.01269899f, 0.01918797f, -0.00564155f, 0.00458603f, -0.01667650f, -0.01538589f, 
    -0.04930757f, -0.02020380f, 0.02923413f, 0.00623873f, 0.03215170f, 0.02109207f, 0.04617234f, -0.00044021f, 
    -0.00174828f, -0.00396102f, -0.03672041f, -0.04012372f, -0.02503670f, 0.05293169f, 0.04310947f, -0.04675329f, 
    -0.00971330f, -0.04306318f, 0.02446770f, 0.01281790f, -0.03296081f, 0.01434856f, 0.01214941f, -0.03418640f, 
    0.04732621f, 0.03278718f, 0.02090178f, -0.04306998f, 0.03194636f, 0.03756160f, -0.01336664f, -0.05050004f, 
    0.01611328f, 0.02758290f, 0.04472748f, -0.04108825f, -0.02588768f, 0.02558703f, 0.00173983f, -0.04841043f, 
    0.05372082f, 0.03963896f, -0.00483906f, 0.04724813f, 0.01659069f, -0.04120661f, -0.03475843f, -0.05620122f, 
    -0.04880202f, 0.02391931f, 0.00865061f, -0.04938348f, -0.00525741f, -0.00138819f, -0.02012070f, -0.01896260f, 
    0.01683757f, -0.01546632f, 0.01195444f, -0.04697311f, 0.03041252f, 0.02258089f, 0.01452617f, -0.04067024f, 
    -0.02879575f, 0.02489234f, -0.00833196f, -0.04869066f, -0.00383460f, -0.02736242f, 0.05238086f, -0.01640996f, 
    -0.01780774f, -0.05183307f, -0.00483252f, -0.05223007f, -0.00820242f, -0.03305486f, -0.01651876f, -0.05500669f, 
    -0.04834896f, -0.03964242f, 0.01707387f, -0.00514742f, -0.03907908f, -0.04982357f, 0.02420697f, -0.00178096f, 
    -0.04468736f, 0.00373058f, -0.04088711f, 0.02392266f, 0.01127327f, -0.05078118f, -0.02995070f, -0.05199919f, 
    0.04034908f, -0.03507723f, -0.02022048f, 0.02667574f, -0.01110465f, 0.02644739f, -0.05378139f, 0.00854388f, 
    -0.00978179f, 0.00099513f, 0.03909535f, -0.00648696f, 0.05251395f, -0.03017628f, -0.04690518f, 0.03605856f, 
    0.00812544f, 0.03367519f, 0.04113367f, -0.05194886f, -0.05845844f, -0.01266192f, -0.04324720f, -0.01819789f, 
    -0.01681947f, -0.02901948f, -0.03700394f, 0.04812660f, 0.02953573f, -0.01827577f, -0.05444910f, -0.04452799f, 
    -0.04763132f, -0.05030973f, 0.00853622f, 0.02635390f, -0.05176134f, -0.02010424f, -0.01085955f, -0.02888572f, 
    -0.01274985f, -0.05919933f, 0.00865593f, -0.01196630f, 0.04417346f, -0.04856531f, 0.02777461f, -0.01413644f, 
    0.00584347f, 0.01330517f, 0.02884895f, -0.04757183f, 0.01706361f, 0.03328457f, -0.00535922f, -0.01783769f, 
    0.00403206f, -0.04656193f, 0.01885237f, -0.01222711f, -0.05016834f, 0.03630114f, -0.00876689f, -0.03252560f, 
    0.03321626f, -0.03584146f, -0.02153930f, -0.00634770f, 0.05340933f, -0.00865282f, -0.00712776f, 0.03215433f, 
    0.03226875f, -0.05980083f, -0.05811617f, 0.01012277f, -0.00352196f, 0.03827240f, 0.01829400f, -0.05044218f, 
    0.02167875f, 0.04165414f, -0.04029001f, 0.01394423f, -0.02270684f, -0.00922372f, 0.04810347f, 0.01113160f, 
    0.04716500f, 0.01899889f, -0.01042602f, 0.05385428f, -0.03793512f, 0.02026266f, -0.03400246f, -0.04357559f, 
    -0.05443871f, -0.04034974f, -0.00695521f, -0.04481178f, -0.03152635f, 0.01579368f, 0.01121075f, 0.04446201f, 
    -0.05830432f, -0.04745086f, 0.03402216f, -0.00704628f, -0.01912615f, 0.04320214f, -0.00584806f, -0.01599579f, 
    -0.04181364f, -0.05554850f, 0.02540422f, -0.05035048f, -0.04714151f, 0.01099264f, -0.01324945f, 0.02611129f, 
    -0.03295026f, -0.05996072f, 0.04623136f, -0.05468670f, -0.04206390f, 0.01228152f, -0.03891077f, 0.01426890f, 
    0.04605670f, -0.04114595f, 0.04274355f, -0.00723161f, -0.02213112f, 0.00345015f, -0.02307096f, -0.00340180f, 
    0.02075096f, -0.04441819f, 0.00975463f, 0.01416548f, 0.02703121f, 0.02857260f, -0.02532446f, -0.01531493f, 
    0.02000836f, 0.04471568f, -0.02267439f, -0.04771727f, 0.03334094f, 0.01830949f, -0.00479319f, -0.01826764f, 
    0.43747753f, -0.15903434f, -0.03893135f, 0.20307101f, 0.04473687f, -0.11544671f, 0.02394655f, 0.21964073f, 
    0.04547218f, 0.08427350f, 0.02004775f, -0.11940043f, -0.00119603f, 0.20133165f, -0.02887072f, 0.06170578f, 
    0.13513853f, -0.26645723f, -0.16789967f, -0.06161093f, 0.01105651f, 0.29166108f, -0.15648632f, 0.21904132f, 
    -0.10213003f, 0.03783697f, -0.03526959f, 0.17044187f, 0.26754531f, 0.02303929f, 0.07569733f, 0.03424590f, 
    0.25779530f, 0.07810066f, 0.26139745f, 0.13963236f, 0.31758901f, -0.07930384f, 0.02346082f, 0.12230014f, 
    -0.20094688f, 0.37546116f, -0.29293150f, -0.19453968f, 0.14984760f, 0.18178421f, 0.14688572f, -0.01177762f, 
    0.28191653f, 0.06722489f, 0.06420015f, 0.07668873f, 0.09254371f, -0.17110735f, -0.04230144f, -0.01419840f, 
    0.12789266f, 0.14404459f, 0.16988647f, 0.27095813f, -0.15566067f, 0.10607030f, -0.18095991f, 0.07589927f, 
    -0.13467593f, 0.06515215f, 0.20327048f, -0.03887208f, 0.13679236f, 0.17363308f, 0.05247805f, 0.11499538f, 
    0.09194168f, 0.04208194f, 0.03084372f, -0.12343781f, 0.08678940f, 0.19521439f, 0.01985496f, 0.06225218f, 
    0.35685417f, 0.05936869f, -0.54581118f, -0.14391196f, -0.26982611f, 0.06227663f, 0.00603173f, 0.02065000f, 
    -0.03481464f, -0.19054571f, 0.03264971f, 0.02249695f, -0.19667514f, 0.04412292f, -0.03534709f, 0.03389418f, 
    -0.02209526f, -0.06043612f, -0.18429893f, 0.04751720f, 0.45539576f, -0.28094888f, -0.47310287f, -0.14637662f, 
    -0.42366177f, 0.22060095f, -0.13841233f, 0.08953864f, 0.21494944f, 0.01212664f, 0.09257046f, -0.01905368f, 
    -0.02865580f, -0.08598136f, 0.04809842f, 0.09837363f, 0.04989987f, -0.18661007f, -0.16000666f, 0.06061529f, 
    0.06763119f, -0.47032613f, -0.03815305f, -0.03220823f, 0.21372469f, 0.11706894f, -0.09096355f, 0.11168952f, 
    0.13081688f, 0.16870348f, 0.18520178f, 0.10747332f, -0.02648898f, 0.15856534f, 0.02445029f, -0.07188552f, 
    0.02202248f, -0.27371395f, 0.14532866f, 0.09432103f, -0.25750309f, 0.15828446f, -0.50799710f, -0.12784758f, 
    -0.18603492f, 0.05109993f, 0.08964816f, 0.20467505f, 0.15058890f, 0.00121883f, -0.06169403f, 0.17670198f, 
    -0.03723998f, -0.08091163f, 0.03811761f, 0.11256488f, 0.10689624f, 0.06109347f, 0.00934957f, 0.21088691f, 
    -0.13140167f, 0.26678658f, 0.08570568f, 0.08552481f, -0.08363463f, 0.27834031f, 0.05105136f, -0.10829477f, 
    -0.02232851f, -0.00591447f, 0.15309855f, 0.05148228f, -0.01529903f, 0.18212745f, 0.21969642f, 0.09302393f, 
    0.03457947f, 0.23061997f, 0.06522709f, 0.07500554f, 0.11301625f, -0.09310936f, 0.03175209f, -0.01234746f, 
    0.24968687f, 0.06477482f, -0.04161126f, 0.18854974f, 0.09050070f, 0.22126868f, 0.02114158f, 0.01752334f, 
    0.18099993f, 0.16765140f, 0.02725434f, -0.04699867f, 0.09707312f, 0.02487260f, 0.06306072f, 0.08300336f, 
    0.24187554f, -0.25341779f, -0.03905935f, -0.08944965f, -0.17339407f, 0.07040583f, 0.22340101f, 0.14651594f, 
    0.04655473f, 0.17902419f, 0.12584358f, -0.02276466f, 0.12593912f, 0.02695266f, 0.02578004f, -0.15196308f, 
    0.22018962f, 0.17356323f, 0.15789375f, 0.06837496f, 0.00399967f, -0.67295766f, 0.10420954f, 0.05796251f, 
    0.29262280f, -0.17810220f, 0.06289803f, 0.18765163f, -0.05004784f, 0.08002876f, 0.22464955f, 0.05162305f, 
    0.00666610f, -0.08077881f, 0.18554281f, 0.12896496f, 0.18087406f, 0.08407629f, 0.05807395f, 0.19577415f, 
    -0.28219399f, -0.09620178f, 0.35879719f, 0.26364836f, -0.09676085f, 0.10160891f, 0.01333626f, 0.22767828f, 
    0.09249325f, -0.02412578f, 0.07500466f, -0.12884018f, 0.11463077f, 0.20722389f, 0.21325861f, 0.07459932f, 
    0.04846869f, -0.01991265f, -0.28973344f, -0.05925987f, -0.14625148f, -0.24619368f, 0.18890058f, -0.23254968f, 
    -0.14662246f, 0.10633450f, -0.18185383f, 0.14338735f, -0.02937544f, 0.16461132f, 0.15727934f, 0.13804339f, 
    -0.07522030f, -0.11386234f, 0.03139821f, 0.06277382f, -0.07430789f, 0.08916906f, 0.08673934f, 0.10508162f, 
    -0.37617305f, -0.52456683f, 0.17467299f, -0.19395299f, -0.04655129f, 0.12224997f, 0.08440144f, 0.12479982f, 
    -0.02662256f, -0.06823235f, 0.01503689f, 0.10675272f, 0.06227969f, -0.03805520f, 0.11538590f, 0.16621397f, 
    -0.05759040f, 0.01852542f, 0.10361064f, 0.08289678f, -0.45259112f, -0.22367220f, -0.06184444f, 0.12424129f, 
    0.00985129f, -0.09460574f, 0.17306240f, -0.04641260f, 0.05077452f, -0.02774855f, 0.04794635f, 0.05895569f, 
    0.16039036f, -0.09710361f, 0.26242629f, -0.03658429f, -0.02865427f, 0.22313762f, -0.04335170f, -0.01803806f, 
    -0.04902310f, 0.03371874f, -0.04626126f, 0.04915947f, -0.02072993f, 0.03264109f, 0.01242924f, 0.05066766f, 
    0.02328719f, -0.01525345f, -0.05778745f, -0.00957328f, 0.04880476f, -0.03616226f, -0.02926895f, 0.00606159f, 
    -0.03589277f, -0.00726299f, -0.01627188f, 0.04811754f, -0.02004065f, -0.03164729f, -0.01007791f, 0.00171496f, 
    0.00529748f, -0.00456544f, -0.05721147f, 0.00257817f, 0.03262166f, -0.02564650f, 0.00768568f, 0.00658136f, 
    0.02601175f, 0.02701300f, 0.00400645f, 0.02833512f, -0.01217951f, -0.05659619f, 0.01289837f, -0.01640685f, 
    -0.04152306f, -0.00539242f, -0.00313084f, 0.03375832f, 0.04693439f, 0.01038852f, -0.05211371f, -0.02922972f, 
    0.01765262f, -0.04905989f, -0.04471456f, -0.01175988f, -0.01895245f, -0.04611727f, -0.04310203f, 0.02234227f, 
    -0.01408266f, -0.00897415f, -0.06156145f, -0.03389351f, -0.05388573f, 0.02136541f, 0.03339452f, -0.01971760f, 
    -0.00984414f, -0.01277977f, -0.01330587f, 0.04844578f, 0.05024771f, 0.04070214f, -0.00581157f, -0.03519101f, 
    -0.03426139f, 0.01865095f, -0.02249672f, -0.02648646f, 0.01500987f, -0.03718347f, -0.04343761f, 0.00171185f, 
    -0.01633386f, 0.03342504f, 0.01820897f, -0.00557023f, 0.02100403f, -0.03327715f, -0.02711255f, -0.01342253f, 
    0.02468197f, -0.00298173f, -0.00756561f, -0.02419828f, -0.03919614f, 0.04794042f, -0.00266913f, -0.06277855f, 
    -0.02957530f, -0.06321398f, 0.00754773f, -0.01084856f, 0.00163918f, 0.00685092f, 0.04216073f, -0.05353932f, 
    -0.01166581f, -0.00113507f, 0.03532344f, -0.03184292f, 0.02641621f, -0.03394119f, 0.00845505f, -0.03047180f, 
    -0.01288612f, -0.04630096f, 0.01023206f, 0.03510376f, -0.05652246f, 0.02831638f, 0.01266173f, 0.00175393f, 
    -0.02723759f, 0.00047947f, -0.04007836f, -0.05128933f, -0.01928482f, 0.04216992f, -0.02119294f, -0.00577537f, 
    0.04891163f, 0.01343020f, 0.04149236f, 0.05038673f, -0.00779789f, -0.01081234f, -0.00647861f, 0.01796629f, 
    0.04699133f, 0.00182666f, -0.00311375f, -0.02977466f, 0.02071221f, -0.05283233f, -0.01651713f, 0.03031861f, 
    -0.00286452f, 0.03840380f, -0.03252483f, 0.02177257f, -0.05535268f, -0.00158812f, -0.04863739f, 0.03900101f, 
    0.03157528f, 0.00345498f, 0.02167425f, 0.03384832f, 0.03275779f, -0.02413799f, -0.01590583f, 0.01749838f, 
    0.01806450f, -0.02290132f, 0.00037984f, 0.01036373f, -0.03424922f, 0.00700843f, -0.01637292f, -0.04119064f, 
    -0.00000821f, 0.02148637f, -0.01376031f, 0.01268963f, -0.04089739f, 0.00843474f, -0.02863628f, 0.00267555f, 
    0.00973814f, 0.02785377f, 0.04767072f, -0.02083912f, 0.01634153f, -0.04842591f, -0.00604459f, 0.00657327f, 
    -0.03958245f, 0.04519707f, -0.01854110f, 0.03501216f, -0.05382175f, -0.00203500f, -0.02432948f, -0.02012820f, 
    -0.02208461f, -0.05793269f, 0.01373471f, -0.04411718f, -0.01288565f, 0.04561571f, -0.01364994f, 0.00421005f, 
    0.01764459f, -0.05354783f, -0.02899905f, -0.01288102f, -0.01084488f, 0.00638138f, 0.01807629f, 0.04563075f, 
    -0.03086838f, -0.02909662f, 0.02428626f, 0.00369304f, 0.02873794f, 0.04913966f, 0.05688421f, 0.03654409f, 
    -0.02696294f, -0.03079137f, -0.04935218f, -0.05353294f, 0.00963992f, 0.02557074f, -0.05330219f, 0.02634967f, 
    -0.03745468f, -0.05947926f, -0.02053472f, 0.03946785f, 0.02629053f, -0.04517012f, -0.04323653f, -0.04334125f, 
    0.02143492f, -0.02759215f, -0.04819660f, 0.00489675f, 0.00686554f, -0.03118373f, -0.02204629f, -0.01776119f, 
    -0.02316830f, 0.01022846f, -0.01443649f, -0.03506868f, -0.03941368f, 0.00396546f, -0.04642995f, 0.02574717f, 
    0.03904089f, 0.04695176f, 0.03431479f, 0.03343232f, -0.03840760f, 0.02526198f, 0.00534621f, -0.02190705f, 
    0.01710363f, -0.03667810f, 0.03959028f, -0.02349426f, 0.01164812f, -0.04767287f, 0.03127992f, -0.04297983f, 
    0.00089054f, 0.03841631f, -0.02521463f, 0.05225493f, 0.00980964f, 0.02801985f, 0.00300509f, -0.02545732f, 
    0.00500604f, -0.01026112f, -0.02404348f, -0.03200509f, -0.06081542f, -0.03902122f, 0.05440729f, -0.04924385f, 
    -0.02268932f, 0.02509337f, -0.04276206f, -0.01443107f, 0.04095287f, -0.05553678f, 0.02944933f, -0.01626561f, 
    0.02164306f, -0.05511583f, 0.02919547f, 0.01574541f, -0.02540779f, -0.02762755f, 0.02541861f, -0.03951496f, 
    -0.02985098f, 0.01313610f, 0.04495887f, 0.04817036f, 0.01736514f, 0.01712323f, -0.05763396f, 0.04748087f, 
    0.01303072f, -0.02711944f, 0.00780886f, 0.00346714f, -0.03606642f, -0.00498459f, -0.04744742f, -0.01324327f, 
    -0.04430161f, 0.00170275f, -0.02428198f, -0.04617634f, -0.05449290f, -0.00307097f, 0.04530947f, -0.05529335f, 
    -0.16398084f, -0.00365614f, -0.00902299f, 0.10467824f, 0.01290217f, 0.00362508f, -0.12116288f, -0.02683513f, 
    -0.01997214f, -0.02821129f, 0.10141455f, -0.03074062f, -0.00665644f, -0.17684828f, 0.02456779f, 0.08115827f, 
    -0.05028182f, 0.15451621f, 0.09719641f, -0.09953834f, 0.14904211f, -0.17375454f, -0.02735503f, 0.13300286f, 
    0.13334784f, -0.08640486f, 0.03905030f, 0.02724510f, -0.00149326f, 0.04443035f, -0.02788087f, 0.07006071f, 
    0.01272910f, -0.04037651f, 0.15751043f, -0.05321237f, 0.04695550f, 0.03059590f, -0.12358066f, -0.05248709f, 
    -0.18865709f, -0.10609157f, -0.09886314f, -0.08127959f, -0.15691145f, -0.01604966f, -0.03142288f, -0.15814926f, 
    -0.08965600f, 0.00009923f, 0.16113262f, -0.07466848f, 0.09091720f, 0.10937823f, 0.03652927f, -0.12294800f, 
    0.00905664f, 0.05099031f, -0.00006298f, 0.03542981f, -0.30821210f, 0.30749562f, 0.41231734f, 0.09418030f, 
    -0.22840410f, 0.13916014f, 0.01997952f, 0.06643144f, 0.00879517f, -0.10992905f, -0.06599206f, 0.05666579f, 
    0.03736113f, 0.01534271f, -0.08107711f, 0.05486993f, 0.08653510f, -0.00814115f, 0.02191851f, -0.03885638f, 
    0.07233132f, 0.20286077f, -0.01778934f, 0.16639043f, -0.23247646f, -0.00016048f, 0.19186993f, 0.03598227f, 
    0.03108793f, -0.04205015f, 0.01357738f, 0.03055648f, 0.02115387f, 0.05778595f, -0.07992234f, 0.00569385f, 
    -0.11457743f, 0.07720175f, 0.10923006f, 0.04313181f, 0.01355420f, 0.30439118f, 0.21652952f, -0.11023361f, 
    -0.03825879f, 0.07314757f, 0.06279361f, 0.02706129f, 0.01953588f, -0.04535835f, -0.09524526f, 0.10796228f, 
    0.05986061f, 0.03935092f, 0.02486972f, -0.01957993f, 0.06358043f, 0.08573830f, 0.06909252f, -0.07569114f, 
    0.14324211f, -0.01883077f, 0.14863299f, 0.07774815f, 0.07890290f, 0.12899829f, 0.00521659f, 0.06523986f, 
    0.12439187f, 0.01145945f, -0.09214671f, 0.02552950f, 0.03840961f, -0.04877802f, 0.11421327f, 0.10889762f, 
    -0.00361164f, 0.09663447f, -0.06053071f, -0.09817170f, 0.05575683f, 0.01310241f, -0.14857349f, -0.02022467f, 
    -0.18633640f, -0.04506367f, -0.24204752f, -0.08932798f, 0.03318174f, -0.09516697f, -0.02056832f, 0.04565864f, 
    -0.00537228f, 0.05772263f, 0.03007407f, -0.00686309f, -0.00227058f, -0.00695702f, -0.00116944f, 0.01871964f, 
    0.16545637f, -0.36121774f, -0.01643844f, -0.35316539f, 0.10593840f, -0.07550132f, -0.19438536f, 0.07292090f, 
    0.05842053f, 0.01499233f, -0.10859426f, -0.01171560f, 0.02401895f, -0.09742911f, 0.00616335f, 0.01144843f, 
    0.05707090f, 0.02007023f, -0.05136456f, 0.15400915f, 0.12901823f, -0.08577123f, 0.14108826f, 0.05001702f, 
    -0.02462155f, -0.00863543f, 0.05592472f, 0.00552979f, 0.08733548f, 0.07259773f, 0.02381358f, 0.02861895f, 
    -0.08422235f, 0.03929890f, 0.02834368f, 0.00123107f, -0.03361287f, 0.11367557f, -0.01211933f, 0.05355642f, 
    -0.21164148f, -0.04741818f, 0.11015606f, -0.13960241f, -0.20112303f, 0.05068694f, 0.05344871f, 0.22607408f, 
    0.02208064f, -0.00940559f, -0.06184986f, 0.10740431f, -0.03275142f, -0.02009780f, 0.05246783f, 0.13913983f, 
    -0.03416525f, -0.04229119f, -0.04084949f, 0.09512640f, -0.01297028f, -0.10319237f, 0.29284921f, -0.31017590f, 
    0.12895484f, -0.17004043f, 0.06104511f, 0.06635050f, 0.13162042f, 0.05119495f, 0.01690860f, -0.08952536f, 
    -0.01651716f, -0.01187320f, -0.00332302f, 0.00792001f, -0.07166292f, 0.06688896f, -0.20897019f, -0.07263551f, 
    0.24495344f, 0.12174044f, -0.15337187f, 0.05747885f, 0.36315390f, -0.14616817f, -0.09681953f, -0.12046798f, 
    0.00245055f, 0.12389106f, -0.11853561f, -0.09854539f, -0.08035383f, -0.16004555f, 0.11401755f, -0.00923461f, 
    -0.10004056f, 0.04430459f, 0.12609771f, 0.03848280f, 0.44704470f, 0.16732250f, 0.08920975f, 0.58879131f, 
    -0.10452738f, 0.10446094f, -0.00887996f, 0.03007204f, -0.04562619f, 0.10374003f, -0.03949786f, -0.08753410f, 
    0.00086705f, 0.06862246f, 0.01061361f, 0.19613396f, -0.03648625f, 0.07465894f, -0.01580669f, 0.07342975f, 
    0.11712568f, 0.21637608f, -0.01185598f, -0.11133432f, 0.34818465f, -0.00084906f, -0.11172047f, 0.10005727f, 
    0.04671797f, 0.02707576f, -0.09625506f, 0.09257291f, -0.03026905f, 0.10694667f, -0.03757130f, 0.05303287f, 
    0.05869653f, -0.06984179f, -0.08047092f, 0.03423790f, 0.35016355f, 0.08925036f, 0.27478075f, -0.03950720f, 
    0.00487128f, 0.06458878f, -0.02450475f, 0.06547007f, 0.07924302f, -0.01961036f, -0.03241782f, 0.10052001f, 
    0.06206379f, 0.02458671f, -0.01767949f, -0.01734786f, -0.04468252f, -0.11059248f, 0.03614135f, -0.05406102f, 
    0.20747949f, 0.15714000f, -0.17072356f, -0.20761633f, -0.10670549f, 0.16952863f, -0.04580585f, 0.09641424f, 
    -0.20878381f, 0.11535751f, -0.03354072f, -0.09001511f, 0.01420609f, 0.09485690f, 0.04820159f, 0.03490905f, 
    0.03452341f, -0.01903356f, -0.07666932f, 0.02133279f, -0.18751884f, 0.06770911f, 0.32504350f, -0.13618843f, 
    -0.33832955f, 0.05521000f, 0.02407672f, 0.00665791f, 0.00697495f, 0.05244032f, 0.01515733f, -0.07169826f, 
    0.13526812f, 0.10280120f, -0.03007289f, -0.00128894f, -0.08580273f, 0.03432982f, 0.03281930f, 0.09477814f, 
    -0.11123972f, 0.26182392f, 0.14229074f, -0.03901611f, 0.20713261f, 0.08520205f, -0.03432422f, 0.06771893f, 
    0.11480069f, -0.06171364f, 0.11624597f, 0.01801435f, 0.03350385f, 0.00864272f, 0.03915511f, 0.14889258f, 
    0.07967032f, 0.06630788f, 0.08030520f, -0.09799628f, 0.01638475f, -0.04622300f, -0.01038396f, -0.04637847f, 
    -0.09328277f, -0.18160526f, 0.16345683f, 0.01157029f, 0.04259984f, -0.08425026f, -0.08851687f, -0.02495082f, 
    0.08183973f, -0.16686586f, 0.10923986f, -0.00937449f, -0.06879140f, 0.08574384f, 0.06048223f, 0.12534702f, 
    -0.13093737f, -0.13561597f, 0.01913975f, -0.18108067f, 0.00863167f, -0.03688911f, -0.13954702f, 0.08452331f, 
    -0.08862386f, 0.01764252f, 0.04715103f, 0.00457538f, -0.02031872f, -0.02251290f, 0.06168257f, -0.01054467f, 
    0.03338235f, 0.02025717f, -0.05463881f, 0.14397578f, 0.49012524f, -0.04906663f, -0.27876559f, -0.05680509f, 
    -0.02223248f, -0.21219203f, -0.05573155f, 0.12217248f, -0.02375576f, 0.06498487f, -0.02600043f, -0.10272843f, 
    0.01889642f, 0.12371021f, 0.09166169f, 0.13175291f, 0.13990407f, -0.03136355f, 0.00036046f, 0.05235130f, 
    0.10338242f, -0.04518313f, 0.05113856f, 0.00730197f, -0.21272767f, -0.06688055f, 0.05627665f, -0.00011831f, 
    0.05437724f, 0.05877493f, 0.12667815f, 0.01868352f, -0.00977793f, 0.00807749f, -0.13693948f, -0.08450118f, 
    -0.01602773f, -0.15039684f, 0.05494104f, 0.04439917f, -0.11105034f, 0.06319554f, 0.11967336f, -0.05277689f, 
    -0.12249457f, -0.04047352f, 0.13353543f, 0.18339333f, -0.03302597f, 0.00781242f, -0.05604048f, -0.06182985f, 
    0.05398279f, 0.09544730f, 0.07120077f, 0.08395670f, -0.04807258f, 0.09993784f, -0.03877642f, 0.02860094f, 
    -0.10102173f, 0.27022734f, -0.29447770f, 0.08239493f, 0.40537360f, 0.00401240f, 0.08743255f, -0.18919279f, 
    0.09415232f, 0.03299717f, 0.00331451f, -0.00305952f, -0.06687301f, 0.13016567f, -0.07635988f, -0.01977693f, 
    0.09222014f, -0.04966687f, 0.06594785f, -0.14131555f, 0.18177912f, 0.03848827f, 0.08106261f, -0.05525403f, 
    -0.14597557f, 0.09833374f, 0.05083603f, -0.01076858f, -0.02527923f, -0.07936819f, 0.04554241f, -0.11959554f, 
    0.05217362f, -0.01830420f, 0.09546129f, 0.10710711f, 0.04736117f, 0.05885894f, -0.09148671f, 0.01004106f, 
    0.32144800f, 0.15462217f, 0.03804139f, -0.03765183f, 0.10457677f, -0.14413406f, 0.02575264f, -0.09587689f, 
    -0.05661207f, 0.04081647f, -0.02373805f, -0.02035569f, 0.15598229f, -0.07916567f, -0.07642035f, 0.07753541f, 
    0.03070276f, -0.01705830f, 0.06608947f, 0.02576703f, 0.27215037f, 0.25661474f, -0.30152434f, 0.20240797f, 
    0.10952135f, 0.06284004f, -0.01295211f, -0.10273886f, -0.03215812f, 0.03625783f, 0.14374933f, 0.03964371f, 
    0.01729453f, 0.16103558f, 0.05293298f, 0.05819841f, -0.08727701f, -0.05881049f, 0.09450064f, -0.10554309f, 
    0.07797079f, -0.17382175f, 0.12202147f, -0.11570395f, 0.16519290f, 0.12906769f, 0.17065227f, 0.00276341f, 
    0.05100735f, -0.06169520f, 0.09046066f, 0.09708625f, 0.05722443f, 0.07902265f, -0.12575570f, -0.05527937f, 
    -0.00150282f, 0.03373719f, -0.01686378f, -0.03035951f, -0.31582096f, -0.26597059f, -0.18712744f, -0.09492768f, 
    0.01457548f, -0.05063593f, -0.06628419f, 0.09183211f, -0.00142778f, -0.05435551f, 0.08521722f, 0.11974001f, 
    0.01017581f, 0.07062070f, 0.01178927f, -0.14428014f, 0.03601241f, 0.16490005f, 0.19574507f, -0.04661786f, 
    0.38136148f, -0.43389359f, -0.11634509f, 0.16774219f, 0.13593629f, -0.01917937f, -0.04824184f, -0.10574485f, 
    -0.04347664f, 0.09652692f, 0.03252036f, -0.04733204f, 0.12044623f, -0.10399510f, 0.03578766f, -0.07062877f, 
    -0.06951161f, -0.07417064f, 0.07533161f, -0.08368234f, -0.13984495f, 0.48497236f, -0.28861320f, -0.09363722f, 
    0.07009323f, -0.02896081f, -0.01017724f, -0.13230255f, 0.00191633f, 0.05285555f, 0.01820852f, -0.09873241f, 
    -0.02566311f, -0.10694092f, 0.04928882f, -0.01435154f, 0.00003602f, 0.10317530f, 0.06249466f, 0.04656367f, 
    -0.05297986f, 0.02213138f, -0.03511286f, 0.04702571f, 0.03150649f, 0.02911591f, 0.02512459f, -0.01306841f, 
    -0.06144418f, 0.02613771f, 0.01171724f, 0.03426472f, 0.00494831f, 0.03053282f, -0.05838782f, -0.05284107f, 
    0.04063936f, 0.03425295f, 0.02619541f, -0.00322438f, -0.02499910f, -0.02993355f, -0.00951969f, 0.01796598f, 
    -0.05989873f, 0.04293200f, -0.01765141f, -0.04641256f, -0.01432341f, 0.02154905f, -0.05029558f, 0.04759794f, 
    -0.02264127f, 0.00469138f, 0.04782360f, -0.00576310f, 0.01340178f, -0.05268207f, 0.01895197f, -0.01276023f, 
    0.01647857f, -0.01402630f, -0.00511136f, -0.02760437f, -0.01979894f, 0.00996915f, 0.00983896f, 0.02879987f, 
    0.02401067f, 0.02785324f, -0.04158923f, 0.00302395f, -0.05190096f, 0.00056698f, 0.04802760f, 0.00143495f, 
    0.00727891f, -0.00758553f, -0.03035621f, 0.04387770f, -0.02921703f, 0.03270942f, -0.01175017f, 0.00275094f, 
    -0.01506289f, 0.02068216f, -0.05944990f, -0.02022803f, 0.01859968f, 0.04347360f, 0.02771612f, 0.04633034f, 
    -0.02512070f, -0.04334154f, -0.01244797f, -0.05308265f, -0.01856427f, 0.02007473f, -0.02724219f, 0.04570687f, 
    -0.04014373f, -0.05261802f, 0.01264619f, -0.05938681f, -0.04671661f, 0.02380043f, 0.02236082f, -0.03069595f, 
    -0.00310672f, 0.02995709f, -0.03953764f, 0.03347415f, 0.03302974f, 0.00192738f, -0.04851848f, -0.00065120f, 
    -0.04574779f, -0.03104879f, 0.04893561f, 0.00436432f, 0.00404707f, 0.04250491f, 0.00133922f, 0.03295187f, 
    0.00601995f, -0.04588028f, -0.02961232f, -0.04074375f, -0.04016599f, 0.01818312f, 0.01697899f, 0.02328078f, 
    -0.04946578f, -0.03740482f, 0.02669072f, -0.02642860f, 0.01029451f, -0.05703223f, 0.03959195f, -0.02550777f, 
    -0.02799653f, 0.03797605f, -0.00846204f, -0.05449766f, -0.01228206f, 0.04293478f, 0.03306783f, -0.04301831f, 
    -0.02683230f, -0.02162970f, -0.00841066f, -0.03395857f, 0.04876306f, 0.04899483f, 0.01787653f, 0.02507882f, 
    -0.04997785f, 0.02192228f, -0.01362124f, 0.03466111f, -0.01077565f, -0.04876955f, 0.03201657f, -0.00269825f, 
    0.01863971f, -0.05751666f, -0.04836761f, -0.04454833f, 0.00875386f, 0.00184225f, -0.02016535f, 0.02158699f, 
    -0.00315848f, 0.01324529f, 0.00961207f, -0.00437761f, -0.01044064f, -0.01158346f, -0.03457590f, -0.01294074f, 
    0.04916337f, -0.05797747f, -0.03324010f, -0.03011439f, 0.01911164f, -0.04012451f, -0.03704949f, -0.03426507f, 
    -0.03766593f, 0.04780846f, 0.00516215f, 0.03702838f, -0.03177615f, -0.05180654f, -0.00582312f, -0.04956699f, 
    -0.04848088f, -0.04039544f, 0.00475286f, -0.00830178f, -0.03916383f, 0.01914520f, -0.04784046f, -0.03859163f, 
    -0.05306059f, 0.00094535f, -0.03671152f, -0.03720756f, 0.02028694f, -0.00032838f, -0.04772818f, -0.02713904f, 
    -0.05619801f, 0.04636268f, -0.02232882f, -0.02495316f, 0.00380281f, 0.00417108f, 0.00625584f, 0.04570949f, 
    -0.01559639f, -0.05243557f, -0.04508400f, -0.05232435f, -0.05654859f, -0.01359791f, 0.01852657f, 0.03188430f, 
    -0.01500717f, -0.01808806f, 0.03166633f, -0.03256170f, 0.00738831f, 0.00707054f, -0.04355628f, 0.01078770f, 
    0.02514668f, 0.00236064f, -0.02067601f, 0.01277173f, 0.04293830f, 0.00686583f, -0.02876279f, -0.01623161f, 
    -0.05685685f, 0.00144803f, -0.01102131f, -0.05227601f, -0.01637502f, 0.04969180f, 0.04420493f, -0.03047359f, 
    0.02445951f, 0.04317655f, -0.05753800f, -0.03682171f, -0.03540936f, 0.03669066f, 0.02118882f, 0.02982593f, 
    -0.03913498f, -0.02959779f, 0.00313950f, 0.04269008f, -0.00553895f, -0.06054489f, 0.04227015f, -0.01004199f, 
    0.00859870f, -0.04193326f, -0.04815652f, -0.05058434f, -0.03179172f, -0.03355537f, 0.03046995f, -0.01494119f, 
    -0.01682307f, -0.01448187f, 0.02630485f, -0.05024010f, -0.02288140f, -0.03303226f, -0.06011198f, 0.00580294f, 
    -0.01156230f, -0.03538693f, 0.04828721f, 0.03864444f, -0.04162773f, 0.00719216f, -0.05183438f, -0.02514924f, 
    0.02360779f, -0.02650122f, 0.00489744f, -0.00254472f, -0.06136665f, -0.00611337f, 0.02725722f, -0.04354842f, 
    -0.00970726f, 0.03252756f, -0.05014217f, 0.00007714f, -0.03320050f, -0.02206085f, 0.02872275f, -0.05188655f, 
    0.01282430f, -0.03342467f, 0.01856255f, -0.03974853f, 0.00158645f, -0.02433708f, -0.00673970f, 0.04435923f, 
    0.03026248f, -0.04868885f, -0.05018870f, -0.01028991f, 0.04368434f, -0.03719166f, -0.03310370f, 0.03797422f, 
    0.04114336f, 0.03331084f, -0.04417491f, -0.02261784f, -0.06089347f, 0.02100522f, -0.02041817f, 0.04193908f, 
    -0.04909777f, 0.02490823f, 0.02485334f, -0.04011435f, 0.02019495f, -0.04925932f, -0.01057224f, -0.02870597f, 
    -0.01485032f, 0.03982530f, 0.01765920f, -0.04840248f, -0.02582462f, -0.02421918f, -0.04963097f, 0.00499219f, 
    -0.03960109f, 0.01947117f, 0.01810943f, -0.02151711f, 0.02412976f, 0.00855938f, 0.02896442f, -0.04994019f, 
    0.02022943f, 0.02563985f, -0.01715532f, -0.04791384f, -0.02197827f, -0.03607520f, -0.06206971f, -0.05965570f, 
    -0.04648545f, 0.03555517f, 0.05513218f, 0.01406782f, 0.04272321f, 0.00470130f, -0.00450360f, -0.03210369f, 
    0.03554758f, 0.02464417f, 0.02546054f, -0.04206907f, -0.02812237f, 0.03867492f, 0.04837299f, -0.05684749f, 
    -0.01345657f, -0.01433930f, -0.00971736f, -0.01073058f, -0.03222886f, -0.05068910f, 0.03348650f, -0.04552965f, 
    -0.00129498f, 0.03142136f, -0.00719262f, 0.01713678f, 0.02823926f, -0.05617107f, 0.02529408f, 0.01467406f, 
    -0.04989364f, 0.03830241f, 0.02504220f, 0.01537723f, 0.00093690f, 0.01977697f, -0.02931617f, 0.04180987f, 
    0.04947255f, 0.01025601f, 0.03281484f, -0.05479123f, 0.04804237f, -0.03171997f, 0.01199882f, 0.04187499f, 
    -0.01558775f, -0.03066043f, 0.01251074f, 0.02224977f, -0.02930397f, -0.05798959f, 0.04437878f, 0.00129706f, 
    0.03309905f, 0.00271253f, -0.00118220f, -0.05315278f, -0.04362859f, 0.04055561f, 0.02461985f, 0.04298751f, 
    0.02376174f, -0.02064490f, -0.00130376f, 0.01895181f, -0.04654656f, -0.03577213f, 0.01290397f, 0.00211915f, 
    -0.04645752f, 0.00364457f, -0.01848106f, -0.03864480f, 0.00671808f, -0.00377377f, -0.01021187f, -0.00738783f, 
    -0.03360054f, -0.05446056f, -0.04931303f, -0.00806995f, 0.03048649f, 0.02515982f, 0.02898175f, -0.04353178f, 
    -0.04170763f, -0.04462205f, -0.01394324f, 0.02617001f, -0.03319352f, -0.03094172f, 0.03755502f, -0.01608126f, 
    0.01558054f, -0.04047965f, -0.05140757f, 0.05483249f, -0.01207433f, -0.05044248f, 0.04007694f, -0.03417432f, 
    0.01618043f, -0.01908084f, 0.00307926f, 0.02370925f, 0.02995075f, -0.01387875f, -0.03112752f, -0.01403210f, 
    -0.05399985f, 0.00374252f, -0.00191796f, -0.05753271f, 0.03698276f, -0.04073828f, -0.01130664f, 0.00297648f, 
    0.03688677f, -0.03290673f, 0.00047243f, -0.02288010f, 0.03279960f, -0.03267326f, -0.00780843f, -0.01041397f, 
    0.01078255f, 0.03951913f, 0.02461493f, 0.03184941f, -0.03205171f, -0.02148319f, -0.04604504f, -0.00482917f, 
    -0.01985879f, 0.04106137f, 0.00256497f, -0.00516584f, 0.00606664f, -0.03681416f, -0.05802040f, -0.06026903f, 
    -0.02546775f, 0.04729111f, 0.00588934f, -0.02333500f, -0.03484850f, 0.03511983f, -0.01772088f, 0.00610570f, 
    -0.06154744f, -0.00490330f, -0.05173133f, 0.02522938f, -0.01863739f, -0.00887073f, 0.04504712f, 0.00877409f, 
    -0.02040813f, 0.03645708f, 0.01191758f, -0.02851485f, 0.00804066f, 0.03654395f, 0.02544026f, -0.03344687f, 
    0.04582147f, -0.03010960f, 0.02981552f, -0.03857999f, 0.02889843f, -0.02815379f, 0.04220803f, -0.02415263f, 
    -0.05133590f, -0.03291573f, -0.03625014f, -0.03910454f, -0.02383961f, -0.00295288f, 0.02916124f, -0.03396758f, 
    0.01956802f, 0.04234478f, -0.04681642f, -0.05026122f, 0.04692246f, -0.04705734f, 0.04345638f, -0.03589951f, 
    0.00288516f, -0.03638435f, -0.03087226f, -0.02136064f, -0.04960202f, 0.00967234f, -0.01208911f, 0.01516018f, 
    -0.00165635f, -0.01185282f, -0.00648642f, -0.05140597f, -0.04592267f, -0.03983745f, -0.02378123f, -0.01473002f, 
    -0.02129814f, 0.02661178f, -0.05398745f, 0.03750456f, -0.03809572f, -0.04621570f, 0.04239374f, -0.00498366f, 
    -0.02882946f, -0.00360969f, 0.04239381f, 0.03275157f, 0.03923481f, 0.04279169f, 0.01822297f, 0.04476898f, 
    -0.05720356f, -0.02576848f, 0.03341178f, -0.02294407f, 0.01831221f, -0.01007501f, -0.01385111f, 0.03722873f, 
    -0.05735309f, 0.01584400f, -0.02908653f, 0.04376829f, -0.00303520f, 0.03249781f, 0.01205864f, -0.04803878f, 
    -0.03549227f, -0.01009466f, 0.02143635f, 0.04442111f, 0.02244098f, 0.04626765f, 0.01623125f, -0.01738183f, 
    0.00970489f, -0.01346567f, 0.02163049f, 0.01357941f, -0.00530397f, -0.03817626f, -0.03991699f, 0.03998226f, 
    -0.04410846f, -0.01672666f, 0.01295317f, -0.04392530f, 0.05197278f, -0.03558021f, -0.00118247f, -0.00192079f, 
    0.02613456f, -0.00575759f, -0.05268007f, -0.03441665f, -0.04726801f, 0.03370403f, -0.02968617f, -0.02379971f, 
    0.01875182f, -0.04468163f, 0.02588833f, -0.02692909f, 0.03186174f, -0.01612910f, -0.05197630f, -0.03113665f, 
    -0.04684119f, 0.01711782f, -0.05941609f, 0.03621572f, 0.02849255f, -0.03070490f, -0.03375415f, -0.04103598f, 
    0.00448300f, -0.04904072f, 0.03910799f, -0.04655819f, -0.04571427f, 0.04167538f, 0.02052728f, -0.05461483f, 
    0.03961019f, 0.08516698f, -0.14938335f, -0.04532293f, 0.03736294f, -0.02227557f, 0.01553398f, 0.13224842f, 
    0.06655709f, -0.14934364f, -0.02703856f, 0.06982789f, 0.01658553f, -0.06164233f, 0.00080879f, 0.05000092f, 
    -0.09508990f, 0.25816968f, 0.21319690f, 0.04669556f, 0.43556899f, 0.08686308f, 0.08049074f, 0.13304731f, 
    0.18380417f, 0.00846766f, 0.13254580f, 0.07288633f, 0.06300320f, 0.08195379f, -0.04010368f, -0.04554917f, 
    -0.00577870f, -0.08826659f, -0.02985449f, 0.03253619f, -0.00612938f, 0.10796382f, 0.11055885f, 0.17322102f, 
    0.07449823f, -0.00061929f, -0.05778808f, 0.07326811f, -0.13808721f, -0.04711318f, -0.05902707f, 0.01753401f, 
    -0.01605120f, -0.07255977f, -0.00750012f, -0.01294131f, -0.05771678f, 0.05602417f, 0.11363698f, 0.04435667f, 
    0.04551775f, 0.00170046f, 0.04011284f, -0.00363660f, 0.47625250f, -0.08446403f, 0.14631711f, -0.04407516f, 
    0.14697339f, 0.01764446f, -0.04531614f, -0.02703315f, 0.08582138f, 0.10291974f, 0.01274560f, 0.03881789f, 
    -0.02460997f, 0.18401726f, 0.04628355f, 0.03843262f, -0.10353872f, -0.05517075f, -0.11092924f, -0.00238543f, 
    0.88730788f, -0.10266569f, 0.14530008f, 0.24589734f, -0.05048039f, -0.13953580f, -0.07844912f, -0.08272087f, 
    0.02277055f, 0.01561174f, 0.11599425f, 0.11429739f, 0.17482163f, 0.07575857f, 0.07526954f, -0.16410978f, 
    -0.07797430f, 0.03099311f, -0.08642126f, 0.00647786f, 0.51143569f, 0.01268534f, 0.26442677f, 0.06335999f, 
    0.07514506f, 0.10111032f, 0.00356432f, -0.08276816f, 0.13564323f, 0.16140012f, -0.06259272f, 0.06456516f, 
    -0.01584652f, -0.00116144f, -0.14505732f, 0.01833341f, -0.17722967f, 0.01301049f, -0.08632887f, -0.08363745f, 
    0.03851099f, -0.33965316f, 0.04913731f, -0.19576159f, -0.09820629f, 0.08695916f, -0.02281301f, -0.04838629f, 
    -0.03147433f, 0.04256544f, -0.22333068f, 0.06863310f, -0.02777637f, -0.01526203f, 0.14517355f, 0.08323070f, 
    -0.07385414f, 0.16639398f, -0.09232675f, 0.11689193f, 0.80262142f, 0.14028740f, 0.04346615f, 0.11876772f, 
    -0.03454051f, -0.18229979f, -0.01601274f, -0.11485241f, -0.19650476f, 0.10999159f, -0.02073818f, -0.13953644f, 
    -0.07281061f, -0.01336347f, 0.00617326f, 0.04988765f, 0.08319559f, 0.05891083f, 0.08679238f, -0.02033979f, 
    -0.33666885f, -0.38105747f, -0.20414321f, -0.17541584f, -0.22003071f, 0.10781231f, -0.02084683f, 0.12464333f, 
    0.06584053f, -0.08623753f, -0.08867995f, -0.00588992f, 0.02471432f, 0.02968245f, -0.03000704f, -0.09318594f, 
    0.10175341f, -0.10489134f, -0.15361691f, -0.02562418f, 0.15180160f, 0.16608565f, 0.06345814f, -0.16305931f, 
    0.06842674f, 0.13443984f, 0.07675223f, -0.00645664f, -0.00622539f, -0.05435494f, -0.03040818f, 0.00853258f, 
    -0.15512067f, -0.08652392f, 0.00779626f, 0.19996950f, 0.03571212f, 0.19148245f, -0.02495598f, 0.01577079f, 
    -0.39474607f, -0.25895119f, -0.04508806f, -0.15074278f, -0.13292211f, 0.01458881f, 0.11779696f, -0.01538086f, 
    -0.03244951f, -0.02526879f, -0.18158157f, -0.03866751f, 0.05396914f, -0.15372105f, -0.02267305f, -0.13729416f, 
    -0.07474262f, -0.03267593f, -0.19762778f, 0.07726871f, -0.02193278f, -0.19666749f, 0.08835050f, -0.18319049f, 
    0.14060101f, 0.08411679f, 0.08540325f, 0.11316822f, 0.10525473f, -0.14084223f, 0.05133072f, 0.15336978f, 
    0.09372673f, 0.05067513f, 0.10014001f, -0.01277900f, -0.15605253f, 0.26087236f, -0.16851227f, 0.04161607f, 
    -0.30430394f, 0.00037601f, -0.10144657f, -0.31871927f, -0.22081217f, 0.01583465f, 0.08795964f, 0.21740517f, 
    0.02344092f, 0.10407742f, 0.08647100f, 0.11380532f, 0.02855946f, 0.00787801f, -0.20356625f, 0.00160738f, 
    0.13441417f, 0.10100428f, 0.03652659f, 0.02365705f, -0.04763244f, 0.13699706f, -0.18209894f, 0.08701783f, 
    0.08115692f, -0.06946918f, 0.04749248f, 0.00852054f, 0.10040399f, 0.13135612f, -0.29378131f, -0.27667654f, 
    0.00560938f, 0.07381385f, 0.08149395f, 0.26436710f, 0.06394428f, -0.10511816f, 0.01273854f, 0.13421482f, 
    -0.14566873f, -0.23395175f, 0.00907731f, -0.08710220f, -0.00115482f, 0.04809839f, 0.04766585f, -0.00210650f, 
    0.02570510f, 0.08874509f, -0.07502256f, 0.03591703f, -0.02002700f, 0.12704049f, -0.03591482f, 0.08667761f, 
    0.06143245f, 0.07824008f, -0.06533007f, 0.07847026f, 0.46232483f, 0.03960744f, -0.21960266f, -0.00069729f, 
    0.14739822f, -0.01249378f, 0.07951687f, -0.00391695f, 0.12400462f, 0.16328458f, -0.10913046f, 0.10540753f, 
    -0.05883254f, 0.13292606f, 0.02602757f, 0.12251528f, 0.01000498f, 0.06115622f, -0.09064638f, 0.03660835f, 
    0.02099954f, 0.03577345f, 0.04187116f, -0.00158903f, 0.02408425f, -0.02045659f, -0.04258210f, -0.04407037f, 
    -0.07280294f, 0.01829550f, -0.07172691f, -0.07245360f, -0.04050115f, -0.04275425f, -0.05099893f, 0.00163306f, 
    -0.07931881f, -0.05059390f, -0.06663425f, 0.01050927f, -0.04055062f, -0.00811433f, 0.01038987f, -0.01009756f, 
    -0.00589718f, 0.01046957f, -0.05263549f, -0.03718545f, -0.03790170f, 0.00697962f, -0.05966732f, -0.01353559f, 
    -0.04551513f, -0.05297142f, -0.01205462f, -0.03706022f, -0.00300706f, -0.04953312f, -0.05733792f, -0.05635959f, 
    -0.00460476f, -0.06174646f, -0.06953193f, 0.02400397f, -0.04556559f, 0.00876081f, 0.00095166f, -0.00956805f, 
    -0.05908398f, 0.00412025f, 0.03935416f, -0.04786372f, -0.03293535f, -0.05643803f, -0.04040134f, 0.00271196f, 
    0.01919003f, -0.05742425f, 0.01803499f, -0.05178674f, 0.01130213f, -0.01971140f, -0.02094680f, -0.03709286f, 
    -0.07671431f, -0.00852323f, -0.06664622f, 0.03535347f, -0.04108318f, -0.06705195f, 0.04395194f, -0.03765329f, 
    -0.06046734f, 0.02424223f, -0.05975061f, 0.02090763f, -0.00245348f, 0.03535089f, -0.01849755f, -0.05676576f, 
    -0.04215740f, -0.06376885f, -0.01406775f, 0.01296514f, -0.05951974f, 0.01390289f, 0.03008380f, -0.03814698f, 
    -0.00876069f, -0.01539954f, 0.00719257f, -0.06111386f, -0.05932300f, -0.03433413f, 0.03691946f, 0.01765078f, 
    -0.00716526f, 0.04456355f, -0.02433653f, -0.00435596f, -0.05104523f, -0.04421368f, 0.04724404f, -0.06095254f, 
    -0.07564152f, 0.00688143f, -0.02540671f, 0.01998487f, -0.06781348f, -0.03538201f, 0.00804305f, -0.04551064f, 
    0.01600158f, 0.00255191f, -0.03167509f, 0.01480208f, 0.01925052f, 0.03291216f, 0.02851049f, -0.05809167f, 
    0.03469833f, 0.00867453f, -0.02247517f, -0.06626078f, 0.03354213f, 0.05715615f, -0.02021847f, -0.03115958f, 
    -0.05586367f, 0.03350426f, -0.04517343f, -0.03563402f, -0.07421985f, 0.01598261f, 0.04221230f, -0.00961933f, 
    0.00680499f, 0.02786887f, -0.05978109f, -0.01286878f, 0.00412314f, -0.05431102f, -0.01703132f, -0.02929276f, 
    0.01079779f, -0.00791027f, -0.06392930f, 0.02952640f, -0.03436711f, -0.00746061f, 0.02685451f, -0.05339583f, 
    -0.00306082f, -0.04046926f, 0.00862974f, 0.00057926f, 0.02504390f, -0.01864475f, -0.00737949f, -0.01549035f, 
    0.01359306f, -0.06492416f, -0.04589324f, 0.02897058f, -0.02623134f, 0.01419396f, -0.05680246f, 0.00892010f, 
    0.03268671f, -0.06105670f, 0.01032330f, -0.03424064f, -0.06552920f, -0.02896705f, 0.04103522f, 0.04264966f, 
    0.02162860f, -0.02561249f, -0.03704776f, 0.01553476f, 0.03965833f, -0.05403843f, 0.00137616f, -0.01178564f, 
    0.03958889f, -0.00294861f, -0.02188930f, 0.01256696f, 0.02261507f, -0.02039207f, 0.02015417f, -0.03886148f, 
    -0.02250340f, 0.04248820f, -0.00341583f, 0.02845207f, -0.01405538f, 0.00467487f, 0.00340000f, 0.00600130f, 
    0.00237875f, -0.06842624f, -0.00758210f, -0.01050045f, -0.04988157f, -0.07454701f, 0.00852559f, -0.01423828f, 
    0.02868720f, -0.06528720f, -0.01226689f, -0.03283164f, -0.02994542f, -0.06804133f, -0.06329153f, -0.03757834f, 
    0.01736213f, 0.01991522f, 0.02749194f, 0.03178626f, -0.08082687f, -0.05556891f, 0.02423159f, -0.01884915f, 
    -0.05399226f, -0.06217314f, -0.01129893f, -0.02139479f, -0.03695800f, -0.05966844f, 0.03158182f, -0.06615270f, 
    -0.07201883f, 0.00614969f, -0.04328420f, 0.02264546f, 0.01326522f, -0.01427663f, -0.04955013f, -0.01299245f, 
    -0.01737698f, -0.03898631f, 0.02843031f, 0.05056405f, 0.02107686f, 0.01386599f, -0.01698603f, 0.00942887f, 
    0.01057810f, -0.01020126f, -0.07487080f, -0.07307297f, -0.08191362f, 0.00946522f, -0.01269359f, 0.04789469f, 
    0.01646672f, 0.02934967f, -0.07033032f, 0.03954285f, -0.06899782f, -0.05554716f, -0.00526798f, 0.02453314f, 
    0.01348042f, -0.02704695f, 0.01307844f, -0.06859798f, -0.05794293f, 0.03481830f, -0.01016070f, -0.06718974f, 
    0.01945176f, -0.01346655f, 0.02015101f, -0.04811355f, -0.04704969f, -0.04429052f, 0.03163905f, -0.04873949f, 
    -0.07619879f, 0.00987386f, 0.03284458f, -0.00458194f, -0.01993036f, -0.03195987f, -0.01454353f, -0.01195823f, 
    0.02579795f, 0.04756368f, -0.04247454f, -0.01022317f, -0.07467933f, 0.02021222f, 0.01506753f, -0.00398666f, 
    0.01818369f, -0.02268621f, 0.00536120f, -0.01241902f, 0.02552045f, -0.03938176f, 0.00241121f, 0.02149468f, 
    0.00232538f, -0.00984577f, -0.06606946f, -0.07187404f, -0.03368855f, -0.05898369f, -0.01393506f, -0.04963836f, 
    -0.05426740f, -0.07280884f, 0.03297860f, -0.07370322f, 0.00974727f, -0.07181022f, -0.01436731f, -0.00646848f, 
    0.11405094f, 0.07106902f, -0.20728269f, -0.07868370f, -0.08054214f, 0.15414922f, -0.05468799f, -0.10365334f, 
    -0.09613276f, 0.06042570f, 0.15026797f, -0.07995220f, 0.20694250f, 0.01637081f, 0.12199560f, 0.12077506f, 
    -0.05713711f, 0.02640633f, 0.00986065f, -0.02754785f, -0.23620899f, -0.12233464f, 0.12024624f, 0.05220022f, 
    -0.14400710f, -0.11866388f, 0.14266066f, -0.13758709f, 0.04237097f, 0.03918926f, 0.01341513f, -0.08510069f, 
    0.04272325f, 0.06455337f, 0.04655432f, -0.06623106f, -0.06110218f, -0.02907262f, 0.00265874f, -0.02815732f, 
    -0.42721590f, 0.36604229f, 0.02761000f, -0.14753693f, -0.01484793f, 0.00206502f, 0.03266247f, 0.02135570f, 
    -0.05991933f, 0.03039263f, 0.06878610f, -0.01962688f, -0.07596729f, 0.07419053f, 0.02117005f, -0.00191464f, 
    0.05907316f, 0.05580006f, 0.04126110f, -0.02099868f, -0.59872395f, 0.48873982f, 0.24209183f, -0.04808840f, 
    -0.11210268f, 0.00038936f, 0.06606328f, -0.01678915f, 0.13122168f, -0.16659625f, -0.02542238f, -0.01677160f, 
    0.01856045f, -0.12675184f, 0.08993375f, 0.06184994f, 0.02508652f, -0.06677852f, 0.04435487f, -0.04195634f, 
    -0.43703982f, 0.12751180f, 0.09233594f, 0.23853818f, -0.06527798f, -0.02958629f, -0.05441888f, 0.03879452f, 
    0.11896481f, 0.13610412f, 0.07193879f, 0.03692262f, 0.07646476f, 0.02587890f, 0.01562042f, -0.02141869f, 
    0.13753358f, 0.04285255f, 0.15012702f, -0.06943957f, 0.14881141f, 0.20184246f, -0.08737683f, -0.18418999f, 
    0.05096395f, -0.12392282f, -0.01692705f, 0.22741917f, -0.02335251f, -0.01282609f, -0.10542854f, -0.17136952f, 
    0.15198489f, 0.00293052f, 0.06757683f, 0.01829922f, 0.11743034f, 0.00332846f, 0.12455380f, -0.06617749f, 
    0.40738210f, -0.00802474f, 0.12649466f, 0.14226095f, -0.10681713f, 0.00254090f, -0.01673594f, 0.01389722f, 
    0.05321187f, 0.02798194f, 0.05658861f, 0.01336009f, -0.06765307f, 0.01055758f, -0.09640951f, -0.07356566f, 
    0.05316491f, 0.03601696f, 0.00004698f, -0.06871844f, -0.00772694f, 0.22637171f, -0.10681700f, -0.03411297f, 
    -0.14096038f, -0.04442843f, -0.13455564f, 0.01390336f, 0.01400575f, 0.02804356f, -0.09337862f, 0.04013119f, 
    0.02664941f, 0.04823556f, 0.04767568f, 0.04307147f, -0.06570998f, 0.01684129f, 0.03911094f, -0.13083060f, 
    0.43175092f, -0.24548844f, -0.11833011f, -0.19302809f, 0.52173030f, -0.05982625f, -0.00913814f, 0.02969271f, 
    0.12753507f, 0.11833981f, 0.05760377f, -0.04259579f, 0.00671057f, 0.08949830f, -0.02670898f, 0.07878955f, 
    0.07713742f, 0.00844886f, -0.00857856f, 0.07583605f, 0.16525285f, -0.22428617f, 0.05662037f, 0.27792364f, 
    -0.12327648f, 0.01128913f, 0.15671429f, 0.02571720f, 0.10190272f, -0.04744729f, 0.04154948f, 0.08068878f, 
    -0.00569571f, 0.06990111f, 0.04556795f, 0.10705172f, -0.02572015f, -0.05595085f, 0.04587331f, -0.00245354f, 
    -0.01786230f, 0.16180497f, 0.35059902f, -0.12225777f, -0.01816971f, -0.01271571f, -0.14673570f, 0.05702668f, 
    0.16431457f, 0.11739155f, 0.14560163f, 0.05925425f, -0.00634590f, -0.05055515f, 0.01490785f, 0.11561614f, 
    0.07711185f, 0.04056352f, -0.06508123f, 0.10251481f, 0.31848669f, 0.06752844f, -0.09957920f, -0.07663938f, 
    0.11328699f, -0.03348116f, -0.02331951f, -0.07453413f, 0.03726764f, 0.11184218f, -0.00665143f, 0.06066829f, 
    -0.12328805f, 0.00396161f, 0.00161168f, 0.03627000f, -0.04007630f, -0.20469856f, -0.01565468f, -0.02215248f, 
    0.51124161f, -0.28448373f, -0.15103227f, 0.07040462f, 0.49848315f, -0.00123723f, -0.09509230f, 0.00788443f, 
    -0.02626940f, -0.05522123f, 0.05621974f, 0.14874826f, -0.12380190f, -0.02638749f, 0.03074728f, -0.01659133f, 
    0.06817076f, 0.06643330f, 0.01505368f, 0.13726802f, 0.04627280f, -0.14307445f, -0.18264033f, 0.58621705f, 
    0.09113555f, -0.00229764f, 0.03251963f, -0.03721083f, 0.01670882f, -0.13253367f, 0.01861644f, 0.00606459f, 
    0.09398504f, 0.05376874f, 0.00294378f, -0.15122017f, -0.05178849f, 0.18764313f, 0.06878439f, 0.04285623f, 
    0.40653932f, -0.25189278f, -0.04191484f, 0.01143458f, 0.16230895f, 0.05357568f, -0.14476423f, 0.06225075f, 
    0.00802349f, 0.11401816f, -0.04155932f, -0.03807692f, 0.07842549f, 0.03272597f, 0.02764443f, -0.09417069f, 
    -0.00297598f, -0.15116115f, -0.06750277f, -0.08421402f, -0.13525882f, 0.64611751f, -0.08228657f, -0.36083207f, 
    -0.08226553f, 0.02642059f, -0.02277016f, -0.04229009f, 0.06909432f, 0.03486449f, 0.02436781f, 0.04488625f, 
    0.11382996f, -0.03064116f, -0.01225693f, -0.04158683f, 0.02846219f, -0.08227254f, 0.08091356f, -0.06174393f, 
    -0.03121330f, 0.04520582f, 0.00075823f, -0.02083967f, -0.01845565f, -0.04321819f, -0.04406808f, -0.02802197f, 
    -0.01657565f, -0.04182285f, 0.03480645f, -0.05380948f, -0.00790529f, 0.03549067f, 0.01239325f, -0.04585962f, 
    -0.05134511f, 0.01898352f, 0.02272799f, 0.00889418f, 0.05015691f, 0.00500763f, 0.00995057f, 0.00741172f, 
    0.00068501f, -0.01123663f, -0.00463913f, 0.01062592f, 0.02198522f, 0.01502268f, -0.04686562f, 0.00776367f, 
    -0.00212162f, -0.04921497f, 0.01277219f, -0.03879718f, 0.05007625f, 0.00113625f, 0.00855681f, 0.04275994f, 
    0.03728073f, -0.05541854f, -0.02947876f, 0.01009240f, -0.04267070f, 0.03192336f, -0.05282004f, -0.04317221f, 
    -0.05059861f, -0.05058853f, 0.03298915f, 0.02200497f, 0.01332507f, -0.00321719f, -0.04437231f, -0.04488483f, 
    -0.00530455f, -0.05701845f, 0.00078518f, 0.04332250f, 0.03399694f, 0.04279636f, -0.03661347f, 0.02499484f, 
    -0.02732549f, 0.02080106f, -0.04241382f, -0.05826519f, 0.04335060f, 0.00660784f, -0.05704113f, -0.04946774f, 
    -0.04598024f, -0.00899620f, -0.01864045f, -0.04473168f, 0.03868429f, -0.00649385f, -0.03692375f, -0.04319201f, 
    -0.04963018f, -0.00324374f, 0.00570288f, -0.04566199f, 0.00292191f, 0.01107585f, 0.04848820f, 0.03569517f, 
    0.00591976f, -0.00465966f, -0.01028727f, 0.04409010f, 0.04344430f, -0.03488535f, 0.01620749f, 0.03803487f, 
    0.00712236f, -0.05906278f, 0.01736869f, 0.02896496f, 0.04264328f, -0.02426255f, 0.01924012f, -0.03058048f, 
    -0.02910680f, -0.03561671f, 0.03074075f, 0.04889213f, -0.00384339f, -0.00126121f, 0.02989923f, -0.00889372f, 
    -0.03904905f, -0.01456813f, -0.00567233f, -0.05263719f, -0.01631461f, -0.03809973f, 0.03959056f, -0.04141207f, 
    0.02248104f, 0.00290281f, 0.02539315f, 0.00502107f, -0.02179375f, 0.03827077f, -0.03140578f, -0.01091928f, 
    -0.01054054f, -0.04562059f, 0.04493735f, -0.03931899f, 0.04140919f, 0.02510403f, 0.02587102f, 0.05455572f, 
    -0.01180681f, 0.04794928f, 0.00314152f, 0.03044104f, -0.04227609f, -0.04229267f, -0.00853274f, -0.02936783f, 
    -0.02227531f, -0.00761259f, 0.04932782f, 0.02093848f, 0.02073789f, -0.00243384f, -0.05360257f, 0.01987012f, 
    0.04981675f, 0.02599335f, 0.04184568f, -0.02033493f, -0.04457571f, -0.01865161f, 0.03041389f, -0.01496434f, 
    0.01541751f, -0.01916547f, -0.05752720f, -0.05201197f, -0.01150998f, 0.04385863f, 0.04300391f, -0.00324934f, 
    -0.00118214f, 0.04253950f, 0.00108137f, 0.03922745f, 0.03034886f, -0.05067344f, -0.01824821f, 0.04826715f, 
    0.02147369f, -0.04228381f, -0.01324464f, 0.03072587f, -0.05495786f, 0.01991070f, -0.05253636f, -0.00883800f, 
    -0.05281097f, -0.00002004f, -0.04088203f, -0.03534131f, -0.01263116f, -0.03298914f, -0.01876174f, 0.00055190f, 
    -0.02214744f, 0.04379519f, -0.04408735f, -0.00790364f, -0.00158293f, -0.01589228f, 0.01398916f, -0.00879887f, 
    0.02352784f, 0.05054038f, -0.00873947f, -0.01776745f, 0.04573378f, 0.01799205f, 0.03937119f, -0.04808265f, 
    0.05047255f, -0.00398364f, -0.05128072f, 0.01714196f, -0.04096125f, -0.05738097f, -0.04317171f, -0.03691707f, 
    0.03037835f, 0.02002011f, -0.05069230f, -0.00752387f, -0.03551888f, -0.01715508f, 0.04160615f, 0.03151004f, 
    -0.01423601f, -0.01024170f, -0.03233546f, -0.05111315f, -0.01569242f, 0.00857257f, 0.00506234f, 0.01356933f, 
    0.02539064f, -0.01516586f, -0.05781791f, 0.02572432f, 0.00669042f, -0.02520122f, 0.03491465f, -0.04084889f, 
    -0.04293688f, 0.03972638f, -0.04717582f, 0.04029532f, 0.01825120f, 0.01719537f, -0.05631228f, -0.03816187f, 
    0.03008874f, -0.00835948f, 0.02380111f, -0.05973063f, -0.00313635f, -0.00531980f, 0.01237495f, -0.05296649f, 
    0.03309904f, -0.01482219f, -0.04578800f, 0.03001358f, 0.04692751f, 0.03887989f, 0.03400155f, -0.02694384f, 
    -0.04153882f, -0.01334767f, -0.05129536f, 0.01161697f, -0.05879307f, -0.03607182f, 0.00616760f, 0.00977795f, 
    -0.03566093f, -0.01481229f, -0.00451435f, -0.01633090f, -0.04771369f, -0.00068251f, -0.05529020f, 0.02402947f, 
    0.05153074f, -0.03912859f, -0.05176944f, -0.01659808f, -0.02661007f, 0.00143170f, 0.00529788f, -0.03115788f, 
    -0.05032204f, -0.05585186f, 0.02965086f, 0.00756989f, -0.03879005f, -0.05634006f, -0.01861788f, 0.04845535f, 
    -0.03040822f, -0.03043430f, -0.00299419f, -0.01374498f, -0.03745177f, -0.01734689f, -0.05496578f, 0.03292888f, 
    -0.04790573f, -0.03291392f, 0.03973351f, 0.00288062f, -0.03582902f, -0.02194791f, 0.03634436f, 0.03431026f, 
    -0.05772379f, -0.02169383f, -0.02213270f, -0.05235067f, 0.02592069f, 0.03690746f, 0.04484625f, -0.04540817f, 
    -0.02410398f, 0.01962105f, -0.02000933f, 0.03690859f, 0.00197797f, 0.01416027f, -0.01965336f, -0.03250665f, 
    -0.05401390f, -0.03241883f, -0.00168212f, 0.02331908f, -0.02278493f, 0.03182771f, -0.03046626f, -0.00100209f, 
    -0.00778747f, 0.00875677f, 0.00278405f, 0.00439953f, 0.01076373f, 0.01846571f, -0.04662279f, -0.01881649f, 
    0.01545791f, 0.04656712f, -0.04354570f, 0.03613066f, 0.01843684f, -0.05450701f, 0.00913755f, -0.03018594f, 
    -0.00883091f, 0.04532246f, 0.04944330f, 0.04627685f, -0.00898667f, 0.02982122f, -0.04731379f, -0.04998535f, 
    -0.02359766f, 0.02079738f, -0.04624525f, 0.04975475f, -0.01262382f, -0.01215454f, 0.03755368f, -0.02245834f, 
    0.03503904f, -0.01519554f, -0.02465570f, -0.01411285f, -0.03587410f, -0.00815505f, 0.01977904f, -0.05316238f, 
    0.02814448f, -0.01148088f, 0.04351552f, 0.04557889f, -0.02004199f, 0.01897844f, 0.00131125f, -0.04292632f, 
    0.03845156f, 0.01713520f, 0.01215203f, -0.05698631f, -0.05796497f, 0.01298717f, 0.00173589f, 0.03676689f, 
    -0.05418034f, -0.01037797f, -0.06094745f, 0.02385406f, 0.00210801f, 0.01071701f, -0.04941873f, -0.00133781f, 
    -0.02058836f, 0.02156603f, 0.02999360f, 0.03290015f, 0.00524709f, 0.02657669f, 0.01812898f, 0.02976770f, 
    -0.06087786f, -0.01946797f, 0.00565638f, 0.00539724f, -0.04261195f, 0.01958483f, -0.04028980f, 0.00554713f, 
    -0.05024427f, 0.03142344f, -0.05699516f, 0.04285288f, 0.03860809f, -0.06000170f, 0.03273365f, -0.03738170f, 
    -0.03562025f, -0.00939432f, -0.00850512f, 0.00641720f, 0.01141397f, -0.01227184f, -0.00849765f, -0.02876451f, 
    -0.05707153f, -0.04896059f, -0.02436013f, 0.04601456f, 0.04038040f, 0.00441198f, -0.06146360f, -0.05204067f, 
    -0.02187899f, -0.02671136f, 0.05204646f, 0.03874872f, 0.03442346f, -0.04056510f, 0.01163217f, 0.00782771f, 
    -0.00265992f, 0.04392985f, -0.04031919f, -0.02405795f, 0.02936676f, -0.05519466f, -0.04650020f, -0.05838504f, 
    0.00962900f, -0.02967228f, 0.01029365f, -0.01452795f, 0.03205972f, -0.05635680f, 0.03082909f, -0.02313109f, 
    0.01623319f, -0.02532501f, -0.05748761f, -0.00721881f, -0.02028434f, -0.04528021f, -0.05739078f, 0.01038582f, 
    0.04585438f, -0.02006169f, -0.02446967f, 0.00466569f, -0.05843198f, -0.03718537f, 0.02256638f, 0.04237840f, 
    0.01153597f, 0.03144725f, -0.05199073f, -0.05502265f, -0.05430870f, 0.01785178f, 0.03304461f, -0.01012912f, 
    0.03609852f, -0.05610067f, 0.00329046f, 0.03206113f, 0.00503492f, -0.04108999f, -0.03188574f, -0.00698040f, 
    0.03161219f, -0.02661493f, 0.02987098f, 0.00029848f, 0.00509096f, 0.03072717f, -0.03527515f, 0.03575939f, 
    0.04152381f, -0.01632157f, 0.02519598f, 0.03414315f, 0.02198041f, -0.05865909f, -0.04938824f, 0.01400075f, 
    0.01418516f, 0.00619065f, 0.00656766f, 0.04081183f, 0.03138408f, -0.00748805f, 0.01259157f, -0.00889666f, 
    -0.05289814f, -0.04942121f, -0.01057473f, -0.01223950f, 0.02912866f, 0.03016668f, 0.02510423f, -0.00745840f, 
    0.05205788f, -0.04893386f, -0.00762593f, -0.03148153f, 0.02894063f, 0.04367271f, -0.05915407f, -0.04381282f, 
    0.03925723f, 0.03540807f, -0.01379509f, -0.00965997f, -0.00655631f, -0.01019352f, -0.02282295f, -0.04839790f, 
    -0.00708081f, 0.03117381f, -0.03704033f, -0.05307813f, 0.00217416f, -0.05507903f, -0.03413694f, 0.00001614f, 
    -0.02271015f, -0.02241026f, -0.02952658f, -0.04333621f, 0.04454168f, 0.02556328f, -0.04269138f, 0.04051792f, 
    -0.04735874f, -0.06219390f, 0.04081038f, -0.01562972f, -0.00441827f, 0.03479166f, 0.01825576f, -0.00463151f, 
    0.01194658f, -0.03391042f, 0.03091302f, 0.01191103f, 0.01483479f, -0.02748718f, -0.00308980f, 0.00592397f, 
    -0.04797476f, -0.00632726f, 0.01719687f, -0.01967975f, -0.01749204f, 0.01422453f, -0.03505952f, -0.04977396f, 
    -0.02431489f, 0.00680786f, -0.00836843f, -0.03821924f, -0.04050105f, 0.00520116f, 0.00034780f, 0.04664913f, 
    0.00449880f, 0.02342060f, 0.00742328f, -0.01888482f, -0.05056839f, -0.03653212f, -0.01913788f, -0.04656779f, 
    -0.02625660f, -0.03400376f, 0.00062386f, 0.04664495f, -0.03126016f, -0.04157472f, -0.00524521f, 0.02825302f, 
    0.03243943f, -0.04560346f, 0.03806353f, -0.01445314f, -0.04105494f, -0.04185868f, 0.00083252f, -0.02772323f, 
    0.02859433f, -0.03766399f, -0.02860970f, -0.01674783f, 0.05262307f, -0.00165775f, -0.05151747f, 0.03271323f, 
    -0.01810275f, 0.02140924f, -0.00917349f, -0.01681118f, -0.04971291f, -0.03210367f, -0.04902606f, 0.00259982f, 
    -0.01263643f, -0.00681998f, -0.06236821f, 0.02408095f, -0.04228803f, 0.03072517f, 0.02544496f, -0.03816407f, 
    -0.01631880f, -0.05591875f, 0.02189752f, 0.00444418f, 0.01316468f, -0.04967900f, -0.02268726f, -0.00743211f, 
    0.04557142f, 0.03450420f, 0.02839121f, 0.03560437f, 0.01942599f, -0.03294800f, 0.01101908f, 0.01554432f, 
    0.01311182f, -0.02669473f, -0.04522264f, 0.03823185f, -0.03310347f, -0.04133018f, -0.06132561f, -0.06213341f, 
    -0.04584883f, 0.01180731f, -0.06417169f, -0.05934953f, 0.01615810f, 0.04256133f, 0.03832916f, -0.01112221f, 
    -0.03484130f, 0.02104594f, -0.05325469f, 0.03133118f, 0.00400636f, -0.04146976f, -0.06220710f, -0.00308516f, 
    0.03924590f, 0.00908218f, -0.06128191f, -0.06209041f, 0.00080922f, -0.01012564f, -0.06337664f, -0.06004690f, 
    -0.02213822f, -0.00354277f, -0.00128712f, 0.01943568f, -0.01576389f, -0.01098874f, -0.03554017f, -0.01646505f, 
    0.04501323f, 0.03926083f, 0.01971678f, 0.00025587f, 0.03087592f, -0.04637304f, 0.01926898f, 0.01443880f, 
    0.03360474f, 0.01538162f, -0.06286017f, 0.04516426f, -0.01977348f, -0.00107358f, -0.01721188f, 0.03231768f, 
    -0.04397253f, -0.03684310f, 0.03951655f, 0.01821689f, 0.03326166f, -0.02427022f, -0.04097364f, 0.01937917f, 
    -0.03182454f, -0.00664228f, -0.05584936f, 0.00792120f, 0.02513584f, 0.04221015f, 0.03750172f, 0.02235277f, 
    -0.03578316f, -0.05880511f, -0.02294695f, 0.04012708f, 0.04112729f, 0.00537060f, -0.05012007f, -0.03657503f, 
    -0.05749310f, 0.00592202f, 0.04525480f, -0.02404169f, 0.00699001f, 0.03917309f, -0.04103922f, -0.03753841f, 
    0.03212925f, -0.00962579f, -0.05347775f, -0.04555558f, -0.01819819f, -0.03918939f, -0.04082299f, -0.05355608f, 
    -0.00750912f, 0.01795666f, 0.01087390f, -0.03738449f, -0.00035196f, -0.05372897f, -0.04871755f, -0.00532138f, 
    0.03667625f, 0.00573651f, -0.00409547f, -0.00353501f, 0.02702035f, -0.02929142f, 0.00980702f, 0.03559239f, 
    -0.01928461f, 0.00934793f, -0.06754887f, -0.02705045f, -0.04172385f, 0.03980448f, -0.01364679f, -0.05747493f, 
    0.01422634f, 0.03953625f, -0.05825005f, -0.05408685f, 0.02774684f, -0.00627904f, 0.01561934f, -0.04795770f, 
    -0.04067296f, 0.02140884f, -0.05930170f, -0.03256036f, 0.03929298f, -0.03320938f, -0.02349560f, 0.00234497f, 
    0.02499705f, -0.02671818f, 0.01348819f, 0.00418530f, -0.01599263f, -0.01016145f, -0.02869355f, -0.02229080f, 
    0.04365264f, -0.02815801f, 0.00263724f, -0.03746767f, 0.03012821f, 0.01557888f, -0.05971687f, 0.03084814f, 
    0.00676149f, -0.05587449f, 0.04131701f, 0.01802366f, -0.03777934f, 0.02143792f, 0.02049579f, -0.01472407f, 
    0.01057172f, -0.05589430f, -0.05249679f, 0.02791249f, 0.02563825f, 0.03909562f, 0.03263699f, 0.00633168f, 
    -0.03139778f, 0.02700118f, -0.04017125f, 0.02003119f, -0.01839444f, 0.02919902f, 0.02629868f, -0.05135700f, 
    0.02389923f, -0.01855989f, -0.01962959f, 0.03853303f, -0.03527915f, 0.02524221f, -0.03292450f, -0.01709764f, 
    -0.02121380f, -0.05503214f, 0.01683987f, 0.01773005f, 0.03572593f, -0.02855349f, -0.05725477f, -0.03099808f, 
    0.00012529f, -0.01317485f, 0.00961557f, -0.00380066f, -0.02921118f, 0.03947780f, 0.00933390f, -0.03086851f, 
    -0.01449272f, -0.01748102f, 0.02579452f, -0.02417926f, 0.01073879f, -0.03402475f, 0.02436878f, -0.05268607f, 
    -0.01889866f, -0.02722065f, 0.03334510f, 0.01815397f, 0.00083350f, -0.04476188f, 0.00850648f, 0.03355902f, 
    -0.03548548f, -0.03950766f, 0.02469669f, -0.02445563f, 0.00524048f, -0.02170279f, 0.00372275f, 0.04351512f, 
    0.04492883f, -0.03340250f, -0.03952903f, -0.03644248f, -0.05933693f, 0.03483493f, 0.03727023f, -0.03103802f, 
    0.03733205f, -0.01569312f, -0.02779336f, -0.01396354f, 0.01116694f, -0.00041606f, -0.04927530f, -0.04123123f, 
    0.01360593f, -0.03802847f, 0.02528582f, -0.01721223f, 0.04182129f, -0.05955299f, -0.03601619f, -0.04200582f, 
    -0.00678923f, 0.02308364f, 0.00970603f, 0.03646953f, 0.02913257f, -0.05700363f, 0.02952443f, -0.04222756f, 
    0.04223938f, -0.04704564f, -0.05735962f, -0.05920769f, -0.01765525f, -0.02701340f, 0.02321221f, -0.04102836f, 
    -0.01247185f, -0.02064853f, -0.05095856f, 0.00755766f, 0.01313591f, -0.06104699f, -0.04440076f, -0.02477662f, 
    0.00707626f, -0.03373371f, -0.03976475f, -0.00820903f, -0.03187520f, 0.01758189f, 0.04151700f, 0.02272776f, 
    -0.01235655f, -0.03392089f, 0.02308758f, 0.04591512f, -0.05548918f, -0.02544134f, -0.00117352f, 0.03154620f, 
    0.03130428f, 0.01056842f, 0.03377222f, -0.00467984f, -0.05731612f, -0.04989321f, 0.04345658f, 0.03305203f, 
    -0.02598560f, -0.03472827f, 0.01042303f, -0.02013175f, 0.00193258f, 0.03784422f, -0.02652708f, 0.01131933f, 
    -0.01508352f, -0.00744092f, 0.00869446f, -0.03169371f, 0.02927319f, -0.00511809f, 0.02612287f, -0.02140720f, 
    -0.03276366f, -0.01020997f, 0.02799451f, -0.03020091f, -0.03930830f, -0.06257910f, 0.03532450f, 0.00898319f, 
    0.04166389f, 0.02592704f, 0.01055804f, 0.03921204f, -0.02845480f, -0.06674170f, 0.01693255f, -0.00348836f, 
    -0.06292044f, 0.01822342f, -0.00453410f, -0.01578822f, 0.04348682f, 0.04591030f, -0.04526496f, 0.01127674f, 
    0.02443872f, -0.03624213f, 0.01937618f, -0.03349144f, 0.02268066f, 0.00965857f, -0.05148870f, -0.02571284f, 
    0.02454267f, 0.01869735f, -0.01251021f, 0.03782558f, 0.03407613f, 0.02950309f, -0.05577530f, -0.04558090f, 
    -0.03260509f, -0.02383856f, -0.01725197f, -0.02175799f, 0.00571028f, 0.02080181f, 0.01718827f, -0.02384081f, 
    0.00156934f, -0.06601472f, -0.03167573f, -0.04074015f, -0.01665775f, -0.02645897f, -0.00717432f, -0.05851818f, 
    -0.00614879f, -0.05486643f, 0.00031199f, 0.04361105f, 0.04440589f, -0.04129378f, -0.05452537f, -0.02615913f, 
    0.04292929f, 0.02298535f, 0.02848160f, 0.02530781f, 0.03900359f, -0.03747104f, -0.06168771f, -0.03046238f, 
    -0.03289280f, -0.05773883f, 0.04048644f, -0.06058495f, -0.06736310f, 0.00644969f, 0.01682964f, -0.06363765f, 
    0.02807587f, -0.03763588f, 0.02242809f, -0.02480120f, -0.00569049f, -0.05616087f, -0.04719127f, -0.04703600f, 
    -0.01723768f, -0.01940821f, 0.02220974f, -0.01856744f, 0.01433747f, -0.03123790f, -0.05982076f, -0.01609647f, 
    0.02037721f, -0.01314101f, 0.01404010f, -0.05005721f, 0.01070628f, -0.01056439f, -0.05055840f, 0.02094579f, 
    -0.02716848f, 0.02877376f, -0.01257783f, 0.01865210f, -0.05746953f, -0.04452014f, 0.03649560f, 0.02986806f, 
    -0.04737643f, -0.04965884f, 0.03731278f, -0.02020164f, -0.01052383f, 0.04027389f, -0.02943566f, 0.00371619f, 
    0.03156204f, -0.00115786f, 0.04222412f, -0.02304589f, 0.03655199f, -0.02327843f, -0.01283505f, -0.04993934f, 
    -0.03129683f, -0.05466344f, -0.02248277f, -0.03192402f, -0.00940528f, -0.03816647f, 0.04435166f, 0.02550060f, 
    -0.06276233f, 0.02013666f, 0.03542421f, -0.05771379f, -0.01932965f, -0.03351538f, -0.01380466f, -0.05433795f, 
    -0.02216059f, 0.02386390f, 0.03855904f, 0.04262287f, -0.02690853f, 0.03414394f, -0.05020562f, 0.04183015f, 
    0.01343451f, 0.04425226f, -0.02618552f, 0.00127553f, 0.03571899f, -0.03780851f, -0.06457142f, 0.02056831f, 
    0.02909596f, -0.03567363f, 0.03544158f, 0.03745767f, -0.05564744f, 0.03553513f, -0.04426495f, -0.03883591f, 
    -0.02885201f, 0.04379661f, 0.01780630f, -0.02141091f, -0.04253254f, -0.05383967f, 0.02446098f, 0.03992521f, 
    -0.01128543f, -0.05135659f, 0.03658677f, 0.00546107f, -0.03610157f, 0.02304405f, 0.03897520f, -0.01717646f, 
    -0.00209946f, -0.00310461f, -0.01363843f, -0.05413426f, -0.01449741f, -0.06752836f, 0.04460452f, 0.01793892f, 
    0.03699704f, -0.04860104f, 0.02694612f, 0.03082149f, -0.06284299f, -0.06067330f, -0.05045646f, 0.00161208f, 
    -0.02484738f, -0.00577017f, 0.04410382f, -0.05856496f, 0.03868645f, -0.03877714f, -0.03858904f, -0.00843609f, 
    0.01294621f, -0.01517472f, 0.00902249f, -0.05063583f, -0.05640744f, -0.02353161f, 0.01039286f, -0.04410184f, 
    0.02788712f, 0.03778421f, 0.00731811f, -0.06118154f, -0.03017782f, -0.04070520f, 0.04027902f, -0.03429273f, 
    -0.01770440f, -0.04231014f, -0.04178829f, 0.00700001f, 0.00545422f, 0.03412542f, -0.06219324f, -0.02773746f, 
    -0.03144055f, -0.01360878f, -0.04032825f, 0.03705608f, 0.04326029f, -0.00833536f, 0.00707224f, -0.00704651f, 
    0.00404430f, -0.00353892f, -0.05394611f, -0.00793532f, -0.05850371f, 0.01967433f, 0.02328426f, -0.02071990f, 
    -0.02351065f, 0.00605813f, 0.02555811f, -0.04060875f, 0.04318668f, -0.00547600f, -0.00063691f, 0.00936762f, 
    0.03946391f, -0.02118056f, -0.00009753f, -0.03404659f, 0.04159499f, 0.00148590f, -0.02906765f, 0.00690284f, 
    0.00901758f, -0.03184054f, 0.03088123f, 0.00445950f, -0.01929699f, -0.01957957f, 0.04150105f, -0.03313733f, 
    -0.04420827f, -0.04297637f, -0.05079462f, -0.05049542f, 0.01060205f, -0.05085891f, 0.02532115f, -0.02252263f, 
    -0.03216735f, 0.03009693f, 0.01293541f, -0.01073381f, -0.00573178f, 0.02881807f, 0.00738605f, -0.00507289f, 
    -0.02260811f, -0.01136911f, 0.03996461f, -0.05010390f, -0.05712620f, -0.01745010f, 0.01967103f, 0.02306614f, 
    -0.03974860f, 0.01239137f, 0.03681583f, -0.00111545f, 0.01893857f, 0.00538873f, -0.04454578f, -0.01740375f, 
    0.00318467f, -0.04056799f, 0.00223642f, 0.02824881f, 0.01430052f, -0.02527506f, -0.00678144f, -0.04981535f, 
    0.01246456f, -0.03863341f, -0.05199154f, 0.03656988f, 0.00569638f, -0.04156049f, 0.03596818f, -0.04162139f, 
    -0.01140931f, 0.04469826f, -0.01735770f, -0.04835533f, -0.03264869f, -0.00105104f, 0.00107977f, -0.04563588f, 
    -0.02011202f, 0.04335536f, 0.00453013f, -0.00969468f, 0.02610950f, 0.01264061f, 0.04752747f, -0.06140181f, 
    -0.05582315f, -0.00467107f, 0.02721330f, 0.00212559f, -0.04182787f, -0.01365372f, 0.01147273f, -0.04809061f, 
    -0.01052237f, 0.02165606f, 0.04543974f, -0.01905399f, -0.04807053f, 0.02906537f, -0.04895591f, -0.00933105f, 
    0.04335824f, -0.00881064f, -0.00277298f, 0.03515859f, 0.02156614f, 0.04878731f, -0.02218239f, -0.04940339f, 
    0.01944484f, -0.01794462f, 0.03858783f, -0.01476150f, -0.00922364f, -0.05812420f, -0.02233008f, 0.03099168f, 
    0.00627993f, 0.05183914f, 0.04902028f, 0.03792002f, -0.05243841f, -0.03965783f, -0.03773447f, -0.01349349f, 
    0.04561055f, 0.01886259f, -0.05062057f, 0.04291477f, -0.04632526f, 0.01960062f, 0.01223380f, -0.01600463f, 
    -0.03493122f, 0.01412034f, -0.02256546f, 0.00661603f, 0.00802720f, -0.03066104f, -0.00869256f, -0.04829607f, 
    0.02938129f, -0.04147511f, -0.06021049f, 0.01489280f, -0.01823802f, 0.00833798f, -0.02609877f, -0.01135568f, 
    -0.00483510f, -0.05781536f, -0.03502119f, -0.01325897f, -0.01658795f, -0.03719925f, 0.02326901f, 0.04639478f, 
    -0.02147316f, -0.03905024f, -0.01344793f, 0.04177249f, 0.03687634f, 0.03453423f, 0.03658657f, -0.03269232f, 
    -0.04571154f, 0.00225653f, 0.02925145f, 0.00236992f, 0.03785443f, 0.04893589f, -0.00171344f, -0.02757634f, 
    0.03569800f, -0.06066320f, -0.02511635f, 0.00720263f, 0.03317660f, 0.02309433f, 0.00762446f, -0.03389013f, 
    0.02446129f, 0.01786058f, 0.02135914f, -0.01632745f, -0.03982881f, 0.03122856f, -0.00363045f, -0.00453095f, 
    -0.01965300f, -0.02985718f, -0.01874476f, 0.03844505f, 0.02808396f, -0.00102343f, 0.00567794f, -0.01618394f, 
    0.01551206f, -0.04435928f, -0.02326480f, 0.01902882f, -0.03722268f, -0.03500013f, -0.02807402f, -0.04638219f, 
    0.01950800f, -0.05535461f, 0.04808031f, -0.00486372f, -0.01883630f, -0.00079299f, 0.01474751f, -0.04464689f, 
    0.00980254f, -0.04832243f, 0.02049368f, -0.05792552f, 0.03986443f, -0.00212066f, -0.00490237f, -0.00907808f, 
    0.00999865f, -0.03619875f, -0.00718707f, 0.03069742f, -0.05778840f, 0.00370944f, 0.03772745f, -0.00539161f, 
    -0.04663961f, 0.02747042f, 0.01672265f, -0.01727183f, -0.02758855f, -0.03894951f, -0.02196271f, 0.03553267f, 
    0.02015705f, 0.01010916f, 0.01204157f, -0.04644815f, -0.06150655f, 0.00141941f, -0.02937313f, 0.01706132f, 
    -0.05903156f, -0.01915740f, -0.04106684f, -0.00478362f, -0.01667858f, 0.03056704f, -0.05661846f, -0.01800101f, 
    -0.05416216f, -0.03087910f, -0.00582101f, -0.05700697f, -0.02588755f, -0.02938988f, -0.02353969f, -0.02568537f, 
    0.02828388f, -0.04119530f, -0.05298224f, 0.02986896f, -0.04261457f, -0.05619407f, 0.03431611f, -0.05404598f, 
    -0.04877298f, -0.02551736f, -0.02540672f, -0.06318794f, 0.02479435f, 0.02122442f, 0.00535872f, 0.02862912f, 
    -0.04519368f, -0.00422628f, 0.02141202f, 0.02369791f, -0.00264346f, -0.00388383f, -0.01980149f, -0.05783326f, 
    0.01058314f, 0.00291436f, 0.02117442f, -0.00921184f, 0.05762254f, -0.06005973f, 0.01963709f, 0.04949963f, 
    -0.02940941f, -0.01947210f, -0.05155673f, -0.04190782f, -0.00063200f, -0.02824097f, 0.04186689f, 0.00181214f, 
    -0.02453293f, -0.06007082f, -0.04288450f, 0.02415929f, -0.05268123f, -0.04550485f, 0.01558938f, 0.03708939f, 
    0.04949798f, -0.05738489f, -0.05772183f, 0.04922717f, 0.04799520f, 0.03392458f, -0.01444498f, -0.00955860f, 
    0.04246276f, -0.04186913f, -0.00024561f, -0.02739570f, 0.02947378f, 0.01908240f, -0.04535668f, 0.02692676f, 
    -0.01549464f, -0.01581169f, -0.00051836f, -0.04007564f, -0.04907881f, -0.02607955f, 0.04490082f, 0.02921853f, 
    0.03664912f, 0.04885064f, -0.05236991f, -0.05505225f, -0.02662535f, -0.02173123f, 0.03959584f, -0.00832995f, 
    -0.01128972f, -0.04023094f, -0.02330558f, -0.01637862f, -0.01433396f, -0.01627244f, -0.03259862f, -0.01398213f, 
    -0.00164578f, -0.05061524f, -0.00627228f, 0.03346020f, 0.03958047f, 0.04148637f, -0.02607555f, -0.01111550f, 
    -0.05812353f, 0.03695635f, 0.03670286f, -0.00802330f, 0.02385178f, 0.02718110f, -0.05728883f, 0.01625998f, 
    -0.03043728f, 0.03831256f, 0.04308457f, -0.03740638f, 0.01107768f, 0.02579813f, -0.02592404f, 0.03553745f, 
    0.02191726f, 0.00643200f, 0.00318930f, 0.03433783f, -0.00543606f, 0.01474541f, -0.01975687f, 0.03925630f, 
    0.10933566f, 0.11387075f, 0.03454071f, 0.14817904f, 0.16123214f, -0.22956638f, 0.15983056f, 0.02140797f, 
    0.11951571f, -0.02799172f, -0.06218863f, 0.12725158f, -0.06159792f, -0.08392236f, 0.13009220f, -0.06294414f, 
    0.08965172f, 0.16162382f, 0.09455067f, 0.10537067f, 0.31098059f, 0.09857481f, -0.20430735f, -0.02936874f, 
    0.31695449f, 0.16467391f, 0.02888162f, -0.00140034f, -0.02184224f, 0.06154710f, -0.00288482f, 0.05967560f, 
    0.03215934f, 0.00745616f, -0.04055078f, 0.12369152f, -0.01745623f, 0.03514798f, 0.24027479f, -0.02631362f, 
    0.13161573f, -0.11988673f, 0.06697288f, 0.10331613f, -0.04429308f, -0.01826356f, -0.02630348f, 0.06843916f, 
    0.00115700f, 0.10983191f, -0.12565173f, -0.04009595f, -0.14787595f, -0.00144129f, -0.04332865f, -0.05247410f, 
    -0.10974462f, -0.13352109f, -0.08926532f, -0.12659191f, 0.34476349f, -0.23282307f, -0.32741570f, -0.04300725f, 
    0.19129057f, 0.04720264f, -0.17503339f, -0.00699288f, 0.00282560f, 0.08974457f, 0.00515739f, 0.05720089f, 
    -0.05605718f, 0.10573746f, 0.09776955f, 0.04210189f, -0.01985512f, -0.06499126f, -0.06763103f, -0.08439398f, 
    0.11608069f, -0.12060361f, -0.18958010f, -0.03871774f, 0.11216204f, 0.03587046f, -0.08245708f, 0.02279728f, 
    0.00809917f, 0.07775360f, -0.00331144f, -0.01370278f, 0.19154103f, 0.02477989f, 0.07242285f, 0.08111542f, 
    -0.02631243f, 0.07134976f, -0.02314733f, 0.02855648f, -0.30829215f, -0.12947640f, -0.01507444f, 0.10503189f, 
    0.06053664f, 0.07080524f, 0.02842685f, -0.16929543f, -0.10421193f, 0.03298426f, 0.06497627f, 0.10002740f, 
    -0.00588499f, -0.01063656f, -0.08438861f, -0.07761736f, -0.16170362f, 0.02259725f, 0.02927612f, 0.04217559f, 
    0.09553467f, -0.13365547f, -0.13040602f, -0.01089933f, -0.00391188f, -0.04441850f, -0.05120763f, -0.02351727f, 
    -0.06173287f, -0.03514052f, -0.07527936f, -0.02975452f, 0.13142683f, 0.02698548f, 0.09579830f, 0.08639533f, 
    0.00275144f, 0.27419269f, -0.09939166f, 0.08640084f, -0.12070938f, 0.03444248f, -0.18155849f, 0.08784791f, 
    0.18686727f, -0.03241329f, -0.06025467f, -0.09957580f, -0.10593648f, 0.04657792f, -0.03749982f, 0.03197245f, 
    -0.04966211f, -0.03881188f, 0.03424864f, -0.02468347f, -0.02415798f, 0.00112279f, 0.12550880f, -0.05028636f, 
    -0.09161799f, -0.10864282f, 0.13056889f, 0.23546764f, -0.21147315f, -0.01502990f, 0.10300536f, 0.16839744f, 
    0.02898345f, 0.05834990f, 0.14586428f, 0.02436355f, -0.03007301f, -0.04953190f, -0.04487557f, -0.01062592f, 
    -0.04962564f, -0.14549467f, -0.10970902f, 0.06080097f, 0.03794198f, 0.12409804f, -0.13601868f, 0.10772344f, 
    0.04160640f, 0.00094226f, -0.11552626f, 0.04104391f, -0.03336874f, 0.01451129f, 0.02624787f, -0.08336427f, 
    -0.07717907f, -0.06616618f, 0.10605771f, 0.00002393f, -0.10706308f, 0.12492625f, 0.02769659f, 0.09297056f, 
    -0.43375060f, -0.17119308f, -0.23196861f, 0.11754304f, -0.10553148f, 0.17303470f, 0.15904938f, -0.13739018f, 
    0.09839704f, -0.05262347f, -0.07059385f, 0.04464786f, 0.02507485f, 0.03594382f, 0.01618536f, -0.05049134f, 
    -0.00728334f, -0.04066266f, -0.16437744f, 0.02111506f, 0.13073593f, -0.19012022f, 0.19715796f, 0.14070001f, 
    -0.18287751f, 0.09651409f, 0.06322357f, -0.07311323f, 0.01176925f, -0.09788021f, -0.02373702f, -0.00190634f, 
    0.03316123f, -0.11567665f, -0.09622468f, -0.04643042f, -0.01180687f, -0.00436884f, -0.04826023f, 0.07110686f, 
    0.02621310f, 0.19025196f, -0.05293365f, -0.03307815f, -0.11418162f, -0.01559965f, 0.07807641f, 0.09227270f, 
    -0.12233549f, 0.11214387f, -0.04606473f, 0.00581291f, -0.05338021f, 0.06014569f, -0.03541719f, 0.03843902f, 
    0.04700279f, 0.08223584f, -0.07956667f, 0.06412630f, -0.11358154f, -0.06912216f, -0.20270361f, -0.24328549f, 
    0.14632422f, -0.21657680f, 0.08448234f, 0.02180249f, 0.17369075f, 0.09369856f, -0.03874565f, -0.10050328f, 
    0.19194750f, -0.00960763f, 0.12253305f, 0.11656523f, 0.15578653f, 0.03275902f, 0.04957173f, 0.08333371f, 
    0.00447223f, 0.25697803f, 0.07467868f, 0.10433180f, -0.20373729f, -0.00998089f, 0.21676920f, 0.04269480f, 
    0.16351424f, -0.01145185f, -0.08448681f, 0.00981528f, -0.00118537f, 0.07953196f, 0.03730319f, -0.03692372f, 
    0.09110957f, 0.14182389f, -0.06634205f, 0.13730757f, 0.18246129f, -0.22973794f, 0.08863171f, 0.04103416f, 
    0.01503170f, -0.03294667f, 0.04658643f, 0.07831320f, 0.05677436f, -0.02821711f, -0.08336474f, 0.06654923f, 
    0.03069424f, 0.08643204f, -0.04727931f, 0.04084806f, 0.16279140f, 0.00830392f, 0.06201044f, 0.12234033f, 
    -0.09147042f, -0.37091511f, -0.01351998f, -0.21051247f, -0.28440168f, -0.18875222f, 0.05719392f, -0.03593463f, 
    0.12913096f, -0.17409517f, 0.21509956f, 0.24621506f, -0.12483870f, -0.15785863f, -0.08810990f, 0.10352472f, 
    0.00185235f, 0.15646701f, 0.27683651f, 0.12294848f, -0.01111916f, -0.23216747f, 0.19744459f, 0.00589256f, 
    0.30612460f, 0.12037682f, 0.02837422f, -0.00117277f, 0.00077446f, 0.01521868f, -0.00344880f, 0.02969816f, 
    -0.07628119f, 0.07251152f, -0.05679568f, 0.09474736f, 0.04159677f, -0.00977893f, 0.09458011f, 0.03620585f, 
    0.06213378f, 0.19767314f, -0.04937867f, 0.16109729f, 0.20130286f, -0.01873921f, 0.07284584f, 0.08395112f, 
    0.09622532f, 0.25673711f, 0.01731319f, 0.08306542f, 0.03839250f, 0.07015791f, 0.07343458f, 0.11844356f, 
    0.07043850f, 0.02372382f, -0.08967658f, 0.02194322f, 0.24877511f, 0.15700828f, 0.17075062f, -0.16046061f, 
    0.28345889f, 0.04502349f, 0.02716194f, -0.02097630f, 0.22472368f, 0.09073804f, 0.07300512f, -0.09130708f, 
    0.07722865f, 0.10511801f, 0.00709063f, 0.06482813f, -0.04908947f, -0.00150944f, -0.04992392f, 0.05050056f, 
    -0.22043248f, 0.14668658f, 0.51298511f, 0.25112242f, 0.27216688f, 0.03125162f, -0.15542397f, 0.00205168f, 
    0.10265215f, 0.06656345f, 0.01993340f, -0.00964398f, 0.00176556f, -0.02333085f, 0.13840401f, -0.09515625f, 
    -0.03765821f, 0.10167689f, 0.08050342f, -0.00508123f, 0.26952696f, 0.01030899f, 0.55133712f, 0.17022569f, 
    0.13244505f, -0.03488976f, 0.00182835f, 0.09097188f, 0.07622481f, 0.21072726f, -0.12022308f, -0.12673394f, 
    -0.01185388f, 0.03716713f, -0.15589043f, -0.03421947f, -0.09568679f, 0.06579236f, 0.04143089f, -0.12617989f, 
    -0.21393007f, 0.01384199f, 0.03430533f, -0.01499024f, -0.39200827f, 0.00949810f, -0.01534583f, -0.01723798f, 
    -0.10756051f, -0.10294928f, 0.07234503f, 0.17692477f, -0.08794542f, 0.06959250f, 0.09765240f, 0.09781697f, 
    0.11181132f, 0.27041876f, 0.07092686f, 0.07718490f, -0.00453229f, 0.39743415f, 0.18862268f, -0.12151814f, 
    -0.11511997f, -0.06100282f, 0.03065632f, 0.02497109f, 0.03365515f, 0.12213810f, 0.08192350f, 0.01775284f, 
    0.00643995f, 0.05481086f, 0.05623280f, -0.02658374f, -0.02582663f, 0.03933466f, 0.12251788f, 0.02353603f, 
    0.03303837f, 0.05434193f, -0.22524869f, -0.28064105f, -0.37104407f, 0.23630446f, 0.05425638f, 0.06914417f, 
    -0.07013676f, -0.10399786f, 0.17823033f, 0.01802681f, 0.08667026f, -0.11642049f, 0.00569597f, -0.03410816f, 
    0.09188607f, -0.02212767f, 0.01178052f, 0.07068972f, -0.13987248f, 0.07963029f, -0.08094209f, 0.04328300f, 
    -0.20948961f, 0.09598072f, 0.01332732f, -0.01493939f, 0.17578915f, -0.02466858f, 0.27566147f, 0.24020977f, 
    -0.13075049f, -0.00790042f, 0.12787279f, 0.09501738f, 0.06513314f, 0.13587300f, 0.09770073f, 0.20492236f, 
    -0.41555586f, -0.01574875f, -0.21606167f, -0.12816018f, -0.03470758f, 0.21517153f, 0.04162250f, 0.06723966f, 
    -0.08645078f, 0.15790078f, -0.08412009f, -0.05481259f, 0.03103957f, -0.09680707f, 0.01701253f, -0.10427772f, 
    0.02562181f, 0.04440523f, -0.06545483f, -0.11840155f, 0.23727369f, 0.01782160f, -0.10557558f, -0.20703076f, 
    -0.08309397f, 0.28767431f, 0.33042350f, -0.04063863f, 0.01835411f, -0.12480081f, 0.00507078f, 0.24991685f, 
    0.23848447f, 0.07105905f, 0.08877162f, -0.00144528f, -0.09370561f, 0.15874453f, -0.06284400f, -0.01617563f, 
    -0.27349696f, 0.56775147f, -0.24969888f, -0.17058039f, 0.00147628f, 0.08598096f, 0.06852620f, -0.01431299f, 
    -0.16985004f, -0.10029254f, 0.25811177f, 0.17262174f, 0.11786751f, -0.07272910f, 0.11267936f, 0.09163419f, 
    0.36545730f, 0.25172889f, 0.20452745f, -0.00057747f, 0.38976201f, -0.19407412f, -0.03168291f, 0.03541692f, 
    0.04690790f, -0.00854469f, 0.03235637f, -0.16913481f, 0.23418684f, -0.20405075f, -0.14068829f, -0.14225377f, 
    0.01322357f, 0.07593372f, -0.03147956f, 0.16470504f, 0.10756060f, -0.04593721f, -0.19359829f, 0.07116643f, 
    -0.02284098f, 0.16728613f, -0.07307452f, 0.08383270f, -0.29626521f, 0.16564518f, 0.06393985f, 0.02558720f, 
    -0.07425357f, -0.02317949f, 0.12337655f, 0.08831351f, 0.03761044f, 0.13737239f, -0.00250940f, 0.19669527f, 
    0.16745071f, 0.03827193f, -0.06039840f, 0.05842331f, 0.51970333f, -0.07637608f, -0.05033552f, 0.09048431f, 
    -0.02941976f, 0.02600874f, -0.08806748f, -0.08734701f, 0.03944300f, 0.09263335f, -0.11634740f, -0.00110128f, 
    0.08232980f, 0.11216307f, -0.05153698f, 0.04154259f, 0.16614959f, -0.07613670f, -0.03070680f, 0.07638854f, 
    -0.17840767f, -0.16905604f, 0.11673603f, -0.07323381f, 0.05395879f, 0.10150699f, 0.07097428f, -0.04020900f, 
    0.04496467f, 0.09029502f, -0.11381187f, 0.00998086f, 0.07367417f, 0.20536767f, -0.03751792f, 0.06548491f, 
    0.14661159f, -0.09230638f, -0.00644597f, 0.03958415f, -0.02529719f, -0.06580879f, -0.26868257f, 0.04070625f, 
    -0.20465322f, -0.00171681f, 0.08623954f, 0.00060289f, 0.17162649f, -0.04562032f, -0.05085931f, 0.05384669f, 
    0.14897844f, 0.03120171f, 0.06719916f, 0.11028445f, -0.03629541f, 0.09894395f, 0.07468294f, 0.05752086f, 
    0.10281530f, 0.19985709f, 0.00400071f, 0.03193024f, 0.00788963f, 0.06687015f, 0.04403974f, 0.04251268f, 
    -0.01071898f, 0.06446621f, 0.05984006f, 0.04458167f, -0.04500321f, -0.10493891f, -0.13840416f, -0.00646747f, 
    -0.06688235f, 0.02431578f, 0.06461238f, 0.05237963f, 0.07843784f, -0.22952300f, 0.00539077f, 0.19498615f, 
    0.01215746f, -0.02880572f, 0.02622528f, 0.04851417f, -0.10256013f, 0.23240130f, 0.04491188f, 0.12737833f, 
    0.09088534f, -0.01844803f, -0.00961865f, -0.00295243f, 0.08278082f, 0.02803129f, 0.03464133f, -0.04433177f, 
    0.05668738f, 0.09448288f, -0.26776019f, -0.25103465f, -0.00877621f, 0.17006503f, 0.07860751f, 0.02997460f, 
    -0.02947154f, -0.04864105f, 0.11438630f, 0.02894146f, -0.02869409f, 0.04233296f, -0.01175338f, 0.17257594f, 
    -0.09127015f, -0.02393100f, -0.11244205f, 0.08463144f, 0.00373603f, -0.30367085f, -0.18488069f, -0.00043011f, 
    0.08596139f, 0.23562117f, 0.02729203f, -0.14766565f, 0.15093040f, 0.06542648f, 0.23353560f, 0.16254885f, 
    0.02563263f, 0.00457561f, 0.18144932f, 0.13702510f, 0.06362614f, -0.10426201f, -0.13318686f, 0.10371833f, 
    -0.12709634f, -0.30029848f, -0.14952876f, -0.20988409f, 0.17196579f, 0.10342184f, 0.05632994f, 0.03026494f, 
    0.08907922f, 0.14336778f, 0.15978320f, 0.01729733f, 0.05786745f, 0.01453194f, -0.04752246f, 0.03995886f, 
    -0.05551721f, 0.03609395f, 0.08568397f, 0.06493871f, -0.05342247f, -0.11704639f, -0.14099921f, -0.01950141f, 
    0.11608126f, 0.11289483f, 0.09231910f, 0.06652336f, 0.11124238f, 0.05917269f, 0.18024395f, 0.10735443f, 
    0.07005229f, -0.01559596f, 0.06024270f, 0.08071758f, -0.08789683f, -0.01394332f, 0.06237082f, 0.11603003f, 
    0.09562525f, 0.79028565f, 0.31596765f, 0.41774768f, 0.26374507f, 0.05006620f, 0.03608815f, 0.09900689f, 
    0.12180733f, 0.08661782f, -0.00162598f, -0.01272299f, 0.04573646f, 0.11359042f, 0.05027213f, -0.05470988f, 
    -0.03486419f, 0.10480854f, 0.01193979f, -0.15003712f, -0.26711413f, -0.08047321f, 0.12777540f, -0.22928013f, 
    0.08533658f, -0.01133025f, -0.00002026f, 0.09733074f, -0.01198665f, 0.04758372f, 0.05543908f, -0.02546745f, 
    0.14258750f, 0.17291348f, 0.04139209f, -0.12168331f, -0.07608557f, 0.05655983f, 0.06803033f, 0.01456703f, 
    0.71078765f, 0.17964733f, 0.36042839f, 0.20954536f, 0.37674004f, 0.06983612f, 0.04444062f, 0.10347062f, 
    0.07365278f, 0.03531703f, 0.05867040f, 0.02733134f, -0.02911452f, 0.16775337f, 0.15502098f, -0.02019651f, 
    0.02872819f, -0.00110469f, 0.07523785f, -0.01356690f, 0.25341254f, 0.15694667f, 0.15544614f, 0.33165568f, 
    0.08192878f, 0.05924252f, -0.09246765f, 0.08546559f, -0.06980714f, 0.13199553f, -0.02235446f, -0.01077095f, 
    0.02668695f, -0.00878468f, 0.03370928f, -0.01522498f, 0.06972398f, -0.08535974f, -0.02054611f, 0.03215665f, 
    0.24868840f, 0.45420057f, 0.08896172f, -0.00128559f, -0.15395197f, 0.03641904f, -0.17235544f, 0.12736349f, 
    0.22274305f, 0.00944333f, -0.02558249f, -0.16901630f, 0.00149283f, 0.20230098f, -0.08749319f, -0.01617096f, 
    -0.01779901f, -0.01448408f, -0.05491957f, -0.02728813f, -0.18520927f, 0.05174191f, 0.10213292f, -0.49157652f, 
    -0.15832269f, 0.03664310f, 0.04981032f, 0.07579243f, -0.05382181f, 0.12361857f, 0.25626069f, 0.08056850f, 
    0.11265650f, 0.07786879f, 0.04266911f, 0.01198606f, 0.13540182f, 0.04823327f, 0.05280621f, -0.04803775f, 
    0.06224905f, -0.10934180f, 0.18753782f, 0.07171074f, 0.06880690f, 0.02240464f, 0.08611505f, 0.07489149f, 
    0.03623451f, 0.02421073f, 0.00799064f, 0.06080072f, 0.07268669f, -0.14865309f, 0.05974773f, 0.05662223f, 
    0.09339618f, 0.08865356f, 0.04567794f, 0.05350692f, -0.20586948f, -0.11578293f, 0.05750330f, 0.03622257f, 
    0.12631901f, -0.04182155f, 0.22245778f, 0.05225033f, 0.04074528f, 0.04025947f, 0.07876135f, 0.02953988f, 
    0.04685316f, 0.04329217f, -0.00754562f, 0.13463598f, 0.01642651f, 0.15604259f, 0.02361321f, 0.08486062f, 
    0.16957851f, 0.35020867f, -0.20825404f, 0.08248564f, 0.22081520f, 0.24874081f, -0.10839502f, 0.04815371f, 
    -0.16838171f, 0.09134296f, -0.04026025f, -0.15857986f, -0.04596845f, 0.06367263f, -0.06248481f, 0.12197452f, 
    -0.05080745f, -0.05686449f, 0.05835463f, -0.08471236f, -0.25791079f, 0.19555578f, 0.20001882f, 0.10813361f, 
    -0.09247573f, -0.05441950f, 0.08661833f, 0.05296522f, 0.13076997f, 0.05735733f, -0.08464120f, -0.02766993f, 
    0.13716128f, 0.04160305f, 0.09789749f, -0.00301009f, -0.04315289f, -0.00146231f, -0.07733421f, 0.11495378f, 
    -0.17451520f, 0.05233813f, -0.00250365f, -0.29569247f, 0.07126696f, 0.11081424f, -0.04978638f, -0.09383176f, 
    -0.02434632f, -0.05378098f, 0.07659642f, 0.00093855f, 0.09105475f, -0.03971757f, 0.05663616f, -0.04058126f, 
    0.08413684f, 0.06285542f, -0.01622978f, 0.04364637f, -0.30136970f, 0.00382621f, 0.09751497f, 0.17108266f, 
    -0.27520838f, 0.02615183f, 0.11934906f, -0.02740589f, -0.08192381f, -0.06195194f, -0.03515886f, 0.04090274f, 
    0.02279963f, -0.09050865f, -0.00577556f, -0.03872195f, -0.03518313f, 0.10498589f, -0.06506980f, 0.08562061f, 
    0.26304370f, -0.06938023f, 0.04337752f, -0.13864984f, -0.20040916f, -0.05336021f, 0.03900475f, 0.01631544f, 
    -0.10242330f, -0.07777210f, 0.12762856f, 0.10750067f, -0.03879752f, -0.04077826f, -0.13990590f, 0.01857654f, 
    -0.00876714f, -0.02661887f, 0.03039831f, 0.07633068f, 0.55600232f, 0.04315812f, -0.38705945f, -0.18871263f, 
    -0.21631755f, -0.17437795f, 0.01519928f, 0.12944306f, 0.01499228f, -0.06187835f, -0.05361927f, -0.02108964f, 
    0.09106617f, 0.04772897f, 0.04221784f, -0.02380916f, 0.14918694f, -0.07684341f, 0.00548973f, 0.07676081f, 
    0.27200565f, 0.01903117f, -0.01091285f, 0.11466002f, 0.45736653f, -0.05338328f, 0.08446799f, -0.00079905f, 
    0.01301980f, 0.08546840f, 0.00251387f, 0.07295822f, -0.12696315f, -0.03723141f, -0.16807778f, -0.04932096f, 
    0.00790722f, -0.15712926f, 0.14497128f, -0.10871477f, -0.08003431f, -0.13368474f, 0.06472651f, -0.07295536f, 
    -0.15351962f, 0.06718385f, 0.04720906f, 0.09279621f, -0.07839888f, -0.04275841f, -0.00693765f, 0.05360280f, 
    0.07730786f, 0.08621933f, 0.06577922f, 0.06887943f, 0.01075500f, 0.06502753f, 0.00569770f, -0.00023767f, 
    0.00729873f, 0.08683238f, -0.13095371f, -0.10422963f, 0.21007404f, 0.06046521f, -0.10884878f, -0.24366453f, 
    0.05858736f, -0.06192930f, -0.00311412f, -0.00903924f, 0.00162519f, 0.22410555f, 0.06894057f, 0.11046249f, 
    0.07417030f, 0.02188400f, -0.03015088f, -0.01981251f, 0.35201269f, -0.05106116f, 0.14208096f, -0.01928278f, 
    0.25604773f, -0.00875550f, 0.01282620f, 0.02776848f, 0.01805707f, 0.02694379f, -0.11339712f, -0.07031613f, 
    0.12116548f, -0.01451614f, 0.05519852f, 0.09249593f, 0.03776772f, -0.02712908f, -0.02762312f, -0.10383442f, 
    0.18294001f, -0.08326862f, 0.07959566f, -0.20385382f, -0.04074630f, -0.24080288f, -0.04565996f, -0.08726423f, 
    -0.03225457f, 0.11578356f, 0.09001829f, 0.03511541f, -0.00555132f, 0.02892842f, 0.04740421f, 0.01337277f, 
    -0.03592632f, -0.01048185f, 0.03056594f, 0.05053437f, -0.17216350f, 0.09031249f, 0.01304148f, 0.10417500f, 
    0.26936033f, -0.00682296f, 0.01151724f, -0.04661430f, 0.17864433f, 0.13733104f, 0.22057219f, -0.01872586f, 
    -0.18060622f, 0.08746923f, 0.04569812f, 0.02169835f, 0.05574318f, -0.04107804f, 0.05635054f, 0.05939337f, 
    0.22435181f, -0.14751118f, 0.15234591f, 0.04509576f, 0.40132621f, 0.04336686f, -0.01387184f, -0.07835964f, 
    0.10276733f, 0.03339360f, 0.03316925f, -0.03372605f, 0.02304757f, 0.11423995f, -0.05722262f, 0.09368318f, 
    -0.02440555f, -0.05562334f, -0.05307290f, 0.02696872f, 0.03103563f, 0.17325453f, 0.07050284f, 0.26456240f, 
    -0.00208303f, -0.00783185f, -0.04701182f, 0.15668783f, -0.13187554f, -0.01733867f, 0.10464121f, 0.11228582f, 
    -0.06866927f, 0.06435569f, 0.00964430f, 0.00254747f, -0.02764872f, 0.10742138f, 0.19683804f, 0.01939648f, 
    0.11333580f, -0.15474047f, -0.14664210f, 0.08367916f, 0.20212945f, -0.19575062f, -0.08545283f, -0.07824341f, 
    0.02080136f, -0.02783026f, 0.00237159f, -0.02851659f, 0.14128089f, -0.06767838f, 0.00734604f, -0.11374796f, 
    -0.13237919f, -0.11756763f, 0.13095546f, -0.01646663f, -0.46738687f, 0.19367744f, -0.09653008f, 0.05382070f, 
    0.05773560f, 0.07477579f, 0.08656510f, -0.07003045f, -0.05255109f, 0.04784309f, -0.04412556f, 0.01941198f, 
    -0.00694232f, -0.09911875f, -0.04514000f, 0.05163732f, -0.16971534f, 0.12671140f, 0.04489177f, -0.06151403f, 
    0.26560801f, 0.18017347f, -0.12739046f, -0.00223948f, 0.03241386f, -0.09598112f, 0.04315307f, -0.01285808f, 
    -0.08278210f, 0.02622580f, -0.01488383f, 0.00717044f, -0.09850147f, 0.01435076f, 0.12281745f, 0.09231364f, 
    0.04361538f, 0.14066741f, 0.08983169f, 0.09106184f, -0.09303391f, 0.04125755f, 0.12525342f, -0.07667799f, 
    0.04218688f, 0.17547281f, 0.02650350f, -0.03332080f, 0.00196716f, 0.05300490f, -0.04960553f, -0.00674290f, 
    0.01658961f, 0.00845625f, -0.07791907f, 0.10576790f, -0.19747275f, 0.01602441f, 0.15655388f, 0.06004869f, 
    -0.32623371f, -0.06453723f, 0.18512206f, 0.18136235f, 0.29026279f, -0.03552633f, -0.11109581f, 0.07525902f, 
    0.06833528f, 0.24995849f, 0.00953822f, -0.04167968f, 0.06727472f, 0.10488211f, 0.00527835f, 0.08825874f, 
    0.12795939f, -0.00402114f, -0.13790794f, -0.21973786f, 0.15647906f, -0.32410175f, -0.22447863f, 0.03677756f, 
    -0.06768675f, -0.11077054f, -0.01212237f, -0.05325831f, 0.24078700f, -0.11837965f, 0.03873123f, -0.03616124f, 
    0.02314756f, -0.05306067f, 0.07171755f, 0.02084927f, -0.05716989f, 0.01613383f, -0.11887781f, 0.11983263f, 
    -0.32794341f, -0.22526692f, 0.11991410f, -0.42264777f, 0.14722903f, 0.06269011f, -0.25216287f, 0.10889480f, 
    0.02800534f, 0.00290977f, -0.04726674f, -0.01703121f, -0.01342827f, 0.01118980f, -0.01477890f, 0.02722777f, 
    0.06267995f, 0.05362131f, 0.07857248f, 0.06937155f, 0.16328177f, -0.17532890f, 0.06766410f, -0.03168068f, 
    0.01490600f, -0.27712470f, -0.00191558f, 0.20061150f, -0.01273081f, -0.15691760f, -0.00447611f, -0.00042919f, 
    0.10524246f, 0.09036516f, 0.08410142f, -0.00315964f, 0.01044654f, 0.13375333f, 0.01134453f, 0.08868036f, 
    0.16448125f, -0.05692670f, -0.01623801f, 0.00572191f, 0.05483218f, -0.22144911f, 0.08800833f, -0.11379948f, 
    -0.04264387f, -0.05729928f, 0.12174019f, 0.05963589f, -0.02547837f, -0.00547201f, -0.13073747f, 0.07978709f, 
    0.05664665f, 0.12796335f, 0.02218821f, 0.14965209f, -0.44754151f, 0.18981509f, 0.06558161f, -0.13710465f, 
    -0.09108425f, -0.04039295f, 0.08586349f, 0.12623033f, -0.11810426f, -0.00729997f, 0.12881021f, -0.00765249f, 
    0.08397970f, 0.04523377f, 0.05196909f, -0.10238849f, 0.03227837f, -0.08432857f, -0.07231412f, -0.13127355f, 
    -0.43947092f, 0.32086843f, -0.14822319f, 0.11836112f, 0.11778136f, -0.14678706f, 0.09609199f, -0.07176814f, 
    0.06908041f, 0.10029975f, 0.07499041f, 0.03948467f, 0.00005004f, 0.00268305f, 0.06441146f, 0.02600887f, 
    0.07302333f, -0.14350760f, 0.10646961f, 0.03576133f, 0.40942365f, -0.02777129f, -0.11593045f, 0.13279663f, 
    -0.06840081f, 0.17611231f, 0.02929644f, -0.07225224f, -0.02797634f, -0.08435162f, 0.03493914f, -0.06022208f, 
    -0.07400323f, -0.02609528f, 0.00940224f, 0.08695995f, -0.02612969f, 0.14133614f, -0.10221762f, 0.04362159f, 
    -0.40724629f, -0.22257563f, -0.25136760f, -0.05089420f, 0.07484737f, -0.09868086f, -0.04011698f, -0.13971151f, 
    0.02453989f, 0.02726311f, -0.15708946f, -0.11489543f, 0.12366045f, -0.03417360f, -0.00539722f, 0.02181583f, 
    -0.04549788f, -0.01980232f, -0.13613877f, -0.04931946f, 0.10010048f, 0.37920848f, -0.27627710f, 0.38013738f, 
    -0.12002157f, 0.16252193f, 0.07478195f, -0.10179174f, 0.12114038f, 0.02016192f, -0.00857383f, 0.04380403f, 
    0.08412147f, 0.08661588f, -0.03897846f, -0.05088582f, -0.05926102f, 0.03464245f, -0.00256103f, -0.16951966f, 
    -0.08800831f, 0.16537793f, 0.21787462f, 0.00815035f, 0.27570274f, 0.17556930f, 0.24398039f, 0.00508055f, 
    -0.00132141f, 0.12098974f, 0.17401345f, 0.05817226f, 0.21791942f, -0.08730554f, -0.20061547f, 0.07117525f, 
    0.21460412f, 0.10347369f, 0.15471207f, 0.11125065f, -0.34739202f, -0.44739607f, -0.30718097f, -0.01316313f, 
    -0.02795741f, -0.03647231f, -0.03837007f, 0.12908825f, 0.13276538f, -0.07362890f, 0.00097134f, 0.00611325f, 
    -0.08789130f, -0.00546394f, 0.01795094f, -0.10681864f, 0.20492585f, 0.09217995f, 0.00420170f, 0.05063121f, 
    0.37176600f, -0.08014960f, -0.16535485f, 0.43565223f, -0.15858778f, -0.06879877f, 0.02760204f, -0.00844825f, 
    0.04772167f, -0.02662655f, 0.09784973f, 0.04622018f, 0.01500831f, 0.01975174f, -0.00651000f, -0.03038465f, 
    -0.07392188f, 0.16330799f, -0.09411606f, 0.06612922f, 0.37628698f, 0.32949609f, 0.10902032f, 0.06773799f, 
    -0.05234380f, -0.08250365f, -0.01269603f, 0.09350813f, -0.01814732f, 0.02064980f, -0.04195911f, -0.04623347f, 
    -0.20483568f, 0.04697939f, -0.03474702f, -0.10048584f, 0.02983987f, 0.19452880f, 0.06997498f, 0.11593589f, 
    -0.19016896f, 0.06761052f, -0.03200981f, 0.12620041f, -0.00178163f, 0.20993586f, -0.04693880f, -0.00843777f, 
    -0.01736736f, 0.00429897f, -0.09279765f, 0.03264806f, 0.05616107f, 0.10653814f, 0.02753629f, 0.03979174f, 
    0.10262900f, 0.06722394f, -0.17033660f, -0.05022216f, 0.21454887f, -0.09184300f, 0.05219318f, -0.01254609f, 
    -0.47636566f, -0.05696743f, -0.09539769f, -0.06744462f, -0.04501678f, 0.04555149f, -0.02044400f, 0.10848273f, 
    0.05131437f, -0.04282937f, 0.06249100f, -0.11991221f, -0.03311954f, 0.08866037f, -0.09598781f, 0.06897969f, 
    0.15035653f, -0.03467508f, -0.02219305f, -0.05537067f, -0.11955890f, 0.02962405f, -0.06320511f, -0.04037061f, 
    -0.00446735f, -0.14941843f, 0.09462956f, 0.03218769f, 0.02187961f, 0.05731632f, -0.06276813f, 0.04168763f, 
    -0.07832096f, -0.00000509f, 0.20803562f, 0.05456729f, 0.21798879f, -0.08924050f, 0.22214432f, 0.00041564f, 
    -0.22642744f, 0.03323601f, -0.06447338f, 0.04971268f, -0.13625100f, 0.09880061f, 0.07039824f, 0.06779429f, 
    0.06502355f, 0.03152702f, 0.01878793f, -0.00125248f, 0.13647775f, -0.08311720f, 0.09362601f, -0.07691644f, 
    0.19796602f, -0.05727214f, -0.35634983f, -0.00172271f, -0.21370262f, -0.10586113f, 0.09335566f, -0.00700632f, 
    0.04415337f, 0.00539564f, 0.06642940f, 0.03934827f, -0.05260376f, 0.00104131f, 0.10634884f, 0.11932766f, 
    -0.05207175f, 0.05627193f, -0.07138274f, 0.11704257f, -0.03992872f, 0.22902159f, -0.22201365f, -0.13740318f, 
    -0.00582224f, 0.14736111f, 0.01265284f, -0.17320566f, -0.00525132f, 0.11176746f, 0.16675833f, 0.16654474f, 
    0.00744505f, 0.04582112f, 0.16045740f, 0.07768355f, 0.06479599f, -0.04272459f, -0.01346526f, -0.00239230f, 
    -0.22403583f, -0.18470706f, 0.15345472f, -0.04774855f, -0.11036532f, 0.15739825f, 0.05800436f, 0.03659667f, 
    0.13495187f, 0.11371537f, -0.04023159f, -0.00798924f, 0.00501122f, -0.09683286f, 0.02848542f, 0.01568506f, 
    -0.06009214f, -0.00725626f, -0.11824401f, 0.08862929f, 0.38953239f, -0.24460922f, -0.04392165f, 0.07775197f, 
    -0.03734628f, -0.04800070f, -0.12360462f, -0.07145733f, 0.07376941f, -0.01856672f, 0.01863386f, 0.04506375f, 
    -0.06894887f, 0.01130111f, 0.10051788f, 0.07197499f, -0.01152819f, 0.01695138f, 0.01578950f, 0.15825070f, 
    -0.12247080f, -0.15905881f, 0.13562664f, 0.05228315f, 0.39005157f, -0.02608543f, 0.01772666f, 0.04733382f, 
    0.03739319f, 0.01504313f, -0.21148142f, 0.02293331f, 0.03185256f, 0.11674237f, -0.01000736f, 0.01198089f, 
    0.07334338f, 0.02241344f, -0.03707450f, -0.11004296f, -0.19489826f, -0.00138630f, 0.24996191f, -0.11408159f, 
    -0.04824467f, -0.00973952f, 0.02910597f, 0.01423850f, -0.06391744f, 0.02702115f, -0.10864832f, -0.05535707f, 
    0.01939749f, 0.02703273f, -0.04750607f, 0.07333213f, -0.03902857f, 0.01206846f, -0.00812166f, 0.05520686f, 
    0.42783678f, 0.27252874f, 0.27267867f, 0.03967109f, 0.09999357f, -0.04809075f, 0.02190855f, 0.05700090f, 
    0.03965545f, -0.15570246f, -0.10337076f, 0.09207609f, 0.06031861f, 0.13051236f, 0.04855794f, 0.20270954f, 
    -0.05346240f, -0.01651036f, 0.09655801f, 0.16978993f, 0.01440433f, 0.29883033f, 0.13998018f, -0.22557209f, 
    0.12244240f, -0.09877985f, -0.10394008f, 0.22834530f, -0.00291265f, 0.05406075f, 0.06270428f, -0.12304214f, 
    0.05020196f, 0.05046511f, 0.07092337f, 0.05070434f, 0.03146451f, 0.06829879f, -0.01632366f, -0.05508531f, 
    -0.05142601f, -0.33270559f, 0.14769836f, 0.02547567f, -0.09706222f, -0.03619684f, -0.09316511f, 0.10385969f, 
    0.04167690f, 0.00779035f, -0.06712192f, -0.17228752f, -0.00459386f, 0.04545656f, -0.08566114f, -0.11671371f, 
    -0.18685566f, 0.01320423f, 0.03240590f, -0.05361627f, -0.25141415f, 0.05211580f, 0.02280607f, 0.15288195f, 
    -0.16340388f, 0.05780148f, 0.07441545f, -0.01994330f, -0.02434285f, 0.26028803f, 0.02512801f, 0.01863936f, 
    -0.04720031f, 0.11518997f, 0.11752407f, 0.06786248f, 0.00796464f, 0.03897680f, 0.09870496f, -0.16403924f, 
    0.09957047f, -0.10611045f, 0.12530974f, -0.01584486f, 0.39783075f, 0.00709616f, -0.03576962f, 0.00856243f, 
    -0.03607620f, 0.05543842f, 0.03929010f, -0.02080940f, 0.01590688f, 0.00191435f, 0.03516024f, 0.08737734f, 
    0.04165282f, 0.02960537f, 0.09152772f, 0.02971854f, 0.32515383f, 0.07543593f, 0.03186179f, -0.12448516f, 
    0.18257958f, 0.06204107f, -0.03052030f, -0.05428689f, 0.05873310f, 0.08205135f, 0.06264935f, -0.04097000f, 
    -0.00476628f, -0.08192975f, 0.00952867f, 0.01164543f, -0.01092342f, 0.01888397f, 0.00927102f, 0.02837459f, 
    0.19206844f, -0.14383860f, 0.07678725f, -0.03428538f, -0.06429786f, 0.15987861f, 0.24226934f, 0.11171245f, 
    0.13680178f, -0.04299628f, 0.11816224f, 0.10104620f, 0.13716942f, 0.05081882f, 0.08521520f, -0.04917409f, 
    -0.04625529f, 0.06807861f, -0.07217406f, 0.09683713f, 0.17780069f, 0.16708678f, 0.12250765f, -0.14465113f, 
    -0.56990254f, 0.02831782f, 0.01661969f, -0.13924485f, 0.06800126f, 0.02488809f, 0.10594613f, -0.07477386f, 
    -0.03452810f, 0.06263132f, -0.17296378f, 0.06931563f, 0.01611848f, 0.00797682f, 0.05708811f, 0.05056222f, 
    0.14059494f, 0.35644487f, 0.05600040f, -0.03426165f, 0.04400935f, 0.02834793f, 0.08780327f, 0.14518107f, 
    0.01186387f, -0.19558063f, -0.11477701f, 0.04469311f, -0.15100807f, -0.05341627f, 0.18832426f, 0.11416098f, 
    0.02029592f, -0.05389629f, 0.10377616f, 0.08468460f, 0.23785058f, 0.30907586f, -0.25406170f, -0.19632444f, 
    0.22606976f, 0.03352614f, -0.11094864f, 0.06710792f, -0.04662087f, 0.05264022f, -0.02230012f, 0.09708963f, 
    -0.03777032f, 0.14433810f, 0.14150417f, 0.05867494f, 0.01505557f, 0.02701810f, 0.07542515f, -0.08026165f, 
    0.04533850f, -0.11956332f, 0.03802782f, 0.42691866f, -0.03093400f, -0.03656940f, -0.09520817f, -0.18854070f, 
    0.10670839f, 0.33856601f, -0.08211788f, 0.00945788f, 0.11066850f, 0.09842316f, 0.17823128f, -0.10752494f, 
    0.19855116f, 0.07271355f, 0.04697268f, -0.13567300f, -0.19620886f, -0.14511372f, -0.00885077f, 0.33149812f, 
    0.03745380f, 0.03160711f, -0.10457662f, -0.06687061f, -0.00684365f, 0.19095218f, -0.02903782f, 0.01331217f, 
    -0.08138117f, -0.01433585f, -0.04125012f, -0.05540737f, -0.12301067f, 0.11087751f, -0.00096172f, -0.01066796f, 
    -0.09242908f, -0.02279276f, 0.07441059f, 0.05582468f, -0.41858679f, 0.14649375f, 0.01487047f, 0.17283803f, 
    0.06816869f, -0.13975804f, -0.11746448f, -0.01686574f, -0.03367785f, -0.02026055f, 0.14220482f, -0.15001133f, 
    -0.00063381f, 0.04985208f, 0.04819071f, 0.05374931f, 0.53490239f, 0.14608301f, 0.11587149f, 0.20207563f, 
    0.10623341f, 0.11759881f, 0.05555307f, 0.03051964f, 0.17780550f, 0.16769901f, -0.14471732f, -0.19729176f, 
    -0.04980604f, -0.06262181f, -0.06101313f, 0.11321101f, -0.07735831f, 0.06862904f, 0.10962524f, 0.02522159f, 
    0.22513032f, -0.37061143f, 0.24514100f, 0.24186377f, 0.29466918f, -0.12614550f, 0.01602688f, 0.05215659f, 
    0.05400923f, 0.06907975f, 0.00782885f, -0.01621678f, -0.02145416f, -0.03353314f, -0.06892866f, 0.07179053f, 
    0.03178875f, 0.00574725f, -0.02841746f, -0.20896783f, -0.25592691f, -0.01233170f, 0.08774463f, 0.00597810f, 
    -0.09127773f, -0.02771594f, 0.19804755f, 0.00545576f, -0.01083599f, -0.09240124f, 0.05539808f, 0.00057728f, 
    0.05159425f, -0.03984995f, 0.03302623f, 0.10527604f, 0.09129468f, -0.06874213f, 0.01771369f, 0.05712079f, 
    0.37306067f, 0.45800751f, 0.11155859f, 0.21206501f, 0.25157252f, 0.04115390f, -0.03335677f, -0.05506965f, 
    -0.03162883f, -0.09012029f, 0.01135151f, 0.03171683f, 0.02329071f, -0.01293848f, -0.10705509f, -0.04357045f, 
    0.07654171f, 0.08787873f, -0.01230979f, 0.05851114f, 0.30238119f, -0.26344231f, -0.15622860f, -0.21039815f, 
    0.08053931f, -0.03186230f, -0.08194770f, 0.01234163f, -0.13995956f, -0.17321394f, -0.03435854f, 0.19025940f, 
    0.15538464f, -0.13924330f, 0.08701457f, 0.07967286f, -0.00365767f, -0.07323337f, 0.07952079f, 0.02668151f, 
    0.07523979f, -0.88894975f, 0.10203891f, 0.08166649f, -0.60330570f, -0.13047610f, -0.08462326f, 0.07326960f, 
    -0.10417522f, -0.19090378f, 0.05834626f, 0.22362562f, -0.09805437f, 0.12916185f, 0.02287848f, 0.00380448f, 
    -0.04870761f, 0.08166694f, -0.11045026f, 0.02837636f, -0.35570383f, -0.30487806f, -0.25304842f, -0.26032418f, 
    0.27969095f, -0.03286902f, 0.08366438f, -0.23076163f, -0.00548078f, -0.09305381f, -0.00225980f, 0.09812636f, 
    -0.00253149f, 0.01755038f, 0.01132459f, 0.01913284f, -0.12002921f, 0.01848543f, 0.09878658f, 0.04914602f, 
    -0.16577874f, -0.24030615f, 0.19432357f, -0.09696575f, 0.00254828f, 0.02235350f, -0.05881350f, -0.13168205f, 
    -0.05107952f, 0.10441791f, 0.03732478f, -0.05868175f, 0.08049374f, 0.03081931f, 0.11053357f, -0.06539930f, 
    0.03574428f, 0.03821133f, 0.05709461f, -0.01427607f, -0.07999031f, 0.03300802f, -0.44911918f, -0.21405964f, 
    0.29928574f, 0.02648324f, -0.00383820f, 0.02401422f, 0.04025454f, 0.12076031f, 0.10758539f, 0.08004086f, 
    0.04404778f, 0.02954197f, 0.10959197f, 0.04592690f, 0.03784082f, -0.00926807f, -0.04865630f, -0.05778012f, 
    -0.04504790f, -0.03952489f, -0.01488440f, 0.02588381f, -0.05547087f, -0.01815780f, -0.03357196f, -0.00612483f, 
    -0.01143104f, 0.03035171f, -0.02512564f, -0.05095253f, -0.01347337f, -0.01960354f, -0.02338943f, 0.04907167f, 
    0.00308473f, 0.00771156f, 0.01885965f, -0.03761554f, 0.02978485f, -0.01100226f, 0.00489389f, -0.02949631f, 
    0.03032955f, 0.04586656f, -0.05248640f, -0.02775965f, -0.03409711f, -0.03636559f, 0.00472941f, -0.03939568f, 
    -0.05528166f, -0.01367038f, 0.04129073f, -0.01661354f, 0.03416537f, 0.00511018f, 0.03550446f, -0.03345364f, 
    -0.03148071f, -0.01715549f, -0.01549037f, -0.03888616f, -0.02853644f, 0.01493910f, -0.03719050f, -0.05482649f, 
    -0.05024366f, -0.03098708f, -0.04170985f, -0.03042902f, 0.01086246f, 0.01417203f, 0.04344884f, 0.04475822f, 
    -0.05665131f, -0.04841018f, -0.05082933f, -0.04921686f, 0.02233987f, 0.04411945f, -0.02838149f, -0.05876470f, 
    -0.00368448f, -0.02042909f, 0.03877922f, -0.01269920f, -0.04652478f, 0.04757741f, -0.05715285f, -0.02394387f, 
    0.00353380f, -0.03598121f, 0.03650994f, 0.00011064f, -0.02837656f, 0.00544804f, 0.01534011f, 0.02801605f, 
    -0.05615566f, 0.03374001f, -0.03953704f, 0.01817485f, -0.05701247f, -0.03533057f, 0.00458659f, 0.00501055f, 
    -0.01855141f, 0.01769985f, -0.03871834f, -0.05635059f, -0.05479652f, 0.03296384f, 0.03673327f, -0.03317173f, 
    -0.03357005f, -0.03492690f, -0.04835210f, 0.00274865f, -0.03254948f, 0.01551277f, 0.00167361f, 0.01735618f, 
    0.03067892f, -0.02311088f, -0.01222510f, -0.02498589f, -0.01364950f, -0.04170337f, 0.03065198f, 0.01693627f, 
    -0.02847433f, -0.01451152f, 0.01626719f, -0.01961008f, 0.01678465f, 0.00919039f, 0.04244358f, -0.04347818f, 
    0.04430303f, 0.04382617f, 0.05079515f, -0.03632707f, -0.03702868f, -0.05752886f, 0.00869557f, -0.02144331f, 
    0.01978569f, 0.02894889f, 0.00807979f, 0.02680814f, 0.04791127f, 0.02668043f, 0.01443261f, 0.02468492f, 
    -0.03135940f, -0.01700527f, -0.03780677f, 0.02844416f, -0.00470402f, 0.01255982f, -0.03242816f, 0.02724967f, 
    -0.00832410f, 0.00629535f, -0.03907125f, -0.04788608f, -0.05191185f, -0.01112068f, 0.01075481f, 0.03835968f, 
    -0.05440689f, 0.03364804f, -0.05187079f, -0.04409425f, -0.02192068f, -0.01387967f, 0.01774082f, -0.00229120f, 
    0.01315320f, -0.05511090f, 0.04130115f, -0.04972690f, 0.01482280f, 0.04282545f, -0.05739781f, -0.04387806f, 
    0.04141558f, -0.05192298f, 0.04902207f, -0.00852966f, 0.04744293f, 0.01728348f, 0.00355109f, 0.05441096f, 
    -0.03664377f, 0.05000590f, 0.05290796f, -0.00863909f, 0.02380186f, -0.04105901f, 0.04861860f, -0.02668926f, 
    -0.05161639f, 0.01071916f, -0.03854724f, -0.02613485f, -0.00010469f, -0.03820751f, -0.00160749f, 0.02555960f, 
    -0.04442778f, -0.01070784f, -0.04791879f, 0.04220390f, 0.04650024f, -0.01635929f, -0.02320789f, 0.01103514f, 
    -0.02016160f, -0.02425458f, 0.02831676f, -0.00863261f, -0.01708622f, 0.02745035f, -0.04333578f, -0.01835829f, 
    -0.05408702f, 0.04192748f, -0.02812004f, 0.00217497f, -0.04196103f, -0.00292824f, -0.00304516f, -0.02160112f, 
    -0.02899900f, 0.04595243f, -0.00313629f, -0.03143842f, 0.02700353f, 0.01392102f, 0.01592135f, -0.01800439f, 
    -0.03401871f, -0.05413421f, -0.05686869f, 0.04822675f, 0.05534684f, -0.04636477f, 0.01572693f, -0.00181821f, 
    -0.04049954f, 0.01615809f, 0.03946013f, -0.04006726f, 0.04276088f, -0.03628035f, 0.00163245f, -0.00109847f, 
    -0.04722477f, 0.04751817f, -0.00353302f, 0.02045113f, -0.03987258f, -0.02202373f, 0.02516290f, 0.02372950f, 
    -0.01657799f, 0.00788639f, -0.01666775f, 0.00029484f, -0.04670315f, -0.01217387f, 0.05216328f, 0.00143048f, 
    -0.00607272f, 0.01728732f, -0.00197913f, 0.04195115f, -0.00351162f, -0.01078286f, -0.04773874f, 0.02977443f, 
    0.01385393f, 0.04229579f, -0.03914610f, 0.01176273f, 0.05412418f, 0.04459965f, 0.00718715f, -0.01181821f, 
    -0.02650151f, -0.05350716f, 0.05008062f, 0.03983413f, 0.03612411f, 0.02602548f, 0.00343034f, 0.02867892f, 
    0.04561176f, 0.02783517f, -0.01711753f, 0.05231929f, -0.01411288f, -0.03368771f, 0.03023921f, 0.02655062f, 
    0.01431791f, 0.03569138f, -0.04535201f, -0.05105186f, 0.02147514f, -0.05097527f, 0.01071766f, -0.02081405f, 
    0.05139102f, 0.00140252f, 0.03451886f, -0.02516870f, 0.04588805f, -0.02373593f, -0.01088784f, -0.01614318f, 
    0.03038337f, -0.03040017f, 0.04494885f, 0.00449862f, 0.02858737f, -0.01390597f, -0.04235514f, -0.04757338f, 
    -0.04559976f, -0.02609406f, 0.02747374f, 0.01164440f, 0.03495602f, -0.02817423f, -0.01391480f, 0.04944695f, 
    0.02358520f, -0.02140934f, 0.01845347f, 0.01588667f, 0.03530221f, -0.03844700f, 0.02558006f, 0.05460538f, 
    0.04376249f, -0.00449030f, 0.00111177f, -0.03266475f, 0.03023350f, -0.05173287f, -0.03983223f, 0.04612682f, 
    -0.04470584f, -0.01195451f, -0.06101215f, 0.00913329f, 0.00410823f, -0.01116223f, -0.02966202f, 0.00395066f, 
    0.02809346f, 0.04733823f, -0.00843564f, -0.05984807f, 0.03958332f, -0.00263342f, -0.03360238f, -0.03006451f, 
    0.01650669f, 0.03461073f, -0.01162732f, -0.06164341f, 0.01569117f, 0.01091427f, -0.00880468f, 0.00607054f, 
    0.04640214f, 0.02926881f, 0.00938958f, -0.04380903f, -0.03176327f, -0.00739679f, -0.05944089f, 0.04555834f, 
    -0.01772633f, 0.02899751f, 0.00714219f, -0.01566983f, 0.01749049f, -0.06304966f, -0.03576769f, 0.04282108f, 
    0.01552420f, -0.02712327f, -0.02524781f, -0.06018580f, 0.03377051f, -0.04569784f, -0.01985489f, -0.05364083f, 
    -0.04998614f, -0.02374766f, -0.01211811f, -0.04041479f, -0.01184803f, 0.01890706f, -0.02562819f, -0.04031505f, 
    0.01691880f, -0.02102971f, -0.03136424f, 0.02433504f, 0.00315607f, -0.03433650f, 0.02316897f, 0.03362963f, 
    0.02539690f, -0.03612687f, -0.03662879f, 0.00558676f, 0.01842139f, -0.04422114f, 0.00851065f, 0.02795954f, 
    0.04050764f, 0.01102418f, -0.00393855f, -0.05906065f, 0.01785781f, 0.01671147f, 0.02945617f, 0.00524093f, 
    0.02439208f, -0.05267091f, 0.02435773f, 0.03017686f, -0.01874820f, 0.01619510f, -0.04522005f, 0.04742619f, 
    0.01570128f, -0.00235322f, -0.06237324f, 0.05035026f, 0.00904896f, -0.01535856f, 0.02519026f, 0.02864608f, 
    -0.03000557f, 0.00590132f, -0.02584296f, -0.00080075f, -0.02653763f, 0.03873374f, -0.02166026f, -0.00237174f, 
    -0.01240342f, -0.04085429f, -0.01489347f, -0.05291586f, 0.00722174f, 0.02504290f, 0.00247672f, -0.03915773f, 
    0.00223159f, -0.00583116f, -0.01071127f, 0.01299684f, -0.00856743f, 0.04383494f, -0.01334648f, -0.02840874f, 
    0.04505366f, -0.02156154f, 0.03962345f, -0.04246480f, 0.02292491f, -0.02858805f, 0.04002925f, -0.02344685f, 
    -0.01436752f, -0.05287709f, -0.05212479f, 0.00376924f, -0.05524836f, -0.04493473f, -0.03492214f, -0.03220524f, 
    0.04254624f, -0.03434491f, -0.03339105f, 0.00414732f, -0.05364713f, 0.02629279f, -0.00040017f, -0.03809531f, 
    0.00342104f, -0.02981071f, 0.02242003f, -0.02021775f, -0.01530052f, 0.02411032f, -0.02371705f, -0.03483270f, 
    0.00374743f, -0.03412704f, 0.01840573f, 0.02180563f, -0.01620901f, -0.05471526f, 0.03829188f, -0.05177951f, 
    -0.01035525f, -0.05282072f, 0.03986466f, -0.01216486f, 0.03228761f, -0.04331723f, 0.02591287f, 0.02372654f, 
    -0.04965885f, -0.02021329f, 0.03185912f, 0.03066880f, 0.05793089f, 0.02172572f, -0.01689612f, 0.04447275f, 
    -0.02583428f, 0.04513754f, 0.01210360f, -0.02854132f, 0.01076396f, -0.00831248f, 0.03204842f, -0.06226799f, 
    -0.02117890f, 0.05194293f, -0.02480494f, -0.03001836f, -0.05409015f, 0.03207554f, -0.02998550f, 0.02500168f, 
    0.00138821f, 0.04712516f, -0.06181983f, -0.03201966f, 0.04356317f, -0.02180052f, -0.00039258f, -0.05337285f, 
    -0.04448843f, -0.00352003f, 0.02864020f, 0.00445057f, -0.01901847f, -0.04270869f, 0.02611614f, 0.00950138f, 
    -0.05695954f, -0.00417145f, 0.00949022f, -0.05212849f, -0.01171535f, -0.03942748f, 0.01378008f, 0.04431312f, 
    -0.05100092f, -0.02372078f, 0.04292194f, 0.01709407f, -0.04026199f, -0.03055918f, 0.01568385f, -0.00412552f, 
    0.02745975f, 0.02275457f, 0.00642828f, -0.03981390f, -0.02293183f, -0.01359625f, 0.00156056f, -0.04605127f, 
    0.04249379f, -0.04904026f, -0.01999511f, 0.00230328f, 0.03957235f, -0.04490479f, -0.02086539f, 0.02833315f, 
    0.02323263f, 0.03476597f, -0.01985452f, -0.03921716f, -0.03765421f, 0.01277388f, 0.00578118f, -0.00124061f, 
    -0.04540183f, -0.05211638f, 0.00119820f, -0.03582630f, -0.01040253f, -0.01695801f, -0.02175947f, 0.02227313f, 
    -0.00160149f, 0.00908452f, -0.04765958f, 0.00717584f, -0.03632309f, -0.05635930f, -0.03418034f, 0.01320866f, 
    -0.05147885f, 0.03353062f, -0.03662883f, -0.05644263f, -0.03058174f, 0.03010549f, -0.04045904f, -0.01321574f, 
    -0.05122573f, 0.05104028f, 0.00860659f, 0.04881229f, -0.01198276f, -0.02558337f, 0.03719362f, 0.03154520f, 
    0.03495039f, -0.04842903f, 0.03392119f, -0.05185692f, 0.05376047f, -0.05331944f, -0.00658843f, -0.03494535f, 
    -0.02541381f, 0.04386814f, -0.01850917f, 0.02336628f, -0.05269789f, -0.02501453f, -0.01070919f, -0.04260329f, 
    -0.05984278f, -0.01017630f, 0.00970219f, 0.03517368f, 0.03457825f, 0.02726240f, -0.00340956f, -0.01578051f, 
    0.04743167f, 0.01827520f, -0.03688965f, -0.05462025f, 0.01748122f, 0.01906840f, -0.01840892f, -0.04981558f, 
    -0.01033674f, -0.03871889f, 0.02787875f, -0.04894586f, -0.02403356f, 0.00276577f, -0.00612225f, -0.05484726f, 
    -0.02967456f, -0.02276511f, -0.03733952f, 0.03578690f, -0.05707963f, -0.02395187f, -0.02621037f, -0.01167244f, 
    0.03927694f, -0.04322560f, 0.01023556f, -0.04610197f, 0.04383616f, -0.05837391f, -0.02811853f, -0.06571990f, 
    -0.02085993f, -0.03482581f, -0.03222339f, 0.02392025f, -0.03283989f, 0.00187531f, -0.01674807f, -0.01782922f, 
    0.02352649f, -0.06204747f, -0.05267226f, 0.00913767f, 0.02557106f, 0.02029420f, 0.00472659f, -0.06114466f, 
    0.03676341f, -0.02818417f, -0.03115251f, -0.04936615f, 0.04248590f, 0.01496711f, 0.00925152f, -0.02536677f, 
    -0.05674620f, 0.01978426f, -0.04445872f, -0.00700034f, 0.02603623f, -0.01088799f, -0.06031665f, 0.02956937f, 
    0.02564706f, -0.02037118f, -0.05742009f, -0.00291247f, -0.03084084f, 0.04513281f, 0.00313398f, 0.02660036f, 
    0.04366125f, -0.04565594f, -0.03462399f, 0.03812621f, 0.04155193f, -0.04997991f, 0.04727855f, -0.04560754f, 
    0.01656715f, -0.03337124f, 0.04200032f, -0.03875656f, -0.01500930f, -0.03073190f, 0.00828499f, 0.00460339f, 
    -0.05485051f, 0.03278948f, 0.00183936f, 0.00819286f, -0.01913862f, -0.01328956f, 0.04412968f, -0.03835758f, 
    0.00046481f, -0.00772784f, 0.03966913f, 0.00414109f, -0.03624475f, 0.03847132f, -0.01749422f, 0.03302803f, 
    0.04151451f, -0.03650809f, 0.04163415f, -0.02712708f, -0.05811732f, -0.03222358f, -0.01798754f, -0.02555276f, 
    0.03536576f, 0.01037924f, 0.01230831f, 0.02046691f, 0.02009972f, 0.03065219f, -0.02020878f, 0.02934790f, 
    0.00780122f, 0.02607826f, -0.01011795f, 0.02503535f, -0.01611526f, 0.02960239f, 0.00360045f, -0.00558322f, 
    -0.05235841f, 0.03964833f, 0.03828985f, 0.04274305f, -0.00571657f, -0.06333078f, -0.05255975f, -0.00133476f, 
    -0.01603515f, -0.05448687f, -0.01465186f, -0.01361199f, -0.03342308f, -0.02519266f, -0.00170079f, -0.04156031f, 
    -0.01729021f, -0.05107769f, 0.00478871f, 0.01444360f, 0.04735081f, -0.00591854f, 0.02194760f, -0.02331050f, 
    0.00505875f, -0.04174242f, 0.00167830f, 0.01505620f, -0.00826608f, -0.01630893f, 0.04011472f, 0.03781567f, 
    -0.00086203f, -0.02006237f, 0.02426282f, -0.00986566f, -0.00486506f, 0.03500732f, 0.00041415f, 0.03181764f, 
    0.01768830f, 0.02397580f, 0.03778460f, 0.03731716f, 0.03090836f, 0.04454840f, -0.00278027f, 0.04437722f, 
    0.00640469f, 0.00954524f, -0.01425701f, 0.01876607f, 0.03166595f, 0.00751202f, -0.03480093f, -0.05109365f, 
    -0.01698505f, -0.04411978f, -0.02610477f, -0.03569361f, 0.03284072f, -0.05757893f, 0.03235509f, -0.00935578f, 
    -0.05476745f, -0.05504246f, -0.02948418f, -0.03571045f, -0.00253730f, 0.03413758f, 0.02102209f, 0.01810504f, 
    0.03093210f, 0.00325688f, -0.00943972f, 0.04498589f, 0.05085786f, -0.01159868f, -0.06112286f, 0.02279440f, 
    -0.01712877f, -0.03058610f, -0.05145193f, 0.01679407f, -0.02019055f, -0.01413924f, 0.00146079f, 0.00008086f, 
    -0.00582280f, -0.06118378f, -0.02040905f, -0.01644027f, 0.03280575f, 0.01340427f, -0.01188978f, 0.02940334f, 
    -0.06604811f, 0.01805852f, 0.01086066f, 0.00701127f, -0.02881921f, 0.00356812f, 0.02323052f, -0.02229438f, 
    0.01317792f, -0.02057444f, -0.01205860f, 0.00176547f, 0.00578338f, -0.06473839f, 0.04628859f, -0.02060205f, 
    0.01342802f, -0.00946766f, 0.00929277f, -0.00701900f, 0.00655658f, -0.01463597f, -0.05339011f, -0.06245656f, 
    0.00544887f, -0.04907756f, 0.04343060f, -0.03576254f, -0.02651333f, 0.00291764f, 0.02978277f, -0.02472534f, 
    -0.02867775f, -0.01090313f, -0.02720891f, -0.03734528f, 0.03052810f, 0.00832462f, -0.03012095f, -0.04942030f, 
    -0.05667972f, 0.03220049f, -0.06235322f, 0.00101723f, 0.03442402f, -0.05475059f, 0.04731277f, -0.00987678f, 
    -0.04638681f, -0.00224628f, -0.03701974f, 0.04452614f, 0.03519855f, 0.01313185f, 0.00706690f, 0.02142620f, 
    0.02192064f, -0.05606417f, 0.02748778f, -0.00459826f, 0.02380407f, 0.01192766f, -0.04892575f, 0.03000997f, 
    -0.01968476f, -0.04905117f, -0.02144029f, -0.00271082f, -0.00488144f, -0.01336616f, -0.02155939f, 0.00426465f, 
    0.02948200f, 0.00335279f, -0.04000632f, -0.05114292f, -0.00932591f, -0.03562983f, 0.03001287f, -0.00912918f, 
    0.02006233f, -0.05088828f, 0.04314969f, -0.02537484f, -0.03273235f, 0.00946319f, -0.00122247f, 0.01898779f, 
    -0.03009508f, 0.01564525f, -0.05871948f, 0.01425745f, -0.05633075f, -0.04440730f, -0.05765729f, 0.02978347f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.03846499f, -0.02173404f, 0.01248643f, 0.08065962f, 0.04594095f, 0.03651338f, 0.10477890f, -0.00673004f, 
    0.21710332f, 0.02102634f, -0.07878526f, 0.07507004f, 0.03766320f, -0.05522259f, -0.02770422f, -0.05196869f, 
    0.01542176f, -0.03414681f, -0.03545009f, -0.00476173f, 0.02395236f, -0.04059833f, 0.02305630f, -0.02716818f, 
    0.11826143f, -0.00784120f, 0.00378880f, -0.00554220f, 0.07000048f, -0.01456932f, -0.04698339f, 0.01266148f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.03742074f, 0.25512549f, 0.02371924f, 0.25529915f, 0.09323568f, -0.08467570f, -0.23714033f, -0.08720971f, 
    0.34580535f, -0.00484852f, -0.29812825f, -0.02674141f, -0.14727803f, -0.03309973f, -0.39855236f, -0.03043692f, 
    -0.41766772f, 0.08058182f, 0.17302102f, 0.16262928f, 0.08604746f, -0.13788295f, -0.00700916f, 0.04891517f, 
    0.32812983f, -0.36628219f, -0.20455901f, 0.40609935f, 0.34696206f, -0.07418288f, 0.06745015f, 0.05061830f, 
    0.15130141f, -0.01357507f, 0.10017382f, -0.53405643f, -0.15075839f, -0.17367947f, -0.46846098f, 0.09522338f, 
    0.15067856f, -0.04943383f, 0.21839082f, 0.18793075f, -0.16032465f, 0.05191661f, 0.07113216f, -0.09236991f, 
    0.07606784f, 0.04213130f, -0.11994578f, -0.00794862f, -0.00347501f, -0.07063533f, -0.37160015f, -0.07450252f, 
    0.11895506f, 0.37489691f, -0.25118425f, 0.09116527f, 0.11579211f, 0.10027526f, -0.05446684f, 0.11335422f, 
    -0.03674211f, 0.37395352f, -0.04987776f, -0.27063334f, 0.35365257f, -0.16292785f, -0.11957760f, -0.03232975f, 
    -0.21054542f, -0.02218104f, 0.04920062f, -0.07628257f, -0.06897254f, -0.07417610f, -0.33708361f, 0.03734361f, 
    0.57940394f, 0.13900410f, 0.12902740f, -0.12810622f, -0.16360024f, -0.15378299f, 0.28641501f, 0.19872390f, 
    0.11592370f, -0.46308985f, -0.01318909f, -0.10079561f, 0.25832695f, 0.05087597f, 0.06498108f, -0.06190213f, 
    -0.06630854f, 0.15576403f, -0.02487291f, -0.04424129f, -0.10459743f, 0.07676321f, 0.35036010f, -0.12537169f, 
    -0.00633202f, -0.04774610f, -0.43794271f, 0.30510113f, -0.10144041f, -0.08610978f, 0.01461367f, -0.03603815f, 
    0.23799258f, -0.06335000f, -0.13647813f, -0.04339399f, 0.16012649f, -0.07407237f, 0.16249886f, 0.11307832f, 
    -0.08951742f, 0.16367622f, 0.58629602f, -0.50518596f, 0.07609650f, 0.03491593f, -0.05281646f, -0.03929727f, 
    -0.15391217f, 0.18263614f, 0.15939729f, 0.17649232f, -0.23685494f, 0.00968977f, -0.23076239f, -0.12963517f, 
    0.22634231f, -0.15067925f, 0.06404503f, 0.28392860f, -0.16750945f, 0.06348906f, -0.09470402f, -0.10700554f, 
    0.18571517f, -0.01088335f, -0.11880745f, 0.04742144f, 0.10736057f, 0.13447186f, -0.41292059f, -0.09015416f, 
    0.08889402f, 0.35648990f, 0.45304608f, 0.25667953f, -0.15736833f, -0.08801495f, -0.05926893f, -0.11580452f, 
    0.12124131f, 0.43652350f, -0.10199174f, 0.05852007f, 0.42639223f, -0.02609918f, 0.09629139f, -0.12011293f, 
    0.08094519f, 0.13289349f, 0.21920149f, -0.29520139f, 0.05726347f, -0.09271065f, 0.30155283f, 0.11493803f, 
    -0.29775360f, -0.05581966f, 0.08059113f, -0.13576832f, -0.03810934f, -0.04209388f, 0.28953260f, 0.06076487f, 
    -0.11847714f, -0.25183132f, 0.26900420f, 0.13113417f, -0.46769699f, -0.14658326f, -0.06689400f, -0.15510280f, 
    0.12534809f, 0.15191576f, -0.07285117f, -0.11484870f, 0.05480280f, 0.16534902f, -0.06574832f, -0.16335393f, 
    -0.16405429f, -0.04497095f, -0.16154233f, -0.12501021f, -0.00297925f, -0.07194893f, -0.10615122f, 0.05344072f, 
    -0.08242340f, -0.13490164f, 0.08594476f, -0.06741520f, -0.02408472f, 0.09941476f, -0.08227344f, -0.13330303f, 
    -0.10141446f, 0.05038380f, -0.05193695f, -0.10756323f, 0.12302290f, 0.04511567f, -0.03784616f, 0.00084445f, 
    0.08672163f, -0.16537070f, 0.04738218f, -0.11093558f, 0.01817317f, -0.17498077f, -0.07772098f, 0.11839743f, 
    -0.04658436f, 0.11443461f, -0.12004173f, -0.12917964f, 0.08052726f, 0.11609600f, 0.02023070f, -0.09648113f, 
    -0.16789123f, 0.00814538f, -0.07117252f, -0.02322947f, 0.00985094f, 0.01600457f, 0.02274217f, -0.05530962f, 
    -0.01801221f, 0.03423928f, -0.13332345f, 0.06776242f, -0.06937498f, -0.09663054f, -0.13587095f, 0.11810457f, 
    0.02512213f, -0.17087583f, -0.06442038f, -0.08799314f, 0.09730151f, 0.16377750f, -0.06097769f, 0.07266214f, 
    -0.04792790f, -0.07842035f, -0.02856150f, -0.09289001f, 0.14953086f, 0.06692405f, 0.13020690f, -0.17331074f, 
    0.10354500f, 0.04741074f, 0.09994261f, -0.06493077f, 0.03279912f, -0.08752170f, -0.14404131f, -0.03077439f, 
    -0.12883465f, 0.08736798f, -0.08886825f, -0.11227868f, 0.00273158f, -0.05240347f, -0.13153151f, -0.03759109f, 
    -0.01018884f, 0.02782779f, 0.00163952f, 0.09309955f, 0.35206929f, 0.04819106f, 0.47698498f, -0.01305578f, 
    0.35537165f, 0.03369988f, -0.21968570f, -0.24214169f, 0.18033338f, 0.08915243f, -0.34899572f, 0.13551119f, 
    -0.04802544f, 0.00493255f, -0.16945368f, -0.14550091f, 0.10444701f, -0.13573223f, -0.11542362f, 0.03063007f, 
    0.05839028f, 0.08693987f, -0.18596523f, -0.33381283f, 0.00750676f, -0.10950410f, -0.04775434f, -0.05557965f, 
    -0.10272266f, 0.12886165f, 0.13066325f, 0.53835547f, -0.29002252f, 0.00519648f, -0.27997071f, -0.12491343f, 
    -0.00992916f, 0.15231554f, 0.00387494f, 0.44361225f, 0.09187118f, -0.16342334f, 0.27504024f, 0.00495269f, 
    0.16231698f, 0.16715756f, 0.03020195f, -0.06689873f, 0.12966429f, 0.04292722f, -0.17567043f, 0.20962472f, 
    -0.25482005f, 0.07689217f, 0.39604980f, 0.17339264f, 0.01034990f, -0.04433296f, 0.16679767f, 0.15414737f, 
    -0.12174872f, -0.00565600f, 0.05568480f, 0.03386394f, -0.11980795f, -0.14032190f, -0.01772333f, -0.06233226f, 
    -0.00002511f, -0.08322953f, 0.06395812f, -0.11515921f, -0.01488865f, -0.09916886f, 0.05045695f, -0.16111927f, 
    0.04923096f, 0.09135365f, 0.03439288f, -0.10720305f, 0.05875609f, -0.17485149f, 0.01381265f, -0.03887492f, 
    -0.09513294f, -0.13933566f, -0.07980014f, 0.12722096f, -0.11621955f, -0.12482906f, 0.00197707f, 0.00007101f, 
    0.14812723f, 0.30083272f, -0.16519621f, 0.02939561f, -0.01410368f, 0.15417224f, -0.33344376f, 0.09468158f, 
    0.14368667f, 0.03487910f, 0.15883173f, 0.05433739f, 0.05578104f, 0.13535514f, -0.10070715f, 0.11174461f, 
    0.42013744f, 0.14901379f, 0.07618967f, 0.14358924f, 0.09843491f, -0.14952648f, 0.00038562f, -0.20393558f, 
    -0.06440910f, -0.03927680f, -0.06121444f, 0.35963506f, 0.53384656f, -0.15650032f, 0.03844739f, 0.16438164f, 
    0.12096743f, 0.19430025f, -0.02658305f, -0.77196687f, 0.12514736f, 0.15390597f, -0.37878519f, -0.14077583f, 
    0.31898037f, -0.00853141f, 0.30370238f, -0.08490870f, 0.06711846f, 0.12580624f, -0.46439189f, -0.07827836f, 
    -0.34555471f, 0.11145138f, -0.08695486f, -0.16298598f, 0.11909170f, -0.03885978f, 0.08517402f, -0.01543387f, 
    0.32014269f, 0.37160701f, -0.08425435f, 0.28524154f, -0.32604182f, -0.12455354f, -0.09312472f, -0.15747064f, 
    0.16023971f, -0.23523776f, 0.07833325f, 0.03761953f, -0.59403712f, -0.09845753f, -0.17913949f, -0.17692244f, 
    0.23626806f, 0.07292549f, 0.07222138f, 0.07008393f, 0.16856541f, 0.05383264f, 0.45381108f, 0.12669197f, 
    0.23807046f, 0.14909123f, 0.13251953f, 0.07602850f, -0.00587459f, -0.09226485f, -0.25713089f, 0.17876600f, 
    0.14538534f, -0.34854987f, -0.44341856f, 0.22392675f, 0.61009860f, -0.02454819f, 0.14228633f, 0.15312235f, 
    -0.03166029f, 0.10954502f, 0.06688169f, -0.17977291f, -0.13185298f, 0.10954362f, 0.02115723f, 0.01372126f, 
    -0.00257143f, -0.04883789f, -0.15824504f, -0.07130193f, 0.13860379f, -0.14112137f, 0.08914678f, 0.04929029f, 
    -0.18039681f, 0.03686574f, 0.03627069f, -0.02463648f, -0.10078190f, 0.07132547f, 0.05520643f, -0.15645793f, 
    0.00162788f, -0.06434858f, 0.03377759f, -0.18323047f, -0.17088553f, -0.10971495f, -0.05103193f, 0.03726737f, 
    0.09911428f, -0.12424996f, -0.10861293f, -0.18319196f, 0.25015625f, -0.17278527f, 0.06809685f, 0.05025402f, 
    0.34003741f, -0.07373850f, -0.20984511f, 0.46173397f, 0.11128467f, -0.07959367f, -0.16630940f, -0.13081798f, 
    0.15832172f, -0.02589120f, -0.08300884f, -0.12335234f, 0.12099144f, -0.11258317f, 0.11945357f, -0.07299470f, 
    0.33182997f, -0.13997208f, 0.09601348f, 0.25582969f, -0.23027256f, -0.14519770f, 0.12675254f, 0.11810336f, 
    -0.01899581f, 0.40378898f, 0.01256807f, -0.05998020f, 0.17284551f, 0.08306137f, -0.04774949f, 0.00754403f, 
    -0.13360633f, 0.13087599f, 0.33267221f, -0.24659701f, -0.13926905f, 0.11330110f, 0.42022270f, 0.12776360f, 
    -0.21922208f, -0.06280785f, 0.06287030f, 0.16551830f, 0.07214799f, -0.15543853f, 0.38583314f, 0.39502397f, 
    -0.23024845f, -0.29344308f, 0.36315864f, -0.13744804f, 0.07419758f, -0.00147927f, 0.03126600f, 0.03394836f, 
    0.06353986f, -0.23279102f, 0.02530603f, 0.51568091f, 0.19077751f, 0.08636773f, 0.44401655f, 0.16451313f, 
    0.33559728f, 0.02106264f, 0.15095927f, -0.00609958f, -0.04514763f, 0.00393258f, 0.37361050f, 0.04449050f, 
    0.28005558f, 0.03524356f, -0.15267684f, 0.16551268f, -0.12427013f, 0.04060773f, -0.04615503f, -0.00389804f, 
    -0.19771595f, 0.40463376f, -0.35793522f, -0.05843211f, -0.06603912f, 0.04346529f, 0.17557240f, 0.03595320f, 
    0.13923863f, -0.00404131f, 0.17159922f, 0.15970734f, 0.33414447f, -0.14942640f, 0.18324751f, -0.06702116f, 
    0.25606108f, -0.06697927f, -0.33777666f, -0.02186664f, 0.07666573f, -0.01259207f, 0.22818838f, 0.11302213f, 
    -0.43788418f, -0.17762408f, 0.14443457f, 0.06679734f, -0.10595504f, -0.08215510f, 0.45183024f, 0.24042001f, 
    -0.01284939f, -0.06171373f, 0.34151837f, -0.20669502f, 0.01041168f, 0.14183778f, 0.00242825f, -0.01327394f, 
    -0.13817692f, -0.03224611f, 0.01326867f, 0.50721258f, -0.17087243f, -0.06649240f, -0.02019928f, -0.14362615f, 
    -0.28930640f, -0.13577187f, -0.34391201f, 0.01787971f, 0.03978847f, 0.13017465f, 0.55889893f, -0.08278106f, 
    -0.26207781f, 0.13215658f, 0.04430695f, 0.06147017f, -0.01652719f, 0.13552783f, 0.13614020f, 0.34030211f, 
    0.32694617f, -0.09740971f, -0.36165568f, 0.37449166f, 0.60707587f, 0.17664793f, 0.09791546f, -0.01926565f, 
    0.00740225f, 0.32827553f, -0.02531860f, -0.03630446f, -0.06632002f, 0.07784501f, 0.09139644f, -0.05544423f, 
    0.35118434f, 0.08237769f, -0.24304619f, -0.09337754f, -0.06071163f, 0.01882559f, 0.08570152f, -0.04739118f, 
    -0.09570084f, 0.03993436f, 0.08389175f, -0.11140269f, 0.11116574f, 0.09402042f, 0.44805944f, -0.50723642f, 
    0.13028838f, 0.12254808f, -0.00448390f, 0.04637768f, 0.49667960f, 0.14535969f, -0.10309477f, 0.05848787f, 
    -0.17134112f, -0.04108223f, -0.15058479f, -0.41878253f, 0.17424174f, -0.02375403f, 0.18780635f, 0.15807888f, 
    0.44613254f, -0.14270249f, 0.04689066f, -0.18324856f, 0.06699619f, -0.09642649f, -0.25663739f, 0.00355036f, 
    -0.09482899f, 0.03620714f, -0.02666995f, 0.07744394f, 0.14750665f, -0.14917701f, -0.03058227f, 0.07366209f, 
    0.33639106f, -0.25988948f, -0.29890415f, -0.18285446f, 0.00017196f, -0.01863093f, -0.15941778f, -0.09326672f, 
    0.04127317f, -0.07468268f, -0.06585548f, -0.13557658f, 0.06257490f, 0.15561624f, -0.04352631f, 0.14464566f, 
    -0.08753743f, -0.02380682f, 0.14866255f, -0.14478286f, -0.12967503f, -0.08901911f, -0.01151041f, -0.04385921f, 
    -0.05428315f, 0.15180302f, -0.15499201f, -0.09553790f, 0.10126077f, 0.10697865f, -0.16571252f, -0.04921122f, 
    -0.02975555f, 0.12564103f, -0.11557163f, -0.03154624f, 0.05168957f, 0.08325412f, -0.09407306f, 0.00086999f, 
    0.05143805f, 0.10505208f, -0.04467149f, 0.02154682f, -0.02508754f, 0.07181848f, -0.13405237f, -0.11399060f, 
    0.06405158f, 0.09410610f, 0.46464726f, -0.17232786f, 0.02906137f, -0.12181316f, 0.56775510f, 0.03497535f, 
    0.32489115f, 0.10984230f, -0.03344230f, -0.14673994f, -0.13629329f, 0.15965119f, 0.30209377f, -0.11614159f, 
    -0.03045714f, 0.17736767f, -0.19250405f, 0.28586602f, -0.19653493f, 0.05870870f, 0.08766204f, -0.16236982f, 
    -0.14353150f, -0.05576893f, -0.05776579f, -0.28655463f, 0.19102927f, -0.14302109f, -0.07198844f, 0.16850843f, 
    0.31088781f, -0.00804668f, 0.41121715f, -0.09286652f, -0.04126476f, -0.16114315f, -0.25420606f, -0.13809280f, 
    0.59874898f, -0.06902707f, -0.05059685f, 0.16124542f, 0.12469711f, 0.12668329f, -0.36664689f, 0.20674676f, 
    -0.12613328f, 0.41453010f, -0.35107145f, -0.21293053f, -0.26385584f, -0.14089830f, 0.16163246f, 0.06816927f, 
    0.06843229f, 0.36946118f, -0.02597536f, -0.33999485f, 0.16463625f, -0.12328371f, -0.06418405f, -0.06834757f, 
    -0.30234104f, -0.00609678f, 0.37402049f, -0.26059976f, 0.03237141f, -0.15558644f, -0.22270791f, -0.17432964f, 
    0.42594245f, -0.08918086f, 0.15334456f, -0.11409914f, -0.04034829f, -0.01110044f, 0.16074149f, 0.19349036f, 
    0.06498797f, -0.24577118f, 0.33710825f, -0.07788825f, -0.18432717f, -0.16942398f, -0.08375803f, -0.01369920f, 
    0.02740158f, 0.18334585f, 0.06481248f, 0.19637312f, 0.17520295f, 0.07596850f, -0.04561798f, -0.05382873f, 
    0.10044577f, -0.15854183f, 0.26348278f, -0.11881352f, 0.06148684f, -0.13118632f, 0.36639243f, 0.11481751f, 
    0.04326293f, 0.04686422f, 0.08351986f, -0.01438994f, 0.17559651f, -0.02043501f, -0.10264077f, 0.25025338f, 
    -0.36055887f, 0.17785428f, -0.16768178f, -0.32807785f, 0.04775517f, -0.09016322f, -0.12345447f, -0.11949174f, 
    -0.12722147f, -0.12533188f, 0.11857428f, -0.16223532f, -0.12003402f, -0.07527526f, 0.38785073f, 0.00587825f, 
    0.00686907f, 0.15232547f, 0.08416982f, 0.58841658f, 0.04497690f, 0.17774592f, -0.19224419f, 0.13730660f, 
    0.51432079f, 0.10233813f, -0.05921956f, 0.14802739f, -0.13775796f, -0.00452307f, -0.26835024f, -0.02391530f, 
    0.26583427f, 0.78694999f, 0.52404910f, -0.02660696f, -0.20089389f, -0.12560874f, -0.11300880f, -0.14970168f, 
    0.10317437f, 0.22886530f, -0.08477280f, 0.32790861f, 0.33194312f, -0.05842118f, 0.55953079f, -0.11656847f, 
    -0.28417858f, 0.03271701f, 0.22928397f, -0.14227235f, 0.07444607f, -0.06903102f, -0.19253311f, -0.09604779f, 
    0.27453041f, 0.04666798f, 0.16811720f, 0.05789773f, -0.00598644f, -0.14645350f, 0.02605115f, -0.13331273f, 
    -0.05138970f, 0.16908473f, -0.39538383f, -0.02074194f, 0.10036428f, 0.15430976f, -0.07680460f, 0.10910907f, 
    0.05767033f, -0.11265825f, -0.12577242f, -0.47176972f, -0.03123381f, -0.10061204f, -0.22816695f, -0.02952115f, 
    0.18945198f, -0.05995075f, -0.04964070f, -0.21303798f, -0.01715252f, -0.03925501f, 0.52772576f, 0.01226265f, 
    -0.35481265f, -0.17285512f, -0.13505454f, 0.02390338f, 0.12291601f, 0.02162640f, 0.35191727f, 0.20478909f, 
    0.35516250f, -0.21837521f, 0.21391602f, -0.24360670f, -0.31402662f, -0.14930424f, 0.10365485f, -0.02685574f, 
    0.10552572f, -0.14659941f, -0.10165112f, 0.16171214f, 0.12145637f, 0.17609307f, 0.17952548f, -0.14210948f, 
    0.14811301f, 0.08750648f, -0.20417140f, 0.61588186f, -0.13878971f, -0.00638984f, -0.29399568f, 0.13426259f, 
    0.37339228f, -0.02034955f, 0.07179897f, -0.12536202f, 0.09586056f, -0.09010652f, -0.00955963f, 0.18359363f, 
    -0.08898172f, 0.11892822f, 0.31803265f, -0.17270800f, 0.16327304f, 0.15467480f, -0.15337627f, 0.03304620f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.32864621f, -0.17711759f, -0.10012981f, 0.01400451f, 0.18354201f, -0.10397781f, 0.15502864f, -0.08501761f, 
    -0.05624484f, 0.25059086f, 0.04499868f, -0.11725163f, 0.04699662f, 0.21761270f, -0.11044879f, -0.16323282f, 
    0.07507639f, 0.15192606f, 0.27550972f, 0.02040978f, 0.18461426f, 0.20824726f, 0.16137365f, -0.03652559f, 
    -0.09623401f, -0.09898446f, -0.04204101f, -0.05927467f, 0.03472657f, -0.14934285f, -0.02750025f, 0.06015363f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.13860670f, 0.31569350f, -0.04884808f, -0.60933369f, 0.36540991f, -0.07158067f, -0.14188154f, 0.07473955f, 
    -0.03352698f, -0.52495879f, 0.21177132f, -0.02721904f, 0.34417009f, 0.42357942f, -0.05582286f, 0.05054723f, 
    -0.05689846f, -0.11877964f, -0.33988860f, -0.66630781f, -0.30006731f, -0.26328292f, -0.15524514f, 0.03108421f, 
    0.16624489f, 0.41621345f, 0.30063620f, 0.13212775f, 0.16670354f, -0.51003695f, -0.10316810f, -0.23737495f, 
    -0.00054085f, 0.26057127f, -0.28200164f, -0.13827465f, -0.10601979f, -0.66214508f, -0.06191937f, 0.11720859f, 
    -0.15753418f, -0.05869780f, -0.26017517f, 0.04492971f, 0.22897233f, 0.09543692f, 0.22369239f, -0.12821385f, 
    0.06061344f, -0.60710514f, 0.17551698f, -0.28641909f, 0.15542051f, 0.40848133f, 0.07472040f, -0.12957655f, 
    0.06507030f, 0.06744486f, -0.53311592f, -0.10816555f, 0.25851643f, 0.30228505f, -0.15887141f, 0.04830113f, 
    -0.04369364f, -0.51267201f, -0.39378184f, -0.31099659f, 0.03396833f, 0.00266739f, -0.16374031f, -0.07509392f, 
    0.00677312f, -0.77914697f, 0.33159155f, 0.10584021f, 0.08519415f, -0.50740814f, 0.58558780f, 0.11976793f, 
    -0.04093296f, -0.06339888f, 0.00364555f, -0.03241693f, 0.41112709f, -0.32542917f, 0.06490925f, -0.10377844f, 
    0.24517764f, -0.07695486f, -0.33639964f, -0.29980513f, -0.28721035f, -0.87001717f, 0.42935619f, -0.24287692f, 
    -0.53698337f, -0.02535227f, -0.08380683f, 0.02100175f, 0.00625928f, 0.20138478f, 0.11818320f, 0.16164945f, 
    -0.03909423f, -0.41314578f, 0.37442476f, 0.03894671f, 0.19971308f, -0.89499378f, -0.72048795f, 0.12607066f, 
    0.10287226f, 0.15401949f, 0.17492431f, -0.03763041f, -0.15985718f, -0.07126005f, -0.92661077f, 0.13786732f, 
    0.21437463f, -0.09508132f, 0.00512335f, 0.01402133f, 0.14777236f, -0.06773791f, -0.61273032f, 0.20194514f, 
    0.07511981f, -0.11679611f, 0.39317158f, 0.31990832f, -0.17570555f, 0.05602450f, 0.06093538f, -0.03713382f, 
    0.08647427f, 0.13367376f, -0.08890434f, -0.02063585f, 0.27907389f, -0.36025089f, 0.07350499f, 0.08510686f, 
    -0.23061745f, 0.19155899f, -0.39695802f, 0.05370942f, -0.05073518f, 0.06858652f, -0.05586307f, 0.04891072f, 
    -0.31041384f, -0.10832110f, 0.31675410f, -0.09806047f, -0.24620800f, 0.07108187f, -0.38199729f, 0.03436264f, 
    0.14278388f, -0.51489085f, -0.09726678f, -0.40662557f, 0.06788275f, 0.10708846f, -0.09186754f, 0.10179770f, 
    -0.17136249f, 0.25586054f, -0.39124346f, 0.02634243f, -0.04551157f, 0.32411897f, -0.58247018f, 0.13869990f, 
    0.34833807f, -0.52061480f, -0.06316955f, -0.01493118f, -0.41037384f, 0.00698145f, 0.33898363f, -0.15127048f, 
    -0.13559291f, 0.18607685f, -0.02266750f, -0.66203201f, 0.08401140f, 0.27554566f, -0.08331461f, -0.05503695f, 
    -0.04508843f, -0.43042433f, -0.22376482f, 0.33965707f, 0.11301886f, 0.22743486f, 0.11399978f, 0.16419254f, 
    -0.13531815f, -0.18443958f, -0.05680987f, 0.04951447f, -0.26197144f, 0.20816833f, -0.77304071f, -0.08137391f, 
    0.15156606f, 0.07630494f, -0.52980363f, 0.31375968f, -0.02178565f, 0.16650197f, -0.08342178f, -0.05810457f, 
    -0.13897477f, -1.00756466f, -0.05242103f, -0.56017983f, 0.19619304f, -0.74338049f, 0.46155652f, -0.16137904f, 
    -0.80223721f, -0.05235717f, -0.24718809f, -0.09393170f, -0.36543497f, 0.38369298f, 0.15082209f, 0.07060239f, 
    0.12712219f, 0.06049644f, -0.06504096f, -0.06569073f, -0.80163354f, -0.13769227f, 0.16135448f, 0.14650889f, 
    -0.63416827f, 0.27360389f, 0.29687873f, -0.02207706f, 0.11728560f, -0.60342330f, -0.29204512f, 0.11028325f, 
    0.06299782f, -0.00449186f, 0.28831783f, 0.16118677f, 0.08412793f, 0.42044550f, -0.35887751f, -0.30964169f, 
    0.21932261f, -0.59846848f, -0.19770180f, 0.14073226f, 0.13362618f, -0.51541251f, 0.17678100f, 0.04070121f, 
    -0.11467080f, -0.07232340f, 0.29095384f, -0.01332988f, -0.27853620f, -0.45222554f, -0.00699048f, -0.10969206f, 
    0.22439116f, -0.35076329f, -0.14336208f, -0.00296975f, 0.43221205f, -0.61439431f, -0.16598679f, 0.14555316f, 
    -0.74793315f, -0.31414598f, -0.23280448f, -0.29631752f, 0.38711029f, -0.20218606f, -0.37137371f, 0.33335450f, 
    0.26552796f, -0.43906960f, 0.01762897f, -0.74118584f, -0.58965039f, 0.25634527f, -0.08124509f, -0.12916911f, 
    -0.06885118f, -0.03401173f, -0.29056036f, -0.10114199f, -0.00214698f, 0.12185060f, 0.14969712f, -0.08228762f, 
    -0.00034909f, 0.29679620f, -0.11709292f, 0.25853750f, 0.20846634f, 0.06938075f, 0.12096000f, -0.02397782f, 
    -0.03731016f, -0.25500703f, -0.08509501f, 0.08191235f, -0.96503466f, -0.08620941f, 0.16308120f, -0.35974634f, 
    0.05670226f, -0.07232270f, -1.02994657f, 0.22632138f, 0.30143836f, 0.08835651f, -0.12643833f, 0.02110457f, 
    -0.11278936f, 0.29168707f, 0.30894798f, 0.00217849f, -0.08915790f, -0.55401075f, 0.13749851f, 0.07983851f, 
    -0.15635268f, -0.11000212f, 0.35604408f, 0.33359963f, -0.15824845f, 0.25564340f, -0.07377370f, -0.17348166f, 
    -0.18646537f, 0.09878331f, -0.92775506f, 0.29942629f, -0.14013007f, -0.39433599f, -0.39987126f, 0.12445289f, 
    -0.49614885f, -0.35917997f, -0.01453121f, 0.28292999f, -0.35647771f, -0.03810190f, 0.04011539f, -0.16517992f, 
    -0.05674467f, 0.10434493f, -0.23200057f, 0.01744127f, -0.66985059f, -0.29739159f, -0.21230941f, -0.04061467f, 
    0.14350176f, 0.05317381f, 0.15943685f, 0.27281305f, -0.37419221f, -0.50132883f, 0.32239839f, 0.07595260f, 
    -0.16691451f, 0.48645145f, 0.04466210f, 0.17805290f, 0.07482661f, -0.29453626f, 0.41189483f, 0.28555176f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.07994896f, -0.11100432f, 0.01601577f, -0.12041124f, 0.08090205f, 0.14462253f, -0.14630145f, 0.01209722f, 
    0.19877830f, -0.04108356f, 0.01350759f, -0.09980928f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
