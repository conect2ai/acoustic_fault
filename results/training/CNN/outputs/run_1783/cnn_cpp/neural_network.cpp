#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.24778052f, -0.20589671f, -0.60318148f, -0.74362570f, -0.46301547f, -0.05678774f, -0.60923773f, -0.24819291f, 
    -0.39890856f, -0.10506993f, -0.41807541f, -0.16532399f, 0.10215902f, 0.26375830f, -0.07049113f, -0.03950241f, 
    -0.35410959f, -0.17956270f, -0.32315490f, -0.19140920f, -0.34794256f, -0.03282008f, -0.07987154f, -0.50384849f, 
    -0.59470940f, 0.72365898f, 1.01680791f, 0.64417315f, -0.16894886f, -0.41801450f, -0.17190123f, -0.20627488f, 
    -0.37422556f, -0.46221966f, -0.45969769f, 0.06611123f, -0.02661597f, -0.20217855f, 0.02322950f, -0.38717681f, 
    0.14185168f, -0.14054137f, 0.19041415f, 0.34156752f, -0.24635166f, -0.18804109f, -0.04820508f, -0.06849336f, 
    0.09449157f, -0.04096241f, -0.59893435f, -0.06216309f, -0.23476903f, -0.02616194f, -0.54632229f, 0.23708059f, 
    0.11336992f, -0.47021878f, -0.56715333f, -0.46430138f, 0.04116217f, -0.02345649f, -0.27102390f, -0.25824898f, 
    0.08827058f, -0.21212195f, 0.11900999f, -0.25486672f, 0.01448057f, -0.06458647f, 0.23052496f, -0.03361307f, 
    0.02910230f, 0.25733364f, 0.57952416f, -1.37689543f, 1.18437898f, -0.32449085f, -1.08490610f, -0.51808542f, 
    0.08981664f, 0.27142537f, 0.50252640f, 0.53057271f, -0.06258859f, -0.35597721f, -0.02576872f, -0.31723845f, 
    -0.27731943f, 0.20682578f, -0.01159001f, -0.01893895f, -0.18958469f, -0.02259175f, -0.17949094f, -0.23954096f, 
    0.01108461f, -0.00922651f, -0.12836449f, -0.04803563f, -0.69483757f, 0.71155715f, -0.00409044f, -0.58730578f, 
    0.08930172f, -0.20592993f, 0.17201822f, 0.83739531f, -0.12951227f, -0.14849660f, -0.01426813f, 0.10848929f, 
    0.39986148f, -0.11309972f, -0.45742154f, 0.55079919f, -0.05545070f, -0.22699285f, -0.04478271f, -0.09659742f, 
    0.17666446f, 0.24498300f, 0.21652804f, -0.36183101f, -0.27212059f, -1.08191729f, -0.60077101f, -0.30665007f, 
    0.58831733f, 0.34692022f, -0.28366506f, 0.31583557f, 0.25699800f, 0.38087663f, -0.12275811f, 0.42306921f, 
    -0.27406099f, -0.02939855f, 0.71203530f, -0.12760444f, 0.17574854f, -0.08340535f, 0.08799536f, -0.31632167f, 
    -0.33288151f, 0.00451095f, 0.16648774f, 0.02793232f, 0.29006812f, -0.05473807f, -0.16716993f, 0.55739921f, 
    0.03440545f, -0.16035654f, 0.37397897f, -0.32174170f, -0.53890038f, 0.19229321f, 0.45045570f, 0.17897080f, 
    0.06452344f, -0.31630278f, 0.04287332f, 0.11935934f, -0.37604797f, 0.01807602f, 0.14874841f, -0.34310812f, 
    0.26117495f, 0.01724519f, 0.30405211f, 0.07434575f, -0.32153553f, -0.25436622f, 0.14534928f, -0.65832001f, 
    -0.34667355f, -0.24453491f, 0.33491340f, 0.20245899f, 0.30848351f, 0.51769120f, 0.20333868f, 0.33647481f, 
    -0.41202033f, -0.03458810f, -0.01532193f, 0.20410950f, 0.01444816f, -0.17734908f, -0.33654091f, -0.27871877f, 
    0.02963088f, -0.15299267f, 0.28911433f, 0.18768674f, 0.08323647f, 0.16163628f, 0.26203650f, 0.12306388f, 
    0.75324571f, -0.77796876f, 0.19206406f, -0.03224088f, -0.25532743f, 0.33404535f, 0.10893983f, -0.01674008f, 
    0.14343821f, 0.26859987f, 0.17429417f, -0.11170087f, -0.37233648f, -0.04461178f, 0.39786008f, -0.37917826f, 
    0.10500690f, 0.24628465f, -0.14675541f, -0.29094714f, -0.17742920f, 0.19623920f, -0.08086394f, 0.20501713f, 
    0.02096788f, -0.00256589f, 0.63121718f, -0.20234104f, -0.26744640f, 0.17237473f, -0.12985310f, -0.04932633f, 
    0.06314128f, -0.28990775f, -0.50335753f, -0.14074393f, 0.56391793f, -0.24898252f, -0.12403106f, 0.18759085f, 
    0.28094399f, 0.05737352f, 0.16871589f, -0.23639791f, -0.11589553f, 0.15045519f, 0.22809601f, -0.39031619f, 
    0.09275173f, 0.28785375f, -0.13479960f, 0.34660411f, 0.22047821f, -0.12332334f, 0.04342301f, -0.19313297f, 
    0.23013134f, 0.38074654f, 0.36975425f, 0.30431283f, -0.51749319f, -0.34966221f, -0.40189549f, -0.17595257f, 
    -0.16516052f, 0.41148326f, 0.59944713f, -0.29760590f, -0.36372176f, -0.04504334f, -0.47492722f, -0.00799575f, 
    0.10133608f, -0.09507919f, 0.06229301f, 1.36349916f, -0.89058012f, -1.33511698f, -0.73783654f, -0.45752978f, 
    0.81091285f, 0.42092475f, 0.72094375f, -0.05080108f, 0.12533775f, -0.11644886f, 0.38141492f, -0.18966372f, 
    -0.30968371f, 0.19797006f, -0.05676759f, -0.27442437f, 0.17900033f, -0.33842233f, -0.48958677f, -0.09533914f, 
    -0.02044777f, -0.19584441f, 0.04079156f, 0.24890171f, 0.85096300f, -0.57135665f, 0.10518824f, 0.56208563f, 
    0.33071882f, 0.60180604f, 0.02606323f, 0.14178169f, -0.16495873f, -0.15014271f, -0.12237812f, -0.22320583f, 
    -0.20303716f, -0.25638238f, -0.01604711f, -0.00105702f, 0.17552425f, -0.02518933f, 0.09271572f, 0.00613247f, 
    0.20567922f, -0.09446724f, -0.36659026f, -0.39921960f, -0.23325092f, 0.14475222f, -0.07469408f, -1.04267609f, 
    -0.01401939f, 0.40784732f, -0.12033459f, -0.43480623f, 0.07500968f, 0.98253012f, -0.90214753f, -0.26588967f, 
    -0.17126936f, 0.02028259f, 0.42593095f, -0.41193613f, 0.00137062f, -0.13728313f, -0.08545816f, -0.13566287f, 
    0.38964257f, 0.00689974f, 0.14512968f, -0.03404655f, -0.40601957f, 0.12066673f, -0.37734386f, -0.19820905f, 
    0.24759729f, 0.36340120f, 0.32576632f, -0.67414021f, -0.68658721f, -0.76814973f, -0.22834805f, 0.53688031f, 
    -0.10363539f, -0.43704557f, -0.35256100f, -0.14977577f, -0.13235033f, -0.23799534f, -0.21147349f, -0.18148807f, 
    -0.37629229f, -0.40406299f, -0.20036796f, 0.10877033f, -0.31315795f, 0.02032472f, -0.03175593f, 0.00895098f, 
    0.33245391f, -0.13334899f, 0.11108202f, -0.40005502f, -0.62076658f, -0.10135699f, 0.02626052f, 0.36645597f, 
    0.73869121f, 0.48657000f, 0.18896000f, -0.13738930f, -0.57724011f, -0.08527235f, 0.02774340f, 0.27851731f, 
    -0.23224759f, 0.01703856f, -0.29874542f, -0.34996656f, 0.11220134f, 0.24773595f, -0.29898161f, 0.44985241f, 
    0.23670034f, 0.38448921f, 0.30216530f, 0.12870196f, -0.24245735f, -0.72083926f, -0.38058832f, -0.19871411f, 
    0.28928760f, 0.47600979f, 0.01198446f, -0.05024554f, -0.29503021f, 0.60276264f, -0.19384067f, -0.31975582f, 
    -0.12791398f, 0.16247939f, 0.26004934f, -0.14770909f, 0.07929874f, 0.21167420f, 0.07090982f, -0.27804878f, 
    -0.06044612f, -0.95698386f, -0.55571890f, -0.86879331f, -0.89815247f, -0.29204452f, 0.18953599f, 0.31519702f, 
    0.60502476f, 0.34668016f, 0.36866033f, 0.10473053f, 0.11513069f, -0.00773257f, -0.30275172f, -0.16531080f, 
    0.16327073f, 0.08017889f, 0.12383138f, 0.18654113f, 0.19013789f, -0.04901104f, -0.12954277f, -0.07774472f, 
    -0.28849521f, -0.06586620f, 0.44101149f, 0.37091374f, -0.02556367f, -0.59498525f, -0.72237116f, -0.33508134f, 
    -0.03745727f, 0.07108480f, 0.26503488f, 0.07286999f, 0.02226244f, 0.21053480f, -0.37188333f, 0.16064101f, 
    -0.32236448f, -0.01087650f, -0.04850825f, -0.15867463f, 0.04932708f, -0.51573914f, -0.60375237f, -0.47962722f, 
    -0.37739253f, -0.50340027f, -0.89511013f, -1.04268610f, -0.47761673f, -0.46852908f, -0.10455259f, 0.18515167f, 
    -0.07303639f, -0.67875850f, -0.99907947f, -0.88292086f, -0.10599197f, -0.34524670f, -0.09694491f, 0.15797047f, 
    -0.65715164f, -0.28432983f, -0.17356862f, -0.24953762f, -0.41059300f, -0.41674918f, 0.40544462f, 0.18080418f, 
    -0.19199896f, -0.55067265f, -0.22302917f, -0.04235938f, 0.33053774f, 0.29911444f, -0.43381968f, 0.50667435f, 
    0.35661575f, -0.37062809f, -0.48047572f, -0.44070256f, -0.14448996f, 0.67776048f, 0.04018537f, -0.41199592f, 
    0.11016830f, 0.15328017f, -0.19817273f, -0.12186060f, 0.11494064f, 0.44556990f, -0.14165238f, -0.35260633f, 
    -0.10547615f, 0.09173086f, 0.16502030f, 0.23298416f, -0.05849947f, -0.66330445f, -0.48419145f, -0.81168127f, 
    -0.76148331f, -0.79121691f, 0.81208080f, -0.11561955f, -0.04873000f, 0.08658026f, 0.12342574f, -0.66015351f, 
    -0.24210694f, -0.01178376f, -0.21623439f, -0.30388182f, 0.33342609f, -0.13732800f, 0.16179158f, 0.31423685f, 
    0.17587006f, -0.08748604f, 0.26220605f, 0.12614055f, 0.12845504f, -0.07590750f, 0.84819561f, -0.10301148f, 
    -0.31342500f, -0.77313453f, -0.98174357f, 0.69849688f, 0.32678679f, 0.34966233f, 0.11314565f, 0.04940812f, 
    0.03293217f, 0.29649934f, 0.06700688f, -0.14752598f, -0.17401107f, -0.31044701f, -0.34391895f, 0.11082979f, 
    0.04355339f, 0.27160478f, 0.23924066f, -0.03168313f, -0.19606699f, -0.03771600f, 0.15933460f, -0.29771605f, 
    -0.32072070f, -0.58564115f, -0.48720995f, 0.28774044f, 0.27618706f, -0.13253468f, -0.24582587f, 0.48020789f, 
    -0.35840857f, 0.58940279f, 0.08331824f, -0.11712891f, -0.15580417f, -0.50630140f, -0.39002308f, 0.03573710f, 
    -0.34472397f, -0.12740158f, -0.57403815f, 0.10636574f, 0.16461214f, 0.44313669f, 0.14141086f, 0.33822218f, 
    0.74220043f, -0.63505417f, -0.22219761f, -0.06297442f, 0.74017245f, -0.21744594f, 0.28855726f, 0.16215318f, 
    -0.26757285f, -0.26866269f, -0.41036659f, -0.30992165f, 0.41430950f, -0.46657175f, 0.00114818f, 0.15154487f, 
    0.15810655f, 0.42049474f, 0.26978695f, 0.06934433f, 0.06046532f, -0.07410748f, -0.22692221f, -0.24415974f, 
    -0.47644848f, 0.29613537f, 0.01623319f, 0.38358060f, -0.34661883f, -0.50761455f, -0.27809107f, 0.20246202f, 
    0.09270255f, 0.13758636f, -0.00157846f, -0.14021833f, 0.33656535f, 0.08165045f, 0.43923193f, -0.42314142f, 
    -0.17746237f, -0.09395386f, -0.23946740f, -0.16249742f, 0.09195791f, 0.06119535f, 0.10104933f, 0.25075978f, 
    0.14830345f, -0.05615747f, 0.44612846f, 0.41531798f, -0.05063080f, -0.07776602f, 0.10344497f, 0.16391332f, 
    0.20822282f, 0.24242841f, 0.02194669f, -0.05933432f, 0.25181326f, 0.32985008f, 0.32419044f, -0.25349489f, 
    -0.32157382f, 0.00551884f, -0.10866443f, 0.12191526f, -0.18470365f, 0.18413787f, -0.05733348f, 0.37258443f, 
    -0.05903398f, -0.15215640f, 0.05731322f, -0.39541563f, -0.47226587f, -0.36816666f, -0.37108406f, -0.65052646f, 
    -1.05771995f, -0.72814167f, -0.86595666f, -0.86511296f, -1.01252067f, 0.27704999f, 0.57342595f, 0.23554859f, 
    0.02855468f, 0.32569316f, 0.05598836f, -0.12934399f, 0.17556788f, -0.05390621f, -0.40576160f, 0.01676114f, 
    0.11041773f, -0.09060024f, 0.38406616f, 0.14715001f, -1.21762729f, 0.28776172f, 0.01155643f, -0.52777320f, 
    -0.30188477f, -0.06446973f, 0.23545083f, 0.08649937f, 0.43994915f, 0.22541967f, 0.06447713f, 0.04480209f, 
    0.06515333f, 0.56617916f, -0.37849376f, -0.15955639f, -0.52360654f, -0.17315318f, 0.28334966f, 0.30832529f, 
    0.07113153f, 0.20800234f, 0.19799727f, 0.05147205f, -0.12226269f, -1.28752291f, -0.77905214f, -0.08652706f, 
    0.57989383f, 0.64082778f, 0.66378760f, -0.34811276f, 0.06794994f, 0.29532051f, 0.08740272f, -0.01457877f, 
    -0.28802964f, 0.03362748f, -0.67117339f, -0.27063829f, 0.09964708f, 0.26339343f, -0.07384805f, 0.24895519f, 
    -0.01357333f, -0.10596406f, 0.19527781f, -0.06209263f, -0.11145309f, 0.28263545f, 0.73443550f, -1.10417640f, 
    -0.68832147f, -0.00521625f, 0.51238853f, 0.34000456f, -0.05334434f, -0.68094784f, -0.55474186f, 0.59146130f, 
    -0.46444917f, 0.15742809f, 0.44357732f, -0.63124716f, 0.13450155f, 0.08672733f, 0.28780383f, -0.28515476f, 
    0.14630291f, -0.10765611f, -0.06974597f, -0.28117058f, -0.37501189f, 0.13425773f, 0.19803016f, -0.53228366f, 
    -0.61247504f, -0.41980645f, -0.50879902f, -0.64714521f, 0.39204761f, 0.09767195f, -0.38657603f, -0.46803010f, 
    0.06073079f, 0.25278962f, 0.22089231f, 0.44181308f, 0.45789108f, 0.19299078f, -0.12660338f, 0.05931337f, 
    0.17901821f, -0.13225679f, -0.30102962f, -0.27948189f, -0.36146066f, 0.20491935f, -0.46020338f, -0.04601474f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.17212880f, 0.34933129f, -0.14200224f, 0.22647351f, 0.33888263f, 0.37949061f, 0.22854981f, 0.10947331f, 
    0.60853559f, 0.14669952f, 0.26646167f, 0.07783807f, 0.22547328f, 0.39573234f, 0.27192301f, 0.43136004f, 
    0.39495206f, 0.04355715f, -0.04652920f, 0.10593851f, 0.24321486f, -0.31471619f, 0.41464221f, 0.13491367f, 
    -0.01062352f, 0.30877066f, 0.09178902f, -0.27354592f, 0.26690507f, 0.01975894f, 0.36152300f, 0.15573934f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.32660276f, 0.18554913f, -0.01314671f, -0.01340087f, 0.07617554f, 0.19504945f, -0.08296183f, 0.08900573f, 
    -0.15372109f, -0.16756536f, -0.01712444f, 0.15327710f, -0.41082293f, -0.19442630f, -0.63335174f, 0.17667910f, 
    0.11199465f, -0.05207616f, -0.11759063f, -0.03066956f, -0.06433919f, 0.02798065f, 0.01358812f, 0.09094752f, 
    0.32721838f, 0.16758505f, -0.33525568f, -0.30176359f, 0.10015455f, 0.10883994f, 0.01704330f, 0.11518154f, 
    0.00673838f, -0.02911450f, 0.01009627f, -0.02601543f, -0.37212193f, -0.11096924f, 0.18832403f, -0.09276450f, 
    -0.07679176f, 0.19554831f, -0.07188801f, 0.02930842f, 0.03577884f, 0.03397359f, 0.06182333f, -0.02684275f, 
    -0.20916767f, -0.07267102f, 0.04792422f, 0.08228705f, -0.10028478f, 0.03767749f, -0.05872785f, 0.01993223f, 
    -0.04709978f, -0.05050159f, -0.05107080f, 0.06190819f, -0.18102528f, 0.19720362f, 0.13990612f, -0.18488310f, 
    0.01622331f, 0.04209932f, 0.09642658f, -0.02034223f, 0.03148794f, -0.13636890f, -0.38520285f, -0.19588451f, 
    -0.54765034f, -0.09630040f, 0.08279198f, 0.12038228f, 0.01442094f, 0.04385681f, -0.00154061f, 0.05724195f, 
    -0.01718685f, -0.04732794f, -0.00534274f, 0.01693230f, 0.04842926f, 0.10201700f, 0.05045710f, 0.00709840f, 
    0.07726894f, 0.04333767f, -0.02108115f, -0.06521894f, -0.25371340f, -0.39432767f, -0.08055616f, -0.15071192f, 
    -0.04347915f, -0.56990391f, -0.36679289f, 0.07479852f, -0.04959421f, -0.05471091f, -0.02180953f, -0.07462130f, 
    -0.09358796f, -0.04460975f, -0.23208493f, 0.07460022f, 0.10536569f, 0.02487813f, -0.07582519f, -0.00621722f, 
    -0.29905459f, -0.22020452f, -0.35854220f, -0.23031326f, -0.01047815f, 0.00852150f, 0.04646552f, -0.08976819f, 
    -0.63406664f, 0.04194792f, 0.15671636f, -0.18300883f, -0.02440953f, 0.05544762f, 0.02650974f, 0.09192294f, 
    0.07024159f, 0.13764282f, 0.03385491f, -0.09221923f, 0.05676154f, -0.04155428f, -0.57421392f, 0.14599875f, 
    0.09181511f, 0.07843724f, -0.09414557f, -0.32850203f, 0.00322585f, -0.00712946f, -0.23002620f, -0.02030647f, 
    -0.16297919f, -0.79301465f, -0.07570961f, 0.03095477f, 0.00095165f, -0.00404715f, 0.08377350f, 0.09033402f, 
    -0.08107539f, 0.02625081f, 0.04814009f, 0.03428065f, 0.10612733f, -0.00032507f, -0.13336052f, -0.09253741f, 
    -0.15729770f, 0.04519453f, 0.24387611f, 0.22271980f, -0.08381470f, -0.02692136f, 0.06336074f, -0.21706195f, 
    0.30495405f, 0.35586017f, 0.18720227f, -0.36840972f, -0.18881184f, -0.18161622f, -0.10346778f, -0.24509534f, 
    -0.08966842f, -0.10494909f, -0.10126965f, -0.04138714f, -0.13511232f, -0.12540090f, 0.06078509f, -0.15297112f, 
    -0.07633658f, -0.00999421f, -0.01166457f, 0.00559810f, -0.18542062f, -0.26260203f, 0.03299305f, -0.22707963f, 
    -0.45906264f, 0.02093736f, 0.17538734f, -0.10979503f, 0.06424882f, 0.05244917f, -0.01217491f, -0.12935279f, 
    0.02948644f, -0.13269013f, -0.10653266f, -0.12750402f, 0.27493915f, 0.12720527f, 0.05697769f, 0.01844864f, 
    0.15696289f, 0.20646299f, 0.06306085f, 0.09582622f, 0.04705653f, 0.00009020f, 0.16775680f, 0.11269368f, 
    -0.44217154f, -0.37197948f, -0.02594181f, 0.15081021f, 0.02313907f, -0.01219220f, -0.11407067f, 0.10103677f, 
    -0.00701780f, -0.01048626f, 0.02970457f, 0.21969154f, 0.45798776f, 0.42136192f, -0.09430741f, -0.15611787f, 
    0.14798889f, 0.24019952f, 0.15826333f, -0.15489568f, -0.03755338f, -0.00913110f, -0.13162355f, -0.17437689f, 
    -0.22780237f, 0.21432894f, 0.14612135f, -0.14949767f, 0.04360605f, -0.07417527f, -0.03058732f, -0.01955027f, 
    -0.02768365f, -0.03728158f, 0.03769466f, 0.05711718f, 0.30322161f, 0.21191773f, -0.01636912f, -0.11552251f, 
    0.08210587f, 0.32967702f, 0.09776414f, 0.07718816f, 0.06018038f, 0.09819966f, 0.02149811f, 0.10984395f, 
    -0.23916543f, -0.86262125f, -0.56261349f, 0.13075176f, 0.06356053f, -0.06732385f, -0.22906457f, 0.07944512f, 
    -0.03289105f, -0.11045019f, -0.25413814f, -0.20485123f, 0.12021610f, 0.06205293f, -0.19903632f, -0.21583639f, 
    0.19731845f, 0.32620907f, -0.36682850f, -0.28054807f, -0.10430625f, -0.16476771f, 0.05672172f, -0.22309592f, 
    0.05484077f, -0.15374763f, 0.03304999f, 0.10708670f, 0.03940107f, -0.13651398f, 0.01955857f, -0.02764267f, 
    0.01245567f, 0.13692430f, 0.03136020f, -0.05491608f, -0.17850290f, -0.57531172f, -0.05119858f, 0.00080861f, 
    -0.09088741f, -0.12151115f, -0.00365476f, 0.00176112f, -0.10122195f, -0.15962952f, -0.03215621f, -0.22508332f, 
    -0.05761346f, 0.01373637f, -0.05661171f, 0.03293895f, 0.03116849f, -0.00691594f, 0.04468130f, 0.03514238f, 
    -0.20747145f, -0.04425007f, -0.05828536f, -0.05633990f, 0.43904203f, 0.23448533f, -0.25713852f, -0.36516967f, 
    0.03235392f, 0.07748524f, -0.05629596f, -0.00153533f, -0.00153795f, -0.03080840f, 0.02678080f, -0.00068990f, 
    -0.01047513f, 0.00730949f, 0.12041365f, -0.10669228f, -0.04978623f, 0.03007932f, -0.06279001f, 0.08692711f, 
    -0.00211914f, -0.03853907f, -0.02223014f, -0.07360385f, 0.48238900f, 0.34086743f, 0.19126937f, -0.28825521f, 
    -0.23535138f, -0.09973065f, 0.19267669f, -0.03393014f, 0.06850790f, 0.03575432f, -0.16247340f, -0.22137620f, 
    0.10187163f, 0.30672041f, -0.36711755f, 0.07521394f, 0.00608708f, -0.15012689f, -0.11617240f, -0.09594940f, 
    -0.08199076f, -0.05929202f, -0.02260580f, -0.10231138f, 0.36697873f, 0.17832956f, -0.16425496f, 0.02327937f, 
    0.09475943f, 0.12752886f, -0.12270200f, -0.01174758f, 0.07543966f, -0.08889502f, 0.08919948f, 0.04841926f, 
    0.06192009f, 0.14993459f, 0.02056109f, 0.33184022f, -0.04570421f, 0.00818144f, -0.17708199f, 0.10408302f, 
    -0.02486510f, 0.08444792f, 0.04853834f, -0.06654970f, 0.42414108f, -0.30774906f, 0.28073037f, -0.39451945f, 
    -0.11322676f, -0.24301109f, -0.10884005f, -0.13941680f, -0.00161454f, -0.00147600f, 0.02096558f, 0.07913063f, 
    0.11334540f, 0.01258921f, 0.33752695f, -0.04263165f, 0.17639777f, -0.06866071f, -0.13100098f, 0.13854580f, 
    -0.01329673f, 0.00851925f, -0.03696326f, -0.01308825f, -0.99370104f, 0.05794140f, 0.03067318f, -0.45884192f, 
    0.10458118f, -0.02963390f, -0.18730439f, -0.41651565f, -0.00063667f, 0.09166039f, -0.11928418f, -0.17968312f, 
    -0.25883314f, -0.26049179f, 0.12543544f, 0.07089163f, -0.08452767f, 0.01460959f, 0.06251092f, 0.01583621f, 
    -0.13317390f, -0.03645130f, 0.03432063f, 0.16875568f, -0.35511866f, -0.04695719f, 0.08697839f, -0.10606492f, 
    -0.14431551f, 0.02658897f, 0.08100040f, 0.08474404f, -0.11644520f, -0.09130260f, 0.10737107f, -0.00840376f, 
    -0.18615146f, 0.27232695f, 0.27585185f, 0.13290893f, 0.01184485f, -0.02851401f, -0.09011012f, 0.04868330f, 
    0.00007488f, -0.07656356f, 0.03349042f, 0.00660317f, -0.09252823f, -0.15640709f, 0.05813367f, 0.07011469f, 
    0.00837696f, -0.07843715f, 0.08079483f, -0.04822637f, 0.05826261f, 0.15177123f, -0.00650083f, 0.06775143f, 
    0.42172945f, 0.40075973f, -0.10571753f, -0.00193891f, -0.17647913f, 0.07505249f, 0.05314112f, 0.05968228f, 
    -0.07650991f, 0.04378511f, 0.11527412f, -0.12056247f, 0.04148734f, -0.08658545f, -0.04295716f, 0.04498572f, 
    0.03083749f, 0.08170801f, -0.03382568f, -0.16626652f, -0.04111800f, -0.00292876f, 0.00196360f, 0.09079074f, 
    0.28749394f, 0.37844777f, 0.49879360f, 0.27197435f, 0.03969724f, 0.00069552f, -0.02862146f, 0.00111277f, 
    -0.00825483f, 0.17535415f, -0.46698022f, 0.16002515f, 0.92490458f, 0.02562700f, -0.28433198f, -0.43103790f, 
    -0.10733351f, 0.04891030f, -0.03833529f, 0.00098733f, 0.07218591f, -0.00439915f, -0.25284258f, 0.02680242f, 
    0.42939398f, 0.14974064f, -0.00318430f, 0.18082391f, -0.04643450f, -0.03249951f, -0.14174445f, 0.02728785f, 
    0.05778277f, 0.02370369f, -0.01172754f, 0.04555571f, -0.46430737f, -0.01748408f, -0.35155070f, 0.13667969f, 
    0.17960766f, -0.29109520f, 0.18541743f, -0.06202164f, -0.09709706f, -0.06860466f, 0.16269286f, -0.00071083f, 
    -0.19392887f, 0.02191690f, -0.50259107f, -0.29293406f, 0.15810241f, -0.01639074f, -0.07526278f, 0.10367583f, 
    -0.03639142f, -0.00185774f, 0.06389879f, -0.09090046f, -0.19965622f, 0.17741562f, 0.33427078f, -0.17171881f, 
    -0.08752948f, 0.20283824f, -0.14304399f, -0.08930219f, 0.19206829f, 0.10460858f, -0.12312004f, 0.08240277f, 
    0.07220247f, 0.10829507f, 0.15945618f, -0.17288794f, 0.05804437f, 0.02293894f, -0.11311200f, 0.15511221f, 
    0.07112102f, -0.10118552f, 0.02252647f, -0.09189593f, 0.03145488f, 0.06477696f, -0.04908236f, 0.02127860f, 
    -0.25096270f, -0.05563721f, -0.18571362f, -0.43068081f, 0.03325938f, -0.10231090f, -0.11452713f, -0.17353684f, 
    -0.00233526f, -0.11911583f, 0.12411804f, -0.20001633f, 0.01705862f, 0.01442785f, -0.15471835f, 0.02594421f, 
    -0.19218901f, -0.41139698f, -0.49072418f, -0.34383970f, 0.14178425f, 0.10272174f, -0.21773364f, 0.32582521f, 
    0.05247557f, 0.03858699f, 0.12242175f, -0.24853590f, -0.00039199f, 0.00366418f, -0.11331028f, 0.04095793f, 
    -0.29093999f, 0.25379273f, 0.10414424f, -0.10627053f, 0.06504317f, -0.13109986f, -0.01372753f, -0.01322759f, 
    -0.01127029f, 0.08836171f, 0.07904948f, -0.00918625f, 0.21658164f, 0.57601309f, 0.14475514f, 0.17683376f, 
    -0.15326087f, 0.06189189f, -0.05598895f, -0.08086602f, -0.00319495f, -0.06834295f, -0.02335888f, -0.12295353f, 
    0.78492361f, -0.10271068f, -0.35739377f, -0.38337877f, 0.04007389f, 0.00827093f, -0.06144735f, 0.03892794f, 
    0.11006903f, 0.28799668f, -0.05548920f, -0.01678691f, -0.08123908f, -0.04868164f, -0.36546278f, -0.03282452f, 
    0.10476460f, 0.01147914f, 0.30995515f, 0.36928204f, -0.01342057f, 0.16791984f, -0.09222500f, -0.01784113f, 
    0.09876208f, 0.02638185f, -0.10251496f, 0.02320950f, 0.02493796f, -0.07800259f, -0.22934954f, 0.08002799f, 
    0.10479357f, -0.25330982f, 0.03354925f, -0.01142359f, 0.24686302f, -0.09213527f, 0.01029540f, -0.15756840f, 
    -0.01673638f, -0.03769146f, 0.01561926f, 0.07286351f, -0.01026446f, -0.13088617f, -0.03723580f, 0.01773427f, 
    0.17237625f, 0.10847474f, 0.08412196f, 0.10555357f, 0.04765769f, 0.02386170f, -0.00862018f, -0.07735720f, 
    0.00328866f, 0.06961940f, -0.13361661f, 0.11019199f, -0.22368878f, 0.03553136f, 0.10125475f, 0.01291296f, 
    -0.30992240f, 0.25388041f, -0.19106446f, 0.17580844f, -0.06415235f, -0.03045053f, -0.03763415f, 0.06220607f, 
    -0.35800388f, -0.09203994f, -0.11508273f, -0.07405677f, -0.10944807f, 0.07530761f, 0.09873930f, 0.15127188f, 
    -0.14750852f, -0.09845778f, 0.05092838f, 0.08201633f, -0.18876486f, 0.12183075f, -0.52063769f, -0.11442952f, 
    -0.03466332f, -0.01704978f, -0.08708452f, 0.08607980f, 0.10105152f, -0.08823634f, -0.22423801f, 0.08751542f, 
    0.34893900f, -0.14118050f, -0.59008408f, 0.26083347f, 0.11688790f, 0.11285127f, 0.19656585f, -0.14486842f, 
    0.14044544f, -0.11828480f, -0.01323815f, 0.01047591f, -0.14697157f, -0.10830208f, 0.14024918f, 0.03136710f, 
    0.20177276f, 0.09091580f, 0.14681906f, -0.02123063f, 0.03308829f, 0.03111632f, 0.04948557f, -0.04538812f, 
    -0.36790845f, -0.11345947f, 0.06823366f, 0.16900152f, 0.08568635f, 0.05053601f, 0.01338312f, -0.20668542f, 
    -0.12368487f, 0.03119501f, 0.07041913f, -0.16386855f, -0.69151419f, -0.39497536f, 0.74972177f, -0.97178882f, 
    -0.07802429f, 0.00507517f, -0.06064677f, 0.07940323f, -0.03751229f, -0.14179331f, 0.09742115f, -0.01185661f, 
    -0.23442671f, -0.16454646f, 0.07292031f, -0.29176340f, 0.06540386f, 0.22513062f, -0.02683643f, -0.00956741f, 
    -0.09459995f, 0.02591607f, -0.06972001f, 0.02593655f, 0.48785415f, 0.59882057f, 0.25802645f, 0.48083800f, 
    -0.09083366f, -0.02728103f, 0.02879856f, -0.23884797f, -0.18219729f, 0.00647294f, -0.09417070f, 0.03288051f, 
    0.18067273f, -0.01226560f, -0.25517863f, 0.11829253f, 0.09493575f, -0.08317886f, 0.32934615f, -0.25683877f, 
    0.12352581f, 0.00127228f, -0.06403454f, 0.14323983f, 0.00998425f, -0.38340724f, -0.12009271f, 0.12772736f, 
    -0.00722684f, 0.11766146f, 0.01211884f, 0.07677837f, -0.00882202f, -0.05190801f, 0.14550129f, 0.13736564f, 
    0.12479778f, -0.38245454f, -0.06191991f, 0.18607430f, -0.08750300f, 0.04864197f, -0.05470820f, 0.18067470f, 
    0.04796396f, -0.02513377f, -0.01564051f, 0.03455323f, -0.01616760f, -0.06303319f, -0.08102149f, -0.00565540f, 
    -0.04065237f, -0.02124342f, 0.15699714f, 0.03420620f, -0.01918823f, 0.09580221f, -0.04574266f, -0.30442807f, 
    -0.31226641f, 0.12719654f, 0.27486649f, -0.08342000f, 0.04237491f, -0.03255402f, -0.04481491f, -0.01724274f, 
    -0.05839919f, 0.01752579f, 0.00689958f, -0.00743130f, -0.03284230f, -0.06941348f, 0.02361435f, -0.02582444f, 
    -0.05354001f, -0.34639430f, -0.25444028f, 0.16125663f, 0.04472649f, -0.05908116f, -0.06958391f, -0.02115748f, 
    -0.17733882f, -0.22153965f, -0.21661679f, -0.16183664f, 0.06637638f, -0.01357468f, 0.02012304f, -0.02884054f, 
    -0.05653975f, -0.03395332f, -0.27632335f, 0.10966810f, -0.20644298f, 0.64505392f, 0.58646643f, -0.08775911f, 
    -0.04486001f, 0.06747906f, -0.01864375f, -0.16459382f, -0.06350553f, 0.08559999f, 0.01728559f, -0.00961852f, 
    -0.14234753f, 0.16093074f, -0.45769745f, -0.02302262f, -0.01041056f, 0.02927483f, -0.10574570f, -0.02618954f, 
    0.00207881f, -0.01879867f, -0.16442861f, 0.04214871f, -0.12912767f, 0.13654460f, -0.06260060f, 0.05985173f, 
    -0.05600062f, -0.03711067f, 0.13690837f, 0.15842701f, 0.05882823f, 0.09816115f, 0.07721030f, -0.23720536f, 
    -0.24353577f, 0.10693040f, 0.10591070f, 0.13336636f, 0.01277522f, 0.04463584f, -0.03662943f, 0.19580594f, 
    -0.00733945f, -0.01672653f, -0.00582560f, 0.02235639f, -0.06838123f, -0.04698118f, 0.08632068f, -0.07921758f, 
    0.21322182f, 0.08075884f, -0.05621503f, -0.08900151f, 0.18829708f, 0.03271572f, -0.30030158f, 0.18979947f, 
    -0.29138225f, 0.00437091f, 0.03360188f, 0.17562802f, 0.01910983f, -0.00264406f, -0.10107122f, 0.07958677f, 
    0.03632241f, -0.13468243f, 0.07782897f, -0.01614432f, -0.12107185f, 0.40748456f, 0.23980664f, 0.26957735f, 
    -0.11437804f, -0.06241961f, 0.21429998f, 0.05942648f, 0.16559464f, 0.08014636f, 0.07621722f, 0.00708984f, 
    -0.02468960f, 0.15759856f, -0.06449804f, 0.02361115f, -0.02539842f, -0.02614083f, 0.05686975f, -0.22429769f, 
    0.12348768f, 0.09260777f, 0.04931412f, 0.20590639f, 0.02154338f, -0.47168911f, -0.16652614f, 0.22971730f, 
    0.02853234f, 0.06091199f, -0.10640212f, -0.00613434f, -0.06804255f, -0.03366461f, 0.02031567f, 0.00733360f, 
    -0.52075094f, -0.20698191f, 0.25636306f, 0.14386624f, 0.02542674f, 0.01741987f, -0.03938964f, 0.06386606f, 
    0.01760358f, -0.05924631f, 0.10338154f, -0.03578076f, -0.50565034f, 0.16861111f, 0.53508800f, 0.55030000f, 
    -0.08782829f, -0.06548726f, 0.25858876f, 0.19746591f, -0.00203247f, -0.03467041f, 0.04874949f, -0.04001692f, 
    -0.23982817f, 0.68065989f, 0.10108365f, 0.06836434f, 0.03662179f, -0.02816660f, -0.02290071f, 0.10635801f, 
    -0.02926695f, -0.06792559f, -0.13499385f, -0.12525579f, -0.13998151f, 0.34219414f, -0.10340672f, -0.38320518f, 
    -0.00817983f, -0.19049013f, 0.16010325f, -0.00588570f, 0.00667596f, -0.11076430f, -0.42258844f, 0.00604556f, 
    -0.03157160f, -0.09226655f, -0.11754581f, 0.05246568f, 0.10347329f, -0.05503842f, 0.04964264f, 0.05832754f, 
    0.12273637f, 0.07337952f, 0.00366656f, -0.05233544f, 0.12341672f, -0.09816935f, -0.29857665f, -0.04295914f, 
    -0.02276087f, -0.02189442f, -0.03410256f, 0.02670728f, 0.00031234f, -0.13597283f, -0.01889317f, -0.05018030f, 
    -0.11300910f, -0.14834054f, 0.00610968f, 0.00827622f, -0.01969670f, -0.02584680f, -0.01265254f, 0.06200524f, 
    0.07877389f, -0.22861926f, 0.02388943f, -0.06676243f, -1.04899454f, -0.87881893f, -0.47416461f, -0.55795550f, 
    -0.13322924f, -0.07551640f, -0.07510590f, -0.15175055f, 0.00869893f, -0.03524197f, -0.07205481f, -0.07467651f, 
    0.36035302f, 0.21946910f, -0.09174281f, 0.33025861f, -0.03834729f, 0.02582360f, -0.00697558f, -0.10957122f, 
    0.05539899f, -0.13264498f, 0.05627561f, -0.08090746f, -0.24132055f, 0.00551945f, -0.40229285f, 0.25341788f, 
    0.07153867f, 0.06758677f, -0.15810983f, -0.10368405f, -0.03060842f, 0.02372246f, -0.13769002f, 0.04872367f, 
    0.30008122f, -0.23987053f, -0.21404502f, 0.24504612f, -0.24787852f, 0.04831560f, 0.06258968f, 0.01337576f, 
    -0.06323382f, 0.05877234f, 0.16636686f, -0.04907379f, 0.23984915f, -0.11833663f, 0.25788182f, 0.01904595f, 
    -0.07874079f, -0.10971560f, 0.15734211f, -0.01931370f, -0.08054538f, -0.00577700f, 0.03028557f, 0.00496733f, 
    -0.00119414f, -0.24771149f, -0.05969228f, 0.20003943f, 0.00956130f, -0.02261434f, 0.08639467f, 0.05708438f, 
    0.04022103f, 0.03230973f, 0.07210930f, 0.06111282f, -0.46292689f, -0.05513987f, 0.60150981f, 0.27089262f, 
    -0.35660490f, -0.15772595f, -0.06462190f, 0.02397000f, 0.05194527f, 0.01265821f, 0.07637087f, 0.10751025f, 
    -0.07407700f, -0.08372304f, 0.05815232f, 0.27978733f, -0.05234442f, -0.06068337f, -0.09234335f, -0.08604691f, 
    -0.11202816f, -0.05457095f, -0.00764810f, 0.16315778f, 1.16563725f, -0.14929290f, 0.05055323f, 0.36634949f, 
    0.19033237f, -0.08264437f, 0.00300581f, -0.11366831f, -0.22666647f, -0.13726000f, 0.08258546f, 0.20145622f, 
    0.52488345f, 0.20286050f, -0.11125577f, 0.03282933f, -0.12488839f, -0.00397527f, -0.00684628f, -0.20131694f, 
    -0.06734393f, 0.08926687f, 0.06445130f, 0.21161924f, 0.15846114f, 0.09313242f, -0.17223985f, -0.56735075f, 
    0.09546074f, -0.05718544f, -0.14408998f, 0.08537263f, -0.27589455f, -0.01855354f, -0.04831933f, -0.08064388f, 
    0.15207830f, -0.42924571f, 0.12057110f, -0.21412106f, -0.23046473f, 0.10113908f, -0.05418962f, 0.11562161f, 
    0.14559968f, -0.05764442f, 0.08851777f, -0.33849025f, -0.12780154f, 0.17018844f, -0.20530029f, -0.16726474f, 
    0.32931265f, 0.15148714f, -0.06280589f, 0.21165022f, -0.19118336f, 0.29892725f, 0.00606868f, -0.09419113f, 
    -1.27144086f, -0.12789923f, -0.08237110f, -0.17161529f, -0.01160366f, -0.28710121f, 0.05100516f, -0.14092925f, 
    -0.16677849f, 0.10230435f, -0.04797964f, 0.01005920f, 0.10773510f, -0.42475650f, 0.51327896f, -0.14372568f, 
    -0.02513177f, -0.13374482f, -0.04919390f, 0.00971509f, -0.07554255f, -0.09508216f, -0.13741569f, -0.08301785f, 
    0.62699813f, -0.00429464f, -0.09221537f, -0.32196334f, -0.01639977f, 0.11988343f, -0.02284220f, 0.12449841f, 
    -0.29534358f, -0.14006941f, 0.21185327f, -0.01611071f, -0.35349289f, 0.03097850f, 0.02375943f, 0.44638821f, 
    0.19072919f, -0.09135471f, 0.06292596f, -0.00282219f, 0.05920855f, 0.02703369f, 0.19965784f, 0.03944349f, 
    -0.53458816f, 1.00291824f, -0.21842347f, -0.06151357f, -0.08940784f, 0.14309067f, 0.04201786f, -0.07204586f, 
    -0.04883698f, 0.04943621f, 0.07370543f, -0.01481097f, 0.52671915f, -0.46827331f, -0.08388361f, 0.07305165f, 
    -0.00686854f, -0.03534476f, -0.37403792f, 0.04511114f, -0.01906861f, -0.04416769f, -0.07754957f, -0.18618268f, 
    -0.01823937f, -0.03335603f, -0.06601227f, 0.09641331f, -0.06104071f, -0.04403159f, 0.06520344f, -0.02673959f, 
    -0.08918545f, 0.05230121f, -0.03368865f, -0.01167951f, 0.10989619f, -0.04800656f, -0.14103444f, -0.05703416f, 
    -0.10050842f, -0.01769165f, -0.12563269f, -0.22173648f, -0.22037414f, 0.06351332f, -0.15092070f, -0.08985353f, 
    -0.21925090f, 0.02981619f, -0.06845129f, -0.38162592f, -0.22655055f, 0.01066122f, -0.22782768f, -0.18605299f, 
    -0.00692557f, -0.22634645f, 0.01009930f, 0.07347440f, 0.47250885f, -0.16287525f, -0.14180104f, 0.18149471f, 
    0.24749073f, -0.01607526f, 0.15423065f, -0.03000124f, 0.01525290f, 0.07803180f, -0.02141025f, 0.06700914f, 
    -0.01946902f, -0.15108526f, -0.12765226f, 0.05849168f, -0.06869076f, -0.03240329f, 0.06828810f, -0.01902539f, 
    0.10538033f, -0.00141853f, 0.07525311f, 0.04773474f, -0.10062102f, -0.13813648f, -0.15511076f, 0.12883696f, 
    0.10538808f, 0.09305906f, 0.01138770f, 0.08061706f, -0.05294837f, 0.08005203f, -0.18191835f, 0.06746258f, 
    0.04543482f, -0.04931651f, -0.13823950f, -0.06747818f, -0.39488187f, -0.07443742f, -0.12114616f, -0.14595708f, 
    -0.03255000f, 0.04367942f, -0.00552760f, 0.04880480f, 0.06041141f, -0.18388167f, -0.01599747f, 0.31652099f, 
    0.07452419f, -0.04096392f, -0.20039617f, -0.04439313f, 0.00417889f, -0.00538674f, 0.07985575f, 0.13217317f, 
    -0.43664235f, -0.09394706f, -0.01423273f, 0.39552817f, 0.05165060f, -0.04356482f, -0.00509266f, 0.08064809f, 
    -0.08368675f, -0.06676691f, 0.17925116f, -0.07705788f, 0.11263121f, -0.11216357f, -0.01504138f, 0.26305100f, 
    0.09988806f, 0.10156371f, 0.00597225f, -0.24406712f, 0.08655758f, 0.24075769f, 0.00185334f, 0.22899193f, 
    0.05123844f, 1.05395234f, -0.17773943f, 0.41476092f, -0.09657462f, -0.11296915f, -0.01676336f, -0.14812568f, 
    0.06565577f, 0.08840728f, -0.11395527f, -0.05446728f, 0.10480798f, -0.08010665f, 0.01516922f, 0.12501691f, 
    -0.13119282f, -0.18816282f, -0.16383287f, -0.00094395f, -0.05879407f, 0.26370835f, -0.07740302f, -0.08399343f, 
    -0.40524757f, -0.50549209f, -0.33744255f, 0.00862335f, -0.14723036f, 0.01477347f, -0.37595731f, -0.11974509f, 
    0.01672418f, 0.10883069f, -0.12654231f, -0.13723516f, 0.04737850f, -0.26090890f, -0.06164501f, 0.18153977f, 
    0.08229256f, 0.08546019f, 0.12350544f, 0.15014049f, 0.01735471f, 0.07888255f, -0.05891116f, -0.17054939f, 
    0.68073606f, -0.19488543f, -0.10829393f, 0.21782625f, -0.10373963f, 0.13806482f, -0.01217049f, -0.00065834f, 
    0.02121997f, -0.11418257f, 0.07791886f, -0.30815077f, -0.12248965f, 0.39298475f, -0.21714236f, -0.82073641f, 
    0.25764278f, 0.03350197f, -0.11433844f, 0.19198212f, -0.23542057f, -0.07917855f, -0.01052952f, -0.00812054f, 
    -0.43555036f, 0.21353196f, -0.25862199f, 0.06679749f, -0.09350913f, -0.13354610f, 0.00530906f, -0.38621446f, 
    -0.08714825f, 0.07827347f, -0.32644761f, -0.00791162f, -0.25758111f, -0.22968118f, -0.17631459f, 0.38111758f, 
    0.26210332f, 0.11513862f, 0.09188387f, 0.07815721f, -0.06922752f, 0.03539550f, -0.06139719f, -0.00424772f, 
    -0.06305020f, 0.13730697f, 0.21834765f, -0.01660453f, 0.00510337f, 0.03535786f, 0.07796469f, -0.09905660f, 
    0.17016961f, 0.00724683f, 0.10533389f, 0.25950491f, 0.52005655f, 0.38023406f, -0.46035463f, 0.58603030f, 
    0.17515418f, 0.04827292f, 0.14881137f, 0.05796237f, 0.04262208f, 0.02295902f, -0.02152229f, -0.11179131f, 
    0.13328137f, 0.05164599f, -0.10028994f, 0.25759947f, 0.05635884f, -0.00801462f, 0.14128907f, -0.09809175f, 
    -0.05079135f, 0.01487801f, 0.05908373f, -0.04314663f, 0.07358975f, -0.36109746f, -0.29080680f, 0.09458444f, 
    -0.15827316f, -0.30539387f, -0.03196105f, 0.08548092f, -0.13484409f, -0.08213150f, 0.09441794f, -0.02998292f, 
    0.23006879f, -0.14810942f, 0.06026233f, -0.18548556f, -0.02463900f, -0.03158936f, -0.11790741f, -0.00221328f, 
    0.11370845f, -0.28358781f, -0.08306508f, -0.35721970f, 0.24325907f, -0.30942190f, 0.08044202f, -0.05128877f, 
    -0.07846478f, -0.04665186f, 0.00386842f, -0.01091941f, -0.06092264f, 0.03968368f, -0.05913363f, -0.10848589f, 
    0.10401072f, 0.08395179f, -0.15000801f, -0.04509611f, 0.01292116f, 0.06993621f, 0.08479019f, 0.05424436f, 
    0.13698488f, 0.01683730f, -0.09928994f, 0.04606350f, 0.29165262f, -0.04758917f, 0.21485947f, 0.04648693f, 
    -0.10569318f, -0.02881503f, -0.10332170f, 0.08136942f, 0.03827053f, -0.05198865f, -0.18236890f, -0.04301708f, 
    -0.28096718f, -0.08224737f, -0.11042688f, -0.12023052f, 0.04701038f, -0.08875954f, 0.03011557f, -0.00449987f, 
    -0.13944009f, 0.00848315f, -0.26777604f, -0.15536869f, 0.13905606f, 0.15689822f, -0.04096552f, 0.14097568f, 
    0.07557476f, -0.07543865f, 0.17135751f, 0.15313907f, 0.07772892f, -0.07306825f, 0.01930169f, -0.18935254f, 
    -0.39154246f, -0.44647649f, -0.27600235f, -0.52198631f, 0.10935273f, 0.07174408f, 0.06822044f, 0.03746237f, 
    0.06495094f, -0.06219088f, 0.02253468f, -0.17336202f, -0.18999064f, -0.03887613f, 0.11096776f, 0.12131923f, 
    -0.05206688f, 0.00064852f, -0.02032761f, -0.10270572f, 0.01216067f, -0.08600574f, 0.05369209f, 0.09259133f, 
    0.32214534f, -0.35083348f, 0.16950525f, -0.05479883f, 0.12374791f, 0.04702680f, 0.02467729f, 0.10269528f, 
    0.20847198f, -0.06575242f, 0.05508527f, 0.21087451f, -0.42284796f, -0.09723375f, 0.35435164f, -0.22391637f, 
    -0.35386077f, -0.00522429f, -0.61899078f, -0.04596271f, -0.03622283f, -0.04260463f, -0.14382367f, 0.02894876f, 
    -0.07254890f, 0.03815772f, 0.08939879f, 0.16357169f, -0.07709969f, 0.03467176f, -0.02725424f, 0.03162220f, 
    -0.03567610f, -0.04298824f, -0.01845274f, -0.02749132f, 0.02927739f, -0.05903187f, -0.33083349f, -0.09249806f, 
    0.00338337f, -0.10855858f, 0.17240275f, 0.05449116f, -0.06545868f, -0.19685198f, -0.01615938f, -0.17210568f, 
    -0.23907347f, -0.18517347f, -0.26546273f, 0.21130809f, -0.05998982f, -0.12033061f, 0.14299995f, -0.16265592f, 
    0.03876330f, 0.05507199f, -0.05189067f, 0.01807380f, -0.19663042f, -0.09564643f, 0.01460318f, 0.08681060f, 
    -0.12648903f, -0.01504823f, -0.00366583f, 0.19253244f, -0.02400654f, 0.03087445f, -0.09354121f, 0.03974255f, 
    -0.11304865f, 0.17843528f, -0.14442049f, 0.06992006f, 0.07467983f, -0.09660392f, 0.05322546f, -0.15271354f, 
    0.22189616f, 0.08768091f, 0.16309032f, 0.52373624f, -0.02549584f, -0.04102654f, 0.07307372f, 0.02532311f, 
    -0.11709609f, -0.00498512f, -0.05200551f, -0.04864402f, -0.10750128f, -0.01899363f, 0.12886901f, 0.09710148f, 
    -0.00895101f, -0.13918427f, 0.13044070f, 0.25425136f, -0.01141807f, 0.07737079f, 0.00521847f, -0.03916210f, 
    0.03625437f, 0.00046139f, -0.02666912f, -0.09615842f, -0.05414083f, -0.05115139f, 0.17375937f, 0.10587065f, 
    -0.15485209f, -0.07188814f, -0.05901149f, -0.05068803f, 0.02743130f, -0.01107411f, 0.01392357f, 0.02295863f, 
    -0.08787457f, 0.12848598f, 0.06390644f, -0.02519325f, 0.03137882f, -0.07734647f, -0.03564562f, -0.07912533f, 
    -0.15398163f, -0.21527973f, -0.16816665f, -0.04004093f, 0.11492313f, 0.00675878f, 0.25758478f, 0.24699508f, 
    0.23034279f, 0.02287475f, -0.23221029f, -0.11333238f, 0.03683587f, -0.35378999f, -0.23049459f, -0.23902395f, 
    0.12006482f, -0.10504106f, 0.30483437f, -0.09015445f, 0.07481837f, 0.08384845f, 0.16678476f, -0.09352326f, 
    0.04547234f, -0.23794053f, 0.04991143f, 0.04993252f, -0.06188311f, 0.02842960f, -0.10286187f, 0.09683877f, 
    0.15763934f, 0.04744102f, -0.04359481f, -0.10790280f, -0.08709969f, -0.10183567f, -0.14525093f, -0.23084265f, 
    0.13297334f, 0.06077862f, -0.00046448f, -0.05138223f, 0.11091184f, 0.13200557f, 0.05617505f, -0.05479011f, 
    0.06146081f, -0.02095933f, 0.01572721f, -0.11997065f, 0.21530533f, 0.31124237f, 0.39709148f, 0.37515959f, 
    -0.03410415f, -0.08054797f, -0.00953583f, 0.21708693f, 0.03424028f, 0.01869628f, 0.01313127f, -0.04615964f, 
    0.12204234f, 0.10774226f, -0.13462257f, -0.14812195f, -0.04091475f, -0.13243450f, -0.19144823f, -0.00912008f, 
    0.06695969f, -0.07628658f, -0.14267273f, 0.11582427f, 0.10142152f, -0.67286354f, 0.09680632f, 0.19176905f, 
    -0.28514931f, 0.10243206f, 0.14891227f, -0.05536440f, -0.11228530f, 0.05059778f, 0.14822055f, -0.11826967f, 
    0.01933517f, -0.29309124f, 0.27832744f, -0.43705174f, -0.06084037f, -0.01502994f, -0.10991716f, -0.17072852f, 
    -0.13020289f, -0.02534195f, -0.01132335f, -0.23814937f, 0.07639991f, 0.14490281f, 0.17023543f, 0.18904698f, 
    -0.11409089f, -0.24281709f, -0.06991307f, -0.11760405f, 0.21096201f, 0.07678881f, 0.02394543f, 0.01101075f, 
    0.00869151f, 0.03851226f, 0.12506023f, -0.14266483f, 0.08487125f, -0.07174708f, -0.06055727f, -0.18288305f, 
    0.01894130f, -0.07327282f, -0.10574179f, -0.19476974f, -0.05719605f, 0.26928106f, -0.79539871f, 0.23844314f, 
    0.27103901f, 0.09710831f, 0.03445178f, 0.13301758f, 0.08717524f, 0.05286786f, -0.07648466f, -0.09265774f, 
    -0.00278601f, 0.16867083f, 0.04938381f, -0.11629128f, -0.02155836f, 0.28650245f, 0.16191068f, 0.12328044f, 
    0.09533715f, 0.07054519f, 0.08623729f, 0.11996805f, -0.39897874f, 0.37167439f, -0.35158026f, -0.01981714f, 
    -0.11242417f, 0.01471969f, 0.00963925f, 0.25636843f, 0.20134236f, -0.09727322f, -0.33390683f, -0.10457996f, 
    -0.13251138f, 0.33297536f, -0.26460755f, 0.01147855f, 0.32916889f, -0.06329716f, 0.06350633f, 0.01229149f, 
    -0.03324626f, 0.00086597f, 0.09587840f, -0.09966592f, 0.03520488f, -0.06948522f, 0.01976594f, 0.24300596f, 
    0.08203157f, -0.11450878f, -0.03028500f, 0.01840153f, 0.25524062f, 0.01700506f, -0.01993609f, 0.05104852f, 
    -0.05962798f, -0.13854316f, 0.07770956f, 0.14139013f, 0.04800383f, -0.01243292f, -0.01643376f, -0.05369939f, 
    -0.04671990f, -0.02869830f, 0.10920478f, 0.09887937f, 0.00127615f, 0.03161279f, -0.16501677f, 0.14081569f, 
    -0.17675941f, 0.03401372f, 0.06326155f, -0.19868222f, 0.09926839f, -0.01193197f, 0.01083895f, -0.08445710f, 
    0.27089450f, -0.38278654f, 0.12188390f, -0.05187530f, 0.10344612f, 0.03285449f, -0.01515552f, 0.05827822f, 
    0.27096915f, -0.07315093f, 0.14458026f, -0.04821127f, -0.03681350f, 0.08480824f, -0.11233286f, -0.17274229f, 
    0.14613476f, 0.18779118f, 0.01813207f, 0.25850022f, 0.03992037f, 0.00230326f, 0.11449807f, 0.21626221f, 
    0.15977222f, -0.19348571f, -0.29173484f, 0.25719067f, -0.01316393f, -0.02942552f, -0.03466350f, -0.02263658f, 
    0.07535435f, -0.39462644f, 0.14928529f, 0.09779914f, -0.29359168f, -0.42004782f, -0.10721231f, -0.48957530f, 
    0.06904002f, 0.00192199f, 0.05356983f, 0.09866894f, 0.18401718f, -0.14019898f, -0.06006757f, -0.16822943f, 
    -0.34534800f, -0.16789749f, 0.12598738f, -0.08221383f, -0.02855636f, 0.00400778f, 0.02167964f, 0.04191574f, 
    -0.14148608f, 0.03839534f, -0.13481611f, -0.25189108f, 0.45796546f, 0.06426486f, -0.04232695f, -0.01494184f, 
    -0.07608855f, 0.15961586f, 0.00494110f, -0.13608962f, 0.09524918f, -0.03747392f, -0.08442335f, 0.25228217f, 
    0.02578351f, 0.04088816f, 0.60409445f, 0.07517533f, -0.03632002f, 0.04780101f, 0.07511499f, 0.06728785f, 
    0.06894656f, -0.00067630f, -0.04712655f, 0.01070359f, 0.10637338f, -0.08021531f, -0.14540610f, 0.25635383f, 
    0.07569799f, -0.31484717f, 0.06549680f, 0.14512014f, -0.05576432f, -0.06510298f, 0.08902167f, 0.18119399f, 
    -0.09140979f, -0.27747345f, 0.10369890f, 0.32793805f, 0.07353152f, -0.10686766f, 0.00488484f, 0.11035575f, 
    -0.09060313f, 0.27781200f, -0.09604254f, 0.03307952f, -0.37778500f, -0.03525140f, -0.31589752f, -0.25909027f, 
    0.11874694f, 0.00500123f, -0.01193009f, 0.00260869f, -0.19842470f, -0.19266236f, -0.01079423f, 0.01860412f, 
    0.14615919f, -0.12488931f, -0.26253468f, -0.02133115f, -0.05952732f, 0.09961484f, 0.11942591f, -0.01655843f, 
    -0.24136424f, -0.24806246f, -0.22205068f, -0.58397549f, -0.10658230f, 0.26099756f, 0.46457130f, -0.11320352f, 
    0.04463970f, -0.06818883f, -0.27370000f, 0.21573138f, 0.06379300f, -0.01408174f, 0.13390015f, -0.03226938f, 
    0.25994852f, -0.12471921f, -0.06430299f, -0.02875943f, 0.03118636f, 0.13995029f, -0.10547484f, 0.20950650f, 
    0.04835184f, -0.01752794f, -0.03878079f, 0.09122027f, -0.12123842f, -0.11327357f, -0.05197595f, -0.31915763f, 
    0.22841060f, -0.11074162f, 0.11455860f, -0.03968402f, -0.03188074f, 0.05547487f, -0.00874485f, 0.07355500f, 
    -0.32851881f, -0.44357085f, -0.70268172f, -0.25831324f, -0.00777884f, 0.10344714f, -0.06841118f, -0.20382796f, 
    0.10962141f, -0.08641881f, 0.21618253f, 0.14080295f, -0.28384891f, 0.08557852f, 0.15539332f, -0.17262460f, 
    -0.32737619f, -0.00029280f, 0.11968010f, -0.22510326f, 0.06469946f, -0.11781644f, 0.16017690f, 0.09084560f, 
    -0.00792524f, -0.13635917f, -0.04241598f, -0.11135781f, -0.24290071f, -0.02712673f, -0.12432314f, -0.06690094f, 
    -0.16019325f, 0.09288039f, 0.02621874f, -0.13669287f, -0.22784770f, 0.01917992f, -0.17454959f, 0.20944184f, 
    -0.07260133f, 0.00289309f, 0.01763459f, -0.02849571f, 0.03930523f, 0.23875891f, 0.01587767f, 0.13532597f, 
    -0.04441538f, -0.11843017f, -0.25088897f, 0.11243159f, -0.02573534f, -0.06841187f, -0.03646304f, -0.09363261f, 
    0.08791503f, -0.13144445f, 0.13810110f, 0.18890099f, 0.09285292f, 0.17192207f, 0.09100179f, 0.00378683f, 
    0.41357893f, 0.11921769f, 0.13200535f, -0.26895204f, 0.10289454f, 0.01618705f, 0.03783078f, 0.03900861f, 
    -0.63469481f, -0.26210466f, 0.09002563f, 0.11735048f, 0.13363840f, -0.00513624f, -0.02324271f, -0.21225953f, 
    0.08557982f, 0.31931612f, 0.09529391f, -0.09429649f, -0.55150521f, 0.11164970f, 0.46998885f, 0.23636204f, 
    0.04016591f, -0.04257258f, 0.19232458f, -0.18637945f, -0.08125455f, -0.08234213f, 0.01742104f, 0.10089182f, 
    0.01612554f, -0.02653688f, 0.43366617f, -0.25527027f, -0.02355812f, 0.01704758f, -0.25367779f, 0.19621129f, 
    0.03229541f, 0.05700026f, -0.11548129f, 0.15182461f, -0.01460709f, 0.08108267f, -0.09655366f, -0.38423586f, 
    -0.10556982f, 0.13224585f, -0.05629469f, -0.01808237f, -0.08101641f, -0.19815692f, -0.10083540f, -0.10316685f, 
    -0.37639299f, -0.94863749f, -0.38503623f, -0.05923963f, -0.04692631f, 0.18549451f, 0.09259065f, -0.08941022f, 
    -0.08158368f, 0.01213544f, -0.04494887f, 0.10514638f, 0.09087637f, -0.76099032f, -0.34848246f, -0.54948270f, 
    0.02311094f, 0.23625466f, 0.15674755f, -0.20093401f, -0.03463229f, 0.04001388f, -0.07877323f, 0.01874302f, 
    -0.72475928f, -0.70995802f, -0.32320708f, -0.03051743f, -0.13171433f, -0.59334397f, -0.04047338f, -0.49139708f, 
    -0.12088965f, -0.04571800f, -0.05652754f, -0.13886680f, -0.46836853f, -0.14608294f, 0.37628546f, 0.12383506f, 
    -0.15576133f, -0.04045739f, -0.08249445f, -0.02384038f, 0.02943750f, -0.01028003f, 0.15140793f, -0.01710477f, 
    0.21808079f, -0.01812869f, 0.03513471f, -0.16453235f, 0.12668085f, 0.22672296f, 0.17524676f, 0.12532587f, 
    0.25348499f, 0.18499233f, 0.07019369f, -0.22537547f, -0.25917092f, 0.08219180f, 0.13823408f, -0.35040689f, 
    -0.02710077f, -0.01147639f, -0.04916730f, 0.07223708f, 0.07594386f, 0.04639582f, 0.17983259f, -0.05024099f, 
    0.12494401f, 0.12694691f, -0.36119562f, -0.06396572f, -0.04536042f, 0.00299738f, 0.07061121f, -0.08319251f, 
    -0.07426462f, 0.02715889f, 0.18679206f, -0.09163117f, -0.25849232f, 0.04583075f, 0.15186748f, 0.02362417f, 
    -0.09524507f, -0.04386855f, -0.09574451f, -0.00644434f, -0.15481412f, -0.12521563f, -0.20104992f, 0.28915960f, 
    0.07631931f, 0.19903132f, 0.02275532f, 0.06109340f, 0.08520242f, 0.06308471f, 0.09129716f, 0.15522222f, 
    0.07624491f, 0.09282140f, 0.27917597f, 0.15689699f, -0.00530736f, -0.25391504f, 0.10391065f, -0.07085590f, 
    0.03846800f, -0.08244333f, 0.00793893f, -0.36493650f, 0.04750842f, -0.03330481f, -0.04686742f, -0.13304716f, 
    0.06557725f, 0.01027612f, 0.07840940f, -0.05654950f, -0.02898698f, 0.03975932f, 0.02337598f, 0.05824589f, 
    -0.19353120f, -0.06737205f, 0.09554926f, -0.01860197f, 0.06233909f, 0.79452920f, -0.04915472f, 0.13820502f, 
    -0.04300055f, 0.01366767f, 0.03021878f, 0.16951241f, 0.04262235f, 0.11703449f, 0.25532502f, 0.00701510f, 
    -0.14931846f, 0.08245935f, 0.00162733f, -0.01907060f, 0.00235825f, 0.07368105f, 0.00627212f, -0.09061880f, 
    0.02784136f, -0.10420061f, 0.19391693f, -0.06341436f, -0.19049671f, 0.54905051f, 0.15719669f, 0.02423500f, 
    0.03035284f, 0.02860749f, 0.00284340f, 0.02263332f, 0.08749411f, 0.02679250f, -0.05181603f, 0.08924526f, 
    0.05696776f, -0.59471667f, -0.89108008f, -0.20283036f, -0.02347133f, 0.09237798f, 0.08104529f, -0.11736900f, 
    0.02340586f, 0.05916060f, 0.08605944f, 0.04860955f, 0.22629292f, -0.18613981f, 0.04142687f, 0.27641508f, 
    -0.05758430f, -0.15189660f, 0.16328520f, 0.15119322f, -0.01089320f, 0.31760344f, 0.01864139f, -0.26013303f, 
    0.29565051f, -0.13148491f, -0.55110645f, -0.02419170f, -0.11681654f, 0.01672695f, 0.10635373f, 0.04832252f, 
    -0.06897010f, 0.01487128f, -0.01759187f, 0.04712382f, -0.95712358f, 0.41511995f, 0.33502495f, 0.10982168f, 
    -0.34121090f, 0.12958750f, 0.06920391f, 0.22284105f, -0.01456217f, 0.16810133f, -0.00712471f, -0.02833240f, 
    0.34967512f, 0.19367877f, 0.06011253f, 0.08465052f, -0.04797804f, 0.04010722f, -0.03045650f, 0.06685838f, 
    0.17874503f, 0.37853473f, 0.27679992f, 0.02260222f, -0.95979398f, -0.87171715f, -0.20684679f, 0.25650251f, 
    -0.14351703f, 0.00032503f, 0.08718658f, -0.27647078f, -0.03304445f, 0.02633347f, 0.06113227f, -0.01962724f, 
    0.04142077f, -0.37239277f, -0.49063602f, 0.02453194f, -0.05775546f, 0.13928445f, 0.02823470f, 0.11032509f, 
    -0.02481425f, 0.04100446f, -0.11904132f, 0.00384782f, -0.43652573f, -0.73695886f, -0.52614659f, 0.02498217f, 
    0.23014636f, 0.05035550f, -0.18161343f, -0.21906167f, 0.02023931f, 0.06373336f, -0.12527440f, -0.04703461f, 
    0.33704519f, 0.39042011f, 0.18859206f, 0.35082594f, 0.14262405f, -0.21199530f, 0.03662243f, -0.23522766f, 
    -0.13494305f, 0.02877324f, -0.18385139f, 0.16815479f, -0.32298142f, -0.31800967f, 0.43904632f, -0.11675969f, 
    0.00512266f, -0.42483017f, -0.09775430f, 0.10121470f, -0.04448606f, 0.18513012f, 0.12212635f, -0.32366961f, 
    -0.10358680f, -0.03391897f, -0.16619605f, 0.14309888f, -0.01075201f, 0.03175322f, -0.01071978f, 0.20184864f, 
    0.14185902f, 0.11722977f, 0.09458953f, 0.07777681f, 0.23440860f, 0.08356288f, 0.18401408f, 0.07273987f, 
    0.16621496f, -0.01482586f, 0.00941231f, -0.03795730f, -0.00489513f, 0.05806616f, -0.10811156f, -0.07939184f, 
    0.03492749f, -0.08550236f, -0.03893033f, -0.13696480f, -0.00347861f, -0.04130451f, 0.02347788f, -0.03970695f, 
    -0.14486639f, -0.06119793f, -0.25771308f, -0.22572191f, -0.78904259f, -0.92974669f, -0.73462653f, -0.35589957f, 
    -0.29621065f, -0.29365608f, -0.31590906f, -0.45684242f, -0.02667947f, -0.00422119f, -0.03831521f, -0.02880788f, 
    -0.61910689f, 0.09099155f, 0.55947888f, 0.26896897f, 0.02166563f, -0.10822549f, -0.29797980f, -0.21155557f, 
    -0.15464635f, 0.03809542f, 0.02184035f, 0.03917377f, -0.12925483f, -0.31100175f, 0.38272330f, 0.04493082f, 
    0.07256687f, -0.31699964f, -0.17200819f, 0.10183351f, -0.07790022f, 0.07963365f, 0.23593241f, -0.03023900f, 
    -0.19919099f, -0.33582869f, -0.10018330f, 0.24748750f, -0.07015876f, -0.08177367f, 0.08294317f, 0.29399237f, 
    0.07294516f, 0.05726076f, -0.11839090f, -0.08377314f, -0.25208437f, 0.11048299f, 0.30524531f, -0.38622296f, 
    -0.07618678f, 0.02370114f, -0.03120631f, -0.01665468f, -0.16330171f, 0.14377959f, -0.03965104f, 0.02016076f, 
    -0.38233423f, -0.29690194f, 0.08080388f, -0.04063444f, 0.13964750f, 0.12393301f, 0.21505202f, 0.09033202f, 
    0.03342950f, -0.16079576f, 0.00714443f, -0.00202451f, -0.12526223f, 0.33109042f, -0.04129001f, -0.00160694f, 
    -0.03342324f, -0.05141847f, -0.06707720f, 0.11463191f, 0.04963298f, 0.00417800f, 0.09825412f, 0.00107252f, 
    -0.48703054f, -0.38293236f, 0.04541814f, -0.10377663f, -0.22022688f, -0.01649501f, -0.35186237f, 0.09283381f, 
    -0.00983416f, 0.03190323f, -0.07118280f, 0.05607997f, 0.30899411f, 0.18636778f, -0.66860801f, 0.08777035f, 
    -0.03024586f, 0.10970165f, 0.21648958f, -0.01423603f, 0.13291007f, 0.04486579f, 0.07599984f, 0.04955172f, 
    0.18293871f, 0.24463393f, -0.33764237f, 0.26470274f, -0.06154933f, -0.06040019f, 0.05901925f, -0.08054528f, 
    -0.05533742f, -0.25702399f, -0.03675771f, 0.15021180f, 0.39998212f, 0.22915773f, -0.13383198f, -0.16810943f, 
    -0.04017931f, 0.07655694f, -0.00209658f, -0.12343652f, -0.07903829f, 0.22644737f, -0.06225706f, -0.02129603f, 
    0.15571734f, -0.05958924f, 0.04912942f, -0.17484631f, -0.00505607f, 0.07850111f, -0.06076523f, -0.08956841f, 
    -0.06404658f, 0.08178890f, -0.03620151f, 0.03317231f, 0.29985145f, 0.11735872f, -0.19262755f, -0.19882779f, 
    -0.00032414f, 0.10033412f, 0.11150022f, 0.02067683f, -0.04465353f, 0.00276811f, 0.07313110f, 0.07909639f, 
    0.06435291f, -0.21294060f, 0.14331788f, -0.22530833f, -0.01794937f, 0.10015590f, -0.07552966f, -0.08274573f, 
    0.05564205f, -0.11639374f, -0.09629927f, -0.19709049f, -0.09411835f, 0.18436991f, -0.00102489f, -0.00254186f, 
    0.00282161f, -0.29170182f, 0.02342878f, -0.19689389f, -0.03017264f, 0.02654034f, 0.01584145f, -0.01134939f, 
    0.02577439f, 0.04471603f, 0.04215878f, 0.03764261f, 0.06585885f, 0.10156656f, 0.04112276f, 0.00383675f, 
    0.02831225f, 0.01438203f, 0.04438112f, -0.07585678f, -0.49269515f, -0.69966799f, -0.52800578f, 0.09737556f, 
    -0.08833887f, -0.11720496f, 0.13972117f, -0.07068747f, -0.05867514f, 0.11980983f, 0.04283358f, 0.00847183f, 
    0.09513140f, -0.04124745f, 0.12963900f, -0.04040021f, 0.01187985f, -0.06758328f, 0.10617001f, -0.12360774f, 
    0.04960273f, 0.08474779f, 0.08166095f, 0.05135589f, -0.77858394f, -0.02557352f, 0.06428992f, -0.08575463f, 
    -0.02809249f, 0.15191440f, 0.21404834f, 0.01534285f, -0.03561166f, -0.05376204f, -0.13991934f, 0.01533911f, 
    0.22896913f, -0.78853583f, 0.11811166f, 0.31800729f, -0.09545683f, -0.17981496f, -0.33085141f, -0.04710364f, 
    0.02748044f, -0.06339198f, -0.12979612f, -0.03754901f, 0.00138942f, -0.18560389f, 0.11452073f, -0.07520658f, 
    -0.02743091f, 0.09671922f, -0.03031003f, -0.11944014f, -0.09147248f, -0.15265195f, 0.03874152f, -0.07958484f, 
    -0.03871097f, -0.24622123f, -0.05793322f, -0.13672309f, -0.14143763f, 0.11158978f, -0.07498536f, -0.06125604f, 
    -0.02383872f, 0.01666545f, 0.02824134f, -0.03405703f, 0.65958434f, -0.63104939f, -0.10370225f, -0.24218908f, 
    -0.11107958f, -0.39101136f, 0.04653371f, 0.17952861f, 0.09358639f, -0.01977360f, 0.01885304f, 0.02667647f, 
    -0.11288720f, -0.21127163f, 0.06432542f, 0.16129807f, 0.02262392f, 0.01988783f, -0.03566029f, -0.06336598f, 
    0.23159029f, 0.08278482f, 0.06929450f, 0.04006879f, -0.11386917f, -0.84242809f, 0.48563522f, -0.03278384f, 
    0.03991766f, 0.13687162f, 0.04873448f, 0.22156443f, -0.03028994f, -0.12448950f, -0.07490657f, -0.00072252f, 
    0.09862687f, -0.17956975f, 0.07305322f, -0.17589317f, -0.02733075f, 0.00035748f, -0.09651659f, -0.07304024f, 
    0.07906859f, -0.14000286f, 0.01695593f, -0.01290220f, -0.80302185f, -0.51401591f, -0.48301682f, -0.58905214f, 
    0.17558536f, 0.07710452f, -0.07671863f, 0.23977196f, 0.09697123f, -0.03760295f, 0.00382254f, -0.08231356f, 
    -0.26088306f, 0.02944020f, -0.06600954f, -0.02727166f, -0.13870852f, 0.07568038f, 0.09332979f, 0.04383958f, 
    -0.11325815f, -0.19734140f, 0.04017654f, -0.00404869f, 0.17352436f, -0.48655826f, -0.13223527f, -0.10373418f, 
    -0.21867621f, -0.05271693f, -0.06130557f, -0.03888687f, -0.04071641f, -0.09970690f, 0.02754365f, 0.02885818f, 
    -0.07951039f, 0.01441141f, 0.03109128f, 0.08330080f, 0.07622750f, -0.26843715f, 0.13571036f, -0.23699439f, 
    -0.07359972f, -0.06663281f, 0.12055087f, 0.13579734f, -0.09594513f, -0.02069798f, -0.08679020f, 0.05067863f, 
    -0.12265000f, 0.02430019f, 0.00474442f, -0.04715025f, -0.04689842f, -0.02937448f, 0.07982804f, -0.04016386f, 
    0.01893872f, 0.11372095f, -0.02842039f, -0.01771927f, 0.00074386f, -0.10433494f, 0.04812750f, -0.01247407f, 
    0.05404291f, -0.07572006f, -0.04638098f, -0.00864506f, -0.62720424f, -0.49292323f, -0.18301857f, 0.87366533f, 
    0.10205595f, 0.06189781f, 0.11272060f, 0.10939950f, 0.04761714f, 0.01135321f, -0.03144297f, -0.00206039f, 
    0.62594795f, 0.12314736f, -0.24495806f, -0.14009567f, -0.03452416f, -0.15673128f, -0.23664857f, 0.01688847f, 
    0.05544531f, 0.07718212f, 0.04904963f, 0.06760167f, 0.80922133f, -0.32493234f, 0.17776328f, -0.90552109f, 
    0.08642058f, -0.03721587f, -0.16271023f, 0.24667662f, 0.02667372f, -0.01166003f, -0.08966260f, -0.24446356f, 
    -0.48583540f, 0.12506172f, 0.78139508f, -0.60154438f, -0.04796146f, 0.01839203f, 0.07456750f, -0.00477461f, 
    0.02778083f, -0.01291419f, -0.05804568f, -0.04536751f, -0.06308296f, -0.50356501f, -0.17703605f, -0.31854278f, 
    -0.02309675f, 0.00040640f, -0.05832810f, 0.14067425f, 0.30791235f, 0.01428263f, 0.05257897f, -0.04171705f, 
    0.00234646f, -0.69790608f, -0.65400702f, -0.13248661f, 0.11444452f, 0.03373677f, -0.15490058f, 0.03604643f, 
    -0.03340960f, -0.01688082f, -0.01443119f, -0.20160457f, -0.72443676f, 0.19211279f, 0.33340162f, 0.24004404f, 
    -0.00736520f, -0.04422315f, -0.20675032f, -0.09892453f, -0.13464294f, -0.00970002f, -0.06347352f, -0.03815538f, 
    -0.17047897f, -0.11425664f, -0.29551443f, -0.11052061f, 0.01992015f, -0.24576329f, 0.13011658f, -0.02340353f, 
    -0.01023938f, 0.02128888f, 0.14119866f, 0.16323617f, -0.23419522f, -0.49055445f, -0.19702448f, 0.39167774f, 
    0.14936467f, 0.22584102f, 0.03616302f, 0.17325494f, -0.19830847f, 0.12470008f, 0.12831749f, -0.37207317f, 
    0.03275598f, -0.11294187f, -0.18520357f, 0.04509394f, -0.05630338f, 0.17604710f, -0.18110035f, 0.15270068f, 
    -0.21422274f, 0.02490335f, -0.31600481f, -0.17717645f, 0.11978137f, -0.26832631f, -0.32891628f, -0.44260174f, 
    -0.01252502f, 0.11660593f, 0.03702808f, 0.09461439f, 0.17819019f, -0.06393692f, 0.00969042f, 0.10597711f, 
    0.07573249f, 0.18123025f, -0.03193741f, -0.05762488f, 0.01759751f, -0.16426308f, 0.05929284f, -0.04292962f, 
    -0.20331672f, 0.00380570f, 0.22047663f, -0.03196743f, -0.02413148f, -0.19128826f, -0.06959364f, -0.11447940f, 
    -0.17360808f, 0.00084813f, 0.02943958f, -0.07816455f, 0.22206102f, 0.08878141f, 0.22485124f, 0.15777008f, 
    0.06731201f, 0.00224333f, 0.09057011f, -0.05756070f, -0.00795223f, 0.05786274f, 0.02192060f, -0.04662881f, 
    0.04838708f, 0.00847479f, -0.18486071f, 0.20255576f, -0.18773703f, 0.04641059f, 0.01778001f, -0.03952994f, 
    -0.04728899f, -0.02114394f, 0.04041950f, -0.03324041f, -0.00222264f, 0.11252552f, 0.05838524f, 0.13256742f, 
    -0.17996833f, 0.26895508f, -0.00994484f, -0.20782886f, -0.08637099f, -0.08827021f, -0.14488305f, -0.12835440f, 
    -0.02870404f, 0.04468179f, 0.02374142f, 0.07608145f, -0.70775765f, -0.81901091f, -0.03308454f, 0.34269658f, 
    0.07094686f, 0.19669367f, 0.09453463f, 0.05702426f, 0.05060884f, 0.07921736f, -0.08067484f, 0.17435688f, 
    -0.14288214f, 0.01144211f, -0.01986949f, -0.19725700f, -0.12443725f, -0.13830292f, -0.04847476f, -0.35636944f, 
    -0.42577928f, -0.15949562f, -0.24178295f, -0.29470667f, 0.52057016f, -0.02443692f, -0.00807253f, -0.14205801f, 
    0.03848503f, 0.28474268f, 0.33155668f, -0.10043748f, 0.02034962f, -0.12870906f, 0.07128479f, 0.11606072f, 
    0.51294851f, -0.03564496f, -0.02728258f, -0.33120829f, 0.11530491f, -0.08954081f, 0.05846667f, 0.02884723f, 
    0.02589978f, 0.01664830f, 0.04944449f, 0.05942829f, -0.04160728f, 0.27224019f, -0.20967120f, 0.05888681f, 
    -0.00327561f, -0.04009498f, -0.01941879f, 0.09870056f, 0.10028008f, 0.14201693f, 0.05175641f, 0.27293500f, 
    0.12949221f, 0.31775334f, -0.10172830f, 0.01261982f, 0.24186887f, -0.02879572f, -0.11261097f, 0.01101519f, 
    -0.09716257f, 0.04125491f, 0.22774452f, 0.06363490f, -0.09002561f, -0.65967625f, -0.36702085f, -0.07126183f, 
    -0.03585401f, 0.14440167f, 0.15913372f, 0.18714879f, -0.08167496f, -0.08729566f, -0.01066448f, -0.11143107f, 
    -0.33483332f, 0.01671971f, -0.01741407f, 0.11161197f, 0.04413971f, 0.02636289f, -0.04706980f, -0.02564119f, 
    -0.45048311f, -0.07757621f, -0.45764932f, -0.49786383f, 0.29482374f, -0.14882958f, -0.39780495f, -0.48553172f, 
    -0.04266988f, -0.21017823f, -0.05278051f, -0.27062416f, 0.02431530f, 0.01595104f, 0.02175388f, -0.06941541f, 
    -0.08838789f, 0.03421555f, 0.13047576f, 0.04348185f, 0.16596337f, -0.22124751f, -0.00300852f, -0.12418379f, 
    0.05582868f, 0.15820363f, 0.09548455f, 0.12136343f, 0.14057709f, -0.59683967f, -0.40072268f, 0.23920475f, 
    0.14956851f, 0.18489888f, 0.10206924f, -0.29581007f, -0.03339304f, 0.00783885f, -0.04895943f, 0.00089566f, 
    -0.50965214f, -0.02048735f, 0.22679381f, 0.31736729f, -0.08101073f, 0.14794795f, 0.10641163f, 0.10046623f, 
    0.04088705f, 0.17979869f, 0.08074164f, 0.16938747f, 0.03565101f, -0.31016126f, -0.40881690f, -0.26224038f, 
    0.08589364f, 0.02551954f, 0.10319248f, 0.17891780f, 0.07082327f, 0.16041732f, 0.24157691f, 0.19386460f, 
    -0.04370207f, -0.13945128f, -0.07892234f, 0.00839005f, 0.11547332f, 0.11312696f, 0.09788184f, -0.11353812f, 
    -0.04916457f, -0.09149290f, -0.21185340f, -0.00725629f, -0.06287178f, 0.15576431f, -0.05579193f, 0.07562400f, 
    0.06504695f, 0.06849411f, 0.02762900f, 0.02789234f, 0.01149183f, 0.06513298f, 0.06132197f, 0.20465744f, 
    -0.28338620f, -0.03995198f, 0.00242396f, -0.11620140f, -0.12945180f, -0.09477307f, -0.01782783f, -0.04007517f, 
    0.00487592f, 0.07657997f, 0.00373777f, 0.08938759f, -0.33849141f, -0.79313266f, -0.35499579f, -0.10496575f, 
    0.05033647f, -0.05130962f, -0.09178722f, 0.11088461f, -0.00371842f, 0.03301876f, 0.03559167f, 0.05815830f, 
    0.11845975f, -0.24441253f, -0.24645567f, -0.12959448f, -0.09364159f, 0.24603491f, 0.19374819f, 0.19976160f, 
    0.05526263f, -0.14121158f, 0.15413852f, -0.02722374f, 0.38472319f, 0.29528928f, -0.52849799f, -0.62266827f, 
    0.12837359f, -0.43288344f, -0.02145928f, -0.01315693f, 0.08006810f, 0.11649556f, -0.01073366f, 0.25608686f, 
    0.64308262f, -0.49136636f, -0.10747634f, 0.33780298f, 0.25041971f, 0.29102951f, 0.11871216f, -0.19229177f, 
    0.15538399f, -0.03961098f, 0.21022578f, 0.11327223f, -0.01166544f, -0.24006248f, -0.23322497f, 0.16187690f, 
    -0.06715720f, 0.13949203f, 0.03622720f, 0.21467759f, -0.30539146f, -0.26395407f, -0.22040416f, -0.15295158f, 
    0.05972537f, 0.34862262f, -0.02788270f, -0.24598326f, -0.27753791f, -0.07231209f, 0.13657077f, 0.12676209f, 
    0.19399709f, 0.18011348f, 0.11224849f, 0.02392362f, -0.02056939f, -0.17163980f, -0.75466639f, 0.29379278f, 
    0.02055356f, 0.14941475f, 0.28201970f, 0.16924113f, 0.07129609f, 0.05454491f, -0.06594037f, -0.03854975f, 
    -0.09651814f, -0.38147569f, 0.10445567f, -0.48237267f, -0.33883744f, -0.04984967f, -0.08403952f, 0.08445013f, 
    0.08221852f, -0.07766595f, 0.02599155f, -0.05199840f, -0.51893836f, 0.06827893f, -0.33049858f, -0.09695433f, 
    0.04541064f, -0.23313300f, 0.06049285f, -0.23044622f, 0.07306221f, -0.02876508f, 0.12525059f, 0.03245734f, 
    -0.76248050f, 0.31575814f, 0.10632388f, 0.30860558f, -0.14116870f, -0.14028198f, -0.38179806f, -0.01393875f, 
    0.11141577f, 0.13506970f, -0.08173902f, -0.03715021f, -0.01103236f, 0.26466289f, 0.25269634f, 0.75880277f, 
    0.21349427f, -0.07878007f, -0.21460748f, -0.19125853f, 0.03393226f, -0.08104902f, -0.06173092f, -0.10093338f, 
    -0.25336206f, -0.05781589f, -0.52646369f, 0.21495384f, 0.02487279f, -0.03119805f, 0.29294235f, -0.19510300f, 
    0.04939510f, -0.05395436f, -0.14573295f, 0.01313272f, -0.10020433f, 0.01714381f, 0.36341494f, 0.32731554f, 
    0.19871828f, -0.13238561f, -0.21487485f, 0.13751413f, -0.13302027f, -0.32077441f, 0.11802785f, 0.06294879f, 
    0.20514670f, -0.28395769f, 0.12371159f, 0.08266675f, -0.08523814f, -0.00496555f, -0.24367668f, -0.11055232f, 
    0.01791109f, -0.09995627f, 0.08553718f, 0.00167149f, -0.19387299f, 0.05536827f, -0.23008417f, -0.11735222f, 
    0.05603558f, -0.02189590f, 0.05647650f, -0.12533948f, 0.02983364f, -0.11563131f, -0.26792645f, -0.11573627f, 
    -0.36386693f, 0.17586780f, -0.35448059f, 0.28317744f, 0.10143209f, -0.06446750f, 0.07871905f, -0.06515449f, 
    -0.04334048f, 0.17932303f, 0.15365599f, -0.17904791f, 0.56702226f, -0.39810193f, 0.61635423f, -0.54968995f, 
    0.01471202f, -0.38992888f, -0.08458915f, -0.10071235f, -0.21900454f, 0.07015370f, -0.03281419f, 0.05694626f, 
    -0.08097309f, -0.40567484f, 0.13787316f, -0.11014449f, 0.06632362f, 0.01987019f, 0.09589311f, 0.07243418f, 
    -0.07195145f, 0.03674427f, 0.06893073f, 0.16676649f, -0.33162287f, -0.35113230f, -0.25822252f, -0.28613216f, 
    0.15175509f, -0.45353243f, 0.09319463f, -0.05154737f, -0.10282941f, 0.03838670f, -0.07183644f, 0.11738549f, 
    -0.25626630f, -0.68034607f, -0.03915131f, 0.19708923f, 0.03963509f, 0.14207812f, 0.14885157f, -0.03782202f, 
    -0.00921544f, 0.04572909f, 0.01908989f, -0.01780728f, -0.28405583f, 0.08018693f, 0.10923807f, -0.13002799f, 
    -0.03385983f, -0.06331851f, -0.07889903f, -0.05823349f, 0.03777196f, 0.05040761f, -0.01006607f, -0.07089735f, 
    -0.03211153f, 0.41946194f, -0.39349273f, -0.07189996f, 0.06135637f, 0.04935676f, 0.28228846f, -0.07961173f, 
    0.14343600f, -0.14100318f, -0.02553356f, 0.03244514f, 0.23983662f, 0.01033169f, 0.39277285f, -0.04713953f, 
    0.13664828f, -0.29064190f, -0.11784343f, -0.25360221f, 0.07176635f, -0.00789388f, 0.14025174f, 0.17846949f, 
    0.08943424f, 0.15618834f, 0.11116467f, -0.13603704f, -0.09081594f, -0.05061652f, -0.00717150f, 0.00660194f, 
    0.22147472f, 0.18157020f, 0.17936738f, 0.33780274f, -0.56794029f, 0.02641566f, 0.16441759f, -0.14998327f, 
    -0.18320806f, -0.03622948f, 0.06120978f, 0.19461317f, 0.06362596f, 0.10364493f, 0.08875386f, -0.07141110f, 
    0.07199948f, -0.46565923f, -0.18016353f, 0.01359429f, 0.08171219f, 0.07928377f, 0.14388560f, -0.11196662f, 
    -0.04340779f, -0.10806973f, -0.12226240f, -0.12481756f, -0.04400862f, -0.31739739f, -0.12219564f, -0.62105668f, 
    -0.35690707f, 0.12599593f, -0.07867697f, 0.16675040f, 0.11770946f, -0.03389223f, 0.04174897f, -0.04589652f, 
    0.14584766f, 0.28523114f, 0.54364294f, -0.90171218f, 0.08212669f, -0.11702255f, 0.08459785f, 0.00129950f, 
    -0.15266715f, 0.01153738f, 0.03094401f, 0.06835409f, 0.24158792f, 0.09315825f, 0.28628162f, -0.03018224f, 
    0.21573828f, -0.38785735f, -0.04060141f, -0.08659913f, -0.16252561f, 0.08659098f, -0.19624731f, -0.09090471f, 
    -0.19235848f, -0.31916538f, -0.06541178f, -0.54709703f, 0.25999206f, 0.09440427f, 0.23049752f, -0.14345522f, 
    0.12801857f, 0.02025316f, -0.15673500f, 0.16868317f, -0.14616473f, 0.27562228f, -0.12741248f, -0.15940845f, 
    0.02757449f, -0.16742241f, 0.06964964f, -0.03500877f, 0.27191979f, -0.07251977f, -0.04819410f, -0.06680693f, 
    -0.17445180f, -0.01260311f, -0.01094392f, 0.05187255f, 0.16171294f, 0.10425576f, 0.07160272f, 0.12682675f, 
    0.21489222f, 0.13941543f, -0.19653231f, -0.08369539f, -0.10687244f, 0.24822935f, 0.00612901f, -0.38663977f, 
    -0.03983882f, -0.17649336f, 0.27901870f, 0.33603951f, 0.00966570f, -0.04273028f, -0.00763513f, -0.00777911f, 
    -0.53319508f, 0.48407042f, -0.02409897f, -0.11139090f, -0.13075221f, -0.20315948f, 0.00839904f, -0.08427848f, 
    0.01571817f, -0.37255755f, -0.09783332f, 0.14714599f, -0.21280983f, 0.09060016f, -0.00337358f, 0.43116811f, 
    -0.06950098f, 0.16292985f, -0.07694822f, 0.14017060f, 0.22915305f, -0.17369205f, -0.11628214f, 0.04273602f, 
    0.02739129f, -0.29894531f, 0.05563999f, -0.56116217f, -0.11147413f, -0.06310717f, 0.02136380f, -0.06165877f, 
    -0.04236151f, 0.01944271f, -0.05607172f, 0.15439460f, 0.17807359f, 0.15135489f, 0.13036665f, 0.17467479f, 
    -0.21025929f, -0.25947049f, -0.28021026f, 0.03471465f, 0.06261323f, 0.12415669f, 0.07086044f, 0.13729061f, 
    0.03293042f, -0.15495585f, -0.33291680f, 0.08750870f, 0.04980958f, -0.14767051f, -0.00538848f, -0.19097273f, 
    0.09070138f, 0.03880638f, -0.31189838f, -0.11230788f, 0.22059077f, -0.46798015f, 0.12836051f, -0.18368901f, 
    -0.24329874f, -0.12532862f, 0.03545235f, -0.03165818f, -0.01028214f, 0.12443307f, -0.11799699f, 0.02092434f, 
    0.15610211f, -0.10215825f, 0.11342049f, 0.09388811f, -0.16892669f, -0.02826019f, 0.26917425f, 0.26006955f, 
    0.07740064f, 0.07513011f, 0.17636956f, 0.11953716f, 0.82390112f, -0.48490447f, 0.27523932f, -0.19862208f, 
    -0.13232966f, 0.23910344f, 0.27932084f, 0.09581763f, 0.00613473f, 0.13664193f, -0.32455114f, -0.47171709f, 
    0.57649112f, -0.24619983f, 0.23748991f, 0.13856746f, -0.01758692f, -0.16055502f, -0.00385875f, 0.10739024f, 
    -0.22987933f, -0.02787582f, -0.39980501f, 0.07210898f, -0.26530093f, 0.52784717f, -0.04699893f, -0.09327596f, 
    -0.00784725f, 0.08736331f, 0.07827829f, 0.00679314f, 0.03694428f, 0.15980245f, -0.02963885f, 0.16720627f, 
    -0.13571127f, 0.20008226f, -0.45353281f, -0.26169524f, -0.42258334f, -0.10225572f, 0.03391794f, -0.25270367f, 
    0.04473956f, 0.32865536f, 0.04092830f, -0.02833360f, -0.00345473f, 0.19042677f, 0.17988575f, -0.18562832f, 
    -0.09693804f, 0.03555485f, -0.17711622f, 0.03498182f, 0.04189131f, 0.04786368f, 0.25129500f, 0.15908635f, 
    -0.14584288f, 0.48456982f, -0.32859325f, 0.05819232f, 0.02651960f, -0.02644711f, 0.04737608f, 0.13210039f, 
    -0.28402296f, 0.13160950f, -0.00471791f, -0.05211555f, -0.02197905f, -0.21460190f, 0.38142338f, 0.05366748f, 
    -0.11937253f, 0.02770521f, 0.17952780f, 0.20435010f, -0.00351368f, -0.04932030f, 0.18692094f, 0.00416435f, 
    0.17386802f, -0.11955851f, 0.28167343f, -0.24530342f, -0.22603814f, 0.10551814f, -0.07734934f, -0.08020447f, 
    0.09679977f, -0.01323104f, -0.11647405f, -0.03704638f, -0.05132257f, 0.25150231f, -0.05828575f, 0.08548892f, 
    0.07974562f, -0.09035055f, 0.05426269f, 0.08070065f, 0.06493733f, -0.01240721f, -0.17218992f, 0.08715155f, 
    -0.20265117f, 0.01712563f, -0.19741876f, -0.00053348f, -0.13218580f, -0.29733160f, -0.14092332f, 0.02821594f, 
    -0.27067673f, -0.08380033f, -0.09226099f, -0.51089323f, -0.13641503f, 0.53247565f, -0.10868693f, 0.13749269f, 
    -0.18608753f, 0.00906380f, 0.11300039f, -0.07814420f, -0.10374209f, 0.15437619f, -0.04187422f, -0.00724763f, 
    -0.34594971f, 0.13858773f, -0.30948386f, 0.01677352f, -0.08964319f, 0.11883966f, 0.06486051f, -0.06158742f, 
    -0.17847091f, 0.14551036f, 0.00342682f, -0.11802638f, -0.00647615f, 0.00851080f, -0.16568401f, -0.17078029f, 
    0.00047814f, 0.07801656f, 0.11006159f, -0.04508517f, 0.00584867f, -0.21803120f, 0.15581396f, 0.17023566f, 
    -0.04988422f, 0.17318888f, -0.15722977f, -0.14503476f, -0.23509201f, -0.07400218f, 0.11999387f, -0.13880609f, 
    0.00682933f, 0.10282601f, -0.11034959f, 0.06742425f, 0.10554881f, -0.38744166f, 0.14909428f, -0.18930976f, 
    0.05366535f, -0.01499627f, -0.17856508f, 0.06842428f, -0.17209719f, 0.00970237f, -0.11711881f, -0.42433661f, 
    0.02068753f, 0.14608820f, 0.17619485f, -0.13623565f, -0.02666520f, -0.15854000f, -0.02747331f, 0.02884493f, 
    -0.21596865f, -0.19589999f, -0.47137791f, -0.50574344f, -0.23943073f, -0.27410924f, -0.22805136f, 0.06855861f, 
    -0.06631158f, 0.01367760f, -0.11451159f, 0.04773479f, -0.02550568f, 0.09322189f, 0.05171485f, -0.08816299f, 
    -0.09326813f, 0.25929102f, -0.58499819f, 0.04578016f, -0.14215590f, 0.06523338f, 0.19767700f, -0.12185062f, 
    -0.01505454f, 0.18521199f, 0.02258017f, 0.10859825f, -0.10603601f, -0.52692431f, -0.12550454f, 0.29390684f, 
    -0.09786689f, -0.07123378f, 0.20929895f, 0.10486798f, -0.06319477f, 0.04162889f, -0.10094975f, -0.09879595f, 
    0.29981929f, -0.21894746f, 0.17202345f, 0.33817247f, -0.13478814f, -0.09488754f, 0.02435452f, -0.07511251f, 
    0.11848981f, -0.10151088f, 0.03141537f, -0.20625775f, 0.12840958f, 0.32375947f, -0.26147437f, 0.25372928f, 
    -0.15702483f, -0.02026410f, 0.01065525f, 0.05342729f, 0.03957831f, 0.12658136f, 0.17087510f, 0.27537698f, 
    -0.36567223f, 0.20438549f, -0.12320504f, -0.20759407f, -0.06475338f, 0.21256702f, -0.10565819f, 0.26834369f, 
    -0.21322241f, -0.21196558f, 0.00547171f, -0.02444641f, -0.08055518f, 0.09306016f, 0.27265301f, -0.12668791f, 
    0.03736891f, -0.09403797f, 0.00517080f, 0.19641528f, -0.07265724f, 0.07611057f, 0.16117626f, 0.20175833f, 
    -0.11109222f, -0.29157010f, -0.23289582f, -0.08465336f, -0.30153620f, -0.25834829f, 0.04732874f, 0.06406670f, 
    0.03732451f, -0.08009286f, 0.19256699f, 0.04431591f, -0.36188868f, -0.34195542f, -0.00018900f, 0.18350013f, 
    -0.14259709f, -0.10429536f, 0.02606852f, -0.16138625f, 0.03831905f, 0.12658240f, 0.00933790f, 0.14445488f, 
    0.36014560f, 0.37540281f, 0.28968793f, -0.41466311f, 0.03690773f, -0.06471702f, 0.13296768f, 0.05547023f, 
    -0.10778763f, 0.14571825f, -0.00958483f, 0.09436465f, -0.24813688f, -0.42718041f, 0.06526477f, 0.03844148f, 
    -0.15061365f, 0.19366601f, 0.10139871f, -0.09834933f, -0.37669441f, -0.12406798f, 0.11874636f, -0.08958345f, 
    -0.44756126f, 0.40703261f, -0.00007325f, 0.19495526f, -0.03608477f, 0.15598069f, 0.04656519f, 0.27365151f, 
    -0.10546278f, -0.11021124f, 0.19215491f, 0.01613471f, -0.19132023f, 0.08981562f, -0.18800369f, 0.16107045f, 
    0.16764484f, -0.26573884f, 0.12198119f, 0.23668748f, -0.28804350f, -0.01583612f, -0.12524094f, -0.06552042f, 
    -0.27601340f, -0.08594210f, 0.00006643f, -0.55106896f, -0.19614016f, -0.38144919f, -0.16297227f, 0.10804676f, 
    0.16026051f, 0.08616918f, 0.09882195f, 0.06539247f, 0.50676471f, 0.18127401f, 0.61953795f, -0.17306322f, 
    -0.09092242f, 0.03040979f, -0.07506888f, -0.00605281f, -0.22671807f, 0.05353315f, 0.04432825f, -0.01756411f, 
    -0.33323997f, 0.16750325f, -0.31106260f, 0.05083017f, 0.18978317f, 0.08545301f, -0.22304340f, -0.28025708f, 
    0.04932657f, -0.12172136f, -0.33224374f, -0.11900389f, 0.02155370f, -0.25262007f, 0.42054433f, -0.87530679f, 
    0.11282066f, -0.00558194f, -0.04202036f, 0.17849125f, -0.02320625f, 0.05990458f, 0.12026021f, 0.34350327f, 
    -0.16218378f, -0.07487452f, 0.27571094f, -0.52113813f, -0.01310277f, 0.16524702f, -0.11171553f, -0.00789777f, 
    -0.04475255f, 0.10771386f, 0.25128099f, 0.00164454f, -0.13424022f, -0.29009667f, -0.10847379f, 0.34373099f, 
    0.23978762f, -0.08347124f, 0.03290725f, 0.10721040f, -0.10543735f, 0.11328956f, 0.02005818f, 0.00613824f, 
    0.32770801f, -0.26765579f, 0.30546203f, -0.20192394f, 0.11961802f, 0.08273152f, -0.12950110f, 0.13792726f, 
    -0.04685730f, -0.11076167f, -0.16876549f, -0.05799055f, -0.35172489f, -0.09968057f, -0.21034929f, -0.08256489f, 
    0.31685799f, -0.05102127f, -0.03578006f, 0.03649572f, -0.14930563f, -0.07199551f, -0.17623630f, -0.30105686f, 
    -0.46766058f, 0.10474380f, -0.19216111f, 0.45386630f, 0.10175410f, -0.13195246f, 0.05614053f, -0.03499426f, 
    -0.01437370f, -0.04415271f, -0.14080721f, 0.15563694f, 0.17946836f, 0.01428333f, -0.00720163f, 0.04875663f, 
    0.01611892f, 0.14717025f, -0.11724881f, 0.06149564f, -0.09237641f, -0.07613723f, 0.12620857f, -0.05480426f, 
    -0.04745089f, -0.27469176f, -0.02288612f, -0.29561910f, -0.07928491f, -0.10269587f, -0.26190364f, 0.00006618f, 
    0.13444787f, 0.02592917f, 0.22054547f, -0.03352525f, -1.03545332f, -0.15455219f, -0.33786568f, 0.22473049f, 
    -0.01003907f, -0.05556969f, -0.03314370f, 0.27902365f, -0.46397159f, -0.01937059f, -0.03092665f, -0.13301867f, 
    -0.21700524f, 0.14565548f, -0.25286540f, 0.18524796f, -0.05391668f, -0.04738678f, 0.26738173f, 0.16140029f, 
    0.04719513f, 0.07920038f, 0.05731418f, 0.10082171f, 0.23850130f, -0.50997490f, 0.53280532f, 0.34480026f, 
    0.16754411f, 0.10670222f, -0.25642708f, 0.03522615f, 0.19864149f, 0.00582115f, 0.12371088f, -0.00397838f, 
    0.11609058f, 0.13603146f, -0.02668316f, -0.01325483f, 0.06646742f, -0.06511357f, 0.15843336f, -0.06603617f, 
    0.07800771f, 0.09631083f, 0.05465969f, -0.05731182f, 0.02678641f, 0.08105161f, -0.17860080f, 0.21842253f, 
    0.04464041f, 0.00407253f, 0.06974601f, -0.08474268f, -0.24616489f, 0.06425495f, 0.16325076f, -0.22805382f, 
    0.30471617f, -0.15583378f, 0.73046100f, 0.09009621f, 0.19672638f, 0.04421170f, 0.11334544f, 0.09429003f, 
    -0.12481043f, -0.00488502f, 0.03935528f, 0.10525255f, -0.25150275f, -0.01388824f, -0.19503580f, -0.42024198f, 
    -0.03800838f, -0.01724277f, 0.05225224f, -0.08821934f, -0.12114841f, -0.02653634f, 0.19524507f, 0.00923002f, 
    0.02667398f, -0.12294743f, -0.01191358f, -0.06902529f, 0.04189068f, 0.08228943f, 0.00558964f, 0.06968328f, 
    -0.09372612f, 0.17157573f, 0.24096844f, 0.11147191f, -0.37276337f, -0.54134995f, -0.06588055f, 0.19822420f, 
    -0.23517710f, -0.19255887f, 0.18443958f, -0.22353587f, 0.09716578f, 0.10014773f, 0.05481505f, -0.02034735f, 
    0.51084292f, 0.18836775f, 0.04347403f, -0.02407300f, 0.00201302f, 0.00740227f, 0.03537711f, 0.19745325f, 
    -0.19995996f, -0.01048967f, 0.01369082f, -0.32608142f, 0.17018208f, 0.14507388f, 0.19178498f, -0.29496500f, 
    0.05769755f, 0.00951684f, 0.15639096f, -0.01053580f, 0.03782481f, -0.01454386f, 0.02825391f, 0.05581586f, 
    -0.38141105f, -0.33777949f, 0.33463308f, 0.00892362f, -0.10130266f, 0.11621784f, 0.15784846f, -0.01413851f, 
    -0.08354662f, 0.13922992f, 0.01430465f, -0.06019664f, -0.07038672f, -0.27914828f, 0.14762330f, 0.10673872f, 
    -0.10095721f, -0.07034606f, -0.48121357f, 0.13103934f, 0.02098927f, -0.09256867f, -0.09314784f, -0.09478804f, 
    0.13958400f, 0.13407394f, -0.07537575f, 0.05656584f, -0.14611472f, 0.23690686f, -0.03240005f, 0.15736854f, 
    -0.25028092f, 0.32368201f, -0.15732425f, -0.01830414f, 0.08431685f, -0.15908912f, 0.39070153f, -0.18346088f, 
    0.02287283f, 0.05724400f, 0.23343134f, 0.09641830f, -0.15213211f, 0.20267794f, -0.05805955f, 0.01122016f, 
    0.05621087f, 0.04254142f, 0.20560989f, 0.01143325f, -0.21212731f, 0.21565546f, -0.16520931f, 0.19907516f, 
    -0.14296247f, 0.10404068f, 0.10213551f, -0.18806338f, -0.18175487f, -0.23190154f, -0.09354544f, -0.16135044f, 
    -0.09531763f, -0.25214741f, -0.10920303f, -0.33697948f, -0.02223605f, 0.01429758f, -0.10136539f, -0.08648977f, 
    0.06709933f, -0.40897098f, 0.09546898f, -0.05521051f, 0.24302134f, 0.05561587f, 0.07543396f, -0.04501776f, 
    0.01849999f, 0.20382807f, -0.19947194f, -0.11955088f, -0.46208102f, -0.34687135f, -0.18525416f, 0.34605518f, 
    0.19154115f, 0.10790270f, -0.05369764f, -0.11078338f, 0.07091809f, -0.14866357f, 0.30668467f, 0.02408128f, 
    -0.85285479f, 0.61353517f, 0.15778098f, 0.30013171f, 0.13409840f, -0.08562773f, 0.08177221f, 0.07864632f, 
    -0.16168372f, -0.03582904f, -0.03207042f, 0.04273883f, -0.37684512f, 0.05202540f, -0.44077015f, 0.07162469f, 
    -0.11377896f, -0.03921968f, 0.02113094f, -0.23450837f, 0.03334245f, -0.00084095f, -0.06460618f, 0.07168803f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.14680773f, 0.15479475f, 0.11153151f, -0.15055853f, -0.08100722f, 0.06321666f, 0.07654633f, -0.08133939f, 
    0.11027297f, -0.00166149f, 0.01090648f, -0.02567262f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
