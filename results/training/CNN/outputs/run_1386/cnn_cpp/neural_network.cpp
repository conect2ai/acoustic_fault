#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.29035234f, 0.00768935f, 0.12302075f, -0.60042846f, -0.60025722f, 0.28233710f, -0.07847275f, -0.14529128f, 
    0.28647327f, 0.40040064f, 0.09219789f, 0.27435043f, -0.15510347f, -0.27486902f, 0.11564044f, 0.00471389f, 
    0.21998078f, -0.31658676f, -0.16677952f, 0.09360584f, 0.06282270f, 0.20029819f, -0.02087535f, 0.13214214f, 
    -0.16680703f, -0.53893483f, -0.03649788f, -0.42770121f, -0.52382964f, -0.49964690f, -0.29724836f, -0.53962135f, 
    -0.45261985f, -0.55212528f, -0.61124325f, -0.02098247f, -0.07432089f, 0.02106800f, -0.04910644f, 0.32970515f, 
    -0.12214659f, -0.06520890f, -0.09048901f, -0.22232769f, -0.08631752f, 0.32885915f, 0.21823338f, 0.15308240f, 
    0.07299417f, 0.14791356f, -0.52377373f, 0.22376087f, 0.16549599f, 0.14421584f, 0.21473862f, -0.43170252f, 
    -0.42666072f, -0.27578107f, -0.10379030f, 0.30992451f, 0.40681466f, -0.10092890f, 0.33442077f, -0.29863268f, 
    0.36916569f, -0.17940494f, 0.06525805f, 0.10730739f, -0.27734977f, -0.23859158f, 0.27797395f, 0.25057510f, 
    0.08472195f, -0.03468696f, -0.01981369f, 0.90864438f, 0.03195138f, -0.66385615f, -0.77029872f, -0.03990491f, 
    0.10076903f, -0.03122021f, 0.11970898f, 0.20399868f, -0.15370783f, 0.13129687f, 0.12006356f, -0.00146449f, 
    -0.29125187f, -0.01414912f, 0.01800461f, -0.17059711f, -0.17015426f, -0.23112155f, -0.01170153f, 0.20570576f, 
    -0.14426954f, -0.33258161f, -0.01622136f, -0.26612732f, 0.24884473f, -0.21500908f, -0.15572512f, 0.21067370f, 
    0.14212686f, -0.22455736f, 0.29903984f, -0.11209396f, -0.16258532f, -0.13890617f, 0.04108067f, -0.05367373f, 
    0.13325830f, 0.10761511f, -0.01269535f, 0.26929921f, -0.09524316f, 0.00156562f, -0.28884852f, 0.04249679f, 
    -0.14709330f, 0.07074085f, 0.17713830f, 0.24027129f, 0.10528477f, -0.91156167f, -0.34541330f, 0.39435825f, 
    0.21427141f, 0.42387325f, -0.10696521f, 0.36603713f, -0.49247286f, -0.10810661f, 0.46349353f, 0.12047627f, 
    0.25184166f, -0.27067158f, 0.08874568f, -0.09561243f, -0.34358531f, 0.02383720f, -0.06640574f, -0.28539571f, 
    -0.03161209f, 0.02532555f, -0.30088490f, -0.13931552f, 0.20246026f, -0.02919904f, -0.48690224f, -0.44800660f, 
    -0.62272096f, -0.20171827f, -0.34118825f, 0.11227532f, -0.38177794f, 0.61345255f, -0.24345315f, -0.51957798f, 
    0.04009756f, 0.00512926f, -0.11354247f, -0.01777235f, 0.12462792f, 0.06906551f, 0.05308317f, 0.08977588f, 
    0.05011237f, 0.16076232f, -0.13286915f, 0.08110275f, 0.32317281f, 0.18663241f, 0.20359175f, -0.42685276f, 
    -0.12613094f, 0.30385855f, 0.42107007f, 0.28558210f, 0.57201582f, 0.07808943f, -0.01154032f, -0.22927211f, 
    -0.28511655f, -0.34762311f, -0.21174943f, 0.24803282f, -0.17310007f, 0.06791180f, -0.12343913f, -0.16485998f, 
    0.15676878f, -0.09892899f, 0.17330319f, -0.10749865f, -0.08382205f, -0.22360030f, -0.06971271f, 0.17650747f, 
    -0.54156524f, -0.46571511f, -0.17346773f, 0.54739952f, 0.44860902f, 0.05644429f, 0.33885664f, 0.20962420f, 
    0.46179911f, 0.61037701f, 0.16451919f, 0.09580506f, -0.38342518f, -0.05453544f, 0.25651643f, -0.11470035f, 
    -0.15300800f, -0.15289919f, -0.12298939f, -0.17760615f, 0.04209937f, -0.02371127f, 0.34328392f, 0.24664439f, 
    -0.19473039f, 0.02913806f, -0.75997388f, 0.08505879f, -0.11411038f, 0.32624429f, 0.09213305f, -0.66003811f, 
    0.15366854f, -0.50536400f, -0.07820339f, 0.65546620f, 0.14759892f, 0.59933418f, -0.38031101f, -0.35394472f, 
    -0.47799566f, 0.21481265f, -0.33751750f, -0.08295032f, 0.01080055f, 0.09409215f, 0.12542683f, -0.12426941f, 
    -0.14017116f, 0.19431768f, 0.73236674f, 0.13381851f, 0.17385185f, -0.65171158f, -0.49745816f, 0.26386803f, 
    0.16354775f, -0.34604967f, -0.26064122f, 0.15696675f, -0.15679595f, -0.14341387f, -0.04280736f, 0.00619794f, 
    0.28929123f, -0.30476591f, 0.28735259f, -0.10807654f, 0.03296854f, -0.11474417f, -0.20392910f, -0.05785949f, 
    -0.17551081f, 0.06405137f, 0.23597603f, -0.80014884f, 0.02905921f, 0.15552120f, 0.30583364f, 0.34933674f, 
    -0.19306463f, 0.21254347f, -0.00589760f, 0.18617529f, -0.04624250f, -0.01258799f, -0.27421990f, -0.22693580f, 
    0.33702117f, -0.10420738f, 0.19733334f, -0.24232683f, -0.06856928f, -0.06705920f, 0.22024655f, 0.09957644f, 
    0.16486444f, 0.02706182f, -0.04401388f, -0.35772195f, -0.36475694f, -0.05505458f, -0.10213323f, 0.31067032f, 
    -0.08669429f, 0.52223808f, 0.05193100f, 0.15286702f, -0.40424091f, -0.05801996f, -0.14961945f, 0.47960916f, 
    -0.15581626f, 0.04211442f, 0.03153720f, -0.36627334f, -0.26660988f, 0.04275050f, 0.04851565f, -0.05535863f, 
    -0.22279848f, 0.16935869f, 0.21031745f, 0.12995681f, 0.30707714f, -0.44053888f, -0.58151084f, -0.06948783f, 
    -0.19866854f, -0.32146472f, 0.28900784f, 0.20353271f, -0.35149753f, -0.56217885f, -0.24258892f, 0.52528989f, 
    -0.03401596f, -0.03476216f, -0.01909841f, -0.26719657f, 0.00469874f, 0.20893045f, -0.00506321f, 0.15966514f, 
    0.17444107f, -0.10324671f, -0.28278971f, 0.28273314f, -0.20295516f, 0.09568792f, -1.00486445f, -0.65080017f, 
    -0.58673042f, -0.13541454f, 0.11559676f, 0.07789747f, -0.20753220f, 0.40615162f, 0.50340003f, 0.35732028f, 
    0.35978705f, 0.30388838f, 0.14392433f, 0.08393649f, -0.03716485f, -0.00594375f, -0.00337173f, -0.17671767f, 
    -0.20015706f, -0.00802082f, 0.02091312f, -0.06847605f, 0.14487460f, -0.02854423f, -0.03240217f, -0.26243538f, 
    0.20863798f, 0.39561543f, -0.60599434f, -0.45040783f, -0.19482459f, 0.12189933f, 0.05437022f, 0.01638475f, 
    0.30075979f, 0.00887695f, 0.20387702f, -0.18619552f, 0.09361590f, 0.27551183f, -0.02307126f, -0.14093843f, 
    -0.03118739f, -0.35876197f, -0.33178148f, 0.15597537f, 0.25243354f, 0.18265539f, 0.05381788f, 0.31545389f, 
    -1.13783503f, -0.40831345f, -0.56773520f, -0.87925339f, -0.58011889f, 0.73467755f, 0.13438857f, -0.50516695f, 
    -0.35104230f, 0.24920872f, -0.45666149f, -0.40817648f, -0.20938866f, -0.23615184f, -0.12901975f, 0.18602827f, 
    0.15625383f, -0.11379910f, -0.12394915f, -0.05772209f, -0.07220995f, 0.05369351f, -0.07647433f, -0.07617623f, 
    -0.09680757f, 0.06124051f, -0.00712045f, 0.22986536f, 0.29792678f, 0.16351692f, 0.29424286f, 0.03300370f, 
    0.21102977f, 0.30872840f, 0.27083644f, 0.26875639f, 0.02792858f, 0.01875003f, -0.03563258f, 0.07696749f, 
    0.08381789f, -0.15338503f, 0.05663372f, -0.20664959f, 0.06430102f, -0.15286198f, 0.02386726f, 0.23155285f, 
    -0.09983648f, 0.14446045f, -0.96433985f, 0.35492367f, -0.42219707f, -0.75008345f, -0.21646644f, -0.13245080f, 
    0.44587365f, 0.39639518f, 0.00094636f, -0.31414759f, -0.13979773f, -0.08739610f, -0.41466990f, -0.44096702f, 
    -0.05881552f, -0.12789716f, -0.22331583f, -0.54520476f, -0.41800198f, -0.14496310f, -0.05149339f, -0.10102969f, 
    0.10472581f, 0.16806115f, -0.34756500f, 0.58006996f, 0.18901441f, -0.31077778f, 0.07875538f, 0.46827805f, 
    0.06322806f, 0.31136394f, 0.21956967f, -0.42649624f, -0.55209213f, -0.14014271f, -0.02243713f, -0.06105507f, 
    0.02755035f, -0.06624886f, -0.00527462f, 0.06535322f, -0.13824439f, 0.16729559f, -0.15475166f, 0.27580124f, 
    -0.10792165f, -0.24306794f, -0.25795397f, -0.33704492f, -0.04199903f, -0.46496400f, -0.57495469f, -0.23319560f, 
    -0.15673891f, 0.22525932f, 0.24507202f, 0.09280825f, -0.15183736f, 0.02144585f, -0.05534095f, 0.05715932f, 
    0.19408135f, 0.06673504f, -0.06299575f, 0.25060457f, 0.21361995f, -0.05116214f, 0.36483341f, 0.07618403f, 
    -0.22083680f, 0.11479374f, -0.18402545f, -0.38753048f, -0.33581915f, -0.45117417f, 0.39566937f, 0.42404106f, 
    -0.37969145f, 0.32644287f, -0.03144483f, 0.00708496f, -0.06023879f, 0.24709621f, 0.19731043f, -0.24251720f, 
    -0.28815791f, 0.15062843f, -0.31261435f, -0.24367276f, 0.17173369f, -0.12526631f, -0.30832994f, -0.20748852f, 
    -0.02879672f, -0.29447314f, -0.39620483f, -0.31050771f, -0.32641187f, -0.62310570f, -0.77433139f, 0.34377223f, 
    -0.43602490f, -0.59515095f, 0.13892044f, -0.35510308f, -0.10256115f, 0.28815234f, -0.29410207f, -0.40885851f, 
    -0.34809422f, -0.41044232f, -0.41413590f, 0.16616213f, 0.17647232f, 0.25086129f, -0.33705500f, -0.24177134f, 
    0.12294686f, -0.39929137f, 0.09048178f, -0.26565048f, -0.29517898f, -0.08867966f, -0.50086612f, -1.09098172f, 
    0.20984507f, -0.16760494f, 0.95022053f, -0.17475864f, -0.50798112f, -0.85767096f, -0.10533849f, 0.31912121f, 
    -0.29451174f, 0.45374209f, 0.11691409f, 0.22938575f, 0.16113359f, -0.22244383f, -0.11039305f, 0.03389192f, 
    0.11909362f, -0.59101284f, -0.20946106f, 0.09634592f, -0.04748815f, 0.07357789f, -0.07305126f, 0.04464199f, 
    0.15070812f, 0.45093545f, 0.08918235f, 0.31740829f, -0.00401861f, 0.06718359f, -0.20971739f, 0.06724035f, 
    -0.18718106f, -0.19995043f, 0.03975484f, 0.10751255f, 0.02070927f, 0.12135669f, 0.14956743f, 0.02734015f, 
    -0.07408433f, -0.18194218f, -0.21240914f, 0.14281909f, 0.05941025f, 0.01963235f, 0.18092024f, 0.09085609f, 
    -0.21331324f, -0.57525986f, 0.57054240f, 0.33800480f, -0.35698023f, 0.26657832f, 0.17612149f, 0.15008612f, 
    -0.27590227f, -0.11201025f, 0.29483056f, 0.35487083f, -0.04811768f, -0.12700672f, -0.37964815f, -0.23692274f, 
    -0.14706336f, 0.06421734f, -0.09840973f, 0.25774524f, -0.26871595f, 0.17556480f, 0.04307163f, 0.11582345f, 
    -0.11699421f, -0.52804083f, -0.01161703f, 0.26340738f, -0.24609098f, -0.03936521f, 0.53030068f, -0.23359293f, 
    -0.34393573f, -0.16350283f, -0.23713776f, -0.52612585f, 0.23383509f, -0.13835423f, 0.07160389f, 0.13347846f, 
    0.13258697f, 0.34156162f, -0.23387824f, 0.29380125f, -0.15324596f, 0.01773311f, -0.33122581f, -0.06507193f, 
    0.09813674f, 0.15777406f, 0.22772925f, -0.35819826f, -0.75760227f, -0.45871574f, -0.09124578f, 0.39666674f, 
    0.08221561f, 0.01063133f, -0.06127800f, 0.01113169f, 0.24484764f, -0.39581951f, -0.21626242f, -0.34240448f, 
    0.23883939f, 0.50371796f, -0.08461442f, 0.03582620f, -0.26912183f, -0.11789936f, -0.54482687f, 0.25402403f, 
    -0.02704413f, 0.11611615f, 0.30615309f, -0.11698202f, 0.17722221f, -0.56004912f, -0.63447934f, -0.58898258f, 
    0.24483079f, -0.25569177f, -0.28223324f, -0.45890611f, -0.08037733f, -0.46867916f, 0.49465984f, 0.19764112f, 
    0.04286582f, -0.36217040f, -0.31654605f, -0.32299945f, -0.30708650f, -0.16235799f, -0.37420642f, -0.29648295f, 
    -0.34735468f, 0.02553701f, 0.39221153f, -0.13261853f, -0.13612916f, 0.33067787f, -0.69950688f, -0.67508465f, 
    -0.50261438f, -0.69460738f, -0.45848024f, -0.33546987f, -0.31573027f, -0.28926757f, -0.51147562f, 0.17314281f, 
    0.06725445f, 0.07835907f, -0.02223309f, -0.11881859f, -0.01806733f, -0.22754945f, 0.21364056f, 0.00102232f, 
    -0.19791888f, -0.41401497f, -0.30918917f, -0.27158391f, 0.02276915f, -0.04649834f, -0.05573868f, 0.63752317f, 
    -0.05173426f, -0.16429375f, -0.24594307f, -0.43450263f, -0.23546274f, 0.27625898f, 0.32876331f, -0.10503757f, 
    -0.45827562f, -0.11830731f, -0.01226244f, 0.15351604f, -0.11204489f, -0.05699187f, 0.35177997f, -0.12949546f, 
    -0.11307743f, -0.38487378f, -0.49355099f, 0.21216582f, -0.12667973f, -0.06974842f, -0.57204455f, -0.76781422f, 
    0.46065620f, -0.29177219f, -0.27793562f, 0.27649209f, -0.34928510f, -0.29259843f, -0.23665321f, -0.35169315f, 
    0.26998094f, 0.39842376f, 0.06854291f, 0.02194554f, 0.27045378f, 0.39104947f, 0.17278270f, -0.39708450f, 
    0.19929521f, -0.33683142f, -0.41317254f, -0.22012812f, 0.20734555f, 0.09932967f, -0.06943987f, 0.30306643f, 
    -0.85761583f, 0.11703487f, 0.34999818f, 0.02059490f, 0.17517984f, -0.27890635f, 0.11282726f, 0.39233941f, 
    0.11200039f, -0.24004695f, -0.55305910f, 0.10755852f, -0.00604244f, 0.21221800f, 0.11190730f, -0.16876234f, 
    0.17372477f, -0.02542887f, -0.23576675f, 0.03236595f, 0.04101435f, -0.01073103f, 0.21141873f, 0.01036505f, 
    0.00585507f, -0.76780790f, -0.46683398f, 0.21786915f, 0.83250481f, -0.05416583f, -0.07353114f, -0.55574155f, 
    -0.40483397f, -0.50126743f, -0.40655768f, -0.23031248f, -0.45642132f, 0.32313222f, -0.38589525f, -0.16115928f, 
    -0.13457923f, -0.43836939f, 0.13213438f, -0.07051533f, 0.04688602f, 0.20479070f, -0.13281819f, -0.12642334f, 
    0.14490619f, -0.07087182f, 0.60393041f, 0.61111134f, -0.13818572f, -0.33774471f, -0.47417188f, -0.53821599f, 
    0.20079650f, -0.13048652f, -0.04403698f, 0.10870428f, 0.32221383f, 0.16809712f, -0.04486259f, -0.12012654f, 
    -0.07553872f, 0.06381484f, -0.22444086f, 0.22366890f, 0.29388568f, -0.29895020f, 0.05735668f, 0.19963895f, 
    -0.07125978f, -0.33515817f, 0.30465743f, -0.31188923f, -0.49163607f, -0.69466829f, -0.69362867f, -0.63894892f, 
    0.50997370f, 0.32936415f, 0.04551794f, 0.15082872f, 0.27279466f, -0.05081488f, -0.16878784f, -0.60246348f, 
    -0.10718324f, -0.27733976f, -0.39565173f, -0.22017789f, -0.09730253f, 0.11620423f, -0.44072652f, -0.13900159f, 
    -0.17442806f, 0.08816753f, 0.14930752f, -0.05177157f, 0.44940528f, 0.37765655f, 0.37099692f, 0.15117593f, 
    -0.58585316f, -0.32352978f, -0.21803920f, -0.25718758f, -0.10488500f, -0.42211670f, 0.42087486f, -0.33594134f, 
    0.03057956f, 0.40581641f, 0.04547728f, 0.03266928f, 0.03163092f, 0.19051799f, -0.20346569f, -0.24081053f, 
    -0.23254867f, -0.10698695f, -0.26658756f, -0.32459030f, -0.01450206f, 1.08571482f, 0.27807406f, -0.01680054f, 
    -0.45218602f, -0.10978891f, 0.15963662f, -0.11403268f, -0.38915068f, -0.61771691f, -0.71924931f, 0.25812298f, 
    -0.07777494f, -0.06478681f, 0.08837120f, -0.04621678f, 0.16307460f, 0.36794373f, -0.02892605f, -0.12079628f, 
    0.00790730f, -0.34204561f, 0.05372021f, 0.01368278f, 0.28269801f, -0.19465233f, -0.56254023f, 0.59071493f, 
    -0.11778818f, -0.59347284f, -0.14085700f, -0.19485536f, -0.10483526f, 0.44543290f, 0.59304023f, 0.11264899f, 
    0.18227351f, -0.41245350f, 0.38388282f, -0.35484079f, -0.12780839f, 0.00614183f, -0.26847979f, -0.04650963f, 
    0.07182163f, 0.01844823f, -0.07998005f, -0.00231041f, 0.29603487f, 0.04383915f, 0.19660479f, -0.18303579f, 
    -0.18126789f, 0.21513213f, 0.24233766f, 0.25258857f, 0.22562151f, -0.06191174f, -0.24895224f, 0.22318204f, 
    0.34854916f, -0.05738529f, 0.08914442f, -0.06583326f, -0.20812567f, 0.21498619f, 0.05523607f, -0.04310743f, 
    -0.26882184f, 0.00086836f, -0.03579530f, 0.11969931f, 0.06292550f, 0.20937935f, -0.12626317f, -0.21698523f, 
    0.35735139f, -0.35266611f, -0.53674734f, -0.30206168f, 0.05698371f, 0.21317567f, 0.14195034f, 0.19361863f, 
    0.20714688f, 0.26056451f, 0.09411001f, 0.10518076f, -0.33204153f, -0.28357524f, -0.00217783f, -0.04706233f, 
    0.14185198f, 0.19878443f, -0.15837605f, 0.00351733f, 0.22626494f, -0.35062644f, 0.41864082f, -0.20574889f, 
    -0.10648171f, 0.49418807f, -0.42411175f, -0.27670333f, -0.08952262f, 0.21946862f, 0.29383144f, 0.28440458f, 
    0.35607976f, 0.15756142f, -0.49671730f, -0.27990988f, -0.07193738f, -0.06158825f, -0.12650789f, 0.00944590f, 
    -0.02588660f, 0.27896321f, 0.17327267f, -0.30884117f, -0.25853756f, 0.21934335f, -0.33674514f, -0.17811744f, 
    0.26525524f, 0.16636972f, -0.82916874f, -0.96352249f, -0.04269633f, 0.50609750f, 0.28463447f, 0.78678954f, 
    0.79530513f, -0.14559391f, -0.37344345f, -0.30827081f, 0.07069075f, -0.08600069f, -0.02267657f, 0.10047436f, 
    -0.20237638f, 0.26299199f, -0.27992114f, 0.26389191f, 0.05256111f, -0.10484565f, -0.01528841f, -0.08004536f, 
    0.12897171f, -0.02551257f, 0.06618816f, -0.23267567f, -0.03712149f, -0.44117352f, -0.15833937f, 0.33164337f, 
    -0.38753888f, -0.60213292f, -0.39863497f, -0.51984638f, -0.65335178f, 0.05783109f, 0.32241559f, 0.19490914f, 
    -0.22296460f, -0.10720133f, -0.12838267f, 0.24931867f, 0.14653812f, 0.06995942f, 0.29941192f, -0.20617971f, 
    0.18361150f, -0.14240205f, -0.12495743f, -0.07808622f, 0.12277850f, 0.25136343f, 0.09244608f, -0.32639673f, 
    -0.13179135f, 0.39807171f, -0.40324390f, -0.25318900f, 0.06351871f, 0.27382314f, -0.22862066f, 0.64034736f, 
    -0.40310609f, -0.11213621f, 0.19205780f, -0.06004884f, 0.16338786f, 0.18592538f, -0.20740235f, -0.18924907f, 
    -0.17839484f, -0.13523442f, 0.37193826f, 0.18451053f, -0.13365631f, -0.67995763f, -0.53501683f, -0.45929432f, 
    0.20890839f, -0.04935014f, -0.39967766f, -0.21473454f, -0.27390835f, -0.09049816f, 0.24346367f, 0.43415707f, 
    -0.01524628f, 0.14609753f, 0.13776268f, 0.32835904f, -0.18951887f, -0.12019753f, -0.28043783f, -0.26573861f, 
    -0.46084255f, -0.26163167f, -0.25042617f, -0.17168351f, -0.01986615f, -0.24796265f, -0.11318443f, 0.09811727f, 
    0.40172714f, 0.24584818f, 0.29540685f, -0.58660132f, -0.62211108f, -0.13514718f, 0.41637310f, 0.17140593f, 
    0.08869503f, -0.31656918f, -0.00535188f, 0.09109521f, 0.16631746f, -0.07332827f, 0.21774474f, 0.05463813f, 
    -0.04814140f, -0.22132255f, -0.08309791f, -0.04659073f, -0.17918143f, 0.25669304f, -0.00656142f, 0.07586750f, 
    -0.52702582f, -0.70328373f, 0.15919039f, 0.85605347f, -0.20389757f, 0.52166736f, -0.67974520f, -0.30921647f, 
    0.11968192f, -0.11473376f, -0.19311900f, -0.12055011f, -0.11698215f, -0.24403548f, -0.27122173f, -0.21395572f, 
    0.25231266f, 0.08214501f, -0.23510082f, 0.29191238f, 0.04724596f, -0.01131881f, -0.09205887f, -0.15008301f, 
    0.23927896f, 0.72816563f, 0.56406659f, 0.06682303f, -0.14054091f, -0.44495219f, -0.33351123f, -0.15940805f, 
    -0.01868540f, -0.19742407f, -0.07040872f, 0.16712505f, -0.10688063f, 0.15411587f, -0.48546550f, 0.12636843f, 
    -0.08551278f, 0.25979090f, 0.18976754f, -0.19821556f, 0.06968423f, 0.08187030f, 0.09990600f, -0.07737210f, 
    0.09098408f, 0.23373291f, 0.54416090f, 0.60423839f, -0.92838603f, -0.46398711f, -0.48408285f, -0.09408689f, 
    -0.11526557f, -0.03000944f, 0.01010563f, -0.11517176f, 0.40237409f, 0.16309313f, 0.27739275f, 0.30101138f, 
    -0.20859988f, -0.00642082f, 0.02984204f, -0.10918227f, 0.13362220f, 0.12723325f, -0.00167688f, 0.09477332f, 
    -0.15829986f, -0.32271928f, -0.85859954f, -0.77961308f, -0.08789332f, 0.21446207f, 0.55542713f, 0.58389091f, 
    0.04071769f, -0.19667168f, 0.24509607f, 0.36264834f, -0.21400279f, -0.47639492f, -0.34610271f, -0.19409601f, 
    0.01183909f, 0.10414096f, 0.19921567f, -0.10401152f, 0.08448765f, 0.04478515f, -0.12546952f, -0.31538105f, 
    -0.23735091f, 0.07110115f, -0.26854095f, -0.51766199f, -0.47832483f, 0.20811410f, -0.09065196f, 0.41170397f, 
    0.07088937f, -0.08570931f, -0.19833204f, -0.09277370f, 0.37331799f, 0.10534529f, -0.48010468f, -0.04434133f, 
    0.42315328f, -0.46984616f, -0.00994306f, -0.19495864f, -0.23455749f, -0.08131668f, -0.57987773f, -0.20949619f, 
    0.08787612f, -0.34846202f, -0.29327914f, -0.40013865f, 0.21663757f, -0.71607167f, -0.01524313f, 0.00350475f, 
    0.31504986f, -0.20510770f, -0.38336867f, -0.00124445f, 0.33355168f, 0.31624681f, 0.01956163f, 0.01021612f, 
    0.10147508f, 0.06226868f, -0.36508536f, 0.28141066f, 0.20749746f, -0.06046447f, -0.13211958f, -0.45967081f, 
    -0.17203306f, 0.23913944f, -0.24342194f, -0.27179694f, 0.32520214f, 0.33662426f, 0.22881342f, -0.01690716f, 
    -0.09808420f, 0.32765260f, 0.08285754f, -0.23003304f, -0.13333076f, -0.10708322f, -0.24247991f, -0.04654218f, 
    -0.23106347f, -0.05464426f, 0.19019541f, 0.18558936f, 0.02875547f, 0.26809451f, -0.02745643f, -0.19684598f, 
    -0.18569852f, -0.16749781f, -0.29034200f, 0.15209666f, 0.31958258f, -0.18918610f, -0.24503461f, 0.41444013f, 
    -0.02889281f, -0.66465443f, -0.39893308f, 0.01545039f, 0.57160264f, 0.52239263f, -0.28295207f, -0.18068171f, 
    -0.14563912f, 0.24992836f, -0.16942047f, -0.30557767f, -0.11534229f, 0.07003286f, 0.31817934f, -0.06202886f, 
    0.14778076f, -0.25863695f, -0.13183685f, -0.14418729f, -0.24334762f, -0.40690538f, -0.42267469f, -0.22028330f, 
    0.41779238f, 0.42167717f, -0.07227616f, 0.07758271f, -0.17807558f, 0.31049976f, -0.31245863f, -0.47954139f, 
    -0.53566533f, -0.42172354f, -0.00911284f, -0.28698328f, -0.15491986f, -0.11458651f, -0.18728553f, -0.14606480f, 
    0.28278974f, 0.40008539f, 0.22697048f, 0.03462681f, -0.02436078f, -0.01840487f, -0.23523040f, -0.06336289f, 
    -0.52817404f, 0.12004354f, -0.12920301f, -1.02354169f, -0.56201553f, -0.29860079f, -0.27664095f, 0.33830181f, 
    0.47266924f, 0.26910195f, -0.25010413f, -0.10275178f, -0.26028833f, -0.06296049f, -0.24724302f, 0.09517887f, 
    -0.24189441f, 0.08087952f, -0.25316393f, -0.35244450f, -0.00580559f, 0.04613779f, -0.07895373f, 0.28470558f, 
    -0.07290158f, 0.03844819f, 0.28665015f, 0.26976797f, -0.38143826f, -0.26084426f, 0.39863911f, -0.08527020f, 
    -0.03162026f, -0.10323943f, -0.18631715f, -0.09115635f, 0.05868261f, -0.10506088f, 0.12006998f, 0.11368617f, 
    0.35987028f, -0.37233704f, -0.17876314f, 0.05017033f, -0.28616390f, 0.16372047f, 0.42004630f, 0.12213852f, 
    0.04135223f, -0.06002526f, 0.20604499f, -0.27051935f, -0.16390564f, 0.55846590f, -0.04097843f, -0.13395545f, 
    0.31735370f, -0.68162137f, -0.62857282f, 0.07471904f, -0.01278796f, 0.28091472f, -0.04446553f, 0.11730752f, 
    0.54477882f, -0.17084186f, -0.05346444f, 0.00696321f, 0.09302698f, -0.06224327f, 0.12582836f, 0.07749803f, 
    0.13271853f, -0.09368950f, -0.34282055f, -0.69828403f, -0.83397830f, -0.66628993f, 0.05959325f, -0.63902646f, 
    0.20597814f, 0.42690906f, -0.20823088f, 0.27051678f, 0.36291710f, -0.01305414f, 0.10008986f, 0.27107817f, 
    -0.09908120f, 0.05357802f, -0.15849601f, -0.27837825f, -0.30116373f, 0.15297179f, -0.05528328f, -0.06158559f, 
    -0.06738472f, 0.08119494f, -0.08334675f, 0.21085243f, -0.51939732f, -0.60976392f, -0.55524981f, 0.06647293f, 
    -0.47294965f, 0.46072546f, -0.19042708f, 0.06880612f, 0.38429478f, 0.53548384f, -0.02487091f, -0.03926685f, 
    -0.04889583f, 0.27934182f, -0.02702761f, -0.15309159f, 0.00636256f, 0.11999781f, 0.00299106f, 0.16380163f, 
    -0.06414630f, -0.24925974f, 0.05856708f, 0.08388703f, -0.30349192f, -0.69022423f, 0.10259027f, 0.14039725f, 
    0.32716197f, 0.18451631f, -0.10668364f, -0.26845589f, -0.16428709f, 0.44098765f, -0.08128507f, 0.07822537f, 
    0.22211693f, -0.33082062f, 0.05086226f, -0.16165882f, -0.14728583f, -0.27391386f, -0.05665268f, 0.36975619f, 
    0.26403901f, -0.05707480f, -0.21265346f, 0.20180672f, -0.17928003f, 0.13178062f, -0.09437443f, -0.20865637f, 
    -0.55702668f, -0.45257124f, -0.61067247f, 0.01928856f, 0.01690900f, 0.38751763f, 0.41764978f, 0.35319924f, 
    0.06270024f, 0.06128776f, -0.13075157f, 0.09080217f, 0.06713510f, 0.19102676f, -0.02657430f, 0.05472032f, 
    0.19395337f, 0.10206310f, -0.08326749f, 0.05391565f, -0.07748391f, -0.27899003f, 0.15934721f, 0.79633498f, 
    -0.21278720f, -0.37300801f, -0.22626075f, -0.15781319f, 0.53100502f, 0.36885914f, 0.14949898f, -0.24448293f, 
    -0.27283028f, -0.01818802f, 0.02591024f, 0.27962852f, -0.21801384f, 0.00936025f, 0.07284488f, 0.05442102f, 
    -0.26732561f, -0.37146184f, 0.01196947f, -0.10593692f, 0.06457422f, -0.00097364f, -0.20361076f, -0.08600936f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.17869742f, -0.31166309f, 0.06093315f, 0.27996707f, 0.08202280f, 0.14221439f, 0.04748166f, -0.00848703f, 
    0.08219662f, 0.20237920f, 0.17434353f, 0.31015056f, 0.14047861f, 0.32976854f, 0.29120073f, 0.05671791f, 
    -0.39832354f, -0.15813108f, -0.25511441f, 0.07850790f, -0.19261254f, -0.11813367f, -0.23284611f, 0.28196302f, 
    -0.12799478f, 0.29085979f, 0.14718303f, 0.01549868f, -0.00188833f, -0.39724177f, 0.06079871f, 0.15452826f, 
    0.28808179f, 0.20010075f, 0.33111051f, -0.39501858f, -0.06962553f, 0.11982220f, 0.27810246f, 0.33934146f, 
    0.05610897f, 0.17912126f, 0.29514271f, 0.00005718f, 0.24795191f, -0.10911192f, 0.43688720f, 0.08504692f, 
    0.18275611f, 0.12070620f, -0.10220990f, -0.17980804f, 0.39101538f, -0.02505486f, 0.09602940f, -0.15044226f, 
    0.02080247f, 0.05198409f, 0.07307854f, 0.52755594f, 0.22513057f, 0.22257677f, 0.07015444f, 0.11703964f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.08038615f, -0.16147107f, 0.08977894f, -0.08111166f, -0.05675608f, 0.01040713f, -0.20591155f, -0.00669176f, 
    -0.04961375f, -0.02411774f, -0.05215604f, -0.08554966f, 0.21551807f, 0.11894633f, -0.17530705f, -0.17327993f, 
    0.03348675f, 0.19761209f, -0.03105787f, -0.01808158f, -0.00702468f, -0.06533805f, -0.00307415f, -0.00290470f, 
    -0.02817018f, 0.17622936f, 0.11692170f, -0.15499133f, -0.10501271f, 0.06628171f, 0.07445505f, -0.04917859f, 
    0.03108938f, -0.07758263f, -0.04002040f, -0.08319969f, -0.05325758f, -0.03407053f, -0.37285241f, 0.01370413f, 
    -0.00936253f, -0.06501149f, -0.13013959f, -0.12904797f, -0.07295383f, -0.11028872f, -0.08417752f, -0.10378309f, 
    -0.01373995f, 0.05998913f, 0.03442822f, 0.03377634f, -0.07795943f, -0.23994370f, -0.01949532f, -0.05909763f, 
    -0.05497746f, 0.00849769f, -0.07320324f, -0.04367996f, 0.16391447f, 0.06764307f, 0.17757690f, -0.13037355f, 
    -0.03582476f, 0.00006191f, 0.07130274f, 0.06915959f, -0.18525413f, -0.03270968f, -0.12313469f, 0.04341026f, 
    0.28360149f, 0.06527083f, -0.01980265f, -0.10975721f, -0.01054376f, 0.09742287f, 0.01801871f, -0.02960516f, 
    -0.03466460f, 0.00740755f, 0.00448085f, 0.06408118f, 0.34917629f, 0.15710415f, -0.15057729f, -0.13600028f, 
    0.01977946f, -0.03649897f, 0.06028006f, 0.00778010f, 0.02162853f, 0.03581585f, 0.02165134f, 0.06827046f, 
    -0.15679379f, 0.01150837f, -0.00422914f, 0.03977052f, 0.05741882f, -0.00243783f, 0.05418964f, 0.01435313f, 
    -0.06122899f, -0.18988556f, -0.20574929f, -0.04025578f, 0.15190463f, 0.27363974f, 0.04639202f, -0.27561182f, 
    -0.15882994f, -0.19110546f, 0.01325521f, 0.03907800f, 0.07566427f, -0.09448972f, 0.03184219f, -0.02300741f, 
    0.02144144f, -0.23754469f, -0.22651842f, 0.03249750f, -0.05578674f, 0.05287344f, -0.09047040f, -0.09403335f, 
    -0.15134881f, -0.12938400f, 0.06345258f, -0.04100046f, -0.08148158f, -0.19919519f, 0.08505373f, -0.17930880f, 
    -0.00267305f, -0.07920387f, 0.06402970f, 0.01763268f, -0.13634206f, -0.00169745f, -0.16956754f, -0.03445920f, 
    -0.09887255f, -0.16759151f, 0.03304434f, 0.02383729f, 0.03163210f, 0.01799845f, -0.02754517f, -0.07703669f, 
    -0.13714616f, -0.07069254f, -0.06879021f, -0.06798560f, 0.25613511f, 0.12080461f, -0.29587257f, -0.17092203f, 
    -0.00102441f, -0.01990747f, -0.03803419f, -0.02703052f, -0.03984532f, -0.01517594f, -0.02758285f, -0.03076847f, 
    0.13164744f, 0.19613114f, 0.10579507f, -0.12337650f, 0.03893751f, 0.07332190f, 0.06428830f, 0.02515747f, 
    -0.00298118f, -0.10416777f, -0.03299728f, 0.04594234f, 0.11056458f, -0.09989720f, 0.13926272f, -0.02832701f, 
    0.02573121f, 0.06268594f, -0.09382708f, -0.14525905f, -0.09769496f, -0.05161961f, -0.07892768f, -0.07587472f, 
    0.27569738f, 0.21494098f, -0.08043799f, -0.14528866f, 0.10037233f, 0.28126350f, 0.08778239f, 0.12094118f, 
    -0.04560587f, 0.02068841f, 0.00269723f, -0.01650219f, -0.03093464f, -0.00383370f, -0.02421470f, -0.00095994f, 
    0.02385841f, 0.02066657f, 0.07211308f, 0.07023029f, -0.06456681f, -0.03133030f, -0.15071957f, -0.20725130f, 
    0.00222830f, 0.05569359f, 0.00844238f, 0.03256906f, -0.11415146f, 0.08445822f, 0.08469985f, -0.02224751f, 
    -0.13747105f, -0.20193091f, 0.01381443f, 0.13927375f, -0.08669593f, -0.53865945f, -0.48630759f, 0.21239950f, 
    -0.05671968f, 0.02691746f, -0.01588718f, -0.04528210f, -0.01413079f, 0.03746878f, -0.03355298f, -0.04439916f, 
    0.18463922f, 0.01851683f, 0.01720393f, 0.04784868f, 0.14897011f, 0.18641150f, 0.06157826f, -0.00694125f, 
    -0.04707265f, 0.13169441f, 0.03251257f, 0.09733973f, -0.34059587f, 0.13644743f, -0.10400707f, 0.09237237f, 
    0.03828410f, 0.04965496f, -0.00378064f, 0.03966524f, 0.03547149f, 0.03451838f, 0.11459638f, 0.07273610f, 
    0.10362918f, 0.13279109f, 0.09820715f, 0.06332758f, -0.05751799f, 0.22937371f, -0.07743932f, 0.01720249f, 
    -0.12520188f, -0.05807124f, -0.05120723f, -0.01890192f, 0.16550815f, 0.27227348f, 0.40987134f, -0.33142146f, 
    -0.03029867f, 0.04356937f, -0.07730269f, 0.09599441f, -0.01288251f, -0.06919151f, -0.18730499f, -0.08612438f, 
    -0.07128425f, -0.06490897f, 0.00533762f, 0.03385619f, 0.02679301f, -0.07430928f, 0.03414084f, 0.06390943f, 
    0.01047665f, 0.04906934f, 0.05158707f, 0.00705242f, -0.53607619f, 0.00020250f, -0.11985832f, 0.27551037f, 
    -0.02754959f, -0.05511555f, 0.09143396f, 0.00398932f, -0.00040409f, 0.02753853f, 0.01926336f, 0.02986183f, 
    0.13687344f, 0.07025124f, -0.10833947f, -0.09114649f, -0.02961988f, -0.07055478f, -0.03541841f, -0.03473943f, 
    0.00658097f, 0.10406461f, -0.02434813f, -0.02295348f, 0.14222270f, 0.11985832f, 0.00231594f, -0.09410528f, 
    0.02464432f, 0.05842758f, 0.09992890f, -0.36292550f, -0.12715527f, -0.00657075f, -0.02597762f, -0.16513902f, 
    0.26105157f, 0.17451406f, -0.22175305f, -0.11369797f, 0.09406075f, 0.13930762f, 0.00062667f, -0.03771206f, 
    -0.08502675f, -0.10503501f, -0.15475717f, -0.02876400f, 0.29949927f, 0.08511166f, -0.03841273f, -0.14609356f, 
    0.21977839f, 0.03180758f, 0.00089494f, 0.00447000f, -0.03901551f, -0.00490228f, -0.02294456f, -0.01090343f, 
    -0.14421090f, 0.00513730f, 0.05771600f, -0.02769739f, 0.00106388f, -0.02406974f, -0.09362147f, -0.03393417f, 
    -0.04153454f, -0.02604871f, -0.11200502f, 0.08165216f, 0.12578964f, 0.22506993f, -0.00053767f, -0.22238606f, 
    -0.11886258f, 0.11436705f, 0.04860989f, -0.32829359f, -0.12557422f, 0.00093394f, -0.08890080f, -0.07262988f, 
    -0.26965851f, -0.17916732f, 0.15361741f, -0.06004348f, -0.20914017f, -0.11986542f, 0.05600864f, -0.01061338f, 
    -0.12746124f, -0.07617252f, -0.02976081f, -0.12028799f, 0.31782439f, 0.20784435f, -0.04201237f, -0.25919864f, 
    0.02334723f, -0.06278542f, 0.02821317f, 0.06046500f, 0.00802213f, -0.03496881f, -0.05698000f, -0.03203734f, 
    -0.05241940f, -0.17746106f, -0.17478594f, 0.03347154f, 0.00714202f, -0.17792001f, 0.11130165f, -0.23227412f, 
    -0.11150043f, -0.02825242f, -0.03456482f, -0.09817208f, 0.18840802f, -0.01096726f, -0.06293620f, 0.04346812f, 
    0.05449956f, 0.07405277f, -0.12979218f, -0.02521638f, -0.04959720f, -0.08846545f, -0.10233264f, 0.02992869f, 
    0.02698181f, -0.18203172f, 0.10687951f, -0.19622488f, -0.07234875f, -0.05330964f, -0.07640382f, 0.00936490f, 
    -0.01138940f, 0.08795235f, 0.04595773f, 0.08184091f, 0.06265874f, -0.14515056f, -0.43703863f, 0.04120327f, 
    -0.04593794f, 0.01282269f, -0.08851588f, -0.04921138f, -0.11035573f, 0.10052422f, 0.04812759f, 0.01549970f, 
    -0.24631181f, -0.16481909f, 0.15530187f, -0.18739283f, -0.03867315f, -0.12842481f, 0.03145102f, 0.06188162f, 
    0.03407454f, -0.22438952f, 0.04240852f, -0.22054476f, -0.23387837f, -0.06537648f, 0.08056639f, -0.04593778f, 
    0.02076188f, 0.00179450f, 0.01846777f, 0.00099402f, 0.03179146f, 0.05347869f, 0.04418261f, -0.07721422f, 
    0.10155483f, -0.07137796f, -0.13757151f, 0.07110517f, 0.04460182f, 0.01869668f, -0.06393410f, 0.01333370f, 
    -0.02455932f, 0.09805404f, -0.10101736f, -0.13101196f, -0.02113587f, -0.41360682f, -0.34787169f, -0.04304746f, 
    -0.08886236f, 0.04329938f, 0.00898494f, 0.01974839f, -0.03141683f, 0.12328704f, -0.01737495f, -0.04721745f, 
    0.48066801f, -0.28354445f, -0.35685876f, -0.13357462f, -0.05448269f, -0.01248309f, 0.02782667f, -0.11502677f, 
    -0.07992484f, -0.14780708f, -0.06562739f, 0.18281966f, 0.31875446f, 0.25112346f, -0.23952015f, -0.09718500f, 
    0.09823428f, -0.05574846f, 0.00026594f, 0.03098531f, 0.01679099f, 0.01748296f, 0.01687431f, 0.01797280f, 
    0.16077375f, -0.18780126f, -0.21174218f, 0.02892113f, -0.22020413f, -0.03455134f, -0.11978548f, 0.03681474f, 
    -0.16077547f, -0.14952523f, -0.18872793f, -0.11485204f, 0.14508057f, 0.17240193f, 0.06791367f, -0.14407779f, 
    0.04036082f, 0.08147175f, 0.02244060f, -0.08480645f, 0.07801580f, 0.07050150f, -0.06326993f, -0.03336827f, 
    -0.50919825f, 0.26582685f, 0.31525955f, -0.39541754f, 0.02664079f, -0.01587415f, -0.08042675f, -0.04162456f, 
    0.05370758f, -0.09167266f, -0.06998318f, 0.00437792f, 0.22590512f, 0.12338220f, -0.03273915f, -0.04280343f, 
    -0.01232622f, -0.09597322f, 0.15491474f, -0.13721018f, -0.01422875f, -0.09369371f, -0.03694225f, 0.07555365f, 
    -0.07764278f, 0.03159341f, -0.04169118f, 0.04053178f, -0.04032449f, -0.09204856f, -0.10089874f, 0.03796414f, 
    -0.00171626f, 0.00512075f, -0.01329943f, -0.01649607f, 0.07770829f, -0.13407052f, 0.00082900f, 0.03610490f, 
    -0.10497589f, -0.01003748f, -0.12053850f, 0.04302417f, 0.06117482f, -0.02740512f, 0.01460894f, -0.07724525f, 
    0.48795703f, 0.14772925f, 0.10696658f, -0.25413874f, -0.05740181f, 0.06267060f, 0.12174992f, -0.12290229f, 
    0.04176362f, 0.12851456f, 0.04123189f, 0.08871835f, 0.22455356f, 0.13694079f, 0.03510903f, -0.01421086f, 
    -0.06677785f, 0.01718768f, -0.01040015f, 0.04090399f, 0.01022389f, 0.10166408f, -0.01321232f, 0.09905607f, 
    -0.15109321f, 0.13742980f, 0.08191460f, -0.11664389f, -0.10716842f, -0.02561300f, 0.14289074f, -0.03458304f, 
    -0.23288324f, -0.05871968f, 0.02951655f, -0.01983237f, -0.06687730f, -0.04633045f, -0.06406563f, 0.09519710f, 
    0.02712536f, 0.03402795f, -0.06587522f, -0.05648666f, 0.01867481f, 0.01251036f, -0.02020020f, 0.05773446f, 
    -0.05090927f, -0.05137638f, -0.06328633f, 0.06732529f, 0.04468048f, 0.10509571f, -0.19495444f, -0.00207655f, 
    0.00834159f, 0.12737110f, -0.04609769f, -0.00680636f, 0.16492729f, 0.09646375f, -0.08523358f, 0.08831719f, 
    -0.04665059f, 0.01434839f, 0.00607123f, -0.01932226f, 0.01957990f, 0.01334502f, 0.05523555f, 0.02291309f, 
    -0.06330197f, -0.05137077f, 0.08474170f, 0.00422840f, 0.00469232f, 0.19258626f, -0.02265014f, 0.01326857f, 
    0.01610032f, -0.08751342f, -0.04432582f, -0.05550152f, -0.02134014f, -0.02514540f, -0.05493548f, 0.05185524f, 
    -0.09315822f, 0.08223211f, -0.13613611f, -0.00005086f, -0.07211439f, -0.07756814f, -0.05482406f, -0.04324548f, 
    0.09456389f, 0.14202954f, 0.00595996f, -0.09049296f, -0.31237617f, -0.17274648f, 0.06812241f, -0.06455164f, 
    -0.05821070f, 0.00124610f, -0.05723818f, 0.01846150f, 0.04447674f, 0.14592297f, -0.09723148f, -0.12057126f, 
    0.12329246f, 0.03458013f, 0.04120788f, -0.19104566f, 0.01018241f, -0.09527781f, -0.05737641f, 0.02866022f, 
    0.18023464f, 0.06765736f, 0.09809039f, -0.02325325f, 0.05064795f, 0.07388208f, 0.00757399f, -0.21186382f, 
    0.01860977f, 0.06661710f, -0.01079986f, 0.01313822f, -0.16171288f, 0.26258481f, 0.14710505f, -0.33367044f, 
    -0.09151857f, -0.16729335f, -0.04830285f, -0.01343494f, 0.05353937f, 0.03242864f, 0.03923730f, -0.12261073f, 
    -0.00514565f, -0.03626597f, 0.01811091f, 0.06682307f, 0.12673669f, 0.06895581f, -0.08271874f, 0.00114109f, 
    -0.06270485f, 0.05525342f, -0.01185241f, 0.07530195f, -0.01571938f, -0.08506651f, -0.30755839f, 0.08214352f, 
    0.01124189f, -0.00123667f, -0.01348635f, -0.03117782f, -0.05356389f, -0.03838583f, -0.18297805f, -0.08466134f, 
    -0.02550491f, 0.05458352f, -0.01425269f, -0.25829637f, 0.04805984f, 0.04455421f, -0.18687952f, 0.02936446f, 
    -0.20409402f, -0.01686138f, -0.09663998f, -0.00287304f, -0.03713425f, 0.19342084f, 0.35902572f, 0.14607954f, 
    0.00545694f, -0.10841469f, -0.16953909f, -0.04708644f, -0.05631211f, -0.02005279f, 0.00385678f, 0.03387044f, 
    -0.21492261f, 0.01193123f, -0.11661935f, -0.02888315f, 0.14425586f, -0.02547223f, 0.07007205f, 0.12414163f, 
    -0.08009975f, -0.08087724f, -0.01764174f, 0.06458289f, 0.38706163f, -0.24532074f, 0.06391225f, 0.19666341f, 
    0.02453280f, 0.03708602f, -0.05060042f, 0.10602459f, 0.08826124f, 0.00311507f, -0.21395472f, -0.04667170f, 
    0.06500931f, 0.01978798f, -0.00562927f, -0.01387367f, -0.08084161f, 0.10977411f, 0.10972595f, -0.03565240f, 
    -0.07832625f, -0.02198866f, 0.05515166f, 0.03693590f, 0.35955572f, -0.01130879f, -0.05581716f, -0.08412452f, 
    -0.11518791f, 0.01387048f, -0.03550067f, -0.00318519f, 0.07385138f, -0.22371410f, -0.26732579f, -0.06483234f, 
    0.02799452f, 0.22975720f, 0.02778408f, 0.04049133f, 0.02173583f, 0.14673220f, 0.20700210f, -0.15564413f, 
    -0.04293739f, 0.00591156f, -0.02953210f, -0.08225940f, 0.13757306f, -0.05798144f, 0.09914886f, 0.27654478f, 
    -0.07158411f, -0.02729182f, -0.01003961f, -0.04473122f, 0.14677867f, 0.02702512f, 0.02749849f, -0.00490955f, 
    0.07881574f, 0.10181674f, 0.07443216f, 0.03164514f, -0.07103818f, -0.05790099f, 0.01655556f, 0.02515714f, 
    -0.06821638f, 0.01016739f, -0.01365860f, 0.14746645f, -0.43494138f, -0.15891330f, -0.61271650f, 0.03569800f, 
    -0.02966047f, 0.17010470f, 0.09973016f, 0.05933542f, -0.02733848f, 0.03246579f, -0.23390837f, 0.09762280f, 
    0.38981560f, -0.19819194f, -0.06264815f, 0.11643269f, 0.07797936f, 0.01128021f, -0.04963566f, -0.03954427f, 
    0.01435200f, 0.11020164f, 0.02800463f, -0.13139884f, -0.14156452f, -0.08406119f, 0.06380319f, 0.10921052f, 
    -0.06184970f, 0.02153450f, -0.00903449f, 0.05634830f, -0.08006959f, 0.01884302f, 0.16258718f, -0.06334528f, 
    0.01798689f, -0.15955061f, -0.00626116f, 0.11987603f, 0.01212090f, -0.02133356f, 0.01798866f, 0.07293328f, 
    -0.10889880f, 0.22210664f, -0.04827916f, 0.06036840f, 0.11490805f, 0.02839115f, 0.04789940f, -0.20027608f, 
    0.00465530f, -0.06243908f, 0.11914742f, -0.10852798f, 0.01398942f, -0.00903172f, -0.00178970f, 0.00257842f, 
    -0.31490421f, -0.18195422f, -0.32711482f, -0.10474657f, -0.06352910f, 0.07576229f, 0.08637688f, 0.07159686f, 
    -0.08167353f, 0.04930062f, 0.09499288f, 0.00312408f, -0.03551495f, -0.14795852f, 0.12209915f, -0.05320788f, 
    -0.00132355f, 0.10438762f, -0.02892546f, 0.09769049f, 0.04268483f, 0.02231177f, 0.01447972f, -0.06205675f, 
    0.51622403f, 0.36147290f, 0.39603293f, 0.27676821f, 0.22183362f, 0.08554223f, -0.22910200f, -0.01998891f, 
    -0.03393512f, 0.01163057f, -0.03025029f, -0.14109503f, 0.08602479f, 0.11980686f, 0.07771356f, 0.08362688f, 
    -0.06263963f, -0.04529017f, -0.00302306f, -0.08108943f, -0.01044637f, 0.09397069f, 0.10164780f, 0.02844621f, 
    0.02403144f, -0.01966561f, 0.10948972f, -0.25497374f, 0.05276821f, 0.05036141f, 0.10514414f, -0.00352290f, 
    -0.08047957f, 0.16447209f, -0.22375500f, -0.07649041f, 0.23723851f, 0.12637904f, 0.07689577f, 0.20654964f, 
    0.00945283f, -0.09445457f, -0.06513474f, -0.01032196f, -0.07162973f, -0.04655154f, 0.06667666f, 0.09856406f, 
    -0.07969814f, -0.07331680f, -0.05673924f, 0.00918234f, -0.00816545f, 0.05399810f, 0.00116307f, -0.09492333f, 
    0.04372367f, -0.16200615f, 0.03743272f, -0.06056413f, 0.00431265f, 0.09449632f, 0.04471987f, 0.04421725f, 
    0.01343641f, 0.03264559f, -0.06651290f, 0.00873189f, -0.35639602f, 0.05902057f, -0.29162383f, -0.30751058f, 
    0.01719934f, -0.13399491f, 0.24855721f, 0.02450047f, 0.09779875f, -0.01424256f, -0.03836479f, -0.04268033f, 
    -0.02743355f, 0.02988182f, -0.01129913f, -0.04665901f, -1.03168786f, -0.03959966f, -0.29966533f, -0.08251829f, 
    0.06737353f, -0.26288894f, -0.09452823f, 0.00156398f, -0.10531186f, 0.03896434f, 0.02224746f, 0.07377186f, 
    0.09973155f, 0.07010698f, 0.05466045f, 0.00567006f, -0.03935885f, -0.00765751f, -0.00537931f, -0.06541038f, 
    -0.06696756f, 0.03601098f, -0.02814914f, -0.01937887f, 0.37202081f, 0.05820068f, 0.28806841f, 0.27947792f, 
    0.02155825f, 0.00349443f, -0.03365441f, 0.06306265f, 0.05152714f, -0.09794048f, 0.04629508f, 0.14169231f, 
    -0.01138796f, 0.02975817f, -0.19290431f, 0.01951061f, -0.14240634f, -0.05915955f, 0.18192385f, 0.00696218f, 
    -0.08895545f, 0.15659113f, -0.00190811f, 0.09264817f, -0.26633307f, 0.00771618f, 0.26726672f, -0.18280733f, 
    0.09102827f, 0.15518452f, 0.04810138f, 0.11092303f, -0.00663507f, -0.04948612f, 0.12990062f, -0.19051899f, 
    -0.08666375f, -0.00597461f, -0.09419753f, 0.04954688f, -0.16503951f, -0.00211330f, 0.14658494f, 0.27139887f, 
    0.08477006f, 0.04521113f, -0.04379395f, 0.12947011f, 0.17540607f, 0.11280467f, 0.17623930f, -0.05638460f, 
    -0.07782198f, 0.06954198f, -0.08766779f, -0.14762297f, 0.07907031f, -0.05972374f, -0.02555137f, -0.00747692f, 
    -0.29830530f, -0.01811545f, 0.22625907f, -0.07497690f, 0.07692315f, -0.03428529f, -0.11399108f, 0.01342067f, 
    -0.00044105f, 0.05206316f, -0.50813961f, 0.00868459f, -0.44535398f, -0.37213916f, -0.18597743f, 0.10374321f, 
    0.02963633f, 0.19359638f, -0.05089561f, 0.11980885f, 0.04134778f, 0.08799246f, 0.02131812f, 0.03118451f, 
    -0.45163122f, -0.19068506f, 0.10102602f, -0.02103566f, 0.14881283f, 0.07154559f, -0.00223056f, 0.05855855f, 
    0.08861418f, 0.01294142f, 0.02978834f, 0.05323860f, -0.39070547f, -0.07861601f, -0.18596274f, -0.00097838f, 
    -0.02332846f, -0.15703157f, 0.06859671f, -0.03253041f, 0.05101589f, 0.03051827f, 0.00200118f, -0.07200080f, 
    0.17211458f, -0.11554539f, 0.20621407f, -0.13312225f, 0.08321428f, 0.21261641f, 0.00913425f, 0.01605023f, 
    -0.03223797f, -0.06206535f, -0.02788595f, 0.03335107f, 0.39448524f, 0.27665430f, 0.03443972f, -0.18362716f, 
    0.03546389f, 0.03700325f, 0.12044207f, 0.07241873f, 0.04292836f, -0.03824272f, -0.20471503f, -0.14583877f, 
    -0.00632349f, -0.04923526f, -0.02041657f, -0.38311899f, 0.06367216f, -0.00114038f, 0.00631548f, 0.06031052f, 
    -0.00099850f, -0.01569482f, -0.18163656f, -0.11523662f, 0.28964549f, -0.02089889f, -0.24223246f, -0.20292787f, 
    -0.15744737f, -0.32875037f, 0.18046488f, 0.14608404f, -0.03441694f, 0.05194189f, -0.11406435f, 0.03386203f, 
    -0.38392353f, 0.09015090f, 0.06613226f, -0.24002862f, 0.06522968f, 0.09194773f, 0.01384383f, -0.05425106f, 
    -0.00214432f, 0.19637729f, -0.05388707f, -0.00961482f, 0.13335626f, 0.12270635f, 0.07701378f, 0.15097919f, 
    -0.03478043f, -0.00774618f, -0.03809400f, 0.03751681f, -0.06958763f, 0.12823664f, -0.00207386f, -0.00579666f, 
    0.15578647f, 0.05420051f, 0.04856730f, -0.00405292f, -0.12837924f, -0.00459307f, -0.02228201f, -0.00106374f, 
    0.00373124f, -0.17057046f, -0.07084938f, 0.02844785f, 0.49348402f, -0.06531733f, 0.24881849f, 0.20336966f, 
    -0.02678132f, -0.04500400f, 0.10049943f, -0.08970851f, 0.24187455f, 0.06881297f, -0.00707643f, -0.06853257f, 
    0.18403243f, -0.31504986f, 0.14061436f, 0.06535055f, 0.10177655f, -0.02493668f, 0.10896447f, -0.03202046f, 
    0.04529002f, -0.08224418f, 0.13841164f, 0.05718949f, 0.00767300f, 0.06572672f, -0.27406514f, 0.13808516f, 
    -0.18762249f, -0.10829888f, -0.06774037f, -0.10679211f, -0.13923797f, 0.00694899f, -0.00678948f, 0.10229522f, 
    0.09025650f, 0.07121905f, 0.06731255f, 0.00146540f, 0.12554280f, 0.04016189f, 0.06028567f, 0.17463487f, 
    -0.02446259f, 0.06967519f, -0.10633364f, -0.06857917f, -0.23399611f, -0.04199035f, -0.12007520f, -0.18543123f, 
    0.01333744f, 0.04960399f, -0.01120571f, 0.01075144f, -0.16685562f, -0.22173110f, 0.11082191f, 0.09321584f, 
    -0.16675438f, 0.27000761f, 0.06792515f, -0.01058604f, 0.04019521f, -0.00969283f, 0.04169067f, 0.04381837f, 
    0.03127806f, -0.03610941f, -0.01382517f, -0.00315543f, -0.06580695f, -0.07864050f, -0.10506731f, -0.14136581f, 
    0.00142865f, -0.08810294f, -0.00265849f, -0.04984017f, -0.02515707f, -0.00764581f, -0.05110579f, -0.09690361f, 
    0.17943616f, 0.01203336f, 0.09224131f, -0.08423763f, 0.01872243f, -0.01455488f, -0.08540362f, -0.08338930f, 
    -0.06658693f, -0.06153082f, 0.03235575f, 0.01558718f, -0.02478780f, -0.12619875f, -0.05343049f, -0.12110214f, 
    0.14048107f, 0.08956468f, -0.12034259f, 0.10771593f, 0.15453227f, 0.15137823f, -0.05322786f, 0.07390604f, 
    0.25813130f, -0.01888983f, -0.28848690f, 0.10107438f, -0.05491397f, -0.00292146f, -0.06863275f, -0.10445175f, 
    0.17191833f, -0.15044390f, -0.16542256f, -0.33130777f, -0.04540178f, -0.18893409f, -0.38290626f, 0.23163988f, 
    0.01001763f, 0.05613362f, -0.05114086f, 0.08507656f, -0.23518942f, -0.16142423f, -0.22457540f, -0.19176432f, 
    -0.23948313f, 0.07308783f, -0.02769795f, -0.02035262f, 0.04696257f, 0.11267133f, -0.01389222f, -0.07344332f, 
    0.09306519f, 0.21024251f, -0.04271275f, 0.18475699f, 0.08552658f, 0.04499530f, 0.00960635f, 0.05390482f, 
    0.00111381f, -0.08011454f, 0.06262813f, -0.10556193f, 0.05246432f, 0.13525455f, 0.03192985f, -0.05828293f, 
    -0.03629815f, -0.21776919f, 0.07301135f, -0.08717006f, 0.04518337f, -0.03416088f, -0.20071435f, -0.08842566f, 
    0.00140082f, 0.03002708f, -0.26011974f, -0.07197057f, 0.02118918f, -0.36491349f, -0.27007747f, -0.47351220f, 
    0.04812818f, -0.10357786f, -0.16567345f, 0.05604441f, 0.01890931f, -0.02795036f, 0.01543741f, -0.01440595f, 
    0.00758031f, 0.14133970f, 0.10137501f, -0.11988360f, 0.03274480f, 0.13639447f, 0.00179510f, 0.10544318f, 
    0.02153550f, 0.02298505f, -0.01804494f, -0.09966654f, 0.12204926f, -0.15770884f, 0.02108703f, 0.04745041f, 
    -0.04518276f, -0.04295112f, 0.06483335f, 0.04893754f, -0.06862719f, -0.07888696f, 0.09054457f, -0.07934242f, 
    -0.04348652f, 0.07548833f, -0.02977319f, -0.20166786f, -0.00018323f, 0.07895663f, -0.08331428f, 0.20288350f, 
    -0.01719776f, -0.04924392f, 0.20281066f, 0.06841431f, 0.04322974f, 0.05548590f, -0.24433726f, -0.15725495f, 
    -0.01566454f, 0.07835113f, 0.09136575f, 0.00328316f, 0.03503779f, 0.07690667f, 0.05882945f, -0.03136244f, 
    0.00528320f, 0.07703236f, -0.11613705f, -0.17599927f, -0.04543503f, 0.06757085f, 0.08004116f, -0.15251890f, 
    0.00865111f, -0.10941261f, 0.07975849f, -0.13499676f, -0.15986499f, 0.10397320f, -0.04235183f, -0.02089809f, 
    0.06027400f, 0.08423761f, -0.06714568f, 0.20510317f, -0.02841370f, 0.04082547f, 0.01161617f, -0.04554591f, 
    -0.10601732f, -0.03031503f, -0.01133651f, -0.09535000f, -0.00710059f, 0.08826500f, -0.08393431f, -0.34452111f, 
    -0.04260220f, 0.00621426f, -0.02316098f, -0.09022351f, 0.55394673f, -0.13696496f, 0.14041734f, -0.01777462f, 
    0.02540778f, -0.04611686f, -0.01590521f, 0.00803418f, -0.04118738f, -0.19741514f, -0.10472798f, -0.11946582f, 
    0.22529206f, 0.13957098f, -0.03200044f, 0.21535267f, 0.02344563f, -0.07645373f, 0.12232144f, 0.09888761f, 
    0.07657778f, 0.03318088f, -0.24129666f, 0.12099853f, -0.85426927f, -0.63835132f, -0.30739281f, -0.44561383f, 
    -0.04768340f, -0.01897892f, -0.13397968f, -0.16458420f, -0.02598014f, -0.03186856f, -0.04114655f, -0.06673430f, 
    -0.11741699f, -0.15836217f, -0.03315057f, 0.03302238f, 0.11571981f, -0.04433376f, -0.20151681f, -0.06706117f, 
    0.03200998f, -0.03601439f, 0.01473802f, 0.01944094f, -0.20987590f, 0.30733639f, 0.11429768f, 0.23477584f, 
    -0.00933396f, 0.03565798f, 0.00459542f, -0.02782400f, -0.04794735f, 0.11844531f, -0.05162552f, 0.26677907f, 
    -0.00070397f, -0.04484641f, 0.00485240f, 0.01124508f, -0.13090459f, -0.10233575f, 0.08898339f, -0.03863094f, 
    -0.08378404f, -0.03350553f, -0.01321379f, 0.00157597f, 0.26249844f, -0.13044170f, -0.02001499f, -0.01772691f, 
    0.05622208f, -0.00039883f, -0.07397538f, 0.07623724f, -0.07358472f, 0.02223638f, 0.04427904f, 0.05062707f, 
    -0.23289743f, 0.18211524f, 0.15848669f, 0.05575267f, -0.07797535f, -0.05150363f, 0.18209642f, -0.14122956f, 
    -0.00590882f, 0.04723091f, 0.01285814f, -0.01659534f, -0.12874989f, 0.17444970f, -0.57566822f, -0.18294524f, 
    0.01499488f, -0.00018232f, -0.01650695f, 0.06713114f, 0.00697084f, 0.06518456f, 0.03520047f, -0.21629913f, 
    -0.15732846f, -0.25373921f, 0.04229216f, 0.08655331f, 0.01104908f, 0.00538221f, 0.01482307f, 0.00510856f, 
    -0.12044752f, -0.02250289f, -0.20918532f, -0.06042735f, 0.19769435f, -0.07092092f, -0.52586156f, -0.04620821f, 
    0.01088150f, 0.14687246f, -0.15612873f, -0.05925265f, 0.03761866f, -0.06427670f, 0.05253872f, -0.03391115f, 
    -0.22894682f, 0.18656497f, 0.09820114f, -0.20339957f, 0.04370557f, -0.08194331f, -0.08559038f, -0.05941372f, 
    0.03079940f, 0.08302209f, -0.10099377f, -0.03290731f, 0.08204566f, -0.07715451f, -0.29171491f, 0.07691981f, 
    0.02893631f, -0.04447068f, 0.04154551f, 0.05915689f, 0.09940605f, 0.06824933f, -0.02692328f, 0.12056103f, 
    -0.12449001f, -0.01775858f, -0.14827521f, -0.05599372f, 0.08690131f, -0.13383304f, 0.01747533f, -0.00385989f, 
    -0.06942218f, -0.02735052f, -0.02227096f, -0.07583725f, 0.04408950f, -0.12358642f, 0.33018479f, -0.27170476f, 
    -0.05888307f, 0.04465621f, -0.01042308f, 0.10396781f, 0.03892089f, 0.04934533f, -0.01373459f, 0.00136531f, 
    0.03755214f, 0.32386243f, 0.05846201f, 0.22016734f, -0.04866733f, -0.05499752f, 0.05138835f, -0.02648708f, 
    -0.00831969f, -0.05113460f, -0.07175342f, 0.08927748f, 0.09878644f, -0.14879318f, 0.00016291f, 0.07460380f, 
    0.04146845f, 0.07598957f, -0.25652891f, 0.01248630f, 0.00135016f, -0.11206374f, -0.13002524f, 0.06699413f, 
    -0.37128082f, -0.36532462f, 0.55444092f, 0.55985516f, -0.06221173f, -0.01751625f, -0.08438636f, 0.01043152f, 
    0.02638502f, -0.00279965f, -0.02603730f, 0.02477144f, -0.10015274f, -0.04622779f, -0.03482492f, -0.04811578f, 
    0.00857989f, 0.00498391f, 0.02600706f, 0.00607217f, -0.10006066f, -0.01685385f, -0.05933438f, 0.02029250f, 
    0.05258266f, 0.27666458f, 0.36777249f, 0.11667304f, 0.04000932f, -0.10459962f, 0.10459629f, -0.00437358f, 
    -0.08007149f, -0.07000824f, -0.26438394f, -0.00139102f, -0.01771555f, -0.04561518f, -0.13998374f, -0.07524087f, 
    -0.02125739f, -0.06984052f, 0.00476509f, 0.05745102f, 0.03250832f, 0.02777450f, -0.09651009f, 0.11146916f, 
    0.01483707f, -0.03252998f, 0.07632434f, 0.03751028f, 0.02874593f, -0.13172090f, 0.15306619f, 0.09465381f, 
    0.08312887f, -0.02808034f, 0.14555433f, 0.03717324f, 0.16345236f, -0.09899227f, -0.09348872f, 0.06292761f, 
    -0.01787080f, -0.01220505f, -0.01477561f, -0.01396984f, 0.03710900f, 0.15930228f, 0.16864949f, -0.03383258f, 
    -0.34382889f, -0.33095542f, 0.10599154f, -0.13636100f, 0.01825722f, -0.20656802f, -0.03126050f, -0.14057687f, 
    -0.08334886f, 0.01236618f, 0.06764659f, -0.14952734f, -0.06420971f, 0.08834494f, -0.60223162f, -0.16562781f, 
    0.07370409f, -0.08090158f, -0.05690159f, -0.02692828f, 0.05229923f, 0.00683836f, -0.02899031f, 0.02153077f, 
    -0.13617086f, 0.01126121f, -0.05817478f, -0.06704222f, -0.04364940f, -0.10237586f, 0.00178109f, 0.04118056f, 
    -0.02456431f, -0.02986627f, -0.03149842f, 0.06221199f, 0.21151461f, -0.13080788f, 0.07155626f, -0.21608654f, 
    0.05810982f, -0.02208969f, 0.04463647f, 0.00471654f, 0.00428050f, -0.01878309f, 0.01382928f, 0.06552774f, 
    -0.12069942f, -0.07868955f, -0.02795668f, 0.02086890f, -0.02386328f, 0.00153530f, 0.06054835f, -0.02089768f, 
    -0.03927757f, 0.00780549f, 0.04571151f, -0.02818124f, -0.08293837f, -0.26466238f, 0.49279869f, 0.25329143f, 
    0.02533370f, 0.09635068f, -0.06901924f, -0.07869872f, 0.00879288f, -0.03311524f, -0.05153246f, -0.06772766f, 
    -0.49833149f, -0.02027545f, -0.12898728f, -0.18292193f, -0.01172376f, 0.04126959f, 0.03695745f, -0.07297500f, 
    0.03033247f, 0.00842410f, -0.08407629f, -0.00667764f, -0.79393297f, -0.02006144f, -0.15196915f, -0.43790495f, 
    -0.16628040f, 0.00421949f, 0.07487405f, -0.20658268f, -0.00085157f, 0.03527201f, 0.08467624f, -0.02541314f, 
    0.02159625f, 0.05685320f, 0.05626442f, 0.17512698f, -0.04693910f, 0.01252612f, 0.04759640f, -0.00431716f, 
    0.04639529f, 0.14018072f, 0.03931314f, 0.20408514f, -0.01753664f, -0.61447108f, -0.21765772f, 0.09416638f, 
    0.04182489f, -0.04033298f, -0.11367840f, -0.17724593f, -0.02730963f, -0.09330475f, 0.03620425f, 0.05801385f, 
    0.24641672f, 0.00565575f, -0.17229991f, 0.05419279f, -0.08985920f, 0.04675493f, 0.07025789f, -0.11242986f, 
    -0.04157620f, 0.06277060f, 0.00105846f, -0.13458553f, -0.20590395f, 0.46338919f, -0.34284192f, -0.07820638f, 
    0.11343233f, -0.16368769f, 0.11033557f, 0.01331922f, -0.08434405f, 0.05044993f, 0.04216211f, -0.10112768f, 
    -0.13894956f, -0.04041863f, 0.14621688f, -0.08748242f, -0.01178199f, 0.11266966f, -0.35648039f, 0.11070972f, 
    0.10443177f, -0.19178991f, 0.13072369f, 0.03329526f, -0.34104332f, 0.48925790f, 0.49552819f, 0.09404022f, 
    -0.05107613f, -0.03980693f, 0.05911549f, -0.09800468f, 0.01393206f, -0.02079063f, 0.02144722f, -0.17775555f, 
    -0.26728827f, -0.00785750f, 0.02676976f, -0.15190493f, -0.00152277f, -0.06628980f, -0.26036635f, -0.11984918f, 
    0.07833772f, 0.00421673f, 0.05242821f, 0.06118317f, -0.39178479f, -0.14979823f, 0.00686075f, -0.32494059f, 
    -0.03625465f, -0.12061162f, -0.16855799f, -0.22090869f, 0.02672995f, -0.01992789f, -0.01721308f, 0.07411106f, 
    0.04701449f, 0.19460578f, -0.15785499f, 0.00039254f, 0.02565356f, -0.03860709f, 0.01781190f, -0.05846530f, 
    -0.04740565f, -0.07071504f, -0.09910701f, 0.02121846f, 0.01607149f, -0.04107041f, -0.06149470f, 0.03703340f, 
    -0.01071815f, 0.02475076f, 0.04998087f, 0.01401263f, -0.03338300f, -0.05360105f, -0.09021483f, 0.06418881f, 
    -0.14713582f, 0.11421507f, 0.12378013f, 0.09784319f, -0.03330140f, -0.01231505f, 0.01443385f, -0.11446695f, 
    0.07809253f, 0.03474610f, -0.21081348f, 0.02494110f, -0.15887736f, -0.04800199f, 0.19768444f, 0.15434334f, 
    -0.00090336f, -0.02073728f, 0.03774608f, -0.00240869f, 0.00312582f, -0.02958187f, 0.08801432f, -0.11630844f, 
    -0.06524681f, -0.13404861f, 0.42090183f, 0.03458104f, -0.07863528f, -0.01055782f, 0.05948541f, 0.19909972f, 
    0.04995360f, 0.07003269f, 0.07906569f, -0.10307968f, -0.34690329f, -0.28944460f, -0.42377371f, -0.18608499f, 
    -0.07899746f, 0.07927577f, -0.01938589f, 0.11947860f, 0.04272290f, 0.01707355f, 0.01674986f, -0.05122337f, 
    -0.07138327f, -0.19913521f, 0.11973665f, -0.00339370f, 0.03544700f, -0.11708415f, 0.03199298f, -0.14832692f, 
    0.06938294f, 0.05282583f, -0.13488892f, 0.17584439f, -0.03366373f, -0.20998983f, 0.10661834f, 0.06750970f, 
    -0.01370148f, 0.00681717f, -0.03576703f, -0.05166896f, -0.06770124f, 0.13724922f, 0.05564278f, 0.06551620f, 
    -0.27023214f, -0.01183865f, 0.07185365f, 0.07050423f, -0.01890496f, 0.03924748f, 0.07612505f, 0.01622578f, 
    0.01835120f, 0.00191146f, 0.00957596f, -0.01557807f, 0.09637933f, -0.12548517f, 0.05516676f, -0.01632675f, 
    -0.00358153f, 0.00476227f, 0.03070140f, 0.05185325f, 0.03541454f, -0.10280811f, 0.06630202f, -0.13978328f, 
    -0.13537185f, -0.11824009f, 0.17644404f, -0.25981757f, 0.02201878f, 0.00567467f, -0.06939986f, 0.12132002f, 
    0.02775904f, -0.11135302f, 0.07004928f, -0.02493185f, 0.05679790f, -0.03106717f, 0.06376517f, -0.01944594f, 
    -0.01344372f, -0.19879432f, -0.07396979f, -0.23521549f, 0.07609078f, 0.07406352f, -0.06075518f, 0.01644510f, 
    -0.15429899f, -0.16930000f, 0.16633999f, 0.14560434f, 0.02797850f, -0.10251582f, 0.00792027f, 0.09684151f, 
    0.10802567f, -0.00240838f, -0.06431078f, 0.12028501f, -0.18628022f, -0.11308303f, 0.20793760f, 0.02959662f, 
    -0.01428062f, -0.03629251f, -0.06958701f, 0.06900863f, 0.17112204f, -0.11081961f, 0.25822359f, -0.04441569f, 
    -0.01338545f, 0.11327901f, -0.14791784f, 0.12556136f, -0.01761019f, 0.04095132f, -0.08694610f, 0.05200220f, 
    0.05613151f, 0.08508467f, 0.08609338f, 0.14140382f, -0.08872927f, -0.05076310f, -0.02677215f, 0.04685875f, 
    0.03141413f, -0.06759499f, 0.08157659f, -0.02255928f, -0.08855319f, 0.03378492f, -0.02072713f, -0.03261134f, 
    0.09103590f, -0.00360229f, 0.07734388f, -0.01471769f, -0.03769795f, -0.08597489f, 0.11915539f, -0.10418110f, 
    0.12217547f, -0.03329223f, -0.05303007f, 0.22060385f, 0.00980163f, -0.02271418f, -0.02213189f, -0.40550628f, 
    -0.02170250f, 0.01206107f, -0.01386311f, -0.06148368f, -0.00098364f, 0.00191697f, 0.04738598f, -0.04807422f, 
    0.16743068f, 0.67921132f, -0.06031412f, 0.26551872f, -0.07059208f, -0.00805117f, 0.09803465f, -0.03740705f, 
    -0.06264357f, -0.03956318f, 0.01365417f, 0.05209031f, 0.02719955f, -0.08315485f, -0.02908160f, 0.04035122f, 
    0.18977743f, -0.17109919f, -0.05103654f, 0.06415109f, 0.01075863f, -0.11234784f, -0.09791675f, 0.09930887f, 
    -0.08191862f, -0.05962216f, -0.03900617f, 0.03098263f, 0.01659847f, -0.22773300f, -0.16949807f, 0.03182248f, 
    -0.03109070f, -0.02207585f, 0.01383810f, -0.04584172f, 0.27769169f, 0.10492568f, 0.30799353f, 0.20717554f, 
    -0.05714419f, -0.03744645f, 0.06160642f, 0.03643241f, -0.00801111f, 0.03413236f, 0.14597212f, 0.01575792f, 
    -0.03865792f, 0.20262755f, 0.16266996f, 0.20309705f, -0.02244592f, -0.03576897f, 0.05641524f, 0.14727654f, 
    0.04485848f, 0.09111566f, 0.06770387f, -0.01990641f, 0.13979188f, -0.02427347f, -0.20058013f, 0.09588311f, 
    0.03434598f, 0.07189641f, -0.06646309f, 0.11373220f, -0.00822955f, 0.01130314f, 0.00879098f, -0.02826505f, 
    -0.01886749f, 0.27061924f, 0.06832137f, 0.12222446f, -0.03285518f, 0.05986559f, 0.04378501f, 0.03650701f, 
    0.06446555f, 0.05562056f, -0.00803069f, 0.06109754f, -0.17047651f, 0.04211728f, -0.03876995f, -0.03875161f, 
    -0.02052365f, -0.00275092f, 0.07835779f, -0.01732570f, -0.01535072f, 0.05577788f, -0.02158830f, 0.03941743f, 
    0.28569448f, -0.07679047f, 0.11636660f, 0.14462656f, 0.01286003f, -0.04446412f, -0.00166144f, 0.01187859f, 
    0.07545924f, 0.07093970f, -0.15866284f, 0.17888997f, 0.03757799f, -0.13283679f, 0.05395386f, 0.13341723f, 
    0.01264694f, 0.03099055f, 0.04512300f, 0.12946782f, 0.02360081f, 0.02361740f, -0.09328087f, -0.07631966f, 
    0.37961736f, -0.07650330f, -0.10964080f, -0.22646844f, 0.01493440f, -0.05615179f, 0.11673202f, 0.06312013f, 
    -0.00025385f, -0.00291068f, -0.08121783f, -0.00563473f, -0.15532140f, 0.08465399f, 0.14059110f, 0.15964156f, 
    -0.06609023f, -0.04884924f, -0.02618275f, 0.02911213f, -0.17020176f, 0.01682006f, 0.06432996f, 0.00170402f, 
    -0.04808780f, 0.09699293f, -0.18025389f, 0.13307571f, -0.02190342f, -0.11053026f, -0.04618530f, -0.06602334f, 
    -0.05914329f, 0.06051344f, -0.05823012f, -0.17411207f, -0.23171510f, 0.38234758f, -0.22057328f, -0.37499219f, 
    -0.00589445f, -0.03078432f, 0.03115896f, -0.18566036f, -0.09109804f, 0.01606575f, -0.17060515f, -0.02551249f, 
    -0.05312276f, -0.14818455f, -0.09440806f, 0.06929982f, 0.12735184f, -0.07960466f, -0.19739023f, -0.04984284f, 
    0.16660868f, -0.08711682f, -0.02324344f, -0.00683040f, -0.12882875f, 0.46080810f, -0.12545557f, -0.08035008f, 
    -0.05673322f, 0.06644166f, 0.01655525f, 0.00027997f, -0.15964769f, 0.00440373f, -0.01813612f, -0.09442628f, 
    0.03521489f, 0.18207479f, -0.14773153f, -0.52887297f, 0.21242911f, 0.16247109f, 0.17440173f, -0.06505553f, 
    -0.07769896f, 0.00599653f, -0.05737059f, 0.02254184f, -0.23624682f, 0.05155650f, -0.16316380f, 0.10309510f, 
    0.02369193f, 0.02524894f, -0.01738922f, 0.02596551f, -0.05753504f, 0.04651095f, -0.07636798f, 0.11749545f, 
    -0.53790998f, -0.17227265f, 0.08918150f, 0.22532633f, 0.00256501f, -0.11758909f, -0.01279648f, 0.01680320f, 
    0.02641984f, -0.07698952f, -0.16691066f, 0.02453141f, 0.27681163f, 0.45756194f, -0.35387227f, -0.44827780f, 
    -0.19237523f, 0.03455248f, -0.00594875f, 0.08476005f, -0.06667522f, -0.15068583f, 0.09303998f, -0.09196897f, 
    -0.00160542f, 0.18554875f, -0.19706270f, 0.01151117f, 0.22829746f, -0.07115255f, -0.02784096f, 0.15034840f, 
    -0.15480803f, -0.11141426f, 0.01832523f, -0.15033472f, -0.19698250f, -0.04358301f, -0.10598316f, 0.11662593f, 
    0.08776806f, -0.02616595f, 0.00315885f, -0.14960679f, -0.03835024f, -0.02872467f, -0.05686875f, 0.07748821f, 
    0.09176710f, -0.13440391f, -0.09415079f, -0.12115350f, 0.13791554f, 0.05449794f, 0.08053917f, -0.01608114f, 
    -0.02513451f, 0.03546812f, -0.15104792f, 0.03050562f, 0.23747443f, 0.07817461f, 0.10158573f, 0.24423605f, 
    -0.03923783f, -0.06854487f, -0.09857528f, -0.09158928f, 0.05922653f, 0.06065203f, -0.09703296f, -0.00135044f, 
    0.14692196f, -0.21066779f, -0.00981036f, 0.22220229f, 0.00349891f, -0.08085518f, -0.06845519f, -0.03519880f, 
    -0.01744696f, 0.07347351f, -0.02753412f, 0.12666404f, -0.59040147f, -0.35942635f, -0.33167171f, -0.41296911f, 
    0.00185590f, 0.11450166f, 0.06114663f, 0.04438100f, -0.02478860f, 0.02507433f, -0.11692050f, -0.15373050f, 
    0.40518981f, -0.08729468f, 0.07557471f, 0.14151739f, 0.12074298f, -0.03958027f, -0.05097543f, -0.13916880f, 
    -0.09917857f, 0.00117483f, -0.03500928f, 0.18300840f, 0.23397705f, 0.34467939f, 0.39247969f, 0.56013155f, 
    0.11134972f, 0.10406889f, -0.09223482f, -0.06209247f, 0.06664639f, 0.01014490f, 0.02688168f, 0.01837701f, 
    -0.00761907f, 0.10393864f, -0.04887587f, 0.21290724f, -0.01176335f, -0.04142809f, -0.09577589f, -0.04338186f, 
    -0.02814776f, -0.00779852f, -0.05044363f, 0.11808132f, 0.44254723f, 0.03079112f, 0.03701342f, -0.23129694f, 
    -0.14363280f, -0.03652998f, 0.00369360f, 0.01982070f, 0.07284629f, -0.04049029f, 0.09263960f, -0.09848166f, 
    0.23358342f, -0.13530405f, -0.07422718f, 0.04274788f, -0.03686437f, -0.00620146f, 0.17560965f, 0.00810161f, 
    0.00931094f, -0.02395980f, 0.12678595f, 0.12658606f, 0.25018033f, 0.00389822f, -0.07220603f, -0.14768524f, 
    0.15264310f, -0.17073651f, -0.04758051f, 0.01169319f, -0.23153359f, 0.04758041f, -0.09818588f, -0.00893947f, 
    -0.36986503f, -0.21083950f, -0.06758724f, -0.20396468f, 0.10463459f, -0.15366785f, -0.06548634f, 0.03187370f, 
    0.00163418f, -0.14924185f, 0.06426378f, 0.00943773f, 0.45768949f, -0.14996785f, 0.13161764f, -0.23469995f, 
    -0.07982291f, 0.04419180f, -0.06080685f, -0.07441115f, -0.01857235f, -0.00266793f, 0.08060713f, 0.01783746f, 
    0.14047426f, -0.19656526f, 0.10731734f, 0.19083554f, -0.05259779f, 0.04996238f, -0.03972595f, 0.04897964f, 
    0.05513129f, 0.04992226f, 0.05565558f, 0.00280033f, -0.03335725f, 0.12579456f, -0.08011385f, 0.06304740f, 
    0.02202936f, -0.05388437f, -0.04997557f, -0.14736187f, -0.04048019f, 0.04342365f, -0.06976544f, 0.18911621f, 
    -0.05085431f, 0.00261260f, -0.16283992f, 0.10941770f, 0.04107557f, -0.01905169f, 0.08971053f, -0.05585276f, 
    -0.08514594f, 0.08742911f, 0.03883079f, -0.00718817f, -0.25282136f, -0.15250297f, -0.04965391f, 0.20842449f, 
    -0.03143409f, 0.06036241f, 0.10023548f, 0.03420673f, 0.00126114f, 0.00810241f, 0.11715911f, -0.04446346f, 
    0.16399339f, -0.13202029f, 0.05536595f, -0.06364550f, -0.16357860f, -0.12703094f, -0.04219945f, 0.06317377f, 
    -0.04661396f, -0.04632521f, 0.05045683f, 0.01496486f, 0.33994025f, -0.05419968f, -0.13166341f, 0.03903488f, 
    0.02069116f, -0.06035758f, 0.06367274f, -0.02761718f, 0.08568321f, -0.09829017f, 0.08162914f, -0.13211040f, 
    0.29860631f, 0.43852443f, -0.03118841f, -0.36110142f, -0.03041610f, -0.10403118f, -0.08072439f, 0.04283758f, 
    -0.04693919f, -0.05917517f, -0.12737538f, 0.09589075f, -0.19298080f, 0.11387481f, -0.09388687f, 0.17203854f, 
    0.03948615f, 0.05688634f, -0.05929937f, 0.04987311f, -0.15833838f, 0.01341469f, -0.06027126f, -0.00986879f, 
    -0.42075083f, 0.13813497f, -0.03476100f, 0.00370070f, -0.17748919f, 0.12446189f, -0.29525977f, 0.04811538f, 
    -0.16395639f, -0.01768758f, 0.19782586f, -0.25024986f, -0.03965394f, -0.09848933f, 0.01671665f, 0.24841443f, 
    0.06093808f, -0.00109138f, 0.04035813f, -0.05197585f, 0.01792589f, 0.00041123f, 0.09540010f, 0.06525926f, 
    -0.05740950f, -0.10384404f, 0.34342739f, 0.13609575f, 0.09092797f, 0.17567839f, 0.01739686f, 0.10987657f, 
    0.07973077f, 0.01357727f, 0.09232990f, 0.01288039f, -0.23306690f, -0.15638557f, 0.25709626f, 0.30776232f, 
    0.04273612f, -0.07391360f, 0.20816736f, 0.02020379f, 0.04906921f, 0.13759156f, -0.07965833f, 0.05130148f, 
    0.77569175f, -0.00360714f, -0.10158271f, 0.12927513f, -0.01347789f, 0.01504233f, -0.16982687f, -0.08565023f, 
    -0.00310041f, 0.02260654f, 0.11153705f, -0.10849310f, -0.10174638f, -0.03042941f, -0.14076014f, -0.50176960f, 
    -0.07928475f, 0.02548554f, -0.00659652f, -0.05428373f, 0.11181220f, -0.01901338f, -0.08860286f, -0.07119562f, 
    0.02303401f, 0.20860848f, -0.15713879f, -0.13640833f, 0.10882584f, 0.03428055f, 0.31552145f, -0.00746149f, 
    -0.06031014f, 0.01444502f, -0.07146423f, 0.03201435f, -0.08550073f, 0.56053197f, -0.11703627f, -0.04146620f, 
    0.19564578f, 0.03572537f, 0.11786915f, -0.05401366f, -0.42209065f, -0.08693863f, -0.23019296f, -0.05182193f, 
    -0.54825312f, 0.67721808f, -0.39693511f, -0.26326242f, 0.24146193f, 0.13677359f, -0.04371994f, -0.04671881f, 
    -0.22904341f, -0.03868017f, 0.05183404f, -0.06370125f, -0.01731870f, -0.17716147f, 0.04446219f, 0.12474318f, 
    -0.00936031f, 0.08433127f, 0.06414057f, 0.04804425f, 0.11875273f, -0.03518622f, -0.17790902f, 0.00593891f, 
    -0.13064167f, -0.03257512f, -0.07159103f, -0.25500450f, -0.05431575f, -0.06906981f, 0.07889234f, -0.12390453f, 
    0.05106525f, 0.03413368f, -0.08039600f, 0.05227209f, 0.03807608f, -0.01493809f, -0.05952536f, 0.04337408f, 
    0.05263278f, 0.02304936f, -0.01123331f, 0.03572924f, -0.05688900f, -0.01239595f, -0.01972809f, -0.00209929f, 
    0.24014294f, -0.24479951f, 0.07927343f, -0.21894497f, -0.35475618f, -0.19658253f, -0.12439056f, 0.05534639f, 
    -0.02187752f, 0.01448658f, 0.01762489f, -0.09580120f, 0.01494344f, 0.23793861f, -0.39135700f, 0.13332105f, 
    -0.02750713f, -0.19981490f, -0.04923842f, -0.01199994f, 0.02696078f, -0.03190342f, -0.01664824f, 0.02358464f, 
    -0.11509357f, -0.05166006f, 0.31520030f, -0.19697849f, -0.18341416f, 0.05331225f, -0.06661191f, 0.01320673f, 
    0.04177127f, 0.09244999f, 0.10164312f, 0.13744701f, -0.02085788f, 0.12520248f, 0.11653544f, -0.14178905f, 
    -0.01309312f, 0.06251469f, -0.02449748f, 0.05918254f, 0.05532333f, -0.29644138f, -0.17403921f, 0.05800993f, 
    -0.08711646f, 0.43918180f, -0.25982502f, -0.47225788f, 0.11013020f, 0.10590623f, -0.02600987f, -0.01380933f, 
    -0.11543775f, 0.14415292f, -0.07156209f, 0.03667357f, -0.03114816f, -0.07018324f, -0.04682401f, 0.01396348f, 
    0.00520243f, 0.01503488f, -0.06837741f, -0.12540630f, -0.08668232f, -0.04639600f, 0.06912851f, -0.10209215f, 
    -0.33176044f, -0.13084942f, -0.15253198f, -0.11997315f, -0.17461684f, -0.04865728f, -0.03465918f, -0.01964863f, 
    -0.19870080f, 0.03876291f, -0.02173713f, -0.06411129f, -0.09756510f, -0.19930246f, 0.01523708f, 0.20056739f, 
    -0.09207674f, -0.13084975f, 0.19801979f, -0.04934143f, -0.11113637f, 0.07777876f, -0.06981595f, -0.02250301f, 
    0.28400040f, -0.09521189f, 0.00955818f, 0.18411574f, 0.11489598f, -0.04941640f, -0.04525258f, -0.07231374f, 
    -0.13215318f, -0.02310101f, -0.02049636f, 0.08673721f, 0.03177796f, -0.01114201f, 0.11706231f, 0.04787974f, 
    -0.12647954f, 0.08779750f, -0.01019707f, 0.07439639f, -0.03835195f, -0.06977247f, -0.01074161f, 0.11500047f, 
    0.37227681f, -0.03278661f, 0.00233293f, 0.15665229f, -0.03680512f, -0.10103252f, 0.04200815f, -0.16976835f, 
    0.05559211f, 0.01534459f, 0.01682051f, 0.13834096f, -0.04403765f, 0.14056869f, 0.25228578f, 0.17066574f, 
    -0.09110861f, 0.03964800f, -0.28231597f, -0.05387350f, -0.02645949f, -0.09563085f, 0.18427688f, 0.00391205f, 
    -0.02821073f, -0.18764666f, -0.32939938f, 0.31653342f, 0.10569834f, 0.02783247f, 0.04293185f, -0.01578660f, 
    0.08551866f, -0.12803036f, -0.09671186f, 0.12551101f, -0.15000981f, -0.00677661f, 0.02241030f, 0.08735113f, 
    0.07378954f, 0.01281089f, -0.02656578f, -0.02933596f, -0.05426950f, -0.00289766f, -0.02795317f, -0.07580661f, 
    -0.16126227f, -0.24417636f, -0.00877594f, -0.02797516f, 0.09595238f, 0.09469861f, -0.00676643f, -0.06479012f, 
    -0.08717802f, -0.07731891f, -0.05947891f, 0.02718292f, 0.13189739f, 0.06192651f, -0.32019073f, -0.47711292f, 
    -0.03385059f, -0.03754967f, -0.13270403f, -0.04602853f, 0.02391445f, -0.09401171f, 0.07980774f, -0.11040166f, 
    0.17695607f, -0.04034422f, -0.01095791f, 0.20358753f, 0.05617057f, 0.08555961f, 0.01275593f, -0.09218384f, 
    -0.09884756f, -0.04937426f, 0.11753926f, 0.05448480f, -0.41791120f, 0.17418243f, -0.03322259f, 0.18459277f, 
    0.04225910f, 0.07512981f, -0.05481211f, -0.02205614f, -0.13948207f, -0.08937337f, -0.15325427f, -0.12284910f, 
    0.00215517f, 0.11706677f, -0.14355749f, 0.07335320f, -0.01837528f, -0.01093937f, -0.04370581f, -0.10739306f, 
    -0.01785230f, -0.07723949f, -0.07431561f, -0.00753909f, 0.10040306f, 0.08572208f, 0.13010189f, 0.16821317f, 
    0.05069865f, -0.02876756f, 0.07708587f, 0.09374733f, 0.05180526f, -0.02645951f, 0.01674552f, 0.04470296f, 
    -0.23016362f, 0.17974143f, 0.13571139f, 0.20256546f, 0.02647431f, 0.02627660f, -0.07445575f, -0.14687845f, 
    0.00023849f, 0.00524109f, -0.07684304f, -0.05431285f, 0.00585824f, -0.07874312f, -0.03591415f, -0.04959797f, 
    0.01240701f, -0.02309467f, -0.00155446f, -0.10866418f, 0.14574033f, -0.06277582f, 0.04689905f, 0.09155013f, 
    0.07734676f, -0.01572439f, 0.02305390f, 0.06752384f, 0.02196417f, 0.05834342f, -0.07132071f, 0.12035704f, 
    -0.01343339f, -0.08642543f, -0.04056863f, -0.06674340f, -0.15040345f, 0.01621759f, -0.29459640f, 0.32456276f, 
    0.02090785f, -0.05546953f, -0.05503927f, -0.08289647f, -0.19002348f, 0.02706363f, 0.08641443f, 0.02186429f, 
    -0.00310930f, -0.07505695f, 0.04818638f, 0.07839685f, -0.19490625f, -0.05580056f, -0.00698165f, -0.09620117f, 
    0.07433608f, 0.04757995f, 0.05828919f, 0.06792449f, -0.01194716f, -0.47320479f, 0.05507125f, -0.07127499f, 
    0.03763610f, 0.04637958f, 0.02730025f, 0.04899263f, -0.15038115f, 0.06200156f, -0.02775648f, 0.02542979f, 
    0.13802901f, 0.02644253f, -0.01305078f, -0.10103646f, -0.00004883f, 0.03862267f, -0.01585295f, 0.05112875f, 
    -0.11038979f, -0.16237251f, -0.33525074f, -0.14533524f, 0.19438763f, 0.16893619f, 0.11675928f, -0.08400059f, 
    0.13726731f, -0.10634879f, -0.01501544f, -0.01869409f, -0.04971126f, 0.03665141f, -0.06152736f, -0.08634546f, 
    -0.10162913f, 0.15263407f, -0.16922572f, 0.00778304f, 0.09508927f, 0.02370779f, -0.19163822f, -0.10020221f, 
    -0.18950072f, 0.12025885f, 0.04966744f, -0.12622470f, -0.09731010f, -0.45988804f, 0.17878455f, -0.00949291f, 
    0.00510434f, -0.02162475f, -0.08483674f, -0.07814763f, 0.05992701f, -0.00300930f, -0.14100003f, 0.10757865f, 
    0.28470960f, -0.07204285f, -0.03010082f, -0.01399721f, 0.01777930f, -0.01270507f, 0.02245601f, -0.12794462f, 
    -0.06105931f, -0.19045188f, -0.02355062f, -0.14981513f, 0.01784572f, 0.01125816f, 0.14577813f, 0.14599006f, 
    -0.05962955f, -0.14614703f, -0.11156593f, 0.02972582f, -0.04266766f, 0.02491925f, -0.01138304f, 0.03122368f, 
    0.23154062f, 0.06966169f, -0.00289829f, 0.07967022f, -0.06572422f, -0.01507290f, -0.08004242f, 0.03516384f, 
    0.08974442f, -0.01536339f, -0.05380335f, -0.00717541f, -0.09914169f, 0.13339838f, -0.01728175f, 0.10926461f, 
    0.00075927f, -0.04403376f, 0.04238706f, -0.04971652f, -0.14545344f, -0.10086416f, 0.05085737f, -0.15161315f, 
    -0.20788912f, -0.14743696f, 0.00964025f, 0.08943672f, -0.07808167f, -0.08678566f, 0.02421774f, -0.06732858f, 
    0.05325261f, 0.00680738f, 0.06465495f, 0.08033479f, 0.08694931f, 0.00643815f, 0.00796033f, -0.04829105f, 
    0.07155656f, 0.03005021f, 0.02933574f, 0.04481925f, 0.01364015f, -0.01477725f, -0.09315471f, -0.03658660f, 
    -0.08481351f, -0.12390196f, -0.03053882f, 0.13822013f, 0.09009889f, -0.02843171f, -0.06539330f, -0.03087385f, 
    0.04397311f, 0.09844100f, 0.02591066f, -0.03207588f, -0.05046234f, 0.02274290f, -0.31471297f, -0.21144804f, 
    0.03133485f, 0.01617645f, 0.04680760f, -0.05119647f, 0.09215184f, 0.06074396f, 0.06947579f, 0.05267801f, 
    0.00787778f, 0.04099844f, 0.17295235f, 0.04897188f, -0.09496026f, -0.10455925f, -0.05519234f, -0.12372505f, 
    -0.11406640f, -0.03718042f, -0.00042637f, 0.04454496f, 0.08637819f, -0.11430778f, -0.08073807f, -0.09822035f, 
    0.03609608f, -0.07151911f, 0.04325988f, -0.01941860f, 0.20081604f, 0.07029418f, 0.22908446f, 0.37577507f, 
    -0.04034152f, 0.00216953f, -0.09681944f, 0.09643246f, 0.04596356f, -0.04663691f, -0.20083359f, -0.04300843f, 
    0.04936900f, 0.05720729f, -0.07130025f, 0.14384735f, -0.02040104f, 0.05037964f, -0.00434216f, 0.11918803f, 
    -0.24843445f, 0.02775466f, -0.09162269f, -0.14837959f, -0.09115226f, -0.10785796f, 0.07270820f, -0.05243038f, 
    0.05180893f, -0.02852206f, -0.00634323f, 0.13932058f, 0.04650972f, 0.19536901f, 0.00388632f, 0.04754972f, 
    0.05269823f, 0.01742642f, 0.03852928f, 0.05470919f, 0.19789338f, -0.29478058f, -0.75444585f, 0.16487427f, 
    0.11343493f, -0.12585153f, 0.00868235f, -0.09084537f, -0.04200275f, -0.01288149f, -0.06003140f, 0.06164250f, 
    -0.04505386f, 0.22844051f, 0.24355757f, 0.08045637f, 0.05800603f, 0.07057802f, -0.12158948f, 0.10521920f, 
    -0.03110245f, -0.11950277f, -0.05747798f, -0.06846416f, -0.05231278f, -0.13954145f, -0.14252728f, 0.13806215f, 
    -0.24256472f, 0.08686217f, -0.11056086f, -0.00724213f, -0.11695075f, -0.01577434f, -0.05896427f, -0.01819887f, 
    0.03354356f, -0.00543298f, 0.28952217f, 0.07379447f, -0.03207511f, -0.16785908f, -0.24670821f, -0.04173095f, 
    0.15021044f, -0.05906487f, 0.15601851f, 0.00527496f, 0.07972439f, 0.16210081f, 0.17180470f, 0.14397740f, 
    -0.07738581f, 0.01876736f, 0.08824156f, 0.03336435f, 0.06188183f, 0.07998274f, 0.06456707f, 0.03285883f, 
    0.03120751f, -0.00832380f, -0.07688264f, 0.11031438f, 0.01670057f, -0.09773340f, 0.06060584f, -0.15252358f, 
    -0.04133485f, -0.01196819f, 0.11156625f, 0.19512817f, -0.00471570f, 0.25172558f, 0.28694370f, 0.26455557f, 
    0.01665255f, 0.03076130f, -0.01557358f, 0.07998762f, -0.09022946f, -0.09257758f, -0.05881564f, -0.03100351f, 
    0.08933727f, -0.32381272f, -0.03119127f, 0.01978030f, 0.06369677f, -0.03960546f, -0.14319098f, 0.00639991f, 
    -0.02176736f, -0.06892546f, -0.01508506f, -0.21698815f, 0.05151516f, -0.13138904f, 0.05720570f, -0.04082339f, 
    -0.03273273f, 0.01972915f, 0.11813325f, -0.04383522f, -0.06478645f, -0.06250010f, -0.07873927f, -0.00177106f, 
    -0.03505334f, -0.05591458f, -0.10325848f, -0.03786096f, 0.14786534f, -0.06597222f, 0.16175526f, -0.22327848f, 
    0.11239424f, 0.08547479f, -0.06755710f, -0.12208524f, -0.12534821f, 0.14150111f, 0.06291036f, 0.13255966f, 
    -0.05077411f, -0.03313115f, 0.03403053f, -0.13539369f, -0.08692188f, 0.10907304f, -0.06258877f, 0.16901553f, 
    0.07427813f, 0.32831773f, -0.14701234f, 0.33038232f, 0.08183215f, -0.07325959f, -0.15775055f, -0.04939495f, 
    0.00424125f, 0.11880717f, -0.08408926f, 0.03516092f, 0.16996844f, 0.40221319f, 0.04494293f, 0.09202240f, 
    0.14590481f, 0.12453195f, -0.12267260f, 0.02410658f, 0.06751425f, -0.03965693f, 0.04677188f, -0.06338341f, 
    -0.04087404f, -0.01461240f, -0.06888262f, -0.04870294f, -0.08381711f, 0.04153812f, -0.08778992f, 0.14038065f, 
    0.04008512f, -0.17575869f, -0.08115188f, -0.16375749f, -0.01724516f, -0.12914407f, -0.02524441f, -0.16187659f, 
    0.04554172f, 0.03390894f, 0.01633569f, -0.00588426f, -0.03924368f, -0.13638203f, -0.14306377f, 0.12603670f, 
    -0.14498414f, 0.01101622f, -0.05406885f, 0.01711883f, 0.04477969f, 0.01997696f, -0.16038623f, -0.06860650f, 
    0.02132614f, -0.03610435f, 0.01951331f, 0.15033025f, -0.12237044f, -0.30237535f, 0.07127818f, -0.05968974f, 
    -0.03607199f, 0.05801364f, -0.04545131f, 0.07896771f, -0.00402685f, 0.05706189f, 0.07125145f, -0.24754724f, 
    0.13513966f, -0.49285373f, 0.16800827f, 0.01705038f, -0.19671698f, -0.05179058f, -0.00864834f, -0.20563690f, 
    -0.10623274f, 0.03143764f, -0.04447451f, -0.16887680f, 0.07282352f, 0.11373843f, 0.28948489f, 0.13616677f, 
    0.02717648f, -0.08877897f, -0.07660916f, -0.04481979f, 0.04337968f, -0.04880032f, 0.02030521f, -0.04477726f, 
    -0.02435073f, 0.14562342f, -0.39399189f, 0.09940780f, 0.13981399f, -0.07738417f, 0.02411551f, -0.24381813f, 
    -0.11025545f, -0.27106610f, -0.03144155f, -0.09681877f, 0.15311684f, 0.17486046f, 0.05009983f, 0.21654776f, 
    -0.08382054f, -0.07387245f, -0.04682162f, 0.02055569f, 0.03748309f, 0.12402498f, 0.04947468f, 0.13060558f, 
    -0.19620785f, -0.11423184f, -0.19126762f, 0.16171573f, -0.14582302f, 0.02070477f, -0.03443037f, -0.02571367f, 
    0.02122637f, -0.04167046f, 0.05260406f, 0.02603036f, -0.16245601f, -0.22997391f, 0.14820753f, -0.01164292f, 
    0.15365975f, 0.14399089f, -0.29350621f, -0.17340510f, -0.04646148f, -0.05462722f, -0.10248528f, -0.14146948f, 
    0.18294616f, 0.03173185f, -0.04484112f, 0.35428548f, -0.01506987f, -0.05198131f, 0.13537325f, -0.01092866f, 
    0.09580234f, -0.04458752f, -0.02200848f, -0.05294659f, -0.09216564f, 0.09649450f, -0.03134098f, 0.15427186f, 
    0.16912322f, 0.03976248f, -0.15937333f, -0.10358801f, 0.06701176f, 0.00805671f, 0.11496165f, -0.05037154f, 
    -0.25872803f, -0.39316964f, 0.04858498f, 0.00305238f, -0.10439608f, 0.09840440f, 0.00057357f, 0.04578737f, 
    -0.07843520f, -0.01610343f, -0.00848897f, 0.05125536f, -0.09454425f, 0.02010430f, 0.02450915f, 0.02075137f, 
    -0.02455678f, -0.08405836f, 0.02294664f, -0.07861674f, 0.12255831f, 0.01308831f, 0.00239059f, 0.19562340f, 
    0.21630712f, -0.22141527f, 0.00723392f, -0.03275186f, -0.07147581f, 0.01210004f, -0.12038709f, -0.09372769f, 
    -0.11857233f, -0.04762592f, -0.13151561f, -0.21224670f, 0.04246259f, 0.16976851f, 0.00969340f, 0.10080960f, 
    -0.10350501f, 0.09804970f, 0.00763104f, 0.05543034f, -0.02844068f, 0.00178118f, 0.00602082f, 0.02323222f, 
    0.01223733f, 0.04880098f, -0.15511233f, -0.06004851f, 0.05303517f, -0.17722447f, 0.17203830f, -0.04673165f, 
    -0.00117580f, -0.08740342f, 0.08525272f, -0.00956164f, 0.20220561f, 0.15921298f, 0.05841452f, 0.39994612f, 
    0.23713739f, -0.00205990f, 0.13272773f, 0.02810386f, 0.03678562f, -0.03521211f, -0.00881170f, -0.00992525f, 
    -0.18761724f, -0.00949969f, 0.03377803f, 0.10570304f, -0.00296074f, -0.06561276f, -0.10107029f, -0.08281697f, 
    -0.06161823f, -0.04003029f, 0.03752239f, 0.02132030f, 0.13727145f, 0.02245110f, -0.07582530f, 0.09611683f, 
    0.07425313f, -0.05881880f, 0.01195517f, 0.01795589f, 0.04743106f, -0.04381022f, -0.09561144f, -0.05508981f, 
    0.02741666f, -0.01662210f, 0.14146426f, 0.08823991f, 0.07907392f, -0.01710062f, -0.00292886f, -0.05023833f, 
    0.03411445f, 0.03496858f, -0.04572320f, -0.02134316f, 0.14436181f, 0.06715602f, 0.06264423f, 0.14997225f, 
    -0.19231120f, -0.10101143f, -0.03417724f, -0.02245011f, -0.09495892f, -0.13645071f, -0.04543443f, 0.02097174f, 
    -0.00382354f, 0.04783329f, 0.00214285f, 0.08601048f, -0.13056979f, -0.03177461f, 0.09041236f, -0.02607302f, 
    -0.01549949f, 0.05320603f, -0.19030872f, 0.12781964f, -0.04492219f, -0.35896471f, -0.02486678f, 0.21360086f, 
    -0.22616315f, -0.05317703f, 0.05281720f, -0.06684765f, -0.17411496f, -0.01456940f, -0.06138795f, 0.14485732f, 
    -0.05633174f, 0.06115168f, 0.06746707f, 0.04648651f, -0.05496501f, -0.06459296f, 0.01230519f, 0.09886205f, 
    0.10263357f, 0.06240544f, -0.01467412f, 0.03694364f, 0.06869110f, -0.16944732f, 0.12649304f, -0.18164195f, 
    0.02454732f, 0.00335990f, -0.03949439f, -0.01844518f, 0.14220729f, -0.10627649f, 0.15430154f, 0.18247342f, 
    -0.36294311f, -0.21222202f, -0.15148495f, -0.09859896f, 0.08416670f, -0.00207253f, 0.04355402f, 0.17768295f, 
    0.14513439f, 0.01872724f, 0.28336453f, -0.06182501f, 0.04782370f, 0.15502669f, 0.01682397f, -0.07578773f, 
    0.15334159f, 0.14151125f, 0.13603920f, 0.09099468f, 0.08045702f, 0.09830717f, 0.05072562f, 0.03460490f, 
    0.19860445f, 0.03670095f, 0.03140420f, -0.07090563f, -0.22548506f, -0.05080086f, -0.08464812f, 0.23943581f, 
    -0.00558827f, 0.08538317f, 0.10808134f, 0.04424051f, 0.03168020f, 0.03363555f, -0.11689448f, -0.28243011f, 
    -0.01105757f, 0.05795797f, -0.01688150f, 0.04181727f, 0.10484045f, -0.26913303f, -0.03719772f, -0.09788772f, 
    -0.11045341f, -0.08874314f, -0.00836137f, 0.00448162f, 0.10013209f, 0.02187034f, -0.05480858f, -0.10620845f, 
    0.14919889f, -0.04021161f, -0.01428556f, 0.08083127f, -0.13807574f, -0.13778894f, 0.34366930f, -0.03784321f, 
    0.04942636f, -0.01220233f, -0.01126384f, 0.12919988f, 0.13360433f, -0.07755876f, 0.08082034f, 0.02002847f, 
    -0.02245535f, 0.06341667f, -0.03969066f, -0.05572512f, 0.15509570f, 0.12172636f, 0.09822468f, 0.02862854f, 
    0.08114100f, -0.00729683f, 0.00629655f, 0.02135472f, -0.02117877f, -0.14438394f, 0.15441887f, 0.08755900f, 
    -0.03259789f, 0.01181177f, -0.01024000f, 0.03120402f, 0.04558737f, -0.16993968f, -0.06034321f, -0.06660940f, 
    -0.23746297f, -0.09875091f, 0.08726569f, 0.19178930f, 0.02347086f, -0.13632946f, -0.02465383f, -0.01479761f, 
    0.11243040f, 0.03810166f, 0.21002494f, -0.11393556f, 0.33607858f, -0.06194035f, 0.31545511f, 0.09401874f, 
    -0.01963370f, 0.01138190f, -0.10115772f, -0.13734382f, -0.08099767f, -0.02113076f, 0.29524836f, 0.01929978f, 
    -0.14305903f, 0.00443600f, -0.19498631f, -0.29394108f, -0.00734623f, -0.09607877f, -0.01962435f, 0.14763044f, 
    0.30563509f, -0.27185845f, -0.10026377f, 0.09333854f, -0.11824737f, -0.03898203f, 0.11431342f, 0.14183332f, 
    0.07099766f, -0.11699662f, 0.02659179f, -0.02464331f, 0.08258992f, 0.02516797f, -0.09427428f, -0.04519415f, 
    -0.14401218f, -0.00211089f, 0.08457696f, -0.11847995f, -0.12433515f, 0.07938987f, -0.07985064f, -0.02657518f, 
    0.21343090f, -0.13295662f, 0.06408159f, -0.07013518f, -0.04732282f, 0.11888569f, -0.01515994f, 0.01629228f, 
    0.16544984f, 0.24358457f, 0.09047890f, 0.11391452f, 0.06781475f, 0.07493775f, 0.09334792f, 0.01138870f, 
    -0.37362018f, -0.25682446f, 0.02346524f, 0.00630848f, 0.05072058f, -0.09165180f, -0.03692645f, 0.01784201f, 
    0.07597680f, -0.06505927f, 0.10297126f, -0.11020289f, -0.10153407f, 0.08919878f, -0.18573716f, -0.10531204f, 
    -0.04507505f, -0.15438713f, -0.03723133f, 0.01849548f, 0.10050762f, 0.08277140f, -0.03772858f, 0.09625069f, 
    -0.43513644f, 0.12180054f, -0.02240731f, -0.34464270f, 0.09618302f, -0.12053441f, 0.00528359f, -0.05915856f, 
    0.00169592f, -0.07198577f, -0.07072588f, -0.01268948f, -0.06361049f, -0.09813482f, -0.05006525f, 0.03669471f, 
    -0.01526854f, -0.08105554f, -0.02143424f, -0.01318348f, 0.06331100f, -0.19095816f, 0.01349060f, 0.02626909f, 
    -0.16090344f, 0.35459372f, -0.25514787f, -0.00510373f, -0.15156674f, -0.04999774f, -0.01272995f, 0.00999111f, 
    0.16623904f, -0.08850653f, 0.02377923f, -0.17703775f, -0.13188440f, -0.08377153f, -0.11261460f, -0.31696212f, 
    -0.03301764f, 0.08148219f, 0.06327285f, 0.04378675f, -0.07198245f, -0.02040919f, -0.05705456f, -0.29280812f, 
    -0.00728616f, 0.03720484f, -0.07794054f, -0.18461262f, 0.07082575f, -0.03527431f, -0.00671976f, 0.17384301f, 
    -0.02657386f, 0.17361961f, -0.03958955f, -0.11131880f, -0.27486253f, -0.10386595f, 0.04135529f, 0.06037465f, 
    0.05052545f, 0.02447749f, 0.03537341f, 0.00617019f, -0.00494719f, -0.46893433f, -0.55729973f, -0.34203711f, 
    -0.12246688f, 0.35268056f, 0.10887724f, -0.06309852f, 0.03891360f, -0.11587646f, -0.00373653f, 0.13300149f, 
    0.05430312f, -0.04588043f, -0.06838941f, -0.18322301f, 0.35997301f, 0.04139692f, 0.18425065f, 0.27018020f, 
    0.00461372f, 0.16553865f, 0.05316398f, -0.06900118f, 0.11701746f, -0.05614704f, 0.05764101f, -0.03218988f, 
    -0.15821959f, -0.06833078f, -0.07375625f, 0.07399708f, 0.04547473f, 0.02088684f, -0.10918085f, -0.01298065f, 
    -0.02856356f, -0.03132867f, 0.01194445f, -0.03862761f, -0.85713536f, 0.20582168f, -0.01249025f, -0.11432489f, 
    0.02344799f, -0.06428703f, 0.03150870f, 0.17005131f, 0.03495648f, 0.01331939f, 0.05514190f, -0.17174052f, 
    -0.09227993f, 0.06425113f, -0.05839044f, -0.21492150f, -0.01378363f, -0.02434512f, 0.02105484f, -0.13469464f, 
    0.09732165f, -0.17150764f, 0.02969816f, 0.13508976f, -0.10416738f, -0.09242422f, 0.10595385f, -0.05945862f, 
    0.04769859f, -0.30203193f, -0.01199603f, 0.10976908f, 0.19516413f, 0.05998420f, -0.07101069f, 0.12901478f, 
    0.17303000f, 0.14160213f, 0.08955589f, -0.09176181f, 0.03821569f, 0.17184399f, 0.13547823f, -0.14402989f, 
    0.00151771f, -0.05346184f, 0.02266898f, -0.08357185f, 0.15756364f, 0.02933001f, -0.05587126f, 0.05069140f, 
    0.11632130f, 0.03931370f, -0.19883533f, -0.08055234f, -0.08220439f, -0.05276611f, -0.02523085f, 0.02479531f, 
    0.22224796f, -0.02798039f, -0.08922464f, 0.09038217f, 0.00600528f, 0.12137871f, 0.09530212f, -0.05541503f, 
    0.00825699f, -0.14350934f, 0.15722308f, -0.47668839f, -0.20656355f, 0.26064286f, 0.18495403f, -0.26890299f, 
    -0.13794121f, -0.10852204f, 0.08987821f, 0.05845492f, -0.01506097f, -0.04823457f, -0.05207240f, 0.04465111f, 
    0.09053442f, -0.06370611f, -0.04908242f, 0.26486185f, 0.01818278f, -0.09161534f, 0.07996716f, -0.02938095f, 
    -0.02171070f, 0.06954291f, -0.03957073f, 0.10094038f, 0.25555280f, 0.13474599f, 0.27084571f, -0.00375590f, 
    0.05716541f, 0.13553333f, -0.04527484f, 0.07494775f, 0.06987920f, 0.05044054f, 0.05277604f, 0.06020576f, 
    0.14141996f, 0.05131583f, -0.36896047f, 0.27289489f, 0.04543316f, -0.18502557f, 0.00347689f, 0.07823569f, 
    0.17359607f, 0.02300110f, -0.13981648f, 0.19490142f, -0.13670678f, -0.10356196f, -0.18749385f, -0.34462330f, 
    -0.09827279f, 0.01433740f, -0.05202780f, 0.08990798f, 0.05861216f, -0.05187009f, 0.03908111f, -0.08962175f, 
    0.12237733f, -0.07718143f, -0.23648629f, 0.14252560f, -0.09553768f, 0.10411625f, 0.06629955f, -0.09295887f, 
    -0.06792577f, -0.03761974f, 0.06856002f, -0.05300865f, -0.13335095f, 0.02930278f, -0.10705141f, -0.34819618f, 
    0.06891248f, 0.20205598f, -0.04943550f, -0.12975618f, 0.03959638f, -0.10871177f, 0.07723719f, -0.00187462f, 
    -0.14874770f, -0.02923753f, -0.15269774f, 0.21591054f, 0.03639867f, -0.05030394f, -0.07339243f, -0.11152020f, 
    0.13007124f, 0.01029442f, 0.01329932f, 0.14140572f, -0.14899831f, -0.13608658f, 0.03352848f, 0.10426586f, 
    -0.05458656f, -0.04935430f, 0.01238227f, 0.02830133f, 0.03719926f, 0.03339839f, 0.04371498f, 0.03390681f, 
    0.03427345f, -0.14803618f, -0.21259788f, -0.18063937f, 0.04097292f, -0.03650878f, 0.13277929f, 0.09045556f, 
    -0.04914304f, -0.07694406f, 0.18737581f, 0.03675860f, -0.22059324f, -0.06859785f, -0.24394992f, -0.28875887f, 
    -0.05157465f, 0.01293735f, -0.10470223f, -0.02850608f, 0.03037176f, -0.18722883f, 0.05868836f, 0.18727045f, 
    -0.20578420f, 0.28638282f, -0.27004451f, -0.21187340f, 0.06865084f, -0.02097454f, 0.03773758f, -0.02087866f, 
    0.17980437f, 0.04246983f, -0.17329039f, -0.02627367f, 0.04654921f, 0.16052344f, 0.13814466f, -0.15256613f, 
    0.18547037f, -0.01244315f, 0.14659831f, 0.10642579f, -0.00795992f, 0.00804659f, 0.06745997f, 0.03120247f, 
    -0.12029254f, 0.26073369f, -0.11789963f, -0.21220048f, -0.08024102f, 0.05578704f, -0.15315583f, 0.02445911f, 
    0.23521395f, 0.05402850f, 0.30278444f, 0.12986386f, -0.04608348f, 0.00728283f, 0.20489785f, -0.04739195f, 
    0.04114482f, -0.03042899f, 0.00469232f, 0.03744761f, 0.10714329f, -0.05532880f, -0.22107686f, -0.14491066f, 
    -0.15045767f, -0.40014899f, 0.12414149f, 0.21990903f, 0.11016829f, 0.01955511f, -0.03096926f, -0.08068200f, 
    -0.00746176f, 0.12676358f, 0.08610564f, -0.00133223f, -0.04243255f, 0.32885411f, 0.12807904f, -0.20727293f, 
    -0.16979761f, -0.09346171f, 0.11348869f, 0.20178026f, -0.02810522f, 0.04776930f, 0.09276567f, 0.10462393f, 
    -0.15272786f, -0.00887405f, -0.26934320f, 0.23596574f, 0.15472087f, -0.09673621f, -0.10168575f, 0.11595303f, 
    0.04009301f, 0.09064872f, -0.07304937f, 0.00666621f, -0.09962083f, 0.01004275f, -0.10509494f, 0.12985411f, 
    -0.21560314f, -0.06207420f, 0.16798536f, 0.01698686f, -0.34516218f, 0.03105879f, -0.00644137f, -0.15806319f, 
    -0.49390578f, -0.20977451f, 0.26612303f, -0.12556772f, 0.01263508f, -0.07342947f, -0.01604654f, 0.07013469f, 
    -0.23586327f, -0.14048398f, -0.26080373f, -0.02874668f, -0.03560130f, 0.06972276f, 0.29657170f, -0.24035674f, 
    -0.01435737f, -0.01276075f, 0.08514074f, -0.00507406f, 0.01924339f, -0.09337329f, -0.27967951f, -0.16526903f, 
    0.19869366f, -0.26497969f, 0.16566522f, 0.11340706f, 0.10486870f, -0.02456625f, 0.08306747f, 0.10397425f, 
    0.13275114f, -0.25548732f, 0.12223291f, 0.12855376f, -0.29171434f, -0.10828987f, -0.06430932f, -0.20175740f, 
    0.05743691f, 0.10113699f, -0.10736296f, 0.01201075f, -0.06516508f, -0.08561876f, 0.10629005f, 0.14545377f, 
    -0.03797237f, 0.28427482f, -0.32937029f, -0.06172110f, -0.02093713f, 0.05859726f, 0.00897400f, 0.18585967f, 
    0.03326176f, -0.18865813f, 0.09133809f, -0.10635348f, -0.17662439f, 0.15220512f, -0.06962025f, -0.03364354f, 
    -0.09292518f, -0.11266948f, 0.13060486f, 0.01301646f, -0.01049855f, 0.03519136f, -0.00595985f, -0.00592264f, 
    -0.01281050f, 0.00650702f, -0.08682842f, -0.06965576f, 0.13061666f, -0.00754055f, -0.01027876f, -0.03093082f, 
    -0.03393262f, -0.02097376f, -0.03936162f, 0.00836482f, -0.11975888f, 0.09562595f, -0.19057059f, -0.28607398f, 
    0.16995040f, 0.01197360f, 0.01799634f, -0.02022821f, 0.10999519f, 0.10836951f, -0.02185133f, 0.07821131f, 
    0.11634675f, -0.09423655f, 0.04246739f, -0.11398011f, 0.02919183f, -0.01778713f, 0.04437968f, -0.00166300f, 
    -0.06267849f, 0.02536212f, -0.13091835f, -0.13063808f, -0.28197077f, -0.25057802f, -0.00778822f, -0.11337939f, 
    0.06200528f, 0.05822520f, -0.07188506f, 0.12587109f, 0.04082805f, 0.08284926f, -0.03813998f, -0.01920095f, 
    -0.20906390f, -0.35418302f, 0.00146290f, -0.08087780f, 0.04237017f, 0.01002759f, -0.08607529f, 0.12434432f, 
    -0.02182404f, 0.02370494f, 0.06888266f, -0.08712330f, -0.35893881f, -0.17393270f, 0.30764225f, 0.24709366f, 
    0.07491399f, -0.09853882f, 0.14505152f, -0.13190429f, 0.09430573f, -0.05235770f, -0.09056778f, 0.02525801f, 
    0.05595991f, -0.25342259f, -0.13963923f, -0.05392073f, 0.13028465f, -0.09068349f, 0.01210895f, 0.23874894f, 
    -0.07551220f, -0.09123594f, 0.03248127f, 0.02094212f, -0.10226444f, 0.06223310f, -0.41038576f, -0.05736427f, 
    0.01549077f, 0.05977300f, 0.03679948f, -0.03819063f, 0.08400407f, 0.13668449f, 0.05818031f, -0.01973196f, 
    0.28590477f, 0.16819498f, 0.11928771f, 0.39627042f, -0.02854422f, 0.00675680f, 0.03992406f, 0.15098085f, 
    0.05076353f, -0.06838959f, 0.10132742f, -0.13300070f, -0.51174080f, -0.65448934f, -0.35443673f, -0.40055203f, 
    -0.10028671f, -0.38920838f, -0.33237904f, -0.34528545f, -0.00969735f, -0.08590941f, 0.00934638f, -0.03337935f, 
    -0.05512645f, -0.31381175f, -0.05547173f, 0.06569255f, -0.14534394f, -0.01626830f, -0.08626996f, -0.12847073f, 
    0.03023722f, 0.01619820f, -0.09463931f, -0.00086868f, 0.28174317f, 0.29405820f, -0.28761438f, -0.20359027f, 
    0.07470791f, 0.02828247f, 0.08007295f, 0.02900346f, 0.03825193f, 0.16640250f, 0.14250144f, -0.02791220f, 
    -0.08706375f, -0.05544904f, -0.01353720f, 0.03054255f, -0.13557135f, -0.04809065f, -0.03173920f, 0.05646784f, 
    -0.00025921f, -0.05119729f, -0.06651475f, -0.07627839f, -0.04271675f, -0.10317740f, 0.19941309f, 0.15406279f, 
    -0.04214157f, 0.01742210f, 0.06879968f, 0.08957624f, 0.20247173f, 0.07054148f, 0.19664493f, 0.11107768f, 
    -0.42591396f, -0.30711317f, -0.16307393f, -0.05901140f, -0.36618987f, -0.28248000f, -0.19576049f, -0.14660634f, 
    -0.00575598f, -0.03452527f, -0.02539615f, -0.05036067f, -0.30220994f, -0.14291404f, 0.00382408f, 0.11166644f, 
    0.06430560f, -0.00972736f, -0.01511034f, 0.00681067f, 0.05768294f, -0.01019115f, -0.05587853f, 0.11053553f, 
    -0.06926979f, -0.00553185f, -0.07790645f, 0.05557013f, -0.02937993f, 0.01736758f, -0.10834360f, 0.04046516f, 
    0.21400709f, 0.07046309f, 0.13166289f, 0.00086495f, -0.34400439f, 0.07966565f, 0.46738523f, 0.03350884f, 
    -0.04262950f, 0.15074737f, -0.07421944f, 0.10117441f, 0.04359995f, 0.13666022f, -0.05560165f, -0.02036675f, 
    0.33997953f, 0.00496123f, -0.02512300f, -0.07912770f, 0.11450209f, -0.05265607f, 0.20014164f, 0.08001835f, 
    0.07785030f, -0.03469162f, 0.13390586f, -0.00368730f, -0.03390911f, -0.10724533f, -0.03518711f, -0.09725849f, 
    -0.07704729f, 0.10839594f, -0.00609862f, -0.05760885f, 0.07538941f, -0.07668488f, 0.20758741f, 0.05520053f, 
    -0.28520539f, -0.09262434f, 0.24937037f, 0.14950311f, -0.01766397f, -0.15795021f, -0.02655490f, 0.01048526f, 
    -0.04768692f, 0.00524460f, -0.06365668f, 0.13010873f, -0.50153828f, -0.35981971f, 0.45075247f, -0.14094673f, 
    -0.09637265f, -0.13405885f, 0.01664824f, -0.16038179f, -0.10527544f, 0.02973106f, 0.00843338f, -0.05322667f, 
    -0.41281646f, 0.38020569f, 0.37233260f, 0.13467328f, -0.07955460f, -0.00347420f, -0.07989109f, 0.03570977f, 
    -0.06861228f, -0.04081020f, 0.10484303f, -0.01957473f, 0.20555750f, -0.08371519f, -0.06386568f, -0.01125702f, 
    -0.02233000f, -0.22974689f, 0.10902930f, 0.00967911f, -0.03509701f, -0.00841793f, 0.03352788f, -0.07569262f, 
    -0.58820933f, -0.64374232f, -0.20856445f, -0.42516527f, 0.02330700f, -0.12853087f, 0.01874186f, -0.09600512f, 
    -0.01368449f, -0.02019795f, 0.00996230f, 0.13285214f, -0.02150855f, -0.06629069f, -0.07851671f, 0.08241760f, 
    0.01906098f, -0.01032081f, -0.00630428f, 0.00777977f, -0.06026886f, -0.24457952f, -0.14895992f, -0.11573977f, 
    -0.16128261f, -0.54456764f, -0.10192328f, -0.12875803f, -0.16676812f, -0.03794197f, -0.18639569f, 0.05196954f, 
    -0.00132827f, -0.09057631f, 0.08864448f, -0.05215673f, -0.08896618f, -0.08040716f, 0.05924506f, -0.04323820f, 
    0.08651450f, 0.02227017f, 0.14533864f, -0.07407590f, 0.04820808f, 0.00771463f, -0.00541770f, -0.06546728f, 
    -0.07033996f, 0.12939240f, 0.06032285f, -0.04793563f, -0.04438962f, -0.01349061f, 0.04196087f, 0.02479208f, 
    0.12466508f, 0.08304868f, -0.03514934f, 0.04283462f, -0.01219753f, -0.04487427f, -0.02666476f, -0.08722208f, 
    -0.01195475f, 0.01024720f, -0.02319472f, 0.05978572f, 0.06049939f, 0.10811022f, 0.10034827f, 0.11374125f, 
    -0.40743539f, -0.58918095f, -0.32449278f, -0.16698340f, -0.24562792f, -0.06934505f, 0.13435449f, -0.03441935f, 
    -0.02047379f, -0.01269715f, 0.08003985f, -0.00643060f, -0.64138103f, -0.29946530f, -0.31680131f, -0.37096995f, 
    -0.28777131f, 0.01696199f, 0.02736825f, 0.06145097f, 0.04410499f, 0.04836520f, -0.01071128f, -0.12549621f, 
    -0.08130093f, -0.12528124f, -0.05630779f, 0.08104468f, -0.00655290f, 0.07486112f, 0.06559873f, 0.00435269f, 
    -0.05382555f, -0.13679491f, -0.02832055f, -0.11740169f, 0.08657905f, -0.09553537f, 0.04574988f, -0.13114230f, 
    0.05856388f, 0.04588845f, -0.05167811f, 0.00506258f, 0.04160199f, 0.11011596f, 0.03607638f, -0.10513828f, 
    -0.39710358f, -0.20996170f, -0.25731412f, 0.06904857f, 0.02833685f, -0.27891454f, 0.03126186f, -0.16477603f, 
    0.00865156f, -0.03547999f, 0.03899230f, 0.01825837f, -0.03537057f, -0.35044876f, -0.37664098f, -0.23561633f, 
    -0.01934950f, -0.04656463f, 0.08648407f, 0.16730668f, 0.01411883f, 0.04829958f, 0.13619620f, 0.03519154f, 
    -0.54419017f, -0.09227853f, 0.04673706f, -0.18200980f, 0.06042059f, 0.07751621f, -0.31524256f, -0.04615622f, 
    -0.11893778f, 0.02338278f, -0.04701339f, -0.07756883f, -0.46879905f, -0.40165189f, -0.42885089f, -0.24779579f, 
    -0.15717210f, 0.01460880f, -0.03775215f, -0.22804956f, 0.01043970f, 0.02785485f, -0.01915690f, -0.00515007f, 
    0.14054944f, 0.13130283f, 0.00868990f, -0.25926191f, -0.14928396f, 0.07165089f, -0.08374075f, 0.12383024f, 
    -0.08164587f, 0.12009016f, 0.10289916f, 0.09878737f, -0.14541061f, -0.32544377f, 0.01251780f, -0.09057861f, 
    -0.13406309f, -0.36967576f, -0.06704500f, 0.09694976f, -0.05984234f, -0.02510982f, 0.06476666f, -0.07332714f, 
    -0.21311396f, -0.08111016f, 0.02893591f, -0.06193921f, -0.00756715f, 0.05831565f, -0.03453137f, 0.02039658f, 
    0.06252387f, -0.04005506f, 0.02181352f, 0.09087722f, -0.16187575f, -0.62655789f, -0.41618657f, 0.27857718f, 
    0.07407142f, 0.20211034f, -0.01258471f, -0.30418757f, 0.01862175f, -0.01495539f, -0.01192022f, 0.10475858f, 
    0.38531855f, -0.02820404f, -0.12773079f, -0.11650568f, -0.03519085f, -0.07792066f, 0.26637143f, 0.14218123f, 
    0.07118875f, 0.01940044f, -0.05476847f, -0.07980093f, -0.51881742f, -0.22448251f, 0.21214126f, 0.32504871f, 
    -0.06925602f, -0.03085800f, -0.06397588f, -0.03905192f, -0.05279465f, 0.11070412f, 0.09900913f, 0.07108779f, 
    0.23910661f, -0.10603809f, -0.14141326f, -0.26224753f, -0.00588600f, 0.04105335f, 0.19500707f, -0.04701902f, 
    0.04101146f, 0.07918029f, -0.03420464f, 0.12538239f, 0.07943327f, -0.16314802f, 0.12677039f, -0.31265977f, 
    0.06542384f, 0.09837795f, 0.15735227f, -0.29230392f, 0.06115214f, 0.01155807f, -0.02011031f, 0.00586158f, 
    0.04200980f, 0.01745688f, -0.06667633f, 0.55789447f, -0.09547899f, -0.05215127f, 0.00143483f, 0.10241435f, 
    0.01712846f, -0.01193487f, 0.04142197f, -0.16531372f, 0.03472270f, -0.09403877f, -0.08268712f, 0.02197311f, 
    0.01969422f, 0.06300536f, -0.00344861f, 0.06657942f, 0.05659812f, -0.10791285f, -0.02925764f, -0.00028510f, 
    -0.02613965f, 0.07846718f, -0.03876284f, 0.14613169f, 0.08731783f, 0.10764387f, -0.08149010f, 0.14730604f, 
    0.11865916f, 0.02462073f, 0.05498670f, -0.15330507f, -0.20261514f, 0.03152605f, 0.15577106f, -0.29779625f, 
    0.05780610f, -0.06885970f, -0.04524022f, 0.05785803f, -0.04754848f, 0.07189152f, 0.01477677f, 0.11914760f, 
    -0.35455361f, -0.10470141f, 0.37217766f, -0.04405632f, 0.07838486f, -0.15965737f, 0.04723573f, -0.15474811f, 
    -0.10873215f, 0.13393219f, -0.03889775f, -0.12559856f, -0.34254867f, -0.38557997f, -0.23014118f, 0.16459861f, 
    -0.08728263f, 0.05791332f, -0.07124165f, -0.33206385f, -0.00342297f, -0.04180934f, -0.01726679f, 0.01484933f, 
    0.23340690f, 0.04958407f, -0.08152305f, 0.18703517f, 0.11790915f, 0.03111707f, -0.07001086f, 0.10531796f, 
    0.02357016f, -0.12116274f, 0.03567066f, -0.20305152f, -0.30711716f, -0.05319015f, -0.07842594f, -0.24004562f, 
    -0.08113464f, -0.00451561f, -0.06490885f, 0.08768801f, 0.11198555f, 0.06507854f, 0.12466450f, 0.00393537f, 
    0.04237594f, -0.14418851f, -0.33662501f, -0.05457999f, -0.05323049f, 0.06255010f, 0.01348118f, 0.11470034f, 
    -0.05635582f, -0.01113248f, -0.02407615f, 0.00903786f, -0.21279097f, -0.58505523f, -0.05488924f, 0.43442664f, 
    0.04661909f, 0.03668006f, -0.12923315f, 0.03964840f, 0.02268770f, 0.07303016f, -0.04748530f, 0.10743600f, 
    -0.08826302f, -0.19380267f, -0.36388385f, -0.42376584f, -0.01498128f, 0.10341778f, 0.20091285f, -0.07077929f, 
    -0.03968407f, 0.02410689f, -0.07159152f, -0.02031545f, 0.36535835f, -0.09147783f, -0.10451368f, -0.08594514f, 
    -0.02369410f, 0.03677914f, 0.11085849f, -0.01612283f, -0.02734526f, -0.08318157f, -0.02558210f, 0.11449302f, 
    0.10827474f, -0.26895949f, -0.00032140f, 0.08025293f, 0.03105845f, 0.07367419f, -0.03647992f, 0.11946931f, 
    -0.00276439f, 0.01504630f, 0.15326674f, 0.10157213f, 0.11523638f, -0.17058188f, 0.11356746f, -0.48202056f, 
    -0.04144767f, -0.02958429f, 0.01322081f, 0.05381809f, -0.00793259f, 0.21604182f, 0.15061924f, 0.14983021f, 
    0.16342907f, 0.04521001f, 0.03760773f, -0.08800657f, 0.02829018f, -0.02141424f, 0.03593739f, 0.14119695f, 
    0.08408938f, 0.12728709f, -0.03684463f, -0.11444341f, -0.03310687f, -0.07162750f, -0.04920434f, -0.03902858f, 
    0.02941723f, 0.05955017f, -0.05354474f, 0.08266024f, -0.07101895f, -0.04801901f, -0.15445198f, 0.05600230f, 
    0.01419738f, -0.04503856f, 0.13286658f, -0.01791454f, -0.01383759f, 0.03228758f, 0.07293564f, -0.05858025f, 
    -0.04709774f, 0.13692242f, 0.14783545f, -0.00587755f, -0.45235899f, -0.44429842f, 0.01178315f, 0.07472973f, 
    0.10950442f, 0.00426412f, 0.07328571f, -0.21894400f, -0.04329868f, -0.03256298f, 0.04275088f, 0.12010094f, 
    -0.27952364f, -0.38784266f, -0.29546472f, 0.25931987f, -0.11777106f, 0.05740500f, -0.07817866f, 0.05453662f, 
    0.03713731f, 0.04972031f, -0.01738314f, -0.12919167f, 0.02806161f, 0.00848272f, 0.05536515f, -0.10927989f, 
    0.04512575f, -0.15271154f, 0.05132173f, -0.10040900f, 0.01911513f, 0.05832047f, -0.03866551f, -0.08387218f, 
    -0.06099771f, -0.35238805f, -0.14228328f, 0.29052746f, 0.10955554f, 0.26262748f, 0.09181651f, -0.20256040f, 
    0.01941070f, -0.03289277f, 0.01436118f, 0.07287298f, -0.36081696f, 0.46883699f, 0.46459195f, 0.24891491f, 
    -0.03716003f, -0.03526247f, -0.05030668f, 0.05663765f, 0.02604339f, 0.08661051f, -0.00857369f, 0.15931319f, 
    -0.27101606f, 0.11256078f, 0.18681015f, 0.20792751f, -0.04476941f, 0.10123108f, -0.01255624f, 0.11020421f, 
    0.02859973f, 0.06809793f, 0.02961414f, 0.08529764f, -0.35888439f, 0.09001784f, -0.03619942f, 0.24726228f, 
    -0.01195828f, 0.00723071f, 0.06853741f, 0.00697425f, 0.02851976f, -0.04955844f, 0.08959477f, 0.01135723f, 
    0.12220082f, 0.27531949f, 0.04340679f, 0.20052801f, -0.06025973f, -0.00787680f, -0.03623073f, 0.19051531f, 
    0.04628071f, -0.07212073f, 0.01567175f, -0.00560173f, -0.10692094f, 0.28777575f, 0.09919994f, -0.04237574f, 
    0.06305375f, -0.00328198f, -0.00842563f, -0.02043897f, 0.10249843f, 0.12564647f, 0.20671356f, 0.18459417f, 
    0.06735764f, -0.12386861f, 0.00304960f, -0.03159524f, -0.02973092f, -0.02584390f, 0.00083705f, -0.13806422f, 
    0.09639951f, 0.00392615f, 0.03579641f, -0.02425118f, -0.36529312f, -0.26085210f, -0.26223433f, 0.38097790f, 
    0.01917100f, 0.09468692f, 0.15555815f, -0.05288851f, 0.00693053f, -0.01500600f, -0.03647413f, 0.00428566f, 
    0.07660268f, -0.15623860f, 0.12402938f, 0.19970872f, -0.04606632f, -0.00362543f, 0.04791353f, -0.05098905f, 
    0.06333049f, 0.01555269f, -0.00737596f, -0.01875425f, -0.35487229f, -0.03078485f, -0.02319771f, 0.09771360f, 
    -0.01007973f, -0.16617243f, 0.05220113f, -0.07628550f, -0.09504478f, 0.09976894f, 0.09754660f, -0.03138891f, 
    0.00100171f, 0.04074698f, 0.03115020f, 0.01787883f, -0.10800803f, -0.12995049f, 0.09203152f, 0.01105556f, 
    0.04113150f, 0.01600809f, -0.01181012f, 0.01733820f, 0.20789106f, -0.04375665f, -0.06019959f, -0.28071007f, 
    0.07241325f, 0.03826274f, 0.02553188f, -0.04061247f, 0.01767135f, 0.06369488f, -0.01541475f, -0.16152464f, 
    -0.16319680f, -0.26260498f, -0.30635661f, -0.29389590f, 0.04026215f, -0.12662689f, -0.16631156f, 0.08624396f, 
    0.07567932f, 0.05041049f, 0.02746674f, -0.01759903f, 0.13919929f, -0.02821618f, -0.06587842f, -0.07604716f, 
    0.03673090f, 0.01776600f, 0.03434364f, -0.00841897f, -0.06890853f, 0.08320019f, 0.04339369f, -0.10153718f, 
    0.21697970f, -0.06876870f, -0.09406321f, -0.24575740f, 0.07148306f, 0.06670240f, 0.03354255f, -0.03553842f, 
    0.01436831f, -0.06482225f, -0.14002112f, -0.22890604f, -0.69994313f, -0.04271458f, 0.16219969f, -0.14423934f, 
    0.07731426f, 0.01267759f, -0.02311166f, -0.00759055f, 0.00983076f, -0.09068098f, -0.03281668f, 0.01735126f, 
    -0.14131673f, 0.12390234f, 0.18245314f, 0.09260298f, -0.08447053f, 0.06049272f, -0.01545534f, 0.04738681f, 
    -0.06960187f, -0.04063250f, -0.14075828f, -0.16420011f, 0.23207431f, 0.14695333f, -0.05259282f, -0.09869111f, 
    -0.08374605f, -0.13819079f, -0.07620170f, -0.06832130f, -0.08578115f, 0.10705924f, -0.20258486f, -0.15638286f, 
    0.06405723f, 0.12515438f, 0.04878718f, -0.14811635f, -0.02522932f, 0.10809522f, 0.08620993f, -0.02247703f, 
    0.00893784f, -0.06228910f, 0.07317100f, -0.00961373f, -0.19149174f, -0.34493300f, 0.05196134f, -0.18722290f, 
    -0.05758888f, -0.02994872f, -0.04673695f, 0.01879951f, 0.01745921f, 0.01066691f, -0.09572540f, 0.01798273f, 
    0.62423617f, -0.34659225f, -0.14858310f, -0.19910854f, 0.04634988f, -0.04755712f, -0.00266041f, -0.04950036f, 
    0.00263902f, 0.05751755f, 0.06339477f, -0.00319400f, 0.03211131f, 0.05655549f, -0.02323662f, 0.12890165f, 
    0.03035744f, 0.04622672f, 0.07069719f, 0.01613384f, -0.02701787f, 0.01429452f, 0.10555339f, 0.05201350f, 
    -0.01308749f, -0.31698039f, -0.22176559f, -0.35686174f, -0.12159506f, 0.03518337f, 0.14824069f, 0.27344659f, 
    0.03717740f, 0.00247504f, 0.01019459f, -0.03981223f, 0.05009079f, -0.01135743f, 0.06386408f, -0.13092324f, 
    -0.02029765f, -0.00993059f, 0.03541658f, 0.00980690f, -0.00974268f, -0.02753792f, -0.07320426f, -0.09608673f, 
    -0.06036342f, 0.21878161f, -0.42021567f, 0.28496569f, 0.03456837f, -0.10118035f, 0.11280249f, 0.02235821f, 
    0.04102382f, 0.02962645f, 0.05883428f, 0.03925424f, -0.00284398f, 0.09033436f, 0.00151956f, 0.02287012f, 
    0.00334132f, -0.05895996f, 0.03341800f, -0.03117927f, 0.08037369f, 0.02492345f, 0.03293050f, 0.01641437f, 
    -0.02083969f, -0.03063297f, 0.00234356f, 0.00252323f, -0.02433051f, -0.01349623f, 0.17118210f, -0.02651858f, 
    -0.00302266f, -0.08608768f, -0.03548831f, -0.03467987f, -0.01901367f, 0.15110286f, -0.10188631f, 0.09097613f, 
    0.02823528f, -0.00579346f, -0.10088560f, -0.02031317f, 0.09352355f, 0.05009732f, 0.06753445f, 0.09945370f, 
    -0.37085164f, 0.31259483f, -0.50447792f, 0.35556972f, 0.09087326f, -0.02544572f, 0.18739508f, -0.04838569f, 
    -0.02940092f, -0.10013159f, -0.10998286f, 0.04664222f, 0.33023775f, -0.44567114f, 0.30533540f, 0.42014331f, 
    -0.11833429f, 0.11883783f, 0.05385870f, -0.04091234f, -0.08026190f, -0.12235808f, -0.05083483f, -0.04913384f, 
    0.03766688f, 0.04957680f, 0.01938567f, 0.00477986f, 0.02167291f, -0.04038782f, 0.03244649f, 0.04793763f, 
    0.05290180f, 0.04303364f, 0.02805683f, -0.03085420f, 0.13314694f, 0.05816718f, -0.02747915f, -0.08076961f, 
    -0.03230280f, 0.02948272f, -0.09612669f, 0.04243503f, 0.01018315f, 0.02156124f, 0.05198172f, -0.08129723f, 
    -0.15454289f, 0.04440119f, 0.00725505f, 0.05158494f, -0.05523646f, -0.04959572f, -0.03381154f, -0.01629646f, 
    -0.02059996f, -0.05772920f, -0.03572509f, -0.03075704f, 0.51886576f, -0.78158629f, -0.04781310f, -0.60397565f, 
    -0.02399122f, -0.06770798f, -0.05326691f, 0.05417102f, 0.01662690f, 0.16482168f, 0.00970648f, -0.01577884f, 
    -0.38612428f, -0.18541323f, 0.16936110f, 0.29824290f, -0.01102932f, -0.01320800f, 0.01714347f, -0.11220583f, 
    -0.09913576f, -0.06235981f, 0.02681817f, -0.05150051f, -0.31501541f, -0.20570056f, -0.20730555f, 0.05712580f, 
    0.01162874f, 0.02262233f, 0.30624616f, 0.12018763f, -0.16897982f, 0.00602631f, -0.06079085f, -0.01836499f, 
    -0.25972301f, 0.02802389f, -0.13716964f, 0.16940892f, -0.12405069f, 0.02885612f, 0.04009667f, -0.12013806f, 
    0.10088914f, -0.07880118f, -0.03659782f, -0.10025816f, 0.15740053f, -0.43577147f, -0.22009158f, 0.46678236f, 
    0.12348476f, -0.13611226f, 0.00453702f, -0.23618682f, -0.05849840f, 0.00556685f, 0.07301967f, -0.01418328f, 
    0.18969034f, 0.18706420f, -0.13699812f, -0.03459717f, -0.14907891f, 0.00897078f, 0.08922052f, -0.12972385f, 
    -0.03531959f, 0.05456337f, 0.04038981f, -0.07265691f, -0.23089008f, -0.26085749f, 0.42979759f, 0.09665322f, 
    -0.06773830f, -0.07326682f, -0.07847769f, 0.03717412f, -0.09174683f, 0.03088914f, -0.02983836f, -0.06978022f, 
    -0.10092581f, 0.02513938f, -0.04341028f, 0.02525569f, -0.05839004f, -0.04572265f, -0.09695692f, 0.00814519f, 
    -0.01438518f, 0.02286491f, 0.03100222f, 0.07659250f, -0.12717235f, -0.46287957f, -0.38685545f, -0.38466790f, 
    0.00359365f, -0.06236700f, 0.03374729f, 0.08137895f, 0.05036184f, 0.01241166f, 0.10844523f, 0.04440193f, 
    0.03337384f, 0.07477916f, 0.00051172f, 0.00662855f, -0.12383509f, 0.01993551f, 0.07099338f, 0.04757622f, 
    0.03303826f, -0.14051341f, 0.10268284f, 0.01686276f, -0.24866723f, 0.25356483f, 0.18551679f, 0.03047758f, 
    -0.02226127f, -0.04610836f, -0.07614943f, -0.03772015f, 0.04927930f, -0.02884572f, 0.04780532f, -0.03632521f, 
    0.08181505f, 0.02199528f, -0.24915242f, -0.00849390f, -0.03052818f, 0.07803837f, 0.11384048f, 0.02111782f, 
    0.00441920f, -0.11197320f, 0.06073063f, -0.03295587f, 0.12945820f, -0.00812172f, 0.00464594f, -0.13157417f, 
    0.01957556f, -0.05184922f, -0.06535657f, -0.05404101f, 0.02217271f, 0.02597431f, -0.03893740f, -0.10461301f, 
    0.01013348f, -0.16323769f, 0.06698303f, -0.12067894f, -0.00042560f, -0.12501292f, 0.08967443f, -0.01512713f, 
    0.00102539f, 0.07381811f, -0.08232841f, -0.12412339f, 0.04101689f, -0.05959674f, -0.07451978f, -0.06679632f, 
    0.02292205f, 0.08507144f, 0.07405891f, -0.04153620f, -0.04513754f, 0.14624903f, -0.24352355f, -0.14476269f, 
    0.25306696f, 0.08603415f, -0.17420329f, -0.29173860f, -0.13487011f, -0.01287016f, -0.01270380f, 0.06773651f, 
    0.06829206f, 0.01714890f, -0.00443001f, -0.01144932f, -0.25551575f, -0.05053683f, 0.12592205f, 0.02000671f, 
    0.07464070f, 0.02382205f, -0.02264966f, 0.09273645f, 0.01911592f, -0.08624915f, -0.01976872f, -0.00814682f, 
    -0.00917473f, 0.00024344f, 0.24751066f, -0.09435131f, -0.06456283f, -0.03143862f, 0.01074754f, 0.03436226f, 
    -0.04182200f, -0.16347292f, 0.07367067f, -0.13427182f, 0.31802160f, -0.45955747f, -0.13099271f, 0.14364903f, 
    0.01269545f, 0.03150962f, 0.00134319f, -0.03626596f, 0.07114519f, 0.10378147f, 0.03411896f, -0.05961595f, 
    -0.00114612f, -0.15569918f, 0.04285377f, 0.02483151f, -0.01638865f, -0.02578540f, -0.11505742f, -0.06707759f, 
    -0.01179110f, 0.01218803f, -0.04922947f, 0.00297636f, 0.10462317f, -0.32284102f, 0.63480943f, -0.15468249f, 
    -0.00342282f, -0.01118433f, 0.04374736f, 0.09240005f, 0.02329269f, -0.08578755f, 0.01020861f, 0.00808713f, 
    -0.08679304f, 0.02456126f, -0.05366265f, -0.03619081f, -0.02232255f, -0.01728973f, -0.03425146f, -0.01922025f, 
    0.08654830f, 0.03880389f, 0.00486484f, 0.01123847f, -0.22993818f, 0.05927580f, -0.09555887f, 0.09197676f, 
    0.04271488f, 0.02274252f, 0.06739767f, 0.07767413f, 0.06713445f, -0.04060281f, 0.12172442f, 0.03436838f, 
    0.32442176f, -0.65905416f, 0.04555844f, -0.30023634f, 0.06045244f, -0.06783228f, -0.21434176f, 0.08129705f, 
    0.06524232f, 0.06592539f, 0.08873923f, -0.02017273f, 0.18053296f, 0.05904390f, 0.00244058f, -0.04288149f, 
    -0.00965686f, -0.12433129f, -0.07033125f, -0.04043214f, 0.16657172f, 0.11324257f, 0.07483314f, -0.04508726f, 
    -0.02767978f, -0.17665729f, 0.04253320f, -0.19474787f, -0.08717991f, -0.00714654f, -0.06326071f, -0.09823048f, 
    -0.02735693f, -0.09535123f, -0.09359831f, -0.14027740f, 0.04414117f, 0.00586956f, 0.09913500f, -0.02480509f, 
    0.00475718f, 0.01534529f, -0.06381956f, -0.03961733f, 0.04667552f, -0.05974493f, 0.04259300f, -0.09053664f, 
    -0.14433356f, 0.16914101f, -0.07158908f, 0.26083666f, -0.01030629f, -0.03175233f, 0.09655891f, -0.12578380f, 
    0.05035811f, 0.00869424f, 0.00371594f, -0.09988608f, -0.12516822f, 0.22437070f, -0.07889704f, 0.08550396f, 
    0.08394447f, -0.01970901f, -0.05500058f, 0.08607785f, -0.04957071f, 0.03652537f, 0.07899477f, 0.03458662f, 
    -0.35444266f, -0.29660353f, -0.30074951f, -0.07629938f, 0.00126325f, 0.22446662f, 0.13734940f, 0.02879637f, 
    0.03153636f, 0.00298833f, -0.05139808f, -0.01754825f, -0.07777487f, 0.20898890f, 0.09446821f, 0.02671329f, 
    -0.24452366f, 0.00791386f, 0.08688696f, 0.05128505f, 0.01928646f, 0.04560452f, 0.02421778f, 0.05565875f, 
    -0.20856148f, -0.22521423f, 0.12818368f, -0.11395896f, 0.08217198f, 0.02819248f, 0.11888422f, 0.01876061f, 
    0.10849261f, 0.05201992f, 0.06451910f, 0.02877147f, 0.24262075f, -0.64888018f, -0.47036454f, -0.44341230f, 
    -0.12259348f, -0.11526959f, -0.05676899f, -0.03783103f, -0.01355667f, -0.05040176f, -0.01439233f, -0.02792588f, 
    0.40203938f, -0.30531392f, -0.09906140f, -0.37947199f, -0.16253337f, -0.10081311f, -0.18967327f, 0.09184485f, 
    -0.03947803f, 0.08016749f, 0.00783059f, -0.08519480f, 0.37239814f, -0.04608202f, -0.06147371f, -0.10052560f, 
    -0.05974334f, 0.01313552f, 0.00676986f, -0.04767298f, -0.12944174f, 0.12211452f, -0.02723080f, -0.04393988f, 
    0.08417328f, 0.01461520f, -0.02461616f, -0.00009227f, -0.07876404f, -0.19558319f, 0.03504367f, -0.19644701f, 
    0.04016571f, 0.03875932f, -0.03135865f, 0.01927373f, -0.06941334f, 0.06472523f, 0.03787990f, 0.14878196f, 
    0.04273209f, 0.00140949f, 0.02807673f, -0.02093113f, 0.03415462f, -0.02080697f, -0.01029182f, -0.20847106f, 
    -0.27578562f, -0.05230398f, 0.06470477f, 0.36976647f, -0.00614145f, 0.14484946f, -0.02208481f, 0.02601396f, 
    -0.09432261f, -0.06496704f, 0.07345568f, -0.01245236f, -0.31088221f, -0.44226760f, -0.37980360f, -0.13363869f, 
    -0.07173601f, 0.00225413f, -0.00163152f, -0.13203534f, 0.02116948f, 0.04311630f, 0.03449835f, 0.00787370f, 
    0.36072880f, -0.06503814f, -0.08829977f, -0.09385698f, 0.08236571f, -0.10827797f, -0.15157944f, -0.14819472f, 
    0.00061290f, 0.15098502f, 0.13122712f, 0.08530407f, -0.22840723f, -0.04208882f, 0.15993969f, 0.02221893f, 
    0.00933129f, 0.05463000f, 0.05861335f, 0.00944678f, -0.15369609f, 0.09237151f, -0.10185532f, -0.13551366f, 
    -0.05911903f, -0.08288671f, -0.04103950f, -0.00224233f, -0.01018471f, 0.06554973f, 0.00102528f, -0.00727271f, 
    0.15309365f, 0.07756402f, 0.06668278f, 0.09266117f, 0.18052700f, 0.04509961f, -0.23360007f, -0.13044019f, 
    -0.01477726f, 0.02492758f, 0.04776707f, -0.00678654f, 0.13739122f, -0.06981188f, 0.21923697f, -0.00163735f, 
    -0.03837444f, -0.30158171f, -0.26427960f, 0.04082073f, -0.05278722f, 0.00413777f, 0.07443279f, 0.06500417f, 
    0.05118259f, -0.03260950f, 0.00682396f, 0.05524784f, 0.16374117f, 0.13853490f, -0.05266027f, -0.15515806f, 
    -0.00573310f, -0.02945384f, 0.01528880f, -0.02700460f, -0.05660812f, -0.02022500f, -0.10015680f, 0.05434401f, 
    -0.06834033f, -0.17151172f, -0.14367858f, -0.29230353f, -0.09854216f, 0.02872870f, 0.02265435f, -0.02004282f, 
    0.12736642f, 0.08306108f, 0.16054931f, 0.08335864f, 0.54480100f, -0.17529468f, -0.54390436f, -0.04688794f, 
    -0.05059816f, -0.08324321f, 0.04304763f, 0.02881574f, 0.09556792f, 0.14666872f, 0.08622689f, -0.01311584f, 
    -0.29438883f, -0.21075030f, 0.08051591f, 0.21625307f, -0.04165387f, 0.01004354f, -0.00924574f, -0.00812134f, 
    0.01709888f, -0.04376021f, 0.10451217f, 0.10286184f, 0.20300272f, -0.05239936f, -0.05722731f, -0.34375599f, 
    0.01682055f, -0.00197982f, 0.04374233f, -0.03069902f, -0.00564771f, 0.06632242f, 0.04841803f, 0.08918590f, 
    0.02860170f, -0.14919619f, -0.09527756f, -0.01261207f, -0.08770876f, -0.10982275f, 0.07554459f, 0.03996592f, 
    0.15229119f, 0.12371498f, 0.12352860f, 0.13185450f, 0.14838256f, -0.10030508f, -0.17506571f, 0.12007143f, 
    0.11434620f, 0.03130855f, -0.00516000f, 0.12698843f, 0.00677745f, -0.15674619f, 0.00965528f, -0.00186273f, 
    -0.13795878f, -0.41508254f, -0.37889436f, -0.26901221f, 0.01504099f, 0.06631540f, 0.06620730f, 0.05828297f, 
    0.08568610f, -0.04829210f, -0.05850165f, -0.05130946f, -0.16570053f, -0.02885211f, -0.09804983f, 0.04298821f, 
    0.11301120f, 0.04416960f, -0.01503891f, 0.04775291f, 0.08668265f, 0.15501644f, 0.14884080f, 0.10606839f, 
    -0.10235678f, -0.29910547f, -0.48797500f, -0.15441507f, -0.22142130f, -0.00290661f, 0.09965964f, -0.12245377f, 
    -0.12351619f, -0.06383938f, -0.02025069f, -0.02292362f, -0.07805444f, 0.02554028f, -0.09340625f, -0.17033981f, 
    -0.04258005f, -0.06448028f, -0.01018448f, -0.05527518f, 0.06043449f, 0.01623852f, 0.03650481f, 0.09104045f, 
    -0.27567086f, -0.35798976f, -0.08764916f, -0.07552748f, -0.09881046f, 0.19987169f, 0.08585050f, 0.06535535f, 
    0.07407731f, 0.09627067f, -0.09731727f, -0.22507939f, -0.28752017f, -0.13857198f, 0.07930773f, -0.04950751f, 
    -0.11965126f, 0.01976088f, -0.04544490f, -0.09725668f, -0.19579957f, -0.07270015f, -0.13325715f, -0.02990681f, 
    -0.05821953f, -0.14614791f, -0.13005400f, -0.01231128f, 0.00048538f, 0.19627501f, -0.01983923f, 0.08969943f, 
    0.00501331f, -0.20191228f, -0.08110940f, -0.19769731f, -0.02648265f, -0.02175641f, -0.04474526f, -0.08682309f, 
    -0.01254958f, -0.06613592f, -0.02542701f, 0.04723727f, -0.10539453f, -0.00264445f, -0.09759530f, -0.24128194f, 
    0.15397824f, -0.15127149f, -0.25090903f, -0.10069266f, 0.09549195f, 0.08744130f, -0.08973031f, 0.09071440f, 
    -0.07210804f, 0.03498481f, 0.05865324f, -0.28317499f, 0.72156274f, -0.02965311f, -0.28626013f, -0.31898353f, 
    0.22642255f, -0.01012727f, 0.11227010f, 0.02308855f, 0.09228692f, 0.16972852f, 0.09063454f, 0.18582200f, 
    -0.09416415f, -0.00995294f, 0.05251573f, -0.10487403f, -0.06652264f, -0.04751395f, -0.04894844f, -0.01573702f, 
    0.01651938f, -0.01856855f, 0.01531168f, -0.01009986f, 0.14817189f, 0.15646647f, 0.01776242f, -0.24369848f, 
    -0.07920657f, -0.05056809f, -0.00490502f, -0.06336356f, -0.07938235f, -0.01659524f, -0.10793810f, -0.08701660f, 
    0.05387592f, 0.05322557f, 0.14508587f, -0.09235009f, 0.01250400f, -0.15660346f, 0.05610479f, -0.04216118f, 
    0.13309725f, 0.00750212f, -0.07604728f, 0.03572289f, 0.04806650f, -0.28171673f, -0.36883461f, -0.35624468f, 
    -0.02581339f, 0.11747383f, 0.07561009f, 0.16820437f, 0.03301360f, -0.03569115f, -0.02866324f, 0.01950509f, 
    -0.02764958f, -0.52821726f, -0.36412224f, -0.19039878f, -0.03451202f, -0.04237700f, 0.04318188f, 0.02578107f, 
    -0.03162960f, 0.05292929f, 0.04546779f, 0.06986902f, -0.24429776f, -0.31207466f, -0.20785968f, -0.17042564f, 
    -0.05702105f, -0.02914956f, 0.02047543f, -0.20929183f, -0.04498985f, -0.10437878f, 0.01615261f, -0.01679895f, 
    -0.06856330f, 0.10878537f, -0.06657126f, 0.11851510f, 0.10187376f, 0.05970672f, 0.08303042f, 0.20598589f, 
    -0.11990631f, -0.14039771f, -0.09170340f, -0.18465103f, 0.24428329f, -0.29258698f, -0.17550422f, -0.38887778f, 
    0.04610550f, -0.10322742f, 0.03924032f, 0.10781730f, 0.10321564f, 0.17609200f, 0.00856604f, 0.04132135f, 
    0.25760442f, 0.13658312f, -0.15690784f, -0.10887856f, 0.05453072f, 0.03385618f, -0.01682533f, -0.00631272f, 
    0.10693700f, 0.01727608f, 0.01446651f, 0.07224986f, 0.45536327f, 0.25510508f, -0.10058475f, -0.08127230f, 
    -0.07271063f, -0.04476772f, -0.09399777f, -0.16370693f, 0.07601596f, 0.07359406f, -0.01802798f, 0.09177393f, 
    -0.30161610f, 0.05048500f, 0.05017599f, 0.06872604f, -0.03730915f, -0.03387463f, 0.01075303f, 0.08364283f, 
    -0.05310985f, -0.01007560f, 0.08559143f, 0.11908938f, -0.21129882f, -0.30243248f, -0.00334505f, 0.19935210f, 
    -0.01827642f, 0.05979301f, 0.11379895f, 0.03003004f, -0.02918777f, -0.05495439f, 0.05862304f, -0.15527570f, 
    -0.38715309f, -0.00034046f, 0.06388423f, -0.01307431f, 0.11013024f, -0.11108243f, -0.04011698f, 0.00014469f, 
    -0.22405393f, -0.10587180f, 0.03776171f, -0.15104821f, -0.56496215f, -0.02714716f, 0.11080951f, 0.20888725f, 
    0.12454265f, -0.10756596f, -0.04393344f, 0.05206172f, 0.02337520f, -0.02010501f, -0.08416471f, -0.04159259f, 
    0.14941326f, 0.05168357f, -0.07002728f, 0.04545933f, -0.09621013f, 0.09341329f, 0.07301216f, -0.03055854f, 
    -0.02300063f, 0.08182679f, 0.00643544f, 0.15525314f, -0.06148027f, 0.04063201f, 0.08378727f, -0.15679038f, 
    -0.00950501f, -0.01779241f, 0.02361700f, -0.02955881f, -0.01883361f, 0.06152248f, 0.06227816f, 0.09706446f, 
    -0.16323006f, -0.04140661f, 0.05675957f, -0.04121883f, -0.05777649f, 0.00466233f, 0.00542538f, -0.06571171f, 
    0.03829029f, -0.01740116f, -0.02235689f, 0.03165346f, -0.20603269f, -0.01492981f, -0.01940927f, 0.05775297f, 
    0.01253546f, -0.04142018f, -0.05007625f, -0.03690651f, 0.17222361f, -0.02458687f, 0.14710885f, 0.14101310f, 
    0.12935422f, -0.12285037f, -0.20136213f, -0.08312028f, -0.29654363f, -0.04391399f, -0.04872544f, 0.16432382f, 
    0.14342409f, 0.04233975f, -0.00035392f, 0.02180254f, 0.10516897f, 0.06225602f, -0.19704370f, 0.03617143f, 
    -0.13951240f, 0.11451100f, -0.02651025f, -0.14094645f, 0.00655239f, -0.01879013f, -0.01373571f, 0.00854793f, 
    -0.24887745f, -0.12406691f, 0.21201973f, 0.17736937f, 0.05287017f, 0.04625332f, -0.00791128f, 0.11518695f, 
    0.05591601f, 0.03037913f, -0.12594905f, 0.04189640f, 0.00872336f, -0.14010972f, -0.08506901f, -0.28340316f, 
    0.00337928f, 0.06079718f, 0.10162853f, 0.06507128f, -0.06251232f, -0.29880905f, -0.21211119f, -0.20956175f, 
    0.28489608f, 0.11020340f, 0.03323630f, -0.08706457f, 0.14655806f, -0.13873601f, -0.01039297f, -0.00929219f, 
    -0.00060062f, -0.02094023f, 0.05754375f, 0.02767756f, 0.35534996f, 0.13832825f, -0.02335994f, -0.07714898f, 
    0.02961878f, -0.08792514f, 0.13652772f, -0.04658143f, 0.05180549f, 0.09245240f, 0.03480295f, 0.11960486f, 
    -0.21756132f, 0.18829198f, 0.05436206f, -0.00781064f, 0.02260515f, -0.02589334f, -0.04572734f, -0.02050091f, 
    -0.00585472f, 0.02290000f, -0.02180905f, -0.02995380f, -0.14539187f, -0.09168190f, 0.08856754f, 0.12040818f, 
    -0.05024158f, 0.00469026f, -0.10593661f, 0.11123230f, -0.11459908f, -0.09156407f, 0.06469104f, -0.01392130f, 
    0.09155183f, 0.09451698f, -0.30703670f, -0.09326191f, 0.00213250f, -0.14182323f, 0.14559452f, 0.11194182f, 
    0.06802475f, 0.06889450f, -0.02863204f, -0.16994220f, -0.05414242f, -0.13043773f, -0.02650564f, -0.36298382f, 
    0.04741535f, 0.01985791f, 0.05108707f, 0.12368039f, 0.04652954f, -0.02873767f, -0.01095376f, -0.40720752f, 
    0.36426875f, -0.01996007f, -0.15461107f, -0.11987674f, 0.10169318f, -0.04444494f, 0.04331194f, -0.00383307f, 
    0.05416672f, 0.03281575f, -0.10196644f, 0.03465349f, -0.13260235f, 0.05230014f, 0.02273906f, -0.09012978f, 
    0.03044158f, -0.17423975f, 0.04257882f, 0.07207840f, 0.04536712f, -0.06901779f, 0.05327122f, 0.00180664f, 
    -0.14212142f, -0.03127480f, 0.10248580f, 0.13416752f, -0.07187220f, 0.16246672f, -0.05519631f, 0.17258610f, 
    -0.28202501f, 0.02922727f, -0.22447515f, -0.28882501f, -0.07347878f, 0.21064469f, 0.11871294f, 0.04800038f, 
    -0.02139239f, 0.08510941f, -0.11356600f, 0.07134192f, -0.00882435f, -0.08384341f, 0.00362707f, -0.02355969f, 
    -0.31279227f, -0.35300258f, -0.23986439f, 0.31699905f, 0.13728666f, 0.02064804f, -0.07451893f, 0.13762091f, 
    0.04360356f, 0.04562313f, 0.03686105f, 0.10217321f, -0.24810059f, -0.10210823f, 0.01961257f, -0.00198555f, 
    0.01428854f, 0.04144999f, -0.07081349f, 0.03715335f, -0.00147428f, 0.13474455f, 0.07478429f, 0.09713875f, 
    0.01565144f, -0.13442123f, 0.13283795f, -0.10052415f, -0.21064772f, 0.04599292f, -0.12814653f, -0.11029740f, 
    -0.12367015f, 0.09150829f, -0.12704395f, -0.05363323f, -0.12854975f, -0.41434884f, -0.31256914f, 0.21854030f, 
    0.01137947f, 0.14569272f, 0.10592173f, 0.01569232f, 0.07563553f, 0.04699205f, 0.11354657f, 0.02289812f, 
    -0.08463044f, -0.09164760f, -0.23899861f, 0.06711146f, 0.10145410f, -0.02682077f, 0.18873972f, 0.07214735f, 
    0.04811053f, -0.07779831f, -0.02580628f, 0.01335676f, 0.49765444f, 0.17573783f, -0.02213484f, -0.37711966f, 
    0.00883473f, -0.08287939f, 0.04348829f, -0.09008492f, 0.01809552f, -0.04359344f, 0.07460598f, -0.00034538f, 
    -0.09161024f, -0.21022177f, -0.06929520f, -0.00735091f, -0.01335877f, 0.07833172f, 0.05391070f, 0.14964217f, 
    -0.08667328f, 0.00359222f, 0.00298874f, -0.00033064f, -0.46414396f, -0.09328397f, -0.03746129f, 0.03343649f, 
    -0.09286337f, 0.01382731f, -0.06115802f, -0.02119655f, 0.01717807f, 0.09361327f, -0.20116149f, 0.05842064f, 
    -0.19465275f, 0.15697862f, 0.11142302f, -0.46074119f, -0.08983383f, 0.12551326f, -0.00233249f, -0.16209193f, 
    0.00145566f, 0.07279995f, -0.00337544f, -0.01206991f, -0.20878208f, 0.06195176f, -0.01016645f, -0.22018936f, 
    -0.17405112f, -0.06897607f, 0.12065083f, 0.05764288f, 0.05334717f, -0.01144404f, 0.01201345f, 0.04866105f, 
    0.12538694f, -0.07867281f, -0.20682338f, 0.08887895f, 0.11535185f, 0.04171755f, 0.08756751f, -0.15644844f, 
    0.14825761f, -0.07978698f, -0.14534320f, -0.10007410f, -0.25463676f, 0.08538155f, 0.43586552f, -0.45449251f, 
    0.00718956f, -0.10960873f, -0.00771722f, 0.06005347f, 0.00174023f, 0.07791334f, 0.08086011f, -0.02781757f, 
    0.01255273f, -0.04522334f, 0.09645306f, -0.11172740f, 0.20080985f, -0.02993294f, -0.00551294f, 0.00604311f, 
    -0.00046671f, -0.18351148f, -0.03686730f, -0.09347363f, -0.32606393f, -0.32738850f, 0.12877418f, 0.23929195f, 
    -0.04359142f, -0.01509476f, -0.20028765f, -0.12542588f, -0.26672748f, 0.10794703f, 0.03278975f, -0.08178777f, 
    -0.16051878f, -0.05618685f, 0.00760602f, -0.09239042f, 0.13498822f, -0.12300125f, -0.24748620f, 0.25033772f, 
    -0.01592932f, -0.09497082f, 0.08551010f, 0.04982864f, -0.29968575f, -0.19455564f, 0.26760015f, 0.06049011f, 
    0.03427394f, 0.11454529f, 0.04148740f, 0.07475093f, -0.07296702f, -0.03576821f, 0.05287813f, 0.12018131f, 
    0.01335048f, 0.20075037f, 0.30381483f, 0.32828340f, 0.09258614f, 0.01391807f, -0.04384501f, -0.09339913f, 
    -0.09113462f, -0.02613514f, 0.06479792f, -0.11625920f, -0.16238812f, 0.03279206f, -0.05520338f, -0.16094151f, 
    0.05493978f, -0.14225061f, -0.00127150f, 0.07113087f, -0.04069468f, -0.02275664f, -0.06222105f, -0.04843386f, 
    0.06200519f, 0.20228578f, -0.03892997f, -0.26341063f, -0.07089267f, -0.00826142f, 0.04688108f, -0.02567358f, 
    -0.09757202f, 0.05723121f, -0.08621765f, 0.18321092f, -0.37318507f, 0.15671676f, 0.00969613f, 0.39885491f, 
    0.10231002f, -0.00406041f, 0.01703828f, -0.03264400f, 0.08211949f, -0.13226897f, -0.01541883f, 0.02575740f, 
    0.04857907f, -0.05499362f, 0.05272250f, -0.12718427f, 0.11743853f, 0.07328130f, -0.20417473f, -0.04581326f, 
    -0.12091784f, -0.02025840f, -0.04677287f, 0.02806423f, -0.05856254f, -0.01371884f, -0.16716416f, -0.13448389f, 
    -0.05706035f, 0.00762071f, -0.17695560f, 0.14678745f, 0.05403853f, -0.14330447f, 0.07129410f, -0.05319165f, 
    0.20415266f, 0.14066462f, 0.43816844f, 0.30350575f, 0.12480489f, -0.14717884f, -0.22922172f, -0.18972510f, 
    0.09079246f, -0.04631957f, 0.09267425f, 0.02903708f, -0.08137053f, 0.33254433f, -0.09204157f, -0.12723148f, 
    -0.03845972f, 0.02839834f, -0.08254447f, -0.04547453f, 0.10454182f, -0.09373075f, -0.10016992f, -0.12225238f, 
    -0.16539057f, -0.16536696f, -0.35223261f, -0.28840381f, -0.30816144f, 0.15035529f, 0.00253668f, 0.06758163f, 
    0.13675261f, -0.00233020f, 0.09142146f, 0.02328092f, -0.05563471f, -0.09747738f, 0.07909415f, 0.04223614f, 
    -0.00483226f, 0.09233856f, -0.01676603f, -0.01755689f, 0.05846613f, 0.08657387f, 0.13754094f, 0.03710788f, 
    -0.54452747f, 0.20548224f, -0.05180151f, -0.08472262f, 0.04896271f, -0.00496952f, 0.01370648f, -0.05187004f, 
    0.04446836f, 0.09878553f, 0.16523431f, 0.12963171f, -0.16036901f, -0.17445365f, 0.05590965f, -0.17708208f, 
    0.07273677f, 0.06545717f, 0.09448635f, 0.10611667f, 0.05002468f, 0.07597787f, -0.08721240f, 0.08101920f, 
    0.03953224f, 0.01954887f, 0.11612361f, -0.03153229f, -0.16460739f, -0.04627450f, -0.12919489f, 0.04355614f, 
    0.20583478f, 0.09236243f, 0.02473009f, 0.05772036f, -0.26135477f, 0.01028816f, -0.05115127f, 0.18838784f, 
    0.05751134f, -0.02170155f, 0.00611190f, 0.03526234f, 0.04046258f, 0.15101241f, 0.13577324f, 0.16391563f, 
    -0.28587887f, 0.19354887f, -0.14427124f, 0.13026370f, 0.12411735f, 0.09039742f, -0.05422660f, -0.10065077f, 
    0.12430544f, 0.03977242f, 0.07488699f, 0.08402478f, -0.15089355f, -0.13063283f, -0.05772097f, 0.18431124f, 
    0.16518186f, -0.00724455f, -0.16318457f, -0.07035746f, 0.06554145f, -0.01371602f, -0.02631930f, 0.03585616f, 
    0.09231653f, -0.07954936f, -0.24429899f, -0.04749773f, 0.17432645f, 0.14498270f, 0.03382923f, -0.00482218f, 
    0.07776640f, -0.14274275f, -0.00649237f, -0.00393788f, -0.26905605f, -0.41588843f, -0.01763542f, 0.20283727f, 
    -0.09161612f, 0.15228559f, -0.06316870f, -0.13002126f, 0.02220553f, -0.08774562f, -0.02010801f, -0.04163389f, 
    0.26083875f, -0.09295519f, 0.06498181f, -0.07851293f, 0.20629741f, -0.04834367f, -0.02832891f, 0.03815010f, 
    -0.04520169f, -0.08683854f, -0.11008070f, -0.18098396f, 0.25467339f, -0.00150347f, 0.10318262f, 0.53814614f, 
    -0.00597494f, -0.13277365f, -0.09017040f, 0.00778692f, -0.11013890f, -0.15483400f, 0.05165227f, -0.13512471f, 
    0.11226924f, -0.06309336f, 0.31382516f, -0.25758579f, -0.10213826f, -0.20524271f, 0.02750480f, 0.04837332f, 
    0.05887226f, 0.01589347f, 0.00202637f, 0.02185999f, -0.13878539f, 0.19774741f, 0.41387314f, -0.22773796f, 
    -0.04312709f, -0.12247279f, 0.08002760f, 0.21892066f, -0.03761046f, 0.08632261f, -0.01200807f, -0.00808226f, 
    -0.19978039f, 0.09615535f, -0.38043606f, 0.16023085f, 0.12929639f, -0.16211544f, 0.02378405f, -0.05055915f, 
    0.15628709f, 0.05107478f, 0.10896286f, 0.09317535f, -0.02405757f, 0.12252811f, 0.20544672f, -0.04729388f, 
    0.06920685f, -0.13000637f, -0.01642139f, -0.22766870f, 0.05212933f, -0.01355268f, -0.09623712f, -0.00733254f, 
    -0.34862593f, 0.15686499f, -0.17944704f, 0.13543992f, 0.02903128f, -0.00852834f, -0.13904230f, -0.01443276f, 
    0.01384724f, -0.18014854f, -0.01601652f, -0.07740526f, -0.33427978f, -0.57218510f, -0.00955272f, -0.08186511f, 
    -0.17044963f, -0.03870928f, -0.03898657f, 0.15867965f, 0.03653964f, 0.01243141f, 0.06933013f, -0.02277806f, 
    -0.30642498f, 0.36503750f, -0.00537241f, -0.33677661f, 0.01274780f, -0.07801183f, 0.15734960f, -0.07460516f, 
    0.00308362f, 0.06247321f, -0.14935733f, -0.01897669f, 0.23961529f, -0.22571144f, 0.10924316f, -0.14371870f, 
    0.04896614f, 0.03917959f, -0.07953751f, -0.00277942f, -0.00074868f, 0.01766411f, 0.01488521f, 0.12079369f, 
    0.13149028f, 0.20683460f, -0.36090103f, -0.15860613f, -0.10918088f, -0.00605211f, 0.09486559f, 0.15320782f, 
    0.05751959f, 0.05128555f, -0.02112794f, -0.01678382f, 0.29900858f, -0.10233447f, -0.24179645f, -0.06421834f, 
    0.01185199f, -0.01849648f, 0.05644248f, 0.22974628f, -0.02259299f, 0.02430784f, -0.04985486f, -0.03670290f, 
    -0.26782078f, 0.18365897f, -0.05122682f, -0.26367137f, -0.04139099f, -0.24649553f, 0.10065351f, -0.10804360f, 
    -0.08478705f, 0.00131901f, -0.09585463f, -0.13198167f, -0.06452690f, -0.13364781f, 0.03604147f, 0.13764179f, 
    0.00814440f, 0.11717319f, -0.02919711f, -0.01552161f, -0.00926499f, 0.02375084f, 0.05597926f, -0.02356910f, 
    0.28072813f, -0.05623182f, 0.39385274f, -0.11714158f, 0.02265394f, -0.05669177f, -0.08850457f, -0.14724684f, 
    -0.06661560f, 0.03365181f, 0.03994234f, -0.12648316f, 0.20133972f, 0.05560912f, -0.16354638f, 0.00651344f, 
    0.11535490f, -0.10125633f, -0.02734347f, -0.06008678f, -0.07187597f, 0.03057743f, -0.14763068f, -0.13833439f, 
    -0.14301278f, -0.08512329f, 0.11283721f, 0.39355445f, -0.05179225f, 0.25101903f, -0.44222742f, 0.23554085f, 
    0.15218952f, -0.09216055f, -0.03907020f, 0.04276205f, -0.20335740f, -0.01950960f, -0.08264674f, -0.11504705f, 
    0.04756429f, -0.11502245f, 0.07260521f, 0.17889252f, 0.02238326f, -0.01114056f, -0.02518824f, -0.07453892f, 
    0.05060179f, -0.36300978f, -0.17831838f, -0.50749683f, -0.11219627f, -0.02737001f, 0.08062474f, 0.00145723f, 
    -0.06887913f, 0.14970991f, -0.07426980f, -0.00538476f, 0.18584824f, -0.06936508f, 0.22414681f, 0.18830639f, 
    0.06391673f, -0.06360968f, 0.00868116f, -0.00803428f, -0.03487918f, -0.00712352f, 0.01944158f, 0.07388363f, 
    -0.10960595f, -0.07526446f, -0.45353431f, 0.16762933f, 0.05347252f, 0.02431784f, 0.13645931f, -0.05695274f, 
    0.04635098f, -0.10256593f, -0.00845180f, -0.03630796f, -0.04313938f, -0.75392812f, 0.12513065f, -0.38513932f, 
    -0.02440063f, -0.02604926f, -0.07082195f, 0.05678107f, -0.00722823f, 0.02825106f, -0.01767126f, 0.03081596f, 
    -0.18755272f, 0.03718965f, -0.80940324f, 0.22018687f, 0.12230723f, 0.16558209f, 0.20071147f, -0.01498886f, 
    0.05742893f, -0.09044874f, -0.06032726f, -0.00912668f, -0.01703505f, 0.71808773f, -0.16050395f, -0.30621648f, 
    -0.00278344f, -0.07264768f, -0.07134243f, 0.00084418f, 0.13503769f, -0.09818940f, 0.00567786f, -0.01395156f, 
    -0.10416374f, 0.16620226f, 0.20915049f, 0.48233211f, 0.04225431f, -0.02687709f, -0.05005928f, -0.09904718f, 
    0.17177865f, 0.04762774f, 0.10420608f, 0.06787195f, -0.11583707f, -0.23395707f, -0.05408922f, 0.46089330f, 
    0.01430620f, 0.09867875f, -0.01993712f, -0.11825760f, 0.02532784f, 0.07428251f, 0.01816490f, -0.03522668f, 
    0.03152898f, 0.01573547f, 0.19126455f, 0.19230831f, 0.05053038f, -0.17306985f, -0.11432522f, -0.08364639f, 
    0.05413758f, 0.05746987f, -0.04863046f, -0.07589133f, 0.09692356f, -0.09790450f, -0.16143802f, 0.05036841f, 
    0.11139394f, -0.01697641f, 0.07354128f, -0.07903064f, -0.01407841f, -0.16105612f, -0.05126450f, -0.10352721f, 
    -0.19003063f, 0.06077119f, 0.06663689f, -0.09760796f, 0.00129118f, -0.01938593f, -0.02658302f, 0.01592047f, 
    0.16062209f, 0.10865548f, 0.01929685f, 0.15798149f, -0.53864622f, -0.28609699f, -0.01223645f, -0.22692229f, 
    -0.04572301f, 0.05766847f, -0.05717285f, 0.13224493f, 0.01064718f, 0.01456531f, -0.04570620f, 0.07813208f, 
    -0.07802487f, -0.01822799f, 0.08325651f, -0.30416277f, -0.00408286f, -0.23039004f, 0.10055987f, -0.13878231f, 
    0.01847152f, 0.06202437f, 0.09773795f, 0.00509459f, 0.06431275f, 0.09933029f, -0.13754217f, 0.00582336f, 
    -0.25208077f, 0.18107088f, 0.06447759f, 0.06840235f, 0.16584633f, -0.10148858f, -0.05131501f, -0.08153506f, 
    0.39318231f, -0.32609946f, 0.12708089f, -0.43343791f, -0.02611771f, -0.09428516f, -0.16150506f, -0.15920971f, 
    0.04455020f, 0.02655047f, -0.16209970f, 0.00422018f, 0.16643228f, -0.01463793f, 0.04840030f, -0.18776460f, 
    -0.08105347f, -0.16707420f, -0.25224867f, -0.06751432f, -0.05305136f, -0.03692211f, -0.00489106f, 0.04805864f, 
    0.31810179f, 0.01111758f, 0.17444977f, 0.04452457f, -0.13297601f, -0.04807706f, -0.31267062f, -0.12377132f, 
    0.03036288f, -0.09387493f, -0.00602484f, 0.10304645f, -0.44198322f, -0.45121264f, -0.07556717f, 0.05404604f, 
    -0.04613919f, 0.01645571f, -0.09133893f, -0.02763847f, 0.04026425f, -0.03695600f, 0.09540213f, 0.04044557f, 
    0.07052733f, -0.03560234f, 0.20852117f, -0.17375444f, -0.04569660f, -0.05757145f, 0.00773182f, -0.11658458f, 
    0.02627953f, 0.00496615f, 0.05512571f, 0.04681452f, -0.01192682f, -0.06519062f, 0.03590378f, -0.18020390f, 
    0.04251698f, -0.07003731f, 0.01899948f, -0.00921382f, 0.01883384f, 0.14986619f, 0.07545408f, 0.06708539f, 
    0.25689018f, 0.02773828f, 0.01637746f, -0.00222518f, 0.02822629f, -0.01770045f, 0.08858514f, -0.03217065f, 
    -0.07951660f, 0.08865896f, 0.13876989f, 0.03348443f, -0.07277393f, -0.30137482f, -0.12180295f, 0.01703311f, 
    -0.07817523f, 0.00852151f, 0.01380722f, 0.10901305f, 0.00105996f, 0.03680885f, 0.09741301f, 0.08197511f, 
    -0.34626308f, -0.22755153f, 0.25236639f, 0.11601007f, -0.01409656f, 0.01567738f, 0.06387250f, -0.19090325f, 
    -0.05637467f, 0.09576555f, 0.12460445f, 0.28228757f, 0.02536412f, 0.09177734f, -0.01998021f, 0.15812446f, 
    0.05151837f, 0.09117223f, -0.02037236f, 0.03565228f, -0.12303869f, -0.12124656f, -0.16839439f, -0.22904623f, 
    -0.13007355f, -0.10019159f, 0.06111966f, -0.00147864f, 0.02119827f, -0.02811180f, -0.09999352f, 0.05022646f, 
    -0.03979849f, 0.14292735f, 0.15568729f, 0.21263769f, -0.27172595f, 0.08770306f, 0.23355836f, -0.03876132f, 
    -0.01030883f, 0.06673821f, 0.05738601f, 0.03263176f, 0.00989397f, 0.04808849f, 0.04243157f, -0.03896736f, 
    -0.07642480f, -0.20154026f, 0.14818697f, 0.31510445f, -0.22061959f, 0.01622873f, -0.05737089f, 0.38045904f, 
    0.00216832f, 0.18578511f, 0.05833586f, 0.10310324f, -0.09574474f, -0.24058962f, 0.06430849f, 0.05148073f, 
    -0.21822736f, 0.07376447f, 0.07314730f, -0.06929530f, 0.09120065f, -0.22795352f, 0.10384870f, 0.02070754f, 
    -0.35299653f, 0.23236445f, 0.02903686f, -0.27061087f, -0.11471229f, 0.03971244f, -0.10408293f, -0.10528351f, 
    0.07453474f, 0.07051257f, 0.02758860f, 0.04159261f, -0.36410505f, -0.28515533f, 0.19431207f, 0.30694285f, 
    0.01423535f, 0.05220491f, 0.17178540f, 0.06155305f, 0.05758496f, -0.26405662f, 0.01744790f, 0.00428731f, 
    -0.10217060f, 0.12518793f, 0.07663466f, 0.14803170f, -0.01744237f, -0.00914554f, 0.12596236f, 0.09169178f, 
    -0.19626988f, 0.12889598f, 0.05461834f, -0.05136291f, 0.03949574f, 0.34544238f, 0.05123900f, -0.16108969f, 
    -0.20966244f, 0.08638560f, 0.01714109f, 0.06367321f, -0.06511326f, 0.00290704f, -0.20501696f, 0.07074827f, 
    0.15142779f, 0.12596570f, 0.10422537f, 0.32072484f, -0.19775242f, 0.14850076f, -0.09393824f, 0.11803522f, 
    0.11276473f, 0.26406378f, 0.13191941f, 0.18139568f, -0.07560186f, -0.10909674f, -0.02494373f, 0.18294433f, 
    -0.02766103f, -0.08613591f, 0.13201776f, -0.00056222f, -0.11622607f, 0.08215375f, 0.01272850f, 0.04185636f, 
    -0.10710269f, 0.24646594f, 0.11201760f, -0.12535672f, 0.05373526f, -0.00706578f, -0.18241370f, 0.05740476f, 
    -0.13345526f, -0.05012254f, -0.05414595f, -0.10238165f, 0.15068543f, -0.02376722f, 0.07647544f, -0.18077034f, 
    -0.12897165f, 0.09066609f, 0.15795767f, -0.00103458f, -0.02570715f, 0.04370563f, 0.17282210f, 0.16952990f, 
    0.11320353f, -0.24719827f, -0.39689413f, 0.07047379f, 0.03101458f, -0.21234351f, 0.05030891f, 0.12447452f, 
    -0.07787897f, 0.08246253f, 0.02104965f, -0.17878243f, -0.29219064f, -0.37528291f, -0.37552103f, -0.22204182f, 
    -0.19546084f, 0.01167787f, 0.08209004f, -0.10760786f, -0.06427289f, -0.03007962f, -0.00229758f, 0.10826974f, 
    0.37525281f, -0.62789071f, 0.18677494f, -0.11827528f, 0.05981496f, 0.13407259f, -0.01121129f, 0.13570169f, 
    0.12370397f, 0.05719893f, -0.28262526f, -0.14615332f, -0.00761299f, -0.22644675f, -0.04787200f, -0.31432441f, 
    -0.04618709f, 0.02098704f, -0.10317226f, 0.03780539f, -0.11025099f, -0.19732925f, -0.10499592f, -0.12521172f, 
    -0.07000955f, -0.14984848f, -0.11117350f, -0.09699819f, 0.07532116f, -0.11844135f, -0.02685815f, -0.01898556f, 
    -0.18889469f, -0.01075541f, -0.15967306f, -0.38570464f, 0.24265395f, 0.03244771f, 0.06422180f, -0.13756563f, 
    -0.01726060f, -0.02293273f, 0.03324424f, -0.07700195f, -0.02814199f, -0.18971826f, -0.36098951f, -0.24442074f, 
    0.13434747f, -0.17552699f, -0.18975142f, -0.13343142f, -0.21264975f, 0.08517648f, -0.01884371f, 0.13469163f, 
    0.08541473f, 0.07298365f, -0.23561153f, -0.03419723f, -0.24477023f, 0.31931427f, -0.11538987f, -0.03023393f, 
    -0.11960410f, 0.32436904f, 0.38228902f, 0.15802303f, -0.12088764f, 0.12601554f, -0.07169859f, 0.17743568f, 
    -0.22767453f, -0.44776303f, -0.16133888f, -0.25698119f, -0.13550790f, 0.13653390f, 0.14361885f, -0.02912769f, 
    -0.08379662f, 0.10453001f, -0.08007362f, -0.05045145f, 0.15415236f, -0.01850156f, 0.00962056f, 0.06369580f, 
    0.00723901f, -0.06768113f, 0.10358185f, -0.03491851f, -0.06301364f, 0.11093803f, -0.19715257f, 0.11400590f, 
    -0.11256052f, -0.14671098f, -0.23293504f, 0.10145893f, -0.03446081f, 0.15329254f, -0.05003822f, 0.03969342f, 
    -0.03407960f, 0.17644913f, 0.01437369f, 0.07636850f, -0.39980003f, 0.35497713f, -0.48456761f, 0.16965717f, 
    0.02363684f, 0.05685308f, 0.06452408f, 0.02432713f, -0.00978516f, 0.02754166f, -0.07379599f, -0.06626691f, 
    -0.20722184f, 0.00600525f, -0.05308590f, 0.25645238f, 0.01573684f, -0.06957793f, 0.08605667f, 0.19197391f, 
    0.01679162f, 0.03650768f, 0.01258557f, 0.07365769f, -0.28298610f, -0.11043695f, -0.20152420f, 0.18221685f, 
    -0.01506385f, -0.14065811f, -0.27512708f, 0.07597581f, 0.13019796f, 0.05233804f, -0.11370119f, -0.11391920f, 
    0.02824719f, 0.10724963f, 0.01105816f, 0.03687829f, -0.06418387f, -0.01321119f, 0.06591868f, 0.05147769f, 
    -0.08132563f, -0.12265442f, -0.28808162f, -0.23793142f, -0.00607257f, 0.00250968f, -0.09626964f, 0.11989731f, 
    -0.07785605f, 0.10304306f, 0.24475279f, 0.12909000f, -0.12141871f, 0.21972954f, 0.01483550f, 0.11369281f, 
    0.25037003f, 0.18247789f, -0.02310587f, 0.07408739f, -0.15450405f, 0.07036681f, -0.05204862f, 0.18009306f, 
    -0.01633733f, 0.15796439f, 0.11440641f, 0.03123655f, -0.27541789f, -0.41283783f, 0.12024410f, 0.08886780f, 
    -0.15178442f, 0.20611641f, -0.16485363f, -0.00432778f, 0.00689208f, -0.04603733f, 0.08374081f, 0.10764656f, 
    -0.08772439f, -0.06745914f, 0.10441068f, 0.03248459f, 0.01144485f, 0.00980835f, 0.21967781f, -0.01839612f, 
    -0.07560695f, 0.03942256f, 0.01240040f, 0.14889362f, 0.02611824f, -0.20366950f, -0.08649865f, -0.03881701f, 
    -0.00586847f, 0.00355786f, -0.04674361f, 0.01996878f, 0.07088137f, -0.01256701f, -0.36780748f, -0.29601255f, 
    -0.10680880f, -0.06195655f, -0.12501714f, 0.08443959f, -0.02806637f, -0.10152134f, 0.09435624f, -0.11695120f, 
    -0.19634897f, -0.07848744f, -0.36016580f, -0.19413255f, 0.07212241f, -0.24139036f, -0.06404778f, 0.15939382f, 
    -0.07681419f, -0.02459912f, -0.23047160f, 0.18497944f, -0.07811181f, 0.01175255f, -0.18347201f, -0.10749082f, 
    0.33997679f, -0.03341691f, 0.24569808f, 0.14725442f, -0.21623941f, 0.00118269f, 0.14600724f, -0.02916083f, 
    0.09298860f, -0.04907857f, -0.01969289f, 0.27612910f, -0.13894904f, 0.05560079f, -0.20006050f, -0.14560735f, 
    -0.04678963f, -0.09177621f, -0.07279037f, -0.05438424f, -0.10067866f, 0.08143461f, 0.01204986f, -0.00305916f, 
    -0.26858535f, 0.22165106f, -0.06030193f, -0.00173877f, 0.03282762f, -0.20364805f, 0.08131364f, 0.08673204f, 
    0.01365088f, 0.03309271f, -0.10859489f, -0.07913766f, -0.29092866f, 0.36813802f, -0.24570934f, 0.16913566f, 
    0.10720440f, 0.04044679f, -0.20446223f, 0.18971220f, 0.07046199f, -0.19843319f, 0.16187721f, 0.07247345f, 
    0.08767954f, 0.38758245f, 0.18834953f, 0.09857310f, 0.07228752f, -0.00358789f, -0.02263379f, 0.04655460f, 
    -0.11635152f, 0.06885565f, 0.00323849f, 0.17950389f, -0.25693625f, -0.28064099f, 0.00101725f, -0.07112075f, 
    0.06771942f, 0.06614823f, -0.09456028f, 0.03928588f, -0.02788409f, 0.07980561f, 0.02707171f, -0.00912905f, 
    -0.07123806f, 0.13704844f, 0.25758544f, 0.32449916f, -0.08520234f, 0.02752071f, 0.14536755f, -0.05467512f, 
    -0.14268661f, -0.05763205f, 0.24280006f, 0.18570527f, -0.42431039f, 0.12570143f, -0.30457339f, 0.15244763f, 
    0.01781100f, 0.03017524f, 0.04399265f, 0.02409387f, -0.13573642f, -0.01906224f, -0.16466816f, -0.23312254f, 
    -0.27086627f, 0.14016834f, -0.28591168f, -0.04416215f, -0.13014273f, 0.05371127f, 0.07835998f, -0.07673080f, 
    -0.03766389f, 0.10764696f, -0.09634493f, 0.04228712f, -0.33690941f, -0.11761552f, -0.15817069f, 0.33524090f, 
    0.02458769f, 0.17538266f, 0.12430174f, -0.15107891f, -0.00366130f, 0.06022825f, 0.02296748f, 0.11701493f, 
    -0.21086574f, -0.11032109f, 0.04094690f, -0.32843050f, -0.09089113f, -0.00687606f, -0.00249557f, -0.25740600f, 
    0.05409951f, 0.18592867f, 0.06787544f, 0.00817857f, 0.04169404f, -0.50609386f, 0.21055028f, 0.00812741f, 
    -0.04629825f, -0.15909964f, 0.20733480f, -0.02777302f, -0.19270919f, 0.04077287f, 0.10940783f, 0.07413039f, 
    -0.47186109f, 0.16866387f, -0.36760110f, -0.10493177f, -0.05232283f, 0.23566611f, 0.18584180f, -0.14382707f, 
    -0.27926764f, -0.05288998f, -0.08423158f, -0.27281955f, -0.03716087f, 0.43993351f, -0.17894579f, -0.08396645f, 
    -0.03622595f, -0.00919942f, 0.16088541f, 0.03277117f, -0.15447222f, -0.01299475f, -0.53653288f, -0.33005437f, 
    -0.44080874f, 0.27825066f, -0.16829447f, 0.05669980f, 0.00779185f, -0.05332071f, 0.05445800f, 0.12554890f, 
    -0.07727101f, -0.21897808f, -0.10776836f, -0.10388490f, -0.12713651f, -0.05930994f, -0.26984650f, -0.06740460f, 
    -0.04670317f, 0.10190965f, -0.10079511f, -0.02530740f, -0.15454051f, 0.01645203f, -0.08272333f, 0.01561072f, 
    0.32475004f, -0.24938892f, 0.24122696f, -0.06438898f, -0.03847053f, -0.07800879f, -0.13311054f, -0.05256745f, 
    -0.17639072f, -0.00927242f, -0.23358804f, -0.23556730f, 0.02459182f, -0.28264424f, 0.11862823f, 0.03926099f, 
    -0.09117396f, 0.05157562f, -0.08759129f, -0.22126526f, 0.01551328f, -0.13059676f, -0.15442291f, -0.07726755f, 
    0.13413183f, -0.10302796f, 0.10503672f, -0.09983372f, -0.16139400f, 0.11887515f, 0.11003742f, -0.00925330f, 
    0.11195113f, 0.03316578f, -0.04158797f, -0.11474689f, 0.15464893f, -0.12722024f, 0.08037499f, 0.23163928f, 
    -0.06451833f, 0.01021524f, 0.04700201f, -0.07737646f, -0.08887272f, 0.16363023f, -0.01737606f, 0.10348982f, 
    -0.30102488f, 0.24094489f, 0.12938868f, 0.15127371f, 0.05549085f, 0.14668545f, -0.13540407f, -0.05660078f, 
    -0.02547904f, 0.07693784f, 0.12087560f, 0.03545826f, -0.08953795f, 0.17198332f, 0.28523907f, -0.02718998f, 
    0.07877913f, 0.05260203f, -0.08830417f, -0.00663089f, -0.06614867f, 0.10668467f, -0.05470241f, -0.14078455f, 
    -0.36772627f, 0.21336111f, -0.12080402f, 0.08446316f, 0.15741628f, -0.02996919f, -0.10161714f, 0.14060467f, 
    -0.04283341f, 0.02810025f, 0.04022312f, -0.32948670f, -0.13829911f, 0.30822167f, 0.15707548f, -0.32127193f, 
    -0.01033065f, 0.05439319f, 0.01107754f, 0.13137881f, 0.02353695f, -0.03183371f, -0.12157149f, 0.02207687f, 
    -0.02326569f, 0.07880782f, 0.01633916f, -0.01610967f, -0.06622548f, -0.17481835f, 0.03217796f, 0.03549787f, 
    0.06628566f, 0.11219749f, -0.09061141f, -0.17795134f, -0.17584337f, -0.01023918f, -0.02127792f, 0.08072214f, 
    0.02010483f, -0.11725467f, -0.12182965f, 0.09688446f, -0.14633368f, -0.29227403f, -0.15283613f, 0.03730064f, 
    -0.11340070f, 0.08065762f, 0.16539627f, -0.09281931f, 0.00659863f, -0.07781564f, 0.17720059f, -0.13942635f, 
    0.06739094f, 0.03227452f, -0.21690114f, -0.10353459f, -0.18121399f, -0.14289168f, -0.05193544f, -0.25648776f, 
    -0.14800908f, -0.29193032f, -0.15026742f, -0.14391704f, 0.03438625f, -0.05641610f, -0.16084777f, -0.06557918f, 
    0.05052241f, 0.35806599f, -0.06245178f, -0.17597315f, -0.04972300f, 0.11775988f, 0.03926662f, 0.14643487f, 
    -0.02679423f, -0.06099401f, 0.00388271f, -0.18206754f, -0.27851918f, -0.43813995f, 0.16418694f, 0.05597459f, 
    0.00121280f, 0.14226240f, -0.00089145f, 0.10346816f, -0.14215255f, 0.12132766f, 0.15058149f, 0.03509330f, 
    0.07877673f, 0.10541744f, -0.07647344f, 0.05861435f, -0.02524383f, -0.00235268f, -0.02591032f, 0.15201047f, 
    0.01837736f, 0.00297954f, -0.11493106f, -0.09363276f, -0.50025350f, 0.06039496f, -0.41065869f, 0.13898635f, 
    0.08188497f, 0.01892447f, 0.04428770f, -0.12850985f, 0.11855927f, 0.08293124f, -0.01721817f, 0.15263472f, 
    0.08229023f, 0.07273670f, 0.49583131f, -0.10692955f, 0.11475964f, 0.04791790f, -0.23666033f, 0.06989569f, 
    -0.06611745f, -0.08283645f, -0.12410077f, -0.13621727f, -0.25565732f, 0.07564889f, -0.06515723f, -0.21578869f, 
    0.09530749f, 0.00228209f, 0.01960443f, -0.03371449f, -0.05309279f, 0.06749020f, 0.03419601f, 0.02510971f, 
    -0.35389093f, 0.02214572f, -0.35996863f, 0.11572963f, 0.09239294f, 0.00359888f, 0.05868673f, -0.00222024f, 
    -0.05360371f, -0.04652225f, -0.03003513f, 0.01722470f, -0.18865645f, -0.19516797f, 0.04012214f, 0.15799804f, 
    -0.08356915f, -0.06727305f, -0.04703986f, -0.12586981f, 0.05863343f, 0.11471634f, 0.10139267f, -0.03092262f, 
    -0.04958635f, 0.13948329f, 0.31022415f, 0.09253261f, 0.00011090f, 0.07983980f, 0.07462635f, -0.07637825f, 
    -0.08545505f, 0.06844057f, 0.05033511f, 0.16663837f, -0.07427518f, -0.16956308f, -0.08128982f, 0.11980012f, 
    0.13684013f, 0.13601696f, 0.11018955f, -0.06274604f, -0.00929360f, -0.02417026f, 0.06641732f, 0.00565533f, 
    -0.28310454f, 0.22304726f, -0.19562927f, 0.09561504f, 0.08189946f, -0.01982046f, -0.01152786f, 0.04731483f, 
    -0.07118511f, -0.04853083f, -0.17969252f, -0.08310291f, -0.17803048f, 0.14836973f, -0.06355478f, 0.38553885f, 
    -0.12712693f, 0.05881423f, 0.00820441f, -0.17101979f, -0.02120432f, -0.00595094f, 0.02002195f, -0.00491846f, 
    -0.29355600f, -0.41698539f, -0.06624012f, -0.04870963f, 0.04197464f, -0.05596485f, 0.06175563f, -0.10421439f, 
    -0.02760661f, 0.07953741f, 0.02123936f, -0.09578292f, -0.13445111f, 0.07001696f, -0.07004593f, -0.09363923f, 
    -0.00327551f, -0.00241246f, 0.25883716f, -0.08785674f, -0.15027347f, -0.07015479f, -0.26347816f, -0.08176477f, 
    -0.11649764f, 0.10081319f, -0.19201553f, 0.00153742f, -0.27919060f, 0.06001322f, 0.21831332f, -0.01250554f, 
    0.01688616f, 0.00914549f, -0.00331820f, -0.04428099f, -0.00725500f, 0.04410116f, -0.08836895f, -0.03080169f, 
    0.01863404f, -0.01953324f, 0.05557453f, 0.00109929f, 0.06483519f, 0.05325015f, -0.01300841f, -0.05902400f, 
    -0.28040293f, -0.20293704f, 0.10048726f, -0.27736589f, 0.14551419f, 0.08804695f, -0.06417510f, -0.01675307f, 
    -0.03990367f, 0.02019643f, 0.07430335f, -0.00738473f, 0.07817595f, 0.18818480f, -0.06276488f, -0.11602613f, 
    -0.12201734f, 0.15882656f, -0.08631827f, 0.08131083f, 0.02703641f, -0.04269268f, 0.08221830f, 0.06369025f, 
    -0.06114583f, 0.02229716f, -0.09984090f, -0.06179124f, -0.18416028f, -0.04860284f, -0.04780279f, -0.03642141f, 
    -0.03508819f, -0.05258774f, 0.03014001f, -0.01745290f, 0.01292303f, -0.04428869f, 0.18357956f, -0.22845948f, 
    -0.00867297f, 0.09653293f, 0.03272562f, -0.01539787f, 0.05337828f, 0.03225394f, 0.17536882f, 0.07107635f, 
    0.09910858f, -0.12991716f, 0.25120550f, -0.25602627f, -0.05495502f, -0.03096996f, -0.06877827f, -0.03190518f, 
    0.03746537f, 0.03075227f, 0.07296169f, 0.10456652f, -0.05837055f, -0.60279167f, -0.02559893f, 0.31727746f, 
    0.13838479f, -0.24418153f, 0.03133247f, 0.17301972f, 0.08820120f, 0.04242891f, 0.09546051f, -0.03283066f, 
    0.33226237f, 0.21120986f, 0.11459521f, -0.30130291f, -0.04579676f, -0.03102305f, 0.00518306f, 0.09137155f, 
    -0.04697604f, 0.04878766f, -0.01544560f, 0.06257657f, -0.23640478f, 0.19868754f, -0.07777245f, -0.02329492f, 
    -0.13501503f, 0.15278822f, -0.01106176f, 0.02200850f, -0.02834530f, 0.08945581f, 0.00428173f, 0.04372785f, 
    0.37642321f, -0.03259879f, 0.22663671f, -0.13065746f, 0.04332597f, 0.21628405f, -0.43073684f, 0.07702283f, 
    -0.03013990f, -0.02419621f, -0.02796991f, -0.05755904f, -0.33763835f, 0.13270536f, -0.08980501f, -0.12106586f, 
    0.09890537f, -0.22352289f, 0.10062441f, -0.09466651f, -0.02837424f, 0.02783287f, -0.06404994f, 0.16778623f, 
    -0.39298037f, -0.42207366f, -0.18391190f, 0.02655490f, -0.15397730f, -0.05047892f, -0.18218502f, -0.04880552f, 
    -0.06762148f, 0.08442195f, 0.00327353f, -0.05674951f, -0.17124368f, -0.23255323f, -0.10773879f, 0.05053993f, 
    -0.09397633f, -0.21514900f, -0.18842925f, 0.17817329f, -0.01285508f, 0.06380766f, -0.06902690f, -0.07064248f, 
    0.24047482f, -0.26542908f, 0.09446009f, -0.24847004f, 0.04981333f, 0.04341292f, -0.01146950f, 0.10194416f, 
    -0.04858059f, 0.11651232f, 0.12670356f, 0.06985721f, -0.03202482f, -0.02392385f, -0.13002765f, -0.03318020f, 
    -0.06890476f, 0.05907199f, -0.34018087f, 0.17430066f, 0.04793988f, -0.00172994f, 0.09667787f, -0.05889385f, 
    0.08600470f, -0.02029891f, 0.04474902f, -0.14635469f, 0.00302388f, 0.11409593f, 0.07968939f, 0.03151950f, 
    -0.10188299f, -0.00872928f, 0.05069462f, 0.15200478f, -0.06668718f, -0.23575263f, 0.00087902f, 0.08502657f, 
    -0.05736110f, -0.26300558f, 0.08599313f, -0.00335391f, 0.01143650f, -0.04254346f, 0.04819756f, 0.03957415f, 
    0.08280930f, -0.05019129f, 0.16228533f, 0.25780413f, -0.10972489f, 0.06520839f, -0.22823031f, -0.03346441f, 
    -0.18590789f, -0.06308487f, 0.08227503f, -0.09804951f, -0.20862719f, 0.02199789f, -0.37465939f, -0.43815669f, 
    0.03181046f, 0.01044318f, -0.06520265f, 0.01739325f, -0.09913421f, 0.03454439f, 0.04437590f, 0.03957128f, 
    0.18887536f, -0.02888677f, 0.44006857f, 0.22424842f, 0.09772691f, 0.06500705f, -0.00357344f, -0.10471424f, 
    0.09411595f, -0.03489181f, 0.07013017f, 0.16082956f, 0.08511753f, -0.00443315f, 0.27182603f, 0.15512922f, 
    -0.22848457f, 0.12605776f, -0.14335608f, -0.03322744f, -0.02085485f, 0.01212126f, 0.07468893f, 0.07220528f, 
    0.18884212f, -0.36707303f, 0.38132119f, -0.43428531f, 0.13537337f, 0.01264388f, -0.16507469f, 0.15642560f, 
    -0.11487548f, 0.01788452f, -0.00164548f, -0.14409946f, -0.07785381f, 0.16343242f, -0.11912711f, 0.04410712f, 
    0.04563728f, -0.05660585f, 0.02619118f, -0.04080486f, -0.01845697f, -0.05906710f, -0.03790699f, -0.05087569f, 
    -0.22182631f, 0.00029674f, -0.22923531f, 0.17668210f, -0.04969384f, 0.06093255f, 0.02152071f, 0.06509503f, 
    -0.16327836f, 0.02977895f, 0.09245560f, 0.01069387f, -0.22172152f, 0.05162676f, -0.00552881f, 0.10114377f, 
    -0.05318495f, 0.04893420f, -0.02459282f, 0.07162238f, -0.22934043f, -0.00926075f, -0.00739356f, 0.16819055f, 
    -0.73717773f, 0.11138824f, -0.40393913f, 0.37730443f, 0.12003638f, 0.07104228f, 0.10385965f, -0.05862514f, 
    -0.09421463f, -0.03099809f, 0.07032096f, -0.06035301f, -0.15061416f, -0.08325734f, 0.22297058f, -0.00723972f, 
    -0.22290042f, 0.06650224f, -0.06573510f, -0.03703370f, 0.01735307f, 0.06183897f, -0.07865413f, -0.05157730f, 
    -0.06904779f, 0.07644952f, 0.01064276f, 0.27023399f, -0.01367429f, 0.12174451f, -0.01439963f, -0.06267830f, 
    -0.17504580f, 0.19119041f, -0.10462744f, 0.07464608f, -0.41559985f, -0.27162108f, -0.38537860f, 0.06282420f, 
    -0.01217718f, -0.10181800f, 0.01670046f, -0.03965364f, -0.01302393f, 0.08165680f, 0.05359576f, 0.15028949f, 
    0.43928874f, 0.11484270f, 0.10878088f, 0.00960641f, 0.09305667f, -0.03634604f, -0.00337502f, 0.06507949f, 
    -0.05822770f, 0.04375998f, -0.03556987f, -0.09644840f, -0.38448483f, 0.13274708f, -0.43038887f, 0.40353733f, 
    0.05539553f, 0.24176992f, -0.01071348f, 0.06585355f, 0.02757302f, 0.10711706f, 0.06853665f, 0.00932442f, 
    0.41076523f, 0.12023699f, 0.52010286f, -0.00693296f, 0.02286613f, -0.08696402f, -0.01139215f, -0.00270240f, 
    -0.16505377f, -0.08558042f, -0.04547360f, -0.05747657f, 0.04057665f, -0.20234282f, 0.29950383f, -0.02911574f, 
    -0.04150737f, 0.01219318f, 0.14692198f, -0.22292137f, -0.06940351f, 0.07852001f, -0.15440007f, 0.10006703f, 
    -0.28398424f, -0.00583034f, -0.10336836f, 0.21124697f, 0.08188664f, -0.00015161f, 0.13335963f, -0.08843672f, 
    0.01078099f, 0.06297646f, 0.27801910f, 0.09625110f, -0.17065421f, 0.03652754f, -0.24274565f, 0.19248855f, 
    0.12084193f, 0.00920281f, -0.00449725f, -0.03606943f, 0.02855064f, -0.01322340f, 0.17238982f, 0.18448979f, 
    -0.08972440f, 0.12182193f, 0.00053596f, 0.08186443f, 0.09703866f, 0.06434247f, -0.05937983f, 0.01919960f, 
    0.01179114f, 0.10142662f, 0.18010634f, -0.10343279f, 0.35481820f, 0.06488919f, 0.05488215f, -0.18321317f, 
    -0.02391069f, 0.10086041f, -0.04501878f, -0.00560868f, 0.00675975f, 0.06739920f, 0.05346671f, 0.03657404f, 
    0.04239047f, 0.16317362f, -0.00540482f, -0.14520611f, -0.04265848f, 0.06753122f, -0.01789550f, 0.00580306f, 
    0.11728473f, 0.10206769f, 0.20474836f, 0.09882683f, 0.03537510f, 0.10134539f, 0.10936248f, -0.06083935f, 
    -0.01699629f, 0.08167620f, 0.05628027f, -0.06957515f, -0.05211765f, 0.02961238f, -0.06197738f, -0.01603155f, 
    0.13916703f, -0.12873897f, 0.06668746f, -0.69330817f, -0.06098478f, -0.28096557f, 0.12446757f, 0.02039809f, 
    -0.10990675f, 0.07714926f, 0.00747407f, -0.00038379f, -0.15354043f, -0.03358750f, 0.09063312f, -0.09190668f, 
    0.03943357f, 0.07654387f, 0.03243431f, -0.14032756f, -0.14939769f, -0.18710145f, -0.03446211f, 0.02703043f, 
    -0.21954547f, 0.45406494f, -0.45177087f, 0.38272351f, -0.13731475f, -0.05291031f, 0.06487906f, 0.01644655f, 
    0.11715593f, -0.00008278f, -0.00028714f, 0.08505685f, -0.11012783f, -0.10537505f, -0.25330999f, 0.12768665f, 
    0.04476788f, -0.14499736f, 0.03405269f, 0.03886968f, 0.01438557f, -0.04417001f, -0.10283698f, -0.01781862f, 
    -0.05471539f, -0.08181531f, -0.08432764f, 0.07443083f, 0.01763405f, -0.09149871f, 0.09703791f, -0.01447075f, 
    0.01089735f, 0.03702032f, -0.05218718f, -0.05723267f, 0.15660742f, -0.11977714f, -0.00843738f, 0.12157308f, 
    0.10754458f, 0.05918210f, 0.05880653f, -0.08763253f, 0.09658773f, 0.00933752f, 0.01841347f, 0.04468137f, 
    -0.00203225f, -0.10294154f, 0.04647963f, -0.11119584f, -0.03689984f, -0.04604447f, 0.01386179f, 0.00619052f, 
    0.01383864f, -0.11905854f, -0.08047568f, -0.07328869f, -0.21494260f, -0.03772822f, 0.12527452f, -0.03123768f, 
    -0.10670212f, 0.03010584f, -0.14054926f, 0.07450230f, -0.16455463f, 0.10095330f, 0.06569695f, -0.02230476f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.16131245f, 0.10374123f, 0.09089299f, -0.09067019f, -0.08461097f, 0.07907231f, 0.02905286f, -0.07514678f, 
    0.05464952f, 0.04482288f, 0.05671510f, -0.02126213f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
