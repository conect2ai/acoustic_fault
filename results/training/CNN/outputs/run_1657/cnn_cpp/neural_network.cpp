#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.06856593f, -0.61126786f, -0.20462446f, -0.81105649f, -0.42897797f, -0.74744964f, -0.12787487f, -0.53668213f, 
    -0.81294715f, 0.44170383f, 0.67565137f, -0.17177935f, -0.44194314f, -0.15247880f, 0.13414210f, -0.20607060f, 
    0.42939305f, -0.19224501f, -0.07421044f, -0.70748633f, -0.69223279f, -0.35796586f, -0.48934591f, 0.06410307f, 
    -0.53029400f, -0.41008365f, -0.64563668f, -1.50472283f, 0.50798160f, 0.79063916f, -0.35272932f, 0.06521190f, 
    0.22264975f, 0.01913180f, -0.56906521f, -0.63526344f, 0.63201964f, 0.60636985f, 0.39785632f, 0.50631726f, 
    -0.09349027f, -0.29022616f, 0.12528023f, -0.21882486f, 0.16374317f, 0.31187320f, 0.89033264f, 0.06240148f, 
    -0.80815327f, 0.40914491f, -0.35668448f, -0.32799965f, 0.52109843f, -0.14354445f, -0.70921236f, 0.25437856f, 
    0.57770020f, -0.52123350f, 0.44747484f, 0.44657636f, 0.15356310f, -0.05382441f, -0.05159647f, -0.39681455f, 
    0.54909265f, -0.33628005f, 0.22467653f, 0.29834023f, 0.02762739f, -0.54560918f, 0.32784054f, 0.28291228f, 
    -0.22124933f, 0.55681771f, 0.10771780f, -0.66653657f, -0.06422579f, -0.13553293f, 0.16733928f, 0.27615735f, 
    0.35882258f, -1.19612503f, -0.80611485f, -0.80356246f, 0.35708228f, 0.34597877f, 0.25781906f, -0.40555108f, 
    -0.66296405f, -0.54622471f, -0.53240335f, -0.84390271f, -0.55960435f, -0.29060069f, -1.38532150f, -0.84591657f, 
    0.32160237f, 0.69975770f, 0.07687265f, -0.97828698f, 1.00976527f, -0.04769913f, -0.28605628f, -0.05080538f, 
    0.28112921f, -0.41856360f, -0.32774991f, -0.14860274f, 0.68553710f, 0.64176488f, 0.83661741f, -0.99472678f, 
    -0.76526803f, -0.00436730f, -0.12423494f, -0.15044323f, 0.01134826f, 1.30673623f, -1.08590043f, -0.61334431f, 
    -0.81127262f, -0.40052375f, -0.37368107f, 0.14800170f, -0.36371505f, 0.38975292f, -1.08013022f, -0.79973656f, 
    0.80903524f, 0.95769465f, 0.66147745f, -0.84241694f, -0.10946044f, 0.08052123f, -0.28100780f, -1.16967964f, 
    -0.10675774f, 0.66315448f, 0.46537507f, -0.84748375f, -0.28144908f, -0.21035030f, -0.47533354f, -0.15919916f, 
    0.76881009f, 0.04332738f, -0.04757167f, 0.02465704f, 0.36677051f, 0.28745550f, -0.18717098f, 0.04081994f, 
    -0.54383749f, 0.15679830f, -0.18222499f, 0.27880341f, -0.53848159f, 0.16541329f, 0.61486942f, -0.16689238f, 
    -0.06800372f, 0.43626645f, -0.39436662f, 0.14722475f, 0.76734257f, -1.08200324f, -0.80109519f, 0.09546041f, 
    -0.66885918f, -0.41033268f, -0.34083149f, 0.60556519f, -0.07487807f, -0.76603496f, -0.60357827f, -0.57687908f, 
    -0.45521212f, -0.47544387f, -0.47545743f, -0.15710235f, 0.30270326f, -0.40562233f, 0.28980693f, -0.21745621f, 
    0.60779995f, -0.46954361f, -0.37956911f, 0.40986058f, 0.22622706f, -0.19177489f, 0.18294239f, 0.14745444f, 
    0.26010928f, -0.37669992f, 0.12470852f, -0.04815057f, 0.00281130f, 0.03819859f, 0.16186720f, 1.29965627f, 
    -1.27327585f, -0.77216935f, -0.69882089f, 0.48903117f, -0.03513971f, -0.34720513f, -0.43948081f, -1.07241023f, 
    0.03811825f, -0.58740705f, 0.78227639f, -0.09704473f, -0.57928294f, 0.66548353f, 0.13341086f, 0.13524869f, 
    -0.12021109f, -1.04760575f, -1.13407278f, 0.79552275f, 0.47143036f, 0.30674151f, 0.09693620f, 0.02812784f, 
    -0.14303976f, -1.18764126f, 0.25937146f, -0.67651379f, 0.08778320f, -0.72852516f, -1.00307357f, -0.28144717f, 
    -0.10855588f, 0.12583382f, 0.77058786f, -0.27304456f, -0.04154193f, -0.48579922f, -0.65662062f, 0.19471917f, 
    0.04310927f, 0.04016285f, 0.58359146f, -0.48417720f, -1.72992599f, -0.07805624f, 0.21247633f, 0.54925388f, 
    0.55318648f, 0.55261534f, -0.46941683f, 0.05246634f, 0.66284806f, -0.63393193f, -0.83030635f, 0.99332923f, 
    -0.25034428f, -0.42071417f, -0.48816329f, 0.30637419f, 0.25100511f, 0.04417045f, 0.14845397f, 0.60365057f, 
    -0.46891472f, -0.84673947f, -0.77397138f, 0.58378798f, 0.22823612f, 0.39223540f, 1.02323663f, -0.01966555f, 
    -0.10203964f, 0.25514188f, 0.12761426f, -0.53239709f, -0.45917627f, -0.22226658f, -0.18258369f, 0.94317895f, 
    -0.34289160f, -0.31627393f, 0.82024711f, -0.37504590f, 0.14494352f, -0.44349796f, 0.61403149f, -0.58339530f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.39981985f, 0.39338893f, -0.27913743f, 0.14401072f, -0.29968271f, 0.22644092f, 0.54114097f, -0.18944572f, 
    -0.14956412f, -0.27827084f, 0.10368383f, 0.08736148f, 0.14285342f, 0.39096218f, 0.04895334f, 0.26597360f, 
    0.00447691f, 0.03049245f, 0.01864355f, -0.00144225f, 0.11439285f, 0.24015968f, -0.10489181f, 0.44727966f, 
    0.29825240f, -0.38386029f, 0.09370241f, 0.17029282f, 0.53724343f, -0.10449611f, 0.00960613f, 0.23266825f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.30114058f, 0.24781239f, 0.28107041f, -0.46542570f, -0.06886300f, 0.14015272f, 0.14629237f, 0.12882948f, 
    0.00010051f, 0.13399367f, 0.01489007f, -0.02818720f, -0.02659357f, -0.12238716f, -0.03833763f, -0.04908636f, 
    -0.12090091f, -0.00842688f, 0.18564656f, 0.21827738f, -0.44421583f, -0.31603742f, -0.26960638f, -0.12096792f, 
    -0.38438097f, 0.03398579f, -0.02367104f, -0.07834630f, -0.03172844f, 0.04281144f, 0.02464406f, 0.00123164f, 
    -0.01986971f, 0.01929546f, 0.02192950f, -0.10371824f, -0.01640312f, -0.16171682f, -0.13286196f, -0.04734120f, 
    0.29102224f, 0.15795408f, 0.19109279f, -0.14867313f, -0.10178824f, 0.20342496f, 0.16103920f, 0.18371686f, 
    -0.05577693f, 0.15428831f, -0.01008949f, -0.03322310f, -0.01947656f, -0.08560061f, -0.16965826f, 0.07226428f, 
    -0.12793711f, -0.00986558f, 0.08627237f, -0.03672577f, -0.04951264f, 0.02846410f, 0.25800487f, -0.24191958f, 
    0.16735065f, -0.25885797f, -0.11642660f, 0.02339389f, 0.15972532f, 0.00519087f, 0.02796247f, 0.01042294f, 
    -0.04929820f, -0.03430808f, -0.02161831f, 0.11646415f, 0.00377389f, -0.00897691f, -0.13594732f, 0.06840084f, 
    -0.09385433f, -0.10948393f, -0.16326457f, -0.01851555f, 0.03453481f, 0.10933515f, 0.04456610f, 0.03106839f, 
    0.02911711f, 0.01460453f, 0.05340986f, 0.03928811f, 0.10896941f, 0.12005389f, 0.09560251f, -0.15711235f, 
    -0.02314158f, -0.04548148f, 0.01717276f, -0.01231050f, -0.20666718f, -0.24353294f, -0.19242072f, -0.01117825f, 
    -0.14956847f, 0.03465284f, -0.04522584f, -0.06158352f, 0.00899061f, -0.00143411f, 0.01351803f, 0.02975152f, 
    0.03135355f, -0.01967821f, 0.05110568f, -0.01323541f, 0.10086855f, -0.21338870f, -0.12423765f, -0.02983858f, 
    -0.40753585f, -0.41236606f, 0.25569424f, 0.02746838f, -0.02586432f, -0.07510331f, -0.03646592f, 0.08915872f, 
    0.04338903f, -0.05882690f, -0.15693590f, -0.15583579f, -0.10590195f, -0.17636436f, -0.13336530f, -0.08782630f, 
    -0.13227458f, 0.00593860f, -0.09367290f, -0.02297485f, 0.01962587f, -0.09896808f, 0.04167954f, 0.08502480f, 
    0.08832200f, 0.02070780f, 0.00503620f, 0.01460402f, 0.03912685f, 0.04679593f, -0.26427066f, -0.01149381f, 
    0.11450556f, -0.13880579f, -0.05569569f, -0.02751999f, 0.04268363f, 0.01261570f, -0.01301755f, -0.07047439f, 
    0.02487819f, 0.03343967f, 0.06631120f, 0.03141895f, -0.00853813f, -0.11379879f, -0.08194100f, 0.12219994f, 
    0.07158258f, -0.01179049f, -0.01098151f, 0.13343786f, -0.01715485f, -0.08179832f, -0.04772815f, -0.03584655f, 
    0.00283096f, -0.00946722f, -0.12605916f, -0.13510700f, 0.40192002f, 0.09156087f, 0.01019483f, -0.20843369f, 
    -0.06560609f, 0.10967430f, 0.16558576f, 0.17921352f, 0.01594567f, 0.08454162f, 0.03556826f, 0.02664820f, 
    0.06243584f, -0.02060334f, 0.07495781f, 0.02377041f, 0.04796979f, 0.10267911f, -0.03955518f, -0.03241868f, 
    0.46603423f, 0.41602197f, -0.10904977f, -0.47143501f, -0.15758155f, 0.13646941f, -0.00975746f, -0.11431406f, 
    0.03325936f, -0.00018568f, 0.11942294f, 0.00308984f, 0.00185362f, 0.03486029f, 0.06316433f, 0.03299430f, 
    -0.05637197f, -0.03074149f, -0.01084600f, 0.10553657f, -0.40717313f, 0.02060199f, 0.24093653f, 0.11197180f, 
    -0.01317829f, -0.08284663f, -0.13684972f, -0.07287806f, 0.03520359f, -0.04898063f, 0.02627546f, -0.04085485f, 
    -0.00033860f, -0.03505924f, 0.07095118f, -0.10628976f, 0.05978703f, -0.15614054f, -0.25001931f, -0.07719098f, 
    -0.64557588f, 0.52133507f, 0.45283613f, -0.33031809f, -0.11002122f, 0.00564050f, -0.13680480f, -0.23999386f, 
    -0.00410363f, 0.05127933f, 0.09010103f, 0.01452693f, -0.01492330f, 0.10633682f, 0.07232960f, 0.17050657f, 
    0.19259763f, -0.10422553f, 0.01987980f, -0.03860623f, 0.17307863f, 0.27328393f, 0.06285398f, -0.49525201f, 
    -0.19444449f, 0.05994654f, -0.07856507f, 0.01394532f, -0.17257179f, -0.01260745f, -0.06337457f, 0.05028601f, 
    -0.03723309f, -0.01027956f, -0.08311599f, -0.05692759f, -0.00729340f, 0.05900547f, 0.01766543f, 0.05303059f, 
    0.63562644f, 0.20909069f, -0.22577858f, -0.39187226f, -0.00087834f, -0.23469673f, -0.07068681f, 0.03207770f, 
    -0.03423994f, 0.17369485f, -0.04229599f, -0.07689241f, -0.19875638f, 0.05306489f, -0.14304332f, -0.02762387f, 
    0.11492494f, 0.06848984f, -0.08994168f, 0.04209364f, 0.25208673f, 0.19472282f, -0.00345971f, -0.55636203f, 
    0.00949900f, -0.13412061f, 0.07959342f, -0.09212421f, -0.02717368f, -0.01562969f, 0.02364049f, -0.05410834f, 
    -0.03788996f, -0.30247945f, -0.11147363f, 0.00278744f, -0.07707351f, 0.07842097f, -0.08413545f, 0.02858397f, 
    -0.18597984f, -0.12875061f, -0.29987258f, -0.07120312f, -0.19747618f, 0.05787986f, 0.01927990f, 0.01191616f, 
    0.05632494f, 0.08497118f, 0.00089160f, 0.09148388f, 0.02281788f, -0.01412315f, 0.06234447f, -0.11601658f, 
    -0.14991708f, 0.22935428f, 0.03133063f, 0.06172223f, -0.07716995f, -0.10082570f, 0.10129748f, 0.03187155f, 
    0.08653017f, 0.00326792f, -0.08473967f, 0.03818272f, 0.03971361f, 0.00044904f, -0.08722804f, -0.11556576f, 
    -0.14709561f, -0.21429805f, -0.08414786f, 0.06246061f, -0.14459184f, 0.02305086f, -0.00687195f, -0.11030943f, 
    -0.06814080f, 0.30883414f, 0.38043249f, -0.37940773f, 0.12606172f, -0.29809788f, 0.00270727f, -0.05646095f, 
    -0.16736303f, -0.11431934f, 0.01823994f, -0.11026355f, -0.03250698f, -0.00925056f, 0.00917562f, -0.13534582f, 
    0.03521954f, 0.08837623f, 0.07447399f, -0.08060157f, 0.09183524f, 0.17681593f, 0.21555521f, -0.29997969f, 
    -0.25033891f, -0.03146076f, -0.08280680f, -0.06915594f, -0.04317392f, 0.02647293f, -0.06035019f, -0.05041336f, 
    -0.02265752f, -0.00885312f, -0.01270515f, 0.04908808f, -0.07895121f, 0.10845011f, 0.06915122f, 0.10139578f, 
    -0.07680535f, -0.02836119f, 0.01945380f, 0.03361221f, 0.04461577f, 0.03906365f, -0.01096565f, 0.02501728f, 
    -0.02150650f, 0.02835620f, -0.21899913f, -0.10339294f, 0.01571175f, -0.23416367f, -0.23744914f, -0.18516092f, 
    -0.08865177f, -0.23488788f, -0.12619080f, 0.03152420f, -0.07670076f, -0.06459138f, 0.00926620f, 0.03620113f, 
    -0.01029895f, 0.03543747f, -0.04531372f, 0.02266528f, 0.05417203f, -0.01524736f, 0.01099020f, -0.00840695f, 
    0.01953031f, -0.02054871f, -0.06739143f, -0.14594631f, -0.18955280f, -0.05835242f, 0.01605512f, -0.03161633f, 
    -0.13455829f, 0.31085941f, 0.28122139f, -0.01478749f, -0.63928223f, -0.25658903f, -0.02770533f, 0.01178669f, 
    -0.09547046f, 0.03567010f, -0.00971429f, -0.02303601f, -0.09773980f, 0.06892139f, 0.08733866f, -0.07304607f, 
    0.12869407f, 0.05497464f, -0.05124407f, -0.03120725f, 0.34359029f, 0.22569382f, -0.11937618f, -0.09830223f, 
    0.02205108f, -0.05398761f, 0.13885029f, 0.05596377f, -0.11088228f, -0.24496078f, 0.03565827f, -0.27651066f, 
    -0.09631940f, -0.04470906f, 0.02665522f, -0.11160075f, -0.00338951f, -0.05040682f, -0.04499450f, -0.02199676f, 
    0.25981489f, -0.10206613f, -0.43500224f, 0.02611720f, 0.06717680f, 0.13464709f, 0.14968030f, 0.11100456f, 
    -0.11656461f, 0.08506549f, -0.06727508f, -0.00715775f, -0.14322411f, 0.05235040f, -0.05983641f, 0.05851517f, 
    0.08354103f, 0.05107725f, 0.00613566f, 0.08673221f, 0.34647179f, 0.35021365f, -0.04985015f, -0.26984316f, 
    -0.01413161f, 0.04850072f, 0.15524825f, 0.04046109f, -0.03323849f, 0.17023279f, -0.02909987f, -0.05686861f, 
    0.05849012f, 0.01067975f, 0.05960570f, -0.05312373f, -0.06210787f, -0.04135584f, -0.25449100f, -0.00111267f, 
    0.09119095f, 0.03454783f, 0.08805208f, -0.20672061f, -0.04223893f, -0.28537577f, -0.17570870f, -0.24149916f, 
    -0.12388007f, -0.25967729f, 0.00348795f, 0.02514954f, -0.00154077f, 0.02436844f, -0.09377530f, -0.06861100f, 
    0.03177618f, -0.00807050f, -0.14860931f, -0.16565117f, 0.24833257f, -0.06124705f, -0.14255740f, -0.09999689f, 
    0.10636061f, 0.21153714f, 0.05551671f, 0.25848445f, -0.08669565f, 0.00120552f, -0.09732518f, -0.03834165f, 
    -0.10111450f, 0.10922185f, 0.03615564f, 0.03061483f, 0.06580546f, 0.06039994f, 0.02460522f, 0.01054615f, 
    0.07078864f, 0.00667850f, -0.43744704f, 0.03524325f, -0.04198311f, -0.09378988f, 0.04534652f, -0.02199040f, 
    -0.26720262f, -0.12239686f, -0.20428991f, -0.09081393f, 0.08408408f, 0.00424373f, 0.01145229f, -0.11869489f, 
    0.04977727f, -0.29640752f, -0.04882472f, 0.01337642f, 0.23769464f, 0.19357853f, 0.06346693f, -0.14311598f, 
    -0.01847700f, -0.10748314f, 0.08641008f, -0.17364575f, -0.12485860f, 0.03471358f, 0.05496226f, 0.04365867f, 
    0.06763002f, -0.06051238f, -0.02984002f, -0.01686981f, 0.00790361f, 0.03674055f, -0.07881330f, -0.18698445f, 
    -0.20292996f, 0.01881210f, -0.51868039f, 0.32890004f, 0.15486690f, 0.00580676f, -0.00472368f, -0.02763337f, 
    0.05372371f, 0.08875564f, -0.01990166f, -0.02233745f, 0.04592020f, 0.04780601f, 0.04508137f, 0.06377452f, 
    0.17651618f, 0.04374747f, -0.20658848f, 0.12565482f, -0.55732203f, -0.37769178f, -0.51139420f, 0.01425748f, 
    -0.07887837f, -0.02405081f, -0.01438404f, -0.00536812f, 0.03932207f, 0.13476878f, -0.13434349f, 0.16057862f, 
    -0.05327619f, -0.11519170f, -0.00795208f, -0.11907652f, -0.17666201f, -0.05986835f, -0.01013199f, -0.01013799f, 
    0.06404953f, 0.23869222f, -0.08471184f, -0.01326542f, 0.03731007f, 0.22758888f, -0.11974951f, -0.07966328f, 
    0.12930217f, -0.04505938f, -0.02873312f, 0.02435977f, 0.08642951f, 0.02919911f, 0.06894991f, -0.10256893f, 
    -0.02828301f, 0.19818927f, -0.22154005f, -0.11268370f, 0.12230119f, -0.04914703f, 0.13762999f, -0.13682455f, 
    0.02354926f, 0.03368525f, -0.02679905f, -0.06098046f, -0.01043557f, -0.03442591f, -0.03325947f, -0.05170637f, 
    0.01080018f, 0.06702170f, 0.00727332f, -0.07527134f, 0.18364772f, -0.07251123f, 0.13527223f, 0.03257593f, 
    0.05789587f, 0.40586963f, 0.17386143f, 0.12501833f, 0.10972214f, 0.01794362f, -0.00273657f, 0.09640011f, 
    0.11718252f, 0.01325861f, -0.02736250f, 0.02854626f, 0.04686658f, -0.02366656f, -0.02652130f, -0.12914419f, 
    -0.02556294f, 0.04852167f, -0.02736168f, 0.00546995f, -0.53561562f, -0.50040895f, 0.01945416f, -0.49442136f, 
    0.26659697f, 0.09747863f, -0.09581477f, 0.07796603f, -0.15947825f, 0.02077705f, 0.09504232f, 0.09088214f, 
    -0.02456467f, -0.09032602f, 0.14373717f, 0.12823032f, -0.08334696f, 0.07777999f, 0.00934108f, -0.31766421f, 
    0.23120226f, 0.14974521f, -0.00305409f, 0.20118950f, 0.18914194f, -0.07930091f, -0.04179643f, -0.01598416f, 
    -0.07497960f, -0.07769626f, -0.03580423f, 0.01132989f, -0.02726859f, -0.02496512f, 0.04934221f, 0.08803969f, 
    0.06819674f, -0.17111255f, 0.05422899f, -0.02995167f, 0.11416257f, -0.01590755f, 0.13529728f, -0.03375636f, 
    -0.04733751f, -0.10514580f, 0.00616462f, -0.19840196f, -0.01063955f, -0.01486117f, 0.01485570f, 0.02808813f, 
    -0.02252786f, 0.05101069f, 0.07219262f, -0.11799587f, 0.24592985f, -0.25614697f, 0.10484575f, 0.03722898f, 
    0.03172304f, -0.15151604f, 0.05855660f, 0.06695759f, 0.14990626f, -0.03120243f, -0.00797465f, -0.03823927f, 
    -0.04386229f, 0.03463253f, -0.03913146f, 0.16542973f, -0.00210772f, -0.01217395f, 0.00694915f, -0.01065985f, 
    -0.01286664f, 0.04299382f, 0.10066593f, -0.00634784f, -0.05381344f, 0.01021276f, 0.09308148f, 0.07105455f, 
    0.06710178f, -0.03840617f, -0.06607499f, 0.07214872f, -0.04507806f, -0.01066373f, 0.02874511f, 0.04389028f, 
    -0.33771688f, -0.04914202f, -0.08696894f, -0.02955854f, 0.01815082f, -0.21275458f, 0.02809358f, -0.06882314f, 
    0.01132264f, -0.10214388f, 0.00760015f, -0.10433167f, -0.02006406f, 0.01112225f, 0.12919362f, -0.18851727f, 
    0.03514594f, 0.13648202f, -0.13346796f, -0.09148597f, 0.01670872f, 0.18517593f, 0.05642953f, -0.04227174f, 
    -0.08976918f, -0.13994491f, 0.02758577f, -0.00947573f, 0.27898809f, 0.29905704f, 0.42153800f, 0.10376047f, 
    -0.27510339f, 0.05374998f, -0.13694951f, 0.05077334f, 0.12065151f, -0.14269502f, 0.03899026f, 0.02883590f, 
    -0.06922369f, -0.22628510f, 0.01889061f, 0.21654624f, 0.04881826f, -0.30204356f, 0.03091794f, -0.05353685f, 
    -0.33594844f, 0.00713209f, -0.21642314f, 0.41407773f, 0.11500300f, -0.03373677f, 0.24653774f, -0.02716882f, 
    0.29714644f, -0.10764870f, -0.05811197f, -0.02501863f, -0.02516473f, 0.02444428f, 0.03186772f, -0.00560307f, 
    -0.00707811f, 0.04968180f, -0.15506509f, -0.00493268f, -0.54183358f, -0.37367177f, 0.13004740f, -0.17015064f, 
    -0.00658586f, 0.00616002f, -0.01949890f, 0.01590553f, -0.15153819f, -0.03931816f, 0.11893264f, 0.12310434f, 
    -0.11597256f, -0.04886405f, 0.03683965f, 0.14248918f, -0.14645614f, -0.15447809f, -0.13484573f, -0.02554354f, 
    0.53520793f, -0.18762542f, 0.13957115f, -0.11336622f, -0.17464860f, -0.06587286f, -0.06583941f, -0.12649523f, 
    -0.12908097f, -0.04150658f, -0.05579393f, 0.01794181f, 0.01367229f, 0.00599305f, 0.00713584f, 0.10122523f, 
    0.09949280f, -0.09467818f, 0.08254173f, 0.03195089f, -0.07858958f, 0.07430114f, -0.13052668f, 0.11214467f, 
    -0.15843037f, -0.14699511f, -0.10756864f, 0.10969784f, -0.18499924f, 0.27232432f, 0.04322382f, -0.03840865f, 
    0.09109625f, -0.08894037f, 0.11333443f, 0.07623868f, 0.02357710f, 0.07160129f, -0.04482623f, 0.02292893f, 
    0.57862616f, -0.19035490f, 0.11061753f, -0.21993622f, 0.20730411f, 0.05285264f, 0.05704599f, 0.12171693f, 
    0.26871014f, -0.18988167f, 0.29579914f, -0.14913136f, -0.01109322f, 0.03949465f, -0.13457371f, 0.08024995f, 
    -0.17137344f, -0.03510780f, 0.05505266f, -0.25319663f, -0.33493009f, 0.16409990f, -0.20555812f, 0.08338037f, 
    0.10724907f, 0.21520126f, -0.06081761f, 0.08554128f, 0.05029764f, -0.03337307f, 0.04259299f, 0.03087856f, 
    0.08242876f, -0.11841837f, 0.11362919f, -0.17551814f, 0.09936803f, -0.05455559f, -0.26746318f, -0.10267840f, 
    0.55221897f, 0.12147147f, 0.09257469f, 0.17134532f, 0.14447381f, -0.08069279f, -0.03738978f, 0.03894204f, 
    -0.01941842f, 0.00663542f, -0.02928746f, 0.01134528f, 0.01805986f, -0.01964166f, 0.01583221f, -0.00277844f, 
    -0.05619301f, -0.01428931f, 0.11309734f, -0.05683092f, 0.03477759f, 0.00691534f, 0.22608100f, 0.11577328f, 
    0.07745917f, -0.08877800f, 0.04460118f, 0.01349751f, -0.11985482f, 0.02577172f, 0.06912015f, -0.05039762f, 
    -0.00043554f, 0.00170693f, -0.07190926f, -0.24989198f, -0.04693612f, 0.01026765f, -0.00578715f, -0.03249615f, 
    -0.33914834f, -0.07028659f, -0.43413082f, -0.44139639f, -0.25533929f, 0.03119324f, -0.09128603f, -0.16715997f, 
    0.07533900f, -0.13194652f, -0.01892886f, 0.04613367f, 0.01630888f, -0.06818845f, -0.04274585f, -0.10907501f, 
    -0.14744015f, 0.05511392f, -0.25144073f, -0.26378629f, -0.00429616f, 0.07915875f, -0.16524723f, -0.05625302f, 
    -0.33888024f, -0.06880592f, -0.03327980f, -0.03988549f, -0.13640304f, 0.16210693f, 0.02396006f, -0.02256680f, 
    0.05529466f, 0.04580413f, 0.04220147f, -0.08454829f, -0.09170113f, -0.02453967f, -0.21426332f, -0.12134147f, 
    0.11142196f, 0.09633499f, 0.02790941f, -0.02030150f, 0.07911304f, -0.08987036f, -0.00721450f, 0.06126430f, 
    -0.03749514f, 0.08151079f, 0.05681392f, 0.11680784f, 0.11304262f, 0.09172703f, 0.00785485f, -0.15392038f, 
    0.04104584f, -0.04713748f, -0.02436291f, -0.08327688f, 0.01024923f, 0.09262874f, 0.10288528f, 0.02061483f, 
    0.13656846f, 0.01882327f, -0.02912037f, -0.04549193f, -0.04050533f, -0.03512429f, 0.04905667f, 0.00744119f, 
    0.03783031f, 0.01285233f, 0.00987337f, -0.12067403f, 0.09770586f, 0.09399839f, 0.04613206f, -0.03909616f, 
    -0.88250357f, -0.04177006f, 0.23115906f, 0.08078104f, -0.57169038f, 0.13362168f, 0.14006776f, -0.14954224f, 
    -0.26822042f, 0.03226421f, -0.10666653f, 0.02581298f, -0.03696763f, 0.06401105f, -0.05062406f, -0.08694890f, 
    -0.24979739f, -0.08360505f, -0.12224106f, -0.07182728f, -0.09917446f, -0.00634215f, -0.26651663f, -0.03727351f, 
    -0.04770762f, 0.12653770f, 0.00784294f, 0.12831506f, 0.22848491f, -0.15233062f, -0.09148084f, 0.06689763f, 
    0.09050123f, 0.01990315f, 0.06839465f, 0.00809520f, -0.05022305f, 0.08274621f, 0.01203415f, 0.02461051f, 
    0.29847741f, -0.10536706f, -0.19123746f, -0.02361619f, -0.30089509f, 0.03209521f, -0.05667933f, 0.11477232f, 
    -0.11863044f, -0.08313204f, 0.19405937f, -0.15067874f, 0.06690689f, -0.16181354f, -0.06512857f, 0.00168524f, 
    -0.03085454f, -0.15118261f, -0.05120879f, 0.06381869f, -0.09791370f, 0.30743706f, 0.04189974f, 0.58074564f, 
    -0.01912135f, -0.04403209f, 0.01344506f, -0.38650146f, -0.03161819f, -0.08900056f, 0.01706927f, 0.03547376f, 
    -0.01284557f, 0.00593193f, -0.02759511f, -0.05866209f, 0.06237378f, 0.02368419f, -0.19165394f, 0.02903726f, 
    -0.16850483f, -0.03862349f, -0.00640278f, -0.08808190f, -0.00394476f, -0.00306584f, 0.16150849f, -0.14792705f, 
    -0.34638634f, 0.12604861f, 0.00845888f, -0.02750714f, 0.10858755f, 0.15677868f, 0.01503910f, -0.00978297f, 
    -0.02558306f, -0.06682076f, 0.12523723f, -0.06094582f, -0.29424876f, -0.20970853f, -0.32405683f, -0.01656113f, 
    -0.09185374f, -0.14218768f, 0.09389605f, 0.11961921f, -0.23783126f, -0.00167306f, -0.02838635f, -0.21904452f, 
    0.13397390f, -0.24158627f, -0.20373011f, -0.00182530f, -0.02604908f, 0.01753846f, -0.04706397f, -0.02402532f, 
    0.74880588f, 0.04644484f, -0.25603658f, 0.19381407f, -0.20924200f, 0.12184787f, 0.05765662f, 0.08514822f, 
    0.18256140f, -0.08817444f, 0.13467132f, -0.09600174f, 0.09209018f, 0.02267311f, 0.00368687f, 0.07559703f, 
    0.11594021f, -0.08469819f, 0.16374859f, 0.17777908f, -0.24530634f, -0.05685990f, -0.03506761f, -0.14295053f, 
    -0.01819780f, 0.06078566f, -0.17989935f, -0.36753416f, 0.16470896f, -0.09529140f, -0.13456371f, -0.09501559f, 
    0.08447248f, 0.18265641f, 0.06500119f, -0.02818080f, -0.06083180f, 0.01150495f, 0.16196595f, -0.03245295f, 
    1.02267551f, 0.07249179f, -0.17310268f, 0.29172882f, -0.01031757f, -0.06452903f, -0.05215820f, 0.00986822f, 
    -0.05263767f, -0.10088925f, -0.05160379f, 0.01074990f, 0.02503600f, 0.06793173f, 0.02084067f, 0.09301828f, 
    -0.29143152f, -0.15536050f, 0.05189380f, 0.14930327f, 1.20958805f, 0.18826123f, -0.27445790f, -0.03757462f, 
    -0.12346481f, -0.07250302f, -0.04091557f, -0.05796283f, 0.07457429f, -0.02521320f, 0.01521513f, 0.08442950f, 
    -0.13043125f, 0.02049229f, 0.03094000f, -0.12823243f, 0.09257922f, 0.14623684f, 0.15058184f, -0.00802470f, 
    -0.59471011f, -0.87006164f, -0.53581363f, -0.11864221f, -0.85871810f, -0.09720876f, -0.10727140f, -0.05401244f, 
    -0.00584445f, -0.16992742f, 0.00677477f, -0.04237378f, -0.00764343f, -0.03222117f, -0.02508414f, -0.13169254f, 
    -0.01975476f, -0.12093925f, -0.06951334f, 0.18067454f, -0.11878821f, -0.14700562f, 0.26093280f, -0.31831476f, 
    -0.09954067f, -0.04371807f, 0.08236030f, -0.01596764f, 0.04835173f, 0.08972888f, 0.06057015f, -0.00554361f, 
    -0.02750314f, 0.12751001f, 0.01047988f, 0.03963307f, -0.07510931f, -0.04854678f, -0.02188016f, -0.05433742f, 
    -0.14331818f, -0.42189503f, 0.10842630f, 0.16909760f, -0.25371233f, -0.08850459f, 0.02241340f, 0.06687036f, 
    -0.03858307f, -0.02005490f, -0.01491112f, 0.04805281f, 0.08252015f, 0.00700045f, 0.02636259f, -0.04058433f, 
    -0.00645021f, -0.21419612f, -0.11684126f, 0.02844742f, 0.35529375f, 0.17486581f, -0.08536789f, 0.13817112f, 
    0.37276295f, 0.01557953f, 0.11857946f, -0.08770736f, -0.03745729f, 0.06121239f, -0.06464710f, 0.02239085f, 
    -0.01912031f, 0.05531589f, -0.07419378f, 0.21162021f, 0.16490631f, 0.15348098f, 0.00205308f, 0.12547857f, 
    -0.40594503f, -0.17872621f, 0.08308662f, -0.53494811f, 0.07763656f, -0.01585015f, -0.05017206f, -0.01830678f, 
    0.09209994f, 0.12418067f, 0.01306540f, 0.03409253f, 0.04162296f, 0.04302640f, 0.00905151f, -0.17982553f, 
    -0.22672674f, -0.11259519f, 0.00970425f, 0.00966649f, -0.13381286f, -0.21900989f, 0.24974506f, -0.34176230f, 
    -0.05858253f, 0.02850945f, 0.05942941f, -0.05574688f, 0.00796239f, 0.10624249f, 0.04503344f, -0.04954702f, 
    -0.03813785f, 0.08501182f, -0.00425460f, 0.04896028f, -0.23676521f, -0.30118898f, 0.04529251f, -0.06351309f, 
    0.25958970f, -0.03724261f, -0.07887517f, -0.03131812f, 0.17242232f, 0.04592285f, 0.02091707f, -0.01355671f, 
    0.00135829f, 0.06160662f, -0.08437601f, 0.11591947f, 0.05507026f, 0.18062705f, -0.04932367f, 0.13681488f, 
    0.02429066f, 0.05888600f, 0.06748812f, 0.03074687f, 0.07053431f, -0.01825973f, -0.15409292f, 0.03414954f, 
    0.07514853f, 0.06297941f, -0.00998913f, 0.07435721f, 0.03501422f, -0.01675353f, -0.26014668f, -0.13215980f, 
    0.02200661f, 0.06110305f, 0.19269243f, 0.03844566f, 0.00775100f, -0.03612080f, 0.12694857f, -0.09348276f, 
    -0.04273416f, -0.04626468f, 0.05190670f, -0.05102798f, 0.08349824f, -0.08227342f, -0.20534156f, -0.29643700f, 
    -0.06244957f, 0.04552417f, -0.02466367f, -0.12139027f, -0.04423804f, 0.01738174f, -0.10029993f, 0.05535308f, 
    -0.07729711f, -0.08264560f, -0.04367223f, -0.01046958f, -0.50255418f, -0.22084638f, 0.84004039f, 0.43023470f, 
    0.39506343f, -0.09709632f, -0.12125564f, -0.05645372f, 0.08870097f, -0.07644908f, 0.03497993f, 0.02370485f, 
    0.04789429f, -0.13936403f, -0.09954657f, -0.00031672f, 0.05879823f, 0.08802937f, -0.02145592f, -0.03548375f, 
    -0.41367072f, -0.52116370f, -0.52930909f, 0.06771854f, -0.50709027f, 0.07441831f, -0.00136210f, 0.03482861f, 
    -0.02927907f, -0.33949983f, 0.03616378f, 0.13881800f, -0.01307117f, 0.04605022f, -0.05510095f, -0.01668773f, 
    -0.00742696f, 0.03406059f, -0.03620045f, 0.01083158f, 0.19540139f, -0.05259760f, 0.02340246f, 0.03328083f, 
    0.14963087f, -0.00821797f, 0.06059415f, -0.00503177f, 0.02284728f, -0.00536296f, -0.01659441f, -0.02397520f, 
    0.06644318f, -0.03449908f, -0.01854654f, 0.15168731f, 0.14768377f, 0.08021604f, 0.27599165f, 0.08367375f, 
    -1.01519752f, -0.45897946f, 0.27198014f, -0.21341707f, -0.12758833f, -0.11558610f, 0.15906902f, 0.08435391f, 
    0.00521970f, 0.05866003f, 0.02752537f, -0.03246531f, 0.02105407f, -0.01200891f, -0.00058663f, -0.11793799f, 
    -0.04075381f, 0.08494300f, -0.21825141f, -0.08167988f, -0.65201753f, 0.42686704f, -0.27840254f, 0.22895102f, 
    -0.69113404f, 0.09798755f, 0.26450565f, -0.02582701f, -0.18365403f, 0.11364537f, 0.03816955f, -0.01478171f, 
    0.05308920f, -0.04999939f, -0.05125314f, 0.00742325f, 0.09111613f, -0.17254300f, 0.01398209f, 0.07987880f, 
    0.22090729f, -0.11898868f, 0.33367440f, 0.37863669f, 0.39073566f, 0.13126144f, -0.34236246f, -0.02690348f, 
    0.24502335f, -0.31966293f, 0.05734285f, 0.06843672f, 0.12908877f, -0.08733595f, -0.10263994f, 0.02421636f, 
    -0.00927021f, -0.01116767f, 0.03868990f, -0.06894153f, 0.28054690f, 0.15442945f, -0.17646788f, 0.51853770f, 
    0.22659646f, 0.05706817f, 0.00919077f, -0.18221363f, 0.06279171f, -0.04827057f, -0.02680306f, 0.05306383f, 
    -0.03938305f, 0.01307629f, 0.03272368f, -0.02871815f, 0.13361287f, 0.17310199f, -0.16533330f, 0.03848762f, 
    -0.17810638f, -0.16460137f, -0.15132093f, -0.43072167f, 0.01310658f, -0.04009238f, -0.01874701f, 0.02414417f, 
    0.03356115f, 0.10945538f, -0.00483925f, 0.03990368f, -0.02572880f, 0.06165671f, -0.07475998f, 0.05262264f, 
    -0.18532991f, 0.05585709f, 0.13575688f, -0.01036014f, 0.05138223f, 0.01592897f, -0.09108262f, 0.03572322f, 
    0.07729317f, -0.04883132f, 0.01644127f, 0.01069528f, 0.01902220f, 0.03240165f, -0.01333746f, -0.04003144f, 
    -0.08186989f, 0.12641588f, -0.06624924f, 0.05511349f, -0.04869193f, 0.03044996f, 0.03940856f, -0.00272287f, 
    0.17816071f, 0.21010706f, -0.24877495f, -0.07783050f, 0.06851544f, -0.29749051f, -0.21054541f, 0.00902959f, 
    0.06545097f, 0.06258044f, -0.01998150f, 0.02331211f, -0.01888078f, -0.00957698f, -0.03145713f, -0.11104141f, 
    -0.12346257f, 0.19786188f, 0.03404709f, 0.26221403f, -0.51455575f, -0.19584835f, 0.24594118f, 0.08936892f, 
    -0.43347225f, -0.03416961f, 0.03095781f, -0.07083781f, -0.18420479f, -0.02091153f, 0.03112732f, -0.04548005f, 
    -0.00720920f, 0.00413765f, -0.06571827f, -0.01675455f, 0.04989067f, -0.13591152f, 0.09711993f, 0.16196720f, 
    0.04663976f, -0.00555104f, -0.11907032f, -0.03103520f, 0.02699943f, -0.01875216f, -0.06335958f, 0.03389279f, 
    0.03056454f, 0.05843415f, 0.02319760f, -0.22763270f, 0.02526288f, 0.01362073f, 0.05224634f, 0.03508272f, 
    -0.12857619f, -0.07896512f, 0.05928811f, 0.05173621f, -0.02897511f, 0.07809435f, 0.01732060f, -0.18654938f, 
    0.11735238f, 0.00335014f, -0.02845561f, -0.08233111f, 0.06837563f, 0.05287668f, 0.07730588f, -0.04390628f, 
    0.00886147f, 0.03905182f, 0.04225726f, -0.08290209f, -0.04275486f, 0.03334112f, 0.07775991f, 0.00353988f, 
    0.22482738f, -0.55882210f, 0.24765842f, 0.19023459f, -0.37553704f, 0.02786844f, -0.12042872f, -0.07575830f, 
    -0.33325350f, 0.25696900f, -0.09262022f, 0.00998253f, -0.02365229f, 0.04309809f, 0.01209905f, 0.09882464f, 
    -0.06860055f, -0.15954635f, 0.27994955f, 0.03007209f, 0.27625710f, -0.09250779f, 0.24396679f, 0.22821063f, 
    0.10125910f, 0.09993976f, -0.12985872f, -0.13299994f, 0.17382900f, -0.30092284f, 0.03919026f, 0.21173991f, 
    0.02918064f, 0.03464113f, 0.01262594f, 0.02212095f, -0.09074361f, -0.16551246f, 0.13062836f, -0.05756183f, 
    -0.24339050f, 0.08335854f, 0.84394240f, 0.17742597f, 0.34462771f, 0.00557454f, -0.01861659f, 0.14879569f, 
    0.08884074f, -0.20293355f, 0.08035394f, 0.07797390f, 0.02776220f, -0.03400179f, 0.14608796f, 0.01172866f, 
    0.01536577f, 0.05315604f, 0.06661484f, -0.01331498f, -0.10242721f, -1.19537520f, -0.57124245f, 0.36391157f, 
    -0.56012440f, 0.08198553f, -0.19221635f, -0.09360814f, 0.16350211f, -0.14649148f, 0.01181986f, 0.05386612f, 
    0.02904461f, -0.04693973f, -0.01470677f, -0.04009733f, 0.05138920f, 0.05280586f, 0.10462658f, 0.01108364f, 
    -0.36031255f, 0.12532736f, -0.03960519f, 0.07582194f, 0.08538184f, -0.13475898f, 0.09624188f, -0.18483429f, 
    -0.36711475f, -0.23674841f, 0.08414165f, -0.04243279f, -0.03248964f, 0.06548829f, -0.04303790f, 0.02786257f, 
    -0.00058304f, -0.02936086f, -0.22916691f, -0.15951079f, -0.03071981f, -0.07278185f, 0.41291606f, 0.08820218f, 
    0.46041861f, -0.00803859f, 0.06251273f, -0.01605443f, 0.23626004f, -0.02790897f, 0.09399817f, -0.02849248f, 
    0.19578834f, -0.02699411f, 0.08987326f, 0.04421731f, 0.05376093f, 0.04223311f, -0.04833768f, 0.01046160f, 
    -0.26666293f, 0.11997524f, 0.33945909f, 0.18341181f, -0.41727898f, 0.06132307f, -0.23134398f, 0.00870093f, 
    0.01254026f, -0.18648452f, 0.02432774f, 0.13683872f, 0.05569306f, 0.06781566f, 0.00312845f, -0.03568428f, 
    0.00758674f, 0.15520866f, 0.28732473f, -0.12798662f, -0.29277977f, -0.11205872f, 0.09377638f, -0.18522269f, 
    -0.06096746f, 0.28176627f, -0.03841663f, -0.31701949f, -0.21897461f, 0.05183333f, 0.02190507f, 0.01584855f, 
    0.05754110f, 0.03664830f, -0.13373570f, 0.02370557f, -0.04714937f, 0.01739974f, -0.25751427f, 0.06330930f, 
    -0.77121502f, 0.25313523f, 0.22787815f, -0.45429027f, -0.13043815f, 0.03148038f, -0.02987212f, -0.00493532f, 
    0.01536824f, 0.04051454f, -0.01339463f, -0.02459532f, 0.03812793f, -0.00784088f, 0.00544414f, 0.16921563f, 
    0.04848097f, 0.17793949f, 0.11485379f, -0.05756843f, -0.57697725f, 0.20892520f, -0.35597339f, -0.19933343f, 
    -0.25408113f, -0.02940889f, -0.01298896f, -0.03164483f, 0.00710939f, 0.07520166f, 0.00783940f, 0.09467046f, 
    -0.11626283f, 0.08984429f, 0.20774987f, 0.13168722f, -0.06517011f, 0.02258907f, 0.21483703f, 0.03753979f, 
    -0.22267814f, -0.17060819f, -0.27027127f, 0.11505009f, 0.21004328f, -0.12767000f, 0.19303139f, 0.02137577f, 
    0.01775444f, 0.11344313f, -0.05602216f, -0.01553764f, -0.02839578f, -0.09949449f, 0.02025328f, 0.04117302f, 
    -0.02436201f, 0.00579083f, -0.17557512f, -0.09248818f, -0.18031469f, 0.02709739f, 0.53522623f, -0.07937132f, 
    0.19272262f, -0.12752083f, -0.10980559f, -0.26394191f, -0.14358659f, -0.08687761f, 0.08907221f, -0.01164975f, 
    -0.07490841f, -0.02828477f, 0.03086000f, 0.00906757f, -0.11064237f, 0.05680857f, -0.00055952f, -0.00566826f, 
    -0.08402878f, -0.13462558f, -0.21243651f, -0.07051191f, 0.27485713f, -0.02616225f, -0.04232856f, -0.04297801f, 
    0.03999141f, 0.00268440f, 0.04332114f, 0.04051412f, 0.02408294f, -0.05441388f, 0.04867519f, 0.02595313f, 
    0.07155169f, 0.04748495f, -0.09610354f, 0.06237476f, 0.64524955f, 0.31719539f, 0.13764760f, -0.45682067f, 
    0.09947257f, 0.07784595f, 0.14812231f, -0.03175781f, -0.00355069f, 0.07106850f, -0.00282861f, -0.06122962f, 
    0.13851561f, 0.01142128f, 0.04362574f, -0.00941647f, 0.08877259f, -0.22023441f, 0.19713348f, 0.10789157f, 
    -0.31177995f, -0.42837694f, -0.30884364f, -0.07978350f, -0.13282648f, 0.02191585f, -0.12842262f, -0.05117231f, 
    0.05499413f, 0.23377228f, 0.03082152f, -0.01678952f, 0.06297136f, -0.18856582f, 0.03967481f, -0.10932257f, 
    0.07602306f, 0.19567344f, -0.25009325f, -0.20790024f, -0.37690988f, 0.13401838f, 0.55446804f, -0.15862498f, 
    0.11402249f, -0.29542312f, -0.18835175f, -0.15169173f, -0.00221265f, -0.03138217f, -0.02642771f, -0.13616656f, 
    -0.00641300f, 0.07923877f, 0.09605003f, -0.00000386f, -0.04385429f, -0.14962669f, -0.00516540f, -0.04590454f, 
    0.87731653f, 0.42094383f, -0.04182476f, -0.26403520f, -0.43886194f, 0.08046596f, -0.01455642f, -0.07400044f, 
    -0.19412194f, -0.15104635f, -0.04503101f, -0.06264086f, 0.04863258f, -0.14263889f, -0.04996879f, -0.11631727f, 
    0.06665737f, -0.29145023f, 0.08744174f, 0.18597421f, -0.04969168f, 0.05157531f, 0.01513331f, 0.03253549f, 
    -0.24764200f, 0.13569443f, 0.12261165f, -0.09368493f, -0.11218294f, 0.17158835f, -0.12257592f, -0.23969671f, 
    -0.02495919f, 0.08728242f, -0.26742643f, -0.10123256f, -0.06114506f, -0.06443789f, -0.19638392f, -0.33644453f, 
    0.17470086f, 0.00644766f, 0.27891055f, -0.22683859f, 0.21596141f, 0.06369686f, 0.09518550f, -0.03580567f, 
    0.00195151f, 0.10886165f, 0.03486813f, -0.06626822f, -0.03379529f, -0.15393075f, 0.07672139f, -0.00618730f, 
    -0.04499952f, -0.10263586f, 0.02293848f, 0.03436158f, 0.12206467f, 0.10366945f, -0.15102611f, 0.02308108f, 
    0.29119003f, 0.25978756f, 0.05654608f, 0.06197432f, 0.08204356f, 0.06352594f, -0.08462531f, 0.14565594f, 
    0.07538971f, 0.13133398f, 0.16774279f, -0.04929616f, 0.17177425f, 0.02700198f, -0.00587003f, 0.07230990f, 
    -0.03946539f, -0.19381845f, -0.36823556f, -0.06686437f, 0.23990829f, 0.17916951f, 0.06874287f, 0.19523782f, 
    0.12402943f, 0.04612873f, 0.16009223f, -0.04941107f, -0.02116841f, 0.02948146f, -0.07210551f, 0.06944165f, 
    -0.16597031f, 0.26915440f, -0.24594432f, 0.16711028f, 0.57770181f, -0.02796586f, 0.11899988f, -0.28868613f, 
    0.02854878f, -0.07091694f, 0.05398566f, -0.05181481f, 0.03427954f, 0.10202953f, 0.03709877f, -0.03372921f, 
    0.14708833f, 0.03929638f, -0.01253016f, 0.07343304f, -0.04193877f, -0.00476922f, 0.12057990f, 0.05608876f, 
    -0.10644584f, -0.52036756f, 0.54870242f, -0.10123883f, 0.32623968f, -0.19434614f, 0.06014358f, 0.03719911f, 
    0.00174952f, -0.05306237f, 0.21755894f, 0.10433854f, 0.07167039f, 0.01906555f, 0.13876988f, -0.08099987f, 
    -0.11492553f, 0.11483675f, -0.03602000f, -0.17118859f, -0.43872494f, 0.10681352f, -0.33078364f, 0.30415398f, 
    0.20234846f, -0.15160455f, -0.14583246f, 0.08736834f, -0.18548110f, -0.13785115f, -0.01705980f, 0.00456330f, 
    -0.01934763f, -0.08010577f, -0.09371489f, -0.06277423f, 0.02534104f, -0.03640423f, -0.04705716f, -0.12146612f, 
    -0.62641168f, 1.07452714f, -0.17468138f, -0.19598591f, 0.03799036f, 0.34007990f, 0.07128863f, -0.01712843f, 
    -0.07149884f, -0.13878167f, -0.46248972f, -0.11811676f, -0.10836647f, -0.17449561f, -0.00234984f, -0.22178830f, 
    0.00959887f, 0.00643892f, 0.12301221f, -0.01009363f, 0.13436203f, 0.26638797f, 0.11356223f, -0.26022625f, 
    0.24582793f, -0.08520252f, 0.00068594f, -0.19610679f, 0.03009732f, -0.13843793f, -0.17719945f, 0.02908782f, 
    -0.14750937f, 0.04746445f, 0.01524581f, -0.08094309f, -0.19025463f, 0.14144963f, -0.00754658f, -0.15854272f, 
    -0.97092569f, 0.03745651f, 0.21178892f, 0.11483832f, 0.00916832f, 0.14683531f, -0.01271391f, 0.10600040f, 
    0.13046835f, 0.08649034f, -0.08604692f, 0.00613288f, 0.10910709f, 0.04570810f, -0.13289320f, -0.01027214f, 
    -0.08260621f, -0.22870229f, -0.02724286f, -0.07719113f, -0.23593241f, -0.04846485f, -0.32214531f, -0.10859933f, 
    -0.29675215f, 0.14955129f, -0.20330878f, -0.13295357f, -0.12349471f, -0.23415466f, -0.04174152f, 0.06422234f, 
    -0.11845447f, -0.27257955f, -0.00533960f, 0.14885704f, 0.00523993f, -0.17436969f, -0.01114395f, -0.07696453f, 
    0.22891368f, -0.08109485f, 0.00717240f, -0.38387781f, 0.12970002f, -0.09502910f, 0.06941738f, -0.04315787f, 
    -0.01669847f, 0.01209336f, 0.01635513f, 0.00391831f, -0.06056521f, 0.03029100f, 0.02167866f, 0.03581641f, 
    -0.02855710f, 0.11729927f, -0.12492075f, -0.00439158f, -0.13618746f, -0.14201760f, -0.24025311f, 0.17568634f, 
    0.41832718f, -0.09751704f, 0.02714798f, -0.01243903f, 0.02815654f, -0.00127219f, -0.02466496f, -0.02524659f, 
    -0.09819177f, -0.11999948f, -0.10167461f, -0.16529985f, 0.05101239f, -0.08425673f, 0.03687535f, 0.01103306f, 
    -0.20024110f, -0.21985002f, -0.52759570f, -0.17052652f, -0.08976616f, 0.01035447f, -0.32584876f, 0.16514815f, 
    -0.15207030f, -0.13287465f, -0.12869376f, -0.07994235f, -0.22888884f, 0.05911950f, -0.05645951f, 0.15390773f, 
    0.00183126f, 0.04298747f, -0.06718061f, -0.22476731f, -0.19934812f, 0.13628106f, 0.26790774f, -0.33263081f, 
    -0.14333923f, -0.17578840f, -0.05356638f, -0.10860717f, -0.00296483f, -0.03901235f, 0.11456865f, -0.03568178f, 
    -0.10404805f, -0.02107964f, -0.05905462f, 0.08406566f, 0.02652075f, 0.12932125f, -0.19796255f, -0.28636110f, 
    0.14772575f, -0.33808127f, 0.09012822f, 0.03401619f, 0.70877647f, 0.01188483f, 0.20935269f, -0.07056401f, 
    0.09716779f, -0.21043569f, 0.13141836f, -0.04709030f, -0.11097340f, -0.12078155f, 0.03107727f, 0.00072788f, 
    -0.11837149f, 0.12511703f, -0.07571283f, -0.00494798f, -0.01394217f, -0.18359227f, -0.35093048f, -0.11441322f, 
    0.31200066f, 0.10541580f, 0.14032172f, -0.04159303f, -0.05983678f, -0.10853370f, -0.15373039f, 0.00189061f, 
    0.06590581f, 0.06321142f, -0.12397375f, 0.01773019f, -0.04231130f, 0.06490342f, 0.21508732f, 0.00405173f, 
    0.07834054f, 0.39329365f, -0.08112721f, -0.01664683f, 0.33634016f, 0.24799493f, 0.04825847f, 0.07114304f, 
    -0.09893155f, 0.03481046f, -0.21753621f, -0.09135986f, 0.09445641f, 0.04384677f, 0.16673549f, -0.01705129f, 
    0.00261304f, 0.02916379f, -0.01235039f, 0.03384008f, 0.12075029f, -0.17591114f, -0.28538454f, -0.14667571f, 
    0.28882989f, 0.04833987f, 0.13569903f, -0.19991118f, -0.11469583f, 0.07388344f, -0.13042371f, 0.02308521f, 
    -0.18206364f, 0.05953585f, -0.06880090f, -0.14362937f, -0.09430136f, 0.10406572f, 0.09844140f, 0.04043785f, 
    -0.28916460f, 0.03670232f, -0.13815406f, 0.12256202f, 0.11690375f, 0.08542138f, -0.08329464f, 0.14481914f, 
    -0.01438948f, 0.01218462f, 0.02416806f, 0.10815548f, -0.10549321f, -0.11209298f, 0.03902659f, 0.00951823f, 
    0.00183891f, 0.11364829f, -0.07394523f, -0.28115466f, -0.71954340f, 0.76562440f, -0.06134298f, -0.28484961f, 
    0.30052274f, 0.24884780f, 0.11407658f, -0.03266193f, -0.14415292f, 0.03499190f, -0.17937191f, 0.05092044f, 
    0.01506103f, -0.08794584f, 0.06751169f, 0.01701103f, 0.08375869f, 0.03062322f, -0.04492711f, -0.01622101f, 
    -0.15952303f, -0.05779241f, -0.15993035f, -0.08963448f, 0.32017881f, -0.02570202f, 0.07334418f, -0.08105263f, 
    -0.12759320f, -0.05754948f, -0.09541459f, 0.07015606f, -0.04056916f, -0.10242573f, -0.03198063f, -0.07395339f, 
    -0.20068447f, 0.00696501f, 0.02868667f, -0.05686382f, 0.20151316f, -0.04100908f, 0.13961731f, -0.10087611f, 
    0.33940053f, 0.13321798f, 0.20768811f, 0.04477124f, 0.19672205f, 0.15600367f, 0.11671324f, -0.04371366f, 
    -0.03565395f, 0.00538156f, 0.07717171f, 0.00475502f, -0.03221507f, 0.07808140f, -0.14077815f, 0.05323822f, 
    -0.77380711f, 0.05934462f, -0.05038792f, 0.51592970f, -0.09029346f, -0.03647356f, -0.11159483f, 0.09208687f, 
    0.06811480f, 0.01636337f, -0.03791380f, 0.07367696f, 0.04085941f, -0.04913967f, 0.07346080f, -0.07984269f, 
    0.11822359f, -0.16392949f, 0.03096403f, -0.06993210f, -0.54766309f, 0.27235591f, 0.11554530f, -0.12189551f, 
    -0.28824890f, -0.09600767f, 0.18124993f, 0.16734032f, -0.05317967f, -0.08982274f, -0.04484345f, 0.02697322f, 
    0.16107255f, 0.10054766f, -0.21120535f, 0.01187543f, -0.07750269f, 0.15575738f, -0.07089037f, 0.01462883f, 
    -0.02608272f, 0.10461926f, 0.23601826f, 0.09097426f, 0.13815518f, -0.07242033f, 0.09209916f, -0.06394035f, 
    -0.04398287f, 0.08142310f, -0.00952645f, -0.02546954f, 0.00084236f, 0.04917959f, 0.01034808f, 0.07900076f, 
    0.13681313f, -0.26685917f, -0.05154837f, 0.30708995f, -0.11141803f, -0.01210952f, -0.29087225f, 0.04772815f, 
    0.20890196f, 0.08462093f, -0.02993689f, 0.11911593f, -0.01443428f, -0.03047034f, 0.03645481f, -0.01306168f, 
    0.01160556f, -0.13109177f, 0.03719655f, -0.04636367f, 0.04593508f, 0.08664266f, -0.10275102f, -0.07383745f, 
    -0.23087944f, -0.00886260f, 0.09113595f, 0.09055603f, 0.07933325f, -0.14658800f, 0.08701702f, -0.15758128f, 
    -0.16985764f, -0.04384901f, -0.03230260f, -0.00124651f, -0.01921613f, 0.12598035f, 0.22947344f, 0.01214012f, 
    0.12854949f, -0.02584267f, -0.08901560f, 0.16972019f, 0.01541697f, -0.47214735f, -0.42060781f, 0.14878988f, 
    -0.42024425f, 0.02882576f, -0.21074651f, 0.03584338f, -0.16978744f, -0.06779303f, 0.06307922f, -0.09212837f, 
    -0.05800724f, 0.15615755f, -0.11867686f, -0.12582922f, -0.02023884f, 0.11355992f, -0.05850343f, 0.16240978f, 
    -0.01558560f, 0.06880051f, -0.03236225f, 0.07925011f, 0.11418635f, 0.16394588f, 0.08834492f, 0.04523888f, 
    0.04012454f, 0.03114474f, 0.01860330f, 0.05696748f, 0.05116009f, 0.00166833f, 0.04846333f, 0.01651417f, 
    -0.08481608f, 0.07641640f, -0.03031111f, -0.02709681f, -0.00030375f, -0.03697826f, -0.23977937f, 0.06821923f, 
    0.15382800f, 0.07148112f, 0.01647394f, 0.04131471f, 0.01781508f, -0.00352879f, 0.13647658f, 0.04650769f, 
    0.03826248f, -0.12165824f, 0.12543859f, 0.00937536f, -0.12322806f, 0.10031866f, -0.15072057f, 0.01746762f, 
    -0.08661817f, -0.09980349f, -0.15667443f, -0.16332234f, -0.08323263f, 0.05757863f, -0.11694978f, -0.03729613f, 
    -0.05053682f, 0.05486561f, -0.00995231f, -0.31314898f, 0.08503325f, 0.05687037f, -0.08866952f, 0.05478824f, 
    -0.12826593f, -0.06658120f, -0.21247071f, -0.04041037f, 0.08902641f, 0.07474033f, -0.03659353f, -0.11494937f, 
    -0.11465674f, 0.00716178f, 0.00094092f, -0.06126420f, 0.05393456f, 0.07428806f, 0.02670556f, -0.24526691f, 
    0.24988793f, -0.31847230f, 0.27011576f, 0.10768107f, 0.00919735f, 0.04026008f, -0.16884372f, -0.02468463f, 
    -0.05701273f, 0.06415089f, -0.02835300f, 0.09768551f, 0.00982105f, 0.06209211f, 0.20453480f, -0.02993051f, 
    -0.05286504f, 0.09663475f, 0.14912598f, -0.06570593f, 0.06765183f, -0.09211121f, 0.05590771f, 0.00427932f, 
    -0.06954642f, -0.12186810f, -0.10940213f, -0.14352638f, -0.24348819f, -0.27568796f, 0.10829053f, 0.06755278f, 
    0.20365292f, -0.17578627f, 0.01900656f, 0.00333770f, -0.13786587f, -0.02361485f, 0.00434153f, 0.02209339f, 
    -0.06868625f, -0.00179472f, -0.02910845f, -0.08886556f, 0.04205342f, 0.05864599f, 0.09452347f, 0.07626157f, 
    0.24159200f, 0.36989599f, 0.49360180f, 0.27443892f, 0.25703385f, -0.21564186f, -0.17374207f, -0.09232607f, 
    -0.11388814f, 0.25017661f, 0.04358838f, 0.02307521f, 0.06057069f, 0.03025499f, 0.03426386f, 0.02980996f, 
    -0.01518197f, -0.12412548f, 0.01608640f, -0.23962849f, 0.46930927f, -0.25709444f, -0.32768059f, 0.10061713f, 
    -0.23572472f, 0.10047071f, -0.11749861f, 0.01086821f, 0.16210130f, -0.00322146f, 0.00946118f, -0.06575540f, 
    0.00094568f, -0.00809113f, 0.00645659f, 0.03502495f, 0.21113671f, 0.10991502f, 0.03127912f, 0.11197375f, 
    0.13249792f, 0.07318313f, -0.27343985f, 0.19825256f, 0.49615562f, -0.23431675f, 0.02877650f, 0.08032653f, 
    0.12269133f, 0.13258326f, 0.08584917f, -0.00839859f, 0.02997580f, -0.01022046f, 0.07259778f, -0.09173925f, 
    0.06713963f, 0.07903481f, 0.01996925f, 0.01016662f, 0.26694611f, -0.08190893f, 0.47388148f, 0.06750307f, 
    0.26548743f, -0.02336779f, 0.08309875f, 0.02889600f, -0.03493250f, -0.17874143f, -0.03081161f, -0.11180245f, 
    -0.02703409f, 0.05403542f, -0.03747806f, -0.11423746f, 0.00989901f, -0.15831432f, -0.00897134f, -0.25016043f, 
    0.14763267f, -0.87164462f, -0.07712024f, 0.16357404f, 0.09865452f, -0.20753205f, -0.38096461f, -0.06692222f, 
    -0.35756856f, 0.13126759f, -0.22304259f, 0.02934248f, 0.01068129f, -0.13497423f, -0.16102299f, -0.07154678f, 
    -0.02445231f, 0.09651891f, -0.22642325f, 0.12023097f, -0.15182020f, -0.37725452f, -0.08123431f, 0.09816318f, 
    -0.26524070f, -0.11945337f, -0.12122523f, -0.01302947f, -0.24762188f, -0.19724461f, -0.03256666f, -0.02600059f, 
    -0.01286840f, 0.07101464f, -0.12841247f, 0.00021391f, 0.08911689f, -0.08150649f, 0.05064688f, 0.05090103f, 
    -0.00038425f, 0.09427036f, -0.10708304f, -0.15499724f, -0.14387965f, 0.10099316f, 0.00370269f, 0.02428593f, 
    0.02694951f, 0.10527907f, 0.16702619f, 0.03955111f, 0.02675227f, 0.03160203f, 0.06871817f, 0.09285660f, 
    0.15202080f, -0.07093862f, -0.17812032f, 0.13524912f, -0.03788257f, 0.03779532f, -0.05879299f, -0.10701284f, 
    -0.04218295f, 0.03439219f, 0.10243482f, -0.01531910f, 0.01558182f, 0.06422535f, -0.04903276f, -0.19892956f, 
    -0.02628147f, -0.17694786f, 0.00461445f, 0.04555001f, -0.11832796f, -0.08676636f, -0.05894922f, -0.01404663f, 
    0.14898548f, 0.03391222f, -0.00824586f, 0.41896671f, 0.08581415f, 0.02082931f, 0.22115755f, 0.00587560f, 
    0.07320032f, 0.07200446f, -0.00109258f, -0.14675935f, 0.03810632f, -0.00500413f, 0.02167420f, -0.02457766f, 
    0.08033154f, -0.02944795f, 0.15078664f, 0.17087968f, 0.02733184f, 0.13006969f, 0.26176828f, 0.02408290f, 
    0.06637546f, -0.00296606f, 0.14899381f, -0.05959985f, 0.05609860f, 0.00169261f, -0.01789879f, -0.04645061f, 
    -0.00617462f, 0.01496911f, 0.02003394f, 0.05523977f, 0.13569243f, -0.07714598f, -0.00140448f, 0.26029262f, 
    0.03386764f, -0.02539519f, 0.10343345f, -0.03807356f, -0.02047819f, 0.11984606f, -0.02933258f, -0.02408980f, 
    -0.01106158f, 0.00776394f, 0.04046274f, 0.05543323f, -0.09748277f, -0.11691254f, 0.13222188f, 0.20531388f, 
    -0.12649451f, 0.03275565f, -0.06960490f, -0.16975494f, 0.06155004f, -0.07130909f, -0.11891335f, 0.00221344f, 
    -0.08633416f, 0.04117159f, -0.00529828f, 0.05531818f, 0.02121361f, 0.00997457f, 0.00732303f, 0.04190488f, 
    -0.02288411f, -0.00581472f, 0.01889238f, 0.07649417f, -0.05079952f, 0.03331544f, -0.00875430f, -0.01818066f, 
    -0.12041910f, 0.04354829f, -0.20040616f, -0.02369355f, -0.01008873f, 0.08894951f, 0.05732965f, 0.01550445f, 
    0.40296695f, 0.15252922f, -0.00420152f, -0.06173446f, 0.13458851f, 0.01504993f, 0.00394039f, -0.17686820f, 
    0.17119588f, 0.16616575f, -0.14398769f, 0.04308437f, 0.02296207f, 0.11430266f, 0.01475987f, 0.12631644f, 
    -0.08199679f, -0.01259585f, -0.19449714f, -0.12352154f, -0.21911697f, 0.04004463f, 0.04040197f, -0.11387210f, 
    -0.07734533f, 0.06534884f, -0.01682996f, 0.10620135f, 0.10343891f, -0.04821102f, -0.12491415f, -0.05159602f, 
    -0.04402118f, -0.02190837f, 0.28926367f, 0.08744223f, 0.02291323f, -0.19997419f, -0.06351954f, -0.14919919f, 
    -0.04603817f, -0.03135252f, 0.04411852f, -0.04076505f, -0.14673840f, 0.14736328f, -0.02786446f, 0.02348625f, 
    0.05312939f, 0.06594960f, -0.00081100f, -0.09360179f, 0.03503047f, -0.02629332f, 0.27670977f, 0.20479345f, 
    0.07073674f, -0.18606846f, -0.06457634f, 0.16595718f, 0.06806474f, 0.03216464f, 0.04978067f, -0.01619618f, 
    0.01883890f, 0.04692931f, 0.03941692f, -0.00076549f, -0.03810384f, -0.04439279f, 0.01487028f, -0.17085922f, 
    0.09089153f, -0.13584749f, 0.16834632f, -0.08273979f, 0.12453082f, 0.03708768f, -0.02857020f, 0.10823290f, 
    -0.01916707f, 0.13212959f, -0.03290038f, -0.02936227f, 0.01885818f, -0.12649918f, 0.01759060f, -0.04933266f, 
    -0.10002261f, -0.05605979f, -0.09568526f, -0.13716477f, 0.16769594f, -0.12156518f, 0.21116512f, -0.07903451f, 
    -0.05774981f, -0.38173172f, -0.18328455f, 0.07609294f, -0.05975648f, -0.13757873f, -0.06133287f, 0.00994724f, 
    -0.15056969f, -0.00807943f, -0.07146295f, 0.04351870f, 0.04879817f, 0.00643457f, 0.04871909f, -0.05484929f, 
    0.08435476f, -0.16972467f, 0.35822055f, -0.11319537f, -0.20442605f, -0.16270714f, -0.14136827f, -0.27123454f, 
    -0.04071410f, -0.17034605f, 0.04583923f, -0.20789470f, 0.03738398f, 0.03996007f, 0.01470307f, 0.04223249f, 
    -0.02141748f, -0.13172978f, -0.30265862f, -0.21257132f, -0.09552889f, 0.08872799f, 0.05097219f, 0.17962107f, 
    0.13836072f, -0.11916674f, 0.01583745f, 0.07085824f, 0.09557188f, 0.25288787f, -0.03466839f, 0.05715581f, 
    -0.06329452f, -0.01318955f, 0.06468082f, 0.00831925f, -0.04054563f, -0.18788952f, -0.19639432f, -0.30497363f, 
    0.07103412f, 0.06355037f, -0.07876742f, -0.34744912f, 0.03699531f, 0.13779204f, 0.03275468f, 0.00214205f, 
    0.09489340f, 0.09464347f, 0.08170785f, 0.10503663f, -0.00224632f, 0.02685241f, -0.07691853f, -0.00099140f, 
    -0.06621031f, 0.05982586f, 0.08051278f, 0.01614957f, -0.00172008f, -0.29412225f, 0.10630334f, -0.22890700f, 
    -0.36381927f, 0.13900143f, 0.10659537f, 0.05142273f, 0.03926253f, 0.03440785f, 0.10504024f, 0.01040429f, 
    -0.14561144f, -0.10787942f, -0.18986377f, -0.05082766f, 0.09803401f, -0.27548090f, -0.30782610f, -0.13968307f, 
    0.05409786f, -0.03019364f, 0.26785266f, 0.23375978f, -0.19194926f, -0.03036590f, -0.01883612f, -0.00004203f, 
    -0.03943202f, -0.19087847f, 0.01941360f, 0.02437220f, 0.05153853f, 0.01599115f, 0.00883403f, -0.02255807f, 
    0.07889345f, -0.28987148f, -0.05202385f, -0.45080107f, 0.35756078f, 0.09095339f, -0.41754374f, 0.31494224f, 
    0.13771804f, 0.06039170f, -0.00824484f, 0.04173777f, 0.04045189f, 0.06291629f, -0.04975554f, 0.08422408f, 
    0.05694852f, 0.01751909f, -0.02795603f, 0.12468038f, -0.13471420f, 0.04857233f, -0.00541641f, -0.05398879f, 
    0.08612092f, -0.03480542f, 0.10887545f, 0.04334654f, -0.13924129f, 0.01454160f, -0.10790788f, -0.01803622f, 
    0.03154734f, 0.04816980f, 0.05806714f, 0.05341711f, 0.01371671f, 0.04623507f, -0.05482464f, 0.02692913f, 
    0.04953789f, -0.08376595f, 0.01992063f, -0.21618551f, -0.51395726f, 0.41976663f, 0.24246769f, 0.32520884f, 
    -0.26384622f, 0.07073066f, -0.02170258f, -0.04148669f, 0.21797706f, -0.04800551f, -0.07373883f, 0.00330779f, 
    -0.09906065f, -0.05659317f, 0.00310435f, -0.10203978f, -0.11922462f, -0.05467452f, -0.15672056f, -0.18876678f, 
    -0.13752785f, -0.20743178f, -0.21707091f, -0.00176587f, 0.16641822f, 0.01038891f, 0.06860774f, -0.07308339f, 
    -0.02126356f, 0.02395304f, 0.11460672f, -0.13645582f, -0.09989225f, -0.08017205f, 0.01339740f, -0.03127512f, 
    -0.06870630f, -0.04434570f, -0.04265111f, -0.02484666f, 0.04548104f, -0.01601271f, -0.45271301f, 0.31695768f, 
    0.15957864f, 0.16564539f, -0.04195810f, 0.09411535f, -0.03888488f, -0.11251676f, -0.04682204f, 0.00486681f, 
    0.05293630f, 0.02908112f, -0.03396082f, 0.13979168f, -0.09452920f, 0.29850227f, 0.00827370f, -0.19826327f, 
    -0.24915464f, 0.13041253f, -0.24922724f, 0.21454723f, -0.01895211f, 0.08007451f, -0.15393679f, -0.04193190f, 
    0.10383903f, 0.05140486f, 0.12204624f, -0.01445344f, -0.14497125f, 0.09424918f, 0.20688446f, -0.02697870f, 
    0.21770190f, 0.20188476f, -0.04715644f, 0.00410450f, -0.02593813f, -0.12584448f, -0.28184587f, -0.03453688f, 
    -0.04762471f, 0.01755184f, 0.01699654f, -0.04607163f, -0.07173917f, -0.03749106f, 0.14204580f, 0.08904313f, 
    -0.01613710f, 0.14780255f, -0.16808452f, 0.04213361f, -0.08925753f, 0.09288771f, 0.16463050f, 0.21221510f, 
    -0.09705938f, 0.06147164f, -0.07291822f, 0.18453828f, 0.01913327f, 0.00430824f, -0.27748358f, 0.14837250f, 
    0.04298361f, -0.13728145f, -0.15272586f, 0.02332525f, -0.17367904f, -0.03560765f, -0.02975169f, 0.03260396f, 
    0.14700128f, 0.18957327f, -0.08569895f, 0.06963418f, -0.44834334f, 0.06735986f, -0.23723586f, -0.11746939f, 
    -0.25349331f, -0.12232928f, -0.05739291f, -0.06069998f, -0.19610496f, 0.02787774f, -0.05229925f, -0.03804597f, 
    -0.03526005f, 0.03934200f, 0.00047702f, -0.22917351f, -0.22286367f, 0.04027668f, -0.09849811f, -0.07773509f, 
    0.09527525f, -0.03678443f, 0.28912288f, -0.20843883f, -0.22310415f, 0.22705120f, 0.13188772f, 0.13000539f, 
    -0.28646749f, -0.08957107f, 0.02621110f, 0.03037799f, 0.02348194f, -0.01438805f, 0.00406618f, -0.06138158f, 
    0.00894981f, -0.01055956f, 0.24729352f, 0.22331966f, -0.54150206f, 0.53751683f, 0.04483015f, 0.13010107f, 
    0.03021711f, 0.07981966f, 0.05159175f, -0.05402222f, 0.09411614f, -0.01276161f, -0.12212958f, -0.02560614f, 
    0.04266434f, 0.03547565f, -0.04273436f, -0.29506445f, -0.18089500f, 0.07580484f, -0.00387339f, -0.23646241f, 
    -0.40936431f, -0.14161089f, -0.40146378f, 0.22945471f, -0.35755888f, 0.25489098f, 0.06582569f, -0.10872632f, 
    0.06966825f, 0.16079967f, -0.03731789f, 0.02462747f, 0.00163090f, -0.02858664f, 0.04974503f, -0.06676774f, 
    -0.11748198f, 0.23187546f, -0.03810862f, 0.04516922f, 0.29915479f, -0.09738529f, 0.22262216f, -0.02414395f, 
    -0.27089518f, 0.18183832f, 0.23272534f, -0.20982653f, 0.11518460f, 0.20053694f, 0.02440400f, 0.02670804f, 
    -0.06935303f, 0.15195112f, 0.02169335f, 0.04073292f, -0.02690369f, -0.00857892f, -0.06610647f, 0.17826942f, 
    -0.81128418f, -0.15541804f, 0.04051009f, -0.29196811f, -0.55979025f, -0.08180532f, 0.07078009f, -0.07587969f, 
    -0.07179537f, -0.14302152f, -0.03325834f, 0.08592619f, -0.08780111f, 0.05769257f, 0.18883924f, -0.03008256f, 
    -0.03745777f, -0.03472300f, 0.11027397f, 0.10676691f, -0.14617145f, -0.05385596f, 0.37843734f, 0.01651333f, 
    -0.16611797f, 0.00092776f, 0.00842504f, 0.07608634f, 0.11618287f, 0.08385690f, 0.04775167f, 0.00569935f, 
    -0.04003512f, 0.06655324f, -0.04437759f, 0.14909750f, -0.07530067f, -0.05973956f, 0.03968767f, 0.02427298f, 
    -0.11879846f, -0.18222727f, -0.06785696f, 0.19537365f, 0.33519748f, 0.07144975f, 0.01718764f, -0.08892480f, 
    0.00486215f, -0.04080401f, -0.00337995f, -0.09364033f, -0.05450895f, 0.04782932f, 0.06616949f, -0.25963688f, 
    -0.08407850f, 0.21664646f, -0.01269281f, -0.16197877f, 0.00228256f, -0.24925938f, -0.15750632f, 0.00752559f, 
    0.08166027f, 0.14941376f, -0.17851868f, -0.04537148f, 0.08321267f, 0.04654415f, -0.02599395f, 0.16581547f, 
    0.16958439f, 0.08511718f, 0.10635483f, 0.06924933f, 0.22828628f, 0.00285882f, -0.04375015f, 0.16213974f, 
    -0.02516239f, -0.23078914f, 0.36843202f, 0.25419345f, -0.43685177f, 0.09544011f, -0.20277084f, -0.07907417f, 
    -0.04804462f, 0.22850023f, 0.05880040f, 0.13086557f, 0.02505374f, -0.02421293f, 0.00984796f, 0.02983109f, 
    0.06583665f, -0.02401355f, -0.18308294f, -0.05161048f, 0.20413491f, 0.08920603f, 0.15673278f, 0.11118507f, 
    0.05563012f, 0.11021837f, 0.04638996f, 0.09046033f, 0.20447953f, 0.02112578f, 0.11825967f, 0.05461477f, 
    0.07833643f, 0.02098512f, 0.00737178f, -0.04407708f, 0.04360411f, -0.07797473f, -0.02191099f, -0.29998052f, 
    -0.00899894f, -0.14344415f, -0.10666016f, 0.07592673f, 0.08076133f, 0.03131308f, 0.05976913f, -0.14689572f, 
    0.13903619f, -0.06154373f, 0.09886080f, -0.09501255f, 0.08366127f, 0.08356900f, -0.01198385f, 0.11232221f, 
    0.04857025f, 0.20807379f, 0.11060275f, 0.16913652f, -0.15655899f, -0.16359155f, -0.13447341f, 0.17247853f, 
    0.00697936f, -0.07014794f, -0.00100233f, -0.02333830f, -0.02721210f, 0.04082500f, 0.01489484f, -0.07325500f, 
    0.03086314f, 0.10712182f, 0.02674867f, 0.16752203f, -0.08279968f, -0.05973177f, 0.00607571f, 0.05547467f, 
    0.79548204f, 0.26318172f, -0.07411195f, -0.12111378f, 0.20338258f, -0.20902959f, -0.24938583f, -0.07326140f, 
    -0.27698651f, 0.11482805f, 0.10856266f, 0.04867145f, 0.03828942f, -0.11394080f, -0.07263391f, 0.15810995f, 
    -0.14925236f, -0.09956677f, 0.06953079f, -0.00905172f, -0.33666170f, 0.14442189f, 0.21988057f, -0.26871717f, 
    -0.07080457f, -0.05298740f, 0.06617341f, 0.08069924f, -0.02057844f, 0.08301473f, 0.20459780f, 0.08130715f, 
    -0.11090522f, -0.13493034f, -0.03020334f, -0.03440775f, 0.03292924f, 0.08910794f, 0.05926231f, 0.07601100f, 
    -0.30481791f, -0.00548593f, -0.05312542f, -0.36704850f, -0.17847088f, 0.02074401f, 0.09683211f, 0.00981926f, 
    -0.18738511f, 0.08150946f, -0.10672797f, 0.12425718f, -0.11534079f, -0.16602580f, -0.05716752f, -0.06187698f, 
    -0.10302114f, -0.01013548f, 0.03171502f, -0.00029398f, -0.23465855f, 0.01101056f, 0.32545191f, -0.21015088f, 
    -0.05269732f, 0.25279915f, -0.07343708f, 0.23124316f, 0.00156422f, -0.16795917f, -0.00934200f, -0.04299108f, 
    0.04648527f, 0.08073674f, 0.06088936f, 0.05478796f, 0.00337289f, -0.06118809f, -0.05119583f, 0.14251554f, 
    0.20368911f, -0.05390101f, 0.06038336f, 0.04390523f, -0.05413488f, -0.01518960f, -0.07288919f, 0.02866376f, 
    0.14185409f, 0.17041580f, -0.07735629f, -0.01971500f, -0.09032498f, -0.12484009f, 0.06853662f, 0.02371789f, 
    0.09322413f, -0.00318365f, -0.09164397f, 0.34970954f, 0.12300066f, -0.52472270f, -0.30945876f, -0.18391755f, 
    -0.27001983f, 0.18398887f, -0.01716367f, -0.04609492f, 0.02025191f, 0.10951660f, 0.10351980f, 0.16006845f, 
    -0.14169781f, 0.04334583f, 0.03178677f, -0.07950681f, -0.01947072f, 0.00023169f, 0.02013080f, 0.07218567f, 
    -0.28931612f, 0.21898042f, 0.13519207f, -0.23402128f, -0.04349535f, 0.10989291f, 0.06033393f, 0.01457740f, 
    -0.07997427f, 0.24696229f, -0.04268540f, 0.22433501f, -0.09268484f, -0.13376619f, -0.06856968f, 0.09019263f, 
    -0.09277235f, -0.03088650f, 0.01942409f, 0.10426715f, 0.03026082f, 0.12704825f, 0.07570932f, -0.11307309f, 
    -0.13097540f, -0.03490612f, -0.05198133f, 0.13308419f, -0.10587289f, -0.14741975f, 0.05840516f, -0.03272576f, 
    -0.05579653f, -0.09328771f, 0.07510930f, 0.05087651f, 0.10227939f, 0.04431335f, -0.12808941f, 0.13361719f, 
    -0.13510068f, 0.13140397f, -0.20088661f, -0.35141501f, 0.30818844f, 0.01725789f, 0.05455636f, -0.00777607f, 
    -0.08169843f, -0.02209968f, 0.08854325f, 0.00890716f, -0.07225210f, -0.13576923f, 0.01438586f, -0.39173764f, 
    -0.07091092f, 0.04424387f, 0.15143287f, -0.15640530f, -0.63195723f, -0.04151792f, 0.12097122f, -0.11596679f, 
    0.40733230f, -0.02273143f, -0.03570579f, -0.17005506f, -0.04153543f, -0.07444438f, 0.14427242f, -0.09212654f, 
    0.30324891f, -0.10028298f, 0.07496739f, 0.14033972f, -0.14640968f, -0.21134667f, 0.18226866f, -0.06413735f, 
    -0.39164707f, -0.25453410f, -0.70485580f, -0.07047931f, 0.13836955f, -0.16167580f, 0.10921753f, -0.08773141f, 
    -0.17445420f, -0.35339174f, 0.01248802f, -0.03170307f, -0.04202192f, 0.05648351f, 0.09461261f, -0.07587339f, 
    -0.05131174f, 0.23856528f, 0.23778540f, 0.10554395f, 0.19804393f, -0.00732021f, -0.22859600f, -0.20548129f, 
    0.07903741f, 0.05065668f, 0.05718526f, 0.16648245f, 0.00928456f, 0.02763224f, -0.02711856f, 0.01331331f, 
    -0.01162109f, -0.09082083f, 0.01251320f, -0.02361580f, -0.07980516f, 0.01342861f, 0.08663598f, 0.12837718f, 
    -0.44287673f, -0.36092946f, -0.91606051f, -0.36259979f, 0.07769410f, -0.01151585f, 0.03023253f, -0.06211305f, 
    0.00380333f, -0.21295404f, 0.00779335f, -0.02709689f, -0.04600840f, 0.00228511f, 0.01689953f, -0.09209900f, 
    -0.04060267f, 0.04575071f, 0.23003289f, -0.04048550f, -0.17151077f, 0.16576339f, -0.18088332f, 0.06676911f, 
    0.19804032f, -0.06596272f, 0.03250599f, -0.03969140f, 0.04782664f, 0.17959979f, -0.05721135f, 0.01933606f, 
    0.08588286f, 0.04061782f, -0.02084649f, -0.04772369f, 0.12616414f, -0.12445177f, 0.12944207f, -0.09409460f, 
    0.20105541f, -0.17015968f, 0.00278402f, -0.11833213f, 0.11841697f, -0.02096427f, 0.02513190f, 0.03930290f, 
    -0.10647995f, -0.04762221f, -0.09674327f, -0.08435857f, -0.12277241f, -0.08211283f, -0.10416166f, 0.00664689f, 
    -0.15835394f, -0.00858184f, -0.13010371f, 0.00222174f, 0.19185719f, -0.14099400f, -0.04534426f, -0.00613854f, 
    0.11547201f, 0.05206014f, 0.04513648f, 0.22202088f, -0.02018375f, -0.01919406f, -0.05721466f, -0.04491089f, 
    -0.10196532f, -0.05013969f, -0.01145571f, -0.11535247f, -0.07178620f, 0.02795448f, 0.00364712f, 0.03400708f, 
    -0.00198835f, 0.09048682f, -0.03391868f, 0.02542864f, 0.06844092f, -0.06941337f, 0.03549679f, -0.01781214f, 
    -0.00726102f, 0.14534916f, 0.02911134f, 0.08277074f, 0.16234507f, 0.02133718f, 0.15736106f, -0.10414863f, 
    0.18405418f, -0.13677056f, -0.03049295f, -0.07021920f, -0.08219147f, 0.06388640f, 0.21576193f, -0.15594637f, 
    0.06328392f, 0.07545892f, -0.07610317f, 0.05088549f, -0.07578923f, 0.02328538f, 0.07396721f, 0.21760985f, 
    -0.13490230f, 0.12390794f, -0.07415538f, -0.00510281f, -0.06857961f, -0.02564600f, -0.16665676f, 0.01982892f, 
    0.06307007f, -0.13292268f, -0.08251170f, -0.08064907f, 0.19332451f, -0.13216671f, 0.05366725f, 0.04988598f, 
    0.05874518f, -0.04422152f, 0.05127517f, 0.02615762f, -0.11461000f, -0.01557222f, 0.06766155f, -0.02228341f, 
    -0.06266377f, 0.05076596f, 0.12438909f, -0.09672495f, -0.32323086f, -0.54691905f, -0.39241543f, -0.20001604f, 
    0.50353664f, 0.02245659f, 0.00523262f, -0.03664618f, -0.06222296f, 0.09734671f, -0.01909432f, 0.04644247f, 
    0.03338377f, 0.09648504f, -0.16412133f, 0.02617769f, 0.04131287f, -0.01838596f, 0.14649743f, -0.01957798f, 
    -1.08817196f, -0.66446537f, -0.34221750f, -0.06141059f, -0.42414060f, -0.26696178f, -0.13538598f, -0.19153225f, 
    -0.21059889f, -0.46701455f, -0.00181251f, -0.06129448f, -0.00579379f, -0.03391428f, 0.01357392f, -0.01394895f, 
    -0.01930186f, 0.12208620f, 0.04157700f, -0.19775242f, -0.35775489f, 0.05333873f, 0.00386228f, -0.11038102f, 
    0.15073709f, -0.14105415f, 0.14835708f, 0.03519916f, 0.05851168f, 0.12374386f, -0.04266078f, -0.02463373f, 
    0.07324315f, 0.02567786f, 0.01873972f, 0.10943605f, 0.01881031f, 0.11469561f, 0.09638070f, -0.00975922f, 
    0.24936120f, -0.53177416f, -0.79904819f, -0.28800988f, 0.18781444f, -0.13050291f, 0.23969340f, 0.36426482f, 
    -0.06079608f, -0.06062961f, -0.06274580f, -0.01799012f, -0.04631698f, 0.01266111f, 0.03734940f, -0.06792729f, 
    -0.09337904f, -0.08907546f, 0.13972445f, 0.24278861f, 0.02390544f, 0.11233822f, -1.36536229f, -0.29793477f, 
    -0.39005095f, -0.04101806f, 0.19509295f, -0.13826118f, 0.02811371f, -0.29600611f, 0.07235327f, 0.01035691f, 
    -0.08847518f, -0.00135024f, 0.01455811f, 0.01738829f, -0.05545085f, 0.21332540f, -0.00526996f, 0.00875519f, 
    -0.33805484f, -0.38192829f, 0.42731312f, 0.32387736f, -0.26037967f, 0.01854906f, -0.05029470f, -0.03449864f, 
    0.09356665f, 0.10512120f, -0.10886408f, 0.14457850f, 0.17144275f, -0.10718998f, -0.23237836f, 0.10889575f, 
    0.16768889f, -0.02812241f, -0.13102889f, 0.12114132f, -0.09674095f, -0.31031218f, -0.09022520f, 0.27811423f, 
    -0.11623558f, 0.01762743f, -0.00099970f, -0.05224410f, -0.03122490f, 0.00618306f, -0.06226758f, 0.01665530f, 
    0.06042746f, 0.11100326f, -0.09760308f, 0.05956434f, 0.00333241f, 0.07904138f, 0.10661051f, 0.07371590f, 
    -0.01261311f, 0.07428236f, 0.01010329f, -0.14674889f, -0.07827849f, 0.01079385f, -0.00149535f, 0.02245237f, 
    -0.04866605f, -0.02800423f, 0.02365118f, -0.12535290f, -0.01207997f, -0.13109314f, -0.11570712f, -0.05157971f, 
    0.06806663f, -0.29250214f, -0.00940206f, 0.14615740f, 0.11588706f, 0.10221762f, -0.20153448f, -0.12969773f, 
    0.05313874f, -0.03395322f, -0.05018610f, 0.03083029f, 0.03051146f, 0.17416796f, 0.00689986f, 0.05620728f, 
    -0.03194491f, -0.09527250f, 0.00179473f, 0.00129219f, 0.08667905f, -0.20211855f, -0.04551385f, -0.01959573f, 
    -0.58959407f, -0.50144756f, -1.05032659f, -0.33793592f, 0.26643616f, -0.18541406f, 0.34505108f, 0.23616053f, 
    -0.02465010f, 0.02205049f, -0.04346784f, -0.06820828f, 0.00181149f, 0.05041644f, 0.01612565f, 0.08644010f, 
    0.08075903f, -0.21372177f, 0.17150536f, -0.03406413f, -0.52153921f, -0.42740780f, -0.84301013f, -0.13827379f, 
    -0.22451255f, -0.11782114f, 0.15963838f, 0.02940520f, -0.02300180f, -0.48227769f, 0.06317625f, -0.04906058f, 
    -0.03784817f, 0.08618371f, 0.05475714f, -0.06221087f, -0.07384405f, 0.20813312f, 0.07650483f, 0.07909097f, 
    -0.01837359f, 0.04103481f, 0.05222701f, 0.05319896f, 0.07366313f, -0.00588090f, -0.00619556f, 0.02993712f, 
    -0.06616244f, -0.00151384f, 0.07328881f, -0.12408022f, -0.17486840f, 0.09121535f, -0.00622216f, -0.00218054f, 
    -0.19385774f, -0.09269541f, -0.09545165f, -0.12940146f, 0.08079948f, -0.05311018f, -0.03744254f, 0.00545777f, 
    0.14090748f, -0.02557928f, 0.07111736f, 0.05342018f, 0.03815092f, 0.08919676f, 0.04602510f, -0.11834148f, 
    -0.02780985f, -0.08950938f, -0.08301705f, -0.10104230f, -0.03510996f, -0.10822963f, -0.03202130f, -0.04586766f, 
    0.04712136f, -0.36404479f, -0.86975926f, -0.69025016f, -0.17449319f, -0.26169515f, 0.07048606f, 0.04044342f, 
    0.24238047f, -0.30205697f, 0.03735320f, 0.02751248f, 0.13284439f, -0.04709762f, -0.04873800f, 0.07622624f, 
    0.10454756f, -0.13958432f, 0.11027841f, 0.06593397f, -0.62460327f, -0.06316664f, 0.54391962f, -0.04497128f, 
    -0.23647891f, -0.05563967f, -0.20910117f, 0.01989063f, -0.11788437f, 0.10097644f, 0.00752216f, 0.11675707f, 
    0.06797516f, -0.01483115f, 0.05124957f, 0.05911990f, 0.05244598f, 0.03111439f, -0.11107794f, -0.05616514f, 
    -0.69672012f, 0.73013169f, 0.52313191f, -0.02719622f, 0.48307449f, -0.05627849f, -0.03617805f, -0.04511247f, 
    0.03133293f, -0.01614729f, 0.11003274f, 0.13071397f, 0.15366583f, 0.12513910f, 0.11546969f, 0.05987980f, 
    -0.01352269f, 0.11297121f, 0.01061526f, 0.00315384f, -0.87656605f, -0.46080488f, -0.69854122f, -0.26296017f, 
    -0.25380749f, 0.00594132f, -0.07440110f, -0.12070116f, -0.00536105f, -0.21746781f, 0.01527033f, -0.03709600f, 
    -0.04639340f, 0.01505253f, -0.05048352f, -0.05462370f, -0.02892263f, 0.10019314f, 0.19270426f, 0.13085315f, 
    0.30941069f, 0.16634184f, -0.41658121f, -0.12572443f, 0.20275345f, -0.04639465f, -0.03955233f, 0.01424782f, 
    0.33346641f, 0.02144682f, 0.05182628f, 0.09724861f, -0.23144567f, -0.05281937f, 0.11748472f, -0.05623123f, 
    0.00129050f, 0.03765740f, -0.02787576f, 0.03683955f, -0.58474380f, 0.81074536f, 0.53728920f, 0.06728925f, 
    0.31756297f, -0.06308419f, -0.00360672f, -0.19811215f, -0.11826730f, 0.24377331f, -0.03876712f, 0.01050205f, 
    0.13282357f, 0.03102942f, 0.15387172f, 0.02570466f, 0.07313169f, -0.10277739f, 0.13610427f, -0.03081148f, 
    -0.36838725f, 0.54938829f, -0.15532145f, 0.08824810f, 0.14406514f, 0.25374526f, -0.12122340f, 0.01574169f, 
    0.10379309f, -0.17807777f, 0.02933854f, 0.12998016f, 0.02741688f, 0.17674224f, 0.03859450f, 0.06174427f, 
    -0.09522426f, 0.17898169f, -0.27378839f, 0.02466497f, 0.07970499f, -0.42976257f, -0.32214692f, -0.01498030f, 
    0.21251173f, -0.08169061f, 0.15393513f, -0.01118817f, 0.03098247f, -0.37429208f, 0.12281125f, 0.03272077f, 
    -0.08656608f, -0.12051229f, 0.07428955f, -0.02636246f, 0.00182420f, 0.11346326f, 0.21425131f, -0.19691059f, 
    -0.30575374f, -0.34111068f, -0.04481098f, 0.05286841f, -0.40823242f, -0.00537554f, 0.12483647f, 0.06284266f, 
    -0.06444499f, -0.15626319f, 0.04508675f, -0.05490767f, -0.05947673f, -0.00364745f, -0.00785237f, 0.24744754f, 
    0.13538216f, 0.01694676f, -0.36239612f, 0.02708594f, -0.02918139f, 0.14521195f, 0.15342706f, -0.14046457f, 
    -0.03628391f, 0.06611823f, 0.08211814f, 0.14189734f, -0.05363468f, 0.02588314f, 0.07298518f, -0.05343425f, 
    0.01442418f, -0.00046470f, 0.06008706f, 0.22539614f, -0.01185865f, 0.03867121f, -0.36251071f, 0.05360694f, 
    -0.35632229f, -0.45020506f, -0.06412552f, 0.38392884f, 0.02265355f, 0.03932986f, -0.08171903f, 0.03597048f, 
    0.01191738f, 0.20166260f, 0.03653427f, -0.05624525f, -0.14259245f, -0.08971988f, -0.11537015f, 0.04977052f, 
    0.16419776f, 0.00083290f, 0.10895843f, -0.08111645f, -0.04938689f, 0.15769015f, -0.01264515f, -0.03812931f, 
    -0.13325672f, -0.05531675f, -0.03330849f, -0.01158273f, -0.06601015f, -0.07128234f, 0.10004622f, 0.02535142f, 
    0.05333127f, 0.00232891f, -0.01325341f, 0.02114889f, -0.22960404f, 0.03012163f, -0.01560114f, 0.00727128f, 
    -0.35499269f, -0.37087783f, -0.24833496f, -0.25746620f, -0.08290579f, 0.12074892f, -0.03873573f, 0.01817901f, 
    0.05820374f, 0.08141749f, 0.00612536f, 0.01641291f, -0.06853612f, -0.00464010f, -0.01627425f, 0.07046911f, 
    0.09859546f, 0.02611054f, -0.08293922f, -0.07856535f, 0.27656108f, 0.10406730f, -0.00745209f, 0.29249120f, 
    -0.31365585f, -0.04621489f, 0.09601349f, -0.14492363f, 0.08864032f, -0.06124184f, -0.07831549f, 0.02814027f, 
    -0.05826512f, -0.06568045f, -0.08724627f, -0.12653935f, -0.00918510f, -0.12096933f, 0.01919775f, 0.12371227f, 
    0.05762398f, 0.19422215f, 0.14837188f, -0.06364146f, -0.03601582f, -0.01899412f, 0.00839160f, -0.05509559f, 
    0.02474646f, -0.00595653f, 0.07665199f, 0.03505505f, 0.06468750f, 0.04144596f, -0.03866216f, -0.15672474f, 
    -0.20972395f, 0.07150917f, 0.09628060f, -0.01381728f, -0.06622251f, 0.16911159f, -0.01640959f, -0.00554973f, 
    -0.21279313f, -0.01557052f, -0.02089296f, -0.02797108f, -0.05612499f, -0.03234212f, 0.06225882f, 0.05798097f, 
    0.05301553f, -0.01000416f, 0.00476760f, -0.04344305f, -0.29809186f, 0.19096710f, -0.07067651f, -0.00732831f, 
    0.17894486f, 0.28177428f, -0.06213755f, -0.06251259f, -0.36594251f, -0.04653868f, 0.06493244f, 0.06609979f, 
    -0.03718548f, -0.15460436f, -0.20469002f, -0.00427218f, -0.10547337f, -0.20318323f, -0.22135407f, -0.00363179f, 
    -0.06996782f, -0.00434952f, -0.03124538f, -0.06492642f, 0.17445999f, 0.15104441f, -0.00527804f, -0.02028617f, 
    -0.13823098f, -0.08430351f, 0.11442109f, 0.01249105f, -0.06345460f, -0.09621333f, -0.14199358f, -0.29039073f, 
    0.11173682f, -0.00096557f, -0.05667470f, -0.03658820f, 0.01642179f, 0.12599324f, -0.06111061f, -0.03561414f, 
    -0.01310138f, -0.00855346f, -0.10400266f, 0.08455379f, -0.16814151f, 0.09348451f, 0.03602691f, 0.20188996f, 
    0.02331341f, -0.04396344f, 0.03829031f, 0.00172266f, 0.10042728f, 0.01911651f, -0.06065302f, 0.04854790f, 
    0.00366941f, -0.00110532f, -0.03395218f, -0.02558200f, 0.71970302f, -0.68135202f, -0.60535091f, -0.58535641f, 
    -0.32470456f, 0.13421246f, 0.07616195f, -0.08929043f, 0.20314443f, 0.05770151f, 0.01407360f, 0.08362782f, 
    -0.03967424f, 0.06743507f, 0.07393222f, -0.20282894f, -0.02913280f, -0.06797653f, 0.05194981f, 0.04919809f, 
    -0.21453987f, -0.64093971f, 0.39887357f, 0.12151671f, 0.02936351f, -0.14027992f, 0.16387744f, -0.04428745f, 
    0.07167973f, 0.04054270f, -0.01588944f, 0.03935466f, 0.05608033f, -0.04097413f, 0.05701685f, -0.03683737f, 
    0.00620922f, -0.02473029f, 0.05047502f, -0.02430853f, 0.04194988f, 0.26476011f, -0.28912428f, 0.27746844f, 
    -0.36162907f, -0.03285757f, 0.10518725f, 0.00429276f, -0.10159799f, 0.01988010f, -0.00195507f, 0.00481792f, 
    0.00959347f, 0.00570405f, -0.04770986f, -0.08420618f, 0.01509158f, -0.02766503f, -0.00965527f, -0.00244640f, 
    -0.17608419f, 0.20635438f, -0.28215918f, 0.02345698f, -0.19028553f, 0.09345160f, 0.00634421f, -0.23793215f, 
    -0.20126732f, -0.01064115f, 0.05901101f, 0.05535368f, 0.08880048f, 0.00859536f, -0.00454567f, 0.04284309f, 
    -0.02817382f, -0.21322007f, -0.10486361f, 0.03328882f, -0.91341400f, -1.09576821f, 0.32434738f, 0.00375268f, 
    0.64181417f, 0.08564695f, -0.14046252f, 0.15038873f, -0.04635610f, -0.08496190f, -0.06028441f, 0.13494657f, 
    0.01205900f, -0.03509971f, -0.02902458f, 0.06262986f, 0.07369588f, -0.05655981f, -0.02861005f, -0.20984289f, 
    0.63213521f, -0.50582963f, -0.07015471f, -0.44538161f, 0.24936996f, 0.10100522f, 0.22296412f, -0.08700791f, 
    0.19293270f, 0.19332159f, -0.04382318f, 0.02341182f, 0.04210412f, -0.20597509f, 0.18968454f, -0.17510261f, 
    0.07922595f, -0.08721413f, 0.00579206f, 0.03821063f, 0.39474475f, -0.64159131f, 0.41846937f, 0.11255655f, 
    0.00396202f, -0.10458910f, 0.04257473f, -0.24393949f, 0.10793313f, -0.01051817f, -0.05012261f, -0.01159571f, 
    0.00353874f, 0.04411989f, -0.03536767f, 0.05954528f, 0.04490088f, -0.06366878f, -0.00918498f, -0.08923223f, 
    -0.02136145f, 0.11386117f, 0.08334612f, 0.07639828f, -0.14863671f, 0.00563003f, 0.03321885f, 0.04274299f, 
    -0.07445068f, -0.05036124f, 0.10557666f, 0.06372401f, 0.06840789f, -0.00159449f, -0.00989394f, 0.06375390f, 
    -0.13871057f, -0.16021396f, 0.11006247f, 0.00951236f, 0.08464267f, 0.16809821f, -0.14039414f, 0.05488082f, 
    -0.20245974f, 0.06413294f, 0.04167917f, -0.00852314f, -0.05098952f, -0.06832772f, -0.17225090f, -0.05760679f, 
    -0.12746236f, -0.04418291f, -0.15088411f, -0.02637499f, -0.14234000f, 0.09943290f, 0.01739054f, -0.03221244f, 
    -0.39196363f, -0.16297278f, -0.57942581f, 0.42223451f, -0.16891977f, 0.15309234f, 0.05531024f, -0.22531964f, 
    -0.12277742f, 0.10930627f, 0.06328106f, 0.02008228f, -0.01287823f, -0.02836309f, 0.02678644f, 0.05882665f, 
    0.04236336f, -0.09988987f, 0.08139101f, 0.02396704f, -0.54805630f, -0.44320974f, 0.27745923f, 0.12712605f, 
    0.17200279f, 0.21774039f, -0.06130955f, -0.00821108f, -0.05557667f, 0.08790016f, 0.04735145f, -0.00275158f, 
    -0.04565015f, -0.04318314f, -0.05177404f, 0.19826901f, 0.10844610f, -0.07521232f, -0.06268909f, -0.07912491f, 
    -0.07100499f, 0.11929233f, 0.09360613f, 0.01910412f, -0.02865094f, 0.01896565f, 0.07114656f, 0.03205001f, 
    -0.05262504f, -0.13599573f, -0.08165341f, -0.04191296f, 0.02818171f, -0.07774469f, -0.18398352f, -0.04374257f, 
    -0.04685217f, -0.05087329f, 0.03211874f, 0.01675330f, 0.02141877f, 0.13459189f, 0.05685949f, -0.03019565f, 
    -0.07546952f, 0.00318184f, 0.03703507f, -0.07746626f, -0.00202232f, -0.11442504f, -0.01784562f, -0.00929772f, 
    0.03430641f, -0.06815467f, -0.03487100f, -0.09117128f, -0.09925572f, 0.07238708f, -0.03731051f, 0.01230300f, 
    -0.75884384f, 0.73519665f, -0.14822868f, 0.47676915f, -0.04383107f, 0.28452513f, -0.15644814f, 0.12891924f, 
    -0.07909524f, -0.04029271f, 0.10110372f, -0.06133461f, 0.03670246f, -0.04921058f, 0.10744600f, -0.01570029f, 
    0.18459712f, 0.08074779f, 0.01655131f, -0.07500287f, 0.71462297f, -0.50474089f, 0.03031720f, -0.31448591f, 
    -0.10891621f, -0.21528172f, 0.07781146f, -0.03046487f, 0.06961267f, -0.03405524f, -0.00777993f, -0.11910506f, 
    0.09917553f, 0.03652308f, 0.05844156f, -0.04728863f, -0.02764672f, -0.04715371f, 0.08381133f, 0.00195062f, 
    0.36262897f, -0.96961433f, -0.79934400f, -0.23681073f, -0.08412710f, -0.15392329f, -0.13718505f, 0.06134553f, 
    0.27578610f, -0.07087006f, -0.10549515f, 0.06022346f, 0.00286031f, 0.06696656f, 0.07526094f, 0.01260488f, 
    0.03084665f, -0.00823831f, 0.06811964f, 0.00690247f, 0.39522409f, -0.40941077f, 0.56510985f, -0.17879105f, 
    -0.26316598f, -0.14062554f, 0.11512469f, -0.06215394f, 0.09616034f, 0.12420870f, 0.00096760f, -0.05318549f, 
    -0.03516505f, -0.04152351f, -0.05319007f, 0.00741629f, -0.02059785f, -0.22252585f, -0.09795183f, 0.02760895f, 
    -0.07866083f, -0.22507124f, -0.12837508f, 0.08427761f, -0.06315719f, 0.15148509f, 0.04741744f, 0.05570955f, 
    0.08134129f, 0.01297585f, 0.05899822f, -0.06593655f, 0.01085640f, 0.02172761f, -0.04102753f, 0.09308201f, 
    0.03872075f, 0.02355609f, -0.04227404f, 0.06398472f, 0.70553052f, -0.28697735f, -0.41770750f, -0.38408726f, 
    -0.21136580f, -0.06102790f, -0.23948921f, -0.20193215f, 0.18077663f, -0.13875191f, 0.01649990f, 0.07182492f, 
    -0.01563114f, 0.05036341f, 0.08486616f, 0.03646201f, 0.05143647f, -0.08703986f, 0.07437363f, 0.02147591f, 
    -0.51843977f, -0.64335334f, 0.65164959f, -0.57095265f, 0.41315514f, -0.39988646f, 0.17257637f, 0.06910401f, 
    0.12203325f, -0.01861844f, -0.03009478f, 0.02554250f, -0.08502998f, -0.08048643f, -0.08591476f, -0.18820648f, 
    -0.06452959f, -0.05446552f, -0.05613054f, 0.00286553f, -0.38907245f, -0.31293017f, 0.06107439f, 0.33310410f, 
    -0.16548666f, 0.10500389f, 0.09264212f, -0.04106358f, 0.15376356f, 0.15958339f, 0.04054798f, 0.05407427f, 
    0.04522187f, -0.01065418f, -0.01804085f, 0.04185969f, 0.03872433f, -0.20057936f, 0.14089939f, 0.10156386f, 
    -0.08014829f, 0.11673217f, 0.25721371f, -0.14772160f, -0.09796170f, 0.07091394f, 0.04012050f, 0.08809117f, 
    -0.04418094f, -0.00897072f, 0.10793328f, -0.00735657f, 0.12385584f, 0.03465267f, -0.00369298f, 0.21941096f, 
    -0.01120055f, -0.00933495f, -0.13570412f, -0.24213760f, -0.10702421f, 0.00603196f, 0.27788383f, -0.15312187f, 
    0.14038609f, 0.07180448f, 0.02892185f, 0.07469507f, -0.02104785f, -0.02848072f, 0.01050538f, -0.14267291f, 
    0.02401584f, 0.06158829f, -0.02767163f, -0.12852271f, -0.05630739f, -0.16557902f, 0.00187234f, 0.02582333f, 
    0.25722319f, -0.24240674f, -0.40922248f, -0.36618468f, -0.21595834f, -0.19227654f, -0.35717914f, -0.01673251f, 
    -0.18547484f, -0.33077848f, 0.00986060f, 0.02566667f, 0.00098461f, 0.15978105f, 0.13639683f, 0.14720836f, 
    0.10678639f, 0.24303235f, -0.16250482f, -0.31071845f, -0.36598256f, 0.23706371f, 0.18228117f, 0.09306905f, 
    -0.06597877f, 0.04487912f, 0.09840306f, -0.05956689f, 0.08298186f, -0.01821697f, -0.08858579f, -0.05389413f, 
    0.00648519f, 0.03122408f, -0.01716993f, -0.03853226f, 0.06401175f, 0.01187125f, 0.01737176f, -0.01378808f, 
    0.18349580f, -0.35776594f, -0.61562955f, -0.35012460f, -0.02483953f, -0.04609314f, -0.02210553f, 0.11578137f, 
    -0.05309296f, -0.14666240f, 0.08599047f, -0.06011723f, -0.04494458f, 0.02139781f, 0.13207886f, 0.08101984f, 
    -0.05647541f, 0.04641428f, -0.11241007f, -0.29247057f, 0.43380979f, 0.31345665f, -0.15330206f, -0.01608953f, 
    -0.08137219f, 0.00981349f, 0.04464696f, -0.10119434f, 0.08918235f, -0.14198561f, 0.04664520f, 0.06340693f, 
    0.04934052f, 0.04996111f, 0.08680615f, -0.14796120f, -0.15455672f, -0.01863159f, -0.13233970f, -0.19032288f, 
    -0.42965001f, 0.04762507f, 0.17459856f, -0.04705270f, -0.12668659f, -0.05230293f, -0.08553442f, -0.04456913f, 
    0.02129040f, -0.16287358f, -0.07720404f, -0.07028019f, -0.02124001f, -0.03667708f, -0.03805507f, 0.10566016f, 
    0.09259736f, 0.00592554f, -0.13278408f, 0.08804340f, -0.35542336f, 0.28935432f, 0.18110560f, 0.10596731f, 
    -0.17451710f, -0.04231171f, 0.07449628f, -0.08020921f, 0.04345960f, -0.03912887f, -0.07811812f, 0.02414302f, 
    -0.06156117f, 0.01862771f, 0.01998039f, -0.00275263f, 0.16536441f, 0.04424600f, 0.09772692f, -0.01348169f, 
    0.12992015f, 0.15676372f, -0.04664557f, -0.17250080f, -0.11556937f, -0.08891719f, 0.13348690f, -0.01194050f, 
    0.13779926f, -0.07673223f, 0.07641099f, 0.07776474f, 0.15631673f, 0.02943964f, 0.10916843f, 0.04849382f, 
    0.06638230f, -0.02891658f, 0.16604662f, 0.03704021f, -0.14896630f, -0.08641853f, -0.10922217f, -0.08988015f, 
    -0.22412528f, -0.10317857f, -0.02324914f, 0.07818913f, 0.10166692f, -0.01655374f, 0.03844546f, 0.13895012f, 
    0.10790922f, 0.05915298f, 0.14201163f, 0.03516957f, 0.20705953f, 0.01588604f, 0.13999286f, 0.11350308f, 
    0.18812408f, 0.05356110f, -0.04249264f, -0.03502914f, -0.15401725f, -0.08007587f, -0.06637379f, -0.10586657f, 
    -0.04711551f, -0.16594177f, -0.09363092f, 0.14001650f, 0.14267819f, -0.06996021f, -0.00628419f, -0.00380164f, 
    0.15294027f, 0.21400619f, 0.20858732f, 0.16882268f, -0.18542390f, -0.30579561f, -0.84000713f, -0.32943362f, 
    0.26860279f, -0.19569382f, 0.02124671f, 0.15695262f, 0.04256074f, 0.03237588f, -0.02415135f, -0.03642068f, 
    -0.03546112f, 0.03392990f, 0.04201826f, 0.14365427f, -0.08931550f, 0.01319779f, -0.10795483f, -0.13066672f, 
    -0.05441431f, -0.66233116f, -0.61885822f, -0.20158158f, -0.14217839f, -0.16636708f, -0.02726179f, 0.02526672f, 
    0.15167163f, 0.18337622f, -0.06589878f, -0.08651033f, -0.05050709f, -0.04039543f, 0.03977951f, -0.02141963f, 
    0.10362974f, 0.08815643f, 0.15171063f, 0.15036868f, 0.36249986f, 0.18645650f, 0.25157326f, 0.05970193f, 
    0.00322062f, -0.08167113f, 0.03883529f, -0.08463881f, 0.03756005f, -0.10651850f, 0.04687146f, 0.00036466f, 
    0.01266888f, -0.01352852f, 0.08704511f, 0.00745827f, -0.13997065f, -0.35718814f, -0.13425636f, -0.18842945f, 
    -0.13711861f, 0.51336771f, 0.29039863f, 0.25191295f, -0.13926901f, 0.19418035f, -0.21439356f, -0.08360576f, 
    -0.15318064f, -0.21143000f, -0.02921889f, -0.02828265f, 0.05016082f, -0.06801410f, -0.07935757f, -0.16144720f, 
    -0.08428109f, -0.03888347f, -0.13370749f, -0.28506845f, 0.84805006f, -0.69356859f, -0.60899889f, -0.04616575f, 
    0.37968761f, 0.28502008f, 0.09424870f, 0.01528755f, -0.16525045f, -0.01393502f, 0.00956357f, -0.03309119f, 
    0.04666154f, 0.01972300f, 0.00862147f, 0.00356840f, -0.04338580f, 0.17091261f, -0.11065695f, 0.12445196f, 
    -0.03685645f, 0.18623431f, -0.56975126f, -0.05531977f, -0.05898213f, -0.11773410f, -0.02401130f, 0.14262126f, 
    0.26270142f, -0.09007169f, 0.17536438f, 0.01621515f, 0.10570619f, 0.14936540f, 0.22164737f, -0.10336759f, 
    -0.03613650f, -0.00632534f, -0.08634199f, -0.00529011f, 0.17875159f, 0.30884823f, -0.32431677f, -0.22615428f, 
    0.09549566f, 0.20261560f, -0.22859387f, 0.18872304f, 0.04073384f, 0.12968682f, 0.06323146f, 0.05165643f, 
    0.00064578f, 0.17237735f, 0.11951496f, 0.06068267f, -0.06195125f, -0.03067688f, -0.19480371f, -0.12688750f, 
    -0.66275597f, 0.15147305f, 0.28035787f, 0.00642999f, -0.14721337f, -0.06940288f, -0.09906628f, -0.09546608f, 
    -0.05094697f, 0.01653117f, -0.08431266f, -0.13572289f, -0.04695895f, -0.00713554f, -0.00350809f, 0.04444987f, 
    0.06879311f, -0.00380653f, -0.08136529f, -0.07836087f, 0.04521955f, 0.16581467f, -0.00308672f, 0.01902155f, 
    -0.18851174f, -0.03289910f, 0.08168057f, 0.00551939f, -0.00551134f, -0.00369761f, 0.11648087f, 0.06132777f, 
    0.06371050f, 0.19545610f, 0.07117638f, 0.03214851f, 0.07801627f, 0.09951167f, 0.12517804f, -0.07056489f, 
    0.57139027f, 0.34155560f, 0.18280403f, 0.04116135f, 0.00655017f, 0.18486062f, -0.09294731f, 0.02284667f, 
    0.13411362f, -0.14437696f, 0.03946001f, -0.07267326f, 0.05713620f, 0.00007165f, -0.03591895f, 0.15146665f, 
    0.07768316f, -0.09209263f, 0.01235528f, -0.35519606f, 0.05323477f, -0.57742631f, -0.11974870f, -0.01539933f, 
    -0.02595519f, 0.07430277f, -0.02297380f, 0.12170130f, -0.22317216f, -0.22060998f, 0.06565538f, 0.02212559f, 
    0.04049870f, -0.00439429f, 0.04251799f, 0.14034562f, -0.05677905f, 0.06225530f, -0.13601871f, -0.31485623f, 
    0.08376228f, -0.00322726f, -0.02880767f, 0.08246671f, -0.19055599f, -0.08016635f, 0.09337202f, -0.10341819f, 
    -0.09961043f, 0.03171296f, 0.08919394f, 0.01936624f, -0.00929532f, 0.04030060f, 0.17470370f, 0.02707311f, 
    0.25000671f, 0.04981770f, 0.14020461f, 0.15475063f, 0.00133599f, 0.05992149f, 0.12822334f, -0.03227289f, 
    -0.04957360f, -0.00806996f, -0.03546128f, -0.04960970f, 0.03728303f, -0.03128794f, -0.04628570f, 0.03547050f, 
    0.01381375f, 0.08616526f, 0.05363736f, 0.09040113f, 0.06651367f, 0.03234630f, -0.00140090f, 0.07667183f, 
    -0.03506591f, -0.66791278f, -0.19378074f, 0.34969443f, 0.20757601f, 0.09124513f, 0.30696797f, -0.10688570f, 
    0.14786074f, -0.21963382f, 0.02467676f, -0.01142027f, 0.00009392f, 0.04680236f, 0.09043062f, 0.07240335f, 
    -0.06156009f, -0.05253871f, -0.20252009f, -0.24448606f, -0.05762888f, -0.31811911f, -0.49543566f, -0.16846703f, 
    -0.02028898f, 0.03209462f, -0.02720780f, 0.22278349f, 0.09786899f, 0.25623882f, -0.01131984f, 0.06300918f, 
    -0.02925569f, -0.06934377f, 0.02086092f, -0.09614515f, 0.00306434f, 0.09206200f, -0.00732445f, 0.12480946f, 
    -0.16840814f, -0.58615071f, -0.62297171f, 0.01783071f, 0.38410932f, -0.07803261f, 0.03702037f, 0.25475544f, 
    0.08070602f, 0.04924357f, 0.03258640f, -0.15014590f, -0.05172817f, 0.05495121f, -0.08903515f, -0.06924523f, 
    0.01288139f, -0.03247268f, -0.11063948f, -0.08399419f, -0.11770526f, -0.29435331f, -0.54651654f, -0.51727569f, 
    -0.32814139f, -0.08393412f, -0.19167107f, 0.05524744f, -0.08035183f, -0.42184928f, 0.04416624f, -0.01999273f, 
    -0.01198423f, 0.03244730f, 0.10264880f, 0.07623276f, 0.11419056f, 0.04700502f, 0.02094342f, -0.05019162f, 
    0.28509161f, -0.04011563f, -0.10276423f, 0.09556446f, -0.10834929f, 0.10037288f, -0.08898345f, -0.15037704f, 
    -0.12917402f, -0.12009440f, 0.06937291f, 0.05165137f, 0.13108008f, 0.10288954f, -0.03504036f, 0.00837566f, 
    0.03635720f, 0.19868261f, 0.14455123f, 0.21770790f, 0.16728257f, -0.79177886f, -0.76008785f, -0.41607013f, 
    0.14493747f, -0.06836000f, 0.06027238f, 0.12032077f, 0.27310720f, 0.20451087f, 0.07713595f, -0.11682879f, 
    -0.11807972f, -0.13481425f, -0.10512298f, 0.00545816f, -0.00836665f, 0.04795859f, 0.06889832f, -0.02547404f, 
    -0.04012116f, -0.57256591f, -0.30580419f, 0.19539730f, 0.33487839f, 0.13472749f, 0.02074846f, 0.17249873f, 
    0.03999446f, 0.06134704f, -0.00558194f, -0.11853789f, 0.00478904f, 0.03359505f, 0.06850193f, 0.06557050f, 
    0.19160025f, 0.03970876f, 0.09804691f, 0.02783997f, 0.36434796f, -0.02937691f, -0.04060616f, -0.03659003f, 
    -0.32092175f, -0.02508133f, -0.27554050f, -0.12762974f, -0.10001992f, -0.23219484f, -0.03278442f, 0.10312065f, 
    0.10360469f, -0.15257697f, 0.00939985f, -0.07359024f, 0.14173310f, 0.26400438f, 0.25284904f, 0.21229000f, 
    -0.91835415f, -0.35222927f, 0.41043633f, 0.22743818f, -0.16213694f, -0.10036834f, -0.07919851f, -0.15196148f, 
    -0.17619571f, -0.06088922f, -0.07884709f, -0.10415582f, -0.08757111f, -0.04294789f, -0.07713187f, 0.09414770f, 
    -0.48854485f, -0.07861463f, -0.22223245f, -0.01804879f, -0.57737571f, -0.04574963f, 0.24720323f, 0.12749732f, 
    0.11323912f, 0.01289709f, -0.10917075f, -0.08786525f, -0.10485043f, 0.10068050f, -0.05023295f, 0.01512920f, 
    -0.08296945f, 0.10269593f, 0.09638726f, -0.05323120f, 0.08294842f, -0.05585231f, -0.27835014f, 0.00496578f, 
    -0.01985362f, -0.46718183f, 0.03512318f, 0.12472098f, -0.20822325f, 0.01607739f, -0.24137560f, 0.03240896f, 
    0.09399143f, 0.21011463f, -0.00562330f, 0.10865897f, 0.08696696f, 0.02472258f, -0.03542114f, -0.02394289f, 
    0.05265190f, 0.08240785f, 0.19160780f, 0.16564402f, -0.15383311f, 0.07727187f, -0.36956131f, -0.05309846f, 
    0.04241723f, 0.03429484f, 0.18313509f, 0.18695514f, 0.06160642f, 0.14982240f, 0.15011957f, -0.08258887f, 
    -0.08806837f, -0.00571092f, -0.10101432f, 0.07303695f, 0.09236548f, -0.13812882f, 0.06110425f, -0.08792408f, 
    0.15384899f, -0.24854389f, 0.16067524f, 0.38366413f, -0.47151151f, -0.06316887f, -0.19713782f, 0.02821218f, 
    0.14504907f, 0.08368084f, 0.00287810f, 0.04464502f, 0.04853161f, 0.04000375f, 0.08876982f, -0.03682047f, 
    0.09066395f, 0.07629157f, 0.11697250f, 0.21406521f, -0.73325235f, -0.10766073f, -0.35167742f, 0.39435807f, 
    -0.20171084f, -0.02165090f, 0.08640189f, 0.02687906f, -0.05399252f, -0.02593101f, -0.00286172f, -0.09819554f, 
    0.06344961f, -0.02420132f, 0.01042641f, 0.00635848f, 0.00431421f, 0.06090118f, 0.18175286f, 0.17242882f, 
    -0.13202943f, -0.12859167f, -0.18045260f, 0.05973053f, -0.10317189f, 0.08706779f, 0.04565755f, 0.29420701f, 
    -0.00498597f, 0.09049045f, -0.01355213f, 0.04660084f, -0.14369433f, 0.03034005f, -0.05955625f, 0.14088258f, 
    0.00309277f, 0.20201889f, -0.01005411f, 0.09690842f, -0.25233847f, 0.06678057f, -0.47498393f, -0.31813076f, 
    0.09751586f, 0.10531574f, 0.13174999f, 0.17495577f, 0.06350064f, 0.17904323f, 0.15897049f, -0.11742856f, 
    -0.11971053f, 0.04971854f, -0.04367525f, 0.06555454f, 0.06703524f, -0.10230841f, -0.01747108f, -0.02334940f, 
    -0.38035151f, 0.13723966f, -0.02749356f, 0.29752868f, 0.10996253f, 0.03114542f, 0.12993181f, -0.05551112f, 
    -0.04935353f, -0.24309553f, 0.07921208f, 0.06122024f, 0.01399517f, -0.15777123f, 0.01019227f, 0.08087939f, 
    -0.08962543f, -0.10549943f, 0.01644398f, 0.08180058f, -0.18093097f, 0.17714266f, 0.06940399f, 0.03183623f, 
    0.13888083f, -0.14958808f, -0.12862720f, -0.18436445f, -0.08927549f, -0.06276202f, 0.15194723f, 0.09115446f, 
    0.16640404f, 0.08594126f, -0.13957292f, 0.14075421f, -0.07960642f, -0.01432491f, -0.13620640f, -0.00130593f, 
    -0.19231568f, 0.24513458f, -0.15439807f, -0.00359234f, -0.05566894f, 0.08855154f, 0.00676910f, 0.14376052f, 
    -0.04530182f, -0.04788505f, 0.15695208f, -0.02875406f, 0.01715733f, -0.09437001f, -0.10968710f, 0.10234644f, 
    -0.06206146f, -0.18338710f, 0.07407761f, -0.15096469f, 0.06309244f, 0.20441329f, 0.11726277f, 0.65259826f, 
    -0.73297954f, -0.01386402f, -0.16434194f, -0.23646499f, 0.08472048f, -0.12682977f, 0.02734186f, -0.00195547f, 
    0.07752705f, 0.04925567f, -0.04646821f, 0.07411152f, 0.11053914f, 0.11481381f, 0.05237750f, 0.11643096f, 
    -0.11065228f, -0.21380101f, 0.27421910f, -0.06852716f, -0.21855247f, -0.05193771f, -0.17737788f, 0.24035908f, 
    0.16608474f, 0.22422588f, -0.08964560f, 0.05497948f, 0.05730157f, -0.04383085f, -0.05862823f, 0.02134472f, 
    0.00381572f, 0.02076457f, -0.13205957f, -0.20788974f, -0.26863557f, -0.04514106f, -0.46873790f, 0.14437079f, 
    -0.09442972f, 0.08409480f, -0.10582856f, 0.16467674f, -0.14575759f, 0.09610680f, -0.01403463f, -0.07090838f, 
    0.00261098f, 0.08868585f, -0.01898827f, 0.02318802f, 0.04132744f, 0.09595912f, -0.00556037f, 0.05930585f, 
    -0.13135712f, 0.22028653f, -1.03357697f, 0.24175504f, 0.09049774f, 0.19872145f, 0.06371638f, 0.28034851f, 
    0.03642070f, 0.01521139f, 0.00154034f, -0.06719548f, -0.03372574f, -0.01404648f, -0.13211364f, -0.05198080f, 
    0.07909257f, -0.10517195f, 0.00885116f, -0.06469807f, -0.06464744f, -0.12111093f, 0.37208879f, -0.34389743f, 
    -0.31713852f, -0.00017838f, -0.49818158f, 0.02272414f, 0.01512828f, 0.08124274f, -0.04621354f, 0.05042762f, 
    0.06556927f, -0.12745833f, -0.00620752f, -0.01691595f, 0.07137050f, -0.02067889f, -0.06325826f, -0.09217688f, 
    -0.71409202f, -0.46968913f, -0.11917632f, 0.31674108f, 0.00177157f, -0.61044610f, 0.40094361f, -0.71317273f, 
    -0.05109478f, -0.17391756f, 0.09252635f, -0.06845662f, 0.02035207f, 0.02577986f, 0.02964832f, 0.14732592f, 
    0.13741209f, -0.11050669f, -0.00111951f, 0.08383801f, -0.44938725f, -0.07045122f, -0.31834498f, -0.02037084f, 
    -0.29763496f, -0.20773491f, 0.20852005f, -0.02500844f, -0.00581303f, 0.21716912f, 0.07214893f, -0.04445425f, 
    0.06543094f, 0.03987943f, -0.01454332f, 0.03348433f, 0.10088915f, -0.01537471f, 0.15506865f, -0.01613735f, 
    -0.11003818f, -0.20659718f, -0.34596485f, -0.40903699f, 0.25193587f, -0.03023868f, 0.05141347f, 0.12193646f, 
    0.11629852f, -0.07316839f, -0.04079209f, 0.04645386f, -0.00324549f, -0.14097767f, 0.02876517f, 0.14149100f, 
    0.12785813f, 0.04678090f, 0.03549707f, 0.07191385f, -0.32943365f, 0.08249464f, -0.03448093f, 0.06516085f, 
    0.07236829f, 0.10838354f, -0.01331361f, 0.05255752f, -0.10030232f, -0.35787749f, 0.07544380f, 0.12280694f, 
    0.01071893f, 0.00729767f, -0.03114781f, -0.01182306f, -0.00151762f, -0.13099131f, 0.03488157f, 0.03822662f, 
    -0.24136823f, 0.15216325f, -1.23946619f, 0.13788210f, -0.19446871f, 0.23571263f, -0.06493837f, 0.21245199f, 
    0.05382751f, -0.04771747f, 0.02671203f, 0.00329006f, 0.01058383f, 0.03575921f, -0.04722159f, -0.07502825f, 
    -0.00422425f, 0.05506267f, 0.18418290f, 0.27643788f, 0.38746169f, -0.36809552f, -0.16144653f, -0.08622633f, 
    -0.10369873f, -0.00046665f, -0.22133397f, 0.03172170f, -0.00834656f, 0.10905334f, -0.06813166f, 0.13767058f, 
    0.01368204f, -0.02600355f, 0.12119623f, -0.05220312f, 0.10177875f, 0.08288684f, -0.05516988f, 0.05858667f, 
    -0.07759415f, -0.10685199f, 0.10013777f, -0.25039798f, 0.15395485f, 0.11498623f, 0.04994959f, -0.14218056f, 
    -0.02489529f, -0.16587770f, 0.15493073f, 0.13881466f, -0.09366453f, 0.08423415f, -0.05501924f, 0.03921584f, 
    -0.09279125f, -0.12770279f, -0.16693798f, 0.11183195f, -0.07088967f, -0.01298206f, -0.11489880f, 0.03153865f, 
    0.03557573f, 0.06783763f, 0.13956106f, 0.20711888f, 0.01687171f, -0.04057910f, 0.05321200f, 0.01527424f, 
    -0.08879252f, 0.02810642f, -0.02338186f, 0.09686225f, 0.10142832f, -0.02358102f, -0.04404165f, 0.00806998f, 
    -0.77403450f, 0.05508486f, -0.81133640f, 0.17440528f, -0.12203003f, 0.00026552f, -0.28612691f, 0.07116271f, 
    -0.27311778f, 0.14841373f, -0.07964177f, 0.12907484f, -0.05116550f, 0.03020853f, 0.04545667f, -0.07542541f, 
    0.15383497f, 0.13498397f, -0.05175998f, 0.14480874f, 0.08813208f, -0.11871674f, 0.15950625f, 0.12184625f, 
    -0.04649039f, -0.16084884f, 0.10724875f, -0.39039117f, -0.17649961f, -0.01140225f, 0.08208129f, 0.02250201f, 
    0.10279623f, 0.04493544f, 0.00218881f, 0.11810525f, -0.06780373f, -0.09128756f, -0.03115493f, -0.07202929f, 
    0.26309589f, -0.06620198f, 0.46012223f, 0.41053471f, -0.66454953f, 0.01468723f, -0.19312416f, -0.38694113f, 
    0.12809633f, -0.09594061f, 0.04238816f, 0.03396318f, 0.03670945f, 0.16012436f, -0.01440819f, 0.09743516f, 
    0.08414064f, 0.03530534f, 0.04809767f, 0.12879947f, -0.70023328f, -0.38346776f, -0.05676031f, -0.06994393f, 
    -0.14930880f, -0.22257642f, 0.14469537f, 0.01967890f, -0.15265781f, 0.26239419f, 0.07036167f, 0.02962835f, 
    -0.00898283f, -0.04299265f, -0.07066467f, 0.02642906f, -0.03908048f, 0.13256988f, 0.02061921f, -0.18755037f, 
    -0.09743047f, 0.11437490f, -0.07249161f, -0.07539084f, -0.22608440f, 0.10381424f, -0.10742039f, 0.26916870f, 
    -0.17765865f, -0.07796109f, 0.06788035f, -0.04747357f, 0.06165344f, -0.12183619f, -0.05090143f, -0.03617543f, 
    0.02173490f, -0.10722496f, -0.04123771f, -0.14319928f, 0.20885596f, 0.16961558f, 0.59839350f, 0.68873763f, 
    -0.63840091f, 0.21142547f, -0.17226528f, -0.35609677f, -0.08662982f, -0.35560536f, 0.14248377f, 0.09670881f, 
    0.06927832f, 0.03696737f, 0.03734463f, 0.10803287f, -0.00508646f, -0.11841410f, -0.00711732f, 0.06668694f, 
    0.07295027f, -0.35804036f, 0.11287429f, -0.45304954f, -0.35605347f, -0.26997629f, -0.05505243f, -0.10261858f, 
    0.00684586f, 0.07640060f, -0.01069625f, -0.05540951f, -0.03339205f, 0.04702957f, -0.04741132f, 0.03866617f, 
    0.06346240f, 0.13627820f, -0.16475347f, -0.09810258f, 0.24377164f, 0.25845972f, -0.56580019f, 0.14678219f, 
    -0.18247554f, -0.03652210f, 0.09593987f, 0.25345489f, -0.01447180f, 0.11003211f, 0.04305520f, -0.00003741f, 
    -0.14544183f, -0.13497344f, -0.13263229f, 0.01974636f, -0.09758858f, -0.09830321f, 0.04641831f, -0.30421731f, 
    0.10265387f, -0.50273836f, -0.11366721f, -0.25536400f, 0.21281140f, 0.10660720f, -0.07063577f, 0.20654000f, 
    0.03910522f, 0.14367726f, -0.05783839f, -0.02999409f, -0.13677162f, -0.03268835f, -0.08982264f, -0.10713738f, 
    0.07220432f, 0.15243468f, -0.06780472f, -0.03485136f, 0.14464064f, -0.25340074f, -0.16363312f, -0.40697137f, 
    0.11247753f, 0.08019302f, -0.09622508f, 0.10695583f, -0.03329404f, -0.02797239f, -0.09344295f, -0.03362945f, 
    -0.04165180f, -0.16063149f, -0.14960597f, 0.15199907f, 0.15039383f, 0.09270368f, 0.03006853f, 0.05252847f, 
    -0.38275188f, 0.05523174f, -0.52390081f, 0.07603432f, -0.03099607f, 0.11077259f, -0.09875625f, -0.11097336f, 
    -0.10069889f, -0.09918145f, 0.04122679f, 0.11179179f, 0.05851598f, 0.04022123f, 0.03112484f, 0.11964066f, 
    -0.06642994f, -0.11622041f, -0.12358047f, -0.28941563f, -0.00086022f, -0.12144651f, 0.36699238f, -0.00659374f, 
    -0.01879092f, 0.06669913f, -0.05628004f, 0.15217778f, -0.02000561f, -0.08157925f, -0.11782410f, 0.10781830f, 
    0.15511130f, -0.03533418f, 0.03822710f, -0.05964524f, 0.03594257f, 0.14481202f, -0.08449456f, 0.00778305f, 
    -0.40255889f, 0.09070396f, -0.66073561f, 0.07669120f, -0.07921330f, -0.18063432f, 0.02583483f, -0.09890806f, 
    -0.24665545f, 0.05149107f, -0.00429222f, 0.09094303f, -0.03246264f, 0.04624367f, -0.10092278f, 0.02185626f, 
    -0.02593835f, -0.00971121f, -0.03554363f, -0.08678054f, 0.43056127f, -0.13019703f, 0.04541440f, -0.16411006f, 
    0.02739661f, -0.13789806f, 0.10367806f, 0.04435377f, 0.06720468f, -0.08901196f, -0.10179552f, -0.04109723f, 
    0.02021808f, 0.02652651f, -0.04270083f, 0.01353471f, -0.30879581f, -0.04646891f, -0.12038686f, -0.13996084f, 
    0.05604694f, -0.57011133f, -0.70391935f, 0.09120194f, -0.69623482f, -0.06759561f, -0.25041014f, 0.03665192f, 
    0.02938819f, -0.19389132f, -0.10872353f, 0.12549561f, -0.13172689f, -0.03574461f, 0.04511910f, -0.07865291f, 
    0.01120570f, -0.06947406f, 0.05879642f, -0.06035294f, -0.02500541f, -0.34497350f, 0.40105861f, 0.01906232f, 
    0.01646680f, -0.01983926f, -0.04782873f, 0.14774629f, 0.00331683f, -0.10464046f, -0.16718274f, 0.01696913f, 
    0.06941784f, -0.07310555f, -0.04069651f, -0.14487329f, 0.08490703f, 0.23157597f, -0.08546563f, -0.05465908f, 
    0.35800913f, -0.36178306f, 0.29616338f, -0.11719039f, -0.04695325f, -0.08755113f, -0.05457246f, 0.11299635f, 
    0.03453125f, -0.04412079f, -0.01893492f, -0.03048335f, -0.15589571f, 0.15578456f, -0.04155253f, -0.09035335f, 
    0.11641468f, 0.12905511f, 0.01703332f, -0.04156730f, 0.31418702f, -0.23244563f, 0.25433800f, -0.12922326f, 
    -0.20559967f, 0.00283226f, -0.02110286f, 0.18942519f, 0.10360341f, 0.09014370f, -0.20701452f, 0.04307495f, 
    -0.03477923f, 0.08158137f, -0.18239987f, -0.07803934f, 0.06995122f, 0.37836224f, 0.16746947f, -0.07970583f, 
    -0.30636832f, -0.40582502f, 0.26225558f, 0.02889817f, -0.04153030f, -0.10830282f, 0.04653649f, 0.16639565f, 
    -0.05370696f, -0.00635035f, 0.01802155f, -0.02471681f, -0.04183421f, 0.08795080f, -0.00715747f, -0.02675737f, 
    0.14372756f, 0.19145046f, 0.07563111f, 0.25289327f, -0.17999154f, 0.03963217f, -0.40827379f, -0.01296388f, 
    -0.09220799f, 0.00782365f, -0.00126128f, 0.03250251f, 0.03280969f, 0.02638260f, -0.02592152f, 0.10313806f, 
    -0.12172122f, -0.25083208f, -0.30696878f, 0.04871402f, -0.12328412f, 0.06334790f, -0.03340784f, -0.03419428f, 
    -0.49100927f, 0.14218521f, -0.18519472f, -0.13310523f, 0.15872835f, -0.02443666f, -0.16747385f, -0.02485352f, 
    -0.03658279f, -0.04766740f, -0.11431452f, 0.01320064f, 0.10426939f, 0.05075006f, 0.02783948f, 0.05888021f, 
    0.06619839f, -0.19102490f, 0.05854701f, 0.21082279f, 0.27439383f, -0.16434863f, -0.08826335f, 0.00858942f, 
    0.06606774f, -0.20570983f, 0.17953849f, 0.23895477f, -0.01506822f, 0.00305926f, -0.00365330f, 0.00532038f, 
    -0.13791776f, 0.03538877f, 0.00875391f, 0.04710092f, -0.14488931f, -0.11827178f, -0.21347484f, -0.29859382f, 
    -0.28853396f, -0.48115808f, -0.33592159f, -0.08074830f, 0.09273408f, -0.22420755f, -0.10260981f, 0.01497870f, 
    0.10352886f, -0.10650003f, -0.18623981f, 0.05441426f, -0.12900646f, -0.05604789f, 0.02169386f, 0.12621655f, 
    -0.23147035f, -0.12053429f, 0.02252437f, -0.02452625f, -0.67980474f, 0.26941487f, -0.59078521f, 0.31204647f, 
    0.04161181f, -0.05202342f, -0.14763790f, -0.27785498f, 0.40740559f, -0.06569792f, -0.11736567f, 0.04619059f, 
    0.02668590f, 0.12385376f, 0.17181353f, 0.10788813f, -0.07780494f, -0.35590756f, 0.13465998f, 0.04934071f, 
    0.26449418f, 0.33224002f, 0.31370538f, 0.07458699f, 0.06483185f, 0.33469209f, -0.22893076f, 0.09397237f, 
    -0.15348822f, -0.10690346f, -0.11133759f, 0.07003246f, -0.04430586f, -0.04913895f, 0.13298716f, -0.03627419f, 
    -0.10410327f, -0.17523557f, 0.03741447f, -0.04283753f, 0.10775625f, 0.13778570f, -0.00873434f, 0.15950932f, 
    0.18036035f, -0.10037837f, 0.08763167f, 0.12100597f, -0.14777200f, 0.11066385f, -0.13059624f, 0.04576527f, 
    -0.09251621f, -0.04214031f, 0.08701913f, 0.05786439f, -0.18681315f, -0.31672084f, 0.07247896f, 0.00780684f, 
    -0.02697719f, -0.13553818f, 0.05597517f, -0.08646594f, -0.29936683f, 0.05692263f, -0.07332217f, -0.21132447f, 
    -0.18284495f, -0.10214270f, -0.14350471f, 0.06431626f, 0.02807731f, 0.08326719f, -0.01961259f, 0.05773528f, 
    0.00857855f, -0.05804729f, -0.27041849f, -0.03649695f, -0.42804995f, -0.61764145f, 0.33334845f, -0.29761085f, 
    -0.10927302f, -0.04553719f, -0.10250199f, -0.00672577f, 0.30874795f, -0.09213376f, -0.10136293f, -0.08075894f, 
    -0.00250786f, 0.04411804f, 0.05096760f, -0.02559844f, 0.13467027f, 0.12315883f, 0.26495361f, -0.11313295f, 
    -0.08722388f, -0.23074763f, 0.01929446f, 0.08393082f, 0.13645779f, -0.16227217f, 0.10802208f, -0.03278768f, 
    -0.03124108f, -0.11602058f, -0.09790532f, 0.16651404f, -0.02448141f, 0.04170805f, 0.07294020f, 0.27464733f, 
    -0.13960211f, -0.18724179f, 0.00402573f, -0.28279355f, -0.16066335f, 0.11205232f, -0.58814538f, 0.04863146f, 
    -0.06870608f, -0.00003130f, -0.05161230f, 0.06646539f, 0.00558960f, -0.05105171f, 0.03194855f, 0.09356845f, 
    0.03168436f, 0.05251848f, 0.00684336f, 0.06985828f, -0.08657829f, -0.14702864f, -0.28583547f, -0.20601764f, 
    -0.57374990f, -0.10155039f, 0.26305950f, 0.02999310f, -0.15894298f, 0.05914541f, -0.03128999f, 0.03018950f, 
    0.23188984f, 0.11586782f, -0.08995884f, 0.04446185f, -0.02221042f, 0.04601558f, 0.01107872f, -0.19066122f, 
    0.27316886f, 0.17211503f, 0.20409185f, 0.25097093f, 0.02982795f, -0.28936255f, -0.04554232f, 0.33033934f, 
    -0.16498709f, -0.01227084f, -0.05009444f, 0.05679860f, -0.18113028f, -0.00337034f, 0.01211060f, -0.01302148f, 
    -0.01238629f, -0.06220070f, 0.07975934f, -0.06540067f, 0.00647672f, 0.03916048f, 0.14495949f, 0.16395178f, 
    -0.00297665f, -0.07934252f, -0.18305176f, -0.19231342f, 0.11508906f, -0.04059503f, 0.03564851f, 0.53417242f, 
    0.01048386f, -0.17811407f, -0.00756873f, 0.14430067f, -0.13807043f, 0.15918227f, 0.01118881f, 0.00372445f, 
    -0.10433807f, 0.04076925f, -0.33932015f, -0.13206886f, 0.11101008f, 0.16184156f, -0.18133590f, 0.20318235f, 
    0.32687446f, 0.09344024f, 0.06958499f, 0.24588898f, 0.01557564f, 0.08296483f, -0.09633382f, 0.08898114f, 
    0.04102516f, 0.00833186f, -0.02019199f, 0.11025435f, 0.05847241f, 0.08802649f, 0.08197143f, 0.21523124f, 
    -0.03179481f, 0.25031018f, -0.28624395f, 0.10808710f, 0.12005515f, 0.12436522f, 0.03451272f, -0.10150874f, 
    -0.00030848f, -0.02075870f, -0.10289805f, 0.05628160f, 0.00733784f, -0.24845305f, -0.19138734f, -0.05671614f, 
    -0.08456802f, -0.06467601f, 0.00901373f, -0.05706556f, -0.20361091f, 0.05400189f, -0.41851190f, -0.22312805f, 
    0.15374111f, -0.09688092f, -0.01046963f, 0.33821887f, 0.11847886f, 0.13860850f, -0.05897088f, 0.22769496f, 
    0.11660556f, 0.00070993f, 0.03640823f, 0.10366480f, -0.05052214f, -0.02644287f, 0.03401593f, -0.05433210f, 
    -0.56526083f, -0.14981203f, 0.11630492f, 0.27275369f, -0.13027181f, -0.01745834f, -0.10938941f, -0.06058845f, 
    0.34617323f, 0.04730913f, -0.22240491f, -0.01754595f, 0.08249199f, 0.03310883f, -0.01947639f, 0.11635979f, 
    0.01978563f, -0.08287806f, 0.31672662f, 0.19853307f, -0.37292087f, 0.15261742f, 0.15008192f, 0.17077152f, 
    0.11984383f, -0.00947019f, -0.05319523f, -0.09441632f, 0.10127129f, 0.03399416f, -0.13977095f, -0.06184396f, 
    -0.14825049f, 0.04836823f, -0.18911834f, 0.06640004f, -0.13001899f, -0.03061128f, -0.08627138f, 0.04583507f, 
    -0.20873094f, 0.36555731f, -0.36488491f, 0.25232637f, 0.24359283f, 0.12233301f, 0.02988552f, 0.14020939f, 
    0.00187588f, 0.17120486f, -0.13457642f, 0.05124046f, 0.10342459f, -0.00887647f, -0.06757715f, -0.09475800f, 
    0.15331574f, -0.31538185f, 0.10272495f, 0.07176983f, -0.41044515f, -0.25295097f, -0.05042973f, 0.01368795f, 
    -0.00034113f, -0.06717737f, -0.07845476f, 0.21038930f, -0.10852488f, 0.14196712f, 0.00802118f, 0.08751322f, 
    0.02489088f, 0.16357143f, 0.04148060f, 0.12827362f, -0.03197604f, 0.08134802f, 0.12235218f, 0.33550122f, 
    -0.15794268f, 0.07680471f, 0.05328195f, 0.19348548f, -0.12297904f, -0.04982401f, 0.03576717f, -0.21273315f, 
    0.13874947f, -0.01853882f, -0.08674313f, -0.07428550f, -0.08452743f, 0.12064925f, 0.04437565f, -0.15496333f, 
    0.10270098f, -0.25998604f, -0.12804179f, -0.11297491f, -0.27735770f, 0.20473239f, 0.30805686f, 0.47743174f, 
    0.14979902f, 0.04966760f, -0.05546728f, -0.14728032f, -0.02161353f, 0.07586102f, -0.23007099f, 0.04271168f, 
    0.22826600f, 0.00447645f, -0.02539676f, -0.19385849f, 0.05197335f, -0.17165498f, 0.07847389f, 0.26580170f, 
    0.12653121f, -0.37574381f, -0.50252360f, -0.19267258f, -0.09101514f, -0.08616245f, -0.04717205f, 0.13179456f, 
    0.00348861f, -0.09769823f, 0.04423668f, 0.03593671f, 0.02716855f, -0.17656709f, -0.04942953f, 0.10266803f, 
    -0.15715654f, -0.01091563f, 0.07431139f, -0.00285550f, 0.36424220f, -0.04617213f, 0.19820487f, 0.32609263f, 
    -0.03881444f, -0.10516148f, 0.10301851f, -0.22509524f, 0.13964909f, 0.08968430f, -0.08007175f, 0.03196815f, 
    -0.03809340f, -0.00857476f, -0.04912875f, -0.00038639f, 0.01602960f, 0.05518189f, -0.07247134f, 0.12604560f, 
    0.10026717f, -0.18051673f, 0.14534453f, -0.15835139f, -0.19496308f, -0.06355720f, -0.05955684f, 0.03197079f, 
    -0.02608589f, -0.18577193f, 0.01664465f, 0.02779933f, 0.09242128f, -0.10380533f, -0.12931029f, 0.17386474f, 
    0.00427816f, 0.04716795f, 0.09204578f, 0.02816053f, -0.02769299f, -0.38736042f, 0.05877074f, -0.21388975f, 
    0.42085889f, 0.05861488f, 0.15884517f, 0.24932103f, -0.11139869f, 0.08607990f, 0.14870118f, 0.08285304f, 
    0.14721571f, 0.01879565f, 0.07218180f, -0.04257150f, 0.15598843f, 0.08633240f, 0.03756210f, 0.07122199f, 
    0.21632400f, 0.05809788f, 0.28401336f, -0.12028442f, -0.56448501f, -0.16501287f, 0.08093968f, -0.07690636f, 
    0.00759236f, 0.06986409f, -0.19148549f, -0.03964905f, 0.11957381f, 0.08785909f, -0.10702311f, -0.01588998f, 
    0.16096604f, 0.07967094f, 0.05804369f, -0.04431424f, 0.38088721f, 0.06608746f, 0.18479738f, 0.21079540f, 
    -0.00189874f, -0.13652508f, 0.15855461f, -0.18299465f, 0.07435440f, 0.11671606f, -0.21354632f, 0.10761667f, 
    -0.02927408f, -0.04215402f, -0.04443405f, 0.00025848f, -0.00648854f, 0.05131929f, -0.05938598f, 0.19531462f, 
    -0.13123924f, -0.08619666f, 0.07286198f, -0.12364520f, 0.28214410f, 0.12603772f, 0.16827816f, 0.12127229f, 
    0.00459040f, 0.10375693f, -0.04495827f, -0.00780141f, -0.00480974f, -0.03433712f, -0.09653967f, -0.03585653f, 
    0.06651472f, 0.00163237f, 0.04326728f, 0.01002778f, -0.18730864f, -0.03168491f, 0.01880274f, -0.08077768f, 
    0.36965847f, -0.01691804f, 0.22963254f, -0.08875248f, 0.08316764f, 0.07259893f, -0.04231083f, 0.09930437f, 
    -0.06805955f, 0.00476672f, 0.09958468f, -0.17095698f, -0.25244695f, -0.05117244f, -0.22004981f, -0.15230633f, 
    0.17712332f, 0.13529553f, 0.32382774f, -0.09320521f, -0.00376344f, 0.13039109f, 0.10289875f, -0.06003860f, 
    -0.12238269f, -0.12122215f, -0.07074021f, 0.10663024f, 0.09841241f, 0.04633474f, 0.07378863f, -0.05741730f, 
    -0.06334009f, -0.20895261f, -0.34047806f, 0.09739970f, -0.13847286f, -0.30037674f, -0.06383214f, -0.22561166f, 
    -0.39095762f, 0.11531483f, 0.09462123f, 0.00580820f, -0.13927130f, -0.02409670f, -0.01706706f, -0.08544846f, 
    0.15825970f, 0.15158129f, 0.09794302f, -0.02371646f, 0.08134412f, 0.05435646f, 0.07266102f, 0.18828498f, 
    0.09890186f, -0.24527489f, -0.35074836f, 0.17462076f, -0.10544612f, -0.14604518f, -0.43826854f, -0.23930301f, 
    -0.26102805f, -0.15780015f, 0.05466947f, 0.09647130f, -0.14752008f, -0.06328268f, -0.05662921f, 0.08494463f, 
    -0.10844515f, 0.08679920f, -0.03294199f, -0.28713462f, 0.15138397f, -0.40066591f, 0.10387319f, -0.38738927f, 
    0.23660348f, 0.13341135f, 0.01700795f, -0.04952585f, 0.11756151f, -0.10880190f, -0.02867766f, 0.11803466f, 
    0.00407865f, -0.01966575f, -0.08140436f, 0.02258757f, 0.11522048f, 0.10171115f, 0.07330301f, 0.08236977f, 
    0.59778148f, -0.00298564f, 0.69089192f, -0.18166427f, -0.18931517f, -0.08960618f, -0.04644446f, -0.15939561f, 
    0.10015780f, -0.21076152f, -0.09694082f, -0.02390776f, 0.07648355f, -0.05693987f, -0.09811201f, -0.00247848f, 
    0.08038501f, 0.00826300f, 0.02195848f, 0.08350658f, -0.51442581f, -0.58645844f, -0.07026388f, 0.15886708f, 
    0.00849907f, -0.10813535f, -0.32233581f, -0.11477582f, 0.26859790f, -0.36359495f, -0.04683532f, 0.00899690f, 
    0.07383399f, -0.00439567f, 0.06667120f, 0.08218580f, -0.09400637f, 0.04509170f, 0.15909408f, -0.04945854f, 
    -1.21949852f, 0.23183721f, -0.27365357f, 0.40812644f, -0.09343553f, 0.28698614f, 0.20122612f, 0.37304583f, 
    -0.47036353f, 0.29229873f, -0.06402073f, 0.00033824f, 0.05211034f, 0.24514510f, 0.04825132f, 0.05640430f, 
    -0.07384455f, 0.12414344f, 0.20004553f, -0.03139260f, 0.10025240f, -0.42424616f, 0.00525285f, 0.15437652f, 
    0.10577057f, 0.10427622f, -0.00123834f, 0.22969267f, -0.02921488f, -0.08393055f, 0.05882522f, -0.00840518f, 
    0.13170537f, 0.05005115f, 0.12613635f, -0.03804642f, 0.00584093f, -0.05497984f, 0.22531319f, -0.02805183f, 
    0.10349264f, -0.14461072f, -0.11984134f, 0.23164745f, 0.00934903f, -0.03529143f, 0.05123939f, -0.13758665f, 
    0.05510546f, -0.08807863f, -0.29386151f, -0.05695793f, 0.04550818f, -0.01248095f, -0.10340257f, 0.12107290f, 
    -0.03821990f, 0.00184969f, -0.23436695f, 0.02584765f, 0.12804571f, 0.05161507f, 0.20805144f, -0.16558623f, 
    0.07205274f, 0.16437255f, 0.35777062f, 0.02443017f, 0.12448891f, -0.11758770f, -0.05125288f, -0.05054807f, 
    0.06652115f, -0.11682012f, 0.10396329f, 0.19114625f, 0.02694710f, -0.16175389f, -0.21538855f, -0.06722535f, 
    0.33940777f, -0.37524685f, 0.55864900f, -0.20721503f, 0.17691767f, 0.01517458f, -0.30580747f, -0.00725906f, 
    -0.03269609f, -0.28521955f, -0.04439142f, -0.03045702f, 0.09120708f, -0.05414840f, -0.02844893f, 0.03902059f, 
    0.12543152f, -0.01790219f, -0.00189429f, 0.02455246f, -0.03204500f, -0.36108634f, -0.21061416f, -0.04129592f, 
    0.06052691f, -0.19188517f, -0.34660634f, -0.11589807f, 0.01289451f, -0.20502760f, -0.06909092f, 0.00707884f, 
    0.10294292f, -0.07613828f, 0.04181406f, 0.10773515f, -0.12484929f, 0.02546068f, 0.13799006f, -0.02457656f, 
    -0.13046312f, 0.35215741f, -0.21598071f, 0.09642605f, -0.10490348f, -0.08098190f, 0.05945180f, 0.09843332f, 
    0.11683976f, -0.04484614f, -0.12587018f, 0.05931056f, -0.05682117f, -0.03705460f, 0.00566052f, 0.13002604f, 
    -0.21744983f, 0.11211919f, -0.21060930f, -0.30911922f, 0.13388722f, 0.01978721f, 0.11307977f, -0.10432939f, 
    -0.19731167f, 0.00803805f, 0.09274576f, 0.01738938f, 0.09448036f, 0.03086110f, -0.13098097f, 0.14466392f, 
    -0.06820529f, 0.02504709f, -0.07234678f, 0.01124129f, 0.06542715f, -0.09605967f, -0.11149754f, -0.01074401f, 
    0.53605831f, -1.09042966f, 0.49435535f, -0.07572894f, 0.22663909f, 0.11389232f, -0.25006375f, -0.41750997f, 
    0.25519747f, -0.14897905f, -0.02893067f, 0.06237517f, 0.02182073f, -0.01276521f, 0.01696229f, 0.06009707f, 
    0.02285320f, -0.07830549f, 0.34506494f, -0.00442472f, -0.45292950f, 0.07702079f, -0.21893176f, 0.50110143f, 
    0.06761766f, -0.09118303f, -0.01399776f, -0.05244757f, -0.13350809f, 0.12421790f, -0.13783479f, -0.06981514f, 
    -0.13845253f, -0.08589877f, -0.13307065f, 0.03565624f, -0.10189421f, -0.00539515f, -0.00916488f, -0.12339763f, 
    -0.62348622f, -0.07180812f, -0.51731396f, 0.11989302f, -0.71899170f, 0.02006369f, 0.01319568f, -0.10370851f, 
    0.20306653f, 0.03366117f, -0.10199387f, -0.08638440f, 0.03471320f, -0.02871087f, 0.05263273f, -0.03253331f, 
    -0.01997798f, 0.09412327f, -0.03113759f, 0.07673248f, -0.21573159f, -0.24792437f, -0.10363352f, -0.19746627f, 
    -0.05401571f, -0.08104850f, -0.27141613f, -0.14530455f, -0.06491313f, 0.07195046f, 0.07006089f, 0.06350268f, 
    -0.02718139f, -0.03044945f, -0.12250481f, 0.09238408f, -0.08590759f, -0.01675701f, 0.11759902f, 0.02854165f, 
    0.29248142f, 0.03148748f, 0.33090934f, 0.02260821f, -0.12835746f, 0.01866828f, 0.10032468f, -0.08218452f, 
    0.13028899f, -0.13905005f, -0.04957861f, -0.04534518f, -0.03797302f, 0.09925786f, 0.12687701f, -0.02881744f, 
    -0.03344274f, -0.01364825f, -0.07139239f, -0.13277276f, -0.16722278f, -0.12161655f, -0.19424354f, 0.33766168f, 
    -0.65546829f, -0.00328439f, 0.10798095f, -0.00089935f, 0.01797527f, 0.05661001f, 0.00768857f, 0.00517336f, 
    0.16505183f, 0.10563380f, -0.11522752f, -0.05863997f, -0.15831013f, 0.11152740f, -0.06993739f, 0.06322777f, 
    -0.67557627f, 0.14706747f, 0.18990831f, 0.39774629f, -0.00678740f, 0.00152432f, 0.07570989f, 0.10499138f, 
    0.18434152f, 0.05942915f, -0.11400034f, -0.15990926f, -0.15370882f, -0.09183786f, 0.13778923f, 0.13231887f, 
    0.02670202f, 0.37290117f, 0.08814335f, -0.04117862f, 0.25124803f, 0.26279461f, 0.25620165f, 0.12466867f, 
    -0.16547860f, -0.09357825f, -0.19796397f, 0.06434268f, -0.19155869f, -0.16011132f, -0.09450777f, -0.00460629f, 
    -0.01662588f, 0.00587959f, -0.06286193f, 0.04007719f, -0.19411147f, -0.07411244f, -0.00426382f, 0.07995952f, 
    0.19340511f, 0.06312715f, -0.00830371f, 0.16881090f, 0.02592396f, 0.01913029f, 0.00294056f, -0.04984052f, 
    0.06329662f, 0.03465825f, -0.16327137f, -0.00574932f, -0.02474911f, -0.05063330f, -0.01240839f, 0.11471675f, 
    0.22355543f, 0.08738261f, 0.13550377f, -0.12771676f, -0.29955357f, -0.19930810f, -0.39766988f, 0.43667737f, 
    0.07291970f, -0.01636305f, 0.09969420f, -0.12814456f, 0.05828447f, 0.01975940f, -0.31162325f, -0.15219027f, 
    -0.37496805f, 0.02979659f, -0.04250608f, 0.10291614f, 0.03732262f, 0.26360512f, 0.03815183f, -0.13767399f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.22076973f, 0.13711852f, 0.01632494f, -0.10898341f, -0.05436537f, 0.08673257f, 0.05207767f, -0.10053898f, 
    0.04328940f, 0.07779379f, 0.04953569f, 0.02357040f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
