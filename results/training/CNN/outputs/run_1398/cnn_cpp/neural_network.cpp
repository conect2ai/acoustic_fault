#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.21357547f, 0.42705315f, 0.25637940f, -0.22171830f, -0.49605018f, 0.04408240f, -0.18798444f, -0.32044789f, 
    -0.33990863f, -0.51384246f, 0.14975481f, -0.21705993f, -0.39561984f, -0.09421785f, 0.06552948f, -0.01527806f, 
    0.02066221f, -0.14106809f, 0.18721095f, 0.07348443f, -0.02829587f, -0.06797282f, -0.23589961f, 0.07492826f, 
    -0.18370417f, 1.03358185f, -0.80695426f, -0.17672130f, 0.16443047f, -0.28237563f, 0.31643879f, 0.46491382f, 
    0.27436942f, -0.46074417f, -0.00801000f, -0.16820605f, 0.11486337f, -0.09554978f, -0.19034544f, 0.01643171f, 
    0.21106033f, -0.16948380f, -0.15592964f, 0.18779069f, -0.14881486f, 0.06402005f, -0.14019367f, 0.01879966f, 
    0.23849733f, -0.09540240f, 0.33194855f, 0.27579758f, 0.04825831f, -0.52224690f, -0.00714176f, -0.22605027f, 
    -0.00898214f, 0.00923118f, 0.01473345f, 0.05665264f, 0.31580257f, -0.20785218f, 0.05613441f, 0.17772804f, 
    -0.04999150f, -0.20360050f, 0.06306598f, 0.12043352f, -0.12779476f, 0.18116924f, -0.01226973f, 0.05516280f, 
    -0.33929938f, 0.21245411f, 0.20659369f, -0.31999743f, 0.07244050f, 0.07778241f, -0.23954348f, -0.04914431f, 
    0.31176999f, -0.04043211f, 0.09932879f, 0.31552637f, -0.00072028f, 0.10082250f, -0.02994181f, -0.04397114f, 
    -0.27990142f, 0.28261682f, -0.15346664f, 0.08012317f, -0.19053517f, 0.13961314f, 0.00888932f, 0.16637091f, 
    0.24703981f, 0.02809811f, -0.04482186f, 0.03602702f, 0.58168596f, 0.28310221f, 0.32170251f, 0.17982958f, 
    -0.65721524f, 0.20749933f, 0.16106503f, 0.06454884f, -0.22856566f, 0.07305524f, 0.18471158f, -0.22182357f, 
    -0.23026943f, 0.24753161f, -0.18536210f, -0.05506096f, 0.11672413f, -0.03636484f, -0.09983022f, 0.09577803f, 
    0.03034563f, -0.08380021f, -0.21981992f, -0.02260698f, 0.20491582f, 0.31813031f, 0.11118138f, 0.12416289f, 
    -0.23063102f, 0.28515127f, 0.07125253f, 0.08007336f, 0.42655537f, -0.39158392f, -0.22031875f, -0.28384703f, 
    -0.26084435f, 0.14816378f, -0.12312191f, 0.09718642f, 0.00078495f, -0.27081633f, -0.00770999f, 0.25828588f, 
    0.37375131f, 0.20000690f, 0.22665697f, -0.26910108f, -0.37699157f, -0.41840035f, -0.19002633f, -0.29932192f, 
    -0.41160348f, -0.17247193f, 0.21703370f, 0.02650810f, 0.22726937f, 0.06287638f, 0.07701676f, 0.20948769f, 
    0.17519426f, 0.10404225f, -0.26508877f, 0.13096684f, -0.25508335f, -0.01109420f, -0.07412513f, -0.17440359f, 
    -0.34977728f, -0.33581972f, 0.29813516f, 0.20962214f, 0.23749492f, 0.29985437f, 0.31436351f, 0.16596678f, 
    0.42622057f, 0.17632888f, 0.03376585f, 0.04690297f, -0.14426993f, -0.34343249f, -0.03892051f, 0.45687941f, 
    0.25256532f, 0.27141649f, -0.11141288f, -0.20375185f, 0.00663902f, 0.07527696f, -0.00691709f, 0.00908977f, 
    -0.07050157f, -0.09009814f, 0.05339947f, -0.16109535f, 0.14566977f, 0.05485219f, 0.09915352f, 0.04499685f, 
    -0.23107827f, 0.16927250f, 0.27571917f, -0.07187725f, -0.23236099f, -0.34808204f, 0.54258698f, -0.56495148f, 
    -0.17385314f, -0.07408588f, 0.29963920f, 0.01428257f, 0.14118250f, -0.17816620f, 0.03984069f, 0.11518139f, 
    -0.16605714f, 0.21567379f, -0.00955117f, 0.06827647f, 0.08945939f, 0.00636926f, 0.17486790f, -0.31485093f, 
    -0.09020360f, 0.23510180f, -0.04734856f, -0.03001471f, 0.31896284f, -0.30749965f, -0.13303278f, -0.03750070f, 
    0.01129346f, 0.04599213f, 0.18962675f, 0.13322057f, 0.29986861f, -0.07405019f, -0.40089333f, -0.20524023f, 
    0.13079375f, 0.01964422f, 0.03893886f, 0.01438530f, -0.31504053f, 0.15939893f, -0.05804859f, -0.15805718f, 
    -0.21657988f, -0.07717233f, 0.52128017f, 0.27210107f, 0.16273233f, 0.23211257f, 0.23615010f, -0.54444265f, 
    -0.44419280f, 0.15742460f, -0.01577838f, -0.31292638f, -0.32910821f, 0.03310785f, -0.00231692f, 0.13359909f, 
    -0.00778624f, 0.01626779f, -0.08492900f, 0.22700784f, 0.11993556f, -0.00521940f, -0.17709248f, -0.13655879f, 
    -0.15866855f, -0.06348258f, -0.24794905f, 0.10229912f, -0.08335856f, 0.07753618f, 0.22837725f, -0.13642246f, 
    0.28099638f, 0.08446086f, -0.16180499f, 0.07083905f, 0.16014233f, 0.19084719f, 0.08116739f, -0.38200787f, 
    -0.09871084f, 0.31316626f, 0.29342806f, -0.24026780f, -0.22018205f, 0.19289476f, -0.26344725f, 0.24407236f, 
    0.03529252f, 0.02114586f, -0.16189507f, 0.13224129f, -0.73785019f, -0.58237427f, -0.52374595f, -0.43306133f, 
    -0.57646090f, 0.36354437f, 0.40057197f, 0.44406986f, 0.30751619f, 0.28400970f, 0.10872182f, 0.09020124f, 
    0.07428993f, -0.19872107f, -0.06671569f, -0.10881709f, 0.28241399f, -0.12799901f, -0.22418608f, 0.09988166f, 
    -0.14578174f, -0.01356238f, -0.02840801f, 0.16196193f, -0.14928988f, -0.19194643f, -0.32379374f, 0.09662001f, 
    -0.10586061f, -0.06115245f, 0.13275905f, 0.45918623f, -0.11601134f, 0.31959158f, -0.73554790f, 0.11343350f, 
    0.02138483f, -0.14814246f, -0.13543929f, 0.02596281f, -0.20730050f, -0.37373078f, -0.11530875f, 0.40770158f, 
    0.24694592f, 0.12652563f, 0.05696561f, 0.18041596f, -0.34793717f, -0.05183525f, -0.91662008f, -0.31763533f, 
    0.29949266f, 0.45798212f, 0.46517527f, -0.27753481f, -0.64675581f, -0.34331256f, 0.39806882f, 0.52177382f, 
    -0.02568515f, 0.45735258f, -0.00135881f, 0.06659412f, -0.05718911f, -0.05607664f, 0.03874829f, -0.02157223f, 
    -0.23257586f, -0.27118215f, -0.11237626f, 0.21860372f, 0.23878612f, 0.20042744f, -0.12305921f, 0.22819281f, 
    -0.96405542f, -0.49411905f, 0.74746746f, 0.43611747f, 0.37892383f, 0.10796350f, -0.29112303f, -0.28687647f, 
    0.03463897f, -0.11211259f, 0.11165189f, -0.52431780f, 0.09215494f, 0.36640200f, -0.05908802f, -0.25099784f, 
    0.19610891f, 0.35129786f, -0.00787132f, 0.11801455f, -0.13839254f, 0.30713585f, -0.16326852f, -0.31276327f, 
    0.45812410f, 0.27872822f, -0.35111010f, -0.44583037f, -0.23307359f, 0.17571475f, 0.05696267f, -0.03977147f, 
    -0.23440535f, -0.29240099f, -0.14002071f, 0.44791555f, 0.10111078f, -0.30248716f, -0.05501553f, -0.25305265f, 
    0.01637948f, -0.02103825f, -0.11331940f, -0.02694218f, -0.08304294f, -0.01741355f, 0.31700224f, 0.34258276f, 
    0.17956217f, -0.00931166f, -0.37950096f, 0.13060774f, 0.21983978f, -0.38200563f, -0.22812523f, 0.32302704f, 
    -0.49019450f, -0.54734790f, -0.56177837f, 0.13011040f, -0.17783315f, 0.02054717f, -0.06607583f, -0.04870357f, 
    -0.12105328f, -0.21814732f, 0.07362677f, 0.12316951f, 0.13624780f, -0.11387715f, -0.14109147f, -0.28620139f, 
    -0.18749681f, -0.32593578f, -0.56892270f, -0.13019574f, 0.69952565f, 0.47638613f, -0.27974144f, -0.23998101f, 
    -0.47989267f, 0.05583001f, 0.09376004f, 0.15282811f, -0.08020018f, 0.14728422f, -0.36543435f, 0.51380432f, 
    -0.44358382f, -0.40382749f, 0.01414948f, 0.26703191f, 0.31115869f, 0.13071057f, 0.16081417f, -0.30202231f, 
    -0.18303883f, -0.08716809f, 0.09413591f, -0.19522199f, 0.02361582f, 0.37093669f, -0.32319000f, 0.27518156f, 
    0.33969682f, 0.21957901f, -0.23551019f, -0.21175195f, 0.04165888f, 0.09531362f, 0.01571172f, -0.38305864f, 
    -0.20008270f, 0.25553229f, -0.06237220f, 0.26575562f, 0.28804532f, -0.23311237f, -0.12307348f, 0.21694113f, 
    -0.01682729f, -0.00797610f, -0.17011866f, -0.23783022f, 0.08812463f, 0.13825884f, 0.03574942f, -0.07671393f, 
    -0.31503731f, 0.18493117f, -0.03863627f, 0.15814576f, -0.10522565f, -0.01022326f, 0.13446853f, -0.23337460f, 
    0.09375617f, 0.13831683f, -0.13252605f, -0.27309367f, 0.09580059f, -0.16131730f, -0.11157787f, 0.37418610f, 
    -0.02617692f, -0.01845437f, -0.05157812f, 0.06186930f, 0.29108122f, -0.24884939f, -0.94013840f, -0.21027154f, 
    0.58994216f, 0.98150933f, -0.20627393f, -0.01240300f, 0.08827841f, -0.18541721f, -0.09808179f, -0.24583390f, 
    -0.42434230f, 0.40434805f, -0.41809657f, 0.10238823f, 0.09449692f, 0.10961553f, -0.04135283f, 0.15159491f, 
    -0.05186169f, 0.00764701f, 0.02452933f, -0.40353453f, -0.20818368f, 0.26303017f, -0.38971752f, 0.52500170f, 
    -0.02066369f, -0.16866753f, 0.17658226f, 0.17650412f, 0.24205370f, 0.01635379f, 0.09806792f, -0.05351690f, 
    0.20095307f, -0.12510085f, -0.15729460f, -0.10045549f, 0.17012136f, 0.21511255f, -0.26415634f, -0.01850942f, 
    -0.05419019f, -0.00866226f, 0.12154929f, 0.24988964f, 0.13651903f, -0.17697853f, -0.31401908f, -0.26247728f, 
    -0.19329213f, -0.15637583f, -0.22348109f, -0.05570594f, 0.00697433f, -0.35097167f, 0.20113590f, -0.46041095f, 
    0.13298789f, -0.03017030f, 0.26873863f, -0.20455873f, 0.11239554f, -0.07095511f, 0.09942182f, 0.05284372f, 
    -0.14515688f, -0.08978748f, -0.05791167f, -0.02549911f, 0.20354299f, 0.24204579f, -0.02729643f, 0.25840324f, 
    -0.16761971f, -0.23035836f, -0.09948910f, -0.06437687f, -0.27627996f, -0.28166497f, -0.19356857f, -0.28997308f, 
    -0.19363382f, -0.38995698f, -0.05094106f, -0.08053246f, 0.02332966f, 0.23919593f, -0.32618496f, -0.26168630f, 
    -0.11218957f, -0.14860457f, -0.01251235f, -0.21437144f, 0.08353643f, -0.11574514f, -0.39636549f, 0.14123504f, 
    0.24026655f, 0.45820257f, -0.28715709f, -0.50611025f, -0.27674651f, -0.28344518f, -0.02203012f, 0.35720983f, 
    0.18176651f, 0.26692417f, -0.30443037f, -0.05273907f, -0.12870188f, -0.17335944f, -0.08128549f, -0.18826559f, 
    -0.28089681f, 0.00898393f, 0.19062397f, -0.03520091f, -0.10084213f, 0.20596716f, -0.08114215f, 0.00118089f, 
    0.20237853f, 0.36809751f, -0.35168234f, -0.69850832f, 0.48971787f, 0.22625712f, 0.66038251f, 0.15121260f, 
    -0.51091820f, -0.77215517f, -0.13983653f, 0.10758676f, 0.08118445f, 0.34093374f, -0.09776019f, 0.25532061f, 
    -0.23744319f, 0.04781695f, -0.17744778f, -0.25737783f, -0.04026178f, -0.24162123f, -0.09900457f, -0.00942244f, 
    0.03606064f, 0.13516754f, -0.06580777f, 0.62571931f, 0.53152567f, 0.15535752f, -0.21822645f, -0.38592348f, 
    -0.36043260f, -0.08231699f, 0.23241942f, -0.09545026f, -0.24528341f, 0.09193994f, 0.20529479f, 0.34321347f, 
    -0.39415362f, -0.12356690f, -0.29541284f, 0.21192411f, -0.12722518f, -0.01742463f, 0.16185789f, 0.09235177f, 
    -0.03405324f, -0.10915660f, 0.22483405f, -0.27358493f, 0.51847601f, -0.08078493f, -0.07370961f, -0.28178081f, 
    -0.81948477f, 0.40937459f, 0.06239019f, -0.24014325f, -0.20704086f, 0.25616702f, 0.15510163f, 0.25087902f, 
    0.09099872f, -0.06021949f, -0.16579871f, -0.18617365f, 0.04427628f, 0.21882187f, -0.16735023f, -0.28030086f, 
    0.09690554f, -0.33404586f, -0.26714566f, 0.10303719f, -0.05868379f, -0.43037733f, 0.17632003f, -0.12297132f, 
    -0.36354759f, -0.42074862f, 0.08290622f, 0.04328566f, 0.34240675f, 0.02421166f, 0.52659190f, -0.21012293f, 
    -0.21355115f, 0.21454193f, -0.09180456f, -0.05459414f, 0.07308073f, 0.15013650f, 0.16949607f, 0.01690532f, 
    0.02591886f, 0.22611828f, 0.44273210f, -0.28695348f, -0.30511662f, 0.07182404f, -0.22137472f, 0.28776258f, 
    0.19273986f, -0.57536125f, -0.42814732f, -0.35274675f, -0.03776347f, 0.04713350f, 0.30574012f, 0.25202802f, 
    0.21650323f, 0.09756000f, -0.01166432f, 0.16490036f, 0.20763054f, -0.20565216f, 0.26750293f, -0.00647482f, 
    -0.26308212f, -0.12102866f, 0.08847210f, 0.11909895f, -0.00744156f, -0.15803108f, -0.06909821f, -0.63860661f, 
    -0.66777176f, 0.06636186f, 0.33097956f, 0.29258043f, 0.62611485f, -0.15428218f, -0.66848451f, -0.10904066f, 
    0.45963678f, 0.28099653f, -0.30617699f, -0.02186575f, 0.45100355f, -0.44631872f, -0.16234595f, -0.08387524f, 
    0.27386677f, -0.02944878f, 0.03164082f, -0.14415377f, 0.13482116f, -0.07509694f, 0.09144957f, 0.00715381f, 
    -0.30724311f, -0.16798666f, -0.38476959f, -0.23381072f, -0.50619090f, -0.20956776f, -0.45812201f, -0.27724177f, 
    -0.40473217f, 0.04931689f, 0.21097995f, 0.31635523f, 0.33666155f, 0.04504671f, 0.13420551f, 0.17815070f, 
    0.14990263f, 0.09485242f, -0.03997463f, -0.17829838f, -0.14716816f, 0.21078847f, 0.24893515f, -0.07521701f, 
    0.05503940f, -0.24287735f, -0.26116526f, -0.52928209f, -0.29540583f, -0.44302246f, 0.09569792f, 0.03617314f, 
    -0.03096830f, -0.02241121f, 0.08774176f, -0.25410926f, -0.33210590f, -0.34666625f, -0.21383226f, 0.02932025f, 
    0.10877033f, 0.02508240f, -0.17699400f, 0.23901506f, -0.07961359f, 0.10968845f, -0.30250245f, -0.01449175f, 
    -0.42138007f, -0.47614303f, 0.19667932f, 0.19074255f, 0.05609331f, 0.32142365f, 0.20736656f, -0.17492500f, 
    0.14380987f, 0.04255455f, -0.03928825f, 0.13116524f, 0.11025662f, 0.25664368f, -0.12092062f, -0.44006276f, 
    -0.03534295f, 0.14081717f, -0.15599677f, 0.16947813f, -0.08684870f, 0.08310229f, -0.27906021f, -0.26934874f, 
    -0.09434493f, -0.05848349f, -0.30225131f, 0.06275585f, -0.00475216f, 0.21652527f, 0.20942384f, -0.01735531f, 
    0.11588298f, 0.02873575f, 0.07192867f, 0.01961393f, 0.00859879f, 0.28473794f, -0.39696571f, -0.06212933f, 
    0.16431805f, -0.10988343f, -0.13886353f, -0.04122550f, 0.12106543f, 0.02471628f, -0.15216321f, 0.18843360f, 
    -0.03699317f, -0.26608104f, -0.10225132f, 0.00162814f, -0.86574024f, -0.81232911f, -0.04188216f, 0.08689172f, 
    0.11497712f, 0.53407228f, 0.43390176f, -0.37443739f, -0.14288305f, 0.30699113f, -0.07446212f, -0.15205023f, 
    -0.04344768f, 0.06486364f, -0.34704080f, -0.01173832f, 0.16815902f, -0.40041208f, -0.24154362f, -0.11620784f, 
    0.10049412f, -0.18747967f, 0.02430980f, 0.13970652f, -0.11227611f, -0.22765376f, -0.03513294f, -0.18117960f, 
    0.10975692f, 0.34639788f, -0.35193202f, 0.24033555f, 0.69326085f, -0.36877844f, -0.29306242f, -0.11087881f, 
    -0.04894960f, 0.46060550f, -0.42900380f, 0.04340004f, -0.14691548f, 0.03883588f, -0.21686654f, 0.10011056f, 
    0.16096672f, 0.24037750f, -0.20113070f, -0.03506663f, -0.03084266f, -0.00132116f, 0.18721557f, -0.20985729f, 
    0.22302781f, 0.66825646f, 0.10919400f, -0.54763246f, -0.51860523f, -0.09115740f, -0.02893746f, 0.24248138f, 
    -0.07506537f, -0.07948874f, 0.02569218f, 0.37820092f, 0.21022424f, -0.23940687f, -0.04942873f, 0.17205743f, 
    0.04642234f, -0.39317402f, 0.02409729f, 0.11202873f, -0.13989708f, -0.11046983f, 0.13892689f, -0.17359190f, 
    0.31091994f, -0.13544369f, -0.07617152f, -0.27475452f, -0.34617200f, -0.17822912f, -0.12570950f, -0.03338587f, 
    -0.30268174f, 0.03363940f, -0.07411829f, 0.28910190f, -0.41018158f, -0.14136060f, 0.00149570f, -0.32677683f, 
    -0.17988263f, -0.48275843f, -0.40861884f, -0.21588528f, 0.15956382f, -0.06725432f, -0.28074571f, -0.03235602f, 
    -0.02022230f, 0.41285720f, 0.10019725f, -0.38246349f, 0.14440075f, 0.02259070f, -0.09641560f, -0.08429893f, 
    0.06782171f, -0.18804792f, -0.14768161f, -0.14510824f, -0.10466320f, 0.16162121f, 0.09393608f, 0.11354899f, 
    0.21906431f, 0.30271968f, -0.01545012f, -0.49455023f, -0.29761323f, -0.19901299f, -0.07868067f, 0.13758096f, 
    0.30770317f, -0.19131486f, -0.24665295f, -0.14698768f, -0.19560771f, -0.38772142f, -0.11808808f, -0.24176598f, 
    -0.01918933f, 0.09984770f, 0.27358449f, 0.07562234f, 0.13524245f, 0.03298423f, 0.17394923f, 0.05700559f, 
    -0.26431465f, 0.22202924f, -0.13802619f, -0.26886201f, -0.05244095f, -0.26884538f, -0.08040570f, -0.10766011f, 
    0.02223285f, -0.33249173f, -0.10451583f, 0.23923253f, 0.17659280f, 0.05869748f, -0.50606263f, -0.41658801f, 
    -0.11390029f, -0.08346735f, -0.13155991f, -0.19866586f, 0.39184234f, -0.26178637f, 0.28490937f, 0.55633873f, 
    -0.22599888f, -0.03852179f, 0.31046262f, -0.11853143f, -0.21951996f, -0.41435343f, 0.09871949f, -0.05399199f, 
    0.04823023f, -0.17540032f, 0.10241451f, -0.58927548f, -0.42898619f, -0.26708490f, -0.30945480f, -0.22705235f, 
    0.44190201f, 0.01229087f, -0.34491134f, -0.23606698f, 0.15669715f, -0.19604728f, -0.31235534f, -0.00489069f, 
    0.29897535f, -0.02547958f, -0.11655542f, -0.13744463f, -0.19798523f, -0.01144804f, -0.19815391f, -0.23678088f, 
    -0.06095797f, 0.10561237f, -0.13442527f, 0.02662947f, 0.31221008f, -0.43698537f, -0.16540681f, -0.50714183f, 
    0.06614386f, -0.40108979f, -0.53817660f, -0.25411478f, -0.17522296f, 0.23255552f, 0.06450077f, 0.35183728f, 
    0.34214327f, -0.10306893f, -0.25515488f, 0.09598089f, -0.08177897f, -0.21878661f, 0.00572505f, -0.17867583f, 
    0.27776968f, -0.20245159f, -0.16644399f, 0.11542091f, -0.12698503f, 0.34044588f, -0.77008146f, -0.03960985f, 
    0.16211237f, 0.21566840f, -0.33078989f, 0.24383245f, -0.51686096f, -0.46230528f, -0.17148642f, -0.22007707f, 
    -0.08109295f, 0.10093512f, -0.28918871f, 0.08955614f, -0.05208731f, 0.26904389f, -0.15335827f, -0.05105841f, 
    -0.07294983f, 0.11823443f, -0.06137278f, 0.22603254f, -0.02741290f, 0.02351210f, 0.13604727f, -0.04217932f, 
    0.06952584f, 0.14355744f, 0.14451951f, 0.23764373f, -0.32575282f, -0.43599138f, -0.23123425f, 0.36988363f, 
    -0.22227646f, 0.32309043f, -0.08494242f, -0.07008688f, -0.21806172f, 0.30989119f, -0.20717651f, -0.05810672f, 
    -0.29739082f, 0.18038289f, -0.30038819f, -0.04106922f, -0.31298357f, -0.27795029f, -0.49043053f, 0.41990724f, 
    0.28243464f, 0.27361467f, 0.32780457f, -0.62403452f, -0.55292583f, -0.40990442f, 0.22257340f, 0.08215670f, 
    0.04031453f, 0.20314902f, -0.31314194f, 0.35489190f, -0.11210139f, -0.15375261f, -0.05475373f, 0.08627511f, 
    -0.21405131f, -0.10725522f, -0.29035103f, 0.15262114f, -0.15514210f, 0.01454432f, 0.19184096f, 0.11750571f, 
    -0.07175683f, -0.08478279f, 0.04725422f, 0.15180190f, 0.16354415f, -0.36277282f, -0.09940609f, -0.30755788f, 
    0.35235950f, 0.23541676f, -0.18123454f, -0.03323603f, -0.15883316f, -0.09055454f, 0.17185198f, 0.05547399f, 
    0.01077306f, 0.02872782f, -0.25790906f, 0.13409741f, -0.22888263f, 0.11671884f, 0.14399302f, 0.10646851f, 
    0.14313604f, -0.76562417f, -0.00966725f, 0.12220050f, -0.45155320f, 0.10184599f, -0.06812885f, -0.30567661f, 
    0.35695991f, 0.53986710f, 0.27507186f, -0.62216926f, -0.34413132f, -0.18669198f, 0.40175700f, 0.21302637f, 
    0.03704365f, -0.09495663f, -0.00275000f, 0.29284734f, 0.13890038f, -0.43992946f, 0.17273480f, 0.10074517f, 
    -0.15624067f, -0.31785965f, -0.79180902f, -0.37039706f, -0.15719664f, -0.31802461f, -0.33123782f, 0.65038997f, 
    0.44539538f, -0.14406922f, -0.30009571f, 0.48226807f, 0.09757356f, 0.23936337f, 0.10355825f, -0.04119860f, 
    -0.14539194f, -0.06870098f, 0.12136285f, -0.06450267f, -0.05605679f, -0.04861989f, 0.02019898f, 0.00481526f, 
    -0.17867766f, 0.21194527f, -0.10401582f, -0.56050891f, -0.37596706f, 0.12891801f, -0.24568716f, 0.06334307f, 
    -0.20274827f, -0.20909840f, -0.36725387f, 0.08194028f, -0.35035589f, 0.55475467f, -0.07625835f, 0.51447862f, 
    0.04707397f, 0.21625169f, -0.08547994f, -0.17259546f, -0.19135574f, -0.00070528f, -0.16113374f, 0.04507231f, 
    -0.10977477f, 0.07235324f, 0.03438910f, 0.06610561f, 0.78870553f, -0.39711446f, -0.44326326f, -0.22712289f, 
    0.47449851f, -0.28408661f, -0.18033940f, -0.10805193f, 0.15516061f, 0.14482006f, 0.01947196f, 0.36375758f, 
    0.16752447f, -0.16616349f, -0.10630397f, 0.29294199f, 0.00441892f, -0.32859966f, 0.03142608f, -0.19796813f, 
    -0.00130357f, -0.11357053f, 0.03666778f, 0.22856863f, 0.20592432f, -0.39143494f, -0.43623590f, -0.29508427f, 
    0.12335770f, 0.26479024f, -0.33317319f, 0.56403428f, -0.47176069f, 0.01428730f, 0.05462590f, -0.28193390f, 
    -0.09590337f, -0.20447940f, -0.30184773f, -0.30344263f, -0.16725178f, 0.18483010f, 0.32408911f, 0.28325033f, 
    0.00985177f, 0.12230698f, -0.05257114f, -0.14398177f, 0.15838070f, 0.19754520f, 0.33296266f, -0.12640992f, 
    -0.20755605f, 0.35567331f, -0.35337424f, -0.29886234f, -0.19498256f, 0.37191477f, 0.05729730f, -0.20458329f, 
    0.38096520f, -0.17891467f, -0.07428921f, -0.22313797f, 0.33295429f, -0.12106406f, -0.01208450f, -0.17513722f, 
    -0.04272895f, 0.03877646f, 0.08002593f, -0.09470811f, 0.13968056f, -0.28871012f, 0.14053389f, -0.07000089f, 
    -0.00068417f, -0.24718325f, -0.28411081f, -0.19307050f, -0.26837108f, -0.08532852f, 0.32426235f, -0.08864897f, 
    -0.14138851f, -0.01177404f, -0.24016571f, -0.22066231f, -0.13200299f, -0.18866210f, 0.24925081f, 0.32178107f, 
    0.00894027f, -0.33722937f, 0.12298062f, -0.14087854f, -0.12553513f, 0.23390161f, 0.15228255f, 0.25340927f, 
    -0.21964277f, -0.36897516f, -0.51667923f, -0.03642642f, -0.06642114f, 0.13358665f, 0.46666819f, 0.45172623f, 
    0.02197865f, 0.04930718f, 0.19042364f, 0.16259140f, 0.24775547f, -0.15198940f, -0.19700745f, 0.05209158f, 
    0.00285468f, 0.00575039f, -0.23048347f, 0.07920089f, -0.17092082f, -0.14257085f, -0.16607925f, 0.14525923f, 
    0.37170711f, -0.16915447f, -0.31108275f, -0.29918805f, 0.32235676f, 0.05232797f, -0.20536640f, -0.20646189f, 
    -0.35990641f, 0.01151966f, -0.14974743f, -0.32511023f, 0.48743948f, -0.31272721f, -0.23716278f, -0.14273176f, 
    -0.07418951f, 0.26378021f, -0.03764856f, -0.24378808f, -0.22079945f, -0.26877981f, 0.43152615f, -0.21789160f, 
    -0.19817191f, -0.17875205f, 0.26263970f, -0.29968387f, -0.04878505f, 0.50160700f, -0.34984520f, 0.48445967f, 
    -0.39079672f, -0.10280464f, 0.41788816f, 0.35449713f, 0.16967456f, -0.05767006f, 0.04957807f, 0.04795076f, 
    -0.02407794f, -0.46550986f, -0.03403084f, 0.43110836f, -0.11283682f, -0.34283742f, 0.05364455f, -0.04953719f, 
    -0.14475316f, 0.23180678f, 0.36099830f, 0.28689581f, -0.18824878f, 0.14606902f, -0.03551621f, 0.16609481f, 
    0.32966813f, 0.22859339f, 0.24086443f, 0.25439659f, -0.07813035f, 0.00161693f, 0.08001648f, -0.12322067f, 
    -0.12909114f, 0.25499931f, 0.12393694f, -0.21704158f, 0.02245416f, -0.02912416f, -0.07571225f, 0.30785394f, 
    0.10686571f, 0.05127155f, -0.16372204f, -0.17367652f, 0.10460002f, 0.62629163f, 0.50652254f, -0.34200299f, 
    -0.33405152f, -0.14398752f, -0.23556694f, -0.28910932f, 0.31960332f, -0.30213487f, -0.18174683f, -0.24880061f, 
    -0.03070514f, 0.04194747f, 0.26214868f, 0.18204658f, 0.21702285f, -0.40912524f, -0.15905133f, 0.17126226f, 
    0.06665976f, 0.21837041f, 0.16726950f, -0.06426313f, -0.11342378f, -0.14210901f, -0.10134827f, 0.18500671f, 
    -0.34201431f, 0.07481728f, -0.29671377f, -0.08923069f, -0.46495530f, -0.38646775f, -0.03812238f, -0.09384858f, 
    -0.05708212f, 0.04580695f, 0.02226618f, 0.21480073f, -0.10005029f, -0.48264834f, 0.13257954f, -0.17133828f, 
    0.03345453f, -0.19625142f, 0.05569924f, -0.40160000f, 0.13674723f, 0.07515968f, -0.33071691f, -0.40736446f, 
    -0.51969147f, -0.15566073f, -0.12363902f, 0.06609911f, 0.08764952f, -0.16333944f, -0.30250219f, -0.05028001f, 
    0.34977415f, 0.18493247f, 0.20672874f, -0.18753630f, -0.01232108f, 0.03015133f, -0.18536577f, 0.03161679f, 
    -0.15200160f, 0.13752569f, -0.30596578f, -0.06865992f, 0.16536823f, -0.13740094f, -0.28470272f, -0.05403864f, 
    0.12381943f, -0.12557405f, 0.14846730f, 0.11800756f, -0.07905137f, 0.06817444f, -0.10552751f, -0.23912825f, 
    0.47699907f, -0.04460940f, 0.34336156f, 0.00204838f, -0.22450735f, -0.05531488f, -0.06013614f, -0.23135975f, 
    -0.13902150f, -0.05196419f, 0.09093430f, -0.20568524f, -0.18131277f, 0.11991219f, 0.03593025f, -0.07061421f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.17304011f, 0.10057696f, 0.26304954f, -0.41717705f, -0.10769679f, -0.18237621f, -0.01864777f, -0.13586514f, 
    0.11751084f, 0.08518457f, -0.10925101f, -0.01214886f, 0.23434609f, 0.20666336f, -0.00828815f, 0.14885697f, 
    0.07353869f, -0.23616466f, -0.04554196f, 0.04857707f, -0.01526384f, -0.07193521f, -0.09380917f, -0.19458975f, 
    -0.19583705f, -0.23833613f, -0.08639632f, 0.13278247f, -0.04516795f, -0.17397542f, -0.02871820f, 0.07702512f, 
    -0.20100844f, -0.14412148f, -0.19335201f, -0.00758171f, 0.16237092f, 0.23362958f, 0.02217679f, -0.07130054f, 
    0.11343089f, -0.12151331f, 0.03961077f, -0.01881406f, 0.19832660f, -0.08134286f, -0.09255394f, 0.06699739f, 
    0.29426649f, -0.01431599f, 0.18938071f, -0.03163154f, -0.00016766f, 0.06284031f, 0.23387156f, -0.22700991f, 
    -0.17207864f, -0.28121221f, 0.09122748f, -0.20168088f, 0.01935559f, 0.00038810f, 0.02061079f, 0.08844280f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.00788719f, 0.10315383f, 0.05801382f, 0.05509641f, -0.06458969f, -0.01363396f, 0.09407467f, 0.16699134f, 
    -0.02419939f, 0.03970089f, -0.04276853f, -0.01356488f, 0.17101626f, -0.17249297f, -0.10536624f, -0.03220065f, 
    -0.03246111f, -0.00855550f, 0.17248924f, -0.22179888f, -0.12880428f, 0.05956061f, 0.04794104f, 0.02195756f, 
    -0.06525806f, -0.02424924f, -0.05800229f, 0.00213954f, 0.03382640f, 0.10096923f, -0.12458108f, -0.02344564f, 
    -0.10290336f, -0.03432774f, 0.00614512f, -0.13149580f, 0.03554327f, -0.02086077f, -0.07713553f, -0.02792493f, 
    0.09061331f, 0.03410666f, 0.05630871f, 0.07599152f, -0.03632965f, 0.00296470f, -0.11330710f, 0.01084553f, 
    -0.18541710f, -0.25333005f, -0.44422641f, -0.12864219f, 0.00455485f, 0.05160286f, -0.03596365f, 0.06375616f, 
    0.03245625f, -0.02529528f, 0.00721712f, 0.09461948f, -0.00774100f, 0.19358370f, -0.16046508f, 0.03387624f, 
    0.06222766f, -0.04106497f, -0.13440037f, 0.22251195f, -0.04453336f, 0.26324928f, 0.08148848f, 0.02075869f, 
    0.17519587f, 0.09963396f, 0.05508009f, 0.05877514f, 0.13397199f, 0.12914826f, 0.04488844f, -0.03886586f, 
    -0.04312345f, -0.12766929f, -0.07753249f, 0.01022811f, -0.27477720f, -0.24491857f, 0.09092971f, -0.05473695f, 
    0.10497725f, 0.07911228f, -0.07439368f, 0.03961190f, 0.05968754f, -0.02305322f, -0.03977302f, 0.02632237f, 
    0.17995499f, 0.33941761f, -0.10719985f, -0.13305581f, 0.00028443f, 0.07392892f, -0.07261850f, 0.00701046f, 
    0.10175736f, 0.05057377f, 0.02983089f, -0.01293862f, -0.07413457f, -0.15162782f, 0.00405531f, -0.09665141f, 
    -0.01559117f, 0.04286551f, -0.01471359f, 0.00881514f, -0.04300101f, 0.00711302f, 0.04318751f, 0.03388897f, 
    -0.07627226f, -0.03613358f, 0.11422037f, -0.11322166f, 0.08929956f, -0.06915287f, -0.10078412f, -0.07941531f, 
    0.12081566f, 0.08177211f, 0.14861612f, 0.10071325f, -0.07719187f, -0.10653084f, -0.15177001f, 0.01921014f, 
    0.01621881f, -0.01302937f, 0.02597702f, -0.01384893f, 0.00161690f, -0.08829195f, 0.02290142f, -0.10637267f, 
    0.32522774f, 0.03420220f, 0.05269519f, 0.08027497f, 0.19862857f, 0.09195928f, 0.12954544f, -0.06659713f, 
    -0.03373316f, 0.00882754f, 0.10823136f, 0.13566169f, 0.00263389f, -0.05290295f, -0.25063017f, -0.03740924f, 
    0.05718860f, 0.04579014f, -0.00896049f, 0.05748426f, 0.01728878f, -0.07627877f, 0.08325672f, 0.08654790f, 
    -0.02688008f, 0.12632491f, 0.07254243f, -0.04085279f, -0.05607689f, 0.22948915f, 0.14335047f, 0.07326089f, 
    0.11669552f, -0.05344220f, -0.12243386f, 0.04864032f, 0.18246375f, 0.00943704f, 0.13986731f, 0.00146504f, 
    -0.12360728f, -0.03482297f, -0.06917472f, -0.16108200f, 0.13493018f, -0.13360357f, 0.07543718f, 0.09505084f, 
    0.15266803f, 0.24218251f, -0.11191332f, 0.15483037f, 0.06198535f, 0.15164384f, -0.00858991f, -0.15883954f, 
    -0.09304392f, -0.06173889f, -0.09184772f, -0.04239960f, 0.01953316f, 0.00511548f, 0.05579603f, 0.01517228f, 
    0.12944397f, -0.08691803f, 0.21095252f, 0.21625482f, 0.03318478f, -0.09876557f, 0.11539781f, 0.09801968f, 
    -0.02114136f, 0.12967469f, -0.00213854f, -0.31894460f, 0.02524407f, -0.12283651f, -0.16332656f, -0.19273397f, 
    0.08775677f, -0.08025665f, 0.05017719f, -0.00441030f, -0.05326391f, 0.03306045f, -0.13146281f, -0.13384402f, 
    0.04931340f, 0.02955788f, -0.05598481f, 0.01246517f, 0.01799222f, 0.03110013f, 0.00201898f, -0.09793929f, 
    -0.00861326f, 0.03531817f, -0.08780844f, -0.05998097f, 0.00368903f, 0.08811133f, -0.03307513f, 0.01178845f, 
    -0.02813305f, -0.04977077f, -0.05387596f, -0.05412632f, -0.02465770f, 0.26510793f, -0.10367808f, 0.03408693f, 
    -0.01713465f, -0.14394586f, 0.00309946f, 0.02302380f, 0.02228582f, -0.06987493f, -0.23467845f, 0.01530686f, 
    -0.10184771f, -0.07604413f, -0.08124107f, 0.03198206f, 0.07273253f, -0.00135748f, -0.04495295f, 0.06380722f, 
    -0.04610805f, -0.14660908f, 0.08111896f, -0.07952001f, 0.24858564f, 0.21853203f, 0.02371731f, 0.12136526f, 
    0.05391231f, 0.05641967f, 0.06079072f, 0.01299183f, -0.02768936f, -0.02164175f, -0.06693731f, -0.04039321f, 
    0.18363079f, 0.13959736f, 0.12638497f, 0.11218369f, 0.20510744f, 0.04037886f, 0.20753376f, 0.21894786f, 
    -0.10246827f, -0.14919682f, -0.05055914f, -0.06765597f, 0.33778134f, 0.14197443f, -0.04736352f, 0.01287921f, 
    0.14172582f, 0.14556809f, 0.02340724f, -0.07446195f, -0.09129057f, -0.01059708f, 0.00758261f, -0.14430739f, 
    0.00708557f, 0.19184132f, 0.01264173f, 0.08438758f, 0.09641460f, 0.04214946f, -0.04342768f, -0.06676740f, 
    -0.02939537f, -0.10286652f, -0.07861914f, 0.07443003f, -0.05544057f, 0.16732930f, -0.17579669f, -0.00991112f, 
    -0.01037221f, -0.13517097f, -0.08193875f, -0.00941507f, 0.04136348f, 0.03076232f, -0.06117114f, 0.09327769f, 
    0.08178414f, -0.14158820f, 0.09823595f, -0.13075525f, -0.03445963f, 0.09307431f, -0.07426088f, -0.06637827f, 
    0.10491565f, 0.06264953f, 0.13429059f, 0.28264421f, 0.11166225f, 0.02721926f, 0.10312834f, 0.08165322f, 
    -0.01794359f, 0.14946842f, -0.07673354f, -0.11454917f, -0.01896439f, -0.01570567f, 0.04418612f, 0.01914219f, 
    -0.10139327f, 0.01199912f, 0.10334442f, 0.14639618f, -0.01708815f, 0.03506633f, -0.08108068f, 0.05709093f, 
    0.04561791f, 0.07490245f, 0.00371488f, -0.01684352f, 0.25279269f, -0.05044015f, 0.18513660f, -0.24468356f, 
    -0.02943204f, 0.16212754f, -0.10268038f, -0.01635002f, 0.10785338f, -0.19677247f, 0.06845998f, -0.01291056f, 
    0.36543521f, 0.24850820f, 0.13454525f, 0.24447149f, 0.02460048f, 0.04699679f, -0.08014771f, -0.00765788f, 
    0.05472824f, 0.08154407f, 0.00859646f, -0.00089475f, 0.23873284f, 0.17040657f, 0.17760228f, 0.16726881f, 
    0.03951192f, 0.09810129f, 0.09450952f, 0.12262431f, -0.01587389f, -0.10936543f, 0.04769129f, 0.24284871f, 
    -0.03107520f, -0.10551079f, 0.02092306f, 0.01864250f, 0.04272007f, -0.02144973f, 0.06929550f, 0.01601799f, 
    -0.07104594f, 0.08818810f, 0.06989592f, 0.16763936f, -0.16382869f, -0.25473008f, -0.07543256f, -0.12629746f, 
    0.04971951f, -0.00501882f, -0.05511644f, 0.08592042f, 0.04702136f, -0.04505160f, 0.01002248f, -0.04368101f, 
    0.30134380f, 0.08007960f, 0.15025896f, 0.00666220f, 0.06381594f, 0.10687774f, 0.00516433f, -0.01517844f, 
    0.00429890f, -0.05212928f, -0.00317731f, 0.08753601f, -0.06872559f, 0.21929505f, -0.34810776f, -0.02042369f, 
    0.08281333f, -0.16145924f, -0.02578145f, -0.17776145f, -0.12019198f, 0.11661371f, -0.10308783f, 0.01784937f, 
    -0.07494958f, -0.03566673f, 0.13150331f, -0.08655808f, -0.00277317f, -0.05151109f, 0.00142422f, 0.13491943f, 
    0.05918933f, -0.09165052f, 0.07578051f, -0.03537855f, 0.03406029f, 0.29982117f, -0.03277918f, 0.21005888f, 
    -0.04530217f, 0.02541757f, -0.07582845f, 0.03047883f, -0.07915732f, 0.01109189f, -0.06999999f, 0.08544308f, 
    0.03100120f, -0.08936255f, -0.01899221f, -0.03777970f, 0.04144591f, -0.03786803f, -0.09873383f, -0.05125832f, 
    0.02058861f, 0.02493438f, -0.01701411f, -0.08464940f, 0.11741246f, -0.01870417f, 0.09663305f, 0.07241490f, 
    0.01596567f, 0.06150443f, -0.03555691f, -0.07065807f, -0.00055284f, 0.06129498f, 0.07014107f, 0.10180929f, 
    -0.01235180f, -0.02464496f, 0.20943844f, 0.08238061f, 0.03722907f, -0.07291707f, 0.03611480f, 0.12582454f, 
    0.08019444f, 0.09190638f, 0.03699950f, -0.09825227f, 0.18721671f, 0.01398087f, 0.22266205f, 0.18010005f, 
    0.12194467f, 0.08283152f, 0.03821855f, 0.06944737f, -0.05909318f, -0.10593379f, 0.08254976f, -0.07205243f, 
    -0.04408538f, 0.18261263f, 0.10312759f, 0.18741117f, -0.02933528f, -0.10559010f, 0.08974867f, -0.06978530f, 
    0.01552840f, -0.07214022f, 0.12386979f, -0.02430512f, 0.05443802f, 0.05743864f, 0.01556231f, -0.06058833f, 
    0.07560960f, -0.11052015f, 0.11643433f, -0.01893224f, -0.04540205f, 0.01993786f, 0.02910864f, -0.00176767f, 
    -0.11241683f, 0.04253881f, -0.01803141f, -0.06414486f, -0.04643190f, -0.01472432f, -0.03765032f, -0.00819455f, 
    -0.06582146f, -0.02688214f, 0.13153487f, 0.12525278f, -0.19858095f, -0.07051136f, -0.13681687f, 0.01281952f, 
    0.11005720f, 0.01150504f, -0.12568456f, 0.01892831f, 0.05880675f, 0.01335701f, -0.10246649f, 0.01740128f, 
    -0.10653649f, -0.06048000f, -0.04177383f, -0.04682949f, 0.01629787f, -0.10098375f, 0.00892771f, 0.07348241f, 
    -0.00498124f, -0.00375634f, -0.09507751f, -0.00459917f, 0.15219450f, 0.18351635f, 0.11315559f, 0.16830835f, 
    0.05409107f, 0.11912528f, -0.14928329f, -0.03722883f, -0.09581665f, -0.05546727f, 0.21142037f, 0.11892344f, 
    0.16412666f, -0.04922350f, -0.17382433f, -0.01058689f, 0.14071572f, 0.13689709f, -0.00957189f, -0.09848996f, 
    0.02422821f, -0.02338911f, 0.05273548f, 0.14796272f, 0.06159035f, 0.05268310f, -0.05187600f, 0.02895557f, 
    0.10430107f, 0.09880365f, 0.00782978f, 0.12233709f, 0.09878695f, -0.03927287f, -0.01721095f, -0.07906865f, 
    -0.08730230f, -0.04887502f, 0.04187189f, 0.00163903f, -0.01830469f, -0.01061633f, 0.03408870f, -0.26967323f, 
    0.04662865f, -0.00322327f, 0.08315554f, -0.00915803f, 0.39554134f, 0.16911227f, -0.11188912f, -0.22056152f, 
    -0.04019309f, -0.10759430f, 0.04230938f, 0.12286128f, 0.02872657f, -0.02634553f, -0.05089079f, -0.05759170f, 
    0.00335877f, -0.16469230f, -0.08267861f, -0.26352304f, 0.05399442f, -0.25035706f, -0.01951235f, -0.03508836f, 
    0.02394661f, 0.05377074f, -0.15943889f, -0.17066705f, 0.25719669f, 0.31591213f, 0.04218588f, 0.04064937f, 
    0.19975868f, 0.02017561f, 0.00128918f, -0.00106377f, -0.09102938f, 0.06045144f, -0.05284494f, -0.08336598f, 
    0.21958074f, -0.05847460f, -0.16018213f, 0.09672979f, 0.10440376f, 0.02177400f, 0.10651963f, -0.03172523f, 
    -0.18469594f, -0.04246518f, 0.01983579f, 0.13897431f, 0.14834005f, 0.18792430f, -0.04077616f, 0.06461197f, 
    -0.04071214f, 0.08342125f, 0.05685256f, 0.24462572f, -0.00674187f, -0.00785788f, -0.09416412f, -0.01342565f, 
    0.17899114f, -0.26873156f, 0.10379598f, -0.45408422f, 0.03272040f, 0.05919119f, -0.06694809f, 0.07974270f, 
    -0.03021915f, 0.00821845f, 0.00662746f, -0.10561933f, 0.00779496f, -0.10498021f, -0.07419319f, 0.03119234f, 
    0.05848311f, 0.00033970f, 0.00304130f, 0.04072817f, -0.04345585f, -0.13546489f, -0.04641625f, -0.08387467f, 
    0.08312167f, 0.18891573f, -0.01095716f, -0.00884060f, -0.10264450f, -0.04189225f, -0.04555548f, 0.13567416f, 
    0.00800788f, 0.05703975f, -0.09446622f, 0.00591626f, 0.26296556f, 0.19471182f, 0.14755709f, 0.06423213f, 
    0.04754847f, 0.12862195f, -0.06860414f, 0.14755581f, -0.16604753f, -0.08512726f, -0.04485821f, -0.06315197f, 
    0.11796894f, 0.05217367f, -0.04045496f, -0.01382529f, 0.02018216f, 0.02412000f, 0.02090156f, 0.08898313f, 
    0.02124149f, -0.06136899f, 0.01024205f, 0.08553831f, -0.09902968f, -0.25125685f, -0.23974361f, -0.05523381f, 
    0.02645831f, 0.04223403f, 0.02495296f, 0.01060566f, -0.11237018f, 0.01503641f, -0.07732094f, -0.15614273f, 
    -0.00708098f, 0.02255385f, -0.02896804f, -0.01801362f, 0.03498014f, -0.00386923f, -0.00486402f, -0.02917523f, 
    0.02572395f, -0.01635236f, 0.00552731f, -0.03549218f, -0.02211823f, -0.02459888f, -0.00482245f, -0.01741567f, 
    -0.00560627f, -0.00462823f, 0.01001552f, 0.01310752f, -0.01973248f, -0.03957982f, -0.00081289f, -0.02661995f, 
    0.00777109f, 0.00427285f, -0.03104153f, -0.03576723f, -0.03942207f, 0.00089952f, -0.03326930f, -0.01391275f, 
    -0.01370654f, -0.02681131f, 0.02120458f, -0.02289785f, 0.01706237f, 0.01724437f, -0.01449446f, -0.02455341f, 
    0.02635803f, 0.00955424f, 0.01995987f, -0.01518759f, -0.03041247f, -0.02394996f, -0.00741046f, -0.01327201f, 
    -0.03724669f, -0.03305683f, 0.01915491f, -0.01488409f, 0.00422346f, 0.01276924f, 0.01674041f, -0.01365998f, 
    0.02875150f, -0.00422500f, 0.01928941f, -0.03837903f, -0.01737174f, 0.01183846f, -0.02349470f, -0.02128729f, 
    -0.01283106f, -0.00924440f, -0.00013708f, 0.01605512f, -0.04300312f, -0.01639614f, -0.02895640f, -0.02029839f, 
    -0.03013645f, -0.02935263f, -0.00508127f, 0.01516527f, 0.01104469f, -0.00993985f, -0.03432002f, 0.02070391f, 
    -0.00922132f, 0.02560974f, 0.00354078f, -0.03237003f, -0.04171931f, 0.01882221f, 0.00046484f, 0.02188566f, 
    -0.02442186f, -0.04253322f, -0.00352965f, -0.01202194f, -0.03568502f, -0.03992185f, 0.02753223f, -0.00099765f, 
    -0.03046741f, -0.01028428f, 0.00355844f, 0.01137330f, 0.02938597f, -0.00717952f, 0.00396462f, -0.00626518f, 
    0.00680365f, 0.02508475f, -0.02173808f, -0.03981701f, -0.01393428f, 0.02411717f, 0.00862208f, -0.03555394f, 
    0.02126063f, -0.00766083f, 0.02844997f, -0.00070075f, -0.03196093f, -0.02023608f, 0.00026019f, 0.02458309f, 
    -0.02190347f, 0.00712147f, -0.01925040f, -0.02005913f, -0.02308365f, 0.00350166f, -0.00841270f, -0.03123742f, 
    0.02045256f, 0.02057303f, -0.03629672f, -0.03295030f, -0.02605064f, -0.01591848f, -0.01450126f, -0.01343420f, 
    -0.02738920f, -0.01685031f, -0.01220174f, 0.01059259f, -0.00423993f, 0.00955408f, -0.02216420f, 0.00579893f, 
    0.00102419f, 0.03388443f, -0.00769776f, -0.00445206f, 0.00488369f, -0.01354033f, -0.01719047f, -0.01054429f, 
    0.03601969f, -0.01619575f, 0.01223105f, -0.02971910f, -0.04068128f, -0.00851265f, -0.03462325f, -0.02608825f, 
    0.00230538f, 0.00972692f, -0.02651582f, -0.03515024f, 0.02184633f, -0.02430295f, -0.03682691f, 0.02175089f, 
    0.02822634f, -0.03190472f, -0.03029298f, 0.01805748f, 0.01411082f, -0.03171014f, -0.01897417f, -0.03757142f, 
    0.01759527f, 0.00046241f, -0.01576983f, -0.03984358f, -0.03878681f, 0.02303370f, 0.02309315f, -0.02919667f, 
    -0.01949688f, 0.00579544f, -0.02999276f, 0.02807030f, -0.03794966f, 0.00449734f, -0.00533674f, -0.00677957f, 
    0.02477905f, -0.00518804f, 0.01647833f, -0.02119778f, 0.00183299f, -0.03512850f, -0.00865333f, -0.00475568f, 
    -0.02821128f, -0.00252894f, -0.01872056f, 0.02093108f, -0.00934430f, 0.01681430f, -0.01687540f, 0.02594342f, 
    0.02160427f, 0.03559164f, -0.00529439f, 0.01626155f, -0.00679433f, 0.00795423f, 0.01817062f, -0.00352300f, 
    -0.01954287f, -0.03554378f, 0.01260201f, -0.02395901f, -0.02921114f, -0.00812404f, -0.01047979f, 0.01842031f, 
    -0.03144034f, -0.00946325f, -0.02295091f, 0.01878097f, -0.01178649f, -0.03610748f, -0.03786619f, 0.01118138f, 
    -0.04215253f, -0.00095821f, -0.01065073f, -0.03700732f, -0.02049087f, -0.00753043f, -0.00661646f, -0.00321765f, 
    -0.01917331f, -0.00388084f, 0.02246025f, 0.01777684f, -0.04096650f, 0.00403414f, -0.01427424f, 0.00625022f, 
    -0.03814399f, 0.02066135f, -0.03647459f, 0.02740877f, -0.01423030f, 0.02134710f, 0.01855817f, -0.02381978f, 
    -0.01978803f, 0.01016307f, -0.02616423f, -0.01776738f, -0.02909868f, -0.02040869f, 0.01252673f, -0.01416706f, 
    -0.04074153f, 0.00142303f, 0.00896942f, -0.01018940f, -0.01282935f, 0.00093664f, -0.01984444f, 0.01284359f, 
    -0.00422737f, -0.03461522f, -0.03386230f, -0.00690901f, -0.00649571f, -0.01148685f, -0.00903052f, -0.00602117f, 
    0.02816053f, -0.02392454f, 0.02238363f, -0.00705568f, -0.01374341f, 0.00152378f, -0.03867008f, 0.02050008f, 
    -0.03078238f, 0.00037805f, 0.00326440f, -0.01515185f, -0.01371771f, -0.01496247f, -0.01387592f, 0.00714352f, 
    -0.02310118f, 0.02769972f, 0.01445394f, 0.00850172f, 0.01768730f, -0.02132900f, -0.01739354f, 0.00428664f, 
    -0.02049226f, 0.00655571f, -0.02221519f, 0.00755028f, -0.03958592f, 0.02074867f, -0.01656619f, -0.00163278f, 
    -0.02808851f, 0.03496239f, 0.01903594f, -0.00818712f, 0.00037474f, -0.00704664f, -0.01405915f, 0.02337071f, 
    -0.02518698f, 0.01986293f, -0.00692262f, 0.00318570f, -0.03296927f, 0.02586502f, -0.00541709f, -0.00143158f, 
    0.01810735f, -0.01722291f, -0.03766523f, 0.00411498f, -0.03100743f, -0.00168848f, -0.03708563f, -0.01784328f, 
    -0.00956740f, -0.01714698f, 0.02849671f, -0.01399800f, 0.00474893f, -0.02203324f, -0.01524021f, 0.02188277f, 
    0.00558322f, -0.01660854f, -0.02311184f, -0.01353956f, -0.03093902f, 0.02660924f, 0.00663141f, 0.01644270f, 
    -0.02513943f, -0.02679064f, -0.03260506f, -0.03421417f, -0.02595247f, -0.03050455f, -0.02759561f, 0.02402523f, 
    -0.01783426f, -0.03119386f, -0.03222090f, 0.02292614f, -0.02819794f, 0.01798248f, -0.02064008f, 0.02868278f, 
    -0.00252035f, 0.03419261f, -0.03374841f, 0.03402971f, 0.00002914f, -0.01121256f, 0.02291428f, -0.03513075f, 
    0.00178905f, -0.02290487f, -0.00858821f, -0.02875993f, -0.03787263f, 0.01891715f, -0.03080648f, 0.02866934f, 
    0.01087401f, 0.00842117f, 0.01645791f, 0.02116698f, 0.00236286f, 0.02851896f, -0.02993923f, 0.01942222f, 
    0.01957474f, 0.02293438f, -0.01582219f, -0.02348568f, 0.02396642f, -0.00261599f, 0.01345014f, -0.00018444f, 
    0.03073512f, -0.03014383f, 0.00003631f, -0.02997103f, 0.00952691f, 0.02397650f, 0.00728291f, -0.01979113f, 
    -0.03414455f, -0.01609105f, -0.00070300f, -0.02462123f, 0.02244810f, 0.02718391f, -0.03707970f, -0.02834575f, 
    0.02061068f, -0.03312210f, 0.01387634f, 0.01050812f, 0.02523609f, -0.01167236f, -0.01808307f, -0.01845389f, 
    -0.04015161f, 0.00310013f, -0.02370556f, 0.02537492f, 0.01557687f, -0.00661811f, 0.01201590f, 0.00986102f, 
    0.03190110f, 0.02626836f, 0.02158180f, 0.03267936f, 0.00199656f, -0.01568438f, -0.01141047f, -0.00074856f, 
    -0.01960935f, -0.01527583f, 0.01761144f, -0.00245571f, 0.01721250f, 0.00576783f, 0.02386388f, -0.03634889f, 
    -0.01636082f, 0.00508267f, 0.01200505f, -0.02174306f, 0.00660788f, -0.01247293f, -0.03673704f, -0.02360645f, 
    -0.01493694f, 0.01722320f, 0.02779040f, -0.00153911f, -0.00471106f, 0.02770502f, -0.02518349f, -0.04043426f, 
    0.00573370f, -0.01478361f, -0.01653793f, 0.01835097f, -0.00717185f, -0.02550522f, -0.02497784f, 0.00407886f, 
    -0.00899274f, 0.02723811f, -0.00534513f, 0.00772806f, -0.02339413f, 0.00074041f, -0.02569522f, -0.01609698f, 
    -0.01058653f, 0.00805167f, 0.02251798f, -0.00105751f, 0.02874909f, -0.00260209f, 0.01880250f, 0.01386857f, 
    0.02426406f, -0.02089145f, -0.00212005f, 0.01772048f, -0.02527232f, 0.01181080f, 0.03460345f, 0.00666495f, 
    -0.02203822f, 0.02855828f, -0.01998772f, -0.00985781f, -0.03034864f, -0.03358667f, -0.02883756f, -0.02739591f, 
    -0.03423636f, 0.01288673f, -0.03554220f, -0.01484964f, -0.02818414f, 0.01194055f, -0.03491307f, 0.02182630f, 
    -0.02491223f, 0.02366149f, -0.00603471f, -0.01966389f, -0.02642063f, -0.01541944f, -0.01249317f, 0.01264471f, 
    -0.01818466f, 0.03286785f, -0.00738186f, 0.03077301f, -0.03868138f, 0.02259287f, -0.02733940f, -0.01296109f, 
    -0.02059067f, 0.00154338f, -0.01899253f, 0.00496677f, 0.01101559f, 0.03319458f, 0.00790423f, -0.01832337f, 
    -0.03482040f, 0.00568387f, -0.04075137f, 0.01388622f, 0.03074418f, 0.01322738f, -0.00979861f, 0.00847057f, 
    0.02110106f, -0.01529011f, -0.00388489f, 0.00531803f, -0.02633221f, -0.03952281f, 0.02646393f, -0.02594829f, 
    0.01421791f, -0.02239596f, -0.01690321f, -0.00240661f, -0.03733763f, 0.01335415f, -0.03898715f, 0.02509008f, 
    -0.02181661f, 0.01486122f, 0.01878251f, 0.00341519f, 0.00571512f, 0.00385734f, -0.01568810f, -0.02615324f, 
    -0.03683351f, 0.01462525f, -0.00591764f, -0.01414669f, -0.02965139f, -0.03018899f, 0.00871515f, 0.02244767f, 
    -0.02492039f, 0.01474705f, 0.00667856f, -0.01292480f, 0.02254587f, -0.00927362f, -0.02484655f, -0.00800726f, 
    -0.02805868f, 0.01327614f, -0.03117693f, -0.04058660f, -0.01357464f, 0.01365298f, 0.01244944f, -0.01774362f, 
    0.00044987f, -0.01437298f, 0.02617237f, -0.01927724f, 0.02387486f, -0.02531428f, -0.02329396f, -0.02544745f, 
    -0.01567115f, -0.03620103f, -0.01648921f, 0.01512368f, -0.03664948f, 0.02708247f, 0.01679620f, 0.01599600f, 
    -0.00247046f, -0.00859983f, -0.00636394f, -0.00213225f, 0.03517645f, -0.03420874f, 0.03025957f, 0.02959978f, 
    0.03150823f, 0.01950994f, 0.01425357f, -0.02926858f, -0.03355514f, -0.02621773f, -0.01357014f, -0.00592649f, 
    -0.04213098f, 0.00143808f, -0.00695287f, 0.01397795f, 0.00043125f, -0.01848318f, -0.04022885f, 0.01673373f, 
    -0.03100947f, -0.02718725f, -0.02968581f, -0.03532726f, -0.01205167f, -0.00824044f, 0.03217590f, -0.01246564f, 
    -0.00720443f, 0.00172792f, -0.02368981f, -0.03239231f, -0.00792046f, 0.02214003f, -0.02414554f, -0.01164144f, 
    -0.01663397f, -0.01993073f, 0.01926389f, 0.00594976f, -0.03136577f, -0.03113652f, -0.04178723f, -0.03337115f, 
    -0.01411599f, 0.02532526f, 0.00263422f, -0.00940782f, -0.00096053f, -0.03068158f, -0.01608241f, 0.00232207f, 
    -0.01035251f, -0.01678256f, -0.00859798f, -0.03391984f, -0.01339703f, -0.02785278f, -0.01391684f, -0.02875745f, 
    -0.01948542f, 0.00136404f, -0.03680851f, 0.00441447f, -0.04267171f, -0.02101832f, -0.01215944f, -0.04167493f, 
    -0.02474069f, -0.02983468f, 0.03431966f, -0.01444721f, 0.01584005f, 0.03513978f, -0.03435539f, 0.01234091f, 
    -0.01792393f, 0.01762537f, 0.02224400f, -0.03236707f, -0.03508883f, -0.00585520f, 0.00825113f, 0.03014438f, 
    0.00568396f, 0.02670518f, 0.00449083f, -0.03841896f, -0.02977393f, 0.02818691f, -0.03298611f, -0.00292221f, 
    -0.03206784f, -0.00364450f, -0.03806138f, -0.03112476f, 0.00980932f, -0.03872740f, 0.00820665f, 0.01483888f, 
    -0.01758106f, 0.00194219f, 0.02319879f, -0.00548292f, -0.03330669f, 0.02601114f, -0.03024807f, -0.01430748f, 
    -0.03964997f, -0.00133532f, 0.01022398f, -0.02333829f, 0.01084333f, -0.03276316f, 0.01577229f, -0.02495151f, 
    -0.00294952f, -0.02030724f, 0.02296700f, 0.01552297f, -0.02918241f, 0.03298099f, -0.02228405f, -0.01209679f, 
    -0.01535910f, 0.03388716f, -0.00705063f, -0.03428201f, -0.04220058f, -0.03583180f, -0.04027352f, -0.04107242f, 
    -0.03529390f, -0.02028672f, 0.03578875f, -0.00994298f, -0.00640629f, -0.01560457f, -0.03110516f, -0.00082491f, 
    -0.02740921f, 0.01682751f, 0.02236775f, 0.01047162f, -0.02992285f, 0.01325699f, 0.01630185f, -0.01564104f, 
    -0.02917063f, 0.02759726f, -0.00670917f, -0.03485649f, 0.02034548f, 0.00595294f, 0.02323275f, -0.00480207f, 
    0.03523330f, 0.07580163f, 0.01372648f, 0.20768419f, 0.09161049f, -0.00356772f, 0.00202947f, 0.11695099f, 
    0.03131264f, 0.00108181f, -0.09351084f, -0.09912822f, -0.48247495f, 0.20280433f, 0.05657670f, -0.12706964f, 
    0.06302994f, 0.07426022f, -0.17597681f, 0.03876982f, -0.02791827f, 0.01335966f, -0.19848463f, 0.04848566f, 
    -0.19865972f, -0.11925524f, -0.05885909f, 0.05915688f, -0.16664167f, 0.09470814f, 0.05451384f, -0.09430693f, 
    0.04282828f, 0.08188097f, 0.01458909f, -0.02231208f, 0.17002146f, 0.00787269f, -0.04183171f, -0.06532216f, 
    -0.02528160f, -0.04151356f, 0.04159841f, -0.03902671f, 0.07517515f, 0.04442544f, 0.07140325f, 0.07583142f, 
    -0.37450349f, -0.14386477f, -0.21055673f, 0.02134438f, 0.02144517f, -0.01298498f, -0.05244801f, -0.08504620f, 
    0.03024071f, 0.21757071f, -0.04028939f, 0.00044086f, -0.16159558f, -0.06122514f, -0.05594114f, 0.06528862f, 
    -0.02351321f, 0.08741524f, -0.00759279f, -0.15935190f, 0.23999737f, -0.08789752f, -0.12194848f, 0.08531795f, 
    0.28522724f, 0.14666532f, -0.02914998f, 0.08405846f, 0.00987781f, -0.00561104f, 0.03164453f, 0.02891635f, 
    0.04082632f, 0.02711558f, 0.07341669f, 0.15055682f, -0.32486600f, -0.23532510f, -0.27843624f, -0.09586916f, 
    -0.10312182f, 0.00873069f, 0.02220274f, -0.05888037f, -0.01584962f, 0.04400519f, -0.04167715f, 0.14569615f, 
    0.00262161f, 0.14852639f, 0.18515940f, 0.13168031f, 0.08979069f, -0.07075489f, 0.09610710f, 0.10020538f, 
    0.00853137f, 0.09211084f, 0.08381769f, 0.06111559f, -0.09317955f, -0.14343642f, -0.07894279f, -0.10047932f, 
    -0.08276366f, 0.05074824f, -0.13650039f, 0.13324845f, 0.12795216f, -0.11795226f, 0.00433011f, -0.03128634f, 
    -0.24656309f, -0.14179453f, 0.04979365f, 0.03743576f, -0.18891469f, 0.06505824f, -0.07468311f, -0.13076715f, 
    0.09215551f, 0.07283070f, 0.03085320f, -0.03359658f, -0.05813116f, -0.05764271f, -0.09731404f, -0.21903937f, 
    0.03436968f, -0.05870942f, -0.05370843f, 0.06705197f, -0.02974482f, 0.00925435f, -0.11138170f, 0.09432811f, 
    0.25431052f, -0.00046158f, 0.13327892f, 0.12183075f, 0.12575038f, -0.03963614f, 0.05286764f, 0.17669980f, 
    -0.00578526f, -0.00824712f, -0.05648850f, -0.02291894f, 0.13832563f, 0.23730960f, 0.08029301f, 0.10807068f, 
    0.03476173f, -0.09463597f, 0.00292488f, 0.13776986f, -0.03008227f, 0.01059875f, -0.06198914f, -0.01787077f, 
    -0.16417769f, 0.26608482f, -0.10356046f, -0.19637084f, 0.01859886f, 0.05450138f, 0.03767252f, -0.18413857f, 
    -0.03573420f, -0.10410380f, 0.02679766f, 0.09672560f, -0.13462627f, 0.28229389f, 0.05097921f, -0.06888776f, 
    0.08421514f, -0.02919912f, -0.07074729f, 0.00144048f, 0.00517825f, 0.03254350f, -0.16491450f, -0.01065997f, 
    -0.11144950f, 0.09204328f, 0.12180410f, 0.15215650f, 0.05689317f, -0.00882410f, -0.01816463f, -0.04420289f, 
    0.01777803f, 0.01382889f, 0.18115084f, 0.07576476f, -0.11600123f, 0.08859894f, 0.14627028f, 0.18215382f, 
    0.05527874f, 0.07822695f, 0.02331284f, 0.06097437f, 0.12207059f, 0.04023960f, -0.03562458f, -0.06535250f, 
    0.14431512f, 0.20636705f, 0.03167447f, 0.03126145f, -0.07298478f, 0.11915317f, -0.10644462f, -0.07165676f, 
    -0.05015125f, 0.18997596f, -0.04628799f, -0.07876195f, 0.04337627f, -0.08286116f, -0.05517657f, -0.00009765f, 
    0.08130859f, -0.24542806f, 0.04320780f, -0.10739220f, -0.03581491f, 0.06509630f, 0.09837535f, 0.01968336f, 
    -0.01911256f, -0.06541070f, -0.04368043f, 0.07805818f, 0.00745007f, -0.04218975f, -0.12560788f, 0.01673399f, 
    0.11634619f, 0.10844851f, 0.04516658f, 0.03099516f, 0.01027361f, 0.12927265f, 0.16969319f, -0.02081800f, 
    -0.07733572f, 0.05855026f, -0.18776868f, 0.01759476f, -0.05599698f, -0.05127166f, -0.00600415f, -0.04320513f, 
    0.11747037f, -0.08697075f, -0.06838339f, -0.06087503f, 0.04006078f, -0.04490860f, -0.03873226f, -0.05250620f, 
    0.01096731f, 0.01348700f, -0.09211659f, 0.12068225f, 0.10922125f, 0.08701440f, 0.10556205f, 0.09248810f, 
    0.03212929f, 0.11587781f, 0.05418005f, 0.07335740f, 0.17015825f, 0.03350055f, 0.10280533f, 0.07051029f, 
    0.00167401f, 0.02129811f, -0.00416355f, 0.15975870f, -0.01133432f, 0.14169778f, 0.03329266f, 0.02814555f, 
    -0.01577077f, 0.06096228f, 0.02033619f, -0.04140747f, 0.07791749f, 0.20436104f, 0.13551787f, 0.22553454f, 
    0.00653988f, 0.05230543f, 0.00877302f, 0.09588987f, 0.09552474f, 0.10401779f, 0.06534162f, 0.17744280f, 
    -0.02515649f, 0.52168792f, 0.21749920f, -0.00595429f, 0.07887309f, 0.14221554f, -0.01306000f, -0.00281920f, 
    -0.01355123f, -0.00489841f, -0.03570825f, 0.11391859f, -0.30452523f, 0.10853019f, 0.01641782f, 0.20058344f, 
    -0.00371128f, 0.14458379f, -0.03437530f, 0.05187708f, 0.04105410f, -0.11725097f, 0.03268109f, -0.04359876f, 
    -0.35885724f, 0.01283383f, 0.02666474f, 0.17243011f, -0.01800656f, 0.11804129f, -0.18327798f, -0.05595997f, 
    -0.00888195f, -0.11192697f, -0.08148055f, 0.01368938f, 0.24940181f, -0.00505651f, 0.16291687f, 0.08692271f, 
    -0.06806181f, -0.00534026f, 0.06717752f, 0.04393724f, 0.10283829f, 0.07467430f, 0.14139417f, 0.07404120f, 
    -0.03961235f, -0.06511539f, -0.03793890f, 0.08824310f, 0.02385678f, -0.13884987f, 0.01764520f, -0.08004236f, 
    -0.06978419f, -0.10194185f, -0.06244538f, 0.16223931f, -0.16760701f, 0.35471267f, -0.17131458f, -0.02867179f, 
    0.05041766f, 0.16238731f, 0.11817902f, -0.14226072f, -0.07027394f, -0.02855441f, -0.03084057f, -0.03142808f, 
    0.09393732f, -0.05811490f, -0.00763945f, 0.23848602f, 0.14214380f, 0.10783163f, 0.13710934f, 0.09103182f, 
    0.08408989f, -0.04417026f, 0.02207185f, 0.14482863f, -0.06624707f, -0.06757841f, -0.04311689f, 0.12721372f, 
    0.04910699f, -0.00760368f, 0.03809799f, 0.04736340f, -0.00646813f, 0.02462758f, -0.09039704f, 0.00195687f, 
    -0.25807282f, -0.14540166f, -0.03476967f, -0.18758078f, 0.00989028f, -0.00335654f, -0.01274690f, -0.01694644f, 
    0.12263712f, 0.03461890f, 0.06548048f, 0.04373750f, -0.02078751f, -0.11710189f, -0.15178047f, -0.01621845f, 
    -0.01494024f, -0.06245514f, 0.03113159f, -0.10835493f, 0.00614940f, 0.05940947f, -0.05087845f, -0.04141333f, 
    -0.11254881f, 0.14786185f, -0.02449772f, 0.02878683f, 0.13126226f, 0.01504759f, 0.05372873f, 0.03307284f, 
    -0.11932023f, -0.04082461f, -0.01365169f, 0.01456314f, 0.01509561f, 0.01353338f, 0.09162050f, -0.03537637f, 
    0.01618803f, 0.01173907f, -0.06395941f, 0.14879805f, -0.01071555f, -0.10575851f, -0.05065073f, -0.01168316f, 
    -0.21487038f, -0.10187831f, 0.14092101f, 0.19738919f, -0.02240126f, 0.01745262f, -0.09634472f, -0.09353831f, 
    -0.04418770f, 0.01592136f, -0.01343494f, 0.00933144f, 0.17002036f, 0.06881040f, 0.13247789f, 0.16836974f, 
    0.08945143f, 0.08722054f, 0.00717130f, 0.00487524f, -0.01096647f, -0.16926101f, 0.04418353f, 0.03163167f, 
    -0.11456076f, -0.01719374f, -0.07024910f, 0.10023630f, -0.05466314f, 0.03844851f, 0.01284547f, 0.01499926f, 
    -0.08659904f, 0.04739610f, 0.08091372f, -0.05227689f, -0.02361148f, -0.03249939f, 0.01482613f, 0.14190558f, 
    0.08299647f, -0.01928480f, 0.05938815f, 0.06419497f, -0.05747100f, 0.01193182f, -0.13994499f, 0.10410626f, 
    0.12448940f, 0.16374415f, 0.10415468f, 0.40959635f, -0.05814193f, 0.11480057f, -0.10068610f, 0.02392307f, 
    -0.08739335f, 0.04681108f, -0.11251020f, 0.06552046f, -0.08358962f, 0.02220636f, -0.19618039f, 0.07010416f, 
    0.05737012f, 0.03181274f, 0.08942985f, 0.11884803f, -0.03600729f, -0.03557247f, -0.02850354f, -0.02243910f, 
    -0.04906651f, 0.07805640f, 0.10636858f, 0.08258294f, 0.12967250f, 0.06854237f, 0.01646387f, -0.03386912f, 
    0.00454307f, 0.12694484f, -0.05816106f, 0.03111431f, -0.13094749f, 0.14867932f, 0.10022539f, 0.15847334f, 
    0.00409071f, 0.09281293f, -0.03687957f, 0.16987248f, -0.04090509f, 0.00874571f, 0.05434164f, 0.04159423f, 
    0.01058104f, 0.00797957f, -0.04880792f, 0.10556406f, -0.02855374f, 0.02730444f, -0.02784779f, -0.05570874f, 
    0.06585348f, -0.01189525f, -0.12317582f, 0.11961576f, -0.36046329f, -0.19386455f, 0.11621417f, 0.27469411f, 
    -0.07931630f, 0.10224050f, -0.15078457f, 0.05769603f, -0.04779792f, -0.05715252f, 0.07039346f, 0.01096663f, 
    -0.07738289f, -0.07013889f, 0.04308481f, -0.00596363f, -0.01772990f, -0.04224992f, -0.03258706f, -0.04560203f, 
    -0.00747020f, 0.00177862f, 0.04241972f, -0.02782612f, 0.13221855f, -0.00497317f, -0.10395568f, 0.11776361f, 
    -0.14789751f, -0.04575252f, 0.04623383f, 0.01637491f, -0.07826916f, 0.00490922f, -0.16970958f, 0.00028045f, 
    0.19199379f, 0.03735400f, 0.09238242f, 0.01624147f, 0.06892373f, -0.01361885f, -0.02014002f, 0.08363579f, 
    -0.02747951f, 0.05906301f, 0.08217445f, -0.11623304f, 0.26698604f, 0.20192911f, 0.09484238f, 0.23088971f, 
    0.16455080f, 0.12546422f, 0.12339874f, 0.05223918f, 0.10282464f, 0.14585418f, -0.11430884f, 0.05246125f, 
    -0.12702698f, 0.05763892f, 0.17744955f, 0.02703768f, -0.08868184f, 0.10595136f, -0.05820836f, -0.03466827f, 
    -0.09836223f, -0.06103298f, -0.07932373f, 0.06967270f, -0.14087421f, 0.07430402f, 0.09900615f, 0.14346048f, 
    -0.00828576f, 0.08002117f, -0.06588352f, -0.09246284f, -0.13540041f, 0.07122675f, 0.03947492f, -0.08148804f, 
    -0.23191079f, 0.00435514f, 0.16388239f, 0.08089183f, -0.03929294f, -0.01319616f, 0.02148887f, 0.06550740f, 
    -0.08139103f, 0.01504026f, -0.03137874f, 0.09906238f, 0.04698424f, -0.09439432f, -0.00632982f, 0.24931102f, 
    0.00634915f, -0.00142909f, 0.03650894f, -0.04353444f, -0.01997041f, 0.06195368f, 0.00555903f, 0.13632147f, 
    0.11668488f, -0.05428668f, 0.00430960f, -0.03461760f, 0.02276816f, -0.01159167f, -0.05362465f, 0.07329030f, 
    -0.03258057f, -0.00925014f, 0.00041045f, -0.03890850f, -0.02423758f, -0.22332200f, 0.12222523f, 0.17305221f, 
    -0.12302174f, 0.08547160f, 0.03951595f, 0.11434313f, -0.08175833f, -0.01503390f, 0.01000072f, -0.06692391f, 
    -0.02446931f, 0.01505118f, -0.20484716f, 0.04427636f, 0.01301611f, 0.10116750f, -0.12617695f, 0.01042334f, 
    -0.03609608f, -0.10409867f, 0.13519533f, 0.04432445f, -0.14758424f, -0.08559103f, -0.24607405f, -0.10880496f, 
    0.02576102f, -0.06322301f, 0.01656169f, 0.05129050f, 0.02064602f, 0.07365461f, 0.02106643f, 0.02725712f, 
    0.04052284f, -0.06450760f, -0.06311359f, 0.21354282f, -0.01805693f, 0.19886078f, -0.01313706f, 0.03676859f, 
    -0.01621475f, -0.03904100f, -0.05019389f, -0.05974851f, -0.03051250f, 0.15231682f, 0.10290097f, 0.02435739f, 
    0.00242985f, 0.05015137f, 0.04204243f, 0.02853312f, -0.00883356f, 0.08775989f, -0.03408832f, -0.05928893f, 
    0.09327052f, -0.03303582f, -0.04431009f, 0.12473942f, 0.13697664f, -0.08846943f, -0.01466995f, 0.09165654f, 
    -0.07163308f, 0.03852979f, -0.07178452f, -0.03556614f, -0.14708278f, -0.02470419f, -0.09175935f, -0.11654031f, 
    -0.02676148f, -0.04154664f, -0.09811740f, -0.03826080f, -0.01999675f, -0.15941523f, 0.00482798f, 0.06393119f, 
    0.17647071f, 0.20113750f, -0.08906425f, 0.15129147f, 0.07566864f, -0.04930837f, -0.02951782f, 0.00712543f, 
    -0.02587879f, -0.00611930f, -0.01485405f, -0.04062803f, -0.25050345f, -0.14663681f, -0.00088286f, -0.08667725f, 
    0.05856861f, 0.14245233f, -0.12257618f, 0.16558716f, -0.07905998f, -0.04571456f, -0.19639610f, -0.01118994f, 
    0.04490165f, -0.06205342f, -0.00231918f, 0.06558153f, -0.01675727f, 0.02724202f, 0.04971713f, -0.03861181f, 
    0.04129025f, 0.02085179f, -0.05669495f, 0.01648317f, 0.12064303f, 0.06512471f, 0.03463993f, -0.02331659f, 
    -0.05371439f, 0.05408831f, 0.06828813f, -0.04395014f, 0.20198655f, 0.03930856f, 0.17644139f, 0.03125475f, 
    -0.06827497f, -0.20204106f, 0.11320952f, 0.29348892f, 0.09753793f, 0.06344333f, -0.01930401f, 0.01458397f, 
    0.00293051f, 0.13435353f, 0.01841569f, 0.04460663f, -0.06931122f, -0.10831501f, 0.30646423f, -0.00180756f, 
    -0.02956895f, 0.12213391f, -0.02288354f, -0.23547561f, -0.00253130f, -0.11308659f, -0.06353656f, 0.11244859f, 
    0.20029336f, 0.09512889f, -0.04265838f, 0.03204117f, -0.02165922f, 0.03937200f, -0.07412276f, 0.01914769f, 
    0.00938161f, -0.13004749f, 0.14200076f, 0.09388828f, 0.13512920f, 0.06884217f, -0.18658924f, 0.00891041f, 
    0.02282413f, -0.01823328f, 0.00031647f, 0.00376163f, 0.05611877f, 0.05364229f, 0.04154374f, -0.00124978f, 
    -0.09602809f, 0.14688405f, 0.00371265f, 0.17331688f, -0.04831118f, -0.07458999f, 0.04391430f, -0.02042214f, 
    -0.02799420f, 0.02415937f, -0.00466370f, -0.05115712f, 0.11763208f, -0.03299414f, -0.05110997f, -0.01198880f, 
    0.03939765f, -0.02244426f, 0.00814144f, 0.01341040f, -0.01768385f, -0.14601281f, -0.03717474f, 0.02314709f, 
    0.24686104f, -0.04199985f, -0.11545818f, 0.00406706f, -0.01329417f, 0.01982443f, -0.11175698f, -0.07834978f, 
    0.05720293f, 0.06114538f, -0.02991426f, 0.00922470f, 0.01696717f, 0.10574695f, 0.07839974f, -0.07504679f, 
    0.04231975f, -0.06039910f, 0.02379916f, -0.02219748f, 0.01473611f, 0.12941878f, -0.09971856f, 0.08460149f, 
    0.00393503f, -0.11776078f, -0.05044978f, -0.15474495f, 0.04001347f, -0.05171740f, -0.14733075f, 0.07539634f, 
    0.09251660f, -0.02206964f, -0.05425756f, 0.03055497f, 0.05833185f, 0.04812227f, 0.15768529f, 0.03768780f, 
    0.02721155f, -0.10972462f, -0.06724843f, -0.03675525f, -0.01655333f, -0.03924060f, -0.26643601f, 0.11781687f, 
    -0.06473100f, 0.05247527f, -0.02147974f, 0.01532075f, 0.00505394f, -0.00589950f, 0.03277996f, -0.18372501f, 
    0.03783737f, -0.02107113f, 0.16778570f, -0.04090281f, -0.21960169f, -0.12927699f, 0.10808113f, 0.02429814f, 
    -0.03861375f, -0.03744370f, -0.10621225f, 0.06186755f, -0.08849172f, 0.07248699f, -0.18714593f, 0.02200348f, 
    -0.03740631f, -0.01233348f, 0.09141750f, 0.04533247f, 0.00002198f, -0.04401598f, -0.11010191f, 0.01908376f, 
    0.08317471f, 0.01060199f, 0.16798170f, 0.02881903f, 0.06948248f, 0.11355416f, 0.08551968f, 0.11768011f, 
    -0.06975393f, -0.03749382f, -0.07689796f, 0.02800946f, 0.01954864f, 0.14133635f, 0.02421763f, -0.03274656f, 
    0.03259208f, -0.38797754f, 0.05970896f, 0.45093724f, -0.02000971f, -0.12182336f, 0.11656337f, -0.08851995f, 
    -0.04050672f, 0.11168775f, -0.08626675f, 0.02882817f, -0.21521641f, 0.16793208f, -0.12715116f, 0.21420661f, 
    -0.04346085f, -0.07819968f, 0.10099306f, -0.14921050f, 0.02085054f, 0.01682204f, 0.14958914f, 0.11622214f, 
    0.04005329f, -0.14168581f, 0.02149541f, 0.12830532f, 0.04384441f, -0.01538287f, 0.00174346f, -0.01020099f, 
    0.00781572f, -0.02377609f, -0.05449778f, 0.07656757f, 0.00257298f, -0.35061356f, 0.39932314f, -0.15829015f, 
    -0.23118646f, 0.00470557f, -0.03997794f, -0.02793380f, -0.19570920f, -0.03794292f, 0.14954802f, 0.00741022f, 
    -0.03299596f, 0.05860503f, 0.03881334f, -0.07464639f, 0.05645233f, 0.04169692f, 0.04692225f, -0.01181207f, 
    0.17853127f, 0.15765953f, -0.03341264f, 0.09072161f, -0.02638381f, 0.13841556f, 0.18934581f, -0.07022475f, 
    -0.07472952f, -0.02911975f, -0.01528651f, 0.10748643f, 0.14428835f, 0.02134887f, 0.11097593f, -0.00942117f, 
    0.03871841f, 0.13344230f, 0.11357062f, 0.17948608f, -0.14498152f, -0.05398104f, -0.02095944f, -0.01339387f, 
    0.07416261f, 0.20375332f, 0.01274866f, 0.04737717f, 0.02555265f, -0.15382838f, 0.07074034f, 0.07183390f, 
    0.00538400f, -0.03086625f, -0.16790441f, 0.18146768f, 0.04542820f, 0.01313888f, -0.00456955f, 0.18688430f, 
    -0.07559919f, 0.02496728f, 0.34101737f, 0.04121416f, 0.01901148f, 0.14032225f, 0.11869273f, -0.15001905f, 
    0.00892134f, 0.08247508f, -0.08556469f, 0.17934552f, 0.04400484f, 0.15101892f, 0.04507818f, 0.08552977f, 
    -0.09123329f, 0.19056275f, 0.01783623f, -0.02790719f, 0.09313772f, 0.02707410f, 0.07423094f, -0.14475191f, 
    -0.17873196f, 0.07907437f, -0.13734302f, 0.16922300f, -0.03196699f, 0.02208083f, 0.03486954f, 0.06362565f, 
    -0.04829089f, -0.09260172f, -0.05280505f, -0.09975129f, 0.02081189f, 0.05323161f, -0.00346302f, -0.13430868f, 
    -0.05240529f, -0.20375444f, 0.11459135f, 0.05340434f, 0.06983484f, 0.04266765f, 0.01215977f, -0.07399063f, 
    -0.17544508f, 0.07803352f, -0.01336636f, -0.03075810f, 0.07495165f, -0.08812428f, 0.14914282f, -0.07399364f, 
    -0.04989857f, -0.09626585f, 0.15302396f, 0.02764950f, -0.03462941f, 0.13937040f, -0.19859695f, 0.25503385f, 
    -0.04218855f, 0.03884673f, 0.13749275f, -0.20023917f, -0.06059502f, 0.15201908f, -0.07392533f, -0.02991932f, 
    0.13245428f, 0.25037754f, 0.09059698f, -0.05549335f, -0.00012496f, 0.02164344f, 0.15968412f, 0.20260473f, 
    0.11814366f, 0.02543015f, 0.06770457f, -0.01887138f, -0.11915461f, -0.03234716f, -0.14548896f, -0.09137762f, 
    -0.03130870f, -0.07100548f, -0.01334525f, 0.08551179f, -0.00575196f, 0.07920094f, -0.02906868f, 0.00480816f, 
    0.03173516f, 0.01500193f, -0.01024247f, -0.04511313f, 0.00361463f, -0.01579565f, -0.04276931f, 0.02467560f, 
    0.01630023f, -0.11081968f, 0.13657182f, 0.02771885f, -0.09943106f, -0.14989015f, 0.02205247f, 0.16236819f, 
    0.00402230f, -0.00351089f, 0.03585898f, -0.03747538f, 0.00975541f, 0.01781238f, -0.07832055f, 0.02815691f, 
    -0.24859899f, 0.01655060f, -0.22854379f, 0.13193305f, -0.03770813f, 0.01642591f, 0.01009758f, -0.05479247f, 
    -0.02251058f, -0.02177710f, 0.02886604f, -0.01299184f, -0.15522347f, -0.11052686f, 0.30365917f, -0.14473435f, 
    -0.08226933f, 0.05216309f, -0.17195116f, 0.16841520f, -0.07196878f, -0.16302752f, 0.05072538f, 0.00114650f, 
    -0.04658547f, -0.18759476f, 0.13671337f, 0.00906072f, 0.11317424f, -0.15072353f, 0.19050999f, -0.09303626f, 
    -0.01108261f, 0.07562112f, -0.05981824f, 0.02884890f, 0.06089155f, 0.04292201f, 0.25582361f, 0.01056425f, 
    -0.07103665f, -0.03700235f, 0.10967997f, -0.05546295f, 0.04875115f, -0.09929629f, 0.09696207f, -0.06192305f, 
    0.09107299f, 0.12694408f, -0.06880924f, 0.02726397f, -0.04555172f, 0.02740861f, -0.04427629f, 0.14707366f, 
    -0.00124764f, -0.07278291f, -0.04632896f, 0.07716267f, -0.09184574f, 0.01000343f, -0.06790016f, -0.02083934f, 
    0.00514159f, -0.08213719f, 0.02217682f, 0.00785259f, 0.06119725f, -0.04496427f, 0.01510169f, 0.01678993f, 
    0.05895228f, 0.29515919f, 0.08766561f, 0.40476337f, -0.04379486f, 0.08283032f, -0.08482408f, -0.00615171f, 
    -0.06622488f, 0.10406390f, -0.06657426f, 0.01621953f, -0.03900585f, 0.11072377f, -0.21732143f, -0.07715783f, 
    -0.07481940f, -0.11098516f, 0.05613608f, 0.05465551f, -0.02124870f, 0.10720249f, -0.06511495f, 0.04988517f, 
    0.04923300f, 0.10711067f, 0.32738587f, -0.07265821f, 0.01319502f, -0.06769921f, -0.02065505f, 0.00400637f, 
    0.00170731f, 0.14242071f, -0.00582111f, -0.02500083f, 0.05479092f, 0.14219496f, 0.24360317f, 0.01697559f, 
    0.00456943f, 0.13563156f, -0.06611884f, 0.26517364f, -0.03551264f, 0.06173341f, 0.05674725f, -0.03842784f, 
    0.17426182f, -0.01474541f, 0.14060239f, -0.00202974f, -0.03695443f, -0.17381695f, 0.03847445f, -0.05291719f, 
    0.15669665f, -0.02492536f, 0.06722939f, 0.03872756f, -0.08067513f, -0.22296047f, 0.07671116f, 0.24280788f, 
    0.04822604f, -0.07827503f, -0.10488553f, 0.09453586f, -0.00152117f, 0.01776738f, 0.08427650f, 0.00756706f, 
    0.03900191f, 0.00611755f, -0.04047960f, 0.10287946f, 0.06796233f, -0.00149191f, 0.00965020f, -0.04615587f, 
    0.09110408f, -0.05264644f, 0.07059612f, -0.03936547f, -0.18814224f, -0.14603291f, 0.06179414f, -0.08238846f, 
    -0.06103678f, -0.19095446f, 0.09095686f, -0.01817198f, -0.05022909f, -0.07683286f, -0.28896552f, 0.02654974f, 
    -0.14286388f, 0.22293924f, -0.09013538f, -0.00635460f, -0.07109398f, -0.02994475f, 0.01143986f, -0.03358309f, 
    0.06158917f, 0.04987177f, 0.05802161f, -0.11877403f, 0.18121344f, 0.22917455f, 0.29743993f, 0.29047558f, 
    -0.00967373f, 0.03040825f, 0.04137625f, -0.11690026f, 0.14189212f, 0.11150908f, -0.01747249f, 0.01599000f, 
    0.02146049f, -0.10998721f, 0.33264253f, -0.07216964f, 0.04297940f, 0.11559591f, -0.20262569f, 0.09126597f, 
    -0.02795643f, -0.09709013f, 0.05572820f, 0.07805242f, -0.18009908f, -0.18245120f, 0.16831557f, 0.27080345f, 
    -0.04522830f, 0.12192012f, -0.04713903f, -0.03733132f, -0.05759133f, 0.00357874f, 0.00412205f, -0.08843010f, 
    -0.04110442f, 0.03826560f, 0.21956815f, 0.09494341f, 0.02483539f, -0.09877432f, 0.07962048f, 0.15480034f, 
    -0.08918510f, -0.09460633f, 0.14306346f, 0.14518112f, -0.07416819f, -0.06301292f, 0.07839119f, 0.08860091f, 
    -0.05341138f, -0.05343727f, -0.04576927f, 0.20084774f, 0.05862717f, 0.02317011f, -0.00110042f, 0.01801376f, 
    -0.06183158f, -0.05652801f, -0.01548880f, 0.00475908f, 0.07793076f, -0.00232833f, -0.09491336f, 0.11304381f, 
    0.02085869f, -0.02436152f, 0.04663618f, 0.09244006f, 0.10080484f, -0.11231467f, 0.29535052f, 0.10599373f, 
    -0.04158352f, 0.04459515f, 0.01076339f, -0.07596301f, 0.03986831f, -0.08064134f, 0.25515789f, -0.06025364f, 
    0.12321870f, -0.25011420f, -0.22674906f, 0.35547259f, 0.08511101f, 0.00562207f, 0.00481789f, -0.04532887f, 
    -0.03906145f, -0.06021660f, -0.10515662f, -0.04162005f, -0.03098883f, 0.08062439f, 0.05032441f, -0.05230045f, 
    0.10958260f, 0.03855853f, 0.01317773f, -0.02558972f, 0.18285003f, 0.19899255f, 0.11873070f, 0.03561656f, 
    0.03933721f, 0.12496758f, -0.16293858f, 0.14243013f, 0.15142962f, 0.13997020f, 0.05385940f, -0.07572100f, 
    0.08865131f, 0.06179669f, 0.04282161f, -0.06351621f, -0.12454953f, 0.11229614f, 0.04188363f, -0.00143989f, 
    -0.02564390f, -0.10766783f, 0.12334719f, -0.13285375f, 0.06396602f, 0.07821924f, 0.08083920f, -0.00728927f, 
    0.05009362f, -0.05769908f, 0.00495534f, 0.08047453f, 0.01616726f, -0.02275165f, -0.10901228f, 0.03787935f, 
    -0.01070773f, 0.01452148f, -0.02096802f, -0.04215056f, 0.00475298f, -0.09025104f, -0.00105171f, -0.00756855f, 
    -0.00429589f, -0.04803910f, 0.01890345f, 0.05934030f, -0.00771503f, -0.07114010f, -0.00970809f, 0.05796992f, 
    0.00512299f, -0.04690194f, 0.12176499f, -0.12020661f, -0.07243908f, -0.04654824f, -0.01625008f, 0.00667478f, 
    0.07573353f, 0.03507212f, -0.00870474f, 0.04662393f, 0.41380426f, 0.17366476f, 0.27445897f, 0.07707606f, 
    -0.12857205f, 0.03749957f, -0.14599995f, 0.14382640f, 0.02601836f, -0.00661856f, 0.08340981f, -0.05960836f, 
    0.05135786f, -0.01649158f, 0.14624907f, -0.08928019f, 0.06270660f, 0.02034776f, 0.02672110f, 0.12826478f, 
    -0.00439155f, 0.01629546f, 0.14912209f, 0.13694887f, -0.21964754f, -0.11511859f, -0.11943665f, -0.16188234f, 
    0.03256784f, -0.04174784f, -0.06663302f, -0.10529127f, -0.04421870f, 0.09979570f, 0.02990171f, 0.08499529f, 
    -0.11528329f, 0.22301172f, 0.28992566f, -0.01876613f, -0.09251606f, -0.09358330f, -0.12792844f, -0.03815055f, 
    -0.02336408f, -0.05617558f, 0.08786392f, -0.07006790f, 0.08966180f, -0.20544319f, -0.02212184f, -0.28549618f, 
    -0.23703970f, -0.10207430f, -0.16688287f, 0.12765636f, -0.23425235f, 0.04757433f, -0.08704194f, -0.21452735f, 
    -0.07956861f, 0.00867722f, 0.05352124f, -0.10492794f, -0.14055535f, 0.04995141f, 0.05316952f, 0.10102430f, 
    0.12730809f, 0.09442804f, 0.12934577f, 0.09186777f, -0.03228945f, 0.18231398f, 0.06211274f, -0.14390478f, 
    -0.10033694f, -0.14436105f, -0.12979978f, -0.13653488f, -0.05078068f, 0.11579179f, -0.01259413f, 0.06526046f, 
    0.07916019f, -0.13593975f, 0.16154669f, 0.05559525f, 0.04446394f, 0.04961645f, -0.00078762f, 0.10401963f, 
    -0.15954721f, -0.01793805f, 0.05195080f, -0.02362885f, -0.04043487f, 0.20199910f, 0.08202814f, 0.04977140f, 
    0.02166442f, -0.00238516f, -0.08413856f, 0.00027697f, -0.03562331f, -0.01876991f, 0.02149983f, -0.03938331f, 
    -0.05409483f, -0.05084341f, -0.04209747f, -0.00455126f, -0.01501046f, -0.07061858f, -0.24494541f, -0.06500649f, 
    -0.21569549f, -0.07257887f, -0.09261192f, -0.13786128f, -0.19271052f, -0.01310878f, -0.02775095f, 0.01740570f, 
    -0.10056714f, 0.00592221f, -0.05254764f, 0.04019700f, 0.11370111f, 0.08380122f, 0.15690391f, 0.08287410f, 
    0.04685490f, 0.09737008f, 0.02366645f, 0.07707761f, -0.08406816f, 0.00561143f, -0.08910581f, 0.04762106f, 
    0.13577822f, -0.00019752f, -0.03102033f, -0.09607954f, 0.17143355f, 0.04308860f, 0.17374615f, 0.02574047f, 
    0.02087191f, 0.07005511f, 0.11209548f, 0.20349483f, 0.03561175f, 0.09337781f, 0.12889533f, -0.12383848f, 
    0.02473358f, -0.07613752f, -0.30722740f, 0.13151796f, 0.03202949f, -0.08338040f, 0.13285831f, 0.05721311f, 
    -0.09236371f, 0.10796636f, 0.02295805f, 0.12712669f, 0.03396237f, 0.27194101f, -0.05158472f, -0.03385853f, 
    -0.02359151f, 0.06520604f, 0.06854658f, 0.21397084f, -0.10090768f, 0.09541366f, 0.08492694f, 0.01991846f, 
    0.12760727f, -0.02505064f, 0.20395961f, 0.08751105f, -0.07485490f, 0.07252510f, 0.00416596f, 0.03940603f, 
    0.03404982f, 0.07826621f, 0.13477868f, 0.12941754f, -0.02605859f, -0.01642334f, 0.00950153f, -0.12727700f, 
    -0.13207336f, -0.09196780f, -0.18446895f, -0.08822807f, -0.12365308f, -0.11803489f, -0.04022131f, -0.13742462f, 
    0.02424830f, 0.11711235f, -0.05848940f, -0.09164934f, 0.08800666f, -0.00737663f, 0.06197616f, 0.19905947f, 
    -0.13954347f, -0.05312105f, 0.05856159f, -0.14694546f, -0.01015367f, 0.12483943f, 0.17508128f, -0.06712659f, 
    -0.05789337f, -0.08781850f, 0.11110593f, 0.09592283f, 0.04781201f, -0.04766957f, -0.08079022f, -0.14443144f, 
    -0.08524224f, -0.01361971f, -0.10050368f, -0.14654955f, 0.03490653f, -0.04880134f, -0.06249957f, -0.05388729f, 
    0.13522980f, 0.16551015f, 0.08697177f, 0.10724476f, -0.17058393f, -0.00863934f, -0.12383369f, 0.19324538f, 
    -0.12761861f, -0.00157044f, -0.00800166f, 0.00032254f, 0.14572221f, -0.02521841f, 0.13462296f, -0.03497822f, 
    -0.00597628f, 0.10493540f, -0.07219104f, -0.11971682f, -0.11386617f, -0.15636145f, -0.12225540f, 0.00419809f, 
    -0.04279096f, 0.10017449f, -0.04157056f, 0.15233558f, -0.12181417f, -0.00921303f, 0.07046717f, 0.21694499f, 
    -0.06731198f, -0.04458883f, 0.08463242f, 0.07892067f, -0.04900307f, 0.06726473f, -0.01880817f, 0.07196261f, 
    -0.16818114f, -0.00198523f, 0.04269678f, 0.03179816f, -0.15230820f, 0.06879979f, -0.10268971f, -0.05760172f, 
    0.05984566f, -0.03376354f, 0.08371621f, 0.10548817f, 0.11397032f, 0.26852432f, 0.23926756f, -0.06334008f, 
    -0.08544759f, 0.01207775f, 0.02280877f, -0.04432026f, -0.00424498f, -0.02636005f, 0.05863786f, 0.05251855f, 
    0.05010312f, -0.06696689f, -0.17622371f, 0.05937488f, -0.13550469f, -0.07333548f, 0.10321908f, 0.07835331f, 
    0.01651464f, 0.00659635f, 0.01373470f, 0.01437185f, 0.09983756f, 0.09582831f, 0.24248828f, 0.04621273f, 
    0.08338577f, 0.06742625f, -0.08359901f, 0.06469411f, -0.11840600f, -0.07122968f, 0.07725260f, -0.00598863f, 
    -0.14325708f, 0.16634043f, 0.04576004f, -0.00907365f, -0.10864609f, 0.00501383f, 0.00007692f, 0.06180584f, 
    0.02961433f, -0.10878565f, 0.16188721f, -0.12847853f, -0.20526472f, -0.06849749f, 0.00543797f, 0.05087279f, 
    0.00186015f, 0.05363907f, -0.00404953f, 0.03902562f, -0.11482636f, 0.03773352f, 0.00776704f, -0.06513157f, 
    -0.06129772f, 0.00989913f, -0.14084435f, -0.15705027f, 0.00185031f, -0.02349575f, 0.01071396f, 0.05867177f, 
    -0.09250036f, 0.02445614f, -0.04069740f, -0.05794369f, -0.15395547f, 0.17529041f, -0.17072007f, 0.40760052f, 
    0.16720285f, -0.04968381f, 0.08362382f, 0.17063971f, -0.04182715f, -0.05344234f, 0.04163993f, 0.17968322f, 
    -0.32967028f, -0.23912241f, 0.11902106f, 0.15740888f, -0.07389452f, -0.04223413f, -0.06118415f, 0.01607364f, 
    -0.12787862f, -0.11061891f, 0.07344989f, -0.02513298f, 0.07464722f, 0.05197916f, 0.14101759f, 0.10929342f, 
    -0.11941781f, -0.09267387f, -0.06199478f, -0.02820454f, -0.00754131f, -0.05221306f, -0.06587658f, -0.31861317f, 
    -0.02671197f, 0.02363240f, 0.00677454f, -0.03583803f, -0.05210626f, -0.04502591f, -0.18896033f, -0.16611984f, 
    -0.07949165f, -0.14920287f, -0.20664071f, -0.23115914f, 0.01950125f, 0.20046443f, -0.02787249f, -0.00393934f, 
    -0.10549620f, -0.12035728f, -0.04769426f, -0.05425728f, 0.01427626f, -0.00222036f, 0.02076656f, -0.11279280f, 
    -0.10335288f, -0.02484496f, 0.09304424f, 0.05375041f, -0.01660462f, -0.00138025f, 0.00875051f, 0.12317257f, 
    0.03238821f, -0.04147513f, 0.03745663f, -0.02241972f, 0.21596971f, -0.12659524f, 0.24404936f, 0.18431462f, 
    0.08676365f, 0.09094120f, 0.07835932f, 0.09618511f, 0.09787326f, 0.02787820f, 0.14393830f, 0.05825300f, 
    0.15884273f, 0.17313758f, -0.23018409f, 0.02952041f, 0.08116791f, -0.12368657f, -0.12528387f, -0.07134299f, 
    0.01734833f, 0.10795856f, 0.03042700f, 0.04103230f, -0.13701199f, -0.18145449f, 0.00323964f, 0.01085851f, 
    0.08758029f, 0.05586785f, -0.02818464f, 0.05051865f, 0.04419285f, -0.07376952f, -0.03332748f, -0.05416060f, 
    0.06082800f, -0.15370004f, -0.00075416f, 0.02352382f, 0.21610215f, 0.00876691f, 0.05472056f, 0.01203310f, 
    0.25575089f, 0.00985043f, 0.03458280f, 0.11773615f, -0.08251669f, 0.01090585f, -0.03075037f, -0.07280787f, 
    -0.04614793f, -0.07820417f, 0.06799123f, 0.08306034f, -0.06159883f, -0.07745026f, -0.09378561f, -0.25300619f, 
    -0.08387659f, -0.11344261f, 0.02036429f, 0.02859269f, -0.07226843f, -0.06923509f, 0.14432894f, 0.01726274f, 
    -0.05861529f, -0.02620452f, 0.06552219f, 0.17530899f, -0.05605976f, 0.08523329f, 0.19388379f, 0.23795891f, 
    0.06884541f, 0.02350006f, 0.02792572f, 0.06510192f, 0.03332983f, 0.05758230f, -0.02240337f, -0.10503254f, 
    -0.02942626f, -0.17217354f, -0.05257325f, 0.18575968f, 0.09112791f, 0.09435789f, 0.01818345f, 0.12633143f, 
    -0.01768481f, -0.03456974f, 0.01491380f, 0.02444798f, -0.02810179f, -0.06797372f, -0.02275616f, 0.13157560f, 
    -0.23934889f, -0.03289821f, -0.03104096f, -0.05548219f, 0.02253416f, -0.05248576f, 0.10619506f, -0.00858281f, 
    -0.15639730f, 0.17676249f, -0.01809613f, -0.06161566f, 0.01008171f, -0.04757551f, -0.02140796f, 0.04738213f, 
    -0.20071055f, -0.15645345f, -0.26310870f, -0.19641435f, 0.03983823f, 0.31477246f, 0.19645390f, 0.06567760f, 
    0.03785150f, -0.07511851f, -0.09747680f, -0.07725609f, -0.06469097f, 0.05899999f, 0.08590615f, 0.14567786f, 
    0.12043152f, 0.06485350f, 0.00049213f, 0.18124071f, 0.02168334f, -0.01366262f, -0.01612462f, -0.11356180f, 
    0.09630752f, 0.10681789f, -0.00680762f, 0.11724433f, -0.03409895f, 0.05724800f, -0.08552701f, 0.11576203f, 
    0.07381094f, -0.12732789f, 0.08454866f, 0.08470295f, 0.03015179f, 0.25051901f, -0.07277054f, -0.19523238f, 
    0.03200290f, -0.09958249f, -0.00954286f, 0.14621557f, -0.00239353f, 0.06506377f, -0.05559058f, 0.06469672f, 
    -0.04405069f, 0.01128228f, 0.12648158f, -0.08410058f, -0.11782556f, -0.30131698f, -0.02646520f, 0.12600784f, 
    -0.06521251f, 0.02619131f, 0.14346658f, 0.08807930f, -0.15834431f, 0.01250632f, 0.08608602f, 0.13573518f, 
    0.13573992f, -0.09834110f, -0.06906262f, 0.13806626f, -0.06812036f, 0.15079470f, 0.01572709f, 0.07959641f, 
    0.10168174f, 0.11354474f, 0.10946751f, 0.09475514f, -0.07867143f, 0.02195447f, 0.10651970f, 0.20682393f, 
    0.04138436f, 0.05155109f, -0.00955832f, 0.01757324f, 0.06390055f, -0.03242044f, 0.11077626f, 0.01066725f, 
    -0.05426602f, 0.25094414f, 0.05364362f, 0.23847225f, 0.11717544f, 0.11608155f, 0.16706452f, -0.01603793f, 
    0.09173325f, 0.14556704f, 0.10486656f, 0.17384028f, 0.00636811f, 0.09601478f, 0.05464703f, 0.14242400f, 
    -0.05507850f, 0.16630118f, 0.15807830f, -0.20493497f, 0.07681941f, 0.00376497f, -0.09276485f, 0.07227349f, 
    -0.03328569f, -0.22125410f, -0.07583341f, -0.09818985f, 0.00776638f, 0.01593993f, -0.14222533f, -0.09997430f, 
    0.23624238f, 0.01800880f, 0.12396833f, 0.12443180f, -0.19618313f, 0.01036445f, -0.01614687f, 0.07958233f, 
    0.02010295f, -0.11027425f, -0.04040983f, 0.14914925f, 0.07595369f, 0.00930009f, -0.11650463f, 0.09511016f, 
    -0.23981450f, 0.09779130f, -0.20912635f, 0.17221835f, -0.08604062f, -0.03157512f, -0.03511769f, -0.09367787f, 
    0.12931126f, -0.05467996f, 0.16989699f, -0.01486697f, -0.15681925f, -0.09634899f, -0.07591091f, -0.09804087f, 
    -0.22014895f, -0.11474710f, -0.08927955f, -0.04853621f, 0.01549098f, -0.01482890f, 0.01398854f, 0.04619014f, 
    -0.09671997f, -0.06994167f, 0.10421827f, -0.16214347f, 0.05182253f, -0.16388488f, -0.02223920f, -0.04074022f, 
    -0.07621568f, 0.14838354f, 0.01244199f, 0.14385100f, 0.01502089f, -0.12411960f, 0.08738805f, 0.06707965f, 
    -0.03456183f, 0.01775979f, 0.02272000f, 0.12778156f, -0.02503905f, 0.06971330f, 0.02935528f, 0.11732437f, 
    -0.06970699f, -0.03598775f, 0.10425496f, 0.09893325f, -0.01990389f, 0.08165583f, 0.03485864f, -0.01055196f, 
    0.01745221f, -0.01881662f, -0.05198826f, -0.06735882f, 0.21192145f, 0.03862606f, 0.08485874f, 0.00608232f, 
    -0.07803193f, 0.04259114f, -0.04701829f, -0.05885023f, 0.10534871f, -0.03807867f, -0.14048241f, -0.06769624f, 
    0.18171234f, 0.19906871f, -0.44045091f, -0.14200325f, 0.00169547f, -0.06135340f, 0.10177521f, 0.21097139f, 
    -0.02527814f, 0.03653727f, -0.05544333f, -0.09611037f, 0.41402391f, -0.09151706f, 0.22444853f, 0.00099249f, 
    0.00871951f, 0.02856463f, 0.08411849f, 0.05685404f, 0.07078465f, 0.08572833f, -0.10626495f, -0.01666593f, 
    -0.05736650f, 0.13833074f, 0.01429313f, -0.00179314f, 0.02484787f, 0.10202084f, 0.00178201f, -0.05927601f, 
    -0.03346577f, 0.03787862f, 0.01565559f, -0.07601760f, 0.08930700f, 0.10316575f, 0.01830851f, -0.01164753f, 
    0.02990031f, -0.05574369f, -0.04267247f, 0.01010515f, -0.07553554f, -0.00081367f, -0.14003465f, -0.03143754f, 
    0.37274963f, 0.12255601f, -0.05605911f, 0.16567415f, -0.01822170f, 0.05940646f, -0.01354058f, 0.02053611f, 
    0.04987329f, 0.07908727f, -0.07613443f, 0.05463459f, 0.08030759f, 0.19406833f, -0.05883482f, 0.06689859f, 
    -0.03230176f, -0.05703688f, -0.15238695f, 0.26456299f, 0.22342378f, 0.12737752f, 0.03069976f, 0.08303839f, 
    0.22770493f, 0.02500002f, 0.16088408f, 0.12274586f, 0.05318109f, 0.12865233f, 0.02154092f, -0.06756637f, 
    -0.03462863f, -0.07364275f, -0.03093852f, 0.14988095f, 0.05515694f, 0.09253155f, 0.03446526f, 0.08398895f, 
    0.06352638f, 0.02752444f, -0.03289917f, -0.07820526f, -0.00748233f, 0.02095274f, -0.00677640f, 0.06463303f, 
    0.00482788f, 0.23147982f, -0.10079313f, -0.35343504f, -0.09535547f, -0.03720102f, -0.03705049f, 0.18946417f, 
    0.00128408f, -0.00955503f, 0.03090171f, 0.01631387f, 0.10345199f, -0.00291009f, 0.16837996f, -0.04892859f, 
    -0.00025681f, 0.06514160f, -0.06379163f, -0.00192727f, 0.14216703f, -0.16382943f, 0.02516538f, 0.09472707f, 
    -0.00488786f, 0.03258976f, 0.04777118f, 0.02121444f, 0.09041546f, -0.11428930f, -0.06496937f, 0.06077133f, 
    0.02687083f, 0.06048556f, 0.09380471f, 0.04037875f, 0.20242925f, 0.10269869f, 0.06628558f, 0.03110861f, 
    -0.03644865f, 0.04999136f, -0.09377349f, 0.03139360f, 0.00186310f, 0.00243296f, -0.08341146f, -0.06553105f, 
    0.32702741f, -0.20634864f, -0.34399906f, -0.36774358f, -0.04454864f, -0.18555298f, -0.21139237f, 0.01083693f, 
    0.05314592f, -0.02551297f, 0.04344080f, -0.01913458f, 0.09828226f, -0.13755882f, -0.28293815f, -0.29350698f, 
    0.10240494f, 0.01993040f, -0.13674507f, 0.17393166f, 0.05134683f, 0.13422641f, 0.07841970f, 0.04963458f, 
    -0.09425893f, -0.00138124f, 0.07292658f, -0.06804029f, 0.07153498f, 0.13719313f, 0.05133171f, -0.18881959f, 
    0.02429318f, -0.20361274f, -0.03274823f, 0.09547476f, 0.44309053f, -0.05229096f, 0.09041243f, -0.37103039f, 
    0.05292317f, -0.00068287f, -0.10323179f, 0.00864314f, -0.04840108f, 0.10435860f, 0.01108483f, 0.00859453f, 
    0.18487881f, 0.06997222f, -0.11643600f, 0.00690148f, 0.03544757f, 0.00608505f, 0.17301054f, 0.00038688f, 
    0.00907077f, 0.06581667f, -0.01107787f, 0.09899335f, 0.25532496f, 0.03291868f, 0.20056172f, -0.41593465f, 
    -0.00710606f, -0.01493313f, 0.17542216f, 0.31493050f, 0.11679838f, -0.01899096f, 0.04289822f, 0.00109800f, 
    -0.21758763f, -0.01067542f, -0.02150992f, -0.10696464f, -0.14068040f, -0.04368387f, 0.03064087f, -0.08047492f, 
    0.02869674f, 0.07008345f, 0.00384355f, -0.02598566f, 0.21910712f, 0.06545490f, 0.12645236f, 0.04266278f, 
    -0.05379755f, 0.01908641f, 0.00122071f, 0.10833402f, 0.21204810f, 0.04226066f, 0.09282525f, 0.07188506f, 
    0.06507479f, 0.10433189f, -0.00593734f, 0.07082114f, 0.02545442f, 0.05243433f, 0.04416486f, -0.08644880f, 
    -0.04843117f, -0.02562511f, -0.01349985f, -0.10003466f, -0.51832622f, -0.12658736f, 0.03253272f, -0.04222065f, 
    0.14305635f, 0.19420739f, -0.21973933f, -0.09734766f, 0.03089416f, -0.12683526f, -0.16073765f, 0.00327352f, 
    0.12583785f, 0.16007261f, 0.12812595f, 0.13423258f, -0.01323904f, 0.00322455f, -0.04814161f, -0.00419783f, 
    0.05910383f, -0.02700979f, -0.10835591f, -0.00741068f, -0.10123947f, -0.12641566f, -0.10919898f, -0.16666383f, 
    0.06446660f, 0.25541499f, 0.10847108f, 0.09583455f, -0.00096696f, -0.01909976f, 0.02168736f, -0.00221862f, 
    -0.27409407f, 0.03755856f, -0.09402104f, -0.01755458f, 0.05892839f, 0.19292384f, 0.07818922f, 0.23562685f, 
    -0.06328599f, -0.05547480f, 0.06944928f, -0.04488601f, 0.31937006f, -0.27330092f, -0.32498449f, -0.38534424f, 
    0.12774312f, 0.13865568f, 0.10174363f, 0.03083172f, -0.01120849f, 0.02697391f, -0.00743954f, 0.04169257f, 
    -0.41538674f, 0.04418683f, 0.26644409f, 0.06768869f, -0.00151578f, 0.06599860f, -0.06657501f, -0.15181668f, 
    -0.02725674f, -0.06486101f, -0.11815152f, 0.04751337f, -0.07134704f, 0.24018291f, 0.01689243f, 0.12530184f, 
    0.10888150f, -0.07394385f, -0.03475977f, 0.06844795f, 0.11859418f, -0.03184949f, -0.00099227f, 0.06357534f, 
    0.01359825f, 0.06622227f, 0.10847012f, -0.31401628f, -0.11288576f, 0.09572326f, -0.09073246f, 0.01576462f, 
    0.13987376f, -0.05989832f, 0.02344244f, -0.03818953f, -0.08220854f, -0.04836541f, -0.03020224f, -0.10655978f, 
    -0.18216224f, -0.05938525f, -0.08089223f, -0.09141394f, -0.04937834f, -0.09791298f, 0.03315941f, -0.05479274f, 
    -0.16565794f, 0.16573443f, -0.00205670f, -0.06896760f, -0.06779317f, -0.00272585f, 0.03110713f, 0.05448356f, 
    0.08242747f, 0.00582918f, 0.04835359f, -0.09670230f, 0.04788990f, -0.10548879f, -0.21338598f, -0.20826073f, 
    -0.31157601f, 0.28286222f, -0.26807621f, -0.20027475f, -0.04469084f, -0.07974202f, 0.01477465f, -0.00836782f, 
    0.09377196f, 0.16339487f, 0.12867489f, -0.21762398f, 0.18365310f, 0.15525569f, 0.08931582f, 0.24087581f, 
    -0.05769097f, -0.04412076f, 0.08058982f, -0.00784572f, -0.21338333f, -0.16858146f, -0.19401337f, -0.41311169f, 
    0.11572274f, -0.13917193f, -0.18263952f, 0.04653079f, 0.00086837f, -0.04954623f, -0.03061038f, 0.12407336f, 
    0.07440105f, 0.04513243f, 0.20977362f, 0.08181342f, -0.00442743f, 0.05507720f, -0.04717994f, -0.02480862f, 
    0.25954267f, 0.11205163f, 0.14542271f, 0.26426512f, 0.24154487f, 0.06175964f, 0.18852662f, 0.20609859f, 
    -0.06188533f, -0.01408660f, 0.02177732f, -0.06379800f, 0.13269892f, 0.07409498f, 0.00521567f, 0.02778755f, 
    0.04444360f, -0.13928339f, -0.26497751f, -0.10355369f, 0.02906699f, 0.14105365f, -0.14700966f, 0.02563095f, 
    0.13382845f, -0.03198504f, -0.11946376f, -0.04095881f, -0.16605641f, 0.00753605f, 0.00782477f, 0.05620795f, 
    0.08457614f, 0.09950221f, -0.06941760f, -0.01513669f, 0.16062440f, 0.01981240f, -0.00837643f, 0.09409596f, 
    -0.01444609f, 0.13085099f, 0.25431553f, 0.05325354f, -0.01428827f, 0.02390987f, -0.07176467f, 0.01347878f, 
    0.00287720f, -0.11617476f, -0.00201438f, -0.06549998f, -0.25537661f, 0.23648818f, -0.05733234f, 0.28204042f, 
    0.04317956f, 0.08893600f, 0.04953063f, 0.12412483f, 0.05598435f, -0.09312210f, 0.01402731f, 0.00230981f, 
    0.08460157f, 0.08914234f, -0.05658419f, 0.01736824f, 0.15428053f, -0.01127819f, 0.04978415f, -0.09299714f, 
    -0.09693320f, 0.05368510f, 0.02149103f, -0.03692871f, -0.04101858f, -0.15707517f, -0.07692084f, -0.14040668f, 
    -0.01210149f, -0.07524924f, -0.04042264f, -0.04959280f, 0.07997035f, 0.06974246f, 0.16028939f, -0.00139015f, 
    -0.30372688f, 0.14295134f, -0.16745424f, 0.26635733f, -0.09117386f, -0.13963693f, 0.07496256f, 0.02985298f, 
    0.04118658f, -0.04793394f, 0.11881682f, -0.12798364f, -0.04047399f, -0.31753761f, -0.49996978f, -0.38507676f, 
    -0.00221203f, 0.02348331f, 0.00333317f, 0.04224699f, 0.11489097f, -0.00242521f, 0.04757148f, -0.17053437f, 
    -0.65284675f, 0.10160962f, 0.49538410f, -0.05096919f, -0.02165367f, 0.03283145f, 0.02245812f, -0.09430034f, 
    0.06984856f, -0.03234012f, 0.01994726f, 0.03637107f, -0.45461175f, -0.05022451f, 0.03068783f, -0.72883314f, 
    0.28502709f, -0.04635185f, -0.05945829f, 0.14822617f, -0.03226687f, -0.01076535f, 0.07205153f, 0.02388331f, 
    -0.03090722f, -0.02514598f, 0.11040790f, -0.06377595f, 0.05646245f, -0.01634682f, 0.03105652f, -0.00582059f, 
    0.04596747f, -0.02830293f, 0.01996779f, 0.19941419f, 0.10315191f, 0.23884238f, 0.20153771f, 0.26404843f, 
    0.06736141f, 0.01265918f, -0.06294332f, -0.04230057f, 0.02078776f, -0.10971712f, -0.00125360f, -0.03058550f, 
    0.03515913f, 0.05206673f, 0.07304583f, 0.06540189f, -0.00291193f, -0.00565555f, 0.01734245f, -0.05293021f, 
    -0.02447885f, 0.00423562f, -0.00225176f, 0.04160094f, -0.12740350f, 0.20221621f, -0.08216227f, -0.09618126f, 
    -0.07354826f, -0.15993683f, -0.19986112f, -0.06566586f, -0.00169009f, -0.03877701f, 0.02901314f, -0.12173511f, 
    0.34203708f, -0.01853394f, -0.23383506f, -0.23864703f, -0.01776756f, 0.01573304f, -0.24718559f, 0.03740580f, 
    0.11898299f, 0.02229551f, 0.07655393f, 0.06841470f, -0.17545345f, 0.01872313f, -0.21506405f, 0.03453066f, 
    0.17669803f, 0.16196480f, 0.02513668f, 0.15758733f, 0.09730419f, 0.00290642f, 0.07479850f, -0.03802310f, 
    0.02801725f, 0.02480474f, 0.43290693f, -0.03906096f, 0.00859686f, 0.11939096f, 0.01778917f, -0.19733155f, 
    0.04405226f, -0.15271676f, 0.01512266f, -0.00653128f, -0.45797116f, -0.43806896f, -0.15994801f, -0.65594023f, 
    0.08358600f, -0.07502036f, -0.00386560f, 0.04305955f, -0.02868658f, 0.00851620f, 0.04704173f, 0.01549331f, 
    0.06813391f, -0.12370663f, 0.20730332f, -0.06719064f, 0.14802119f, -0.07425595f, 0.04601441f, 0.05932209f, 
    -0.00590840f, 0.09793229f, -0.19627519f, -0.03932087f, -0.44596112f, -0.20021336f, -0.19214819f, -0.29081476f, 
    0.09531037f, 0.16999187f, 0.16112599f, -0.01333041f, -0.07840592f, 0.02481571f, -0.00406989f, -0.03535066f, 
    0.27579671f, -0.17062078f, -0.04267443f, -0.01943462f, -0.02664839f, -0.11953069f, -0.07448472f, -0.09109361f, 
    -0.12132483f, -0.12146682f, 0.03899816f, 0.19628289f, -0.44501108f, -0.10617949f, -0.02401962f, -0.24362224f, 
    0.07158650f, 0.02896627f, -0.03323374f, 0.23597081f, -0.06819894f, -0.00405062f, 0.03498672f, -0.03857608f, 
    0.44173017f, 0.11434015f, 0.23770198f, 0.00631352f, -0.08917494f, 0.09044109f, -0.10649604f, -0.01006607f, 
    0.11771029f, -0.01471729f, 0.14315891f, -0.10179627f, 0.25822955f, 0.07766107f, 0.09763736f, 0.09644376f, 
    0.01702835f, -0.04732691f, -0.07303672f, 0.04373373f, 0.10675312f, 0.02636222f, -0.02563324f, -0.04733046f, 
    0.07378408f, 0.36267462f, -0.23668896f, 0.04241925f, -0.00320240f, 0.08221793f, 0.13129829f, 0.13068143f, 
    -0.08856746f, -0.00497717f, -0.04686167f, -0.02069833f, 0.07092879f, 0.34741941f, 0.15794949f, -0.13255283f, 
    -0.14875144f, 0.08513054f, 0.02786429f, 0.04722805f, -0.05375525f, -0.01643449f, -0.04015979f, -0.04844488f, 
    0.16900843f, -0.37837106f, -0.11687955f, -0.34977829f, 0.10904834f, -0.10012170f, -0.05207418f, 0.11906981f, 
    0.20761985f, 0.06953458f, 0.01114993f, 0.10325802f, 0.18158603f, -0.01070402f, 0.08330143f, 0.08335018f, 
    0.00421492f, 0.06935826f, -0.02728116f, -0.06642740f, 0.10838699f, 0.01567541f, -0.00050103f, -0.01431397f, 
    -0.06869511f, 0.08531624f, 0.28231975f, 0.09010212f, -0.18191245f, -0.00343405f, 0.00262167f, -0.09693845f, 
    0.03672962f, 0.03347459f, 0.04345929f, -0.01071414f, -0.13280922f, 0.09175481f, 0.16741167f, 0.34199214f, 
    -0.10443304f, -0.01840874f, 0.03803319f, -0.03874382f, 0.05846627f, 0.00239758f, 0.05209095f, -0.01417939f, 
    -0.05112791f, 0.04341200f, 0.07856324f, -0.02944330f, 0.12312951f, 0.02986333f, 0.02020807f, 0.13328734f, 
    -0.02852134f, 0.00103938f, 0.12340152f, 0.14555532f, -0.04638785f, -0.00039425f, 0.00918186f, -0.06237788f, 
    -0.02665105f, 0.07866053f, 0.04813843f, 0.07180422f, 0.05552078f, 0.01629333f, 0.14428189f, 0.10393613f, 
    -0.26762480f, 0.18598656f, 0.30729884f, 0.19469632f, -0.10005221f, 0.04382624f, -0.07408908f, -0.01551101f, 
    -0.08205985f, -0.09218545f, 0.13205926f, -0.04622261f, -0.05089604f, 0.07812978f, 0.02518973f, -0.04148774f, 
    -0.05168446f, -0.07043481f, 0.00317036f, 0.00760331f, -0.22658038f, 0.04738842f, -0.08693355f, -0.16742054f, 
    -0.14452705f, -0.11208537f, -0.09316636f, -0.04532682f, 0.01018317f, 0.16533887f, 0.09512511f, 0.04943005f, 
    0.04263736f, 0.12301945f, 0.10580385f, 0.15652351f, 0.10511490f, 0.08960122f, 0.20234521f, -0.16868164f, 
    -0.00461724f, -0.00044401f, -0.09395789f, 0.00377253f, -0.00297605f, 0.03615679f, 0.04660916f, 0.05347117f, 
    0.00253955f, 0.04408761f, -0.12635970f, 0.07351287f, 0.10419030f, -0.02912566f, -0.03036185f, 0.01697826f, 
    -0.10700998f, -0.02588315f, 0.03462732f, -0.08603439f, -0.16434473f, 0.16370529f, -0.00061066f, 0.06085647f, 
    0.04427069f, -0.07734278f, -0.09096988f, -0.07483110f, -0.12062250f, -0.03399581f, -0.07847480f, -0.13213789f, 
    0.04187923f, 0.01115777f, 0.06483372f, -0.04280261f, 0.03575249f, 0.01583738f, -0.15252912f, -0.10354363f, 
    -0.06039776f, -0.03273534f, -0.06514253f, -0.08902235f, -0.11771449f, 0.04587500f, 0.00730653f, -0.06461826f, 
    -0.01826185f, 0.07109804f, -0.00653972f, -0.07308483f, 0.12572883f, 0.10752502f, 0.20310107f, 0.12198766f, 
    0.04875289f, -0.45803124f, -0.36509943f, -0.07145660f, -0.02425275f, 0.10912412f, 0.12942725f, 0.15340686f, 
    0.03703370f, -0.01613692f, -0.00381867f, -0.00203000f, 0.16100447f, -0.14724751f, -0.18724394f, -0.11205823f, 
    -0.02924488f, 0.02354096f, 0.14710814f, 0.12103683f, -0.08186752f, -0.03299659f, 0.19061306f, -0.09111982f, 
    0.71273685f, -0.06935583f, 0.03141347f, -0.24213272f, 0.10005552f, 0.02862207f, -0.03368505f, -0.08418107f, 
    -0.05195384f, 0.21361390f, 0.15363632f, 0.04996271f, 0.34824163f, 0.13136825f, -0.23689228f, -0.18202150f, 
    0.00921164f, 0.06262890f, 0.07196119f, -0.07167347f, -0.08273622f, -0.06804825f, 0.15563172f, 0.04865765f, 
    -0.15284525f, -0.04223971f, 0.17270777f, 0.37702858f, -0.09260095f, 0.02903386f, 0.23188768f, 0.09114121f, 
    0.03673771f, -0.03531036f, 0.05405288f, 0.06379333f, 0.14636230f, 0.06630865f, -0.00548215f, 0.05233245f, 
    0.02644556f, -0.07988622f, 0.08541266f, -0.01735840f, -0.13777761f, -0.07165610f, -0.03261608f, -0.03537242f, 
    0.26421779f, 0.27151990f, -0.07959431f, -0.16138630f, 0.11612581f, -0.12456957f, 0.10834224f, 0.16565357f, 
    -0.01993452f, -0.09547929f, -0.00608596f, -0.16804747f, -0.27507302f, 0.15973809f, 0.16395606f, -0.11809700f, 
    -0.13804290f, 0.04174971f, -0.06302159f, 0.01533697f, -0.02598271f, -0.01885157f, -0.09725608f, -0.08885362f, 
    -0.03276952f, 0.07736708f, -0.03154755f, -0.03051526f, 0.05840289f, 0.03614517f, -0.00167931f, -0.02912758f, 
    0.03128335f, 0.08665145f, 0.12186667f, 0.09086740f, 0.47698969f, 0.35886487f, -0.21076922f, -0.11932099f, 
    0.07183916f, -0.11567698f, 0.04365440f, -0.10684900f, 0.09327407f, 0.07334770f, -0.04781456f, 0.01846148f, 
    -0.06429324f, 0.07086024f, 0.11213051f, -0.13018526f, -0.09893185f, -0.00668096f, -0.05807657f, -0.02268105f, 
    -0.03296399f, 0.14815563f, 0.02325089f, 0.11289072f, -0.02549372f, -0.07480289f, -0.11516798f, 0.12298934f, 
    0.10052150f, -0.13372071f, -0.11499598f, -0.01107578f, -0.10556834f, 0.00574929f, -0.07573551f, 0.00153713f, 
    0.09442027f, -0.03886204f, 0.01373080f, 0.01163482f, 0.00649516f, -0.02494963f, 0.04816201f, 0.13160008f, 
    0.05019898f, -0.04135760f, 0.02827771f, 0.09450375f, -0.00140557f, -0.01544527f, -0.10795849f, 0.15862240f, 
    0.03591441f, 0.08496974f, 0.07893661f, 0.00540817f, -0.01651531f, -0.06845926f, 0.05242637f, 0.16077180f, 
    0.51175714f, 0.08783724f, -0.13067083f, -0.13006036f, -0.09641302f, -0.03696657f, 0.01722553f, 0.00861528f, 
    0.07851771f, 0.00954635f, -0.05112994f, 0.01429861f, -0.16823514f, 0.07921502f, 0.18450208f, 0.27485019f, 
    -0.12276790f, -0.06791202f, -0.02617676f, 0.08096264f, -0.12966825f, 0.06462675f, -0.03071997f, 0.00942078f, 
    -0.48961017f, -0.09686799f, -0.03112043f, 0.19884151f, -0.04143713f, 0.02306570f, 0.08725893f, 0.12381195f, 
    0.07332786f, -0.05563557f, -0.00992421f, -0.13138866f, -0.02851821f, -0.10994295f, -0.04881529f, 0.11035465f, 
    0.11781038f, 0.09280485f, -0.02893135f, 0.04635727f, -0.04233020f, 0.01232884f, 0.03326659f, 0.02294705f, 
    -0.08103069f, -0.05913407f, -0.08935348f, -0.16686468f, 0.05834742f, 0.08947072f, -0.03454572f, 0.01747184f, 
    -0.14669034f, -0.04726744f, -0.13520902f, -0.03542988f, 0.27975306f, 0.14776179f, -0.11781742f, -0.17920917f, 
    0.14654373f, -0.05193450f, 0.06368459f, 0.19285522f, -0.00767533f, -0.09926896f, -0.00880132f, 0.11694071f, 
    0.00311321f, -0.04558046f, -0.02084718f, 0.13635166f, 0.11129458f, -0.07874003f, -0.11171454f, 0.02452693f, 
    -0.14218852f, -0.02174271f, -0.00018349f, -0.05130734f, 0.20123808f, 0.06795079f, 0.02923624f, 0.06121941f, 
    0.01362013f, 0.03518151f, 0.10895450f, -0.03579936f, 0.01157880f, -0.03425053f, -0.04223316f, -0.22465955f, 
    0.01965899f, 0.10358821f, 0.01334645f, -0.08211750f, -0.03190494f, -0.02349295f, -0.03885033f, -0.07555465f, 
    -0.24729253f, -0.08282334f, -0.16853455f, -0.19872290f, 0.03711167f, 0.10958984f, 0.20182538f, -0.07109129f, 
    -0.05314764f, -0.01273683f, -0.03994772f, -0.02370797f, -0.12445214f, -0.04692655f, 0.06557867f, -0.08695789f, 
    0.04281889f, 0.04041054f, -0.18449579f, -0.22027853f, -0.03079401f, 0.17597355f, 0.13533358f, 0.09769291f, 
    0.01380491f, 0.10253019f, 0.00585941f, -0.02719424f, 0.34855852f, 0.15599456f, -0.15964867f, 0.18501885f, 
    -0.12535210f, -0.02870675f, 0.00633148f, -0.02901216f, -0.00281936f, 0.06180692f, -0.02957877f, -0.08002876f, 
    0.39297974f, 0.14883597f, 0.15300116f, -0.10521815f, 0.12949096f, -0.10772081f, -0.15763363f, -0.07144059f, 
    0.04998943f, 0.08338714f, 0.09319919f, -0.04999096f, -0.10980702f, -0.03911646f, -0.10995775f, 0.04978574f, 
    0.10652487f, 0.00753594f, 0.04666954f, 0.18483342f, 0.00274449f, 0.12938021f, -0.05222140f, -0.13885343f, 
    -0.02841365f, -0.00288965f, 0.15036565f, -0.01602972f, 0.03010156f, -0.11818340f, -0.07854822f, 0.03547383f, 
    0.16045357f, -0.02609191f, 0.11563218f, 0.06362586f, 0.03255245f, -0.18554153f, -0.13533518f, -0.12363286f, 
    0.12652428f, 0.05059795f, 0.11933596f, 0.12805557f, -0.16218823f, -0.01125284f, -0.11309145f, -0.20740548f, 
    -0.04457670f, -0.25268739f, 0.16741914f, -0.03496293f, 0.13006356f, 0.03746096f, 0.12370411f, 0.24370292f, 
    -0.00315964f, -0.01527017f, 0.13021860f, 0.04883714f, 0.16543370f, -0.04503386f, 0.02972037f, -0.03567423f, 
    0.02711561f, 0.07532994f, 0.05406792f, -0.00585233f, -0.03677577f, 0.02203871f, -0.04298566f, -0.02665098f, 
    0.10553250f, -0.20002736f, -0.02161862f, 0.14134222f, 0.07517711f, -0.00827006f, 0.03996004f, 0.07547589f, 
    0.01351608f, -0.11053701f, 0.10238449f, -0.00710436f, 0.23668726f, 0.14011656f, 0.09211028f, 0.12475346f, 
    -0.11431288f, -0.09914191f, 0.08614701f, -0.20840204f, 0.04652035f, 0.03537039f, -0.05750529f, 0.02126868f, 
    -0.19264771f, 0.17555381f, 0.06965709f, -0.08398657f, -0.02598839f, -0.09969504f, -0.01338717f, 0.00925095f, 
    -0.11961401f, -0.03472381f, -0.19823292f, -0.27848455f, 0.09528989f, 0.14686118f, 0.19519664f, 0.21662210f, 
    0.10434493f, -0.13961008f, -0.12031840f, -0.11774436f, 0.00573405f, 0.02024705f, -0.00158345f, 0.08182312f, 
    0.16143979f, 0.01604811f, 0.10428242f, -0.08838846f, 0.03235466f, -0.13372822f, -0.09954284f, -0.07634627f, 
    0.07416421f, 0.04783848f, -0.00834770f, 0.01146141f, 0.55562425f, -0.08977991f, -0.07510568f, -0.21634915f, 
    0.20394492f, 0.03969114f, 0.09935014f, -0.07302789f, -0.01646028f, 0.06243309f, 0.06045356f, -0.04786154f, 
    -0.12016090f, -0.13178451f, -0.39339536f, -0.03855899f, -0.01556620f, 0.12382810f, 0.04761957f, 0.13086061f, 
    0.04295712f, -0.04296597f, -0.06592043f, 0.02019446f, 0.16357158f, -0.29946247f, -0.20332520f, -0.17580566f, 
    0.02170084f, 0.12116759f, 0.16606101f, 0.11809690f, 0.00484888f, 0.07347286f, 0.07813572f, -0.02534678f, 
    0.02148965f, -0.23998396f, -0.05570751f, 0.09638003f, 0.14760368f, 0.01665305f, 0.09342232f, -0.06846087f, 
    0.15611953f, 0.12327358f, 0.13150677f, 0.20268607f, 0.32810280f, 0.25042787f, -0.09416774f, -0.08913060f, 
    -0.01744009f, -0.11297205f, -0.00915741f, 0.07600494f, 0.03623896f, -0.08333108f, 0.04851329f, 0.10230982f, 
    0.07365026f, 0.10078420f, -0.00669312f, 0.08194173f, 0.03050198f, -0.01826133f, 0.01087925f, 0.06334244f, 
    0.00498873f, 0.05382914f, 0.04328996f, 0.12404580f, 0.20802815f, -0.01793547f, 0.00117085f, 0.07512478f, 
    0.09808306f, 0.00860177f, -0.00027719f, -0.00734900f, 0.03070768f, -0.02102262f, -0.07411421f, 0.07763774f, 
    -0.00136615f, -0.17081161f, -0.31616691f, -0.13394378f, 0.01443296f, 0.14577313f, 0.12523213f, 0.01312912f, 
    0.20503470f, 0.03345950f, 0.01863304f, 0.05681764f, 0.01451839f, 0.15757561f, 0.00293895f, -0.15719630f, 
    0.13954622f, -0.12066887f, -0.02034956f, 0.11971351f, 0.09685072f, 0.11532409f, -0.04272624f, 0.01505928f, 
    -0.00138044f, -0.17906876f, 0.08684605f, -0.13053149f, -0.00416869f, -0.04925876f, 0.05211025f, -0.02994958f, 
    0.15923426f, 0.12336184f, 0.13498572f, 0.17459233f, -0.09799206f, -0.01824596f, 0.06782106f, -0.10763436f, 
    -0.07554895f, 0.02692053f, 0.01778116f, -0.07475678f, 0.03981992f, 0.02433409f, 0.08672519f, 0.15501127f, 
    -0.32249299f, 0.03700714f, 0.29819188f, 0.03813103f, 0.11041021f, -0.14552547f, -0.11964702f, -0.07883500f, 
    0.02053744f, 0.04897129f, 0.13177931f, 0.10611018f, 0.17138718f, -0.06766174f, 0.11101785f, 0.09056590f, 
    -0.01221784f, -0.00663052f, -0.01453628f, 0.03263360f, -0.02150136f, 0.04605666f, 0.08014619f, 0.04843389f, 
    0.05975291f, -0.12940355f, -0.23600987f, -0.04525375f, 0.11517087f, 0.18071325f, 0.17091133f, 0.00274481f, 
    0.03767237f, -0.15230165f, -0.05991331f, -0.11818353f, 0.17918044f, 0.10085441f, 0.02264329f, 0.00263902f, 
    -0.03895304f, -0.01403655f, 0.01122779f, -0.06653091f, 0.06398661f, 0.03321813f, -0.10799304f, 0.00642320f, 
    0.11839154f, 0.18155695f, -0.15635523f, 0.24126169f, -0.03268331f, 0.00737115f, 0.06237124f, 0.01899046f, 
    -0.12937947f, -0.00043623f, -0.01651699f, -0.00762107f, -0.23515949f, -0.12395763f, -0.00340977f, 0.10530687f, 
    0.06470746f, -0.10754802f, 0.16219565f, 0.05662022f, -0.05907254f, 0.05561474f, -0.01055179f, 0.08779407f, 
    0.00319861f, 0.02301439f, -0.19235803f, -0.13888600f, -0.06653356f, 0.01569159f, 0.05127177f, -0.20983155f, 
    -0.12954052f, -0.02931085f, -0.09657133f, -0.17257965f, 0.20840734f, 0.12881376f, 0.02849696f, -0.21375412f, 
    -0.04251014f, 0.13197017f, -0.02009927f, -0.01560669f, 0.04511542f, -0.15283145f, -0.05189319f, -0.05259910f, 
    0.09894367f, -0.09652092f, 0.04501996f, 0.15749322f, -0.12323196f, 0.16488372f, 0.03251847f, -0.02308012f, 
    -0.08186266f, 0.07632406f, -0.03205870f, 0.08384991f, -0.30347756f, 0.21410212f, 0.00412046f, 0.06447891f, 
    0.10022109f, 0.11564379f, 0.16793841f, 0.02771554f, 0.07386900f, -0.13624525f, 0.07129825f, 0.20987457f, 
    0.10408255f, -0.02145480f, 0.00521828f, 0.15942761f, 0.16701375f, -0.00151512f, 0.08040275f, -0.12075523f, 
    -0.07023264f, -0.08219444f, -0.01572758f, -0.09805763f, 0.03327283f, -0.26626560f, -0.01003776f, -0.04020881f, 
    -0.03380547f, 0.07033738f, -0.07024366f, -0.20241316f, -0.07911508f, -0.05621320f, 0.01437400f, -0.08374520f, 
    -0.13307318f, 0.30868042f, -0.09432115f, 0.06250814f, -0.05152192f, -0.04074382f, 0.10054599f, 0.00631369f, 
    0.09897463f, -0.06118044f, -0.10704945f, -0.13054009f, -0.06493116f, -0.04214165f, 0.09312323f, 0.00069835f, 
    -0.06464235f, -0.03073663f, 0.04804836f, -0.02162816f, 0.07016809f, -0.03163988f, -0.02066829f, 0.05752921f, 
    0.15183322f, -0.00919284f, -0.16517659f, -0.03918779f, 0.09465644f, -0.05746084f, 0.10111808f, 0.08504896f, 
    0.03044929f, 0.03682784f, -0.06076710f, 0.00732630f, 0.09344679f, -0.05597775f, 0.00534910f, -0.19689007f, 
    -0.06212156f, -0.07864846f, -0.08152457f, -0.23796082f, 0.05336276f, -0.06534208f, -0.00263378f, -0.10674443f, 
    0.24567433f, -0.23990113f, -0.22480761f, -0.21976501f, 0.03284707f, 0.00384755f, -0.05091072f, 0.02591193f, 
    -0.02939332f, 0.00857572f, 0.01151343f, 0.10026463f, -0.00934441f, -0.01514357f, -0.06122360f, -0.13857640f, 
    0.00813662f, -0.00499271f, -0.05756656f, 0.06487499f, 0.01604178f, -0.07913373f, 0.05481165f, 0.19127187f, 
    0.19909438f, -0.02980641f, 0.21056403f, 0.02366626f, 0.02725518f, 0.11901709f, -0.10111540f, -0.15493131f, 
    0.10794310f, -0.02117852f, -0.00752211f, -0.09707385f, 0.27942485f, -0.32562861f, -0.06196491f, -0.09688324f, 
    -0.06104063f, 0.04142345f, 0.08011433f, -0.05871956f, 0.01174392f, -0.10978459f, 0.03650917f, 0.06886741f, 
    -0.08160712f, 0.19969369f, 0.00527178f, 0.15008779f, 0.03999859f, 0.04052043f, 0.12855311f, 0.17073435f, 
    -0.13841328f, 0.02073063f, -0.05092780f, -0.06052487f, 0.23229748f, 0.14159852f, 0.13527364f, 0.14373410f, 
    0.06657713f, 0.01023309f, 0.20783085f, 0.25596273f, 0.10224833f, 0.07529411f, 0.03737878f, 0.07932601f, 
    -0.04160575f, -0.01528986f, 0.05676373f, 0.14609271f, -0.06098668f, 0.05521588f, 0.09999548f, -0.02455524f, 
    0.08701953f, 0.01053905f, -0.16156089f, 0.13612930f, -0.05983465f, -0.03630803f, -0.00170910f, 0.00465095f, 
    -0.23689216f, 0.18743961f, 0.05304763f, -0.14023204f, -0.02945184f, -0.00012703f, 0.11386253f, 0.12204317f, 
    0.11433122f, -0.02974261f, -0.04065877f, -0.10952689f, -0.01969174f, -0.01968042f, -0.06871954f, -0.01720040f, 
    -0.10352518f, -0.25736403f, -0.11690167f, -0.17963484f, 0.06116018f, -0.02264065f, 0.21402644f, -0.16615447f, 
    0.22968857f, -0.05983195f, 0.00090704f, 0.01193763f, -0.02563483f, 0.00099468f, -0.01636730f, -0.14077759f, 
    0.03411930f, -0.02762423f, 0.10721006f, -0.02446137f, -0.12078089f, 0.17761645f, -0.02684680f, -0.20401326f, 
    0.03007075f, -0.04702813f, 0.07610173f, -0.07285108f, 0.14275619f, 0.16847612f, 0.06865285f, -0.17066872f, 
    0.05316475f, 0.03017954f, -0.03376954f, 0.04576815f, 0.04625599f, -0.20963152f, -0.02485528f, -0.06837989f, 
    0.27896968f, 0.13453232f, 0.10653511f, 0.09886108f, 0.09259419f, -0.03220737f, 0.12137953f, 0.29351333f, 
    -0.07462374f, 0.08918273f, -0.05177974f, -0.00773245f, 0.06897262f, -0.27714536f, -0.16192138f, 0.02889620f, 
    0.11439299f, -0.08905236f, 0.06426068f, 0.25220749f, -0.07645776f, 0.07623559f, 0.08442272f, -0.00209383f, 
    0.03071539f, -0.11326229f, 0.25903538f, 0.13777573f, 0.01296114f, 0.03645793f, 0.07217098f, -0.04273668f, 
    0.03122920f, 0.02139893f, 0.04879679f, -0.00240782f, -0.16777480f, 0.19135335f, 0.04385858f, 0.05409890f, 
    -0.05101708f, 0.01164145f, 0.08549817f, 0.05558135f, 0.05909397f, 0.06261122f, -0.06356639f, 0.09081717f, 
    -0.15203153f, -0.07965869f, 0.13500297f, -0.01530979f, -0.12267442f, 0.09088483f, 0.04854850f, -0.07433778f, 
    -0.02322713f, 0.06701661f, -0.01607751f, 0.03358677f, 0.13699862f, 0.16733716f, -0.04967638f, -0.34473461f, 
    0.03391175f, 0.01148070f, 0.08464909f, -0.06155978f, -0.00316836f, -0.00817944f, -0.13136695f, -0.01603396f, 
    -0.04710192f, 0.07912377f, 0.01526857f, -0.13970736f, -0.08093241f, -0.04446632f, 0.00634043f, -0.21511595f, 
    -0.00442981f, -0.01361563f, -0.00995501f, -0.01271274f, 0.35810378f, 0.04719440f, 0.04852196f, -0.16882221f, 
    -0.17117572f, 0.04931779f, -0.02261009f, -0.06184739f, 0.07311380f, 0.08871025f, -0.03448790f, -0.01124002f, 
    0.50455630f, 0.47371730f, 0.02824524f, -0.12794825f, 0.11906512f, 0.02839355f, 0.11140279f, 0.17967691f, 
    -0.06063120f, -0.01718839f, -0.03555284f, -0.05953447f, 0.03844492f, 0.01089251f, -0.13436382f, -0.11230844f, 
    0.11447602f, 0.05495385f, 0.02667983f, 0.11724456f, 0.04149276f, 0.05737681f, 0.03773734f, 0.18829095f, 
    0.00191048f, 0.00748837f, 0.06802314f, -0.01039963f, -0.04585521f, 0.04535563f, 0.01277630f, 0.02928235f, 
    0.10448395f, 0.06281986f, 0.13521455f, 0.10840917f, 0.06597545f, -0.13063224f, 0.16317625f, 0.08901455f, 
    -0.11352000f, -0.01600538f, 0.05016719f, -0.09657913f, -0.04895585f, 0.00987543f, 0.02196548f, 0.07899068f, 
    0.16892597f, 0.06003399f, -0.25557742f, -0.00799216f, -0.06175245f, 0.04931933f, -0.01850210f, 0.00953368f, 
    0.03000402f, 0.07962118f, 0.00545122f, 0.02983092f, -0.26557007f, 0.19226515f, -0.07816532f, -0.21028233f, 
    -0.00508958f, -0.02043141f, -0.09119691f, 0.01834150f, -0.01799309f, 0.00332451f, 0.02558625f, -0.07197590f, 
    0.15127189f, -0.10051541f, 0.11056439f, -0.12367903f, -0.01694130f, 0.02575359f, 0.04572864f, -0.13576294f, 
    -0.06984289f, -0.07776449f, -0.06534697f, -0.05317191f, -0.01876427f, 0.24331802f, 0.12505451f, 0.22324903f, 
    -0.03995085f, 0.02430926f, 0.11212870f, 0.10019089f, 0.07447226f, 0.04595732f, 0.03869531f, -0.00990001f, 
    -0.02049158f, 0.22880228f, -0.02646964f, -0.01684142f, -0.11308980f, -0.06429370f, 0.00033609f, 0.00552825f, 
    -0.22681424f, 0.09788509f, -0.11735954f, -0.29428503f, 0.09400176f, -0.07610635f, 0.00714869f, -0.03192464f, 
    0.07854531f, -0.07608175f, -0.12773664f, -0.05818402f, 0.02219409f, 0.06458421f, 0.04942239f, 0.12238634f, 
    -0.02108764f, 0.23270276f, 0.11895803f, 0.27968037f, 0.03718311f, 0.03430263f, 0.01979531f, 0.23814386f, 
    0.00796703f, 0.01136764f, 0.06399188f, -0.09405440f, 0.24350649f, 0.00815954f, -0.30061334f, -0.21348016f, 
    -0.05681256f, -0.03214580f, 0.02644406f, 0.06165408f, 0.07390785f, -0.02098594f, 0.01753928f, 0.12700942f, 
    -0.04306466f, 0.20492560f, 0.43774724f, -0.05841047f, -0.08801089f, -0.11533162f, 0.13914588f, 0.04536098f, 
    -0.01273687f, -0.06144086f, 0.06085816f, 0.00971596f, 0.14706758f, 0.12753843f, 0.21723844f, -0.23613474f, 
    0.19483802f, -0.04599877f, 0.06926198f, 0.08429184f, -0.09404930f, 0.05840232f, -0.02475716f, -0.08144289f, 
    0.05683075f, -0.06808180f, 0.16021389f, 0.00908560f, 0.00911999f, -0.00503429f, 0.08169577f, -0.01669018f, 
    0.17121807f, 0.01523714f, 0.18099844f, 0.18912762f, 0.06989022f, -0.00009774f, 0.05098336f, 0.20032477f, 
    0.03076649f, -0.00017312f, 0.03201098f, 0.06087093f, -0.05930797f, -0.06027643f, -0.09380645f, -0.02064752f, 
    -0.03120058f, -0.11417873f, 0.05796813f, -0.16941006f, 0.09134752f, -0.14741553f, -0.08244617f, -0.15892498f, 
    -0.07468677f, -0.24225946f, -0.02509502f, -0.22507595f, 0.34465507f, -0.01773806f, -0.14570715f, -0.07520339f, 
    0.03854394f, 0.05867569f, -0.01153153f, -0.14793508f, 0.03650219f, -0.17336202f, -0.03925944f, 0.14293583f, 
    0.08562004f, 0.12827659f, -0.18033469f, -0.28253740f, -0.11648242f, -0.03435497f, -0.07230064f, -0.05239780f, 
    0.11609996f, 0.10299800f, -0.07691417f, 0.09814423f, 0.29217735f, 0.29908544f, 0.17109494f, 0.11883678f, 
    0.01699010f, 0.06542531f, -0.02972240f, 0.04662494f, 0.19314791f, 0.06517967f, -0.10288852f, -0.13490660f, 
    -0.21381468f, -0.13305001f, 0.38654864f, -0.16760729f, 0.21871960f, -0.12664202f, 0.04550136f, -0.15689884f, 
    -0.02656703f, -0.02833278f, 0.09789538f, -0.19635814f, 0.07701474f, -0.05207475f, 0.02598805f, -0.23059760f, 
    -0.03339855f, -0.10303328f, 0.00347108f, 0.13596347f, -0.04982658f, -0.03403023f, -0.10106050f, -0.03193768f, 
    0.21040471f, -0.17244044f, 0.11860357f, -0.21618085f, 0.05439499f, -0.08789729f, -0.06846604f, 0.08253338f, 
    -0.15362814f, -0.10595264f, -0.10287969f, -0.06312605f, -0.03920434f, -0.08795425f, 0.04018092f, -0.12422504f, 
    0.14448565f, -0.09240819f, 0.00091599f, 0.31761554f, -0.12504493f, -0.06451281f, 0.13589159f, -0.06763091f, 
    0.09668948f, -0.00759452f, -0.18265934f, -0.06790280f, -0.02352505f, -0.09308659f, -0.02892504f, 0.02629439f, 
    -0.06874529f, 0.01603515f, 0.05718149f, -0.04838067f, 0.23339041f, 0.08536510f, 0.13045961f, -0.02662275f, 
    0.12585840f, 0.07313578f, 0.04325798f, 0.08638544f, 0.07003685f, -0.00735674f, 0.14878184f, -0.07790628f, 
    0.33432776f, -0.33942091f, 0.22975793f, -0.16815342f, -0.15442349f, 0.03854634f, -0.13881578f, -0.15853214f, 
    0.03504034f, 0.16618599f, 0.00876448f, 0.00257426f, 0.05986144f, 0.05132103f, 0.00600005f, -0.02566568f, 
    0.12068179f, 0.09481019f, -0.03553962f, -0.10705635f, -0.01293522f, -0.00092166f, 0.12201667f, 0.02536233f, 
    0.06071346f, 0.39877504f, -0.22169846f, 0.15970103f, 0.04241082f, 0.13892311f, 0.09695882f, -0.00732939f, 
    -0.01335509f, -0.16803706f, -0.07134505f, -0.07416064f, 0.02732603f, 0.20965450f, 0.12513384f, 0.10941998f, 
    -0.02568264f, 0.08229697f, 0.15055610f, -0.01343129f, 0.01871830f, 0.03080760f, -0.01031226f, 0.00008482f, 
    0.15106912f, -0.08261380f, -0.06642456f, -0.02506186f, 0.02698220f, -0.09388520f, -0.03213602f, 0.10434178f, 
    0.07711283f, 0.02664950f, 0.04961427f, 0.01553067f, 0.00689826f, 0.01347985f, 0.05081647f, -0.03571295f, 
    0.01593010f, -0.02617667f, -0.07585426f, -0.15528728f, 0.01282976f, -0.04735965f, 0.02838028f, 0.03144346f, 
    -0.03407473f, -0.03405756f, 0.01275360f, 0.04178308f, -0.00025993f, -0.01752244f, 0.01964959f, 0.01068561f, 
    0.00079333f, 0.00740601f, -0.02795494f, -0.04075441f, -0.04025294f, 0.01704168f, 0.00655137f, 0.01163213f, 
    -0.01042656f, 0.02537080f, 0.01791022f, 0.00784176f, 0.01538442f, -0.02074457f, -0.03901112f, -0.02878673f, 
    -0.04265383f, -0.02373855f, -0.01855033f, -0.00140636f, 0.00164800f, -0.00356404f, 0.00024373f, 0.00821097f, 
    -0.00728312f, -0.03177524f, 0.00457146f, 0.00466146f, 0.00343889f, -0.02303034f, 0.00891576f, -0.00749462f, 
    0.01091427f, -0.02508841f, -0.02750495f, -0.02222746f, 0.01553108f, 0.01135534f, -0.00552611f, -0.00691992f, 
    -0.00895116f, 0.02001688f, 0.02373232f, -0.01479100f, 0.02878081f, -0.01830430f, 0.02435723f, 0.01960886f, 
    -0.04115979f, 0.02825250f, -0.00503650f, -0.01677814f, -0.00246623f, 0.02180762f, 0.02043975f, 0.02864986f, 
    -0.02160376f, 0.01947768f, -0.02126930f, -0.02407690f, -0.01946031f, -0.01763394f, 0.01347515f, -0.03523310f, 
    0.01185517f, 0.02152639f, 0.02667231f, -0.03732713f, -0.01419731f, -0.02833943f, 0.00199775f, -0.02056639f, 
    -0.02341828f, 0.00481436f, -0.03375590f, 0.02133924f, -0.03161607f, -0.02835342f, 0.02246377f, -0.04132770f, 
    -0.02802359f, -0.00556011f, -0.00954310f, 0.00454746f, -0.02874982f, 0.00459529f, -0.01549074f, -0.01828603f, 
    0.02360667f, -0.00557653f, 0.02208157f, 0.01703361f, 0.01487355f, -0.04149324f, -0.01752379f, 0.02668533f, 
    -0.01575277f, 0.02812786f, -0.02772954f, 0.02700411f, 0.02695026f, 0.01545920f, 0.00512522f, 0.00515191f, 
    -0.00546370f, -0.00730038f, -0.00279215f, -0.00951575f, -0.03570966f, -0.03496637f, -0.02959537f, -0.02395263f, 
    -0.02039249f, -0.03245240f, 0.00959564f, -0.00453953f, 0.01972762f, 0.02831926f, -0.03347593f, -0.03827356f, 
    -0.02706557f, -0.03751121f, 0.00061336f, -0.00897887f, -0.01531979f, 0.00328005f, -0.01710496f, 0.02086730f, 
    0.02423264f, 0.00436334f, -0.00510786f, -0.01087794f, 0.02737466f, -0.01564770f, -0.03320405f, -0.02880075f, 
    -0.01803868f, 0.02713997f, -0.01080662f, -0.02761199f, -0.02883749f, 0.02093360f, 0.03040846f, -0.03938916f, 
    0.02180992f, -0.01252658f, -0.02076838f, -0.00981044f, 0.02790817f, -0.01652495f, -0.03906572f, 0.01276737f, 
    -0.03191246f, -0.02961285f, -0.00385697f, -0.01707434f, -0.04116121f, 0.02758635f, -0.00462814f, 0.02524600f, 
    0.00453864f, -0.02723392f, 0.01494417f, 0.02944874f, -0.03462657f, 0.02752888f, 0.01976276f, -0.00229630f, 
    -0.02276587f, -0.03912979f, 0.01119406f, -0.03691974f, -0.03669066f, 0.02171602f, 0.01493547f, 0.02878211f, 
    0.01926917f, -0.02819483f, -0.00651401f, -0.00395178f, -0.01941273f, -0.03535110f, -0.02834588f, 0.00758749f, 
    0.00916783f, 0.00282137f, -0.00734203f, -0.00665072f, -0.02662612f, -0.03785436f, -0.03453933f, -0.02171599f, 
    -0.00192193f, 0.00373037f, -0.00255270f, -0.04226489f, 0.02339241f, -0.03822392f, 0.01045152f, 0.00346843f, 
    -0.03631189f, -0.03661373f, -0.00836259f, -0.01955449f, 0.02176024f, -0.02057094f, -0.00453383f, 0.02095194f, 
    -0.00802916f, 0.01016418f, 0.03121918f, -0.03767010f, 0.02879344f, 0.00082883f, 0.00513219f, -0.03284499f, 
    0.00288085f, -0.04080838f, 0.01464909f, 0.02458635f, 0.00221506f, 0.00530870f, -0.02958222f, 0.02775530f, 
    0.01519814f, 0.02020600f, -0.01181819f, 0.01579601f, 0.00776391f, 0.01141030f, -0.02208759f, 0.02721175f, 
    -0.02872277f, -0.04059071f, 0.00700580f, 0.00512421f, 0.01133763f, -0.00642582f, 0.02895253f, 0.02851811f, 
    0.01122969f, 0.02011730f, -0.02322378f, 0.00248593f, -0.00884788f, -0.01727995f, 0.00431355f, -0.00067892f, 
    0.01271906f, 0.02446347f, 0.02906805f, 0.01882974f, 0.01219391f, 0.00023371f, 0.00256907f, 0.03067544f, 
    0.02151293f, -0.02152449f, -0.02257189f, -0.01798804f, 0.00197377f, -0.03759152f, 0.01887259f, 0.00171995f, 
    -0.02699281f, -0.01352518f, -0.03649843f, 0.00609860f, 0.00025828f, 0.01618215f, -0.00368091f, 0.02281809f, 
    0.00404876f, -0.02444497f, -0.00689895f, -0.00828820f, -0.03427893f, 0.00304409f, -0.01828958f, -0.00879012f, 
    0.01588781f, 0.01606258f, 0.03041822f, 0.00311571f, 0.01213894f, -0.03272355f, -0.00893234f, -0.01704334f, 
    -0.02702088f, -0.02620819f, -0.00223678f, -0.01326904f, 0.00247125f, -0.01906298f, 0.02778551f, 0.01571000f, 
    -0.00954411f, -0.01359944f, -0.03521593f, 0.01682446f, -0.01948244f, 0.02988445f, -0.03425911f, -0.03132089f, 
    -0.00285415f, 0.01519199f, -0.02247319f, -0.02359981f, -0.02971656f, -0.03488401f, -0.03383649f, -0.03007659f, 
    -0.02872287f, 0.02469854f, 0.02339647f, 0.00536384f, -0.01282923f, -0.01015594f, -0.03862482f, -0.00749539f, 
    -0.00966695f, -0.00560629f, 0.02341990f, -0.01174827f, -0.01241451f, 0.01684867f, -0.03806706f, 0.00002588f, 
    -0.03329121f, -0.03403351f, -0.01743571f, -0.01603888f, -0.03920404f, 0.00533721f, 0.02085125f, -0.02790978f, 
    -0.02787595f, -0.02513512f, -0.01811632f, -0.00174460f, -0.03999415f, 0.02748656f, -0.00408928f, -0.00749978f, 
    0.00869465f, 0.01060040f, -0.01542398f, -0.03660826f, -0.02141622f, -0.03145000f, -0.01004907f, -0.00825000f, 
    -0.02557401f, 0.02722007f, -0.03774571f, -0.01819430f, -0.02992308f, 0.01283638f, -0.03233444f, 0.03077517f, 
    -0.03754874f, -0.01266342f, -0.03188391f, -0.03847443f, -0.00436526f, -0.02011430f, 0.00910620f, -0.02756830f, 
    0.02626656f, -0.02912685f, -0.00846082f, 0.01845722f, 0.00068322f, -0.01941675f, -0.00759488f, 0.00118876f, 
    0.01720658f, -0.01949605f, 0.03083318f, 0.01695006f, 0.02647083f, -0.01801039f, -0.03235554f, -0.00173209f, 
    0.02656947f, -0.01643636f, 0.01030891f, -0.02563114f, 0.00230265f, 0.02105808f, -0.01077795f, 0.01703624f, 
    -0.03811549f, 0.02189155f, -0.00988453f, 0.00573434f, -0.02623191f, 0.03166534f, -0.03751869f, -0.03867614f, 
    -0.02038541f, 0.00886725f, -0.03310730f, 0.02840934f, 0.01088432f, 0.01946446f, 0.02079283f, 0.02151799f, 
    0.00642211f, -0.00967201f, -0.01829547f, -0.03126749f, 0.00165504f, 0.01528025f, -0.02894210f, 0.01633007f, 
    -0.02400210f, -0.00733833f, 0.02529064f, 0.01680745f, -0.03273106f, -0.01633908f, -0.02127310f, -0.02891110f, 
    0.01337329f, -0.00939152f, 0.01893057f, 0.00680104f, 0.01981751f, -0.03177478f, -0.00160215f, -0.00541551f, 
    -0.01470902f, 0.00255918f, 0.03252964f, 0.01866654f, -0.03895792f, -0.01739705f, -0.00777703f, -0.02003375f, 
    0.01764483f, -0.00766974f, -0.03563981f, -0.03364801f, -0.00012645f, -0.01805105f, -0.00111240f, -0.02531760f, 
    -0.00799447f, -0.02685289f, -0.01517644f, -0.02284533f, -0.00243230f, 0.00319031f, 0.01180668f, -0.01058688f, 
    -0.01009627f, -0.00905821f, -0.01611869f, -0.00313685f, -0.01641987f, -0.04158726f, 0.01567321f, 0.00094052f, 
    0.01325841f, 0.00183817f, -0.04323919f, 0.01697507f, 0.01103039f, 0.00221070f, 0.01267545f, -0.01376097f, 
    -0.02308168f, -0.01572051f, 0.02782259f, 0.02517604f, -0.01536951f, 0.01526406f, -0.01537684f, 0.02752699f, 
    -0.02292679f, 0.02082138f, 0.00628758f, -0.03441120f, -0.03559499f, 0.00130382f, -0.00054930f, -0.00706675f, 
    -0.00077661f, -0.02333877f, -0.03799794f, -0.03007417f, -0.00673904f, 0.00868185f, 0.02562223f, 0.02038578f, 
    0.01276776f, -0.02769024f, 0.02640118f, -0.03780764f, -0.02336055f, -0.02587366f, 0.00098191f, 0.00163072f, 
    -0.01518445f, -0.03722450f, -0.00412253f, -0.03583812f, -0.02865868f, 0.01338026f, -0.02339733f, 0.01031771f, 
    -0.03982826f, 0.02227021f, -0.00945482f, -0.00802385f, -0.03859111f, -0.00722407f, 0.01347232f, -0.02484689f, 
    0.01626419f, 0.00035458f, -0.01783888f, -0.01729855f, -0.03767962f, 0.01607004f, 0.02449880f, -0.00945763f, 
    -0.00448185f, 0.01807265f, 0.00498918f, -0.00653718f, -0.03322779f, -0.00365579f, 0.01256531f, 0.00831785f, 
    0.01699625f, -0.01691908f, -0.03804656f, -0.01985217f, 0.02082006f, -0.01681119f, -0.00671875f, 0.02832614f, 
    0.01961819f, 0.02211789f, 0.00501216f, -0.04280398f, 0.02469036f, 0.00086391f, -0.01916915f, -0.01633053f, 
    -0.01980245f, -0.03758495f, 0.01193495f, 0.01413767f, -0.03571161f, -0.03634400f, 0.00750122f, 0.02699366f, 
    0.01239528f, 0.01890691f, -0.01719933f, 0.01490621f, 0.01657106f, 0.00264730f, 0.02049060f, -0.02178214f, 
    -0.03079034f, 0.02883962f, -0.02009986f, -0.00777405f, -0.03056328f, -0.00152991f, 0.01797542f, -0.00318941f, 
    -0.03245837f, 0.02542274f, 0.00937603f, -0.01005905f, 0.02436073f, 0.00615137f, 0.01343441f, -0.00179395f, 
    -0.03360715f, 0.00565466f, -0.00295168f, 0.01768022f, 0.00672082f, -0.00975165f, -0.01487129f, -0.00439476f, 
    0.00929089f, 0.02689840f, -0.01260570f, -0.00555156f, 0.00481561f, -0.03431262f, 0.02305389f, -0.01914872f, 
    -0.02048734f, -0.02721765f, 0.00208616f, 0.02436709f, -0.02782447f, 0.02429258f, -0.00908266f, 0.03271214f, 
    -0.02998088f, -0.02322722f, -0.03773030f, -0.00362277f, 0.00281629f, -0.01329593f, -0.01836612f, 0.01282325f, 
    0.00241720f, -0.00515672f, -0.02540879f, -0.03426393f, 0.02715266f, -0.02953453f, 0.02135725f, -0.02607809f, 
    0.01695283f, -0.03383103f, 0.02870484f, -0.00441668f, -0.01449508f, -0.01071249f, -0.02014506f, -0.00305141f, 
    0.00753672f, 0.01430006f, 0.00967434f, -0.00463946f, 0.00855980f, -0.01739928f, 0.00573182f, -0.01049251f, 
    -0.02309456f, 0.02390891f, -0.00943335f, 0.01936782f, -0.01211693f, -0.03814148f, -0.00921519f, -0.03328949f, 
    0.02942884f, 0.02315132f, -0.03414439f, -0.00012365f, 0.01415478f, 0.02034042f, -0.04085109f, 0.01455638f, 
    -0.01401921f, 0.02127149f, 0.01947406f, 0.00213934f, -0.02265766f, 0.02385112f, -0.02687007f, 0.01658643f, 
    0.00487346f, -0.00838609f, 0.02990845f, -0.01226042f, -0.02887514f, -0.02680470f, -0.03747777f, -0.01663331f, 
    0.02502155f, 0.00089144f, 0.00858633f, 0.00868395f, -0.01644052f, -0.01972773f, 0.00232336f, -0.01714652f, 
    -0.03735831f, -0.00110785f, 0.00294815f, 0.00700086f, 0.01002664f, -0.04237344f, -0.03393204f, -0.00296399f, 
    -0.00169814f, -0.01602599f, 0.02605623f, -0.02475386f, 0.01511108f, 0.00976546f, 0.00425748f, -0.03505425f, 
    -0.03575940f, 0.00439737f, 0.00426041f, -0.04155449f, -0.00231625f, -0.01796224f, -0.01282605f, 0.01903593f, 
    -0.01342877f, 0.01196438f, -0.03648528f, 0.00292267f, -0.02586425f, -0.01366786f, -0.00114482f, -0.00004107f, 
    -0.01395902f, 0.01315142f, 0.02054851f, -0.00855560f, -0.03877216f, -0.03151020f, -0.02770471f, -0.00139883f, 
    -0.02239749f, 0.01731170f, -0.00282109f, -0.01307325f, -0.01917602f, 0.02695826f, 0.02901851f, -0.03175882f, 
    -0.02931552f, -0.04253189f, -0.01468773f, 0.00344038f, -0.03394160f, -0.03681223f, -0.02359392f, -0.02102797f, 
    -0.02500686f, -0.01643399f, -0.04293446f, -0.04341634f, -0.03226821f, -0.03642780f, -0.02949429f, 0.01696120f, 
    0.00141167f, -0.01891849f, -0.00652632f, 0.00457083f, -0.04114300f, -0.03291615f, 0.01923070f, -0.02332535f, 
    0.00767214f, -0.01019824f, 0.02935454f, -0.03382067f, 0.02386540f, -0.00496324f, -0.00490935f, 0.01929417f, 
    0.04820644f, 0.00416954f, 0.21673757f, 0.10855865f, 0.02005484f, 0.08189002f, 0.04142678f, 0.01095920f, 
    0.10083836f, 0.04787526f, 0.00660969f, -0.10426149f, -0.14471819f, 0.42476553f, -0.20521316f, -0.00478901f, 
    0.04532268f, -0.03079123f, 0.04735402f, 0.03651943f, 0.11075698f, 0.05041830f, -0.02212402f, -0.17477435f, 
    0.10767107f, -0.16904014f, -0.10825869f, 0.08088677f, 0.00438180f, 0.00793495f, -0.06766464f, -0.00561355f, 
    0.00048097f, -0.07091294f, -0.00856452f, 0.10393274f, -0.14360116f, -0.09698810f, -0.15792492f, 0.11749686f, 
    -0.10398524f, -0.09287193f, -0.00759635f, -0.10316920f, 0.03001697f, -0.04315030f, 0.10414168f, 0.05682686f, 
    0.11609216f, 0.00813746f, -0.02081214f, 0.19011047f, 0.15559676f, -0.02961787f, -0.01453610f, -0.12861942f, 
    -0.06574491f, -0.04092909f, 0.02465589f, -0.07043698f, -0.14573206f, 0.10351886f, 0.02540936f, -0.01688426f, 
    0.03885249f, 0.02846100f, 0.08931798f, -0.06776872f, -0.04205002f, 0.06351037f, -0.05710316f, -0.29741669f, 
    -0.13705499f, -0.06393529f, -0.04507616f, -0.04969271f, -0.10703276f, -0.01736859f, -0.06297255f, -0.02861488f, 
    0.08228465f, 0.12769625f, -0.03420984f, -0.05928859f, 0.03023770f, -0.02445773f, 0.01764492f, 0.09880449f, 
    -0.06103929f, -0.09647316f, -0.09471808f, -0.00686402f, -0.03945708f, -0.04588195f, -0.02760264f, -0.05077165f, 
    -0.09236597f, -0.02839829f, 0.03683447f, 0.02637574f, 0.21818303f, 0.00638408f, 0.18264420f, 0.08615661f, 
    0.02797843f, 0.02909431f, -0.00627674f, 0.07954780f, 0.09022683f, -0.08096376f, -0.21060199f, 0.08998328f, 
    0.00463981f, -0.13935581f, 0.01892235f, -0.02041027f, -0.09199685f, 0.01890353f, 0.06846662f, 0.02383758f, 
    -0.05025432f, -0.28996617f, 0.09191315f, -0.02768338f, -0.09247002f, 0.11538025f, -0.04806388f, 0.00331774f, 
    0.10180328f, 0.14174543f, -0.06063205f, -0.12682125f, -0.04173281f, 0.10003157f, -0.09021006f, -0.06025104f, 
    0.07631123f, -0.08731344f, -0.01343720f, -0.01492461f, 0.08989688f, 0.08076894f, 0.07248258f, 0.14311729f, 
    -0.38079897f, -0.11185440f, -0.19873533f, -0.06780042f, -0.02982574f, 0.05167050f, 0.05038599f, 0.03016902f, 
    0.00464979f, 0.04039860f, 0.07687955f, 0.03450200f, -0.04881094f, 0.14365919f, -0.08682382f, 0.09826232f, 
    0.02905922f, 0.10118277f, 0.09929047f, -0.15205188f, -0.10665592f, 0.12194385f, 0.04051286f, -0.05084369f, 
    -0.08975470f, -0.15493678f, 0.21814460f, -0.13130750f, -0.27332976f, 0.06433466f, 0.00098302f, 0.03932164f, 
    0.16207744f, 0.10783183f, 0.06391776f, -0.03359395f, -0.22010951f, 0.43899915f, -0.13885728f, 0.06279290f, 
    0.09224215f, 0.05375905f, 0.11438558f, 0.05661429f, 0.07085311f, 0.18552147f, -0.05501699f, -0.10164234f, 
    -0.07391758f, 0.09315282f, 0.03214686f, 0.02101261f, 0.03657860f, 0.11296967f, 0.01410910f, -0.09774213f, 
    0.01042121f, -0.03379295f, 0.09178876f, -0.04842452f, 0.05377227f, 0.08192452f, 0.05732766f, 0.31633016f, 
    0.00469830f, -0.06206821f, -0.01675120f, -0.25763485f, -0.04359929f, 0.01177850f, -0.12114310f, -0.05039976f, 
    0.08285639f, -0.05957700f, 0.34378162f, 0.26311573f, 0.11715095f, 0.11643874f, 0.09094788f, -0.00658887f, 
    0.05745819f, 0.17872226f, -0.17223798f, -0.15548633f, -0.16935201f, 0.14855738f, 0.06293637f, -0.10625443f, 
    -0.01908256f, -0.11875454f, 0.12473246f, 0.07451221f, 0.14002493f, 0.10885186f, 0.03319354f, 0.07902396f, 
    0.01636687f, -0.14184436f, -0.00055807f, 0.22787967f, 0.04514711f, -0.02742315f, -0.21541356f, -0.17011848f, 
    0.11662886f, 0.08453882f, -0.05596063f, 0.06398292f, 0.18857501f, 0.30324951f, 0.19005010f, 0.02620745f, 
    -0.04497055f, -0.15050310f, -0.12410891f, 0.11635973f, -0.11853067f, -0.03573688f, 0.07203286f, 0.20739438f, 
    -0.12169277f, 0.05252892f, -0.09043966f, -0.17207000f, 0.01219753f, -0.06815016f, -0.00078405f, -0.00665582f, 
    0.07287327f, 0.10151369f, 0.01996308f, -0.04886187f, -0.10933562f, 0.04315951f, 0.09276193f, 0.00358969f, 
    0.23921245f, 0.07161637f, 0.09861055f, 0.07229559f, 0.04512690f, -0.03267455f, -0.06771731f, 0.00131469f, 
    0.17595889f, 0.13957392f, 0.03704398f, 0.10519788f, 0.19058359f, 0.09729596f, 0.04711711f, -0.09789033f, 
    -0.00442725f, -0.09276638f, -0.00279017f, 0.11349545f, -0.09431101f, 0.11453139f, -0.06745710f, 0.21392149f, 
    -0.02504797f, 0.12032878f, -0.07748120f, -0.13868295f, 0.02294365f, 0.02933213f, 0.00921630f, 0.06716190f, 
    -0.04411418f, 0.54521042f, 0.17146382f, -0.17735942f, -0.07046526f, 0.09814319f, 0.01897904f, -0.04648503f, 
    0.10894753f, -0.08767019f, 0.07922700f, 0.24731635f, 0.33596194f, -0.21081060f, 0.11516494f, -0.03016906f, 
    0.00316838f, 0.00510620f, -0.00260381f, -0.08752273f, -0.05301075f, 0.01905242f, 0.02758872f, -0.15471195f, 
    -0.03696779f, 0.02723005f, -0.24670771f, 0.17042598f, 0.03533436f, 0.00821874f, 0.04938412f, 0.06540648f, 
    0.06063823f, -0.01891174f, 0.12504105f, -0.19435787f, 0.05840883f, -0.20561239f, -0.08307366f, 0.03721916f, 
    0.34444267f, -0.06305376f, 0.07189287f, 0.19865380f, -0.16711749f, 0.00343081f, 0.04646209f, -0.00173464f, 
    0.11048429f, -0.26936921f, -0.02134596f, 0.05834252f, -0.04839320f, -0.04551267f, 0.00199044f, 0.13980980f, 
    -0.02507149f, 0.04969014f, 0.00439829f, -0.07321103f, -0.36500606f, 0.19057848f, 0.25069165f, -0.30734476f, 
    0.10354923f, 0.07314669f, 0.22835526f, 0.04905107f, 0.03622132f, 0.02887509f, -0.00289163f, 0.15070693f, 
    -0.00462958f, 0.00791760f, -0.10324198f, -0.09899458f, 0.33520627f, 0.19129336f, 0.08336240f, -0.02414385f, 
    -0.01425294f, -0.00196037f, -0.03572724f, 0.03839393f, 0.00606536f, 0.05727281f, 0.00386965f, 0.04853850f, 
    -0.08379055f, -0.02997220f, 0.12468916f, 0.06480430f, -0.07378480f, -0.01915723f, 0.06549054f, -0.05642909f, 
    0.06611998f, 0.07251160f, -0.19273894f, 0.02371175f, 0.08897915f, -0.10557722f, 0.00406731f, -0.04669189f, 
    -0.09264844f, 0.08752290f, -0.06104284f, -0.03882993f, 0.05378938f, 0.10456127f, -0.01405699f, -0.02308140f, 
    0.08705430f, -0.09902250f, 0.00267652f, -0.06027276f, -0.12371159f, -0.11156388f, 0.04487212f, 0.09020694f, 
    -0.38872167f, 0.11244359f, -0.02402894f, -0.25360540f, 0.06630894f, -0.06221883f, 0.13484393f, -0.02527252f, 
    0.05456172f, 0.11075284f, 0.08848134f, 0.12888126f, 0.20354661f, 0.25345153f, -0.09192397f, -0.04133832f, 
    -0.07399943f, -0.03061694f, -0.01045102f, 0.06938358f, 0.01388650f, -0.01573135f, 0.08074681f, 0.06714443f, 
    0.10452643f, -0.15719652f, 0.15247853f, 0.13939698f, 0.06220886f, 0.06914751f, 0.00095205f, 0.03416722f, 
    -0.04137472f, 0.09907980f, -0.06956135f, 0.09557230f, 0.25258312f, 0.04979464f, 0.14760101f, 0.00121274f, 
    -0.04123395f, -0.00334623f, 0.06715234f, 0.06422462f, -0.06464147f, 0.03803120f, 0.06016180f, 0.13205272f, 
    -0.03095610f, -0.13219443f, -0.02691629f, -0.05730969f, -0.10279407f, 0.12821966f, -0.14111248f, -0.02956194f, 
    -0.04002061f, -0.08857413f, 0.16236579f, 0.24721062f, -0.06200965f, -0.11473718f, -0.00968430f, -0.02452007f, 
    0.03595333f, 0.03070684f, -0.03148627f, 0.13148886f, -0.03534127f, -0.00032964f, 0.05182163f, -0.08727966f, 
    0.34934741f, -0.02994912f, 0.13670397f, -0.11178076f, -0.04224828f, 0.18814078f, -0.03381858f, -0.00383858f, 
    -0.08667390f, 0.09276453f, -0.09024663f, 0.01861690f, -0.20869271f, 0.08799279f, -0.05289541f, -0.17244717f, 
    0.14727089f, 0.05090491f, 0.10778624f, 0.01093950f, -0.01632649f, 0.00397320f, -0.11544786f, 0.06070449f, 
    0.22786821f, 0.07231076f, -0.05013320f, -0.02507659f, 0.13780113f, 0.21868752f, 0.03226326f, 0.18008868f, 
    -0.04586019f, -0.02398578f, 0.04595402f, -0.07493360f, 0.10409514f, 0.27350149f, -0.03824147f, 0.29051885f, 
    0.15082008f, 0.12074779f, 0.06142389f, 0.14508034f, -0.04492453f, -0.02294080f, 0.00163611f, 0.07091334f, 
    -0.09392720f, 0.03116131f, -0.10016359f, 0.09160639f, -0.11386912f, -0.01393785f, 0.03921590f, 0.03634899f, 
    0.13540770f, -0.10502499f, -0.03904810f, -0.13615309f, 0.50669211f, -0.20268692f, 0.14629924f, -0.03378789f, 
    0.06745927f, 0.03807702f, 0.01341784f, -0.00236617f, -0.06894795f, 0.02011386f, -0.06118038f, 0.02615944f, 
    0.05302102f, -0.05828446f, 0.09653620f, 0.14587550f, -0.10537236f, 0.04164205f, -0.05949730f, 0.00255367f, 
    0.00397175f, -0.05508215f, -0.02552361f, 0.01484813f, 0.12156219f, -0.27724013f, 0.13138910f, -0.27481624f, 
    -0.12949499f, -0.01356928f, 0.06075764f, 0.11710320f, 0.07304986f, 0.13597544f, -0.17765188f, -0.14446142f, 
    -0.59573364f, -0.00007842f, 0.04367280f, -0.18779761f, 0.07305886f, -0.04592948f, 0.01734130f, 0.11293723f, 
    0.11027659f, 0.13980059f, 0.03677414f, -0.04335006f, 0.04288407f, 0.16811164f, 0.08435743f, -0.07510357f, 
    0.02643254f, 0.10277596f, 0.01354232f, -0.02596916f, 0.04775213f, -0.07120131f, -0.05482432f, -0.01269186f, 
    -0.07429334f, 0.15261728f, -0.16936822f, -0.08340339f, -0.02300778f, 0.23527284f, -0.00175439f, 0.08225518f, 
    0.07001344f, -0.06514530f, -0.23899195f, 0.16577117f, -0.02963371f, 0.21525790f, -0.00920880f, 0.20025271f, 
    0.11579561f, -0.00372096f, 0.13085477f, -0.03587167f, -0.13208517f, -0.00017135f, 0.07731953f, 0.12256107f, 
    0.19184251f, -0.01821436f, -0.06807324f, 0.12592119f, 0.06023730f, 0.05681229f, -0.01995622f, 0.14279331f, 
    -0.02920673f, 0.00899461f, 0.04959361f, 0.06241379f, 0.21685958f, -0.08733083f, -0.09515943f, 0.15414824f, 
    0.12667324f, 0.07491804f, -0.13103393f, 0.04552715f, -0.07091086f, -0.05736061f, -0.03743351f, 0.03977292f, 
    -0.27931151f, -0.10308312f, -0.16742192f, -0.03567607f, -0.07879505f, -0.01218595f, 0.01545321f, -0.02018462f, 
    0.03190326f, -0.02869701f, -0.01098517f, 0.05068805f, 0.16140762f, 0.07879162f, 0.17499390f, 0.03262650f, 
    -0.04949523f, -0.02279854f, 0.13387080f, -0.10391943f, -0.06064501f, -0.00641758f, 0.10872815f, 0.07959554f, 
    -0.14980271f, -0.04767399f, -0.10556258f, 0.25653127f, -0.06744988f, -0.07780119f, -0.02899176f, 0.05432802f, 
    0.16563749f, -0.01561565f, 0.02706158f, 0.09570076f, -0.01417965f, -0.03860686f, -0.11096852f, -0.13038588f, 
    0.03568476f, -0.06496020f, -0.04209968f, -0.04605310f, -0.02785121f, 0.04681966f, 0.06852370f, -0.00306800f, 
    -0.03711755f, -0.28837559f, 0.18480860f, 0.00389761f, 0.02797041f, 0.17176273f, 0.13385452f, 0.04409054f, 
    -0.03101566f, 0.00350451f, -0.04645877f, -0.11734691f, 0.00190138f, 0.05281528f, 0.08246163f, 0.07597061f, 
    0.14768822f, -0.04144084f, 0.06057667f, -0.03465401f, -0.02169164f, -0.12281723f, 0.00262763f, 0.02065565f, 
    -0.01928130f, 0.25676060f, -0.06701730f, -0.04879393f, 0.07459015f, 0.07876655f, 0.07138746f, 0.00210030f, 
    -0.00409499f, -0.01462685f, 0.00049735f, 0.03872026f, -0.03297070f, 0.09892368f, -0.02740934f, 0.21687211f, 
    -0.03525578f, -0.13898189f, 0.03596382f, 0.12950999f, -0.00967193f, -0.13295703f, 0.06646114f, 0.09382148f, 
    -0.01940667f, -0.00731442f, 0.02038633f, -0.03863853f, 0.00077662f, 0.00067246f, -0.01959885f, -0.01863670f, 
    0.01785840f, -0.01745919f, 0.00654399f, 0.02475823f, -0.01309310f, 0.01756578f, -0.00592217f, -0.01594464f, 
    -0.02129419f, -0.00742713f, 0.03928662f, -0.02960285f, -0.01001068f, -0.01163734f, -0.00690914f, -0.01368416f, 
    -0.02493315f, -0.00424712f, -0.02733633f, -0.03016601f, 0.00980679f, -0.01556947f, -0.03668738f, -0.01373296f, 
    0.02900818f, -0.02389931f, 0.01661944f, 0.03028438f, -0.03382882f, -0.00028764f, -0.01179972f, -0.02025898f, 
    -0.02509943f, 0.01944783f, 0.02132956f, -0.03013949f, -0.03607544f, -0.01803835f, 0.00798591f, -0.02923177f, 
    0.03343986f, 0.01304317f, 0.00759614f, -0.03532923f, 0.02144114f, -0.02247010f, -0.01567890f, 0.03413348f, 
    0.02880946f, -0.00290587f, -0.03561310f, -0.01835561f, 0.01234446f, -0.00715414f, -0.00244289f, 0.02383544f, 
    0.01302652f, 0.02598721f, 0.02164779f, 0.01590227f, 0.01846201f, -0.01751586f, -0.02602153f, -0.00282142f, 
    0.00127433f, 0.00131321f, 0.02344039f, -0.01163646f, 0.02103944f, -0.00264611f, -0.02828028f, 0.02284596f, 
    -0.00857331f, 0.02615879f, -0.03963714f, -0.04029680f, 0.00116004f, -0.01984002f, -0.00649935f, 0.02560215f, 
    -0.02134253f, -0.03684462f, -0.00848672f, 0.01962570f, 0.02326520f, 0.00261126f, -0.03677937f, -0.02536730f, 
    0.01884449f, -0.03534373f, 0.00288355f, -0.01120011f, -0.01633729f, -0.02548998f, -0.02602611f, -0.02059854f, 
    -0.03583689f, -0.01610419f, -0.00816017f, -0.04120577f, -0.02172277f, -0.01750027f, -0.01360290f, 0.01173147f, 
    0.00619966f, -0.00390968f, 0.01047908f, -0.03029085f, -0.00928278f, 0.00008364f, -0.01311704f, 0.00831415f, 
    -0.02455185f, 0.01231560f, -0.00929956f, -0.02727673f, -0.03860086f, -0.03158794f, 0.02645342f, -0.00761332f, 
    -0.03912153f, 0.02675321f, 0.02513841f, 0.02018263f, -0.00624803f, 0.01463546f, 0.00822211f, 0.02977289f, 
    -0.02919077f, 0.00755096f, 0.03011260f, -0.02726279f, -0.01212780f, 0.01264946f, -0.00982128f, -0.01036178f, 
    -0.00065317f, -0.02023466f, -0.01543451f, -0.03443640f, -0.01625070f, -0.02992211f, 0.01069579f, -0.02268281f, 
    -0.01305956f, -0.00022480f, -0.02023123f, 0.00766508f, -0.03496633f, -0.01594747f, -0.03625171f, -0.00542596f, 
    -0.03286960f, 0.00538128f, 0.01007610f, -0.00974557f, -0.02618049f, -0.03468235f, -0.01420178f, -0.00766599f, 
    -0.03835898f, -0.00122909f, 0.01210233f, 0.00461683f, 0.01997580f, -0.02851725f, -0.01452155f, 0.02406943f, 
    0.00681055f, -0.02151528f, -0.02472055f, -0.01844913f, 0.01090157f, -0.01030284f, 0.02983766f, -0.00190136f, 
    0.02717940f, 0.02686162f, 0.01621933f, -0.03206290f, -0.00825181f, -0.03512458f, -0.00610939f, 0.01814857f, 
    0.02664940f, 0.02579106f, -0.00546486f, -0.01792853f, -0.00199936f, -0.03317776f, -0.00821854f, 0.00973657f, 
    -0.03356214f, -0.02009817f, -0.01594693f, -0.04016366f, -0.01062869f, -0.01299441f, -0.00745569f, -0.01541537f, 
    -0.01079923f, 0.00460690f, -0.04047301f, -0.04154707f, 0.00757530f, 0.02187374f, -0.01069106f, 0.03085830f, 
    0.03398868f, 0.00719896f, 0.01992011f, -0.03238508f, 0.01907220f, -0.02685835f, -0.00773187f, -0.03102915f, 
    -0.00979055f, -0.00503846f, -0.00692058f, -0.01437007f, -0.00475496f, 0.01284012f, 0.01819932f, -0.01842332f, 
    -0.01728961f, -0.03563235f, 0.01195383f, -0.03005603f, -0.03933486f, -0.01447742f, -0.00003799f, 0.00201907f, 
    0.01823771f, 0.02349153f, -0.00897009f, 0.00922608f, -0.02532081f, -0.00939894f, 0.02126070f, 0.02845849f, 
    0.02004562f, 0.00350389f, -0.00496224f, 0.00177015f, -0.03614597f, -0.01319301f, -0.03236486f, -0.02965050f, 
    0.04115383f, 0.02622469f, 0.00970012f, 0.01934644f, 0.02811700f, -0.00804146f, -0.01284138f, -0.02277412f, 
    -0.00376971f, 0.02914773f, -0.01074247f, 0.01451273f, 0.00622973f, 0.02301287f, -0.01651203f, 0.00395134f, 
    -0.01560505f, -0.03673837f, -0.01663387f, 0.01242859f, -0.01896168f, 0.00515461f, 0.01418584f, -0.00338037f, 
    -0.01542297f, -0.02405726f, -0.01296920f, -0.01704942f, -0.00857472f, -0.03141740f, 0.02177799f, 0.02560339f, 
    -0.02316716f, 0.01498855f, -0.03340413f, 0.00948372f, 0.02743400f, -0.02881597f, -0.01521783f, -0.02835154f, 
    -0.00508989f, -0.02164584f, -0.01763971f, -0.02767480f, -0.01279885f, -0.02480478f, 0.01776488f, -0.00586961f, 
    -0.01373082f, -0.02091767f, 0.00608470f, -0.02194282f, -0.02249804f, -0.00781582f, 0.00750873f, 0.02351297f, 
    -0.02764559f, 0.02715456f, 0.01257778f, -0.01513072f, 0.00135837f, 0.01288305f, -0.00719748f, -0.01871110f, 
    -0.03578587f, 0.01468260f, -0.04144394f, -0.00172542f, 0.01242675f, 0.01517741f, 0.02237213f, -0.00440475f, 
    0.00204466f, -0.02143697f, -0.03661340f, -0.01181174f, -0.02119502f, 0.01154558f, -0.02478206f, -0.00899491f, 
    0.01091999f, 0.00269794f, -0.00142878f, 0.00971929f, 0.02971693f, -0.01856300f, -0.01118902f, -0.01673093f, 
    -0.02079473f, 0.01956084f, 0.01548394f, -0.00984303f, -0.03247508f, -0.01232483f, 0.02048870f, -0.01747590f, 
    -0.00580373f, 0.01971992f, 0.01468978f, -0.03535107f, -0.00998493f, -0.00903758f, 0.01244118f, -0.02752733f, 
    -0.02540375f, -0.02685251f, -0.01162700f, -0.03950127f, -0.02028331f, -0.04009764f, -0.00650050f, -0.02574077f, 
    0.00202596f, 0.00392555f, 0.00138334f, -0.03201101f, -0.02277886f, -0.01475122f, 0.02780495f, 0.02028133f, 
    -0.00188220f, -0.03296028f, -0.00893575f, -0.01044817f, -0.01453975f, 0.01972288f, 0.00115974f, -0.02367698f, 
    0.02220312f, -0.02676637f, -0.01865435f, -0.00801386f, -0.00691750f, -0.03224791f, 0.01925640f, -0.01622639f, 
    -0.01516537f, -0.00495024f, -0.00017531f, 0.02717135f, -0.00379454f, -0.00694240f, 0.00145249f, -0.01864531f, 
    -0.02630415f, -0.00283012f, 0.01916724f, 0.02936075f, 0.02042969f, -0.00914920f, 0.00936414f, 0.01333911f, 
    -0.02908756f, 0.02787645f, -0.02501742f, -0.02077667f, -0.03954912f, 0.02873765f, -0.00280182f, 0.00344757f, 
    -0.01954859f, -0.01574595f, -0.00937400f, 0.02728488f, 0.00413325f, -0.00318537f, 0.02252415f, 0.02451717f, 
    -0.03009631f, 0.01818231f, 0.00203801f, 0.02959179f, -0.02055498f, 0.02637206f, 0.02032232f, -0.02747834f, 
    -0.01507763f, 0.02183183f, 0.01728142f, -0.01140305f, 0.01764216f, 0.02353108f, -0.03559118f, 0.01991381f, 
    0.00097022f, 0.00202764f, -0.00731776f, -0.01590993f, -0.03044700f, -0.02350750f, 0.02935619f, -0.04051541f, 
    0.00477381f, 0.01562934f, -0.01272510f, -0.01975652f, -0.03142008f, -0.00934934f, 0.00574694f, 0.01543838f, 
    -0.03223834f, -0.00198603f, -0.03931114f, -0.02360863f, 0.00790675f, 0.01807811f, -0.03376272f, -0.01816335f, 
    0.01657545f, 0.00983654f, -0.03736349f, 0.01361388f, -0.02445413f, -0.04159928f, -0.02174676f, -0.01962407f, 
    0.00290863f, 0.02258555f, -0.02384356f, 0.00809651f, -0.02213777f, -0.03685902f, -0.00053870f, -0.02080846f, 
    0.00202424f, -0.02542230f, -0.03815908f, -0.02097564f, 0.00946937f, -0.03407494f, -0.02105326f, -0.01955544f, 
    0.02063614f, -0.02661593f, 0.01400204f, 0.00839967f, -0.03826182f, -0.01035321f, 0.00233258f, 0.00295958f, 
    -0.01423523f, 0.01319737f, 0.02041490f, -0.01651240f, 0.03848340f, -0.02897388f, -0.02890095f, 0.02200087f, 
    0.02067015f, -0.03445075f, -0.03282002f, -0.02699994f, -0.00840920f, 0.02967333f, 0.01962083f, -0.00660804f, 
    0.02753660f, -0.03905228f, 0.01393834f, -0.00412461f, -0.00561422f, 0.02163176f, -0.01569460f, -0.03511566f, 
    0.01947301f, -0.03947191f, 0.02162256f, -0.01526944f, 0.01133607f, -0.03871708f, 0.00082712f, 0.01099788f, 
    -0.03738216f, 0.00560054f, 0.02388338f, 0.00122206f, -0.00511497f, 0.02540137f, -0.02925741f, 0.00444190f, 
    0.01283431f, -0.04040559f, 0.02062850f, -0.02803441f, -0.02659292f, -0.04052553f, -0.03630970f, 0.00754796f, 
    0.00037565f, 0.02323936f, -0.03730220f, 0.00938851f, -0.03032220f, 0.00744547f, 0.01352356f, 0.00989277f, 
    -0.00438113f, 0.01991503f, 0.01882285f, -0.01872450f, -0.02425342f, -0.03127055f, 0.00496418f, -0.02823992f, 
    -0.00592932f, -0.03107120f, 0.00069886f, -0.04108413f, 0.00147771f, -0.00004888f, 0.00785585f, -0.02404451f, 
    -0.00077696f, 0.01725890f, 0.01087202f, 0.00879145f, 0.03010084f, -0.00373953f, -0.03233114f, 0.01679081f, 
    0.01392704f, -0.02824646f, 0.01806824f, -0.02853295f, 0.01067959f, 0.00032879f, 0.00530616f, -0.02663850f, 
    -0.02072682f, 0.02205385f, -0.00348527f, 0.01013445f, 0.01176810f, 0.02296725f, -0.00661517f, 0.01499138f, 
    -0.03144185f, -0.03444192f, -0.03805245f, 0.01702734f, -0.01456413f, -0.03740432f, 0.00033388f, 0.00910483f, 
    -0.01534846f, 0.03837383f, -0.01547771f, 0.02219140f, -0.00470468f, -0.03231386f, -0.03105426f, 0.00446634f, 
    -0.00770966f, 0.02574973f, -0.01975887f, 0.03043468f, -0.00846928f, -0.02226495f, -0.04160692f, -0.00461144f, 
    -0.01434527f, 0.00011294f, 0.01312132f, -0.02935304f, 0.01250832f, 0.02457879f, -0.00854810f, -0.01740588f, 
    -0.01661516f, 0.00609409f, 0.00299920f, 0.01003571f, 0.02294587f, 0.02237069f, -0.02987709f, -0.00765365f, 
    -0.01716192f, 0.00903385f, 0.01185321f, -0.00995981f, 0.01368382f, 0.00493305f, 0.02190715f, -0.03394845f, 
    0.03555886f, 0.02752806f, 0.00050324f, 0.02239047f, -0.02824188f, -0.03192898f, 0.02310207f, -0.01351144f, 
    0.01781579f, -0.02364071f, 0.01164358f, -0.01462453f, -0.01742734f, 0.02224514f, 0.02146768f, 0.02564046f, 
    -0.03670951f, -0.02800439f, -0.00209097f, -0.00148148f, 0.02019336f, 0.01630929f, -0.03072409f, 0.01408194f, 
    0.02230728f, -0.03762159f, -0.03952858f, 0.02559823f, 0.01270065f, 0.01806974f, 0.01618438f, 0.02201672f, 
    0.02526019f, 0.03154414f, -0.02246088f, -0.01441921f, 0.00822155f, 0.00884436f, -0.03512232f, 0.00927099f, 
    -0.02069562f, 0.03017740f, 0.00724272f, -0.01536189f, -0.01338552f, 0.01810048f, -0.01316489f, 0.01136257f, 
    0.00861873f, 0.03908919f, -0.00607358f, -0.00967343f, -0.02319490f, 0.02742285f, -0.03002782f, -0.00524719f, 
    -0.02386506f, -0.00403927f, 0.02988403f, -0.03315959f, -0.02126976f, -0.01653358f, -0.03551357f, -0.02178182f, 
    0.00531713f, 0.01129486f, -0.03965886f, 0.01597974f, 0.03767435f, -0.01552908f, -0.00066236f, -0.00437843f, 
    -0.00483747f, 0.00647384f, -0.00429429f, -0.03987714f, -0.00235336f, 0.00717940f, 0.01329018f, 0.00851769f, 
    -0.01634274f, -0.00755664f, -0.01455193f, 0.00742533f, -0.00174921f, -0.01697039f, -0.00549076f, -0.04002132f, 
    0.03602408f, -0.01741945f, 0.01057389f, -0.01671341f, 0.01800572f, 0.01223805f, -0.03208847f, 0.01843128f, 
    -0.01967868f, 0.00274901f, -0.02853777f, -0.02126344f, 0.02675791f, -0.03861382f, -0.01496558f, -0.00123808f, 
    -0.00151453f, -0.03895337f, -0.00921769f, -0.00856512f, -0.03750274f, -0.01572737f, 0.01323652f, -0.00060058f, 
    0.00116531f, -0.04101486f, 0.01945063f, -0.00767928f, 0.00049141f, -0.01943095f, 0.00792040f, -0.02451551f, 
    -0.01192825f, -0.01373406f, 0.02408111f, 0.03315077f, 0.01427922f, -0.01903628f, 0.01344822f, -0.03851246f, 
    0.02458248f, -0.25998631f, 0.08150728f, 0.05455573f, 0.01984531f, 0.10100292f, 0.04807857f, -0.09360230f, 
    0.01811996f, -0.01926436f, 0.07531275f, 0.02344271f, -0.08102242f, 0.23348886f, 0.07734866f, 0.25733131f, 
    0.03542106f, 0.02003612f, -0.02246515f, 0.06680537f, 0.10947791f, 0.06965610f, 0.14516079f, 0.06489093f, 
    0.20058723f, 0.05882450f, 0.03847405f, 0.04505445f, 0.07239766f, 0.02992360f, 0.15255935f, 0.10031106f, 
    0.10228946f, 0.02661554f, -0.00192518f, 0.05886073f, -0.04038521f, 0.01329065f, -0.00442147f, -0.01808620f, 
    -0.02011729f, 0.00083523f, 0.00637503f, -0.04752057f, 0.00827966f, -0.07172202f, 0.03268535f, -0.06794801f, 
    0.20310590f, 0.04938914f, 0.31937981f, 0.12245293f, -0.04768071f, -0.03717072f, 0.12072488f, -0.10186362f, 
    0.05570690f, 0.02120444f, 0.01694855f, -0.00752742f, -0.02897465f, 0.03881266f, 0.14436132f, -0.02095960f, 
    -0.04205418f, -0.01975722f, 0.22257765f, 0.03500718f, -0.06119348f, -0.08690050f, 0.04243489f, 0.01210314f, 
    -0.10358792f, 0.02199712f, 0.00450042f, -0.02948451f, -0.06634554f, -0.04549691f, 0.02671107f, 0.03047759f, 
    0.02992439f, 0.07291503f, 0.12389898f, -0.10609684f, 0.18994373f, 0.07464006f, 0.00568379f, 0.08033578f, 
    -0.15266350f, -0.02248605f, -0.02115053f, -0.00042095f, -0.04030404f, -0.03451340f, -0.02730069f, -0.13031301f, 
    -0.11474013f, -0.35764173f, 0.00977237f, 0.27840391f, 0.01517252f, 0.14898600f, 0.16198747f, -0.05487083f, 
    -0.05941396f, -0.13703214f, -0.06466590f, -0.03803523f, 0.05368778f, 0.17094861f, 0.01106320f, 0.08367831f, 
    0.02211990f, -0.02684605f, 0.08058577f, -0.05050806f, 0.05188622f, 0.16515902f, 0.07293376f, 0.10070893f, 
    0.06750685f, -0.06429484f, -0.13788860f, -0.01556580f, -0.08026113f, 0.00453617f, 0.15691504f, 0.16147865f, 
    -0.06229194f, -0.03498383f, -0.09380599f, -0.01175071f, 0.02564173f, 0.08495171f, 0.02961652f, 0.00142066f, 
    -0.01033740f, -0.00287515f, 0.04640570f, -0.06167423f, 0.10965892f, 0.12232362f, 0.15239127f, 0.01303319f, 
    -0.17805794f, -0.00799223f, 0.01894599f, -0.03093493f, -0.17657965f, -0.05865397f, -0.08856582f, 0.10299318f, 
    0.00158251f, 0.08083380f, 0.07820003f, -0.01448921f, 0.02196218f, 0.12685207f, 0.21556009f, -0.00335787f, 
    0.08690993f, 0.04650339f, 0.04141424f, -0.08472957f, 0.02526286f, 0.03324959f, 0.15483208f, 0.00049919f, 
    0.08714741f, -0.05208270f, -0.04224880f, 0.10360337f, 0.02103838f, 0.15618919f, -0.00753663f, 0.10079314f, 
    0.05822691f, 0.00649892f, 0.11649312f, -0.04348548f, -0.16991876f, 0.02264593f, -0.18743800f, 0.29176193f, 
    0.13231985f, 0.24817377f, 0.01362396f, 0.19512901f, 0.04836214f, 0.04910970f, 0.24316393f, 0.03111856f, 
    -0.01903041f, -0.10560309f, 0.05819496f, -0.02766770f, -0.01622088f, -0.05377924f, 0.10089917f, 0.17823094f, 
    -0.01542279f, 0.03778546f, -0.02005532f, -0.04546636f, -0.08215369f, -0.21521977f, -0.13293426f, 0.09706903f, 
    -0.03859716f, 0.08062664f, 0.00500891f, -0.01828809f, 0.03555705f, -0.03474984f, -0.06026852f, 0.07266561f, 
    -0.11377805f, 0.01192500f, 0.12211396f, 0.04110931f, 0.09148546f, 0.14351672f, 0.25068083f, 0.09102879f, 
    0.01737651f, 0.00829897f, -0.01010274f, 0.07640513f, 0.03147377f, 0.07765119f, 0.13416693f, 0.04564114f, 
    -0.07864982f, 0.12415486f, 0.08796126f, 0.03444507f, 0.06956223f, 0.13123588f, 0.12062855f, 0.11726299f, 
    0.00281042f, 0.01201462f, 0.10242120f, 0.02352920f, 0.04877447f, 0.00151636f, 0.05719165f, -0.04937407f, 
    -0.00893511f, -0.00196447f, 0.01314127f, -0.04206054f, -0.09476593f, 0.07809481f, 0.01890199f, 0.08279851f, 
    0.06582864f, -0.01677643f, 0.17187425f, 0.02245115f, 0.07666381f, 0.00784085f, 0.16538677f, 0.05716839f, 
    0.01400386f, 0.07826310f, 0.07283188f, 0.00901332f, -0.07953212f, 0.00123508f, 0.00756976f, -0.00032687f, 
    0.09725319f, 0.07029779f, 0.12807581f, 0.05584200f, -0.19454767f, -0.08751242f, -0.08404648f, -0.21490261f, 
    -0.13382033f, -0.16976266f, -0.10192255f, -0.00438225f, -0.11910856f, -0.05485974f, -0.05335152f, -0.10225368f, 
    -0.28581175f, -0.18677558f, -0.22525996f, -0.17693546f, -0.04337362f, -0.09999720f, -0.12459601f, -0.02930771f, 
    0.01128018f, 0.04850952f, -0.07683941f, 0.00278039f, -0.21976702f, -0.15455310f, -0.01344330f, -0.13154393f, 
    -0.00904136f, -0.07603402f, 0.01312652f, 0.03866250f, -0.04695860f, 0.02769099f, -0.01159646f, 0.00514522f, 
    -0.20611416f, -0.21932009f, -0.13456145f, 0.13289981f, 0.14820838f, 0.16740964f, 0.10449108f, 0.05317804f, 
    -0.03102110f, 0.06389393f, 0.08210764f, -0.01366291f, 0.25000238f, -0.03518363f, 0.15582839f, -0.01081035f, 
    0.02328312f, 0.07271510f, 0.17491572f, 0.09457904f, 0.01588779f, 0.08699906f, 0.04274775f, 0.07459451f, 
    0.00057851f, 0.08362006f, 0.02359567f, 0.21712111f, -0.02378377f, -0.06325167f, 0.10171582f, 0.06677363f, 
    -0.05748547f, 0.03752094f, -0.04361461f, -0.12292570f, -0.01368608f, -0.00142838f, -0.02453401f, -0.04291588f, 
    0.13144243f, 0.04091502f, 0.22437596f, 0.08701957f, -0.10942823f, -0.09694757f, -0.11422545f, -0.11857209f, 
    0.11846756f, 0.01129081f, -0.03199466f, -0.05542215f, -0.04149598f, -0.04077967f, 0.04225824f, -0.02734899f, 
    0.01306476f, 0.05513483f, 0.05591197f, 0.03429842f, -0.17627138f, 0.11943690f, 0.02859781f, 0.11750550f, 
    0.21422459f, -0.07960983f, 0.00780659f, 0.24864565f, -0.04169122f, 0.09294426f, 0.06316470f, 0.02019473f, 
    -0.24535051f, -0.16533794f, -0.10363486f, -0.16460675f, -0.08479417f, -0.01645744f, 0.05505460f, -0.02717754f, 
    -0.11166741f, -0.15290187f, -0.11512472f, -0.08410250f, -0.04396646f, -0.16360050f, -0.22576013f, -0.11969715f, 
    0.02098809f, 0.03227672f, 0.13799168f, 0.11496088f, 0.03603811f, 0.03693236f, 0.04543266f, -0.01981023f, 
    -0.03070812f, 0.02659344f, -0.10578366f, -0.01373051f, -0.07101487f, -0.04615102f, 0.00137214f, -0.04722816f, 
    0.27969259f, 0.20567788f, 0.07228588f, 0.01726829f, 0.09964674f, 0.19578932f, 0.13476890f, 0.08761454f, 
    -0.06043521f, -0.03098450f, -0.01361593f, -0.04426697f, 0.04702577f, 0.08775964f, 0.00638054f, 0.07819040f, 
    -0.11694974f, 0.07122523f, -0.08668116f, -0.05490527f, 0.01945669f, 0.06600927f, -0.07197285f, 0.05071482f, 
    0.03451603f, 0.02297794f, 0.07891016f, -0.02181153f, 0.08274266f, 0.14910230f, 0.24250412f, 0.03816416f, 
    0.07741784f, 0.16196233f, 0.04330649f, 0.07318295f, 0.14551647f, 0.04323732f, 0.09743056f, 0.18628360f, 
    0.29013330f, 0.10303169f, -0.09377790f, -0.03516738f, 0.06241366f, 0.11445996f, 0.06810291f, -0.03747933f, 
    -0.00112255f, 0.02204474f, -0.00759500f, -0.03964056f, -0.14505245f, -0.31488907f, -0.06765559f, -0.17879464f, 
    0.08232125f, -0.00229813f, 0.12078585f, 0.09647378f, 0.08821672f, 0.03963154f, 0.06087795f, 0.04432176f, 
    0.13019130f, -0.00734468f, 0.00711507f, -0.10867380f, -0.05473359f, 0.09092801f, 0.04295727f, 0.15651639f, 
    0.06847648f, 0.00937578f, -0.06208476f, 0.05396920f, -0.03791006f, -0.00175974f, -0.03906751f, -0.12586972f, 
    -0.10165127f, -0.05150020f, -0.02590768f, 0.06277640f, 0.01714507f, -0.03426697f, -0.06254823f, -0.04634726f, 
    0.05445191f, -0.02624680f, -0.03902844f, -0.08616820f, 0.11419193f, 0.06495733f, 0.11844027f, -0.04051272f, 
    0.04366001f, 0.02812483f, -0.03507904f, 0.04117592f, -0.16746327f, -0.07358886f, -0.22476433f, -0.25952604f, 
    -0.05407999f, -0.09019556f, -0.03488084f, 0.08818958f, 0.01633950f, 0.03992446f, -0.05357075f, 0.03836014f, 
    -0.15568854f, -0.11268832f, -0.13038467f, -0.15152448f, 0.03837913f, 0.11776829f, 0.05305190f, 0.10346526f, 
    -0.00957133f, -0.01043244f, -0.09393979f, -0.03773066f, -0.22525169f, -0.04895569f, -0.26737285f, 0.20915587f, 
    -0.08870543f, 0.09988654f, 0.07876905f, 0.06072161f, -0.07893688f, -0.05441603f, -0.02848255f, 0.04784200f, 
    -0.01689342f, -0.01010229f, -0.01414187f, 0.02949154f, -0.01695497f, 0.05670888f, 0.04069512f, 0.05828009f, 
    0.20238300f, 0.09016386f, 0.08936153f, 0.06017430f, 0.43247914f, 0.18237086f, 0.06096404f, -0.03899784f, 
    -0.06302872f, -0.01584471f, 0.12935656f, -0.03497127f, -0.07057454f, -0.02358549f, -0.03542200f, -0.01973359f, 
    0.14940625f, 0.01357261f, -0.00447175f, 0.06822279f, -0.05127376f, 0.06023649f, 0.00316701f, -0.02141849f, 
    -0.05494123f, 0.01733980f, -0.01076107f, -0.02730682f, 0.28357810f, 0.11020441f, -0.04114047f, -0.14797036f, 
    0.13363343f, 0.06762858f, 0.17946696f, 0.09667438f, 0.11226881f, 0.01881576f, 0.03883347f, -0.00319125f, 
    -0.09795455f, 0.09537815f, 0.14539821f, 0.01497067f, -0.10872250f, -0.08236695f, 0.02385514f, -0.00912733f, 
    -0.00855541f, 0.07448844f, 0.03196341f, -0.04185066f, -0.16464560f, -0.24220529f, 0.01874347f, 0.02720783f, 
    -0.01670150f, -0.07111624f, -0.04733705f, -0.09881510f, -0.07847276f, -0.00333202f, 0.03448035f, 0.00188289f, 
    0.10633613f, 0.09585770f, -0.04612960f, -0.03338309f, 0.07717777f, 0.07329781f, 0.01207270f, 0.29065856f, 
    -0.05101521f, 0.05558410f, 0.06549715f, -0.06916222f, -0.19005224f, -0.11070646f, -0.01239952f, 0.14713024f, 
    0.07018872f, 0.08145819f, 0.01393660f, 0.07392191f, -0.08082498f, -0.00899100f, -0.00278424f, 0.16472852f, 
    0.20255691f, 0.23407371f, 0.01229186f, 0.20380220f, 0.06516729f, 0.19574803f, 0.11925808f, 0.03594168f, 
    0.07088160f, -0.06833349f, 0.19247814f, 0.04875485f, -0.11085633f, -0.26924688f, -0.13279866f, -0.19292064f, 
    -0.14132212f, -0.07503507f, -0.04932009f, 0.09183405f, -0.05048759f, -0.07439813f, -0.06689926f, -0.07846987f, 
    -0.21682820f, 0.13995132f, 0.18209910f, -0.02681248f, -0.05542578f, -0.09324552f, -0.10407059f, -0.00015190f, 
    0.14616075f, 0.18637036f, 0.01354899f, -0.09090652f, -0.21028428f, -0.05509494f, -0.15046296f, -0.05055542f, 
    0.04167260f, 0.03893912f, 0.02313991f, -0.11873041f, 0.05813615f, 0.07481413f, 0.10371772f, 0.02300540f, 
    0.04088281f, 0.16365984f, 0.08706875f, 0.26292545f, -0.04365012f, -0.08282991f, 0.03051068f, -0.00424844f, 
    0.12738690f, 0.18642384f, 0.01100586f, 0.12731890f, -0.03856609f, 0.02853589f, 0.01303821f, -0.04723102f, 
    -0.01890515f, -0.01919456f, -0.00704261f, -0.01522490f, 0.05925217f, 0.03003399f, 0.05286159f, 0.06879006f, 
    0.13816838f, -0.01479033f, 0.12018006f, -0.05235312f, 0.07344508f, 0.06821931f, 0.15262279f, -0.09199572f, 
    0.00394233f, -0.10258885f, 0.00420453f, -0.03833690f, -0.29401076f, -0.32659149f, -0.20957153f, 0.03789688f, 
    0.09254798f, -0.05851634f, 0.16908835f, 0.00516557f, 0.07235897f, 0.00977590f, 0.09099787f, 0.09406306f, 
    -0.19379370f, -0.05122506f, -0.02972287f, 0.00957581f, -0.06572966f, 0.02569762f, -0.00632965f, 0.07452768f, 
    0.07002638f, 0.00516897f, 0.06317484f, -0.04115272f, 0.15317969f, 0.23863886f, 0.15488832f, 0.13125728f, 
    -0.04075841f, -0.05618946f, -0.03548193f, -0.00674766f, 0.08522250f, 0.10370614f, 0.09527811f, 0.18526968f, 
    0.03209327f, 0.01602851f, -0.03051853f, -0.03155826f, 0.01067035f, -0.03473163f, 0.01029795f, 0.01406648f, 
    0.01647415f, -0.02723481f, 0.00581936f, -0.01974475f, -0.04530494f, -0.02469810f, 0.01370887f, -0.00052114f, 
    -0.03734115f, 0.02909574f, -0.02110263f, -0.03317072f, -0.00860471f, 0.02653697f, -0.04204481f, -0.02557270f, 
    -0.01515560f, 0.01317593f, -0.03768921f, -0.03534066f, 0.00048393f, 0.01260349f, 0.01661932f, -0.00233671f, 
    -0.02790852f, -0.02640039f, 0.00794287f, -0.02669115f, 0.03426045f, 0.02580939f, 0.00747291f, 0.01380922f, 
    -0.02164157f, -0.01191341f, -0.00331457f, -0.03106348f, -0.03255675f, -0.03446557f, -0.03679888f, 0.01225204f, 
    -0.00116169f, -0.03765049f, -0.01313470f, 0.01488352f, 0.02882304f, -0.03102636f, 0.00296990f, -0.00799836f, 
    -0.02351087f, -0.02056323f, 0.00353217f, 0.02754198f, 0.02556789f, -0.01841949f, 0.02381704f, 0.03190353f, 
    -0.00111963f, -0.03543383f, -0.00407413f, 0.00025562f, -0.02443673f, -0.00621619f, -0.02843803f, -0.02026541f, 
    -0.03725880f, -0.01988318f, -0.02294598f, -0.01926564f, 0.02882843f, -0.02118752f, -0.01429172f, 0.02833496f, 
    0.02950036f, -0.03452193f, -0.03037808f, -0.04142844f, -0.01944752f, 0.02973543f, 0.02432249f, -0.01258302f, 
    -0.01671985f, 0.03089970f, 0.01881459f, 0.02772029f, -0.02179983f, 0.01966128f, -0.02786789f, -0.01239645f, 
    0.03201833f, -0.00085161f, -0.03670174f, 0.00321638f, -0.00619201f, -0.02339398f, 0.00302653f, -0.02598458f, 
    0.03091125f, -0.03013223f, -0.03262477f, -0.03580207f, -0.00592822f, -0.01099174f, -0.01614950f, 0.02498230f, 
    0.02507277f, 0.01349529f, -0.02349185f, -0.02987383f, -0.03427729f, 0.00762053f, 0.01334464f, -0.00064277f, 
    -0.02622819f, 0.01799130f, 0.02299532f, -0.01146982f, -0.00772101f, 0.00244294f, -0.02308225f, 0.02160758f, 
    -0.02236433f, 0.01171639f, -0.03818233f, -0.01816982f, 0.02871042f, 0.01635235f, -0.03071842f, 0.02433083f, 
    0.01730782f, -0.03363751f, -0.01471029f, -0.02786509f, -0.03559636f, 0.01470485f, -0.01331554f, 0.01775727f, 
    -0.01289175f, -0.03474222f, 0.02168262f, 0.02655965f, 0.02730730f, -0.00125801f, 0.00671597f, -0.03782142f, 
    0.00286109f, 0.02004604f, -0.03876884f, 0.00672609f, 0.01415857f, -0.02669946f, 0.01441951f, 0.02679688f, 
    -0.03850099f, 0.02406413f, 0.02106633f, -0.03024965f, 0.02900001f, 0.03092251f, 0.01026895f, -0.02468649f, 
    -0.00658127f, -0.03220978f, -0.00622489f, -0.03131775f, 0.01506196f, 0.02614127f, 0.02611010f, 0.00402375f, 
    -0.01808019f, 0.02678930f, 0.02667035f, 0.01746651f, 0.00321611f, 0.02441090f, 0.01206676f, 0.02768274f, 
    -0.02656886f, -0.02999351f, 0.03175994f, -0.02793628f, 0.02253484f, -0.00764274f, -0.00970873f, 0.03384468f, 
    0.00660323f, -0.02783754f, -0.03921480f, -0.00814974f, 0.00964734f, -0.00258179f, 0.01618469f, -0.02398486f, 
    -0.03405971f, -0.03339566f, -0.02455767f, -0.04014668f, -0.01042560f, 0.02854288f, -0.01996914f, 0.03195624f, 
    -0.00239574f, -0.03796596f, 0.02473940f, 0.00431494f, -0.01639062f, 0.01272927f, 0.02153764f, 0.00436816f, 
    -0.02281091f, -0.03514542f, -0.01730833f, 0.02878123f, 0.00513512f, 0.02316089f, 0.00442852f, 0.03336072f, 
    -0.00329651f, -0.00230540f, -0.00014187f, 0.02247321f, -0.01059721f, -0.02535862f, -0.03669308f, -0.02895624f, 
    0.01267080f, -0.02191906f, -0.01258812f, -0.03771564f, -0.02204376f, 0.02167858f, -0.03702876f, 0.02627035f, 
    0.01369015f, 0.03267235f, 0.03028558f, 0.00174464f, -0.02937218f, 0.02208563f, 0.01156914f, -0.01859233f, 
    -0.00418520f, 0.00605310f, -0.00988718f, 0.01628466f, -0.01970139f, 0.01801854f, 0.02545383f, -0.00911193f, 
    0.00323705f, 0.01722464f, 0.00361459f, 0.01054347f, 0.01893203f, -0.01476215f, -0.04577085f, 0.01298304f, 
    -0.02640672f, 0.02257277f, 0.02350476f, -0.03363175f, 0.03037922f, -0.02138112f, 0.02839868f, 0.00594699f, 
    0.03285312f, -0.03517846f, -0.03491561f, 0.01373649f, 0.02827559f, 0.00144627f, -0.00852368f, -0.02880279f, 
    -0.00248341f, -0.00972189f, 0.00400583f, 0.02531982f, 0.02677483f, -0.00127814f, 0.01533546f, -0.03044820f, 
    0.01401421f, 0.00819470f, -0.03550629f, 0.00905964f, 0.01527185f, -0.01489893f, 0.03354716f, 0.01015729f, 
    -0.02433157f, -0.01026214f, -0.01435617f, 0.01067586f, -0.01677678f, -0.02968123f, -0.04202107f, -0.02780493f, 
    -0.01936856f, -0.03047782f, -0.01694573f, -0.00661455f, -0.01898018f, 0.02197567f, -0.01997626f, 0.01714715f, 
    -0.00732754f, 0.00391339f, 0.00942090f, 0.03422381f, 0.03048516f, 0.00385210f, 0.02036194f, -0.00409363f, 
    -0.00389782f, 0.00422934f, -0.02648712f, 0.00929669f, 0.00586782f, -0.02392332f, 0.00913866f, 0.01156719f, 
    0.01744897f, -0.02029181f, -0.03090031f, 0.03131632f, -0.01877720f, 0.02240587f, -0.01949907f, -0.02432530f, 
    -0.03879889f, -0.01969371f, 0.00520544f, 0.01148797f, 0.01443436f, -0.01281553f, 0.01843268f, 0.01458172f, 
    0.00256850f, 0.00626673f, -0.03693215f, 0.02061849f, -0.00292274f, -0.03287852f, 0.00710047f, 0.01958972f, 
    0.01678209f, 0.00645395f, -0.03654017f, 0.01679999f, 0.02293583f, -0.02226295f, 0.01705597f, 0.00218827f, 
    0.02725422f, -0.03160818f, -0.02476426f, 0.02443640f, -0.00299103f, -0.01247063f, -0.00731272f, 0.00241085f, 
    -0.01263071f, 0.01347021f, -0.00626223f, 0.01425709f, -0.00471983f, 0.02412117f, 0.02576045f, 0.01809775f, 
    0.02866295f, 0.01764178f, -0.01508725f, 0.02850087f, -0.03003544f, 0.01725697f, -0.01900396f, -0.00564254f, 
    -0.01908647f, 0.00639272f, 0.01771532f, -0.00461317f, 0.00833699f, 0.00278144f, 0.01324681f, -0.00051745f, 
    -0.01614927f, 0.00077304f, 0.01891094f, 0.02950938f, -0.00328355f, 0.00713685f, 0.02771631f, 0.00796275f, 
    -0.03245313f, -0.03335204f, -0.02492349f, 0.00483592f, 0.02855240f, -0.02412530f, -0.03545043f, 0.01492661f, 
    0.02057778f, -0.01057949f, -0.02837292f, 0.00289769f, 0.01509402f, 0.02621032f, -0.00887462f, -0.00611210f, 
    0.02085464f, -0.00419463f, -0.01061402f, -0.02084243f, 0.02527798f, 0.02645789f, -0.03381152f, -0.03328123f, 
    -0.01370617f, -0.01223041f, -0.03285009f, -0.00002761f, 0.02171269f, -0.03254596f, -0.00713906f, -0.03855217f, 
    -0.02929277f, -0.02757950f, 0.01851670f, 0.01752681f, 0.03462632f, -0.03315623f, 0.00463918f, 0.01626097f, 
    0.01536387f, -0.03113627f, 0.01275807f, 0.00299692f, 0.00393900f, 0.00279023f, -0.00438944f, -0.00975685f, 
    -0.02533361f, -0.00660924f, -0.03824424f, 0.01615267f, -0.01703653f, -0.02119480f, 0.00344019f, -0.02482265f, 
    0.01732107f, 0.03280861f, 0.01361423f, 0.02492003f, 0.01545799f, -0.04129279f, -0.02212828f, 0.00086748f, 
    -0.01729229f, 0.01550082f, -0.03880359f, 0.01133771f, -0.00790975f, 0.00485883f, 0.02339295f, -0.02021533f, 
    0.01385689f, -0.01684117f, -0.00582208f, -0.01958234f, -0.03021585f, -0.03897159f, -0.04530158f, -0.02354123f, 
    -0.03168011f, 0.00846604f, -0.02766260f, -0.01244225f, -0.04033715f, -0.00847122f, -0.00149249f, -0.02569428f, 
    0.03115426f, 0.03348697f, 0.00586373f, 0.01166241f, -0.00685534f, -0.01624925f, 0.00450062f, -0.00925825f, 
    0.01376118f, 0.01914771f, -0.00643777f, 0.01837604f, -0.02238631f, -0.01528018f, -0.03548877f, -0.01072329f, 
    -0.01808323f, -0.00501980f, -0.01369392f, -0.01510584f, -0.02011645f, 0.01006550f, -0.03239828f, 0.00184207f, 
    -0.03973693f, 0.02630015f, 0.01382447f, 0.01157178f, -0.01346593f, 0.01594502f, 0.02368244f, -0.02642772f, 
    -0.02267504f, -0.02708517f, 0.02171681f, 0.03439534f, 0.00747698f, -0.03466876f, 0.01297669f, -0.00268789f, 
    0.03110935f, -0.00842244f, -0.01472864f, -0.00162516f, 0.02167716f, -0.00134881f, -0.02333454f, -0.01593814f, 
    -0.01972036f, 0.00518690f, -0.00930326f, -0.02857806f, 0.02539267f, -0.01124007f, -0.02014831f, 0.02153395f, 
    -0.00400747f, -0.04134882f, 0.02312372f, 0.00226202f, -0.02526015f, 0.01692421f, 0.03032912f, 0.01324313f, 
    -0.00497333f, 0.00932749f, -0.03379610f, -0.03141233f, 0.01620620f, -0.03140171f, -0.03833252f, -0.02226290f, 
    -0.02752919f, 0.02685490f, -0.02218734f, -0.00852702f, -0.02376294f, -0.03249481f, 0.02783420f, 0.02568307f, 
    0.02944579f, 0.01898664f, -0.01775815f, -0.01408422f, -0.00920820f, 0.01106131f, -0.04000627f, 0.02933977f, 
    0.02623809f, -0.02832271f, -0.02573881f, -0.02324568f, 0.01603288f, 0.01715660f, -0.03691574f, 0.03001924f, 
    -0.00674599f, -0.01163173f, -0.02745521f, 0.01242493f, -0.01021861f, 0.02979080f, -0.02811727f, -0.00506586f, 
    0.02439023f, 0.00601641f, -0.01441238f, -0.02521101f, -0.01082829f, 0.01650210f, -0.01250614f, 0.02295347f, 
    -0.03500452f, -0.03908802f, -0.00189394f, -0.03751504f, 0.00571749f, 0.00167378f, 0.00842003f, 0.00495997f, 
    -0.02189172f, -0.01603843f, 0.01023628f, 0.02568777f, -0.02762979f, 0.02569744f, -0.00064243f, 0.02080111f, 
    0.01520719f, -0.01598920f, -0.02506506f, 0.00028272f, -0.03744430f, 0.01828421f, 0.00080439f, -0.02481521f, 
    0.00576366f, 0.02080077f, -0.03493653f, -0.01684907f, 0.00214692f, -0.04019270f, 0.00275706f, -0.00616846f, 
    0.01902813f, 0.00517466f, -0.01111150f, -0.02900979f, 0.02079959f, -0.02244363f, 0.02570529f, -0.02293584f, 
    0.00150947f, -0.03470309f, 0.00153412f, -0.01763441f, 0.00946735f, -0.01932304f, -0.00388087f, -0.01937308f, 
    0.02357910f, -0.00358065f, -0.00106130f, -0.01264184f, 0.02574632f, -0.02692481f, 0.00104591f, -0.02427035f, 
    -0.00564436f, -0.01105316f, -0.01478824f, -0.03761151f, -0.03226451f, 0.01111494f, -0.02884715f, -0.00818133f, 
    0.03356529f, 0.01618577f, -0.00365651f, 0.03061268f, -0.03375711f, -0.03187289f, -0.00941053f, 0.00011845f, 
    -0.01426430f, 0.01424035f, -0.02926207f, 0.03529283f, -0.00851754f, 0.02589780f, -0.01018775f, -0.02489697f, 
    0.02473418f, -0.03436442f, 0.00174706f, -0.00661469f, 0.01675872f, -0.00411241f, -0.02304918f, -0.01613171f, 
    0.01681368f, -0.01268679f, -0.02878926f, -0.04287307f, 0.00890060f, -0.00877751f, 0.02900793f, -0.00538738f, 
    0.03043932f, 0.00284598f, -0.03453735f, -0.02549926f, 0.03047443f, 0.02113538f, -0.00878140f, 0.02021590f, 
    -0.03660991f, -0.02574068f, 0.00161950f, -0.02403457f, -0.02678686f, 0.01931011f, -0.00660739f, 0.00110623f, 
    0.00494917f, -0.00777833f, -0.01207555f, -0.01550852f, -0.00205776f, -0.04018613f, 0.01016661f, -0.00926403f, 
    -0.00973483f, 0.01238989f, -0.02692268f, 0.00555645f, 0.02990904f, -0.03568177f, -0.02101302f, 0.01583181f, 
    0.02147115f, 0.02724196f, -0.00353458f, 0.02774356f, -0.00606827f, 0.03395785f, 0.02601328f, -0.02812288f, 
    0.00538540f, -0.01490482f, -0.00830945f, -0.02569143f, -0.01322140f, 0.02926079f, -0.01456589f, 0.00847633f, 
    -0.03274009f, -0.01591380f, -0.01298147f, 0.00751885f, 0.01515992f, -0.01728570f, 0.02538697f, -0.00641798f, 
    -0.04003996f, -0.00698431f, -0.03631422f, 0.00835978f, 0.02389158f, -0.03061455f, -0.02970389f, -0.01180941f, 
    0.03356971f, -0.02090069f, 0.02556138f, 0.02775750f, -0.00579366f, -0.02606054f, -0.03362677f, -0.04034787f, 
    -0.02457155f, -0.02900295f, 0.01611241f, 0.03039359f, -0.02597615f, -0.03657717f, 0.02209940f, -0.01226195f, 
    -0.00312756f, -0.04005551f, -0.03713350f, 0.02130639f, -0.03832156f, 0.01791877f, -0.03856172f, 0.02166223f, 
    0.02553536f, -0.03459513f, -0.00576053f, -0.03314822f, -0.00671044f, 0.00631683f, -0.02575140f, -0.02966828f, 
    0.02020493f, -0.02608957f, -0.02896799f, 0.00704519f, 0.00657785f, -0.00780857f, 0.02120049f, 0.00573427f, 
    -0.01246843f, -0.01532393f, 0.01366070f, 0.02737528f, 0.02269053f, 0.00391962f, 0.00890187f, 0.00541907f, 
    0.00727217f, 0.01727098f, -0.03154390f, -0.00858636f, -0.01843624f, 0.01076532f, -0.00054523f, -0.00386663f, 
    0.02090767f, 0.02386239f, -0.01133456f, -0.01755613f, 0.00184975f, 0.02164354f, -0.03075797f, -0.00836356f, 
    0.01364755f, -0.00257763f, -0.03754612f, -0.04161398f, 0.00556750f, -0.00827387f, 0.02398275f, 0.01959700f, 
    0.00724129f, -0.01435957f, -0.00251982f, -0.03083140f, 0.01032899f, 0.02218232f, -0.00119198f, -0.03758036f, 
    -0.02594568f, -0.02980276f, 0.01929651f, 0.00124678f, 0.00539647f, 0.02984652f, 0.01928421f, -0.01922808f, 
    -0.00415457f, 0.02084974f, 0.01059945f, -0.01877580f, 0.02101557f, -0.03722224f, -0.01456803f, 0.00351959f, 
    -0.02854979f, 0.02524616f, 0.00497446f, -0.01224941f, -0.02894306f, -0.02852282f, -0.00488823f, -0.02969017f, 
    0.01413172f, 0.01253091f, -0.00959076f, -0.00973611f, -0.00639979f, 0.02633247f, -0.04021840f, -0.01785735f, 
    -0.00713592f, -0.01852852f, 0.02666452f, -0.02438686f, -0.00136889f, -0.02110722f, -0.01133453f, -0.02900095f, 
    -0.00038477f, -0.03017292f, -0.04056454f, 0.02195722f, -0.03132837f, -0.00739375f, -0.02570393f, 0.00306101f, 
    0.01229465f, -0.03673781f, -0.01178234f, -0.02581405f, -0.03676035f, 0.00548175f, 0.01910644f, 0.00025909f, 
    -0.01849798f, 0.01630218f, 0.02303398f, 0.00818014f, 0.02580022f, -0.00205938f, 0.01177698f, -0.03314003f, 
    -0.01705149f, 0.00356312f, -0.02933878f, -0.03131044f, 0.00978910f, -0.04177471f, 0.02368868f, -0.01036883f, 
    -0.00403353f, 0.00485078f, -0.02120272f, -0.04028498f, 0.01235613f, -0.00512703f, 0.01790116f, -0.00395861f, 
    -0.02862640f, -0.01960001f, -0.02628848f, -0.03781553f, 0.00107263f, -0.03411682f, 0.02971474f, -0.00795238f, 
    -0.02133714f, -0.03228459f, 0.00701131f, -0.01962653f, -0.02773977f, -0.01312978f, -0.02150096f, -0.03771731f, 
    -0.00562596f, -0.02558983f, 0.01413528f, 0.02502682f, -0.03940567f, -0.01877935f, -0.03195363f, -0.01016868f, 
    0.00289986f, 0.01256166f, -0.02878894f, -0.02509782f, 0.00343732f, 0.01772313f, 0.02569724f, -0.00326767f, 
    -0.00247302f, 0.01806654f, 0.02071252f, 0.02204906f, -0.03203939f, -0.03529840f, -0.04108754f, -0.02094165f, 
    -0.00519765f, -0.03874336f, 0.02439682f, 0.00244791f, -0.02715775f, 0.02084325f, 0.02058369f, 0.00217237f, 
    0.00445521f, -0.02231586f, 0.02796809f, -0.01105780f, -0.00403836f, 0.00595043f, -0.00630444f, -0.01456327f, 
    0.01265431f, -0.02414163f, -0.00188268f, -0.01752224f, -0.00057705f, 0.00921967f, -0.01145088f, -0.00027180f, 
    0.00497211f, 0.00591893f, 0.02974174f, -0.02915078f, -0.03015008f, -0.04136990f, -0.03558206f, 0.00347230f, 
    -0.04131720f, -0.00303581f, -0.02985038f, -0.03779409f, 0.02628534f, -0.03474636f, -0.02355947f, -0.03699540f, 
    0.00441350f, -0.01005937f, -0.03097544f, -0.01864222f, -0.01364653f, -0.03935447f, -0.01269220f, -0.03096233f, 
    -0.02938354f, 0.00376564f, 0.02244163f, 0.01794350f, -0.03318723f, 0.02368457f, 0.00585522f, -0.02367096f, 
    0.02645850f, 0.01950011f, 0.00128074f, -0.04120878f, -0.03657264f, 0.01894611f, 0.00844591f, 0.02190430f, 
    0.00871402f, 0.02182239f, -0.01265825f, -0.03358613f, -0.00343590f, 0.01458402f, 0.02728377f, 0.02574579f, 
    -0.03559618f, -0.01986063f, 0.01911787f, -0.03593738f, 0.02997333f, -0.02336968f, 0.01405601f, -0.00933886f, 
    -0.01401377f, 0.02069921f, -0.00611773f, -0.01706532f, 0.00127291f, 0.01271221f, -0.01258558f, 0.03408174f, 
    -0.01694081f, 0.02999417f, 0.03513738f, 0.00602332f, 0.00476069f, 0.01335634f, -0.00360415f, -0.02833908f, 
    -0.01996955f, 0.01590162f, 0.01053258f, 0.02424726f, 0.01735102f, 0.02058325f, 0.00393987f, 0.01704915f, 
    0.01832681f, 0.00391847f, 0.01270107f, 0.01337803f, -0.01491613f, -0.00518202f, 0.03235926f, 0.02628696f, 
    -0.00312340f, -0.01848364f, -0.01815979f, 0.04188953f, 0.00087458f, -0.03907327f, 0.03359607f, 0.00682955f, 
    -0.02053349f, 0.01887939f, -0.02771802f, -0.03520597f, 0.02261099f, 0.03672040f, -0.00693787f, 0.04226919f, 
    0.00512271f, -0.00362807f, -0.00342553f, 0.00974733f, 0.00965486f, 0.01602572f, -0.01405257f, 0.01721802f, 
    0.01922010f, 0.01585416f, -0.00363481f, -0.00079210f, -0.02003673f, -0.03824184f, 0.02741338f, 0.00235657f, 
    -0.02688113f, 0.01654443f, 0.02754346f, 0.01766546f, -0.01227725f, -0.02958468f, 0.01250392f, -0.03172279f, 
    0.01731003f, -0.03149199f, 0.00456464f, 0.00206951f, -0.01104072f, -0.00805986f, -0.01146590f, -0.01226518f, 
    -0.02156671f, -0.03640230f, -0.00172402f, 0.02351028f, -0.02330824f, 0.01782579f, -0.01981987f, -0.03519934f, 
    -0.00490869f, 0.00003593f, 0.02630222f, -0.00432060f, 0.01533936f, 0.01985299f, -0.03925938f, 0.00031522f, 
    0.01510861f, 0.01475358f, -0.02684544f, 0.00280591f, 0.01821557f, 0.02741036f, 0.00140161f, 0.01374851f, 
    -0.00011148f, 0.00637250f, 0.00827282f, -0.01858262f, -0.03454253f, 0.02774037f, -0.02910856f, -0.00590464f, 
    0.01843948f, 0.02351087f, -0.01797189f, 0.04159292f, 0.04208313f, -0.03233329f, -0.02424418f, -0.03379377f, 
    -0.04094869f, -0.02982521f, -0.01584331f, 0.02594311f, -0.02988265f, -0.00737675f, -0.00286486f, 0.01334885f, 
    0.00297018f, -0.01584657f, -0.02100127f, 0.01964717f, 0.01450571f, 0.00706055f, -0.00145553f, -0.02332006f, 
    -0.03446952f, -0.02743421f, -0.03906498f, -0.02036810f, 0.01727760f, -0.01248351f, -0.02187106f, -0.00491244f, 
    0.00615496f, -0.00887289f, 0.00974810f, 0.02213783f, 0.00550886f, -0.02723035f, -0.01066427f, -0.00476494f, 
    -0.03616215f, -0.03446017f, -0.01278676f, -0.00501255f, 0.02015840f, -0.02496201f, 0.00953600f, 0.01724282f, 
    0.00853337f, -0.00409179f, 0.00338189f, 0.02272801f, -0.01717200f, 0.02856158f, -0.01660656f, 0.02067541f, 
    -0.02531240f, -0.04086436f, -0.01728806f, -0.02806634f, -0.02442596f, -0.03827847f, -0.02863243f, -0.00277495f, 
    -0.01958362f, 0.02881005f, -0.01604151f, 0.00064231f, -0.02362209f, -0.00272215f, 0.00690457f, 0.02395071f, 
    0.01199476f, -0.00787111f, 0.02897293f, -0.02922414f, -0.00962269f, 0.02587217f, -0.01059460f, -0.02315562f, 
    0.00981231f, 0.00946895f, -0.01318359f, -0.02924829f, -0.00895224f, 0.03018524f, -0.02542225f, -0.00565105f, 
    -0.00197512f, -0.01999619f, 0.01781419f, 0.00906243f, 0.02834778f, 0.00257834f, 0.03877206f, -0.03549887f, 
    -0.00771664f, 0.02223453f, -0.02271862f, -0.03244198f, -0.00785838f, -0.00200261f, 0.01164938f, -0.03073891f, 
    -0.03109093f, 0.02108000f, -0.00636989f, 0.02033414f, 0.01932349f, 0.03699004f, 0.03469605f, 0.02126451f, 
    0.01230942f, 0.03432414f, 0.02944225f, -0.02664987f, -0.00914734f, 0.01979634f, -0.03394793f, -0.01207237f, 
    0.01939612f, 0.01889236f, 0.00068607f, -0.01360049f, 0.00821912f, 0.02407617f, 0.02134819f, -0.00840469f, 
    -0.03373990f, 0.02005926f, -0.00453076f, 0.00083175f, -0.03321072f, 0.01642185f, 0.00669657f, 0.01396736f, 
    0.02948615f, -0.01610514f, 0.02641917f, -0.03943011f, -0.00958149f, -0.00994768f, -0.01003926f, -0.00957788f, 
    -0.00333007f, 0.01137142f, -0.01015063f, 0.03654569f, 0.03885229f, -0.00693192f, 0.02578254f, -0.01469281f, 
    -0.02709056f, 0.03065896f, 0.00032387f, -0.01644368f, -0.00020285f, 0.03990304f, -0.03998620f, 0.00697202f, 
    -0.01368297f, -0.03249543f, -0.02153719f, -0.00698166f, -0.03608031f, 0.01215007f, -0.03981395f, -0.01340936f, 
    0.02577694f, -0.03084991f, -0.02653044f, -0.01377837f, -0.00810779f, -0.00132402f, 0.00780862f, -0.03723253f, 
    -0.04151338f, 0.01984936f, 0.02087609f, 0.01362474f, -0.03502367f, -0.00780876f, -0.03553795f, -0.02873778f, 
    0.00618080f, -0.01044055f, -0.00720802f, -0.01546496f, -0.02439189f, 0.00879849f, -0.02032118f, 0.00894367f, 
    0.01353223f, 0.00994543f, -0.00117396f, -0.04169768f, 0.00886605f, -0.01753902f, -0.02237248f, -0.00371877f, 
    0.00431105f, 0.01348136f, 0.01150535f, 0.01523869f, 0.00563963f, 0.03294866f, -0.02043304f, 0.03341121f, 
    0.01458827f, -0.02240916f, 0.04145172f, -0.00443582f, 0.00278388f, -0.01535222f, -0.01343059f, -0.01063240f, 
    0.02439990f, -0.02474205f, 0.02901740f, -0.02614626f, -0.03969927f, -0.02370500f, -0.03110719f, 0.00272996f, 
    0.02625207f, -0.00897392f, 0.00140689f, 0.02014071f, -0.02809683f, 0.02932752f, 0.00479393f, 0.02678546f, 
    -0.00914178f, 0.01022065f, 0.00044965f, -0.01781014f, -0.00999117f, -0.02267049f, 0.02565508f, 0.03322678f, 
    0.01063776f, -0.02946663f, 0.00642929f, -0.01979633f, 0.01273819f, -0.01165777f, 0.01515811f, -0.00172268f, 
    -0.00516840f, -0.01418309f, -0.03454930f, -0.04051453f, 0.02460762f, -0.02890927f, 0.00449786f, -0.01630702f, 
    0.01195937f, -0.02768315f, -0.03499459f, -0.02113090f, -0.01907610f, -0.02663798f, -0.01663901f, -0.01949301f, 
    0.02355405f, 0.02270043f, 0.00966868f, 0.01791629f, -0.01407968f, 0.01804353f, 0.01780258f, -0.01508264f, 
    -0.02040663f, 0.00569874f, -0.03923716f, -0.01544444f, 0.01527262f, 0.02554247f, -0.00647047f, -0.01181953f, 
    -0.02736073f, 0.02797383f, -0.01499566f, -0.00657290f, -0.01453719f, -0.03823646f, -0.00915947f, -0.02482827f, 
    -0.01669367f, -0.01025352f, -0.01214908f, -0.01361686f, 0.01103967f, 0.00797968f, 0.00534209f, 0.00365605f, 
    0.02821577f, 0.01984796f, 0.00469314f, 0.01816032f, 0.00203266f, -0.03007962f, -0.03731677f, 0.01298216f, 
    -0.02323447f, 0.00823529f, -0.02976187f, -0.02432813f, -0.01449821f, 0.03163516f, 0.01257080f, 0.02970215f, 
    0.02128164f, -0.00509949f, -0.00676646f, -0.04145144f, -0.02688304f, 0.02942221f, 0.01577667f, -0.03733511f, 
    0.00487904f, 0.02534555f, 0.00901366f, -0.02399066f, 0.02117694f, -0.01463414f, 0.02610882f, -0.00217776f, 
    -0.04182430f, -0.01888020f, -0.02098146f, 0.00961588f, 0.02751651f, -0.02953609f, -0.02993349f, -0.04091338f, 
    0.00380894f, -0.02255682f, -0.03611694f, -0.01242493f, -0.00559155f, -0.03367976f, -0.04171965f, -0.00471879f, 
    0.00769716f, 0.02889950f, -0.01262830f, -0.01424701f, -0.00043412f, -0.03179068f, -0.03772901f, 0.02254294f, 
    -0.01998014f, 0.01778953f, -0.02898166f, -0.00839890f, -0.03589708f, -0.01108975f, 0.01423851f, 0.02645844f, 
    0.00788854f, 0.02053659f, 0.02366301f, -0.01681555f, 0.01405133f, 0.03317570f, 0.03470418f, -0.02025203f, 
    0.02205795f, 0.03098028f, -0.00296244f, -0.02118988f, 0.01583379f, 0.02591458f, -0.03121805f, 0.01784954f, 
    0.02777392f, 0.00780564f, 0.02034209f, -0.03374138f, -0.01114120f, -0.03858853f, 0.00940666f, -0.03699340f, 
    0.11523785f, 0.13847353f, -0.13406153f, -0.11587316f, -0.10051616f, -0.07120350f, -0.06936046f, -0.07277981f, 
    -0.01082332f, -0.05498164f, 0.07795729f, -0.00105132f, 0.79973376f, -0.11051229f, -0.09439147f, 0.10678876f, 
    -0.05698344f, -0.01077298f, 0.07236958f, 0.10723037f, -0.06853275f, 0.00258693f, -0.00756915f, 0.00213857f, 
    0.14815272f, 0.00246088f, 0.12656587f, 0.06109571f, 0.06538397f, 0.05865724f, -0.17846645f, 0.10279948f, 
    -0.04156471f, -0.01200225f, 0.08585333f, -0.00298188f, -0.05906118f, 0.07793429f, 0.04074837f, 0.04846637f, 
    -0.07215410f, -0.04954938f, -0.00542758f, -0.04201365f, -0.06592529f, 0.06583486f, 0.00852471f, -0.05457253f, 
    0.47506762f, 0.20361862f, 0.10474718f, 0.13258164f, -0.00467540f, 0.01596417f, -0.04016747f, 0.03190600f, 
    0.03386990f, -0.10991038f, 0.06264465f, -0.01817218f, 0.21331710f, 0.04511279f, -0.06694619f, -0.05288250f, 
    -0.05122516f, -0.03589862f, -0.09826116f, 0.03835299f, -0.08104251f, -0.02063398f, -0.07329186f, -0.07050119f, 
    -0.16101038f, 0.04267842f, 0.02604249f, -0.00313180f, -0.09705867f, 0.01614176f, 0.01192695f, 0.09396092f, 
    0.06546652f, -0.00172081f, 0.07289243f, -0.04952772f, 0.19277459f, 0.21003515f, 0.11291474f, 0.12065320f, 
    0.00706239f, -0.00278481f, -0.02465597f, 0.00885837f, 0.05147828f, 0.06635572f, 0.06617512f, 0.00339878f, 
    -0.01922300f, -0.02308723f, 0.08706536f, 0.03155384f, -0.13580485f, 0.05317137f, -0.06748699f, 0.00344035f, 
    -0.06835064f, -0.07556976f, 0.04599928f, 0.00310927f, 0.03470499f, -0.00002055f, 0.12032104f, -0.03913987f, 
    0.00258542f, 0.02537100f, 0.09420179f, -0.02917139f, -0.11486678f, -0.05817788f, 0.05749344f, 0.04481304f, 
    0.11276048f, 0.11717161f, 0.08152508f, -0.05088246f, 0.10165215f, -0.00110045f, -0.11492647f, 0.05031016f, 
    -0.09830299f, -0.00218372f, -0.05112120f, 0.03214004f, 0.06927798f, 0.04048170f, 0.07269398f, 0.12849693f, 
    -0.07772831f, 0.05557085f, 0.00387465f, 0.03726292f, 0.08803532f, 0.01383589f, 0.06734666f, -0.06568347f, 
    -0.14671417f, -0.09981656f, -0.22064443f, -0.29355302f, -0.01251047f, 0.01347233f, 0.00823559f, -0.12990141f, 
    -0.01537585f, -0.11238207f, -0.07491474f, -0.15667088f, 0.07601978f, -0.16079086f, -0.01801744f, -0.04511856f, 
    0.05615288f, 0.06585623f, 0.12640005f, 0.04676178f, 0.01640128f, 0.11313268f, 0.01848345f, -0.05066226f, 
    -0.34626707f, -0.02548334f, 0.00389680f, 0.08726294f, -0.05553759f, -0.03895207f, 0.00499201f, 0.11452897f, 
    -0.07356764f, 0.04160693f, 0.11032856f, -0.08672857f, 0.01532930f, 0.15111832f, -0.11068227f, 0.02634818f, 
    -0.09918909f, 0.08581484f, 0.19813538f, -0.00647493f, 0.05815055f, 0.12416913f, -0.04129003f, -0.12140656f, 
    0.28957114f, 0.02784637f, -0.03378833f, 0.06005403f, -0.00711361f, 0.00249495f, 0.03878892f, 0.09750745f, 
    -0.01702248f, 0.03074374f, -0.01202279f, 0.06720304f, 0.26860204f, 0.12030097f, 0.02381899f, -0.19856955f, 
    -0.05975686f, -0.12844945f, -0.04992636f, -0.02414569f, -0.02893259f, -0.03170107f, 0.05136609f, 0.03302208f, 
    -0.15058245f, -0.13079862f, 0.32591861f, -0.13931942f, 0.08616922f, -0.17887826f, 0.06665921f, 0.17737979f, 
    0.01922653f, -0.12469197f, 0.03003683f, 0.05772638f, -0.12035743f, 0.05045894f, 0.01632723f, 0.12407221f, 
    0.01201373f, 0.11189536f, 0.01026582f, 0.14973792f, 0.06211340f, -0.19929327f, -0.00928817f, 0.00355656f, 
    0.04989249f, 0.01346290f, 0.06503130f, 0.05946825f, -0.00278087f, -0.07433150f, 0.03043664f, -0.03902433f, 
    -0.00074037f, -0.02928239f, 0.02002411f, 0.04197826f, -0.11405213f, -0.31045213f, 0.19255464f, 0.03683028f, 
    0.02371250f, 0.17499332f, 0.10016820f, -0.07688314f, 0.10654059f, -0.14419913f, 0.03516501f, 0.07266238f, 
    0.01867357f, -0.03017039f, 0.04314626f, 0.07072654f, -0.00912596f, -0.04134624f, -0.05470483f, 0.08229834f, 
    0.03784424f, 0.08807811f, 0.05438274f, 0.06105079f, 0.02888133f, 0.13643222f, 0.19216351f, 0.07801997f, 
    -0.01195471f, -0.03562078f, -0.00132742f, 0.10691521f, -0.05773263f, 0.05055849f, 0.01193250f, 0.01737878f, 
    0.10116815f, 0.10536830f, 0.15199931f, 0.02865432f, -0.03199288f, -0.10019786f, -0.09378763f, -0.07262716f, 
    0.06076284f, -0.01403291f, 0.07406119f, 0.05815469f, 0.14201103f, -0.04296851f, 0.01744450f, -0.08843087f, 
    0.04985018f, 0.06733942f, 0.06244659f, 0.06782818f, 0.04751009f, -0.00869669f, -0.05439397f, -0.02260459f, 
    -0.00196641f, -0.16790158f, 0.07106130f, -0.00448202f, -0.15025182f, -0.12266302f, 0.12535599f, 0.00451745f, 
    0.00723820f, -0.00879140f, 0.05996314f, -0.01869046f, 0.43082297f, -0.12284452f, 0.20436707f, -0.04172145f, 
    -0.00351710f, -0.08393081f, -0.06123170f, -0.10214847f, -0.11387020f, 0.07339189f, 0.12684232f, -0.01267944f, 
    0.18221600f, -0.09700147f, -0.12046853f, -0.13941713f, 0.00011424f, -0.02772220f, -0.00300947f, 0.14163134f, 
    0.08219317f, -0.03424242f, 0.16524911f, -0.03840284f, -0.23012426f, -0.04505629f, 0.07308836f, -0.13215625f, 
    -0.06485428f, 0.04674671f, -0.06358807f, -0.03583337f, -0.09500387f, -0.07859292f, -0.01634609f, -0.07783351f, 
    -0.08180884f, -0.26481116f, 0.06270904f, -0.13035053f, -0.02616807f, 0.11988333f, 0.00456262f, 0.13308115f, 
    0.06727196f, -0.02635040f, 0.00305267f, -0.13602212f, 0.16632371f, 0.14985830f, -0.06082297f, 0.25762007f, 
    0.02152471f, -0.18145354f, 0.07579251f, 0.04652453f, 0.06463376f, 0.00247547f, 0.10920607f, -0.05213176f, 
    -0.06823408f, 0.13729864f, 0.17843466f, -0.17524713f, -0.06897007f, 0.00579664f, -0.20795514f, -0.01623286f, 
    -0.07032681f, -0.03001050f, 0.05332395f, -0.03378503f, 0.08680753f, 0.17972560f, 0.13802621f, 0.02532688f, 
    -0.04424381f, 0.01652791f, -0.05491439f, -0.10147832f, -0.05031758f, -0.06287004f, -0.07050855f, -0.08206759f, 
    0.09952504f, 0.07744048f, 0.06534898f, 0.09445138f, 0.02255326f, 0.03605448f, -0.05517450f, -0.00078474f, 
    -0.07725669f, -0.15136434f, -0.06565775f, -0.02964899f, 0.08848320f, 0.12643784f, 0.02256527f, 0.02853820f, 
    -0.00574887f, -0.01892273f, 0.00276119f, 0.03293588f, 0.08053825f, -0.03770500f, 0.06561571f, 0.07576434f, 
    0.14793943f, -0.16855836f, -0.07541935f, -0.03390401f, -0.10590638f, -0.03688091f, 0.10863944f, 0.01316253f, 
    0.08586244f, 0.03539472f, 0.03398269f, -0.07747930f, -0.00983640f, -0.28766838f, 0.14076212f, -0.04149089f, 
    0.02551646f, -0.06433363f, 0.09976253f, -0.04294770f, 0.00599910f, 0.05394437f, 0.02960318f, 0.14593653f, 
    -0.11180168f, 0.18951395f, 0.01092014f, -0.19008553f, -0.02441077f, -0.04456739f, 0.08523973f, 0.00545136f, 
    -0.02376800f, 0.03874411f, -0.02927383f, 0.06502841f, -0.06334949f, -0.03478075f, 0.11368271f, 0.00067022f, 
    -0.01596691f, 0.04762701f, -0.05535441f, -0.06118370f, 0.02585368f, 0.12769733f, -0.01173259f, 0.05426001f, 
    0.14485568f, 0.00121002f, -0.03273942f, -0.04003776f, 0.07078839f, 0.02093128f, 0.01583906f, 0.07764026f, 
    0.16136891f, 0.09515776f, -0.06664293f, 0.02276845f, -0.03145344f, 0.03353416f, -0.12926495f, -0.20657355f, 
    0.00825157f, 0.09653558f, 0.08594871f, 0.10722049f, 0.03284459f, -0.13293946f, 0.01750070f, -0.14210574f, 
    -0.10512600f, -0.02436799f, 0.13034883f, -0.11261193f, -0.06063326f, -0.13103655f, 0.17210111f, -0.09036937f, 
    0.00270263f, -0.11475205f, -0.03059042f, -0.03683496f, 0.14386229f, 0.17734043f, 0.14778228f, 0.06019890f, 
    0.03244854f, -0.00987627f, -0.01269524f, -0.04722910f, 0.09645895f, 0.00729032f, 0.01586872f, -0.03554277f, 
    0.05410621f, 0.01296987f, 0.14960457f, 0.10791403f, -0.08045515f, -0.05737947f, -0.08467446f, -0.03639141f, 
    0.12233795f, 0.01651111f, -0.03954349f, 0.02241057f, 0.13671246f, -0.01121675f, 0.15493730f, -0.17582932f, 
    -0.02693868f, -0.06897224f, 0.01779293f, 0.02130087f, -0.02039497f, 0.00494091f, 0.06719149f, 0.06272662f, 
    -0.03522619f, 0.19563524f, -0.00538411f, -0.07177810f, 0.05678526f, 0.00500871f, 0.09453196f, 0.14067923f, 
    -0.09015453f, -0.06877273f, 0.04615380f, -0.07674299f, 0.27431488f, 0.09006895f, 0.35392424f, -0.20359632f, 
    -0.05459182f, -0.09169652f, 0.05192189f, -0.01508107f, -0.02468697f, 0.00718756f, 0.05497159f, 0.06093425f, 
    -0.00459052f, 0.22629651f, 0.03990230f, 0.12715876f, -0.02967943f, -0.03967399f, -0.01900649f, -0.02050078f, 
    0.01534553f, 0.04988356f, 0.05195622f, 0.09616693f, -0.65249401f, -0.01099911f, 0.15183711f, -0.23432438f, 
    0.10034571f, 0.01358394f, -0.00098570f, -0.00286429f, -0.09298552f, 0.01661659f, -0.09137466f, -0.01311751f, 
    -0.06234978f, -0.04728249f, -0.24693607f, -0.15450114f, -0.04864547f, -0.05032260f, 0.04131725f, 0.18480861f, 
    -0.14650093f, -0.07934059f, -0.06571814f, -0.10568340f, -0.28946689f, 0.08054767f, 0.21585940f, 0.14430283f, 
    -0.05405982f, -0.03760793f, 0.05093494f, 0.13427825f, 0.03296335f, -0.02170620f, 0.00134546f, 0.05412624f, 
    0.33236787f, 0.10081027f, -0.33024296f, 0.07187744f, -0.11051131f, 0.16262636f, -0.06650101f, 0.18244384f, 
    -0.02667986f, 0.06815980f, -0.01405250f, 0.04747162f, -0.00568640f, -0.03785015f, 0.08011022f, 0.08561218f, 
    0.00850087f, 0.07699687f, -0.01854757f, 0.04481905f, 0.10007886f, -0.02276600f, -0.05375242f, 0.02776162f, 
    0.07996141f, 0.03242427f, 0.03006569f, 0.05980929f, -0.02785336f, 0.01919114f, 0.18086040f, -0.03985902f, 
    -0.00503535f, -0.03089545f, 0.01407535f, 0.05478228f, -0.03340469f, 0.16992462f, 0.20353882f, 0.03610772f, 
    -0.01003131f, 0.08992369f, 0.09658974f, 0.10471351f, 0.01399136f, -0.00049041f, -0.00489989f, 0.00353160f, 
    -0.13400833f, -0.28297684f, -0.20662108f, -0.11753687f, -0.04641265f, 0.02030090f, 0.06689307f, 0.00150489f, 
    0.12595046f, -0.04360855f, 0.03182665f, -0.06164575f, 0.07008843f, 0.22079124f, 0.17505768f, 0.03282332f, 
    0.06257767f, 0.03283587f, -0.10402640f, -0.08985816f, 0.02671511f, 0.07838132f, 0.00248756f, 0.08783628f, 
    -0.11537632f, 0.19113494f, -0.06115984f, 0.08047904f, -0.07272609f, 0.03699340f, 0.02570328f, 0.04362170f, 
    0.20813696f, -0.00416578f, -0.11049096f, -0.07177515f, 0.17103483f, 0.08972726f, 0.02934206f, 0.07619355f, 
    -0.07689824f, -0.05205091f, -0.02443194f, 0.01629483f, 0.02834057f, -0.01485540f, 0.02603949f, 0.00955987f, 
    0.01160650f, 0.07192394f, 0.04091759f, 0.00472182f, -0.08753650f, -0.05099857f, 0.01695756f, -0.09292340f, 
    -0.10213614f, 0.01816809f, 0.08064634f, -0.04811173f, 0.04473085f, 0.05501256f, -0.02132828f, 0.10168081f, 
    -0.15845105f, -0.11973193f, -0.03284317f, 0.05033217f, 0.06561063f, 0.03040711f, 0.01443936f, 0.03814179f, 
    0.02019371f, 0.12189820f, -0.01166140f, 0.00310053f, -0.08796837f, 0.03383387f, 0.02927842f, 0.01411702f, 
    0.09181902f, 0.00908394f, -0.10286351f, -0.06101607f, 0.09959590f, 0.04018667f, -0.04783082f, 0.16512215f, 
    0.01537040f, 0.04586919f, 0.06220036f, 0.05497096f, 0.07037870f, 0.11955848f, 0.11468125f, -0.08435904f, 
    0.08811806f, 0.15520607f, -0.16705717f, -0.09511190f, 0.10777277f, 0.02572914f, 0.02028385f, 0.07676505f, 
    -0.05212690f, -0.02747604f, 0.02809955f, -0.02538618f, 0.42940411f, -0.26013568f, 0.04759156f, -0.15543638f, 
    -0.06727944f, -0.05661396f, -0.08938827f, 0.03328022f, -0.01844439f, 0.04157383f, 0.02065546f, 0.17743760f, 
    -0.10814437f, -0.13337518f, 0.01918774f, -0.05211508f, -0.02593368f, 0.06031713f, -0.01557478f, 0.06779695f, 
    0.09512322f, -0.00497555f, 0.09003182f, -0.01039344f, 0.02993727f, -0.03048695f, -0.10683560f, -0.05041461f, 
    0.01226869f, -0.08168244f, -0.04061095f, -0.01585125f, -0.06173544f, 0.06165544f, -0.13857870f, -0.06920214f, 
    -0.02457001f, -0.23413989f, -0.37175116f, -0.28459787f, -0.03848109f, -0.01516254f, -0.17517065f, 0.02955493f, 
    0.03097302f, 0.03495776f, -0.05753411f, -0.02936921f, -0.03754681f, -0.27394289f, -0.40588206f, -0.19469665f, 
    0.00043690f, -0.18241110f, -0.02108625f, -0.00047745f, 0.06853695f, 0.04058055f, -0.12390328f, 0.09618610f, 
    0.19385275f, 0.11639666f, 0.12344596f, 0.02760835f, -0.00151913f, 0.02059139f, -0.00405562f, 0.01115912f, 
    -0.11449398f, -0.30070800f, -0.12154608f, -0.13162750f, -0.39481917f, -0.36768231f, -0.12319268f, -0.14826968f, 
    -0.00191351f, 0.04215840f, 0.00799833f, -0.00327122f, 0.09080604f, 0.00104326f, 0.03529003f, 0.21904425f, 
    0.04143635f, 0.19958718f, 0.11321634f, -0.04187597f, -0.00766529f, -0.02998363f, 0.01952317f, 0.18334465f, 
    0.11461069f, 0.09860558f, 0.08087996f, 0.05993816f, -0.00648000f, -0.03397085f, 0.14057621f, -0.14608677f, 
    -0.10808199f, 0.06953751f, -0.04443431f, 0.01041436f, 0.14509007f, -0.10590173f, 0.14373773f, 0.18746647f, 
    -0.23918554f, 0.11259994f, -0.27379161f, -0.31281912f, 0.03179974f, 0.02061925f, -0.04053156f, -0.15540639f, 
    -0.15578075f, -0.09222864f, 0.07751742f, 0.02840526f, -0.06059673f, -0.20652741f, -0.09551142f, -0.05705414f, 
    -0.07241505f, 0.03075513f, -0.04424639f, 0.06404379f, -0.06094131f, 0.03779704f, -0.05635060f, 0.10600095f, 
    0.23550658f, 0.31772262f, 0.20740981f, 0.04554267f, -0.07820348f, -0.07194504f, 0.04274716f, -0.10597364f, 
    0.04261263f, 0.00073218f, -0.05377586f, -0.07870505f, 0.10387974f, 0.13069522f, 0.07386139f, 0.07445095f, 
    0.07818205f, -0.11080492f, 0.08370160f, 0.10238872f, 0.12524061f, 0.10678229f, -0.21358715f, 0.02185861f, 
    -0.50855052f, 0.14397427f, 0.03004443f, 0.20745578f, 0.12732960f, -0.05269827f, 0.04336256f, -0.10403044f, 
    -0.08153015f, -0.09239189f, 0.08805649f, 0.01936020f, -0.05802455f, -0.15258445f, 0.38944131f, -0.14437923f, 
    -0.00520641f, -0.06415017f, 0.07517597f, 0.06933021f, 0.05298276f, 0.04978586f, -0.19907723f, 0.00788864f, 
    0.27324915f, 0.09266579f, 0.00881892f, -0.02313948f, 0.04555844f, 0.03226717f, 0.05358528f, 0.01515497f, 
    -0.09829339f, 0.03217201f, -0.02939991f, -0.08334234f, 0.17130284f, 0.09776630f, 0.03027093f, -0.26291367f, 
    0.06703639f, -0.00443910f, -0.02933295f, 0.08024696f, 0.09166113f, 0.05744884f, 0.10805115f, -0.02027162f, 
    -0.14486259f, -0.03159614f, -0.08210617f, -0.14514844f, 0.06476418f, 0.04609631f, -0.05703263f, 0.10644428f, 
    0.05222612f, -0.02752563f, 0.15749137f, 0.02788119f, 0.02691731f, -0.30139354f, -0.02570236f, 0.00816032f, 
    0.11943971f, -0.09946346f, -0.09180712f, 0.04524266f, -0.02377447f, -0.10003496f, 0.10017000f, -0.00787297f, 
    -0.04688516f, 0.00362750f, -0.07649612f, -0.23276092f, 0.00448801f, 0.05656984f, 0.06944527f, 0.10034341f, 
    0.02579180f, -0.11751091f, -0.08880634f, -0.14676100f, -0.02013090f, -0.40546528f, 0.28059813f, -0.09156121f, 
    0.08510769f, 0.18465556f, -0.00049846f, -0.02045563f, 0.13751972f, -0.09165594f, 0.00695105f, 0.00105669f, 
    -0.02141304f, -0.18269266f, -0.11933248f, 0.06254780f, 0.04124600f, -0.13636279f, -0.04475386f, -0.02433131f, 
    0.04127145f, 0.06440338f, -0.03358186f, 0.16586672f, 0.16727729f, 0.18457709f, 0.24833322f, 0.10108459f, 
    -0.03479113f, 0.08295482f, -0.00529525f, 0.09363802f, 0.02167134f, -0.00292248f, 0.07035556f, 0.03947473f, 
    0.06901181f, 0.10492960f, 0.06772288f, 0.00402191f, -0.04953877f, 0.03815192f, -0.07630739f, 0.05815552f, 
    0.08682371f, 0.00065383f, 0.08189649f, -0.02787819f, 0.13240379f, 0.15505747f, 0.10976557f, -0.08457965f, 
    0.01583871f, 0.07841092f, 0.12807763f, 0.03137156f, 0.02837694f, -0.12820776f, -0.11042181f, -0.21386506f, 
    0.03671140f, -0.12213199f, 0.21843565f, 0.00231134f, 0.04023837f, -0.00975430f, 0.07000142f, 0.00866492f, 
    0.03462381f, 0.03577004f, 0.02058474f, 0.03434682f, 0.01723610f, 0.01397796f, -0.15016580f, -0.09332661f, 
    0.04428634f, 0.15014897f, 0.01782353f, 0.12308436f, 0.04300297f, -0.09826628f, 0.04457905f, -0.01921590f, 
    0.35005197f, 0.03892041f, 0.07115479f, -0.29040909f, 0.04825388f, -0.01686442f, -0.13871272f, 0.02337676f, 
    0.02050336f, -0.01978775f, 0.06158128f, 0.18103331f, -0.24223308f, 0.10002193f, 0.16308612f, -0.10177924f, 
    -0.14564811f, 0.12960684f, -0.13810724f, -0.07007790f, 0.16128619f, -0.10585845f, 0.05117199f, -0.01324284f, 
    -0.06373484f, -0.04364071f, -0.00644922f, -0.10622379f, -0.07642948f, 0.06225650f, -0.00296440f, -0.03397302f, 
    0.17819440f, -0.05340732f, 0.07998125f, 0.14886017f, 0.13978486f, 0.09941747f, 0.05886171f, 0.19553408f, 
    -0.01431612f, -0.05047067f, -0.01374293f, 0.03339231f, 0.13468905f, -0.06443579f, 0.02248008f, -0.09825610f, 
    0.11830527f, 0.15223110f, 0.22523992f, 0.02661119f, -0.11525453f, -0.01785998f, -0.04559144f, 0.07437394f, 
    0.09524436f, 0.06240686f, 0.11233351f, 0.05822740f, 0.02105208f, 0.08267070f, 0.15107153f, 0.00238218f, 
    0.02515077f, 0.00854534f, -0.08621452f, -0.01298843f, 0.01221146f, 0.02226260f, -0.09419648f, 0.01501334f, 
    -0.11774186f, -0.18423590f, 0.10077918f, -0.16906852f, 0.03509670f, 0.04434146f, -0.12664701f, -0.08047980f, 
    -0.00695631f, -0.17312478f, -0.01353725f, 0.13064542f, -0.10409081f, -0.13235974f, -0.23166457f, 0.05583797f, 
    0.04340786f, -0.05295005f, -0.02508879f, -0.05110884f, 0.04902522f, -0.05254199f, -0.11522727f, -0.06063488f, 
    0.26261604f, -0.05622196f, 0.18748122f, 0.23234819f, 0.03041468f, -0.11379458f, 0.09625117f, 0.00218635f, 
    0.15373836f, -0.10998174f, -0.05376381f, -0.02736217f, -0.06618782f, -0.33089846f, 0.10122960f, -0.00873319f, 
    0.08720213f, -0.04325634f, 0.06000556f, 0.06941771f, 0.06297544f, 0.02474624f, 0.00422482f, 0.07073932f, 
    -0.57318527f, -0.07679306f, -0.12306762f, -0.07260701f, 0.06668288f, -0.00591833f, 0.02494679f, -0.07611943f, 
    -0.02500267f, -0.07642721f, -0.03383318f, -0.02668038f, -0.02993083f, 0.10271405f, 0.09914337f, 0.07238421f, 
    0.05732470f, 0.13467619f, 0.03693086f, -0.11377310f, 0.06427096f, -0.07612118f, -0.04365750f, 0.11741354f, 
    -0.15107271f, -0.05574604f, -0.12944213f, 0.06382190f, 0.24301572f, 0.08797771f, 0.06982382f, -0.02011486f, 
    0.04030566f, 0.03538961f, -0.07779154f, -0.11581644f, 0.09841829f, 0.21886666f, 0.06570468f, 0.09757686f, 
    0.00049030f, 0.04894510f, 0.10103215f, -0.01950501f, 0.12877427f, -0.06625833f, 0.00571356f, 0.05087929f, 
    -0.08760423f, 0.15360382f, -0.00055984f, 0.06274503f, -0.01203964f, -0.05671300f, 0.01637550f, -0.06113851f, 
    -0.05207724f, -0.13513897f, -0.02440905f, 0.07059409f, 0.16186973f, 0.17619780f, 0.20833641f, 0.11666017f, 
    -0.04500153f, -0.00091819f, 0.08508438f, 0.10765401f, 0.10146867f, -0.03419845f, 0.10394089f, -0.02831775f, 
    0.05043382f, 0.07186004f, 0.13727792f, 0.12004644f, -0.03047710f, 0.04333279f, -0.04840915f, -0.00970670f, 
    0.10390511f, 0.11688831f, -0.00784095f, 0.08569575f, 0.08060040f, -0.12650782f, 0.22894694f, -0.26759875f, 
    -0.03167621f, 0.07237657f, 0.04981579f, 0.12280817f, 0.04438145f, -0.02474972f, 0.16793284f, 0.01504410f, 
    0.15362032f, -0.00698571f, -0.05639132f, -0.06313111f, 0.12911752f, 0.03199201f, -0.00159673f, 0.01487599f, 
    -0.13280319f, -0.04366472f, 0.12778465f, 0.08559715f, -0.52914894f, -0.24480830f, -0.02318328f, -0.07611713f, 
    0.00636738f, 0.15014349f, 0.00061320f, 0.01468494f, -0.01316576f, -0.15988232f, 0.11170577f, 0.11024579f, 
    -0.25291014f, -0.11815116f, -0.07893585f, 0.10102684f, 0.04764469f, 0.04388719f, 0.00137026f, 0.02658756f, 
    0.03057085f, -0.03745494f, 0.11305905f, 0.08355361f, -0.66859621f, 0.08158570f, 0.07775356f, 0.18562117f, 
    -0.06431265f, -0.04008719f, -0.07632702f, -0.03970576f, 0.02978189f, 0.07857507f, -0.04771523f, 0.02386425f, 
    0.40775406f, 0.09246621f, 0.13958290f, 0.08607145f, -0.11813129f, -0.08619375f, 0.00646439f, 0.05418704f, 
    0.02441435f, -0.03514433f, 0.09845705f, 0.01055976f, 0.03187067f, 0.23698026f, 0.13123493f, 0.12880212f, 
    -0.00314804f, -0.03158329f, -0.01302403f, 0.13629609f, 0.03297177f, 0.06954934f, 0.08820631f, 0.10460060f, 
    0.19871707f, -0.13049822f, -0.02783167f, -0.00221690f, -0.14171870f, 0.07066316f, -0.14547189f, 0.05588411f, 
    -0.07898758f, -0.04688379f, -0.08279629f, -0.01875274f, -0.01112491f, -0.03139281f, 0.29895794f, 0.09956936f, 
    0.04950030f, 0.09655190f, -0.01070348f, 0.01485549f, 0.15325359f, -0.02299879f, -0.02738590f, -0.10856739f, 
    -0.16516598f, -0.02821289f, 0.01353184f, 0.03019063f, -0.03929723f, 0.06512883f, 0.11364088f, 0.02840191f, 
    0.11611957f, 0.04981408f, -0.07246142f, -0.02386699f, -0.04685530f, 0.28476402f, 0.21689180f, 0.01613817f, 
    -0.01537442f, 0.06230361f, 0.11644918f, 0.11607706f, 0.03386876f, 0.07934804f, 0.08672195f, -0.02467689f, 
    0.37887362f, 0.02173820f, 0.06357843f, -0.02386591f, -0.14095849f, -0.02100297f, 0.06967626f, -0.01662380f, 
    0.08967472f, 0.05275239f, -0.00075242f, -0.00619562f, 0.02005539f, 0.06857155f, 0.13413490f, 0.10618941f, 
    -0.12127630f, 0.12495180f, -0.01332197f, -0.01191259f, 0.03264450f, -0.06808022f, 0.05458709f, 0.01453331f, 
    -0.10749836f, 0.25275144f, -0.17879920f, -0.12694833f, 0.03093721f, 0.09140691f, 0.01162844f, -0.05994678f, 
    -0.05408413f, -0.13898909f, 0.09809576f, -0.08852072f, -0.07344364f, -0.06249981f, -0.30272785f, 0.01347898f, 
    -0.21833539f, -0.20241761f, -0.07354955f, 0.06038943f, 0.08500305f, 0.14693433f, -0.07403985f, 0.08130440f, 
    -0.09061366f, -0.04685646f, -0.31982952f, 0.02863981f, 0.05222381f, 0.06199044f, 0.03093311f, 0.12815887f, 
    -0.07529234f, 0.02462093f, 0.03238453f, -0.05972331f, 0.07085835f, 0.15348063f, 0.04617210f, -0.00437330f, 
    -0.09468345f, -0.08311109f, -0.09380637f, 0.08406226f, 0.02936272f, 0.08955544f, -0.02826465f, 0.03366597f, 
    0.21181995f, 0.10934727f, 0.10819104f, 0.11755833f, 0.01467125f, -0.06511302f, 0.05508877f, 0.11998053f, 
    0.03115617f, 0.07878968f, -0.03439286f, 0.08547292f, -0.08482663f, -0.13319185f, -0.08537335f, -0.01776519f, 
    0.03556535f, 0.04574557f, -0.03176265f, -0.02015211f, -0.09603499f, -0.01692246f, 0.01507002f, -0.07307569f, 
    -0.01100428f, -0.02594345f, -0.03550450f, 0.02304751f, 0.02009172f, -0.01403891f, -0.02771539f, -0.02058684f, 
    0.02200176f, 0.00117698f, 0.02981684f, 0.00156583f, -0.02716262f, -0.02963556f, -0.00238543f, -0.01303640f, 
    -0.01361176f, -0.01320250f, -0.02111248f, 0.00477220f, -0.03413701f, 0.01623140f, -0.03107796f, -0.02081820f, 
    -0.03722986f, -0.00608017f, 0.01411939f, 0.02948433f, 0.01380815f, 0.02582526f, -0.01744774f, 0.00673577f, 
    -0.00661878f, 0.02454299f, -0.01940320f, 0.01736495f, -0.02028568f, -0.03801934f, -0.02383575f, -0.03808258f, 
    0.00276205f, 0.02519527f, 0.01564394f, -0.01911976f, 0.02817314f, 0.01930278f, 0.01186367f, -0.00080453f, 
    -0.00727401f, 0.03096950f, -0.03349970f, 0.03030083f, -0.01548990f, -0.01159460f, -0.00014456f, -0.00273696f, 
    -0.01168515f, 0.03014853f, -0.01805168f, 0.00362755f, -0.03972668f, -0.01593956f, -0.03428604f, 0.01344046f, 
    -0.04105799f, -0.01312179f, -0.02140835f, 0.01381989f, -0.00687933f, -0.00416362f, -0.02567430f, -0.00856320f, 
    0.01991374f, -0.02454219f, 0.00307473f, -0.01600885f, -0.02857504f, -0.00784239f, -0.01568822f, -0.00705656f, 
    -0.01797510f, 0.02844045f, -0.02215153f, -0.03231470f, -0.01200381f, -0.03850247f, -0.01044061f, 0.02460091f, 
    -0.01786835f, -0.01028168f, -0.01748202f, -0.01197823f, -0.01245576f, -0.03541173f, 0.01077178f, -0.00169111f, 
    -0.00969551f, 0.00976269f, -0.01565810f, 0.01203282f, -0.02199953f, 0.02068106f, 0.01637247f, 0.02061821f, 
    0.00809600f, -0.03379145f, -0.00599497f, -0.00147503f, -0.00553701f, -0.01375752f, 0.00623068f, 0.00495669f, 
    -0.03584787f, -0.02169945f, 0.02087351f, 0.00813064f, 0.02561506f, 0.00896950f, -0.03718155f, -0.03956379f, 
    0.00703009f, -0.00286832f, -0.01057553f, 0.02658715f, 0.01105475f, 0.02692019f, -0.04078744f, -0.03568254f, 
    0.00344282f, 0.00076606f, -0.04145653f, -0.01845619f, 0.00275777f, -0.03751788f, -0.03369577f, 0.00058768f, 
    0.01235245f, -0.00712563f, 0.00064088f, 0.00068999f, 0.00997116f, -0.01452177f, -0.02599177f, 0.00459486f, 
    -0.02215506f, -0.03666317f, 0.01831654f, -0.01125880f, 0.02516926f, 0.01296063f, -0.00047473f, 0.00059412f, 
    -0.01054175f, -0.00216106f, -0.00242538f, 0.01361555f, 0.00082698f, 0.02065661f, 0.01341587f, 0.02331557f, 
    0.02793341f, 0.02967562f, -0.00329054f, -0.03972707f, -0.00445184f, 0.01234501f, -0.03359536f, 0.02445259f, 
    -0.03673169f, -0.03180326f, -0.02957273f, -0.03211325f, 0.01739344f, -0.02980211f, -0.02929522f, -0.04021093f, 
    -0.01569127f, -0.00245845f, 0.02191839f, -0.03623956f, -0.01525207f, -0.02878407f, -0.00180535f, -0.02997685f, 
    -0.03099954f, 0.01182000f, -0.00704764f, -0.00706629f, 0.01690834f, -0.00684432f, 0.01041392f, -0.00649301f, 
    -0.00974810f, 0.02580686f, -0.01634856f, -0.03240916f, -0.00156344f, -0.00043347f, 0.02134188f, -0.03555750f, 
    -0.00312089f, -0.01990185f, -0.00751794f, 0.01191112f, -0.00213766f, -0.00768960f, -0.03657396f, 0.02847346f, 
    -0.00029416f, 0.02485171f, -0.02227698f, -0.02109180f, -0.02653775f, -0.01753313f, 0.00234616f, -0.00732405f, 
    -0.01790786f, -0.01045394f, -0.04017425f, -0.01787709f, 0.03203572f, -0.02497278f, -0.02435061f, 0.01322994f, 
    -0.00931539f, -0.01119755f, 0.00619675f, -0.00445599f, -0.01409365f, -0.02215922f, -0.00223205f, -0.03118855f, 
    -0.00868715f, -0.01872685f, 0.00437635f, -0.01006867f, 0.02216554f, -0.01300880f, 0.02475260f, -0.02711376f, 
    -0.01107961f, -0.02694437f, -0.01732430f, 0.02650120f, -0.02823898f, -0.03332971f, -0.02288430f, 0.02002104f, 
    -0.01122840f, 0.00087162f, -0.00570297f, -0.01664915f, 0.00952543f, -0.00162057f, -0.03894976f, 0.00851824f, 
    -0.02128856f, -0.03881165f, 0.01468854f, 0.02413657f, -0.00611008f, -0.03650565f, 0.02284348f, -0.03403420f, 
    -0.02347401f, -0.02513993f, -0.01412894f, 0.01787979f, 0.02452131f, 0.01698785f, -0.03715970f, 0.00625774f, 
    -0.03743601f, 0.02303057f, 0.00480833f, 0.02368340f, 0.02548959f, 0.02481520f, -0.00408665f, 0.02826878f, 
    -0.02233949f, 0.00369808f, 0.03020423f, 0.01766127f, -0.01966768f, 0.00157974f, -0.00301414f, -0.02131080f, 
    -0.02110793f, -0.00187080f, -0.01176800f, 0.01168866f, 0.02773677f, 0.02334663f, -0.02919658f, 0.00783322f, 
    -0.03612586f, 0.01825978f, -0.03220725f, 0.01750570f, 0.02803705f, -0.02839580f, -0.01324720f, -0.03194969f, 
    -0.00525989f, 0.01961763f, -0.01328434f, -0.00267094f, 0.02331033f, -0.03414023f, 0.00332541f, 0.02492961f, 
    -0.03188492f, 0.02742670f, -0.03990136f, -0.00432937f, 0.02315317f, 0.00287053f, 0.02042824f, 0.02756909f, 
    0.03050202f, -0.03876195f, 0.00316290f, -0.02068532f, -0.03215606f, -0.01736079f, -0.01651092f, 0.01740102f, 
    0.02337083f, -0.04102643f, -0.01808438f, -0.02582600f, 0.02592253f, 0.01147466f, -0.00795106f, 0.01231011f, 
    0.02214195f, -0.01910752f, 0.02686550f, -0.01803917f, 0.01679118f, -0.00976114f, 0.02515866f, 0.00818930f, 
    0.00877844f, -0.03827794f, -0.01263543f, 0.02487939f, -0.00301904f, 0.01217720f, -0.00178792f, 0.02092291f, 
    -0.02349131f, -0.01581069f, 0.01542998f, -0.03839605f, 0.00956514f, -0.03063503f, -0.03677569f, 0.00673362f, 
    -0.02249247f, -0.03180635f, -0.01614921f, -0.01663913f, -0.00151348f, 0.00375329f, 0.00116778f, -0.01167262f, 
    -0.01614187f, -0.03024667f, -0.02135514f, 0.02600567f, -0.02535998f, 0.00045679f, -0.02338271f, 0.00353690f, 
    0.02148136f, 0.01437741f, 0.00377106f, 0.00520077f, 0.00962820f, 0.00503013f, -0.01403192f, -0.02044358f, 
    0.02862487f, -0.02517089f, -0.00774649f, -0.00602399f, -0.00078886f, 0.01697137f, -0.00101408f, -0.02898398f, 
    -0.02241427f, -0.00457543f, -0.02910701f, -0.02173482f, 0.02013574f, -0.03428660f, -0.03118583f, 0.01305055f, 
    -0.01044440f, -0.03091472f, 0.02373721f, 0.01480033f, -0.01430619f, -0.02848546f, -0.00823353f, -0.00041914f, 
    -0.01564643f, 0.00885463f, 0.03030321f, -0.01052040f, -0.02355378f, -0.01410208f, -0.03685852f, -0.01886248f, 
    0.00505465f, -0.01961717f, 0.00017630f, 0.01895707f, 0.00155167f, -0.00619656f, -0.03060188f, -0.00669798f, 
    0.03110584f, -0.00088387f, -0.00734783f, 0.01738440f, -0.00174082f, -0.02070588f, -0.02194248f, 0.00056490f, 
    -0.03280660f, 0.01719999f, -0.03598114f, 0.01020319f, -0.02085781f, 0.02657664f, 0.00924106f, -0.01377589f, 
    -0.01600450f, 0.02466648f, -0.01890669f, -0.01452175f, -0.03440449f, 0.02698690f, -0.00551346f, 0.02437188f, 
    -0.00025894f, 0.02283257f, 0.01213014f, 0.01685985f, -0.02381981f, -0.01222856f, -0.02314866f, 0.01170413f, 
    -0.02666875f, 0.01027104f, -0.02655820f, 0.00815803f, -0.01552391f, 0.01218909f, 0.02106870f, 0.00658770f, 
    -0.02684012f, -0.03184095f, -0.02740561f, 0.02043897f, -0.02530986f, 0.00610840f, -0.02917295f, -0.01436737f, 
    -0.01634236f, 0.01035461f, 0.02100908f, 0.02194439f, -0.00295276f, -0.00462124f, 0.00546557f, -0.01869160f, 
    -0.00357847f, 0.01592867f, 0.00138907f, -0.01579255f, -0.02331039f, -0.03373053f, 0.03015260f, 0.01907936f, 
    -0.03684076f, 0.00986245f, -0.03272626f, -0.03688604f, -0.04034030f, 0.01318839f, -0.02939980f, 0.00392333f, 
    -0.02589031f, 0.02867299f, 0.00880443f, -0.02904426f, 0.02600894f, 0.02367217f, -0.00650023f, -0.00316229f, 
    -0.03586541f, 0.01282249f, 0.00060803f, -0.00386734f, -0.04048081f, -0.02032174f, 0.02920087f, -0.00960712f, 
    -0.03333766f, -0.00342185f, -0.01918310f, -0.02683358f, -0.01492443f, -0.02351411f, 0.00288272f, 0.02468512f, 
    -0.02138334f, 0.01480393f, -0.00123999f, 0.00177899f, 0.00267831f, -0.01409450f, -0.03322736f, -0.00114347f, 
    0.01919636f, -0.01897575f, 0.00911078f, -0.00959991f, 0.01113366f, -0.00855188f, 0.03137855f, -0.01783299f, 
    0.02937195f, -0.02037845f, -0.01004072f, -0.02001896f, 0.00433495f, -0.01338741f, -0.01605503f, 0.00234074f, 
    -0.00680404f, 0.02963807f, -0.02087166f, -0.00864746f, 0.01955789f, -0.01569931f, -0.00784954f, 0.02979947f, 
    -0.02968823f, 0.01968658f, -0.03561286f, -0.00185005f, 0.00846150f, 0.01671273f, 0.02381910f, -0.03048123f, 
    0.02903313f, 0.00014297f, 0.01115042f, -0.00153881f, -0.00098077f, -0.01936443f, -0.02640596f, -0.01773611f, 
    -0.01489870f, -0.03825285f, -0.03481025f, -0.01885045f, -0.03688407f, -0.02042778f, -0.01275763f, -0.03708451f, 
    0.01781393f, -0.01896591f, 0.00974740f, 0.03095620f, 0.00906730f, 0.01006218f, 0.02883254f, 0.00406517f, 
    -0.03181360f, 0.02094016f, 0.00009573f, 0.01880355f, 0.00662849f, -0.02953851f, 0.00748583f, -0.01155675f, 
    -0.00867755f, 0.02924288f, -0.02272979f, -0.03331505f, 0.02295197f, 0.01040097f, -0.02615266f, -0.03786849f, 
    -0.02487577f, -0.03553792f, -0.02604426f, -0.00604020f, 0.01126513f, -0.03027365f, -0.01104158f, -0.01468401f, 
    -0.03085787f, 0.01997257f, 0.02538221f, -0.00374497f, -0.03672936f, 0.02115397f, -0.00618838f, -0.03035704f, 
    -0.00919584f, 0.02181326f, -0.00316491f, 0.00727336f, -0.00982143f, -0.02563267f, -0.00024365f, -0.01137581f, 
    -0.03464136f, 0.00845241f, -0.01539981f, -0.02407617f, 0.01149591f, -0.02937617f, 0.03090970f, -0.02277560f, 
    -0.01008582f, 0.00969991f, 0.01662739f, -0.02331163f, 0.01069888f, 0.01723717f, -0.00562779f, 0.01306788f, 
    0.02388222f, 0.00911028f, 0.02152668f, -0.03270839f, 0.02916870f, -0.03044321f, -0.03073703f, 0.02961665f, 
    -0.03885908f, 0.00275123f, 0.02176521f, 0.01865426f, -0.02992078f, -0.03515090f, -0.00366720f, -0.02244911f, 
    0.01841485f, 0.00870988f, -0.03340432f, 0.01692168f, 0.00725365f, 0.01207774f, -0.02117095f, -0.03670051f, 
    -0.03182432f, -0.00915123f, 0.02764845f, 0.01801849f, -0.00280851f, 0.02116862f, 0.01991462f, -0.00580761f, 
    0.00737678f, -0.03298180f, -0.00793290f, 0.02867571f, 0.02141197f, 0.01875051f, -0.00332615f, -0.01089575f, 
    0.00083857f, 0.00139182f, -0.00295124f, -0.03239515f, 0.01869819f, -0.02750433f, 0.02943626f, -0.03565702f, 
    0.00735158f, -0.00868954f, 0.01438430f, -0.01071268f, 0.00540679f, 0.02653997f, -0.02934955f, -0.01285618f, 
    0.00082567f, 0.01927038f, 0.00458982f, -0.03644150f, 0.00510745f, -0.03741151f, -0.03840475f, 0.01059193f, 
    0.00127716f, 0.00175351f, 0.03442468f, 0.00077191f, -0.00962335f, 0.01860476f, -0.03055530f, -0.01788521f, 
    0.01228148f, -0.02988934f, -0.01086028f, -0.00058794f, 0.00216324f, -0.03228320f, -0.02606911f, -0.01387076f, 
    -0.03312770f, -0.00034654f, 0.02404662f, -0.02481574f, 0.00844989f, -0.00042399f, -0.02649147f, -0.03929250f, 
    -0.00594255f, -0.02361190f, -0.03973195f, -0.03536417f, 0.01284980f, -0.02343952f, 0.01389298f, 0.00513452f, 
    -0.02629304f, 0.02941621f, 0.02291602f, -0.04133667f, 0.00457004f, -0.03515768f, -0.03531994f, -0.01400527f, 
    0.00457601f, -0.03307803f, -0.01852564f, -0.02598691f, -0.03351657f, 0.01591476f, 0.02834045f, -0.03235333f, 
    0.00051529f, -0.02544873f, 0.01803277f, -0.02914017f, -0.01161796f, -0.03550608f, -0.02590164f, -0.02507763f, 
    0.01176292f, -0.01082602f, -0.01196639f, -0.01565921f, -0.03417362f, 0.00044284f, -0.02491556f, -0.00694840f, 
    -0.04548546f, 0.08128419f, -0.04478807f, -0.03973914f, 0.19443782f, 0.14458781f, 0.08816008f, 0.03635045f, 
    -0.05132071f, 0.01212648f, -0.00035843f, -0.00671147f, 0.35758176f, -0.14307022f, 0.12427642f, -0.01918303f, 
    0.02028086f, 0.02769266f, 0.05735369f, -0.11827394f, 0.25300944f, 0.09046756f, 0.18475713f, -0.06643946f, 
    -0.07195724f, 0.11184871f, -0.03626790f, 0.01548279f, 0.12579192f, -0.12844104f, 0.23510094f, 0.06835408f, 
    0.11446583f, 0.08248567f, 0.05017520f, 0.09444150f, 0.10473032f, -0.00159851f, 0.00879277f, 0.03214517f, 
    0.08526109f, -0.09136329f, 0.04910749f, 0.10647828f, 0.06121291f, 0.02711829f, -0.05423937f, 0.12537105f, 
    0.25408447f, 0.16180225f, -0.09223194f, -0.16801010f, -0.00835244f, 0.00444136f, 0.02209609f, -0.01752729f, 
    0.10078808f, 0.01979652f, -0.00589047f, 0.09586208f, 0.08662274f, 0.05464015f, -0.10942210f, 0.20339890f, 
    -0.00214382f, -0.18899651f, 0.04359225f, 0.06441806f, 0.07189957f, 0.08930904f, 0.06883086f, -0.02426352f, 
    0.19787320f, -0.09027681f, 0.30139533f, 0.11983173f, 0.14217219f, 0.09399043f, 0.09251450f, -0.01298479f, 
    -0.00831919f, 0.02554299f, 0.01500012f, 0.09119838f, -0.12612313f, 0.00019663f, 0.08067575f, -0.05982129f, 
    0.01262733f, 0.03528927f, 0.03101226f, 0.00283177f, 0.08919948f, -0.02256060f, 0.13828805f, 0.01318227f, 
    0.02910796f, -0.05567973f, -0.02982887f, -0.16732907f, 0.14251350f, -0.01316868f, 0.03529378f, 0.11236750f, 
    0.13456368f, 0.02829955f, 0.09634671f, 0.01674717f, 0.14256845f, 0.00862862f, 0.01325858f, -0.00455751f, 
    0.03121402f, -0.06965902f, -0.03141164f, -0.04294738f, 0.11676696f, 0.11124819f, -0.00450988f, 0.10243970f, 
    -0.27126443f, 0.00317861f, -0.13009323f, 0.01867927f, -0.05733147f, -0.01395735f, 0.09538934f, 0.00810406f, 
    0.08370677f, -0.00789803f, 0.07984598f, 0.03052582f, 0.22984754f, -0.05687290f, 0.11137706f, -0.06622792f, 
    0.04660471f, 0.04999788f, -0.04899222f, 0.04556281f, 0.04473374f, 0.00454013f, -0.06941465f, 0.03299503f, 
    -0.05154843f, 0.22426598f, 0.10491307f, 0.18722630f, -0.13039680f, -0.05373610f, -0.05399013f, 0.11027367f, 
    0.07882433f, -0.00410417f, 0.12184618f, 0.07933999f, -0.08257739f, 0.08805197f, -0.07841863f, 0.12794100f, 
    -0.01074923f, 0.03863711f, -0.08605597f, 0.01536678f, -0.01292883f, 0.09325806f, -0.04236749f, -0.02098218f, 
    0.31058195f, -0.22867632f, 0.29492024f, -0.00073515f, 0.03822549f, -0.05667454f, -0.11160701f, 0.04748558f, 
    0.00822117f, -0.05270268f, 0.04222643f, 0.05593590f, 0.33594400f, -0.41182929f, 0.46129659f, -0.33923638f, 
    0.04886567f, -0.12901266f, 0.03172824f, 0.09832881f, -0.06567918f, 0.02466923f, 0.10959274f, -0.13272320f, 
    -0.13068424f, 0.06523028f, -0.07438618f, -0.12298124f, 0.07846390f, -0.05343057f, 0.06114195f, -0.02911749f, 
    0.16487963f, -0.09040450f, 0.02274351f, 0.01590308f, -0.04843519f, -0.08034188f, -0.01682963f, -0.22170056f, 
    0.20984095f, 0.18433060f, 0.13401397f, -0.01309766f, -0.16450574f, -0.10330312f, -0.06050282f, -0.08850975f, 
    -0.09712479f, 0.02955675f, -0.23946071f, 0.11165473f, 0.09608948f, 0.17728835f, 0.00475230f, 0.02941395f, 
    -0.01477383f, 0.08371335f, 0.05485463f, 0.01989897f, 0.22299343f, -0.14886780f, 0.20319194f, 0.06564055f, 
    0.07195596f, -0.08073608f, -0.12215345f, 0.12723695f, 0.21892783f, 0.09449224f, 0.03208422f, -0.05714672f, 
    0.00234636f, 0.09843791f, -0.05300131f, 0.03120961f, -0.09343775f, -0.03214397f, 0.07144052f, -0.01478754f, 
    0.03682829f, 0.05638127f, 0.02557235f, -0.01147123f, 0.36823696f, -0.20891532f, 0.08650243f, -0.01502919f, 
    0.09911393f, -0.06451685f, 0.10550255f, 0.12438262f, -0.13364449f, 0.00394799f, -0.16645366f, 0.04579852f, 
    0.13109186f, 0.11736978f, 0.10130534f, 0.06774866f, -0.00165218f, -0.04424058f, 0.07684116f, -0.01551082f, 
    0.15163672f, -0.00444090f, -0.08135165f, -0.18530028f, -0.11761596f, -0.34124973f, -0.27863166f, -0.05276884f, 
    0.17380303f, 0.14953624f, 0.05747417f, -0.02207350f, -0.05077004f, -0.01066135f, 0.03759288f, 0.01264890f, 
    -0.02637761f, -0.01977772f, -0.11150517f, -0.13297109f, 0.16167814f, 0.14924778f, 0.11347608f, -0.00151002f, 
    -0.09547923f, -0.10843547f, -0.10336319f, 0.00678398f, -0.12970528f, -0.21813090f, -0.05618855f, -0.03747622f, 
    -0.12557219f, 0.02843017f, 0.25099021f, -0.18418632f, 0.09913288f, 0.00508270f, 0.00160939f, 0.01755471f, 
    0.12070256f, -0.45934978f, 0.18049517f, -0.26967183f, -0.07760182f, 0.05612506f, -0.14579280f, 0.09173155f, 
    0.02606458f, 0.00470452f, -0.07083169f, -0.15948334f, -0.08681224f, 0.04759371f, -0.40338299f, -0.06134485f, 
    0.14150338f, 0.02971337f, 0.14479734f, 0.05704415f, 0.22822596f, 0.00355524f, 0.01042046f, -0.01713452f, 
    0.42696998f, 0.06463815f, 0.12672666f, -0.28494921f, 0.00569599f, -0.03290384f, 0.07157156f, 0.01520942f, 
    0.10806596f, 0.13790660f, 0.01720167f, -0.14896768f, 0.05068288f, -0.03445682f, -0.09503097f, 0.02315569f, 
    0.07139191f, -0.07040834f, 0.04919318f, 0.12283847f, 0.00675849f, 0.03978427f, 0.01417073f, 0.15850128f, 
    0.08719253f, 0.11420760f, -0.15032281f, 0.01401480f, 0.04876735f, 0.00782521f, 0.02448905f, 0.09272805f, 
    0.06612115f, 0.02314417f, 0.13541298f, 0.01519236f, 0.21236822f, -0.36535630f, 0.55284703f, -0.28784889f, 
    -0.09767520f, 0.16165042f, -0.13981271f, 0.12260380f, -0.06835277f, 0.04798943f, -0.07284736f, 0.11153464f, 
    -0.17817347f, -0.14171422f, -0.08041868f, -0.11006799f, 0.17866643f, 0.06578316f, -0.03663455f, -0.10318387f, 
    -0.05754557f, 0.01958215f, 0.02115553f, 0.00022978f, -0.10871483f, -0.02840866f, 0.04853183f, -0.03329517f, 
    -0.05824011f, 0.08786272f, 0.05197194f, 0.03961033f, -0.10792368f, -0.11519824f, 0.00681106f, 0.02921751f, 
    0.02693052f, 0.04745183f, 0.10082877f, 0.00558654f, 0.03503105f, -0.00903304f, 0.04798826f, -0.05282189f, 
    0.05951907f, 0.09671756f, 0.08106782f, 0.05347243f, 0.12503216f, 0.17567770f, 0.04625008f, -0.16644998f, 
    0.07070777f, -0.00165181f, 0.00907700f, -0.01175063f, -0.02780888f, 0.02637907f, 0.00117922f, 0.07774459f, 
    0.28279111f, -0.20638308f, 0.35825187f, -0.06271899f, -0.05973244f, -0.03721862f, -0.02167981f, 0.08642496f, 
    0.01268837f, 0.07425468f, 0.02386266f, 0.02956636f, 0.06450085f, 0.19794591f, -0.28037706f, 0.11750066f, 
    -0.06882138f, 0.05053256f, 0.11835343f, -0.02786412f, -0.00407401f, 0.03132139f, -0.04635787f, 0.02623593f, 
    -0.11646546f, -0.22368504f, -0.06894948f, 0.16823846f, -0.12644821f, 0.13076924f, 0.00334982f, 0.01600684f, 
    -0.02253857f, -0.07379697f, -0.04714200f, 0.01575617f, -0.00483683f, 0.22918029f, -0.19832264f, 0.07079095f, 
    -0.04023631f, -0.06358349f, 0.07271288f, -0.03802930f, -0.01997731f, -0.04210071f, -0.09843635f, -0.02870138f, 
    -0.28688997f, 0.05200348f, 0.01444579f, -0.00391944f, 0.08739145f, -0.00559796f, 0.03001352f, -0.07237650f, 
    -0.04028273f, -0.03534260f, 0.08381223f, 0.12261114f, 0.03420069f, 0.12120333f, 0.08695342f, 0.17403097f, 
    -0.01445073f, -0.01950112f, -0.04726090f, 0.05281446f, -0.01372908f, -0.08460152f, 0.09887727f, -0.03367635f, 
    -0.01633557f, -0.02340764f, -0.32548288f, -0.28063241f, 0.04539777f, 0.09877546f, -0.04374142f, -0.07103813f, 
    -0.06871790f, 0.00466078f, 0.03298241f, -0.08144213f, -0.05366697f, -0.15849794f, 0.19148175f, -0.21057196f, 
    0.16863766f, 0.10558865f, 0.05887995f, 0.05877985f, -0.07444669f, -0.01004974f, -0.04931403f, -0.03130512f, 
    0.14923935f, 0.00270639f, -0.04726151f, 0.06617375f, 0.06173990f, 0.13630563f, -0.01984439f, 0.01287787f, 
    -0.05425916f, -0.07122327f, -0.03784380f, 0.00390268f, 0.14219847f, -0.34437469f, 0.11020172f, -0.22771561f, 
    0.26773003f, 0.03085086f, -0.11067358f, -0.10712221f, -0.02001630f, -0.04408113f, -0.00790068f, 0.00088472f, 
    0.09944748f, -0.32244730f, 0.05030771f, -0.01194386f, 0.06506627f, 0.01147730f, 0.02249814f, -0.11910969f, 
    0.06709006f, -0.02746401f, -0.00081041f, -0.11416444f, 0.08179596f, 0.11482144f, -0.36587110f, -0.01136043f, 
    0.01204692f, 0.04689974f, -0.05356487f, -0.05819912f, 0.05998838f, 0.00129565f, 0.01331077f, 0.00807683f, 
    -0.04803321f, -0.07150607f, 0.02317033f, 0.00729097f, -0.00620059f, 0.04143057f, -0.00936399f, 0.05070099f, 
    -0.03264081f, -0.06223112f, 0.02384008f, 0.05811818f, -0.22035013f, 0.02489279f, -0.05550247f, 0.03667575f, 
    -0.05796818f, -0.03575212f, -0.12689202f, 0.09789351f, 0.00287743f, 0.00595720f, 0.03113042f, 0.04905253f, 
    0.13665102f, -0.12519316f, 0.33996072f, -0.05751321f, -0.08909284f, 0.00021742f, -0.03311296f, 0.06313079f, 
    0.12870516f, 0.04663562f, 0.10089225f, 0.11847710f, -0.11895110f, 0.04939487f, -0.14145301f, -0.26307875f, 
    0.14466280f, 0.07244162f, -0.10431234f, 0.04009441f, -0.06844830f, -0.03025754f, 0.02820055f, -0.00542831f, 
    -0.10315184f, 0.03255552f, 0.16165029f, -0.15041667f, 0.19089627f, -0.14973322f, 0.08033818f, -0.08700431f, 
    0.25894812f, -0.08266617f, -0.00224313f, 0.10020945f, 0.00599216f, -0.10921989f, 0.03788530f, -0.22481899f, 
    0.02743234f, -0.09930643f, 0.05297057f, 0.12690762f, -0.00195701f, -0.06724782f, 0.04771815f, 0.05404526f, 
    0.12536018f, -0.03037427f, -0.13670400f, -0.09510937f, 0.11420637f, 0.14182979f, -0.06637684f, -0.02936152f, 
    0.10299612f, 0.14030294f, -0.08071069f, 0.00459419f, -0.16820300f, 0.01884518f, -0.27930376f, 0.00313232f, 
    0.11212524f, 0.05476568f, 0.16217254f, 0.00357700f, -0.01383652f, -0.02116678f, 0.00898445f, 0.02721478f, 
    0.12285534f, 0.21230516f, 0.15004539f, -0.08305595f, -0.15164234f, -0.04291154f, 0.01689497f, -0.03636337f, 
    -0.03134490f, -0.00461857f, -0.05262954f, 0.11460433f, 0.09482594f, 0.01522748f, -0.01141958f, -0.12642361f, 
    0.03464458f, -0.05111814f, 0.08681454f, -0.13713095f, -0.11373019f, -0.19154453f, 0.06094100f, -0.00385977f, 
    0.29388472f, 0.23496826f, 0.22398868f, -0.28460070f, 0.04709160f, 0.03243172f, -0.00067853f, 0.00030920f, 
    0.06275030f, -0.06808819f, 0.03171692f, 0.02539174f, 0.21075615f, -0.00276816f, 0.18178190f, 0.04918056f, 
    0.02608722f, -0.03454699f, -0.00648300f, 0.00466721f, 0.09588245f, -0.01733239f, -0.09573252f, -0.04879534f, 
    -0.18085609f, 0.13004969f, -0.11474868f, 0.02589365f, -0.11875497f, 0.10130967f, 0.07745396f, 0.11836926f, 
    -0.04381542f, -0.03932716f, 0.12029988f, -0.03165950f, 0.08734006f, -0.04590388f, 0.02686342f, -0.07592931f, 
    0.19975565f, 0.11364064f, -0.13354433f, 0.11307195f, -0.06502801f, -0.08520880f, -0.06852531f, -0.06831877f, 
    0.03802897f, 0.16562785f, 0.26641273f, -0.22044455f, 0.09318689f, 0.07499456f, 0.01229850f, -0.01218916f, 
    -0.02394179f, -0.02174487f, 0.00252491f, 0.04029386f, 0.02723100f, -0.05870998f, 0.04627576f, 0.02728351f, 
    0.00747307f, 0.00619057f, 0.02413580f, 0.05203507f, -0.01820423f, 0.01327237f, 0.04715725f, -0.05528951f, 
    -0.02640774f, -0.08648175f, 0.16089270f, 0.06236121f, -0.07229340f, -0.00590385f, 0.03262229f, 0.01051873f, 
    0.08391904f, 0.04333188f, -0.04056173f, 0.00760867f, -0.51870334f, 0.37814260f, -0.01442264f, 0.00712250f, 
    -0.00383809f, 0.02771304f, -0.11840441f, 0.05759204f, 0.01099874f, -0.02422664f, -0.10958569f, -0.02691525f, 
    -0.02825050f, -0.14163835f, -0.04759026f, 0.00769026f, -0.10715393f, 0.04540170f, -0.06864548f, -0.14211598f, 
    -0.00668243f, -0.04012666f, -0.03702224f, -0.00309263f, -0.02481172f, -0.09184654f, -0.07686295f, -0.01446704f, 
    -0.09311283f, -0.02311012f, -0.06331985f, -0.14626436f, 0.06499348f, -0.03262272f, 0.14794122f, 0.02669602f, 
    -0.31824979f, -0.06156216f, 0.02352263f, 0.12467748f, 0.05239380f, -0.06812571f, -0.01479600f, -0.11314686f, 
    -0.07702833f, 0.01092256f, 0.01527363f, 0.00498507f, -0.07707804f, -0.07976667f, 0.05658098f, -0.08794023f, 
    -0.10966758f, 0.11592300f, -0.12982708f, -0.11155298f, 0.03114051f, 0.04076824f, -0.15670137f, -0.04538545f, 
    0.00619003f, 0.11410379f, -0.13111615f, -0.04716386f, -0.07285292f, -0.02345503f, -0.04138609f, -0.04125433f, 
    0.02828135f, 0.07622910f, 0.02972624f, 0.06627646f, -0.01261357f, -0.00453419f, -0.07912428f, 0.07162297f, 
    -0.04463683f, -0.11524473f, -0.11532085f, -0.11952750f, -0.04612302f, 0.01657056f, -0.08786840f, -0.00919410f, 
    0.03224558f, 0.01915149f, 0.08256095f, 0.00128768f, 0.19644693f, -0.01171687f, 0.14214194f, 0.05392836f, 
    -0.08032408f, 0.07727287f, 0.05408391f, 0.04879038f, -0.05451759f, 0.00488501f, -0.15331575f, 0.04087985f, 
    0.02821190f, 0.01723408f, -0.08195911f, 0.06415688f, -0.07659453f, -0.06209907f, 0.08185771f, -0.08369931f, 
    -0.03182659f, -0.16756126f, 0.17668372f, 0.11473931f, -0.07761344f, 0.11636417f, -0.09157451f, -0.07783301f, 
    0.03822834f, 0.11166729f, -0.08195936f, -0.09477884f, -0.17571044f, 0.04876667f, -0.08250366f, 0.00833760f, 
    0.00632786f, -0.05474117f, -0.10922609f, -0.05763444f, -0.04679596f, 0.05485231f, 0.08482510f, 0.13209578f, 
    -0.04923379f, -0.14795645f, -0.14161746f, -0.03005315f, 0.11483710f, 0.10127657f, 0.00695627f, 0.02996530f, 
    -0.06907236f, 0.08218835f, 0.02006697f, -0.01451037f, 0.14400840f, 0.11591844f, -0.03355003f, -0.02185255f, 
    0.05015472f, 0.01225365f, 0.04392709f, 0.05480637f, -0.07708917f, -0.00446148f, 0.10503873f, -0.07752141f, 
    -0.05773390f, 0.15519652f, -0.00777917f, -0.24111861f, -0.10087705f, -0.03363531f, 0.01759719f, -0.00119876f, 
    -0.02816403f, 0.03763121f, -0.01481626f, 0.07154833f, -0.25490960f, 0.60111493f, -0.28292441f, 0.08576712f, 
    0.10347996f, -0.00946711f, 0.04573793f, -0.00200307f, 0.00604898f, -0.00726316f, -0.01570382f, -0.03612251f, 
    -0.08211420f, -0.06218966f, 0.06730317f, 0.05999195f, 0.03420863f, 0.15635023f, -0.05613693f, -0.07129771f, 
    0.03569902f, 0.01027797f, 0.07784184f, 0.06561311f, -0.06370758f, 0.03289497f, 0.06935655f, 0.25253347f, 
    -0.05265131f, -0.08470267f, -0.05077657f, -0.06891144f, 0.05411593f, 0.06258148f, 0.06967376f, -0.07636311f, 
    0.11097764f, 0.22871573f, 0.10101099f, -0.05175846f, 0.02327384f, 0.03113766f, -0.01977072f, 0.02061434f, 
    -0.04198277f, 0.08521606f, -0.08836927f, -0.16969873f, -0.06729038f, 0.19886872f, 0.02752318f, -0.12621829f, 
    -0.02547585f, -0.07745662f, 0.11402916f, -0.07091443f, -0.04567992f, 0.02501686f, -0.07080487f, 0.05926030f, 
    -0.05452069f, -0.17568058f, -0.05033394f, 0.05651787f, 0.10050905f, -0.12231395f, -0.14429319f, -0.12726355f, 
    0.13812077f, 0.00769529f, -0.00674530f, 0.05292151f, -0.05172509f, 0.58877355f, -0.06171486f, 0.14518595f, 
    -0.19631889f, -0.10553975f, -0.13176465f, 0.05692933f, -0.02924741f, 0.03357032f, 0.07303312f, -0.00685405f, 
    -0.04063074f, -0.06181695f, -0.13592169f, 0.01070182f, -0.00758155f, -0.04367045f, -0.06550197f, -0.04713701f, 
    -0.15187614f, 0.06338228f, -0.04681382f, 0.15321426f, 0.02349201f, 0.04311880f, 0.01163620f, -0.02295888f, 
    0.14794821f, 0.13353106f, 0.13960288f, 0.12598926f, 0.04909110f, 0.07832993f, -0.02881512f, 0.09360924f, 
    0.06407315f, 0.04636965f, -0.02230661f, 0.10878570f, 0.12850994f, 0.14125864f, 0.02029776f, -0.00514214f, 
    0.05009775f, 0.05222794f, 0.08027014f, 0.03524619f, 0.07624394f, 0.32210654f, 0.04523072f, 0.22466336f, 
    0.12605438f, 0.05393861f, -0.16585977f, -0.05578005f, 0.01924586f, 0.03868238f, 0.06596503f, 0.19122042f, 
    -0.00116998f, 0.77835321f, -0.08452523f, -0.09808306f, 0.04414026f, 0.02899100f, -0.02728459f, 0.04595455f, 
    0.04643662f, -0.07003942f, 0.01089429f, 0.18779203f, -0.09759829f, -0.05988856f, 0.20198728f, 0.23208004f, 
    -0.01267294f, 0.08927932f, -0.08944403f, -0.03766905f, -0.08171094f, -0.06161465f, -0.06110597f, 0.03821422f, 
    -0.41319591f, -0.02647484f, -0.14096311f, 0.22770549f, -0.05540300f, 0.05419458f, -0.05486523f, 0.01691227f, 
    -0.01422297f, -0.13930574f, 0.03948739f, 0.07641957f, 0.13998829f, -0.11850484f, -0.04786657f, 0.12943003f, 
    0.08411303f, -0.04265356f, -0.01751637f, -0.03109497f, -0.03851087f, 0.07700332f, 0.04150350f, -0.02615095f, 
    -0.01238118f, -0.09461527f, 0.00912736f, 0.04426974f, -0.02502268f, -0.10439238f, 0.01052717f, 0.00909092f, 
    -0.04426739f, 0.03366320f, -0.12057470f, -0.00878525f, -0.43579474f, 0.41201687f, -0.20529293f, -0.12827744f, 
    0.16866907f, 0.08995562f, 0.15993211f, -0.10463464f, -0.03589649f, 0.04114084f, 0.04035171f, 0.09760976f, 
    0.03916459f, -0.18025157f, -0.14624344f, 0.00325586f, 0.21357065f, 0.18435906f, 0.13070443f, 0.09788468f, 
    0.00410510f, 0.00004613f, -0.02130963f, 0.12480318f, 0.14971592f, 0.02004775f, -0.01954002f, 0.11823354f, 
    0.05876931f, -0.02689806f, -0.00066675f, -0.02391183f, 0.04650185f, 0.08849052f, 0.03834708f, -0.10464650f, 
    -0.07245925f, -0.06195816f, -0.07970630f, 0.01624685f, 0.01072689f, -0.00761799f, -0.08497560f, -0.01237786f, 
    -0.08019407f, 0.03180148f, -0.01548348f, -0.09427160f, 0.00635493f, -0.01756675f, -0.06262832f, 0.06238395f, 
    -0.00844952f, -0.07457073f, -0.00905820f, -0.01881321f, -0.05164012f, 0.02198936f, 0.03674274f, -0.01447249f, 
    -0.38627768f, 0.26934519f, -0.05055764f, -0.11542320f, 0.19988370f, 0.03691292f, 0.06634302f, 0.01336763f, 
    -0.07449537f, 0.09124375f, 0.00096322f, 0.05974540f, 0.11092212f, 0.01641734f, 0.08075221f, 0.04584631f, 
    -0.00188607f, -0.03157896f, -0.10072502f, 0.13600820f, -0.01650414f, -0.05888547f, 0.02750965f, -0.05273769f, 
    0.07927983f, 0.01563948f, 0.09648245f, 0.08605960f, 0.08760870f, -0.04202639f, -0.13488591f, -0.00644546f, 
    0.01635749f, 0.11634544f, 0.01561601f, -0.01315044f, 0.20752974f, -0.02516146f, 0.13263333f, 0.01075628f, 
    0.10929532f, 0.03233374f, -0.03398910f, 0.07368723f, -0.01570010f, -0.00762346f, 0.06525601f, 0.12349946f, 
    0.02885257f, -0.11279512f, -0.03976442f, 0.03565459f, -0.13128062f, 0.02878878f, -0.07854806f, -0.01619835f, 
    0.00519060f, -0.09514215f, 0.07152302f, 0.02448291f, -0.05672060f, -0.18618117f, -0.05976840f, 0.03486398f, 
    0.09599793f, 0.02095323f, 0.04533244f, 0.08044034f, -0.05821696f, 0.14322074f, -0.08692464f, -0.01942113f, 
    0.29029739f, -0.03551409f, 0.11466809f, 0.08088025f, -0.04561482f, 0.13793322f, -0.02993127f, 0.04309990f, 
    -0.09715403f, 0.14257674f, -0.00967601f, 0.13902414f, -0.12798090f, 0.04880137f, -0.11649735f, 0.07390002f, 
    0.10078089f, 0.12189894f, 0.05427789f, -0.03797611f, 0.08321457f, 0.05355564f, -0.04744610f, 0.01611529f, 
    0.05185302f, 0.04660760f, -0.08759686f, -0.09272809f, 0.11195010f, 0.11407478f, 0.09467138f, 0.07286250f, 
    0.00690330f, 0.04741804f, 0.09245034f, 0.02199554f, -0.07592249f, 0.29728895f, -0.22107938f, 0.35634589f, 
    0.02726405f, 0.04692734f, 0.08133621f, 0.15786096f, -0.00326367f, 0.06180176f, 0.00108057f, 0.04219125f, 
    -0.08569457f, 0.23259218f, -0.06118537f, 0.08485763f, -0.08046440f, -0.01853080f, -0.02910046f, 0.08412059f, 
    0.05538929f, 0.00136348f, -0.16248116f, -0.05291740f, -0.02496310f, -0.09930996f, 0.21429271f, 0.13858990f, 
    0.08784517f, 0.03282361f, -0.07917282f, -0.02630089f, -0.08004870f, 0.02325903f, -0.00559580f, 0.05792335f, 
    -0.00630826f, 0.03809124f, 0.07482982f, 0.04030403f, -0.07416549f, -0.03466410f, -0.04848672f, -0.10629254f, 
    0.01956276f, 0.04601954f, 0.00959382f, 0.00208843f, 0.40942848f, -0.12558354f, 0.01754407f, -0.00894995f, 
    -0.07682869f, -0.03971653f, 0.09326622f, 0.00240470f, 0.03779201f, 0.05448661f, -0.13784817f, -0.22759239f, 
    -0.28721586f, -0.09706839f, -0.06848729f, -0.10134330f, 0.14625081f, 0.02038035f, -0.00767573f, -0.01402227f, 
    -0.01220619f, 0.15888672f, 0.03129928f, -0.07776766f, 0.28525242f, 0.03095718f, -0.00931586f, -0.09659697f, 
    -0.02443802f, 0.12341278f, 0.16750881f, 0.04039373f, 0.11255770f, 0.01514217f, -0.00773830f, 0.00304529f, 
    -0.15243566f, 0.13603969f, -0.03441577f, -0.01255850f, -0.12389745f, 0.14692397f, 0.01072634f, -0.13754795f, 
    -0.11789530f, -0.03222131f, -0.11925672f, 0.04173087f, -0.02465548f, 0.29352102f, -0.07773654f, 0.14870806f, 
    0.12311570f, 0.08442166f, 0.09168859f, -0.09234458f, -0.11434060f, 0.07267999f, 0.10568315f, -0.05112907f, 
    -0.13804828f, -0.00512988f, 0.07084078f, 0.18491550f, 0.02483466f, 0.02826038f, 0.03761068f, 0.10045576f, 
    -0.05919423f, -0.02016741f, 0.11049645f, 0.09033953f, 0.24800168f, -0.08113133f, -0.00361704f, 0.13630493f, 
    0.09827156f, 0.10326854f, -0.01076632f, -0.12518910f, -0.01509431f, -0.01361997f, -0.02456134f, 0.12680411f, 
    -0.04800566f, -0.16566736f, -0.16431971f, -0.01723569f, 0.16682890f, 0.01736967f, -0.06459793f, -0.00583660f, 
    -0.02285548f, -0.00548541f, 0.00908876f, 0.09980545f, 0.04877219f, -0.00942633f, 0.00223173f, 0.10888202f, 
    -0.00222242f, -0.03695282f, 0.12344510f, 0.11960598f, 0.05422181f, 0.10204551f, -0.05584174f, 0.03652779f, 
    -0.17508306f, -0.03459131f, -0.14261092f, 0.25895607f, -0.00853806f, -0.08362319f, -0.03403968f, -0.02836245f, 
    0.05893027f, 0.04773141f, 0.20423573f, 0.14251469f, -0.16564988f, -0.02704023f, -0.09580421f, 0.01121147f, 
    -0.05268601f, -0.05099861f, -0.08078238f, -0.07388751f, -0.08172216f, 0.05346689f, 0.08688014f, -0.01887629f, 
    0.03383319f, -0.35085583f, 0.15780132f, 0.01385663f, 0.12968865f, 0.10738648f, -0.00111701f, -0.01622433f, 
    -0.01909961f, 0.08138201f, -0.10481609f, 0.00888761f, 0.06318677f, 0.06045855f, 0.07719123f, -0.03126178f, 
    0.03642275f, 0.03040318f, 0.07766981f, -0.01072137f, 0.01367601f, 0.06044740f, 0.03893657f, -0.00196526f, 
    -0.14034551f, -0.04252240f, -0.16135591f, 0.08872138f, 0.11417326f, 0.01494332f, 0.05656099f, 0.01001863f, 
    -0.03141052f, 0.02261082f, -0.05741475f, -0.03384723f, -0.07368597f, 0.06759335f, 0.05642121f, 0.03693181f, 
    0.00160583f, -0.01607920f, -0.00659014f, -0.05021575f, 0.11189710f, -0.11538671f, 0.03955114f, 0.08078549f, 
    -0.02551535f, 0.11769489f, 0.19352095f, 0.16469754f, 0.03485106f, 0.02463927f, 0.11466043f, 0.17361473f, 
    -0.01351312f, 0.03792742f, -0.10101212f, 0.04099376f, -0.41737723f, 0.02183084f, 0.10369143f, -0.05362459f, 
    0.07169496f, -0.02196544f, 0.06824756f, -0.11784326f, -0.06936339f, 0.10164795f, 0.06024075f, 0.09044793f, 
    -0.19131769f, 0.07145497f, -0.07779891f, -0.17222917f, 0.03340413f, 0.04677018f, -0.00272134f, -0.04070393f, 
    -0.00609813f, 0.00891521f, -0.21471740f, -0.17561871f, -0.01774498f, -0.04563877f, -0.04497384f, -0.02845475f, 
    0.10691136f, 0.09385234f, -0.01841816f, -0.02081959f, 0.06120554f, -0.17761227f, -0.11313817f, 0.04290788f, 
    -0.22757673f, 0.04301114f, -0.00422119f, -0.10851703f, -0.02794698f, -0.10300580f, -0.04229433f, 0.01321963f, 
    0.02236534f, 0.08234765f, -0.00923203f, 0.13586833f, -0.10073848f, 0.14534093f, -0.06914332f, -0.08432777f, 
    0.06112947f, 0.05870426f, 0.05073747f, 0.05265428f, 0.25965485f, 0.04055601f, 0.10972015f, 0.08772723f, 
    0.12373400f, -0.02744264f, 0.02069437f, 0.14056090f, 0.04624769f, -0.10462821f, -0.00812807f, -0.06369781f, 
    -0.13721919f, -0.06706892f, -0.08871609f, -0.12326916f, -0.16724131f, -0.23901087f, -0.01015250f, 0.00799632f, 
    0.04306510f, 0.14645432f, -0.04552238f, 0.00219917f, -0.05112773f, -0.18528637f, -0.02549606f, -0.03813292f, 
    0.01049443f, 0.19370852f, -0.18156396f, -0.10618098f, 0.01541486f, 0.05411341f, 0.04790783f, -0.00143776f, 
    0.09353956f, 0.08788677f, -0.12734841f, -0.08769380f, 0.04880739f, -0.08309165f, 0.00607321f, 0.04603765f, 
    -0.06461716f, -0.00327394f, 0.06603165f, -0.02236970f, 0.21734533f, 0.16725926f, 0.00402516f, 0.12081841f, 
    0.00960507f, -0.11975487f, -0.00527397f, 0.11591380f, 0.01266879f, -0.01941613f, 0.15446448f, -0.06534336f, 
    0.16071363f, 0.00787407f, 0.11484946f, 0.04695417f, -0.05648157f, -0.05165190f, -0.01571144f, -0.03838989f, 
    -0.02679239f, -0.11780585f, -0.07646542f, -0.03997565f, 0.01682986f, -0.03270155f, -0.09469963f, 0.02650981f, 
    0.14710124f, 0.18664350f, 0.23148574f, 0.25259930f, 0.02864312f, -0.09604523f, 0.09748979f, 0.03008020f, 
    0.01527346f, 0.04617892f, 0.03500610f, 0.18852051f, -0.11132248f, 0.08478267f, -0.00331398f, 0.08309066f, 
    0.05893145f, 0.05333085f, -0.09133430f, -0.00648363f, 0.03131910f, -0.05321774f, 0.04674959f, 0.07805144f, 
    0.15392447f, -0.20751151f, -0.21045075f, 0.21082337f, -0.04610411f, 0.01768093f, -0.01732971f, -0.14163886f, 
    0.08779331f, -0.03453799f, -0.14765875f, -0.15025963f, 0.07000753f, -0.17577177f, 0.19603446f, 0.06436726f, 
    -0.04650422f, 0.02129174f, 0.00818675f, -0.06465147f, 0.12732244f, -0.11357211f, -0.01086770f, 0.13272738f, 
    -0.08678564f, 0.17229126f, 0.10573781f, -0.00240350f, 0.06037279f, 0.11450391f, 0.03857606f, -0.00297340f, 
    -0.08115595f, -0.08320369f, -0.08982295f, -0.11359529f, -0.18582550f, 0.09470999f, 0.01976435f, 0.26131788f, 
    0.10120721f, 0.09488570f, 0.20709175f, 0.18333919f, 0.23261522f, 0.16386428f, 0.02748016f, 0.13459612f, 
    0.21884872f, -0.07298549f, -0.17955007f, 0.15482973f, 0.00055555f, 0.08028990f, -0.02050710f, -0.11289108f, 
    0.02368360f, 0.09672651f, -0.01206714f, 0.08430935f, 0.06203890f, -0.06299204f, -0.07929944f, 0.07901759f, 
    -0.14438525f, 0.04680046f, -0.04084505f, -0.06457047f, 0.09868280f, 0.19488329f, 0.06815513f, 0.14854740f, 
    -0.13905288f, 0.12779899f, -0.12339576f, -0.26224813f, 0.05287356f, -0.01861565f, -0.06782856f, 0.03307921f, 
    -0.21474615f, -0.12901175f, -0.21098326f, -0.28959152f, 0.08348102f, 0.20222624f, -0.17923260f, 0.06710319f, 
    -0.01277703f, -0.11986644f, -0.11639531f, 0.18617831f, 0.07664970f, 0.18327937f, -0.04800240f, -0.09890877f, 
    0.03439032f, 0.03395798f, 0.00046243f, 0.07366325f, 0.02571006f, 0.11769909f, -0.09307873f, -0.05851408f, 
    0.13461946f, -0.07153679f, 0.21128820f, 0.02391346f, -0.02950932f, -0.07056823f, -0.12666754f, -0.02588006f, 
    -0.05014868f, 0.10610609f, 0.04883993f, -0.03274470f, 0.06743631f, -0.23095267f, -0.11352915f, -0.23553617f, 
    -0.05186323f, -0.11043411f, 0.07140398f, 0.11947125f, 0.07461213f, 0.05071893f, 0.17266122f, 0.15646414f, 
    -0.01143764f, 0.04174212f, 0.01439592f, -0.00633595f, -0.11094303f, -0.05175485f, 0.14399809f, 0.04120173f, 
    0.05651429f, 0.01772931f, 0.00125810f, -0.00735948f, -0.24401534f, -0.00689047f, 0.00792429f, -0.11494823f, 
    0.01491495f, -0.07552145f, 0.06142646f, 0.20407270f, 0.12902226f, 0.04363697f, -0.20714499f, -0.10990191f, 
    -0.17142843f, -0.01425400f, 0.02137095f, 0.11959516f, -0.08657863f, 0.32544184f, -0.03198688f, 0.10873670f, 
    0.08111141f, 0.00811396f, 0.09693404f, 0.08297421f, 0.04818227f, -0.08803544f, -0.04664411f, 0.08458696f, 
    -0.13339342f, 0.14496663f, 0.35419372f, 0.01125074f, -0.04586791f, 0.07481974f, -0.02247749f, -0.17638278f, 
    0.05931923f, 0.17466201f, -0.00253170f, 0.20913115f, 0.22064854f, 0.17085123f, -0.10053215f, 0.04753918f, 
    -0.08587512f, 0.05036617f, 0.09718207f, -0.07328279f, -0.12227982f, -0.12007839f, -0.17822397f, 0.11256243f, 
    -0.01267248f, 0.27808201f, -0.10988446f, 0.18033513f, -0.00594046f, -0.09361139f, -0.07469755f, -0.24559794f, 
    0.14720371f, 0.11893325f, 0.06837825f, 0.18148908f, -0.08312134f, -0.24328573f, 0.24108250f, -0.02168986f, 
    -0.15148830f, 0.15135553f, -0.05391449f, 0.11979545f, -0.00459777f, -0.07411934f, 0.01756905f, -0.07557825f, 
    0.01274669f, -0.02581530f, -0.05819963f, 0.14640421f, -0.00024793f, 0.04116066f, 0.24482438f, 0.04466928f, 
    0.04402893f, -0.06535535f, -0.17855890f, -0.19073147f, -0.08050116f, -0.06625600f, 0.06966831f, 0.12426092f, 
    0.08314330f, -0.00978930f, 0.11514653f, 0.19033362f, 0.10941096f, 0.01420378f, 0.17203051f, 0.33791625f, 
    -0.11160871f, -0.27709672f, -0.17112769f, -0.13082552f, -0.19263960f, 0.06074794f, 0.20761462f, -0.04361913f, 
    0.24021548f, 0.33779508f, 0.18511741f, 0.15404871f, 0.03272549f, 0.05555508f, 0.08064976f, 0.04375673f, 
    -0.01983166f, -0.02102361f, 0.01543105f, -0.02235394f, 0.08083657f, 0.11236830f, 0.15959269f, 0.05897137f, 
    -0.05167166f, 0.16088416f, 0.15780802f, 0.26780245f, 0.02748214f, 0.08315650f, -0.09951682f, 0.05380702f, 
    0.00804470f, -0.01631846f, 0.02712506f, 0.18252580f, -0.06036583f, 0.23170795f, -0.22654043f, -0.11346386f, 
    0.07530681f, 0.01470167f, 0.03650941f, 0.06371464f, 0.00238771f, 0.07129836f, -0.04276646f, -0.09870967f, 
    0.22255048f, -0.10080557f, 0.05099022f, 0.19360028f, -0.01996838f, -0.08475438f, -0.11351485f, -0.06679148f, 
    -0.11692363f, -0.15643336f, -0.01720623f, -0.09722929f, 0.07134264f, 0.16492648f, 0.05693771f, 0.16266039f, 
    0.06425458f, 0.01425309f, 0.07935207f, 0.09010252f, 0.14642365f, 0.16870968f, 0.15246022f, 0.08631179f, 
    -0.02404275f, 0.01417935f, 0.03516020f, -0.01315573f, -0.00648123f, -0.04669874f, -0.07502940f, 0.00122903f, 
    -0.16434833f, -0.01727870f, -0.05588648f, -0.27751756f, 0.09509422f, -0.01334685f, 0.11671341f, 0.27923942f, 
    0.01472940f, 0.00829437f, 0.01122644f, -0.13751952f, 0.13380772f, 0.13825412f, 0.11791917f, 0.32689336f, 
    0.03691078f, 0.03342040f, -0.02152056f, 0.13333559f, 0.07875968f, 0.06385624f, -0.04609881f, 0.01302992f, 
    0.01918928f, -0.07525450f, 0.07375284f, 0.02558256f, -0.00975343f, -0.13332397f, 0.12209783f, 0.17476588f, 
    0.02376506f, 0.05588808f, 0.02017404f, 0.16286214f, 0.09218682f, -0.08548383f, -0.00910851f, 0.04399943f, 
    0.03913044f, 0.00911668f, 0.11253740f, 0.09753468f, 0.05196698f, -0.04073403f, 0.14500014f, -0.01469039f, 
    -0.01569341f, 0.00284688f, 0.09937582f, -0.09061706f, -0.09874108f, 0.00791705f, 0.03577165f, 0.08432969f, 
    0.02151737f, 0.11458334f, 0.06731684f, 0.03836129f, -0.02405508f, -0.06348098f, -0.07145234f, -0.15431510f, 
    0.08440352f, -0.23609932f, 0.05151151f, 0.00394996f, 0.03052949f, 0.09137738f, -0.03234305f, 0.03595073f, 
    0.23192824f, 0.13715820f, 0.15583009f, 0.29169318f, -0.04132987f, 0.24816482f, -0.19967262f, 0.16792688f, 
    0.07785626f, 0.02636380f, -0.04596355f, -0.05080348f, -0.03796769f, -0.11458757f, -0.01821345f, -0.24818031f, 
    -0.02234831f, -0.14778130f, -0.07654483f, -0.04601071f, 0.03526411f, -0.01302800f, -0.10479148f, -0.05063875f, 
    -0.08535977f, -0.11207535f, -0.14700337f, -0.29544580f, 0.38491744f, -0.04741973f, -0.19397457f, 0.27125955f, 
    0.02692040f, 0.08589349f, -0.07393549f, -0.07177676f, -0.00079387f, -0.21757706f, 0.14751402f, 0.17821179f, 
    0.02782903f, 0.05854489f, 0.22659995f, 0.18176544f, -0.00266800f, -0.01150171f, -0.02843400f, -0.02918514f, 
    0.09888438f, 0.04178300f, -0.02501294f, 0.14149080f, 0.13159454f, -0.05961067f, -0.11790205f, 0.02919424f, 
    0.07207289f, -0.07954537f, 0.04306741f, -0.02405628f, -0.00443508f, 0.00790584f, -0.06546894f, -0.16397230f, 
    -0.01858667f, -0.11065923f, 0.24798690f, 0.02232496f, 0.01472792f, -0.16125733f, -0.09912836f, -0.10896913f, 
    -0.10408773f, 0.02206547f, -0.10322119f, -0.26010683f, -0.05877063f, -0.04156598f, 0.02882397f, -0.06281687f, 
    -0.01543839f, -0.01201766f, 0.03512254f, 0.08447722f, -0.12864834f, 0.01597126f, -0.10213902f, -0.04517385f, 
    -0.04846448f, 0.09913459f, -0.02328244f, -0.06114442f, 0.06301663f, -0.03742403f, -0.02032191f, -0.13175477f, 
    -0.01136275f, -0.00614657f, -0.13428667f, -0.12020577f, -0.00233608f, 0.04741603f, -0.05758418f, 0.03044111f, 
    0.07565539f, -0.07959334f, 0.01390825f, -0.03451610f, -0.11839469f, -0.09234051f, -0.11698639f, -0.04772282f, 
    0.20096694f, 0.39484990f, 0.07303052f, 0.06800812f, -0.04917581f, -0.07833315f, -0.05701048f, 0.03300228f, 
    -0.15961918f, 0.15292414f, 0.10545243f, -0.03127414f, 0.02816462f, -0.16339152f, -0.01293254f, 0.09451923f, 
    0.04867497f, -0.00682676f, 0.02405835f, 0.13472006f, 0.10348286f, -0.00445213f, 0.07920862f, 0.07068502f, 
    0.20998931f, -0.10191932f, 0.21538667f, -0.26484489f, -0.06014820f, -0.17470413f, -0.21841459f, -0.13023928f, 
    -0.13671626f, 0.08635263f, 0.01450985f, -0.04729190f, -0.08616016f, 0.01239242f, -0.04691051f, 0.08748674f, 
    0.15608917f, 0.10775281f, 0.05634782f, -0.05190263f, 0.12296806f, 0.06317131f, 0.05172280f, 0.01170230f, 
    0.04769963f, 0.13194928f, 0.01159693f, 0.07025769f, 0.11143140f, 0.05191325f, 0.04149894f, -0.05798316f, 
    -0.07356381f, -0.07773283f, -0.15797941f, -0.13283706f, 0.01051489f, 0.05322646f, 0.14331628f, 0.09683926f, 
    0.17839724f, 0.14368528f, 0.06363028f, 0.05704961f, 0.09334768f, 0.06879552f, -0.03367138f, 0.08163878f, 
    -0.03463635f, -0.05163595f, 0.16177443f, 0.12324840f, -0.00319249f, 0.01294464f, 0.05809817f, 0.05556720f, 
    0.08674543f, 0.10933640f, 0.19532712f, 0.10860135f, 0.09267943f, -0.10248246f, -0.01408363f, -0.00573967f, 
    0.00451596f, 0.01139788f, -0.08332079f, -0.23601076f, -0.01270768f, 0.07541136f, 0.08926971f, 0.13427109f, 
    -0.00513996f, -0.02422533f, -0.02305804f, -0.01785576f, -0.02748145f, -0.01745064f, -0.02249134f, 0.01056297f, 
    0.02079300f, -0.01829740f, -0.03100801f, -0.01188110f, 0.01629388f, 0.00556259f, 0.02156890f, 0.00879965f, 
    0.02129886f, -0.01939072f, 0.00757503f, -0.00109357f, -0.03669326f, 0.01169485f, -0.00530353f, -0.01785770f, 
    -0.01572297f, -0.00939795f, -0.04201026f, -0.00001521f, 0.02301964f, -0.01870553f, -0.02520820f, -0.04291622f, 
    0.00615275f, 0.02514354f, 0.01140438f, 0.01982507f, 0.01493371f, 0.01261711f, -0.00676979f, -0.03562040f, 
    -0.00650593f, -0.03033180f, -0.01028548f, -0.01938968f, -0.01748135f, -0.00311996f, 0.00721698f, -0.03272366f, 
    -0.02171383f, -0.00490972f, -0.03248421f, 0.01587308f, -0.00672354f, 0.01627830f, 0.00850073f, 0.00060607f, 
    0.00904593f, 0.01930412f, -0.03843233f, -0.00067928f, 0.02245990f, -0.00022502f, -0.03773544f, -0.02693599f, 
    -0.00872513f, 0.01125213f, 0.01739437f, 0.00334063f, -0.04284977f, -0.04334750f, -0.03067905f, -0.04329695f, 
    0.02058012f, -0.02343436f, -0.02596904f, -0.03446692f, -0.00646940f, 0.00429117f, -0.03066447f, 0.00254078f, 
    -0.04010498f, 0.01986497f, -0.01080804f, 0.02723022f, -0.04304915f, 0.01446336f, 0.00934456f, 0.00205748f, 
    0.00921319f, -0.00569153f, 0.02578867f, 0.00091789f, -0.00448812f, 0.00898259f, -0.01026549f, -0.00239098f, 
    -0.01084961f, 0.00069071f, 0.01743809f, -0.04310252f, 0.02380329f, 0.02916234f, -0.02575365f, -0.02795966f, 
    0.01776478f, -0.04401923f, -0.04071313f, -0.01807879f, -0.03844560f, 0.00208840f, -0.02545661f, 0.02182997f, 
    0.00547960f, -0.02439101f, 0.00833705f, 0.02155942f, -0.00032708f, 0.00374125f, 0.00182024f, -0.01238161f, 
    -0.00379798f, 0.02087571f, -0.01620309f, 0.02615909f, -0.03162673f, -0.02637351f, -0.03685606f, -0.02191212f, 
    -0.03447298f, -0.01923875f, -0.02428530f, 0.02692851f, -0.03059037f, -0.02257687f, -0.01801471f, -0.02453216f, 
    0.00269621f, -0.03485136f, 0.00857919f, -0.03841516f, -0.00934617f, -0.02967601f, -0.00303823f, 0.02420852f, 
    -0.04146491f, -0.02544369f, 0.00145434f, 0.02171686f, -0.03928613f, -0.02161572f, 0.01223585f, -0.01977517f, 
    -0.00200119f, 0.01618436f, 0.00265551f, -0.01655810f, -0.02996377f, -0.01885066f, -0.00014654f, -0.02325501f, 
    0.01637148f, 0.04121709f, 0.01050757f, 0.01171902f, -0.03590899f, -0.02079167f, -0.01730102f, -0.03959306f, 
    -0.02928024f, -0.00930885f, 0.00420207f, -0.01974409f, -0.04202389f, -0.03358953f, -0.03792205f, 0.01016605f, 
    0.02186734f, -0.01624764f, 0.02097530f, -0.02599639f, -0.02432629f, 0.01847732f, -0.02561561f, 0.00550894f, 
    0.01251585f, -0.04301916f, -0.01449820f, 0.00409405f, -0.01366375f, -0.02982636f, -0.04075253f, 0.00843745f, 
    0.02703658f, 0.01615108f, -0.01873465f, 0.03282590f, 0.01727285f, 0.00713510f, -0.01474014f, 0.00923831f, 
    0.02546974f, -0.04284102f, -0.01733545f, -0.03955473f, 0.00003340f, -0.01735312f, -0.00046280f, 0.01329392f, 
    -0.01826207f, 0.00313825f, -0.03131984f, -0.01406606f, -0.02651171f, -0.00321449f, -0.02740309f, -0.03206857f, 
    -0.00688240f, -0.01623962f, -0.02234011f, -0.02067656f, -0.01651899f, -0.00165866f, -0.01026680f, -0.01159151f, 
    -0.03696893f, -0.02668711f, -0.02358823f, 0.00580498f, 0.00193603f, -0.01838064f, -0.00780463f, -0.02008388f, 
    -0.01608962f, 0.01911574f, -0.00799977f, -0.03410520f, 0.01844936f, -0.01211826f, -0.04078127f, -0.00739751f, 
    0.01693117f, 0.00027327f, 0.00737220f, -0.00175727f, -0.01654735f, -0.01291004f, -0.01530490f, 0.00641230f, 
    0.01832219f, -0.03159849f, -0.01042771f, -0.03342655f, -0.02324789f, 0.01304704f, -0.03429466f, 0.02141493f, 
    -0.00884703f, -0.03199736f, -0.00985276f, 0.04056723f, -0.02585055f, -0.00333182f, 0.01340025f, 0.02643016f, 
    -0.02156967f, -0.02536169f, 0.00115025f, 0.01092478f, 0.00487101f, 0.01811551f, -0.04428863f, -0.00440363f, 
    -0.01194106f, 0.02825914f, 0.01570604f, 0.02245262f, -0.03606761f, -0.01270963f, 0.00476861f, -0.00271384f, 
    0.02513706f, 0.03080698f, -0.02552782f, 0.02176124f, -0.02133982f, -0.02154678f, -0.00181182f, -0.02406204f, 
    -0.00350307f, -0.01851371f, -0.00641568f, 0.03423591f, -0.00995503f, 0.01715333f, -0.01710263f, -0.02298382f, 
    0.02868565f, 0.01005322f, 0.01576053f, -0.02335612f, -0.02681883f, 0.02402234f, -0.03294951f, -0.01507858f, 
    -0.01139799f, -0.02166905f, -0.02116845f, 0.02554309f, 0.01518301f, 0.02027167f, 0.00808086f, -0.04298059f, 
    0.03304993f, 0.00485773f, 0.03548313f, 0.01162573f, -0.03835048f, -0.01250990f, 0.02725185f, 0.00753700f, 
    -0.03675504f, 0.00289952f, -0.01414507f, -0.01359603f, 0.02224450f, -0.03971590f, -0.03358296f, 0.02050263f, 
    -0.00665328f, 0.01198529f, 0.02303677f, -0.00893941f, -0.01465481f, -0.01336294f, 0.00896184f, 0.00297465f, 
    -0.01957052f, -0.02730797f, 0.01238242f, -0.01872005f, 0.01450422f, 0.02189309f, -0.02493316f, -0.00997930f, 
    0.02456669f, -0.01667329f, 0.00431266f, 0.00928067f, -0.02321166f, 0.01971557f, -0.02958732f, -0.04258648f, 
    -0.01969529f, -0.02356711f, -0.01246283f, -0.01872314f, -0.01662346f, 0.02765533f, 0.02510429f, -0.02887212f, 
    0.01212635f, 0.01163689f, -0.03700814f, -0.01114887f, 0.01297679f, 0.02791241f, -0.01443035f, 0.02635746f, 
    -0.01667661f, 0.02397831f, -0.02646964f, -0.01625884f, 0.01838064f, -0.00885871f, -0.00136840f, -0.03952843f, 
    -0.02210080f, -0.00620710f, -0.00540364f, 0.02699748f, 0.00359295f, 0.01459831f, 0.01806351f, -0.00010022f, 
    -0.03786455f, -0.00881740f, -0.03957369f, -0.02016410f, -0.03376757f, -0.02556915f, -0.02608381f, -0.00019528f, 
    -0.01055629f, -0.02899347f, 0.02826267f, 0.00644987f, 0.01914268f, 0.02451150f, 0.01514782f, 0.03779239f, 
    -0.03683187f, -0.02614656f, -0.01520817f, 0.03165257f, -0.02983249f, 0.03138756f, 0.02178557f, 0.03204241f, 
    -0.00606743f, 0.00881965f, 0.00773058f, 0.02776734f, -0.04032583f, -0.00801641f, -0.02200574f, -0.04211424f, 
    0.01375392f, 0.02221126f, -0.02044472f, -0.02174306f, 0.03822247f, -0.00889648f, 0.00332377f, -0.00012021f, 
    0.01941747f, 0.00474281f, -0.03833846f, 0.02783672f, 0.00856372f, 0.02526908f, -0.00627004f, 0.01019955f, 
    -0.01649405f, 0.02419010f, 0.02136800f, 0.01642518f, 0.00504006f, -0.00309336f, 0.00817787f, -0.02704173f, 
    -0.00207908f, -0.01078538f, 0.04025723f, -0.00053472f, 0.01338837f, 0.02753989f, -0.01471400f, -0.03655592f, 
    -0.02467507f, -0.00829620f, -0.01041790f, -0.01485223f, 0.01147607f, 0.02042705f, -0.02110603f, -0.03552320f, 
    0.00124349f, -0.00178806f, 0.01532661f, 0.01643940f, -0.02254575f, 0.02746306f, -0.00966410f, -0.01967409f, 
    0.01158114f, 0.00645965f, -0.01515894f, 0.02550841f, 0.01746701f, -0.01163589f, 0.00105409f, 0.03355259f, 
    -0.00907098f, -0.00947175f, 0.01560237f, 0.00685040f, 0.01472203f, -0.00981700f, -0.02406775f, 0.02191970f, 
    -0.01329815f, -0.00488341f, 0.02134368f, -0.02832505f, 0.01148069f, -0.00593189f, -0.02960689f, -0.00669501f, 
    0.02286174f, 0.00282756f, -0.00234424f, -0.02024263f, -0.02241116f, 0.01510122f, 0.00216043f, -0.01944383f, 
    -0.01383741f, 0.01897497f, -0.02404640f, -0.03190508f, -0.01648713f, 0.00603390f, 0.03441982f, -0.02172882f, 
    0.02252154f, 0.00491323f, -0.01017506f, 0.02505939f, 0.03628099f, -0.00411125f, -0.02109564f, 0.03172363f, 
    -0.03360412f, -0.03999875f, 0.01956251f, 0.01903985f, -0.02699082f, 0.01735486f, -0.01252016f, -0.00048973f, 
    -0.02330058f, -0.02763000f, 0.01814414f, -0.01835744f, 0.02391444f, -0.02431072f, -0.02405653f, -0.02392193f, 
    0.03242609f, -0.00788614f, 0.03637049f, 0.04038144f, 0.03585638f, 0.03805831f, -0.00412701f, 0.00853243f, 
    -0.01573741f, 0.01536289f, -0.02267496f, -0.01552257f, 0.03591098f, 0.03509576f, -0.01574882f, -0.00266019f, 
    -0.00845551f, -0.00547675f, -0.02978720f, -0.03344197f, 0.00570276f, -0.03381202f, 0.02055124f, -0.04026527f, 
    -0.01137545f, -0.01983080f, 0.00394548f, -0.00503441f, -0.02571842f, 0.00536644f, 0.02141675f, -0.02910289f, 
    -0.03862041f, 0.02844489f, -0.02101851f, 0.00820594f, -0.04231278f, -0.02893525f, -0.03584485f, -0.00322816f, 
    -0.01134150f, 0.01894848f, -0.00839987f, 0.02416656f, 0.00016867f, -0.04163224f, -0.02135315f, 0.00336053f, 
    -0.00805076f, 0.02380637f, 0.00114588f, 0.02423889f, 0.01453930f, -0.03899890f, -0.02647161f, 0.02729823f, 
    -0.04395763f, 0.01009204f, -0.00942005f, 0.01109677f, -0.00207345f, -0.03873412f, -0.01600952f, -0.00615812f, 
    -0.03039033f, -0.02296197f, 0.00841144f, -0.01363677f, -0.03684628f, 0.02584188f, 0.02932371f, 0.02432543f, 
    -0.01565638f, 0.00789788f, -0.04211252f, -0.04284800f, 0.01648598f, 0.01943303f, -0.02329885f, 0.01353555f, 
    -0.01250512f, -0.03663699f, 0.01520020f, -0.02168292f, 0.00318461f, 0.03870166f, 0.01574900f, 0.00100825f, 
    -0.01168390f, -0.02920317f, 0.02805159f, 0.01052228f, 0.00586970f, -0.01909974f, 0.01631860f, 0.00290405f, 
    0.02137028f, -0.00176357f, 0.00856047f, -0.01382787f, -0.02321212f, 0.00217654f, -0.02172236f, 0.00723722f, 
    -0.02508230f, -0.02861537f, 0.01954549f, 0.02253438f, 0.02470092f, 0.01753010f, -0.02013661f, -0.02774671f, 
    -0.00509819f, 0.02211143f, -0.03479915f, 0.01957799f, -0.04208587f, 0.02556591f, -0.03627374f, 0.00014390f, 
    -0.02549833f, -0.01824791f, 0.02572391f, -0.01381365f, 0.00136996f, -0.00147763f, -0.02407770f, -0.00652730f, 
    -0.01261122f, -0.03101884f, -0.02936782f, 0.02343843f, -0.02121866f, -0.01744630f, -0.02637559f, -0.01158739f, 
    0.00698152f, 0.03122213f, -0.00387504f, -0.00051627f, 0.00433703f, -0.03573395f, 0.01001978f, -0.01262084f, 
    -0.03488186f, -0.03618690f, -0.04395934f, -0.01325970f, -0.02174636f, -0.02674782f, -0.02984077f, -0.03808288f, 
    -0.01683501f, 0.00923259f, -0.01352485f, -0.03566740f, 0.00422321f, 0.01357246f, -0.01933199f, -0.01653088f, 
    0.02878942f, 0.02277387f, -0.01012411f, 0.01111898f, -0.00728766f, 0.01385737f, 0.01494909f, -0.03332872f, 
    0.00442737f, 0.02754040f, -0.00485781f, 0.02515844f, -0.02386519f, -0.01472565f, -0.02606272f, 0.00894445f, 
    0.02679904f, -0.00535308f, -0.00787557f, 0.00786864f, -0.03427246f, -0.03822451f, 0.00786147f, -0.01325732f, 
    -0.03706440f, -0.03986836f, 0.02286497f, -0.01134861f, -0.02370094f, 0.02399445f, 0.00405516f, 0.00453788f, 
    -0.01257041f, 0.00228247f, 0.01308904f, 0.01820652f, -0.03094240f, -0.00673892f, -0.02512761f, -0.02683204f, 
    -0.00491879f, 0.00476944f, 0.01552451f, -0.02958442f, -0.01635366f, -0.02745020f, 0.03027832f, -0.02130738f, 
    -0.01307364f, -0.01806770f, -0.02086274f, 0.00961537f, -0.03417324f, -0.02784487f, -0.00762942f, -0.03162449f, 
    -0.00667426f, -0.02544807f, 0.02524589f, -0.02687746f, -0.01526124f, 0.02327533f, 0.01208122f, -0.01449298f, 
    0.00670723f, -0.01275694f, 0.02879790f, -0.00374555f, -0.03285328f, -0.03164679f, -0.04161442f, -0.02964052f, 
    -0.03002851f, 0.01575748f, 0.01222236f, -0.03152874f, -0.01374289f, -0.02585029f, 0.01968165f, -0.03486150f, 
    0.00105116f, 0.03568293f, 0.01356327f, -0.02959595f, -0.01081872f, 0.00751467f, 0.00012624f, -0.02840954f, 
    0.01199986f, -0.02355148f, -0.00934079f, -0.00996406f, -0.02325903f, -0.01690201f, 0.01239766f, -0.02363333f, 
    0.00600100f, -0.00222684f, -0.03225947f, -0.02296421f, 0.01722240f, -0.02691440f, 0.02832804f, -0.00166412f, 
    -0.01141022f, -0.03978459f, 0.02687934f, -0.00219381f, 0.00756107f, -0.00874909f, -0.01291449f, 0.02285643f, 
    0.02271604f, -0.03249022f, 0.00274272f, -0.00292982f, -0.03325273f, 0.00356314f, 0.02573676f, -0.01073866f, 
    0.02347602f, -0.03824544f, 0.02775212f, -0.02106304f, -0.00574495f, 0.02301923f, -0.01181524f, 0.01652396f, 
    0.00863156f, 0.01641844f, 0.02615433f, -0.03486780f, -0.02472362f, -0.00175346f, 0.00600915f, -0.02024031f, 
    0.00123447f, 0.00301568f, 0.01620307f, -0.00543689f, -0.00588378f, -0.02273513f, 0.00947896f, -0.01387604f, 
    -0.02268003f, 0.01442749f, -0.02058221f, -0.01186124f, -0.02386200f, 0.02198487f, 0.01428048f, 0.02653487f, 
    0.03070011f, -0.02459566f, -0.02705217f, 0.01680980f, -0.02364940f, 0.02237675f, -0.00621447f, 0.02733978f, 
    0.00449286f, -0.04364780f, 0.00172294f, 0.02069896f, 0.02309121f, -0.01569223f, 0.00349216f, -0.00902236f, 
    -0.01489838f, 0.00199389f, 0.01841638f, -0.04037079f, -0.01505875f, -0.04288842f, -0.03732179f, 0.02725680f, 
    0.01310430f, -0.02798017f, 0.01535390f, 0.00525774f, 0.00365258f, 0.00046986f, 0.00400672f, 0.02180403f, 
    -0.02204803f, 0.01830469f, 0.02249945f, -0.00572762f, 0.00995617f, -0.00181926f, -0.01864250f, 0.00167669f, 
    -0.03075695f, -0.00731131f, 0.00031887f, 0.00967142f, -0.00248115f, -0.01081479f, -0.01735355f, 0.02653088f, 
    -0.03291702f, -0.03120235f, 0.00821544f, -0.03078338f, -0.00436082f, -0.01766081f, -0.01638121f, -0.02444045f, 
    -0.01253450f, 0.01664525f, -0.01669995f, -0.00983593f, -0.00550129f, -0.00116440f, 0.01565126f, -0.04112824f, 
    -0.04294951f, 0.01296040f, 0.02317468f, 0.00085331f, -0.03113033f, -0.00034162f, -0.00239750f, -0.03184210f, 
    -0.02531924f, -0.04149522f, 0.00870643f, 0.02166709f, -0.01097273f, 0.02933960f, 0.00742823f, -0.02198399f, 
    0.02385924f, -0.00612255f, 0.00691986f, 0.02103238f, -0.03877205f, -0.01132390f, 0.00427567f, 0.00440739f, 
    0.01082951f, 0.03235712f, -0.00020963f, -0.02660002f, -0.01500069f, -0.01380687f, 0.02652269f, 0.01844611f, 
    -0.01635883f, 0.00700141f, 0.00997510f, -0.03465629f, -0.03669012f, -0.01394233f, -0.00858154f, -0.03901219f, 
    0.02279280f, -0.00107349f, 0.01852051f, -0.03652471f, 0.01453563f, 0.01882089f, -0.01438939f, 0.02693524f, 
    0.01881640f, 0.01406142f, -0.01533193f, -0.03634156f, -0.00343159f, -0.01841249f, -0.00317916f, -0.01449576f, 
    -0.01363667f, -0.02344737f, 0.00135792f, 0.01539332f, -0.01261614f, -0.01526401f, 0.01155804f, -0.02982634f, 
    -0.00573120f, 0.01860070f, -0.01834870f, 0.00437720f, 0.00065917f, -0.02294677f, -0.02239996f, -0.01839796f, 
    0.03116417f, 0.03002067f, -0.02922728f, -0.01855723f, 0.01186195f, -0.02839902f, 0.01628473f, -0.01705561f, 
    0.01570469f, 0.00540425f, -0.03346935f, 0.02246005f, -0.00304345f, -0.04106413f, -0.01250766f, 0.01014312f, 
    -0.04082695f, 0.00319367f, -0.03735723f, 0.01078504f, 0.02114681f, -0.00546662f, 0.02484201f, 0.02095160f, 
    -0.02180794f, -0.00651261f, 0.02037561f, -0.02733113f, 0.00264292f, 0.01263975f, -0.04044404f, 0.02413607f, 
    -0.03865140f, -0.01174164f, 0.01223028f, -0.03460953f, -0.02972884f, 0.02394091f, 0.01270490f, 0.00163457f, 
    0.01862367f, -0.04360880f, 0.00655057f, -0.03792527f, -0.01868532f, -0.03600333f, 0.02713506f, 0.00048036f, 
    -0.01748315f, -0.01109225f, -0.02130195f, -0.03086741f, 0.02443006f, 0.02554462f, -0.01458084f, 0.03399319f, 
    -0.01031286f, 0.01382757f, 0.00915080f, -0.02126047f, 0.02032781f, -0.00303320f, -0.04135690f, -0.01759606f, 
    0.00500570f, 0.01578958f, 0.02988741f, -0.00766118f, -0.00211103f, 0.00723984f, 0.00754871f, 0.00023957f, 
    -0.01638251f, -0.02752181f, 0.01707825f, 0.01801825f, -0.02825350f, -0.00032556f, -0.02064346f, -0.03634153f, 
    0.04108331f, 0.02871133f, -0.00241911f, -0.02313683f, -0.02418957f, -0.01166986f, 0.04235827f, 0.00332888f, 
    0.03614980f, 0.00278029f, 0.01060497f, -0.03954332f, 0.04018476f, 0.00516542f, -0.01726898f, -0.02317903f, 
    0.00384074f, 0.01508468f, -0.04191806f, -0.02503891f, 0.00760252f, 0.02041971f, -0.00842118f, 0.01830204f, 
    -0.02435434f, -0.01683477f, -0.02940789f, 0.00267473f, -0.03092234f, -0.03632944f, 0.01528214f, 0.01855965f, 
    0.01423273f, -0.01354446f, -0.03198946f, 0.02336247f, 0.00268186f, -0.03863049f, -0.01830497f, 0.00975979f, 
    -0.01376401f, 0.02642140f, -0.02575165f, -0.01809942f, 0.01324628f, -0.01134482f, 0.01117671f, -0.02822737f, 
    -0.00449506f, -0.00694117f, -0.02265369f, 0.02038860f, -0.00094588f, 0.02308068f, -0.01097472f, 0.01126013f, 
    0.00421005f, -0.00616170f, -0.02427650f, -0.02281432f, -0.01648192f, -0.01682022f, -0.01788075f, -0.00722338f, 
    -0.02198839f, -0.00946366f, 0.02349863f, -0.03410767f, -0.00252138f, 0.01431846f, -0.03683550f, 0.02010995f, 
    0.01666758f, 0.01482043f, -0.01500662f, 0.01365987f, -0.03506135f, -0.03664773f, -0.02890857f, -0.00608875f, 
    -0.02969594f, 0.00274610f, 0.02234250f, 0.02031174f, 0.00222906f, 0.01468605f, -0.01888056f, -0.00074202f, 
    -0.04248387f, -0.00609192f, 0.00877346f, -0.03265180f, -0.01754973f, 0.01179265f, 0.00589938f, 0.02310832f, 
    -0.04272501f, -0.00771144f, -0.02357380f, -0.00913114f, 0.00845771f, 0.02500967f, -0.01730882f, -0.01522468f, 
    -0.01280475f, -0.02193145f, -0.00423582f, 0.02438670f, 0.01520634f, 0.00496309f, -0.02278483f, -0.00266315f, 
    0.01931841f, 0.02506143f, 0.01977051f, -0.03098199f, -0.00650629f, -0.01474543f, 0.00510031f, -0.03796591f, 
    -0.00448263f, 0.00274039f, -0.03893497f, 0.01688642f, 0.00997441f, 0.00424742f, -0.00110700f, -0.02947483f, 
    -0.04224886f, -0.00896790f, -0.03997899f, -0.03057469f, 0.00766024f, -0.01431648f, -0.02206748f, -0.02513260f, 
    -0.00550597f, 0.02537896f, -0.03468071f, 0.02196004f, -0.00347722f, 0.01489544f, -0.01124866f, -0.02924683f, 
    -0.03974211f, -0.01354288f, 0.01594277f, -0.00344189f, -0.03134716f, -0.02608324f, -0.01720038f, -0.00700343f, 
    -0.02874799f, -0.02578608f, 0.00667772f, -0.02723809f, -0.03212585f, 0.00732513f, -0.01545249f, -0.01830711f, 
    0.02350055f, 0.00632488f, -0.04008375f, -0.02169844f, 0.02045369f, -0.02182695f, 0.02126925f, -0.00617171f, 
    -0.00079654f, -0.04137610f, 0.00247651f, -0.02273204f, -0.01762190f, 0.00046537f, -0.02378480f, -0.04129178f, 
    -0.03178670f, 0.01464622f, 0.02234505f, -0.00380609f, 0.01466706f, 0.00408646f, 0.03155169f, -0.01835660f, 
    0.01613409f, -0.03056742f, -0.00920387f, 0.02411818f, 0.00236474f, -0.00496872f, 0.02018027f, 0.00554436f, 
    0.02207461f, 0.01113050f, -0.02511613f, 0.02535680f, -0.00091940f, 0.00971899f, 0.01807094f, -0.02894751f, 
    0.02666166f, 0.01483879f, -0.01706288f, 0.00206370f, -0.02787618f, 0.00784010f, 0.03313676f, -0.00702473f, 
    -0.01657147f, 0.03010201f, 0.02953124f, 0.02325002f, 0.02894204f, -0.00607356f, -0.01803652f, -0.02957723f, 
    -0.00609293f, -0.00498014f, 0.00272210f, -0.00958901f, 0.00059342f, -0.00803569f, -0.03646698f, 0.00373477f, 
    -0.04075488f, -0.01955959f, -0.01307476f, -0.03667676f, 0.02921065f, 0.00258002f, -0.00774005f, -0.00716416f, 
    -0.01782874f, 0.00705032f, 0.01673331f, 0.03341885f, -0.01031683f, -0.03047136f, -0.04269152f, 0.01112181f, 
    0.02975851f, -0.01565401f, -0.02262323f, 0.00548774f, -0.02767803f, -0.01877442f, -0.00006618f, 0.01184111f, 
    -0.01719611f, -0.00742369f, -0.00318551f, -0.01243421f, 0.00080957f, 0.00518262f, -0.00010408f, 0.00977647f, 
    0.02209381f, 0.01705522f, 0.02855950f, 0.00039426f, 0.02510536f, -0.03828494f, 0.01976328f, 0.01671020f, 
    -0.01684358f, -0.03728018f, -0.03028647f, -0.01250851f, 0.02539577f, -0.00393264f, -0.02702299f, 0.01171876f, 
    0.02564858f, -0.03020205f, 0.00919732f, -0.01669229f, -0.03938664f, -0.00346615f, -0.02166036f, -0.03393798f, 
    -0.02155478f, 0.00606056f, 0.00441622f, -0.03350671f, 0.02211045f, -0.03147506f, 0.01030377f, -0.00904888f, 
    -0.03642047f, -0.03323422f, -0.03356319f, -0.02421788f, 0.02798248f, -0.01820288f, -0.02066959f, -0.01641207f, 
    0.00118139f, 0.00641055f, -0.03778527f, 0.01689379f, 0.00130524f, -0.00372132f, 0.04048655f, 0.01397875f, 
    -0.00602695f, -0.02402241f, 0.00222299f, -0.00603175f, 0.00501234f, 0.00744010f, -0.00583709f, -0.00558226f, 
    0.00051240f, -0.01020195f, -0.02432058f, 0.01986941f, -0.00429009f, 0.01699669f, -0.00042043f, -0.00788763f, 
    -0.00078037f, -0.01140876f, -0.03442824f, 0.02498628f, 0.01533662f, -0.02807238f, -0.00828794f, 0.01307743f, 
    -0.01233843f, -0.01465647f, -0.01801606f, -0.00587890f, -0.03062221f, -0.00376900f, 0.02059389f, -0.00166477f, 
    0.00351574f, -0.02322008f, -0.00410415f, -0.02128405f, -0.04147296f, -0.01247659f, 0.01761269f, -0.04078216f, 
    -0.04171465f, 0.02550626f, 0.01139885f, -0.01729011f, 0.01633455f, 0.02854826f, -0.01921109f, -0.01297371f, 
    0.01289943f, 0.01524621f, -0.03828247f, -0.01856739f, 0.02427305f, -0.04205078f, -0.00283651f, 0.02460914f, 
    -0.01160572f, 0.00790161f, 0.00485403f, -0.00424277f, 0.00225549f, -0.03601191f, -0.01717300f, -0.02218676f, 
    -0.02638382f, 0.02663398f, -0.03793831f, -0.02215495f, -0.00977811f, 0.04102190f, -0.02626535f, 0.01851677f, 
    0.02361806f, 0.00205567f, -0.01917035f, 0.03377562f, -0.03248121f, 0.01978570f, -0.00803983f, -0.01769514f, 
    -0.01584724f, -0.00791370f, -0.00862850f, -0.01419521f, -0.01988691f, -0.00581974f, -0.02541695f, -0.03482261f, 
    0.02035295f, -0.03808556f, -0.03455348f, 0.01467862f, -0.02283992f, -0.02835745f, -0.01178270f, 0.01811919f, 
    -0.00763723f, 0.00293970f, -0.02780707f, -0.03824989f, -0.02832898f, -0.00136875f, -0.01983359f, -0.01292424f, 
    -0.00057702f, -0.02921529f, 0.02651378f, -0.02885894f, -0.03655610f, 0.02666326f, 0.02496732f, -0.03355253f, 
    -0.01294660f, 0.01239105f, 0.00376931f, 0.00427137f, 0.00245552f, -0.00285262f, -0.03941915f, 0.00938134f, 
    0.02421868f, 0.00528960f, -0.03422678f, -0.03153558f, 0.02173156f, 0.00275173f, -0.03779902f, -0.04160426f, 
    -0.00715316f, 0.02734358f, 0.02289477f, 0.01423131f, -0.03796691f, -0.01429869f, -0.02769648f, 0.02154329f, 
    0.02022392f, 0.01214778f, -0.02912122f, -0.02910602f, 0.01454061f, 0.02165087f, -0.00944699f, -0.00594819f, 
    0.02847672f, -0.01820789f, 0.01664953f, 0.03874164f, -0.04377764f, -0.00155609f, 0.00349402f, 0.00410136f, 
    0.01289803f, 0.00962028f, 0.01126260f, -0.00317344f, 0.01669401f, -0.02331752f, 0.01974779f, 0.03434617f, 
    0.00921832f, 0.01648406f, -0.03262533f, 0.00089564f, 0.00692849f, 0.00274592f, 0.01975840f, -0.04060747f, 
    -0.02582763f, 0.02469224f, 0.01808419f, 0.00387543f, -0.02402118f, 0.02183195f, 0.01141437f, -0.01962183f, 
    0.08103527f, 0.21489440f, -0.12214373f, -0.02608196f, -0.01597559f, 0.00841869f, 0.03862703f, -0.01049674f, 
    -0.01628161f, -0.03440974f, -0.03860126f, -0.06729136f, 0.42575559f, -0.12622882f, 0.05940694f, 0.01140275f, 
    -0.06185305f, -0.16856767f, -0.03577370f, -0.03941164f, 0.09578315f, 0.10602376f, -0.06542495f, -0.11470446f, 
    0.01551132f, -0.01603665f, -0.06063833f, -0.02423176f, -0.02159619f, 0.04802340f, 0.03600066f, -0.07460627f, 
    0.02150365f, 0.02011698f, 0.10524312f, 0.23933905f, -0.00021940f, -0.02457236f, -0.05534702f, -0.03576352f, 
    -0.08431213f, -0.03594603f, -0.02626692f, 0.02507412f, 0.10150055f, 0.11360112f, 0.03489496f, 0.03977521f, 
    0.41718817f, -0.03926920f, -0.15100501f, 0.04035922f, -0.09282786f, 0.08055378f, -0.09346599f, -0.05734155f, 
    0.00221209f, -0.09325532f, -0.11855122f, -0.04648453f, -0.11931909f, 0.03355401f, -0.32845008f, 0.04270098f, 
    -0.03277363f, -0.06250229f, 0.03021943f, 0.00410911f, -0.08447158f, 0.02016206f, -0.11909323f, -0.11366682f, 
    -0.06384825f, -0.05284766f, 0.09545348f, -0.01391482f, -0.03495422f, 0.02100161f, -0.00363381f, -0.01628986f, 
    0.05107739f, -0.06239672f, -0.02816644f, 0.00179056f, -0.04116428f, -0.04884930f, 0.11409242f, -0.10676027f, 
    -0.06373057f, -0.05589688f, -0.00111294f, -0.03308143f, 0.09309866f, 0.06639107f, 0.05469921f, -0.03783729f, 
    -0.02787963f, 0.05850996f, 0.12106590f, -0.05036582f, 0.08114793f, -0.13987520f, 0.10267605f, 0.21137440f, 
    0.05092017f, -0.00005465f, 0.05669554f, 0.05881769f, 0.09056221f, -0.02127626f, 0.09425867f, 0.05639990f, 
    0.03150430f, -0.12338164f, -0.07811086f, -0.04243255f, -0.09337775f, -0.22338158f, 0.00332730f, -0.02762091f, 
    -0.23921524f, -0.09742058f, -0.18771556f, -0.17094176f, 0.06330073f, 0.02000525f, 0.04458328f, 0.02601748f, 
    -0.24011165f, -0.11892562f, -0.09692339f, -0.20062400f, 0.15872954f, 0.02885467f, 0.06776027f, -0.12747592f, 
    -0.05162026f, 0.08369704f, -0.07345987f, -0.08352294f, 0.05357453f, 0.18470839f, 0.04118191f, 0.11927784f, 
    -0.03371665f, -0.13661359f, -0.32528275f, -0.22230572f, 0.00974911f, -0.02158748f, -0.09587196f, 0.04224479f, 
    0.05156263f, -0.05005661f, -0.02065129f, -0.13056162f, 0.08296059f, 0.11687274f, -0.13259581f, 0.01041901f, 
    -0.00740136f, 0.03755109f, 0.11072441f, 0.05208292f, -0.03420579f, 0.12225498f, -0.05962100f, 0.01054185f, 
    -0.02253654f, -0.08964781f, 0.34490010f, 0.07999215f, 0.00586254f, 0.00549248f, 0.02011576f, 0.04370011f, 
    0.06763024f, 0.02774465f, 0.13853511f, 0.01359310f, 0.22711760f, -0.03119787f, 0.11395711f, -0.33156466f, 
    0.12685844f, -0.05439796f, 0.15205611f, 0.11154192f, -0.11905327f, 0.19740120f, -0.06943289f, -0.22307067f, 
    0.15285015f, 0.05826287f, 0.02728021f, -0.02549665f, 0.01429007f, 0.06393064f, 0.12262577f, 0.05805913f, 
    0.10098282f, 0.05790135f, 0.00572473f, 0.03666404f, 0.22611107f, 0.07359199f, 0.13820250f, -0.16909528f, 
    0.10385729f, -0.05233778f, 0.01687568f, -0.10243793f, -0.13426316f, -0.00440991f, -0.05251704f, -0.11239848f, 
    -0.24635459f, -0.10912161f, 0.02870232f, -0.01995808f, 0.03003055f, -0.02165362f, 0.11168605f, 0.10746688f, 
    0.03269473f, -0.04734165f, -0.11064619f, -0.07511200f, 0.02045670f, 0.03866871f, 0.12722652f, 0.00521817f, 
    -0.05743735f, 0.02781756f, 0.02892845f, 0.09071429f, 0.07016966f, 0.05609878f, 0.02623519f, -0.07122871f, 
    0.13214350f, -0.12860398f, -0.12589778f, 0.07684596f, -0.04752845f, -0.01149940f, -0.03707920f, -0.00704786f, 
    0.23937578f, -0.00198515f, -0.00632647f, 0.23404084f, 0.03283503f, -0.21871102f, 0.31898838f, -0.10944772f, 
    0.06556273f, 0.10898089f, 0.02799609f, -0.02192361f, -0.10528632f, -0.03935757f, -0.02597269f, -0.00853121f, 
    0.01574811f, 0.06350476f, 0.05947320f, 0.01421285f, -0.13413288f, -0.03556963f, -0.00502058f, -0.08184163f, 
    0.15799394f, 0.19307934f, -0.14864592f, -0.06001571f, -0.00760471f, 0.07229718f, 0.16278388f, 0.04207506f, 
    0.12787910f, 0.09150629f, 0.07885030f, 0.14436539f, -0.07275829f, -0.03954731f, 0.02013619f, 0.03986029f, 
    0.17155623f, 0.19450565f, 0.10077320f, 0.08457533f, 0.07689412f, 0.11459634f, 0.04581367f, 0.10164011f, 
    -0.02702271f, -0.08625963f, -0.01767996f, 0.14920668f, 0.11561596f, -0.06782556f, -0.12995563f, -0.04080098f, 
    -0.09507331f, -0.01110459f, 0.03730931f, 0.02194353f, 0.10071860f, 0.02565298f, 0.05894052f, -0.02647217f, 
    -0.00083174f, -0.01576472f, 0.38489410f, -0.23608349f, -0.07852905f, 0.12067690f, 0.07630132f, 0.06293061f, 
    0.13529196f, -0.04541033f, -0.04248841f, -0.09802333f, -0.04125819f, -0.13152830f, -0.09699415f, 0.04191144f, 
    0.05168925f, 0.10510561f, 0.00843385f, 0.05753161f, 0.09763511f, -0.03978250f, 0.07263064f, -0.11010761f, 
    0.08921121f, 0.01394758f, -0.07304695f, -0.26935619f, -0.04306829f, -0.05265082f, -0.01397191f, 0.11382481f, 
    0.07707748f, -0.14126508f, 0.03786585f, -0.18052460f, -0.25727510f, -0.05801853f, -0.03692609f, -0.13832352f, 
    0.21060281f, -0.02479981f, -0.06081112f, 0.11892099f, 0.02708035f, 0.02581566f, 0.07393198f, 0.06963845f, 
    -0.08371936f, -0.14299786f, -0.07454839f, -0.10006278f, -0.06952132f, -0.01735865f, -0.03805951f, 0.08179193f, 
    -0.04342787f, -0.10596703f, -0.00306232f, -0.11185730f, 0.10521737f, 0.11641641f, 0.17063938f, -0.05351601f, 
    0.00126210f, 0.04232648f, 0.11452636f, -0.04413700f, 0.01413169f, 0.02976060f, -0.02821144f, 0.04172460f, 
    0.08845042f, 0.19243301f, 0.15258336f, -0.08736032f, 0.20517221f, 0.10286528f, -0.04995227f, 0.10341378f, 
    -0.15947314f, -0.14200601f, 0.05512322f, 0.03513796f, 0.09493905f, 0.17026280f, 0.09260140f, -0.07005657f, 
    -0.01172276f, -0.02794704f, 0.00618676f, 0.02203310f, -0.06290167f, -0.00848258f, -0.03820627f, -0.18468471f, 
    0.01273111f, 0.10327023f, 0.09692556f, -0.01337886f, 0.11108911f, -0.01767244f, -0.09229547f, -0.08803880f, 
    -0.23721313f, -0.27368343f, -0.10829937f, -0.09258300f, 0.16030101f, 0.01476369f, 0.05808422f, 0.00142150f, 
    -0.07872356f, -0.00272139f, -0.06056822f, -0.13131663f, -0.12273519f, -0.12282462f, -0.11420356f, 0.00419941f, 
    -0.03603423f, -0.05122947f, 0.01260924f, -0.07978848f, 0.00074639f, -0.11185928f, 0.01278102f, 0.06135050f, 
    0.03978005f, 0.07095867f, 0.01693125f, -0.09602183f, -0.02370349f, 0.07339403f, 0.05907562f, -0.02312759f, 
    0.05213222f, 0.00643590f, -0.05452554f, 0.09711125f, -0.06205592f, 0.03771010f, 0.13154107f, 0.01202543f, 
    -0.07835417f, -0.10713421f, 0.11087060f, -0.02740614f, 0.05429787f, 0.15972826f, 0.10399237f, 0.00165919f, 
    -0.05368144f, 0.02022206f, -0.13198000f, -0.02870552f, 0.04629181f, 0.17428656f, 0.12787086f, 0.14002083f, 
    0.06009841f, 0.04180865f, 0.09194767f, 0.12241688f, 0.02431845f, -0.02362809f, -0.06720924f, 0.02552309f, 
    -0.18543243f, 0.03163452f, -0.05514057f, -0.05026134f, 0.07782311f, 0.01831502f, 0.02697546f, 0.00896076f, 
    0.12385889f, -0.08821517f, 0.07557201f, 0.22452883f, -0.05581529f, 0.00278510f, -0.04353601f, -0.09302031f, 
    0.06359649f, -0.04264345f, -0.06396186f, 0.10277028f, -0.10311977f, -0.07965699f, 0.09137364f, -0.19778615f, 
    -0.00722644f, 0.15907246f, 0.05659968f, 0.00469950f, -0.05080231f, 0.11058447f, 0.05050143f, 0.02283784f, 
    -0.03639340f, -0.05434521f, -0.05491715f, -0.04535373f, 0.06612577f, 0.12793648f, 0.02621588f, -0.13791826f, 
    0.11773444f, 0.07158347f, 0.11178439f, 0.05078344f, -0.04874692f, 0.00342350f, -0.02744995f, 0.01671918f, 
    0.10315006f, 0.07076311f, 0.18467677f, 0.02095167f, 0.02672025f, 0.05282826f, 0.00527781f, 0.13383378f, 
    -0.05450643f, 0.01619681f, -0.04286272f, -0.00933684f, 0.20516817f, 0.04807225f, 0.27131128f, -0.23004188f, 
    0.22897054f, -0.01070264f, 0.00292949f, 0.11606843f, -0.03477747f, 0.02991641f, 0.09683252f, 0.01261536f, 
    -0.02892586f, -0.04958779f, 0.01218563f, -0.02997605f, 0.06721272f, -0.04066208f, 0.00734841f, -0.13542275f, 
    -0.16218005f, -0.17120919f, -0.14551856f, -0.33224255f, 0.22434330f, -0.12246381f, 0.01979532f, 0.08534301f, 
    -0.05736367f, 0.02447874f, -0.01736233f, 0.03166495f, 0.05030435f, -0.02901595f, -0.04336093f, 0.06708389f, 
    -0.04427258f, -0.06449742f, 0.05102778f, 0.04381324f, -0.02599211f, 0.00530346f, -0.04135780f, -0.00636160f, 
    0.06324569f, -0.07542736f, 0.05813570f, 0.03293933f, -0.30336553f, -0.04435956f, 0.15086521f, -0.15892687f, 
    -0.04541929f, -0.13455608f, -0.04293073f, -0.07011898f, 0.12867214f, 0.10166065f, -0.18946131f, -0.09818451f, 
    -0.17227350f, -0.02194960f, -0.12808651f, -0.23552988f, -0.05404551f, -0.07324445f, -0.08440938f, 0.14808396f, 
    0.12651752f, 0.02252197f, -0.02921727f, -0.12767075f, 0.01065978f, 0.23086946f, 0.18233535f, 0.03831006f, 
    -0.00222985f, 0.14000428f, 0.00889895f, 0.01239655f, 0.08973674f, -0.11807426f, -0.09062008f, 0.01930068f, 
    -0.11913225f, -0.06957426f, 0.12658310f, -0.16223538f, 0.10212545f, 0.03072239f, 0.11831541f, -0.00209678f, 
    0.17524023f, -0.00884036f, -0.13895266f, 0.19624250f, 0.02461786f, 0.04799856f, 0.17087786f, 0.06931922f, 
    0.04809234f, -0.07593864f, 0.09433815f, 0.03748176f, 0.02086726f, -0.02388013f, 0.05481450f, 0.09684896f, 
    0.15258080f, -0.04176122f, -0.01513883f, 0.06007498f, 0.03626874f, 0.02046819f, 0.04771901f, 0.21145846f, 
    -0.03145778f, 0.13483779f, -0.01075425f, 0.11973832f, 0.09318007f, 0.11687259f, 0.04665181f, 0.06811243f, 
    0.14706759f, 0.11105750f, 0.10775688f, 0.09627850f, 0.00860787f, 0.04684014f, 0.08605292f, 0.00579097f, 
    -0.03366385f, -0.23469789f, -0.23678838f, -0.09799501f, -0.06742324f, -0.02811332f, -0.04935867f, -0.01303623f, 
    0.06118168f, -0.10439958f, -0.07783075f, 0.12178791f, 0.17725690f, 0.16549270f, 0.24324737f, 0.02177586f, 
    0.16159536f, 0.04021272f, 0.06612978f, 0.00622515f, -0.01764367f, -0.12122934f, 0.16770816f, -0.06473689f, 
    0.22954082f, 0.03509314f, -0.01988620f, 0.04940423f, -0.16987418f, 0.06347401f, -0.05901220f, 0.02107260f, 
    0.20144980f, -0.06752546f, 0.12417338f, 0.04492939f, 0.17183623f, 0.05478819f, -0.01301756f, -0.06273802f, 
    -0.15723702f, -0.13500643f, -0.14033474f, -0.04703939f, 0.11996342f, 0.10842486f, 0.06256742f, 0.03598912f, 
    -0.14361805f, 0.10151511f, -0.22538802f, 0.04571293f, -0.04907046f, 0.16768619f, 0.16898772f, 0.14058076f, 
    0.01954637f, 0.02464032f, 0.02933178f, -0.04099793f, 0.11052388f, 0.13828138f, 0.14479993f, 0.02102998f, 
    0.04613179f, 0.05343151f, 0.00201895f, 0.01677210f, -0.04592837f, -0.10883527f, -0.05769742f, 0.00970357f, 
    0.13929446f, 0.15677252f, 0.02623104f, -0.07814339f, 0.13931246f, 0.08839448f, 0.00288218f, 0.09821182f, 
    -0.03132823f, -0.01159135f, -0.13661051f, -0.07614383f, -0.02009881f, 0.09085326f, 0.06784977f, 0.11901356f, 
    0.00788203f, -0.07687523f, 0.05942915f, 0.10383148f, -0.02159740f, -0.14711608f, 0.04320027f, -0.13462299f, 
    -0.04770243f, 0.07291001f, -0.10099023f, -0.08980012f, -0.02209665f, 0.04793097f, 0.01225260f, 0.07485820f, 
    0.01628551f, 0.03851043f, -0.07178394f, 0.00035191f, -0.27202383f, 0.01290821f, 0.10245372f, 0.01156036f, 
    -0.06233793f, -0.05455378f, -0.06616684f, 0.00277035f, 0.04034989f, 0.02875713f, -0.09117437f, 0.11194809f, 
    -0.20493865f, -0.06822345f, -0.04395675f, 0.00009515f, -0.05685994f, 0.15182425f, 0.01807216f, -0.04903065f, 
    -0.11541021f, 0.05106735f, -0.04394912f, -0.02456489f, 0.10440090f, 0.04824595f, -0.00595973f, -0.04533076f, 
    -0.11631320f, -0.06764146f, -0.01671132f, -0.05204044f, -0.05604246f, 0.00736513f, 0.01025783f, 0.02937726f, 
    -0.31579873f, -0.00835851f, -0.01743826f, 0.16966699f, 0.00042343f, 0.03974684f, -0.01149867f, 0.02050852f, 
    -0.02932541f, 0.02633551f, -0.08546960f, 0.03816148f, -0.18608043f, -0.17651328f, -0.05573837f, 0.02130040f, 
    -0.06479090f, 0.11545866f, 0.06298789f, -0.03993012f, 0.14604938f, 0.07042610f, -0.24537820f, 0.06466225f, 
    0.06391672f, 0.07040437f, -0.00475214f, 0.08804382f, 0.12809676f, 0.09138682f, -0.06793954f, -0.15340292f, 
    -0.12810329f, -0.07826158f, -0.02606801f, 0.06556441f, -0.04644962f, 0.00724880f, -0.01265882f, -0.03700254f, 
    -0.03692899f, -0.03563331f, 0.01021564f, -0.12714911f, -0.09583586f, 0.00127315f, -0.09240855f, 0.09422702f, 
    0.13694075f, 0.19113940f, -0.01523141f, -0.10456087f, 0.05974218f, -0.05505268f, 0.09384277f, 0.12491857f, 
    0.02101517f, 0.10649864f, 0.02706673f, 0.00671932f, -0.21537906f, 0.05600138f, 0.07954305f, -0.04619908f, 
    -0.00929179f, 0.05474092f, -0.13414977f, 0.04761873f, 0.02775175f, -0.05469197f, 0.13716553f, -0.01958984f, 
    -0.22845598f, 0.02375193f, 0.17718281f, -0.02363792f, 0.01135943f, 0.07690623f, -0.03645187f, -0.04442375f, 
    -0.04436270f, 0.05348111f, -0.03443651f, -0.03958673f, -0.06018144f, -0.00642437f, -0.01641550f, -0.02092207f, 
    -0.04399435f, 0.02914391f, -0.02060138f, -0.08180716f, -0.17806706f, 0.00541745f, 0.02847437f, 0.10461638f, 
    0.34828058f, -0.01177373f, -0.00637903f, -0.06510481f, 0.04296820f, 0.02403408f, -0.06042808f, 0.09196502f, 
    0.00780975f, 0.01777274f, 0.04348313f, 0.01428166f, 0.27609912f, 0.08524828f, -0.07288045f, -0.10069767f, 
    0.05587807f, -0.12780945f, 0.16255939f, 0.22305980f, -0.07607460f, -0.05257217f, -0.03985757f, 0.00922812f, 
    0.05229339f, 0.42914250f, 0.26698905f, -0.24823944f, 0.23424883f, 0.03241948f, -0.05657172f, -0.17538801f, 
    -0.07027078f, -0.03056940f, 0.05997821f, 0.09124527f, 0.31530377f, 0.26105526f, 0.03988405f, -0.00311236f, 
    0.07921472f, -0.09059039f, 0.15303694f, -0.01000999f, -0.05949686f, 0.06542941f, 0.00502654f, 0.14508811f, 
    0.00680547f, -0.07894545f, -0.08265118f, 0.06434716f, 0.08144362f, 0.09208416f, 0.04435047f, 0.09490754f, 
    -0.07088219f, 0.04572171f, 0.02110986f, -0.02355597f, 0.17694825f, 0.04970609f, -0.01269480f, -0.12532961f, 
    0.09338945f, -0.07236583f, -0.00442139f, 0.10900123f, -0.00799168f, 0.04946721f, 0.06274597f, -0.05345081f, 
    0.07504131f, 0.30682740f, 0.04700333f, -0.25915369f, 0.02435267f, 0.00540770f, 0.04006508f, 0.17642502f, 
    0.07784671f, -0.01988813f, -0.05732996f, -0.07252931f, -0.01880992f, 0.02034191f, 0.01494295f, 0.02488739f, 
    0.00035506f, -0.00465473f, -0.00227547f, -0.07192747f, -0.12976509f, -0.00867568f, -0.04017094f, 0.03777472f, 
    -0.10869386f, -0.03716444f, -0.01472841f, -0.05480604f, -0.00931907f, 0.00632307f, -0.00113764f, -0.01715023f, 
    0.03707054f, -0.05847800f, -0.05690439f, 0.03238987f, 0.29559246f, 0.11878332f, 0.06695238f, -0.00469143f, 
    0.01354625f, 0.09213920f, 0.05261252f, -0.05885371f, -0.01737899f, -0.03634967f, 0.00609458f, -0.08340587f, 
    0.02939756f, -0.04832041f, 0.01648064f, 0.08944519f, -0.08073761f, 0.00165996f, -0.01002437f, -0.08250410f, 
    -0.14665076f, -0.00309807f, -0.13698953f, 0.24773325f, 0.16786183f, 0.14288001f, 0.03386911f, -0.07987346f, 
    0.03676635f, 0.03787969f, -0.07365289f, 0.00192420f, -0.02539024f, -0.02005501f, 0.02899966f, 0.09090039f, 
    0.24476868f, 0.18304743f, -0.09874898f, -0.12238445f, 0.10936562f, -0.01521587f, 0.02456388f, 0.15680861f, 
    -0.03393542f, -0.01992661f, 0.03209439f, -0.05010385f, 0.09451932f, 0.09196939f, -0.17215604f, 0.11057975f, 
    0.10431051f, 0.05357591f, -0.12005811f, 0.00450261f, 0.01643726f, -0.10217892f, 0.01650278f, 0.01403900f, 
    0.37420803f, 0.40892550f, 0.02654399f, -0.08171908f, 0.11741331f, 0.03178300f, 0.04865801f, 0.01155051f, 
    0.05898578f, -0.09605792f, 0.01395442f, -0.06071493f, -0.37079549f, -0.00393582f, 0.09593757f, 0.26669487f, 
    0.04825398f, 0.18862511f, -0.01113576f, 0.05497124f, 0.03436657f, -0.01353973f, -0.08303970f, -0.02782357f, 
    -0.21604918f, -0.02718487f, -0.14051050f, -0.03302129f, -0.00625718f, 0.05833872f, -0.13164860f, -0.00265675f, 
    0.02349895f, -0.10940987f, 0.05582501f, 0.16341582f, -0.08772063f, -0.01166688f, 0.02001268f, -0.00991183f, 
    -0.04805062f, 0.12612148f, -0.07730953f, -0.02897361f, 0.09287260f, 0.01309544f, -0.00736835f, -0.05121933f, 
    -0.03500923f, 0.02924267f, 0.04373110f, -0.02721732f, -0.12017276f, -0.08899283f, -0.03073564f, -0.12856612f, 
    0.04168115f, 0.04491484f, -0.00478725f, 0.14880835f, 0.25714642f, 0.28840506f, -0.17528842f, 0.03163292f, 
    0.07658537f, 0.07897013f, 0.02511238f, -0.16467665f, 0.04247478f, 0.01664065f, 0.02238999f, 0.01282662f, 
    0.35357323f, 0.12703545f, -0.00109562f, -0.13557695f, 0.02090891f, -0.04317988f, -0.11869665f, 0.10718505f, 
    0.01120018f, 0.00334646f, -0.00687873f, 0.08025012f, 0.20600007f, 0.07968417f, 0.00720892f, -0.00096993f, 
    0.15383573f, 0.05109899f, -0.03194529f, -0.02251980f, -0.01167327f, 0.03086066f, -0.10449819f, 0.01269788f, 
    -0.09769822f, -0.02852688f, 0.14661805f, 0.02854205f, 0.03679910f, 0.04593345f, -0.10174060f, -0.05037935f, 
    -0.10625122f, -0.14756884f, 0.04115997f, 0.05270704f, -0.00781817f, -0.12481027f, -0.00740009f, 0.21680678f, 
    -0.08471166f, 0.02755621f, -0.01070477f, 0.00750407f, -0.05072475f, -0.08024172f, -0.06892645f, 0.06444069f, 
    0.14105341f, 0.09811834f, -0.11370899f, -0.01892010f, 0.09575012f, 0.00968780f, 0.05466138f, -0.02866349f, 
    -0.01142165f, 0.03890313f, -0.02145625f, -0.06106748f, 0.03204648f, -0.13640706f, 0.11150555f, 0.09486487f, 
    -0.03217972f, -0.05100142f, -0.01806905f, 0.03944755f, -0.00915688f, -0.03333835f, -0.03581214f, -0.07716609f, 
    -0.20267439f, 0.27887741f, 0.37528750f, -0.03738056f, 0.21755317f, 0.03220356f, 0.02692538f, -0.01227853f, 
    -0.02687919f, -0.02594204f, -0.04153812f, -0.05283727f, 0.06877295f, 0.06967143f, 0.03159584f, -0.02364180f, 
    0.06271978f, 0.06791693f, -0.04408907f, -0.00079113f, -0.11071759f, -0.06233256f, -0.08953165f, 0.06714316f, 
    -0.12577567f, -0.04721421f, -0.07207476f, 0.07176799f, 0.03589993f, 0.03498661f, 0.04114471f, -0.06013283f, 
    -0.07069517f, 0.01262234f, 0.06034499f, -0.02498285f, 0.12055763f, 0.06859750f, -0.03901483f, -0.05412309f, 
    0.07112528f, -0.00297875f, -0.02814894f, -0.08342876f, -0.03963023f, 0.10347725f, 0.01810367f, 0.05836320f, 
    0.05218302f, 0.16288123f, 0.18109243f, 0.06286749f, -0.02727472f, 0.06546056f, 0.05046691f, 0.17325735f, 
    0.03894758f, 0.10077248f, -0.03513169f, 0.04837164f, 0.20656881f, 0.11854180f, -0.03663244f, -0.03105836f, 
    -0.00636471f, 0.06619189f, -0.06203473f, -0.11522768f, -0.10021523f, -0.03686759f, -0.00396838f, -0.05879390f, 
    0.08077186f, 0.15223914f, 0.02029907f, -0.09722446f, -0.03033781f, -0.01542684f, -0.00427233f, -0.07441375f, 
    0.00365869f, 0.04132790f, 0.04108721f, 0.05362351f, 0.16844672f, 0.07789724f, -0.00975973f, -0.15313457f, 
    0.10832082f, -0.05924599f, 0.16020897f, 0.00780988f, -0.03929818f, 0.01531540f, 0.03118882f, -0.02373223f, 
    -0.11867755f, 0.21088909f, -0.01487078f, -0.00432229f, -0.03753357f, -0.06359826f, -0.07466213f, -0.03332348f, 
    -0.08893616f, 0.05349427f, 0.04946955f, 0.04832824f, -0.48494580f, -0.18943952f, 0.41452307f, 0.35058063f, 
    0.06044316f, 0.12617938f, -0.02323767f, 0.00618784f, -0.06150392f, -0.11021526f, -0.00884525f, 0.11261939f, 
    -0.14533143f, 0.05356732f, 0.11729976f, -0.03145311f, 0.02136849f, -0.06772415f, -0.05870039f, -0.07202440f, 
    -0.05551318f, -0.05794718f, 0.01343674f, -0.04162050f, 0.07791084f, 0.11669709f, 0.18616177f, 0.01840764f, 
    -0.00978410f, -0.00693851f, 0.11043058f, -0.15732907f, 0.04104668f, 0.04189729f, -0.10904527f, 0.10274640f, 
    0.25174305f, 0.01107631f, -0.11062638f, -0.00911284f, -0.00256986f, 0.00078834f, -0.12618689f, 0.03427285f, 
    0.07151425f, -0.01632347f, 0.08547510f, -0.06823084f, 0.29229680f, 0.17456514f, -0.00071721f, -0.16888924f, 
    -0.00281716f, 0.13654256f, 0.06307241f, 0.18114692f, 0.14499773f, 0.02619983f, -0.04808846f, -0.03095314f, 
    -0.11839950f, 0.08424074f, 0.13751712f, -0.00220753f, 0.00270761f, 0.08808887f, 0.00299680f, -0.20474872f, 
    -0.19326445f, -0.06836215f, 0.08765072f, 0.14849530f, 0.20635076f, 0.04437277f, 0.03319509f, -0.05177883f, 
    0.09462308f, 0.03910636f, -0.05682790f, -0.04645118f, 0.01790165f, 0.00748050f, 0.01642234f, -0.08086167f, 
    -0.14609295f, -0.15043861f, 0.15730135f, 0.01874906f, 0.00113558f, -0.00016835f, 0.07264505f, 0.19243513f, 
    -0.01745334f, -0.02749417f, -0.07343863f, 0.04105843f, 0.15783283f, 0.08834878f, 0.13361983f, -0.04418885f, 
    0.12797226f, -0.00616620f, 0.01842092f, 0.01745798f, -0.10593589f, 0.01192693f, 0.02861243f, 0.03672069f, 
    0.23857756f, -0.09145270f, -0.10042448f, -0.01918651f, 0.02656066f, -0.02414227f, -0.01847969f, 0.06747168f, 
    0.02429447f, -0.08695860f, 0.01324314f, 0.04462413f, 0.19372009f, 0.11787129f, 0.02972964f, -0.05052001f, 
    0.01280023f, 0.06161683f, 0.03787219f, 0.06062948f, -0.01471074f, -0.00457042f, 0.00587218f, -0.04078762f, 
    0.01340975f, 0.08140253f, 0.01622161f, 0.26050708f, 0.09045564f, 0.08430741f, -0.08631319f, -0.02709757f, 
    -0.03512357f, 0.01769600f, 0.19524300f, 0.02712906f, -0.02709381f, 0.07163966f, -0.02759871f, 0.07633212f, 
    -0.10406678f, -0.05664163f, 0.01228382f, -0.06601512f, -0.12216754f, 0.01155832f, 0.02784331f, 0.09282722f, 
    -0.09143969f, -0.14273684f, -0.10927621f, 0.06481178f, 0.11788255f, 0.08057832f, -0.03111918f, 0.03283343f, 
    -0.01723804f, -0.02436848f, -0.10145435f, 0.10508261f, 0.21398281f, 0.18226171f, -0.00950952f, -0.18857746f, 
    -0.04012675f, 0.04290914f, 0.02644170f, 0.04872309f, -0.03818441f, 0.04030631f, -0.05099022f, -0.12792560f, 
    0.19782294f, 0.01035051f, -0.21589376f, -0.04867250f, 0.05401988f, -0.03284331f, 0.03430517f, 0.01935921f, 
    -0.04817331f, 0.05492972f, -0.08321020f, -0.01959328f, -0.07238209f, 0.07359353f, 0.10935607f, 0.00151661f, 
    -0.09166330f, 0.05524438f, -0.00893357f, -0.06949367f, -0.00177116f, -0.08149383f, 0.01527559f, -0.01893920f, 
    0.08661091f, -0.09317309f, 0.10911342f, 0.04533772f, -0.06847771f, -0.06369229f, 0.00196439f, 0.02701014f, 
    -0.00609049f, -0.06333721f, 0.00029154f, 0.02687512f, -0.14306419f, 0.33300573f, -0.12505062f, 0.16895704f, 
    -0.01097069f, -0.05746280f, 0.03348390f, 0.08673971f, -0.05690745f, 0.06631799f, 0.07102614f, 0.20982137f, 
    0.21558546f, -0.01450312f, 0.09379329f, -0.05364234f, 0.01174902f, 0.20428187f, 0.05286610f, 0.04802532f, 
    0.03368455f, -0.05368562f, -0.02534483f, -0.11965647f, -0.03991596f, 0.06628881f, -0.00366254f, 0.05038032f, 
    0.04426182f, 0.07346875f, -0.03174566f, -0.02566826f, -0.07207344f, -0.01815648f, -0.00396182f, -0.14262301f, 
    0.05977308f, 0.00203050f, 0.24552856f, 0.11703858f, -0.06715949f, -0.06969109f, 0.05729983f, -0.07165994f, 
    -0.08715280f, 0.05918752f, 0.06233290f, 0.02875156f, 0.08491294f, 0.18714300f, 0.20576236f, -0.02958377f, 
    0.01370729f, 0.17685924f, 0.07090864f, 0.03337690f, 0.10092459f, -0.07936087f, 0.06536308f, 0.13331676f, 
    -0.06628378f, 0.12623496f, -0.06269162f, 0.03452833f, 0.05933874f, -0.08953458f, -0.00834127f, 0.06551502f, 
    -0.03885823f, 0.03235412f, -0.02541219f, -0.12624991f, 0.22110249f, 0.00666875f, 0.00416254f, 0.17187966f, 
    -0.04254591f, 0.05044040f, -0.08220204f, -0.03809042f, -0.03717038f, -0.01420005f, -0.06619617f, -0.10568715f, 
    -0.01119652f, 0.00452767f, 0.06454564f, 0.15116106f, -0.12346566f, 0.14582224f, 0.01758528f, -0.04324365f, 
    -0.03158656f, -0.07143345f, -0.05491006f, -0.05565221f, -0.07180823f, 0.07968065f, 0.02496277f, 0.02413390f, 
    -0.11713972f, 0.10980434f, 0.05541192f, 0.00756164f, 0.06782741f, 0.21578763f, 0.04266716f, 0.15281801f, 
    0.39817637f, 0.00124581f, 0.20381035f, 0.06366692f, 0.01919151f, -0.02543441f, -0.00594851f, -0.02772150f, 
    0.06337839f, 0.06987770f, 0.09432004f, 0.16991784f, -0.11075393f, 0.04713374f, -0.04123133f, 0.12957472f, 
    -0.02956956f, -0.00543195f, 0.02354979f, -0.05692903f, 0.01131813f, 0.02318727f, 0.11179852f, -0.08454414f, 
    0.17727622f, 0.02815253f, 0.16136019f, -0.09218791f, 0.00441348f, 0.01315695f, 0.03570739f, -0.13503170f, 
    -0.07875575f, 0.09795414f, 0.02556965f, 0.04085401f, 0.01422056f, -0.05015746f, 0.07840971f, -0.01746206f, 
    0.11616907f, 0.15962303f, 0.13358577f, -0.01281385f, 0.07469041f, -0.10937800f, 0.11484568f, 0.12704894f, 
    -0.38563287f, 0.31852221f, -0.27965835f, -0.00891702f, 0.20971346f, 0.05721251f, 0.02102044f, 0.10329076f, 
    -0.08231067f, 0.13526721f, -0.05802535f, 0.00690214f, -0.21753491f, 0.25460917f, -0.27179119f, 0.53539753f, 
    0.07002696f, 0.12051445f, 0.08839668f, 0.02635480f, 0.22104995f, -0.03780671f, 0.12254833f, 0.21185867f, 
    0.19768457f, 0.00112972f, -0.02638675f, 0.11300828f, 0.00414662f, 0.04019333f, 0.00959852f, 0.19554582f, 
    -0.17814831f, 0.09986758f, -0.15994705f, -0.04454885f, -0.00420641f, -0.01529554f, -0.04260612f, 0.18295826f, 
    -0.07564195f, 0.02154244f, 0.00790212f, 0.17923342f, 0.17671284f, 0.05990656f, 0.14579491f, 0.15455897f, 
    0.03390996f, 0.05449903f, 0.17739461f, -0.08668389f, 0.06943233f, 0.04344259f, 0.06955574f, -0.02827816f, 
    0.03489681f, -0.14545839f, 0.06026648f, 0.14450353f, -0.02752480f, 0.20833246f, -0.02477267f, -0.00634132f, 
    -0.01153835f, 0.07328820f, 0.15357871f, -0.03924530f, -0.12581302f, 0.02784375f, 0.04134449f, 0.18345562f, 
    -0.00234270f, -0.05611528f, 0.14053327f, -0.02616309f, 0.10187400f, 0.04124016f, 0.04933686f, -0.04189365f, 
    -0.02910860f, -0.13467696f, -0.10949814f, -0.13655198f, -0.29750323f, 0.31274095f, -0.09680916f, 0.20236468f, 
    0.12849066f, 0.00808799f, 0.10448536f, -0.01170201f, 0.14942616f, 0.00497666f, 0.12926719f, 0.00764712f, 
    0.04862704f, -0.06182671f, -0.02510502f, 0.03519122f, 0.02060297f, 0.11524051f, -0.07240529f, 0.02380888f, 
    -0.10970427f, -0.04370588f, 0.19178511f, 0.11330260f, 0.10091566f, 0.13811843f, 0.11447386f, -0.01585951f, 
    -0.12462233f, -0.06882857f, -0.09670515f, 0.03367617f, -0.02916547f, -0.04180362f, -0.08439082f, -0.08133905f, 
    0.00055868f, 0.00031844f, 0.05676144f, 0.06642126f, 0.04120676f, -0.11443319f, -0.01255672f, -0.03033330f, 
    -0.01697333f, 0.01201453f, -0.07869605f, -0.09648106f, 0.13588445f, 0.16624658f, 0.08252574f, 0.00585853f, 
    0.21086624f, -0.03409185f, -0.02622784f, 0.12583360f, -0.14289328f, 0.01287509f, -0.04301013f, -0.06359460f, 
    -0.19830580f, 0.23472668f, -0.25933659f, 0.39896876f, 0.19626446f, -0.03219207f, 0.11419057f, 0.04756960f, 
    -0.05995180f, 0.05499614f, 0.13201310f, 0.11849857f, 0.22169627f, 0.08897850f, 0.39395589f, 0.04265636f, 
    -0.04250176f, 0.03730701f, 0.14686893f, -0.00953093f, -0.07759570f, 0.10680005f, 0.00126039f, 0.23013885f, 
    -0.14416374f, -0.05629592f, 0.03672063f, 0.15709603f, -0.02196675f, 0.02152745f, 0.12482354f, 0.00336031f, 
    -0.08534189f, 0.06088763f, 0.04942016f, 0.31899539f, 0.12584412f, 0.02005861f, 0.11309014f, -0.03046793f, 
    -0.07179354f, 0.14608175f, -0.00360636f, 0.02613704f, -0.00986730f, -0.06413728f, -0.06252685f, -0.20154326f, 
    -0.04042132f, -0.10828133f, 0.08904436f, -0.09775492f, -0.06416737f, 0.04494042f, -0.09321158f, -0.07097600f, 
    0.06408252f, 0.08155513f, 0.03147128f, 0.16916150f, 0.01272639f, 0.19561775f, -0.24903256f, 0.15981610f, 
    0.12753585f, -0.07686698f, 0.13249432f, -0.04268746f, 0.12872596f, 0.05495199f, 0.16258463f, -0.06603775f, 
    0.11934973f, 0.12658401f, 0.01936488f, 0.00305973f, -0.13530901f, -0.04294766f, 0.01196368f, 0.06477161f, 
    0.05310014f, 0.04802259f, -0.13779631f, -0.08323771f, 0.08503320f, 0.01534304f, -0.01177818f, 0.11542267f, 
    0.09301279f, 0.12053293f, 0.02587121f, 0.01597986f, 0.09774749f, 0.08678759f, 0.14577080f, 0.16880730f, 
    0.01343630f, -0.05517897f, -0.02495455f, 0.03185629f, -0.13639688f, -0.06837551f, -0.06965913f, -0.07241441f, 
    0.29985690f, 0.22631888f, 0.14317995f, 0.23522915f, -0.02327444f, 0.02094494f, 0.03819327f, 0.26323467f, 
    0.01168747f, -0.04080269f, -0.01331652f, -0.03900776f, 0.09544144f, 0.07986572f, 0.07058448f, 0.05471846f, 
    0.00107305f, 0.15111279f, -0.14577200f, 0.09463024f, 0.17333953f, 0.00491082f, 0.04103727f, -0.05462825f, 
    -0.01301537f, 0.04247755f, 0.09329385f, 0.05951602f, -0.05190662f, -0.00937587f, 0.14153346f, -0.02741814f, 
    0.16192694f, 0.04934610f, 0.01668913f, -0.11126786f, 0.21459703f, -0.00828551f, 0.02682537f, 0.16303796f, 
    0.13597304f, 0.23396359f, -0.09792873f, -0.05067947f, 0.15232712f, 0.06739391f, 0.04199059f, 0.00649523f, 
    -0.03346255f, -0.03250424f, 0.15358326f, -0.00700208f, -0.00116638f, -0.13179986f, 0.00976073f, 0.00751715f, 
    0.10161462f, 0.07143348f, -0.02451993f, 0.05505091f, 0.00714831f, 0.13577037f, 0.06152544f, 0.16057952f, 
    0.32912013f, -0.08844361f, -0.01800047f, -0.03866246f, 0.02614018f, 0.06987678f, 0.08838624f, 0.09426358f, 
    0.03093755f, 0.22010647f, -0.10887687f, -0.21496116f, 0.07853687f, 0.04469953f, 0.04979138f, -0.05592234f, 
    -0.05962901f, -0.07025488f, -0.06787866f, -0.07456525f, 0.04851305f, 0.08824041f, -0.05331992f, 0.11725903f, 
    0.01290437f, 0.00692981f, 0.27266392f, 0.16377804f, 0.13595225f, -0.00149761f, 0.12791914f, 0.15778579f, 
    0.08010340f, 0.05379324f, 0.01296674f, 0.18186255f, 0.11442603f, 0.05778051f, -0.01507541f, 0.16296846f, 
    0.00414992f, -0.02481435f, -0.03240772f, 0.01702677f, 0.06536513f, -0.04066788f, 0.04753788f, 0.03600077f, 
    -0.07998949f, 0.07280898f, 0.03390270f, 0.05805664f, 0.01819883f, -0.06558140f, 0.06602602f, 0.01906846f, 
    0.09217138f, 0.12846771f, -0.00539636f, 0.04276672f, -0.12559777f, 0.16964638f, -0.09795288f, 0.24455711f, 
    -0.21327370f, -0.00510606f, 0.11195639f, 0.08506275f, -0.05817296f, -0.00163311f, -0.10234068f, -0.03561941f, 
    -0.04969703f, 0.25101951f, -0.09282102f, 0.14773747f, -0.06551045f, 0.04114079f, 0.00519762f, 0.11936657f, 
    0.11158509f, 0.19143440f, 0.22167777f, 0.31677622f, -0.01659724f, 0.07629853f, 0.33014187f, -0.08185825f, 
    -0.00924687f, -0.02025498f, 0.15395902f, 0.03373138f, -0.15362155f, 0.06079612f, -0.01186592f, -0.06751985f, 
    -0.00139942f, 0.07821001f, 0.00376661f, 0.05018202f, 0.01823764f, -0.01313690f, -0.05318930f, -0.05034884f, 
    -0.08313492f, 0.01465511f, -0.03388176f, -0.09143853f, 0.30744642f, 0.04140754f, -0.02190617f, -0.07576979f, 
    0.02748038f, 0.15571098f, 0.09862953f, -0.03030768f, 0.02051836f, -0.08325451f, 0.20351648f, 0.21116200f, 
    0.03275915f, 0.20403022f, -0.14093874f, -0.00149374f, 0.00392720f, -0.02941172f, 0.03523006f, -0.10462853f, 
    -0.11810877f, 0.05865968f, 0.00970031f, 0.02650774f, -0.00885702f, 0.02260548f, 0.15019239f, 0.15530702f, 
    0.01091492f, -0.13201465f, 0.08411218f, 0.12230467f, 0.07986059f, 0.04585952f, 0.00853926f, 0.01448424f, 
    0.21410061f, 0.25512183f, -0.16380264f, 0.17774197f, -0.10324763f, 0.03935482f, 0.10965994f, 0.15414917f, 
    -0.19825602f, 0.04903621f, 0.08981762f, -0.19413681f, 0.06509848f, 0.02218800f, -0.02439652f, 0.13998538f, 
    0.04860418f, 0.14867358f, 0.01236951f, 0.01558350f, -0.00095154f, -0.01514639f, -0.08434060f, -0.05791162f, 
    -0.02795897f, -0.00175359f, 0.13763089f, 0.05164206f, 0.02621445f, 0.10090157f, 0.11255464f, -0.08435888f, 
    0.00660484f, -0.12394433f, 0.11673505f, -0.03761844f, 0.09209182f, 0.00629516f, 0.22466063f, -0.04256289f, 
    -0.06130851f, -0.05620185f, -0.11375512f, 0.07889371f, -0.08621065f, -0.01296759f, -0.05564082f, -0.11590687f, 
    -0.06951121f, 0.09060942f, -0.01267576f, 0.00574313f, 0.02489579f, -0.01996181f, 0.01632156f, -0.00320219f, 
    0.02745738f, 0.12637030f, 0.06939403f, -0.09828684f, -0.08199147f, 0.06943330f, -0.12632808f, 0.10012946f, 
    -0.05699381f, 0.15043086f, -0.08184879f, 0.17790039f, 0.04653791f, 0.18949857f, -0.08517770f, 0.01764646f, 
    -0.04553213f, 0.04720312f, 0.08816090f, 0.19145702f, 0.02509390f, -0.11184723f, 0.01931938f, 0.02830848f, 
    -0.06387945f, 0.15445970f, 0.03875674f, -0.02966027f, -0.05390930f, 0.08341162f, -0.10649516f, 0.06678664f, 
    0.01441549f, 0.11660904f, 0.07723043f, -0.04716009f, -0.11220188f, -0.00584127f, 0.06056941f, 0.03226477f, 
    0.30435112f, -0.23126225f, 0.10991158f, -0.12418584f, 0.09490486f, -0.00161332f, -0.04811825f, -0.02960107f, 
    -0.01980679f, -0.08658064f, -0.04770400f, -0.06067362f, 0.02683089f, 0.03239489f, -0.02332449f, 0.15797363f, 
    -0.08417342f, 0.03506133f, 0.14045504f, 0.05668896f, 0.00471604f, 0.06753413f, 0.07628205f, 0.00418620f, 
    -0.02235799f, -0.00778731f, -0.07873066f, 0.17288139f, -0.12247172f, -0.05134717f, 0.13161895f, 0.05881781f, 
    0.08434562f, 0.09846956f, 0.07896763f, 0.08974901f, 0.07509746f, 0.12034429f, -0.01634742f, 0.07760035f, 
    -0.01217554f, -0.01738391f, -0.07842893f, -0.12068246f, 0.02895826f, 0.13870212f, -0.02933867f, 0.08496841f, 
    0.01785708f, 0.02100562f, 0.04784410f, -0.09226241f, -0.13042341f, 0.04101337f, 0.00291814f, -0.02686563f, 
    0.05366365f, 0.08242220f, 0.05996745f, 0.04633557f, 0.20569967f, 0.15297584f, 0.04905165f, 0.17858228f, 
    -0.12300868f, -0.03181691f, 0.00450742f, 0.02904179f, 0.09774294f, 0.06897724f, 0.04345299f, -0.08353351f, 
    -0.01921494f, -0.02850436f, 0.03321520f, -0.02941856f, -0.03197447f, 0.01080845f, -0.09603398f, 0.02979354f, 
    -0.10795194f, -0.01643869f, 0.01465461f, 0.09291354f, -0.07803728f, -0.09035986f, -0.12032806f, -0.06824681f, 
    -0.14228539f, -0.05206945f, -0.10578178f, -0.08942885f, -0.10105709f, -0.03031859f, 0.00052563f, -0.02152932f, 
    0.08228344f, 0.23799089f, 0.13083959f, 0.20609102f, -0.04300717f, -0.01201372f, -0.04527872f, -0.03048802f, 
    -0.04936419f, -0.12435969f, 0.00164634f, -0.05520579f, -0.00947260f, 0.01700426f, -0.08403865f, 0.02089260f, 
    -0.06383698f, -0.10323380f, -0.01919768f, 0.06849273f, -0.19751053f, 0.10954235f, -0.13271815f, -0.19391955f, 
    -0.22793925f, -0.07973050f, -0.02775156f, -0.02950044f, 0.01636700f, 0.07222203f, -0.06331392f, -0.05304079f, 
    0.02428348f, 0.02890594f, -0.00065838f, 0.04072437f, 0.09280338f, 0.12374022f, 0.14263271f, -0.00778665f, 
    -0.04039397f, -0.08452526f, -0.13143976f, -0.10897923f, -0.07158652f, 0.01536718f, -0.04112423f, 0.02900079f, 
    0.03502823f, -0.03490492f, 0.03179615f, -0.09254602f, 0.09175899f, -0.00246923f, 0.10757294f, 0.14182906f, 
    -0.08208570f, 0.02303402f, 0.08422820f, -0.00290323f, -0.08690476f, 0.08957495f, 0.06831346f, 0.13253453f, 
    0.02475772f, -0.03919166f, -0.09059870f, 0.00805285f, -0.10982119f, -0.03660562f, 0.05946754f, 0.00304904f, 
    -0.07694338f, -0.00183017f, 0.15328434f, 0.04749243f, -0.03591867f, 0.05872596f, -0.13567446f, -0.04313726f, 
    -0.11527430f, -0.00496133f, -0.14440349f, -0.12048667f, -0.08417775f, 0.06878261f, -0.01770604f, -0.01541820f, 
    -0.09909470f, 0.08066852f, -0.06186699f, -0.05917583f, -0.00040221f, 0.04793699f, 0.20553604f, 0.13488245f, 
    -0.06429496f, -0.15373908f, -0.27337247f, -0.11967672f, 0.04776255f, 0.15791264f, 0.02872087f, 0.08324902f, 
    0.00369952f, -0.06438858f, 0.05904435f, -0.05414920f, 0.19624543f, -0.00758016f, -0.20793322f, -0.14925142f, 
    0.03206559f, 0.05654798f, 0.23781094f, 0.15454663f, -0.05436124f, 0.06570042f, 0.13033241f, -0.05241072f, 
    0.17585491f, 0.07359627f, 0.24509659f, -0.20740652f, -0.04960865f, -0.01208712f, -0.07789863f, -0.00746812f, 
    0.01652826f, 0.07534417f, 0.06950209f, 0.03947885f, 0.24439485f, 0.33734351f, -0.09176931f, -0.10355502f, 
    0.00850128f, -0.02761321f, 0.15041874f, 0.08568725f, -0.03402024f, 0.08092145f, 0.08076274f, -0.08275075f, 
    0.05139113f, -0.01407585f, 0.01501787f, 0.06139653f, 0.00142375f, 0.08824299f, 0.08473998f, 0.09027344f, 
    0.04024485f, 0.06722930f, 0.01057396f, 0.01454554f, 0.16241333f, -0.00658982f, -0.00248343f, -0.11172874f, 
    0.02216604f, -0.13616531f, 0.00187845f, -0.07450121f, -0.13177687f, -0.01825472f, -0.02227243f, -0.06188796f, 
    0.00439467f, 0.20805691f, 0.14716028f, -0.17085388f, 0.04237055f, -0.05902291f, 0.02888657f, 0.25866553f, 
    0.07334828f, -0.05376522f, -0.09965657f, -0.08828993f, -0.14762582f, 0.15267676f, 0.23451172f, -0.04394856f, 
    -0.04969549f, 0.00300204f, -0.01087573f, 0.11375742f, 0.00751871f, -0.04336126f, -0.08140828f, -0.03062302f, 
    0.02724983f, -0.03771766f, -0.09525143f, 0.05297892f, 0.00741129f, -0.07482241f, -0.04976353f, -0.07858116f, 
    0.09050012f, -0.03014350f, -0.04050586f, 0.05834987f, 0.23443387f, 0.17496370f, 0.01246331f, 0.05063548f, 
    -0.02364838f, -0.01408266f, 0.09919004f, 0.00708922f, -0.00330164f, -0.04450316f, 0.07010238f, 0.02350407f, 
    -0.04204905f, 0.09338185f, 0.02283428f, -0.04632470f, -0.11918728f, -0.07750134f, -0.04142778f, -0.07290468f, 
    -0.09408903f, 0.07849121f, -0.09678710f, 0.07597111f, 0.02313719f, -0.01089852f, 0.00253941f, 0.02334231f, 
    0.17075484f, -0.00959365f, 0.00372219f, 0.04209869f, -0.05557576f, 0.04889056f, -0.04660105f, 0.06435613f, 
    0.15372819f, 0.08512238f, -0.08012779f, -0.07338751f, 0.13473329f, 0.01541253f, 0.00306817f, 0.03736133f, 
    0.05056600f, -0.07015444f, 0.07141287f, 0.08733308f, 0.12228651f, 0.03261843f, -0.13130660f, -0.02197366f, 
    -0.02662966f, 0.05744733f, -0.00606483f, -0.06618220f, 0.01781538f, -0.04418910f, 0.05773358f, 0.03299483f, 
    0.24335507f, 0.29562584f, -0.02271764f, -0.26263958f, -0.12345321f, 0.01106384f, 0.04020641f, 0.06854568f, 
    0.14899351f, -0.06444674f, -0.00001108f, -0.04047088f, 0.04065694f, -0.14387444f, 0.14592718f, 0.16302525f, 
    -0.00871001f, 0.07301597f, -0.04211055f, 0.01896426f, -0.08891194f, 0.07510035f, -0.02862343f, 0.03321403f, 
    -0.13320526f, -0.03224948f, -0.18732280f, -0.07956154f, 0.02377058f, 0.00741846f, -0.00420524f, 0.12833136f, 
    0.07495935f, -0.05904324f, 0.08703648f, -0.10969830f, -0.21295920f, -0.20620584f, -0.10468367f, -0.02718193f, 
    0.12619522f, 0.04760253f, -0.02588099f, 0.06712665f, -0.09068680f, 0.04701304f, 0.00026060f, -0.00053694f, 
    0.05389603f, -0.17758746f, 0.00808857f, -0.10290908f, -0.05137672f, -0.00512308f, -0.01930808f, 0.10515998f, 
    -0.02865831f, 0.06015410f, -0.01150665f, -0.11845815f, 0.11325025f, 0.20688400f, 0.02398971f, -0.09335817f, 
    0.13417718f, -0.01441090f, 0.05151509f, 0.07393796f, 0.07365102f, -0.00185012f, 0.00409901f, 0.13321373f, 
    0.06323736f, 0.03366211f, -0.00357096f, -0.12564412f, 0.14578672f, 0.05206138f, -0.15331724f, -0.04349508f, 
    -0.12043641f, -0.04256458f, 0.03781419f, 0.00545064f, 0.21665148f, 0.09963327f, 0.07782479f, -0.02650931f, 
    0.02849364f, 0.03794215f, 0.01593645f, -0.06463762f, -0.03595769f, -0.00653043f, -0.07626697f, -0.19417502f, 
    0.09363825f, 0.18301331f, 0.08029086f, 0.10507873f, 0.04883658f, 0.00892912f, -0.10673705f, -0.08365816f, 
    -0.28422561f, -0.19946553f, -0.11582886f, -0.06212732f, 0.14650200f, 0.13264935f, 0.16718668f, 0.07617939f, 
    -0.02224336f, -0.04384788f, -0.07926375f, -0.05517979f, -0.06313320f, -0.14285843f, -0.01064517f, 0.06136684f, 
    0.05740776f, 0.03047650f, -0.03025421f, -0.16968685f, 0.03251909f, -0.02413929f, 0.09816585f, 0.07545287f, 
    0.00727926f, 0.09224287f, 0.07511030f, -0.05933348f, 0.19765265f, 0.05789705f, -0.01613421f, 0.10550867f, 
    -0.06097946f, -0.04467788f, -0.00816838f, -0.00880539f, -0.01097440f, 0.07026698f, 0.08439666f, 0.03265917f, 
    0.06071603f, 0.23206960f, 0.21391049f, -0.05507353f, 0.05131800f, -0.04885839f, -0.06196849f, -0.06156730f, 
    -0.02931649f, 0.01956695f, -0.00616504f, 0.02247548f, 0.01407740f, -0.04908370f, -0.00961740f, -0.04218995f, 
    0.05718093f, 0.03672478f, -0.04690822f, 0.03823494f, -0.02710374f, 0.02719301f, -0.06655497f, 0.03700868f, 
    -0.07713548f, -0.05836890f, 0.06193785f, 0.01089247f, 0.01571617f, -0.07320292f, -0.03194765f, 0.00299363f, 
    0.13264666f, 0.00845316f, 0.07617845f, 0.12686731f, 0.04782698f, -0.06766490f, -0.07173806f, -0.15575792f, 
    0.13161901f, 0.06294650f, 0.03266714f, 0.16206048f, -0.12760349f, -0.01967273f, -0.05449362f, -0.17443164f, 
    0.05366710f, -0.05446963f, 0.06472564f, -0.11936607f, 0.00506540f, 0.00801168f, 0.11206982f, 0.04807429f, 
    0.00913411f, 0.02056349f, -0.00048280f, 0.00170251f, 0.09125227f, 0.02621580f, 0.04366675f, -0.07455914f, 
    0.10964274f, 0.08402394f, 0.05764778f, -0.06389832f, -0.04253954f, -0.00715169f, 0.03493984f, -0.00288101f, 
    0.07880733f, 0.00911241f, -0.02256881f, -0.04321836f, 0.03854641f, 0.06739441f, -0.03937680f, 0.03583095f, 
    0.04929448f, -0.03404683f, 0.07398216f, 0.06437491f, 0.20411262f, 0.12965295f, 0.01308090f, -0.00301930f, 
    0.06727725f, -0.12777212f, 0.04763915f, -0.06343807f, -0.00137907f, 0.07055480f, 0.07986783f, 0.04913972f, 
    -0.20966515f, 0.20346138f, 0.02859954f, 0.05010663f, -0.02349232f, -0.03886859f, -0.02143669f, 0.07672890f, 
    -0.15177496f, -0.09948307f, -0.12331904f, -0.21083693f, 0.16072664f, -0.00574689f, 0.39991713f, 0.07707146f, 
    0.11901505f, -0.04884450f, -0.01439466f, -0.08412801f, -0.01429047f, -0.01005028f, -0.03876356f, 0.12172872f, 
    0.01777720f, 0.17014191f, 0.15858217f, 0.09519023f, -0.00008185f, -0.03877319f, -0.12415992f, -0.10659305f, 
    -0.00409164f, -0.01382201f, -0.02228522f, 0.07459742f, 0.07196889f, -0.03703032f, 0.17138228f, -0.17828578f, 
    0.05627939f, -0.03566145f, 0.08772364f, -0.09531230f, 0.09698818f, 0.15009786f, -0.06530221f, -0.04161931f, 
    -0.23232073f, -0.19733706f, -0.22528067f, -0.18037097f, 0.00794057f, 0.07367265f, 0.01957681f, 0.18182859f, 
    0.02913820f, 0.05418640f, -0.00293789f, -0.02066970f, 0.01283729f, 0.02500003f, -0.02914558f, -0.20786113f, 
    -0.01515743f, 0.11081471f, 0.06169809f, 0.07855258f, 0.01524438f, -0.04550008f, -0.03579829f, -0.01559563f, 
    -0.11152070f, 0.11203282f, -0.11164633f, 0.06009193f, 0.03542417f, 0.13202709f, -0.05563500f, -0.06576180f, 
    0.01558743f, 0.04572796f, -0.02429398f, 0.17688288f, 0.20961040f, 0.20187156f, -0.02205049f, -0.01928888f, 
    0.08919793f, -0.03214092f, 0.03240047f, -0.00270959f, 0.05800498f, -0.01290405f, 0.08254078f, 0.10145298f, 
    0.07835443f, -0.06702372f, -0.06071532f, 0.15022072f, 0.02643694f, 0.05592348f, 0.04427544f, 0.09987405f, 
    -0.02998589f, 0.06181374f, 0.02384662f, 0.08323650f, 0.13989130f, 0.05644097f, 0.05530915f, -0.00001761f, 
    0.06705127f, 0.11591981f, 0.05492705f, -0.02407027f, 0.01603596f, 0.03842703f, 0.03487901f, 0.05431988f, 
    -0.09865155f, -0.27835804f, -0.23057966f, -0.12025652f, 0.00143630f, -0.00402745f, 0.01550525f, -0.01350598f, 
    0.09394845f, -0.10826316f, 0.00153099f, 0.16373377f, 0.10468005f, 0.22711043f, 0.06396237f, -0.10324273f, 
    0.05101505f, -0.00008497f, 0.00085773f, -0.02266097f, 0.01798387f, 0.03339308f, -0.02744209f, 0.02976350f, 
    -0.07035115f, 0.05111418f, 0.01911691f, 0.08647286f, -0.08199315f, 0.02043265f, -0.04503177f, -0.01327864f, 
    0.17519593f, 0.00285070f, 0.14681973f, 0.10842293f, 0.09226616f, 0.01971786f, 0.04001256f, -0.05090617f, 
    -0.18426993f, -0.07353744f, -0.04376381f, -0.14489013f, -0.16592091f, -0.06364252f, -0.00550855f, 0.00099223f, 
    -0.14896487f, -0.14807335f, 0.15574798f, -0.06344067f, 0.00461515f, 0.03500018f, -0.00009794f, 0.01681950f, 
    -0.03204293f, 0.06876338f, 0.02972020f, 0.08829916f, 0.17717490f, 0.05494101f, 0.03415632f, -0.05888807f, 
    -0.02895783f, -0.02825313f, -0.05380064f, 0.05170229f, -0.07033247f, -0.04180641f, -0.00658279f, 0.02211542f, 
    0.08114006f, 0.05244694f, -0.12781481f, -0.04429198f, 0.08137256f, 0.10418182f, 0.11725594f, 0.01987423f, 
    -0.00450513f, -0.06507210f, -0.12209512f, -0.08770836f, 0.03532664f, 0.18807350f, 0.18474166f, 0.17495407f, 
    -0.05440632f, -0.00619213f, -0.01351111f, 0.06450509f, 0.08469395f, -0.05300116f, -0.00647192f, -0.05520911f, 
    -0.02268120f, -0.04637783f, 0.10463428f, -0.00682219f, 0.01947935f, 0.10981353f, 0.11859174f, 0.05283644f, 
    0.01690706f, 0.05529094f, 0.06283151f, 0.01516683f, 0.14231394f, -0.06669031f, 0.32359731f, -0.05468576f, 
    0.01951693f, 0.04535714f, -0.03314744f, 0.01774585f, 0.08609051f, 0.03440448f, 0.13964325f, -0.09378434f, 
    -0.12120061f, 0.10979950f, -0.08978370f, -0.08904631f, 0.13523597f, -0.15303873f, 0.07179621f, 0.01511967f, 
    0.05077942f, 0.04307356f, 0.01555841f, 0.21003518f, -0.13495694f, -0.16406886f, -0.11492287f, -0.07004904f, 
    -0.03566715f, -0.05453391f, -0.05536380f, 0.01184801f, 0.06892824f, -0.01388588f, 0.05432848f, 0.16508554f, 
    -0.05624180f, 0.10092378f, 0.04309146f, -0.08443993f, -0.08380600f, -0.08953842f, -0.00129118f, -0.04762003f, 
    0.00620898f, -0.06168068f, -0.05037462f, -0.02398405f, -0.08507027f, -0.02555195f, -0.00101163f, -0.11112719f, 
    0.02090331f, -0.14487422f, 0.02485220f, 0.11150097f, -0.08953725f, -0.00611344f, 0.06826251f, -0.14584103f, 
    -0.01942390f, -0.10824417f, 0.11612833f, -0.05084055f, -0.06201892f, -0.07392532f, 0.02782715f, 0.04579770f, 
    0.17092095f, 0.23182391f, 0.11135907f, 0.11218588f, -0.17901340f, -0.03631044f, -0.02291290f, -0.12434917f, 
    -0.10709137f, -0.10675430f, -0.05718378f, -0.06464112f, -0.01630273f, -0.03222799f, 0.00973011f, -0.02299724f, 
    -0.02115358f, -0.09424534f, -0.03012289f, -0.11248323f, 0.14766516f, 0.06783394f, 0.08272674f, 0.11445460f, 
    0.00491600f, -0.01168781f, 0.02334213f, 0.04099926f, 0.16551675f, 0.11070863f, 0.03604930f, 0.13241215f, 
    0.03644245f, -0.04207147f, 0.00344435f, -0.06897206f, 0.09616406f, 0.13062017f, 0.04716061f, 0.00621321f, 
    -0.16230506f, -0.17569774f, -0.21940549f, 0.05476080f, 0.03589285f, -0.00997325f, 0.12364563f, 0.05472480f, 
    -0.07679024f, -0.07267242f, -0.05727596f, -0.17070937f, 0.03998358f, -0.07467959f, 0.05144088f, -0.10138061f, 
    -0.01596142f, 0.00728949f, -0.07318392f, -0.07741304f, 0.12944433f, 0.13563684f, 0.18920064f, 0.14352916f, 
    -0.16454512f, 0.08061830f, -0.01907460f, 0.15988290f, -0.07745536f, -0.05497243f, -0.03839742f, 0.07896852f, 
    0.18276069f, 0.03010814f, 0.14978422f, 0.04388908f, -0.04993428f, 0.10663540f, 0.08179788f, 0.10854807f, 
    0.04580367f, 0.09868183f, -0.04120735f, 0.07598051f, 0.00796292f, 0.14100035f, 0.14361319f, -0.02515507f, 
    0.43740100f, -0.48820218f, 0.03417319f, 0.18729711f, -0.11429052f, -0.08811855f, -0.00259486f, 0.05058401f, 
    0.20414308f, 0.01936527f, 0.00203827f, 0.13452590f, 0.16521206f, -0.18011686f, 0.18087675f, -0.24573612f, 
    0.03235905f, -0.02863400f, -0.03998812f, 0.20850135f, -0.00025794f, -0.00955986f, 0.09610765f, -0.10575553f, 
    -0.06547265f, -0.00072052f, 0.16542809f, -0.10174508f, -0.08315834f, -0.00459066f, 0.16619717f, 0.08969469f, 
    0.16799432f, 0.03697947f, 0.14377032f, 0.13872506f, -0.14233653f, -0.05520084f, 0.01583448f, -0.05650310f, 
    0.00944050f, 0.07886469f, -0.00462233f, -0.10649851f, -0.01323362f, -0.01302985f, -0.05050602f, -0.08225131f, 
    0.03593425f, -0.00233862f, -0.25758126f, 0.21959941f, 0.13757403f, 0.14743695f, 0.14048329f, 0.08869333f, 
    -0.00777335f, 0.10610472f, 0.00305520f, -0.06559284f, 0.15849294f, -0.07159175f, 0.18225966f, -0.06378481f, 
    -0.07253160f, 0.00781845f, -0.08165450f, 0.05553942f, 0.20294540f, 0.07871491f, 0.00331755f, -0.05384843f, 
    -0.08997903f, -0.02343825f, -0.13596970f, -0.07135592f, 0.07054478f, -0.07317404f, -0.02953829f, -0.05374542f, 
    0.07237326f, 0.13302435f, 0.09880373f, 0.14424168f, -0.02320206f, 0.08927026f, -0.09263121f, 0.05651554f, 
    0.00777018f, -0.07673310f, 0.01434706f, 0.13467796f, 0.07307815f, 0.13101539f, -0.05090968f, 0.02550430f, 
    -0.13219832f, 0.14221433f, -0.03095422f, -0.02198895f, -0.08994476f, -0.11569276f, -0.07702538f, -0.02876200f, 
    0.18299676f, 0.18585508f, 0.04036940f, -0.06490928f, -0.25510097f, -0.22162849f, -0.10158149f, 0.00625730f, 
    0.06206089f, 0.00891385f, 0.06054710f, 0.04278176f, 0.03552093f, 0.01095299f, 0.02759057f, 0.00025202f, 
    -0.21094596f, -0.13256647f, -0.08239491f, -0.03329786f, -0.04850486f, 0.08096914f, 0.01809038f, -0.00323813f, 
    0.08199073f, 0.03994135f, 0.05942617f, 0.09202433f, -0.07290857f, -0.02379199f, 0.05625223f, -0.09037979f, 
    -0.17033423f, -0.00645643f, 0.20448454f, -0.01338397f, 0.02370495f, 0.07731892f, 0.09177345f, 0.16362494f, 
    0.04192860f, -0.28742620f, 0.09564578f, -0.11057859f, -0.05186719f, 0.11844128f, -0.06637971f, 0.12664191f, 
    0.04215379f, -0.04640802f, 0.03278708f, 0.03366191f, 0.00579782f, 0.04673149f, -0.12729444f, 0.08359890f, 
    0.13661781f, 0.07448996f, 0.06830632f, 0.14683418f, 0.07263993f, -0.02073379f, -0.02372308f, -0.02624158f, 
    0.07347645f, 0.18840615f, 0.22185387f, -0.11529731f, 0.01874840f, 0.04829288f, 0.04676912f, 0.00366438f, 
    0.04794560f, 0.08380841f, 0.03371917f, -0.24620372f, -0.09247161f, -0.06625875f, -0.19919607f, 0.01293837f, 
    0.12820749f, -0.07328201f, 0.16380815f, 0.04860867f, -0.10956482f, 0.06905706f, -0.03878671f, 0.09347842f, 
    -0.00724933f, 0.14342117f, -0.17739186f, 0.05568467f, 0.01344708f, -0.09296545f, 0.01775643f, 0.00410510f, 
    -0.01417699f, 0.06144357f, 0.03878709f, -0.02373781f, -0.22676130f, -0.15559992f, 0.33205879f, 0.05175346f, 
    0.04881499f, 0.08853354f, -0.01732928f, 0.23993464f, 0.02707554f, -0.07631771f, 0.04020211f, 0.18239619f, 
    -0.27600071f, -0.21392158f, -0.06941854f, -0.00269790f, 0.12231774f, 0.01283746f, 0.09784196f, -0.01621403f, 
    -0.06228881f, -0.09491268f, -0.02526911f, -0.03047045f, -0.08479137f, -0.09387886f, -0.01760172f, -0.01640187f, 
    -0.00896105f, -0.05903607f, 0.02349053f, 0.14170435f, 0.05626277f, 0.04548735f, 0.12849487f, -0.12104081f, 
    -0.01249393f, -0.02694973f, -0.02438228f, -0.07024211f, -0.05212726f, -0.00727457f, 0.00663432f, -0.04997353f, 
    -0.02490301f, 0.02400872f, -0.05331854f, -0.20856658f, 0.11636999f, 0.26277888f, 0.13729461f, -0.10492174f, 
    -0.06517053f, -0.06758624f, -0.00849091f, -0.05210961f, -0.06420690f, 0.06602784f, 0.04758924f, -0.04649930f, 
    -0.18601821f, -0.03903358f, 0.20527448f, 0.03852659f, -0.02192606f, 0.10985537f, -0.00210005f, 0.17553025f, 
    0.18272902f, 0.09946775f, 0.03768964f, 0.09691475f, 0.13462760f, 0.21747676f, -0.05408629f, 0.17127883f, 
    0.10188290f, 0.06941815f, 0.05266064f, 0.19592054f, 0.01936759f, 0.12386081f, 0.12048671f, 0.09331787f, 
    0.34181184f, -0.25828025f, -0.10368283f, 0.14996213f, 0.06030856f, 0.01322477f, -0.07020579f, -0.02564200f, 
    -0.03479488f, 0.03059618f, -0.09240150f, 0.03965552f, -0.07356784f, -0.00316839f, -0.07583290f, 0.07227997f, 
    0.13355057f, 0.04270853f, 0.17143998f, 0.20325193f, 0.16928415f, 0.14589244f, -0.02622686f, -0.05526649f, 
    -0.16454446f, -0.05337964f, 0.00342507f, -0.06361134f, 0.08755234f, -0.02495531f, 0.00404240f, 0.02694295f, 
    0.06019025f, -0.14730155f, 0.12812576f, 0.19328918f, -0.06097223f, 0.02619940f, 0.09981421f, 0.09156534f, 
    -0.00372842f, 0.00943665f, 0.02392451f, 0.12736258f, -0.04551134f, -0.02057250f, 0.07096099f, -0.10859182f, 
    0.03156756f, -0.00937798f, -0.26778403f, -0.05041825f, 0.05637377f, 0.07464487f, 0.06117178f, 0.03828758f, 
    0.01434486f, 0.03483623f, 0.08675463f, 0.00806141f, -0.19322120f, -0.09283805f, 0.06213249f, -0.02494363f, 
    0.06094166f, 0.05948390f, 0.10290282f, 0.08684421f, 0.10909755f, 0.06354383f, -0.01381470f, 0.06214010f, 
    0.01278450f, -0.08927526f, 0.02557962f, -0.02095675f, 0.04592283f, 0.04922504f, 0.05423404f, 0.16302451f, 
    -0.05286295f, -0.00974744f, 0.06060087f, -0.00962375f, -0.04185581f, -0.12722361f, -0.01291080f, -0.02454000f, 
    0.02737409f, 0.04624908f, -0.08068272f, -0.01670325f, 0.05653657f, 0.02492850f, -0.00490917f, 0.01211904f, 
    0.09450714f, -0.14723539f, 0.18524173f, -0.04828816f, 0.08290078f, 0.07347652f, 0.07723308f, -0.00024592f, 
    0.05569782f, -0.08971735f, -0.10191683f, -0.20545341f, 0.24805677f, 0.31315932f, -0.46070457f, 0.17537539f, 
    0.05104503f, -0.07988416f, -0.02200704f, -0.10186549f, 0.06354544f, 0.04742923f, -0.02393053f, -0.01111078f, 
    0.10690505f, -0.16394982f, -0.00267784f, 0.02948164f, 0.00294143f, -0.00178947f, 0.02658532f, -0.01155549f, 
    0.04901850f, -0.02317684f, 0.02142754f, 0.08317130f, 0.19279838f, -0.02932819f, -0.12636465f, 0.08872554f, 
    0.16865179f, -0.07921025f, 0.01453724f, 0.15536787f, 0.12043353f, 0.10067087f, 0.11043016f, -0.09968212f, 
    -0.19271560f, -0.08943146f, 0.21120259f, -0.01430495f, -0.03735320f, 0.01325555f, -0.12620625f, 0.10765091f, 
    0.14854987f, 0.08564308f, 0.07020531f, 0.07109534f, 0.01715358f, -0.20257975f, -0.13330302f, -0.04553306f, 
    0.04493603f, 0.01920913f, 0.05233490f, -0.05670283f, -0.01025179f, 0.09428259f, 0.03020753f, -0.00257427f, 
    0.00522287f, -0.26176575f, 0.23764361f, -0.14914212f, 0.12220640f, -0.12749752f, 0.03792788f, -0.00410190f, 
    0.16280940f, 0.09362404f, -0.04167124f, 0.11506606f, -0.11730771f, 0.00808758f, 0.06283472f, -0.05171020f, 
    0.00584779f, -0.01674232f, 0.10908328f, 0.16752005f, 0.01385810f, -0.04365419f, 0.13410686f, 0.18195331f, 
    0.17926882f, 0.22227047f, -0.04608676f, 0.12149917f, 0.14483817f, 0.17657620f, 0.00899489f, 0.00032585f, 
    0.14293233f, 0.21696100f, 0.11937810f, 0.11797422f, -0.06910156f, -0.09111605f, -0.17821085f, 0.00949134f, 
    0.00434418f, -0.00905692f, 0.12478571f, -0.12807073f, 0.07343551f, -0.05950496f, 0.02069334f, 0.08014921f, 
    -0.11266339f, 0.07635974f, 0.01617726f, -0.01001648f, -0.09156526f, 0.00407116f, -0.10117997f, -0.10956264f, 
    0.10790533f, 0.10716226f, 0.07603635f, 0.17597762f, -0.12287465f, -0.11422647f, -0.06791754f, -0.05578878f, 
    0.08914865f, -0.15456507f, 0.05254303f, 0.03333589f, 0.13305193f, 0.07527421f, 0.05634570f, 0.10688386f, 
    0.21079284f, -0.03356531f, 0.20615585f, -0.17511813f, -0.06053698f, -0.06775449f, -0.05748101f, -0.09432450f, 
    0.13794421f, 0.09323604f, 0.13187984f, 0.18587977f, -0.05764380f, -0.13002238f, 0.10310914f, -0.05547259f, 
    -0.06442772f, -0.10267133f, -0.13585831f, -0.09754737f, 0.11590823f, 0.12764178f, 0.06657986f, 0.03826140f, 
    -0.21859658f, 0.01703260f, -0.09647344f, 0.02756526f, 0.02062411f, -0.01312588f, 0.17878316f, 0.02383338f, 
    -0.01557863f, 0.06031848f, 0.07693759f, 0.05826828f, -0.03333062f, -0.13660565f, 0.08946010f, -0.03565373f, 
    0.20372108f, 0.09289623f, 0.02221619f, 0.01110734f, 0.14755295f, 0.02979521f, 0.09176830f, 0.13183105f, 
    -0.11921634f, -0.02856412f, 0.16895138f, -0.06435767f, 0.12298308f, 0.13572302f, 0.00074125f, -0.00902836f, 
    0.12240688f, 0.01802195f, 0.09723172f, 0.00009602f, 0.28392050f, 0.00112601f, 0.17619708f, 0.08154135f, 
    -0.03617138f, -0.03586377f, -0.01335441f, -0.00611237f, 0.10756506f, -0.01298923f, 0.02137341f, 0.05985510f, 
    -0.05765143f, -0.14753671f, -0.08024771f, -0.19389977f, 0.04724616f, -0.05475017f, 0.03485821f, 0.00791939f, 
    0.00707106f, -0.03153570f, -0.02931267f, 0.09261787f, 0.43202829f, 0.05328929f, 0.25190866f, 0.19453071f, 
    -0.17381522f, 0.03009433f, -0.06909978f, -0.04377446f, 0.03960150f, 0.00934098f, 0.13772745f, 0.07324148f, 
    -0.09096361f, -0.00918807f, 0.02072193f, -0.08804345f, 0.01622362f, -0.03166944f, 0.03187661f, 0.04348597f, 
    0.09979831f, 0.07159739f, 0.08799797f, -0.02782951f, -0.08817154f, -0.06596509f, -0.12290044f, -0.13125841f, 
    0.10195848f, 0.03135661f, -0.02708912f, -0.00412331f, -0.02763282f, 0.14002965f, 0.03070237f, 0.07754995f, 
    0.19495587f, 0.27691841f, -0.03736820f, -0.12397525f, -0.14328189f, -0.07363828f, -0.08565366f, -0.03212375f, 
    0.06620067f, -0.12202190f, -0.00672188f, -0.03406107f, 0.23063797f, -0.26015511f, -0.05545900f, 0.19170852f, 
    -0.07806168f, -0.08400125f, -0.11518668f, 0.10583479f, -0.00727641f, 0.06373094f, -0.03444519f, -0.07829223f, 
    0.03005268f, 0.03554618f, 0.01121328f, 0.01563282f, 0.05022013f, 0.13042866f, 0.10895323f, 0.00333185f, 
    0.08627281f, 0.08274156f, 0.13538629f, 0.12402079f, -0.15872423f, 0.13047253f, 0.07754830f, -0.08688867f, 
    -0.02342086f, -0.16512407f, -0.09302805f, -0.13594462f, 0.03679571f, 0.10253516f, -0.08802132f, 0.08088534f, 
    0.16633479f, -0.14603582f, 0.15293404f, -0.18653621f, 0.03385296f, 0.03926376f, -0.01140411f, 0.05436034f, 
    -0.05788118f, -0.01433749f, 0.11722703f, -0.03282111f, -0.01436022f, 0.12712277f, 0.18569091f, -0.08503307f, 
    -0.07692738f, 0.04291929f, -0.10692405f, -0.01763695f, -0.04661527f, 0.02752695f, 0.05489120f, -0.04160304f, 
    -0.29476824f, 0.14868729f, 0.00824380f, -0.10823738f, -0.15064654f, -0.08281698f, -0.08934046f, -0.09362885f, 
    -0.10030061f, -0.09223203f, -0.06115883f, 0.00792014f, 0.09964098f, -0.02651228f, -0.05215487f, 0.04255161f, 
    -0.07215596f, 0.08967690f, -0.05148620f, -0.02831505f, -0.05056746f, 0.01561607f, 0.15490080f, -0.08568880f, 
    0.35221913f, 0.14003339f, 0.07438583f, 0.00419922f, 0.01622354f, 0.02938444f, 0.01571774f, -0.02606880f, 
    0.06460399f, 0.05480669f, 0.01138401f, -0.06700734f, 0.18252020f, -0.02117829f, 0.02126391f, -0.04837757f, 
    0.05046470f, 0.07381381f, 0.12326168f, 0.24157727f, 0.05314860f, 0.01372386f, 0.06472548f, -0.10564911f, 
    -0.15257104f, 0.25808638f, -0.08642860f, -0.10529755f, 0.09981953f, -0.05730340f, -0.01437624f, 0.06299356f, 
    -0.09156519f, 0.04273597f, -0.14099462f, 0.06096376f, 0.15525392f, 0.16497515f, 0.06573051f, -0.01044780f, 
    -0.03477940f, 0.02432667f, -0.02996007f, 0.06578092f, 0.07502771f, -0.02085468f, 0.07926293f, 0.09791853f, 
    0.15240908f, -0.13250193f, 0.06269578f, 0.17545925f, 0.01638776f, 0.03126613f, 0.07334333f, 0.05908377f, 
    0.00206326f, 0.01517167f, -0.10025036f, 0.08761454f, 0.05578355f, -0.06085358f, -0.00441527f, -0.26584753f, 
    0.07328091f, 0.02327295f, -0.00119512f, 0.10796826f, -0.07874242f, -0.06790968f, 0.22013907f, 0.10698617f, 
    -0.18498826f, 0.33873802f, -0.23132257f, -0.58762515f, -0.01161388f, 0.02149989f, -0.14139615f, 0.14443204f, 
    -0.06347423f, -0.18421797f, 0.06887316f, -0.11359437f, 0.26720193f, -0.12439528f, 0.16842680f, 0.09076830f, 
    0.15905751f, 0.02333480f, -0.07512137f, 0.05254350f, -0.02075692f, -0.12002153f, -0.01639934f, -0.14003241f, 
    -0.05209308f, -0.02791473f, -0.08615518f, -0.19214782f, 0.03299729f, -0.00497130f, 0.05325688f, -0.05887152f, 
    0.01597829f, -0.10968908f, 0.05074385f, -0.07474094f, -0.12840156f, 0.05443178f, -0.19997080f, 0.14894888f, 
    0.02094418f, 0.12117802f, 0.10993980f, 0.00698548f, 0.12054726f, -0.14688006f, -0.02360131f, -0.15771610f, 
    0.36787856f, -0.04096965f, 0.08397365f, -0.00191286f, -0.03273508f, -0.10362581f, 0.00785460f, -0.00490907f, 
    -0.18300815f, -0.03653436f, -0.06057359f, 0.10377180f, 0.08192783f, 0.01186921f, -0.10582649f, 0.10181054f, 
    0.00996695f, -0.00384348f, 0.01323582f, 0.01177255f, -0.15298063f, 0.02963139f, -0.03961490f, 0.05685876f, 
    -0.05816098f, -0.05129758f, -0.11384168f, -0.10335547f, -0.03378530f, 0.00058107f, -0.03124494f, 0.01263706f, 
    -0.04870931f, -0.10847240f, 0.11755884f, -0.02190577f, 0.14928378f, 0.23985520f, 0.00856213f, 0.02103367f, 
    0.04167226f, 0.01911191f, 0.14239752f, 0.00530356f, 0.06188921f, -0.11808703f, 0.01705671f, -0.04733126f, 
    -0.06945553f, 0.07493583f, -0.26370326f, 0.06200500f, 0.02480784f, 0.01273184f, -0.01416715f, 0.23724985f, 
    0.02310234f, -0.04222599f, -0.06983775f, -0.12929428f, -0.04391635f, -0.08526565f, 0.04810261f, 0.03035883f, 
    0.06996511f, -0.06812907f, 0.05866832f, 0.07623710f, -0.07524374f, 0.04586685f, -0.04625859f, 0.15197051f, 
    0.23166758f, -0.15599687f, 0.11684811f, -0.09434906f, -0.01826594f, -0.07483644f, -0.01259947f, 0.12023628f, 
    0.08550476f, -0.03230885f, 0.11995088f, 0.18783085f, -0.10107613f, -0.10873393f, 0.07221960f, 0.05946729f, 
    -0.09269059f, 0.24600247f, -0.00937738f, -0.03970834f, 0.10076049f, -0.04086555f, 0.03371376f, -0.01930726f, 
    0.06560457f, -0.09726323f, 0.03131722f, -0.14311875f, -0.06739936f, 0.00800634f, -0.07941929f, 0.01152502f, 
    0.01909261f, 0.06197069f, -0.03079463f, 0.00329634f, 0.20195776f, 0.14279605f, -0.16472036f, 0.00586147f, 
    0.07635678f, -0.00953956f, -0.04475359f, 0.16107111f, 0.02534029f, 0.04793170f, -0.00663750f, -0.03865895f, 
    0.04894308f, -0.06734870f, 0.00088685f, -0.04104675f, -0.07278620f, -0.05944597f, -0.22180660f, -0.07041876f, 
    -0.03860005f, 0.06050446f, 0.05153527f, 0.00573093f, 0.13611892f, 0.00615558f, 0.07641927f, 0.15046950f, 
    0.06775522f, 0.16090052f, -0.11836081f, -0.10340684f, 0.01807237f, 0.00891395f, -0.04021785f, 0.00028519f, 
    -0.06743388f, 0.01698995f, 0.25194961f, -0.02569302f, -0.09098586f, -0.10770682f, -0.20006412f, -0.06873606f, 
    -0.04905351f, -0.19210809f, -0.03700129f, -0.03694674f, 0.04824075f, 0.17397587f, -0.05269770f, -0.04519835f, 
    -0.10069625f, 0.01157971f, -0.13027395f, -0.02990949f, 0.06182452f, -0.01851431f, -0.01492123f, -0.06282525f, 
    0.43228292f, -0.06887633f, 0.10020020f, -0.03057532f, 0.03508289f, 0.01245494f, 0.07623740f, 0.10773353f, 
    -0.00101266f, 0.07212618f, -0.00425165f, -0.04106392f, 0.01705138f, -0.22382909f, -0.03494982f, 0.18788779f, 
    0.06258988f, 0.00756940f, 0.03845574f, -0.05021996f, 0.03856652f, 0.03365824f, 0.03551760f, 0.05236442f, 
    -0.45136449f, 0.22643702f, -0.24451271f, -0.13353908f, -0.19115523f, -0.02795868f, -0.10038020f, -0.17695744f, 
    -0.03308804f, -0.04885247f, 0.00050901f, -0.08912674f, -0.08487637f, -0.14390002f, -0.15153864f, -0.02150079f, 
    0.09246998f, 0.05112493f, -0.02404955f, 0.07604868f, -0.08504659f, -0.05485743f, -0.11078131f, 0.07634364f, 
    0.04246699f, -0.09906758f, -0.05796389f, 0.02277310f, 0.20215563f, -0.07166900f, 0.14403680f, -0.09078930f, 
    0.18212543f, 0.09285236f, -0.06968601f, 0.00321129f, 0.04651028f, 0.06969271f, 0.00144282f, -0.02760507f, 
    -0.04845732f, 0.02738342f, 0.07501487f, 0.07061363f, -0.04127486f, 0.03818901f, -0.08592384f, -0.02604719f, 
    -0.17234606f, -0.13824609f, -0.03270966f, -0.22279617f, 0.00959755f, -0.15762293f, 0.28510886f, 0.03241702f, 
    0.13137305f, -0.01272707f, 0.03393195f, -0.02105038f, 0.18951187f, 0.05146445f, 0.20257451f, 0.19648178f, 
    0.05010036f, 0.10789010f, -0.01251917f, 0.06099615f, 0.03068844f, 0.02658214f, 0.10699430f, -0.08879254f, 
    -0.15888174f, -0.04968391f, -0.12534232f, 0.12629861f, -0.03393858f, 0.03767577f, -0.03179060f, 0.00509041f, 
    0.12436978f, 0.00820957f, 0.02102402f, 0.11632541f, -0.05623595f, -0.14152546f, -0.10264122f, -0.07586263f, 
    -0.03127132f, -0.12293720f, 0.05665431f, -0.09869460f, 0.00734392f, -0.03468369f, 0.07836774f, 0.01465128f, 
    -0.06270063f, 0.21818255f, -0.02833051f, 0.07846681f, 0.01870734f, 0.00373329f, 0.03684385f, 0.07122852f, 
    -0.18839699f, 0.05685204f, -0.07385330f, 0.01000059f, -0.27342612f, 0.12679245f, 0.20691861f, -0.10264044f, 
    -0.06088493f, -0.04389445f, -0.02875618f, -0.17233990f, -0.02845786f, -0.01196839f, -0.01715517f, 0.04612777f, 
    -0.16545881f, 0.16679981f, -0.02350744f, -0.02583349f, -0.05062001f, -0.03681186f, -0.07260351f, -0.05718907f, 
    -0.04785340f, 0.07948041f, -0.00668426f, 0.15918189f, -0.23875409f, 0.27834502f, 0.02589047f, 0.05330499f, 
    0.02109024f, 0.04663893f, -0.10181542f, -0.02913990f, -0.05232739f, 0.02919225f, -0.04695388f, 0.03497219f, 
    0.54540831f, -0.20911057f, 0.02113503f, -0.00506937f, 0.02396300f, 0.08828300f, 0.03446971f, -0.00102682f, 
    -0.07047831f, 0.02576922f, 0.07094749f, 0.04843908f, -0.15687855f, -0.07173862f, -0.04715747f, -0.14504506f, 
    -0.00732935f, 0.13276179f, 0.08442762f, 0.28682366f, -0.10046724f, 0.05774799f, 0.08710052f, 0.07699160f, 
    0.00603289f, 0.19633608f, -0.27519542f, 0.11136153f, -0.11374292f, -0.02081304f, 0.07378251f, -0.07999094f, 
    0.05717099f, 0.11803469f, 0.11784095f, 0.04359539f, 0.10105846f, 0.02875794f, 0.00426019f, -0.08274235f, 
    0.03475509f, -0.03815896f, -0.06109504f, 0.07216403f, 0.09840301f, -0.06307442f, 0.02041914f, -0.08563634f, 
    -0.14818442f, 0.02578520f, -0.02691876f, 0.04037930f, -0.06965517f, 0.15265079f, 0.05694725f, -0.10783830f, 
    0.09138872f, 0.11771180f, -0.02432627f, 0.02496834f, 0.04183450f, 0.06153350f, 0.07365777f, -0.00300694f, 
    -0.02424667f, 0.12143780f, 0.20015624f, -0.07101393f, -0.00890186f, 0.03888297f, -0.07940608f, 0.01772158f, 
    0.18575774f, -0.15584464f, -0.09689614f, -0.09102591f, 0.04725473f, -0.01361027f, 0.04849399f, -0.06217479f, 
    0.15470004f, -0.01717252f, 0.05208063f, 0.00996586f, -0.16652477f, 0.07250305f, -0.23250283f, -0.05337251f, 
    0.03303448f, 0.11535440f, -0.09407231f, 0.17161399f, -0.04935224f, 0.12807408f, -0.18924333f, 0.07750766f, 
    -0.11032640f, 0.43021926f, -0.07338226f, -0.30289078f, -0.08625714f, 0.00296424f, -0.07460648f, -0.09867936f, 
    -0.02701246f, 0.06187338f, 0.11295240f, 0.03082425f, 0.19620089f, 0.02131780f, -0.01732420f, 0.00452611f, 
    -0.18650101f, -0.07127324f, -0.08538941f, -0.02011054f, 0.02356291f, 0.01113000f, 0.01575786f, 0.05282741f, 
    0.05037427f, -0.02358722f, 0.00742479f, -0.12419017f, -0.10128516f, -0.13404532f, -0.00863559f, 0.04728869f, 
    -0.05635243f, 0.02364509f, -0.07936356f, 0.07623006f, 0.10178421f, -0.04712560f, -0.11199159f, -0.04861153f, 
    -0.12163820f, 0.14434333f, -0.11166678f, 0.20198856f, -0.09305698f, 0.06837218f, 0.00581598f, 0.02465576f, 
    0.05930509f, -0.00733140f, 0.00848205f, 0.07662413f, 0.03838143f, 0.03543967f, 0.10206236f, 0.10779177f, 
    0.04091411f, 0.01504350f, 0.00124692f, 0.04512011f, -0.02098328f, 0.10218857f, 0.13748172f, -0.07101217f, 
    -0.11203120f, 0.04015673f, -0.15098737f, -0.03672691f, 0.01518017f, 0.05030907f, -0.13211726f, -0.20638941f, 
    0.00669560f, -0.15572579f, 0.18149190f, -0.14140573f, -0.04873868f, -0.08120701f, -0.06611072f, 0.04222832f, 
    -0.00965022f, -0.10718998f, -0.10387155f, 0.01209749f, 0.36721069f, 0.23444353f, 0.05963204f, -0.01524524f, 
    -0.02992358f, -0.10147005f, -0.09687182f, -0.03216051f, -0.05043704f, 0.00164542f, 0.01921819f, -0.01553731f, 
    -0.00251828f, 0.01816541f, 0.20165114f, 0.00603527f, 0.10897424f, 0.07178377f, -0.00718155f, 0.14049082f, 
    0.12916020f, 0.03477598f, -0.01102909f, -0.04805679f, -0.05192225f, 0.06621069f, -0.03387864f, 0.09855800f, 
    0.16832666f, 0.11869579f, 0.04089461f, 0.01869287f, -0.05309521f, 0.03473045f, -0.02070476f, 0.03145702f, 
    0.05342308f, 0.21770924f, 0.07588454f, -0.01041527f, -0.04337509f, -0.05493464f, -0.00812679f, 0.01196103f, 
    0.05182450f, -0.08294064f, 0.02768825f, 0.00507970f, 0.25832576f, 0.09063034f, -0.07845891f, -0.07765832f, 
    -0.04768968f, -0.12105915f, -0.22443523f, 0.14467005f, 0.20295526f, -0.05419154f, -0.05886579f, -0.01694969f, 
    -0.02418775f, -0.02799296f, -0.00815470f, -0.00838195f, 0.07110310f, 0.10230345f, -0.06471662f, -0.08055579f, 
    -0.03829280f, -0.03522319f, 0.05400645f, 0.09910455f, 0.04477926f, 0.12633649f, 0.16702950f, 0.20681323f, 
    0.01730795f, -0.03572202f, -0.02117345f, -0.00204902f, 0.02002712f, 0.04964818f, -0.03734165f, 0.10200135f, 
    0.17326306f, -0.01926916f, 0.05319126f, -0.15301250f, 0.02664717f, 0.09620243f, -0.17990936f, 0.01426457f, 
    -0.05704064f, -0.02730158f, -0.00658922f, -0.01189481f, 0.06155679f, 0.03034555f, 0.08850295f, -0.04303624f, 
    -0.08926041f, 0.04351261f, -0.01569418f, -0.05129579f, 0.06807711f, 0.04961912f, -0.03806316f, 0.06637428f, 
    -0.03047253f, 0.09478137f, 0.26305565f, 0.09554984f, -0.01477017f, -0.02303532f, 0.00849913f, -0.17827924f, 
    0.00213604f, 0.03869423f, 0.05988200f, 0.09962329f, -0.01013525f, 0.04508527f, -0.00648431f, 0.19505140f, 
    0.03892112f, 0.12178157f, 0.04442216f, 0.05745633f, -0.00129466f, 0.03273267f, 0.10172655f, 0.06906655f, 
    0.05736631f, 0.18454097f, 0.22277750f, 0.17756069f, 0.06256317f, 0.02396555f, 0.12247194f, -0.16352654f, 
    0.06066854f, 0.04976552f, -0.04255351f, 0.03376835f, 0.06309598f, -0.01337164f, -0.00345909f, 0.06442443f, 
    0.09900135f, 0.15546605f, 0.06475393f, 0.12774317f, 0.07894730f, 0.11418075f, 0.00654623f, -0.12298654f, 
    -0.30306613f, 0.18415761f, -0.25743374f, 0.08291586f, 0.12395483f, -0.05516605f, 0.11532096f, 0.15569910f, 
    -0.13482754f, 0.04546165f, -0.05606292f, 0.17782198f, -0.11415692f, 0.41733280f, -0.08058713f, 0.21190549f, 
    -0.05665598f, -0.00677187f, 0.02720329f, 0.02540383f, 0.07641405f, -0.02550552f, 0.02586342f, 0.02413065f, 
    0.19722357f, -0.02468393f, 0.06784393f, 0.15359046f, -0.02505339f, 0.10187653f, -0.03800070f, -0.09960523f, 
    -0.08796585f, 0.04574194f, -0.19831581f, 0.05751558f, -0.17399354f, 0.02039590f, 0.03538481f, 0.08875894f, 
    -0.09211791f, -0.00670760f, -0.09128246f, -0.01405516f, 0.03857667f, 0.06325155f, 0.20757759f, -0.06872638f, 
    -0.04865037f, 0.09070127f, -0.05838447f, -0.28286162f, -0.05644758f, -0.04822410f, -0.29808405f, 0.00832239f, 
    -0.14286847f, -0.18186171f, 0.08158528f, -0.05136613f, 0.23508349f, 0.04911027f, -0.05530737f, -0.05287826f, 
    0.09784074f, 0.04451981f, 0.00414743f, 0.01827484f, 0.02742246f, -0.05312986f, -0.08509623f, 0.00194094f, 
    0.01914438f, 0.04805120f, 0.04000247f, -0.02645500f, 0.10883886f, -0.00415916f, -0.02698724f, 0.00275036f, 
    0.00410271f, 0.00240633f, -0.02098090f, -0.11065549f, -0.30984583f, 0.33365780f, -0.37076515f, 0.20004627f, 
    0.00655523f, 0.20465712f, -0.01636709f, 0.00646230f, 0.21013846f, -0.07704180f, -0.03397229f, -0.08055076f, 
    0.17384510f, 0.02316911f, -0.06942355f, 0.09920261f, 0.04575162f, 0.01840441f, -0.06150585f, 0.05833033f, 
    -0.14716376f, -0.05868362f, 0.03015130f, 0.09492891f, 0.07806817f, -0.02383197f, -0.05404063f, 0.27102304f, 
    -0.02098566f, 0.07220744f, 0.07717764f, -0.02098923f, -0.12176087f, -0.05543945f, -0.14694333f, 0.01080756f, 
    -0.08114138f, -0.11609049f, 0.14664668f, 0.15607652f, -0.05822790f, 0.17235450f, -0.05228109f, -0.09688742f, 
    -0.11400615f, -0.09098373f, 0.02501689f, -0.12595753f, 0.14646417f, 0.44607157f, 0.25841278f, 0.10040170f, 
    0.07125504f, 0.08267412f, -0.05403191f, -0.11298750f, -0.12160023f, -0.08866529f, -0.01249133f, -0.17003940f, 
    -0.12129320f, 0.20201138f, -0.33520892f, 0.18674579f, 0.02584505f, -0.20956901f, -0.12877439f, 0.08635358f, 
    -0.16739506f, -0.08068725f, 0.01409060f, 0.09639146f, 0.09288943f, -0.09360611f, 0.24779016f, 0.07986928f, 
    0.16186707f, -0.08275091f, -0.12041079f, 0.01949710f, -0.03516112f, -0.02547687f, -0.14119889f, 0.19037214f, 
    0.00528402f, -0.03739042f, 0.06523774f, -0.15523826f, 0.01403567f, -0.11632807f, -0.14638388f, -0.07051258f, 
    0.07196334f, -0.07983644f, 0.12987205f, 0.24233760f, 0.02443189f, -0.01927925f, 0.08571408f, 0.06159463f, 
    -0.07279224f, 0.26353550f, -0.14371774f, 0.03338945f, -0.04902066f, -0.07534768f, -0.04039540f, -0.00030257f, 
    -0.02666535f, -0.10464914f, 0.01125441f, -0.03202046f, -0.01101550f, 0.07118841f, -0.14786009f, -0.00856133f, 
    0.01349369f, 0.06860484f, -0.11773790f, 0.13445278f, -0.30317616f, 0.09799564f, -0.17740695f, 0.17312883f, 
    0.11171588f, -0.04671864f, 0.03774340f, 0.02743720f, -0.03381835f, -0.08106873f, 0.17291471f, -0.01362454f, 
    -0.24342263f, -0.28917825f, 0.00191556f, 0.28049815f, -0.06460900f, -0.05790273f, -0.01065071f, -0.02480653f, 
    -0.10278010f, -0.07169484f, -0.08837348f, -0.09819321f, 0.08968229f, 0.11602347f, 0.28480810f, 0.27205884f, 
    0.02210168f, 0.00312712f, -0.08358999f, -0.08221436f, 0.00699229f, 0.03563095f, 0.04205755f, -0.06984638f, 
    0.01859638f, -0.07832376f, 0.04941387f, 0.11837821f, -0.02619990f, -0.02385921f, 0.01012299f, -0.09126333f, 
    0.21307410f, 0.18936430f, 0.04346314f, 0.10979023f, 0.03045668f, 0.13109800f, -0.03294083f, 0.06525961f, 
    -0.02941351f, 0.01259490f, -0.03865793f, 0.05469954f, 0.05347810f, 0.01707039f, 0.05364459f, 0.00658096f, 
    -0.04840485f, -0.03936874f, 0.22220276f, 0.12575169f, 0.08115322f, 0.07767980f, 0.06402413f, 0.09505729f, 
    -0.00728377f, -0.03447035f, -0.04657022f, 0.04281351f, 0.06595179f, -0.17378977f, -0.00969889f, 0.21350971f, 
    0.16009560f, 0.02775286f, 0.10819598f, -0.03295793f, 0.22902903f, -0.00881552f, -0.00557106f, 0.06882732f, 
    -0.09384190f, 0.25931060f, -0.07528925f, 0.13803273f, 0.00720172f, -0.08463670f, -0.19449416f, -0.00914341f, 
    -0.03787073f, -0.00399957f, 0.11885133f, 0.12702633f, 0.00585701f, -0.07513307f, -0.08294952f, 0.04632873f, 
    0.09918714f, 0.08900020f, -0.08916073f, 0.06682632f, -0.10546177f, -0.06359234f, -0.03256866f, 0.05609519f, 
    0.19291125f, -0.13867608f, 0.02618836f, 0.10174867f, 0.22119753f, 0.00034286f, 0.03143131f, -0.09429474f, 
    0.08942012f, 0.03212568f, 0.05298487f, -0.05829537f, -0.05124540f, 0.04377510f, -0.00776617f, 0.07204928f, 
    -0.03266104f, 0.00263807f, 0.01851615f, -0.13210151f, -0.06994002f, 0.04708588f, -0.08877169f, 0.02199282f, 
    -0.11409723f, -0.22477920f, 0.04879665f, -0.11709844f, 0.04456989f, -0.08295377f, 0.10754696f, -0.01622091f, 
    0.09169764f, -0.09065400f, -0.00729977f, 0.06504109f, -0.00640528f, 0.06889521f, 0.37655088f, 0.50249338f, 
    0.05722896f, 0.09545716f, 0.04042605f, -0.03175332f, 0.05223602f, -0.03729280f, 0.06705754f, -0.09173199f, 
    -0.11994177f, -0.13708907f, -0.15944283f, 0.25441244f, 0.08669417f, -0.00524458f, -0.03838009f, -0.00619982f, 
    0.05163847f, 0.12547417f, -0.02589883f, -0.02580969f, -0.12630500f, -0.00980210f, -0.13049416f, 0.22110659f, 
    -0.25774023f, -0.03232383f, -0.00083152f, -0.14057735f, -0.06360016f, -0.11621620f, -0.09000590f, -0.03659762f, 
    -0.13609770f, 0.15564260f, -0.11165585f, 0.04674713f, -0.06628021f, 0.05350491f, -0.11475298f, -0.04843542f, 
    -0.15810369f, -0.02570435f, -0.14975277f, 0.02162364f, -0.16687678f, 0.18416700f, 0.17484458f, -0.07502649f, 
    -0.04341063f, -0.04431151f, 0.04219816f, -0.11539618f, -0.04985194f, -0.02130182f, -0.03495995f, 0.01491679f, 
    -0.04649331f, 0.08610128f, 0.04984886f, 0.13438234f, -0.00431593f, -0.06826230f, -0.01784447f, 0.01970875f, 
    -0.02943178f, 0.08138505f, -0.00604047f, 0.03420686f, -0.17827676f, 0.12931737f, -0.13835110f, 0.13766128f, 
    0.00857604f, 0.04498317f, -0.10805462f, 0.00931230f, -0.05254792f, 0.00153764f, 0.11223730f, -0.04442951f, 
    0.15560076f, -0.13620634f, 0.04384052f, 0.12024058f, 0.09330645f, -0.00478244f, 0.02507451f, -0.08322071f, 
    -0.05595007f, 0.05900732f, 0.05634197f, 0.10184077f, -0.29141054f, -0.27016264f, -0.15511543f, -0.02203217f, 
    0.02432401f, -0.01706619f, 0.17393188f, 0.16923472f, -0.10632614f, 0.07379685f, 0.03057066f, -0.02092073f, 
    0.28354037f, 0.13399637f, -0.32148990f, 0.20344284f, -0.07774236f, 0.14311227f, 0.08334334f, -0.09194299f, 
    -0.03246284f, 0.22845221f, 0.05742934f, -0.01820896f, -0.11469764f, 0.13378780f, -0.01498570f, 0.04519870f, 
    -0.02249156f, 0.11379892f, 0.00000017f, -0.00359197f, -0.06823654f, -0.10156227f, 0.02306164f, -0.21303560f, 
    -0.18872973f, 0.04403859f, 0.06151235f, 0.04530511f, -0.09278148f, 0.11712997f, 0.07772487f, -0.23158333f, 
    0.02526087f, 0.08508888f, -0.05568650f, 0.00485358f, 0.09431545f, 0.08911372f, 0.16453488f, 0.21431056f, 
    -0.09601445f, 0.07315093f, 0.12646700f, -0.26414171f, -0.11041714f, -0.06108721f, -0.14811285f, -0.03471676f, 
    0.14659999f, -0.09411907f, 0.01338734f, 0.03560414f, -0.02782611f, -0.00074062f, 0.06962915f, -0.06392539f, 
    0.01024239f, -0.07261863f, 0.06078288f, 0.02506633f, -0.22366050f, 0.02401407f, -0.18347956f, 0.11337998f, 
    0.02434121f, 0.02574352f, -0.06185108f, 0.23627417f, -0.00539152f, 0.06837031f, -0.27483478f, 0.16581859f, 
    -0.18088122f, 0.25830057f, 0.07609748f, 0.00724330f, 0.03185407f, -0.04703250f, 0.00354824f, 0.01573438f, 
    -0.05401065f, 0.00602050f, 0.24555041f, -0.03108413f, 0.13998659f, 0.03570716f, 0.00596981f, 0.13016282f, 
    -0.05608439f, 0.05890295f, 0.02652424f, 0.05445054f, 0.05356722f, 0.02475157f, 0.04791972f, 0.08176713f, 
    0.19647709f, -0.32221225f, 0.10169255f, -0.09064014f, -0.07228152f, -0.13381939f, -0.03020523f, 0.12835254f, 
    -0.07190449f, -0.01382002f, -0.07115024f, 0.10204171f, 0.03472647f, -0.08273773f, 0.07143052f, 0.10888874f, 
    -0.08807063f, 0.14547201f, -0.05128834f, 0.11414320f, -0.07404279f, 0.03543741f, -0.01219688f, -0.03058936f, 
    -0.13766536f, 0.00915627f, 0.04917397f, 0.18354484f, -0.04446611f, -0.00779102f, 0.09319507f, -0.00661911f, 
    0.07419689f, 0.07210836f, 0.01881305f, 0.03167625f, 0.07619366f, 0.02572957f, 0.08528654f, 0.03654487f, 
    -0.00246635f, 0.05123998f, -0.04638506f, -0.04853314f, -0.02118548f, 0.10032561f, -0.06529696f, -0.11317239f, 
    -0.02071987f, -0.10395330f, 0.20149821f, 0.07609842f, 0.08686044f, 0.06685301f, -0.02055097f, -0.00081732f, 
    0.03467361f, -0.05876864f, 0.01631780f, 0.05657575f, -0.33033103f, 0.21151958f, -0.14850667f, 0.00661210f, 
    0.06723201f, -0.09227218f, -0.01113270f, 0.03359817f, -0.02780915f, 0.00781762f, 0.05667825f, 0.09722371f, 
    0.11592972f, 0.00284295f, 0.08094033f, 0.02850213f, 0.02502858f, -0.02110959f, 0.06201034f, 0.07112502f, 
    0.08803031f, 0.00436147f, -0.08346619f, -0.01860075f, -0.11196657f, -0.01905535f, -0.01804835f, 0.06559889f, 
    0.06141545f, 0.03547657f, -0.03079638f, 0.02805729f, 0.09293950f, 0.01099156f, 0.07555559f, 0.04820373f, 
    -0.06727854f, 0.04762293f, 0.18719457f, -0.03666033f, 0.03192786f, -0.11477358f, 0.08087948f, -0.03708151f, 
    0.02653777f, -0.01525592f, -0.01833918f, -0.02511045f, -0.00644595f, -0.02247830f, 0.19434375f, -0.16828685f, 
    0.09745447f, 0.06180474f, 0.11639264f, -0.03501252f, 0.11290742f, -0.12843935f, 0.10126651f, 0.02448979f, 
    -0.17164920f, -0.13950239f, -0.13028374f, -0.01326955f, -0.01395752f, -0.09030436f, 0.00807332f, 0.05897265f, 
    0.04370974f, 0.12939879f, -0.04919316f, -0.13213328f, 0.16247664f, 0.00751323f, -0.06118150f, 0.06262198f, 
    -0.09633770f, 0.05907287f, 0.04202500f, 0.06682028f, -0.04007865f, -0.08250446f, -0.07331488f, -0.09068317f, 
    -0.07280716f, -0.18658224f, -0.06930754f, 0.21474776f, 0.03590408f, 0.15266168f, 0.01370517f, -0.10757013f, 
    0.01156984f, 0.01208180f, -0.08266849f, -0.00932795f, 0.09251346f, 0.08320608f, -0.10215794f, 0.09526519f, 
    -0.05779274f, -0.01105894f, 0.12138706f, -0.00927072f, 0.09986786f, 0.18652104f, -0.00493866f, 0.01380937f, 
    0.20875791f, -0.02587278f, 0.06123367f, 0.04827614f, -0.04740822f, 0.03975056f, 0.20674720f, 0.10755483f, 
    0.02887530f, -0.03909146f, -0.04099806f, 0.09308691f, -0.11282828f, 0.00955722f, -0.09410142f, 0.10950679f, 
    0.04821583f, -0.02392133f, 0.06214423f, -0.01010581f, 0.09175222f, 0.01955353f, -0.03708385f, 0.00230446f, 
    -0.21196459f, 0.10965821f, 0.27083141f, 0.17657895f, -0.08190744f, -0.02607686f, 0.16185543f, -0.04037430f, 
    0.04824441f, 0.07591278f, 0.03765515f, 0.09301645f, -0.12539431f, 0.01478286f, 0.22828777f, 0.13653700f, 
    -0.01481243f, 0.08067861f, -0.02142714f, -0.16872585f, 0.07071307f, 0.07886445f, 0.08337295f, 0.04965604f, 
    -0.07847171f, -0.01883633f, -0.32903939f, 0.20145029f, 0.03872010f, -0.02954933f, -0.06613054f, 0.05421678f, 
    -0.05076110f, 0.01556858f, -0.12530956f, 0.03436464f, -0.34847012f, 0.00829026f, -0.21543089f, 0.42694664f, 
    0.05789886f, 0.14141677f, -0.02216598f, 0.03809077f, 0.10796674f, 0.05378009f, 0.03597173f, 0.09074815f, 
    -0.12327667f, -0.07267651f, 0.01362611f, -0.07259514f, 0.01805041f, 0.02467407f, 0.05539985f, 0.04643648f, 
    -0.06715811f, 0.07681117f, -0.01897230f, -0.09718379f, -0.20891640f, -0.04027657f, -0.08115188f, 0.27440196f, 
    -0.04936600f, 0.05473036f, -0.00981881f, -0.12021577f, 0.09875301f, 0.03765635f, -0.04116857f, 0.07375319f, 
    0.17840853f, -0.11219162f, 0.02800750f, 0.24101628f, 0.00631819f, 0.10065714f, 0.06722872f, -0.12081654f, 
    -0.00231966f, -0.12448080f, 0.11303554f, 0.11978591f, 0.10355317f, 0.02020502f, -0.21990958f, -0.01003017f, 
    0.02859478f, 0.06259849f, 0.08057880f, -0.10087116f, -0.06606799f, 0.10093835f, 0.04654637f, 0.11225348f, 
    -0.02492212f, -0.00581810f, 0.06645240f, -0.04964921f, 0.07600480f, 0.05559675f, -0.01380553f, 0.06215730f, 
    -0.02787339f, 0.06355896f, 0.00599066f, -0.02219858f, -0.08149417f, 0.09311165f, -0.13008763f, 0.10445262f, 
    0.13614634f, 0.11539193f, -0.04585985f, 0.08911894f, 0.06050444f, 0.09282769f, 0.12376922f, 0.06752474f, 
    0.05976742f, -0.04032779f, -0.13463795f, -0.02227376f, 0.05414724f, 0.06291959f, 0.01630982f, 0.02182627f, 
    0.03802241f, -0.04926595f, 0.20425348f, 0.08306288f, -0.11422293f, -0.15201998f, -0.02454058f, -0.03650915f, 
    -0.12498927f, -0.06504223f, -0.01617966f, -0.07676756f, 0.01607411f, -0.04298551f, -0.00453581f, -0.08593126f, 
    -0.18392986f, -0.17487006f, 0.00587732f, 0.04619799f, -0.09333807f, -0.06211938f, -0.02907305f, -0.18929529f, 
    -0.01370093f, 0.06878697f, -0.03286985f, -0.04632135f, -0.31116396f, 0.00482365f, 0.14414684f, 0.07014483f, 
    0.00352436f, -0.06289711f, -0.04712843f, 0.08389714f, -0.07939855f, 0.03449998f, -0.01927968f, -0.08309758f, 
    -0.04279223f, -0.05734376f, -0.22850318f, 0.21572517f, 0.10203838f, -0.02279680f, 0.00369619f, 0.02877128f, 
    -0.09789901f, 0.01020653f, 0.08227306f, 0.00720476f, 0.23800115f, -0.08201639f, 0.26961908f, -0.13916245f, 
    -0.00512394f, -0.09497960f, 0.11053720f, 0.02020239f, 0.04567616f, 0.01411041f, -0.03854920f, 0.01814414f, 
    -0.02124328f, 0.11753477f, 0.08762598f, 0.24906690f, 0.10177384f, -0.10159589f, 0.04691688f, -0.14024974f, 
    0.00478967f, 0.11214140f, -0.04359864f, 0.09029943f, 0.09686613f, 0.04933316f, 0.02083411f, 0.02094997f, 
    -0.01075366f, 0.00594184f, 0.13126013f, 0.13057107f, 0.06329731f, 0.03042078f, -0.04839550f, 0.06673021f, 
    0.14168593f, 0.04576614f, 0.02238366f, 0.03615901f, -0.00415146f, -0.00069195f, -0.01740369f, -0.09158959f, 
    0.09952455f, 0.01385782f, 0.01164313f, 0.19445668f, -0.29063863f, -0.10376986f, -0.04186942f, 0.19017032f, 
    0.07344616f, -0.11306889f, 0.03968535f, 0.08766855f, 0.03532558f, 0.01860308f, 0.06713691f, -0.05398852f, 
    -0.25846830f, -0.21591832f, -0.10725379f, 0.11839747f, -0.14247505f, -0.06881440f, 0.20976284f, -0.09863153f, 
    0.08320905f, 0.00463575f, -0.01243051f, -0.01688280f, -0.13054311f, -0.16702721f, -0.03454734f, 0.04056840f, 
    -0.02557332f, 0.02199646f, 0.11024824f, -0.00305911f, 0.07342925f, 0.13367775f, 0.18427274f, 0.08576281f, 
    0.00116642f, -0.03723151f, -0.10493134f, -0.00477905f, -0.08941288f, -0.07154857f, 0.09801607f, 0.06603374f, 
    0.15198299f, 0.25601035f, -0.01889138f, -0.01461359f, 0.01576014f, 0.10575140f, -0.02670634f, 0.13057649f, 
    0.00675007f, -0.02230456f, 0.01767829f, -0.00862032f, 0.01557951f, 0.01912564f, 0.05514612f, -0.03731570f, 
    -0.14938524f, 0.03768890f, 0.04544248f, 0.11107939f, 0.02453472f, -0.01797161f, -0.04672755f, -0.05306995f, 
    -0.05958420f, -0.03101874f, 0.06867285f, 0.08928896f, 0.12663640f, 0.03922762f, 0.07804874f, -0.03963263f, 
    0.14241885f, 0.11334235f, 0.14598182f, 0.00690875f, 0.15860738f, 0.01175425f, -0.00945736f, -0.00243409f, 
    0.29847950f, 0.14439802f, -0.18796961f, 0.13500135f, -0.04665784f, 0.02419379f, 0.02473384f, 0.05006260f, 
    -0.04977926f, -0.04487142f, 0.07168600f, -0.01064518f, -0.01219280f, -0.14312907f, 0.04018928f, -0.14946836f, 
    0.05447330f, -0.02677209f, 0.01435181f, -0.05577278f, 0.07091267f, 0.04396395f, 0.16098513f, -0.02882147f, 
    0.06296701f, 0.01491345f, 0.08898398f, -0.00437454f, -0.04125721f, 0.10262395f, 0.07585196f, 0.05617521f, 
    -0.04368421f, 0.06774887f, 0.01777754f, -0.08397073f, -0.00192311f, 0.07447781f, 0.09614225f, 0.13397400f, 
    -0.06047354f, -0.04723375f, 0.01253820f, -0.04896608f, 0.08232126f, 0.03570846f, -0.03267679f, 0.19007480f, 
    0.02568403f, -0.10034330f, 0.00580570f, 0.02405576f, 0.09091790f, -0.00580282f, -0.07542647f, -0.09086785f, 
    0.14554282f, -0.03859748f, 0.07341259f, 0.11106966f, -0.18279459f, -0.10261456f, 0.01825056f, 0.12853867f, 
    -0.10371355f, -0.08974665f, -0.02253084f, 0.02491814f, -0.00041941f, 0.02236793f, -0.02963921f, 0.14201020f, 
    -0.04966020f, -0.07872374f, -0.17989878f, 0.01116246f, 0.05186982f, 0.02702309f, 0.07632035f, 0.01170406f, 
    -0.01828751f, 0.03184089f, -0.07253443f, -0.02952308f, -0.22409087f, -0.03979042f, -0.19328755f, 0.30812028f, 
    -0.17990150f, 0.10533592f, -0.02345664f, -0.01599135f, 0.01659222f, -0.06987412f, -0.09408440f, 0.01238401f, 
    0.12011252f, -0.00216027f, -0.03790043f, 0.14029805f, -0.03760105f, 0.07770701f, 0.03107425f, 0.00442734f, 
    0.08543935f, 0.12645066f, 0.09265694f, 0.17038827f, 0.25132027f, 0.15706512f, 0.00666799f, -0.19076489f, 
    -0.11320531f, -0.04798870f, 0.19720531f, 0.08336415f, 0.02129761f, 0.07822595f, -0.06505098f, -0.11888823f, 
    0.10538914f, -0.06055609f, -0.10913780f, 0.00226749f, -0.01150357f, 0.09175234f, 0.11224318f, 0.07226737f, 
    -0.03272020f, 0.03096134f, -0.00760141f, -0.04212561f, 0.21132395f, -0.01056709f, -0.16150917f, 0.01790464f, 
    -0.06272990f, 0.13459013f, 0.08981162f, 0.10693521f, 0.06808247f, -0.02409991f, 0.21592562f, 0.13200423f, 
    -0.12893398f, 0.17803946f, 0.15690920f, 0.24669804f, -0.01281870f, -0.10816650f, 0.10926330f, -0.13067354f, 
    0.02196573f, 0.04994310f, 0.05650923f, 0.11843961f, -0.11098064f, -0.24956730f, -0.07245439f, 0.11501653f, 
    0.00185435f, -0.22660242f, -0.10612655f, -0.10958020f, -0.05935678f, -0.01863024f, 0.01528220f, 0.06227846f, 
    0.14778444f, 0.01232911f, -0.27545503f, 0.07480239f, 0.00461495f, -0.01191700f, -0.03091278f, 0.28997368f, 
    -0.04530741f, 0.13665083f, -0.01978862f, -0.11686848f, -0.25193807f, -0.05695910f, -0.03431721f, 0.18072645f, 
    -0.07569179f, 0.12219245f, 0.03807608f, -0.03193217f, -0.00133679f, 0.05899521f, -0.05281225f, 0.05806772f, 
    0.07733671f, 0.13623367f, 0.01357993f, 0.09223919f, -0.11199145f, 0.14506875f, -0.02625229f, -0.03075816f, 
    0.04575440f, -0.03253373f, 0.03781858f, -0.08278451f, -0.12230587f, -0.19849902f, 0.02990635f, 0.01128401f, 
    -0.16744217f, -0.15281521f, -0.14395232f, -0.02815321f, 0.00961020f, -0.06153473f, -0.00631241f, -0.06317646f, 
    -0.17479658f, 0.10227685f, 0.21552631f, 0.02571138f, -0.03249203f, -0.02169455f, 0.01287576f, -0.00770270f, 
    0.02772765f, 0.12531649f, 0.01124560f, -0.19839579f, -0.08603419f, -0.13718000f, -0.11325546f, 0.08376565f, 
    -0.05846967f, -0.00068571f, -0.02144423f, -0.12418441f, -0.01740026f, 0.06406273f, 0.02451006f, 0.06096911f, 
    -0.27784747f, 0.05601084f, -0.01819544f, 0.17722586f, 0.07386988f, -0.09703664f, 0.09396888f, 0.03367580f, 
    -0.00462222f, 0.11806761f, -0.06674286f, 0.04583173f, -0.10708888f, -0.01884234f, -0.10356350f, -0.05127871f, 
    0.08548440f, 0.08972330f, 0.10445899f, 0.01146393f, 0.04810587f, 0.00737890f, 0.03653681f, 0.02239191f, 
    0.21163529f, -0.30233729f, 0.11790945f, -0.06561404f, 0.07611481f, -0.06316163f, 0.00177116f, -0.00834115f, 
    0.09207209f, -0.08874623f, -0.05662284f, -0.01286075f, -0.18305255f, -0.15408491f, -0.02153773f, 0.08565809f, 
    0.03904251f, -0.06346344f, 0.09971596f, -0.07508616f, 0.04921224f, 0.04249134f, 0.00297966f, 0.12972328f, 
    -0.17559639f, -0.05292604f, 0.10868813f, 0.11884193f, -0.09155545f, -0.02821221f, 0.04422284f, -0.06899813f, 
    0.04798384f, 0.09156058f, 0.16329651f, 0.07816817f, 0.10464992f, 0.11413201f, 0.05295150f, 0.07443832f, 
    -0.00425691f, -0.04821878f, -0.01297777f, -0.05391728f, -0.08587295f, 0.02868520f, -0.02244079f, 0.21709606f, 
    0.02108589f, -0.00010919f, 0.06642268f, 0.17446996f, 0.03862343f, 0.02583573f, 0.08794757f, 0.14058445f, 
    -0.01113387f, 0.03051451f, -0.05459428f, -0.03080874f, -0.31741932f, -0.03985235f, 0.06866187f, -0.24840471f, 
    0.12410226f, -0.01382970f, -0.05181426f, 0.06072615f, -0.01335261f, -0.01101533f, -0.05460116f, 0.04157771f, 
    -0.04531176f, 0.07355272f, -0.11959479f, -0.01690474f, 0.01245954f, -0.02589416f, 0.04141038f, -0.01432638f, 
    0.03623124f, 0.04067729f, -0.07142545f, 0.01599023f, 0.01509447f, 0.00076101f, -0.01696220f, -0.00393322f, 
    0.07515708f, 0.07367828f, 0.05812259f, -0.01868760f, 0.19490790f, 0.00778975f, 0.02128979f, 0.10414246f, 
    -0.33114806f, -0.25099492f, -0.09202910f, -0.07237165f, 0.09555207f, 0.00654607f, 0.08248247f, 0.04174734f, 
    -0.09002694f, 0.07469409f, 0.00131053f, 0.01487099f, -0.18915547f, 0.01839763f, 0.02650059f, -0.16585664f, 
    0.02200839f, 0.12159461f, 0.15880220f, 0.00290192f, 0.16447920f, -0.09655981f, 0.02469818f, 0.11695457f, 
    0.14282000f, -0.02804524f, 0.06553852f, 0.04154458f, 0.00971584f, -0.04819269f, -0.04838286f, -0.03094990f, 
    -0.06156456f, 0.02849307f, -0.00368355f, 0.02464038f, -0.13799439f, -0.17335692f, -0.19984317f, -0.01554206f, 
    0.01504096f, 0.09099439f, 0.06117492f, 0.04646748f, -0.00496398f, -0.04797881f, 0.05588028f, -0.02132528f, 
    -0.09479944f, 0.11508264f, -0.04308264f, 0.05965520f, 0.03464653f, 0.03902242f, 0.08798634f, 0.06134446f, 
    0.06048274f, 0.07407071f, -0.02893038f, 0.01694445f, 0.14933421f, -0.10726137f, -0.06671480f, 0.03533488f, 
    0.00350515f, -0.00590327f, 0.05085830f, 0.04321492f, 0.19574535f, 0.04133608f, 0.05285510f, 0.00412149f, 
    -0.01316886f, -0.21766220f, -0.17446055f, 0.01657392f, 0.08415373f, 0.05607517f, 0.11167935f, 0.05535204f, 
    0.08255268f, -0.01546611f, -0.01967690f, -0.07148970f, -0.05325015f, 0.00222060f, -0.02229414f, -0.00430963f, 
    0.10793962f, -0.08075422f, -0.01910253f, 0.02483387f, 0.08794957f, 0.11490925f, -0.01658811f, 0.11239254f, 
    -0.14842844f, 0.12594180f, 0.16160214f, 0.13395889f, 0.05219328f, -0.04750987f, -0.04737694f, 0.01691046f, 
    0.00832637f, -0.01037992f, 0.06430307f, 0.12784669f, -0.11298894f, 0.10754171f, 0.21187429f, 0.11316884f, 
    0.01935557f, 0.01426183f, -0.13384424f, -0.06581689f, 0.03544625f, -0.00812934f, -0.04828500f, 0.07212495f, 
    0.05110886f, -0.19180861f, -0.05568946f, 0.19514734f, -0.01849794f, 0.01730824f, 0.02038682f, -0.08837627f, 
    0.13875045f, 0.01116160f, 0.01157596f, 0.02314519f, -0.13021553f, -0.17794585f, 0.17609365f, 0.04751506f, 
    0.04495590f, -0.00776622f, -0.07687599f, 0.12007814f, 0.01259188f, 0.01866766f, -0.05552451f, 0.05206849f, 
    -0.15972924f, 0.07112799f, 0.06485420f, -0.12271694f, -0.01777718f, 0.04356766f, -0.10992551f, -0.09673730f, 
    0.06415905f, -0.02707437f, 0.12931968f, -0.00812772f, -0.20926167f, -0.00380013f, 0.00552916f, 0.14542930f, 
    0.00495860f, 0.02534755f, -0.01188663f, -0.00757726f, 0.10136207f, 0.05445016f, -0.06127351f, 0.03611235f, 
    0.10025987f, -0.15338144f, -0.07768729f, 0.38528383f, 0.05510845f, 0.06691640f, 0.05263036f, -0.17284279f, 
    0.02245243f, 0.22575434f, -0.01250379f, -0.03824128f, 0.04455911f, 0.03580771f, -0.06704523f, -0.04324694f, 
    -0.14302097f, -0.01477303f, 0.04887440f, -0.06691316f, 0.07767053f, 0.10043865f, 0.09719796f, 0.11952235f, 
    -0.06712078f, -0.00274191f, -0.06414776f, -0.03522759f, 0.06400638f, 0.02037466f, -0.04307566f, 0.01807005f, 
    -0.00240726f, 0.05140047f, -0.03161265f, 0.03592262f, -0.06595307f, 0.00828274f, 0.04976914f, -0.02339765f, 
    -0.07610640f, -0.06332832f, -0.12281041f, 0.11273082f, -0.05644204f, 0.07646358f, -0.01504706f, 0.06564983f, 
    -0.16158214f, 0.06572779f, -0.06113523f, 0.03727419f, 0.03424780f, 0.10852095f, -0.02842767f, -0.03385866f, 
    0.14359626f, 0.09094872f, 0.14332446f, -0.03037245f, -0.13135676f, -0.04614014f, 0.02426662f, -0.04694102f, 
    -0.02661384f, 0.00927025f, 0.06659714f, 0.03912931f, 0.10135932f, -0.11349765f, 0.02298172f, -0.04806620f, 
    -0.08097970f, -0.05696485f, 0.06303938f, 0.09522874f, -0.02023781f, 0.08508632f, 0.07311232f, 0.00586014f, 
    -0.01486181f, 0.08081673f, 0.01168885f, 0.00350174f, -0.06629058f, -0.03269888f, 0.07945420f, 0.02710823f, 
    -0.07447809f, -0.11223090f, -0.13231000f, 0.02252704f, -0.08354747f, 0.09503095f, 0.05389521f, 0.09108038f, 
    -0.12860836f, -0.15695453f, 0.18999153f, 0.02021188f, 0.01471727f, 0.02562033f, -0.05501330f, -0.07020669f, 
    -0.07867327f, 0.01847837f, 0.02786203f, 0.12293150f, -0.02618792f, 0.17920977f, -0.06335950f, 0.03441308f, 
    0.08511270f, 0.08796706f, 0.07550503f, 0.08538982f, 0.10160991f, -0.10383198f, 0.02107078f, -0.13754252f, 
    -0.09572551f, 0.22131638f, 0.15190129f, 0.03885165f, -0.00735953f, 0.08961809f, 0.00448138f, -0.14631321f, 
    -0.04447760f, 0.07856467f, -0.04037346f, -0.01610394f, 0.16830240f, 0.14371921f, -0.06656187f, -0.02671037f, 
    0.04200916f, -0.10774307f, 0.12633687f, 0.03984817f, -0.00868350f, 0.03303568f, 0.00264472f, 0.03964663f, 
    -0.03266476f, 0.29759794f, -0.01755499f, 0.15007651f, 0.03039918f, -0.11319558f, -0.01781468f, -0.11178257f, 
    0.02783288f, 0.04219289f, 0.07865725f, 0.05833710f, -0.26105002f, -0.23613644f, 0.10422944f, 0.17910042f, 
    -0.04716606f, 0.12124736f, 0.02346567f, -0.08533359f, -0.02771286f, -0.06151674f, 0.04373072f, 0.07820743f, 
    -0.08492932f, -0.05687371f, 0.01631383f, 0.10077132f, 0.02809689f, 0.04960142f, 0.28381419f, 0.08173807f, 
    0.00551173f, -0.07717206f, -0.05224709f, -0.03282186f, -0.15814587f, -0.13587749f, -0.04012808f, -0.01731373f, 
    -0.05389866f, -0.10156029f, 0.05601781f, 0.19400872f, 0.01418121f, 0.00616254f, 0.07719370f, 0.11869497f, 
    -0.06729298f, -0.19706978f, -0.14821447f, -0.03527337f, -0.04251904f, 0.03971377f, 0.06239463f, 0.05466463f, 
    0.14225659f, 0.27864549f, 0.11170458f, 0.00027458f, -0.02251028f, -0.08385779f, 0.00433978f, 0.09307267f, 
    0.04658978f, -0.00769235f, 0.06497776f, 0.01366971f, -0.05068796f, 0.06593474f, 0.05035146f, -0.01429781f, 
    -0.37071338f, 0.10934957f, 0.06788662f, 0.16241378f, 0.04392540f, 0.02992218f, -0.11956323f, -0.02432542f, 
    0.01789492f, -0.01175722f, 0.06302193f, 0.13719319f, -0.06601571f, 0.11648912f, 0.09835477f, -0.04955281f, 
    0.10133138f, 0.10288724f, -0.03103630f, 0.14297239f, -0.00020303f, -0.03644781f, -0.06449918f, -0.01595797f, 
    0.25232008f, -0.26594344f, -0.03746381f, 0.25574338f, 0.07687531f, 0.02658900f, -0.04189721f, 0.08406838f, 
    0.01458397f, -0.00189303f, -0.09157386f, -0.02904684f, 0.04362388f, 0.04568813f, 0.04393446f, 0.08393368f, 
    -0.03532985f, -0.03644205f, 0.05432637f, 0.05362093f, 0.11576393f, 0.01553696f, 0.16193359f, -0.01779689f, 
    -0.03356998f, 0.06909267f, -0.01664133f, 0.02177335f, 0.00562115f, 0.04783567f, -0.04238772f, 0.04026243f, 
    -0.13035934f, -0.09194519f, 0.01683374f, 0.02021697f, -0.04126832f, -0.03203056f, 0.09768246f, 0.16557175f, 
    -0.03826438f, -0.07515058f, -0.05457786f, -0.08150470f, 0.08043329f, 0.07196976f, 0.06545727f, 0.10264199f, 
    0.13415983f, 0.16515057f, -0.11507858f, 0.20630033f, -0.02620673f, 0.13510275f, -0.14030613f, -0.00491068f, 
    -0.06729443f, 0.03206158f, -0.03838641f, 0.00792002f, -0.17497207f, -0.11139598f, -0.08089817f, 0.02908831f, 
    -0.02479770f, -0.02049568f, 0.04130183f, 0.12200460f, 0.10237761f, -0.02226142f, -0.08860512f, 0.06465434f, 
    0.00503074f, 0.07971606f, 0.12595831f, -0.04278735f, 0.06031814f, -0.00449279f, 0.09687497f, 0.07561092f, 
    -0.06826591f, 0.07822272f, 0.02163946f, -0.07001913f, -0.06622021f, -0.00985711f, 0.02161578f, 0.09231566f, 
    0.01999783f, 0.12549402f, -0.05177499f, 0.18748297f, 0.00887711f, -0.04723334f, 0.00220987f, -0.03834525f, 
    0.09043629f, -0.27689630f, 0.09376925f, -0.02510653f, 0.00392947f, 0.01437978f, 0.00701464f, 0.00564938f, 
    0.20627004f, -0.03387769f, 0.06161679f, 0.10086540f, 0.02456338f, 0.07237637f, -0.37907198f, 0.15786070f, 
    0.06673553f, 0.04537374f, -0.00602408f, 0.03184488f, 0.00831435f, -0.07005010f, 0.06555378f, -0.11084899f, 
    0.06282903f, -0.20967478f, -0.05275392f, 0.02695695f, 0.09668512f, 0.08778978f, 0.02802626f, 0.02588732f, 
    -0.01851945f, -0.10966492f, 0.00018341f, -0.14590487f, 0.19481415f, -0.06535446f, -0.17239784f, 0.19720185f, 
    0.00522080f, -0.06222135f, 0.00339779f, 0.09166425f, 0.08702525f, -0.13264252f, 0.03964461f, -0.00322691f, 
    -0.28512201f, 0.09215476f, 0.21842103f, 0.14390804f, 0.02083753f, -0.02047177f, -0.06610511f, -0.05925627f, 
    0.08086522f, 0.04585059f, 0.07259133f, 0.01507183f, 0.14138871f, -0.00504921f, -0.00540353f, 0.18226464f, 
    -0.00368362f, -0.13580275f, -0.03232399f, -0.11571826f, 0.07802634f, 0.00636754f, -0.08889676f, -0.03314976f, 
    0.07680064f, -0.15264463f, 0.40351483f, -0.11495610f, 0.06942908f, -0.08587316f, -0.04767849f, 0.02192765f, 
    -0.03742888f, -0.07083290f, -0.10412340f, -0.01690972f, -0.15242833f, -0.00458523f, 0.04547690f, 0.10338321f, 
    -0.00964850f, 0.01175535f, 0.03590567f, 0.00055632f, -0.15234877f, 0.02965718f, 0.01201203f, 0.04893832f, 
    0.05373699f, 0.10101415f, 0.06320849f, 0.00240877f, 0.11742951f, -0.01075451f, -0.07165275f, 0.11016466f, 
    -0.00358946f, -0.02150568f, -0.01335082f, 0.01148026f, -0.08505303f, -0.06387747f, -0.07789654f, 0.03911858f, 
    0.01618833f, -0.10879024f, -0.06300721f, -0.03369777f, -0.02859487f, -0.07499124f, 0.00486492f, 0.04727134f, 
    0.00681029f, 0.20822284f, 0.19034538f, 0.09014989f, 0.01496516f, 0.01142781f, -0.12305001f, 0.06106853f, 
    -0.06058030f, 0.06500208f, 0.08956095f, 0.00895854f, -0.06259059f, -0.16797875f, 0.02970336f, 0.07047489f, 
    -0.03532142f, -0.08909158f, 0.07317210f, 0.02829728f, 0.04468921f, -0.05337825f, 0.17712149f, 0.04524101f, 
    0.15496187f, -0.28374073f, 0.11298033f, 0.19806454f, 0.03385812f, -0.03800017f, -0.03287414f, -0.04557373f, 
    -0.08228577f, 0.02306471f, -0.03459306f, 0.02093017f, -0.19265585f, -0.06204177f, -0.03973355f, 0.02177944f, 
    0.13613935f, 0.07900049f, -0.00472652f, 0.04529040f, 0.12821193f, 0.12081040f, 0.11510617f, 0.06929749f, 
    0.00041230f, -0.00202473f, -0.12999421f, 0.11424154f, 0.13631456f, 0.13833348f, 0.14307410f, 0.00890478f, 
    0.04001111f, -0.02615852f, -0.06176792f, -0.07246863f, -0.12928452f, -0.04097697f, 0.05989400f, 0.01311629f, 
    0.13685736f, 0.04145839f, 0.09088016f, -0.04403417f, 0.09095444f, 0.04147127f, -0.04584003f, 0.05088813f, 
    -0.15291645f, -0.07833602f, 0.14193332f, 0.02349584f, -0.01178658f, -0.04133365f, -0.12659615f, -0.01310032f, 
    0.03074609f, 0.07483636f, 0.13186987f, 0.06454247f, 0.07338626f, -0.14941661f, -0.05119733f, 0.04278724f, 
    0.02424959f, 0.00230062f, -0.03500091f, -0.04464075f, -0.03195457f, -0.07303462f, 0.07174707f, 0.15374990f, 
    0.04640922f, 0.29761165f, -0.13450876f, -0.15416448f, 0.06566611f, 0.02495984f, -0.02897349f, 0.09829162f, 
    -0.05073802f, 0.01410037f, 0.04432878f, 0.00580828f, 0.37093991f, -0.47503954f, 0.06213913f, -0.22747359f, 
    -0.06268264f, -0.00416950f, -0.00871503f, -0.00602981f, 0.03426399f, 0.00864162f, 0.04469055f, 0.07993761f, 
    -0.12498372f, -0.05731612f, -0.03474341f, -0.02467212f, 0.04918953f, -0.06186736f, -0.07861635f, 0.01921292f, 
    0.00258548f, 0.03260395f, -0.02156621f, 0.14102584f, -0.03721166f, -0.10870274f, -0.04332661f, -0.10017323f, 
    -0.07439867f, 0.00919102f, 0.03867758f, -0.07075992f, 0.10451432f, -0.00219726f, -0.03096112f, 0.06099439f, 
    -0.14033693f, -0.12813869f, -0.18578546f, -0.13465211f, 0.06448548f, 0.03332425f, -0.10501208f, 0.07879963f, 
    -0.08945888f, -0.03208522f, -0.01239127f, 0.05002764f, -0.15376805f, -0.18886638f, -0.36510497f, -0.05588118f, 
    -0.01156849f, -0.05675877f, 0.05181242f, -0.11357661f, -0.03390139f, -0.02052057f, -0.18233760f, -0.00459383f, 
    -0.02297838f, -0.12478336f, 0.10956640f, -0.04947994f, 0.02807444f, 0.05231439f, -0.06756988f, -0.02342897f, 
    0.02901177f, -0.10686811f, -0.01860101f, 0.02488872f, -0.26030597f, -0.06058251f, 0.01977146f, -0.05077391f, 
    0.11911559f, -0.01980527f, -0.05938241f, 0.00099705f, 0.07119671f, -0.02779685f, 0.10071304f, 0.10834394f, 
    -0.00645744f, 0.28309768f, -0.10243324f, -0.15480742f, 0.01640870f, -0.07152648f, 0.10238688f, 0.19979768f, 
    0.05730649f, 0.11212967f, 0.07516144f, -0.03663512f, 0.08046967f, -0.07038865f, 0.08810066f, 0.04148066f, 
    0.03932732f, -0.04143510f, 0.01562206f, 0.02627952f, 0.01653101f, -0.03420583f, 0.12180487f, 0.13686158f, 
    -0.18497731f, -0.01463673f, -0.18535604f, 0.01572426f, 0.12699576f, 0.08518534f, -0.01262521f, -0.01780855f, 
    -0.07081159f, -0.07334040f, -0.07786360f, -0.11388320f, -0.01282270f, -0.13964529f, 0.08821813f, -0.03683385f, 
    0.05251966f, -0.02662159f, -0.05126946f, 0.03000462f, -0.05263919f, 0.11846869f, 0.00189119f, 0.29010999f, 
    -0.12770061f, 0.12533380f, -0.12784202f, 0.04310339f, 0.04755937f, 0.08008004f, -0.02205072f, 0.08437652f, 
    0.11251701f, -0.05176152f, 0.00137535f, -0.02818049f, 0.04228309f, 0.03997057f, -0.10975114f, 0.06415443f, 
    0.01393718f, -0.00675987f, 0.01171254f, 0.09560195f, 0.00887709f, 0.06101400f, -0.18582048f, 0.06142646f, 
    0.09252115f, -0.15725957f, 0.39326534f, 0.16908069f, -0.06629915f, -0.18055406f, 0.01332743f, -0.04456608f, 
    0.15170504f, 0.04477239f, 0.15185793f, 0.00088698f, 0.32997215f, -0.33519590f, 0.58276051f, -0.27459204f, 
    -0.00057894f, -0.21158601f, 0.16424859f, 0.07287952f, 0.00053666f, 0.00044183f, -0.17512670f, -0.05383331f, 
    0.11998261f, 0.04464638f, -0.07171018f, -0.19695318f, 0.02955629f, 0.11827414f, -0.04630679f, -0.01224462f, 
    0.09016079f, -0.05329509f, 0.08614384f, 0.00629184f, 0.14903273f, 0.10666644f, 0.02249770f, -0.30112907f, 
    -0.00090295f, -0.09321288f, 0.01435941f, -0.08726276f, -0.11625280f, 0.08772406f, -0.03753717f, -0.06997661f, 
    0.08735353f, -0.27109686f, -0.07682224f, 0.18264432f, 0.22386548f, -0.08623983f, 0.09556815f, 0.15460870f, 
    0.02096282f, 0.06271182f, -0.09473956f, 0.02957368f, -0.13632074f, -0.08565120f, 0.13343857f, 0.09097330f, 
    -0.01437229f, -0.05005245f, -0.11033177f, 0.03389555f, 0.11879385f, -0.05240367f, -0.01758840f, 0.00160402f, 
    -0.02336200f, -0.05495743f, -0.20614608f, -0.10864400f, 0.05528164f, -0.09053913f, -0.02386738f, 0.05061159f, 
    0.05811580f, -0.07736199f, -0.05082915f, 0.12604995f, 0.28933218f, -0.39630887f, 0.39935231f, -0.10327245f, 
    -0.02379134f, -0.10315970f, 0.11645368f, 0.09669473f, 0.01241639f, 0.00450360f, -0.05421125f, -0.01047148f, 
    -0.20669924f, 0.02746711f, -0.02110295f, 0.04228103f, -0.01879906f, -0.00526976f, 0.00468275f, -0.01828333f, 
    0.14144585f, 0.17000303f, -0.04087177f, 0.02379102f, -0.00909290f, 0.07460730f, 0.12996891f, -0.02062911f, 
    0.09056255f, 0.05563727f, 0.00310823f, 0.03469321f, 0.06678393f, -0.01616868f, 0.03384965f, 0.06605335f, 
    0.14988026f, 0.15307440f, 0.10766781f, -0.04992849f, 0.01505189f, 0.00900211f, 0.03321861f, 0.03109070f, 
    0.08965576f, -0.00649451f, 0.09800870f, 0.08155846f, 0.09085331f, -0.15951298f, 0.00678076f, -0.17294411f, 
    -0.04786678f, 0.05305484f, -0.00181874f, -0.09880896f, 0.13197201f, -0.05153385f, -0.02813357f, 0.09429707f, 
    0.30986226f, -0.30024254f, 0.48100480f, -0.24489456f, -0.13688143f, -0.07730683f, -0.01327187f, 0.02882081f, 
    0.12765869f, -0.01588411f, -0.00491608f, -0.06703556f, 0.02500716f, 0.06908593f, -0.28908053f, -0.02249617f, 
    0.11324642f, 0.25722265f, 0.00834658f, 0.05043288f, 0.09447686f, -0.11033638f, 0.11777510f, -0.15328717f, 
    0.29128206f, 0.12217669f, -0.02093388f, -0.36456886f, -0.00796694f, 0.06686711f, -0.00582244f, -0.00716053f, 
    0.03614940f, 0.03670761f, 0.10789759f, -0.04776865f, -0.23224908f, 0.00288507f, -0.12866889f, -0.14799640f, 
    0.14520118f, 0.07471234f, -0.04248326f, 0.14095038f, 0.00140963f, 0.01381727f, -0.05340817f, 0.12053432f, 
    -0.11156725f, 0.07117593f, -0.04064717f, 0.03804739f, 0.08050980f, -0.01346834f, 0.03330627f, -0.02233227f, 
    0.06064451f, 0.02722692f, 0.16592163f, 0.02962646f, 0.30891767f, -0.14296186f, 0.44712156f, 0.15150319f, 
    -0.10869327f, 0.00293455f, 0.10389642f, 0.00526469f, 0.10435206f, -0.02997477f, 0.01636556f, 0.05822267f, 
    0.06732424f, 0.22047785f, 0.15623870f, -0.11765726f, 0.00947863f, 0.03078717f, -0.01445384f, 0.01733014f, 
    0.10676434f, -0.01981685f, -0.01249032f, 0.04093741f, -0.01043382f, 0.18333006f, 0.11920831f, -0.12132701f, 
    -0.14479528f, -0.09401548f, -0.06049829f, 0.07872532f, -0.01039166f, -0.05526299f, -0.00881015f, -0.01310784f, 
    0.00568594f, -0.02384817f, 0.00609840f, 0.01741453f, 0.07438464f, 0.01114026f, -0.05572566f, 0.01409994f, 
    -0.18280049f, -0.19200785f, -0.01752491f, -0.07219106f, -0.03781151f, -0.08934295f, -0.06688617f, -0.08780944f, 
    0.05713930f, -0.00966881f, 0.02273311f, 0.00351407f, -0.09542321f, -0.07340620f, -0.03730114f, 0.06321236f, 
    -0.03281122f, -0.14245340f, 0.14677055f, 0.06386954f, -0.11691203f, -0.06370959f, 0.14207070f, 0.02251281f, 
    0.20611976f, 0.09724987f, 0.06375960f, 0.02162959f, 0.00582058f, -0.09279581f, -0.08731901f, 0.03991218f, 
    -0.04990177f, -0.08129649f, 0.01445683f, 0.26061550f, -0.09634001f, 0.00592584f, -0.04552962f, -0.03403585f, 
    -0.16771261f, -0.20764545f, 0.17987946f, 0.11292788f, 0.16489978f, -0.00512792f, 0.05968411f, 0.03891336f, 
    0.04275458f, 0.06750011f, -0.08449525f, 0.03914152f, 0.02126613f, 0.20961493f, -0.01729168f, -0.01604855f, 
    -0.04639567f, 0.04896622f, 0.05892344f, -0.03776091f, 0.07655378f, 0.02357689f, -0.05035720f, 0.03527871f, 
    -0.21676642f, 0.08556338f, -0.06073940f, 0.04309065f, 0.19419761f, -0.04000564f, -0.07232978f, 0.16302693f, 
    0.07544627f, -0.19483429f, 0.05873845f, 0.06360507f, -0.02346408f, 0.12220960f, 0.02743087f, 0.05337933f, 
    0.09622123f, 0.02545374f, 0.03747206f, -0.00464224f, 0.05252431f, -0.06606172f, 0.16621722f, -0.06690341f, 
    0.02209305f, 0.17093332f, -0.07852108f, -0.02889192f, -0.05908238f, 0.05130859f, -0.02752205f, -0.00287463f, 
    -0.05192883f, -0.02732598f, -0.00944789f, 0.01306745f, 0.07951725f, 0.04724348f, 0.17578961f, -0.09960384f, 
    0.04765419f, 0.02773443f, 0.05757331f, 0.02781738f, 0.10842482f, -0.02865340f, -0.01726949f, 0.06851093f, 
    0.28369325f, 0.08299063f, 0.29022583f, -0.01462122f, -0.06226413f, -0.06753547f, -0.07547624f, 0.01671599f, 
    0.02500514f, 0.13668731f, 0.09005862f, -0.02656744f, 0.35306686f, -0.12837683f, 0.35222051f, -0.42008939f, 
    0.09995859f, 0.02819266f, -0.04235612f, 0.00077823f, 0.02592673f, 0.01942141f, 0.10369556f, -0.01336384f, 
    0.14654839f, -0.15656585f, 0.09112754f, -0.13841365f, 0.07590012f, -0.03473992f, 0.07240173f, -0.08499060f, 
    0.01059497f, -0.09417293f, 0.02659602f, -0.15943290f, -0.24040243f, -0.15982573f, -0.32267126f, 0.12544094f, 
    0.15752292f, 0.05910250f, -0.05003368f, -0.00261084f, 0.01304787f, -0.00574018f, 0.06501246f, 0.03711817f, 
    -0.10454649f, -0.12178134f, 0.09078071f, 0.13047121f, 0.12383377f, 0.01551967f, -0.07335585f, 0.04199151f, 
    0.05128433f, -0.10398862f, 0.01971961f, 0.09252795f, -0.58336008f, -0.28947482f, 0.16889158f, 0.17553955f, 
    0.05762360f, -0.09150801f, -0.02635399f, -0.03147629f, 0.14076348f, 0.01307945f, -0.20044622f, 0.07607944f, 
    -0.17438710f, -0.04195111f, -0.00358548f, -0.09009185f, -0.05609914f, 0.07999343f, 0.03907840f, 0.13571697f, 
    0.13518323f, -0.04864143f, 0.05333819f, -0.08968079f, 0.12370381f, 0.24750270f, 0.05551634f, 0.00918083f, 
    -0.05483572f, -0.05598690f, -0.01242623f, 0.01526272f, 0.17586064f, 0.08584906f, -0.05249802f, 0.01795082f, 
    0.11933344f, -0.25777161f, 0.30125940f, -0.21012981f, 0.10099008f, 0.00829696f, -0.08779625f, -0.12685345f, 
    0.09169865f, -0.03461927f, -0.06556427f, 0.14451689f, 0.12195938f, 0.00095901f, 0.23171687f, -0.02249477f, 
    -0.00219582f, -0.02427350f, 0.10545374f, 0.07992750f, 0.08032248f, 0.01032705f, 0.05428981f, -0.04165990f, 
    0.08105820f, -0.00874279f, -0.00828220f, -0.06084854f, 0.10658350f, -0.01076932f, 0.04879151f, 0.11800602f, 
    0.01443424f, 0.06650409f, 0.04380148f, 0.12413380f, -0.02418985f, 0.25086465f, 0.02711001f, -0.00344437f, 
    0.12613563f, 0.06472039f, 0.07115167f, 0.07548603f, 0.03045110f, 0.04115644f, 0.11643357f, 0.07644178f, 
    0.11226950f, -0.02816209f, -0.20813015f, -0.03516991f, -0.02169023f, 0.06012416f, 0.03150973f, 0.04612800f, 
    0.02663237f, -0.05192363f, 0.05624143f, 0.17983827f, 0.15641661f, 0.02355846f, 0.20955983f, -0.08943310f, 
    -0.05323460f, -0.04022339f, 0.09625489f, -0.10748151f, 0.10404777f, -0.15595606f, 0.11160127f, 0.02521519f, 
    0.09216861f, -0.16743888f, 0.07515974f, -0.03417908f, 0.00901742f, 0.02022104f, -0.04506408f, -0.04384515f, 
    0.05546923f, -0.08648857f, 0.05199638f, 0.01043674f, -0.01367242f, -0.06341985f, 0.03358963f, 0.00554038f, 
    -0.06251072f, -0.07290061f, -0.11062612f, -0.03488689f, 0.07161788f, 0.18055803f, 0.04836535f, 0.12840299f, 
    -0.32355157f, 0.11326449f, -0.18379077f, 0.10225920f, 0.10551985f, 0.14729281f, 0.01316476f, 0.06246970f, 
    0.00763105f, 0.08175974f, 0.06178662f, 0.03253148f, 0.10461529f, 0.11648515f, 0.03844120f, -0.14915201f, 
    0.04000719f, -0.12294917f, -0.14173573f, -0.01936202f, 0.06493516f, 0.03327045f, -0.00281829f, 0.07314539f, 
    0.18999541f, 0.15420964f, 0.17080788f, -0.10554343f, -0.01037542f, 0.08060453f, -0.02037005f, -0.04067409f, 
    0.03803166f, -0.02932552f, -0.06057307f, -0.06369074f, 0.08749031f, -0.18888290f, 0.04931688f, 0.08582114f, 
    0.06132229f, -0.02107753f, 0.03385364f, 0.10708247f, -0.01327428f, -0.07841817f, 0.12646623f, -0.08367869f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.06513986f, -0.04187568f, 0.02632791f, 0.01433553f, 0.17963931f, 0.04797601f, 0.01798374f, -0.07920607f, 
    -0.00642325f, 0.05988340f, 0.02196906f, 0.14492825f, -0.01805445f, 0.02509559f, 0.05917277f, 0.03687019f, 
    0.01972913f, 0.10973465f, 0.04689099f, -0.01949845f, -0.02464385f, -0.04110404f, 0.05017688f, -0.00697380f, 
    0.03550504f, 0.02696445f, 0.16594332f, 0.01753127f, 0.09770631f, 0.05296976f, 0.05210472f, 0.07144928f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.16646416f, 0.07020548f, -0.04804407f, -0.01989429f, -0.01983186f, -0.18017346f, -0.21373470f, -0.18454371f, 
    -0.05433076f, 0.07977851f, 0.04557539f, -0.07460846f, -0.13168728f, 0.15315993f, -0.04705053f, 0.16560037f, 
    -0.00399424f, 0.07541180f, -0.08190380f, 0.16459703f, 0.13638115f, -0.17199916f, -0.18618105f, -0.19163509f, 
    0.11062125f, -0.20097524f, -0.15750058f, -0.10994758f, 0.00325296f, -0.03616047f, -0.11676174f, -0.18092817f, 
    -0.07863955f, -0.01302985f, -0.20993508f, -0.24240702f, 0.06482497f, -0.22368126f, -0.05698938f, -0.04435270f, 
    -0.05326017f, -0.13072523f, -0.00739128f, 0.33819619f, -0.05792735f, -0.04611469f, -0.27994418f, 0.04747674f, 
    0.15090625f, 0.16412558f, -0.22593082f, 0.13515934f, -0.06035253f, 0.07762681f, -0.02122957f, -0.05120286f, 
    0.05046064f, -0.02155968f, 0.39162329f, -0.09078270f, -0.25937450f, -0.02508422f, 0.36404151f, 0.27627370f, 
    -0.04949571f, 0.06141435f, 0.06215679f, -0.23088162f, 0.35374415f, 0.03917120f, 0.29547337f, -0.50640249f, 
    0.11087762f, 0.22431107f, 0.00359002f, -0.18091892f, -0.16150019f, 0.15624833f, -0.21386498f, 0.07262699f, 
    0.15631741f, 0.17619814f, 0.24526988f, -0.03982583f, -0.14256744f, 0.00772103f, 0.35707432f, -0.06025986f, 
    -0.15639551f, 0.02552686f, 0.25180086f, 0.36051762f, 0.24420297f, -0.24169160f, 0.03736749f, 0.19504854f, 
    0.24363156f, -0.00790626f, -0.05907175f, -0.01842728f, -0.09970361f, 0.00321192f, -0.06615163f, -0.05703335f, 
    -0.18238433f, -0.05125857f, 0.14020067f, 0.11319365f, 0.13164812f, -0.03160449f, 0.16607594f, -0.43742856f, 
    -0.14689302f, 0.01702230f, -0.11117639f, 0.08572780f, 0.11158213f, 0.04676848f, -0.35984814f, -0.16222487f, 
    -0.06962393f, -0.17573920f, -0.09982787f, 0.14535010f, 0.13030633f, 0.05519821f, 0.10195690f, -0.24462683f, 
    0.35018259f, -0.04591950f, -0.02761257f, -0.21725795f, -0.09720886f, 0.31565735f, 0.48250347f, 0.37992564f, 
    0.08463489f, -0.12403578f, 0.07372857f, 0.00853261f, 0.02458462f, 0.06070546f, 0.06873129f, -0.29182416f, 
    0.04394106f, 0.05888060f, -0.03715558f, -0.05979820f, -0.03082033f, 0.02181391f, -0.19400124f, 0.20481265f, 
    -0.00460646f, 0.19892858f, -0.04012479f, 0.30425167f, 0.08123438f, 0.07880206f, -0.25781775f, -0.09303144f, 
    -0.11302518f, 0.11403743f, 0.31220958f, 0.22338888f, 0.07879447f, 0.16977543f, -0.23423702f, -0.05926117f, 
    -0.16375998f, -0.01412019f, 0.00018438f, -0.09927984f, 0.04102454f, 0.08216660f, 0.11170258f, 0.26600614f, 
    -0.16814959f, 0.13797325f, 0.01785808f, 0.12122910f, 0.08023464f, 0.15792967f, 0.00593397f, 0.24471861f, 
    -0.05132703f, 0.00582957f, 0.02455917f, -0.14429618f, 0.07111830f, 0.07706185f, 0.06592811f, 0.28697851f, 
    -0.16579513f, -0.16194792f, 0.19301495f, 0.08061222f, -0.24664490f, -0.01971287f, -0.35533145f, -0.00135860f, 
    -0.11163348f, 0.00937192f, -0.11024863f, 0.30956727f, -0.05523869f, 0.05038123f, -0.05660864f, 0.25728321f, 
    -0.06421665f, -0.04375353f, 0.15303795f, -0.17265765f, 0.03068516f, 0.01064514f, 0.09359838f, 0.27485073f, 
    0.13170603f, 0.07804316f, -0.09256916f, 0.30207381f, -0.10670978f, -0.06793439f, -0.20075047f, -0.03892439f, 
    -0.16387422f, 0.02770419f, -0.06739839f, 0.03250713f, -0.19102848f, 0.36851555f, 0.04341716f, 0.38764101f, 
    -0.01259253f, 0.08745265f, 0.06048871f, 0.31320032f, -0.12730663f, -0.00461134f, 0.01819897f, -0.22513171f, 
    0.09053958f, 0.34484598f, -0.24559642f, -0.01791824f, -0.01169578f, -0.05616612f, 0.22761975f, -0.29468417f, 
    -0.14129503f, 0.03406120f, 0.14612809f, 0.12375232f, -0.11066650f, -0.07501725f, -0.07115223f, -0.24915448f, 
    0.05391710f, 0.15106326f, -0.20394620f, -0.09464087f, 0.02871856f, 0.14952722f, -0.04803384f, 0.30654526f, 
    -0.02308562f, 0.08263344f, -0.05035136f, 0.28168944f, -0.02735555f, 0.16988689f, -0.08631172f, -0.26255202f, 
    0.04378730f, -0.31286669f, 0.12188844f, 0.18140280f, -0.10079239f, 0.05564120f, -0.12407727f, 0.02092984f, 
    0.23872572f, -0.01040648f, -0.08416028f, -0.14735357f, -0.08874942f, 0.03718714f, 0.02340591f, -0.32024565f, 
    -0.28696653f, 0.10700297f, -0.34256354f, -0.10952872f, -0.00654685f, -0.35224062f, -0.08298868f, -0.30170411f, 
    0.07720114f, 0.31957728f, -0.04652675f, 0.20668359f, -0.11953776f, 0.14415638f, 0.18094979f, -0.28617585f, 
    -0.04793192f, 0.05323553f, -0.01730506f, -0.02381551f, 0.12579648f, 0.16635229f, -0.30444098f, -0.04014127f, 
    0.25582659f, 0.11726935f, 0.08098172f, -0.28077418f, -0.00587736f, 0.14775911f, 0.00193321f, -0.06970844f, 
    -0.16393560f, 0.12854291f, 0.19962704f, 0.23206775f, 0.16553509f, -0.08155388f, 0.25335121f, 0.33171842f, 
    -0.17222182f, -0.14780827f, -0.13729906f, 0.19176884f, 0.08415281f, 0.12328804f, -0.12776418f, -0.09662633f, 
    -0.10143729f, -0.21282718f, -0.10508095f, 0.29686338f, 0.06040587f, -0.07041006f, -0.29478830f, 0.00168892f, 
    0.24141578f, -0.17477512f, 0.02831833f, -0.06979065f, -0.09768689f, 0.05022252f, 0.12877737f, -0.21921092f, 
    0.17195942f, -0.06187954f, -0.29428965f, -0.26015225f, -0.25039861f, -0.19892408f, 0.07660706f, -0.13393447f, 
    -0.06046400f, -0.02542942f, -0.05800466f, -0.12802437f, -0.04987343f, 0.06506217f, -0.02478581f, 0.08637440f, 
    -0.09337074f, 0.15684770f, -0.08620328f, -0.21615162f, -0.02577707f, -0.00050278f, -0.19276495f, -0.15905981f, 
    0.07767913f, -0.18524183f, -0.13327299f, -0.07983522f, 0.06120459f, 0.08033082f, -0.00960956f, 0.10666860f, 
    -0.05303790f, 0.01611328f, -0.02763410f, -0.08831562f, 0.31055856f, 0.04536920f, 0.44750956f, 0.10884868f, 
    -0.04682964f, 0.17799515f, -0.05049641f, 0.07807535f, -0.01568333f, -0.13456984f, 0.18875757f, -0.18544634f, 
    -0.08743774f, -0.16241740f, 0.16395351f, -0.25040665f, -0.09001596f, 0.02120470f, 0.27630052f, 0.10377251f, 
    0.10201415f, 0.45150855f, 0.10411067f, -0.04247612f, -0.05739842f, -0.16962951f, -0.27946603f, 0.17016451f, 
    -0.17697068f, 0.11702989f, -0.07718242f, 0.31204221f, -0.16053498f, -0.15572494f, 0.34053442f, 0.29235852f, 
    0.08309868f, 0.29839554f, -0.08617987f, 0.14358500f, 0.05930940f, 0.11466669f, 0.13029125f, -0.00558500f, 
    0.12253492f, 0.09311941f, -0.06644377f, -0.10551404f, 0.09901586f, 0.14911787f, 0.42111111f, -0.01463483f, 
    -0.04009048f, 0.31073707f, -0.07134122f, -0.40613335f, -0.33376837f, 0.07790814f, -0.05202422f, 0.27775416f, 
    -0.22890416f, -0.05482887f, -0.05838104f, 0.01684051f, 0.38294494f, 0.06693292f, 0.00172010f, -0.39351526f, 
    0.12831636f, 0.00374723f, -0.13023521f, 0.21660905f, -0.01613973f, -0.11038976f, 0.17272052f, 0.28461450f, 
    -0.16292104f, -0.29604346f, 0.09978422f, -0.05751848f, -0.12101652f, -0.00420855f, 0.13628766f, 0.20555662f, 
    0.09323751f, 0.30637568f, -0.05043406f, 0.24880804f, 0.36879382f, -0.04366356f, -0.16996485f, -0.08011285f, 
    0.09503886f, 0.15295042f, 0.39396119f, 0.09776155f, 0.09438174f, 0.18526679f, -0.30600843f, -0.10121800f, 
    0.15495786f, 0.36925080f, -0.01177557f, -0.13481973f, 0.09054639f, 0.08073024f, 0.22083415f, 0.16950364f, 
    0.07846133f, -0.20204090f, 0.15279154f, -0.26158273f, -0.02070061f, 0.03557888f, 0.24047767f, -0.12530921f, 
    0.14388552f, 0.14486073f, -0.07168815f, 0.08010027f, 0.07688857f, -0.07349739f, 0.09607399f, -0.05319264f, 
    0.21209016f, 0.15810408f, -0.06165059f, -0.17258528f, -0.02036245f, 0.16063476f, 0.48443258f, -0.02023704f, 
    -0.13469467f, 0.04991718f, -0.14674076f, -0.05783155f, 0.03184426f, -0.07353295f, 0.02519973f, -0.04102710f, 
    -0.01187505f, 0.18089047f, 0.07271967f, 0.18806283f, -0.06386657f, 0.06152160f, 0.30841866f, 0.00897876f, 
    -0.22577977f, 0.28051096f, 0.29207337f, -0.08962343f, -0.00209510f, -0.20516823f, -0.09400467f, 0.09739680f, 
    -0.17997590f, 0.12869076f, 0.10284159f, -0.08189156f, 0.06952152f, -0.05487182f, -0.15169725f, 0.16896293f, 
    -0.07797390f, 0.08700459f, 0.06163344f, -0.02304124f, -0.12015153f, -0.14330496f, 0.06704958f, -0.08186489f, 
    -0.16632529f, -0.19139311f, 0.04598984f, -0.13141733f, 0.12386543f, 0.11558868f, 0.08090081f, -0.11139476f, 
    -0.04247866f, -0.07425803f, 0.02779056f, 0.00634637f, -0.14541665f, -0.19931197f, -0.00965670f, 0.09765755f, 
    -0.17715077f, -0.08117626f, -0.00232649f, 0.04871026f, 0.05604796f, -0.15678416f, -0.12498936f, 0.03594529f, 
    0.13940144f, 0.03538808f, -0.11367286f, -0.12406304f, -0.11616514f, 0.15396966f, 0.11079220f, -0.08900966f, 
    0.03442488f, -0.13700783f, -0.00415082f, -0.02041326f, 0.06502749f, 0.15963380f, -0.13367504f, 0.07015778f, 
    0.06867412f, 0.01116933f, -0.09477141f, 0.03710775f, -0.14706582f, -0.21378197f, -0.12372337f, -0.18349516f, 
    0.29759252f, 0.02996856f, -0.13158552f, 0.18803304f, -0.18103522f, 0.35985306f, -0.03632477f, 0.45606154f, 
    0.13129079f, 0.21530151f, 0.07682705f, -0.25511733f, 0.14222576f, 0.06064832f, -0.13605784f, 0.32009077f, 
    0.00644237f, -0.02383623f, -0.01634839f, 0.08681576f, 0.05170969f, 0.17636319f, 0.17378010f, 0.18296678f, 
    0.22727604f, 0.05351382f, -0.18703796f, 0.03542819f, -0.11794042f, -0.31968495f, -0.05379417f, 0.21224804f, 
    -0.17960939f, -0.09376065f, 0.03045155f, -0.09726709f, 0.07868888f, -0.13597105f, -0.21310829f, 0.13364579f, 
    -0.01431612f, 0.06989237f, 0.04102921f, -0.26699615f, -0.10816644f, 0.11211669f, -0.14204447f, 0.13874991f, 
    0.07399900f, -0.00883749f, -0.22108366f, -0.19367935f, 0.07153515f, -0.03894437f, 0.11870585f, 0.13153824f, 
    -0.00625120f, -0.05247548f, 0.03745759f, 0.02335059f, -0.07659518f, -0.06704155f, -0.08283924f, 0.02186316f, 
    0.11170599f, 0.14534076f, -0.17108800f, -0.34647453f, 0.16533569f, -0.03550117f, 0.05079399f, -0.28003678f, 
    -0.15495236f, -0.25605446f, 0.03055537f, 0.11255897f, 0.16200151f, 0.03610491f, 0.08904732f, 0.22941490f, 
    0.01762491f, 0.03572721f, -0.24239221f, 0.07213000f, -0.14633682f, 0.03690664f, -0.23376898f, -0.13218127f, 
    0.21027814f, 0.06464875f, -0.00952791f, 0.40564221f, 0.27899081f, 0.22625083f, -0.04017932f, 0.09144790f, 
    0.28968808f, 0.16353677f, 0.20757060f, -0.02294859f, -0.23458971f, -0.08371295f, -0.02548088f, 0.16706520f, 
    0.01682533f, -0.07742289f, -0.08740817f, -0.27529794f, -0.13714379f, -0.07571555f, -0.21802801f, 0.16578521f, 
    -0.17895424f, -0.17498553f, 0.07486004f, 0.34968635f, -0.04995942f, -0.00373496f, -0.14577538f, 0.19315322f, 
    0.24762087f, -0.11455276f, -0.19078130f, 0.13769536f, 0.30205604f, 0.01638170f, -0.01406317f, 0.10843078f, 
    -0.07313345f, -0.03690280f, -0.00445928f, -0.19364108f, 0.23129097f, -0.17986672f, 0.47324726f, -0.02967552f, 
    -0.03139523f, 0.02227327f, -0.08962653f, -0.03509251f, -0.03877028f, -0.08233056f, -0.12058180f, -0.10896087f, 
    -0.02665572f, 0.07148083f, 0.09910509f, -0.10636406f, 0.06127517f, -0.02861400f, 0.10523161f, 0.20543961f, 
    0.04426926f, 0.37059233f, 0.13008329f, 0.47925538f, 0.09369051f, -0.18944563f, -0.14394456f, -0.07112146f, 
    0.16333415f, -0.03346842f, -0.11044825f, -0.09458448f, 0.07155798f, 0.34167495f, -0.36738843f, 0.24006703f, 
    -0.06604709f, 0.05747104f, 0.05573823f, -0.05726070f, 0.13722511f, 0.13484089f, 0.07191487f, 0.08404113f, 
    -0.02787217f, 0.40975973f, -0.22954521f, 0.42923206f, 0.01338844f, -0.01153043f, 0.06633644f, 0.07385159f, 
    -0.13441615f, 0.03477516f, 0.19893987f, 0.09393093f, -0.07016601f, -0.04772510f, 0.16196400f, 0.20226391f, 
    0.17199445f, 0.10027169f, 0.19864306f, 0.24330024f, -0.23867019f, 0.33500895f, 0.06945121f, 0.47356150f, 
    0.16064945f, -0.03241985f, 0.11957989f, -0.09006706f, -0.04001814f, 0.17062943f, -0.33084914f, -0.02418208f, 
    -0.11522698f, -0.15674151f, 0.17334597f, 0.07892478f, 0.16653711f, 0.09187777f, 0.10601211f, 0.14520003f, 
    0.16575406f, 0.09387531f, -0.04684458f, -0.38622785f, -0.21566239f, -0.18920632f, 0.25453424f, 0.12087354f, 
    0.00765799f, -0.04527203f, -0.04877676f, 0.11138620f, -0.10091684f, -0.05481570f, -0.30744180f, 0.17958061f, 
    -0.08542239f, 0.00298901f, 0.01833175f, 0.20424211f, 0.01332177f, -0.05499392f, -0.20815897f, -0.14605024f, 
    0.02316391f, 0.21834970f, -0.23291124f, 0.10915569f, -0.14230114f, -0.17394188f, 0.09399438f, -0.29133761f, 
    -0.07634560f, -0.21165584f, 0.21478045f, 0.11666465f, -0.20527001f, 0.12928565f, -0.04285430f, 0.04381801f, 
    -0.16229717f, 0.06074864f, -0.07309635f, 0.08245713f, 0.13489930f, 0.09715279f, -0.15739758f, -0.04977883f, 
    0.05788272f, 0.12818436f, -0.01691930f, 0.24169271f, -0.14287363f, 0.16047359f, -0.01429908f, -0.09036434f, 
    0.05474655f, 0.02458190f, 0.10424166f, 0.14608601f, 0.15251464f, 0.09321450f, -0.08481659f, -0.10760533f, 
    0.14888312f, -0.11180346f, 0.39309138f, -0.23699725f, 0.25754124f, 0.26840860f, 0.39652401f, 0.07143134f, 
    -0.00044962f, 0.09039415f, 0.01721124f, -0.30016589f, 0.25761232f, 0.14686124f, -0.13699786f, -0.14169002f, 
    0.03188948f, -0.00442191f, -0.03711329f, 0.16619764f, -0.03323969f, -0.02270932f, 0.09738726f, 0.24638626f, 
    0.02892776f, 0.05451442f, 0.00792298f, -0.36120448f, 0.04552643f, -0.05461732f, 0.13767479f, -0.18008548f, 
    0.16218600f, 0.16687392f, -0.01894030f, 0.16571775f, 0.26802716f, -0.18764631f, -0.16260031f, -0.18494943f, 
    -0.21920559f, 0.08668353f, -0.10786550f, -0.15528370f, 0.12438199f, -0.06377733f, -0.20334493f, -0.16623968f, 
    -0.16209099f, -0.17609608f, 0.06188953f, 0.01961245f, -0.02737963f, -0.16483213f, -0.05154527f, -0.07792247f, 
    -0.04623242f, -0.11982520f, -0.12664461f, -0.16990386f, -0.09981265f, -0.08249538f, -0.03020864f, -0.01374628f, 
    -0.10616294f, -0.03520532f, 0.05637941f, 0.06454326f, 0.08801665f, -0.03539572f, -0.14450605f, -0.07744391f, 
    0.19652124f, -0.08179112f, 0.19955437f, -0.33409774f, -0.31539893f, -0.27836239f, 0.01446344f, -0.15961593f, 
    0.13263865f, 0.29696590f, 0.01682866f, -0.00630799f, -0.01404039f, 0.06789508f, -0.35383451f, -0.12418449f, 
    0.06617060f, 0.09135365f, 0.30032083f, 0.33382353f, -0.15195212f, 0.06396709f, -0.38210285f, 0.05103211f, 
    0.16805398f, 0.20061332f, -0.12040401f, -0.13349913f, 0.14166971f, 0.19947368f, 0.02057611f, -0.23555183f, 
    -0.22545107f, -0.04202171f, 0.22857234f, 0.19837962f, 0.21220472f, -0.37538716f, 0.07998741f, -0.15369776f, 
    -0.03829107f, 0.26795670f, 0.17335866f, 0.22896671f, -0.06359848f, -0.03387896f, -0.29582414f, -0.20257758f, 
    -0.01180720f, -0.27873337f, 0.32994220f, 0.07587695f, 0.11603385f, -0.01839938f, -0.19333714f, -0.03628451f, 
    0.07645543f, 0.04500129f, 0.13166279f, -0.11885506f, 0.21968693f, 0.22393538f, 0.22481395f, -0.27154228f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.01426115f, 0.25348151f, 0.21725973f, -0.17838301f, -0.08543766f, 0.23720929f, 0.04228022f, 0.25444952f, 
    0.03575257f, 0.22039686f, 0.06220890f, 0.00270696f, -0.14281712f, -0.04787453f, -0.03725366f, 0.13429712f, 
    -0.01547994f, -0.07670987f, -0.05119929f, 0.00287848f, -0.07063919f, 0.03853932f, -0.12034012f, -0.15417191f, 
    0.16832756f, 0.16993019f, -0.05585993f, 0.26390857f, -0.00291790f, 0.00292622f, 0.08592390f, -0.07354110f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.06996195f, -0.11498848f, -0.14541037f, 0.25613451f, 0.30975482f, -0.04597437f, 0.25946882f, -0.35848495f, 
    -0.20854494f, -0.22871354f, -0.38001758f, 0.00835836f, 0.17591798f, 0.11948838f, -0.02081443f, 0.07708492f, 
    -0.06292643f, -0.15035115f, -0.01428998f, 0.17302583f, 0.23676565f, -0.17734003f, 0.17365085f, 0.09248211f, 
    0.04494467f, 0.05931908f, 0.14177333f, -0.50842041f, -0.32082745f, 0.10457678f, 0.12744851f, -0.43861112f, 
    0.06947286f, -0.38040292f, 0.21921898f, -0.13597625f, 0.12109680f, -0.09221324f, -0.17083073f, 0.21556316f, 
    -0.00765383f, 0.09803508f, -0.41094065f, 0.10493767f, 0.20175084f, -0.16392022f, 0.23417048f, 0.15057950f, 
    0.14244030f, -0.08938628f, -0.20349482f, 0.00874259f, -0.07079548f, 0.31500420f, 0.18558694f, 0.04254621f, 
    -0.00616424f, -0.32819748f, -0.04101729f, -0.03737016f, 0.21155794f, -0.03368589f, -0.46905214f, -0.28910440f, 
    -0.00080995f, 0.23714095f, 0.29559216f, 0.00252775f, -0.05369698f, 0.23411344f, -0.22095610f, -0.57275683f, 
    -0.41519371f, -0.03280252f, -0.03878417f, -0.09028560f, -0.39101794f, -0.44515222f, 0.12135308f, -0.12839149f, 
    0.06114883f, -0.11237811f, -0.20045225f, -0.56416649f, -0.13283290f, 0.32844836f, 0.14181478f, 0.03702417f, 
    0.16142373f, -0.38151169f, -0.13545567f, -0.01442251f, -0.15878735f, -0.07290559f, 0.29581115f, 0.10617845f, 
    -0.10941223f, -0.26855579f, 0.04288788f, -0.61253387f, 0.27644753f, -0.08772523f, -0.20276785f, -0.24138871f, 
    0.23270333f, -0.56292921f, 0.02256597f, -0.23661327f, -0.06772380f, -0.32709929f, -0.19451283f, 0.10900079f, 
    0.06713825f, 0.12890360f, 0.06436257f, -0.13557562f, -0.10897009f, -0.16941789f, 0.17614979f, 0.03654977f, 
    -0.11290968f, 0.15407585f, -0.39586461f, -0.02519206f, -0.21545953f, 0.02256623f, 0.37755951f, 0.36184806f, 
    0.01755660f, -0.45623273f, -0.11978533f, 0.07593536f, -0.10458266f, 0.24549076f, -0.09273823f, 0.03483099f, 
    -0.51664186f, -0.20117004f, 0.12310211f, -0.19359630f, -0.31389505f, 0.12920518f, -0.15123418f, 0.14452711f, 
    -0.07981191f, 0.10334880f, -0.09321445f, 0.04177851f, -0.09936208f, -0.10427246f, 0.23382266f, -0.52423799f, 
    0.08184947f, 0.22260393f, -0.28358355f, 0.05290388f, -0.20403960f, -0.11098953f, -0.09095585f, 0.00261120f, 
    0.10462230f, -0.02813499f, 0.25031713f, -0.10271016f, -0.19036157f, 0.15907568f, -0.32749593f, -0.30884871f, 
    -0.18137673f, 0.01016826f, -0.40470877f, 0.14131683f, 0.22895789f, 0.39438185f, -0.06656659f, 0.15187471f, 
    0.24425751f, -0.12036560f, 0.00029760f, -0.10312302f, -0.24301857f, -0.31924465f, -0.17854713f, -0.08369624f, 
    0.13662325f, 0.14583038f, -0.24192873f, 0.03421438f, -0.19222319f, -0.02569362f, -0.29228279f, 0.02645268f, 
    -0.13488089f, 0.20801596f, -0.13731617f, -0.06112521f, -0.49703133f, -0.24577808f, -0.02198308f, 0.08014904f, 
    0.11724744f, 0.41361311f, -0.02560078f, -0.16958712f, -0.34914473f, -0.01616215f, -0.23344098f, -0.22102900f, 
    -0.19502336f, 0.02734329f, -0.12417426f, -0.63385105f, 0.08950372f, 0.21284761f, -0.54358739f, -0.28127012f, 
    0.14738412f, -0.44976199f, 0.13226700f, 0.21998855f, -0.07379580f, 0.05025519f, 0.11545591f, 0.09211209f, 
    0.08366660f, 0.05876121f, -0.10112915f, -0.16026358f, 0.11216078f, -0.19700103f, -0.53249013f, 0.32203290f, 
    0.11231178f, -0.50046647f, 0.22369009f, -0.36171481f, 0.08084188f, 0.18497165f, -0.40807819f, -0.04352032f, 
    0.26433492f, -0.14627317f, -0.16565214f, 0.08442672f, 0.15474945f, -0.14764439f, -0.35225922f, 0.15313350f, 
    0.20581807f, 0.00992764f, 0.09585257f, -0.15309936f, -0.21207815f, 0.03554517f, -0.29464829f, -0.38340339f, 
    -0.25690478f, 0.06967859f, 0.21908160f, -0.13683636f, 0.14556067f, -0.07546895f, -0.48580027f, -0.23508945f, 
    -0.40512809f, 0.15758248f, 0.07793263f, 0.04533851f, 0.26169384f, 0.34495535f, 0.06546161f, -0.42321655f, 
    0.20788313f, -0.03484696f, 0.01369704f, -0.63984251f, 0.01287484f, 0.03520624f, -0.48348710f, 0.34150851f, 
    -0.40962163f, -0.43189469f, -0.27028316f, -0.00204752f, -0.22761515f, -0.09360877f, -0.28987888f, 0.07535202f, 
    -0.51450467f, 0.31369054f, -0.20233727f, -0.62408209f, -0.04519210f, 0.07065746f, -0.14965390f, 0.00830309f, 
    0.03725454f, -0.45335293f, 0.15973452f, -0.23886327f, -0.56870586f, -0.39513832f, -0.26575288f, -0.33397201f, 
    0.02847756f, 0.06179354f, 0.09364392f, -0.08525597f, 0.02097595f, 0.10175441f, -0.05343907f, -0.51843733f, 
    0.27349749f, 0.34623885f, 0.00673321f, 0.17474751f, -0.19699267f, -0.15799865f, -0.27927655f, -0.15490852f, 
    -0.05327031f, -0.06866035f, 0.04650458f, -0.06242123f, -0.38793594f, 0.20319316f, 0.42385697f, -0.29297253f, 
    -0.26287284f, -0.23470046f, 0.14676414f, -0.17516887f, 0.08434401f, 0.00379286f, 0.29079494f, 0.25954419f, 
    -0.42137989f, -0.01446957f, 0.15851934f, -0.40770534f, -0.00726520f, -0.24807529f, -0.17490804f, 0.24530573f, 
    -0.50699955f, 0.01762132f, -0.05213089f, -0.11501359f, 0.22113231f, 0.08320589f, -0.31231716f, 0.39039701f, 
    -0.35080951f, -0.17166607f, -0.50576937f, -0.12894005f, -0.09317935f, -0.30238345f, -0.36082566f, -0.23058394f, 
    0.43865505f, 0.27210322f, 0.23689072f, -0.11140648f, 0.14992636f, 0.17744133f, 0.29143843f, -0.00238594f, 
    -0.10311313f, -0.07045097f, -0.06628618f, -0.15625678f, 0.03756005f, 0.07780042f, 0.09900553f, -0.24287309f, 
    -0.34695280f, -0.01522324f, -0.31578588f, 0.17482190f, -0.07496104f, 0.05812876f, -0.22097887f, 0.24890813f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.20602585f, -0.10246419f, 0.21576922f, -0.02545657f, 0.14954928f, -0.00613608f, -0.00001325f, -0.14536962f, 
    -0.08218908f, 0.23379169f, 0.01397981f, -0.00689852f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
