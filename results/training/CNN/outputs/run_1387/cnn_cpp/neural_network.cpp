#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.19159812f, -0.70465064f, -0.09127584f, -0.31594080f, -0.41091791f, 0.61997598f, 0.30588216f, -0.35981789f, 
    -0.08150463f, 0.46357411f, 0.06766260f, 0.07597014f, 0.06997468f, -0.15890048f, 0.11650559f, -0.04647568f, 
    0.08594898f, -0.04250109f, -0.39234325f, 0.13453443f, 0.09821529f, -0.29253820f, 0.20923194f, 0.22503002f, 
    -0.12768051f, 0.19799097f, 0.34862968f, 0.28461862f, -0.23756093f, 0.06970537f, 0.10110371f, 0.24598908f, 
    0.05297808f, -0.07744943f, 0.23682688f, 0.28400680f, 0.00913986f, -0.17190780f, -0.31177384f, -0.05014687f, 
    -0.02599213f, -0.27799228f, -0.19486190f, 0.02977375f, 0.06813069f, 0.23072377f, 0.33299136f, 0.06245334f, 
    -0.32036301f, -0.25338623f, 0.07143286f, -0.34593400f, -0.68153334f, -0.71763891f, -0.15265940f, 0.44079730f, 
    0.14863719f, -0.04633963f, 0.39709234f, 0.02158853f, 0.24636219f, 0.01217290f, 0.16967219f, -0.04135405f, 
    -0.25881091f, -0.25199279f, -0.02582649f, -0.31415877f, -0.24743451f, -0.09595347f, -0.31164631f, -0.22949505f, 
    0.01833040f, -0.22497702f, -0.24298880f, 0.58907062f, 0.60058886f, 0.06706508f, -0.27582723f, -0.30854252f, 
    -0.20883100f, -0.30301017f, -0.10498779f, -0.17895764f, 0.35681310f, -0.03594983f, -0.09571461f, 0.13790414f, 
    -0.14545873f, -0.33759645f, -0.06644877f, 0.13498387f, 0.14806704f, 0.29312405f, -0.21222204f, 0.03753810f, 
    -0.10796914f, -0.05527888f, -0.19426452f, -0.06256689f, -0.43866754f, 0.45178217f, 0.20035537f, 0.52711624f, 
    0.26498416f, -0.38308114f, -0.54483563f, 0.34329909f, -0.37711200f, -0.14740807f, 0.05131044f, 0.17986026f, 
    -0.06976701f, -0.16298202f, 0.10217781f, -0.10909888f, 0.14208244f, -0.16931646f, -0.26918730f, 0.20758554f, 
    -0.14904127f, -0.18554351f, 0.08454432f, 0.16139862f, -0.09606036f, 0.19207889f, 0.19937307f, 0.28773537f, 
    0.26358712f, 0.12382539f, 0.02015236f, -0.04046246f, 0.17675006f, 0.26864922f, 0.26409376f, 0.24001692f, 
    0.10840692f, -0.01695702f, 0.05573321f, -0.10960128f, 0.01948334f, -0.10302451f, 0.12908770f, -0.00693812f, 
    -0.18760972f, 0.04180045f, 0.11251533f, -0.04305453f, 0.08466252f, -0.00703052f, -0.35847691f, -0.56615072f, 
    0.73568499f, -0.31957984f, 0.13051108f, -0.43019706f, -0.39641431f, -0.18568957f, -0.22209145f, -0.41089177f, 
    -0.05438640f, -0.07824933f, -0.31750607f, -0.17233999f, -0.20750596f, -0.38449275f, -0.04044645f, -0.05644805f, 
    -0.18048725f, -0.32291216f, 0.21008120f, -0.16618389f, -0.02687694f, -0.46109074f, 0.24052104f, -1.26244307f, 
    -0.06331755f, -0.55424249f, 0.16996589f, 0.10229709f, -0.39900136f, 0.13605557f, 0.17452744f, 0.64858252f, 
    -0.08082493f, 0.16929410f, 0.13758457f, 0.13685510f, 0.35884956f, -0.14850408f, 0.00778339f, -0.15985103f, 
    -0.11653986f, -0.40065980f, -0.04325880f, 0.22395068f, 0.03411679f, 0.25673175f, -0.10435736f, 0.05119109f, 
    -0.15977198f, 0.15613340f, 0.39631188f, -0.16075803f, -0.39256686f, -0.46479335f, -0.33288541f, 0.26046693f, 
    0.02789516f, 0.05461205f, 0.43252671f, -0.35002246f, -0.19626799f, 0.55156505f, -0.46141830f, -0.03485110f, 
    -0.06063211f, -0.14426088f, 0.29084820f, -0.14777237f, -0.00957862f, -0.03594949f, -0.17483489f, -0.08896533f, 
    0.30081666f, 0.75662231f, 0.68128312f, -0.53024119f, -0.75397575f, -0.83293188f, -0.56554973f, 0.26188642f, 
    0.16012672f, 0.20566142f, 0.11842658f, 0.13847411f, 0.20497397f, 0.18816927f, -0.04210967f, -0.11475207f, 
    0.14617133f, -0.38167405f, 0.21123172f, -0.09603351f, -0.00453380f, -0.08416105f, 0.01516483f, -0.09185879f, 
    -0.30666396f, 0.28361043f, -0.34895051f, -0.31806505f, -0.60520500f, -0.32575133f, -0.92354655f, 0.05892235f, 
    -0.06377566f, 0.29481795f, 0.31754515f, 0.49037451f, -0.18977478f, 0.11021928f, -0.45051727f, -0.14360930f, 
    -0.30523679f, -0.01220003f, 0.23410298f, 0.19951722f, 0.07586240f, -0.05407332f, 0.18945785f, -0.01940863f, 
    -0.04547113f, 0.03849611f, 0.30356398f, -0.79479098f, -0.54991829f, -0.63701981f, -0.77137607f, -0.53699315f, 
    0.19392112f, 0.15910706f, -0.09478976f, -0.49622503f, -0.11926085f, -0.33738431f, -0.38610372f, -0.25828221f, 
    -0.01157544f, -0.01793675f, 0.13532896f, -0.07230174f, -0.13041137f, -0.14689732f, -0.17221004f, -0.28694713f, 
    0.07008187f, -0.11432721f, 0.04583473f, -0.05663810f, 0.26998097f, -0.47152567f, -0.23493446f, 0.15440422f, 
    -0.28069934f, 0.51379669f, -0.48185232f, -0.25678307f, -0.07550869f, -0.00213725f, -0.23687835f, 0.30791619f, 
    -0.28592449f, 0.03085567f, -0.14727320f, -0.14947633f, 0.29246965f, 0.20163952f, 0.13032426f, 0.11898141f, 
    -0.04021778f, 0.03137855f, -0.07974625f, -0.20364448f, 0.01850353f, -0.04962809f, 0.10860340f, 0.13645586f, 
    0.10357467f, -0.26938948f, -0.38593605f, -0.42057899f, 0.03070693f, 0.34915417f, 0.33220488f, 0.29607281f, 
    -0.34063542f, -0.18536225f, 0.14966024f, 0.15680668f, -0.41675475f, 0.19839981f, 0.03994582f, -0.05278888f, 
    0.19703451f, -0.25415835f, 0.53708571f, 0.17638992f, -0.19836870f, -0.34714428f, -0.98648930f, -0.34123832f, 
    0.01516579f, 0.41852275f, 0.69755602f, 0.13213092f, 0.15930763f, -0.14850560f, -0.22266372f, 0.29977950f, 
    0.47806042f, -0.14575440f, 0.00352840f, -0.26628599f, -0.43027630f, 0.07638538f, 0.28964794f, -0.07273507f, 
    -0.07500508f, 0.18220600f, 0.03767546f, 0.02236411f, 0.11958689f, -0.06285222f, -0.17453213f, 0.95948386f, 
    0.43732402f, -0.74910712f, -0.41582465f, -0.59409857f, -0.21808887f, 0.13887446f, 0.02835158f, -0.10242627f, 
    0.26808086f, -0.22607712f, 0.14206994f, -0.23742291f, -0.32659355f, 0.20059049f, 0.28448755f, -0.13667515f, 
    -0.32715210f, -0.13844864f, -0.19083962f, -0.48591003f, -0.52719492f, -0.38451174f, -0.34548241f, -0.65274674f, 
    0.01448264f, -1.04177380f, 0.16051616f, 0.42920685f, 0.16949567f, -0.44442576f, -0.55367070f, -0.51187712f, 
    -0.32407790f, 0.40582809f, 0.17435414f, -0.03383754f, 0.15911867f, -0.35571551f, 0.46199721f, -0.01177085f, 
    0.10671790f, -0.27812418f, 0.07603557f, -0.13083772f, 0.21786416f, -0.31189713f, -0.28888381f, 0.01774646f, 
    0.39270440f, 0.57482982f, -0.07291777f, -0.27586630f, -0.32871249f, 0.26313105f, 0.36887854f, 0.63227081f, 
    -0.52992004f, -0.71650815f, -0.40356410f, -0.27621639f, -0.02952294f, 0.08245987f, -0.21092544f, -0.19680364f, 
    -0.26756147f, -0.02376977f, 0.06576245f, 0.19163105f, -0.13950469f, -0.14226475f, 0.06157490f, -0.02390954f, 
    0.04780589f, -0.15410759f, 0.58553439f, 0.26611146f, 0.06984229f, -0.13768931f, -0.00474472f, 0.18102594f, 
    0.04539284f, 0.35596734f, -0.30319846f, -0.39502481f, -0.22060318f, 0.06392393f, -0.09805550f, 0.05869649f, 
    0.18115644f, -0.19091044f, -0.11297419f, -0.18267211f, -0.14614224f, 0.06086155f, 0.12159958f, 0.04339223f, 
    0.13422938f, -0.37582234f, -0.16507313f, -0.45148528f, -0.72671646f, -0.23405516f, -0.27353823f, -0.08369350f, 
    -0.23404448f, -0.27764058f, 0.18987975f, 0.13456501f, -0.05419500f, -0.25866172f, -0.21970470f, -0.06161963f, 
    0.32751408f, -0.53847975f, 0.27960089f, -0.40757751f, -0.05258571f, 0.11443748f, 0.00975690f, 0.17798842f, 
    -0.11958929f, -0.37064826f, -0.02925186f, -0.11988994f, 0.24004726f, -0.20505236f, 0.27951366f, -0.24635789f, 
    -0.16948719f, -0.36041960f, 0.15034820f, 0.26776451f, -0.09751413f, 0.07951386f, -0.17555857f, -0.28840432f, 
    0.05355414f, 0.08257232f, 0.00313797f, 0.10128041f, -0.41253066f, -0.13878728f, 0.37717324f, -0.11535683f, 
    -0.05702358f, -0.29930416f, 0.08706297f, 0.13776958f, 0.16509919f, -0.56409353f, -0.12613121f, -0.11331579f, 
    -0.56812090f, -0.51331896f, 0.25774592f, 0.20571373f, 0.24462911f, 0.25658238f, 0.46387416f, -0.27250770f, 
    0.12207305f, 0.08266185f, -0.24442790f, -0.08874545f, 0.17595141f, -0.10657921f, 0.10689504f, 0.22362320f, 
    0.18878715f, 0.08755261f, 0.01406263f, 0.07015292f, -0.16872638f, -0.25116372f, 0.41022497f, 0.01088250f, 
    -0.02214385f, 0.25114581f, -0.32612756f, -0.06184495f, -0.32255691f, 0.07546025f, -0.21109501f, -0.35630387f, 
    0.10963535f, 0.05792511f, 0.08776695f, 0.11011192f, 0.19122818f, 0.10813979f, 0.07369768f, -0.18204397f, 
    -0.16041054f, 0.05759931f, -0.17996021f, 0.09328260f, 0.23822196f, 0.03342433f, 0.25605851f, 0.72085947f, 
    0.43764085f, 0.15502158f, -0.10165603f, -0.40967557f, -0.20409560f, -0.01245188f, 0.45560461f, 0.13052204f, 
    -0.16180225f, -0.10901115f, -0.00790518f, -0.08718319f, 0.02176292f, -0.44216004f, 0.05001268f, 0.07488585f, 
    -0.23252226f, -0.24599493f, -0.00283893f, 0.22406977f, 0.05197743f, 0.08897451f, -0.25918514f, -0.04736724f, 
    -0.53615713f, -0.43049675f, 0.01367582f, 0.01094007f, 0.57335693f, -0.04671605f, -0.42436722f, -0.67376369f, 
    -0.41605753f, 0.44431847f, 0.10549329f, -0.07584476f, -0.13816105f, 0.34137437f, -0.51103783f, -0.23593144f, 
    -0.35763136f, -0.40915170f, -0.39195693f, -0.13457845f, -0.34107572f, 0.20538813f, -0.33503655f, -0.35124969f, 
    -0.47240904f, 0.12963477f, -0.18873225f, 0.03863746f, 0.20817600f, 0.23019978f, -0.35063431f, -0.07305805f, 
    0.51014858f, -0.37095943f, -0.14516166f, 0.11369018f, -0.28265113f, -0.24067999f, 0.07398212f, -0.16391559f, 
    0.11282598f, 0.45768881f, -0.15817429f, 0.15383616f, 0.25805724f, -0.26880628f, -0.40849891f, -0.20610850f, 
    0.11837904f, -0.04808940f, -1.04093802f, -0.01124822f, 0.38586241f, -0.14416659f, -0.40386298f, 0.10967527f, 
    -0.10550889f, -0.13309589f, 0.50062668f, 0.70704204f, -0.29922438f, -0.06156068f, 0.02871683f, 0.08501955f, 
    -0.06376746f, 0.09366047f, -0.28010809f, -0.26913023f, 0.05025993f, 0.09127520f, 0.00099017f, 0.15771043f, 
    0.16825682f, -0.07383516f, 0.40264758f, 0.14672647f, 0.23295960f, 0.18391581f, 0.11929926f, -0.24899098f, 
    -0.25179014f, 0.29018262f, 0.45329407f, 0.09613905f, -0.28226691f, -0.22530186f, -0.24639365f, -0.08553275f, 
    0.01664013f, 0.11954266f, 0.06913693f, 0.24318150f, 0.12663880f, -0.21975887f, 0.03080479f, -0.05044965f, 
    -0.11415305f, -0.52408201f, 0.26347244f, 0.18095928f, 0.02154997f, -0.51592571f, -0.23605983f, 0.18760714f, 
    0.59023541f, -0.10083102f, 0.62561512f, 0.39105973f, -0.16651040f, -0.39140007f, -0.29320452f, 0.00933690f, 
    0.11343934f, -0.08568501f, -0.08723359f, -0.11606485f, -0.14332552f, 0.06338403f, 0.07172849f, -0.11941160f, 
    0.06410985f, 0.16838808f, -0.13380648f, -0.22767618f, 0.20357399f, 0.30343476f, -0.13117306f, -0.14261326f, 
    -0.06638146f, 0.14333974f, -0.52834064f, -0.33695859f, 0.24070403f, 0.17649986f, 0.24369442f, -0.19315416f, 
    -0.28189349f, -0.07344668f, -0.08583316f, -0.13799584f, -0.10588911f, 0.10267735f, 0.19265728f, -0.11482677f, 
    -0.01601965f, 0.13467816f, -0.20043570f, -0.17363362f, 0.30936280f, 0.32752085f, -0.56131339f, -0.41347480f, 
    -0.42164540f, 0.46694949f, 0.59818619f, -0.32342857f, -0.05398487f, 0.15070499f, 0.62394190f, 0.56424999f, 
    -0.19897182f, -0.06284849f, -0.33515918f, 0.17493419f, -0.01115783f, 0.13270937f, -0.11660886f, 0.31140789f, 
    -0.15581426f, -0.13930547f, 0.11579158f, -0.11362284f, -0.13817237f, 0.19576289f, -0.23028603f, -1.15875995f, 
    -0.26236850f, -0.62696582f, -0.38992208f, 0.30414221f, 0.24676248f, 0.05182057f, 0.05285898f, 0.39408064f, 
    0.42384389f, 0.02270102f, -0.05898936f, -0.07198182f, -0.04126766f, 0.12180177f, 0.17827143f, 0.01031978f, 
    -0.15020272f, 0.19641045f, -0.28916454f, -0.11865003f, -0.15894923f, -0.20480667f, -0.21463633f, -0.06889317f, 
    -0.78019989f, -0.43194294f, 0.21107046f, 0.24782877f, 0.40913022f, 0.43394423f, 0.33855966f, -0.21272412f, 
    -0.14977567f, -0.16128454f, 0.09762505f, 0.19183932f, 0.18408135f, -0.19509692f, 0.09529428f, -0.35466427f, 
    0.14976928f, -0.18289582f, -0.18896812f, -0.26602218f, 0.27776447f, 0.13428770f, 0.04298932f, 0.18784507f, 
    0.17297816f, 0.35447297f, 0.35804152f, 0.03975967f, -0.00573663f, -0.42121705f, 0.00685060f, 0.09110118f, 
    -0.08838984f, -0.00297763f, 0.13492088f, 0.15665913f, 0.04078325f, -0.07569744f, 0.41496423f, -0.21221833f, 
    0.00348799f, 0.00675046f, -0.04601166f, -0.00595928f, -0.23090339f, 0.24602488f, 0.12267445f, -0.04520700f, 
    -0.10098749f, -0.08003064f, 0.72879714f, 0.59036326f, -0.28742108f, -0.02242890f, -0.35433936f, -0.39103842f, 
    0.03849558f, 0.19372004f, -0.09374376f, -0.00251385f, 0.22161089f, 0.00429161f, 0.32414210f, -0.26541892f, 
    -0.46790594f, 0.10780199f, 0.12447675f, 0.09829704f, 0.06380304f, -0.33120781f, -0.09173875f, 0.12184056f, 
    -0.19464432f, 0.05835433f, 0.24097462f, -0.42279267f, 0.59371275f, 0.39093181f, -0.52246428f, 0.33004126f, 
    -0.48808572f, -0.21348897f, 0.19790827f, 0.00032726f, -0.19111408f, -0.23967594f, -0.15481992f, 0.44781289f, 
    -0.30078706f, -0.04978853f, 0.23232207f, -0.23137262f, -0.07881083f, -0.26881450f, 0.11268760f, -0.24820505f, 
    0.06792258f, -0.13430175f, 0.00421571f, -0.41794723f, -0.67070287f, -0.47313040f, -0.08067760f, -0.65653068f, 
    -0.63067919f, 0.27151537f, -0.04041781f, -0.46328974f, -0.15516394f, -0.00013846f, -0.01585908f, -0.16983944f, 
    -0.15795611f, 0.09985575f, -0.02378535f, -0.10326965f, -0.32961476f, -0.26188630f, -0.42720973f, -0.24058917f, 
    0.02655921f, 0.46809351f, 0.16781870f, 0.24597141f, 0.02503283f, 0.35008514f, 0.56902695f, 0.43807945f, 
    0.09618601f, -0.12131122f, -0.44506806f, -0.44694918f, -0.26123706f, -0.10543481f, -0.37197110f, -0.01587248f, 
    -0.22136837f, -0.21208733f, 0.10460537f, 0.39931545f, 0.34148088f, 0.11718389f, 0.24298868f, -0.04072945f, 
    -0.11069896f, -0.16491899f, 0.18115880f, -0.11725465f, 0.11334323f, -0.24069907f, 0.05170883f, 0.10814520f, 
    -0.15188508f, -0.32631314f, -0.12934467f, 0.41751868f, -0.34270632f, 0.01266489f, 0.13440619f, 0.19000426f, 
    -0.05399227f, 0.12254094f, 0.04071511f, -0.22137922f, 0.17503549f, -0.45924297f, 0.02475764f, 0.05340299f, 
    0.19318357f, 0.03934798f, -0.03390504f, 0.16243620f, 0.03298451f, 0.04558596f, 0.01133213f, -0.06872081f, 
    0.06057661f, 0.14305164f, 0.34736845f, -0.39531893f, 0.20544475f, -0.11891294f, 0.08895573f, 0.27247363f, 
    -0.21349208f, -0.25832629f, -0.24123569f, 0.05125355f, 0.08001520f, -0.09607411f, 0.09969557f, -0.19212916f, 
    -0.15257630f, 0.26822478f, 0.28229377f, -0.24161564f, 0.19597544f, -0.10204688f, -0.18165432f, -0.12443323f, 
    -0.15067624f, 0.33533034f, 0.42504966f, -0.51402259f, -0.26979128f, -0.54512185f, 0.13251758f, -0.12596567f, 
    0.02468589f, 0.09446672f, 0.03209154f, -0.27342659f, -0.39183968f, -0.10536072f, 0.34261522f, 0.12095977f, 
    0.34520775f, -0.07803988f, -0.04375635f, -0.39091900f, -0.04429039f, -0.25276050f, -0.29643986f, -0.50072777f, 
    -0.35152104f, -1.18082881f, 0.37983474f, 0.49722224f, -0.60245788f, -0.23636673f, -0.08818743f, 0.52200407f, 
    0.39555493f, 0.01413811f, -0.03106038f, -0.10558344f, -0.03658073f, -0.04567049f, 0.09891564f, 0.21687618f, 
    0.10983390f, 0.10937374f, -0.14059672f, -0.15735731f, -0.01129019f, -0.06754913f, 0.04747211f, 0.28067094f, 
    -0.08754361f, -0.33282548f, 0.17488845f, 0.39368376f, 0.24139141f, -0.00420004f, -0.02060971f, -0.43930438f, 
    -0.40350187f, -0.12695608f, 0.16135611f, 0.23284371f, 0.05573788f, -0.12962788f, -0.25880042f, -0.43999454f, 
    0.46520859f, 0.08160033f, 0.20988195f, -0.21958406f, 0.20924707f, 0.03978567f, -0.18923929f, -0.33683643f, 
    -0.02828430f, -0.01372042f, -0.20613103f, -1.08532393f, -0.43777233f, -0.55245775f, -0.59051830f, -0.67357081f, 
    0.50888431f, 0.17405663f, 0.45564711f, 0.24645460f, 0.45132646f, 0.22301522f, 0.06200053f, 0.00903108f, 
    -0.24273716f, 0.11750147f, -0.09104017f, -0.12847370f, -0.10389850f, 0.07412263f, 0.19044383f, -0.27007660f, 
    -0.00825102f, -0.06094430f, -0.07805227f, 0.06045084f, -0.20362140f, 0.56211007f, -0.05143702f, 0.05978302f, 
    -0.12122751f, -0.52194130f, 0.01095882f, 0.46392924f, 0.01551851f, -0.34792012f, -0.16524993f, 0.29753697f, 
    -0.15133442f, 0.21923171f, 0.06337306f, 0.13810392f, 0.16145559f, 0.13418360f, -0.10983217f, -0.50974089f, 
    -0.13696420f, 0.06246709f, 0.04239102f, 0.30885246f, 0.00935798f, -0.15634757f, 0.02903953f, -0.19010070f, 
    -0.55692142f, -0.05937807f, -0.38227391f, -0.46605510f, -0.48448765f, -0.24968076f, -0.07259229f, -0.14289185f, 
    -0.40355927f, 0.15898250f, 0.40073565f, -0.00845891f, 0.05473131f, 0.00225891f, -0.28402096f, -0.20992534f, 
    -0.34396964f, -0.35025024f, -0.12399227f, -0.12960877f, -0.12193679f, -0.34700710f, 0.48469824f, 0.06025399f, 
    0.21109767f, -0.23470496f, -0.24059139f, 0.14491507f, -0.08602899f, -0.08441918f, -0.27247742f, -0.16595098f, 
    -0.04005759f, -0.29271850f, -0.19248086f, -0.01850244f, 0.47741142f, -0.00550695f, 0.01979380f, -0.19013081f, 
    -0.04650234f, 0.19218682f, -0.09224297f, 0.03993103f, -0.20899272f, 0.14625548f, -0.05120683f, -0.28065595f, 
    0.66199231f, -0.29880938f, -0.54491490f, 0.20879239f, -0.49659240f, -0.21652663f, 0.08617380f, -0.57368261f, 
    -0.47593039f, -0.13200937f, 0.50690109f, -0.37367272f, -0.06883807f, -0.29261598f, 0.00748621f, -0.40663868f, 
    -0.36351660f, -0.47293496f, -0.39416215f, -0.22494730f, 0.16377388f, -0.00229880f, -0.15659812f, -0.16213039f, 
    -0.69332165f, -0.17329387f, 0.08841149f, 0.02271250f, 0.19311728f, 0.36588752f, -0.30689949f, -0.34506303f, 
    -0.22430831f, 0.41108364f, 0.15730004f, 0.18904854f, 0.05043566f, -0.08506772f, -0.36433819f, -0.35944283f, 
    0.20684427f, -0.28778729f, 0.20343629f, -0.19085582f, -0.04207025f, -0.01217533f, -0.29759803f, 0.17093052f, 
    -0.31934771f, -0.64771944f, -0.50027585f, -0.18333097f, -0.22350754f, -0.06863347f, 0.24997759f, 0.17266069f, 
    0.13827603f, 0.40258557f, -0.09956322f, -0.04300587f, 0.51830220f, -0.05397801f, -0.38211367f, -0.22181351f, 
    -0.45440739f, -0.18540442f, -0.02176748f, -0.24923059f, 0.01519038f, 0.32895067f, 0.38931012f, 0.17803890f, 
    0.12496222f, 0.33338371f, -0.42783347f, -0.21785976f, -0.02060336f, 0.28425702f, 0.10807072f, -0.26534122f, 
    -0.02027019f, 0.10240478f, 0.06808754f, 0.27671412f, -0.19351301f, -0.05556590f, 0.33092454f, -0.34399837f, 
    0.06284980f, -0.32395238f, -0.07963553f, 0.17625345f, 0.03249652f, -0.18079342f, 0.23945664f, 0.14091812f, 
    -0.04068422f, -0.04290153f, 0.34177673f, 0.75486422f, -0.56993347f, -1.04446971f, -0.47988412f, -0.54196233f, 
    0.73139650f, 0.27156749f, 0.39068896f, 0.53672779f, -0.42280060f, -0.00652958f, -0.19400881f, -0.03658444f, 
    0.28830215f, -0.09918027f, -0.26548555f, -0.18441278f, 0.51857650f, -0.09694913f, 0.12853673f, -0.10055731f, 
    0.15236427f, 0.03362942f, 0.09063979f, -0.06522505f, 0.36304533f, -1.72038758f, -0.30443195f, 0.47291097f, 
    0.20365700f, 0.10808117f, 0.59352851f, 0.31651998f, -0.08554607f, -0.22032297f, -0.02022180f, -0.14386791f, 
    0.20762083f, -0.43469274f, 0.24550158f, 0.04099834f, -0.15128371f, 0.03579349f, 0.03659625f, -0.03046405f, 
    0.07571330f, -0.21450335f, -0.13391097f, 0.01169536f, 0.05237517f, 0.40312344f, 0.01086354f, -0.35402480f, 
    -0.40042630f, -0.16467239f, 0.44813412f, 0.39822128f, -0.05545978f, -0.14864112f, -0.57520938f, 0.08859657f, 
    -0.19662035f, -0.05832734f, 0.24572739f, 0.15518451f, -0.31781924f, -0.30560681f, 0.02588836f, -0.05757908f, 
    -0.01871318f, 0.28711641f, -0.33712283f, 0.18543431f, 0.22110277f, 0.00654642f, 0.43626788f, 0.26006934f, 
    -0.07283339f, -0.21476065f, -0.16025178f, -0.48701671f, -0.59690940f, -0.50125134f, -0.52482307f, -0.80729163f, 
    -0.05462955f, 0.46987829f, -0.08020231f, -0.14431286f, -0.00017934f, 0.06723864f, -0.05643641f, 0.32847810f, 
    0.25519386f, -0.11069563f, -0.09668981f, -0.04740221f, 0.01407646f, -0.16307104f, 0.16651559f, 0.06286644f, 
    0.39034125f, 0.42331839f, 0.02864797f, -0.20654459f, -0.51628131f, -0.32662094f, 0.01477277f, 0.04468852f, 
    0.20963663f, -0.23407876f, -0.16493733f, 0.19370338f, 0.37695539f, -0.40525806f, -0.09647126f, 0.24087492f, 
    0.02901972f, -0.11570628f, 0.11337204f, 0.20854260f, -0.16233811f, -0.18134783f, -0.09998476f, 0.02076299f, 
    -0.15902446f, 0.73112059f, 0.83995539f, -0.54554409f, -0.83138555f, -0.20438030f, -0.16358054f, -0.19584621f, 
    -0.23594232f, 0.18641023f, 0.60028464f, -0.17807738f, 0.25475219f, -0.23182796f, 0.12161347f, -0.10271257f, 
    0.32192862f, -0.09566252f, 0.15099205f, -0.32893851f, -0.06160139f, 0.09227477f, -0.10539516f, -0.12174487f, 
    0.07082214f, -0.66972733f, 0.17963018f, 0.25880563f, -0.01338427f, -0.45089272f, 0.43373606f, -0.17750467f, 
    0.12858839f, 0.17355229f, 0.25537062f, 0.27614513f, -0.05401228f, -0.01598975f, -0.37062848f, -0.09154353f, 
    -0.03142534f, -0.11044528f, -0.32398254f, 0.07286795f, 0.16762249f, -0.06018580f, -0.14200766f, 0.19893666f, 
    0.04014393f, 0.30132401f, 0.02216076f, -0.29442939f, 0.01858311f, -0.48728070f, -0.46379411f, -0.07118134f, 
    -0.13259122f, -0.54864615f, -0.48743591f, -0.41978732f, 0.43945149f, 0.17090727f, 0.50385666f, 0.26146543f, 
    0.13136595f, -0.22605518f, -0.19045064f, 0.05166958f, -0.45846552f, -0.15819713f, -0.02741880f, 0.02880525f, 
    -0.18478806f, 0.06316634f, -0.08291572f, 0.50720292f, -0.05648960f, 0.22143301f, -0.24807797f, -0.27068281f, 
    -0.71054435f, -0.12940638f, -0.45125580f, -0.57304907f, -0.56221098f, 0.16875371f, -0.21515511f, -0.19450600f, 
    0.17884500f, 0.38693571f, 0.12810378f, -0.27743939f, 0.00081976f, 0.01131851f, 0.14606749f, -0.20082578f, 
    -0.05404948f, -0.03876525f, 0.00059756f, 0.17980011f, 0.26669693f, 0.47618580f, -0.58645386f, -0.85546988f, 
    0.76239425f, 0.57645833f, -0.00492686f, -0.04404527f, -0.62680113f, -0.69089496f, -0.13273956f, 0.40547648f, 
    -0.34373716f, 0.33100015f, -0.23435390f, 0.22092947f, -0.29477379f, -0.15152387f, 0.31175432f, -0.26148307f, 
    0.08615773f, 0.13060921f, -0.13589258f, 0.10680468f, 0.12524374f, -0.51738727f, -0.31782469f, -0.49421316f, 
    -0.25234783f, -0.25921318f, -0.25201273f, -0.53024161f, -0.70431072f, -0.66736871f, -0.45216912f, 0.21337838f, 
    -0.04953240f, 0.01614123f, -0.14423293f, -0.31362966f, -0.19572563f, -0.28676036f, 0.21114336f, -0.11960857f, 
    -0.37445623f, -0.29447728f, -0.24691240f, -0.08650375f, 0.27634969f, 0.15036088f, -0.71684295f, -0.03462875f, 
    -0.22787127f, 0.04606308f, 0.33051428f, 0.21236324f, 0.19125134f, -0.00333005f, 0.04157976f, -0.02806735f, 
    0.04898973f, -0.08537456f, -0.12426157f, 0.16028644f, -0.03785060f, 0.20372948f, -0.27803242f, -0.28415287f, 
    0.07124037f, -0.07969237f, 0.14865452f, 0.10552917f, -0.02185703f, 0.16936976f, 0.10721383f, 0.19352607f, 
    -0.06159848f, -0.24418123f, -0.24995375f, -0.50838417f, 0.36010772f, 0.20796870f, -0.07217730f, 0.08004215f, 
    -0.30390665f, 0.45432499f, 0.44019669f, -0.13026704f, 0.30202997f, -0.60652870f, -0.27576628f, -0.27106249f, 
    -0.20779945f, 0.10083594f, -0.12060034f, 0.20376793f, 0.03505494f, 0.16545495f, -0.07036407f, 0.14041851f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.20468020f, 0.13699733f, -0.18960600f, 0.27572832f, -0.01091159f, -0.01694192f, 0.19460964f, 0.24580547f, 
    0.01967343f, 0.24225175f, -0.14643776f, -0.18248692f, -0.06438289f, 0.08880737f, 0.12331236f, 0.02686273f, 
    0.23105761f, 0.19224678f, 0.27234563f, 0.14754292f, 0.12122224f, -0.06851616f, -0.11948167f, 0.40438226f, 
    -0.10681124f, -0.13143148f, 0.18675518f, 0.32424536f, 0.22458477f, 0.28536361f, 0.29148310f, 0.10564026f, 
    0.09529141f, -0.00812104f, 0.33673826f, -0.05232713f, -0.11226399f, 0.01846972f, -0.09827130f, -0.05140803f, 
    -0.21317270f, 0.06796317f, 0.00844984f, 0.09885880f, 0.15919745f, -0.30089375f, 0.06418250f, -0.11714865f, 
    -0.06647747f, -0.18324257f, 0.16127706f, -0.12377978f, -0.00789108f, 0.23206300f, -0.03977780f, 0.32586271f, 
    0.14005074f, 0.29313421f, -0.09442999f, -0.11813939f, 0.32067531f, -0.51920581f, 0.04322484f, 0.18330030f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.06349341f, -0.00420800f, -0.14298789f, 0.07767225f, 0.02681626f, 0.06345519f, -0.06733361f, -0.09849179f, 
    0.06363615f, -0.00675645f, -0.06231632f, -0.01348442f, -0.48598230f, -0.59124547f, -0.24177387f, -0.05474026f, 
    0.00703893f, 0.04909158f, 0.09857206f, 0.07071015f, -0.05807371f, -0.00238963f, 0.04382378f, 0.00425768f, 
    0.04259019f, -0.25800401f, -0.36109811f, 0.08056480f, 0.03991723f, 0.07400635f, 0.05904293f, 0.01205254f, 
    -0.11848839f, 0.10450041f, 0.08950474f, 0.05632073f, -0.59513575f, -0.10192518f, -0.25970745f, 0.20456730f, 
    0.02606553f, 0.04082368f, 0.02095637f, 0.03828459f, -0.08392312f, -0.06105809f, 0.01146861f, 0.04817501f, 
    -0.24481280f, -0.02297712f, 0.17790982f, -0.23426114f, -0.01143373f, -0.07700725f, 0.02047833f, -0.04506328f, 
    0.03772177f, 0.00848053f, -0.02564870f, 0.03053351f, -0.06151592f, -0.00716002f, -0.01294866f, 0.04890016f, 
    0.04129751f, 0.07525650f, -0.00091560f, 0.01878020f, -0.03947784f, -0.01868831f, -0.08515792f, -0.01981588f, 
    0.27920261f, 0.14336896f, -0.03873864f, -0.19823018f, -0.16722684f, 0.13094890f, -0.00406907f, 0.01006777f, 
    -0.03836272f, -0.06079958f, -0.02890327f, -0.02087477f, 0.19209127f, 0.16978596f, 0.14397095f, -0.11181690f, 
    0.01757650f, 0.05143128f, 0.06945659f, 0.06059717f, -0.05127655f, -0.03580997f, -0.07466844f, -0.03402476f, 
    -0.15617332f, 0.00681193f, 0.24330947f, -0.12511286f, -0.05934598f, -0.00484033f, -0.10788822f, 0.10200422f, 
    -0.01113905f, -0.02244803f, -0.03904252f, -0.08110068f, 0.01510090f, -0.13724892f, 0.06157307f, 0.05788562f, 
    0.00838044f, -0.15086691f, 0.04616953f, -0.18184777f, -0.10717624f, -0.06259067f, -0.02650289f, -0.12180725f, 
    0.20619759f, 0.05727615f, 0.08480704f, -0.11198425f, 0.14116940f, 0.14963005f, 0.01712419f, 0.03605483f, 
    0.01645098f, 0.08106203f, 0.11535011f, 0.02907170f, 0.25767022f, 0.19713336f, -0.03006035f, -0.07791213f, 
    0.13998391f, 0.17947942f, 0.01804484f, 0.05782122f, -0.03964661f, -0.01907167f, 0.01050708f, 0.01100797f, 
    0.21874261f, 0.04717775f, -0.05468027f, -0.19521035f, 0.08694532f, -0.00129703f, 0.04162442f, -0.13202117f, 
    0.00796320f, 0.10311899f, 0.06798159f, 0.02489746f, -0.22607739f, 0.06980526f, 0.16295847f, 0.00257850f, 
    -0.13773489f, -0.20195377f, -0.04286797f, -0.07096466f, -0.06818134f, -0.08928160f, -0.14818139f, -0.14764699f, 
    0.37846220f, 0.10481189f, 0.13163833f, -0.28477252f, 0.01430924f, -0.01447486f, 0.05684196f, -0.02369528f, 
    -0.02862837f, 0.01925216f, 0.01251189f, -0.11806145f, -0.29173574f, -0.11589873f, 0.00724975f, 0.15830986f, 
    0.03496647f, -0.01347273f, -0.14434594f, -0.02504922f, -0.03057528f, 0.02391657f, -0.05040278f, 0.01796721f, 
    0.16302270f, 0.26614180f, -0.03605397f, -0.51300740f, -0.01667012f, 0.06791099f, 0.10169478f, -0.07083824f, 
    0.01157999f, -0.02888319f, -0.05088927f, -0.08177318f, 0.13523246f, -0.12980327f, -0.33120283f, 0.16016993f, 
    -0.08012574f, -0.14142843f, -0.03022947f, -0.03744184f, -0.03999082f, 0.00160271f, -0.00125156f, 0.06806248f, 
    -0.11070357f, -0.55346203f, -0.24688329f, 0.08891656f, 0.07030114f, 0.00649165f, 0.00584146f, 0.00968345f, 
    0.00283351f, -0.00577391f, 0.07507177f, -0.13270655f, 0.32456687f, 0.18334551f, 0.04636984f, -0.06189492f, 
    0.16607799f, 0.24246854f, 0.13972370f, 0.07212806f, 0.02281710f, -0.03097621f, 0.04506001f, -0.04343831f, 
    -0.21704011f, -0.01694195f, 0.08431230f, 0.14129989f, -0.01809902f, -0.02910991f, -0.00753626f, -0.06450827f, 
    -0.05735726f, -0.01933159f, -0.03326713f, -0.11792570f, -0.07392522f, -0.03741340f, 0.06676164f, 0.01044060f, 
    0.09970898f, 0.21781836f, 0.03805683f, -0.12126962f, 0.02614913f, 0.01834198f, 0.04545759f, 0.06602509f, 
    0.05383479f, 0.00335775f, 0.04120803f, 0.01731673f, -0.31439054f, 0.10858507f, -0.10251802f, -0.07763506f, 
    0.03418570f, 0.06725944f, -0.07134587f, -0.09598045f, -0.48847848f, -0.52170229f, -0.40294874f, 0.10776943f, 
    0.00021446f, 0.05163904f, -0.04306947f, 0.07519068f, 0.01711035f, -0.01778534f, 0.01116923f, 0.00078355f, 
    0.33427709f, 0.28057262f, 0.00687341f, -0.18457466f, -0.15684758f, -0.03193484f, -0.02245287f, -0.04728907f, 
    -0.16514206f, -0.07786424f, 0.04018478f, -0.00551401f, 0.11019635f, 0.02729359f, 0.06771782f, -0.13131136f, 
    0.09341385f, 0.04667812f, 0.07517695f, 0.08286946f, -0.03915285f, 0.13263460f, 0.00242743f, 0.02715128f, 
    -0.05387208f, 0.02771655f, 0.26866582f, -0.23982155f, -0.00773267f, -0.10484806f, 0.03420569f, -0.05952015f, 
    -0.02381544f, -0.02418651f, -0.05814309f, -0.18394323f, -0.18292469f, -0.39776206f, 0.17668535f, -0.06574684f, 
    -0.01549905f, -0.01553200f, -0.02276312f, 0.08789863f, 0.02785860f, 0.00947203f, 0.06252769f, 0.02999882f, 
    0.17259233f, -0.45093164f, -0.19724053f, -0.03970723f, -0.03682607f, -0.02460054f, 0.09169704f, -0.01599975f, 
    -0.00411127f, 0.01286139f, -0.00217188f, -0.10620826f, 0.03341884f, 0.16962712f, -0.02560103f, -0.22455551f, 
    -0.08382542f, 0.02025556f, -0.02941088f, -0.00044546f, -0.03760780f, -0.05612870f, -0.00497894f, -0.01381034f, 
    0.04185057f, 0.13312551f, 0.09485773f, -0.02127790f, 0.03291820f, -0.00266274f, 0.06570915f, 0.00332662f, 
    -0.04181477f, 0.00490175f, -0.05267853f, 0.00892705f, 0.15160167f, 0.15246719f, 0.06613699f, -0.00507046f, 
    0.09684661f, 0.21681207f, 0.11925747f, 0.00808807f, 0.06991027f, 0.07469781f, 0.00991796f, -0.02174407f, 
    0.00509725f, 0.13732783f, 0.01437208f, -0.14836866f, 0.00041877f, 0.04707093f, 0.07906503f, 0.01133823f, 
    -0.05163459f, -0.10338892f, -0.18302538f, -0.32973683f, -0.05027911f, -0.12915742f, -0.04561232f, 0.06193710f, 
    -0.00423870f, -0.00336496f, 0.06845424f, -0.01268781f, -0.04436844f, -0.12053888f, -0.32181072f, -0.18802217f, 
    -0.25494102f, -0.11387034f, -0.44662938f, 0.03390960f, 0.01194008f, 0.02214720f, -0.02921291f, 0.02401770f, 
    -0.08649959f, -0.02798482f, 0.02292511f, -0.00448199f, -0.73145539f, 0.03123351f, 0.01880212f, 0.19299285f, 
    0.01504313f, 0.01668585f, -0.03733976f, 0.08875240f, 0.01582421f, -0.04192453f, -0.00676073f, 0.17041765f, 
    0.21363340f, 0.09881523f, -0.09296546f, -0.11774442f, 0.05821269f, 0.19936334f, -0.05862363f, 0.03500370f, 
    -0.07519836f, -0.13088773f, -0.02391482f, 0.03058030f, -0.08226476f, 0.07607371f, 0.11863286f, -0.05302489f, 
    -0.06296659f, 0.06662790f, -0.07292495f, -0.21816930f, 0.09398492f, 0.03573806f, 0.00602771f, 0.02903983f, 
    -0.01796044f, -0.04134549f, 0.02805083f, 0.02925118f, -0.12529288f, -0.00679319f, -0.05380470f, -0.06813149f, 
    0.04159218f, -0.07354595f, -0.09165206f, -0.06790848f, -0.33612704f, -0.44900778f, 0.14908695f, -0.07519838f, 
    0.04384594f, -0.00083867f, 0.04599087f, 0.03835761f, 0.16329421f, -0.06589891f, -0.05411167f, -0.03460065f, 
    -0.14812607f, -0.02853861f, 0.07997411f, 0.09212741f, 0.01741632f, 0.12768178f, -0.04729174f, 0.03800651f, 
    0.01778731f, 0.06926065f, 0.19580485f, 0.12085123f, -0.21472447f, -0.48106200f, 0.14030378f, 0.00747907f, 
    0.00157534f, 0.13360070f, 0.06580206f, 0.09224772f, -0.20752394f, 0.03489411f, -0.02139407f, 0.05017034f, 
    -0.42835987f, 0.27138269f, 0.16431099f, -0.07608359f, 0.00935961f, 0.08458421f, -0.04441832f, -0.13898823f, 
    0.00103045f, -0.03858455f, -0.04197739f, 0.03701213f, 0.12392899f, -0.04054355f, -0.00070370f, 0.00833539f, 
    0.14421263f, 0.16752586f, 0.08106636f, -0.04653757f, 0.05110844f, 0.00471973f, 0.03186885f, 0.02671248f, 
    0.01625669f, -0.05031346f, 0.06339237f, -0.00986859f, -0.26023310f, -0.21590613f, -0.00059535f, -0.10087512f, 
    0.01631270f, 0.04240782f, -0.07563439f, 0.00414816f, 0.27689168f, 0.15531549f, 0.05099563f, -0.12019873f, 
    0.08857320f, 0.16204664f, -0.07609128f, 0.11627808f, -0.11074361f, -0.06852376f, 0.00203143f, 0.03692004f, 
    -0.08992857f, -0.03509955f, -0.06883480f, -0.09259571f, 0.03937024f, -0.01664090f, -0.02512417f, -0.04787528f, 
    -0.02566537f, 0.02704424f, 0.04368109f, 0.03630109f, 0.07138920f, 0.11685902f, -0.22187074f, 0.05964361f, 
    -0.12632500f, 0.04957555f, -0.04434265f, 0.11311035f, -0.10238581f, 0.00185363f, -0.11279069f, -0.00583600f, 
    0.24390723f, 0.21306565f, 0.04403306f, -0.13202055f, -0.05328886f, 0.05472111f, 0.04201114f, 0.02778443f, 
    -0.03095799f, -0.11195254f, 0.01293821f, -0.01437591f, 0.11597539f, 0.14908169f, -0.06411363f, -0.09684124f, 
    0.10241331f, 0.21053539f, 0.04782674f, -0.09911533f, -0.06868622f, -0.09428088f, 0.03473186f, -0.08279926f, 
    0.05065558f, 0.15572551f, 0.09562640f, -0.11434497f, 0.01766456f, -0.12942344f, 0.01249555f, -0.05330377f, 
    0.03439412f, -0.05741984f, -0.04921167f, -0.12861621f, 0.33472878f, -0.22250293f, -0.46567273f, 0.07855006f, 
    0.15880625f, 0.10810947f, -0.23652233f, 0.00943253f, 0.01065228f, -0.03542475f, -0.12080103f, 0.00449966f, 
    0.34861237f, -0.25450248f, -0.13922279f, -0.02525176f, 0.07043218f, -0.04937059f, 0.12565789f, -0.05319094f, 
    -0.03102011f, 0.04551111f, -0.05319476f, 0.00970046f, 0.10739262f, -0.31831235f, -0.49726975f, -0.00204103f, 
    0.04229876f, 0.01733193f, -0.16231537f, -0.09518689f, -0.11903463f, -0.21845296f, -0.32158902f, -0.08913564f, 
    0.19465613f, 0.15715803f, -0.25102055f, -0.08921228f, -0.03689633f, -0.12574877f, 0.08612618f, 0.13004424f, 
    0.05654209f, 0.07263900f, 0.02281237f, -0.01018858f, -0.47977915f, 0.02800093f, 0.17559204f, -0.10650818f, 
    0.03266922f, 0.01651550f, -0.13697365f, 0.03744108f, 0.01100197f, -0.04164254f, 0.00474559f, 0.02091607f, 
    0.09281309f, -0.07993367f, 0.03585050f, -0.09017234f, -0.11388931f, -0.03047421f, 0.04132044f, -0.16517259f, 
    0.09322352f, -0.21268928f, -0.03821571f, -0.17389518f, -0.13375720f, -0.26339173f, 0.22399691f, -0.21077564f, 
    -0.05986058f, -0.06791840f, 0.00734346f, 0.03855968f, -0.08981430f, -0.09399645f, -0.12833272f, -0.34900257f, 
    0.32629773f, 0.10333246f, -0.25796512f, -0.17566672f, -0.04987782f, -0.00925402f, -0.05108361f, 0.02370013f, 
    0.01252673f, -0.03020263f, 0.03996180f, 0.01433331f, 0.23478313f, -0.04451452f, -0.07857097f, -0.25524980f, 
    -0.01153898f, -0.09940775f, 0.01925137f, -0.05418544f, -0.00664947f, 0.10547134f, 0.03728225f, -0.04281046f, 
    0.11883034f, 0.02731500f, -0.89603812f, 0.17521213f, -0.05604088f, 0.04095635f, -0.13271056f, 0.00465079f, 
    -0.08169965f, -0.04417683f, -0.06499489f, -0.10009935f, 0.34750915f, 0.28533763f, -0.07572145f, -0.13729587f, 
    0.15065259f, 0.00171277f, 0.02543155f, 0.07606340f, -0.03521619f, -0.08671741f, -0.06639521f, -0.03158817f, 
    -0.00487075f, 0.02035564f, 0.02900298f, -0.06686405f, -0.02123458f, 0.07980260f, -0.01123764f, -0.01967384f, 
    -0.12237589f, -0.06163505f, -0.06752033f, -0.15195523f, -0.02186611f, -0.14747873f, -0.32960561f, -0.00590887f, 
    0.09427019f, -0.01741113f, -0.06019800f, -0.12665480f, -0.02098246f, -0.18560351f, -0.22404717f, -0.11334312f, 
    0.44535881f, -0.15519308f, -0.10278770f, -0.16915229f, -0.04511065f, -0.06032721f, 0.02046699f, -0.03129423f, 
    0.13444765f, -0.08027069f, 0.18332434f, -0.15395035f, 0.35782748f, 0.08648077f, 0.13455397f, 0.14850006f, 
    0.02739752f, -0.02421544f, 0.00061456f, 0.03351906f, -0.02229393f, -0.02218520f, 0.02692679f, -0.04252817f, 
    0.12023377f, 0.02156887f, -0.23452784f, -0.13897878f, -0.06187290f, -0.01685574f, 0.04122578f, 0.05534204f, 
    -0.13825101f, -0.05349134f, -0.30354989f, -0.10629077f, 0.08972587f, 0.11351459f, 0.11119841f, -0.13559194f, 
    0.02788584f, -0.00706008f, -0.05771065f, -0.06998739f, 0.03535360f, -0.09621830f, 0.10346731f, 0.04060756f, 
    -0.10024286f, -0.04920926f, 0.12865128f, 0.09324154f, -0.03146053f, 0.01594899f, -0.00998658f, -0.04229537f, 
    -0.04721535f, 0.07660218f, -0.04227037f, 0.08665495f, 0.09709207f, 0.15286689f, 0.13702224f, 0.13544978f, 
    0.01401381f, 0.01451912f, -0.00683423f, -0.04465947f, 0.04242039f, -0.00374945f, 0.05038737f, 0.06873741f, 
    -0.37390476f, 0.01433969f, -0.12483787f, -0.20257634f, 0.04226676f, -0.13573207f, -0.22299019f, 0.09680314f, 
    -0.03635492f, 0.01871244f, 0.00428714f, -0.03707333f, -0.91069669f, -0.42096883f, -0.26974967f, -0.15015724f, 
    -0.03864399f, -0.02193351f, 0.08769098f, 0.02149791f, -0.05414992f, -0.09153464f, 0.10649576f, -0.03192779f, 
    -0.02651301f, -0.10931616f, 0.07800034f, -0.30650353f, 0.25313270f, -0.04891600f, 0.15055944f, 0.00612656f, 
    0.10550481f, -0.14452043f, -0.00840968f, -0.08131090f, 0.01446148f, -0.19055972f, 0.06023359f, -0.08668476f, 
    0.01631260f, 0.13400102f, 0.04866670f, 0.04149965f, 0.10074053f, 0.11776624f, -0.03286261f, 0.01278165f, 
    0.10126004f, 0.29659590f, 0.02978718f, -0.34187803f, -0.16445386f, -0.02269995f, -0.14042811f, -0.18083774f, 
    -0.06678790f, -0.06895320f, -0.04080116f, -0.05572752f, 0.21831110f, 0.25125045f, 0.33985987f, 0.21046177f, 
    0.27027932f, 0.12147813f, -0.09735314f, -0.17110583f, 0.00219528f, 0.03950426f, 0.03139907f, -0.09810527f, 
    0.12249576f, 0.12125653f, -0.05477754f, -0.21419853f, -0.17426243f, -0.03699015f, -0.26114088f, 0.00918346f, 
    0.00186570f, -0.07290395f, -0.02850410f, 0.00646967f, -0.13546860f, 0.06823979f, -0.00376255f, -0.09292116f, 
    0.04361175f, 0.10726593f, -0.19755371f, 0.24300073f, -0.04471289f, 0.08685450f, -0.03948504f, -0.02742956f, 
    0.10026410f, -0.06162110f, -0.21627122f, 0.05269995f, -0.02461728f, 0.06498913f, 0.17647447f, 0.03825815f, 
    0.03025984f, -0.09712842f, -0.21239233f, 0.25947362f, 0.23116329f, -0.13589922f, 0.07782156f, -0.10397977f, 
    0.08306348f, 0.01210582f, -0.09773503f, -0.04091109f, -0.07882477f, -0.18123809f, -0.14018719f, -0.25367931f, 
    -0.56670612f, 0.22028039f, -0.23878460f, -0.04651095f, -0.12953342f, 0.13022441f, -0.01157852f, -0.04400640f, 
    0.14396675f, -0.06432184f, 0.01251184f, -0.03187667f, 0.45520648f, -0.28970012f, -0.18552297f, 0.07967223f, 
    -0.10847801f, -0.03678210f, 0.10385418f, -0.08289587f, -0.07061958f, -0.02807013f, -0.00005432f, 0.09626247f, 
    0.41133291f, 0.18837345f, 0.16934055f, 0.09044525f, -0.03751219f, -0.03776886f, 0.02394824f, -0.03320964f, 
    -0.03880984f, 0.05146793f, -0.05406889f, 0.05750391f, -0.09447530f, -0.00272944f, 0.09969081f, 0.15989985f, 
    -0.13594861f, 0.09798785f, -0.03274900f, -0.16375296f, -0.01612775f, -0.04493374f, 0.06175792f, -0.12328674f, 
    -0.04013058f, 0.00689870f, 0.12611941f, 0.03405268f, -0.03865886f, 0.03419788f, 0.12130502f, -0.06644461f, 
    0.03552174f, -0.06897021f, -0.00548626f, -0.02307981f, -0.08898050f, 0.07288178f, -0.06866843f, -0.02793095f, 
    -0.10790569f, -0.04737338f, -0.11551583f, -0.10922557f, -0.13394178f, -0.08634441f, -0.00087183f, -0.08079176f, 
    0.03469866f, -0.02602675f, -0.03785682f, 0.02601731f, 0.05420011f, 0.00823853f, 0.07800505f, -0.15843238f, 
    -0.06075594f, -0.03148254f, -0.01576444f, 0.01475104f, 0.43264824f, 0.15377015f, 0.17026585f, 0.11475778f, 
    0.00105198f, -0.01748182f, -0.00398936f, 0.00391338f, -0.05648155f, -0.04455687f, -0.00326795f, 0.04247879f, 
    -0.01426516f, -0.18548600f, -0.57016724f, 0.17516625f, 0.03949187f, 0.08708974f, 0.04985946f, 0.07746594f, 
    0.01214538f, 0.14739612f, -0.12196190f, -0.48982444f, -0.08479927f, 0.04885484f, 0.02884814f, 0.07923394f, 
    0.08496076f, -0.07300248f, 0.16137467f, -0.16541643f, 0.13768841f, -0.14339130f, -0.01923000f, 0.00107330f, 
    -0.27746585f, 0.26180002f, -0.02388667f, -0.03983927f, 0.01641799f, 0.16715077f, 0.00617273f, 0.01267869f, 
    -0.00099277f, 0.03785461f, 0.05724589f, -0.02411096f, 0.28216207f, 0.10472865f, 0.32773095f, 0.12142672f, 
    0.01645491f, -0.04155583f, 0.06285168f, -0.04012775f, 0.07877300f, 0.02940542f, -0.06183315f, 0.01155192f, 
    0.12593041f, 0.05116142f, 0.14801380f, 0.28069657f, -0.05213699f, 0.00731306f, -0.06047561f, -0.03978147f, 
    0.07831311f, 0.07781193f, -0.08510093f, -0.00008963f, -0.00118884f, 0.24896224f, 0.06526212f, 0.09206516f, 
    0.06755210f, 0.02203441f, 0.07193901f, -0.08598725f, 0.01422742f, -0.03184345f, -0.01855659f, 0.04810004f, 
    -0.19890851f, 0.02449049f, 0.17233703f, 0.09101730f, -0.07256737f, 0.00602070f, -0.05284430f, 0.03045288f, 
    -0.11446115f, -0.08782033f, -0.24728051f, 0.03313366f, -0.04046855f, 0.04675585f, -0.11923850f, 0.03226456f, 
    0.04486925f, 0.01331408f, -0.06205678f, -0.10360259f, -0.03370163f, 0.06435338f, -0.03279354f, 0.09752299f, 
    -0.02711857f, -0.11140029f, 0.05942435f, 0.12088522f, -0.07758855f, -0.05107279f, 0.05343865f, 0.09820572f, 
    0.05241319f, -0.00571904f, -0.03448743f, 0.14917424f, 0.08187536f, 0.05523133f, -0.00491421f, 0.06394689f, 
    0.00516261f, -0.05318488f, -0.04960282f, 0.03729468f, 0.03045910f, -0.06878133f, 0.02031476f, 0.00563357f, 
    0.18105595f, 0.04602697f, 0.14799754f, -0.17402393f, 0.01787546f, -0.04104907f, 0.03530532f, -0.07778874f, 
    -0.05222899f, -0.02159948f, 0.04769399f, 0.07190115f, 0.05464380f, -0.19162121f, -0.01720820f, 0.02992483f, 
    0.06865227f, -0.07959305f, -0.03997830f, 0.00799056f, -0.01817966f, 0.15564258f, -0.18951584f, -0.24582379f, 
    0.12227291f, 0.18991783f, 0.16876169f, 0.11632822f, 0.01520719f, 0.09045968f, 0.07602310f, 0.32950494f, 
    -0.06937788f, 0.01900385f, 0.05953417f, -0.03121938f, 0.01275346f, -0.08233721f, -0.02003814f, -0.03745781f, 
    0.04682493f, -0.05457855f, -0.06265134f, 0.10360053f, -0.03948765f, 0.08898303f, 0.00752114f, 0.01202287f, 
    -0.01394364f, 0.10487302f, -0.00917620f, 0.01173481f, 0.07275836f, 0.01811555f, -0.01549532f, 0.01855957f, 
    -0.23191291f, 0.10823250f, -0.02805417f, -0.06402835f, -0.04285796f, 0.09392321f, 0.03544697f, 0.04769403f, 
    -0.05537307f, -0.02788219f, -0.04093055f, 0.01633308f, -0.03936648f, 0.03067420f, 0.17651805f, -0.05173039f, 
    0.01953751f, -0.07679993f, 0.07153209f, -0.08896138f, 0.03776219f, 0.00999511f, -0.13676070f, 0.01557855f, 
    -0.16874582f, 0.03926603f, -0.31138450f, -0.09897572f, -0.17288791f, -0.24567525f, 0.15313768f, -0.11096476f, 
    0.08246740f, -0.04702052f, -0.21606120f, 0.06464794f, 0.00481759f, 0.08115730f, 0.11493034f, -0.11571205f, 
    -0.02238586f, 0.00056372f, 0.18004115f, 0.06649967f, 0.02467793f, -0.00566877f, -0.01525784f, -0.06182869f, 
    0.05268739f, 0.04287402f, 0.03787926f, -0.04577121f, 0.04811031f, 0.17520268f, -0.28666168f, -0.09606159f, 
    -0.01214303f, 0.04486767f, 0.02725798f, -0.15663129f, 0.04603814f, 0.08041909f, -0.04116098f, -0.07241423f, 
    -0.12420014f, -0.11831008f, 0.10730813f, -0.07550620f, -0.10888891f, 0.03511019f, 0.03672989f, -0.05703273f, 
    -0.03783976f, 0.04901544f, 0.05147146f, 0.04747604f, -0.01169833f, 0.00046715f, 0.11432466f, 0.16729850f, 
    0.24590601f, -0.21212469f, -0.00800986f, 0.04242875f, -0.04383788f, 0.05139632f, 0.03854191f, 0.00872419f, 
    0.21474755f, 0.05759935f, 0.02256839f, 0.14076318f, -0.01099214f, -0.06702270f, -0.05349959f, 0.00657117f, 
    0.01661865f, 0.05267501f, -0.00355558f, -0.06534818f, -0.16414876f, -0.39242712f, -0.24372417f, -0.04670916f, 
    -0.12216899f, 0.03486211f, -0.11943758f, 0.25513923f, 0.01569730f, 0.04247522f, -0.18202139f, 0.04011376f, 
    0.20657596f, 0.03293901f, -0.33877775f, 0.12725213f, -0.07443224f, 0.00686161f, 0.03190773f, 0.00580881f, 
    -0.22465968f, -0.36188141f, -0.06564011f, 0.02104306f, -0.16310056f, 0.23646897f, -0.21553226f, -0.03133384f, 
    0.03222338f, -0.09937651f, 0.01389600f, 0.19977418f, -0.07237288f, 0.10278758f, -0.13400105f, 0.05100891f, 
    -0.22199343f, 0.06415857f, 0.03471827f, 0.06983356f, 0.01478449f, 0.19174449f, -0.00907358f, 0.02538903f, 
    0.01484149f, 0.04668596f, -0.02727915f, 0.01710851f, 0.55012375f, 0.00249681f, -0.12927589f, -0.10264872f, 
    -0.01364457f, -0.00890682f, 0.14183782f, -0.13123292f, 0.02959872f, 0.02945480f, 0.01369482f, -0.25160950f, 
    0.30799884f, -0.22153275f, -0.16596133f, 0.08733378f, -0.05684337f, -0.02342203f, 0.06335870f, -0.19555272f, 
    0.19436166f, -0.25719967f, 0.06501800f, 0.06763598f, 0.28616077f, -0.22878595f, 0.21705325f, 0.04280576f, 
    -0.03472279f, 0.04666286f, 0.07089144f, -0.02924040f, 0.15901913f, -0.07027460f, 0.09163634f, 0.00343398f, 
    0.13471445f, 0.01843163f, -0.30882439f, -0.27262962f, -0.24871388f, -0.09647891f, 0.02699554f, -0.20936188f, 
    -0.08380128f, 0.00103647f, -0.04513584f, 0.06874803f, 0.02759655f, 0.17882949f, 0.05207743f, -0.14653318f, 
    0.04147380f, 0.03615417f, -0.09010921f, -0.01849537f, 0.01525549f, -0.01915666f, 0.04619250f, 0.02611862f, 
    0.06730461f, -0.15509629f, 0.23788942f, -0.52795374f, 0.03577461f, 0.15606625f, -0.18312012f, 0.07187559f, 
    0.02186706f, 0.09845880f, -0.11780269f, 0.05598732f, 0.02677862f, 0.26303011f, -0.03958793f, -0.13975160f, 
    -0.01692624f, 0.13879609f, 0.02088707f, -0.06005858f, 0.09809625f, 0.13288885f, -0.07168180f, 0.12512287f, 
    -0.02326423f, -0.07688199f, 0.07544721f, -0.01402140f, 0.08369518f, -0.00435230f, 0.00908943f, 0.15772414f, 
    -0.00134083f, -0.04568115f, 0.07758828f, 0.02610300f, 0.15407023f, 0.02500986f, 0.05250999f, -0.40241241f, 
    -0.26814765f, -0.02026538f, -0.06275788f, 0.14364816f, -0.08962466f, 0.07489276f, 0.06335592f, 0.02759119f, 
    0.39348826f, -0.20535628f, -0.25008404f, 0.33233902f, -0.14211908f, 0.02746701f, 0.21388564f, 0.13409989f, 
    -0.10435732f, 0.04259357f, 0.00966705f, 0.06772109f, 0.12537026f, 0.04773150f, 0.18227670f, 0.04949887f, 
    -0.10722618f, 0.15581940f, 0.02714900f, -0.12495312f, 0.03388874f, 0.03460022f, -0.08625611f, 0.08647179f, 
    -0.08850250f, -0.08704457f, 0.05090208f, 0.10437623f, 0.00008731f, -0.04614462f, 0.01010109f, -0.02848036f, 
    0.00062482f, -0.08760750f, 0.08423864f, -0.03620633f, 0.15318306f, -0.21020462f, -0.18566969f, -0.26288676f, 
    -0.01119893f, -0.07982790f, -0.00933483f, 0.11690742f, -0.01507153f, 0.15661487f, -0.13568014f, 0.14620212f, 
    0.02940519f, 0.07577834f, 0.16334125f, 0.05041486f, 0.00362610f, 0.03015954f, 0.06258973f, -0.17547387f, 
    0.04580785f, 0.09324946f, -0.00270354f, 0.07013840f, 0.04273143f, -0.13941419f, -0.05008039f, -0.13817836f, 
    -0.00434562f, 0.03828280f, -0.01113147f, 0.07791805f, 0.02119013f, -0.05496645f, -0.03604673f, 0.09290063f, 
    -0.09194377f, 0.26639059f, 0.13880792f, 0.12370573f, -0.03674404f, -0.02082279f, 0.08211778f, -0.04567145f, 
    0.04765114f, 0.01235844f, 0.02707230f, 0.17242143f, -0.22306664f, -0.06381288f, 0.32089520f, -0.19929813f, 
    -0.00553794f, -0.00415083f, 0.05353609f, -0.00010496f, 0.07196318f, -0.01862841f, 0.08503456f, -0.03609346f, 
    -0.15662359f, 0.09431845f, -0.12559614f, -0.08576710f, -0.00867248f, -0.05176343f, 0.02138842f, 0.05993608f, 
    -0.03064689f, 0.01756950f, -0.05966118f, 0.07884783f, -0.15806794f, -0.04493383f, -0.00607011f, -0.00055708f, 
    -0.01932772f, -0.05740779f, 0.01664352f, 0.08590092f, -0.01784907f, -0.09583995f, -0.00321040f, -0.06892424f, 
    0.31943032f, 0.15051092f, -0.02811606f, -0.08852001f, 0.10647807f, 0.08731203f, -0.18643293f, -0.02198449f, 
    -0.01993053f, 0.01489619f, -0.03034016f, 0.02892237f, 0.16985422f, -0.02062268f, -0.09969455f, 0.15694143f, 
    -0.01709748f, 0.01029160f, 0.03813800f, 0.02066901f, -0.02991610f, -0.00578015f, -0.05260927f, 0.11277785f, 
    -0.06904487f, -0.06536324f, -0.18644410f, -0.29927304f, 0.05016628f, 0.05911227f, -0.06398733f, 0.07797962f, 
    -0.01379110f, -0.06093835f, 0.11920226f, -0.00342050f, -0.05559471f, 0.23249245f, 0.00443965f, -0.02456264f, 
    -0.05813971f, 0.11905903f, -0.14721660f, -0.15351944f, 0.02518482f, 0.01337578f, -0.00939716f, 0.14759466f, 
    -0.12380120f, 0.46211648f, 0.23283587f, 0.14640932f, -0.20891605f, 0.06966788f, -0.05734993f, -0.01973082f, 
    0.05495701f, -0.04614576f, -0.01310662f, 0.06405208f, -0.51806760f, -0.06988775f, 0.37327352f, 0.21175137f, 
    -0.06581082f, 0.05543312f, 0.00225378f, 0.07106055f, -0.00166334f, -0.02226985f, -0.01704075f, -0.00245031f, 
    -0.18917581f, 0.11940782f, -0.15911111f, -0.11460301f, 0.00840268f, -0.05347055f, 0.02841339f, 0.15284704f, 
    -0.00872188f, 0.05906073f, -0.02598426f, 0.07747021f, -0.10893000f, 0.00157144f, -0.03629559f, 0.04764848f, 
    0.13513829f, 0.04418700f, -0.07017805f, -0.00354422f, 0.16162680f, -0.02705870f, -0.06516507f, 0.17863432f, 
    -0.05828496f, -0.26114795f, -0.16254394f, 0.10075815f, 0.09122659f, -0.13451484f, 0.08931383f, 0.10532829f, 
    0.10378007f, -0.01834859f, -0.09352461f, 0.09193458f, -0.02926425f, 0.12616903f, 0.10520215f, -0.01808636f, 
    -0.01107828f, 0.08562887f, 0.01249026f, -0.28021571f, 0.05055725f, 0.19309272f, -0.04631952f, 0.29202095f, 
    -0.11706898f, -0.19774269f, -0.21377350f, 0.05079661f, -0.04757874f, 0.10372157f, -0.23011868f, -0.02291827f, 
    -0.10284059f, 0.00406949f, -0.00990559f, 0.02432763f, -0.07779414f, 0.03164727f, -0.05416951f, -0.42814043f, 
    0.07053626f, -0.00503522f, 0.02480922f, -0.05888773f, 0.00747522f, -0.02022607f, 0.03273968f, -0.12914090f, 
    -0.17031989f, -0.02768219f, -0.06014301f, -0.12793133f, 0.01256353f, -0.00064639f, 0.03302730f, -0.04860296f, 
    0.04998303f, 0.03800198f, -0.09500159f, 0.05682454f, -0.06036253f, 0.19966292f, 0.21013859f, 0.33940145f, 
    0.00702518f, -0.12624754f, 0.11147297f, 0.13017972f, -0.00414987f, -0.04588316f, 0.10941643f, -0.06197259f, 
    0.07408866f, -0.01792431f, 0.00714205f, 0.01411481f, -0.03515587f, 0.05196884f, 0.00302122f, -0.00528416f, 
    -0.05227979f, -0.10498741f, 0.08387377f, -0.18207341f, 0.12168752f, 0.10626348f, 0.08134998f, 0.20258355f, 
    0.05877656f, 0.01129617f, 0.05048415f, 0.08034621f, 0.09062297f, 0.08618893f, 0.10898851f, 0.01780601f, 
    -0.19132395f, -0.02677934f, -0.02045331f, 0.01515294f, -0.26847923f, -0.11225116f, -0.11976124f, -0.37487587f, 
    0.01009805f, -0.06175267f, -0.07414825f, -0.03514017f, -0.15963247f, 0.02736077f, 0.05916347f, -0.13880429f, 
    0.01973788f, 0.02768817f, -0.01601585f, 0.00096913f, 0.00493281f, -0.04548619f, -0.02356311f, 0.05429934f, 
    -0.04722085f, -0.37193176f, -0.03260479f, 0.12070142f, -0.01424368f, -0.11299229f, 0.00866428f, 0.02304622f, 
    -0.07489215f, -0.15785833f, 0.13232079f, -0.03645748f, 0.02099668f, -0.10291567f, -0.14584431f, 0.04084978f, 
    0.05334285f, -0.07752358f, 0.16638432f, -0.02396391f, 0.08017521f, 0.03040314f, -0.04057789f, 0.06910829f, 
    0.26663086f, -0.01918313f, -0.06642639f, 0.33233181f, 0.14208597f, 0.09802818f, -0.23678024f, 0.09417456f, 
    -0.03593599f, -0.14452748f, 0.03292687f, 0.11458217f, -0.03409886f, -0.02489622f, -0.17477758f, -0.02585618f, 
    0.07898169f, -0.00082804f, 0.02905192f, 0.00504383f, -0.04083313f, -0.00312398f, -0.00442206f, -0.00185811f, 
    0.23910019f, 0.11591598f, -0.05235027f, 0.11920775f, 0.01258973f, 0.05508708f, -0.00069723f, 0.06118439f, 
    -0.03246544f, 0.00592069f, 0.02664198f, -0.14158975f, -0.12192442f, 0.04123767f, 0.07981024f, 0.16531746f, 
    -0.01177762f, 0.09798383f, 0.02945072f, 0.04305850f, -0.03023409f, 0.01998364f, 0.04169935f, -0.00988691f, 
    -0.16999553f, -0.20126277f, -0.01701043f, 0.20831680f, 0.03236653f, -0.04254264f, 0.05361459f, 0.04697185f, 
    0.02854220f, -0.05087518f, 0.00945352f, 0.00368535f, 0.10439277f, 0.08293178f, 0.13730633f, 0.22961971f, 
    -0.03474304f, -0.01614158f, 0.01756458f, 0.08405101f, -0.03849309f, -0.00228190f, 0.04454941f, 0.07883275f, 
    0.01738315f, -0.04566940f, -0.16280842f, 0.05694355f, 0.12101105f, -0.08741201f, 0.07589509f, 0.07195870f, 
    -0.06256753f, 0.00965691f, -0.16469906f, -0.14441490f, -0.07521091f, 0.01089202f, -0.02503146f, -0.06570309f, 
    0.00681652f, 0.00188108f, -0.10254770f, 0.00603618f, -0.05402425f, -0.28676742f, 0.14517078f, 0.09919165f, 
    -0.22599031f, -0.02807532f, 0.23294064f, -0.14095016f, 0.07290017f, 0.07952875f, -0.03052447f, 0.00233799f, 
    0.01011127f, -0.06176396f, 0.06654920f, -0.00273382f, 0.13551562f, 0.00626203f, -0.19043460f, -0.07674378f, 
    0.00002736f, 0.01173668f, -0.00876442f, -0.04114933f, -0.10225731f, -0.04701320f, 0.06427303f, -0.05746135f, 
    -0.22575848f, -0.01963677f, 0.12724048f, 0.18928288f, 0.00088750f, 0.02325957f, 0.04363276f, -0.01097538f, 
    0.04966395f, -0.08875151f, -0.05866413f, 0.00677231f, -0.24262834f, -0.07632843f, 0.10648222f, -0.01807651f, 
    -0.15098536f, -0.22982219f, -0.25695157f, -0.00746168f, -0.00964985f, -0.03286890f, 0.01021212f, -0.02685865f, 
    -0.06533225f, 0.08263722f, -0.10065991f, 0.08974271f, 0.06903273f, 0.03797655f, -0.10681929f, 0.05844998f, 
    -0.08595575f, 0.16385345f, -0.04877226f, 0.04388900f, -0.28441104f, 0.06757851f, -0.26381412f, 0.03276557f, 
    -0.00762982f, -0.02071839f, -0.08688629f, 0.06632438f, -0.11096405f, -0.00751031f, 0.08081787f, -0.01264312f, 
    0.09822005f, -0.08271082f, 0.02187449f, -0.01027906f, 0.03263100f, -0.05480920f, -0.02985692f, -0.06079331f, 
    0.12273604f, 0.11322624f, -0.13707204f, 0.10139740f, 0.43169862f, 0.05632664f, 0.04102582f, -0.01087200f, 
    0.04749026f, -0.02178545f, 0.08245289f, -0.14007354f, -0.03192884f, -0.01871242f, 0.04296328f, 0.03991636f, 
    -0.10261896f, -0.12554462f, 0.11177153f, -0.01273157f, 0.02578062f, 0.03670111f, 0.05125906f, -0.10091636f, 
    0.01466786f, 0.02300402f, -0.11043922f, 0.06742579f, 0.00759914f, 0.50402099f, 0.35200298f, 0.30180210f, 
    -0.08463547f, -0.04140538f, 0.05230094f, 0.02259497f, 0.08275844f, 0.05626826f, 0.04622188f, 0.05788324f, 
    -0.06367096f, -0.11554753f, -0.01498230f, 0.08936158f, -0.10922819f, -0.01133509f, 0.08055720f, -0.10447267f, 
    0.04067819f, -0.06454188f, 0.00488000f, 0.00759926f, -0.56944758f, -0.65762800f, -0.07336099f, -0.17792203f, 
    -0.00239148f, -0.01419229f, 0.10846259f, -0.09321162f, -0.02339204f, -0.02938134f, 0.02063831f, 0.00240803f, 
    -0.15405156f, -0.03602650f, -0.01029552f, -0.10408391f, 0.03726567f, -0.04854589f, -0.08549432f, 0.02409641f, 
    -0.01326655f, 0.03941035f, -0.08806387f, 0.01968310f, 0.24944317f, -0.29644758f, 0.01488426f, -0.31632406f, 
    0.10967901f, 0.06474125f, -0.00391491f, -0.22017816f, 0.02592661f, -0.05052971f, -0.03098752f, 0.07713407f, 
    0.09849899f, -0.12939645f, -0.10075460f, 0.09328853f, 0.03851499f, -0.06624208f, -0.01467853f, 0.05441635f, 
    0.00535134f, -0.09038524f, 0.12497732f, 0.05773669f, -0.15997426f, 0.08994256f, 0.02382779f, 0.03811706f, 
    0.02997230f, 0.00458574f, -0.14396171f, 0.03912500f, -0.01339602f, -0.07099076f, -0.10690508f, -0.12385488f, 
    -0.08047084f, 0.00294411f, -0.09067884f, 0.02167192f, 0.03933154f, 0.19764444f, -0.09820544f, 0.06117873f, 
    -0.01204970f, -0.08879484f, 0.04825994f, -0.05769212f, -0.71061093f, 0.43549642f, 0.57709473f, 0.00346938f, 
    -0.03851059f, -0.04628073f, 0.17782159f, -0.07938784f, 0.09867308f, 0.06757581f, 0.00568237f, -0.22220768f, 
    0.16896689f, 0.03748474f, 0.21624057f, 0.06563646f, -0.06900356f, 0.03521468f, -0.03135791f, 0.08678983f, 
    0.06514972f, 0.08825647f, 0.09580568f, -0.07011616f, -0.25908151f, -0.07047189f, 0.00235404f, -0.12965827f, 
    -0.00489782f, -0.10723555f, 0.07624615f, -0.02452188f, -0.17418048f, 0.02963372f, -0.05900684f, -0.16093580f, 
    -0.60285807f, -0.35132360f, 0.13873558f, -0.39243951f, -0.01854467f, 0.05587898f, -0.08951472f, -0.04566368f, 
    -0.00709537f, -0.03765269f, 0.01800782f, 0.00145675f, -0.13793303f, 0.02353496f, 0.07142542f, -0.05156491f, 
    0.01168643f, -0.02925619f, 0.08330479f, 0.14779675f, 0.02390788f, -0.05261147f, 0.03786353f, 0.00238711f, 
    0.17572813f, -0.17497225f, 0.22930996f, -0.29197824f, 0.21445711f, -0.00671740f, -0.08267009f, 0.01379861f, 
    0.02576645f, 0.01692760f, -0.05494129f, 0.16171880f, 0.16910563f, 0.10740183f, -0.11671878f, -0.07005960f, 
    0.09396036f, -0.02047133f, -0.07290859f, 0.07790731f, -0.04145712f, 0.08563594f, -0.03884394f, 0.11324085f, 
    -0.22379380f, -0.34556502f, -0.05102374f, -0.39294633f, -0.01477197f, 0.00082369f, -0.02587049f, -0.10560691f, 
    0.07028997f, 0.01794914f, 0.04790888f, -0.02288712f, -1.03441393f, -0.20398015f, -0.10125484f, -0.07034775f, 
    0.05180311f, 0.05090193f, -0.18828635f, -0.16024859f, 0.09255409f, 0.02998664f, -0.03425397f, -0.08000858f, 
    -0.00754155f, -0.32058620f, -0.02882316f, -0.24057625f, 0.13451013f, -0.10652012f, 0.08110757f, 0.16499729f, 
    -0.04921427f, -0.05613672f, -0.04393066f, 0.01183219f, -0.72715479f, -0.48266020f, -0.15938780f, -0.35047996f, 
    0.02443593f, -0.07721292f, 0.08213019f, -0.05626963f, -0.04005498f, -0.02394910f, 0.07369559f, 0.02906113f, 
    0.03794125f, -0.07275249f, 0.00433681f, 0.16543956f, 0.03162640f, 0.01177273f, -0.00792094f, -0.02322741f, 
    0.07197689f, -0.10879578f, -0.04859070f, -0.00219216f, -0.24404012f, 0.16681510f, -0.13640590f, -0.32371497f, 
    0.10145430f, -0.04748731f, -0.03117269f, 0.12886789f, 0.05010257f, -0.32213980f, -0.01422430f, 0.01243110f, 
    -0.68935293f, -0.25655082f, -0.03641351f, 0.03315547f, 0.11260059f, 0.12761375f, 0.17311384f, -0.10619140f, 
    -0.01244231f, 0.12219919f, -0.15370521f, 0.03430095f, -0.15167320f, -0.01887742f, -0.18584198f, -0.02198652f, 
    -0.00725495f, 0.01674456f, -0.03483844f, -0.01532131f, -0.09172962f, -0.02104157f, -0.08178208f, -0.03970373f, 
    -0.08452811f, -0.07148722f, -0.03724073f, 0.20276985f, 0.11402641f, 0.09350769f, -0.00114153f, -0.00686936f, 
    0.08604562f, 0.04124304f, -0.17406818f, 0.03024139f, -0.29344356f, -0.03147081f, 0.20288345f, -0.10918291f, 
    -0.27277395f, -0.02000077f, -0.09442575f, 0.00577368f, 0.01348236f, 0.08772071f, 0.01120788f, 0.01342498f, 
    0.28198683f, 0.21796423f, 0.16732988f, -0.00658362f, 0.24250075f, -0.23812488f, -0.03663509f, 0.02022407f, 
    -0.02865691f, 0.05958256f, -0.08174322f, 0.15002504f, -0.27196875f, -0.28834918f, -0.05064097f, -0.01195249f, 
    -0.10605785f, -0.02235431f, -0.03621683f, -0.11415166f, -0.04452631f, 0.03386943f, -0.03211725f, -0.03101491f, 
    -0.03635552f, -0.04984248f, 0.05660997f, 0.03988434f, 0.01399974f, 0.11646407f, -0.09165558f, 0.05490203f, 
    -0.08224294f, -0.03435422f, -0.05105022f, -0.03303379f, 0.20038624f, -0.05682770f, -0.06773464f, -0.09605132f, 
    0.03511019f, -0.02066226f, 0.03138134f, -0.02703410f, -0.20860878f, 0.02345906f, -0.14947934f, -0.04082184f, 
    0.10378350f, -0.01973820f, -0.00187082f, -0.15711431f, -0.16001193f, 0.13355000f, -0.03550408f, -0.19194297f, 
    0.07699440f, 0.08857112f, 0.02914095f, -0.27048606f, -0.18674240f, 0.23958786f, -0.07188600f, 0.23453858f, 
    -0.06900252f, 0.03233965f, -0.30844545f, 0.07855697f, -0.16610289f, -0.07776578f, 0.22710565f, -0.08828112f, 
    0.09855756f, -0.23658544f, -0.10504065f, 0.22535855f, 0.04841462f, -0.06556642f, -0.04373984f, 0.03557882f, 
    -0.08886658f, 0.09552702f, 0.01930940f, 0.09458558f, -0.00620841f, -0.16844621f, -0.04640137f, 0.21073042f, 
    -0.01010868f, -0.02256768f, -0.03714342f, -0.00967903f, 0.04748518f, 0.06437776f, -0.00620181f, 0.01511176f, 
    -0.20118038f, -0.03496186f, -0.05951523f, 0.06116665f, -0.17631632f, 0.00995235f, -0.05168864f, 0.00104127f, 
    -0.15465118f, 0.00314049f, 0.01055644f, 0.01565336f, 0.06550717f, -0.15140691f, 0.19614062f, -0.23129532f, 
    0.02595584f, 0.09453575f, -0.17771444f, -0.11404872f, -0.05552013f, -0.12091929f, -0.00153750f, -0.06530420f, 
    -0.22140130f, 0.24557544f, -0.32120204f, -0.86982226f, 0.12882707f, 0.10591367f, -0.06232196f, 0.03237760f, 
    -0.01271377f, -0.04051815f, -0.06872692f, -0.11807165f, -0.16005875f, -0.00963859f, -0.02250068f, 0.22001693f, 
    -0.08907504f, 0.03436553f, -0.04868357f, 0.02349109f, 0.06006980f, 0.09107839f, 0.09159665f, 0.14266112f, 
    -0.01854977f, 0.03936404f, -0.13644032f, 0.10968325f, -0.04349472f, -0.11740728f, -0.06711160f, -0.07720590f, 
    -0.13941671f, -0.00259947f, -0.09548439f, -0.01394708f, -0.14151496f, 0.19004142f, -0.01934201f, 0.27583972f, 
    0.00799339f, -0.10230887f, -0.03885238f, -0.07639810f, 0.08148977f, -0.06822813f, -0.03631749f, 0.00847246f, 
    -0.21399081f, -0.13619497f, 0.30828771f, 0.12567203f, -0.06310817f, 0.03065406f, -0.10761956f, -0.00604451f, 
    -0.02995380f, -0.19279832f, -0.01612467f, -0.05305424f, -0.05907663f, -0.10064963f, -0.09630228f, 0.03782685f, 
    -0.03602305f, 0.01522853f, -0.08829379f, 0.00734265f, 0.01937675f, 0.03844624f, 0.11392237f, 0.02755042f, 
    -0.19017752f, 0.02790778f, -0.08096154f, -0.01815445f, -0.01341924f, 0.03046986f, -0.15260276f, -0.12078919f, 
    -0.02551679f, -0.14104728f, 0.14626373f, -0.07289529f, 0.52634519f, -0.04971045f, -0.00337527f, 0.14094777f, 
    0.10912403f, 0.05565758f, 0.11056236f, -0.08722873f, -0.07739496f, -0.09200804f, -0.00084885f, 0.11734496f, 
    0.04058838f, -0.17523749f, 0.12315574f, 0.24437656f, 0.16567597f, -0.08206032f, -0.20109965f, -0.01417012f, 
    0.00920738f, -0.14016239f, -0.05247750f, -0.15034935f, -0.17594215f, -0.11556829f, 0.21956104f, -0.13323723f, 
    -0.01866882f, 0.07314174f, -0.02872838f, 0.02597008f, -0.08605196f, 0.09047176f, 0.01660224f, -0.04038366f, 
    -0.12284443f, -0.05582681f, -0.17513674f, -0.03856070f, 0.03580638f, 0.00677468f, -0.12415175f, 0.14791186f, 
    -0.02863341f, -0.01705728f, -0.02349945f, 0.01140685f, 0.11852241f, 0.21334654f, -0.12725998f, 0.27482703f, 
    -0.17151080f, -0.06742770f, 0.02545217f, -0.08422610f, 0.21843182f, -0.08449958f, -0.18310994f, 0.10346954f, 
    0.42545259f, 0.05373623f, 0.03994850f, 0.05068266f, -0.03054467f, 0.10992283f, -0.11244076f, -0.09738378f, 
    -0.10145660f, 0.01329190f, -0.00004612f, 0.06502707f, 0.12936836f, -0.03225882f, -0.03835981f, -0.14372799f, 
    -0.15479074f, -0.32232270f, 0.04929995f, 0.21336876f, -0.09572557f, 0.00015852f, 0.00548513f, 0.05651902f, 
    0.26395828f, 0.64948678f, -0.28830051f, -0.18935527f, 0.19014555f, -0.08693445f, 0.00294656f, 0.01105440f, 
    -0.03971107f, -0.14283338f, 0.05766519f, -0.04840551f, -0.00687222f, 0.09922693f, 0.03844744f, -0.10281662f, 
    -0.11074249f, -0.18411042f, -0.12606944f, -0.10463367f, -0.06928084f, 0.04454763f, -0.14377883f, -0.06511201f, 
    0.19260627f, 0.04778034f, -0.16298836f, -0.60131913f, 0.17484337f, 0.03157493f, -0.00969639f, -0.03332330f, 
    -0.22282030f, 0.02687156f, -0.04335903f, -0.12986086f, 0.17406850f, -0.08262110f, -0.18688560f, 0.03245927f, 
    0.18381114f, -0.06399596f, 0.08322351f, -0.18834151f, -0.15565898f, 0.08802423f, 0.01240731f, 0.08917730f, 
    -0.17901303f, 0.28876176f, -0.11242938f, -0.24363546f, 0.12405649f, 0.01881537f, -0.05078153f, -0.07769558f, 
    -0.29363069f, 0.02072977f, -0.07102612f, 0.12105127f, -0.29069069f, -0.07009067f, -0.29852000f, 0.25114843f, 
    -0.10606046f, -0.09058583f, -0.14550963f, 0.08482140f, 0.01584935f, 0.06128546f, -0.01569315f, 0.08625615f, 
    -0.35311890f, 0.07631548f, -0.00248180f, 0.16127111f, -0.15193860f, -0.03636859f, -0.16542394f, -0.11799648f, 
    -0.06255874f, 0.13220893f, -0.02896190f, -0.14019038f, 0.59248787f, -0.06110315f, 0.21525408f, -0.34867173f, 
    -0.19235633f, -0.15339565f, -0.03663427f, -0.06606797f, 0.11226778f, 0.13505584f, 0.16886315f, -0.03656101f, 
    0.05900071f, -0.05359015f, -0.00767652f, 0.25318214f, -0.02002071f, -0.05150743f, -0.00887606f, 0.05368910f, 
    0.02048726f, 0.11520460f, -0.04156528f, 0.12580454f, 0.16424997f, -0.12395032f, 0.40882707f, 0.23626180f, 
    -0.22999002f, -0.07751608f, 0.03944719f, 0.06119831f, 0.09160548f, -0.06152585f, 0.06876655f, 0.05908347f, 
    0.04471219f, -0.10833539f, -0.09490522f, -0.15656415f, 0.10954175f, -0.12477548f, -0.13202336f, 0.01461136f, 
    -0.00549284f, -0.11624233f, -0.15597613f, 0.01381354f, 0.00707541f, 0.12962775f, 0.27770194f, -0.03453007f, 
    0.01727175f, 0.06453659f, 0.01034773f, 0.26282561f, 0.04722703f, -0.10281496f, 0.19710630f, -0.18451135f, 
    0.34918746f, -0.15368538f, 0.17388566f, -0.01390332f, -0.08943407f, 0.10822234f, -0.00205088f, 0.03050112f, 
    -0.08720183f, -0.02233891f, -0.05746780f, 0.11316921f, 0.81807876f, 0.33859670f, 0.18433659f, 0.20404865f, 
    0.07907819f, -0.02010707f, -0.15022078f, -0.23307279f, -0.24821967f, -0.02264006f, 0.02346336f, 0.07172675f, 
    0.13597384f, -0.30760574f, 0.07348073f, -0.04805948f, -0.27423355f, -0.10937769f, -0.01632423f, -0.06645911f, 
    0.04901781f, 0.07628418f, -0.06002843f, 0.10302357f, 0.23281901f, -0.27585754f, -0.02824659f, 0.08545066f, 
    0.21177325f, -0.00580530f, 0.04503020f, 0.06709058f, -0.03190045f, -0.01104310f, 0.05258460f, 0.00538463f, 
    0.31322140f, -0.00739651f, 0.21291997f, -0.19517589f, -0.07266188f, -0.21442756f, -0.08049987f, -0.09482245f, 
    0.02291127f, -0.16474897f, 0.05137349f, -0.11770353f, 0.06247657f, -0.16602984f, -0.01493085f, 0.11015522f, 
    -0.05350306f, 0.04842122f, 0.14717233f, 0.05993349f, 0.03016879f, 0.05537098f, 0.06746397f, 0.06588016f, 
    -0.40603042f, -0.32463124f, 0.16716260f, 0.14544000f, -0.03386022f, -0.23289073f, -0.04293787f, 0.03688971f, 
    0.14489184f, -0.01945363f, -0.03273628f, 0.04077219f, 0.15489158f, -0.04192847f, 0.27607566f, -0.03105201f, 
    -0.00057886f, -0.07366174f, 0.03603727f, 0.05926365f, -0.15662536f, 0.00313864f, 0.11929247f, 0.04660008f, 
    -0.20683818f, 0.07745416f, -0.21327935f, -0.13899772f, 0.04080159f, 0.07264252f, 0.03221164f, -0.06983562f, 
    -0.03657653f, -0.01094336f, -0.03510135f, 0.06750052f, 0.11583281f, 0.00583657f, 0.00019915f, 0.10047244f, 
    0.17936632f, 0.02468293f, 0.04197338f, 0.02023028f, 0.15763251f, 0.14161602f, -0.03669626f, 0.09856007f, 
    0.04888381f, 0.04036165f, -0.11926261f, -0.20551744f, 0.00657377f, -0.06650946f, -0.09547928f, -0.12072042f, 
    0.06394238f, 0.10889348f, 0.05880548f, 0.03555324f, -0.06047316f, -0.13904780f, 0.07252795f, 0.21560572f, 
    0.24014063f, 0.09549619f, -0.20812359f, 0.11237495f, 0.03276050f, 0.01814884f, 0.11402741f, 0.05902644f, 
    -0.74591845f, 1.08912051f, -0.10137784f, -0.26333115f, 0.19508965f, 0.01426380f, -0.04160357f, -0.05148486f, 
    -0.03584950f, 0.02211597f, -0.02649805f, -0.31420031f, -0.22800663f, 0.05013685f, -0.14195630f, 0.29360685f, 
    0.03149141f, -0.10759789f, 0.17786619f, -0.06291804f, -0.09472857f, -0.08732426f, 0.12102351f, -0.04982376f, 
    -0.01756960f, -0.21800752f, 0.23726256f, 0.13564177f, 0.01382288f, 0.21617946f, -0.06408799f, 0.09052294f, 
    0.03036109f, -0.06945315f, -0.00517101f, -0.02320354f, 0.05341005f, -0.35099745f, 0.12311477f, -0.34347859f, 
    -0.18169963f, -0.09493154f, -0.03207943f, -0.16103275f, 0.04206470f, 0.07224908f, 0.01182524f, -0.00250964f, 
    0.19667166f, 0.06304976f, 0.16029881f, 0.06379266f, -0.04248286f, 0.00336534f, -0.19935361f, -0.10518860f, 
    -0.00693878f, 0.12692904f, 0.03227366f, 0.00118005f, 0.23749371f, -0.01209921f, 0.08513699f, -0.18014710f, 
    0.12894295f, -0.04517676f, -0.07859647f, -0.09329657f, -0.05225985f, 0.03951795f, 0.04639683f, -0.11068145f, 
    -0.07372705f, -0.17467658f, 0.00462313f, 0.23961784f, 0.13775323f, 0.05660722f, 0.04507003f, 0.17469738f, 
    0.05901220f, 0.11985257f, -0.08099775f, -0.02882581f, -0.07941526f, -0.24014592f, 0.07391532f, 0.22944723f, 
    0.09284869f, 0.16060679f, 0.09544426f, 0.12513302f, -0.05623426f, -0.15486214f, -0.00118608f, -0.09615699f, 
    0.12574637f, -0.11151148f, 0.15038827f, 0.17528306f, 0.00332400f, -0.11236376f, -0.06931008f, -0.18087865f, 
    0.04014941f, -0.17079738f, 0.11626016f, -0.07859927f, -0.03803324f, -0.18087319f, -0.03639947f, 0.15537333f, 
    0.06248183f, 0.10886616f, 0.07812198f, 0.07016670f, -0.06487732f, -0.02325107f, -0.01722539f, -0.09921621f, 
    0.05192766f, 0.10926951f, -0.20844005f, -0.22019473f, 0.06147686f, 0.08025826f, -0.02884374f, -0.05995102f, 
    -0.15846710f, -0.03911268f, 0.08484972f, -0.06342011f, -0.08731376f, -0.03218156f, -0.08768285f, 0.21615005f, 
    0.02632864f, -0.04703854f, -0.10182150f, -0.05008247f, -0.01618368f, 0.21141398f, 0.13286194f, 0.01061674f, 
    0.06272004f, 0.17267852f, -0.03329225f, 0.04472569f, 0.05032171f, -0.03497273f, -0.01514065f, 0.02035574f, 
    -0.08754055f, -0.15626845f, 0.07855008f, 0.02446787f, 0.15714183f, 0.05300499f, -0.13722569f, -0.20120633f, 
    0.12860049f, 0.02501666f, 0.08360676f, 0.03782668f, 0.05970285f, 0.01269720f, -0.02052522f, 0.03485456f, 
    0.00429721f, 0.07499452f, 0.21252488f, 0.05426476f, 0.04504340f, -0.01866379f, -0.02617421f, 0.02273948f, 
    0.19525877f, -0.09730144f, 0.17254232f, 0.13231175f, 0.26695615f, -0.34963113f, -0.19585085f, 0.21585885f, 
    0.02945630f, 0.04695838f, 0.07153178f, -0.08920186f, 0.07525989f, 0.03403815f, -0.05781772f, 0.04309043f, 
    -0.01470514f, -0.03515781f, 0.02859895f, 0.32164136f, -0.14700152f, 0.03400161f, -0.03005365f, 0.02400837f, 
    0.02596727f, -0.03489850f, 0.00353685f, 0.02067707f, 0.06475556f, 0.00512512f, 0.02447316f, 0.00150883f, 
    0.09794480f, 0.04283503f, 0.05860793f, 0.03907689f, 0.10643996f, 0.03296033f, 0.04307783f, 0.04028276f, 
    -0.09813034f, -0.00470091f, 0.05697080f, 0.13071066f, 0.06277709f, -0.06656809f, -0.03893732f, -0.13019495f, 
    -0.04764478f, -0.05582217f, 0.02148777f, -0.00729360f, 0.10301328f, -0.02007495f, 0.06677704f, -0.00623347f, 
    -0.00651052f, 0.03456799f, -0.01379166f, 0.01809365f, 0.14697506f, -0.01722532f, -0.12014439f, 0.00819411f, 
    -0.10585172f, 0.01816056f, -0.05614492f, 0.05022635f, -0.03678707f, -0.02822465f, -0.18741007f, 0.04713514f, 
    0.03551819f, 0.02052969f, -0.16131216f, 0.02295806f, -0.17491427f, -0.08800888f, -0.04352843f, 0.06940488f, 
    0.11060055f, 0.05555850f, -0.18845586f, -0.25924379f, -0.02700933f, 0.02503265f, -0.01465085f, -0.08798563f, 
    -0.03959096f, 0.10432549f, 0.10836363f, 0.04366346f, -0.09353770f, 0.02286056f, 0.12338039f, 0.00217321f, 
    0.08149251f, 0.08447330f, 0.03558403f, 0.08906139f, -0.14000197f, 0.00451202f, -0.00269553f, -0.01565674f, 
    -0.07200885f, -0.09493069f, 0.01348359f, -0.00666990f, 0.01529320f, 0.01276758f, 0.05836522f, 0.09959189f, 
    0.10786990f, -0.03900134f, 0.23141871f, 0.06419729f, -0.07479431f, -0.05424404f, 0.02721263f, -0.14652385f, 
    0.15565585f, -0.00001848f, -0.04053994f, -0.03437999f, -0.02132947f, -0.10166717f, -0.10316982f, 0.02675946f, 
    -0.12989613f, 0.11697476f, 0.00721655f, -0.24308763f, -0.00564311f, -0.25567439f, 0.04778119f, -0.01488977f, 
    0.01878888f, -0.15926103f, 0.02762099f, 0.18215933f, -0.18948077f, -0.05013626f, -0.04776278f, -0.19580376f, 
    -0.10085490f, 0.09351462f, -0.03171958f, -0.07183370f, -0.13265452f, 0.11910658f, -0.14136384f, -0.02855205f, 
    0.03267821f, -0.11010019f, 0.07270998f, -0.05818221f, -0.02033147f, -0.00510546f, 0.12742649f, 0.30351630f, 
    0.12280758f, 0.01399340f, 0.24850653f, 0.18555127f, -0.18705490f, -0.14489311f, -0.14322361f, -0.10618365f, 
    -0.20930280f, 0.00299597f, -0.05339899f, -0.00159120f, -0.15655187f, -0.05088622f, -0.01840490f, -0.18491401f, 
    0.01638871f, 0.05862447f, 0.02523637f, -0.03850469f, -0.07946196f, 0.04810730f, 0.03506695f, -0.10583260f, 
    -0.14872281f, -0.31301138f, -0.78795290f, 0.02589430f, 0.08255211f, 0.10673124f, 0.07348128f, -0.04629087f, 
    0.03257084f, 0.04640314f, 0.04073283f, 0.01981055f, -0.12251235f, -0.14801911f, -0.02170154f, -0.01281931f, 
    -0.14016749f, -0.10283561f, -0.21917409f, -0.20308104f, -0.05448940f, -0.00496496f, -0.09786408f, 0.09401327f, 
    -0.02224698f, 0.04995220f, -0.16415538f, -0.05900829f, 0.01968461f, 0.00311943f, -0.05007669f, 0.08897161f, 
    -0.10038967f, 0.01665260f, -0.16280653f, -0.04511434f, -0.10193189f, -0.00643164f, 0.04984671f, 0.08688801f, 
    -0.09938212f, -0.18835315f, 0.03490121f, 0.15741818f, 0.03424044f, 0.07343865f, -0.02306704f, 0.00134553f, 
    0.11462304f, 0.05119472f, 0.08181958f, 0.10148543f, -0.08416688f, 0.03002856f, 0.05634310f, 0.27478069f, 
    0.02373368f, -0.00931131f, 0.07279335f, 0.00527492f, 0.06382754f, 0.07304781f, -0.52381724f, -0.17866014f, 
    0.01729584f, 0.05695182f, 0.03405485f, 0.05216674f, 0.10001649f, -0.00741116f, 0.00082303f, -0.02614877f, 
    -0.01836328f, 0.07490997f, 0.10586350f, 0.06826565f, -0.00452518f, -0.02604879f, -0.03258580f, -0.14728434f, 
    0.09815277f, -0.02534119f, 0.15575024f, 0.25596526f, 0.02832864f, 0.06208578f, 0.00924675f, 0.14079006f, 
    -0.19606136f, 0.08357393f, -0.18000083f, 0.29275417f, -0.15853454f, -0.03468879f, 0.15204878f, -0.03143496f, 
    0.13103870f, -0.02564435f, -0.36831361f, -0.09082100f, -0.26129249f, -0.21701495f, 0.13494518f, -0.01042054f, 
    0.01404396f, -0.16078252f, 0.04449581f, -0.09620150f, -0.22060622f, 0.13155495f, -0.20147014f, -0.35951027f, 
    0.09352501f, 0.05482034f, -0.04989849f, 0.08560809f, 0.06326432f, 0.11840372f, -0.02748430f, -0.17001624f, 
    -0.53535974f, -0.52762312f, 0.13752273f, -0.18880314f, 0.06739966f, 0.17145309f, -0.12248989f, 0.04014860f, 
    0.01873660f, -0.18462209f, -0.04217067f, -0.10806718f, -0.15783717f, -0.23455086f, 0.08188565f, -0.14219390f, 
    -0.12072144f, 0.00600039f, -0.01026536f, 0.15675962f, 0.00270444f, 0.00080135f, -0.06170202f, -0.06493759f, 
    -0.32709986f, -0.09755468f, -0.06981847f, -0.09333438f, 0.03549842f, 0.09914925f, -0.02763295f, 0.12335956f, 
    -0.00364053f, 0.10511532f, -0.09684944f, -0.00587116f, -0.14807777f, -0.07978525f, 0.00175158f, 0.06153858f, 
    -0.15577026f, 0.00076330f, -0.04820877f, 0.15357718f, 0.02526365f, -0.05574703f, 0.00121543f, -0.05252744f, 
    0.33729059f, -0.04519009f, -0.02782161f, 0.04629227f, 0.11417165f, -0.03680624f, 0.03142981f, -0.13645366f, 
    -0.02007909f, -0.09881750f, -0.03814797f, -0.25643578f, 0.00042177f, -0.03785727f, 0.04539052f, 0.05411205f, 
    0.11707043f, 0.09250192f, 0.06466097f, 0.01380975f, 0.06732992f, 0.07579375f, -0.10243070f, -0.03045225f, 
    -0.01138452f, -0.10919249f, -0.10368562f, -0.13391753f, -0.05085755f, 0.04403997f, 0.05401951f, 0.14827240f, 
    0.05086114f, -0.06776984f, -0.05757080f, -0.06252556f, 0.12497681f, 0.04482812f, -0.13149062f, 0.13530689f, 
    -0.03380388f, -0.07913212f, -0.02048904f, -0.05371198f, 0.11359731f, -0.18129751f, -0.00578635f, 0.18373705f, 
    0.00146863f, 0.11438630f, 0.06445847f, 0.10361652f, -0.00101309f, -0.01367787f, -0.00416704f, -0.20094509f, 
    0.05143572f, 0.01456259f, 0.10210413f, 0.04392892f, 0.14231515f, 0.27622083f, -0.10149055f, 0.24784507f, 
    0.22550341f, 0.12559040f, 0.05875710f, 0.08955117f, 0.10436557f, -0.00703190f, -0.07494651f, 0.02096416f, 
    0.09462794f, 0.06376009f, -0.00413935f, -0.02292411f, 0.01753261f, 0.00708594f, -0.00172040f, -0.03354216f, 
    0.09245951f, -0.16257015f, -0.01895781f, -0.06551278f, 0.12539205f, -0.16661121f, -0.03444574f, -0.07989656f, 
    -0.00007453f, 0.05144719f, 0.04740960f, -0.05359501f, -0.23561507f, 0.08734258f, -0.15153018f, 0.06347071f, 
    -0.03430093f, 0.13886973f, -0.20161583f, 0.06087073f, 0.00774995f, -0.07269362f, 0.07122871f, -0.14367087f, 
    0.15089437f, -0.13084461f, 0.06783658f, 0.31315336f, -0.19858296f, -0.15475127f, -0.13589351f, -0.11151306f, 
    -0.02594931f, -0.07509766f, 0.04279134f, -0.04218239f, 0.04321705f, -0.26260993f, 0.00705900f, -0.01707481f, 
    0.13811368f, 0.26266131f, -0.17747526f, 0.10791218f, -0.03285412f, -0.00381288f, 0.01609556f, -0.07695322f, 
    0.04474572f, 0.00916787f, 0.08749900f, 0.00852677f, 0.06011199f, 0.21219383f, 0.05667024f, 0.09703124f, 
    -0.06222138f, -0.03386125f, -0.04212398f, -0.00471840f, -0.00360424f, -0.13085748f, -0.13885611f, 0.05335647f, 
    0.01306664f, 0.01694175f, -0.09346923f, 0.12782061f, -0.05425836f, -0.03198416f, -0.08633748f, 0.08598716f, 
    0.01559204f, 0.00125305f, -0.04713881f, -0.17025758f, 0.04909837f, 0.24804324f, 0.13592413f, 0.15068921f, 
    -0.12554505f, 0.05724518f, 0.01029401f, -0.03803847f, 0.03923318f, 0.03585353f, 0.04263430f, 0.13080062f, 
    -0.01012413f, 0.12930700f, -0.05251998f, 0.12372350f, 0.02189352f, 0.17190363f, -0.04801409f, 0.04928457f, 
    -0.03591042f, 0.02422251f, -0.02933561f, -0.04908538f, 0.03554350f, 0.07079143f, 0.00294152f, 0.20296687f, 
    0.09454403f, -0.01615971f, 0.10198601f, -0.13166894f, -0.00942258f, -0.14940365f, 0.19401619f, -0.06459686f, 
    0.02512007f, -0.13188124f, -0.12968531f, 0.16397108f, 0.07486346f, -0.16295205f, -0.04068822f, -0.03458187f, 
    0.01355976f, 0.23500790f, -0.06632814f, 0.08574197f, 0.18822461f, -0.00275950f, 0.03131204f, 0.02459992f, 
    -0.00150385f, -0.00093091f, -0.05167290f, -0.04772577f, 0.05726957f, -0.05257492f, -0.08546600f, -0.03552202f, 
    0.04968034f, 0.02490055f, -0.06180031f, -0.03908829f, 0.00240327f, -0.05964224f, 0.00443813f, 0.03945038f, 
    0.04753353f, 0.01946525f, -0.12570094f, -0.17745402f, -0.38055855f, -0.06160760f, 0.25033593f, 0.06578680f, 
    -0.12865315f, -0.07017890f, 0.00865684f, -0.06771451f, -0.04315596f, -0.06389417f, -0.09914166f, 0.07802247f, 
    0.00452544f, -0.62600583f, -0.02224436f, -0.08058817f, -0.14747597f, -0.04260231f, -0.09477213f, 0.03438298f, 
    -0.14149380f, -0.05773489f, -0.21458647f, 0.15917885f, -0.05818938f, -0.02692208f, 0.04438455f, 0.05179929f, 
    -0.03098235f, -0.05469442f, 0.02743967f, -0.02448719f, 0.04701493f, 0.02738085f, -0.00434109f, 0.01258762f, 
    0.15506621f, 0.31917542f, 0.13447081f, 0.22104825f, 0.13819614f, -0.01351887f, 0.11578903f, 0.01846443f, 
    0.06534301f, -0.04070790f, 0.02301365f, -0.07834006f, 0.04522590f, -0.10233402f, -0.19664663f, 0.22790469f, 
    -0.07509598f, 0.03230707f, -0.13805439f, -0.02504914f, 0.14275426f, 0.00645705f, -0.00694360f, -0.01312825f, 
    -0.11760750f, 0.20745344f, -0.16668920f, 0.32119742f, 0.02448931f, -0.03764846f, -0.10661829f, -0.30593523f, 
    -0.00824753f, 0.03822158f, 0.02468653f, -0.12737365f, 0.19328724f, 0.04028997f, -0.20546398f, 0.07234139f, 
    0.00581620f, -0.03106473f, 0.12719628f, 0.03200844f, -0.12037551f, -0.16039471f, -0.03151432f, -0.08674797f, 
    0.12938607f, 0.34928751f, 0.24798694f, 0.16980362f, -0.11112513f, -0.04661684f, -0.06703755f, 0.02404253f, 
    0.06412078f, 0.08979727f, 0.03470998f, -0.01529089f, 0.03444172f, 0.39580071f, 0.14845259f, 0.21342325f, 
    -0.00771641f, 0.14267635f, 0.04444712f, 0.09377567f, 0.03690857f, -0.03987573f, -0.02190387f, -0.02666261f, 
    -0.03731239f, 0.07549831f, -0.03635865f, -0.03263713f, 0.04221733f, -0.08747458f, -0.05359937f, -0.07383365f, 
    0.03987757f, 0.06329426f, -0.02030165f, -0.10515729f, 0.00636434f, 0.09255575f, 0.15561692f, 0.16846345f, 
    -0.09222327f, 0.00263087f, 0.00656440f, 0.13330182f, -0.05379827f, 0.04418596f, 0.00098088f, 0.02111699f, 
    0.18897375f, -0.05451754f, -0.05108063f, -0.04375807f, -0.04436921f, -0.03867511f, -0.10030094f, 0.06161852f, 
    0.01264645f, -0.00979715f, -0.20535523f, -0.01536224f, 0.11138626f, -0.02739812f, -0.12448618f, 0.10861746f, 
    -0.01850484f, 0.04026001f, -0.08262669f, -0.08572096f, 0.02286635f, -0.44788811f, -0.24987391f, -0.12274070f, 
    -0.24872059f, -0.20703481f, -0.03708392f, -0.02136247f, -0.01348569f, 0.07910607f, -0.01872933f, 0.15834486f, 
    0.01661002f, 0.15884350f, 0.04468878f, -0.08792244f, -0.54450738f, 0.03092055f, -0.28149062f, 0.08707342f, 
    -0.01348958f, -0.07440608f, 0.02458288f, -0.01994093f, 0.03516136f, 0.02514824f, -0.04734812f, 0.15428734f, 
    -0.01687869f, -0.26485851f, -0.17848484f, -0.21113274f, 0.04978094f, 0.04434371f, 0.01666063f, -0.00659214f, 
    -0.07032038f, -0.18014088f, 0.21246336f, -0.08276947f, 0.24314713f, -0.10915905f, -0.16728069f, 0.10638560f, 
    0.01997420f, 0.06778170f, -0.04959064f, 0.11789096f, 0.02678958f, 0.02011429f, -0.03340757f, -0.01699372f, 
    -0.19097747f, 0.00691688f, -0.01246164f, -0.00469550f, 0.16155140f, -0.08776167f, -0.03456622f, 0.02016235f, 
    0.01889518f, -0.07703456f, 0.11046797f, -0.15505676f, -0.16606545f, -0.16515616f, -0.01790855f, -0.01889775f, 
    0.01786065f, -0.05659260f, -0.06642972f, -0.02261410f, -0.04266947f, -0.03317181f, 0.07110403f, 0.09835774f, 
    0.32176450f, 0.06067237f, 0.24491327f, 0.21133001f, 0.00330506f, -0.08102798f, 0.09763172f, 0.00432360f, 
    0.07541928f, 0.01725727f, 0.07687810f, 0.05001142f, -0.00211264f, 0.09185039f, 0.07896851f, 0.24714166f, 
    0.03820939f, -0.04399999f, -0.07018495f, 0.06694523f, 0.01887286f, 0.08308386f, 0.03348311f, 0.00850760f, 
    0.05162114f, 0.00223115f, -0.06359189f, 0.22218677f, -0.03651641f, -0.06890105f, -0.15013441f, -0.20439659f, 
    -0.13621049f, 0.10806834f, -0.00547131f, 0.17453620f, 0.23597996f, 0.05803019f, -0.33367199f, 0.10009643f, 
    -0.03144166f, -0.06198757f, 0.00557392f, 0.12264557f, 0.10209806f, -0.24150908f, -0.16793907f, 0.12513562f, 
    -0.08860505f, -0.23644669f, -0.12763928f, 0.08854839f, 0.11009791f, 0.00941929f, -0.08311320f, 0.15354896f, 
    -0.06308740f, -0.02214497f, 0.04119200f, 0.10090204f, -0.03562092f, 0.10912310f, -0.03339573f, -0.16807543f, 
    0.03674900f, -0.05245664f, 0.00095455f, 0.01665560f, 0.01486449f, -0.03426320f, 0.03491635f, 0.06725649f, 
    -0.00667994f, -0.08473299f, 0.08717908f, -0.11950447f, 0.25130123f, 0.01112941f, 0.05606374f, 0.12011024f, 
    0.00433133f, 0.08741478f, 0.15897220f, -0.02620374f, 0.01082382f, -0.20092089f, -0.06560067f, 0.17914052f, 
    0.03736681f, -0.24297732f, 0.08237498f, 0.15413339f, -0.08710325f, 0.03809286f, -0.00585841f, -0.06402931f, 
    -0.36819762f, 0.00347049f, 0.31923428f, 0.09638829f, 0.14795254f, -0.16303629f, -0.06577992f, 0.15938520f, 
    0.06804776f, -0.08014058f, 0.08310067f, 0.00982203f, 0.23250853f, -0.02293487f, -0.21284263f, 0.02836311f, 
    -0.00622538f, 0.01891650f, 0.07713986f, 0.07562789f, 0.02353163f, -0.24993148f, -0.40957540f, -0.58085471f, 
    0.31492987f, -0.15223618f, 0.24888235f, 0.00778236f, 0.28498343f, 0.20776163f, -0.10881332f, 0.23968634f, 
    0.03135999f, 0.04996708f, 0.03407923f, 0.14338234f, -0.07103764f, 0.31562176f, -0.12939866f, -0.43961221f, 
    0.02552692f, 0.04259467f, -0.04526466f, 0.07962785f, 0.13861071f, 0.04591268f, -0.05146730f, -0.11980203f, 
    -0.21750177f, -0.16029820f, -0.08926070f, 0.16973832f, 0.05080277f, 0.01535064f, 0.06144095f, 0.05699751f, 
    0.00596046f, 0.10250687f, -0.00192143f, -0.06290542f, 0.09610003f, 0.07803975f, 0.00712377f, -0.06785524f, 
    0.18985872f, -0.07048795f, 0.04051148f, 0.05302496f, 0.04446017f, 0.02051418f, -0.06590413f, 0.10476310f, 
    0.23978643f, -0.08216529f, 0.02031313f, -0.02403247f, 0.20634364f, -0.10425164f, -0.14575072f, 0.07258283f, 
    0.11437076f, 0.12952858f, -0.09247195f, 0.14994712f, -0.13923280f, -0.15360409f, -0.11987967f, -0.04330561f, 
    0.14842860f, -0.00883632f, -0.02130254f, 0.08779890f, -0.00045781f, 0.02073282f, 0.01199201f, -0.01950016f, 
    -0.08713645f, -0.01155241f, -0.06488712f, -0.05389897f, 0.16645098f, 0.09673582f, 0.06997129f, 0.09293151f, 
    0.03446900f, -0.01704973f, -0.01344989f, 0.08138959f, 0.15466624f, -0.08952895f, -0.13018374f, 0.11717052f, 
    -0.01041773f, 0.02116046f, 0.04094952f, -0.01645220f, 0.08690755f, 0.03689859f, 0.07169964f, 0.03903636f, 
    -0.04797827f, 0.11574755f, 0.53054535f, -0.14782368f, 0.08968311f, -0.06364567f, 0.02528046f, -0.01378056f, 
    -0.01263547f, -0.16939913f, -0.39382526f, 0.10810840f, 0.00763375f, -0.10384035f, -0.10267320f, -0.07103656f, 
    0.04792893f, -0.12203591f, -0.26733339f, -0.14803062f, -0.08363767f, 0.04381302f, 0.05461408f, -0.04190550f, 
    -0.51186067f, -0.43523201f, 0.18982355f, 0.02105840f, 0.07010710f, -0.10840505f, -0.02725662f, 0.08580014f, 
    0.07140148f, 0.01789692f, -0.10595302f, 0.07937371f, -0.03525808f, -0.35424870f, -0.29798546f, 0.07035592f, 
    0.07281630f, -0.00347608f, 0.01756974f, -0.01854376f, -0.11173734f, -0.09366012f, 0.18278287f, 0.12687375f, 
    0.00903872f, 0.03736853f, -0.01889501f, -0.10064253f, -0.00613556f, -0.06560160f, 0.11461784f, -0.02121194f, 
    -0.07827442f, 0.05691278f, 0.02698753f, 0.14414963f, 0.18730758f, -0.04457537f, -0.00033277f, -0.05897259f, 
    0.08365937f, -0.03168010f, -0.04432165f, -0.01547535f, 0.01236726f, 0.06084809f, 0.06500058f, 0.06849857f, 
    -0.00949254f, -0.32831523f, 0.12333278f, 0.11527317f, -0.03826547f, -0.08211186f, 0.08404990f, -0.03554146f, 
    -0.03084359f, -0.20626436f, 0.18896063f, 0.01932299f, -0.48098445f, -0.05774347f, 0.12077625f, -0.15452869f, 
    -0.02987073f, -0.04001232f, 0.11743183f, 0.08100637f, -0.00558674f, -0.23074345f, 0.02483227f, 0.00042865f, 
    -0.01459816f, -0.03763820f, 0.05818389f, 0.06338083f, -0.11194377f, -0.00125876f, -0.06937534f, -0.03871413f, 
    0.11995447f, -0.03725981f, 0.17381164f, -0.01452296f, 0.08976790f, -0.18875022f, -0.12970865f, 0.03234824f, 
    0.03189844f, -0.03930110f, -0.03310330f, -0.04224728f, -0.09039894f, 0.23359771f, -0.00146224f, -0.08779231f, 
    0.30892980f, -0.09467646f, -0.34769464f, 0.30834478f, 0.14628348f, 0.03225749f, -0.11223011f, 0.00496578f, 
    0.10882230f, 0.03696196f, -0.03323032f, 0.10967362f, -0.55435705f, 0.02115746f, 0.12934695f, 0.12056246f, 
    0.03109747f, 0.07070321f, -0.00374941f, -0.01859181f, 0.06175352f, -0.06091455f, 0.13429654f, -0.21388862f, 
    0.00965305f, 0.04396586f, -0.04138004f, -0.16966535f, 0.03535829f, -0.06024899f, 0.11898313f, -0.05469105f, 
    0.12343088f, 0.04257958f, -0.02110958f, -0.06780100f, -0.16098778f, -0.15003383f, -0.08833754f, -0.06143484f, 
    -0.04942128f, 0.05570937f, 0.05947297f, -0.02053731f, -0.00928858f, 0.00542553f, 0.10612553f, -0.01815667f, 
    -0.10577992f, -0.17180508f, -0.07030709f, 0.00352070f, 0.02909813f, -0.01439838f, -0.00732959f, 0.03608560f, 
    0.16583453f, 0.04445938f, 0.18627046f, 0.04486244f, 0.16826898f, -0.18083984f, -0.26129782f, 0.05040357f, 
    0.00284679f, 0.00084618f, 0.03381065f, -0.01613705f, -0.04748667f, -0.16550033f, -0.18902235f, 0.02629127f, 
    -0.12942573f, 0.05600569f, -0.02809612f, 0.13312955f, -0.02750481f, 0.02696981f, -0.10748807f, 0.06430726f, 
    -0.13753648f, -0.07929966f, 0.08526465f, -0.40114671f, -0.46116975f, 0.37016436f, -0.36888096f, 0.20756577f, 
    -0.02337899f, 0.00129422f, 0.10067027f, 0.07824557f, 0.26666701f, 0.05239353f, -0.12990925f, -0.11121988f, 
    -0.05389378f, -0.12879653f, -0.07704127f, 0.08913597f, 0.11796421f, -0.03751966f, -0.02852708f, 0.20764744f, 
    -0.00321070f, 0.06410874f, 0.00803791f, -0.10087717f, -0.39298871f, -0.10705891f, -0.20375299f, -0.23263696f, 
    0.00846772f, 0.01328930f, -0.04827381f, 0.06168235f, 0.03689912f, -0.07566277f, -0.02013356f, -0.01512855f, 
    -0.03516041f, 0.03182525f, -0.10598031f, 0.04017447f, 0.24990168f, 0.15934359f, -0.08432954f, 0.02582075f, 
    -0.02736947f, -0.03226003f, 0.06313197f, 0.08846823f, -0.06846153f, 0.08510128f, 0.08727369f, -0.09042164f, 
    -0.03444548f, -0.04052573f, -0.12130660f, -0.18449229f, 0.01069549f, -0.05655655f, -0.01884311f, -0.03777014f, 
    -0.19393659f, -0.26385593f, -0.01879043f, 0.01186649f, 0.10012459f, -0.01024841f, 0.12272888f, 0.02169700f, 
    -0.01743829f, -0.00067619f, 0.00644889f, 0.13924262f, 0.05807685f, 0.32687467f, 0.00700243f, -0.05242479f, 
    0.07217337f, -0.17214012f, -0.07185666f, -0.12661837f, 0.02982093f, -0.00797075f, -0.01028463f, -0.03334751f, 
    -0.41248521f, -0.00855897f, 0.40790188f, -0.23510079f, -0.05033388f, 0.00219237f, -0.03750097f, 0.10352931f, 
    0.14522500f, 0.00127110f, 0.17193122f, -0.20274535f, -0.13913265f, -0.24605131f, -0.01492215f, -0.05093399f, 
    -0.16262501f, 0.13876599f, 0.08877441f, -0.21642205f, 0.17306080f, -0.00984553f, 0.17723863f, 0.00538944f, 
    0.06262361f, -0.10242504f, 0.01772715f, 0.11709497f, -0.10356358f, -0.03891463f, 0.02184721f, 0.05723099f, 
    0.03908074f, 0.02473117f, 0.13455136f, 0.13746722f, -0.03319705f, -0.04199719f, -0.50948966f, -0.43763044f, 
    0.01230934f, 0.13910221f, -0.17662410f, 0.00719889f, 0.04075746f, -0.09664323f, 0.04653354f, 0.02042594f, 
    0.24926685f, -0.13579664f, 0.11081055f, -0.05297327f, 0.09101783f, -0.06280682f, -0.00728930f, 0.01986759f, 
    -0.20672499f, 0.05498196f, -0.13748062f, -0.06515677f, -0.18265466f, 0.20722573f, -0.46536040f, -0.28771031f, 
    0.02898202f, 0.09610580f, -0.16154309f, 0.12757529f, 0.04587645f, 0.15149155f, -0.05883249f, -0.08572932f, 
    0.04223788f, 0.10832538f, 0.00167370f, 0.01066084f, 0.15919934f, -0.03498725f, -0.05165445f, 0.20067920f, 
    0.05768662f, -0.00168083f, 0.02871179f, 0.05803109f, 0.05094558f, -0.09366122f, -0.01444132f, 0.25781631f, 
    0.04464163f, -0.01195288f, 0.06298646f, 0.07958086f, -0.07645317f, 0.06377289f, -0.05528564f, -0.00872307f, 
    -0.23833215f, 0.25067919f, -0.23919989f, 0.18665290f, 0.13611212f, -0.20684747f, 0.13094640f, 0.24264330f, 
    -0.09714454f, -0.13906612f, 0.04655673f, 0.00048912f, -0.35718831f, -0.25539270f, -0.06241535f, 0.31584731f, 
    0.01122069f, -0.21833992f, -0.02951018f, 0.08517348f, 0.05785251f, -0.04086872f, -0.03673866f, 0.17524396f, 
    0.09220897f, 0.12178336f, 0.03149733f, -0.06312793f, 0.01959112f, 0.14335698f, -0.06611545f, -0.26392975f, 
    -0.12156668f, -0.11524917f, -0.02593686f, 0.02199803f, -0.04334302f, -0.07785444f, -0.12663165f, 0.12585792f, 
    0.09212989f, -0.07009745f, -0.03805684f, -0.13528571f, -0.02718190f, 0.02699606f, -0.01601960f, 0.08979576f, 
    -0.32125124f, 0.29786751f, 0.00010806f, -0.62009984f, 0.13997544f, 0.19479536f, 0.00963109f, -0.10172657f, 
    0.03828353f, 0.02150183f, -0.05157815f, 0.06783825f, 0.01309197f, 0.14474797f, 0.11269274f, -0.14623417f, 
    0.13922015f, 0.10094058f, -0.01221753f, -0.21823180f, 0.11840456f, -0.00234320f, 0.03865291f, 0.10261336f, 
    -0.18382658f, 0.06655372f, 0.01118551f, -0.08951878f, 0.02061768f, 0.01634265f, 0.07306709f, -0.08869012f, 
    0.13725334f, 0.10999344f, -0.04493432f, 0.01693154f, -0.05584067f, 0.12254493f, -0.00396948f, -0.07523593f, 
    -0.09694456f, 0.17054807f, 0.01505047f, -0.15002982f, 0.03809308f, 0.10373069f, 0.35096866f, 0.00329480f, 
    0.18618354f, 0.14531139f, 0.09680779f, 0.13702795f, 0.00477114f, -0.03694383f, 0.00900033f, 0.12431032f, 
    -0.04756432f, -0.00401960f, 0.11250406f, -0.02259923f, 0.09132950f, 0.07862554f, -0.08731411f, 0.02517600f, 
    0.08355506f, -0.02120680f, 0.00933058f, -0.04231368f, -0.04802882f, -0.01243268f, 0.03697492f, -0.15811191f, 
    -0.14535333f, 0.19220141f, 0.18130536f, 0.00562642f, 0.03540046f, -0.03871422f, -0.07302247f, 0.02790598f, 
    0.01209984f, 0.06646431f, 0.08706848f, 0.05955100f, 0.21489193f, -0.12707478f, -0.15334375f, -0.16956498f, 
    -0.00572565f, 0.10693716f, 0.09888706f, 0.02436550f, -0.01941131f, 0.16139813f, -0.05973646f, 0.03383191f, 
    -0.29233074f, -0.14362489f, -0.19409913f, 0.10561185f, -0.00457969f, 0.09273925f, 0.00920649f, 0.12859172f, 
    -0.03136390f, -0.00858551f, 0.02304266f, 0.01081469f, 0.09743415f, -0.02536305f, -0.08832310f, -0.00765175f, 
    0.05080915f, -0.01082837f, 0.00704995f, -0.00479702f, -0.03550244f, -0.10743252f, -0.23121242f, -0.09197149f, 
    -0.59545249f, -0.32979426f, -0.45210469f, -0.25740415f, 0.12887837f, 0.01720801f, 0.13457799f, -0.14533041f, 
    -0.00662588f, 0.00444492f, 0.03590751f, 0.03340859f, -0.53186852f, 0.25891587f, 0.37571147f, -0.09337227f, 
    -0.02027552f, 0.04556974f, -0.00675492f, 0.03136134f, 0.03070078f, 0.03776883f, 0.13479833f, 0.05721094f, 
    0.23373729f, 0.00977075f, -0.09838157f, -0.10045880f, 0.12931611f, 0.01908696f, 0.09058099f, 0.01414499f, 
    -0.06047422f, 0.08383734f, 0.01422567f, -0.04060132f, 0.38261545f, 0.15306546f, -0.10905380f, 0.05660909f, 
    -0.01586056f, -0.10080202f, 0.06869906f, 0.08604840f, 0.17409341f, 0.04389345f, -0.08060428f, -0.08518780f, 
    -0.61402726f, -0.18786965f, 0.03865836f, 0.73476994f, -0.10761901f, -0.21242192f, 0.09809009f, 0.00452489f, 
    -0.00712130f, 0.05515330f, -0.02819811f, -0.05207567f, -0.39844948f, -0.59414959f, -0.48737276f, -0.33039701f, 
    -0.05950959f, -0.15482183f, -0.03389950f, -0.21979451f, -0.01050017f, -0.02224635f, -0.01426381f, 0.02959175f, 
    -0.13632306f, -0.14524771f, -0.07424178f, 0.24215713f, 0.07062244f, 0.09609159f, 0.14802009f, -0.20562087f, 
    0.00694706f, 0.02759602f, 0.00213403f, -0.01589320f, 0.13855408f, -0.08440212f, -0.17855456f, 0.12432081f, 
    -0.11416908f, 0.13038114f, -0.02353365f, 0.08250921f, 0.07361905f, 0.01021456f, 0.10482798f, -0.00744320f, 
    0.10668384f, -0.16119298f, 0.29253307f, -0.10812357f, 0.12967654f, -0.08579090f, -0.05705698f, 0.06134979f, 
    -0.09416686f, 0.01291510f, 0.09555529f, -0.18530478f, 0.30013922f, 0.11290622f, -0.17767730f, -0.00022793f, 
    -0.06592497f, 0.00737542f, 0.03550852f, 0.07803538f, 0.05718948f, 0.11876694f, 0.32938379f, 0.08134075f, 
    -0.21653894f, -0.64614761f, -0.22577408f, 0.27824572f, -0.17010242f, -0.00757360f, 0.15291776f, 0.14881599f, 
    0.01480176f, -0.08039161f, -0.00693936f, -0.07626758f, -0.65401173f, -0.41143838f, -0.00795728f, 0.34284988f, 
    0.16590928f, 0.09946206f, -0.05387130f, -0.06505824f, 0.02351946f, 0.06315514f, 0.02283142f, 0.12003938f, 
    0.02386527f, -0.01574512f, 0.13693315f, -0.11967988f, 0.04122268f, 0.00994239f, 0.02800970f, 0.04419269f, 
    -0.00370266f, -0.08527157f, -0.00506754f, -0.03338627f, -0.15337186f, -0.50340992f, -0.01836231f, -0.06459297f, 
    -0.01644801f, 0.09129819f, 0.13552001f, -0.11110132f, 0.00024163f, 0.09571560f, -0.09939072f, 0.02442082f, 
    0.09076496f, 0.08120903f, -0.17706251f, 0.05592221f, -0.06910902f, 0.00365592f, 0.06778979f, 0.04858168f, 
    -0.06714216f, -0.03018356f, -0.07979671f, 0.09970453f, 0.00714963f, 0.05357898f, 0.08523695f, 0.10451735f, 
    -0.06161941f, 0.04459068f, -0.01013182f, 0.14286791f, 0.03107564f, 0.03868981f, -0.08340085f, 0.13095564f, 
    0.09634822f, 0.00507334f, 0.04096169f, -0.04337903f, -0.11420454f, -0.18744886f, 0.00062564f, -0.12220822f, 
    -0.00592898f, -0.04408563f, -0.01048615f, -0.06986157f, -0.01039906f, 0.03082971f, -0.07161760f, -0.39325488f, 
    -0.01003487f, -0.00837593f, 0.06104203f, -0.04342069f, -0.02558153f, 0.03346327f, 0.00151162f, -0.09672860f, 
    -0.02371865f, -0.45423403f, -0.06447405f, -0.02035541f, -0.07087938f, 0.06048394f, 0.02706992f, 0.07095288f, 
    -0.02959579f, 0.02451101f, 0.16637753f, 0.20281945f, -0.06725392f, 0.03060151f, -0.00808438f, -0.00527780f, 
    0.11107551f, -0.00424516f, 0.03756978f, -0.00152709f, 0.03639626f, 0.01252727f, 0.10316466f, 0.03415160f, 
    -0.04875905f, -0.27390242f, -0.01030281f, 0.24462384f, 0.08177578f, -0.12451831f, 0.07219687f, 0.01354316f, 
    -0.09777918f, 0.08513819f, -0.01893022f, 0.05709640f, -0.07741858f, 0.04661199f, 0.08861709f, -0.19599076f, 
    0.03775365f, 0.04746146f, 0.10038982f, -0.06212771f, 0.02632668f, -0.04039372f, -0.00264421f, 0.08704537f, 
    -0.19864051f, -0.01353850f, -0.05628362f, 0.00100468f, 0.10542856f, -0.06464321f, -0.06428337f, 0.03543949f, 
    0.05619862f, 0.02368385f, 0.03748714f, 0.10671373f, -0.19138457f, -0.14908232f, -0.37602428f, -0.15551478f, 
    -0.04694739f, -0.00769550f, 0.07162443f, 0.04378624f, 0.01015587f, 0.04947020f, 0.00430646f, 0.03433589f, 
    0.09507863f, -0.00541155f, -0.09225328f, 0.02592825f, -0.07050537f, -0.00155311f, -0.02881909f, 0.07860567f, 
    0.11709923f, 0.07808488f, 0.03966859f, 0.02388923f, -0.25632167f, 0.18503068f, 0.12512322f, 0.00560221f, 
    -0.03149648f, -0.09662374f, 0.05094383f, 0.12128831f, -0.04962444f, 0.02096085f, 0.09113987f, 0.01394852f, 
    -0.25389841f, -0.12824477f, 0.11373682f, 0.02923514f, 0.02046959f, 0.05878077f, -0.05087761f, -0.04199254f, 
    0.06167194f, 0.02755105f, -0.04037491f, 0.02966456f, 0.28955153f, 0.00328196f, -0.04708532f, -0.04729100f, 
    0.02176471f, -0.00247819f, 0.06747730f, 0.04555278f, -0.06620620f, 0.06201039f, -0.17289826f, -0.24688277f, 
    0.25164485f, -0.13279711f, -0.31405410f, -0.39693403f, 0.03947173f, -0.00901038f, 0.19032463f, -0.02919063f, 
    0.05027038f, 0.18174796f, -0.14302434f, -0.10525884f, 0.11739612f, -0.04572110f, -0.11386070f, -0.17292030f, 
    0.00069293f, 0.03082152f, 0.04933637f, 0.12637116f, -0.05790275f, -0.01770433f, 0.05576352f, 0.01739425f, 
    -0.57799405f, -0.52807486f, -0.37645885f, -0.43089163f, -0.00713041f, -0.36231026f, -0.13072190f, -0.16506861f, 
    -0.04447258f, 0.02432356f, 0.07168598f, -0.00099499f, 0.06814634f, -0.24689300f, -0.11844002f, -0.06302588f, 
    -0.17425680f, 0.11542352f, 0.16866617f, -0.13588546f, -0.01007180f, -0.06313314f, 0.00465875f, -0.01405864f, 
    0.05954236f, 0.05804457f, -0.00879742f, 0.09264091f, -0.04710562f, -0.11002760f, 0.09557482f, 0.08520179f, 
    -0.04707301f, -0.09326979f, -0.00756013f, 0.10229774f, 0.02142326f, 0.14765744f, 0.02958745f, -0.06158828f, 
    0.00447051f, 0.01183516f, 0.06769129f, -0.16243899f, 0.06938459f, -0.19236535f, 0.06387806f, 0.07469977f, 
    0.19808660f, -0.08696271f, -0.14224163f, 0.01251096f, -0.06685344f, 0.00507923f, 0.09711391f, 0.01843619f, 
    -0.03616805f, 0.12587214f, 0.12867229f, -0.02170875f, -0.01329700f, -0.16210200f, 0.05600288f, -0.04384454f, 
    -0.02551793f, 0.10114047f, -0.03871601f, 0.00603383f, 0.04129449f, 0.02944215f, 0.15812725f, 0.11427126f, 
    0.12411581f, -0.15322612f, -0.19389831f, 0.07372985f, -0.00509865f, 0.07397530f, 0.11914775f, 0.21039686f, 
    -0.17891039f, 0.02929523f, 0.09739584f, -0.00931984f, -0.45924816f, 0.23250860f, 0.29977468f, 0.24811955f, 
    -0.05141520f, -0.08145060f, -0.09967534f, 0.02521013f, -0.05953318f, -0.01868133f, 0.06902082f, 0.05356887f, 
    0.07470831f, -0.05470364f, 0.01858712f, -0.25044191f, -0.13022570f, 0.11485480f, 0.03193412f, 0.08531860f, 
    -0.01277212f, 0.02907323f, 0.00391286f, -0.06942072f, -0.38254604f, -0.43632653f, -0.56329519f, -0.26111111f, 
    -0.01495619f, 0.10634588f, -0.08041145f, -0.05812078f, 0.00474951f, -0.04168899f, 0.02692268f, 0.04991379f, 
    0.12622285f, -0.07936580f, 0.09153358f, 0.00426569f, 0.09003994f, 0.02618277f, 0.16146983f, -0.05350238f, 
    -0.01445941f, -0.14907444f, 0.10816893f, 0.01405945f, -0.55303371f, -0.51685470f, -0.20601730f, -0.49795121f, 
    -0.07132857f, -0.03580965f, -0.01477889f, 0.10478809f, 0.00799561f, 0.03658715f, 0.07412140f, -0.10242710f, 
    -0.03209668f, -0.05145032f, 0.19505288f, 0.07174482f, -0.07243512f, 0.04960613f, 0.05385041f, 0.07383575f, 
    0.20473659f, 0.21072105f, 0.03850753f, 0.02647628f, -0.31169045f, -0.00688961f, 0.25557241f, 0.17136511f, 
    -0.27525499f, -0.25560194f, 0.06383551f, 0.01427427f, -0.04053650f, 0.04386824f, -0.13373840f, 0.03674420f, 
    -0.06110571f, -0.07094022f, -0.03963601f, 0.02192334f, -0.13487567f, -0.23850791f, 0.16486675f, 0.03336827f, 
    -0.03935301f, -0.05335413f, -0.04408935f, 0.11530753f, -0.53475696f, 0.50303334f, -0.04733488f, 0.04363317f, 
    0.00327243f, -0.02608024f, -0.03676574f, 0.06473141f, 0.08585040f, 0.07685829f, -0.05597860f, 0.11188497f, 
    -0.34699059f, 0.40377781f, 0.06411666f, 0.03853279f, -0.08791783f, 0.01711845f, 0.01878000f, -0.03208001f, 
    0.10536972f, -0.00455078f, 0.11538939f, -0.04335464f, 0.02450593f, 0.13686793f, 0.18574245f, -0.08605179f, 
    0.08334506f, -0.06977019f, 0.06213786f, -0.00439206f, 0.07475709f, 0.00212842f, -0.02068030f, 0.14737628f, 
    -0.38256791f, -0.73806864f, -0.27800429f, -0.17105706f, 0.09312502f, 0.09477301f, 0.10152247f, -0.40989184f, 
    0.01406138f, 0.00577361f, -0.00951145f, 0.09650639f, 0.05214150f, -0.07857337f, -0.22257164f, -0.09146800f, 
    -0.09855084f, 0.07568905f, 0.11137142f, 0.02124706f, -0.01324739f, 0.00682652f, 0.01581948f, 0.06136284f, 
    0.34205401f, -0.52948374f, 0.04048889f, 0.02013130f, 0.01492382f, 0.04021908f, 0.04799258f, -0.02454814f, 
    0.09282737f, 0.13789548f, 0.06947742f, -0.11665436f, 0.01181677f, -0.11354436f, 0.09088866f, 0.27952331f, 
    -0.01834480f, -0.09227202f, -0.03995247f, -0.03097975f, -0.03274389f, -0.06853089f, 0.11909582f, -0.18021196f, 
    -0.38083023f, -0.15121403f, 0.12419103f, -0.22255127f, -0.06233227f, -0.28355387f, -0.16002163f, -0.23268017f, 
    -0.08759606f, -0.01492397f, -0.02551499f, 0.07156928f, -0.13402736f, -0.62987465f, -0.61650848f, -0.08836398f, 
    0.00303896f, -0.11937696f, 0.23519887f, -0.33194101f, 0.01466291f, -0.12891425f, -0.01392560f, 0.02949789f, 
    -0.30857193f, -0.19291140f, 0.38265997f, -0.12317833f, 0.27940747f, -0.13664450f, -0.08187397f, -0.18090399f, 
    0.01189631f, 0.07096346f, -0.07204138f, -0.05481182f, -0.45778638f, -0.66294640f, -0.29576930f, -0.17776917f, 
    -0.15277466f, -0.23908114f, -0.08757451f, -0.10038377f, -0.05702291f, -0.02380554f, 0.00335555f, -0.10277931f, 
    -0.08682812f, -0.06225513f, 0.10187284f, -0.02766407f, 0.06748653f, -0.14009877f, 0.02950078f, 0.09277010f, 
    -0.02860905f, 0.04497288f, 0.13327940f, -0.04215826f, -0.09777982f, 0.15481816f, 0.51512837f, 0.20076707f, 
    0.12786706f, -0.05761462f, 0.02863967f, 0.01746502f, 0.03173341f, 0.05203199f, -0.09314961f, -0.02483871f, 
    -0.08281056f, -0.07138748f, 0.10065602f, -0.14890406f, -0.10790946f, 0.02864709f, -0.09486341f, 0.06759512f, 
    -0.05724727f, -0.12673971f, -0.15002300f, 0.04160162f, -0.01397940f, 0.01992274f, 0.03101806f, -0.06056959f, 
    0.02632074f, 0.01670265f, 0.00981978f, -0.00424545f, 0.02908150f, 0.06859297f, 0.03838373f, -0.05134585f, 
    0.17850521f, -0.16229527f, 0.04300262f, -0.14935321f, -0.03072102f, -0.03835874f, -0.00948642f, 0.00835405f, 
    0.22587237f, 0.03207507f, 0.01299872f, -0.01483764f, -0.08708207f, 0.14655910f, -0.02845968f, -0.06371791f, 
    0.04011565f, 0.04699425f, -0.10795497f, -0.01987536f, 0.04964033f, 0.06355938f, 0.08206771f, 0.08659001f, 
    0.10925454f, -0.01470121f, -0.17811282f, 0.02936571f, -0.00619834f, -0.09489041f, 0.01335125f, -0.02056252f, 
    0.04881597f, 0.07067176f, 0.04048996f, -0.08212526f, 0.01849762f, 0.03575368f, 0.01965747f, -0.11016011f, 
    -0.04513954f, 0.00934291f, -0.00282878f, -0.02140909f, 0.01265826f, -0.02873188f, -0.03159220f, -0.07139904f, 
    -0.36393395f, 0.08905602f, -0.02049432f, 0.29759818f, -0.07343666f, 0.04206675f, -0.09324626f, -0.02162909f, 
    0.00902761f, -0.04269127f, -0.10657033f, -0.01585389f, 0.63611847f, 0.11184982f, -0.31061181f, -0.19156146f, 
    0.04689756f, -0.00169289f, -0.00484874f, -0.07426347f, 0.02562968f, 0.04230496f, 0.02112594f, 0.01485378f, 
    -0.26699606f, -0.00852562f, 0.02593594f, 0.10007245f, -0.28447258f, 0.08540566f, -0.12267318f, 0.07212009f, 
    -0.06880140f, 0.07644452f, -0.05463310f, 0.02231638f, -0.03925051f, 0.10480529f, -0.13698190f, 0.03168736f, 
    0.02216749f, -0.07573531f, 0.09587787f, 0.00250325f, -0.13764174f, 0.01133916f, 0.08983213f, 0.04581592f, 
    -0.16039436f, -0.35033983f, -0.19920596f, -0.39669153f, -0.02961339f, 0.04028442f, 0.00787872f, 0.05412473f, 
    0.11124942f, 0.05050208f, 0.01279215f, -0.04596302f, -0.38363975f, -0.29051778f, -0.19977783f, -0.32439610f, 
    0.09500471f, -0.06662366f, 0.02741060f, 0.11371829f, 0.02725293f, -0.03764355f, -0.09293353f, 0.02867812f, 
    -0.12352517f, -0.06328104f, 0.29474512f, -0.20811352f, -0.14297859f, 0.03169681f, 0.07886855f, 0.09737567f, 
    0.01678776f, -0.00590226f, 0.00966910f, 0.00175806f, -0.01063030f, -0.08103979f, 0.10683408f, -0.03313810f, 
    -0.03853498f, 0.03777103f, 0.12600507f, -0.05596890f, -0.08164101f, -0.03813478f, 0.00600086f, -0.02242944f, 
    0.31308642f, 0.12490238f, -0.01044715f, -0.18044126f, 0.04095178f, -0.07310472f, -0.14975522f, -0.06163538f, 
    -0.10371388f, -0.01810714f, 0.01790637f, -0.13698857f, -0.26982701f, 0.05825952f, -0.00380435f, 0.10327212f, 
    -0.01665648f, 0.01304804f, 0.04539529f, -0.03982758f, -0.03825146f, 0.02121681f, 0.08580506f, 0.04705665f, 
    -0.38228992f, -0.55828363f, 0.41551405f, 0.08254497f, -0.04396460f, -0.07691897f, 0.11623619f, -0.11969801f, 
    0.03186545f, 0.06744377f, -0.04850330f, 0.00295281f, 0.17695665f, 0.09928564f, 0.24235058f, -0.02206398f, 
    0.05180694f, -0.10908110f, 0.04861272f, -0.01802103f, 0.03567554f, -0.04050110f, 0.06027876f, -0.03907489f, 
    0.01822366f, 0.13055654f, -0.10699555f, -0.01741908f, -0.03449807f, -0.04642359f, 0.00485430f, -0.02742877f, 
    0.06880365f, 0.01934481f, -0.01032746f, -0.11455816f, -0.17689213f, -0.35548103f, -0.40978208f, -0.27372137f, 
    0.01057641f, -0.05022834f, -0.04121251f, 0.14245524f, -0.02903302f, 0.00051577f, -0.09203400f, 0.04147962f, 
    -0.04905483f, 0.13387337f, -0.21217570f, 0.06754024f, -0.04952677f, 0.14620438f, 0.01588401f, -0.04772019f, 
    -0.04050897f, 0.05584294f, 0.06134178f, 0.00396773f, 0.15091234f, -0.01618223f, -0.01799833f, -0.05376852f, 
    -0.04368994f, -0.01472628f, -0.22847052f, -0.16243599f, 0.07231384f, -0.10039715f, 0.00418977f, 0.00007825f, 
    -0.04325889f, 0.11584201f, 0.00953704f, -0.02471977f, -0.09793885f, -0.06394657f, -0.10105632f, -0.01801169f, 
    0.03060363f, 0.04713775f, -0.00896345f, 0.01696584f, -0.12171722f, 0.01714713f, -0.02159762f, 0.03698258f, 
    0.02307065f, 0.04071194f, 0.03298176f, -0.04271936f, 0.00859996f, 0.02558883f, 0.02730559f, 0.02792250f, 
    0.15326506f, -0.19895387f, 0.03292782f, -0.02849279f, -0.02159237f, -0.06740942f, -0.08984627f, 0.04969453f, 
    0.09756206f, -0.05136897f, 0.02789167f, -0.00102749f, 0.04845049f, 0.03327845f, 0.08126938f, -0.01353392f, 
    -0.13062605f, -0.03065643f, 0.11397346f, -0.01246191f, -0.16730054f, 0.06998585f, 0.05418532f, 0.06167796f, 
    0.48148549f, -0.19777378f, -0.16197121f, -0.18672521f, -0.04378722f, 0.22852100f, -0.06375093f, -0.00169648f, 
    0.02335257f, 0.07417440f, 0.03247375f, -0.01584234f, 0.02674294f, 0.09968795f, -0.01446687f, 0.06120718f, 
    -0.04596011f, 0.09996589f, 0.00363255f, -0.05011464f, -0.06211001f, 0.03278791f, -0.01754081f, -0.02595674f, 
    0.06548520f, 0.02345280f, -0.08014427f, -0.02814971f, 0.02147238f, -0.09025317f, 0.07718319f, -0.02282447f, 
    -0.01653144f, 0.04400045f, -0.01677499f, -0.09312901f, 0.06328801f, -0.32381856f, 0.00065279f, 0.06644321f, 
    0.04925895f, 0.06690082f, -0.02028926f, -0.02077476f, 0.00019059f, 0.01929216f, -0.01650942f, 0.02889283f, 
    0.27205929f, -0.09936524f, -0.05876973f, -0.25578502f, 0.02723484f, -0.03475770f, -0.01980017f, 0.01178132f, 
    -0.05795546f, 0.05001832f, -0.16696386f, -0.20901853f, 0.48409021f, -0.41855153f, -0.19934306f, -0.25296792f, 
    -0.12266919f, -0.10722736f, -0.00793604f, -0.00800247f, 0.18479645f, -0.16301696f, -0.14239970f, -0.06047693f, 
    0.19460534f, 0.16255935f, 0.10338431f, -0.15612951f, -0.02806468f, 0.08093543f, 0.05146709f, 0.01575465f, 
    -0.03654279f, 0.08982018f, -0.06324701f, -0.06311321f, -0.07071196f, -0.00433365f, 0.02725755f, -0.05461973f, 
    -0.02661640f, 0.00715246f, 0.02164547f, 0.00421030f, 0.01491988f, -0.15171713f, -0.01736598f, 0.00741718f, 
    -0.17430507f, 0.05090155f, 0.04617660f, 0.04781300f, -0.03402989f, -0.00409045f, -0.00994967f, -0.06515543f, 
    0.03731094f, 0.02096702f, 0.02763554f, 0.02717200f, 0.02538370f, 0.17035821f, -0.36318541f, 0.06800102f, 
    -0.04789448f, -0.02346197f, 0.00627203f, -0.06413294f, 0.02248007f, -0.04535643f, -0.08892385f, 0.02556987f, 
    -0.37504956f, -0.37316737f, -0.27581254f, -0.05864909f, -0.05491945f, 0.03327256f, -0.04600639f, 0.03691557f, 
    0.01945515f, 0.05324217f, 0.01411616f, 0.02697095f, -0.02983825f, 0.08430573f, -0.03129244f, 0.00172701f, 
    -0.16308954f, -0.10592038f, -0.01324899f, -0.03294973f, 0.00467399f, -0.01321290f, 0.04248036f, 0.06252059f, 
    0.02851368f, -0.02407658f, 0.10217397f, -0.06294566f, -0.07653698f, -0.04009601f, 0.05714337f, 0.05820546f, 
    0.03106826f, -0.13146684f, 0.06976938f, -0.05624449f, 0.11023235f, 0.06385022f, -0.01130493f, 0.03934935f, 
    0.07963469f, -0.00814384f, 0.00071275f, -0.09984763f, -0.15236238f, 0.13601400f, 0.00804698f, 0.06477790f, 
    -0.00875379f, -0.03654263f, 0.04998969f, 0.02310191f, -0.05750956f, -0.00748719f, 0.12321316f, -0.04378766f, 
    0.09914504f, -0.05223363f, 0.00260789f, 0.11722299f, 0.12366889f, 0.15020145f, -0.17053078f, 0.09753272f, 
    -0.03052063f, 0.04536540f, 0.03548792f, -0.09170876f, 0.02944272f, 0.03294232f, 0.06301384f, 0.06874794f, 
    0.03096008f, 0.05543919f, 0.07543784f, -0.05190334f, 0.01240998f, 0.03184853f, -0.07908342f, -0.01068411f, 
    0.00269458f, 0.05684046f, 0.02311609f, 0.01694233f, 0.41416430f, -0.77163517f, -0.41081041f, -0.17918621f, 
    -0.07036494f, -0.14235380f, -0.14245756f, 0.01592302f, 0.00435967f, -0.03404096f, 0.04785092f, 0.00974417f, 
    -0.04910963f, 0.17473371f, -0.12580907f, 0.01360759f, -0.02325405f, -0.09190778f, -0.02860835f, -0.03137597f, 
    0.02119819f, -0.07243630f, -0.02451495f, -0.05217194f, -0.29665557f, -0.38264415f, -0.14489792f, 0.14563225f, 
    -0.05644775f, 0.20437424f, 0.18021496f, 0.09158699f, -0.06081807f, -0.00484865f, -0.02738832f, -0.08813366f, 
    -0.02245174f, 0.12821268f, -0.00870019f, -0.06044972f, -0.10748459f, 0.02255072f, -0.02102546f, -0.01316356f, 
    0.00267871f, 0.03678359f, 0.02169335f, -0.01291627f, -0.60995275f, 0.63670653f, -0.30732343f, 0.40205044f, 
    -0.02270988f, -0.13924925f, 0.15472914f, -0.07672130f, -0.02227863f, -0.04965458f, -0.15564325f, -0.11230568f, 
    0.17498657f, -0.00296690f, 0.15020624f, -0.20608401f, -0.03051534f, 0.07326897f, -0.05996152f, 0.03082038f, 
    -0.02901804f, 0.06977986f, -0.00908974f, -0.02450174f, 0.38973671f, -0.19844602f, -0.17167594f, -0.24692897f, 
    0.03518229f, -0.00147272f, 0.13616502f, 0.17398918f, 0.04742289f, -0.01041679f, 0.06231184f, -0.04022590f, 
    0.20254074f, -0.09146459f, -0.00698635f, -0.02259242f, -0.01932436f, -0.02913253f, 0.07424017f, 0.08049310f, 
    0.05984331f, 0.02951081f, -0.00852637f, -0.04054455f, -0.44700983f, -0.22039722f, -0.31527412f, -0.26842785f, 
    -0.00207322f, -0.21076466f, 0.31510320f, 0.03339142f, -0.03909447f, -0.00437715f, -0.04246269f, 0.07741765f, 
    0.04738241f, -0.29837152f, -0.19840568f, -0.10985173f, 0.04772399f, -0.02665773f, 0.03388491f, 0.03240159f, 
    -0.06083293f, 0.08630933f, -0.04163275f, -0.06825126f, -0.03623208f, 0.23771712f, 0.11742653f, 0.00154901f, 
    0.03446475f, 0.00675873f, 0.02107175f, 0.03052738f, -0.08469491f, -0.00546394f, -0.11699106f, 0.10163278f, 
    -0.53548920f, 0.09303983f, 0.07662003f, 0.01823387f, 0.11065739f, -0.10492206f, -0.03690086f, 0.06406093f, 
    -0.02897660f, -0.00854205f, 0.06594719f, 0.04560490f, 0.06315202f, -0.04687358f, -0.11020723f, 0.00365049f, 
    -0.01975659f, -0.01596203f, -0.11917280f, -0.08978343f, 0.03820719f, 0.07370342f, 0.01665597f, 0.05876569f, 
    -0.28450665f, -0.01627129f, -0.10948585f, 0.22881888f, -0.13697138f, 0.12595581f, -0.10166059f, 0.13894971f, 
    0.03855440f, -0.08280143f, 0.05866565f, 0.02792619f, 0.14877956f, 0.00565690f, 0.02272712f, -0.11613660f, 
    0.01696019f, 0.09738168f, -0.02160284f, 0.06599818f, -0.00178069f, -0.07156698f, -0.08903582f, -0.08723487f, 
    -0.39898431f, -0.30769593f, 0.19840135f, 0.10980000f, 0.18199323f, 0.12896349f, 0.03914583f, 0.07834688f, 
    -0.01476214f, 0.03976137f, -0.00085317f, 0.01182947f, -0.52398980f, 0.33452791f, -0.02765152f, 0.12860849f, 
    0.05352974f, -0.00521008f, 0.01389558f, -0.02454496f, -0.01632312f, -0.01919299f, -0.02347895f, 0.01638588f, 
    -0.50863498f, 0.39186153f, 0.08917174f, 0.19187501f, -0.07399575f, -0.18543579f, 0.05915036f, 0.05206615f, 
    -0.00283744f, 0.02340825f, 0.01892737f, 0.04690676f, -0.29494151f, -0.36026338f, 0.25409997f, 0.19973114f, 
    -0.11546995f, -0.08883622f, -0.11973459f, 0.14551122f, -0.04410643f, -0.08295207f, -0.05972101f, -0.02513842f, 
    0.24125801f, 0.03843932f, -0.09867825f, -0.12698288f, -0.06548620f, 0.04288771f, 0.07037246f, 0.02353432f, 
    -0.02323283f, 0.10835981f, 0.03917850f, 0.02939901f, -0.17368901f, -0.03200733f, -0.06735079f, 0.11467847f, 
    -0.02818787f, -0.14960513f, 0.12067793f, 0.07732437f, -0.01855453f, -0.05197031f, -0.03651851f, 0.04461974f, 
    -0.25342068f, -0.16337317f, 0.04017908f, 0.20140040f, -0.10149904f, 0.14979053f, 0.09925627f, 0.07069181f, 
    0.10348804f, -0.15583105f, 0.00361590f, -0.07474755f, -0.17195137f, 0.07509549f, 0.16921975f, -0.07649467f, 
    -0.13271211f, -0.07041825f, -0.01649211f, -0.03651486f, -0.13152930f, 0.07578175f, 0.03641728f, 0.05040298f, 
    -0.31841183f, -0.18898648f, -0.02457206f, 0.01354587f, -0.06176990f, 0.06820808f, 0.02680151f, 0.00292008f, 
    -0.17326838f, 0.07217973f, -0.14231093f, -0.33818343f, -0.37511569f, -0.01974874f, -0.01287186f, 0.19828627f, 
    -0.04423844f, -0.01954754f, -0.07410624f, 0.01688544f, -0.15858698f, -0.06046361f, -0.09787814f, -0.07644122f, 
    0.39654213f, 0.24982741f, -0.07193337f, -0.04637060f, -0.04292050f, -0.12733918f, -0.01236124f, -0.19009325f, 
    0.07116559f, -0.02438171f, -0.02431362f, -0.06976696f, 0.01914474f, 0.05348832f, -0.04948647f, -0.09225998f, 
    -0.01499954f, -0.05374355f, -0.01437493f, -0.04143127f, -0.00342039f, 0.01040474f, 0.10324115f, 0.11819606f, 
    0.35679784f, 0.02247259f, -0.25252709f, -0.37047511f, -0.01890977f, -0.03143132f, -0.03348306f, 0.10175996f, 
    0.03738795f, 0.05209377f, 0.07464913f, 0.04032018f, 0.09019554f, -0.41855130f, -0.41356173f, -0.41552797f, 
    0.12565699f, 0.07963938f, 0.08351398f, -0.00367373f, 0.05780709f, 0.01332196f, -0.15075026f, 0.01158127f, 
    0.14548466f, 0.19347110f, 0.03133128f, -0.00021856f, 0.07284774f, -0.04172218f, 0.02423622f, 0.19482291f, 
    0.14808519f, -0.05913183f, 0.23494819f, 0.03570705f, -0.35936630f, -0.04272786f, 0.08327565f, 0.03574351f, 
    0.03291195f, 0.07966878f, 0.03974519f, 0.02300910f, -0.17903081f, -0.04672069f, 0.02695201f, 0.08505259f, 
    -0.27277997f, -0.37257832f, -0.38510364f, 0.38908353f, 0.04838584f, 0.03435717f, 0.09520261f, -0.00840581f, 
    -0.00632899f, -0.07746498f, -0.03422437f, 0.01519566f, 0.00609766f, -0.35021937f, -0.45407811f, -0.32981148f, 
    -0.15961820f, -0.06505851f, 0.02177913f, -0.11185639f, -0.03869652f, -0.03957146f, -0.03221151f, -0.00778962f, 
    -0.08431415f, -0.11706755f, -0.24753354f, 0.04261154f, 0.09860806f, 0.12488041f, 0.02592326f, -0.05448273f, 
    -0.07871203f, -0.06934352f, -0.05134929f, -0.00036050f, 0.06666442f, 0.18602681f, -0.11219443f, -0.19112821f, 
    0.28739595f, 0.03635164f, -0.11499485f, 0.09913924f, -0.20509125f, 0.06963135f, 0.06352037f, 0.12514794f, 
    0.15944560f, 0.13086142f, -0.13324720f, -0.35075045f, -0.01318694f, -0.10433579f, -0.05263167f, -0.07271829f, 
    0.04794689f, 0.05388055f, 0.11575711f, 0.05673688f, -0.35964191f, -0.12142140f, 0.16665410f, 0.06158229f, 
    0.04641753f, 0.05784483f, -0.06254282f, 0.00045383f, -0.13348515f, -0.09287449f, -0.10507917f, -0.34740314f, 
    0.80807471f, -0.01081255f, -0.15599039f, 0.01203736f, 0.25325060f, -0.11535184f, 0.09696564f, -0.08506452f, 
    0.10195598f, 0.01012034f, 0.12987243f, -0.00788938f, -0.17205192f, -0.11275841f, 0.10506760f, 0.26900563f, 
    -0.07077722f, -0.01069485f, -0.05110659f, 0.00328680f, 0.02036731f, 0.03093278f, 0.00065557f, 0.04500869f, 
    -0.43030697f, -0.03637117f, 0.07423638f, -0.10202426f, -0.03549527f, 0.05629071f, -0.05993978f, -0.02172945f, 
    -0.08344726f, -0.06011911f, 0.01922183f, 0.12933987f, 0.31932452f, -0.15944889f, -0.25312212f, 0.12802003f, 
    -0.04735041f, -0.03866740f, 0.02588582f, -0.07520791f, 0.03010677f, -0.09008648f, 0.02474046f, -0.09222932f, 
    0.10947879f, -0.03982723f, 0.11805590f, 0.02314914f, -0.03585194f, -0.01213466f, -0.10407811f, 0.04536883f, 
    0.12704220f, 0.05139433f, 0.15538453f, 0.05227877f, -0.11120504f, -0.16607882f, -0.14343823f, -0.03636139f, 
    -0.04964898f, 0.07990858f, 0.02405445f, 0.09384912f, 0.02120448f, -0.00004978f, 0.03174276f, -0.16903682f, 
    -0.19612823f, 0.02279293f, -0.00597807f, -0.01958821f, 0.03478085f, -0.00153160f, -0.17733915f, -0.03843661f, 
    0.12900563f, 0.06099738f, 0.11029014f, 0.06765141f, -0.54113042f, 0.26175824f, 0.15767103f, 0.14134420f, 
    -0.06321120f, -0.10529496f, -0.08274283f, -0.05927844f, -0.11754271f, 0.03251335f, 0.00190907f, 0.07557268f, 
    0.21013063f, -0.18275988f, -0.16889784f, -0.28206691f, -0.02203288f, 0.04093574f, 0.09159290f, 0.01846876f, 
    0.09670097f, 0.08536854f, 0.05153232f, -0.26450118f, -0.00946898f, 0.03319839f, -0.08919697f, -0.02810729f, 
    0.04914440f, 0.06459344f, 0.07054691f, -0.23378590f, 0.14180075f, -0.19012025f, -0.06344310f, -0.18430851f, 
    0.03045106f, -0.02507577f, -0.17867391f, 0.14009245f, 0.11562551f, 0.02356773f, -0.00848617f, 0.03842178f, 
    0.02488694f, 0.11267176f, 0.07842537f, -0.02427678f, -0.15701830f, 0.13213733f, 0.21522042f, 0.19455734f, 
    -0.02465484f, -0.06485146f, -0.08783969f, 0.04251189f, 0.06921305f, -0.01247624f, 0.02248826f, -0.02721890f, 
    0.25057673f, 0.04495011f, -0.07671832f, -0.00669010f, -0.17233683f, -0.03442063f, 0.03266973f, -0.03239647f, 
    -0.01900806f, 0.08687750f, 0.05288361f, 0.11230689f, 0.12323005f, 0.11085075f, 0.03044548f, 0.16549885f, 
    0.07134673f, -0.04552020f, -0.05330336f, -0.02361862f, 0.12059108f, 0.02741974f, 0.07035083f, 0.01248237f, 
    0.24238448f, -0.06023596f, -0.19752616f, -0.36831358f, 0.02078149f, -0.09134790f, 0.08489204f, -0.10601474f, 
    0.22095561f, 0.07212162f, -0.01444255f, -0.00838614f, -0.08263224f, -0.19070865f, -0.20542398f, -0.08156411f, 
    0.03728904f, 0.06944038f, 0.04708705f, -0.01869475f, -0.25146779f, 0.07224899f, -0.13519882f, -0.25757772f, 
    -0.04449591f, -0.11055332f, -0.19925207f, -0.21123666f, -0.22101256f, 0.02399095f, 0.04461632f, -0.02002336f, 
    0.14027663f, 0.07950684f, 0.15316783f, 0.20757999f, -0.25232276f, 0.10203625f, 0.00915634f, -0.02643112f, 
    -0.00943208f, 0.00990483f, -0.06482790f, 0.02499999f, 0.00607016f, 0.05371185f, 0.11803974f, 0.05436333f, 
    -0.42355105f, 0.11970498f, 0.04613438f, 0.27362800f, -0.03739659f, 0.00717317f, -0.05011813f, 0.04452484f, 
    0.08829638f, 0.02439751f, -0.00211818f, 0.09486688f, 0.35859457f, 0.16992514f, -0.03230282f, 0.07557678f, 
    0.01025418f, -0.03553246f, -0.03040999f, -0.00645161f, -0.03829898f, 0.02155526f, -0.19900239f, -0.01870631f, 
    -0.40854803f, -0.56711280f, -0.25122881f, -0.13172889f, 0.16762671f, 0.15854806f, 0.03178975f, 0.17019659f, 
    -0.00090379f, 0.12638742f, 0.08509988f, 0.09595913f, -0.25948539f, 0.04913886f, 0.15752800f, 0.00077902f, 
    0.15699518f, -0.07954355f, -0.06999881f, -0.04884567f, 0.00566534f, 0.00800434f, -0.00455452f, -0.03669581f, 
    -0.04821971f, -0.12565778f, -0.07109035f, 0.02267950f, -0.00802460f, 0.00776284f, 0.07519183f, 0.03907416f, 
    0.11720753f, -0.04949754f, 0.08771590f, 0.06069974f, 0.10421146f, 0.03655386f, 0.03385930f, -0.05269217f, 
    -0.00786874f, 0.02102614f, 0.00856518f, -0.04560784f, -0.06457233f, -0.06765093f, -0.01631563f, -0.20810021f, 
    -0.21983080f, -0.08609491f, 0.04332592f, -0.02269183f, 0.05707026f, -0.00172533f, -0.11057033f, -0.01108216f, 
    -0.22127753f, -0.12277507f, -0.09168694f, -0.34282827f, -0.07681496f, -0.13819976f, -0.13228147f, -0.16873901f, 
    -0.11348829f, 0.07205436f, 0.00920666f, 0.16859105f, 0.11027101f, 0.12253562f, -0.04767447f, -0.04303754f, 
    -0.15640596f, 0.07175744f, 0.08190179f, -0.05162600f, 0.00240980f, -0.02948149f, -0.09957508f, -0.07954285f, 
    -0.11551678f, -0.27519044f, -0.04127605f, -0.14915070f, -0.28689221f, -0.46968400f, -0.21743581f, 0.17383844f, 
    -0.02431489f, 0.09218097f, 0.15722862f, 0.09574399f, -0.00823428f, 0.01718489f, 0.02057162f, 0.00138464f, 
    0.01024091f, 0.14875878f, -0.00620242f, 0.16098844f, 0.14249757f, 0.00590284f, -0.03678470f, 0.17738472f, 
    0.11809473f, -0.00633802f, 0.07438666f, 0.09369852f, -0.12400005f, -0.25321716f, -0.15325610f, -0.19202992f, 
    0.12771770f, -0.04533648f, -0.09020955f, 0.03950015f, -0.00853200f, -0.04567271f, -0.08720581f, -0.09206676f, 
    -0.27485597f, -0.02568370f, 0.12898286f, 0.04291011f, -0.00448140f, -0.08559984f, -0.04299855f, 0.02380427f, 
    -0.04297617f, -0.08322705f, 0.02141815f, -0.00576536f, -0.21037361f, -0.33374438f, -0.44359219f, -0.21302676f, 
    -0.02918716f, 0.02937376f, 0.07461189f, 0.06835125f, -0.00122392f, 0.11537740f, 0.03028887f, 0.00071542f, 
    0.15962078f, -0.10401831f, -0.22396658f, -0.08148125f, 0.03901192f, 0.03781131f, 0.11028247f, -0.01534068f, 
    -0.02664119f, -0.03258123f, -0.08837128f, -0.20421927f, -0.17862505f, -0.20259765f, -0.16601288f, 0.22539774f, 
    -0.10229856f, 0.00293787f, 0.11731687f, 0.02059179f, 0.09745284f, 0.03950218f, 0.15651073f, 0.19454797f, 
    0.09863763f, 0.02319850f, -0.15277250f, -0.00177578f, 0.11096269f, -0.14018944f, -0.05821913f, -0.00373246f, 
    0.02942559f, 0.06024350f, 0.06366631f, 0.10666485f, -0.20221972f, -0.60905170f, 0.24742486f, 0.18279526f, 
    -0.01349668f, 0.03667717f, 0.18998046f, -0.12759598f, 0.02288653f, 0.09741335f, -0.15430939f, 0.10045621f, 
    0.29915959f, -0.32786387f, -0.32956558f, -0.10001311f, -0.11026567f, 0.07098041f, 0.09599726f, -0.05584747f, 
    0.12327822f, -0.09133317f, -0.00679927f, 0.01537401f, -0.28798065f, -0.08260298f, 0.09775994f, -0.10572006f, 
    -0.11394182f, -0.00348342f, -0.05097893f, 0.00967555f, 0.12338036f, 0.13761608f, 0.12541641f, 0.01993479f, 
    -0.08151005f, 0.07997194f, 0.15174656f, 0.03462351f, 0.03027350f, 0.13650718f, 0.00467783f, -0.11385190f, 
    -0.02662389f, 0.01556226f, -0.01824415f, 0.04450377f, -0.03244162f, 0.12592350f, 0.05752220f, 0.18424335f, 
    0.04123750f, -0.08603553f, 0.10529960f, 0.07651787f, -0.05991533f, -0.07659943f, 0.02449676f, 0.03199872f, 
    -0.06687222f, -0.12077951f, -0.19547643f, 0.25205520f, 0.01398994f, 0.08884890f, -0.02432721f, 0.16189107f, 
    0.01158081f, -0.03462695f, 0.13930000f, -0.13560279f, 0.06958456f, 0.02592253f, -0.06301274f, 0.08727393f, 
    -0.02619241f, -0.03990246f, 0.02941305f, 0.03827771f, 0.14072806f, 0.00634843f, 0.15169168f, -0.04965691f, 
    -0.21098220f, -0.34400171f, -0.20633329f, -0.09740309f, -0.03104972f, 0.17316085f, 0.12254807f, 0.14672771f, 
    -0.06138241f, 0.06513155f, -0.02199520f, -0.01597422f, -0.00006756f, -0.04353187f, 0.20823476f, -0.08600035f, 
    0.15382284f, -0.10019646f, -0.05600341f, -0.07248833f, 0.02439879f, 0.08134726f, 0.03961999f, 0.06178746f, 
    -0.09557054f, -0.05155035f, -0.01527555f, -0.03318283f, -0.01662738f, -0.14687248f, 0.03586712f, -0.00826899f, 
    0.03362712f, 0.03405102f, 0.04599966f, 0.05813447f, -0.09886424f, -0.32664263f, -0.38594377f, -0.48997128f, 
    0.04159869f, -0.10981382f, 0.14316756f, -0.13083239f, 0.11838188f, 0.03948488f, 0.10439744f, 0.06385684f, 
    0.04235932f, -0.09717893f, -0.08988160f, -0.10152886f, -0.12775737f, 0.02823543f, -0.00600883f, -0.02491642f, 
    0.02429315f, 0.11017898f, 0.10009225f, 0.09757477f, 0.00617456f, -0.03242895f, 0.01217734f, 0.15662098f, 
    -0.06675635f, 0.08533536f, 0.08983783f, -0.01586999f, 0.00769752f, -0.00799032f, 0.02532056f, -0.02664263f, 
    0.17868315f, 0.09723314f, 0.15311642f, -0.25605297f, -0.07859202f, 0.06444600f, -0.23662305f, -0.23108847f, 
    -0.04057764f, -0.10744998f, -0.01596763f, 0.13841116f, -0.06616013f, -0.10850736f, 0.04828981f, -0.01027730f, 
    -0.03687629f, 0.13669665f, 0.09582222f, 0.02388911f, 0.12699661f, 0.15439419f, -0.01592007f, 0.01967275f, 
    0.30212522f, 0.20726296f, 0.30376321f, -0.07180584f, -0.03753360f, -0.13163590f, -0.03200400f, -0.11906224f, 
    0.02082115f, 0.12276410f, 0.01724174f, 0.09525134f, -0.06301838f, 0.09338450f, -0.30613101f, 0.05177244f, 
    0.06925407f, -0.02099508f, 0.19591650f, -0.17369814f, -0.05561125f, -0.01722891f, -0.04911410f, 0.04159686f, 
    0.05756849f, -0.40761244f, -0.39928982f, -0.01641925f, 0.09378824f, 0.27472684f, 0.06732613f, -0.04294601f, 
    0.02107707f, -0.09934755f, -0.03294466f, -0.10397040f, -0.04637409f, -0.04857292f, -0.01890734f, 0.13281140f, 
    0.05793270f, 0.21443866f, 0.14040127f, -0.01443031f, 0.09927622f, 0.10798093f, 0.04133631f, -0.04339657f, 
    -0.41420779f, -0.20870285f, -0.23196138f, 0.09435819f, -0.04674939f, 0.05411365f, -0.03322834f, 0.03343247f, 
    0.00353532f, 0.10308449f, 0.05021650f, 0.01544747f, -0.11684091f, 0.27434307f, 0.20609409f, 0.49338198f, 
    0.09785706f, -0.14103821f, -0.23754512f, -0.10742210f, 0.03822736f, -0.05876321f, 0.07510724f, 0.09763467f, 
    -0.40146831f, 0.02380148f, -0.71079648f, 0.04275887f, -0.15044190f, 0.05540308f, 0.17792358f, -0.01472257f, 
    0.01024491f, -0.07427416f, -0.09202436f, 0.00902208f, -0.32132885f, 0.37673697f, 0.37987134f, -0.36149430f, 
    0.09836613f, -0.23006426f, 0.14023818f, -0.02431286f, -0.07694096f, 0.13528962f, 0.00308593f, -0.06113183f, 
    0.28436777f, -0.04097297f, 0.03068509f, -0.37565681f, 0.03200418f, -0.03990459f, 0.15067250f, -0.10621484f, 
    0.06362490f, 0.00392275f, -0.02708101f, 0.02073189f, -0.20213513f, -0.05939056f, -0.15822586f, -0.06940854f, 
    -0.15451303f, 0.04714932f, 0.14731938f, 0.10231347f, 0.02455140f, 0.02418447f, 0.08367776f, 0.03509924f, 
    0.10820931f, -0.27594581f, 0.08790216f, -0.34801802f, -0.16601513f, -0.09027123f, -0.10048002f, 0.00841296f, 
    0.12333165f, -0.08133771f, -0.11507760f, 0.00650931f, 0.19090486f, 0.07722667f, -0.12342067f, -0.22186771f, 
    0.01205033f, 0.05277498f, 0.09595495f, -0.15767074f, 0.14166392f, -0.05852442f, -0.11499036f, 0.09991962f, 
    -0.31496957f, -0.12833671f, 0.19597049f, 0.42761123f, 0.04553436f, 0.14220226f, -0.28178579f, -0.16043103f, 
    0.08293115f, 0.03115494f, -0.02713449f, -0.07571312f, -0.11136556f, 0.04372127f, 0.13852179f, -0.32431975f, 
    0.00899257f, -0.05472581f, 0.04965029f, 0.07791161f, 0.01560174f, 0.01245512f, 0.18387471f, 0.18931505f, 
    -0.05828265f, -0.31644213f, -0.03311707f, -0.24503289f, 0.00656363f, -0.17098139f, -0.07198621f, -0.13934083f, 
    -0.00049914f, -0.07880421f, 0.01558622f, 0.01847812f, 0.28990886f, -0.57807726f, 0.23580582f, -0.42221275f, 
    0.05641834f, 0.01847249f, 0.01344717f, 0.06295966f, 0.07355242f, 0.10542097f, -0.03916432f, 0.01933617f, 
    -0.03728114f, 0.00621225f, 0.00462783f, -0.04404042f, 0.07493883f, -0.01515229f, 0.08821467f, 0.00637312f, 
    0.08962990f, -0.05437781f, 0.11724395f, 0.09471187f, -0.18357663f, 0.00816026f, -0.11709227f, 0.09507907f, 
    -0.05782226f, -0.11021985f, 0.00846589f, 0.07826829f, 0.03196690f, -0.02488843f, 0.02600472f, -0.05335993f, 
    -0.15812752f, -0.02432260f, -0.09013919f, -0.13600031f, 0.05524525f, 0.01865577f, 0.02308036f, -0.03870197f, 
    0.04330943f, 0.05106808f, 0.03564401f, -0.05897012f, -0.07778466f, 0.08822770f, 0.17668377f, -0.13982241f, 
    -0.19302884f, -0.01697517f, -0.03286216f, -0.15535066f, 0.11277536f, 0.00846918f, 0.03246047f, 0.02887103f, 
    0.13125949f, -0.08908402f, -0.03910858f, -0.06462628f, 0.15529428f, 0.00361073f, 0.06524312f, 0.19396928f, 
    0.08399254f, -0.07087938f, -0.01286798f, -0.08581856f, -0.25304303f, -0.07953694f, -0.30551878f, 0.15488955f, 
    0.08700965f, 0.04603875f, 0.17675087f, 0.03314708f, 0.09244332f, -0.01848255f, -0.05781915f, 0.02044966f, 
    -0.36612493f, -0.38246781f, 0.20076662f, 0.06955538f, -0.03429037f, 0.06622617f, 0.04985864f, -0.04683940f, 
    0.02261462f, 0.12340875f, 0.03076328f, -0.01600983f, -0.07392891f, -0.13171394f, -0.19798684f, -0.03238589f, 
    0.17593178f, 0.09072605f, 0.04208658f, 0.05047742f, 0.01759143f, 0.11340054f, -0.10877197f, 0.01137853f, 
    -0.24331865f, 0.22509946f, -0.07984229f, -0.10795408f, -0.28980020f, 0.03877155f, -0.00588778f, -0.07579958f, 
    0.11457539f, -0.15239915f, -0.00531500f, -0.04743274f, -0.16855285f, 0.01553477f, -0.23866592f, 0.14934973f, 
    0.05298659f, -0.01869312f, 0.09334955f, 0.05519029f, 0.01922144f, -0.00569676f, -0.08296732f, 0.02411614f, 
    -0.25470790f, -0.13291830f, 0.21906333f, -0.01815972f, 0.14097637f, -0.06168762f, -0.03152046f, 0.18420683f, 
    0.04720357f, -0.02654751f, -0.00068850f, -0.00650796f, -0.05929375f, -0.09195746f, -0.37357667f, 0.04068920f, 
    0.09013063f, -0.07314038f, 0.11841418f, -0.04254167f, -0.10381914f, -0.03869271f, -0.07025710f, -0.06255247f, 
    0.18731120f, 0.27722549f, 0.24817258f, 0.34406719f, 0.06185605f, -0.07385534f, 0.05079048f, -0.10050642f, 
    0.07155037f, 0.01673119f, -0.00231153f, 0.05286384f, 0.19528013f, -0.04969408f, 0.32260516f, 0.32933223f, 
    0.02038990f, -0.11449160f, -0.11175530f, -0.23877564f, 0.14271893f, 0.01005472f, -0.06231426f, 0.05611879f, 
    0.01271066f, -0.16408348f, 0.20111221f, 0.26358473f, 0.09290511f, 0.14238927f, -0.30813739f, 0.01692462f, 
    -0.20591190f, -0.03676583f, 0.00665968f, -0.06626538f, -0.06993300f, 0.22695287f, -0.07627714f, -0.03211711f, 
    0.01789049f, 0.04770974f, 0.13016516f, 0.03506131f, 0.25857195f, 0.07714616f, -0.04105849f, 0.05087736f, 
    -0.31968060f, 0.25749543f, -0.12682393f, 0.00650172f, 0.09194782f, 0.01435165f, 0.06779118f, 0.07229062f, 
    -0.03107630f, -0.04227273f, -0.12874806f, -0.07242687f, -0.46978158f, 0.13885333f, -0.18611966f, 0.18323213f, 
    0.09890038f, 0.00233901f, 0.07150321f, 0.01298855f, 0.06077499f, -0.03746450f, -0.09870472f, 0.03026042f, 
    -0.12855898f, 0.02241416f, -0.04480086f, -0.06335323f, -0.23958902f, -0.00012690f, -0.08049294f, 0.05133504f, 
    0.05523068f, -0.02545735f, 0.10000923f, 0.01251713f, 0.15523273f, 0.04676511f, -0.58031392f, 0.02464758f, 
    0.18507783f, 0.11914586f, 0.12730040f, 0.14015038f, -0.01261546f, -0.14954765f, -0.09870386f, 0.03702132f, 
    0.10275155f, 0.04100982f, 0.12179674f, -0.40675062f, 0.15288363f, -0.14148398f, 0.09840842f, -0.17751095f, 
    0.02552695f, -0.01117224f, -0.01479874f, 0.08904833f, -0.17379053f, -0.05834001f, 0.03475643f, 0.05896349f, 
    0.08934591f, -0.01147109f, -0.03156518f, 0.23154755f, 0.12210725f, -0.02662247f, -0.01177618f, 0.18875885f, 
    0.03001855f, 0.19881999f, 0.01353532f, 0.04250095f, -0.08300827f, 0.00183834f, 0.00191764f, -0.03297019f, 
    0.13877788f, 0.05026861f, 0.17608382f, 0.12991567f, -0.39763325f, 0.34237891f, -0.21557486f, 0.29966965f, 
    -0.16132367f, -0.00212843f, -0.16351815f, 0.00214080f, 0.05257838f, -0.08467478f, 0.06532829f, -0.00375028f, 
    -0.02991512f, -0.13093099f, -0.21232480f, -0.01826051f, 0.07760391f, 0.13767523f, 0.05248024f, 0.01223410f, 
    -0.06544244f, -0.13167228f, -0.02131933f, 0.06002884f, 0.10167030f, 0.00059444f, 0.20541528f, -0.13259757f, 
    -0.06470140f, -0.19288790f, -0.13512328f, -0.08713176f, 0.03510826f, -0.10507527f, 0.07178185f, 0.08130881f, 
    -0.36275473f, 0.15064953f, -0.34087029f, 0.17983438f, 0.18987884f, -0.09844742f, 0.05807118f, -0.00645281f, 
    0.11001350f, -0.16966753f, -0.17381622f, -0.07153239f, -0.03518622f, 0.08022441f, -0.01599549f, 0.20722954f, 
    -0.03846488f, -0.00524144f, 0.01813330f, 0.00264182f, -0.03451904f, 0.11301962f, 0.09419999f, -0.03358526f, 
    -0.05181743f, -0.21249890f, -0.06915591f, -0.25728977f, -0.04565440f, 0.09637287f, -0.02615729f, 0.10863655f, 
    -0.07999934f, -0.06337743f, -0.05805954f, 0.17284727f, -0.44280908f, 0.14012356f, -0.07639243f, -0.11098693f, 
    -0.00768452f, 0.05733787f, 0.07067715f, -0.11368681f, 0.14477819f, 0.03638352f, -0.00658326f, -0.08437526f, 
    0.05172904f, -0.25348264f, 0.16153871f, 0.05569595f, 0.01655000f, 0.13117677f, -0.10034678f, -0.10418014f, 
    0.02028636f, 0.07914885f, -0.09972181f, 0.06168495f, -0.02667130f, 0.03561201f, 0.15211020f, -0.09752180f, 
    0.17483680f, -0.17776886f, -0.06212076f, 0.07784142f, -0.02089073f, -0.07420839f, -0.04097700f, 0.11935467f, 
    0.08460193f, -0.13310552f, -0.04661876f, -0.00102638f, -0.03828771f, 0.03979611f, -0.00678379f, 0.08013409f, 
    -0.03057565f, -0.15582317f, -0.13767423f, 0.00933303f, 0.23085195f, -0.27072051f, -0.01804349f, -0.16785276f, 
    0.07889535f, -0.29618964f, -0.10085154f, 0.01344110f, -0.07171221f, -0.04983690f, 0.11812462f, 0.12179199f, 
    -0.21154305f, -0.28993556f, 0.26761433f, 0.23176116f, 0.15094158f, -0.08225435f, -0.07003983f, 0.13807304f, 
    0.07143879f, 0.05688325f, -0.07930900f, 0.20976348f, 0.17126183f, -0.09539302f, 0.03791139f, -0.11768712f, 
    0.07004347f, 0.03786692f, -0.11905484f, -0.15176310f, 0.00450860f, 0.03959449f, -0.00233683f, 0.00096646f, 
    0.14771771f, 0.01454420f, -0.33843458f, -0.07999803f, -0.02365633f, -0.07744578f, 0.05709304f, 0.17078306f, 
    -0.03683322f, 0.03676454f, -0.02954007f, -0.04808832f, -0.24984677f, 0.12694927f, -0.39060596f, 0.10706011f, 
    0.25787580f, 0.03742402f, 0.16283651f, -0.10685760f, 0.02093982f, -0.04105996f, -0.09604833f, 0.09903619f, 
    -0.08678770f, 0.44196159f, -0.85235423f, -0.39110744f, -0.31271607f, -0.04881053f, 0.15140925f, -0.06668667f, 
    0.00929182f, -0.02768053f, -0.12081520f, -0.03215542f, -0.24208766f, -0.02137141f, -0.04090057f, -0.10383834f, 
    -0.16398348f, 0.08248096f, 0.11439912f, -0.08069807f, 0.06260251f, -0.10138850f, 0.05097716f, -0.06724399f, 
    0.08597826f, 0.28787363f, -0.03351583f, -0.25970078f, -0.16844819f, -0.03371742f, 0.05166092f, 0.07893248f, 
    0.00462572f, 0.00441857f, -0.03188799f, -0.05690163f, 0.26276824f, -0.18131304f, -0.13524368f, -0.33731315f, 
    0.00081301f, -0.00104708f, 0.01443810f, 0.12384315f, -0.02220539f, -0.02263857f, -0.01847212f, -0.05601443f, 
    -0.11770122f, 0.01566913f, -0.01564778f, -0.32717481f, -0.18052766f, -0.23374328f, 0.01994530f, -0.04836068f, 
    0.10916165f, 0.02901741f, -0.03706217f, -0.12534940f, -0.28949848f, -0.08130724f, 0.14241847f, -0.23183078f, 
    0.00301971f, 0.02380511f, 0.13136566f, 0.22776303f, 0.00209885f, 0.05606234f, 0.05390996f, -0.03469148f, 
    -0.07369611f, 0.13938671f, 0.15491669f, 0.32150680f, 0.09786402f, 0.14023638f, -0.09873634f, -0.02109492f, 
    -0.01005349f, -0.14795676f, -0.06423506f, -0.12467588f, 0.05751456f, 0.08214507f, 0.01805256f, -0.25047988f, 
    0.04311759f, -0.04082606f, -0.03681531f, -0.06899283f, -0.04026493f, 0.12582624f, -0.03298560f, 0.01363367f, 
    -0.38313654f, 0.39019865f, -0.04033180f, 0.20185499f, 0.14564914f, -0.11698665f, -0.03750440f, 0.05918493f, 
    -0.21491137f, 0.04526070f, 0.02999873f, 0.03690695f, 0.00302780f, -0.04548331f, 0.08396988f, 0.08906016f, 
    -0.04954127f, -0.16350828f, 0.07294026f, 0.01022165f, -0.03891842f, -0.06030157f, -0.06245009f, 0.07954093f, 
    -0.13032342f, 0.13695845f, -0.19978176f, 0.02276671f, 0.13935533f, -0.07748432f, -0.04093892f, -0.01958111f, 
    -0.14261082f, -0.25118816f, -0.32445791f, -0.26993692f, 0.04964833f, 0.25529355f, -0.22533044f, 0.09265320f, 
    -0.04130821f, -0.17633143f, 0.02327288f, 0.00916365f, -0.04080130f, 0.10861787f, -0.14664707f, 0.03118947f, 
    -0.38926634f, -0.53429908f, 0.25766188f, -0.31908077f, -0.20524977f, 0.04834488f, 0.14529268f, 0.11353782f, 
    -0.03809980f, 0.03681160f, 0.05276207f, -0.18585439f, -0.20591317f, -0.19280215f, -0.33867979f, -0.22510405f, 
    -0.13484184f, -0.03417858f, -0.00806466f, -0.07535065f, -0.03047192f, 0.05944405f, 0.02673668f, 0.05854443f, 
    -0.05276703f, -0.12381054f, -0.19665805f, 0.12517354f, -0.05095169f, -0.04055941f, 0.27854639f, 0.06766876f, 
    0.04703501f, 0.06563504f, -0.05847739f, 0.13622975f, 0.10845479f, 0.32372898f, 0.00141054f, -0.23131540f, 
    -0.03415382f, 0.03062345f, 0.05834867f, 0.04081037f, -0.02859278f, -0.09704281f, -0.07121921f, -0.12983780f, 
    0.12367265f, 0.26987919f, -0.03711206f, -0.04632459f, -0.20355634f, -0.04961702f, 0.03292046f, 0.05425692f, 
    0.12867770f, 0.21546769f, -0.08489015f, 0.20518440f, -0.03543676f, -0.11718117f, 0.13253841f, 0.08936127f, 
    -0.04012914f, -0.15250695f, 0.22464295f, -0.01316319f, 0.05425702f, -0.07315284f, 0.05286242f, -0.01222071f, 
    -0.20918097f, -0.06741274f, 0.07184540f, 0.02278236f, -0.02490461f, 0.01611915f, -0.03033546f, 0.03015817f, 
    0.02275959f, -0.00134564f, 0.03113998f, -0.29281914f, -0.06553424f, -0.23122454f, -0.24222665f, 0.00244703f, 
    -0.13983099f, -0.00640063f, -0.12857053f, -0.03052086f, 0.08226962f, 0.07899155f, 0.05833922f, -0.09111870f, 
    -0.29821858f, 0.13656391f, -0.25716811f, 0.33104157f, 0.09537356f, 0.04394866f, -0.03916612f, -0.02227539f, 
    -0.19212376f, -0.00705635f, 0.03563163f, -0.08152495f, -0.08012753f, 0.04995966f, -0.15245908f, -0.16623370f, 
    -0.12914278f, -0.22029184f, 0.05956379f, 0.01445906f, -0.02926333f, 0.13001965f, -0.12059466f, 0.07154726f, 
    -0.30955949f, -0.00759669f, 0.11543728f, 0.06429503f, -0.08393910f, 0.11949257f, -0.02556811f, -0.07988160f, 
    -0.22438835f, 0.01676956f, -0.07266277f, 0.11413652f, -0.05764260f, 0.14553277f, 0.11348013f, -0.08797231f, 
    0.02690290f, -0.06390014f, -0.03581917f, 0.01034155f, -0.13034552f, -0.21693015f, -0.37251732f, -0.42235437f, 
    -0.49450776f, 0.09273903f, 0.14444147f, 0.03864586f, -0.05002025f, 0.09535161f, 0.08288139f, 0.00864347f, 
    -0.05298083f, 0.07808970f, 0.13441126f, 0.00349023f, -0.01986055f, -0.00059961f, 0.13112395f, 0.10915076f, 
    0.00708414f, 0.10694381f, -0.11903612f, 0.17459095f, 0.07703476f, -0.13633408f, 0.00477069f, 0.03888214f, 
    -0.02785648f, -0.14665438f, 0.05380350f, -0.05554539f, -0.06260145f, -0.08809306f, 0.03473518f, 0.04604778f, 
    -0.00480291f, -0.03734303f, -0.08786914f, -0.01912079f, -0.17006211f, 0.24266171f, -0.07759764f, -0.08929794f, 
    -0.08304943f, -0.03505149f, -0.21518868f, -0.04529177f, -0.00719310f, 0.13840587f, -0.07424722f, -0.01805979f, 
    -0.00850148f, -0.11022298f, 0.16846511f, -0.11596132f, -0.08848317f, -0.03279908f, 0.07008248f, 0.16160992f, 
    0.20217755f, 0.11099604f, 0.01444163f, 0.12345012f, 0.10473289f, -0.03199521f, 0.11334904f, -0.05599652f, 
    0.02059810f, -0.18261628f, -0.11478310f, 0.02936951f, -0.06492376f, 0.13249454f, 0.03926379f, -0.08418237f, 
    -0.13026181f, -0.18673791f, -0.10002664f, 0.06276171f, -0.07701781f, 0.05944340f, -0.02131512f, 0.10808949f, 
    -0.10498824f, 0.26402059f, 0.13397487f, 0.14487706f, -0.08915967f, -0.18821062f, -0.05458689f, -0.16094911f, 
    -0.12234161f, -0.10276300f, -0.00950109f, 0.04253674f, -0.07456549f, 0.00047123f, 0.06445210f, 0.05508700f, 
    -0.16593219f, 0.37769231f, -0.33577049f, -0.13668916f, 0.02169340f, 0.14705127f, 0.11067730f, -0.01379702f, 
    -0.04383554f, 0.11676875f, -0.34525830f, -0.14632814f, -0.08390865f, -0.13239966f, 0.31947884f, -0.08221354f, 
    0.07984440f, 0.11085866f, -0.25334486f, -0.11075089f, -0.22021185f, 0.07818640f, -0.00228476f, -0.15775205f, 
    0.13343494f, 0.10772781f, 0.20279360f, -0.18140538f, -0.12049933f, -0.02378749f, 0.02528413f, -0.03084490f, 
    -0.06207137f, 0.07015600f, -0.00135883f, 0.04873117f, 0.04452854f, 0.04936000f, 0.14782752f, -0.01611421f, 
    0.03983236f, 0.15857056f, 0.03683629f, -0.13815902f, 0.05623439f, -0.00529234f, 0.08931603f, 0.01927503f, 
    -0.24188107f, -0.05674841f, 0.20648350f, 0.08020803f, -0.10868401f, 0.12421943f, 0.06243739f, -0.00287751f, 
    0.11106192f, -0.13373981f, 0.09673785f, 0.12900656f, -0.10635707f, 0.00488585f, -0.04994052f, 0.03587148f, 
    -0.03112034f, 0.12900946f, -0.08283605f, -0.01041016f, 0.11539694f, -0.07710505f, 0.10131392f, 0.09737425f, 
    -0.46196657f, 0.27196059f, -0.09177101f, -0.15632376f, -0.04744248f, 0.17856053f, -0.09296516f, -0.07973272f, 
    0.02524869f, -0.22044109f, 0.07247690f, -0.04304188f, 0.05457916f, -0.00854276f, -0.19761479f, -0.26242116f, 
    -0.06630418f, 0.02909944f, -0.00457425f, -0.04364550f, -0.11035845f, 0.13199793f, -0.03745506f, -0.28115526f, 
    0.02023264f, 0.03578444f, 0.03562091f, -0.09001205f, -0.10037923f, -0.02777372f, 0.01804321f, 0.04727104f, 
    0.14352542f, 0.17533821f, 0.13713792f, 0.15469427f, 0.09282929f, -0.11366045f, -0.06992557f, -0.17137228f, 
    -0.01130351f, 0.02798025f, 0.13599843f, -0.02738896f, -0.17989737f, 0.04572996f, 0.04055005f, 0.00741652f, 
    0.17294252f, -0.20148161f, -0.05557414f, 0.20830640f, -0.15747830f, -0.01043110f, 0.09693696f, 0.04120912f, 
    -0.04472969f, 0.04101722f, 0.10866021f, 0.11957626f, 0.30237338f, -0.32225284f, 0.31404063f, 0.00461035f, 
    -0.10533883f, 0.06802849f, 0.01123727f, 0.00402357f, -0.04444292f, -0.22523661f, -0.22608162f, -0.03635006f, 
    -0.03017901f, 0.00139399f, -0.16417685f, -0.07345170f, -0.08530806f, -0.09335165f, -0.06280772f, 0.00292814f, 
    -0.03154014f, 0.10111275f, 0.01928366f, 0.03728841f, -0.11841170f, -0.27384865f, -0.18325901f, -0.25467306f, 
    -0.03682446f, -0.04092272f, 0.01831391f, -0.18720630f, -0.19741285f, -0.05633733f, -0.15511969f, -0.01839124f, 
    -0.11502783f, 0.05010265f, 0.01580248f, 0.32104474f, -0.06687030f, -0.02967608f, 0.06854211f, -0.01831366f, 
    0.04303285f, 0.12799035f, 0.10550488f, -0.06828728f, -0.02911170f, 0.18249150f, 0.02022655f, -0.02437331f, 
    -0.03183040f, 0.16189085f, 0.07954466f, -0.28345001f, 0.00379186f, 0.03438515f, -0.31794935f, -0.17269769f, 
    0.05475748f, 0.01208690f, 0.03115802f, -0.17992458f, -0.12625358f, -0.19804716f, 0.09951114f, 0.08819663f, 
    -0.26984370f, -0.05980605f, -0.24220726f, -0.19810979f, 0.60440534f, -0.31277499f, 0.21192044f, -0.23523934f, 
    0.00987075f, -0.05941100f, 0.07998180f, 0.18172818f, -0.18048894f, 0.15676925f, -0.16794512f, -0.04069619f, 
    -0.25813836f, 0.11099638f, -0.05081416f, -0.08053397f, -0.08787553f, -0.02274380f, -0.00443443f, -0.08777346f, 
    -0.09833750f, 0.07057941f, -0.07293788f, -0.09149404f, 0.19153386f, -0.21288753f, 0.21955359f, 0.03841321f, 
    -0.04380853f, -0.00349170f, -0.06811342f, -0.00523735f, -0.03708809f, 0.16069128f, -0.07280369f, -0.20050173f, 
    0.00101360f, -0.06594657f, 0.15958834f, -0.11001554f, -0.05422640f, 0.08796494f, 0.18681344f, 0.11076596f, 
    -0.07033474f, 0.10128001f, 0.01676629f, 0.09221844f, -0.05702838f, 0.01430944f, -0.39385733f, -0.08873525f, 
    -0.04770519f, -0.12336808f, 0.04018545f, -0.05686619f, -0.02663179f, -0.03949777f, -0.22832456f, -0.01405760f, 
    0.06126890f, 0.22428061f, 0.14575104f, -0.06560204f, -0.03203800f, -0.10135982f, 0.02628127f, 0.07115377f, 
    -0.02154923f, 0.09945023f, 0.01329786f, -0.08958406f, 0.07780089f, -0.32736456f, 0.42862687f, 0.05346179f, 
    0.09114596f, 0.02117289f, 0.11240424f, 0.02240909f, -0.00701177f, -0.07041124f, -0.05763179f, -0.02695740f, 
    -0.23698463f, 0.22323212f, -0.20057426f, 0.01832471f, -0.00304964f, 0.10331849f, 0.00371052f, -0.04269408f, 
    -0.09783464f, -0.00628457f, -0.16109399f, -0.14855678f, 0.08587486f, 0.11036527f, 0.08424558f, 0.06505813f, 
    -0.21099967f, -0.08138527f, 0.01971216f, 0.03114424f, -0.00935360f, -0.00859804f, 0.09280746f, 0.11786328f, 
    -0.23225716f, -0.05361401f, 0.24889553f, 0.07811927f, -0.04589586f, 0.02698367f, 0.03233903f, 0.02012465f, 
    0.00877437f, -0.11639304f, 0.26057085f, 0.20059818f, -0.05361593f, 0.23507090f, -0.14740109f, 0.22197567f, 
    -0.03318947f, -0.23351252f, 0.03826681f, -0.03229138f, 0.02636779f, 0.10350640f, -0.00074453f, -0.11273412f, 
    -0.70310944f, 0.44462460f, 0.05259873f, 0.06407365f, 0.03579813f, 0.07266387f, -0.23280270f, 0.09157024f, 
    0.00100241f, -0.17967553f, 0.15914260f, 0.10874348f, 0.12634464f, 0.03781181f, 0.05263396f, 0.27150005f, 
    0.01079698f, 0.07891493f, -0.02581521f, 0.10646462f, 0.09566972f, 0.01421081f, -0.06791176f, 0.08070443f, 
    -0.09941735f, -0.37138012f, 0.14738664f, -0.07077694f, 0.06311177f, -0.04470119f, -0.05409726f, -0.04622544f, 
    0.08463054f, 0.10524241f, 0.03589704f, -0.02459781f, -0.00504893f, 0.10344087f, -0.09521969f, 0.09406570f, 
    -0.27682841f, 0.00952923f, 0.03547002f, 0.00718640f, -0.05598660f, 0.13765869f, 0.01085132f, -0.00235308f, 
    0.26016286f, -0.27466494f, 0.28131434f, 0.01770572f, -0.11023232f, -0.04485430f, 0.22742069f, -0.13369170f, 
    -0.03354732f, 0.07536044f, -0.15042663f, 0.24012735f, 0.27465519f, -0.16840760f, 0.12587701f, 0.13259625f, 
    -0.07497390f, 0.02697426f, -0.01847946f, -0.03632971f, 0.01851852f, 0.03129987f, -0.03222989f, 0.12666516f, 
    -0.08132055f, -0.22629885f, 0.03336711f, 0.13277313f, -0.01378260f, -0.01810450f, 0.01838928f, 0.00557583f, 
    0.00419513f, 0.04962249f, 0.05093507f, -0.00185913f, -0.20200127f, -0.05108616f, -0.00856550f, -0.02433102f, 
    0.07060271f, -0.08094388f, -0.12860478f, 0.15019551f, 0.12193498f, 0.02933113f, 0.05680206f, 0.00570218f, 
    0.29500321f, -0.12814464f, 0.44286826f, 0.17723860f, -0.10484945f, 0.02028946f, 0.01158448f, 0.05111843f, 
    0.04481906f, 0.04160763f, 0.08132134f, 0.00078314f, -0.00907066f, -0.28749195f, -0.45877293f, 0.00917198f, 
    -0.04419357f, -0.17580825f, -0.06060658f, -0.11989884f, 0.18014386f, 0.07614067f, 0.04377448f, -0.02557404f, 
    0.04869315f, 0.13092081f, 0.05808881f, -0.17141733f, -0.07723434f, 0.05181324f, 0.01630881f, -0.00039013f, 
    0.08215059f, 0.20113277f, -0.00360827f, 0.08982623f, 0.12868501f, 0.15243080f, 0.21204491f, 0.02350977f, 
    -0.11159691f, -0.04177408f, -0.00118516f, 0.04294070f, -0.05661937f, 0.07663763f, -0.06453373f, 0.02821023f, 
    -0.51169360f, 0.22141418f, -0.12217850f, 0.16672869f, 0.10014116f, -0.15018088f, 0.09333029f, 0.03481676f, 
    -0.12073503f, 0.02299987f, -0.22293170f, 0.09682195f, -0.05354432f, 0.07709611f, 0.00996052f, -0.03347779f, 
    -0.05628933f, 0.14279278f, -0.04880537f, -0.11360672f, -0.07843450f, -0.02241243f, 0.05904257f, 0.00137464f, 
    -0.24011819f, -0.21212265f, -0.10476886f, -0.13943447f, -0.04155022f, -0.02389406f, -0.11023258f, 0.01608109f, 
    -0.04740742f, 0.00890234f, 0.03862525f, -0.02908996f, 0.19400549f, -0.06086196f, 0.40414175f, -0.07629647f, 
    0.04308886f, -0.02216115f, -0.09744137f, 0.05038053f, -0.16553031f, -0.07050644f, 0.05714736f, -0.08630037f, 
    0.37290069f, 0.27930787f, 0.21794958f, -0.21975707f, -0.04524254f, 0.07870238f, -0.00373279f, 0.11261148f, 
    -0.08997343f, 0.07373816f, -0.06569665f, 0.05923759f, 0.08617307f, 0.01491896f, 0.02659329f, 0.04523090f, 
    -0.01838191f, -0.01771974f, 0.05879958f, 0.08144109f, -0.09376432f, -0.03360213f, -0.07752361f, -0.11334392f, 
    -0.27827209f, -0.34468654f, 0.12935139f, -0.01797314f, -0.12914094f, 0.11149970f, 0.09400354f, -0.27565101f, 
    0.01227397f, 0.04052917f, 0.01121567f, 0.06036354f, -0.21491867f, -0.68841803f, -0.03832707f, -0.04373365f, 
    0.07632739f, 0.07359387f, -0.00875165f, 0.03795923f, 0.08090829f, 0.07734573f, 0.24784262f, -0.17093965f, 
    0.24653669f, -0.32728848f, 0.46514887f, 0.36037117f, 0.05957078f, -0.26586568f, 0.13018343f, 0.04410286f, 
    -0.08257745f, -0.01843646f, 0.02085244f, 0.03008008f, 0.09250265f, -0.17947404f, 0.11114505f, 0.04100012f, 
    0.10642181f, 0.12065634f, -0.05214307f, 0.04794225f, -0.12494956f, 0.10538833f, 0.08830716f, -0.09720209f, 
    0.15465291f, 0.17534982f, 0.00201083f, -0.54888099f, 0.04224429f, -0.20064487f, -0.04277385f, 0.03027140f, 
    -0.06310716f, -0.02735805f, 0.04688139f, -0.06174170f, 0.07863254f, -0.06737354f, -0.06884447f, -0.09198111f, 
    -0.24408497f, -0.18054233f, -0.00885181f, -0.09302683f, -0.00209510f, 0.05656839f, -0.01255895f, -0.06231321f, 
    0.00777589f, 0.07633591f, -0.01659979f, 0.62381923f, 0.01199660f, 0.02598929f, 0.08438469f, -0.03114201f, 
    -0.08783530f, -0.07713247f, -0.05045913f, -0.10045249f, 0.21052662f, -0.02576655f, 0.07812118f, 0.31138989f, 
    -0.11871716f, 0.04667423f, 0.16382062f, -0.09334785f, 0.05584329f, 0.12911317f, 0.12979174f, -0.03835609f, 
    -0.49185365f, 0.10844813f, -0.35633928f, 0.08990270f, -0.13123879f, 0.23560852f, 0.10167597f, -0.05148644f, 
    0.03043279f, 0.00689979f, 0.25073349f, -0.09392172f, -0.10027305f, -0.00073916f, -0.03851415f, 0.03732605f, 
    -0.04384705f, 0.07305330f, 0.04599890f, 0.09728616f, -0.00638027f, 0.27085868f, 0.16978182f, 0.09055170f, 
    -0.05256201f, 0.07222424f, -0.32443136f, 0.01932241f, 0.05388244f, -0.33859652f, 0.29359484f, -0.06701868f, 
    0.00970680f, 0.05106406f, -0.01582085f, -0.03696261f, -0.21471967f, 0.48972061f, -0.11242760f, 0.02594519f, 
    -0.06773413f, 0.03373362f, 0.05779846f, 0.03423598f, -0.04351688f, 0.09415511f, 0.03873717f, 0.05775481f, 
    0.21209122f, 0.15111208f, 0.00835324f, -0.20289360f, -0.06803469f, 0.06236112f, -0.09637783f, 0.00346779f, 
    -0.00700714f, 0.00323972f, 0.12385252f, 0.06818245f, 0.26144490f, -0.23208676f, 0.17351304f, -0.33585253f, 
    0.01520680f, -0.17531420f, 0.08439574f, 0.09345039f, 0.06634676f, 0.08225137f, 0.09247550f, 0.03640376f, 
    0.05312034f, -0.09319569f, 0.01848222f, -0.04535857f, 0.06517871f, -0.04426884f, 0.18432112f, -0.03521272f, 
    -0.06294962f, -0.01628104f, -0.07574734f, 0.03912552f, -0.02291716f, 0.09068356f, -0.11089443f, -0.07897572f, 
    0.06086388f, 0.04324000f, 0.17712328f, -0.06634142f, -0.00106976f, 0.00878718f, -0.05500693f, 0.05544512f, 
    0.20314668f, 0.05132659f, 0.04621921f, -0.03962163f, 0.01317551f, 0.11986224f, 0.10489544f, 0.14533299f, 
    0.03631459f, -0.09726077f, -0.05049028f, -0.00439471f, 0.25323552f, -0.13881619f, 0.29041350f, -0.09204081f, 
    -0.02319246f, -0.03976193f, -0.12080500f, -0.01494776f, -0.10372027f, -0.03232203f, 0.04927479f, -0.11414646f, 
    -0.44392297f, -0.34373978f, -0.26524189f, 0.12287898f, 0.03978391f, 0.06661397f, -0.07346322f, -0.08337010f, 
    0.07226158f, -0.08195888f, 0.22051370f, 0.07235592f, 0.16460057f, 0.04867477f, 0.19044113f, -0.08347078f, 
    -0.11166873f, 0.15394171f, 0.01172554f, 0.22653835f, 0.08242015f, 0.00785829f, -0.10860998f, 0.07238871f, 
    -0.10006180f, -0.00630689f, 0.00331832f, 0.01747194f, 0.17719896f, -0.06637715f, 0.17367695f, -0.13258940f, 
    0.02012988f, 0.03633677f, -0.06944215f, -0.01007762f, 0.16555433f, -0.00947277f, -0.03718985f, -0.05508219f, 
    -0.02660790f, -0.05528116f, -0.09188982f, 0.03944520f, -0.05069057f, -0.02393351f, -0.00257567f, -0.00758186f, 
    -0.08250182f, 0.18280852f, -0.30187127f, 0.09272037f, -0.05708381f, 0.11020583f, -0.12360135f, 0.04394203f, 
    0.06434134f, -0.09657864f, 0.04957243f, 0.06425709f, 0.17754471f, -0.13782828f, 0.13708384f, -0.02618206f, 
    0.03500685f, -0.04890502f, -0.15396224f, 0.01575127f, -0.20546234f, -0.08866775f, -0.02403867f, -0.12777738f, 
    -0.28159845f, -0.20627542f, -0.32869110f, 0.14195453f, 0.13558342f, 0.05881339f, 0.01768966f, -0.01851308f, 
    0.11974886f, 0.13577649f, 0.21615079f, 0.14219657f, -0.11053080f, 0.11690348f, -0.04621556f, -0.25005755f, 
    -0.01421390f, -0.12637162f, -0.14045674f, -0.03399903f, 0.07488651f, 0.13753100f, 0.14253257f, 0.05429906f, 
    -0.37124959f, 0.08819681f, -0.44374242f, -0.04115322f, 0.11797446f, -0.02977247f, 0.04945877f, -0.03286193f, 
    -0.15011883f, -0.02813745f, -0.03540057f, -0.10338575f, -0.05897864f, -0.11293335f, 0.33078992f, 0.05953619f, 
    0.03000993f, 0.01559831f, 0.09147774f, -0.01371302f, -0.10848607f, 0.05419642f, 0.10512754f, 0.11595993f, 
    0.21581048f, -0.02717146f, 0.42210370f, -0.01241181f, -0.04652088f, -0.01738034f, -0.10041294f, 0.09334818f, 
    -0.14875476f, -0.00957823f, 0.04107723f, -0.19443631f, 0.26128969f, -0.15541324f, 0.36036775f, -0.38519609f, 
    -0.02585241f, 0.18589748f, -0.00749096f, 0.06151309f, -0.03919234f, 0.11385109f, 0.11817359f, 0.07589570f, 
    -0.17473042f, -0.11655609f, 0.02503359f, -0.21263017f, -0.16369182f, -0.35252818f, -0.03857720f, -0.22998412f, 
    -0.00892483f, -0.02616917f, -0.14471774f, -0.03550215f, 0.45561954f, 0.18225180f, 0.20877191f, 0.00770745f, 
    0.02800141f, -0.04058779f, -0.05620014f, 0.04252131f, 0.00076724f, 0.01265566f, -0.01099739f, 0.00043158f, 
    -0.02052769f, 0.03742328f, 0.07394490f, 0.07746792f, -0.02871505f, 0.09041344f, 0.03320964f, 0.05214636f, 
    -0.04297737f, 0.02310521f, -0.17208555f, -0.14094500f, 0.09584416f, -0.12562747f, 0.14094394f, 0.03135977f, 
    0.05107136f, -0.05683639f, 0.01677326f, 0.10242397f, 0.22172941f, 0.10201196f, -0.01304242f, 0.17067169f, 
    0.06209834f, 0.22583306f, -0.03639026f, 0.01095120f, -0.01835524f, 0.03648322f, 0.10546721f, 0.08879742f, 
    0.16008411f, 0.03634280f, 0.06135427f, 0.00459570f, -0.34731635f, -0.04813676f, 0.02618837f, 0.02489208f, 
    -0.03498901f, 0.08006716f, 0.17088369f, -0.10243579f, -0.00323022f, -0.01761235f, -0.10052357f, 0.03837004f, 
    0.34021419f, 0.15674110f, -0.00562607f, -0.02766330f, 0.00596282f, -0.05106128f, 0.03734606f, 0.07592450f, 
    -0.00674590f, 0.04501523f, -0.03211909f, 0.07962825f, 0.05225574f, -0.03658625f, -0.06623691f, -0.49402118f, 
    0.03991153f, -0.05471615f, 0.05309168f, 0.04312217f, -0.07340560f, 0.03781469f, 0.05380015f, -0.07738646f, 
    0.40454882f, -0.00077835f, 0.10934176f, -0.09281351f, -0.03794431f, 0.01192386f, -0.10717238f, 0.12601274f, 
    -0.04823392f, -0.02021920f, -0.02974525f, -0.03020421f, -0.12099813f, -0.17430688f, -0.11740069f, -0.30238917f, 
    -0.24567394f, -0.17952037f, -0.12951069f, 0.06153553f, 0.07272240f, 0.03695714f, 0.10494760f, 0.07824899f, 
    0.25603145f, 0.17940359f, 0.02695875f, -0.10825643f, 0.03926116f, 0.02166781f, 0.12082282f, -0.01878766f, 
    0.08476269f, 0.05831525f, -0.00395374f, 0.02288555f, -0.04806218f, -0.33965847f, 0.35664809f, -0.29994884f, 
    0.08061630f, 0.11589703f, -0.27631715f, 0.08345787f, 0.02239842f, 0.07862982f, 0.12478700f, 0.13900039f, 
    -0.16263688f, 0.10867507f, -0.09849703f, 0.19844168f, 0.06816491f, -0.18207587f, 0.10873273f, -0.14941803f, 
    -0.07175151f, -0.07656845f, -0.10021067f, 0.09469059f, -0.04403172f, -0.18211460f, -0.10193361f, -0.12968455f, 
    0.06870258f, 0.00746473f, -0.04070278f, 0.00539884f, -0.12200204f, -0.07075283f, 0.02364030f, -0.20335169f, 
    0.00117421f, 0.03939269f, -0.21828157f, -0.02302829f, 0.05216306f, 0.01154276f, 0.03039420f, -0.06187355f, 
    -0.06786440f, -0.13544811f, -0.01106029f, -0.21558177f, -0.25528714f, -0.19160105f, 0.49493027f, 0.25176650f, 
    -0.08618543f, 0.19935703f, -0.04278516f, 0.13537364f, -0.14249150f, -0.05184984f, 0.09635451f, -0.07550047f, 
    -0.49063459f, -0.00224832f, -0.26301512f, 0.20024018f, 0.15872708f, 0.04687005f, 0.06695594f, 0.19547404f, 
    -0.08925739f, 0.09004312f, 0.19623423f, -0.00323773f, -0.19784258f, 0.04526019f, -0.11715852f, -0.00571587f, 
    -0.00726890f, 0.06981902f, 0.05921634f, 0.04221010f, -0.16165820f, 0.04842622f, -0.01433036f, 0.12891038f, 
    0.01680061f, -0.25650385f, 0.14645407f, 0.24197961f, -0.31380239f, -0.19319169f, -0.33324316f, -0.06493542f, 
    -0.04913081f, 0.05437153f, -0.01069341f, -0.00433202f, 0.25025403f, -0.19460538f, 0.36660269f, -0.12483537f, 
    0.06628072f, -0.06819785f, 0.05609266f, 0.01500470f, -0.14308168f, 0.05698205f, 0.05356461f, -0.05353744f, 
    -0.17478648f, 0.04212935f, 0.37923765f, 0.02551336f, 0.04864742f, -0.15204184f, 0.04733286f, -0.06884094f, 
    -0.04886436f, 0.01054141f, 0.13203877f, 0.10099515f, -0.19071868f, -0.05670839f, -0.04564994f, -0.00216076f, 
    0.08789026f, 0.00905961f, -0.01561320f, -0.05588299f, 0.00922493f, 0.07449584f, -0.01855474f, 0.02218364f, 
    -0.56632990f, -0.40339234f, -0.17579544f, 0.00638607f, -0.09436166f, -0.03749757f, 0.01790396f, -0.29808962f, 
    0.04439590f, 0.08490252f, -0.10027627f, -0.01163885f, 0.25207925f, 0.02555391f, 0.18650036f, 0.10669885f, 
    -0.10155815f, -0.15646932f, -0.18920425f, -0.11497718f, 0.06762144f, -0.02074965f, 0.00967785f, 0.03455513f, 
    -0.17573644f, -0.08490881f, 0.11649776f, -0.11414575f, -0.09824723f, 0.31529188f, -0.27263367f, 0.09981984f, 
    -0.04961582f, -0.06635521f, 0.05127378f, 0.00311698f, -0.23924160f, -0.29093146f, -0.37224641f, 0.06409700f, 
    -0.06938432f, -0.09440251f, -0.22875652f, -0.09448496f, 0.00875639f, 0.05824035f, -0.04663290f, -0.07231648f, 
    -0.22468875f, -0.08609860f, -0.11954831f, 0.03478705f, 0.12903465f, -0.04611892f, -0.03919764f, -0.00908257f, 
    -0.11485554f, -0.12228005f, 0.07492722f, 0.04582904f, -0.03937211f, -0.11465739f, 0.18839300f, 0.07092763f, 
    -0.03097239f, 0.05487993f, 0.17355454f, 0.13256422f, 0.03754715f, 0.00472752f, 0.03777947f, -0.07039078f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.12847503f, 0.10623922f, 0.07495324f, -0.11077831f, -0.05823011f, 0.00571346f, 0.03766824f, -0.13331042f, 
    0.09457437f, 0.00396957f, 0.03706147f, -0.00539283f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
