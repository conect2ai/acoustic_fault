#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.03185029f, 1.32902241f, -0.98795295f, 0.15675731f, 0.76486862f, -0.92149675f, 0.36054674f, -0.09774563f, 
    -0.20297325f, -0.47688019f, -0.59267956f, 1.02825618f, -1.00564110f, 0.01978994f, -0.70928675f, -0.04231725f, 
    0.52083403f, 0.56169027f, -0.36175573f, -1.44577622f, -0.02126436f, -0.76431966f, 0.58592200f, -0.81280398f, 
    -0.01722508f, -0.04420374f, -0.25295329f, 1.28856838f, -0.45805383f, 0.19557756f, 0.78459221f, 0.45640296f, 
    -0.53540486f, -0.45544404f, 0.67044747f, -0.63053745f, 1.25377548f, 0.78239864f, 0.08207582f, -0.98919082f, 
    -0.16190997f, -0.78397191f, 0.00304389f, 0.04203015f, -0.28563017f, 1.16484785f, -0.82849336f, -1.29175901f, 
    0.52366763f, -0.81792706f, 0.50749081f, -0.61997527f, -0.23718579f, -0.04943680f, -1.16936970f, -0.15517393f, 
    -0.92851037f, 0.97882384f, 0.99512351f, -0.60618031f, -0.02968312f, -0.27246931f, 0.32960910f, -1.39961219f, 
    -0.13153999f, 1.32977748f, 0.29956150f, -0.15941679f, 0.50399822f, -0.14091890f, -0.35293218f, 0.06526309f, 
    0.55052191f, -0.43522161f, -0.31635603f, 1.12500870f, 0.96570885f, -0.67497545f, -0.09363566f, -0.49852034f, 
    -0.49701411f, -0.98217422f, 1.31823921f, -0.45271280f, 1.14517403f, -0.76770580f, -1.05529463f, 0.13051622f, 
    0.13923799f, 0.09653535f, -0.83170497f, -0.33261219f, -0.71780896f, -0.29618254f, -0.80961537f, -1.17014992f, 
    -0.34430233f, 0.18838367f, 0.23415855f, -0.20768332f, -1.87846911f, -0.42679131f, 0.28514510f, 1.05189610f, 
    -0.11955018f, -0.36295947f, -0.14497660f, -0.17032410f, 1.31804776f, -0.54112202f, -1.16342068f, -0.57006586f, 
    -0.08512162f, -0.49508885f, -0.18008488f, -0.27932230f, 0.27271444f, 0.47287527f, -0.40025237f, 0.95115447f, 
    -0.22097851f, -1.06839967f, -0.98049217f, 0.68834704f, 0.61622339f, -0.13898222f, -1.22418690f, 0.85217363f, 
    -0.37706614f, 0.47420558f, 0.98867941f, 0.81546026f, 0.22665946f, -0.16611840f, 0.33230513f, 1.05292654f, 
    0.88772291f, 0.60866344f, -0.67119735f, -1.04714966f, 0.25289565f, 0.39680615f, 0.84297395f, -0.33493787f, 
    -0.54384899f, 1.51424766f, 0.79184437f, -1.29281461f, 0.96262527f, -0.42269874f, -0.16398180f, 0.52903712f, 
    -0.58315283f, -1.01096177f, 0.66327041f, -0.71360767f, -1.06133759f, -0.89035749f, 0.15105569f, -0.41535807f, 
    0.04076558f, -0.66334355f, 0.25771448f, 0.00233381f, 1.21608055f, 1.07725048f, -0.55488884f, -0.42806831f, 
    -0.11817322f, 0.52798861f, 0.33202249f, -0.49355686f, 1.08459663f, 1.21765411f, 0.16470410f, 1.14381719f, 
    0.13817827f, 0.01767835f, -0.06926259f, 0.26427138f, 0.43402308f, -0.82186538f, -0.67773277f, -1.14732921f, 
    0.52078623f, 0.06789552f, 0.71209550f, 0.43693271f, -0.50601822f, 0.91316426f, 0.10842339f, 0.96182674f, 
    0.85493088f, -0.29298669f, 0.68132514f, 0.07936385f, 0.46938571f, -0.37043822f, 0.48145923f, 0.62326992f, 
    1.00972915f, -1.27918458f, 0.14292710f, -0.25059485f, 0.65827155f, -0.31404743f, -0.34219801f, 1.15347362f, 
    1.32051754f, 0.70190501f, -0.21371983f, -0.48634598f, -0.43182197f, -0.30794534f, -0.39351591f, 0.05877719f, 
    0.55873454f, 1.48200512f, -0.91366512f, 0.51981270f, 0.58096629f, 0.59361100f, -0.38272566f, -0.16600551f, 
    0.28693154f, -0.94179946f, 0.10496263f, -0.35255507f, 0.49768910f, 1.23633516f, 0.76812989f, -0.35948405f, 
    -0.60299468f, -0.58695877f, -0.86797053f, -1.09075415f, -0.87957615f, 0.24438895f, 0.21942312f, 0.60017008f, 
    -0.41617328f, -0.17747702f, -0.45180273f, -0.20028736f, -1.00481355f, 0.82612038f, -1.05848420f, -1.00261772f, 
    0.23677728f, 0.74289012f, 0.41319391f, 0.24854234f, 1.33984900f, -1.46197605f, 0.95427293f, -0.49873552f, 
    0.33421820f, 0.15950124f, 0.00673475f, -0.26763657f, -0.33717999f, 0.94969326f, 0.23464085f, 0.13151504f, 
    0.55226177f, 0.39195085f, 0.00870152f, 0.52870858f, 0.74572909f, 0.39330274f, -1.05238330f, -1.34778678f, 
    -1.09069765f, -0.85425681f, 0.42004341f, 0.91134638f, 0.20434818f, 0.03785272f, 0.42396054f, 0.57347810f, 
    0.26677355f, -1.16103625f, -0.41205132f, 1.08818424f, 0.71444345f, 0.32679614f, -0.25292224f, 0.40864527f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.17797449f, 0.18657498f, 0.20449638f, 0.06539792f, 0.27146769f, 0.22567987f, -0.08226933f, 0.31513813f, 
    0.21708442f, -0.09038404f, 0.30236909f, 0.50714523f, 0.49171051f, 0.30362898f, 0.22531383f, -0.00440362f, 
    0.00286078f, 0.06654691f, 0.05950888f, 0.31916308f, -0.02740338f, 0.39349276f, 0.16327222f, 0.24984799f, 
    0.15003830f, 0.13763767f, 0.19309455f, 0.21105212f, 0.15310018f, -0.04064265f, 0.28719643f, 0.33857045f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.35234064f, 0.04122724f, 0.12701039f, -0.15004373f, 0.29429597f, -0.13161799f, 0.11432576f, 0.09887454f, 
    0.02073687f, 0.03088623f, -0.04412184f, 0.06511153f, -0.08210593f, 0.00911197f, 0.07365035f, -0.07175441f, 
    -0.02182083f, 0.12438036f, -0.05078289f, -0.11413129f, 0.05781067f, -0.28602657f, -0.04342754f, 0.07087938f, 
    -0.10838675f, -0.03690517f, 0.06208726f, 0.02300053f, 0.13923009f, -0.00251472f, 0.01945663f, 0.10328420f, 
    -0.02807268f, -0.03047634f, -0.05595269f, -0.00808631f, 0.06367382f, -0.05206247f, 0.06448030f, -0.02615161f, 
    -0.11413024f, -0.54372180f, -0.09525225f, 0.07729062f, -0.48994640f, 0.03610874f, -0.11628105f, 0.05313661f, 
    0.06132847f, -0.07571052f, -0.00816333f, 0.11581296f, -0.22939613f, -0.04237333f, 0.01707198f, -0.03629758f, 
    -0.11338136f, 0.05893625f, -0.05057754f, 0.00434070f, 0.22247770f, -0.07075780f, 0.12997903f, -0.07490171f, 
    0.10582528f, -0.06869212f, -0.17756967f, -0.03799279f, 0.08175126f, 0.07337834f, -0.02221081f, 0.08718118f, 
    0.11500427f, 0.11012904f, -0.02670110f, -0.07379302f, 0.01471138f, 0.04207120f, 0.02461427f, -0.11834173f, 
    0.06298326f, 0.07404430f, 0.08145773f, -0.00322301f, 0.16690484f, -0.10025436f, -0.02614998f, -0.14069544f, 
    0.03070315f, 0.05949017f, 0.02160175f, 0.00179143f, 0.01073669f, -0.08869933f, -0.01820796f, -0.06701469f, 
    0.08031145f, -0.00280073f, 0.07115198f, -0.04181989f, 0.31644374f, -0.30690190f, 0.14384885f, 0.11882959f, 
    -0.06715697f, 0.07018249f, 0.12622443f, 0.01486868f, 0.07699321f, -0.19344421f, -0.15074176f, -0.00492425f, 
    0.07147855f, 0.04980991f, 0.06503902f, 0.09646158f, 0.04483998f, 0.05667397f, -0.12180088f, -0.05852214f, 
    0.70713222f, 0.00139804f, 0.13620538f, -0.14064606f, -0.23245353f, 0.04263686f, 0.03371209f, -0.06717961f, 
    0.01877226f, -0.07060563f, 0.09364654f, -0.00289387f, -0.09884882f, 0.15786430f, 0.08652737f, -0.00543609f, 
    0.01835100f, 0.05341502f, 0.04838935f, 0.01127472f, -0.43986392f, 0.06518614f, 0.08671968f, 0.26325306f, 
    -0.18894286f, -0.10047492f, -0.01129838f, 0.02232780f, 0.10528304f, -0.00167412f, 0.05932263f, -0.01052873f, 
    0.00930677f, -0.01577969f, -0.05525955f, 0.00339273f, -0.05730271f, -0.01664463f, 0.18803555f, 0.07866680f, 
    -0.07274970f, 0.17862020f, 0.28959429f, 0.03732697f, 0.13043885f, -0.04923473f, -0.01231451f, 0.08082044f, 
    0.08084698f, -0.08351412f, 0.12549162f, 0.08373175f, 0.01867878f, 0.06643598f, -0.07355081f, 0.06303045f, 
    0.10254685f, 0.09011744f, -0.07822429f, 0.10608005f, 0.12336399f, 0.08422974f, 0.13061829f, -0.11748996f, 
    0.11419562f, -0.03790755f, -0.21337892f, 0.10598614f, -0.25318685f, 0.06331856f, 0.01252043f, 0.15411219f, 
    -0.00809543f, 0.07694337f, -0.02181774f, -0.00817540f, 0.06057166f, 0.15654454f, -0.21191165f, -0.08998656f, 
    -0.19430400f, -0.42667019f, -0.07034016f, 0.06950390f, 0.00051017f, 0.07332403f, -0.12203775f, -0.10042766f, 
    -0.00066295f, 0.08456842f, 0.03795396f, -0.04025105f, -0.14240056f, 0.08730825f, -0.07502687f, 0.02728246f, 
    -0.00965753f, 0.07985295f, -0.01815387f, -0.08886133f, -0.25108704f, 0.06069291f, 0.09361454f, -0.04886994f, 
    -0.43873179f, 0.04224173f, 0.00284779f, 0.04212621f, -0.01548321f, -0.05764149f, -0.07384712f, -0.01698463f, 
    -0.01875663f, -0.04401157f, 0.01967614f, 0.00281424f, 0.08786886f, 0.05166679f, -0.10278700f, 0.01791841f, 
    -0.14099389f, -0.30104092f, 0.27580127f, 0.15119249f, 0.18989441f, -0.03341603f, -0.07866691f, 0.08677469f, 
    0.07937170f, -0.03262582f, -0.05326052f, -0.07621273f, 0.02840687f, 0.01589990f, -0.11102224f, 0.01413513f, 
    -0.04689639f, -0.11314894f, 0.03407095f, -0.13573100f, -0.08756915f, -0.19100668f, 0.01017564f, 0.09225689f, 
    -0.17398979f, -0.12067115f, -0.07442649f, 0.01872577f, -0.16038790f, -0.03635871f, 0.00423673f, -0.00269280f, 
    0.01985827f, -0.04991995f, -0.12735379f, 0.00266549f, -0.07270562f, 0.04105263f, 0.06377741f, -0.05626618f, 
    0.39411327f, 0.12037019f, 0.11365265f, -0.25645983f, -0.04005912f, 0.16227861f, 0.01004345f, -0.01250331f, 
    0.01112159f, -0.07555295f, 0.01398657f, -0.08341216f, -0.13429569f, 0.03548836f, 0.07342996f, 0.01847301f, 
    0.01407160f, -0.04685657f, 0.05469508f, -0.07288542f, 0.17108950f, 0.15036598f, 0.12696502f, -0.10086413f, 
    0.17055225f, -0.10733363f, -0.11222719f, -0.10341056f, 0.08285650f, -0.00966183f, -0.12766756f, -0.09005710f, 
    0.12788512f, -0.02852199f, 0.03705321f, 0.00950581f, -0.04412721f, -0.08174422f, 0.09273282f, 0.02361565f, 
    -0.22226080f, 0.00152228f, 0.02748512f, -0.13788378f, 0.23587652f, 0.01512216f, 0.01425982f, -0.02228270f, 
    -0.10861379f, 0.07170841f, -0.10257772f, 0.05999634f, 0.01096185f, -0.12166383f, -0.03050849f, -0.05740955f, 
    0.02900467f, 0.04839779f, -0.00335373f, -0.17871989f, -0.09728588f, -0.14023574f, 0.02505797f, 0.04288798f, 
    0.09396198f, 0.02228050f, -0.05724076f, -0.01475512f, -0.06731588f, 0.05125567f, -0.06273891f, -0.11248785f, 
    0.11972509f, 0.00594310f, -0.09573737f, -0.02274357f, 0.00874309f, -0.01766592f, 0.00081801f, -0.10360435f, 
    -0.19214149f, -0.13052537f, 0.26671746f, 0.06728670f, -0.15434268f, -0.03343956f, -0.11836933f, 0.06623536f, 
    -0.15020448f, -0.02128129f, -0.15665676f, 0.06524522f, 0.02071485f, -0.10667551f, -0.04934359f, 0.03605438f, 
    -0.04791779f, 0.01674209f, -0.11218867f, -0.13395423f, -0.09748827f, -0.07173511f, 0.18198335f, 0.08764278f, 
    0.25742736f, -0.11534180f, -0.08074924f, 0.13444439f, -0.12537180f, -0.08540062f, 0.01917019f, -0.12198532f, 
    0.10949606f, 0.04364683f, -0.01999725f, 0.01002926f, -0.02023268f, -0.07195041f, -0.04164998f, -0.00146283f, 
    -0.21132623f, -0.16434880f, 0.05819826f, 0.19161236f, -0.01914759f, -0.12435061f, -0.04810980f, 0.04269818f, 
    -0.12319417f, 0.13791417f, 0.04063901f, -0.03075974f, -0.02369440f, 0.01299418f, 0.06538463f, -0.10027683f, 
    -0.08528973f, -0.01003992f, -0.06115915f, 0.03258048f, 0.21657734f, -0.12386585f, -0.03676544f, -0.06698068f, 
    -0.15314640f, -0.02477380f, -0.02262801f, 0.03702401f, 0.00938959f, -0.04550665f, -0.06788922f, 0.06738402f, 
    0.03404495f, -0.01164321f, -0.14840795f, -0.02310945f, -0.09636404f, -0.05516336f, -0.07424979f, 0.00207628f, 
    0.09177119f, 0.08474734f, -0.17028780f, 0.11502497f, 0.11161187f, -0.20620440f, -0.18604399f, -0.12415903f, 
    -0.03126974f, 0.00809393f, 0.05151092f, -0.06417658f, -0.07075756f, -0.04270347f, 0.04790109f, -0.05284033f, 
    -0.05528141f, 0.07110063f, -0.02937643f, 0.11979862f, 0.11659367f, 0.17484243f, 0.04609046f, -0.23892751f, 
    0.19308028f, -0.27827749f, -0.20358571f, -0.03731034f, 0.00990854f, 0.05648740f, -0.01409668f, -0.05134917f, 
    -0.05319037f, -0.11111442f, -0.07264822f, 0.14126134f, 0.02410166f, 0.07066296f, -0.02428887f, 0.03615554f, 
    0.15295839f, 0.01294986f, 0.01624340f, -0.23149742f, 0.39178005f, -0.14158273f, 0.00351860f, 0.06988814f, 
    0.12775515f, -0.10793154f, 0.03590829f, 0.05224193f, -0.04375353f, 0.00274469f, 0.10281558f, 0.01236838f, 
    -0.04231238f, 0.02718852f, -0.12985812f, 0.06751747f, 0.32995385f, 0.25893688f, 0.24870610f, -0.11657750f, 
    -0.10777465f, 0.17337365f, 0.11465862f, -0.05174449f, 0.06536322f, -0.05018807f, 0.01048635f, -0.02949430f, 
    -0.04759156f, 0.02264986f, 0.00087296f, 0.04730677f, 0.13624620f, -0.13115501f, 0.08633839f, 0.06564321f, 
    -0.00671246f, 0.06855225f, -0.12358142f, -0.23395310f, -0.44281316f, 0.11770841f, 0.12719408f, -0.02559015f, 
    0.07047824f, 0.01302986f, 0.04188436f, -0.09770758f, 0.01485717f, 0.03121529f, -0.07651344f, 0.00838759f, 
    -0.02503135f, -0.00351405f, -0.01960820f, -0.00224527f, -0.01890464f, -0.34376988f, -0.29686460f, 0.17281924f, 
    -0.25834817f, 0.00480479f, 0.02688964f, -0.02021948f, 0.01391161f, -0.01401250f, -0.08039566f, -0.05080819f, 
    0.02838694f, 0.01444183f, -0.01083128f, -0.00446053f, 0.02362484f, 0.01485813f, 0.03284472f, 0.03213490f, 
    0.32015994f, -0.13448131f, 0.08242557f, 0.21074456f, -0.42441976f, -0.12335397f, -0.16208452f, 0.00952272f, 
    -0.02125893f, -0.00260738f, -0.03583562f, 0.11066766f, -0.10410555f, -0.16168033f, 0.06872136f, -0.07129127f, 
    -0.15507467f, 0.05752985f, 0.05883836f, 0.03001372f, -0.12550449f, -0.08039512f, -0.08407492f, -0.08884742f, 
    0.16677012f, -0.07124355f, -0.02493380f, -0.08927229f, 0.08070858f, 0.01674527f, 0.12151834f, 0.13789384f, 
    0.05845995f, 0.06826211f, 0.01350977f, 0.05105704f, -0.21947363f, 0.04170509f, 0.02496969f, 0.01915240f, 
    -0.43879747f, 0.35283780f, -0.35316128f, -0.07790584f, -0.38468847f, 0.04002530f, -0.07510734f, 0.01456789f, 
    0.16502890f, 0.01949059f, 0.07749941f, -0.01515203f, -0.03858186f, 0.05466356f, 0.05064289f, -0.05470428f, 
    -0.15737946f, 0.04470378f, 0.06918417f, 0.03428069f, -0.56217015f, 0.25938973f, -0.04046299f, -0.27331448f, 
    0.09372804f, 0.05773200f, -0.03494543f, -0.13248959f, -0.10440604f, -0.03126337f, -0.01886299f, -0.06724344f, 
    -0.00368474f, 0.11205678f, 0.02373945f, -0.03157515f, 0.01855501f, -0.02775557f, -0.05833792f, -0.10994229f, 
    -0.05275178f, -0.21388081f, -0.30792829f, -0.25746408f, 0.06217155f, -0.06587092f, -0.14807323f, 0.00364817f, 
    -0.11360873f, 0.02635475f, 0.08466244f, -0.02327061f, 0.09648279f, -0.04698090f, 0.13646336f, -0.12153410f, 
    -0.03642584f, -0.06103971f, 0.00535796f, 0.04155000f, -0.36632764f, -0.11343336f, -0.09525019f, -0.00725632f, 
    -0.14210618f, -0.01194145f, -0.02554846f, -0.09074514f, -0.07488157f, 0.00496501f, 0.04736283f, -0.00820267f, 
    0.02702583f, 0.09516289f, 0.02933422f, -0.15900250f, 0.02760918f, -0.15191905f, -0.12820652f, 0.07637967f, 
    0.09770432f, -0.10234533f, -0.05227043f, 0.19053535f, -0.16130656f, -0.01030799f, 0.02199745f, 0.06672081f, 
    0.05178220f, 0.12253385f, 0.03127041f, -0.11044998f, 0.07769437f, 0.02835082f, 0.03302331f, 0.00216505f, 
    0.04238005f, -0.07835300f, -0.15248001f, 0.01069799f, 0.38035822f, -0.04393744f, 0.21843554f, -0.08666440f, 
    0.04692125f, 0.00861349f, -0.09625353f, 0.02538387f, -0.08181150f, 0.02573494f, -0.06203227f, -0.10577165f, 
    -0.03033113f, 0.01003530f, 0.01726447f, -0.00340036f, 0.07063852f, -0.01108791f, 0.12672648f, 0.19897470f, 
    0.34289280f, 0.07509716f, -0.15988614f, 0.00553089f, 0.02179733f, 0.02042101f, -0.11946245f, 0.12462921f, 
    0.02669009f, -0.04548507f, -0.00902565f, 0.01634728f, -0.05965177f, 0.15600972f, -0.04148253f, 0.00971148f, 
    -0.01516265f, -0.09234796f, -0.03930102f, -0.01522178f, -0.06790689f, -0.42684883f, 0.18583518f, -0.39590800f, 
    0.02253889f, -0.12717906f, 0.07067581f, -0.00552061f, -0.01101353f, 0.07097027f, 0.04447259f, -0.07506453f, 
    -0.01135180f, 0.00109148f, -0.11729769f, -0.10872377f, -0.01063753f, -0.11542034f, 0.10893155f, -0.21899655f, 
    -0.50706786f, -0.02679781f, -0.17277293f, -0.00513308f, -0.07528047f, 0.11165453f, -0.03273762f, 0.02035441f, 
    0.02602937f, 0.00620527f, -0.05708317f, 0.02794229f, -0.01165271f, -0.17040047f, -0.03727480f, 0.08357347f, 
    -0.02251116f, -0.06492456f, 0.00291612f, -0.15452114f, -0.27332374f, 0.21268889f, -0.11906753f, -0.07613649f, 
    -0.35385907f, 0.11378176f, 0.02347349f, -0.01103209f, -0.05335961f, 0.09871851f, -0.12887847f, 0.12295426f, 
    -0.12450296f, 0.01956663f, -0.01764090f, 0.02944344f, -0.13393548f, 0.05393579f, -0.03128713f, 0.07355012f, 
    0.29111147f, -0.47206795f, -0.03357521f, -0.04330229f, -0.01827507f, 0.04301715f, -0.03589278f, -0.08370770f, 
    0.00329532f, -0.08131777f, -0.07166700f, 0.03980100f, -0.06563661f, -0.05153327f, 0.10957243f, -0.10534067f, 
    -0.01296408f, -0.12014671f, 0.10431680f, -0.01592580f, -0.43430078f, -0.49018103f, -0.07567848f, -0.15308340f, 
    0.32027781f, 0.09339758f, -0.03964996f, 0.01552394f, -0.06905972f, -0.02581145f, 0.01563569f, 0.04571018f, 
    0.03534465f, -0.06708173f, -0.03161906f, -0.02089140f, -0.13819228f, -0.20947699f, 0.00890020f, -0.00139237f, 
    0.01503742f, 0.09406813f, -0.00720574f, -0.23170850f, -0.12144866f, 0.03468075f, -0.01270148f, 0.21730518f, 
    0.01312563f, -0.01612831f, -0.09171931f, -0.17577443f, 0.13148578f, 0.01289707f, 0.04049647f, -0.06098386f, 
    0.06642593f, -0.17468375f, -0.11929611f, -0.05863927f, 0.39525437f, -0.27244374f, -0.19281131f, -0.05566312f, 
    -0.24593996f, -0.04571635f, 0.11632912f, 0.01053391f, -0.02324219f, 0.12669766f, 0.14270201f, 0.00150711f, 
    -0.11104406f, 0.00381355f, -0.06295623f, 0.13836706f, 0.07707651f, -0.02056267f, 0.01209787f, 0.04081956f, 
    0.26287809f, -0.49058694f, -0.04432166f, -0.20051391f, -0.08867748f, -0.00981137f, -0.06887940f, 0.03205094f, 
    0.06934516f, -0.05910658f, -0.06238031f, 0.06485622f, -0.05115223f, 0.10171482f, 0.03755302f, -0.13443150f, 
    -0.02242175f, -0.12117044f, -0.10490943f, -0.06127881f, -0.22466207f, 0.02005285f, 0.06535443f, 0.00814717f, 
    -0.21828823f, -0.04998169f, 0.05513700f, 0.02908534f, 0.03757613f, -0.02814015f, 0.06561598f, 0.06735256f, 
    0.09493897f, 0.04022621f, 0.08344653f, -0.03067236f, 0.03264492f, -0.17167404f, -0.03962309f, 0.11468443f, 
    -0.14199018f, 0.20530581f, -0.11910282f, -0.08672865f, 0.05311992f, 0.01386208f, 0.13407959f, -0.06108289f, 
    -0.07422616f, -0.01982647f, 0.06911527f, -0.00226449f, 0.02141257f, -0.05842537f, 0.02898133f, 0.10279573f, 
    -0.02764413f, 0.02162099f, -0.00291598f, 0.08352707f, -0.03758270f, 0.11106633f, 0.11935099f, 0.15507004f, 
    -0.02145016f, -0.05789446f, -0.05705828f, 0.00214437f, 0.00835488f, -0.04191749f, -0.01115834f, 0.04040424f, 
    0.04408616f, 0.09711295f, -0.07130250f, 0.05544850f, 0.02357981f, -0.12561885f, -0.06257306f, -0.05167426f, 
    -0.21593156f, 0.22978549f, -0.36893860f, -0.08318386f, 0.11019179f, -0.02303825f, 0.06839807f, 0.01110481f, 
    0.02310677f, 0.17137487f, 0.14144422f, -0.13542962f, 0.04848964f, 0.06491756f, -0.20477875f, -0.03047004f, 
    0.03816879f, 0.10050671f, -0.13510358f, 0.14839810f, -0.10085153f, -0.17846560f, -0.12883638f, -0.77851528f, 
    0.00920321f, 0.07571298f, -0.04161822f, 0.01947067f, 0.05317489f, -0.02905219f, 0.02291888f, 0.00384840f, 
    -0.11898708f, 0.04327462f, 0.03466036f, -0.15835038f, 0.09788608f, 0.04153617f, 0.06868206f, -0.14617528f, 
    -0.09998040f, 0.21183781f, 0.11770307f, 0.04180422f, 0.14570409f, -0.22040400f, 0.01512917f, 0.00633518f, 
    -0.09842164f, 0.15214701f, 0.10276435f, 0.03898415f, 0.03647041f, -0.06107059f, 0.11933901f, -0.07399076f, 
    -0.05156844f, -0.03622333f, 0.09762168f, 0.23094389f, -0.16751558f, 0.32493910f, 0.12076338f, -0.09905351f, 
    0.39176214f, -0.14855465f, 0.11864296f, -0.03425220f, -0.07745346f, -0.01337368f, -0.05558494f, -0.01409481f, 
    0.13148779f, -0.04741448f, -0.02594316f, 0.05600139f, -0.05078677f, 0.14583282f, -0.02158883f, 0.01575092f, 
    0.30630675f, -0.41998374f, -0.22286811f, 0.12073885f, 0.04289373f, -0.20975596f, -0.00200598f, -0.07041303f, 
    0.03441719f, -0.10696156f, 0.00903839f, 0.03646789f, -0.03505708f, 0.21325696f, -0.08913063f, 0.20201124f, 
    -0.13271801f, 0.07981848f, 0.04438793f, -0.02784809f, 0.19490464f, 0.15524572f, 0.12614125f, 0.13016684f, 
    0.10585839f, -0.00246642f, -0.08225992f, 0.00719884f, -0.02763158f, 0.15835650f, 0.07421366f, -0.04886850f, 
    0.09944579f, -0.00616150f, 0.00158425f, -0.03096684f, 0.04870632f, 0.04372156f, 0.08921131f, 0.11772777f, 
    0.06673303f, 0.20638424f, -0.21829252f, 0.09167964f, 0.05665877f, 0.10847456f, -0.01941261f, 0.03433651f, 
    -0.01555073f, 0.00292571f, 0.03825535f, 0.00510881f, -0.06328939f, 0.05276613f, -0.05763949f, 0.05860081f, 
    0.00868211f, 0.10176166f, -0.04046822f, -0.06120720f, 0.25937861f, 0.03095207f, 0.04415566f, 0.11739434f, 
    0.22245403f, 0.00417505f, -0.07707664f, 0.06773786f, 0.01729543f, -0.00189852f, -0.09492893f, -0.04294768f, 
    -0.05507299f, 0.05677880f, 0.04900146f, 0.01171553f, 0.00001324f, -0.04285198f, -0.04065332f, -0.05525617f, 
    0.03747261f, 0.03075885f, 0.19443488f, -0.07447885f, 0.23102544f, -0.00782563f, -0.09334639f, -0.11866660f, 
    0.06407959f, -0.02765266f, 0.05202997f, 0.04347045f, -0.02054506f, 0.01046618f, 0.07427008f, -0.08447643f, 
    0.00905869f, 0.09694133f, 0.05787648f, -0.09895166f, -0.18898343f, 0.07842222f, -0.09127837f, 0.02535899f, 
    0.09988382f, -0.04337132f, -0.02780920f, -0.15300956f, -0.06116033f, 0.00729003f, 0.16514125f, 0.18751808f, 
    -0.09513553f, -0.10554840f, 0.12214898f, -0.00386399f, -0.07974441f, 0.01388683f, -0.00714715f, 0.10548075f, 
    0.20128985f, -0.01891829f, -0.14567412f, 0.02474129f, -0.31925032f, -0.02621739f, -0.09210427f, -0.05132734f, 
    -0.04858583f, 0.08489281f, 0.08389521f, 0.07936850f, -0.05750475f, -0.01456092f, 0.02864347f, -0.01899295f, 
    0.11091652f, -0.09550020f, -0.05874924f, -0.01610090f, -0.58885175f, 0.01132190f, 0.01389252f, -0.03603369f, 
    -0.23965488f, 0.01419281f, -0.01802184f, -0.00455307f, 0.17673637f, -0.06201473f, -0.09182253f, 0.07481629f, 
    0.01447552f, 0.04894619f, -0.05163415f, 0.01969149f, -0.07965229f, -0.01951481f, -0.07261163f, -0.12066194f, 
    0.18159766f, -0.23043351f, 0.10711989f, 0.04051671f, 0.19054459f, 0.06982897f, 0.00067981f, -0.02068494f, 
    -0.02273219f, 0.05221711f, 0.14093715f, 0.06323694f, 0.00152720f, -0.04940458f, -0.21730815f, -0.01670303f, 
    -0.01660694f, 0.01321921f, -0.09064218f, -0.01170551f, 0.29505229f, -0.05041560f, 0.23867752f, -0.06001201f, 
    -0.06265922f, -0.09493510f, -0.11215894f, -0.08349974f, -0.04648480f, -0.09497350f, -0.08075585f, -0.06897529f, 
    -0.09711578f, -0.00161194f, -0.02339662f, 0.06641115f, 0.13745855f, -0.08696159f, -0.02056601f, -0.08135268f, 
    0.38574886f, -0.05602624f, 0.02692914f, 0.03123961f, -0.12477690f, 0.03269877f, 0.00438125f, 0.09780197f, 
    0.05320714f, 0.15660225f, -0.06188572f, -0.17606916f, 0.05434112f, 0.03415070f, 0.08433595f, 0.12200490f, 
    0.03074104f, 0.06987999f, -0.15690826f, 0.01719324f, 0.48410258f, -0.23336245f, 0.04434984f, -0.06307147f, 
    -0.04973592f, -0.12586923f, 0.06308853f, 0.01085800f, 0.10703260f, -0.03313773f, 0.03193745f, 0.00061259f, 
    -0.05003969f, -0.04364250f, 0.07256105f, 0.02594429f, 0.00701992f, 0.01627955f, -0.05017477f, 0.19310427f, 
    0.26627576f, -0.21814044f, -0.00653566f, -0.30625290f, -0.10228059f, 0.05748292f, -0.10678003f, 0.03622525f, 
    -0.13525012f, 0.03794928f, -0.06699216f, -0.07262475f, 0.01219671f, 0.02671254f, -0.02950277f, 0.00177753f, 
    -0.12257031f, 0.05523229f, 0.04911699f, -0.05590594f, 0.30068865f, 0.14664207f, -0.17075665f, -0.01345854f, 
    -0.28241864f, -0.11912855f, 0.04371223f, -0.08701373f, -0.01487262f, 0.02337928f, -0.00815577f, -0.07174325f, 
    -0.06793344f, -0.09143839f, 0.02597832f, 0.09343994f, 0.03639267f, 0.05608192f, 0.09808537f, -0.11299130f, 
    0.50602174f, -0.34190294f, -0.19781779f, -0.22963339f, -0.12812051f, -0.14922878f, 0.03591742f, -0.17315985f, 
    0.08685571f, -0.05822701f, 0.09029603f, -0.07300336f, 0.04028442f, 0.09489912f, -0.05556894f, 0.09488747f, 
    0.07216292f, 0.05256524f, 0.08162746f, -0.04839128f, -0.34119388f, -0.09291533f, 0.18574305f, -0.19151185f, 
    0.03271345f, 0.04754446f, 0.03453273f, 0.03127158f, 0.08445597f, 0.04687461f, 0.06067953f, -0.02129719f, 
    0.11610590f, -0.08813107f, 0.06317022f, 0.07681699f, -0.07464723f, -0.06459997f, -0.03029354f, -0.01026143f, 
    -0.08050475f, 0.12269907f, -0.06539220f, -0.19368187f, 0.01792788f, 0.04041778f, 0.04656701f, 0.01276756f, 
    -0.05642201f, -0.04979154f, -0.02787008f, 0.05679836f, -0.04879684f, -0.17345221f, -0.05602980f, 0.01937326f, 
    0.00424704f, 0.05790771f, 0.01966865f, 0.00239158f, -0.14197779f, -0.06358876f, -0.15919207f, 0.15338056f, 
    -0.23052925f, -0.00571055f, -0.09316609f, 0.07808293f, 0.11799771f, 0.09021849f, -0.06156312f, -0.10020008f, 
    -0.05668998f, 0.03014747f, -0.02487528f, 0.01018536f, 0.02685797f, 0.00457607f, -0.02021591f, -0.09802260f, 
    0.43924856f, -0.01972422f, 0.25058043f, -0.06518938f, 0.26252326f, 0.01511668f, -0.08088076f, -0.16930827f, 
    0.15544501f, 0.18199371f, 0.04318586f, 0.01693706f, -0.02545266f, 0.02458880f, 0.00637937f, 0.03378747f, 
    -0.12206259f, 0.03510213f, 0.05184144f, 0.03884129f, 0.30530313f, -0.13526496f, -0.28342330f, 0.06784688f, 
    -0.04566653f, -0.18973015f, -0.01993452f, 0.15057163f, -0.06418416f, -0.06077249f, 0.08157276f, -0.00934143f, 
    0.06313567f, -0.07441632f, 0.04908900f, 0.02770162f, -0.00192965f, -0.08420295f, 0.08080322f, 0.00750128f, 
    0.09181535f, -0.40570062f, 0.24493748f, -0.08598460f, 0.13592365f, 0.00870441f, -0.19308308f, 0.04503631f, 
    0.02675944f, 0.14076826f, 0.03796326f, -0.01770006f, 0.07257710f, -0.00940404f, -0.05366772f, -0.01547615f, 
    -0.16327147f, -0.02650381f, -0.06835088f, -0.04157525f, 0.06817698f, 0.24163596f, -0.00471098f, -0.20096849f, 
    -0.14628026f, 0.15564388f, 0.05657448f, 0.09743722f, -0.02333436f, -0.09871554f, -0.06413055f, 0.06601647f, 
    -0.05895345f, 0.01784761f, -0.08954709f, -0.02776124f, -0.06420989f, 0.08520865f, 0.07773608f, 0.05350979f, 
    -0.32684249f, -0.36271465f, -0.13767186f, -0.29799244f, -0.39351839f, 0.06838243f, -0.09697869f, -0.13885775f, 
    -0.02331603f, -0.01101102f, -0.00047769f, 0.03415858f, -0.02167803f, -0.02931732f, -0.00661058f, -0.11201131f, 
    -0.03059127f, 0.06532893f, -0.01366535f, -0.10514896f, 0.13803980f, -0.28024316f, 0.19436026f, 0.01086816f, 
    0.26075229f, -0.23055044f, -0.07720130f, -0.10785002f, 0.04121051f, 0.05153217f, 0.12971741f, -0.09759364f, 
    0.00497989f, 0.06755853f, 0.08599760f, -0.00666553f, -0.03162903f, -0.00593739f, -0.07359912f, 0.00713361f, 
    -0.03265639f, -0.34763822f, -0.21166812f, -0.18186554f, -0.50603205f, -0.08575378f, -0.04927931f, 0.09781466f, 
    0.03854063f, 0.02476553f, -0.03919305f, -0.04580443f, -0.05921900f, -0.04008758f, 0.01339122f, -0.03539037f, 
    -0.10651002f, 0.09059030f, 0.03895936f, 0.03248753f, 0.05163718f, 0.03622255f, 0.02080941f, 0.00912302f, 
    -0.04719473f, 0.00128384f, 0.10883860f, 0.01268004f, 0.00868033f, -0.04401863f, 0.05442054f, -0.04980996f, 
    0.04206902f, -0.09847053f, -0.05928665f, 0.04872172f, 0.01045711f, 0.03677950f, 0.00593213f, -0.05088421f, 
    0.13177279f, 0.16866927f, 0.00162581f, 0.05487491f, 0.12911798f, -0.02755795f, 0.01428721f, -0.06389502f, 
    0.02756063f, 0.06623210f, 0.03177107f, -0.00705391f, -0.02648419f, -0.02491584f, -0.04225864f, 0.04334575f, 
    -0.02095321f, -0.05179220f, -0.06841840f, 0.03583825f, -0.28031474f, 0.18404664f, 0.04777404f, -0.24116562f, 
    0.03507722f, 0.04346734f, 0.12288705f, 0.20542513f, 0.00168433f, -0.10294924f, -0.03042795f, 0.08484767f, 
    0.04229712f, -0.10492945f, -0.03058200f, 0.03553932f, -0.04799321f, -0.06710491f, 0.06709874f, -0.05780766f, 
    0.36222953f, 0.12808692f, -0.45715073f, -0.22091414f, -0.09174660f, 0.08942731f, 0.11248935f, 0.10629249f, 
    -0.14060099f, -0.08456924f, -0.11021340f, -0.15377942f, 0.09014861f, -0.06006827f, -0.01334759f, 0.00798534f, 
    0.01399280f, -0.16355972f, -0.04320623f, -0.00218896f, -0.37171316f, -0.36733723f, -0.26486561f, -0.21265580f, 
    -0.46921539f, 0.06249011f, 0.05551447f, 0.06636001f, -0.14371271f, 0.04834018f, -0.10834007f, 0.02348965f, 
    0.06983088f, 0.03752496f, -0.05065831f, -0.03344868f, 0.05479674f, -0.00954019f, -0.00673031f, -0.00963105f, 
    0.04232937f, -0.01822239f, 0.06974911f, 0.00450924f, -0.09905732f, -0.02086514f, 0.12714858f, -0.01234644f, 
    -0.04722408f, 0.00811469f, -0.02823083f, 0.08510529f, -0.08804671f, -0.00828248f, 0.10068972f, 0.04017969f, 
    -0.04456868f, 0.09072825f, 0.00066118f, 0.04978427f, 0.28922200f, 0.06761858f, -0.09020004f, -0.04931283f, 
    -0.11072274f, 0.05433148f, 0.00940803f, 0.09690485f, -0.01564824f, -0.04427632f, 0.00251121f, 0.07099945f, 
    -0.01927269f, 0.00146278f, 0.04834990f, -0.00032828f, -0.14524226f, -0.13317937f, -0.03450120f, -0.07477433f, 
    0.55711293f, -0.05243038f, 0.20882039f, -0.08001171f, -0.27843985f, -0.01929304f, 0.10502902f, 0.12829572f, 
    -0.02065320f, -0.06084864f, -0.05863568f, -0.05014070f, 0.02538548f, 0.00786617f, -0.08282067f, 0.10140967f, 
    -0.02777626f, -0.05785328f, 0.12194479f, 0.01555858f, -0.18945783f, 0.13916917f, 0.12103746f, -0.07071546f, 
    0.08780292f, 0.00096272f, 0.04283833f, -0.00199871f, 0.04939235f, -0.00291668f, -0.06386964f, -0.03175406f, 
    0.03703004f, -0.04286242f, 0.03925170f, 0.00953256f, -0.00541076f, -0.13384216f, -0.06928286f, -0.01009999f, 
    0.02401693f, 0.06953321f, -0.10490757f, 0.06947443f, 0.11074070f, -0.03031342f, 0.09821936f, -0.01304952f, 
    -0.08326792f, -0.14278184f, -0.07630423f, 0.03575598f, -0.03873900f, 0.05839844f, 0.00583250f, 0.00973911f, 
    0.04072644f, -0.10416472f, -0.03887319f, -0.08276406f, -0.11157577f, 0.05357967f, -0.07675389f, -0.09891267f, 
    0.06224393f, 0.08859106f, 0.04326683f, 0.14236934f, -0.05210984f, -0.03569698f, -0.00575474f, 0.11105642f, 
    -0.06731737f, -0.07741949f, -0.13644244f, -0.04630264f, 0.04952096f, 0.07012534f, -0.20041883f, 0.04212969f, 
    0.16077530f, -0.02606714f, -0.01011163f, -0.14181347f, -0.10890844f, 0.03964311f, -0.05490450f, 0.11602325f, 
    -0.08597103f, 0.11998902f, 0.00340342f, 0.00183676f, 0.10420208f, 0.13532023f, -0.07397858f, -0.10516392f, 
    -0.07149773f, 0.04341919f, -0.11959144f, -0.09235498f, 0.28693283f, -0.00146183f, 0.04304979f, 0.09640384f, 
    0.20177996f, 0.01837269f, -0.15602569f, -0.04886757f, 0.09542386f, 0.15438692f, 0.04332060f, -0.00934461f, 
    0.00378623f, -0.00740908f, 0.02791816f, -0.01887641f, -0.08793427f, -0.09421799f, -0.14835285f, -0.09189423f, 
    0.17128640f, -0.14642932f, 0.00573133f, 0.14671005f, 0.15497318f, -0.14955041f, -0.11831834f, -0.12882882f, 
    -0.03020443f, 0.01492342f, 0.05525196f, -0.06213322f, -0.04611718f, 0.00723996f, 0.01516022f, -0.03413397f, 
    -0.03260474f, -0.02381374f, -0.01576801f, 0.03763012f, 0.23178014f, -0.09921216f, -0.20623916f, 0.09437805f, 
    -0.37287378f, -0.09420139f, 0.14128001f, -0.06716902f, -0.04415865f, -0.12539132f, -0.02374466f, 0.01398073f, 
    -0.07090890f, -0.09852548f, -0.09786285f, 0.04286152f, 0.02105918f, -0.05263507f, 0.12191477f, -0.05567808f, 
    -0.02672460f, 0.15935509f, -0.16301587f, -0.25354132f, 0.10298228f, 0.05466089f, -0.02810700f, 0.00960922f, 
    0.13409247f, -0.02373046f, -0.02087135f, -0.03355559f, -0.02872900f, -0.00426154f, 0.00804210f, -0.04912655f, 
    0.06804703f, -0.03494098f, 0.04396262f, -0.03648753f, 0.02972925f, 0.11618619f, 0.11026771f, -0.12136391f, 
    -0.02629102f, -0.08417756f, -0.00534204f, 0.02239109f, -0.00996685f, -0.12340853f, -0.11573436f, 0.01691287f, 
    0.09707237f, -0.01644916f, -0.01589150f, -0.04914298f, -0.17580175f, 0.00202830f, 0.06297928f, 0.02459114f, 
    0.49731034f, -0.19973969f, -0.11065826f, 0.25469220f, -0.01846480f, -0.27664858f, -0.04930214f, -0.09631070f, 
    -0.09470604f, 0.02406087f, 0.05261658f, -0.00520904f, 0.06224490f, -0.00001604f, -0.09915189f, -0.02058800f, 
    -0.08842628f, 0.05552523f, 0.06051605f, 0.06766863f, 0.15945418f, 0.10946702f, 0.13785946f, 0.03619082f, 
    -0.08923610f, -0.02345035f, -0.10519038f, -0.01337509f, -0.00119951f, 0.03609369f, -0.04224658f, -0.05693413f, 
    0.03983107f, 0.02413336f, -0.00420812f, -0.04451245f, -0.06998731f, -0.06532858f, 0.01138722f, 0.02674249f, 
    0.41678095f, 0.28084770f, -0.10700238f, -0.00647859f, 0.02953544f, 0.02276813f, 0.00021383f, 0.07622602f, 
    0.08467831f, -0.04636585f, -0.08921944f, -0.09196863f, 0.00036196f, 0.03278054f, -0.09617501f, -0.07400563f, 
    0.08146449f, -0.00144378f, 0.06306858f, 0.10781143f, -0.28477967f, 0.31975004f, 0.08336788f, 0.17476237f, 
    0.06767020f, 0.03168364f, 0.05307066f, 0.11052076f, 0.00147079f, -0.05782263f, 0.01369763f, -0.04713958f, 
    -0.05185691f, 0.00749088f, -0.15854235f, 0.06649128f, -0.09605891f, 0.05178136f, 0.02189586f, 0.01211466f, 
    -0.11620781f, 0.28325269f, 0.09946712f, 0.14457302f, 0.06065715f, -0.09022101f, -0.15420325f, -0.02691349f, 
    -0.04262151f, 0.01600856f, 0.03748683f, -0.06207912f, -0.01336703f, -0.05426599f, 0.04825706f, -0.02460073f, 
    0.03110548f, 0.07698425f, 0.11145847f, -0.06859404f, -0.16611604f, -0.09891088f, -0.27866748f, 0.08946842f, 
    -0.19181092f, -0.06571367f, -0.01160721f, -0.04574012f, -0.02906043f, 0.01616801f, -0.07034633f, -0.04028483f, 
    0.07966516f, 0.09131522f, 0.03430952f, 0.01325785f, -0.05216257f, 0.06626909f, -0.10568972f, -0.04071569f, 
    -0.08470465f, -0.09211299f, -0.03798884f, -0.07999796f, 0.21269190f, 0.05403437f, 0.13851395f, 0.00462848f, 
    -0.08396994f, 0.09040377f, 0.06934689f, -0.00466749f, 0.03169166f, 0.01857629f, -0.04969605f, -0.02480642f, 
    0.00154763f, 0.08144751f, -0.00641999f, 0.02158802f, 0.08676146f, 0.11677738f, 0.09285334f, 0.13637027f, 
    -0.15080091f, -0.03966502f, 0.09764680f, 0.00700730f, -0.00588848f, -0.03578698f, -0.08950347f, 0.03276637f, 
    -0.09366499f, 0.02853436f, -0.00736113f, 0.04443891f, 0.02291956f, -0.09650923f, 0.01452199f, 0.07817953f, 
    0.05717469f, 0.18143937f, -0.32164586f, -0.11722771f, -0.07209367f, -0.02968123f, -0.11818958f, -0.04482251f, 
    0.09201745f, -0.07833254f, 0.00040616f, -0.08743723f, 0.02289818f, 0.00809081f, 0.03612870f, -0.15708888f, 
    -0.03697914f, 0.06154513f, 0.03716957f, 0.03378733f, -0.03472599f, -0.14406763f, 0.17211121f, -0.15719873f, 
    -0.03511425f, 0.02026860f, -0.06559052f, -0.00528597f, 0.00877255f, -0.02899970f, 0.01691927f, -0.02834067f, 
    0.07398207f, -0.01520360f, -0.08473568f, -0.09168395f, 0.06827718f, -0.04647859f, -0.02248452f, 0.02028670f, 
    -0.18025374f, -0.18976131f, -0.14145343f, 0.07304348f, -0.07573470f, -0.00053736f, -0.13720667f, -0.00905000f, 
    -0.08447476f, -0.05793943f, -0.12325025f, -0.10196648f, 0.03558293f, 0.01344579f, 0.07887416f, 0.03666319f, 
    0.08814815f, 0.05072144f, -0.11496250f, 0.02248324f, 0.68228942f, 0.31367511f, -0.12089607f, 0.18445933f, 
    0.00648388f, 0.07015810f, -0.01854215f, -0.00395928f, 0.11293618f, 0.00357710f, -0.04490387f, -0.08640465f, 
    -0.11399758f, 0.02697831f, -0.04083366f, -0.02015848f, 0.04716907f, -0.00585410f, -0.01384683f, -0.01306147f, 
    0.21761329f, 0.21637835f, -0.00288693f, 0.06853250f, -0.06144111f, -0.02922974f, -0.02911414f, -0.00310239f, 
    0.05323195f, -0.04557556f, -0.00946457f, -0.04547946f, -0.02591584f, -0.01502018f, 0.02677687f, -0.02367887f, 
    -0.01251669f, 0.16578266f, -0.03308881f, 0.05668054f, 0.03208299f, -0.06820615f, -0.03664974f, 0.05646434f, 
    -0.12412464f, -0.05456325f, -0.15237200f, 0.03417226f, -0.10045097f, 0.05054823f, 0.03361786f, 0.05848645f, 
    0.06312469f, -0.00928052f, 0.10480347f, -0.10703603f, -0.04269669f, 0.01681427f, 0.04411016f, 0.01172862f, 
    0.23591116f, 0.00583135f, 0.25691661f, -0.03702970f, -0.00535979f, -0.04175666f, 0.04069755f, -0.04756735f, 
    0.02184727f, 0.12778719f, 0.04521870f, 0.01298511f, 0.00705294f, -0.05367660f, -0.03342635f, 0.01143338f, 
    -0.02170266f, -0.01831579f, 0.06205514f, 0.05483675f, -0.04778784f, -0.01081708f, -0.03397388f, 0.17743197f, 
    0.06363395f, 0.08904725f, 0.03474321f, 0.10250573f, 0.00435236f, 0.04819489f, -0.07839314f, 0.08121490f, 
    -0.10470040f, -0.17500028f, -0.08736058f, -0.00242870f, 0.01708748f, 0.13022874f, -0.01937913f, -0.10356868f, 
    -0.33226401f, 0.22711350f, -0.02622129f, -0.22327203f, -0.24518278f, -0.06870469f, -0.03113965f, -0.00222457f, 
    -0.00640656f, -0.10747555f, 0.00645759f, -0.03024287f, -0.09380300f, -0.01678932f, -0.09391724f, -0.04863693f, 
    -0.03226155f, -0.07085560f, 0.05236197f, 0.04869366f, -0.09586259f, -0.61339921f, -0.31725597f, 0.18529440f, 
    0.22261851f, 0.00440276f, 0.07507142f, 0.04587813f, -0.06212335f, -0.03373080f, 0.06296220f, -0.00953544f, 
    -0.10557424f, -0.06587777f, 0.02181725f, -0.06902385f, -0.06712861f, -0.07134169f, 0.05165207f, -0.10101577f, 
    -0.24207191f, 0.33867094f, -0.00983487f, 0.02069978f, 0.20355123f, 0.03193123f, 0.09201844f, -0.04133929f, 
    0.12293510f, -0.01363317f, -0.01618765f, -0.01426285f, -0.04582809f, 0.03103948f, -0.12315194f, -0.10909534f, 
    0.06973603f, -0.25316271f, 0.19593529f, 0.04840248f, -0.01294299f, 0.33580735f, 0.16661105f, 0.18794845f, 
    0.06189600f, -0.05103318f, 0.12581415f, 0.00145754f, -0.01536863f, 0.09034620f, 0.00621297f, 0.01945863f, 
    -0.00168240f, 0.00559438f, -0.02501108f, -0.00364554f, 0.05931967f, 0.15284286f, 0.19359717f, 0.03290760f, 
    -0.03679926f, -0.51087481f, -0.04022821f, 0.13941766f, 0.01357407f, 0.17468476f, 0.02640861f, 0.07599695f, 
    0.02911141f, -0.13211785f, 0.02103666f, 0.02725346f, -0.17489223f, -0.02963113f, -0.06188798f, -0.01232896f, 
    0.07071656f, 0.03335020f, -0.05016237f, -0.02150155f, -0.55299455f, -0.20729735f, 0.09668832f, -0.03401272f, 
    -0.20410326f, -0.05718637f, -0.07536415f, 0.03083310f, 0.05589383f, -0.13220920f, 0.04542124f, -0.02813767f, 
    0.08912884f, 0.05696185f, 0.05313621f, -0.00002518f, -0.02087720f, -0.21217053f, -0.02231815f, 0.06197031f, 
    -0.04198211f, 0.09116802f, 0.15589401f, 0.05523285f, 0.12461576f, 0.01843160f, -0.02225882f, 0.01013805f, 
    0.05551985f, -0.04260442f, -0.01591885f, 0.00776333f, -0.05928718f, -0.08086712f, 0.04517554f, -0.08617678f, 
    0.10677404f, -0.09528019f, -0.07184783f, -0.03149195f, -0.24587157f, -0.47099635f, -0.35965499f, -0.01222952f, 
    -0.04813740f, -0.13375318f, -0.04734058f, -0.00566369f, 0.02440719f, -0.17476293f, -0.02762848f, -0.01524724f, 
    -0.02812963f, -0.00725620f, 0.03199751f, -0.02349180f, -0.12998736f, 0.05171501f, -0.03800928f, -0.07010965f, 
    -0.57148945f, 0.12478327f, -0.17137414f, 0.16229767f, 0.19457343f, 0.00159878f, 0.07049125f, 0.00284567f, 
    0.03635283f, 0.04540525f, -0.05750637f, 0.00959537f, 0.06216468f, -0.14223987f, 0.13090412f, -0.01921804f, 
    0.06736699f, -0.03201913f, -0.00807400f, -0.05340968f, -0.11018090f, -0.59833527f, -0.43048772f, 0.07555375f, 
    0.20353280f, 0.00008894f, 0.01234932f, 0.07420243f, -0.04124358f, -0.01280082f, 0.02683916f, 0.00539160f, 
    0.01385921f, 0.05671183f, -0.10587520f, 0.05119763f, 0.02449603f, 0.05997114f, -0.01161047f, 0.05478187f, 
    0.00131658f, 0.05314852f, -0.16866730f, -0.01119065f, -0.18627603f, -0.18433823f, -0.05304172f, 0.09713233f, 
    0.09634729f, 0.08799570f, -0.03894842f, -0.02899900f, -0.02253078f, 0.07345923f, 0.01700536f, -0.04141898f, 
    0.00365699f, 0.00937663f, -0.06006217f, 0.10096956f, -0.41430181f, 0.12555481f, 0.02958777f, -0.12167220f, 
    -0.23228385f, -0.11407772f, -0.17611158f, 0.09777543f, -0.03828659f, 0.00908015f, -0.00221324f, -0.07149028f, 
    0.00318720f, -0.03671793f, -0.06050636f, 0.07038498f, 0.05059293f, 0.01556443f, 0.10873289f, 0.10369617f, 
    0.07839434f, -0.01284009f, -0.02886667f, -0.01211403f, -0.05206320f, -0.10518998f, -0.18245295f, 0.06109625f, 
    -0.01396009f, 0.01330900f, -0.11767617f, 0.05104657f, 0.12238131f, -0.00168547f, 0.04799774f, -0.03314366f, 
    -0.03488467f, 0.07263310f, 0.07969700f, -0.00394954f, 0.03753690f, 0.12330721f, 0.10948801f, 0.26487124f, 
    0.07845861f, -0.05691163f, 0.04386574f, 0.00390746f, -0.08858106f, -0.08176363f, -0.03184615f, -0.01438837f, 
    0.06673557f, -0.12620471f, -0.03605367f, 0.03191717f, 0.05952205f, -0.14706966f, 0.02067986f, -0.04329491f, 
    -0.18009070f, 0.07869992f, -0.13427940f, 0.04925075f, -0.01442500f, 0.01508144f, 0.15842175f, -0.03723232f, 
    0.12054116f, -0.00616451f, -0.07420234f, -0.02030715f, -0.06110876f, -0.01623619f, 0.00781572f, 0.01036924f, 
    0.07370415f, -0.06389029f, 0.06459739f, 0.05473741f, -0.20437558f, -0.35602430f, -0.24411108f, -0.01308042f, 
    -0.25932020f, -0.19772154f, -0.08763137f, -0.01769703f, 0.13900337f, -0.05035957f, -0.07851593f, -0.04327559f, 
    0.02280656f, -0.02048359f, 0.04227327f, -0.04801999f, -0.05690222f, 0.11319838f, -0.02557696f, -0.12813471f, 
    0.16675369f, -0.06920102f, 0.04594691f, -0.03212859f, -0.09619020f, -0.10922451f, -0.25314984f, 0.04614655f, 
    -0.15947418f, -0.00689607f, -0.09737681f, 0.08462320f, -0.05263541f, -0.00026304f, 0.13500941f, -0.02563179f, 
    0.06806104f, 0.06302039f, 0.10102586f, -0.04037695f, 0.04274195f, -0.16317055f, -0.18428057f, -0.06211375f, 
    -0.23743756f, -0.15203778f, -0.16521014f, 0.04136024f, -0.08720025f, 0.00167992f, -0.01997453f, 0.03818133f, 
    -0.04922302f, 0.05442831f, -0.00278624f, 0.00071027f, 0.03722643f, -0.08291084f, 0.05165894f, -0.02750374f, 
    -0.32899308f, -0.05354074f, -0.01380597f, -0.12711251f, -0.13459006f, 0.10658167f, -0.04461436f, 0.03686973f, 
    -0.10461295f, -0.06743523f, -0.06560074f, -0.01118234f, 0.00603988f, 0.04558889f, -0.03682737f, -0.03230481f, 
    0.13954759f, -0.08485653f, -0.03733788f, 0.04973636f, -0.25799429f, -0.15168677f, 0.03774783f, 0.00261562f, 
    0.03623131f, -0.04618109f, -0.10311205f, -0.05447461f, -0.02799102f, 0.02181759f, -0.09268732f, -0.01169567f, 
    0.06921907f, -0.02433477f, -0.02078838f, -0.07081340f, -0.03938679f, -0.10811914f, 0.06730744f, -0.07356496f, 
    -0.31661618f, -0.03109974f, -0.09735432f, 0.04508582f, -0.01404422f, 0.06482806f, 0.05572216f, -0.08111714f, 
    0.07807231f, -0.01612077f, -0.06258075f, 0.05065208f, -0.05094887f, 0.01493262f, -0.03653559f, 0.02252055f, 
    0.03162851f, -0.01510463f, 0.14583883f, -0.11271977f, -0.05803112f, 0.26784459f, 0.26070991f, -0.08443806f, 
    -0.18403746f, 0.09356499f, 0.02998201f, -0.07953664f, 0.02514972f, -0.10538547f, 0.10006113f, 0.06652067f, 
    -0.09524384f, 0.03445305f, 0.03189212f, -0.00662479f, -0.02142220f, -0.17651175f, -0.16163519f, -0.01222551f, 
    0.00801045f, -0.18568529f, 0.12552992f, 0.11552022f, -0.07241609f, -0.05957022f, -0.04147149f, 0.02674682f, 
    -0.00997239f, 0.03039514f, 0.10958863f, 0.05435289f, 0.03732326f, -0.14072108f, 0.09915099f, 0.04034183f, 
    0.06353775f, -0.01381452f, -0.01139903f, 0.09930953f, 0.01719993f, 0.14393397f, -0.32396221f, 0.17610697f, 
    -0.22607064f, -0.01513327f, -0.07513323f, -0.03972285f, -0.11495015f, 0.03727238f, 0.02634864f, 0.07085403f, 
    0.01436829f, 0.03620505f, -0.00226974f, -0.03696606f, -0.07871922f, 0.11997678f, -0.04350993f, 0.03867665f, 
    -0.42842835f, -0.11823048f, -0.09350675f, -0.00567277f, 0.03823051f, 0.06768884f, 0.03604348f, 0.14539389f, 
    -0.14604747f, 0.01590049f, 0.10608541f, -0.01961615f, 0.01296943f, 0.04738201f, -0.02269137f, -0.01430810f, 
    -0.00451321f, 0.18683822f, 0.11695499f, 0.06094942f, 0.54956245f, 0.29415914f, -0.13862142f, -0.40793040f, 
    0.01892856f, -0.09526306f, -0.02843068f, 0.03578499f, 0.13667239f, -0.15509303f, -0.07011005f, -0.03972591f, 
    0.00410608f, -0.00948469f, -0.06842694f, -0.10817179f, 0.01488434f, -0.14172466f, -0.07462421f, 0.06113723f, 
    -0.37459362f, 0.13864240f, 0.11801504f, 0.06458123f, -0.14183111f, -0.02011656f, -0.13886277f, -0.05800828f, 
    0.09138236f, -0.05364924f, -0.16267349f, -0.00855724f, -0.04633320f, 0.11313443f, 0.13037601f, -0.06671586f, 
    0.04718836f, 0.13621284f, -0.07682280f, -0.04378951f, 0.17661652f, -0.02491600f, 0.10952571f, -0.29579628f, 
    -0.26364058f, 0.03050193f, 0.09536193f, -0.12749901f, 0.09465475f, 0.05133120f, -0.07514825f, -0.16264521f, 
    0.02052290f, 0.05713413f, 0.04188372f, -0.18329430f, 0.06169584f, 0.05603444f, -0.08866440f, 0.12424745f, 
    0.07939176f, -0.06193928f, 0.22430970f, 0.01774427f, -0.05268748f, 0.05683767f, 0.12483154f, -0.11470381f, 
    0.15447879f, 0.05629526f, 0.16558520f, -0.00194583f, -0.02803096f, 0.02403804f, 0.15103076f, 0.06090599f, 
    0.07572500f, -0.04995414f, 0.04732872f, 0.15672626f, -0.85716552f, 0.31277421f, 0.15958230f, 0.15450741f, 
    0.10019742f, 0.07160427f, -0.04883626f, -0.13286605f, 0.11643513f, -0.03863809f, -0.03341848f, -0.01354380f, 
    -0.01130263f, 0.04331163f, 0.05055688f, 0.03805229f, 0.00639349f, 0.09217308f, 0.12557817f, 0.01654604f, 
    0.24183501f, 0.17974114f, -0.26780221f, 0.08449513f, -0.21946414f, -0.01088737f, -0.05827247f, 0.10686465f, 
    0.04795824f, -0.18685594f, -0.02612067f, -0.03582206f, 0.09403700f, -0.03630692f, -0.00860384f, 0.07518417f, 
    0.00481710f, 0.16478457f, 0.02026442f, 0.03510973f, -0.26168233f, -0.25758836f, 0.25461394f, 0.15408584f, 
    -0.00084895f, 0.05618226f, -0.02550211f, -0.13233511f, -0.10359825f, 0.01389282f, 0.00916342f, -0.01305893f, 
    -0.10935746f, -0.00464426f, 0.10312434f, -0.07712446f, -0.10750096f, -0.00078718f, -0.05438033f, 0.03471748f, 
    0.06235775f, -0.06002212f, -0.13474201f, 0.10717876f, 0.09821991f, 0.08019710f, 0.16219775f, 0.13668641f, 
    -0.02873345f, -0.01853831f, -0.01941097f, 0.02347161f, 0.05489028f, 0.07375523f, -0.11760301f, 0.02294572f, 
    -0.03430890f, -0.10991389f, 0.11696021f, -0.04642365f, -0.27068171f, -0.63871068f, 0.05996877f, 0.16594750f, 
    0.05705875f, -0.24247853f, 0.01311585f, -0.04170907f, -0.14952537f, 0.01870327f, 0.13233659f, -0.01960181f, 
    0.00017469f, -0.14220022f, 0.01135864f, -0.03045131f, -0.10108344f, 0.05818022f, -0.10904507f, 0.00159623f, 
    -0.36337996f, 0.25160012f, 0.35274750f, 0.13920608f, 0.02717895f, -0.13460961f, -0.00249996f, 0.10926197f, 
    -0.04970064f, -0.10341650f, 0.01773755f, 0.03395873f, -0.09544725f, -0.09311605f, 0.02942496f, 0.07763864f, 
    -0.07530114f, -0.01660006f, -0.04647841f, -0.06903666f, 0.26710880f, -0.01668717f, -0.11983171f, -0.04182649f, 
    0.04415827f, -0.05874832f, 0.00808117f, 0.13656361f, 0.11407469f, -0.05518945f, 0.06244186f, -0.07902692f, 
    0.01135484f, 0.09731692f, 0.06958333f, -0.01092221f, -0.05893311f, 0.12503150f, -0.02199201f, 0.04687646f, 
    -0.15189712f, 0.08452614f, -0.17605567f, -0.32552132f, -0.05762749f, 0.03502451f, -0.03476656f, -0.14389437f, 
    0.09999310f, -0.10525284f, -0.03078542f, -0.10959930f, -0.03234547f, 0.21403496f, -0.07081798f, -0.01752634f, 
    0.07488210f, 0.00615893f, -0.04341956f, -0.07727915f, -0.24707991f, 0.37002194f, -0.27189338f, 0.02050491f, 
    0.03308450f, 0.00034271f, -0.04020732f, 0.12917323f, 0.15676634f, 0.10092720f, -0.07088685f, 0.12133401f, 
    0.00310502f, 0.08185712f, -0.01739926f, 0.05175990f, 0.14417629f, -0.11770708f, 0.00360263f, -0.01572418f, 
    -0.46460742f, 0.08019856f, -0.13641132f, -0.06804772f, 0.07157672f, -0.01220490f, 0.08774288f, 0.15857513f, 
    0.10234824f, 0.00164293f, -0.00279033f, 0.10969742f, 0.01045227f, -0.12449034f, -0.15795435f, -0.07585609f, 
    -0.05488631f, 0.01806896f, -0.10160507f, -0.15170908f, -0.19740641f, -0.04832293f, -0.08926794f, -0.20995104f, 
    0.02904906f, 0.07769937f, 0.01202536f, -0.08353229f, -0.01100557f, 0.02361760f, 0.16723229f, -0.03035126f, 
    0.01984930f, 0.02892226f, -0.11235534f, 0.09782980f, -0.12301934f, -0.08923691f, -0.06068762f, -0.03504286f, 
    -0.34344640f, -0.26374948f, 0.11712201f, 0.07031773f, 0.03711833f, -0.04463087f, -0.03221656f, 0.09586558f, 
    -0.01044246f, 0.03966363f, 0.07929393f, 0.00212630f, -0.09966109f, -0.09853692f, 0.05264078f, 0.02710260f, 
    -0.04402846f, -0.03940452f, 0.09793223f, 0.05277978f, -0.03484299f, -0.03648229f, 0.23689614f, 0.16747762f, 
    -0.12956859f, -0.11086350f, 0.01504999f, -0.02214640f, -0.01479314f, 0.03593494f, 0.08280467f, 0.10991313f, 
    0.07889154f, -0.05767864f, -0.01831127f, -0.00558986f, 0.10606011f, 0.00654836f, 0.10497621f, 0.17386824f, 
    0.28881961f, -0.36504751f, -0.21908516f, 0.22769757f, -0.22644113f, 0.16167410f, -0.02219534f, 0.07718968f, 
    0.00800958f, 0.12379485f, -0.13028528f, -0.15220730f, -0.01047647f, -0.13311216f, -0.05676555f, 0.03972662f, 
    -0.00170349f, -0.03890944f, 0.02431766f, -0.13328142f, -0.11670874f, -0.19877805f, -0.07454521f, 0.14344083f, 
    0.19341658f, 0.06839348f, -0.01630657f, 0.14681719f, -0.05610956f, 0.01355434f, -0.03759373f, -0.02819805f, 
    0.05629628f, 0.16340259f, 0.03523419f, -0.05641099f, 0.20438571f, 0.05045430f, 0.06095267f, -0.12925807f, 
    -0.47568163f, -0.10914766f, -0.18132667f, 0.08613671f, 0.24012665f, 0.12333872f, 0.07776840f, 0.05065756f, 
    0.18516216f, 0.13892804f, 0.10909956f, -0.02519082f, 0.09338254f, 0.01813465f, 0.06781300f, 0.05005139f, 
    0.12338469f, 0.02608055f, 0.10550144f, -0.01177444f, -0.07240515f, -0.31276163f, 0.00713934f, 0.08871508f, 
    0.25373366f, 0.07838195f, -0.09998861f, 0.00131868f, -0.05750126f, 0.02235153f, 0.03786645f, 0.04542216f, 
    -0.13840526f, 0.00850605f, 0.00842023f, -0.15837100f, -0.06369265f, -0.10690553f, -0.03825327f, -0.00433537f, 
    -0.44451159f, 0.23191696f, 0.17816263f, -0.19637331f, -0.21482636f, 0.04100098f, 0.03241705f, -0.01341270f, 
    -0.02071594f, 0.03445693f, 0.02127189f, -0.12445469f, 0.07568367f, -0.08215843f, 0.02203880f, 0.07400322f, 
    0.01110572f, 0.09804641f, 0.06179450f, 0.06689949f, -0.06990124f, -0.09829897f, -0.02710153f, -0.02993562f, 
    0.09440052f, 0.01548723f, 0.08245253f, -0.00189282f, -0.00629789f, 0.03559240f, -0.00158006f, -0.15076351f, 
    0.01465842f, 0.05067213f, 0.08265543f, -0.09877367f, 0.01289758f, -0.05801534f, -0.00009569f, -0.01323557f, 
    -0.33779109f, 0.10986964f, -0.14928435f, 0.12453280f, 0.24436525f, 0.15504366f, 0.07936155f, -0.00785703f, 
    0.11333732f, 0.11342937f, 0.03823136f, 0.00121249f, 0.05577068f, -0.02902616f, -0.07380875f, -0.01882160f, 
    -0.04728510f, -0.02538647f, 0.04047301f, -0.21884377f, 0.24698773f, -0.13581911f, -0.00972982f, -0.15362395f, 
    0.03297839f, -0.01322288f, 0.03312861f, 0.01665198f, -0.14411695f, 0.00745678f, 0.01410088f, -0.01613257f, 
    -0.01047739f, -0.00485165f, -0.02821667f, -0.01856635f, -0.08264212f, -0.01136314f, 0.03781438f, -0.17368399f, 
    -0.08107047f, -0.14445287f, 0.13710183f, 0.06416622f, 0.04019850f, -0.07708045f, 0.00482267f, -0.03613328f, 
    0.10582012f, 0.11621518f, 0.09289435f, 0.04267857f, 0.02738993f, -0.11462326f, -0.06381322f, -0.01316726f, 
    -0.02470045f, -0.13734649f, 0.07284550f, 0.06074058f, 0.08397736f, 0.01171168f, 0.01003627f, -0.03845422f, 
    0.01595908f, 0.07407948f, -0.09517990f, 0.00918377f, 0.03068870f, 0.04091256f, -0.05126413f, 0.07475378f, 
    0.00852520f, 0.08997821f, 0.09822446f, 0.13258319f, -0.09086742f, 0.04548122f, -0.05417304f, -0.07037631f, 
    -0.41199180f, 0.03437663f, -0.21352701f, 0.08179604f, 0.10630219f, 0.16683522f, 0.07266746f, 0.05864750f, 
    0.08986351f, -0.15293056f, -0.09143235f, 0.01333979f, 0.06627248f, -0.06040653f, 0.00294940f, -0.14586073f, 
    0.00994728f, -0.00287759f, -0.12511320f, -0.07995635f, -0.21332130f, -0.14082330f, 0.06773334f, 0.24628368f, 
    0.18018842f, 0.02364576f, -0.01106541f, 0.08696004f, -0.02029367f, 0.02183341f, 0.08648015f, -0.06345602f, 
    0.00105664f, -0.07109543f, -0.02699935f, -0.04432341f, 0.05611946f, 0.00514433f, -0.03182095f, -0.14495650f, 
    0.05609474f, -0.09432472f, -0.01237178f, 0.12073625f, 0.24367540f, -0.05328695f, -0.02063519f, -0.04690939f, 
    0.04400008f, -0.04653795f, -0.15096229f, -0.16811340f, 0.12513357f, 0.04646444f, 0.06563434f, -0.04776045f, 
    -0.05855591f, -0.04892315f, 0.07902205f, -0.02376739f, 0.04494997f, -0.09287798f, -0.13183028f, -0.21218604f, 
    -0.00124489f, 0.01714703f, 0.02017491f, -0.13148326f, -0.02258060f, 0.12375858f, 0.12084287f, 0.12325695f, 
    0.02513216f, -0.08059054f, -0.02714935f, 0.00279354f, -0.12845244f, -0.07736590f, 0.07218520f, 0.10576697f, 
    -0.60144037f, 0.01400748f, -0.08644652f, -0.34144458f, -0.03642917f, 0.03572823f, 0.12631872f, 0.15041941f, 
    -0.04732108f, -0.14413971f, 0.05562388f, -0.02740895f, 0.13886200f, -0.23457651f, 0.03585096f, 0.01336850f, 
    0.07350621f, -0.14506066f, -0.11004879f, 0.06426213f, -0.32429364f, -0.20152694f, 0.01416683f, 0.15688685f, 
    -0.32179832f, 0.04374266f, 0.04615425f, -0.04165548f, -0.13133693f, 0.11177632f, 0.04130317f, -0.12213057f, 
    -0.03449452f, 0.04269195f, 0.02434063f, -0.10201096f, 0.08899918f, 0.11048701f, -0.09061152f, -0.08114260f, 
    0.15105420f, 0.26658952f, -0.16617624f, 0.00454325f, 0.09109370f, -0.00090585f, 0.06185747f, -0.04257512f, 
    -0.04943411f, -0.10071974f, 0.04592568f, -0.00568133f, -0.04867165f, -0.07094780f, 0.02053699f, -0.00311597f, 
    -0.02273833f, -0.11092282f, 0.09160093f, 0.06978758f, -0.32549679f, -0.02925803f, 0.16429619f, 0.12780683f, 
    -0.36220279f, -0.17355406f, 0.01263682f, 0.03458496f, -0.00699463f, 0.06484723f, -0.08717608f, 0.06455173f, 
    -0.06797239f, -0.06727702f, -0.09666795f, 0.03689645f, -0.04563396f, -0.07776155f, 0.06204637f, -0.00978249f, 
    0.02677021f, 0.02673292f, -0.10723678f, 0.05231837f, 0.05690334f, -0.00994652f, 0.12059930f, 0.06018801f, 
    -0.06530853f, 0.08154678f, 0.01275609f, 0.21022238f, 0.19187313f, 0.07690184f, 0.04626000f, -0.12205486f, 
    0.08424067f, -0.09764636f, -0.08991055f, -0.19137749f, -0.46677375f, 0.23799637f, -0.53047228f, -0.07565365f, 
    0.12457653f, 0.17214020f, 0.09636668f, -0.07608160f, -0.04084283f, -0.12310738f, 0.04754064f, 0.06901196f, 
    0.02404065f, -0.12556674f, 0.00708672f, -0.06128446f, 0.07182083f, -0.06629177f, 0.10189238f, -0.02161860f, 
    -0.18803807f, -0.28987411f, 0.08193345f, 0.13128763f, 0.11243086f, 0.04448280f, -0.02712984f, -0.07019392f, 
    -0.02956078f, 0.13953424f, 0.12570976f, -0.04433982f, 0.01268077f, 0.06624226f, -0.03015522f, -0.04439202f, 
    0.03546163f, -0.22201519f, -0.04853478f, 0.02637748f, 0.05877984f, 0.07434747f, -0.16222863f, 0.13385385f, 
    0.29120636f, -0.10391898f, -0.02995859f, 0.02293692f, 0.12671423f, 0.05260231f, 0.07660255f, -0.12157729f, 
    0.00587130f, 0.21069092f, 0.15983774f, 0.03849990f, 0.11558986f, -0.15353386f, -0.04377736f, -0.21652772f, 
    -0.45926371f, 0.08603653f, 0.04957944f, 0.03020556f, -0.14683324f, 0.03028622f, -0.03503642f, 0.02259828f, 
    -0.03948460f, 0.00784562f, 0.12899379f, -0.01659876f, -0.02096470f, -0.02861620f, -0.07186972f, -0.03653678f, 
    -0.05509370f, 0.07007623f, -0.04546784f, 0.09449832f, 0.21499982f, 0.16847914f, -0.01925164f, 0.14370461f, 
    -0.03401375f, -0.22997145f, -0.07581381f, -0.09838911f, 0.06089016f, 0.03233335f, -0.09925266f, -0.15627924f, 
    -0.06890389f, 0.07424369f, 0.07754094f, 0.03975912f, 0.05654493f, 0.15594587f, 0.02172650f, -0.03260608f, 
    0.09992865f, -0.10604868f, -0.06216318f, 0.09932401f, -0.34916937f, -0.18484674f, 0.00329145f, -0.06805881f, 
    0.08676801f, -0.12360791f, 0.02673641f, 0.06363751f, -0.08563815f, 0.13890016f, 0.28372514f, -0.08789299f, 
    -0.08184787f, 0.08187307f, 0.02368630f, -0.05885455f, -0.00627439f, 0.03219989f, 0.02899849f, 0.33699009f, 
    0.12291623f, 0.10004187f, 0.00060978f, -0.04773911f, -0.03002808f, 0.24349111f, -0.01125644f, -0.02302309f, 
    -0.05493908f, 0.18006292f, 0.08965761f, -0.09877892f, -0.03794604f, 0.00979782f, -0.17320216f, -0.04544821f, 
    0.02652809f, -0.04060439f, 0.04709927f, 0.31678692f, 0.01794351f, 0.03848894f, 0.01433651f, -0.02014930f, 
    0.09954329f, -0.01895237f, -0.05818141f, 0.00695199f, 0.00485124f, 0.02726521f, 0.05546649f, 0.04548416f, 
    0.04554540f, -0.11769981f, -0.07313849f, -0.15767774f, -0.12576833f, -0.03605444f, 0.10362367f, 0.11443818f, 
    -0.56374151f, 0.01623540f, 0.01416120f, -0.12593734f, 0.03395731f, -0.02801801f, 0.03768635f, 0.03857286f, 
    -0.01862371f, 0.05844770f, -0.09083046f, 0.00204422f, 0.02527991f, 0.11113843f, 0.10034188f, 0.04878883f, 
    -0.26505575f, -0.24038282f, 0.15377074f, -0.04201966f, 0.07317483f, 0.06665763f, -0.23136777f, -0.08993154f, 
    0.01081009f, -0.07018856f, -0.00777973f, -0.09011023f, -0.18833208f, -0.05301980f, 0.00504430f, 0.03354716f, 
    0.01940679f, -0.00709014f, -0.15876590f, 0.07550780f, -0.11928459f, 0.03111345f, 0.14793581f, 0.18753046f, 
    -0.03022370f, -0.01856425f, 0.07631855f, -0.00171531f, -0.06024317f, -0.03005026f, 0.02856682f, 0.01693084f, 
    0.01939215f, -0.03435043f, 0.09787040f, 0.00502157f, 0.02606068f, 0.05418343f, -0.01760749f, -0.06067766f, 
    0.16215900f, -0.03666103f, 0.00238097f, 0.04734069f, -0.15929899f, -0.09975021f, 0.07683505f, -0.00045502f, 
    0.11120930f, 0.04228277f, -0.16898924f, -0.04602809f, 0.22192842f, 0.04545422f, 0.07459390f, -0.14664124f, 
    0.03329783f, 0.05532157f, -0.02348085f, 0.02665602f, 0.18266256f, 0.00981732f, 0.10041399f, 0.12036835f, 
    0.07217295f, -0.12826155f, -0.11493171f, 0.03868428f, -0.02923106f, 0.02215224f, -0.04921640f, -0.05277791f, 
    0.09801974f, 0.07546697f, 0.04172284f, -0.03510179f, -0.06777567f, -0.03237323f, 0.09215268f, 0.00851687f, 
    0.03800180f, 0.22482187f, 0.18281683f, -0.02405609f, -0.10413392f, -0.17684737f, 0.16789219f, -0.15814914f, 
    -0.27321744f, 0.09804296f, 0.03526919f, 0.01534938f, -0.00660857f, 0.06923654f, -0.09242531f, 0.06408069f, 
    0.03153500f, -0.00294807f, 0.25216788f, 0.05580443f, 0.02804568f, 0.33870563f, 0.11588740f, -0.16268101f, 
    -0.16761194f, 0.07026852f, 0.03165091f, 0.14852828f, -0.09643984f, -0.05265373f, 0.15837999f, -0.11170071f, 
    -0.13573104f, -0.17033508f, -0.06245314f, 0.08019768f, -0.10504247f, 0.07669672f, 0.02264912f, -0.04197848f, 
    -0.21484236f, 0.18265365f, -0.22518983f, -0.22462891f, 0.02047368f, 0.16360782f, 0.14440519f, 0.19627143f, 
    -0.15609607f, 0.02098121f, -0.08080079f, 0.10586540f, -0.15706819f, -0.07515653f, -0.10983363f, 0.08993353f, 
    -0.04482393f, 0.02655636f, 0.01558123f, -0.05905174f, -0.00365848f, -0.11650320f, 0.08696638f, 0.04233737f, 
    0.05580327f, -0.06736664f, -0.06360917f, -0.03762239f, 0.06606437f, 0.03093731f, 0.06951352f, -0.09651725f, 
    0.08374379f, 0.15994887f, 0.02229846f, 0.06084853f, 0.02450480f, 0.07378787f, -0.38105690f, 0.09405193f, 
    -0.30914035f, 0.07495513f, 0.07358130f, 0.16151948f, -0.05106425f, -0.03667393f, 0.04948687f, -0.10647916f, 
    -0.00271690f, 0.05310922f, 0.02710554f, -0.02075574f, 0.01092343f, 0.01512133f, -0.00621290f, -0.00263548f, 
    -0.04256978f, -0.00973011f, -0.05882799f, -0.14537445f, 0.14032210f, 0.11468854f, 0.06340215f, 0.16918957f, 
    0.11508154f, 0.07494684f, 0.00375591f, 0.13012132f, 0.10718599f, 0.05652343f, 0.11745737f, -0.13114692f, 
    0.03342244f, 0.00066809f, 0.00314770f, 0.11703428f, 0.19496660f, -0.06803788f, 0.08221387f, 0.17452410f, 
    -0.88285881f, -0.36800122f, -0.33666423f, -0.31795359f, -0.06431393f, 0.13168761f, 0.03277576f, 0.01182308f, 
    0.01578905f, -0.22303228f, -0.00548773f, 0.12872116f, -0.09942213f, 0.07508995f, -0.11510570f, 0.08460759f, 
    0.02833092f, 0.01277601f, -0.15260598f, 0.12478290f, -0.27002046f, 0.08157306f, 0.00250572f, -0.00542930f, 
    0.02704607f, -0.03655330f, -0.11760097f, -0.00640262f, -0.04766386f, 0.00778934f, 0.08920602f, 0.13036731f, 
    -0.02468430f, -0.06993648f, 0.00306349f, 0.05166749f, 0.07030958f, 0.08893354f, 0.12684362f, -0.04517308f, 
    -0.24841511f, 0.01279137f, -0.16013715f, 0.38543335f, -0.16128136f, 0.13884614f, 0.08265698f, -0.07110351f, 
    0.07161293f, 0.02503592f, -0.07613564f, 0.03647558f, 0.05778262f, -0.00823445f, 0.06953793f, 0.14479242f, 
    -0.08759499f, 0.09072310f, -0.09457937f, -0.04806327f, 0.20843662f, -0.03469937f, -0.08835860f, 0.00989798f, 
    -0.04988273f, 0.14430518f, 0.17421503f, 0.00854090f, -0.14783286f, -0.05358384f, 0.13588497f, 0.02078211f, 
    -0.00743173f, -0.04510735f, -0.02464526f, -0.00445415f, -0.10378468f, 0.00947157f, -0.01904199f, -0.01253845f, 
    0.36840346f, 0.14872378f, -0.19218530f, -0.46775389f, -0.19298716f, -0.06395942f, 0.02974496f, 0.09489802f, 
    -0.10680845f, -0.02623300f, -0.02971998f, -0.05580404f, 0.14227675f, -0.12439560f, -0.01429085f, 0.01200782f, 
    -0.05463426f, 0.05899579f, 0.07244620f, 0.12844880f, -0.09040699f, -0.35428408f, -0.06314485f, -0.06765626f, 
    0.25365153f, -0.07732572f, -0.01991132f, -0.02328529f, 0.04889392f, 0.00119161f, -0.12861919f, -0.08755724f, 
    -0.01965825f, 0.03483858f, 0.05670354f, 0.02470905f, -0.00122027f, 0.06329409f, -0.07436594f, 0.15847158f, 
    -0.27546585f, 0.22972865f, 0.05038848f, 0.07366381f, -0.50232834f, 0.04977519f, 0.14373212f, 0.00697101f, 
    0.10546266f, 0.09031566f, 0.01957702f, 0.01582557f, -0.06370011f, 0.14781815f, -0.06600086f, 0.01404914f, 
    -0.03658741f, 0.00457918f, 0.03819003f, 0.04439586f, -0.13647732f, -0.23890431f, -0.03744932f, -0.26448548f, 
    0.26343551f, 0.00607828f, 0.08143476f, 0.15041234f, 0.00240656f, 0.02122675f, -0.06272111f, -0.11944444f, 
    -0.04979028f, 0.07345022f, -0.08007032f, 0.00475908f, 0.04865149f, 0.17500490f, 0.11773574f, 0.02612781f, 
    0.22307853f, -0.20437928f, 0.02887633f, 0.11722475f, 0.13959850f, -0.16637526f, 0.11055972f, -0.07182648f, 
    -0.03189327f, 0.00058586f, -0.07970910f, 0.07532068f, -0.07909068f, 0.08092860f, 0.20233215f, -0.14697582f, 
    0.01899905f, 0.09681824f, -0.14777467f, 0.02253044f, 0.12680264f, -0.42640045f, -0.10644150f, -0.05511986f, 
    0.04340719f, 0.09036592f, -0.03159413f, 0.01266035f, 0.00602389f, 0.09104119f, -0.03606010f, 0.04767494f, 
    -0.08804552f, -0.11332567f, 0.06537536f, -0.05853752f, -0.02668384f, 0.04087202f, 0.06402921f, 0.02344346f, 
    0.20475292f, -0.41607133f, -0.21329162f, -0.14042963f, 0.18560112f, -0.10925093f, 0.10540678f, 0.01165312f, 
    0.05318072f, 0.02464864f, 0.07158328f, -0.00022985f, 0.11802563f, 0.08965701f, 0.05118678f, 0.05601213f, 
    -0.04985034f, 0.04104629f, -0.29083872f, 0.14007798f, 0.25683793f, 0.07291792f, 0.01038233f, 0.26600620f, 
    0.20899895f, -0.08064876f, 0.07042605f, 0.00620542f, 0.06876869f, -0.14620027f, 0.07482452f, 0.07096293f, 
    0.06046891f, 0.10384040f, -0.03283642f, -0.03442022f, 0.12075523f, 0.06750858f, 0.00196931f, 0.00427589f, 
    -0.14327620f, -0.04539717f, -0.10158799f, -0.11023261f, 0.16358727f, 0.00500104f, -0.02767139f, -0.06329934f, 
    -0.15429166f, -0.14855267f, -0.07681502f, -0.10786237f, -0.04518824f, -0.08212683f, 0.03394236f, 0.05384544f, 
    0.00280472f, 0.05975246f, 0.07140741f, 0.07911448f, 0.40657488f, -0.36496660f, 0.02645305f, -0.34073424f, 
    0.12306495f, -0.06191940f, -0.00379758f, -0.00506111f, -0.06364896f, -0.15871038f, 0.06323072f, -0.04568416f, 
    0.02125321f, 0.08635373f, -0.07101945f, 0.03988679f, -0.07547398f, -0.00564068f, -0.17025605f, 0.14657637f, 
    -0.12589040f, -0.08720192f, -0.34314242f, 0.01130709f, 0.15068488f, -0.03465278f, 0.09561390f, -0.02756165f, 
    -0.12524720f, 0.00273762f, -0.10637054f, -0.08438969f, -0.00475490f, 0.09487289f, -0.22132376f, 0.07066716f, 
    0.10755122f, 0.15583567f, 0.06718532f, 0.03971439f, -0.10620873f, 0.09477864f, -0.05998200f, -0.05595476f, 
    -0.05729216f, -0.00614345f, 0.03314570f, 0.02567224f, -0.01688916f, 0.04549988f, -0.06434280f, 0.03658883f, 
    -0.14572431f, -0.12403950f, -0.18519498f, -0.01602423f, -0.16370250f, 0.22868551f, 0.00621520f, 0.08385234f, 
    0.13116875f, -0.27036241f, -0.14041510f, 0.12035784f, -0.04927556f, -0.09338748f, -0.12437961f, 0.03070777f, 
    -0.04544961f, 0.05627204f, -0.06819374f, -0.04704465f, -0.01711981f, 0.07513686f, 0.01605836f, -0.06931252f, 
    -0.08138921f, -0.01237716f, 0.03510411f, -0.18454294f, -0.26742855f, 0.37118453f, -0.03198466f, 0.02360009f, 
    -0.23975718f, 0.12017769f, -0.00728891f, -0.01395652f, 0.11080380f, -0.02449560f, -0.00114622f, 0.07645574f, 
    0.01924944f, 0.00916768f, -0.15980710f, 0.06199470f, 0.02927976f, 0.01182852f, 0.00677157f, 0.07101215f, 
    -0.03493121f, -0.08545420f, 0.16996312f, -0.12935632f, -0.05621535f, 0.27668571f, -0.07332864f, 0.13188517f, 
    -0.05584685f, -0.13530356f, -0.14581220f, 0.07554522f, 0.02095364f, 0.03527736f, -0.23787661f, 0.00005076f, 
    0.03880182f, 0.06145024f, 0.10500698f, -0.01848797f, -0.22926497f, 0.02219788f, 0.04844624f, -0.21154712f, 
    0.07434716f, -0.12490470f, -0.10147019f, 0.09178276f, -0.14734931f, -0.02754435f, 0.02088385f, -0.01557966f, 
    0.01189678f, -0.18050823f, -0.05687388f, -0.00229830f, -0.10825633f, -0.08576383f, 0.16911875f, 0.20700155f, 
    -0.07042889f, 0.09129372f, 0.00162312f, 0.16987884f, -0.00910341f, -0.03011867f, 0.00856618f, 0.07604561f, 
    -0.03107847f, 0.01158285f, 0.00920131f, -0.02265014f, -0.03676791f, -0.05803090f, -0.01671471f, 0.03767306f, 
    -0.12507352f, 0.04919271f, -0.05906782f, 0.12298840f, 0.40372196f, -0.15742110f, 0.08094171f, 0.11061414f, 
    -0.08028848f, 0.05731120f, -0.17873450f, 0.11913103f, -0.03315552f, 0.13896254f, 0.03456394f, 0.07237322f, 
    -0.10244940f, -0.08335543f, 0.05075865f, -0.09944723f, -0.01129809f, -0.01174098f, -0.02167469f, -0.23670928f, 
    0.21507908f, 0.17247880f, -0.06534588f, -0.09817309f, 0.14029802f, 0.08311553f, 0.09108566f, -0.02271928f, 
    0.00437926f, 0.10698570f, -0.10529996f, -0.10733812f, 0.15164723f, -0.11162391f, 0.04628920f, -0.08465417f, 
    0.14443608f, 0.07948902f, 0.06995093f, 0.05607959f, -0.19631034f, 0.24293685f, 0.03187639f, 0.30829802f, 
    0.23337412f, -0.00720910f, -0.09297869f, -0.08495875f, 0.04643258f, 0.00361144f, -0.14433584f, 0.08728656f, 
    -0.04152481f, 0.12712565f, 0.10327886f, -0.07998757f, 0.11786128f, -0.04780768f, -0.09635472f, -0.13093683f, 
    0.07682950f, 0.25439829f, 0.28998455f, -0.00500681f, -0.16769210f, -0.01167662f, -0.04215407f, 0.04920327f, 
    -0.01019321f, -0.10195666f, 0.03991076f, 0.00089644f, -0.20775670f, 0.03640939f, -0.06107146f, 0.14086518f, 
    -0.06692524f, -0.08688810f, -0.08298161f, -0.02864260f, -0.19336598f, 0.40152958f, 0.03232815f, 0.05932244f, 
    -0.51352459f, 0.10827498f, -0.00977607f, 0.07060304f, 0.12151442f, 0.03836118f, 0.00759847f, 0.03985447f, 
    0.00386224f, -0.05658404f, -0.05078036f, -0.04094782f, -0.11355311f, -0.02088760f, -0.01961739f, -0.06245704f, 
    -0.32538101f, 0.24670446f, -0.21546027f, 0.24375288f, -0.14048240f, -0.12861072f, -0.11501424f, 0.07019384f, 
    0.05700685f, -0.00023921f, -0.03117625f, 0.07477373f, -0.05261907f, 0.04524455f, -0.09025823f, 0.03758982f, 
    -0.05502219f, -0.02152034f, -0.15379752f, -0.06769279f, 0.06568719f, -0.58999544f, -0.16353799f, -0.06887658f, 
    -0.11275674f, -0.01087376f, 0.07899553f, -0.00454378f, -0.02424580f, 0.00133821f, -0.21536151f, 0.02211939f, 
    0.08804917f, 0.10045712f, 0.08510970f, 0.10223797f, -0.01278892f, -0.05269028f, -0.13021038f, -0.03012810f, 
    -0.21131864f, -0.32184163f, -0.09161919f, -0.41645727f, 0.19331405f, -0.11599801f, 0.06560666f, -0.14032631f, 
    0.04668778f, -0.07292085f, -0.10421826f, -0.04341327f, 0.02003749f, 0.02721679f, 0.05463436f, -0.01999342f, 
    -0.06348240f, -0.10602162f, -0.03576700f, 0.03737314f, 0.03674015f, -0.02543350f, -0.07078500f, -0.15350397f, 
    -0.18921916f, 0.03082550f, 0.04576626f, 0.13029081f, -0.09376324f, 0.07988820f, 0.07649113f, -0.02939424f, 
    -0.14782144f, -0.07855316f, 0.11484192f, -0.03513063f, -0.05452367f, 0.08011612f, 0.15785414f, -0.16358984f, 
    0.48916328f, 0.04336850f, 0.18738087f, 0.02341953f, 0.30520707f, -0.05405244f, -0.02801598f, -0.02165255f, 
    -0.04066797f, -0.09726396f, -0.11327390f, 0.03795203f, 0.11650159f, 0.06652351f, 0.15089852f, 0.09166794f, 
    -0.00063834f, -0.02253126f, 0.08567034f, 0.00052012f, -0.29550079f, -0.08480414f, -0.08215426f, 0.12022976f, 
    0.04550097f, -0.09664325f, -0.03910503f, 0.01958664f, -0.08527359f, 0.14038342f, -0.05504825f, 0.06711342f, 
    0.00652955f, -0.10754286f, -0.06469256f, -0.03199102f, -0.04716476f, 0.06122246f, -0.24044602f, -0.22609229f, 
    -0.30237919f, -0.14939189f, 0.01924469f, -0.35769171f, 0.22012371f, -0.07765415f, -0.04224981f, 0.13374385f, 
    -0.18241259f, 0.07417249f, 0.01354666f, -0.12798493f, 0.12065893f, 0.08330905f, 0.02129336f, -0.09643684f, 
    -0.00623500f, -0.12757924f, 0.10425816f, 0.05268730f, -0.45767665f, -0.16867158f, -0.05303131f, 0.20204887f, 
    0.14004645f, 0.09533833f, -0.02759282f, 0.04299195f, 0.15537734f, -0.02557401f, 0.01307598f, -0.07112276f, 
    -0.00093186f, -0.02665661f, -0.14238273f, -0.00105485f, 0.02134837f, -0.14788696f, -0.01035713f, 0.06493436f, 
    -0.51301229f, 0.14788970f, 0.04871416f, 0.09193823f, 0.06367457f, -0.01368954f, -0.17115819f, -0.08723177f, 
    0.15635386f, -0.13825010f, 0.02837563f, -0.00889471f, -0.02108367f, -0.00395453f, -0.09433824f, 0.07374047f, 
    -0.05616425f, 0.12726037f, -0.03444287f, -0.00269314f, 0.15984771f, -0.23513821f, 0.03534712f, -0.03152217f, 
    0.05989265f, -0.04417657f, 0.00052689f, -0.03066329f, -0.00665733f, -0.05284707f, -0.06486423f, -0.06850802f, 
    -0.05850833f, -0.01173458f, -0.03097103f, -0.06747893f, 0.03533931f, 0.01655871f, 0.07108600f, 0.00237975f, 
    0.17604670f, 0.06939076f, 0.20151538f, -0.05246031f, 0.23208228f, 0.04802097f, 0.13936676f, 0.04195714f, 
    0.03101677f, 0.01501156f, -0.06916749f, 0.06131738f, -0.11321338f, 0.01337624f, -0.02386658f, 0.03048079f, 
    0.01143282f, -0.03449915f, 0.02049597f, -0.02998804f, -0.17901306f, -0.00028208f, -0.33413765f, 0.04143467f, 
    -0.05891188f, -0.14617893f, 0.03321498f, -0.00275532f, 0.00234337f, -0.05212185f, 0.04816129f, 0.01770014f, 
    -0.14943779f, -0.03461738f, -0.00829388f, 0.00950967f, -0.03895240f, -0.01200460f, -0.09414633f, -0.05134379f, 
    -0.15704241f, -0.07823784f, -0.17276509f, 0.02474663f, 0.04721303f, -0.00978003f, -0.02447899f, -0.04014839f, 
    -0.00937124f, -0.02512077f, -0.08084820f, 0.00114580f, 0.01221508f, -0.02237869f, -0.02116206f, 0.02052363f, 
    -0.04351982f, 0.01773985f, -0.02327220f, -0.00907936f, 0.03809590f, 0.11304423f, 0.06204795f, 0.08554100f, 
    0.11997886f, -0.05995877f, 0.14499649f, -0.02106832f, 0.03065841f, -0.02521983f, -0.12009109f, -0.00012518f, 
    -0.13138244f, -0.07058672f, 0.01728683f, 0.02898166f, 0.01766047f, 0.05082345f, -0.01002430f, -0.01144639f, 
    -0.28535593f, 0.13271114f, 0.16691642f, 0.09621575f, 0.12397286f, 0.08101614f, -0.02608399f, 0.00056570f, 
    0.15052004f, -0.02357023f, -0.04859715f, 0.04358197f, 0.04638028f, 0.00410307f, -0.10008741f, 0.08259455f, 
    0.08611974f, 0.10780509f, 0.00407050f, -0.02844792f, 0.13132171f, -0.15901236f, 0.00733175f, 0.13237357f, 
    0.26551187f, 0.07941174f, -0.01429187f, -0.13709326f, -0.02400374f, -0.00028194f, 0.01642758f, -0.01637114f, 
    -0.08520483f, -0.17138670f, 0.01861010f, 0.00621226f, -0.00279858f, -0.04060297f, -0.00274787f, -0.03872715f, 
    -0.30124474f, 0.22780877f, 0.01288465f, -0.10540712f, -0.07131682f, -0.16676308f, 0.08576090f, -0.01419670f, 
    -0.04492236f, -0.03665352f, -0.01130059f, 0.08799246f, -0.09172632f, 0.09039061f, -0.14283475f, -0.04016091f, 
    -0.02724933f, -0.00399557f, 0.03169166f, 0.00925051f, -0.24789099f, 0.16481826f, -0.04809426f, 0.17695898f, 
    0.09494282f, 0.09280987f, -0.16952376f, 0.00193203f, 0.06571712f, 0.01116310f, -0.06825851f, 0.04655332f, 
    0.10879096f, -0.08189935f, -0.00141335f, 0.03800952f, -0.01305153f, 0.09042709f, 0.03398047f, -0.02001868f, 
    -0.06921335f, 0.11740031f, 0.10040721f, 0.10753974f, 0.17082752f, 0.11376059f, -0.07550578f, -0.11087820f, 
    -0.04966840f, 0.00495812f, -0.07239028f, 0.00703924f, -0.08565427f, -0.08259068f, -0.05631147f, 0.02402452f, 
    -0.07935739f, 0.03078680f, 0.06455673f, -0.03906159f, 0.06164166f, 0.14631584f, 0.31952760f, 0.00892712f, 
    0.18580365f, -0.04314891f, 0.11710649f, -0.00438342f, 0.04551179f, -0.02258568f, -0.03744738f, 0.03936021f, 
    -0.13172413f, 0.00296586f, -0.04187901f, -0.11127147f, 0.04253162f, 0.01808711f, 0.04621277f, -0.10667017f, 
    0.06002388f, 0.25874478f, 0.02675091f, -0.09590804f, 0.21613753f, -0.01933289f, 0.11940477f, -0.09459864f, 
    -0.01943322f, -0.03470718f, -0.06637696f, -0.08391018f, -0.08172072f, -0.09083941f, -0.04348146f, 0.01888375f, 
    -0.01116304f, 0.08462684f, -0.06410449f, -0.04164898f, -0.02409454f, -0.07055429f, -0.17488885f, 0.03532382f, 
    0.16763522f, -0.05030655f, -0.07921527f, -0.07840809f, 0.00525964f, 0.00622041f, -0.05529863f, 0.00636502f, 
    -0.01076823f, -0.04586383f, -0.03220522f, -0.11481124f, -0.02643504f, -0.02520604f, -0.05280459f, 0.09345703f, 
    -0.04892512f, -0.24911664f, 0.08315125f, 0.05950198f, -0.07951102f, 0.08086387f, -0.12922210f, -0.02689967f, 
    -0.01534458f, 0.00226129f, 0.00568407f, -0.03312021f, -0.02660246f, -0.00519614f, -0.03535825f, -0.04298536f, 
    -0.05895523f, 0.01393602f, -0.04805958f, -0.07336402f, -0.45042735f, 0.03083083f, -0.50594985f, -0.13266073f, 
    -0.14501837f, 0.06630975f, -0.06354349f, -0.11150432f, -0.04738739f, -0.06349340f, -0.10691167f, 0.04695221f, 
    0.05068872f, -0.08627285f, -0.03585680f, -0.06816902f, 0.05176431f, 0.00391310f, 0.04170522f, 0.15879899f, 
    0.15696211f, -0.57482606f, 0.17283417f, 0.07195055f, -0.18995005f, 0.08136801f, -0.02213453f, 0.02254629f, 
    0.00473067f, -0.05627993f, -0.01980072f, -0.05624938f, -0.04442938f, 0.00828537f, -0.11694797f, -0.01439774f, 
    0.09160165f, 0.02194844f, 0.03608166f, -0.07421513f, 0.09182195f, 0.08246226f, 0.08280054f, 0.08363611f, 
    0.21097648f, 0.12462498f, -0.07189503f, -0.05335952f, -0.04581518f, 0.04699163f, 0.03759054f, -0.05702644f, 
    -0.09430566f, -0.09516726f, -0.08920082f, 0.01386415f, 0.02190671f, -0.02226209f, 0.01687682f, -0.01416156f, 
    -0.05941913f, 0.04844335f, -0.19397385f, -0.16435830f, 0.07928561f, 0.03737625f, -0.06238408f, -0.05171710f, 
    0.02056392f, -0.07426417f, -0.07980641f, 0.07557741f, -0.03067342f, -0.05387106f, -0.06967322f, 0.01945218f, 
    -0.04571570f, -0.00775627f, 0.04060914f, 0.01111349f, 0.13192396f, -0.27137238f, 0.05552193f, -0.02444338f, 
    -0.14014591f, 0.04404898f, 0.05032967f, -0.05523930f, -0.12425916f, -0.04160099f, -0.01508971f, -0.03683044f, 
    -0.14443316f, 0.01096652f, -0.11083849f, -0.01380385f, 0.05160735f, -0.00676562f, 0.00591575f, -0.03699847f, 
    0.24775091f, 0.09724099f, 0.14064334f, -0.08570913f, 0.15411694f, -0.11889262f, 0.03369173f, -0.11584540f, 
    0.01761930f, 0.00098033f, -0.00430090f, 0.00982176f, 0.02559475f, 0.01855376f, -0.06752954f, -0.01191891f, 
    -0.03667481f, 0.04477255f, 0.01864266f, -0.00410016f, -0.22755425f, -0.05544989f, -0.15838417f, -0.14747749f, 
    -0.17763734f, 0.05120041f, -0.01914191f, 0.03273981f, 0.05327968f, -0.11070210f, 0.01169441f, 0.02094811f, 
    -0.06599703f, -0.03673213f, -0.06352309f, -0.01089265f, -0.03817360f, -0.08839720f, -0.03524567f, 0.00295360f, 
    0.06751969f, -0.41515672f, 0.06429678f, -0.13547289f, 0.01925621f, -0.00827971f, -0.02977851f, 0.00738511f, 
    -0.05816469f, -0.00507379f, -0.04573302f, -0.09221616f, -0.05994349f, -0.05615082f, -0.02838807f, -0.05919501f, 
    0.00689423f, -0.03996915f, 0.02906754f, 0.02751452f, -0.34237215f, -0.09528887f, -0.15315542f, -0.09322040f, 
    -0.10004261f, -0.00089912f, -0.11405941f, -0.08081032f, -0.02267650f, -0.13042071f, -0.07141750f, -0.05298310f, 
    0.10962253f, 0.00595220f, -0.08010904f, 0.03472409f, -0.01682462f, -0.01659365f, 0.04676459f, 0.00972113f, 
    -0.11285327f, 0.15296051f, 0.18124574f, -0.10669997f, -0.17011365f, -0.06415392f, -0.13767132f, -0.02556948f, 
    -0.00149545f, -0.06696114f, 0.03525361f, 0.02867419f, -0.00225060f, 0.00712658f, -0.06445444f, 0.09283503f, 
    0.00571923f, -0.09861394f, -0.09129991f, 0.02343868f, 0.01429996f, -0.02480276f, 0.12996459f, -0.02890761f, 
    -0.03186728f, 0.06361617f, 0.00562194f, 0.00020781f, -0.00060234f, -0.06445136f, 0.00039781f, 0.00884313f, 
    0.09135581f, 0.02459608f, -0.08075469f, -0.00101221f, -0.03441376f, -0.05344530f, -0.03303119f, 0.00669865f, 
    0.09624147f, 0.09325469f, 0.29336935f, 0.22981574f, 0.16778316f, 0.13979779f, 0.08841375f, 0.06301003f, 
    0.02428170f, 0.00364156f, -0.01909255f, -0.02416888f, 0.00858601f, 0.04391208f, -0.07349120f, 0.00345018f, 
    -0.00380545f, -0.04591237f, -0.01395800f, -0.04365344f, 0.24573015f, 0.12397527f, -0.02352868f, -0.01128568f, 
    0.17856640f, -0.12322155f, -0.05737460f, -0.00322549f, -0.11324431f, -0.01445834f, -0.06516524f, 0.05454555f, 
    -0.03587362f, 0.04170533f, -0.04773588f, -0.16481385f, -0.02531525f, 0.01342444f, 0.12292001f, -0.00488115f, 
    0.10252155f, -0.01129610f, -0.22690633f, 0.00956335f, 0.08320785f, -0.19924860f, -0.09642312f, 0.01767263f, 
    -0.01913397f, -0.03774561f, -0.05066375f, -0.02919217f, -0.06267264f, 0.02803190f, 0.03002098f, 0.06758815f, 
    -0.06130812f, -0.05302737f, -0.08881326f, -0.05647912f, -0.30287644f, 0.08215218f, 0.00207584f, -0.04893649f, 
    -0.13202076f, -0.07806441f, 0.00194337f, -0.08502207f, -0.05740154f, -0.06335290f, -0.03625318f, 0.03839408f, 
    -0.04716297f, 0.02960582f, 0.02924963f, -0.04127323f, -0.03158981f, 0.06067928f, -0.12304686f, 0.01153308f, 
    0.22062726f, 0.00329200f, 0.26927289f, 0.05020541f, 0.12254426f, 0.03483556f, 0.13905314f, -0.02858035f, 
    -0.03854325f, -0.05999501f, -0.02157994f, 0.09763205f, -0.04788423f, 0.03763168f, -0.03996166f, 0.02023531f, 
    0.02177580f, -0.03447278f, 0.11144631f, -0.11416401f, 0.01757028f, -0.08051976f, 0.08938846f, -0.08235774f, 
    -0.05154354f, -0.00551531f, 0.06726376f, -0.00837011f, -0.05520662f, -0.06292597f, -0.01433808f, 0.05129729f, 
    -0.09614328f, 0.01604872f, -0.01709702f, -0.00938631f, 0.04823172f, 0.01914006f, -0.00939933f, 0.01109442f, 
    0.02846062f, 0.20832495f, -0.36266398f, 0.10736922f, -0.05835713f, 0.00034889f, 0.00621952f, -0.20457572f, 
    -0.12413996f, 0.00386475f, 0.08078089f, -0.02013214f, 0.06602859f, 0.06443784f, -0.00699526f, 0.06181142f, 
    -0.02809275f, -0.08979993f, 0.13044482f, 0.00524375f, -0.03478348f, -0.12096278f, -0.01407827f, -0.14715935f, 
    -0.12737781f, -0.09228344f, 0.00853595f, 0.02248632f, -0.10392527f, -0.04419491f, 0.02447044f, 0.04283477f, 
    0.00605294f, -0.00485047f, 0.04049846f, 0.05156989f, -0.04349689f, 0.01461019f, -0.14365716f, -0.01524892f, 
    -0.16433646f, -0.13575694f, 0.20935708f, -0.39058596f, -0.16693065f, -0.04765966f, 0.05197947f, 0.03275875f, 
    -0.17512821f, 0.00877089f, 0.05023333f, 0.01086685f, 0.02038300f, 0.06421141f, -0.09128479f, -0.11697143f, 
    0.02354642f, -0.05085777f, -0.09914400f, -0.09525471f, 0.26068497f, 0.14189938f, -0.00387446f, 0.02855998f, 
    0.08592822f, -0.10591846f, 0.01909498f, 0.02120512f, -0.15001523f, -0.08462741f, 0.03370015f, 0.00221843f, 
    -0.02415187f, -0.08095316f, -0.06005616f, -0.11970847f, -0.02108003f, -0.08026591f, 0.14310639f, -0.03964129f, 
    -0.10924113f, -0.04479924f, -0.22021748f, -0.04718677f, 0.03744538f, -0.03204802f, 0.00490448f, -0.05081417f, 
    -0.02391478f, -0.03121592f, 0.02589568f, -0.02190062f, 0.03288940f, 0.03069022f, 0.06097052f, -0.00469474f, 
    -0.04163232f, -0.04090837f, -0.00228087f, -0.08016706f, -0.29258031f, 0.21439996f, 0.07406399f, -0.13156947f, 
    -0.21590275f, -0.03609392f, 0.02199658f, 0.03226479f, 0.05442395f, -0.12832312f, 0.05824872f, 0.02067988f, 
    -0.04529554f, 0.00379040f, 0.01635470f, -0.07984477f, -0.00561328f, -0.10542069f, 0.12217250f, 0.03768685f, 
    -0.00145586f, -0.03472581f, 0.06838278f, 0.07203098f, -0.02506515f, -0.12039375f, -0.13824454f, -0.11447159f, 
    0.01045893f, 0.08860186f, 0.00069190f, -0.03139034f, -0.08453405f, -0.01594268f, 0.01207556f, 0.04186819f, 
    0.06287418f, -0.04072985f, 0.11017159f, 0.02896545f, 0.02577488f, -0.19212461f, 0.20621917f, -0.11588595f, 
    0.06267009f, -0.07983185f, -0.08014473f, 0.00849615f, -0.09442423f, -0.07968089f, -0.09465822f, 0.00962198f, 
    0.02315855f, -0.04111199f, 0.06901046f, 0.01223967f, -0.04652696f, 0.09199379f, -0.07593546f, 0.04074513f, 
    0.17532721f, 0.13680674f, 0.07265872f, 0.02178219f, -0.02324668f, -0.04226909f, 0.04175903f, -0.01529451f, 
    -0.06243381f, 0.04907273f, 0.05447322f, -0.07707232f, 0.02211319f, 0.01005585f, 0.08966892f, 0.04342757f, 
    -0.04686582f, -0.01817788f, 0.12908997f, -0.12776391f, -0.18073541f, 0.01811979f, -0.23626442f, -0.12987998f, 
    -0.24207208f, 0.10134796f, -0.09886430f, -0.11649268f, 0.06696279f, -0.00838062f, 0.16108608f, -0.00534383f, 
    0.01976209f, -0.08550282f, 0.09771501f, -0.07044012f, -0.00102494f, -0.09699283f, 0.11154919f, 0.05482167f, 
    -0.26822549f, -0.13707316f, 0.02146528f, -0.33494279f, -0.32396179f, -0.00932799f, 0.01391174f, -0.03563501f, 
    0.01382889f, -0.05196406f, 0.06534756f, 0.03154653f, 0.07426436f, -0.06684151f, 0.00660111f, -0.10393845f, 
    -0.07549944f, -0.11214680f, -0.12123267f, -0.04078950f, -0.14679600f, 0.10644890f, 0.26520431f, -0.00454964f, 
    0.06582116f, -0.09843391f, -0.06674564f, 0.12693487f, 0.05165526f, 0.03665611f, 0.00699678f, -0.02033946f, 
    -0.07011791f, -0.08826025f, 0.03277702f, 0.02253911f, -0.02103861f, -0.04052644f, 0.07814521f, 0.02463997f, 
    -0.20994170f, 0.28198636f, -0.04145057f, -0.18310569f, -0.31066391f, -0.19832718f, -0.05919274f, -0.07109806f, 
    0.01958095f, -0.09074455f, 0.04923486f, -0.01241598f, -0.08800408f, -0.04072662f, -0.02292022f, -0.04536985f, 
    -0.10158879f, -0.19160326f, 0.00482321f, 0.06895816f, 0.08227371f, -0.07667042f, -0.10418945f, -0.16969229f, 
    -0.04331166f, 0.02543269f, -0.05086759f, -0.01153795f, 0.00658616f, -0.04466544f, -0.03737834f, 0.03966686f, 
    0.05888451f, 0.04273010f, -0.10313537f, 0.07968834f, 0.06284530f, 0.00210745f, -0.05604590f, -0.10577551f, 
    0.10312049f, 0.05377665f, 0.04009229f, 0.09638415f, 0.15534136f, -0.17529747f, -0.09787198f, -0.11858109f, 
    -0.11334423f, 0.11200839f, -0.11177228f, -0.05013180f, 0.02158736f, 0.00797124f, -0.03854402f, 0.02485905f, 
    0.06434458f, 0.00802880f, 0.03748209f, 0.03059539f, 0.03744548f, 0.01634479f, -0.24266709f, -0.16106775f, 
    0.11820635f, 0.12724018f, 0.02293339f, -0.02050468f, 0.00152336f, 0.00267555f, 0.08345813f, 0.02710037f, 
    -0.07874711f, 0.11569973f, -0.05542366f, 0.01805965f, 0.01897909f, 0.10063818f, 0.09740729f, 0.00368891f, 
    -0.05368862f, 0.02681935f, -0.32192630f, 0.09292042f, 0.03623553f, 0.02491317f, -0.11415414f, -0.09044924f, 
    -0.02727150f, -0.07167114f, 0.09678046f, -0.06120142f, -0.00957777f, 0.00347911f, 0.09969804f, 0.04087225f, 
    -0.08772335f, -0.02354265f, 0.12436026f, 0.01680543f, -0.23262316f, -0.01828476f, -0.19788322f, -0.30963650f, 
    -0.18942378f, 0.07035858f, -0.04203970f, -0.10015158f, 0.02519398f, -0.02018957f, 0.07916644f, -0.00912908f, 
    0.02381966f, 0.02817545f, -0.04502186f, -0.03382018f, 0.10940602f, -0.16118719f, -0.07885385f, 0.07511548f, 
    0.14642401f, 0.00723484f, 0.00944094f, -0.09439328f, -0.00768581f, 0.10556060f, -0.05428123f, -0.01658345f, 
    -0.08745095f, -0.03487020f, 0.12777989f, -0.02369420f, 0.03225743f, -0.01898653f, 0.03984399f, 0.03210872f, 
    -0.01902742f, 0.08507863f, 0.04028598f, 0.06090619f, 0.25466806f, 0.11982287f, -0.06402430f, 0.11573870f, 
    0.23289560f, 0.07253643f, -0.00371931f, -0.05384888f, -0.02624591f, 0.00458994f, -0.00124748f, -0.02651759f, 
    -0.07023229f, -0.06503141f, 0.02860062f, 0.06303170f, 0.03827744f, -0.01112973f, 0.12741740f, 0.06261116f, 
    -0.17174982f, 0.23844306f, -0.20252451f, -0.19083726f, -0.14541095f, 0.15517366f, 0.04300907f, -0.08970962f, 
    -0.00074062f, 0.01385987f, 0.08427285f, 0.05770243f, 0.04267569f, 0.07395313f, 0.06517147f, -0.03334615f, 
    -0.03870293f, -0.09915550f, -0.09973438f, 0.13255881f, 0.12212823f, 0.23903230f, -0.06109262f, 0.04800561f, 
    0.09656496f, 0.06379824f, 0.08061676f, -0.00836879f, -0.07145754f, -0.03035497f, 0.08636442f, 0.07551162f, 
    -0.06409173f, 0.06505446f, -0.10759626f, -0.02429363f, 0.00829626f, 0.08129568f, 0.08628445f, -0.02848012f, 
    -0.06759057f, -0.17895080f, -0.06652977f, -0.01204139f, 0.12515163f, 0.16407397f, -0.03038742f, 0.02432934f, 
    -0.02253652f, -0.09327059f, 0.06770582f, 0.03263971f, 0.04244058f, 0.00352973f, -0.07727153f, -0.00684312f, 
    0.01952216f, 0.01642009f, 0.00594783f, -0.09189839f, -0.15779959f, -0.18464309f, -0.15109636f, 0.20284574f, 
    0.22924761f, 0.04964520f, -0.00482415f, -0.09548383f, -0.01988859f, -0.07071432f, 0.02807765f, 0.04158316f, 
    0.04106958f, -0.03833594f, 0.10631928f, -0.11373797f, 0.02239387f, 0.06296581f, 0.10491918f, -0.07028726f, 
    0.13484141f, 0.12983024f, -0.13775899f, 0.06681287f, 0.02096583f, -0.00592150f, 0.03303790f, -0.23776327f, 
    -0.06217056f, -0.00415282f, 0.02844175f, 0.09528617f, 0.09445604f, -0.20049031f, -0.03225277f, -0.09577265f, 
    -0.03321758f, -0.05444974f, 0.21297935f, -0.04754139f, 0.17240074f, 0.01709901f, 0.01061971f, 0.07866096f, 
    0.18163504f, -0.08010358f, -0.03845128f, -0.00670244f, -0.11223379f, 0.09737016f, -0.11102044f, -0.04903961f, 
    -0.18328741f, -0.12267620f, 0.04750873f, 0.03676984f, 0.00927134f, 0.00055861f, 0.08217344f, 0.01228593f, 
    -0.25737336f, -0.12139517f, 0.18712234f, 0.01593000f, 0.09819636f, -0.04261095f, 0.02738168f, -0.02165554f, 
    -0.09882468f, -0.09920247f, -0.01620715f, 0.00789219f, -0.14610456f, 0.01491684f, 0.02104761f, 0.01200083f, 
    0.05810778f, 0.05059684f, -0.05989457f, 0.01912334f, -0.07580099f, -0.20246260f, 0.15529481f, -0.23214978f, 
    -0.08175267f, 0.06505810f, -0.04487591f, 0.00532880f, -0.12014284f, -0.22591068f, -0.04121779f, 0.01825771f, 
    0.08402292f, 0.08529334f, -0.03578494f, 0.08874778f, 0.10132170f, 0.05913657f, -0.44609919f, 0.11484979f, 
    -0.11340795f, -0.00744289f, -0.11302405f, -0.04591221f, -0.03489596f, 0.02980668f, -0.00142685f, -0.07273953f, 
    -0.10481226f, -0.06638771f, 0.10503786f, -0.02380855f, 0.00601861f, -0.02968747f, -0.17832051f, -0.10731943f, 
    0.08022456f, 0.00602423f, -0.03012090f, -0.05180209f, 0.13132247f, 0.14049031f, -0.14065005f, 0.02975124f, 
    0.02287132f, -0.01995497f, 0.06981649f, 0.06908973f, -0.06728326f, 0.00733948f, 0.04591658f, 0.09933224f, 
    0.04750906f, 0.05806362f, -0.02544174f, -0.06132578f, 0.08149267f, 0.00648874f, 0.07876797f, 0.05737462f, 
    -0.30247349f, -0.08834364f, 0.28393739f, -0.05912475f, 0.05496115f, -0.07113739f, 0.00056412f, 0.08351735f, 
    -0.09974005f, -0.00651217f, 0.03025370f, -0.01002235f, 0.01849521f, 0.11243097f, 0.07004030f, 0.00471851f, 
    -0.00052785f, 0.06789285f, -0.03267709f, 0.03266994f, -0.01900063f, 0.13971137f, -0.07020936f, 0.06979758f, 
    0.08045562f, -0.03406274f, -0.04967875f, -0.02756273f, -0.07590681f, 0.06871603f, 0.00855201f, 0.03980442f, 
    -0.00827386f, -0.01096346f, 0.01266547f, -0.02383780f, -0.08867913f, -0.01528911f, 0.03047507f, 0.04886617f, 
    -0.34079853f, -0.11874967f, 0.37074366f, -0.10239600f, 0.31308904f, 0.07581645f, 0.03502474f, -0.02716519f, 
    -0.02108828f, -0.08751100f, 0.04643000f, -0.04873309f, -0.13411149f, -0.08116426f, -0.16724060f, 0.05637101f, 
    0.05825941f, 0.11077195f, -0.12306160f, 0.14925712f, -0.13687043f, -0.01593087f, 0.12320063f, -0.17269358f, 
    0.07900289f, -0.01931956f, 0.09892179f, 0.09237523f, -0.00458411f, -0.00826656f, -0.04584811f, -0.11566869f, 
    -0.05713185f, -0.08431540f, -0.06158245f, -0.08134048f, -0.00387457f, 0.18331861f, 0.04465412f, 0.12586001f, 
    0.02705577f, -0.35833853f, -0.05346531f, 0.00457093f, 0.10902341f, -0.05823012f, 0.08813953f, -0.06437933f, 
    -0.15350796f, 0.04299475f, -0.04984517f, 0.08743677f, -0.00711029f, 0.16760051f, -0.01423011f, -0.03984568f, 
    0.04486758f, 0.05128315f, 0.08898583f, 0.02925368f, -0.18690063f, 0.40235314f, -0.32841811f, 0.10845263f, 
    -0.21930441f, 0.00514672f, 0.03233574f, -0.01566889f, 0.05791770f, 0.00276417f, -0.10535824f, 0.14063495f, 
    0.04201935f, 0.02889003f, 0.06337915f, 0.11862365f, 0.01574382f, 0.17188701f, 0.03882210f, -0.08126892f, 
    -0.35442784f, -0.02854176f, 0.12641843f, -0.21206650f, -0.27237535f, -0.01330372f, -0.03645557f, -0.01510578f, 
    -0.06915497f, -0.01575291f, -0.08374820f, 0.04149122f, -0.05930335f, -0.01400737f, -0.05109265f, -0.01372897f, 
    -0.00935250f, 0.12727177f, 0.01687768f, -0.05641543f, 0.00295734f, 0.34104201f, 0.06867878f, 0.17361976f, 
    0.04383059f, 0.03231281f, -0.06165015f, -0.03991084f, -0.09646681f, -0.02611544f, -0.06236656f, -0.05121675f, 
    0.11949265f, 0.09601097f, 0.20412327f, 0.12435290f, 0.05503932f, 0.01853808f, -0.19039649f, 0.06405094f, 
    -0.18557259f, -0.26853254f, 0.05480326f, 0.16251735f, 0.14382143f, 0.07835200f, -0.05460609f, -0.06684247f, 
    -0.01513004f, 0.10905042f, 0.02718301f, 0.06460454f, -0.12371467f, 0.11442046f, -0.10725060f, -0.06484964f, 
    -0.10324077f, -0.00860907f, -0.00018436f, 0.10215342f, 0.20666073f, 0.08607544f, -0.01981008f, -0.00956702f, 
    0.10584740f, 0.15667488f, -0.13048294f, -0.00354858f, -0.01505235f, 0.02522379f, 0.03747678f, -0.04212885f, 
    -0.00056361f, 0.13878711f, 0.03979775f, 0.16098614f, -0.01119367f, -0.10442217f, 0.02013689f, -0.09650669f, 
    -0.45414910f, 0.28544408f, -0.14798380f, 0.08582269f, 0.14974806f, 0.25612983f, 0.01472519f, -0.03151000f, 
    -0.03288969f, 0.24122752f, 0.06586882f, -0.06410522f, 0.05719708f, -0.01806113f, -0.02647615f, 0.22492494f, 
    0.04308765f, 0.04437301f, -0.08670908f, -0.06112404f, -0.57750905f, -0.16835281f, 0.01888989f, -0.26760298f, 
    -0.01135965f, -0.15691265f, 0.00890576f, 0.06109010f, 0.00792607f, 0.10571065f, -0.06764577f, -0.12780240f, 
    0.01404994f, -0.06248386f, -0.01107338f, 0.11899273f, 0.00885689f, 0.02990031f, -0.05979633f, -0.06162580f, 
    -0.10867034f, -0.22548144f, -0.08171431f, 0.19341594f, 0.08794437f, -0.07237718f, 0.06257808f, 0.13559474f, 
    -0.00754180f, -0.08303732f, -0.01426120f, -0.00803842f, -0.10082589f, -0.01776233f, -0.11447024f, 0.12384115f, 
    -0.06831925f, 0.09168673f, 0.02424892f, 0.10431985f, 0.15897949f, -0.19852969f, -0.19539729f, 0.06214698f, 
    0.04394861f, 0.06057348f, -0.01063814f, -0.01069278f, -0.04100617f, 0.24916299f, -0.20594445f, 0.07214719f, 
    -0.01199340f, 0.11701342f, 0.03299274f, 0.05127314f, -0.12352309f, 0.01004731f, -0.00413136f, -0.12156773f, 
    -0.54864103f, 0.25928891f, 0.03678571f, 0.02366201f, -0.13785855f, 0.05959675f, 0.03319956f, -0.02705018f, 
    -0.07459856f, 0.05971253f, -0.09714859f, 0.01062464f, -0.06557784f, 0.01005892f, 0.21341388f, 0.01656312f, 
    -0.00395535f, 0.08288254f, -0.06520446f, 0.01917066f, 0.23412898f, 0.23921141f, -0.05822834f, -0.49814934f, 
    -0.22548252f, -0.04861141f, 0.03000252f, 0.04914938f, -0.00231681f, -0.01727557f, -0.07138610f, -0.03325736f, 
    0.07060117f, 0.02056831f, -0.02178529f, -0.04614377f, 0.05348851f, -0.03184391f, 0.13985212f, -0.01308742f, 
    0.26607862f, -0.27954373f, -0.05495511f, -0.06098399f, -0.17085856f, -0.03195239f, 0.01591233f, -0.04068194f, 
    0.14971137f, -0.05446252f, -0.02277056f, 0.09049451f, -0.01576852f, 0.01284106f, 0.01788562f, -0.04423499f, 
    0.02302426f, 0.00746337f, -0.00620365f, 0.02708110f, 0.18833125f, -0.16973391f, 0.34454373f, -0.17392227f, 
    -0.52937007f, -0.02721764f, -0.01767433f, 0.23851961f, -0.11621600f, 0.13589166f, -0.08017568f, 0.02677899f, 
    -0.03208260f, -0.22364539f, 0.01256181f, -0.16235162f, 0.00904868f, -0.13843332f, 0.14595522f, -0.13607749f, 
    0.28342521f, -0.57420999f, 0.29803509f, -0.14156599f, 0.13931406f, -0.09516195f, -0.02616525f, -0.05955989f, 
    0.10041638f, 0.03378601f, 0.04204603f, -0.04910123f, 0.05731629f, -0.23265184f, 0.09850199f, 0.06687538f, 
    0.03160641f, -0.02535389f, -0.01378306f, 0.10923300f, 0.18784960f, -0.52284914f, -0.01363529f, 0.17376389f, 
    -0.26763722f, -0.21828093f, 0.06680146f, -0.09506329f, 0.02413147f, -0.03620188f, -0.05137813f, 0.10590532f, 
    0.16968162f, -0.09881163f, 0.01615518f, 0.18443634f, 0.08130372f, -0.04497218f, -0.00844594f, -0.02519121f, 
    0.16169544f, 0.26369798f, -0.15566318f, -0.47556806f, -0.05472646f, -0.02813575f, -0.12413038f, -0.10644720f, 
    0.05456191f, 0.06817807f, -0.08733843f, 0.00566276f, 0.11724806f, -0.04189227f, -0.07875893f, -0.00644472f, 
    0.01360604f, -0.07419448f, -0.03347401f, -0.05206655f, 0.26513627f, -0.35339451f, 0.16100369f, -0.10154001f, 
    -0.04538199f, 0.12450341f, 0.08615103f, -0.07159488f, -0.00173678f, -0.21436834f, 0.04462303f, -0.05271889f, 
    -0.16640911f, 0.11384712f, -0.00929640f, -0.04072321f, -0.05305611f, -0.10379378f, -0.02029056f, -0.04833648f, 
    -0.26977548f, -0.08657431f, 0.03054149f, 0.09145424f, -0.36504218f, 0.01884770f, 0.03577500f, -0.07903489f, 
    -0.06206584f, 0.06665521f, 0.11731704f, -0.00461613f, 0.06911661f, 0.13439044f, 0.06323811f, -0.05625234f, 
    0.05130991f, -0.05496407f, 0.03222414f, -0.11025321f, 0.44685957f, 0.09367274f, 0.04091312f, -0.04035446f, 
    -0.15071583f, -0.07930333f, 0.07765283f, 0.11056671f, 0.10866256f, -0.20079929f, -0.05849220f, 0.03211972f, 
    -0.08727971f, -0.01756622f, 0.05768759f, -0.00944432f, 0.09207730f, -0.16388758f, 0.10365900f, -0.03084713f, 
    -0.07062185f, -0.10890717f, 0.11881556f, -0.15069182f, -0.35314333f, -0.11693145f, -0.05231596f, -0.05809330f, 
    -0.04199519f, 0.13108355f, 0.05768440f, 0.02600802f, 0.09054127f, -0.05873732f, -0.05912600f, 0.04867387f, 
    -0.05945808f, -0.06775727f, 0.17134672f, -0.02313458f, -0.20156409f, -0.20679182f, 0.17887072f, -0.10343654f, 
    -0.08581083f, -0.04777067f, 0.20942569f, -0.06142090f, -0.07209190f, 0.04065390f, -0.00972687f, -0.06896652f, 
    -0.05285748f, -0.03569170f, -0.00230402f, -0.04440177f, -0.01632925f, 0.05010177f, -0.13578752f, -0.07824526f, 
    -0.07986708f, -0.22584268f, 0.30739972f, -0.15282801f, 0.16360354f, 0.05270107f, 0.00999069f, 0.06583969f, 
    0.05271068f, -0.16028419f, 0.08608007f, 0.08757752f, 0.01297854f, -0.00195237f, 0.08981750f, -0.00297968f, 
    -0.02606211f, -0.02368369f, -0.24344237f, 0.08335620f, 0.08704462f, -0.12237570f, -0.03506497f, 0.08834542f, 
    -0.04071012f, 0.10682265f, 0.02129160f, 0.00300941f, 0.03770893f, 0.05709369f, -0.03348181f, -0.01844683f, 
    0.09498046f, 0.04569365f, 0.01594802f, -0.02939907f, 0.04877315f, 0.00042552f, -0.02431427f, 0.07885702f, 
    0.01554794f, -0.08690591f, -0.13263963f, 0.17511843f, -0.08683696f, -0.06877317f, -0.04498558f, -0.02071034f, 
    -0.01467419f, 0.03267982f, -0.04019491f, -0.00991329f, 0.05133937f, 0.07288815f, 0.12186934f, -0.07768966f, 
    -0.06547251f, 0.05099875f, 0.04259322f, 0.05158181f, 0.15209076f, 0.07770925f, -0.09718962f, -0.11959801f, 
    -0.02379212f, -0.04465811f, 0.01540168f, 0.06733263f, -0.07466295f, 0.04422593f, 0.09943621f, -0.02412879f, 
    0.05490904f, -0.17621389f, -0.04429594f, 0.09096214f, 0.00990685f, -0.10564931f, 0.26493919f, 0.16478406f, 
    0.34441274f, -0.24095103f, -0.29873085f, 0.06324435f, -0.33890170f, 0.00503976f, 0.06493174f, 0.03000825f, 
    0.12920475f, 0.00920975f, -0.10134987f, -0.09574155f, -0.10251236f, 0.17943133f, 0.01037598f, 0.01171249f, 
    0.01994520f, 0.02530575f, -0.02581784f, 0.15379806f, 0.10487213f, 0.30473694f, -0.05713749f, -0.05656610f, 
    -0.18653746f, 0.04229027f, 0.03642084f, 0.05537470f, -0.04710558f, -0.13739392f, -0.15934965f, 0.05427907f, 
    0.04969101f, -0.06060807f, 0.08837734f, 0.02320486f, 0.02600877f, 0.04190271f, -0.02499217f, -0.01252946f, 
    0.12833461f, -0.30780482f, -0.16118799f, 0.21437405f, -0.04446622f, -0.05802545f, -0.01459662f, -0.14618278f, 
    0.03711409f, -0.04658934f, -0.08990297f, 0.12494242f, -0.08142259f, -0.09052891f, 0.03947245f, -0.01581390f, 
    -0.04340676f, 0.04791506f, 0.04831745f, 0.07903448f, -0.21638834f, -0.08690091f, 0.18929684f, 0.17505750f, 
    -0.12860364f, 0.01955985f, -0.00409654f, -0.10703578f, 0.18054943f, -0.04561545f, -0.11912522f, -0.04436323f, 
    0.03694461f, 0.05559538f, -0.03781608f, -0.02753458f, -0.03064859f, -0.04779462f, -0.10572983f, -0.05588816f, 
    -0.24180704f, -0.13672006f, -0.14459363f, 0.09630989f, -0.07528179f, 0.06448547f, 0.02344497f, -0.05586718f, 
    0.03328189f, 0.04040037f, 0.08111179f, 0.09148941f, 0.01297278f, -0.02713057f, 0.11394113f, -0.01885151f, 
    0.00997727f, -0.00816991f, 0.06430845f, -0.07268615f, 0.20082511f, 0.17609972f, 0.01986451f, -0.07839660f, 
    -0.02343296f, 0.02761329f, 0.06460442f, -0.01388223f, 0.11594606f, 0.07289439f, 0.00094269f, 0.07000607f, 
    0.06523375f, 0.02747923f, 0.00088568f, 0.11918575f, 0.11532246f, -0.05244924f, -0.07032165f, 0.09594983f, 
    0.17064616f, -0.01472651f, -0.07238073f, 0.08411724f, -0.05693959f, -0.10415365f, -0.05539914f, 0.03725508f, 
    0.01355015f, 0.08666552f, 0.03905891f, 0.04207480f, -0.05650889f, 0.00517837f, 0.00013089f, 0.04315025f, 
    -0.04613168f, -0.25699249f, -0.18154797f, -0.00291439f, -0.47211811f, -0.29378727f, -0.04913155f, -0.07513742f, 
    -0.26986974f, 0.12690069f, 0.13195102f, -0.01564319f, -0.06445365f, 0.04608133f, 0.12163211f, -0.02821776f, 
    0.04675282f, -0.04917434f, -0.13448015f, -0.02321933f, 0.03173328f, -0.00700621f, 0.11351530f, 0.10403442f, 
    -0.22547536f, -0.25665373f, 0.19602554f, 0.08322109f, -0.19711781f, 0.08983833f, -0.00205678f, 0.03252026f, 
    -0.01455173f, 0.03227244f, 0.00125499f, 0.06414733f, 0.02678483f, 0.03083413f, -0.01674620f, -0.00044532f, 
    -0.00443347f, -0.02566211f, -0.07845499f, -0.09035771f, -0.25803092f, -0.17109358f, 0.01826542f, 0.02783108f, 
    0.26593691f, 0.05123027f, 0.00992032f, 0.10374181f, -0.03391632f, -0.01284905f, 0.02831194f, -0.03888491f, 
    -0.02322700f, -0.02704982f, 0.04962846f, -0.05168927f, -0.00048839f, -0.16315608f, 0.00837276f, -0.00770858f, 
    0.29849425f, 0.17201363f, -0.12278939f, 0.20475857f, -0.16857918f, -0.25317043f, -0.14277013f, 0.04512266f, 
    -0.10604580f, -0.06110995f, 0.03418561f, 0.01151070f, -0.00678675f, -0.15616307f, -0.07450417f, -0.03529752f, 
    -0.01312706f, -0.01282138f, 0.01855255f, -0.08543792f, -0.37345418f, 0.24068855f, -0.02637170f, 0.10983304f, 
    0.12361469f, -0.09641454f, 0.06543469f, -0.07394300f, 0.03100559f, 0.08481838f, -0.01237511f, 0.01022731f, 
    0.06514779f, -0.01294120f, 0.02716515f, -0.02406749f, 0.00852361f, 0.09294936f, -0.04638794f, 0.09048911f, 
    0.07578978f, 0.04005378f, -0.12118024f, 0.01130210f, -0.17943618f, 0.01532625f, 0.07875814f, 0.11213665f, 
    0.04731628f, -0.05026574f, 0.12429713f, -0.03305560f, 0.02636452f, -0.06726654f, -0.08032159f, -0.01630603f, 
    -0.04726077f, 0.05726707f, 0.10982339f, 0.00852648f, -0.11677942f, -0.01643830f, -0.20162581f, 0.03750062f, 
    0.23102251f, 0.08984991f, -0.02946780f, -0.03273978f, -0.06998821f, 0.10053159f, 0.01310096f, 0.13563454f, 
    0.08625520f, -0.03406309f, 0.01004080f, 0.00576180f, -0.00594953f, -0.06218509f, 0.01916652f, 0.07866546f, 
    0.32013026f, 0.16337332f, -0.01359297f, 0.09221459f, 0.04192784f, 0.02464707f, -0.01802932f, 0.05174297f, 
    -0.09002201f, 0.05752335f, -0.07895620f, -0.05415401f, 0.07842918f, -0.06931166f, -0.03495692f, 0.05189288f, 
    -0.01112936f, -0.23895119f, -0.15774700f, -0.02482089f, 0.33797839f, -0.01670201f, -0.08982833f, 0.06834990f, 
    0.01817054f, -0.20832367f, -0.09523319f, 0.08262444f, 0.06228027f, -0.04233204f, -0.08282551f, -0.04212612f, 
    0.03350120f, -0.15138912f, -0.04715803f, 0.00482144f, 0.02393484f, -0.01170391f, -0.00255402f, -0.02934295f, 
    -0.21981002f, -0.36406446f, 0.07548759f, 0.13149670f, 0.02888087f, 0.02843094f, 0.11780358f, 0.09816168f, 
    0.00013386f, -0.04742678f, 0.08608039f, 0.03429832f, -0.00095773f, -0.00158073f, 0.08319936f, -0.03010776f, 
    0.02930850f, -0.19290523f, -0.05146451f, -0.05572845f, 0.14074631f, 0.12769006f, 0.11839315f, -0.06129440f, 
    -0.06359614f, 0.06892365f, -0.06306549f, -0.01983366f, 0.04595145f, 0.06671154f, -0.01071381f, 0.04555152f, 
    0.12503886f, 0.09299529f, 0.04144326f, 0.03942727f, 0.12955959f, -0.08438934f, -0.02817043f, -0.00969809f, 
    0.10530042f, -0.02938601f, -0.04879826f, 0.02043537f, 0.02163762f, -0.09480771f, 0.03034244f, -0.09029920f, 
    0.03458779f, -0.02746344f, 0.04112176f, 0.06067893f, -0.04519235f, -0.00369545f, 0.12851179f, 0.03543966f, 
    0.01107497f, 0.12630013f, 0.02106103f, -0.02949066f, -0.28766870f, -0.06119560f, -0.11684460f, -0.15011282f, 
    -0.09758192f, 0.19444804f, -0.09256265f, -0.09066635f, -0.08285869f, 0.04082909f, -0.02013958f, 0.08762385f, 
    0.01474025f, 0.21115607f, -0.00721492f, 0.09168304f, 0.17403433f, 0.02640477f, -0.04511201f, 0.01301632f, 
    -0.55085480f, -0.01838876f, -0.21283288f, 0.09463748f, 0.04658217f, -0.00270671f, -0.07646880f, -0.08853340f, 
    0.02598882f, 0.13207561f, 0.02076403f, 0.06936589f, 0.01624316f, 0.03120554f, 0.04474720f, 0.09297632f, 
    -0.11671167f, 0.01133775f, -0.10624015f, 0.00382358f, 0.26337346f, 0.13674232f, 0.04086289f, 0.04127701f, 
    0.07748789f, 0.08703052f, 0.08122889f, 0.03092879f, 0.00439368f, -0.10614373f, -0.02615177f, 0.09561276f, 
    -0.14952120f, -0.08239920f, 0.12120140f, 0.00029305f, -0.02718846f, -0.18753751f, -0.21591839f, 0.02373495f, 
    -0.26356575f, -0.03640640f, -0.06126090f, -0.02141689f, -0.06262621f, 0.01415775f, 0.02139225f, 0.01691087f, 
    -0.11804952f, 0.14381604f, 0.00264478f, -0.09557739f, 0.05842070f, -0.02618561f, -0.02903650f, -0.05552156f, 
    0.07126252f, 0.04030077f, 0.14758015f, 0.10142040f, -0.70042020f, -0.09892068f, -0.49652150f, -0.28871211f, 
    -0.02448106f, 0.06896760f, 0.05229371f, -0.26715204f, -0.07716244f, 0.02143195f, -0.01098494f, -0.01005521f, 
    0.01108065f, -0.07404178f, 0.06968929f, -0.10404954f, -0.04634870f, 0.18414532f, 0.06040400f, 0.14880913f, 
    0.01837642f, -0.14764501f, -0.01633548f, 0.04506813f, -0.05407903f, 0.07093308f, 0.03864910f, -0.09691988f, 
    0.01863603f, -0.03040121f, 0.02402991f, -0.09315643f, 0.00487665f, -0.00427067f, -0.05136177f, 0.01573930f, 
    0.05493806f, 0.12287261f, 0.08852680f, 0.03254863f, -0.49270654f, -0.43697840f, -0.11343904f, -0.07035037f, 
    -0.09416962f, 0.07624812f, 0.10599841f, 0.03222278f, -0.01371555f, 0.03283013f, -0.01268253f, -0.00371563f, 
    -0.02125755f, 0.09215824f, 0.07298876f, -0.00931204f, 0.08102710f, 0.16130742f, 0.11361016f, 0.11264270f, 
    -0.20462731f, 0.02238102f, 0.01510317f, -0.11831361f, -0.13797088f, 0.07698723f, 0.05669414f, 0.01830797f, 
    -0.03927423f, 0.07249290f, -0.14275175f, 0.00583383f, 0.04133213f, 0.13485375f, -0.00059340f, 0.08117327f, 
    -0.05077681f, 0.07298192f, -0.06352161f, 0.02123808f, -0.64394510f, -0.30556625f, 0.11372042f, -0.23683937f, 
    -0.28245023f, 0.13881257f, -0.01810789f, -0.10285065f, -0.05956067f, 0.05717970f, -0.02357187f, -0.00309777f, 
    -0.03804701f, 0.10630719f, 0.00359743f, -0.00314859f, -0.13134414f, -0.08109432f, -0.07099123f, -0.11170178f, 
    -0.36890799f, -0.19360803f, -0.16473198f, -0.07758028f, 0.12278112f, 0.02488497f, 0.01382869f, -0.13518493f, 
    -0.05976878f, -0.15492594f, -0.02872811f, -0.03263989f, -0.01184614f, -0.01023044f, 0.12543479f, -0.02657663f, 
    0.01684830f, 0.03076022f, 0.11781284f, 0.00048548f, 0.24567351f, -0.10293184f, -0.09161441f, 0.02328300f, 
    0.04194177f, -0.18696472f, 0.01622933f, -0.19755392f, -0.02597286f, -0.10755742f, 0.00433817f, 0.09828698f, 
    -0.08403042f, -0.10086106f, -0.02852030f, -0.12882085f, -0.07375918f, 0.04758976f, -0.11253069f, -0.06382909f, 
    0.26566499f, 0.02340904f, 0.11080755f, -0.01161734f, -0.02991397f, -0.15558575f, -0.06608206f, -0.02782016f, 
    0.06651142f, -0.07468782f, 0.02990093f, 0.08734630f, -0.14005814f, -0.02974497f, -0.14013563f, -0.05976706f, 
    -0.01704761f, -0.06521598f, -0.09600566f, -0.00926112f, 0.19198360f, 0.35915866f, 0.09186715f, -0.12133970f, 
    -0.08970612f, 0.12329532f, 0.03715388f, 0.06043498f, 0.06871316f, -0.01267370f, -0.07810538f, 0.00831358f, 
    0.06405429f, 0.00136471f, 0.01866664f, 0.03563977f, 0.13239290f, 0.08768748f, -0.08216566f, 0.09735530f, 
    -0.33715919f, -0.36422566f, 0.10013963f, -0.04594519f, -0.07978262f, -0.03181728f, -0.00184309f, -0.01911358f, 
    -0.04995985f, -0.02030045f, -0.01285371f, 0.03207387f, 0.05923880f, -0.07581040f, 0.13368018f, 0.00657023f, 
    0.00248078f, 0.00858628f, -0.02933192f, 0.06703205f, -0.45443660f, -0.41411737f, -0.21859403f, -0.08235377f, 
    -0.02480782f, 0.12097143f, -0.05488873f, -0.08937936f, 0.03370295f, -0.03730343f, 0.11108117f, -0.10029813f, 
    -0.04623584f, 0.04654311f, -0.04609141f, 0.09519926f, 0.06995374f, 0.10423133f, 0.18145262f, 0.10294560f, 
    0.18737391f, 0.07376154f, 0.02574776f, -0.03983426f, -0.07104580f, -0.14153865f, -0.00116894f, -0.07751174f, 
    0.03611548f, -0.05974567f, 0.00298167f, 0.02269898f, -0.02965151f, 0.01563868f, -0.02893901f, -0.04013683f, 
    0.07025004f, -0.01289038f, -0.20730625f, 0.09110591f, 0.07404441f, -0.05021268f, 0.00428591f, 0.01285915f, 
    0.16303736f, -0.03653277f, 0.09596597f, 0.01803350f, 0.02737843f, -0.03395658f, 0.03568991f, -0.05813086f, 
    0.04537127f, -0.10120941f, 0.11340802f, -0.01407373f, 0.15069823f, 0.10207688f, 0.04374187f, 0.04268894f, 
    0.19432427f, -0.01572222f, -0.17071345f, 0.11885501f, -0.20041132f, -0.11047605f, 0.03259159f, 0.05090281f, 
    -0.02628693f, -0.03184015f, 0.03026518f, 0.01813345f, 0.02946419f, 0.04392908f, -0.10503729f, 0.04014784f, 
    0.08337712f, -0.02327736f, -0.13900822f, -0.13710399f, -0.04665794f, 0.14278169f, -0.09571984f, 0.09517363f, 
    0.26409692f, 0.04125700f, -0.14168869f, 0.01141737f, 0.03075272f, 0.02756798f, 0.05141904f, 0.00796493f, 
    -0.01327100f, -0.00964139f, -0.04279165f, -0.03995093f, 0.02538632f, 0.02072796f, 0.12913638f, -0.04354247f, 
    -0.17187223f, 0.23933628f, -0.11399654f, -0.09918033f, 0.29736450f, 0.00981097f, -0.19674979f, -0.02201063f, 
    -0.08998156f, -0.12959640f, 0.00272825f, -0.04076575f, 0.09593888f, -0.04431023f, 0.07268080f, 0.05597387f, 
    -0.03195782f, 0.06417781f, -0.00239734f, -0.01905162f, -0.09387032f, -0.41992614f, -0.25617400f, 0.02272206f, 
    0.01289411f, 0.02778667f, 0.03169904f, 0.05871320f, -0.05073528f, 0.13244903f, -0.02730577f, 0.07977549f, 
    -0.14025320f, -0.03111875f, -0.03429276f, -0.02283218f, 0.08962119f, 0.03076735f, -0.03326311f, -0.08070704f, 
    0.26759538f, 0.19021034f, -0.21909517f, -0.12666985f, -0.00561403f, -0.01828952f, 0.09213229f, -0.02609625f, 
    -0.01651289f, -0.07306568f, 0.06551237f, 0.07428978f, -0.03077627f, 0.01682839f, -0.04252240f, 0.02068549f, 
    0.02940277f, 0.03240401f, -0.02080829f, 0.06018770f, 0.06040937f, 0.19336270f, -0.09322359f, 0.14819497f, 
    0.08173972f, 0.07798322f, -0.18783706f, 0.04403948f, -0.01603002f, -0.00048188f, 0.01340107f, 0.06681813f, 
    0.06410165f, -0.01707499f, -0.00445634f, -0.00294711f, 0.09444087f, -0.04917616f, 0.01245968f, 0.10123342f, 
    0.29340443f, -0.29259366f, 0.10143484f, 0.02990056f, -0.12304206f, -0.07395933f, 0.06104467f, 0.04817069f, 
    0.01615285f, 0.00406303f, -0.22158761f, -0.15385260f, 0.01087724f, 0.08360278f, -0.13517727f, 0.03188071f, 
    -0.10050903f, -0.04158390f, -0.19378455f, -0.07231995f, -0.62705123f, 0.12709016f, 0.12352484f, -0.04910328f, 
    0.28605005f, -0.14339031f, 0.12910655f, 0.00725842f, 0.05356841f, -0.11126642f, 0.08012392f, 0.01255117f, 
    0.02396534f, 0.08558179f, 0.02849646f, -0.05520826f, 0.00361144f, -0.07212312f, 0.04236850f, -0.07385259f, 
    0.09222011f, -0.38840210f, 0.04928293f, 0.09241126f, -0.12743674f, -0.08071064f, -0.02003182f, 0.17110388f, 
    -0.14784418f, 0.08625035f, -0.08127330f, 0.06101634f, -0.09419029f, -0.06001853f, -0.18595548f, -0.19391014f, 
    -0.04686800f, -0.09314053f, -0.05838396f, -0.05556169f, -0.03053956f, -0.22492415f, -0.07250622f, 0.22942923f, 
    0.06461048f, -0.02662602f, 0.05601256f, -0.02718610f, -0.01183719f, -0.18929818f, 0.11286338f, -0.14666708f, 
    -0.02792547f, 0.06152870f, 0.10850704f, 0.10273873f, -0.04266697f, 0.03409054f, 0.02287245f, -0.05123406f, 
    0.03428035f, 0.00492802f, -0.13055563f, -0.14261572f, -0.03159672f, -0.22690096f, -0.06388421f, -0.05477946f, 
    0.02210421f, -0.03006622f, 0.08089482f, -0.01905395f, -0.04751889f, 0.02293801f, -0.02627833f, 0.07573911f, 
    -0.06429850f, 0.02775322f, 0.17124803f, -0.00688572f, -0.06494342f, -0.03247203f, 0.02985762f, 0.11253355f, 
    -0.06590676f, 0.02080646f, -0.05740625f, 0.09858160f, -0.12335298f, -0.08807704f, -0.03894717f, -0.11790580f, 
    0.00966814f, -0.07372104f, 0.02025251f, -0.09698693f, -0.06774698f, -0.00570876f, -0.09094202f, 0.04729672f, 
    -0.06955352f, 0.26099998f, 0.01053128f, 0.00335859f, 0.18342769f, 0.15964085f, -0.05348615f, -0.05794948f, 
    0.02723955f, -0.08816636f, 0.04721293f, 0.10004418f, -0.05798258f, -0.00692696f, 0.08410268f, -0.04450007f, 
    0.07949483f, 0.04752054f, -0.02208944f, 0.05124629f, 0.24873489f, -0.16651919f, -0.00767186f, 0.07838310f, 
    0.21794486f, 0.12452326f, -0.03831719f, -0.00723226f, 0.10045494f, -0.01667521f, 0.01315150f, -0.03491531f, 
    -0.01192132f, 0.01439204f, 0.09124193f, 0.09601574f, 0.04772140f, -0.00026791f, 0.03038893f, 0.08365124f, 
    -0.31423834f, -0.15152507f, 0.05586162f, -0.03570717f, 0.06504197f, -0.05576844f, 0.11489675f, -0.01635179f, 
    0.03909076f, 0.05834160f, -0.14795303f, 0.06832761f, -0.01078068f, -0.02054070f, -0.04930845f, -0.11800919f, 
    -0.01745235f, -0.03054831f, -0.19217180f, -0.08487550f, 0.37922341f, 0.16927186f, -0.16729237f, -0.15001827f, 
    0.01836684f, 0.17987755f, 0.12374805f, -0.00306355f, 0.07057618f, 0.03514257f, 0.19926316f, -0.00357506f, 
    0.08003101f, -0.12317865f, 0.10653464f, 0.02299557f, -0.18399614f, 0.00887996f, 0.02986804f, 0.16806604f, 
    0.37294805f, 0.11953577f, -0.20916373f, 0.05841203f, -0.46938697f, -0.32902592f, -0.10588087f, 0.00886106f, 
    0.09609901f, -0.02957609f, 0.06189076f, 0.01598274f, 0.14227383f, -0.03707549f, 0.02219634f, 0.06958936f, 
    0.02165930f, -0.08390895f, -0.01601382f, 0.01785635f, -0.31958196f, 0.23170990f, -0.12672430f, -0.04226647f, 
    -0.06514176f, -0.10682935f, 0.00402977f, -0.04852222f, -0.05608658f, -0.27379435f, 0.01704282f, -0.00850165f, 
    0.01702159f, -0.02876706f, 0.02603221f, 0.18451807f, 0.03964688f, -0.02471030f, -0.03358579f, 0.04804508f, 
    0.26093110f, -0.22906372f, 0.02377834f, 0.12617871f, 0.05666034f, 0.02160698f, 0.06438544f, 0.02921853f, 
    0.02838107f, -0.03968656f, 0.12410145f, 0.02580692f, -0.09069633f, 0.13693447f, 0.04924933f, 0.12512484f, 
    -0.03758318f, -0.11538271f, 0.10193098f, -0.02779462f, -0.10958515f, -0.20212209f, -0.18702443f, -0.06722853f, 
    -0.15850292f, -0.06332483f, 0.05274308f, -0.08359683f, 0.03677105f, 0.10109436f, -0.02413263f, 0.02263383f, 
    0.00738793f, -0.05752379f, 0.03600076f, -0.04437891f, 0.03830455f, -0.12941895f, -0.05516632f, 0.02410630f, 
    -0.23995173f, 0.21802987f, -0.13255374f, -0.22476256f, 0.01359263f, 0.10276622f, 0.02399997f, 0.07844689f, 
    -0.03004480f, 0.00421775f, -0.04505209f, 0.15151119f, 0.00986164f, -0.03934839f, 0.10747182f, -0.04725850f, 
    -0.02804046f, -0.09445278f, 0.06649113f, -0.07363214f, 0.16211860f, -0.37775290f, -0.09814181f, -0.25426200f, 
    -0.13701504f, 0.07633583f, -0.01177558f, 0.05208484f, 0.01128310f, 0.08821635f, -0.00240956f, 0.00769157f, 
    0.03006341f, -0.02958149f, -0.04051736f, 0.10629424f, 0.01764407f, -0.02378626f, -0.07188779f, -0.02182039f, 
    0.50639647f, -0.01941279f, -0.20940529f, -0.14742635f, 0.19973125f, 0.00251394f, 0.07626353f, -0.02336069f, 
    0.04392540f, -0.00451942f, 0.11491914f, -0.03019837f, -0.02723555f, 0.04131500f, 0.04866145f, -0.05423775f, 
    -0.06631303f, -0.02135592f, 0.06276752f, 0.01281893f, 0.47663358f, 0.25789240f, -0.33940542f, -0.22275485f, 
    -0.12427083f, -0.04436855f, -0.00979120f, -0.11776471f, 0.02142076f, -0.00388500f, 0.07356811f, -0.01859861f, 
    -0.05836607f, 0.00964395f, 0.08384965f, -0.00357198f, 0.06339268f, 0.05322526f, -0.01822507f, 0.08110546f, 
    -0.25857881f, -0.12697606f, -0.10122469f, 0.06300216f, -0.33063161f, 0.23532264f, 0.08842737f, 0.00598319f, 
    0.07064745f, -0.00227673f, -0.05823332f, -0.12316110f, 0.00220799f, 0.04474982f, 0.10416308f, -0.09082117f, 
    0.01858533f, -0.04198034f, -0.16358450f, 0.06043940f, -0.33814952f, -0.12830713f, 0.01728827f, -0.02368607f, 
    -0.15000954f, -0.03533855f, -0.01392021f, -0.02465058f, 0.05004714f, 0.04479911f, -0.17135210f, 0.14188072f, 
    0.06799040f, -0.06049843f, -0.07416337f, -0.16682215f, -0.04170818f, -0.04348908f, -0.16596346f, -0.02678025f, 
    0.07443810f, 0.11166333f, -0.02931138f, -0.08591107f, -0.01941735f, -0.03114954f, -0.06826410f, -0.01519073f, 
    -0.14166223f, -0.23607558f, -0.04937302f, -0.02801699f, 0.09164119f, 0.04813286f, -0.07345380f, 0.05323512f, 
    -0.07245352f, -0.07939520f, 0.05299030f, -0.03063656f, -0.38398400f, 0.09322597f, -0.03493706f, -0.17239614f, 
    0.21693417f, 0.07373146f, -0.05600409f, 0.05168178f, 0.01783620f, 0.09677041f, -0.02418078f, -0.02996037f, 
    0.01237884f, -0.02335125f, 0.16861223f, -0.04537405f, -0.08346381f, 0.05905678f, 0.10161716f, -0.07144251f, 
    -0.36203015f, 0.11886225f, -0.00653389f, -0.13054633f, 0.38914141f, 0.13537733f, -0.07485188f, 0.06246978f, 
    0.03644899f, 0.13685387f, -0.02202542f, 0.05203886f, 0.03511231f, 0.13648616f, -0.04396506f, -0.02735376f, 
    0.13172461f, -0.08296677f, -0.01873946f, -0.07594484f, 0.01288740f, -0.15639353f, -0.14666317f, -0.04429983f, 
    -0.02698146f, 0.24187070f, -0.02047987f, -0.10021164f, 0.04340008f, 0.08159079f, -0.03092287f, 0.02476612f, 
    -0.00507145f, -0.01780607f, -0.06568176f, -0.13156660f, -0.18787868f, 0.01197962f, -0.16239101f, -0.01446836f, 
    -0.17211631f, 0.31448218f, -0.01133613f, -0.08676752f, -0.07399697f, -0.02029999f, -0.14174433f, -0.01906810f, 
    -0.28692704f, -0.13821881f, -0.00931522f, -0.02902314f, 0.06352188f, -0.10309257f, 0.01432387f, 0.03827957f, 
    0.05785341f, -0.10923482f, -0.00029868f, -0.15812480f, -0.15869790f, 0.09391684f, -0.00962280f, 0.12541658f, 
    -0.19357501f, 0.12932023f, 0.18214640f, 0.11173431f, -0.01808468f, 0.08233711f, -0.05287531f, -0.11424935f, 
    0.05257012f, -0.02572194f, -0.03365503f, -0.11242747f, 0.04150209f, -0.00939985f, -0.03471494f, 0.03724160f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.03430531f, 0.01337706f, -0.07967028f, -0.01409624f, 0.00611262f, 0.03216639f, -0.02874648f, -0.07509864f, 
    -0.01718578f, 0.00444905f, 0.07373644f, -0.01722449f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
